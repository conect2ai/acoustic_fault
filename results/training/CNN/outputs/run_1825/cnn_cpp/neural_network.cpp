#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.11498179f, 0.13054156f, 0.00549695f, -0.58615923f, -0.22770375f, 0.46918800f, -0.09919713f, 0.17844793f, 
    -0.26559073f, 0.49614358f, 0.50253552f, -0.43821833f, -0.03858402f, -0.37048605f, 0.01122691f, 0.08001713f, 
    0.01472283f, 0.09171088f, -0.16360357f, 0.13323663f, 0.02648386f, 0.06498527f, -0.31171554f, 0.10347264f, 
    0.24257779f, -0.56057358f, -0.38277695f, -0.45861912f, -0.43189776f, 0.28220937f, 0.30002129f, -0.22230397f, 
    0.18525609f, 0.07634500f, 0.27949050f, 0.34729651f, -0.08113007f, -0.03827845f, -0.12510988f, 0.23214896f, 
    -0.27575889f, -0.34515670f, 0.13605507f, -0.20010683f, -0.34191090f, 0.03328608f, 0.28493917f, 0.28371620f, 
    0.16848573f, 0.16694783f, 0.36834037f, 0.21753681f, -0.00865331f, -0.30950421f, 0.25592846f, -0.15107447f, 
    0.32192972f, 0.21737429f, 0.37166983f, -0.21289723f, -0.22513331f, 0.16611369f, -0.19686577f, 0.56056684f, 
    0.09327325f, 0.01990501f, -0.30243778f, -0.34695780f, -0.29841727f, 0.04670313f, 0.19864632f, 0.03701861f, 
    0.30223289f, 0.14046980f, -0.11996299f, -0.17010373f, -0.27385068f, 0.21886347f, 0.06976057f, 0.23604731f, 
    0.00595745f, -0.28320345f, 0.04210358f, 0.46706909f, 0.41051233f, -0.28343257f, 0.22238091f, -0.35159570f, 
    -0.19109012f, 0.63614106f, -0.29366115f, 0.08783813f, -0.27325866f, -0.00650801f, -0.22310023f, 0.28181386f, 
    0.06855891f, 0.01293712f, 0.16730671f, -0.03412989f, -0.50661129f, -0.11311609f, 0.11144623f, -0.16214913f, 
    -0.38397408f, -0.17172021f, -0.52746695f, -0.61722016f, -0.54122102f, -0.40434718f, -0.24295631f, -0.25381550f, 
    -0.21658167f, -0.52867639f, -0.28590366f, -0.27382010f, -0.31754020f, 0.02822659f, -0.04798574f, -0.05804848f, 
    0.07541887f, 0.13408314f, -0.07454991f, -0.27510124f, 0.00880528f, -0.82870293f, 0.03962469f, -0.29743570f, 
    -0.45508206f, 0.07393767f, 0.28819212f, -0.23920716f, 0.22578833f, 0.58648151f, -0.11329356f, 0.06138955f, 
    0.22363231f, -0.03840882f, 0.20628534f, -0.09920654f, -0.09001201f, -0.15874004f, -0.13669640f, -0.15467651f, 
    -0.09511000f, 0.10635334f, 0.29013482f, 0.12029954f, -0.00437733f, 0.18870755f, -0.16883150f, 0.20767683f, 
    -0.31202549f, -0.75463068f, -0.17781869f, -0.07660987f, 0.32566050f, 0.02780652f, -0.33383802f, 0.07447080f, 
    -0.29231274f, 0.54928422f, -0.47985268f, -0.25896144f, 0.35095176f, 0.22460175f, -0.18298896f, -0.24068260f, 
    -0.22014627f, -0.31560010f, -0.14364402f, 0.27646482f, -0.14402850f, -0.19646211f, 0.40754619f, 0.64576787f, 
    0.01125815f, -0.43527603f, -0.14266659f, -0.19802608f, -0.20873235f, -0.03413706f, 0.23869400f, 0.39070660f, 
    -0.31197944f, 0.04225793f, 0.31861019f, -0.14148253f, -0.14298631f, -0.13604313f, 0.06659625f, -0.10723834f, 
    0.07257934f, -0.38820523f, 0.03296351f, 0.01199715f, 0.24062112f, 0.09443758f, 0.16373394f, 0.45799831f, 
    -0.36688846f, -0.45261407f, -0.47049618f, -0.50632876f, 0.19568627f, -0.42870113f, -0.33524665f, -0.33962137f, 
    0.16331409f, -0.30083454f, -0.20470767f, 0.44538352f, -0.53399134f, -0.12733732f, -0.22326685f, -0.27113980f, 
    -0.35703325f, 0.12328433f, -0.43649057f, -0.24327132f, -0.20706798f, 0.23427212f, -0.00344658f, 0.19636641f, 
    0.34225932f, 0.20247401f, -0.35997140f, 0.09408617f, 0.09497366f, -0.31612110f, -0.63024926f, -0.17936844f, 
    -0.21769142f, -0.21732271f, 0.27603340f, 0.04330217f, 0.35310498f, 0.20723999f, -0.05951824f, -0.12802160f, 
    -0.00378665f, 0.08450429f, -0.14129612f, -0.02777166f, -0.01077716f, 0.31849223f, -0.33344862f, -0.05180314f, 
    0.31348580f, 0.15162116f, 0.65287888f, 0.55121839f, 0.19532357f, -0.09113280f, 0.20720051f, -0.07438743f, 
    0.20779289f, 0.08983878f, -0.02909303f, -0.50466841f, -0.21649104f, 0.07070341f, 0.02762466f, -0.12151835f, 
    -0.13053471f, -0.09827364f, -0.03874560f, 0.11181746f, 0.16059059f, -0.02943118f, -0.26208839f, 0.20797075f, 
    -0.14033598f, 0.06423482f, -0.12688512f, -0.81612170f, -0.82817048f, -0.10387009f, 0.78537822f, 0.67815459f, 
    0.26400685f, 0.11649110f, -0.13960414f, -0.13658918f, 0.35341477f, -0.02250234f, 0.27376145f, -0.30422044f, 
    -0.28399003f, -0.42435765f, -0.13640152f, 0.40924469f, -0.13852076f, 0.25821033f, 0.41575703f, -0.42629820f, 
    0.06792638f, -0.06546025f, -0.20922011f, -0.24661487f, 0.01378524f, 0.22995040f, 0.22604477f, 0.04240266f, 
    0.28017095f, 0.16689602f, 0.41164726f, 0.33596042f, 0.29510829f, 0.12855160f, 0.19316266f, 0.22998308f, 
    0.12524690f, 0.02462922f, -0.38095838f, 0.19174886f, -0.04534099f, -0.12037324f, -0.17574862f, -0.37980211f, 
    0.20301889f, 0.14887042f, -0.00167733f, -0.21471310f, 0.02350582f, 0.36952969f, 0.42612776f, 0.05468129f, 
    -0.10317050f, 0.46198699f, -0.08361483f, -0.29676464f, -0.11323255f, -0.06544315f, -0.29705220f, -0.32203746f, 
    0.03362815f, 0.08238097f, -0.13014579f, -0.02470874f, 0.02206820f, -0.20107362f, 0.23341256f, -0.04104258f, 
    0.01801494f, -0.31969523f, 0.16007784f, 0.08881776f, 0.24844749f, 0.08570807f, 0.37507886f, 0.76225263f, 
    0.28942284f, -0.88325232f, -0.19325414f, 0.22400354f, 0.11930583f, 0.17300731f, -0.52209330f, -0.06230452f, 
    -0.28334823f, -0.05294837f, 0.10198990f, -0.06547219f, 0.25061071f, 0.27728298f, 0.08558968f, -0.03588254f, 
    -0.36990920f, -0.18739071f, 0.09996921f, -0.24920738f, -0.21210587f, -0.12892368f, -0.37580192f, 0.37145081f, 
    1.20329714f, 0.78795391f, -0.73036647f, -0.30558696f, -0.37226558f, -0.37636760f, -0.12330859f, 0.05381353f, 
    -0.14561467f, 0.09841853f, 0.05848783f, 0.11211005f, -0.11089046f, -0.39532062f, 0.22080764f, -0.07174722f, 
    -0.12938362f, 0.41435528f, -0.07711447f, 0.06703030f, 0.15435851f, -0.08330978f, -0.12098996f, -0.02769130f, 
    -0.88438284f, -0.23021322f, -0.49725109f, -0.25564042f, -0.44806099f, 0.45131761f, 0.24633807f, 0.19061357f, 
    0.20127934f, 0.55851614f, 0.30958322f, 0.21169861f, -0.02822727f, -0.07960357f, -0.11297247f, 0.16965325f, 
    -0.05973434f, -0.05140696f, 0.35481608f, 0.05182786f, -0.08643626f, 0.09897519f, 0.00708203f, -0.16719675f, 
    -0.22412881f, -0.32017395f, -0.41768339f, -0.45044172f, -0.07419640f, -0.44987220f, -0.38893187f, -0.29474342f, 
    -0.38863951f, -0.28719702f, -0.71867329f, 0.06666057f, 0.13339217f, 0.35983986f, 0.55399251f, 0.00171195f, 
    0.09697978f, -0.12123692f, 0.02313424f, -0.01495908f, -0.04408167f, 0.09653283f, 0.25544253f, -0.03649832f, 
    -0.17589700f, 0.19379456f, -0.11773255f, -0.35288519f, -0.75538683f, -0.65417910f, -0.67265564f, 0.04882092f, 
    0.11156148f, 0.47255653f, 0.17551434f, 0.08528897f, 0.10786738f, -0.06853542f, -0.26216125f, -0.01284745f, 
    -0.11870188f, -0.08939039f, -0.06260242f, 0.19219232f, -0.07321689f, 0.04005590f, -0.24132434f, -0.27037033f, 
    -0.01827280f, -0.18423080f, -0.08589142f, 0.72457778f, 0.01949947f, -0.28533241f, -0.07562573f, -0.17459175f, 
    0.30443278f, -0.20038104f, -0.28047654f, -0.19625460f, 0.10229468f, -0.19071387f, 0.29207894f, 0.17432107f, 
    -0.08849650f, 0.14545336f, 0.49696073f, -0.03444406f, -0.25779220f, -0.14886901f, -0.33434883f, 0.05021766f, 
    -0.07742463f, 0.30039504f, 0.24118704f, 0.00747239f, -1.06394529f, -0.58247638f, -0.33713096f, -0.05154701f, 
    0.68236011f, 0.34114432f, -0.10606313f, 0.31145874f, -0.01551255f, -0.61699313f, 0.13236640f, 0.24875882f, 
    0.15684073f, -0.07423052f, -0.01334920f, 0.08987635f, 0.12376836f, 0.07174914f, 0.01898172f, -0.13187060f, 
    0.12619497f, 0.16851722f, -0.22609492f, -0.20082301f, 0.18205811f, -1.09711111f, -0.38507870f, 0.29124260f, 
    0.07196674f, 0.61244059f, 0.29599434f, 0.37805164f, 0.11695275f, -0.01374722f, -0.44681960f, -0.17130479f, 
    0.05146878f, 0.00703019f, -0.03864064f, -0.33495721f, -0.10250686f, -0.52564156f, -0.31081000f, -0.06098643f, 
    -0.10466423f, -0.19988222f, -0.20325376f, -0.13704871f, 0.05772006f, -0.26479653f, -0.25860152f, -0.21024017f, 
    -0.65159535f, -0.35373282f, -0.10309529f, -0.05010916f, -0.40582281f, -0.59930521f, -0.58088309f, -0.68000484f, 
    0.37737387f, -0.17266771f, 0.04207318f, -0.09136410f, -0.30345795f, -0.29037827f, -0.60183823f, -0.05022360f, 
    -0.21188956f, -0.13782744f, -0.17119679f, 0.01242133f, -0.22167060f, 0.08768620f, 0.22313264f, -0.99068254f, 
    -0.25914797f, -0.58914357f, -0.40455425f, -0.43605712f, 0.68583465f, 0.07527459f, -0.02821231f, 0.17077136f, 
    0.44962242f, -0.12983425f, -0.42272329f, -0.00409372f, -0.07774445f, 0.03926810f, -0.19963467f, -0.09619819f, 
    -0.10553414f, -0.05494064f, -0.13328047f, -0.16876799f, -0.09136892f, -0.02510351f, -0.02205034f, -0.00791932f, 
    -0.31310874f, -0.23586917f, -0.18673040f, 0.19224866f, 0.38878867f, 0.02502318f, -0.03542494f, 0.33664563f, 
    0.16638994f, 0.20779015f, -0.30640325f, 0.09938397f, 0.35760128f, -0.20676807f, -0.26981866f, 0.15161386f, 
    0.13217391f, 0.07588841f, 0.19013868f, 0.03353665f, -0.09821203f, -0.38903943f, -0.29126006f, 0.18402228f, 
    0.24360968f, -0.55184448f, -0.45477983f, 0.37838078f, 0.20057112f, 0.00435965f, 0.49672392f, 0.45720568f, 
    0.24007234f, -0.03848653f, 0.35278070f, 0.12855969f, 0.24982993f, -0.23162311f, 0.47778267f, -0.17423034f, 
    -0.18222529f, 0.10092784f, -0.10523286f, -0.30001807f, -0.20211574f, 0.08984581f, 0.18719853f, -0.12517524f, 
    0.22273399f, 0.08190773f, -0.00689244f, -0.63197023f, -0.91464341f, -0.43367645f, -0.19914323f, 0.01601355f, 
    0.17398147f, 0.28642762f, 0.35995370f, 0.17420319f, 0.17941844f, 0.31297532f, -0.07215425f, -0.05866947f, 
    0.49394542f, -0.20197707f, -0.14493717f, 0.09652529f, -0.15872586f, -0.31201169f, -0.04625382f, -0.16215269f, 
    0.12783924f, 0.00478726f, 0.06974962f, 0.47847354f, 0.02056514f, 0.19761409f, -0.13133553f, 0.40001476f, 
    0.08797833f, -0.10255425f, 0.09645403f, 0.23458657f, 0.08328716f, -0.13939628f, 0.15373348f, 0.04540875f, 
    -0.07077122f, 0.01423805f, 0.05213499f, -0.17950144f, -0.16671833f, -0.20774056f, 0.11266815f, -0.19844162f, 
    0.33122268f, 0.03338932f, 0.01665313f, -0.32078895f, 0.11834253f, -0.73600399f, 0.45254767f, 0.48547593f, 
    0.72705770f, -0.51153767f, -0.32163441f, -0.06349715f, -0.23707299f, 0.19472024f, -0.21987750f, -0.25602829f, 
    0.45646229f, -0.19950727f, -0.31177086f, -0.04523780f, 0.14985296f, -0.01690085f, 0.06500445f, -0.09858040f, 
    -0.06445406f, 0.12515260f, -0.23746017f, 0.01267985f, 0.06971499f, -0.22727013f, -0.56547618f, -0.01928973f, 
    0.40241170f, 0.21048638f, 0.02430693f, 0.29671919f, -0.04794223f, -0.09627483f, 0.14595982f, -0.02318852f, 
    0.10055856f, 0.08584964f, -0.22329396f, 0.07593240f, -0.13735442f, -0.19520317f, 0.04228941f, -0.36217004f, 
    0.50223684f, -0.26814985f, -0.24906696f, 0.19235004f, 0.57003605f, -0.24230696f, 0.33736342f, -0.40777889f, 
    -0.02018792f, 0.48853382f, 0.55964315f, 0.03013940f, 0.60590583f, -0.35696575f, -0.59729820f, -0.57352072f, 
    0.23854145f, -0.39134935f, 0.30954576f, -0.05050569f, -0.12747665f, -0.28636533f, 0.26854619f, 0.32242659f, 
    0.07207616f, -0.05419198f, 0.37317908f, -0.11805267f, -0.18998042f, -0.13807446f, -0.21937037f, 0.55797791f, 
    0.02912955f, 0.22413039f, -0.08562385f, -0.27752182f, -0.40122283f, -0.12664573f, -0.00068770f, 0.01357611f, 
    -0.13366976f, -0.43166944f, 0.46878868f, -0.11550813f, 0.30973190f, -0.23944990f, -0.16803652f, -0.01034367f, 
    0.06677853f, 0.26043990f, -0.13002209f, 0.25934821f, -0.11232758f, 0.00089792f, -0.01803958f, 0.13206427f, 
    0.16658364f, 0.20802289f, 0.14470094f, 0.55563736f, 0.11372019f, 0.29225188f, -0.30489567f, -0.13796158f, 
    -0.15914106f, 0.27731466f, 0.17622854f, -0.03120286f, 0.02734523f, -0.04382947f, 0.36529237f, -0.16020715f, 
    -0.21126071f, -0.13183226f, 0.10949202f, 0.19698295f, -0.03672640f, 0.05678635f, 0.17151117f, -0.08413441f, 
    -0.22598076f, -0.40861601f, 0.02930249f, -0.56802088f, -0.31022277f, 0.57395613f, -0.31560883f, -0.39020434f, 
    -0.06934002f, -0.60395181f, -0.56683421f, -0.02616692f, 0.03145832f, 0.48048240f, -0.49646544f, -0.28221712f, 
    -0.08711716f, 0.28946796f, -0.32291415f, 0.21151945f, 0.02100941f, -0.06641539f, -0.13009885f, 0.30960253f, 
    -0.02901481f, -0.07625511f, -0.29673171f, -0.35631493f, -0.26524764f, -0.34480053f, -0.48158392f, -0.29793969f, 
    -0.36460283f, -0.72069103f, -0.77788645f, -0.13984968f, 0.10262103f, 0.03143175f, 0.18784608f, 0.01291692f, 
    -0.06823380f, 0.20686252f, 0.32236615f, 0.12835936f, -0.11173336f, -0.39074373f, -0.10936353f, -0.00294476f, 
    0.39055023f, -0.20290247f, -0.13079998f, -0.49775717f, 0.53925627f, 0.22562556f, -0.49999541f, -0.05057832f, 
    -0.68762493f, -0.29748279f, -0.28904992f, -0.37465936f, -0.36511618f, 0.53582531f, -0.11598977f, 0.49780130f, 
    0.20596580f, -0.07267493f, -0.17483339f, -0.33850056f, 0.22745675f, -0.44571427f, -0.52863300f, 0.14422692f, 
    -0.02610659f, 0.23520193f, 0.06064923f, 0.23448509f, -0.81581897f, -0.60956526f, -0.44918644f, -0.55614966f, 
    -0.21260093f, 0.67652714f, 0.22935541f, 0.19065501f, 0.51526296f, 0.49575639f, 0.08649816f, -0.11421062f, 
    -0.07559184f, 0.32453111f, -0.18162835f, -0.07094666f, 0.06196402f, -0.07120936f, -0.20958781f, -0.23110978f, 
    -0.08540729f, 0.15789360f, 0.24590044f, -0.00059310f, 0.00762497f, 0.01843298f, 0.29920459f, 0.29454449f, 
    0.07000795f, -0.10386571f, -0.22773068f, -0.44857073f, -0.23818730f, 0.15276444f, -0.09852797f, 0.14985676f, 
    -0.19323470f, -0.04671339f, 0.36608422f, 0.08585030f, 0.14749126f, 0.18817340f, -0.08087257f, -0.32774675f, 
    -0.40199155f, -0.06090491f, 0.40395904f, 0.09459786f, 0.24382773f, 0.19463018f, 0.59158593f, -0.00961017f, 
    -0.21954201f, 0.27336538f, 0.18139383f, 0.12807198f, 0.06697303f, -0.03268019f, -0.28289020f, 0.21977675f, 
    0.22641073f, 0.11835062f, -0.40791041f, -0.41073573f, 0.39531651f, -0.01138857f, -0.08049870f, -0.17138122f, 
    0.05121668f, -0.00950441f, 0.00409598f, 0.00413198f, 0.15822431f, 0.01998730f, -0.31886396f, 0.14444296f, 
    0.04208415f, 0.11193167f, -0.29922995f, -0.42031839f, -0.16268466f, 0.10383866f, 0.08119381f, 0.22774468f, 
    0.07826397f, -0.03696034f, 0.04650213f, -0.28771573f, 0.58183467f, -0.20803915f, -0.30740428f, -0.17835310f, 
    -0.33766720f, 0.47089431f, 0.22678532f, 0.20378590f, 0.09114125f, 0.02668076f, -0.03353053f, 0.04886031f, 
    -0.26860037f, -0.13318336f, 0.14956200f, -0.43128413f, -0.27043486f, -0.19485967f, 0.38678843f, -0.08337931f, 
    -0.19387028f, -0.05687513f, -0.23909891f, 1.05163836f, -0.33614323f, -0.24242021f, -0.24407735f, -0.42726913f, 
    -0.01416493f, -0.28415716f, -0.14195456f, -0.14926456f, 0.20801501f, 0.34855554f, 0.03623870f, -0.17022851f, 
    -0.13338830f, -0.51622713f, -0.31433129f, 0.10031716f, 0.28811017f, 0.55302489f, 0.38817993f, 0.38070181f, 
    -0.35121167f, -0.32982478f, 0.30522361f, 0.04204787f, -0.18872388f, 0.13784300f, -0.16013797f, -0.17678688f, 
    -0.37238619f, -0.01643599f, 0.16798387f, 0.16895740f, -0.05583870f, 0.25103447f, -0.25154355f, -0.30758113f, 
    0.20709354f, 0.20823057f, -0.96043742f, -0.38602751f, -0.69325119f, -0.58611625f, -0.28420195f, 0.40036824f, 
    0.41178179f, 0.11728369f, -0.39178061f, 0.02348359f, -0.23660479f, -0.29357165f, -0.56037307f, -0.46021256f, 
    -0.23897412f, 0.00151126f, -0.05096405f, -0.13084988f, 0.16625223f, -0.01859559f, -0.03834794f, -0.04986730f, 
    -0.07350655f, -0.03147876f, -0.25799051f, -0.76784754f, -0.17176032f, -0.51529658f, -0.58676046f, 0.28733012f, 
    -0.04555838f, 0.23107913f, -0.45153582f, -0.22043173f, -0.04575031f, 0.43125522f, 0.36647186f, 0.07452433f, 
    -0.07609767f, -0.15431713f, -0.25478530f, -0.10446300f, -0.29132944f, -0.01824675f, -0.36443904f, 0.24022703f, 
    -0.20768461f, -0.32723302f, -0.09277502f, -0.39150631f, -0.08910232f, -0.61578774f, -0.36040369f, 0.49930772f, 
    0.63511962f, 0.10320055f, 0.09562272f, -0.41261086f, 0.12241044f, 0.10677649f, -0.26256087f, -0.03567556f, 
    -0.37251332f, 0.24628237f, -0.25248653f, 0.09701777f, -0.16781788f, -0.23324141f, 0.33414888f, 0.32014930f, 
    0.19708914f, -0.38372475f, 0.10027025f, -0.34037781f, -0.17340094f, -0.07579700f, -0.18467027f, -0.26368815f, 
    0.32495505f, -0.09018151f, 0.08550386f, -0.08788330f, -0.08073670f, 0.03364206f, 0.31807095f, 0.29768375f, 
    0.39720666f, -0.01726039f, -0.22420491f, -0.30720314f, -0.38833663f, -0.04589745f, 0.30177733f, 0.00029931f, 
    -0.47480732f, 0.03565798f, 0.31989598f, -0.12526229f, 0.25341129f, 0.49777722f, -1.06557548f, 0.09079019f, 
    0.66530889f, -0.83049434f, -0.24362250f, -0.48867646f, -0.37790993f, -0.03033544f, 0.56069440f, 0.38658330f, 
    -0.42520976f, -0.44679224f, -0.35299537f, -0.03184036f, -0.08224128f, 0.02877534f, -0.10408282f, -0.21035650f, 
    -0.15017326f, -0.38629362f, -0.07344704f, -0.14871594f, 0.05383148f, 0.03419861f, -0.17809914f, -0.51651168f, 
    -0.32002711f, -0.29659465f, 0.37936491f, 0.62397534f, 0.54254591f, -0.50911087f, -1.01528752f, -0.14715718f, 
    0.66702569f, -0.15514624f, 0.34822971f, -0.34908715f, 0.25636381f, -0.17254235f, 0.15136652f, 0.08336025f, 
    -0.05059743f, -0.03348520f, -0.35730925f, 0.35390779f, -0.14261240f, -0.25410169f, 0.14648604f, -0.34391406f, 
    0.68411952f, 0.15021852f, -0.16568598f, -0.50386828f, -0.31749767f, -0.13684459f, -0.08643693f, -0.00822340f, 
    0.12248919f, 0.06419231f, -0.13967952f, 0.08577822f, 0.10176057f, -0.10448344f, -0.26702037f, 0.07410191f, 
    -0.22256458f, 0.07385093f, -0.26015937f, -0.10167237f, -0.47119266f, -0.45565575f, -0.27896449f, -0.43332246f, 
    -0.58371633f, -0.20149793f, 0.01205437f, -0.01181160f, 0.33794203f, 0.26328865f, 0.34961271f, -0.11754666f, 
    0.00431519f, -0.29372188f, -0.24370827f, 0.28128690f, -0.13453101f, 0.00580221f, -0.11403311f, 0.06468579f, 
    -0.14544465f, -0.17101575f, 0.34614143f, -0.25697875f, 0.19532883f, -0.29544404f, -0.02361576f, 0.06371997f, 
    0.07751881f, 0.27075216f, -0.39604175f, -0.64465570f, -0.25302273f, 0.20670094f, -0.01268198f, 0.26516190f, 
    0.28772333f, 0.17031962f, 0.11810492f, 0.06718908f, 0.12288726f, 0.05122973f, -0.04704876f, 0.16446483f, 
    0.22840415f, -0.16392429f, 0.18266922f, -0.16891272f, -0.05295540f, 0.03947774f, 0.17755574f, -0.37993670f, 
    -0.01567638f, 0.10512522f, -0.09759613f, 0.62888432f, 0.28437477f, -0.04617850f, 0.52614915f, -0.19983207f, 
    -0.43974999f, -0.30170262f, -0.49022847f, 0.00307643f, 0.16775671f, 0.43051314f, -0.31529111f, -0.14053255f, 
    0.25086799f, 0.15244967f, -0.12323543f, -0.07542866f, 0.25774774f, -0.29229745f, 0.07262455f, 0.15583515f, 
    -0.11543278f, -0.07241388f, -0.00000952f, -0.08773562f, -0.39919043f, -0.59949261f, 0.01778354f, -0.57721770f, 
    -0.61366427f, 0.44562954f, 0.17848051f, -0.18410666f, -0.18470092f, -0.07074516f, -0.03132895f, 0.04864549f, 
    -0.02072197f, 0.38656774f, 0.24777728f, -0.14583333f, 0.05885110f, 0.01094233f, -0.32375696f, -0.22243115f, 
    -0.10552002f, -0.07604195f, -0.01998031f, -0.19490147f, -0.13653280f, 0.34238961f, -0.04501495f, -0.01514578f, 
    0.13147745f, 0.16591899f, 0.45263407f, 0.06087568f, -0.28727323f, -0.12928334f, 0.29369801f, -0.09377804f, 
    -0.18279274f, 0.12812296f, 0.03767569f, -0.12906733f, 0.09893060f, 0.08713040f, -0.12027230f, -0.12319764f, 
    0.00451690f, 0.15032196f, -0.02682798f, 0.15264133f, -0.08790890f, -0.37859944f, 0.66079646f, 0.45864713f, 
    0.03156806f, 0.16608916f, -0.59071845f, -0.34597579f, -0.39981717f, 0.06801625f, 0.24448198f, 0.15882628f, 
    0.22063029f, -0.02837511f, -0.08335715f, 0.03004303f, -0.22847526f, -0.18156068f, -0.09206586f, 0.25119200f, 
    0.17958279f, -0.25888094f, -0.16843109f, 0.25963575f, -0.13252279f, -0.05174052f, 0.24781923f, -0.22162995f, 
    -0.24359672f, 0.13200873f, -0.37665087f, -0.28299156f, -0.14358325f, -0.05316831f, -0.00228091f, 0.46526667f, 
    0.09179737f, 0.14713065f, -0.31591398f, -0.25516701f, 0.03509909f, -0.02921526f, -0.13095951f, 0.36539480f, 
    0.24898137f, 0.17196675f, -0.00509762f, -0.28561604f, -0.27505660f, -0.18389194f, -0.27983525f, -0.41952312f, 
    0.64395380f, -0.07357001f, -0.14352816f, 0.18658282f, 0.14729783f, 0.42818573f, 0.36676291f, 0.07525364f, 
    -0.08668918f, -0.21424671f, -0.31382847f, -0.02378720f, -0.19212903f, -0.07965881f, 0.10093693f, -0.05585261f, 
    -0.05496021f, -0.07392561f, 0.07042283f, -0.21934614f, -0.14049664f, -0.25280240f, -0.41868719f, -0.61037952f, 
    -0.49895206f, 0.07751274f, -0.36676824f, -0.51022071f, -0.07994166f, -0.11712843f, -0.34755480f, -0.26130456f, 
    -0.34790048f, 0.13516459f, -0.03380097f, 0.41724646f, 0.30338681f, 0.35422778f, 0.18042582f, 0.32804966f, 
    0.07347818f, -0.01549954f, 0.10173097f, -0.19285198f, -0.00259487f, -0.19611926f, 0.22760661f, -0.04913253f, 
    -0.29211861f, 0.10528952f, 0.39404178f, 0.38108817f, -0.12574099f, -0.44143295f, -0.01499734f, 0.34476027f, 
    -0.04818106f, -0.11614221f, -0.37249485f, 0.02081425f, -0.19950214f, 0.47724685f, -0.26699325f, -0.01972203f, 
    0.36027724f, 0.12093607f, 0.21106301f, 0.00097352f, -0.02439817f, -0.36568490f, -0.15601367f, -0.12438925f, 
    0.10109196f, 0.06811305f, 0.23825945f, 0.23837440f, -0.00740820f, -0.04752567f, 0.53424644f, -0.76660258f, 
    -0.21475810f, 0.00837125f, 0.13175252f, -0.00103759f, -0.06985682f, 0.55453879f, -0.50884283f, -0.11613475f, 
    0.03937314f, 0.27473608f, -0.00397624f, 0.28211322f, 0.05201402f, -0.09153037f, -0.24803424f, -0.25596929f, 
    -0.19719230f, 0.35344359f, 0.31812951f, -0.09626820f, 0.49576715f, -1.14310658f, 0.14749782f, 0.41246939f, 
    0.28459635f, 0.50113052f, 0.70521158f, -0.41424820f, -0.73662031f, 0.02321938f, -0.13592242f, -0.13513045f, 
    0.07853840f, -0.24076556f, 0.02704944f, 0.03126822f, -0.27444881f, 0.24110194f, 0.22023271f, -0.18335964f, 
    -0.10404732f, 0.05395328f, 0.02815382f, 0.04260978f, -0.14662629f, 0.56417871f, 0.10188390f, -0.47229752f, 
    0.06943207f, -0.15521947f, -0.32875738f, -0.01357893f, 0.07050089f, 0.24007359f, 0.37054354f, -0.18959425f, 
    0.00663745f, -0.12091284f, -0.22568861f, 0.11229964f, -0.10095371f, -0.10491244f, 0.10484056f, 0.26247647f, 
    -0.29170379f, -0.00251774f, -0.21014117f, 0.12924175f, 0.08773924f, 0.19710872f, -0.27485240f, -0.01089101f, 
    0.53540754f, 0.57136828f, -0.29907468f, -0.71686888f, -0.56471717f, 0.08847514f, -0.11136749f, -0.36447349f, 
    0.62475759f, -0.18156356f, 0.27941248f, 0.15483055f, -0.10047808f, -0.30769452f, -0.00578523f, 0.23192286f, 
    -0.46135056f, -0.63200617f, -0.05877795f, -0.24802053f, -0.12725683f, -0.19963892f, 0.24343520f, 0.30179784f, 
    0.16784281f, 0.09916736f, -0.13907269f, 0.01596998f, -0.08327243f, 0.07511416f, 0.05552471f, 0.21329868f, 
    0.29061452f, 0.01344566f, 0.20163521f, -0.21981463f, 0.16986200f, 0.24051155f, -0.03540905f, 0.01448686f, 
    -0.22640663f, -0.12836422f, 0.00871672f, -0.33920586f, 0.08128045f, 0.24003325f, 0.21042150f, 0.13091408f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08954994f, 0.36609650f, -0.09440483f, 0.37398279f, -0.15044037f, 0.24712241f, 0.27623519f, -0.08629672f, 
    0.19822688f, 0.06618243f, 0.07078493f, 0.13064584f, -0.09141741f, 0.20594835f, 0.18486822f, 0.33935964f, 
    -0.04185263f, -0.08106679f, 0.11440565f, 0.20055963f, 0.23162341f, 0.19158871f, -0.16337542f, 0.15541054f, 
    0.30472913f, 0.24424757f, 0.27661699f, 0.25126249f, 0.13750559f, 0.42253807f, -0.01463079f, 0.17026702f, 
    -0.13631614f, 0.13566436f, -0.11147389f, 0.15615058f, 0.10104303f, 0.11860413f, 0.32349467f, 0.12992448f, 
    0.24396017f, 0.32946759f, -0.18921253f, 0.09037423f, -0.03094126f, 0.13883090f, -0.01049274f, 0.41503787f, 
    0.08470915f, 0.13006461f, 0.04802646f, 0.13300826f, -0.00979184f, 0.22477633f, 0.36893135f, -0.22771667f, 
    0.10398009f, 0.10742893f, 0.03393756f, 0.16259931f, 0.17376475f, 0.34723014f, -0.03492627f, 0.18092962f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00302767f, 0.02374955f, 0.00464327f, -0.01459865f, 0.01365272f, 0.00905144f, 0.01223231f, -0.02594335f, 
    0.01811698f, -0.00092952f, -0.00065158f, -0.02496083f, 0.01086565f, 0.01944647f, -0.02569410f, -0.04159221f, 
    0.02649380f, -0.02172150f, -0.03701121f, 0.00654163f, -0.02004747f, 0.02576166f, -0.00926247f, -0.02170233f, 
    -0.03387673f, -0.02851240f, -0.03416091f, 0.02137639f, -0.02158658f, 0.00843583f, 0.00601374f, -0.03069197f, 
    0.02295503f, -0.03399373f, -0.00262558f, -0.02780473f, -0.01649967f, 0.00204521f, -0.02604325f, -0.00081365f, 
    0.00006246f, -0.01155429f, -0.02298244f, -0.00478824f, -0.00628117f, -0.01153299f, -0.03970673f, 0.02391372f, 
    -0.03936426f, 0.02523022f, -0.01382821f, 0.02329297f, 0.01787869f, 0.01929406f, -0.01509811f, 0.00140404f, 
    -0.00302927f, -0.02194801f, -0.03914317f, -0.03498147f, 0.02579490f, -0.04055905f, 0.01592311f, -0.00614389f, 
    0.02624519f, -0.03610377f, -0.00492904f, -0.00230154f, 0.02171763f, -0.01122349f, 0.00287115f, -0.03488132f, 
    -0.03288456f, -0.03621953f, -0.01489880f, -0.02603157f, -0.01921634f, 0.02010498f, 0.00556623f, 0.00270909f, 
    -0.02013808f, -0.03315918f, -0.01540383f, -0.00175001f, 0.01811175f, -0.00002014f, -0.01858002f, -0.02788580f, 
    0.03545489f, -0.01509266f, -0.03740415f, 0.01481450f, 0.01096481f, -0.00896360f, 0.02751124f, -0.02215372f, 
    0.01925415f, 0.00076440f, -0.00910585f, 0.00012044f, -0.02525718f, 0.00157453f, -0.02417587f, 0.02581133f, 
    -0.01990114f, -0.03013100f, -0.02318062f, 0.02406740f, -0.00673234f, 0.02036596f, -0.02943069f, -0.02882719f, 
    -0.00064810f, -0.01794814f, -0.03327560f, -0.00910012f, -0.03073840f, 0.01201094f, -0.02185663f, -0.03474906f, 
    0.01467163f, 0.01367200f, -0.02130722f, 0.02164579f, -0.02463742f, 0.01101536f, 0.01268908f, -0.04220435f, 
    -0.00805718f, 0.02185471f, 0.00815048f, 0.02453988f, -0.01415597f, 0.01493453f, 0.00676915f, 0.01044278f, 
    -0.02945223f, -0.01799387f, 0.00535476f, -0.02707463f, 0.02507360f, -0.00024489f, 0.02608769f, -0.01642158f, 
    -0.02827180f, 0.02401535f, -0.00998169f, 0.01927134f, -0.03267312f, 0.02032581f, -0.01538271f, 0.01607058f, 
    -0.02482412f, 0.03362527f, -0.01358930f, -0.00897155f, -0.00430633f, -0.02985916f, -0.03794184f, 0.01816730f, 
    -0.01045440f, -0.03481149f, -0.00023875f, 0.01010444f, 0.02217904f, 0.01594392f, -0.00675416f, -0.02124391f, 
    0.01083828f, -0.04564051f, 0.00320695f, -0.00066357f, 0.02167135f, -0.03767296f, 0.00306922f, 0.01354057f, 
    0.00267858f, 0.00366980f, 0.03281220f, -0.01489832f, -0.01403710f, 0.01774889f, -0.01470657f, -0.01936674f, 
    0.01337152f, 0.03116568f, -0.04033405f, 0.02041787f, 0.02260869f, 0.01948406f, 0.02219107f, -0.00322543f, 
    -0.01361016f, -0.01863077f, -0.01216215f, -0.01429265f, 0.00406243f, 0.03250289f, 0.01565679f, -0.00706338f, 
    -0.01324685f, -0.02246683f, 0.00972991f, 0.02262586f, 0.01008078f, 0.02314496f, -0.03351237f, 0.02753114f, 
    0.03258312f, -0.02972433f, 0.02053980f, -0.00088144f, -0.00364401f, -0.01858494f, 0.02626271f, -0.01198434f, 
    -0.03985645f, -0.02723885f, -0.02045132f, -0.02616696f, 0.00236800f, -0.01100789f, -0.03413271f, 0.02482526f, 
    0.00250513f, -0.02650621f, 0.00319501f, 0.02457783f, -0.04366823f, 0.01329994f, 0.00361579f, 0.00802368f, 
    -0.00337755f, -0.01594371f, 0.01369686f, -0.03585266f, -0.00031733f, -0.00499619f, -0.01780751f, 0.02511729f, 
    -0.01946382f, -0.00065256f, -0.01573699f, -0.01098582f, 0.00335039f, 0.02203026f, -0.00581741f, -0.02714168f, 
    -0.00552389f, -0.02780389f, -0.01760409f, -0.00182428f, 0.02469470f, -0.03644354f, -0.01413801f, 0.01527042f, 
    -0.02978434f, -0.03087502f, 0.02642658f, 0.02750717f, -0.00500343f, 0.03146751f, -0.01610284f, 0.02333208f, 
    -0.00723896f, 0.02565252f, 0.01731568f, 0.00742291f, -0.01806232f, -0.02692086f, -0.00695008f, -0.01398013f, 
    0.00380122f, 0.02294875f, -0.01738299f, -0.03243963f, -0.01968312f, -0.01620092f, -0.02210245f, 0.00499655f, 
    0.01635646f, -0.02374001f, 0.00465788f, -0.00940165f, 0.02745805f, -0.04075651f, -0.03269487f, 0.02152223f, 
    -0.01014740f, 0.01881184f, -0.03691814f, -0.03091375f, 0.01882733f, 0.00792435f, -0.03149285f, -0.02339570f, 
    -0.04221512f, 0.00976597f, -0.03619508f, -0.00823403f, 0.01818554f, 0.02149599f, -0.03442412f, -0.04114060f, 
    -0.00944240f, -0.00143312f, -0.00853467f, -0.03505210f, 0.02861835f, 0.02880556f, -0.01367601f, -0.00557071f, 
    -0.03432669f, -0.04257120f, -0.00893892f, 0.01284255f, 0.02306226f, -0.02615442f, -0.02274575f, -0.01013451f, 
    -0.03856116f, -0.01854927f, -0.03647984f, 0.00284366f, 0.01051051f, -0.03548430f, 0.00523263f, 0.02117860f, 
    -0.00006238f, -0.00700630f, 0.02134341f, -0.03552809f, -0.00164113f, -0.02742646f, -0.03863801f, 0.00146292f, 
    0.02408733f, 0.01607582f, 0.02005001f, -0.02197301f, -0.04238300f, -0.01360947f, -0.01287637f, -0.00757558f, 
    -0.01446070f, 0.01671488f, -0.00070537f, -0.01164815f, -0.03472551f, 0.02129480f, 0.01960207f, -0.04090533f, 
    -0.01278112f, -0.00548834f, -0.02126495f, 0.01930495f, 0.00540758f, 0.01323509f, 0.02357209f, -0.02213166f, 
    0.02023971f, -0.03896593f, 0.01045961f, -0.00851942f, 0.01833832f, -0.02983365f, -0.01534735f, -0.00115026f, 
    0.02421725f, -0.00917804f, -0.01168702f, -0.04197497f, 0.01325831f, 0.00380469f, -0.03831634f, -0.00819068f, 
    -0.00063858f, -0.03232951f, 0.03891537f, 0.00157031f, 0.01480818f, -0.00778198f, -0.00287576f, -0.00968315f, 
    0.01854569f, -0.02133468f, -0.00830043f, 0.00235358f, -0.03409370f, -0.00516277f, 0.02821592f, -0.00575039f, 
    0.00463852f, -0.01696439f, -0.03482772f, 0.00698861f, -0.01679834f, 0.02589246f, 0.00963070f, -0.03670987f, 
    0.02694710f, -0.01580356f, -0.01470610f, -0.02368517f, 0.01752781f, 0.02656941f, 0.02316357f, -0.01091916f, 
    -0.03221764f, -0.00314472f, -0.03849744f, -0.00900456f, -0.01361068f, -0.02678794f, -0.01076496f, 0.02220569f, 
    -0.01474077f, -0.01410597f, -0.02346530f, -0.02485467f, 0.00802976f, -0.03442325f, -0.03207241f, -0.03226833f, 
    0.03070380f, -0.02465900f, 0.02172636f, -0.04330345f, -0.00982631f, -0.02368750f, 0.01742189f, -0.01923218f, 
    -0.00787233f, 0.00507096f, -0.01028485f, -0.01399836f, -0.00787967f, -0.03908612f, 0.02376098f, -0.02904331f, 
    -0.02338347f, -0.01681328f, 0.00179458f, 0.01976360f, 0.00601480f, -0.00590588f, -0.03561651f, -0.03421172f, 
    0.04333748f, -0.01307874f, 0.00123045f, -0.00142440f, -0.02699266f, 0.02820350f, -0.00650610f, -0.01707242f, 
    -0.04182178f, -0.00787738f, 0.00485743f, 0.00922273f, -0.03686607f, -0.03515144f, -0.03889101f, -0.02873713f, 
    -0.03070039f, -0.03651323f, -0.01159263f, 0.01697084f, 0.02577472f, -0.00461593f, 0.00647059f, 0.01982524f, 
    -0.02391249f, 0.02859100f, 0.02627313f, -0.03310397f, 0.01945581f, 0.02593102f, 0.02505528f, -0.03798714f, 
    -0.02512744f, -0.00436018f, 0.03024447f, 0.00802582f, -0.00863730f, -0.01781925f, 0.01132248f, -0.04308105f, 
    -0.01775138f, 0.01940671f, -0.01978300f, 0.02618015f, 0.00039581f, 0.02217149f, 0.01383427f, -0.04375872f, 
    0.01783640f, 0.02628641f, -0.02843921f, 0.01796673f, -0.02128164f, 0.00324469f, 0.01589304f, 0.01280141f, 
    -0.01534435f, -0.04013106f, 0.02326982f, -0.00941656f, -0.02984710f, 0.00567862f, -0.01166382f, -0.02708889f, 
    -0.01589483f, 0.00071383f, 0.01686640f, 0.00222630f, -0.02589313f, 0.00371837f, -0.02628998f, -0.03960967f, 
    0.01462384f, -0.02480901f, -0.00607876f, 0.02574604f, 0.01080998f, -0.02720563f, 0.02185353f, 0.02750159f, 
    -0.01614001f, -0.01369258f, 0.00518535f, 0.02238245f, 0.00440111f, -0.00561938f, 0.02324392f, 0.02516738f, 
    0.02967491f, 0.01868973f, 0.02748862f, -0.03083430f, 0.00315427f, -0.00454405f, -0.03165150f, 0.02693092f, 
    -0.02123476f, -0.02208253f, 0.00409967f, -0.00714984f, 0.02084838f, -0.01730682f, -0.03100679f, -0.03901409f, 
    -0.01991797f, 0.02717607f, -0.00421573f, 0.00379336f, 0.01345856f, 0.00078589f, -0.00527394f, -0.00730304f, 
    -0.02972628f, 0.00262699f, -0.00635435f, -0.03165472f, -0.01312890f, 0.00322747f, 0.01043194f, 0.01458788f, 
    -0.02540083f, -0.02093227f, 0.02420775f, 0.02232707f, -0.01298134f, 0.02367931f, 0.00602859f, -0.03837741f, 
    -0.02534221f, 0.00911846f, -0.02573066f, 0.01501217f, 0.01294688f, -0.03096570f, -0.01946042f, -0.02226846f, 
    -0.00624929f, -0.00446124f, -0.00856903f, 0.00174419f, 0.00413879f, -0.02767071f, 0.01311041f, 0.01645902f, 
    -0.02026500f, -0.00411837f, 0.01016287f, -0.02908411f, -0.00280105f, -0.03336409f, -0.01045957f, -0.03637829f, 
    -0.03457285f, 0.00543340f, 0.00631586f, -0.03540524f, 0.02310338f, -0.04269907f, 0.01425213f, 0.01899709f, 
    0.01499857f, -0.00837685f, -0.01060191f, -0.00448605f, 0.00663899f, -0.00447799f, 0.01492307f, 0.01425907f, 
    -0.03924484f, 0.00980087f, -0.02978417f, -0.00709684f, -0.00801938f, -0.01042033f, 0.01012365f, -0.04016153f, 
    0.01523184f, -0.00094310f, -0.04031648f, 0.02313010f, 0.02770763f, -0.01995510f, -0.00510682f, 0.02970790f, 
    0.02234592f, -0.00235644f, -0.00365815f, -0.02847013f, -0.03535145f, -0.02578514f, -0.00269107f, 0.02511571f, 
    -0.00520693f, -0.03673391f, -0.03629632f, -0.00208956f, 0.02644123f, -0.00004142f, 0.01883209f, 0.02375234f, 
    -0.00376148f, -0.03048060f, -0.02456650f, 0.02570337f, 0.00252093f, 0.01289647f, 0.02223644f, -0.02715685f, 
    -0.01566181f, -0.01236592f, -0.00034241f, -0.04136616f, -0.02683045f, -0.00908689f, -0.03530779f, 0.01492715f, 
    0.02385312f, 0.01585882f, 0.00253860f, 0.00773572f, 0.00876870f, -0.04108663f, 0.01558592f, 0.00723495f, 
    -0.02307342f, 0.00047812f, -0.03816546f, 0.01267595f, -0.00649104f, -0.01404899f, -0.02720654f, 0.00809452f, 
    -0.03355283f, 0.01849617f, 0.03456504f, -0.00969896f, 0.02247725f, -0.01342406f, -0.03429394f, -0.01149485f, 
    0.03562772f, -0.03145744f, -0.02399730f, 0.03168310f, -0.01146363f, 0.00681619f, -0.00003602f, 0.01683870f, 
    -0.00691790f, 0.02054784f, 0.00559608f, 0.00769335f, 0.01281165f, 0.00702100f, 0.02615387f, -0.00094509f, 
    0.00315573f, -0.04377456f, -0.03334299f, -0.04095553f, 0.00495882f, -0.03036120f, -0.03025104f, 0.01904802f, 
    -0.02375690f, -0.01224761f, -0.00416866f, -0.02319736f, -0.01499842f, -0.00238562f, 0.00011852f, -0.03173455f, 
    0.01946041f, -0.01908587f, -0.01078778f, -0.00260348f, 0.01506802f, -0.02293647f, -0.02263008f, -0.00622600f, 
    -0.03656433f, -0.03908151f, -0.02914707f, 0.03049703f, -0.00371819f, 0.00957186f, -0.03907413f, -0.00917773f, 
    -0.03522435f, 0.02524325f, -0.03479786f, 0.02477175f, -0.02967357f, 0.00290707f, 0.00893752f, -0.00078306f, 
    0.00210642f, 0.02589738f, -0.04030069f, -0.00460259f, 0.02040883f, 0.01365680f, -0.00174941f, -0.00754496f, 
    -0.00697990f, 0.00062311f, -0.00725666f, -0.01201752f, 0.01481026f, -0.00776368f, 0.01090596f, -0.02484669f, 
    -0.02062756f, -0.03598851f, -0.02995443f, -0.01434705f, 0.01318442f, -0.01666068f, 0.00322846f, 0.03517391f, 
    0.09185704f, -0.04426594f, 0.09185842f, -0.05249463f, -0.03908794f, -0.00988806f, 0.09410516f, -0.03754654f, 
    -0.02429869f, 0.09078638f, 0.12342126f, -0.04965888f, -0.07532771f, -0.08786414f, 0.04437863f, -0.10736203f, 
    0.04733504f, -0.04128642f, 0.05734248f, 0.16712759f, 0.05304038f, 0.08388963f, 0.10505811f, 0.01859355f, 
    -0.01419465f, 0.11841080f, 0.16423155f, -0.07768765f, -0.01044130f, -0.07792137f, -0.03606417f, -0.07637977f, 
    0.02642449f, -0.01344662f, 0.25064570f, 0.17713904f, 0.15997469f, 0.08020705f, -0.01219369f, 0.13031484f, 
    0.07062573f, -0.00157358f, -0.01023963f, -0.05776024f, 0.10017654f, 0.08834771f, 0.20819305f, 0.19356988f, 
    -0.11772481f, -0.08614024f, -0.08510367f, -0.00156817f, -0.13870998f, -0.05762231f, 0.04840832f, 0.00443902f, 
    -0.00145134f, 0.04717948f, 0.05118362f, 0.11045520f, -0.37785655f, -0.03945410f, 0.03990002f, -0.07545416f, 
    0.02106960f, -0.12341973f, 0.02133361f, 0.04030889f, -0.02494950f, -0.01995823f, 0.10392491f, 0.00038642f, 
    -0.19588906f, 0.14598624f, -0.04933706f, -0.04865816f, 0.09332267f, 0.17190701f, 0.03684365f, 0.16631193f, 
    0.03966023f, 0.13659465f, 0.05299431f, 0.00086951f, 0.01054092f, -0.04183056f, -0.06577252f, -0.07109011f, 
    0.26132336f, 0.00259763f, 0.05715061f, -0.09255949f, 0.02839769f, 0.05875966f, -0.09770337f, -0.04709861f, 
    -0.07018573f, -0.07260390f, -0.13395731f, -0.04415910f, 0.04379994f, -0.03051029f, 0.20936492f, 0.29297501f, 
    0.00823925f, 0.01649714f, 0.04103637f, 0.09728001f, -0.02217451f, -0.06174233f, -0.06123137f, -0.11856694f, 
    -0.03469785f, -0.04452166f, 0.11543302f, 0.06538476f, 0.02804547f, -0.08288320f, -0.03869817f, -0.04069969f, 
    0.04532495f, 0.00491402f, 0.21763921f, -0.02822008f, -0.01611143f, -0.04031254f, -0.01800775f, -0.07126708f, 
    -0.04169538f, -0.05889121f, -0.05655877f, -0.00819848f, -0.08364906f, 0.05030432f, -0.10949346f, -0.03623213f, 
    0.03516005f, 0.21335290f, -0.04456338f, 0.12454038f, 0.36132190f, -0.06668273f, 0.12099100f, 0.11238881f, 
    -0.07377816f, 0.12486503f, 0.23829333f, 0.11881902f, -0.06833767f, -0.00704403f, -0.06800836f, -0.09871242f, 
    0.10926865f, 0.26098719f, 0.06210025f, 0.18436365f, 0.09550772f, -0.11377604f, -0.14813437f, -0.07978746f, 
    0.11514341f, -0.07280609f, 0.01270279f, -0.03718534f, -0.00965364f, -0.04074403f, -0.07441903f, -0.01625954f, 
    0.02482793f, -0.10696927f, 0.26897743f, -0.15941377f, 0.05878752f, 0.01494307f, 0.18280451f, 0.06444505f, 
    0.13846277f, 0.08258106f, -0.03554654f, 0.13589792f, 0.10108183f, 0.04499197f, -0.02066544f, -0.06802776f, 
    -0.01386033f, 0.05588157f, 0.29118121f, 0.06002753f, -0.06016729f, -0.02001606f, -0.09671486f, -0.01344965f, 
    -0.33494696f, -0.01964750f, -0.02000258f, -0.13987751f, -0.15081383f, 0.06264848f, -0.11719245f, -0.17997307f, 
    0.00437617f, -0.05311361f, 0.10637063f, 0.00421137f, -0.29019439f, 0.00305902f, 0.03902253f, -0.03886710f, 
    -0.17130728f, -0.08190184f, -0.08731344f, -0.05698507f, -0.18401653f, -0.14094211f, -0.04737011f, -0.04493316f, 
    0.05742447f, -0.09179118f, 0.02232822f, -0.02452616f, 0.05031964f, 0.10347933f, 0.12412931f, -0.07381198f, 
    0.07543418f, -0.01128243f, 0.13157694f, -0.04706774f, 0.39435053f, -0.18617900f, 0.12852263f, -0.12840927f, 
    0.15898283f, -0.07771811f, 0.18312596f, 0.08723785f, 0.03200293f, 0.09064726f, 0.03563681f, -0.07276683f, 
    -0.39971313f, 0.13220291f, 0.07137414f, 0.04676891f, 0.03690822f, -0.10667764f, 0.20893756f, 0.01724386f, 
    0.06324752f, -0.00159362f, -0.07706118f, -0.04546355f, -0.17328987f, -0.06353086f, 0.14561665f, 0.13816489f, 
    -0.00634503f, -0.04226786f, 0.05444676f, -0.00650071f, 0.12017753f, 0.10468699f, 0.08484326f, 0.01991951f, 
    -0.16775006f, -0.04313067f, 0.05727686f, -0.15126345f, -0.20247495f, -0.06524117f, 0.13602196f, 0.03417429f, 
    -0.07217313f, 0.07818617f, 0.06989516f, 0.03281025f, -0.02290281f, 0.13562004f, 0.00856084f, -0.08078345f, 
    0.08643185f, 0.00559012f, -0.01800861f, -0.14140064f, 0.00818095f, 0.06315820f, 0.07669315f, 0.04375994f, 
    0.05743862f, -0.03166148f, 0.00451616f, -0.02121859f, 0.07710471f, -0.09327083f, 0.02681863f, -0.06646786f, 
    0.18883784f, 0.06326731f, 0.07509438f, 0.25279748f, -0.11673909f, -0.00260316f, 0.02828941f, 0.14865758f, 
    -0.10506845f, -0.02223798f, -0.11686876f, -0.06413990f, 0.19268274f, 0.19798040f, 0.11065151f, 0.12940224f, 
    0.03479319f, 0.02940082f, 0.10021500f, -0.00850370f, -0.04467408f, -0.01052618f, -0.08205758f, 0.03309993f, 
    0.03872906f, 0.10918146f, 0.18637988f, -0.00343890f, 0.18153787f, 0.19403735f, 0.11075120f, 0.02282063f, 
    0.04462280f, -0.01857367f, -0.01802088f, -0.01984427f, 0.00129553f, 0.03739499f, -0.02705764f, 0.02162306f, 
    -0.06496706f, 0.10418576f, -0.49902937f, 0.03268471f, 0.14048047f, 0.00706593f, -0.01110278f, -0.09800395f, 
    -0.06406398f, -0.01998479f, -0.10772106f, -0.02619646f, 0.04754593f, 0.03106360f, 0.12769240f, 0.17218846f, 
    -0.01719145f, -0.00361164f, -0.06756107f, 0.04618162f, 0.38139051f, -0.00856789f, 0.25472745f, 0.19960126f, 
    -0.18174282f, 0.05027823f, -0.06427706f, -0.25185460f, 0.10378437f, 0.18295220f, 0.19107765f, -0.13512933f, 
    -0.05758628f, -0.06069028f, -0.01585387f, -0.05955519f, 0.17171003f, 0.17372911f, -0.21170177f, -0.09056389f, 
    0.21358882f, 0.01696475f, 0.15386677f, 0.07318875f, 0.01466161f, -0.12555932f, 0.00231269f, 0.08014584f, 
    0.14074761f, -0.01202324f, 0.06487408f, 0.01642605f, -0.03409321f, -0.01943822f, 0.02226006f, -0.09924248f, 
    -0.08507764f, -0.10263930f, -0.02405891f, -0.08029823f, -0.11168382f, 0.03654309f, -0.07912613f, 0.01831188f, 
    -0.13124357f, -0.07891387f, 0.09685654f, -0.10731054f, -0.00091069f, 0.02092436f, -0.06776112f, 0.04437059f, 
    -0.05635178f, 0.00658840f, 0.06427871f, 0.00806356f, -0.06275151f, -0.06022650f, -0.09720087f, 0.08362360f, 
    -0.03606247f, 0.07712733f, -0.05577224f, -0.09139120f, -0.10209218f, -0.08151509f, -0.13778888f, -0.23224036f, 
    -0.05453402f, -0.16919188f, 0.10097628f, 0.25592598f, -0.03080687f, 0.06314186f, 0.02161284f, 0.03621283f, 
    -0.05807363f, -0.05424795f, -0.02992480f, -0.07393160f, -0.05487301f, -0.10228781f, -0.04245178f, -0.01477994f, 
    -0.03468035f, 0.08618309f, 0.07472554f, 0.00417663f, 0.02858707f, -0.00598853f, -0.16028589f, -0.10964721f, 
    0.16695160f, -0.08225635f, 0.05698758f, 0.06212240f, -0.01095405f, 0.02437088f, 0.07002299f, 0.03892200f, 
    0.30357227f, -0.06538147f, 0.17391482f, -0.01571186f, -0.04051835f, 0.06661317f, 0.00171838f, 0.02338200f, 
    -0.01125641f, -0.04518348f, 0.04075986f, -0.16396445f, 0.10162047f, 0.02761678f, -0.05885963f, -0.03038393f, 
    0.15837784f, 0.16840956f, 0.11951478f, -0.00706494f, -0.02791975f, -0.12158953f, 0.16235283f, 0.02913975f, 
    -0.23884001f, 0.11910377f, -0.09621494f, 0.09187593f, 0.11802065f, 0.26072541f, -0.09997217f, 0.20231628f, 
    0.14640471f, 0.27542260f, -0.08597863f, 0.26813701f, 0.03484856f, -0.17015798f, 0.17737795f, 0.16908288f, 
    -0.01664500f, -0.07144222f, 0.00240813f, -0.01596400f, 0.19439863f, 0.00136172f, 0.09088510f, 0.08981562f, 
    0.11195271f, 0.06818719f, 0.06069683f, 0.03868884f, 0.07079685f, 0.13092630f, 0.02868606f, 0.01065456f, 
    0.07666350f, -0.00623306f, 0.10327460f, 0.03464589f, -0.23564200f, -0.12050826f, 0.20289955f, -0.02912621f, 
    -0.06947090f, 0.04981042f, 0.04880958f, -0.02520077f, -0.13450460f, 0.07897957f, 0.00876957f, 0.03983678f, 
    0.20383039f, -0.08431974f, -0.22179294f, 0.00435174f, 0.02405524f, -0.03505588f, 0.00680939f, 0.09051438f, 
    0.09333885f, -0.08060631f, 0.19078724f, -0.04961295f, -0.00909720f, -0.07881839f, 0.06358404f, 0.05521978f, 
    0.07185778f, -0.13897690f, 0.07876197f, 0.05229510f, 0.06080543f, 0.29900476f, -0.17204213f, 0.14987864f, 
    -0.14712764f, -0.07716074f, -0.13751438f, -0.10184558f, 0.24503076f, -0.16275705f, -0.00193943f, 0.14864065f, 
    0.19762604f, 0.10139192f, 0.21301635f, 0.09572954f, 0.13694383f, -0.23437783f, -0.12487804f, 0.05603242f, 
    0.06476556f, 0.22921278f, 0.22008081f, 0.12993439f, 0.12560984f, 0.17274934f, -0.01853898f, 0.00231932f, 
    0.07260515f, 0.00468340f, 0.11137408f, -0.05366825f, -0.02633628f, 0.00938548f, 0.03091331f, 0.08067130f, 
    0.04554521f, 0.10661582f, -0.11930484f, -0.07533699f, -0.04117039f, -0.10362275f, 0.00616535f, 0.03648349f, 
    0.05915185f, 0.07534990f, -0.05529794f, -0.06575678f, 0.00752491f, -0.00234206f, -0.01008133f, -0.01786087f, 
    -0.02660540f, -0.00638489f, 0.02112551f, 0.00563635f, -0.08939712f, -0.06092910f, 0.01285594f, -0.10078381f, 
    0.21899234f, -0.07863285f, 0.17472732f, 0.05656121f, 0.43859875f, 0.10037059f, -0.18344644f, -0.05525904f, 
    0.01207550f, -0.03398214f, 0.14284158f, -0.01798826f, 0.02125209f, -0.14121045f, -0.03583838f, -0.00178262f, 
    -0.17937697f, 0.01441350f, -0.08919499f, -0.03340191f, -0.00467756f, 0.08694223f, 0.08907440f, 0.12642500f, 
    -0.01668468f, 0.06377328f, 0.08314944f, -0.08391891f, 0.10331504f, 0.01289055f, 0.09862892f, 0.06859907f, 
    0.02348849f, 0.02055499f, 0.04583757f, -0.04038290f, -0.03547663f, 0.03820587f, 0.03105586f, -0.00368360f, 
    0.44800612f, 0.34815446f, 0.02344312f, 0.09918603f, 0.02546878f, -0.04223598f, 0.08566586f, 0.00501075f, 
    0.03025418f, -0.02525066f, -0.10725772f, 0.00978073f, -0.03801958f, -0.14792691f, -0.00840430f, -0.09276233f, 
    -0.00447442f, -0.04600467f, 0.08175040f, 0.03143371f, 0.01161112f, -0.02035286f, -0.03914710f, -0.21149632f, 
    0.08745236f, -0.01126912f, 0.22205612f, 0.00369587f, -0.04568392f, -0.02541386f, -0.01848311f, -0.07672244f, 
    -0.05424923f, -0.01529768f, 0.09512047f, -0.08943737f, -0.04808747f, 0.01145992f, -0.08195733f, -0.06209862f, 
    -0.01169713f, -0.11071840f, 0.01311546f, 0.09353489f, -0.00805925f, -0.07643246f, -0.03779666f, -0.03094913f, 
    0.06285270f, -0.11497398f, 0.00296178f, -0.16895917f, 0.04795782f, 0.03192224f, 0.02858578f, 0.15277405f, 
    0.20186673f, 0.07909980f, -0.10968638f, -0.00065436f, 0.18210292f, 0.13965149f, -0.05166472f, -0.04750249f, 
    0.00165756f, 0.04190021f, 0.12439035f, 0.28507432f, 0.29421014f, -0.03142171f, 0.06030650f, -0.09965301f, 
    0.30234283f, -0.33048382f, 0.21018723f, 0.06322259f, -0.07226197f, 0.07212082f, -0.11705430f, 0.02140353f, 
    -0.04692452f, -0.02592845f, 0.08875120f, -0.03926908f, 0.44601175f, 0.00415254f, 0.19912753f, 0.08090810f, 
    0.00683856f, -0.05898630f, -0.04106231f, -0.08680564f, 0.08745454f, 0.02053772f, 0.08581928f, 0.02431980f, 
    0.06682936f, 0.03097722f, -0.58406669f, -0.44044408f, -0.00171538f, 0.02196456f, 0.10399601f, 0.05526026f, 
    0.09576055f, 0.03799734f, -0.02568264f, 0.00160387f, 0.08260922f, 0.10906244f, 0.03042352f, -0.00319811f, 
    0.01347394f, -0.04684268f, 0.01068173f, 0.02720998f, 0.12298223f, 0.10766643f, 0.18111543f, 0.04160926f, 
    0.08414424f, -0.00972874f, 0.06291585f, -0.02075885f, -0.01432669f, 0.12730645f, 0.08703097f, 0.07281549f, 
    0.06592307f, 0.10938314f, 0.06046106f, -0.13904496f, 0.12716426f, -0.00466602f, 0.30532908f, 0.15174098f, 
    0.05743251f, -0.10440309f, 0.01555120f, 0.09986459f, -0.05377678f, -0.06126179f, 0.05814956f, 0.04021834f, 
    0.08677119f, 0.17566684f, -0.01955768f, 0.06056448f, 0.09743932f, -0.05524170f, -0.01003474f, -0.01765907f, 
    0.17099854f, 0.00186061f, 0.04153252f, -0.06957135f, 0.26081052f, -0.09291548f, -0.09439292f, 0.14549151f, 
    0.02422288f, -0.00249982f, 0.00582075f, -0.01522704f, 0.06388298f, -0.12948117f, -0.15777631f, -0.09114819f, 
    -0.13566804f, -0.05730972f, -0.05491124f, 0.01271808f, 0.05801960f, 0.10168066f, 0.05291405f, -0.04323918f, 
    -0.01061529f, -0.09290455f, 0.05694399f, 0.15451059f, 0.09497217f, 0.13138704f, 0.04230800f, 0.05469695f, 
    0.03468049f, -0.17437029f, -0.02761916f, 0.04798376f, 0.08974466f, 0.01222273f, 0.07788169f, 0.09339559f, 
    -0.14423163f, -0.01004085f, -0.00027407f, -0.14419262f, 0.03476096f, 0.00190528f, 0.12166253f, -0.00463646f, 
    -0.01702249f, 0.04700127f, 0.12702167f, -0.07725921f, 0.02681824f, 0.02909763f, -0.02796467f, -0.06361085f, 
    0.06579335f, -0.22282080f, 0.18755002f, 0.09058771f, 0.05344069f, 0.04622468f, -0.03350725f, -0.15385456f, 
    -0.22865620f, -0.11439828f, 0.05674321f, 0.04482852f, 0.03871977f, -0.14864117f, -0.05235724f, 0.04592954f, 
    -0.10121036f, -0.04364150f, -0.02858211f, -0.08682187f, -0.03761119f, 0.00640373f, 0.03643669f, 0.03365920f, 
    -0.04326734f, -0.03239800f, -0.02460398f, -0.11059271f, -0.05426027f, -0.07103840f, 0.03528367f, -0.09236924f, 
    0.15578139f, -0.12278788f, 0.04654118f, 0.02216556f, 0.13789055f, 0.02355147f, 0.13913187f, -0.07950338f, 
    0.05712319f, 0.06025235f, 0.05877661f, -0.01942705f, 0.06749927f, -0.38016364f, 0.39793181f, 0.31552163f, 
    -0.09100047f, 0.01109419f, -0.21596813f, 0.13572402f, 0.08953922f, 0.10856311f, 0.24447680f, 0.04503592f, 
    0.12043125f, 0.06828467f, 0.06222404f, 0.00226458f, 0.06961728f, 0.03344293f, -0.01844581f, -0.04301481f, 
    0.22216514f, 0.01111960f, -0.04894368f, -0.16747577f, -0.01548423f, -0.02897369f, 0.04933869f, 0.15338196f, 
    0.07081503f, 0.10100816f, 0.11092899f, 0.05971716f, -0.05061280f, -0.10320732f, -0.04375730f, -0.06745146f, 
    0.13694108f, 0.25546479f, -0.17597421f, -0.02631240f, 0.01381081f, 0.05209773f, 0.04454815f, -0.07753257f, 
    0.04789744f, 0.06175375f, 0.18985213f, 0.33032128f, 0.17694077f, 0.09882875f, -0.25833255f, 0.07304368f, 
    0.07745506f, 0.00788764f, 0.20555374f, -0.03811039f, 0.02665334f, 0.04362252f, -0.03629669f, -0.02710568f, 
    0.09460038f, 0.13259749f, 0.27977374f, 0.07313607f, -0.07905477f, -0.03314263f, -0.03082882f, -0.11925869f, 
    0.21114892f, -0.00902295f, 0.00210199f, 0.20238496f, -0.05144135f, 0.15742898f, 0.10589775f, -0.01613403f, 
    -0.18019488f, -0.17599805f, 0.02196834f, 0.03933718f, 0.02767250f, 0.04202698f, 0.00283456f, -0.04692371f, 
    -0.20509671f, 0.05189344f, 0.21922484f, 0.02826533f, -0.03425761f, -0.04762547f, 0.21370795f, 0.07500557f, 
    -0.01908275f, 0.06705554f, 0.04656769f, 0.04995640f, 0.26022762f, -0.04151032f, 0.08881167f, -0.04146406f, 
    0.08824723f, 0.06638483f, 0.01281867f, 0.10555575f, 0.09197292f, 0.01896896f, 0.07459431f, -0.09673541f, 
    -0.06144851f, -0.18073137f, 0.35428503f, 0.16997413f, 0.00616485f, -0.12327029f, -0.10531751f, -0.00980033f, 
    0.08490792f, -0.03414277f, -0.04351290f, -0.00789736f, -0.20452456f, -0.00133774f, 0.21279587f, 0.21672547f, 
    -0.00131632f, -0.01876525f, -0.06783380f, 0.04907569f, 0.03401764f, 0.31344610f, 0.18439618f, 0.28025141f, 
    -0.11790133f, -0.03331215f, 0.22988585f, -0.01603168f, -0.00397229f, -0.09061282f, -0.02564094f, 0.09691542f, 
    -0.06028190f, -0.01323426f, 0.04060560f, -0.07807223f, 0.05590997f, 0.07132138f, 0.24615334f, 0.15438727f, 
    -0.13783652f, -0.15444148f, 0.02157365f, 0.12966090f, -0.05313038f, 0.03445339f, 0.09953757f, 0.24120472f, 
    0.02603108f, 0.04228649f, 0.05145391f, 0.05939258f, 0.08057249f, -0.00412430f, -0.01503455f, 0.03371330f, 
    0.06777517f, 0.19397837f, -0.12637722f, -0.07614846f, 0.24580358f, 0.09824038f, 0.08773655f, 0.08633542f, 
    -0.01710795f, 0.01071381f, -0.08650831f, -0.07790409f, -0.09611993f, -0.01746030f, -0.03208696f, -0.09928775f, 
    0.24966036f, 0.18465504f, 0.35930261f, 0.05891855f, -0.04930746f, -0.04853067f, 0.00149539f, -0.01764140f, 
    -0.01229890f, -0.00931365f, 0.11381406f, 0.20199950f, 0.12824449f, -0.01827049f, -0.01924864f, -0.06917301f, 
    0.03510160f, 0.03380540f, 0.04125071f, -0.01585582f, 0.09904770f, -0.06522181f, -0.01632216f, -0.09315554f, 
    -0.01367573f, -0.54410535f, -0.19609575f, 0.08079228f, 0.07540372f, 0.06622325f, 0.00488123f, 0.09637412f, 
    0.01681073f, -0.01336730f, 0.04670006f, 0.01384132f, 0.20193978f, -0.08539596f, 0.04904895f, 0.04291492f, 
    -0.06889123f, 0.02475297f, -0.12196453f, 0.11688904f, -0.18593925f, -0.09587060f, 0.07544878f, -0.00844614f, 
    0.01986181f, -0.42913610f, 0.26034158f, 0.09021144f, 0.32812944f, 0.17487712f, 0.14489684f, 0.09773581f, 
    0.12447131f, 0.00543230f, 0.03160001f, 0.00579690f, 0.01301631f, 0.14418173f, -0.11920708f, -0.09006865f, 
    0.10227524f, 0.07863326f, 0.19831026f, 0.04853957f, 0.02739696f, 0.01838755f, -0.12397207f, -0.07010682f, 
    0.14986596f, -0.18225406f, -0.01126122f, 0.06127207f, 0.03837102f, 0.13659617f, 0.05034959f, 0.00566712f, 
    0.04055387f, 0.06932145f, 0.05214527f, 0.00969216f, -0.22782256f, -0.08425765f, 0.13696197f, -0.17311682f, 
    -0.00627167f, -0.19051455f, -0.12634449f, 0.17240670f, 0.01208752f, 0.01191969f, -0.03643700f, -0.04199903f, 
    -0.12565936f, 0.05106063f, 0.06785864f, 0.04481284f, -0.08625718f, 0.07163538f, 0.02026279f, 0.02397574f, 
    0.01843459f, 0.00206153f, 0.03626877f, -0.01781703f, -0.23748706f, 0.14392102f, -0.07180480f, 0.14986832f, 
    -0.01582920f, -0.16318157f, -0.09628566f, -0.06739227f, 0.06690247f, -0.03331730f, -0.07578271f, -0.08852678f, 
    0.45318455f, 0.29310006f, 0.26421520f, 0.20564206f, -0.06134130f, -0.14746103f, -0.05455739f, 0.08403549f, 
    0.09745046f, 0.06074803f, 0.16391502f, 0.10577018f, 0.10754608f, 0.04067063f, -0.10403976f, 0.13825820f, 
    -0.02529458f, 0.03998484f, 0.16083305f, 0.08634999f, 0.04291999f, -0.11161060f, -0.14861225f, -0.13949242f, 
    0.25864047f, -0.23102242f, -0.02088320f, -0.05637623f, 0.04452676f, 0.07670698f, -0.00277466f, -0.00657118f, 
    0.02157503f, 0.00368462f, 0.10784855f, 0.00006458f, 0.02463556f, 0.28842679f, -0.19523245f, -0.17900321f, 
    0.16743492f, -0.08383384f, 0.03907547f, 0.02680067f, 0.01717211f, -0.09858612f, -0.10354072f, 0.08458954f, 
    -0.14890988f, 0.07008380f, 0.00106471f, 0.04483781f, 0.14184171f, 0.00418463f, 0.01442139f, -0.27901959f, 
    0.11124000f, -0.07280019f, 0.10587427f, -0.07692455f, 0.16158216f, -0.35644206f, 0.22973764f, 0.10177639f, 
    0.10480026f, 0.12222575f, -0.06118166f, 0.04126891f, -0.05567545f, 0.09520172f, -0.03081059f, 0.08868168f, 
    -0.27053702f, -0.19897909f, 0.10090686f, 0.07647996f, -0.05270489f, 0.00773992f, -0.10699400f, 0.11529631f, 
    0.00002199f, 0.01908334f, 0.09091652f, 0.10827093f, -0.05327160f, -0.00064189f, 0.33352432f, 0.08356403f, 
    -0.02487102f, -0.05344624f, 0.00439642f, -0.09257115f, 0.17540462f, 0.25283432f, 0.09935665f, 0.22285746f, 
    -0.10370813f, -0.43616208f, 0.47133502f, 0.23632573f, 0.09920800f, 0.00912327f, -0.16116422f, 0.21427143f, 
    -0.07989508f, 0.08036990f, 0.08371275f, 0.18689287f, 0.15218002f, -0.06500656f, 0.25742090f, -0.08784206f, 
    0.11708303f, 0.03409213f, 0.10728632f, -0.01136523f, 0.01007818f, -0.05900620f, -0.21000431f, -0.01139018f, 
    -0.37253535f, -0.09865581f, -0.23179711f, 0.23476435f, -0.11139555f, 0.01957334f, -0.05497758f, -0.09831786f, 
    -0.08598974f, -0.05509456f, 0.19140774f, 0.17452897f, 0.13435943f, -0.57928437f, 0.24872197f, 0.26324788f, 
    -0.02638135f, 0.06641320f, -0.15810283f, 0.10149968f, -0.03838068f, 0.14031188f, 0.05019144f, -0.09752636f, 
    -0.00513981f, 0.14751953f, 0.09921019f, -0.03579190f, 0.03288968f, -0.04938856f, 0.12077625f, 0.02672350f, 
    0.25550470f, 0.38226992f, 0.29851454f, 0.38335800f, 0.04253604f, -0.14552727f, 0.16999492f, 0.08953501f, 
    0.12804790f, 0.12534933f, 0.01230995f, 0.10435570f, -0.12699105f, -0.11225459f, -0.00020913f, -0.14249052f, 
    0.01057256f, 0.02351481f, 0.15283333f, 0.08024752f, -0.02489705f, -0.05344713f, -0.04918101f, -0.05436373f, 
    -0.03823136f, 0.02807963f, -0.06461188f, 0.16021840f, 0.22081733f, -0.13744773f, -0.23928018f, 0.07929178f, 
    -0.02383796f, -0.02338966f, 0.16178744f, -0.04407274f, 0.06448101f, 0.00985296f, -0.02959296f, -0.05712013f, 
    -0.04937598f, 0.14083487f, 0.08390666f, -0.09311954f, -0.14711206f, -0.12231315f, 0.05785876f, -0.02422887f, 
    0.07848387f, 0.12007675f, 0.10438486f, 0.16808116f, 0.21295939f, -0.02589926f, 0.12329432f, -0.07035738f, 
    0.06021299f, -0.03460091f, -0.01277217f, -0.03281039f, 0.13055658f, 0.05982267f, 0.01826346f, -0.00708288f, 
    0.33454832f, 0.00963404f, -0.11346529f, -0.02933845f, -0.02262140f, -0.03917697f, 0.16737719f, -0.03492909f, 
    0.10589161f, 0.05558752f, -0.05021561f, 0.00112592f, -0.08214530f, 0.00702440f, 0.05668481f, 0.07221644f, 
    -0.11088858f, -0.01449720f, 0.22632526f, 0.05888796f, 0.13140213f, 0.06129418f, 0.12064886f, 0.37451893f, 
    0.05956326f, 0.02535213f, 0.15351771f, 0.02233116f, 0.08936121f, -0.01130656f, 0.03702930f, -0.02622953f, 
    0.14049776f, 0.09197304f, 0.27447262f, 0.45342487f, 0.07485693f, 0.11193684f, 0.16731708f, -0.03219641f, 
    0.01056896f, -0.05156836f, -0.00882846f, -0.00305559f, 0.04575354f, 0.03652486f, 0.08676119f, 0.02428135f, 
    0.22313501f, 0.01842875f, -0.02924521f, -0.08147968f, 0.07684737f, -0.03866716f, 0.10044445f, 0.02481405f, 
    -0.01589979f, -0.01668477f, 0.03385555f, -0.14116298f, 0.26560178f, 0.00858391f, -0.05991706f, -0.11609689f, 
    0.05474970f, -0.02116698f, 0.02978246f, 0.22263579f, 0.19364001f, 0.06562933f, -0.10016014f, -0.15283622f, 
    0.12823346f, -0.68732786f, 0.26241204f, -0.01141080f, 0.09375582f, 0.13422453f, -0.05220687f, 0.05256769f, 
    -0.01788703f, 0.06085191f, 0.05185488f, -0.04692646f, 0.06922369f, -0.15141867f, -0.10354879f, -0.20544967f, 
    0.01541936f, -0.02467261f, 0.08885126f, 0.09497330f, -0.09604248f, 0.05456704f, -0.05712228f, -0.01560639f, 
    -0.20541875f, -0.06585912f, -0.23198637f, 0.14481091f, -0.07557486f, 0.14474230f, 0.03423103f, 0.01473853f, 
    0.07264143f, 0.01281804f, -0.08783697f, -0.07980599f, 0.18723121f, 0.00395525f, -0.06121196f, 0.00026185f, 
    0.06182900f, -0.04742575f, -0.01249505f, -0.00414264f, -0.00787529f, -0.04347851f, -0.04175355f, -0.12073273f, 
    0.04151418f, -0.12741253f, -0.17069456f, 0.00769671f, 0.05947663f, 0.07789770f, -0.13342091f, -0.10740726f, 
    0.16507572f, 0.07767942f, -0.04073889f, 0.06551012f, 0.09391976f, 0.16616833f, 0.09198298f, 0.12450012f, 
    0.09592170f, 0.19622114f, 0.03749833f, -0.24329142f, 0.13577002f, -0.05615078f, -0.08616679f, 0.12758119f, 
    -0.30127403f, -0.07626868f, -0.13845789f, -0.08872934f, -0.01356647f, -0.05370175f, -0.00680866f, -0.02057227f, 
    -0.01374220f, 0.06420306f, -0.03795107f, 0.13773832f, -0.15800707f, 0.07913290f, 0.13093038f, 0.01100285f, 
    -0.06328642f, 0.03584544f, -0.02737885f, 0.03103703f, 0.03711176f, 0.01801063f, 0.22315970f, 0.08586840f, 
    0.21425575f, 0.23854554f, -0.20164482f, -0.37644473f, 0.00915312f, 0.02311333f, -0.09599462f, 0.11189444f, 
    0.03146117f, 0.06652716f, 0.03417992f, -0.01676757f, -0.08483754f, 0.13178127f, -0.14967570f, 0.09160122f, 
    -0.01471973f, 0.08416183f, 0.06712467f, -0.12503263f, 0.01492877f, -0.00949089f, -0.04264942f, 0.09471185f, 
    0.31516954f, -0.05657336f, 0.21660066f, -0.05097811f, -0.01827390f, 0.14599721f, 0.02094662f, 0.13740179f, 
    -0.04606678f, -0.06081018f, -0.06800653f, 0.05744960f, -0.24394652f, -0.03457827f, 0.03931822f, -0.05250438f, 
    0.02502298f, -0.06111306f, -0.13201360f, -0.10188621f, 0.06514654f, 0.00975475f, 0.15515414f, 0.17378028f, 
    0.27393979f, 0.26618099f, 0.08734162f, -0.14897516f, 0.22280131f, 0.17879623f, 0.22208872f, 0.05679905f, 
    0.04821773f, -0.00214642f, 0.06704655f, 0.13797992f, 0.19408523f, 0.25712132f, 0.18826748f, -0.11348310f, 
    0.04950809f, 0.26215139f, -0.07856672f, -0.01020032f, 0.00772766f, -0.02464443f, 0.17567775f, 0.06957753f, 
    -0.36040369f, -0.26437795f, -0.09284207f, 0.01939469f, 0.00552569f, -0.04172355f, 0.02448523f, 0.09917631f, 
    -0.03999939f, -0.03098108f, -0.06121678f, -0.04486132f, -0.02095636f, 0.03794362f, 0.00985427f, 0.05959138f, 
    0.00381102f, -0.00184396f, 0.00177871f, -0.06239216f, 0.19129230f, -0.02922191f, -0.13281935f, 0.01308238f, 
    -0.24978815f, -0.04773713f, -0.09389147f, 0.06825677f, -0.02640145f, -0.04243026f, 0.03869658f, -0.01420997f, 
    0.04312835f, 0.03043557f, 0.04696439f, 0.15950659f, -0.18090598f, -0.15306211f, -0.06254955f, 0.08705007f, 
    0.08731578f, 0.00633478f, 0.01709087f, 0.02569230f, -0.00074665f, -0.01775186f, 0.02941779f, 0.05902014f, 
    -0.22973169f, -0.17862143f, -0.01317623f, 0.05141192f, 0.05952226f, -0.04951896f, -0.03636874f, -0.09731153f, 
    -0.08754625f, -0.07605426f, -0.05176505f, -0.01651952f, -0.32270613f, 0.07345103f, -0.17423573f, 0.13921739f, 
    0.05856562f, -0.04709996f, 0.00921030f, 0.16781333f, 0.01496650f, 0.05032650f, 0.01260024f, -0.00598548f, 
    0.09289984f, -0.03690675f, 0.02469297f, 0.07266940f, 0.09799881f, 0.08735663f, 0.08346380f, 0.01196826f, 
    0.04770048f, 0.14859566f, -0.04468472f, 0.01213646f, 0.08954806f, 0.09810313f, -0.13690132f, -0.00389103f, 
    -0.06538341f, 0.15694453f, 0.21565023f, 0.21019429f, -0.00645731f, 0.04837573f, 0.05346521f, 0.00257692f, 
    0.34961480f, 0.11211317f, 0.05905202f, 0.01372011f, 0.08145473f, 0.00835090f, -0.03744532f, 0.01043844f, 
    -0.04932711f, 0.01919101f, -0.00157162f, 0.08449572f, -0.06850024f, -0.10020663f, -0.10427336f, -0.07195754f, 
    0.02143856f, 0.04889572f, -0.07454902f, -0.35040197f, 0.01154544f, -0.05491396f, 0.02336809f, 0.07087354f, 
    0.08448036f, 0.19198170f, -0.41527587f, 0.09430332f, -0.08653978f, 0.10808264f, -0.02694878f, 0.18829586f, 
    0.05021156f, -0.02747115f, -0.03953536f, 0.06176499f, 0.25872111f, 0.22591040f, 0.00060543f, 0.17102396f, 
    -0.02098920f, 0.01558998f, 0.05396698f, 0.07839297f, 0.02006428f, -0.02816697f, -0.08907323f, -0.09223080f, 
    0.25480783f, 0.13041332f, -0.32783806f, -0.30175635f, 0.17747162f, 0.15807830f, 0.11661546f, -0.10209512f, 
    0.01028139f, 0.02028915f, 0.13579804f, 0.01150964f, 0.19674303f, 0.04310009f, 0.05284277f, 0.23699033f, 
    0.04206832f, 0.06839285f, 0.01576168f, -0.08213899f, -0.05556732f, -0.05816177f, 0.03213643f, -0.06255113f, 
    -0.00180066f, -0.07036942f, -0.08034614f, 0.03079656f, -0.02683143f, 0.04187957f, -0.01222129f, 0.08174234f, 
    0.15504947f, -0.01282723f, 0.23735428f, 0.06378856f, -0.00301296f, -0.17362221f, -0.00336063f, 0.04206133f, 
    0.00827740f, 0.00599499f, -0.02965653f, -0.00635009f, -0.01745081f, -0.06366665f, 0.04643373f, 0.05402965f, 
    0.03976990f, 0.06915957f, 0.18222198f, 0.03286435f, 0.03669287f, -0.00699196f, 0.05962267f, 0.01190390f, 
    0.02018059f, -0.02028666f, -0.07131071f, 0.10349717f, -0.18679366f, -0.06331722f, 0.00740943f, 0.03683751f, 
    0.02009208f, -0.02489762f, 0.10942915f, -0.07888734f, -0.01868468f, 0.03855511f, 0.06351833f, 0.13443767f, 
    0.00764542f, 0.07341484f, 0.08515378f, 0.13710104f, 0.02278762f, 0.07702004f, 0.17473802f, 0.05360161f, 
    0.04278927f, -0.06593704f, 0.05309585f, -0.00169643f, 0.03982899f, 0.02853722f, 0.05274722f, 0.02223362f, 
    0.01677446f, -0.02205970f, -0.01821638f, -0.09820104f, 0.06772889f, -0.10414916f, 0.04408276f, 0.14448410f, 
    0.18533474f, -0.14823519f, -0.10258842f, -0.12666896f, -0.13020271f, -0.14302580f, -0.16320702f, 0.28239140f, 
    0.05754733f, -0.02224021f, 0.00033232f, -0.01138842f, -0.12065743f, 0.10098312f, 0.01269418f, -0.13170709f, 
    0.15286802f, 0.12726030f, -0.13769388f, 0.17070933f, 0.03123361f, 0.07749279f, 0.06195440f, -0.03665961f, 
    -0.12225839f, -0.10733715f, 0.00857094f, -0.07093553f, -0.00326581f, -0.04179835f, -0.03087995f, -0.05560475f, 
    -0.05858368f, -0.04187777f, -0.06988990f, 0.08441833f, 0.21249141f, 0.04810690f, -0.39646572f, -0.05780125f, 
    0.07751780f, 0.06815799f, 0.29891300f, 0.06131087f, 0.03996449f, 0.03563315f, 0.16212438f, 0.07210623f, 
    0.20716527f, 0.07303268f, -0.16310959f, -0.21476763f, 0.16306761f, -0.01863579f, 0.05046782f, 0.25449139f, 
    -0.04881361f, 0.01323045f, 0.01899207f, 0.10030448f, 0.32087308f, 0.26731363f, 0.02047513f, -0.18646392f, 
    0.08686522f, 0.21009400f, 0.20944533f, -0.04085841f, 0.07624887f, 0.10727677f, 0.02693802f, -0.00666023f, 
    0.00926314f, 0.15038815f, 0.06641170f, 0.28325114f, 0.08859405f, 0.13723963f, 0.08946932f, -0.12614664f, 
    0.06500027f, 0.04491236f, -0.05043456f, 0.15605308f, -0.14791659f, 0.05854147f, -0.21851982f, -0.07283644f, 
    0.12668101f, -0.00601230f, 0.00441033f, -0.05860390f, 0.00626886f, 0.03653935f, 0.04772630f, 0.14567426f, 
    -0.18803354f, -0.16053821f, 0.16865979f, -0.09764746f, -0.05209643f, 0.01356490f, 0.07411875f, 0.00412511f, 
    -0.07159679f, 0.00287909f, -0.01367289f, 0.14336653f, -0.13253951f, 0.03900931f, -0.00132734f, -0.10408904f, 
    0.13672808f, -0.01998500f, 0.00856782f, 0.22250521f, 0.19218937f, 0.03080774f, 0.09965450f, 0.03764013f, 
    0.15030876f, 0.10864305f, 0.19355150f, -0.09779007f, 0.03812070f, 0.04773019f, -0.00176577f, 0.25672212f, 
    -0.02339480f, 0.08787772f, -0.09463919f, -0.00973954f, 0.07776902f, -0.19501895f, 0.12894212f, 0.03666733f, 
    -0.10569194f, 0.03585419f, 0.00353610f, 0.12268885f, 0.06528837f, -0.07380810f, 0.14606419f, -0.06152315f, 
    0.24381709f, 0.18613502f, 0.12562439f, -0.01291171f, -0.00822705f, 0.07044224f, -0.02082466f, -0.05568704f, 
    -0.00710612f, -0.01098506f, -0.06005017f, -0.03195422f, 0.16177022f, 0.19566047f, 0.03396893f, 0.02123392f, 
    0.05379547f, 0.07548428f, -0.03649050f, -0.04578083f, -0.01013546f, -0.16095361f, -0.01644238f, -0.02398100f, 
    0.17921527f, 0.11587449f, 0.06380592f, -0.22020943f, -0.13405399f, -0.02941617f, 0.04538861f, 0.01421165f, 
    0.04708825f, -0.08112793f, -0.02780770f, -0.09229489f, -0.02779272f, 0.00559351f, -0.04788215f, -0.02549399f, 
    0.04516757f, 0.12583801f, -0.13678209f, -0.05123890f, 0.05983427f, 0.04970194f, 0.33317593f, 0.29647231f, 
    -0.05444642f, 0.39067420f, 0.23723537f, -0.08818576f, -0.00285184f, -0.12067927f, 0.04745483f, 0.15338059f, 
    0.02711284f, -0.14628139f, -0.13687626f, -0.08676463f, 0.21455008f, 0.33469379f, 0.00705983f, -0.15424670f, 
    0.03748990f, -0.01313685f, 0.04422225f, -0.14299625f, -0.02139542f, -0.03695978f, 0.08211876f, 0.15051830f, 
    -0.11085716f, -0.03336481f, 0.07045051f, 0.04774413f, 0.11323342f, -0.02904683f, -0.04830271f, -0.05505613f, 
    -0.02979327f, -0.08663005f, -0.02082748f, -0.02989252f, 0.02085638f, -0.14295740f, -0.03524695f, -0.02279941f, 
    -0.04574684f, 0.02963291f, 0.02480356f, 0.06620351f, 0.00704533f, 0.00703248f, 0.02481179f, 0.06696784f, 
    0.03639297f, -0.03127497f, 0.03302246f, 0.08070239f, 0.00470545f, 0.00075773f, 0.00068523f, 0.04632820f, 
    0.00687384f, 0.00473157f, 0.15141870f, -0.01803022f, -0.40089601f, 0.11286558f, -0.12484550f, -0.04092894f, 
    -0.03421037f, -0.02835450f, -0.03263547f, -0.13954845f, -0.10115161f, -0.01106850f, -0.02510051f, 0.07653113f, 
    0.31768394f, 0.04809630f, -0.14575572f, 0.06894144f, 0.04953055f, 0.09093837f, -0.07136888f, 0.08935826f, 
    -0.09989775f, -0.00456690f, -0.00918393f, -0.08075885f, -0.19847502f, -0.06434546f, 0.02685276f, 0.01992434f, 
    0.00949762f, -0.03122541f, 0.07180414f, -0.03263123f, -0.02953838f, 0.02927969f, -0.01474477f, 0.09355529f, 
    -0.46201545f, 0.10260884f, -0.06755123f, 0.09323642f, 0.05652754f, 0.01781187f, -0.06620236f, 0.08661270f, 
    0.01350683f, 0.01716014f, 0.05292145f, -0.05588679f, -0.00122969f, 0.14464000f, -0.02858029f, -0.00805557f, 
    0.21043418f, -0.08779957f, -0.15489559f, -0.01077839f, 0.07587760f, 0.02622958f, 0.16282730f, -0.02885159f, 
    -0.17737554f, -0.21109979f, 0.02158043f, -0.11173228f, 0.03183948f, 0.07110080f, -0.00655737f, 0.06020384f, 
    -0.11060759f, 0.01485967f, -0.03810253f, 0.02072966f, 0.23762245f, 0.05853683f, 0.01307812f, 0.00562069f, 
    -0.00312111f, -0.11682183f, 0.15930720f, 0.05579839f, -0.02513441f, 0.04244585f, 0.00141836f, 0.04260995f, 
    -0.05167104f, -0.14171974f, -0.05120517f, 0.02587285f, 0.02458403f, -0.02985192f, -0.10059168f, -0.04644698f, 
    0.03596558f, 0.01791131f, 0.03054423f, 0.04192770f, -0.19089538f, -0.14610717f, -0.06805874f, -0.15357569f, 
    0.20563334f, -0.10110600f, -0.04647684f, 0.04221389f, -0.05203098f, 0.11752661f, -0.01067795f, 0.21567415f, 
    0.23085590f, -0.12806526f, 0.22754219f, -0.14383700f, -0.12359842f, 0.00759991f, -0.01905529f, 0.00044018f, 
    -0.02849568f, -0.12182564f, 0.04887274f, 0.07776735f, -0.21961962f, 0.16219145f, 0.25787333f, -0.04571727f, 
    -0.00989269f, -0.02548728f, -0.06533964f, -0.06032323f, 0.15226872f, -0.03049096f, 0.09255789f, 0.01230667f, 
    0.18779762f, 0.31198412f, 0.11251219f, -0.10349627f, 0.03381245f, -0.11999346f, -0.08128317f, 0.03136340f, 
    0.04187674f, -0.00089586f, 0.14002667f, -0.04914727f, -0.18009925f, -0.06185594f, -0.01477826f, -0.05621922f, 
    -0.02831927f, -0.08535443f, -0.03887878f, -0.06728662f, 0.06867830f, 0.11465026f, 0.03028002f, 0.16582802f, 
    -0.02034038f, 0.02198109f, 0.02233467f, -0.01744560f, 0.00207784f, -0.02623377f, 0.00048612f, -0.03265067f, 
    -0.02740323f, -0.01799253f, 0.01390797f, 0.02587407f, 0.01424677f, -0.01796569f, 0.02969286f, 0.00541388f, 
    0.00299085f, -0.00641682f, 0.02475197f, 0.01142807f, -0.01607784f, -0.00946680f, 0.01276532f, 0.02820730f, 
    0.02922859f, -0.03673829f, 0.03286064f, -0.00183090f, -0.00833500f, -0.01685618f, -0.03915966f, -0.00437090f, 
    0.00172973f, -0.02769540f, -0.03712844f, 0.02075926f, 0.02305542f, -0.02401542f, -0.04095543f, 0.02820955f, 
    -0.03991307f, -0.02428541f, -0.04004717f, -0.01610395f, -0.03312067f, 0.00176286f, -0.02230564f, -0.00074848f, 
    -0.02229662f, 0.01118216f, -0.03945056f, -0.01995756f, -0.02238257f, 0.02889679f, 0.00545301f, 0.01262010f, 
    -0.02849497f, -0.03197976f, 0.02287663f, 0.03201978f, -0.00208409f, -0.00692008f, 0.02803564f, -0.00746050f, 
    -0.03686420f, 0.02768818f, -0.02663203f, -0.02458633f, -0.02488883f, -0.01616204f, -0.02138798f, 0.00793546f, 
    0.02513581f, 0.02390412f, -0.03106587f, 0.01167000f, -0.01123226f, -0.03577522f, -0.03694094f, -0.01084599f, 
    0.02100154f, -0.00664481f, -0.00236697f, 0.02398059f, 0.03537839f, -0.02163584f, 0.00076206f, -0.00317721f, 
    0.01784595f, 0.02853956f, -0.02207079f, -0.00720883f, 0.00240950f, 0.02931388f, -0.03072929f, -0.01034951f, 
    -0.02996246f, -0.01720246f, -0.01816273f, -0.03377355f, 0.02592428f, -0.02060398f, 0.02881923f, -0.01355564f, 
    -0.00846866f, 0.02612748f, 0.02784760f, -0.04130011f, -0.01636663f, -0.00584265f, 0.00850426f, -0.01365505f, 
    -0.00226620f, 0.02557545f, -0.00010746f, 0.02048606f, -0.03585263f, -0.01845792f, 0.00395717f, -0.02728032f, 
    -0.01073509f, -0.03025910f, 0.04037822f, -0.02766873f, 0.02999394f, -0.04176462f, -0.03351247f, -0.00055237f, 
    -0.03001717f, 0.02231463f, -0.01934527f, 0.00616564f, -0.00276334f, -0.02047704f, -0.00333115f, -0.00070248f, 
    0.02133121f, 0.00429080f, 0.02680846f, -0.00028053f, 0.00839370f, -0.02783774f, 0.00884560f, 0.01315186f, 
    0.03113526f, 0.00091600f, 0.03694556f, 0.00489685f, -0.03788708f, -0.01324759f, 0.02921850f, -0.03095461f, 
    -0.02973136f, 0.01034898f, -0.01851646f, -0.00759202f, -0.02650926f, -0.04049494f, 0.02947161f, 0.01619469f, 
    -0.02396547f, -0.00179805f, -0.03000559f, -0.01907196f, -0.01979121f, -0.03199270f, 0.01825614f, 0.01672325f, 
    0.00036000f, 0.00216789f, 0.00249697f, -0.01589639f, -0.01225952f, 0.01370409f, -0.00051713f, 0.01325184f, 
    -0.00737287f, -0.01668850f, -0.03461055f, 0.02008855f, -0.01685775f, -0.02376151f, -0.03828495f, -0.01667988f, 
    0.01130161f, 0.00185900f, -0.02442624f, 0.01253405f, -0.02856388f, -0.01947786f, 0.01461273f, 0.02130010f, 
    -0.02760491f, 0.03847242f, -0.00171337f, 0.02679400f, 0.02069958f, -0.00668981f, -0.02873957f, 0.02227726f, 
    0.01266136f, 0.01825497f, 0.02928478f, -0.03076990f, 0.00897650f, 0.01600445f, 0.02263810f, 0.00439572f, 
    0.02704107f, -0.00405291f, -0.01052876f, -0.00285500f, 0.01869003f, -0.01086533f, -0.03640972f, 0.02099326f, 
    0.02770635f, -0.01863536f, 0.00578465f, -0.03392620f, -0.00895337f, -0.01497180f, -0.04008853f, -0.03944209f, 
    -0.04198131f, 0.02626481f, 0.02939837f, -0.02367939f, -0.00702455f, 0.00448744f, -0.03885100f, 0.01068048f, 
    -0.02935150f, -0.03965295f, -0.02516559f, -0.02263728f, -0.01271609f, 0.01791051f, -0.01162382f, 0.01671862f, 
    0.02617270f, 0.00799737f, 0.00491774f, 0.00029132f, 0.02347114f, -0.00367734f, -0.01981278f, 0.02817736f, 
    -0.03490102f, 0.01163826f, -0.01832293f, -0.01173731f, -0.01942694f, 0.00342192f, -0.03264171f, 0.02194258f, 
    0.01296996f, 0.02058336f, 0.02046403f, -0.01796503f, 0.01494108f, -0.02584116f, -0.01460961f, -0.00809565f, 
    -0.03796920f, -0.04113246f, -0.00354145f, 0.01208019f, 0.01441292f, -0.04052163f, 0.02470990f, 0.02865843f, 
    0.01165957f, 0.01303879f, 0.01592965f, 0.02671180f, 0.02988969f, 0.00447146f, -0.02729966f, -0.03340681f, 
    0.01488761f, -0.00278202f, -0.00896934f, 0.00963564f, 0.01160170f, 0.01589021f, -0.02727794f, -0.00536553f, 
    -0.02096104f, -0.01069222f, -0.01449503f, -0.00209296f, 0.00573107f, -0.01695103f, -0.02976197f, -0.02209103f, 
    -0.03484435f, -0.00143175f, -0.03061815f, -0.02187995f, 0.00649619f, 0.00780464f, -0.02090875f, 0.01575856f, 
    0.01145761f, -0.04154886f, 0.00996250f, -0.00500823f, -0.02189824f, 0.02746607f, -0.01559515f, -0.03238519f, 
    0.02106274f, 0.01056667f, -0.00989336f, -0.01628652f, -0.03484727f, -0.01351505f, 0.01532022f, -0.01026850f, 
    -0.02302890f, 0.00528071f, -0.03342232f, 0.02631638f, 0.02338503f, 0.00539217f, 0.02053418f, -0.02205309f, 
    0.01949766f, -0.04169912f, 0.00260027f, -0.02377309f, 0.00896672f, 0.01874091f, 0.02375834f, 0.02109433f, 
    -0.01995564f, -0.01771862f, -0.00202162f, -0.03882325f, -0.01963210f, -0.01753045f, 0.02908084f, -0.02665723f, 
    -0.00244467f, 0.00414727f, -0.00803227f, -0.01280471f, 0.01276953f, -0.01867778f, 0.01029059f, 0.00768702f, 
    0.03063393f, -0.03087496f, -0.03987031f, 0.01089994f, 0.02653397f, -0.01221237f, 0.01746199f, 0.02808908f, 
    -0.04156773f, -0.03928138f, 0.03662428f, 0.00568197f, -0.01581229f, -0.01954549f, -0.03704736f, 0.00367535f, 
    0.01130273f, 0.01761927f, 0.01394210f, -0.00575953f, -0.02961949f, -0.04090526f, 0.00662209f, -0.02951046f, 
    0.02089935f, -0.03052430f, -0.03323366f, 0.00393466f, 0.02577633f, -0.00719532f, 0.01258137f, -0.03123363f, 
    0.00954503f, -0.00669148f, -0.00501909f, 0.01798046f, 0.02622775f, -0.03008173f, 0.00701965f, 0.01467652f, 
    0.02197181f, 0.02259472f, 0.01233724f, -0.01900043f, -0.02891000f, -0.01686211f, 0.02082676f, -0.02525549f, 
    0.02214793f, 0.02084945f, -0.02414136f, 0.00907885f, -0.00222666f, 0.00246155f, 0.01381559f, 0.02017988f, 
    0.01175273f, 0.00642784f, -0.01770383f, 0.02556082f, -0.02490929f, -0.03175145f, 0.02478123f, 0.02813015f, 
    0.00554910f, -0.00208879f, 0.00245218f, 0.02120818f, 0.00753971f, 0.01992267f, 0.01995249f, 0.01229887f, 
    -0.03603296f, -0.01839221f, -0.01251561f, -0.00767230f, -0.03504073f, -0.00824277f, 0.00299631f, 0.02003415f, 
    0.02610140f, -0.02999246f, 0.00772684f, -0.03883127f, -0.02071972f, 0.02963598f, -0.02685700f, -0.01023743f, 
    0.00889992f, -0.02869661f, -0.01926691f, 0.01702407f, -0.00618633f, -0.00477544f, 0.03405359f, -0.00542837f, 
    0.02415989f, -0.02270421f, -0.00317487f, 0.00203089f, -0.01680738f, -0.01591382f, 0.02683919f, -0.01415963f, 
    -0.01466860f, -0.03425515f, -0.01045354f, 0.02368340f, 0.01634226f, 0.00308444f, -0.01988980f, 0.01427766f, 
    0.01149760f, 0.01376108f, 0.02668422f, -0.00024064f, 0.03236420f, 0.02895514f, -0.02760506f, -0.00274168f, 
    0.03144457f, -0.02319716f, -0.00459511f, 0.00643200f, 0.01337006f, -0.00737461f, -0.03561342f, -0.02155538f, 
    -0.00090888f, 0.01366972f, -0.02048616f, -0.01408712f, -0.02167984f, -0.01458098f, -0.02724249f, -0.03997831f, 
    0.02215920f, -0.02677536f, 0.01631388f, -0.03892963f, 0.01162731f, -0.02439461f, 0.00211627f, 0.00067409f, 
    -0.04084447f, -0.03519385f, -0.02387329f, 0.01404265f, -0.01524946f, -0.01773261f, 0.00095610f, 0.01245488f, 
    -0.01343536f, -0.03569644f, -0.01931984f, -0.00284507f, 0.00513157f, -0.01130797f, 0.01054737f, -0.02008321f, 
    0.01758819f, -0.00520634f, -0.00449355f, -0.01144074f, 0.00144140f, -0.01075546f, 0.00340119f, -0.00292139f, 
    -0.01710288f, -0.01998342f, -0.03209711f, 0.00789029f, -0.02747088f, 0.01685332f, 0.00224256f, -0.01849160f, 
    -0.01163695f, -0.00641780f, -0.00477572f, -0.00587879f, -0.02153917f, -0.03765601f, -0.04049589f, 0.02621804f, 
    -0.02969829f, -0.00779679f, 0.02752817f, -0.03277754f, -0.01159897f, 0.02188373f, -0.04041728f, -0.04037651f, 
    -0.00034971f, -0.03170196f, 0.01435088f, -0.02986898f, 0.02842081f, 0.01851453f, 0.02984644f, -0.03772893f, 
    -0.03225553f, 0.00043048f, -0.02321902f, 0.02089006f, -0.02959780f, -0.00529475f, 0.00401644f, -0.02648107f, 
    0.00836413f, -0.01905139f, 0.02650841f, 0.00734719f, -0.00702730f, 0.01202426f, -0.03885308f, 0.02125334f, 
    -0.01259613f, -0.03501831f, -0.00072022f, -0.03303705f, -0.01881635f, 0.00622179f, 0.02925696f, 0.00660258f, 
    0.02774796f, 0.00362821f, -0.03941326f, -0.00506815f, -0.03567429f, -0.03460587f, -0.00337491f, -0.00610561f, 
    0.01210921f, 0.01682248f, 0.01098234f, -0.03573009f, 0.02454524f, -0.01661318f, -0.03831308f, 0.02256387f, 
    0.00496389f, -0.04093773f, 0.00919654f, 0.01604117f, -0.00684177f, -0.03211601f, 0.00520888f, -0.00875124f, 
    0.00780462f, -0.02273344f, 0.02072762f, 0.02860506f, -0.04002122f, 0.02870511f, -0.03319339f, 0.01862643f, 
    -0.00631143f, -0.01977884f, -0.00286623f, 0.00753560f, -0.02062078f, 0.01564665f, -0.02728316f, 0.02583879f, 
    -0.01631453f, -0.04149248f, 0.01726112f, -0.01367801f, -0.01590744f, -0.01031544f, -0.02408805f, 0.01991091f, 
    0.01155520f, -0.00639275f, 0.00293754f, 0.00945258f, 0.02536353f, 0.02239461f, -0.01216385f, -0.02493518f, 
    0.01241685f, 0.01980205f, -0.03453079f, -0.01215348f, -0.02445309f, 0.00537015f, 0.01088407f, -0.02333091f, 
    -0.02299801f, 0.01050125f, 0.02490142f, -0.03697210f, -0.00185278f, 0.01589829f, -0.01019182f, 0.00047488f, 
    -0.02654511f, 0.00687653f, -0.02434047f, -0.01119303f, 0.02714120f, 0.01138311f, -0.03644632f, 0.00445888f, 
    0.00971148f, -0.02976063f, -0.03731335f, 0.01349922f, -0.00702751f, -0.00198752f, -0.02535151f, 0.01538862f, 
    -0.03542729f, 0.01975453f, 0.02654808f, -0.01254881f, -0.00508228f, -0.04178445f, -0.01956000f, 0.01038670f, 
    0.00900690f, 0.00574711f, -0.01645336f, 0.01236214f, 0.01506777f, -0.03994879f, 0.02719403f, -0.00724178f, 
    0.01760419f, 0.00284683f, -0.02696085f, -0.00102508f, 0.02798211f, -0.01769361f, -0.01529607f, 0.01370357f, 
    -0.01747670f, -0.00074605f, -0.03596748f, 0.01367253f, -0.02366238f, -0.03172564f, -0.00588443f, 0.00311044f, 
    0.00494018f, -0.02017333f, 0.00126494f, -0.00512137f, -0.01108067f, -0.04075865f, -0.02190529f, 0.01164271f, 
    -0.02962057f, 0.02971538f, 0.02671848f, 0.02134623f, 0.03254811f, 0.01334888f, -0.02986240f, 0.00051769f, 
    -0.01970613f, -0.02650124f, -0.00566731f, 0.00229453f, 0.00085660f, 0.01359046f, -0.00357398f, 0.02861885f, 
    0.02979113f, 0.02793010f, -0.01129111f, -0.00760751f, -0.01453197f, 0.03613776f, -0.04116452f, 0.01491920f, 
    -0.02697578f, -0.02381650f, 0.02391236f, 0.00785548f, 0.03231000f, -0.01179267f, -0.00832465f, -0.02750870f, 
    0.02323101f, 0.01258929f, 0.00793869f, -0.00233253f, -0.03801829f, -0.02815408f, -0.00638213f, -0.02689178f, 
    0.01575602f, -0.00893636f, -0.02033920f, -0.03047045f, -0.02343244f, 0.01103675f, 0.03084726f, -0.03801874f, 
    -0.03199990f, -0.03557693f, 0.03759149f, 0.01122165f, -0.01543719f, 0.02154979f, 0.03973196f, 0.01152401f, 
    0.04026565f, 0.01365025f, -0.02886849f, -0.02364111f, 0.00683494f, -0.01945231f, -0.03543574f, -0.02546096f, 
    -0.03733992f, -0.02543924f, 0.02823992f, -0.01278319f, -0.02453114f, 0.00101734f, 0.00787439f, 0.02119499f, 
    -0.02037661f, 0.00761718f, -0.02385419f, -0.00042271f, 0.00502616f, 0.01932873f, 0.02320975f, -0.02006873f, 
    0.01670462f, 0.02389726f, -0.03387213f, 0.02650467f, -0.00584426f, -0.00322490f, -0.02682430f, 0.01358846f, 
    -0.00782552f, -0.00263540f, -0.00105922f, 0.01642587f, -0.01701563f, 0.00437314f, -0.01813416f, 0.00876107f, 
    -0.02529526f, 0.00808525f, -0.01576024f, -0.03525295f, -0.01811954f, 0.01398445f, -0.03528579f, -0.01444472f, 
    -0.01425978f, -0.01441814f, 0.00203343f, -0.00282130f, -0.02951852f, -0.03262516f, -0.00985004f, -0.02360969f, 
    -0.02276244f, 0.00403946f, -0.01599556f, -0.02269119f, 0.02558060f, 0.02678888f, 0.02617858f, -0.00066129f, 
    0.02772528f, 0.00048266f, 0.00798364f, 0.02248079f, -0.01771835f, -0.02235351f, -0.01386219f, -0.01506083f, 
    0.00737780f, 0.00436398f, 0.01386293f, -0.04091893f, -0.01931008f, 0.02342250f, -0.03903018f, -0.00797979f, 
    -0.02341607f, -0.00341518f, -0.03265645f, 0.01201834f, -0.01431967f, -0.00612046f, 0.00689571f, -0.01181590f, 
    -0.00674400f, -0.00594144f, 0.00772514f, 0.02820701f, 0.00749102f, -0.00842489f, -0.01465117f, 0.02912413f, 
    -0.00930680f, -0.01997115f, -0.03537845f, -0.02666696f, -0.02947272f, 0.00642412f, -0.02990424f, 0.02909348f, 
    -0.03016527f, -0.01203381f, 0.02511461f, -0.04050489f, -0.00654249f, 0.02515009f, -0.02225101f, 0.02243979f, 
    -0.01318237f, -0.03324630f, 0.01592739f, 0.01593776f, -0.03923990f, -0.01689024f, 0.01956490f, 0.00536507f, 
    -0.03228276f, 0.01612907f, -0.01786707f, 0.03483978f, -0.00513467f, -0.02559976f, -0.00766494f, 0.02518483f, 
    -0.01813160f, 0.02303336f, -0.00975086f, 0.00044896f, 0.02801088f, -0.03249991f, -0.00163432f, 0.01983517f, 
    -0.02942339f, 0.02128370f, -0.03540552f, -0.02419645f, 0.00324421f, -0.04180678f, 0.01021783f, -0.00030679f, 
    -0.00537756f, -0.00509178f, 0.00008838f, 0.01182541f, 0.00829209f, -0.02646166f, 0.01654255f, -0.02016213f, 
    0.02348405f, -0.00541794f, -0.01999923f, -0.04085267f, -0.02258937f, -0.00588540f, 0.02837243f, -0.00649260f, 
    0.01200299f, 0.00473964f, -0.02477665f, -0.00711520f, -0.01440630f, -0.02438953f, 0.01106785f, -0.01493155f, 
    -0.02870893f, 0.03369671f, -0.00183697f, -0.02729167f, 0.00420049f, -0.02492885f, 0.02486762f, -0.00008665f, 
    -0.00349741f, -0.01623115f, 0.00946164f, -0.00242355f, 0.00123014f, 0.02032818f, 0.02902952f, 0.00879948f, 
    -0.03118208f, -0.03258115f, 0.00077449f, -0.04088254f, 0.02500197f, -0.02062746f, -0.00237023f, -0.03530340f, 
    -0.02246274f, -0.02917300f, 0.00036901f, -0.01569658f, -0.03836071f, 0.00124529f, -0.01292973f, 0.02667342f, 
    0.02430013f, -0.01581098f, 0.03508252f, -0.02764842f, -0.00408475f, -0.00732063f, -0.01846735f, -0.03224577f, 
    0.02714557f, 0.00950500f, 0.02610670f, -0.02546874f, 0.02625694f, 0.02631432f, -0.00328719f, 0.01637886f, 
    -0.04199919f, -0.01497529f, 0.01184394f, -0.00720321f, -0.03873501f, -0.01402760f, 0.00165988f, 0.01517461f, 
    -0.02492735f, 0.01996257f, -0.03235486f, -0.01671113f, -0.00912679f, -0.03072984f, -0.04018468f, -0.03781383f, 
    0.02403413f, 0.01335000f, 0.00684198f, -0.01653883f, -0.03399818f, 0.00367080f, -0.00594317f, 0.01929833f, 
    -0.00491192f, -0.00881245f, 0.02163954f, 0.03288963f, 0.01467880f, -0.01441517f, -0.03636476f, -0.02888814f, 
    -0.02932131f, -0.01745860f, -0.02171626f, -0.01953094f, -0.02614263f, -0.01055478f, -0.00976224f, 0.01080569f, 
    -0.00062665f, 0.03282878f, -0.00190740f, -0.03739988f, -0.02086187f, 0.02212237f, 0.03674515f, 0.01494822f, 
    0.01138347f, 0.00495779f, -0.04166755f, 0.00781495f, 0.00196977f, -0.00217273f, -0.01487497f, 0.00195047f, 
    0.01611738f, 0.01649152f, -0.02765178f, 0.00505256f, -0.02250360f, -0.01179948f, 0.00667058f, -0.01341297f, 
    -0.00427215f, 0.01060749f, 0.01764905f, 0.02166668f, -0.04397281f, 0.02194339f, -0.03843378f, -0.03358231f, 
    0.01771472f, -0.03165811f, -0.03573981f, -0.00569951f, 0.01140990f, -0.03601813f, -0.03656822f, -0.01842291f, 
    0.01986116f, 0.02021027f, -0.01558910f, 0.00650404f, -0.04424364f, -0.03415095f, -0.03924118f, -0.01273998f, 
    0.00264962f, -0.02575241f, -0.01076854f, -0.02443584f, -0.03672430f, 0.01082712f, -0.00545386f, 0.00979442f, 
    -0.03171168f, -0.01951739f, -0.00218837f, -0.01163260f, 0.00115148f, 0.00360920f, -0.04087483f, -0.00747491f, 
    -0.01502315f, -0.01492793f, -0.00763322f, -0.02927303f, 0.01624990f, -0.03156645f, -0.01511811f, -0.00733539f, 
    -0.04056451f, 0.02924278f, 0.01544413f, -0.00113301f, -0.03368264f, -0.02336391f, -0.01018645f, -0.02855079f, 
    0.01158089f, 0.01193101f, -0.03919358f, -0.01810178f, 0.01661079f, -0.02281910f, 0.00530273f, 0.00530113f, 
    -0.03253413f, 0.01644203f, 0.02195416f, -0.02667282f, 0.00408544f, -0.01510247f, -0.03768036f, -0.01647879f, 
    0.00661997f, 0.00390630f, 0.01056227f, -0.02170768f, 0.00732253f, -0.01359947f, 0.02578016f, -0.03832056f, 
    -0.03225379f, 0.00069398f, 0.00232256f, -0.00953280f, 0.01318401f, -0.01585478f, 0.01520166f, -0.02541480f, 
    0.03036442f, -0.00184041f, 0.01767650f, -0.00200604f, -0.02882680f, -0.02173286f, 0.02678161f, 0.00205536f, 
    -0.01652449f, -0.01715119f, 0.01643840f, 0.02368289f, -0.00983693f, -0.02294238f, -0.02422279f, 0.00806593f, 
    -0.03788659f, -0.02326826f, -0.03761675f, -0.00949535f, -0.03057017f, -0.04206943f, 0.01350468f, 0.01553761f, 
    0.02826263f, 0.00539387f, 0.02394133f, -0.01684282f, 0.01091743f, 0.01741063f, 0.01991744f, -0.01089971f, 
    -0.02808408f, -0.01787253f, -0.01003669f, -0.02440524f, -0.02861666f, -0.01332803f, -0.02676243f, 0.00298791f, 
    -0.01305570f, -0.01559306f, -0.01621696f, 0.02013535f, -0.01188908f, -0.02336225f, -0.00205569f, 0.00636928f, 
    0.00977237f, 0.02744945f, -0.02282337f, -0.00823565f, 0.02506183f, -0.02230215f, -0.03010995f, -0.00464424f, 
    0.00443948f, -0.01714910f, 0.02087387f, -0.01496334f, 0.02156370f, -0.02828457f, -0.03063952f, 0.02527772f, 
    0.00300225f, -0.00194063f, -0.00573363f, -0.03316789f, 0.00693361f, -0.03423129f, 0.01036816f, 0.01081772f, 
    -0.00512096f, 0.02760151f, 0.03230812f, -0.01333397f, -0.01586134f, -0.00539841f, -0.00979209f, 0.00597208f, 
    0.01694215f, 0.00788563f, -0.03059822f, -0.01571026f, -0.00305250f, 0.01059492f, 0.02351712f, 0.02341893f, 
    0.00986182f, -0.01995867f, 0.03398646f, -0.03085084f, -0.02657019f, 0.02484533f, -0.03987378f, -0.02713388f, 
    0.01837970f, 0.01184533f, -0.03266114f, 0.00796194f, -0.00884380f, 0.00529212f, 0.01369751f, 0.01673817f, 
    0.02462089f, -0.03112889f, -0.04214728f, 0.01808597f, 0.00065045f, 0.00859502f, -0.01323658f, -0.03659900f, 
    0.02220915f, 0.02718212f, 0.02227104f, -0.00304375f, 0.01867084f, 0.01784015f, 0.02455532f, -0.03873387f, 
    -0.01726731f, 0.00250914f, -0.00465236f, -0.03901952f, 0.01570901f, 0.00046922f, -0.00494521f, -0.03058194f, 
    -0.03602891f, -0.00455545f, -0.02484697f, -0.01734949f, -0.04201057f, -0.02547448f, -0.03971539f, -0.02219609f, 
    0.00385333f, 0.02728478f, 0.00142163f, 0.01603893f, -0.03045581f, -0.02387038f, 0.01687921f, -0.00938525f, 
    -0.02067409f, -0.02170925f, 0.01713555f, 0.02867968f, -0.03299959f, 0.02702683f, -0.02195062f, -0.02195737f, 
    -0.00792188f, 0.00576077f, -0.00530191f, 0.01457946f, 0.01308634f, 0.02856338f, 0.03745961f, 0.02810202f, 
    -0.02472311f, 0.01905145f, -0.00206731f, 0.02209450f, -0.00563923f, 0.02346356f, -0.01822668f, -0.03392225f, 
    -0.03868571f, -0.02744938f, 0.00796860f, -0.03098598f, 0.02707683f, -0.03163391f, -0.00657694f, 0.01121905f, 
    -0.02547323f, -0.04266183f, -0.03237437f, 0.01092216f, 0.01054814f, -0.01973393f, -0.02026369f, -0.02054440f, 
    0.00206629f, -0.00306666f, -0.01367525f, -0.03693519f, -0.03855928f, 0.01146090f, -0.01074992f, -0.02143451f, 
    0.02364449f, -0.00551159f, -0.01483469f, 0.03163051f, -0.00804312f, -0.00336790f, 0.01725838f, 0.00605805f, 
    0.02948820f, 0.02669642f, -0.00822561f, 0.02504541f, 0.00479038f, 0.01938063f, -0.03023591f, -0.03804556f, 
    -0.01177303f, -0.00045071f, -0.03156482f, -0.02127614f, -0.02288802f, 0.00115333f, 0.01656510f, -0.01258406f, 
    -0.03272676f, -0.00658142f, 0.00141360f, -0.03376654f, 0.01603382f, 0.01906548f, -0.00379807f, 0.00268239f, 
    -0.02816845f, -0.02114709f, -0.03176270f, 0.02411665f, -0.02762917f, -0.03547780f, 0.00377587f, 0.00789904f, 
    -0.00816635f, -0.00317021f, -0.02622421f, 0.01022499f, -0.00731973f, 0.02181736f, -0.00031312f, -0.00702293f, 
    -0.00423332f, -0.02169006f, -0.00929903f, 0.01868368f, 0.00315711f, 0.00231779f, -0.01566658f, 0.02508716f, 
    0.01924880f, 0.00744950f, 0.02565332f, -0.03365228f, -0.03910594f, -0.01315102f, -0.03372362f, -0.02400609f, 
    0.02619651f, -0.03202220f, -0.01650486f, 0.01898484f, -0.02504714f, 0.02591479f, -0.02097421f, -0.01896111f, 
    0.00813285f, -0.00327306f, -0.01140606f, 0.01531329f, 0.00657484f, -0.02902181f, -0.03503047f, -0.02512819f, 
    0.01431619f, -0.00172480f, -0.00754736f, -0.01018333f, 0.02267143f, 0.02542369f, -0.00891008f, -0.04062356f, 
    -0.01773868f, 0.01277433f, -0.02780887f, -0.03050057f, -0.02987148f, 0.02553998f, -0.00020595f, 0.01477046f, 
    0.01795555f, -0.00588462f, -0.00228085f, -0.02645196f, -0.00339774f, 0.02000200f, -0.00224738f, 0.02438190f, 
    0.01062529f, 0.00782763f, 0.02736969f, 0.00377234f, -0.02102477f, -0.03094129f, -0.03963781f, 0.02373170f, 
    0.01251318f, -0.03447477f, -0.01964425f, -0.04298991f, -0.01847605f, 0.03160276f, -0.00771175f, 0.01076530f, 
    -0.03875092f, -0.00506736f, -0.03189854f, -0.02283605f, 0.00962963f, 0.00045480f, -0.00902169f, 0.00007320f, 
    0.02461323f, 0.02763856f, -0.01207898f, 0.03112992f, 0.00602911f, 0.02100804f, -0.00002648f, 0.00368692f, 
    0.01456469f, 0.01257682f, -0.00592552f, -0.01009227f, 0.00367968f, 0.01768971f, -0.02846457f, -0.03505646f, 
    0.00067847f, -0.01556728f, -0.02456414f, 0.00040619f, -0.03406740f, 0.01903919f, -0.02273553f, 0.00011391f, 
    0.01792309f, 0.02753928f, 0.02893713f, -0.03129600f, 0.02021809f, -0.03354951f, -0.00832392f, -0.02948895f, 
    0.00769942f, 0.00481500f, 0.02239176f, -0.03679023f, -0.03416289f, 0.00342495f, -0.01156556f, -0.01243991f, 
    -0.02138315f, 0.00794712f, -0.02397739f, -0.01929678f, 0.00530077f, -0.01029809f, -0.01927422f, 0.00276177f, 
    -0.01983470f, -0.03177970f, -0.00684081f, -0.02744529f, 0.01177800f, -0.00577484f, 0.02327863f, -0.01615392f, 
    0.00516008f, -0.00555395f, 0.02105738f, 0.01637601f, -0.01312875f, -0.00461447f, -0.00801269f, -0.03840544f, 
    -0.00459033f, 0.00786151f, -0.03409662f, 0.02825151f, -0.03132241f, 0.00109974f, -0.01304505f, 0.01787404f, 
    0.01354313f, 0.02700959f, 0.02754575f, 0.01846728f, 0.02442128f, -0.03994993f, -0.01311038f, -0.00644729f, 
    -0.00074864f, 0.02635293f, -0.02589860f, -0.01110832f, 0.02474087f, -0.02404823f, -0.04061526f, 0.02294713f, 
    -0.00652793f, -0.00428930f, 0.00066668f, -0.00559079f, -0.02435832f, -0.03990711f, 0.01778076f, -0.03537755f, 
    -0.02455752f, -0.03456735f, -0.02920883f, 0.00025907f, -0.01554129f, -0.00509902f, -0.01792192f, 0.01753732f, 
    0.02660076f, -0.02609451f, -0.00327533f, -0.02720168f, -0.03866325f, -0.03836416f, -0.01684228f, -0.03876255f, 
    0.03762135f, -0.03405858f, -0.00020983f, -0.03433693f, 0.02139358f, -0.01054917f, -0.00061651f, -0.01619329f, 
    0.00405718f, -0.01362980f, -0.00044746f, 0.02529046f, -0.01414195f, -0.01129831f, -0.02400766f, 0.00477579f, 
    -0.02778864f, -0.01506568f, -0.03745814f, 0.01369243f, -0.00084178f, -0.03352957f, 0.01326056f, 0.02439201f, 
    -0.02114100f, -0.00035648f, -0.00585599f, 0.02193420f, -0.03901334f, 0.01976244f, 0.02347652f, 0.00754835f, 
    -0.01908957f, 0.03826150f, -0.02454860f, -0.00652757f, -0.02222582f, -0.02404197f, -0.03216856f, -0.04238867f, 
    0.02775379f, -0.04061237f, -0.01686492f, -0.02607499f, 0.01922897f, -0.04337163f, 0.01261722f, 0.00381926f, 
    -0.03578283f, -0.01886286f, -0.01567530f, -0.02502988f, -0.03536720f, 0.00726418f, -0.02320948f, -0.01381430f, 
    0.00150216f, 0.01215575f, 0.02269437f, 0.00276047f, 0.00184942f, -0.03741160f, 0.01286592f, -0.02783834f, 
    0.02321764f, -0.01612389f, 0.01082375f, 0.01356607f, -0.03749480f, -0.00094540f, 0.00689481f, 0.00730291f, 
    -0.01044858f, -0.01097034f, 0.01981268f, 0.01030447f, 0.02443021f, 0.00667443f, -0.01765374f, -0.03293100f, 
    -0.01808855f, -0.02917467f, -0.00682968f, 0.02501746f, 0.02759643f, -0.03772548f, -0.00096821f, -0.02722215f, 
    0.00121699f, -0.00248477f, -0.02256104f, -0.03452469f, -0.03091665f, -0.04150150f, 0.02688516f, -0.01323818f, 
    -0.04293154f, 0.02489247f, -0.04187404f, -0.00869196f, 0.02387047f, -0.00540893f, 0.02241321f, 0.00742860f, 
    -0.04106085f, -0.01451661f, -0.00680175f, -0.02190998f, -0.02311891f, 0.01427634f, -0.02222469f, 0.01282328f, 
    -0.00706468f, -0.01868882f, 0.00780420f, -0.00326613f, -0.03417332f, 0.02009722f, 0.02165927f, -0.01059222f, 
    -0.00891685f, 0.00438605f, 0.02934037f, 0.02302204f, 0.03099084f, -0.02264133f, -0.01109371f, -0.01073126f, 
    0.02411046f, -0.01033728f, -0.02408191f, 0.00830814f, 0.02139696f, 0.01187192f, -0.03933851f, -0.02144316f, 
    0.01686111f, -0.02661238f, -0.00434853f, 0.01846419f, 0.01962006f, 0.00224958f, -0.00955352f, -0.02644128f, 
    0.00840592f, 0.01442137f, 0.02490373f, 0.02470545f, -0.03207199f, 0.00712824f, 0.02372563f, 0.02722285f, 
    0.02700417f, 0.00413993f, 0.00896731f, 0.00567052f, -0.02169611f, 0.01169654f, 0.01884047f, -0.02644876f, 
    0.01288477f, -0.01372343f, -0.01876215f, -0.02504993f, -0.03329616f, -0.04075240f, -0.02886309f, 0.01409412f, 
    -0.03647842f, -0.01924738f, -0.00498506f, 0.02341105f, -0.02863915f, -0.00613307f, -0.00522132f, -0.04279581f, 
    0.02196766f, -0.00550238f, -0.00685045f, -0.03056581f, 0.01231490f, -0.02858668f, -0.00314819f, -0.00071639f, 
    -0.04276193f, 0.00041120f, 0.00023267f, -0.02280435f, -0.02984808f, -0.00381753f, -0.00618450f, 0.02018322f, 
    0.01728114f, 0.01295836f, -0.01858504f, 0.00271988f, -0.03113781f, 0.01888022f, -0.01118444f, -0.03270010f, 
    0.01557209f, 0.01633668f, -0.03241511f, 0.01548974f, -0.00596017f, 0.01125641f, 0.02830464f, 0.00498959f, 
    -0.04183055f, -0.03008812f, -0.01677403f, 0.02393289f, -0.00084168f, -0.00028201f, -0.03369185f, -0.01945010f, 
    -0.02535358f, -0.00400088f, 0.02122491f, 0.00845907f, -0.02182559f, 0.00307475f, -0.00945659f, -0.00471392f, 
    -0.01065654f, -0.01559748f, -0.00749220f, 0.02301736f, 0.01804060f, -0.04246710f, -0.00124363f, 0.00392168f, 
    -0.02366748f, -0.03325755f, -0.04286608f, -0.04129337f, 0.02110587f, -0.01502901f, 0.02629542f, 0.01391490f, 
    -0.02849450f, -0.01389553f, 0.01443555f, -0.02590580f, -0.00252903f, -0.00588229f, 0.01299262f, 0.01607544f, 
    -0.01249722f, 0.00239101f, -0.02681453f, 0.02431460f, 0.02526162f, -0.00049046f, -0.02928860f, 0.03162209f, 
    -0.02481905f, 0.00045331f, 0.01658769f, 0.00856789f, 0.01298727f, -0.03179784f, 0.01853858f, -0.00414424f, 
    0.00059369f, -0.01718919f, -0.03630225f, 0.01783958f, -0.01388948f, -0.02590449f, 0.01705675f, 0.02318889f, 
    0.02585299f, 0.01546587f, 0.01737815f, -0.01815205f, 0.01503059f, 0.01674064f, 0.03208016f, 0.01078991f, 
    -0.03686785f, 0.01662015f, 0.02177100f, -0.03522263f, 0.02214181f, 0.02037716f, 0.02022147f, -0.03742532f, 
    -0.01855378f, 0.01748881f, -0.02024445f, -0.00815516f, -0.01740290f, 0.02582077f, 0.01505194f, 0.00831517f, 
    0.00916692f, -0.03438869f, -0.03258665f, 0.01151814f, -0.02742648f, -0.01864085f, -0.00511659f, -0.00235619f, 
    -0.01421765f, 0.01251870f, 0.01963208f, 0.02656410f, 0.00048616f, -0.01489280f, -0.00828507f, -0.01537786f, 
    -0.04409523f, -0.02166799f, 0.00903834f, 0.01030339f, -0.03612852f, -0.02323977f, -0.04176484f, -0.01579756f, 
    0.01807174f, 0.02312275f, -0.00935243f, -0.01941011f, -0.01966044f, 0.00280937f, -0.02539883f, 0.03283237f, 
    -0.03620462f, -0.04157192f, -0.01102934f, 0.02168044f, 0.01267901f, 0.01827363f, 0.00045902f, -0.01618401f, 
    0.02175156f, -0.02595744f, 0.02141334f, 0.01043203f, -0.00898857f, -0.02545337f, -0.02089162f, 0.02110304f, 
    -0.04114543f, -0.03007403f, 0.02972426f, -0.01492241f, -0.02279333f, -0.01486105f, -0.01501690f, -0.02154993f, 
    0.01417217f, -0.03531142f, -0.01035631f, -0.04034735f, -0.04071520f, -0.00253391f, -0.01482788f, -0.03071203f, 
    0.01656487f, 0.02020360f, -0.02240166f, 0.03992444f, -0.02458981f, 0.02555555f, 0.01385235f, -0.01204014f, 
    -0.00975847f, 0.02578673f, -0.01056916f, 0.00909914f, -0.04003832f, -0.02516776f, 0.00752412f, -0.00970492f, 
    -0.02170953f, -0.00490872f, 0.01090683f, 0.02592882f, -0.00430641f, 0.02281921f, -0.02208391f, 0.02557050f, 
    -0.03429796f, -0.03763314f, 0.02659874f, 0.00623613f, -0.03014138f, 0.03422756f, -0.03476317f, 0.00119039f, 
    -0.03739243f, -0.00693929f, 0.01487039f, 0.00006545f, -0.02559700f, -0.02079021f, -0.00512999f, 0.01266206f, 
    -0.00129391f, -0.02504091f, 0.01035701f, -0.03857218f, -0.01597388f, 0.02095458f, 0.00207668f, -0.03318312f, 
    -0.02521751f, -0.00072241f, 0.00374670f, -0.01360627f, 0.02793310f, -0.04135743f, -0.00901179f, 0.02033872f, 
    -0.01800184f, -0.04147329f, -0.00380876f, -0.00514434f, 0.01433440f, -0.02586066f, -0.03407027f, -0.02079439f, 
    0.01291959f, -0.00816647f, 0.00161184f, 0.01146246f, -0.00242038f, -0.02027898f, 0.02084914f, -0.01981671f, 
    0.01441705f, 0.01471898f, -0.03801011f, -0.02322811f, -0.02368319f, -0.01160128f, 0.02557387f, -0.00185201f, 
    -0.02420468f, -0.04238270f, 0.01453920f, 0.00761012f, -0.00737823f, -0.03078566f, -0.03642256f, 0.01198862f, 
    0.02405700f, 0.01949959f, -0.04114828f, 0.02809995f, 0.01588845f, -0.00506640f, 0.01123394f, -0.02599625f, 
    -0.04132307f, 0.02463093f, -0.01398981f, 0.01131091f, 0.00444462f, -0.00377995f, -0.03455846f, -0.00026793f, 
    -0.01276396f, -0.03166008f, -0.03284391f, 0.01000612f, -0.04145023f, 0.00844333f, 0.02070689f, 0.02531121f, 
    0.01723953f, -0.01505298f, -0.00668517f, -0.02344628f, -0.01960081f, 0.00970413f, -0.03210064f, -0.00849505f, 
    0.00904126f, -0.03878487f, 0.02683415f, 0.02719565f, 0.02470470f, -0.02952221f, -0.00390204f, -0.02088892f, 
    -0.01120729f, 0.01418988f, -0.01776888f, -0.03456893f, 0.02287522f, 0.00049473f, -0.01658854f, -0.02619452f, 
    0.00305790f, 0.02343563f, 0.02495605f, -0.02143624f, -0.03045776f, 0.00586192f, -0.03674387f, 0.02493431f, 
    -0.03616716f, -0.02279123f, -0.01263249f, -0.04124377f, -0.01888609f, -0.03166034f, 0.01916705f, -0.00733585f, 
    0.02417628f, 0.01643673f, -0.00633473f, 0.00878300f, 0.02359268f, -0.01271863f, -0.01321216f, -0.02666557f, 
    -0.00846518f, -0.03089098f, 0.00308858f, -0.04192493f, -0.03693747f, -0.03507329f, -0.03032509f, -0.02728766f, 
    0.00457115f, 0.01995180f, -0.04239054f, -0.00648666f, 0.00332489f, 0.01350818f, 0.02716893f, 0.01322875f, 
    0.02156417f, 0.01384412f, 0.02142556f, -0.02396186f, -0.04217528f, 0.01684915f, 0.01501950f, -0.02256957f, 
    0.01342683f, 0.02468051f, -0.03852816f, 0.01835122f, -0.00120734f, -0.03369865f, -0.01401255f, 0.00195917f, 
    0.02277865f, 0.02251416f, -0.03735708f, 0.02588887f, 0.00572909f, -0.01707355f, -0.02372119f, -0.01300335f, 
    -0.03931883f, 0.02026602f, -0.01248914f, -0.03203914f, -0.00482670f, -0.01339783f, 0.00273476f, -0.02176346f, 
    -0.04443745f, 0.01452392f, -0.03117533f, -0.03929906f, -0.03296722f, -0.03062775f, -0.03155276f, -0.00037998f, 
    -0.03030003f, 0.01105457f, -0.02554541f, 0.02345803f, 0.02241951f, -0.03674333f, -0.01573592f, -0.01910160f, 
    -0.04302665f, 0.02266671f, -0.01813985f, -0.01221812f, 0.01147540f, -0.03196935f, 0.01856472f, -0.00013074f, 
    -0.04142173f, 0.00024313f, -0.02076339f, -0.01011257f, -0.03108721f, -0.03942939f, 0.00208007f, 0.01217496f, 
    -0.02303126f, -0.01503965f, -0.00684861f, -0.03010006f, 0.02657681f, 0.01222891f, -0.02812059f, 0.01947482f, 
    0.01464328f, 0.02461106f, -0.03720112f, -0.01593368f, -0.00881154f, 0.03461298f, -0.01638654f, 0.00173045f, 
    0.02279826f, -0.00715979f, -0.01554340f, -0.00250134f, -0.02189534f, -0.03456616f, -0.00170192f, -0.04337540f, 
    -0.03081998f, 0.01683317f, 0.00800269f, 0.00023701f, -0.02212650f, 0.01206740f, -0.01515780f, -0.00667188f, 
    0.01905881f, -0.01769174f, -0.02185920f, -0.03391016f, 0.02284153f, 0.00380232f, -0.03240014f, -0.02694452f, 
    0.02304548f, -0.00933163f, 0.02383123f, -0.02748381f, 0.01307320f, 0.01408293f, -0.01908488f, -0.00719297f, 
    -0.01289965f, 0.01073691f, 0.02127282f, 0.00064841f, 0.00755309f, -0.02918882f, 0.01057268f, -0.00410227f, 
    0.01235915f, -0.03290169f, 0.01325847f, 0.01404548f, 0.01886000f, 0.02411812f, 0.00290546f, -0.03228955f, 
    -0.03550551f, -0.04174721f, -0.00260459f, 0.01534957f, -0.02199958f, -0.01917323f, 0.01085884f, -0.01471860f, 
    0.02165560f, 0.02630460f, -0.02598215f, -0.00234075f, 0.00843891f, -0.02423024f, 0.01236799f, -0.00199806f, 
    -0.03127470f, -0.01188859f, 0.01511938f, -0.00371617f, 0.00767134f, -0.00812351f, -0.03622497f, 0.03184008f, 
    0.01107286f, -0.02202434f, -0.00206507f, -0.00098633f, -0.00698333f, -0.03510087f, 0.01913033f, 0.02544195f, 
    0.00288101f, -0.02671186f, -0.00048618f, 0.00104213f, -0.01706946f, 0.00434880f, 0.02565695f, 0.00227224f, 
    0.02006752f, 0.00099465f, -0.01775549f, -0.04176724f, -0.02654773f, -0.01008930f, -0.00197681f, -0.00448451f, 
    -0.01544093f, 0.00407660f, -0.00727983f, 0.02953416f, -0.01380901f, 0.02909512f, 0.00519650f, 0.02178708f, 
    -0.04324984f, -0.01496590f, -0.04429091f, -0.03201980f, -0.03909818f, 0.00378494f, -0.00154116f, -0.02127337f, 
    0.02545561f, -0.01355083f, -0.04315490f, 0.00406456f, -0.00776729f, -0.02245945f, -0.03241078f, -0.02065256f, 
    0.01390104f, 0.01093586f, -0.03192287f, -0.02762338f, -0.00020512f, -0.02220490f, 0.02774638f, -0.01288958f, 
    0.05382776f, -0.13633464f, -0.23722565f, -0.10281064f, -0.05952022f, 0.14502953f, 0.08972363f, -0.00743806f, 
    0.02081638f, -0.06028230f, 0.20156655f, -0.25175461f, 0.23924759f, 0.20941319f, 0.14184557f, -0.05766445f, 
    0.06905760f, 0.12862846f, -0.01110215f, -0.05986900f, 0.00453789f, -0.06345659f, 0.01541579f, -0.07274344f, 
    0.16544580f, -0.03503579f, -0.12456531f, 0.04696814f, 0.03142331f, -0.03796766f, -0.02913091f, 0.06397253f, 
    0.05133289f, 0.00325596f, 0.04607162f, 0.03602243f, -0.19145969f, 0.07051139f, 0.19789615f, -0.07287039f, 
    0.03949651f, 0.01077438f, -0.03793874f, 0.03669782f, 0.03246094f, -0.00014183f, -0.08421547f, -0.15750884f, 
    0.21855153f, 0.34416834f, -0.03631216f, 0.00046309f, -0.00757498f, 0.03393498f, 0.03810068f, 0.14969681f, 
    -0.06297076f, -0.04138053f, -0.09650906f, -0.13508055f, 0.03978006f, 0.00220901f, 0.17140161f, -0.04093346f, 
    0.02635254f, 0.13071541f, -0.00496346f, 0.05336363f, -0.04302289f, 0.00219162f, 0.10525293f, -0.01332149f, 
    0.19003564f, 0.18639062f, -0.10649434f, 0.03931746f, -0.00159410f, 0.00716370f, -0.14244148f, -0.20556039f, 
    -0.10571533f, -0.02372304f, -0.04623509f, -0.12963398f, 0.20189202f, -0.09131499f, -0.08101222f, 0.06687441f, 
    0.16470051f, 0.08373245f, 0.04159373f, -0.06381923f, -0.11150052f, 0.03829776f, -0.00590379f, -0.00945040f, 
    0.19578646f, 0.25883147f, 0.07174384f, -0.04150993f, 0.13021067f, 0.15012057f, -0.06171708f, 0.07602014f, 
    -0.02617105f, -0.05323639f, -0.08033656f, -0.09673420f, 0.18828858f, 0.30440831f, 0.16604997f, -0.07279278f, 
    0.01561143f, -0.12688544f, 0.21296401f, 0.05954764f, 0.05688337f, 0.06248711f, -0.05009027f, 0.03387939f, 
    -0.15452430f, -0.30114180f, -0.44062734f, 0.01853441f, -0.04573103f, -0.08533374f, -0.09474074f, -0.00096195f, 
    0.03936088f, 0.10088507f, 0.01875545f, 0.11203537f, 0.24518034f, 0.33161196f, 0.00188331f, -0.10655996f, 
    0.02629426f, 0.05289848f, 0.07588188f, -0.09050655f, 0.04546631f, -0.29640579f, -0.05823772f, 0.02129207f, 
    -0.13262048f, -0.21599147f, -0.06517071f, 0.04626714f, 0.06708790f, 0.12424801f, -0.00021213f, 0.00177672f, 
    -0.08191886f, 0.07601018f, 0.01870572f, -0.21432555f, -0.06096780f, -0.03313196f, -0.11365972f, -0.01576412f, 
    -0.05665714f, -0.14865856f, -0.01880044f, -0.02715892f, 0.02448902f, 0.11078372f, -0.05098220f, 0.01713555f, 
    -0.19460489f, -0.30751464f, -0.20661817f, 0.13247439f, 0.00015060f, -0.01505391f, -0.12410191f, 0.00793292f, 
    0.03085776f, 0.03926540f, -0.08648626f, 0.01407349f, -0.32172960f, -0.27502784f, -0.00628202f, 0.09681730f, 
    -0.14244065f, -0.14663763f, -0.16078940f, -0.06333323f, 0.03255180f, 0.03193638f, 0.06207087f, 0.02604967f, 
    0.07595252f, 0.07323476f, -0.07268357f, 0.00339673f, 0.18177165f, 0.22387014f, 0.02345948f, 0.09542530f, 
    -0.05527641f, 0.01059996f, 0.03990219f, 0.11139185f, 0.30776495f, 0.24427335f, 0.09586699f, 0.03324224f, 
    0.10242837f, 0.00863791f, 0.14594434f, 0.00654790f, -0.03403581f, -0.05239286f, 0.03283135f, 0.03008549f, 
    0.33166295f, 0.02746318f, -0.05670753f, -0.08893301f, 0.10977975f, 0.10759320f, 0.02440851f, 0.00481307f, 
    -0.05911972f, -0.06452641f, -0.02087962f, -0.01682081f, 0.26957881f, 0.05321897f, -0.16537516f, -0.00172414f, 
    -0.14179283f, -0.07878097f, 0.09807276f, -0.02383470f, -0.13804133f, 0.01634437f, -0.01141031f, 0.00215980f, 
    0.05047125f, 0.35180452f, 0.01619978f, -0.04718332f, -0.07440632f, 0.22544292f, 0.12616153f, -0.09493418f, 
    -0.04447288f, -0.04634061f, 0.07913621f, -0.00986192f, 0.01155033f, 0.04760585f, -0.18578397f, -0.01399141f, 
    0.01049649f, 0.04345080f, 0.03772473f, -0.03161383f, -0.19259062f, -0.10805009f, 0.04323245f, -0.02887090f, 
    0.27738875f, 0.25664717f, -0.03428952f, -0.01902381f, 0.09577290f, 0.14807178f, 0.03484778f, 0.04944023f, 
    -0.04326421f, -0.05159483f, -0.09741636f, -0.04652294f, 0.29973066f, 0.13374437f, -0.02535897f, -0.22406065f, 
    0.13227569f, 0.08533791f, -0.02761132f, -0.06110469f, -0.03003548f, -0.04589776f, -0.01892676f, -0.07884312f, 
    0.00154027f, -0.00366047f, -0.03688888f, -0.08272120f, 0.03128397f, 0.09524090f, 0.09859838f, -0.04172038f, 
    -0.03871844f, -0.21809259f, -0.08424367f, 0.05300123f, -0.19529842f, -0.16230430f, -0.18356784f, 0.00595984f, 
    0.00945605f, 0.03377619f, 0.03002929f, 0.02307617f, -0.08100834f, -0.00806689f, -0.18307456f, -0.09154309f, 
    0.18795152f, -0.02203961f, -0.12401115f, 0.00673961f, 0.09940062f, 0.08228785f, -0.07181980f, -0.02818177f, 
    -0.02708937f, 0.08032124f, 0.09909514f, 0.00660780f, -0.23537658f, -0.34610540f, -0.12278485f, -0.05919506f, 
    0.04054862f, -0.07911154f, -0.05414483f, -0.00580189f, 0.02324142f, 0.06893825f, 0.01201412f, -0.11685784f, 
    -0.45340499f, 0.11132802f, -0.01775252f, -0.24228096f, -0.07427682f, -0.10114352f, 0.01742104f, -0.00731880f, 
    0.04614282f, 0.07358150f, -0.07185086f, 0.06147744f, -0.14173746f, -0.00793360f, 0.00514256f, -0.17712381f, 
    0.05277045f, 0.00321728f, 0.06805634f, -0.05130094f, 0.04927265f, -0.11884059f, -0.02270356f, -0.02693418f, 
    0.11100753f, 0.14933574f, -0.13577335f, -0.03177754f, -0.28197911f, -0.03382846f, 0.20755544f, -0.12325703f, 
    -0.00752524f, 0.06117531f, 0.03635842f, 0.11301129f, 0.14533569f, -0.01892423f, -0.01038725f, -0.09244558f, 
    -0.01811280f, -0.19147375f, -0.05249516f, -0.25666946f, 0.03351187f, 0.06531990f, -0.03652073f, 0.08077372f, 
    -0.06340711f, -0.14929143f, -0.04506201f, -0.01339476f, 0.03114420f, -0.00839080f, -0.01770435f, 0.05561842f, 
    0.05051699f, -0.00581832f, 0.12457058f, -0.03299347f, 0.22396053f, 0.25973603f, -0.05490369f, 0.16851453f, 
    0.02025053f, 0.04784685f, 0.06909853f, 0.02660854f, -0.01887819f, -0.01051099f, -0.13334945f, 0.08646446f, 
    0.35242894f, 0.29759255f, 0.11050214f, -0.00058216f, 0.03516272f, 0.02706940f, -0.01327225f, 0.17028196f, 
    -0.08737764f, 0.02427512f, -0.00688976f, -0.02481306f, 0.21077208f, 0.27096152f, 0.05767887f, -0.00005152f, 
    0.12206028f, 0.12952688f, 0.04403280f, 0.28112596f, -0.03198591f, -0.03043555f, -0.02656933f, -0.02473952f, 
    0.30378667f, 0.08610996f, -0.03015773f, -0.03095986f, 0.16649014f, 0.20478345f, 0.04660454f, 0.03199540f, 
    -0.00878001f, 0.08356270f, 0.07372659f, -0.04213944f, 0.13926007f, 0.03637541f, 0.13162583f, -0.10230084f, 
    -0.01893522f, 0.04093842f, 0.02379578f, 0.02537548f, 0.00945604f, 0.00984306f, 0.00960782f, 0.00308735f, 
    -0.26689887f, -0.29330486f, -0.15919493f, 0.01736947f, -0.05923353f, -0.02835739f, 0.02057261f, 0.00964733f, 
    -0.00888082f, 0.02608863f, 0.14771722f, -0.09435762f, -0.05400391f, -0.14471692f, -0.01815015f, 0.15846016f, 
    0.02005134f, -0.07509577f, 0.03637396f, -0.07067958f, 0.05498226f, -0.09184784f, -0.01357928f, 0.03371890f, 
    0.08688538f, 0.06392144f, -0.04549805f, 0.04498680f, -0.03287061f, 0.11966244f, -0.09051103f, 0.07926341f, 
    -0.17910741f, -0.12357897f, -0.22647412f, -0.00902508f, 0.00367905f, 0.07445268f, -0.03599444f, -0.18926063f, 
    -0.05458451f, -0.00253774f, 0.07925462f, -0.02030012f, 0.08744982f, -0.00636675f, -0.05039579f, 0.09235165f, 
    0.43840471f, 0.38029239f, -0.02039477f, 0.02818632f, 0.20188540f, 0.21429405f, 0.21424197f, 0.09184626f, 
    -0.08110579f, -0.07775799f, -0.03371401f, -0.00219459f, 0.11183285f, 0.16570531f, -0.06305612f, 0.11116663f, 
    0.06325087f, 0.10902663f, -0.06137699f, -0.11966744f, -0.08848107f, -0.07690368f, -0.03608417f, 0.01591514f, 
    0.17234173f, 0.17228499f, -0.18162289f, -0.02026967f, -0.01064103f, -0.10108827f, 0.19400345f, -0.07002486f, 
    -0.03156297f, -0.09871420f, 0.10115820f, -0.08580104f, 0.05286150f, 0.05687731f, 0.21272901f, 0.00084400f, 
    0.01980868f, 0.08778159f, 0.01294411f, 0.03450556f, -0.05182449f, 0.09998331f, -0.02545807f, -0.08141090f, 
    0.18143445f, 0.22225420f, 0.30897415f, -0.00998792f, -0.01573954f, -0.02288131f, -0.12684828f, -0.02219505f, 
    -0.04092355f, -0.12464931f, -0.07614629f, 0.00515693f, -0.03616034f, 0.33556765f, -0.15281224f, -0.08104140f, 
    -0.10926588f, 0.03129771f, 0.07904060f, -0.01934680f, -0.07107899f, -0.14058313f, 0.00811346f, -0.13713825f, 
    0.00625533f, -0.14886616f, -0.04473499f, 0.05159651f, -0.05120778f, -0.03165313f, -0.16441807f, -0.00044425f, 
    -0.17387255f, -0.03393943f, 0.00352549f, 0.01691162f, -0.05878865f, -0.15927416f, -0.09081823f, 0.03475046f, 
    -0.13178095f, -0.04051248f, 0.01689767f, -0.05232105f, 0.03200737f, 0.00637956f, -0.01693376f, -0.01643534f, 
    -0.11016643f, -0.03573842f, -0.11675594f, -0.01431963f, 0.05599828f, 0.02262464f, 0.06697736f, -0.06665721f, 
    -0.03767561f, -0.03536104f, -0.00538369f, -0.07369257f, -0.03870807f, -0.07790658f, -0.00424446f, -0.28643641f, 
    -0.11484750f, -0.09839343f, -0.12807329f, 0.15506187f, 0.04712222f, -0.05467040f, 0.07413866f, 0.04006026f, 
    0.08056067f, -0.02330644f, 0.07485663f, 0.01993259f, 0.11290248f, 0.20320384f, -0.14544380f, -0.01516760f, 
    -0.04039939f, -0.04586877f, 0.04045671f, 0.03009372f, -0.13518146f, -0.17056392f, -0.04620551f, -0.05252027f, 
    0.00357034f, -0.04553972f, 0.02935231f, 0.02638398f, -0.02280854f, 0.06533725f, 0.14301574f, -0.03486846f, 
    -0.19864194f, -0.47068927f, 0.01614145f, -0.22262639f, -0.05103008f, -0.09259044f, -0.08869075f, 0.00699737f, 
    -0.04142032f, -0.00344583f, 0.00100192f, 0.06661323f, 0.16935341f, 0.03847370f, 0.18906419f, 0.07722417f, 
    0.10587782f, 0.10883052f, -0.25183406f, 0.03254436f, -0.04780601f, 0.00295874f, 0.13249819f, -0.01393824f, 
    -0.13426970f, -0.26929325f, -0.14886306f, 0.10709652f, 0.01189646f, 0.03507382f, 0.00000895f, -0.03832912f, 
    -0.21366547f, -0.08077650f, 0.00226993f, -0.03626217f, 0.20514975f, 0.18906921f, 0.00357934f, -0.01003673f, 
    0.05411374f, 0.18043067f, 0.18017049f, 0.00975057f, 0.02950132f, 0.02223636f, 0.10585099f, 0.02939256f, 
    0.11703882f, 0.06358916f, -0.16040954f, -0.05487431f, 0.13610828f, 0.07364098f, -0.02163472f, -0.00134917f, 
    -0.05848677f, 0.07211812f, -0.00328627f, -0.05936614f, 0.01610148f, -0.12447402f, 0.12263690f, -0.14897282f, 
    -0.06697837f, 0.17390323f, -0.19641225f, -0.08041080f, 0.04750687f, 0.05523027f, -0.02793484f, -0.05774722f, 
    -0.03322945f, -0.06192784f, -0.22146730f, 0.05901357f, -0.11923772f, -0.08501585f, 0.16136606f, 0.03884360f, 
    0.00408198f, 0.04227406f, -0.00008864f, 0.03519828f, -0.05552943f, -0.08272620f, -0.04525555f, 0.06173147f, 
    0.03752693f, -0.07433182f, -0.01475559f, -0.00108807f, -0.00820529f, -0.00073215f, -0.01293621f, 0.06108551f, 
    -0.16694994f, 0.06365632f, 0.34653416f, -0.28388527f, -0.15256099f, 0.03648024f, 0.04939226f, 0.13885574f, 
    0.00344797f, -0.00865980f, -0.10557321f, 0.05283681f, -0.12112044f, -0.13767964f, -0.12529933f, -0.01129510f, 
    0.03129773f, 0.01592808f, -0.01984106f, -0.00083334f, 0.04659279f, 0.03734564f, -0.11801016f, -0.08868369f, 
    0.06561848f, 0.03984772f, -0.12039463f, -0.23744713f, -0.03113904f, -0.03827691f, -0.05732001f, 0.09016725f, 
    -0.19614048f, 0.07864780f, -0.00515852f, 0.16165473f, -0.20523843f, 0.00918925f, -0.02531866f, -0.05050411f, 
    -0.02588898f, 0.06969337f, 0.02555543f, -0.04261299f, 0.03598026f, 0.03897681f, -0.00159870f, -0.05829852f, 
    0.22823262f, -0.07539621f, 0.11811376f, 0.24893427f, -0.05297853f, -0.01198001f, -0.01711034f, -0.05934187f, 
    0.06313850f, -0.04857581f, 0.06399848f, -0.02871549f, -0.05820649f, 0.14620271f, 0.13353392f, 0.25024509f, 
    -0.02932089f, 0.01196245f, -0.03861216f, 0.01387988f, -0.04701192f, 0.01251786f, -0.06578875f, -0.04932135f, 
    0.00794744f, 0.25663659f, 0.13149282f, 0.00361152f, 0.01842240f, 0.01690175f, 0.10266406f, 0.08991767f, 
    0.02923059f, 0.02601692f, 0.04600867f, 0.01778040f, -0.30977276f, -0.15652041f, -0.00020158f, -0.02769065f, 
    -0.00444933f, -0.02531621f, -0.05640047f, -0.05372646f, 0.05556028f, -0.02000427f, 0.02997399f, -0.08249658f, 
    -0.07425582f, 0.27152899f, -0.22429416f, -0.23466152f, 0.09025546f, 0.05488582f, -0.17599361f, 0.05664005f, 
    0.05913407f, -0.04763382f, -0.04804441f, 0.17131844f, 0.22205891f, -0.12733608f, 0.02814426f, 0.03325044f, 
    0.07758117f, 0.00652706f, -0.11362097f, 0.00477714f, -0.01096884f, -0.06770765f, -0.13618712f, -0.14608839f, 
    -0.03155711f, 0.10487726f, 0.11454128f, -0.00707545f, 0.11184603f, 0.09009266f, -0.04729931f, -0.04928438f, 
    0.01069215f, 0.01048082f, 0.03696450f, 0.07369997f, 0.05619973f, 0.13922468f, 0.15578620f, -0.28803009f, 
    0.09990093f, 0.19309781f, -0.00954443f, 0.15596282f, -0.04371802f, 0.04076292f, -0.02834967f, 0.01697730f, 
    0.39555576f, -0.00027277f, 0.00383041f, 0.10577960f, 0.02776585f, -0.00101132f, -0.05177771f, 0.05911304f, 
    0.00789250f, 0.01489130f, -0.02574069f, 0.03900827f, 0.02979152f, -0.05772867f, 0.06282301f, 0.09233171f, 
    -0.10117531f, 0.10279575f, 0.08703618f, 0.05768375f, 0.06931564f, 0.02663889f, -0.07535134f, 0.06396773f, 
    0.13040927f, 0.02822193f, 0.06247394f, 0.19997279f, -0.05388594f, -0.00397434f, -0.06526634f, -0.01384145f, 
    0.04331986f, 0.04819210f, 0.06795099f, 0.03684675f, 0.28803548f, 0.09870868f, -0.03256384f, 0.05481013f, 
    0.06661632f, -0.01102793f, -0.04910186f, -0.08803591f, -0.07096870f, -0.01744040f, -0.03166924f, -0.05775313f, 
    0.16850407f, 0.08204619f, -0.06122429f, -0.15228856f, 0.07527895f, 0.11417221f, -0.01733788f, -0.01917404f, 
    0.14360154f, 0.15913613f, 0.02844472f, 0.03558938f, 0.23323409f, 0.00046350f, 0.05746468f, 0.07344042f, 
    0.09695056f, -0.12850919f, -0.02048168f, -0.03039626f, -0.00917001f, -0.08594537f, -0.04128407f, -0.00468547f, 
    -0.22468454f, -0.02066082f, -0.24829525f, -0.14577341f, -0.01357172f, -0.07980850f, -0.03530379f, -0.13161722f, 
    -0.02437756f, -0.01547459f, 0.09924486f, 0.06055294f, 0.21984577f, 0.31322259f, 0.14361124f, -0.05333427f, 
    0.06978774f, -0.00196436f, 0.03642086f, 0.04649947f, 0.03118597f, -0.03625363f, 0.00198196f, -0.07339468f, 
    0.16170675f, 0.06027225f, -0.02878061f, -0.42489371f, -0.12030953f, -0.04313923f, 0.01775561f, -0.17551553f, 
    0.06951078f, 0.00053886f, 0.07010461f, 0.10748913f, 0.74782974f, 0.07891895f, -0.22630563f, -0.06295885f, 
    -0.05920423f, 0.03190057f, 0.12805344f, 0.05725529f, 0.03309520f, -0.05711646f, -0.00627583f, 0.00286197f, 
    -0.16784760f, -0.07791618f, 0.11163609f, 0.19982348f, 0.11534691f, 0.04761488f, 0.05212744f, -0.06967203f, 
    0.08011968f, -0.02860723f, 0.04207432f, -0.05378624f, -0.21434765f, -0.18243030f, 0.30883834f, 0.25731739f, 
    0.07520951f, -0.05366462f, 0.01167123f, -0.06083069f, 0.04987203f, -0.10463800f, -0.22490551f, 0.03851057f, 
    0.05070753f, 0.29530546f, 0.33275434f, 0.06695218f, 0.06637141f, 0.18164006f, -0.10328355f, -0.01301146f, 
    0.02876900f, -0.00998168f, 0.03325512f, 0.07865275f, -0.13120380f, 0.22572422f, -0.20399736f, -0.39956310f, 
    -0.07522102f, -0.03262357f, -0.04750158f, -0.02820916f, 0.08751751f, -0.15605508f, -0.06708804f, -0.04199437f, 
    -0.03289991f, -0.05014446f, 0.04051708f, 0.09866406f, -0.01012471f, -0.08245351f, -0.00676046f, 0.01466546f, 
    0.04734778f, -0.01107206f, -0.02850410f, 0.07875486f, 0.03769144f, -0.08268831f, -0.02865564f, 0.16992378f, 
    -0.01956849f, -0.07403734f, -0.01090728f, -0.01154122f, -0.02451125f, 0.05525144f, 0.00960095f, -0.01996713f, 
    0.24897347f, -0.26665586f, -0.10911552f, -0.23515612f, -0.07862990f, -0.04803863f, -0.06326692f, 0.00805098f, 
    0.05893100f, 0.00506708f, -0.03463176f, -0.05287009f, 0.20987104f, 0.03557060f, 0.06015179f, 0.09598363f, 
    -0.01036890f, 0.04040996f, -0.04279850f, -0.01652856f, -0.00692785f, -0.02444119f, 0.01740936f, -0.07120566f, 
    -0.12124673f, 0.01923407f, 0.13602720f, -0.09029953f, -0.01170271f, 0.04763408f, 0.00525452f, 0.08970897f, 
    0.00690906f, 0.00387123f, -0.02255340f, 0.01297041f, 0.09942853f, -0.11518863f, 0.01306374f, 0.06885902f, 
    0.04583570f, -0.03469328f, 0.02716979f, -0.06573217f, 0.03396164f, 0.03568939f, -0.06172115f, -0.04846551f, 
    0.16415526f, 0.06965230f, -0.06267986f, -0.13889526f, -0.03083709f, 0.13357711f, 0.18482693f, 0.20069942f, 
    0.11649470f, 0.00953561f, 0.02938885f, -0.07073255f, 0.24376807f, -0.04334237f, -0.08954184f, -0.01627937f, 
    0.08497803f, 0.06129262f, 0.01615616f, 0.01762359f, -0.03051206f, -0.00136405f, -0.04567533f, -0.03784481f, 
    0.06429385f, 0.13623570f, -0.02910025f, 0.13638048f, 0.02426101f, -0.02994501f, -0.07722337f, 0.03693989f, 
    0.02084286f, -0.04761331f, 0.02929282f, 0.02315360f, 0.11621177f, 0.34042236f, 0.23427621f, -0.13001676f, 
    -0.04474086f, -0.02763523f, 0.16090357f, -0.09472626f, -0.04618376f, 0.03010551f, 0.05742466f, 0.02712923f, 
    0.01695510f, 0.39427787f, 0.27053747f, -0.09141520f, 0.00684266f, 0.07504807f, 0.01420754f, -0.04597718f, 
    0.01758745f, -0.01424773f, 0.07437563f, 0.06064511f, -0.06349870f, 0.19966848f, 0.14997034f, -0.02988091f, 
    -0.02660510f, -0.02616051f, -0.07617771f, 0.10886319f, -0.01861650f, -0.11142480f, -0.05908256f, -0.04036736f, 
    -0.13279708f, -0.23609033f, -0.30624038f, -0.22701293f, -0.04455657f, -0.03774069f, -0.08819566f, -0.07356402f, 
    -0.02535123f, -0.13023070f, 0.09697174f, -0.01053948f, 0.11423286f, 0.02672599f, 0.00844712f, 0.03674578f, 
    0.05104299f, 0.21525815f, 0.06359224f, 0.03735721f, -0.04714841f, -0.09100054f, -0.01579971f, -0.08032648f, 
    0.28573015f, 0.06007385f, -0.12642169f, 0.09376863f, 0.02390284f, -0.00295132f, -0.01067611f, 0.00678827f, 
    -0.01612495f, -0.06333452f, -0.02280641f, -0.01049586f, -0.08240692f, -0.09144599f, -0.06618714f, -0.12188277f, 
    0.07582223f, -0.03673429f, 0.04313783f, -0.04175096f, 0.06451569f, 0.10701564f, -0.03933324f, 0.05497012f, 
    -0.13169433f, 0.05733265f, -0.28828350f, -0.21140940f, -0.03218389f, -0.04631217f, -0.05254133f, 0.14663868f, 
    0.09852341f, -0.01111794f, 0.09997855f, 0.10427981f, -0.07310218f, -0.00242298f, 0.05966949f, 0.21935701f, 
    -0.06705830f, -0.03808969f, 0.05120045f, -0.10371333f, 0.14055900f, 0.08201457f, -0.14063206f, -0.04741092f, 
    -0.14190288f, 0.39642745f, -0.00387763f, -0.12392561f, 0.06303678f, -0.03844088f, 0.02862836f, -0.12698428f, 
    0.12888770f, -0.00267384f, -0.02219879f, 0.15252537f, -0.14613032f, 0.04315747f, -0.10974611f, 0.01077078f, 
    0.02131778f, -0.01596097f, -0.05208777f, 0.15149814f, 0.13337107f, -0.09664448f, 0.10230132f, 0.17778338f, 
    -0.14417158f, 0.03427581f, 0.15298684f, 0.14202800f, -0.07071999f, 0.01593602f, 0.04565223f, 0.07948032f, 
    -0.06176080f, 0.08289498f, -0.07590089f, 0.01875559f, -0.06566993f, 0.02118408f, 0.05377821f, 0.06276504f, 
    -0.06521983f, 0.15105328f, -0.08882841f, -0.00126992f, -0.08098034f, 0.02176841f, -0.11699458f, -0.13911469f, 
    -0.47606343f, -0.09884077f, 0.14036712f, -0.30855495f, 0.16476466f, -0.07782666f, 0.13297737f, -0.06888257f, 
    0.07172226f, 0.07957514f, -0.04245230f, -0.18243396f, -0.30687344f, 0.06136452f, -0.04152574f, -0.07056026f, 
    -0.06069335f, -0.05019663f, 0.02876172f, -0.01064290f, 0.18098632f, -0.19300833f, 0.07625329f, 0.04204952f, 
    0.22581168f, -0.04406092f, 0.02751538f, -0.05250421f, 0.00961596f, 0.04945820f, -0.01064650f, 0.01682744f, 
    0.04756505f, -0.28674176f, -0.00799093f, -0.10004871f, 0.01533304f, -0.04124709f, 0.00080388f, 0.11793372f, 
    0.10529573f, 0.05935900f, -0.07748933f, -0.06064535f, 0.00703034f, -0.02225003f, -0.03154289f, 0.00375148f, 
    0.03611788f, -0.05994538f, -0.04452337f, -0.00040735f, -0.04034529f, -0.07286412f, 0.00464893f, -0.05644559f, 
    -0.02406276f, 0.11586060f, 0.01438974f, 0.01300797f, 0.18265350f, 0.16344145f, 0.06779993f, 0.01468310f, 
    0.02734832f, -0.06213462f, -0.02409231f, 0.12641966f, -0.04405808f, -0.00470188f, 0.00014337f, 0.02168113f, 
    -0.02033721f, 0.10991941f, 0.02060651f, -0.22513078f, -0.06063022f, -0.00700572f, 0.00530481f, -0.09568151f, 
    0.14962363f, 0.05559690f, 0.10738271f, 0.01735950f, 0.15514994f, -0.01431486f, 0.01195143f, 0.08510797f, 
    -0.08552940f, 0.01307403f, -0.03405094f, 0.05702319f, -0.04274955f, 0.02927604f, 0.08746651f, -0.12966451f, 
    0.42607787f, -0.03068216f, 0.24198355f, 0.09639505f, 0.04090148f, -0.02288679f, -0.02393558f, 0.10631716f, 
    0.05957274f, -0.01304976f, -0.05887381f, -0.06538942f, -0.03714821f, -0.03739505f, -0.01598418f, -0.04144251f, 
    -0.15365040f, -0.18574828f, -0.01296605f, 0.03224277f, 0.12062395f, -0.05073194f, 0.12198487f, 0.07330709f, 
    0.28715563f, 0.01476247f, 0.04186990f, 0.10074878f, 0.00628109f, 0.02344039f, 0.01231994f, 0.04489376f, 
    -0.06061735f, -0.05840436f, 0.00906860f, 0.02562954f, 0.05567519f, 0.00207451f, -0.00431951f, -0.11933430f, 
    0.03750195f, 0.10267483f, 0.05915538f, -0.00258713f, 0.11488955f, 0.01267864f, 0.01903570f, -0.03485053f, 
    0.17946137f, 0.05434655f, -0.13575174f, -0.03933829f, 0.01174314f, 0.11915260f, -0.03030771f, 0.00533267f, 
    -0.00331305f, 0.02713032f, -0.06974681f, 0.03965729f, 0.04401771f, -0.01858169f, -0.09112775f, -0.07780484f, 
    0.07948661f, 0.06206695f, -0.03483932f, -0.04503221f, -0.00062548f, -0.02385548f, 0.09279838f, -0.10633910f, 
    0.25240710f, -0.07467773f, -0.23449010f, -0.04217461f, -0.02588545f, 0.06246117f, 0.09587491f, -0.00771664f, 
    0.01946900f, 0.04438201f, -0.02703822f, -0.08188845f, 0.38967645f, -0.01849960f, 0.21076794f, 0.09948642f, 
    0.05696836f, -0.03717865f, -0.01756492f, 0.00465882f, 0.05605908f, 0.02484043f, -0.02302181f, -0.12349308f, 
    -0.16532725f, 0.09809490f, 0.10850561f, -0.03823702f, 0.02856430f, 0.03928722f, 0.03445232f, -0.12126309f, 
    -0.04126526f, -0.05335984f, 0.08801736f, -0.05868572f, 0.11600135f, 0.06504229f, 0.09675711f, 0.08633560f, 
    -0.02834185f, -0.01266609f, -0.03124432f, 0.03272938f, -0.04194667f, -0.01165699f, -0.02358386f, -0.04649052f, 
    -0.01453704f, -0.03698245f, -0.00374955f, 0.00990858f, -0.01784351f, -0.01216650f, 0.02443130f, 0.01276581f, 
    -0.01602876f, -0.01492080f, -0.03737355f, -0.03649742f, -0.02999151f, 0.02812414f, -0.00975446f, -0.00942828f, 
    0.02686726f, 0.00284338f, -0.02334752f, -0.02991282f, -0.02733992f, 0.02270806f, -0.04178987f, 0.01460292f, 
    0.03314018f, 0.00502721f, 0.01580173f, 0.00375273f, 0.00575080f, -0.01853523f, -0.02049141f, -0.03734505f, 
    0.01731726f, -0.04110621f, -0.00433096f, 0.00476553f, -0.03870952f, 0.01975328f, -0.01832472f, 0.00627607f, 
    -0.02520550f, -0.03974579f, -0.03151416f, 0.02816093f, -0.02790327f, 0.00378365f, -0.01693192f, -0.02632561f, 
    0.00705939f, 0.01187923f, 0.00730471f, -0.01020408f, -0.00521426f, -0.03582969f, -0.00903851f, -0.03288142f, 
    -0.00251926f, -0.00074625f, -0.03505127f, 0.02339260f, 0.00051297f, -0.02847942f, -0.03818489f, -0.01408524f, 
    0.00608966f, -0.01416460f, -0.00580524f, -0.02912879f, -0.03124582f, -0.00086493f, -0.02153655f, 0.01565350f, 
    -0.02334419f, -0.03480226f, -0.00242479f, -0.03100864f, 0.00635215f, 0.01457388f, -0.01395596f, -0.02484329f, 
    -0.01529837f, -0.04041368f, 0.02567896f, 0.02097467f, -0.02119405f, 0.02480323f, 0.01974392f, -0.01160696f, 
    0.00383858f, -0.02749965f, -0.01290722f, -0.00602423f, 0.01453512f, -0.02274517f, -0.00072006f, -0.00038672f, 
    -0.01127058f, 0.01840599f, 0.01562515f, -0.01318173f, -0.03498418f, -0.01141035f, -0.01437947f, 0.02066198f, 
    0.02476921f, -0.02687264f, 0.01758826f, -0.01261302f, 0.01302396f, 0.02278925f, 0.01146507f, 0.02835360f, 
    -0.01417550f, -0.02741598f, 0.02233455f, -0.01471740f, -0.00997411f, -0.01190097f, 0.02581113f, 0.00706440f, 
    -0.00146898f, 0.04165811f, -0.00445124f, -0.01965189f, -0.02667722f, -0.00034762f, -0.03662124f, -0.02068732f, 
    -0.03888631f, -0.00050129f, 0.02650409f, -0.02279309f, -0.02345538f, -0.00275642f, 0.01171806f, 0.00006577f, 
    -0.03085631f, 0.02695390f, -0.02846389f, -0.00002667f, -0.02680730f, -0.02549242f, -0.02516327f, -0.03940606f, 
    0.01295020f, -0.01871571f, -0.02665292f, -0.00093038f, -0.00294685f, 0.00893041f, -0.03142511f, 0.01815226f, 
    0.04141375f, 0.03117560f, 0.00838482f, -0.04135574f, 0.04045206f, 0.00488848f, -0.03594013f, 0.03093996f, 
    0.00871246f, 0.00592634f, -0.00344081f, -0.00818641f, -0.02584844f, 0.01967268f, -0.01376521f, -0.02597286f, 
    -0.03800348f, -0.01057890f, 0.02286813f, -0.01540562f, -0.04077228f, 0.02033996f, 0.02781972f, -0.02452870f, 
    -0.01913812f, 0.01506787f, 0.01451306f, 0.01645130f, -0.04154578f, 0.01192246f, -0.00330887f, -0.00371388f, 
    0.02557466f, 0.02111066f, -0.04087082f, -0.01865183f, 0.01933570f, -0.01327371f, -0.03238408f, 0.02925650f, 
    -0.02678023f, -0.01707288f, -0.01852067f, 0.00780050f, 0.00115708f, -0.00086704f, -0.02587880f, -0.02925813f, 
    -0.02648316f, 0.02700426f, 0.02904831f, -0.00374817f, 0.01833838f, -0.01847536f, 0.00601480f, 0.02371380f, 
    0.03931976f, 0.01421752f, -0.02021769f, 0.00638504f, -0.02063155f, -0.00103704f, -0.03442391f, 0.03902297f, 
    0.02735227f, -0.01809296f, 0.02081463f, 0.02962904f, 0.01185523f, 0.02778371f, 0.00448922f, 0.02903508f, 
    -0.00717918f, 0.01611570f, 0.02836125f, -0.02891571f, 0.00644631f, -0.03236195f, 0.02227603f, 0.00887365f, 
    -0.01442875f, 0.02519038f, 0.01812207f, -0.01390100f, 0.02464933f, -0.01884881f, -0.02558014f, -0.01508312f, 
    -0.03941816f, 0.01256361f, 0.03830137f, -0.02912275f, 0.00144417f, -0.03447272f, -0.03635386f, -0.01724057f, 
    -0.03434534f, 0.01396987f, -0.04179666f, -0.01284468f, -0.02256627f, 0.00775785f, 0.00163852f, -0.01052636f, 
    -0.02293127f, -0.01248986f, -0.03028121f, 0.00338625f, -0.00529512f, 0.02373830f, 0.01924226f, -0.03041968f, 
    -0.03669912f, -0.00192556f, -0.03950691f, 0.02907003f, -0.00610425f, -0.01997123f, 0.01204755f, -0.01835191f, 
    -0.00731132f, 0.01483499f, 0.00960292f, 0.01541785f, 0.02184350f, 0.02016166f, -0.02293927f, -0.02668380f, 
    0.02813341f, -0.03070727f, 0.00753384f, 0.01812905f, 0.00072582f, 0.00813185f, -0.03093745f, -0.01795975f, 
    0.03898482f, -0.02912337f, 0.03785992f, -0.00845377f, -0.00330234f, -0.02674902f, -0.03332993f, 0.02062997f, 
    -0.02465744f, 0.00309989f, -0.04166215f, -0.02519322f, -0.02629972f, -0.02205733f, 0.03132673f, 0.00170969f, 
    -0.01694584f, 0.02982529f, -0.00515781f, 0.02731440f, -0.00831098f, 0.02020654f, -0.00283609f, -0.00330487f, 
    0.02822681f, 0.02107851f, -0.00846380f, -0.01601381f, 0.01133799f, -0.03000487f, -0.03291644f, 0.02895204f, 
    -0.00591924f, -0.01805923f, -0.00395891f, -0.01210402f, 0.03347593f, -0.00952906f, 0.01381472f, 0.01424339f, 
    -0.03964544f, -0.01582597f, -0.00273119f, 0.01647755f, -0.02328069f, 0.00680550f, -0.03191664f, -0.03247205f, 
    -0.03825997f, 0.01439068f, 0.00976237f, 0.01765410f, -0.03501288f, -0.01815288f, -0.00259348f, -0.03717038f, 
    0.02633371f, 0.02147926f, -0.02776535f, -0.01174411f, -0.00738130f, -0.01240682f, -0.02037589f, -0.01689242f, 
    -0.00329446f, -0.02650461f, -0.00603251f, -0.03181423f, 0.00423314f, 0.01215475f, -0.03923928f, -0.01180311f, 
    0.00185973f, -0.00579260f, -0.02195379f, -0.02185468f, 0.02974995f, 0.00284275f, -0.03466656f, -0.00928493f, 
    -0.02929524f, 0.01311391f, 0.02979953f, -0.02116461f, -0.02240965f, 0.02620300f, -0.01993294f, 0.01548379f, 
    -0.00727140f, 0.02539866f, -0.00919488f, -0.02659678f, -0.01335358f, -0.03224411f, 0.00494766f, -0.02727588f, 
    -0.02333600f, -0.00871515f, 0.02699603f, 0.03660613f, -0.00265078f, 0.01155158f, 0.01753289f, -0.02676039f, 
    -0.00055702f, -0.02574796f, -0.03834178f, -0.01552615f, -0.04009981f, -0.00437205f, -0.00575146f, -0.02009613f, 
    -0.03517609f, 0.02540969f, -0.01852789f, -0.03110547f, -0.01582375f, -0.03296010f, -0.01540223f, -0.02734673f, 
    -0.02445668f, 0.02234197f, 0.01454437f, 0.02861295f, -0.00064001f, -0.02632061f, 0.02227246f, -0.01120630f, 
    -0.00045765f, -0.00023660f, 0.00170237f, -0.03717330f, 0.01212237f, 0.00227358f, -0.01915641f, -0.00961754f, 
    -0.03536825f, 0.00107639f, -0.02129809f, -0.04085374f, -0.02007573f, -0.00478577f, -0.00816209f, 0.00680525f, 
    0.02375335f, 0.02319892f, 0.02762079f, 0.00901715f, -0.03037424f, 0.00757237f, -0.04139550f, -0.01810044f, 
    0.03356141f, -0.00174803f, 0.01996186f, -0.01658475f, 0.01947218f, -0.01868296f, -0.02738984f, -0.02609219f, 
    -0.01865735f, -0.00724072f, -0.04156861f, 0.02368801f, 0.02428004f, -0.01191468f, -0.03344526f, -0.01931231f, 
    0.00972808f, -0.00972170f, -0.02201732f, -0.01346675f, -0.01263878f, 0.00323602f, 0.01270023f, 0.02306381f, 
    0.03289489f, -0.02726160f, -0.04082872f, -0.03822898f, -0.03098084f, -0.00941835f, -0.01060050f, -0.03784448f, 
    0.03004668f, 0.00180216f, 0.00223026f, 0.00473816f, -0.03708414f, 0.03309670f, 0.02814899f, 0.00244951f, 
    -0.04107204f, -0.01303706f, 0.02601557f, -0.00591188f, 0.00050099f, -0.01350764f, -0.00746786f, -0.03161895f, 
    0.02292635f, 0.02923228f, -0.00758252f, -0.02788068f, -0.03062064f, 0.01466836f, 0.01085055f, -0.00340295f, 
    0.01945163f, -0.00562629f, 0.01152781f, -0.02115978f, -0.03810084f, -0.00680545f, -0.02646542f, 0.00653306f, 
    -0.03985757f, 0.01770746f, -0.01721560f, 0.02856154f, -0.01318698f, -0.00874231f, 0.01095591f, -0.04100094f, 
    -0.01449025f, 0.02986098f, -0.02637660f, 0.02265020f, -0.02053389f, 0.02395994f, 0.01164823f, -0.00937166f, 
    -0.03378555f, -0.01342830f, -0.00347884f, -0.03213528f, -0.01248761f, 0.02145561f, 0.00360108f, 0.01444115f, 
    -0.02851438f, -0.01578550f, 0.00998136f, -0.02800593f, -0.00042362f, -0.03411116f, -0.01137433f, -0.03984159f, 
    0.03904462f, 0.02646066f, 0.01545739f, 0.01283694f, 0.02801168f, -0.00016893f, -0.02623305f, -0.02003287f, 
    -0.02414128f, -0.02254398f, 0.00143419f, -0.02836782f, -0.03288155f, -0.00221924f, 0.01661448f, 0.00145404f, 
    0.01558963f, -0.01393100f, 0.00907039f, 0.02316325f, -0.01315366f, -0.01236959f, 0.01437452f, 0.00424384f, 
    0.01892494f, -0.03083693f, 0.01621473f, -0.03630438f, 0.02505765f, -0.03350830f, 0.01116223f, 0.00772974f, 
    -0.02912898f, -0.03826644f, 0.02489738f, -0.03979717f, 0.02168107f, 0.00839913f, -0.02085892f, 0.02335779f, 
    -0.04078865f, -0.00949393f, -0.01121887f, 0.01993864f, 0.01942234f, -0.01758231f, 0.00152877f, -0.00977915f, 
    -0.03644130f, 0.00598477f, 0.02006073f, -0.03333117f, 0.00111576f, -0.02951839f, -0.00930885f, 0.02214194f, 
    0.00533863f, 0.02592433f, -0.01739184f, -0.00489212f, 0.01858529f, 0.02283257f, 0.00382686f, -0.01395644f, 
    0.01142315f, 0.03355309f, -0.00079789f, -0.02662528f, -0.02111791f, 0.02574644f, 0.00946100f, 0.02321827f, 
    -0.01181969f, 0.02190444f, -0.03653365f, 0.02774305f, -0.00312745f, -0.03311809f, -0.03012076f, -0.03396083f, 
    0.02129845f, -0.01584527f, -0.00597639f, 0.00657537f, -0.00007324f, 0.02213060f, -0.02395906f, -0.02305878f, 
    0.01915326f, -0.01168414f, 0.02791948f, 0.02696534f, 0.02864626f, 0.03007871f, -0.03246725f, -0.01003871f, 
    -0.02083449f, 0.01917485f, 0.02197850f, -0.03635730f, 0.02311012f, 0.00804462f, -0.02835039f, -0.02961393f, 
    0.01923516f, 0.01413574f, -0.00727157f, -0.00266366f, -0.03733664f, -0.03175632f, -0.00313612f, -0.00076692f, 
    -0.02507951f, 0.02275849f, -0.01953708f, 0.02156389f, -0.02601313f, -0.00168021f, 0.00481789f, -0.04109937f, 
    0.02485873f, -0.00132036f, 0.02321521f, -0.00039801f, -0.01736245f, -0.01802845f, -0.03635924f, 0.02454397f, 
    -0.02097195f, 0.01707737f, -0.03660323f, -0.02042754f, -0.02062614f, -0.02039508f, 0.01330477f, -0.01209956f, 
    -0.02997733f, -0.00455826f, 0.00460280f, 0.00618918f, -0.00268811f, 0.01985182f, 0.00273716f, 0.01515391f, 
    -0.00701462f, -0.00071238f, 0.00960397f, -0.03659847f, -0.01495902f, -0.04127349f, -0.02900833f, -0.00404639f, 
    -0.01637304f, -0.04147626f, -0.04184745f, 0.00464835f, 0.01178211f, 0.01436234f, 0.04116827f, -0.01838798f, 
    0.00013551f, 0.03517213f, -0.01942464f, -0.04196052f, -0.04147549f, -0.02337027f, 0.02136666f, -0.03520671f, 
    -0.02949626f, -0.00923521f, 0.02597935f, -0.00911360f, -0.01356499f, 0.01981200f, -0.01953951f, 0.01814109f, 
    0.01658918f, -0.03890610f, 0.00025976f, 0.02944775f, 0.00493386f, -0.03362705f, 0.02480889f, 0.00813820f, 
    0.02575747f, -0.00470399f, 0.02669694f, 0.00846627f, -0.00917346f, -0.01502139f, 0.00395823f, -0.03605326f, 
    0.00151869f, -0.02576925f, -0.01792897f, -0.00097708f, 0.02912198f, 0.00828586f, 0.00524353f, -0.03415706f, 
    0.02342314f, -0.02526398f, -0.03345485f, -0.01215718f, 0.01960141f, 0.02981328f, 0.00540341f, 0.00793363f, 
    0.03481426f, 0.01201648f, -0.03374439f, -0.01401565f, -0.02003958f, -0.04031202f, 0.02992865f, 0.00718660f, 
    0.00696995f, 0.02102970f, 0.02089408f, -0.02472406f, -0.02682748f, 0.02856856f, 0.03425797f, 0.01177376f, 
    -0.02594918f, 0.03070322f, -0.01127813f, -0.01143442f, -0.00499516f, -0.02972278f, -0.01328312f, -0.00367654f, 
    -0.00453811f, 0.01936602f, 0.03298033f, -0.02358469f, 0.01019362f, -0.03702980f, -0.00904936f, -0.00933194f, 
    -0.00680581f, 0.01492367f, -0.02394283f, -0.00673843f, -0.02905702f, -0.03080099f, -0.01756767f, -0.00493952f, 
    -0.01390674f, 0.00107362f, 0.03006061f, -0.01150014f, -0.04014360f, 0.01086153f, -0.01054248f, 0.02745372f, 
    0.02409777f, -0.03567544f, 0.03285937f, 0.01955781f, 0.01464128f, 0.00745431f, 0.02658644f, 0.02546330f, 
    0.02504946f, -0.00510846f, -0.03445780f, -0.03401046f, -0.00326329f, -0.00221737f, 0.02411070f, 0.02755306f, 
    -0.01586454f, 0.02771710f, 0.01259708f, -0.01592694f, 0.00911876f, -0.00277185f, 0.01273571f, 0.01624403f, 
    -0.02412499f, -0.02814208f, 0.00776722f, -0.00761488f, -0.00147589f, -0.03527720f, -0.04162520f, -0.02972908f, 
    -0.02498429f, -0.03566725f, 0.02473916f, -0.00939177f, -0.02836312f, -0.03150064f, -0.03909145f, -0.00692900f, 
    -0.03724635f, -0.01411940f, 0.00073155f, -0.02486740f, 0.02797667f, -0.03474993f, 0.00656347f, 0.00835510f, 
    -0.01162469f, 0.01902155f, -0.01908614f, -0.01147795f, -0.01743958f, -0.02290400f, -0.02093703f, -0.02206925f, 
    -0.03888843f, -0.03990319f, -0.01420650f, 0.02194033f, 0.00491190f, 0.02597310f, -0.02216724f, -0.00500747f, 
    -0.00476241f, 0.03221142f, -0.03465210f, 0.02062795f, -0.03773553f, -0.00558722f, -0.02133767f, 0.00417063f, 
    -0.00159402f, 0.01952940f, 0.00263257f, -0.00394506f, 0.02386716f, 0.01203237f, 0.00288471f, 0.02523118f, 
    -0.00659557f, -0.03071448f, 0.00110126f, 0.00527558f, -0.03915517f, -0.01870419f, -0.03000768f, -0.00377028f, 
    -0.03326475f, 0.00536839f, 0.00045655f, -0.02680660f, -0.01619739f, -0.01899274f, -0.00763509f, -0.03576099f, 
    0.01490272f, -0.03206171f, -0.02490335f, -0.00139479f, -0.02338735f, -0.00211447f, -0.04193740f, -0.01787389f, 
    0.00672827f, -0.01570716f, -0.00365170f, 0.01849147f, -0.00971285f, 0.00663405f, -0.01981600f, 0.02863590f, 
    -0.01952853f, 0.02767794f, -0.00337738f, -0.03361235f, -0.01628381f, 0.02776760f, -0.01147593f, 0.02225389f, 
    0.00337131f, 0.02342606f, 0.00965755f, 0.01306978f, 0.02850445f, 0.02865409f, 0.02959553f, -0.00156932f, 
    -0.01773963f, -0.02163941f, -0.03439723f, 0.02394273f, -0.02992132f, -0.03978284f, -0.00523714f, -0.02064062f, 
    -0.03380199f, 0.01255732f, 0.00719894f, -0.01637869f, -0.03298693f, 0.00878701f, -0.02051066f, 0.02427197f, 
    0.02200760f, -0.03456581f, -0.01584889f, 0.00642587f, -0.02132735f, -0.02525204f, 0.01665561f, -0.00816780f, 
    0.01482825f, 0.02923791f, 0.01014517f, 0.01578070f, -0.02738440f, 0.01811297f, 0.00895556f, 0.02935920f, 
    -0.00846949f, 0.00911956f, -0.03213105f, 0.00603160f, -0.01745304f, -0.01025258f, -0.00503671f, -0.03489106f, 
    0.00605582f, 0.01679862f, 0.02455538f, -0.01510537f, 0.02774949f, 0.00379265f, 0.01126656f, 0.01965907f, 
    -0.00923231f, -0.00892457f, -0.00626915f, 0.00028629f, -0.01069731f, -0.02060887f, 0.02284831f, -0.00576360f, 
    -0.01148424f, -0.00744548f, 0.01213747f, 0.02556460f, -0.00444659f, 0.00244283f, -0.04133169f, -0.00179464f, 
    -0.03678742f, -0.02536342f, -0.00866304f, -0.00111404f, -0.00036884f, -0.02917326f, 0.00873572f, 0.01242235f, 
    0.02395406f, -0.02229334f, 0.02031558f, 0.01287975f, -0.00788981f, -0.03374809f, -0.03432016f, -0.03353394f, 
    -0.00979275f, 0.02323350f, 0.00631095f, -0.03904225f, -0.03337463f, -0.00506232f, -0.00171145f, -0.04014786f, 
    -0.01831254f, -0.02435118f, -0.00430096f, -0.03358539f, -0.00685776f, -0.00447225f, 0.00021356f, -0.00447007f, 
    -0.04177364f, -0.03420639f, 0.00703762f, 0.00986281f, 0.01799886f, 0.01373665f, -0.03872692f, -0.00468644f, 
    -0.03221745f, -0.00546515f, -0.01686808f, 0.01461291f, -0.02350306f, 0.00063988f, -0.03708164f, -0.02136491f, 
    0.02655785f, 0.01530467f, -0.00907566f, 0.01032903f, 0.00185971f, 0.00975349f, -0.01033220f, 0.00356163f, 
    -0.01884553f, 0.02961477f, 0.01401011f, 0.02307198f, 0.01428209f, -0.01802775f, 0.00588250f, -0.02326813f, 
    -0.00296542f, 0.01151922f, -0.01893892f, -0.02667452f, 0.00086719f, 0.00614252f, 0.00724514f, -0.02088438f, 
    -0.00030218f, 0.03259195f, -0.01110399f, 0.00570176f, 0.02612107f, 0.00604884f, -0.00688600f, 0.03318881f, 
    0.02838786f, -0.02917766f, -0.02009995f, 0.01624977f, -0.02799259f, -0.03408239f, 0.01550331f, -0.01281365f, 
    -0.01973438f, 0.00862104f, 0.00943952f, -0.01494116f, -0.03255215f, 0.01253384f, 0.01228622f, 0.02821521f, 
    -0.02765084f, -0.02997089f, -0.01839798f, 0.00362223f, 0.01835242f, 0.01277596f, -0.00559812f, -0.01976032f, 
    -0.03703730f, -0.02388906f, 0.01650896f, 0.01852974f, -0.01650465f, 0.00156095f, 0.00862998f, -0.03564477f, 
    -0.00225761f, -0.03263251f, -0.03692112f, -0.03481470f, -0.00483814f, 0.00140160f, -0.00637870f, 0.02368577f, 
    0.02159939f, -0.00195741f, 0.02661669f, -0.00139850f, 0.01756124f, -0.00022441f, -0.02640257f, 0.00234940f, 
    -0.04170962f, 0.02584012f, -0.00136629f, 0.00053457f, 0.00350555f, -0.02303240f, 0.03027439f, -0.02875694f, 
    0.02504785f, -0.01260141f, 0.02163099f, 0.02352192f, -0.04084276f, 0.01675088f, 0.00916623f, 0.00640780f, 
    0.01375905f, -0.03902683f, -0.01991854f, 0.01714958f, -0.00955538f, -0.01180124f, -0.02771140f, -0.02620642f, 
    -0.01136942f, 0.01388222f, -0.00208242f, -0.00821922f, -0.02875225f, -0.01179886f, -0.00659688f, 0.01098971f, 
    0.03002160f, -0.02850275f, -0.03932144f, 0.00901290f, 0.01013074f, -0.04074818f, 0.01312054f, 0.01464114f, 
    -0.03185858f, -0.00238490f, 0.01243381f, 0.01059496f, -0.00700972f, -0.02337521f, -0.02927833f, -0.02984443f, 
    0.01477431f, -0.01603019f, 0.00934708f, 0.02296482f, 0.01865081f, -0.03238757f, 0.00642085f, -0.01868882f, 
    0.01290583f, -0.02838064f, -0.00756560f, -0.03954202f, -0.00366554f, -0.02257684f, 0.01175229f, -0.01766322f, 
    -0.02612488f, -0.03540377f, 0.00663503f, -0.02316851f, -0.02177954f, 0.02745055f, 0.02383607f, -0.01983004f, 
    0.03360686f, -0.03154096f, -0.00244518f, 0.01721961f, -0.02654698f, -0.02133141f, 0.01942314f, 0.00387104f, 
    -0.03553733f, -0.01371234f, -0.02984623f, -0.03332761f, -0.03206344f, -0.00311190f, 0.02613246f, 0.01392354f, 
    -0.03245653f, -0.02825049f, 0.01725927f, -0.03467948f, -0.03355417f, -0.03774512f, -0.00492283f, 0.01977342f, 
    0.02932376f, 0.01771114f, 0.02442303f, 0.00182937f, -0.03269066f, -0.01833073f, -0.03117092f, 0.01728101f, 
    -0.02232843f, -0.01894942f, -0.00098697f, -0.02469171f, 0.00459655f, -0.00128753f, 0.01142002f, -0.02681782f, 
    0.00323244f, -0.03710715f, -0.00482211f, -0.01779165f, -0.03435788f, -0.04024778f, -0.02689044f, -0.02441657f, 
    0.01617366f, -0.04169570f, 0.00561291f, -0.01974435f, -0.01722806f, -0.02661669f, 0.03200848f, 0.01652986f, 
    0.00788614f, -0.00493717f, 0.00886498f, -0.01677244f, 0.02814933f, 0.01893507f, 0.00792435f, 0.00827280f, 
    0.01450632f, -0.00007749f, -0.04166354f, 0.01682583f, -0.02727610f, -0.01900789f, 0.00755800f, 0.01153117f, 
    -0.01748155f, 0.00131870f, -0.03357014f, -0.01970347f, 0.00633078f, -0.01896100f, -0.01767497f, -0.03856357f, 
    -0.02111493f, -0.00613014f, -0.04031261f, -0.00850434f, -0.02959032f, 0.01024777f, -0.01190793f, -0.02747390f, 
    -0.01701299f, -0.03898698f, -0.03194135f, -0.01867656f, 0.00707535f, 0.01771105f, -0.03322196f, -0.01269367f, 
    0.00510714f, 0.02994371f, 0.00897025f, 0.02021137f, 0.01873454f, 0.01741814f, -0.00904150f, 0.01830309f, 
    -0.00532040f, 0.01743558f, -0.02982726f, 0.01427505f, -0.01164661f, 0.02986481f, 0.01995335f, -0.03488776f, 
    0.01526424f, -0.02246252f, 0.01643495f, 0.02150417f, 0.01958843f, -0.00980309f, -0.00833972f, -0.03037814f, 
    -0.03640433f, -0.00297327f, -0.03057888f, 0.01546508f, 0.01667574f, 0.00497049f, -0.02090102f, 0.00373635f, 
    0.02833433f, 0.02284325f, -0.04069345f, -0.02462648f, -0.01265309f, -0.00278979f, -0.02453362f, -0.03823781f, 
    0.00747818f, 0.01778713f, -0.02070500f, -0.01380789f, -0.00744268f, 0.01846032f, 0.01803798f, -0.01167103f, 
    0.03268341f, 0.02318720f, 0.02763304f, 0.00363058f, -0.02899341f, -0.03520362f, -0.04148418f, -0.00266401f, 
    -0.03580377f, 0.01744456f, -0.01952473f, -0.01340322f, -0.00290445f, 0.02882173f, 0.01143792f, 0.01637434f, 
    -0.02300411f, 0.01819997f, -0.02335442f, -0.00533033f, -0.01299526f, -0.02797398f, -0.03548615f, -0.02052367f, 
    0.02592165f, 0.00268686f, 0.00282403f, -0.01522780f, 0.00829447f, -0.01490913f, 0.01078430f, 0.01336741f, 
    0.01515369f, -0.00512759f, -0.02543781f, 0.02202653f, -0.00750601f, 0.00822025f, 0.02545945f, -0.03990787f, 
    0.01106495f, -0.02080762f, -0.03694071f, 0.02624931f, -0.00974076f, 0.01738588f, -0.03135899f, 0.00353030f, 
    0.01013183f, 0.01966400f, -0.01049829f, -0.01939858f, -0.03321951f, -0.02523674f, -0.03037286f, -0.03945014f, 
    -0.03634974f, 0.02973781f, -0.01407490f, -0.03196899f, 0.01789474f, -0.02913986f, -0.01283946f, 0.00184097f, 
    0.00404124f, 0.00372537f, 0.01781784f, -0.00079465f, 0.01947946f, -0.00266374f, -0.00860552f, -0.01565033f, 
    0.00549502f, -0.00936775f, -0.03009897f, 0.02626315f, -0.01669322f, -0.04095651f, 0.02593670f, 0.00831707f, 
    -0.03323488f, 0.00650146f, -0.01652291f, -0.02721677f, -0.04189901f, -0.00361576f, 0.00189151f, 0.01348159f, 
    0.01610570f, -0.03281974f, -0.01846845f, -0.04081875f, -0.03298644f, 0.02053237f, -0.00185816f, -0.03963086f, 
    -0.02419475f, -0.02091841f, -0.03892243f, -0.03514455f, 0.00808722f, -0.03201191f, -0.03584699f, 0.02159586f, 
    0.02657300f, 0.02463916f, -0.03425071f, 0.01347239f, -0.00049625f, -0.00542263f, -0.00258530f, -0.02311064f, 
    -0.02235463f, -0.02266418f, 0.02616399f, 0.01730809f, -0.00490505f, 0.03386927f, -0.01257858f, -0.03387977f, 
    -0.02964886f, 0.01541111f, 0.01043179f, -0.02751414f, -0.01921282f, 0.00720058f, -0.00747255f, 0.00034565f, 
    0.02094135f, -0.00319074f, 0.01511209f, -0.01353430f, -0.03003274f, -0.03840961f, 0.01299411f, -0.01044584f, 
    -0.00006887f, 0.00119965f, 0.00587090f, -0.00462770f, -0.03276327f, -0.00434942f, 0.02259529f, -0.00330085f, 
    -0.01172220f, -0.02932176f, -0.01164300f, 0.00730840f, -0.00198481f, -0.02067471f, 0.01288331f, 0.01217225f, 
    0.01766580f, -0.00644136f, 0.01590032f, -0.00429787f, -0.00694241f, -0.02101597f, 0.01096924f, -0.01376899f, 
    0.00587690f, 0.02798536f, -0.03711823f, 0.02563852f, -0.03320281f, -0.04050061f, 0.01546161f, 0.01771602f, 
    -0.01937892f, -0.00753828f, 0.02768025f, 0.00549797f, -0.00537790f, -0.01748990f, 0.00456916f, 0.01213996f, 
    -0.03423605f, 0.01420389f, 0.02180950f, 0.02686628f, 0.00887049f, -0.01516243f, -0.04176998f, 0.00962721f, 
    -0.03866184f, -0.00412918f, 0.01668343f, -0.02521660f, -0.03075479f, -0.02339191f, 0.02117488f, -0.01844794f, 
    0.00429107f, 0.01189500f, 0.03154491f, -0.00990796f, -0.02089901f, 0.02624120f, -0.00196020f, -0.00767297f, 
    -0.02958561f, -0.03215130f, 0.00746526f, -0.02242798f, 0.00014765f, -0.03509131f, -0.00613752f, -0.03450891f, 
    0.02592615f, -0.01475245f, -0.00097521f, -0.03474420f, -0.04328602f, 0.02831512f, 0.02590496f, -0.00706190f, 
    0.01946716f, -0.02339040f, 0.00150115f, 0.02386664f, 0.02562805f, 0.00833938f, -0.04165095f, 0.02897792f, 
    -0.00572247f, -0.00388559f, -0.03830367f, -0.00354497f, 0.01206661f, 0.00194015f, -0.02130440f, 0.00391035f, 
    -0.02904808f, 0.02496713f, 0.00702742f, -0.03688239f, 0.02148014f, -0.01212616f, 0.02176866f, 0.02407663f, 
    0.01848596f, -0.03337535f, 0.01095150f, -0.00409392f, 0.01488979f, 0.02577011f, -0.01380262f, -0.04007298f, 
    -0.03508694f, 0.02124586f, -0.00368449f, -0.01562833f, 0.01281087f, -0.03347388f, 0.03113148f, -0.03973895f, 
    0.01692571f, 0.03742994f, 0.00542379f, 0.03365126f, -0.00586672f, -0.01257307f, 0.01676878f, -0.01897606f, 
    -0.00665341f, -0.03488767f, -0.01461675f, 0.01198630f, -0.03128821f, -0.02704063f, -0.01263026f, 0.02753603f, 
    0.01844143f, -0.00445415f, 0.00966090f, -0.04090932f, 0.01578907f, -0.02769453f, 0.00208310f, -0.01146352f, 
    0.01208091f, 0.00328167f, -0.01052828f, -0.03036349f, -0.02541263f, 0.02302351f, -0.02553019f, -0.03130841f, 
    -0.02870013f, 0.00876814f, 0.00932173f, 0.01288275f, 0.02083973f, -0.00355772f, 0.01278643f, -0.00702600f, 
    -0.02274379f, 0.01068927f, -0.01340591f, -0.04173451f, 0.02538085f, 0.02617371f, 0.01674360f, -0.02098201f, 
    0.01411106f, 0.03731680f, -0.02844669f, -0.00358002f, 0.01126000f, 0.00913595f, -0.02797852f, 0.01284885f, 
    0.02894505f, 0.00269899f, -0.00434022f, -0.02369305f, -0.03191995f, -0.00148746f, -0.02240288f, -0.02335207f, 
    -0.03124414f, 0.01355305f, -0.00167623f, -0.00447512f, -0.00857069f, 0.01058504f, -0.04231113f, -0.00457492f, 
    -0.03123603f, -0.00189345f, 0.00397427f, 0.00353218f, 0.00192512f, 0.00476254f, 0.01954823f, -0.03123256f, 
    -0.02862062f, 0.02498654f, -0.03498074f, 0.02949397f, -0.02747342f, 0.02384690f, -0.01169770f, -0.02680511f, 
    -0.04349118f, -0.03015219f, -0.01848380f, -0.03072384f, 0.00317284f, 0.01834985f, -0.00543190f, -0.02013901f, 
    -0.03594175f, -0.00603071f, -0.02224480f, -0.03620964f, -0.01996384f, 0.02400681f, 0.02016601f, 0.02726479f, 
    -0.03022612f, -0.02741864f, 0.01675432f, -0.01345503f, -0.01150213f, 0.02023222f, 0.01382238f, 0.02748684f, 
    0.02359418f, 0.02450506f, -0.02148219f, -0.00868392f, -0.01251731f, 0.01509568f, -0.00642915f, 0.00304614f, 
    0.00719382f, 0.00509352f, -0.00547363f, 0.01877202f, -0.01251170f, 0.02243814f, -0.01330136f, -0.01668963f, 
    -0.01591366f, -0.02554417f, -0.01693753f, 0.01644343f, 0.01514912f, -0.04058554f, -0.01208613f, -0.04274524f, 
    -0.02616839f, -0.00547470f, 0.02532480f, -0.00905036f, -0.02402006f, 0.00488661f, -0.02043863f, -0.03109465f, 
    -0.01023494f, -0.02097217f, -0.03392021f, 0.00350051f, -0.00464291f, 0.00701982f, -0.03826590f, 0.01572672f, 
    -0.02393841f, 0.03097660f, 0.00416397f, 0.01311437f, 0.01170942f, -0.00052835f, 0.01471290f, 0.03856391f, 
    -0.01891601f, 0.02410639f, 0.00827563f, -0.03017348f, -0.02526626f, -0.03626788f, -0.00337029f, -0.04418430f, 
    -0.01163785f, -0.02211185f, -0.00437237f, -0.00772329f, 0.01594208f, -0.00929730f, -0.01132042f, 0.02768906f, 
    0.02720738f, -0.02724262f, 0.01036849f, -0.03799201f, -0.03438161f, -0.01205097f, -0.01571026f, -0.00067915f, 
    0.02344131f, -0.00741984f, -0.00574468f, -0.00456669f, 0.01731129f, 0.01810988f, -0.00835827f, 0.02371809f, 
    -0.01010734f, 0.00561496f, 0.02188635f, -0.00145172f, -0.00167651f, 0.00267885f, -0.04267733f, -0.03507492f, 
    0.00596243f, 0.00832282f, 0.00237716f, 0.02716934f, -0.02204096f, -0.02012539f, -0.04071676f, -0.00480399f, 
    0.01545528f, 0.01036812f, -0.03978693f, -0.02604413f, 0.02104010f, 0.00843623f, -0.03969609f, -0.01012158f, 
    0.00636927f, -0.00031967f, 0.01033529f, 0.01064895f, -0.01266874f, -0.02417918f, 0.01543907f, -0.01335061f, 
    -0.00084967f, 0.04085626f, -0.02752810f, 0.03182404f, 0.01795046f, 0.00520909f, -0.01635861f, -0.03390937f, 
    0.00548387f, 0.02139953f, 0.00840387f, -0.03216496f, -0.01516187f, -0.00606881f, -0.01084279f, -0.03042453f, 
    -0.00582604f, -0.02143361f, 0.01456659f, -0.00248588f, -0.02318740f, -0.01119948f, -0.01915793f, -0.02162159f, 
    -0.02363366f, 0.00517214f, -0.01459863f, 0.02023735f, -0.03244989f, 0.02201859f, -0.00812741f, -0.03641053f, 
    -0.03970193f, -0.01994411f, -0.01575724f, -0.00215589f, 0.01141852f, 0.01433029f, -0.02262919f, -0.01284682f, 
    0.01037512f, 0.03384212f, -0.02942356f, 0.01120527f, 0.01698974f, 0.01590339f, 0.00541151f, -0.02562855f, 
    -0.02257035f, 0.00243724f, -0.00873835f, -0.01671203f, -0.00183692f, 0.02212257f, -0.01228954f, 0.01893368f, 
    -0.00325742f, 0.00651564f, 0.00123686f, -0.00041809f, 0.01904555f, -0.04161138f, -0.04191521f, 0.01767997f, 
    -0.02158256f, -0.00156997f, -0.03908306f, 0.01712729f, -0.00333138f, -0.00008077f, 0.03190245f, 0.00487832f, 
    0.01735287f, 0.02730818f, -0.03068108f, 0.01347943f, -0.00008720f, -0.04334143f, 0.01001055f, -0.02843148f, 
    -0.02001606f, -0.02845674f, 0.00280211f, -0.01220813f, -0.04020780f, -0.02432059f, -0.02833072f, -0.03010249f, 
    -0.01516073f, -0.00332859f, -0.00736322f, 0.02858963f, 0.01816681f, -0.03175601f, -0.01675847f, -0.01249277f, 
    -0.01831087f, -0.02108282f, 0.01023825f, -0.00920511f, -0.02450334f, 0.00984165f, 0.00261982f, -0.02921308f, 
    0.02470942f, 0.02449495f, -0.03835135f, -0.02884217f, -0.01161344f, -0.02218177f, -0.02957882f, -0.03453294f, 
    -0.02341235f, -0.01155987f, -0.01793287f, 0.00175874f, 0.00881536f, 0.00732335f, 0.01799974f, -0.01728720f, 
    -0.02891813f, 0.01752490f, -0.04260118f, -0.02607398f, 0.02641294f, 0.00139178f, -0.00618209f, -0.00413150f, 
    -0.02364518f, 0.01736423f, -0.03902121f, -0.04313444f, -0.01221919f, -0.02408233f, 0.01439200f, 0.02325787f, 
    0.03536969f, 0.03272345f, 0.02299955f, 0.02082786f, -0.03450005f, 0.02050752f, -0.00116762f, -0.01902701f, 
    -0.02284968f, 0.00797885f, -0.01283933f, 0.01162319f, 0.02516522f, -0.01122367f, -0.04093583f, 0.01814465f, 
    -0.00315378f, -0.02488477f, 0.01009968f, -0.01239788f, -0.00571135f, 0.02656853f, -0.00121123f, -0.03239728f, 
    -0.03399414f, 0.02478378f, -0.02544265f, 0.01094633f, -0.01893137f, -0.02437597f, 0.01035760f, 0.01692305f, 
    -0.00859648f, 0.02771682f, -0.00719776f, -0.01025763f, -0.01678482f, 0.01994083f, -0.01851362f, 0.02400034f, 
    -0.03850929f, 0.01757564f, -0.03606404f, -0.01342668f, 0.03487596f, -0.03732175f, -0.01182584f, -0.03169504f, 
    0.01925947f, 0.01447569f, 0.02546530f, 0.01894453f, -0.03651299f, 0.00513875f, 0.00886256f, -0.01001015f, 
    -0.01376876f, -0.01695221f, -0.03810199f, 0.01384090f, 0.01749218f, -0.02710887f, -0.03452383f, 0.00805974f, 
    -0.02394729f, -0.02779063f, -0.04423417f, -0.02546835f, 0.01095964f, 0.02201527f, 0.01884507f, -0.00902595f, 
    0.03935567f, 0.01394793f, -0.02112492f, 0.01229459f, -0.00545673f, 0.00720485f, -0.00309928f, -0.02808626f, 
    0.02443060f, -0.01202261f, -0.01477665f, 0.03283495f, 0.00685109f, -0.02478559f, 0.02609277f, 0.02814383f, 
    0.01238164f, 0.01386133f, -0.00865933f, -0.03444044f, 0.00125626f, 0.02111330f, 0.01227584f, 0.02566969f, 
    -0.01598066f, -0.03040698f, -0.01766720f, 0.03388765f, 0.01773528f, -0.02804968f, -0.01802537f, -0.02152546f, 
    0.02261625f, 0.02767663f, -0.02812616f, 0.00950756f, 0.00849155f, -0.01790308f, 0.02140232f, 0.00973405f, 
    0.02432339f, -0.02809838f, -0.00353914f, 0.01609412f, 0.02127940f, -0.00109819f, 0.00148456f, 0.01492344f, 
    -0.00091110f, -0.00298764f, -0.02594120f, -0.02904582f, -0.02513962f, 0.03576820f, 0.01012935f, -0.02334456f, 
    -0.00755047f, -0.00307764f, 0.02971467f, -0.02009475f, -0.01990059f, -0.00755495f, -0.02486184f, 0.00691983f, 
    0.00226735f, 0.02253706f, -0.00541869f, 0.00931256f, -0.00804990f, -0.01910956f, -0.02132982f, -0.04180755f, 
    0.03347415f, 0.03225176f, 0.01123724f, -0.03041512f, -0.01179160f, -0.03421286f, 0.00119473f, -0.00281793f, 
    0.02831874f, 0.02075404f, 0.00409234f, -0.02639164f, -0.03122710f, 0.01639763f, -0.03648685f, 0.02320464f, 
    0.01606068f, -0.00717500f, 0.02195942f, -0.01365596f, -0.03813252f, -0.03466024f, 0.01819555f, 0.00254923f, 
    -0.02184163f, 0.02034205f, 0.01517485f, 0.00524043f, -0.00895533f, 0.01628502f, 0.01182927f, -0.01137460f, 
    -0.00844187f, -0.02437602f, -0.02767705f, -0.02332140f, 0.02010975f, 0.00104316f, -0.02827246f, -0.01115542f, 
    0.00633178f, 0.01431034f, -0.00074018f, -0.00883397f, -0.03118240f, 0.02489197f, -0.03179095f, -0.03787175f, 
    0.00543728f, 0.00035260f, -0.03265596f, -0.04086319f, -0.03686127f, -0.00133777f, -0.03060080f, 0.03329593f, 
    -0.03793982f, -0.02279408f, -0.02810434f, 0.02217123f, -0.02622303f, -0.00801527f, 0.01741133f, -0.00966553f, 
    -0.02702945f, 0.01720182f, 0.02683631f, 0.02686320f, 0.01737810f, 0.02479268f, -0.00011335f, -0.00097394f, 
    0.00633229f, 0.00844615f, 0.02286358f, 0.01712660f, -0.03975614f, 0.00629294f, -0.03168986f, 0.00282601f, 
    -0.02261635f, 0.01329315f, 0.00145750f, -0.00837565f, -0.00826886f, 0.02642108f, 0.02475397f, -0.03451107f, 
    0.00701290f, -0.01078870f, -0.03567068f, -0.03584655f, -0.03996575f, 0.02141186f, 0.00024616f, -0.00999446f, 
    -0.00519774f, -0.01034412f, -0.03018832f, 0.00687338f, -0.02196004f, -0.00466475f, 0.02489404f, -0.01090089f, 
    -0.02251510f, 0.00133961f, 0.01695729f, -0.03700398f, -0.02477770f, 0.01889862f, -0.03632215f, -0.00034862f, 
    0.02392181f, -0.03545443f, -0.03642735f, -0.02201230f, -0.02512341f, -0.01482438f, 0.00788043f, 0.02001163f, 
    0.01267703f, 0.00008393f, 0.02724932f, -0.02358853f, -0.01354145f, -0.03230144f, -0.00675836f, 0.01196668f, 
    -0.02123764f, 0.01617699f, -0.01210039f, -0.03569913f, 0.00602182f, 0.03708644f, -0.00478602f, 0.00632164f, 
    0.00351928f, 0.02937360f, 0.01323383f, -0.04282184f, -0.02325074f, 0.00775090f, -0.02435880f, -0.00709074f, 
    -0.02272544f, 0.00123512f, 0.00190563f, -0.01122233f, -0.01640058f, 0.02534851f, -0.03347155f, 0.02681844f, 
    0.01945355f, 0.03423133f, 0.00857038f, 0.00576114f, -0.01480911f, 0.00519585f, 0.01986273f, -0.00433071f, 
    -0.00454010f, 0.00436602f, 0.01701611f, 0.01754191f, -0.02990255f, -0.00559475f, -0.03264517f, -0.02658895f, 
    0.01975051f, 0.00114667f, -0.00125883f, -0.02364478f, 0.00591628f, -0.03706172f, -0.00632604f, -0.04048795f, 
    -0.03100582f, 0.00525901f, -0.02146825f, -0.01197660f, -0.00450138f, 0.01967400f, 0.01213109f, -0.03749025f, 
    -0.01690846f, -0.01334949f, -0.03473639f, 0.02379199f, -0.01908196f, -0.01552294f, -0.03403264f, -0.03307471f, 
    -0.01303134f, -0.02147843f, 0.01001037f, -0.03115124f, -0.02611062f, -0.02479903f, -0.03638931f, 0.02236870f, 
    0.00399505f, -0.01999266f, -0.04252319f, -0.03153930f, -0.01152099f, 0.01994879f, -0.02158847f, -0.00961461f, 
    -0.02649330f, -0.00480130f, -0.00390876f, -0.00603041f, 0.02107172f, -0.03691538f, 0.00660375f, -0.01959720f, 
    0.00387163f, -0.12920122f, -0.03232516f, 0.18949044f, 0.09664054f, 0.01965282f, -0.00754369f, -0.02082180f, 
    0.14830266f, 0.00255322f, 0.12250546f, 0.07681902f, -0.02302114f, 0.00681671f, -0.12186048f, -0.15848809f, 
    -0.01839327f, 0.19748804f, 0.13255209f, 0.20863372f, 0.07768767f, 0.08524404f, 0.05743058f, 0.11434592f, 
    0.06769719f, 0.26535740f, 0.02066517f, 0.01424044f, -0.12912852f, -0.13662635f, -0.01878138f, -0.04777295f, 
    -0.02749537f, -0.00719230f, 0.00397382f, 0.14551131f, 0.04135440f, -0.01002393f, 0.11503997f, -0.11943099f, 
    -0.03644784f, 0.02593912f, -0.11863426f, 0.02738975f, 0.05712420f, 0.11637160f, 0.27190715f, 0.10284602f, 
    0.03549045f, 0.04718014f, -0.06083645f, -0.05031393f, 0.01483721f, -0.02427637f, -0.11967216f, 0.09394790f, 
    -0.12929615f, -0.03291940f, 0.01522783f, 0.04775484f, -0.12852153f, 0.05887681f, -0.09173979f, -0.12686364f, 
    -0.02391672f, 0.13778506f, 0.13389118f, 0.06242022f, 0.02672107f, 0.05135421f, 0.09963372f, 0.06328127f, 
    0.05733814f, 0.00268792f, 0.03077020f, 0.07544445f, 0.11566009f, 0.08699506f, -0.00068324f, 0.11109067f, 
    0.07528654f, 0.07114401f, 0.01046685f, 0.06338286f, -0.00390463f, 0.12666000f, -0.14337766f, -0.06742577f, 
    0.00823125f, 0.09316410f, 0.03891324f, -0.23234452f, 0.16469254f, 0.09109844f, 0.06177532f, 0.28624830f, 
    -0.00956544f, 0.08062205f, -0.15350631f, -0.03546524f, -0.04239484f, 0.19585136f, 0.14438790f, 0.14775956f, 
    0.09903953f, 0.00581761f, 0.03193798f, 0.08464320f, -0.03275176f, -0.10723954f, -0.07680477f, -0.03349160f, 
    -0.00116583f, 0.12852889f, 0.00047381f, 0.00438205f, 0.14627637f, -0.10982621f, -0.02536525f, 0.08579635f, 
    -0.05128836f, 0.19266988f, 0.19718109f, 0.13691472f, -0.07275375f, -0.18447958f, -0.06802936f, -0.16481267f, 
    -0.07040714f, -0.07324071f, -0.04435970f, 0.01415645f, 0.22062120f, 0.28659287f, -0.14672743f, -0.20572028f, 
    0.02953346f, 0.05983035f, 0.00697167f, 0.05112920f, -0.03259171f, -0.11571760f, -0.15201883f, -0.01084707f, 
    0.14090139f, 0.05741875f, 0.04911248f, -0.06467583f, -0.10999621f, -0.09698112f, -0.01867142f, -0.09399249f, 
    -0.01178192f, 0.06489773f, -0.00188878f, 0.15104656f, -0.13408285f, -0.02966941f, -0.01877573f, -0.03552011f, 
    -0.06026476f, -0.13653712f, 0.03652048f, -0.13752259f, 0.04389473f, 0.06087646f, 0.05777362f, 0.07031442f, 
    0.11975198f, -0.31324422f, 0.21048650f, 0.20333993f, -0.01848855f, -0.13134307f, 0.09440180f, 0.17749199f, 
    0.02914278f, -0.05199294f, -0.18658639f, -0.21004243f, -0.03132106f, -0.08909836f, 0.09837398f, -0.03718702f, 
    -0.07315242f, -0.04960613f, 0.04551716f, 0.06920975f, -0.06642476f, 0.02105780f, -0.03944657f, 0.04356654f, 
    0.00465882f, -0.09235942f, -0.08088546f, -0.09486867f, -0.00632182f, 0.12244595f, -0.07396407f, 0.14970684f, 
    -0.06648985f, 0.01431425f, -0.01627631f, -0.04213122f, -0.20647919f, -0.09917664f, -0.09669555f, -0.08310822f, 
    0.10081982f, 0.02810123f, 0.06394179f, -0.05223045f, -0.18910728f, -0.05573273f, 0.03664668f, 0.07351298f, 
    0.11159810f, 0.12335999f, -0.13847533f, 0.13430400f, 0.04180790f, 0.13670190f, 0.06323758f, -0.01679733f, 
    0.08976113f, -0.04880734f, -0.06901696f, -0.06390080f, -0.01295474f, -0.04135375f, -0.03058002f, -0.01707726f, 
    0.14484203f, -0.02988397f, 0.09941741f, 0.03178150f, 0.12865649f, 0.14274551f, 0.06300770f, 0.06528480f, 
    -0.09757590f, 0.20400462f, -0.13132848f, -0.26552749f, 0.07189906f, -0.02167738f, 0.26539961f, 0.10530964f, 
    -0.03806437f, 0.06288708f, -0.06072636f, 0.07835569f, 0.32025456f, 0.03394789f, -0.11032099f, -0.15273681f, 
    -0.11715531f, 0.00586741f, 0.05511381f, 0.08276795f, -0.00959329f, -0.04377170f, -0.06635560f, -0.34381941f, 
    -0.01375818f, 0.02029352f, -0.11540906f, -0.08546509f, 0.05269419f, -0.00293115f, 0.02292989f, -0.16409951f, 
    -0.07992793f, -0.05140070f, -0.01378930f, 0.16753520f, 0.10646018f, 0.10597295f, -0.02041315f, -0.01925226f, 
    0.10545586f, 0.12466077f, 0.05965210f, 0.03253684f, -0.02433337f, 0.07113712f, -0.04120615f, -0.07320765f, 
    0.01666115f, 0.10021540f, -0.03005791f, -0.03748783f, -0.08041506f, 0.01348745f, 0.03117600f, -0.11788115f, 
    0.06814313f, -0.16582711f, 0.11119751f, 0.14348015f, 0.17673558f, -0.06976990f, 0.07221581f, -0.14838372f, 
    -0.18774581f, -0.04908997f, -0.04925886f, 0.04584158f, 0.14973475f, 0.06330542f, 0.07155306f, 0.15615322f, 
    -0.09903579f, 0.05880063f, -0.17310901f, -0.15012270f, -0.07713029f, 0.08838941f, 0.00945463f, 0.06023494f, 
    0.12269419f, 0.14437179f, 0.09429162f, -0.01332529f, 0.09926372f, 0.17025611f, 0.12503622f, 0.05979367f, 
    -0.05780179f, -0.16971353f, -0.09410031f, -0.02047342f, -0.03980835f, 0.03904227f, -0.02482532f, -0.03517792f, 
    -0.05866818f, 0.40614986f, -0.25430521f, 0.17429392f, -0.07862160f, -0.02096852f, -0.06269341f, -0.30520108f, 
    -0.02697197f, 0.01483471f, -0.05510592f, -0.01347035f, 0.07443027f, 0.16744271f, 0.15467250f, -0.00722625f, 
    -0.09758633f, 0.03599856f, 0.01871887f, -0.09137771f, 0.25798529f, 0.10043727f, 0.09148499f, 0.09504297f, 
    -0.01033953f, 0.24886520f, 0.00153520f, -0.12415019f, 0.08458548f, -0.10081893f, 0.04904951f, -0.10133050f, 
    -0.08767731f, -0.09001717f, 0.00702248f, 0.04047687f, -0.01358262f, -0.00785648f, -0.09942676f, -0.19874205f, 
    -0.06068433f, 0.07606427f, -0.03310051f, -0.00662811f, -0.00033905f, -0.08635969f, 0.09011962f, 0.07041873f, 
    -0.08066439f, 0.00411788f, 0.05361030f, 0.01671412f, -0.07132924f, -0.10683024f, -0.12734620f, -0.09117732f, 
    -0.06961219f, -0.07366619f, 0.01932674f, -0.17932194f, 0.05482230f, 0.03779421f, -0.19059406f, 0.21940394f, 
    -0.00613306f, 0.06882909f, 0.28897005f, -0.20314406f, -0.01807426f, 0.00593309f, -0.02917843f, 0.13259579f, 
    0.09166878f, -0.06578195f, 0.08034473f, -0.08911972f, 0.20710698f, -0.03519545f, -0.02671107f, 0.00455925f, 
    -0.04436848f, -0.03311418f, -0.07846452f, -0.02748859f, -0.02894896f, -0.21564476f, -0.04981491f, -0.07995839f, 
    0.11674287f, -0.05052205f, 0.10963416f, 0.01121363f, -0.03789310f, 0.00346791f, 0.07440434f, 0.16181031f, 
    -0.12188416f, -0.13899368f, -0.10850304f, -0.21221519f, -0.07719304f, 0.08565966f, 0.03184146f, 0.19695826f, 
    0.08870768f, 0.14004377f, 0.03593504f, 0.11747524f, -0.12429887f, -0.05679748f, -0.03794426f, -0.14253405f, 
    0.00835368f, -0.07682618f, 0.01661755f, -0.02842857f, -0.00942164f, 0.05157478f, 0.11666733f, 0.13474804f, 
    0.08781038f, 0.05953981f, 0.31003174f, 0.02015655f, 0.01649714f, -0.09746804f, -0.02448332f, 0.02084122f, 
    0.02597185f, 0.02718564f, -0.01744622f, -0.11503760f, 0.06454332f, -0.08062187f, -0.16072400f, 0.06497605f, 
    0.01804795f, 0.07808544f, -0.05958473f, 0.13018033f, 0.00434390f, -0.00133135f, 0.17432977f, -0.06720439f, 
    0.01160278f, -0.05592467f, 0.03964476f, 0.08058695f, 0.11838678f, 0.12083553f, -0.01569515f, 0.32076713f, 
    -0.02178425f, 0.12954900f, -0.00727043f, 0.14303371f, 0.23792788f, 0.23973614f, 0.14115778f, -0.07649037f, 
    -0.12018897f, -0.02090473f, -0.04344081f, 0.04638896f, 0.21144529f, -0.10612016f, 0.10109180f, 0.09443808f, 
    0.33813229f, 0.20553403f, 0.00618017f, -0.06213370f, -0.05834551f, -0.02181025f, 0.03936243f, 0.07117388f, 
    0.01159601f, -0.04696180f, -0.17891683f, -0.14047666f, 0.11802772f, -0.07692432f, 0.02778269f, -0.09475560f, 
    0.06304110f, 0.11861852f, 0.13743904f, 0.22974607f, -0.17802799f, -0.13701011f, -0.12905419f, -0.07712008f, 
    0.26375672f, 0.33430868f, -0.24115859f, -0.10551851f, -0.05917468f, 0.02851690f, 0.08466468f, -0.05212715f, 
    -0.01875297f, -0.10332325f, 0.03781145f, -0.15540937f, -0.14875996f, -0.10423284f, 0.02187664f, -0.01523386f, 
    0.08233944f, -0.00422734f, -0.01572912f, -0.05002818f, 0.19448340f, 0.17239173f, 0.14889826f, 0.23610090f, 
    0.19794808f, 0.09455727f, 0.09084156f, -0.00394458f, 0.10689131f, 0.06712727f, -0.05305190f, 0.38915437f, 
    0.06639705f, -0.00758791f, -0.08474887f, -0.06231086f, 0.16371791f, 0.10181347f, -0.08667822f, -0.16797641f, 
    0.16219114f, 0.16184655f, 0.21903831f, 0.19930619f, 0.05744707f, 0.04467975f, 0.02104618f, -0.01581853f, 
    0.04139204f, -0.03700021f, 0.01272161f, 0.07091346f, -0.02713864f, -0.01183074f, -0.06249904f, 0.10074589f, 
    -0.06986055f, -0.20159140f, -0.19440648f, -0.17412120f, 0.01865048f, -0.03355580f, -0.07938135f, 0.09003596f, 
    -0.00480717f, 0.00939845f, -0.02706027f, -0.08692120f, 0.05941747f, -0.00304667f, 0.01383104f, 0.12572284f, 
    0.01347678f, 0.01034861f, -0.09829651f, -0.23698434f, -0.08404374f, -0.05097691f, -0.05451516f, -0.06901812f, 
    0.08075473f, -0.08000410f, 0.06227256f, -0.08559384f, -0.12817776f, 0.05966723f, -0.06572631f, -0.12176477f, 
    -0.06638592f, 0.01988463f, -0.07738766f, 0.08750691f, 0.04482250f, -0.09898408f, -0.00902313f, 0.04854365f, 
    0.02370996f, -0.10050694f, 0.11259392f, -0.01689511f, 0.17531303f, 0.09545303f, 0.09112155f, 0.10913008f, 
    -0.09449571f, 0.00657773f, 0.05873233f, -0.11952391f, 0.04293092f, 0.12972483f, 0.01696423f, 0.07914884f, 
    -0.07573120f, -0.04283813f, -0.02051177f, -0.00273817f, 0.03790588f, 0.01494152f, 0.03298505f, 0.02913525f, 
    0.04199157f, 0.30829495f, 0.12682667f, -0.08839488f, 0.00801798f, -0.00186417f, -0.06288768f, 0.00626436f, 
    -0.00124970f, -0.05282357f, -0.03519613f, 0.06049561f, -0.06993941f, -0.05521611f, -0.01207439f, -0.08273678f, 
    0.14055620f, 0.08888179f, -0.11148011f, 0.02435421f, -0.19394341f, -0.03920641f, -0.12386365f, -0.30411911f, 
    0.14398740f, 0.10238000f, 0.19206490f, 0.06960505f, -0.06812566f, -0.08084661f, -0.10245938f, -0.14162473f, 
    -0.07325806f, -0.12483821f, -0.04526893f, -0.29350856f, -0.13679466f, -0.02012728f, -0.29220095f, -0.16567373f, 
    0.09792453f, 0.06756112f, 0.04228157f, 0.05739113f, 0.01488216f, -0.04593621f, -0.03936631f, 0.06760908f, 
    -0.03575495f, -0.09763123f, 0.05113494f, -0.08917722f, 0.09883307f, -0.04994849f, -0.02719128f, 0.00829445f, 
    0.15484232f, 0.03600617f, -0.00597012f, 0.06345259f, -0.08654969f, 0.01054471f, 0.11153717f, -0.13324644f, 
    -0.05410814f, 0.18812263f, 0.08814224f, 0.04791909f, 0.09283218f, 0.01386143f, 0.13473870f, 0.04228165f, 
    0.41643038f, 0.29821774f, 0.18313730f, -0.00336084f, 0.00018738f, -0.04158320f, 0.02978998f, 0.01087895f, 
    0.00670230f, -0.03528640f, 0.05470206f, 0.04131060f, 0.10903553f, 0.31130263f, 0.18350635f, 0.05873816f, 
    -0.03109581f, 0.08381236f, -0.07718535f, -0.10581461f, 0.15601128f, 0.02630314f, 0.13881443f, 0.06912962f, 
    0.01499894f, 0.02380263f, -0.05714528f, -0.46754590f, -0.05946675f, 0.04410633f, 0.04402547f, 0.03501181f, 
    0.01504039f, -0.05941420f, -0.15148573f, 0.01351515f, -0.04318190f, 0.04049161f, 0.06252964f, -0.07134927f, 
    -0.04521177f, -0.08134612f, -0.00591531f, -0.02911691f, 0.20760697f, 0.07402045f, 0.05356353f, 0.14421144f, 
    -0.03463842f, 0.02341329f, -0.02918354f, 0.00355978f, 0.02507499f, -0.03277782f, -0.01790378f, -0.02959535f, 
    -0.02948492f, -0.02621108f, 0.02811460f, -0.03668370f, 0.02279047f, 0.03009972f, 0.02677322f, -0.01321892f, 
    -0.00684762f, -0.03373704f, 0.02034774f, -0.03405624f, 0.02713690f, -0.00633639f, 0.02612445f, -0.01115829f, 
    0.00065185f, -0.03611438f, 0.01005523f, 0.02519418f, -0.03484568f, -0.00607445f, 0.00432803f, -0.03940528f, 
    -0.02528009f, 0.02876209f, 0.00856560f, -0.04033625f, 0.01867473f, 0.02121722f, -0.03019546f, -0.02671310f, 
    0.02174759f, -0.03473705f, -0.02938733f, -0.02569867f, 0.00313349f, -0.01727914f, -0.01821749f, -0.03001177f, 
    -0.03282840f, -0.00381337f, 0.02213299f, -0.01996309f, 0.00929554f, 0.02583922f, -0.01311951f, -0.03757414f, 
    0.01383734f, 0.01644276f, -0.02881145f, -0.00396551f, -0.01850216f, 0.02682087f, -0.03749588f, -0.00570860f, 
    0.02745086f, -0.03310378f, 0.00990972f, -0.00426369f, -0.03404605f, -0.02339702f, 0.01107487f, 0.01455636f, 
    0.02908674f, 0.01181703f, 0.01753369f, 0.02250702f, -0.00825275f, -0.00806848f, 0.02526889f, -0.03578786f, 
    -0.03557377f, 0.01310453f, 0.01843116f, 0.02563035f, 0.00063393f, -0.02049792f, 0.01217184f, -0.01866296f, 
    -0.02902541f, -0.02373818f, -0.00111696f, 0.02842041f, -0.01138162f, -0.01866204f, 0.00847739f, 0.01352410f, 
    -0.00243158f, 0.02513271f, -0.00963432f, 0.01617286f, -0.01249127f, -0.00846562f, 0.02860483f, -0.00864403f, 
    -0.03459044f, -0.00374212f, -0.02531846f, 0.01736224f, 0.01168228f, 0.02037194f, 0.00422576f, -0.04118850f, 
    -0.03404735f, -0.02324689f, -0.03127306f, -0.00208403f, -0.00238224f, 0.01361994f, -0.03316909f, 0.03100204f, 
    -0.01779069f, -0.02151557f, 0.00834907f, 0.00009765f, -0.02813474f, 0.01252212f, -0.03223050f, -0.03468858f, 
    -0.01589936f, -0.02720033f, 0.01580964f, -0.01966212f, 0.02316995f, 0.00245764f, -0.03602137f, -0.02085975f, 
    0.01850306f, -0.00783345f, 0.02743741f, -0.02720517f, 0.00865583f, -0.02491673f, 0.00418492f, 0.01537657f, 
    0.02593615f, -0.04195874f, 0.01335239f, 0.02677066f, -0.01005161f, -0.00513580f, -0.01945473f, 0.00479690f, 
    0.03063102f, -0.01758392f, 0.02974606f, 0.01336912f, 0.02076217f, 0.02946439f, -0.03590344f, 0.00682157f, 
    -0.03901412f, 0.01082924f, -0.03266959f, 0.01117737f, 0.04209426f, 0.03723596f, 0.02099699f, 0.02922207f, 
    0.01263985f, -0.03963272f, -0.03133606f, -0.02840362f, 0.02290809f, 0.00435430f, 0.02129141f, -0.01608463f, 
    -0.03123155f, -0.00735803f, 0.00197984f, 0.00767298f, 0.00466691f, -0.00089109f, 0.02530202f, 0.00735338f, 
    -0.03405778f, -0.03858837f, -0.02816420f, -0.03699879f, -0.02764817f, 0.02116211f, -0.01519177f, -0.02426962f, 
    -0.02836069f, -0.02672438f, 0.00616673f, -0.00598701f, -0.01861706f, 0.01454732f, -0.03097527f, 0.01187849f, 
    -0.01869046f, 0.00121368f, 0.00442313f, -0.04100198f, -0.03366818f, 0.00110059f, 0.02608320f, -0.03316239f, 
    0.01919910f, -0.00186144f, 0.01423188f, -0.00752383f, 0.02102459f, -0.03620450f, 0.01814011f, -0.00551522f, 
    -0.00013826f, -0.03792515f, 0.02807925f, -0.02344641f, -0.00163510f, -0.00018359f, 0.01020122f, 0.00416602f, 
    -0.03679946f, -0.00332987f, -0.01341617f, -0.04044406f, -0.02767928f, -0.02885091f, 0.02538718f, -0.01012635f, 
    -0.04227152f, 0.01556208f, -0.00401201f, -0.02491371f, -0.03000166f, 0.01523416f, -0.03751498f, -0.01580093f, 
    0.02874343f, -0.01119437f, 0.02339427f, -0.02759333f, -0.03906650f, -0.03073113f, 0.00804635f, -0.01863535f, 
    -0.03093244f, 0.02286056f, -0.00593698f, -0.02498414f, 0.01642256f, -0.04118832f, -0.01008224f, 0.00585545f, 
    0.02345197f, -0.03523181f, 0.01512609f, 0.01696958f, 0.02448117f, 0.00110550f, 0.02343954f, 0.02592160f, 
    0.03042686f, 0.02660741f, -0.02950834f, -0.03654136f, -0.03615315f, 0.00185374f, 0.02993487f, -0.00505680f, 
    0.01671526f, -0.00710104f, -0.00745997f, 0.01022578f, -0.00087941f, 0.01328386f, 0.00745522f, 0.00491931f, 
    -0.00832118f, -0.02521878f, 0.02469440f, -0.00891866f, -0.00389457f, 0.01524019f, 0.01400557f, -0.03844506f, 
    0.00559643f, 0.00045496f, 0.01343080f, 0.02328015f, -0.02149815f, 0.00900260f, -0.03855253f, -0.01766695f, 
    -0.03593204f, 0.02424020f, -0.00400321f, 0.01336640f, -0.01790403f, -0.01898853f, 0.00371570f, -0.03862609f, 
    -0.00012712f, 0.00277585f, -0.02954684f, 0.01498259f, -0.01414688f, 0.01908922f, 0.01792975f, -0.01239156f, 
    0.00660184f, -0.01482473f, 0.02062822f, 0.02857674f, 0.00783522f, -0.01247743f, 0.01622175f, -0.01540381f, 
    -0.00442379f, -0.00084067f, -0.03502600f, 0.01774402f, -0.01882660f, 0.00016702f, -0.02243936f, 0.02604466f, 
    -0.02562002f, -0.00424209f, -0.01727438f, -0.02254815f, 0.03200136f, -0.00474368f, -0.02115669f, -0.03523523f, 
    -0.04034749f, 0.03757229f, -0.00927513f, 0.02443418f, -0.03641520f, -0.03845428f, -0.01971090f, -0.00252644f, 
    -0.01427422f, -0.02267204f, -0.03976269f, 0.00862433f, 0.02676943f, -0.00947976f, -0.02871952f, 0.02492825f, 
    -0.00665194f, -0.03265781f, 0.01737276f, -0.01897330f, 0.02975914f, -0.02957780f, -0.01748726f, 0.02593377f, 
    -0.01216822f, 0.00279154f, 0.02955674f, 0.01821737f, 0.02533582f, 0.01265041f, -0.03197163f, 0.00192375f, 
    0.01312945f, -0.01813873f, 0.01020496f, 0.02517462f, 0.00258789f, 0.02451693f, 0.02487858f, -0.02351363f, 
    0.02972616f, -0.01383610f, -0.02336178f, 0.00575651f, -0.02590994f, -0.03592699f, 0.01224564f, -0.03026864f, 
    0.00459650f, -0.01500404f, -0.03934921f, 0.02998681f, 0.00252420f, -0.02974886f, 0.02635030f, 0.00122122f, 
    0.00979875f, 0.01060618f, -0.02676613f, -0.00657862f, 0.02333030f, -0.03485729f, -0.00710018f, -0.00921434f, 
    -0.01917879f, -0.03086541f, -0.03779468f, -0.00022087f, -0.02759639f, 0.01628922f, -0.00052643f, -0.03826096f, 
    -0.01251817f, 0.01861075f, -0.03569572f, -0.00055781f, 0.01834363f, -0.03451047f, 0.01993056f, -0.00186490f, 
    0.02438597f, 0.03668041f, 0.02043857f, 0.01026559f, -0.00552144f, 0.00432980f, 0.00410917f, 0.02772769f, 
    0.01866227f, 0.02257752f, -0.03152758f, 0.02311144f, -0.03880573f, 0.01417799f, 0.00403430f, -0.00255336f, 
    -0.01300507f, 0.01947807f, -0.00580627f, 0.02974976f, -0.02467158f, 0.01254644f, -0.02697385f, -0.01525954f, 
    -0.03810960f, -0.00847589f, -0.00926445f, 0.01988222f, 0.01925895f, -0.03814806f, 0.00492774f, 0.01584849f, 
    -0.02215719f, -0.01756894f, -0.03804555f, -0.02980949f, 0.01146689f, -0.02423667f, -0.03342475f, 0.00775929f, 
    -0.02754087f, -0.01881049f, -0.00207477f, 0.01824018f, -0.00656640f, -0.03721714f, -0.01804233f, -0.00541747f, 
    -0.02789087f, -0.01180949f, -0.04025396f, -0.01841970f, 0.03600428f, -0.01219699f, -0.03512492f, 0.00070434f, 
    -0.02536417f, -0.01299239f, 0.00153483f, -0.02246359f, 0.02642110f, -0.01557011f, -0.01647012f, -0.00570346f, 
    0.00376946f, -0.03975808f, 0.02985178f, 0.00510111f, -0.00618169f, -0.02273457f, -0.01556060f, 0.03113288f, 
    0.00065061f, -0.00454359f, 0.00353530f, -0.01991707f, -0.00320184f, -0.02471659f, -0.01843157f, 0.00592284f, 
    -0.02805081f, -0.04003319f, -0.02717519f, -0.01431503f, 0.01163636f, 0.02754059f, 0.01491555f, -0.03390629f, 
    -0.02078465f, -0.00270945f, 0.00622749f, -0.03055827f, -0.02416673f, 0.00076878f, 0.01663389f, -0.01689376f, 
    0.01985149f, -0.01818950f, 0.02008415f, 0.02791275f, 0.00681454f, 0.02352805f, -0.03494475f, -0.02811792f, 
    0.02829701f, 0.00448391f, 0.01930143f, -0.00353875f, 0.02152039f, -0.01490945f, -0.01805123f, -0.03873498f, 
    0.01889041f, 0.00441944f, -0.00831267f, 0.01563185f, -0.01488839f, -0.00859531f, 0.02187867f, -0.01023220f, 
    0.02900583f, 0.02466166f, -0.02695413f, -0.00387222f, -0.03121771f, -0.03954409f, 0.02315444f, -0.04009907f, 
    0.00665029f, -0.01225665f, -0.01985513f, 0.01101173f, 0.00448639f, -0.03127176f, 0.01932703f, -0.01914030f, 
    -0.01237976f, -0.02022839f, 0.00392610f, 0.02612542f, 0.00380779f, 0.02705289f, 0.02736649f, 0.01962613f, 
    0.00387417f, 0.00425742f, -0.01394140f, 0.02103152f, 0.02229603f, 0.01221562f, -0.01961405f, -0.01332349f, 
    -0.03707352f, -0.02970368f, -0.02765708f, 0.02100626f, -0.02507341f, 0.02353217f, -0.01538762f, -0.03337749f, 
    -0.03526594f, -0.01099373f, -0.02139961f, 0.02503615f, 0.01260128f, 0.01006641f, -0.03288824f, 0.01457591f, 
    0.01641489f, 0.02355323f, -0.00347389f, -0.03510371f, -0.01318618f, 0.02952139f, 0.01467190f, 0.02088753f, 
    0.01943090f, 0.02365794f, 0.00609212f, 0.01600406f, 0.00878047f, -0.02076121f, 0.02688232f, 0.00950825f, 
    0.01602467f, -0.00477174f, -0.00062941f, 0.03898998f, 0.00959209f, -0.02729331f, 0.01749660f, -0.02004198f, 
    0.02471721f, -0.01977058f, 0.00860644f, 0.01376558f, -0.02267072f, -0.00960237f, 0.00484410f, -0.02910572f, 
    -0.03724827f, 0.02846665f, -0.03317572f, 0.01956242f, 0.00583497f, -0.03335693f, 0.02744684f, 0.02181865f, 
    -0.02791890f, 0.00533458f, -0.01091893f, -0.03376704f, 0.00064493f, 0.02785484f, -0.01707655f, 0.02222627f, 
    -0.01301978f, -0.03643786f, -0.01741861f, 0.02343166f, -0.01429989f, -0.01911690f, -0.02173620f, -0.00841329f, 
    -0.00928784f, -0.01367069f, -0.00654332f, -0.02687863f, -0.01946140f, 0.00258476f, -0.03105429f, 0.01593733f, 
    0.00782759f, -0.03840426f, -0.00925229f, -0.03660744f, -0.02263520f, -0.02304194f, -0.02543094f, 0.02507727f, 
    0.00460159f, -0.01321959f, 0.00478297f, 0.01709696f, -0.03299921f, 0.00340856f, 0.02760472f, 0.02712773f, 
    -0.01912999f, -0.02690372f, 0.00314051f, -0.02493232f, -0.01001318f, -0.04280093f, 0.02211937f, -0.01835679f, 
    -0.00159797f, -0.00868109f, -0.00804836f, 0.00011332f, 0.02342585f, 0.02831385f, -0.02584594f, 0.02908530f, 
    0.02399254f, -0.02548212f, 0.02139734f, 0.02572280f, 0.02055927f, -0.00909291f, -0.02942623f, 0.01273635f, 
    -0.01374156f, -0.00022824f, -0.03280513f, 0.00748281f, -0.03591889f, 0.02721666f, -0.01271184f, -0.00602219f, 
    -0.03697288f, 0.00807901f, -0.03949233f, 0.01200760f, -0.02675621f, 0.02502762f, -0.03766662f, 0.02432563f, 
    0.00688539f, -0.01650835f, 0.01745165f, 0.02234959f, 0.00132349f, 0.01064639f, -0.02390790f, -0.00144961f, 
    -0.00720135f, -0.00438817f, 0.01744031f, -0.03574781f, -0.03266045f, -0.01687218f, -0.00163937f, 0.01598086f, 
    -0.03649401f, -0.01783522f, 0.00944193f, -0.01779629f, -0.03708533f, 0.00679124f, -0.04031662f, -0.02681554f, 
    0.00429214f, 0.02870118f, -0.00128686f, -0.01535960f, -0.02891242f, 0.00616870f, -0.03606222f, -0.03883063f, 
    0.02344891f, -0.01603429f, -0.01892508f, -0.03429883f, -0.00264963f, 0.00903571f, 0.02916854f, -0.01682669f, 
    -0.00902896f, -0.03275449f, -0.03727617f, -0.02254872f, -0.01096429f, -0.03890047f, -0.01799210f, 0.01926724f, 
    -0.02689658f, -0.01370323f, -0.03619575f, -0.03019664f, 0.01407658f, -0.01977661f, -0.02274665f, 0.00604755f, 
    -0.02620977f, 0.01742487f, 0.01092846f, -0.01622410f, 0.02307569f, -0.01041167f, 0.00971358f, -0.00705189f, 
    -0.01059040f, -0.03641407f, -0.02007042f, -0.01569812f, 0.01099893f, 0.02794594f, -0.03939660f, -0.03849578f, 
    0.00499330f, 0.02022708f, -0.02987323f, 0.02540037f, 0.02351013f, -0.04202632f, -0.00558823f, -0.01733592f, 
    0.00587417f, 0.01696019f, -0.02906447f, 0.00752247f, -0.00197877f, 0.01259195f, 0.02259322f, -0.01623718f, 
    0.02548458f, -0.02755683f, -0.00428854f, 0.01082605f, -0.00436327f, -0.03750099f, 0.02104497f, -0.00153715f, 
    0.01640480f, 0.02672370f, 0.02224451f, 0.00400355f, -0.03326361f, -0.02669355f, -0.02779513f, 0.02861559f, 
    -0.01030703f, 0.00719504f, -0.00014605f, 0.00989624f, -0.00854775f, -0.00946448f, -0.02451899f, 0.01561949f, 
    0.01474304f, 0.00953560f, -0.01192698f, -0.02961393f, -0.03052763f, -0.02375552f, -0.02230644f, -0.03180608f, 
    -0.00065693f, -0.01048338f, 0.02565724f, -0.03373202f, -0.04075047f, -0.03147156f, -0.03968747f, -0.01212899f, 
    0.00118698f, 0.02261575f, -0.02856477f, 0.01820574f, 0.00247054f, -0.03119106f, 0.00315895f, -0.00219772f, 
    0.01014576f, -0.03261653f, 0.00433528f, -0.02898733f, 0.02595405f, -0.00135027f, -0.04082024f, -0.00811586f, 
    -0.03371666f, -0.02357543f, 0.01168650f, -0.02068311f, 0.01017511f, -0.00683257f, -0.03326435f, 0.00695510f, 
    -0.00629753f, -0.02926961f, -0.01453996f, 0.02508613f, -0.01201986f, -0.00660670f, 0.00975018f, -0.03101605f, 
    0.01090953f, -0.01257695f, 0.03056747f, -0.02049050f, 0.00560776f, -0.01183092f, 0.00467428f, 0.03088674f, 
    -0.02303596f, -0.03470645f, 0.02732198f, 0.02432181f, 0.01347740f, 0.03213265f, 0.00973780f, -0.02886467f, 
    -0.02968845f, -0.01634734f, 0.00808929f, 0.03103722f, 0.00328764f, -0.02232477f, 0.01332715f, -0.01209705f, 
    0.01974520f, 0.00573903f, -0.00499857f, 0.00385139f, 0.02728451f, 0.00261393f, 0.02007946f, -0.02829053f, 
    0.00263846f, -0.00167398f, 0.00252012f, -0.02551594f, -0.03202162f, -0.01794598f, 0.02192695f, -0.02626165f, 
    -0.00949423f, 0.01627438f, -0.03526998f, -0.01797049f, -0.02740559f, 0.02120306f, -0.03998198f, -0.03943389f, 
    -0.03704371f, -0.02279409f, -0.01426327f, -0.02067178f, 0.01434286f, -0.01016308f, -0.03727574f, 0.00234912f, 
    0.01373448f, -0.00804519f, -0.00882883f, 0.02772238f, -0.00613730f, -0.02807761f, -0.01154495f, 0.01175546f, 
    0.01459205f, -0.01223484f, 0.00868400f, 0.00060726f, 0.00390900f, 0.01617406f, 0.00080147f, -0.02841516f, 
    -0.02614348f, -0.00539657f, -0.00363114f, -0.00270899f, -0.03079936f, -0.02452288f, -0.02344113f, -0.03947340f, 
    -0.00904448f, -0.00378357f, 0.01390525f, 0.03351768f, -0.00204940f, 0.02005905f, 0.02655327f, -0.04152739f, 
    -0.02082458f, -0.02904266f, -0.01006399f, -0.00037159f, -0.03009241f, 0.00653940f, -0.00572910f, -0.03264241f, 
    0.02807444f, -0.01117270f, 0.00575542f, 0.02157954f, -0.01676932f, 0.01526117f, -0.01736828f, -0.03776274f, 
    -0.02898978f, 0.01102128f, 0.00114654f, -0.00686204f, -0.02531017f, 0.00945066f, -0.01430167f, 0.00227189f, 
    0.02221622f, 0.01930001f, -0.00017828f, -0.00927622f, -0.00258597f, 0.02353795f, -0.00763991f, 0.00039674f, 
    0.01257009f, -0.02359962f, -0.02716373f, -0.00871442f, -0.02266855f, -0.02083855f, 0.00175193f, 0.01276418f, 
    -0.01959847f, -0.02713692f, 0.03006402f, -0.00264322f, -0.00476659f, 0.01461158f, -0.00281693f, 0.00335125f, 
    0.01667807f, -0.01693675f, -0.03960333f, -0.00778419f, 0.02457903f, 0.01405297f, 0.00881760f, -0.00371441f, 
    0.02802886f, -0.02132733f, -0.03582941f, 0.02959014f, -0.01094227f, -0.00884475f, -0.03404785f, 0.02350330f, 
    -0.03070969f, -0.01155045f, 0.00858970f, 0.01712812f, -0.02604736f, 0.02584975f, -0.00871109f, -0.03123327f, 
    -0.03220432f, 0.00752549f, 0.01362875f, 0.00784384f, 0.01337557f, -0.00789254f, 0.02377316f, 0.00433004f, 
    0.03598254f, -0.01695012f, -0.00663069f, -0.00583730f, -0.00301962f, -0.03336734f, -0.01786873f, -0.02155206f, 
    0.01537856f, 0.00975460f, -0.02559914f, 0.02913247f, -0.02267835f, -0.02942343f, -0.01819903f, 0.00083552f, 
    0.02160658f, -0.02354036f, -0.01016797f, -0.03108781f, -0.02111531f, -0.01475429f, -0.02044201f, 0.02569408f, 
    -0.01353629f, 0.00167188f, 0.00002035f, -0.00092244f, 0.01445495f, -0.01005231f, -0.02549918f, -0.01392090f, 
    0.03289350f, -0.00041341f, -0.02767877f, 0.01975663f, 0.02514228f, -0.03438617f, -0.02625366f, -0.01189714f, 
    -0.01494836f, 0.00744081f, 0.02548874f, 0.00208979f, 0.01844349f, 0.03314147f, -0.00801020f, -0.02095456f, 
    -0.03952444f, 0.00442290f, 0.02069608f, -0.03311053f, -0.03745189f, 0.00865270f, -0.01111926f, -0.01801265f, 
    -0.03994801f, -0.00098326f, 0.02152839f, 0.00663355f, -0.03902462f, -0.02955869f, 0.00353533f, 0.01261329f, 
    0.00326104f, 0.02902844f, -0.02758362f, 0.01635867f, 0.02064827f, -0.01872417f, 0.00490925f, 0.00759393f, 
    -0.02759696f, 0.02882034f, -0.01077863f, 0.00716376f, 0.02531312f, 0.00069965f, 0.02295299f, -0.02193617f, 
    -0.01750779f, 0.02264265f, -0.04183142f, 0.00829315f, -0.02092181f, -0.00740971f, -0.01407413f, -0.00393783f, 
    -0.01189038f, -0.03463569f, -0.03881460f, -0.03950455f, 0.02283954f, -0.01960280f, -0.02861538f, -0.00469406f, 
    0.02473394f, 0.02339309f, -0.00858426f, 0.02313275f, -0.01995712f, 0.02321651f, -0.01589476f, -0.03965170f, 
    -0.02433062f, -0.00230826f, -0.03432944f, -0.01161256f, -0.02733875f, 0.00041469f, 0.01952960f, 0.00108983f, 
    -0.03113803f, 0.02422942f, 0.03178256f, -0.02622429f, 0.01155599f, -0.00549546f, -0.03426390f, -0.02518044f, 
    0.02704502f, 0.00420664f, 0.00595523f, 0.02212651f, -0.00681651f, 0.02774909f, 0.00204884f, -0.01647563f, 
    -0.02577184f, 0.01504509f, 0.02206623f, -0.01115851f, 0.01234654f, 0.00849388f, 0.01163260f, 0.03467150f, 
    0.02657981f, -0.03481548f, -0.00025706f, -0.02976268f, -0.01268217f, 0.01053939f, 0.02476236f, 0.02502014f, 
    -0.02484678f, 0.01220038f, -0.01006924f, -0.03406402f, 0.01937239f, -0.02174134f, 0.00654399f, 0.03362181f, 
    -0.02513671f, -0.02277416f, -0.02548104f, -0.02410928f, 0.01915743f, -0.03050354f, 0.02890248f, 0.00621181f, 
    -0.00930979f, -0.00121565f, -0.03866110f, 0.00484868f, -0.01858290f, 0.01171351f, -0.00125121f, -0.00873178f, 
    0.02081733f, 0.02026596f, -0.02707523f, 0.01683096f, 0.00176030f, -0.00539552f, -0.00443120f, 0.00179607f, 
    -0.02712552f, -0.01420222f, -0.02917134f, -0.03266033f, -0.00564368f, -0.00829241f, -0.02081411f, 0.01532665f, 
    -0.00381678f, -0.02440350f, 0.00244679f, 0.01125475f, -0.03193726f, -0.03417895f, 0.01596943f, -0.01743670f, 
    0.02989185f, 0.01380440f, -0.00275988f, -0.02951592f, 0.02999256f, 0.00717119f, -0.03149842f, 0.00816137f, 
    0.00537813f, 0.00953833f, 0.01711208f, 0.01483616f, -0.03809229f, 0.01430725f, -0.00299728f, -0.00913306f, 
    -0.04136479f, -0.01799588f, -0.03934273f, 0.02764777f, -0.01321121f, 0.01335840f, -0.03447713f, -0.01329164f, 
    0.03142543f, 0.03416373f, -0.00273375f, 0.03070567f, -0.03814632f, -0.00641696f, -0.03789927f, 0.01245569f, 
    -0.03290030f, -0.02248167f, 0.01574395f, -0.03298971f, -0.02698002f, -0.01020297f, -0.02421110f, -0.04192867f, 
    -0.00113752f, -0.02063612f, 0.02362658f, -0.02034266f, -0.00224234f, 0.02119219f, -0.02023773f, 0.00755672f, 
    -0.02169079f, -0.00813919f, -0.02294178f, 0.00940338f, -0.02556739f, -0.03722136f, -0.00307853f, 0.02037779f, 
    -0.01047848f, 0.01353430f, 0.01085640f, 0.02752568f, -0.00538314f, -0.01759701f, 0.01629190f, 0.00225325f, 
    0.01924153f, -0.00612718f, -0.02394891f, -0.02836197f, -0.00227206f, -0.00810919f, 0.01766671f, -0.02779702f, 
    0.03339825f, -0.02149471f, -0.00570691f, -0.03374294f, -0.03668792f, -0.00449310f, -0.03032323f, -0.01419316f, 
    0.02221655f, -0.00088273f, -0.03256966f, -0.03156744f, -0.02164062f, -0.03845650f, 0.00789494f, -0.04075621f, 
    0.00341987f, 0.00810191f, -0.04138888f, -0.00949059f, -0.00740445f, -0.00412186f, 0.00699355f, -0.01708409f, 
    -0.00917707f, 0.02068041f, -0.00723267f, 0.00389216f, 0.03366291f, 0.00528095f, -0.01173112f, -0.00497817f, 
    -0.01331447f, -0.03146214f, 0.02880486f, 0.02185247f, 0.00077357f, 0.01161202f, 0.00597994f, -0.02029947f, 
    -0.01151114f, 0.00437962f, -0.01113247f, 0.01747613f, -0.02486840f, -0.02911548f, -0.00512952f, 0.02364356f, 
    0.02683438f, -0.01365415f, 0.02013734f, -0.02367908f, -0.00051210f, -0.00276004f, 0.00205623f, 0.01896855f, 
    -0.03551966f, -0.03040692f, -0.00303616f, 0.00765602f, -0.00824992f, -0.01520241f, -0.03986236f, 0.00749371f, 
    -0.02339516f, -0.02090289f, -0.03675308f, 0.00685245f, 0.02085601f, -0.03891664f, 0.01186820f, -0.01478348f, 
    -0.01516667f, 0.02804230f, 0.01572190f, -0.00851648f, -0.02291646f, -0.01752331f, -0.02330949f, -0.01501781f, 
    0.00975213f, -0.03059045f, 0.03138490f, -0.01979061f, -0.02269068f, 0.01414154f, -0.00153101f, -0.00297786f, 
    0.01128450f, 0.01763514f, -0.01888590f, -0.02478907f, -0.02629592f, -0.04076013f, 0.02721700f, 0.02552019f, 
    -0.00832385f, 0.03355552f, -0.00924798f, 0.00014298f, -0.01571576f, -0.04059153f, -0.01707632f, -0.02859875f, 
    0.01975947f, 0.01694993f, -0.02807897f, 0.02242704f, 0.00325009f, 0.00551832f, -0.03321275f, -0.01967585f, 
    -0.04091131f, -0.02960119f, -0.01643003f, -0.01224622f, -0.01796020f, -0.03441438f, -0.03148720f, -0.03215121f, 
    0.02992215f, -0.01682335f, 0.00110236f, -0.03838266f, -0.00349163f, 0.01138755f, -0.03578259f, -0.03751289f, 
    0.01073824f, 0.01799039f, -0.03787022f, 0.02534814f, 0.02744589f, -0.03272147f, 0.02057705f, -0.00700401f, 
    -0.01710244f, -0.00110977f, -0.01885468f, -0.02049961f, -0.01114093f, 0.02422470f, -0.03486523f, -0.03722079f, 
    0.02320424f, -0.02329399f, 0.02831437f, 0.02281152f, -0.01334612f, -0.01230752f, -0.02671399f, -0.03683646f, 
    -0.03061385f, 0.01907625f, 0.00421515f, 0.01420564f, -0.02428330f, 0.00888511f, -0.00292819f, -0.00888082f, 
    -0.03505977f, -0.03574514f, 0.00916344f, -0.01505225f, -0.03109359f, -0.02008279f, 0.00551550f, -0.00727434f, 
    -0.03351062f, -0.00280443f, 0.01331976f, -0.01770529f, -0.01750090f, -0.00628074f, 0.02447996f, -0.02529511f, 
    0.02949998f, -0.02309707f, -0.00616362f, 0.02826929f, 0.02097055f, -0.00316340f, 0.02934023f, 0.01580815f, 
    -0.00926704f, -0.01363604f, -0.00245689f, 0.02862606f, -0.01720856f, -0.02242960f, -0.02585366f, -0.02576291f, 
    -0.01336626f, -0.00162617f, -0.00309616f, -0.03122996f, 0.00808377f, 0.00632711f, 0.02140155f, -0.01201179f, 
    0.01032804f, 0.01023765f, -0.02566105f, -0.03868839f, 0.01221491f, -0.02381175f, -0.04145569f, -0.03375966f, 
    0.02469342f, -0.03589621f, -0.03605793f, 0.00657801f, -0.02804881f, 0.02035748f, 0.02798849f, 0.00121978f, 
    -0.00610780f, 0.01941838f, -0.00221544f, -0.02272519f, 0.00534438f, 0.00126009f, -0.03664236f, -0.01390382f, 
    0.01512824f, 0.00774812f, -0.01292813f, 0.01391578f, 0.02101931f, -0.00201919f, 0.01098340f, -0.00350081f, 
    0.02566275f, -0.00436665f, 0.00263997f, 0.00602662f, -0.02605925f, -0.02589035f, 0.02602215f, 0.01453772f, 
    0.14589256f, -0.11992958f, -0.08694153f, 0.00665537f, -0.08008467f, -0.03140157f, 0.03067656f, 0.09861983f, 
    -0.14431983f, 0.01245946f, 0.13514261f, -0.26352710f, 0.18273334f, 0.10992487f, 0.01528691f, 0.15031287f, 
    0.08850668f, 0.15506546f, 0.02346084f, 0.08163500f, -0.11326861f, -0.01910735f, -0.05373125f, -0.05087729f, 
    0.20311445f, -0.00483243f, -0.18484871f, -0.22920626f, -0.04813088f, 0.07930013f, -0.01762792f, 0.10760803f, 
    0.00327071f, -0.18129219f, -0.02293400f, 0.02976548f, -0.24806556f, 0.11714197f, 0.04476439f, -0.26195693f, 
    0.09039797f, 0.08039489f, 0.04556850f, -0.08372284f, -0.13069479f, -0.08060769f, -0.21592847f, -0.05399541f, 
    0.08340222f, 0.05589528f, -0.05789864f, 0.18796253f, 0.03744121f, -0.04125516f, 0.06581644f, 0.02014262f, 
    -0.00776999f, -0.02061273f, -0.04640239f, 0.04877802f, 0.23049442f, -0.09567383f, 0.07924997f, 0.16155033f, 
    -0.02257104f, 0.02591073f, -0.05316587f, 0.20015773f, -0.08681554f, 0.01280021f, -0.00806342f, -0.07824022f, 
    0.13424063f, 0.01574774f, -0.09544306f, 0.23861028f, -0.00193488f, 0.03883466f, -0.14976691f, -0.17010377f, 
    -0.02817033f, 0.07019023f, 0.00723073f, -0.20167477f, 0.14194745f, -0.07636248f, 0.08231534f, 0.01685620f, 
    0.14759199f, -0.08093090f, 0.09956636f, -0.02059124f, -0.15172362f, 0.02927886f, -0.04686749f, -0.04873681f, 
    0.07338335f, 0.18622243f, 0.04723990f, 0.16467425f, -0.02287275f, 0.10786801f, -0.01101222f, 0.09759059f, 
    -0.06442560f, 0.01809667f, -0.00794131f, -0.11849576f, 0.00206425f, 0.14757913f, 0.03980114f, 0.13143140f, 
    -0.07220893f, -0.05183761f, 0.02265407f, -0.06426303f, 0.02587601f, 0.01769558f, 0.05997850f, 0.04041086f, 
    -0.24208227f, -0.24832806f, -0.22790521f, -0.03103733f, 0.04820365f, -0.09702548f, -0.05129917f, -0.11524470f, 
    -0.04613948f, 0.07617030f, 0.09733018f, 0.06966148f, 0.16317627f, 0.08130238f, -0.21827215f, -0.12802133f, 
    -0.13650073f, 0.00606757f, 0.08997357f, -0.14321923f, 0.03370902f, 0.08108760f, -0.13242166f, 0.08919857f, 
    -0.24105519f, -0.24270312f, -0.14003211f, -0.14859727f, 0.06251414f, 0.14926192f, 0.08021124f, 0.09822262f, 
    -0.04190771f, 0.08303083f, -0.04666921f, -0.05937929f, -0.11091057f, 0.02963064f, 0.13591255f, 0.11312032f, 
    0.13463242f, -0.07072674f, -0.05752631f, -0.04423992f, -0.06706139f, 0.04270425f, -0.04618321f, -0.08816415f, 
    0.12989625f, -0.19614571f, -0.04339544f, 0.07745527f, 0.12044264f, -0.07258296f, -0.15091920f, -0.09642183f, 
    -0.05229636f, 0.13562316f, 0.00315613f, -0.05332629f, 0.03023319f, -0.29769817f, 0.35892823f, -0.11147667f, 
    0.09074647f, 0.09153931f, -0.06236082f, 0.03607927f, 0.08793669f, -0.17439650f, 0.09968279f, -0.03599432f, 
    0.29185143f, 0.13287245f, -0.04295920f, 0.27815935f, 0.04408058f, 0.07701156f, 0.08823511f, -0.04912001f, 
    -0.08362170f, 0.06185979f, -0.09525128f, -0.00491035f, 0.19702278f, 0.02189461f, 0.18207423f, 0.20703501f, 
    -0.12608750f, 0.02995960f, 0.15080941f, 0.15309119f, 0.02411256f, 0.05575577f, 0.07831226f, 0.02161965f, 
    0.07974611f, -0.01005352f, 0.11813342f, 0.10412526f, 0.15911259f, 0.07102393f, -0.00288832f, -0.19089472f, 
    0.11032370f, 0.09035060f, -0.01139470f, 0.04812973f, 0.13833639f, -0.19450587f, 0.01324291f, 0.05843271f, 
    -0.00687432f, 0.04883842f, 0.10528509f, -0.00150903f, -0.15742759f, -0.01542341f, -0.06817693f, -0.07534059f, 
    0.13839756f, -0.14153659f, -0.02938299f, 0.08149964f, -0.13252354f, 0.07712362f, 0.06867533f, 0.01369787f, 
    -0.01389608f, 0.04921202f, 0.00744128f, -0.09274064f, 0.00411552f, -0.25055850f, -0.21970157f, -0.13247865f, 
    0.01739742f, -0.07076392f, -0.00991493f, 0.06499122f, -0.13014670f, 0.15567179f, -0.04404535f, -0.06659347f, 
    0.18741696f, 0.08575961f, 0.08240412f, 0.23341936f, 0.03656444f, 0.01728977f, -0.00515212f, 0.17288390f, 
    -0.01335619f, 0.01653519f, 0.03142435f, 0.02590584f, 0.32969674f, 0.11462498f, -0.04943814f, 0.10250365f, 
    0.10416275f, 0.07834944f, 0.03255991f, -0.10282086f, -0.00159912f, 0.00817496f, 0.03000262f, -0.06398829f, 
    -0.11292133f, -0.06620031f, -0.15533015f, -0.06662351f, -0.07554421f, 0.01901770f, 0.06221006f, -0.07719681f, 
    0.16020940f, 0.05651895f, -0.02387907f, 0.00306176f, -0.25904226f, -0.03873951f, -0.42456126f, -0.11335506f, 
    0.06083880f, -0.00338179f, 0.08009116f, -0.02219404f, -0.13182904f, -0.08178822f, -0.06423437f, -0.03177290f, 
    0.06534209f, 0.12231936f, -0.02863504f, 0.08202261f, 0.06774955f, 0.16277984f, 0.00945732f, -0.08132914f, 
    0.08597346f, 0.06678429f, 0.04030511f, 0.08252370f, -0.20186417f, -0.22860405f, -0.11438366f, -0.27483752f, 
    0.01623212f, -0.04891034f, -0.09353361f, -0.01928185f, -0.01978166f, 0.02465090f, -0.04394729f, 0.08027107f, 
    -0.28486699f, 0.28840250f, -0.17414133f, -0.12359877f, -0.01995865f, 0.01980568f, 0.09763918f, -0.12955244f, 
    0.03633668f, -0.05861584f, -0.07376284f, 0.01917090f, -0.10674958f, 0.24585904f, -0.24286777f, -0.25143287f, 
    0.01351732f, 0.00895415f, 0.09722014f, -0.09430511f, -0.03571833f, 0.12893170f, -0.01638832f, -0.04960889f, 
    0.03030816f, 0.27880448f, 0.07468852f, 0.21924201f, 0.09560401f, -0.01009436f, -0.03509315f, -0.03275198f, 
    0.12343819f, -0.06782323f, 0.01529182f, 0.06501935f, 0.12140229f, -0.03395069f, -0.09701955f, -0.27047446f, 
    -0.03220422f, 0.15350528f, -0.07208507f, -0.02478484f, -0.01609178f, -0.10028377f, -0.00352439f, -0.11104062f, 
    -0.12522618f, -0.21957135f, -0.15816189f, -0.15779607f, 0.05940506f, -0.04642035f, -0.06951790f, -0.04956647f, 
    -0.12685369f, 0.04154655f, 0.15865663f, 0.03162836f, 0.10448783f, 0.00955579f, -0.04865417f, 0.19034961f, 
    -0.19186586f, -0.17105657f, -0.08176600f, -0.08546489f, 0.02413635f, -0.00642920f, 0.02523968f, -0.03401283f, 
    0.15966144f, 0.12955362f, 0.17620079f, 0.28653052f, -0.09004281f, -0.06659694f, 0.02043070f, 0.08948756f, 
    0.08638640f, 0.06341290f, -0.00615024f, 0.03998289f, 0.07889792f, 0.08345246f, 0.04532503f, 0.11168528f, 
    0.09104405f, 0.05285575f, 0.04989997f, 0.22172436f, -0.01655463f, -0.02394531f, 0.03943108f, -0.01730264f, 
    0.50026524f, 0.14149840f, -0.01302372f, 0.21800409f, 0.09456003f, 0.17117050f, 0.05918200f, 0.05016595f, 
    -0.01497129f, 0.04871237f, -0.06879506f, 0.01760455f, -0.05149945f, -0.06557451f, 0.03815980f, -0.07688106f, 
    0.09792569f, -0.09515370f, 0.05379682f, 0.11875425f, -0.09053836f, -0.05175249f, -0.11091574f, -0.01926779f, 
    -0.22082964f, -0.35409415f, -0.39923063f, -0.06331871f, -0.07440738f, -0.03522274f, -0.00700312f, -0.12212589f, 
    -0.07150628f, 0.03232633f, 0.01088493f, 0.10681668f, -0.09882705f, -0.09199695f, -0.02720683f, -0.09693148f, 
    0.00667859f, 0.17264372f, -0.08305460f, 0.05616412f, -0.04842170f, -0.31305277f, -0.17944971f, -0.03580277f, 
    0.11837987f, 0.05535418f, -0.13651721f, 0.07699873f, 0.11759065f, -0.09292893f, 0.00512642f, -0.01136296f, 
    -0.05533121f, -0.12135651f, -0.20803681f, -0.09063211f, -0.11178411f, 0.06827770f, -0.29263684f, -0.21814951f, 
    -0.00089210f, 0.01633637f, -0.07864761f, -0.19214290f, -0.04735323f, -0.03345358f, -0.07212831f, -0.12355638f, 
    0.29731104f, 0.01933944f, 0.00701383f, 0.08060185f, 0.10720074f, 0.05822057f, -0.01592023f, -0.09750237f, 
    -0.01811086f, 0.05985344f, -0.00736279f, 0.11629582f, 0.26277065f, -0.06920862f, -0.10665514f, 0.29575640f, 
    0.05438754f, 0.04325164f, 0.08476293f, 0.07018298f, 0.04966901f, 0.09749611f, -0.06132963f, 0.13652758f, 
    0.11575465f, -0.00200774f, -0.17015696f, -0.17907698f, -0.07502791f, 0.02183243f, -0.11169811f, -0.15677348f, 
    0.00630926f, 0.04502688f, -0.00534477f, 0.11886476f, 0.05043080f, 0.19702430f, 0.05186305f, -0.11426644f, 
    0.07659868f, -0.01751776f, -0.01525629f, -0.01892135f, -0.06293076f, -0.02102003f, -0.09681420f, -0.22682829f, 
    0.31043535f, 0.07654194f, -0.01521979f, 0.07623304f, 0.14230466f, 0.06312631f, -0.10031272f, -0.07672683f, 
    0.05106181f, 0.01969456f, 0.18990368f, 0.08241162f, 0.11666428f, 0.16658401f, -0.16972044f, 0.15125835f, 
    -0.00513863f, 0.03578939f, -0.05060505f, -0.01342391f, -0.09094097f, -0.05004516f, -0.13786696f, 0.09097919f, 
    0.01297939f, 0.05720892f, 0.06607442f, 0.04030009f, 0.04295433f, -0.02582416f, 0.01202024f, 0.01455747f, 
    0.06419718f, 0.08485870f, 0.11330366f, 0.22532414f, -0.14921823f, 0.09169640f, -0.11361893f, -0.07369307f, 
    0.05008836f, -0.07480802f, 0.00345738f, 0.05282504f, -0.16470924f, 0.00899766f, -0.04526845f, -0.14111038f, 
    -0.10494422f, -0.09589225f, -0.12021463f, -0.02900333f, 0.01674334f, -0.02031014f, 0.13285320f, -0.15702184f, 
    -0.01608548f, 0.01427194f, 0.05913775f, 0.00201741f, -0.35683027f, 0.22238174f, -0.00044992f, -0.16564542f, 
    -0.05642092f, -0.02825207f, -0.01662988f, 0.00932955f, -0.05634346f, -0.09530315f, 0.02742798f, -0.04008075f, 
    -0.01190549f, -0.01807003f, 0.22296759f, 0.29317173f, 0.11712216f, 0.05545203f, 0.06459031f, 0.00138852f, 
    0.12922008f, 0.11063381f, 0.07974070f, 0.12424733f, -0.11498077f, 0.03024055f, -0.18017606f, -0.29968444f, 
    -0.00222175f, 0.00519948f, -0.00547826f, -0.00789280f, -0.06644225f, 0.03877015f, 0.15565403f, 0.03789108f, 
    -0.51422167f, -0.21531454f, 0.39215669f, -0.51693034f, 0.03743896f, -0.02228902f, -0.10336063f, -0.04315655f, 
    -0.03216784f, -0.02720117f, 0.06845862f, -0.01341409f, 0.01359715f, -0.10942239f, 0.08060800f, 0.06173879f, 
    0.21792243f, 0.12926245f, -0.10659681f, 0.02827085f, 0.09571798f, 0.12822019f, 0.15170333f, 0.28739321f, 
    0.07002722f, 0.13675645f, -0.01347346f, 0.06951553f, 0.00375228f, -0.08867817f, -0.10809841f, -0.03980468f, 
    -0.07931662f, 0.00176572f, 0.03347359f, 0.27383640f, 0.17182694f, 0.00224821f, 0.02911199f, -0.00371211f, 
    -0.03596558f, 0.10291734f, 0.08725781f, 0.07598555f, 0.16566694f, 0.12068063f, 0.07087198f, 0.04183996f, 
    0.24760231f, -0.12481276f, -0.26363891f, 0.12295711f, 0.15208447f, 0.03655126f, 0.11994343f, -0.12919249f, 
    -0.03477763f, -0.04468710f, -0.12394036f, -0.11049650f, -0.13709347f, 0.03870307f, 0.26472020f, -0.08036432f, 
    -0.02792442f, -0.22568722f, 0.06569425f, 0.05772058f, -0.00629551f, 0.14409053f, -0.11324885f, 0.00802880f, 
    -0.14316899f, -0.15389051f, -0.11948907f, 0.11871391f, 0.04050480f, -0.05309289f, 0.10596694f, -0.20748539f, 
    -0.01512521f, -0.02694242f, 0.02775681f, 0.11053602f, -0.24081944f, -0.00288406f, -0.03969846f, -0.07474870f, 
    -0.02325086f, 0.00980853f, -0.03586566f, -0.12879370f, -0.01699232f, 0.00085290f, 0.04009110f, -0.07372966f, 
    -0.23847003f, 0.23848288f, 0.05205109f, -0.22863133f, -0.00123819f, -0.03270376f, -0.11197253f, 0.08780901f, 
    -0.05919506f, -0.01357904f, -0.11024763f, 0.15229148f, -0.14326830f, -0.16666888f, -0.14731081f, -0.13727207f, 
    0.03085121f, 0.05366988f, -0.05137599f, -0.06565735f, -0.09584703f, -0.11666069f, -0.04972364f, -0.03913334f, 
    0.02745475f, 0.09587388f, -0.00190753f, -0.08614223f, -0.04574739f, -0.03119824f, -0.05927904f, 0.08017088f, 
    -0.14733064f, 0.02013803f, 0.00930263f, 0.11488046f, -0.28446198f, 0.05394902f, -0.11746660f, -0.07065814f, 
    -0.10523334f, 0.16529877f, -0.02713224f, -0.03014454f, -0.14937621f, 0.01997652f, -0.07365502f, -0.12021670f, 
    0.29428416f, -0.30666158f, -0.14160562f, 0.12124580f, -0.17315552f, 0.07237278f, 0.10639967f, 0.03406326f, 
    -0.00940077f, 0.04571779f, -0.14466034f, 0.04320884f, -0.22074497f, 0.12762949f, -0.04299087f, 0.21347551f, 
    -0.00764563f, 0.11483169f, -0.01173368f, 0.10292067f, -0.01624900f, -0.03966055f, -0.02348672f, 0.06740895f, 
    -0.01264059f, 0.24874233f, -0.04607216f, -0.15219726f, 0.00737651f, -0.08426287f, -0.02542449f, -0.03082523f, 
    0.04835063f, 0.03553171f, 0.06334210f, -0.10646971f, -0.32186541f, -0.07170089f, -0.02433030f, 0.03511206f, 
    -0.02629344f, 0.12357081f, 0.04470664f, 0.01325225f, -0.03208989f, -0.04624370f, -0.01251097f, -0.10399473f, 
    0.03865326f, 0.16780607f, 0.06566138f, -0.06763712f, -0.02507675f, 0.11217026f, -0.00746285f, 0.03877409f, 
    0.03239355f, -0.00136955f, -0.14697088f, -0.00510519f, 0.14086819f, -0.03598802f, 0.03478664f, 0.02585345f, 
    -0.08835123f, 0.10591862f, -0.04425410f, -0.03285673f, -0.12167122f, -0.06657209f, -0.17395666f, -0.05625807f, 
    0.01791129f, 0.19799379f, 0.06662778f, 0.00004079f, -0.04601216f, 0.12364781f, -0.09782474f, -0.04150622f, 
    0.01374043f, 0.02090892f, -0.13940997f, 0.03273805f, 0.07423037f, 0.01602829f, -0.12526758f, -0.14688021f, 
    0.15088539f, 0.13912474f, -0.11375245f, 0.15699038f, -0.01646926f, -0.02445119f, -0.04521971f, 0.05603699f, 
    0.20227242f, -0.00782841f, -0.18309473f, -0.12662674f, -0.01102125f, -0.05856574f, -0.00452682f, 0.00713371f, 
    -0.08587823f, -0.01254592f, -0.01036525f, 0.01005238f, 0.22139476f, -0.12616245f, -0.14178979f, 0.18868694f, 
    -0.08581915f, 0.10417230f, 0.20348673f, -0.07906900f, 0.01987064f, -0.03590805f, -0.09446093f, 0.09385171f, 
    -0.00774250f, -0.10183263f, -0.07942744f, 0.05691827f, -0.03342786f, 0.06214031f, 0.00847214f, 0.05820205f, 
    0.01706390f, -0.05091572f, 0.11258338f, 0.13871241f, 0.21252598f, 0.12090728f, -0.02160612f, -0.03699957f, 
    -0.01549903f, -0.01267286f, 0.00487143f, 0.01896124f, -0.02765403f, 0.07519165f, -0.00365382f, 0.00247135f, 
    0.16615134f, -0.15212767f, -0.03887125f, -0.23036040f, 0.12173744f, -0.01643698f, -0.12072407f, -0.00001918f, 
    0.01833189f, 0.23202197f, -0.02781152f, -0.15983143f, 0.17947428f, -0.28005674f, 0.35824814f, -0.15305565f, 
    0.03843129f, -0.07651459f, -0.10566716f, 0.04114690f, -0.02574448f, -0.09505503f, 0.05500133f, 0.02753662f, 
    -0.03226424f, 0.31098756f, -0.08973818f, 0.13122196f, -0.01717382f, -0.04650194f, 0.11487147f, 0.08765806f, 
    -0.00437907f, 0.03493533f, -0.04448421f, -0.00715988f, 0.10046479f, 0.00533626f, 0.08036160f, 0.01201393f, 
    -0.04037425f, -0.10213220f, 0.02300973f, -0.06272952f, -0.03078328f, -0.08584895f, -0.02215919f, -0.01544704f, 
    0.04883712f, 0.41753307f, 0.16299918f, -0.12987629f, -0.13128386f, 0.00525640f, 0.03307560f, -0.05442097f, 
    0.03496682f, 0.01252086f, -0.02521408f, 0.04096852f, 0.32859078f, -0.18891960f, -0.10916048f, -0.02205868f, 
    0.09421127f, 0.08233772f, -0.02393003f, 0.07015308f, -0.01759340f, 0.05715751f, -0.08766037f, -0.00201754f, 
    -0.09856059f, -0.12743667f, 0.17918046f, 0.16020589f, -0.07003313f, 0.01428395f, 0.03241175f, 0.08945250f, 
    0.03452267f, 0.02163024f, 0.12748809f, -0.05940134f, 0.15892091f, -0.28070262f, 0.00996017f, 0.07899138f, 
    -0.01169506f, -0.05802125f, 0.03616296f, 0.05526227f, 0.00554672f, -0.01513522f, 0.04751897f, -0.02666418f, 
    0.00036766f, 0.14162403f, 0.06503521f, -0.08994499f, 0.00007185f, -0.00049333f, -0.04476817f, 0.02174039f, 
    -0.05051302f, -0.02923516f, -0.07945165f, 0.00543730f, -0.06689735f, 0.34225923f, 0.09652298f, 0.07775139f, 
    -0.08662864f, -0.04717490f, 0.03203905f, 0.01182717f, 0.08767430f, -0.04919772f, -0.10350683f, -0.02361155f, 
    -0.07652825f, -0.08267401f, 0.02112623f, 0.10922085f, -0.07981070f, 0.04785711f, 0.04187654f, 0.07509153f, 
    0.14281210f, 0.02120314f, 0.12237243f, 0.07694256f, -0.11846498f, -0.22573103f, -0.04916111f, 0.02397627f, 
    -0.04659595f, -0.03684746f, 0.11482240f, 0.08426980f, 0.07001457f, -0.07748947f, -0.01593938f, 0.02511234f, 
    -0.14590210f, -0.02755069f, 0.03149939f, -0.12945114f, -0.07272848f, 0.16624442f, 0.04753910f, 0.00221759f, 
    0.13061580f, 0.04818521f, -0.10667041f, -0.06606795f, 0.13526529f, 0.05551670f, 0.03317285f, 0.16155151f, 
    0.03342367f, 0.05099249f, 0.02932818f, 0.02233312f, -0.02688180f, 0.04835970f, -0.02237019f, 0.03695976f, 
    0.30091262f, 0.26012018f, 0.08833723f, -0.05446698f, -0.10380110f, 0.08339574f, -0.09339657f, 0.12820591f, 
    0.00779099f, -0.05899476f, -0.00917417f, 0.00418973f, 0.25566691f, -0.03883550f, -0.10413388f, 0.11695882f, 
    -0.00428984f, -0.10521983f, 0.13159268f, -0.00134704f, 0.11622929f, 0.17131114f, -0.03633024f, -0.04812570f, 
    0.09090506f, 0.04154436f, -0.11922595f, -0.28243315f, 0.03400566f, -0.09430985f, -0.03539280f, 0.17816857f, 
    -0.01836323f, -0.01469126f, 0.00786658f, -0.06277730f, 0.15785058f, 0.03925517f, 0.00402648f, 0.03653492f, 
    0.06247563f, 0.05643216f, -0.12171111f, 0.10390911f, -0.08335635f, -0.05523155f, 0.03647903f, 0.01980011f, 
    -0.03922449f, 0.23245339f, -0.03851058f, 0.07485595f, -0.03658818f, -0.11578941f, 0.04028559f, 0.05129282f, 
    -0.06535559f, 0.06416865f, 0.04793877f, 0.01600888f, 0.17635764f, 0.15741791f, 0.08784780f, -0.03473965f, 
    -0.03695952f, 0.12816437f, 0.19331881f, -0.02540579f, -0.03494388f, 0.00359108f, 0.00217084f, 0.01055397f, 
    0.02937551f, 0.12524948f, 0.20015125f, -0.18569727f, 0.04491958f, 0.05714205f, -0.06038778f, -0.10800792f, 
    -0.01133274f, -0.06649753f, 0.00566767f, -0.00645948f, -0.13775426f, -0.14833167f, 0.04035786f, -0.09402572f, 
    0.13211232f, 0.04324715f, -0.02491514f, 0.06833106f, -0.03607693f, 0.00516064f, -0.07702369f, 0.01459499f, 
    -0.37523800f, 0.12162603f, 0.08518696f, 0.08917744f, -0.07908664f, 0.07406983f, 0.03437067f, -0.03447665f, 
    0.06850027f, -0.11418235f, -0.01650537f, -0.08207057f, -0.06517372f, -0.12510110f, 0.10936589f, 0.03314883f, 
    0.10651189f, 0.05442655f, 0.02173330f, 0.00680326f, -0.07853787f, -0.01295476f, 0.00154229f, 0.01787597f, 
    0.12734269f, 0.16413067f, -0.13158119f, 0.14119822f, 0.03801734f, -0.00266405f, 0.09930488f, -0.00448466f, 
    0.00735917f, -0.03954826f, -0.01359724f, 0.07616565f, 0.02207911f, -0.05523334f, -0.00677704f, -0.02248421f, 
    -0.00814774f, 0.06486870f, -0.02616990f, 0.03812961f, -0.04477702f, 0.02982361f, -0.05097966f, -0.00645838f, 
    0.09802063f, 0.02461640f, -0.08974395f, -0.03726768f, 0.03338023f, 0.06182299f, 0.09597959f, 0.18896355f, 
    -0.01658099f, -0.01233812f, -0.12496284f, -0.01100379f, -0.06690015f, 0.04486729f, -0.10611956f, 0.06484684f, 
    -0.05622881f, 0.04800336f, 0.09647673f, 0.07995541f, 0.23367365f, 0.01394690f, 0.05810300f, -0.02118333f, 
    0.02691510f, 0.29060572f, 0.34798816f, 0.00033792f, -0.07166114f, -0.02709298f, 0.14130068f, 0.04182725f, 
    0.00280651f, -0.01227451f, -0.07032784f, -0.05790551f, 0.01699857f, 0.01429128f, -0.11264093f, -0.00349636f, 
    -0.08017846f, 0.02532376f, -0.02123479f, 0.11657552f, -0.03630947f, -0.15875019f, 0.02219078f, 0.06768616f, 
    -0.06212678f, -0.16558808f, 0.06790752f, 0.08992448f, 0.00420482f, 0.12502606f, 0.03097090f, 0.01936848f, 
    0.05246088f, 0.02936974f, 0.01478899f, -0.04194924f, -0.13855481f, 0.16646847f, -0.15048596f, -0.01486478f, 
    0.03329738f, 0.24654867f, -0.15776157f, 0.08730244f, -0.06446170f, -0.13987273f, 0.08934508f, -0.14582697f, 
    -0.25634003f, 0.11837725f, 0.06841130f, -0.07007495f, 0.08540015f, -0.10653648f, 0.05629069f, 0.04794190f, 
    0.06300981f, 0.03507260f, -0.07061898f, -0.11040427f, -0.09814590f, 0.16665810f, -0.01262366f, 0.17910437f, 
    0.01669299f, -0.17237133f, 0.05954346f, 0.24777824f, 0.11145505f, -0.19870998f, 0.10921963f, -0.02013026f, 
    0.07294983f, -0.00206729f, -0.09975077f, 0.03628286f, 0.02779472f, 0.03348389f, -0.12601671f, -0.08159860f, 
    -0.09937589f, -0.07298959f, 0.04587420f, 0.00407913f, -0.02424743f, 0.09120318f, -0.07537398f, -0.05134057f, 
    -0.01736490f, -0.01043801f, 0.01024289f, 0.01500039f, 0.04421119f, 0.07294217f, -0.01299660f, 0.00818399f, 
    0.03598439f, -0.09923103f, -0.05107942f, 0.04223443f, -0.08441848f, -0.05283159f, 0.10965136f, 0.06764330f, 
    0.14051719f, 0.08313894f, 0.00924902f, -0.00541794f, -0.19301477f, 0.23875862f, 0.33174390f, -0.02945096f, 
    0.07387778f, -0.13670784f, -0.08070254f, 0.05888006f, 0.00270464f, 0.03468298f, 0.05246190f, 0.06910539f, 
    0.13425355f, 0.04228196f, 0.30584848f, -0.12901105f, -0.00588069f, 0.03238865f, 0.02208430f, -0.17714076f, 
    0.10743939f, -0.03918318f, 0.00200375f, -0.05625856f, -0.02879061f, 0.13383864f, -0.11269722f, 0.11748158f, 
    -0.02169860f, -0.02667421f, 0.08947278f, 0.11674335f, -0.05110226f, 0.10071635f, 0.09720378f, -0.00048731f, 
    0.10161882f, -0.02567339f, 0.39843816f, -0.08962692f, 0.11696780f, -0.00648630f, -0.01259139f, 0.05848320f, 
    -0.01676033f, -0.07790426f, 0.11739538f, 0.00573298f, -0.04307878f, 0.11126322f, -0.04703083f, 0.03957365f, 
    0.06891167f, -0.01536074f, -0.11772906f, -0.04192617f, -0.01085267f, 0.09590349f, -0.03919381f, -0.01613766f, 
    -0.04310231f, -0.01592131f, -0.20124838f, -0.02686236f, 0.00960274f, 0.02087852f, -0.03522426f, 0.03759520f, 
    -0.01730141f, 0.04460986f, -0.01401952f, 0.06016693f, 0.07469314f, -0.00545892f, 0.08224864f, 0.04508744f, 
    -0.04197136f, 0.06157236f, -0.08784168f, -0.10854443f, 0.06618261f, 0.02561681f, -0.00034163f, 0.03593060f, 
    0.11728703f, -0.06778865f, -0.10708838f, 0.11500286f, -0.00942156f, 0.04753050f, 0.02272280f, -0.03537404f, 
    -0.12741026f, 0.11082066f, -0.12359682f, 0.06406677f, -0.13791646f, 0.07390152f, 0.08454648f, 0.09809578f, 
    -0.08332023f, 0.06149033f, 0.20677981f, -0.10721850f, -0.01901984f, 0.02672454f, 0.08566421f, 0.10308799f, 
    0.51438719f, -0.06230819f, -0.09101573f, -0.09405399f, -0.04078800f, -0.00907474f, 0.03342374f, 0.11399545f, 
    -0.05092787f, 0.01934463f, 0.11215434f, -0.08207085f, 0.02197844f, 0.12961176f, 0.16867675f, 0.21614854f, 
    0.07945049f, 0.12231962f, 0.01935858f, -0.00660638f, -0.01220624f, -0.15202399f, 0.07740405f, 0.01471162f, 
    -0.30653495f, 0.04901925f, 0.05548033f, -0.24399880f, 0.08524424f, -0.10536987f, -0.19462052f, -0.02639487f, 
    0.02000887f, -0.02779607f, 0.05220164f, -0.01178943f, 0.03824465f, -0.06900876f, 0.07215427f, 0.09478563f, 
    -0.01705079f, 0.11777026f, 0.07563398f, 0.02890967f, 0.02609276f, 0.05224466f, -0.15521125f, 0.08971892f, 
    -0.02820957f, -0.00750809f, 0.02129364f, -0.03933734f, 0.01619358f, -0.00297777f, -0.02371742f, 0.02119247f, 
    0.01969337f, -0.03251752f, 0.02973596f, -0.00464416f, 0.00889324f, 0.03422070f, 0.02438170f, 0.03561864f, 
    -0.03368651f, -0.03067628f, -0.01028037f, -0.02058717f, -0.03337470f, 0.02275097f, -0.04048733f, 0.00158580f, 
    0.02381565f, 0.02283632f, 0.01207184f, -0.00095383f, -0.01253973f, -0.02377213f, 0.02104558f, -0.02612034f, 
    -0.02001167f, -0.02143521f, -0.00956727f, 0.01079524f, -0.02654792f, 0.02640363f, -0.02570670f, -0.00018799f, 
    0.00568970f, 0.01282143f, 0.00507130f, -0.00320671f, -0.00771037f, 0.02830205f, 0.00635981f, -0.02585789f, 
    -0.02793246f, 0.01308798f, -0.03199374f, -0.00309763f, 0.01344293f, 0.02342035f, -0.02240089f, -0.00627582f, 
    -0.00886740f, 0.01204663f, 0.00290795f, -0.03139250f, -0.02078978f, -0.02967391f, -0.00358966f, -0.03101247f, 
    -0.00120981f, 0.01922108f, 0.00107063f, 0.02656659f, -0.02269802f, 0.02161764f, 0.02911117f, 0.00918000f, 
    -0.00476379f, -0.01685079f, 0.01626378f, -0.01212267f, -0.00535215f, 0.01195464f, -0.00433366f, 0.01558339f, 
    -0.02722287f, 0.00067464f, -0.00808575f, -0.03064105f, -0.03962529f, 0.02193750f, -0.01504832f, 0.02116937f, 
    0.01902396f, -0.02946401f, 0.00984628f, 0.01169791f, 0.02019579f, -0.03887298f, -0.03086012f, 0.01428361f, 
    0.00768879f, 0.03046311f, 0.03243203f, -0.02806914f, 0.02263380f, -0.00537408f, -0.00623762f, -0.00866248f, 
    -0.00835636f, -0.00434833f, -0.00326265f, 0.02501381f, 0.01049828f, 0.00004710f, 0.00729672f, 0.02980343f, 
    -0.00073460f, 0.00864122f, -0.01852278f, 0.01329657f, 0.00997747f, -0.02457612f, 0.00439024f, 0.00543114f, 
    -0.01331700f, 0.02553865f, -0.01675391f, -0.02881632f, -0.01211596f, -0.01146580f, 0.02863638f, 0.02923623f, 
    -0.02182000f, 0.01751765f, -0.01856901f, 0.03492233f, 0.01379790f, 0.02494053f, -0.02599806f, 0.02107117f, 
    -0.02921650f, 0.03284123f, 0.03273089f, -0.03698919f, -0.03340575f, -0.03024337f, -0.03136388f, 0.01253867f, 
    -0.00913500f, -0.02842434f, 0.02530053f, 0.00741530f, 0.00821241f, -0.02901871f, 0.01081640f, 0.02323294f, 
    -0.02734626f, 0.00273723f, -0.01589528f, -0.01869217f, -0.02989095f, 0.01470178f, -0.03238926f, 0.00809382f, 
    -0.02176674f, 0.00727630f, -0.01274501f, 0.01100516f, -0.00600936f, 0.01973369f, 0.00640854f, -0.01159622f, 
    0.01554910f, 0.01415040f, -0.03874440f, -0.00495870f, -0.02598987f, 0.00438911f, -0.04002164f, 0.00580658f, 
    -0.01413019f, 0.02673101f, 0.00937879f, -0.00489680f, -0.01717173f, -0.03990710f, -0.01671822f, -0.03702906f, 
    -0.03577569f, -0.01825070f, -0.00196489f, -0.02861909f, -0.03353490f, -0.00861117f, 0.02040256f, 0.01810844f, 
    -0.03297459f, 0.00734681f, 0.02697416f, -0.00730566f, 0.01561645f, -0.01942392f, 0.00645222f, 0.00488303f, 
    0.01591609f, -0.00506455f, -0.00846812f, 0.00093913f, 0.01405943f, -0.03709091f, 0.02039175f, 0.02728182f, 
    0.01300185f, 0.00725855f, 0.03083960f, 0.00946051f, -0.02440208f, 0.02738884f, -0.00690236f, -0.02333803f, 
    -0.03315471f, -0.02619785f, 0.02294415f, -0.01248286f, -0.02798551f, -0.03468505f, 0.00239664f, -0.01928113f, 
    0.00643487f, -0.02474334f, 0.00123242f, -0.03878039f, -0.00131153f, -0.02651453f, 0.01861738f, 0.02332204f, 
    -0.03774445f, -0.03706937f, -0.01664900f, -0.00405477f, 0.01298099f, -0.00449574f, -0.02957090f, 0.00468520f, 
    -0.03039651f, -0.00901447f, -0.01133331f, -0.00553159f, -0.01555483f, -0.02865711f, 0.02678602f, -0.02543932f, 
    -0.02590246f, 0.02761864f, -0.00573017f, 0.00872438f, 0.02451951f, -0.01981902f, -0.02199442f, -0.02340069f, 
    -0.02384267f, 0.01372787f, 0.01585544f, 0.00420352f, -0.03125230f, -0.00584854f, -0.03666908f, -0.02104490f, 
    0.02509215f, 0.03415452f, -0.01545063f, -0.02787695f, -0.03193461f, -0.02797109f, 0.01357271f, 0.02723630f, 
    -0.00686571f, 0.02419942f, -0.03263757f, -0.01434916f, -0.00111087f, -0.01764406f, -0.00126913f, 0.01651780f, 
    -0.02766780f, -0.00332600f, -0.02190713f, -0.00542554f, -0.01973134f, 0.00060812f, 0.00391082f, 0.00801131f, 
    -0.02393806f, 0.02735236f, -0.03604306f, -0.00921152f, 0.00241441f, -0.03059223f, -0.00985960f, 0.01364480f, 
    0.03314768f, 0.01712104f, -0.02067799f, 0.02783673f, 0.01742751f, 0.01609219f, 0.02556846f, 0.01426751f, 
    -0.01873976f, -0.02290988f, 0.03032720f, -0.00204844f, 0.02495418f, 0.00380978f, -0.03090301f, 0.01817554f, 
    -0.00821511f, -0.00101272f, 0.00017406f, 0.03314845f, 0.01371046f, 0.01154322f, -0.00270283f, -0.03201183f, 
    -0.02833258f, 0.02712099f, -0.01135108f, 0.02368320f, -0.01404315f, -0.01719683f, 0.01869190f, 0.00955277f, 
    0.00609386f, 0.02340293f, -0.03590237f, -0.01002939f, -0.02290959f, 0.00313948f, -0.01295231f, -0.00426456f, 
    0.00918788f, -0.01533768f, 0.02953419f, -0.01888718f, -0.00096149f, 0.01445197f, -0.00877991f, 0.01720478f, 
    -0.04006838f, 0.02058033f, -0.02131063f, 0.02226381f, 0.00487267f, -0.00224176f, -0.03127390f, -0.03683002f, 
    0.02504603f, -0.03771952f, 0.03414775f, -0.03867038f, -0.00209382f, 0.02561183f, -0.01265655f, 0.00063688f, 
    0.02455890f, -0.02631381f, -0.00356240f, 0.02536384f, 0.00699260f, -0.00585082f, -0.02437284f, -0.02740176f, 
    0.00125999f, 0.03073039f, 0.01595600f, -0.03000187f, 0.00874180f, 0.01454336f, -0.00750438f, 0.00550229f, 
    -0.03672729f, -0.01015790f, -0.01746431f, -0.03663439f, -0.01477179f, 0.02295733f, -0.03298332f, -0.02268684f, 
    -0.02987788f, -0.00902289f, -0.01909323f, 0.02265791f, 0.00445122f, -0.01141014f, 0.01173293f, -0.03721367f, 
    0.02997732f, -0.01820559f, -0.03530873f, -0.03824980f, -0.00098954f, -0.01084300f, 0.02519688f, 0.03215589f, 
    0.02594694f, 0.00447418f, 0.01527396f, -0.02771478f, -0.02822208f, -0.03694471f, -0.01725857f, 0.02169554f, 
    -0.00344005f, -0.01396639f, -0.02817210f, 0.00030485f, -0.02226347f, 0.02350097f, 0.01792469f, 0.01332890f, 
    -0.03486759f, -0.01961881f, -0.01226262f, -0.01550202f, 0.00211318f, 0.02059059f, -0.00747654f, 0.00102816f, 
    -0.01467794f, -0.04233770f, -0.00021204f, 0.01426349f, -0.02506340f, 0.02143528f, 0.02942980f, -0.01974256f, 
    -0.02226436f, -0.01868730f, 0.00955388f, -0.00330415f, -0.03008549f, 0.02978660f, -0.02327254f, -0.01329135f, 
    0.01610339f, -0.01091533f, -0.01109850f, -0.01165099f, -0.00694170f, 0.00794602f, 0.02187754f, 0.01774164f, 
    -0.03636529f, -0.02390627f, -0.00402989f, 0.01292151f, -0.03640252f, -0.03084714f, 0.01422131f, -0.00320055f, 
    -0.02413045f, 0.00641207f, -0.01314357f, -0.00734120f, 0.02246800f, 0.00743337f, -0.03998251f, -0.03233896f, 
    0.02029672f, 0.00362942f, -0.00285408f, -0.02361896f, -0.03862153f, -0.02673011f, -0.02157494f, -0.01765236f, 
    0.01366412f, 0.00605822f, 0.03092073f, 0.01807050f, -0.02876450f, -0.00882419f, -0.01846924f, 0.02433301f, 
    -0.02935374f, -0.03822710f, 0.01573035f, 0.00583903f, -0.02870685f, -0.01682705f, -0.00475735f, -0.01427034f, 
    -0.01916710f, 0.01363788f, 0.01004199f, -0.01029916f, -0.01711516f, -0.03372265f, 0.01018806f, -0.00308020f, 
    0.01098208f, 0.00524983f, -0.00486798f, 0.01048029f, -0.00408774f, 0.01161971f, 0.00146014f, -0.03057424f, 
    -0.02463962f, 0.03181216f, 0.00552984f, -0.03403609f, -0.03485106f, 0.00193232f, -0.01003343f, 0.02591751f, 
    -0.02259205f, -0.02803066f, -0.00295560f, 0.01077106f, -0.00614639f, 0.02566692f, 0.00108030f, 0.00485609f, 
    -0.03148788f, 0.02784024f, -0.01538749f, -0.01895631f, -0.02256070f, -0.02120053f, 0.02907173f, -0.00747479f, 
    0.02552908f, 0.01205844f, 0.01198174f, -0.03616394f, -0.02601712f, -0.02684408f, -0.03684067f, -0.03715191f, 
    0.00126962f, 0.02448404f, -0.02860659f, -0.03987367f, 0.02139834f, 0.01239541f, 0.01202585f, -0.03526022f, 
    0.02102608f, 0.02134494f, -0.02535591f, -0.03106169f, 0.01289636f, -0.03392353f, 0.01785454f, -0.03506564f, 
    -0.03476586f, -0.03512970f, 0.00076674f, -0.02346300f, 0.02099882f, -0.03333011f, 0.00258051f, 0.02202377f, 
    0.00783418f, 0.03018154f, 0.01395995f, 0.02504671f, 0.00196331f, 0.01370759f, 0.02577221f, -0.03429199f, 
    0.02285403f, -0.02989291f, 0.02447344f, 0.02654774f, -0.00457107f, 0.02588343f, 0.00736733f, -0.01687615f, 
    -0.00076924f, 0.00435358f, 0.01567066f, 0.00978685f, -0.02004039f, -0.03455441f, 0.01255000f, -0.00576496f, 
    -0.03553900f, -0.03251582f, -0.00243008f, -0.00779091f, -0.02155498f, 0.01799367f, -0.02733169f, -0.01502385f, 
    -0.03841837f, 0.00302511f, 0.03001557f, -0.01626823f, -0.00058366f, -0.02514780f, -0.01414630f, -0.03113759f, 
    -0.02113236f, -0.01648713f, 0.01278361f, -0.03351710f, 0.01094201f, -0.03046924f, -0.00174053f, -0.02305102f, 
    0.01394994f, 0.03211635f, -0.02964526f, -0.01199719f, -0.02137339f, -0.03063273f, 0.02872353f, -0.02182713f, 
    -0.02220351f, -0.02140079f, -0.01537489f, -0.00110252f, -0.00581172f, -0.01151880f, -0.01523716f, -0.03147805f, 
    -0.03181307f, -0.03567830f, -0.01791991f, -0.02671220f, -0.03074101f, -0.02948355f, 0.00655717f, 0.00756585f, 
    0.02257907f, -0.03978214f, -0.02713571f, -0.03670823f, -0.01221168f, 0.00982756f, -0.03914986f, -0.02182146f, 
    0.02415180f, 0.02021897f, -0.03642101f, 0.02727141f, -0.00537364f, 0.00974775f, -0.00528463f, 0.02785420f, 
    0.02366060f, -0.01491086f, -0.00351088f, -0.02911888f, 0.01689111f, 0.00198492f, 0.00325433f, -0.03710549f, 
    -0.00570351f, -0.03752814f, -0.01631076f, -0.01773576f, -0.03221567f, 0.01888668f, -0.01861048f, -0.02602562f, 
    0.00831677f, -0.00222942f, -0.00098625f, 0.01351405f, 0.00279020f, -0.04078490f, 0.00512012f, 0.02341175f, 
    0.02815700f, 0.02594616f, -0.01416022f, 0.00717304f, -0.03848498f, -0.03687644f, 0.02407011f, 0.00932119f, 
    -0.02111072f, -0.03084234f, 0.02874607f, 0.03194930f, -0.02583198f, 0.02099661f, -0.00183981f, 0.02838160f, 
    -0.00811516f, 0.00118010f, -0.00519652f, 0.03114283f, -0.01082197f, 0.01611398f, -0.00252090f, -0.03257203f, 
    -0.03140827f, 0.00874675f, -0.01798777f, -0.02977368f, 0.01426349f, 0.02770190f, 0.02729370f, -0.01616709f, 
    -0.02480361f, -0.00933856f, 0.02593898f, -0.00808197f, -0.03955277f, -0.01639988f, -0.00225522f, -0.02076309f, 
    -0.00167631f, 0.02161234f, -0.02230352f, 0.02008815f, -0.02492314f, -0.01483775f, -0.04187946f, 0.01051350f, 
    -0.01826879f, -0.00947499f, -0.03484623f, -0.02191054f, -0.02474249f, -0.01228992f, 0.01833890f, -0.00938704f, 
    -0.00184659f, 0.01371005f, -0.01960176f, 0.01541244f, -0.04024837f, -0.02186796f, -0.00629649f, 0.00381512f, 
    -0.01502719f, 0.00609810f, 0.02784099f, -0.01718547f, 0.03026263f, -0.00571102f, -0.02593689f, -0.01009003f, 
    -0.00037042f, -0.00983944f, -0.00197107f, -0.03327235f, 0.02471568f, -0.00434905f, -0.00951771f, 0.02076252f, 
    0.02993907f, 0.01304896f, -0.03720911f, -0.02852631f, -0.02321538f, -0.02061505f, 0.01597877f, -0.00975793f, 
    -0.01258248f, 0.01393512f, -0.00408371f, -0.00408803f, -0.00588930f, -0.01787643f, 0.01317770f, 0.00519736f, 
    -0.02213012f, 0.00573997f, -0.01424044f, -0.00352892f, -0.03218460f, -0.01923453f, -0.03651407f, 0.02085401f, 
    -0.00788034f, 0.00051798f, 0.02218977f, -0.02376374f, 0.01809198f, -0.01651500f, -0.01214521f, -0.00543794f, 
    0.02529376f, -0.04124407f, 0.00399143f, -0.01050389f, -0.01170405f, 0.03489514f, -0.04267180f, 0.01446474f, 
    0.00603647f, 0.02692478f, -0.03411944f, -0.03076615f, 0.00692550f, -0.02523043f, 0.02212373f, 0.02754015f, 
    0.02051182f, 0.01279184f, 0.02463846f, 0.00004277f, -0.02992611f, 0.01267246f, 0.02123619f, -0.01394058f, 
    -0.00954841f, -0.02211782f, -0.00265115f, 0.00203776f, -0.00525604f, -0.00745906f, 0.01230756f, -0.01713450f, 
    0.00229779f, 0.03608143f, -0.02973337f, -0.03749035f, -0.01881658f, -0.01285195f, -0.02103302f, -0.02912345f, 
    0.03474464f, -0.01099180f, -0.01054625f, -0.00167625f, -0.02299253f, -0.00558511f, -0.04213428f, -0.03289965f, 
    -0.01592173f, -0.02425264f, -0.03588548f, -0.03371828f, -0.01372060f, -0.02254613f, -0.02747710f, -0.03807669f, 
    -0.01687890f, -0.00444780f, 0.01924539f, 0.01412206f, -0.00208232f, 0.00974763f, -0.01197779f, 0.01738917f, 
    -0.00552757f, -0.00821713f, -0.03151808f, 0.01244260f, -0.02179118f, -0.02444811f, 0.00777331f, 0.01301845f, 
    -0.00423888f, 0.00164031f, 0.02082746f, 0.01543041f, 0.01736563f, 0.02043030f, 0.02089421f, -0.01427293f, 
    0.00430530f, -0.04013653f, -0.00252089f, 0.01222293f, 0.03490620f, -0.00814967f, -0.04264577f, 0.03085529f, 
    0.03303087f, 0.01576763f, 0.01545480f, 0.02754960f, -0.00795554f, -0.01101610f, 0.01167467f, -0.03362254f, 
    -0.01240425f, -0.00102194f, 0.01020299f, 0.02634194f, 0.00002457f, -0.02968967f, 0.00116198f, -0.00520270f, 
    -0.04187243f, -0.01297052f, -0.00402392f, -0.00854329f, -0.02073011f, -0.01816118f, 0.00070598f, 0.02300040f, 
    0.02668679f, 0.02756246f, -0.02320010f, -0.00164630f, 0.00307593f, -0.01601268f, 0.02261048f, 0.02841223f, 
    0.02529271f, -0.02647366f, 0.00712886f, 0.02986435f, -0.00317609f, -0.04061765f, 0.01297874f, -0.00398445f, 
    -0.01336687f, 0.00965007f, -0.00822748f, 0.00341268f, -0.02595707f, -0.02187070f, -0.03360967f, 0.02994329f, 
    -0.02373129f, 0.00223036f, 0.00592450f, -0.00536167f, 0.02912051f, -0.00458439f, 0.01293185f, 0.01492955f, 
    0.00550837f, 0.00574148f, -0.01600711f, 0.00429053f, 0.03553365f, 0.01540310f, 0.03024445f, -0.00911834f, 
    -0.00445340f, 0.02582525f, 0.01031340f, -0.03791771f, -0.01597687f, -0.00872852f, 0.02524018f, 0.01483043f, 
    0.01615549f, -0.02955985f, -0.01206506f, 0.02661304f, 0.01706701f, 0.02910195f, -0.01634265f, 0.02881666f, 
    -0.00474179f, -0.02795872f, 0.01997031f, 0.01117639f, -0.03683897f, 0.02986850f, -0.00714126f, -0.01978001f, 
    0.01702439f, -0.02771356f, 0.00387832f, -0.00138801f, 0.01926293f, 0.00133510f, -0.00194131f, 0.02403936f, 
    0.03318638f, -0.01953495f, -0.00662132f, 0.03871558f, 0.01193780f, 0.01542055f, -0.02754111f, -0.02641391f, 
    0.00535101f, -0.01672592f, -0.02232889f, -0.01520737f, 0.02482698f, -0.02881117f, -0.02768866f, 0.00943167f, 
    0.00690041f, -0.01199302f, 0.00827197f, 0.00598614f, -0.00661062f, 0.04055198f, -0.02648088f, -0.00342275f, 
    0.02060986f, 0.01450096f, -0.03009464f, -0.01301942f, 0.00214941f, -0.03155971f, -0.01531929f, -0.03768937f, 
    -0.02096657f, 0.01630140f, 0.02079010f, -0.04194811f, 0.03516360f, -0.00242970f, -0.01907980f, -0.03437820f, 
    -0.02528897f, -0.02240649f, -0.01793496f, 0.01968339f, -0.03223186f, -0.00252726f, -0.01465506f, 0.00074650f, 
    0.02284615f, 0.02913405f, -0.00664592f, -0.03003820f, 0.01889438f, 0.02259121f, -0.00995925f, -0.01461846f, 
    -0.03426819f, -0.00264804f, -0.03780482f, -0.01808651f, -0.01460776f, -0.00201505f, 0.00828076f, 0.02891146f, 
    0.01391348f, 0.00489817f, 0.00638735f, 0.01938616f, 0.02488332f, -0.01950999f, -0.02064855f, 0.01051311f, 
    0.01559451f, -0.02972627f, -0.00001993f, 0.00295511f, 0.02397025f, -0.01231034f, -0.00469917f, 0.00873794f, 
    -0.03574689f, -0.03171730f, -0.00987029f, -0.03682298f, -0.00142556f, -0.00917838f, 0.01931255f, -0.00715795f, 
    -0.00799819f, -0.00449753f, -0.00650835f, -0.03049810f, -0.02150990f, -0.03311420f, -0.00508296f, -0.02924631f, 
    0.00358099f, -0.01921908f, -0.00831449f, -0.02823579f, -0.01003354f, 0.01403259f, 0.01858979f, 0.01161939f, 
    0.02588113f, 0.01910388f, 0.01983972f, 0.02538320f, -0.01356684f, 0.02608289f, -0.01002559f, -0.04312500f, 
    -0.03580601f, -0.02030154f, -0.03419469f, 0.00863361f, -0.00133803f, 0.00402555f, -0.02162669f, 0.02643678f, 
    0.01875122f, -0.03361684f, -0.01767253f, 0.02111487f, 0.02195837f, 0.00421509f, -0.03139832f, 0.00485349f, 
    0.02054300f, -0.03119069f, -0.01077133f, 0.02079087f, -0.01912604f, -0.02527953f, -0.03377442f, -0.04217079f, 
    -0.00594879f, 0.03283712f, -0.03917569f, -0.02946415f, 0.01168135f, -0.00711455f, 0.02269920f, -0.01960824f, 
    0.02562041f, 0.01471175f, -0.01896223f, -0.01430645f, 0.02355127f, -0.02629655f, 0.02608312f, 0.00298766f, 
    -0.02745289f, -0.01618287f, -0.02911968f, 0.02355087f, 0.03011100f, -0.03066936f, -0.00667602f, 0.01118094f, 
    -0.03274918f, -0.03662324f, -0.00540950f, -0.03020817f, -0.02032501f, 0.00056558f, 0.01189111f, 0.02997002f, 
    -0.01478961f, 0.03478237f, 0.01423054f, 0.01084513f, -0.01180259f, 0.03540938f, -0.02345210f, -0.02511090f, 
    -0.00299532f, 0.03813027f, 0.03255580f, -0.01728659f, 0.02646120f, 0.00335557f, 0.01628236f, 0.01896743f, 
    0.02028566f, 0.01491050f, 0.01105958f, 0.03914135f, 0.00314935f, 0.01577361f, 0.02044410f, 0.02889264f, 
    0.01391080f, -0.00615097f, -0.03800175f, -0.02479503f, -0.03133463f, -0.04364885f, 0.00327425f, -0.01019321f, 
    -0.00784079f, -0.00249305f, 0.02901933f, -0.00062259f, 0.00809914f, -0.00616187f, 0.02370725f, 0.01251828f, 
    0.01153325f, -0.02996010f, 0.01120388f, -0.01177344f, -0.00900637f, 0.03265791f, 0.00743201f, -0.02203600f, 
    -0.02376968f, 0.03227636f, 0.00613508f, 0.01096210f, -0.02176056f, -0.01730048f, -0.03296531f, -0.01084442f, 
    -0.01180719f, -0.01569996f, 0.00783004f, 0.00253017f, -0.00647522f, -0.01664131f, -0.02751058f, 0.02682121f, 
    -0.00406225f, -0.00607395f, -0.00666245f, -0.02041980f, 0.01864330f, -0.03664708f, 0.01036668f, -0.01723530f, 
    0.00664805f, -0.02026063f, -0.00942843f, -0.03501623f, 0.00934876f, -0.03373839f, -0.00702301f, -0.03482759f, 
    -0.01275966f, -0.03887805f, -0.01482571f, 0.00436893f, -0.02813202f, 0.00654072f, -0.03457114f, 0.02934502f, 
    0.02992520f, 0.00815915f, -0.02335103f, -0.02555857f, -0.01213770f, -0.02662267f, -0.03054832f, 0.00129346f, 
    0.02162090f, -0.03432178f, 0.02479178f, 0.01059783f, 0.01272005f, -0.03034038f, 0.01276136f, 0.00030529f, 
    0.03543070f, 0.02693166f, -0.01805562f, -0.00026627f, -0.00290717f, 0.04071946f, 0.02034798f, -0.02274069f, 
    -0.01807530f, 0.00935170f, 0.00800609f, -0.00152769f, 0.01639150f, 0.02311759f, 0.00367699f, -0.02307695f, 
    0.00583012f, 0.01084161f, -0.00347323f, 0.01449520f, -0.03362252f, 0.01129934f, -0.02846804f, -0.00497136f, 
    -0.03763562f, -0.00448576f, -0.02658092f, -0.02342145f, -0.03571875f, -0.01563688f, 0.00593996f, 0.02238607f, 
    -0.02841610f, -0.02688840f, -0.02423039f, 0.00446731f, 0.01702877f, -0.00104540f, -0.02132242f, 0.00920228f, 
    -0.00917861f, 0.00904253f, -0.01223819f, 0.01584675f, -0.00344329f, -0.02030538f, -0.00136714f, -0.00047011f, 
    -0.00104714f, 0.02547766f, 0.00968238f, -0.03293682f, -0.01006628f, 0.04083183f, 0.02622573f, 0.01283120f, 
    -0.01408451f, -0.02315285f, 0.02147959f, 0.00157710f, -0.00946945f, -0.04505602f, 0.01315745f, -0.00030312f, 
    -0.02137194f, 0.01566100f, 0.00917151f, 0.02194589f, 0.01097378f, 0.02263106f, -0.01802557f, 0.01993739f, 
    -0.00649477f, 0.01246213f, 0.00921391f, 0.00618908f, -0.00147151f, 0.02131742f, -0.03834167f, 0.00343043f, 
    0.00335971f, 0.01224580f, 0.01541017f, 0.00812373f, -0.02215522f, -0.03213906f, -0.03932009f, 0.01262538f, 
    -0.00579577f, -0.00282983f, 0.00776373f, 0.03004778f, -0.00621732f, 0.01057102f, 0.00500691f, -0.03699353f, 
    -0.00029588f, -0.03648341f, -0.03313193f, -0.00589590f, -0.00657395f, -0.04128135f, -0.00977545f, -0.00761601f, 
    0.00880082f, -0.03986157f, -0.03550969f, 0.00637449f, 0.01823440f, -0.01824085f, -0.04181957f, -0.03771443f, 
    -0.02334741f, -0.00201665f, 0.00636165f, 0.00790311f, -0.01667352f, 0.00698291f, -0.02631846f, -0.04109439f, 
    0.00060188f, 0.00552839f, 0.03081059f, -0.00109570f, 0.02427438f, -0.04248164f, -0.01338508f, 0.01201853f, 
    0.00908474f, 0.01104751f, 0.02636545f, 0.00179089f, -0.03134248f, 0.02049115f, -0.01978439f, -0.03090933f, 
    -0.01278068f, -0.01738197f, -0.01576158f, -0.02354525f, -0.03880934f, -0.01206681f, -0.01928487f, -0.03648230f, 
    -0.01011962f, -0.04131140f, 0.00928495f, 0.01954854f, 0.02762485f, -0.02484699f, -0.03015456f, -0.03459664f, 
    -0.00141689f, 0.03874510f, -0.00491248f, 0.02166437f, -0.00653401f, 0.01194348f, 0.00349063f, 0.04144958f, 
    -0.02559402f, -0.03283822f, -0.00160756f, -0.00771499f, -0.04081303f, -0.01079823f, -0.03344528f, -0.02759827f, 
    0.03406813f, -0.03687598f, -0.01309669f, -0.01541024f, -0.00265793f, 0.02449935f, 0.03470841f, 0.00485899f, 
    0.00899393f, 0.01177475f, 0.01768892f, -0.02933831f, -0.03579882f, -0.02004420f, -0.02422766f, -0.01766801f, 
    0.02556013f, -0.00687712f, -0.02824988f, -0.01542765f, 0.01798932f, 0.02156954f, -0.01898454f, -0.00867838f, 
    0.02553323f, 0.01526555f, 0.02109361f, 0.00238878f, -0.02951499f, -0.03016040f, 0.00846091f, -0.04111069f, 
    0.01338179f, -0.01579326f, 0.01537358f, -0.00795004f, 0.02562179f, 0.02360437f, 0.00910629f, 0.00736749f, 
    0.02277062f, -0.02242701f, 0.02666846f, -0.04008947f, -0.00676164f, -0.03866079f, 0.02890329f, -0.00703058f, 
    0.00888730f, 0.03022449f, 0.01922876f, -0.03086614f, -0.00452149f, 0.02719068f, -0.01596949f, 0.00815561f, 
    0.00391160f, 0.00591643f, 0.01267778f, -0.02935916f, 0.01814757f, 0.00288879f, -0.02400954f, -0.00030580f, 
    0.02339635f, -0.01920182f, -0.02771548f, 0.01924825f, -0.00780160f, -0.02782337f, -0.01379977f, 0.01300162f, 
    -0.00373961f, -0.03447520f, 0.01887965f, 0.00178420f, -0.01112414f, -0.01187445f, -0.01136846f, -0.02412818f, 
    0.02163361f, -0.03907703f, -0.00771821f, 0.00520586f, -0.00942604f, -0.04270988f, 0.01434803f, -0.03281936f, 
    -0.04029894f, -0.01563858f, -0.01067375f, 0.02322292f, 0.00100644f, -0.00303836f, -0.03475621f, -0.00944558f, 
    0.00115882f, -0.00845275f, -0.04096108f, 0.00453354f, 0.01183883f, 0.02532800f, -0.00001343f, -0.01349154f, 
    0.01069766f, -0.00116557f, -0.03874181f, -0.02288814f, 0.00066597f, -0.02130721f, 0.01967220f, -0.02296256f, 
    0.00381726f, -0.01738662f, -0.01659924f, 0.01835955f, 0.00459385f, 0.00655050f, -0.03050086f, 0.02351792f, 
    -0.01525151f, -0.03338561f, -0.01882992f, -0.01854740f, -0.00157566f, 0.03657709f, -0.00987965f, 0.03327182f, 
    -0.03519847f, -0.02412394f, 0.02450479f, -0.01390492f, -0.02844449f, -0.03579968f, 0.00132759f, 0.01289865f, 
    -0.00812926f, -0.03406807f, 0.02906039f, 0.02803876f, -0.00214292f, -0.02416425f, 0.02076882f, 0.00818302f, 
    -0.00393771f, 0.02953944f, -0.00499397f, 0.00793021f, -0.01936136f, 0.02231062f, -0.02495908f, -0.00524909f, 
    0.02384401f, 0.01011338f, 0.00314707f, -0.02266320f, -0.02867806f, -0.01927697f, 0.00383095f, -0.03425145f, 
    -0.00876262f, 0.00965561f, -0.00248772f, -0.01382913f, -0.01842390f, 0.02132573f, 0.02402520f, -0.03320961f, 
    -0.01275702f, -0.02693124f, -0.00651875f, -0.01434695f, 0.00864039f, -0.01896911f, -0.02033848f, -0.03535408f, 
    0.02552740f, -0.00266493f, 0.00190601f, -0.04153951f, 0.02316726f, 0.01436799f, 0.02737769f, -0.02550823f, 
    -0.00101044f, -0.01732264f, 0.00513914f, -0.01649342f, -0.02891930f, 0.01691474f, 0.02662925f, 0.01312875f, 
    -0.03198352f, -0.01089910f, 0.01669727f, 0.02395106f, -0.03196088f, -0.01788602f, -0.03207928f, 0.01689990f, 
    -0.02144194f, 0.02277638f, 0.01886249f, 0.01623913f, -0.00080595f, 0.01716057f, -0.00521862f, -0.02361425f, 
    0.02429253f, -0.00030426f, -0.00457364f, -0.03018798f, -0.00786572f, 0.02453295f, 0.02999130f, 0.03070685f, 
    -0.00369788f, -0.02806858f, -0.01617273f, -0.04192218f, 0.01718721f, -0.01608746f, 0.01425907f, 0.01704872f, 
    0.00178115f, -0.02548240f, -0.02772386f, 0.01946083f, -0.01867441f, -0.04004202f, -0.02547579f, -0.02566488f, 
    -0.03608772f, -0.03574483f, -0.02033466f, -0.02933815f, -0.01679628f, -0.00279233f, 0.01779617f, 0.00149085f, 
    0.01446814f, 0.00672051f, 0.01248186f, 0.01772809f, -0.04107134f, -0.03912464f, 0.00560662f, 0.02449901f, 
    0.01032761f, -0.03874609f, 0.03709458f, -0.02462417f, 0.02832718f, -0.01221177f, 0.01102685f, 0.00794842f, 
    0.01309348f, 0.01939519f, 0.01527854f, -0.00197277f, -0.03666030f, 0.01122284f, -0.00474641f, 0.00027036f, 
    -0.00990221f, -0.00808768f, -0.02979930f, 0.02766193f, 0.03276455f, -0.01787575f, 0.00058602f, 0.03166380f, 
    0.00903520f, 0.02694262f, 0.02829168f, 0.03338064f, -0.00265695f, -0.00148326f, -0.03627821f, 0.01857672f, 
    -0.00581216f, 0.02599577f, -0.00003549f, 0.03205981f, -0.02245176f, 0.01387284f, -0.02817553f, 0.01665078f, 
    0.01746581f, 0.00812136f, 0.00818707f, 0.01880717f, -0.00174740f, 0.01629584f, -0.01890257f, -0.01072222f, 
    0.01261299f, 0.00281101f, 0.04062437f, -0.00634097f, -0.03501457f, -0.01537759f, 0.00197212f, 0.02271187f, 
    0.01342466f, -0.02694195f, -0.00743761f, -0.01699681f, 0.02282996f, 0.02945146f, -0.00139437f, -0.03779888f, 
    -0.02469120f, -0.02920556f, -0.02840306f, 0.02618279f, -0.04006461f, -0.02545412f, -0.00120390f, -0.00489154f, 
    0.02712284f, 0.03021147f, -0.01874208f, 0.02781015f, 0.03473705f, -0.00379199f, 0.02945470f, -0.01725142f, 
    0.01450660f, -0.03696406f, -0.03166658f, 0.02959069f, -0.02531932f, 0.01536654f, -0.02492385f, 0.00613178f, 
    -0.01496676f, 0.00462931f, -0.00542626f, 0.03399257f, -0.00039412f, -0.01438318f, -0.00639473f, -0.02257354f, 
    -0.03785974f, -0.00799413f, -0.03021332f, -0.00820406f, -0.01592327f, -0.02918811f, 0.02173954f, -0.02546224f, 
    -0.00370871f, -0.02069948f, -0.02941668f, -0.03465762f, -0.04077929f, -0.00979976f, 0.03122739f, 0.01716319f, 
    0.01417282f, 0.00411006f, -0.01854598f, -0.00816096f, 0.02311577f, 0.01320887f, 0.00596607f, 0.01971496f, 
    -0.00187207f, 0.03105302f, -0.01722608f, -0.01246279f, 0.02755012f, -0.01227960f, -0.01747771f, 0.03132376f, 
    -0.01099189f, -0.02097890f, -0.00576528f, -0.01099451f, -0.02268398f, -0.03548570f, 0.00007700f, -0.02706074f, 
    -0.02546445f, 0.01196956f, -0.00093099f, -0.03051490f, 0.01565713f, 0.01702537f, -0.00289634f, 0.00511539f, 
    0.01438800f, -0.01912566f, -0.03709655f, 0.00971209f, -0.01460282f, -0.03226907f, 0.02457197f, -0.00367105f, 
    -0.01087559f, -0.00532466f, -0.01738913f, -0.01100482f, 0.03194983f, -0.03437546f, -0.00432447f, -0.01213759f, 
    0.02254088f, -0.00343594f, -0.02680068f, 0.01629950f, 0.00816702f, 0.00503913f, -0.02751522f, 0.03023598f, 
    -0.01414802f, 0.00292592f, -0.01084293f, -0.00370006f, 0.00891182f, 0.01751352f, 0.00781709f, -0.02177414f, 
    -0.02233491f, 0.00407700f, 0.02469497f, -0.01112549f, 0.03098123f, -0.03078745f, 0.00578449f, -0.00848656f, 
    0.01143456f, 0.01070356f, -0.00534875f, 0.00284432f, -0.02014579f, 0.02113914f, 0.02232727f, -0.01538811f, 
    0.00699215f, -0.00191569f, 0.01028121f, 0.01260146f, 0.03203028f, -0.03657455f, -0.02378521f, -0.03366128f, 
    0.00742618f, 0.03009983f, 0.00335227f, -0.01209017f, 0.00435585f, -0.02880876f, -0.01342640f, -0.02443799f, 
    0.01914090f, -0.01664064f, 0.00587539f, -0.02041273f, -0.01854768f, -0.00879500f, -0.02910208f, 0.02867581f, 
    -0.01605444f, -0.00950360f, -0.02445488f, -0.03067821f, -0.02490849f, 0.00003924f, 0.00428685f, -0.00423545f, 
    0.00014688f, 0.01907880f, -0.03446940f, -0.00899046f, -0.03684456f, 0.00461095f, -0.00856086f, 0.00845133f, 
    0.01717257f, -0.00275894f, 0.02547859f, -0.03054593f, -0.02195678f, -0.01758971f, -0.03807594f, -0.00071928f, 
    0.00841684f, 0.02434104f, 0.01340509f, 0.01245644f, 0.00392664f, 0.03135094f, -0.02793564f, -0.01443164f, 
    0.01815983f, 0.01566281f, -0.00151751f, 0.00535076f, 0.00834108f, 0.00324136f, 0.02355758f, -0.03127490f, 
    0.00113525f, -0.00129349f, 0.00325512f, -0.00901579f, -0.00752843f, 0.02370375f, -0.00522828f, 0.01701337f, 
    -0.01508908f, 0.01422976f, 0.00722087f, -0.02439798f, 0.00047301f, -0.04101532f, 0.02067808f, 0.02723115f, 
    -0.02777984f, 0.03079018f, -0.03316668f, -0.01081638f, 0.03036321f, -0.00404162f, -0.02517929f, -0.02725161f, 
    -0.00749104f, 0.02868068f, -0.00552935f, -0.02006855f, 0.02241526f, 0.02024205f, 0.00959975f, -0.02328696f, 
    0.02486251f, 0.00206440f, 0.02740145f, 0.01771173f, 0.01988805f, -0.01787256f, -0.01118559f, 0.02198380f, 
    -0.01939708f, 0.02586933f, -0.01866733f, 0.02709290f, -0.03115052f, -0.01572571f, -0.01965304f, 0.02210500f, 
    0.01267347f, -0.00751652f, 0.01357242f, 0.00406594f, 0.00767143f, -0.03342391f, -0.00572250f, -0.01384393f, 
    0.01699456f, 0.00346375f, 0.01120032f, -0.03446988f, -0.03830929f, -0.03696072f, -0.00522090f, -0.03355530f, 
    0.00255534f, -0.00132454f, 0.02187456f, 0.01389471f, -0.03905056f, -0.00392385f, -0.02927235f, -0.01176650f, 
    -0.00540901f, 0.02419020f, 0.03321064f, -0.01771221f, -0.01898297f, -0.00918020f, -0.01226688f, -0.02281366f, 
    -0.01734958f, -0.03113005f, -0.02306295f, 0.00152112f, -0.00336765f, -0.00038733f, 0.03229764f, -0.03887527f, 
    0.00996973f, 0.03146456f, 0.01282651f, -0.00574323f, -0.01156673f, -0.01867024f, 0.02287773f, 0.00717119f, 
    -0.02662774f, 0.02780130f, 0.02113706f, 0.02213058f, -0.00718852f, -0.03430514f, -0.03231849f, -0.01700306f, 
    -0.01422081f, 0.00334792f, 0.00152504f, 0.02887326f, 0.02157163f, 0.00374037f, 0.01459514f, -0.01477327f, 
    -0.00466915f, 0.00968052f, -0.00646162f, 0.00242422f, 0.02163877f, -0.04050514f, -0.01536669f, -0.00830361f, 
    -0.03507468f, -0.02508405f, 0.01912011f, -0.01059878f, -0.03469244f, 0.02530794f, 0.00181008f, 0.01215569f, 
    -0.03234960f, 0.00932554f, 0.01841233f, -0.00567510f, 0.01414144f, 0.00648521f, 0.00130074f, -0.01744006f, 
    0.01877785f, -0.03184401f, -0.03100670f, -0.01642459f, -0.03210913f, 0.02320632f, -0.02072453f, 0.02961020f, 
    -0.01329425f, 0.00840010f, 0.00592066f, -0.00012749f, 0.03423750f, -0.00516380f, 0.00696355f, 0.00253351f, 
    -0.00244035f, -0.00176969f, -0.00864675f, -0.02268726f, 0.00299738f, -0.02748187f, -0.01743185f, 0.00779960f, 
    -0.02654864f, -0.00874489f, -0.01637551f, 0.02821771f, 0.01592122f, 0.02196254f, 0.00277197f, 0.01805910f, 
    -0.02860706f, -0.02902934f, 0.02151238f, -0.02924794f, -0.02950331f, 0.03251408f, 0.01048628f, 0.01508932f, 
    -0.02684660f, -0.03769952f, -0.01219396f, 0.00682696f, 0.02068610f, 0.01179340f, -0.02128729f, -0.02188980f, 
    0.00150923f, 0.00673708f, -0.00910470f, -0.02137717f, -0.01351681f, 0.01979559f, -0.03362215f, 0.00519682f, 
    0.03507528f, -0.02503647f, -0.00653215f, -0.00264778f, -0.03653239f, 0.03128275f, -0.00789000f, -0.02339926f, 
    0.02412602f, -0.03655735f, 0.00504946f, -0.00863372f, 0.02488879f, 0.00206204f, -0.02875767f, 0.00244933f, 
    -0.03408582f, 0.02635736f, -0.02772082f, -0.00690089f, 0.00308552f, -0.03510623f, 0.00886515f, 0.01895539f, 
    0.03274992f, -0.01397819f, -0.02312996f, 0.00953247f, -0.00627275f, -0.01292861f, -0.03093852f, -0.03279923f, 
    -0.02138524f, 0.00298144f, -0.01060878f, 0.02374174f, -0.00423612f, 0.01462676f, 0.01006535f, -0.01870427f, 
    0.01788421f, -0.01521571f, 0.01346200f, -0.01473992f, 0.01951610f, 0.03044156f, -0.03966594f, 0.01454598f, 
    -0.03772820f, -0.02684684f, 0.03559904f, -0.00118991f, -0.01523739f, 0.00736494f, -0.00617847f, 0.01332189f, 
    0.02796461f, 0.00828752f, -0.02004795f, 0.02975713f, 0.01237017f, 0.02361282f, -0.00437402f, -0.02490308f, 
    0.00792572f, 0.00385210f, -0.01426985f, -0.00997647f, -0.02079605f, -0.00399877f, -0.02746048f, 0.00318229f, 
    -0.01588308f, -0.02908966f, 0.03277563f, -0.03573850f, -0.02216727f, -0.02119433f, 0.00165492f, 0.00085572f, 
    0.00929012f, -0.00647758f, -0.02248141f, -0.02704331f, -0.02144915f, -0.02310492f, -0.00828537f, -0.01969317f, 
    -0.02040738f, -0.02276701f, 0.00082310f, -0.01563586f, 0.02557159f, -0.02404095f, 0.01839158f, -0.00536139f, 
    -0.01913382f, -0.00827978f, -0.01981778f, 0.02020890f, -0.00124018f, 0.01053587f, 0.02317199f, -0.03125937f, 
    -0.03132853f, 0.02745679f, -0.00557192f, -0.00029490f, 0.00717679f, 0.00498440f, -0.03305725f, 0.00825909f, 
    0.02616389f, -0.00799687f, 0.00037797f, -0.00872195f, 0.00588848f, 0.02725749f, -0.01422880f, 0.01603930f, 
    0.02597609f, -0.00774138f, 0.01829649f, 0.00299045f, -0.00349886f, -0.02871121f, 0.01780863f, -0.04169841f, 
    -0.04496597f, -0.00830481f, -0.03727883f, -0.00717860f, -0.00805865f, 0.00547856f, -0.00901606f, 0.01275224f, 
    -0.01419230f, -0.00235128f, 0.02865806f, 0.02657602f, -0.02553067f, 0.02056515f, -0.01147432f, 0.02834678f, 
    -0.02497323f, -0.00526450f, 0.00618245f, -0.02687068f, 0.02904996f, -0.00864243f, -0.03212848f, -0.04283926f, 
    -0.01135212f, -0.00614537f, 0.01463662f, -0.00207059f, -0.02300820f, 0.03176599f, -0.00262263f, -0.00961185f, 
    0.01420170f, 0.00100621f, -0.00425585f, 0.00043105f, -0.01878945f, 0.00652910f, 0.01071108f, 0.00391839f, 
    -0.01455617f, -0.03578119f, 0.00093208f, -0.04188304f, 0.02153805f, 0.03165384f, -0.01723625f, -0.02277804f, 
    -0.00662459f, 0.03283191f, -0.02049611f, 0.02071722f, -0.01414268f, 0.01441216f, -0.02050382f, 0.01478209f, 
    0.01486728f, 0.01241913f, -0.02953954f, 0.01624121f, -0.02769849f, 0.00793384f, -0.03215705f, 0.00257205f, 
    -0.04334862f, -0.02325676f, -0.01680529f, 0.02243373f, -0.02540260f, 0.02319176f, 0.01036010f, 0.02221832f, 
    -0.09121881f, 0.07812440f, 0.00922310f, -0.11757956f, -0.02749707f, -0.02390789f, -0.02330466f, 0.14433041f, 
    -0.17837764f, -0.00689026f, 0.14095998f, 0.09529344f, -0.21867059f, -0.06657194f, -0.13471997f, -0.05592910f, 
    -0.06414639f, 0.07566687f, -0.03455548f, 0.19919609f, -0.02257442f, 0.06834786f, 0.01140218f, -0.04796874f, 
    0.20594837f, -0.16538249f, -0.05536083f, 0.03279780f, -0.16348118f, 0.10519727f, 0.05001636f, -0.01238313f, 
    -0.05824150f, 0.01888063f, -0.04653772f, 0.21582878f, -0.02525526f, 0.07198929f, -0.07247266f, 0.11003765f, 
    0.04807718f, 0.10769854f, -0.01397207f, 0.08120931f, 0.02465668f, -0.03830754f, -0.01661580f, 0.18330608f, 
    -0.11554191f, 0.06378748f, -0.02325450f, 0.00164795f, -0.11364665f, -0.19647652f, -0.01086456f, -0.07450987f, 
    0.04283896f, 0.07733255f, 0.04571387f, -0.00042040f, -0.29513004f, -0.23534395f, -0.09732918f, 0.07508216f, 
    -0.01730971f, 0.05052776f, -0.00934462f, 0.12596051f, -0.06929595f, -0.01487025f, 0.03458506f, -0.02146019f, 
    -0.11679862f, 0.11779344f, -0.06686425f, 0.01863925f, -0.02152524f, 0.08823229f, -0.13031104f, 0.01526133f, 
    0.02339840f, 0.04313408f, -0.03363783f, 0.01179098f, 0.00211952f, -0.06841403f, -0.03517124f, 0.03068218f, 
    0.08946188f, 0.09221853f, -0.03006518f, -0.02217979f, -0.01658815f, 0.06630973f, -0.15460457f, -0.02374505f, 
    -0.01023832f, 0.03223434f, -0.11426909f, 0.07263022f, -0.11289986f, 0.02189271f, -0.03782320f, 0.06084081f, 
    0.00414506f, 0.04110236f, -0.09525574f, 0.03889261f, 0.17432283f, 0.01949692f, -0.15717517f, -0.06665310f, 
    0.05574352f, -0.05267546f, -0.04057317f, 0.10099813f, -0.00623619f, -0.03011034f, -0.07271668f, 0.04128895f, 
    0.14250909f, 0.19577654f, 0.09290199f, -0.00631863f, -0.07732640f, 0.00291155f, -0.01204325f, -0.00333470f, 
    -0.06157200f, -0.05578755f, 0.00833096f, 0.01548845f, 0.22322091f, 0.01686275f, -0.24917930f, 0.02244384f, 
    -0.07215917f, 0.07003023f, 0.17548463f, 0.01279027f, 0.09096987f, -0.01976348f, -0.06673335f, 0.17496058f, 
    -0.01603929f, 0.00317465f, 0.02324613f, 0.00066053f, -0.03568253f, 0.01184119f, 0.02309464f, 0.03381907f, 
    -0.02080544f, 0.03865351f, 0.17789878f, 0.19084714f, 0.13836293f, 0.10768466f, 0.15627292f, -0.04377522f, 
    -0.02550853f, -0.12144228f, -0.07552152f, -0.05327854f, -0.01674937f, 0.00050698f, -0.05598145f, 0.01848680f, 
    0.06470682f, -0.11773262f, 0.16285485f, -0.23338926f, 0.07599905f, -0.01953913f, -0.08852351f, 0.05886805f, 
    0.06193336f, 0.27227485f, 0.05439582f, -0.18537819f, 0.13818413f, -0.15733266f, 0.50104493f, -0.10332768f, 
    0.04951756f, -0.01573662f, -0.07623184f, -0.03341329f, -0.03451619f, -0.17430469f, 0.04716888f, -0.00738404f, 
    -0.20785703f, 0.10687166f, -0.16826670f, 0.01654130f, -0.10967200f, -0.00434266f, 0.01871048f, 0.16757496f, 
    -0.07753621f, -0.02477122f, 0.00048292f, -0.04029468f, -0.03457530f, -0.20641297f, 0.06009297f, -0.01270605f, 
    -0.10288356f, -0.07818465f, 0.04031351f, -0.05718463f, 0.01155127f, -0.14204900f, -0.03347308f, -0.01398306f, 
    -0.04380864f, 0.31817228f, 0.19195217f, 0.13811842f, -0.06694137f, 0.09566762f, 0.08478423f, -0.08111148f, 
    0.01730332f, -0.03379269f, 0.00792534f, 0.03903889f, 0.11395267f, -0.29572591f, 0.04398109f, -0.04901450f, 
    0.06468491f, 0.07387766f, 0.05378367f, 0.16570762f, 0.03455986f, 0.03697662f, 0.02172197f, -0.02176727f, 
    -0.20870282f, -0.18794420f, 0.04737475f, 0.03212461f, 0.04111280f, -0.19507247f, 0.01099355f, 0.01279033f, 
    0.01186463f, 0.01054622f, -0.06197206f, -0.00951134f, -0.06271085f, -0.39819798f, -0.10838299f, -0.02139066f, 
    0.05136668f, -0.04408830f, 0.07439159f, 0.02611300f, 0.02455196f, 0.03588272f, 0.06757960f, -0.04094121f, 
    -0.15243013f, 0.06994119f, 0.22312576f, -0.05895250f, -0.11674549f, -0.01638318f, -0.01636643f, -0.00727994f, 
    -0.02845825f, 0.02424856f, -0.05702266f, 0.09857937f, -0.19367929f, 0.26314253f, 0.12324210f, 0.14207442f, 
    0.00539062f, -0.02057334f, 0.06605469f, 0.01347872f, 0.04044583f, -0.04739796f, 0.00231664f, 0.04732221f, 
    0.01859888f, -0.08556125f, -0.04235030f, 0.02371205f, -0.04837904f, -0.04651427f, 0.08615804f, 0.03137568f, 
    0.11981660f, 0.05045064f, 0.09626685f, 0.14327873f, -0.13716494f, -0.21907619f, -0.03935956f, -0.03587886f, 
    -0.03008680f, -0.02836398f, 0.07093132f, 0.00858587f, 0.13820325f, 0.02293317f, 0.02828453f, 0.08600070f, 
    -0.25138146f, -0.13286687f, -0.05652425f, -0.08432152f, -0.09841868f, 0.15616415f, 0.06967119f, 0.01329087f, 
    0.02254368f, 0.03700965f, 0.01540573f, -0.05033466f, 0.15000758f, 0.11895446f, 0.10467853f, 0.03516255f, 
    -0.02744277f, -0.00832377f, -0.09262989f, 0.02483662f, -0.00151236f, 0.04754529f, -0.04644113f, 0.07447165f, 
    0.57025224f, 0.41957587f, -0.08551855f, -0.03052406f, -0.07308238f, 0.01640691f, -0.07598882f, -0.03750662f, 
    -0.03139266f, 0.03044690f, -0.08374016f, 0.03403730f, 0.21731821f, 0.03824365f, -0.17722856f, 0.10239556f, 
    -0.00647477f, -0.12839085f, 0.08440977f, -0.00496713f, 0.21993329f, 0.14791656f, -0.04197932f, 0.00031643f, 
    -0.05548978f, 0.34623644f, -0.07202989f, -0.09149745f, 0.06500915f, -0.06712011f, 0.00875617f, -0.15304002f, 
    -0.09066655f, 0.03908169f, -0.02690436f, -0.03238099f, 0.20713027f, -0.02718950f, -0.09565444f, 0.01510141f, 
    0.01953767f, 0.05485173f, -0.06783927f, 0.01412809f, -0.01931911f, -0.09785379f, 0.07719293f, -0.01095879f, 
    0.00924634f, 0.21268114f, 0.03002372f, 0.06168637f, -0.01300645f, -0.11725161f, -0.00756062f, 0.02350001f, 
    -0.05653571f, 0.03136811f, 0.03486064f, -0.04932736f, 0.06533074f, 0.18124068f, 0.04534552f, 0.08605611f, 
    -0.09143374f, -0.00420670f, 0.14724429f, -0.17294393f, 0.03932210f, 0.08236013f, -0.02488561f, 0.04471590f, 
    -0.09480172f, -0.01668551f, 0.29338497f, -0.09279580f, -0.03130367f, -0.04495005f, -0.04721094f, -0.14883925f, 
    0.00819674f, -0.02303630f, -0.01690244f, -0.01974127f, -0.03111781f, -0.20716968f, 0.05765833f, -0.06510784f, 
    0.11941532f, -0.13216230f, 0.04364701f, 0.16293046f, -0.00687098f, 0.01128075f, 0.01142685f, 0.03065263f, 
    -0.41726655f, -0.15742734f, 0.01997287f, 0.02393703f, -0.12321745f, 0.04261871f, 0.03134544f, 0.11062203f, 
    0.05766181f, -0.09284407f, 0.01171060f, 0.03968081f, -0.02491660f, -0.10505584f, 0.10787398f, -0.05425752f, 
    0.15203965f, -0.10770445f, -0.10669589f, 0.10064223f, -0.05278649f, -0.00894231f, 0.05497050f, -0.03419602f, 
    0.12126602f, 0.14316194f, -0.03429807f, 0.14368387f, -0.02479619f, -0.02699435f, 0.04662635f, -0.00683237f, 
    -0.00491177f, -0.00497039f, -0.06356424f, 0.04744163f, 0.05613542f, -0.07393196f, -0.02461635f, 0.06177936f, 
    -0.02322603f, 0.29112297f, -0.11005355f, 0.06580149f, -0.10826292f, 0.00795552f, 0.02097426f, 0.02325389f, 
    0.09431249f, 0.05387326f, -0.29553804f, 0.06615189f, 0.09850384f, 0.07726185f, 0.03341754f, 0.10899187f, 
    0.05827116f, 0.09707560f, -0.17358427f, 0.11469045f, -0.00638662f, 0.13378799f, -0.09931411f, 0.06757443f, 
    -0.03033025f, -0.04025567f, 0.01856531f, -0.01648457f, 0.13968836f, -0.02147406f, 0.09153108f, -0.00231299f, 
    -0.01828106f, 0.21319853f, 0.27733335f, 0.14355800f, -0.10262778f, -0.14477599f, 0.19855541f, -0.07806949f, 
    0.03660122f, 0.03421493f, -0.05370862f, -0.06789184f, -0.06914077f, -0.15074554f, -0.09475739f, 0.03513971f, 
    -0.04207475f, -0.03008278f, 0.04505466f, 0.04982970f, -0.10413969f, -0.08120191f, -0.00324616f, 0.12099719f, 
    0.23462045f, -0.12992592f, -0.03478966f, 0.05344787f, -0.03403009f, 0.14576912f, -0.03144137f, 0.01199785f, 
    0.07454940f, -0.02514882f, 0.08253119f, 0.04197013f, -0.10106260f, 0.11810900f, -0.13892803f, 0.02570022f, 
    0.04528211f, -0.04040112f, -0.06278790f, 0.15831447f, -0.02949839f, 0.06234661f, -0.04874248f, -0.06036824f, 
    -0.07808968f, -0.01380643f, -0.14854996f, 0.02484731f, 0.23910852f, -0.06820893f, 0.04117734f, 0.12749618f, 
    0.13085580f, 0.06219569f, 0.12820905f, 0.07476671f, 0.06894033f, 0.04191486f, -0.11725437f, 0.08093102f, 
    0.10167236f, -0.10638130f, 0.01928049f, 0.22052041f, 0.12866804f, -0.03781673f, -0.06268881f, 0.06992080f, 
    0.10401154f, -0.00936174f, -0.00502296f, 0.05014033f, 0.01518103f, 0.06740603f, -0.04010678f, 0.00200634f, 
    -0.01028522f, -0.08072039f, -0.02844725f, -0.08773629f, -0.10085999f, 0.20199570f, -0.02761798f, -0.03292565f, 
    0.02030574f, 0.00973440f, -0.00959553f, 0.03961105f, -0.02298646f, 0.01984330f, -0.06077117f, 0.02124241f, 
    -0.04622117f, -0.16399784f, -0.08039764f, 0.01061184f, -0.08715649f, -0.10122307f, 0.10191974f, -0.00539361f, 
    0.10990106f, -0.04271153f, -0.05074334f, 0.02395843f, -0.11657821f, 0.18348983f, 0.27830690f, 0.05268173f, 
    0.13745706f, -0.14013900f, -0.15056847f, 0.03545254f, 0.01607937f, -0.02172136f, 0.04086581f, 0.05746958f, 
    -0.08441249f, 0.02146688f, 0.34606323f, 0.06562301f, 0.01507920f, 0.03238634f, 0.09193141f, -0.08358462f, 
    0.11542060f, -0.03064606f, -0.00498772f, -0.05046761f, -0.04721889f, 0.14771134f, 0.02809710f, 0.05028931f, 
    -0.02676445f, 0.05072181f, 0.05817815f, 0.04846870f, -0.01344593f, 0.03519079f, 0.02028062f, 0.00433154f, 
    0.07701587f, 0.16261554f, 0.41497192f, 0.03360729f, 0.07317343f, -0.02638297f, -0.07045562f, 0.08712494f, 
    0.00923276f, -0.02513855f, 0.04197872f, 0.07265477f, -0.05058166f, -0.09721289f, -0.03554823f, -0.02725629f, 
    0.14394090f, 0.04808659f, -0.02298303f, -0.05137115f, -0.05182367f, 0.05077994f, -0.06744221f, -0.07323117f, 
    0.03902889f, 0.07082627f, -0.04183608f, 0.02127889f, -0.03362382f, 0.00671658f, 0.01411484f, -0.00235705f, 
    0.04503236f, 0.07428566f, -0.02013455f, -0.00132380f, -0.03347290f, -0.15236959f, -0.04343579f, -0.00407922f, 
    -0.11899683f, 0.07500102f, -0.09363936f, -0.01018443f, 0.10673358f, -0.01924466f, 0.00240087f, -0.04465866f, 
    -0.05588829f, -0.09269238f, -0.09297965f, 0.05295638f, -0.01789293f, 0.07283200f, 0.08327502f, 0.06398164f, 
    0.05525208f, 0.11645688f, -0.12234947f, 0.00407298f, -0.18429513f, 0.15395731f, 0.14407814f, 0.06161423f, 
    -0.18101078f, -0.04536552f, 0.22585188f, 0.04581154f, 0.12277412f, 0.09824448f, 0.15571842f, -0.02714067f, 
    0.33151057f, 0.06599336f, -0.00803990f, -0.03219705f, -0.05497102f, 0.00458599f, 0.01163394f, 0.04327397f, 
    -0.04829855f, 0.02024969f, 0.07890180f, -0.03984770f, 0.14348094f, 0.11397399f, 0.21058483f, 0.17400132f, 
    0.03994847f, 0.08144435f, -0.05930581f, -0.00131416f, 0.03371183f, -0.07428908f, 0.07374462f, 0.00522214f, 
    -0.14223973f, 0.02313689f, -0.23968658f, -0.24095561f, 0.19816272f, -0.08331435f, -0.07311787f, -0.06142366f, 
    0.02492792f, -0.01434198f, 0.07006219f, 0.01087995f, 0.05963433f, 0.00072536f, 0.05707001f, 0.07703163f, 
    0.01996077f, 0.09063485f, -0.02290834f, 0.09578056f, 0.03546759f, 0.04515481f, -0.03108990f, 0.12964816f, 
    0.10858560f, 0.01435387f, -0.10713961f, -0.15763736f, -0.15404570f, 0.01905856f, -0.01492887f, -0.17451097f, 
    -0.04134704f, -0.00666170f, -0.04195343f, -0.00928235f, 0.12645398f, 0.01661865f, -0.07882867f, 0.18599634f, 
    -0.01431088f, -0.00297498f, 0.12882735f, 0.07994080f, -0.01417099f, 0.05186306f, 0.03054936f, 0.06158479f, 
    0.16445933f, -0.07532111f, 0.14841886f, 0.14418894f, -0.05844617f, 0.04067186f, -0.01384394f, 0.02208363f, 
    0.09352691f, -0.12696192f, -0.05428819f, -0.15256713f, -0.09774829f, 0.20070010f, 0.16705517f, 0.00156155f, 
    0.01223219f, -0.02804271f, 0.04453589f, -0.02869484f, -0.02074451f, -0.05534603f, -0.04767353f, 0.01238887f, 
    -0.11113350f, -0.20254576f, 0.19927381f, 0.27935377f, -0.01762363f, -0.01082993f, 0.09435797f, 0.17023626f, 
    0.00808095f, 0.02750580f, 0.00537216f, 0.01777615f, 0.26666534f, 0.01742635f, -0.11418281f, 0.02684099f, 
    0.01706966f, -0.05177741f, 0.10425603f, 0.12836549f, -0.03118237f, -0.00714103f, 0.05993864f, 0.07968473f, 
    0.03712011f, 0.07295147f, 0.22214469f, 0.12481030f, 0.00079627f, 0.14939310f, 0.03947011f, 0.07203210f, 
    0.04546480f, 0.00969618f, -0.12368502f, 0.04266659f, 0.13425353f, 0.07931528f, 0.16081196f, 0.03757798f, 
    0.15837283f, 0.08947950f, -0.00049269f, -0.00709956f, -0.04612458f, -0.02899224f, -0.04457396f, 0.07069335f, 
    -0.03658805f, 0.11592045f, 0.29758307f, 0.32585663f, -0.03304775f, 0.05331973f, 0.12618843f, 0.13919926f, 
    -0.04460850f, 0.13172255f, 0.09705792f, 0.04589178f, -0.36731616f, 0.07327969f, 0.21999988f, 0.06625920f, 
    0.06668471f, 0.07871194f, -0.25762263f, -0.07463483f, -0.06944343f, -0.03321717f, 0.09669845f, 0.04026187f, 
    0.36789179f, 0.03673945f, -0.00519788f, 0.09403999f, -0.08354446f, -0.12818287f, 0.04006803f, 0.07694218f, 
    0.07594807f, 0.08869629f, 0.08670386f, 0.03262358f, -0.20926115f, -0.09797414f, -0.01880732f, 0.00511412f, 
    -0.12849456f, 0.18749225f, -0.19236082f, -0.02925592f, -0.09006216f, 0.01582450f, -0.09792182f, 0.01002206f, 
    0.11706530f, 0.06038716f, 0.09395197f, 0.10567947f, -0.04276844f, -0.00675163f, -0.03094555f, -0.03996907f, 
    0.19701780f, 0.00129475f, -0.04363406f, 0.08799656f, 0.33832276f, 0.09916275f, -0.02345021f, 0.05188244f, 
    -0.15958306f, -0.11187355f, -0.02248554f, -0.04851108f, 0.01834507f, -0.02133803f, -0.02230184f, -0.04457237f, 
    0.02755995f, 0.16555922f, -0.04749302f, -0.01323964f, -0.02029636f, -0.00612411f, 0.04774317f, -0.11861128f, 
    0.00470219f, -0.14149265f, -0.04862117f, -0.05867979f, 0.27538729f, 0.14141870f, 0.23743656f, 0.11364910f, 
    -0.08822440f, -0.23312369f, 0.07637539f, -0.01974670f, 0.07630772f, 0.05717450f, 0.01635480f, 0.06905109f, 
    0.26741159f, -0.03373369f, -0.19802950f, -0.08617117f, -0.05045780f, -0.16601560f, -0.11979797f, -0.15628292f, 
    -0.10326421f, -0.04707021f, -0.07578814f, 0.00684730f, -0.12555879f, 0.24502401f, 0.22462068f, 0.17909653f, 
    -0.10386354f, 0.04520622f, -0.03270559f, 0.32083508f, -0.02177079f, 0.04910785f, 0.00238923f, -0.06448498f, 
    0.01609798f, -0.03527195f, 0.10656738f, -0.17804444f, 0.03558611f, -0.09002937f, 0.00033606f, -0.20089220f, 
    0.02878848f, -0.00318949f, -0.11753046f, -0.04022909f, 0.12532718f, 0.09535947f, 0.16057387f, 0.00820437f, 
    0.07931070f, 0.07393639f, 0.01007049f, 0.07412311f, -0.03481193f, -0.13281345f, 0.13160248f, -0.01198621f, 
    0.11233227f, -0.33901075f, -0.08847144f, 0.35099462f, 0.08076689f, 0.09611359f, -0.18468100f, 0.12662266f, 
    -0.02925738f, -0.02403012f, 0.02985549f, 0.00391400f, -0.00433537f, -0.12952261f, 0.07690455f, 0.24220422f, 
    0.04414698f, 0.05478654f, -0.09460993f, -0.08897875f, 0.00969918f, -0.06546941f, -0.23466910f, -0.08064409f, 
    -0.03067773f, -0.03966859f, 0.32181028f, 0.34196773f, -0.08637736f, 0.04984362f, 0.06663052f, 0.25438437f, 
    0.08718348f, 0.05562609f, 0.05676445f, 0.07052696f, 0.28497449f, 0.04855065f, -0.16496223f, 0.02686775f, 
    -0.05883528f, -0.11166545f, 0.01646187f, -0.01054719f, 0.00686787f, -0.02678238f, -0.07833008f, -0.18731509f, 
    -0.09794401f, 0.00799924f, 0.06234640f, 0.01185077f, 0.03773789f, 0.04017327f, -0.12705699f, -0.12672502f, 
    0.13540739f, -0.00093956f, -0.07431558f, -0.06869906f, 0.23593196f, 0.24245965f, -0.05021137f, 0.01513567f, 
    -0.00067288f, 0.02452729f, -0.01231406f, -0.06540430f, -0.08085012f, -0.06545380f, -0.03414986f, -0.10593451f, 
    0.04333055f, -0.14318532f, 0.03908302f, -0.14810404f, -0.06442250f, -0.03003633f, -0.05208837f, -0.08440825f, 
    0.03968938f, 0.08164924f, 0.04843896f, -0.02591771f, 0.06851410f, -0.01295312f, 0.09404068f, 0.05887406f, 
    -0.00005853f, 0.01741292f, 0.01818396f, -0.01090065f, 0.05868273f, 0.06172809f, 0.00351545f, 0.06037939f, 
    -0.45675191f, 0.02082004f, 0.01344672f, 0.02470033f, -0.04146357f, 0.00883306f, -0.03539355f, 0.06136072f, 
    0.00978543f, -0.08890405f, -0.00116093f, -0.00140703f, 0.04154617f, 0.08875088f, 0.01718254f, -0.05790611f, 
    0.04152615f, 0.05317717f, 0.02704703f, -0.02359866f, -0.06683948f, 0.13590561f, -0.01667663f, 0.04302081f, 
    0.01616879f, 0.19459476f, 0.14715520f, -0.08977573f, -0.14744654f, 0.14385629f, 0.08236092f, 0.21282442f, 
    0.05897914f, -0.10328007f, 0.13288350f, -0.08032096f, -0.03179489f, 0.15584141f, 0.09445273f, 0.06040050f, 
    -0.02853637f, -0.02248869f, -0.12702714f, 0.09889721f, -0.00216118f, 0.00352604f, 0.10561291f, -0.04216956f, 
    0.10434127f, 0.06263421f, 0.04741770f, -0.09126195f, -0.02560758f, 0.01143196f, -0.06820986f, -0.01516041f, 
    0.13879798f, 0.16904996f, 0.01898965f, 0.05434449f, -0.14988390f, -0.14529839f, 0.27070206f, 0.13633640f, 
    -0.03285826f, -0.10849169f, -0.05316145f, 0.08113568f, -0.06378379f, 0.00184149f, -0.01645826f, -0.00315378f, 
    -0.06235921f, -0.00544004f, 0.21667066f, 0.36787468f, -0.07491279f, -0.05555970f, -0.01413157f, 0.13139121f, 
    0.01733240f, 0.01628492f, -0.01733932f, 0.01624148f, -0.05074164f, 0.10050800f, 0.27388448f, 0.42462319f, 
    -0.07249634f, 0.02557960f, -0.00457449f, 0.15089238f, -0.03810350f, -0.06471139f, 0.03926106f, 0.06435523f, 
    0.55879337f, 0.20930740f, -0.29960939f, -0.08940270f, -0.02438863f, -0.20829713f, -0.00262924f, -0.01839727f, 
    -0.09448039f, -0.06906220f, 0.00093588f, 0.04438694f, -0.01443693f, 0.18888369f, -0.08311541f, 0.12231923f, 
    0.01736331f, -0.06672913f, 0.03908479f, 0.03525645f, -0.12565832f, -0.01295270f, -0.04249914f, 0.03217071f, 
    0.19224304f, 0.05800244f, 0.00213432f, 0.02572774f, -0.06180229f, 0.08216502f, -0.02389461f, 0.00671926f, 
    0.04926163f, 0.05219575f, 0.00200374f, 0.06059564f, 0.05106961f, 0.08595049f, -0.06476638f, -0.29325619f, 
    0.03992444f, -0.02149562f, 0.15882005f, 0.11602654f, 0.08680819f, 0.05199079f, -0.07617185f, -0.00609134f, 
    0.08430289f, 0.05515337f, 0.05320749f, -0.10879620f, -0.00878066f, -0.19768366f, 0.03113004f, 0.13191558f, 
    0.00778061f, -0.06546592f, -0.12151040f, 0.02215381f, -0.09517530f, -0.12950653f, -0.02919709f, 0.18002059f, 
    -0.03023249f, 0.12406013f, -0.02589037f, -0.16059622f, 0.02174839f, 0.04707814f, -0.01493410f, -0.20393269f, 
    0.02530449f, -0.12269552f, 0.14046274f, 0.15687953f, 0.11490531f, -0.01817878f, -0.10208457f, 0.06533613f, 
    0.07681794f, -0.03423049f, -0.16407567f, 0.01775705f, 0.10511504f, -0.23048036f, -0.01015488f, 0.17207059f, 
    -0.01436109f, -0.12317589f, -0.11573902f, 0.04770372f, 0.07303572f, -0.01665392f, 0.01516717f, 0.07400464f, 
    -0.27901590f, 0.11022283f, -0.01107937f, -0.17909151f, -0.03850929f, -0.03335834f, -0.27318218f, -0.00838572f, 
    -0.15165988f, 0.05294631f, -0.18126833f, 0.02974317f, 0.09355440f, 0.09526353f, 0.05558626f, -0.14432658f, 
    -0.05501252f, 0.23169884f, -0.03581752f, -0.06824522f, -0.06657159f, -0.13032512f, -0.03434294f, 0.09370993f, 
    0.06841662f, 0.02773341f, -0.13562076f, 0.05996794f, 0.21221823f, 0.03167124f, 0.07587654f, -0.16267076f, 
    0.06625555f, 0.06918684f, 0.06674129f, 0.10301138f, -0.13704528f, 0.10149463f, 0.10179790f, 0.12222123f, 
    -0.04943092f, 0.11645691f, -0.10363521f, 0.01221197f, -0.11093759f, -0.03735569f, 0.03197909f, 0.10221547f, 
    -0.03893631f, 0.00935866f, 0.11049309f, -0.16133447f, 0.03845451f, -0.05927131f, -0.07439439f, -0.06601235f, 
    0.06664799f, -0.08464565f, -0.02233343f, -0.03127682f, 0.07316596f, 0.03650754f, -0.08189271f, 0.00879410f, 
    -0.08377694f, 0.04402470f, -0.02727119f, 0.01960844f, 0.00329168f, 0.04685771f, -0.00694650f, -0.06609973f, 
    0.01999964f, -0.04694168f, -0.09340194f, -0.00028988f, 0.00835561f, -0.00920144f, -0.01781994f, -0.06162516f, 
    -0.05053509f, 0.02420999f, 0.11297056f, 0.00922701f, -0.01683638f, 0.28088802f, 0.04410993f, 0.11414362f, 
    -0.00790578f, -0.07115907f, -0.01918216f, -0.02205481f, 0.02463791f, -0.05764361f, 0.03409508f, -0.05599115f, 
    -0.01330669f, 0.15668446f, -0.03233811f, 0.22963084f, -0.03548079f, -0.29671976f, 0.00241072f, 0.07520588f, 
    0.10537118f, 0.11008985f, -0.00611934f, -0.16864391f, 0.13908827f, 0.11294086f, -0.00762193f, 0.03193644f, 
    -0.03005600f, -0.00805390f, 0.00442572f, 0.02299033f, -0.00428187f, 0.11898825f, 0.14911553f, 0.07121876f, 
    -0.09006857f, 0.08834513f, 0.27214378f, -0.02428836f, -0.10471218f, -0.03584709f, -0.01106582f, -0.05727780f, 
    0.06840935f, 0.00731761f, 0.02743707f, 0.00346515f, -0.06666635f, -0.00216882f, -0.12711257f, -0.11198463f, 
    -0.02638215f, -0.19747515f, -0.06773378f, -0.15447302f, 0.06481338f, -0.21130526f, -0.12114483f, 0.07576730f, 
    0.29630947f, 0.11284813f, 0.05443853f, 0.04107477f, 0.00927636f, 0.01899846f, -0.05433810f, -0.00424281f, 
    0.02025899f, -0.12572369f, -0.03060628f, 0.08237238f, -0.28621826f, -0.12904422f, 0.10304819f, 0.13670428f, 
    0.21817116f, 0.07193345f, 0.06246963f, 0.01203222f, -0.00333197f, 0.12063193f, 0.04575450f, 0.00778525f, 
    0.11595405f, 0.08622237f, -0.03373259f, 0.00737301f, -0.00429378f, -0.02745276f, 0.11648748f, -0.02468389f, 
    -0.05552571f, 0.20122902f, -0.01367116f, -0.02322053f, -0.01038808f, 0.15536423f, 0.08974445f, 0.20231317f, 
    0.08337930f, -0.02493989f, 0.08817358f, 0.10145067f, -0.18406639f, 0.00954614f, -0.05150660f, 0.00935578f, 
    -0.13527548f, -0.16337210f, 0.08639688f, 0.01565984f, -0.01981542f, 0.07057817f, -0.04251735f, 0.05913808f, 
    -0.06883934f, -0.10006315f, 0.02876981f, -0.02720714f, -0.01185570f, 0.12295795f, 0.27484050f, -0.23850949f, 
    -0.00231681f, -0.04068639f, 0.04940911f, -0.05882186f, 0.02518981f, 0.02739988f, 0.02145652f, -0.01944228f, 
    -0.36936805f, 0.10789417f, -0.12651576f, 0.48034245f, -0.14491044f, -0.08712466f, -0.13275708f, -0.01372812f, 
    -0.05901248f, -0.12037078f, -0.07573266f, 0.04463898f, -0.00082797f, 0.06430348f, 0.09874859f, -0.02806371f, 
    0.02202803f, 0.01763063f, 0.04191492f, -0.03941333f, 0.00928860f, 0.06126661f, 0.11263182f, 0.03249615f, 
    -0.13467939f, -0.20917282f, -0.38230264f, -0.34879446f, -0.03939542f, 0.17053625f, -0.04117616f, -0.14014538f, 
    0.16361575f, 0.06987440f, -0.01618021f, 0.16451418f, 0.27647588f, -0.14434034f, 0.01341926f, -0.09535062f, 
    0.05347983f, 0.09310980f, 0.05333168f, -0.03347218f, 0.08912069f, -0.09019170f, -0.05242024f, -0.10451981f, 
    -0.08190912f, 0.00676876f, -0.37695915f, 0.11535638f, 0.08947591f, -0.24670802f, 0.06958688f, -0.23977387f, 
    0.06693806f, 0.05279097f, -0.14595544f, 0.17837223f, 0.14989096f, -0.15297274f, 0.20183633f, -0.01864350f, 
    -0.06453122f, 0.02801984f, -0.24155246f, -0.09513882f, 0.07514426f, 0.17458321f, -0.02747324f, 0.00745983f, 
    0.06159761f, 0.30454257f, 0.20098767f, 0.02764538f, -0.00026115f, 0.08091594f, -0.12275772f, 0.24638921f, 
    0.05941912f, 0.01735269f, -0.03722185f, -0.04598127f, 0.18352738f, 0.03205902f, -0.27975449f, 0.00844452f, 
    -0.05894973f, 0.16884983f, 0.05138909f, -0.08037360f, 0.08791183f, -0.04609345f, -0.08085772f, 0.14741379f, 
    0.03817418f, 0.14807343f, -0.05277472f, -0.11122021f, 0.04825838f, 0.00005645f, -0.10344315f, -0.04172649f, 
    0.03138416f, -0.02593949f, -0.21495843f, 0.14441104f, -0.27908954f, -0.08858655f, -0.26176238f, -0.06885429f, 
    0.12232967f, 0.00296059f, 0.07199839f, -0.15360633f, -0.08903872f, 0.10103849f, -0.14612697f, -0.03792059f, 
    0.19936283f, 0.16060470f, 0.03307348f, -0.02185100f, 0.10996547f, 0.00296931f, 0.05558872f, -0.02138167f, 
    0.05954134f, -0.05644100f, -0.03897402f, -0.01642075f, 0.05325134f, 0.20386527f, 0.16951984f, 0.08515891f, 
    0.05051308f, 0.02433286f, -0.06727719f, -0.02698348f, -0.08593144f, -0.01870192f, -0.09367853f, 0.11508107f, 
    -0.07462183f, -0.01313320f, -0.12707303f, 0.10287887f, 0.08838939f, -0.21894120f, -0.03069523f, 0.17843209f, 
    0.07968880f, 0.00218051f, 0.13855851f, -0.04816463f, 0.16932088f, -0.07447977f, 0.15655261f, 0.08262579f, 
    0.08187197f, -0.04888286f, 0.00655671f, 0.14693405f, 0.17969559f, 0.00824617f, -0.06648148f, 0.12244009f, 
    0.07999055f, 0.03095654f, -0.15854348f, 0.19296026f, -0.07994311f, -0.05634993f, -0.05957130f, -0.22264990f, 
    0.17832735f, -0.07713851f, 0.01205362f, 0.04409423f, -0.13804930f, 0.02490277f, 0.12578522f, -0.00060725f, 
    0.15857995f, -0.07536285f, -0.03488799f, 0.04410663f, 0.04194027f, -0.17521830f, 0.06963374f, -0.28110003f, 
    -0.38633674f, 0.21475765f, -0.15212940f, 0.10798864f, -0.13962831f, -0.00525182f, -0.18645409f, -0.04884876f, 
    0.14071108f, 0.08498995f, 0.09553743f, -0.02096183f, -0.60800236f, 0.34255886f, -0.17585553f, 0.18607649f, 
    0.05554765f, -0.03618004f, -0.06617711f, 0.12459613f, 0.10868719f, -0.09118357f, 0.07643498f, 0.05858269f, 
    0.51242870f, -0.16316794f, 0.08314479f, 0.07580835f, 0.13738038f, -0.05572509f, -0.04703119f, 0.04660356f, 
    0.19724479f, -0.02793863f, 0.08620384f, 0.18222529f, 0.20781104f, -0.07452485f, -0.18332791f, -0.17569745f, 
    0.13812557f, 0.03226453f, 0.18136628f, 0.21743141f, 0.04699160f, -0.09032939f, 0.03285700f, 0.00424858f, 
    0.16550875f, 0.19001067f, 0.02864368f, -0.01247248f, 0.00057144f, -0.00107255f, 0.10935850f, 0.04032534f, 
    -0.07519276f, 0.02355955f, 0.07705250f, 0.11732489f, -0.34512728f, 0.06572758f, 0.22360298f, 0.04790999f, 
    -0.12054903f, -0.04805240f, -0.01565639f, -0.15406677f, 0.02398870f, -0.15492918f, -0.02554649f, -0.00653006f, 
    0.22412623f, 0.18316282f, -0.21854614f, 0.14273773f, 0.17557910f, 0.12862003f, -0.06324574f, 0.19132794f, 
    0.13935587f, -0.11798629f, -0.13569345f, 0.16078635f, 0.06185815f, 0.19196141f, -0.16414379f, 0.26002422f, 
    -0.03063988f, 0.03207998f, 0.02469139f, 0.10628227f, -0.04817199f, 0.06318880f, 0.09213920f, -0.04806500f, 
    0.00137554f, 0.30584356f, 0.14253265f, -0.21923079f, -0.01063275f, 0.13536294f, 0.06954547f, 0.11279650f, 
    0.05220648f, -0.06472234f, -0.03675617f, -0.02593657f, 0.30606109f, -0.24134479f, 0.12350164f, 0.11414458f, 
    -0.07999304f, 0.09903556f, -0.06276299f, 0.01731201f, 0.09665955f, 0.00408975f, 0.01527175f, 0.09142691f, 
    0.05454483f, 0.02877346f, -0.13316277f, 0.15932044f, -0.02426359f, -0.04351829f, 0.06553888f, -0.03757152f, 
    -0.04555867f, 0.02140990f, 0.00573821f, 0.07644403f, 0.29916996f, 0.06358685f, -0.08152112f, -0.03896823f, 
    -0.09768702f, 0.12631863f, -0.17395312f, 0.14725569f, 0.11648094f, -0.05038727f, -0.09719928f, -0.02122037f, 
    0.24976265f, -0.30439338f, 0.16642332f, -0.00320003f, 0.11973277f, -0.14363848f, 0.08047475f, -0.23010683f, 
    0.00299344f, 0.07029467f, -0.01548588f, 0.10545452f, -0.11215397f, -0.07930579f, 0.06472526f, -0.00197600f, 
    0.05596178f, -0.11994364f, -0.12296952f, -0.28148583f, 0.13612472f, -0.04633035f, 0.06404954f, -0.01176189f, 
    -0.03891207f, -0.00237248f, -0.03285073f, 0.02150772f, 0.14867541f, -0.09654821f, 0.04063644f, -0.05715603f, 
    0.07594777f, -0.00442669f, 0.02121606f, -0.10822496f, 0.14311132f, -0.02955167f, 0.05488376f, -0.20486985f, 
    0.13945116f, -0.21698502f, -0.00091983f, -0.11860848f, -0.11043498f, -0.03997710f, -0.00804665f, -0.04228272f, 
    0.31946546f, 0.05090756f, 0.24690950f, -0.43714568f, -0.04248260f, -0.07875904f, 0.15545005f, 0.28138065f, 
    0.10688423f, 0.21018220f, -0.01395901f, 0.00663816f, -0.37784731f, -0.00504076f, -0.15089184f, -0.06408257f, 
    -0.02612595f, 0.02637353f, -0.09755726f, -0.04836067f, 0.07756145f, 0.04856132f, -0.10419695f, 0.02130033f, 
    -0.01903973f, -0.06746624f, 0.09287766f, -0.25573030f, -0.01069764f, -0.05168249f, -0.19739036f, -0.01443874f, 
    0.15466805f, 0.07508464f, -0.03641802f, 0.03368210f, 0.08898619f, 0.30786720f, -0.15804787f, -0.00008429f, 
    0.16926743f, -0.06489903f, 0.25519654f, 0.15805522f, 0.02289036f, -0.02301932f, -0.04623174f, 0.00493590f, 
    0.12707223f, 0.02015748f, 0.11969949f, -0.06306222f, 0.11139607f, 0.09500153f, 0.11821535f, 0.19909430f, 
    0.04810267f, -0.03970720f, 0.05905519f, 0.06761005f, 0.01816195f, 0.36042404f, -0.01001430f, 0.16822833f, 
    0.10572615f, 0.14631228f, 0.09308130f, -0.04949255f, -0.07171465f, -0.04351228f, 0.05966647f, -0.11563905f, 
    0.30059636f, -0.21847528f, 0.07482953f, 0.13931791f, -0.08894844f, 0.20996769f, 0.01774143f, -0.01781508f, 
    0.17261927f, -0.06492009f, 0.05677988f, 0.14843349f, -0.33534625f, -0.05497497f, 0.12061365f, 0.21396416f, 
    0.01883037f, -0.02676962f, -0.09411497f, 0.07577773f, 0.02437300f, -0.34365627f, 0.01332715f, -0.06122863f, 
    0.02622681f, -0.23518988f, 0.19075230f, -0.14938229f, -0.03641797f, -0.03932766f, -0.00946626f, 0.05841775f, 
    -0.00651229f, 0.06385204f, -0.12317113f, 0.08772251f, -0.22930837f, 0.03320149f, -0.53704089f, -0.24643052f, 
    -0.11256403f, 0.01412152f, -0.04121781f, -0.07163817f, -0.02359429f, -0.04514388f, -0.06154511f, 0.02850896f, 
    0.01959219f, 0.03741550f, -0.22767277f, -0.06252716f, 0.04272363f, -0.05744098f, -0.02679410f, 0.22140259f, 
    0.16314329f, -0.03401257f, -0.13732615f, 0.05781901f, 0.13666968f, -0.04379006f, 0.17852530f, -0.12422265f, 
    -0.11892103f, 0.07167760f, -0.17907667f, 0.19115222f, -0.05559248f, 0.10004910f, 0.07214313f, -0.04879262f, 
    0.04659799f, 0.28127679f, 0.15300094f, 0.00619951f, 0.02042521f, -0.15277624f, -0.00126391f, 0.15458228f, 
    0.05700330f, -0.02025513f, 0.05781563f, 0.05302071f, 0.23641166f, 0.12346917f, 0.01970292f, 0.05592050f, 
    0.14553533f, -0.08633792f, -0.03850695f, 0.09987567f, 0.15107396f, -0.04849457f, 0.03705168f, 0.08774494f, 
    0.10184519f, -0.08160108f, 0.17822240f, -0.25032178f, 0.00309478f, -0.13119581f, 0.18208948f, 0.02306202f, 
    0.03513571f, 0.00598559f, 0.03069114f, 0.09163278f, 0.09825098f, -0.23414186f, 0.01430855f, -0.24124889f, 
    0.00534436f, 0.20203717f, -0.19725263f, -0.00666290f, -0.04078049f, -0.03622090f, 0.12848465f, 0.04762611f, 
    0.06724883f, 0.39172214f, 0.41888434f, 0.40510249f, 0.09047942f, 0.29550105f, -0.10728821f, 0.08440323f, 
    0.03598372f, -0.04477410f, -0.12077440f, -0.00198601f, 0.25449058f, -0.27431825f, 0.47580042f, -0.33712062f, 
    0.03154255f, -0.02725988f, -0.10312146f, 0.04424561f, -0.07036643f, -0.03951325f, -0.03008348f, 0.02099207f, 
    -0.23130848f, 0.02069481f, 0.10920041f, 0.10061532f, 0.06960900f, 0.11175419f, 0.09403716f, -0.04195902f, 
    0.03834551f, -0.05028819f, 0.17185542f, 0.13176684f, 0.20823276f, 0.10532875f, 0.02666811f, -0.35868680f, 
    0.02827336f, -0.06326614f, 0.01440559f, 0.08132497f, -0.03486998f, -0.09876863f, -0.10432354f, -0.13712271f, 
    0.40046293f, -0.22527733f, 0.08207015f, 0.10045058f, 0.00271626f, -0.15325186f, -0.13450189f, -0.03957093f, 
    0.03554874f, 0.10194223f, 0.02963295f, 0.06387851f, -0.41495061f, -0.11425403f, 0.21267548f, -0.18662708f, 
    -0.12352268f, 0.09291866f, -0.35365456f, 0.14229932f, 0.02328465f, -0.01213522f, 0.03113810f, -0.01857967f, 
    0.23121300f, -0.12034264f, 0.03910845f, 0.03294912f, 0.02733847f, 0.16973379f, -0.10918165f, 0.07574657f, 
    0.17534642f, -0.03956233f, 0.04227874f, 0.05269998f, 0.06421635f, -0.15055172f, 0.10525948f, -0.04002216f, 
    0.00681756f, 0.02649600f, 0.00356524f, -0.09179631f, 0.14956658f, 0.00160676f, 0.08846492f, 0.02696700f, 
    -0.32897797f, 0.03585661f, 0.13121670f, 0.07780743f, -0.01287707f, 0.09997350f, -0.27068117f, 0.03003555f, 
    0.06294858f, -0.15953436f, 0.09757023f, -0.00671530f, 0.09327819f, -0.01933845f, 0.21937746f, 0.01607553f, 
    -0.01697896f, 0.15751262f, 0.07282435f, 0.02291406f, 0.08831207f, 0.07900728f, 0.08525552f, 0.22602786f, 
    0.09237818f, -0.09911740f, -0.02503259f, 0.06701665f, 0.00898234f, -0.01816047f, 0.14322160f, 0.07453474f, 
    -0.00398895f, 0.13976578f, 0.06190275f, 0.06204760f, 0.13400997f, -0.13281010f, 0.02553245f, -0.06575618f, 
    0.00216027f, -0.05381395f, 0.07243741f, 0.01367028f, 0.05164232f, 0.10255383f, 0.10043506f, 0.06345949f, 
    -0.28910050f, 0.03992482f, -0.02208606f, -0.20705800f, 0.00699620f, -0.10990691f, -0.09893234f, 0.07824822f, 
    0.10709944f, -0.08751012f, -0.09654120f, -0.09591869f, -0.09820244f, -0.08299605f, 0.13360953f, -0.33865833f, 
    0.07050948f, 0.07211285f, -0.19097289f, -0.10768287f, -0.15254082f, -0.04369864f, 0.09525864f, -0.01819610f, 
    0.23369221f, -0.01817922f, 0.31758299f, -0.15844968f, -0.11415976f, -0.00812113f, 0.02306924f, -0.12440114f, 
    0.03670040f, -0.03074672f, 0.10434611f, 0.00336292f, -0.09767732f, 0.09550869f, 0.26495928f, -0.09093382f, 
    0.07141861f, 0.07013047f, -0.14936703f, -0.10695837f, 0.03955702f, -0.01360719f, 0.00741891f, 0.04298869f, 
    0.03331563f, -0.00837630f, 0.08004003f, 0.31110397f, 0.06329165f, 0.04141360f, -0.04181752f, 0.12565330f, 
    -0.04006866f, -0.05221614f, 0.11709734f, -0.05805582f, -0.14367941f, -0.09125983f, 0.01724911f, -0.08354072f, 
    -0.07237185f, -0.10109710f, -0.17780180f, -0.20634259f, 0.07116641f, -0.00998983f, -0.03952696f, 0.08692303f, 
    0.02333106f, -0.03853219f, -0.01497523f, -0.01479804f, 0.02809654f, 0.01670082f, -0.02774868f, 0.02481881f, 
    -0.00648875f, -0.01740171f, -0.03391301f, 0.00837552f, 0.00359371f, 0.01410315f, 0.02799797f, -0.01177001f, 
    0.00919653f, 0.00183793f, -0.00368062f, -0.00772308f, 0.00851472f, -0.03017540f, 0.01941392f, 0.02374756f, 
    0.02690553f, 0.00269795f, 0.00950925f, 0.01325645f, -0.00779217f, -0.03371525f, -0.00897816f, 0.00065321f, 
    -0.00758477f, -0.01445740f, -0.03164530f, 0.02337292f, 0.03003786f, 0.01178094f, 0.01190649f, -0.01498392f, 
    -0.03469109f, 0.02543372f, 0.01956704f, -0.01974373f, -0.01303826f, 0.00570180f, 0.01973662f, 0.00034594f, 
    -0.00171127f, 0.01568390f, -0.00726347f, 0.00912063f, 0.01845331f, -0.03842425f, -0.02392120f, -0.01795239f, 
    -0.02892393f, -0.01549490f, -0.03140428f, 0.00700890f, -0.02936333f, -0.00302912f, -0.02869855f, -0.01680711f, 
    -0.03780347f, 0.01388378f, -0.02634210f, -0.00343008f, -0.00747433f, 0.01182031f, 0.02076812f, 0.03244159f, 
    -0.02251371f, 0.00593196f, 0.00009121f, -0.04129428f, -0.03099864f, -0.01786025f, -0.03792187f, 0.00569418f, 
    -0.02330273f, -0.01914723f, -0.04398156f, -0.04813092f, -0.02750014f, 0.01327638f, 0.02901880f, 0.02780778f, 
    -0.00232898f, 0.03934518f, -0.00092880f, -0.01046416f, -0.00032165f, -0.03462832f, -0.01258536f, 0.00292496f, 
    0.02209402f, -0.01339551f, -0.02696279f, -0.01451794f, -0.02965923f, -0.00591060f, -0.02816993f, 0.00801047f, 
    0.00599903f, -0.01406027f, 0.00618569f, 0.01969163f, 0.01104367f, 0.00959094f, -0.03132707f, 0.00506091f, 
    0.02040762f, 0.03247328f, -0.01473896f, 0.03185190f, 0.01755588f, -0.00751593f, 0.02819475f, -0.02451133f, 
    -0.02636209f, 0.01064167f, -0.02731390f, 0.00126219f, 0.02333171f, 0.01166127f, -0.02325433f, -0.00821785f, 
    -0.02292325f, 0.02689566f, 0.02435544f, 0.02409584f, -0.00405087f, -0.01413142f, -0.02787992f, 0.02145884f, 
    0.02266432f, 0.02047133f, -0.02414606f, -0.01290721f, -0.02100507f, -0.03746655f, -0.03021740f, -0.04373132f, 
    -0.00569213f, -0.01043126f, -0.00871068f, -0.02006475f, -0.02670046f, -0.02969302f, -0.02829119f, -0.01014361f, 
    -0.00259948f, 0.01874531f, -0.01418172f, 0.01280821f, -0.03112115f, 0.01528476f, 0.00011224f, -0.00612079f, 
    0.01833342f, -0.02627138f, -0.02734367f, -0.00802070f, -0.02806083f, 0.02391124f, -0.03224927f, 0.02037355f, 
    -0.04172922f, -0.02949240f, -0.03965320f, -0.03981466f, 0.00164910f, 0.02343124f, -0.03391613f, 0.02480773f, 
    0.00807600f, -0.00249531f, -0.01769783f, -0.04152855f, 0.00682494f, -0.01479366f, -0.00438484f, 0.01338530f, 
    -0.03105947f, -0.00105991f, -0.01228344f, 0.01285801f, 0.00913161f, -0.03516766f, -0.01080002f, 0.00594324f, 
    0.00478092f, -0.00715394f, 0.03012838f, 0.01973831f, -0.04078321f, 0.00276078f, -0.02110115f, 0.00017101f, 
    -0.02367665f, 0.02470397f, -0.03169452f, -0.00018069f, 0.01457048f, -0.00413386f, -0.02221189f, -0.02962021f, 
    -0.03327376f, -0.02406687f, -0.01960539f, 0.00978340f, -0.00903482f, -0.02954683f, 0.01727171f, -0.01724843f, 
    -0.03251389f, -0.01276197f, 0.02049354f, -0.01768929f, -0.01367614f, -0.03819116f, 0.01819642f, 0.01890418f, 
    -0.02170408f, 0.02784291f, -0.02674154f, -0.03086635f, -0.01242022f, -0.03951088f, -0.01053645f, -0.00396318f, 
    -0.00539140f, -0.03301705f, 0.02499414f, -0.00066871f, -0.03119804f, -0.03375505f, -0.02476442f, 0.00977108f, 
    0.00970126f, -0.02614582f, 0.01443056f, 0.01290402f, -0.03760219f, -0.02682819f, -0.03592800f, 0.02632383f, 
    -0.03915751f, -0.02378513f, 0.00862323f, -0.02517916f, -0.04367607f, 0.01949899f, 0.00955964f, -0.04732644f, 
    -0.00540638f, -0.00356034f, 0.00483805f, 0.01410610f, -0.02360917f, 0.02482145f, -0.00732765f, 0.00750810f, 
    0.00500484f, -0.00058167f, -0.02049837f, 0.00727845f, 0.02219315f, 0.01438890f, -0.03507365f, -0.02298567f, 
    -0.00774314f, 0.02899674f, 0.01982443f, 0.02032633f, 0.02962037f, -0.03072246f, 0.02427145f, 0.00086362f, 
    -0.01587788f, 0.02502888f, 0.00484566f, -0.00006918f, -0.03839991f, 0.02485947f, -0.04695543f, -0.04624942f, 
    -0.03245039f, 0.01239466f, -0.00543469f, 0.02538139f, -0.03673013f, -0.03921667f, -0.00620767f, 0.00141459f, 
    0.01424179f, -0.01576247f, 0.02789377f, -0.03391078f, -0.03460467f, 0.00389697f, 0.01269064f, -0.03287518f, 
    -0.00464529f, -0.03294784f, 0.01622283f, -0.02259022f, -0.00977412f, 0.02457332f, -0.02779854f, -0.02924422f, 
    -0.03327347f, -0.01604035f, -0.01658338f, 0.01330558f, -0.03382721f, -0.01707313f, 0.02628819f, -0.03946206f, 
    -0.03331043f, -0.03735386f, 0.00591560f, 0.01641947f, 0.00616854f, -0.02354162f, 0.01432694f, -0.02951542f, 
    -0.00361871f, -0.00655910f, -0.01420496f, -0.02193814f, -0.00452379f, -0.01958898f, -0.02006220f, 0.00186426f, 
    0.01372647f, 0.02840687f, 0.02565472f, -0.01004652f, -0.01724729f, 0.00580906f, -0.00600426f, -0.00969830f, 
    -0.01528451f, -0.02442530f, -0.02541718f, 0.01209637f, -0.03213250f, 0.02294428f, -0.02655797f, 0.01658435f, 
    -0.00389400f, 0.01919659f, -0.01678189f, 0.01773806f, -0.03710701f, 0.00794726f, 0.02472299f, -0.00495638f, 
    0.01793710f, -0.01596205f, -0.02772155f, -0.01737433f, -0.03484330f, -0.02580982f, -0.00297693f, 0.00007276f, 
    0.01178567f, 0.01628973f, -0.02532937f, -0.03235033f, -0.03385574f, -0.04148658f, 0.01536910f, 0.03075568f, 
    -0.01416050f, 0.01344195f, 0.01217082f, 0.01148451f, -0.02155988f, 0.00008039f, 0.00144102f, -0.02669207f, 
    0.00452004f, 0.03049039f, -0.02399800f, -0.00667631f, -0.01541578f, -0.00498464f, 0.01411546f, -0.03841364f, 
    -0.02078301f, 0.00787214f, -0.00468449f, -0.00241520f, -0.00369017f, -0.02775592f, -0.00610020f, -0.01817542f, 
    -0.04175392f, -0.01497346f, 0.00681048f, -0.00252059f, -0.01214410f, -0.03455621f, 0.01993915f, -0.00787850f, 
    -0.00950680f, -0.00809564f, 0.01322157f, 0.00541248f, -0.03800755f, -0.01219170f, -0.00471211f, -0.02417818f, 
    -0.01443855f, 0.01926021f, 0.00358245f, -0.01320803f, -0.01632232f, -0.02073036f, 0.00880974f, -0.00021333f, 
    -0.03509863f, 0.02166671f, -0.02888692f, -0.03421896f, -0.02016323f, 0.00057005f, 0.00834185f, -0.02661472f, 
    0.03287933f, 0.00104617f, 0.00289701f, -0.04324267f, -0.03127381f, -0.01355909f, -0.01245795f, -0.03025497f, 
    -0.03563472f, 0.01905887f, -0.00115684f, -0.01210276f, 0.01127943f, -0.01286922f, 0.02715012f, 0.01266872f, 
    0.01731170f, -0.02737663f, -0.04435230f, 0.02662949f, -0.04233987f, 0.01992290f, -0.03016159f, -0.01326837f, 
    -0.03282043f, -0.01748403f, -0.01465919f, -0.03149724f, 0.00524988f, -0.01554293f, -0.04181682f, -0.03862854f, 
    0.00442549f, 0.02584493f, 0.00693797f, 0.02832745f, 0.02948667f, 0.02825187f, -0.00126028f, -0.02666040f, 
    0.01915520f, -0.01497438f, -0.03140507f, -0.02573523f, -0.03689941f, -0.00703600f, -0.00009810f, -0.00527182f, 
    0.01397828f, 0.02465849f, -0.01626926f, -0.02312109f, -0.00356793f, -0.00484726f, -0.02973682f, -0.03928122f, 
    0.00584557f, -0.01718633f, -0.03392383f, 0.00991923f, -0.00301789f, -0.00520815f, 0.02852445f, -0.00106272f, 
    -0.03448225f, -0.00550594f, -0.03334115f, 0.02351077f, -0.02065482f, -0.02427294f, 0.01417401f, -0.02075399f, 
    -0.00920908f, -0.02737891f, 0.00242845f, -0.02769018f, -0.00677480f, 0.02176768f, -0.03683195f, 0.01467353f, 
    0.00153745f, -0.03332185f, -0.01983089f, -0.00372964f, 0.02536959f, -0.00642021f, 0.01179691f, -0.04544366f, 
    0.00627096f, -0.02124078f, -0.02379139f, -0.04108995f, -0.03004551f, -0.03721622f, -0.02688991f, 0.00559978f, 
    0.01136551f, -0.01267743f, -0.04636602f, -0.00997645f, 0.00552308f, 0.02254548f, -0.00752647f, 0.00158596f, 
    0.00945301f, 0.01160008f, -0.01970410f, -0.02523706f, -0.00994102f, 0.01877841f, 0.03179664f, 0.01611437f, 
    -0.02813362f, 0.02218558f, 0.02553347f, 0.01673779f, -0.03944419f, -0.02931357f, 0.00288148f, -0.00587154f, 
    -0.02840316f, -0.01804875f, -0.03135642f, 0.01361257f, -0.02369393f, 0.00339672f, 0.02565749f, 0.00417008f, 
    -0.00007999f, 0.02828800f, -0.01023055f, 0.01519441f, -0.01627017f, -0.01681340f, -0.01698915f, -0.00913777f, 
    -0.04358785f, 0.01440529f, 0.00108228f, -0.00613786f, 0.00720942f, -0.01906585f, 0.00702365f, -0.03611945f, 
    0.02909419f, 0.02598875f, -0.01874910f, -0.01421242f, 0.00364029f, -0.02259078f, -0.00687683f, -0.03959482f, 
    -0.00827315f, -0.01814467f, 0.00595294f, 0.00818692f, -0.02546742f, 0.00697619f, 0.02133636f, -0.00721234f, 
    -0.02178691f, 0.00674058f, -0.03801679f, 0.01152374f, -0.00762262f, -0.03875285f, -0.03445596f, 0.02490081f, 
    -0.01355624f, 0.02331992f, 0.00637117f, -0.02880568f, -0.03316629f, 0.01239865f, 0.02449381f, 0.01828544f, 
    0.01345062f, 0.00316919f, -0.02439494f, -0.01119841f, 0.00537678f, 0.01085366f, -0.01392137f, -0.01398724f, 
    0.02197854f, 0.01879044f, 0.01513179f, 0.02049161f, 0.02066494f, -0.00815928f, -0.03816847f, -0.03320707f, 
    -0.00795530f, -0.01970311f, -0.02461810f, -0.04234288f, -0.01332280f, 0.00093080f, -0.04280652f, -0.01867086f, 
    -0.00223085f, -0.02541590f, -0.03822397f, -0.02635909f, 0.00764163f, -0.00898161f, -0.02355025f, -0.02842156f, 
    -0.00596867f, 0.00062073f, 0.02923239f, 0.03117619f, -0.00428098f, 0.00086739f, 0.00324216f, -0.01026311f, 
    -0.00284285f, 0.00731061f, 0.00927187f, 0.00117029f, 0.01889407f, 0.00756815f, -0.00015713f, 0.00387758f, 
    -0.04137478f, -0.00708207f, -0.01507256f, 0.01684770f, -0.00032636f, 0.00196177f, -0.00058855f, -0.01671088f, 
    -0.03812167f, -0.02009716f, -0.01765739f, -0.00728211f, 0.00062862f, -0.03723955f, -0.01809775f, -0.03918127f, 
    0.00527096f, 0.00241334f, -0.02986010f, 0.00720736f, 0.02911667f, 0.00322883f, -0.00448750f, 0.00900082f, 
    0.02509426f, 0.00192495f, -0.00516392f, 0.01979463f, -0.02378245f, -0.03893815f, -0.00369856f, 0.02911015f, 
    -0.01238458f, 0.01742690f, -0.02622407f, 0.01676214f, 0.00445052f, -0.02945535f, -0.00048496f, 0.01858827f, 
    -0.00335123f, 0.02181992f, -0.00529008f, -0.03011485f, 0.00244462f, 0.02625095f, -0.03130802f, -0.02963117f, 
    -0.00781780f, -0.00000349f, 0.00298278f, -0.00983729f, -0.01018745f, -0.03136032f, -0.01989450f, 0.01166305f, 
    0.01904795f, -0.01737390f, -0.02588609f, 0.02446588f, 0.00971927f, 0.00987696f, 0.02584161f, -0.03095164f, 
    -0.00765344f, -0.04573958f, -0.01358118f, -0.03854727f, 0.02086548f, 0.02607046f, -0.03647790f, 0.00188239f, 
    0.02155415f, -0.01549278f, -0.02181699f, 0.00348059f, -0.03876226f, -0.01508575f, -0.01264982f, 0.00947579f, 
    -0.01571695f, -0.02171179f, -0.01150593f, -0.02493690f, -0.01982921f, -0.00851008f, 0.02739655f, -0.00356617f, 
    -0.02317118f, 0.00031593f, -0.03958093f, -0.01252614f, 0.01461131f, -0.02338473f, -0.02863753f, 0.01675500f, 
    -0.02866165f, -0.04775715f, -0.04321948f, 0.01934215f, -0.03609123f, 0.03097238f, 0.03092548f, -0.02425789f, 
    -0.02203989f, -0.00087751f, 0.02811014f, 0.02385873f, -0.01605613f, 0.01618040f, 0.01773997f, 0.02110938f, 
    -0.31900668f, 0.00564740f, -0.04023529f, -0.15989710f, 0.03032444f, 0.02719445f, 0.03160762f, -0.02702305f, 
    -0.03514637f, -0.07071877f, 0.03922936f, 0.08392848f, 0.12588833f, -0.17131169f, -0.10608200f, -0.03995747f, 
    0.08316320f, -0.02097104f, 0.00015835f, -0.06209867f, 0.14165798f, -0.06054830f, 0.01144770f, -0.00851718f, 
    -0.14014889f, -0.04330574f, -0.06751721f, -0.10593061f, 0.09726350f, 0.04150392f, -0.00412271f, 0.00232486f, 
    -0.08120152f, 0.14473820f, 0.06201549f, 0.11757287f, 0.08697950f, -0.14279619f, 0.03977367f, -0.04201408f, 
    0.07651987f, -0.05140663f, -0.07099292f, -0.09444584f, 0.04139883f, 0.05692761f, -0.00760491f, 0.07657140f, 
    0.14786048f, 0.07697142f, 0.26721662f, 0.15746151f, -0.00520853f, -0.03329606f, 0.13728081f, 0.01918445f, 
    0.05395471f, 0.02164287f, -0.00611378f, 0.04147016f, 0.22396472f, -0.31934339f, 0.02503916f, -0.02304113f, 
    0.08115167f, 0.12413254f, -0.07928491f, 0.00538326f, 0.11609293f, 0.03671118f, -0.08606747f, -0.04675405f, 
    -0.07824049f, 0.05709353f, -0.21597899f, 0.16344510f, 0.07915561f, -0.05725322f, 0.00272113f, -0.02648661f, 
    0.00251989f, -0.09720165f, 0.13640186f, 0.08084662f, -0.16052620f, -0.21515663f, 0.00031737f, 0.08091379f, 
    0.03847766f, 0.04830585f, -0.05623091f, 0.12049167f, 0.01377869f, -0.00119498f, 0.17799881f, 0.05495483f, 
    0.18401402f, -0.13100132f, 0.04033837f, 0.08226960f, 0.06622564f, -0.08176925f, -0.04328589f, -0.08943240f, 
    0.05744771f, -0.02840852f, 0.07841305f, 0.07893161f, 0.30430964f, 0.03169217f, 0.11981346f, 0.23914969f, 
    0.01256595f, -0.12160502f, 0.22656786f, 0.13606420f, -0.00446554f, 0.14948726f, -0.06200704f, -0.00963521f, 
    -0.01037944f, 0.10491178f, -0.07817695f, 0.06626581f, -0.01212974f, 0.09101523f, -0.07157616f, 0.08307718f, 
    0.03932355f, -0.02494561f, -0.05061191f, -0.10322228f, -0.01216836f, 0.12202208f, -0.22170047f, -0.10564004f, 
    0.14662871f, -0.06913150f, 0.09455312f, -0.00525226f, -0.09188420f, 0.11039769f, 0.18298760f, 0.07345458f, 
    -0.09888089f, 0.04520440f, -0.01108298f, -0.06539815f, -0.00374844f, 0.02629817f, -0.01947289f, 0.01645068f, 
    -0.02347973f, 0.05616041f, 0.11978722f, -0.01129555f, 0.07840700f, 0.14235322f, 0.10704117f, -0.08803096f, 
    0.05421240f, 0.09950519f, -0.12501958f, 0.00630827f, 0.06761857f, -0.04820834f, -0.01016105f, -0.01996343f, 
    -0.39590302f, 0.33108574f, 0.00575090f, 0.14243336f, -0.13627882f, 0.03463439f, -0.00406644f, -0.04671868f, 
    0.02429882f, 0.08479489f, 0.20935678f, -0.04914667f, -0.24554040f, 0.25170767f, 0.07121134f, 0.12647192f, 
    0.01129485f, 0.12568231f, -0.08567096f, 0.02823886f, -0.02759019f, -0.00327018f, -0.00926985f, -0.03934656f, 
    -0.13197562f, -0.35186568f, -0.32031873f, -0.15922195f, 0.14751045f, 0.03963250f, 0.15483394f, 0.16708940f, 
    0.13861293f, 0.06039880f, 0.10498584f, -0.04420860f, 0.46645528f, -0.00866590f, 0.00795198f, 0.03945410f, 
    0.19161816f, 0.16421026f, 0.03314950f, 0.12906256f, 0.06101862f, -0.07544643f, -0.05550151f, -0.03528823f, 
    -0.01065263f, -0.34655055f, -0.20641038f, -0.06386455f, 0.07543752f, -0.07692112f, 0.01661650f, 0.18358766f, 
    -0.10298187f, -0.03596872f, 0.10027871f, 0.12144174f, -0.40384319f, 0.11508315f, 0.21974353f, 0.06533578f, 
    -0.08435691f, -0.01245172f, 0.04173087f, 0.16319956f, -0.02406054f, 0.05023829f, -0.00420536f, 0.10025383f, 
    0.33461064f, 0.11455161f, 0.08493776f, -0.06119166f, 0.04009295f, 0.15912861f, -0.07964335f, -0.10916270f, 
    -0.00966417f, -0.11724242f, 0.02092840f, -0.03038499f, -0.17967568f, 0.04932463f, -0.11734775f, -0.10582688f, 
    0.02265378f, 0.02390461f, -0.05436517f, -0.01321904f, 0.07819592f, -0.05458444f, 0.22772861f, 0.21619171f, 
    0.10471433f, 0.15380965f, 0.05093875f, 0.09624645f, -0.08943950f, 0.03516951f, 0.12265068f, 0.04933864f, 
    0.01508584f, 0.01058386f, 0.06501047f, -0.04284963f, -0.15943244f, -0.45011148f, -0.26275480f, -0.29904369f, 
    0.07776460f, 0.06295251f, 0.02739098f, 0.15224254f, 0.03475262f, -0.07557837f, 0.03918749f, 0.16653211f, 
    -0.02019775f, -0.12576021f, -0.13097689f, -0.15094742f, 0.11073385f, -0.04351353f, -0.01641922f, 0.06200683f, 
    -0.15371911f, 0.08398780f, 0.02661640f, 0.07545915f, -0.22340208f, 0.11171386f, -0.18289882f, -0.10759898f, 
    0.05231994f, 0.03668347f, 0.03797022f, 0.00264937f, 0.17783318f, 0.10752971f, 0.01530677f, 0.03649308f, 
    -0.01141392f, -0.39584053f, -0.29626259f, 0.15365770f, 0.08771032f, -0.05132104f, 0.07726933f, 0.08911593f, 
    -0.02690947f, -0.11444293f, 0.00752304f, -0.05704897f, -0.09624854f, -0.02051401f, -0.01473003f, -0.12030486f, 
    -0.04522125f, 0.07973761f, -0.02008246f, -0.04800258f, 0.01165808f, -0.09366717f, -0.05396087f, 0.01461811f, 
    0.64428222f, 0.03163804f, 0.47481838f, -0.25653663f, 0.04894854f, -0.08134926f, 0.00440135f, -0.06562322f, 
    0.01556231f, 0.02981638f, -0.03707299f, -0.05883240f, -0.03847950f, -0.10030965f, -0.14413722f, -0.05861599f, 
    0.06021425f, -0.03408877f, 0.03240917f, -0.03217011f, 0.06057874f, -0.05979540f, -0.01523478f, 0.01050302f, 
    -0.01502474f, 0.15815094f, 0.13469142f, 0.11650338f, -0.13119414f, 0.02673293f, 0.04574465f, -0.02537768f, 
    -0.07376536f, 0.10033648f, -0.10391410f, -0.05773052f, -0.03818766f, -0.16163267f, 0.18944317f, 0.31064177f, 
    0.02896447f, -0.06270029f, 0.08170910f, 0.12586562f, 0.01003312f, 0.09922697f, -0.08555815f, 0.00454856f, 
    0.05338495f, 0.08494618f, 0.06173762f, -0.25326371f, 0.01190843f, -0.00139770f, -0.04040402f, 0.01686874f, 
    0.00554630f, -0.06362122f, -0.07444888f, 0.10565428f, 0.22516496f, 0.32528961f, 0.25458086f, -0.06744075f, 
    0.10653856f, 0.12086018f, -0.09781525f, 0.12553471f, 0.01432544f, -0.06308495f, -0.04247553f, -0.04400402f, 
    0.16363655f, 0.18396342f, 0.01925852f, 0.06945281f, -0.05711837f, 0.11496339f, 0.15845348f, -0.03943367f, 
    -0.02589682f, -0.07569605f, 0.03367171f, -0.00863346f, 0.32767025f, 0.24841991f, 0.09180155f, 0.30658770f, 
    -0.08234352f, 0.15759927f, 0.06436434f, 0.16777271f, 0.01868882f, 0.03645180f, 0.04744168f, -0.04685640f, 
    -0.18861078f, -0.55627137f, -0.21727671f, -0.14140204f, 0.08358568f, 0.12245154f, 0.04203237f, 0.02251728f, 
    0.15482721f, 0.02655804f, -0.05789128f, 0.03397594f, 0.10933758f, 0.00794654f, 0.24379709f, 0.03552582f, 
    0.04119882f, 0.13703004f, -0.04589909f, 0.06999195f, 0.05357088f, -0.00784552f, 0.07623950f, -0.04308238f, 
    -0.20499142f, 0.21053217f, -0.05411361f, -0.09445727f, -0.00073710f, -0.00044407f, 0.06836750f, 0.08642138f, 
    -0.04704927f, 0.02683310f, -0.02868699f, -0.07057557f, -0.02780054f, -0.21122280f, 0.15784332f, 0.14695463f, 
    -0.00470006f, 0.15030544f, 0.06209104f, -0.07526833f, -0.04063078f, 0.13281715f, 0.03502729f, -0.06968128f, 
    0.01516632f, 0.06307011f, -0.11079502f, 0.28700799f, -0.06303364f, 0.13907965f, 0.10311165f, -0.04169102f, 
    0.06297781f, 0.04280369f, 0.18493788f, -0.07215211f, -0.13868237f, 0.16156788f, -0.19928911f, -0.14403608f, 
    0.05686108f, -0.13467862f, 0.03588948f, -0.00468959f, -0.04043159f, -0.04122186f, -0.06234338f, 0.09497383f, 
    -0.16440286f, 0.01210712f, -0.41381043f, -0.06310123f, 0.06197602f, 0.08678991f, 0.16009228f, -0.00988308f, 
    -0.03038409f, -0.06199761f, 0.14985487f, 0.20178902f, -0.04065681f, 0.29489490f, -0.19484249f, 0.01110113f, 
    0.03908083f, 0.03485474f, 0.00989401f, -0.01455865f, 0.03975948f, 0.06255220f, 0.16689816f, -0.12098575f, 
    0.16969761f, -0.01640018f, 0.15058549f, 0.02716310f, 0.11108698f, -0.08934654f, 0.23013628f, -0.08016618f, 
    -0.05360902f, -0.10335887f, 0.07626008f, 0.06748671f, 0.03339109f, 0.00570455f, -0.14916436f, 0.04502868f, 
    -0.07280095f, 0.02426848f, 0.08537374f, -0.01091407f, -0.06163820f, 0.06837533f, 0.07276037f, -0.02157403f, 
    0.10906519f, -0.14905673f, 0.17300230f, -0.02881971f, 0.04403169f, 0.04057414f, 0.08752882f, -0.03137097f, 
    0.15325330f, 0.07060843f, 0.03797102f, 0.13769840f, 0.05413223f, 0.29266754f, 0.11804482f, -0.17745042f, 
    0.02884123f, -0.15259132f, -0.02570938f, -0.15078147f, -0.01969649f, 0.00277304f, 0.06131960f, 0.01059758f, 
    -0.09853528f, -0.10380858f, 0.01476588f, 0.10118071f, -0.07319121f, 0.07432518f, 0.04921523f, 0.02140751f, 
    -0.10010709f, -0.16828522f, 0.01602327f, -0.26336294f, 0.17042741f, 0.16196033f, 0.03627535f, -0.21217217f, 
    -0.05335658f, -0.02278901f, -0.00170088f, 0.00242138f, 0.06147644f, -0.06318187f, -0.01031029f, -0.04219087f, 
    -0.04657900f, -0.07498415f, -0.20568447f, -0.09914536f, 0.04711429f, 0.00889618f, -0.02377929f, 0.02877941f, 
    0.05349730f, 0.08068635f, -0.06085400f, 0.08685151f, 0.22365552f, -0.04639849f, 0.22450258f, 0.17143202f, 
    0.07546438f, -0.03762923f, -0.01510673f, 0.00538652f, -0.03092366f, 0.00049853f, -0.01322986f, -0.09921452f, 
    -0.08122002f, 0.04663917f, -0.27328268f, 0.04184425f, 0.00803526f, 0.02830662f, 0.04706036f, 0.06294937f, 
    0.09587217f, -0.06865020f, -0.12499438f, 0.00475047f, -0.12355158f, -0.09257852f, -0.00002962f, -0.09931340f, 
    -0.00177951f, -0.03174568f, 0.02059359f, -0.00982331f, -0.02485089f, -0.09007666f, -0.09739459f, -0.06199431f, 
    0.01525929f, -0.10088334f, -0.01827909f, 0.34959936f, 0.01817762f, -0.08043971f, -0.03180782f, 0.05756597f, 
    -0.07588303f, -0.02858666f, 0.00744914f, -0.02896765f, 0.18043368f, -0.09546340f, -0.00320392f, 0.04746461f, 
    -0.05657736f, 0.07414178f, 0.17959493f, 0.18891700f, -0.05589263f, 0.02068926f, -0.00348919f, 0.05865033f, 
    -0.19747727f, 0.01078440f, -0.16050501f, 0.08449333f, -0.05223901f, 0.01844998f, -0.01264625f, -0.02054470f, 
    0.03486124f, 0.12843320f, -0.15134856f, -0.19873407f, 0.14980617f, -0.02298019f, 0.15145946f, 0.15182169f, 
    0.01362765f, 0.01449977f, -0.04633211f, 0.08528578f, -0.18351620f, -0.13386631f, -0.09310755f, -0.11031257f, 
    -0.31974229f, 0.19348918f, -0.00420999f, 0.04396515f, -0.02707096f, 0.09540026f, 0.00504451f, 0.16743742f, 
    0.01282311f, -0.04742711f, 0.05253419f, 0.06463669f, 0.02728904f, -0.00606299f, -0.01959879f, 0.21036381f, 
    0.06140429f, -0.01578828f, -0.10106039f, 0.03547231f, 0.10163666f, -0.09996501f, -0.04864112f, 0.02913212f, 
    -0.19446550f, 0.45016870f, -0.09947793f, 0.13391079f, -0.05060884f, -0.09631671f, 0.01353995f, -0.04164066f, 
    -0.06062583f, -0.03132012f, -0.08570384f, 0.02762613f, -0.04877507f, -0.28949234f, -0.02779604f, 0.18202429f, 
    0.01638340f, -0.13159652f, -0.08082619f, 0.02212617f, -0.02557657f, 0.00083957f, -0.08783978f, 0.09219024f, 
    0.72057050f, 0.08125894f, 0.36345223f, 0.65788418f, 0.26617739f, 0.04895157f, 0.06084992f, 0.02033280f, 
    0.03577030f, 0.00601385f, 0.18610311f, 0.08814314f, -0.11437851f, -0.02420348f, -0.04448717f, 0.03335482f, 
    0.06363199f, 0.04289467f, -0.06714901f, -0.01364232f, -0.00025999f, 0.03645575f, 0.04159271f, 0.15056710f, 
    -0.03174269f, 0.03580462f, 0.19934179f, 0.11018081f, 0.07679004f, -0.03690327f, -0.04787409f, -0.05155378f, 
    0.09431187f, -0.17506950f, -0.12544785f, 0.22587664f, -0.08503604f, 0.00281523f, -0.13355723f, -0.13230330f, 
    -0.09383731f, 0.08464696f, 0.09144986f, 0.16792075f, 0.03079252f, 0.17679426f, 0.12053508f, 0.05713616f, 
    -0.12533201f, 0.17146218f, 0.15776999f, 0.13439322f, 0.03656995f, -0.03134443f, -0.01802713f, -0.01043608f, 
    -0.10384316f, 0.04024974f, 0.12615271f, 0.05145379f, 0.00809626f, 0.00029681f, 0.20551169f, 0.01824467f, 
    0.01740942f, -0.01481943f, 0.00448818f, 0.06820127f, -0.01563689f, 0.20106198f, 0.38141298f, 0.00989999f, 
    0.19860266f, 0.27568716f, 0.13373144f, 0.08333681f, 0.09902479f, 0.04443625f, 0.01415440f, 0.08759892f, 
    0.03026667f, 0.05702634f, -0.00685882f, 0.01394297f, -0.08917478f, 0.14314553f, 0.05555456f, -0.12726115f, 
    -0.08085148f, 0.07844222f, 0.09844592f, -0.10422660f, -0.11304859f, 0.13041590f, 0.07955103f, -0.00332405f, 
    -0.04954514f, 0.18423173f, 0.09622342f, -0.05959945f, 0.09255643f, 0.05503442f, 0.18284549f, 0.06076947f, 
    0.09000348f, 0.02314822f, 0.02983326f, 0.01922334f, 0.06523552f, 0.05562313f, -0.09597310f, 0.01518744f, 
    -0.06304382f, 0.23165160f, -0.00769460f, -0.07435551f, 0.09099357f, -0.12686504f, 0.06727654f, 0.21779034f, 
    0.04817983f, 0.06929542f, 0.05883999f, 0.02204103f, -0.05642829f, 0.17190601f, 0.04099355f, -0.05098714f, 
    0.09864964f, 0.00913838f, 0.10103405f, 0.06550401f, 0.04991655f, -0.15184842f, 0.03339738f, 0.02054478f, 
    0.02414369f, 0.22658852f, -0.04416949f, 0.11031543f, 0.11634162f, -0.01507132f, 0.02016963f, 0.04163805f, 
    -0.06504194f, 0.13202283f, -0.14971730f, 0.15679143f, 0.05512992f, 0.00682317f, -0.02968014f, -0.01969941f, 
    -0.00721260f, -0.05426269f, -0.00009095f, 0.03636670f, 0.06586687f, 0.14546843f, 0.16589023f, -0.22363560f, 
    0.09526359f, -0.15960653f, 0.14740889f, -0.00196413f, -0.12385637f, -0.03452933f, 0.03863078f, -0.03759765f, 
    0.15606929f, 0.08066828f, 0.02578557f, -0.01740731f, -0.01363987f, -0.05770463f, -0.02796928f, -0.02057483f, 
    -0.08664731f, -0.09436961f, -0.08333336f, 0.20435180f, -0.18649785f, -0.02385480f, -0.22610655f, -0.12259624f, 
    0.03657662f, 0.02374105f, -0.02616396f, -0.01021003f, 0.05713395f, 0.02931049f, 0.07037484f, 0.14619532f, 
    0.02724223f, -0.06422468f, -0.11748791f, 0.28948611f, 0.01331026f, 0.08937532f, 0.05620344f, 0.09497868f, 
    0.05034338f, -0.18606071f, -0.22754507f, -0.28126732f, -0.19091602f, -0.06566112f, -0.43895024f, 0.10369578f, 
    0.16092946f, 0.14126892f, -0.08433628f, -0.00864595f, -0.02228999f, 0.07063900f, 0.02063224f, 0.05663810f, 
    -0.06310543f, -0.08431949f, -0.17249420f, -0.17194700f, -0.02609888f, 0.02957018f, -0.05653872f, 0.16256888f, 
    -0.11963440f, 0.03288335f, -0.00001375f, -0.15128818f, 0.03946400f, 0.23698662f, 0.05996022f, -0.04003256f, 
    0.15297085f, 0.15512717f, 0.04094176f, -0.07426270f, -0.02214115f, 0.05052838f, 0.03352704f, 0.08847240f, 
    0.03536087f, -0.10290083f, -0.19592580f, -0.11026602f, -0.01306966f, 0.08554967f, -0.08859419f, 0.14832680f, 
    0.10289036f, -0.05815185f, -0.08174752f, -0.08361094f, 0.06041079f, 0.15575826f, 0.00508084f, -0.08672449f, 
    -0.01857275f, -0.00889417f, -0.03142385f, 0.09293095f, 0.07458422f, -0.06581775f, -0.05134641f, 0.04355463f, 
    0.10262541f, 0.10815067f, -0.01675372f, -0.19044472f, -0.08648048f, 0.15186705f, 0.29775468f, -0.13726845f, 
    -0.00625662f, 0.02369050f, 0.07004691f, 0.07537649f, 0.26959664f, 0.00471202f, 0.05783417f, -0.07461884f, 
    -0.05867663f, -0.03271716f, 0.03001732f, -0.02351142f, 0.16749087f, -0.12767187f, -0.12217999f, -0.18910967f, 
    0.18409373f, 0.19993412f, 0.06752466f, 0.03617851f, -0.04574916f, 0.03164403f, 0.02715723f, -0.23534206f, 
    0.01139692f, 0.00212479f, 0.01485142f, 0.14213210f, -0.16501068f, 0.01480233f, -0.15574980f, -0.33876345f, 
    -0.01127639f, 0.05997250f, -0.07030172f, -0.01680631f, 0.11530954f, 0.03571607f, -0.08140963f, -0.08163223f, 
    0.05686554f, 0.07662032f, 0.06967160f, 0.01734520f, -0.11045209f, -0.01467784f, -0.05065473f, -0.10616350f, 
    -0.12166437f, -0.13780303f, 0.08624855f, 0.15642583f, 0.03107242f, 0.08513387f, 0.08424792f, -0.02939012f, 
    -0.07234089f, 0.00274205f, -0.06556530f, 0.00520022f, 0.20630580f, 0.09751171f, 0.14879149f, 0.06108436f, 
    -0.03478864f, -0.06636517f, -0.34388772f, -0.13777669f, 0.02187355f, 0.01013789f, -0.01680582f, 0.03891874f, 
    0.09178710f, 0.05033869f, 0.18116662f, -0.15725444f, 0.05580046f, 0.01743934f, 0.01008971f, 0.06478516f, 
    0.00434654f, 0.01078573f, -0.05840399f, 0.01556876f, 0.01633209f, 0.03452331f, 0.07639352f, 0.01919231f, 
    0.12455422f, -0.20981713f, 0.02334708f, -0.08474725f, 0.07732839f, -0.03607612f, -0.03355344f, -0.09379338f, 
    0.03411075f, 0.09271235f, -0.03886078f, 0.02657855f, 0.08529960f, -0.05093664f, 0.14223632f, 0.12970252f, 
    -0.12527040f, 0.03199946f, 0.05399136f, -0.00576000f, 0.15283617f, -0.05766376f, 0.19549128f, 0.03202061f, 
    0.02989650f, -0.16418497f, 0.14062393f, -0.28490403f, -0.13972111f, -0.00123344f, 0.04947371f, -0.11619494f, 
    -0.00685928f, -0.01373437f, -0.07152405f, 0.02984186f, 0.03061965f, -0.15048057f, -0.06418099f, 0.10481867f, 
    -0.08541316f, -0.00470116f, -0.03421291f, -0.08200201f, 0.03410425f, 0.09196573f, 0.06153224f, 0.08490432f, 
    -0.02365525f, -0.00159311f, 0.09461470f, 0.08234599f, 0.04176197f, -0.02533214f, 0.02427971f, 0.05390066f, 
    -0.09242107f, 0.00958913f, 0.01461455f, -0.05787561f, 0.17599490f, 0.22440723f, 0.01877083f, 0.10815090f, 
    0.14923617f, 0.19190364f, 0.17077848f, -0.07876720f, 0.02898353f, 0.07082537f, 0.08293997f, 0.07736378f, 
    0.12488122f, 0.27803922f, 0.14003539f, -0.12373734f, 0.32993108f, 0.03231166f, 0.01698388f, 0.04513676f, 
    -0.04916371f, -0.00288018f, 0.05101007f, 0.01548120f, -0.11715999f, -0.00992380f, 0.03254750f, 0.11287028f, 
    -0.06281168f, 0.00972118f, 0.07429181f, -0.04760127f, -0.09699326f, 0.00725313f, 0.06370678f, 0.09114691f, 
    -0.26411557f, -0.25708631f, -0.27663863f, -0.34536526f, -0.07710083f, -0.03815110f, -0.05791016f, 0.05070744f, 
    -0.04064244f, 0.14261508f, 0.02460023f, -0.04019793f, -0.14153323f, 0.03448649f, 0.01481938f, -0.12625335f, 
    -0.02067372f, 0.11951148f, -0.15991649f, -0.03918273f, -0.04227727f, 0.11081792f, 0.09039126f, 0.11025824f, 
    0.01720538f, 0.13578203f, 0.23629263f, -0.04624567f, 0.11534961f, 0.02048774f, -0.05450194f, 0.02569329f, 
    0.02112295f, -0.06875288f, 0.02312158f, -0.14958803f, 0.03491518f, -0.16483043f, 0.05193372f, 0.14466961f, 
    -0.19245918f, -0.06296409f, 0.08034817f, -0.12450322f, -0.00948445f, 0.12148125f, 0.13885829f, 0.04822727f, 
    -0.07968222f, -0.03909092f, 0.25606430f, 0.15740129f, -0.08657178f, 0.05755090f, 0.01817066f, 0.09740020f, 
    -0.03180588f, -0.04045425f, 0.28364429f, 0.03424238f, 0.15384254f, 0.10941199f, 0.08258040f, 0.04658482f, 
    -0.01502731f, -0.15327407f, -0.02626576f, 0.08365835f, 0.10307655f, 0.08457692f, -0.09021933f, 0.08291530f, 
    0.11729338f, 0.17348856f, -0.14163426f, -0.23795420f, -0.08107645f, -0.04507775f, -0.03419980f, 0.09530174f, 
    0.03942890f, -0.01604260f, -0.09253711f, -0.08059239f, 0.00698264f, 0.16758943f, 0.10843277f, -0.18485284f, 
    -0.01428042f, 0.12425243f, 0.05783931f, 0.08787940f, -0.12846205f, -0.21111123f, -0.07751502f, -0.16580975f, 
    0.11214268f, -0.03142228f, 0.09555787f, -0.15667838f, -0.07889213f, -0.09321916f, 0.12662709f, -0.09261846f, 
    -0.05790309f, -0.01522197f, -0.09331811f, -0.14633383f, -0.01220529f, 0.01191491f, 0.00702101f, 0.09398878f, 
    -0.21167462f, -0.00159310f, 0.05629668f, -0.00517552f, 0.01038517f, -0.02014002f, -0.06140283f, 0.12527953f, 
    -0.23569126f, 0.06526030f, 0.16245110f, -0.03590975f, 0.01731480f, 0.15678428f, -0.07658480f, 0.18208602f, 
    0.05211664f, 0.07751720f, -0.13025400f, -0.12450709f, 0.00156967f, 0.07199661f, 0.46215963f, -0.24731542f, 
    -0.01554916f, 0.12351054f, 0.12895569f, 0.03061509f, 0.17215818f, -0.02441123f, 0.14994816f, -0.02067827f, 
    0.11022374f, -0.03766890f, -0.14351955f, -0.03045209f, -0.03236380f, 0.01148377f, -0.01371688f, 0.11755618f, 
    -0.20431891f, -0.36672631f, -0.29050827f, -0.38084102f, 0.07107083f, -0.07769077f, -0.04484285f, 0.15028128f, 
    0.11025078f, -0.11239470f, -0.01277356f, -0.05908642f, 0.10552283f, 0.01253110f, 0.01971913f, 0.10413382f, 
    0.02531796f, 0.00018693f, -0.06656724f, -0.07847063f, -0.03972072f, 0.05132933f, -0.05698073f, 0.02871656f, 
    0.10099112f, 0.06131588f, 0.11637757f, -0.09731333f, 0.14106064f, -0.11500333f, -0.01592496f, -0.17919223f, 
    0.13554491f, 0.14481115f, 0.03080174f, 0.13100855f, -0.02117421f, 0.03501081f, 0.05106919f, 0.04084713f, 
    0.00170205f, 0.04384075f, -0.15174215f, -0.36770475f, 0.13700345f, 0.10187697f, -0.01389176f, 0.06254330f, 
    0.03351960f, -0.09973511f, 0.02648008f, -0.12892351f, 0.11415505f, -0.02407350f, 0.11814325f, 0.09678882f, 
    -0.05085289f, 0.00479524f, -0.09400128f, 0.03100803f, 0.01704890f, -0.04192983f, -0.03669018f, 0.01261710f, 
    0.29479194f, -0.00789648f, -0.12935032f, 0.01080364f, 0.11670680f, 0.02845395f, -0.02248429f, -0.01791067f, 
    0.02256592f, 0.01066617f, -0.03758433f, 0.05374397f, -0.17228486f, 0.03651821f, -0.00730915f, -0.15595554f, 
    0.03865110f, 0.10271980f, 0.03252409f, 0.07616521f, -0.13485742f, -0.18373580f, -0.08330893f, -0.28928608f, 
    0.04464070f, -0.06061097f, 0.06757424f, 0.06433642f, -0.03776702f, -0.07242023f, -0.01503661f, -0.03188293f, 
    -0.03066813f, -0.17078733f, -0.20214549f, -0.44419053f, -0.06305545f, 0.01488026f, -0.01419272f, -0.13698813f, 
    0.01722510f, -0.03119378f, 0.13836053f, 0.05857612f, -0.04726772f, -0.00345863f, -0.02819902f, 0.05795931f, 
    -0.09228326f, 0.09259181f, 0.01317989f, -0.01602778f, -0.05351107f, 0.08205542f, 0.00017868f, 0.11612505f, 
    0.03314622f, -0.08089771f, 0.04611543f, 0.04679295f, -0.01232360f, 0.10219360f, -0.06525782f, -0.12341080f, 
    0.12572695f, 0.20354897f, -0.09889188f, 0.02190327f, -0.17512070f, -0.05993849f, 0.07124446f, 0.02864559f, 
    0.61411017f, 0.07436591f, 0.10284234f, -0.19639681f, -0.02842358f, -0.09467518f, 0.09337600f, 0.00190460f, 
    0.13937512f, 0.06551171f, -0.13309416f, 0.01796679f, 0.31837216f, -0.03356711f, -0.00770989f, 0.09839960f, 
    0.03150106f, 0.07675757f, -0.03142052f, 0.02452848f, 0.09779510f, 0.08766106f, 0.09778614f, 0.14592418f, 
    0.12838562f, -0.04874422f, 0.10815866f, 0.00813631f, -0.08752454f, 0.02259961f, 0.27029061f, 0.03148678f, 
    0.01844703f, -0.04101719f, -0.03424929f, 0.07827610f, -0.03185398f, 0.02791748f, 0.08326819f, -0.01072703f, 
    0.00116288f, -0.03598934f, -0.01908606f, 0.00852713f, 0.09578457f, -0.02587814f, 0.11932495f, -0.05870555f, 
    -0.03034976f, 0.00891836f, -0.02367097f, 0.01901383f, -0.04044189f, -0.03698618f, -0.02354110f, -0.00290687f, 
    -0.02773483f, 0.00597763f, 0.02151514f, -0.03083638f, -0.03663709f, -0.03058463f, 0.02164729f, -0.00950849f, 
    -0.00451224f, -0.01226115f, 0.01095978f, 0.01974010f, -0.00933346f, 0.01730428f, -0.01135160f, -0.01861262f, 
    -0.01096073f, -0.00721510f, -0.00896758f, 0.01952614f, -0.01253825f, -0.02431969f, 0.02845762f, 0.00211368f, 
    -0.00779067f, 0.00995240f, 0.00893424f, 0.02510870f, -0.02675107f, -0.00513613f, -0.02464284f, 0.00329993f, 
    -0.03644572f, -0.03276906f, -0.01703210f, -0.03607424f, -0.00026204f, 0.01175185f, 0.00542210f, -0.00367093f, 
    0.00443390f, 0.01962612f, 0.00734617f, 0.02528504f, -0.03158631f, -0.01599625f, 0.00565339f, 0.01403224f, 
    -0.00765018f, 0.02369929f, -0.02563139f, 0.02081639f, -0.02587475f, -0.01497029f, 0.01590138f, -0.02281144f, 
    0.02236109f, -0.03973449f, -0.00827957f, 0.00155427f, -0.02021542f, 0.02492442f, -0.02660525f, -0.03161785f, 
    -0.02409215f, -0.03444578f, -0.01579031f, -0.02787191f, -0.02752589f, -0.01832796f, -0.01168842f, 0.01658976f, 
    -0.00950829f, -0.01497065f, -0.02181143f, -0.00585148f, -0.01669340f, 0.02168042f, 0.00609299f, 0.01078397f, 
    0.02671736f, 0.01258637f, 0.01959285f, 0.00063876f, 0.02099122f, -0.03834651f, -0.01458721f, 0.01782851f, 
    0.01250706f, -0.01883897f, 0.00273876f, -0.00164497f, -0.00640339f, -0.02061491f, -0.01505784f, -0.02766979f, 
    -0.03201085f, 0.00670959f, 0.02212385f, -0.04003175f, -0.04161964f, -0.00151729f, -0.02044045f, -0.01096545f, 
    0.01070651f, 0.02794425f, 0.00562850f, 0.01447419f, 0.00821708f, 0.02380032f, 0.00586362f, -0.01989769f, 
    0.02573885f, 0.01518734f, -0.02169956f, -0.03062473f, -0.01231142f, 0.02539259f, 0.01966441f, 0.01131019f, 
    -0.00402372f, -0.04024501f, 0.01662423f, 0.00875928f, 0.01668779f, 0.01447121f, 0.00188094f, -0.02360336f, 
    -0.03790070f, 0.01265400f, -0.01813943f, 0.01507981f, -0.01060730f, 0.01654947f, -0.02869921f, -0.01575457f, 
    -0.02263778f, 0.00789174f, 0.01426551f, 0.00337076f, -0.02239966f, 0.00763374f, 0.00046347f, 0.02062746f, 
    0.01457167f, -0.01513558f, -0.00561036f, 0.01168921f, -0.01848883f, 0.00590002f, -0.02329030f, -0.02088998f, 
    0.00262810f, -0.01456226f, -0.00608373f, -0.00732558f, 0.01255116f, -0.02336944f, -0.00616470f, 0.01958512f, 
    -0.02563373f, 0.01639159f, 0.00293865f, -0.00319814f, 0.02189243f, -0.00671581f, -0.02746132f, 0.00451742f, 
    0.02036740f, -0.03135253f, 0.01108375f, 0.02136372f, 0.01245788f, -0.00703363f, 0.02910972f, -0.02125094f, 
    -0.00910631f, 0.01147963f, -0.00370836f, 0.01162031f, -0.03302374f, 0.02722481f, -0.03339918f, -0.01589929f, 
    -0.02493171f, 0.00500159f, -0.03692380f, -0.03538318f, -0.00823374f, -0.03831344f, -0.01016737f, 0.02803638f, 
    0.02000460f, -0.02272496f, -0.02135602f, 0.01985228f, -0.04138553f, -0.00203694f, 0.02806382f, -0.02015347f, 
    -0.03150176f, -0.01516868f, -0.04117423f, -0.00169039f, 0.01492788f, 0.00540294f, 0.00526725f, -0.01613011f, 
    -0.03969181f, 0.02691161f, -0.03237446f, 0.01825925f, -0.01750395f, -0.01654871f, -0.03562566f, 0.01598668f, 
    0.00294717f, -0.03550827f, -0.02467377f, -0.00357448f, 0.00778037f, -0.00077505f, 0.01067967f, -0.01981277f, 
    -0.00747069f, -0.04098032f, 0.01051502f, -0.01087351f, -0.03881824f, -0.01421876f, -0.00417210f, -0.00727984f, 
    0.02236755f, -0.02182639f, -0.03199965f, -0.00833397f, -0.03445379f, -0.02744958f, -0.03143852f, -0.01543150f, 
    -0.01710184f, 0.01095019f, -0.00329820f, -0.00880854f, -0.01369097f, -0.04165442f, 0.00979949f, -0.00792778f, 
    0.02950088f, -0.04037595f, 0.01381636f, -0.00124495f, -0.03003156f, 0.01141978f, -0.01643690f, 0.02201703f, 
    -0.00141111f, -0.00593853f, -0.01591104f, 0.00401141f, 0.02656580f, -0.01386744f, -0.00404189f, -0.03110940f, 
    -0.03387768f, 0.02829316f, -0.02164335f, -0.02190864f, 0.01756215f, 0.01036560f, -0.02178487f, -0.03489472f, 
    0.00127732f, -0.03173899f, -0.03496312f, -0.01981384f, -0.00842313f, 0.00121233f, -0.03497970f, -0.01446480f, 
    0.02011140f, 0.02403277f, -0.03538549f, 0.00191138f, -0.00171228f, -0.02179052f, 0.00442761f, -0.03056189f, 
    0.01235432f, 0.00167138f, 0.01245255f, -0.00081495f, 0.01838581f, -0.02518499f, -0.00972761f, -0.00427085f, 
    -0.01806222f, 0.02068234f, -0.02160078f, -0.03132716f, -0.01948660f, -0.02940890f, -0.01391003f, -0.01232964f, 
    0.01499547f, 0.02511202f, -0.01809490f, 0.02357461f, -0.03512765f, -0.00132516f, 0.00722836f, 0.01804202f, 
    -0.02171416f, -0.03281011f, -0.03524674f, -0.01703952f, -0.01751081f, -0.03812979f, 0.01194323f, -0.03242728f, 
    -0.03267018f, -0.03450566f, 0.00022827f, -0.01990210f, -0.02858050f, -0.02936281f, 0.00401042f, -0.01986790f, 
    -0.02345731f, -0.00918051f, -0.01707600f, 0.02883813f, -0.00423436f, 0.02239935f, -0.01940034f, -0.00297935f, 
    0.01488725f, -0.00499678f, -0.01305486f, -0.00166671f, 0.01295472f, -0.02362587f, 0.00996106f, 0.00592306f, 
    0.01944491f, -0.02367616f, -0.03821434f, -0.01821782f, -0.02947673f, -0.04064640f, -0.01014831f, -0.01620165f, 
    0.01452734f, 0.00037716f, -0.01504976f, 0.00513865f, -0.03504771f, 0.02481473f, 0.00387655f, -0.02466623f, 
    -0.01782894f, 0.00524829f, 0.00191962f, 0.00094881f, -0.02038298f, -0.01124352f, 0.00350920f, -0.00194399f, 
    -0.03580623f, -0.01520380f, 0.01046721f, -0.04053166f, -0.01743613f, 0.02463389f, -0.01825044f, -0.00469624f, 
    -0.02973309f, -0.01546365f, 0.00770742f, 0.02930871f, -0.01542402f, -0.02096473f, -0.03911471f, 0.01718209f, 
    -0.00656154f, 0.02933513f, -0.01370358f, 0.02130317f, 0.01614914f, 0.02665620f, -0.02077907f, -0.03039743f, 
    -0.01210940f, -0.03734021f, 0.00059052f, -0.03061128f, 0.00639198f, 0.00912080f, -0.01639825f, -0.00897084f, 
    -0.02577013f, 0.00627058f, -0.02796937f, -0.00217292f, -0.03139143f, -0.01120115f, 0.01665939f, -0.01026398f, 
    0.00410442f, -0.00746119f, -0.03543271f, 0.00494839f, -0.04035359f, 0.01000239f, -0.01463508f, -0.00617111f, 
    -0.01430643f, -0.00011356f, -0.02531832f, 0.01916143f, 0.02159042f, 0.02286234f, -0.02006939f, 0.01115826f, 
    -0.00250074f, 0.02414790f, 0.00655331f, -0.03035545f, -0.02081874f, 0.02999129f, 0.00618418f, -0.03252126f, 
    -0.01023850f, -0.03062182f, 0.01629231f, 0.00317023f, 0.02919493f, -0.02075481f, 0.02192789f, -0.00068567f, 
    -0.03491787f, -0.03031743f, -0.00253287f, -0.03589693f, 0.02144622f, -0.01208307f, 0.01578369f, -0.03843923f, 
    0.01678015f, -0.02681304f, 0.00106667f, -0.02578693f, 0.01349420f, -0.03088259f, 0.01278126f, -0.02607223f, 
    -0.01483174f, -0.02092199f, 0.01245070f, -0.01043644f, -0.03901473f, 0.02555378f, -0.03330224f, -0.01267441f, 
    0.02638541f, -0.01178535f, -0.03055498f, -0.02550704f, -0.01857302f, 0.01719552f, -0.02913809f, 0.02428524f, 
    -0.03118738f, 0.00684359f, 0.00590274f, 0.00427447f, 0.00926800f, 0.01365497f, -0.02749488f, -0.04112991f, 
    0.00695082f, -0.03335338f, -0.00772765f, -0.00315349f, 0.01744276f, -0.00256056f, 0.00568445f, 0.01940274f, 
    -0.03090617f, 0.02287425f, -0.00406861f, -0.01319441f, -0.00213654f, 0.00440933f, -0.00006455f, 0.01594413f, 
    0.00798066f, 0.02746850f, -0.03349044f, -0.00841498f, -0.02997758f, 0.01411163f, -0.04136179f, -0.00020893f, 
    -0.03364788f, -0.02906393f, 0.01474075f, -0.01986278f, -0.02856844f, 0.01353600f, 0.00438415f, -0.00691447f, 
    -0.03616318f, -0.00882413f, 0.01858134f, -0.01917199f, -0.03159005f, 0.01437747f, -0.01002724f, 0.02823556f, 
    0.02378974f, -0.03287230f, -0.01632722f, -0.01496736f, 0.01582403f, -0.02962914f, -0.01635441f, 0.00149736f, 
    0.00770035f, 0.00192950f, -0.00793157f, -0.03406532f, 0.00682451f, 0.02885149f, 0.00550479f, 0.01101525f, 
    -0.00687320f, 0.00718647f, 0.01933934f, 0.02419509f, -0.00145184f, -0.01891617f, 0.00844963f, 0.02458003f, 
    -0.04070546f, 0.01422581f, -0.02910277f, 0.02537887f, 0.02364533f, -0.02318241f, 0.00435904f, -0.03783429f, 
    -0.03895117f, -0.02449600f, -0.01671347f, 0.02344182f, 0.02579935f, -0.02426376f, -0.00104728f, 0.02321959f, 
    -0.03562689f, -0.03499321f, 0.01050901f, -0.02355330f, -0.00546497f, -0.00509529f, 0.02264919f, 0.01366187f, 
    -0.04190951f, -0.00741719f, -0.00643064f, -0.02610072f, -0.01339337f, -0.00515369f, -0.03139690f, -0.02862761f, 
    0.01589096f, 0.01541599f, 0.01789526f, -0.03723801f, -0.03603366f, 0.00736211f, -0.01935645f, -0.02015315f, 
    -0.00582009f, 0.00241338f, 0.00334911f, -0.03914580f, 0.01621938f, 0.01133118f, 0.01460157f, 0.00095708f, 
    -0.01870620f, 0.02152956f, -0.01643316f, 0.02875343f, 0.00671454f, -0.04127671f, -0.01770282f, -0.00206710f, 
    -0.03109626f, -0.02181926f, -0.02171107f, -0.01989387f, 0.00146296f, -0.03295976f, -0.01077208f, 0.02731701f, 
    0.00284414f, -0.01789641f, -0.00712735f, 0.00831619f, 0.01675499f, 0.00628704f, 0.02490634f, -0.00122200f, 
    -0.03987812f, -0.04076103f, 0.00731754f, -0.02570945f, -0.03513436f, 0.02567892f, -0.00094439f, -0.01315684f, 
    0.01379941f, -0.02619396f, 0.02536876f, -0.01929144f, 0.01046664f, -0.04106235f, -0.02728079f, -0.02764350f, 
    -0.03885571f, -0.03278967f, 0.01190226f, -0.00828627f, 0.00816956f, -0.03519097f, 0.02065810f, -0.01226672f, 
    0.00695753f, 0.02375587f, 0.00700936f, 0.03006784f, -0.01578567f, 0.00401238f, 0.00037845f, 0.00514577f, 
    -0.01091277f, 0.00235327f, 0.00407480f, 0.02375369f, 0.00223088f, 0.00075313f, 0.01496344f, 0.02135812f, 
    -0.03938827f, 0.01884440f, 0.01865195f, -0.02209260f, 0.00681754f, -0.03694267f, 0.02801734f, -0.04189247f, 
    0.01146023f, 0.00509606f, -0.04000266f, -0.00347252f, -0.01256115f, -0.02406973f, -0.02952992f, 0.02456339f, 
    -0.04112402f, 0.00027803f, -0.00740025f, -0.01502120f, 0.02988882f, -0.00366772f, 0.01061158f, -0.01457003f, 
    -0.03856446f, -0.03654940f, 0.01450767f, -0.00157969f, -0.00211988f, -0.04006593f, -0.00095082f, -0.03982842f, 
    -0.02741826f, -0.03368565f, 0.00022221f, -0.03032455f, 0.02089682f, 0.00825063f, 0.00031937f, 0.01627111f, 
    -0.01386526f, -0.02309063f, 0.01639260f, 0.00897811f, -0.00678522f, 0.02132519f, -0.03904684f, 0.02974745f, 
    0.02951333f, 0.01994949f, 0.02463741f, -0.03383766f, 0.01398623f, 0.01887373f, -0.00862877f, 0.00675370f, 
    -0.00698005f, -0.01051688f, -0.01912547f, -0.00444861f, -0.03563057f, 0.00304481f, -0.01923356f, 0.00455416f, 
    -0.03489560f, 0.00867963f, -0.00665932f, 0.02471052f, 0.00816213f, -0.00738878f, 0.00237475f, -0.02131333f, 
    0.01137049f, -0.02358552f, -0.01120120f, 0.01425571f, 0.02089216f, 0.02515368f, 0.01020980f, 0.00098771f, 
    -0.01290416f, -0.01768750f, 0.02386747f, 0.01349286f, -0.00283476f, 0.01948595f, -0.02900619f, -0.02328323f, 
    0.00111198f, 0.01617398f, -0.03114346f, 0.02707420f, -0.01782974f, 0.01030912f, 0.02014595f, -0.02323885f, 
    -0.02046685f, 0.02272089f, -0.03675280f, -0.01550691f, -0.03487477f, -0.03388717f, -0.01337073f, -0.00759185f, 
    0.01925063f, 0.00043635f, -0.01867373f, -0.03076006f, -0.01600928f, -0.03707855f, -0.01193917f, -0.04049819f, 
    0.01301906f, -0.03552055f, -0.03812078f, 0.00580326f, 0.01252871f, 0.01923109f, 0.02352845f, 0.02676307f, 
    -0.00759229f, -0.01417806f, 0.01252652f, -0.03298790f, -0.01054785f, 0.00195987f, -0.04166789f, 0.02803409f, 
    -0.03188849f, -0.00993291f, 0.00928642f, 0.00682124f, 0.02741715f, 0.01050443f, 0.00709816f, -0.00868513f, 
    0.00184243f, -0.03012302f, -0.03703867f, -0.00990159f, -0.03568129f, -0.03757625f, -0.00789191f, -0.02921042f, 
    -0.01484081f, -0.00541624f, 0.02914040f, -0.00292086f, 0.00107529f, 0.00207890f, -0.03157953f, -0.01903934f, 
    -0.00694912f, 0.01518053f, 0.02525622f, 0.02925005f, 0.01662979f, 0.02982491f, 0.02359527f, -0.03827582f, 
    -0.01510465f, -0.01768558f, -0.01868357f, -0.02994513f, -0.00497650f, 0.02589885f, 0.02727549f, -0.04046610f, 
    -0.01285003f, -0.02657478f, -0.00274061f, -0.01307390f, 0.01002373f, -0.03443946f, -0.00368359f, 0.02739890f, 
    -0.03659261f, 0.00906847f, -0.03162219f, -0.01849388f, 0.00362770f, -0.00637851f, -0.04186142f, -0.02309322f, 
    0.00731254f, -0.01373587f, 0.00011623f, -0.00101083f, 0.02892152f, -0.00033917f, -0.01647808f, -0.01044077f, 
    -0.03683240f, -0.01697089f, -0.02378519f, -0.02305805f, 0.01464529f, 0.01532406f, -0.00080385f, -0.01719493f, 
    0.00137640f, -0.03318477f, -0.02103210f, -0.02999214f, 0.00799960f, 0.01092682f, -0.02672326f, -0.01603564f, 
    0.02605128f, 0.02305546f, -0.02591042f, -0.03369107f, -0.03195429f, 0.01183146f, 0.02320121f, 0.00129657f, 
    0.00473445f, 0.02695605f, -0.01068095f, 0.00749098f, -0.03423424f, -0.01106521f, -0.00373380f, 0.01238985f, 
    0.00337481f, 0.03478781f, -0.00939559f, 0.03127458f, 0.02809521f, -0.03099048f, -0.00327244f, -0.01392819f, 
    0.01876950f, 0.01257523f, 0.01707902f, -0.01685489f, -0.03039555f, -0.03900534f, -0.03305628f, 0.01658255f, 
    -0.01019438f, 0.00348061f, 0.00896816f, 0.02326023f, 0.02489968f, -0.02555543f, -0.00445762f, -0.01054554f, 
    -0.00451834f, -0.01856150f, -0.03667096f, -0.03885778f, -0.02728062f, -0.00998469f, -0.02077582f, -0.01404603f, 
    -0.02675352f, 0.01874715f, -0.02877943f, -0.00929278f, -0.03615879f, 0.00827384f, 0.01435587f, 0.01196595f, 
    -0.03280643f, -0.02361253f, 0.00549626f, 0.00588724f, -0.02458342f, -0.01480263f, -0.01792330f, -0.00477873f, 
    -0.01113415f, -0.04006229f, 0.02430846f, -0.01465865f, -0.00421613f, -0.02403597f, -0.03913112f, -0.01641539f, 
    -0.01260780f, 0.01669739f, -0.02323053f, 0.01082318f, -0.03752261f, 0.02439306f, -0.02404947f, 0.02547301f, 
    -0.00172692f, 0.02825244f, -0.00529086f, -0.03483868f, -0.00179621f, -0.03618338f, -0.03557650f, 0.00288907f, 
    -0.03005050f, 0.02128392f, 0.02932040f, -0.02325035f, -0.03686460f, -0.03254208f, -0.02471230f, 0.01799282f, 
    -0.03522382f, 0.01319696f, -0.00683598f, 0.01018641f, -0.01501877f, 0.01836642f, -0.02960134f, 0.02132177f, 
    0.02679084f, 0.02784970f, 0.01790665f, -0.00755580f, -0.01852204f, -0.00060844f, -0.02170825f, -0.00599061f, 
    -0.00908848f, -0.01199644f, -0.03339933f, -0.02063121f, 0.00419845f, -0.03673598f, 0.02216965f, -0.02291225f, 
    0.01245969f, -0.04168224f, -0.01755475f, -0.01218424f, -0.02464809f, 0.01727933f, -0.00516171f, -0.01683478f, 
    0.01213697f, 0.02449338f, -0.04079762f, 0.00969823f, -0.02778296f, -0.02020940f, 0.01326379f, -0.01489493f, 
    -0.02741310f, -0.01861455f, -0.00473707f, -0.00802229f, -0.02744029f, -0.01586149f, -0.01061660f, -0.02483650f, 
    -0.04087111f, -0.01943654f, 0.01631799f, -0.04109035f, 0.01001097f, -0.03626782f, 0.00324980f, 0.01778540f, 
    -0.01644135f, -0.03134936f, -0.00710844f, 0.00648391f, -0.03557169f, -0.02219945f, -0.03923979f, 0.02696021f, 
    -0.00000827f, 0.01395170f, -0.00959710f, -0.00813654f, -0.03384520f, 0.02601282f, 0.01488850f, 0.02337829f, 
    -0.00542850f, -0.02798987f, -0.03216153f, 0.00790334f, -0.04071661f, 0.01327579f, 0.01971778f, 0.01773334f, 
    0.00573300f, 0.01499650f, -0.00230008f, -0.02540541f, -0.02297067f, -0.00086196f, 0.02285613f, -0.01134567f, 
    -0.03354064f, -0.00282867f, 0.03018955f, 0.03002238f, 0.02849492f, 0.02407696f, -0.01298508f, 0.02788227f, 
    -0.02556637f, 0.02791151f, 0.01264071f, -0.03088959f, -0.03054667f, -0.00505776f, -0.00783657f, -0.01333929f, 
    -0.01684143f, -0.00199211f, 0.02405248f, 0.02202842f, -0.04090365f, 0.00840170f, 0.00123703f, -0.00905704f, 
    0.01805754f, 0.00056881f, -0.03476926f, -0.02296699f, 0.00760053f, 0.02176739f, -0.04020262f, -0.03039607f, 
    -0.03082759f, 0.01485758f, 0.00426372f, -0.02989300f, 0.02350347f, -0.01768657f, 0.00990786f, -0.00005531f, 
    0.01568645f, -0.02596736f, 0.00894518f, 0.00165229f, 0.01205932f, 0.00599201f, 0.02008234f, -0.02327151f, 
    -0.00111293f, 0.02630624f, 0.02095384f, -0.01189585f, -0.01973704f, -0.02378879f, 0.00559028f, -0.00334350f, 
    0.01069574f, 0.00905216f, -0.03877139f, -0.00916975f, 0.00051793f, 0.01415922f, 0.01301709f, -0.00397518f, 
    -0.01054964f, 0.00616625f, 0.02624806f, 0.01608594f, 0.01239675f, 0.01646261f, -0.00404700f, 0.02687786f, 
    0.00095718f, -0.03502513f, -0.03131404f, -0.01474542f, -0.03428567f, 0.01568667f, -0.00714907f, 0.02204984f, 
    0.01361771f, -0.02809372f, 0.02067950f, 0.02021003f, -0.02183497f, -0.00044392f, -0.02160194f, 0.02716146f, 
    0.02384577f, 0.01587880f, -0.04207090f, -0.01502721f, -0.01215773f, -0.02472149f, -0.02983544f, -0.03226725f, 
    -0.00522194f, -0.00190866f, 0.00138637f, 0.00559774f, 0.03113708f, 0.00311514f, -0.02678326f, -0.02452635f, 
    0.02054823f, -0.03059531f, 0.02568644f, -0.03163513f, 0.01677505f, -0.01595622f, -0.02775480f, 0.00189048f, 
    -0.02006898f, -0.01753372f, 0.02356883f, -0.03260291f, 0.02488389f, -0.04027705f, -0.01997128f, 0.00004242f, 
    -0.03618509f, 0.00897764f, 0.01202514f, -0.01680344f, -0.03984100f, 0.01292597f, -0.00451988f, -0.02200907f, 
    0.02047627f, -0.00304728f, 0.02303818f, -0.02673971f, 0.02603086f, 0.01561929f, 0.01549715f, -0.01483750f, 
    -0.02494871f, -0.03811708f, 0.01860653f, 0.02466693f, 0.02819870f, 0.02099216f, -0.03542328f, -0.01817240f, 
    0.02864172f, 0.01697825f, -0.03599450f, 0.02550682f, -0.00481215f, -0.01892792f, -0.02925410f, 0.01590909f, 
    0.01132538f, 0.02768786f, -0.03260035f, 0.02411307f, -0.02290082f, -0.02105139f, -0.00877903f, -0.01904225f, 
    -0.00373632f, 0.01179019f, -0.02014903f, 0.01819517f, -0.01563994f, -0.02165802f, -0.01303351f, 0.02184224f, 
    -0.00496113f, 0.00494272f, 0.01325722f, -0.01879393f, 0.02947657f, -0.02943965f, 0.02949024f, 0.00422518f, 
    -0.00748405f, -0.01500279f, -0.01168237f, -0.02331260f, 0.00119010f, -0.01677412f, -0.01046537f, -0.03883947f, 
    -0.00933352f, 0.00000618f, 0.00904802f, -0.01183517f, -0.02091558f, -0.01837774f, -0.01686183f, -0.03296788f, 
    -0.00050229f, -0.01370900f, -0.04127222f, -0.01504099f, 0.00900529f, 0.00269272f, 0.02468759f, -0.01921996f, 
    -0.00499870f, 0.00882410f, 0.02911390f, -0.00575823f, 0.00113373f, -0.01598810f, 0.01258462f, -0.01777097f, 
    0.01282984f, -0.01671443f, -0.01615059f, -0.01608574f, -0.01339883f, -0.02248657f, -0.03809051f, -0.03804710f, 
    0.01127499f, -0.03900223f, -0.01992327f, -0.03544535f, -0.02750730f, -0.03150692f, 0.01151088f, 0.03165428f, 
    -0.01242171f, 0.00985612f, 0.02812800f, -0.02105114f, -0.01644715f, 0.00876967f, -0.04167857f, -0.03339975f, 
    -0.01409310f, -0.04001652f, -0.03474485f, -0.02817880f, 0.01282572f, -0.02266979f, 0.00668492f, -0.03814999f, 
    -0.01417659f, 0.01627218f, -0.03063806f, -0.02471751f, 0.00385692f, -0.02837996f, 0.00660923f, 0.03471365f, 
    0.00547704f, 0.00971984f, -0.04010672f, 0.00676319f, 0.02070087f, 0.02806784f, 0.00187414f, -0.02799059f, 
    -0.02159745f, 0.01531564f, -0.03446847f, -0.03775979f, -0.03774972f, 0.02768079f, 0.02203407f, 0.01539093f, 
    0.01916924f, -0.03741299f, 0.00263476f, 0.02280580f, -0.01547908f, -0.00721172f, -0.02419364f, -0.02683371f, 
    0.02282755f, -0.03232953f, -0.02666654f, 0.02075977f, 0.01236234f, 0.00529193f, -0.00716557f, 0.01117796f, 
    0.01831687f, 0.02666667f, 0.00902051f, 0.02971856f, 0.03298762f, -0.02953282f, 0.02343061f, -0.03190726f, 
    -0.02225373f, -0.01567749f, 0.01667592f, -0.04063717f, -0.00848266f, -0.02537255f, -0.02636699f, 0.01130699f, 
    -0.03229029f, -0.03695306f, -0.00451358f, -0.01768682f, -0.03659371f, -0.02834192f, 0.00155407f, -0.00922790f, 
    -0.02637462f, -0.00609996f, 0.01280515f, -0.01363744f, 0.00858092f, -0.02906125f, -0.00844777f, -0.03370208f, 
    -0.00267471f, 0.00998776f, 0.01616357f, 0.02453781f, -0.01847744f, 0.02193093f, -0.02975377f, 0.01929463f, 
    -0.03833656f, -0.03948112f, -0.01605595f, -0.01125117f, -0.01349318f, 0.02016569f, -0.00023514f, 0.03574644f, 
    0.00000902f, -0.04102500f, -0.04012469f, -0.03541775f, -0.00908556f, -0.00562897f, 0.02866466f, -0.01470848f, 
    0.02352874f, -0.00430283f, 0.01177646f, -0.00246039f, -0.00299424f, 0.01546501f, 0.00782808f, -0.00658178f, 
    0.02013060f, -0.03942848f, -0.04062340f, 0.00718621f, 0.00358754f, 0.01840072f, -0.00315847f, 0.02266484f, 
    0.02730531f, -0.03157252f, -0.03923742f, 0.01943653f, 0.01359922f, -0.02215311f, 0.02432263f, -0.03362019f, 
    -0.01351708f, -0.02534650f, -0.00319535f, -0.03158620f, -0.03285936f, 0.01145099f, -0.01473775f, -0.01103354f, 
    -0.03494642f, -0.02918080f, 0.02526495f, 0.02912872f, 0.00477059f, -0.03529708f, -0.01884462f, -0.01067183f, 
    -0.02895619f, -0.04061794f, 0.02307249f, 0.00209682f, -0.00157572f, -0.03674674f, -0.03317856f, -0.03307964f, 
    -0.02755293f, 0.02465218f, -0.03304512f, 0.02435083f, 0.03480709f, -0.03486526f, 0.02272991f, -0.02334679f, 
    -0.00747513f, -0.02209841f, 0.00463826f, -0.03279410f, -0.02152963f, 0.02864117f, 0.00333905f, -0.02875117f, 
    -0.02420434f, 0.00064921f, 0.01896318f, -0.01365518f, 0.00267625f, -0.00805181f, -0.03269666f, -0.00230190f, 
    -0.02608532f, -0.03880093f, -0.02718769f, 0.02008873f, 0.01238322f, -0.03704564f, 0.01326222f, -0.03196151f, 
    -0.00569529f, 0.02902987f, 0.01746662f, -0.01366369f, -0.02067166f, -0.03402487f, -0.01642048f, -0.02900723f, 
    -0.00507405f, 0.01255676f, 0.02131183f, 0.00731481f, 0.01134230f, 0.01288300f, -0.01727039f, -0.03728793f, 
    0.01142459f, -0.01122321f, -0.03063283f, 0.02018774f, 0.00807472f, -0.00468670f, -0.00150449f, -0.00911127f, 
    -0.03793073f, -0.01095246f, 0.02575091f, 0.02547036f, 0.00232937f, 0.00132901f, -0.01408670f, -0.03847221f, 
    0.01659432f, -0.00401799f, -0.00444733f, 0.02352914f, 0.01103551f, -0.01888352f, 0.01255663f, -0.02400941f, 
    -0.03040018f, -0.02693469f, 0.02314706f, -0.01197988f, -0.02860464f, 0.00759507f, 0.02558005f, 0.01993950f, 
    -0.00376358f, -0.00431571f, 0.02100130f, -0.03165437f, -0.00055906f, 0.00268097f, 0.00589598f, 0.01397930f, 
    -0.00010168f, 0.01155244f, 0.00872432f, 0.02688929f, 0.02525978f, -0.03363921f, 0.01527237f, -0.00095565f, 
    -0.00417230f, 0.04092050f, 0.07596913f, 0.05690026f, 0.05464461f, -0.06840786f, -0.08339237f, -0.19852866f, 
    0.19022404f, -0.08650936f, -0.11423893f, 0.38615540f, -0.04603788f, 0.14946461f, 0.08175872f, 0.05210564f, 
    -0.03572481f, 0.01842119f, 0.08742324f, -0.02775296f, 0.12071095f, 0.13582906f, 0.05989761f, 0.03244072f, 
    -0.21985373f, -0.04091876f, 0.06947210f, -0.02597612f, 0.09285419f, -0.01392740f, -0.03998147f, -0.02278629f, 
    0.02165665f, 0.14951165f, 0.10571592f, -0.09738776f, -0.17671138f, -0.21730666f, 0.05575062f, 0.14499994f, 
    -0.17249928f, -0.10247347f, -0.03311215f, 0.04328308f, 0.11497694f, 0.16877112f, 0.31629163f, 0.07094321f, 
    0.02847038f, 0.11332040f, 0.28821808f, 0.13155368f, 0.07107603f, 0.08927345f, 0.02671535f, 0.05907684f, 
    0.09482020f, 0.06814139f, 0.09190389f, 0.09661007f, -0.10772990f, 0.17704464f, -0.00182799f, -0.05875528f, 
    -0.01110440f, 0.03109794f, 0.11551710f, -0.07891146f, 0.10791810f, 0.08823010f, 0.03020295f, -0.01111588f, 
    0.10658464f, 0.17000145f, 0.21357921f, -0.03805503f, 0.06959408f, 0.05060245f, 0.28865892f, 0.23590584f, 
    0.12022605f, -0.15853578f, -0.04485316f, 0.11539999f, -0.02063576f, -0.11349459f, 0.01329659f, -0.10495291f, 
    -0.15735072f, 0.07756698f, -0.07110235f, 0.02733674f, 0.22544864f, -0.04692489f, 0.06826299f, 0.16017370f, 
    0.03116911f, 0.12795082f, 0.24883264f, 0.19106950f, 0.06066545f, 0.08557926f, 0.18656874f, -0.01046141f, 
    0.09856506f, 0.02772744f, 0.14958249f, 0.08462098f, 0.01615542f, -0.03798524f, 0.19627514f, 0.06263880f, 
    0.06705920f, 0.22140376f, -0.17133729f, 0.23568112f, 0.04218884f, 0.07942858f, 0.02855256f, 0.00439086f, 
    -0.03719082f, -0.32534879f, -0.34471652f, -0.07790535f, 0.01039904f, 0.09702664f, 0.00714618f, 0.08175869f, 
    -0.00033006f, -0.11371306f, -0.14048989f, -0.07475136f, -0.41190234f, -0.19751355f, 0.22162758f, 0.01581479f, 
    0.04020742f, -0.11915681f, 0.04908302f, 0.13543628f, -0.07443636f, 0.05805569f, 0.14840236f, -0.07099054f, 
    -0.05740548f, -0.15651809f, -0.00572481f, 0.06391700f, -0.03302728f, -0.14780191f, -0.10718373f, -0.04628183f, 
    0.11327928f, 0.01599515f, 0.08739541f, 0.20752701f, -0.02773323f, -0.17990942f, -0.27075383f, -0.15895331f, 
    0.00893022f, 0.16936374f, -0.00522909f, 0.03055016f, 0.04384963f, -0.03491881f, 0.04704117f, 0.12685256f, 
    -0.04434618f, 0.10895314f, -0.30596808f, -0.06123172f, -0.03728266f, 0.03603695f, 0.03705094f, 0.02421444f, 
    -0.02190119f, -0.22393580f, -0.08228199f, -0.18553071f, -0.07253207f, 0.13209492f, -0.55062193f, 0.09482760f, 
    0.12745894f, -0.06834489f, 0.13045251f, 0.07545447f, 0.02081883f, 0.08421955f, -0.08174039f, 0.05661925f, 
    -0.35744518f, -0.17757502f, -0.09325068f, -0.15442622f, 0.01415481f, -0.07526283f, 0.05029591f, 0.03896337f, 
    0.01950853f, 0.02180291f, -0.01424355f, -0.07756949f, 0.11229065f, 0.40839472f, 0.22816025f, 0.14725214f, 
    0.05825294f, 0.19705166f, 0.03546995f, 0.02605972f, 0.00705576f, 0.05497080f, 0.03139806f, 0.07791067f, 
    0.07720031f, 0.04039045f, -0.00023535f, 0.00633247f, 0.04562871f, 0.07003944f, -0.04372977f, 0.18786345f, 
    0.01164059f, -0.13135062f, -0.04897638f, -0.14163336f, 0.14553624f, 0.15710942f, -0.09761823f, -0.11776513f, 
    0.05636222f, 0.09448273f, -0.00145333f, 0.07568127f, 0.05715038f, -0.07615618f, 0.00604602f, 0.09016070f, 
    0.10219224f, 0.07898088f, 0.12899379f, 0.15014461f, 0.11196262f, 0.02716425f, 0.04791396f, -0.00432560f, 
    0.00962571f, 0.01314305f, 0.09820163f, 0.15871334f, -0.06087317f, 0.14359072f, 0.33358052f, 0.20041372f, 
    0.01255932f, 0.00936933f, -0.05568645f, -0.03461624f, 0.19329907f, -0.14473622f, -0.19532001f, -0.04217197f, 
    -0.01165491f, 0.14418751f, 0.21096341f, 0.12485430f, -0.04453152f, 0.10692712f, 0.16950116f, -0.10713474f, 
    0.14032143f, 0.06965777f, 0.03696778f, 0.14495707f, -0.32642436f, -0.01033432f, 0.02465018f, -0.04002814f, 
    -0.04000970f, 0.04732971f, 0.03138730f, -0.01010015f, 0.06899653f, -0.07651810f, -0.08606520f, -0.07627251f, 
    -0.09779666f, -0.16197722f, 0.01562800f, 0.05734239f, 0.04523595f, -0.03609598f, -0.17344382f, -0.06313813f, 
    -0.04608855f, 0.05288126f, 0.10593063f, 0.08181591f, -0.04014447f, 0.00325045f, 0.20888238f, 0.12215158f, 
    -0.02613356f, -0.06055778f, -0.07618172f, -0.01614080f, 0.17048101f, 0.08962919f, 0.17589913f, 0.08214325f, 
    0.01454100f, 0.08632322f, 0.07903062f, 0.08953312f, -0.02943350f, -0.13998896f, -0.02546002f, 0.08815353f, 
    0.07952639f, -0.07002763f, 0.05090923f, -0.18015034f, -0.15239005f, -0.31980780f, -0.21727185f, 0.06421846f, 
    -0.08756310f, 0.04317261f, 0.07203846f, -0.04437846f, -0.00880929f, -0.04112224f, 0.06625681f, -0.04732117f, 
    -0.14197113f, -0.52358395f, 0.22370775f, 0.04933306f, 0.03616158f, 0.07306504f, 0.00113499f, 0.09198277f, 
    0.00056111f, -0.00328840f, 0.05580112f, 0.01841914f, -0.02766629f, -0.23352799f, 0.07623948f, 0.21865103f, 
    -0.08748052f, 0.09467132f, -0.05626041f, 0.07437276f, -0.00427677f, -0.09275564f, 0.10812066f, 0.09200463f, 
    -0.05856929f, -0.33100909f, -0.05537375f, -0.24683103f, -0.07236419f, 0.00831601f, -0.08078936f, 0.16027769f, 
    0.02429921f, -0.08188083f, -0.08586540f, -0.11891071f, -0.07172471f, -0.03053727f, 0.04787305f, 0.28414658f, 
    0.07987012f, 0.09163752f, 0.04399502f, 0.20022523f, -0.00250042f, 0.18220671f, 0.03137600f, 0.05515587f, 
    -0.21840113f, -0.10907935f, -0.03791816f, 0.01892638f, 0.01971450f, 0.01564637f, -0.05403941f, 0.04965495f, 
    -0.06762565f, -0.00656982f, -0.10983710f, 0.05768421f, 0.02596440f, 0.20172973f, 0.31825697f, -0.03073060f, 
    0.16095302f, 0.15993556f, 0.10729535f, 0.11531775f, 0.06324023f, 0.00557989f, 0.11629628f, 0.04474016f, 
    -0.03767477f, 0.20299426f, 0.21537143f, 0.04773872f, 0.13381380f, 0.09486867f, 0.08022807f, 0.03327068f, 
    -0.03856745f, -0.04578278f, 0.00525256f, 0.03637801f, 0.04152679f, 0.20864300f, 0.16904408f, 0.19674061f, 
    -0.15420683f, 0.03337428f, 0.08803872f, -0.04534304f, -0.04409678f, -0.03497916f, -0.00267799f, 0.05640251f, 
    -0.30604908f, -0.02998454f, -0.11358637f, -0.08555357f, -0.03858723f, -0.11876255f, -0.00948564f, -0.15661825f, 
    0.05015531f, -0.02618051f, 0.09801162f, 0.02633283f, -0.09248612f, -0.09234031f, -0.19718494f, -0.01670214f, 
    0.03349667f, 0.22898528f, 0.10856921f, 0.05116002f, -0.01679248f, 0.10547329f, 0.03708640f, 0.07305314f, 
    -0.04400248f, -0.02305204f, -0.08756591f, -0.18620430f, 0.15240628f, 0.00199268f, -0.02488327f, 0.09910005f, 
    -0.06120249f, -0.12291228f, -0.02953586f, -0.12642312f, 0.01925700f, 0.06863131f, 0.04414586f, -0.06349123f, 
    -0.04343025f, -0.01345990f, 0.09692079f, -0.05874450f, 0.09097309f, 0.25093606f, 0.10197935f, 0.05629727f, 
    0.06025301f, 0.09410048f, 0.27711070f, 0.07074879f, -0.04698875f, -0.00287570f, 0.10407357f, 0.05093144f, 
    0.16618633f, -0.00164920f, 0.33536664f, -0.05062171f, -0.16971785f, -0.19947444f, 0.14175177f, 0.11458358f, 
    0.01933696f, -0.00448693f, -0.04884330f, 0.07333507f, 0.11165652f, 0.11868364f, -0.09709468f, 0.04558404f, 
    -0.32528219f, 0.12929921f, 0.05546306f, -0.01228755f, -0.00428809f, 0.04669565f, 0.00626688f, 0.03481615f, 
    0.05279335f, -0.09340112f, -0.09606928f, -0.09946444f, -0.11759877f, 0.18687804f, 0.26741704f, -0.01501654f, 
    0.02091790f, 0.01941004f, 0.00295624f, 0.04539191f, 0.01741183f, -0.11574470f, -0.01486635f, -0.25052992f, 
    -0.30955619f, -0.07205637f, 0.32319582f, -0.00040923f, -0.04634552f, -0.15523419f, -0.05409833f, 0.09008984f, 
    -0.14638467f, -0.05656913f, -0.21025626f, -0.19503091f, 0.04347646f, -0.04046982f, 0.01217155f, 0.01723309f, 
    -0.17391273f, 0.15371607f, -0.01095943f, -0.05178440f, 0.09977555f, -0.01850928f, 0.03097294f, 0.14570896f, 
    -0.23814362f, 0.03109573f, 0.09057774f, 0.04115349f, 0.06062043f, -0.00270521f, 0.07639197f, -0.02365836f, 
    0.08446337f, 0.06995994f, -0.20266941f, -0.13226283f, -0.13554968f, 0.01793641f, 0.46007058f, -0.04826532f, 
    0.05323582f, -0.00835035f, 0.07839975f, 0.00456435f, 0.17816332f, -0.05299133f, 0.09925918f, 0.09090142f, 
    0.17036365f, 0.04919727f, -0.11309850f, -0.12382933f, -0.00127531f, -0.00994415f, 0.05519300f, 0.06858861f, 
    -0.10332221f, -0.36817297f, -0.25489503f, -0.51445401f, 0.12770140f, -0.19450486f, 0.03349400f, 0.07004354f, 
    0.06609087f, 0.01055080f, 0.02430261f, 0.00955344f, 0.12479591f, -0.01586937f, -0.00015519f, 0.12134933f, 
    -0.04655153f, -0.06041635f, -0.05802214f, 0.02270996f, -0.01867816f, -0.03188011f, -0.14010708f, 0.06633352f, 
    0.10942194f, 0.12174773f, 0.06209282f, 0.00777821f, 0.07593752f, -0.19225733f, -0.34834364f, -0.11316890f, 
    0.14391892f, 0.07964278f, 0.07411228f, -0.05230265f, -0.15329441f, 0.02069618f, -0.03506005f, -0.03158497f, 
    0.10760525f, 0.22400872f, 0.01528312f, -0.06457552f, 0.09536816f, -0.10152202f, 0.01477508f, 0.04684516f, 
    -0.07034179f, -0.07200955f, -0.03882653f, -0.21495420f, -0.10915352f, -0.30416667f, -0.10507444f, -0.02997369f, 
    -0.08068421f, -0.02940661f, -0.14410652f, 0.05345547f, 0.00180276f, -0.08128973f, -0.15608051f, -0.12859313f, 
    0.31747591f, -0.14159735f, -0.51583761f, 0.20281462f, -0.07272390f, -0.00978999f, 0.06902596f, 0.04485986f, 
    0.05537611f, 0.00823407f, -0.07515226f, -0.00949416f, -0.06873872f, 0.07194185f, -0.10228792f, -0.04315572f, 
    -0.06929952f, -0.08135928f, 0.08489566f, 0.14197694f, -0.03085564f, -0.19803956f, -0.14646196f, -0.23185588f, 
    -0.02972985f, -0.27342346f, -0.12976196f, -0.26112869f, 0.01927834f, 0.04593285f, 0.00917922f, 0.01267549f, 
    -0.03492068f, -0.17684114f, -0.27899826f, -0.43411064f, -0.00620094f, 0.09010028f, 0.19630970f, 0.13406944f, 
    0.09416828f, -0.04575016f, 0.06547610f, 0.03200933f, -0.16346586f, -0.06751576f, -0.05759968f, 0.03727367f, 
    -0.10600898f, 0.04120521f, -0.00716206f, -0.09161331f, 0.04270929f, 0.02975022f, 0.00456919f, 0.18555555f, 
    0.08881676f, -0.06264815f, 0.14924544f, 0.14383143f, 0.04828657f, 0.00667721f, -0.31221002f, -0.02049335f, 
    0.29449120f, 0.09074846f, -0.02782071f, 0.09372260f, -0.09113126f, -0.09137551f, 0.04489987f, 0.07475680f, 
    0.05132749f, -0.01244961f, 0.09405586f, -0.33479676f, -0.04057591f, -0.09187932f, -0.12328174f, 0.04070319f, 
    0.08652929f, 0.02745405f, -0.18030113f, -0.05742563f, 0.39361671f, -0.07166078f, 0.02070320f, -0.01786075f, 
    0.02765849f, -0.09611209f, 0.01939518f, 0.08369732f, 0.11149057f, 0.06236780f, 0.01369127f, 0.06785297f, 
    0.19393194f, -0.00964775f, -0.06739831f, 0.39497426f, -0.08225635f, 0.04670757f, 0.10398418f, -0.12364959f, 
    -0.02544188f, -0.13299142f, -0.08276080f, -0.00178961f, -0.13079116f, -0.12818024f, -0.08255665f, -0.05450889f, 
    -0.01951693f, -0.10824852f, 0.05550856f, -0.00812937f, 0.11698624f, 0.16393974f, 0.11972670f, 0.04312423f, 
    -0.06958082f, -0.04701065f, 0.11252152f, -0.00303355f, 0.08726660f, -0.01946442f, -0.07969125f, 0.09444819f, 
    -0.03787016f, -0.05282735f, -0.09283093f, -0.00527252f, 0.02744527f, 0.12182320f, 0.05256724f, 0.03502673f, 
    -0.03335215f, 0.05728698f, -0.08753502f, -0.09563408f, 0.01544602f, -0.13174172f, -0.10574764f, 0.00665662f, 
    0.06888501f, -0.15890995f, -0.04208556f, 0.00886346f, -0.07298196f, 0.15646780f, 0.11268310f, -0.01173284f, 
    0.00531857f, 0.16441731f, -0.11112946f, -0.00198013f, -0.13819194f, 0.05698359f, 0.10903198f, 0.09528083f, 
    -0.16148974f, 0.07954572f, -0.02053686f, -0.00547093f, -0.11137259f, -0.13038774f, 0.07594653f, -0.09366566f, 
    0.20148602f, 0.25827554f, 0.01963631f, -0.08697698f, 0.09437869f, 0.10222419f, 0.05050102f, 0.00761707f, 
    0.07227719f, -0.04050129f, 0.08503716f, 0.06126447f, 0.03271771f, 0.12863111f, 0.08399699f, -0.04763962f, 
    -0.13409738f, 0.06531644f, -0.01871529f, -0.09981495f, 0.05949365f, -0.11149999f, -0.05649435f, -0.14713944f, 
    0.04027819f, 0.07551195f, -0.03084465f, -0.05964306f, 0.00684344f, 0.08207957f, 0.06736831f, -0.02521517f, 
    -0.00559451f, -0.03269465f, 0.05652060f, 0.01995609f, -0.11909964f, -0.20134106f, 0.05771212f, -0.01618608f, 
    -0.05773775f, -0.00544053f, 0.01392684f, 0.21852882f, -0.01003884f, -0.28686047f, -0.03474796f, -0.24000274f, 
    0.09836639f, 0.10436075f, 0.07776923f, -0.04687811f, 0.08678629f, 0.05121014f, -0.03987735f, -0.04238749f, 
    0.04048942f, -0.06131395f, -0.01841984f, 0.01612165f, 0.18284570f, 0.09126827f, 0.06350263f, -0.06904556f, 
    0.03400557f, 0.09033816f, 0.06361350f, 0.16208760f, -0.02248048f, 0.01750691f, -0.13978016f, -0.19199935f, 
    -0.01770354f, -0.08776263f, -0.56538665f, 0.26718599f, 0.19163364f, 0.16536008f, 0.12790866f, -0.00040417f, 
    -0.01554268f, -0.15234056f, -0.14648810f, -0.09811808f, 0.29830047f, -0.22638984f, 0.27618611f, 0.06354949f, 
    -0.00365032f, -0.09135816f, 0.09449882f, -0.23193265f, 0.04471154f, 0.05805879f, 0.14779004f, -0.05745127f, 
    0.15472673f, 0.09450852f, -0.10144566f, 0.19069381f, -0.02592048f, -0.11616118f, -0.05396744f, -0.01990051f, 
    -0.00253949f, -0.04803966f, 0.03758175f, 0.04375107f, -0.22151972f, 0.16948549f, -0.31133592f, -0.09813485f, 
    0.12900195f, 0.13681512f, 0.09086715f, 0.14698961f, -0.19543077f, -0.19815056f, -0.11820659f, -0.27656841f, 
    -0.02391548f, 0.04282269f, -0.42471573f, 0.30460888f, -0.02925429f, 0.08271880f, -0.11747654f, -0.03521059f, 
    0.02651963f, -0.03088922f, 0.07504729f, 0.15218846f, -0.15105866f, -0.19473305f, -0.69722039f, 0.41062111f, 
    0.03094221f, 0.02646185f, 0.10821518f, -0.05292113f, -0.01803321f, -0.12226892f, -0.06692048f, -0.15722752f, 
    -0.12317702f, 0.10653944f, -0.11015068f, -0.06815187f, -0.01629383f, -0.08534053f, 0.04157463f, 0.06448309f, 
    0.11339717f, 0.08462334f, -0.02802656f, 0.00793004f, 0.28444320f, 0.24954557f, 0.06713601f, -0.13069856f, 
    0.08422735f, 0.00600246f, 0.08391202f, 0.05275549f, 0.09733777f, 0.07683548f, -0.08599629f, -0.01351546f, 
    0.05214478f, 0.02749313f, -0.01494491f, -0.00948070f, 0.03452698f, 0.04433480f, -0.04144095f, 0.17313758f, 
    0.01399836f, -0.05611504f, 0.03926315f, 0.03838648f, 0.07215210f, -0.05500092f, -0.17327289f, -0.02181000f, 
    0.07126595f, 0.05047083f, -0.14072403f, 0.02727533f, -0.06039169f, -0.06020231f, -0.05923804f, 0.13865431f, 
    0.29543841f, -0.07842212f, 0.13464729f, 0.02221212f, -0.16371880f, 0.10170598f, 0.00512197f, -0.04584366f, 
    0.02088561f, -0.08491451f, 0.11585585f, -0.10462751f, 0.20190147f, -0.02400154f, 0.12794591f, 0.09107043f, 
    -0.02937430f, -0.02704301f, 0.05108104f, 0.00800771f, 0.03320013f, 0.08962860f, 0.01805841f, 0.16328581f, 
    0.24713992f, 0.15269779f, -0.04017322f, 0.04210046f, 0.11606400f, 0.03848481f, -0.02280327f, 0.06237652f, 
    -0.02150489f, 0.00390269f, 0.07519873f, 0.06833486f, -0.05155154f, 0.08230657f, -0.06855804f, -0.10056590f, 
    -0.15028270f, 0.01015413f, 0.04375925f, 0.08932327f, 0.13650298f, 0.00984518f, -0.04042503f, 0.01577933f, 
    -0.05427534f, -0.16746822f, 0.03351418f, 0.01622627f, -0.08160715f, 0.02422435f, -0.02835706f, 0.06844737f, 
    -0.07133165f, 0.10687231f, 0.09131479f, -0.11466871f, 0.13208844f, 0.03712914f, 0.24584827f, 0.06880377f, 
    -0.17984203f, -0.12225698f, 0.13019235f, -0.06380703f, 0.07111353f, 0.02143002f, 0.01436592f, -0.09137775f, 
    0.18044487f, -0.03190885f, -0.05395449f, -0.07181629f, -0.04506405f, -0.04522194f, -0.07730798f, -0.08017100f, 
    0.06925972f, -0.03704011f, -0.03996275f, 0.08584169f, -0.07399469f, -0.28126803f, -0.18808647f, -0.00079026f, 
    -0.07384416f, 0.15409020f, 0.09958883f, -0.07465819f, -0.01070378f, -0.10896103f, 0.05082536f, -0.02392546f, 
    0.54141521f, -0.34182096f, 0.46931520f, -0.26632285f, 0.14205328f, 0.11428440f, -0.01658883f, 0.03867496f, 
    -0.09887375f, -0.03779305f, -0.01543294f, 0.05525195f, 0.38055390f, -0.19416480f, -0.08539604f, 0.06502656f, 
    -0.10203873f, -0.07171295f, 0.07298578f, -0.05232108f, -0.14775026f, -0.14660700f, -0.00920601f, -0.07151670f, 
    0.27783951f, -0.69279110f, 0.31310475f, -0.06402370f, 0.08533918f, -0.03021335f, -0.06130550f, 0.14710751f, 
    0.07953550f, 0.03370801f, -0.25481403f, 0.03303514f, -0.03544252f, -0.10712279f, 0.02613645f, 0.06987230f, 
    0.16742992f, 0.01109945f, 0.05301547f, 0.04791631f, 0.04697239f, 0.09604955f, -0.14582838f, -0.21279339f, 
    0.00170628f, -0.28950575f, 0.06893621f, 0.33405638f, 0.21893942f, 0.14710383f, 0.29259670f, 0.01181501f, 
    -0.06025388f, 0.02648422f, 0.12093817f, 0.17175612f, 0.15183108f, 0.14563690f, 0.12534332f, -0.15745255f, 
    0.03554015f, 0.01566522f, -0.04874446f, 0.13138747f, -0.03727023f, 0.03055385f, 0.06777083f, -0.07869162f, 
    0.16468404f, 0.17717956f, -0.05734266f, -0.10348019f, 0.07409901f, 0.01828854f, 0.02022544f, 0.03512823f, 
    -0.05284199f, -0.06447210f, 0.10290918f, 0.04457583f, 0.02973319f, 0.13780092f, 0.05199792f, 0.09262227f, 
    -0.04215148f, 0.04479094f, 0.12483711f, 0.01116776f, -0.05314351f, -0.03490328f, -0.06824791f, -0.01696787f, 
    0.02690522f, 0.11399269f, 0.01623465f, 0.00713553f, -0.13126138f, 0.02897958f, -0.09890149f, -0.06529897f, 
    0.11049373f, -0.03175088f, -0.01148807f, -0.03409909f, -0.17736508f, -0.03051757f, 0.07540752f, -0.01823348f, 
    0.08493011f, 0.16635501f, -0.00960163f, -0.07915778f, -0.04302020f, -0.16546173f, -0.01046305f, -0.31081927f, 
    -0.08278807f, 0.01166209f, -0.02854549f, -0.14664966f, 0.03949001f, -0.03008837f, 0.13826217f, -0.08312016f, 
    -0.05607355f, -0.10984718f, 0.01263332f, 0.03927062f, -0.10859916f, -0.00380798f, 0.02438182f, -0.14514615f, 
    0.06070986f, -0.12582026f, 0.17924631f, -0.04335033f, -0.00871739f, 0.13287173f, -0.23388737f, -0.17255978f, 
    0.02521435f, -0.01413335f, 0.11936169f, 0.11029666f, 0.05470465f, 0.02697907f, 0.12626077f, 0.02180200f, 
    0.00400134f, -0.02473492f, 0.20671804f, -0.08258715f, 0.22474778f, -0.10258290f, 0.02856628f, 0.03128038f, 
    -0.13044903f, -0.08331982f, -0.00175339f, 0.02405042f, -0.01336972f, 0.04474723f, -0.20349860f, -0.02379970f, 
    0.01702154f, 0.10966423f, -0.13530013f, -0.03978667f, 0.00508454f, 0.07152418f, -0.01712955f, 0.02160825f, 
    0.02252916f, -0.00001426f, 0.01974109f, 0.08752044f, 0.07457802f, 0.19928989f, -0.02403056f, 0.07979201f, 
    -0.00714974f, 0.04495948f, -0.00369799f, -0.00430006f, 0.09116140f, -0.02000706f, 0.07453261f, 0.07056386f, 
    0.08154098f, -0.28666005f, 0.45526457f, -0.13652277f, 0.14425054f, 0.08782072f, 0.01955641f, -0.13150935f, 
    0.03712762f, 0.04346308f, -0.21523742f, 0.07400614f, -0.06958580f, 0.15442044f, 0.03649963f, 0.00872522f, 
    0.11359230f, 0.21227793f, 0.03165652f, -0.05101848f, -0.19730754f, -0.21559297f, -0.01175864f, -0.14188097f, 
    -0.30293250f, 0.04269268f, 0.05678153f, -0.07551741f, 0.01136245f, 0.16428103f, 0.14300758f, 0.06430120f, 
    0.02437629f, 0.00429537f, -0.00516242f, -0.05514007f, 0.07692395f, 0.08824662f, 0.19351287f, 0.05764998f, 
    -0.02235762f, -0.09132532f, -0.09893416f, 0.05639286f, 0.03895986f, 0.03566047f, 0.17882071f, -0.03283369f, 
    0.04827430f, -0.03702591f, -0.11479570f, 0.06622881f, 0.04902748f, -0.08618502f, -0.07213083f, 0.01602015f, 
    -0.08174884f, -0.01144492f, 0.02828577f, 0.12802374f, 0.10210697f, -0.26140457f, 0.08941848f, 0.04423042f, 
    0.10689148f, -0.08196391f, 0.04064606f, -0.04428906f, -0.09382613f, -0.00348491f, -0.11449046f, -0.20398585f, 
    0.11964822f, -0.07233205f, -0.13061303f, -0.13493913f, -0.24297573f, -0.00226057f, -0.04322520f, 0.04411691f, 
    0.05462574f, 0.02800579f, 0.00450710f, -0.00558766f, 0.01461092f, -0.18583666f, 0.04388650f, 0.08530828f, 
    0.19387779f, 0.11903207f, -0.05762468f, 0.04074351f, -0.10747453f, 0.13392785f, 0.02299321f, 0.02190105f, 
    0.14722745f, 0.07134657f, -0.08607068f, -0.15524384f, -0.03967108f, -0.04052845f, -0.01519144f, -0.09488188f, 
    0.12243602f, -0.09763454f, 0.08614665f, 0.19769362f, 0.02475986f, -0.42219773f, 0.12522995f, 0.12198948f, 
    -0.01275281f, -0.16314173f, 0.00696775f, -0.07298063f, 0.05213277f, -0.00812070f, -0.05628826f, 0.06065860f, 
    0.14685321f, -0.33915687f, -0.13119589f, 0.08644851f, 0.05088532f, -0.02807007f, 0.14217275f, 0.00682833f, 
    0.00698608f, -0.05101816f, 0.05936617f, -0.04634622f, -0.14443257f, 0.14470944f, -0.01426381f, -0.02380235f, 
    0.01360433f, 0.00342243f, 0.03394086f, 0.13800588f, 0.08475769f, 0.16739973f, 0.18118057f, 0.11864363f, 
    -0.31390041f, -0.41991943f, -0.16823864f, -0.05137723f, 0.00286172f, -0.09247629f, 0.07023392f, 0.08970971f, 
    0.05325046f, 0.04576723f, 0.00427513f, 0.13606988f, 0.30093861f, 0.20262344f, 0.20749277f, -0.11714991f, 
    -0.01760845f, 0.00088950f, -0.01736455f, -0.05387815f, -0.04524235f, -0.03661821f, -0.03890132f, -0.01979458f, 
    0.03631736f, 0.25097215f, -0.15686084f, 0.22480820f, -0.07846641f, 0.11587319f, 0.13060629f, 0.02441105f, 
    -0.08295263f, 0.06703090f, 0.09063791f, -0.09092416f, 0.01651223f, -0.20145366f, -0.08437827f, -0.13498819f, 
    0.12883483f, 0.04549028f, -0.05466458f, 0.12932052f, -0.16101402f, 0.06437413f, 0.13830268f, 0.01887967f, 
    0.45330364f, -0.38923377f, 0.06150187f, -0.18993257f, -0.01387006f, -0.02557877f, 0.04044155f, -0.03534360f, 
    0.07529727f, -0.00730852f, -0.14139554f, 0.07943552f, -0.22500327f, -0.21762826f, -0.18726763f, 0.00296592f, 
    -0.00839562f, -0.00442129f, -0.01031341f, 0.00814165f, -0.02923002f, -0.04619116f, -0.22437902f, 0.02161255f, 
    -0.02999299f, 0.02427805f, 0.29934394f, 0.11031266f, -0.01669724f, 0.04635599f, 0.00887572f, -0.01864466f, 
    0.05777575f, -0.03203722f, 0.01870150f, 0.06202800f, -0.00528706f, -0.25891787f, -0.03486657f, 0.10664352f, 
    -0.07725123f, 0.10265110f, 0.13232335f, -0.03500298f, -0.07988536f, -0.06002535f, -0.04013666f, -0.04757833f, 
    0.09894987f, 0.09132487f, 0.03002523f, 0.04722430f, 0.12207875f, -0.05824693f, 0.00902743f, 0.03112153f, 
    -0.04540966f, 0.10563934f, 0.02613334f, 0.20988457f, -0.06391458f, 0.24813586f, 0.27596554f, 0.21972324f, 
    0.08553804f, -0.11078224f, 0.07109402f, 0.09737689f, 0.05684176f, 0.10470123f, 0.03783181f, -0.11293346f, 
    0.20094299f, -0.08870392f, -0.03280746f, 0.08095968f, -0.01321489f, -0.04551238f, -0.06469198f, 0.02112775f, 
    0.01238718f, -0.02897438f, 0.07280944f, -0.04581849f, -0.09648136f, -0.09343071f, -0.19934432f, 0.28187919f, 
    -0.03232773f, -0.08096383f, 0.03587509f, 0.03393222f, 0.03425554f, 0.01446611f, -0.15320626f, 0.14811972f, 
    -0.19247539f, -0.19043449f, 0.24549311f, 0.19128782f, 0.07818253f, 0.08186287f, 0.16840798f, -0.02346045f, 
    0.03174230f, 0.02633412f, 0.00724738f, -0.00238020f, 0.01506735f, -0.01995920f, 0.07170428f, 0.20759995f, 
    0.13927212f, -0.02503967f, 0.02582735f, 0.13599800f, 0.10035025f, 0.10829142f, -0.05468610f, -0.05852022f, 
    0.16387489f, -0.01481185f, 0.15181805f, 0.14703006f, 0.11450604f, 0.00662675f, 0.07651403f, 0.19000797f, 
    0.15757938f, -0.00169745f, 0.01127880f, 0.16653731f, 0.14652859f, -0.04017442f, 0.07427695f, -0.05094155f, 
    -0.06966036f, -0.03248966f, -0.05497712f, 0.04592383f, 0.11439162f, -0.02706053f, -0.09262894f, -0.16692123f, 
    -0.05609304f, 0.05326806f, 0.20486268f, 0.19984119f, 0.00169605f, 0.01985560f, 0.13259733f, 0.02104640f, 
    -0.00784113f, 0.03530093f, -0.02882806f, -0.01841254f, 0.00167357f, 0.00801692f, 0.00086743f, 0.03157406f, 
    0.11250065f, 0.06273524f, 0.01335641f, 0.06615292f, -0.09827729f, 0.06273186f, -0.09500740f, -0.08574341f, 
    0.19567938f, -0.11313272f, 0.15529339f, -0.15918386f, -0.07910355f, 0.05054455f, -0.06062660f, -0.03394041f, 
    -0.01205721f, -0.03941286f, -0.07616781f, -0.01340232f, -0.30600992f, -0.10297257f, -0.01680446f, 0.21347065f, 
    -0.00638364f, 0.03025707f, 0.15244320f, 0.30945000f, -0.14159180f, 0.14062904f, -0.03470999f, 0.10867266f, 
    -0.09642718f, -0.20523553f, -0.10814445f, -0.03605528f, 0.00562699f, -0.01694838f, -0.07412290f, 0.04114668f, 
    0.05490524f, 0.06670018f, 0.05231474f, 0.04698275f, 0.12931946f, -0.03347277f, 0.12442192f, 0.01631682f, 
    -0.10663740f, 0.12644121f, -0.02487912f, -0.02799739f, -0.09474248f, -0.06559847f, -0.02492382f, -0.05198954f, 
    0.36128291f, 0.01574804f, 0.09751654f, -0.31571612f, 0.02517233f, -0.01447829f, 0.00246129f, -0.09930237f, 
    0.05890336f, 0.16999871f, 0.11921083f, 0.10910424f, 0.47398973f, -0.17550895f, 0.21824953f, -0.21093307f, 
    0.04169406f, 0.03559823f, -0.09296133f, 0.02148368f, -0.00314845f, -0.02366589f, -0.00219071f, -0.07978878f, 
    -0.17589498f, 0.22081323f, 0.20578991f, 0.19264776f, 0.07916962f, -0.06157925f, 0.13216750f, 0.00838356f, 
    -0.10589758f, 0.00417397f, 0.09569941f, 0.05097294f, -0.07866295f, -0.15312874f, 0.13627778f, 0.22815974f, 
    0.10249241f, 0.11547345f, -0.02226888f, -0.10828917f, 0.08278973f, -0.01651377f, -0.03235582f, -0.07564696f, 
    -0.08789203f, 0.30925748f, 0.29308516f, 0.27724501f, 0.05073548f, 0.06132422f, 0.04485697f, -0.01730043f, 
    0.05239015f, 0.10815063f, 0.08069422f, 0.11326757f, 0.25625715f, 0.10780899f, -0.16956836f, 0.00578142f, 
    0.13264404f, 0.21847565f, 0.16488822f, 0.01507298f, 0.00276121f, 0.03575787f, -0.03981668f, 0.06780775f, 
    -0.14172350f, -0.08076026f, 0.27254415f, 0.14863141f, 0.23260069f, -0.12739244f, 0.06266184f, 0.13129307f, 
    -0.02406942f, 0.11974723f, -0.01004211f, 0.01112666f, -0.20111780f, 0.17637384f, 0.27362111f, -0.00740422f, 
    0.03356761f, -0.01271980f, -0.00688645f, -0.01820414f, 0.00378858f, 0.02044821f, -0.08224779f, 0.17373912f, 
    -0.17138959f, 0.02935795f, 0.29109886f, 0.14790951f, 0.10460774f, 0.09525023f, 0.03578222f, 0.00864942f, 
    0.03259746f, -0.04399338f, -0.03562659f, -0.01041033f, -0.23989688f, 0.19416921f, 0.40022829f, 0.41904813f, 
    0.07294069f, -0.01632099f, 0.10767159f, 0.09701014f, 0.04187172f, 0.03909546f, 0.06876207f, 0.17059176f, 
    -0.07468721f, -0.05484243f, 0.01284525f, -0.00920774f, -0.01047038f, -0.04606907f, -0.02865049f, 0.08999471f, 
    -0.04558657f, 0.10281402f, -0.09281783f, 0.00347219f, -0.12030027f, -0.15878995f, 0.12448151f, 0.06525226f, 
    0.10587965f, -0.11148591f, 0.01429524f, -0.05225686f, -0.08358255f, 0.08177503f, 0.15226552f, 0.14583915f, 
    -0.00489688f, 0.50546032f, 0.33631575f, 0.24319530f, -0.08281186f, 0.01031679f, 0.03328897f, 0.11974127f, 
    0.08435376f, 0.09982736f, 0.03389997f, -0.01949657f, 0.04700478f, -0.07870308f, -0.13028497f, 0.05051078f, 
    -0.08789960f, 0.00720582f, -0.05885393f, 0.00776427f, -0.01584408f, -0.05728413f, 0.02450714f, 0.05933696f, 
    -0.24197766f, 0.01752316f, 0.05194134f, 0.27071089f, -0.19473979f, -0.03770025f, -0.02123458f, 0.19465396f, 
    -0.05959070f, -0.02152776f, -0.01992042f, -0.00381868f, -0.26703292f, -0.08603655f, -0.04017041f, 0.16213812f, 
    0.05565557f, 0.02044493f, 0.02510456f, 0.09315404f, -0.06882422f, 0.21559761f, -0.11562909f, 0.03530855f, 
    -0.07028586f, 0.33052820f, -0.26767910f, 0.35026982f, 0.21244919f, 0.06960303f, -0.07174487f, 0.06772652f, 
    0.09718521f, 0.00963323f, -0.01005341f, -0.01886454f, 0.13719410f, -0.07313649f, 0.00838112f, 0.07906259f, 
    0.03308351f, 0.16021901f, 0.12599708f, 0.01918926f, -0.04616563f, 0.00609206f, -0.06810816f, -0.06704038f, 
    -0.24639963f, -0.06766868f, -0.18807749f, 0.13754344f, -0.04150850f, -0.06095295f, -0.08335679f, -0.02269704f, 
    0.04630170f, -0.05922928f, -0.04601439f, 0.05761817f, -0.13932304f, -0.05416794f, 0.32493794f, -0.00229607f, 
    0.05371331f, 0.07514828f, 0.05341033f, -0.00864526f, 0.02464101f, 0.01091333f, -0.01053433f, -0.02176506f, 
    -0.19453339f, -0.13586642f, 0.15805575f, 0.29321688f, -0.07830168f, 0.11735734f, 0.08998136f, -0.16478355f, 
    0.07061653f, 0.01970536f, 0.02794385f, 0.00817306f, 0.13861491f, -0.08503226f, 0.16571984f, -0.08702514f, 
    0.03912532f, 0.03372635f, -0.09567353f, -0.04020382f, -0.02600456f, -0.07485694f, -0.04710579f, -0.06229218f, 
    -0.17731890f, 0.25560611f, 0.44543186f, 0.36861318f, 0.06380436f, -0.01339762f, 0.06096778f, 0.01370972f, 
    0.04250959f, -0.09884367f, 0.05948660f, 0.05779386f, 0.15548193f, -0.19056056f, -0.02895453f, -0.01319728f, 
    -0.05069080f, 0.20413306f, 0.02834620f, 0.07345513f, 0.03415948f, -0.05706634f, -0.04587330f, -0.10839050f, 
    0.04736485f, -0.01106047f, -0.27285242f, 0.20086409f, 0.06422636f, -0.07430635f, -0.04159738f, -0.05391530f, 
    0.06136893f, 0.04060290f, -0.03962278f, 0.13311704f, 0.08966932f, 0.00827807f, 0.02825877f, 0.07855122f, 
    0.05379845f, 0.09874575f, -0.11814861f, -0.02425539f, 0.12852970f, 0.07322296f, 0.01616722f, -0.03579481f, 
    0.25235236f, 0.15939930f, -0.04117822f, -0.08056109f, 0.05656827f, -0.06853334f, -0.00369202f, -0.10379791f, 
    0.09509255f, -0.02488339f, 0.07862224f, 0.10256197f, -0.29142460f, 0.02202349f, -0.05760244f, 0.07176092f, 
    0.21260606f, 0.00098128f, 0.05261159f, -0.02501410f, -0.05808356f, 0.08328033f, -0.07079181f, -0.04647714f, 
    -0.36629730f, -0.04740079f, 0.34641960f, 0.27206731f, 0.02428886f, -0.00813488f, 0.08422067f, -0.11835111f, 
    0.02290747f, 0.11774674f, 0.08572833f, 0.07143908f, -0.12057550f, -0.03430505f, 0.12659261f, 0.14670049f, 
    0.10840177f, -0.12141808f, 0.00951203f, 0.10230536f, 0.10525809f, 0.16490693f, 0.08096839f, 0.13405883f, 
    -0.30214658f, 0.20488477f, -0.01206787f, 0.52074903f, -0.10946294f, -0.05510160f, -0.08510143f, 0.29035497f, 
    -0.01183453f, 0.06296247f, 0.01291327f, 0.05575937f, -0.05667897f, 0.00580396f, -0.01555969f, -0.02471781f, 
    -0.01910365f, 0.01530700f, 0.00051274f, 0.05014811f, -0.05073252f, 0.05434078f, -0.08457029f, -0.17665780f, 
    0.27875003f, -0.07793875f, -0.04701549f, 0.16134183f, -0.05132198f, -0.09248210f, 0.10286193f, -0.12379768f, 
    -0.15800011f, 0.05159609f, -0.00581497f, -0.01325763f, -0.28115436f, -0.04372863f, -0.11115742f, 0.30763537f, 
    0.07709635f, -0.09385329f, 0.05914317f, 0.11088105f, 0.15181094f, -0.03528807f, -0.02306377f, 0.19776089f, 
    0.16995423f, 0.10928225f, -0.06593823f, -0.08363833f, -0.04866319f, 0.05764286f, 0.01925338f, -0.10851982f, 
    0.26513726f, 0.19991566f, 0.16184141f, 0.12797247f, -0.13866168f, 0.05254780f, -0.04577287f, 0.07357194f, 
    0.19170891f, -0.00726102f, -0.00780350f, 0.02089167f, -0.10364415f, -0.01848759f, -0.09074986f, -0.08532355f, 
    -0.10463437f, -0.01549440f, 0.10195105f, 0.07319787f, 0.00237658f, -0.09748666f, 0.00403903f, 0.02547896f, 
    -0.06851249f, 0.16232334f, -0.07147367f, 0.06845611f, -0.01216855f, -0.03798932f, -0.09719487f, 0.14573987f, 
    0.01031783f, 0.01059776f, 0.17186190f, -0.14117299f, -0.01627787f, 0.03438454f, -0.09341513f, 0.02445111f, 
    0.03343903f, 0.20457533f, 0.40549901f, 0.36282933f, 0.05396260f, -0.07445812f, 0.07280826f, -0.06490459f, 
    0.04727679f, 0.12583974f, -0.00693199f, 0.08444715f, -0.10370688f, -0.07925817f, -0.13525756f, -0.10838815f, 
    -0.00483340f, 0.07377390f, -0.02922284f, 0.06510624f, 0.02044845f, 0.00397917f, 0.00285184f, -0.05473211f, 
    0.27661929f, -0.02640404f, -0.05758001f, 0.04079952f, -0.08271220f, -0.00210517f, -0.02927370f, 0.03779395f, 
    0.08827870f, 0.04848977f, -0.04660362f, -0.07475465f, 0.10097790f, -0.01726350f, -0.08958577f, 0.05783671f, 
    -0.02570994f, -0.08279582f, 0.04933722f, -0.02294344f, 0.02260155f, -0.00429757f, 0.04839383f, 0.14605705f, 
    0.00387750f, 0.15187006f, -0.07526376f, -0.14023100f, -0.02540675f, 0.01324526f, 0.00368518f, -0.04194604f, 
    0.14238448f, 0.08448160f, 0.14189591f, 0.06471980f, -0.06694679f, -0.04858386f, 0.01810856f, 0.14490239f, 
    0.09604010f, 0.18097633f, 0.02903376f, 0.12095261f, 0.21586321f, -0.04079249f, -0.02914203f, -0.04248958f, 
    0.10070532f, -0.08608236f, -0.15522848f, -0.04039512f, 0.11128337f, 0.10027336f, 0.00804918f, -0.11487424f, 
    0.07923346f, 0.03087215f, -0.03563991f, 0.05169600f, -0.00258027f, -0.03139787f, -0.16928735f, 0.11553233f, 
    0.05297084f, -0.06813380f, 0.16874422f, -0.06929477f, 0.04998529f, -0.02072127f, 0.06094286f, -0.01227488f, 
    -0.56044680f, 0.35406592f, -0.22163065f, 0.12116090f, 0.05112930f, -0.04855196f, -0.09108015f, 0.01424643f, 
    -0.00888953f, 0.08224832f, -0.07225442f, -0.11432406f, 0.21036287f, 0.07357676f, -0.02435437f, 0.12119640f, 
    -0.05378178f, -0.03183359f, 0.00619558f, 0.03801582f, 0.01557413f, -0.00434090f, 0.00018287f, -0.09478850f, 
    0.03055564f, 0.08251986f, -0.10336587f, 0.08961213f, 0.06499944f, -0.00674216f, -0.09050880f, -0.09430498f, 
    -0.03988556f, 0.05830317f, 0.13181755f, 0.09927513f, 0.06481341f, -0.09490276f, -0.10034000f, 0.04251453f, 
    -0.02930089f, -0.02323238f, -0.05215674f, 0.05022252f, -0.03523293f, 0.02210438f, -0.05088410f, -0.01646529f, 
    -0.10884893f, 0.11317205f, 0.11880770f, 0.26976353f, -0.05427757f, -0.01752198f, 0.06187048f, 0.00420890f, 
    0.04105759f, -0.00849067f, 0.13359670f, -0.03023118f, 0.00491261f, 0.07620601f, -0.04118410f, 0.11002935f, 
    0.06288203f, 0.01558298f, 0.02113837f, 0.07265379f, 0.05833162f, 0.01856040f, 0.03891844f, -0.01271529f, 
    0.10186546f, -0.02494513f, 0.09460717f, -0.21278669f, -0.10455915f, 0.01506793f, 0.02191538f, 0.01376540f, 
    -0.07367120f, -0.00753357f, -0.02656607f, 0.05310816f, -0.00505216f, 0.22203487f, -0.07172626f, -0.11252066f, 
    0.01638723f, -0.03410463f, 0.06930640f, -0.10429695f, 0.15813522f, 0.11183232f, -0.06374785f, 0.10800513f, 
    -0.04302036f, -0.29256046f, -0.08207382f, 0.04198785f, 0.04881905f, 0.00251172f, -0.00144921f, -0.06859513f, 
    -0.02786103f, 0.00708903f, -0.06666702f, -0.05216219f, 0.26167533f, -0.00145430f, 0.14641270f, 0.06813028f, 
    0.03420160f, 0.03573513f, 0.01240388f, 0.20656222f, -0.03168875f, 0.03296196f, -0.02343599f, -0.08462617f, 
    0.16980922f, -0.02358722f, 0.15112127f, 0.23985232f, 0.06116404f, 0.02901942f, 0.05576301f, 0.04503537f, 
    0.02129129f, 0.05770366f, 0.08751947f, 0.03829581f, -0.05211444f, 0.13155691f, 0.04245528f, 0.03195500f, 
    -0.06913816f, 0.11468172f, -0.04865973f, 0.03816409f, -0.12051608f, 0.11037809f, 0.08127890f, 0.01945742f, 
    0.06689442f, -0.07597476f, -0.03812356f, 0.00874969f, -0.02291438f, 0.07357900f, 0.02584837f, 0.09001530f, 
    0.00541898f, 0.02016172f, 0.01624686f, 0.02969320f, -0.08867487f, -0.09013493f, -0.06352595f, 0.09483290f, 
    0.04140916f, -0.05912965f, 0.19572204f, 0.09551098f, -0.02228266f, 0.03748497f, 0.04207923f, 0.03284363f, 
    -0.05802246f, 0.14382461f, 0.26805347f, -0.22071531f, -0.17541696f, -0.03176093f, -0.11929227f, -0.02797728f, 
    -0.15050425f, 0.01245799f, -0.04103706f, -0.02930623f, -0.10801698f, 0.40187636f, -0.44592810f, -0.09197143f, 
    0.16280673f, 0.24783635f, 0.11924569f, 0.05639543f, 0.00622096f, 0.12754601f, 0.05018328f, 0.02701120f, 
    -0.13415526f, -0.08952022f, -0.08290581f, -0.29350308f, -0.06304070f, -0.03784404f, 0.01478087f, -0.01021734f, 
    -0.19235665f, 0.06459935f, 0.13057625f, 0.00226468f, 0.04968765f, 0.00458463f, 0.15203826f, -0.05714627f, 
    -0.14923207f, 0.02700266f, -0.09159449f, -0.02477874f, -0.04824651f, 0.04253023f, -0.02493014f, -0.02772110f, 
    0.19446163f, -0.10748670f, 0.48058563f, 0.02886304f, -0.02179548f, -0.10572418f, 0.16853461f, 0.07899828f, 
    -0.02581257f, 0.10125855f, 0.03953766f, 0.03448208f, 0.08017833f, -0.19801298f, 0.62352937f, -0.24344446f, 
    -0.17491958f, 0.02549135f, -0.05290578f, 0.03318213f, -0.10758843f, -0.01036078f, 0.02751054f, 0.04169766f, 
    0.12473595f, 0.06687171f, -0.05110819f, 0.09736336f, 0.01398225f, -0.01429212f, 0.03344706f, 0.02757708f, 
    -0.07617518f, 0.05909396f, 0.09108116f, -0.00441329f, -0.24550727f, -0.32228276f, -0.12434729f, 0.04815407f, 
    0.08074028f, 0.03861932f, -0.09969095f, -0.09686650f, -0.07885059f, -0.05646924f, -0.02407514f, -0.07570463f, 
    0.02523713f, -0.00395155f, -0.02084299f, 0.08306691f, 0.05720222f, 0.05569698f, -0.00195910f, 0.09303374f, 
    0.07543665f, 0.12105617f, 0.07671064f, 0.00107646f, -0.30293843f, 0.10278357f, 0.07967672f, 0.22547020f, 
    0.03779066f, 0.16531487f, 0.17502683f, 0.13014737f, -0.16424099f, 0.16637108f, 0.13325612f, 0.09688726f, 
    0.04003867f, 0.15635055f, 0.03125946f, -0.12890711f, 0.14229192f, 0.05057205f, 0.03279426f, 0.22146378f, 
    -0.08901239f, 0.02933335f, 0.07120483f, -0.02141606f, 0.14056520f, 0.13056457f, -0.10731144f, -0.20706354f, 
    0.04146518f, 0.10180410f, 0.03356548f, -0.03007700f, 0.03290751f, -0.00150643f, 0.11735678f, 0.03389269f, 
    -0.08119483f, -0.27414361f, -0.27908811f, 0.16699755f, 0.01139855f, -0.02187225f, -0.02976396f, 0.02112749f, 
    0.01992213f, -0.03717099f, -0.01283064f, -0.05271056f, 0.14514801f, 0.03772848f, 0.06907254f, 0.14624940f, 
    0.16250671f, 0.01739478f, 0.07990406f, 0.09752892f, 0.05443497f, 0.10676704f, 0.02994172f, -0.09535266f, 
    -0.09782159f, 0.10603078f, -0.04545779f, -0.17732267f, 0.04408256f, 0.03819945f, -0.00823351f, 0.00115023f, 
    0.06692025f, 0.06599061f, 0.09104726f, -0.01486322f, -0.23859635f, 0.08033861f, -0.03086635f, -0.14890887f, 
    0.03147632f, -0.02576500f, 0.06324197f, 0.01373630f, 0.03843151f, 0.07415496f, 0.10773174f, 0.13611913f, 
    -0.16771597f, 0.28905836f, -0.04771590f, 0.16463062f, -0.00971319f, 0.03336283f, 0.02962911f, 0.19855319f, 
    -0.00055462f, 0.18772826f, 0.04978279f, -0.02375714f, 0.03596344f, 0.18631148f, 0.01795365f, -0.03082321f, 
    -0.11070688f, 0.01861593f, -0.05664638f, 0.08946633f, -0.12663418f, 0.06871802f, 0.01082847f, 0.09767016f, 
    -0.14608650f, 0.51821607f, 0.09189811f, 0.05817528f, -0.12613329f, -0.02387836f, 0.03166268f, -0.01754206f, 
    -0.10662422f, -0.01963820f, 0.02380385f, -0.09811406f, -0.30708086f, 0.28395170f, -0.06148101f, -0.10655573f, 
    0.14573820f, 0.04169760f, -0.02578374f, -0.02201722f, 0.18321194f, 0.34051788f, 0.03789714f, 0.11564368f, 
    -0.23023598f, 0.53694469f, -0.22757529f, 0.38748702f, -0.05433648f, 0.15395865f, 0.00727860f, -0.02746149f, 
    -0.11294020f, 0.01083551f, 0.12632801f, 0.07066900f, -0.11506418f, -0.06139263f, 0.35108748f, 0.01148095f, 
    -0.02009275f, 0.06276853f, 0.12008882f, 0.08416337f, -0.10967509f, -0.05355602f, 0.11908415f, 0.02435216f, 
    -0.16940948f, 0.19285794f, -0.10753200f, -0.18986638f, -0.21323666f, -0.10811960f, -0.02992194f, -0.10369238f, 
    -0.01828044f, -0.07502196f, -0.06140159f, -0.02639201f, 0.02503708f, -0.25946230f, -0.00180425f, 0.24771573f, 
    0.04183096f, 0.19260454f, -0.13155527f, 0.00311624f, -0.03496332f, -0.01267220f, -0.01779443f, 0.00685763f, 
    -0.07175615f, -0.32009655f, -0.15725632f, 0.13375247f, -0.06853916f, -0.06990938f, 0.00544296f, -0.13396530f, 
    -0.00513706f, -0.00588895f, -0.08237493f, -0.04752732f, 0.14603683f, -0.30614045f, 0.07560930f, -0.09095196f, 
    0.19977663f, 0.11463268f, 0.00850073f, 0.08117487f, 0.04018923f, 0.08346164f, 0.03010284f, 0.08022792f, 
    -0.04958736f, 0.17635243f, 0.07537803f, 0.10552715f, 0.02378379f, 0.06001864f, 0.02226316f, 0.08491497f, 
    -0.03440647f, 0.09169625f, -0.04913277f, -0.03306822f, 0.04400948f, -0.01751679f, 0.04991797f, -0.09170223f, 
    -0.06067240f, 0.00431642f, 0.10907061f, -0.09213042f, -0.01070251f, 0.09719191f, 0.01949460f, 0.08825979f, 
    -0.15470968f, 0.37075388f, -0.04859223f, 0.28670394f, -0.11292480f, -0.04605152f, -0.03006873f, 0.01999975f, 
    -0.00721672f, 0.05605400f, -0.05698838f, 0.05113450f, 0.11422383f, -0.03742563f, 0.27640277f, 0.18768063f, 
    0.04372418f, 0.08950518f, 0.08596562f, 0.03864846f, 0.01070337f, 0.02915045f, 0.13879468f, -0.11975139f, 
    0.24603669f, 0.00302312f, 0.12681811f, 0.10315251f, 0.08883838f, 0.14454453f, 0.07218534f, 0.15306054f, 
    -0.08829014f, 0.09289116f, -0.02361877f, 0.13441220f, -0.24772635f, 0.38924742f, -0.15091880f, -0.13678859f, 
    0.08683892f, 0.00960501f, 0.05728446f, -0.09076664f, 0.01366305f, -0.07600908f, 0.13306139f, -0.00128618f, 
    0.24432969f, -0.06495779f, 0.04729613f, 0.13715045f, 0.10080587f, 0.08632848f, 0.07050302f, 0.00678237f, 
    -0.03507037f, 0.09352381f, 0.00135043f, -0.02225398f, 0.08993509f, -0.10212654f, -0.15434322f, -0.00097747f, 
    0.05050257f, 0.03077370f, 0.02339366f, 0.07626123f, -0.01853489f, 0.08992146f, 0.02462376f, -0.05603712f, 
    0.01738494f, 0.56461608f, -0.61112279f, 0.20119888f, 0.08272428f, 0.15726981f, 0.05830773f, 0.07449424f, 
    0.11156749f, 0.01857887f, 0.13698450f, 0.05273031f, -0.10393567f, 0.05019336f, -0.11617850f, 0.05144240f, 
    0.04682609f, -0.01778631f, 0.09887694f, 0.07327005f, 0.10634091f, 0.10745732f, 0.17335106f, -0.02330365f, 
    0.55758780f, -0.06695241f, 0.00218102f, -0.08241099f, 0.03316705f, 0.02787713f, 0.10574071f, 0.08282560f, 
    0.03571013f, 0.03714160f, 0.01630826f, 0.06250765f, -0.02480130f, 0.38668787f, -0.37741664f, 0.29731840f, 
    0.16711664f, 0.14787388f, 0.22787313f, 0.07825642f, 0.07589975f, 0.04805570f, 0.04187812f, 0.09937011f, 
    -0.04912644f, 0.04605164f, -0.03520124f, 0.08877118f, -0.03260190f, 0.01896746f, -0.00422766f, 0.04010367f, 
    0.10474552f, 0.15200664f, 0.08164015f, 0.02300149f, -0.14268467f, 0.14985964f, -0.08167656f, -0.02425049f, 
    -0.05401614f, 0.07859070f, -0.03573595f, -0.04839290f, 0.00346602f, 0.01874324f, -0.02926327f, 0.06785468f, 
    -0.21969791f, 0.13117211f, -0.06831083f, -0.18270242f, 0.00294300f, 0.00854646f, -0.02912708f, 0.00862649f, 
    -0.03079409f, 0.03569972f, 0.08042472f, 0.04653728f, -0.01337953f, 0.07582324f, 0.16252193f, 0.12825370f, 
    -0.01777125f, 0.06326053f, 0.08407224f, -0.01107452f, -0.00161838f, 0.01185347f, 0.04861896f, -0.04354227f, 
    0.04696144f, -0.09616203f, 0.02547193f, 0.20845599f, 0.02105648f, -0.06179389f, 0.08719592f, 0.15363501f, 
    -0.07198074f, 0.08119379f, -0.09801142f, 0.03706777f, -0.09792457f, 0.19806227f, -0.19588050f, 0.03501835f, 
    -0.06549694f, -0.03917883f, 0.00610220f, -0.01272058f, -0.10969462f, -0.01259323f, 0.04293068f, 0.08025552f, 
    -0.15676032f, 0.11466479f, 0.20858654f, 0.03539383f, -0.08781813f, 0.09728709f, -0.05101310f, -0.07936147f, 
    -0.08429059f, -0.00596397f, 0.04846072f, 0.02070359f, 0.20486763f, 0.02636286f, -0.06848530f, 0.00140550f, 
    0.04376799f, 0.00963247f, 0.06849287f, 0.06044805f, 0.01513234f, 0.18938561f, -0.04559485f, -0.08690817f, 
    -0.02960848f, 0.31929696f, -0.01153079f, 0.07098199f, -0.10961822f, -0.06963842f, -0.04367002f, -0.03635675f, 
    0.05234443f, 0.08295318f, -0.00603955f, -0.03156525f, -0.26356897f, -0.10846642f, -0.25168589f, 0.11095452f, 
    0.01068628f, 0.07525597f, -0.09485675f, 0.11447065f, 0.06514846f, -0.00088307f, -0.00224778f, -0.07716247f, 
    -0.19475801f, -0.07765395f, 0.16866426f, 0.03812001f, -0.03210681f, -0.02909546f, 0.05353693f, -0.08983053f, 
    -0.14184897f, 0.11117409f, 0.06845422f, 0.03012696f, -0.08014046f, 0.03257900f, 0.13007328f, 0.42977491f, 
    -0.10099399f, 0.09534134f, 0.25847998f, -0.13305061f, 0.16291897f, -0.01329217f, 0.03245913f, 0.20777614f, 
    -0.70248932f, 0.79125333f, -0.28448555f, 0.45565420f, 0.02563788f, -0.06615809f, 0.02667088f, 0.04454358f, 
    -0.03139632f, -0.02507204f, 0.09188855f, 0.02183366f, -0.12097798f, 0.16494365f, -0.05245390f, 0.27593443f, 
    -0.03075419f, 0.04253516f, 0.03675052f, -0.02227797f, -0.00903840f, -0.02528149f, 0.11734975f, 0.02706087f, 
    0.15012941f, 0.02654989f, 0.14561345f, -0.06649919f, 0.21610332f, 0.08920406f, 0.01928901f, 0.02959260f, 
    0.05453019f, 0.07590318f, 0.08184918f, 0.18524992f, -0.03686689f, -0.03326902f, -0.06301727f, -0.07599519f, 
    -0.06074435f, 0.03251041f, 0.03616802f, -0.03237428f, -0.07993446f, 0.05006983f, 0.04794266f, 0.12009519f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00695959f, 0.18544510f, 0.01904006f, 0.05478967f, -0.03537342f, -0.01026230f, 0.00660154f, -0.12797028f, 
    0.09879314f, -0.00357604f, -0.03299532f, -0.01383619f, 0.08452339f, 0.00903580f, 0.02468780f, -0.05593672f, 
    0.12152355f, 0.00219901f, 0.01026522f, 0.02653874f, 0.07978170f, 0.08613906f, 0.03375366f, 0.00989343f, 
    -0.09454562f, 0.02642160f, -0.03649434f, -0.04062306f, 0.11391205f, -0.02881349f, 0.09023474f, 0.01491344f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03694931f, -0.45820650f, -0.16984163f, 0.25167704f, 0.08209142f, 0.09454244f, -0.07279909f, 0.37252694f, 
    0.05851780f, -0.12688422f, -0.17967798f, -0.04518604f, -0.05183573f, 0.13824438f, -0.18007378f, 0.12868544f, 
    0.14689259f, 0.16921431f, -0.18025619f, -0.15096062f, -0.20763637f, -0.34630069f, 0.12333796f, 0.05095908f, 
    0.10219548f, 0.02969721f, -0.16525696f, 0.10201637f, -0.26856914f, 0.50421220f, -0.18468714f, -0.10223697f, 
    -0.13467269f, 0.14741592f, -0.16586742f, 0.03296068f, -0.15782709f, -0.14293911f, 0.16559802f, 0.22465008f, 
    0.26596969f, 0.08412053f, -0.15195212f, 0.15595838f, 0.29775593f, 0.08180001f, -0.04351748f, 0.39256757f, 
    0.26545826f, -0.07572331f, -0.00152246f, -0.10978127f, 0.27373707f, 0.19866976f, -0.15489472f, 0.15362132f, 
    -0.49049285f, 0.05790512f, -0.10588793f, 0.07633649f, -0.14634095f, -0.55752456f, -0.01601200f, -0.11161753f, 
    0.12333056f, -0.25438020f, 0.02043464f, 0.22892167f, 0.06029566f, -0.13180861f, 0.16133314f, -0.45448333f, 
    -0.25726688f, 0.04418527f, 0.06979107f, -0.13111484f, 0.00719005f, -0.04710937f, -0.10445450f, -0.20486085f, 
    0.29729530f, 0.08065224f, 0.08756239f, 0.07289317f, 0.25359276f, -0.09200133f, 0.34680414f, -0.02495349f, 
    -0.76043022f, -0.34298831f, -0.17023331f, -0.16931435f, -0.27169347f, -0.65721476f, 0.30388424f, 0.12317266f, 
    0.08365794f, -0.22381219f, -0.23495880f, 0.06128155f, -0.13066246f, -0.11626394f, -0.01566193f, 0.16579203f, 
    -0.19246791f, -0.09424169f, -0.16715854f, 0.07617169f, 0.03618871f, -0.13180178f, -0.04896547f, 0.28592455f, 
    -0.54624224f, 0.06967610f, 0.00183398f, 0.08852110f, -0.20820852f, 0.08578867f, 0.06096815f, -0.09879345f, 
    0.23349364f, -0.33638284f, -0.00857893f, -0.16683306f, -0.32334077f, -0.58045256f, 0.23658508f, 0.31486696f, 
    -0.14094234f, -0.45287642f, 0.20659620f, 0.00529481f, -0.03486601f, 0.11357065f, -0.07411680f, -0.10411479f, 
    0.05098433f, -0.01327319f, -0.00594870f, -0.08101762f, -0.64408284f, -0.13617958f, 0.06854054f, 0.20851631f, 
    -0.00866123f, 0.00846038f, -0.08142835f, 0.11905965f, 0.03204940f, 0.26464754f, -0.05072734f, 0.11643946f, 
    0.17725904f, -0.12250852f, 0.08004677f, 0.06830575f, -0.01047929f, 0.34611431f, 0.19248633f, -0.27377144f, 
    0.06333701f, -0.12322530f, -0.16468893f, 0.08051423f, -0.14494142f, 0.10064840f, -0.12598051f, 0.00887806f, 
    0.28550792f, -0.05787173f, -0.01533593f, 0.02538197f, -0.06577860f, 0.05114327f, 0.10949136f, -0.56261820f, 
    -0.01710857f, -0.14620447f, 0.06677590f, -0.06137207f, -0.01321459f, -0.20338623f, 0.08572739f, -0.02994049f, 
    0.30482692f, 0.30585340f, -0.08018967f, 0.05946981f, 0.39949185f, 0.09181848f, 0.07012171f, -0.26050654f, 
    -0.07711178f, 0.25444433f, 0.36981010f, -0.24755207f, 0.08699834f, 0.13020608f, 0.04824833f, -0.26666638f, 
    -0.12391448f, -0.02808503f, 0.11104040f, 0.04316716f, -0.01979316f, 0.16099891f, 0.11750069f, -0.24245290f, 
    -0.17261779f, -0.14194345f, 0.04503259f, 0.04713150f, -0.05496691f, -0.62104207f, -0.84278625f, -0.05856723f, 
    -0.59946692f, -0.03280581f, 0.01695373f, -0.11305360f, -0.29670137f, -0.04096238f, 0.32895046f, 0.08321389f, 
    0.02913582f, -0.11238987f, 0.12835762f, -0.40094870f, -0.15207329f, 0.04046203f, -0.04405655f, -0.23994979f, 
    -0.16944198f, 0.05877804f, -0.02415022f, -0.15277423f, 0.11435025f, -0.15689246f, -0.02209001f, -0.38431284f, 
    -0.25672558f, -0.03666424f, 0.14093401f, -0.12679856f, -0.22311148f, 0.26134568f, 0.57108849f, 0.06838614f, 
    0.29916811f, 0.23324580f, 0.07929501f, -0.07827168f, -0.22669949f, -0.04159321f, -0.54199946f, -0.01046328f, 
    0.16231146f, 0.21932980f, -0.32982594f, 0.22289221f, -0.05757540f, -0.07032917f, 0.14432620f, -0.41541559f, 
    -0.51498061f, 0.15249015f, 0.04989469f, 0.01020490f, 0.36992759f, 0.14635195f, 0.06878791f, -0.37426466f, 
    -0.07597085f, 0.15537760f, 0.05255068f, 0.08281245f, 0.35682148f, -0.24222480f, -0.15284312f, -0.01356213f, 
    0.34639454f, 0.14312834f, -0.00165103f, 0.05402883f, -0.32538497f, -0.39459056f, -0.38891962f, 0.12147963f, 
    0.16491483f, 0.23343714f, 0.36667627f, 0.28609332f, -0.07422444f, 0.09071302f, 0.14999849f, -0.19343758f, 
    0.10621398f, -0.08261223f, 0.01051466f, -0.11318896f, -0.52341968f, -0.00057872f, -0.17310812f, -0.27782738f, 
    -0.50043213f, 0.10416686f, 0.09663116f, 0.05597526f, -0.39805734f, 0.25328103f, 0.25673801f, -0.06692884f, 
    -0.30853197f, -0.35995132f, -0.08716031f, 0.13840239f, 0.03215728f, -0.08652970f, -0.02209098f, -0.30368844f, 
    0.15168680f, -0.15532906f, -0.27873984f, 0.20761476f, -0.05582861f, 0.16105008f, -0.09991044f, -0.28476614f, 
    -0.43620294f, 0.09844996f, -0.05028867f, -0.13962948f, 0.05662387f, -0.02226379f, -0.03508067f, -0.28544116f, 
    -0.22971025f, -0.07086650f, 0.02571308f, 0.00825751f, -0.55438119f, 0.42043954f, -0.56389505f, 0.00087710f, 
    -0.24531938f, 0.10216813f, 0.06875630f, 0.07826292f, 0.30808359f, -0.17887571f, 0.17365015f, 0.39658156f, 
    -0.05271484f, 0.01674701f, -0.16248947f, -0.39702016f, 0.00702656f, -0.07841439f, 0.14958717f, -0.01317202f, 
    0.18729614f, -0.15574528f, -0.00573754f, -0.00751085f, -0.37092358f, 0.13003495f, 0.12214158f, -0.21920130f, 
    0.25223657f, -0.14559382f, -0.02828017f, 0.16274682f, 0.31857988f, 0.04443296f, -0.54450399f, -0.17404856f, 
    0.41604447f, -0.34033841f, 0.16645177f, -0.05863076f, -0.38985541f, -0.23267522f, 0.20521826f, 0.35972166f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23499863f, -0.18262219f, 0.18617865f, 0.12642391f, 0.05533310f, -0.05098503f, -0.04632917f, 0.00706570f, 
    -0.08088140f, -0.04168291f, 0.07646454f, -0.09794381f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
