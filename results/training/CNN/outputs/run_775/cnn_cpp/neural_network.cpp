#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.13135070f, 0.15903960f, 1.53813076f, -1.15271056f, -1.66983533f, -0.03299694f, -0.40404066f, 0.34321493f, 
    -0.20495225f, -0.44168350f, 0.07752187f, 0.76689827f, -0.43973947f, -0.03621606f, -0.19425119f, -0.10642366f, 
    0.11148076f, -0.18878140f, -0.35057193f, -0.38317493f, 0.12847319f, -0.07445578f, -0.05119339f, 0.22573870f, 
    0.27211550f, 0.14363693f, -0.61679149f, -0.31529436f, 0.12607740f, -0.64817011f, -0.45111185f, 0.45282373f, 
    1.16106403f, 0.83224499f, -0.26506460f, -0.02810612f, -0.18781361f, -0.57002163f, -0.22585851f, -0.04210652f, 
    0.55520517f, -0.05595061f, -0.74011058f, -0.34756303f, 0.01615730f, -0.17580505f, -0.09125867f, 0.56820375f, 
    -0.06294620f, -0.11696634f, -0.44436571f, 0.96852309f, -0.62659061f, -1.18936467f, -0.88293880f, 1.66287673f, 
    0.05334077f, 0.43060622f, 0.81081098f, 0.66216332f, 0.68024063f, -0.01769398f, 0.19729687f, 0.47181195f, 
    0.09249420f, 0.18730251f, 0.04353879f, 0.31132516f, 0.03028632f, 0.43661249f, 0.10624576f, 0.16367377f, 
    -0.13367188f, 0.05048976f, -0.00896756f, -2.28476644f, 1.33176899f, 0.13949239f, 0.39365920f, -0.38127834f, 
    0.16646448f, 0.74957037f, 0.31342697f, 0.49056518f, -0.54272807f, -0.52552271f, -0.21738151f, 0.26348928f, 
    0.04567057f, 0.10081142f, -0.29448968f, -0.28782669f, -0.09262727f, -0.15409653f, -0.25845268f, 0.28698868f, 
    0.18024679f, 0.29213437f, 0.09178501f, 0.00541682f, -0.85168040f, -0.58319396f, 0.00419482f, 1.34748781f, 
    0.81488955f, -0.76943159f, -0.66339016f, -0.61425328f, -0.00725867f, -0.73619586f, 0.46983510f, -0.02082793f, 
    -0.19797604f, 0.65357947f, 0.11756241f, -0.49985412f, -0.03740937f, 0.39045405f, -0.34632894f, 0.50962466f, 
    0.16917112f, 0.12100676f, -0.28307551f, 0.09184490f, 0.16647501f, -0.08148713f, -0.17497966f, 0.32318857f, 
    0.72795278f, 1.06740737f, 0.65424848f, 0.80703086f, -0.12283394f, -0.51893771f, 0.02447082f, 0.16899405f, 
    0.60019177f, 0.58437961f, 0.40372714f, 0.42533615f, 0.33146250f, 0.61803365f, 0.27586901f, 0.38140014f, 
    0.57229155f, -0.13281749f, -0.09251676f, -0.38819915f, -0.19647962f, 0.36428574f, 0.45300382f, 1.09975863f, 
    -0.36562568f, 0.16605620f, 0.12478324f, 0.63437825f, -1.17337120f, -1.77523422f, -0.95151848f, -0.42538133f, 
    0.44467470f, 0.44039941f, -0.15663242f, -0.04657312f, -0.63401169f, -0.12959491f, -0.08289342f, 0.34879196f, 
    -0.32790378f, -0.20516255f, 0.12876517f, 0.17040713f, 0.18595299f, 0.40773427f, -0.23920098f, -1.74884057f, 
    -0.29033387f, -1.21176457f, 0.41585550f, -0.12370631f, 0.20655854f, 1.48647666f, 0.03778376f, 0.63921404f, 
    0.50706071f, 0.44412208f, -0.30014643f, 0.12798940f, 0.09227518f, 0.42435205f, 0.21022584f, 0.06041305f, 
    -0.53394783f, 0.02009678f, -0.18270612f, 0.10989085f, 0.08178934f, 0.22781894f, -0.02510707f, 0.19807778f, 
    1.12078547f, 1.41687953f, 0.72989541f, 0.58938557f, 0.68032324f, 0.37399125f, -0.32023934f, 0.60304230f, 
    0.48576397f, 0.75502980f, -1.14117622f, 0.28563553f, -0.02795806f, -0.72489262f, -0.09980614f, -0.52394623f, 
    -0.18291752f, -0.33147904f, -0.29455429f, 0.03799199f, -0.27159894f, -0.17747024f, 0.15778159f, -0.30268332f, 
    0.00031808f, 0.88436592f, 1.77264166f, 1.58719182f, 0.45965230f, 0.62542564f, -1.18967044f, 0.61906725f, 
    -0.30079684f, -0.66540474f, -0.30005530f, -0.00783923f, 0.12894663f, 0.06464533f, 0.51361322f, 0.49404940f, 
    -0.03878484f, 0.10681791f, 0.11883626f, 0.19410834f, 0.01527878f, -0.14099920f, 0.00597016f, 0.24602623f, 
    0.26648834f, 0.16029260f, -0.52500987f, -1.80011833f, -0.40567026f, 0.80268288f, -0.65629929f, -1.09158278f, 
    0.57729453f, 0.69091308f, -1.09625506f, 0.06014874f, 0.54593128f, 0.51858145f, -0.15172066f, -0.23358485f, 
    0.19577646f, -0.30146882f, 0.00758591f, 0.33755797f, 0.03190719f, -0.52000594f, 0.11796832f, -0.47095823f, 
    0.04192505f, 0.28333250f, 0.17772225f, 0.02145428f, -0.95175260f, -0.65784538f, 0.45649305f, 1.27494407f, 
    0.63926101f, 1.39525473f, 0.85940647f, 1.00515759f, 0.47057605f, 0.03324927f, 0.20072706f, -0.34753364f, 
    0.12593974f, -0.35646594f, -0.18707597f, -0.25659883f, 0.23324785f, -0.18529627f, -0.06900240f, 0.11358237f, 
    -0.30503127f, -0.10561709f, -0.03725567f, -0.02960887f, -0.16962476f, -0.63847452f, -1.10760558f, -1.15794265f, 
    -0.53979200f, 0.21434349f, -0.26801810f, 0.83594978f, 0.88403738f, -0.02922405f, -0.88172472f, -0.35267267f, 
    -0.39306486f, -0.37024543f, -0.27403060f, -0.27304006f, -0.02934356f, 0.30652481f, 0.13452756f, 0.07021281f, 
    -0.42868409f, 0.19230703f, -0.65596950f, -0.00856490f, 0.09599696f, 2.00247359f, -0.12888414f, -0.24821822f, 
    1.48641944f, 1.10346186f, -0.06465432f, 0.30878022f, 0.15795256f, 0.38514337f, -0.20231842f, -0.58917391f, 
    0.23501694f, 0.03628355f, 0.04855191f, -0.03003409f, 0.01180070f, 0.09161562f, 0.21111907f, 0.21518081f, 
    0.06285985f, 0.39537254f, 0.61962003f, 0.25400585f, 0.14737830f, -0.09802541f, -1.06504703f, -0.79535878f, 
    -1.02952731f, -0.94922203f, -0.50437593f, -0.25203270f, -1.07482922f, -0.35090148f, -0.33794177f, 0.14839691f, 
    -0.46024612f, 0.08004471f, 0.64167160f, 0.23155560f, 0.08801742f, 0.56585300f, 0.10649558f, 0.19256708f, 
    0.33975485f, 0.02356358f, 0.20080478f, -0.01892783f, 0.30753836f, -0.08408105f, -0.37890124f, 0.10339265f, 
    -0.61900151f, -0.01945693f, -0.79700989f, 1.63531244f, 1.10874999f, -0.65061212f, -0.54369915f, -0.68680036f, 
    -0.35155782f, -0.02651459f, 0.51875740f, 0.06069748f, 0.15407982f, 0.22271845f, -0.12297562f, -0.06149578f, 
    0.09027720f, 0.37506574f, 0.36933666f, 0.05810809f, 0.23335974f, -0.10302357f, 0.12732483f, 0.03778928f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.45674971f, 0.12283795f, 0.24777526f, 0.12074366f, 0.46950996f, 0.46956593f, 0.47084671f, -0.03682761f, 
    0.45085073f, 0.27429140f, 0.24590090f, 0.31834909f, -0.02844866f, 0.32880256f, 0.32430381f, 0.46141085f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -1.01782870f, 0.29262578f, 0.22400658f, 0.11771542f, -0.20116562f, 0.05386835f, -0.01269368f, -0.29724401f, 
    -0.00796683f, -0.00994433f, 0.03943717f, -0.15293820f, -0.19248562f, 0.28368351f, -0.26111704f, -0.15101391f, 
    -0.21295424f, 0.26910713f, 0.16165590f, -0.12369909f, 0.12612347f, 0.04244322f, 0.14156570f, -0.29393286f, 
    0.58484751f, -0.25794157f, -0.34721446f, -0.33786306f, -0.03072345f, 0.17282149f, 0.22652332f, -0.27132642f, 
    -0.09052368f, 0.00619277f, 0.10730504f, 0.16483805f, 0.56694031f, 0.25101683f, 0.01025725f, 0.17185023f, 
    -0.10172427f, 0.05780192f, 0.02780940f, -0.05617327f, 0.12943096f, 0.05453301f, -0.00837633f, 0.01041807f, 
    -0.12512881f, -0.13649690f, -0.26450986f, 0.30254847f, -0.07756362f, -0.04827248f, -0.20608248f, -0.04064076f, 
    0.04870038f, -0.25100857f, -0.02823761f, 0.02676760f, -0.34274781f, -0.06287248f, -0.16757217f, -0.03868896f, 
    -0.17011458f, -0.05105902f, -0.00226180f, -0.04609945f, 0.04488322f, 0.09082794f, 0.02749140f, 0.07600271f, 
    0.06879357f, 0.09918857f, 0.45001918f, -0.04328131f, -0.21737219f, -0.16436392f, 0.05552218f, 0.00423827f, 
    -0.09752963f, 0.08551200f, -0.15405518f, -0.05956691f, 0.63252008f, 0.34048873f, 0.12550007f, -0.12075138f, 
    -0.03855014f, 0.30932021f, -0.16088337f, -0.02304411f, 0.04121355f, -0.06451375f, -0.19407453f, 0.05846182f, 
    0.08576050f, -0.18808529f, -0.02081258f, 0.20231958f, -0.35322446f, -0.02055630f, 0.00352242f, 0.13347019f, 
    -0.02453539f, -0.09730457f, -0.06329550f, -0.00225019f, 0.06003848f, 0.17667350f, -0.23762588f, -0.09832856f, 
    -0.46030229f, -0.31202939f, -0.00317957f, 0.17039996f, -0.07321511f, -0.03963874f, 0.03677627f, -0.31099680f, 
    -0.48739016f, -0.25822064f, -0.21036901f, 0.27525812f, 0.09353564f, -0.18245581f, -0.05063574f, -0.01104433f, 
    0.21726248f, 0.10637227f, -0.17116474f, 0.09405784f, -0.46732649f, 0.43742612f, 0.08837959f, 0.16507646f, 
    0.06629878f, 0.26959980f, -0.14851707f, -0.05380098f, -0.07012384f, 0.09632669f, -0.02252980f, -0.01713667f, 
    0.45694101f, 0.04720756f, -0.03089416f, -0.82481021f, -0.02537099f, 0.01846623f, 0.17228688f, 0.00105060f, 
    -0.11796734f, 0.03300825f, 0.10833126f, 0.07046441f, 0.30756783f, 0.04274139f, -0.19873239f, 0.70260245f, 
    -0.06648538f, 0.06555913f, -0.28735206f, 0.02143607f, -0.31331784f, 0.19948117f, 0.10304860f, -0.09165729f, 
    -0.46533507f, -0.39289469f, 0.13237233f, -0.07738049f, -0.07004815f, -0.12243521f, 0.13649146f, -0.02631755f, 
    -0.09028167f, 0.01216845f, -0.14569618f, 0.11498171f, -0.24778798f, -0.57792336f, 0.50278372f, -0.67029232f, 
    -0.02895224f, 0.20047639f, 0.13233067f, -0.23894681f, 0.06110033f, -0.08386386f, 0.09655179f, -0.09933915f, 
    -0.60265785f, -0.16444921f, -0.63765752f, -0.19850892f, -0.02010245f, -0.05330173f, 0.01289745f, 0.01675524f, 
    0.02652594f, -0.12370401f, -0.18608221f, -0.07741101f, 0.23360409f, -0.14730661f, -0.01367332f, -0.08949713f, 
    -0.32829028f, -0.30031767f, -0.16923127f, 0.00700256f, -0.03534221f, 0.06491368f, -0.13641544f, 0.19498390f, 
    -0.42445832f, -0.27139351f, 0.19390103f, -0.38439488f, -0.07631245f, -0.08536161f, 0.02395218f, 0.18690917f, 
    0.02187789f, 0.20942372f, 0.03778559f, -0.07375953f, -0.85174143f, 0.13569482f, -0.18833144f, -0.07690997f, 
    0.01351638f, 0.22378065f, 0.08154960f, -0.05714899f, 0.01584698f, -0.16607615f, 0.02701015f, -0.04532013f, 
    -0.63153261f, 0.10465961f, -0.39932701f, 0.06171161f, 0.37656125f, 0.05916346f, -0.06311632f, 0.07875877f, 
    -0.29881233f, -0.11114431f, 0.16288878f, -0.16031276f, 0.32444179f, -0.01780212f, -0.08157894f, -0.00669668f, 
    -0.18025336f, 0.23568285f, -0.16553289f, -0.06423151f, -0.00318751f, 0.03331508f, 0.23049967f, 0.06513964f, 
    -0.23325507f, -0.30238178f, -0.39064500f, -0.18117069f, 0.11471651f, -0.14515075f, 0.19085869f, 0.05602610f, 
    0.12816784f, -0.02545624f, 0.16885039f, -0.22131285f, 0.00716637f, 0.24600171f, -0.41095787f, -0.01470959f, 
    0.01144332f, 0.06837329f, -0.10463487f, -0.02755055f, 0.03155341f, 0.09140550f, -0.30140093f, -0.01800835f, 
    0.58963519f, 0.14327516f, 0.16015336f, 0.36883283f, -0.05950502f, -0.11749835f, 0.10600317f, 0.05037422f, 
    -0.06217817f, -0.16098118f, 0.09530117f, -0.34814662f, 0.16849566f, 0.34440103f, 0.09921435f, 0.17128971f, 
    0.12581538f, -0.00427478f, 0.19373387f, -0.06465714f, 0.13801572f, 0.07241931f, 0.00082579f, 0.10403494f, 
    -0.19711052f, -0.09626585f, -0.26009509f, 0.40908673f, -0.19189012f, -0.05182515f, -0.18127975f, -0.02613007f, 
    0.03411403f, -0.36465681f, 0.21488415f, 0.18427861f, 0.76031947f, -0.30664900f, -0.02057704f, 0.09601898f, 
    -0.04999773f, 0.09689496f, -0.15619692f, 0.26607421f, 0.09915640f, 0.05475572f, -0.05489665f, -0.04423786f, 
    0.03623020f, -0.07148570f, 0.03705948f, -0.45076230f, 0.17573686f, -0.02850503f, -0.21849267f, -0.10139660f, 
    0.11027244f, 0.03105595f, 0.07837334f, -0.02620213f, 0.47475955f, -0.23513156f, 0.07706109f, 0.51422656f, 
    -0.26943004f, -0.10486299f, -0.15794733f, -0.12196467f, 0.18159848f, 0.06752251f, -0.02871458f, 0.14625688f, 
    0.15438659f, 0.33696002f, 0.35027933f, -0.16450465f, -0.33500114f, -0.03390222f, 0.35118389f, 0.15037248f, 
    0.05922668f, 0.03631720f, 0.10288843f, 0.11053055f, 0.52224910f, -0.07049859f, -0.03124297f, -0.53537959f, 
    -0.05588888f, -0.12555701f, -0.08327462f, 0.14718013f, -0.14018725f, 0.04588665f, -0.08134890f, 0.05231706f, 
    -0.77125925f, 0.09334590f, -0.34656906f, -0.64659387f, -0.13471751f, 0.12998539f, -0.00170972f, 0.08864929f, 
    -0.05899445f, -0.15566814f, -0.06490161f, -0.05022655f, 0.03547407f, 0.12464793f, -0.02063634f, 0.30939960f, 
    -0.30423027f, -0.02180140f, 0.02751195f, 0.26331660f, 0.01126829f, -0.01332021f, 0.14570142f, -0.02027416f, 
    0.43373621f, 0.42018405f, 0.19535165f, 0.21332625f, -0.06802280f, -0.15373391f, 0.04817022f, -0.02008669f, 
    -0.04697591f, -0.14748017f, -0.06356464f, -0.15421025f, 0.27723581f, 0.15625980f, -0.62765622f, -0.33576474f, 
    -0.06141307f, 0.19715534f, -0.01796829f, -0.03809720f, -0.06538541f, -0.10757634f, -0.12150589f, 0.15937196f, 
    0.25814727f, 0.05521268f, -0.41533238f, 0.18823767f, -0.04258202f, 0.11609153f, -0.12141076f, -0.05490718f, 
    -0.19098678f, 0.01939982f, -0.11859939f, -0.03149368f, 0.43550268f, -0.34613895f, 0.16539612f, -0.00219389f, 
    -0.14060992f, 0.05563961f, 0.04143471f, -0.22475521f, -0.12206189f, -0.02917732f, -0.09316326f, 0.05068327f, 
    -0.32393709f, -0.19633611f, -0.15073821f, -0.53031635f, 0.18066593f, 0.06084028f, -0.07576629f, 0.00320081f, 
    -0.12216846f, -0.01871425f, -0.14441612f, -0.29497564f, 0.63054115f, -0.06307399f, 0.20232590f, -0.02961562f, 
    -0.05913753f, -0.04373559f, -0.19760473f, 0.01993521f, 0.13537440f, 0.06278997f, 0.07745250f, -0.13530172f, 
    0.08811828f, -0.11139791f, -0.14948833f, -0.05813292f, 0.01169448f, 0.17422564f, 0.14710151f, -0.05879911f, 
    -0.02578784f, 0.29300076f, 0.06263247f, 0.21549603f, 0.10031824f, 0.13992558f, -0.43994796f, 0.14881155f, 
    0.12589155f, 0.06624651f, -0.05936791f, -0.15993103f, -0.08901098f, -0.02720239f, 0.06257685f, -0.06967792f, 
    1.38179040f, -0.32170311f, -0.27327555f, -0.07427401f, -0.35112295f, 0.15110569f, -0.05107665f, 0.05353126f, 
    0.03605711f, -0.02059124f, 0.19095978f, -0.27008671f, 0.05972423f, -0.12377560f, 0.12513024f, 0.18710589f, 
    -0.12524816f, -0.02030509f, 0.10483545f, -0.03449221f, 0.07229846f, 0.01929449f, 0.01099707f, 0.17962496f, 
    -0.14914554f, 0.43745989f, -0.01659020f, 0.42187080f, -0.10739393f, -0.00449015f, 0.14517021f, 0.07234605f, 
    -0.14863370f, -0.01717657f, -0.17570220f, 0.16451213f, -0.20294599f, 0.18310134f, -0.02635518f, -0.27789679f, 
    0.12083959f, -0.02921360f, -0.03318924f, 0.12699032f, -0.05834670f, 0.08103997f, -0.03325563f, -0.03761124f, 
    -0.71120399f, -0.41258448f, -0.17234826f, -0.36719394f, -0.21971653f, -0.02310362f, -0.23112635f, 0.03198562f, 
    0.11998869f, 0.14749314f, -0.32346568f, 0.23501892f, -0.63467526f, -0.37318254f, 0.33822912f, -0.25808868f, 
    -0.06979735f, 0.08031686f, -0.10209670f, -0.14024964f, -0.24979432f, -0.03610479f, -0.13263302f, -0.10318828f, 
    0.17025207f, 0.40241212f, 0.22311117f, -0.12201636f, -0.02809033f, 0.07238527f, 0.15927216f, 0.01503263f, 
    -0.06470172f, 0.08931864f, 0.03147286f, -0.05301997f, 0.10068407f, -0.41287559f, 0.02641245f, 0.09507807f, 
    0.07006266f, -0.13155133f, -0.15389030f, -0.07352632f, -0.14393093f, -0.01602227f, 0.04441650f, -0.20396258f, 
    -0.18708824f, 0.36759263f, -0.07331885f, -0.49327764f, -0.01162777f, -0.09676853f, -0.00289948f, -0.10061807f, 
    -0.06530982f, -0.30307376f, -0.11939666f, -0.14050597f, -0.16094084f, 0.76616466f, -0.10880603f, -0.33675733f, 
    -0.05612882f, 0.12348984f, 0.10329571f, 0.25334203f, 0.05300348f, -0.01532935f, 0.03180376f, 0.02989441f, 
    -0.09952610f, 0.20402294f, 0.15751055f, 0.40866289f, 0.11395205f, 0.00553315f, 0.27250370f, -0.06378307f, 
    -0.00620448f, 0.04630575f, 0.05677973f, -0.21833462f, -0.71479470f, -0.33533010f, 0.22695129f, 0.12891728f, 
    0.03931091f, -0.03561223f, 0.10376046f, -0.02564932f, -0.09605157f, -0.12533614f, -0.10786745f, 0.19424503f, 
    0.66670042f, 0.25441086f, -0.22537015f, 0.44206870f, 0.17673269f, 0.06045806f, -0.16857573f, 0.12626036f, 
    -0.11539395f, -0.04497326f, -0.09223226f, -0.12998131f, -0.40802047f, 0.70013267f, -0.17096755f, -0.17839754f, 
    -0.08599625f, -0.00010227f, 0.05267584f, -0.03098089f, 0.28564632f, -0.15974522f, -0.08964737f, -0.11841585f, 
    -0.34671235f, -0.91188318f, -0.81484920f, 0.38378611f, -0.13097727f, -0.13380453f, 0.13078141f, -0.00111711f, 
    0.15567307f, 0.06701337f, -0.11719070f, 0.31112155f, -1.25802040f, -0.54864967f, 0.16984831f, 0.14374870f, 
    -0.12646835f, 0.10526618f, 0.14594205f, -0.00428687f, -0.08965755f, -0.07770102f, -0.02460386f, -0.12474544f, 
    0.04152217f, -0.03208875f, 0.37518746f, -0.15098710f, 0.07570659f, -0.06031774f, 0.05578396f, -0.03091749f, 
    -0.00894180f, 0.09852342f, -0.06524342f, 0.04882266f, -0.28504869f, 0.14058581f, -0.17214613f, -0.23203163f, 
    -0.19289337f, -0.02259473f, 0.06135019f, -0.40962318f, -0.00685065f, 0.26668820f, 0.04962539f, -0.05607137f, 
    -0.18398361f, -0.15716557f, 0.02699803f, -0.07144640f, -0.29938516f, -0.09487534f, 0.21486591f, 0.07161184f, 
    -0.12810923f, -0.05531658f, -0.19998601f, 0.20898952f, -0.18017665f, -0.27655092f, -0.02053925f, -0.27091408f, 
    0.16679794f, 0.01254596f, -0.01671259f, 0.06461571f, 0.06565630f, -0.01180595f, 0.05830137f, 0.01417457f, 
    0.18808359f, 0.09900080f, -0.10724774f, -0.03771659f, -0.11464637f, 0.15520792f, -0.01410895f, 0.04506045f, 
    0.09802268f, 0.04694561f, -0.06916022f, 0.11245966f, 0.18008281f, 0.01647365f, -0.14087224f, 0.23847899f, 
    -0.12142960f, 0.16286080f, 0.04541481f, -0.10895967f, 0.04398820f, -0.33167464f, 0.04984830f, 0.02958694f, 
    0.57812953f, -0.41550359f, 0.09797270f, -0.60134780f, -0.06102020f, 0.23062803f, -0.02798904f, -0.03757387f, 
    -0.03772207f, 0.21196434f, 0.28194049f, -0.05442787f, -0.31920826f, -0.00630665f, -0.02417983f, 0.20011890f, 
    -0.03231294f, 0.08712696f, -0.11970703f, -0.02304791f, -0.03738441f, 0.09868430f, 0.00976159f, 0.18642791f, 
    0.24515319f, 0.12467261f, -0.09193026f, 0.30841658f, 0.19467667f, -0.00417842f, -0.16813433f, 0.06895963f, 
    0.05176019f, -0.07271042f, -0.03497687f, 0.00511923f, 0.22760864f, 0.32130000f, -0.16110691f, -0.37593344f, 
    0.16031422f, 0.07538418f, 0.25352696f, 0.11284828f, -0.04285490f, -0.04469820f, -0.19411807f, -0.15177600f, 
    -0.26715681f, 0.07015909f, 0.12670396f, -0.08251916f, 0.06069331f, 0.01485563f, -0.23545651f, -0.14872651f, 
    0.24404915f, -0.14130321f, -0.26165807f, 0.00401080f, -0.45478541f, -0.02793704f, 0.13521485f, -0.33305365f, 
    0.00545871f, -0.28046897f, 0.13949479f, 0.08975893f, 0.03663164f, -0.05538908f, -0.07707994f, -0.19802384f, 
    -0.39559782f, 0.01611772f, 0.46045008f, -0.09257042f, -0.23269750f, 0.21182251f, -0.10406288f, 0.04813942f, 
    -0.15574788f, -0.16724968f, -0.00624222f, 0.20966882f, -0.42261758f, -0.08621818f, 0.03300797f, -0.03586815f, 
    -0.00120836f, 0.12895119f, 0.03595377f, -0.06650091f, 0.06227884f, -0.26991391f, 0.26427293f, -0.03556855f, 
    0.13279521f, -0.43442580f, 0.10125498f, 0.02779224f, -0.06074250f, -0.02705772f, 0.16151315f, 0.19220205f, 
    -0.07668757f, 0.01023672f, 0.22276393f, 0.14011879f, -0.62319320f, 0.14792868f, 0.38148937f, 0.23539272f, 
    -0.10098015f, -0.17726567f, -0.03369710f, -0.02242233f, 0.02767018f, 0.06757735f, -0.04393232f, -0.13377121f, 
    -0.86054081f, 0.01778484f, -0.16771391f, -0.17251867f, 0.02654106f, 0.05729695f, 0.02835231f, 0.17233606f, 
    -0.11466249f, 0.06689344f, -0.09417356f, -0.09219772f, -0.48213029f, -0.18908562f, -0.28165397f, 0.10863813f, 
    -0.01310856f, -0.24472421f, 0.23939009f, -0.05000802f, -0.02136279f, -0.11794192f, 0.14384232f, 0.09386156f, 
    -0.54678118f, -0.32215181f, 0.05701755f, 0.41858736f, -0.07362565f, -0.01710364f, 0.18667608f, 0.09243945f, 
    -0.00527854f, 0.14073443f, 0.18197943f, 0.03109778f, 0.56368470f, 0.15857942f, -0.03179535f, -0.07424196f, 
    -0.12115058f, 0.02392218f, 0.04270560f, 0.01833578f, 0.02543442f, -0.03501412f, -0.14742842f, 0.04371427f, 
    0.52858377f, -0.11112317f, 0.03888730f, 0.33896521f, 0.12306897f, 0.13009381f, 0.01382543f, 0.19779707f, 
    0.25301298f, -0.03476641f, 0.05576697f, -0.12219184f, -0.49411964f, -0.11037965f, -0.18710136f, -0.06509813f, 
    0.08302664f, -0.17887017f, 0.05093290f, -0.02032269f, 0.12814450f, -0.18985130f, -0.07111378f, -0.00736799f, 
    -0.44149223f, -0.00598993f, 0.02136962f, 0.31205437f, -0.12450900f, -0.21384381f, -0.11771595f, 0.18067454f, 
    0.05236372f, -0.07971614f, -0.07719236f, 0.01147188f, 0.03881684f, -0.12620829f, -0.36657372f, 0.08941130f, 
    0.27654707f, 0.05877894f, 0.29517898f, -0.19904579f, 0.00424956f, 0.10796061f, -0.44019711f, -0.02228581f, 
    -0.14364928f, -0.04904614f, -0.27410629f, -0.23168366f, 0.24016693f, -0.04059580f, -0.17663892f, -0.26343310f, 
    0.16205493f, -0.01436830f, 0.03889175f, 0.02666192f, -0.74202234f, -0.23660716f, 0.46840298f, 0.42244217f, 
    -0.11170892f, -0.02661368f, 0.01092376f, -0.03263542f, 0.02762488f, 0.01511884f, 0.18440743f, -0.18636961f, 
    0.16094802f, -0.25718689f, -0.08415414f, -0.19158788f, -0.10277433f, -0.13798000f, 0.00038292f, -0.06497429f, 
    -0.12486426f, 0.22138545f, 0.27126694f, 0.37392759f, -0.28487411f, 0.11864948f, 0.26306075f, 0.04658777f, 
    0.21444255f, 0.14861201f, 0.01433706f, 0.20382018f, -0.05125080f, 0.11080321f, 0.13900582f, 0.13774094f, 
    0.00609432f, -0.00767227f, 0.11826696f, 0.34160894f, -0.16131088f, -0.10976351f, 0.06670701f, -0.04727905f, 
    0.02629482f, -0.01630137f, -0.05341091f, 0.11682976f, -1.07684946f, -0.14385363f, -0.15338883f, -0.31939498f, 
    -0.02057089f, 0.02993117f, 0.23647861f, -0.07768062f, -0.02715897f, 0.02071888f, 0.09067366f, 0.12875338f, 
    0.26748216f, 0.16382001f, 0.28436139f, -0.18509977f, 0.03983758f, 0.01531661f, -0.04233713f, -0.16097006f, 
    -0.13041614f, 0.01134058f, -0.17984551f, -0.37510875f, 0.29662535f, -0.13002390f, 0.05662578f, 0.20622982f, 
    -0.04976100f, 0.15073785f, 0.10256895f, 0.03367560f, -0.05543189f, 0.05719099f, 0.14195162f, 0.14843062f, 
    -0.41366768f, 0.19017099f, -0.15911433f, -0.16784626f, 0.09565932f, -0.02210403f, 0.05398409f, 0.29432642f, 
    0.08157123f, -0.32108423f, 0.08193765f, -0.04956609f, -0.16012478f, 0.54990906f, 0.10882916f, -0.45482713f, 
    0.25909507f, -0.16629465f, -0.25965449f, -0.13524878f, 0.12098813f, -0.14809395f, -0.13089877f, -0.09255730f, 
    0.18772867f, -0.34750587f, -0.23917840f, 0.05318965f, 0.11668404f, 0.23578423f, -0.25820187f, -0.08796310f, 
    -0.08375265f, -0.30801797f, -0.17163044f, -0.06976262f, -0.20605506f, -0.06466714f, 0.13515995f, -0.30517742f, 
    -0.09713905f, -0.13628030f, -0.00328868f, 0.02688699f, 0.20228262f, 0.00219721f, 0.20070605f, 0.02252744f, 
    -0.48405921f, -0.41704857f, -0.01851060f, 0.07540048f, 0.32735533f, 0.16393551f, -0.30522189f, 0.00523070f, 
    -0.02978314f, -0.00634386f, 0.32146171f, 0.01330529f, -0.16686243f, 0.01812130f, 0.17320161f, 0.05965773f, 
    0.03694849f, 0.06428209f, -0.14239003f, 0.08079429f, -0.02251284f, 0.19660297f, 0.16424958f, 0.20020293f, 
    -0.50706232f, -0.44153664f, -0.15792018f, 0.58908671f, 0.09977621f, -0.03062644f, -0.14192036f, -0.18053260f, 
    -0.02878313f, 0.02282393f, 0.01562061f, 0.01879231f, -0.07485903f, -0.31252301f, 0.21753061f, -0.00227817f, 
    0.10256489f, -0.00011892f, -0.13073230f, 0.09894978f, 0.11882305f, -0.07400871f, 0.41774556f, 0.08689699f, 
    -0.09322194f, -0.30255741f, -0.38108072f, 0.48419321f, -0.28512925f, 0.22982554f, -0.03839276f, 0.05651286f, 
    -0.01637041f, 0.10001088f, 0.09918109f, -0.08472907f, 0.74146080f, -0.32461503f, 0.39792421f, 0.27357164f, 
    0.10436836f, -0.26794881f, -0.10461505f, -0.01068486f, -0.20223725f, 0.03837326f, -0.10858158f, 0.00017909f, 
    0.42161620f, 0.24202749f, -0.19474888f, -0.18133491f, 0.14343402f, 0.36212987f, -0.06627888f, -0.09899425f, 
    0.11510671f, -0.10873811f, -0.09697464f, -0.19246545f, 0.09520906f, 0.01599317f, -0.07794826f, -0.03541535f, 
    -0.13763079f, -0.04388341f, -0.06074354f, -0.19138394f, 0.23223549f, -0.38589704f, -0.23511605f, -0.40173468f, 
    0.18359835f, -0.08268567f, -0.56342947f, 0.16951595f, -0.06787153f, 0.10661031f, 0.01693405f, 0.06680643f, 
    0.01560781f, -0.01714141f, -0.00443259f, 0.09491047f, -0.08374570f, -0.56016397f, 0.21214555f, 0.36827952f, 
    -0.00377944f, 0.01887909f, 0.21630810f, -0.10176720f, -0.12855750f, -0.06161004f, 0.05651090f, 0.08810300f, 
    -0.87860316f, 0.65822649f, 0.09342268f, -0.05796926f, -0.33887193f, -0.05664882f, -0.00391409f, 0.32322472f, 
    0.10468925f, 0.17512901f, 0.14250021f, 0.24073328f, -0.06012907f, 0.49676779f, 0.36570382f, -0.19942690f, 
    0.18891260f, -0.09481642f, -0.16485108f, 0.11781374f, -0.12361990f, -0.02927095f, -0.20023492f, 0.05433970f, 
    0.30359012f, -0.15510464f, 0.06243102f, -0.39589199f, -0.10418225f, -0.01253496f, 0.16882132f, -0.07068173f, 
    0.15144248f, 0.27200681f, 0.00018706f, -0.13891663f, -0.00992606f, -0.78481877f, 0.30747536f, -0.32219648f, 
    -0.05763154f, 0.09124880f, 0.03082635f, 0.39006424f, -0.01563327f, 0.10619718f, 0.16766496f, 0.09596580f, 
    -0.57421052f, -0.15375589f, -0.40314263f, -0.33129707f, -0.04893291f, -0.13929091f, 0.24259287f, -0.08794687f, 
    0.27789614f, -0.00621711f, 0.20990543f, 0.12474772f, 0.11408189f, 0.05636046f, 0.26111361f, -0.53345788f, 
    -0.05690020f, 0.13253275f, 0.17411014f, -0.02858539f, -0.17953575f, -0.00649734f, -0.09578992f, -0.16297404f, 
    -0.42806637f, 0.04862801f, -0.25908026f, -0.31280577f, -0.08342941f, -0.21621025f, -0.17617963f, -0.14399882f, 
    -0.10925142f, -0.12384813f, -0.02939184f, -0.02422022f, 0.10789087f, -0.00417126f, -0.13548961f, -0.03871747f, 
    -0.05775686f, 0.06396715f, -0.04305794f, -0.01800955f, 0.06688067f, -0.05680773f, -0.08557593f, -0.10241792f, 
    0.31451821f, -0.15664147f, 0.19509119f, 0.34576410f, 0.18680899f, 0.03232243f, 0.13555944f, -0.11428604f, 
    0.04082806f, -0.35012755f, -0.00467283f, -0.31123444f, 0.17494932f, 0.10914974f, 0.06812364f, -0.01642772f, 
    -0.11454868f, 0.28341693f, -0.05675245f, 0.07459022f, 0.16117717f, -0.10408460f, 0.03273563f, -0.19096886f, 
    -0.30888522f, 0.40368623f, -0.23155107f, 0.16849205f, 0.11243438f, -0.12610412f, -0.04210623f, 0.01233684f, 
    0.08665384f, -0.04654258f, 0.10421617f, -0.11561346f, -0.07064223f, -0.38644147f, 0.08700074f, -0.06560589f, 
    0.18144494f, -0.03409896f, -0.05926075f, -0.30461019f, -0.10198212f, 0.18019804f, 0.03508845f, -0.05152935f, 
    0.02693895f, -0.34799394f, 0.22912663f, -0.06906509f, 0.05800455f, -0.05650951f, -0.10251570f, -0.05966133f, 
    -0.05215800f, 0.11134543f, -0.09937105f, 0.04989714f, -0.19436534f, 0.06314778f, 0.24946433f, -0.13258411f, 
    0.00916854f, -0.03482187f, 0.12815441f, -0.07664845f, 0.06375485f, 0.04264655f, -0.08625724f, -0.21344791f, 
    -0.49029174f, 0.02867843f, -0.19738416f, 0.19944246f, -0.16389139f, -0.30326340f, -0.24165119f, -0.16083339f, 
    -0.24594504f, 0.21415062f, -0.01308989f, -0.08410526f, -0.38144302f, -0.14024828f, 0.19765815f, -0.13362588f, 
    0.17764051f, -0.07443014f, 0.09208116f, 0.27986673f, -0.11338925f, -0.13770141f, 0.17408499f, -0.09125374f, 
    0.05760344f, 0.05509078f, -0.27611831f, -0.47986996f, -0.09689444f, 0.01059162f, -0.17490180f, -0.07850990f, 
    -0.12118993f, 0.01093430f, 0.00813335f, 0.02136445f, 0.09550925f, -0.80749059f, -0.12261061f, -0.08267235f, 
    0.01686457f, 0.02945477f, -0.04468887f, -0.00314723f, -0.02230920f, -0.06166876f, 0.02073633f, -0.08103330f, 
    0.64035928f, 0.09021988f, 0.50219548f, -0.01305873f, -0.09011970f, 0.02584262f, -0.00649440f, -0.05736604f, 
    0.01851438f, 0.28820738f, -0.20074563f, -0.09448792f, -0.16389716f, -0.11147881f, 0.12581143f, -0.07829505f, 
    -0.20367160f, -0.04051331f, -0.14919265f, -0.31781077f, -0.23468159f, -0.00253977f, 0.03040581f, -0.25567073f, 
    0.40128562f, 0.35691968f, 0.18031517f, 0.43996552f, 0.10677134f, 0.13195634f, 0.18117160f, 0.08702054f, 
    -0.06280532f, 0.11560885f, -0.08384986f, -0.08023936f, -0.22844635f, 0.24239387f, -0.18557088f, -0.05184854f, 
    -0.10527864f, 0.07828582f, -0.11221588f, -0.08739515f, -0.12856205f, -0.15703815f, -0.03207671f, -0.39663419f, 
    0.17359124f, 0.23376335f, 0.24364381f, 0.42238453f, 0.11560571f, -0.02741961f, -0.17973632f, -0.11530873f, 
    0.06327171f, -0.24190724f, -0.16620275f, -0.01798201f, -0.20853858f, 0.16565661f, -0.31985733f, 0.25570136f, 
    -0.12368339f, -0.04747503f, -0.09281089f, -0.00765992f, -0.22660838f, -0.03852146f, -0.02926261f, -0.14265281f, 
    0.74999231f, -0.11163750f, -0.09255620f, -0.53078896f, 0.14920151f, -0.08378146f, 0.04279511f, 0.15706387f, 
    0.11732240f, -0.15818386f, -0.15985084f, 0.26668346f, -0.09374666f, -0.18677253f, 0.08303209f, -0.00227238f, 
    0.19070983f, -0.17133155f, 0.16260399f, 0.06384113f, -0.13518234f, -0.11314687f, -0.45379430f, 0.25507975f, 
    0.05886350f, 0.43029764f, 0.10115598f, 0.14148512f, -0.04946589f, -0.11961840f, -0.04093164f, 0.13615508f, 
    -0.11741946f, -0.09307766f, 0.00563982f, 0.26282021f, -0.08635496f, -0.24733664f, -0.12443772f, -0.00140800f, 
    0.03675283f, -0.06229647f, -0.27822092f, -0.17412665f, 0.14570168f, 0.07369345f, 0.11944733f, -0.46497065f, 
    -0.52208853f, -0.73009795f, 0.08407077f, -0.20415336f, -0.09077013f, -0.00449796f, -0.07415483f, 0.03822960f, 
    0.12061596f, 0.07928046f, -0.09203488f, 0.12753786f, 0.17905638f, -0.14322786f, -0.26133788f, 0.15556191f, 
    0.00886493f, -0.04915439f, -0.04378013f, -0.19088136f, -0.12644742f, -0.11976232f, 0.07192764f, 0.27541813f, 
    -0.16507965f, 0.00627889f, -0.65960318f, -0.25364280f, 0.14033711f, -0.02234000f, 0.04236186f, 0.10594002f, 
    0.24577715f, 0.05496747f, -0.00613505f, 0.05521922f, 0.05593771f, -0.12031618f, 0.19424959f, 0.35192296f, 
    0.01799943f, 0.00508994f, -0.23421739f, -0.34821200f, 0.06328861f, -0.05543618f, -0.04965788f, 0.12931268f, 
    0.21634071f, -0.10257211f, 0.04221687f, 0.20489286f, 0.26504326f, -0.08037572f, -0.39547226f, -0.29094788f, 
    -0.00925125f, 0.03872956f, -0.12773168f, -0.17545933f, 0.09838462f, -0.39839977f, -0.16022879f, 0.34553996f, 
    0.12006880f, 0.04478732f, -0.03091524f, -0.17883334f, 0.08409147f, 0.22810543f, 0.08926358f, 0.17381059f, 
    -0.20834634f, -0.30216989f, 0.12266862f, -0.43874222f, -0.11522571f, -0.08482413f, 0.07135019f, -0.23114583f, 
    -0.07808109f, 0.04744074f, 0.06231173f, 0.22848326f, 0.28739899f, 0.05049724f, 0.11699376f, 0.28083676f, 
    -0.29105973f, -0.14158666f, 0.00325882f, -0.21139127f, -0.09501240f, 0.01808602f, -0.17472528f, -0.04432087f, 
    -0.48781523f, 0.30249605f, 0.16948387f, -0.27677152f, -0.18579529f, 0.23172987f, -0.28533879f, 0.05272119f, 
    0.05035402f, -0.04162776f, -0.24012424f, -0.58443373f, 0.25340173f, -0.15463951f, 0.35607964f, 0.29541016f, 
    0.05060321f, -0.13412188f, 0.00851188f, 0.11011688f, 0.27357349f, -0.03375403f, 0.04294581f, -0.09564501f, 
    -0.50731349f, 0.08031604f, 0.13561669f, -0.43215296f, 0.20666769f, -0.35069516f, 0.04545246f, -0.20687836f, 
    0.04169385f, -0.04384971f, 0.22188815f, -0.33238661f, -0.51524282f, 0.02411092f, -0.02223374f, 0.17665084f, 
    -0.33048803f, -0.15893281f, -0.18639961f, -0.01874953f, 0.20690686f, 0.10782219f, 0.11947593f, 0.14065415f, 
    0.56096512f, -0.00857545f, 0.29278883f, 0.16728480f, 0.04027912f, -0.21976729f, 0.05218621f, -0.11484367f, 
    -0.19882888f, 0.05234047f, 0.05414783f, 0.15423316f, 0.33263290f, 0.41156560f, 0.01873706f, 0.00439466f, 
    0.07530898f, -0.02184339f, -0.01518319f, 0.06632743f, 0.01514413f, -0.13225883f, 0.19812377f, -0.05964587f, 
    -0.70609802f, -0.35718462f, 0.63320237f, -0.19567710f, 0.06285042f, 0.05784832f, 0.20819691f, 0.10150415f, 
    0.02309942f, -0.21932414f, -0.03244773f, -0.19963379f, 0.73392761f, -0.47202939f, -0.30452847f, 0.33382627f, 
    -0.05852691f, -0.11865662f, 0.21354264f, 0.05602090f, -0.07939326f, -0.03868777f, 0.10131948f, 0.39273256f, 
    -0.00967631f, 0.03941597f, 0.04322914f, 0.01373598f, -0.50441635f, -0.14843988f, 0.16895625f, -0.07551344f, 
    0.15129685f, 0.07955174f, -0.10760637f, 0.03312194f, 0.31237698f, 0.63894397f, -0.41709408f, -0.11788252f, 
    0.15899400f, -0.00902888f, -0.01997656f, 0.01869608f, 0.10688050f, -0.01138445f, -0.38923800f, -0.17657074f, 
    -0.37297881f, 0.32131472f, 0.11743127f, -0.68362379f, 0.01069071f, 0.01491328f, -0.15008476f, -0.05054604f, 
    -0.10901619f, 0.07236701f, 0.02311813f, -0.29066244f, 0.10003732f, -0.27440342f, -0.16025838f, 0.11006282f, 
    -0.02185586f, -0.10517207f, -0.08002638f, -0.01998994f, 0.04668769f, 0.29081944f, -0.03317453f, -0.02879160f, 
    -0.00369054f, 0.23955582f, 0.09986018f, -0.13606252f, -0.03122879f, 0.10533921f, 0.06679352f, -0.12587151f, 
    0.07395737f, 0.16171545f, -0.00369267f, 0.10806373f, 0.25332105f, -0.60968602f, 0.09062888f, -0.50881147f, 
    0.04763240f, 0.16508274f, -0.10060289f, -0.05062002f, -0.04531354f, -0.18123542f, -0.06272062f, -0.07031754f, 
    -0.15575697f, -0.18884635f, -0.10275021f, 0.33341727f, 0.10160716f, -0.02811124f, -0.11913396f, -0.15761717f, 
    -0.11217710f, 0.07068025f, 0.21286479f, -0.09715962f, -0.15097156f, 0.34443742f, -0.16138704f, 0.09721072f, 
    0.26606423f, 0.14036939f, 0.05525620f, -0.08064505f, -0.22152621f, 0.03684742f, 0.22724412f, 0.04715337f, 
    -0.10661166f, -0.02278683f, 0.07532672f, -0.01652528f, -0.09186409f, -0.22550240f, 0.01139157f, 0.23121230f, 
    -0.14015357f, -0.09006679f, -0.01257210f, 0.12644093f, -0.67258441f, 0.47861010f, -0.52927768f, -0.46756575f, 
    0.20030844f, -0.07913285f, 0.20229907f, -0.19154862f, -0.12647536f, -0.05539169f, 0.06781110f, 0.06524867f, 
    -0.19754231f, -0.77418226f, -0.24475949f, 0.15924989f, 0.06088848f, 0.00988175f, 0.03313483f, -0.05484288f, 
    -0.06519563f, -0.01006205f, -0.38026744f, 0.12593125f, 0.16531347f, 0.31509647f, -0.64564699f, -0.17763948f, 
    0.20608421f, 0.03827089f, 0.03153202f, -0.01123026f, 0.04410703f, 0.11620355f, 0.13007312f, -0.18444793f, 
    -0.43305409f, 0.10347291f, 0.00548565f, 0.13098837f, 0.24777411f, 0.05086968f, 0.11333096f, 0.02544233f, 
    0.09872944f, -0.05382477f, -0.15793884f, 0.07957432f, 0.10818653f, -0.22722727f, 0.19488022f, -0.41439119f, 
    0.00958686f, 0.18934099f, 0.04246840f, -0.36151999f, -0.05868534f, -0.01258807f, -0.24929009f, 0.09744466f, 
    0.27403235f, -0.16402699f, -0.08477748f, -0.05010740f, -0.13568811f, -0.12245896f, 0.11532997f, 0.03713069f, 
    -0.01019357f, 0.22540000f, 0.12695873f, 0.21179985f, -0.24845460f, -0.47437724f, -0.33955258f, -0.13277631f, 
    -0.05963220f, 0.01631609f, -0.29890931f, 0.03975661f, 0.28062302f, 0.12757473f, 0.01555512f, -0.27005830f, 
    0.77885211f, 0.31418586f, -0.13843596f, 0.03702971f, 0.03143496f, 0.05732562f, -0.00660239f, 0.35419038f, 
    -0.02768754f, 0.10171372f, 0.22262146f, 0.22594878f, -0.18023649f, 0.13973856f, -0.13801233f, 0.07583978f, 
    -0.22096965f, 0.13154441f, -0.05084655f, 0.26226401f, 0.08898454f, 0.11894576f, 0.39884543f, 0.10129888f, 
    -0.07739399f, -0.02199869f, 0.14103007f, -0.05455116f, 0.13031223f, 0.04491127f, 0.12778346f, 0.08428878f, 
    0.20281243f, -0.00664310f, 0.09635532f, 0.05192728f, 0.31709588f, -0.19755167f, -0.00241226f, 0.11656370f, 
    -0.37210420f, -0.22155465f, -0.10031056f, 0.40359190f, -0.05587571f, 0.18739542f, -0.20883837f, 0.16295031f, 
    -0.91782600f, -0.39240500f, -0.31456289f, -0.53426188f, 0.15809432f, 0.10671415f, -0.25964248f, -0.14417894f, 
    -0.06618492f, -0.30780825f, -0.11165775f, -0.22036709f, -1.54111469f, 0.03522582f, -0.19729146f, -0.55406988f, 
    0.09491031f, -0.06522386f, -0.19348991f, 0.01186988f, 0.06469118f, 0.17234378f, 0.04547852f, 0.12612587f, 
    0.17508695f, 0.03076711f, -0.17428502f, 0.04428789f, -0.00168418f, 0.33975860f, -0.13386971f, -0.05700649f, 
    0.03658983f, -0.03387055f, -0.24888517f, 0.14343350f, 0.61650145f, -0.14063644f, -0.29502025f, -0.03587751f, 
    0.05829390f, -0.15799740f, -0.13750783f, 0.14175831f, -0.15983553f, -0.22702889f, -0.17473479f, -0.03562329f, 
    0.34052613f, -0.05555395f, -0.01837012f, -0.19008708f, -0.04923543f, 0.16758303f, -0.09262162f, -0.27036256f, 
    0.09546404f, -0.09383422f, -0.16390921f, -0.47302210f, -1.02861178f, -0.73627406f, -0.21996062f, -0.23051548f, 
    -0.16132531f, -0.15930422f, 0.12402575f, -0.01425938f, 0.18600282f, 0.33321515f, 0.12809917f, 0.13784832f, 
    0.30229846f, 0.16603878f, -0.31868926f, -0.12722529f, -0.06791195f, 0.21309045f, 0.23027301f, -0.15046495f, 
    -0.34489381f, 0.11838705f, 0.10691763f, -0.00393152f, 0.40355036f, 0.19732989f, 0.18963638f, -0.21833616f, 
    0.09174826f, 0.05394621f, 0.20168822f, 0.23244058f, 0.14103958f, 0.02770857f, 0.23690288f, 0.06080261f, 
    0.11421392f, 0.18854444f, 0.11107361f, 0.00316951f, -0.01907950f, 0.04670307f, -0.16808073f, 0.11493669f, 
    0.24277464f, -0.02117267f, 0.00900770f, -0.11642622f, -0.43275645f, 0.35934538f, 0.07559863f, -0.14326455f, 
    0.15258507f, -0.21277168f, -0.18431142f, 0.35741985f, 0.10164358f, -0.04822939f, 0.21074805f, -0.22959469f, 
    -0.07979509f, -0.56061673f, -0.11290444f, 0.13965131f, -0.00420707f, 0.07954188f, -0.19527534f, 0.09414897f, 
    -0.17714374f, -0.04342917f, -0.25868636f, -0.00883732f, -1.02131641f, 0.05898310f, 0.06325693f, -0.29098594f, 
    0.03501602f, 0.00984747f, -0.11149654f, -0.01108335f, -0.19801727f, 0.15427667f, 0.10812484f, 0.22293688f, 
    -0.25683114f, -0.07796402f, 0.12348562f, -0.43821707f, 0.22076376f, 0.12042887f, 0.05067062f, 0.16953655f, 
    0.09061453f, -0.05321306f, 0.02782985f, -0.05514419f, 0.15579493f, -0.13048841f, 0.28802514f, 0.05885353f, 
    0.25912678f, 0.02179739f, -0.05532316f, -0.15066309f, -0.20733574f, 0.04007182f, 0.02733014f, -0.00538597f, 
    0.47153553f, -0.21614300f, -0.34471935f, 0.33966723f, 0.35107428f, -0.19345672f, 0.03332373f, -0.08782279f, 
    0.09260053f, -0.00002825f, 0.18356034f, 0.01567409f, 0.23819603f, -0.09643430f, 0.18770528f, -0.09062915f, 
    0.01280891f, -0.06392250f, 0.20909518f, 0.08684377f, -0.18523012f, 0.08449949f, 0.05687216f, -0.04513960f, 
    -0.08036720f, 0.02652203f, -0.29259804f, -0.47669101f, 0.12496208f, -0.00997450f, -0.05504850f, 0.12038848f, 
    0.21793458f, 0.00949423f, 0.17730735f, 0.00031986f, 0.86844367f, 0.10099036f, -0.53968579f, 0.11378404f, 
    0.08586998f, -0.37332186f, 0.00170581f, -0.02717883f, -0.06405929f, 0.15990518f, -0.10392626f, 0.03423398f, 
    -0.67446595f, 0.57675672f, -0.01483731f, -0.01899763f, 0.18475613f, 0.03522204f, 0.09640846f, -0.24382734f, 
    -0.13253801f, 0.05442715f, -0.01211667f, -0.09702324f, -0.48692933f, -0.21639323f, -0.01483849f, -0.19064020f, 
    -0.00777887f, 0.04961554f, 0.28225446f, 0.13163471f, -0.04938555f, 0.10459372f, -0.17837361f, 0.18125494f, 
    0.09806488f, 0.10355812f, -0.10432604f, 0.19885924f, -0.06328902f, -0.17942889f, -0.25189403f, -0.28400207f, 
    -0.04506487f, -0.03891245f, 0.10472549f, 0.11214115f, -0.54043907f, -0.04701181f, -0.05297440f, -0.03497557f, 
    0.26974502f, 0.10841909f, -0.06379438f, 0.05525556f, -0.04372936f, -0.08491442f, -0.20358603f, 0.06951398f, 
    0.13930766f, 0.36686981f, -0.28045738f, -0.23683426f, -0.26689306f, -0.09855240f, -0.11945367f, -0.00238254f, 
    -0.05770604f, 0.03871353f, -0.13197577f, -0.21970214f, 0.25882879f, -0.30332032f, -0.04575533f, 0.78143752f, 
    -0.10195791f, -0.12558816f, -0.01924521f, 0.07520442f, -0.17686947f, -0.04215764f, -0.17164694f, -0.12971193f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20428042f, 0.04519947f, -0.09647910f, -0.02665622f, 0.02205187f, -0.03071612f, 0.01722392f, -0.14203033f, 
    -0.05257623f, 0.07042331f, 0.18294446f, 0.05953943f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
