#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.37610596f, -0.20209727f, 0.72603410f, 0.48782358f, -0.76141340f, 0.31831759f, 0.16379084f, -0.01123247f, 
    0.06982186f, -0.26019096f, -0.97871792f, -0.30250967f, -0.25399807f, -0.87429124f, -0.02786627f, 0.05158422f, 
    0.01250339f, -0.34985638f, 0.42951316f, 0.40839428f, -0.20132607f, -0.81562769f, -0.07095295f, -0.53037828f, 
    0.25475761f, 0.70922828f, 0.09860068f, -0.15507986f, -0.00647127f, -0.15342158f, 0.49370119f, -0.34969136f, 
    0.04876665f, -0.46330160f, -0.48357776f, -0.53538752f, -0.58672762f, -0.38066030f, -0.28805095f, 0.57200497f, 
    0.23846516f, -0.28276828f, -0.41091800f, 0.41487885f, 0.23533991f, 0.04675382f, 0.86522865f, -0.30646378f, 
    0.33078104f, -0.65630019f, -0.71293169f, 0.10849415f, 0.00668845f, -0.04011726f, 0.56779188f, 0.35375482f, 
    0.40933520f, -0.84578913f, -0.12781365f, -0.52870518f, -0.27278063f, -0.10498991f, -0.06066170f, 0.68426454f, 
    0.27233085f, 0.44382611f, 0.39170510f, 0.52805543f, 0.42399317f, -0.32976681f, 0.23822142f, 0.28185892f, 
    0.12612225f, 0.55881894f, 0.76403278f, -0.29206505f, 0.32606161f, 0.34449458f, -0.10285085f, 0.00575692f, 
    0.13409981f, 0.79600364f, 0.80146641f, 0.76103824f, 0.14306840f, -0.19448194f, 0.06593195f, 0.33292484f, 
    0.20935668f, 0.00680413f, -0.82414067f, 0.07961847f, -0.32818466f, 0.04844685f, 0.86115879f, -0.23814796f, 
    -0.15300536f, -0.13866788f, -0.24714950f, 0.05099482f, 0.17956887f, 0.69575435f, 0.79841340f, 0.65450615f, 
    -0.29779074f, 0.17177099f, 0.46416450f, -0.10478460f, -0.89598233f, -0.07899979f, 0.58286083f, -0.22847193f, 
    0.39626488f, -0.13479029f, 0.19228831f, 0.38743266f, -0.05577810f, 0.40873578f, 0.74681699f, -0.51440674f, 
    -0.00227256f, 0.49732557f, 0.15291783f, 0.50427043f, 0.13410896f, 0.19953772f, -1.01444149f, -0.56046385f, 
    -0.41082081f, 0.55100101f, 0.56103379f, 0.60359430f, 0.32754162f, -0.32970771f, 0.00834616f, 0.52772987f, 
    -0.52353382f, -0.47160992f, -0.47442284f, 0.53786451f, -0.33572724f, -0.09565870f, -0.02338027f, 0.00258328f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.38450298f, -0.13303703f, -0.07955219f, 0.00564247f, 0.04199077f, 0.17653871f, 0.21876401f, 0.22810510f, 
    0.47059491f, 0.44599056f, -0.12448668f, 0.12827975f, -0.15466167f, -0.26145858f, 0.00041887f, 0.24217314f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.84442413f, -0.16581443f, -0.02811980f, 0.28711993f, -0.09688387f, 0.13801764f, -0.10566697f, 0.13326499f, 
    0.11768341f, 0.11097664f, -0.18861167f, -0.27519318f, -0.23979777f, -0.05966455f, 0.04811224f, 0.14810835f, 
    0.02851240f, -0.08818300f, 0.25730631f, -0.07575457f, 0.11877584f, 0.18168889f, -0.06212872f, -0.04400766f, 
    0.06251440f, -0.18378913f, -0.05968071f, -0.25988302f, -0.01351544f, 0.15380569f, 0.42173967f, 0.16402175f, 
    0.12509005f, -0.25132659f, 0.01705639f, 0.05315050f, 0.14446619f, -0.18148619f, -0.18416345f, -0.29205546f, 
    0.02795268f, -0.10202511f, 0.11759702f, 0.17483552f, -0.13445912f, 0.21325985f, -0.24461985f, 0.17043905f, 
    -0.21391882f, 0.01142496f, -0.00971934f, 0.05357645f, 0.14957544f, 0.02768256f, 0.65797466f, -0.02027985f, 
    0.35653216f, 0.01707084f, -0.08581752f, 0.14366978f, 0.08287260f, -0.17025654f, 0.02878062f, -0.40690288f, 
    -0.04929893f, -0.09124580f, 0.00622325f, 0.33756477f, -0.23209359f, 0.04971172f, -0.12934481f, 0.06449039f, 
    -0.06351080f, 0.11526948f, 0.14629015f, 0.19672056f, -0.15062737f, 0.19319519f, -0.05692229f, 0.11040040f, 
    -0.00085979f, -0.38635898f, -0.08222962f, -0.01893469f, 0.01462990f, 0.18398830f, 0.20331858f, 0.15018603f, 
    -0.00388376f, 0.06657095f, 0.10470156f, 0.03840275f, 0.10450801f, 0.14418358f, 0.08730233f, 0.17219381f, 
    -0.31159040f, 0.07232989f, -0.03543385f, -0.21107166f, -0.22868279f, -0.04254228f, 0.17404531f, -0.07210472f, 
    -0.00593037f, -0.01025325f, 0.04212975f, 0.10874304f, 0.17711116f, -0.08359785f, -0.04951233f, -0.27160126f, 
    -0.15218483f, -0.00164868f, 0.11100893f, -0.10613979f, -0.04089127f, -0.70004404f, -0.10892078f, -0.08260349f, 
    0.01280588f, 0.04044505f, -0.14271797f, -0.02717836f, -0.08120824f, 0.01250140f, 0.12070151f, -0.01088595f, 
    -0.15704700f, -0.08626767f, -0.10911749f, -0.07502753f, 0.04222246f, 0.11895998f, 0.04926532f, 0.13894798f, 
    0.09122988f, 0.01608554f, 0.21281014f, 0.09007838f, 0.00211868f, 0.01414599f, -0.02294170f, -0.02751634f, 
    -0.07408985f, 0.15927789f, 0.03589841f, -0.07990577f, 0.04649747f, -0.30966938f, -0.02272191f, -0.06617586f, 
    0.19619144f, 0.07951780f, 0.45560735f, -0.15221724f, 0.18726973f, -0.00062676f, 0.11446491f, -0.02762030f, 
    0.26821002f, -0.04957709f, 0.22257365f, -0.10115350f, -0.28731698f, 0.15276989f, -0.07245748f, 0.20203070f, 
    0.00874574f, 0.08932309f, 0.15056905f, -0.24982752f, -0.05852278f, -0.14172295f, 0.06487828f, -0.13458645f, 
    -0.01840267f, -0.03065173f, 0.15926284f, -0.06503043f, 0.02647663f, -0.01914404f, -0.05012904f, -0.03772769f, 
    0.10273793f, 0.05047034f, -0.10780103f, -0.15646257f, -0.06720180f, -0.21743718f, -0.28427780f, -0.22031857f, 
    0.37060449f, 0.00575785f, 0.06573066f, 0.11069868f, -0.00692476f, -0.02955738f, 0.19015945f, -0.06090021f, 
    -0.25802723f, -0.02726131f, -0.08104394f, 0.09416508f, -0.02691889f, -0.08831982f, -0.00640970f, 0.13075161f, 
    -0.04088031f, -0.16581987f, 0.16206235f, -0.14344275f, -0.23180705f, -0.11803742f, 0.11636938f, 0.11115816f, 
    0.08434792f, 0.00589189f, 0.08878095f, 0.09711601f, -0.13971554f, -0.01727225f, 0.05888782f, 0.00075451f, 
    0.09935716f, 0.43088123f, 0.03788486f, 0.04423384f, 0.12371638f, 0.17624733f, 0.14755172f, 0.11054567f, 
    0.04841949f, -0.01174376f, -0.33471990f, -0.11852997f, -0.14283577f, -0.09176788f, 0.09206147f, 0.02097123f, 
    -0.00263734f, 0.05048751f, -0.11318370f, -0.04045488f, 0.16947423f, -0.09529226f, -0.10560343f, -0.03010808f, 
    -0.08920245f, -0.19456141f, 0.09413698f, 0.16563073f, -0.31584755f, 0.08630858f, 0.02255170f, -0.19966078f, 
    0.26125553f, 0.02426731f, 0.07351928f, -0.01577848f, 0.08350316f, 0.50123918f, -0.27710208f, 0.05501080f, 
    -0.21660760f, 0.06919023f, -0.02967023f, 0.01870510f, 0.09239175f, 0.09558495f, -0.04874153f, 0.06295393f, 
    0.22353099f, -0.14242014f, 0.03499288f, -0.25938213f, 0.06211004f, 0.03317298f, -0.09225924f, 0.09057297f, 
    0.02249338f, -0.31762829f, 0.22196811f, -0.06986070f, 0.12279151f, -0.13325697f, -0.05502327f, -0.10649760f, 
    -0.25192386f, -0.21918809f, -0.22020963f, 0.05951817f, 0.19734122f, 0.06263633f, -0.04385985f, -0.31170559f, 
    -0.25492144f, 0.08910272f, 0.21217403f, -0.03178118f, -0.07310408f, 0.12595870f, 0.04486336f, 0.14469698f, 
    0.14821921f, 0.24222794f, 0.27182540f, -0.17383753f, -0.09378482f, -0.10455193f, -0.04323386f, -0.11266463f, 
    -0.02911327f, 0.09114373f, 0.07049561f, -0.05506261f, -0.04661600f, -0.04755947f, -0.02315658f, -0.03175767f, 
    0.20626487f, 0.11674815f, -0.04893181f, -0.05680998f, 0.07116727f, -0.03500157f, 0.04417059f, -0.19741143f, 
    -0.15854004f, -0.10442080f, -0.08509653f, 0.03445992f, -0.00083286f, 0.63006365f, 0.12902310f, 0.04181327f, 
    0.03415446f, -0.14407477f, -0.13942730f, 0.11343599f, 0.21468267f, 0.14670724f, 0.01130539f, 0.22665547f, 
    -0.14264318f, -0.05715386f, 0.19936219f, -0.02133829f, 0.15348364f, 0.15622704f, 0.19093436f, -0.13292874f, 
    -0.25736344f, -0.08007674f, 0.23040602f, 0.27092686f, 0.30047941f, -0.05656647f, 0.08525477f, -0.13324808f, 
    0.24633452f, -0.00811282f, 0.19533847f, 0.15602960f, 0.22399440f, 0.07894195f, 0.10313872f, 0.09052236f, 
    -0.10503624f, 0.40711823f, -0.15315951f, -0.09122339f, 0.24661259f, 0.04361853f, 0.05003275f, 0.11903545f, 
    -0.04321948f, -0.02736155f, -0.12201786f, -0.02692510f, 0.25482491f, -0.42277938f, -0.23328188f, -0.07970537f, 
    -0.37344152f, 0.07663111f, 0.24378932f, 0.19728072f, -0.04476190f, -0.25157058f, 0.01166195f, 0.08873186f, 
    0.20133150f, -0.01017297f, 0.02340508f, -0.06844286f, -0.04656089f, 0.12521921f, -0.02675445f, -0.14982906f, 
    -0.08029570f, -0.00482480f, 0.09638690f, 0.25369138f, 0.08059786f, 0.14976123f, -0.23338230f, 0.10923826f, 
    -0.01915248f, 0.23681708f, 0.14164437f, -0.17715040f, -0.07773503f, -0.13883381f, -0.06940032f, 0.04037534f, 
    0.21596026f, -0.19275932f, -0.07288340f, 0.16294317f, 0.05971983f, 0.02945124f, 0.18155652f, -0.01024350f, 
    0.38543448f, 0.18667354f, -0.23682471f, -0.03786491f, 0.05711645f, 0.18406175f, 0.19337909f, 0.14483143f, 
    0.01887614f, -0.12516020f, 0.04422257f, -0.23298538f, 0.13165671f, 0.08633514f, -0.11011852f, 0.06783826f, 
    -0.20036933f, -0.11235942f, -0.08764374f, 0.16503119f, -0.05840203f, -0.02324023f, -0.10670857f, 0.02631341f, 
    0.06809008f, 0.08363155f, 0.05019741f, 0.05530443f, 0.00338201f, -0.27927417f, 0.01601817f, -0.09212179f, 
    -0.12519407f, 0.12589441f, -0.08907146f, 0.07746524f, 0.14696592f, -0.05270174f, -0.15206842f, 0.09221207f, 
    0.04790328f, 0.25612852f, 0.04512709f, 0.06569194f, -0.24157962f, -0.29453108f, -0.15623663f, 0.27597889f, 
    -0.10351422f, 0.25750351f, 0.26801038f, -0.16518605f, -0.02841697f, 0.14552417f, 0.02682615f, 0.18028900f, 
    -0.21592340f, 0.08380721f, -0.30238694f, 0.09347242f, 0.05901683f, 0.22434145f, 0.00944447f, 0.16056022f, 
    0.29399136f, -0.14382090f, -0.00024123f, 0.01308367f, -0.10231685f, 0.04345414f, 0.08900890f, -0.22849269f, 
    0.21830074f, 0.02681268f, 0.08367501f, 0.10164825f, 0.06825951f, 0.22814485f, 0.12732880f, -0.07012793f, 
    -0.10837887f, -0.13607396f, 0.41340175f, 0.13674730f, -0.06625866f, -0.05835551f, -0.00920282f, -0.07122602f, 
    -0.13745832f, 0.10806359f, 0.31072450f, 0.35600382f, -0.14723624f, -0.09824842f, -0.04815159f, -0.03604276f, 
    0.05261885f, 0.09011714f, 0.43116102f, 0.07121715f, -0.11248405f, 0.21809353f, 0.03084193f, 0.08327106f, 
    -0.05933382f, -0.25648120f, -0.07951152f, -0.19843321f, -0.01172718f, 0.28694734f, -0.05238751f, 0.02105845f, 
    0.05433086f, 0.02679180f, 0.09554905f, 0.01948397f, -0.28810957f, -0.34836391f, 0.40816149f, 0.21627170f, 
    -0.00139357f, -0.00116407f, -0.20797873f, 0.00500860f, -0.18097363f, -0.40002802f, 0.10746842f, -0.38206252f, 
    -0.00936794f, -0.13086843f, -0.18519095f, -0.11802007f, -0.23194242f, -0.29134640f, -0.03450287f, 0.11050989f, 
    -0.68105555f, 0.28216818f, 0.40778375f, 0.13335271f, 0.08447871f, 0.02645093f, -0.03842169f, 0.00554316f, 
    -0.26156849f, -0.10578746f, -0.13956608f, -0.09421368f, -0.14354156f, -0.15011063f, 0.08710927f, 0.12635379f, 
    0.15364826f, 0.05631248f, -0.23659652f, 0.05485223f, 0.03513876f, 0.04880432f, -0.00645761f, -0.08871073f, 
    -0.17313518f, 0.37490824f, -0.08730896f, 0.42421284f, 0.04625168f, 0.08165604f, -0.25286534f, 0.16264082f, 
    -0.14523095f, -0.02275543f, -0.10362776f, 0.19737966f, -0.09963031f, -0.05654547f, 0.12427872f, -0.25561050f, 
    0.05188004f, 0.00254351f, 0.03307966f, 0.42317298f, 0.00417071f, 0.04508774f, -0.07342362f, -0.08025123f, 
    0.32828236f, 0.07879464f, 0.09955148f, 0.04232076f, -0.10315520f, -0.28591332f, 0.16983335f, -0.11748457f, 
    -0.19120894f, 0.12061608f, 0.11033890f, 0.04520382f, 0.04715944f, -0.00273753f, 0.07713474f, 0.03566261f, 
    0.03645797f, 0.01984947f, -0.09342878f, -0.21797675f, 0.11684866f, -0.07396924f, -0.07029434f, -0.01266433f, 
    -0.03353570f, 0.10343328f, 0.15437050f, -0.04655865f, 0.00131041f, -0.05860274f, -0.04626813f, 0.04193493f, 
    -0.04033069f, -0.30242237f, -0.12363627f, 0.07407466f, 0.03349927f, 0.07616050f, 0.04601272f, -0.12630419f, 
    -0.07533685f, 0.12890108f, 0.15202536f, 0.11436254f, 0.02336669f, 0.18672942f, 0.06607650f, 0.05564677f, 
    -0.03167366f, -0.37726989f, -0.18517844f, 0.09602341f, 0.08838030f, 0.05779032f, 0.09010535f, -0.06109838f, 
    -0.01908528f, -0.20901015f, 0.14585742f, 0.21780343f, 0.11494154f, -0.04448770f, -0.10473790f, 0.08023322f, 
    0.12201653f, -0.08310717f, 0.03412699f, -0.21656148f, 0.05005319f, -0.12515759f, 0.08018932f, -0.04486199f, 
    0.12354015f, 0.09520948f, -0.01356534f, -0.15236281f, 0.24705806f, 0.07907481f, -0.06214255f, -0.03786318f, 
    -0.45420700f, -0.07881084f, -0.01248437f, 0.03155684f, -0.06165181f, -0.19134638f, 0.15755299f, 0.27186665f, 
    0.10301331f, -0.19756231f, -0.26617405f, 0.03729106f, 0.06943697f, 0.18367378f, -0.06177686f, -0.35927823f, 
    0.05512053f, 0.01548754f, 0.01803237f, -0.02140378f, -0.04663711f, 0.11730286f, -0.14153776f, 0.16331224f, 
    0.02323916f, 0.29411995f, 0.05067125f, -0.17681888f, -0.09876575f, 0.09158840f, -0.11199717f, -0.02034889f, 
    -0.04818206f, -0.31343979f, -0.39829275f, -0.18031582f, 0.21535233f, -0.15916447f, 0.10372134f, 0.06035011f, 
    0.11408792f, 0.07596135f, -0.10767148f, -0.04202671f, 0.10382437f, 0.06597876f, -0.00189663f, -0.07937220f, 
    0.12821016f, 0.00506345f, 0.05270691f, -0.03163718f, -0.52734321f, 0.05614087f, -0.08301233f, 0.01113628f, 
    0.00310403f, -0.09749394f, -0.16160640f, 0.13536170f, -0.04187094f, -0.29370198f, -0.03281111f, -0.08732428f, 
    0.10714027f, 0.03799576f, -0.06030200f, -0.03962357f, -0.19947739f, 0.16588832f, 0.27121550f, -0.00599214f, 
    0.02865751f, 0.06429362f, 0.11462936f, -0.00559947f, -0.18177357f, -0.09145457f, 0.04829954f, -0.37001145f, 
    0.24061283f, 0.05244677f, 0.10764185f, 0.03011836f, -0.00731195f, -0.06733460f, -0.00968064f, 0.31629416f, 
    -0.28451580f, 0.00711533f, -0.04356885f, 0.09938294f, 0.01649910f, 0.09527812f, 0.12251616f, 0.08450003f, 
    0.06965245f, 0.08765496f, 0.07518972f, -0.09459452f, -0.00425312f, 0.01896898f, 0.05789809f, -0.02370653f, 
    -0.09476567f, 0.33492932f, -0.19750424f, 0.12223382f, -0.06240774f, 0.07271141f, 0.03790427f, 0.02572659f, 
    0.10281195f, 0.16358384f, 0.24047847f, 0.17951958f, 0.09832009f, -0.06484117f, -0.04781616f, -0.01319794f, 
    -0.02683941f, -0.02513948f, -0.59063983f, -0.13088720f, 0.25994274f, 0.18104090f, -0.02035877f, 0.02211115f, 
    -0.25092292f, -0.01637916f, 0.14960417f, 0.21497497f, -0.15588464f, -0.41179302f, -0.13155164f, -0.06028184f, 
    0.01018821f, -0.02685278f, -0.03011814f, 0.05256663f, -0.54507232f, 0.18129544f, -0.06771848f, -0.05300232f, 
    -0.01459203f, -0.03719133f, -0.00171647f, -0.15204035f, -0.11423128f, -0.19600262f, 0.29607767f, -0.10551970f, 
    -0.09248791f, 0.02919366f, -0.01060487f, -0.12427097f, 0.00070510f, 0.04525181f, -0.33725139f, -0.29797772f, 
    0.18425208f, 0.01984962f, 0.11656387f, 0.12689413f, -0.03211341f, 0.11927924f, -0.00772716f, 0.33022135f, 
    -0.22528282f, 0.18629451f, -0.09040003f, 0.06169219f, 0.02613242f, 0.04916865f, -0.02863525f, 0.09894106f, 
    -0.02525842f, 0.05425292f, -0.08309744f, 0.00386480f, 0.14043309f, -0.09269265f, -0.02679178f, 0.10168323f, 
    -0.09540983f, -0.62056506f, -0.10584351f, 0.37082624f, 0.10395322f, 0.00462573f, -0.09531397f, -0.02513566f, 
    0.10633416f, 0.05776767f, -0.01194323f, 0.31934601f, -0.23571251f, -0.04110145f, 0.07178197f, -0.13180853f, 
    0.14766142f, -0.16363117f, -0.16375525f, 0.17812957f, -0.16958387f, 0.00113571f, 0.09772281f, -0.09724753f, 
    0.05204208f, -0.03064391f, 0.06063550f, 0.12432785f, -0.17057501f, -0.25121486f, 0.15401143f, 0.12010844f, 
    -0.04577281f, -0.09449659f, 0.18924241f, 0.01459842f, 0.03519283f, -0.20694774f, 0.08105230f, -0.28963047f, 
    0.09412174f, -0.07937188f, -0.06645615f, 0.08516701f, 0.03056622f, -0.06818008f, -0.19358584f, -0.28641793f, 
    -0.39249668f, 0.13722770f, 0.13704138f, 0.06519780f, 0.09895576f, -0.17503062f, 0.15781701f, 0.17065893f, 
    -0.00110776f, 0.09998379f, 0.16763860f, -0.05359029f, 0.08523567f, -0.05385868f, 0.22452827f, 0.10192266f, 
    -0.11714465f, 0.02829185f, 0.11754911f, 0.10745312f, 0.10250185f, 0.15557559f, 0.06058341f, -0.01105952f, 
    -0.01406981f, 0.18264171f, 0.10234744f, 0.12006010f, 0.03693196f, 0.07993725f, -0.08415187f, -0.05376049f, 
    -0.07109528f, -0.00148133f, -0.07574202f, 0.11284504f, -0.04728177f, -0.06522144f, -0.11030760f, 0.18672575f, 
    -0.09732782f, -0.03861643f, 0.04665427f, 0.32523030f, -0.21162708f, -0.13237363f, -0.12965201f, -0.13811365f, 
    0.20878987f, 0.01017105f, 0.01398760f, -0.05706050f, -0.06133837f, -0.08863557f, -0.26575488f, -0.00296781f, 
    0.13386579f, 0.01170450f, 0.11165906f, -0.08572226f, 0.06967622f, -0.02006190f, 0.13795362f, -0.03179034f, 
    0.00025978f, -0.09952085f, -0.06948358f, -0.09130658f, 0.00508181f, 0.08084629f, 0.21697889f, 0.09137359f, 
    0.57602477f, -0.02382272f, -0.01313734f, -0.10450460f, -0.22140789f, 0.05318462f, 0.09401373f, 0.03804902f, 
    0.12778690f, -0.17126188f, -0.11575581f, 0.13243043f, -0.12034328f, -0.09754106f, -0.14801675f, -0.15234885f, 
    -0.04298569f, 0.05620210f, -0.03569546f, 0.05185033f, 0.07101856f, 0.05581963f, -0.07199616f, 0.07230749f, 
    -0.00146783f, 0.04600381f, -0.07705849f, 0.01951780f, 0.04419376f, 0.02725586f, 0.02531164f, 0.04202306f, 
    -0.07205907f, 0.06452538f, -0.09087719f, -0.08922313f, 0.02308168f, 0.07036357f, -0.03604267f, -0.08806162f, 
    0.03435276f, -0.05742900f, 0.03765871f, -0.08754519f, -0.01157913f, -0.05765963f, -0.01962350f, 0.00191800f, 
    -0.07064159f, 0.04001136f, 0.01431563f, 0.04432616f, -0.10293569f, -0.02179759f, -0.01743861f, -0.01526105f, 
    0.03540083f, -0.09484814f, -0.02202502f, -0.04892709f, -0.07170967f, 0.01035668f, -0.06343921f, -0.08166333f, 
    0.02584086f, -0.08104934f, -0.07667454f, -0.07612595f, -0.02412940f, 0.03600018f, 0.04450402f, -0.02018827f, 
    -0.05359456f, 0.04609446f, 0.01839093f, 0.05239388f, 0.02744765f, -0.08470939f, -0.00016647f, -0.01874878f, 
    -0.00835827f, -0.07777026f, 0.02888496f, 0.00018007f, -0.08911356f, 0.05404222f, -0.02327283f, -0.01463483f, 
    0.00387051f, -0.09146405f, 0.06138189f, 0.04616105f, 0.06116676f, 0.01596083f, 0.05756828f, -0.05133447f, 
    -0.06496021f, 0.03583027f, 0.03818366f, -0.07991415f, -0.01309930f, -0.07264240f, -0.03900211f, -0.07618305f, 
    -0.02894293f, -0.00913271f, -0.10084657f, 0.01638233f, 0.03680642f, -0.05963317f, -0.00479066f, -0.07924665f, 
    -0.00553005f, 0.00790268f, 0.01383038f, -0.08071859f, -0.01371507f, -0.05072080f, -0.01669204f, -0.08310722f, 
    -0.01606752f, -0.00765109f, -0.05015891f, -0.01594474f, 0.00418142f, -0.10549777f, 0.03697531f, 0.01366088f, 
    -0.09316377f, 0.01331751f, -0.02729471f, 0.01010348f, -0.05423157f, -0.04349605f, 0.00761242f, -0.02654679f, 
    -0.05475936f, 0.00650194f, 0.02709460f, 0.03924879f, 0.03077269f, 0.01141533f, -0.04360745f, -0.08237094f, 
    -0.10498196f, -0.00487145f, 0.04510914f, -0.09412631f, 0.06160611f, -0.07793358f, -0.01787758f, -0.02799165f, 
    0.02090554f, -0.06181520f, -0.05952706f, -0.03151775f, -0.05936173f, 0.05264435f, -0.00149893f, -0.07961926f, 
    -0.03556017f, -0.03587981f, 0.03276343f, -0.00294475f, -0.03085268f, 0.00246483f, -0.01955440f, -0.07692208f, 
    0.01041589f, -0.05322556f, -0.07583070f, -0.00037930f, 0.05047862f, -0.02005661f, 0.05008580f, -0.04173923f, 
    -0.08411814f, 0.04757778f, 0.02714595f, -0.01799157f, -0.03925241f, 0.04928236f, -0.05719739f, -0.07012109f, 
    0.05900901f, -0.10339793f, 0.03621740f, 0.02174603f, 0.01461168f, -0.02082988f, -0.07676602f, -0.07369965f, 
    -0.09138076f, -0.03687147f, 0.01398138f, -0.09004461f, -0.00739550f, -0.02976841f, -0.00495136f, -0.00963196f, 
    -0.05556656f, -0.05958874f, -0.07764761f, 0.04720838f, -0.02710171f, 0.04208469f, -0.08946119f, -0.11004692f, 
    -0.06535342f, 0.02680942f, -0.01313019f, 0.01407019f, 0.00702871f, 0.03518432f, 0.04864887f, -0.06062913f, 
    0.06120985f, -0.05872434f, 0.03587003f, 0.06851313f, -0.07570288f, 0.02755192f, -0.07251079f, -0.01001794f, 
    -0.07671789f, -0.00309950f, -0.00458901f, 0.05218753f, -0.10276080f, -0.10768452f, 0.02316845f, 0.06852733f, 
    0.07133713f, -0.09128260f, 0.00193043f, 0.02280106f, -0.10301176f, 0.01746949f, 0.01187671f, -0.02849822f, 
    -0.01181466f, -0.06943947f, -0.04332664f, -0.04549544f, 0.04171404f, -0.09815727f, -0.06029345f, -0.04073531f, 
    -0.09022118f, -0.05436198f, 0.03636933f, -0.06050988f, -0.05285834f, -0.01281842f, 0.02740143f, -0.08348250f, 
    -0.09298381f, -0.00594026f, -0.00917708f, -0.03822479f, -0.07698745f, 0.02265382f, 0.06164603f, 0.03714093f, 
    -0.05207310f, 0.04568672f, 0.04593745f, -0.00316975f, -0.06369185f, 0.01697195f, -0.06593873f, 0.03127683f, 
    -0.06263054f, -0.05590203f, 0.05335722f, -0.10607763f, 0.04853425f, 0.04938585f, 0.06657701f, 0.04118617f, 
    0.00630808f, -0.08401012f, -0.09576424f, -0.04401104f, -0.07695303f, 0.07348983f, -0.08568271f, 0.03289793f, 
    -0.02801323f, -0.08225261f, 0.03591176f, -0.05743545f, -0.00080652f, -0.08056691f, -0.02282653f, 0.01315315f, 
    -0.09707738f, 0.01348938f, -0.05448726f, 0.00494080f, -0.04709138f, 0.05419894f, -0.06201050f, 0.02147103f, 
    -0.39126259f, 0.11336738f, 0.24626489f, -0.04802691f, -0.18629846f, -0.01561206f, 0.24029727f, -0.11036929f, 
    -0.10581741f, -0.29351205f, -0.09667663f, 0.06706560f, 0.20038246f, 0.08331186f, 0.17735586f, -0.08256137f, 
    0.07063617f, -0.10422233f, 0.07505406f, -0.01667057f, -0.12716362f, -0.08223873f, -0.10649092f, 0.00584536f, 
    -0.04645815f, 0.07586844f, 0.01588962f, 0.05030070f, 0.11611833f, 0.00991735f, 0.03778313f, 0.15232971f, 
    -0.19616829f, 0.15005428f, 0.20014383f, -0.07000486f, 0.00298905f, 0.17302999f, -0.21166342f, 0.23987693f, 
    0.12940000f, 0.10002851f, 0.02863651f, -0.09947067f, 0.00583336f, -0.16415435f, -0.03339092f, -0.23312628f, 
    -0.08859933f, 0.18166922f, 0.10211922f, 0.09090197f, -0.17062028f, -0.02627197f, -0.06105136f, 0.07189404f, 
    0.07618960f, 0.03610792f, -0.08055569f, 0.11903720f, -0.23947178f, -0.11338008f, 0.06896684f, -0.15029344f, 
    0.09695912f, 0.03433017f, 0.09291955f, 0.10721671f, -0.25469047f, 0.23831344f, 0.12429194f, 0.15458441f, 
    -0.16988467f, 0.07864759f, -0.06744689f, -0.10596300f, 0.11456837f, -0.02220939f, 0.16209356f, 0.09715603f, 
    0.12017677f, -0.07083091f, 0.15413257f, 0.10758485f, -0.01582027f, -0.22005750f, 0.08664241f, -0.23394994f, 
    0.19635707f, 0.09576529f, -0.28517255f, 0.00187368f, -0.22866544f, 0.05397389f, -0.02241114f, 0.14019121f, 
    0.03656651f, -0.15683351f, -0.05525703f, -0.19452405f, -0.22589391f, 0.13859974f, -0.04015246f, 0.07984404f, 
    -0.20790158f, 0.04812096f, 0.04860522f, 0.20488352f, -0.18537101f, -0.15487359f, -0.04506611f, 0.13304217f, 
    -0.02649943f, 0.10541924f, 0.11392868f, 0.12424879f, 0.07510012f, 0.00216157f, -0.23017390f, 0.00428628f, 
    -0.05224733f, -0.30367142f, -0.23460351f, -0.23189802f, -0.15786119f, -0.02229746f, -0.03812562f, 0.32578474f, 
    -0.04230086f, 0.08563918f, -0.01554340f, 0.04344808f, 0.03400161f, 0.17084585f, -0.13606770f, 0.08989984f, 
    -0.10555535f, 0.00966900f, 0.17035039f, 0.08819800f, 0.18640237f, 0.00759806f, -0.19120240f, -0.02513707f, 
    0.00019359f, -0.04195137f, -0.07442865f, 0.09051493f, -0.21258938f, -0.01349348f, -0.20895165f, 0.02320211f, 
    0.05338899f, -0.27384701f, -0.04451708f, 0.22155282f, 0.14048544f, 0.12965338f, -0.07071821f, 0.04461090f, 
    -0.02539732f, 0.11082582f, 0.07561341f, 0.07052676f, 0.00157235f, -0.06726374f, 0.02207492f, -0.04866583f, 
    0.00883860f, -0.06138358f, 0.01598410f, 0.17034005f, -0.03016168f, -0.03005890f, -0.15179567f, -0.12135813f, 
    -0.13162383f, 0.20281352f, 0.14103432f, 0.00353092f, -0.60473424f, -0.03489636f, 0.02901340f, 0.01518551f, 
    -0.11789814f, 0.03826938f, 0.01554072f, 0.28581417f, -0.01478190f, 0.01172746f, 0.01358291f, -0.05522137f, 
    0.07130812f, 0.18651430f, -0.01472631f, 0.18759783f, -0.03320625f, 0.05942916f, -0.22797601f, -0.10401719f, 
    0.05204002f, 0.06314467f, 0.27428746f, 0.12364285f, 0.20869386f, 0.15560250f, 0.18580624f, 0.14592412f, 
    0.07621685f, -0.04850126f, 0.04505361f, -0.13172525f, -0.04243357f, 0.12119295f, 0.08991987f, -0.01003209f, 
    0.23642701f, 0.13557427f, 0.07318554f, 0.01216506f, 0.03945704f, -0.10520975f, -0.17896244f, 0.22611839f, 
    0.01247513f, -0.09453806f, 0.23875527f, 0.23682052f, 0.16770245f, 0.08616906f, -0.08367313f, 0.03052310f, 
    0.07321320f, -0.08854289f, -0.12437130f, -0.36297613f, -0.15379202f, 0.22608431f, 0.14051016f, 0.08574933f, 
    -0.10574235f, -0.17705433f, -0.04289323f, -0.07080261f, 0.11449940f, -0.03511110f, -0.14604168f, -0.30149040f, 
    -0.16979542f, 0.01360499f, -0.00361494f, -0.03113259f, -0.44308791f, -0.49603537f, -0.06639966f, 0.12767507f, 
    0.06063497f, -0.05319951f, -0.02648881f, -0.16757499f, 0.01163527f, -0.12000591f, 0.08188605f, -0.31962532f, 
    -0.18282099f, 0.01211088f, 0.07924866f, -0.04807422f, -0.01410753f, 0.06031168f, -0.28977099f, -0.24102104f, 
    0.08181287f, -0.12269743f, 0.01425078f, -0.04094123f, -0.01741031f, -0.03832540f, 0.06159335f, -0.26248264f, 
    0.12842461f, -0.23903702f, 0.10407019f, 0.03188293f, 0.09144086f, 0.07734875f, -0.06594703f, -0.00722159f, 
    0.20135748f, -0.16634192f, 0.24327588f, 0.08623756f, 0.16013257f, 0.18083411f, 0.02472071f, -0.04051956f, 
    0.14950930f, 0.14422217f, 0.20309992f, -0.35998237f, -0.24756670f, -0.06665830f, 0.12347039f, 0.08400758f, 
    0.14841221f, -0.08685421f, 0.25966451f, 0.08980092f, -0.11232262f, -0.01024398f, -0.12018810f, 0.07524835f, 
    0.14029366f, -0.16400953f, 0.00554233f, 0.00354969f, 0.08437608f, 0.06045298f, -0.05646729f, -0.06614898f, 
    0.05803115f, -0.09736703f, -0.12717316f, 0.19646618f, -0.26887518f, 0.06834062f, -0.21378291f, 0.01011871f, 
    0.15596315f, -0.23668054f, -0.02006297f, -0.09096499f, -0.05684923f, 0.09817774f, 0.02312496f, -0.07421506f, 
    0.25582817f, -0.01141622f, -0.05580602f, 0.11442091f, 0.00836840f, 0.01639722f, 0.24002936f, 0.14823711f, 
    -0.00542817f, -0.22091310f, 0.02588998f, -0.05046961f, -0.12010208f, -0.00850078f, 0.10429582f, 0.16350718f, 
    0.07606239f, 0.23464254f, -0.13046661f, 0.03511735f, -0.10797962f, -0.09335149f, 0.09443501f, -0.01708316f, 
    0.19339608f, 0.17856461f, 0.10366115f, -0.01705995f, -0.10879844f, 0.08804140f, 0.03891364f, 0.23472455f, 
    0.11325601f, 0.66484058f, -0.00741413f, 0.07391084f, -0.02696955f, -0.04392492f, 0.07686923f, 0.31973377f, 
    -0.01262039f, -0.06423164f, -0.76754540f, -0.25430033f, -0.05195593f, 0.13027468f, 0.06723493f, -0.12227089f, 
    -0.13212781f, -0.15941618f, 0.06699005f, -0.20870037f, -0.24580613f, 0.16538906f, 0.04193380f, 0.12051095f, 
    0.13231596f, -0.03876375f, -0.06497833f, -0.16063808f, -0.34927344f, 0.01773768f, -0.08931481f, -0.09280370f, 
    -0.20268656f, -0.08339223f, 0.05872102f, -0.12995489f, -0.00124984f, 0.37116337f, -0.12131663f, 0.43366140f, 
    -0.10403647f, -0.01969922f, -0.18281011f, 0.00697877f, 0.15229118f, -0.05311817f, -0.42923254f, -0.17505617f, 
    -0.05987916f, -0.08572176f, 0.08810206f, -0.03475850f, -0.08220422f, 0.08757901f, -0.19254276f, 0.00076554f, 
    0.06455696f, -0.16714080f, -0.03246938f, 0.07679849f, 0.02470831f, -0.04699858f, -0.03236917f, 0.05196559f, 
    -0.26351470f, -0.13369729f, -0.14681491f, 0.12869124f, 0.15872371f, -0.17106846f, -0.01038322f, -0.31291372f, 
    0.02400433f, -0.42381996f, -0.27456561f, 0.02007636f, -0.04211485f, 0.05961513f, 0.18777193f, 0.01645034f, 
    -0.06226389f, 0.21434705f, -0.32554400f, 0.01453285f, 0.09064071f, -0.14478537f, -0.10575203f, -0.08762591f, 
    -0.11563017f, 0.03036841f, 0.11895686f, -0.05236313f, 0.11177073f, 0.15035503f, 0.05611772f, -0.14784445f, 
    0.12161116f, 0.30387262f, 0.05079059f, -0.12885633f, 0.07980734f, -0.04047688f, -0.10715361f, -0.24235652f, 
    0.00901563f, 0.06985553f, 0.12162078f, -0.00388482f, 0.20632598f, -0.18054986f, -0.01473569f, -0.01808538f, 
    -0.21076958f, 0.09139425f, 0.20370211f, 0.06169549f, 0.14015912f, 0.15076295f, 0.17515205f, -0.07954513f, 
    -0.14226817f, -0.15162587f, 0.06175781f, 0.16802181f, -0.19517007f, 0.06891143f, 0.14955837f, 0.45487231f, 
    0.19194473f, -0.28156537f, -0.02356602f, 0.04776512f, 0.26237366f, 0.14806174f, 0.10614555f, 0.20110667f, 
    0.13361877f, 0.08381233f, -0.16978829f, -0.14999819f, 0.13394608f, 0.03900079f, -0.09175042f, 0.03192975f, 
    0.26852095f, 0.13455132f, 0.14978828f, -0.00483008f, -0.02798608f, -0.22693233f, -0.02678883f, 0.10263682f, 
    0.11635526f, -0.06625267f, 0.41782978f, 0.17781813f, -0.17256984f, 0.11839858f, -0.09825184f, 0.06124906f, 
    0.02584452f, 0.03662659f, -0.14133179f, -0.05860801f, 0.14857769f, 0.24786212f, 0.11343902f, 0.25743505f, 
    0.12332030f, -0.20472156f, 0.08087517f, 0.00797818f, -0.51597422f, 0.16778131f, 0.13939616f, 0.06456307f, 
    -0.08975938f, -0.16141397f, -0.05599950f, -0.08106512f, 0.00537072f, -0.32433799f, 0.01225830f, -0.13934267f, 
    0.02933805f, -0.07037445f, -0.05622757f, 0.00894563f, -0.22453173f, -0.09321503f, 0.28942615f, 0.19018142f, 
    -0.23183413f, -0.05497476f, -0.01460656f, 0.02974839f, 0.15980525f, -0.34434500f, 0.15073755f, -0.19794892f, 
    -0.12318517f, -0.04757279f, 0.02362776f, 0.22518629f, 0.02577688f, -0.01048294f, 0.19245331f, 0.04758050f, 
    -0.69412690f, 0.32316583f, -0.04113904f, 0.12114494f, 0.13502704f, 0.04093849f, -0.09759009f, -0.03071091f, 
    -0.01273795f, -0.50664598f, -0.10301947f, -0.32535669f, -0.09886810f, 0.10808967f, -0.01563580f, -0.05694826f, 
    -0.08264021f, 0.20881538f, 0.15518647f, 0.29888070f, -0.07473669f, 0.18046318f, 0.01181814f, -0.01170033f, 
    -0.11413036f, 0.03734351f, -0.05070240f, -0.17891863f, -0.07613569f, 0.10047892f, -0.03413604f, 0.16603357f, 
    -0.05951764f, -0.08383234f, -0.00717755f, 0.17459452f, 0.35634032f, -0.22971633f, 0.23231103f, -0.16797024f, 
    -0.20570333f, -0.14591634f, 0.03215931f, -0.01742887f, 0.17901750f, 0.10577647f, -0.38484856f, 0.09407046f, 
    -0.03756029f, 0.01083079f, 0.20164849f, -0.12904927f, 0.16062050f, 0.02441234f, -0.17107685f, 0.36280319f, 
    -0.02977346f, 0.08244080f, 0.23321785f, 0.04946896f, -0.04697503f, 0.06434508f, -0.04339379f, -0.46463120f, 
    0.13191770f, 0.14893867f, -0.01947885f, 0.00249501f, -0.04827985f, -0.00095617f, 0.09141409f, 0.17529234f, 
    -0.03589362f, 0.13627484f, -0.29578212f, -0.02051535f, 0.13891929f, 0.11010879f, -0.13686864f, -0.32376501f, 
    0.05586611f, -0.41066882f, 0.15431692f, -0.03695099f, -0.03952861f, 0.15457653f, 0.09936340f, -0.03892057f, 
    -0.15898637f, -0.01445982f, 0.13557124f, -0.24377137f, -0.38598853f, 0.07039084f, -0.21652439f, -0.05456440f, 
    0.13116252f, -0.00443070f, 0.20822446f, -0.12240864f, -0.26619899f, 0.07234775f, -0.03149214f, 0.09765583f, 
    -0.03295238f, -0.01884454f, 0.15714826f, 0.03663381f, 0.39969918f, -0.26895854f, -0.22307725f, -0.00123500f, 
    0.04862413f, 0.03870054f, 0.03776215f, 0.08944714f, -0.23322086f, 0.03388187f, 0.02008216f, -0.21876836f, 
    -0.38491824f, -0.09533788f, -0.09757028f, 0.16334790f, 0.00621627f, -0.02128197f, 0.60433346f, 0.25551310f, 
    -0.08636421f, -0.18670681f, 0.03947911f, -0.15059392f, -0.05847055f, 0.05206411f, 0.13740733f, 0.18428424f, 
    -0.26278332f, -0.22181898f, 0.00274849f, 0.13381347f, 0.13190727f, 0.03114927f, -0.17586067f, -0.09961900f, 
    -0.36694911f, 0.28077924f, 0.12270854f, -0.08345437f, 0.07341342f, -0.21037082f, 0.08955985f, 0.09133211f, 
    0.19745219f, -0.11363693f, -0.10132528f, -0.18028229f, -0.09627659f, 0.04403844f, 0.33222446f, -0.10849672f, 
    0.07752186f, -0.11379702f, 0.22228716f, -0.08078083f, -0.08059465f, 0.06028349f, 0.02844958f, -0.20350178f, 
    -0.08446991f, -0.12688507f, -0.24648486f, 0.03660243f, 0.13896291f, 0.10208449f, -0.02720738f, 0.09443462f, 
    -0.09212298f, 0.13999481f, 0.15209889f, -0.22305377f, 0.21550222f, -0.11090954f, -0.17848477f, 0.25693625f, 
    0.07188803f, 0.00853010f, -0.10577407f, -0.07990800f, -0.04387050f, 0.00136833f, -0.22976060f, -0.03546080f, 
    -0.09540936f, 0.06695431f, -0.11351351f, 0.10241534f, -0.03898382f, 0.12495907f, 0.17069247f, -0.02834662f, 
    -0.23964922f, 0.15655568f, -0.14947601f, 0.07535681f, 0.11353286f, 0.18650326f, -0.07118404f, -0.06162262f, 
    0.21027814f, -0.06614257f, -0.13696405f, 0.10629314f, 0.02755088f, -0.02391123f, -0.00246615f, -0.01700249f, 
    0.02487617f, 0.10549086f, -0.15360729f, -0.08752390f, 0.08212179f, 0.03857601f, 0.17952907f, 0.07699166f, 
    -0.12373989f, 0.43878326f, 0.10769460f, 0.10852415f, -0.21503907f, -0.11432380f, 0.03377784f, -0.08557532f, 
    0.03988739f, -0.01571448f, 0.06335633f, -0.15547095f, -0.08940360f, -0.07924568f, 0.09989944f, 0.11571129f, 
    -0.23602811f, -0.06173179f, -0.04593273f, 0.17659289f, -0.07502752f, 0.33881232f, -0.29798061f, -0.02083321f, 
    -0.20478338f, 0.02693079f, 0.07919654f, -0.00385746f, -0.34384772f, 0.13089378f, 0.06876369f, -0.17600511f, 
    0.07966148f, 0.06656673f, -0.18038012f, -0.05504151f, -0.20176789f, 0.19660379f, -0.08269062f, -0.18332876f, 
    -0.06318845f, -0.00918735f, 0.02590705f, -0.13929714f, -0.10775420f, 0.02066990f, 0.17736514f, 0.27511093f, 
    -0.16847035f, 0.11725696f, -0.17057414f, 0.06543775f, 0.16078289f, -0.06876424f, -0.08716010f, -0.11427782f, 
    -0.30318040f, -0.14825103f, -0.08946137f, 0.38288289f, 0.12481537f, 0.02698505f, 0.04004763f, -0.12658444f, 
    -0.34266669f, -0.22034836f, -0.15239544f, 0.08249849f, -0.01649262f, 0.02746090f, -0.04618409f, 0.13706325f, 
    0.18755089f, 0.19153994f, 0.08681591f, 0.25036839f, 0.03764325f, -0.06749861f, 0.05070008f, -0.02403581f, 
    0.14033042f, -0.15759824f, -0.22360741f, -0.40137747f, -0.12124299f, -0.12419522f, -0.19588636f, -0.08474888f, 
    -0.19337074f, -0.11714026f, -0.07693923f, 0.12578169f, -0.27519462f, 0.17510578f, 0.05303579f, 0.06606772f, 
    0.10442196f, 0.03635551f, 0.10663329f, 0.05136837f, 0.22826390f, 0.28832641f, 0.03044290f, 0.01039350f, 
    0.09093905f, -0.09935981f, 0.26018804f, -0.02586630f, -0.06327298f, 0.08154506f, -0.26793009f, -0.15238351f, 
    -0.14252423f, -0.02062906f, -0.07154228f, -0.00094938f, 0.08706932f, -0.02383874f, -0.21737172f, -0.33272496f, 
    0.23693883f, -0.08300889f, 0.10697389f, 0.17223038f, -0.15044151f, -0.09395675f, 0.03892741f, 0.08754923f, 
    -0.20109817f, 0.10792249f, 0.11915637f, 0.13054471f, 0.12268282f, 0.14647448f, 0.03508268f, 0.11008247f, 
    -0.25876001f, 0.30887219f, -0.04609536f, 0.11744925f, 0.06846324f, -0.08633488f, 0.09277830f, -0.13931897f, 
    -0.11369176f, -0.27708912f, 0.03047961f, -0.18294270f, 0.20712876f, -0.09044791f, 0.05899012f, -0.04918769f, 
    0.08014447f, 0.04628552f, 0.35563821f, 0.23385192f, -0.01647705f, -0.00187764f, -0.01965469f, 0.04773947f, 
    0.02057480f, 0.12784134f, -0.14523692f, -0.20881103f, -0.15225443f, -0.36222881f, 0.14913122f, 0.07605956f, 
    -0.06159211f, 0.15179747f, 0.02277530f, 0.02918858f, -0.09595548f, 0.28012496f, 0.11920847f, -0.13841823f, 
    -0.13359968f, -0.18552367f, 0.00845328f, -0.14114891f, 0.11179950f, 0.04955520f, -0.03277024f, -0.14995554f, 
    -0.13715598f, -0.16839723f, -0.04011554f, -0.20733590f, -0.10932987f, 0.19875969f, 0.50400519f, 0.39537010f, 
    0.28749993f, 0.10024226f, 0.18553121f, -0.06646554f, 0.11944509f, 0.16511722f, 0.09890114f, -0.41791815f, 
    -0.00987716f, -0.08043018f, -0.00407463f, -0.08959530f, 0.07867846f, 0.00240817f, -0.04523591f, -0.04449236f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.13826342f, 0.02081346f, 0.03332389f, -0.06769280f, 0.11850154f, 0.16068703f, -0.06983823f, -0.03449725f, 
    -0.03484481f, 0.18865325f, 0.13565980f, 0.23346254f, 0.30263007f, 0.17339614f, -0.10650744f, 0.02880104f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00883921f, -0.07812968f, -0.15072304f, 0.04665336f, -0.32116473f, -0.20388708f, 0.12064113f, 0.02177799f, 
    0.11673957f, -0.08432759f, -0.22561963f, 0.01482299f, -0.00939054f, -0.20800889f, 0.10551244f, -0.07985481f, 
    0.33938491f, -0.29251212f, 0.11182341f, -0.00512626f, 0.50313270f, -0.24307144f, -0.11272850f, 0.04308741f, 
    -0.13900386f, -0.15331724f, -0.16911285f, -0.34201017f, 0.41426310f, -0.29879147f, -0.39687759f, 0.64798784f, 
    0.04608798f, 0.27091035f, -0.07203683f, -0.44979039f, -0.42813608f, 0.27427611f, 0.56985152f, 0.02024456f, 
    -0.09223736f, 0.29546458f, 0.49248946f, -0.06455140f, 0.31871963f, 0.04896613f, 0.06280934f, -0.73208559f, 
    0.42716980f, -0.42246512f, 0.37267357f, 0.12272582f, 0.18301475f, 0.63818282f, 0.14036278f, -0.18982972f, 
    0.12456849f, -0.35582793f, -0.49126166f, -0.35924226f, -0.13174316f, 0.28121987f, -0.11272034f, -0.10325788f, 
    -0.05365514f, 0.06792998f, -0.20565741f, 0.05501473f, -0.24342987f, 0.01358119f, 0.13319707f, -0.21239027f, 
    0.04324886f, 0.12179441f, -0.27413100f, 0.02323054f, -0.01572529f, -0.24585496f, -0.13035980f, -0.23956026f, 
    -0.26272574f, 0.14001609f, 0.10473485f, 0.15477438f, -0.07712161f, -0.45114991f, 0.28270942f, -0.21339215f, 
    0.03000070f, -0.13382252f, 0.09000352f, -0.41955125f, 0.39693397f, 0.57369274f, 0.60664797f, -0.70293564f, 
    0.07390644f, 0.10407474f, -0.16094674f, -0.13378955f, 0.11642121f, -0.28405777f, 0.05981183f, -0.18188120f, 
    -0.13288963f, -0.10320924f, -0.22932020f, -0.13274114f, 0.03215970f, -0.13652991f, -0.07623868f, -0.15026560f, 
    0.43679115f, -0.31569633f, 0.43652654f, -0.35983980f, 0.14018714f, 0.12874958f, 0.13978145f, -0.08381502f, 
    -0.16507868f, -0.20830864f, -0.19563767f, -0.13814878f, 0.09248471f, 0.58311301f, 0.09840926f, -0.38833830f, 
    -0.08611095f, 0.14605220f, -0.10717990f, 0.15805307f, -0.33032998f, -0.64653641f, -0.52892363f, 0.00360847f, 
    -0.17681098f, 0.39900362f, 0.41399160f, 0.44123232f, 0.25647533f, -0.24330211f, 0.17726442f, 0.40640637f, 
    0.22091751f, -0.28649017f, 0.27998447f, 0.44769171f, 0.15810719f, 0.80671638f, -0.61101443f, -0.21230282f, 
    0.22369365f, 0.07912182f, -0.22878665f, 0.61393785f, 0.32041061f, 0.01749154f, -0.55022496f, -0.60995334f, 
    -0.00306296f, -0.13846429f, 0.06227345f, -0.12509409f, -0.20912580f, 0.02362464f, -0.15629290f, -0.23398691f, 
    0.21673536f, -0.09962287f, -0.03767331f, -0.24186039f, 0.04879362f, -0.24392925f, -0.24797203f, -0.24957070f, 
    0.20721222f, 0.29461384f, 0.36145708f, 0.24687214f, -0.13249002f, 0.43386042f, -0.26070160f, 0.13340272f, 
    -0.25301954f, -0.39426610f, -0.51506096f, 0.13907959f, -0.07968488f, 0.11230090f, 0.45548657f, -0.55642480f, 
    -0.69459057f, 0.25565955f, 0.01275943f, 0.27079597f, 0.08658846f, -0.15806580f, 0.55866665f, -0.01265256f, 
    -0.05712782f, -0.02734135f, -0.27953613f, -0.22148259f, 0.34394094f, 0.36351657f, 0.50651199f, -0.24694751f, 
    -0.12648386f, 0.09856489f, -0.00015468f, -0.07768977f, -0.38321176f, 0.34214839f, -0.03211252f, 0.08141724f, 
    -0.05504933f, -0.25537282f, -0.02152170f, 0.47760671f, 0.14915428f, 0.58928823f, -0.09037682f, -0.05607769f, 
    0.26690373f, 0.43199861f, 0.05438083f, 0.05214453f, 0.10377888f, 0.14648956f, 0.30509624f, 0.04793233f, 
    0.00168507f, 0.47102097f, 0.09804003f, 0.25107515f, -0.06373068f, -0.48003554f, -0.47115573f, 0.74457717f, 
    0.20917046f, 0.21770445f, -0.02685679f, 0.13076468f, -0.30144557f, -0.79163867f, 0.06883002f, 0.11927264f, 
    -0.10000957f, 0.39490330f, 0.73215258f, 0.05417603f, 0.30852866f, 0.09160259f, 0.03303524f, -0.19995880f, 
    0.33130923f, 0.23913334f, 0.37967214f, -0.11921188f, -0.45253736f, 0.38412330f, 0.45604438f, -0.06608466f, 
    0.17650922f, 0.24157675f, 0.08520881f, 0.45690387f, -0.19690865f, -0.01156534f, -0.32346299f, -0.46992749f, 
    0.04507374f, 0.32112345f, 0.17443246f, 0.15335396f, -0.10170219f, 0.78553540f, 0.23115413f, -0.05772087f, 
    -0.23058265f, -0.12303016f, -0.54454392f, 0.10615171f, -0.16408432f, -0.24595271f, 0.37541038f, 0.11462232f, 
    0.36220881f, 0.50889242f, 0.15127051f, -0.18762079f, -0.43011352f, -0.52238810f, -0.21889181f, -0.04618423f, 
    -0.24086414f, 0.20598513f, -0.31643915f, -0.17361854f, 0.43519655f, 0.07710525f, 0.66884112f, 0.06722034f, 
    0.35979450f, 0.22346665f, -0.22539486f, 0.46471411f, 0.34451863f, -0.34311944f, -0.66421425f, 0.22505587f, 
    -0.13647385f, -0.11619527f, -0.14752093f, 0.18607453f, 0.43668848f, -0.22402956f, 0.61366427f, -0.16846144f, 
    -0.10337959f, 0.04958637f, -0.16970345f, 0.18960051f, 0.20695291f, -0.48344153f, 0.20468003f, -0.19119608f, 
    -0.22772554f, 0.36434343f, -0.13330989f, 0.21679854f, -0.18016250f, -0.22112863f, 0.23277077f, -0.32852870f, 
    0.00079543f, -0.18467270f, -0.01389183f, -0.13567367f, -0.02719447f, -0.00628092f, 0.19499891f, 0.08690494f, 
    0.22719052f, 0.03609014f, 0.05610281f, 0.03305498f, -0.27547967f, -0.15244527f, 0.01692575f, 0.02332430f, 
    -0.15581563f, -0.35351774f, 0.01703140f, 0.62449753f, -0.30153289f, 0.03141423f, 0.19701265f, 0.00039488f, 
    0.15836817f, 0.52158195f, 0.74171287f, 0.09491593f, 0.11482280f, -0.14543691f, -0.20893601f, -0.26565793f, 
    0.00842422f, -0.38884825f, 0.23354787f, 0.61749625f, 0.14890654f, 0.26969084f, -0.59960347f, 0.09464482f, 
    -0.22856143f, -0.32008129f, 0.42610070f, -0.20368363f, 0.46294269f, 0.20350489f, -0.12327938f, 0.02904373f, 
    0.28071672f, -0.00439317f, 0.02693235f, 0.17843676f, 0.52518827f, -0.66153806f, 0.50022030f, 0.18194351f, 
    -0.03197119f, 0.00358294f, 0.12398171f, 0.52473074f, -0.19823596f, -0.13747698f, -0.28752863f, -0.15211800f, 
    0.11381023f, -0.08518435f, 0.14946149f, 0.20005198f, 0.05945580f, 0.38471022f, -0.51545954f, 0.10279637f, 
    -0.03245400f, 0.12844266f, 0.29054356f, 0.87533069f, -0.06039349f, 0.06088800f, 0.20276795f, -0.51233584f, 
    -0.05365606f, 0.37634927f, 0.30283600f, -0.16345730f, 0.52621418f, -0.30043173f, -0.01034074f, -0.06612344f, 
    0.05253778f, -0.11299190f, -0.43862668f, -0.33177343f, -0.02100123f, 0.23646878f, -0.18804663f, 0.58285362f, 
    -0.23801747f, 0.30304393f, -0.20171188f, -0.40229374f, -0.13596290f, -0.01284494f, 0.49952960f, -0.08178520f, 
    -0.13904810f, 0.34753153f, 0.35777226f, 0.31381384f, -0.15107761f, 0.60337853f, 0.13862537f, 0.45919719f, 
    0.44751570f, 0.39538887f, -0.02306870f, -0.28068051f, 0.01988722f, -0.13367537f, -0.20742518f, 0.23369172f, 
    0.17598459f, 0.12852906f, 0.04042661f, 0.39276624f, -0.24959446f, 0.66879833f, 0.36442506f, -0.10702111f, 
    0.04133400f, 0.25364316f, -0.33659229f, 0.01135567f, -0.16838051f, -0.27468732f, -0.27621445f, -0.21172275f, 
    0.10386731f, 0.18064860f, 0.39908463f, 0.33677140f, 0.13134891f, 0.49215525f, 0.50320584f, 0.20529589f, 
    0.46329352f, -0.07112624f, 0.35177886f, -0.28970861f, 0.41775748f, 0.06530517f, -0.02268047f, -0.05075407f, 
    -0.03687597f, -0.33840004f, -0.26689196f, -0.05207925f, -0.16295306f, 0.19811885f, -0.21518196f, 0.14673825f, 
    -0.33780459f, -0.55773699f, 0.07859298f, 0.10063506f, 0.76474392f, 0.49770108f, 0.09026694f, -0.15627934f, 
    0.02213615f, -0.20483713f, 0.33386233f, -0.11270943f, 0.31891814f, 0.23284589f, -0.06358624f, 0.05315952f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12538512f, 0.13521571f, 0.28608122f, 0.06349846f, 0.08381164f, -0.14879826f, -0.09971002f, 0.09109578f, 
    0.19966273f, 0.40585479f, 0.16576099f, 0.00055221f, -0.22699663f, 0.28169087f, 0.28726631f, 0.44437155f, 
    0.21373868f, -0.51758534f, 0.31551918f, -0.03522122f, -0.09380997f, -0.25949514f, -0.02212967f, 0.36714903f, 
    -0.38195077f, 0.19474533f, -0.17061087f, -0.07347088f, 0.14492816f, -0.19060442f, 0.24823867f, 0.30534106f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03166251f, -0.36096150f, -0.19150184f, 0.02406816f, 0.05828318f, -0.16428432f, -0.07254864f, 0.26123166f, 
    0.01344568f, -0.05203705f, 0.06343736f, 0.28224555f, -0.30273983f, 0.41946009f, 0.10960777f, -0.08860524f, 
    0.44411612f, -0.08868530f, 0.16702206f, -0.33732831f, -0.07437889f, 0.02744861f, -0.29296497f, -0.11922693f, 
    0.03334030f, 0.25444093f, 0.02052519f, 0.38620546f, 0.64880615f, 0.24232644f, 0.07862956f, -0.54339623f, 
    0.09818571f, 0.10997888f, 0.44061121f, -0.00167666f, -0.11490142f, -0.22770326f, 0.03496134f, -0.37323830f, 
    0.29561976f, 0.25089788f, 0.10678899f, -0.23553284f, -0.14569883f, 0.02363203f, 0.51893717f, 0.15468283f, 
    0.40147766f, 0.35653573f, -0.17564769f, -0.29599231f, -0.12097552f, 0.07097992f, 0.24367169f, -0.05527577f, 
    0.00409652f, 0.11419137f, -0.17708005f, -0.08199622f, -0.64833099f, -0.54112685f, -0.03530474f, -0.43050310f, 
    -0.00063382f, -0.15597607f, 0.10910371f, -0.09720661f, -0.02777384f, 0.38550910f, -0.11686012f, -0.00272163f, 
    0.12861034f, 0.12190598f, 0.12916398f, 0.40466771f, -0.09165363f, 0.16329753f, 0.22566804f, 0.48315549f, 
    0.33756724f, -0.04359067f, 0.62570316f, 0.48923096f, 0.03389412f, -0.11295639f, -0.20355839f, -0.02512440f, 
    -0.40584889f, -0.09329297f, 0.06067977f, -0.27110460f, 0.34072375f, 0.26768640f, -0.16030772f, -0.61135215f, 
    -0.20016287f, -0.12435068f, -0.92078096f, 0.54740971f, 0.07263803f, 0.19295157f, -0.00136317f, 0.39486301f, 
    -0.38490507f, 0.23191075f, -0.15481970f, 0.71056837f, 0.19610776f, 0.14345081f, -0.02172937f, -0.22207688f, 
    0.07698248f, 0.43359569f, -0.11786747f, -0.03528681f, -0.05066078f, -0.05409807f, -0.05904620f, 0.15493770f, 
    -0.08791396f, 0.22909239f, -0.13133161f, -0.31920385f, 0.20511836f, -0.20456539f, 0.32984814f, -0.05052632f, 
    0.03173475f, -0.35687274f, -0.66796851f, -0.02785590f, -0.19022697f, 0.07083002f, 0.00939101f, -0.02535686f, 
    0.13535959f, 0.23975734f, -0.17223415f, 0.18362288f, 0.10068985f, 0.47266009f, -0.21505998f, -0.20750710f, 
    0.08409043f, -0.00917391f, -0.38962948f, -0.17762436f, 0.07800762f, -0.09727147f, -0.06083907f, 0.05616282f, 
    0.11795535f, 0.39718822f, -0.18106119f, 0.36337152f, 0.46999425f, 0.23670390f, 0.16852863f, 0.25172025f, 
    0.03968854f, 0.46485391f, -0.14273059f, 0.27503574f, 0.08303489f, 0.02806622f, 0.03086098f, 0.27669904f, 
    0.04529020f, 0.32898200f, -0.00420890f, 0.40847504f, -0.06064839f, 0.04050815f, -0.08351046f, 0.07718085f, 
    0.13972624f, 0.04062577f, 0.43512708f, 0.21729018f, 0.09993658f, 0.05380609f, -0.10367998f, 0.20886470f, 
    -0.36093390f, 0.01699167f, 0.24210569f, -0.58519256f, -0.43781769f, -0.55565882f, 0.08004005f, 0.14242603f, 
    0.13407458f, -0.05095297f, -0.09066952f, 0.09407254f, -0.06114439f, -0.20017198f, 0.08435316f, 0.11507736f, 
    -0.04776754f, 0.10465664f, -0.00146781f, -0.07728641f, -0.02647113f, 0.00505738f, -0.05659389f, -0.12747543f, 
    -0.12105509f, -0.01806613f, -0.07158655f, 0.06396952f, 0.07820956f, -0.00976844f, 0.05525186f, -0.18514298f, 
    -0.00412592f, 0.12545535f, 0.02909752f, -0.04201493f, 0.03300204f, 0.04347437f, -0.11343447f, -0.18437383f, 
    -0.14156269f, -0.15188041f, -0.12778738f, -0.10565288f, 0.03467701f, 0.09035646f, 0.11751641f, -0.21318643f, 
    -0.22570646f, -0.10051501f, 0.11519397f, -0.00388651f, -0.20234172f, -0.17298226f, -0.14975910f, -0.03176665f, 
    -0.17020136f, -0.00908286f, -0.01349598f, 0.05472531f, 0.12918025f, -0.12605429f, -0.01753553f, 0.02517728f, 
    0.12703739f, -0.03514412f, -0.15885760f, -0.12936164f, 0.09148531f, -0.06968810f, -0.02428665f, 0.11244606f, 
    0.12520228f, -0.13790351f, 0.10671249f, -0.10825919f, 0.07881033f, -0.00441598f, 0.15053228f, -0.09786753f, 
    -0.07995668f, -0.14889525f, 0.12376443f, -0.16475028f, -0.15398304f, 0.13405563f, -0.10723174f, -0.12114846f, 
    -0.03365055f, 0.04260315f, -0.07967621f, -0.16633995f, -0.14414378f, 0.08849620f, -0.11348256f, -0.12722458f, 
    -0.04853005f, -0.10662508f, 0.14452352f, -0.09476472f, -0.07374687f, 0.01995917f, 0.02288268f, 0.05773766f, 
    0.15075915f, 0.04951994f, -0.11241177f, -0.10443277f, -0.01251525f, 0.00945924f, 0.14355905f, -0.08950594f, 
    0.10982874f, -0.18733501f, 0.03008986f, 0.05432333f, 0.00632568f, -0.16081670f, -0.02332733f, -0.11255492f, 
    0.13860352f, 0.10574628f, -0.19786207f, -0.00816930f, -0.13447718f, -0.07008738f, -0.02356322f, -0.12472555f, 
    -0.14833672f, 0.07749261f, 0.01771055f, -0.04573324f, 0.14869034f, -0.04561856f, -0.12334925f, 0.05517871f, 
    -0.11594183f, 0.26042262f, -0.14202973f, -0.21249533f, -0.00883931f, 0.02978750f, 0.13769923f, 0.19208366f, 
    0.39705011f, 0.19867252f, -0.01734459f, -0.00940027f, -0.39216405f, 0.01801669f, -0.05775362f, 0.23776238f, 
    -0.06031868f, -0.44830388f, 0.43411517f, 0.30429929f, 0.07288212f, 0.10093461f, -0.24588616f, 0.07871646f, 
    0.12852387f, 0.29670712f, 0.05313054f, -0.33984736f, 0.29550624f, 0.54513884f, 0.25921747f, -0.22452630f, 
    0.00421960f, -0.49425954f, 0.51678020f, -0.70284653f, -0.00704024f, 0.06848773f, -0.10754664f, -0.14072588f, 
    0.34394357f, 0.11179926f, -0.16790950f, -0.02373982f, 0.20778424f, 0.14265205f, 0.10881243f, 0.19263147f, 
    0.33554751f, 0.13542293f, 0.00174347f, 0.05773859f, 0.02297051f, 0.15364033f, 0.20719028f, -0.28643650f, 
    0.20439352f, 0.20773841f, -0.46985888f, 0.56255853f, 0.37899444f, 0.11991800f, -0.48345008f, -0.06666522f, 
    0.10695400f, 0.23596548f, 0.16232003f, -0.20428495f, -0.15010515f, -0.30348817f, -0.03755918f, 0.06122384f, 
    0.38841143f, 0.17347613f, 0.00247515f, -0.31299782f, -0.40231380f, -0.09937677f, 0.15068667f, 0.27844059f, 
    -0.05787125f, -0.56003565f, -0.11907946f, 0.08998343f, 0.01868677f, 0.08807897f, 0.21100770f, 0.14536950f, 
    0.32780722f, 0.22939657f, 0.15672597f, -0.05512680f, 0.18206431f, 0.24736805f, 0.01500552f, -0.03632872f, 
    -0.17444710f, 0.57268035f, -0.19387470f, 0.03537693f, 0.04303857f, 0.15323292f, -0.05668024f, -0.13984621f, 
    0.12379123f, -0.08271040f, 0.07224742f, -0.40484312f, 0.51399833f, -0.45000046f, 0.32133436f, 0.14494118f, 
    -0.42583150f, -0.34681389f, -0.06872948f, 0.03457580f, 0.14526536f, -0.05675939f, 0.45583051f, 0.25327551f, 
    0.30831811f, -0.24307793f, 0.50896108f, 0.19689429f, -0.59257859f, 0.01598729f, 0.13758850f, 0.54349500f, 
    -0.10915270f, 0.23832633f, -0.23332885f, 0.01883692f, -0.17213868f, 0.05826804f, -0.03514363f, 0.07502393f, 
    0.03268109f, 0.14652681f, 0.06687775f, 0.75546068f, 0.32441148f, -0.26070157f, -0.14718276f, -0.02942394f, 
    -0.26380351f, 0.39439219f, 0.25097224f, 0.92060882f, -0.19632499f, -0.01235507f, -0.00406984f, 0.10986514f, 
    0.48009250f, 0.17908937f, 0.08709794f, -0.33858851f, 0.01210117f, 0.24683084f, -0.07568923f, 0.10186382f, 
    -0.08788463f, 0.11947925f, -0.18152642f, -0.17062698f, 0.09010354f, 0.08921552f, 0.07910103f, -0.05317922f, 
    0.11675844f, -0.12370642f, -0.10371452f, -0.14786355f, -0.19180954f, 0.12870651f, -0.13388978f, -0.07721727f, 
    -0.05357387f, 0.06334694f, 0.03631899f, 0.15315199f, -0.12855844f, -0.00632892f, 0.08990108f, -0.16790621f, 
    -0.09031145f, -0.07095169f, -0.07848442f, -0.10325290f, -0.12442314f, -0.01307890f, -0.02104465f, 0.13872060f, 
    -0.06163898f, 0.06421507f, 1.04899609f, -0.32807136f, 0.05295846f, 0.31769416f, 0.01159846f, -0.30396661f, 
    0.59524131f, 0.30794472f, -0.15980829f, -0.19977993f, 0.16024551f, 0.25353068f, 0.19688627f, 0.17700864f, 
    -0.19411521f, -0.25425151f, -0.09932538f, 0.23116633f, -0.06603607f, -0.05010101f, 0.48922077f, 0.43885288f, 
    -0.44399884f, 0.32870230f, -0.17631157f, 0.26388714f, -0.21700525f, 0.20311932f, -0.26812708f, 0.54660946f, 
    0.00034675f, -0.03226341f, -0.42879701f, 0.42600426f, 0.02110405f, -0.05820931f, -0.01315342f, 0.23617506f, 
    -0.48473394f, 0.14080234f, -0.01145849f, 0.18564199f, 0.09149263f, -0.01723557f, 0.31444725f, -0.18077862f, 
    0.26613435f, 0.41956431f, -0.37955654f, -0.47328442f, 0.41913679f, 0.14136453f, 0.01708043f, -0.13274641f, 
    0.18423828f, 0.02426817f, 0.43897733f, 0.54082090f, 0.21478720f, -0.37902540f, 0.47571909f, 0.55696541f, 
    0.04835571f, -0.06665362f, 0.02334936f, 0.36153132f, 0.04849450f, 0.35922086f, 0.11313464f, 0.35016918f, 
    -0.52843112f, 0.34454522f, -0.03173291f, 0.21007855f, 0.55572093f, 0.14969863f, -0.26841095f, -0.00299819f, 
    -0.06997567f, -0.01693723f, -0.19474420f, -0.18840034f, 0.37017336f, -0.02964822f, 0.15473285f, 0.38111413f, 
    -0.73098904f, 0.12476536f, -0.11848287f, -0.33993489f, -0.32576227f, -0.32080910f, -0.13452467f, 0.57556093f, 
    -0.04374101f, 0.27467507f, -0.06970020f, 0.26202980f, -0.09852380f, -0.39776805f, -0.01460904f, -0.05587954f, 
    -0.16812466f, 0.05340275f, -0.05387096f, -0.12623377f, -0.28310516f, 0.23995577f, 0.21975167f, -0.25521299f, 
    -0.01066136f, 0.52968782f, 0.34371293f, -0.10366674f, -0.18575349f, -0.06096622f, -0.84444189f, -0.01918113f, 
    -0.13960408f, -0.24365839f, 0.67588454f, 0.46433568f, 0.29763871f, 0.04628238f, 0.29592821f, -0.13469520f, 
    -0.10423090f, -0.07070156f, 0.15541878f, -0.00674148f, -0.13581541f, -0.07691164f, 0.04023422f, -0.18667555f, 
    -0.04560022f, -0.08974178f, 0.07629294f, 0.13611466f, 0.07951847f, 0.13879353f, 0.04896820f, 0.03536162f, 
    -0.20064332f, 0.03025674f, -0.16805784f, 0.08844784f, 0.02942423f, -0.04313047f, -0.02925742f, -0.09484912f, 
    -0.00180145f, 0.09344390f, -0.01306257f, -0.05124649f, 0.03770698f, -0.02287165f, 0.14263839f, -0.13745932f, 
    -0.02093196f, -0.08731731f, 0.03222868f, 0.14946747f, -0.00881499f, -0.04800568f, 0.07779887f, -0.12424166f, 
    -0.17333791f, 0.10459762f, -0.12754907f, -0.13969845f, -0.12294876f, 0.14337406f, -0.13782230f, -0.06462397f, 
    0.09496511f, -0.17546074f, 0.11576919f, -0.06829720f, 0.03439996f, -0.10958878f, -0.16633135f, -0.05116256f, 
    0.03812730f, -0.15944761f, 0.15338673f, -0.15633792f, -0.11577423f, 0.13110302f, -0.04199236f, 0.05503890f, 
    -0.08259899f, 0.13698237f, -0.14197101f, 0.04237286f, -0.10207233f, 0.05787484f, 0.12455390f, -0.08655455f, 
    0.05099743f, -0.12256005f, 0.08556803f, 0.10347555f, -0.11062278f, 0.04366962f, -0.11524436f, 0.09725476f, 
    0.09306013f, -0.09137186f, -0.17362754f, -0.02493111f, -0.03331091f, 0.04938738f, 0.05604131f, -0.11997036f, 
    -0.19128548f, 0.14532578f, -0.09169590f, 0.13567235f, -0.05121614f, -0.14788561f, -0.04266904f, -0.08594477f, 
    0.22518860f, -0.15121630f, 0.22050855f, 0.16877887f, -0.11199991f, -0.33341300f, -0.11487282f, 0.08385237f, 
    0.08789027f, 0.33852696f, 0.02769198f, 0.22069025f, -0.60496241f, 0.04326015f, 0.22034138f, -0.00415802f, 
    0.42088827f, 0.38572091f, -0.13733937f, 0.03538508f, -0.07357934f, 0.14997940f, 0.15498801f, -0.17699066f, 
    0.73883098f, 0.08419844f, -0.08201424f, -0.23191057f, 0.33919051f, 0.18951458f, 0.19390544f, -0.44843647f, 
    0.08926114f, -0.11138698f, -0.46704179f, 0.23404050f, -0.03605294f, 0.44538864f, -0.08639891f, 0.54630858f, 
    -0.04024106f, 0.12410471f, 0.14062254f, 0.01268267f, -0.00934055f, 0.04655813f, -0.20920739f, 0.47302306f, 
    0.27695295f, -0.55611748f, 0.24982390f, -0.23549858f, 0.32647943f, 0.08284019f, -0.10647432f, 0.00854714f, 
    0.20700093f, 0.05079708f, -0.00359189f, 0.30657107f, 0.87462699f, 0.45219216f, 0.40119243f, -0.19062498f, 
    -0.08221092f, -0.43620205f, 0.70510882f, 0.20451795f, 0.12993740f, 0.42871583f, 0.12278393f, 0.34025687f, 
    -0.52934349f, -0.00509648f, -0.03144705f, 0.06383418f, 0.33997419f, 0.23411912f, -0.20746011f, 0.09972284f, 
    0.37945896f, -0.21614926f, 0.13448255f, -0.74941492f, -0.05058502f, 0.17644860f, 0.06823918f, -0.07836002f, 
    0.26305804f, -0.04725460f, -0.09448027f, 0.41400132f, 0.01474967f, -0.53351015f, 0.14592135f, 0.08765391f, 
    0.15768400f, -0.06211079f, 0.59061569f, -0.08503474f, -0.02775013f, 0.13384962f, 0.01915316f, -0.19500513f, 
    0.22136901f, 0.04144197f, 0.06092117f, -0.21120010f, 0.03843740f, -0.12781741f, 0.14658816f, 0.25444853f, 
    0.10622561f, -0.07519653f, 0.12396806f, 0.08363396f, 0.02398291f, -0.12909082f, 0.24840803f, 0.32172972f, 
    -0.08448190f, 0.07593700f, -0.02038892f, -0.10418376f, 0.05136698f, 0.26817188f, -0.20822440f, -0.08708113f, 
    0.09197342f, 0.57251120f, 0.08189827f, 0.69822580f, 0.10493326f, -0.26191536f, 0.00485887f, 0.37296882f, 
    -0.55407959f, 0.18472421f, 0.03229044f, -0.33858714f, -0.70449728f, -0.43874493f, 0.03228273f, -0.21358801f, 
    -0.01669999f, -0.15777402f, -0.22160202f, -0.10988687f, -0.02602010f, 0.07036089f, 0.05420977f, 0.19952974f, 
    0.07001636f, -0.25710675f, 0.14360352f, -0.10357177f, -0.16594382f, -0.28050494f, 0.29863462f, 0.58914953f, 
    0.12276298f, -0.03854797f, 0.02854307f, 0.07081605f, -0.01323185f, 0.10056745f, 0.07795787f, -0.18601252f, 
    0.03645699f, 0.04966042f, -0.04659861f, -0.07346991f, -0.07321909f, -0.15400197f, -0.02651355f, 0.04987739f, 
    0.09813271f, 0.03747373f, -0.13559468f, -0.01780385f, -0.12156898f, -0.01030324f, -0.12042639f, -0.14504322f, 
    0.11695805f, -0.17507984f, -0.16631684f, -0.07249742f, 0.05981236f, 0.07308538f, 0.01860413f, 0.01069274f, 
    -0.00337716f, -0.19823620f, -0.10146164f, 0.03441907f, 0.16696082f, -0.07188934f, -0.06099580f, 0.08413316f, 
    0.14296751f, -0.09043202f, 0.06310717f, 0.04280152f, -0.00101356f, -0.16442581f, -0.17442560f, -0.01313974f, 
    -0.09494205f, 0.10271045f, 0.03758869f, -0.17487395f, 0.13655813f, -0.13103351f, -0.14823569f, 0.01414121f, 
    0.12575316f, 0.13418898f, -0.02391911f, -0.16473903f, -0.05272178f, 0.02593510f, -0.10670909f, -0.06383364f, 
    -0.18668760f, -0.13518073f, -0.23802736f, 0.28028649f, 0.09266709f, -0.22753488f, 0.05074735f, -0.03683928f, 
    -0.16864181f, 0.42963025f, -0.05835570f, 0.70526963f, -0.43286908f, 0.06266002f, -0.15110943f, 0.02129947f, 
    0.24936837f, -0.08194365f, -0.39275214f, 0.31335840f, 0.12560712f, 0.11425268f, 0.09621482f, 0.17762852f, 
    0.14287516f, 0.56689543f, -0.57987046f, -0.95267445f, 0.05471405f, -0.45514703f, 0.15638876f, 0.25376421f, 
    0.13804223f, -0.31674796f, 0.73581254f, 0.05839025f, 0.06687088f, 0.50204206f, -0.02404078f, -0.11769079f, 
    -0.11240015f, 0.29478478f, 0.16209216f, 0.46666589f, 0.65216357f, 0.17438282f, 0.03870552f, 0.18038194f, 
    0.27942243f, 0.34457833f, 0.03201163f, 0.36762318f, 0.30203980f, -0.02241476f, 0.36944357f, 0.03646031f, 
    -0.08743428f, 0.38076988f, -0.46526027f, -0.35018727f, -0.41188085f, -0.48147300f, -0.23232485f, 0.06155299f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05133674f, 0.52061278f, 0.22677143f, -0.02103109f, 0.11555844f, 0.41748735f, -0.14767225f, -0.09490806f, 
    -0.02504530f, -0.12561212f, 0.42250305f, 0.10631097f, 0.52031934f, 0.18498053f, -0.48442268f, -0.17493390f, 
    0.20809963f, -0.01077427f, 0.04950878f, -0.24329732f, -0.20049934f, -0.13643242f, -0.14529382f, -0.02162979f, 
    0.21989562f, 0.16649823f, 0.01525724f, 0.34969234f, -0.12893240f, -0.10482325f, 0.21719544f, 0.02466284f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.77768332f, -0.01927118f, 0.21591912f, 0.16425444f, -0.76535136f, 0.35271963f, -0.15140559f, 0.13492291f, 
    0.05956464f, -0.08704317f, 0.18720888f, -0.45530611f, -0.06279887f, 0.41080397f, 0.27956152f, -0.06417593f, 
    0.15166621f, -0.26264915f, 0.19469532f, -0.73223305f, -0.00874211f, -0.15910603f, 0.15184049f, -0.93095350f, 
    0.00736174f, -0.46497467f, 0.01016630f, -0.33887431f, -0.05473679f, 0.01991787f, -0.33597383f, 0.08309244f, 
    0.02146721f, -0.51538455f, 0.20319769f, -0.58365989f, -0.33961633f, -0.25408837f, -0.02535238f, -0.01496297f, 
    -0.00217398f, 0.12389804f, 0.17280354f, 0.31847084f, 0.10605250f, -0.06420973f, 0.14744149f, -0.04922045f, 
    0.36385557f, -0.29893276f, -0.05609171f, 0.48943123f, 0.12726843f, -0.04500649f, 0.03757247f, -0.34122309f, 
    -0.05604617f, -0.20166713f, 0.22296272f, -0.07087330f, -0.04782562f, 0.14477143f, -0.26009008f, 0.10410697f, 
    0.25989261f, -1.05959737f, 0.02286263f, 0.23425755f, 0.27182573f, -0.30461177f, 0.07584830f, 0.10828432f, 
    -0.07450181f, 0.14306930f, -0.24013527f, -0.12649831f, -0.39914617f, -0.45325693f, -0.16442531f, 0.04129027f, 
    -0.03356105f, 0.10499403f, 0.47641838f, -0.39762327f, 0.06609193f, 0.01986887f, -0.04710316f, -0.37474304f, 
    0.36066404f, 0.51132035f, 0.11741531f, 0.00582329f, 0.03481512f, 0.08690587f, -0.28846511f, 0.01999018f, 
    -0.10261969f, -0.46096009f, -0.15365724f, 0.30051026f, -0.19512412f, -0.09088084f, 0.01622177f, -0.07747335f, 
    -0.06400345f, 0.05064888f, 0.19309257f, 0.55690163f, 0.16335838f, -0.11429762f, 0.14690036f, 0.05146424f, 
    -0.74812526f, 0.26876894f, -0.18456164f, -0.00568689f, -0.08400720f, -0.13768347f, 0.16621828f, 0.22059996f, 
    0.23005806f, -0.77247274f, -0.24298744f, 0.38818151f, 0.13765848f, 0.02986417f, 0.13227905f, -0.66536969f, 
    -0.39760563f, 0.27327883f, -0.19063678f, -0.10339508f, -0.20225036f, 0.09421019f, -0.03006229f, -0.14281075f, 
    -0.06761787f, -0.14584503f, -0.15621999f, -0.21395198f, 0.18924443f, 0.25093055f, -0.14238599f, 0.08027669f, 
    0.06131613f, 0.05682700f, -0.01407040f, -0.72761303f, -0.19361271f, -0.06792076f, -0.02218357f, -0.00365671f, 
    -0.02459507f, 0.43850073f, 0.07824583f, 0.45006713f, -0.08410677f, -0.02787772f, 0.19080320f, 0.06087787f, 
    -0.09827509f, 0.24646027f, 0.07608784f, -0.39249855f, -0.43575519f, 0.14957911f, -0.07024804f, 0.06474764f, 
    0.12306974f, -0.16432862f, 0.18701147f, 0.14837657f, 0.29679045f, 0.08421151f, 0.01791959f, -0.08417840f, 
    0.33754137f, -0.90282214f, -0.53657579f, -0.26740122f, 0.04177378f, 0.00258451f, 0.13188469f, 0.10420587f, 
    -0.39933649f, 0.20132130f, 0.03957380f, -0.25220087f, -0.28261873f, 0.03514162f, 0.11015064f, 0.02878010f, 
    0.20414506f, 0.13712500f, -0.08227270f, 0.26155603f, 0.40106913f, -0.09103713f, 0.00809948f, 0.07071345f, 
    -0.12836623f, -0.05083533f, 0.15646864f, -0.02610639f, 0.17488487f, -0.41138795f, 0.08271633f, 0.14105158f, 
    -0.02968658f, -0.20648336f, -0.00552956f, -1.16176617f, -0.12044503f, -0.11610030f, 0.07952026f, 0.07569912f, 
    -0.09967896f, -0.76980460f, -0.09139203f, -1.07127905f, -0.04333441f, -0.05396424f, 0.55414182f, 0.01271077f, 
    0.21316060f, -0.44387552f, -0.79528886f, -0.49969050f, 0.29341733f, 0.10062937f, -0.15482239f, -0.11195460f, 
    -0.15349498f, 0.07239290f, -0.14381829f, 0.75963104f, -0.11977941f, 0.61722916f, 0.02617577f, -0.13354595f, 
    -0.09342917f, 0.41118675f, -0.55870962f, 0.28395426f, 0.08465320f, 0.17232934f, -0.03385488f, -0.51240081f, 
    -0.43498853f, -0.30333558f, -0.59177548f, 0.47170311f, 0.12837383f, -0.04626565f, -0.42414388f, -0.09375192f, 
    0.33716682f, 0.55649024f, 0.04255464f, -0.34925470f, -0.72274768f, -0.85765737f, -0.08633813f, 0.06195740f, 
    -0.03447985f, -0.00894397f, -0.54772007f, 0.41960344f, -0.20573087f, 0.21416797f, -0.60047853f, 0.02465614f, 
    -0.00333624f, 0.14015390f, -0.67441249f, -0.03855335f, -0.17763111f, 0.04887631f, -0.04632727f, 0.17871553f, 
    -0.18758224f, 0.26178965f, 0.10427284f, -0.85558784f, -0.06571791f, 0.03770231f, -1.00304675f, 0.12423726f, 
    -0.39601094f, 0.39200053f, -0.23915899f, 0.28481692f, -0.04769491f, 0.07601051f, -0.16312300f, -0.10164148f, 
    -0.06615203f, 0.06011241f, -0.39841789f, -0.04184081f, -0.28391376f, -0.40207639f, -0.12151042f, -0.19015685f, 
    0.25928417f, 0.07875443f, 0.49986178f, -0.07802800f, -0.07789687f, -0.16229217f, 0.04720253f, -0.24254079f, 
    -0.62108135f, 0.03494629f, 0.03835065f, 0.32072955f, -0.27659830f, 0.09586872f, 0.37725115f, 0.25327033f, 
    0.31758124f, 0.09753095f, 0.08221377f, -0.14498036f, 0.55074269f, 0.20253235f, 0.14265774f, -0.00808524f, 
    0.17353632f, 0.09047928f, 0.28622654f, -0.16992237f, 0.14024545f, -0.36011508f, -0.49990577f, -0.04185998f, 
    -0.19152986f, 0.15226556f, -0.55773515f, 0.24570300f, -0.11161169f, 0.02961815f, -0.01151714f, -0.09119290f, 
    0.40549624f, -0.66296619f, -0.16056845f, 0.20873670f, -0.16859370f, -0.07144497f, -0.73111141f, -1.21919620f, 
    0.27120468f, -0.04206902f, 0.19017212f, 0.35916823f, -0.18407497f, 0.24744824f, 0.12816381f, 0.01733112f, 
    -0.04133223f, 0.06953759f, -0.09575678f, -0.83551526f, -0.45693421f, -0.92724746f, 0.24559827f, -0.09200804f, 
    -0.73748237f, 0.29115710f, -0.28749904f, -0.00184564f, 0.07681259f, -0.10008519f, -0.09009993f, 0.25513190f, 
    -0.06547302f, -0.25688013f, -0.17843620f, -0.61364061f, -0.16793740f, 0.08617811f, 0.38167116f, -0.02887845f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.04823146f, -0.26205754f, -0.34746683f, -0.33109358f, 0.10399005f, 0.10733311f, 0.11263463f, -0.38421181f, 
    -0.12656173f, -0.11461885f, 0.74674398f, -0.27493018f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
