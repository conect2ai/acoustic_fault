#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.92584860f, 0.62040001f, -0.07342633f, -0.16401058f, 1.00190115f, 0.46280381f, -0.63287282f, -0.07399545f, 
    -0.07285722f, 0.80483276f, -1.31225467f, 0.04386038f, 1.25644636f, 1.19422972f, 0.67986178f, -0.68431318f, 
    -0.19320302f, -0.27577376f, -1.19397819f, 1.86985409f, -0.99801403f, 1.08394492f, -0.06819754f, 0.10809465f, 
    0.14285769f, -0.25265917f, -0.42525232f, 1.27048612f, -0.07472311f, 1.58676898f, 1.33635414f, -0.88470322f, 
    0.25665712f, -0.26515433f, -0.15732071f, -0.52210104f, 1.86269808f, 1.08106124f, 0.45334175f, -1.47386813f, 
    -0.02491786f, -0.79624850f, 0.02341385f, 0.36058614f, -0.16295877f, 0.87525564f, 1.14211214f, 1.20052087f, 
    0.51133567f, 0.83020854f, -0.04222716f, 0.18917182f, 0.99626130f, 0.15391842f, -0.54329175f, 0.10182800f, 
    1.41812694f, -1.24104142f, 1.14694393f, 0.71392471f, -0.33955011f, 0.48518825f, 0.66761994f, -0.40835270f, 
    -0.88968915f, -0.40098232f, -0.52404040f, 1.39638209f, -0.58367538f, -0.02983929f, -0.70071143f, -0.25442246f, 
    0.18177140f, -1.35827231f, -1.22704232f, -0.51843327f, -1.68924975f, -1.10974419f, 0.30152994f, -0.12825812f, 
    -0.13074768f, 0.55051827f, 1.47418928f, 1.26154578f, -1.36616457f, 0.20563644f, -0.15131374f, 0.75314486f, 
    0.00558491f, -0.14164481f, -1.04117429f, -1.03279090f, -1.35508883f, -1.16529703f, 0.21754767f, 1.09370255f, 
    0.79887480f, 0.09257040f, 0.55167419f, 1.48706329f, 1.25192750f, -0.42891908f, 1.19129050f, 1.10147882f, 
    0.21600531f, -0.33545026f, -0.59979707f, 0.06465358f, 1.06489527f, 0.11534757f, 0.48410976f, 0.30697167f, 
    0.58782113f, 0.34152991f, 0.35129422f, -0.65838474f, 0.69259524f, -1.07347047f, -2.10497618f, 0.44176179f, 
    0.76908040f, 0.82580829f, 0.82464612f, -0.07918291f, -0.36762440f, -0.31656215f, -0.11499903f, -1.21616399f, 
    -0.80208331f, 0.89569026f, -0.04776940f, -1.14886093f, -0.61553949f, 0.68922800f, -0.07389595f, -0.73227495f, 
    -1.01218343f, -0.94709355f, 0.70218909f, 1.20338941f, -0.08863334f, 0.69136697f, 0.05078449f, 0.04723246f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28736928f, 0.09674215f, -0.17344067f, 0.39169878f, 0.10894692f, 0.29232317f, 0.38171071f, 0.10936441f, 
    0.43196714f, -0.12981270f, 0.20394255f, 0.14790289f, 0.35146520f, 0.16636071f, 0.31175306f, 0.37308493f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.62406075f, 0.34407392f, 0.22788602f, -0.13984527f, -0.01228095f, 0.20908542f, -0.06020799f, -0.06868055f, 
    0.05808176f, 0.05923490f, -0.02790923f, -0.11297330f, -0.12724398f, -0.03415361f, -0.07092509f, 0.05603713f, 
    -0.00692279f, -0.03805812f, 0.18177556f, 0.05537874f, 0.02670081f, 0.20751894f, 0.20510833f, 0.00777283f, 
    -0.21934056f, 0.13341057f, 0.06578461f, 0.08234364f, -0.13502130f, -0.08181517f, 0.00737270f, 0.06305907f, 
    0.02421279f, 0.02701524f, -0.06200622f, 0.23448165f, 0.17622635f, 0.04291258f, -0.07648473f, 0.12759186f, 
    0.73302394f, -0.03163808f, 0.35540509f, -0.10850512f, 0.02889319f, -0.00969930f, -0.19708195f, 0.19822507f, 
    -0.05570756f, -0.07731184f, 0.12399886f, 0.03634480f, -0.19799685f, -0.09541899f, 0.22407721f, 0.02637878f, 
    -0.05431477f, 0.04351062f, -0.05250385f, -0.25189888f, 0.28748807f, -0.38146338f, 0.17899169f, 0.10494969f, 
    -0.29910451f, -0.19769159f, -0.25091237f, 0.13364056f, -0.01404393f, 0.04220066f, -0.16464223f, 0.06560610f, 
    -0.07467552f, -0.02583430f, -0.08762407f, -0.02429714f, 0.01040638f, 0.08269596f, -0.06684741f, 0.09147266f, 
    0.28111318f, 0.12526882f, -0.18717949f, -0.22409780f, 0.27990761f, -0.35416836f, -0.21010409f, -0.27812168f, 
    0.17007951f, 0.05283106f, -0.08683989f, 0.00730052f, -0.05321250f, -0.18304391f, 0.06193760f, -0.07219055f, 
    0.05785875f, -0.06631827f, 0.15464438f, -0.01777680f, -0.03536555f, 0.07915422f, 0.06419554f, -0.26099411f, 
    0.23656173f, -0.13935424f, -0.16902463f, 0.05687749f, -0.01846698f, -0.04348503f, 0.04534810f, 0.06275459f, 
    -0.04700892f, 0.06747958f, -0.02848098f, -0.09584338f, -0.10821094f, -0.00344237f, -0.04913886f, -0.04003262f, 
    -0.29745468f, -0.04103519f, 0.03117948f, 0.26006582f, 0.06802116f, -0.02728117f, 0.03090147f, 0.14226475f, 
    0.02989763f, -0.10800716f, 0.05026491f, -0.22936477f, 0.20734157f, 0.00558192f, 0.10432355f, -0.15531543f, 
    -0.04479186f, -0.01290143f, 0.02709142f, 0.05596025f, 0.13669509f, 0.16813648f, 0.17000461f, -0.18652655f, 
    -0.27143982f, -0.12662183f, 0.04780318f, -0.03482080f, 0.09793385f, -0.10191187f, -0.03615633f, 0.01376118f, 
    -0.06293317f, -0.02947804f, -0.05411354f, -0.04352210f, -0.19849317f, 0.07631058f, -0.17342287f, 0.00025399f, 
    -0.18209976f, -1.25093901f, 0.27799457f, 0.32591376f, -0.02246238f, -0.14082760f, -0.01264875f, 0.13814311f, 
    0.09804254f, 0.07275587f, -0.01883994f, -0.06181520f, -0.19493391f, -0.06106823f, -0.03332993f, 0.12240337f, 
    -0.06240666f, 0.01206020f, 0.09874681f, -0.11731534f, 0.11272349f, 0.09068602f, -0.17535602f, -0.06356738f, 
    0.19840331f, -0.39863425f, -0.34286410f, -0.08344159f, -0.05253550f, -0.00920109f, 0.00303331f, -0.08104642f, 
    0.00955950f, -0.07151432f, 0.15690836f, -0.09298868f, 0.00261052f, 0.09276375f, -0.09806685f, 0.08865198f, 
    -0.78269595f, 0.26446471f, -0.33539540f, 0.00942966f, -0.30155930f, -0.07484086f, -0.18897820f, -0.11862066f, 
    0.04427212f, 0.02881142f, 0.01347592f, -0.02238243f, -0.08854070f, 0.11676958f, 0.04489429f, -0.03497081f, 
    -0.21463098f, 0.06365950f, 0.12488569f, -0.20583053f, 0.04920483f, -0.00131491f, 0.15165031f, -0.10245845f, 
    0.49880800f, -0.23431756f, -0.14280859f, 0.05504315f, 0.08383416f, -0.16061552f, -0.00871397f, 0.22908272f, 
    0.05774501f, -0.06564800f, -0.24172083f, 0.14298701f, 0.03004851f, 0.00663039f, -0.14877261f, 0.12719613f, 
    0.10882539f, -0.02143713f, 0.08426978f, -0.01789575f, 0.09292786f, -0.02273350f, -0.03986507f, -0.03073391f, 
    -0.05248823f, -0.10956566f, -0.23284160f, -0.12163156f, -0.01977148f, 0.07901254f, -0.04747155f, -0.14096205f, 
    -0.13675460f, -0.01126289f, -0.15332711f, 0.06211662f, -0.36621270f, 0.14702089f, 0.29012373f, -0.13744833f, 
    -0.70460242f, 0.16122940f, 0.01944275f, 0.03885075f, 0.15499008f, -0.00276165f, -0.00458189f, -0.06904347f, 
    -0.07387037f, -0.04473065f, -0.18735020f, 0.00770530f, 0.10312549f, -0.09346257f, 0.00150399f, -0.00257326f, 
    -0.17075168f, -0.42646879f, 0.15287641f, -0.05004916f, -0.17058592f, 0.07272426f, -0.17394948f, 0.13934816f, 
    0.06186773f, -0.00793010f, -0.04518368f, 0.01442786f, 0.18834382f, -0.03750747f, 0.02397562f, -0.03912956f, 
    0.03270672f, 0.01141188f, -0.19142139f, 0.05674538f, 0.15152077f, 0.18826140f, 0.00137986f, -0.23282370f, 
    -0.42772707f, -0.03171429f, 0.04027788f, -0.07038621f, 0.17417602f, -0.05560490f, 0.07598455f, -0.00436124f, 
    0.03168510f, 0.10799349f, 0.01542757f, 0.22282645f, 0.21640833f, 0.01073815f, 0.07530650f, -0.03988204f, 
    -0.70349872f, 0.00021409f, -0.34683055f, -0.24773720f, -0.20179468f, 0.05891425f, 0.12841472f, -0.17094173f, 
    -0.01925380f, -0.01368530f, 0.02240064f, 0.12808408f, 0.10602961f, -0.17156610f, 0.08165184f, 0.03644605f, 
    -0.09702979f, 0.09220713f, -0.00623302f, -0.06630802f, 0.61850661f, -0.35210976f, -0.00261922f, -0.01836305f, 
    -0.05545499f, 0.07645942f, 0.09062489f, -0.07168537f, 0.08937810f, -0.12272777f, 0.19758588f, 0.13079771f, 
    0.05847685f, -0.00594067f, -0.20999536f, 0.04378510f, 0.09630954f, -0.10703716f, 0.09379271f, -0.01929110f, 
    -0.80025232f, -0.32697117f, -0.47612035f, -0.25217196f, 0.29595968f, -0.01198958f, -0.13774762f, -0.02539332f, 
    -0.24753068f, -0.04318531f, 0.16537112f, 0.13760531f, -0.10351790f, -0.10762512f, 0.13841613f, -0.03862027f, 
    -0.02313799f, 0.01082581f, 0.07645334f, 0.02243892f, 0.12912661f, 0.18631779f, 0.11695172f, -0.03041948f, 
    0.06955321f, -0.27282551f, -0.01777496f, 0.07280574f, -0.01474908f, 0.19833796f, 0.03888836f, -0.09314102f, 
    0.19125172f, 0.10378071f, 0.04761301f, 0.06304002f, -0.11716588f, -0.04490227f, 0.06100199f, 0.27655068f, 
    0.50187194f, -0.23393805f, -0.12153896f, 0.04502944f, 0.08119532f, 0.05288808f, -0.18285400f, 0.00605308f, 
    0.01132787f, -0.04034131f, -0.03427792f, -0.00139763f, -0.06537779f, 0.16575247f, -0.09340245f, 0.00817806f, 
    0.00516306f, -0.06916206f, -0.13476637f, -0.00964999f, 0.16006532f, 0.55171579f, 0.24121305f, 0.07782830f, 
    0.24977453f, -0.24685745f, -0.10974442f, 0.03972354f, -0.03191468f, 0.13531052f, 0.10389486f, -0.13506697f, 
    0.02851632f, -0.06325138f, 0.08915477f, -0.01210973f, 0.14917612f, 0.01803568f, -0.13012996f, 0.02760535f, 
    -0.39679992f, 0.29343906f, -0.11827863f, -0.23240349f, -0.09628472f, -0.05463837f, -0.00014927f, -0.16572914f, 
    -0.08467536f, -0.12521888f, -0.06818923f, -0.06882545f, -0.17233905f, -0.09678220f, -0.18845607f, -0.07319885f, 
    -0.12280789f, 0.13630547f, -0.09940545f, 0.09823760f, 0.22136028f, -0.55685765f, -0.33747908f, -0.06286053f, 
    -0.19412781f, -0.15441076f, -0.08953232f, 0.07867989f, 0.04078259f, 0.11011132f, 0.21245585f, 0.04967239f, 
    -0.08174981f, -0.13146108f, 0.08657492f, -0.02575319f, -0.09602747f, -0.06253567f, -0.23506320f, -0.01582407f, 
    -0.15264480f, 0.05298999f, -0.06939606f, -0.23495720f, -0.11225617f, 0.23014855f, 0.01658857f, 0.17538078f, 
    0.17483415f, 0.00092049f, -0.02501169f, -0.05396033f, 0.17938030f, 0.20739534f, -0.11342971f, -0.08180492f, 
    -0.00458771f, -0.46514612f, -0.30629838f, -0.29179835f, -0.11079834f, 0.20388113f, -0.29021433f, -0.04084469f, 
    0.04019560f, -0.01713658f, -0.09508001f, 0.02270880f, 0.01358971f, 0.02476819f, 0.04045802f, -0.11061285f, 
    0.07316045f, 0.15141794f, -0.02721862f, 0.05028590f, 0.00842233f, -0.02093313f, -0.21271361f, -0.06246663f, 
    0.35820609f, 0.01509126f, -0.01204335f, 0.17644003f, -0.15556663f, -0.03296341f, 0.01697627f, 0.06219055f, 
    0.21974081f, 0.08570333f, -0.12058859f, -0.17184724f, 0.09935544f, -0.03026059f, 0.01863553f, 0.12213694f, 
    -0.04506842f, 0.00914236f, -0.07864658f, 0.13610221f, 0.31974956f, -0.01442625f, 0.26377577f, -0.02422719f, 
    0.36846441f, -0.10369146f, -0.05410814f, -0.13709615f, 0.07078651f, -0.10658257f, -0.15909307f, -0.04546770f, 
    -0.15436003f, 0.00713928f, 0.04625173f, -0.01960437f, 0.12450740f, 0.10954088f, 0.19782284f, -0.02068082f, 
    0.20861922f, -0.03678134f, 0.21852544f, 0.12397287f, 0.25719702f, 0.01920255f, -0.26274496f, 0.11578747f, 
    0.07084467f, 0.00319926f, 0.19725871f, 0.04764791f, -0.03746385f, 0.01021580f, -0.09491053f, -0.01428015f, 
    0.06163557f, 0.06323244f, 0.09357976f, 0.10609952f, 0.04559007f, 0.17909998f, -0.18116766f, 0.14453870f, 
    -0.48002535f, -0.01079316f, -0.05312317f, 0.02625848f, -0.11688086f, 0.05557389f, -0.01248954f, 0.06258563f, 
    -0.12461623f, 0.13941273f, 0.08470762f, 0.03127614f, 0.03163912f, -0.02175169f, 0.01747850f, -0.18499756f, 
    0.31583610f, -0.22242934f, -0.06271787f, -0.07836381f, -0.03729911f, -0.08698449f, -0.02897145f, -0.10021470f, 
    0.00259553f, 0.13345170f, -0.14965788f, -0.21265207f, 0.01532000f, -0.06199702f, -0.01358860f, -0.04468207f, 
    0.09922709f, -0.06947960f, -0.03461932f, 0.20541069f, 0.29238772f, 0.00956211f, -0.33324018f, 0.07460243f, 
    -0.22166535f, 0.03140943f, 0.09308003f, -0.00588421f, 0.03625623f, 0.14710668f, -0.13180138f, -0.01914027f, 
    -0.17077537f, -0.12221479f, -0.04685546f, 0.18442406f, 0.12044001f, -0.03696687f, -0.11488768f, -0.09109831f, 
    0.38394389f, 0.13723090f, -0.38517436f, -0.08336887f, 0.14753406f, -0.01004819f, 0.02387171f, -0.10240848f, 
    0.06761862f, 0.11988544f, 0.04598513f, -0.03173068f, 0.01014800f, -0.06578609f, 0.07280614f, -0.05062840f, 
    -0.01830604f, -0.20670535f, -0.14592238f, -0.03948928f, -0.19055761f, 0.12231372f, 0.27232280f, 0.06858136f, 
    0.17018543f, -0.03503804f, -0.11995939f, 0.03309746f, 0.13916567f, 0.10748676f, -0.02883002f, -0.16429690f, 
    -0.04033025f, -0.02365827f, 0.05852136f, -0.21858647f, -0.04826611f, -0.03954232f, -0.06983099f, 0.04186834f, 
    0.30234894f, 0.37401292f, -0.13690767f, -0.04336372f, 0.00917499f, 0.02144559f, -0.12202846f, 0.11779716f, 
    -0.05130341f, -0.00640633f, -0.19471453f, -0.15938821f, -0.09599689f, 0.01649198f, -0.06421246f, 0.02730506f, 
    -0.03848326f, 0.27421138f, -0.03429182f, 0.00643934f, -0.55153626f, -0.03513450f, -0.00480026f, -0.18232612f, 
    0.03074883f, 0.15867823f, 0.14854950f, -0.14732900f, 0.04103796f, 0.05329889f, -0.09747404f, 0.02385234f, 
    -0.09447997f, -0.08235706f, 0.06497645f, -0.08613564f, 0.06150950f, -0.10734474f, -0.28742400f, 0.03705653f, 
    0.02603778f, 0.40533608f, -0.08164871f, -0.61157489f, 0.01692674f, 0.01528363f, 0.08800226f, 0.15005769f, 
    -0.06347036f, -0.04793579f, -0.06345729f, 0.09593917f, -0.03981858f, -0.20607145f, -0.18584831f, 0.12459224f, 
    0.00034353f, -0.01795184f, 0.02931498f, 0.14856613f, -0.02398052f, -0.01354820f, -0.14962961f, -0.21430117f, 
    0.15162820f, 0.05944103f, 0.16816942f, 0.19772813f, -0.11007335f, -0.14276455f, 0.01800872f, 0.04157980f, 
    0.12704842f, -0.01171764f, 0.04861193f, 0.09724960f, -0.30015248f, 0.01415466f, -0.13735054f, 0.01682328f, 
    0.29301551f, 0.16441891f, -0.32053432f, -0.02076708f, -0.19785224f, -0.15655723f, 0.04947128f, 0.12566249f, 
    -0.00433970f, -0.11209442f, 0.04087140f, -0.00789515f, -0.07323129f, 0.03490707f, -0.05878359f, 0.02358217f, 
    0.00190980f, -0.19182804f, 0.17458491f, -0.08381606f, 0.53018755f, -0.13417847f, 0.09864824f, -0.15864645f, 
    0.03280351f, 0.05474108f, 0.03776630f, -0.24387689f, 0.18605584f, 0.06521355f, -0.07582217f, -0.02272573f, 
    -0.00964055f, 0.27712131f, -0.03365777f, -0.00918592f, -0.04676904f, 0.10777071f, 0.08271282f, -0.07272250f, 
    -0.58165723f, -0.79619396f, -0.25007808f, -0.29388708f, -0.99395323f, 0.04136853f, 0.04194449f, -0.13101234f, 
    -0.18939276f, -0.02113958f, 0.05149260f, 0.21704569f, 0.03595074f, -0.18478617f, -0.13152266f, 0.07258948f, 
    -0.11825695f, 0.14186876f, -0.11785173f, -0.03920872f, 0.05909665f, 0.13805032f, -0.09744045f, 0.02498724f, 
    -0.05767919f, 0.04575536f, 0.19038314f, 0.08806685f, -0.07931454f, -0.25129652f, 0.01384373f, 0.00795469f, 
    -0.06652969f, -0.04386579f, -0.07872968f, -0.09024570f, -0.03016219f, -0.02612323f, -0.03851370f, -0.06621984f, 
    0.82240164f, -0.20345703f, -0.16637450f, 0.28904223f, -0.34754008f, -0.28974897f, 0.09928884f, -0.04120290f, 
    -0.17208265f, 0.06138394f, -0.01973482f, -0.08385044f, 0.08668060f, 0.05896261f, -0.13188659f, -0.02102651f, 
    -0.08650757f, 0.00557319f, 0.06468827f, -0.01305472f, 0.29804966f, -0.31498113f, 0.22269851f, -0.16157436f, 
    -0.16913706f, 0.11965654f, -0.14232564f, 0.26580736f, 0.00034354f, 0.18635873f, -0.09066223f, 0.04890690f, 
    0.14777243f, 0.09234215f, -0.11179585f, -0.09457312f, -0.12357060f, 0.14055073f, -0.18727526f, -0.08653095f, 
    -0.28905430f, 0.02536396f, 0.08826784f, -0.07783339f, -0.09238391f, -0.00069201f, -0.18972994f, 0.08811414f, 
    0.01861545f, 0.09923135f, -0.13527615f, 0.05055875f, 0.10659089f, 0.04458730f, -0.09892554f, -0.06755193f, 
    -0.09245179f, 0.00360379f, -0.10241072f, 0.01132210f, 0.17638753f, -0.04221958f, 0.16770092f, 0.04964658f, 
    0.27854094f, -0.19971545f, -0.07881220f, -0.15585646f, 0.07646874f, -0.01364943f, 0.24404353f, -0.03582321f, 
    -0.07397667f, -0.23112367f, 0.00938270f, -0.00883976f, -0.09561067f, -0.16547741f, 0.05833644f, -0.08412073f, 
    0.03596838f, -0.76740950f, 0.28917694f, -0.19091606f, 0.01090979f, -0.06271978f, -0.12230963f, -0.08135737f, 
    0.06240726f, 0.08917769f, -0.04848841f, -0.02082624f, -0.00905737f, 0.11771629f, -0.00912349f, 0.00864843f, 
    0.01681237f, -0.09012029f, 0.00662489f, -0.00186901f, 0.43272677f, -0.28019437f, 0.36816752f, 0.01426737f, 
    0.30381465f, -0.06104540f, -0.17992941f, -0.21730830f, 0.13526537f, -0.07670243f, 0.19275664f, -0.03569604f, 
    -0.08187228f, 0.08151805f, 0.01911488f, 0.12184879f, -0.01576187f, 0.08141166f, 0.02751187f, 0.06590209f, 
    -0.40088692f, 0.43941969f, 0.16376795f, -0.09764761f, -0.01665714f, -0.16006342f, -0.10697760f, 0.18037181f, 
    0.06133077f, -0.02866013f, 0.05922007f, 0.03787105f, -0.09154840f, -0.01310695f, -0.20663036f, -0.04245678f, 
    0.04268879f, 0.01986965f, 0.27383336f, 0.01445870f, -0.27800414f, -0.17630896f, -0.59574366f, -0.16014074f, 
    -0.57324225f, -0.03387416f, 0.05830251f, -0.04878717f, -0.05186078f, -0.09563052f, -0.13966173f, 0.16019268f, 
    0.14601813f, -0.04103642f, -0.04361202f, 0.15859647f, 0.05827595f, 0.01014659f, -0.15535067f, 0.13628994f, 
    0.66371590f, 0.70479947f, -0.09184964f, -0.07032605f, -0.03567217f, -0.11281767f, 0.14360324f, 0.04089616f, 
    0.23262461f, 0.03530855f, -0.14153406f, -0.10658693f, -0.12826362f, 0.05926814f, -0.08297941f, -0.06678883f, 
    -0.03351671f, 0.06820212f, 0.16129281f, 0.07368982f, -0.23481423f, -0.67008412f, -0.79316503f, 0.19424666f, 
    0.20035174f, -0.12477834f, 0.16463129f, -0.01085374f, 0.09318205f, -0.07752474f, 0.18470120f, -0.07561141f, 
    -0.10521556f, -0.01950171f, -0.06765816f, -0.09580949f, 0.12060176f, 0.14621378f, 0.00577201f, -0.07217961f, 
    -0.40681890f, -0.06334246f, -0.33955973f, 0.03072804f, 0.44004124f, -0.06713484f, 0.35666478f, 0.04241193f, 
    0.05705976f, 0.03649521f, 0.18700191f, 0.09395536f, 0.05048848f, -0.14043234f, 0.06547662f, -0.00287773f, 
    0.05185796f, 0.04632349f, 0.15956858f, 0.04226288f, -0.37392002f, -0.51541638f, -0.16816683f, -0.12948397f, 
    -0.22442003f, -0.25110528f, -0.16082680f, 0.00655736f, 0.04581274f, -0.06689274f, -0.00701941f, 0.11075400f, 
    -0.05159099f, -0.02535485f, 0.15660779f, -0.10834067f, -0.12294496f, -0.00469583f, -0.14831801f, 0.00300656f, 
    -0.48824549f, 0.48397121f, 0.02784446f, 0.13069697f, 0.07589132f, 0.15661921f, -0.06336242f, 0.05631549f, 
    0.04586983f, -0.10056160f, -0.13739620f, -0.07808210f, -0.10669076f, 0.18386617f, 0.05043400f, 0.10120108f, 
    -0.03517458f, -0.14814733f, -0.01980469f, 0.01240196f, -0.40868497f, 0.22094251f, 0.10035531f, 0.29316065f, 
    0.12184428f, 0.04432677f, -0.12271128f, 0.23087437f, 0.03746217f, 0.03621488f, 0.04115678f, -0.08406519f, 
    -0.07049967f, 0.08164509f, 0.06501681f, 0.13996406f, -0.02966698f, 0.02189458f, 0.33833924f, -0.03130576f, 
    0.42198509f, 0.41122094f, 0.04246966f, 0.19065338f, -0.03015089f, -0.10583987f, 0.08679541f, 0.02943471f, 
    -0.17191871f, 0.10302073f, -0.05478121f, 0.01524315f, -0.15288721f, -0.27935031f, -0.09220347f, 0.02147708f, 
    0.16620050f, 0.15439995f, 0.09651475f, 0.09844255f, -1.00695384f, -0.20295604f, -0.17378825f, 0.18122128f, 
    0.32660949f, 0.04025231f, 0.17179210f, 0.05065057f, 0.14308247f, 0.05175786f, -0.04789475f, 0.07748994f, 
    0.00426009f, -0.24787416f, 0.02024907f, -0.02227202f, 0.06204568f, 0.00044286f, -0.02335155f, -0.14317594f, 
    0.14965670f, -0.31367227f, 0.04320458f, 0.00906443f, -0.19777893f, -0.03701711f, -0.28247944f, 0.05416731f, 
    -0.14918925f, -0.06516533f, -0.02150914f, -0.00907123f, 0.02452181f, 0.00706828f, 0.18475854f, -0.00800037f, 
    0.00203685f, 0.02862907f, -0.00332967f, -0.02873120f, -0.47316945f, -0.39225301f, -0.17836355f, 0.00121559f, 
    -0.40389696f, -0.20490052f, -0.07277812f, -0.14401419f, 0.01171544f, 0.09027882f, -0.13157560f, -0.14449656f, 
    0.12625460f, 0.07316788f, -0.04510164f, -0.03701613f, 0.01194408f, -0.11132792f, -0.02806635f, 0.06567651f, 
    -0.13503340f, -0.52457356f, -0.29427385f, -0.07948676f, 0.06815878f, -0.10255571f, -0.02962647f, -0.04118781f, 
    -0.06392622f, -0.28771579f, 0.07176834f, -0.02970277f, 0.13688442f, 0.11958656f, -0.06544787f, 0.09914821f, 
    0.21473730f, -0.01606049f, -0.39318457f, -0.08513267f, 0.42918092f, -0.31080824f, 0.16959746f, -0.07264612f, 
    -0.16377787f, -0.06844822f, -0.18557496f, -0.09435842f, -0.10551605f, -0.06487505f, 0.02340540f, 0.04639412f, 
    0.16019754f, -0.04802949f, -0.00061962f, 0.00433686f, -0.04741065f, -0.03665868f, 0.03971478f, 0.16209027f, 
    0.18143398f, 0.09377035f, -0.31821054f, 0.06527770f, 0.00308535f, -0.02187099f, -0.07546570f, -0.06928077f, 
    0.06236938f, 0.01940780f, -0.02508301f, -0.00618770f, -0.01532507f, 0.00644103f, 0.12349534f, 0.17055795f, 
    -0.00349215f, 0.14625479f, -0.04014106f, -0.06340437f, -0.01388314f, 0.09327665f, -0.21242769f, -0.04014416f, 
    0.04336896f, -0.04103299f, -0.25119445f, 0.08684042f, -0.01655708f, 0.02779239f, 0.04566325f, 0.08980085f, 
    0.01672804f, 0.12020522f, 0.03038376f, -0.21015389f, 0.05245752f, -0.10964590f, 0.09221695f, -0.09021082f, 
    0.15969165f, 0.05449281f, -0.01241691f, -0.00243049f, 0.11105400f, 0.03204334f, -0.06326499f, 0.15225792f, 
    -0.01347819f, -0.17307916f, -0.12410094f, -0.26152301f, 0.02012901f, 0.08872662f, 0.01498956f, -0.08856244f, 
    0.00921186f, -0.00290364f, -0.04760981f, -0.04487294f, -0.99332482f, 0.32208851f, 0.03910425f, 0.23783860f, 
    -0.08051898f, 0.00528073f, -0.21441841f, 0.05896462f, -0.08855589f, 0.08380719f, 0.04982363f, 0.11657465f, 
    0.07040398f, 0.07826725f, 0.10432098f, 0.07428588f, -0.13148470f, -0.01200032f, -0.11022734f, -0.02454964f, 
    0.58016229f, -0.09638327f, -0.42529577f, 0.10646892f, -0.13562523f, 0.12504493f, 0.08187392f, 0.19586943f, 
    -0.04866268f, -0.04970273f, 0.00388043f, -0.12288018f, 0.17127220f, 0.08336367f, -0.14578022f, -0.01639981f, 
    -0.03615317f, -0.11675590f, 0.06611378f, 0.12131114f, -0.19113372f, 0.32633093f, 0.22779357f, -0.31686768f, 
    0.05273593f, 0.16185823f, 0.06558508f, -0.15366895f, -0.07352193f, -0.11931928f, 0.20791906f, -0.07756185f, 
    -0.05559963f, -0.00796734f, -0.30925995f, 0.01736745f, 0.01469614f, -0.07271093f, -0.11820690f, -0.02845069f, 
    -0.21896212f, -0.33577311f, 0.48214170f, 0.26547965f, -0.17769504f, -0.20204547f, 0.01316816f, 0.03193581f, 
    -0.13684957f, 0.03906947f, 0.18639596f, 0.13010748f, -0.03394771f, -0.24326552f, 0.13704503f, -0.03292306f, 
    0.06642634f, 0.06020978f, -0.04099689f, 0.08854701f, -0.54544914f, 0.01235866f, -0.10270006f, -0.25328878f, 
    0.12028112f, -0.04374355f, -0.01984719f, -0.07129138f, 0.20473324f, 0.04220180f, 0.03565266f, 0.01592023f, 
    0.08501530f, -0.09175639f, -0.03944352f, 0.20477760f, 0.07412590f, -0.11208094f, 0.05383613f, 0.02241061f, 
    -0.46733025f, 0.24189162f, 0.06637844f, -0.25907117f, -0.00658932f, -0.15948632f, -0.03468911f, 0.06329039f, 
    0.01818088f, 0.18311997f, -0.07989340f, -0.09127091f, 0.01420565f, -0.00247168f, 0.04983401f, -0.01332487f, 
    0.01029254f, -0.29706788f, -0.08542971f, -0.19964631f, -0.83219212f, -0.09015196f, 0.15601532f, 0.05454612f, 
    0.08857746f, -0.00306936f, -0.04247183f, -0.06972050f, -0.03097885f, -0.10577241f, -0.11155173f, -0.04002779f, 
    0.04772918f, 0.10350535f, 0.15710847f, -0.10164929f, 0.11856706f, 0.15276305f, 0.31540596f, -0.06826907f, 
    -0.16846399f, 0.07423507f, -0.20677821f, 0.27287573f, -0.22144441f, 0.07229314f, -0.03768761f, -0.00280176f, 
    0.13140735f, -0.12978517f, 0.17698312f, -0.01869884f, 0.09328310f, -0.02870035f, 0.14298967f, -0.04982448f, 
    -0.00192573f, 0.14337549f, 0.04847098f, 0.23006645f, -0.81282151f, -0.38278988f, 0.12660353f, 0.13370426f, 
    0.14975935f, -0.08996873f, -0.11372180f, 0.19670744f, -0.13414933f, 0.06872655f, 0.05195540f, 0.10974641f, 
    -0.10833336f, -0.07364748f, 0.00306513f, -0.02468216f, -0.02328630f, -0.15037754f, 0.09311044f, 0.01345243f, 
    -0.03229469f, 0.12419041f, -0.40279883f, 0.03831874f, 0.23502873f, 0.19989970f, 0.05366981f, 0.08190256f, 
    0.04255124f, 0.09608605f, 0.08120708f, 0.09295061f, 0.02059409f, -0.13379718f, -0.08745928f, -0.00430099f, 
    -0.13475387f, 0.03049533f, -0.01791031f, -0.25829661f, 0.34800261f, 0.14073974f, -0.32981110f, 0.23567966f, 
    -0.18723118f, 0.06658572f, -0.14138097f, 0.11921003f, 0.02588806f, 0.16315858f, -0.06968105f, 0.04314271f, 
    0.08921430f, -0.14987563f, 0.06979887f, -0.13016322f, 0.07239709f, 0.06628681f, -0.07464890f, -0.03971221f, 
    0.28778461f, 0.31912979f, -0.21948692f, -0.37674138f, -0.19281159f, -0.11169101f, 0.12784247f, -0.17397353f, 
    0.18803363f, 0.08801659f, -0.08168826f, -0.21563342f, 0.10055739f, 0.08997485f, 0.02822915f, -0.12597677f, 
    0.11274462f, -0.23991662f, 0.04021935f, 0.02423352f, -0.69436073f, -0.06748577f, -0.20764376f, 0.05909548f, 
    0.36563298f, -0.03473581f, 0.08659931f, -0.04563482f, 0.11669538f, 0.05790551f, 0.04477799f, -0.02158121f, 
    0.06034908f, 0.06966434f, -0.01161486f, 0.12005622f, 0.19352455f, -0.01016834f, 0.08786128f, 0.00243862f, 
    -0.47512412f, 0.35523751f, -0.11360573f, 0.16797104f, -0.23223938f, -0.07083156f, -0.02921326f, -0.04901496f, 
    0.03962321f, -0.09753690f, 0.04300286f, 0.06407689f, -0.12308782f, 0.10229741f, 0.00666209f, 0.04414472f, 
    -0.11579593f, 0.05519315f, 0.07028798f, 0.11116278f, -0.82729524f, 0.17766416f, -0.10823718f, 0.03751488f, 
    0.14883509f, -0.17709680f, 0.08319504f, 0.14095296f, 0.01572862f, 0.11987966f, -0.10438202f, -0.08799091f, 
    0.08682805f, 0.01931329f, -0.09181999f, -0.08534073f, -0.16282746f, 0.22824073f, -0.00994991f, 0.01526783f, 
    -0.45260587f, 0.09473351f, 0.10792897f, 0.04936824f, -0.12739667f, 0.11434692f, 0.17557345f, 0.04353959f, 
    -0.10614045f, -0.02106125f, 0.26076955f, -0.08257589f, -0.01574126f, -0.10109493f, -0.01796539f, -0.08763357f, 
    -0.07649161f, -0.03566033f, 0.10244945f, -0.04747558f, -0.04343209f, 0.17511682f, 0.03200499f, -0.03903400f, 
    0.08207989f, -0.07622522f, 0.04203550f, 0.00692857f, 0.01425537f, -0.12726545f, 0.03478510f, 0.00925716f, 
    -0.10020860f, -0.03415068f, 0.02671530f, -0.01685413f, 0.14076918f, 0.01969103f, 0.19237779f, 0.05187957f, 
    -0.27841598f, 0.21458428f, 0.50305039f, 0.09199005f, -0.41865832f, 0.06802412f, 0.06182881f, -0.00108876f, 
    -0.01205955f, 0.15944248f, -0.15277375f, -0.00431910f, 0.11155555f, 0.09826043f, -0.20174626f, -0.04183725f, 
    -0.05972673f, -0.14456832f, -0.12491371f, 0.08257132f, -0.11072750f, -0.19217962f, 0.12693594f, 0.44605452f, 
    0.03417676f, -0.02711830f, 0.01877750f, -0.01347103f, -0.02334243f, -0.08425244f, 0.04562398f, -0.03885087f, 
    0.01424618f, -0.08986200f, 0.16407232f, -0.06412340f, -0.10201652f, 0.02867872f, 0.04193997f, -0.23062576f, 
    0.10116474f, -0.03147618f, 0.04599449f, 0.16889466f, 0.39683083f, -0.14168973f, -0.08346611f, -0.01561776f, 
    0.07683194f, 0.06040991f, -0.15322492f, -0.26438975f, 0.12356535f, 0.10590199f, 0.23388253f, -0.08155885f, 
    -0.14316767f, -0.14151202f, 0.07245791f, 0.07926632f, -0.05891864f, -0.29311255f, 0.16790171f, 0.14878646f, 
    -0.28055227f, 0.19643424f, 0.21422878f, 0.07975607f, 0.15119375f, -0.02686850f, -0.05999517f, -0.07068418f, 
    -0.12584160f, 0.13052718f, -0.04535435f, -0.06850494f, -0.06173016f, 0.04419799f, 0.05435537f, -0.07294352f, 
    0.08058962f, -0.06185158f, -0.04027045f, 0.16952406f, -0.37639588f, 0.03011750f, -0.08316345f, -0.08777412f, 
    -0.01336663f, 0.05858805f, -0.02625270f, 0.16835122f, 0.08496991f, -0.20348705f, -0.12065671f, 0.00036483f, 
    -0.22639824f, 0.08799881f, 0.06690349f, 0.02763848f, -0.47949350f, 0.10318159f, -0.23351608f, 0.04138648f, 
    0.13160892f, 0.10160933f, 0.07127008f, 0.09141296f, 0.10004814f, -0.06326988f, 0.05203003f, -0.13423952f, 
    -0.07698645f, -0.00853902f, -0.11330938f, -0.11033022f, -0.04259077f, -0.15924530f, -0.18395333f, -0.01727812f, 
    0.05217978f, -0.03662578f, -0.06685950f, 0.33370209f, 0.18168733f, 0.09427596f, -0.17287971f, -0.19995804f, 
    -0.01174766f, 0.13278209f, -0.00401219f, 0.03812880f, 0.22386718f, 0.31204143f, 0.04003861f, -0.04698868f, 
    0.04907994f, -0.14956141f, -0.31137446f, -0.01931069f, 0.18588780f, 0.15325959f, 0.03272570f, 0.17996901f, 
    -0.44763973f, -0.32587406f, -0.11410938f, -0.05104627f, 0.17141154f, 0.07326470f, -0.10180967f, -0.07018035f, 
    0.08698185f, 0.09862158f, 0.32349411f, -0.04733869f, 0.07626072f, 0.06238640f, -0.02388741f, -0.01895556f, 
    -0.87083459f, -0.40987122f, -0.25308126f, -0.26540369f, 0.03766906f, 0.12265700f, -0.03988266f, -0.15272297f, 
    0.08709336f, -0.09848478f, 0.03432396f, 0.11361939f, -0.23989022f, 0.06093518f, -0.08106498f, 0.03595985f, 
    0.13264221f, 0.07080887f, -0.36810133f, 0.19561295f, 0.29421419f, 0.27358097f, 0.10564995f, -0.10772474f, 
    0.02661781f, -0.09765816f, -0.04944193f, -0.11175710f, -0.10110933f, 0.05185795f, 0.13920785f, -0.03179298f, 
    0.02276251f, 0.13283637f, 0.01984096f, 0.09340872f, 0.01752640f, -0.02889869f, 0.14121877f, -0.01232156f, 
    0.16333498f, 0.05969905f, 0.19034109f, 0.13047668f, 0.21400440f, -0.00986986f, -0.00537758f, 0.11866415f, 
    -0.13298900f, -0.01648296f, -0.12881657f, 0.06437974f, -0.15258615f, -0.29218754f, 0.04348389f, 0.22108418f, 
    -0.07271846f, 0.09258889f, 0.15196922f, 0.18077339f, -0.49528667f, 0.30046654f, -0.32428592f, -0.07929921f, 
    -0.17518270f, 0.09118919f, 0.00676372f, 0.19238427f, -0.10054929f, -0.19746991f, -0.05226891f, -0.05997065f, 
    -0.01748010f, -0.07748266f, -0.06597008f, 0.12871268f, -0.12829903f, 0.11478990f, 0.06710775f, 0.02610397f, 
    -0.55754489f, 0.13441020f, -0.25586268f, -0.22254966f, 0.00798422f, 0.24485102f, 0.26058808f, -0.01511844f, 
    -0.12862688f, 0.14010255f, 0.07134724f, 0.20183133f, 0.16421489f, -0.21082546f, 0.13210109f, -0.03224977f, 
    0.12337731f, -0.22774172f, 0.06873216f, -0.36886328f, -0.68929851f, -0.14597893f, -0.23375872f, -0.37919834f, 
    -0.05344708f, 0.11939451f, -0.03033148f, 0.02695660f, -0.15998375f, -0.17057498f, 0.04698837f, 0.01332690f, 
    0.03633200f, -0.07267261f, 0.11792006f, 0.10414959f, 0.19697762f, -0.13243632f, 0.00034790f, 0.02583656f, 
    0.10897533f, -0.40122589f, -0.07769071f, -0.10298131f, 0.04532656f, -0.12213589f, 0.08274763f, 0.08682109f, 
    0.03462771f, -0.00319301f, -0.13707410f, 0.06859550f, -0.09940276f, 0.02974107f, 0.02168768f, 0.01835554f, 
    -0.02315428f, 0.12670562f, -0.00651305f, 0.18153484f, 0.03720479f, -0.77127028f, -0.07623142f, -0.20559710f, 
    0.41073027f, -0.00984975f, 0.09822138f, -0.15973355f, 0.18536393f, -0.01376051f, 0.03973355f, -0.07301304f, 
    -0.04156154f, 0.25087637f, 0.04073356f, 0.04639438f, 0.09019937f, -0.09713263f, -0.21490715f, -0.18943499f, 
    0.12984952f, 0.05873068f, -0.01961757f, 0.42992488f, 0.21284494f, -0.09276020f, 0.01003885f, -0.14498511f, 
    0.00396037f, 0.14472902f, 0.03609970f, 0.02278700f, 0.18355963f, 0.07811859f, 0.08133434f, 0.03037932f, 
    -0.06765735f, 0.07527853f, 0.03606744f, -0.05439503f, -0.39671630f, 0.49048027f, -0.13179976f, 0.14925981f, 
    0.16636167f, -0.05749253f, -0.16196206f, 0.14778405f, 0.06940885f, 0.05541373f, 0.01178197f, 0.07749953f, 
    -0.03863815f, 0.00585029f, 0.17779540f, -0.00794753f, -0.03883168f, -0.02841256f, 0.13232489f, 0.09829485f, 
    -0.26241285f, 0.49032184f, 0.20063658f, 0.09101649f, -0.76071674f, 0.25142398f, 0.00470797f, 0.00671798f, 
    0.21686386f, 0.19579925f, -0.13802983f, 0.06747978f, -0.03830064f, 0.09100210f, -0.25740275f, 0.01115507f, 
    -0.02051861f, -0.07447246f, 0.08830019f, -0.03653913f, -0.41613910f, 0.25732660f, -0.03704887f, 0.37548128f, 
    -0.30656973f, -0.13813753f, -0.10716590f, -0.02967663f, 0.05214369f, 0.10324017f, -0.04831066f, 0.02568429f, 
    0.03724915f, -0.07143991f, -0.08331385f, -0.10968591f, -0.07528196f, -0.11640730f, -0.16535218f, -0.15233722f, 
    0.41598967f, -0.38880172f, 0.09726930f, 0.12289453f, -0.01071335f, 0.05895182f, 0.05871100f, 0.05162093f, 
    -0.09845339f, 0.05142055f, 0.11917944f, 0.02583023f, 0.04218287f, -0.11240649f, 0.13816524f, 0.02957547f, 
    0.03384615f, -0.02194100f, -0.00679920f, -0.26987037f, 0.36620432f, -0.15244116f, -0.15739188f, -0.38887084f, 
    -0.02477192f, 0.06845719f, 0.15157351f, 0.08548207f, -0.06644796f, -0.35258254f, -0.03345595f, -0.10420682f, 
    0.28607777f, 0.05545114f, 0.02528778f, 0.18037432f, -0.05515307f, 0.08274852f, -0.06092119f, 0.22979704f, 
    -0.28201929f, 0.07972975f, -0.57412595f, -0.55810547f, 0.29706508f, -0.17470005f, -0.03373519f, 0.03527601f, 
    -0.12895578f, 0.09057501f, -0.08824513f, -0.16536723f, -0.15671985f, -0.11600913f, -0.14337364f, 0.08511835f, 
    -0.04042581f, 0.25797606f, 0.18935257f, 0.12711924f, -0.03935104f, 0.46339950f, 0.30608049f, 0.02573100f, 
    -0.36451730f, 0.22911921f, -0.13825800f, -0.04837491f, -0.06189517f, -0.18319362f, 0.05918629f, 0.02305392f, 
    -0.15643483f, 0.03776559f, -0.20640495f, 0.11274745f, -0.09802344f, -0.09256351f, 0.10792492f, -0.19958231f, 
    -0.55733407f, -0.06430975f, 0.04321405f, -0.28171051f, 0.24551652f, 0.00355532f, 0.10718162f, 0.10958094f, 
    -0.12869008f, 0.04589025f, 0.07955106f, -0.21997221f, 0.11178203f, 0.01243001f, 0.03989097f, -0.13153748f, 
    0.03308619f, -0.29611725f, 0.14975460f, -0.04964045f, -0.29803672f, 0.02139858f, -0.19123091f, 0.29277629f, 
    -0.39701134f, -0.04923826f, 0.02479452f, -0.08908614f, 0.16355227f, 0.03196028f, -0.09528960f, -0.05702277f, 
    -0.02973631f, 0.00899243f, -0.04271855f, -0.03563613f, -0.07950129f, -0.10367651f, -0.22477126f, 0.10168824f, 
    -0.23606123f, -0.08725645f, -0.08897953f, 0.15903635f, 0.03585048f, -0.02964061f, -0.08082005f, -0.02637716f, 
    -0.05601546f, 0.14468217f, 0.10871352f, -0.05495279f, 0.27065128f, 0.09394403f, -0.06942979f, -0.04576431f, 
    -0.06884961f, -0.06479850f, -0.05982520f, -0.20183341f, 0.21511054f, -0.88942146f, -0.08306181f, -0.20097613f, 
    -0.03493585f, -0.03195492f, 0.04205228f, -0.05887276f, 0.03631677f, 0.12446079f, -0.04490356f, 0.09675251f, 
    0.08446804f, 0.10428210f, 0.05988587f, -0.02933034f, -0.01122805f, -0.10202266f, -0.04613386f, 0.06788554f, 
    0.21118370f, -0.27293825f, 0.00268240f, -0.54493541f, 0.26373738f, -0.22345495f, 0.07614161f, 0.01941288f, 
    -0.12931001f, -0.34609604f, 0.07821663f, 0.03731236f, -0.06435834f, 0.01060324f, 0.02681364f, -0.07147601f, 
    -0.03352726f, 0.06500524f, -0.01888001f, 0.15068276f, 0.35444102f, -0.16843013f, -0.10409346f, -0.07548553f, 
    0.13810499f, 0.01075396f, 0.10507042f, 0.02613956f, -0.09366440f, -0.10066321f, 0.01902953f, 0.10808053f, 
    0.01969067f, -0.04028998f, 0.13566563f, -0.17327806f, 0.02056027f, 0.08748852f, -0.06662796f, 0.12405140f, 
    0.19425628f, -0.22882925f, 0.25983435f, 0.08234672f, -0.05393718f, 0.30474576f, -0.04048476f, 0.01109758f, 
    -0.04685090f, 0.16105641f, -0.12570375f, -0.03079812f, 0.06611650f, -0.02068548f, -0.08490733f, -0.06151008f, 
    0.06660334f, -0.04290054f, -0.03516320f, -0.08952283f, -0.12292819f, -0.13477799f, -0.03318813f, -0.12232333f, 
    -0.05056845f, -0.27615362f, 0.10721822f, 0.01990458f, -0.07966448f, 0.02323438f, 0.01318951f, 0.03404503f, 
    -0.14862816f, -0.07461248f, -0.02126782f, -0.12234396f, -0.00939958f, 0.13759539f, -0.05459394f, 0.01677938f, 
    -0.53998756f, 0.35891750f, 0.27946597f, 0.07055829f, -0.09079942f, 0.11334407f, -0.11019530f, 0.00982358f, 
    0.21490739f, -0.08569568f, 0.07245135f, 0.04773499f, 0.15532909f, 0.06101540f, -0.15744780f, 0.09061717f, 
    0.00111192f, -0.02544622f, -0.03231357f, -0.19331907f, 0.08890093f, 0.17091675f, -0.36577338f, -0.30760667f, 
    -0.00236404f, 0.02514658f, -0.18423937f, -0.11920290f, 0.00280163f, -0.15751140f, -0.27568462f, 0.10864520f, 
    -0.17450230f, -0.02377728f, -0.17710614f, -0.02014690f, -0.16366859f, -0.14134042f, -0.01611913f, -0.03388719f, 
    -0.33612150f, -0.26640955f, -0.73306566f, -0.01822926f, 0.05259297f, -0.16750126f, -0.11788507f, -0.04871732f, 
    0.02284158f, -0.12080267f, -0.05530363f, 0.00053280f, 0.00257772f, -0.14496058f, -0.00888019f, -0.00015426f, 
    0.00478138f, -0.02311321f, -0.00153358f, 0.00587408f, 0.00869485f, -0.38170338f, -0.09598359f, -0.11461847f, 
    -0.26431051f, 0.00015504f, -0.07295025f, -0.01402496f, -0.03859477f, -0.16463140f, 0.00684267f, -0.11511939f, 
    0.01446650f, 0.00973388f, -0.10198632f, 0.02628433f, 0.15441835f, -0.04877858f, 0.06445158f, -0.01306777f, 
    0.50837159f, -0.63193965f, -0.03531851f, -0.18058370f, -0.08033163f, -0.01073205f, 0.05760401f, -0.07405684f, 
    -0.09343608f, 0.03018819f, -0.03144681f, -0.03890941f, -0.03675598f, 0.06692855f, -0.04715196f, -0.11240067f, 
    0.19640495f, -0.06703516f, -0.08298311f, -0.06260854f, 0.08003721f, 0.39459506f, 0.43273962f, 0.02267317f, 
    0.33150747f, 0.05864162f, 0.11236835f, -0.14076680f, 0.11284997f, -0.07934716f, -0.03712991f, 0.02190165f, 
    0.08823252f, 0.02304574f, -0.24049322f, 0.07325054f, -0.16663988f, -0.05742367f, -0.01337273f, -0.14909403f, 
    0.05121066f, 0.27947199f, 0.11703774f, -0.03488471f, 0.35263798f, -0.15857078f, 0.11617889f, -0.27458456f, 
    -0.09437884f, -0.11955436f, 0.02268085f, 0.05128693f, -0.15516312f, -0.30307385f, -0.14613463f, -0.02715744f, 
    -0.07662697f, 0.24144186f, 0.13911891f, 0.04041563f, -0.00940220f, -0.66846049f, 0.05824950f, -0.22080959f, 
    -0.11982875f, -0.00539018f, 0.06315212f, 0.00852482f, -0.03280304f, -0.03933075f, -0.03173130f, -0.08774390f, 
    -0.14360744f, -0.12306664f, -0.08683845f, -0.08105192f, 0.17725424f, -0.04819192f, 0.02173314f, 0.17407386f, 
    0.42140558f, -0.20146953f, 0.43645757f, -0.03925503f, 0.14363243f, 0.14698388f, 0.10052756f, -0.09846028f, 
    -0.11820734f, 0.05988650f, 0.03073500f, 0.16525507f, -0.11349574f, 0.01709591f, -0.04697262f, -0.08209790f, 
    0.00412340f, -0.09440985f, 0.13807800f, -0.10714626f, -0.29066911f, 0.20290200f, 0.16610941f, -0.16730867f, 
    -0.27014560f, -0.09529915f, -0.03850578f, -0.02605938f, -0.06611814f, -0.04073678f, 0.03559996f, 0.01548314f, 
    -0.05032331f, -0.00234628f, -0.05054361f, 0.02480893f, -0.01586065f, -0.12645917f, -0.06880376f, -0.00126277f, 
    -0.43933526f, -0.09709543f, 0.01018438f, -0.29869327f, -0.20002453f, -0.18905434f, 0.00557846f, -0.02421712f, 
    -0.10034662f, -0.00607772f, -0.00784489f, -0.17147118f, -0.04625349f, -0.10493766f, -0.03722174f, -0.15223460f, 
    -0.08309644f, -0.03097627f, -0.06759144f, -0.03191709f, -0.08563816f, 0.22300243f, 0.23032436f, 0.18270653f, 
    0.34867212f, 0.11112663f, 0.21502022f, -0.05743582f, 0.05790811f, -0.02835347f, -0.08681392f, 0.04439539f, 
    0.11805618f, -0.14072785f, -0.09184440f, -0.14734486f, -0.00414739f, -0.01067087f, 0.00923607f, -0.00288177f, 
    0.01862636f, 0.19626631f, 0.26398608f, 0.19618911f, 0.33293161f, 0.10901268f, 0.24859700f, 0.05648190f, 
    0.06496952f, -0.07990086f, -0.10784269f, 0.05451058f, -0.13547638f, -0.04919029f, -0.13379252f, -0.19924855f, 
    -0.04538385f, 0.16272245f, -0.03175686f, -0.09573758f, -0.11482035f, 0.23050603f, 0.32326657f, 0.03915119f, 
    0.12233123f, -0.03909910f, 0.19322020f, 0.05833586f, 0.16409165f, -0.16159743f, -0.17211485f, 0.07325031f, 
    0.11369380f, -0.14285529f, -0.16005927f, -0.02945327f, -0.10356757f, 0.04749842f, 0.19198732f, -0.08126076f, 
    -0.09499349f, 0.00683793f, 0.16811322f, 0.06952900f, 0.23252971f, -0.22607239f, -0.12532367f, -0.17071833f, 
    -0.23313482f, 0.14441216f, -0.15214932f, 0.01142232f, -0.03672651f, -0.15424487f, -0.06255534f, 0.00283984f, 
    -0.05096546f, -0.00753773f, 0.12276527f, -0.07372950f, 0.25177172f, 0.42981362f, 0.02670015f, -0.08523833f, 
    0.11413153f, -0.20188758f, -0.26308283f, 0.00384974f, -0.06821144f, -0.09708531f, 0.12215593f, -0.15499932f, 
    -0.19487250f, -0.08445042f, 0.12170997f, 0.00649451f, 0.01020663f, -0.01190402f, 0.15105926f, -0.10668913f, 
    -0.23338030f, 0.16084008f, -0.45718461f, -0.03868895f, -0.09190997f, -0.32475615f, -0.22543158f, -0.54123169f, 
    -0.06856507f, -0.18223034f, 0.13490713f, -0.02330953f, -0.02333982f, -0.04184901f, 0.02780056f, -0.04490910f, 
    0.17592300f, -0.07491558f, 0.10633179f, 0.01319560f, 0.07218860f, 0.28914472f, 0.16800277f, 0.06304315f, 
    0.09781199f, 0.06897148f, 0.11958256f, -0.24394190f, -0.14642648f, -0.06433049f, 0.15585713f, 0.00494229f, 
    0.06023572f, 0.04467678f, 0.02388594f, -0.13665953f, 0.02388412f, 0.03041614f, 0.04987087f, -0.17922169f, 
    -0.06089031f, -0.23576349f, -0.53436732f, 0.09251004f, 0.12895165f, 0.12723750f, 0.13869023f, -0.11439995f, 
    -0.10502703f, -0.08450328f, 0.08601291f, 0.02614678f, 0.03012592f, 0.16029395f, 0.15904845f, -0.05433260f, 
    -0.04579477f, -0.05888779f, 0.07941003f, -0.10984651f, 0.33384135f, -0.07953089f, -0.22955368f, 0.14794862f, 
    0.21622166f, 0.08524425f, 0.07973529f, -0.11756375f, -0.06739856f, -0.01499784f, -0.18299913f, 0.03297646f, 
    -0.02838000f, 0.05570730f, -0.10087331f, 0.05796733f, -0.01694528f, 0.12869361f, 0.12570752f, -0.02181691f, 
    0.19561301f, -0.06187759f, 0.07138368f, -0.02279060f, 0.11481034f, -0.07244099f, 0.07348780f, -0.04002600f, 
    -0.08260389f, -0.09497260f, -0.05792348f, 0.06321789f, -0.02829292f, 0.03089298f, 0.00944536f, 0.14159092f, 
    -0.08588829f, 0.06993990f, 0.06926862f, 0.03880586f, -0.13344981f, -0.10508287f, -0.14992042f, -0.17100342f, 
    -0.26081505f, 0.02608071f, -0.03430184f, 0.20570350f, -0.41288096f, 0.08792672f, 0.12263951f, 0.01983053f, 
    -0.16778822f, 0.05208520f, 0.07307202f, -0.01885602f, -0.04112899f, -0.23898423f, 0.01469486f, -0.01270198f, 
    -0.39839613f, 0.14984889f, 0.33800787f, -0.45132127f, -0.32421169f, -0.08286024f, -0.09523296f, -0.19824696f, 
    0.03687053f, -0.25019813f, 0.13050061f, 0.21650709f, -0.08019609f, -0.04189470f, 0.01003845f, -0.09292620f, 
    0.11486660f, -0.27585161f, -0.32100579f, 0.01092533f, 0.16002198f, 0.03410110f, -0.23136093f, -0.15375450f, 
    0.25692093f, 0.27407873f, 0.07935625f, -0.12243174f, -0.02968291f, -0.15072456f, 0.01894023f, 0.15693411f, 
    0.16617474f, 0.03651018f, -0.10813294f, 0.20102769f, 0.05592283f, 0.06690408f, 0.05638714f, -0.06974713f, 
    -0.24948172f, 0.03018409f, 0.33341756f, -0.16756456f, 0.16442889f, -0.04287365f, -0.09644531f, 0.11506697f, 
    -0.03147391f, -0.16269778f, -0.03430124f, 0.00074472f, 0.14671350f, 0.27282566f, -0.00074843f, 0.14960499f, 
    -0.07439401f, 0.12500416f, -0.15964545f, 0.13979851f, 0.28513014f, 0.19440870f, -0.15780729f, 0.19627886f, 
    0.10498238f, -0.00707302f, 0.15167136f, -0.18903063f, -0.15741235f, -0.19608419f, -0.07481799f, 0.02887513f, 
    -0.01550837f, -0.31408241f, 0.06205490f, -0.20406710f, -0.01663860f, 0.02828476f, 0.20426230f, -0.21046379f, 
    0.11435718f, 0.14896479f, -0.12864153f, 0.18664539f, 0.05793829f, 0.18453191f, 0.04360796f, -0.07685834f, 
    -0.15537210f, -0.06807721f, 0.11793768f, -0.02984392f, -0.10457880f, -0.12805787f, -0.08783466f, -0.06290700f, 
    0.05445096f, 0.05692796f, 0.11203710f, -0.05537920f, -0.15048009f, -0.27114737f, 0.25305292f, -0.04672787f, 
    0.23558806f, -0.15275565f, -0.08043322f, -0.05650655f, -0.12783898f, 0.07621764f, 0.01272246f, 0.02453691f, 
    -0.10376604f, -0.13026354f, 0.03161117f, 0.02415161f, -0.04252783f, 0.10855061f, 0.00835163f, 0.13888146f, 
    -0.21047880f, -0.17224897f, 0.03610554f, -0.28145242f, -0.56641060f, -0.26294291f, 0.01397387f, 0.06501307f, 
    -0.07786898f, -0.12932581f, 0.04256256f, 0.01137562f, -0.09344537f, 0.00090534f, -0.07256898f, -0.14331025f, 
    -0.08153228f, -0.46770260f, 0.02191575f, -0.05320489f, -0.15855056f, -0.26894683f, 0.24817839f, 0.12283625f, 
    0.11335234f, 0.01302884f, -0.05492276f, 0.05335410f, -0.07314882f, 0.06756041f, -0.02618477f, -0.06289895f, 
    -0.17488816f, 0.05898476f, 0.11533522f, 0.13732438f, -0.00389143f, -0.07362143f, 0.11107900f, 0.05053816f, 
    0.53374529f, -0.64970887f, 0.02452505f, 0.25859711f, -0.05094006f, -0.06072021f, -0.13107376f, 0.12493159f, 
    0.03642641f, 0.08616626f, 0.09089653f, 0.02950581f, 0.09016068f, 0.22327876f, 0.04273732f, 0.01839594f, 
    0.18084703f, -0.06263528f, -0.06813622f, 0.08401842f, 0.22227822f, 0.28101057f, -0.37101930f, 0.03177678f, 
    0.01247721f, 0.09092799f, 0.05866442f, -0.00129810f, -0.04927341f, 0.07146439f, -0.26966998f, -0.04631942f, 
    -0.01060065f, -0.03398183f, -0.08793264f, -0.03414076f, -0.08777486f, 0.02205379f, -0.08162147f, 0.12068222f, 
    -0.37752342f, -1.05836976f, 0.18519050f, -0.31363863f, 0.10996576f, -0.04222620f, 0.16012508f, 0.06896307f, 
    0.13119869f, -0.00728523f, -0.18955398f, -0.16475658f, -0.12215880f, 0.03844153f, -0.00794595f, 0.18849003f, 
    0.16023743f, 0.07567274f, 0.05220174f, -0.00839193f, 0.61480618f, 0.02194962f, -0.04065687f, -0.45811936f, 
    -0.20351556f, 0.03258755f, 0.07795502f, 0.06915178f, 0.02686528f, -0.13610587f, -0.15724123f, 0.00235143f, 
    0.11137124f, -0.09327654f, 0.01368608f, 0.15293078f, 0.07688915f, -0.09429151f, -0.08183460f, -0.03477992f, 
    -0.54392612f, -0.11567435f, 0.17055261f, -0.39342311f, -0.58994603f, -0.00221827f, 0.11171380f, 0.05997408f, 
    -0.09420203f, -0.10858037f, -0.07020767f, -0.12498424f, -0.05578950f, -0.01213902f, -0.00908160f, -0.15919216f, 
    -0.00076465f, 0.25846332f, 0.05042868f, -0.07436720f, 0.15231952f, -0.23278339f, 0.22450690f, -0.19719490f, 
    -0.14027460f, 0.24387939f, 0.04301509f, -0.10784560f, -0.10203852f, -0.05243323f, -0.10460964f, 0.14929861f, 
    0.06732113f, 0.10160293f, 0.07536805f, -0.10747319f, 0.05628144f, -0.15946941f, 0.09293050f, -0.07728497f, 
    0.26154196f, -0.44171461f, 0.42554629f, 0.05807600f, -0.00292938f, 0.22721379f, 0.09923790f, -0.11157044f, 
    0.04791088f, -0.10341703f, -0.08626179f, -0.06013339f, -0.04162946f, 0.16926607f, 0.11197052f, 0.06379240f, 
    0.09560493f, -0.10242533f, -0.00268504f, 0.10888654f, -0.16650853f, -0.20740314f, -0.02276799f, 0.23219158f, 
    0.11965148f, -0.04988868f, -0.07002446f, -0.19484940f, 0.03533059f, 0.25373515f, -0.05766540f, 0.18270384f, 
    0.01796428f, 0.00018092f, 0.01898330f, -0.05372719f, 0.08810958f, -0.13500673f, 0.01948843f, -0.01978288f, 
    0.05060543f, -0.20596501f, 0.10441720f, -0.00661336f, -0.33361542f, -0.02646724f, 0.22173254f, 0.01922468f, 
    -0.05168278f, -0.05293570f, -0.09756954f, -0.08405061f, -0.13603453f, -0.06358121f, 0.20135051f, -0.00018877f, 
    0.14913316f, 0.01284893f, 0.00095065f, -0.03818826f, 0.15942538f, -0.32835203f, 0.36661631f, -0.29756212f, 
    -0.38843456f, -0.07058147f, -0.02270005f, -0.20178016f, -0.02666709f, 0.15857963f, -0.00063421f, -0.15147834f, 
    0.25124180f, -0.07898602f, -0.19021702f, -0.01316072f, -0.22526883f, -0.19809984f, 0.02825392f, -0.06921542f, 
    0.03054328f, -0.46497691f, -0.10647555f, 0.30811438f, -0.02569810f, -0.17039353f, 0.04914500f, -0.09343271f, 
    0.17072545f, -0.00945701f, -0.14364007f, -0.04909132f, -0.11220472f, -0.00196571f, 0.06559325f, -0.16186430f, 
    0.03266722f, 0.05818548f, 0.24877429f, -0.04185792f, -0.75280762f, 0.12104054f, -0.03124758f, 0.04886375f, 
    0.10166730f, 0.15363316f, 0.13900068f, 0.10706060f, -0.02463456f, -0.25760689f, 0.10815497f, 0.09807029f, 
    -0.01434425f, 0.04218548f, 0.02010122f, 0.13556468f, -0.00359624f, 0.04486743f, -0.28615403f, 0.02126644f, 
    -0.07212733f, -0.12805685f, -0.06142778f, 0.16633882f, -0.22866052f, -0.00979552f, 0.25747043f, -0.08718497f, 
    -0.11424225f, -0.21013913f, 0.06100288f, 0.13877352f, -0.11018181f, 0.02822309f, 0.06375578f, 0.03047594f, 
    -0.10620476f, -0.03402215f, -0.22011080f, -0.04132221f, 0.80835855f, 0.06321604f, -0.06388632f, -0.10572767f, 
    0.05958611f, 0.15474118f, -0.08072871f, 0.12062847f, -0.16784172f, 0.17445904f, 0.01050095f, -0.04719538f, 
    0.04519385f, 0.04049873f, 0.05718073f, -0.02000320f, 0.10572892f, -0.03836051f, 0.00246575f, -0.09757435f, 
    -0.60597342f, -0.10329206f, -0.00687650f, 0.39305976f, 0.07992257f, 0.09669000f, -0.05803189f, 0.02126369f, 
    0.04409265f, 0.25746214f, 0.04896770f, -0.01060188f, -0.09039578f, 0.00646809f, -0.02540129f, 0.19199911f, 
    -0.12560493f, 0.14010090f, 0.15794635f, 0.07313071f, -0.49189487f, -0.36384219f, 0.03325580f, 0.26362255f, 
    0.06176113f, 0.07882039f, 0.00574784f, -0.29903758f, -0.05298643f, 0.15798132f, -0.01044581f, 0.17651331f, 
    0.01388582f, 0.03640747f, 0.02467386f, -0.24325009f, -0.16978779f, -0.10709998f, -0.00505301f, -0.05196320f, 
    0.13372572f, -0.08734132f, -0.10703743f, 0.06635544f, 0.05651689f, -0.14879830f, 0.04383365f, -0.14236295f, 
    0.05017912f, 0.07975927f, 0.14794889f, 0.15263997f, 0.08127660f, -0.05144523f, 0.13002576f, 0.04326014f, 
    -0.02885277f, 0.07226723f, -0.21508823f, 0.01008846f, 0.33541045f, 0.25776467f, -0.03070568f, 0.02335532f, 
    -0.02052187f, -0.18818291f, 0.20356730f, 0.02452829f, 0.11215383f, -0.04812965f, 0.00403572f, -0.05079622f, 
    0.03808185f, -0.27086183f, 0.01824486f, -0.23388261f, -0.05014394f, 0.16931273f, 0.15059090f, -0.02346172f, 
    -0.40641433f, -0.38960123f, -0.13334221f, -0.03415674f, -0.05095184f, 0.08396133f, 0.08504832f, -0.07870097f, 
    0.09403481f, -0.05125756f, 0.08864469f, 0.13421184f, -0.23244089f, -0.11193903f, 0.16394633f, -0.07628846f, 
    -0.06312346f, -0.11244364f, -0.03889108f, 0.07376899f, -1.25469005f, -0.58578825f, 0.20767266f, -0.18916731f, 
    -0.35522228f, 0.30394620f, 0.15714133f, -0.00208081f, -0.12333947f, 0.09380672f, -0.02191871f, -0.05420171f, 
    0.03923419f, 0.17355518f, 0.07381963f, -0.08337192f, -0.18789497f, 0.06304210f, 0.13297351f, 0.06459387f, 
    -0.94035637f, -0.21026213f, 0.40946004f, 0.03942057f, -0.30262831f, 0.08845848f, 0.05219484f, 0.03283554f, 
    -0.04379579f, 0.09237178f, 0.02048961f, 0.19663428f, 0.05870396f, 0.23083209f, -0.03903332f, 0.13894254f, 
    0.05608452f, -0.07757110f, -0.27969605f, -0.18912843f, -1.04545105f, -0.65392220f, -0.44344646f, -0.30715579f, 
    -0.28824505f, 0.21824917f, 0.15343410f, -0.16838919f, -0.18435037f, 0.08359515f, 0.09600748f, 0.02854650f, 
    -0.06437028f, 0.08168945f, -0.05187801f, 0.00627788f, -0.01109637f, 0.10569616f, 0.06861373f, 0.15883651f, 
    -0.52591676f, -0.16113032f, -0.25396386f, -0.09280876f, 0.13466863f, 0.00344702f, 0.16955058f, -0.03912410f, 
    0.20719263f, 0.01713829f, 0.17896245f, -0.01257196f, 0.03836066f, 0.01467690f, 0.17913139f, 0.29667556f, 
    0.06634870f, 0.24876365f, 0.02038829f, 0.34823272f, 0.47166842f, -0.25748298f, -0.44645023f, 0.27606860f, 
    -0.10139233f, -0.11165883f, 0.08893781f, 0.11621188f, -0.03812515f, 0.14496389f, 0.02147659f, 0.14915027f, 
    -0.12494431f, -0.13713598f, -0.15686917f, -0.01829698f, 0.12398195f, -0.23232758f, -0.15070073f, 0.02591842f, 
    0.30627874f, -0.06901723f, 0.20719327f, -0.21775593f, -0.09468627f, 0.14719054f, 0.02847257f, 0.06693501f, 
    0.14099394f, -0.02701849f, 0.07534523f, -0.07040185f, -0.09394763f, 0.10493537f, -0.12713391f, -0.04072621f, 
    0.05055465f, -0.45360431f, -0.01416087f, 0.00235746f, -0.44592386f, 0.15925100f, -0.19527300f, -0.21401767f, 
    -0.01601752f, 0.15759933f, 0.02688732f, -0.09022295f, 0.02322483f, 0.08419363f, -0.09856135f, 0.05418218f, 
    -0.05476269f, 0.27070805f, -0.05392426f, 0.11461481f, -0.09203888f, 0.03889257f, -0.04097532f, 0.10346729f, 
    -0.06001531f, 0.08402736f, -0.03497358f, -0.28850162f, -0.12314487f, 0.05192345f, 0.10440435f, 0.08339374f, 
    0.13526741f, -0.03262298f, -0.12496500f, 0.07091563f, -0.03007038f, -0.07826413f, -0.00800108f, 0.01249153f, 
    0.21652389f, 0.03649364f, -0.18641368f, 0.09287631f, -0.74494159f, -0.40750495f, -0.30190012f, -0.35591328f, 
    -0.07234187f, 0.14574227f, 0.17617697f, -0.06961980f, -0.17269512f, -0.11657556f, 0.22487906f, -0.09991562f, 
    -0.07466765f, -0.15625288f, -0.00655956f, -0.00009234f, -0.00904466f, 0.15554450f, 0.27717581f, 0.04854221f, 
    -0.37491348f, -0.32483831f, 0.01816957f, -0.06464929f, -0.13798276f, 0.19855465f, 0.01344765f, 0.23914608f, 
    -0.11419749f, 0.05633786f, 0.11664166f, 0.04869493f, -0.15209332f, -0.05030723f, 0.21142289f, 0.08947966f, 
    0.08117055f, 0.16765344f, 0.19324630f, 0.19496745f, 0.31116864f, 0.22057976f, -0.17543800f, -0.02491431f, 
    0.09259059f, -0.11601617f, -0.13950527f, 0.00098024f, 0.08462635f, -0.10797507f, -0.07275555f, 0.12534493f, 
    -0.08858298f, -0.09388532f, -0.07934499f, -0.10293965f, -0.00067238f, 0.08313125f, -0.15658922f, -0.01195101f, 
    0.29864645f, 0.31614599f, -0.17958987f, 0.14655349f, -0.17615546f, 0.09916565f, -0.11305196f, 0.23389274f, 
    -0.08886794f, -0.01631274f, -0.07171222f, 0.00555718f, 0.05095988f, -0.14076260f, -0.07784709f, -0.01386853f, 
    0.14858536f, -0.08769002f, 0.08044094f, 0.04785225f, 0.47659826f, 0.13121413f, -0.10750692f, 0.09159474f, 
    -0.13550179f, -0.21267869f, -0.22561179f, 0.09191211f, -0.00135794f, -0.06115800f, -0.02870771f, -0.03702628f, 
    -0.06946822f, -0.08521377f, -0.03741336f, 0.06029493f, 0.12582105f, -0.16063486f, -0.01661177f, -0.07262187f, 
    -0.52342743f, 0.23303045f, 0.05193866f, -0.10883585f, -0.11565071f, -0.08805782f, -0.02853773f, -0.06802155f, 
    0.00795890f, -0.24132077f, -0.23805146f, 0.09912392f, 0.19222911f, 0.09805137f, 0.02787173f, -0.06491143f, 
    0.05413606f, 0.07911765f, -0.23138459f, 0.02339078f, -0.55868775f, -0.56051421f, -0.01351979f, 0.04014915f, 
    -0.12171316f, -0.01443290f, -0.00239507f, 0.22684667f, -0.11892326f, 0.28829637f, -0.13027240f, -0.09267849f, 
    -0.09734524f, -0.08213752f, -0.02212133f, -0.03926548f, -0.11042406f, -0.15551905f, -0.06698283f, -0.04860876f, 
    -0.58561635f, -0.30186141f, -0.05496401f, -0.06801412f, 0.02086047f, -0.10419269f, 0.18811402f, -0.04366885f, 
    0.00208710f, 0.02339637f, 0.07697868f, 0.09798686f, 0.00286089f, -0.04039774f, -0.08002735f, 0.13032357f, 
    0.15989089f, 0.01904140f, -0.23084724f, -0.05699736f, 0.37503201f, -0.63633960f, -0.06786802f, -0.32049859f, 
    0.01776335f, -0.02020129f, -0.12987690f, -0.00568359f, 0.06528782f, 0.10032770f, 0.11078639f, -0.04548182f, 
    0.08849189f, -0.00473494f, -0.05441460f, 0.27873930f, 0.16594562f, -0.08321901f, 0.01211240f, -0.04829397f, 
    0.60861254f, 0.45008212f, -0.29864678f, -0.16504259f, 0.14149220f, 0.04659626f, -0.03344991f, 0.02262529f, 
    -0.01346526f, 0.04716718f, 0.20039284f, 0.19310556f, -0.07771607f, 0.03761337f, 0.02318759f, -0.00890297f, 
    0.13847561f, -0.01450466f, -0.15414205f, 0.22505431f, 0.90566468f, -0.27806625f, -0.33516982f, 0.02142729f, 
    -0.35437581f, -0.01006207f, -0.14823678f, 0.00389117f, -0.05579347f, 0.06072026f, 0.15401512f, -0.11610256f, 
    0.04355476f, 0.01256573f, -0.02920700f, 0.02348968f, -0.11303250f, -0.03059680f, -0.00184690f, 0.06880458f, 
    -0.33264124f, 0.36185864f, -0.12839811f, -0.08332230f, 0.27937943f, 0.03650619f, -0.16170058f, 0.04652638f, 
    0.14631931f, 0.25618842f, 0.08048924f, 0.19129062f, 0.01040584f, 0.00011255f, -0.08937004f, 0.12501752f, 
    0.06699525f, 0.00742613f, -0.16402614f, -0.09338345f, 0.44587982f, 0.36220011f, 0.05823940f, -0.04112008f, 
    0.03454364f, 0.19636612f, -0.22083424f, 0.10449869f, -0.19518667f, -0.13812077f, -0.24418418f, 0.03003092f, 
    0.13206588f, -0.11690632f, 0.00515940f, 0.11447614f, -0.00808356f, 0.13360003f, 0.10952878f, -0.13273729f, 
    0.13866109f, -0.11226762f, -0.51728165f, -0.26839685f, 0.25435728f, 0.01055252f, -0.41902614f, 0.06823155f, 
    0.06988051f, -0.04475921f, -0.03580017f, 0.14312394f, -0.04849992f, -0.05442159f, -0.04548291f, 0.17980817f, 
    -0.10843894f, -0.01417453f, 0.34415013f, 0.10060877f, 0.95467603f, 0.03797449f, -0.24307489f, 0.00087646f, 
    0.21762751f, 0.03018203f, 0.15070981f, 0.00556192f, 0.08085592f, 0.02265003f, 0.21842226f, 0.03841646f, 
    -0.04220472f, 0.10193256f, -0.05146439f, 0.08552171f, -0.00915993f, -0.07801704f, 0.07069904f, 0.13629927f, 
    -0.56888849f, 0.51045763f, 0.05430360f, -0.12694791f, -0.03201530f, -0.06575688f, 0.02989310f, 0.10846093f, 
    -0.38040778f, -0.02162709f, -0.03889178f, 0.08388644f, 0.10732245f, -0.24086434f, -0.09852724f, 0.07715910f, 
    0.02324301f, -0.12402445f, -0.01533121f, -0.22600761f, -0.36561945f, -0.48400652f, -0.09617114f, 0.03750417f, 
    -0.63038915f, 0.15820464f, 0.16076466f, 0.01673131f, -0.02529634f, 0.15332530f, 0.04259288f, -0.02538780f, 
    -0.01139437f, -0.00319988f, 0.13594773f, -0.12226741f, 0.04465709f, -0.23949510f, -0.13884582f, -0.01204782f, 
    -0.02320280f, -0.06610847f, -0.08146684f, -0.06030051f, -0.19043601f, 0.12584467f, -0.15643474f, 0.02088945f, 
    0.03891559f, 0.08811198f, 0.01370436f, 0.17875099f, -0.11590280f, 0.20062040f, -0.01326058f, 0.01614571f, 
    -0.09823596f, 0.04054625f, -0.07941651f, -0.19932331f, -0.42341295f, 0.12862080f, -0.05103176f, -0.00121901f, 
    0.21653527f, -0.09094994f, 0.05793734f, 0.06394958f, 0.19017926f, -0.07896014f, 0.02692426f, -0.09985564f, 
    0.15071012f, 0.03060605f, 0.06782461f, -0.14997989f, -0.22165692f, -0.04727197f, -0.11490827f, 0.00308607f, 
    0.32747391f, -0.01213169f, -0.06833313f, 0.08833686f, -0.02393997f, -0.02541621f, 0.06435107f, 0.10778526f, 
    0.05919767f, -0.14604415f, 0.02311340f, -0.04738638f, -0.13993843f, 0.09143487f, -0.11477102f, -0.03147529f, 
    0.01301638f, 0.01168772f, -0.11624670f, -0.17620409f, 0.32607746f, -0.07827304f, 0.04457393f, -0.08429494f, 
    -0.06630882f, 0.07459942f, 0.09528351f, 0.12780505f, -0.04428375f, -0.27698186f, -0.15898108f, -0.29050002f, 
    0.11426702f, -0.07027759f, -0.14482939f, -0.05306478f, -0.18755756f, -0.12131660f, -0.15880929f, -0.03515203f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13733454f, 0.04913256f, -0.14638010f, 0.04568718f, -0.00205706f, -0.00511958f, -0.00437906f, -0.12001809f, 
    -0.10559788f, 0.04719113f, 0.15579943f, 0.01725713f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
