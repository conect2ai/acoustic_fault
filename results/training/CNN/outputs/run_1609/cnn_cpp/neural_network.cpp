#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.64662546f, 0.88497841f, 0.42686895f, -0.35736090f, 0.31400955f, -0.48159102f, -0.46307224f, 0.13409565f, 
    -0.29323903f, -0.59334660f, -0.20226434f, 0.04879884f, -0.10530993f, -0.21155675f, -0.22622234f, -0.09699316f, 
    -0.12734774f, 0.22186114f, 0.24784346f, 0.19141737f, -0.22291178f, 0.23699151f, -0.02605599f, 0.01169235f, 
    -0.16563177f, -1.04835296f, -0.27026847f, -0.13064061f, -0.03815383f, -0.11600818f, 0.48598227f, 0.44598013f, 
    0.11293780f, -0.09499477f, 0.65579420f, 0.24242607f, -0.05702565f, 0.21298496f, -0.01913559f, 0.10075613f, 
    -0.04267628f, -0.18686259f, -0.10673682f, 0.02740941f, -0.12857404f, 0.06919665f, -0.04090834f, 0.04913575f, 
    -0.19641209f, 0.15287475f, 0.21283913f, 0.32132152f, -0.58315670f, -0.67349762f, -0.24612404f, 0.32883522f, 
    0.31972629f, 0.11598564f, 0.11339998f, -0.22572671f, -0.03161038f, 0.54819649f, -0.34249145f, -0.04643016f, 
    -0.27354664f, -0.33070093f, -0.48803714f, -0.01810268f, -0.46455675f, -0.35135335f, 0.44126257f, 0.16124552f, 
    -0.35914764f, -0.05091325f, 0.01583138f, -0.11460515f, 0.49608505f, 0.30341938f, 0.06018409f, 0.01441438f, 
    -0.44844013f, 0.04640088f, -0.15145573f, -0.01509472f, 0.21440066f, 0.36249834f, -0.04185363f, -0.23281392f, 
    -0.29856461f, 0.09764453f, 0.21955189f, 0.07766043f, -0.21552524f, 0.07486331f, -0.20466325f, 0.05005650f, 
    0.21094219f, -0.20145981f, -0.09061595f, -0.04830255f, -0.13167933f, -0.30868644f, -0.21164860f, 0.11270498f, 
    0.10767286f, 0.30969480f, 0.15962070f, -0.12862097f, 0.05127469f, 0.43216708f, 0.04097758f, 0.61078566f, 
    -0.20680436f, -0.29817757f, -0.06619964f, -0.36767992f, -0.25648528f, 0.20771112f, -0.34595832f, 0.02498790f, 
    -0.11464694f, 0.31636980f, 0.19422296f, 0.34041458f, 0.28625685f, -1.06778085f, 0.45108014f, -0.39982969f, 
    -0.94160223f, -0.44505164f, 0.03190402f, 0.30051187f, 0.44368541f, 0.68900102f, 0.34404081f, 0.14104547f, 
    -0.03592798f, 0.12500353f, -0.19997855f, -0.19110256f, -0.15151031f, -0.11676458f, -0.05956868f, 0.23863359f, 
    -0.25418374f, -0.04569414f, 0.27388194f, 0.37924540f, 0.14513505f, -0.25265193f, 0.11600909f, -0.63101375f, 
    -0.18268891f, 0.85300100f, 0.52310991f, -0.42578763f, -0.63069189f, -0.69627649f, -0.19617303f, 0.01052604f, 
    0.05702866f, 0.13924503f, 0.02213288f, 0.67215377f, -0.17214267f, 0.28180534f, 0.35061404f, -0.01037503f, 
    -0.08720394f, -0.36826068f, -0.32827649f, 0.11461722f, -0.22970684f, -0.06785949f, -0.18271306f, -0.56489760f, 
    -0.09322289f, -0.21471816f, -0.85326660f, -0.84230053f, -0.16321285f, 0.19612759f, 0.39448896f, 0.38684520f, 
    0.19514361f, 0.02914209f, 0.18621378f, 0.19217034f, -0.18328290f, 0.04735816f, 0.04232546f, -0.19405852f, 
    0.04949364f, 0.20012350f, -0.04146169f, -0.01585310f, -0.19264643f, -0.24697219f, -0.28113085f, -0.01771877f, 
    0.31642377f, -0.19995208f, -0.50010508f, -0.40835670f, 0.09569945f, -0.13823342f, -0.41805062f, -0.61676955f, 
    -0.71748483f, -0.39060706f, 0.51568508f, 0.57325661f, 0.09108668f, 0.18058424f, -0.25924835f, -0.17348933f, 
    -0.48890239f, -0.36581376f, -0.23639174f, 0.04382983f, -0.15539736f, -0.16861562f, 0.01495522f, 0.09947042f, 
    -0.29075065f, -0.01707299f, 0.08310700f, -0.03006211f, 0.25180814f, 0.39639157f, 0.17437515f, 0.18308108f, 
    0.04166675f, 0.04863377f, 0.28551292f, 0.09711585f, -0.13610184f, 0.24254844f, -0.21070457f, -0.31887662f, 
    0.02796570f, 0.22040476f, 0.19651827f, 0.24149819f, -0.00779426f, -0.10590711f, -0.16989708f, -0.06873272f, 
    -0.24710242f, 0.16652444f, 0.48754415f, 0.19785716f, -0.30186409f, -0.43729761f, -0.36483887f, 0.10453459f, 
    0.26383990f, 0.20498857f, -0.07685151f, -0.03480194f, 0.34098962f, -0.29040825f, -0.12810817f, 0.19465436f, 
    -0.30746269f, -0.18653661f, 0.06250963f, -0.50250107f, 0.17933208f, -0.01794350f, 0.04611317f, 0.02591399f, 
    0.20651187f, 0.17379571f, 0.25974464f, -0.31395429f, 0.05822543f, 0.00089240f, 0.20726332f, 0.46883234f, 
    0.29681519f, 0.35444042f, 0.28732735f, 0.28755304f, -0.07159358f, 0.15593524f, 0.01806882f, 0.12835546f, 
    -0.05593965f, 0.17248937f, -0.05102960f, 0.05764198f, -0.34703240f, 0.09343824f, -0.01632706f, 0.02074024f, 
    -0.22052707f, 0.08897074f, 0.16689289f, 0.05001668f, -0.33780137f, -0.01426398f, -0.59684128f, -0.39255270f, 
    0.27800488f, 0.27086917f, 0.30061039f, 0.18667760f, 0.10327928f, 0.28784952f, -0.09492572f, -0.21683051f, 
    0.09177971f, -0.00241381f, -0.32517213f, -0.28928515f, -0.09077342f, -0.21637888f, -0.10182733f, -0.46652219f, 
    0.18273601f, 0.29373288f, 0.29859063f, -0.00623456f, 0.41111633f, -0.01931994f, -0.20353808f, -0.34761572f, 
    -0.09250659f, -0.46369618f, -0.12635590f, -0.34821200f, -0.47372234f, -0.09745248f, -0.11084865f, -0.16141985f, 
    -0.31448567f, -0.00613902f, -0.33082458f, -0.38750106f, 0.18583781f, 0.00073904f, -0.09796195f, -0.25610474f, 
    -0.42552346f, -0.46056300f, -0.32686102f, 0.07268383f, -0.07639144f, 0.11394706f, -0.58307260f, -0.18676339f, 
    -0.24316487f, -0.07925855f, -0.63753098f, 0.46578801f, -0.45360878f, 0.14835590f, 0.51430851f, 0.63592720f, 
    -0.05838091f, 0.28675497f, -0.11821991f, -0.04120887f, 0.02448380f, 0.10528773f, 0.08883387f, 0.29741248f, 
    0.20969741f, 0.03733541f, -0.04144207f, 0.04597234f, -0.09385419f, 0.09648485f, -0.08504274f, 0.42697823f, 
    -0.18711892f, -0.22070862f, -0.06992715f, -0.11736199f, 0.12889823f, 0.33489338f, -0.27703479f, -0.20503996f, 
    -0.16231146f, 0.01871494f, 0.47204942f, -0.16069034f, -0.14355409f, -0.22124533f, -0.21578620f, 0.14653604f, 
    0.32208544f, -0.30100080f, -0.10799186f, -0.40292549f, 0.16878645f, 0.12517031f, 0.19123611f, 0.12877041f, 
    0.00745846f, 0.52094960f, 0.52704567f, 0.09817750f, -0.18900938f, 0.40212092f, -0.38775218f, -0.21971183f, 
    -0.09804047f, -0.10132888f, -0.13707928f, -0.39622253f, -0.17395386f, 0.35916153f, -0.01027699f, -0.16780926f, 
    0.07286032f, 0.14415933f, 0.37366769f, -0.20952620f, 0.13676620f, -0.27122757f, -0.30189329f, -0.04114636f, 
    0.17842025f, 0.64075613f, 0.61546671f, 0.04041348f, 0.02413347f, -0.73211300f, 0.09483407f, -0.10538295f, 
    0.05645683f, 0.35865855f, -0.39203563f, -0.22155571f, -0.22590308f, 0.12916291f, 0.24090426f, -0.38680336f, 
    0.01270987f, 0.10192986f, 0.05352533f, -0.07672395f, -0.24855480f, -0.14546001f, 0.00010499f, 0.06935879f, 
    -0.10319144f, 0.09882059f, -0.54836178f, -0.43603349f, -0.43696609f, -0.21060653f, -0.53471136f, -0.17929737f, 
    -0.16826072f, -0.59044158f, -0.60063934f, 0.16029827f, 0.08145417f, 0.00066800f, 0.28700793f, 0.38256544f, 
    0.21223149f, -0.01314096f, -0.11582255f, -0.02902058f, -0.07320471f, -0.28424659f, -0.04095525f, 0.21116124f, 
    0.41414583f, 0.08439974f, 0.32245740f, 0.29261598f, -0.41835192f, 0.24917358f, 0.15116645f, -0.29525489f, 
    -0.57605577f, 0.43145066f, 0.34054166f, 0.34399685f, -0.67253637f, -0.21948588f, -0.13512339f, 0.67784405f, 
    -0.48718619f, -0.23001409f, -0.08557148f, 0.06869053f, 0.23332156f, -0.13572809f, 0.04228462f, -0.04139937f, 
    -0.24147749f, -0.40350500f, 0.31554502f, 0.17591029f, -1.26061583f, -1.03128409f, -0.07782102f, 0.60725605f, 
    0.52728581f, 0.25238585f, 0.35485837f, 0.09206320f, 0.05275628f, 0.24987881f, -0.05028976f, -0.18139541f, 
    -0.39970475f, 0.50312203f, -0.17902078f, 0.15615270f, 0.22511081f, -0.15854728f, 0.11774143f, 0.13709380f, 
    -0.06135579f, -0.21144921f, 0.10327274f, 0.07988065f, -0.27246925f, 0.45841432f, -0.29413596f, -0.14647974f, 
    0.19352463f, 0.29254335f, 0.30164531f, -0.33746776f, -0.30576557f, 0.52900881f, -0.50574064f, 0.08809860f, 
    0.08526925f, 0.03983771f, -0.17697048f, -0.18911192f, -0.27061766f, -0.13852882f, 0.33523464f, -0.19419196f, 
    0.21400221f, 0.15738593f, -0.09080449f, -0.26452726f, 0.07062500f, 0.26700473f, 0.38416734f, 0.66694891f, 
    -0.01416163f, -0.19154212f, -0.53397644f, -0.42715541f, 0.03353128f, -0.31868511f, -0.52616948f, -0.54098582f, 
    0.22148187f, 0.08746355f, 0.21346956f, 0.14634597f, 0.01693857f, -0.11163066f, 0.14295177f, 0.25543687f, 
    -0.02347779f, 0.08504728f, -0.04386104f, -0.04361220f, -0.05591243f, 0.20675160f, -0.02842493f, 0.77471519f, 
    0.31267187f, -0.17536981f, -0.60165244f, -0.78234392f, 0.17822169f, 0.25879580f, 0.30523607f, -0.40701899f, 
    0.30484217f, -0.18728445f, 0.38844541f, -0.35670194f, -0.14741184f, 0.23492534f, 0.10234562f, 0.16710661f, 
    -0.15728314f, -0.30843541f, 0.07731335f, -0.18033981f, -0.01113378f, 0.01290166f, 0.05730284f, 0.35066298f, 
    -0.11708168f, 0.51810974f, 0.56015140f, -0.37686801f, -0.60986990f, -0.46183056f, -0.37164891f, 0.40789372f, 
    0.47567353f, 0.34936678f, -0.16637847f, -0.19547516f, 0.29746106f, -0.56388295f, -0.07099465f, 0.15560672f, 
    -0.08929617f, 0.23400632f, 0.03498379f, -0.02450563f, -0.19547912f, -0.16998561f, -0.38959721f, 0.06776949f, 
    -0.17463391f, 0.14973073f, 0.07298987f, 0.12922601f, 0.19460106f, -0.15625572f, -0.30760461f, 0.04758951f, 
    -0.14225325f, -0.09792042f, -0.02350807f, 0.23239297f, 0.07288527f, -0.00950867f, 0.01279577f, -0.26574972f, 
    -0.18433997f, -0.06418379f, 0.38374132f, 0.33664027f, 0.05951245f, 0.00046172f, 0.06990112f, -0.32388148f, 
    0.48382708f, 0.38506427f, 0.12440329f, -0.11474090f, 0.11835783f, 0.02585972f, -0.10877675f, 0.18100013f, 
    0.18459687f, -0.26121938f, 0.20072295f, 0.09781348f, -0.19365856f, -0.16682765f, 0.31678531f, -0.05030742f, 
    -0.31460610f, 0.08246816f, -0.25961709f, 0.04932565f, -0.13008252f, -0.01883683f, -0.00866257f, -0.09406773f, 
    0.06620437f, 0.13121282f, 0.19295368f, 0.14718281f, 0.57165504f, 0.09274019f, -0.61808383f, 0.32749054f, 
    -0.55169028f, 0.53010553f, -0.28299829f, -0.21332905f, 0.13997561f, -0.08667213f, -0.18673138f, 0.49855313f, 
    -0.40238571f, 0.07862680f, 0.05574484f, -0.08196960f, -0.25175050f, 0.11429692f, 0.25536749f, -0.01698496f, 
    0.15659277f, 0.00140654f, -0.27908969f, 0.17506285f, -0.69013005f, -0.93169749f, -0.81275028f, -0.31089839f, 
    0.14257973f, 0.55341643f, 0.32518059f, 0.25296637f, 0.36384770f, 0.24402395f, 0.01917155f, 0.24589700f, 
    -0.11823513f, 0.23164281f, 0.21582755f, 0.05145540f, -0.00034751f, -0.18405582f, 0.06959758f, -0.19342995f, 
    -0.02526510f, -0.21371360f, 0.11254535f, 0.38568652f, -0.11187148f, 0.21581110f, 0.84141815f, 0.22792318f, 
    -0.55840433f, -0.41427276f, -0.22744469f, 0.45970750f, 0.36949247f, -0.38477787f, -0.70239586f, -0.28187677f, 
    0.00167781f, -0.11342933f, -0.00371219f, 0.29029784f, 0.09782316f, -0.20323020f, -0.12338727f, 0.01861044f, 
    -0.16814364f, 0.28536403f, 0.17046079f, 0.20096982f, 0.23439273f, -0.26152888f, 0.58201540f, 0.22321196f, 
    0.28751653f, 0.31981170f, 0.24330036f, -0.20460758f, -0.24773936f, 0.00658503f, 0.04936746f, 0.43082112f, 
    0.04835472f, 0.32240540f, 0.04021848f, -0.04891014f, -0.00821888f, -0.10238359f, -0.22855279f, 0.01091664f, 
    0.08959213f, -0.42341745f, -0.03999344f, 0.08566275f, 0.21456383f, 0.05387656f, -0.17010660f, -0.79416126f, 
    -0.94366634f, 0.03203695f, 0.98830217f, 0.83478832f, -0.35743204f, -0.21284701f, -0.38266423f, -0.12331723f, 
    -0.40062317f, -0.04828813f, 0.03025028f, 0.15539637f, -0.20093442f, -0.02901054f, -0.16320646f, 0.12791054f, 
    -0.01342712f, 0.23280190f, 0.10680602f, -0.51498508f, -0.28841501f, -0.30361295f, 0.25061333f, 0.02825318f, 
    -0.95420861f, -0.70934194f, 0.06334016f, 0.56175619f, 0.29616442f, 0.33213109f, -0.15178664f, -0.10042038f, 
    0.44569960f, 0.17853679f, -0.08477781f, -0.23233049f, 0.05054468f, -0.35258684f, -0.33547732f, 0.18340267f, 
    0.01665637f, 0.18336114f, 0.20731407f, 0.12982076f, -0.09433880f, -0.25073004f, -0.25016201f, -0.20641981f, 
    -0.42875513f, -0.06903368f, 0.17731202f, 0.05520137f, 0.64363915f, 0.10711050f, -0.02852506f, -0.21793707f, 
    -0.74746114f, -0.63831294f, -0.22850478f, -0.00921476f, 0.08734454f, 0.57590020f, -0.24669485f, -0.06469908f, 
    0.02096107f, -0.12631814f, 0.19043581f, -0.01405286f, 0.16200209f, 0.12015990f, -0.19015852f, 0.11575148f, 
    0.21044339f, -0.07088236f, -0.69156820f, -0.76932257f, -0.30806440f, 0.23200059f, 0.72608525f, -0.40788111f, 
    -0.61373973f, -0.13786693f, 0.90801948f, 0.04507108f, 0.56831247f, 0.23003940f, 0.00163564f, 0.00471217f, 
    -0.02994546f, -0.19051673f, -0.15874851f, 0.06844585f, -0.44029012f, 0.26025161f, -0.07083405f, 0.42803106f, 
    -0.04221005f, -0.05543901f, 0.35557169f, 0.30891314f, -0.39066857f, -0.27160969f, -0.17945403f, -0.50943393f, 
    -0.36491218f, -0.43220165f, -0.32774433f, -0.30898440f, -0.23491687f, 0.33397761f, 0.01503739f, 0.08969338f, 
    -0.10905768f, -0.23577064f, 0.25109738f, 0.28709745f, 0.26831910f, 0.30745718f, 0.25536531f, 0.18067630f, 
    0.14508991f, -0.10670978f, -0.41628352f, -0.28458652f, 0.47949266f, 0.46811259f, -0.18959595f, -0.33064756f, 
    -0.63899368f, -0.00113750f, 0.26761088f, 0.26428893f, -0.09560504f, -0.01077140f, 0.29759380f, -0.16308999f, 
    -0.38701677f, -0.08581065f, 0.35665450f, 0.00769789f, -0.05348164f, -0.03467255f, 0.01608033f, 0.29748219f, 
    0.02348373f, -0.04492778f, -0.40954232f, -0.09231403f, 0.35927093f, 0.24388301f, -0.20959593f, -0.62670690f, 
    -0.15691294f, -0.48564827f, 0.11051308f, 0.23116961f, 0.39983159f, -0.04560709f, -0.33907640f, -0.18752277f, 
    0.39446920f, 0.35834551f, -0.13640653f, -0.24050583f, -0.26226324f, -0.50838172f, -0.46068126f, -0.49154270f, 
    -0.48694411f, -0.40996128f, 0.41968751f, 0.16482744f, 0.09064417f, -0.43144614f, -0.91345096f, 0.11351883f, 
    -0.47709540f, 0.32525617f, 0.88747233f, 0.13696729f, -0.38840398f, -0.22623309f, 0.16882592f, 0.23410861f, 
    0.14310969f, -0.25456986f, -0.42638233f, 0.25757354f, 0.06636823f, 0.28236416f, 0.07220042f, 0.38968199f, 
    0.17144027f, -0.49702516f, 0.03302704f, -0.36080122f, 0.20417266f, -0.10960504f, -0.27971643f, 0.04818482f, 
    0.41344199f, -0.10279092f, -0.24479224f, -0.43324128f, -0.48736465f, -0.07847865f, 0.39111739f, 0.34344599f, 
    -0.03296600f, -0.09911317f, -0.11081807f, 0.51377952f, 0.32640499f, -0.43762940f, 0.43469131f, -0.21372989f, 
    -0.44850361f, -0.07362466f, -0.03239962f, -0.04839175f, -0.02891164f, 0.07324437f, 0.23113649f, -0.02006126f, 
    -0.03362784f, -0.21321683f, -0.50274277f, 0.08434224f, -0.20880234f, -0.70564389f, -0.35171625f, 0.00401383f, 
    -0.37589860f, -0.42035463f, 0.12443426f, -0.30694672f, 0.06098406f, 0.25416535f, -0.14020853f, -0.10792874f, 
    0.05460372f, -0.02311571f, 0.02898109f, -0.34387484f, -0.37292701f, 0.02226202f, -0.05015878f, -0.34816483f, 
    0.40993044f, 0.40008304f, 0.19174643f, -0.17068239f, 0.16513398f, 0.14968796f, -0.24286869f, 0.06457914f, 
    0.31707931f, 0.10431671f, -0.14943503f, 0.02048819f, 0.37654504f, -0.18802969f, 0.12935074f, 0.03293324f, 
    -0.25609425f, 0.03646565f, -0.20331307f, -0.15613981f, 0.12079880f, -0.17986223f, 0.07204991f, 0.16629097f, 
    0.28032920f, 0.20854779f, 0.50511420f, 0.40826544f, -0.52897251f, -0.40308160f, 0.38767040f, 0.12748744f, 
    0.36632410f, -0.23458096f, -0.47547668f, 0.22974260f, -0.21848208f, 0.22805440f, 0.05067672f, -0.27305120f, 
    -0.07555317f, 0.28573036f, -0.06540435f, 0.17355211f, -0.16743788f, -0.08020666f, -0.05497510f, -0.27785707f, 
    -0.14669286f, -0.12373529f, 0.05211513f, -0.08711153f, 0.30870056f, -0.28549442f, -0.50706851f, 0.76460254f, 
    -0.37327996f, 0.00640927f, -0.33546737f, -0.34365726f, -0.69291276f, 0.14941058f, 0.37700137f, -0.16338082f, 
    0.14986371f, -0.13859989f, 0.02698767f, 0.10454579f, 0.31504086f, 0.01446624f, 0.13012968f, -0.06106775f, 
    -0.25618222f, -0.11898995f, 0.18625759f, 0.13247275f, 0.62607998f, -0.15239947f, -0.25133133f, 0.21470526f, 
    -0.23030625f, 0.43381840f, 0.66440243f, 0.36256766f, -0.68845731f, -0.48269957f, -0.12360734f, 0.20982073f, 
    0.07488732f, -0.26502964f, 0.01614439f, 0.09841862f, -0.26177037f, 0.06518667f, 0.14928685f, -0.19747306f, 
    0.16884652f, -0.16738798f, -0.14119750f, -0.17516945f, 0.23443900f, -0.07781487f, -0.14206882f, 0.18007824f, 
    0.14856537f, -0.01304631f, 0.10015872f, 0.05138320f, -0.39951214f, -0.26117715f, -0.16953759f, 0.32217053f, 
    -0.34243128f, 0.05047412f, -0.05040212f, 0.50254256f, -0.21655945f, 0.15271986f, -0.10737590f, -0.05487573f, 
    0.03435739f, 0.17268108f, -0.03112928f, 0.13685746f, 0.07313558f, 0.01374559f, -0.54385841f, -0.72471160f, 
    -0.04987600f, 0.23412794f, -0.17062351f, -0.51132315f, -0.32719690f, -0.58905154f, -0.62447691f, -0.25553286f, 
    0.10062777f, -0.11493455f, -0.33228800f, -0.42738521f, -0.41691211f, -0.31892172f, -0.46517351f, -0.36204344f, 
    -0.31473988f, -0.15566027f, -0.16171089f, -0.12519848f, -0.07410275f, 0.09601901f, 0.23553775f, 0.32111779f, 
    0.27401200f, 0.28971669f, 0.31578842f, 0.50855559f, -0.15663218f, -0.31845033f, -0.19296215f, -0.20570748f, 
    -0.18936628f, -0.06816615f, 0.00102710f, 0.34087962f, 0.08622435f, 0.11361407f, -0.17021433f, -0.39883992f, 
    0.03924239f, 0.21840943f, 0.00302952f, -0.15315212f, 0.16471247f, 0.20820056f, -0.19232361f, -0.13804486f, 
    -1.04604161f, 0.80310357f, 0.50632948f, -0.74511951f, -0.21878427f, -0.21795118f, -0.35626042f, -0.16459215f, 
    0.33921865f, 0.32582656f, -0.11952709f, -0.27539864f, -0.24003090f, 0.12433732f, -0.30157185f, 0.44794610f, 
    -0.26714820f, 0.18480562f, 0.05572812f, -0.00044237f, -0.07337347f, 0.10412075f, -0.37650380f, -0.04078221f, 
    -0.56118160f, 0.48722234f, 0.31676620f, -0.08592549f, 0.15566081f, -0.15047607f, 0.27350825f, -0.39860496f, 
    0.07566939f, 0.56765634f, 0.03927019f, -0.21346714f, -0.19884726f, -0.17224303f, 0.20341280f, -0.11852299f, 
    0.16498944f, 0.19606221f, -0.17077646f, -0.33866510f, 0.19260158f, 0.19048272f, -0.08082640f, -0.01162266f, 
    -0.25003406f, -0.44058219f, 0.46732596f, -0.08937216f, 0.03961755f, -0.42165500f, -0.38284200f, 0.00922046f, 
    -0.07555291f, 0.29797703f, -0.06131545f, 0.15045181f, 0.01980435f, 0.38562241f, 0.23242155f, 0.14382009f, 
    -0.29655281f, -0.27155134f, -0.11274346f, 0.41312286f, -0.30173901f, -0.01990269f, 0.20781536f, 0.13535863f, 
    0.07584427f, -0.02824143f, -0.20315871f, 0.36502409f, 0.48822308f, 0.05060800f, -0.07370266f, -0.37135702f, 
    -0.51250708f, -0.55762601f, 0.33031398f, 0.52582479f, -0.14509659f, 0.26845905f, -0.32818902f, -0.09310526f, 
    0.39521551f, -0.28536496f, -0.12921610f, 0.05008056f, 0.24643356f, 0.31245601f, 0.06180905f, -0.14174354f, 
    0.20161918f, -0.31127298f, -0.41869065f, -0.20760213f, 0.49413982f, -0.04110028f, -0.21492803f, 0.08303119f, 
    -0.05245887f, -0.06730857f, -0.05544724f, 0.17139427f, 0.33952096f, 0.43647119f, 0.28836626f, -0.02025674f, 
    -0.31485799f, -0.20625967f, -0.12653495f, 0.37666982f, 0.22136097f, -0.28179157f, -0.15021639f, -0.35961446f, 
    0.01304439f, 0.33846849f, -0.10309653f, -0.35208321f, 0.01811407f, -0.95106286f, -0.42200717f, -0.52251744f, 
    0.43841857f, 0.70344573f, -0.27463177f, -0.24425319f, -0.05621331f, -0.50223738f, -0.03015331f, -0.19246346f, 
    -0.34598938f, 0.22044408f, 0.59730160f, -0.32626611f, 0.17513317f, -0.17684744f, -0.09832810f, -0.42032301f, 
    -0.32383162f, -0.07298571f, 0.52859116f, 0.29488745f, -0.13514160f, 0.25255796f, -0.15276356f, 0.09964539f, 
    0.35303959f, 0.36979190f, 0.43198884f, -0.28028291f, -0.17542869f, 0.50048441f, -0.03528096f, 0.36558694f, 
    0.02197110f, 0.27708641f, -0.26690638f, -0.30064163f, 0.25156245f, -0.20481169f, -0.15841933f, 0.12434843f, 
    -0.14288966f, -0.15638143f, 0.22036773f, -0.33639446f, 0.01753451f, -0.19175300f, -0.29490793f, 0.48629630f, 
    0.46283937f, -0.23011565f, -0.47269186f, 0.16494395f, -0.31521210f, -0.03668087f, 0.78725785f, -0.28666270f, 
    -0.68873131f, -0.31832486f, 0.12823203f, 0.28002375f, -0.18810663f, 0.04662236f, 0.35196075f, 0.03620931f, 
    0.18400775f, -0.16252320f, -0.19180295f, -0.08368248f, -0.11786252f, -0.25078088f, -0.01358230f, 0.35651937f, 
    -0.77402335f, -0.37046278f, -0.21092516f, -0.51264632f, -0.51587838f, 0.51513803f, 0.00760505f, -0.44271144f, 
    -0.44834676f, 0.12602833f, -0.03065304f, -0.11538935f, -0.06722124f, 0.05970099f, -0.08827854f, -0.06126329f, 
    0.05081925f, -0.30340600f, -0.02928467f, -0.24438147f, -0.12724978f, -0.06029160f, 0.23244105f, -0.41370270f, 
    -0.04678928f, 0.26622120f, 0.09465207f, -0.13949993f, 0.01813968f, -0.11722206f, -0.34098133f, -0.18401825f, 
    0.16703692f, -0.13596427f, -0.14745110f, 0.42362693f, -0.29174754f, 0.22213297f, -0.21472783f, -0.16424088f, 
    0.15634742f, 0.02156542f, 0.08847582f, -0.20956007f, -0.21107611f, -0.03380900f, 0.01626555f, 0.24710512f, 
    0.14688368f, 0.47420397f, 0.32563606f, -0.20569605f, 0.35950002f, -0.07110477f, 0.31904650f, 0.21682549f, 
    0.24888207f, 0.21349457f, -0.41337129f, -0.55968457f, -0.24363452f, -0.39557537f, 0.18602036f, -0.18007897f, 
    0.34018978f, 0.06583157f, -0.06698172f, 0.05932030f, -0.10394140f, -0.16216496f, -0.12011486f, -0.23266199f, 
    -0.14039820f, -0.32466802f, -0.42647851f, -0.94085497f, 0.19763637f, 0.00999444f, -0.55605441f, -0.19847278f, 
    0.03392232f, 0.20272566f, -0.47517091f, -0.30037916f, -0.30942693f, -0.20618649f, -0.40434977f, -0.32470578f, 
    -0.39051583f, -0.19902231f, -0.01198678f, -0.13591664f, -0.17966172f, 0.06273060f, -0.11046129f, 0.04374761f, 
    -0.14678386f, -0.32299402f, -0.38160631f, -0.35534689f, 0.33627906f, 0.51568586f, -0.21585777f, -0.57547492f, 
    0.17785004f, 0.35313261f, 0.12083488f, 0.02687263f, -0.45081204f, 0.04087158f, -0.46393558f, 0.29047161f, 
    -0.33126122f, -0.05360365f, 0.42191395f, -0.10784955f, 0.29434851f, 0.14652094f, -0.52511388f, 0.17826223f, 
    0.26832554f, -0.41016552f, -0.21257846f, 0.17356278f, -0.14509967f, -1.16667759f, -0.36547965f, -0.51821536f, 
    -0.84110636f, -0.58491760f, 0.85167938f, 0.11551555f, -0.17990361f, -0.16408682f, 0.37351146f, -0.41025990f, 
    -0.44613278f, -0.35202834f, -0.38214731f, -0.34007865f, 0.21055439f, 0.08819602f, -0.31891903f, 0.01233947f, 
    0.09616388f, 0.00611225f, -0.09561544f, -0.15868360f, -0.04449359f, -0.14443190f, 0.16701594f, -0.69717222f, 
    -0.55411214f, -0.42055374f, 0.40845999f, -0.37639132f, -0.46024337f, 0.14026634f, 0.39030662f, -0.05701113f, 
    0.30066472f, -0.36622390f, 0.42570299f, -0.09623588f, 0.36922336f, -0.18716292f, 0.02086226f, -0.33106002f, 
    -0.03013395f, 0.02141662f, -0.30858278f, 0.32262272f, -0.31052595f, -0.13310561f, 0.61803597f, 0.13454160f, 
    -0.53890234f, -0.39952084f, -0.55371147f, -0.53524417f, -0.03534343f, -0.02524394f, -0.15091857f, 0.18560892f, 
    -0.06411345f, 0.29122654f, -0.12302914f, -0.24346650f, 0.03597178f, -0.25295955f, -0.34783643f, 0.40641522f, 
    0.01380888f, -0.53056544f, -0.30428541f, -0.36264038f, -0.35872445f, 0.06253678f, -0.14567056f, -0.19855210f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01409288f, 0.15921740f, 0.24793701f, 0.17409153f, -0.13717556f, 0.08872995f, 0.14690372f, -0.11672276f, 
    0.05259802f, -0.45779160f, 0.15484647f, -0.31924883f, -0.18911301f, -0.24057864f, -0.13303463f, 0.35668060f, 
    0.14432949f, 0.19459087f, -0.18598258f, 0.16693713f, 0.04386556f, 0.08509955f, 0.03713542f, 0.31366029f, 
    0.01328351f, -0.22461003f, 0.02147845f, -0.00046408f, 0.08865552f, 0.03971880f, -0.13151009f, 0.27067825f, 
    -0.24523921f, 0.12279511f, 0.23622389f, -0.20658444f, 0.22884269f, -0.17863263f, 0.21566226f, 0.17629448f, 
    -0.08842918f, -0.30171010f, 0.14864185f, -0.18516330f, 0.05644342f, 0.17217119f, 0.04795267f, -0.07615728f, 
    0.12316214f, 0.05812261f, -0.13640702f, 0.20557237f, 0.34633136f, 0.00284189f, -0.19727379f, 0.19223954f, 
    -0.04923730f, 0.14245403f, -0.16142675f, -0.34562251f, 0.38734734f, -0.26351580f, 0.33546096f, 0.08118670f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03514836f, -0.02853619f, -0.01157219f, -0.00796589f, -0.03766553f, 0.00546046f, 0.00353933f, 0.02439631f, 
    -0.02884740f, -0.00122526f, -0.03297002f, -0.03245629f, -0.00855112f, 0.00607104f, -0.01762951f, 0.00239318f, 
    0.02870748f, -0.02498731f, 0.00515530f, -0.02946029f, 0.00566183f, -0.00381448f, -0.01507785f, -0.00866115f, 
    -0.02918847f, -0.01438248f, 0.02832323f, -0.00021495f, -0.00471920f, -0.02932201f, -0.00262017f, -0.01776280f, 
    -0.04078548f, -0.02271543f, -0.00524629f, 0.00319988f, -0.02723250f, 0.01262007f, 0.00265644f, -0.00461217f, 
    -0.00565245f, -0.02728045f, -0.02028450f, 0.01041801f, 0.02805306f, 0.02249695f, -0.04144511f, -0.02651545f, 
    0.01042142f, -0.01167096f, 0.03584185f, 0.03186401f, -0.00905798f, 0.03605267f, -0.01823679f, 0.03562083f, 
    -0.03946853f, -0.02020569f, -0.01427797f, -0.02579570f, -0.01497973f, 0.00141391f, 0.01922242f, -0.00787786f, 
    -0.04317291f, -0.01429869f, 0.01025935f, 0.02864595f, 0.00798013f, -0.01018960f, -0.01214346f, -0.01552977f, 
    0.02309204f, -0.01574725f, 0.02008937f, 0.01475388f, -0.02824762f, 0.02776852f, 0.00169233f, -0.01288071f, 
    -0.01258295f, 0.01491482f, -0.03550906f, -0.02305506f, -0.00815395f, 0.02463379f, 0.01642069f, -0.03457331f, 
    0.01365472f, -0.03401420f, -0.00338572f, -0.03127199f, -0.03006949f, 0.00826674f, -0.02413547f, -0.00755374f, 
    -0.03958023f, 0.01467933f, 0.01527390f, 0.02555799f, -0.02016241f, -0.02159722f, -0.02821461f, 0.02380812f, 
    -0.03108991f, 0.00643954f, -0.00017536f, 0.01936888f, -0.03327559f, -0.00351234f, 0.00184572f, -0.00338521f, 
    0.00637378f, -0.01956545f, 0.00642166f, -0.00656704f, -0.03116498f, 0.02248623f, -0.03394979f, -0.02719628f, 
    0.02779325f, -0.00477522f, -0.03469330f, 0.00249875f, -0.01957699f, -0.02136465f, -0.01940870f, 0.00316722f, 
    -0.02957864f, -0.00681587f, -0.01635840f, -0.00306830f, 0.00736630f, 0.03109705f, 0.02807914f, 0.01554202f, 
    0.00137879f, -0.01982996f, 0.00629661f, -0.02179096f, -0.01261136f, 0.00828245f, 0.02008925f, -0.03792473f, 
    0.02166221f, 0.00609418f, -0.01854220f, -0.01095252f, -0.02375770f, -0.00524114f, 0.02304626f, 0.02506267f, 
    -0.01478126f, 0.00610344f, 0.02559045f, -0.01244473f, -0.03921888f, -0.01018493f, -0.01499311f, -0.01440847f, 
    -0.03657124f, 0.02852736f, 0.02420870f, -0.02837290f, 0.01354551f, -0.01065498f, -0.02145414f, 0.02585733f, 
    -0.03341996f, -0.02760194f, -0.02111314f, 0.02325975f, -0.01528742f, -0.00373296f, -0.00120176f, -0.01175493f, 
    -0.02051674f, -0.03784389f, -0.04122009f, 0.02598688f, -0.03207850f, -0.03527946f, -0.00683575f, 0.02905685f, 
    -0.02049241f, 0.02715232f, 0.03022869f, 0.02369663f, -0.00070236f, 0.02592020f, -0.00182561f, -0.03458964f, 
    -0.01662814f, 0.01357076f, 0.03124959f, 0.02835839f, 0.02105298f, -0.01435492f, -0.01806446f, 0.01326326f, 
    -0.02434205f, -0.01995777f, 0.01361682f, -0.03663865f, -0.00933745f, -0.00607660f, 0.00650842f, 0.02866720f, 
    -0.02045096f, -0.00183747f, 0.02531794f, -0.00162186f, -0.00406328f, 0.00526723f, -0.01743933f, -0.03333924f, 
    0.02606448f, -0.00583487f, -0.03432982f, -0.01710592f, -0.00520309f, -0.02922010f, 0.00074118f, -0.03297947f, 
    -0.04114065f, -0.03796218f, 0.02491182f, -0.01731365f, 0.02824915f, -0.02461044f, 0.02686494f, 0.01992914f, 
    -0.04410208f, -0.00516981f, -0.00699770f, -0.01015305f, -0.02412444f, -0.03531376f, -0.01231021f, -0.02606883f, 
    0.00783122f, 0.01027135f, -0.00228254f, 0.03211932f, -0.03275220f, 0.02107001f, -0.02406058f, 0.01135901f, 
    0.02742166f, 0.00164500f, -0.01599465f, -0.02934448f, 0.01145623f, 0.03027552f, -0.02498765f, -0.00680546f, 
    0.02416932f, 0.00200443f, 0.02144992f, 0.01055233f, -0.00476657f, -0.02193215f, -0.03524511f, 0.00583444f, 
    -0.02764432f, -0.01724765f, 0.01333211f, -0.02809467f, 0.00020890f, -0.02555351f, -0.00986468f, 0.01239349f, 
    0.00349536f, 0.00546604f, -0.00828137f, 0.02749806f, -0.02596596f, 0.01449874f, 0.00837510f, -0.03505087f, 
    -0.00145602f, 0.01680787f, 0.01001590f, 0.00175181f, -0.02013898f, 0.00621749f, 0.02824278f, 0.01626636f, 
    -0.00729362f, -0.00355289f, -0.03514365f, -0.03631881f, -0.02692571f, 0.00504514f, 0.02789080f, -0.00217356f, 
    0.02557511f, 0.02396643f, -0.03531514f, -0.02405984f, 0.00114146f, -0.00856876f, -0.01486733f, -0.00974389f, 
    0.00204562f, 0.01409511f, -0.03648949f, 0.02379129f, 0.00261605f, 0.00609657f, 0.02883989f, 0.01285612f, 
    -0.00093420f, 0.02748715f, 0.00253929f, 0.00528642f, 0.03016951f, -0.00665770f, 0.01053770f, -0.02350272f, 
    -0.03124002f, 0.02559048f, -0.03015322f, -0.03690530f, -0.01355209f, -0.01004525f, 0.02399854f, -0.02089998f, 
    -0.02029514f, 0.02558354f, 0.00079055f, 0.00110011f, 0.00602374f, -0.02964846f, -0.03206165f, 0.02151511f, 
    0.03048106f, 0.01721263f, -0.03864874f, 0.01289325f, 0.00954422f, -0.04240181f, -0.03639086f, -0.04271660f, 
    0.02201857f, -0.02223398f, -0.00918746f, -0.02162272f, -0.04165282f, -0.00732805f, -0.02034273f, -0.03964128f, 
    0.02673305f, -0.02520875f, -0.00685441f, -0.01460490f, -0.02584513f, -0.01958906f, -0.02460346f, -0.00212338f, 
    0.01858813f, 0.02178432f, -0.01386269f, 0.02632617f, -0.00240145f, -0.01871242f, 0.00626626f, 0.00597086f, 
    -0.00236781f, -0.04102325f, -0.03414012f, -0.03342933f, 0.01462651f, -0.00850869f, -0.03876048f, -0.01002096f, 
    -0.01620966f, -0.00762520f, -0.02187216f, 0.01892510f, 0.02369147f, 0.01684588f, 0.01518534f, -0.02968028f, 
    -0.03458289f, 0.01283096f, -0.01055954f, -0.03614803f, -0.02925638f, -0.02405587f, -0.01685366f, -0.02936917f, 
    -0.00818441f, -0.03579112f, 0.01835486f, -0.02333175f, 0.02548733f, -0.03494512f, 0.00991831f, 0.02158239f, 
    -0.01687752f, -0.00093745f, -0.02760487f, 0.00062390f, 0.00892272f, -0.01671345f, 0.02643206f, -0.01985627f, 
    -0.02026324f, -0.02940069f, 0.02119379f, 0.01766125f, -0.01383606f, 0.02202417f, 0.02749128f, -0.01582660f, 
    -0.01560164f, -0.03423496f, 0.02826789f, 0.02563383f, -0.01587938f, 0.00982970f, 0.00610394f, 0.02359985f, 
    -0.00069374f, 0.01022594f, -0.01138907f, 0.00019669f, 0.02114616f, -0.00970618f, -0.04224149f, 0.02002143f, 
    -0.02532645f, 0.00963182f, -0.03474334f, -0.00923277f, -0.00311784f, -0.00924718f, 0.02197356f, 0.02063725f, 
    0.01088963f, -0.02256412f, -0.01813498f, 0.01172497f, 0.00150258f, 0.01626286f, -0.01549621f, -0.03985054f, 
    0.02559362f, -0.02123477f, 0.01903743f, -0.03674268f, -0.03163790f, 0.01670275f, -0.01173763f, -0.02789671f, 
    -0.02005051f, 0.01555181f, 0.02519830f, 0.02874419f, 0.00656578f, -0.01427521f, 0.00913218f, -0.03724721f, 
    -0.02219366f, 0.01568064f, -0.03734388f, 0.01695959f, 0.00275725f, 0.01739294f, 0.01030251f, 0.02294158f, 
    0.00055444f, -0.02855174f, 0.01163646f, 0.02281270f, 0.00024288f, -0.01486929f, 0.00174537f, 0.00777740f, 
    0.02467007f, 0.00506543f, -0.01905823f, 0.02218292f, -0.03660071f, 0.02504955f, -0.02959435f, 0.02420394f, 
    -0.01711782f, -0.03407228f, -0.02973880f, 0.01756697f, -0.03468775f, -0.03510312f, 0.01981693f, 0.00302872f, 
    0.04365296f, 0.02863915f, -0.03761239f, -0.01705720f, -0.02930445f, 0.01705750f, 0.00356602f, 0.01786852f, 
    -0.01735280f, -0.02973866f, 0.01694568f, 0.01821621f, -0.03493382f, 0.00237102f, -0.01439893f, -0.02150824f, 
    0.00989024f, 0.02387494f, -0.00715518f, 0.00461330f, -0.03513663f, -0.02893345f, 0.02728571f, -0.01373341f, 
    -0.03555845f, -0.00247687f, -0.00706125f, 0.00780995f, -0.02231880f, -0.01729112f, -0.00183585f, 0.00300637f, 
    0.01644738f, -0.02260654f, 0.00480763f, 0.02411206f, -0.00880183f, 0.02562646f, 0.00503725f, -0.02282847f, 
    -0.03687526f, -0.01769522f, 0.01349495f, -0.02514878f, -0.00852269f, 0.01121722f, -0.00761925f, 0.01980680f, 
    -0.00412205f, -0.01829621f, -0.00246156f, -0.02130626f, 0.00334285f, -0.02432970f, -0.00775437f, 0.01201187f, 
    -0.04106501f, -0.00649260f, 0.00401986f, 0.02522532f, 0.02959172f, -0.00467135f, -0.02241568f, 0.00852884f, 
    0.01444844f, -0.02332104f, -0.03200692f, -0.03098585f, -0.03644181f, -0.01807434f, -0.02320969f, 0.03054081f, 
    0.02477310f, 0.02649426f, 0.02633094f, 0.00774623f, 0.01996063f, 0.00558671f, -0.03499327f, -0.00266256f, 
    -0.04157529f, -0.04325783f, 0.01439769f, -0.03495437f, 0.01812386f, -0.04320260f, -0.00474258f, -0.03031363f, 
    -0.03595459f, -0.01681024f, -0.02864897f, 0.01500650f, -0.02713624f, -0.01748883f, -0.00094366f, 0.02663371f, 
    -0.00946382f, 0.00385240f, 0.00424304f, -0.02280658f, 0.02439031f, -0.02262362f, -0.02418830f, -0.00876350f, 
    -0.00056029f, 0.01966291f, -0.00412460f, 0.02264083f, 0.02909112f, -0.03497346f, -0.00013023f, -0.01837240f, 
    -0.02114215f, -0.01683827f, -0.02711119f, -0.03423560f, 0.00041990f, -0.00405915f, -0.01165092f, -0.01241198f, 
    0.01721448f, -0.00967030f, 0.02576358f, 0.01759930f, 0.02350198f, -0.02458413f, 0.01568092f, -0.01080106f, 
    -0.01870240f, -0.03435807f, 0.01169841f, -0.02087203f, -0.03465116f, -0.01877946f, 0.02291486f, -0.03517011f, 
    0.01774433f, 0.00313101f, 0.01445834f, 0.00805212f, -0.03325498f, 0.02632683f, 0.02316757f, -0.03472473f, 
    -0.03259259f, -0.00019015f, 0.02750414f, -0.03686955f, -0.03454133f, 0.01725257f, -0.01157801f, -0.04141968f, 
    -0.02061558f, 0.01369438f, -0.00233304f, -0.01171427f, 0.01428241f, -0.00801282f, 0.01272652f, 0.00430658f, 
    -0.03190183f, 0.00525501f, -0.01297972f, 0.02019010f, -0.03854741f, -0.00566952f, -0.03118600f, 0.02944490f, 
    0.01598980f, -0.03868254f, 0.01266169f, -0.00043991f, -0.01970833f, -0.00558742f, -0.01354976f, -0.03957257f, 
    -0.02288729f, 0.02108560f, 0.01668019f, -0.03435513f, -0.01525199f, 0.02736905f, -0.03341918f, -0.01767541f, 
    0.02225629f, -0.02796762f, -0.03511095f, -0.02574959f, 0.02018594f, -0.03661700f, 0.02185596f, -0.00809158f, 
    0.01362974f, -0.01012458f, -0.02484395f, 0.02508144f, -0.00758615f, -0.02993895f, -0.04140019f, -0.03405710f, 
    0.00196703f, -0.02419835f, -0.02576798f, -0.02716561f, -0.01241503f, 0.01939450f, -0.02956753f, 0.02515059f, 
    -0.00305542f, 0.00421680f, 0.01591862f, -0.04117575f, -0.01567499f, -0.01758163f, 0.01338075f, 0.01127532f, 
    -0.03000952f, 0.02509223f, 0.01173769f, 0.01859934f, -0.03000513f, -0.01515285f, -0.00860785f, 0.01269096f, 
    0.02844245f, -0.00505780f, -0.02207158f, 0.02368907f, 0.00809924f, -0.01150911f, -0.02316185f, 0.00216588f, 
    0.01879875f, -0.03645981f, -0.02774541f, 0.00065098f, 0.02194446f, -0.04006238f, -0.02243598f, 0.00686955f, 
    -0.04024897f, -0.03601913f, 0.01120326f, 0.00619650f, -0.02551189f, 0.02463498f, -0.01016954f, 0.02880576f, 
    -0.00921860f, 0.00312528f, -0.01246539f, 0.00208642f, 0.02576814f, 0.00162934f, 0.00638256f, 0.02083712f, 
    -0.01073403f, -0.04246670f, 0.02663801f, -0.03155182f, 0.02079371f, 0.01155634f, -0.02285830f, -0.00699070f, 
    -0.01299632f, -0.03689696f, 0.01998682f, 0.01144752f, 0.00999161f, -0.03488616f, -0.03683832f, -0.04136338f, 
    -0.00262018f, 0.02295839f, -0.03541840f, -0.00152263f, -0.01202498f, -0.00672500f, -0.04055990f, -0.01064928f, 
    0.02551979f, -0.03154806f, 0.01758276f, -0.02110736f, -0.02011283f, 0.00143062f, 0.01335943f, -0.02689713f, 
    0.00792942f, 0.00894015f, 0.01696725f, -0.03722986f, 0.00531983f, -0.03092573f, -0.00620613f, -0.01891331f, 
    -0.01429470f, -0.02791923f, 0.00488240f, -0.01972220f, -0.03092901f, 0.01700338f, -0.01550365f, 0.00978422f, 
    -0.03591009f, -0.00653973f, -0.02142081f, -0.00613113f, -0.02676734f, 0.02512269f, -0.04093241f, 0.02441015f, 
    0.02523057f, -0.03258158f, -0.03275644f, 0.01741280f, 0.01500627f, 0.02710689f, -0.03801791f, 0.02432130f, 
    0.00115333f, -0.02346334f, -0.00266508f, -0.00126689f, -0.02489847f, -0.00326606f, -0.00147902f, 0.02324438f, 
    0.01557020f, -0.03650818f, 0.01508501f, 0.02199415f, 0.01085032f, -0.01857107f, 0.02623351f, -0.03199164f, 
    0.02690421f, -0.03273842f, -0.00544622f, -0.02704051f, 0.02100519f, 0.00464442f, -0.00258674f, 0.02439718f, 
    -0.01390988f, -0.02863130f, -0.00914877f, 0.00375302f, 0.00806826f, -0.01681991f, 0.00364373f, 0.01711909f, 
    0.01421323f, 0.02817518f, -0.01417306f, -0.04130520f, -0.01585586f, 0.00439287f, -0.02288219f, -0.03849449f, 
    0.01028224f, 0.02004164f, -0.01265735f, -0.03480860f, -0.02629143f, 0.00517490f, 0.01403325f, 0.00848040f, 
    -0.03377814f, -0.02938675f, -0.00550852f, -0.00082382f, 0.02647330f, 0.00536695f, -0.01976491f, -0.03976069f, 
    0.00784841f, -0.02027443f, 0.02651096f, -0.02263574f, 0.01304904f, 0.02237026f, -0.03704161f, 0.02227065f, 
    0.02519796f, -0.04173222f, 0.01931575f, -0.01334070f, 0.00288289f, 0.00920948f, 0.00429948f, -0.00705676f, 
    0.00596836f, 0.02705957f, -0.01099768f, 0.00276036f, -0.03404671f, 0.02383627f, 0.01648164f, -0.03411937f, 
    -0.00780622f, -0.00484332f, 0.01125065f, -0.00558865f, -0.03535664f, 0.02039263f, -0.00869718f, -0.03024984f, 
    0.00072747f, -0.00164243f, 0.00612379f, 0.00548516f, 0.01736716f, -0.04257345f, 0.02501637f, 0.00848352f, 
    -0.01419217f, 0.02708833f, -0.01883753f, -0.03541947f, 0.00391836f, 0.01088321f, 0.00647154f, -0.01063933f, 
    -0.03633318f, -0.00612736f, -0.00344828f, -0.04124484f, -0.02096041f, 0.02490343f, 0.00504913f, -0.03497476f, 
    -0.01273729f, -0.00751429f, -0.00638468f, 0.02744148f, -0.01137203f, 0.00177108f, 0.02678710f, 0.02077056f, 
    0.00802703f, -0.02689298f, -0.00623944f, 0.01276209f, 0.00875054f, -0.04055711f, -0.01852522f, 0.01529327f, 
    -0.03854254f, -0.02718030f, -0.01435025f, -0.01730752f, -0.00373828f, 0.01280360f, 0.00631097f, -0.01496060f, 
    0.01729256f, 0.00699928f, -0.01867581f, 0.00675881f, 0.00853076f, 0.01780744f, -0.03872147f, 0.01968805f, 
    -0.03813064f, -0.02210921f, -0.00822140f, -0.01650050f, 0.00714502f, -0.03028681f, 0.01194929f, 0.00039764f, 
    0.02238190f, -0.02673934f, -0.03509200f, -0.00204308f, -0.01016691f, 0.01367320f, -0.03060641f, -0.01175385f, 
    -0.01439677f, -0.01977699f, -0.03023876f, -0.03269885f, -0.02527208f, 0.01875740f, 0.00948410f, -0.00812905f, 
    0.00831390f, -0.01047499f, -0.01293983f, -0.04003936f, 0.01268198f, 0.01183327f, 0.01726302f, -0.03538966f, 
    0.00685835f, -0.00229428f, 0.01512186f, -0.01232138f, 0.02268733f, 0.02698926f, -0.04089764f, 0.02714919f, 
    -0.01754801f, 0.02109633f, -0.00702918f, -0.01178446f, -0.01436047f, -0.01670004f, 0.00351335f, 0.00711626f, 
    0.02507185f, -0.03595029f, -0.00352267f, -0.01395147f, 0.01187699f, -0.00744402f, -0.01233067f, -0.02856901f, 
    -0.00316875f, 0.02688963f, 0.00191149f, -0.00779381f, -0.01122406f, -0.02922178f, 0.01363506f, -0.03533940f, 
    0.01822350f, -0.01590550f, -0.02082440f, -0.03664057f, -0.02077868f, -0.04213085f, -0.01410941f, 0.01848504f, 
    -0.00010321f, 0.01861433f, 0.00691381f, -0.00464624f, 0.00669178f, -0.03154910f, -0.01304153f, -0.03736672f, 
    -0.03729314f, -0.02439241f, -0.03252026f, -0.02397970f, -0.00942110f, -0.02467746f, -0.02220148f, 0.02890538f, 
    -0.01949814f, -0.00451058f, -0.01056772f, -0.00123572f, 0.00015701f, -0.03379956f, -0.02750981f, 0.01732896f, 
    -0.00734280f, -0.03856469f, 0.02122806f, -0.04111189f, -0.01498883f, 0.00622047f, -0.02570628f, -0.02322922f, 
    0.01656572f, -0.02794315f, 0.01998984f, -0.00521310f, -0.01438705f, -0.01181636f, 0.01672799f, 0.00893403f, 
    0.01230948f, 0.00497427f, -0.00976342f, -0.04071729f, -0.00588363f, 0.00293113f, -0.01350315f, 0.01376679f, 
    0.02437667f, -0.01257624f, -0.03876616f, -0.00034899f, 0.01121232f, 0.02274033f, -0.03047061f, 0.01370570f, 
    -0.01168650f, -0.00712762f, -0.01594356f, -0.03862391f, 0.00811341f, 0.00617069f, -0.03856157f, -0.00549316f, 
    -0.01683202f, -0.00741480f, 0.00207211f, -0.04381921f, -0.02503242f, 0.02020616f, -0.01747845f, -0.03464226f, 
    0.02174691f, -0.02549809f, 0.02504209f, -0.01788973f, 0.00555473f, 0.00454974f, -0.03706923f, -0.02132247f, 
    -0.03500063f, 0.01134148f, 0.01008231f, 0.02896420f, 0.01410396f, 0.00775421f, 0.02429803f, -0.02168189f, 
    0.02448882f, 0.02398868f, 0.01607823f, 0.00268530f, -0.00538354f, -0.01114020f, -0.03382725f, -0.04199376f, 
    -0.01964093f, 0.00486252f, -0.02459924f, 0.01320856f, -0.00088963f, -0.00060317f, -0.01266477f, 0.00342925f, 
    0.00378518f, 0.01103482f, -0.02541463f, 0.02702394f, -0.00482000f, 0.01764441f, 0.01745234f, -0.01393417f, 
    -0.01210156f, 0.02023500f, -0.01313345f, -0.01478847f, -0.02036785f, -0.03272480f, -0.01239009f, -0.00629117f, 
    -0.02988677f, 0.00926010f, -0.03024295f, -0.03948857f, 0.00191081f, -0.03849337f, -0.02217489f, -0.03929733f, 
    0.01699437f, -0.02213619f, 0.00117653f, 0.01638507f, 0.02978315f, 0.00086661f, -0.03593302f, 0.00513466f, 
    -0.00444011f, -0.01748594f, 0.01834996f, -0.01156873f, 0.01326266f, -0.00630687f, -0.01605532f, -0.01461769f, 
    -0.03195684f, -0.00799581f, -0.03161506f, -0.01654254f, 0.00632897f, -0.03358912f, 0.02792421f, 0.00562330f, 
    -0.03594108f, -0.03709606f, -0.00070916f, -0.02917608f, -0.01884687f, 0.01895706f, 0.00669542f, 0.02512392f, 
    -0.00131649f, -0.03706726f, 0.00396416f, 0.01284656f, -0.04037154f, 0.00589222f, 0.02037781f, -0.03364440f, 
    0.01520559f, -0.00912210f, 0.01846512f, 0.00736884f, -0.01538065f, -0.04190600f, 0.00029361f, -0.01274205f, 
    -0.04033452f, -0.02653343f, 0.01613686f, -0.00207225f, 0.02565958f, 0.01031119f, -0.02968254f, -0.01053498f, 
    0.01762233f, -0.01867088f, -0.03616682f, -0.02499096f, 0.02442726f, -0.03062928f, -0.00558095f, 0.02760344f, 
    0.02085256f, -0.02712231f, -0.02310375f, -0.00976745f, -0.04172677f, -0.03646654f, 0.01501639f, -0.03028471f, 
    0.02738852f, -0.01683187f, 0.00415313f, -0.01620613f, -0.03863823f, -0.03761950f, -0.02621731f, -0.01657348f, 
    -0.04251673f, 0.02280022f, -0.03963491f, -0.03424276f, -0.02809585f, 0.00468442f, 0.00581239f, -0.02925540f, 
    -0.01036179f, -0.01099368f, 0.00618511f, -0.03758281f, -0.03341842f, 0.00945268f, -0.01446403f, 0.01141230f, 
    0.00521771f, -0.02852113f, -0.02037449f, -0.01805181f, 0.00093792f, 0.01189420f, -0.00432878f, 0.01143368f, 
    0.00341083f, -0.01297838f, -0.02355224f, -0.04335548f, 0.02437725f, 0.00554208f, -0.00085450f, 0.00095409f, 
    0.00731384f, 0.01298745f, -0.01010500f, -0.03847521f, -0.01239928f, -0.00861100f, -0.03750439f, -0.03319710f, 
    0.00202888f, -0.04000362f, -0.04179985f, 0.02847887f, 0.00984788f, 0.00666316f, -0.00183060f, -0.01058450f, 
    -0.02229032f, 0.01138702f, -0.00548501f, 0.00410476f, -0.00475643f, -0.01743267f, 0.01981226f, -0.01684582f, 
    0.00180527f, -0.01684861f, -0.01884217f, -0.03001810f, -0.02857264f, -0.02401757f, -0.01664911f, -0.00435776f, 
    -0.01545614f, -0.00685678f, 0.01446889f, 0.00638162f, 0.00294897f, -0.00165456f, 0.00279989f, -0.00975404f, 
    0.02792871f, -0.00409106f, -0.00204704f, 0.00841061f, -0.03625309f, 0.02107039f, -0.01162322f, -0.03434080f, 
    0.02088678f, -0.03849967f, -0.00211551f, -0.00732407f, -0.01796936f, -0.01296192f, 0.02524978f, -0.00323595f, 
    0.01137159f, -0.02027730f, -0.01128813f, 0.00521625f, -0.00108383f, -0.00041010f, 0.02823644f, -0.02588874f, 
    -0.01899419f, -0.01246084f, 0.01893645f, 0.01933414f, -0.04087377f, -0.00293495f, -0.03265389f, -0.04171332f, 
    0.00243512f, 0.01593882f, -0.04138952f, -0.03369864f, 0.02495829f, 0.00802981f, 0.00476326f, 0.00870776f, 
    0.01688315f, -0.02787767f, -0.00083683f, 0.01842429f, -0.03942750f, 0.02215708f, -0.01243669f, 0.01450604f, 
    0.00986191f, -0.02394705f, -0.00328672f, 0.00324886f, 0.02327894f, -0.00702567f, -0.03548123f, -0.01301672f, 
    -0.04235151f, -0.03965323f, -0.00475330f, 0.01461162f, -0.01457180f, -0.00240719f, -0.04317730f, -0.02874931f, 
    -0.02658131f, -0.01803346f, -0.03741755f, 0.00155181f, 0.01955369f, 0.02567724f, 0.02903076f, -0.04110967f, 
    0.02342597f, 0.02456629f, -0.02967477f, -0.03318527f, -0.03110261f, -0.02476892f, 0.02226362f, -0.00646848f, 
    -0.01121106f, 0.02178377f, -0.00606394f, -0.02329440f, -0.01490745f, -0.00339057f, 0.02106600f, -0.00312882f, 
    -0.00307920f, -0.02796958f, -0.01129461f, -0.00454054f, 0.02442061f, 0.02995568f, 0.00247573f, -0.00554828f, 
    -0.02252617f, -0.01372994f, -0.03687419f, 0.01730469f, 0.01419196f, -0.02178876f, 0.02342988f, 0.01126808f, 
    0.02426058f, -0.03519653f, -0.03622514f, 0.01948236f, -0.03974049f, -0.03849331f, -0.03020536f, 0.01009262f, 
    0.00900897f, -0.00239384f, -0.02988108f, -0.02241754f, -0.03888392f, -0.03678395f, -0.03217122f, 0.02714770f, 
    -0.03152783f, 0.02325259f, -0.02984479f, -0.00364832f, -0.01609698f, 0.02897389f, -0.01479862f, 0.01130791f, 
    0.02963892f, -0.01344004f, -0.01540267f, -0.02252979f, -0.03273299f, -0.02290435f, -0.03375065f, -0.03465727f, 
    -0.02034850f, 0.00042001f, -0.00649383f, -0.03641103f, 0.00327778f, 0.00776505f, 0.01384005f, -0.03774291f, 
    -0.01293913f, -0.00313478f, -0.00698709f, 0.02084696f, 0.00399786f, -0.01840368f, 0.01869820f, 0.01608883f, 
    -0.03964292f, -0.00433637f, -0.01011879f, -0.02544556f, 0.02614356f, -0.01344938f, -0.02017788f, -0.03462040f, 
    -0.02954312f, 0.00523013f, 0.02391389f, -0.00475110f, 0.02337164f, -0.03718361f, -0.01550433f, -0.02335888f, 
    -0.01761532f, 0.01744372f, -0.03476098f, -0.00043532f, -0.04008482f, -0.01456281f, -0.03403540f, -0.02117452f, 
    -0.01957908f, 0.00084348f, 0.01058900f, 0.02521161f, 0.02343602f, 0.01623460f, 0.02737755f, -0.00728229f, 
    -0.03035294f, -0.03640747f, 0.02752779f, -0.02306647f, 0.02667671f, -0.04062623f, -0.00581033f, -0.01635483f, 
    -0.02673578f, -0.02942623f, -0.01394487f, -0.00872081f, -0.03938003f, -0.03289372f, 0.00768586f, 0.00661773f, 
    -0.03557411f, 0.01083588f, 0.00897133f, -0.00253431f, 0.00843311f, -0.04202840f, -0.01178964f, -0.01311592f, 
    -0.03163942f, -0.02361296f, -0.04187895f, 0.00518072f, -0.01654444f, 0.00763754f, 0.02118075f, -0.01300353f, 
    -0.03066989f, 0.02074865f, -0.04030083f, 0.02972390f, 0.02763813f, -0.02832970f, -0.00598125f, -0.01737479f, 
    0.27370569f, -0.21855809f, 0.55932939f, -0.08404865f, -0.07067967f, -0.12883259f, -0.09178894f, -0.07749833f, 
    -0.05208543f, -0.03487251f, -0.04683957f, 0.01194900f, -0.14105694f, -0.01015038f, 0.00782374f, -0.04158973f, 
    0.05827327f, -0.02507237f, 0.08542795f, -0.12637281f, -0.05061197f, 0.07733520f, 0.05856654f, -0.02666349f, 
    0.13338464f, 0.00298583f, 0.27603942f, 0.38547939f, 0.00293320f, -0.02967903f, 0.01980027f, 0.11096614f, 
    -0.06018741f, 0.10342294f, -0.01273497f, 0.01277576f, 0.27953559f, 0.00947989f, 0.08244053f, -0.20117921f, 
    -0.15889849f, -0.04720580f, 0.02880783f, -0.03485528f, -0.15855952f, 0.10533896f, 0.03431958f, -0.15699135f, 
    -0.10655917f, 0.08462843f, -0.06077719f, 0.06279255f, 0.08311683f, -0.07208239f, 0.06086297f, 0.04684814f, 
    -0.09686608f, 0.11307930f, 0.01000336f, 0.28798667f, 0.58501595f, -0.05667376f, 0.23619761f, 0.10840844f, 
    0.04165619f, 0.13439162f, -0.05869430f, 0.20771825f, -0.02348059f, 0.10283525f, -0.03951625f, 0.04890804f, 
    -0.10758110f, 0.03603983f, -0.36256796f, 0.19603427f, -0.00313458f, 0.01037721f, -0.01690662f, 0.11075344f, 
    -0.02170437f, 0.12025242f, -0.00667991f, 0.03511093f, 0.15669298f, -0.10310324f, 0.14159614f, 0.02276061f, 
    0.01503259f, -0.02758794f, -0.02300097f, -0.14928226f, 0.08792170f, 0.02793833f, -0.05587495f, -0.10418186f, 
    -0.22241561f, -0.25663865f, -0.00926260f, 0.14774570f, 0.01399679f, 0.12267900f, 0.10413121f, 0.14401630f, 
    0.04578228f, 0.07958258f, 0.10660259f, 0.08692541f, -0.02852349f, 0.02390773f, -0.11612339f, -0.16884209f, 
    -0.09550044f, 0.00754152f, 0.03865576f, 0.02665000f, 0.27427572f, 0.16629542f, 0.02542746f, -0.12422556f, 
    0.07050525f, -0.02816591f, 0.08505515f, 0.17588040f, 0.03611157f, 0.06680589f, -0.00885028f, 0.04093317f, 
    -0.19542117f, -0.02159772f, 0.09365372f, 0.08983871f, -0.15043654f, -0.04343616f, -0.02941647f, -0.21190357f, 
    -0.02849599f, -0.02023250f, 0.02382727f, -0.03334995f, 0.23069341f, 0.17108053f, 0.19647266f, 0.04944019f, 
    0.00790392f, 0.05085762f, 0.01666912f, 0.01337802f, 0.09652526f, -0.03982908f, -0.07209909f, 0.02386719f, 
    0.00878108f, 0.14071603f, 0.17793064f, 0.16636467f, -0.09238845f, -0.13866846f, -0.10636849f, 0.03198076f, 
    0.04119568f, 0.01945250f, 0.04998830f, -0.08271454f, 0.07006733f, 0.06894038f, 0.10943785f, 0.07081109f, 
    -0.21204694f, 0.00470443f, -0.06948696f, 0.09098862f, 0.11463371f, 0.07072890f, 0.15960480f, 0.08955096f, 
    -0.04074647f, -0.09407469f, -0.12641752f, -0.13230522f, -0.01945422f, 0.08909719f, 0.09696515f, 0.17779724f, 
    -0.00209388f, -0.08071277f, 0.01132082f, 0.00219870f, -0.12202101f, 0.22775482f, -0.05407445f, 0.10732609f, 
    -0.01730549f, -0.01068639f, 0.19678098f, 0.05973552f, -0.17029969f, -0.04789967f, 0.04694161f, -0.11298867f, 
    0.03036953f, -0.02243810f, -0.06808478f, -0.08209423f, -0.16307557f, -0.07223730f, 0.33101079f, -0.20797446f, 
    -0.15116461f, -0.15256932f, -0.05961854f, -0.12703083f, -0.05995756f, 0.01261272f, -0.04505357f, 0.07461954f, 
    -0.04991510f, -0.12068843f, -0.01059740f, 0.20818020f, -0.02695661f, -0.10699251f, -0.08999522f, -0.10141100f, 
    -0.09294601f, 0.10874331f, -0.07154102f, -0.00363269f, -0.04390957f, 0.22603692f, 0.13742025f, 0.06501148f, 
    0.10929631f, -0.04621522f, 0.05971564f, -0.03258681f, 0.11093453f, 0.13648126f, -0.01847791f, 0.17116529f, 
    -0.32186526f, 0.37261051f, -0.16515854f, -0.25512707f, 0.09490977f, 0.12327497f, 0.06156732f, 0.01412829f, 
    -0.05660072f, -0.00269975f, 0.07302357f, 0.02227253f, -0.14783429f, 0.28858808f, 0.08426935f, 0.11785553f, 
    0.03449957f, -0.14225873f, -0.21425696f, 0.01370290f, -0.02645181f, 0.04843868f, -0.14677198f, 0.00184885f, 
    -0.01606585f, -0.19401596f, 0.12973242f, 0.14054440f, -0.03562962f, -0.10152414f, 0.03617250f, -0.01676973f, 
    -0.01172043f, -0.06940359f, -0.08078719f, 0.03483242f, 0.03236054f, -0.06629954f, 0.14548874f, 0.30621555f, 
    0.06220122f, 0.05133554f, 0.01629119f, -0.01128275f, -0.02361263f, 0.09162569f, 0.07576262f, 0.05150146f, 
    0.53920931f, -0.01286598f, 0.11336017f, -0.18233609f, 0.00705914f, -0.06234688f, -0.06264339f, 0.03590600f, 
    0.04746721f, 0.17312159f, 0.02076150f, -0.00553636f, -0.03017532f, -0.03526233f, -0.03671118f, -0.03770049f, 
    0.17549449f, -0.11931312f, 0.04713909f, 0.09817703f, -0.07958468f, -0.05653105f, -0.04750588f, -0.02096521f, 
    -0.00516481f, 0.05453064f, 0.04397303f, -0.05951175f, -0.12898760f, -0.00017715f, -0.02351593f, -0.02846162f, 
    -0.06194405f, 0.03161536f, -0.01459512f, 0.01296612f, 0.36298591f, -0.18591721f, 0.20369826f, 0.12528139f, 
    -0.01304568f, 0.08118522f, -0.03755286f, 0.19001870f, -0.12054971f, -0.10718381f, 0.07304467f, -0.06100812f, 
    -0.26591146f, 0.09196495f, -0.10363344f, -0.03205423f, 0.07007580f, 0.07095880f, -0.01160130f, 0.06132593f, 
    -0.01908842f, 0.12105594f, 0.03175662f, -0.06827436f, 0.18851940f, -0.23728114f, 0.39908183f, -0.13007560f, 
    -0.07374209f, 0.03388320f, -0.08294908f, 0.05013941f, -0.03844969f, -0.13162564f, 0.08903356f, 0.18027559f, 
    0.20307018f, 0.18269576f, -0.18331374f, -0.05648207f, -0.09715415f, -0.03475253f, 0.00271694f, -0.00460165f, 
    -0.07694381f, 0.13771740f, -0.08249189f, -0.01621861f, -0.33733672f, 0.14913985f, -0.22293997f, 0.18025957f, 
    -0.08454803f, 0.06469779f, 0.05256620f, -0.10584468f, 0.05577926f, -0.02497012f, 0.10016173f, 0.06330265f, 
    -0.16548522f, 0.18928629f, -0.15318969f, -0.13073750f, 0.03449471f, -0.00065487f, 0.07220616f, 0.02237427f, 
    -0.06767640f, -0.09990262f, 0.00816513f, -0.14975628f, -0.03655602f, -0.04609033f, 0.05313382f, 0.33772254f, 
    -0.06638096f, 0.09741433f, 0.08148604f, -0.27148512f, 0.03746204f, 0.01401259f, -0.10182795f, 0.13053088f, 
    -0.15169853f, -0.07794685f, -0.19764578f, 0.07057531f, 0.09749141f, 0.04205126f, -0.06059055f, 0.26578173f, 
    -0.07716717f, 0.07298475f, 0.03975318f, -0.00459157f, -0.20641848f, -0.23192541f, -0.14525865f, 0.14350793f, 
    -0.14790079f, 0.00813773f, -0.01726535f, -0.16414838f, -0.04346884f, -0.14752951f, -0.13298790f, -0.13486250f, 
    0.12180332f, 0.00222007f, 0.11482239f, 0.15806624f, 0.02388490f, -0.04594828f, 0.15567788f, 0.18809892f, 
    -0.04699241f, -0.08353763f, 0.09179985f, -0.19736767f, -0.36272448f, 0.02808889f, 0.09687743f, 0.06199244f, 
    -0.07891236f, 0.04994499f, -0.02227605f, 0.24436940f, -0.05239719f, 0.11062443f, -0.09589900f, 0.14082618f, 
    0.04713339f, 0.01848551f, -0.40520254f, -0.05521793f, 0.12303174f, 0.19764274f, 0.02996678f, 0.00789308f, 
    0.02509837f, 0.16309701f, 0.03319455f, 0.00818847f, 0.34907243f, 0.08947182f, 0.34414345f, -0.11887346f, 
    -0.14824362f, 0.15338895f, 0.07604119f, 0.09486829f, 0.02994452f, 0.03999766f, 0.07850670f, 0.11796157f, 
    -0.14005217f, -0.10686927f, -0.15123318f, 0.07381717f, -0.17522776f, -0.11582650f, -0.06327496f, -0.26668361f, 
    0.01628936f, 0.06601363f, 0.00348306f, -0.03489327f, 0.13782392f, 0.08586621f, -0.06729162f, -0.10101704f, 
    -0.06455651f, -0.06003699f, -0.02362231f, 0.05208465f, -0.08527660f, -0.01236471f, 0.00739797f, -0.04404132f, 
    0.10349502f, 0.12232461f, 0.17020659f, 0.27803025f, 0.00014971f, -0.05171946f, -0.15880319f, -0.01096059f, 
    -0.03683180f, 0.13603625f, 0.04895824f, 0.10390364f, -0.09886791f, -0.17209159f, 0.31197366f, 0.23677777f, 
    -0.16331612f, 0.06638635f, 0.12815470f, -0.25380355f, 0.17416070f, -0.07786335f, -0.02816519f, -0.09845502f, 
    0.03489033f, 0.07845665f, 0.09068630f, 0.02245573f, 0.02495894f, 0.01625393f, 0.00503051f, -0.05218271f, 
    -0.01578695f, 0.02291860f, 0.08501455f, 0.03222843f, -0.12112493f, 0.12814949f, -0.07597568f, 0.03406494f, 
    0.04270655f, 0.01670264f, 0.04583207f, -0.14561550f, -0.01735988f, -0.01188944f, 0.13995303f, 0.12722890f, 
    -0.24079230f, -0.18567419f, -0.25879884f, 0.14607181f, -0.10484777f, 0.01208718f, -0.09476022f, -0.18333547f, 
    0.02407705f, 0.13576123f, 0.09898250f, 0.10391306f, 0.15770492f, -0.01007165f, 0.02574179f, -0.07203204f, 
    -0.04532590f, 0.02307603f, -0.11269953f, -0.06465677f, -0.02677015f, 0.01459649f, 0.03319774f, 0.06521320f, 
    0.49920726f, -0.20238154f, 0.00950814f, -0.05244658f, 0.08213201f, 0.07379811f, 0.07354797f, -0.04307086f, 
    0.07823627f, 0.12145153f, 0.09129995f, 0.02635900f, 0.02894516f, 0.16417377f, 0.07516715f, 0.01546576f, 
    -0.17027567f, -0.05547863f, -0.02901246f, -0.05576398f, -0.12255634f, 0.19202818f, 0.11846977f, -0.07642351f, 
    0.00482074f, -0.02453767f, 0.12393878f, -0.07247894f, -0.02753062f, -0.02867270f, 0.09233430f, 0.03161925f, 
    0.09889163f, 0.24605550f, -0.07298168f, 0.02060842f, 0.09051506f, -0.21182442f, 0.06137607f, -0.08152353f, 
    0.05217948f, 0.11643544f, 0.09204798f, 0.08439957f, 0.02853624f, -0.14080617f, -0.05650425f, -0.11214665f, 
    -0.17470074f, 0.10014997f, -0.05962598f, 0.05919775f, -0.11185430f, 0.06593237f, -0.00500374f, -0.10773794f, 
    -0.12773465f, 0.14741020f, 0.05970745f, 0.08484107f, -0.08933348f, -0.06437541f, -0.15298173f, 0.15040115f, 
    -0.12374420f, -0.05729926f, 0.00101103f, 0.07942541f, -0.04158483f, 0.15306897f, 0.03213507f, -0.00351212f, 
    0.17169540f, 0.18917240f, -0.16988483f, -0.20678875f, -0.13708597f, -0.03365200f, -0.00266400f, -0.11096454f, 
    -0.00794486f, 0.01262723f, -0.10089447f, -0.00635118f, 0.39007148f, -0.11507171f, 0.36933616f, -0.10885159f, 
    -0.05571021f, 0.07524347f, 0.09470844f, 0.05602463f, 0.06793181f, 0.01786054f, 0.01341981f, 0.07143134f, 
    0.01611897f, -0.08776665f, -0.00585955f, 0.19168375f, 0.06893852f, -0.06608001f, -0.04623047f, -0.16839735f, 
    -0.01089705f, 0.13940504f, 0.04368840f, 0.11330262f, 0.02471775f, -0.03060028f, -0.01711995f, -0.00000677f, 
    0.05580755f, -0.13507091f, 0.00519021f, -0.00094930f, -0.04337790f, 0.04922597f, 0.00594746f, -0.04265794f, 
    -0.13736905f, 0.29770124f, 0.20336047f, 0.02298898f, -0.02049584f, -0.06461958f, -0.07805961f, 0.00582183f, 
    0.00583852f, -0.08083960f, 0.05830648f, 0.08186720f, 0.16388792f, -0.31317952f, -0.00445942f, 0.04817018f, 
    0.02879629f, 0.10512439f, -0.00416343f, -0.21766271f, 0.03206420f, 0.09745979f, 0.20522085f, 0.15000203f, 
    0.12029123f, -0.08602773f, 0.41438067f, 0.18361852f, 0.06232382f, 0.05353720f, 0.14917074f, -0.09178949f, 
    -0.06704359f, 0.02408305f, 0.00602114f, 0.04806923f, 0.26294336f, -0.10003285f, -0.06163568f, 0.21086252f, 
    0.05073550f, 0.03095952f, -0.05973415f, -0.10308096f, -0.05821502f, 0.05817415f, 0.03769188f, -0.05518574f, 
    -0.18619150f, 0.07996062f, -0.04714593f, 0.17485215f, 0.06216500f, 0.03914241f, 0.02996487f, 0.13258871f, 
    0.03573396f, -0.01239850f, 0.13151902f, -0.01866730f, -0.16744478f, -0.02632409f, -0.05484394f, 0.14549245f, 
    0.03989780f, 0.02967680f, 0.07678382f, 0.14207938f, 0.07984038f, 0.09810212f, -0.05216518f, 0.05812651f, 
    -0.04210637f, 0.00917326f, 0.01706477f, -0.00797348f, -0.03631115f, 0.00357253f, -0.01599774f, -0.04087853f, 
    0.01878166f, -0.02177870f, -0.03712269f, 0.00043061f, -0.03923227f, -0.02696883f, 0.00160012f, 0.00626893f, 
    -0.03056815f, -0.04554354f, -0.03994274f, -0.01258122f, -0.02134079f, -0.04527356f, -0.03869066f, -0.02531337f, 
    -0.03286156f, 0.00860664f, 0.01917378f, -0.01400130f, 0.00621468f, 0.01696976f, -0.02047602f, 0.01378025f, 
    -0.00253791f, 0.01646193f, -0.02611730f, 0.00599733f, 0.02511354f, -0.00441025f, -0.01547058f, 0.00583190f, 
    0.00767387f, -0.01528958f, -0.01056978f, -0.02856973f, 0.02720139f, -0.00712667f, 0.01078605f, -0.03749771f, 
    -0.00554929f, -0.00601762f, -0.01875982f, -0.03008883f, -0.04141320f, -0.04375165f, -0.00120206f, 0.00476052f, 
    0.00800336f, -0.04199936f, -0.04170683f, -0.01084287f, 0.00449780f, -0.00186154f, 0.01023739f, -0.04027681f, 
    -0.00335120f, -0.00535968f, -0.01405889f, -0.00270016f, -0.01413261f, -0.01421856f, 0.01353188f, -0.03413803f, 
    -0.03597447f, 0.00626084f, -0.01145864f, -0.02512303f, 0.00342963f, 0.02222900f, 0.01089906f, -0.02252276f, 
    -0.03985726f, -0.00370929f, 0.02317586f, -0.00766585f, -0.01386668f, 0.01057160f, -0.03170260f, -0.00077885f, 
    0.00168304f, 0.00281327f, 0.00985549f, -0.03441084f, -0.02362270f, 0.02592158f, -0.01470532f, -0.00555139f, 
    -0.03333851f, 0.01799762f, 0.02545995f, 0.00923239f, 0.02380218f, -0.03790471f, 0.00116445f, 0.00780028f, 
    -0.03997672f, -0.01719574f, 0.02387751f, 0.00502150f, 0.02575806f, -0.01297541f, 0.01857273f, -0.03985507f, 
    0.01394539f, -0.02987605f, 0.00737390f, 0.01704857f, -0.01407918f, 0.01714894f, 0.02743011f, -0.00032043f, 
    -0.02660599f, -0.03724327f, -0.02057939f, 0.01405411f, -0.04173825f, 0.01628413f, -0.03087076f, 0.01484310f, 
    -0.03461562f, 0.00894046f, -0.04577702f, -0.03575953f, 0.01605743f, 0.01112163f, -0.03579158f, -0.00031513f, 
    -0.03903299f, 0.02198870f, -0.00520089f, -0.03392410f, 0.01063167f, 0.02018394f, 0.01638545f, -0.01929913f, 
    0.02610993f, -0.03984001f, -0.02084257f, 0.01261784f, 0.01115567f, -0.02335851f, -0.01873932f, 0.02471011f, 
    -0.03886276f, -0.04021475f, -0.03693689f, -0.00662021f, -0.02864144f, 0.00619177f, 0.00046874f, -0.01025630f, 
    0.02476379f, 0.02650360f, -0.02016486f, -0.02391291f, 0.00766104f, -0.04471174f, 0.00763768f, 0.00120096f, 
    0.00364320f, 0.00304052f, 0.00702826f, 0.01894909f, 0.00118578f, -0.00042191f, 0.01653896f, -0.04495692f, 
    0.01014277f, -0.03213356f, 0.02730973f, -0.00216785f, 0.01046681f, -0.01278836f, -0.03176014f, 0.01223089f, 
    -0.01525584f, -0.02033536f, 0.00158374f, -0.03872186f, -0.00018282f, -0.04068470f, -0.01027962f, -0.00629409f, 
    -0.03824457f, 0.00948498f, 0.01187238f, 0.01313960f, -0.01545857f, 0.02555900f, -0.01437001f, 0.02392217f, 
    -0.01478815f, -0.02133824f, -0.03749190f, 0.01669714f, -0.04306730f, 0.01984419f, 0.02931210f, 0.01664390f, 
    0.02085652f, -0.00019864f, -0.03759624f, -0.02426200f, -0.00402345f, -0.00163893f, -0.00087115f, 0.02082046f, 
    -0.00024463f, -0.01288290f, -0.03887567f, 0.01920567f, -0.00610414f, -0.00732986f, -0.00735301f, -0.02805529f, 
    -0.00941928f, -0.01245808f, 0.01503490f, -0.00611491f, 0.01972589f, -0.02439840f, -0.00721526f, -0.03110979f, 
    -0.04433360f, 0.03073879f, -0.03233340f, 0.00617389f, 0.00294839f, -0.02002171f, -0.03050688f, 0.02529374f, 
    0.01926208f, -0.00324583f, -0.01079522f, -0.04135825f, 0.01695424f, -0.02009127f, -0.01306712f, -0.03169239f, 
    -0.03133008f, -0.00789480f, -0.01935309f, -0.01413253f, 0.02643560f, 0.02234191f, -0.03697721f, -0.02085183f, 
    -0.01413003f, -0.04183735f, -0.03417066f, 0.01107557f, -0.02923794f, -0.01317373f, 0.01085013f, 0.00147318f, 
    -0.01983686f, -0.03896575f, -0.02595665f, -0.02827540f, 0.01159461f, 0.01795904f, -0.00337886f, -0.00861212f, 
    -0.03157935f, -0.01844220f, 0.01015469f, 0.02628320f, -0.03109810f, 0.01701179f, -0.00988946f, 0.01102492f, 
    0.00234885f, -0.01187583f, -0.00207210f, 0.01387545f, 0.02356141f, -0.00411378f, -0.02850457f, -0.00200474f, 
    0.01047710f, -0.03614195f, -0.00694602f, 0.00911313f, -0.02907263f, -0.03709779f, 0.00501180f, -0.03942245f, 
    0.02229626f, -0.00936905f, 0.01863939f, 0.01242412f, 0.00203021f, 0.00518723f, 0.01646657f, 0.00915371f, 
    -0.00664978f, -0.00841628f, 0.01777383f, 0.01353475f, 0.00982999f, 0.00073488f, -0.02546084f, -0.02281439f, 
    -0.00246673f, 0.01771860f, -0.02772965f, 0.01402347f, -0.02113536f, 0.00244469f, -0.03023390f, -0.01233936f, 
    0.01722368f, 0.02584125f, 0.00875163f, -0.02748697f, -0.01666121f, 0.01382671f, 0.02426680f, 0.01743756f, 
    -0.01267342f, 0.00686745f, -0.01454876f, -0.03310524f, 0.02390807f, 0.00064107f, -0.00852147f, -0.00885464f, 
    -0.02994418f, -0.03417546f, 0.00983515f, 0.01680141f, -0.04234608f, -0.01713298f, -0.04061185f, -0.01977099f, 
    -0.00009814f, 0.00877790f, -0.00326554f, -0.00868479f, -0.02219196f, -0.03791452f, -0.03503140f, 0.01905895f, 
    -0.02297524f, -0.00914403f, 0.00545754f, 0.00269593f, -0.03587169f, -0.01323805f, -0.02614002f, 0.02768090f, 
    0.02487730f, -0.03409142f, -0.00280394f, 0.01301590f, 0.00836926f, -0.01912086f, -0.01264856f, 0.01627903f, 
    -0.00653302f, -0.00516949f, 0.00052123f, 0.00105305f, -0.00315787f, 0.01890456f, 0.01982277f, 0.02657847f, 
    -0.01075989f, -0.02495143f, 0.00092064f, -0.02382527f, 0.03076345f, -0.00137127f, 0.02949438f, -0.01043960f, 
    -0.02329066f, -0.01607102f, -0.00693922f, -0.03292401f, 0.00503885f, -0.04128187f, 0.02508153f, -0.02855302f, 
    -0.04513342f, -0.01731001f, 0.01009375f, -0.02248034f, 0.00348386f, 0.00647637f, 0.00496406f, 0.01881712f, 
    0.00619307f, -0.00203207f, -0.02340797f, 0.02017043f, 0.02554875f, -0.02872832f, -0.01725793f, 0.01831795f, 
    0.00737660f, -0.04383825f, -0.02322248f, 0.00743846f, -0.00122579f, -0.01944209f, 0.01107659f, 0.02354005f, 
    -0.03174417f, -0.01607522f, -0.02156386f, -0.02982820f, -0.01172713f, 0.02104067f, 0.00395030f, -0.01720196f, 
    -0.00699596f, -0.01403251f, 0.00056169f, -0.01008336f, -0.02292581f, -0.03477392f, -0.03685258f, 0.01574527f, 
    -0.00009638f, 0.02561658f, -0.03516065f, -0.02543480f, 0.01073218f, -0.01656332f, 0.00396963f, -0.01943432f, 
    0.00329841f, -0.03514344f, 0.00415289f, 0.00077682f, 0.00691377f, -0.01398114f, 0.02088605f, -0.01833538f, 
    0.01713867f, -0.01007995f, -0.01428442f, -0.02906136f, -0.04379535f, 0.02865317f, -0.00820006f, -0.00856551f, 
    -0.02220864f, -0.03860436f, -0.03019575f, 0.00292161f, 0.02514639f, 0.01991958f, -0.03562819f, 0.00469803f, 
    0.02617628f, 0.02066452f, 0.00841859f, -0.01445077f, -0.01115699f, -0.03013522f, -0.01628805f, -0.04172351f, 
    0.01577333f, 0.01038314f, 0.01980594f, -0.01486881f, 0.02131784f, -0.03375901f, 0.02935613f, -0.00466854f, 
    -0.02052363f, 0.01677736f, -0.00286299f, -0.01804134f, -0.02080991f, -0.02754997f, 0.01378534f, -0.04013682f, 
    0.01544525f, -0.02005896f, -0.02286012f, -0.03011784f, -0.01487096f, -0.02420926f, -0.03070864f, 0.00693988f, 
    0.01240241f, 0.01165665f, 0.01875470f, -0.00403043f, -0.03840986f, -0.02378569f, -0.03313257f, -0.01595061f, 
    0.01629619f, 0.01571455f, -0.02695263f, -0.03312895f, 0.02811938f, 0.00363362f, 0.00653067f, 0.02375395f, 
    0.00297748f, -0.01160164f, 0.01033822f, 0.01990446f, 0.01275760f, 0.01259435f, 0.02153384f, 0.01059197f, 
    -0.00160563f, -0.00155832f, -0.03450687f, 0.01962032f, -0.00264498f, -0.00759686f, 0.03021933f, 0.02563514f, 
    0.00952581f, 0.01043351f, -0.03837609f, 0.00313626f, -0.00142797f, 0.00527555f, 0.01685252f, -0.02689906f, 
    0.01165670f, -0.01191817f, -0.01177859f, -0.01203583f, -0.01214493f, 0.00613874f, -0.00854347f, 0.02415751f, 
    0.01278745f, -0.01982823f, -0.01507644f, -0.02811482f, 0.00429086f, 0.01014314f, 0.01548305f, 0.01926513f, 
    0.02207138f, -0.00838110f, 0.01036900f, 0.00546190f, 0.01253596f, -0.01161082f, 0.00113601f, -0.03269229f, 
    0.03211720f, -0.00087027f, 0.02838740f, 0.00186919f, -0.02109948f, 0.02092639f, 0.01726813f, 0.00611321f, 
    -0.00557116f, 0.00733279f, -0.00672531f, -0.04390753f, 0.02546571f, -0.02208948f, -0.04120393f, -0.01791050f, 
    0.01155721f, -0.00153415f, -0.00500660f, 0.01974330f, 0.02071528f, -0.04411138f, -0.03892494f, 0.00005998f, 
    -0.00574611f, -0.01544058f, -0.03304544f, 0.02305729f, -0.04569951f, -0.02520541f, 0.00907263f, 0.02494647f, 
    0.02298028f, 0.02364381f, -0.02091651f, 0.00123106f, 0.03186817f, -0.03879072f, -0.03491346f, -0.01448448f, 
    -0.03705775f, -0.00242446f, 0.02360332f, 0.00595952f, 0.02049164f, 0.01663746f, -0.03130407f, 0.01028489f, 
    -0.03828092f, 0.00891170f, -0.03729519f, 0.00386729f, -0.02940030f, -0.00831472f, -0.00915214f, -0.04086471f, 
    0.01242328f, -0.02076602f, -0.02450143f, -0.00308650f, -0.02486756f, -0.04348923f, 0.00542570f, 0.00394147f, 
    -0.01999334f, 0.02405191f, -0.03391656f, -0.02911062f, 0.01861125f, -0.02011712f, 0.00321111f, -0.04318084f, 
    -0.02471371f, -0.01555807f, 0.00112554f, -0.01391936f, 0.02201069f, -0.03844092f, 0.00961581f, -0.04576962f, 
    -0.02325041f, -0.01588617f, -0.02418466f, 0.00896880f, -0.02857132f, -0.02752787f, -0.04136394f, 0.00016880f, 
    0.00793748f, -0.02740418f, 0.00456142f, -0.02813380f, -0.03285431f, -0.00769456f, -0.02497292f, 0.02700722f, 
    -0.00585526f, -0.02418219f, 0.00188893f, 0.01204639f, -0.04486336f, 0.02246080f, 0.00899477f, -0.01450851f, 
    -0.03421915f, 0.02281720f, -0.03620068f, 0.01651638f, 0.00934036f, 0.00496408f, -0.03765707f, -0.03676462f, 
    -0.02905808f, -0.00160945f, 0.00389741f, 0.00217571f, 0.01856106f, -0.04165557f, -0.03777193f, -0.02572352f, 
    0.02221313f, -0.04182521f, -0.03251679f, -0.02553248f, -0.03858677f, 0.02495816f, -0.00452536f, 0.02488945f, 
    -0.03199596f, -0.01352923f, 0.01230096f, 0.01836604f, -0.01968674f, -0.00124261f, -0.01489914f, -0.02117990f, 
    0.03094889f, -0.01109911f, 0.01974484f, -0.03713464f, 0.01753119f, -0.00387185f, 0.02594074f, -0.03896224f, 
    -0.01772714f, 0.01883059f, -0.03135221f, 0.02568211f, -0.04490577f, -0.00817827f, -0.01830944f, -0.00211407f, 
    0.02172129f, 0.00913304f, -0.00028249f, -0.02656299f, 0.02380038f, 0.01392424f, 0.02161759f, -0.00581496f, 
    -0.00202240f, -0.00762046f, 0.01627052f, -0.03903778f, -0.00643296f, 0.00580351f, -0.01720683f, 0.00312939f, 
    0.02094134f, 0.02472384f, -0.01337464f, 0.00250210f, -0.03502774f, -0.03987666f, -0.01997870f, 0.01216197f, 
    0.00420233f, 0.00712836f, -0.02428643f, -0.00107328f, -0.01251337f, 0.01748221f, 0.01684438f, -0.01373701f, 
    -0.00550536f, -0.04435203f, -0.01068558f, 0.00977650f, 0.02552900f, -0.00195806f, -0.00008840f, 0.02021600f, 
    0.00656085f, 0.00076108f, 0.00077956f, -0.04213538f, -0.01603387f, -0.00045225f, -0.01372125f, -0.00484836f, 
    -0.04142639f, -0.01256248f, -0.00994181f, 0.01593112f, 0.01751846f, -0.02531480f, 0.00814703f, 0.02822456f, 
    -0.02452466f, -0.00505181f, 0.01724509f, -0.04266707f, 0.00834016f, 0.01146787f, -0.02939540f, 0.02574202f, 
    0.01743548f, -0.03608865f, -0.00879572f, 0.01275205f, -0.03707136f, 0.00350981f, -0.04182461f, -0.02929257f, 
    -0.00903539f, -0.02446790f, -0.00240095f, -0.01776896f, -0.02136313f, 0.01067602f, 0.01997610f, -0.01712521f, 
    0.00044538f, -0.01642794f, -0.03581455f, 0.03054869f, -0.01428101f, 0.00021127f, -0.01654440f, 0.00016294f, 
    -0.00483875f, -0.01562440f, -0.01626606f, -0.03958148f, -0.00180592f, -0.02017127f, -0.01797696f, -0.04009644f, 
    -0.02759801f, 0.00724371f, -0.01759121f, -0.00707864f, -0.03135122f, 0.02132876f, 0.00460635f, -0.00467034f, 
    0.03235680f, -0.00496295f, 0.00134107f, -0.02606810f, 0.00116361f, -0.02446194f, -0.00335783f, -0.00323658f, 
    0.01113695f, 0.03416741f, 0.00018015f, -0.01330791f, 0.00384758f, -0.00413894f, 0.02174682f, 0.02673280f, 
    0.02035540f, -0.04393293f, 0.00806178f, 0.00211804f, -0.00307438f, -0.04078619f, 0.03002562f, -0.02444431f, 
    -0.01261349f, -0.02299731f, -0.00755025f, -0.03643829f, 0.02102276f, 0.02941576f, -0.00970458f, -0.01083159f, 
    -0.02401460f, -0.03038424f, 0.00707976f, -0.03331232f, 0.02614745f, -0.04265663f, -0.02125019f, -0.03151886f, 
    -0.02909179f, -0.00453192f, 0.00333324f, 0.00086506f, 0.00964180f, 0.02174716f, -0.00074712f, -0.01483145f, 
    0.02101472f, 0.00585973f, -0.02131776f, 0.00631066f, -0.02475592f, 0.02798497f, 0.00639895f, -0.03703771f, 
    -0.00687958f, 0.00172139f, -0.03946016f, -0.00289225f, -0.02888583f, -0.01411132f, 0.02123005f, -0.00385488f, 
    -0.03653712f, 0.02677247f, 0.01388321f, 0.02370932f, -0.02100818f, -0.02557329f, -0.04284475f, -0.01234725f, 
    -0.03012030f, -0.02346987f, -0.00889586f, -0.04095485f, -0.03033892f, -0.01496459f, 0.00730648f, 0.01856000f, 
    -0.01143038f, -0.03156896f, -0.00107599f, 0.00798144f, -0.02721941f, -0.01840222f, -0.01608936f, 0.02828331f, 
    0.01168394f, 0.00396437f, -0.03861450f, 0.02160647f, 0.00103754f, -0.02697108f, 0.01364102f, 0.00999354f, 
    0.03083329f, -0.00786682f, 0.03382154f, 0.00403932f, 0.00532030f, -0.02270680f, -0.00269091f, -0.02255826f, 
    0.01466207f, -0.03803382f, 0.01934844f, -0.04024380f, -0.02235524f, 0.00218724f, 0.00414781f, -0.02440618f, 
    0.00951880f, 0.02742804f, -0.03477352f, -0.00721436f, -0.02408377f, -0.00119182f, 0.01873480f, 0.02429791f, 
    0.00084030f, -0.04271922f, -0.02333274f, -0.01754155f, -0.01236805f, 0.02408178f, 0.00555540f, -0.03460335f, 
    0.00427697f, -0.02067217f, 0.01242753f, 0.00660346f, -0.00751238f, 0.00941047f, 0.01244831f, -0.01786333f, 
    -0.01740615f, -0.02536432f, -0.03325332f, 0.00094764f, -0.00364704f, -0.03955599f, -0.01930133f, 0.00114821f, 
    -0.01579516f, -0.01544339f, -0.03242429f, -0.02918283f, -0.01519128f, -0.01594906f, 0.01776197f, 0.00209671f, 
    -0.00710011f, 0.02739017f, 0.02520533f, -0.01553857f, 0.00740539f, 0.00287534f, -0.00482122f, -0.01142349f, 
    0.03010399f, -0.02873646f, -0.00114748f, 0.00682433f, -0.01154221f, -0.00927547f, 0.00750380f, -0.00381987f, 
    -0.01884910f, 0.01283463f, -0.03872461f, 0.01236815f, 0.01515780f, -0.00001409f, -0.01916789f, -0.03047343f, 
    0.00821974f, -0.03231665f, -0.01047088f, -0.01184881f, 0.00645629f, -0.02356456f, -0.01929060f, 0.00268628f, 
    0.00788653f, -0.01203995f, 0.01793104f, 0.01678232f, 0.02497349f, -0.02493663f, 0.02162329f, 0.02606778f, 
    -0.02557020f, -0.02139985f, -0.03738755f, -0.01255324f, 0.00178079f, -0.02822958f, -0.03328359f, 0.02559670f, 
    0.01355538f, 0.02924302f, 0.00460951f, 0.01201947f, -0.00510956f, 0.00995973f, -0.00747720f, 0.01456045f, 
    -0.01334558f, -0.02753448f, -0.00420492f, -0.00141088f, -0.04084022f, -0.03547495f, -0.03912827f, 0.02402037f, 
    -0.00930109f, 0.00640975f, -0.01790532f, -0.02020639f, -0.00864065f, 0.01037180f, 0.00324166f, -0.00469065f, 
    0.01073434f, 0.02672942f, 0.00754461f, 0.01779513f, 0.02510893f, 0.02042668f, -0.03768924f, -0.02513489f, 
    -0.03313185f, 0.02082151f, -0.00399031f, -0.03415952f, 0.01243297f, -0.00501100f, -0.02139794f, -0.04164018f, 
    0.01658984f, -0.02876980f, 0.02209270f, 0.01087920f, -0.00621585f, -0.01425327f, 0.01540141f, -0.00376815f, 
    0.02417118f, -0.01602874f, -0.03748853f, -0.01108986f, -0.02703480f, 0.03721022f, -0.01064913f, -0.00933509f, 
    -0.01359698f, 0.00568295f, 0.00595514f, 0.02031979f, -0.01525340f, -0.00730588f, -0.01824589f, -0.01288309f, 
    0.00286004f, -0.00209399f, 0.00760615f, 0.00276457f, 0.01886606f, -0.03757571f, 0.02514804f, -0.00350080f, 
    -0.02844085f, 0.00882185f, 0.00669235f, 0.01578176f, -0.02751618f, -0.01461362f, -0.02134023f, -0.01953748f, 
    -0.03296925f, 0.01694636f, -0.00445972f, -0.01488026f, -0.00124513f, -0.03320194f, -0.04225800f, 0.00176617f, 
    0.02996808f, -0.02331433f, 0.02106802f, -0.01288981f, -0.01727215f, -0.03781362f, -0.03672623f, -0.03678105f, 
    -0.02861478f, -0.02128498f, 0.00882294f, 0.01387593f, -0.00024366f, -0.02634720f, 0.01976765f, 0.02174565f, 
    0.00372675f, -0.03709192f, -0.03431288f, -0.00530251f, -0.04126730f, 0.00354273f, 0.01578796f, -0.00230861f, 
    0.00711205f, 0.00838734f, -0.01027167f, -0.02911016f, 0.01519960f, -0.02175820f, -0.00798439f, 0.02505907f, 
    0.01373002f, 0.00846217f, -0.01064655f, -0.01629516f, 0.02128883f, -0.03133380f, 0.00742575f, -0.01110540f, 
    -0.03317221f, -0.00096482f, -0.01550984f, -0.00537164f, 0.02092721f, -0.02955584f, -0.01432181f, -0.01253468f, 
    0.00070638f, 0.01638974f, 0.00240033f, 0.01933316f, -0.04327887f, -0.03586020f, 0.01871065f, -0.02409807f, 
    -0.01267941f, -0.01224819f, 0.01381949f, -0.03402775f, 0.01786241f, -0.00199702f, -0.02371220f, -0.01399575f, 
    0.01762520f, -0.01051460f, -0.01353000f, -0.04283938f, -0.00808293f, -0.04319117f, 0.00338419f, 0.01052881f, 
    -0.00153665f, -0.00702087f, 0.01651841f, 0.03545975f, 0.01032808f, -0.03990243f, -0.03257214f, 0.01393106f, 
    -0.00054823f, -0.01031284f, -0.02102886f, 0.02686998f, -0.00918540f, 0.00378645f, -0.01242588f, -0.03212538f, 
    0.03464922f, -0.02324551f, 0.00557955f, -0.02254416f, -0.01783840f, 0.02558499f, 0.02178632f, -0.01578470f, 
    -0.00439090f, 0.02043994f, -0.02323237f, 0.00343771f, 0.00123279f, -0.00195560f, -0.00299142f, 0.00566856f, 
    0.01576984f, -0.01995830f, 0.00702494f, -0.01748658f, -0.02088642f, 0.02048851f, 0.01294013f, -0.00256879f, 
    -0.00390081f, 0.02207213f, 0.01240060f, 0.02657877f, -0.04145734f, -0.04047901f, 0.00967209f, -0.02247841f, 
    0.01838069f, 0.01124761f, -0.00856826f, -0.02915454f, -0.01775542f, -0.03058517f, -0.00864450f, -0.00857382f, 
    -0.03702345f, -0.00985595f, 0.02076402f, 0.02184652f, -0.01077035f, -0.00112606f, 0.01945482f, -0.02843486f, 
    -0.03144770f, -0.00982171f, -0.04362890f, 0.02549124f, 0.02416569f, -0.04382144f, 0.02703601f, -0.03206446f, 
    -0.00007687f, 0.00302138f, 0.00718079f, -0.03553399f, 0.01789578f, -0.04265339f, 0.01761067f, -0.01134083f, 
    0.00996936f, -0.00690206f, -0.03942370f, 0.02399974f, -0.02024376f, 0.01185919f, -0.03392753f, -0.00301566f, 
    -0.00064034f, 0.01581251f, 0.00579591f, 0.03186000f, -0.02512310f, -0.00119109f, 0.01657271f, -0.02139475f, 
    -0.01058969f, 0.02255428f, -0.01974121f, -0.00996904f, -0.03351584f, 0.00202985f, 0.01821713f, 0.00138961f, 
    -0.01720147f, -0.00884763f, 0.00167280f, 0.01659213f, 0.01521839f, -0.01241353f, 0.02280409f, -0.03349333f, 
    0.01733422f, 0.02944229f, -0.03608395f, 0.03623349f, 0.01665596f, 0.02157096f, 0.02757055f, 0.00810026f, 
    0.03154109f, -0.03426926f, 0.02939277f, 0.03115239f, -0.03059629f, -0.02202613f, 0.00503242f, -0.02053499f, 
    -0.00264853f, 0.01517608f, 0.00807055f, -0.03752142f, -0.01156428f, 0.03377565f, -0.01784781f, -0.01468215f, 
    0.01834564f, 0.02009876f, -0.01286951f, 0.01419387f, 0.02350473f, 0.02739446f, 0.02041871f, -0.04019155f, 
    0.00321657f, 0.01898689f, 0.00339373f, -0.01047236f, -0.03118229f, -0.01413105f, 0.01376345f, -0.03230430f, 
    -0.01917488f, -0.01013983f, 0.00494311f, -0.02526460f, 0.01641862f, -0.04393985f, -0.01544232f, -0.01136270f, 
    -0.00005496f, 0.02859793f, -0.01180826f, -0.02768411f, -0.03244060f, -0.02805991f, -0.00198182f, -0.00946657f, 
    -0.01309270f, -0.02864659f, -0.01284527f, -0.02243411f, -0.00876454f, -0.01948185f, -0.04063033f, 0.01605992f, 
    -0.00710619f, -0.03401606f, -0.04116436f, 0.00030020f, 0.01651539f, -0.01121141f, 0.00381329f, 0.02180286f, 
    -0.00190493f, -0.02759255f, -0.00331734f, -0.01917964f, 0.02204932f, 0.02129039f, -0.04076612f, 0.01396427f, 
    0.00004419f, -0.02592985f, 0.00257887f, 0.00221663f, -0.01487790f, -0.01152691f, 0.00257735f, -0.00598733f, 
    -0.02110695f, 0.00903861f, -0.02385214f, -0.02778369f, -0.01541528f, -0.01456309f, -0.00226738f, -0.01682418f, 
    0.02431416f, -0.01834958f, -0.00975639f, -0.03908406f, -0.04039759f, -0.03346536f, 0.01614679f, 0.00913508f, 
    -0.00655165f, 0.00402316f, 0.02760548f, -0.02910597f, -0.04071029f, -0.02682416f, -0.01148565f, -0.00888559f, 
    -0.00233478f, 0.02781485f, -0.00905174f, -0.00526963f, -0.02030014f, 0.01101939f, -0.00769901f, -0.04144242f, 
    0.01760616f, 0.02175722f, -0.01073404f, 0.02545402f, -0.03186847f, -0.01258822f, 0.02271986f, -0.04032473f, 
    0.02472501f, 0.02631987f, -0.02841702f, -0.03004545f, 0.01541774f, 0.00077650f, -0.01714456f, -0.03343457f, 
    0.00285784f, -0.04072187f, -0.02498244f, -0.02632372f, -0.02537952f, 0.00766672f, -0.04454266f, 0.01805854f, 
    -0.00685298f, -0.00208550f, 0.00935275f, -0.00987095f, -0.02553758f, -0.00755779f, -0.03847852f, 0.02703325f, 
    -0.01387130f, -0.00038421f, -0.00948412f, -0.00186532f, -0.00448169f, -0.03009716f, 0.01590803f, -0.00569582f, 
    0.01702133f, -0.02258222f, -0.00668673f, 0.02542521f, 0.00789099f, 0.00629454f, -0.03483255f, 0.01569281f, 
    -0.01868741f, -0.00580002f, 0.01299232f, -0.03729097f, -0.00719925f, -0.03023919f, -0.04002324f, -0.02890109f, 
    0.00822852f, -0.02511958f, -0.00182953f, -0.00076573f, -0.01401965f, 0.00783952f, -0.00640264f, -0.00866565f, 
    -0.02947047f, 0.00953016f, 0.02553507f, 0.00526903f, -0.02015236f, -0.03391182f, -0.01568413f, 0.02003759f, 
    -0.01553264f, 0.02127977f, -0.01738560f, -0.01602011f, -0.03775479f, -0.02073323f, -0.03832000f, 0.01019255f, 
    -0.01714865f, 0.03174330f, -0.04110150f, -0.04075971f, -0.02200317f, 0.02551423f, 0.00817894f, -0.02620963f, 
    -0.04028090f, 0.01513638f, 0.00460992f, -0.00023617f, -0.02818965f, -0.00421961f, -0.03007810f, -0.00400646f, 
    0.00677744f, 0.00670009f, -0.01176050f, 0.00494706f, -0.02337741f, 0.01590783f, -0.01157322f, -0.01228945f, 
    -0.00091491f, -0.03142207f, 0.02079104f, 0.00978875f, -0.01772423f, -0.01489567f, 0.01487011f, -0.00019339f, 
    -0.00291844f, 0.02701624f, -0.01475108f, -0.02421796f, -0.01163983f, -0.00253945f, 0.01291934f, -0.00332015f, 
    0.01911920f, -0.01821315f, -0.00688366f, 0.00557685f, -0.00151620f, -0.04408463f, 0.00027727f, 0.02018617f, 
    0.00687439f, -0.03875844f, 0.01816257f, 0.01167734f, -0.00745082f, -0.01243656f, 0.01319085f, -0.02454068f, 
    -0.00989528f, 0.01674143f, -0.02624318f, -0.01497719f, -0.02291426f, 0.00980980f, 0.00395110f, 0.01385739f, 
    -0.00223123f, -0.00621689f, -0.00294034f, 0.02682870f, 0.00114686f, -0.00507887f, 0.02115785f, -0.02736252f, 
    0.02970895f, -0.02828162f, 0.00789304f, -0.00343642f, 0.01710486f, 0.01388796f, -0.01518761f, 0.01688564f, 
    -0.03714453f, 0.01914344f, -0.01581511f, -0.03494861f, -0.00967659f, -0.02583601f, 0.00152116f, 0.01950194f, 
    -0.03997861f, -0.02477350f, 0.02718241f, -0.03633690f, -0.00961476f, -0.01428738f, 0.01526626f, -0.01839755f, 
    -0.01272152f, 0.02826443f, -0.02745760f, -0.03075408f, 0.00693112f, -0.02138767f, 0.02063214f, 0.00354982f, 
    -0.03252747f, 0.00942431f, -0.01256530f, -0.00618136f, -0.00331957f, -0.03544468f, 0.01598415f, 0.03089148f, 
    -0.01961847f, -0.00089751f, 0.02527707f, -0.04009565f, -0.02719495f, 0.00709012f, -0.00387183f, -0.03070908f, 
    -0.03940242f, -0.02106794f, -0.01973415f, 0.02584024f, -0.02866243f, 0.00264862f, 0.00020391f, 0.01366699f, 
    -0.01535742f, -0.00671005f, -0.01661347f, -0.00802038f, 0.02978039f, -0.03263922f, -0.00230585f, -0.00806768f, 
    0.00545432f, -0.00349213f, -0.04019689f, -0.01123320f, -0.00575630f, 0.00641412f, 0.02195892f, -0.02721873f, 
    0.02142505f, -0.02819714f, -0.00762965f, 0.01957128f, -0.02336561f, -0.03141541f, -0.02816735f, -0.03191943f, 
    0.01633828f, 0.02757847f, -0.03469445f, -0.02910511f, -0.02498650f, 0.02182882f, -0.00199469f, -0.00199971f, 
    0.00535785f, -0.02624529f, -0.01635491f, -0.02319035f, 0.00243111f, 0.01511982f, 0.01242847f, -0.03273467f, 
    -0.00550055f, -0.03055863f, -0.02354633f, -0.02198175f, -0.04052693f, 0.00429480f, -0.02552539f, 0.01871589f, 
    -0.03278141f, -0.03498562f, -0.00490379f, 0.01175175f, 0.00423439f, -0.02376838f, 0.00470178f, -0.00292355f, 
    -0.04038718f, -0.01019935f, -0.00567787f, 0.02078019f, -0.01920878f, 0.01191352f, 0.02846304f, -0.01935389f, 
    -0.01851628f, 0.02205556f, -0.00970881f, -0.00412763f, -0.01018065f, 0.02044903f, -0.02172266f, -0.03338424f, 
    -0.01884169f, 0.02412316f, 0.01645920f, -0.03728422f, -0.00411184f, 0.02921849f, -0.03024516f, -0.02768072f, 
    0.01359305f, -0.00010710f, 0.00378214f, -0.03676928f, 0.00176850f, 0.00711286f, -0.01898872f, 0.01993391f, 
    -0.03066576f, -0.04102712f, 0.00384442f, -0.01520744f, -0.02205057f, -0.00669619f, 0.00608431f, 0.02875558f, 
    -0.00395075f, -0.03564676f, 0.02292697f, -0.02092087f, 0.00576334f, 0.02113234f, -0.04008230f, 0.03024841f, 
    -0.02784616f, -0.03588260f, 0.01700203f, -0.02795606f, 0.00929038f, 0.00692759f, -0.03737681f, -0.01018215f, 
    -0.00774021f, 0.00984106f, -0.01386078f, -0.02840235f, -0.00073723f, 0.00302375f, -0.01360845f, 0.02447982f, 
    -0.00599156f, 0.01388794f, -0.00069191f, 0.00838259f, 0.02981374f, 0.01708318f, -0.02197719f, -0.02889807f, 
    0.02028694f, -0.00975176f, 0.00530455f, -0.00091878f, -0.01687136f, -0.02624567f, 0.00566071f, -0.02838185f, 
    -0.02335935f, -0.02098177f, -0.02880816f, -0.03231841f, -0.03090631f, -0.03201475f, 0.00191352f, -0.01016782f, 
    0.01862689f, -0.00071479f, 0.00232543f, -0.01440040f, 0.00925176f, -0.00797837f, -0.02571064f, 0.03046511f, 
    -0.00886559f, -0.01009508f, 0.02218765f, -0.01922545f, -0.00028847f, -0.02332537f, -0.02544317f, -0.01720268f, 
    0.01496215f, -0.00898352f, -0.01473844f, -0.03210957f, -0.03413675f, -0.03739161f, -0.02527878f, -0.03961367f, 
    -0.00521418f, 0.02460464f, -0.01975438f, -0.03105324f, 0.02672183f, -0.02744756f, -0.01227401f, -0.00725640f, 
    -0.01651319f, -0.03120447f, -0.03896605f, -0.03942334f, 0.01209608f, -0.00107930f, -0.01028285f, -0.02186750f, 
    0.02286642f, -0.02429844f, 0.02304155f, -0.03316347f, -0.01864336f, -0.03754232f, -0.02229666f, 0.00676869f, 
    0.00711866f, -0.01955970f, -0.02906897f, -0.03287197f, 0.01262748f, 0.00711199f, 0.02280866f, 0.01163517f, 
    -0.03320596f, -0.00064802f, -0.03496482f, -0.03019369f, -0.02973944f, -0.00480769f, 0.01863363f, -0.02897142f, 
    -0.02321447f, -0.01725614f, 0.00314631f, 0.02335033f, 0.01211687f, 0.00598080f, -0.00136767f, -0.01037861f, 
    -0.03706378f, -0.03590858f, 0.01961864f, 0.01609051f, -0.03819327f, -0.00567279f, -0.00262279f, 0.01902272f, 
    -0.03477570f, -0.02827072f, 0.01769657f, 0.00768883f, 0.02885671f, 0.01596123f, -0.01422766f, 0.01174290f, 
    0.02301947f, 0.00265359f, 0.01471856f, -0.02032884f, -0.01635690f, -0.02178202f, -0.03718734f, 0.02313522f, 
    0.02926652f, 0.02775483f, 0.01017774f, -0.01543541f, -0.01946480f, 0.00693156f, -0.00094224f, -0.00033447f, 
    0.02281258f, -0.03274797f, -0.01974590f, 0.01782815f, 0.00474722f, -0.03680137f, -0.03019886f, -0.02765262f, 
    -0.01266244f, 0.02289215f, 0.01666466f, -0.02006922f, -0.01369877f, 0.01050868f, 0.00779644f, 0.01596725f, 
    -0.03806762f, -0.01296463f, 0.00798912f, -0.01251227f, -0.00112207f, -0.01934772f, -0.02823880f, 0.01338641f, 
    -0.01197925f, -0.01743164f, -0.01660329f, 0.02881570f, -0.00273538f, -0.00090187f, -0.01531863f, 0.00139594f, 
    0.01677256f, 0.01606704f, -0.01970985f, -0.03949024f, -0.01623094f, -0.03606118f, -0.00211587f, 0.01270728f, 
    -0.01799436f, -0.03786669f, 0.01845153f, -0.03714818f, -0.01016551f, -0.00921494f, -0.01389929f, -0.00076772f, 
    -0.01729381f, 0.02265936f, -0.01237806f, -0.02760493f, 0.00298372f, -0.03442827f, -0.03816059f, -0.00662405f, 
    0.02803023f, -0.02014608f, -0.03484689f, 0.00735898f, -0.04047867f, 0.02443221f, 0.00301383f, 0.00951294f, 
    0.00055888f, 0.01503006f, 0.00680479f, -0.00705448f, -0.02144748f, -0.01287907f, 0.01264324f, -0.04041659f, 
    -0.03590551f, 0.02540493f, -0.03957289f, -0.03422718f, -0.00471491f, -0.01986280f, -0.02757683f, 0.00825021f, 
    -0.03691464f, 0.02035159f, -0.01819365f, 0.02900477f, 0.02377082f, 0.02248253f, 0.00218798f, -0.01763213f, 
    -0.00192142f, -0.04093381f, 0.00616646f, 0.00827734f, 0.02455986f, -0.02645322f, 0.00203145f, -0.01281340f, 
    -0.03567177f, -0.01635216f, -0.01348308f, 0.02478168f, 0.00624987f, -0.03473014f, 0.01139010f, -0.00384239f, 
    -0.01466257f, -0.00861452f, -0.03101020f, -0.03033083f, -0.01480386f, -0.02036653f, 0.02270225f, 0.01994705f, 
    0.00843048f, -0.01707254f, -0.02684863f, -0.00028529f, -0.00619953f, -0.02204782f, -0.00003124f, 0.03064102f, 
    0.01965195f, -0.02805825f, 0.01489356f, 0.00114594f, -0.03450798f, 0.00298583f, -0.01825187f, -0.04016956f, 
    0.02462584f, -0.03464283f, -0.00777080f, -0.00463673f, 0.03044720f, -0.03706273f, -0.03043319f, -0.01181599f, 
    -0.01153352f, 0.00707076f, 0.00031980f, -0.02572508f, 0.01748510f, -0.00542923f, 0.00649861f, 0.01719247f, 
    -0.03423893f, 0.00668484f, -0.02033432f, -0.01807270f, 0.02227051f, -0.00130473f, -0.02076871f, 0.00924528f, 
    -0.00003381f, -0.03322763f, -0.03343356f, 0.01982131f, 0.01533869f, -0.04084887f, -0.00367170f, -0.02532248f, 
    0.02957331f, -0.00612652f, 0.01624689f, 0.02176683f, -0.01656924f, -0.03391943f, -0.01131449f, 0.00362196f, 
    -0.01550211f, 0.02296861f, -0.00366664f, -0.01369948f, -0.01154459f, 0.03062364f, -0.00169363f, 0.02882247f, 
    0.02391363f, -0.02869304f, -0.01382809f, 0.00488573f, -0.02039196f, -0.00170183f, 0.01543082f, 0.02498235f, 
    -0.03442914f, 0.02094720f, 0.00396573f, -0.01311596f, -0.00715137f, -0.03216024f, 0.01059872f, -0.03994047f, 
    -0.00972026f, -0.03538036f, -0.02389795f, -0.01632249f, -0.04011652f, -0.03223644f, 0.02548587f, -0.01131969f, 
    0.02829284f, -0.00501118f, 0.03035827f, -0.00677294f, 0.02652625f, -0.02542214f, 0.01552610f, -0.01229887f, 
    0.02473840f, -0.00600628f, 0.01868898f, 0.01397979f, -0.02630369f, 0.00375246f, -0.02492936f, -0.04031058f, 
    0.01216126f, 0.02871588f, -0.01691438f, -0.00796424f, -0.03525951f, 0.01393938f, 0.01892196f, -0.03229453f, 
    0.00675031f, 0.00782926f, -0.00755261f, -0.02769731f, 0.00914424f, 0.02973600f, -0.01104307f, 0.01590390f, 
    0.01611803f, -0.02102626f, 0.02852196f, -0.01355033f, -0.02551542f, 0.02338881f, -0.01197072f, -0.04074014f, 
    0.00045297f, -0.01592181f, -0.03099340f, -0.01936200f, -0.02896960f, 0.03054470f, 0.00655685f, 0.00788744f, 
    0.00723138f, -0.01148206f, -0.00689956f, -0.02310164f, -0.03318895f, -0.00904884f, 0.01390872f, -0.03739538f, 
    -0.03251134f, -0.03314210f, 0.02148356f, 0.00161594f, 0.00612827f, -0.01035468f, 0.01165773f, -0.00937548f, 
    -0.02947091f, 0.01077314f, 0.02285906f, -0.01001530f, 0.01558434f, -0.00123699f, 0.03062166f, 0.00347266f, 
    0.00250984f, 0.00438659f, -0.01033065f, -0.00987026f, 0.02486563f, -0.03407602f, -0.00036800f, 0.02394032f, 
    0.02890174f, 0.00161322f, 0.00829679f, 0.00046827f, 0.00777024f, -0.00375541f, 0.01328510f, 0.02138986f, 
    0.01156456f, -0.00744402f, -0.00136989f, -0.00676707f, -0.00862089f, 0.00309988f, -0.03444006f, 0.01559339f, 
    0.00575812f, 0.00707160f, 0.02534621f, 0.00736102f, -0.01054154f, -0.03128470f, -0.03598513f, -0.03447761f, 
    -0.03455851f, -0.02948500f, 0.01456169f, 0.00279089f, 0.01975493f, 0.02654668f, -0.01779708f, -0.01253155f, 
    -0.03273782f, -0.04057604f, 0.00451844f, -0.02256475f, -0.00974517f, -0.00502528f, -0.03362524f, 0.01577672f, 
    0.02863587f, 0.01057962f, 0.01321115f, 0.01300525f, -0.02861539f, -0.00763359f, 0.01563141f, -0.03861442f, 
    0.00168097f, -0.01854480f, 0.02438162f, 0.02439552f, 0.00156835f, 0.01213235f, 0.00085400f, -0.02678180f, 
    -0.02401213f, -0.02722959f, 0.02699528f, 0.02987682f, -0.02290703f, -0.03040063f, -0.01453623f, -0.03632872f, 
    -0.04046721f, 0.02847259f, -0.02490197f, 0.01564050f, -0.03862831f, -0.02614884f, 0.02917830f, 0.01314812f, 
    0.02316838f, 0.00944852f, 0.02282684f, -0.01007962f, -0.01221401f, 0.02442830f, 0.02377972f, 0.01021759f, 
    -0.02888323f, -0.01170788f, 0.00136925f, -0.04004664f, -0.01983906f, -0.04091355f, 0.01681010f, 0.02757155f, 
    -0.03728278f, -0.01662891f, -0.04008539f, -0.02638766f, -0.00877266f, -0.02160821f, 0.00545409f, -0.02711622f, 
    0.01555742f, 0.02753906f, -0.02082754f, 0.02668718f, 0.00900454f, -0.02052955f, -0.03254831f, 0.01397423f, 
    0.00476991f, 0.02251892f, -0.02361935f, -0.03459616f, -0.03201865f, -0.03139807f, -0.01327771f, 0.01050566f, 
    0.01701810f, -0.02026657f, -0.01679930f, -0.00530958f, -0.01833794f, 0.02600176f, -0.01140876f, -0.00890522f, 
    -0.01579627f, 0.03036053f, 0.03030784f, 0.00911569f, 0.00112082f, -0.00726223f, -0.00659613f, -0.01477611f, 
    0.02220382f, -0.01201540f, -0.00290110f, 0.00256856f, 0.01716775f, 0.00544654f, 0.01283246f, 0.00547233f, 
    -0.02657631f, 0.01186339f, 0.02897066f, 0.00013631f, 0.02461772f, -0.02012999f, -0.04061135f, 0.02982027f, 
    0.01204753f, 0.00653006f, -0.00718207f, 0.00528678f, 0.02158112f, -0.03527192f, -0.03224567f, 0.03081465f, 
    0.02812413f, -0.02647717f, -0.00855098f, -0.01446520f, 0.00048164f, -0.02923752f, 0.00597628f, -0.03417547f, 
    -0.03857575f, -0.07460862f, 0.04951619f, 0.16922489f, 0.10585211f, 0.25076747f, 0.12015860f, 0.02944221f, 
    -0.02051944f, -0.09156029f, -0.12357290f, -0.06797505f, -0.34248424f, -0.01730841f, 0.32769948f, 0.14033303f, 
    -0.02703257f, 0.06903644f, -0.06396481f, -0.02186510f, 0.20908828f, 0.19664566f, 0.10090721f, 0.11191104f, 
    -0.08145643f, 0.26017910f, 0.44102174f, -0.13464817f, 0.01311062f, -0.03205135f, 0.03020472f, -0.02912975f, 
    0.14755991f, 0.27003098f, 0.21044353f, 0.11412340f, -0.05034070f, 0.06813612f, -0.17139964f, 0.08210128f, 
    0.09441289f, 0.10093612f, 0.02586214f, 0.06901297f, -0.01797886f, 0.07802694f, -0.01760380f, 0.00100889f, 
    -0.08093379f, -0.05274847f, 0.01498273f, 0.09380966f, -0.09937198f, -0.09827249f, -0.04254820f, -0.12820780f, 
    0.13601089f, 0.14240840f, 0.19901469f, 0.28405210f, -0.26011726f, 0.11801100f, 0.15681714f, 0.24469866f, 
    -0.00714397f, -0.05504582f, 0.01699204f, -0.10515595f, 0.05173361f, 0.09235189f, 0.23641004f, -0.04646841f, 
    0.14808227f, -0.08013148f, -0.08761435f, 0.19765042f, 0.03378287f, 0.01134901f, 0.03689114f, 0.07324281f, 
    0.08857556f, 0.06373045f, 0.04994951f, -0.09310684f, 0.09829047f, 0.15360883f, 0.07562202f, 0.00496238f, 
    -0.00436873f, -0.16240108f, -0.02353526f, 0.19472049f, -0.14691645f, -0.11228731f, 0.06902557f, -0.12533151f, 
    0.00939601f, -0.04413734f, 0.13621220f, -0.21387537f, 0.00000498f, 0.07530440f, 0.03256238f, -0.03494697f, 
    0.06926279f, 0.06789345f, 0.11300524f, 0.01432904f, -0.05817326f, -0.16019815f, -0.12199789f, -0.09479778f, 
    -0.01944926f, -0.09871569f, -0.01445363f, 0.02831307f, 0.07658081f, 0.21648864f, 0.03501341f, -0.02413940f, 
    -0.04602005f, -0.03164561f, 0.04467686f, -0.06660298f, -0.01962161f, 0.18768789f, -0.01276665f, -0.07448646f, 
    0.19585356f, 0.18262789f, 0.07891551f, 0.08308554f, -0.20886202f, -0.09262035f, 0.01848485f, 0.01872392f, 
    0.00282670f, -0.06452093f, -0.08467499f, -0.02055539f, 0.24417092f, 0.17099041f, 0.13970715f, 0.13986459f, 
    -0.16771822f, -0.00266931f, 0.12531948f, 0.09892657f, -0.10236322f, -0.17946410f, -0.10828109f, -0.09613746f, 
    -0.10358305f, 0.25698087f, 0.07632493f, 0.20057127f, -0.10560014f, -0.14488211f, -0.00949707f, -0.05131968f, 
    0.01785542f, 0.14169751f, 0.24227306f, 0.08614021f, 0.09988046f, 0.12803340f, 0.08242486f, -0.01208629f, 
    -0.00281937f, -0.16748811f, -0.16559504f, 0.07026144f, 0.08601000f, -0.01524868f, 0.12142235f, 0.07809351f, 
    0.13739763f, -0.05360649f, 0.07939948f, 0.09046341f, 0.00991911f, -0.03084205f, 0.20457208f, 0.02538360f, 
    0.03627456f, 0.12461280f, 0.01600101f, -0.01788256f, 0.20235929f, 0.07762640f, 0.05623782f, 0.11422111f, 
    -0.21313158f, -0.08722504f, 0.12785871f, 0.24920286f, 0.10438642f, -0.06290776f, 0.14113875f, 0.00119989f, 
    -0.06809439f, -0.07418795f, -0.06337087f, -0.07080238f, -0.20157570f, 0.12436929f, -0.11305501f, 0.17064621f, 
    0.04983233f, -0.03914656f, -0.00645699f, -0.03482791f, -0.00229829f, -0.01616230f, -0.12556837f, -0.00281970f, 
    -0.15827850f, -0.12326235f, -0.03757612f, -0.14927121f, -0.03969021f, -0.00733175f, -0.08448990f, 0.08599085f, 
    0.04786988f, -0.02743606f, 0.01056180f, 0.02852950f, 0.10189453f, 0.25423071f, -0.00831338f, 0.23532650f, 
    0.36696386f, 0.01024449f, -0.10308006f, 0.11830545f, 0.07231257f, -0.02062431f, 0.13388854f, 0.02388217f, 
    -0.49043682f, 0.19379938f, 0.03985039f, 0.18688414f, 0.04517168f, -0.06368219f, -0.12716171f, 0.07604993f, 
    0.14422072f, -0.12341850f, 0.17902170f, 0.11531936f, -0.06607059f, -0.09101851f, -0.00931328f, 0.04646723f, 
    -0.01077133f, -0.00957437f, 0.13714324f, -0.09021148f, -0.01797253f, 0.03067608f, 0.04180472f, 0.04201940f, 
    -0.10362665f, 0.09328836f, 0.09959880f, -0.03096697f, -0.00160903f, 0.18643306f, 0.15396871f, 0.05066631f, 
    -0.11371761f, -0.04572740f, -0.01234359f, -0.07506695f, -0.35879311f, 0.08345290f, 0.20738237f, -0.03111787f, 
    0.01169346f, 0.01331961f, -0.02631904f, 0.06087413f, 0.18619682f, 0.14875224f, 0.07643583f, 0.32341874f, 
    0.19723779f, -0.05487506f, -0.24907343f, 0.07631869f, -0.00991610f, -0.20301169f, -0.03674020f, 0.00307217f, 
    -0.10304581f, -0.04801849f, -0.13809092f, -0.04992957f, -0.02942217f, -0.09114450f, -0.10102033f, -0.03018449f, 
    0.14922258f, 0.20025957f, 0.22699575f, 0.09059656f, 0.04044772f, 0.07640416f, -0.04246070f, 0.00035671f, 
    -0.21674560f, -0.08647982f, 0.11930390f, 0.08908391f, -0.05126799f, -0.08082507f, -0.02689561f, -0.07463224f, 
    0.01913305f, 0.03754142f, -0.05271422f, 0.08859921f, -0.27940285f, 0.00227617f, -0.11901454f, -0.13442117f, 
    0.05313675f, 0.05934847f, 0.19552657f, 0.09359651f, 0.12413155f, 0.00612289f, -0.00152653f, 0.06744619f, 
    -0.30089176f, 0.28825060f, 0.20855628f, 0.11290821f, 0.02115527f, -0.07293839f, -0.07616682f, 0.07646818f, 
    0.07435245f, -0.00491971f, 0.03171650f, 0.02037428f, -0.22606526f, -0.17037956f, 0.00362714f, -0.31363076f, 
    0.19302429f, 0.15091008f, -0.02010439f, 0.05201944f, -0.02304449f, -0.01422141f, -0.00144547f, -0.06558412f, 
    -0.01421149f, 0.00637907f, -0.17750233f, -0.06202125f, 0.01312709f, 0.03336495f, 0.09108393f, -0.01432331f, 
    0.03684560f, 0.03921019f, -0.03423548f, 0.11899144f, -0.01969250f, 0.01877190f, 0.10362910f, 0.19172652f, 
    0.07177146f, 0.07937139f, 0.11234176f, 0.10642237f, 0.16592598f, 0.14307374f, 0.15803993f, 0.13207278f, 
    -0.24844185f, -0.20693642f, 0.04022363f, -0.00811231f, -0.03121709f, -0.09025847f, -0.08043409f, -0.06700728f, 
    0.03798554f, -0.00057135f, -0.04383408f, 0.02419607f, 0.36798251f, -0.44281206f, 0.10484941f, 0.04687518f, 
    0.04056570f, 0.23314650f, 0.02999129f, -0.02957756f, 0.03863110f, -0.00206957f, -0.07171489f, -0.03916283f, 
    -0.03288950f, -0.17387562f, 0.18064931f, 0.25278467f, 0.00702676f, -0.18745008f, 0.08911102f, 0.11373867f, 
    0.05589516f, -0.04945177f, 0.02340741f, 0.08418469f, -0.08293883f, -0.03905661f, -0.08825938f, -0.09274623f, 
    -0.04594261f, -0.05019286f, -0.03521687f, 0.08249914f, -0.12784114f, 0.01909381f, -0.01231505f, -0.08275102f, 
    -0.12421328f, -0.01709705f, 0.06514473f, -0.03113944f, -0.02012088f, 0.04946391f, 0.13557093f, 0.16518591f, 
    0.12518345f, -0.01193686f, 0.09969383f, 0.21517767f, -0.14073281f, 0.12334000f, 0.17524095f, -0.12676902f, 
    0.03724758f, 0.03955672f, -0.02722905f, 0.11190486f, 0.35351303f, 0.12762919f, 0.00125384f, -0.03394906f, 
    -0.13345528f, 0.02326956f, 0.04695106f, -0.06172005f, 0.02681779f, -0.11292952f, 0.21131273f, -0.06324232f, 
    0.12544124f, -0.03033373f, 0.09501308f, 0.03774501f, 0.08649954f, 0.40813553f, -0.01374099f, -0.00610842f, 
    0.06861299f, -0.15973559f, 0.00674203f, -0.00639475f, 0.18581946f, 0.16950901f, 0.16606075f, -0.10279844f, 
    -0.10221389f, -0.17159498f, -0.09267226f, 0.07744525f, -0.09865271f, -0.02298550f, -0.20300759f, 0.16752943f, 
    0.03841499f, 0.08222060f, 0.08468927f, 0.15467292f, -0.14401558f, -0.08005290f, -0.00235683f, -0.12884024f, 
    0.02743322f, -0.01192134f, -0.07155680f, -0.04580409f, 0.08827150f, -0.02359411f, 0.12709819f, 0.03193785f, 
    0.01979120f, -0.08148936f, 0.21428052f, -0.26592070f, -0.10971100f, 0.08983834f, 0.11351763f, 0.12551455f, 
    -0.00987615f, 0.02462258f, -0.04138993f, 0.04733415f, -0.18453133f, -0.04946164f, 0.25172231f, -0.21639659f, 
    -0.04773029f, 0.08941280f, 0.00579753f, 0.01415901f, -0.14545031f, -0.09844469f, 0.02227776f, -0.04009839f, 
    -0.36644572f, -0.22863017f, 0.23584200f, -0.10846834f, -0.05747261f, 0.07463235f, -0.02916490f, 0.04738729f, 
    -0.05428764f, 0.05931655f, 0.05604379f, 0.15111792f, 0.13352476f, -0.09180378f, -0.03792796f, 0.01820327f, 
    0.10940024f, 0.07186614f, 0.00277375f, 0.10606863f, 0.12147086f, 0.07858183f, -0.00160086f, 0.05696956f, 
    -0.17925933f, -0.13995585f, 0.00259084f, -0.03896374f, -0.04046330f, 0.19275449f, 0.21553214f, 0.11042283f, 
    0.14665377f, 0.17391944f, 0.21949548f, 0.08451127f, -0.04982056f, -0.15144505f, 0.01422220f, 0.01608700f, 
    0.00507851f, 0.08217348f, 0.07852387f, -0.03601190f, -0.00625697f, -0.09451155f, -0.13909346f, 0.01943607f, 
    0.06919203f, 0.08193881f, 0.04271958f, -0.10327853f, 0.08840489f, -0.21105042f, 0.04685755f, 0.02145805f, 
    0.03080079f, 0.13179485f, 0.04092400f, -0.00994694f, 0.00296628f, 0.10792154f, -0.16521393f, -0.10214769f, 
    -0.00262365f, -0.03404416f, 0.06969822f, -0.15577456f, -0.00644704f, -0.18338427f, 0.09358254f, -0.05251653f, 
    -0.02726196f, 0.13878244f, 0.01335741f, 0.00767054f, 0.03508510f, -0.02439551f, -0.03731465f, -0.05288403f, 
    0.04941525f, 0.10772642f, 0.12078366f, 0.02692352f, 0.01850628f, 0.08388030f, -0.28877422f, 0.00756525f, 
    0.07668644f, 0.15228394f, 0.20605190f, 0.08582712f, 0.01110421f, 0.01853069f, -0.08942152f, -0.08601762f, 
    0.11096077f, 0.40286544f, -0.06640162f, 0.03749587f, -0.04365646f, -0.06654131f, 0.01514240f, -0.08256275f, 
    0.15415438f, 0.15618989f, 0.23056176f, 0.10130630f, -0.15432921f, 0.04639249f, -0.09892373f, 0.06666037f, 
    -0.03051410f, 0.00030627f, -0.16632783f, 0.31519875f, 0.04928300f, 0.14337072f, -0.05196288f, 0.21676895f, 
    -0.05254264f, 0.06995138f, -0.00632477f, -0.07020473f, -0.03166284f, 0.08540247f, 0.02826752f, -0.02970549f, 
    -0.01742830f, -0.04415251f, -0.15133333f, -0.06738035f, -0.26915622f, -0.03494242f, 0.15807328f, 0.13612877f, 
    0.39881778f, 0.06955377f, -0.07998227f, 0.16436765f, -0.05970130f, -0.16390203f, 0.13482259f, -0.00487409f, 
    -0.25406548f, -0.04693936f, -0.08167252f, -0.11439592f, -0.01436221f, 0.09532937f, 0.13797610f, 0.07025889f, 
    0.09698182f, 0.06838020f, 0.06622749f, -0.00343546f, -0.00876146f, -0.02287649f, -0.08355460f, 0.04033925f, 
    0.13726439f, 0.08546394f, -0.05473924f, 0.10205244f, 0.12658562f, 0.04666707f, 0.10408940f, 0.09690121f, 
    -0.23489428f, -0.04648652f, 0.20839828f, -0.05740249f, -0.05018444f, 0.06543814f, 0.05112947f, 0.02250673f, 
    0.00789342f, -0.05258505f, -0.08240730f, -0.01047868f, -0.24991995f, -0.08723351f, 0.12311086f, -0.06393006f, 
    0.05769024f, 0.00405114f, 0.05961410f, -0.02983042f, 0.16647160f, 0.10681356f, 0.02534612f, 0.03164693f, 
    -0.14648743f, 0.11304219f, 0.25980219f, 0.00277383f, 0.01999983f, 0.00890256f, 0.03507220f, 0.12982537f, 
    0.04372296f, 0.02541013f, 0.16757490f, 0.25984138f, -0.38931677f, -0.29688054f, -0.17201141f, 0.03477018f, 
    -0.14183654f, -0.18076852f, 0.07567952f, -0.14871885f, -0.00078557f, -0.01999384f, 0.04372639f, -0.01036374f, 
    0.21010484f, 0.01871475f, 0.28267813f, 0.23562340f, 0.06643166f, -0.08248188f, 0.11390509f, 0.29763758f, 
    -0.05456302f, 0.05756679f, 0.11145057f, 0.19238368f, -0.05094089f, 0.02775629f, 0.09369417f, 0.03726641f, 
    0.04567525f, 0.03705942f, 0.16522808f, 0.09410812f, 0.11955807f, 0.06267045f, 0.09319700f, -0.00136683f, 
    -0.04677238f, 0.24968831f, 0.58321595f, 0.02606571f, -0.03028150f, -0.06441817f, -0.10221072f, -0.06030754f, 
    -0.08374647f, 0.00278745f, -0.09339263f, -0.04489843f, -0.19420387f, -0.16114256f, -0.33835346f, -0.11045004f, 
    -0.04457075f, 0.02089863f, 0.09153244f, 0.02942057f, 0.21583250f, 0.01556581f, 0.04825467f, -0.02338698f, 
    -0.39745772f, -0.01618938f, -0.19686088f, 0.35333854f, -0.05125200f, 0.11462571f, -0.04061072f, 0.04505238f, 
    0.00842858f, 0.09117186f, 0.01801992f, 0.00847548f, 0.06646738f, 0.27246392f, 0.30929580f, 0.00909771f, 
    -0.00179486f, -0.11784073f, -0.02586099f, 0.02330023f, -0.05777020f, 0.03592804f, 0.05220893f, -0.10182489f, 
    -0.10640153f, -0.00309411f, -0.17553344f, 0.02842750f, -0.02194880f, 0.01737297f, 0.05627760f, 0.06894101f, 
    0.02605822f, 0.05070673f, -0.05195071f, 0.02217292f, -0.18772396f, -0.14244066f, -0.16284567f, 0.07076278f, 
    -0.00634636f, 0.39603192f, 0.07366192f, 0.24891177f, 0.07481543f, 0.09563625f, 0.01646627f, -0.03397873f, 
    0.19119205f, 0.02791763f, 0.04889185f, -0.06986158f, 0.01543718f, -0.11112363f, -0.02601436f, -0.13604738f, 
    0.12865038f, -0.09782344f, 0.04334820f, -0.06641629f, -0.06540339f, -0.15684210f, -0.16280472f, 0.08317526f, 
    0.04580116f, 0.17982443f, 0.13474637f, 0.10881372f, -0.09941258f, -0.04732121f, 0.05685008f, 0.00868844f, 
    -0.06198964f, -0.33910874f, -0.33072144f, -0.04333871f, 0.07244691f, -0.00616844f, 0.15593116f, 0.02150142f, 
    -0.01531448f, 0.08919999f, 0.04375353f, 0.05344827f, -0.06470209f, 0.02454049f, -0.06626137f, -0.17406683f, 
    -0.08139339f, 0.02771410f, -0.03558999f, 0.03923469f, 0.11338384f, 0.10868320f, 0.12052175f, 0.03343041f, 
    -0.27541983f, -0.05503271f, 0.11785308f, 0.09710248f, 0.15166602f, 0.17430049f, -0.02890154f, -0.02390752f, 
    -0.10746470f, 0.00091115f, 0.06387755f, 0.04551750f, 0.04448962f, -0.05217196f, -0.12783651f, -0.21728145f, 
    -0.08574449f, 0.01254023f, 0.05353425f, 0.02586419f, 0.14595759f, 0.09785517f, 0.14523205f, 0.12460013f, 
    -0.37318489f, -0.12304299f, -0.11182095f, -0.00047658f, 0.02228954f, 0.05007710f, -0.08450479f, -0.04035128f, 
    0.06051743f, -0.00133284f, 0.03252524f, 0.11184074f, -0.02180975f, -0.03605477f, 0.13906354f, -0.25237188f, 
    0.00673445f, -0.06045441f, -0.09425694f, -0.21886906f, 0.07379632f, 0.04299494f, 0.06876157f, 0.19052230f, 
    -0.07207181f, -0.01330814f, -0.13461556f, -0.02889970f, 0.13472365f, 0.05281448f, 0.22118887f, 0.22780889f, 
    -0.02477998f, -0.05134789f, -0.05961882f, -0.08793543f, -0.15361941f, 0.10318451f, -0.07824466f, 0.21445189f, 
    0.05034345f, 0.06387444f, 0.06437723f, -0.00424867f, 0.01420381f, 0.07282136f, 0.04930645f, -0.06627306f, 
    -0.05565673f, 0.17399436f, 0.30185717f, -0.02136419f, 0.02100089f, -0.07401130f, 0.00742992f, 0.14954843f, 
    0.00482430f, -0.12693298f, 0.07509750f, -0.11374530f, -0.14650661f, 0.03067635f, 0.37903017f, 0.10247820f, 
    -0.05096611f, -0.08053973f, -0.18154944f, -0.07482588f, -0.05054045f, -0.00884741f, 0.09761413f, 0.00718356f, 
    -0.03928703f, -0.30811599f, -0.24005923f, -0.21530704f, 0.20338260f, -0.00516022f, 0.01253880f, -0.10724599f, 
    -0.03464837f, -0.02588097f, -0.04842158f, -0.04300040f, 0.48198789f, -0.28644791f, 0.00412342f, 0.18680806f, 
    0.04738798f, 0.21088557f, 0.06944107f, -0.11314084f, 0.12678075f, 0.09973525f, -0.08377073f, 0.12856847f, 
    0.25808376f, -0.27341074f, -0.30386198f, -0.29596916f, -0.03398886f, 0.05138437f, 0.13685130f, 0.01226165f, 
    0.12509644f, -0.06403536f, 0.13873696f, 0.16730866f, 0.08988956f, 0.03002572f, 0.33241677f, -0.03767290f, 
    -0.13129242f, 0.03800645f, -0.12170812f, 0.02796958f, -0.02730856f, 0.03128574f, -0.04691627f, -0.04968056f, 
    -0.20063521f, -0.09590929f, 0.13951203f, 0.04145625f, -0.01317226f, -0.17687203f, -0.12229215f, 0.05037360f, 
    0.05377288f, -0.01043597f, -0.05063586f, -0.08580750f, -0.41948733f, -0.06759150f, -0.01849186f, 0.30582508f, 
    -0.00910270f, 0.15188326f, -0.09046303f, 0.04223153f, -0.09267724f, -0.03694724f, 0.06618692f, 0.11236445f, 
    0.10252623f, -0.14861637f, 0.15811640f, -0.05407228f, 0.03267429f, -0.00557310f, 0.04489340f, 0.11960842f, 
    -0.00662155f, 0.13051778f, 0.06870508f, 0.02726118f, 0.03970375f, 0.13960691f, 0.05811812f, -0.00157976f, 
    0.10144410f, -0.02112379f, -0.05448324f, 0.16252024f, -0.00388467f, 0.02954780f, 0.06323006f, -0.04971466f, 
    0.05595600f, 0.15014626f, 0.07856434f, 0.06644809f, -0.01555009f, -0.02407430f, -0.06314395f, -0.05335143f, 
    0.01554283f, 0.04999176f, -0.05556382f, -0.02997847f, 0.06447204f, -0.06784436f, 0.07724641f, 0.04064994f, 
    0.15020412f, 0.12870748f, -0.12797402f, -0.02487231f, -0.07734239f, 0.13449533f, -0.07435678f, -0.06532561f, 
    -0.01145883f, -0.37920398f, -0.23694554f, -0.09258180f, -0.00727707f, 0.05772167f, 0.19052656f, 0.15861534f, 
    0.17564991f, -0.12709217f, -0.03856656f, 0.04421116f, -0.18061545f, 0.01233447f, 0.11976811f, 0.07076396f, 
    -0.06006741f, 0.00496928f, -0.06288933f, 0.00900024f, -0.06872694f, 0.06162309f, 0.05817160f, 0.01273089f, 
    0.08802509f, 0.21745928f, 0.23018605f, 0.08625338f, -0.01092402f, -0.07470134f, -0.07190767f, -0.03583383f, 
    -0.08916385f, -0.01830073f, -0.02139374f, 0.04261360f, 0.65303254f, 0.33483756f, -0.04117301f, -0.09567460f, 
    -0.00473157f, -0.08459776f, 0.09063613f, -0.10968903f, 0.22058855f, 0.12844457f, 0.11080602f, 0.06565614f, 
    0.20341042f, 0.00293646f, -0.23156451f, -0.08279131f, 0.06230482f, -0.06864977f, 0.17893024f, -0.00919650f, 
    0.02356008f, 0.05764091f, 0.31668365f, -0.06719130f, 0.07540310f, 0.50298172f, 0.16931552f, -0.11563642f, 
    -0.07889205f, -0.19303921f, 0.10699737f, -0.03895226f, -0.09612405f, 0.10508363f, -0.06522503f, -0.09358033f, 
    0.57651305f, -0.34246099f, -0.32429376f, -0.20213439f, -0.00197207f, 0.11320492f, -0.02901928f, 0.18020698f, 
    0.08518232f, 0.06388430f, 0.04024137f, -0.07423424f, -0.12278128f, -0.11020732f, -0.03167685f, 0.00505586f, 
    -0.04809524f, 0.03799370f, -0.05364221f, -0.02724174f, -0.07211412f, -0.13219281f, -0.09891783f, -0.12639855f, 
    -0.14397307f, 0.05173497f, 0.10984611f, 0.08181391f, 0.05089421f, 0.11415316f, 0.05776897f, 0.18808486f, 
    -0.06996866f, -0.11974976f, 0.03786591f, 0.00377839f, -0.18916354f, -0.23917718f, -0.10435552f, 0.23303801f, 
    -0.16236761f, 0.13679498f, 0.03894641f, 0.14247508f, 0.19390914f, 0.06041890f, 0.03382904f, 0.02945099f, 
    0.12895875f, 0.13380919f, -0.12286145f, -0.16297278f, 0.12258548f, 0.10187481f, 0.02628092f, 0.00017518f, 
    0.09019564f, 0.14114821f, 0.01236028f, 0.03480945f, 0.22751710f, -0.27721325f, 0.19159043f, 0.15385175f, 
    0.10070907f, 0.19553819f, 0.02811726f, -0.02536831f, 0.04743928f, 0.03318067f, 0.17986819f, 0.22101331f, 
    0.18668883f, -0.07452034f, 0.03247828f, -0.36546808f, -0.10007308f, -0.16114374f, -0.03457710f, -0.15554443f, 
    0.02816835f, -0.05158584f, -0.00393058f, 0.02683120f, 0.05852993f, 0.15202026f, -0.03300293f, 0.00610115f, 
    -0.07078157f, 0.05206520f, -0.00750350f, 0.00635741f, -0.02398823f, 0.03124008f, -0.04084359f, 0.02776754f, 
    -0.24417441f, -0.16361547f, -0.00146167f, 0.33583552f, -0.11038671f, 0.07564579f, -0.12328827f, 0.01730222f, 
    -0.10677913f, 0.16771132f, 0.10323396f, 0.06617621f, 0.08604952f, 0.16124189f, -0.12488964f, 0.14265269f, 
    -0.10847375f, -0.01093812f, 0.01611034f, -0.10335264f, 0.22325179f, -0.05229510f, -0.17221606f, 0.01781865f, 
    -0.18418846f, 0.19236214f, -0.10137281f, 0.07939614f, -0.12142371f, -0.01636312f, 0.12485686f, -0.03129581f, 
    -0.17633280f, 0.03852088f, 0.10839915f, 0.15506646f, -0.03784099f, 0.07457642f, -0.09702149f, -0.10747159f, 
    0.05863656f, 0.11803356f, 0.14015447f, 0.04800401f, 0.03695834f, 0.01844681f, 0.04435343f, -0.04280727f, 
    0.29203653f, 0.04706602f, -0.10197058f, -0.25592726f, 0.01732541f, -0.11075317f, 0.05427120f, -0.07506812f, 
    0.05089980f, 0.02633206f, 0.01828812f, 0.08299012f, 0.15709859f, 0.35014635f, 0.28073391f, -0.12816900f, 
    -0.06258446f, 0.01718355f, -0.07360282f, -0.00042060f, -0.08915389f, 0.03976089f, -0.00352379f, -0.04272582f, 
    0.19439048f, -0.17259924f, 0.16132408f, -0.00417340f, 0.29372051f, 0.13601938f, -0.01378186f, 0.25760782f, 
    0.02597588f, -0.00296728f, 0.17613676f, -0.02157971f, -0.31753770f, -0.06958546f, 0.23170632f, 0.11615268f, 
    -0.02356569f, -0.02710508f, -0.02422267f, 0.05039268f, 0.03630193f, 0.04244796f, 0.16680466f, -0.04511683f, 
    -0.06769850f, -0.05826915f, 0.01899812f, 0.05772686f, 0.02334196f, 0.03005078f, 0.04051796f, 0.03137722f, 
    0.09494983f, 0.07761830f, 0.04941333f, 0.03556532f, -0.04268481f, -0.18492199f, 0.15737379f, 0.00217926f, 
    0.13481072f, 0.19966355f, -0.15455595f, 0.17080894f, 0.03989770f, -0.18434431f, 0.03548934f, -0.01684116f, 
    -0.30664968f, 0.00473146f, 0.17170505f, 0.09550446f, -0.01292281f, 0.03008209f, 0.02463124f, -0.05094710f, 
    0.02694147f, 0.20053387f, 0.11612365f, 0.25830331f, 0.36055455f, -0.36850601f, -0.01189442f, -0.36804938f, 
    -0.01212000f, -0.01976881f, 0.02403957f, -0.09352247f, 0.03482168f, -0.00583590f, -0.03216133f, -0.07132039f, 
    0.24943013f, 0.17714876f, 0.01323928f, -0.07669902f, 0.01454734f, -0.09575476f, -0.03465502f, -0.15366910f, 
    -0.00095623f, 0.03721936f, -0.05471304f, 0.02453288f, 0.09509143f, -0.04180044f, 0.27661118f, 0.10268208f, 
    -0.00171830f, 0.09509925f, -0.03200935f, 0.18006329f, 0.09165271f, 0.08627330f, 0.02883809f, 0.08760875f, 
    0.10939558f, -0.12345737f, 0.08257293f, 0.03947918f, -0.12294989f, 0.01114734f, -0.01331649f, -0.22585364f, 
    -0.07700575f, -0.05633747f, -0.00214658f, 0.03316885f, -0.06767674f, -0.00838805f, 0.05139846f, -0.01782015f, 
    0.10308083f, -0.03149249f, -0.16671476f, -0.04718015f, 0.04194184f, 0.10031001f, 0.01579078f, -0.02784492f, 
    -0.00653598f, -0.04045904f, -0.01421178f, 0.04318473f, 0.03442545f, -0.00691124f, -0.05922459f, -0.13063425f, 
    0.16234241f, 0.34260109f, 0.05606041f, 0.03203922f, 0.05594908f, 0.18696189f, -0.18232201f, -0.05937265f, 
    0.04524779f, 0.08071005f, -0.01802037f, -0.04148856f, 0.02429127f, 0.09442551f, 0.07478440f, 0.01377807f, 
    -0.28862920f, -0.08669069f, 0.07546439f, 0.25574034f, 0.04928436f, 0.11951759f, -0.10871775f, 0.07932021f, 
    0.02698275f, 0.10792503f, -0.05086376f, 0.15454230f, 0.17353931f, 0.19616278f, 0.04493500f, 0.07311570f, 
    -0.06998993f, 0.07924189f, 0.22384137f, -0.00237137f, -0.06604618f, -0.03203863f, 0.02237900f, 0.04821892f, 
    0.32183138f, -0.22983997f, -0.39489809f, -0.17822927f, 0.25646448f, 0.08962006f, -0.12806240f, 0.08183677f, 
    0.08431011f, 0.07144909f, -0.08505002f, 0.02469026f, -0.14929676f, -0.18612629f, 0.04965829f, -0.07029930f, 
    0.11076986f, 0.19971970f, 0.19079086f, 0.01954243f, 0.07994683f, 0.06987777f, 0.05197757f, 0.19889624f, 
    -0.01514113f, -0.00411831f, -0.02047247f, 0.01310711f, -0.00149025f, 0.02047884f, 0.03418287f, -0.01345397f, 
    -0.03376786f, 0.00862166f, 0.00032319f, 0.01483476f, 0.01002657f, 0.02062368f, -0.00378062f, -0.02458124f, 
    -0.04092507f, 0.00261614f, -0.02103123f, 0.01993089f, -0.02591120f, -0.00405546f, -0.02588897f, 0.02509893f, 
    -0.01720874f, 0.00393736f, -0.00997261f, -0.02087131f, 0.02942238f, -0.01288235f, -0.03622997f, 0.01920077f, 
    -0.00870538f, -0.03444693f, 0.02760681f, 0.01239274f, 0.01790710f, -0.02687046f, -0.03297115f, 0.03490457f, 
    0.00239919f, 0.01152841f, 0.03381799f, -0.02640261f, -0.00615307f, 0.01220254f, 0.02799086f, 0.02675414f, 
    -0.03683188f, -0.01856053f, 0.01882344f, -0.00763978f, 0.02059886f, 0.00004319f, -0.01412560f, 0.01627566f, 
    -0.02548512f, -0.00076142f, 0.00407467f, 0.02495498f, 0.00359363f, -0.01306207f, 0.01053104f, -0.00232581f, 
    -0.01389916f, 0.02537075f, 0.00009969f, -0.03975712f, 0.01102768f, 0.02405276f, -0.01827266f, 0.00818804f, 
    -0.01138238f, 0.02496940f, -0.02976232f, -0.04037571f, 0.01186008f, -0.02692859f, 0.00920574f, 0.01091544f, 
    0.01160668f, -0.03907145f, 0.00870257f, 0.02092023f, -0.03239186f, 0.00802135f, -0.03795266f, 0.01503906f, 
    -0.04371305f, 0.01040423f, 0.02088949f, 0.01368700f, -0.01595464f, -0.00769525f, 0.02693862f, 0.02005187f, 
    0.00068163f, -0.02102959f, 0.02261587f, -0.04017510f, -0.02473605f, -0.01174802f, 0.00909935f, 0.03493920f, 
    -0.00223928f, 0.00620711f, 0.02481132f, 0.00163357f, -0.01043916f, -0.00661333f, -0.01639698f, 0.01340844f, 
    -0.01655729f, -0.03056002f, 0.00493488f, -0.03531114f, 0.02541420f, 0.00209760f, 0.02824825f, 0.01259588f, 
    0.01403375f, 0.01660933f, -0.03576368f, -0.02752243f, -0.04286616f, -0.00529071f, 0.00122612f, -0.01911787f, 
    0.02985866f, -0.00474365f, -0.00625801f, -0.01204758f, -0.03142947f, -0.03591864f, 0.02247457f, -0.02668711f, 
    -0.01086453f, -0.03559842f, 0.00579548f, 0.01394507f, 0.01606953f, -0.01132592f, 0.01621741f, 0.00103438f, 
    -0.00836073f, -0.00915657f, -0.00920302f, 0.02514908f, 0.01258114f, 0.02685387f, -0.00763127f, -0.03840140f, 
    0.01058504f, -0.00263162f, 0.00277458f, 0.00453434f, 0.01066171f, 0.00246749f, -0.03056345f, 0.01190324f, 
    0.02143965f, -0.02279056f, -0.02536740f, -0.00618827f, -0.02488838f, 0.03386262f, 0.00296123f, 0.01215945f, 
    0.01207519f, -0.01358708f, 0.00362123f, -0.03314114f, -0.02250751f, -0.01753263f, -0.01738318f, -0.03357322f, 
    -0.02451512f, -0.04247602f, 0.01729403f, 0.00687256f, -0.03146097f, -0.00673414f, 0.02036119f, 0.00267937f, 
    -0.01336202f, 0.03225365f, -0.04471636f, 0.00195492f, 0.01607680f, -0.00780335f, 0.00412026f, 0.02727030f, 
    0.02240442f, 0.02010237f, -0.00626678f, 0.01588315f, -0.03471089f, 0.02245327f, -0.01536450f, 0.03687024f, 
    0.01314826f, -0.03336538f, 0.00513278f, -0.01708224f, -0.02268120f, 0.00086687f, -0.01447832f, 0.00074453f, 
    -0.03349921f, -0.02535882f, 0.00465991f, -0.02717678f, 0.02459368f, 0.01808470f, -0.00221062f, -0.04244177f, 
    -0.01376804f, -0.04146814f, 0.00427636f, -0.00760283f, -0.01507059f, -0.02069814f, 0.00284846f, -0.01292257f, 
    0.01312747f, 0.02012032f, -0.00490080f, 0.04022745f, -0.01211390f, -0.02750188f, 0.02499776f, 0.03794298f, 
    0.00127563f, 0.02689500f, 0.00874313f, -0.02231925f, 0.00549685f, 0.01577483f, -0.04406349f, -0.00162818f, 
    0.00048733f, 0.01592617f, -0.00617260f, 0.00518470f, -0.01450341f, -0.03718263f, -0.03500765f, -0.00980304f, 
    0.03018653f, 0.01554185f, -0.02461407f, 0.03550452f, -0.02581932f, -0.03539595f, 0.02913551f, -0.02430059f, 
    -0.00855980f, -0.03471459f, 0.00450605f, 0.00698879f, -0.03907321f, -0.02711421f, -0.01397582f, 0.02279520f, 
    -0.04228489f, -0.00335100f, -0.03177769f, 0.01728129f, 0.02265372f, -0.03042034f, -0.02478725f, 0.01629527f, 
    -0.03177704f, -0.00758622f, 0.00139692f, -0.00547707f, -0.01134544f, 0.01643152f, -0.02042179f, -0.00708522f, 
    0.02313050f, -0.02682590f, -0.00876397f, 0.02143850f, -0.03903637f, 0.01565058f, -0.04242345f, 0.02448655f, 
    -0.02263923f, 0.02955040f, 0.03264301f, 0.00450967f, -0.02477823f, 0.02627681f, -0.02931937f, 0.03326695f, 
    -0.02184751f, 0.02082337f, -0.00365222f, -0.00128786f, -0.02564873f, -0.02494392f, -0.00413596f, 0.02911143f, 
    -0.02395220f, -0.02530467f, -0.01226138f, -0.03258651f, 0.02824816f, 0.01392339f, -0.00380850f, -0.03782232f, 
    0.01122178f, -0.02134478f, -0.03161643f, 0.00854641f, -0.00319874f, -0.01842108f, 0.01506727f, 0.01208314f, 
    0.01995104f, -0.02116998f, 0.01965987f, -0.00594068f, 0.02337037f, 0.03061997f, 0.00926502f, -0.00233301f, 
    -0.00323220f, -0.03255105f, 0.01522283f, -0.01281529f, -0.04148450f, 0.02965429f, 0.02936051f, -0.03631216f, 
    0.02758244f, 0.03231851f, -0.02134335f, -0.01826806f, 0.00655109f, -0.00492846f, -0.02519171f, -0.01983136f, 
    0.01752305f, 0.00666391f, -0.02612724f, -0.03479856f, -0.01062723f, 0.01687879f, -0.00545212f, -0.04267504f, 
    0.01840890f, -0.00120340f, -0.03427230f, 0.01136997f, 0.01141250f, -0.02581446f, 0.02495360f, -0.03744644f, 
    -0.03059432f, -0.02718757f, 0.01925267f, 0.01871999f, 0.02257323f, 0.02427596f, -0.02351684f, 0.02271589f, 
    0.01027536f, -0.01173116f, -0.01398220f, -0.03580979f, -0.00206241f, 0.01732322f, 0.02770185f, -0.02719353f, 
    0.02377797f, 0.00294928f, 0.01058763f, 0.01640632f, -0.00150933f, -0.03893531f, -0.02164224f, -0.00291606f, 
    -0.01018062f, 0.03063432f, -0.02139404f, 0.02253565f, 0.00646273f, -0.03443199f, -0.02787244f, -0.04058250f, 
    -0.01232495f, -0.01132751f, 0.02549548f, 0.00430361f, -0.03845819f, -0.02506186f, -0.00936227f, -0.02877030f, 
    0.01074594f, 0.00245086f, 0.00481156f, -0.02720384f, -0.01133080f, -0.03721189f, -0.01017205f, -0.00193592f, 
    0.01574488f, 0.01384577f, -0.03077285f, 0.01162837f, -0.02812954f, -0.00304729f, 0.00633809f, 0.01307900f, 
    0.01025193f, 0.02524606f, 0.02279459f, 0.02248907f, -0.02849736f, 0.00363228f, -0.02940512f, -0.03118051f, 
    0.02045316f, -0.04251885f, 0.00390619f, -0.02708066f, 0.00973869f, 0.01644590f, 0.00198385f, -0.01940407f, 
    0.00627783f, -0.04147274f, 0.00388361f, 0.00058718f, -0.03559624f, -0.03231899f, -0.03308989f, -0.02023925f, 
    0.00701407f, 0.01636526f, 0.00416370f, -0.00156846f, -0.00062492f, -0.01938597f, -0.02229537f, 0.02154707f, 
    0.02784577f, 0.00418749f, 0.03803084f, -0.01800160f, -0.01938719f, -0.02687632f, -0.02400345f, 0.03748237f, 
    0.00072691f, -0.01861010f, 0.01599783f, 0.00000816f, -0.02132399f, -0.01829624f, 0.02516378f, -0.02731322f, 
    -0.01209801f, -0.01221053f, -0.03223986f, 0.03459632f, -0.02568439f, 0.00217349f, -0.04362357f, -0.00671587f, 
    -0.01402980f, 0.02271005f, -0.01128892f, 0.02449752f, 0.01959830f, -0.02739390f, -0.01689398f, 0.01936785f, 
    -0.01752469f, -0.00939437f, 0.02346860f, -0.02416027f, -0.04377709f, 0.01049121f, 0.01306482f, 0.00704741f, 
    -0.00762631f, -0.00716285f, 0.03477196f, -0.01996382f, 0.02295018f, 0.00469344f, -0.01121616f, 0.00811542f, 
    -0.02893943f, -0.00735498f, -0.03574762f, 0.01257355f, -0.00847170f, -0.01755975f, -0.00582590f, -0.03897397f, 
    0.03780065f, 0.01627069f, 0.00531714f, 0.00062584f, -0.02099881f, -0.02782850f, -0.01738473f, 0.03254552f, 
    0.00689609f, 0.00581690f, 0.02536212f, -0.00236592f, 0.00380986f, -0.02987729f, -0.01791294f, -0.03112799f, 
    -0.03279062f, 0.01149919f, -0.03634905f, 0.00016816f, -0.00975013f, 0.02530811f, -0.02378170f, -0.02549645f, 
    -0.02985756f, -0.03333560f, -0.01782059f, 0.02446218f, -0.02835985f, 0.01466625f, -0.01812268f, 0.01821152f, 
    -0.00630133f, -0.03384575f, -0.02295501f, -0.00152365f, 0.02086865f, -0.01276065f, 0.01717502f, 0.02852700f, 
    0.02565624f, -0.02616061f, -0.02209637f, 0.00777699f, -0.02627781f, -0.00793487f, 0.01041849f, 0.02067884f, 
    0.00540904f, -0.00264251f, -0.01779641f, 0.02518786f, -0.03608384f, 0.00887803f, -0.01631910f, 0.01061101f, 
    -0.00600409f, 0.02210621f, -0.02619867f, 0.04086135f, -0.00306955f, -0.02745028f, 0.00396017f, -0.02546421f, 
    -0.01720786f, 0.04032739f, 0.00645002f, -0.02920969f, 0.01560714f, -0.00609168f, -0.02294733f, 0.01675806f, 
    -0.01209049f, 0.00082605f, -0.01983815f, -0.01711610f, -0.02085076f, -0.02575561f, 0.02788493f, 0.03334781f, 
    0.00006895f, 0.03287186f, 0.00784739f, -0.00225917f, -0.02319449f, -0.01782862f, -0.00431555f, 0.00786206f, 
    -0.01504378f, 0.01860141f, 0.02048113f, -0.00107603f, -0.03703740f, 0.02449705f, -0.01256775f, -0.01689848f, 
    -0.00247248f, -0.01929147f, -0.01482758f, 0.02107208f, -0.00392150f, -0.04018599f, -0.02729498f, 0.02269518f, 
    0.00712615f, 0.00496362f, -0.00411809f, -0.02686066f, -0.04231889f, -0.02623426f, 0.01235506f, 0.00301062f, 
    -0.01131318f, -0.00460789f, -0.01757738f, -0.00097433f, -0.02816073f, -0.01574454f, -0.03345256f, -0.00386877f, 
    0.03506240f, 0.01912749f, -0.01153177f, -0.00444925f, -0.03229933f, 0.02522210f, -0.03406996f, -0.03239803f, 
    0.01316991f, -0.01065468f, -0.01363844f, -0.04474036f, 0.01348272f, -0.04288745f, 0.02440897f, -0.00822770f, 
    -0.00440913f, 0.02060728f, 0.02079595f, -0.02027716f, -0.01193587f, -0.02433424f, 0.00174269f, 0.02726631f, 
    -0.01650691f, 0.00056578f, 0.01886738f, 0.02269496f, -0.00814597f, -0.02649488f, -0.00367573f, -0.00549561f, 
    -0.02655334f, -0.03938334f, -0.00720791f, -0.01493801f, 0.01916678f, 0.03038752f, 0.02475591f, -0.03239712f, 
    -0.01401689f, 0.01716007f, -0.02438804f, 0.01932119f, -0.00336812f, -0.02880798f, 0.00595847f, 0.01123841f, 
    -0.00987417f, -0.04058009f, -0.00615004f, -0.04032958f, -0.01055805f, -0.02183667f, -0.01280722f, 0.03544881f, 
    -0.02288385f, 0.03813154f, 0.01050021f, 0.00274203f, 0.01504200f, -0.03198726f, 0.02448380f, 0.00830039f, 
    0.03092651f, 0.00873278f, 0.02387093f, 0.00995186f, 0.02530099f, -0.00346158f, -0.02563190f, -0.01976525f, 
    -0.02036398f, 0.02349901f, -0.00858919f, -0.00167391f, 0.00910837f, 0.02764644f, -0.00451921f, -0.00457554f, 
    -0.02523634f, -0.00373905f, -0.02347817f, -0.01723507f, -0.00409805f, -0.01775504f, 0.02419691f, -0.02354754f, 
    0.00298167f, 0.00931523f, -0.00109569f, 0.03882351f, 0.01328073f, -0.00596563f, 0.02132634f, -0.00223322f, 
    0.01078081f, 0.00829190f, 0.02950499f, -0.03164105f, 0.02307065f, 0.01540559f, 0.02978521f, -0.01152969f, 
    0.03872047f, -0.01894812f, 0.00362038f, -0.02044752f, -0.02474811f, 0.01155102f, -0.00211789f, -0.00272574f, 
    -0.00955942f, -0.02993059f, 0.00501710f, -0.00885136f, -0.02760613f, 0.02964309f, 0.02497525f, 0.00618639f, 
    0.01323991f, 0.00376606f, -0.02770495f, 0.01068685f, 0.00980102f, 0.01345877f, 0.02011323f, -0.03976670f, 
    -0.03150528f, 0.00227338f, -0.03698922f, -0.04364917f, -0.00825971f, -0.01609187f, 0.01873189f, -0.00070816f, 
    -0.03230677f, -0.02401137f, 0.01209565f, -0.01340878f, -0.02817656f, -0.01236161f, 0.00190942f, 0.02905609f, 
    -0.01149315f, -0.01121043f, 0.00723282f, -0.01222167f, -0.00963083f, -0.01628289f, -0.01822918f, -0.01502777f, 
    0.00492146f, -0.02256820f, -0.02652009f, -0.00812863f, -0.03076772f, -0.04089914f, -0.00128106f, -0.01250400f, 
    -0.02270892f, -0.00149858f, 0.01465062f, -0.02884327f, -0.02815432f, -0.01535625f, 0.02062947f, -0.00499014f, 
    -0.02084250f, 0.02107710f, -0.04311305f, -0.02792040f, -0.00923275f, -0.02663699f, -0.03519151f, 0.02587268f, 
    0.02055112f, -0.03406844f, -0.02234361f, 0.01594951f, -0.01376983f, -0.01714994f, -0.02251702f, -0.01161076f, 
    0.01996827f, 0.01755719f, 0.01497906f, -0.00774192f, -0.04118367f, -0.03360945f, 0.01323903f, -0.03154056f, 
    0.01250019f, -0.00412905f, -0.03544872f, -0.00260451f, -0.01594306f, -0.02565731f, -0.01799723f, 0.00802207f, 
    0.00933153f, -0.03536291f, -0.01564529f, 0.00185277f, -0.01413044f, 0.02434403f, -0.02854378f, 0.01249377f, 
    0.02125858f, -0.00270809f, -0.04333981f, 0.00152850f, -0.00941240f, -0.03558888f, -0.03299555f, 0.02502552f, 
    -0.00408718f, -0.00821858f, 0.01816220f, 0.02426428f, -0.02085253f, -0.00336443f, -0.01834234f, -0.00644062f, 
    0.01624001f, 0.00391169f, -0.00307373f, -0.01651871f, -0.01397356f, 0.00973585f, -0.00151919f, -0.03651983f, 
    0.02232259f, 0.02541418f, 0.02736553f, 0.01467546f, 0.02014078f, -0.03261027f, 0.00974149f, 0.00266143f, 
    -0.03369395f, -0.00756956f, -0.00206923f, -0.03279799f, -0.01624254f, -0.01964329f, 0.02380936f, 0.01465979f, 
    -0.01079445f, -0.04249560f, -0.00585291f, -0.00651679f, 0.01173353f, 0.01765749f, -0.00886628f, -0.02521908f, 
    0.01626146f, -0.03240115f, 0.00485468f, -0.02274769f, 0.01729367f, 0.00623132f, -0.00181364f, 0.02397417f, 
    0.01881250f, -0.02112387f, -0.01358140f, 0.00223050f, -0.00135941f, 0.01437272f, -0.03308432f, 0.00945184f, 
    -0.02823258f, 0.01775762f, 0.00620311f, 0.01664904f, 0.01135147f, -0.03217581f, -0.03981647f, -0.01312761f, 
    -0.03317757f, 0.00503106f, -0.00791193f, -0.03208233f, -0.04103557f, -0.02267144f, -0.03454961f, 0.01945334f, 
    -0.02725884f, 0.01061152f, 0.02796520f, -0.00891249f, -0.03320137f, -0.01588951f, -0.00285654f, -0.03229955f, 
    -0.03531977f, -0.00078832f, 0.02739029f, 0.00032784f, 0.00500191f, 0.02185535f, 0.02601685f, -0.02613846f, 
    0.01047780f, 0.00880991f, -0.03267862f, 0.00550002f, 0.00494347f, -0.02176216f, -0.00896318f, -0.00326993f, 
    -0.03899064f, 0.01364916f, -0.02901943f, -0.03324247f, 0.01705925f, -0.00854986f, -0.00867811f, -0.02008981f, 
    0.02210604f, -0.01047453f, -0.03965126f, 0.02605944f, -0.00718667f, -0.00624624f, 0.00826941f, -0.01416706f, 
    -0.02547037f, 0.02408491f, -0.01096070f, 0.00816113f, 0.02454509f, 0.02688110f, -0.00880112f, -0.02043500f, 
    -0.03140083f, -0.03982336f, -0.00990161f, 0.01561391f, 0.01276723f, 0.00112373f, -0.03701103f, 0.02100833f, 
    0.01567991f, -0.03869630f, -0.02735678f, 0.02359414f, 0.01044431f, 0.01123375f, -0.03942688f, -0.01135582f, 
    0.00183391f, 0.00503954f, -0.01827363f, -0.01698026f, 0.01757059f, -0.00601125f, -0.03960955f, 0.02377497f, 
    -0.02675972f, -0.02602813f, -0.00649605f, 0.01598655f, -0.03345701f, -0.01288775f, -0.00743303f, -0.03006370f, 
    0.02602650f, 0.02620477f, -0.00497207f, -0.01158801f, -0.02858379f, -0.01443397f, -0.02875574f, -0.03984602f, 
    -0.04193175f, -0.00831694f, 0.01835991f, -0.04102446f, -0.04157832f, 0.01097343f, -0.03833671f, -0.00759519f, 
    0.00947034f, -0.01770206f, -0.00177515f, -0.03294156f, -0.01519971f, 0.01113551f, -0.01765959f, 0.02497419f, 
    0.01277388f, 0.02448230f, -0.00612238f, 0.01741749f, 0.01929520f, 0.00111152f, 0.01854291f, -0.03334850f, 
    -0.00046551f, -0.00926930f, -0.04163632f, 0.00198547f, 0.02262232f, -0.04172964f, -0.01770815f, 0.01882949f, 
    -0.01062746f, 0.02448442f, 0.01781471f, -0.03531215f, 0.02400408f, 0.01563298f, -0.00134340f, 0.01133286f, 
    -0.04310973f, 0.01237342f, -0.00048803f, 0.01241574f, -0.02580396f, -0.00203527f, 0.00127164f, -0.03808858f, 
    0.02024446f, -0.03266345f, -0.01283037f, -0.01675266f, 0.01060755f, 0.02513716f, 0.01669184f, -0.02854650f, 
    0.02009657f, -0.00577302f, 0.00365747f, 0.01063320f, 0.02298124f, -0.00295801f, 0.01559144f, -0.01268184f, 
    0.01814564f, -0.00674224f, -0.03661124f, -0.04318715f, -0.02043724f, -0.03707635f, 0.01408476f, -0.03209404f, 
    -0.04276961f, -0.01908342f, 0.01312751f, -0.00247906f, 0.01857589f, -0.03390057f, -0.02946028f, 0.00461572f, 
    -0.01532607f, 0.02618339f, -0.01317063f, 0.00107927f, 0.02261799f, -0.02434664f, 0.02756128f, -0.03106548f, 
    -0.03177933f, -0.02344035f, 0.00017883f, -0.00005571f, -0.00754222f, -0.03882062f, -0.00274055f, -0.03749225f, 
    -0.02144497f, -0.03335923f, -0.03504315f, -0.04284604f, -0.03152090f, 0.01751745f, -0.03260384f, -0.02428154f, 
    -0.02461435f, -0.00611448f, -0.01879626f, -0.04231906f, 0.02519506f, -0.03951238f, 0.02402154f, -0.02312032f, 
    0.02210830f, -0.01466384f, -0.03362609f, -0.00307486f, 0.02040786f, -0.03181875f, -0.01217161f, 0.02032128f, 
    -0.03485797f, 0.01202008f, 0.00803366f, -0.03743559f, -0.00053921f, -0.01017398f, -0.00208113f, 0.00110361f, 
    -0.04011839f, 0.01088970f, -0.02962625f, 0.02463181f, 0.01607705f, 0.00983004f, -0.04131737f, -0.02429594f, 
    -0.00380755f, -0.03285043f, -0.03441262f, -0.00120966f, -0.01538999f, -0.02104503f, -0.02312431f, -0.02887217f, 
    0.00856372f, -0.00380167f, 0.00559939f, -0.02273123f, -0.02000684f, 0.01561589f, 0.00555975f, -0.03589052f, 
    -0.02875629f, 0.01523413f, -0.03962204f, 0.01082006f, 0.01094049f, 0.00479543f, 0.00954056f, 0.01578453f, 
    0.01048345f, -0.04120296f, -0.03831214f, -0.00046601f, 0.01925528f, -0.03302589f, 0.01216204f, -0.02634875f, 
    -0.00257874f, -0.01985378f, -0.04067247f, -0.01232270f, -0.00067396f, -0.00660989f, 0.01054646f, -0.01336271f, 
    0.01294113f, -0.03374116f, -0.01562726f, 0.00105526f, -0.00588721f, -0.01202439f, -0.00821153f, -0.00062795f, 
    -0.02509978f, 0.02598415f, -0.00500838f, 0.00053350f, 0.00875901f, 0.01136929f, -0.04262588f, 0.01788016f, 
    -0.03129937f, 0.00629022f, 0.00646348f, -0.00396371f, 0.01489263f, -0.00622561f, -0.02697019f, 0.02553898f, 
    -0.01014991f, -0.02053906f, -0.02499385f, 0.00175654f, 0.00315524f, -0.03251436f, -0.03351716f, -0.03447041f, 
    -0.00383114f, 0.00807993f, 0.00903209f, 0.02251412f, 0.02701770f, -0.01477410f, 0.01777696f, -0.03049296f, 
    0.00423397f, 0.00656546f, 0.01202080f, 0.00192879f, -0.02236156f, -0.04456231f, 0.00658589f, 0.00548828f, 
    -0.04280396f, -0.01820522f, 0.02589474f, 0.01966390f, 0.01143773f, -0.01793799f, -0.01393224f, -0.01560871f, 
    0.02523219f, 0.01555454f, -0.03171545f, -0.02514178f, -0.01541060f, -0.00554485f, -0.02006684f, 0.00091957f, 
    -0.01506508f, 0.01983953f, -0.01496588f, 0.02123894f, -0.03842125f, -0.02392434f, 0.00680197f, 0.02013893f, 
    -0.00661027f, 0.00164363f, -0.03425787f, -0.00199069f, 0.01594652f, 0.01829658f, -0.03542572f, 0.02402289f, 
    0.01183718f, 0.00678394f, 0.00098022f, -0.04137559f, 0.01094596f, 0.00063851f, 0.01052118f, -0.02849036f, 
    -0.00450854f, 0.01196457f, -0.01120933f, -0.03064286f, -0.03047749f, 0.01450100f, 0.01438852f, 0.02320859f, 
    -0.04337268f, -0.03671059f, -0.00681422f, 0.00968939f, -0.02869004f, -0.00640997f, 0.02586173f, -0.03633593f, 
    0.02543418f, -0.03996607f, -0.03989487f, 0.00742703f, -0.03084358f, 0.02151766f, -0.03661765f, 0.01793711f, 
    0.01634564f, 0.01955307f, -0.01054263f, -0.04265273f, -0.04067053f, 0.02861405f, 0.01809264f, -0.02726062f, 
    -0.02011319f, 0.00521372f, -0.03506006f, -0.04166033f, -0.02874955f, 0.01700244f, 0.02780911f, 0.00267852f, 
    0.01002103f, 0.00275431f, 0.01123325f, 0.01410531f, -0.02653720f, -0.01797024f, -0.04080702f, -0.00609796f, 
    -0.03721278f, -0.02745053f, 0.01278109f, -0.01535037f, 0.01175435f, -0.00128987f, -0.01640612f, -0.01280687f, 
    0.01490743f, -0.02964603f, 0.00346539f, -0.00178530f, -0.03140979f, -0.04034358f, 0.00407848f, -0.02577577f, 
    -0.04283394f, -0.00769562f, 0.00220373f, -0.00846569f, 0.01977236f, 0.02292069f, 0.00127457f, -0.03027649f, 
    -0.04184493f, -0.03467494f, -0.00215421f, -0.00117802f, 0.02722921f, -0.02782537f, -0.02743513f, 0.00130746f, 
    -0.04169282f, 0.01885864f, 0.00655954f, 0.02580674f, -0.00016367f, 0.01995416f, -0.03514171f, -0.03981935f, 
    0.00530057f, 0.00652554f, -0.01239078f, 0.01462030f, -0.01259547f, -0.03882537f, -0.01052201f, 0.01879800f, 
    0.01051979f, -0.03286541f, -0.02928898f, -0.00043235f, 0.01035453f, -0.02267700f, -0.03617948f, 0.00425307f, 
    0.02355216f, -0.01207344f, -0.02591200f, -0.02529682f, 0.00490306f, -0.01908736f, -0.03606732f, 0.01187008f, 
    -0.02577587f, -0.03276900f, 0.01741039f, -0.02719301f, 0.01574323f, 0.02043590f, 0.00798145f, -0.00631062f, 
    -0.01134350f, -0.01424176f, -0.03915178f, -0.01355801f, -0.04050119f, 0.02640376f, 0.02617190f, 0.00673516f, 
    -0.03137517f, -0.02787443f, -0.00579871f, -0.01761373f, 0.02644585f, -0.04296132f, -0.01803260f, -0.00157178f, 
    0.02448271f, -0.02842045f, -0.00780141f, -0.00021925f, 0.00363939f, 0.01018895f, 0.02563064f, -0.02816552f, 
    -0.04211802f, 0.00711811f, -0.03919588f, 0.00092882f, -0.01609206f, -0.00054092f, 0.02089346f, 0.00753297f, 
    0.01358143f, -0.03234579f, -0.00313694f, 0.02547262f, -0.00131878f, -0.02950511f, -0.02763924f, -0.01872908f, 
    -0.01121209f, 0.02655105f, 0.00873336f, -0.02012667f, -0.04078687f, -0.03195516f, -0.03079923f, -0.02659725f, 
    -0.03468530f, 0.00792466f, 0.02265837f, -0.00591134f, 0.00026400f, -0.02810874f, -0.01760668f, 0.01368352f, 
    -0.03293270f, -0.00514472f, 0.00696256f, -0.01935114f, -0.01259498f, -0.00870839f, -0.00432943f, -0.03849721f, 
    0.01327718f, -0.01411249f, -0.02423797f, 0.01077388f, -0.03742601f, 0.01909354f, 0.00798715f, 0.00496181f, 
    -0.03551031f, -0.03789507f, -0.00705566f, 0.01047451f, -0.02021859f, -0.00210128f, -0.03468754f, -0.02925930f, 
    0.01271097f, -0.03429158f, 0.02222237f, 0.02636109f, 0.00292265f, -0.03857598f, -0.00735268f, 0.00874350f, 
    0.02178121f, 0.01477978f, -0.01807673f, -0.04028025f, -0.04101232f, 0.00505350f, 0.02711981f, 0.00654338f, 
    -0.00062294f, 0.00190325f, -0.04306569f, 0.00423653f, 0.02248095f, -0.00990922f, -0.03583999f, -0.02141088f, 
    -0.00960444f, 0.02543629f, 0.01540522f, 0.00628811f, 0.02422235f, -0.00714248f, 0.01023199f, 0.00394343f, 
    -0.01734899f, -0.01912201f, -0.01165371f, -0.02506026f, -0.00854564f, -0.01366284f, 0.00043512f, -0.00983314f, 
    0.01855961f, -0.02932412f, -0.03060854f, -0.03082461f, -0.00012238f, -0.03894414f, -0.02303582f, -0.00312817f, 
    0.00277215f, -0.02429141f, 0.01455806f, -0.00234515f, 0.02509251f, 0.02159657f, -0.03875234f, -0.01501283f, 
    -0.02368957f, 0.01962627f, 0.02189492f, 0.00202291f, 0.01261343f, -0.01460359f, 0.00981936f, -0.03630353f, 
    0.01141720f, -0.00787603f, -0.03335710f, 0.01179134f, -0.01842122f, -0.03270189f, 0.00167567f, -0.04355211f, 
    -0.04274113f, -0.02405385f, -0.04019253f, -0.03490944f, -0.01262251f, 0.00130950f, 0.01673117f, 0.00567419f, 
    -0.01141158f, -0.02438397f, 0.02712091f, 0.02491285f, -0.04175500f, -0.02847114f, -0.03648330f, -0.02589077f, 
    0.02203454f, -0.01034072f, 0.00514168f, -0.02807388f, -0.01002411f, -0.03868126f, -0.02969758f, -0.01215480f, 
    -0.01505274f, -0.01165427f, -0.04137649f, -0.02591941f, 0.01157737f, -0.01263699f, 0.00449395f, -0.03468221f, 
    0.00185504f, -0.01165255f, -0.00715284f, -0.01388874f, -0.03621967f, -0.01450775f, 0.02619863f, 0.02531928f, 
    -0.00237180f, 0.02168280f, -0.00970414f, 0.00239361f, 0.01927685f, -0.01573385f, -0.02160724f, -0.04386193f, 
    -0.03663214f, 0.00209320f, -0.03548969f, -0.00160746f, -0.01150123f, 0.00061805f, 0.00014563f, -0.00704063f, 
    -0.04109209f, -0.01103679f, 0.00983251f, -0.01409991f, -0.00482550f, 0.00793502f, -0.04211363f, -0.04107663f, 
    -0.03237383f, 0.02429401f, 0.01008119f, 0.01444893f, 0.01502775f, -0.03428636f, -0.00906257f, -0.03978248f, 
    -0.03288366f, 0.02170635f, 0.01074303f, -0.00788315f, -0.04255579f, 0.01842949f, -0.00330056f, -0.02180533f, 
    0.00389204f, -0.02626109f, -0.00809987f, -0.02791093f, -0.02961173f, -0.00672156f, -0.02209472f, -0.03535633f, 
    0.01495713f, -0.02428555f, 0.01072062f, -0.01242627f, -0.01262329f, 0.00310112f, 0.01350025f, -0.00044859f, 
    -0.02157635f, -0.00162436f, 0.01940897f, -0.01025938f, 0.02701212f, -0.00964789f, 0.00374362f, 0.00126114f, 
    -0.00932297f, 0.01663932f, -0.03182762f, -0.03543283f, -0.02641626f, -0.01347362f, 0.01588142f, -0.01734172f, 
    -0.02232706f, -0.00714568f, 0.00488483f, 0.03168271f, -0.00979499f, -0.00735875f, -0.04108497f, 0.02024787f, 
    0.01702782f, -0.02217195f, 0.00366370f, -0.02107707f, -0.04036583f, -0.00305586f, 0.01109101f, -0.03901889f, 
    -0.03127784f, -0.01066016f, -0.03707729f, 0.01521234f, -0.01271003f, 0.02546618f, -0.02356366f, -0.02937909f, 
    0.03563460f, 0.02379810f, -0.03995392f, -0.00096885f, -0.04106805f, 0.01697696f, 0.00962264f, -0.03655896f, 
    -0.00161669f, 0.02564842f, 0.00643170f, -0.00365269f, -0.02394222f, -0.02477668f, -0.02382200f, 0.02841165f, 
    -0.04010832f, -0.01073585f, -0.00727804f, -0.00584690f, 0.02126783f, 0.02141205f, 0.02168031f, -0.03998730f, 
    0.02640721f, -0.00316614f, 0.02526622f, 0.00310724f, -0.01893847f, 0.02408242f, -0.02580543f, 0.00848209f, 
    0.01732288f, -0.02485852f, -0.01871757f, -0.02839767f, 0.01744918f, -0.00004544f, -0.00245186f, 0.01304620f, 
    -0.01338365f, -0.01192942f, 0.02770373f, -0.01598103f, -0.04211017f, -0.02153598f, 0.01320604f, -0.02960805f, 
    -0.02714277f, -0.03876491f, 0.00216726f, -0.01099292f, -0.03575001f, -0.03082086f, -0.03281340f, 0.01920273f, 
    -0.01649460f, 0.02003804f, 0.00831045f, 0.02536912f, 0.01366908f, -0.02516969f, 0.00285661f, 0.00101732f, 
    -0.04103919f, 0.01986480f, 0.01376546f, 0.00684646f, -0.00202658f, 0.01331466f, 0.02151949f, 0.00671440f, 
    0.01717740f, -0.04140364f, 0.03965535f, -0.02943478f, 0.02972971f, -0.03360818f, 0.01911401f, -0.00582333f, 
    0.02608114f, -0.01868225f, 0.02710220f, -0.02202311f, -0.01973014f, -0.04311286f, 0.01650336f, -0.01925655f, 
    0.00746722f, -0.00108359f, 0.02278675f, -0.01039007f, -0.00034298f, 0.01919012f, 0.02852011f, -0.00005143f, 
    -0.01223375f, 0.00190871f, -0.02659724f, 0.00603743f, -0.04435744f, 0.01543323f, -0.03347635f, 0.00298607f, 
    -0.00854671f, -0.01113424f, 0.00918597f, 0.00476081f, -0.00846626f, 0.02008466f, 0.01078818f, -0.02638894f, 
    -0.01291305f, -0.03250958f, -0.03983802f, -0.04296460f, 0.01135958f, -0.00365150f, -0.00263470f, 0.01456050f, 
    -0.03428997f, -0.00747933f, 0.00900716f, 0.00822009f, 0.02884261f, 0.02701740f, 0.01435240f, -0.01565509f, 
    0.01312605f, 0.02176407f, -0.01770783f, 0.01023777f, 0.02056263f, 0.02679418f, 0.00892612f, 0.01035673f, 
    -0.02809380f, -0.01487015f, 0.02317823f, 0.00809927f, 0.00090853f, -0.02046989f, 0.02482201f, -0.00533011f, 
    -0.00296648f, -0.01552192f, 0.02473642f, -0.03525407f, 0.01718733f, 0.00323653f, 0.02758107f, 0.02089524f, 
    0.02020891f, 0.02590846f, 0.01590136f, -0.00220547f, -0.02865153f, 0.00353608f, -0.00034178f, -0.01705359f, 
    -0.04260236f, 0.02847173f, -0.04164681f, 0.00848229f, 0.00576447f, 0.01474156f, -0.00975824f, 0.02598362f, 
    0.02757485f, -0.00896760f, 0.01551871f, 0.00998807f, 0.00974464f, -0.01225586f, -0.01475807f, 0.00945340f, 
    0.01419970f, 0.00345827f, -0.01353170f, 0.00300531f, 0.00493202f, -0.01272920f, -0.04056581f, -0.03090761f, 
    0.02795855f, -0.02817456f, 0.00838505f, 0.00155466f, 0.01108184f, -0.04388301f, -0.00181535f, -0.00807178f, 
    0.00304336f, 0.02612990f, 0.00909256f, -0.04187653f, -0.03029522f, 0.00703753f, 0.00519072f, -0.00482013f, 
    -0.00292985f, -0.01353744f, 0.00125800f, -0.04142228f, 0.01064828f, 0.01860833f, -0.03381244f, 0.02873993f, 
    0.00764994f, -0.02172354f, -0.00886942f, 0.01005064f, -0.03712905f, -0.02786896f, -0.04006184f, 0.00178581f, 
    -0.02339575f, 0.00009405f, -0.01763599f, 0.01002156f, -0.04062672f, -0.03613032f, -0.01796661f, 0.01366565f, 
    0.00232158f, -0.02739342f, -0.01738783f, -0.00045079f, 0.02133543f, 0.02349292f, -0.01281360f, -0.02840680f, 
    -0.02336474f, -0.02133991f, 0.02059079f, -0.02699648f, -0.02268850f, 0.00491092f, 0.02765795f, -0.02159148f, 
    -0.03616422f, -0.01096161f, 0.02017473f, 0.00919977f, 0.01519752f, 0.00376300f, 0.01089438f, -0.04096004f, 
    0.02090591f, -0.03194746f, -0.03893458f, 0.01881905f, 0.03130647f, -0.00559715f, 0.01636286f, 0.02194859f, 
    -0.02281600f, -0.02441649f, -0.02855224f, -0.03937731f, -0.03912495f, 0.01404053f, -0.03882580f, 0.02220742f, 
    0.01325984f, -0.02260251f, -0.03862409f, 0.01166586f, -0.01147746f, 0.00269106f, -0.01733009f, -0.01510596f, 
    0.02099681f, -0.00831719f, -0.03798010f, -0.01753529f, 0.02348672f, 0.00638625f, 0.00176202f, 0.00667212f, 
    -0.03367737f, -0.03949445f, 0.00533296f, -0.02258337f, -0.01389251f, -0.02467318f, -0.00308361f, -0.01112937f, 
    -0.04111755f, -0.02902795f, -0.03880436f, -0.00420895f, -0.01858333f, -0.04079158f, -0.03409192f, -0.02855993f, 
    -0.03007494f, -0.02883881f, -0.01051732f, -0.02303634f, -0.03072344f, 0.02680023f, -0.02591768f, 0.00211267f, 
    -0.01104842f, 0.00866943f, -0.02124256f, -0.01340272f, -0.01362015f, 0.00979393f, -0.03852944f, 0.02795911f, 
    -0.02540004f, -0.02319866f, 0.00976527f, 0.00121856f, -0.02246463f, 0.02861539f, -0.01885531f, 0.02880023f, 
    -0.03187706f, 0.02635905f, -0.00431506f, -0.04581985f, -0.01325679f, 0.02647185f, -0.01091818f, -0.00447329f, 
    0.02524355f, -0.03628098f, -0.00362303f, 0.01664525f, -0.00217075f, 0.02031851f, -0.01396184f, 0.01803049f, 
    -0.03125983f, -0.01702627f, -0.00467669f, -0.03256952f, -0.00962254f, -0.01334214f, -0.04073790f, 0.02060922f, 
    -0.00296535f, 0.02577982f, 0.01693083f, -0.03329593f, 0.02415387f, -0.03744001f, 0.00033883f, -0.00728740f, 
    0.01456289f, -0.04624218f, 0.00742280f, -0.00584738f, -0.01383037f, -0.01377114f, 0.01185371f, 0.01522553f, 
    0.01950756f, -0.03519138f, -0.03933862f, -0.03686420f, 0.01697924f, -0.00761542f, -0.02760804f, -0.00490531f, 
    0.00614751f, -0.01846850f, -0.00217108f, 0.02508644f, 0.01259212f, 0.00496136f, -0.01868066f, -0.01729452f, 
    -0.02449771f, 0.00126732f, -0.02233646f, -0.03974678f, 0.02718110f, 0.02103124f, -0.00167408f, 0.00024640f, 
    -0.01741098f, 0.01222700f, -0.03138764f, -0.04184093f, -0.02789506f, 0.00019999f, 0.00444003f, -0.01673695f, 
    -0.02235783f, -0.01796148f, -0.01546555f, -0.02705606f, -0.00002892f, 0.01962411f, -0.01677656f, 0.02610388f, 
    0.00747108f, -0.03488141f, -0.02964205f, 0.00654173f, -0.04043986f, -0.03702918f, -0.01091915f, 0.02314743f, 
    -0.03262349f, 0.02157885f, 0.01815646f, -0.00603440f, -0.01847162f, -0.00989481f, -0.03570277f, -0.02086494f, 
    0.01814838f, 0.01901706f, -0.04367186f, -0.02594729f, 0.00168567f, -0.01428091f, 0.01604809f, -0.00038680f, 
    0.02429710f, -0.02992179f, -0.00765932f, 0.01277992f, 0.00380065f, -0.03064662f, -0.00024787f, -0.00482289f, 
    0.02313565f, -0.03834108f, 0.02006745f, 0.02186416f, -0.01506663f, -0.04156448f, -0.02193349f, 0.00649565f, 
    -0.00877179f, -0.03953706f, -0.03185380f, -0.00014556f, 0.02229640f, -0.03888128f, 0.02352784f, -0.02156454f, 
    -0.00190219f, -0.02163058f, 0.02513705f, -0.01872933f, -0.03342663f, -0.02950916f, -0.01443235f, 0.02040635f, 
    -0.04162917f, 0.00279908f, -0.02288823f, -0.03507199f, 0.01356853f, -0.02891551f, 0.01388327f, -0.03895020f, 
    0.02384500f, -0.03861212f, 0.00472810f, 0.02699217f, -0.03890482f, -0.00970020f, -0.01588817f, -0.01527593f, 
    -0.01101443f, -0.02593923f, 0.00706605f, -0.00197071f, -0.03824132f, 0.01435181f, -0.01530189f, -0.04138547f, 
    -0.01825532f, -0.00573380f, 0.00405897f, 0.00698926f, 0.01714766f, 0.00981323f, 0.02302694f, 0.02613843f, 
    -0.04033274f, 0.01058143f, 0.01153125f, -0.00053950f, 0.01162822f, 0.00937842f, 0.01724615f, 0.02635460f, 
    0.00299219f, -0.03325765f, 0.02057429f, -0.04190818f, -0.01868706f, 0.01780347f, -0.00080958f, -0.02879837f, 
    -0.03841941f, -0.01969473f, 0.02775115f, 0.01684987f, -0.01182821f, -0.03356926f, -0.03296430f, 0.02744179f, 
    -0.03929628f, 0.02074890f, -0.02988689f, 0.01381547f, 0.01466682f, -0.03221771f, -0.03497032f, 0.02261497f, 
    -0.02909794f, -0.03806048f, -0.00302621f, -0.01047584f, 0.02054136f, 0.02435112f, 0.00923042f, 0.01732576f, 
    0.01136097f, -0.01576905f, 0.01131778f, -0.00724109f, 0.02353938f, -0.03607721f, 0.00890004f, -0.04072890f, 
    0.01830341f, -0.00819881f, -0.01182782f, -0.00862634f, -0.04369244f, 0.00433838f, -0.04318092f, -0.01592335f, 
    0.01925740f, -0.02152186f, -0.02123863f, 0.00633398f, 0.00765292f, -0.04227522f, -0.00399576f, 0.02739015f, 
    0.02546912f, -0.04132521f, -0.02314128f, 0.00276239f, -0.04337669f, 0.00594706f, 0.03211406f, 0.02868521f, 
    -0.03180109f, 0.01450887f, 0.00468860f, -0.01502638f, -0.02261020f, -0.03185705f, 0.00268545f, 0.01646228f, 
    -0.00300919f, 0.00458839f, 0.02420080f, 0.00804890f, -0.01188073f, -0.03157061f, -0.01442044f, -0.01064389f, 
    -0.03163655f, -0.01025987f, -0.04297043f, -0.00451578f, -0.01643320f, 0.01098109f, -0.03707013f, -0.01252363f, 
    0.01833231f, 0.01715402f, -0.03851098f, 0.01357976f, 0.01578094f, 0.01672078f, -0.01336668f, -0.01329100f, 
    -0.04117609f, 0.00288271f, -0.01799711f, -0.00779724f, -0.01028842f, 0.03753497f, 0.03142228f, -0.02096013f, 
    0.02625756f, 0.00484165f, -0.01691112f, -0.00796989f, -0.01077438f, 0.01505218f, -0.01492154f, 0.01760866f, 
    -0.01226713f, -0.03383186f, -0.00326239f, 0.00755023f, 0.01150942f, -0.02153505f, -0.02959341f, 0.00532256f, 
    -0.03165019f, -0.03814137f, 0.01045369f, -0.01522731f, 0.02088747f, 0.00854471f, -0.01038191f, -0.00543953f, 
    -0.04350566f, 0.02658383f, 0.00654704f, 0.02625738f, -0.00258371f, -0.03264458f, -0.02742410f, -0.03400327f, 
    -0.02858406f, 0.23123655f, 0.02234648f, 0.32571501f, 0.08781343f, 0.06570581f, -0.03057163f, 0.21125346f, 
    0.08937418f, -0.11426055f, -0.01502479f, -0.05041640f, 0.20386904f, 0.01389043f, -0.31800801f, -0.08645206f, 
    0.00239110f, -0.07158502f, -0.21256125f, -0.15629414f, -0.00701702f, -0.02276806f, -0.03023378f, -0.02882474f, 
    0.06576873f, 0.02177520f, -0.03542591f, 0.13698311f, 0.07957999f, 0.04334150f, -0.02705985f, -0.10273856f, 
    -0.06543485f, -0.03706150f, 0.19438781f, -0.02215643f, -0.10167515f, 0.06979392f, -0.01804699f, -0.01337701f, 
    -0.09445432f, -0.00066938f, -0.00166998f, -0.03232352f, -0.07322790f, 0.02250828f, -0.00493343f, -0.03455992f, 
    0.09820637f, 0.07476376f, 0.05915517f, -0.29516482f, -0.06776921f, 0.05705306f, -0.08166716f, -0.32570687f, 
    -0.03882313f, -0.00416374f, 0.18258323f, 0.14519477f, 0.48466489f, -0.36370957f, 0.03022235f, -0.11992589f, 
    0.05159467f, -0.06170137f, 0.14642021f, -0.05808363f, -0.02543347f, 0.00414225f, 0.03281711f, 0.07924861f, 
    0.44083890f, 0.16019768f, 0.29247141f, -0.09943286f, 0.10615978f, 0.11257625f, 0.03126520f, 0.06295868f, 
    -0.11950415f, 0.19845241f, 0.02355679f, -0.08619349f, -0.02955786f, -0.36077440f, 0.04873650f, -0.08803684f, 
    0.14826977f, -0.20928749f, -0.07738622f, 0.04288270f, -0.00763698f, -0.00537493f, 0.08209617f, 0.04351535f, 
    0.21771272f, 0.17191449f, 0.04736887f, 0.10540609f, -0.07929279f, -0.04575359f, 0.14696589f, 0.11406025f, 
    -0.00423123f, 0.15285057f, 0.16613010f, -0.10167480f, 0.00078511f, 0.07380150f, -0.01760855f, 0.13359882f, 
    -0.08068416f, -0.16200298f, 0.03376017f, -0.02938685f, -0.00569358f, 0.06933530f, -0.04329135f, -0.05205580f, 
    -0.18129781f, -0.11262011f, -0.12106665f, 0.02421609f, -0.07301991f, 0.00191290f, -0.09312510f, -0.25771064f, 
    -0.00827931f, 0.09120629f, -0.10253939f, 0.16591090f, 0.11380907f, 0.12268526f, -0.09353587f, -0.17454806f, 
    -0.01472414f, 0.05704451f, -0.12937629f, -0.19288611f, -0.13160464f, -0.11758506f, -0.13771625f, -0.04087184f, 
    0.36093980f, 0.14533886f, -0.17734593f, 0.13814402f, 0.11295802f, 0.05168273f, -0.02345936f, -0.17355475f, 
    -0.06195829f, 0.17996007f, 0.08180442f, 0.14804795f, 0.05106527f, -0.03446419f, 0.01119716f, 0.11758266f, 
    -0.00599342f, 0.04608199f, 0.12163062f, 0.16850840f, -0.10024235f, -0.00728160f, 0.00826108f, -0.15087847f, 
    0.24163267f, -0.33000800f, -0.01288260f, -0.24173109f, -0.06310342f, -0.06138286f, 0.06093016f, -0.08737274f, 
    0.01235493f, 0.00199074f, -0.00394420f, 0.11717613f, -0.20347340f, -0.00108820f, 0.12770644f, 0.09490354f, 
    -0.00389936f, -0.09062047f, -0.01722627f, -0.01663716f, -0.07412060f, -0.02401151f, -0.03362895f, -0.04306112f, 
    0.01619483f, 0.08472994f, 0.12353709f, 0.13479607f, -0.12960584f, -0.15425667f, 0.18357676f, -0.04848464f, 
    -0.08911964f, 0.10070676f, -0.13962717f, -0.12799643f, 0.01610248f, -0.07945701f, -0.14835487f, 0.53449339f, 
    -0.02759079f, -0.01682246f, -0.15380336f, 0.12417466f, 0.03341734f, 0.02359017f, 0.08920838f, -0.08523513f, 
    0.23800360f, 0.31958395f, -0.08078403f, -0.05242145f, 0.10782529f, 0.05141726f, 0.05520075f, 0.16957024f, 
    0.02977388f, 0.00184047f, -0.02616841f, 0.07760313f, -0.14809266f, 0.22461775f, 0.16757311f, 0.16356343f, 
    0.13752036f, -0.11731827f, -0.21210448f, 0.43962988f, 0.00676031f, 0.02928369f, 0.08707011f, -0.15557919f, 
    0.02631569f, 0.44829276f, -0.32122764f, -0.01150261f, 0.23917127f, 0.09981681f, -0.10146887f, -0.14516106f, 
    -0.11501174f, 0.04947123f, 0.06188019f, 0.04405444f, 0.16125026f, -0.03483761f, 0.14946492f, 0.00201836f, 
    -0.00073088f, -0.00443192f, -0.00462364f, 0.01288791f, -0.12815382f, -0.11134794f, 0.00184241f, -0.18073791f, 
    -0.04475100f, 0.00461927f, 0.10739928f, 0.38126948f, 0.09485794f, 0.09163157f, -0.00187535f, 0.07303233f, 
    -0.04492837f, 0.12986578f, -0.00933058f, -0.08728940f, -0.56424952f, 0.03623395f, -0.02869121f, 0.13490658f, 
    -0.03824250f, -0.18895511f, -0.00294773f, -0.12895867f, -0.10609749f, -0.08337880f, 0.08251227f, 0.13774461f, 
    -0.14845362f, -0.06289128f, 0.12114128f, 0.02947106f, -0.02017122f, -0.03958886f, -0.09953072f, -0.04697059f, 
    0.19080175f, -0.03459148f, 0.10464946f, 0.12911882f, -0.07559843f, -0.12062152f, -0.03075293f, 0.19952036f, 
    -0.12973393f, 0.06857749f, 0.01142397f, -0.16572522f, -0.07478793f, 0.13730697f, -0.06901819f, -0.09257784f, 
    0.04983662f, -0.00643249f, 0.00584040f, 0.06569964f, 0.12480957f, -0.07395981f, -0.19684239f, -0.03614422f, 
    -0.02733899f, -0.10144032f, 0.01366717f, -0.09798073f, -0.72761524f, 0.61269575f, 0.24622747f, -0.09240862f, 
    0.07230237f, -0.02055922f, 0.01753198f, -0.14429995f, 0.00777148f, -0.19845082f, -0.02932975f, -0.02761469f, 
    0.21324374f, -0.14610764f, -0.35345051f, -0.08471890f, 0.10096104f, -0.03256380f, -0.18422572f, -0.19843860f, 
    -0.05810815f, -0.00732917f, -0.09419096f, 0.04096665f, -0.17296377f, 0.31320173f, -0.03381290f, 0.34055609f, 
    0.15701969f, 0.07472542f, -0.00876626f, 0.19144556f, 0.06341214f, -0.10172740f, -0.05028805f, 0.11931252f, 
    -0.03845061f, 0.02872300f, 0.12845987f, -0.02795791f, 0.02124994f, 0.01938778f, -0.03623029f, -0.07515757f, 
    -0.09546637f, -0.07280674f, 0.00010507f, 0.01025440f, 0.17563370f, 0.10163082f, 0.32786041f, -0.16000096f, 
    0.15064469f, 0.14600286f, 0.01925033f, 0.00849247f, -0.08832255f, 0.11148702f, -0.13326395f, -0.06373653f, 
    0.03504166f, 0.04151344f, 0.17132021f, -0.01818167f, 0.04090096f, 0.06286290f, 0.14519826f, -0.05634317f, 
    -0.03352890f, 0.20224184f, 0.02523006f, 0.15735435f, 0.16790441f, 0.18139553f, 0.31605205f, 0.01713055f, 
    0.13157365f, -0.01352261f, 0.10479942f, 0.12569512f, 0.05140557f, -0.04507471f, 0.05624773f, -0.05164476f, 
    0.46432996f, 0.05190894f, 0.40485412f, -0.24195024f, 0.08092418f, 0.07267027f, 0.01914123f, -0.17640945f, 
    0.01580503f, -0.02572012f, -0.02020132f, -0.20877583f, 0.31396884f, -0.02374865f, 0.15735750f, 0.18923542f, 
    0.19930422f, -0.02530073f, 0.01965555f, 0.15079737f, -0.13762130f, 0.07016169f, 0.15057974f, -0.01762415f, 
    -0.47508770f, -0.18815954f, -0.12556697f, -0.11821210f, -0.12028368f, -0.02317640f, -0.03060147f, -0.09565607f, 
    -0.11164919f, -0.02698367f, 0.04653437f, 0.08137425f, 0.03858869f, -0.15345955f, -0.10130072f, 0.30473888f, 
    0.10218381f, -0.05151743f, -0.04014987f, -0.09842163f, 0.05016809f, 0.01510804f, -0.02628741f, 0.04434657f, 
    0.26244041f, 0.06051452f, 0.04012225f, 0.01489912f, -0.10572153f, 0.00835028f, 0.02727933f, -0.11015971f, 
    -0.05582087f, 0.00879643f, 0.10391440f, 0.01857455f, -0.13510592f, -0.03437712f, 0.16751085f, 0.03122720f, 
    -0.00766834f, -0.03449659f, -0.12719344f, -0.06708121f, 0.06225738f, 0.01252564f, 0.10544079f, -0.00348938f, 
    0.30070555f, 0.06972460f, 0.00595329f, 0.19083624f, 0.08554019f, 0.20040916f, -0.17307132f, 0.40805367f, 
    -0.05199479f, 0.05653443f, 0.03058230f, -0.07852887f, -0.03073978f, -0.07330246f, 0.00182340f, -0.09414539f, 
    -0.05564420f, -0.00393163f, -0.07986639f, -0.02604614f, -0.09947615f, -0.07640453f, 0.16313542f, -0.05026560f, 
    -0.29110038f, 0.45319444f, 0.07493685f, 0.20312710f, -0.10792888f, -0.11422632f, 0.12358358f, -0.05647934f, 
    0.10787033f, -0.03376785f, -0.02616824f, -0.02376519f, 0.29254973f, 0.15406753f, 0.32738280f, 0.03609148f, 
    0.11620059f, 0.30250689f, -0.00129982f, 0.03241911f, -0.09706564f, 0.09509078f, 0.02250467f, -0.16629203f, 
    -0.26593190f, 0.17170392f, 0.08740585f, 0.06204922f, 0.12827416f, -0.13641523f, -0.02529820f, 0.19825503f, 
    0.02479146f, 0.01851853f, -0.06968849f, -0.01164326f, 0.01442469f, 0.13872692f, 0.09772674f, -0.09721112f, 
    -0.10141524f, 0.09245922f, 0.02256447f, 0.06967749f, 0.05014737f, -0.02590258f, -0.17111193f, -0.18871000f, 
    0.14287059f, 0.19927439f, 0.05008971f, 0.19427039f, -0.01232551f, 0.05132158f, 0.10099501f, 0.17571305f, 
    0.00713971f, 0.04511480f, 0.02546778f, -0.05564408f, -0.02765570f, 0.00976348f, 0.06858625f, -0.17787428f, 
    0.04982450f, 0.03234558f, -0.08897667f, 0.17284320f, 0.09430555f, -0.02139205f, -0.01716572f, -0.00878844f, 
    0.04419343f, 0.14483678f, -0.01139295f, -0.17798479f, -0.14126150f, 0.03403047f, 0.11629882f, -0.05634463f, 
    0.11216337f, -0.03398106f, 0.02676340f, 0.10001018f, 0.06758165f, -0.26521251f, 0.12986191f, 0.12820455f, 
    -0.03827360f, -0.01427193f, 0.12247945f, -0.15915197f, 0.13758007f, -0.13163471f, -0.04110963f, -0.01511027f, 
    -0.25092879f, -0.08033919f, -0.02844229f, 0.16870722f, -0.07138414f, -0.05938933f, -0.02275422f, -0.07451108f, 
    -0.16831924f, 0.01853167f, -0.04048655f, -0.06364579f, -0.05206547f, -0.10274842f, 0.07743502f, 0.03627115f, 
    -0.01026396f, 0.01854134f, -0.02338452f, 0.07381254f, -0.03692792f, 0.04976998f, -0.02433930f, 0.09765079f, 
    -0.06811238f, -0.05042300f, -0.03651629f, -0.13007806f, -0.16116841f, -0.08071568f, 0.05010551f, -0.15888028f, 
    -0.11219624f, -0.07854934f, 0.12074888f, -0.19155313f, 0.32294941f, 0.43378365f, -0.12984441f, -0.18302435f, 
    0.15886976f, 0.25129747f, -0.16893786f, 0.03836091f, 0.09477838f, -0.04415059f, -0.06561540f, 0.01384685f, 
    -0.00124094f, -0.09027791f, 0.27587309f, -0.08109699f, -0.02559594f, 0.16874638f, -0.05434343f, -0.06638742f, 
    -0.07983003f, 0.07529622f, -0.04386968f, 0.01482454f, -0.22490039f, -0.01434399f, 0.08797003f, 0.25764534f, 
    0.10481552f, -0.13001756f, -0.12261115f, 0.18398245f, -0.00683502f, 0.06330068f, 0.08329917f, -0.09666549f, 
    0.08866343f, -0.01219094f, -0.35324347f, -0.18500477f, 0.11172190f, -0.05729047f, 0.00946552f, 0.13358516f, 
    0.02995288f, -0.02727525f, -0.01119960f, 0.01220792f, -0.08457197f, -0.04138175f, 0.02168714f, 0.22236249f, 
    0.02968651f, 0.07995005f, -0.08243839f, 0.04427656f, -0.12595187f, -0.08066442f, -0.00868373f, -0.01746823f, 
    -0.02169698f, 0.14144932f, 0.08288231f, 0.06342951f, -0.14028192f, 0.01260385f, -0.01361325f, 0.11278774f, 
    0.05487339f, 0.09909321f, 0.00757142f, 0.20896652f, 0.20635004f, 0.11757787f, 0.00106224f, 0.01139071f, 
    0.07221740f, 0.14156947f, 0.14996158f, 0.18234529f, 0.01945501f, -0.06870313f, 0.00713435f, -0.00239862f, 
    -0.32289389f, 0.27165577f, -0.10654120f, 0.06535290f, -0.16038044f, -0.12539694f, 0.02276848f, -0.14273499f, 
    -0.14334604f, -0.16088846f, 0.03960692f, -0.04241670f, 0.01195318f, -0.21002442f, -0.41768789f, -0.21521668f, 
    0.07781938f, 0.11741088f, 0.06189809f, 0.16575140f, 0.03174611f, 0.03763714f, 0.08724957f, 0.19075796f, 
    0.21931872f, -0.22870989f, 0.21859409f, -0.11861455f, 0.06224851f, -0.03053749f, 0.07200798f, -0.02717642f, 
    -0.15373999f, -0.05133381f, 0.04182916f, -0.10686771f, -0.10030176f, -0.23111491f, -0.24383955f, 0.10563145f, 
    0.00799270f, -0.04754525f, -0.04405355f, 0.15892169f, -0.08407468f, 0.03161424f, 0.04191742f, -0.00412973f, 
    0.14341699f, -0.14006369f, 0.33385798f, -0.00514604f, -0.02655903f, 0.02600379f, 0.01830198f, 0.04325127f, 
    -0.00451046f, 0.02692213f, -0.01161971f, 0.10595568f, -0.02748515f, 0.01806376f, 0.11917615f, -0.08572432f, 
    0.12539880f, -0.14444152f, -0.08633827f, -0.12127653f, -0.02294354f, -0.01928945f, 0.05220041f, 0.09753334f, 
    0.02481108f, 0.06172913f, 0.14320596f, 0.10515540f, 0.04389705f, -0.09250928f, -0.09421611f, -0.00345934f, 
    0.11178201f, 0.19532552f, 0.12542029f, 0.24213599f, 0.13759044f, 0.01739871f, -0.11134414f, -0.09021219f, 
    -0.18723828f, 0.08375051f, 0.00096260f, 0.07609822f, 0.05450195f, 0.02261392f, -0.05654651f, -0.12870270f, 
    -0.05721961f, -0.01509073f, 0.00855999f, -0.12767591f, 0.02078305f, -0.13032229f, -0.13761584f, -0.06070270f, 
    -0.19786085f, 0.08085527f, -0.21020068f, -0.06036150f, 0.45908040f, -0.05205353f, 0.11364789f, 0.03925854f, 
    -0.06169913f, -0.21687499f, -0.14916234f, -0.05770314f, -0.07499145f, -0.02158139f, 0.03022882f, 0.10034611f, 
    -0.16800591f, -0.26193100f, -0.29098749f, 0.21246061f, 0.01988305f, 0.09821546f, 0.03992186f, 0.18161556f, 
    0.15196407f, 0.11747562f, 0.01596738f, 0.06212714f, 0.31123790f, 0.05816354f, 0.11075271f, -0.16946360f, 
    0.00027383f, -0.02980463f, 0.07497428f, -0.14684145f, 0.08427864f, 0.17398579f, 0.08476387f, 0.29997480f, 
    -0.33580101f, -0.09737682f, 0.16488206f, 0.14682266f, -0.07340998f, 0.01206654f, 0.04630088f, 0.09718252f, 
    0.07647144f, 0.08377318f, 0.13187687f, -0.01502200f, -0.00978319f, 0.08028299f, -0.05032597f, -0.15481146f, 
    -0.00846678f, 0.09819646f, 0.08325234f, 0.12964383f, 0.05017820f, -0.04369561f, -0.13500084f, -0.17291866f, 
    -0.00270569f, 0.09045947f, 0.03282070f, 0.00257281f, -0.00532655f, -0.04026847f, 0.05604248f, 0.07807627f, 
    -0.16339158f, -0.08851588f, -0.01167840f, -0.11291572f, -0.06065387f, 0.10449376f, -0.12352503f, -0.15995936f, 
    0.11378250f, 0.00808177f, -0.06550010f, -0.12251295f, -0.05429127f, -0.08989238f, -0.10957718f, -0.25865769f, 
    0.11913710f, -0.19242710f, -0.03218663f, -0.15758002f, 0.10440029f, -0.26800591f, -0.17658927f, 0.07709005f, 
    0.00911692f, 0.09438319f, 0.08431035f, -0.10021638f, -0.21533220f, -0.21321352f, -0.00539613f, 0.17301111f, 
    -0.07280203f, -0.09427084f, 0.04038732f, 0.05913116f, -0.03172306f, 0.09036666f, -0.01052066f, -0.07728857f, 
    0.21943882f, -0.15546203f, 0.16635522f, -0.17845879f, -0.01537519f, -0.00712501f, 0.04858817f, -0.13560040f, 
    0.04775945f, -0.08985032f, -0.15696803f, 0.11922282f, 0.00820488f, 0.13459191f, 0.14922868f, 0.04121054f, 
    -0.07954873f, 0.07228130f, 0.06854290f, 0.06536623f, -0.22851689f, 0.00910792f, -0.15405189f, -0.08951297f, 
    0.17869152f, -0.07743958f, 0.24608150f, -0.01593098f, -0.10146882f, 0.18258400f, 0.17781602f, -0.08199174f, 
    0.01123823f, 0.18747252f, -0.00258846f, 0.03501078f, 0.15130290f, -0.05904156f, 0.37809688f, -0.07293648f, 
    -0.05934620f, -0.09261797f, 0.07343812f, -0.02866363f, 0.05255039f, 0.07037067f, 0.14857836f, 0.01476274f, 
    -0.21879475f, -0.30286577f, -0.18485571f, -0.07390053f, -0.15389119f, -0.10833685f, -0.05617820f, -0.06596937f, 
    -0.08748835f, -0.12061980f, -0.24170615f, -0.07917897f, -0.18230321f, 0.17810252f, -0.13781522f, -0.05300479f, 
    0.20758578f, -0.15352033f, 0.24228172f, 0.19313100f, -0.07391948f, 0.32776907f, -0.02819649f, 0.08323005f, 
    -0.02790355f, 0.47365177f, -0.12247567f, 0.21981342f, 0.23425260f, 0.10841685f, -0.13889892f, 0.06165735f, 
    -0.04602904f, -0.06809142f, 0.19802770f, 0.10736002f, 0.00544484f, -0.11237834f, 0.21813971f, 0.07619829f, 
    0.08183151f, -0.07537828f, -0.11675167f, 0.00717539f, -0.09718151f, -0.09550592f, -0.15590946f, -0.09744558f, 
    0.05477632f, 0.05213325f, 0.13459682f, 0.05169626f, 0.04335194f, -0.13135085f, 0.07426855f, -0.00301960f, 
    0.03241943f, -0.01447097f, -0.17310655f, -0.04698498f, 0.08355079f, 0.22283545f, -0.01659334f, 0.04449546f, 
    -0.03046219f, 0.10185912f, 0.09728546f, -0.04117239f, -0.06631260f, -0.06493411f, -0.07947630f, -0.02190410f, 
    0.29024377f, -0.08721299f, -0.01151549f, -0.16424294f, -0.02808838f, -0.01441579f, 0.07901856f, 0.00636070f, 
    0.03974290f, 0.34341517f, 0.14941162f, 0.15566179f, -0.00068041f, -0.30624193f, -0.28598416f, -0.04166372f, 
    -0.05481976f, -0.08595327f, 0.09493132f, -0.08034763f, -0.27378124f, -0.14099100f, -0.39666903f, -0.23456906f, 
    0.02211694f, -0.03811184f, -0.06636407f, -0.08661079f, 0.09479770f, 0.05271224f, -0.04094832f, -0.11123352f, 
    -0.12218314f, -0.02749172f, -0.02264320f, -0.19940840f, 0.04104120f, 0.09033280f, 0.33009985f, -0.01896828f, 
    0.12011232f, -0.10457265f, -0.16139030f, 0.18765847f, -0.00580467f, -0.09461941f, -0.14135315f, -0.08395909f, 
    0.04194554f, 0.11245308f, 0.08861385f, 0.05450685f, 0.11423815f, -0.16116950f, 0.04531014f, 0.04517077f, 
    -0.09195636f, 0.03389117f, 0.00587621f, 0.20061599f, 0.15471064f, 0.21052065f, 0.22903299f, -0.11009431f, 
    -0.00045856f, -0.02146438f, 0.08346363f, -0.16373037f, -0.04812640f, -0.04334643f, -0.04201427f, 0.18776867f, 
    0.27948725f, -0.11741825f, -0.06897502f, -0.01297269f, -0.08571672f, 0.04508581f, 0.00678222f, 0.06611095f, 
    -0.01779569f, -0.05437413f, -0.15081592f, -0.18443756f, -0.34346935f, -0.11830152f, -0.31902596f, 0.17147723f, 
    0.23071024f, -0.03687522f, 0.05465350f, 0.20270798f, 0.00414123f, -0.06940158f, 0.02922679f, 0.02496132f, 
    -0.11564486f, 0.18068352f, 0.13268496f, -0.06758026f, 0.15244231f, 0.10565186f, -0.00687013f, 0.11016989f, 
    0.23074266f, 0.11161905f, 0.26727384f, 0.25631046f, -0.09031465f, -0.14806549f, -0.02436423f, 0.21383096f, 
    -0.02410112f, 0.07422809f, 0.11307146f, 0.01950242f, -0.07490056f, -0.06376852f, -0.15761402f, 0.05639037f, 
    -0.03515490f, -0.32589012f, 0.26279032f, 0.06618498f, 0.12390248f, -0.12366752f, -0.12504673f, 0.10174882f, 
    0.11423057f, 0.07424587f, 0.00716618f, -0.24188173f, -0.19828048f, -0.11732763f, -0.15197872f, -0.01974353f, 
    -0.05826921f, 0.07935478f, 0.22986405f, 0.00337781f, 0.01573069f, 0.10494690f, -0.04924215f, 0.04774693f, 
    0.26915166f, 0.01064467f, -0.12097381f, 0.11263670f, -0.05389027f, 0.03055687f, 0.05636593f, 0.16656074f, 
    -0.11871747f, -0.06185708f, -0.06138036f, -0.08979232f, -0.28916377f, 0.27359101f, 0.05626203f, 0.03417223f, 
    -0.09566266f, -0.15157981f, -0.10871571f, 0.10470306f, 0.03161246f, 0.24104144f, 0.24091797f, 0.30186492f, 
    0.27831399f, -0.16399926f, -0.09036535f, 0.15920313f, 0.11717166f, 0.16459863f, -0.07982693f, 0.02174879f, 
    0.20371404f, 0.12800539f, 0.21588324f, 0.00072112f, 0.12456020f, 0.20581144f, 0.06202435f, 0.04176249f, 
    0.06862698f, 0.03212512f, -0.01851490f, 0.14373350f, -0.03489871f, 0.11243606f, 0.18031111f, -0.01360243f, 
    -0.16340321f, -0.23562276f, -0.19438919f, 0.03136175f, -0.02376482f, -0.10059473f, 0.13447809f, 0.07401322f, 
    -0.10308955f, -0.10606238f, -0.10262220f, -0.11280666f, 0.20692763f, 0.06962619f, -0.11817090f, -0.04614655f, 
    -0.02403599f, -0.03089708f, -0.10368336f, 0.12559909f, -0.23118225f, -0.22497642f, -0.19529930f, -0.28119406f, 
    0.11389735f, 0.13719808f, 0.16761051f, 0.24366851f, 0.05879008f, -0.02413163f, -0.00884150f, 0.12915714f, 
    0.05417353f, 0.33581781f, 0.19195369f, 0.16196415f, -0.15276949f, -0.29811728f, 0.06991883f, 0.13883914f, 
    0.07680339f, 0.08639582f, -0.03716974f, 0.01226310f, 0.03770403f, -0.11677231f, -0.03241517f, -0.13963972f, 
    -0.10140342f, 0.20735869f, 0.06910261f, 0.03434234f, 0.05059630f, 0.00210874f, 0.00854541f, 0.07441392f, 
    0.01408203f, 0.07090395f, 0.06674726f, -0.13742872f, -0.09291107f, 0.00820693f, -0.01286377f, 0.02570918f, 
    0.06067024f, 0.08792931f, -0.01439624f, -0.20041922f, -0.01551771f, -0.27920106f, -0.13567548f, -0.14823240f, 
    -0.35678840f, -0.22934662f, -0.06245999f, 0.20799260f, -0.02106630f, 0.01189942f, 0.06338307f, 0.01182193f, 
    -0.02744780f, 0.04087785f, 0.01518858f, -0.09128760f, 0.18734774f, 0.03788465f, 0.01233753f, -0.08987243f, 
    -0.04771559f, 0.06564531f, -0.05859881f, -0.04589934f, 0.07957296f, -0.15164535f, 0.00096939f, -0.05135648f, 
    0.26998857f, -0.21913724f, 0.04613397f, -0.02490117f, -0.05327587f, 0.19638368f, 0.14809884f, 0.01771374f, 
    0.12027926f, 0.17887618f, 0.25800914f, 0.17901042f, 0.09537221f, -0.15495764f, 0.09046098f, -0.00541064f, 
    -0.00185714f, 0.06093691f, 0.15801443f, -0.06724684f, 0.16984779f, 0.18734580f, 0.20747790f, 0.16148001f, 
    0.11689626f, 0.06294475f, 0.08996636f, 0.00462882f, -0.11160059f, -0.06374959f, 0.07145692f, -0.00747796f, 
    -0.04613836f, 0.17362386f, -0.14808616f, -0.01168529f, 0.34626317f, -0.22608800f, 0.06404883f, -0.07033756f, 
    0.01325272f, 0.07584597f, 0.18662120f, 0.12428539f, 0.10338530f, 0.09088694f, 0.18466686f, 0.11213154f, 
    -0.02996101f, 0.01125619f, 0.06057576f, 0.03371045f, -0.01191856f, 0.09748744f, 0.03828360f, -0.05694855f, 
    0.01586026f, 0.11644676f, 0.15754549f, -0.06213682f, -0.11392920f, -0.23869637f, -0.16961586f, 0.02551172f, 
    0.02800515f, -0.11955971f, -0.22468032f, 0.04021681f, -0.04543222f, -0.07264028f, 0.00683972f, -0.11132371f, 
    0.07276613f, 0.00071623f, -0.15742636f, 0.03834517f, 0.08157165f, 0.14949311f, 0.00170389f, -0.03757615f, 
    0.21917202f, 0.13518687f, 0.00547323f, 0.07040466f, 0.29404336f, 0.17785850f, 0.14369248f, -0.06196396f, 
    0.07013627f, -0.18618365f, 0.12250336f, 0.19022660f, 0.02186432f, 0.24297319f, 0.11660470f, 0.00951694f, 
    -0.17464644f, -0.19721991f, -0.03873404f, 0.08522660f, -0.01205728f, 0.00624969f, -0.01056641f, 0.09279046f, 
    0.04393451f, 0.06715188f, 0.03391488f, 0.16697404f, 0.05838514f, 0.04118522f, -0.10903300f, 0.00315639f, 
    -0.02584999f, -0.06078313f, 0.04030966f, 0.04828839f, -0.16274743f, -0.12923972f, -0.22657867f, -0.46893412f, 
    -0.16037303f, 0.33348358f, 0.01523026f, 0.10417228f, 0.05429961f, 0.05700119f, 0.05789072f, -0.01350225f, 
    0.17320478f, 0.31723261f, 0.31031057f, 0.37235904f, 0.04108920f, -0.19498688f, 0.00599125f, 0.22486041f, 
    -0.00225681f, 0.13355647f, 0.10180496f, -0.04472660f, 0.02139963f, 0.08340762f, 0.13386197f, 0.21176097f, 
    0.18588360f, -0.04855813f, 0.20805128f, 0.10706877f, 0.00555666f, 0.10128581f, 0.19293875f, -0.11750729f, 
    -0.04852963f, 0.08167110f, -0.08084293f, 0.24575830f, -0.04850359f, -0.33259803f, -0.07456346f, 0.00525013f, 
    0.01339575f, 0.04705094f, 0.04240125f, 0.22598621f, 0.07949596f, 0.06126627f, 0.02681387f, 0.15863191f, 
    -0.29418176f, 0.02291671f, 0.07130227f, -0.04486797f, -0.01070559f, -0.19162558f, 0.03575170f, 0.19758044f, 
    0.02251436f, -0.07231470f, 0.10663638f, -0.05377319f, -0.23409794f, -0.07391068f, 0.06467659f, 0.11022677f, 
    -0.12333339f, -0.04216678f, 0.01841342f, 0.05097513f, 0.04602458f, 0.13525897f, 0.15202260f, 0.25006363f, 
    0.19105251f, -0.22245306f, 0.68223423f, -0.07684927f, -0.07421623f, -0.14800772f, -0.24142526f, -0.05668787f, 
    -0.11407213f, 0.03066219f, 0.02610316f, 0.06153688f, 0.09416965f, -0.26275989f, 0.02948736f, -0.16219012f, 
    0.15678310f, 0.06647290f, 0.01204281f, 0.01013231f, -0.16603093f, 0.00281605f, 0.12443969f, 0.05015159f, 
    0.18274815f, 0.02180918f, -0.05003825f, 0.16687720f, -0.04161262f, 0.02325022f, -0.01474642f, 0.10690200f, 
    -0.04510853f, -0.00018624f, -0.05171430f, 0.00994246f, 0.07548123f, 0.05450548f, 0.35567105f, -0.13949129f, 
    -0.09837088f, -0.12169541f, -0.10709432f, 0.08259284f, -0.08347914f, -0.06593601f, 0.00825310f, 0.03054448f, 
    -0.09385375f, -0.04636697f, -0.00144274f, -0.01439296f, -0.02907852f, -0.07048792f, -0.04982480f, 0.00424492f, 
    -0.01483659f, 0.05296256f, -0.03585426f, 0.12118821f, 0.46672249f, 0.04824653f, 0.13139817f, 0.14975330f, 
    -0.00681830f, 0.12619092f, 0.05319542f, 0.08703440f, -0.00622546f, 0.19122726f, 0.10420997f, 0.04551198f, 
    -0.31162554f, 0.03387084f, -0.36100787f, 0.20868978f, -0.12178537f, -0.10623153f, 0.01431710f, 0.01229392f, 
    0.01786011f, -0.04386428f, 0.11047339f, 0.16347113f, 0.20437804f, -0.08456475f, -0.05368012f, 0.13093425f, 
    0.05767583f, 0.12683938f, -0.09853040f, -0.08406544f, 0.07999123f, 0.01344182f, -0.03232989f, 0.03000500f, 
    -0.26196757f, -0.21614321f, -0.08848906f, 0.14986780f, 0.13127758f, 0.13968515f, 0.17005442f, 0.01130498f, 
    0.02914799f, -0.05264668f, 0.00410589f, 0.03166625f, -0.03957157f, 0.03301693f, -0.05327643f, -0.10896434f, 
    -0.13591686f, -0.10401621f, -0.17425537f, -0.14170186f, 0.08361270f, -0.04925122f, -0.01330038f, -0.12590742f, 
    0.03985600f, 0.01620386f, 0.04069356f, 0.15438366f, 0.05366322f, 0.06019048f, -0.05747668f, -0.06668187f, 
    0.05530763f, 0.02090920f, 0.18227097f, 0.09905336f, -0.02691510f, -0.05416072f, -0.07642139f, -0.05068388f, 
    -0.12324484f, -0.07969191f, -0.04239776f, -0.07017720f, 0.04656568f, 0.03402098f, 0.13887773f, 0.02499097f, 
    -0.13687751f, -0.04044475f, 0.03832255f, 0.03169079f, 0.08162779f, 0.03154251f, 0.01997270f, -0.03590742f, 
    0.10029366f, 0.13298017f, 0.25776884f, 0.11505517f, -0.06021289f, -0.09714696f, -0.01142154f, 0.03350957f, 
    0.05707311f, 0.03390889f, -0.03465710f, -0.16357601f, 0.01512381f, 0.00423610f, -0.11858436f, 0.04183012f, 
    -0.20181283f, -0.07414275f, -0.08700220f, -0.08105256f, 0.08061943f, 0.07907071f, -0.05033716f, 0.13652252f, 
    -0.12722556f, -0.07082641f, 0.03952244f, 0.00727909f, -0.02951646f, 0.20906256f, 0.07242148f, 0.09941459f, 
    0.03496174f, -0.01129402f, -0.03856769f, -0.03069790f, -0.07404976f, 0.13542207f, 0.07752145f, 0.22274470f, 
    -0.05867874f, 0.06423903f, 0.40815380f, -0.10142019f, -0.10792822f, 0.00585856f, -0.12470568f, -0.02984249f, 
    0.08202069f, -0.14283922f, 0.10599004f, -0.04809664f, 0.28178570f, 0.00746028f, 0.43531778f, -0.31039858f, 
    -0.15049887f, -0.04075209f, -0.03850175f, -0.16570631f, -0.05175465f, 0.01597062f, 0.03331869f, -0.01755950f, 
    -0.05515708f, -0.22440602f, 0.08855541f, 0.22760291f, 0.14672416f, 0.11312451f, -0.05648312f, -0.15847300f, 
    -0.10007824f, 0.06699708f, -0.03436601f, -0.09682699f, 0.28844252f, 0.16074440f, -0.08069772f, 0.16756783f, 
    -0.00421319f, 0.03921751f, 0.09846076f, -0.24282874f, 0.10501967f, 0.12607828f, 0.11107375f, 0.08150099f, 
    -0.03483274f, 0.30096713f, -0.05610108f, -0.26367941f, 0.17507221f, 0.04918142f, 0.04548567f, -0.03619202f, 
    -0.06446719f, -0.13603891f, 0.04662558f, -0.00817863f, -0.21553609f, 0.53772116f, 0.04402347f, 0.19965240f, 
    0.01537248f, -0.06768527f, -0.15354900f, -0.03682005f, 0.00096153f, 0.06294467f, -0.04356791f, 0.03102831f, 
    -0.06917427f, -0.41590992f, 0.04885390f, -0.04345189f, 0.05560423f, -0.00719253f, 0.02402762f, -0.07891667f, 
    0.04571318f, -0.01422589f, -0.04771401f, 0.13127270f, 0.38002783f, -0.04200298f, -0.03891284f, 0.22383650f, 
    -0.06085688f, -0.01305474f, -0.06080682f, -0.03614514f, 0.13361318f, 0.09933890f, -0.13250980f, 0.11133543f, 
    0.45431626f, -0.01898403f, 0.27752799f, -0.08896118f, -0.01666494f, 0.06229914f, -0.06580090f, 0.02425829f, 
    -0.04668698f, 0.03765702f, -0.04541426f, -0.04212209f, -0.08977239f, -0.07405427f, -0.04903658f, -0.13717483f, 
    0.16632316f, -0.10879327f, 0.00786951f, 0.07449681f, -0.08934629f, -0.07398219f, 0.07222632f, -0.03702315f, 
    0.10105970f, 0.10987096f, -0.03882078f, -0.03498381f, -0.09364616f, -0.00101021f, -0.00174883f, -0.07695629f, 
    -0.02879740f, 0.08675447f, 0.05745014f, 0.00147825f, 0.42350873f, -0.23238367f, 0.13163629f, 0.17170376f, 
    0.00323239f, 0.04628619f, -0.16781114f, 0.20281665f, -0.13481972f, 0.06042058f, 0.17954603f, -0.01893651f, 
    -0.16066228f, -0.03099784f, 0.00640463f, -0.16586743f, 0.10571128f, 0.02023471f, 0.13705271f, -0.08093636f, 
    -0.01754923f, 0.08077788f, 0.11701421f, 0.02763551f, 0.35739592f, -0.14353110f, 0.47156113f, -0.01044456f, 
    -0.20573135f, 0.01882221f, -0.06686102f, -0.01003242f, -0.01876868f, -0.08370848f, 0.02124392f, 0.08825203f, 
    0.08620504f, 0.13080499f, 0.04867305f, -0.02176122f, -0.20515838f, -0.17301930f, -0.22881570f, -0.03696244f, 
    -0.09629754f, 0.01291877f, -0.07306615f, -0.04146560f, -0.27042240f, 0.28068241f, -0.28763810f, 0.13984857f, 
    0.00253628f, -0.04034720f, 0.15129191f, -0.01664273f, 0.15004897f, -0.15719621f, 0.10553914f, 0.08895271f, 
    -0.16082491f, 0.34212056f, -0.10062209f, -0.20063092f, 0.03652824f, -0.03213189f, -0.07156833f, 0.02287139f, 
    -0.13391928f, -0.22700943f, -0.08932441f, -0.22363922f, -0.12396874f, 0.17460643f, -0.06103877f, 0.11841588f, 
    0.01481055f, 0.01071014f, 0.05064771f, -0.12527148f, 0.05579933f, -0.03282264f, -0.00156365f, 0.13246553f, 
    -0.16151842f, -0.08105845f, -0.38228905f, 0.04872200f, 0.03242999f, 0.12432761f, -0.03598879f, 0.36110902f, 
    -0.05834246f, 0.24403407f, 0.09395394f, 0.09872856f, -0.22731039f, -0.19365966f, -0.20909716f, 0.02855077f, 
    -0.14290585f, -0.00671931f, -0.04276614f, -0.08721649f, -0.07956129f, -0.10142120f, -0.07316177f, 0.03441695f, 
    0.23574869f, -0.06190291f, 0.03734464f, 0.10992034f, -0.02478019f, -0.01136242f, 0.05666957f, -0.00046661f, 
    0.10750508f, -0.02729780f, -0.02139648f, -0.08952592f, -0.25317129f, 0.01473908f, -0.09892679f, 0.07198330f, 
    -0.00460544f, 0.04855265f, 0.04837464f, 0.21001007f, -0.18849552f, 0.05427281f, -0.08727893f, -0.07983318f, 
    0.04957379f, 0.14554720f, -0.21920073f, -0.11315367f, 0.13731492f, 0.06259873f, 0.08013728f, 0.06163231f, 
    0.10245086f, -0.00950436f, 0.09982812f, 0.08956895f, 0.42482591f, 0.05000095f, 0.08591763f, 0.08976807f, 
    -0.06223370f, 0.12089884f, 0.17237626f, 0.06248263f, 0.07964895f, 0.04924171f, 0.09671194f, 0.16433115f, 
    -0.09752148f, -0.09278052f, -0.09421763f, 0.13339645f, -0.00226816f, 0.00458132f, -0.00860130f, -0.30740747f, 
    0.02671363f, -0.05325015f, -0.04097739f, -0.04215845f, 0.04267386f, 0.05856577f, 0.00894707f, -0.02533264f, 
    -0.07932571f, -0.10391475f, -0.12978382f, -0.08603126f, -0.05418300f, 0.01696484f, -0.09373559f, 0.01217476f, 
    0.45548284f, 0.09056018f, 0.09352862f, 0.19675700f, 0.00449989f, -0.05676837f, -0.15782121f, -0.01050673f, 
    -0.08937030f, -0.04283273f, -0.05833655f, 0.02925958f, -0.09344772f, -0.27344203f, 0.17682920f, 0.05956541f, 
    -0.09069163f, -0.12206686f, 0.05860808f, -0.10911655f, 0.16214041f, -0.02855490f, 0.02501202f, 0.09213495f, 
    0.38109449f, 0.21065141f, -0.08197425f, 0.11719181f, 0.00048875f, -0.05164661f, -0.08111141f, -0.09296918f, 
    0.00509368f, -0.00433041f, 0.13166675f, -0.08470348f, -0.14155127f, 0.03018418f, -0.01623237f, 0.05503723f, 
    -0.01996034f, 0.05340086f, 0.18578459f, -0.01376909f, 0.04124201f, 0.05695812f, 0.19830813f, 0.15535705f, 
    -0.18072505f, -0.02380339f, -0.20236182f, 0.07867330f, 0.07006046f, 0.11842882f, -0.02709300f, -0.09626769f, 
    -0.06050124f, -0.04892941f, -0.00860199f, 0.04777489f, 0.00906556f, 0.11196002f, 0.02263801f, 0.01414955f, 
    -0.09720599f, -0.20499896f, -0.28468242f, -0.08559781f, -0.01887561f, 0.01553433f, 0.07314176f, -0.07660627f, 
    0.32346401f, -0.04843078f, 0.19676055f, 0.08305820f, 0.05914262f, 0.09419446f, 0.04242510f, 0.09460893f, 
    -0.08349052f, 0.08181691f, -0.00360413f, -0.08138214f, 0.06853256f, 0.24357355f, 0.22650526f, 0.01746401f, 
    -0.10211197f, 0.04048565f, -0.13025314f, 0.04379559f, -0.15709129f, 0.17931026f, -0.08449516f, -0.16664080f, 
    0.09156008f, -0.15347238f, -0.23768102f, -0.16072653f, -0.04523320f, -0.02447744f, 0.04702213f, 0.00666785f, 
    0.10634646f, 0.20005676f, 0.14923917f, -0.00461510f, 0.02254052f, -0.21017714f, 0.18879047f, -0.07440724f, 
    -0.01811799f, 0.01388629f, -0.07811686f, 0.04807861f, 0.07845327f, -0.02381311f, 0.05668993f, -0.05384218f, 
    -0.04000650f, 0.04972655f, 0.09675935f, 0.14055452f, -0.03529444f, 0.12112741f, -0.04874418f, -0.10599484f, 
    -0.10951976f, 0.05546353f, -0.05321840f, 0.22215499f, 0.00183812f, -0.00397776f, -0.09394228f, 0.14616017f, 
    0.00499967f, -0.06661345f, 0.07827321f, 0.03543099f, -0.08298696f, 0.06629837f, 0.03900445f, -0.04470856f, 
    0.25907367f, 0.26465547f, -0.02607392f, -0.06409045f, -0.05928441f, -0.18877701f, -0.13396321f, -0.00817201f, 
    0.01319598f, 0.03096938f, -0.11087511f, -0.06238182f, 0.62088341f, -0.11666469f, 0.27102888f, 0.21732919f, 
    -0.03367829f, 0.15444310f, 0.02645171f, -0.10089296f, 0.17494398f, 0.15845051f, 0.05748448f, 0.06229145f, 
    0.03461193f, -0.07268529f, 0.19629356f, 0.19269140f, 0.14468502f, 0.04848498f, 0.01775228f, -0.12024231f, 
    -0.10675357f, 0.06487644f, 0.01672171f, 0.05895294f, -0.01185753f, 0.02475866f, 0.00346202f, -0.11046720f, 
    0.01748228f, 0.01862493f, 0.02950293f, -0.17194746f, 0.03541984f, 0.08569457f, 0.11178862f, 0.14591824f, 
    0.09082951f, 0.32902345f, 0.03711745f, 0.12921292f, -0.06268582f, -0.06856516f, -0.11133447f, -0.13906164f, 
    -0.05621704f, 0.08215228f, 0.00202540f, -0.25740948f, 0.11722530f, -0.14791240f, 0.11754946f, -0.01760830f, 
    0.02636195f, 0.01289268f, -0.05494354f, -0.01657403f, -0.09103856f, -0.03556232f, 0.00346740f, -0.05101405f, 
    0.25481701f, -0.12883542f, 0.53161639f, 0.20820282f, 0.11032055f, -0.04206019f, 0.20139563f, -0.03707700f, 
    0.00653413f, 0.09786091f, -0.17965592f, 0.02870315f, 0.24476045f, 0.14943665f, 0.20865981f, 0.21987841f, 
    0.17448299f, 0.04256054f, 0.02063000f, -0.08926564f, -0.13856418f, 0.07226262f, -0.06959217f, -0.02721420f, 
    -0.25870407f, 0.02408133f, -0.12612928f, 0.21477309f, 0.08599805f, 0.19733153f, 0.01530723f, 0.09363230f, 
    0.06030976f, 0.10069891f, 0.01934483f, 0.08625906f, -0.09296913f, -0.04210300f, 0.00967140f, 0.10193747f, 
    0.01184343f, 0.07232533f, 0.04201398f, -0.09079942f, 0.05065054f, -0.00901890f, -0.13238797f, 0.01451111f, 
    -0.03808721f, 0.11919986f, 0.02473992f, 0.16795498f, 0.09101244f, 0.12529637f, 0.06102899f, -0.02271487f, 
    0.01235178f, -0.08473530f, -0.09817708f, -0.07265367f, 0.24491802f, -0.07690787f, 0.39698717f, -0.05774849f, 
    -0.00100643f, 0.02381162f, -0.05348099f, 0.15928487f, 0.22464113f, 0.11430223f, 0.06010137f, 0.07890180f, 
    -0.00627205f, 0.35422227f, 0.27960670f, 0.02868567f, 0.00522247f, -0.13076790f, 0.14040160f, -0.04701830f, 
    0.10795719f, -0.01733892f, 0.20892765f, -0.01263341f, 0.01008863f, -0.07732214f, -0.03116893f, 0.00302437f, 
    0.12245195f, -0.13559829f, 0.04645143f, -0.02325431f, 0.03478687f, 0.02034099f, 0.00569743f, 0.07452855f, 
    0.02498144f, -0.08006127f, 0.07876520f, -0.10656938f, -0.18624194f, -0.05292732f, -0.00286443f, -0.18978886f, 
    0.10458040f, -0.16251692f, 0.19505076f, -0.02859113f, 0.22338249f, 0.10246474f, -0.00869609f, 0.33454910f, 
    -0.07864849f, -0.05343588f, 0.08285755f, -0.03393076f, 0.11517307f, 0.05170848f, 0.14243700f, 0.02760262f, 
    -0.04017998f, -0.15010834f, 0.14684585f, 0.14861569f, -0.02734909f, 0.29236734f, -0.17663352f, -0.13013010f, 
    0.08044405f, 0.00933010f, -0.00808263f, -0.04997668f, 0.24963419f, 0.07991007f, -0.00260040f, 0.25497562f, 
    0.00920675f, -0.11308265f, 0.14488237f, 0.17154326f, 0.07901812f, -0.12924951f, -0.12576266f, 0.04912605f, 
    -0.20073113f, 0.00041425f, 0.20104203f, 0.06706236f, 0.24332252f, 0.08679081f, -0.00015914f, -0.05314455f, 
    -0.01067528f, -0.06290891f, -0.00386216f, -0.05446859f, -0.09640937f, -0.04819064f, -0.05471433f, -0.26061288f, 
    -0.06509417f, -0.12570487f, -0.21426924f, 0.08616921f, -0.24847777f, -0.10712172f, -0.09829923f, 0.02393188f, 
    -0.05092107f, 0.10429931f, 0.03201370f, 0.08224452f, -0.11910120f, 0.05334665f, -0.04440685f, -0.25610316f, 
    0.24724832f, 0.15862764f, -0.11821853f, 0.01900586f, 0.07425593f, -0.04673773f, -0.11414076f, -0.31038520f, 
    -0.05521305f, -0.08944107f, -0.03274313f, -0.09140994f, 0.05841503f, -0.08105083f, -0.12296479f, 0.11776733f, 
    0.06041325f, -0.12153514f, 0.06882062f, -0.14768834f, -0.05936126f, -0.05350502f, -0.08928487f, -0.06215055f, 
    0.05019135f, 0.05051708f, 0.16503914f, 0.13263035f, -0.12191533f, -0.21109363f, 0.08860478f, 0.13031372f, 
    -0.03324154f, 0.04220309f, 0.07163457f, 0.09671649f, 0.08000369f, -0.03274654f, -0.04893413f, -0.07308099f, 
    0.00748742f, 0.01941535f, -0.35080758f, 0.34389338f, 0.04967277f, 0.02814397f, -0.07066685f, 0.18746886f, 
    -0.02849242f, -0.10541436f, 0.08253733f, -0.00872028f, -0.07821771f, -0.01702706f, 0.34184572f, -0.08381718f, 
    0.06745546f, 0.03226174f, 0.03640053f, -0.13858987f, 0.10260571f, -0.11880485f, 0.18947673f, -0.03287723f, 
    -0.00333909f, 0.12416966f, 0.08350448f, 0.07156923f, -0.05615105f, -0.00607837f, -0.15047678f, 0.00410734f, 
    -0.00556759f, -0.01320384f, 0.02277008f, -0.03296136f, -0.03469903f, 0.40347525f, -0.04596217f, 0.05317474f, 
    -0.15215708f, 0.09264479f, -0.02896247f, -0.10369674f, 0.07268444f, -0.04643482f, -0.05267213f, 0.01147340f, 
    -0.21082382f, -0.19585657f, 0.02052983f, 0.05784386f, 0.01704031f, 0.03644950f, -0.05912115f, 0.12953293f, 
    0.07963409f, 0.05553036f, 0.00283214f, 0.00923496f, 0.10637626f, 0.25671080f, 0.17124929f, 0.16725227f, 
    0.02028623f, 0.18803023f, -0.03230032f, -0.00621860f, -0.03530437f, -0.05907541f, 0.13278532f, 0.04790676f, 
    -0.10191917f, 0.01476541f, 0.10976839f, -0.39739597f, -0.08554182f, 0.00842640f, -0.11458933f, 0.03057580f, 
    -0.01758396f, 0.07540679f, 0.02244871f, -0.05449753f, -0.09412483f, 0.26240775f, 0.22025807f, -0.45256394f, 
    -0.10031998f, 0.03519804f, 0.07528787f, 0.02444746f, -0.06525218f, 0.01733762f, 0.24104378f, 0.08572454f, 
    -0.26004595f, -0.11507794f, 0.16219765f, 0.19321327f, 0.07096236f, 0.15524878f, 0.21893206f, 0.03571298f, 
    0.04747561f, -0.14535347f, 0.00039587f, -0.03679929f, -0.13993858f, 0.34249669f, 0.14730780f, 0.12907766f, 
    -0.04556588f, -0.07021216f, 0.06679562f, -0.01288564f, 0.13677880f, 0.00959702f, 0.00902514f, 0.19150713f, 
    0.38069579f, 0.10664733f, -0.20387122f, 0.31733242f, -0.17877454f, -0.01202744f, -0.09166837f, 0.03154904f, 
    -0.04907455f, 0.01154025f, -0.00914176f, 0.13182206f, -0.11347816f, -0.12167989f, -0.08760494f, -0.04140201f, 
    -0.02989825f, 0.02560497f, 0.13156101f, 0.01217573f, 0.04487814f, 0.02561723f, -0.12199511f, -0.02818508f, 
    -0.04467048f, -0.04444342f, -0.01572901f, -0.05985949f, -0.12539394f, -0.04937722f, -0.17514329f, -0.03740729f, 
    0.01439110f, -0.03072051f, 0.08113170f, 0.16338655f, -0.31465784f, 0.00759311f, -0.07959084f, -0.11670554f, 
    0.05990715f, 0.02328388f, 0.14580108f, 0.01291321f, 0.13572644f, -0.08838849f, 0.12861899f, 0.05222502f, 
    -0.14886411f, 0.05977152f, 0.15203768f, -0.09471216f, -0.11290945f, 0.00062222f, -0.08254311f, 0.16731872f, 
    0.26368859f, 0.01701052f, -0.01251752f, -0.09379213f, -0.00998821f, 0.34474406f, -0.16344763f, 0.10520274f, 
    0.16767225f, 0.07554328f, 0.12513071f, 0.00785738f, -0.07701371f, 0.06246222f, -0.10184797f, -0.12899499f, 
    -0.43132010f, -0.16194049f, -0.04763302f, -0.26732039f, -0.13280845f, -0.18084162f, -0.03181833f, -0.03084689f, 
    0.11952177f, -0.07982146f, 0.04085702f, 0.10986947f, -0.00355985f, 0.01578127f, 0.22687338f, 0.18478988f, 
    -0.03345668f, 0.03472743f, 0.02777106f, 0.08426382f, -0.04358445f, 0.13206854f, 0.05988635f, 0.04123088f, 
    -0.06598584f, -0.27200499f, -0.03051206f, -0.22819866f, -0.08695236f, 0.01794276f, -0.15158118f, -0.04344530f, 
    -0.07277046f, 0.03368971f, -0.02121419f, 0.00391770f, -0.12628850f, -0.24683399f, 0.25488457f, 0.04180478f, 
    0.15317963f, 0.24196973f, 0.04342155f, 0.02464241f, 0.07184009f, -0.05859531f, 0.04647882f, -0.11438869f, 
    0.22950242f, -0.16197087f, -0.15244290f, 0.10237370f, -0.17205913f, 0.08888365f, 0.04480612f, 0.10295922f, 
    0.03539779f, 0.09629870f, 0.02446331f, -0.03174444f, -0.14379337f, -0.09533072f, -0.11158568f, 0.13562550f, 
    0.10243659f, 0.03561413f, -0.00412596f, 0.10162484f, -0.05129857f, -0.07390814f, 0.02520738f, 0.04917891f, 
    0.02644600f, 0.29293898f, 0.01603815f, 0.09423389f, -0.00686085f, -0.13150363f, 0.14847763f, -0.00986501f, 
    0.04988605f, 0.06784967f, 0.01136465f, 0.29024443f, 0.00069339f, 0.20943633f, 0.14516504f, -0.01271775f, 
    -0.01306858f, -0.03347703f, -0.03311235f, -0.13634473f, 0.15989430f, 0.01287860f, 0.14725311f, -0.18879347f, 
    0.11321060f, -0.12931781f, 0.07351796f, -0.24715124f, 0.00529409f, -0.02594302f, 0.01766562f, -0.06920791f, 
    -0.07642157f, -0.04962731f, 0.09513977f, 0.01812828f, 0.13899723f, 0.34144244f, -0.29207951f, 0.18658738f, 
    0.00720169f, 0.08397514f, -0.05436571f, -0.02332670f, 0.03573232f, 0.09270571f, 0.01010052f, -0.05192959f, 
    -0.14518213f, -0.12247315f, -0.13482457f, 0.26941389f, 0.00537538f, 0.15378295f, 0.00748585f, 0.08761206f, 
    0.08945099f, 0.01603193f, 0.02716263f, 0.10053117f, -0.29970780f, -0.05499425f, 0.11595815f, -0.31442219f, 
    -0.03755398f, -0.14581127f, -0.02543523f, -0.21023561f, 0.07365578f, -0.07745042f, 0.06245776f, -0.02334242f, 
    0.07451226f, -0.03767368f, 0.20404091f, -0.21086353f, -0.10540614f, -0.06541781f, 0.18666132f, 0.12521571f, 
    0.08963170f, -0.05332908f, 0.10387028f, 0.01950918f, -0.19664879f, -0.05443297f, 0.33369517f, 0.01384181f, 
    0.03732135f, -0.04429085f, -0.01000708f, 0.05629011f, -0.20930825f, -0.02958178f, 0.08306956f, 0.11583795f, 
    -0.38611388f, -0.02861336f, 0.03561201f, -0.12003131f, -0.04575142f, -0.12528840f, 0.07718670f, 0.10169031f, 
    0.06692374f, 0.09613046f, -0.00178841f, -0.02613237f, -0.01990929f, 0.00610074f, 0.08782337f, 0.16545661f, 
    0.06054476f, -0.07840751f, 0.03818553f, 0.12705064f, -0.00400984f, 0.14561740f, -0.07431137f, 0.06331596f, 
    -0.19341256f, -0.06358465f, 0.15338747f, 0.21911609f, 0.05910516f, 0.07478288f, 0.01169142f, 0.16346131f, 
    0.10841710f, 0.03558528f, -0.00152818f, 0.01128776f, -0.59960240f, -0.23623659f, 0.00059597f, 0.15360680f, 
    -0.04176547f, -0.04555693f, 0.11205164f, -0.01863198f, 0.01872909f, -0.16656755f, -0.17552334f, 0.04077167f, 
    0.26157889f, -0.15296794f, -0.05464235f, 0.17303637f, -0.00621583f, -0.05827487f, 0.10810453f, 0.06464707f, 
    -0.13554049f, 0.07689732f, -0.12593576f, 0.01940669f, 0.04501529f, 0.28071159f, -0.02177560f, -0.09180450f, 
    -0.02095840f, 0.12436588f, -0.13295583f, -0.17570834f, 0.12982960f, -0.11521976f, -0.06702836f, -0.06402953f, 
    -0.15509616f, -0.00951538f, -0.22436714f, -0.03042946f, -0.00405581f, -0.14596492f, -0.09905661f, -0.04682255f, 
    -0.06322287f, -0.10730444f, 0.15858620f, 0.02679158f, 0.08651652f, 0.12390032f, -0.26491138f, -0.01621532f, 
    0.01411693f, 0.10484052f, 0.19369118f, -0.01313260f, 0.10899744f, 0.09635111f, 0.06389206f, -0.03110008f, 
    0.08318176f, 0.14704862f, -0.10626148f, -0.09483265f, 0.01768269f, -0.03490758f, 0.04254323f, -0.12048400f, 
    0.18486278f, -0.14092514f, 0.10309342f, 0.08848806f, 0.08239740f, -0.06875577f, -0.08970287f, 0.02698138f, 
    0.00607809f, 0.06231364f, -0.08904950f, 0.18901068f, 0.06225606f, 0.13936964f, -0.08290888f, 0.14447142f, 
    0.01815988f, -0.06813081f, 0.01047444f, -0.22962612f, 0.06057396f, -0.24793787f, 0.05527131f, 0.03885227f, 
    0.02408060f, -0.08226743f, -0.01769213f, 0.05536355f, -0.23181038f, 0.22206664f, 0.00725167f, 0.05168505f, 
    0.18243609f, 0.20166066f, -0.02304572f, 0.09000424f, -0.01768238f, -0.14738302f, 0.18275155f, 0.07574265f, 
    -0.26795188f, -0.09359120f, 0.11080053f, 0.01159619f, 0.05901617f, -0.09071604f, 0.05889408f, 0.05413888f, 
    0.06001059f, 0.01405643f, 0.00560885f, 0.06386078f, -0.19349891f, -0.08916584f, -0.05249546f, 0.22190994f, 
    0.00534559f, 0.07101409f, -0.11053450f, 0.02118082f, 0.11911859f, -0.05583889f, 0.10224140f, 0.13805118f, 
    0.02456858f, -0.05356122f, -0.15154216f, 0.10844044f, -0.03994787f, -0.13342799f, 0.02885125f, 0.03410086f, 
    0.09743321f, 0.04920558f, -0.12140156f, -0.09288988f, -0.25788355f, -0.20265453f, 0.11722670f, -0.03546446f, 
    -0.07346085f, -0.23624966f, 0.07828279f, 0.02737639f, 0.01276016f, -0.06179785f, -0.06856450f, -0.04964080f, 
    -0.06337804f, 0.17436203f, 0.21339698f, 0.04366273f, 0.01121372f, -0.09771165f, 0.06688127f, 0.20994285f, 
    -0.05356515f, -0.02277958f, 0.22332118f, 0.08225638f, -0.40585834f, -0.32819784f, -0.03090105f, 0.17283253f, 
    0.05908011f, -0.21521589f, 0.00193145f, 0.05563629f, -0.06683335f, -0.06824059f, -0.11141657f, 0.03788592f, 
    -0.02534198f, 0.02154374f, 0.05362066f, 0.23016246f, -0.05402447f, 0.16883218f, 0.06267716f, 0.15383112f, 
    0.00102730f, 0.18252644f, 0.03358174f, 0.19808353f, -0.14758077f, 0.02981211f, 0.03325457f, 0.04483516f, 
    -0.03551298f, 0.01778529f, 0.08702578f, 0.04882799f, 0.04233180f, -0.03283996f, 0.01462050f, -0.02923511f, 
    -0.03535355f, -0.01237040f, 0.02014719f, 0.00789154f, -0.02873690f, -0.01084809f, -0.00615644f, -0.02006908f, 
    -0.00922192f, -0.00981075f, -0.03444751f, -0.00812390f, 0.01927433f, -0.02524593f, -0.02473476f, -0.02016551f, 
    -0.02785879f, -0.02274047f, 0.00461557f, 0.02468363f, -0.02868742f, -0.00070743f, -0.03103713f, 0.02340892f, 
    -0.02793566f, -0.01655981f, -0.01429394f, -0.02334385f, -0.03143512f, 0.00684176f, 0.00593685f, -0.02237162f, 
    -0.03083774f, -0.03577184f, 0.01941098f, -0.01107916f, 0.03084692f, -0.03518108f, -0.03254480f, -0.02019596f, 
    -0.02692317f, 0.01047627f, 0.00730242f, -0.01023496f, 0.00376274f, 0.03255467f, -0.02003485f, -0.02632521f, 
    0.01387401f, -0.02786191f, 0.02228276f, -0.02433422f, -0.01659832f, -0.03127593f, -0.03578430f, -0.01543649f, 
    -0.01876782f, -0.01257484f, -0.02352981f, 0.01020605f, 0.01538891f, -0.00745191f, -0.02915767f, -0.02871541f, 
    0.02628087f, -0.01485924f, -0.01963422f, -0.01241747f, 0.00692194f, -0.00847175f, -0.01709353f, 0.00999991f, 
    -0.03284202f, 0.02781005f, -0.01886671f, -0.02750859f, 0.03000929f, -0.02305310f, -0.02594051f, 0.01491227f, 
    0.02737226f, 0.02866563f, -0.03482461f, -0.03228886f, 0.00976419f, -0.03371615f, -0.03285592f, 0.01962071f, 
    -0.01869133f, 0.02078718f, -0.02625060f, 0.00267821f, -0.02735090f, -0.02180714f, -0.01196849f, -0.03445954f, 
    -0.00325851f, -0.02892976f, -0.02651734f, -0.02273631f, 0.00388982f, 0.01959228f, -0.02067575f, -0.03525730f, 
    0.00547750f, 0.00597871f, 0.01169048f, 0.02674957f, -0.02062709f, -0.01972807f, 0.00547393f, 0.01135800f, 
    0.00566068f, -0.03018631f, 0.03504002f, 0.03581422f, 0.02657342f, -0.03375718f, -0.00781680f, -0.02541739f, 
    0.01739558f, 0.01349740f, -0.01446226f, 0.00385321f, 0.00292736f, -0.00585834f, -0.02602745f, 0.01581285f, 
    -0.02454685f, -0.00787420f, -0.01296545f, -0.00284455f, 0.00477133f, 0.00973517f, -0.00316600f, 0.02401190f, 
    -0.01036224f, -0.02545960f, 0.01060349f, -0.00605232f, -0.02759605f, 0.03265528f, -0.02908698f, 0.02604106f, 
    0.02643210f, 0.01969574f, -0.00318524f, 0.00041143f, -0.01384900f, 0.03131849f, 0.00331272f, 0.01736297f, 
    0.00517321f, -0.02977332f, -0.00285169f, -0.00047957f, 0.00456877f, 0.00219587f, -0.01879802f, -0.02820609f, 
    -0.02580328f, -0.03026846f, -0.00100029f, -0.00486627f, 0.03160803f, -0.02455976f, 0.02665738f, 0.01241996f, 
    0.03021582f, 0.02493597f, 0.02661106f, 0.02976849f, -0.00212013f, -0.03208124f, 0.03486457f, 0.00384426f, 
    -0.01857454f, 0.01673016f, 0.01486391f, -0.03101891f, -0.02619394f, 0.01297778f, 0.00077467f, -0.00596297f, 
    0.00090202f, -0.00125528f, 0.02061827f, -0.00921293f, -0.00275346f, -0.01442134f, -0.03379989f, 0.01718823f, 
    0.01210453f, 0.00028358f, 0.01824811f, 0.01999823f, 0.01571794f, -0.01815563f, -0.02739587f, 0.01712399f, 
    -0.01324858f, -0.03069797f, -0.00450709f, 0.02523685f, -0.02919666f, -0.01534240f, 0.01430605f, -0.00088690f, 
    -0.03176310f, 0.01139276f, 0.02444247f, 0.01549505f, -0.02162409f, 0.01573154f, 0.03557405f, 0.01472600f, 
    0.02622448f, 0.02555246f, -0.03227256f, -0.01923828f, 0.00860773f, -0.00712237f, 0.02403201f, 0.01879057f, 
    0.01037243f, 0.00172607f, 0.03359591f, 0.00673129f, 0.00555467f, -0.02460196f, 0.02157291f, 0.02144660f, 
    0.03175606f, 0.03296632f, -0.03355246f, 0.01677706f, 0.01685730f, -0.02453334f, -0.01525212f, 0.01667580f, 
    0.01051357f, 0.01557748f, -0.02511078f, -0.02318699f, -0.03179210f, -0.00568157f, -0.01630215f, 0.00297743f, 
    -0.03274872f, 0.02047158f, -0.00069233f, 0.01039718f, 0.03352650f, 0.03130112f, 0.02495737f, 0.01042183f, 
    0.03099024f, 0.03299301f, -0.03300109f, -0.01875946f, -0.00841624f, 0.01106743f, 0.03456724f, 0.00532096f, 
    -0.03421500f, -0.01936603f, -0.01065616f, 0.03107557f, -0.03246766f, -0.02644922f, 0.03114703f, 0.03426604f, 
    0.00815279f, 0.03508110f, 0.03444206f, -0.00565643f, 0.00846165f, 0.00873009f, 0.01305017f, -0.00188750f, 
    0.03277325f, -0.03331376f, 0.00095248f, 0.00372265f, -0.02946545f, -0.03186278f, 0.01282850f, 0.03126971f, 
    -0.01259748f, 0.00687525f, -0.01101222f, -0.01119453f, -0.03547842f, -0.00262238f, -0.02460893f, -0.01931732f, 
    0.02024916f, 0.02946257f, 0.03423783f, -0.03233885f, 0.00910482f, -0.01184238f, -0.01568363f, 0.01619912f, 
    0.02725258f, -0.02415031f, -0.03347078f, 0.02538723f, -0.01666036f, -0.00844382f, -0.01539920f, 0.01856481f, 
    -0.00977399f, -0.01417640f, -0.00671128f, -0.03386492f, 0.01076530f, -0.00738460f, 0.00260657f, -0.01066845f, 
    -0.01273736f, 0.03551662f, 0.02886924f, -0.01625070f, -0.01336795f, 0.02994082f, 0.01654010f, 0.01449615f, 
    0.01312508f, -0.02523931f, 0.02278107f, 0.00036604f, -0.01038403f, 0.01926890f, -0.02142321f, 0.00812787f, 
    -0.01588517f, 0.01773732f, -0.01944695f, -0.01749470f, -0.03011950f, 0.02123221f, 0.01916499f, -0.00287661f, 
    -0.02645975f, 0.00192973f, -0.00319953f, -0.01851573f, -0.02004492f, -0.00800611f, -0.01101826f, 0.00068115f, 
    0.03291078f, -0.01020954f, -0.00260200f, -0.00616775f, 0.01239863f, 0.00899892f, -0.01307409f, 0.00364876f, 
    -0.02145549f, -0.01625465f, -0.01158592f, 0.03338790f, -0.02719329f, 0.01649358f, -0.02540820f, 0.02827883f, 
    0.00170015f, -0.02810694f, 0.00926810f, 0.02221700f, 0.02624874f, -0.00343983f, 0.03170698f, -0.01382867f, 
    0.02539927f, -0.01255879f, -0.00206040f, -0.03009730f, -0.00510913f, -0.00342623f, 0.02864271f, -0.00882506f, 
    0.02789215f, 0.00846253f, 0.01457243f, -0.03502380f, 0.03410738f, -0.01496688f, -0.01626864f, -0.02020569f, 
    0.00737597f, 0.03145036f, 0.01797875f, -0.02879656f, -0.03177758f, 0.00035775f, -0.01270311f, -0.01155657f, 
    0.00466759f, 0.00951369f, -0.02819510f, -0.01232818f, -0.00895092f, -0.03148151f, 0.02364242f, 0.03363029f, 
    0.00689095f, 0.01579546f, -0.00254170f, -0.03264091f, -0.02941879f, -0.02639452f, 0.01233761f, 0.03166258f, 
    0.01478149f, -0.01834727f, -0.00747703f, -0.01604969f, -0.03069964f, -0.01152776f, -0.00350972f, 0.00182594f, 
    -0.02507114f, -0.01426360f, 0.01017732f, -0.01566596f, -0.01799709f, -0.03595546f, 0.00586910f, 0.02535769f, 
    -0.02760483f, 0.01712605f, 0.02583820f, 0.01137481f, -0.00485812f, 0.01528456f, -0.01492342f, 0.02106590f, 
    0.01831665f, 0.02874592f, 0.02303636f, -0.00145761f, -0.03028282f, -0.02274162f, -0.02551699f, -0.00556455f, 
    -0.02772672f, 0.03104682f, 0.02214345f, -0.00552590f, -0.01869985f, 0.01581180f, -0.02049584f, -0.03052849f, 
    0.00493119f, 0.03261082f, -0.03072677f, 0.00084925f, 0.01168685f, 0.00796683f, -0.02833343f, -0.01102602f, 
    -0.01859377f, 0.02982034f, -0.01707635f, -0.03298350f, -0.03143416f, 0.01947116f, 0.00969177f, -0.01425685f, 
    -0.03301680f, 0.02353752f, -0.01871870f, 0.03053264f, 0.02410556f, -0.01121494f, -0.02024566f, -0.03535744f, 
    -0.02901863f, -0.02805411f, -0.02276061f, -0.01270404f, 0.02567223f, -0.01545633f, -0.00235327f, 0.01891591f, 
    -0.01937265f, -0.01375622f, 0.00423530f, 0.00516156f, 0.02863020f, 0.00187535f, -0.01122314f, 0.02432429f, 
    -0.02690270f, 0.02603102f, -0.00717314f, -0.01211610f, 0.00694894f, -0.00335481f, -0.03331370f, -0.00195187f, 
    0.02365661f, 0.02693855f, 0.00829628f, -0.03532973f, -0.01084195f, -0.00170984f, 0.01376819f, 0.03425041f, 
    -0.01333398f, -0.01928907f, 0.02074257f, -0.02463794f, -0.03499156f, -0.00660694f, 0.02809289f, 0.03079620f, 
    -0.03135841f, 0.01522913f, -0.01914901f, 0.01022772f, 0.01095540f, -0.03111140f, 0.00764173f, 0.02353644f, 
    0.01278403f, -0.01488828f, -0.03602348f, -0.02362113f, 0.01093711f, -0.02405130f, -0.01119538f, -0.02207443f, 
    -0.01824514f, -0.02028121f, -0.01880564f, 0.00980930f, -0.02792520f, -0.00490475f, 0.01324472f, -0.02024120f, 
    -0.02956077f, 0.01797075f, -0.02313951f, -0.00934588f, 0.01255891f, -0.01529672f, -0.01013586f, 0.00251249f, 
    0.01085858f, 0.01531573f, -0.00149609f, -0.02608914f, 0.03432142f, -0.02593493f, 0.01707365f, 0.02401850f, 
    0.01416393f, 0.00114908f, -0.00979603f, -0.03393127f, -0.00756271f, 0.02061990f, -0.02567943f, -0.01624970f, 
    -0.02436646f, 0.00311349f, -0.03077370f, -0.03541763f, -0.02499298f, -0.01436144f, -0.01288959f, -0.03084360f, 
    -0.02194835f, 0.00073362f, -0.00158137f, 0.01234549f, 0.01602846f, -0.02671793f, -0.02245181f, 0.03521133f, 
    -0.03474451f, -0.01669003f, 0.00319397f, -0.01631230f, -0.02287801f, -0.01801883f, -0.00466475f, 0.03224172f, 
    -0.01596834f, -0.00821976f, -0.01335865f, 0.00355955f, -0.01508217f, -0.01689762f, -0.00889220f, 0.01565412f, 
    -0.00067076f, -0.03522074f, 0.02891532f, 0.01866464f, -0.02470423f, 0.03511197f, -0.00273135f, 0.02265214f, 
    0.01696699f, 0.02704938f, 0.01554983f, -0.00472714f, -0.02074261f, -0.03064488f, -0.02554354f, 0.03359864f, 
    0.01082567f, -0.01583064f, -0.02800379f, -0.02702024f, 0.00018175f, -0.00287289f, 0.02272973f, -0.02271488f, 
    0.01945755f, 0.00200205f, 0.01912286f, 0.01007430f, -0.02549955f, -0.01373720f, -0.00834480f, 0.02790186f, 
    -0.01428201f, -0.00755430f, -0.01521165f, -0.01505603f, 0.02657005f, 0.02889273f, -0.00558978f, 0.01143862f, 
    -0.02062929f, 0.00457241f, -0.02189607f, -0.03227402f, 0.00007707f, 0.01493658f, 0.00489498f, -0.00167117f, 
    -0.03532349f, -0.02033018f, 0.00548569f, 0.00227672f, 0.00597039f, 0.00377645f, -0.03356526f, -0.00535584f, 
    -0.01163932f, 0.02997365f, 0.02867673f, 0.02296781f, 0.02632061f, 0.02346569f, 0.00731157f, 0.00632996f, 
    -0.03539968f, 0.01067517f, -0.00956238f, 0.02183458f, -0.03172027f, 0.00632360f, -0.02791070f, -0.02079610f, 
    0.02045414f, 0.03456055f, 0.01562369f, 0.00894152f, 0.02649301f, 0.00776096f, -0.01826182f, -0.02364542f, 
    0.02536938f, -0.01823708f, 0.01071364f, 0.02631042f, 0.00690543f, -0.01222556f, -0.02961025f, 0.00663221f, 
    -0.00709109f, 0.00376021f, -0.03398077f, -0.03000704f, 0.03162290f, -0.02553736f, 0.00597430f, -0.01565289f, 
    -0.02693353f, 0.01519961f, -0.01940427f, -0.03117064f, 0.02824983f, 0.00684434f, 0.00167909f, -0.02464893f, 
    -0.01209599f, -0.01813922f, 0.00155884f, -0.00354627f, 0.01558567f, 0.00252860f, -0.03386646f, 0.02493125f, 
    0.02740779f, -0.01716920f, 0.03434612f, -0.01284256f, -0.01295106f, 0.02547510f, -0.01924896f, -0.01166775f, 
    -0.03463415f, -0.01152705f, 0.02280269f, -0.01869217f, -0.01351525f, -0.00573452f, 0.00232195f, 0.01954138f, 
    0.02595373f, 0.00502998f, 0.02307700f, -0.01500880f, -0.02766205f, 0.00017022f, 0.01320102f, 0.00945169f, 
    -0.02230567f, 0.00033501f, 0.01981334f, -0.02531335f, -0.03267621f, 0.03300688f, 0.01068976f, -0.02033409f, 
    0.00049135f, -0.01459360f, 0.01510951f, -0.01756573f, 0.02407508f, -0.02060183f, -0.01320491f, -0.03134800f, 
    -0.00149286f, 0.02559778f, 0.00140777f, -0.01133327f, 0.00327524f, 0.01312943f, -0.00373665f, -0.03348194f, 
    -0.00184661f, 0.03452757f, -0.02603997f, -0.00621088f, 0.01392982f, 0.01667021f, -0.01487271f, 0.00029428f, 
    -0.01637301f, -0.04211286f, -0.04007212f, -0.00995503f, -0.04143591f, -0.00531559f, -0.03313162f, 0.00313669f, 
    -0.02538891f, 0.00215129f, 0.00029533f, -0.02315534f, -0.00882534f, -0.02737315f, 0.03006881f, -0.02486864f, 
    0.01103968f, 0.01161092f, -0.02168903f, -0.02983890f, 0.00234893f, -0.02431099f, -0.00250332f, -0.00816510f, 
    -0.02453182f, -0.00502338f, -0.00178842f, -0.03769580f, 0.02842827f, 0.01256385f, -0.01062198f, 0.02504019f, 
    0.01828109f, -0.00850422f, -0.02796013f, -0.04218555f, -0.03817514f, -0.00746399f, -0.00387054f, -0.03511929f, 
    -0.02856807f, -0.00216573f, -0.00338264f, -0.03887254f, 0.01824703f, 0.00768354f, 0.02417649f, 0.00080055f, 
    0.00118466f, 0.02006092f, -0.03084813f, -0.02186331f, -0.02326527f, -0.02142488f, 0.02953359f, -0.01813272f, 
    0.02289458f, -0.02228241f, -0.00941822f, 0.00367476f, -0.03676102f, -0.01978042f, -0.03457618f, -0.02876930f, 
    -0.01273063f, -0.02976177f, -0.02373036f, 0.02214200f, -0.01616760f, -0.03450011f, -0.00779108f, 0.01557814f, 
    -0.03242522f, -0.01719765f, 0.01388471f, -0.01243425f, -0.02083616f, 0.02368270f, 0.01311282f, 0.00440830f, 
    -0.01596685f, 0.02658060f, 0.02938393f, -0.00108918f, 0.00445426f, 0.02253657f, 0.00492511f, -0.01305926f, 
    -0.04124117f, -0.01152343f, -0.03649604f, -0.01926347f, 0.01300812f, -0.01324066f, 0.01385170f, -0.02459695f, 
    0.02060579f, 0.02064684f, 0.01287457f, 0.02775128f, 0.00268691f, -0.01812769f, -0.00253090f, -0.03140525f, 
    0.01818722f, -0.01637583f, -0.03576099f, 0.00523290f, 0.02848659f, -0.01441093f, 0.02249365f, 0.01096608f, 
    0.00915866f, -0.01481430f, 0.02058305f, -0.00319083f, -0.01478656f, -0.02678905f, -0.02111487f, 0.00253062f, 
    -0.03451482f, 0.00082604f, 0.00025031f, -0.01523961f, -0.01692234f, 0.00114564f, -0.02430606f, -0.00913172f, 
    0.02067062f, 0.01450928f, 0.00502043f, 0.02148110f, -0.01620739f, 0.02798253f, 0.02615036f, -0.02538611f, 
    0.00759350f, -0.00917282f, 0.02768418f, -0.01537160f, -0.01756860f, 0.02842776f, 0.01127294f, -0.01681600f, 
    0.00578462f, 0.01041696f, -0.01581771f, -0.03833854f, 0.02664515f, -0.00531575f, -0.00186385f, -0.02091104f, 
    -0.00627431f, -0.01092497f, -0.02431344f, -0.02153168f, -0.02203349f, -0.02267631f, -0.02171642f, -0.01652599f, 
    0.00927634f, -0.02583613f, -0.00852666f, -0.03199129f, -0.01971879f, -0.03530497f, 0.00610055f, -0.01929297f, 
    0.02280722f, -0.00037849f, 0.01489389f, 0.02133813f, 0.02336688f, -0.03523470f, -0.03186850f, 0.00970832f, 
    0.02964223f, 0.00984742f, -0.00452959f, 0.00702994f, -0.01182127f, -0.03846239f, -0.02533020f, -0.00922573f, 
    -0.01242456f, -0.01194857f, 0.02671419f, -0.03924367f, -0.00573523f, -0.01015835f, -0.01287047f, -0.00147148f, 
    -0.03401812f, -0.02779447f, -0.04230514f, 0.01363128f, 0.00539044f, -0.00221703f, -0.03824522f, 0.01412677f, 
    -0.03430950f, 0.01960727f, -0.01845671f, -0.00062002f, -0.01773694f, 0.02850818f, -0.02871426f, 0.02471760f, 
    0.02447719f, -0.01713963f, 0.00527848f, -0.01498205f, -0.00748907f, 0.00200427f, 0.00221531f, -0.02992312f, 
    -0.02550245f, 0.00570126f, 0.03102553f, -0.03623105f, 0.00692142f, -0.01806975f, -0.04220571f, 0.01093177f, 
    -0.00097838f, -0.01412740f, 0.00301826f, -0.01661052f, 0.00585407f, -0.03780630f, -0.02464924f, 0.01705928f, 
    -0.00352259f, -0.03961580f, -0.01805757f, -0.01373199f, 0.02016115f, 0.00536628f, -0.02175895f, -0.00270586f, 
    -0.03641886f, 0.00966217f, 0.00810272f, -0.03634520f, 0.00814547f, -0.01575164f, -0.02734849f, 0.00046630f, 
    -0.01871616f, -0.01839390f, -0.00352974f, 0.00577434f, -0.00312157f, -0.03928261f, -0.01184282f, 0.00584535f, 
    -0.02969657f, 0.03285863f, 0.02190714f, 0.01170668f, -0.00119477f, 0.01048915f, -0.02508118f, 0.00402464f, 
    0.00037962f, -0.02468883f, 0.02551648f, -0.03926305f, 0.01432987f, -0.02557054f, -0.02985892f, -0.04083789f, 
    -0.00760733f, 0.00097493f, 0.02288460f, -0.02779715f, 0.00909885f, -0.03631284f, -0.03148524f, 0.01702631f, 
    -0.01436258f, -0.00647053f, -0.02859074f, -0.03342894f, -0.04343665f, -0.01712533f, 0.00859210f, -0.01204395f, 
    -0.00305573f, 0.00373049f, -0.01156924f, -0.01281666f, 0.00410099f, -0.00188984f, 0.01770688f, -0.02776041f, 
    -0.00662075f, -0.00260325f, 0.02238937f, -0.01692674f, -0.01204067f, 0.02550281f, 0.02422703f, 0.02319722f, 
    0.00157130f, -0.03040180f, 0.02331658f, 0.02209796f, -0.01720375f, 0.00590702f, -0.03490416f, 0.03037442f, 
    0.01707800f, -0.03412142f, -0.02069570f, -0.02988473f, 0.02635843f, 0.01364590f, -0.00578963f, -0.01068053f, 
    0.01583043f, -0.02289733f, -0.01632917f, -0.00590743f, -0.01093018f, 0.01611944f, 0.02844382f, -0.00769678f, 
    -0.02853317f, 0.01403240f, -0.02571561f, 0.02825524f, 0.00925327f, -0.00366478f, 0.02560158f, -0.01982755f, 
    -0.00732862f, 0.00912487f, -0.02085144f, 0.01947129f, -0.00911365f, -0.04066047f, 0.02438982f, 0.02086165f, 
    0.01557404f, -0.01480103f, -0.03903321f, -0.04087056f, -0.04128281f, -0.04016620f, 0.01313298f, 0.02122014f, 
    -0.03134624f, -0.03204414f, -0.03223766f, 0.02413477f, 0.01983701f, -0.01244643f, -0.00257768f, 0.01317579f, 
    0.02290497f, 0.02918204f, 0.00862313f, 0.00070311f, 0.02859410f, 0.01291096f, 0.01797752f, -0.01885089f, 
    0.00217520f, -0.01047833f, -0.03836544f, 0.00327464f, -0.03688677f, -0.00227408f, -0.03342252f, -0.03859244f, 
    0.00406792f, -0.01071683f, 0.01854321f, 0.01138950f, 0.02323063f, 0.01604468f, 0.01146602f, 0.02299693f, 
    -0.02634306f, -0.01377152f, 0.02321893f, -0.03366792f, -0.01145564f, 0.00634040f, 0.01315278f, -0.00956629f, 
    -0.01788370f, -0.01783127f, 0.01604745f, -0.01239609f, 0.01713578f, -0.03400788f, 0.00182753f, -0.02859363f, 
    -0.00445181f, -0.01420305f, -0.00685139f, -0.03364351f, 0.02122776f, -0.02355053f, -0.02521934f, -0.03024272f, 
    0.00446872f, -0.00763751f, -0.00339310f, -0.03309456f, -0.03880361f, 0.01818691f, 0.02849715f, -0.02096432f, 
    -0.00167975f, 0.02320121f, 0.00097128f, -0.01775160f, -0.02463276f, 0.02444447f, -0.00419689f, -0.02563546f, 
    -0.02966733f, 0.01186545f, -0.03730297f, -0.00250098f, -0.03854756f, 0.01946037f, -0.01470684f, -0.02468354f, 
    -0.00313767f, -0.00336193f, 0.00874430f, 0.01482902f, -0.03257428f, -0.01594622f, -0.04045108f, -0.02552535f, 
    -0.01272305f, -0.03590259f, -0.00747191f, 0.02170530f, 0.01980950f, 0.00968140f, 0.00215388f, -0.01808448f, 
    0.01940892f, 0.00307078f, -0.00977494f, 0.00682278f, -0.04269303f, 0.01424016f, -0.00678856f, -0.00902212f, 
    0.01373634f, -0.03459295f, 0.00728692f, -0.01136007f, -0.03037091f, 0.00289069f, -0.02346010f, -0.00200104f, 
    -0.00934364f, 0.02229866f, 0.01902985f, -0.00120918f, -0.00301835f, -0.03639491f, 0.01393196f, -0.01882946f, 
    -0.01624188f, -0.00163210f, -0.00627390f, -0.03866945f, 0.00211221f, 0.02447395f, -0.03200563f, -0.02328245f, 
    -0.00639275f, -0.03698193f, 0.03186207f, -0.01822373f, 0.02067877f, -0.02082714f, 0.01793448f, -0.02949237f, 
    0.01391061f, -0.03669669f, 0.00016696f, -0.01525153f, 0.00028654f, -0.00422696f, 0.01591090f, -0.00886705f, 
    -0.03409700f, -0.00685541f, -0.00721680f, 0.01770362f, 0.02395266f, -0.00764224f, 0.02056506f, 0.00785737f, 
    0.02223656f, 0.02361175f, 0.00792826f, -0.03771356f, 0.01125001f, 0.00238410f, -0.01713524f, -0.03104525f, 
    0.00525690f, -0.02605755f, 0.02050335f, 0.02044453f, -0.01787589f, 0.01018130f, 0.03017904f, -0.04336635f, 
    -0.00506316f, -0.01092506f, 0.00613862f, -0.03454025f, -0.03960410f, 0.00646358f, -0.03501154f, 0.02042241f, 
    -0.02584733f, -0.03166725f, -0.00916892f, 0.00260211f, 0.02624835f, 0.00826009f, -0.03652896f, -0.00455814f, 
    0.01689166f, -0.00753381f, -0.00834230f, -0.03420746f, -0.02373199f, -0.01969349f, 0.00896381f, 0.01067158f, 
    -0.00530590f, -0.01471451f, 0.01062471f, 0.00224644f, -0.01116301f, 0.00563842f, -0.01851217f, -0.00665695f, 
    0.01071879f, -0.03641452f, -0.01854861f, -0.02575780f, 0.02390762f, -0.03443651f, -0.03044947f, -0.01920808f, 
    -0.00113605f, 0.01056085f, -0.03559921f, -0.01051724f, -0.00046350f, 0.00230968f, 0.00172105f, -0.01628375f, 
    -0.01797173f, 0.02750927f, -0.01819190f, 0.00806796f, 0.02271830f, -0.00341543f, -0.00663242f, -0.03383111f, 
    -0.00021612f, -0.04251075f, 0.02677853f, -0.00322840f, -0.01596804f, -0.00451515f, -0.01851843f, 0.00651473f, 
    -0.03279978f, -0.00378964f, -0.03345125f, 0.01423067f, 0.01461538f, -0.01240888f, -0.01815563f, -0.03471454f, 
    0.02546635f, 0.02524120f, 0.01855580f, 0.02101744f, -0.00433040f, 0.01492456f, -0.02324957f, -0.03785900f, 
    -0.02639391f, -0.03167428f, 0.02727397f, -0.02360908f, -0.00568995f, -0.02208615f, 0.01991814f, -0.03690818f, 
    -0.02788307f, -0.03848571f, -0.02297948f, -0.00467900f, -0.01642968f, 0.01900600f, 0.02681245f, 0.01336074f, 
    -0.02534972f, 0.01454886f, -0.03076068f, -0.03661863f, 0.02376247f, -0.03945761f, -0.01233751f, -0.02283661f, 
    0.00765079f, 0.01066564f, -0.00774219f, -0.03395014f, 0.00769325f, -0.03285186f, -0.03300693f, -0.03075380f, 
    -0.03396336f, -0.01582448f, 0.00917087f, 0.00489405f, 0.00694483f, -0.00601564f, -0.02665851f, 0.02355384f, 
    -0.02164224f, -0.01911031f, -0.03069940f, 0.01414746f, 0.01679036f, -0.03642958f, -0.00083996f, 0.00828663f, 
    0.02093198f, 0.00045867f, 0.02671484f, -0.01218471f, -0.02643195f, -0.01349691f, -0.01107526f, -0.02783172f, 
    -0.02269966f, -0.00232235f, -0.01893042f, 0.00141880f, -0.02023474f, 0.01703645f, 0.01997968f, -0.01933799f, 
    -0.03694019f, 0.02025622f, -0.03191176f, -0.03947802f, -0.04063533f, 0.03022484f, -0.02094025f, 0.00456547f, 
    0.02270719f, -0.03488865f, -0.01384844f, 0.02512248f, -0.04166252f, 0.02625475f, -0.03933862f, -0.00799070f, 
    0.01022409f, 0.02637978f, 0.02662012f, -0.03529883f, -0.01774724f, 0.00642945f, 0.01162299f, -0.02136890f, 
    0.01392745f, 0.01695420f, -0.01893546f, -0.00994934f, 0.01598895f, 0.02434243f, 0.03495681f, -0.02848833f, 
    -0.02415033f, 0.00570441f, 0.02581760f, 0.02938171f, -0.01187470f, 0.02124412f, -0.00484484f, -0.03484540f, 
    -0.02573796f, 0.01796674f, -0.01039929f, 0.02588235f, 0.02148844f, 0.01460903f, 0.02353073f, -0.00268327f, 
    0.01591956f, 0.00853565f, 0.01618043f, 0.01729161f, 0.01348777f, -0.00467645f, -0.03086918f, -0.01941582f, 
    -0.03497187f, -0.03873738f, 0.01153464f, -0.03924099f, 0.01430702f, -0.00802622f, 0.02309185f, 0.02135247f, 
    -0.00755297f, -0.02420253f, -0.02643166f, -0.00817312f, 0.02264540f, 0.03079244f, 0.02199138f, -0.03622504f, 
    -0.01380132f, -0.01157774f, -0.01137482f, 0.01261225f, -0.03923530f, -0.02913366f, 0.02645537f, 0.01146246f, 
    0.01095424f, 0.00499375f, -0.00663621f, 0.02847045f, -0.01686780f, 0.02149787f, 0.00245215f, -0.02114294f, 
    -0.00021237f, -0.01071118f, -0.03104972f, -0.00510947f, -0.03771236f, 0.00246843f, 0.02156700f, -0.00927308f, 
    -0.01223612f, 0.01044940f, -0.03194110f, 0.00991040f, 0.00007665f, 0.02536424f, 0.01820768f, -0.01165167f, 
    -0.27011016f, -0.10508913f, -0.12202662f, 0.14353196f, -0.10656181f, -0.19685572f, 0.14202492f, -0.06612459f, 
    0.01147167f, -0.03756591f, 0.09090719f, 0.05820971f, 0.69685161f, 0.12251902f, 0.21314725f, 0.35700479f, 
    -0.05059127f, 0.00766933f, -0.12399784f, -0.07868940f, -0.19588871f, -0.09951133f, 0.06401266f, 0.02938198f, 
    0.32820079f, 0.00583024f, 0.22198345f, 0.12989669f, 0.01946892f, -0.03495139f, -0.07280861f, -0.03809552f, 
    -0.05035370f, 0.18102689f, -0.24000782f, 0.04669644f, -0.07332894f, -0.26783913f, 0.19733539f, -0.12415037f, 
    -0.08672021f, 0.20044036f, -0.06544509f, -0.02625525f, 0.07249215f, -0.04074212f, -0.05567490f, 0.19601358f, 
    0.19647543f, -0.09444800f, 0.08654324f, -0.18848617f, 0.14896871f, 0.00936369f, 0.01292982f, 0.01912750f, 
    -0.09970376f, 0.05974968f, -0.16227475f, 0.00072708f, 0.28329942f, 0.28703541f, 0.07312400f, 0.13815430f, 
    0.06870274f, -0.11780071f, -0.00249254f, -0.26337674f, -0.21452011f, -0.17949651f, -0.06873278f, 0.20586200f, 
    -0.21838905f, -0.01486222f, -0.29750109f, -0.01708120f, 0.04371015f, 0.02215786f, 0.03857731f, 0.11880794f, 
    -0.08367406f, 0.00140605f, -0.09595351f, 0.07544801f, -0.09789248f, 0.17146382f, 0.25017172f, 0.10268574f, 
    -0.04850689f, 0.02411281f, -0.11113615f, -0.25823030f, 0.13403741f, 0.19424348f, 0.10190385f, 0.05644412f, 
    0.07903636f, -0.06216915f, -0.09794949f, 0.02253287f, -0.00952688f, -0.02435779f, 0.10071716f, 0.19391486f, 
    0.12935551f, 0.00374871f, -0.05293038f, 0.03703295f, 0.03656556f, -0.06064516f, 0.07511552f, 0.09330311f, 
    0.01338403f, 0.13524847f, 0.08684457f, -0.06370637f, 0.13555054f, -0.06092644f, 0.13168468f, -0.07108603f, 
    0.02271058f, 0.03789390f, 0.03979334f, -0.06220814f, 0.10557182f, -0.12694322f, 0.18349221f, 0.10938112f, 
    -0.20092735f, -0.05845080f, 0.04651820f, -0.12637728f, 0.10764799f, 0.04856289f, 0.18854657f, 0.17259789f, 
    -0.04360200f, 0.02166480f, 0.04232261f, -0.05690449f, -0.06303064f, -0.00374839f, 0.05122612f, -0.07558890f, 
    0.18626684f, -0.01031231f, 0.19048451f, 0.12973776f, 0.11398271f, 0.07242463f, 0.13843414f, -0.06337100f, 
    -0.03378519f, -0.07811975f, -0.02482861f, -0.13520491f, -0.00508688f, 0.04394338f, -0.13933389f, 0.08765877f, 
    0.15742016f, 0.02423457f, 0.08896568f, 0.09372778f, -0.09088453f, 0.04675070f, -0.06793848f, 0.01483387f, 
    0.18453334f, 0.40248978f, 0.25139195f, -0.03404304f, -0.07744378f, 0.05300447f, 0.01215855f, -0.21851461f, 
    0.01292566f, -0.00156348f, 0.00648116f, 0.09104352f, 0.09125590f, -0.13965198f, -0.00262823f, 0.01873890f, 
    0.03561054f, -0.06385498f, 0.02686488f, 0.06627554f, -0.07396205f, 0.02051297f, -0.01111941f, 0.14393505f, 
    0.00968252f, 0.11535677f, -0.23089959f, -0.02198319f, -0.09424581f, 0.05195517f, -0.00794836f, -0.06163264f, 
    -0.06012558f, 0.04566513f, 0.05925958f, -0.08343737f, -0.40160865f, -0.05431894f, -0.03150347f, -0.02577612f, 
    0.00367353f, -0.09838206f, 0.01560391f, -0.03969232f, -0.06467527f, -0.01775333f, 0.03713311f, -0.04091440f, 
    0.09454732f, -0.03954009f, 0.04498111f, 0.20231205f, -0.14380640f, 0.02639950f, 0.08068039f, 0.08807845f, 
    -0.11165580f, -0.06207827f, 0.00842452f, -0.07385784f, -0.31286079f, 0.08517198f, -0.31491083f, -0.06912261f, 
    -0.09656953f, -0.07317400f, 0.29015967f, -0.02943354f, 0.14327753f, -0.07230094f, -0.16293231f, -0.16763063f, 
    0.58031166f, 0.10428105f, 0.23226437f, 0.21251380f, -0.12975873f, 0.12725887f, -0.01642890f, -0.08738752f, 
    0.12476069f, -0.04694955f, 0.07829326f, -0.03598122f, 0.02861147f, 0.06113200f, -0.12162802f, 0.07761095f, 
    0.04717062f, -0.00238901f, 0.01957073f, 0.01652917f, -0.06814113f, 0.00877093f, -0.02407137f, -0.04034457f, 
    -0.04796970f, 0.07455745f, -0.01336250f, -0.05406526f, 0.08396643f, 0.00206827f, -0.01525669f, 0.04661897f, 
    -0.05549121f, 0.00107039f, 0.00373314f, 0.08940609f, 0.16583018f, -0.10475848f, 0.10562964f, -0.11451967f, 
    -0.02332134f, -0.00922251f, 0.07167483f, -0.09830455f, -0.19802979f, 0.26215827f, -0.12514372f, -0.26552349f, 
    -0.22689660f, 0.39064893f, -0.05187421f, -0.06770375f, -0.14820231f, 0.07376662f, 0.03138060f, -0.22313583f, 
    0.23495719f, 0.05637281f, 0.16381496f, 0.16165552f, -0.09546919f, 0.00743772f, 0.10051160f, -0.08502217f, 
    -0.04037590f, -0.01769260f, -0.05074954f, 0.04502277f, -0.01559168f, -0.15735246f, 0.18586977f, -0.08550269f, 
    0.01693262f, -0.03652201f, -0.09186516f, -0.07881269f, 0.02029821f, 0.10091078f, 0.13931288f, 0.01540166f, 
    -0.09587198f, -0.01662564f, 0.10764897f, -0.10584495f, 0.34550998f, -0.15188029f, -0.02145235f, -0.33248964f, 
    0.00518434f, -0.00479588f, 0.16103190f, 0.16242403f, -0.10198062f, 0.04689423f, -0.03841597f, -0.11623926f, 
    0.73077559f, 0.16571577f, 0.35876262f, 0.31320232f, -0.10170677f, -0.00839193f, -0.01424554f, -0.18699208f, 
    -0.04276853f, 0.05327396f, 0.15239598f, 0.16659978f, -0.04474109f, -0.05920348f, 0.08048712f, 0.17637365f, 
    -0.02730223f, 0.00436299f, 0.13568208f, -0.03025537f, 0.03579595f, -0.06161321f, -0.02208046f, 0.05868535f, 
    -0.14867018f, -0.06289222f, 0.07730608f, -0.07463524f, 0.01640167f, 0.06546029f, -0.01904436f, -0.15501909f, 
    0.07293212f, -0.06317977f, 0.07150523f, 0.05367880f, 0.01888082f, -0.00580339f, -0.50046808f, -0.02325750f, 
    -0.02729896f, -0.01577937f, 0.02422923f, 0.05229709f, -0.00386031f, -0.05816159f, -0.02370624f, -0.19133197f, 
    0.12924227f, 0.22014195f, -0.17241874f, 0.15209122f, -0.02775354f, 0.06775149f, -0.13970147f, -0.06142758f, 
    0.13584593f, 0.15298441f, 0.01891666f, -0.02284364f, -0.18965848f, 0.04004430f, -0.21456474f, 0.27976540f, 
    0.21595196f, 0.03563798f, -0.08984221f, -0.03620426f, 0.00434151f, -0.03772909f, -0.00283713f, 0.02993119f, 
    -0.16806079f, 0.27926484f, -0.24691157f, 0.03879719f, 0.21999356f, -0.07980079f, 0.01134237f, -0.07501953f, 
    -0.16092268f, 0.09212258f, -0.14237279f, 0.15725017f, -0.14446823f, 0.08987441f, -0.06389978f, -0.14726676f, 
    0.04484429f, 0.04511571f, 0.10938018f, -0.01922516f, 0.05190784f, -0.02357245f, -0.05836712f, 0.10155326f, 
    -0.00224819f, -0.05558592f, 0.20389710f, -0.13569011f, 0.09463850f, 0.09816101f, 0.03790404f, 0.03253712f, 
    -0.06572430f, 0.20598550f, 0.01623887f, -0.23227954f, -0.04549159f, 0.13946435f, 0.06771289f, 0.10788927f, 
    0.01721644f, -0.16206393f, 0.01021915f, -0.07063379f, 0.00360710f, 0.05975476f, -0.08685798f, 0.33706257f, 
    0.17467169f, -0.12963347f, -0.04126271f, 0.07534551f, 0.21410103f, 0.31350178f, -0.10575394f, -0.00181464f, 
    0.13227181f, -0.00360879f, -0.14086586f, 0.09837956f, -0.35132253f, 0.09111124f, -0.09454551f, -0.02487275f, 
    -0.19592138f, 0.00035852f, 0.08232925f, -0.06556447f, 0.10589856f, -0.26120862f, 0.04545391f, -0.25205386f, 
    -0.25625765f, -0.00420711f, -0.11727720f, -0.10352872f, 0.09476686f, -0.00497605f, 0.33072662f, 0.08919507f, 
    -0.10095100f, 0.01324102f, -0.06559610f, -0.11980562f, -0.09045354f, -0.12607747f, -0.04301327f, 0.02087104f, 
    -0.00335203f, -0.08330041f, 0.07730039f, -0.08020365f, -0.08946764f, 0.02621391f, -0.08373628f, 0.02792569f, 
    0.09212832f, -0.27671200f, 0.12878865f, -0.03045259f, 0.13642037f, -0.09911378f, -0.02697220f, -0.13429338f, 
    0.03578128f, 0.26651636f, 0.03372300f, 0.01605725f, -0.01674239f, -0.22761630f, -0.13456959f, 0.29371029f, 
    0.07527097f, -0.14058205f, 0.22095330f, 0.04776680f, 0.12579073f, 0.01778667f, 0.01702530f, -0.10981905f, 
    0.28716296f, -0.09758411f, 0.25426817f, 0.05532973f, 0.02580566f, -0.03667032f, -0.17264850f, -0.05711960f, 
    0.06837091f, -0.05668839f, 0.04516033f, 0.01713918f, -0.09259319f, -0.09715623f, 0.04280560f, -0.01859774f, 
    -0.01651007f, -0.09312228f, -0.09834459f, -0.00842449f, -0.07675777f, -0.02183796f, 0.01887042f, -0.02322550f, 
    -0.00210254f, -0.03360108f, -0.14132532f, -0.06598222f, 0.08494652f, 0.10882526f, 0.01849107f, 0.17003340f, 
    -0.12041289f, -0.06928335f, -0.04312667f, 0.02499273f, -0.11626700f, -0.05052852f, -0.08668116f, 0.04634139f, 
    0.07241815f, -0.04574143f, -0.01700526f, -0.10644753f, -0.01141029f, 0.01619003f, 0.16966245f, -0.02368445f, 
    0.06774116f, 0.24801047f, -0.19762366f, 0.07138053f, 0.05808471f, 0.21317482f, -0.09898946f, -0.05218906f, 
    0.15405311f, 0.04379740f, 0.18114588f, 0.16433676f, -0.28196812f, 0.19343810f, -0.12229685f, -0.04149853f, 
    0.09168994f, -0.12869592f, 0.01255512f, 0.04533533f, -0.03278296f, 0.15978640f, -0.04405706f, 0.23884924f, 
    -0.10538996f, 0.17613485f, 0.07268717f, -0.08857228f, 0.10649940f, -0.01794774f, -0.02166990f, -0.02085777f, 
    0.11604875f, 0.01758586f, -0.09563410f, 0.12879983f, -0.34643665f, 0.13980043f, 0.09570839f, -0.19188289f, 
    0.02448973f, 0.07634716f, 0.08196687f, -0.17813101f, 0.02286367f, 0.01811141f, 0.05618909f, 0.11402477f, 
    -0.09193709f, -0.14991663f, 0.23797810f, 0.00682293f, 0.07360765f, 0.01952952f, -0.01920971f, 0.05557554f, 
    0.15200913f, 0.12050335f, -0.23808424f, 0.11322877f, -0.02304466f, -0.00684588f, -0.04196700f, 0.20835100f, 
    0.12024701f, 0.04098654f, 0.16731420f, -0.00205716f, -0.10624188f, -0.04936162f, 0.03136899f, -0.14434867f, 
    0.04019506f, -0.17336187f, 0.05373638f, 0.01637832f, -0.07401721f, 0.13575679f, 0.00670018f, -0.05369228f, 
    0.14333114f, 0.02172485f, -0.00960400f, 0.13926938f, -0.12780440f, -0.00582254f, -0.10878565f, 0.19243285f, 
    -0.04923135f, -0.17177394f, 0.29563782f, -0.21680330f, -0.00921777f, 0.15591455f, -0.10761927f, -0.13053666f, 
    0.26814514f, 0.02809500f, 0.13369733f, 0.16615579f, 0.01661933f, 0.06353007f, -0.04214501f, 0.25333804f, 
    0.07303976f, 0.00424481f, -0.01374926f, -0.04550165f, -0.10555442f, 0.00261239f, -0.02010932f, 0.03821946f, 
    -0.03066511f, -0.02611721f, 0.18073981f, -0.07731017f, -0.10557137f, 0.00327208f, -0.00968078f, -0.00091745f, 
    0.01957545f, 0.02326972f, 0.03498603f, 0.07361751f, -0.00504907f, -0.05327214f, -0.13123655f, -0.01259130f, 
    -0.09411674f, -0.08842469f, 0.19519353f, 0.20381612f, 0.21949294f, -0.09501906f, -0.12134910f, 0.00332937f, 
    0.22353630f, 0.08712043f, -0.05006652f, 0.07158963f, -0.00499718f, 0.00918272f, -0.00628058f, 0.16631818f, 
    0.30819696f, -0.21950217f, 0.07779958f, -0.19848011f, 0.09134572f, -0.03653609f, 0.08899857f, -0.15681185f, 
    0.13554400f, 0.20088334f, -0.17302662f, -0.15470159f, 0.43755463f, 0.10926369f, 0.11395831f, 0.23507009f, 
    -0.04192014f, 0.20668235f, -0.06404485f, 0.09788469f, 0.07066429f, 0.00614318f, -0.04360344f, -0.10204455f, 
    -0.20014150f, 0.13910811f, -0.38135469f, -0.06842723f, -0.06205797f, -0.07345489f, 0.15893167f, -0.06643791f, 
    -0.10910248f, 0.02056463f, 0.05479415f, -0.19596788f, 0.14371336f, 0.02404165f, 0.13802022f, 0.10117720f, 
    0.07044695f, 0.03699962f, 0.00538748f, 0.13607982f, 0.11832041f, 0.06819855f, -0.02133252f, 0.10828695f, 
    -0.03334275f, 0.00955905f, -0.00292036f, 0.00695474f, -0.01219794f, 0.02698431f, -0.01847973f, 0.00621912f, 
    0.02084003f, -0.01122778f, 0.02825047f, -0.02918182f, 0.00221974f, 0.01366156f, 0.00318595f, -0.04038870f, 
    0.01041730f, -0.04159862f, -0.02536436f, -0.02776625f, -0.02082362f, -0.02629775f, -0.01936321f, 0.02961110f, 
    -0.00272077f, -0.03504061f, 0.00958978f, 0.01424250f, -0.02198705f, -0.03577828f, -0.00562418f, -0.02426985f, 
    0.00288155f, -0.00584827f, -0.03149220f, 0.02626976f, -0.03846042f, -0.03375252f, -0.01292459f, 0.02679075f, 
    -0.02849767f, 0.00525730f, -0.01110352f, -0.01492894f, -0.04085133f, -0.03299025f, -0.01162168f, -0.00429044f, 
    0.01163359f, 0.00478444f, 0.01458522f, 0.02379206f, 0.02126298f, 0.01869668f, 0.00327731f, 0.01510509f, 
    -0.01399392f, 0.02916651f, 0.03612934f, 0.00878513f, -0.02167935f, -0.02351118f, 0.01175265f, -0.03511746f, 
    -0.01974015f, -0.01815945f, 0.01635139f, 0.02791334f, -0.03967442f, 0.00865012f, 0.02840901f, -0.01301748f, 
    -0.00939597f, 0.00631214f, 0.01097760f, -0.01251896f, -0.03441080f, -0.03769249f, 0.00058577f, -0.02793720f, 
    -0.03319975f, -0.03270674f, -0.00843878f, -0.00053707f, -0.01148615f, 0.00214340f, -0.04257900f, -0.01468426f, 
    -0.00986486f, -0.02878149f, 0.01896864f, -0.03200114f, -0.02158871f, -0.03433568f, -0.04222269f, 0.00451481f, 
    -0.00139753f, -0.04025900f, 0.02593675f, 0.01610341f, -0.00269046f, -0.02127115f, 0.01772388f, -0.01897304f, 
    0.00001868f, -0.03016835f, 0.00219685f, 0.02311963f, -0.02801764f, -0.00012141f, 0.00789322f, -0.03410416f, 
    -0.00311026f, -0.03999548f, 0.01654484f, -0.02889955f, 0.01294047f, 0.01589715f, -0.02455377f, 0.03181084f, 
    0.02331758f, -0.01944330f, -0.02395432f, -0.01882936f, -0.02081414f, -0.01752719f, -0.04146555f, -0.00814554f, 
    -0.00581573f, 0.00607796f, 0.03429088f, 0.00029337f, 0.00620386f, 0.01302010f, 0.01959099f, -0.03370218f, 
    0.01053091f, -0.01618459f, 0.01188002f, 0.00636747f, 0.00067381f, 0.00992827f, -0.00581423f, -0.03034894f, 
    0.02087381f, -0.01344576f, 0.01146288f, -0.00806736f, -0.02791660f, 0.02655107f, -0.00213308f, 0.01004699f, 
    0.01721920f, 0.01704221f, 0.03323792f, 0.01971353f, -0.03338860f, -0.00070847f, 0.02764277f, 0.01284731f, 
    -0.00311489f, -0.02201401f, -0.03506764f, 0.00905762f, -0.03917698f, 0.01986053f, 0.03536391f, 0.02836080f, 
    0.01802646f, 0.02623306f, 0.01262031f, -0.03423799f, -0.00923433f, 0.02638576f, 0.02474850f, -0.02689490f, 
    0.00273061f, -0.02808229f, -0.02297577f, -0.01680873f, -0.03972017f, 0.02221492f, 0.00166875f, 0.01959581f, 
    -0.03313579f, 0.02727243f, 0.00135749f, -0.01908207f, -0.01075664f, 0.01570412f, -0.01421325f, -0.02285241f, 
    -0.01440286f, 0.00380154f, -0.02388349f, 0.00105072f, -0.01080831f, -0.00329312f, -0.00231211f, -0.00109369f, 
    -0.01572840f, -0.03828930f, 0.00180027f, 0.02893297f, -0.02911322f, 0.02375127f, -0.02351932f, -0.02699423f, 
    -0.00152415f, -0.02808987f, 0.00784811f, 0.00989775f, 0.00117805f, 0.03349680f, 0.02014430f, -0.02308547f, 
    0.01593673f, -0.01706027f, 0.01494750f, -0.04061958f, -0.02249411f, 0.02172493f, 0.01916019f, 0.02107431f, 
    0.01770158f, -0.01274524f, -0.00891737f, -0.00659257f, -0.02194905f, -0.01223165f, 0.01269796f, 0.02003353f, 
    0.02035031f, -0.00073690f, -0.03332370f, 0.02573182f, 0.03164535f, -0.02947391f, -0.00960303f, 0.02398563f, 
    -0.00093924f, -0.03649741f, 0.01428893f, -0.00892646f, 0.00165776f, -0.00684791f, -0.01360535f, -0.03633928f, 
    -0.04304614f, 0.00341277f, -0.02705605f, -0.03719395f, -0.03567983f, 0.03036773f, 0.02246029f, 0.00671794f, 
    0.00738870f, -0.03407581f, -0.01077944f, -0.01131615f, 0.04339632f, 0.01216972f, -0.03697697f, -0.00005383f, 
    0.01170397f, -0.00659111f, 0.00077559f, 0.01966091f, -0.01618842f, -0.03412914f, -0.01325467f, 0.02708151f, 
    -0.03515816f, 0.01310984f, 0.00362003f, -0.01356248f, -0.02681144f, -0.01954926f, -0.02661326f, 0.00059250f, 
    -0.01449860f, -0.02326602f, 0.02812183f, -0.01761657f, 0.00949483f, 0.01158302f, 0.00660711f, -0.03588656f, 
    0.02594242f, -0.00666970f, -0.00549125f, -0.02828761f, 0.00147219f, 0.01526286f, 0.01137699f, -0.03616929f, 
    0.01637678f, -0.00123172f, 0.01701586f, -0.02770431f, -0.00311375f, -0.02467612f, -0.00920181f, -0.00835142f, 
    0.03665902f, -0.00120778f, 0.01427430f, 0.03698927f, 0.00943590f, -0.00923868f, 0.01727735f, 0.00884738f, 
    0.00894115f, 0.00320339f, 0.03441714f, -0.02203989f, 0.02127671f, -0.03676945f, -0.00554608f, -0.02417029f, 
    0.00544199f, -0.02250291f, -0.00863380f, -0.03166127f, -0.01914685f, -0.00218225f, -0.02588160f, 0.01642393f, 
    -0.02572872f, 0.02023397f, 0.02413663f, -0.02260946f, -0.03011610f, 0.00392456f, 0.01498191f, 0.01832571f, 
    -0.02549972f, -0.02666884f, -0.03132625f, -0.02336279f, 0.01463224f, 0.00626833f, -0.01118253f, -0.01852131f, 
    0.01309581f, -0.01077645f, 0.02684178f, 0.01547988f, -0.03886203f, -0.01641861f, -0.00704485f, -0.01701405f, 
    -0.01166640f, 0.00488282f, 0.00542562f, 0.02831771f, -0.01647805f, 0.02414394f, -0.02174579f, -0.02750710f, 
    0.02424176f, -0.00052445f, -0.03359661f, 0.01211401f, -0.01306886f, -0.00929286f, 0.00347864f, 0.02742902f, 
    -0.03428431f, -0.00211543f, -0.03460621f, -0.01314164f, -0.00585663f, -0.01251105f, -0.00185231f, 0.00857210f, 
    -0.02070533f, -0.00814476f, 0.01290088f, 0.01664155f, 0.03365065f, -0.02521573f, -0.01991702f, 0.00228703f, 
    -0.00027547f, -0.00887078f, -0.00253111f, 0.02708014f, -0.00204243f, 0.01655485f, -0.01210798f, -0.03228174f, 
    -0.02420904f, -0.02319286f, 0.01579038f, 0.00588746f, 0.00734465f, -0.00344506f, 0.02076268f, -0.00238589f, 
    0.01337217f, 0.01582095f, 0.03161280f, 0.01301560f, 0.00913686f, 0.00621694f, 0.00479020f, -0.01299580f, 
    -0.03210837f, -0.00907327f, -0.01377856f, -0.04160259f, -0.00692966f, 0.03157419f, -0.02405660f, -0.00536576f, 
    0.02687559f, -0.03243966f, -0.02552847f, 0.02773049f, 0.02553466f, -0.02655933f, -0.00063116f, 0.00452217f, 
    -0.00159188f, -0.02473252f, -0.00323937f, 0.03074452f, 0.02602594f, -0.01981556f, -0.00100988f, 0.01392513f, 
    -0.00301341f, 0.00607414f, 0.01429889f, -0.03190089f, -0.04201248f, -0.02082478f, -0.02315746f, -0.02490316f, 
    -0.03564263f, 0.00450409f, 0.02849800f, 0.01881850f, -0.01665245f, 0.00972302f, -0.02281650f, 0.00713175f, 
    -0.01090261f, 0.03511335f, 0.00265198f, 0.01526449f, -0.01613700f, 0.02551558f, 0.02320905f, 0.01046755f, 
    0.00530112f, -0.04113479f, -0.00863784f, -0.00344511f, 0.01240208f, -0.02386595f, -0.03350216f, 0.02294433f, 
    -0.01018322f, 0.01260259f, -0.00236040f, 0.02006336f, -0.02389965f, 0.02213707f, 0.02889475f, 0.00795437f, 
    -0.00584929f, -0.02561473f, -0.00299281f, -0.01237124f, 0.00704253f, -0.02263642f, -0.00946840f, -0.02201969f, 
    -0.01912353f, 0.00670481f, -0.00406815f, 0.01712870f, -0.04025130f, -0.01917329f, 0.00572546f, -0.03789791f, 
    -0.01995904f, -0.00701362f, 0.02444075f, -0.01031913f, -0.02006411f, 0.01576500f, 0.03314461f, -0.01368735f, 
    -0.03556529f, -0.00024386f, 0.00460481f, 0.03604420f, -0.02343312f, -0.01354983f, -0.00885960f, 0.00557785f, 
    -0.01423824f, 0.01952251f, -0.00864731f, 0.00193101f, -0.04331082f, -0.00427448f, -0.01063992f, 0.00003959f, 
    -0.03512263f, 0.01776731f, -0.02370109f, -0.01942120f, -0.03509783f, -0.00601760f, 0.00192593f, -0.00173775f, 
    -0.02487563f, -0.01136688f, -0.03510278f, -0.00575385f, 0.03081705f, 0.03309111f, -0.02815717f, 0.00294632f, 
    0.01771845f, -0.02936706f, 0.00810917f, -0.00125132f, -0.01546586f, 0.01548433f, -0.01057342f, -0.02782912f, 
    -0.01220995f, -0.02103863f, -0.03528915f, -0.02515843f, -0.00136193f, -0.03461463f, -0.03042532f, -0.00523715f, 
    -0.01712869f, -0.02398691f, -0.00970569f, -0.01080354f, -0.00171270f, 0.02849690f, 0.00202387f, -0.02949454f, 
    -0.04255833f, -0.03777220f, -0.04295632f, 0.02571707f, 0.01891102f, 0.02804692f, -0.02340373f, -0.02572025f, 
    -0.01025373f, 0.02384097f, -0.02027841f, -0.01129174f, 0.01757994f, -0.03155076f, 0.02750774f, -0.00593555f, 
    0.03125944f, -0.01522197f, -0.02370065f, -0.01016582f, 0.02582490f, 0.02987410f, 0.00791173f, 0.00014381f, 
    -0.01788257f, 0.01147101f, 0.02873325f, 0.01295270f, 0.00570958f, -0.00783828f, -0.01471660f, 0.02410280f, 
    -0.01114087f, -0.01014290f, 0.03038008f, 0.02805515f, -0.04052060f, 0.01806432f, -0.02117009f, 0.02009245f, 
    -0.02329714f, -0.03593318f, -0.00104961f, -0.00753866f, 0.01301160f, -0.03190978f, -0.01089392f, -0.03472363f, 
    0.00319309f, 0.00248064f, -0.01356496f, -0.03443673f, -0.01489739f, 0.04172541f, -0.01385496f, 0.01159072f, 
    -0.02443957f, -0.00900106f, 0.02953558f, 0.02497331f, -0.00131947f, 0.01472534f, 0.01793231f, -0.04140163f, 
    -0.03314080f, -0.01569085f, -0.03083593f, 0.02109893f, 0.02207546f, 0.01450205f, 0.01933158f, -0.00782839f, 
    0.01500744f, 0.00947638f, -0.02117835f, 0.01133236f, -0.00858547f, 0.01119629f, -0.02382193f, -0.00804700f, 
    0.00115531f, -0.03171399f, -0.01905221f, 0.02013654f, -0.02696947f, -0.00371879f, -0.02380547f, 0.02702976f, 
    -0.02195900f, -0.00831740f, 0.00836388f, -0.02515747f, -0.02671179f, -0.02426304f, -0.02804486f, -0.02835550f, 
    0.00131784f, 0.02566351f, -0.01901782f, 0.04047896f, -0.02469793f, 0.02389482f, -0.04254061f, 0.00366813f, 
    -0.00689565f, 0.01210093f, -0.04095333f, -0.02942769f, -0.03405720f, -0.04073283f, -0.02885615f, 0.00878539f, 
    -0.02616645f, -0.01065334f, -0.03666236f, 0.01153919f, 0.02454861f, -0.02383221f, 0.02713540f, -0.04265354f, 
    -0.03338950f, -0.02736741f, 0.02122587f, -0.03855857f, -0.03665328f, 0.02865666f, 0.00282713f, -0.00179145f, 
    0.02497519f, 0.02860870f, -0.01430136f, 0.02061865f, -0.01321096f, 0.01617069f, -0.03778084f, -0.02439463f, 
    -0.00928169f, -0.00545639f, -0.00729788f, -0.02455789f, -0.03586021f, 0.03600400f, -0.02664388f, 0.00902542f, 
    0.00957597f, 0.00694975f, -0.02628781f, 0.00960400f, 0.00859080f, -0.02482605f, 0.02634395f, 0.02587169f, 
    0.03514908f, -0.00293415f, 0.02266433f, -0.03348953f, -0.03028212f, 0.01600401f, -0.00503444f, 0.02480397f, 
    -0.00622796f, 0.00311230f, -0.01966652f, -0.01655592f, -0.00653410f, 0.00502270f, -0.03518749f, 0.02188090f, 
    0.02312030f, 0.02515389f, 0.00812601f, -0.02498486f, -0.02661810f, -0.00447004f, -0.01912125f, 0.01396557f, 
    -0.02168700f, -0.03362620f, -0.02014972f, 0.00824077f, 0.01147607f, -0.02542513f, 0.00170742f, -0.01217873f, 
    -0.00613820f, -0.00871970f, 0.02443132f, -0.00146661f, 0.01291832f, -0.01608070f, -0.03316133f, -0.03268930f, 
    -0.00315964f, -0.02744244f, 0.01288626f, -0.04054351f, -0.03218867f, 0.01700107f, -0.02428610f, -0.00269676f, 
    0.02761666f, 0.01325279f, -0.00951995f, -0.03885187f, -0.02567516f, -0.02394284f, -0.00371361f, -0.01643937f, 
    -0.01980666f, -0.02734590f, 0.02076433f, -0.02030102f, 0.01812463f, -0.00501385f, -0.01373771f, -0.02869089f, 
    -0.03254966f, -0.01695445f, -0.01979011f, 0.01949791f, -0.02376523f, 0.00483140f, -0.00279077f, -0.02486526f, 
    -0.02579570f, 0.02155993f, -0.01702875f, -0.03977778f, 0.02422840f, -0.02324268f, -0.01310826f, -0.00550700f, 
    0.01736997f, 0.01914892f, -0.01430711f, -0.03152670f, -0.00119704f, -0.01104237f, -0.03232034f, 0.00682704f, 
    -0.00382246f, -0.02963439f, -0.01175697f, -0.01065585f, 0.00844110f, 0.01289224f, -0.01582494f, -0.02774030f, 
    -0.00278238f, 0.02836986f, -0.03393340f, 0.02574434f, -0.00085620f, -0.01374840f, 0.02720205f, -0.02498417f, 
    0.02480650f, -0.00794311f, -0.03724422f, -0.03207226f, -0.01819550f, 0.00998994f, -0.02366108f, 0.03099540f, 
    -0.04075993f, 0.02083888f, -0.03856096f, -0.02101167f, -0.03743683f, -0.01468399f, -0.03362168f, 0.02709743f, 
    -0.02825047f, 0.00035517f, 0.00196791f, -0.04144423f, -0.00700785f, 0.02800151f, 0.01817952f, 0.02085562f, 
    -0.02581854f, 0.03002402f, -0.00451966f, 0.02106116f, -0.02692475f, -0.01414141f, -0.01275209f, 0.00873241f, 
    -0.02868015f, -0.02843286f, -0.03590678f, 0.02130546f, 0.02097784f, -0.03811653f, -0.03504623f, -0.01642758f, 
    0.02491814f, 0.00948585f, -0.00866611f, -0.02200181f, -0.02676811f, 0.01656010f, 0.00715646f, 0.00459765f, 
    -0.01845768f, 0.03197491f, -0.01482973f, 0.01479126f, -0.00546106f, -0.00913100f, 0.02356333f, -0.00439627f, 
    0.01111831f, 0.01006465f, -0.01079506f, -0.02497521f, -0.02072402f, 0.00564193f, -0.03225623f, -0.01525425f, 
    0.02180634f, -0.02749745f, 0.01082330f, 0.02440056f, -0.01452507f, 0.01620334f, 0.02682149f, 0.01731809f, 
    0.00508704f, -0.00848117f, -0.00570373f, -0.01403411f, -0.00975159f, -0.00847515f, 0.03273605f, -0.00896491f, 
    -0.01287560f, 0.03220379f, 0.01562813f, -0.00824111f, 0.02143204f, -0.03661527f, 0.00611875f, 0.01224558f, 
    0.00463499f, 0.01084321f, 0.03042916f, 0.01348715f, -0.01051341f, -0.02595960f, 0.00534539f, 0.02808044f, 
    0.01238520f, 0.02993496f, 0.02479454f, 0.02753869f, -0.00623003f, 0.00163092f, 0.00738199f, 0.02836638f, 
    0.00305583f, -0.02165319f, -0.00877464f, -0.02445436f, -0.00434199f, 0.00107348f, -0.01588835f, -0.00816806f, 
    -0.01421397f, -0.02613725f, -0.02254681f, -0.02542379f, -0.02552553f, -0.01260687f, -0.03094334f, -0.04016625f, 
    0.01907197f, -0.00352656f, 0.00482550f, -0.00210864f, -0.00951620f, 0.01043247f, 0.00921951f, -0.02791355f, 
    0.02628272f, 0.02656429f, -0.01587578f, 0.02165167f, -0.00161684f, -0.01241407f, -0.01911411f, -0.03549203f, 
    0.01648418f, 0.00813653f, 0.01850159f, -0.00199658f, -0.01985481f, 0.00408137f, 0.00102720f, 0.02915492f, 
    -0.01141318f, 0.00617405f, 0.00153473f, -0.01069877f, 0.02780711f, -0.00117280f, 0.00334327f, 0.02334793f, 
    -0.01389051f, 0.02274174f, -0.01000126f, -0.00726803f, -0.02032633f, -0.00325907f, -0.00691964f, -0.02829904f, 
    -0.01267529f, 0.03273468f, 0.02618580f, 0.00546303f, 0.01311878f, 0.00383969f, -0.03450222f, 0.00397542f, 
    0.02557354f, -0.02101897f, 0.02475128f, 0.02023790f, -0.03798512f, -0.03048351f, -0.03084564f, 0.00283111f, 
    -0.01713846f, 0.03085932f, 0.03558294f, -0.02350688f, 0.01107813f, 0.02774761f, 0.02118656f, 0.02922694f, 
    -0.01865541f, -0.03479288f, -0.03892746f, -0.03495459f, -0.03602633f, -0.00838181f, -0.01507457f, -0.02513853f, 
    -0.01939606f, 0.03290352f, -0.03509750f, 0.01753910f, -0.03528602f, -0.01112108f, -0.00286178f, -0.01106082f, 
    0.00440325f, 0.02668638f, -0.00599589f, -0.01374364f, 0.00326634f, -0.01145202f, 0.00018450f, -0.01630717f, 
    -0.01513859f, 0.01337558f, 0.00066522f, 0.01726293f, 0.01565642f, -0.03359272f, -0.02122631f, -0.00198236f, 
    -0.00466959f, 0.01206023f, -0.00002568f, -0.02067162f, -0.03036813f, 0.01213911f, -0.03881920f, -0.01026428f, 
    0.00138336f, -0.03266532f, -0.02129296f, -0.01027119f, 0.00191411f, 0.02187246f, 0.01883046f, -0.01504304f, 
    -0.03259403f, -0.03229158f, -0.00979046f, -0.02121122f, -0.03850075f, 0.02606938f, -0.01081959f, -0.03065765f, 
    -0.02805047f, -0.03090923f, 0.00120580f, -0.00007225f, 0.00973111f, -0.02483504f, -0.02332264f, -0.00433976f, 
    0.01503460f, -0.01974355f, -0.03007925f, 0.02990023f, -0.03209507f, -0.00364242f, -0.00128201f, -0.00387978f, 
    -0.03092608f, 0.01659287f, -0.00240555f, -0.01305391f, -0.03204316f, 0.00552845f, -0.04033097f, -0.03037638f, 
    0.00387664f, 0.02463285f, -0.02017192f, 0.00960229f, -0.03484563f, -0.00116806f, -0.02277624f, -0.03678786f, 
    0.01111257f, 0.01394189f, -0.01872862f, -0.02397287f, -0.02661041f, -0.01978765f, -0.03142397f, -0.03252040f, 
    -0.02914825f, 0.01603040f, 0.01664212f, -0.03405654f, -0.02594687f, -0.03180579f, -0.02121054f, -0.03720982f, 
    -0.02804748f, -0.00888141f, 0.00931656f, -0.01787046f, 0.01174186f, -0.01681699f, 0.00517189f, -0.00766713f, 
    -0.01706419f, 0.02521081f, 0.02921999f, 0.00425647f, -0.01779675f, -0.02086244f, -0.01811968f, 0.02757288f, 
    -0.01725361f, -0.00190734f, -0.01661661f, 0.02322935f, -0.01875541f, -0.00649621f, -0.01270782f, 0.00053318f, 
    0.00440136f, 0.02606889f, 0.01506700f, 0.02543823f, -0.02133103f, -0.02986655f, 0.01533111f, -0.03510546f, 
    0.00649481f, -0.02816099f, -0.02936263f, -0.00788802f, 0.02087163f, 0.01852469f, -0.04052221f, 0.02472634f, 
    0.01791131f, 0.00652678f, 0.03001120f, -0.03101586f, 0.02526068f, -0.00297985f, -0.00983490f, 0.01422290f, 
    -0.00046708f, 0.02937544f, 0.01512399f, 0.02953247f, 0.01906621f, 0.03243380f, -0.03322021f, -0.02980390f, 
    -0.03760497f, -0.03505882f, 0.01631998f, -0.03401455f, -0.02346008f, -0.01628241f, 0.01049501f, 0.01434239f, 
    0.01700728f, 0.02386984f, 0.03224349f, -0.02056935f, -0.02943536f, 0.02965171f, -0.00381462f, 0.01716397f, 
    -0.01011845f, -0.01787845f, 0.00976562f, -0.03372259f, 0.01109911f, -0.03172792f, 0.02600331f, 0.00655707f, 
    -0.03015584f, -0.02441149f, -0.01325108f, 0.02663324f, -0.01428785f, 0.02221804f, 0.01356212f, -0.01867890f, 
    0.02730497f, 0.01672571f, -0.01995528f, -0.01015249f, -0.01655529f, -0.01848607f, -0.03431872f, -0.01753846f, 
    0.02823108f, -0.01010583f, 0.01964000f, -0.01517039f, -0.03257528f, 0.00858671f, 0.01568629f, -0.00598208f, 
    -0.01689921f, 0.01125033f, 0.00976417f, 0.00010937f, 0.00055938f, -0.01581910f, 0.02505514f, 0.01916664f, 
    -0.03393799f, 0.02093009f, -0.02300305f, -0.01709430f, -0.01387146f, -0.02258391f, -0.03451143f, -0.03263521f, 
    -0.02579059f, -0.03789182f, 0.01465828f, 0.02375606f, 0.02195579f, -0.01750340f, -0.00521643f, 0.02743242f, 
    0.02141825f, -0.02910804f, -0.01088108f, -0.00040669f, -0.02048266f, -0.03077487f, 0.02329835f, -0.00260060f, 
    -0.02808721f, 0.02480204f, -0.02235191f, 0.02584001f, -0.00501778f, -0.01140673f, 0.00478630f, -0.03013531f, 
    -0.02188644f, -0.01342306f, 0.01375666f, -0.03872150f, -0.00238059f, -0.00736419f, 0.00105129f, -0.00186643f, 
    -0.02647175f, -0.01071749f, 0.01006940f, 0.01317118f, 0.02704717f, 0.01783685f, -0.01150804f, 0.00953040f, 
    -0.02469167f, -0.00110026f, 0.01246429f, -0.03648701f, 0.02571263f, -0.04131370f, 0.02747847f, -0.01911441f, 
    -0.01988418f, 0.02062791f, -0.00521753f, -0.01433538f, 0.01203265f, 0.02345514f, 0.00383745f, -0.04073982f, 
    -0.03248757f, 0.00843925f, -0.02388371f, -0.00881414f, 0.02552152f, 0.02035855f, -0.01050414f, -0.01180116f, 
    -0.00455067f, -0.03678229f, 0.01096521f, -0.03244827f, -0.03012792f, 0.02233360f, 0.01333055f, -0.02815164f, 
    0.01615370f, 0.02391754f, -0.02605691f, -0.02295071f, -0.00923896f, -0.02190124f, 0.03274700f, -0.01193652f, 
    -0.03509660f, -0.00335957f, 0.02325698f, -0.00482740f, 0.00417125f, 0.00882495f, -0.01851863f, -0.02414294f, 
    -0.03134090f, 0.01118302f, 0.02590008f, -0.03379800f, -0.03413664f, -0.01727264f, -0.00258169f, 0.01348393f, 
    -0.00479017f, -0.02782097f, 0.01311350f, 0.00789609f, -0.02912941f, -0.03999629f, 0.01468417f, -0.03826004f, 
    -0.03122283f, 0.00109247f, 0.02591252f, 0.02750401f, -0.03575621f, 0.01449649f, -0.02608746f, -0.00278057f, 
    0.00209393f, -0.01411025f, 0.00256249f, -0.03457361f, -0.01687084f, -0.04052081f, 0.02426600f, -0.02089253f, 
    0.02917926f, -0.01752411f, -0.00833263f, -0.02589656f, 0.00956064f, 0.01674165f, 0.00131416f, 0.02532520f, 
    -0.03210163f, 0.01476406f, 0.02425846f, -0.02349701f, 0.02875821f, -0.03165846f, -0.02763451f, -0.03589275f, 
    -0.00467407f, 0.02358595f, 0.00378210f, 0.01510539f, 0.02486247f, -0.01165553f, -0.03698565f, 0.02708793f, 
    -0.00116259f, 0.02401407f, 0.01462950f, -0.02520485f, 0.01071934f, -0.03302820f, 0.00377197f, 0.01543884f, 
    -0.00852611f, 0.02677611f, -0.01301809f, 0.02206483f, -0.02895998f, -0.03227030f, -0.02001344f, -0.00021256f, 
    -0.03239791f, -0.03930860f, 0.03055528f, -0.00065697f, -0.00290136f, 0.01841019f, -0.01583964f, -0.01207438f, 
    -0.00533298f, -0.03411658f, -0.00855758f, 0.01268974f, -0.02355345f, 0.01087798f, -0.00682381f, -0.02540857f, 
    -0.03859540f, 0.00449522f, -0.02522996f, 0.00755162f, -0.00211534f, -0.02139112f, 0.00239000f, 0.02007528f, 
    -0.01390976f, -0.04088771f, 0.02038451f, 0.00967945f, 0.00111783f, -0.03968035f, -0.01042803f, 0.00632904f, 
    -0.02523364f, 0.00346458f, 0.00599215f, -0.02406388f, -0.00103387f, 0.03097062f, 0.01873321f, 0.01907583f, 
    0.00563663f, -0.03899773f, -0.00810072f, -0.01840145f, -0.00398089f, 0.02717868f, 0.00114111f, -0.00969751f, 
    -0.03671017f, 0.01632226f, 0.00630714f, -0.01068273f, -0.01619653f, -0.01119680f, 0.03174530f, 0.02422469f, 
    -0.01896103f, 0.02064722f, 0.01111669f, -0.02682245f, -0.00717143f, -0.03451163f, -0.03460272f, 0.00863707f, 
    0.03566540f, -0.00057557f, -0.01435607f, -0.01743207f, 0.03110986f, 0.00941120f, -0.02243886f, 0.01718096f, 
    0.01101613f, -0.02586216f, -0.02311534f, -0.02902371f, -0.00169720f, 0.02673487f, 0.01701098f, 0.00054819f, 
    0.02265512f, -0.03481516f, -0.00741802f, -0.01084455f, -0.01946525f, -0.02960621f, 0.01822167f, -0.00221817f, 
    0.02478026f, -0.01120993f, 0.00884277f, 0.01139304f, -0.03525263f, -0.00211982f, 0.01287892f, -0.00747329f, 
    0.00535859f, -0.01859309f, -0.02805514f, -0.02691437f, 0.01130206f, -0.03567977f, 0.03008758f, -0.01709635f, 
    -0.01685816f, -0.01730416f, -0.02225304f, -0.02191457f, 0.01062191f, -0.01445316f, 0.01650641f, -0.03671108f, 
    0.03150323f, 0.02260262f, 0.02877720f, -0.00601101f, 0.01144589f, -0.01881307f, -0.00626943f, 0.02634666f, 
    -0.01413828f, 0.00227048f, 0.00629295f, -0.00264006f, 0.02490528f, 0.03311795f, -0.01174705f, 0.00477252f, 
    0.01966189f, -0.00350880f, -0.01584105f, 0.00116432f, 0.03042780f, 0.00368208f, 0.01808004f, -0.00701270f, 
    -0.02988156f, -0.03478270f, 0.01718659f, 0.02084986f, 0.00048280f, -0.01445889f, -0.00004897f, -0.00513653f, 
    0.01416773f, 0.03301002f, -0.00796679f, -0.02866239f, -0.02767178f, 0.00280404f, -0.01276431f, 0.02476738f, 
    -0.01288849f, 0.01821844f, 0.00308652f, -0.00058791f, -0.01670595f, -0.00504976f, 0.02765210f, 0.01719048f, 
    0.23038992f, -0.21652277f, -0.47522691f, -0.03498819f, -0.13690491f, -0.19127193f, -0.15397997f, -0.01127073f, 
    0.06696098f, 0.04019813f, -0.00426490f, -0.03656530f, -0.13316034f, 0.07580435f, -0.20377158f, -0.08402805f, 
    0.09695835f, 0.01142999f, -0.01533731f, -0.00911491f, -0.14854689f, -0.07032699f, 0.05039022f, 0.09335642f, 
    0.23668392f, -0.17882656f, -0.23713669f, -0.15284210f, -0.00009763f, -0.02152569f, -0.04484642f, -0.03747205f, 
    -0.07227013f, 0.02624469f, -0.04800862f, 0.00826635f, -0.37920237f, -0.19852971f, -0.15926594f, 0.03192831f, 
    0.02099793f, -0.08538535f, -0.10561919f, -0.03171207f, 0.08509611f, -0.03948469f, 0.07490779f, 0.04059003f, 
    0.04771425f, -0.11201981f, -0.05283031f, -0.12586221f, -0.02799426f, 0.06281649f, 0.02091081f, 0.03391273f, 
    -0.06141059f, 0.03087204f, 0.03032915f, 0.01672874f, 0.14609292f, 0.14072211f, 0.19710697f, -0.07739241f, 
    0.16447559f, 0.00906234f, -0.10680063f, -0.06592870f, -0.02749817f, -0.03777687f, 0.13215400f, -0.11555605f, 
    0.04998304f, 0.14301066f, 0.19659437f, -0.11370370f, -0.01935194f, -0.08323915f, 0.06506659f, 0.09525609f, 
    0.01292842f, 0.05987906f, -0.01672992f, 0.10258649f, 0.00725366f, -0.01608249f, 0.05585203f, 0.07199652f, 
    0.17056341f, 0.07901592f, -0.10412280f, 0.03585366f, 0.03612550f, -0.05464814f, 0.07082038f, 0.01063821f, 
    0.50061768f, 0.56881422f, 0.38860288f, 0.22880347f, 0.04609634f, 0.03967562f, 0.11182639f, 0.18027098f, 
    -0.12673266f, -0.13848449f, -0.05257024f, 0.06461005f, -0.03227885f, -0.06685642f, -0.02517105f, -0.03719350f, 
    0.00350007f, 0.00289025f, 0.00649894f, 0.00326517f, 0.01591247f, 0.05075154f, 0.06765275f, 0.18538217f, 
    0.08378369f, -0.01382404f, -0.07507655f, 0.02927304f, 0.01657829f, 0.04811163f, 0.00419733f, -0.03340017f, 
    0.00045845f, 0.05021721f, 0.01841691f, 0.04451132f, -0.17501231f, -0.10776563f, -0.14544436f, -0.01238456f, 
    0.07465798f, -0.00321835f, -0.00205514f, -0.02713670f, 0.05062826f, 0.03105927f, -0.06773166f, 0.01803541f, 
    0.27762389f, 0.20958516f, 0.08774815f, 0.06843718f, 0.07979165f, 0.09235577f, 0.06356809f, -0.02312924f, 
    0.04263812f, 0.02010580f, 0.07132091f, 0.04300350f, 0.33987546f, 0.42644650f, 0.06941279f, 0.33469683f, 
    0.14476934f, 0.15193458f, 0.02351209f, 0.10350392f, 0.00835514f, -0.09385600f, -0.03683704f, 0.14320678f, 
    -0.00448161f, -0.00058189f, 0.10427254f, -0.11169045f, 0.09169521f, 0.04247831f, 0.14611264f, 0.08675200f, 
    -0.08595940f, -0.02015867f, 0.08342744f, -0.02424079f, 0.19613077f, 0.04809519f, -0.20219536f, -0.04492615f, 
    -0.05260143f, -0.05500585f, 0.04942345f, -0.07519399f, -0.08916091f, -0.10238717f, -0.09703358f, 0.04191693f, 
    -0.13123651f, -0.27870923f, -0.27903676f, 0.05768337f, -0.08525698f, -0.03445638f, -0.14257133f, -0.01266024f, 
    0.05410686f, 0.02215362f, -0.05138375f, 0.06929604f, 0.11198802f, -0.35864091f, -0.56765568f, -0.04263769f, 
    -0.03442847f, -0.02390910f, -0.01153542f, -0.00617684f, 0.00735054f, 0.00416729f, 0.08436364f, -0.00740338f, 
    0.47890952f, 0.50619560f, 0.47810730f, 0.39925176f, -0.03720625f, 0.00882878f, 0.05823310f, 0.19096436f, 
    -0.05208657f, -0.01124849f, 0.02658854f, -0.02807292f, 0.12517628f, -0.04607956f, -0.06775389f, -0.16737489f, 
    -0.30606315f, -0.00917435f, -0.01936479f, -0.10457134f, -0.13162498f, 0.03763279f, -0.00913526f, -0.06464969f, 
    -0.26721963f, 0.04586199f, 0.07558210f, 0.03386268f, 0.05311063f, 0.07966883f, 0.08327209f, -0.04064110f, 
    -0.12748374f, 0.00799991f, -0.15054813f, 0.07845362f, 0.13350895f, -0.29281196f, -0.09921826f, -0.11539226f, 
    -0.08111662f, -0.03728401f, -0.03528060f, -0.03024136f, -0.05843412f, -0.03462679f, 0.00120803f, 0.06149726f, 
    0.27531949f, 0.31022635f, -0.00092463f, 0.11593366f, 0.06662459f, 0.12844832f, 0.07791033f, 0.18620487f, 
    -0.06296393f, 0.05177098f, 0.05204630f, 0.07129493f, 0.20112881f, -0.15433945f, -0.24399669f, -0.00564428f, 
    0.01362553f, 0.04339785f, -0.01510338f, -0.14049466f, -0.02841296f, 0.04462219f, -0.00207300f, -0.03335735f, 
    -0.19033778f, -0.15997970f, 0.00043117f, -0.12118392f, 0.03178306f, -0.00663254f, -0.14563222f, -0.20750402f, 
    0.03557205f, -0.14524724f, 0.24398001f, -0.00965278f, 0.02556839f, -0.00606558f, 0.01899261f, 0.00293341f, 
    -0.08705143f, 0.10203146f, -0.05991154f, 0.01151341f, 0.08378459f, 0.06312153f, -0.07456126f, 0.03460480f, 
    0.03240769f, -0.17335331f, -0.16193728f, -0.09970394f, 0.01557094f, 0.01871979f, -0.02015091f, -0.01663383f, 
    0.04397182f, -0.02621988f, 0.00395926f, 0.11909921f, -0.06410465f, 0.04844860f, -0.14887364f, 0.03331973f, 
    -0.08513716f, -0.03980957f, -0.10174636f, -0.17220493f, 0.09527881f, -0.02765722f, 0.00245355f, 0.07719982f, 
    0.04573599f, 0.08822366f, -0.11938413f, 0.04164429f, 0.10548127f, 0.07031693f, 0.03163771f, -0.10265628f, 
    -0.04660387f, -0.10733967f, 0.01091387f, -0.01850228f, 0.15128726f, 0.23842554f, -0.04208859f, 0.21558118f, 
    0.10051375f, 0.09178676f, -0.03198780f, -0.06695390f, -0.06388750f, -0.07810705f, 0.15004452f, -0.06327371f, 
    -0.37166691f, -0.39399531f, -0.19100556f, -0.17878181f, 0.01562009f, -0.00566004f, -0.07164228f, -0.07359917f, 
    0.06252780f, 0.10158244f, 0.10717460f, 0.02667122f, 0.08335821f, 0.13879454f, 0.34081155f, 0.09017304f, 
    -0.00526663f, 0.12851606f, 0.02198280f, 0.07731025f, 0.01914204f, 0.01045926f, -0.09929676f, 0.02178595f, 
    -0.15309916f, -0.00113627f, 0.08089942f, -0.08067816f, -0.03291015f, 0.04490161f, 0.07605112f, 0.01801807f, 
    -0.00287518f, 0.05816228f, -0.09280677f, 0.01184847f, 0.35550267f, 0.38491657f, 0.17823836f, 0.12211934f, 
    0.08334798f, -0.06718197f, -0.04622024f, 0.24627666f, -0.05804832f, 0.02004488f, -0.00069951f, 0.05750857f, 
    -0.16355075f, 0.37657017f, 0.28427699f, 0.07862154f, -0.19042745f, 0.21999416f, 0.21325335f, 0.00662599f, 
    0.05225077f, -0.04171319f, 0.08626636f, -0.03068816f, 0.32789701f, 0.34883365f, 0.26125756f, 0.17079215f, 
    -0.00686403f, -0.06353986f, -0.01642778f, 0.22055720f, -0.02805330f, -0.03330776f, 0.00365551f, 0.07792015f, 
    -0.01366553f, -0.14998093f, -0.16335258f, 0.01311271f, 0.09979177f, 0.03342242f, -0.06443641f, -0.22382240f, 
    -0.00860630f, 0.03357217f, -0.04944098f, 0.05401019f, 0.48771566f, 0.02928121f, 0.00791983f, 0.22437991f, 
    0.01904516f, -0.03406639f, -0.05606049f, -0.03500472f, -0.04823994f, -0.01003200f, -0.04896993f, -0.09676571f, 
    -0.22668654f, 0.16704172f, 0.29499418f, -0.07369719f, -0.17230913f, 0.10108665f, 0.08011381f, 0.01100866f, 
    0.04997553f, -0.06151271f, -0.02709150f, -0.04661701f, -0.12536485f, -0.15401727f, 0.03650167f, -0.09507916f, 
    0.05493653f, -0.19310997f, -0.13955173f, -0.07632753f, 0.10270603f, -0.10185533f, -0.16902399f, -0.03490790f, 
    0.28912708f, 0.43195668f, 0.39533180f, 0.28448334f, 0.15933776f, 0.12167154f, -0.00360535f, 0.18285775f, 
    -0.03451455f, -0.03714979f, -0.01126138f, -0.02264249f, -0.14526114f, -0.22380736f, -0.09185578f, 0.01140845f, 
    0.04514012f, -0.01799002f, 0.00832224f, -0.01334177f, 0.01859989f, 0.00671160f, 0.02123843f, 0.08190316f, 
    -0.01517377f, -0.07532895f, -0.39385453f, -0.11052792f, -0.01027865f, -0.02572597f, -0.01364738f, -0.10344734f, 
    0.00000710f, -0.06763200f, -0.00557764f, -0.00200203f, 0.28433689f, 0.22990148f, 0.01900398f, 0.14489345f, 
    0.08854751f, -0.05826993f, 0.03196923f, 0.30550250f, -0.01151239f, -0.02393366f, -0.01701873f, -0.01035532f, 
    0.13495584f, -0.20868078f, -0.22591902f, -0.12456315f, 0.08505748f, 0.02107580f, 0.02701463f, -0.07704625f, 
    0.08941556f, 0.12933372f, -0.05406655f, -0.02166822f, 0.03567803f, -0.02661046f, -0.03357164f, 0.01202918f, 
    -0.02393911f, 0.04862173f, 0.08265328f, 0.18008435f, 0.05159813f, 0.03439182f, 0.02124386f, 0.01518017f, 
    0.24037337f, 0.37709752f, 0.38781109f, 0.26994976f, 0.13106911f, 0.24102442f, 0.05278449f, 0.18596907f, 
    -0.00901728f, -0.04692660f, -0.20516431f, 0.01405118f, -0.10400469f, -0.30210546f, -0.30781019f, -0.05082621f, 
    0.04787785f, -0.05109422f, -0.03291487f, -0.02626248f, 0.06994397f, 0.02651769f, 0.03885317f, 0.07876755f, 
    -0.13405868f, 0.27217516f, 0.25023103f, 0.04422632f, 0.01471462f, 0.02607982f, 0.04173429f, -0.00327257f, 
    -0.07624622f, -0.09707173f, 0.04421351f, 0.05716939f, -0.14113961f, -0.42875227f, -0.18164341f, -0.18442361f, 
    0.04263363f, 0.01628689f, -0.10358839f, 0.00761836f, 0.06709321f, 0.11712769f, -0.07251175f, -0.11210899f, 
    -0.01135121f, -0.26670697f, -0.04449278f, -0.04919429f, 0.03562926f, 0.04978743f, -0.00261574f, 0.03906903f, 
    0.09209805f, 0.09965445f, 0.02100287f, -0.05815747f, 0.07967834f, -0.02532979f, 0.02382065f, 0.01827062f, 
    -0.12760590f, 0.03788185f, -0.08556272f, 0.11707391f, -0.13653466f, 0.02646172f, 0.04476680f, -0.06808084f, 
    0.09805208f, -0.31373048f, -0.13009536f, -0.23040386f, 0.04288348f, 0.02901558f, -0.06669596f, 0.06162343f, 
    -0.01431052f, -0.05512002f, 0.00912870f, -0.15776983f, 0.06283171f, 0.40194994f, 0.39364529f, 0.35428476f, 
    0.11802753f, 0.05067112f, 0.21712238f, 0.01034018f, 0.09832410f, -0.00908155f, -0.07105830f, -0.04540594f, 
    -0.60171407f, -0.39177245f, -0.08270189f, -0.07630029f, 0.02757077f, -0.01880020f, -0.04976202f, -0.00976512f, 
    0.02634212f, 0.02525822f, 0.14374518f, -0.03030440f, 0.14080052f, -0.08477607f, -0.12463359f, 0.05851748f, 
    -0.13249779f, -0.07389635f, -0.01887105f, -0.16769332f, 0.07251372f, 0.05519086f, -0.00947871f, 0.11391444f, 
    0.17057468f, 0.34475094f, 0.12220591f, 0.12772946f, 0.16222146f, 0.20618427f, 0.06953482f, 0.12835351f, 
    -0.05973012f, -0.08132342f, -0.05329479f, -0.03176091f, 0.10452670f, 0.13658403f, 0.11329422f, 0.03310740f, 
    0.00239593f, 0.02922765f, 0.00579901f, -0.00180919f, -0.00811871f, -0.05375519f, 0.00569788f, 0.01580828f, 
    -0.25334376f, -0.28852010f, -0.20917764f, -0.23654160f, 0.02161850f, -0.04706258f, -0.10839457f, -0.04398289f, 
    -0.13953206f, -0.01249173f, -0.03625217f, 0.03808235f, 0.15792938f, 0.27121457f, 0.21903148f, 0.15163130f, 
    0.09663574f, -0.08353163f, 0.19011585f, 0.23797964f, 0.00041490f, -0.08089177f, 0.20805177f, 0.13143821f, 
    -0.02149971f, -0.06318705f, -0.45795029f, -0.03765323f, -0.02712143f, -0.01112701f, -0.15495175f, -0.17643386f, 
    0.11709058f, -0.01690460f, 0.15512590f, -0.21027449f, 0.35007462f, 0.46977368f, 0.20657758f, -0.11178721f, 
    0.18544739f, 0.26624709f, -0.03095212f, 0.06747694f, -0.02922367f, -0.06430026f, -0.04720702f, -0.00270178f, 
    0.12910068f, 0.32829818f, 0.29755351f, 0.13203166f, -0.02118309f, 0.23377971f, 0.07103072f, -0.06156510f, 
    -0.01988692f, -0.08188639f, -0.07154664f, 0.01442637f, 0.48277986f, 0.16950220f, 0.20792025f, 0.26388150f, 
    0.04390096f, 0.05063934f, 0.05745861f, 0.14696896f, 0.12314845f, 0.05738522f, 0.04031021f, 0.11283378f, 
    0.47517309f, 0.13657492f, 0.32905498f, 0.16404699f, -0.11497641f, 0.14775521f, 0.04389819f, 0.03483621f, 
    0.01314590f, -0.18109319f, -0.09871569f, -0.09195285f, -0.09263013f, 0.31467485f, 0.08797637f, 0.19092454f, 
    -0.07916746f, -0.07500534f, -0.00252656f, -0.07824846f, 0.02111083f, -0.06646618f, 0.02099709f, 0.04081737f, 
    -0.00439249f, -0.02107475f, 0.02757325f, -0.01523352f, -0.00884393f, -0.06206466f, -0.12009984f, 0.04698844f, 
    -0.06251100f, -0.06218819f, 0.01341157f, 0.09349856f, 0.16138485f, 0.09363062f, -0.11626201f, 0.14336197f, 
    -0.01139267f, 0.00116669f, -0.02166714f, -0.06446169f, 0.09206115f, -0.06815217f, -0.05663007f, 0.04761585f, 
    0.03342269f, 0.13130184f, -0.26474735f, -0.06086368f, 0.17962809f, -0.01828386f, -0.02996751f, -0.01101764f, 
    -0.32346758f, -0.04155697f, -0.14832132f, -0.14715628f, 0.27443138f, 0.33997339f, 0.18727046f, 0.12867551f, 
    0.05701601f, -0.09072515f, -0.04100304f, 0.03406697f, -0.00161953f, -0.25349849f, 0.02400227f, 0.08395820f, 
    0.17634512f, 0.01462931f, 0.16375199f, 0.17516732f, 0.07572380f, -0.04693395f, -0.25380719f, 0.19026831f, 
    -0.03940029f, 0.07304545f, 0.08511042f, 0.06672102f, 0.04012145f, 0.26878425f, 0.10303968f, 0.05356694f, 
    -0.04277186f, -0.22574133f, -0.03740000f, -0.02792652f, -0.04450530f, 0.08947596f, 0.17219189f, 0.07977031f, 
    0.04937837f, 0.01104627f, 0.10393361f, 0.09386595f, -0.02030554f, 0.07657907f, 0.11232659f, -0.05496915f, 
    -0.00202569f, 0.10691162f, 0.03439127f, 0.10850870f, -0.16403553f, -0.19455224f, -0.12432306f, -0.01479878f, 
    0.09335544f, 0.11700024f, 0.17036544f, 0.03418195f, 0.12484906f, 0.21698278f, -0.02982018f, -0.09222156f, 
    -0.06937978f, 0.00268044f, 0.11197929f, -0.10254958f, 0.09745915f, 0.07986859f, -0.05184897f, 0.17569070f, 
    -0.18964645f, -0.13401778f, -0.05971131f, -0.00459734f, -0.12354654f, -0.08457869f, -0.18249550f, -0.00192264f, 
    0.15769537f, 0.00670549f, 0.00759008f, 0.08442365f, 0.01534708f, 0.06092450f, -0.04557472f, -0.00349416f, 
    0.25192603f, 0.10542119f, 0.01846963f, 0.09094413f, 0.08396032f, 0.04822851f, -0.15288360f, 0.02867513f, 
    -0.03459656f, -0.27399594f, -0.20720114f, -0.14563179f, -0.10737447f, -0.06799493f, 0.04324502f, 0.20669229f, 
    0.03861761f, -0.01544833f, -0.00598384f, -0.02945999f, -0.02586628f, 0.05469235f, 0.13848595f, 0.04606221f, 
    0.23836651f, 0.31560189f, 0.06575490f, 0.17456487f, 0.02332567f, -0.18887010f, 0.20280385f, 0.01732061f, 
    -0.11315639f, 0.04719297f, -0.02372757f, 0.02766768f, -0.08897923f, 0.14442521f, -0.07265842f, 0.08310522f, 
    0.01741776f, 0.02914942f, 0.02942042f, 0.01864138f, -0.12898901f, 0.01026896f, -0.05847125f, -0.30743957f, 
    0.33381087f, 0.07351740f, 0.07760379f, 0.14063568f, 0.02281705f, -0.05558059f, 0.01199547f, 0.00002763f, 
    0.06331455f, 0.22449410f, -0.03578524f, -0.06441675f, -0.07028817f, -0.18697301f, 0.12538949f, 0.01449275f, 
    -0.09900334f, -0.10137905f, -0.11956427f, 0.06278694f, -0.02616205f, -0.07964084f, 0.08121381f, -0.19635414f, 
    0.13772988f, 0.09513953f, 0.03783837f, 0.22945918f, -0.19315229f, -0.02158870f, 0.08749346f, 0.02667843f, 
    0.06119711f, -0.09679149f, -0.05859848f, -0.06463908f, -0.05402598f, 0.04145151f, 0.03958915f, -0.31829107f, 
    0.07471716f, -0.12816772f, 0.02884678f, 0.21053809f, -0.09001867f, 0.02829305f, -0.01195781f, -0.26879597f, 
    -0.30104724f, -0.31431714f, 0.17602330f, 0.32744652f, -0.04815306f, 0.04594911f, 0.00120793f, -0.13654782f, 
    -0.16030790f, 0.10731743f, 0.12365854f, 0.26551363f, 0.30449226f, -0.15706462f, 0.17452314f, 0.15943770f, 
    0.06804087f, -0.08932766f, -0.07607639f, 0.18230376f, -0.15339765f, -0.15174289f, -0.21358231f, -0.20009039f, 
    -0.05857583f, 0.19181019f, 0.17530008f, 0.06285325f, 0.00774127f, -0.00026240f, -0.13291432f, 0.01706800f, 
    0.01694113f, 0.09061119f, -0.03215042f, -0.19161309f, -0.28720516f, -0.02203396f, 0.02538947f, -0.14755850f, 
    0.01762244f, 0.03922994f, -0.11362177f, -0.05343623f, -0.15232135f, 0.02218289f, -0.04785868f, 0.06416682f, 
    0.07185583f, 0.02560034f, -0.19008578f, -0.39157239f, 0.05540492f, -0.14667746f, -0.01709574f, -0.00851464f, 
    0.09140780f, 0.16567963f, 0.19897602f, 0.08152691f, 0.03058688f, 0.05994786f, 0.07000240f, 0.05562761f, 
    -0.01891110f, 0.12201694f, 0.07703733f, 0.15195215f, -0.03002823f, -0.16252930f, -0.24778260f, -0.32277325f, 
    -0.10766789f, -0.10156320f, 0.05901158f, -0.03944144f, 0.11481301f, 0.00996430f, 0.01321753f, 0.02674353f, 
    -0.10934110f, -0.10580184f, -0.08491609f, -0.23058936f, 0.25800401f, 0.03678084f, 0.24793500f, -0.22741929f, 
    0.09171571f, -0.00834482f, 0.04514782f, 0.10727717f, 0.02465069f, -0.20215657f, -0.20759663f, -0.21466421f, 
    -0.01598490f, 0.04278073f, 0.18754458f, 0.30193689f, 0.00032962f, -0.09444001f, -0.00271496f, 0.01966135f, 
    -0.04044205f, 0.00705490f, -0.08809125f, 0.17403327f, 0.19786161f, 0.07877735f, -0.15238710f, -0.16233931f, 
    0.11236584f, 0.08253798f, -0.03139106f, -0.03377996f, 0.08975533f, -0.10216050f, -0.10354178f, -0.07452119f, 
    0.04612191f, -0.03595987f, -0.02240742f, 0.04559007f, -0.03411081f, 0.04844291f, 0.06417753f, -0.04264657f, 
    -0.02214327f, -0.01101250f, 0.02609118f, 0.04467584f, -0.03607092f, -0.17792466f, 0.06096851f, 0.19827583f, 
    -0.06454889f, 0.02756347f, -0.14950149f, 0.11404679f, -0.25274891f, 0.11581659f, -0.10724752f, -0.12430505f, 
    -0.14839706f, -0.36816379f, -0.18337686f, 0.29191354f, -0.02566969f, -0.01203436f, 0.02094778f, -0.11620693f, 
    0.11144786f, 0.24500395f, 0.25007448f, 0.26061833f, 0.07784943f, 0.14656539f, 0.38496619f, 0.03984444f, 
    0.12528908f, -0.08090881f, 0.06153936f, 0.04000507f, -0.09233131f, -0.00602524f, 0.01818741f, -0.11327861f, 
    0.12642999f, -0.01163149f, 0.04738114f, 0.08017968f, 0.25164646f, 0.12648918f, -0.19211371f, 0.00333888f, 
    0.06684482f, -0.09208019f, -0.09645045f, -0.27708721f, -0.01392961f, 0.10083746f, 0.16925155f, 0.21622199f, 
    -0.06723548f, -0.10790693f, -0.10903891f, -0.02703027f, 0.13258672f, 0.08201993f, 0.02094894f, -0.04207048f, 
    -0.24374521f, 0.27483311f, -0.11634161f, -0.12284596f, -0.02789651f, 0.09521831f, -0.16281316f, 0.16989736f, 
    -0.08586625f, 0.08696669f, -0.11311940f, -0.03106406f, 0.13657218f, -0.06050003f, 0.24854361f, 0.09500802f, 
    -0.10163219f, -0.03679500f, 0.00245365f, -0.12788905f, 0.09484838f, -0.08321126f, 0.15208226f, 0.19296390f, 
    -0.06666794f, -0.16504779f, -0.13836762f, 0.27358139f, 0.05871582f, -0.05712751f, -0.24394228f, 0.00705162f, 
    -0.03587563f, 0.15831442f, 0.13527168f, 0.27519962f, 0.05063938f, -0.11086377f, 0.14758301f, -0.06530762f, 
    -0.05148423f, 0.15394196f, -0.15801951f, -0.05926383f, -0.16756703f, 0.00830403f, 0.00920365f, 0.03617306f, 
    -0.10145810f, 0.01206935f, 0.07909224f, 0.11107388f, -0.07403647f, 0.03837529f, -0.08109561f, 0.17482330f, 
    -0.04627630f, -0.10529958f, 0.03705591f, -0.09486374f, 0.22548769f, -0.13578296f, -0.17761356f, 0.18077029f, 
    -0.03234016f, 0.00912279f, -0.06283841f, 0.08247092f, -0.18757631f, -0.16852078f, -0.13278991f, -0.14148800f, 
    -0.13141651f, -0.01436237f, 0.06090435f, -0.03571888f, -0.03674557f, 0.00663509f, -0.11855639f, 0.01628741f, 
    0.11212878f, 0.24192107f, 0.05776320f, 0.04151085f, 0.00605679f, 0.04345337f, 0.07213251f, 0.10039321f, 
    -0.03710646f, 0.11730397f, -0.05839705f, 0.08493363f, -0.00696451f, 0.10530144f, -0.01695977f, -0.22380458f, 
    -0.27841687f, 0.05845373f, -0.20719598f, -0.26568127f, 0.06553970f, 0.08822636f, 0.02097505f, 0.08940434f, 
    0.02627807f, 0.07532435f, -0.01160378f, -0.03654547f, -0.05729177f, 0.07345310f, -0.01331767f, 0.06185485f, 
    0.23410033f, 0.05117131f, 0.03450795f, 0.07343765f, -0.04280567f, -0.10443014f, -0.21833178f, -0.19342203f, 
    -0.08851811f, -0.02478565f, 0.16194351f, 0.18162593f, 0.00887113f, 0.11018559f, 0.00748165f, 0.03447342f, 
    0.01640541f, 0.07528535f, 0.00385313f, 0.11265129f, 0.18729110f, 0.24253578f, 0.22293842f, -0.10353965f, 
    -0.01239766f, 0.10046855f, 0.02350111f, 0.00319742f, -0.03608851f, -0.07322522f, 0.09921478f, 0.02684415f, 
    0.40514529f, -0.12916014f, -0.09259903f, 0.03774877f, 0.12558825f, -0.18190143f, -0.00818359f, -0.08821331f, 
    0.08232563f, -0.02933744f, 0.22973062f, 0.24568984f, 0.05360708f, -0.15522282f, -0.17582639f, 0.04014190f, 
    -0.09313469f, 0.02124846f, -0.02153903f, 0.08862551f, 0.24075517f, -0.03164537f, -0.01266030f, 0.30211172f, 
    -0.12716740f, -0.02669129f, 0.13132414f, 0.00934745f, -0.00737083f, -0.00817627f, 0.07933339f, -0.08319759f, 
    0.03437793f, 0.00607540f, 0.02597320f, 0.04795558f, -0.01077456f, -0.03311032f, -0.02359509f, 0.14805043f, 
    0.01533889f, 0.14955388f, -0.15446067f, -0.00444086f, 0.19387634f, 0.01568053f, 0.10862391f, 0.04906725f, 
    -0.11742955f, -0.04307863f, -0.14508332f, 0.01706952f, -0.04631022f, 0.04920271f, -0.00704137f, 0.20023739f, 
    -0.01890088f, -0.01168825f, -0.05506285f, 0.15186810f, 0.00626665f, -0.15915900f, 0.08160008f, 0.15888624f, 
    -0.06534617f, 0.12626371f, -0.17332056f, 0.03348595f, 0.04998363f, -0.17917638f, 0.03779712f, -0.13724560f, 
    -0.16626009f, -0.04412188f, -0.18936765f, 0.00808618f, 0.02135373f, -0.00053838f, -0.05672063f, -0.18418531f, 
    0.07870323f, -0.08867659f, -0.08797367f, 0.28600934f, 0.13508813f, 0.26208523f, 0.20684035f, -0.33095664f, 
    -0.11535620f, 0.04789304f, -0.13281684f, 0.04119879f, -0.01869467f, 0.01392478f, 0.00501116f, -0.19011997f, 
    -0.00640020f, 0.02413483f, 0.11352286f, 0.23937346f, -0.07464168f, -0.06337343f, -0.00590259f, 0.02145499f, 
    0.07382239f, 0.01157468f, 0.03426468f, 0.10978748f, -0.01143975f, -0.02192615f, 0.16962995f, 0.03541084f, 
    0.06058352f, 0.09523578f, 0.09107271f, 0.17548102f, -0.11399055f, -0.09876329f, -0.14436974f, -0.40371138f, 
    -0.10127331f, 0.09869050f, 0.04451466f, -0.13854007f, 0.02890216f, 0.01795814f, -0.02552301f, -0.05362265f, 
    0.15041384f, 0.29953668f, 0.16570878f, 0.38973606f, -0.06263971f, -0.18006462f, -0.08546560f, 0.16449717f, 
    0.11484206f, 0.08393748f, -0.00924019f, -0.06169442f, 0.09956056f, 0.06278267f, 0.11343606f, 0.13759167f, 
    -0.01239143f, 0.07482356f, -0.23115098f, -0.09053788f, -0.10204595f, 0.12228733f, -0.09626900f, 0.03619627f, 
    0.07068487f, 0.16574101f, 0.02782035f, 0.22671662f, -0.18081696f, -0.15108772f, 0.19281983f, 0.34093311f, 
    -0.17425077f, -0.12978487f, 0.02162456f, 0.06565789f, 0.00888752f, -0.05248595f, 0.02981633f, 0.18756823f, 
    0.03850743f, -0.04731720f, 0.15476152f, 0.05812682f, 0.05677804f, 0.07606369f, -0.11958256f, 0.11726063f, 
    0.09254058f, -0.08468598f, 0.03308813f, -0.14356777f, -0.02140935f, 0.13049959f, 0.18089306f, 0.19362764f, 
    -0.00075432f, -0.12991455f, 0.04329082f, -0.02115560f, 0.00971133f, 0.07844644f, 0.11507735f, 0.35170603f, 
    -0.18751298f, -0.00832268f, -0.13471664f, 0.05530434f, -0.14456789f, -0.17538168f, -0.14615089f, 0.03513500f, 
    -0.15726335f, 0.00551315f, 0.00075935f, -0.03189087f, 0.11575286f, -0.22114538f, -0.20182972f, -0.01672653f, 
    -0.04107562f, 0.09635311f, -0.13681169f, 0.03345735f, -0.01714373f, 0.07926065f, 0.14179741f, 0.12870318f, 
    0.11799822f, -0.11570273f, 0.03380284f, -0.05617752f, -0.15196839f, 0.22156157f, 0.03180215f, 0.03394783f, 
    -0.05176473f, -0.07079926f, -0.07327357f, 0.02436706f, -0.21452837f, 0.09633100f, 0.32362056f, 0.10527457f, 
    -0.01030972f, 0.00014030f, -0.12728046f, -0.01896791f, -0.13428235f, -0.08277769f, 0.01415145f, 0.08486512f, 
    -0.18633316f, -0.14263874f, -0.02987373f, -0.13704614f, -0.23293096f, 0.03887970f, -0.08733999f, -0.05486614f, 
    0.20326202f, 0.01089981f, 0.13319978f, 0.19394776f, -0.35042199f, 0.00418729f, 0.03605764f, -0.22366425f, 
    0.01075962f, 0.12861760f, 0.29674426f, -0.15222794f, -0.09568372f, 0.18864797f, -0.05740220f, 0.04535209f, 
    -0.19337153f, 0.30992573f, -0.11922839f, -0.25740692f, 0.18314154f, 0.01355102f, 0.14399430f, 0.11875044f, 
    -0.04417598f, -0.07750867f, 0.02133823f, -0.21395682f, -0.09984425f, -0.13067357f, -0.10819697f, -0.21794970f, 
    0.09148563f, 0.11717260f, -0.11196278f, 0.05703378f, -0.08276287f, -0.04120664f, -0.01477219f, -0.09513196f, 
    0.19679810f, -0.02459470f, -0.22531554f, -0.08439584f, 0.03027256f, -0.02632564f, 0.15008052f, 0.18494937f, 
    0.00015033f, -0.00127414f, -0.03414109f, -0.04514723f, -0.11483350f, -0.12103993f, -0.13490264f, -0.05917642f, 
    -0.20167395f, -0.08457994f, -0.23743321f, -0.33344620f, 0.06964790f, -0.02906635f, 0.16064960f, 0.00853800f, 
    0.01393682f, -0.09713925f, -0.08834725f, -0.08407409f, -0.05731735f, 0.15042067f, 0.11360978f, 0.03556690f, 
    0.04340505f, 0.12781279f, -0.00429698f, 0.17161362f, -0.09831946f, -0.14562251f, -0.08633356f, -0.00634742f, 
    -0.26479575f, -0.05769793f, -0.12750928f, -0.22897553f, 0.14476775f, 0.14416464f, 0.16240735f, 0.16572012f, 
    -0.26768711f, 0.06440899f, 0.05502439f, 0.10121865f, -0.21099098f, 0.02808969f, 0.11675736f, -0.21576768f, 
    -0.02915705f, 0.13962336f, 0.02054746f, 0.05268251f, 0.22084576f, 0.24912372f, -0.00882087f, -0.12868312f, 
    0.16414973f, 0.08101896f, 0.04820286f, -0.08540564f, 0.02220485f, -0.04640688f, -0.09589863f, 0.08445302f, 
    -0.30510333f, -0.04897840f, -0.07171578f, -0.32968163f, 0.06981395f, 0.19465698f, 0.01285412f, -0.09418146f, 
    0.06327498f, 0.14167736f, 0.23759675f, 0.03812615f, 0.19622980f, 0.05680157f, 0.05841078f, -0.02932982f, 
    0.04901202f, 0.14717500f, 0.03554559f, 0.26356280f, 0.12631775f, 0.13280882f, 0.09761949f, 0.38687399f, 
    -0.18087342f, 0.20069051f, -0.08133624f, 0.08046373f, 0.00907861f, -0.11070823f, -0.03152564f, 0.06993686f, 
    0.03783261f, -0.12419765f, 0.02457812f, -0.10068892f, 0.12955727f, 0.07505252f, -0.21885352f, 0.22030254f, 
    -0.06158410f, -0.02099314f, -0.05319088f, -0.01369816f, 0.01933073f, 0.00861606f, -0.03285098f, 0.06138428f, 
    0.05548177f, 0.13753372f, 0.11085965f, -0.12029494f, 0.10436846f, 0.13435428f, -0.05427295f, 0.00269342f, 
    -0.03916699f, -0.04973563f, 0.08151313f, 0.02881509f, 0.31358436f, 0.17179981f, 0.25348771f, 0.39136621f, 
    0.02337935f, 0.16986223f, -0.12734686f, 0.01940558f, 0.20537834f, -0.14349698f, 0.23948905f, 0.13964276f, 
    0.18191254f, -0.00919276f, 0.00426862f, 0.12231379f, 0.11391406f, -0.06101872f, -0.07394559f, -0.01846554f, 
    0.27784610f, -0.06328334f, -0.05907100f, -0.08599461f, 0.05707105f, 0.27569142f, -0.27412513f, 0.41007823f, 
    -0.17735659f, 0.06386770f, 0.06755181f, 0.01701041f, 0.11157901f, 0.03785667f, 0.15107439f, 0.09010472f, 
    0.05736455f, -0.22530650f, -0.03919950f, -0.25415480f, -0.03359308f, 0.05203629f, 0.09027901f, 0.11780661f, 
    -0.08719409f, 0.09191231f, 0.11265876f, 0.11003621f, 0.10410093f, -0.14495485f, 0.16650021f, -0.13859408f, 
    0.00857884f, 0.07989962f, 0.09742846f, 0.00082136f, 0.21962760f, 0.20080762f, 0.02576995f, 0.17341363f, 
    -0.53111720f, 0.00692847f, 0.31656906f, 0.04637000f, 0.00949998f, 0.04389208f, -0.07763059f, -0.20414186f, 
    0.08848018f, -0.11321985f, -0.05013507f, -0.04526914f, -0.07585774f, 0.00716702f, 0.02607653f, -0.19664130f, 
    0.10479390f, 0.13002425f, -0.13032153f, 0.05388338f, 0.05226965f, 0.02301715f, 0.19472429f, 0.05159499f, 
    0.00796315f, 0.06512918f, 0.00838255f, 0.16338275f, -0.14356075f, -0.08198711f, 0.03365256f, -0.08025859f, 
    0.09844000f, 0.12382728f, 0.06220113f, 0.09829944f, 0.07183367f, -0.13630919f, -0.01091257f, -0.06422283f, 
    -0.06181563f, 0.13880312f, 0.18281291f, 0.12831469f, -0.15864260f, 0.22747126f, 0.10482459f, 0.18715852f, 
    0.18200767f, -0.05324236f, -0.02823956f, -0.18686812f, 0.03656415f, 0.00623503f, -0.03631992f, -0.11692515f, 
    -0.01422971f, -0.00889937f, 0.09620406f, -0.04842856f, -0.02413524f, -0.26795119f, 0.17565921f, 0.08843628f, 
    -0.04512471f, 0.01583998f, 0.07534436f, 0.06134264f, -0.06858044f, 0.12293287f, -0.02070974f, 0.11703187f, 
    -0.07430209f, 0.11782899f, 0.11191169f, -0.00649299f, -0.09758481f, -0.10466842f, -0.19538292f, -0.13163617f, 
    -0.10064258f, 0.02716522f, 0.07151727f, -0.07202021f, 0.25302717f, 0.31496245f, 0.02926430f, -0.11014236f, 
    0.13692312f, 0.22165553f, 0.15268981f, 0.05683921f, 0.26945052f, -0.14070243f, 0.04217141f, -0.10506453f, 
    -0.05306745f, 0.05553545f, -0.04529906f, -0.05675487f, 0.09063441f, -0.03354696f, -0.13029766f, -0.05529669f, 
    -0.21520667f, -0.29796055f, -0.22773439f, -0.20093636f, 0.30672270f, 0.34395090f, 0.00032452f, -0.10949175f, 
    -0.03951964f, -0.01329920f, -0.01207443f, 0.18317367f, 0.04981694f, -0.06457495f, 0.07086018f, -0.01841346f, 
    -0.13625510f, 0.36534014f, -0.18254904f, 0.02196035f, 0.07676658f, 0.05636806f, 0.19826397f, -0.04383246f, 
    0.03609468f, -0.02549173f, -0.02234272f, 0.22361092f, 0.07118369f, -0.05263013f, -0.18886954f, -0.15254058f, 
    0.05282330f, -0.10240960f, 0.00839110f, 0.22334908f, -0.11553585f, -0.00116898f, -0.02411987f, -0.02341853f, 
    -0.01987114f, -0.30349723f, 0.08608076f, -0.17904790f, 0.03305838f, 0.10071098f, 0.08113609f, 0.00119313f, 
    0.16648516f, 0.12502779f, 0.07794950f, 0.17735811f, 0.07604396f, -0.27947944f, -0.21037085f, 0.01760099f, 
    0.08647903f, 0.08951163f, 0.13554429f, 0.12028956f, -0.04400343f, -0.11365362f, -0.24099167f, -0.14373577f, 
    -0.20723324f, 0.21950747f, 0.07161821f, 0.01493868f, 0.19206765f, 0.11608379f, 0.23332198f, 0.21857305f, 
    0.10680281f, -0.03738355f, -0.04284286f, -0.03956763f, -0.01937217f, -0.07849037f, 0.19640943f, 0.00150688f, 
    -0.04331740f, -0.03794142f, 0.32317102f, -0.03125599f, 0.22825223f, 0.10089085f, -0.11212014f, 0.23476021f, 
    0.14271057f, 0.12679514f, -0.01109346f, -0.16446564f, 0.16349778f, 0.00253065f, 0.00582125f, -0.03078316f, 
    0.01518320f, 0.13027059f, 0.00263443f, 0.03742924f, -0.09157458f, -0.10870656f, -0.08356036f, -0.12241444f, 
    -0.15960279f, 0.02360468f, -0.10810285f, -0.10257010f, 0.12537248f, 0.12033322f, 0.04560208f, 0.12685145f, 
    0.13310641f, 0.06837370f, 0.08267841f, 0.03771317f, -0.05410529f, 0.01035698f, 0.06042375f, -0.08426914f, 
    0.11537793f, -0.32084075f, -0.07061656f, 0.06356262f, 0.09684053f, 0.01417419f, 0.01250029f, -0.20805232f, 
    0.02103448f, 0.13902137f, 0.19566372f, 0.16285808f, -0.00720203f, 0.03723663f, 0.02262559f, 0.01842303f, 
    0.31217119f, -0.17833218f, 0.17004047f, 0.05659141f, -0.23352104f, -0.02825663f, -0.15290050f, -0.02859079f, 
    -0.00694120f, -0.07068659f, 0.06828539f, 0.25277296f, 0.00044348f, -0.00314791f, -0.03420527f, -0.20722118f, 
    -0.04672524f, 0.04883151f, 0.12854023f, 0.12994787f, 0.04491326f, 0.15398778f, 0.22650447f, 0.11579727f, 
    0.25894502f, 0.15950762f, -0.13526590f, -0.20580049f, 0.13829754f, 0.04766565f, 0.06587275f, 0.06560536f, 
    0.04217740f, -0.00635811f, -0.08805513f, 0.04619058f, 0.12749802f, 0.08555054f, -0.13985765f, -0.09595376f, 
    -0.12865837f, -0.20849375f, -0.17949276f, -0.12584379f, -0.06648554f, 0.17225207f, 0.00767100f, -0.21788760f, 
    -0.31779334f, 0.38010770f, 0.14971392f, 0.00047981f, 0.12698542f, 0.01432711f, 0.03948854f, 0.13193043f, 
    0.00089771f, -0.02030842f, -0.08763994f, -0.12739941f, -0.18248624f, 0.09856885f, 0.03877015f, 0.18176194f, 
    -0.00609839f, -0.24066702f, -0.02621055f, -0.05991779f, -0.23828354f, 0.00300927f, -0.05641944f, -0.02988487f, 
    -0.11797213f, -0.06518822f, -0.04668991f, -0.17220825f, -0.09423096f, -0.00677980f, -0.04891384f, 0.02464501f, 
    0.12274012f, 0.04038367f, 0.26777247f, 0.04963287f, -0.29808602f, 0.04003661f, 0.05037714f, -0.09642637f, 
    0.05320992f, -0.05893985f, -0.03035707f, 0.12236369f, -0.10828447f, -0.05330508f, -0.16710657f, -0.05425578f, 
    -0.07412603f, 0.15117794f, 0.21024425f, 0.24696466f, -0.05543333f, -0.07504356f, -0.14119972f, -0.18817927f, 
    -0.01745442f, 0.05925086f, -0.00432073f, 0.23316848f, -0.00087845f, 0.33192155f, 0.13676724f, 0.06631349f, 
    0.13075159f, 0.04807171f, 0.27528936f, -0.08028273f, 0.10186727f, 0.04746151f, -0.02084268f, -0.04531917f, 
    -0.07763100f, 0.01868591f, 0.29533237f, -0.00286448f, -0.19457662f, 0.00945748f, -0.14931428f, -0.08467838f, 
    -0.16947801f, 0.05045148f, 0.06517318f, -0.13791300f, 0.05447979f, -0.32670796f, 0.14114551f, 0.39053002f, 
    0.08283027f, 0.03476972f, 0.14459188f, -0.00690977f, 0.02023994f, 0.08084241f, -0.07896722f, 0.16214140f, 
    0.24916989f, 0.17199561f, -0.02028709f, -0.06789547f, 0.13586466f, 0.12745354f, 0.02150127f, 0.13677771f, 
    -0.09182678f, -0.05826637f, -0.01028915f, -0.12848911f, 0.06763498f, 0.00362743f, 0.00928761f, -0.09706283f, 
    0.14823112f, 0.18460140f, 0.09663779f, -0.05936965f, 0.09410904f, 0.04325339f, 0.14334017f, 0.36269116f, 
    0.14286444f, -0.27674931f, 0.02803623f, -0.04099647f, -0.05899229f, -0.02700275f, -0.14925133f, -0.09755503f, 
    -0.06706724f, -0.31489646f, -0.20735303f, -0.22804576f, 0.15698290f, 0.29850182f, 0.06866390f, -0.17353217f, 
    0.09720086f, 0.05213819f, -0.13217288f, 0.13453928f, -0.08585876f, -0.07480198f, -0.10915857f, -0.08949184f, 
    0.10132677f, 0.09638232f, 0.21531315f, 0.08265542f, 0.08624074f, 0.01596658f, 0.12002812f, 0.02919630f, 
    0.24336594f, 0.05668329f, 0.08476155f, -0.09569052f, 0.42323214f, 0.42952517f, 0.06503819f, -0.16087864f, 
    0.13374653f, 0.15761121f, -0.02747692f, -0.04902131f, -0.02998613f, -0.06693436f, -0.09772208f, -0.24912138f, 
    0.14895327f, 0.12228741f, -0.08405749f, 0.03118395f, 0.10219603f, 0.17741419f, 0.13064730f, -0.09222376f, 
    -0.07952966f, 0.09477426f, -0.09768008f, 0.07283463f, 0.24730918f, 0.04319940f, -0.06984445f, -0.13771585f, 
    0.12120172f, 0.16307035f, -0.03970638f, 0.13126427f, 0.04606967f, -0.10183635f, -0.17527765f, -0.24435721f, 
    -0.00583998f, -0.01588536f, -0.00348314f, 0.00227864f, -0.03246693f, 0.00874410f, 0.02819798f, 0.01960891f, 
    -0.02021387f, -0.03405479f, 0.02182240f, 0.01111845f, -0.01001518f, -0.03135763f, 0.01028647f, -0.00130753f, 
    -0.03921754f, 0.01091288f, -0.02084139f, -0.01894198f, -0.03853496f, 0.02701492f, -0.01676407f, 0.01517986f, 
    -0.01196413f, -0.01226887f, -0.01231314f, -0.00635855f, 0.02173802f, -0.01328168f, 0.01340833f, -0.01452635f, 
    -0.00255168f, 0.02932436f, -0.00797819f, 0.02727063f, -0.00302210f, -0.01461352f, -0.01339516f, 0.02292940f, 
    0.01984810f, 0.00769806f, -0.02169958f, -0.03409014f, -0.01816721f, -0.02755683f, -0.00574514f, 0.00453797f, 
    -0.01254306f, 0.00120377f, 0.02566537f, 0.03561638f, 0.02853765f, -0.00924766f, -0.00074442f, -0.01380494f, 
    0.02242059f, -0.01468059f, -0.00801926f, 0.00235290f, -0.04057258f, -0.00671723f, -0.03713961f, -0.03032155f, 
    -0.01927196f, -0.00432261f, -0.03354623f, 0.01312935f, -0.00867181f, -0.03198380f, -0.03319623f, 0.02893536f, 
    -0.01551169f, -0.02397544f, -0.00613695f, 0.01344491f, 0.00140628f, -0.00391995f, -0.04170581f, -0.00076162f, 
    -0.03822109f, 0.01114145f, 0.02041915f, -0.00665611f, 0.01858091f, 0.00795384f, -0.00270966f, -0.03568897f, 
    -0.01061095f, -0.02286743f, 0.00706603f, 0.00849478f, -0.00378139f, -0.00248529f, 0.00634318f, -0.00475288f, 
    0.00178576f, -0.03932395f, -0.03378123f, 0.00224258f, -0.03214275f, -0.00514209f, 0.00932080f, -0.00545096f, 
    -0.00173160f, -0.02498315f, -0.01339917f, 0.01964476f, -0.02582317f, -0.01550487f, -0.01686136f, -0.02215477f, 
    -0.02682189f, -0.02324939f, -0.00013844f, -0.03885448f, -0.01983511f, 0.02457448f, 0.01768416f, 0.02520492f, 
    -0.01412919f, -0.00300043f, 0.01128025f, -0.00762582f, -0.01698327f, 0.02768916f, 0.01014912f, -0.01049534f, 
    -0.00433320f, -0.03589915f, -0.01695587f, -0.00616464f, -0.02894069f, 0.02640881f, -0.01793843f, -0.01714168f, 
    0.02344562f, 0.01814057f, -0.02851977f, -0.01976183f, -0.04006515f, -0.01633264f, -0.02359931f, 0.02661981f, 
    -0.03428507f, 0.01928512f, -0.00960916f, 0.03005932f, -0.01598624f, -0.00732386f, -0.00833771f, -0.01498334f, 
    -0.01041959f, 0.00639619f, -0.00380956f, 0.00480842f, -0.03259645f, 0.00960903f, -0.03129042f, -0.01715411f, 
    -0.02640941f, -0.01720415f, -0.01696346f, -0.02988280f, 0.00965064f, -0.02063817f, 0.01923016f, -0.02672297f, 
    -0.00114859f, -0.00266992f, 0.02911079f, -0.03058202f, -0.03036978f, -0.00704221f, -0.04170484f, 0.02354762f, 
    -0.01288501f, -0.00930287f, -0.02937073f, -0.01417146f, -0.03642390f, -0.01230058f, -0.03574096f, -0.03469047f, 
    -0.02393645f, -0.03748352f, 0.01281910f, -0.00668637f, -0.00797606f, 0.02443545f, -0.03976507f, -0.03696733f, 
    0.00064987f, -0.00787160f, 0.00301965f, -0.00924037f, -0.01135520f, -0.03800629f, 0.01503438f, 0.00470331f, 
    -0.03105795f, -0.02829514f, 0.00608340f, -0.02808683f, -0.01478401f, 0.01610311f, -0.01991275f, 0.00014391f, 
    0.01131946f, -0.02773618f, -0.02070629f, -0.00115458f, -0.02969589f, 0.00243707f, 0.00596832f, -0.00523121f, 
    0.00733639f, -0.00897946f, -0.03804969f, 0.01496706f, -0.01653017f, -0.00047727f, -0.02669714f, 0.02423049f, 
    -0.01653813f, -0.03468494f, 0.03074213f, -0.03439670f, -0.02040026f, -0.03695755f, -0.00412666f, -0.00001783f, 
    -0.01029894f, 0.02652903f, 0.00482539f, 0.02122066f, -0.00081822f, -0.01787822f, -0.03173494f, 0.02304260f, 
    0.03035629f, -0.00516916f, 0.02567721f, 0.01373861f, -0.03258256f, 0.02767694f, 0.00136817f, -0.01404927f, 
    0.01216037f, 0.02290262f, -0.02021815f, 0.00841915f, -0.02678022f, -0.00832051f, 0.00972634f, -0.02390699f, 
    -0.01830840f, -0.00687645f, -0.00463720f, 0.00344342f, -0.00580996f, -0.03405458f, 0.02836855f, -0.02486683f, 
    -0.02932121f, -0.01717603f, -0.03315572f, -0.00249125f, 0.00898087f, -0.00833845f, -0.01120020f, 0.01728183f, 
    0.02646289f, 0.00820298f, -0.03062486f, 0.00117881f, 0.02430276f, -0.04013094f, -0.03559950f, 0.01663785f, 
    -0.01298608f, -0.00563746f, -0.01832454f, -0.02361774f, 0.00361790f, 0.01735864f, -0.03786106f, 0.01644761f, 
    0.02944336f, 0.01103443f, 0.01323373f, -0.02406500f, -0.00969644f, -0.02258940f, -0.00264385f, 0.00555579f, 
    0.02085981f, -0.00734085f, 0.00237015f, 0.02791253f, -0.04055224f, 0.01987099f, -0.04009862f, 0.01951628f, 
    0.01710858f, 0.02603163f, -0.02750273f, -0.00030919f, 0.00962266f, 0.02354305f, 0.01982925f, -0.02395656f, 
    -0.00701718f, -0.01362800f, -0.03218073f, -0.01515275f, -0.02843049f, -0.03287846f, -0.03223557f, -0.01578229f, 
    0.00622701f, 0.02272946f, 0.02729800f, -0.01396848f, 0.00731322f, 0.00938763f, 0.01993576f, 0.01799329f, 
    0.00266324f, 0.02524346f, -0.02818011f, 0.01564819f, -0.00928629f, 0.02249485f, 0.02143558f, -0.00642480f, 
    -0.02453774f, 0.02984622f, -0.00369078f, 0.00930395f, -0.03755366f, 0.00800317f, -0.03073747f, -0.03869446f, 
    0.02857404f, -0.03945945f, -0.02393920f, -0.00827535f, -0.01558796f, -0.04179903f, -0.01632564f, -0.02976803f, 
    -0.02582803f, -0.03909958f, -0.02026150f, 0.02860443f, -0.01611996f, -0.03565557f, 0.01002018f, 0.00855516f, 
    -0.02505754f, -0.00694058f, -0.02137834f, 0.01374762f, 0.02532306f, -0.00131771f, 0.01975887f, 0.00258351f, 
    -0.00860685f, -0.04115448f, 0.02785807f, -0.00239517f, -0.02807666f, -0.01186287f, -0.00957908f, -0.01413321f, 
    -0.03834713f, -0.03019712f, -0.00105979f, -0.00210615f, 0.00460505f, -0.03766963f, -0.00788156f, -0.01131832f, 
    0.00938515f, -0.00625727f, -0.02420988f, 0.00780077f, 0.02919946f, -0.01349466f, -0.03070583f, -0.00414388f, 
    -0.00177185f, -0.00598699f, -0.03191721f, 0.01463529f, -0.01050504f, -0.00670577f, 0.02613397f, 0.01011996f, 
    -0.00063240f, -0.01650345f, 0.00033327f, 0.02079345f, -0.03162950f, -0.03754790f, 0.00923108f, -0.02208654f, 
    -0.00729214f, 0.02935045f, -0.03665318f, -0.02247343f, 0.01776539f, -0.02106262f, 0.00409639f, 0.00112421f, 
    0.02597580f, -0.01988995f, -0.00118915f, 0.02893886f, 0.02903174f, 0.01625491f, 0.01361877f, -0.04050910f, 
    -0.02475110f, -0.01585244f, -0.03750874f, -0.01676946f, 0.01390735f, -0.03837715f, 0.02508464f, -0.00812517f, 
    -0.00621097f, -0.00892909f, -0.03971319f, 0.01590459f, 0.02675646f, -0.00352869f, -0.01490762f, 0.01456633f, 
    -0.03929251f, -0.02171477f, -0.01157180f, -0.02367429f, 0.00768453f, -0.00338574f, -0.03283470f, 0.01184087f, 
    0.02358563f, 0.00317939f, -0.02976837f, -0.02086948f, -0.02478411f, 0.02229257f, 0.02739396f, -0.01106006f, 
    -0.02979289f, 0.02630210f, -0.03642508f, 0.02898020f, -0.04086459f, -0.02081218f, 0.02593573f, 0.00073354f, 
    0.02648107f, -0.02769663f, -0.02263951f, -0.03382924f, -0.00885820f, -0.01275993f, -0.01392542f, -0.03251640f, 
    -0.00847412f, 0.00979744f, -0.01406781f, -0.02347128f, 0.02584160f, -0.01008030f, -0.04052306f, -0.02218264f, 
    0.00296388f, -0.03654016f, -0.00492891f, 0.01651280f, 0.01665971f, -0.03006206f, 0.01330159f, 0.01177748f, 
    0.02281830f, 0.00094583f, -0.00418547f, -0.02350711f, -0.00232267f, -0.01459520f, -0.01796834f, 0.00528473f, 
    -0.02019705f, -0.01546973f, -0.02472381f, -0.00401768f, -0.02954034f, 0.02172469f, -0.04142082f, 0.02183462f, 
    -0.03581234f, 0.00691399f, -0.00731398f, -0.03926289f, -0.00176939f, -0.02121616f, -0.02590612f, -0.00782227f, 
    0.01909329f, 0.01676211f, -0.02527165f, 0.00397559f, 0.03601700f, -0.02192954f, 0.01369778f, -0.00899447f, 
    -0.00993801f, 0.02396982f, 0.01692815f, -0.04123371f, -0.00745566f, 0.01400505f, 0.02381115f, -0.03791611f, 
    0.01480079f, -0.00534195f, 0.02753533f, 0.01027892f, 0.01250814f, -0.01594673f, -0.00783417f, -0.03238649f, 
    -0.00021478f, 0.00073070f, -0.01637818f, -0.04094677f, 0.00712243f, 0.00720922f, -0.03316838f, -0.03364392f, 
    0.02453998f, 0.02711963f, 0.01615644f, -0.00670394f, 0.01998929f, -0.00318524f, -0.02083079f, -0.02659285f, 
    -0.01800470f, -0.02564802f, -0.01133716f, 0.00667549f, -0.01982069f, -0.03484138f, 0.01730869f, -0.02818747f, 
    0.00964456f, 0.02387732f, -0.01571885f, -0.01319396f, 0.02226279f, -0.02464437f, -0.02607328f, 0.01803384f, 
    -0.01336450f, 0.02678138f, 0.01594160f, -0.00980993f, -0.01545914f, 0.02418075f, 0.00767845f, 0.01045909f, 
    0.00086376f, -0.01959507f, 0.01524186f, 0.00222850f, -0.03188754f, -0.02326880f, -0.02180003f, -0.03713115f, 
    -0.03064528f, 0.01521407f, -0.02375223f, -0.02307813f, -0.03343580f, -0.00411101f, -0.01558584f, 0.01045792f, 
    0.01721451f, -0.01699002f, -0.00087372f, 0.03542186f, -0.03933949f, -0.00835693f, 0.01320830f, -0.01702642f, 
    -0.02670342f, 0.01245871f, 0.02293623f, -0.02518726f, -0.03719954f, 0.00689963f, -0.00012704f, -0.02049205f, 
    -0.01727909f, 0.02334174f, 0.01347437f, 0.00718142f, 0.01502789f, -0.00997575f, -0.02925850f, -0.03620758f, 
    -0.01950418f, 0.00095562f, -0.00053369f, -0.02343194f, 0.01769145f, -0.01897066f, -0.02497206f, 0.02309578f, 
    0.00288605f, -0.02710925f, -0.02863858f, -0.00588627f, 0.01352542f, 0.00751071f, 0.01146924f, -0.02114726f, 
    0.00073598f, -0.03115132f, -0.03506821f, -0.00561971f, -0.03927971f, -0.03956692f, -0.03643211f, -0.03220054f, 
    -0.00875472f, 0.00794268f, -0.02821144f, -0.03517720f, 0.00217086f, 0.01781110f, 0.02725493f, 0.00379383f, 
    -0.01776686f, -0.03901457f, -0.01744731f, -0.02274368f, 0.01841872f, -0.01866355f, -0.03555594f, -0.01501002f, 
    0.00202742f, -0.01992337f, -0.00435970f, -0.01819446f, 0.01712011f, -0.03564490f, -0.00528235f, -0.00391959f, 
    0.02302533f, 0.01969014f, 0.02978093f, 0.01396407f, 0.01501084f, 0.02789642f, -0.01822218f, -0.02403274f, 
    0.00213308f, -0.03848398f, 0.01004373f, -0.03567201f, -0.01134767f, -0.00303797f, -0.03059947f, 0.01850595f, 
    0.00644425f, -0.03250922f, -0.02953983f, 0.02384841f, 0.02206562f, 0.02604774f, -0.02236944f, -0.01639630f, 
    0.02942430f, 0.01878455f, 0.02545001f, -0.02160010f, 0.01494563f, -0.01319490f, -0.01808549f, 0.01409092f, 
    -0.01500678f, -0.02728705f, -0.03293821f, 0.01732075f, 0.02644700f, -0.01207433f, 0.01575745f, -0.00917998f, 
    0.01472538f, -0.02216314f, 0.02579769f, -0.02066024f, -0.03825535f, -0.03302464f, 0.01812513f, -0.02843100f, 
    -0.01783536f, -0.02901438f, 0.00319970f, -0.02125745f, -0.02921699f, 0.00370851f, 0.01434127f, 0.02854549f, 
    0.02363504f, 0.02104975f, -0.02499798f, 0.01784829f, -0.00937752f, 0.02993819f, -0.02479747f, 0.00533011f, 
    -0.02670686f, -0.03163759f, -0.03741559f, 0.00507400f, 0.01412563f, -0.01092856f, -0.02099781f, -0.03142567f, 
    0.00203945f, -0.01602011f, -0.04195886f, 0.00380353f, -0.02604313f, 0.01380907f, 0.00424956f, -0.03704895f, 
    -0.04059943f, -0.02670106f, 0.00638771f, 0.00170185f, -0.01487335f, 0.00286325f, -0.02039809f, 0.00259620f, 
    -0.03502868f, -0.02483538f, 0.00590730f, 0.01127048f, 0.00438534f, 0.01092651f, 0.00025681f, 0.00302792f, 
    0.02598117f, 0.00459453f, 0.01728799f, 0.00520018f, -0.02553993f, 0.02827836f, -0.01371226f, 0.02973010f, 
    0.00725727f, 0.00873910f, -0.00577610f, 0.02447866f, 0.02217750f, 0.02010357f, 0.01211328f, -0.03710813f, 
    -0.02529795f, -0.00212886f, 0.00874621f, -0.02018105f, -0.02202105f, -0.01239455f, -0.03690521f, -0.04030168f, 
    -0.02759207f, -0.00027903f, -0.02209555f, 0.00383953f, 0.02537650f, 0.00378691f, -0.04327540f, -0.01736086f, 
    -0.00587600f, 0.01769614f, -0.03394053f, 0.01104278f, -0.00606717f, 0.00807570f, 0.02227616f, -0.00493328f, 
    -0.01296809f, 0.02417613f, 0.00567573f, 0.00018681f, 0.01427439f, -0.01130667f, -0.02468648f, -0.00010217f, 
    0.02650012f, -0.03961749f, 0.00456449f, -0.00422000f, 0.01832953f, 0.00851501f, -0.01429148f, -0.03159264f, 
    -0.00806738f, -0.00652421f, -0.02064803f, 0.00383337f, -0.00404362f, -0.03022757f, -0.03370299f, 0.00286394f, 
    0.00836439f, -0.02819949f, 0.00412966f, 0.01901506f, -0.01638484f, -0.03658042f, 0.00904573f, 0.02069320f, 
    0.02712577f, -0.02626204f, 0.01102490f, -0.02110260f, -0.00457564f, -0.01152008f, 0.01666862f, -0.00912091f, 
    0.01467289f, 0.00545518f, -0.02507735f, 0.00377016f, -0.01277550f, -0.00700689f, 0.00080901f, -0.00055450f, 
    0.02185890f, -0.02194775f, -0.03543673f, -0.02573088f, 0.02055251f, 0.03126114f, -0.01597514f, -0.01975983f, 
    0.01133960f, -0.00685948f, 0.00278226f, -0.03732839f, -0.03362548f, -0.01781821f, -0.02722826f, 0.02849815f, 
    -0.01704473f, -0.01501599f, 0.01953146f, -0.02996924f, 0.01506429f, 0.01133172f, 0.00364698f, -0.00131142f, 
    0.02507091f, -0.00797822f, -0.01009102f, -0.00832679f, 0.00565577f, -0.00607380f, -0.03368828f, -0.00087708f, 
    -0.00174531f, -0.00558369f, -0.01964757f, 0.00224148f, -0.01941860f, -0.02798272f, 0.01987555f, -0.01359481f, 
    0.00725972f, -0.00456324f, 0.02591309f, -0.00628904f, 0.01635419f, -0.04221781f, 0.00156019f, -0.00826322f, 
    -0.03601765f, -0.03730627f, -0.01749377f, 0.02574664f, -0.02695446f, 0.00168606f, 0.01443030f, -0.02090224f, 
    -0.02135296f, 0.01182533f, 0.02360781f, -0.02083467f, -0.00128096f, -0.00045246f, -0.03485955f, -0.02849778f, 
    -0.02597756f, -0.03341535f, 0.00622660f, -0.02060377f, -0.01102102f, 0.00703614f, 0.01220873f, -0.01519119f, 
    -0.01085351f, 0.00854500f, 0.02057163f, -0.00509185f, -0.03778964f, -0.02879908f, -0.01337770f, -0.00340967f, 
    -0.00119578f, -0.01324487f, -0.00138958f, -0.00525459f, 0.03336578f, -0.02439784f, -0.00203496f, 0.02926134f, 
    -0.03617654f, -0.02609027f, -0.00745164f, -0.01193221f, 0.01330930f, -0.00818175f, 0.01897886f, 0.02819233f, 
    0.02965602f, -0.01363898f, -0.00429480f, 0.01820431f, -0.03631339f, 0.02618305f, -0.02889551f, -0.03859523f, 
    -0.04039886f, -0.02396203f, 0.02911965f, 0.00201259f, -0.01766001f, -0.01062222f, 0.00219087f, -0.00888710f, 
    -0.02663424f, 0.01387668f, 0.00458319f, -0.03829815f, 0.02607883f, -0.03549637f, -0.03533198f, 0.02968027f, 
    0.02168903f, -0.02916338f, -0.01009640f, 0.00779197f, 0.01894929f, 0.00781832f, 0.01023882f, -0.00327813f, 
    0.02573408f, 0.00461442f, -0.00386048f, -0.03994593f, 0.00163070f, -0.02459983f, -0.00118414f, -0.00917651f, 
    0.00642645f, 0.00636080f, 0.02939952f, 0.02521881f, 0.02933617f, -0.01980450f, -0.02471582f, 0.00941954f, 
    -0.02579125f, -0.02102248f, 0.01221951f, 0.02288252f, -0.00221727f, -0.01582841f, -0.00994706f, -0.03013919f, 
    -0.03476926f, -0.02876347f, -0.02187970f, 0.01864306f, 0.00750562f, 0.02351915f, -0.01917177f, 0.00158791f, 
    -0.00053971f, -0.00362081f, -0.00558395f, 0.03106350f, -0.00699534f, 0.01970572f, 0.00071887f, -0.02417477f, 
    0.00813008f, 0.01093318f, -0.00745604f, -0.02659504f, -0.03374995f, 0.00480353f, 0.00129411f, -0.01476808f, 
    0.00272994f, 0.00118395f, -0.01091013f, -0.01660974f, -0.01465490f, 0.01990478f, -0.01749023f, -0.03641991f, 
    0.00370842f, 0.01317994f, -0.00483772f, -0.04101040f, -0.03031547f, -0.02944091f, -0.00845822f, -0.03545948f, 
    0.00928489f, -0.02325405f, -0.01521988f, -0.02068385f, 0.01998851f, 0.01197956f, -0.01098832f, 0.01135969f, 
    -0.01820669f, 0.01440383f, 0.00447865f, -0.02621298f, 0.00093749f, -0.01705436f, -0.02447772f, 0.01941787f, 
    -0.03735564f, 0.01214736f, -0.01995060f, 0.01440927f, -0.01990322f, 0.02448381f, -0.03234688f, 0.00509563f, 
    -0.02319112f, 0.02600270f, 0.02625920f, -0.01211351f, -0.00200672f, -0.03955123f, -0.03448382f, -0.01585460f, 
    0.02005854f, -0.01923178f, -0.03194493f, -0.03435582f, -0.01048630f, -0.00908041f, -0.04228742f, 0.00853103f, 
    -0.02856076f, -0.01718657f, -0.03070714f, -0.03095376f, 0.00673171f, 0.00311242f, -0.02321364f, 0.00043627f, 
    0.00381501f, -0.01876703f, -0.02403759f, 0.02940057f, -0.00263371f, -0.03571972f, -0.00697631f, 0.00929578f, 
    -0.00015253f, -0.01053467f, 0.02795390f, -0.04137507f, -0.03014110f, -0.03818773f, -0.04336448f, -0.01761610f, 
    0.02010290f, -0.01131282f, 0.02437313f, 0.00734531f, -0.02775332f, 0.00929420f, 0.01036004f, 0.02287499f, 
    0.00405990f, -0.02614196f, -0.00490456f, 0.01563772f, 0.00466908f, -0.02533142f, -0.04104648f, 0.01080515f, 
    0.02331227f, -0.03445770f, -0.01293968f, -0.02594158f, 0.00520203f, 0.02376944f, -0.02597539f, -0.03194994f, 
    -0.02357610f, 0.00131069f, -0.00455524f, 0.02839820f, 0.02664017f, -0.02986442f, 0.00570846f, -0.02432335f, 
    0.02159886f, 0.01661183f, 0.01284912f, 0.02347202f, -0.01724895f, -0.02471566f, -0.04002923f, 0.00980149f, 
    0.01653044f, -0.03779512f, 0.02458922f, 0.00294412f, 0.01928014f, -0.03452425f, 0.02806526f, 0.02341026f, 
    -0.02423480f, -0.04109112f, -0.03564918f, 0.02000175f, 0.02885695f, -0.01949145f, 0.01329662f, 0.02826841f, 
    0.02201396f, -0.04173961f, 0.00908173f, -0.04060951f, 0.00594536f, -0.02924009f, 0.02661444f, -0.03517680f, 
    -0.04015745f, 0.02993051f, -0.02088223f, 0.01215149f, -0.00595481f, 0.02361701f, -0.02693988f, -0.00361897f, 
    0.02352800f, -0.02780633f, -0.03521501f, 0.02017262f, -0.03539157f, -0.01475938f, 0.02014447f, 0.01350070f, 
    0.02881076f, 0.01692264f, 0.01683067f, -0.03705386f, -0.02829308f, -0.00712236f, -0.00618719f, 0.00943558f, 
    -0.03733838f, -0.02801288f, -0.01420963f, 0.01831518f, 0.01976016f, -0.02205851f, 0.01486914f, 0.00212619f, 
    -0.04220846f, 0.00540605f, -0.03112931f, 0.01268410f, 0.01391279f, 0.02490791f, 0.01642293f, 0.02032589f, 
    -0.02539681f, -0.03416440f, -0.01449078f, 0.01414706f, 0.02318103f, -0.01818956f, -0.02724366f, -0.03027416f, 
    0.00774830f, 0.00902431f, -0.02366545f, -0.01222934f, -0.00750067f, 0.01910199f, -0.01670538f, -0.03827734f, 
    -0.00669154f, -0.03711957f, -0.00120534f, 0.00995793f, 0.00040746f, -0.01984084f, -0.03328353f, -0.02592550f, 
    -0.02528288f, -0.02883363f, -0.01968597f, 0.02900044f, 0.02628832f, -0.00204180f, -0.00352193f, 0.02458519f, 
    0.02749198f, 0.02234161f, -0.00842540f, 0.00851131f, -0.02997152f, 0.00315425f, -0.00819191f, 0.00376277f, 
    -0.04003988f, -0.01269024f, -0.01779788f, 0.01157691f, -0.03072423f, -0.01980724f, 0.02045608f, 0.00773132f, 
    -0.02542593f, 0.02659823f, -0.01803911f, 0.00684838f, -0.02176456f, 0.00950989f, -0.03358676f, -0.00637849f, 
    -0.01549944f, 0.02718479f, -0.00272455f, -0.01215369f, -0.00550231f, 0.01920941f, 0.01469062f, 0.01047448f, 
    -0.02704909f, -0.03299120f, -0.00798770f, -0.03346798f, -0.00229536f, 0.02031366f, -0.03974019f, 0.02407997f, 
    -0.00686826f, 0.03130243f, 0.00202030f, -0.02429808f, -0.00052125f, -0.02473979f, -0.01789140f, 0.00640883f, 
    -0.00092085f, 0.01698591f, -0.03115897f, -0.01927480f, -0.03431026f, -0.03988041f, -0.02139154f, -0.03961758f, 
    0.00423024f, 0.02241869f, -0.00029827f, -0.01122328f, 0.02657527f, -0.00118270f, -0.03831138f, 0.02223461f, 
    0.02837870f, -0.00035910f, -0.02049331f, -0.02067635f, -0.01208925f, 0.02481010f, -0.03736726f, -0.02911651f, 
    -0.03371434f, 0.00335652f, 0.00595892f, -0.01118664f, -0.00833747f, -0.01202172f, 0.00281356f, 0.00496201f, 
    -0.02396160f, 0.01745791f, -0.00699677f, 0.02432547f, -0.01676394f, -0.02694367f, 0.02804033f, 0.00368285f, 
    0.01282923f, -0.02151665f, -0.02977290f, -0.00928036f, -0.02980345f, -0.02302080f, -0.01476130f, 0.02240656f, 
    0.00652609f, 0.01070097f, -0.00680275f, -0.03446680f, -0.03750071f, -0.03041273f, -0.00332048f, 0.01817637f, 
    0.02454730f, 0.02545747f, 0.00097294f, 0.01105286f, 0.00911901f, -0.00793346f, 0.02256035f, -0.03987369f, 
    0.02430651f, 0.02101116f, -0.02981769f, 0.00705009f, 0.02434700f, -0.01037419f, -0.02806080f, -0.00098727f, 
    0.00644142f, -0.02115732f, -0.01828119f, 0.02410532f, -0.01425649f, -0.02978355f, -0.02352138f, 0.01019954f, 
    -0.01622909f, -0.03846042f, -0.02623362f, -0.03181656f, -0.00415963f, 0.01315281f, 0.00342788f, 0.00262527f, 
    -0.03354757f, 0.00684013f, 0.00455553f, 0.00681451f, -0.01021094f, 0.02734181f, -0.02909202f, 0.02566348f, 
    -0.01463646f, 0.01794495f, -0.02691029f, 0.00246100f, 0.02653906f, -0.00172730f, 0.00882549f, 0.01743204f, 
    0.00030316f, -0.03919669f, 0.02999168f, -0.02543393f, -0.02203804f, 0.02380465f, -0.03585634f, -0.00340642f, 
    -0.01608873f, -0.03446414f, -0.00208191f, 0.00034201f, -0.03089791f, 0.02101227f, -0.03840235f, 0.01338796f, 
    0.02341198f, -0.01959466f, -0.03844820f, -0.02316920f, 0.01618323f, -0.01327600f, -0.00483938f, 0.01781574f, 
    -0.01124611f, -0.03420424f, -0.04087303f, 0.00285773f, 0.00186775f, 0.01125303f, -0.02718653f, -0.04187281f, 
    -0.02348567f, -0.01448605f, 0.01480879f, -0.00845071f, -0.01489744f, 0.00186643f, -0.02232912f, -0.03833284f, 
    -0.03086638f, -0.03504648f, -0.01931724f, -0.00635857f, -0.00365369f, -0.01810124f, 0.00763352f, -0.02868886f, 
    0.00553351f, 0.02255690f, 0.02451413f, -0.01957371f, 0.00473232f, -0.01098709f, -0.03689532f, 0.00048193f, 
    0.01690481f, 0.02685726f, 0.01005322f, -0.01254214f, 0.00451619f, 0.02030185f, 0.00531127f, -0.00049570f, 
    -0.00813075f, -0.00105763f, -0.02845352f, -0.01657896f, -0.01796667f, 0.01017323f, -0.03963772f, 0.01636925f, 
    0.00485257f, -0.02089822f, -0.00377504f, -0.03029657f, -0.00041969f, -0.01990687f, 0.01568728f, 0.00303060f, 
    0.02729267f, 0.02984296f, -0.01662474f, 0.02277098f, -0.01767196f, 0.02759296f, -0.00371070f, -0.02649586f, 
    0.01804817f, 0.02457858f, -0.00340699f, -0.00990181f, -0.00094418f, -0.03061937f, 0.01668123f, 0.02256292f, 
    -0.03952565f, -0.02662839f, 0.01542093f, -0.03691928f, -0.03426545f, -0.03415705f, 0.00983484f, 0.02586813f, 
    0.01973820f, -0.00180126f, 0.01637830f, -0.03476442f, 0.02826747f, -0.03500329f, 0.00285672f, -0.02495683f, 
    -0.02100374f, -0.02103938f, 0.01593991f, 0.02076339f, -0.03889736f, 0.00471263f, -0.01467432f, -0.00599361f, 
    -0.03744040f, -0.02350001f, -0.00674499f, -0.02088483f, -0.02688782f, 0.00489219f, -0.01783375f, -0.01792401f, 
    -0.00877709f, 0.00787253f, 0.03164659f, 0.01784787f, -0.01948727f, 0.01462347f, -0.02920357f, 0.01580941f, 
    0.02395668f, -0.03147103f, -0.03448898f, 0.00320590f, -0.02460647f, 0.01528543f, -0.01470958f, 0.01005107f, 
    0.01581665f, -0.03324915f, 0.00480106f, -0.02459517f, -0.01265674f, -0.01462963f, 0.00276879f, -0.03442277f, 
    0.02743194f, 0.02638046f, -0.04094613f, -0.00461296f, 0.02984904f, -0.00765217f, -0.00257775f, -0.01053793f, 
    0.02580638f, -0.01479235f, 0.02268168f, -0.03729169f, 0.02865205f, 0.02564556f, -0.02222773f, 0.00342275f, 
    -0.01673642f, 0.01403960f, 0.01470365f, 0.02091356f, -0.00733608f, 0.00197710f, 0.00176863f, -0.00249906f, 
    -0.03901095f, -0.03027369f, 0.00774562f, 0.00239406f, -0.01703539f, 0.01717481f, -0.00238347f, -0.01517679f, 
    -0.03855913f, -0.01087123f, 0.02578321f, 0.01855965f, -0.00857647f, -0.01681663f, -0.00733794f, 0.00224102f, 
    -0.02547182f, 0.01685324f, -0.02895384f, -0.01257449f, -0.03935546f, 0.03092741f, -0.02403776f, -0.03249015f, 
    -0.03212705f, -0.00439608f, 0.01702914f, -0.01623710f, 0.00491714f, -0.00874015f, -0.03298392f, -0.02400307f, 
    -0.00082941f, 0.01540126f, -0.00153875f, -0.04032006f, -0.02168480f, 0.02986553f, -0.03512990f, 0.02526937f, 
    0.02953551f, -0.01623606f, 0.00504415f, -0.00404914f, 0.02620042f, 0.02365650f, 0.01228045f, 0.03857131f, 
    -0.01232434f, 0.00948522f, 0.00836901f, 0.02236465f, -0.01195140f, -0.00173576f, -0.00914487f, -0.03253393f, 
    0.00439900f, 0.01484377f, 0.03488638f, 0.00426351f, 0.02237777f, -0.04067935f, 0.00675586f, -0.01295103f, 
    -0.00223821f, 0.00040517f, 0.02794756f, -0.00467844f, -0.03319477f, 0.00004903f, -0.04035678f, -0.01657943f, 
    -0.04081134f, -0.01206862f, -0.03667451f, 0.02344947f, 0.02953419f, 0.04087874f, -0.01808346f, -0.00455253f, 
    -0.02781016f, 0.02539162f, -0.04154662f, 0.01878903f, 0.01426521f, -0.02820790f, 0.00098184f, -0.03381586f, 
    -0.03196181f, 0.02403100f, 0.02435067f, 0.01123309f, -0.02641317f, 0.01269441f, -0.01891972f, -0.02409604f, 
    0.02735967f, -0.03246051f, 0.02823506f, -0.02966827f, -0.01162927f, -0.02154313f, -0.02924841f, -0.00955519f, 
    0.00393596f, -0.01237063f, 0.01537318f, -0.01454308f, -0.01189344f, 0.00571902f, -0.00175970f, 0.01567964f, 
    -0.01831552f, -0.02200234f, 0.02771222f, 0.01517596f, -0.02914873f, -0.00786741f, 0.00532442f, 0.00049963f, 
    -0.02077539f, 0.00779107f, -0.00949815f, -0.03964508f, -0.00461126f, -0.00220478f, 0.01818168f, -0.03907602f, 
    -0.00905357f, 0.03365054f, -0.04094855f, -0.01992290f, 0.02124716f, -0.03759639f, -0.00893518f, 0.02300923f, 
    -0.01179815f, -0.03948820f, -0.02563225f, -0.02587733f, -0.02535224f, -0.00890557f, 0.02259876f, 0.01799090f, 
    -0.02542294f, -0.03390430f, -0.02805744f, -0.03389940f, 0.01877887f, -0.02105012f, -0.02976370f, -0.03568868f, 
    -0.01423008f, -0.00848749f, -0.03024736f, -0.00684591f, 0.01460712f, -0.01719225f, -0.00926715f, 0.01856994f, 
    -0.01513135f, -0.03059933f, -0.02551742f, -0.00366386f, -0.01716512f, -0.02898016f, 0.00640958f, 0.03363766f, 
    -0.02192305f, -0.00652750f, 0.02621319f, 0.02891736f, -0.01882377f, 0.02229165f, 0.02155343f, -0.01265439f, 
    -0.03601684f, -0.00070682f, 0.02709790f, 0.01448541f, -0.03286905f, 0.01625960f, -0.00339242f, 0.00486207f, 
    -0.02308738f, -0.02282081f, 0.02185168f, -0.03308585f, -0.00983019f, -0.04108771f, -0.02805209f, -0.01336853f, 
    0.00996758f, -0.04079344f, -0.00544963f, 0.02552550f, 0.01138224f, -0.02320754f, -0.01271484f, -0.03212119f, 
    -0.04097750f, 0.02546200f, -0.02961424f, -0.03289847f, -0.02811511f, -0.02619421f, -0.01206702f, -0.02685652f, 
    -0.00390384f, 0.03216056f, 0.02464869f, 0.02297530f, 0.01261900f, -0.02385700f, 0.00495708f, 0.02953919f, 
    -0.01721132f, 0.02702075f, 0.00029888f, -0.00868518f, 0.00915210f, -0.04141435f, -0.00554836f, -0.03915407f, 
    0.00986976f, -0.02607495f, -0.03415649f, 0.00749312f, -0.01692346f, -0.00057361f, 0.02094653f, -0.01936706f, 
    -0.01440302f, 0.01395930f, 0.02190053f, -0.00555830f, -0.01432736f, 0.00117384f, -0.02466570f, -0.03372543f, 
    -0.01547178f, 0.00239856f, 0.00676438f, 0.00904370f, -0.02850714f, -0.01494823f, 0.02772513f, 0.01338727f, 
    -0.03246638f, -0.02203732f, 0.00297089f, 0.00763187f, -0.01099275f, -0.00948216f, -0.00640620f, -0.03967213f, 
    0.02500334f, 0.01582664f, -0.01729373f, -0.02831173f, 0.02397023f, -0.00136426f, -0.00515294f, 0.00524352f, 
    0.02008854f, -0.01306093f, -0.01728147f, -0.02444871f, -0.01969681f, 0.00089354f, 0.00058277f, -0.00026746f, 
    -0.01304825f, -0.02094896f, -0.00190745f, -0.02296504f, 0.00172277f, 0.00225797f, 0.00318938f, 0.01313715f, 
    -0.01568922f, -0.02542695f, -0.01072261f, 0.01190255f, -0.02977886f, -0.02831157f, -0.00194657f, -0.00273519f, 
    0.02899675f, -0.01528129f, -0.00349603f, -0.03758087f, 0.01705731f, 0.03194883f, 0.00254687f, -0.02959473f, 
    -0.01420916f, 0.02252782f, -0.02226151f, -0.03697617f, -0.03289355f, 0.02329925f, 0.00760860f, -0.01343744f, 
    0.02570458f, 0.01274587f, 0.02807164f, -0.01063942f, 0.02170228f, 0.00212935f, -0.04178731f, -0.04023781f, 
    0.00070459f, 0.02802393f, 0.02709142f, 0.02216590f, -0.00141255f, -0.01772357f, -0.01370665f, -0.03484495f, 
    -0.02899681f, -0.00369822f, -0.02161497f, -0.02531699f, -0.03516181f, -0.03091015f, -0.03581600f, -0.00106973f, 
    0.00238768f, -0.00352367f, -0.01115377f, -0.01632169f, -0.00165630f, -0.01208863f, 0.00927845f, -0.02780348f, 
    -0.04088350f, -0.01229426f, 0.01645191f, 0.02011004f, -0.00263397f, 0.01385501f, -0.02971638f, -0.01820153f, 
    -0.02835391f, -0.00828322f, 0.02111592f, -0.01391329f, 0.01089746f, -0.02147158f, 0.01767787f, 0.00280377f, 
    0.04051634f, -0.02561023f, -0.00587477f, -0.02131262f, -0.00000830f, 0.01531480f, 0.00175004f, -0.01993586f, 
    0.02740449f, 0.02681771f, 0.00266182f, -0.01521598f, -0.00462043f, 0.01791949f, 0.04019596f, -0.00753689f, 
    0.00682710f, 0.02570807f, 0.01678723f, -0.00719795f, -0.00266471f, -0.02430923f, -0.01332605f, -0.03860474f, 
    0.04099208f, 0.02564512f, -0.01229688f, -0.01810700f, -0.01762514f, -0.02330119f, -0.01078260f, -0.04027469f, 
    -0.01470545f, 0.01054265f, -0.01395988f, 0.02951727f, 0.01946664f, -0.03592327f, 0.00848194f, -0.02575416f, 
    0.02525646f, -0.01021864f, 0.02220549f, -0.00225313f, 0.01650185f, -0.03062375f, 0.02362048f, -0.00825156f, 
    0.01677651f, -0.04102474f, -0.01136869f, -0.03582105f, -0.03920574f, 0.01182401f, -0.01468371f, -0.02148815f, 
    0.00838162f, -0.02931999f, -0.03180539f, -0.01616627f, 0.02518781f, -0.02928174f, -0.01504133f, 0.00368176f, 
    -0.02588846f, 0.01780559f, -0.01749106f, 0.00170732f, -0.00314237f, 0.01573905f, -0.01970746f, -0.01296310f, 
    -0.01720385f, -0.02920549f, 0.02131170f, 0.02813763f, -0.02620808f, -0.00262456f, 0.00663867f, -0.01420734f, 
    -0.01326386f, 0.00576621f, -0.00966222f, -0.02835642f, 0.01849988f, 0.02139406f, -0.03715228f, -0.03461238f, 
    0.01307381f, -0.04026024f, -0.02007288f, 0.02988461f, 0.00643609f, -0.01501759f, -0.03039654f, 0.01452002f, 
    0.01748936f, -0.00422543f, -0.00738473f, 0.01186744f, 0.02426374f, -0.03600673f, -0.00990570f, 0.02913510f, 
    -0.03863937f, 0.01784402f, -0.00240059f, -0.00384408f, -0.02679031f, -0.01118153f, 0.02258096f, -0.00659050f, 
    -0.02797363f, -0.02061349f, 0.01658845f, -0.03467488f, 0.01475339f, -0.03602668f, -0.00339419f, 0.02627638f, 
    0.00759561f, 0.00774588f, 0.01199744f, -0.01849460f, 0.04037745f, -0.00622401f, 0.01916059f, 0.01006792f, 
    0.02894091f, -0.01302026f, 0.02933709f, 0.01658843f, -0.02495185f, -0.02104087f, -0.00589956f, -0.03171005f, 
    -0.00013441f, -0.00565808f, 0.03968923f, -0.01465653f, -0.01768978f, -0.03110184f, 0.00459897f, -0.00470666f, 
    0.02215929f, -0.01981423f, 0.03924170f, -0.01462586f, 0.02608447f, -0.00973044f, -0.00164649f, 0.02858601f, 
    -0.00610787f, -0.03561297f, -0.01011996f, 0.00109202f, -0.03001224f, -0.02060294f, -0.02034342f, 0.01346431f, 
    0.02452816f, -0.00603251f, 0.01854487f, 0.00610776f, -0.03421832f, -0.02861032f, -0.00536931f, 0.02459715f, 
    -0.02821193f, -0.03780928f, -0.03737415f, -0.03955084f, -0.03497475f, -0.00763167f, -0.01520693f, 0.00006768f, 
    -0.01496476f, 0.01145079f, -0.02131711f, -0.04129846f, -0.02136665f, -0.00123719f, -0.00929052f, 0.00655697f, 
    -0.02406167f, -0.01690038f, 0.00200270f, 0.02290803f, 0.01908411f, 0.00067810f, 0.00682358f, -0.01203671f, 
    -0.04005457f, 0.00053862f, 0.02971265f, -0.03640736f, -0.01040586f, 0.02804677f, -0.02913087f, -0.02743390f, 
    0.03091611f, -0.02620025f, -0.02142196f, 0.02081871f, -0.00573122f, 0.00653664f, 0.02099475f, -0.04056258f, 
    0.01231227f, 0.01846772f, 0.00147413f, 0.01416356f, -0.00759275f, 0.02777519f, 0.00234954f, -0.02247682f, 
    0.02062353f, -0.00166935f, -0.02673460f, 0.02641492f, -0.00416582f, -0.00269417f, 0.00104134f, -0.03547239f, 
    -0.03241093f, -0.00382613f, -0.02603323f, 0.01097797f, -0.02366913f, -0.00801894f, 0.02519817f, -0.00401158f, 
    -0.00062035f, -0.00579864f, -0.02613225f, -0.03289157f, 0.00714598f, -0.03910730f, -0.02266145f, 0.01983944f, 
    -0.01542574f, -0.00096815f, -0.00510409f, -0.00112255f, 0.02074644f, 0.02769063f, 0.01743467f, -0.00959361f, 
    0.01789728f, 0.01057081f, 0.01394852f, 0.03688786f, -0.00805522f, -0.00505453f, 0.00141305f, 0.00127293f, 
    -0.00677021f, 0.02207312f, 0.00912929f, 0.01056719f, 0.03529777f, -0.01944946f, -0.01340887f, 0.02790632f, 
    -0.01810768f, 0.00272768f, 0.01745157f, 0.01088697f, -0.01181014f, 0.03271371f, -0.00037226f, -0.01698985f, 
    0.00767903f, 0.01390546f, 0.00641099f, -0.02185878f, -0.00206256f, 0.00685140f, 0.01839789f, 0.00097677f, 
    -0.03419822f, -0.00289283f, 0.01590328f, 0.02818503f, -0.01058713f, 0.02433257f, -0.04198619f, 0.01475640f, 
    -0.03145828f, -0.00710322f, -0.02355593f, -0.01925487f, -0.03681244f, -0.03315417f, -0.02203524f, -0.03398247f, 
    0.00410427f, -0.01763342f, 0.02196019f, 0.02355589f, 0.02770836f, 0.00583388f, -0.01154165f, -0.01257317f, 
    -0.02991384f, 0.00714382f, 0.01070621f, 0.02645535f, -0.01869667f, -0.01777731f, -0.02372756f, 0.02078285f, 
    0.02379258f, 0.03592807f, 0.02273561f, 0.02909605f, 0.01324492f, -0.02597841f, 0.03987854f, 0.02158394f, 
    0.02699254f, 0.00125226f, -0.01170824f, -0.02001953f, -0.02979407f, -0.00986026f, -0.00317513f, 0.01311960f, 
    0.00301800f, -0.00134793f, 0.00884597f, -0.01729682f, -0.00493484f, 0.01553333f, 0.02468255f, -0.01723068f, 
    0.02992672f, 0.01808014f, -0.00509851f, 0.02149544f, -0.01248272f, -0.01060094f, -0.00478131f, -0.02762007f, 
    -0.03239711f, -0.00840885f, 0.00235073f, -0.01526634f, 0.02893809f, 0.00025942f, 0.02943510f, -0.03677212f, 
    -0.02878848f, -0.00794120f, -0.02462349f, 0.00282227f, -0.00042763f, 0.01627504f, 0.02874172f, -0.03649009f, 
    -0.03161249f, 0.00265452f, -0.01436461f, -0.03256048f, 0.02290929f, 0.00967757f, -0.00572322f, -0.00236769f, 
    0.02131491f, -0.01046787f, 0.02923510f, -0.03459371f, -0.04090166f, -0.02437518f, -0.01260482f, -0.03441775f, 
    0.00257166f, -0.03186199f, -0.03628021f, -0.02471911f, 0.00895199f, -0.02232618f, -0.03835911f, -0.02128330f, 
    0.37200433f, 0.15057001f, 0.10481099f, 0.12527052f, -0.05091984f, -0.09115165f, -0.02535342f, -0.00044742f, 
    -0.08569965f, -0.01413621f, -0.00410272f, 0.02282406f, 0.03847754f, 0.23357472f, 0.06717457f, -0.05784179f, 
    -0.05864162f, -0.04636255f, -0.03425846f, 0.04313823f, -0.02704994f, 0.01923585f, 0.02156722f, 0.06653310f, 
    0.13808782f, -0.08049186f, 0.09949122f, 0.10694922f, -0.01276498f, -0.07564365f, -0.03081922f, 0.01645487f, 
    0.13203889f, 0.17758797f, -0.04569812f, 0.06686164f, 0.06810667f, 0.06955750f, -0.00725230f, 0.18340598f, 
    0.02430559f, 0.00467030f, 0.05748922f, -0.06892864f, -0.00401709f, 0.00624516f, 0.05516821f, 0.06533508f, 
    0.05801181f, 0.08330888f, 0.13578582f, 0.14533022f, 0.01116288f, -0.05348503f, -0.06885636f, -0.04380153f, 
    0.00670018f, 0.00025032f, -0.06202639f, 0.00689036f, -0.62313414f, -0.17150135f, -0.09811958f, -0.37778601f, 
    0.01311044f, -0.02115387f, -0.08696870f, 0.05854909f, -0.08493556f, 0.08016587f, 0.06231817f, -0.07201623f, 
    -0.23764189f, 0.11470537f, -0.01333718f, -0.01187697f, 0.08558383f, -0.07663720f, 0.07121336f, 0.01775458f, 
    0.13544756f, 0.18077309f, 0.12216312f, 0.10108031f, -0.08845926f, -0.06616248f, 0.02621988f, -0.12164931f, 
    -0.11334418f, -0.02381279f, -0.07193185f, 0.06306507f, 0.16182797f, -0.10246748f, -0.04953440f, -0.05098165f, 
    0.10515662f, 0.41492721f, -0.16723408f, -0.08787384f, 0.03353639f, 0.13344447f, -0.09220940f, 0.14836842f, 
    0.16047451f, -0.03380109f, -0.11561654f, 0.06212084f, 0.01862613f, 0.01574857f, 0.07032855f, 0.06649500f, 
    0.00524367f, -0.04337678f, -0.06583162f, -0.03786698f, 0.13832521f, -0.01071788f, -0.03104578f, -0.02103207f, 
    0.10228226f, 0.06589811f, 0.07086045f, 0.10359053f, 0.20975152f, -0.15822060f, -0.04763343f, -0.02590100f, 
    0.04745120f, -0.00610350f, 0.01210830f, -0.20832120f, 0.05399259f, 0.05587576f, 0.12669805f, 0.15280265f, 
    -0.00068132f, -0.02270463f, -0.02040753f, -0.02775122f, 0.04663783f, -0.01364552f, 0.03121926f, 0.04607835f, 
    -0.07703681f, 0.06151181f, 0.20001295f, 0.15024553f, 0.03413003f, -0.01969955f, -0.06672029f, -0.06038168f, 
    0.00846565f, 0.17130083f, 0.04218476f, -0.09762505f, -0.02161588f, -0.39642829f, -0.77734816f, -0.02218658f, 
    0.05876831f, 0.09768701f, 0.06256594f, 0.14004195f, -0.01496606f, 0.03501899f, -0.00376382f, 0.14202364f, 
    -0.04841504f, -0.00740548f, 0.03374008f, -0.08773782f, 0.03336728f, 0.09953867f, -0.01751303f, 0.15085414f, 
    -0.22213790f, -0.16345738f, -0.11552283f, -0.14101189f, 0.19410238f, -0.02726834f, 0.04365239f, 0.10001185f, 
    0.17389505f, 0.00668819f, -0.11248069f, 0.02126848f, 0.05791442f, 0.03893723f, -0.09480254f, 0.09289186f, 
    0.24941984f, 0.12629789f, -0.03265209f, 0.14184098f, -0.05532870f, -0.02329154f, -0.04868111f, -0.10234632f, 
    0.04094657f, 0.06438117f, 0.00657634f, 0.06273583f, 0.37794089f, 0.23652016f, 0.15539292f, -0.01013088f, 
    0.00199391f, -0.04181950f, -0.01394616f, 0.02588535f, 0.03116507f, 0.06588905f, -0.04801346f, 0.00279965f, 
    -0.31702930f, -0.22523229f, -0.57131761f, -0.43313235f, 0.09099215f, 0.06120131f, 0.04534505f, 0.00487701f, 
    -0.11501090f, -0.10390137f, -0.01760898f, -0.06989260f, -0.25709960f, -0.20371810f, 0.02980432f, -0.31624091f, 
    0.01685190f, -0.14830473f, 0.33939147f, -0.18005839f, 0.12214890f, -0.11108848f, -0.16075280f, 0.16966666f, 
    0.06184933f, 0.13210388f, 0.05333206f, -0.13208847f, -0.12337736f, 0.16779749f, 0.06315059f, 0.00905534f, 
    -0.06399201f, -0.29581374f, -0.07937943f, -0.07226146f, 0.06615704f, 0.13374634f, -0.11449290f, 0.26204276f, 
    -0.01279666f, 0.01599459f, -0.05864358f, -0.06373262f, -0.00901555f, -0.01127921f, -0.02152909f, 0.12731685f, 
    0.12423467f, -0.07593609f, -0.25627893f, -0.03986740f, 0.09155837f, 0.20379327f, 0.24494329f, 0.11595713f, 
    -0.05875730f, -0.00100696f, -0.00588576f, -0.03564241f, 0.31622487f, -0.04412116f, 0.02466591f, 0.03105931f, 
    0.00103081f, -0.09099563f, 0.02390506f, 0.05937347f, 0.25556844f, 0.04632579f, -0.10451178f, -0.12131471f, 
    -0.05858430f, -0.09829700f, -0.04583790f, 0.05130108f, -0.04015823f, -0.07100702f, 0.15424615f, -0.02587391f, 
    -0.11902522f, -0.11229605f, -0.10325077f, -0.18811212f, -0.01264808f, 0.03391997f, -0.01806796f, 0.00654216f, 
    0.03186646f, -0.00779703f, 0.07066053f, -0.12350436f, -0.08051822f, -0.08641580f, -0.03673079f, -0.03853472f, 
    0.11859603f, 0.10509265f, 0.09311575f, 0.16186768f, -0.09951713f, -0.04322526f, -0.02768104f, -0.02612670f, 
    0.00939253f, -0.05689687f, -0.03575547f, -0.01826631f, 0.08223461f, 0.02487033f, -0.12060615f, 0.10928438f, 
    -0.06768723f, 0.11125051f, 0.12003273f, -0.03958455f, -0.01563176f, -0.10447177f, 0.07642582f, -0.05341827f, 
    0.07829791f, 0.21381739f, -0.10074874f, -0.15801449f, -0.15308161f, 0.04309516f, -0.05823309f, -0.01893475f, 
    0.08801018f, -0.06790726f, -0.01973063f, -0.02754458f, 0.43115520f, -0.20674782f, 0.17133534f, 0.15564702f, 
    0.07370201f, 0.08798424f, 0.24221429f, -0.00818405f, -0.12408739f, -0.07291520f, 0.01198906f, -0.13036336f, 
    0.10468367f, 0.14567164f, 0.07351357f, 0.13262488f, 0.03119790f, 0.00366428f, -0.04197264f, -0.00755995f, 
    -0.01359747f, -0.06741283f, -0.01920751f, 0.06043141f, -0.29718429f, 0.08952758f, -0.10028389f, -0.00448129f, 
    -0.11032633f, -0.02536695f, -0.26025698f, -0.03637172f, 0.23724180f, 0.04379327f, -0.11208273f, 0.06800907f, 
    -0.02216353f, 0.02446990f, 0.02798941f, -0.16154431f, -0.19973211f, 0.13973559f, 0.14646746f, 0.05583037f, 
    0.14090000f, -0.09575689f, -0.12255795f, -0.05205236f, 0.19826603f, -0.09186660f, -0.27342844f, 0.32861963f, 
    0.03267585f, 0.28064349f, -0.09361146f, -0.03892665f, -0.08971750f, -0.09296682f, 0.00662113f, 0.02378700f, 
    -0.51471835f, 0.37056288f, -0.03536754f, -0.28877184f, -0.07128510f, 0.00758238f, 0.09376531f, -0.04707506f, 
    -0.01053157f, 0.13683185f, -0.00631155f, -0.00049303f, 0.11420824f, 0.06151190f, -0.07860315f, -0.10984277f, 
    0.04402038f, -0.07558340f, -0.08405867f, 0.14146139f, -0.10143219f, -0.02778262f, 0.02746440f, -0.02276027f, 
    0.07775380f, -0.05501656f, -0.03681048f, 0.06929254f, 0.12475676f, -0.02877625f, 0.04890303f, 0.00395735f, 
    0.13780585f, 0.00596120f, 0.07884742f, -0.10146477f, 0.21935295f, 0.02407641f, 0.21161784f, -0.35624173f, 
    -0.03372281f, -0.18561855f, 0.04491361f, -0.08464890f, -0.07969996f, 0.02936573f, 0.04815388f, -0.02490775f, 
    -0.08601206f, 0.14115976f, 0.05135022f, -0.08821577f, 0.04380352f, 0.01520114f, -0.01042415f, 0.12686352f, 
    0.04130538f, 0.02915620f, 0.15077043f, 0.15319197f, 0.12281965f, 0.35227790f, 0.05984778f, -0.02245444f, 
    -0.04908396f, -0.12112691f, 0.07119162f, 0.07494263f, 0.15785415f, 0.07494397f, -0.06423005f, -0.13680525f, 
    -0.03738326f, -0.01803371f, -0.27035311f, -0.33702174f, 0.07173496f, 0.14383997f, 0.04457114f, -0.06011134f, 
    -0.02219229f, -0.01165651f, 0.02878223f, -0.00272409f, 0.04725388f, 0.07024484f, 0.14909345f, 0.09059281f, 
    0.02722345f, -0.04538028f, -0.04136886f, -0.03964778f, -0.08877525f, -0.06440432f, -0.04916801f, 0.00373576f, 
    0.29955047f, -0.01608641f, -0.06231439f, 0.04355283f, 0.01156887f, -0.04498271f, -0.00031920f, 0.06587959f, 
    0.16339290f, 0.14398025f, -0.03021786f, 0.13626641f, -0.05982931f, -0.06355190f, -0.21112011f, 0.01709026f, 
    0.11992294f, -0.20420131f, 0.07865845f, 0.13789067f, 0.00840089f, -0.07825340f, -0.00349857f, -0.03928215f, 
    0.31096461f, -0.01043952f, 0.07675771f, 0.21770586f, -0.02893976f, -0.01713706f, -0.03565726f, -0.08781717f, 
    0.13541906f, 0.07627310f, -0.02276721f, -0.01672193f, -0.00193215f, -0.07828134f, -0.04037502f, 0.05699881f, 
    0.07803173f, 0.03231228f, 0.05303670f, 0.01207270f, -0.12395467f, -0.03073178f, -0.00708164f, -0.05798639f, 
    -0.53393131f, -0.29110196f, -0.42833653f, -0.26675305f, 0.12514989f, 0.01777484f, 0.06335626f, 0.00313463f, 
    -0.06790008f, 0.06807482f, 0.01801188f, 0.02992425f, 0.02982429f, 0.02035379f, -0.00006758f, 0.19240794f, 
    0.08382201f, -0.00648909f, -0.03408328f, 0.00470214f, -0.09059687f, -0.07652082f, -0.00791169f, 0.01979268f, 
    -0.36141846f, -0.14330548f, -0.07327903f, -0.04323797f, -0.01689003f, -0.08913044f, 0.03440039f, -0.17416044f, 
    -0.03343040f, 0.09434992f, 0.00226811f, 0.01458556f, 0.07115164f, 0.15422870f, 0.01171110f, -0.02161006f, 
    -0.05274643f, 0.01500588f, -0.01287502f, 0.04495316f, 0.09000938f, 0.06297400f, 0.05399590f, 0.12301093f, 
    0.16131906f, 0.05640382f, -0.05730571f, -0.09315600f, -0.00089992f, -0.00036000f, -0.01192373f, 0.08858769f, 
    0.14342709f, 0.05129519f, -0.18766093f, -0.09162901f, -0.07469261f, -0.00276758f, 0.02409865f, 0.04225305f, 
    0.17328805f, 0.11581618f, 0.11386193f, -0.03151437f, 0.24787337f, 0.21076275f, 0.05763915f, 0.04581678f, 
    0.25376031f, 0.11317030f, -0.03401002f, 0.07049163f, 0.03247100f, -0.01046650f, -0.04991109f, 0.06977403f, 
    0.13046287f, 0.17553663f, -0.00884732f, 0.13397290f, -0.59648412f, -0.21340452f, -0.52102137f, -0.33553115f, 
    -0.00177330f, -0.02909771f, 0.09523117f, -0.13031662f, -0.13406867f, -0.06955708f, 0.02512194f, 0.04928213f, 
    0.01393298f, 0.05319241f, 0.14538988f, 0.13996400f, -0.00787739f, -0.00616478f, 0.00009904f, 0.04099571f, 
    0.06412023f, 0.03520039f, 0.01366306f, 0.21639939f, 0.01540138f, -0.03760245f, 0.02330578f, 0.09422937f, 
    0.06868089f, -0.01393793f, 0.19347204f, -0.19824176f, 0.01944579f, 0.04440370f, 0.16512215f, -0.04773039f, 
    -0.62232751f, -0.19402936f, -0.54221225f, -0.43494478f, 0.16499497f, 0.21461202f, 0.09823709f, 0.02747254f, 
    0.02840022f, 0.05154023f, 0.04198648f, -0.04422177f, 0.06566986f, 0.01876774f, 0.03105174f, -0.02917508f, 
    -0.03205951f, 0.08432127f, 0.00977759f, -0.14583750f, -0.10222140f, -0.08769747f, -0.03456416f, -0.05077788f, 
    -0.01547758f, 0.00942189f, 0.08462931f, 0.02815121f, -0.02950329f, 0.03701133f, 0.02101769f, 0.01919206f, 
    -0.00364765f, -0.11630688f, 0.05222894f, -0.02848014f, -0.10016336f, -0.77317846f, -0.09713322f, -0.10044971f, 
    0.00372366f, -0.08981241f, 0.09576909f, 0.11502139f, -0.08428335f, 0.02924052f, 0.07896806f, 0.07887439f, 
    0.28813115f, -0.05157763f, 0.01398667f, -0.00734190f, 0.02340188f, 0.01399573f, 0.08224997f, 0.13745388f, 
    0.27290025f, 0.21042374f, -0.01409572f, 0.18017556f, -0.23479411f, -0.35789895f, -0.64253360f, -0.56057578f, 
    0.03571376f, -0.15706025f, -0.21579537f, -0.20870692f, -0.08167893f, -0.04723087f, -0.06208262f, -0.07192875f, 
    -0.54239917f, 0.13653086f, -0.32801419f, -0.05721212f, -0.02322549f, 0.07128922f, 0.21754161f, 0.02463241f, 
    0.08391860f, -0.05190122f, -0.00647706f, -0.02568533f, 0.15543310f, 0.01465145f, -0.09144330f, 0.06916161f, 
    0.02581146f, 0.11635382f, 0.01838893f, 0.08222589f, 0.08537143f, -0.09686208f, 0.10897482f, -0.00435125f, 
    -0.30779827f, 0.12439157f, -0.40083101f, 0.11603001f, 0.04676860f, -0.06257454f, 0.05195832f, -0.05945886f, 
    -0.04534275f, 0.04036628f, -0.00293692f, 0.05071673f, 0.24041031f, -0.12013773f, -0.24929425f, -0.12623799f, 
    -0.02333578f, -0.02541238f, -0.18090822f, -0.09722669f, 0.03451290f, -0.00232234f, 0.08582683f, 0.09123364f, 
    -0.19612390f, 0.19193777f, -0.13947915f, -0.16995151f, 0.06120972f, 0.01043878f, 0.06348039f, -0.06363379f, 
    0.02566748f, 0.28691420f, 0.02048421f, 0.03566693f, 0.03481400f, 0.06149453f, -0.12545210f, -0.04598808f, 
    -0.07521226f, 0.16116275f, -0.11209503f, 0.01083120f, -0.01998920f, 0.06063297f, -0.04843006f, 0.00264192f, 
    0.02869914f, -0.07139922f, 0.24424253f, -0.04017146f, -0.01689999f, 0.07292827f, -0.02885168f, 0.01382614f, 
    0.15469633f, 0.04828599f, -0.07245065f, -0.01961685f, -0.17337991f, -0.24081829f, -0.15092328f, -0.09595352f, 
    0.02401623f, -0.09384871f, 0.17245069f, -0.08210307f, 0.01002507f, 0.02275553f, 0.21305962f, 0.06774066f, 
    0.10265201f, -0.29570913f, -0.03991615f, -0.04570926f, 0.18672268f, 0.03470869f, 0.29215261f, -0.04510443f, 
    0.01514469f, 0.14200057f, 0.06238059f, -0.05785123f, -0.36053252f, -0.10803140f, -0.08060471f, -0.16506571f, 
    -0.03861624f, 0.04968753f, 0.13360989f, 0.06432553f, -0.03251904f, -0.06531103f, 0.14867665f, 0.16524185f, 
    0.06881893f, 0.07507818f, 0.09950790f, -0.08456690f, 0.05453559f, 0.04356984f, 0.09007000f, 0.06316926f, 
    -0.00355081f, -0.11965031f, 0.00929051f, 0.05761825f, 0.02102846f, 0.06272661f, 0.08445055f, -0.12525727f, 
    -0.02646983f, -0.05759607f, -0.09210741f, -0.06083531f, 0.00256911f, 0.05660939f, 0.03762507f, 0.12507167f, 
    -0.05394765f, 0.06275917f, -0.01658016f, 0.00574188f, -0.00295973f, 0.18883044f, 0.17522977f, -0.04384785f, 
    0.16635661f, 0.12997307f, 0.02344800f, -0.00135811f, 0.10680164f, 0.08892517f, 0.02819255f, -0.03629338f, 
    -0.03315048f, -0.03545240f, -0.01560927f, -0.13856131f, 0.07126427f, -0.04232134f, 0.01883135f, -0.03727501f, 
    0.09518327f, 0.00896300f, 0.07516447f, 0.05694667f, 0.13019402f, -0.04858379f, 0.09377304f, -0.04347735f, 
    -0.17647152f, 0.01298364f, 0.20037946f, 0.08186670f, 0.17031796f, 0.12856771f, 0.20841934f, -0.06902043f, 
    0.07475248f, -0.00111420f, 0.01765021f, 0.15553257f, -0.06824389f, -0.06004410f, -0.06006974f, 0.00535729f, 
    0.10657255f, -0.18087070f, 0.00711667f, -0.23679245f, -0.07797107f, -0.08545329f, -0.12830034f, 0.10004196f, 
    0.16337560f, -0.00121005f, 0.08874691f, -0.04705973f, -0.02475158f, 0.10214790f, 0.10597467f, -0.04560049f, 
    0.06484735f, 0.18754236f, 0.10556468f, 0.05296412f, 0.19459775f, -0.04587138f, -0.07285470f, 0.05306244f, 
    -0.04357529f, 0.03146675f, 0.20245552f, -0.09497485f, -0.06023503f, 0.06916428f, 0.05724729f, -0.01200275f, 
    -0.13162276f, 0.01960951f, 0.04867113f, 0.07424614f, 0.28671828f, 0.05562814f, -0.10023779f, 0.15452191f, 
    0.00283390f, -0.00045123f, 0.09663088f, -0.07625291f, 0.04634614f, -0.12332171f, -0.00086041f, -0.00446122f, 
    -0.03160273f, -0.06429610f, -0.04230421f, -0.22384325f, 0.17487474f, 0.01725031f, -0.01842521f, 0.10307074f, 
    -0.01828504f, -0.03177949f, -0.01953752f, -0.03807169f, 0.03970842f, -0.16303310f, -0.32372314f, 0.24529685f, 
    0.19182698f, 0.08916230f, 0.04369286f, -0.13852619f, 0.01065563f, 0.11042953f, -0.02432380f, 0.10669006f, 
    0.45365709f, -0.07676402f, -0.15099581f, 0.14750996f, 0.23175909f, 0.01243738f, -0.32362896f, -0.05408964f, 
    0.11918090f, -0.08870734f, 0.13577062f, -0.13749847f, 0.27747652f, -0.44764024f, 0.09695041f, 0.05713646f, 
    0.05627545f, -0.00004467f, 0.00378654f, -0.18355055f, -0.00343362f, 0.06086497f, 0.04037729f, -0.02841783f, 
    -0.11056209f, 0.20379995f, 0.07825749f, -0.12209664f, 0.07341294f, 0.04508081f, -0.01204837f, 0.05605222f, 
    -0.05109159f, -0.06412999f, -0.09844197f, 0.03319752f, -0.05462136f, 0.12085782f, -0.09452488f, -0.01516104f, 
    -0.17108466f, 0.14677079f, 0.20188685f, 0.04089608f, 0.16603433f, 0.08213735f, -0.03596035f, 0.03588484f, 
    -0.04309449f, 0.03720401f, -0.26134190f, 0.09958312f, -0.02446873f, 0.15516354f, -0.10161966f, -0.14273006f, 
    -0.05130710f, -0.04002488f, -0.15031476f, -0.16567071f, -0.00097107f, -0.05087515f, -0.10701664f, -0.07567149f, 
    0.12740034f, 0.19196369f, 0.15753056f, -0.03721377f, 0.01291854f, 0.10817313f, 0.00631584f, 0.01321034f, 
    0.05461634f, -0.00308763f, -0.12067509f, 0.10812505f, 0.07413162f, -0.00118674f, -0.01127519f, -0.07748920f, 
    -0.00632413f, 0.00957378f, -0.06751751f, -0.01293812f, -0.37901205f, 0.18201412f, -0.25635871f, -0.11652402f, 
    0.11204055f, 0.00330234f, 0.10723676f, -0.04251834f, 0.04874562f, 0.15408981f, -0.09708058f, 0.09490067f, 
    0.43176219f, -0.19607291f, -0.00967295f, -0.12809068f, 0.01252041f, -0.14270034f, -0.07222164f, -0.09274841f, 
    -0.01692597f, -0.01506558f, 0.10090547f, 0.01386082f, -0.32267833f, 0.45779389f, -0.01347957f, 0.15381759f, 
    -0.05045052f, -0.05110562f, 0.06231929f, -0.01833311f, 0.00458464f, -0.00587572f, 0.05786096f, 0.01476977f, 
    0.15239757f, -0.08905305f, 0.06947261f, -0.03501386f, 0.09533200f, 0.06342214f, -0.05288726f, -0.07412416f, 
    0.10784719f, -0.06867662f, -0.04952810f, 0.00949021f, 0.31977540f, -0.14755771f, -0.02266452f, -0.13243783f, 
    0.28924623f, -0.02787527f, 0.17826174f, 0.04219056f, 0.12461976f, 0.00477521f, -0.02299733f, 0.02743373f, 
    0.14709285f, 0.02576069f, 0.14030917f, -0.07831982f, 0.14097442f, -0.12502426f, -0.14496499f, -0.10658801f, 
    0.22597252f, -0.00613188f, -0.00430410f, -0.04602509f, 0.32903257f, -0.14087506f, -0.06518561f, 0.10127434f, 
    -0.11432604f, -0.07028507f, -0.02592738f, 0.05420912f, -0.02347202f, 0.02988940f, -0.03859060f, -0.04098718f, 
    0.54473996f, -0.21528471f, 0.40267932f, 0.10124797f, 0.26587555f, -0.19981080f, 0.04066835f, 0.07476796f, 
    -0.00723341f, 0.15147176f, 0.12113289f, 0.03458539f, 0.04552026f, 0.15993720f, 0.07095693f, -0.07341240f, 
    -0.02715551f, 0.13132264f, 0.13648528f, 0.00247172f, -0.06466596f, -0.05878823f, -0.04187743f, -0.00285255f, 
    0.05267596f, -0.10118151f, -0.09716030f, -0.08645137f, -0.04923974f, 0.16607484f, 0.31414670f, -0.00014662f, 
    0.05029906f, 0.05469308f, -0.00416956f, 0.05832507f, -0.13282402f, 0.18289806f, -0.17827955f, 0.00216009f, 
    -0.02512209f, -0.11494118f, 0.01742537f, 0.12917227f, 0.08488856f, 0.22177435f, 0.07343256f, -0.07957336f, 
    0.22001441f, -0.07796685f, 0.25209317f, -0.06688824f, 0.18953787f, 0.06428682f, 0.03553978f, -0.12383419f, 
    0.11697755f, 0.05235430f, 0.02565837f, -0.08464763f, -0.08161717f, 0.24714385f, -0.11404134f, 0.19569039f, 
    0.15320386f, -0.11965467f, 0.03384763f, -0.06262070f, 0.15615524f, 0.08037736f, 0.20878762f, 0.03574247f, 
    0.26134825f, 0.10898748f, 0.08044966f, -0.01275073f, 0.15781672f, -0.20845869f, 0.10880112f, 0.06072539f, 
    -0.02259487f, 0.00690445f, -0.06945096f, 0.03589782f, -0.04016961f, 0.07725745f, -0.04819703f, -0.00468841f, 
    0.03786615f, 0.03185746f, -0.00334031f, -0.08951420f, 0.07131083f, -0.01716208f, -0.05770747f, -0.02980251f, 
    -0.12599264f, 0.08632742f, 0.28796166f, 0.03281597f, -0.01440764f, -0.09925292f, 0.01326761f, 0.02510965f, 
    0.16867189f, 0.15104504f, -0.08345822f, 0.14553960f, -0.14279577f, -0.07465532f, -0.01484416f, -0.01610962f, 
    0.10676081f, -0.14793475f, 0.01691589f, -0.03366557f, 0.00538747f, -0.03593170f, -0.08306094f, 0.09075527f, 
    0.00956683f, 0.17483374f, 0.25078496f, 0.12290032f, -0.06411586f, -0.05711215f, -0.01234176f, -0.02951212f, 
    0.02610336f, 0.16176748f, -0.06675227f, 0.15993679f, 0.11032555f, -0.09097790f, 0.02043057f, -0.15980145f, 
    0.03894598f, 0.14064543f, -0.00252282f, 0.18210459f, 0.06790154f, 0.05100688f, -0.03202504f, -0.02898855f, 
    0.11684507f, 0.07221060f, 0.11162995f, -0.03545238f, 0.05786434f, 0.01193479f, 0.12802635f, 0.07946938f, 
    0.03187277f, -0.09863003f, -0.04105030f, -0.02542313f, 0.17219646f, -0.05555457f, -0.03772112f, -0.09484582f, 
    0.12449043f, 0.11862365f, 0.01839214f, -0.10016258f, 0.01125740f, -0.06099366f, -0.05784120f, -0.04065900f, 
    -0.57733411f, 0.16574000f, 0.08327248f, -0.03356975f, -0.06462274f, 0.19789790f, 0.05691601f, 0.02681696f, 
    0.02917848f, -0.04358551f, -0.08103263f, 0.01947889f, 0.21709388f, -0.01769776f, 0.06388892f, -0.05323095f, 
    0.05295264f, -0.06058581f, 0.04301749f, -0.07716578f, 0.06982353f, -0.04700157f, 0.21071769f, 0.02973964f, 
    -0.00779735f, 0.18711364f, -0.05577607f, -0.12144469f, -0.04146012f, 0.01122566f, -0.00884332f, 0.02597982f, 
    0.14220700f, 0.13038369f, 0.13773665f, 0.05318939f, 0.07625776f, 0.03938232f, -0.14825217f, -0.05785982f, 
    -0.09268977f, 0.12617758f, 0.19038536f, 0.17235552f, -0.16980655f, 0.10923626f, 0.14563717f, 0.14038680f, 
    0.20321532f, 0.03972341f, 0.35443819f, 0.06685812f, 0.04950889f, -0.02002933f, -0.01127672f, -0.18223546f, 
    0.03286401f, 0.17232254f, 0.08776990f, -0.04284256f, 0.05973918f, -0.12268565f, 0.01503560f, -0.05084893f, 
    0.22260404f, -0.16082554f, 0.05950385f, 0.01547708f, -0.00562369f, 0.01253991f, -0.02187932f, -0.01264353f, 
    0.19740179f, -0.10371576f, -0.13252015f, 0.03294630f, 0.02641507f, 0.09380721f, -0.03210673f, -0.08574121f, 
    -0.00090370f, 0.11704823f, 0.01249517f, -0.19616397f, -0.23776640f, 0.12762921f, -0.27782264f, 0.36234435f, 
    0.20058674f, -0.16274664f, 0.12051234f, 0.01691848f, 0.09340740f, 0.10470962f, 0.05835468f, 0.11482893f, 
    -0.04504354f, 0.04139477f, -0.01515033f, -0.19736862f, 0.06293795f, 0.18648040f, 0.06808713f, 0.13108924f, 
    -0.05872542f, -0.04567449f, -0.00687756f, -0.01728376f, 0.05732108f, 0.08001149f, -0.14583124f, 0.02247703f, 
    0.15947866f, 0.03879531f, 0.01752162f, -0.01660115f, 0.03898005f, 0.04820684f, 0.00584456f, 0.01113542f, 
    0.01379292f, -0.04558843f, 0.08724014f, 0.12817566f, -0.07303464f, -0.09772426f, -0.09704453f, -0.03452893f, 
    0.13747083f, 0.11275206f, -0.02437465f, -0.14302656f, -0.05635901f, 0.30581608f, 0.11125381f, 0.04063473f, 
    0.04623256f, 0.08480019f, 0.17595395f, 0.21506900f, -0.08810871f, 0.00228446f, -0.01280157f, 0.11012397f, 
    -0.18709566f, 0.18812373f, 0.16566133f, -0.04186527f, -0.11900044f, 0.04915659f, 0.09703068f, -0.07887080f, 
    0.17431960f, -0.00465773f, -0.10110992f, 0.09076229f, -0.00917093f, 0.11623513f, -0.18453713f, -0.43237376f, 
    0.02746521f, 0.08859032f, 0.03475876f, 0.07365815f, 0.02829710f, -0.04862593f, -0.05765013f, 0.08021507f, 
    0.12503868f, -0.12882058f, 0.02212801f, -0.16536084f, 0.17026930f, -0.28078398f, 0.12417863f, -0.05831018f, 
    -0.12604965f, 0.18524997f, -0.05002387f, 0.07270863f, 0.08303977f, -0.18870685f, 0.00530544f, -0.13659941f, 
    0.02014231f, 0.04823500f, 0.05211155f, 0.05991570f, 0.00098373f, 0.01408984f, 0.09133724f, -0.11002356f, 
    0.18901035f, -0.05634400f, -0.34223595f, -0.21791013f, 0.18262076f, 0.17835820f, 0.07780478f, -0.04907176f, 
    -0.08280523f, -0.01811086f, -0.02975249f, 0.03635582f, -0.27997583f, 0.16524792f, 0.30132589f, 0.19141538f, 
    -0.15273736f, -0.07282629f, -0.02859753f, 0.04133663f, 0.15099148f, 0.08343928f, 0.00280668f, 0.20332840f, 
    -0.00765273f, -0.02511844f, 0.16601907f, -0.15040316f, -0.00195260f, -0.04476961f, 0.07161057f, 0.00245069f, 
    0.16566095f, 0.01901913f, -0.02815140f, 0.14297946f, 0.07172424f, 0.02828995f, -0.09707601f, 0.16488171f, 
    0.06190566f, 0.03046683f, -0.00948008f, 0.02408542f, -0.10705381f, -0.04964150f, 0.06290651f, -0.07588464f, 
    -0.11361413f, -0.02685147f, 0.10006306f, 0.12817766f, -0.02113567f, -0.08256640f, -0.11049020f, 0.02852036f, 
    0.00395593f, -0.05579385f, -0.04254615f, -0.17083623f, -0.88646263f, 0.29157844f, 0.15864260f, -0.05668404f, 
    -0.05114357f, -0.03694431f, -0.06180258f, 0.21311790f, 0.21499227f, 0.02450506f, 0.01977067f, -0.04088072f, 
    -0.24545440f, -0.09480305f, -0.04117956f, 0.04798080f, 0.17471470f, 0.02467643f, 0.24534605f, -0.01059905f, 
    -0.00400172f, -0.07307297f, 0.05497008f, 0.03910342f, -0.20840542f, 0.24802217f, 0.05523699f, -0.09558515f, 
    -0.17116815f, 0.01420930f, -0.02974158f, -0.03373944f, 0.18680516f, 0.14211941f, -0.03709036f, 0.11827391f, 
    -0.04364297f, 0.01518383f, 0.01972928f, -0.06964190f, -0.01710191f, 0.05234835f, -0.14020562f, -0.07314935f, 
    0.16880366f, 0.12024405f, -0.18492246f, 0.05189444f, -0.03015976f, -0.08038458f, 0.02373841f, 0.00515213f, 
    -0.00872081f, -0.02753764f, -0.01679286f, 0.06420904f, 0.14377517f, 0.12803131f, -0.15997629f, -0.02429381f, 
    0.17451468f, 0.01049287f, 0.07849683f, -0.15555166f, -0.10597491f, -0.21277137f, 0.03747678f, 0.08824691f, 
    0.04107426f, -0.10741235f, 0.06571037f, -0.20129457f, -0.09347545f, 0.02018792f, 0.09001844f, 0.13869824f, 
    0.02939702f, -0.04440607f, -0.03466298f, -0.01421147f, 0.03351548f, 0.08897877f, 0.16797021f, 0.06042599f, 
    -0.31806281f, -0.09988406f, 0.12830809f, -0.03688683f, -0.12962529f, -0.10809227f, -0.05626915f, 0.03330958f, 
    0.06415648f, -0.11305368f, -0.04951166f, -0.12046109f, 0.01653706f, 0.06506635f, -0.06878027f, -0.14167078f, 
    -0.03722042f, 0.00244707f, -0.05970107f, 0.04571753f, -0.00192972f, 0.09516711f, -0.06149976f, 0.04300499f, 
    -0.18588668f, -0.01720521f, 0.04003004f, 0.04545489f, -0.05847684f, 0.07378002f, -0.05590789f, 0.09755494f, 
    -0.01759502f, 0.11243871f, 0.02272370f, 0.06221731f, 0.27017969f, -0.09434089f, 0.03286124f, -0.17757346f, 
    0.13377367f, -0.01110598f, -0.05440135f, 0.18552469f, -0.01920350f, -0.04124411f, -0.08660195f, 0.04055096f, 
    0.30582318f, 0.04718889f, -0.08848961f, 0.00488785f, 0.14679314f, 0.08846285f, 0.03892132f, 0.02734068f, 
    0.01403528f, 0.01219047f, 0.00950165f, 0.13950580f, 0.49737957f, 0.24728933f, 0.03606796f, -0.35791308f, 
    -0.01644508f, 0.04160900f, 0.06786318f, 0.02435801f, -0.05567955f, -0.01575698f, -0.12693180f, 0.00380758f, 
    -0.06888652f, 0.05033734f, -0.01808181f, -0.25792348f, -0.00567934f, -0.12103304f, -0.02760659f, -0.15056267f, 
    0.03952406f, 0.01025451f, -0.05106946f, -0.02724846f, -0.00431837f, -0.08615262f, 0.11117855f, -0.16981936f, 
    0.13410991f, 0.00782085f, 0.20796016f, 0.00162719f, 0.02435282f, 0.04346117f, 0.02151932f, 0.23874238f, 
    -0.12426112f, -0.37811583f, 0.14942588f, 0.27182981f, -0.14206526f, -0.05693498f, 0.04798959f, 0.17653859f, 
    0.07677689f, 0.16429959f, 0.12163905f, 0.09406502f, 0.01148900f, 0.03743704f, -0.09391376f, 0.09940231f, 
    0.07871404f, -0.03413270f, 0.05467181f, -0.02920484f, -0.00481935f, 0.03220661f, -0.07381874f, 0.08198254f, 
    0.17948636f, 0.01745837f, -0.19373435f, -0.23336874f, 0.00940615f, 0.08610600f, 0.09116860f, -0.07728656f, 
    0.02607827f, -0.11692438f, -0.05732893f, -0.05039085f, 0.65718406f, -0.06449088f, 0.08501337f, -0.23020719f, 
    0.10607782f, -0.01650120f, 0.06004342f, 0.13452631f, 0.15733807f, -0.22816396f, 0.04521227f, -0.04795274f, 
    -0.15760820f, 0.03669887f, -0.00577731f, 0.08586606f, -0.02039804f, 0.03249051f, 0.18420544f, 0.13286738f, 
    0.22027081f, 0.15006779f, -0.02844642f, -0.00994976f, -0.04003925f, 0.00122980f, -0.07482582f, -0.13096628f, 
    0.14284569f, -0.00441410f, 0.19345635f, 0.18635671f, -0.08913269f, -0.06707141f, -0.07986690f, 0.01791831f, 
    -0.03721711f, 0.05811440f, 0.05089511f, 0.02614681f, -0.05892723f, -0.02917350f, 0.00076887f, 0.00769960f, 
    -0.03418662f, -0.04402896f, -0.08090774f, 0.01899907f, 0.16586798f, -0.27576923f, -0.03351182f, 0.19233792f, 
    0.10207973f, 0.02251785f, 0.21167704f, -0.09085774f, 0.11969950f, -0.11959761f, 0.00588396f, -0.03678186f, 
    -0.26070726f, 0.18496114f, 0.24582961f, 0.10063918f, -0.10827525f, -0.03611796f, -0.02287481f, 0.08335113f, 
    0.04316771f, 0.11930567f, 0.10474523f, 0.02815792f, 0.26461732f, -0.28358063f, -0.08820324f, -0.26845410f, 
    -0.04257414f, -0.02557194f, 0.10691968f, -0.10405651f, 0.00298764f, -0.05303643f, -0.01744688f, -0.09480587f, 
    0.18692744f, 0.00091814f, -0.06813159f, 0.14175110f, -0.00191142f, 0.00025231f, 0.00461777f, 0.01928275f, 
    -0.05200727f, -0.07189150f, -0.05506614f, -0.06938047f, -0.19341396f, -0.25798184f, 0.01918582f, 0.13488232f, 
    0.08516549f, -0.05076580f, 0.13433260f, 0.15637268f, 0.01226991f, 0.05243828f, -0.01368648f, 0.01288188f, 
    0.04161415f, -0.10895737f, 0.05020383f, 0.13327275f, -0.09888116f, 0.09082508f, 0.03991333f, 0.08183282f, 
    0.11363013f, 0.01783916f, 0.06470867f, 0.17759144f, -0.09302163f, -0.22050726f, -0.16133665f, -0.01124175f, 
    0.08006342f, 0.15690888f, 0.04972355f, 0.10839137f, 0.00657857f, 0.03853106f, 0.01864314f, -0.00347061f, 
    -0.40045121f, 0.25207788f, 0.34238774f, 0.42833152f, 0.01167691f, -0.13170622f, -0.09775171f, 0.01815947f, 
    0.02857277f, -0.09359622f, 0.06685364f, -0.05970297f, -0.02180757f, -0.02430109f, 0.02189502f, -0.22922365f, 
    0.00370993f, 0.01419391f, 0.03057645f, -0.07708083f, 0.05389871f, 0.07089400f, -0.02444381f, 0.01465004f, 
    0.28227654f, -0.05468871f, -0.02236309f, -0.11071922f, 0.03940956f, -0.10251413f, 0.27305973f, 0.05331955f, 
    0.17261405f, -0.03372303f, 0.08026123f, 0.05750052f, 0.16952783f, 0.17202362f, 0.17545308f, -0.29355827f, 
    0.00614290f, -0.07227212f, 0.04037725f, 0.00040037f, -0.01742326f, -0.05543819f, 0.19124828f, 0.00562613f, 
    -0.27362296f, -0.15307647f, 0.09094541f, 0.28866100f, 0.13522175f, -0.07477783f, 0.08515640f, 0.31211174f, 
    0.15040278f, 0.04763781f, 0.25903502f, -0.04569339f, 0.18308197f, 0.24549566f, 0.06597597f, 0.06182289f, 
    0.19567034f, -0.15988454f, 0.12548618f, 0.14085241f, -0.12201179f, 0.08535575f, -0.04003065f, 0.14828604f, 
    -0.08210330f, -0.00067026f, 0.07329349f, -0.04443210f, 0.03151419f, -0.16039661f, 0.09234759f, -0.20233804f, 
    0.00905901f, -0.01238196f, -0.01587466f, -0.00025701f, 0.10069552f, -0.02329885f, -0.01309126f, 0.06505454f, 
    0.07316766f, -0.03336897f, 0.03774389f, 0.00376722f, -0.11154987f, -0.08170256f, -0.02312426f, -0.02569599f, 
    0.31052816f, -0.11153319f, 0.03474576f, -0.05903492f, 0.00849054f, 0.06520782f, 0.04678650f, 0.04479113f, 
    0.04015699f, 0.00385680f, 0.07101902f, 0.04049739f, -0.18294613f, -0.08097161f, -0.30029875f, -0.12436018f, 
    0.02408127f, -0.04511975f, -0.00324168f, 0.03179419f, -0.06178067f, -0.00331554f, 0.04636943f, -0.02412528f, 
    0.25258774f, -0.10868707f, 0.04679823f, -0.03913301f, -0.00054454f, -0.12284719f, -0.03539356f, -0.05672846f, 
    0.06348402f, -0.06790323f, -0.16844988f, -0.04877295f, 0.01240195f, -0.07750664f, -0.01714552f, 0.03973454f, 
    0.18391487f, 0.06442730f, -0.00298856f, -0.06258551f, -0.02644789f, -0.10837197f, 0.01227881f, -0.03100742f, 
    -0.00923634f, -0.12382928f, -0.04029678f, -0.11207432f, 0.08088792f, -0.05605496f, -0.01227611f, -0.12396738f, 
    0.07211976f, 0.06571985f, 0.11250571f, -0.09999593f, 0.10824580f, -0.00176866f, -0.10318382f, 0.17969590f, 
    0.00955314f, 0.06112638f, 0.14975876f, 0.08052798f, -0.10132870f, -0.09086845f, -0.06851356f, 0.04356162f, 
    -0.33928755f, -0.14594096f, -0.08710802f, 0.03752478f, 0.02698605f, 0.04177009f, 0.06966135f, 0.14335310f, 
    0.12445828f, 0.02801445f, 0.01927525f, 0.03785965f, 0.31020078f, 0.16666968f, -0.05178947f, 0.02420189f, 
    -0.09583219f, 0.03208360f, -0.00604434f, 0.00793402f, -0.12727776f, -0.13795948f, 0.08066735f, -0.05919414f, 
    0.15586933f, 0.06531290f, 0.02174270f, -0.05412770f, -0.03755164f, -0.06754061f, -0.13922974f, -0.00639163f, 
    0.18599029f, -0.03206395f, -0.26415768f, -0.00286008f, 0.07808727f, 0.02111876f, -0.10308618f, 0.04609010f, 
    0.12215953f, -0.05725852f, 0.30927107f, 0.07778396f, 0.26677009f, 0.12010971f, 0.10268582f, 0.12649737f, 
    0.34469146f, -0.03721754f, 0.01224310f, 0.21247783f, -0.04004326f, -0.02862087f, -0.06986485f, 0.04345098f, 
    -0.14681193f, 0.22080500f, 0.20217156f, -0.04179515f, -0.29311261f, -0.23540746f, 0.14963095f, 0.03292273f, 
    0.05665918f, -0.12791964f, 0.18270640f, -0.09944071f, -0.01943041f, -0.05710985f, 0.00300544f, 0.12925807f, 
    0.10698406f, 0.14937429f, -0.11028604f, 0.27256477f, -0.00312726f, 0.02680041f, 0.04781404f, 0.08152308f, 
    -0.13647301f, -0.04415696f, -0.05987116f, -0.03917164f, 0.09990294f, 0.19009204f, -0.17896523f, -0.30230829f, 
    0.15960905f, -0.02230850f, 0.24635559f, 0.00824728f, -0.04091055f, 0.00153404f, -0.06828173f, -0.01510129f, 
    -0.10103849f, 0.11208013f, 0.13050731f, -0.09962416f, -0.12071761f, 0.11814517f, 0.02877042f, -0.06625118f, 
    0.01867233f, 0.08801207f, 0.00955175f, -0.04648259f, 0.03669909f, -0.04206646f, -0.04024438f, -0.15280241f, 
    0.05020136f, 0.05050611f, 0.13010712f, 0.11476327f, -0.07026395f, -0.00007888f, -0.10674163f, 0.00179143f, 
    0.13365880f, 0.02792862f, 0.18194114f, 0.01857203f, 0.03308290f, 0.04751121f, 0.01401434f, -0.00535163f, 
    0.14358914f, 0.05673409f, 0.14403160f, 0.02030464f, -0.29588160f, 0.06196795f, -0.04907317f, 0.00117235f, 
    -0.05957321f, -0.00760112f, 0.09833595f, -0.00585680f, 0.01571252f, 0.05668942f, 0.03429958f, 0.01045354f, 
    0.39541256f, -0.09795145f, 0.00659885f, -0.15678230f, 0.07503682f, -0.01069486f, 0.00979143f, 0.15006331f, 
    0.21157281f, -0.01878266f, 0.11412207f, 0.16497037f, -0.31504312f, 0.11618823f, 0.18183815f, -0.04051501f, 
    -0.06601259f, 0.01286842f, -0.00952005f, -0.03650381f, 0.02262491f, 0.11181873f, 0.04218712f, -0.04430188f, 
    0.03343473f, 0.14978269f, 0.23222692f, 0.11297400f, 0.07460673f, -0.06527051f, 0.06098807f, 0.08903006f, 
    0.31425390f, -0.01441909f, -0.00924431f, -0.02629310f, 0.00872960f, 0.18568262f, 0.14873593f, -0.10190744f, 
    -0.06198999f, -0.07950716f, -0.01244416f, -0.09207651f, 0.08061892f, 0.10230172f, 0.07497997f, -0.03879349f, 
    -0.09229174f, 0.25047639f, 0.00692048f, 0.17840244f, 0.12680613f, 0.17196572f, 0.03592224f, -0.01782496f, 
    0.07506131f, -0.08894001f, -0.10400540f, -0.18331189f, -0.10915793f, -0.07878542f, 0.20027652f, 0.00905753f, 
    0.03448739f, 0.03492486f, -0.00551892f, 0.20251827f, 0.14989404f, 0.10824704f, 0.10112059f, 0.07541844f, 
    -0.14701663f, 0.19402829f, -0.26722533f, -0.15551412f, 0.01686280f, -0.02834044f, -0.02827712f, -0.10950199f, 
    0.13388547f, 0.05634320f, 0.13131791f, 0.14008212f, -0.21844843f, -0.04723826f, 0.01049264f, 0.23813939f, 
    0.21353063f, -0.12198649f, -0.10504691f, 0.04674068f, 0.09270928f, -0.02437867f, -0.02568501f, 0.04837951f, 
    -0.06220112f, -0.20718776f, -0.10416418f, -0.12621266f, -0.07022597f, -0.04273400f, -0.08800457f, -0.02868194f, 
    0.02476504f, -0.08828626f, -0.00661121f, -0.18907638f, -0.27259338f, 0.11233183f, -0.08578622f, 0.43212181f, 
    0.02654608f, 0.10613189f, 0.02193144f, -0.02718043f, 0.19034018f, -0.02192087f, 0.18455262f, -0.08181467f, 
    0.19835715f, -0.14373535f, 0.39712656f, -0.01147635f, -0.07552959f, -0.07124235f, -0.03446248f, -0.08528020f, 
    0.21690083f, -0.09111132f, 0.03996453f, 0.12976548f, 0.01279936f, 0.15890196f, -0.18269122f, 0.28464252f, 
    0.09023613f, 0.08970933f, 0.16127639f, 0.22764382f, -0.02706498f, 0.00467279f, 0.08008713f, 0.19481719f, 
    0.12141340f, 0.25106171f, -0.07536308f, -0.14393705f, 0.17853016f, 0.08770544f, 0.02836240f, -0.09341224f, 
    -0.05238057f, -0.01608527f, -0.05516855f, -0.00909126f, -0.10719728f, -0.26690015f, 0.04562678f, -0.07575484f, 
    0.08923285f, -0.08245062f, -0.10354087f, 0.22166000f, -0.18305026f, -0.00383076f, -0.07619368f, 0.01340899f, 
    -0.13762389f, 0.10473171f, -0.11890595f, -0.09308615f, 0.08129283f, 0.03884911f, -0.16682987f, -0.18403538f, 
    0.24544986f, -0.02481396f, -0.07551253f, -0.15870449f, 0.08888743f, -0.07168087f, -0.09484805f, 0.19731441f, 
    0.03410824f, -0.12523346f, 0.06342059f, 0.06521517f, -0.10782308f, -0.08085962f, -0.06220836f, 0.07769027f, 
    -0.16591553f, -0.12797739f, -0.03211600f, -0.00294618f, 0.05674325f, 0.02202637f, -0.14292595f, -0.09324373f, 
    -0.04563973f, -0.08725356f, -0.00728867f, 0.05447480f, 0.00588718f, 0.04385520f, 0.05607450f, -0.01467962f, 
    0.03216526f, 0.15469828f, -0.03108709f, 0.07705602f, -0.06152745f, -0.06415306f, 0.00619018f, 0.15187070f, 
    0.20768578f, -0.02511217f, -0.07601415f, 0.03151280f, 0.10625780f, 0.05055672f, -0.02387872f, 0.20484973f, 
    -0.05429995f, 0.02132800f, 0.06723342f, 0.05663337f, -0.03225884f, 0.01704560f, -0.12766169f, -0.24350701f, 
    0.13225864f, 0.19262180f, -0.06282058f, -0.06485403f, 0.09243104f, -0.22643909f, 0.03287275f, -0.15013008f, 
    -0.03984076f, 0.15541971f, 0.17485441f, -0.00484697f, 0.09394920f, -0.00174747f, -0.07121826f, 0.12757210f, 
    -0.00019002f, -0.10223515f, 0.11144353f, 0.00812724f, 0.04719519f, 0.06056058f, 0.03210694f, 0.03847159f, 
    0.04596611f, 0.06923710f, -0.12459105f, 0.05129354f, -0.02903551f, -0.10293119f, 0.02181323f, -0.09050398f, 
    0.15469240f, 0.06383207f, -0.00735294f, -0.04996163f, 0.14250171f, 0.16247261f, 0.06606831f, 0.03983488f, 
    -0.00677225f, -0.12708592f, -0.08498684f, -0.02181640f, 0.24575244f, -0.17061564f, -0.23226292f, -0.03720525f, 
    -0.01115061f, 0.04478742f, 0.01358827f, -0.05461894f, -0.17527279f, -0.03461833f, 0.02867964f, -0.06700933f, 
    0.07798100f, -0.38026574f, 0.12371295f, -0.06219051f, 0.00413341f, -0.08905344f, 0.07504521f, 0.07971726f, 
    -0.14329600f, 0.01841524f, 0.04831725f, 0.13731097f, 0.05744185f, -0.03199555f, 0.07776123f, -0.27869919f, 
    -0.05243641f, 0.06316839f, 0.09383287f, -0.13855073f, 0.00784794f, -0.07947057f, 0.07168621f, -0.01837265f, 
    0.00138176f, 0.10577865f, -0.16486587f, -0.12555271f, 0.08578741f, 0.14459415f, 0.02518312f, -0.06081919f, 
    0.03793696f, -0.10727154f, 0.00829832f, -0.08776336f, -0.09725665f, 0.07712370f, -0.20102805f, -0.03559363f, 
    0.06841683f, -0.09401624f, -0.20193304f, -0.05501549f, 0.17408761f, -0.04154546f, -0.07870992f, 0.09066251f, 
    0.03484655f, -0.09949850f, -0.31780350f, 0.17210732f, -0.03610847f, -0.10736042f, -0.06191412f, 0.12472864f, 
    -0.04807878f, -0.01674817f, 0.04366755f, 0.13220355f, -0.04893728f, 0.03614631f, 0.01363349f, 0.03128780f, 
    -0.00939216f, 0.10308973f, 0.12736130f, 0.04809027f, 0.00440692f, -0.06133367f, -0.22377357f, -0.19144893f, 
    0.05201570f, -0.07587042f, -0.07901499f, 0.02681481f, 0.00209741f, -0.04858585f, -0.10164993f, -0.01365057f, 
    -0.01302160f, -0.15483251f, -0.02377790f, -0.01308513f, -0.40369985f, 0.11767139f, -0.47886986f, -0.05081850f, 
    0.20655815f, -0.12633286f, 0.02647867f, -0.10512249f, 0.21117024f, 0.06377050f, -0.16428611f, -0.03970178f, 
    -0.10113525f, -0.11224847f, 0.15460292f, 0.02851930f, 0.01970809f, -0.01833851f, 0.14446966f, -0.02688713f, 
    0.08804826f, -0.00517661f, 0.00144893f, 0.01064679f, -0.06389901f, 0.17210069f, -0.22428060f, 0.17616178f, 
    0.18843162f, 0.07524317f, 0.02664046f, -0.04626546f, -0.01065514f, -0.00252330f, -0.07111493f, -0.29640090f, 
    -0.37437761f, -0.24839400f, 0.18018910f, 0.18619485f, 0.07060185f, -0.02656261f, -0.03297201f, -0.02105043f, 
    0.10420617f, -0.10861063f, -0.03964674f, 0.08910605f, 0.37460783f, 0.12777233f, 0.24419902f, 0.05077131f, 
    0.04184964f, -0.04871436f, 0.10255718f, 0.18880130f, -0.05588283f, 0.09281139f, -0.04551113f, 0.06389647f, 
    0.04591981f, -0.26613826f, 0.03243235f, -0.06396464f, -0.03312219f, 0.00721352f, 0.03701573f, 0.12861548f, 
    -0.01633506f, 0.10859082f, 0.12445349f, 0.13117684f, 0.10005961f, 0.18640198f, -0.04099553f, -0.17022160f, 
    0.07793184f, -0.10772941f, -0.04367683f, 0.19978943f, -0.05704002f, 0.00974744f, -0.00326045f, -0.15202950f, 
    0.36088145f, -0.01104368f, 0.10170840f, -0.12701139f, -0.12975363f, 0.16088258f, -0.01601003f, 0.04769313f, 
    0.08797732f, -0.04776086f, -0.03030657f, -0.18545008f, 0.06481885f, 0.06186089f, 0.03502541f, -0.14210823f, 
    0.18738437f, 0.12103290f, 0.02219755f, 0.14983574f, 0.02861397f, 0.10236929f, 0.16558672f, 0.05682335f, 
    -0.07613970f, 0.01659785f, -0.19953440f, -0.02164538f, 0.12864392f, -0.02913174f, -0.07628898f, -0.04345252f, 
    0.22644483f, -0.06406555f, -0.04703998f, 0.28774557f, 0.30233246f, 0.08926725f, -0.04663479f, 0.07516481f, 
    -0.02453871f, -0.02725813f, 0.03640588f, -0.16982567f, 0.23267160f, 0.05419310f, 0.30295846f, 0.03654056f, 
    -0.04541261f, -0.00968700f, 0.25424865f, -0.13380386f, 0.00192973f, -0.15161930f, 0.04773358f, 0.10324053f, 
    -0.04879466f, -0.15612726f, 0.19891720f, 0.11916414f, 0.07364382f, 0.08289473f, -0.38165537f, 0.33601293f, 
    0.12536427f, -0.05704660f, -0.08285940f, 0.02003781f, 0.05921027f, 0.04466831f, 0.04624343f, -0.00650805f, 
    0.11697701f, 0.04336776f, 0.19816932f, 0.01481346f, 0.09868514f, 0.26095521f, -0.02479570f, 0.18099521f, 
    0.03660776f, -0.08879808f, 0.01978647f, 0.03988992f, -0.29945669f, -0.08706198f, -0.05211281f, 0.13972650f, 
    0.07271852f, 0.06576692f, -0.03257158f, -0.08872745f, -0.10701177f, -0.12295239f, -0.17420554f, -0.04318713f, 
    -0.07684141f, -0.20068462f, -0.09811814f, -0.26199856f, -0.06450316f, -0.05151192f, 0.02244466f, 0.04056819f, 
    0.09037041f, 0.02065429f, 0.07445160f, -0.03447418f, 0.08647030f, 0.13429940f, -0.27594271f, -0.15320294f, 
    0.10945950f, -0.16103715f, -0.13284473f, 0.20235185f, -0.18245558f, -0.07491993f, 0.01075378f, 0.15518413f, 
    -0.22138414f, 0.04562238f, -0.27981380f, -0.18876222f, 0.05149907f, -0.06806932f, 0.07577829f, -0.07396674f, 
    0.04273928f, 0.05068943f, 0.00985847f, 0.08717123f, 0.10630852f, -0.18494445f, -0.07307489f, -0.07587071f, 
    0.09397156f, 0.00854779f, 0.10101689f, 0.20023151f, 0.01584510f, -0.00489110f, -0.21690346f, -0.20430885f, 
    0.27784148f, 0.27365178f, 0.28901276f, -0.09229875f, 0.15858686f, 0.09923847f, 0.19454834f, 0.20711119f, 
    -0.02790788f, -0.13086843f, -0.07800413f, 0.03326212f, -0.42182985f, 0.01566053f, 0.09161555f, 0.29021865f, 
    0.07559519f, -0.07285946f, 0.03169132f, -0.07527693f, -0.04815691f, -0.12456843f, -0.07742092f, -0.03115121f, 
    -0.08388917f, 0.07064348f, 0.10403748f, 0.13614824f, 0.04203551f, 0.00482108f, 0.01776266f, 0.16287769f, 
    -0.07932944f, -0.03209020f, 0.06946897f, 0.00840617f, -0.11715513f, -0.03597648f, -0.05807552f, -0.15012737f, 
    0.05034234f, 0.17762849f, -0.07662646f, 0.05452896f, 0.23627615f, -0.16367878f, -0.04985002f, 0.09919100f, 
    0.11716739f, -0.05780577f, -0.35824758f, 0.14595981f, -0.04860090f, 0.07641052f, -0.05945957f, -0.16460070f, 
    0.01523611f, -0.07128765f, 0.09723961f, -0.02095609f, -0.06649996f, 0.02967265f, -0.18160756f, 0.08805179f, 
    0.02150434f, 0.14980067f, -0.04334154f, 0.04109410f, 0.08681463f, 0.11425323f, 0.09432989f, 0.07866280f, 
    0.16384986f, -0.03686517f, -0.04851824f, 0.05001059f, 0.08378049f, -0.06556806f, -0.06545106f, 0.06624956f, 
    0.15317164f, -0.00475320f, 0.09597709f, 0.12633775f, 0.22637130f, -0.03085201f, 0.04671112f, -0.18607682f, 
    0.14153296f, -0.02857404f, -0.04556079f, 0.10670333f, 0.08987700f, -0.14045095f, -0.13667077f, 0.05186620f, 
    -0.03600490f, -0.10597757f, -0.01836350f, 0.19408512f, 0.16222681f, -0.14212424f, -0.06168421f, 0.02807575f, 
    0.02123686f, -0.01630520f, 0.02003319f, 0.10716936f, -0.25383475f, 0.15668218f, -0.12211712f, 0.11134772f, 
    0.20267570f, 0.05338868f, -0.15426129f, 0.06334706f, 0.07307411f, -0.00626509f, 0.12402687f, -0.02304133f, 
    -0.09264164f, -0.01784541f, 0.11437128f, -0.05849681f, 0.13090928f, 0.18468986f, 0.08818264f, 0.05222876f, 
    0.03927344f, -0.07038494f, 0.00413110f, 0.07029578f, -0.05958971f, -0.06254646f, -0.03248170f, -0.03312345f, 
    0.08767464f, 0.17519704f, -0.04355133f, 0.02404269f, -0.00111687f, -0.11900385f, -0.12990479f, -0.15892199f, 
    0.04033883f, -0.15936546f, -0.12245418f, 0.10272215f, 0.04643348f, 0.01647990f, 0.01574535f, -0.11411636f, 
    0.07345278f, 0.27401635f, 0.05064204f, -0.09032850f, -0.22989297f, 0.27160734f, 0.08546230f, -0.05217823f, 
    -0.02121878f, -0.05431244f, 0.16221268f, 0.20943470f, -0.01255447f, -0.04746430f, -0.02698842f, 0.01241466f, 
    -0.12889931f, 0.06154291f, -0.20789070f, 0.06443889f, 0.04209541f, -0.13704512f, -0.20389919f, 0.19317341f, 
    0.06485985f, 0.08216680f, -0.00120968f, 0.16954282f, -0.29264864f, -0.02663299f, 0.17296651f, -0.00308359f, 
    0.10243656f, -0.00732692f, 0.07517279f, 0.07096245f, 0.00433438f, -0.05426339f, -0.01496879f, 0.20705485f, 
    0.28461608f, 0.07803127f, 0.00529476f, 0.07944424f, 0.14024031f, 0.12652801f, -0.01447954f, 0.06620432f, 
    0.07801960f, 0.02844595f, -0.13191907f, 0.02010632f, 0.14242731f, 0.06748852f, 0.10858462f, -0.08224562f, 
    0.07493787f, 0.13788119f, 0.14976588f, -0.09701524f, 0.02953754f, 0.10889588f, 0.18262294f, 0.24056056f, 
    0.39944816f, 0.28116158f, -0.18965967f, -0.07782471f, -0.13382885f, -0.19760120f, -0.07599708f, -0.08358358f, 
    -0.02921252f, -0.00478815f, 0.01164138f, 0.00460594f, 0.01737813f, 0.05538102f, -0.43246490f, -0.15311556f, 
    -0.03983700f, -0.08593291f, -0.08388747f, 0.02700817f, 0.05718987f, -0.04560426f, 0.03916296f, 0.09675986f, 
    -0.00211548f, 0.00964199f, -0.09931277f, -0.25460187f, -0.10426491f, -0.03342520f, 0.06056986f, 0.13069233f, 
    -0.02996588f, -0.17257538f, -0.05244271f, -0.11845347f, 0.14827858f, 0.20371933f, 0.08362009f, 0.18427075f, 
    0.05261011f, -0.05338279f, -0.06746539f, 0.02736211f, 0.04743222f, 0.02445136f, 0.00984387f, 0.09704483f, 
    0.08623401f, 0.13638453f, 0.10726546f, 0.03266836f, -0.06787309f, 0.06694763f, -0.01638226f, 0.03067509f, 
    -0.04391357f, -0.17750619f, -0.05974529f, -0.20670979f, -0.41696656f, 0.00481494f, -0.19357476f, -0.49439216f, 
    -0.08189892f, -0.16264871f, 0.09865258f, 0.04619912f, -0.06240600f, 0.05202894f, 0.05922351f, -0.06535958f, 
    -0.19232436f, -0.00019634f, 0.18826155f, -0.06564289f, 0.08057883f, 0.09255541f, -0.07300755f, 0.01215407f, 
    -0.00525429f, -0.01590045f, 0.15886562f, 0.03179806f, -0.27965274f, -0.17982703f, -0.28311116f, -0.28956351f, 
    -0.19021766f, -0.08965221f, 0.01199836f, -0.01005289f, 0.08856482f, -0.11111168f, 0.01709471f, -0.16898727f, 
    -0.04976170f, -0.10189825f, 0.29141012f, 0.24239881f, 0.04050716f, 0.05685270f, 0.00564520f, 0.00553427f, 
    -0.10888575f, -0.17828339f, 0.04316344f, 0.04501631f, 0.04705447f, 0.12913802f, 0.04831849f, 0.01101161f, 
    -0.06442997f, 0.06849788f, -0.04352529f, -0.08629106f, -0.06248903f, -0.02458217f, 0.04516610f, 0.05444232f, 
    0.03419248f, -0.04155207f, 0.00697959f, -0.02478410f, 0.00020112f, 0.15404889f, 0.07690767f, -0.01083130f, 
    -0.02189605f, -0.03577128f, -0.02229768f, 0.10225357f, 0.16515532f, 0.04737255f, 0.02200130f, 0.05830759f, 
    -0.00595500f, 0.00429549f, -0.04012289f, -0.03884161f, 0.05640393f, 0.04166703f, -0.09878682f, -0.03686067f, 
    0.00380533f, -0.01049116f, -0.03936309f, -0.08714171f, -0.09837282f, 0.10947399f, 0.06421894f, 0.04430202f, 
    -0.02324747f, -0.18858932f, 0.00352303f, -0.20698220f, 0.12243572f, 0.17322695f, 0.20844446f, 0.19069545f, 
    0.11433073f, 0.01368740f, -0.04084543f, 0.02396642f, 0.10611669f, -0.05596579f, 0.03353776f, 0.21759062f, 
    -0.06894118f, 0.02711197f, -0.00253370f, -0.12627408f, -0.13594230f, -0.08094766f, -0.15990765f, -0.04865254f, 
    -0.13663054f, -0.13652992f, 0.00728211f, -0.16343899f, 0.14299704f, 0.19619773f, 0.00174845f, -0.07791816f, 
    0.03755187f, 0.08417045f, -0.04834047f, -0.00532142f, 0.03687619f, -0.09710520f, 0.06381547f, -0.04460359f, 
    0.41061303f, 0.02918866f, 0.09295060f, 0.01652062f, 0.03624083f, -0.02710657f, -0.12951665f, 0.02281145f, 
    0.06919446f, 0.19140960f, 0.01009878f, -0.00466268f, 0.67752206f, 0.11018156f, -0.18857160f, 0.18636702f, 
    0.00520405f, -0.01462599f, 0.02312723f, 0.00926062f, -0.00777077f, 0.03084578f, 0.08411071f, -0.01979556f, 
    -0.02509521f, 0.09973929f, 0.22036791f, 0.13254853f, 0.00555526f, 0.05266507f, 0.03868714f, 0.17811784f, 
    0.08898626f, -0.01849364f, 0.02240721f, -0.04858852f, 0.30250520f, -0.20567790f, 0.11148693f, 0.10040579f, 
    -0.01705095f, 0.16352300f, -0.09412472f, -0.06265447f, 0.06953771f, 0.07418716f, 0.09778070f, 0.04314812f, 
    0.17618017f, -0.38112456f, -0.08293948f, -0.01041803f, -0.05603691f, -0.05023705f, -0.06373110f, -0.12714852f, 
    0.02548186f, -0.02630657f, -0.10722489f, 0.12146570f, 0.47611684f, -0.11153140f, 0.14413969f, 0.15057850f, 
    -0.13415308f, 0.02207400f, -0.04355477f, 0.01964362f, 0.05088982f, -0.02450598f, 0.05246243f, -0.00770835f, 
    -0.14122798f, 0.05622669f, -0.04940468f, -0.13868782f, 0.01028194f, -0.07348476f, -0.05762465f, 0.03559006f, 
    -0.09292857f, -0.00421569f, 0.04794106f, 0.00249387f, 0.20540632f, 0.01713232f, -0.06489351f, -0.12395404f, 
    0.01251970f, 0.16387212f, 0.10548706f, 0.01380749f, 0.04246727f, 0.14394975f, -0.18364659f, -0.02385139f, 
    0.00219291f, -0.14205217f, 0.10234411f, -0.10969965f, 0.07877986f, 0.10097715f, -0.13948958f, -0.11804123f, 
    0.01441298f, 0.08952338f, -0.01769911f, 0.04159218f, 0.02034749f, 0.07407860f, 0.01613476f, -0.02584055f, 
    -0.01753605f, 0.07946480f, -0.14474596f, -0.02053258f, -0.05617723f, -0.03782535f, 0.00065323f, -0.05628784f, 
    0.14239813f, 0.03037143f, 0.04351369f, 0.06008960f, -0.06220042f, 0.02889423f, 0.00628505f, -0.04807756f, 
    0.02408257f, -0.04257390f, -0.01514746f, -0.04312040f, 0.10860518f, 0.03190367f, 0.12055026f, -0.02785308f, 
    -0.13043591f, 0.18296699f, -0.06517278f, -0.01431256f, -0.05891202f, 0.01970112f, 0.00901382f, 0.03273971f, 
    -0.05191415f, -0.26423886f, -0.16524085f, -0.18479504f, -0.13731456f, -0.13002360f, -0.05709660f, 0.04963564f, 
    0.16333267f, -0.12254784f, -0.00610030f, -0.09950006f, 0.16230910f, 0.38641366f, -0.25229967f, -0.00528581f, 
    -0.04499894f, -0.00928878f, 0.17704378f, 0.00107240f, -0.09214002f, 0.04239606f, -0.00642122f, -0.05225543f, 
    0.18288185f, 0.09671755f, 0.14784445f, 0.12853548f, -0.02092445f, -0.02331357f, 0.00854074f, -0.02644840f, 
    0.05914296f, 0.03031360f, 0.09214268f, -0.02054171f, 0.00022449f, -0.24936585f, 0.25051224f, -0.02090178f, 
    -0.22094133f, 0.19767320f, -0.02624544f, 0.06213470f, 0.02667179f, -0.02889805f, -0.01591608f, -0.06888641f, 
    -0.04702983f, -0.20591490f, -0.02626737f, -0.07659123f, -0.00788116f, -0.01695157f, -0.08656297f, -0.02555394f, 
    -0.11578158f, -0.25113764f, -0.09631058f, 0.00488387f, 0.08918616f, 0.18014380f, 0.45056304f, -0.14896132f, 
    -0.21320914f, -0.22397308f, -0.09351463f, 0.14434637f, -0.06107930f, 0.01340638f, 0.09655789f, -0.05775640f, 
    0.04391006f, -0.34166023f, -0.18678591f, 0.29737261f, -0.03279854f, 0.00145962f, -0.00189754f, 0.04756539f, 
    -0.00248120f, 0.08620945f, 0.11647331f, 0.04009243f, -0.07641318f, -0.02002385f, 0.01442624f, -0.05156546f, 
    -0.10535862f, -0.09205307f, -0.17751226f, 0.05538229f, -0.09893246f, -0.10615840f, 0.01464754f, -0.02494493f, 
    0.13198821f, 0.12246154f, -0.06697094f, -0.05274594f, 0.00335882f, 0.11729490f, 0.08245885f, 0.00053654f, 
    -0.04851651f, 0.12925652f, -0.15049151f, 0.08270206f, 0.15703270f, -0.28141606f, 0.04133708f, -0.13495463f, 
    -0.17223917f, -0.00081349f, 0.08605789f, 0.01623548f, -0.12530443f, -0.31450152f, 0.10250910f, -0.38202211f, 
    -0.14568268f, -0.03198614f, 0.17110963f, 0.00532548f, 0.07855378f, -0.08283136f, -0.04275165f, 0.11133273f, 
    0.03333713f, -0.10269444f, 0.01177303f, 0.02040138f, 0.05916538f, -0.25380379f, -0.03025068f, -0.08528047f, 
    0.08893280f, 0.09313433f, 0.02164926f, -0.03504468f, 0.07744680f, 0.15369651f, -0.13577874f, 0.12251133f, 
    0.04187470f, 0.19189595f, 0.25375459f, 0.16405460f, 0.02744157f, -0.07418340f, 0.04783161f, -0.08623154f, 
    0.00948566f, -0.01888873f, -0.02990430f, 0.00645281f, 0.21238400f, 0.06867636f, 0.09321496f, 0.09377491f, 
    0.04161727f, 0.02956668f, -0.04419625f, -0.02037509f, -0.00136005f, -0.00200707f, -0.01268689f, 0.00781646f, 
    0.27743062f, 0.18170509f, 0.09868657f, 0.03195456f, -0.01562682f, 0.07682363f, -0.06200118f, 0.04073174f, 
    0.19776769f, -0.09906983f, 0.06009323f, 0.11921757f, -0.12631543f, 0.01617088f, -0.07992609f, -0.13584800f, 
    -0.11859237f, 0.09592319f, 0.00681928f, 0.16426931f, -0.01885059f, 0.01750081f, 0.03533353f, 0.07105695f, 
    0.34582978f, 0.18189405f, -0.00284082f, 0.12626301f, -0.11468916f, 0.04827975f, 0.01044533f, -0.03389336f, 
    0.04803815f, 0.09564510f, -0.04604411f, 0.12774090f, -0.00960292f, 0.10390675f, -0.01122242f, 0.00192435f, 
    -0.01242828f, -0.06237448f, 0.02358495f, 0.09941589f, -0.02010394f, 0.09116839f, 0.02461519f, 0.00556845f, 
    -0.01803485f, 0.02920741f, 0.29764688f, 0.26291257f, 0.00823411f, 0.05185813f, -0.02527042f, -0.00182311f, 
    0.04192613f, -0.07343470f, -0.16608821f, 0.12281094f, 0.24317858f, 0.21898876f, 0.07721851f, -0.00258480f, 
    -0.04756932f, -0.07504733f, -0.03702096f, -0.02516355f, 0.01177394f, 0.06118331f, 0.04749889f, -0.02727300f, 
    -0.21964720f, -0.04174658f, 0.00642236f, 0.01756647f, 0.25152686f, -0.29994518f, -0.04680818f, -0.08681129f, 
    -0.11674771f, -0.12005239f, -0.11015216f, 0.16927159f, 0.36005726f, -0.01669331f, 0.15611714f, 0.13541442f, 
    0.04341200f, -0.03472908f, 0.00481505f, 0.07154165f, 0.14627609f, 0.10409348f, 0.19668764f, 0.13880171f, 
    0.00581385f, -0.09890812f, -0.04074524f, -0.11557230f, -0.03222758f, 0.01894101f, 0.03809518f, 0.05271286f, 
    0.00274854f, -0.05999990f, 0.26661426f, -0.06164462f, 0.05656562f, -0.00923160f, 0.01700979f, 0.03520420f, 
    0.10897841f, -0.02966901f, -0.15833847f, -0.00486508f, -0.03494443f, 0.12031022f, 0.16440171f, 0.04251735f, 
    0.19889809f, 0.01626516f, 0.14105816f, 0.04725377f, 0.02604422f, 0.03680157f, 0.00989054f, 0.02135818f, 
    0.15098926f, -0.26664114f, -0.10054737f, 0.12062389f, -0.20892800f, -0.14044353f, 0.32976303f, 0.23962334f, 
    -0.04052930f, 0.08415578f, 0.26553598f, 0.02294413f, 0.11296436f, -0.06031037f, 0.14528382f, -0.07252301f, 
    0.18672636f, 0.14795880f, 0.12107536f, 0.06027012f, 0.01994608f, -0.01830090f, -0.03796370f, -0.01714208f, 
    0.18538338f, -0.02501215f, 0.14950708f, -0.01045706f, 0.24699967f, 0.22613178f, -0.02003844f, -0.05365317f, 
    -0.04682858f, 0.17214206f, -0.13459995f, 0.00454871f, 0.01237091f, 0.06506761f, -0.07064464f, 0.16348821f, 
    -0.05529317f, 0.16616639f, 0.30867955f, 0.10739862f, -0.05509582f, -0.02058929f, 0.07164666f, 0.02689228f, 
    0.04055709f, -0.06633355f, -0.03236483f, -0.15747239f, -0.01677425f, 0.03542009f, 0.14522994f, -0.02870953f, 
    0.01063348f, 0.13385476f, -0.12185101f, -0.09372058f, -0.05294071f, -0.04136375f, -0.01163323f, 0.02778609f, 
    0.20038807f, 0.03643175f, 0.02178095f, -0.08956174f, -0.01006154f, -0.07546388f, -0.03704666f, -0.03664317f, 
    0.09060238f, -0.00968086f, -0.08639432f, -0.14255412f, -0.21446997f, 0.07358456f, 0.18882135f, 0.07328062f, 
    0.00347291f, -0.17394842f, 0.03055889f, 0.01159566f, 0.00289216f, -0.05489611f, 0.06976782f, 0.02856463f, 
    0.16667067f, 0.18081319f, -0.09872118f, 0.02239760f, 0.00127003f, 0.16283432f, 0.05403830f, 0.16657333f, 
    0.24401924f, 0.27480739f, 0.03518560f, 0.03104633f, -0.09765174f, 0.26744223f, 0.20927389f, 0.00630156f, 
    -0.02073574f, -0.08477168f, 0.05932466f, -0.05227628f, 0.00512544f, -0.07022464f, -0.15555488f, -0.07646938f, 
    -0.08651861f, -0.15880585f, 0.11139209f, 0.11016491f, -0.03105469f, 0.07581190f, 0.00863113f, -0.04186461f, 
    -0.01050454f, 0.14244626f, 0.01441445f, -0.00422178f, 0.10379907f, 0.00207904f, 0.08684006f, 0.08700099f, 
    -0.08910767f, -0.04882976f, 0.07781495f, -0.06541455f, 0.19558124f, -0.09445792f, -0.01953522f, -0.01787388f, 
    0.02059602f, -0.01840053f, 0.00523172f, -0.03254009f, -0.03997507f, -0.03863343f, 0.00272356f, -0.02129136f, 
    0.01741295f, -0.03340607f, -0.00049370f, 0.01558222f, 0.00847618f, 0.02555721f, 0.02761356f, -0.02217150f, 
    0.01419160f, -0.00880982f, -0.03093351f, -0.01825488f, -0.04054504f, -0.00418433f, -0.03014653f, 0.01264519f, 
    -0.02411202f, -0.01843879f, 0.00647310f, -0.02820634f, -0.02904307f, 0.01120964f, -0.03979829f, -0.01195142f, 
    0.01346032f, -0.00265677f, -0.01960187f, 0.00402388f, -0.01654409f, 0.01836251f, -0.03279993f, -0.01089277f, 
    0.02215117f, -0.04287818f, 0.02295535f, 0.00667962f, 0.02114670f, -0.02083745f, -0.01069126f, 0.01573740f, 
    -0.03483189f, -0.01933265f, 0.00374173f, -0.01622117f, 0.02382463f, -0.00057187f, 0.01067091f, -0.03997690f, 
    -0.04403915f, -0.02159940f, -0.04259497f, -0.01977540f, 0.02031036f, -0.04240497f, 0.00679965f, -0.02985490f, 
    -0.00676755f, 0.00176673f, -0.01176610f, 0.01295544f, -0.02896190f, -0.01683154f, -0.02481579f, -0.04014164f, 
    0.02477147f, -0.01296268f, -0.03704007f, -0.02666212f, -0.03906329f, 0.02542056f, -0.03552379f, -0.03898742f, 
    -0.04061490f, 0.00720476f, -0.01533034f, -0.02598824f, -0.02588910f, 0.02603384f, 0.02130865f, 0.01084382f, 
    -0.04114046f, -0.02557487f, -0.03114999f, -0.00212947f, -0.00525968f, 0.02435433f, 0.01755740f, -0.01724611f, 
    -0.00614781f, -0.01072276f, -0.01799172f, -0.01578044f, -0.01736971f, -0.03079483f, -0.00992152f, -0.03302466f, 
    -0.03292563f, -0.04286697f, -0.02993401f, 0.02777160f, 0.02272682f, -0.00430934f, -0.02156949f, 0.02683756f, 
    0.01995055f, -0.03540760f, 0.01056166f, -0.02019821f, -0.00165882f, -0.01859515f, -0.03736470f, -0.02118029f, 
    -0.02429870f, -0.00775928f, -0.03921503f, -0.04310483f, -0.04060858f, -0.02919340f, -0.03373618f, -0.01750533f, 
    -0.02041478f, 0.01326542f, -0.00258987f, -0.01662072f, 0.01850716f, 0.01692228f, -0.01326232f, 0.02600575f, 
    0.00324467f, -0.01578925f, 0.02011585f, -0.00666253f, 0.00648427f, 0.00755929f, 0.02372687f, -0.02218842f, 
    0.01643739f, -0.01520398f, -0.03200398f, 0.02632232f, -0.02624875f, -0.04273288f, 0.01154095f, -0.02857269f, 
    0.02741254f, -0.02909765f, -0.02502559f, -0.02889102f, 0.00482398f, 0.02585383f, -0.02572555f, -0.01215720f, 
    0.01959377f, -0.02603081f, 0.00486011f, -0.00291729f, 0.02013879f, -0.00350227f, -0.04051561f, -0.01051523f, 
    -0.02139184f, 0.00044707f, -0.04238238f, -0.03052164f, 0.02848526f, 0.01249405f, -0.04022628f, -0.00568841f, 
    -0.00293177f, -0.04338727f, -0.01555725f, -0.02748797f, 0.02161903f, 0.01171618f, -0.04122366f, -0.01494226f, 
    -0.04447775f, 0.02453840f, -0.01705836f, -0.00963439f, 0.00412313f, -0.02304212f, 0.01998132f, -0.00595652f, 
    0.00081956f, -0.03761378f, -0.04143457f, 0.00416201f, -0.00124585f, 0.01142067f, 0.01331933f, -0.03545668f, 
    0.01590152f, 0.01066006f, -0.04153845f, -0.02051179f, -0.00163029f, -0.01350791f, -0.01628712f, -0.03094777f, 
    0.01225299f, 0.00241087f, -0.00038924f, -0.01308255f, 0.00964317f, 0.00834183f, -0.03275091f, -0.01032546f, 
    0.01098385f, 0.00106588f, -0.00440513f, 0.02587921f, -0.02964406f, -0.02545855f, -0.01170785f, 0.01872128f, 
    -0.03810964f, -0.02977000f, -0.03577438f, -0.01905165f, 0.01971912f, 0.01143498f, 0.02677377f, 0.02844673f, 
    -0.00450029f, 0.02187364f, 0.02494294f, -0.03567539f, -0.02777742f, 0.00211331f, 0.00112158f, 0.02845998f, 
    0.01054287f, -0.03460312f, -0.02982437f, 0.00112580f, 0.02012034f, -0.01253404f, -0.02011720f, -0.01960732f, 
    0.01881281f, -0.02285714f, -0.00729825f, 0.00669740f, -0.01401188f, -0.00240859f, 0.02193690f, 0.01831333f, 
    0.01560910f, 0.01849886f, -0.00637734f, -0.02530585f, -0.00074175f, 0.01545796f, 0.02025680f, -0.03868400f, 
    0.01598002f, 0.00009958f, 0.02737021f, -0.03310703f, -0.00580751f, -0.01637490f, 0.00037421f, -0.00536030f, 
    -0.04011598f, 0.00778852f, 0.02496197f, -0.03332038f, -0.01432558f, 0.00850333f, 0.00561082f, -0.02350702f, 
    0.00942010f, -0.03538749f, -0.02013214f, -0.03050646f, -0.01852873f, 0.00954448f, 0.02720623f, -0.02864703f, 
    0.01374728f, -0.00309678f, -0.02161828f, -0.00374582f, 0.02639394f, -0.01157244f, -0.04084345f, -0.02089576f, 
    -0.00411151f, -0.00205674f, 0.01655719f, 0.01697775f, -0.01438025f, -0.02421898f, 0.01889733f, -0.04250603f, 
    -0.00824282f, 0.01710888f, -0.02297295f, 0.01944310f, 0.01853022f, -0.00759301f, 0.01695166f, -0.01262365f, 
    0.01491954f, 0.01894408f, 0.00205567f, 0.01222042f, -0.01637653f, 0.01396708f, 0.02152788f, -0.00479033f, 
    -0.00684610f, 0.01708299f, -0.00061549f, 0.02152901f, 0.02475202f, -0.01602991f, -0.03680206f, 0.00364648f, 
    -0.02276985f, -0.02835480f, 0.02589117f, -0.01997994f, -0.01032586f, 0.01448782f, -0.01399045f, 0.00200407f, 
    0.00662758f, -0.02515418f, -0.02178600f, 0.01527426f, -0.02741713f, -0.01197483f, -0.02771297f, -0.01870335f, 
    -0.01154382f, 0.00041510f, -0.03863995f, -0.01852424f, 0.02548841f, -0.00211446f, 0.00974799f, -0.02254515f, 
    0.02288212f, -0.03421722f, -0.02030193f, 0.02304514f, -0.00602394f, -0.04021409f, -0.01510753f, -0.00315337f, 
    -0.01220489f, -0.03217087f, 0.00791134f, 0.01392613f, -0.02267627f, -0.03515258f, 0.02324117f, -0.03316541f, 
    -0.02511847f, -0.00946995f, -0.03893802f, -0.03334012f, -0.03864859f, -0.01324084f, -0.04066180f, 0.00399409f, 
    0.02449900f, -0.03817348f, -0.02473420f, -0.03515462f, -0.00935024f, -0.04197622f, -0.00243266f, 0.00875474f, 
    -0.02839172f, 0.01209904f, -0.04432422f, -0.02868002f, 0.02119641f, -0.02657637f, -0.03762988f, -0.01550836f, 
    -0.02923094f, -0.02588683f, -0.01463681f, -0.03245069f, -0.01421287f, 0.02525185f, 0.00230093f, 0.02336561f, 
    -0.03879753f, 0.00880997f, -0.01757698f, -0.03351500f, 0.01858848f, -0.04114165f, 0.00641143f, -0.03925731f, 
    -0.01095702f, -0.03835891f, 0.02382608f, 0.00299245f, -0.03664544f, -0.01665304f, 0.01797621f, 0.02598274f, 
    -0.01370281f, -0.03583505f, -0.00074251f, 0.00499950f, -0.03548782f, 0.02808998f, -0.03870401f, -0.01444993f, 
    0.01282882f, 0.02192683f, -0.02189438f, -0.04079767f, -0.00668671f, 0.00829086f, -0.02381141f, 0.01356672f, 
    -0.01657181f, -0.03121493f, -0.03502969f, -0.02925156f, 0.00809639f, 0.00449228f, 0.02369171f, -0.00604542f, 
    -0.02920489f, -0.01222389f, 0.00700475f, -0.04269670f, -0.00037649f, 0.02598921f, 0.01889707f, -0.03699467f, 
    -0.03858371f, -0.03186637f, -0.02884311f, -0.00445398f, -0.03796316f, -0.01742070f, -0.01175573f, -0.03121247f, 
    -0.03619814f, 0.02332811f, 0.02475537f, 0.00108062f, -0.01901876f, -0.02576315f, -0.01898150f, -0.01223014f, 
    -0.03048764f, -0.03363149f, -0.02793678f, 0.02469688f, 0.02783547f, 0.00308226f, -0.00865952f, -0.03973036f, 
    -0.02481115f, 0.00733291f, -0.04213315f, 0.01632257f, 0.02263728f, 0.01069193f, 0.02329773f, 0.00891192f, 
    -0.01912626f, -0.01578713f, 0.00064252f, -0.02847845f, -0.01900564f, 0.02110918f, -0.00548168f, -0.04087260f, 
    0.00427046f, -0.02094016f, 0.00373856f, 0.00691423f, 0.02456159f, 0.01517027f, -0.03461369f, -0.02309551f, 
    -0.00125085f, -0.01392450f, -0.02037224f, -0.00340506f, 0.00173231f, -0.03206470f, -0.01267330f, -0.02536671f, 
    0.00478950f, 0.02246583f, 0.02081924f, -0.01647311f, -0.01040791f, -0.00249810f, 0.02475223f, 0.00306452f, 
    -0.01873342f, 0.02573583f, -0.03365465f, 0.00470640f, 0.00629231f, 0.01762727f, 0.01842651f, -0.00833218f, 
    -0.03915116f, 0.00144123f, -0.04323056f, -0.02761490f, 0.01305828f, -0.00112134f, -0.00029118f, -0.01470410f, 
    -0.03534323f, -0.01378813f, -0.03920421f, 0.02163250f, 0.00611963f, -0.02019399f, 0.01852018f, -0.03967529f, 
    -0.03293972f, -0.02827808f, -0.01704574f, -0.03754600f, -0.02640041f, 0.01888614f, -0.03415858f, 0.00877702f, 
    -0.03830599f, 0.00355912f, 0.01558773f, -0.03479277f, -0.04336423f, -0.00211419f, -0.03763330f, 0.01241460f, 
    -0.00869229f, -0.03125394f, -0.00214033f, 0.02589863f, -0.01920591f, 0.00876191f, -0.01818347f, 0.02910102f, 
    -0.03787109f, -0.01783266f, -0.03032064f, -0.01871181f, -0.01356433f, -0.02451948f, -0.01711386f, 0.02490658f, 
    0.00519697f, -0.04097389f, -0.02526576f, 0.00666460f, 0.01177867f, -0.03488713f, -0.00754915f, 0.01446605f, 
    -0.02917519f, -0.02529174f, 0.01277510f, -0.00592995f, 0.01650846f, -0.01260656f, 0.01414775f, 0.00860481f, 
    0.01138072f, 0.01486385f, -0.03063922f, 0.00416386f, 0.00712284f, -0.02912662f, 0.01229375f, -0.01806440f, 
    0.02396487f, 0.02263555f, -0.03341753f, -0.04418248f, -0.04075230f, -0.04126064f, -0.03537217f, -0.00962271f, 
    -0.00991857f, -0.02717784f, 0.02416338f, 0.00849800f, 0.02147419f, 0.00443769f, 0.01946153f, -0.03671373f, 
    -0.02402478f, -0.01434085f, 0.01772387f, 0.02111957f, -0.03784275f, 0.01683928f, 0.02761814f, 0.01836255f, 
    0.00542838f, -0.03599247f, -0.00170427f, 0.02738148f, 0.02172780f, 0.01863029f, -0.03938511f, -0.04193983f, 
    0.00217090f, 0.00345756f, -0.01546760f, 0.00777137f, 0.00409821f, -0.00181744f, -0.00030621f, -0.00198702f, 
    -0.03824709f, 0.02361035f, 0.00881191f, -0.01518001f, 0.00032874f, -0.00634786f, -0.01959961f, -0.02602268f, 
    -0.03930752f, 0.00556365f, -0.04207992f, -0.02514578f, -0.03636730f, -0.01827147f, -0.02080953f, -0.03022534f, 
    0.02779879f, -0.04104079f, -0.01372346f, -0.00441764f, 0.00549367f, -0.01023932f, -0.02934231f, -0.01293380f, 
    -0.03425085f, 0.00779711f, -0.02903037f, -0.01813795f, 0.01860848f, -0.01465074f, 0.00748107f, -0.01375409f, 
    -0.00852232f, -0.00875342f, -0.03307126f, -0.00025795f, -0.04433315f, 0.00358385f, -0.02611642f, -0.01043870f, 
    0.00277127f, -0.00836735f, -0.00957888f, -0.00272486f, -0.00846880f, -0.03063820f, -0.00409815f, -0.00807509f, 
    0.02737126f, -0.01949003f, 0.01417853f, 0.01302541f, 0.01617735f, 0.00513088f, 0.01979523f, -0.02024822f, 
    0.00685425f, 0.02284616f, -0.01794806f, 0.01779557f, -0.02163316f, 0.02727195f, 0.00666450f, 0.01324147f, 
    -0.01174770f, -0.00976125f, 0.01459966f, -0.03229654f, 0.01825857f, 0.02080405f, -0.01868466f, -0.04146607f, 
    -0.00946158f, -0.00477131f, 0.01148934f, 0.01871890f, 0.02779511f, 0.00592265f, -0.01149036f, -0.02607412f, 
    -0.01682933f, 0.02836319f, 0.02474875f, -0.01140269f, -0.01411065f, 0.00246632f, 0.02038494f, 0.00065157f, 
    0.00228914f, -0.03428701f, 0.01541476f, -0.00149192f, 0.00300532f, 0.02478061f, 0.00854159f, 0.00869400f, 
    0.01091877f, 0.02284943f, -0.04214413f, -0.02096801f, -0.02897710f, -0.02250549f, 0.00110138f, 0.00626556f, 
    0.01597735f, 0.01897863f, -0.00853177f, 0.02648430f, 0.02637349f, 0.00476997f, 0.01716883f, -0.00426492f, 
    -0.00804007f, -0.03575183f, -0.00253980f, 0.01694439f, 0.02480411f, -0.02401789f, -0.00252566f, -0.02060072f, 
    0.00334938f, -0.01549406f, -0.00983952f, 0.02646644f, -0.00884189f, 0.03279485f, -0.02435631f, -0.01769377f, 
    -0.00722746f, -0.01317519f, -0.03657393f, 0.00873534f, 0.01030486f, -0.02230740f, -0.00997671f, -0.03534645f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01865240f, -0.02100957f, 0.01239821f, -0.04167756f, -0.00632609f, 0.01254581f, 0.16313560f, 0.03991431f, 
    -0.01201502f, 0.02360429f, 0.01083058f, -0.06294519f, -0.03080867f, 0.07985520f, 0.05999809f, -0.01673329f, 
    0.01648012f, 0.02710382f, 0.00362622f, -0.01834104f, -0.03659249f, 0.01048138f, 0.17999113f, 0.01733896f, 
    0.02489696f, -0.00272129f, 0.19215250f, 0.08848405f, 0.13240117f, 0.06352948f, 0.08840574f, 0.00613597f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13553539f, 0.09129342f, -0.38067898f, 0.08251259f, 0.00534658f, -0.03131448f, -0.51006389f, 0.10222580f, 
    -0.09241428f, -0.03673366f, -0.02710108f, 0.32111299f, -0.37619758f, -0.34284195f, -0.71694976f, 0.10466506f, 
    -0.17537972f, 0.23015803f, -0.07014048f, -0.10421871f, 0.15609920f, -0.13303049f, 0.32551304f, 0.05132612f, 
    0.11072712f, 0.03128648f, -0.04135346f, 0.02704028f, -0.10691721f, 0.17477867f, -0.29945630f, 0.04668595f, 
    0.09706331f, -0.05837294f, 0.04729130f, -0.02421399f, -0.16762413f, -0.01257455f, -0.30792782f, 0.03341661f, 
    -0.08518260f, -0.12284543f, 0.04313335f, -0.45189065f, -0.32805371f, 0.33956593f, -0.37754440f, 0.01300216f, 
    0.03580457f, 0.18796803f, -0.01225873f, 0.06721029f, 0.09571259f, -0.24765138f, 0.36542344f, 0.10278924f, 
    0.05131828f, -0.11414208f, 0.45143437f, 0.00658475f, 0.13573650f, -0.16442439f, 0.23038125f, -0.16553259f, 
    0.12317150f, 0.09170355f, -0.12974109f, 0.11355581f, -0.04055187f, 0.17090015f, -0.06031002f, 0.06519432f, 
    0.12797445f, 0.09163992f, -0.13355556f, -0.66064411f, -0.02619417f, 0.39234647f, 0.30699164f, 0.00879225f, 
    0.15652156f, 0.27732962f, 0.09447591f, 0.16877788f, -0.21689337f, 0.17802215f, -0.05346577f, -0.16120069f, 
    -0.18229075f, -0.02258940f, -0.53270251f, -0.26093560f, 0.12278806f, 0.21520124f, -0.14795449f, -0.05881450f, 
    -0.12860435f, -0.01386183f, 0.27308071f, -0.12698999f, -0.07625355f, -0.06747543f, -0.12416261f, -0.05731601f, 
    -0.15151396f, -0.07452742f, -0.08550402f, 0.24615122f, 0.21141902f, 0.47075525f, 0.01099298f, 0.00651972f, 
    -0.13850574f, 0.01504194f, -0.12632819f, 0.03273014f, 0.06044956f, 0.03965097f, -0.23047915f, -0.12810838f, 
    0.04486291f, 0.00736046f, -0.32253078f, -0.10697074f, -0.75780702f, 0.04608081f, -0.33707952f, 0.13650073f, 
    -0.06423710f, 0.11418939f, -0.22987975f, 0.03381334f, -0.10532692f, 0.12522362f, -0.04934612f, -0.06778081f, 
    0.06342297f, -0.06524306f, -0.14812866f, 0.12224629f, -0.22360350f, -0.58004379f, 0.07434299f, -0.09539054f, 
    -0.11500547f, 0.07541928f, -0.05986162f, 0.11582120f, 0.14177093f, 0.38202703f, -0.36352295f, 0.02992703f, 
    -0.09422886f, 0.10484125f, 0.01007897f, -0.24108794f, 0.04446070f, 0.17377269f, 0.27329385f, 0.11920274f, 
    0.11126278f, 0.06619801f, -0.35354775f, -0.13959268f, -0.04523126f, -0.02425443f, 0.11411778f, -0.07093743f, 
    -0.04117074f, -0.11669834f, 0.08822160f, 0.01204150f, -0.42531812f, -0.11902439f, 0.30817339f, -0.08767621f, 
    0.15401056f, -0.48288152f, 0.11172786f, -0.01136564f, 0.10015561f, -0.24598743f, 0.16387905f, -0.10209552f, 
    0.01214951f, 0.08140017f, 0.00753684f, 0.17898582f, 0.20789731f, 0.29099590f, 0.18556619f, 0.05470106f, 
    0.13811815f, 0.02790151f, 0.25549141f, 0.01113324f, 0.16996753f, -0.05122864f, 0.09249480f, -0.23531477f, 
    -0.18342166f, 0.06638505f, 0.05377180f, -0.75807482f, 0.30221590f, 0.12541811f, 0.16616961f, -0.10293257f, 
    0.13256110f, -0.02312801f, 0.01033873f, -0.01071803f, -0.64878088f, -0.20077622f, -0.68450922f, -0.06448125f, 
    0.14760913f, 0.04194840f, 0.11185873f, 0.03679896f, 0.29825675f, -0.04727659f, -0.36109051f, 0.13631059f, 
    0.01207584f, 0.02087811f, -0.09639253f, -0.00416232f, 0.08538264f, -0.07700825f, -0.49871203f, 0.00420637f, 
    0.05225575f, -0.13839737f, -0.15022212f, 0.32412177f, 0.25541067f, 0.12673405f, 0.35922971f, -0.12330326f, 
    -0.17722268f, 0.18166886f, -0.02590328f, -0.04828684f, -0.37417507f, -0.40014458f, -0.29172072f, 0.14230116f, 
    -0.15321331f, -0.01768351f, -0.30457520f, 0.35175332f, -0.22381203f, -0.07137457f, 0.26593933f, -0.10787901f, 
    0.05698988f, -0.14148915f, 0.23843017f, 0.11803296f, 0.12249137f, 0.10099632f, 0.21921684f, 0.44870421f, 
    -0.03055004f, -0.10646683f, -0.09578262f, 0.08539931f, -0.39097100f, 0.01327996f, 0.22870329f, -0.15019603f, 
    -0.08774164f, -0.17390493f, 0.18014592f, -0.03129455f, -0.57513064f, -0.63428551f, 0.20504858f, -0.01712700f, 
    -0.03922430f, -0.03975433f, -0.23495094f, 0.12550297f, -0.33974272f, -0.17037019f, -0.14505085f, -0.17136322f, 
    0.13462141f, -0.04265130f, -0.15974276f, -0.00771075f, -0.13880807f, -0.06749643f, 0.23832351f, -0.53176558f, 
    0.15153658f, 0.04009086f, 0.06751113f, 0.03711019f, 0.22634484f, -0.70658273f, -0.22220176f, 0.03927382f, 
    -0.01857768f, 0.18031232f, -0.13415776f, 0.13761829f, -0.09630613f, 0.12796633f, -0.10769543f, -0.06485885f, 
    0.01364294f, 0.06328758f, 0.03899384f, 0.32206586f, 0.07094902f, -0.06872743f, -0.13152429f, -0.12767331f, 
    -0.12638755f, -0.01414900f, 0.39241087f, -0.16756549f, -0.03814901f, -0.07394093f, 0.18957411f, -0.49978906f, 
    -0.05336417f, 0.08392923f, 0.06608219f, 0.23685466f, -0.19467326f, 0.28212082f, 0.36334190f, -0.09442358f, 
    0.05257113f, -0.02301678f, 0.00743548f, 0.05008752f, -0.09024758f, -0.28606698f, 0.40466595f, 0.01552378f, 
    -0.06948271f, 0.07500684f, -0.26574448f, -0.50182170f, -0.16489704f, -0.60434496f, -0.09033407f, -0.10011227f, 
    0.08533867f, -0.11571579f, 0.29747364f, 0.16244893f, 0.00946680f, 0.11117325f, -0.06293194f, 0.21736293f, 
    0.07556721f, 0.09603775f, -0.10811919f, 0.06079590f, 0.24660069f, 0.22632435f, -0.55427331f, -0.13388231f, 
    0.01029978f, -0.67856169f, 0.05682847f, 0.12123858f, -0.21257980f, 0.39287734f, -0.08083969f, -0.14731069f, 
    0.00585504f, 0.10101029f, -0.31260529f, -0.06673352f, 0.05820663f, -0.39135125f, 0.09792026f, 0.15406010f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04435622f, 0.16277570f, 0.35807058f, -0.30882984f, 0.19732244f, 0.30566761f, -0.13371798f, -0.07102762f, 
    -0.26349047f, -0.44243094f, -0.13609487f, -0.31872630f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
