#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.46782231f, 0.85762864f, 0.72025937f, -0.78657782f, -0.60144848f, -0.09595092f, 0.06358528f, 0.05998595f, 
    0.15058520f, -0.79162621f, 0.57247692f, 0.36972174f, -0.69849163f, 0.53956586f, 0.48541039f, -0.10907569f, 
    -0.36490718f, -0.44793308f, 0.38423085f, 0.01228440f, 0.77230453f, 0.46924716f, -0.43041515f, 0.20963305f, 
    -0.09618086f, -0.42048520f, 0.58200502f, -0.65526187f, 0.18474138f, 0.93927526f, 0.41578108f, 0.55479795f, 
    1.05665898f, -0.44705114f, 0.17406769f, 0.51004797f, -0.07333898f, 0.62153560f, 0.75367808f, 0.26464093f, 
    0.21654971f, -0.17792343f, -0.29930946f, -0.29388848f, -0.11887278f, 0.94768167f, 0.71516460f, 0.39851841f, 
    0.31888077f, 0.30041879f, 0.46884787f, 0.23509157f, -0.52962071f, -0.21133387f, -0.55430210f, -0.63223249f, 
    -0.62765974f, 1.04487717f, -0.43308637f, 0.42179698f, -0.16193257f, -0.22697924f, -0.43168506f, 0.38193968f, 
    1.13618731f, -0.93622965f, -0.36323771f, 0.02321676f, -0.04803015f, -0.13899018f, -0.09187985f, 0.42093441f, 
    -0.52875900f, -0.71291375f, -0.26741931f, -0.59941858f, -0.07454085f, -0.71259511f, 0.37147132f, -0.12006680f, 
    -0.08601693f, 0.06758146f, 0.03510334f, -0.47508389f, -0.72618127f, -0.67048043f, -0.60341990f, -0.21764800f, 
    -0.51679122f, -0.22726065f, -0.00644356f, -0.26619783f, 0.14570583f, 0.06377718f, -0.18208098f, -0.55830085f, 
    0.29948008f, 0.03817559f, 0.98940456f, -0.27346128f, 0.28064522f, -0.13506977f, 0.18682387f, -0.97952807f, 
    1.03703070f, 0.42147744f, -0.40080133f, -0.19212054f, -0.18031587f, -0.05567756f, -0.26695359f, 0.04352828f, 
    1.54513741f, -0.44034585f, 0.14058574f, -0.28608182f, -0.39705300f, -1.34360337f, -0.17869782f, 0.43969750f, 
    0.65636075f, -0.05542703f, -0.32880223f, -0.18955255f, 0.09100448f, -0.32558686f, -0.65302664f, -0.06650565f, 
    0.33737275f, 0.33565468f, 0.40441471f, 0.20232835f, 0.72927523f, -0.27467838f, 0.40978292f, 0.58976161f, 
    0.30649424f, 0.06686104f, -0.27726877f, 0.67093283f, -0.83087403f, -0.00374639f, 0.49758580f, 0.28934076f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.13711415f, 0.19121194f, 0.48790199f, 0.10284127f, 0.26285464f, -0.02713592f, 0.35103008f, 0.71753669f, 
    -0.04874669f, 0.27496278f, 0.31487259f, -0.17752680f, 0.06265347f, -0.08052336f, 0.48692805f, 0.46784565f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.25450081f, 0.09695479f, 0.18659554f, 0.06222052f, 0.07615735f, 0.03044098f, -0.24841787f, 0.12517449f, 
    0.27704448f, -0.00428509f, -0.03653245f, 0.11227979f, -0.01040372f, -0.09561370f, -0.00394331f, -0.07089596f, 
    -0.19225977f, -0.08135758f, 0.00854752f, 0.12407512f, 0.58661932f, 0.01359595f, 0.20779267f, -0.04001744f, 
    0.06317513f, -0.03006200f, -0.05465894f, -0.10987495f, 0.13141188f, 0.00273044f, 0.39714265f, -0.10811596f, 
    0.03825520f, 0.01609959f, 0.05746797f, -0.10505897f, -0.09638952f, 0.10047428f, 0.15743604f, -0.02179664f, 
    -0.01720555f, -0.05505873f, -0.05289877f, 0.05605144f, -0.30259562f, 0.02878339f, 0.06330964f, 0.19158860f, 
    -0.00700367f, -0.07316145f, 0.00666501f, 0.00611914f, -0.22086728f, -0.30875179f, -0.08383127f, -0.01410382f, 
    -0.03966669f, 0.19031446f, -0.05532140f, -0.12236419f, -0.32194796f, -0.08073802f, 0.04584234f, 0.00385466f, 
    0.03362682f, 0.16744128f, 0.05645531f, 0.14662178f, 0.03331346f, -0.08835261f, 0.09668808f, 0.10909124f, 
    -0.43663907f, -0.29073766f, 0.22557756f, 0.18505245f, 0.06254687f, -0.10027194f, 0.17103402f, -0.01868732f, 
    0.13182263f, 0.12049856f, -0.07922330f, -0.25678149f, 0.05462304f, 0.10176390f, 0.19317676f, 0.00953847f, 
    0.03874961f, -0.05701502f, 0.10595505f, 0.12977131f, 0.01425124f, -0.09207556f, 0.25293443f, 0.04316965f, 
    -0.04442772f, -0.00847312f, -0.10521883f, 0.03530219f, 0.15388685f, 0.60888457f, -0.01003000f, 0.11732687f, 
    0.36119455f, -0.24689297f, -0.43443584f, -0.04137891f, 0.06439402f, 0.20376387f, 0.11756710f, 0.21506420f, 
    -0.01303607f, -0.08648400f, -0.22436772f, 0.22815235f, -0.26455000f, -0.49548349f, 0.02909628f, -0.04401967f, 
    0.25927258f, 0.05992776f, -0.03791942f, 0.03509378f, -0.02799328f, -0.00766014f, -0.07728452f, 0.05052331f, 
    0.30954272f, -0.03172879f, -0.11556193f, 0.10294674f, -0.16073605f, -0.02099927f, 0.01562202f, 0.23424935f, 
    -0.06440452f, -0.08731529f, 0.02290042f, 0.13165317f, 0.06876617f, -0.14333965f, 0.16966276f, 0.20296659f, 
    -0.08219381f, 0.05804241f, 0.03838269f, 0.03710397f, -0.00078337f, 0.02950600f, -0.03090003f, -0.03904306f, 
    0.05166708f, -0.01604403f, -0.06496336f, 0.04827422f, -0.00334919f, 0.02676459f, -0.03102105f, -0.04004448f, 
    -0.05536945f, -0.04228899f, -0.01912679f, 0.02736593f, 0.01550888f, -0.05671188f, -0.06287882f, -0.06671286f, 
    -0.02737415f, -0.02637209f, -0.06285267f, 0.04210772f, -0.01048272f, 0.02466825f, -0.08251425f, 0.05063008f, 
    0.04295098f, -0.01935683f, -0.08534893f, -0.04899741f, 0.02649910f, -0.07509416f, 0.00005823f, -0.00568813f, 
    0.03658920f, -0.04617665f, -0.03079618f, -0.02699018f, -0.03122644f, -0.06910060f, -0.08896772f, -0.07571788f, 
    -0.03498916f, 0.05133033f, -0.04916746f, 0.07925680f, -0.07898098f, -0.01729791f, 0.06991110f, -0.04146452f, 
    -0.07294498f, -0.03726514f, 0.04030189f, -0.09178539f, -0.05981784f, 0.04697401f, -0.08194704f, -0.06008419f, 
    -0.05845720f, -0.07503437f, 0.00015521f, 0.03823964f, 0.01332622f, 0.06542949f, -0.01768983f, 0.04850397f, 
    -0.08854841f, 0.06759486f, 0.01259229f, 0.05134860f, -0.02475762f, -0.07274964f, 0.00108193f, 0.04797056f, 
    0.06752683f, 0.00834846f, -0.01133674f, 0.02058960f, 0.03575666f, 0.02961757f, 0.01820393f, 0.06292285f, 
    -0.06462356f, -0.05244229f, 0.06663767f, 0.06956843f, 0.05054745f, 0.01419366f, 0.05549607f, -0.01227735f, 
    -0.08470075f, -0.04781488f, -0.07113702f, 0.02282536f, -0.03096173f, 0.00449954f, -0.08615410f, 0.03852769f, 
    0.05970517f, -0.04586713f, -0.01686222f, -0.06808453f, -0.09227394f, -0.03436151f, -0.00000266f, -0.03159480f, 
    0.07188707f, -0.06896154f, 0.05785980f, -0.00597987f, 0.04856400f, -0.07640411f, -0.08447938f, -0.07093721f, 
    -0.01772928f, 0.05046538f, 0.02419934f, 0.00485509f, -0.04925468f, -0.03575012f, 0.03652057f, 0.00545727f, 
    0.04433865f, -0.01793533f, -0.04576240f, -0.00253599f, -0.06579001f, 0.07029825f, -0.00478991f, -0.01725367f, 
    -0.08751518f, -0.02929504f, 0.08130661f, -0.04744569f, -0.06550339f, 0.02272488f, 0.06351684f, -0.06677129f, 
    -0.04116049f, -0.27390519f, 0.15394725f, 0.13972680f, 0.17378058f, -0.19954288f, -0.04507954f, 0.01800845f, 
    0.03188448f, -0.20482391f, -0.27739850f, 0.10512147f, 0.02270408f, -0.00238373f, 0.20485961f, 0.08476953f, 
    -0.23816633f, 0.14990760f, -0.03957518f, -0.25674242f, 0.00903304f, 0.18056044f, 0.34651840f, -0.06347349f, 
    0.24756528f, -0.06813321f, -0.16672496f, 0.36232504f, -0.25631708f, -0.51525885f, -0.00388646f, -0.14525440f, 
    0.27989197f, -0.06354708f, -0.01978980f, 0.05488316f, -0.05427504f, -0.07424977f, -0.25994244f, 0.36153424f, 
    0.17923892f, -0.05579219f, 0.14678563f, -0.19411701f, -0.11397983f, 0.08869096f, -0.21399117f, -0.88642293f, 
    0.02664843f, -0.13637160f, 0.05534784f, 0.23268940f, -0.15825701f, 0.20093693f, 0.37673727f, -0.09161674f, 
    -0.03134553f, -0.08865654f, 0.00510608f, 0.10787871f, 0.06806219f, -0.16940695f, -0.08269180f, -0.23576809f, 
    -0.10790320f, -0.20677163f, 0.05281667f, -0.08913243f, -0.12501115f, 0.07985668f, 0.01456545f, -0.11364488f, 
    0.51812649f, 0.18306217f, 0.13910075f, 0.17530064f, -0.15916818f, 0.00955992f, 0.18519358f, 0.03285594f, 
    0.17186598f, 0.07329335f, 0.06420759f, 0.37106931f, -0.17543785f, 0.07322189f, -0.01788972f, -0.16411860f, 
    -0.06211868f, -0.10893058f, 0.05524594f, 0.23476914f, -0.15479940f, 0.08001481f, 0.10375395f, 0.12827343f, 
    0.19336337f, 0.06955820f, 0.00964478f, -0.48851490f, -0.15774059f, 0.18082660f, -0.07549375f, 0.20360208f, 
    0.08127405f, 0.12740996f, 0.04944999f, -0.17852382f, 0.28199789f, -0.51809067f, 0.12445462f, -0.11055291f, 
    -0.20325156f, -0.07500255f, -0.04101661f, 0.05626909f, 0.05392812f, 0.15852442f, 0.10797250f, -0.00869170f, 
    -0.22780880f, -0.00962569f, 0.08533774f, -0.29137698f, -0.01264105f, -0.02973182f, -0.30852580f, -0.12516841f, 
    -0.07577342f, -0.02334679f, -0.00684168f, -0.05135059f, 0.05767102f, 0.00750031f, 0.03080331f, -0.31067270f, 
    -0.67546856f, 0.01997770f, 0.13769805f, 0.01626277f, -0.05690275f, -0.07234381f, 0.21282814f, 0.22632839f, 
    0.22764289f, 0.21444449f, -0.05276986f, -0.25973234f, -0.03686563f, -0.01056492f, 0.02500897f, -0.03806179f, 
    -0.02551462f, 0.02145254f, 0.25623843f, -0.10901374f, 0.17185105f, 0.19299111f, -0.03391530f, 0.15493831f, 
    0.04268738f, 0.21825778f, 0.14818707f, 0.14157239f, 0.15727840f, -0.04124224f, 0.11799809f, 0.01610472f, 
    0.24300589f, 0.16575485f, -0.26207685f, -0.16836457f, -0.19215265f, -0.21741986f, 0.14635752f, 0.32407424f, 
    0.12116412f, -0.11013289f, 0.06768232f, -0.35488254f, 0.09632821f, 0.22541653f, 0.16864982f, -0.02930737f, 
    0.13597913f, 0.03207877f, 0.14932430f, -0.04851873f, -0.11756921f, 0.16461043f, 0.18076250f, 0.02907499f, 
    0.03945273f, -0.10802659f, 0.05091551f, 0.04965679f, 0.02265656f, -0.09483618f, -0.16220620f, -0.07761052f, 
    -0.04387229f, 0.27786079f, -0.00221647f, 0.37259367f, 0.20017107f, 0.23194084f, 0.39978495f, 0.11589738f, 
    0.11859215f, 0.29366463f, 0.05188880f, 0.34411761f, -0.07156087f, 0.25475308f, 0.08833945f, 0.11040382f, 
    0.05722950f, -0.21765587f, -0.19782072f, 0.09887122f, 0.00713196f, -0.01961446f, 0.04773783f, 0.05967401f, 
    -0.13518383f, 0.14377049f, -0.02900242f, 0.44197768f, 0.23459297f, 0.08097520f, 0.01828889f, -0.05043368f, 
    -0.02264895f, 0.06279504f, -0.20061277f, -0.11168806f, -0.13676696f, 0.24755503f, 0.05895160f, 0.03926377f, 
    -0.26446506f, -0.30988055f, -0.51288551f, 0.02211199f, 0.22543022f, -0.01451165f, -0.02538073f, 0.02624594f, 
    0.17885715f, 0.15822035f, 0.09476227f, 0.18112613f, -0.09200031f, 0.02180278f, 0.05172741f, 0.30728179f, 
    0.20831695f, 0.18493408f, 0.12193815f, -0.01928111f, 0.22542813f, 0.02405569f, -0.07718386f, -0.23836024f, 
    -0.06244286f, -0.16422185f, 0.13545555f, 0.06528325f, 0.01697837f, 0.29106861f, 0.04793742f, -0.08504251f, 
    0.05297967f, 0.00492088f, -0.01660878f, 0.13552140f, 0.11223695f, -0.00227825f, 0.03302582f, 0.18984254f, 
    -0.03495421f, 0.03080378f, 0.06673711f, 0.13620818f, 0.07157529f, -0.04934352f, -0.14701194f, -0.24260573f, 
    -0.01744602f, -0.02469214f, -0.05668584f, -0.04021544f, 0.03203835f, 0.03665162f, -0.04483837f, -0.06090809f, 
    -0.03985755f, 0.04516000f, -0.03311187f, -0.04493926f, -0.08103777f, 0.03230384f, 0.05606175f, -0.07547272f, 
    0.03173038f, -0.08816438f, 0.02492497f, -0.06563213f, -0.06985953f, -0.08567284f, -0.02758375f, 0.06379157f, 
    0.02301409f, 0.06379934f, -0.07253271f, 0.00104629f, -0.03542440f, -0.09225144f, -0.02789573f, -0.01010247f, 
    -0.07393692f, -0.03577273f, -0.04844946f, -0.03702311f, -0.05332679f, -0.03064697f, 0.00556365f, -0.02261607f, 
    0.06646547f, -0.09244608f, 0.05360954f, -0.04785764f, 0.03914243f, -0.06972922f, -0.05616312f, -0.01791095f, 
    0.05572770f, -0.06935757f, -0.09397953f, 0.07416478f, 0.07957736f, -0.08237062f, -0.03299496f, -0.02446713f, 
    -0.02534647f, -0.02247615f, -0.02486077f, -0.06561423f, -0.09113729f, -0.05284926f, -0.00763688f, 0.02982128f, 
    -0.05602833f, -0.03880718f, -0.00010570f, -0.07615799f, 0.04346492f, 0.02162124f, 0.01039051f, -0.00801684f, 
    -0.07922224f, 0.00591137f, -0.06362636f, -0.07996847f, -0.02793466f, 0.03038014f, -0.05145043f, 0.05885948f, 
    0.00202037f, 0.04353998f, -0.07203504f, -0.08730226f, 0.00236277f, 0.01834676f, 0.05201387f, 0.05416049f, 
    -0.07374560f, 0.07327153f, 0.02280341f, -0.03795341f, 0.06659431f, 0.00069839f, -0.02181100f, 0.04898882f, 
    -0.08570962f, -0.05343126f, -0.07035955f, -0.05051282f, 0.06346211f, -0.09716214f, 0.02564762f, -0.03109335f, 
    -0.02340744f, -0.02896105f, 0.05653898f, 0.01952532f, -0.02495826f, 0.05909216f, 0.00650562f, -0.03774981f, 
    0.02198234f, -0.02103846f, 0.02945000f, -0.05901857f, 0.02273494f, -0.05788253f, -0.00151871f, 0.01053365f, 
    0.02459663f, -0.07250584f, -0.00615351f, 0.00401193f, 0.07247412f, 0.00991870f, -0.05949012f, -0.00608079f, 
    0.04998903f, -0.06944095f, 0.03249575f, 0.02634002f, -0.04754427f, -0.03936972f, -0.04263455f, -0.03934478f, 
    -0.05825176f, 0.04624120f, -0.06944200f, -0.07389020f, -0.06122286f, -0.02168001f, 0.00828720f, 0.04257438f, 
    -0.65953481f, -0.42637378f, 0.08620568f, 0.00289886f, -0.18236424f, 0.03410162f, -0.06290799f, 0.12381922f, 
    0.04728351f, -0.41718176f, 0.13992600f, 0.51555181f, 0.05630849f, -0.25181243f, 0.14211035f, -0.03063316f, 
    0.00133884f, -0.31187701f, -0.18240800f, 0.09727544f, -0.08955795f, -0.02943718f, 0.26462561f, -0.08453990f, 
    -0.07277103f, -0.00007052f, -0.03653781f, -0.50998956f, 0.04107246f, -0.28119940f, -0.00516125f, -0.08617839f, 
    -0.09052173f, 0.02934939f, -0.08791602f, 0.09883241f, -0.09127451f, -0.06918763f, -0.18176746f, 0.03660819f, 
    0.01509160f, -0.12546648f, -0.04290819f, 0.07030184f, -0.12539747f, -0.38166937f, -0.34953082f, 0.00663148f, 
    0.09063334f, -0.08932436f, -0.09864599f, 0.01030219f, -0.03545441f, 0.09834265f, 0.22043419f, 0.17242786f, 
    -0.18374658f, 0.19063297f, 0.12771057f, -0.25314716f, 0.15651497f, -0.05026039f, -0.22022428f, -0.06546528f, 
    -0.25834310f, 0.07220956f, -0.02241055f, 0.31901130f, -0.01325016f, -0.01281551f, 0.12736039f, 0.12967554f, 
    0.18242466f, 0.16817364f, 0.00708825f, -0.04768215f, 0.00701919f, 0.06795715f, 0.05784767f, 0.06844988f, 
    0.00800333f, -0.05179680f, 0.37679082f, -0.00978971f, 0.03641493f, 0.03559702f, -0.11441428f, 0.18543625f, 
    -0.10904282f, 0.01652206f, 0.17603986f, 0.41964069f, 0.04930211f, 0.04878701f, 0.18015172f, -0.24221691f, 
    0.14940512f, 0.20706157f, 0.19010817f, -0.02732886f, 0.59580511f, 0.03807920f, -0.01710398f, -0.02838992f, 
    -0.04034920f, 0.01581383f, 0.03252500f, -0.01279852f, 0.20719464f, 0.23103492f, 0.02572605f, -0.27496707f, 
    0.11061221f, 0.01166804f, -0.04258110f, 0.16264522f, -0.03821778f, 0.35827923f, 0.23356663f, 0.24744911f, 
    -0.09602689f, 0.24283481f, 0.19107074f, 0.07637744f, 0.22284794f, 0.12538420f, -0.26838270f, -0.10608402f, 
    -0.14142135f, 0.06613283f, 0.01553534f, -0.04861778f, -0.05439235f, -0.24373601f, 0.18840384f, -0.11622279f, 
    0.09517301f, 0.00009254f, -0.15134427f, 0.04297839f, 0.03219983f, -0.07327000f, 0.22605963f, 0.03265250f, 
    -0.19972141f, 0.10224860f, 0.00045902f, -0.15042953f, -0.07997814f, 0.06419469f, 0.05808387f, 0.11897471f, 
    -0.15571555f, 0.25244522f, 0.05902528f, 0.15449551f, 0.00032230f, 0.17482214f, 0.07071247f, 0.12677936f, 
    -0.08452504f, 0.21035324f, 0.23644795f, -0.18094474f, -0.31727505f, 0.19444160f, 0.13142508f, 0.01785444f, 
    0.14887720f, 0.09192044f, -0.15336172f, 0.17183127f, 0.10811707f, -0.31779125f, 0.11015396f, -0.09575617f, 
    -0.10113203f, -0.21840920f, -0.40790290f, -0.00801826f, 0.08884805f, 0.08326377f, -0.21134171f, -0.17748845f, 
    -0.06070876f, -0.10373395f, 0.08427594f, -0.04792265f, -0.13481733f, -0.05585418f, -0.03574185f, -0.07920744f, 
    0.00843842f, 0.09473062f, -0.12694243f, 0.00128285f, -0.07156874f, 0.22229965f, -0.01749005f, -0.17902952f, 
    0.36095160f, 0.11012536f, 0.21846700f, 0.02093974f, 0.14558406f, 0.22748329f, 0.01770048f, -0.31255054f, 
    0.48716676f, 0.09436119f, 0.03449396f, 0.04154595f, -0.13350172f, 0.06500800f, 0.11233597f, -0.24101394f, 
    0.04500017f, 0.17991333f, 0.16079903f, 0.21442789f, 0.11327655f, -0.06790696f, -0.22308747f, -0.12074143f, 
    0.03035934f, 0.09433573f, 0.23606955f, 0.23551713f, -0.01931001f, -0.11427780f, -0.12303934f, 0.08876117f, 
    0.09791005f, -0.06165113f, 0.27725208f, 0.02481778f, -0.29056475f, 0.07017484f, -0.01673556f, -0.16306947f, 
    -0.06555427f, -0.33976832f, -0.26918182f, 0.35969177f, 0.41084683f, -0.08621550f, -0.30342233f, 0.17254148f, 
    0.06795409f, 0.16052434f, 0.10390534f, 0.06358049f, 0.10399527f, -0.21409221f, 0.24044220f, -0.04522028f, 
    0.00336106f, 0.16630039f, 0.10687941f, 0.17575905f, 0.21231821f, 0.25798908f, -0.03907949f, 0.22387798f, 
    -0.01544869f, 0.07525028f, 0.31949875f, 0.02815886f, -0.09193869f, 0.18932202f, 0.19359022f, -0.23613900f, 
    -0.08774336f, 0.00285256f, 0.08788756f, 0.10289712f, -0.14335021f, -0.30812073f, -0.09315504f, -0.02190125f, 
    0.10951377f, 0.14367108f, -0.12492078f, 0.16355997f, 0.01898498f, -0.26128730f, -0.11043324f, -0.58640707f, 
    -0.21674034f, -1.02408135f, -0.08954234f, 0.00940393f, 0.19942726f, -0.13111944f, 0.11368022f, -0.12763880f, 
    0.08810608f, 0.02252364f, 0.03469055f, -0.10621545f, 0.03226813f, 0.02442120f, 0.03952704f, 0.14938264f, 
    0.21679720f, 0.35554001f, 0.12552050f, 0.19854897f, 0.13412535f, 0.05284002f, 0.01619579f, 0.00406231f, 
    0.14597788f, 0.03148700f, 0.16161618f, 0.04611403f, 0.08370630f, -0.18068065f, -0.33299503f, -0.09276840f, 
    -0.12914376f, 0.07325611f, -0.11294208f, -0.08470418f, 0.21447304f, 0.26410720f, -0.03302282f, 0.00191243f, 
    -0.01915607f, -0.03690455f, 0.17278859f, 0.13131921f, -0.01194067f, 0.32068732f, 0.24878396f, 0.10002915f, 
    0.03531602f, -0.14526710f, -0.19712768f, 0.10243067f, -0.16366124f, 0.10489867f, 0.08061294f, -0.45431417f, 
    -0.38834557f, -0.22118653f, -0.11548261f, -0.01323640f, 0.05243550f, 0.04463204f, -0.05559459f, 0.09567479f, 
    -0.21214914f, -0.09544610f, -0.05703610f, 0.27139431f, 0.30771855f, 0.12921631f, -0.00584522f, 0.03381316f, 
    -0.12890099f, 0.14677364f, -0.60296923f, -0.23231496f, 0.01578824f, 0.02296185f, 0.12426390f, -0.10095529f, 
    -0.00955660f, -0.28152546f, -0.37307107f, -0.23664285f, 0.02848413f, 0.06963028f, -0.09702141f, 0.05349361f, 
    -0.03646708f, -0.00824478f, -0.07770985f, 0.04404215f, 0.29924834f, 0.06941748f, 0.13409628f, 0.17391220f, 
    -0.13592853f, -0.02241271f, 0.26250890f, 0.15426478f, 0.25709748f, -0.15822917f, 0.30081168f, -0.17647959f, 
    -0.21800798f, -0.18328908f, 0.14813867f, -0.15533693f, -0.13910206f, 0.03647017f, 0.00275589f, -0.10889155f, 
    -0.09463526f, 0.01088764f, 0.02741727f, 0.06842498f, -0.18799828f, 0.22877671f, -0.22906394f, 0.53799397f, 
    -0.17938426f, -0.06169087f, -0.03272069f, 0.18426530f, 0.08910178f, -0.06112481f, 0.27322638f, 0.44646683f, 
    0.23634152f, -0.08149085f, -0.30477512f, 0.39407003f, 0.02936341f, 0.01044984f, -0.00037220f, -0.14325127f, 
    -0.01009721f, 0.45502660f, 0.09677418f, -0.12240134f, -0.28166828f, 0.04352610f, -0.08448619f, -0.08235786f, 
    0.16892186f, -0.72602367f, 0.24250197f, -0.07651825f, 0.01547056f, -0.27480015f, -0.01427691f, -0.05952735f, 
    -0.15473169f, 0.07273961f, -0.25782192f, -0.01479836f, -0.14113262f, 0.13085051f, 0.17630602f, 0.03339857f, 
    0.02908829f, -0.00330955f, -0.65903074f, 0.10792887f, 0.21122898f, -0.04948588f, 0.11057983f, 0.12730598f, 
    -0.09017821f, 0.06641914f, -0.00413777f, 0.09554690f, -0.01004447f, 0.44788548f, -0.31603101f, -0.14302611f, 
    -0.10233600f, 0.02585052f, -0.16099688f, 0.08231217f, -0.31234390f, 0.19380403f, 0.21560262f, -0.14419188f, 
    0.09483536f, -0.00392211f, -0.10296919f, -0.03498758f, 0.10691525f, -0.47522402f, -0.28646562f, 0.10724904f, 
    0.17032515f, -0.15633258f, -0.42855996f, 0.13485867f, -0.01945997f, 0.07638422f, -0.29636556f, 0.09605337f, 
    0.27590758f, 0.00812440f, -0.05830995f, -0.03596133f, -0.07004457f, -0.04180379f, -0.03419473f, 0.60067445f, 
    -0.25083616f, -0.12637477f, 0.09617945f, 0.27565399f, 0.11722828f, 0.10350811f, 0.01489212f, 0.11177348f, 
    -0.17948556f, 0.06750633f, 0.47806773f, -0.28363481f, -0.37585387f, -0.13550900f, 0.14535916f, -0.20278011f, 
    0.02368571f, 0.19819553f, 0.28427935f, 0.46078637f, -0.09342214f, 0.05360791f, 0.05651060f, 0.30850473f, 
    -0.00054645f, 0.19722560f, -0.02413943f, 0.17560181f, 0.05674503f, 0.11388174f, 0.07829300f, -0.23170632f, 
    0.15735427f, 0.12402485f, -0.00575073f, -0.95532894f, 0.05068388f, 0.24018902f, 0.17079712f, -0.14781472f, 
    -0.21354550f, -0.20685555f, -0.00712778f, 0.17744705f, -0.47199285f, 0.62582690f, 0.12287744f, -0.10009068f, 
    -0.16804910f, -0.13936363f, -0.02287399f, 0.02304508f, 0.07026196f, -0.64172381f, -0.35520360f, 0.16411196f, 
    -0.12709233f, 0.02009461f, -0.19979253f, 0.00330613f, -0.00240620f, -0.03499268f, -0.00763613f, 0.12816864f, 
    0.34676701f, 0.08785620f, -0.04633272f, -0.21558073f, 0.12293594f, 0.06040430f, 0.05029169f, -0.54353666f, 
    0.06311616f, -0.29816809f, -0.07674928f, 0.04898330f, 0.00579723f, 0.09316366f, 0.09198628f, -0.15453471f, 
    0.65062863f, 0.34370038f, 0.38391924f, -0.21232547f, -0.29519209f, -0.21232714f, 0.00746850f, 0.14114429f, 
    0.15380085f, 0.06293433f, -0.02179657f, 0.08972224f, -0.11099739f, 0.07689575f, 0.04958152f, 0.06741969f, 
    0.13369097f, 0.06669051f, 0.11264563f, 0.15917593f, 0.23739412f, 0.12962112f, -0.09247377f, 0.05402324f, 
    0.14646645f, 0.08785458f, 0.10074908f, 0.24581221f, -0.28856745f, -0.09824008f, -0.16241610f, -0.09851632f, 
    -0.09451286f, -0.06839974f, -0.19011091f, -0.16319376f, 0.01756229f, 0.09700743f, 0.00517458f, 0.09520124f, 
    -0.16767405f, -0.02992433f, -0.08815031f, 0.13467142f, 0.08540492f, -0.04170409f, 0.11952472f, 0.17499438f, 
    -0.27955011f, -0.10489006f, -0.19359906f, -0.13995299f, -0.03669478f, 0.16012305f, -0.25280711f, -0.43758279f, 
    -0.38812280f, -0.20625655f, -0.00850040f, 0.09613679f, -0.09027825f, -0.11011340f, 0.00953161f, 0.04844018f, 
    -0.00159026f, 0.03141598f, 0.11534196f, 0.43910819f, 0.12890483f, 0.01239875f, 0.20367470f, -0.08933921f, 
    0.26186991f, -0.22737028f, -0.63715082f, -0.09912159f, 0.07702183f, 0.11625364f, -0.07504454f, -0.10204858f, 
    -0.02497996f, -0.27051228f, -0.07290825f, -0.10157732f, 0.08659281f, -0.14017877f, 0.06950941f, 0.08202402f, 
    -0.00285770f, 0.15048435f, 0.05654044f, 0.11650702f, 0.17103092f, 0.02563394f, 0.07402600f, -0.19256769f, 
    0.42497393f, 0.09036868f, -0.00608782f, -0.26023331f, 0.18606536f, 0.28845048f, 0.04303613f, -0.00268935f, 
    -0.13795318f, -0.02611678f, -0.29952127f, 0.03149317f, -0.69388217f, -0.13560002f, -0.82362407f, 0.05451463f, 
    0.16141944f, -0.20342922f, -0.00913975f, -0.13965851f, 0.06190563f, -0.15051517f, -0.19506779f, -0.93894547f, 
    -0.07776274f, -0.04043717f, 0.11016791f, 0.16096921f, -0.07384750f, 0.01637526f, 0.11720406f, -0.01518284f, 
    -0.33302772f, 0.07460154f, 0.05771140f, 0.01565869f, 0.01252847f, 0.19253448f, -0.08611058f, 0.17278457f, 
    0.36756289f, 0.10945568f, -0.19604419f, -0.10358624f, -0.01990284f, 0.14721212f, 0.13420913f, -0.10584085f, 
    0.14401560f, -0.42610991f, 0.05575138f, -0.23546660f, -0.04612546f, -0.18091382f, -0.02130249f, 0.03654552f, 
    0.18475232f, -0.13754357f, 0.01960695f, 0.15384381f, 0.24828663f, 0.01036260f, -0.11500818f, 0.12006757f, 
    0.07626953f, -0.07507621f, 0.12441880f, -0.00107565f, -0.24945258f, -0.18105468f, 0.30101186f, 0.14002770f, 
    -0.01057653f, 0.13460071f, -0.06337149f, -0.22696002f, -0.31705704f, -0.27859727f, -0.02641972f, -0.15211707f, 
    -0.09023198f, -0.03529805f, 0.08432876f, 0.21420394f, 0.01691815f, 0.08803383f, 0.18220919f, 0.16434853f, 
    -0.08376502f, 0.22319950f, -0.02984490f, -0.03406657f, -0.00744642f, 0.42759818f, -0.07079291f, 0.25832170f, 
    0.19841115f, 0.04980985f, 0.04917425f, 0.12846573f, 0.00010371f, -0.02201238f, -0.18153787f, 0.33033654f, 
    -0.13630585f, 0.11809300f, 0.19176267f, 0.03552134f, 0.01535003f, -0.08668165f, 0.23466338f, 0.77343756f, 
    -0.07457965f, -0.59216988f, -0.01518024f, -0.17064708f, 0.23720393f, -0.06612201f, 0.09758390f, -0.26059195f, 
    0.35355574f, 0.02903988f, 0.48809844f, 0.16534750f, -0.01028792f, -0.07736917f, 0.13088506f, -0.08817677f, 
    -0.12239984f, 0.07253043f, -0.04661228f, 0.21465003f, -0.05141057f, 0.05553018f, 0.03134248f, -0.02717305f, 
    -0.06514861f, -0.03807606f, 0.12942351f, 0.15670492f, -0.08303118f, -0.05523146f, -0.01975110f, -0.00641852f, 
    -0.31110150f, -0.45340636f, -0.26785246f, -0.03756280f, -0.16798241f, -0.60867602f, -0.00622582f, 0.04387116f, 
    -0.04585041f, -0.02292224f, 0.11317375f, 0.24524178f, -0.20032325f, -0.35764819f, -0.24656589f, 0.11308181f, 
    -0.11002459f, -0.16507238f, 0.14747973f, -0.01970396f, -0.02106996f, -0.33023435f, 0.03574128f, 0.36824709f, 
    0.18709956f, -0.07160769f, -0.01207240f, -0.10313343f, 0.14596525f, -0.05956612f, -0.14137833f, -0.19353837f, 
    0.05877773f, 0.18238382f, 0.02563581f, -0.04201809f, 0.14306709f, 0.05329590f, 0.13562433f, -0.00544624f, 
    -0.19300957f, -0.05154965f, -0.01433033f, 0.09174757f, 0.12725128f, -0.12906249f, -0.37189320f, -0.11256491f, 
    -0.39777920f, 0.13567807f, 0.00906212f, 0.02691771f, 0.17043287f, -0.00234009f, -0.20762226f, 0.03770633f, 
    0.04707611f, 0.04251389f, -0.07166311f, 0.13480359f, -0.00809605f, -0.13946374f, -0.03257092f, 0.11282007f, 
    0.04201352f, -0.01443715f, -0.09973911f, -0.10156690f, 0.05305468f, -0.04551446f, 0.05610925f, -0.05811020f, 
    0.04868200f, 0.03948157f, 0.14314710f, 0.29763031f, -0.29700258f, -0.07701615f, -0.24400727f, 0.13609274f, 
    -0.23946993f, 0.01393350f, -0.07692954f, -0.07236808f, 0.02720370f, -0.32708612f, 0.23324730f, 0.00164322f, 
    -0.04727511f, 0.09873579f, -0.05869001f, -0.12518643f, -0.39024198f, -0.08766401f, -0.22126737f, 0.23157693f, 
    0.08753560f, -0.07757289f, -0.23176664f, -0.00111484f, -0.02749887f, -0.08962066f, -0.02425186f, -0.16706301f, 
    -0.11779769f, -0.10447894f, 0.14782451f, -0.14934649f, 0.21228124f, -0.05236077f, 0.00296474f, 0.08923848f, 
    -0.01842917f, 0.15841570f, 0.06581809f, 0.15178835f, 0.37516713f, -0.07978523f, -0.08298085f, 0.19670068f, 
    0.13226831f, 0.06982231f, -0.44924375f, -0.05671826f, -0.12387572f, -0.26594415f, -0.08213062f, 0.06490635f, 
    0.04803886f, 0.05122316f, 0.04621235f, 0.07022986f, 0.01208529f, -0.04495230f, 0.13007674f, 0.08423727f, 
    0.03622322f, -0.15445732f, -0.03139774f, -0.04310114f, 0.07953761f, 0.04190769f, 0.21309979f, 0.08988909f, 
    0.07565175f, 0.33898252f, 0.28597069f, -0.12291251f, -0.19710591f, 0.09655489f, 0.09736819f, -0.00548350f, 
    -0.02540359f, -0.08182586f, -0.11734898f, 0.13650727f, -0.04745943f, -0.20422074f, 0.48712510f, -0.08448602f, 
    -0.15420224f, -0.18113106f, -0.10276590f, -0.08034088f, -0.11866011f, 0.90190077f, 0.15023628f, -0.16041516f, 
    -0.09187862f, -0.19905847f, -0.25768521f, -0.07591659f, 0.16795102f, 0.07502531f, 0.24065836f, -0.25336868f, 
    -0.09396046f, 0.17971118f, 0.27998352f, 0.16051237f, -0.16623539f, 0.09792203f, 0.00835660f, -0.33667991f, 
    -0.11925270f, 0.44586688f, -0.19054499f, 0.02772705f, 0.12995234f, -0.06758529f, 0.01415768f, 0.12328273f, 
    -0.60148948f, -0.08796817f, -0.20246062f, 0.06750561f, 0.06996583f, -0.02829451f, -0.13882151f, -0.01970175f, 
    -0.19763662f, 0.04370700f, -0.09103721f, -0.08694776f, 0.13713765f, 0.08198970f, 0.20427875f, -0.16574652f, 
    -0.42722446f, -0.14296232f, 0.10199073f, 0.12698941f, -0.29358932f, 0.10099819f, 0.02820783f, 0.12492358f, 
    -0.05551479f, 0.18037117f, 0.07222036f, 0.06763443f, -0.07169152f, -0.12683430f, 0.32663903f, -0.03394365f, 
    0.00277207f, -0.00403276f, -0.07824457f, 0.01679547f, -0.21497351f, -0.10700912f, -0.01993938f, -0.06198820f, 
    -0.02160481f, 0.21213372f, -0.03000106f, -0.17412202f, -0.13084227f, -0.25919187f, 0.02945526f, 0.10914583f, 
    -0.03279666f, 0.07064028f, -0.02370759f, -0.17907633f, 0.08585159f, -0.19016686f, 0.14196117f, 0.07905273f, 
    0.29277262f, 0.23249626f, 0.01205205f, -0.00949776f, 0.00999317f, -0.21686849f, -0.13592352f, 0.11182738f, 
    0.09534986f, 0.26063707f, -0.00177784f, 0.15075466f, 0.21781647f, 0.29824710f, -0.00378936f, 0.10941056f, 
    0.11581756f, -0.05838332f, 0.30336133f, -0.05708571f, -0.13230698f, 0.20030826f, 0.17920901f, 0.26675501f, 
    0.05509473f, 0.16260485f, -0.05544172f, 0.33592966f, 0.05702568f, 0.19282539f, 0.22304487f, -0.02102651f, 
    0.14782578f, -0.25116768f, -0.18885407f, -0.22487217f, 0.00615714f, 0.09422834f, 0.25563166f, 0.28664777f, 
    0.44337952f, 0.38220751f, 0.25223553f, 0.32706103f, 0.25269088f, -0.39011225f, -0.03662163f, -0.27234793f, 
    -0.16331302f, -0.17111981f, 0.26968342f, -0.23271208f, -0.00013192f, 0.10688519f, -0.27186614f, 0.14801092f, 
    0.08724709f, 0.27592888f, -0.15616050f, -0.12348441f, -0.38638890f, 0.30727798f, -0.03093234f, 0.16836058f, 
    0.35867262f, 0.05724904f, -0.22147699f, -0.03215721f, -0.34435242f, -0.07148132f, 0.14729530f, 0.09446780f, 
    -0.18018137f, 0.27278963f, 0.28038681f, 0.00507737f, -0.06847925f, 0.19349591f, 0.23483150f, -0.20583969f, 
    -0.16062120f, -0.16460972f, -0.00911300f, 0.06705631f, -0.06199281f, 0.34537035f, 0.18171442f, 0.19027585f, 
    -0.24536410f, -0.46351299f, -0.07696561f, -0.15737996f, -0.25045171f, -0.01291543f, -0.17878205f, 0.01352121f, 
    0.02692735f, -0.12522896f, -0.22742614f, 0.04638946f, 0.07575446f, -0.07816158f, 0.07916097f, -0.01334914f, 
    -0.01981844f, 0.03401914f, 0.30298552f, 0.52714676f, 0.12095131f, 0.09569538f, 0.07812653f, -0.00137907f, 
    0.20391650f, 0.25500256f, -0.01265798f, -0.07326537f, -0.25612566f, -0.56927842f, -0.10574565f, 0.02878163f, 
    0.04031335f, -0.12183705f, -0.20270261f, 0.00706076f, -0.22315124f, 0.29484662f, 0.24439734f, 0.10373966f, 
    -0.08146507f, -0.20636129f, 0.05068845f, 0.09844188f, -0.00276454f, -0.14784802f, 0.04079781f, -0.05933851f, 
    -0.33216497f, -0.37489200f, -0.51033950f, -0.13211390f, 0.00217621f, -0.16599277f, -0.30660239f, 0.39675856f, 
    0.20886317f, -0.05502238f, -0.17420736f, 0.00951605f, 0.00728990f, 0.01419933f, 0.04341725f, 0.37583771f, 
    -0.07529243f, 0.00602297f, 0.22240697f, 0.21733098f, 0.41518646f, 0.17703976f, 0.06938390f, 0.04102571f, 
    -0.38094845f, -0.02018987f, -0.14281426f, 0.00026076f, -0.05079523f, -0.08065280f, 0.07966602f, 0.08040783f, 
    0.09795300f, -0.37212929f, -0.22161411f, -0.19263016f, 0.13979571f, 0.00158349f, 0.05436368f, 0.14942597f, 
    -0.01926875f, 0.18375422f, 0.02644208f, 0.05488590f, 0.19298086f, 0.06361738f, -0.07148296f, -0.10886431f, 
    0.24085580f, 0.18446255f, 0.09833131f, -0.65746588f, 0.23674731f, -0.14730106f, -0.24428496f, -0.32379061f, 
    0.21632592f, -0.05247647f, 0.04629972f, 0.18331620f, -0.37494764f, -0.45168388f, 0.46630099f, 0.03171151f, 
    0.17390744f, -0.17160106f, 0.00433777f, 0.01871284f, 0.09145874f, -0.32571542f, -0.09091418f, 0.43374717f, 
    -0.14591566f, 0.03761486f, -0.07574727f, -0.23925938f, 0.04414283f, -0.05719162f, -0.05736974f, 0.12946515f, 
    0.27512375f, -0.03095262f, 0.03488838f, 0.28475070f, 0.00744846f, 0.09224323f, 0.13652226f, 0.05925358f, 
    -0.35362083f, 0.31886744f, 0.12669016f, 0.00652379f, -0.01784051f, 0.14025861f, 0.19246762f, 0.11231645f, 
    -0.11384404f, -0.49808413f, 0.11858504f, -0.07351261f, -0.11487757f, -0.06307655f, -0.02654392f, 0.12773813f, 
    0.09619284f, -0.18141331f, -0.12972388f, 0.08116747f, 0.15254022f, -0.11264021f, 0.17258720f, 0.02495378f, 
    0.12079401f, -0.20425150f, -0.03940202f, 0.11209820f, 0.10769785f, -0.06052433f, -0.00084964f, -0.31376177f, 
    -0.02200145f, -0.05719218f, 0.05529997f, 0.15363666f, -0.05156822f, -0.04777160f, 0.12040179f, -0.02681697f, 
    -0.15299669f, -0.08784769f, -0.19684577f, -0.09237032f, -0.07925498f, -0.17279145f, 0.07790773f, -0.04635874f, 
    -0.06882061f, 0.00349471f, -0.12345722f, -0.09740224f, -0.18253045f, 0.01695784f, 0.15536794f, -0.02551241f, 
    -0.13606921f, -0.05563396f, -0.04305327f, 0.03945739f, -0.00905833f, -0.21119781f, 0.00348326f, -0.13440692f, 
    -0.74962002f, -0.01146760f, 0.03168524f, 0.19287750f, -0.04024088f, -0.16123933f, -0.24532104f, 0.32192135f, 
    -0.25949302f, -0.12725252f, 0.00064708f, 0.41874284f, 0.17035660f, 0.13021605f, -0.04070236f, 0.06158299f, 
    -0.13844582f, 0.13614696f, -0.08764582f, 0.03290026f, -0.10510750f, 0.06104961f, 0.10810310f, 0.07833744f, 
    0.11205103f, 0.06758178f, 0.15329158f, 0.01670543f, 0.17642923f, 0.20161726f, 0.09908835f, 0.01477152f, 
    0.10422172f, -0.14960353f, 0.04841272f, 0.01791381f, -0.04762197f, 0.05254192f, 0.24193440f, -0.21269602f, 
    0.49201742f, 0.30859366f, 0.13809995f, -0.24603860f, 0.31401661f, -0.30180341f, 0.16644610f, 0.01994601f, 
    -0.01186894f, -0.04905386f, -0.15861881f, -0.29969275f, 0.01405626f, 0.05861825f, -0.12397911f, 0.01209740f, 
    0.12535754f, 0.21574874f, -0.02197952f, -0.09358661f, 0.06701275f, -0.50698847f, 0.01037112f, 0.05135381f, 
    -0.06903667f, -0.10939889f, -0.15660782f, 0.04534660f, 0.01573804f, -0.21816015f, 0.20404114f, 0.02551248f, 
    -0.10190719f, -0.03845828f, -0.01758905f, -0.02727057f, 0.01818368f, 0.03614891f, -0.01064163f, 0.08393567f, 
    0.11992852f, 0.11479559f, 0.06533177f, -0.05650274f, 0.17119993f, 0.48490176f, 0.13633810f, 0.36558926f, 
    0.01116710f, -0.44759762f, -0.46268848f, 0.11938593f, 0.04865284f, -0.17915559f, -0.15503252f, -0.10351623f, 
    0.05557902f, -0.74766695f, -0.37830451f, 0.48429713f, -0.14077973f, 0.08139087f, -0.15584330f, 0.11248705f, 
    0.06710465f, -0.07347949f, -0.00779132f, 0.05214455f, -0.26035470f, -0.09946685f, -0.02325676f, 0.38322291f, 
    0.00060560f, -0.08575930f, -0.08456802f, -0.58243185f, -0.08374151f, 0.25214884f, -0.40202063f, 0.15337688f, 
    0.18491371f, 0.15341157f, 0.03341813f, 0.00940474f, 0.10763678f, -0.51204556f, -0.72337592f, 0.23806231f, 
    0.02879747f, -0.28714475f, 0.22427152f, -0.00685924f, -0.25211772f, -0.61734033f, -0.28500417f, -0.56231952f, 
    -0.00892879f, 0.06310190f, 0.02487904f, -0.08983315f, 0.10289314f, 0.02348268f, 0.21363911f, 0.20670369f, 
    0.22574317f, -0.06667647f, 0.03596159f, 0.16016608f, 0.16163288f, -0.06996108f, -0.09697784f, -0.53440833f, 
    -0.21405971f, -0.20923707f, 0.04559225f, -0.00812986f, -0.00120103f, 0.01052027f, -0.03113337f, -0.06371313f, 
    0.37589738f, 0.09199589f, 0.14340857f, -0.18111180f, 0.00258841f, 0.16254744f, 0.11701153f, 0.14144103f, 
    0.03666453f, 0.08268482f, 0.08120107f, 0.01272810f, 0.23867486f, 0.15707374f, -0.10800240f, -0.03175382f, 
    -0.06544503f, 0.10793260f, 0.28530946f, 0.17608595f, -0.01508819f, -0.07865618f, -0.03175417f, 0.08446104f, 
    -0.16498844f, 0.15736428f, 0.26596594f, -0.51152098f, -0.12396841f, 0.27261469f, 0.05973288f, -0.08153015f, 
    0.01476435f, 0.02024089f, -0.09011696f, -0.23219585f, -0.16375905f, -0.74208671f, 0.52194458f, 0.00503905f, 
    -0.20519391f, -0.07659347f, 0.10387393f, 0.23024286f, 0.20981908f, -0.18267737f, 0.08125427f, 0.21789962f, 
    -0.01387093f, -0.15935375f, 0.03905486f, -0.09223399f, -0.03813638f, -0.08525320f, -0.55839419f, -0.28743398f, 
    -0.34080741f, -0.29733548f, 0.01628747f, 0.01540283f, -0.31333381f, -0.12029752f, -0.00915862f, 0.09673688f, 
    -0.36982954f, -0.23088817f, 0.34213611f, 0.10632193f, -0.12268560f, -0.01210871f, 0.21985944f, -0.01905892f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.13378868f, 0.05233966f, -0.23738927f, 0.23411366f, 0.05037357f, 0.05132619f, -0.23841061f, 0.10257053f, 
    0.34936956f, 0.22730736f, 0.15788156f, 0.06286439f, 0.03496213f, 0.43372837f, 0.26607829f, 0.02599633f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24035551f, -0.14483805f, -0.09544657f, 0.29603919f, 0.23054497f, -0.38574949f, 0.13043554f, 0.09598611f, 
    0.30198878f, -1.05541205f, 0.05247800f, -0.11727766f, 0.07014500f, 0.21717715f, 0.15283647f, -0.65864903f, 
    0.34435809f, -0.23466960f, -0.18806702f, 0.20509827f, 0.07345409f, 0.05697108f, -0.49458310f, -0.27719107f, 
    -0.17516458f, -0.22830647f, 0.49167576f, -0.16934943f, 0.05644915f, 0.49038735f, -0.31974828f, -0.22020355f, 
    -0.38619733f, 0.08509086f, 0.21364883f, 0.31131154f, -0.03892088f, 0.00647541f, 0.11277319f, -0.70703495f, 
    -0.03219580f, -0.06922634f, 0.52934670f, 0.25006950f, 0.24196386f, 0.21473369f, -0.40355313f, -0.68050259f, 
    0.25920817f, -0.17283964f, 0.39339510f, -0.29716575f, -0.21326894f, 0.35520905f, 0.07766097f, 0.39758295f, 
    -0.54316777f, 0.22330135f, 0.51721090f, 0.34153023f, -0.13899882f, -0.40413585f, 0.24719454f, 0.37544093f, 
    -0.04494277f, -0.16743112f, 0.43251115f, -0.01238823f, -0.24706575f, 0.15129863f, 0.35732242f, -0.12174311f, 
    0.00390988f, -0.01140557f, -0.25425115f, 0.57758737f, 0.32091555f, -0.55737668f, -0.60727149f, -0.03294725f, 
    -0.08981878f, -0.22273722f, 0.21597955f, -0.18059707f, -0.12824968f, 0.08926791f, 0.11915758f, -0.13285676f, 
    -0.18686613f, 0.01218867f, -0.16072315f, 0.16974956f, -0.18591702f, 0.13948020f, 0.02864906f, -0.10946694f, 
    0.24368425f, -0.22861207f, -0.23393564f, -0.26385120f, -0.14036077f, 0.04308935f, 0.06030008f, 0.25703940f, 
    0.55077767f, 0.02054159f, 0.47988948f, 0.40665710f, 0.17847106f, -0.35077441f, 0.13695197f, -0.33586058f, 
    -0.00628286f, -0.15379484f, 0.05137457f, 0.14462525f, -0.11894464f, 0.01652244f, 0.12569550f, -0.70150930f, 
    0.78170449f, 0.10505629f, 0.11029229f, 0.41602284f, 0.39356238f, -0.39574412f, 0.15107667f, -0.66599935f, 
    0.13532408f, -0.00886576f, 0.07626836f, -0.03344435f, 0.08295425f, 0.21557008f, -0.26849291f, -0.38425985f, 
    -0.20254228f, 0.88956016f, 0.25660157f, -0.56506294f, 0.00085661f, 0.49311656f, 0.35181853f, 0.55023509f, 
    0.34170941f, 0.23736249f, -0.01671716f, -0.36069521f, 0.16088958f, 0.47311538f, -0.31835130f, 0.21195778f, 
    0.13221279f, 0.59022504f, 0.53510505f, 0.27663273f, 0.06105699f, 0.05327116f, 0.17575414f, 0.58314919f, 
    0.01316387f, -0.08324023f, -0.23823340f, 0.38854915f, -0.11580468f, -0.33292091f, -0.27258107f, -0.31191224f, 
    0.68895882f, -0.21331568f, -0.34254882f, -0.27034357f, 0.42585075f, 0.18851639f, -0.14953093f, -0.25382367f, 
    -0.01939824f, 0.20707609f, 0.07186346f, -0.13022357f, -0.05106892f, 0.39308298f, -0.39683643f, 0.02889800f, 
    0.42626467f, -0.16774552f, 0.11546206f, 0.87737972f, 0.45402217f, -0.24882761f, -0.05885430f, -0.63586736f, 
    0.23673888f, -0.09650707f, 0.31879893f, -0.22127573f, 0.18024969f, 0.09829400f, 0.05756915f, 0.08890863f, 
    -0.29785785f, -0.78888756f, -0.12943634f, 0.00648126f, 0.35139230f, -0.05451332f, -0.33659980f, -0.00875739f, 
    -0.35038424f, -0.21444649f, -0.06287077f, -0.34057915f, 0.19626604f, 0.35298207f, -0.09867159f, 0.15445486f, 
    -0.36470854f, 0.37138590f, 0.36174947f, 0.41901129f, 0.27213842f, 0.52109456f, 0.41921067f, 0.42297640f, 
    0.08094474f, -0.14025478f, 0.26918977f, -0.06212060f, -0.06550662f, 0.42491961f, 0.35811716f, -0.40469030f, 
    -0.54705632f, -0.41543081f, -0.21202940f, 0.43396494f, 0.35484233f, -0.17314753f, -0.26691470f, 0.55597025f, 
    -0.01836189f, 0.18365631f, -0.00621335f, -0.22013833f, -0.18598390f, -0.01169831f, -0.06671671f, -0.22193252f, 
    -0.06923217f, -0.02160177f, 0.18398219f, -0.21275713f, 0.08775843f, -0.09107055f, 0.11353753f, -0.21762787f, 
    0.33396095f, 0.15238337f, 0.14417472f, 0.13377580f, 0.13979729f, -0.24697855f, -0.06086545f, -0.23649001f, 
    0.30435106f, -0.38236570f, 0.59169710f, -0.39231431f, -0.07213422f, 0.11051416f, 0.41653997f, -0.47623113f, 
    0.09555862f, 0.14107221f, 0.13395508f, 0.29924494f, 0.15234035f, -0.39862362f, 0.47880653f, -0.58032405f, 
    0.63330501f, 0.29165021f, 0.23597272f, -0.19745646f, -0.29281831f, 0.21797825f, -0.12057682f, -0.24396260f, 
    0.19268669f, -0.01565371f, 0.39587510f, -0.13970207f, 0.01435997f, 0.37921652f, -0.45774293f, -0.27253121f, 
    0.43932816f, -0.59724456f, 0.48191497f, -0.06800964f, 0.13218832f, 0.00816537f, -0.02412613f, 0.96205127f, 
    -0.21041150f, -0.20589989f, -0.05407351f, -0.07612699f, 0.24918407f, -0.14582025f, 0.00667593f, 0.07927694f, 
    -0.04411584f, 0.22601962f, -0.21709822f, 0.08498280f, -0.20892140f, 0.01973763f, -0.09941654f, -0.22318241f, 
    -0.22967908f, 0.24106452f, -0.08332306f, -0.22219864f, 0.00377098f, -0.23697948f, 0.13664865f, 0.08602887f, 
    0.23248479f, -0.12626451f, -0.08198896f, -0.08128580f, -0.03656101f, 0.06686765f, -0.14805925f, 0.23797232f, 
    0.26466933f, 0.20604524f, -0.38702148f, -0.02830069f, -0.16441163f, -0.17131828f, -0.05088018f, -0.25714603f, 
    -0.12053934f, 0.15889487f, -0.11149868f, -0.02903297f, 0.19502656f, 0.02514244f, -0.25346974f, 0.04303980f, 
    -0.09286185f, -0.15430896f, 0.28485256f, -0.16825509f, -0.08594063f, 0.35542926f, 0.21647896f, 0.20707822f, 
    -0.52497005f, 0.13201933f, 0.11091237f, 0.81743586f, 0.17214954f, 0.16022912f, -0.19893688f, 0.59400755f, 
    0.25026444f, -0.21972711f, -0.28697869f, -0.10119298f, -0.22871558f, 0.31408420f, -0.46961910f, 0.03824282f, 
    0.76924652f, 0.22961140f, 0.32463080f, -0.09903593f, -0.03825620f, 0.41217950f, -0.16412361f, -0.16804343f, 
    -0.05594240f, -0.00179860f, 0.47700417f, -0.10298896f, -0.05889151f, -0.00719960f, 0.01447636f, 0.33331701f, 
    0.02630257f, 0.23473212f, -0.03562591f, 0.08095773f, -0.19279523f, 0.02974813f, 0.12964602f, 0.79068255f, 
    0.34358114f, -0.18608263f, -0.33728278f, -0.10134472f, -0.11920480f, 0.31371987f, 0.19945374f, 0.10802375f, 
    -0.29121730f, -0.15507011f, -0.42194974f, 0.74090940f, -0.09699928f, 0.58856142f, -0.47954962f, 0.50760418f, 
    0.10111243f, -0.01408034f, -0.04538815f, 0.33873269f, -0.15956351f, -0.35150644f, 0.28338659f, 0.03439372f, 
    0.14125037f, 0.28810191f, 0.03078643f, -0.80175161f, -0.27519831f, -0.32780239f, 0.00598693f, -0.42946118f, 
    -0.26073974f, 0.23478590f, 0.17009982f, -0.29663831f, -0.00702050f, 0.39857620f, 0.22309804f, 0.33867687f, 
    -0.25394440f, 0.20196353f, 0.05583602f, 0.37904817f, -0.00342053f, 0.26248056f, 0.48283616f, 0.18507794f, 
    0.16179620f, 0.08370207f, 0.16780056f, -0.14688814f, 0.16017300f, -0.16056110f, 0.16025469f, -0.05103044f, 
    0.08189503f, -0.20206164f, -0.12345005f, -0.19800416f, -0.05429174f, -0.09808528f, -0.20994852f, -0.25248039f, 
    -0.12843941f, 0.08075619f, -0.24229948f, -0.23876947f, -0.04990771f, 0.24462035f, -0.17672022f, -0.19254452f, 
    0.06907565f, -0.19257757f, 0.05770668f, -0.05005100f, -0.06052816f, 0.17147152f, -0.13245545f, 0.15298891f, 
    -0.03665568f, -0.05297160f, -0.50134969f, 0.19292264f, 0.01040658f, -0.33256698f, 0.42724222f, 0.07163673f, 
    0.34562001f, 0.15315923f, -0.41404170f, -0.02288432f, 0.34588525f, 0.34852219f, 0.01690354f, -0.41040218f, 
    0.19240347f, -0.16856040f, -0.43843466f, -0.08301804f, 0.25028008f, 0.07772794f, -0.37184915f, -0.19344047f, 
    0.35060588f, -0.01169132f, -0.01884709f, -0.12762740f, 0.24256191f, 0.58393848f, -0.03288773f, 0.36962739f, 
    0.04962963f, 0.09919503f, -0.09194724f, -0.23577446f, -0.11131539f, 0.22506689f, 0.15438709f, -0.06265337f, 
    -0.15967260f, 0.12096454f, -0.06696586f, 0.09377173f, -0.15436675f, 0.08862893f, -0.15823269f, -0.21094666f, 
    0.27727640f, -0.05819366f, 0.35525367f, 0.01570552f, 0.21290493f, 0.26635653f, -0.25286093f, -0.08938707f, 
    -0.48465493f, 0.24940443f, 0.07576492f, -0.28423825f, -0.02306538f, 0.47441819f, -0.00387969f, 0.52844203f, 
    -0.28402656f, 0.07412706f, 0.62902576f, 0.22067873f, -0.10126269f, -0.03190450f, 0.66864681f, -0.32262307f, 
    0.66924584f, 0.61783153f, -0.29442111f, 0.20808300f, -0.19534963f, -0.68280798f, -0.15570360f, -0.08679776f, 
    -1.03794241f, -0.04876142f, 0.29773581f, 0.21266730f, -0.08265742f, 0.02294878f, 0.52030760f, -0.58232236f, 
    -0.01707039f, 0.32088721f, 0.00133150f, 0.27283832f, 0.19640552f, -0.15582956f, -0.71654946f, -0.22979397f, 
    -0.15676592f, -0.03563828f, 0.17952783f, -0.05730346f, -0.04792422f, 0.29386857f, -0.03445832f, 0.23551172f, 
    0.51607883f, 0.39685389f, 0.75906932f, 0.09468298f, 0.06990470f, -0.61672431f, 0.33774292f, 0.33719671f, 
    0.28958118f, -0.18514414f, 0.28246400f, 0.34961379f, -0.24372777f, -0.26034325f, -0.15816396f, -0.13882470f, 
    0.78421354f, -0.15962443f, -0.16973104f, -0.45333433f, -0.22719975f, -0.27798557f, -0.13109671f, 0.11644450f, 
    -0.38417023f, 0.06137471f, 0.20466088f, 0.35455126f, 0.20116407f, -0.05118401f, 0.04819965f, 0.33015788f, 
    0.48839754f, -0.74393970f, 0.16867593f, 0.13665989f, -0.16230394f, -0.09345455f, -0.02036615f, 0.10592658f, 
    0.03331109f, 0.20151308f, -0.11646713f, -0.19669807f, -0.10544896f, 0.12191281f, 0.11611179f, -0.18778495f, 
    0.09208806f, 0.12139094f, 0.11079994f, -0.15873183f, -0.12049753f, -0.20938726f, 0.09672564f, -0.19378352f, 
    -0.55014032f, 0.20471525f, -0.12677583f, 0.01902216f, -0.01614965f, 0.28882656f, 0.14540319f, -0.29824543f, 
    0.00889422f, 0.39892051f, 0.48776579f, -0.40467265f, -0.01559536f, 0.41627392f, 0.35570657f, 0.07474641f, 
    -0.09802932f, 0.08024921f, -0.13884981f, -0.15372011f, 0.00384556f, 0.41257185f, -0.16401283f, -0.78136641f, 
    -0.13636564f, 0.06146557f, 0.45643678f, 0.17473143f, 0.40002909f, 0.67254418f, 0.17514330f, -0.41710499f, 
    0.03231940f, -0.07937738f, 0.11702031f, 0.27504876f, -0.24047188f, -0.09917708f, 0.19494677f, -0.04062064f, 
    -0.58199573f, 0.01904201f, 0.24644670f, -0.38850373f, -0.09413226f, 0.59259307f, 0.12451535f, 0.41518235f, 
    -0.40694782f, 0.08267326f, -0.32831487f, 0.30450627f, -0.16347018f, -0.48389763f, 0.24651018f, 0.10694345f, 
    0.05936357f, 0.02048788f, -0.00081589f, -0.00439577f, 0.39514029f, 0.22242615f, -0.18006852f, -0.67980188f, 
    0.28374195f, 0.23972718f, 0.41189235f, -0.00177949f, -0.22863685f, 0.17244373f, 0.05157504f, 0.18580326f, 
    -0.68026650f, 0.38382399f, -0.12419939f, 0.16838756f, 0.10612991f, 0.23245104f, -0.23114115f, -0.87008357f, 
    -0.15877114f, 0.17905071f, -0.70622796f, 0.18667790f, -0.24761578f, -0.06449572f, -0.18431297f, 0.18453470f, 
    0.04827018f, 0.73883253f, 0.42673209f, -0.07773510f, -0.20047197f, -0.32904425f, 0.31409785f, 0.24090886f, 
    -0.26961058f, -0.03045361f, -0.71142417f, 0.29281321f, -0.07369501f, -0.62066722f, 0.48965734f, 0.20381072f, 
    0.37045828f, -0.51176190f, -0.42664382f, -0.45843402f, -0.03088936f, 0.70167392f, -0.05703930f, -0.13747977f, 
    0.19393960f, 0.00617524f, 0.43625611f, 0.22023721f, 0.18179129f, 0.01829390f, -0.08393668f, -0.27384803f, 
    0.32937568f, -0.40579319f, 0.94424981f, -0.21357769f, -0.08432063f, 0.08174553f, -0.32250100f, 0.15162185f, 
    -0.30505165f, 0.13252158f, -0.43732908f, 0.25843552f, 0.22691768f, 0.05490667f, -0.21335396f, -0.28483537f, 
    0.57005107f, -1.19827402f, 0.39437410f, 0.54218674f, 0.04726056f, 0.07320087f, -0.31523225f, 0.34986567f, 
    -0.05380455f, -0.09277383f, -0.18026273f, -0.14411950f, 0.10748041f, 0.01438819f, 0.14437065f, -0.11092108f, 
    -0.11004058f, -0.01161864f, -0.15868096f, -0.08602592f, -0.08688506f, 0.09374677f, -0.15893550f, -0.19933175f, 
    -0.13618220f, -0.04393518f, 0.04348224f, -0.20363586f, 0.04105267f, -0.18117063f, -0.22270000f, 0.10161880f, 
    -0.12702081f, 0.09479450f, 0.20465210f, 0.14102940f, -0.15560235f, 0.03394173f, -0.03370338f, 0.08225557f, 
    0.04762542f, -0.15906721f, -0.36448905f, 0.14174923f, -0.19461405f, 0.03348065f, -0.00001402f, 0.15824606f, 
    0.25753894f, 0.44963259f, -0.55672371f, -0.05034730f, 0.22488548f, 0.51451606f, -0.33021435f, 0.00283286f, 
    0.23231921f, -0.18948969f, 0.24446993f, -0.21723892f, -0.00922442f, 0.56404865f, -0.53133833f, 0.06941308f, 
    0.40851644f, -0.02831266f, -0.18833216f, 0.63407040f, 0.22378750f, -0.32599035f, 0.40133357f, 0.54338413f, 
    0.31438807f, -0.08438233f, 0.14731538f, -0.03890347f, 0.02527579f, -0.10700054f, -0.17222904f, -0.32234213f, 
    0.43078914f, 0.94148439f, -0.22455895f, -0.12895964f, 0.35413381f, -0.19519050f, 0.22058588f, 0.31981939f, 
    0.23067571f, -0.05746047f, -0.56205094f, -0.21131541f, 0.00420364f, 0.64386433f, -0.57242358f, -0.07839315f, 
    -0.25657204f, 0.22240379f, 0.17724997f, 0.49134046f, 0.49368423f, 0.00933740f, 0.11691096f, -0.29015401f, 
    0.12348112f, -0.09892853f, -0.09324694f, -0.20529577f, -0.04374701f, -0.17028016f, 0.13717282f, -0.22892928f, 
    0.19633333f, 0.00131030f, -0.17375156f, -0.13885361f, -0.01265438f, -0.16325444f, 0.22107033f, -0.08070951f, 
    -0.28780288f, -0.20238829f, -0.09807670f, 0.07765514f, 0.15439844f, -0.05706413f, -0.15415327f, -0.25148425f, 
    -0.15408760f, 0.15010557f, -0.08519398f, 0.18082075f, -0.16282870f, -0.19470075f, 0.12455703f, 0.07198122f, 
    0.15507255f, -0.06127506f, 0.38823619f, 0.28841242f, 0.03459203f, 0.17392190f, 0.12783810f, -0.08520120f, 
    -0.60115290f, -0.45582235f, -0.22852154f, 0.62841338f, -0.04154848f, -0.48075148f, -0.09796808f, -0.25039157f, 
    -0.10570796f, 0.16460535f, 0.06363026f, -0.25340089f, 0.15737088f, 0.18369605f, -0.15337290f, -0.23969193f, 
    0.02069679f, 0.01230166f, -0.00340304f, -0.19295278f, -0.02637135f, -0.16437137f, -0.01673278f, 0.02972478f, 
    -0.32180235f, -0.02460569f, 0.44991943f, 0.24593936f, -0.11403078f, -0.27268699f, 0.34870088f, 0.23528467f, 
    -0.31142062f, 0.07122267f, -0.12294448f, 0.44236931f, 0.19699965f, -0.35349599f, -0.01336321f, 0.09422769f, 
    0.10360094f, -0.13833474f, -0.42889825f, 0.26345298f, 0.18838237f, 0.04543391f, -0.15537892f, 0.18800160f, 
    0.45797026f, -0.80822307f, -0.14951979f, -0.12486142f, -0.26556617f, 0.63764483f, 0.14336029f, 0.32244787f, 
    -0.36125556f, 0.25382689f, 0.14240789f, 0.05456413f, 0.20471874f, 0.03245401f, 0.55040592f, 0.23815617f, 
    -0.25055793f, 0.47109929f, 0.22893460f, -0.19578174f, 0.11730493f, -0.17581341f, 0.54475731f, 0.01781541f, 
    -0.43773246f, -0.08340973f, 0.04560664f, 0.27780735f, -0.14671929f, -0.04643350f, 0.28906241f, -0.41053084f, 
    0.61255485f, 0.03620855f, -0.03436609f, 0.44232729f, -0.30116352f, -0.32258728f, 0.34750575f, -0.23705363f, 
    0.21107325f, 0.17818686f, 0.42371988f, -0.09207001f, 0.08560085f, 0.23063989f, 0.04265462f, 0.26130211f, 
    -0.30609503f, -0.95946598f, 0.03540409f, -0.21389142f, -0.01341525f, -0.47830158f, -0.30800575f, 0.42291930f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.22271703f, 0.36291617f, -0.03046034f, -0.25396535f, -0.07625274f, -0.24691066f, -0.56171453f, -0.20130928f, 
    0.67964792f, 0.09239279f, 0.20026849f, 0.08163377f, -0.04851607f, 0.18362893f, -0.28055447f, -0.03184029f, 
    -0.02983760f, -0.29069945f, 0.07508484f, -0.15083840f, -0.17758217f, -0.09681747f, -0.46854201f, -0.00030764f, 
    0.18834531f, -0.04238997f, 0.09107936f, -0.32645103f, 0.05699717f, -0.10372605f, 0.11456116f, 0.38745627f, 
    0.12852514f, 0.21415982f, -0.26745173f, 0.06349808f, -0.23002449f, 0.09183435f, 0.40644196f, -0.05541277f, 
    -0.20646246f, 0.03935084f, 0.42913052f, 0.18545908f, -0.35755923f, -0.02828526f, 0.51913166f, 0.39338961f, 
    0.15512934f, 0.14571469f, -0.24186136f, 0.55991501f, -0.05402714f, -0.05889189f, 0.17367911f, -0.24101810f, 
    -0.19575518f, -0.38192683f, -0.07485314f, -0.16690606f, 0.37809932f, 0.00820388f, -0.10980970f, -0.42107373f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.26835710f, -0.29235125f, 0.03734278f, 0.29048130f, 0.30429167f, 0.11878569f, -0.04704561f, -0.05576193f, 
    -0.25077730f, -0.03253651f, -0.71497262f, -0.00451127f, -0.02780306f, -0.16353256f, 0.38029876f, -0.06163235f, 
    -0.30215621f, -0.34538320f, 0.09899071f, -0.07444821f, 0.02555846f, -0.09894733f, 0.42392921f, -0.36381084f, 
    0.25636026f, 0.33096173f, -0.05912507f, 0.26948717f, -0.03247251f, 0.03737067f, -0.26169351f, -0.60027182f, 
    -0.10482523f, 0.14404927f, 0.29534978f, 0.25908661f, 0.05888780f, -0.08594629f, 0.05218222f, -0.07219997f, 
    -0.22344793f, -0.30721894f, 0.08342752f, -0.48737586f, 0.14757898f, 0.06517772f, -0.04639496f, 0.07343058f, 
    -0.09901118f, -0.01477557f, -0.09020380f, -0.21580787f, 0.13541543f, -0.45319310f, -0.17727561f, 0.05288310f, 
    0.05723526f, 0.52925497f, -0.10868771f, 0.18184280f, -0.12514453f, -0.05652356f, -0.07361168f, 0.23754480f, 
    -0.30202067f, 0.04300386f, -0.22670943f, 0.05829659f, -0.11911194f, -0.10201061f, -0.09978221f, -0.36432418f, 
    0.47970346f, 0.28415176f, -0.30643195f, -0.03573616f, 0.12916012f, 0.36215439f, 0.25945500f, -0.05766470f, 
    -0.25719541f, -0.99757463f, 0.38173988f, -0.00928385f, -0.08826298f, -0.21691722f, 0.26019549f, -0.04567732f, 
    0.16820022f, 0.02230042f, -0.07217617f, 0.16837710f, -0.04283751f, 0.12038326f, -0.15635628f, 0.15549201f, 
    0.06037532f, 0.12191152f, -0.75914478f, -0.41823116f, 0.16243453f, -0.26480079f, -0.04965860f, 0.08472846f, 
    0.02630349f, 0.03531764f, 0.10605469f, -0.27861938f, -0.15572686f, 0.26980495f, -0.25009990f, 0.09352086f, 
    0.02586487f, -0.08193509f, -0.07345097f, 0.06247268f, 0.13244237f, 0.00175867f, 0.25063494f, -0.07236023f, 
    -0.02240052f, -0.28142840f, -0.05693348f, -0.14149003f, 0.03272272f, 0.09895763f, -1.44111621f, -0.10058428f, 
    0.36427000f, 0.34897643f, 0.43994209f, 0.25562352f, -0.94445312f, 0.01217653f, -0.11246309f, -0.11333005f, 
    -0.10173780f, -0.28124887f, 0.04362302f, -0.03128733f, 0.03958952f, 0.15174881f, -0.71685672f, -0.10078494f, 
    0.04192897f, -0.15019552f, -1.17057252f, -0.06367486f, -0.04278493f, -0.13676523f, -0.07373693f, 0.08776588f, 
    -0.40498394f, 0.18302101f, -0.59868169f, -0.17812508f, -0.00229202f, 0.07653615f, 0.11442906f, 0.12546460f, 
    -0.10729719f, -0.13504815f, -1.25409651f, 0.11843780f, -0.21033022f, -0.06167324f, 0.24083546f, -0.01608407f, 
    0.29300630f, 0.31182379f, 0.03932644f, 0.15951413f, -0.06861024f, -0.54219419f, 0.24245544f, 0.17039552f, 
    0.70796990f, -0.03167976f, -0.09988029f, -0.01502691f, -0.42371631f, -0.78510481f, 0.09266428f, -0.02706977f, 
    -0.12599131f, -0.01938025f, -0.01455012f, -0.05220298f, 0.17289148f, -0.32143167f, -0.32517105f, 0.20408998f, 
    0.17800352f, -0.10503458f, 0.29464614f, 0.32768220f, 0.43753499f, 0.06811285f, 0.15181020f, 0.26857287f, 
    -0.45379344f, -0.49157774f, 0.03869130f, 0.21509670f, 0.38489494f, -0.38364455f, 0.15343365f, -0.03951339f, 
    -0.09107012f, 0.13912380f, -0.22059457f, -0.06542156f, 0.11455968f, -0.13417053f, 0.05305045f, -0.42065179f, 
    -0.66419995f, -0.24653217f, -0.70756388f, -0.20972623f, -0.09478787f, 0.06803755f, 0.05874231f, -0.47413808f, 
    -0.10110699f, -0.37635940f, 0.07900190f, 0.60522026f, -0.04564711f, -0.20736691f, -0.00657716f, 0.00908025f, 
    0.00233378f, 0.03562016f, -0.28454772f, 0.24994111f, 0.18419741f, -0.42511535f, -0.20658213f, 0.10023726f, 
    0.01961681f, -0.04590160f, 0.04101923f, -0.08556661f, -0.19063251f, -0.16740368f, 0.10680261f, 0.11449600f, 
    0.09606031f, 0.48513585f, -0.11938397f, 0.22508903f, -0.53411138f, 0.03007175f, 0.17426983f, -0.40730959f, 
    -0.02369430f, -0.00235703f, -0.02464123f, 0.09903593f, -0.00114158f, 0.00439709f, 0.12349562f, 0.19422783f, 
    -0.24240410f, -0.06034130f, 0.04092683f, 0.00438738f, -0.54497361f, -0.56635433f, -0.18581267f, -0.05047223f, 
    0.16200285f, 0.36297706f, 0.17150795f, -0.07237748f, -0.10308509f, -0.28018740f, -0.09445495f, 0.00194936f, 
    0.24855284f, -0.29449737f, -0.00208304f, -0.37107047f, -0.11347923f, 0.10543210f, -0.17644274f, -0.16749489f, 
    -0.16121338f, -0.09106360f, 0.42454985f, 0.03176393f, 0.17306875f, 0.50165945f, 0.21105985f, -0.03451703f, 
    -0.03451676f, -0.38564068f, -0.23050846f, -0.35972273f, 0.26027504f, -0.22551249f, -0.48347110f, 0.22171260f, 
    0.17495108f, -0.08301365f, 0.01525887f, -0.09800110f, 0.09787040f, 0.09884682f, -0.18203445f, 0.04133954f, 
    0.09312900f, -0.09883433f, 0.05508460f, 0.09547021f, -0.08461762f, -0.16167271f, 0.46788529f, -0.21582504f, 
    0.03535967f, 0.12418005f, 0.02476721f, -0.02781785f, -0.35545871f, 0.11192346f, 0.23709968f, 0.26140514f, 
    0.08451205f, 0.14834654f, -0.12236884f, 0.17457683f, -0.33012134f, 0.24009807f, -0.09065428f, -0.07628577f, 
    0.56069624f, -0.16148297f, 0.15046737f, -0.04454322f, 0.04455204f, -0.37706524f, -0.19241835f, 0.09789743f, 
    -0.31092915f, -0.49883369f, 0.29729059f, 0.09985093f, -0.01482318f, 0.05803708f, -0.14960365f, -0.03356989f, 
    -0.00125549f, -0.10687740f, -0.42769897f, -0.32451528f, 0.21286744f, 0.04626911f, -0.16817228f, -0.04427975f, 
    0.15872507f, 0.48371351f, -0.14881746f, -0.28744203f, -0.17386955f, 0.27607349f, -0.23385976f, 0.14046022f, 
    0.07710450f, -0.07075664f, -0.07242770f, -0.22533217f, 0.16100127f, -0.02675057f, 0.25684860f, 0.12329940f, 
    -0.02887260f, -0.09631407f, -0.05896695f, -0.30477080f, -0.04186340f, -0.06126949f, -0.17377947f, -0.19983183f, 
    0.73414624f, -0.10039652f, -0.84051752f, -0.54547393f, -0.82217008f, 0.04506946f, -0.57677782f, -1.51562476f, 
    -0.00968962f, -0.81506491f, 0.26667058f, -0.88498628f, -0.13046843f, -0.07438008f, -1.15760148f, 0.03877305f, 
    0.20044503f, -0.04427776f, -0.43050462f, 0.03722214f, -0.06108750f, 0.04196064f, -0.47760233f, -0.18725416f, 
    -0.11210205f, -0.12801477f, 0.08657193f, 0.11015262f, -0.10485141f, -0.06447846f, 0.20079152f, -0.02183357f, 
    0.07942394f, -0.03209518f, -0.25508687f, -0.66215181f, -0.74830496f, 0.22020836f, 0.41379556f, 0.01806821f, 
    -0.10722997f, -0.61843097f, 0.37508148f, 0.31359044f, -0.04044019f, -0.33731717f, 0.39858747f, -0.24567261f, 
    -0.98485720f, -0.10022156f, 0.00410110f, 0.22895910f, -0.28152308f, -0.40332222f, -0.53171027f, 0.03000021f, 
    0.06543589f, 0.12467103f, 0.10389498f, 0.10755444f, 0.44661316f, 0.19945200f, -0.19335026f, -0.40760002f, 
    -0.68299770f, -1.19031990f, -0.53441978f, 0.08155343f, 0.20652921f, -0.03159553f, 0.16992937f, -0.06467929f, 
    -0.25406778f, 0.13021022f, -0.63815767f, -0.35233015f, -0.65594560f, 0.37335771f, -0.82727957f, -0.02582836f, 
    -0.17835151f, -0.22383074f, -0.25411850f, 0.05242316f, -0.00021853f, -0.21305893f, 0.35885561f, -0.00633812f, 
    0.16477518f, -0.08002578f, -0.06498779f, 0.47073084f, 0.06878940f, 0.06096303f, 0.12757403f, -0.51190889f, 
    -0.01356636f, -0.21227331f, 0.39347669f, 0.00683182f, 0.45219389f, -0.42727792f, -0.14963412f, 0.00487305f, 
    0.36127403f, -0.64547056f, 0.03421479f, 0.12599865f, 0.12270270f, 0.04463398f, -0.02922124f, -0.94458902f, 
    -0.88373280f, 0.01955180f, 0.00676021f, 0.07123552f, -0.13635108f, -0.11545417f, -0.21230072f, -0.09549512f, 
    -0.09365051f, 0.14273682f, -0.09999555f, 0.24430569f, -0.12249597f, 0.41128957f, 0.35205099f, -0.25532481f, 
    -0.66873705f, -0.24820670f, -0.28268188f, -0.43459192f, -0.21129331f, 0.06057642f, -0.21158350f, 0.22735669f, 
    0.24874607f, 0.02294643f, 0.29528123f, 0.26998103f, -0.15143158f, 0.25261763f, 0.01721823f, -0.07057964f, 
    -0.57222682f, -0.75999016f, -0.89350468f, -0.04770137f, -0.05450532f, 0.21170567f, -0.06271517f, 0.08393946f, 
    -0.30743954f, -0.13924727f, -0.31207690f, 0.14896837f, -0.06057614f, 0.00612859f, 0.17307596f, 0.32337695f, 
    -0.02127042f, 0.04108580f, -0.43929157f, 0.01366111f, -0.16225652f, -0.22343995f, -0.72016197f, 0.03253689f, 
    -0.15948728f, 0.27864623f, -0.11071789f, 0.05929597f, 0.03820642f, -0.34531313f, 0.00918857f, -1.07836497f, 
    -0.76420772f, -0.09817425f, 0.02335549f, 0.20921609f, 0.23732550f, 0.39167368f, 0.42925575f, -0.09787294f, 
    0.01438874f, -0.13981187f, 0.05137037f, 0.01710337f, -0.20579498f, 0.04015236f, 0.03450095f, -0.04066763f, 
    0.36383644f, -0.19470826f, -0.21172912f, -0.30482188f, -0.17246719f, 0.04264116f, -0.07546585f, 0.29921398f, 
    0.01935992f, -0.34092441f, 0.18562032f, -0.10126194f, 0.26897344f, -1.17179871f, -0.50052291f, -0.07167775f, 
    0.32900137f, 0.46490276f, -0.13133189f, 0.07285979f, 0.06280716f, -0.33275667f, -0.83735985f, -0.01821727f, 
    -0.12669218f, -0.61783844f, 0.16726156f, -0.48903292f, -0.01225575f, -0.04390351f, 0.13730048f, -0.07047456f, 
    -0.00113331f, -0.31651530f, 0.33719584f, -0.81724185f, 0.19734772f, 0.32232201f, 0.39826515f, -0.01722283f, 
    -0.48392567f, -0.44892904f, -0.01288323f, 0.13475741f, -0.41154009f, 0.04189600f, 0.14821015f, 0.24251261f, 
    0.22297950f, -0.03446908f, -0.09629551f, 0.05423605f, -0.07937376f, 0.05084493f, -0.61623544f, -0.06213421f, 
    0.08438834f, -0.44441342f, 0.07740251f, -0.09046714f, 0.01131909f, 0.11274987f, 0.10352288f, -0.25768077f, 
    -0.18393175f, -0.01966294f, -0.48199847f, -0.69259602f, 0.33271664f, 0.02235968f, 0.45348918f, 0.06880567f, 
    -0.62229925f, 0.21512118f, 0.08259164f, 0.32005867f, 0.18593584f, -0.02727045f, -0.11245668f, 0.10176726f, 
    -0.28327999f, -0.54041141f, -0.07238778f, 0.08548889f, 0.08087270f, -0.25489920f, 0.06611069f, 0.29315802f, 
    -0.39271897f, 0.61844546f, 0.09118508f, 0.03832986f, 0.00418388f, 0.10082029f, 0.06348998f, 0.37185618f, 
    0.02402699f, -0.34703603f, -0.16012809f, -0.75455421f, -0.27880049f, 0.07729632f, -0.17027229f, 0.08983101f, 
    -0.74537826f, -0.06217547f, -0.64057326f, -0.21882592f, -0.13850993f, -1.02474594f, -0.08290168f, -0.17820524f, 
    0.16993894f, -0.11685509f, -0.12035983f, 0.13337749f, 0.34314579f, -0.10364203f, 0.26611829f, 0.08340009f, 
    -0.06258009f, -0.23154786f, -0.08516722f, -0.49871388f, 0.29290721f, -0.74157155f, 0.23285846f, -1.23412955f, 
    -0.73547387f, 0.47472587f, 0.24137715f, -0.10538409f, 0.07886379f, -0.02334912f, -0.33252427f, -0.27372900f, 
    0.44379327f, 0.06287996f, 0.10122862f, -0.71307409f, 0.45401514f, -0.21497065f, -0.81032437f, -0.12783107f, 
    0.27629727f, 0.56706667f, -1.36071813f, 0.03797436f, -0.11333634f, 0.03842311f, -0.22418116f, 0.13044451f, 
    -0.18885107f, 0.29367992f, -0.03596063f, -0.42909798f, -0.08437957f, -0.10380973f, 0.04881293f, 0.32831749f, 
    0.03403543f, 0.29164019f, -0.29942235f, 0.27831239f, -0.55537957f, -0.03405834f, -1.04638755f, 0.07194000f, 
    0.32967499f, 0.34750414f, 0.31353030f, -0.13558169f, 0.20504254f, -0.33555853f, 0.00878682f, 0.17425932f, 
    -1.03927290f, -0.11392765f, 0.00263369f, 0.14756408f, -0.85590422f, 0.17075317f, -0.14359291f, 0.04748088f, 
    0.00625318f, -0.22068529f, 0.08566836f, -0.42297959f, 0.00749965f, -0.19372804f, -0.09034210f, 0.19658354f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14199647f, 0.46465173f, 0.11231457f, -0.07480747f, 0.04189762f, -0.21737492f, 0.21991679f, -0.44503143f, 
    0.04883576f, 0.06971257f, -0.06287249f, 0.07840477f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
