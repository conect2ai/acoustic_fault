#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.00328712f, 0.53231138f, -1.05545902f, -0.76595622f, -1.01120329f, -1.11140513f, 0.50543231f, 0.41666177f, 
    0.66349673f, -1.47452748f, 0.80752987f, 1.04618788f, -0.36168185f, 0.97091454f, 0.12431063f, -0.13456258f, 
    -0.00086439f, 0.13863079f, -0.53337520f, 0.09830447f, 0.49443340f, -0.94897246f, -0.32650921f, -0.88350803f, 
    -0.51757878f, 0.77689713f, -0.66165727f, 0.20685181f, -0.68393010f, -0.89223909f, -0.44742927f, -0.85133553f, 
    -0.48815984f, -0.69442773f, -0.46182445f, -0.45789966f, 1.20268035f, 1.14796221f, 0.77835262f, -0.25549951f, 
    0.02538649f, -0.52457219f, 0.69169617f, 0.21448621f, 0.28581104f, -0.02466111f, -0.90115184f, -0.54863852f, 
    0.49288386f, 1.38932681f, -0.58292931f, -0.14651233f, 0.38266167f, -0.24836157f, -0.63508987f, -0.93399775f, 
    0.00358176f, -0.50672966f, 0.78150433f, -0.69368398f, 0.37907851f, 0.10996107f, -0.51247573f, 0.02972904f, 
    1.50299704f, 0.19588193f, -1.21713436f, 0.33468485f, -0.39118913f, -0.15994784f, -0.26834488f, -0.26169455f, 
    -1.13461769f, 0.03350126f, -0.39723438f, 0.96045727f, 1.35164905f, 0.50320309f, -0.52280372f, -0.62659639f, 
    -0.11024126f, -0.81806898f, -1.43391669f, -0.51882601f, -1.08302951f, 0.53459477f, 1.01729536f, 0.12154615f, 
    -0.06974719f, 0.32107508f, -1.00117171f, -0.34505862f, -1.38449061f, 0.03152129f, 0.59061646f, 0.35287488f, 
    0.30993932f, -0.06640044f, -0.04259232f, 1.32840228f, 0.67884487f, -1.19865274f, -0.82654339f, -0.28715345f, 
    0.80256343f, -0.09477013f, 0.13679725f, 0.38831827f, 0.76092213f, 0.71240062f, 1.17507517f, 0.42457870f, 
    -0.02831979f, 0.63049597f, -0.63533372f, -0.19755432f, 0.41620240f, 1.35043836f, 0.55073518f, -1.03454828f, 
    0.22144935f, 0.27782354f, -0.28032073f, -0.43281969f, -0.26107928f, -0.08592135f, 0.98305881f, -1.27223814f, 
    0.82886553f, 0.92938143f, -0.37303990f, 0.50913823f, 0.15490146f, 0.04003667f, -0.54453510f, -0.52664214f, 
    1.34550452f, 0.81917465f, 0.70830756f, 0.40400973f, 0.53656840f, -0.21194415f, 0.63352728f, -0.35597649f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30693081f, 0.07324438f, 0.34763914f, -0.00824996f, 0.07950794f, 0.50501251f, 0.06863268f, 0.12455458f, 
    -0.02092308f, 0.31757838f, 0.06156348f, 0.00143289f, 0.53938687f, 0.13013357f, 0.28941771f, 0.47447777f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.28575853f, 0.16311193f, 0.13121389f, 0.09767929f, -0.09784095f, 0.05065284f, -0.04946602f, 0.10526735f, 
    0.04716804f, 0.02479441f, -0.03241396f, -0.03261323f, 0.17583092f, 0.06890183f, 0.15121876f, 0.07413024f, 
    0.10666523f, -0.39050162f, -0.18951499f, 0.04785708f, -0.69103873f, 0.12514217f, -0.14798357f, -0.15571146f, 
    -0.03547651f, 0.00179641f, 0.13027522f, -0.03391208f, 0.11104813f, 0.01724432f, 0.04041797f, 0.01165906f, 
    -0.00587650f, -0.09868135f, -0.05096538f, 0.02207715f, -0.04211581f, 0.21676666f, -0.01586150f, 0.02685544f, 
    0.04166016f, 0.33932287f, -0.11064018f, 0.00689665f, -0.09610152f, 0.10738500f, 0.01818994f, 0.01015965f, 
    0.01121310f, 0.06738560f, -0.11171803f, 0.04772584f, -0.04645530f, 0.16743790f, 0.03321956f, -0.03874777f, 
    0.02655272f, 0.09141120f, -0.24592617f, 0.15961064f, -0.15305482f, -0.03524595f, 0.04510323f, -0.22328617f, 
    -0.06006755f, 0.06778336f, 0.17958076f, 0.10776076f, 0.13091502f, 0.19091898f, 0.00331645f, 0.05048024f, 
    -0.13850002f, -0.05739355f, -0.16436040f, -0.24976821f, -0.05883307f, -0.28637865f, -0.06428530f, -0.10297748f, 
    -0.13099283f, -0.25963363f, -0.05110343f, 0.21266668f, 0.12936902f, 0.04252390f, -0.02962157f, 0.12381082f, 
    -0.09263998f, 0.04064419f, 0.00809096f, -0.04443606f, 0.10702766f, 0.14382568f, 0.03780817f, 0.06910259f, 
    0.26118702f, -0.02109490f, 0.05456946f, -0.03092930f, 0.34165916f, 0.02599233f, -0.23583223f, 0.02830653f, 
    -0.01405356f, -0.05811607f, 0.01702311f, 0.10504162f, 0.14968757f, 0.05821238f, 0.07567845f, -0.01784967f, 
    -0.01062190f, 0.07723778f, 0.10186689f, 0.13484232f, 0.12122388f, -0.22615036f, 0.14421782f, 0.15911219f, 
    -0.11186818f, -0.04888666f, -0.23069189f, 0.07362381f, -0.20063134f, 0.05474700f, -0.06085895f, -0.01647906f, 
    -0.07636052f, 0.14218880f, 0.11677773f, -0.02611426f, -0.16865106f, 0.15050884f, 0.05651090f, 0.04299872f, 
    -0.01666450f, -0.16082455f, -0.23157918f, 0.01853503f, -0.20622498f, 0.34087262f, -0.25046599f, 0.21492544f, 
    0.14437613f, 0.06872850f, 0.04029908f, 0.02997260f, 0.00527551f, 0.08748245f, 0.11993729f, 0.01905332f, 
    0.10368229f, 0.18638094f, 0.08452077f, -0.02319549f, -0.22599560f, -0.14218289f, 0.02268089f, -0.08044417f, 
    -0.32897392f, 0.23932900f, -0.17286223f, -0.00677503f, 0.01318094f, -0.19430459f, -0.09234305f, 0.07631457f, 
    -0.10867923f, -0.18652652f, 0.13061848f, 0.08187506f, -0.08903131f, -0.20780694f, -0.02807812f, 0.08271497f, 
    0.03112862f, 0.07769968f, 0.11857435f, 0.04600629f, 0.01476494f, -0.39646557f, 0.20839944f, -0.08748891f, 
    -0.17313632f, -0.00961877f, -0.03044076f, 0.10878631f, -0.02200053f, -0.15137741f, 0.04737850f, 0.00160507f, 
    0.01223278f, 0.04472357f, -0.08163757f, 0.03155543f, 0.03556565f, 0.15424994f, -0.20585808f, 0.17761475f, 
    -0.07673413f, 0.26326868f, -0.11719666f, -0.03016291f, 0.01484769f, 0.07333658f, 0.01907021f, 0.14076966f, 
    -0.03888562f, 0.13676293f, 0.09344997f, -0.02719762f, -0.08334666f, 0.11398708f, 0.05001038f, 0.04349566f, 
    0.05575240f, 0.06529542f, -0.21744488f, 0.15820853f, 0.24838880f, -0.34464383f, 0.02482978f, 0.05455815f, 
    0.11959865f, -0.16299868f, -0.11525896f, -0.09711700f, -0.04981165f, -0.10059100f, 0.03562271f, 0.03343821f, 
    -0.10752223f, 0.07590926f, 0.03707072f, 0.07999926f, -0.03672960f, 0.16200113f, 0.04526446f, 0.05620712f, 
    0.10711287f, 0.06280647f, -0.01690541f, 0.22052087f, 0.26826096f, -0.00210305f, 0.01661010f, 0.02099429f, 
    -0.06702143f, 0.15252472f, 0.02338582f, -0.11098760f, 0.07617616f, 0.01330375f, 0.18190502f, 0.07144745f, 
    -0.06345958f, 0.24671492f, 0.14906912f, 0.13978606f, 0.14738162f, -0.34494954f, 0.07370114f, -0.15966982f, 
    -0.04586488f, -0.06537215f, -0.00378507f, -0.04605834f, -0.11649577f, -0.01386414f, 0.20962241f, -0.02123961f, 
    -0.03853886f, -0.00853442f, 0.07369993f, -0.20456858f, -0.07456155f, -0.07755326f, 0.11327144f, -0.09636559f, 
    -0.24629463f, 0.23283982f, 0.19747916f, 0.27660003f, -0.06610926f, -0.08279096f, 0.02035643f, -0.02454423f, 
    -0.12999520f, 0.20123173f, 0.19148390f, -0.02680032f, 0.08857168f, -0.03291181f, 0.02898582f, -0.00142384f, 
    0.14619963f, -0.02155586f, 0.08018366f, 0.01082565f, -0.08612613f, 0.26472357f, -0.06600240f, 0.01782033f, 
    0.14028458f, -0.02106925f, 0.04936680f, -0.10177480f, 0.07520321f, 0.11465596f, 0.09737699f, 0.14486471f, 
    -0.09420139f, 0.01563722f, 0.10825571f, 0.03013570f, 0.05958007f, 0.23218133f, 0.11279207f, 0.11917715f, 
    -0.03937453f, 0.03829712f, -0.03503932f, -0.04274946f, -0.04939120f, -0.01157745f, 0.03015523f, 0.02850652f, 
    0.04169916f, -0.00685663f, -0.05203984f, -0.02199529f, 0.04302192f, -0.00159332f, 0.03539614f, 0.02432747f, 
    -0.06121179f, -0.05832762f, -0.05075425f, -0.05561493f, 0.01835107f, -0.00337976f, -0.05503173f, 0.04182021f, 
    -0.03397850f, 0.02321429f, 0.03390667f, 0.04304808f, 0.02500585f, 0.04502434f, -0.04651696f, -0.04518316f, 
    0.01128628f, -0.02631664f, 0.03199194f, 0.00110349f, -0.05098529f, -0.00012706f, -0.04344912f, -0.05130514f, 
    -0.02398751f, 0.00131848f, -0.02350345f, -0.01163015f, -0.04137943f, 0.02681072f, -0.02514262f, -0.04644858f, 
    -0.06227371f, -0.06356222f, -0.00539367f, 0.03364531f, -0.01908126f, 0.00240668f, 0.04278557f, -0.06061057f, 
    0.00709533f, -0.01788170f, 0.01092358f, -0.02350103f, -0.03778648f, -0.03771675f, -0.05338347f, -0.00002102f, 
    -0.00093955f, 0.00306282f, -0.03366273f, -0.05810932f, -0.02863198f, -0.00347891f, -0.00276648f, -0.01617239f, 
    -0.00331369f, -0.00704346f, 0.04176446f, 0.04688171f, 0.02302905f, -0.02170673f, -0.01625955f, 0.02786914f, 
    -0.02653091f, -0.01612506f, 0.02218841f, -0.00600492f, -0.05359501f, -0.05830321f, -0.05871256f, -0.02924394f, 
    -0.06164356f, -0.04794032f, 0.04672451f, 0.01722287f, -0.03536769f, 0.02372703f, 0.03659857f, 0.00441513f, 
    0.04149761f, -0.01287342f, 0.03564609f, 0.03251014f, -0.00657117f, -0.04608203f, -0.00243848f, 0.04693857f, 
    -0.01341441f, 0.01389326f, 0.00107040f, -0.01260089f, -0.05367987f, -0.04347888f, 0.03530668f, -0.02700303f, 
    -0.02226678f, 0.04510442f, -0.05282343f, -0.04360438f, 0.04363934f, -0.02442126f, -0.02063838f, -0.02576621f, 
    0.03663214f, 0.00950140f, -0.01449227f, -0.02834206f, -0.02043977f, 0.01128781f, -0.01917557f, 0.01608497f, 
    0.02989572f, -0.00632369f, -0.03576456f, 0.02428937f, 0.03779335f, -0.02830025f, 0.04796267f, 0.01759514f, 
    -0.04696482f, -0.05271917f, 0.03649543f, -0.04741415f, -0.00100406f, -0.05587773f, -0.04528020f, 0.01594971f, 
    -0.05894792f, -0.00183229f, -0.01685667f, -0.00824686f, 0.03291149f, 0.02099429f, 0.02047142f, 0.00183141f, 
    -0.01183166f, 0.00723326f, -0.05972178f, 0.00213663f, -0.00219621f, -0.05126273f, 0.02124897f, -0.05044955f, 
    0.04684082f, 0.04113835f, 0.02992198f, -0.03945836f, -0.00687833f, 0.02600637f, -0.04612344f, -0.00841100f, 
    -0.04134332f, -0.05508732f, -0.01034292f, 0.03938646f, -0.04598537f, -0.06238719f, 0.02620594f, 0.00486382f, 
    -0.03369381f, 0.04008494f, -0.04031538f, 0.03584408f, -0.01783578f, -0.05909538f, 0.02171514f, -0.04148920f, 
    -0.03511652f, -0.00914798f, 0.04401137f, -0.01849704f, 0.00809556f, 0.03803335f, -0.05787656f, -0.01175091f, 
    -0.03758337f, -0.05452324f, -0.00996902f, -0.05278648f, 0.04603700f, 0.01494264f, 0.03861262f, -0.02444766f, 
    0.00922553f, 0.03517329f, -0.04994749f, -0.04729085f, -0.02449063f, -0.02016598f, 0.01807354f, -0.02187855f, 
    0.00164287f, -0.00048700f, 0.03916731f, -0.03253824f, -0.02136283f, 0.02612206f, -0.02483218f, 0.02031906f, 
    -0.01127645f, 0.01305260f, -0.06120728f, 0.03034348f, -0.02281958f, -0.05847208f, 0.02173322f, -0.01091891f, 
    0.03802196f, -0.01891973f, -0.03702827f, 0.00348269f, -0.01722170f, -0.02408439f, 0.02634529f, 0.03118954f, 
    -0.05270792f, -0.05379766f, -0.04916239f, -0.04410861f, 0.00708693f, 0.01136824f, -0.06371017f, 0.03245782f, 
    -0.01618931f, 0.02171846f, -0.02956578f, -0.02989763f, -0.00838601f, -0.05817064f, -0.04541986f, 0.00281775f, 
    0.03967283f, 0.02150877f, -0.01403920f, 0.01905155f, -0.05907955f, -0.00187749f, 0.01117458f, 0.02524565f, 
    0.04278819f, -0.05811891f, 0.02391917f, -0.04278292f, -0.05496817f, 0.02781145f, 0.03695526f, 0.00541503f, 
    -0.04903226f, 0.03214797f, -0.03950804f, -0.06024372f, -0.05323219f, 0.04047301f, -0.03334324f, -0.06193181f, 
    -0.05404766f, -0.00561516f, 0.02316404f, -0.02277374f, 0.01753532f, -0.03201810f, -0.00561598f, -0.06153212f, 
    -0.03625084f, 0.03428701f, 0.01872779f, 0.03123689f, 0.03169803f, 0.03488296f, -0.04131982f, 0.01570028f, 
    0.03268111f, 0.04702565f, 0.01761047f, 0.01881129f, 0.00777245f, -0.03196672f, -0.00324456f, -0.01120812f, 
    0.02056937f, 0.01560301f, 0.02235484f, -0.03727614f, 0.03824117f, -0.02710009f, -0.05510973f, 0.02184488f, 
    -0.01685298f, 0.03715751f, -0.02054377f, -0.05314778f, -0.06286865f, 0.02575671f, 0.04232769f, -0.05567410f, 
    0.04234573f, -0.06118081f, 0.01810122f, 0.02640170f, -0.02904784f, 0.04048935f, 0.02069899f, -0.03634784f, 
    0.16503620f, 0.06198823f, -0.16755910f, 0.10523658f, 0.05572191f, 0.00003919f, 0.05678315f, -0.03353478f, 
    0.06921044f, -0.06079367f, 0.17801626f, -0.00001803f, -0.00301705f, -0.01755902f, 0.01119170f, -0.12322316f, 
    0.02458125f, 0.14857408f, 0.00586883f, 0.00875986f, -0.21185854f, 0.57654202f, 0.04772679f, -0.08018996f, 
    -0.08021834f, 0.02236229f, 0.01193617f, -0.08165237f, 0.12364042f, -0.04333549f, 0.06003850f, 0.08347035f, 
    -0.07868487f, 0.20020498f, 0.05585193f, -0.03440309f, 0.08893766f, -0.26471442f, -0.12052556f, 0.03399398f, 
    0.13460685f, 0.16308357f, 0.30917314f, 0.22528334f, 0.08677579f, -0.16118167f, -0.00756570f, -0.04283806f, 
    0.03055567f, -0.16159970f, 0.16377720f, -0.01269813f, -0.04323231f, 0.01036103f, 0.17118286f, 0.08100862f, 
    -0.04830382f, -0.06609041f, 0.10010987f, -0.07800388f, 0.20448211f, 0.49983004f, -0.03954797f, 0.48194537f, 
    0.03721270f, -0.02358170f, -0.12251361f, 0.01802120f, 0.03428630f, -0.14650385f, 0.12302563f, 0.22439089f, 
    0.11428710f, -0.07467416f, 0.15804069f, 0.11849324f, 0.06714199f, 0.01569470f, 0.17959870f, 0.18294828f, 
    -0.10288349f, -0.47770631f, -0.10916071f, 0.04515217f, 0.19193991f, 0.01605461f, 0.09866242f, -0.01542453f, 
    -0.02160652f, 0.07202937f, 0.10089294f, -0.01875650f, -0.07313304f, -0.16782333f, 0.12279999f, 0.03257455f, 
    -0.02914208f, -0.14006741f, 0.10570562f, 0.21049243f, -0.48871601f, 0.39253768f, 0.15684813f, 0.40121967f, 
    -0.01149616f, 0.11270379f, -0.03235123f, -0.01452924f, -0.11248752f, -0.05021407f, -0.17058283f, 0.01885724f, 
    -0.02393620f, 0.01245529f, -0.04311133f, -0.09477199f, 0.02640323f, 0.11126872f, 0.10125861f, -0.07764094f, 
    -0.42812997f, 0.24169227f, 0.26846036f, -0.01741847f, 0.33691457f, -0.07290363f, 0.03640003f, 0.01832473f, 
    0.01524152f, -0.00471495f, 0.09246393f, 0.04251838f, 0.03821069f, 0.02183476f, 0.00108546f, -0.00530873f, 
    0.03222410f, 0.06147785f, 0.10338524f, -0.06822312f, 0.17097610f, -0.19966336f, 0.14220449f, 0.26116228f, 
    -0.10671815f, -0.10670209f, 0.05912365f, -0.01853073f, -0.03918795f, 0.04239867f, 0.23133476f, -0.01757857f, 
    0.06368591f, -0.06865588f, 0.16289295f, 0.03048769f, 0.16733560f, 0.01755710f, 0.00943209f, 0.09204446f, 
    -0.57379544f, -0.20494781f, -0.02661030f, 0.17158318f, 0.15006730f, 0.03651686f, -0.02613810f, 0.20907831f, 
    0.08496416f, 0.20937428f, -0.10967792f, -0.14684086f, 0.15581033f, 0.08548887f, -0.06244592f, -0.12070324f, 
    0.02422572f, 0.08329845f, 0.04593620f, -0.05556126f, -0.31096265f, 0.27791232f, 0.00050749f, 0.14779286f, 
    0.24872757f, 0.09100678f, 0.05263945f, -0.07072335f, 0.00642079f, 0.14776680f, -0.08626170f, 0.08453188f, 
    -0.06809261f, -0.10280208f, 0.08284663f, -0.03528336f, 0.12874752f, 0.06004930f, 0.05223722f, -0.14505240f, 
    -0.10362942f, -0.20713520f, -0.06209805f, 0.19832425f, 0.08494541f, 0.00182148f, -0.09807285f, 0.11052769f, 
    -0.15968050f, -0.03050875f, -0.09561384f, -0.00211134f, 0.15927266f, -0.11754896f, -0.09800564f, 0.00804799f, 
    -0.00218964f, 0.07909171f, 0.05919696f, -0.11856288f, 0.10064247f, 0.11407342f, -0.13619827f, 0.07207582f, 
    -0.18827556f, 0.05201385f, 0.11148464f, 0.10037094f, -0.25314081f, 0.03592305f, -0.10049687f, 0.05253334f, 
    -0.09277547f, -0.16651160f, 0.20045844f, 0.04996656f, 0.06257682f, 0.03774261f, -0.05184337f, -0.07814965f, 
    0.02919576f, -0.34406859f, -0.05433702f, -0.40646860f, -0.05216246f, 0.04133613f, 0.09261589f, -0.11737531f, 
    0.03260503f, -0.13192755f, 0.07529762f, 0.08942951f, 0.01061148f, 0.09107297f, -0.11883000f, 0.06640923f, 
    0.01923269f, -0.00246743f, -0.00693663f, 0.02425631f, -0.00220352f, 0.47207022f, -0.04428473f, -0.05430178f, 
    -0.42886713f, 0.15487321f, 0.00397143f, 0.02846468f, -0.00396007f, 0.05985255f, 0.02239290f, 0.05173954f, 
    0.11104719f, -0.03258179f, 0.07394347f, 0.04668263f, 0.13156714f, 0.08193983f, 0.01354444f, 0.09543826f, 
    -0.28858420f, 0.00866609f, -0.27453154f, -0.20152186f, -0.19121480f, 0.19637880f, -0.05808749f, -0.01925357f, 
    0.03051151f, -0.08152828f, 0.13905795f, -0.07874853f, -0.11873023f, 0.04589134f, 0.00978046f, 0.08574245f, 
    0.11182019f, -0.14473186f, -0.15502577f, -0.03319877f, 0.24317966f, -0.22351347f, 0.13936965f, -0.15914270f, 
    -0.10854164f, 0.11643536f, 0.17649040f, 0.00157868f, 0.21368103f, -0.13275453f, 0.04034871f, -0.07075356f, 
    0.05837261f, 0.00263767f, 0.08433906f, 0.26005596f, 0.06781063f, -0.02654700f, 0.14801775f, -0.01321433f, 
    0.03467182f, 0.02964951f, -0.04496477f, 0.01500186f, -0.02706890f, -0.04311170f, -0.04797259f, 0.04302341f, 
    -0.00367147f, -0.04697473f, 0.01909320f, 0.04522641f, 0.01737983f, 0.03616763f, -0.02029642f, -0.01415046f, 
    -0.01503443f, 0.02375150f, 0.01902102f, 0.01751821f, 0.02894231f, 0.01337908f, -0.01139250f, -0.03239583f, 
    0.00166561f, -0.02468814f, 0.01599255f, -0.04472442f, -0.05022544f, -0.02637680f, 0.04140745f, 0.04998231f, 
    -0.00449909f, -0.04948587f, 0.03167750f, 0.02441124f, 0.04820360f, -0.05330549f, -0.05130532f, -0.01752750f, 
    0.02335176f, -0.00837958f, -0.04042258f, -0.03402982f, -0.05095026f, 0.04788397f, 0.00738792f, 0.02648455f, 
    0.00345037f, -0.02947950f, 0.01605289f, 0.04862392f, -0.01910421f, 0.00538495f, -0.01520777f, 0.04305911f, 
    -0.04328652f, -0.01156134f, 0.04612832f, 0.03324582f, -0.02873720f, -0.01007275f, -0.00111333f, 0.04384832f, 
    -0.01727939f, -0.01064885f, -0.01591442f, 0.01150608f, -0.00420769f, -0.01848459f, 0.03951826f, 0.03112665f, 
    0.00027855f, 0.04754961f, -0.02460209f, -0.03718953f, -0.01436068f, 0.02416297f, -0.02032869f, -0.03065187f, 
    -0.03079963f, -0.01664645f, 0.01291453f, -0.04340532f, 0.03203426f, 0.00550353f, -0.02316896f, 0.00755951f, 
    0.03148816f, 0.03231507f, 0.02308101f, -0.00223590f, -0.01609922f, 0.00635336f, -0.01213305f, -0.04054834f, 
    -0.03295375f, -0.01241023f, -0.03111858f, 0.01226297f, 0.00787173f, -0.02205864f, -0.01755167f, 0.03909762f, 
    -0.02921457f, -0.00792371f, -0.00618221f, -0.00793757f, 0.02510746f, 0.00530877f, -0.03159241f, 0.00244684f, 
    0.01395371f, -0.03880970f, 0.01259305f, 0.03238989f, 0.02639956f, -0.01114129f, 0.03673637f, -0.02698790f, 
    0.00094087f, 0.05211471f, 0.00435645f, 0.04598513f, -0.04370466f, 0.04975227f, 0.03332847f, 0.00580910f, 
    0.04661643f, 0.00753823f, -0.03140207f, 0.01996348f, -0.05916007f, 0.01836375f, 0.02640748f, -0.01242314f, 
    -0.01600219f, 0.02247715f, -0.05074368f, 0.02057068f, 0.01562402f, 0.04438460f, -0.03537651f, -0.04764529f, 
    -0.05394334f, -0.04160674f, -0.06046399f, 0.01153824f, 0.03922718f, -0.05740608f, 0.02716825f, -0.01388689f, 
    0.03696657f, 0.00060410f, 0.02186194f, -0.04926154f, 0.02592141f, 0.03387500f, 0.02823286f, 0.03328785f, 
    -0.02291583f, 0.00744093f, 0.00676397f, 0.04506703f, 0.00420919f, 0.00833096f, -0.05477713f, -0.00462500f, 
    -0.04987966f, 0.04155964f, 0.01155219f, 0.02487351f, 0.00971439f, -0.05177922f, 0.01758257f, 0.04060258f, 
    0.01317282f, 0.04520603f, -0.06223360f, -0.05377103f, 0.04675905f, -0.04420562f, 0.01931033f, -0.01248929f, 
    -0.05640557f, -0.06202833f, -0.00838579f, -0.05701247f, -0.01225713f, -0.01564370f, 0.00029856f, 0.04738200f, 
    0.00891330f, -0.05094902f, 0.04476993f, -0.00691079f, -0.03150015f, -0.05131676f, 0.01172772f, -0.01666024f, 
    -0.00493461f, 0.02748626f, 0.01227612f, 0.00108558f, -0.03923060f, -0.02107126f, -0.05978552f, 0.04540996f, 
    0.00629619f, 0.04147640f, -0.01257456f, -0.03600546f, 0.01648639f, -0.04168932f, -0.03442416f, -0.01421756f, 
    0.04728007f, -0.04993568f, 0.02084240f, -0.03704360f, 0.04518189f, -0.01213338f, -0.01838554f, 0.01650401f, 
    0.05019230f, -0.02116163f, -0.02027385f, -0.06129786f, -0.04713618f, 0.04827614f, 0.01746454f, -0.04886632f, 
    -0.01964707f, 0.01340467f, -0.03244863f, -0.03310619f, -0.02973845f, -0.05888836f, 0.04251452f, -0.05915874f, 
    -0.05424003f, -0.05049634f, -0.01882652f, 0.04062829f, 0.00359965f, 0.02015604f, -0.02610465f, 0.02431872f, 
    -0.01248089f, -0.03447085f, 0.00428087f, 0.04272159f, -0.00131621f, -0.00585352f, 0.03248905f, 0.03062880f, 
    0.03325152f, -0.01820716f, -0.03341282f, 0.01641017f, 0.04222017f, 0.02415999f, -0.04479468f, -0.03620581f, 
    -0.02784663f, -0.05976210f, 0.00893464f, 0.01892736f, -0.05970785f, 0.03272716f, -0.04275513f, -0.02526827f, 
    -0.02541132f, 0.00368926f, -0.03248818f, 0.01917850f, 0.02775422f, -0.05882291f, -0.05805647f, 0.03446919f, 
    -0.00075345f, 0.02683942f, -0.03865558f, -0.02347928f, 0.02762933f, -0.00177238f, 0.01979182f, -0.00990993f, 
    -0.03838506f, 0.04090615f, 0.03022300f, 0.00458041f, 0.00151402f, -0.04234173f, -0.01122523f, 0.02624262f, 
    -0.05912271f, -0.03760374f, -0.03777339f, -0.04563878f, 0.02005902f, -0.02427929f, -0.05410013f, 0.00072178f, 
    -0.01055503f, 0.00159247f, 0.03093384f, -0.05265985f, 0.00827155f, -0.01531172f, 0.00227480f, 0.02860039f, 
    -0.05420936f, 0.02725158f, -0.05175076f, -0.02025693f, 0.02604779f, -0.02259183f, 0.03103137f, -0.05312159f, 
    -0.01791065f, 0.04092162f, 0.01195613f, 0.03578207f, -0.00032230f, -0.03513935f, 0.00531579f, 0.03366182f, 
    -0.00832610f, -0.01214680f, -0.02958071f, -0.01123731f, -0.00575147f, -0.04217606f, -0.00290661f, -0.04178035f, 
    -0.06060370f, -0.02767739f, -0.04080911f, 0.02790307f, -0.03365261f, -0.03295168f, -0.05295200f, 0.03126397f, 
    -0.00136988f, -0.02037539f, -0.04966700f, 0.04584769f, 0.01691264f, -0.04082533f, -0.01473958f, 0.03204680f, 
    -0.01596947f, 0.01666925f, 0.03193221f, -0.01203332f, 0.03106822f, -0.02565846f, 0.00240627f, 0.03599567f, 
    -0.04329691f, -0.00962099f, 0.02710792f, 0.03928675f, 0.02809882f, -0.00604668f, -0.05211104f, -0.05103303f, 
    0.02222394f, 0.00462483f, 0.00293729f, 0.03646779f, -0.00408715f, 0.00631407f, -0.05436775f, 0.00396259f, 
    -0.02154555f, -0.00234905f, 0.01219015f, -0.04590680f, -0.02082992f, -0.00535177f, -0.03247353f, -0.02700552f, 
    0.03062350f, 0.02963344f, 0.05059591f, 0.03294622f, 0.01495517f, -0.03169573f, 0.02684005f, -0.01902064f, 
    0.03585548f, -0.01915579f, -0.05948406f, -0.00816946f, -0.04198947f, 0.00808480f, -0.03474300f, -0.05250431f, 
    0.02639918f, 0.00734166f, 0.01920234f, -0.01791098f, 0.01164778f, 0.01707682f, -0.00270420f, -0.00191290f, 
    -0.04005432f, 0.01527197f, 0.01727864f, -0.02870066f, 0.00809790f, 0.03023934f, 0.02784207f, -0.04965699f, 
    -0.03370903f, 0.00256121f, 0.01566426f, 0.02396002f, -0.05863065f, 0.03106130f, 0.02854025f, 0.00860863f, 
    -0.02945417f, 0.01854745f, -0.03744159f, -0.02152838f, -0.04177972f, -0.01655613f, 0.04283735f, 0.00713435f, 
    0.01323113f, -0.02093233f, -0.02813466f, -0.03909855f, -0.04843785f, 0.03021708f, 0.02403930f, -0.01517262f, 
    -0.06422882f, 0.03042444f, 0.02212590f, -0.05443928f, -0.03101363f, 0.01921327f, -0.05971076f, 0.01816722f, 
    0.01031263f, 0.03627472f, 0.01930659f, -0.03028307f, -0.00555053f, 0.00638785f, 0.03145609f, -0.03403598f, 
    -0.00907404f, 0.04208736f, 0.01130516f, -0.01601728f, -0.03793877f, 0.01901846f, -0.04920486f, 0.04146133f, 
    0.04758325f, 0.03685649f, 0.01758191f, 0.02402131f, -0.02988610f, 0.02225497f, 0.02418044f, 0.04407796f, 
    0.03649275f, -0.01150614f, -0.02703395f, 0.00689852f, -0.04577920f, 0.02990835f, -0.03946585f, -0.04803104f, 
    -0.00648022f, -0.04947394f, 0.02126189f, -0.05346814f, 0.02339721f, 0.02049666f, -0.01824170f, -0.00450540f, 
    0.02103331f, 0.01066202f, -0.04562058f, 0.04313463f, 0.04794668f, 0.00714504f, -0.03469190f, 0.00460739f, 
    0.01773248f, -0.00031445f, -0.04742197f, -0.01574867f, 0.02801813f, 0.00967413f, 0.03245918f, 0.04408766f, 
    -0.00432259f, -0.01317924f, 0.03773417f, 0.02659347f, -0.02286504f, 0.01735002f, 0.01781623f, -0.03779540f, 
    0.04072137f, 0.04353314f, -0.02356024f, -0.03167383f, 0.04042298f, -0.00103104f, -0.02410597f, -0.04163155f, 
    -0.03691953f, -0.04401495f, 0.01489868f, -0.04894709f, -0.03684654f, 0.03579327f, 0.02321454f, 0.00628612f, 
    0.00972727f, -0.04361752f, 0.04155042f, 0.01603285f, -0.04129774f, -0.00807653f, 0.04806464f, -0.01697377f, 
    0.00224689f, 0.01426158f, -0.00347331f, 0.02666180f, -0.01923849f, 0.00039172f, 0.00619112f, -0.04325963f, 
    -0.01900854f, 0.01404563f, -0.03963836f, 0.00071563f, -0.04513532f, -0.03538650f, 0.00775903f, -0.01197736f, 
    -0.06460914f, -0.04718168f, -0.00123427f, 0.02839085f, -0.05515205f, 0.01346854f, 0.02434403f, 0.00749439f, 
    0.02689371f, -0.05438151f, 0.03551382f, -0.04612688f, 0.03419079f, -0.05942822f, 0.04353791f, 0.00769649f, 
    0.01222118f, -0.04509169f, -0.03927222f, 0.02586297f, 0.01802502f, -0.03296250f, 0.03184178f, -0.04742897f, 
    -0.00402898f, -0.01586719f, 0.00854283f, -0.00573822f, -0.00243336f, 0.03609579f, -0.05403542f, -0.02230909f, 
    0.01736981f, 0.00501706f, 0.01271034f, -0.02498895f, -0.05338670f, -0.03838453f, -0.04563782f, -0.03161218f, 
    0.04308064f, 0.04893857f, -0.01527241f, 0.01342330f, 0.00574923f, -0.02323526f, -0.03486589f, 0.02769314f, 
    -0.01510600f, -0.01208993f, -0.03916663f, -0.03009427f, -0.00060681f, -0.05591463f, 0.04169995f, -0.03204530f, 
    0.03659621f, -0.05876920f, -0.03436656f, -0.05201110f, 0.00081503f, 0.00922660f, -0.03912651f, 0.00792151f, 
    0.04232169f, 0.03685554f, -0.03711876f, -0.05197687f, 0.00216057f, -0.00434894f, -0.06156790f, -0.02267134f, 
    0.01806891f, 0.00643147f, -0.00067797f, -0.06004805f, 0.02594735f, -0.04281062f, -0.00537330f, -0.02170859f, 
    0.00057873f, 0.03755521f, 0.00303448f, 0.00860780f, -0.06080030f, 0.04157304f, -0.01057447f, 0.02711849f, 
    -0.01452295f, 0.02263911f, -0.01372924f, -0.31514987f, -0.21065050f, 0.09452097f, 0.10205388f, 0.10094400f, 
    -0.01984145f, 0.02317259f, -0.05000493f, 0.01238554f, -0.02428886f, -0.07479024f, 0.03849538f, -0.01679643f, 
    0.04664780f, 0.13456205f, 0.11065250f, 0.08147990f, 0.56827259f, -0.10938127f, -0.24811840f, 0.01746645f, 
    0.41014874f, 0.01818246f, 0.03992715f, 0.19282302f, 0.12932831f, 0.07896814f, 0.01627271f, -0.00265919f, 
    0.09179924f, -0.08944252f, 0.04511234f, 0.02104011f, 0.04461181f, 0.03279082f, 0.07490812f, 0.04222846f, 
    -0.15435521f, 0.02663777f, 0.17306520f, -0.13071577f, -0.24712785f, 0.07702220f, 0.06562069f, 0.04928124f, 
    -0.04474012f, 0.18699199f, 0.07245751f, 0.16189982f, 0.19856972f, -0.10676495f, -0.27898753f, -0.04141878f, 
    -0.10695027f, -0.00210645f, 0.14676343f, 0.13684756f, -0.29719722f, -0.42903444f, -0.10166830f, -0.22121857f, 
    -0.25298956f, -0.04434257f, 0.10753854f, 0.05650374f, -0.11333228f, -0.03727305f, -0.02932350f, -0.11613745f, 
    -0.00617677f, -0.00025214f, -0.00793517f, -0.04244250f, 0.08232104f, 0.09709065f, -0.01617050f, -0.17871928f, 
    -0.26397270f, 0.37149975f, 0.17087789f, -0.11321326f, -0.15484726f, 0.00334325f, 0.07935359f, -0.03135495f, 
    0.00800496f, 0.02091696f, 0.08467680f, 0.09028944f, 0.04233545f, 0.02485621f, -0.09541859f, -0.08898178f, 
    -0.15095764f, 0.10822685f, -0.04804406f, -0.18735902f, 0.25264895f, -0.29889271f, 0.09166936f, -0.18518266f, 
    -0.03243647f, -0.09741554f, 0.06321338f, -0.02291796f, 0.02187045f, 0.10617631f, 0.15148573f, 0.10582956f, 
    0.07192200f, 0.03540483f, 0.10386251f, 0.17705686f, -0.02667946f, 0.18546680f, -0.05216772f, 0.21741974f, 
    0.52782655f, -0.48086566f, -0.22077020f, -0.03067795f, -0.30874440f, 0.00908168f, -0.00461609f, -0.10308675f, 
    -0.01922274f, 0.10115622f, 0.03795664f, -0.01603136f, -0.00485061f, 0.00371173f, 0.05517882f, 0.11445225f, 
    0.06469113f, 0.03671133f, 0.15390615f, 0.10270394f, -0.34790340f, 0.33810687f, 0.08859215f, -0.29361999f, 
    0.20260516f, 0.37224552f, 0.13726425f, 0.05665401f, -0.04788822f, -0.04497070f, -0.07112006f, 0.01988880f, 
    -0.03954187f, -0.05078898f, -0.08978350f, 0.07055557f, 0.08229735f, 0.10287848f, -0.04545680f, -0.00956426f, 
    0.74367595f, -0.21020989f, -0.12632677f, 0.10549652f, 0.12389254f, 0.05162142f, -0.06539202f, -0.17612459f, 
    0.14654945f, 0.22057801f, 0.08513788f, 0.10696127f, -0.07488167f, 0.10987632f, 0.13694620f, 0.03959167f, 
    0.08932583f, 0.01771746f, -0.02868196f, 0.01245766f, 0.60012829f, -0.09766138f, 0.08554879f, 0.10335834f, 
    -0.13884427f, -0.09128805f, 0.09822532f, 0.03180896f, 0.03945836f, 0.16610844f, 0.06473623f, -0.09710080f, 
    0.19314846f, 0.13870130f, 0.09610809f, -0.03000113f, 0.05728216f, -0.08134906f, 0.17803578f, 0.03674753f, 
    0.36526933f, 0.04161059f, -0.02358356f, 0.12551433f, -0.04390872f, -0.09694814f, 0.02591243f, -0.18457632f, 
    0.23394960f, 0.13087863f, 0.08618545f, 0.01745423f, -0.06262235f, 0.03361216f, 0.14576299f, -0.02634435f, 
    0.02889296f, 0.00901773f, 0.15028772f, 0.11830842f, 0.09677298f, -0.28990120f, 0.05447054f, 0.06182363f, 
    -0.12087981f, 0.03793247f, -0.15029150f, 0.04743889f, 0.17633143f, 0.04339638f, 0.09119806f, 0.00240025f, 
    0.16757812f, 0.20005146f, -0.03274206f, 0.00383230f, 0.02565809f, 0.05299937f, 0.10418724f, -0.10358443f, 
    -0.17320737f, 0.27804023f, 0.06760351f, 0.27321523f, 0.14330336f, 0.12262847f, 0.17575270f, 0.04903345f, 
    0.03748577f, 0.09185311f, 0.06338921f, 0.09495142f, 0.03194752f, 0.11468759f, 0.05590668f, -0.06141693f, 
    0.13977937f, -0.06518984f, -0.03546886f, -0.06297456f, -0.07429677f, -0.44027731f, 0.09304063f, 0.08729200f, 
    0.04138414f, -0.03798698f, -0.04862200f, 0.04590999f, 0.13370751f, -0.02395510f, 0.08376516f, -0.03245137f, 
    -0.00715438f, 0.02335319f, 0.01709680f, 0.07823813f, -0.06711772f, 0.07812937f, 0.06238729f, -0.01313749f, 
    0.37674490f, 0.16098014f, 0.21610563f, -0.03817539f, 0.14819294f, 0.05298172f, 0.15404662f, 0.21158631f, 
    -0.07547820f, 0.02431934f, -0.05830477f, 0.09150568f, 0.01073037f, 0.03230958f, 0.17157184f, -0.04852606f, 
    -0.07067393f, 0.17128514f, 0.10938172f, 0.23856951f, 0.21681392f, 0.33345240f, -0.29663643f, 0.00409899f, 
    0.33556983f, -0.04516465f, -0.08631510f, 0.16294813f, -0.02499249f, 0.23473795f, 0.02616669f, 0.04347062f, 
    0.09607530f, 0.04755008f, 0.10333951f, -0.06226990f, -0.05330333f, -0.06639270f, -0.03332056f, -0.01377271f, 
    -0.00085797f, 0.04067097f, -0.01403284f, 0.03717497f, -0.06097652f, 0.01462522f, 0.03111155f, 0.01926854f, 
    0.01187246f, 0.01207001f, -0.00626437f, 0.02421609f, -0.00991533f, -0.02445874f, 0.01088365f, 0.02719145f, 
    -0.04656543f, 0.01579137f, -0.03277484f, 0.02569814f, 0.01906422f, -0.04729443f, 0.00726690f, 0.01124895f, 
    -0.04605815f, 0.05018514f, -0.04861644f, 0.03835781f, 0.01306992f, -0.00735712f, -0.01751069f, -0.05719233f, 
    -0.01167780f, -0.02294769f, -0.04423969f, -0.04233887f, 0.02684893f, 0.00340892f, 0.02360550f, -0.04248409f, 
    0.02297221f, 0.01035665f, -0.01600641f, -0.00177870f, -0.04044158f, -0.02099336f, -0.04184240f, -0.03105329f, 
    -0.00481511f, -0.06114697f, -0.03260618f, -0.00960830f, 0.04998665f, -0.05832211f, -0.03350056f, -0.02572218f, 
    0.00197624f, 0.01682429f, -0.00763723f, 0.02534793f, -0.02636773f, -0.04131479f, -0.04696467f, 0.04547730f, 
    -0.04335862f, 0.00583137f, -0.04058249f, 0.01342925f, 0.03667123f, -0.03577613f, -0.00008378f, -0.05958216f, 
    0.01561446f, -0.03704581f, 0.01926476f, -0.03295929f, -0.04132958f, 0.05514899f, 0.00463944f, 0.04788309f, 
    0.05513129f, 0.05827638f, -0.00206907f, -0.04466280f, -0.01030267f, 0.03610843f, -0.00287888f, -0.01283429f, 
    -0.03672834f, 0.03939178f, -0.03506298f, -0.01623484f, 0.01105516f, -0.03782360f, 0.02839866f, 0.05253668f, 
    0.04279716f, 0.01130806f, -0.02652144f, 0.03398810f, 0.00264997f, -0.04948835f, 0.01798577f, 0.00150139f, 
    -0.02970422f, -0.03478994f, 0.01317615f, -0.05192183f, -0.03201459f, -0.01890504f, 0.03656759f, -0.02339827f, 
    -0.05986175f, 0.03506968f, -0.01166013f, 0.00028018f, -0.02373425f, 0.00936627f, 0.03966730f, 0.03732949f, 
    0.00550164f, -0.02997845f, -0.04075980f, 0.00018647f, 0.04852986f, 0.01163147f, -0.05281839f, 0.04013998f, 
    0.04658281f, 0.03283442f, 0.03756635f, -0.03701128f, 0.04636316f, 0.01449292f, -0.06125661f, 0.01785077f, 
    0.03240308f, -0.06200395f, 0.02022536f, -0.01986963f, -0.06431733f, -0.03584514f, -0.02267695f, -0.05828776f, 
    -0.02902496f, 0.04600408f, 0.04847248f, -0.04083941f, -0.04668530f, -0.04052146f, 0.02246669f, -0.02844540f, 
    -0.03182948f, 0.02181042f, 0.02085479f, 0.02006860f, 0.00719244f, 0.03268529f, 0.06054037f, 0.01308356f, 
    -0.01982338f, -0.02894202f, -0.05978957f, 0.03735872f, -0.05455292f, 0.03992412f, 0.01914821f, 0.03103512f, 
    0.04353676f, -0.03590363f, -0.03661195f, 0.01562199f, -0.02555976f, -0.05609814f, 0.00016484f, 0.04246300f, 
    -0.04913267f, -0.01675703f, -0.01521184f, -0.06510772f, -0.02099507f, 0.02491270f, -0.02012051f, -0.04129007f, 
    -0.02242953f, -0.00911731f, -0.03781731f, -0.02195846f, -0.05138173f, -0.00326198f, 0.02336182f, -0.01808960f, 
    0.00622968f, 0.04994206f, -0.03699402f, 0.04810027f, -0.02405404f, -0.04486407f, 0.03920458f, -0.04381478f, 
    -0.04067412f, 0.01512812f, 0.02932990f, 0.00782426f, -0.04090222f, 0.01138137f, 0.04274714f, -0.02526363f, 
    -0.01066125f, 0.02483366f, 0.03226874f, 0.03642209f, -0.03308389f, 0.02172340f, -0.05717314f, 0.01019185f, 
    0.00173433f, -0.05319894f, -0.01982522f, -0.02858028f, 0.04960803f, -0.04146860f, -0.01368778f, 0.01163775f, 
    -0.02141487f, 0.04138009f, 0.03174398f, -0.02321130f, 0.00243654f, 0.00448431f, -0.04658423f, -0.01340729f, 
    0.01614692f, -0.01532832f, 0.01441268f, 0.00728961f, -0.03224196f, -0.05018659f, 0.02103718f, -0.06285479f, 
    0.04476645f, 0.00345767f, -0.03113558f, -0.04930982f, -0.05096800f, 0.01036074f, -0.03906480f, -0.02585714f, 
    0.02971414f, -0.03231492f, -0.02287478f, 0.01481477f, 0.02304867f, 0.02582095f, -0.02588487f, -0.02286939f, 
    0.01066396f, 0.02234541f, -0.04844158f, -0.02314137f, -0.02065153f, 0.02667726f, -0.03767904f, 0.00399375f, 
    0.02325007f, 0.03970027f, 0.04747094f, 0.00373201f, -0.01302244f, -0.03062732f, 0.02316364f, -0.06123872f, 
    -0.03760611f, -0.01336210f, -0.00358966f, -0.03952627f, 0.04380673f, -0.05871006f, 0.01306226f, 0.04088956f, 
    -0.01436105f, 0.03775013f, 0.02278256f, 0.02521435f, 0.02652887f, -0.03957135f, 0.02447267f, 0.04202573f, 
    -0.01437847f, 0.00610303f, -0.02040483f, -0.05085372f, -0.05018173f, -0.02610221f, 0.03959598f, 0.02747153f, 
    -0.04603084f, -0.03519464f, -0.00006547f, 0.00615217f, 0.04482013f, -0.02472829f, 0.03020217f, -0.01629427f, 
    -0.00410969f, -0.02066304f, 0.01291754f, -0.05739115f, 0.02514740f, -0.00284630f, -0.03991195f, -0.01165720f, 
    -0.04582554f, -0.02452090f, 0.02512859f, 0.04130397f, 0.02531540f, -0.00422360f, -0.01754713f, 0.03511522f, 
    0.01556797f, -0.04594906f, 0.01254691f, -0.03036994f, 0.00573161f, -0.04995422f, -0.05490916f, 0.03467137f, 
    -0.01939647f, 0.01006475f, -0.03476469f, 0.04061780f, 0.04016658f, -0.01818700f, -0.03828865f, 0.04032742f, 
    -0.01114601f, 0.04325764f, -0.04594821f, -0.05145397f, 0.00973889f, 0.00477649f, -0.02546478f, -0.01094255f, 
    0.03128784f, 0.03502688f, 0.03318708f, 0.04709564f, -0.01003177f, -0.03973753f, -0.03374550f, 0.02054496f, 
    -0.03301631f, -0.01318705f, 0.00157951f, 0.04566230f, 0.03045342f, 0.01384488f, 0.00363197f, -0.04979089f, 
    0.00848351f, 0.04566617f, 0.00920155f, 0.00224101f, -0.00779822f, -0.05660161f, -0.00024353f, 0.03827191f, 
    0.01060502f, -0.03932090f, -0.01169869f, 0.01901341f, -0.05731953f, -0.02890606f, 0.02245630f, -0.04337725f, 
    0.02490671f, -0.00330163f, -0.06300460f, -0.03378784f, 0.00287301f, -0.03608489f, -0.00428914f, -0.00331078f, 
    -0.04986348f, 0.02891583f, -0.00212288f, -0.04798038f, 0.04427975f, -0.04115301f, 0.02287774f, -0.05210711f, 
    -0.04899593f, -0.02269452f, 0.00266952f, -0.04138199f, 0.02718107f, -0.05148225f, 0.00736485f, -0.01790148f, 
    0.03655651f, -0.00531715f, -0.04021706f, -0.05319569f, -0.02904682f, 0.01019080f, -0.04291629f, 0.01485567f, 
    -0.01686789f, 0.02297196f, -0.02190192f, -0.00199576f, -0.02852643f, -0.05757475f, 0.00511640f, 0.03844632f, 
    -0.05827213f, -0.05153625f, 0.00021280f, -0.01991577f, 0.05142920f, 0.04184569f, -0.03376961f, -0.01683819f, 
    -0.01336394f, -0.05423345f, -0.04281066f, 0.01372946f, 0.00272298f, 0.04422636f, 0.00618912f, -0.04487515f, 
    -0.02759809f, -0.05634304f, 0.01674211f, -0.02942725f, 0.02830805f, -0.01969024f, 0.00332947f, 0.03728041f, 
    -0.02042528f, 0.01781145f, -0.00592659f, 0.00430825f, 0.01107859f, -0.03278303f, -0.01229171f, 0.03891512f, 
    0.00606381f, -0.05433590f, -0.00574463f, 0.03596756f, -0.00553996f, -0.03148881f, 0.00964864f, -0.02534322f, 
    -0.03450571f, 0.02683612f, -0.04251093f, -0.00761494f, 0.04326769f, 0.03295958f, -0.04661963f, -0.00011581f, 
    -0.00665512f, 0.00658496f, -0.04950609f, 0.02202116f, -0.03768375f, 0.03067514f, -0.04000545f, 0.00570636f, 
    0.02097904f, 0.03311089f, -0.02543054f, -0.02446292f, -0.05028052f, 0.03650225f, -0.02366128f, 0.03421077f, 
    -0.04981654f, -0.04351420f, 0.02014685f, 0.01871478f, -0.05101025f, 0.04058158f, -0.01963656f, -0.06008774f, 
    0.03999506f, 0.02236117f, -0.05344544f, 0.02825165f, -0.00854550f, -0.04895880f, 0.01991958f, -0.02600908f, 
    0.03101837f, 0.04754129f, -0.03728233f, -0.04456973f, -0.03152448f, -0.01003965f, 0.00318287f, -0.00992476f, 
    -0.04401737f, 0.00148789f, 0.01657558f, 0.01444547f, -0.03565191f, -0.04351339f, 0.03894677f, -0.05782167f, 
    0.04562974f, 0.03149492f, -0.03412701f, 0.02141962f, 0.01444475f, 0.04332810f, -0.00541034f, 0.03715678f, 
    0.01717301f, -0.03819737f, -0.02229450f, -0.04324583f, -0.01070984f, 0.00416317f, 0.04040208f, -0.05881287f, 
    -0.02442326f, -0.05627322f, 0.04348079f, -0.00819403f, -0.02416904f, -0.01596077f, -0.05479017f, 0.00265793f, 
    -0.05869626f, 0.01803050f, -0.01256938f, -0.00120551f, 0.04533141f, 0.04378161f, -0.04211222f, 0.03779293f, 
    -0.03408640f, 0.02257953f, -0.01756616f, -0.03418335f, 0.04240805f, -0.03186556f, -0.02311421f, 0.02583819f, 
    -0.00956406f, -0.02660686f, 0.03030501f, -0.01159096f, 0.03129467f, -0.03479890f, -0.01863172f, -0.01614119f, 
    0.01697731f, 0.05438969f, -0.00590415f, 0.01595212f, -0.00214519f, -0.05155078f, 0.04129462f, -0.03592886f, 
    -0.00927995f, 0.01697063f, -0.02256284f, 0.01717767f, -0.06458330f, -0.01264833f, -0.05232104f, -0.00905675f, 
    0.02144704f, 0.02456920f, -0.03625377f, -0.00407718f, 0.04811078f, -0.02160456f, 0.02857850f, 0.04979000f, 
    0.05023114f, -0.00092036f, -0.03039042f, 0.01158754f, 0.00566163f, 0.02576748f, 0.02178515f, 0.04517023f, 
    -0.01734131f, -0.06103127f, -0.05630656f, 0.05057178f, -0.03398657f, -0.00319101f, -0.06377978f, -0.05649886f, 
    -0.05958800f, 0.01343469f, 0.04104482f, -0.03796725f, -0.02402063f, -0.05009168f, -0.02123005f, -0.05479141f, 
    -0.01112664f, 0.01802721f, -0.00470679f, 0.01648335f, 0.00227301f, -0.04888347f, -0.04113107f, -0.05211081f, 
    -0.02897292f, 0.03550556f, -0.00678844f, 0.02899037f, -0.01799542f, 0.01395144f, 0.00301520f, 0.04385558f, 
    0.01327015f, 0.02110113f, -0.04087819f, -0.01971204f, -0.05800107f, -0.00444600f, -0.05242145f, 0.02515333f, 
    0.02908129f, 0.03813886f, -0.00415751f, 0.00156654f, -0.05755245f, -0.04508036f, 0.00604644f, -0.01500469f, 
    -0.08831120f, 0.16058324f, 0.02417680f, -0.03874637f, -0.22216684f, 0.01371117f, -0.02986812f, -0.11694036f, 
    -0.04198302f, 0.02263302f, 0.02821647f, -0.17153864f, -0.08532877f, 0.01242789f, -0.02878894f, -0.07474261f, 
    0.00870863f, 0.01467988f, -0.02322595f, 0.06500082f, 0.52252102f, -0.00445855f, -0.05715240f, 0.06404852f, 
    -0.46105283f, 0.11346536f, -0.29219449f, 0.11135110f, 0.06970814f, -0.05138228f, -0.01718427f, 0.02188532f, 
    -0.12645279f, -0.00315345f, 0.00462088f, -0.07710538f, 0.08476394f, -0.09449654f, -0.03527059f, -0.10972021f, 
    0.24263997f, 0.09713739f, 0.08741251f, 0.00866888f, 0.20606713f, -0.06052065f, 0.12006400f, 0.00256148f, 
    -0.07180684f, -0.08880773f, 0.03093960f, -0.07282525f, -0.06134594f, 0.19210678f, 0.15237965f, -0.00982838f, 
    -0.00180761f, -0.00002127f, 0.11723806f, -0.14140838f, -0.18599932f, 0.44805813f, -0.27885312f, 0.06443681f, 
    0.07923397f, 0.02117322f, 0.17857338f, -0.00341827f, 0.20905389f, 0.18467860f, 0.17722520f, 0.11466319f, 
    0.12979944f, -0.05065750f, 0.09816538f, 0.05377645f, -0.08659957f, 0.29938030f, 0.15256441f, 0.08815883f, 
    -0.48193997f, 0.25478414f, 0.17270218f, 0.29935822f, -0.04374009f, 0.01008125f, 0.11705925f, 0.18703818f, 
    -0.02088406f, 0.02154016f, -0.11212339f, -0.13261937f, -0.02416930f, -0.14524812f, -0.06348840f, -0.02952851f, 
    0.06545825f, -0.18432863f, 0.10797910f, -0.03507010f, -0.31079242f, -0.04893735f, 0.14168884f, -0.06358511f, 
    0.31466532f, 0.04482771f, -0.04293528f, -0.09226549f, 0.06579664f, -0.11764389f, -0.06804901f, 0.02771724f, 
    -0.03783563f, 0.11718514f, 0.15282018f, -0.07724446f, -0.05329252f, -0.08072477f, 0.08033974f, 0.04425817f, 
    -0.01464474f, -0.02932374f, 0.02647780f, -0.19101922f, 0.17355755f, 0.07774583f, 0.17128116f, 0.05781266f, 
    -0.06433025f, 0.00772208f, -0.05951170f, -0.03040985f, 0.17529042f, -0.07039510f, 0.08912735f, -0.14298676f, 
    0.08010728f, -0.01929902f, 0.20927346f, 0.03795568f, -0.10939128f, -0.00973439f, 0.22031944f, 0.36385092f, 
    -0.05964259f, 0.22024772f, 0.10364314f, 0.10834317f, -0.10043506f, -0.09432482f, -0.05098227f, 0.04145153f, 
    -0.04777678f, 0.09340676f, -0.04058141f, -0.03781933f, 0.09413710f, -0.00735851f, 0.12285470f, 0.12699057f, 
    -0.25447446f, -0.07569662f, -0.21366213f, 0.04781745f, 0.36340216f, -0.02033933f, -0.08364543f, 0.27756003f, 
    -0.06083057f, 0.19152741f, 0.06883814f, -0.07554898f, 0.16935050f, 0.07427006f, 0.02875168f, 0.10588820f, 
    0.14212725f, 0.03024889f, 0.06507491f, -0.09535897f, 0.29749420f, -0.51105481f, 0.05240779f, -0.07733687f, 
    0.24633530f, 0.07397442f, -0.08646411f, -0.02705788f, 0.00565203f, 0.04841833f, -0.00498397f, 0.01121159f, 
    0.04940178f, 0.02939526f, -0.03666183f, -0.03737922f, -0.02876786f, 0.07818338f, 0.07192965f, -0.07337304f, 
    -0.74813324f, -0.18633661f, -0.24818639f, 0.05649810f, 0.39514831f, -0.02176491f, 0.00670997f, 0.15812580f, 
    -0.04187529f, 0.01387674f, 0.09893490f, 0.12170489f, 0.11208893f, 0.09203693f, 0.02062960f, -0.00836636f, 
    -0.17062211f, 0.04887829f, 0.12123390f, 0.24245790f, 0.45279238f, 0.02227608f, -0.12193045f, 0.08872497f, 
    -0.37375021f, -0.08830832f, -0.16617633f, 0.26468760f, -0.23027383f, 0.09757797f, -0.01734238f, -0.10244994f, 
    0.04718424f, -0.18552393f, -0.15209773f, 0.10662772f, -0.01464689f, 0.07383591f, 0.01296212f, 0.06009131f, 
    -0.03607910f, 0.12023557f, 0.22576396f, 0.10237790f, -0.00246625f, 0.07109174f, 0.15496352f, 0.10838382f, 
    0.07345922f, -0.03702414f, -0.07302508f, 0.21437979f, 0.07387809f, 0.14661179f, -0.09753472f, -0.15120696f, 
    0.02832364f, -0.06146654f, 0.08098115f, -0.08494493f, 0.03561063f, 0.10708665f, -0.26462033f, 0.09131196f, 
    -0.30124539f, 0.04540413f, -0.09109994f, 0.08247790f, 0.01365298f, 0.16439708f, -0.05196017f, -0.05215927f, 
    0.09854393f, 0.13951689f, 0.04309866f, 0.01820771f, -0.00344353f, 0.15493903f, 0.00342314f, 0.04481095f, 
    -0.39287123f, 0.51576126f, -0.16762878f, 0.08852758f, 0.36727947f, -0.12700894f, -0.08184968f, -0.06557409f, 
    -0.01218881f, -0.09605429f, 0.14321619f, -0.09936348f, 0.02722663f, 0.01242366f, 0.09384387f, -0.01161839f, 
    0.09464210f, -0.19328231f, -0.10537159f, 0.01999727f, 0.57976043f, -0.05206634f, -0.04210025f, 0.15567634f, 
    -0.18626702f, -0.14941913f, 0.03401096f, 0.03273593f, 0.24861978f, -0.05912306f, -0.04466331f, -0.03511227f, 
    0.00731583f, 0.09981598f, 0.08081174f, 0.15551332f, -0.00009814f, 0.04152787f, 0.06523933f, 0.03528937f, 
    -0.11824204f, 0.06564297f, -0.06096484f, -0.06821096f, 0.24950995f, 0.11781060f, -0.09983153f, 0.08470758f, 
    0.01026597f, 0.12940806f, -0.16657479f, 0.10876331f, 0.10674388f, -0.09387413f, -0.04653274f, 0.09029040f, 
    -0.12130957f, -0.02447920f, 0.00680684f, -0.14665350f, -0.21781673f, 0.02032715f, -0.01449286f, 0.02500252f, 
    -0.27195147f, 0.01858757f, 0.15484194f, -0.02931247f, -0.09553872f, 0.00845422f, -0.04795123f, 0.02073611f, 
    0.22257864f, 0.00647186f, -0.05727078f, 0.10848019f, -0.14989749f, 0.07767633f, 0.02108183f, -0.02062359f, 
    0.10663095f, -0.13914113f, -0.38261288f, -0.06958584f, 0.02913332f, 0.05513928f, -0.09848090f, 0.02978363f, 
    0.09141000f, -0.12422392f, -0.04752060f, -0.20483476f, 0.00964231f, -0.07872602f, -0.04954190f, -0.06916493f, 
    0.20244816f, 0.03077997f, -0.04870904f, 0.17918675f, 0.10123705f, -0.02325459f, 0.15215904f, -0.23812939f, 
    0.16603693f, 0.03313741f, 0.07292191f, -0.04433732f, 0.10564722f, 0.10639568f, -0.00944405f, -0.01140544f, 
    0.11115012f, 0.14230618f, -0.20707618f, -0.04027789f, 0.02565341f, -0.03776835f, -0.12311909f, -0.07623812f, 
    0.62830693f, 0.24650031f, 0.23998195f, -0.06505734f, 0.07838294f, -0.02066951f, -0.09542747f, 0.15875238f, 
    -0.04583539f, -0.07219042f, -0.06622411f, 0.08341984f, -0.01721927f, 0.13158749f, -0.00151566f, 0.00809915f, 
    0.05084093f, 0.08455338f, -0.12357993f, 0.11188234f, 0.54966545f, -0.32539940f, 0.12149972f, -0.15499434f, 
    0.22397155f, 0.00054625f, 0.00741847f, 0.05952557f, 0.07388261f, 0.12241731f, 0.04838447f, -0.11057078f, 
    0.01625914f, -0.04717501f, -0.12915541f, 0.02647748f, 0.06763907f, 0.01491239f, -0.04966959f, -0.00380921f, 
    0.40235293f, 0.15535566f, 0.09573460f, 0.14333853f, 0.21957439f, 0.02597273f, 0.03208968f, -0.02738408f, 
    0.05899239f, 0.01558519f, -0.02666450f, -0.09117462f, 0.08493737f, 0.07004467f, 0.06150113f, 0.08963034f, 
    -0.01006321f, 0.00201787f, -0.02430235f, -0.13570978f, 0.39750046f, -0.13161907f, -0.52093124f, -0.24865264f, 
    -0.24178481f, -0.05610939f, 0.00943010f, 0.05244378f, 0.11687527f, -0.04048300f, -0.11612289f, -0.07180247f, 
    0.08819804f, 0.25865346f, -0.09995888f, -0.02567229f, -0.02472235f, -0.01910075f, -0.09784809f, 0.05608618f, 
    -0.17674950f, 0.42198229f, 0.12748075f, -0.05749945f, -0.06576001f, -0.00759769f, -0.05576323f, -0.07906586f, 
    -0.01869248f, -0.08662795f, 0.15130557f, 0.01318966f, 0.07780582f, -0.06120937f, -0.11065437f, 0.09395363f, 
    -0.11294647f, -0.03841554f, -0.10562656f, 0.02702802f, 0.70462793f, -0.05713041f, -0.08044258f, 0.25147930f, 
    -0.14310732f, -0.05165442f, -0.02789377f, -0.05402185f, -0.00636100f, -0.06417272f, 0.03265629f, 0.12446005f, 
    -0.06734587f, -0.03844107f, -0.06487816f, 0.01834858f, -0.00836339f, 0.11279356f, 0.03845705f, 0.04833154f, 
    0.45203087f, 0.15160798f, 0.04382746f, 0.04049738f, -0.00981989f, 0.19192269f, 0.11640847f, 0.00910684f, 
    -0.14704700f, 0.09535857f, 0.00347906f, -0.08481393f, -0.06730042f, -0.00656150f, -0.03608009f, -0.02243535f, 
    0.03825184f, 0.03150256f, -0.11389974f, 0.06997214f, 0.11038826f, 0.34801173f, 0.15408418f, 0.00509548f, 
    0.11914168f, 0.12882377f, 0.04699940f, 0.17074388f, 0.20799541f, 0.07103582f, -0.08496763f, -0.00482457f, 
    -0.01860261f, 0.00270739f, 0.02379708f, -0.05498667f, -0.11240825f, 0.10064903f, -0.06499840f, 0.17337666f, 
    0.24586980f, -0.02557719f, -0.05480287f, -0.09660996f, -0.00266789f, -0.09328431f, -0.08567797f, 0.23128997f, 
    -0.01272671f, 0.00125333f, 0.00420982f, -0.16736846f, -0.01107311f, -0.04586388f, 0.08233528f, 0.02481922f, 
    -0.06132045f, 0.15390192f, 0.02436045f, 0.06694029f, 0.23218784f, -0.09696902f, 0.18473606f, -0.23779185f, 
    0.18868342f, 0.02577630f, -0.08335094f, 0.02569352f, 0.02074242f, 0.07356212f, -0.08858821f, 0.03188738f, 
    -0.12619974f, 0.05311776f, -0.05743776f, -0.12861192f, 0.02077603f, -0.02598086f, -0.07575399f, -0.02776470f, 
    -0.08442182f, -0.03426304f, 0.15178613f, 0.06639168f, -0.04651221f, -0.09632072f, -0.01514163f, -0.05649075f, 
    0.22933225f, 0.17685021f, 0.04283075f, 0.00935230f, 0.13647527f, -0.08748680f, 0.03358164f, 0.06723374f, 
    0.04377177f, -0.00843141f, 0.11569010f, -0.03716996f, -0.11513993f, -0.02426987f, 0.13016041f, -0.02162478f, 
    -0.20856813f, 0.02087848f, -0.07004977f, 0.00786101f, -0.15329322f, -0.13588002f, -0.06317678f, 0.04924791f, 
    -0.11250766f, -0.06823193f, -0.04631336f, -0.09218084f, -0.02985169f, 0.04789891f, -0.11724212f, -0.00313997f, 
    -0.02094891f, 0.03474261f, -0.00587936f, -0.02710297f, -0.05187226f, 0.04591947f, 0.00524618f, 0.01727336f, 
    0.03029184f, -0.06116521f, -0.04120286f, -0.02396488f, 0.00883032f, -0.05313777f, -0.04964182f, -0.00108045f, 
    0.04440412f, -0.04439790f, 0.01419290f, -0.02552719f, 0.04054197f, -0.00244545f, 0.03770375f, -0.02814504f, 
    -0.02982297f, 0.00567031f, -0.02495142f, 0.02507806f, -0.03275567f, -0.00606468f, 0.00209359f, -0.03144856f, 
    -0.05782668f, -0.03314441f, 0.00845053f, 0.01279378f, -0.04656481f, -0.00867369f, 0.00843041f, 0.00685441f, 
    -0.02913636f, -0.06063268f, -0.05834255f, -0.05586801f, -0.00593115f, -0.05705818f, -0.05294118f, -0.05019245f, 
    0.01202277f, -0.00002428f, 0.02580535f, -0.00351363f, 0.02723768f, 0.00246019f, -0.05501401f, -0.05447568f, 
    0.04135793f, 0.00363326f, 0.00647952f, 0.04735920f, 0.05553075f, 0.04768230f, 0.01244565f, 0.02180509f, 
    -0.01866576f, 0.00019990f, -0.03300895f, 0.04165911f, 0.00219417f, -0.02580211f, -0.00921813f, -0.05868125f, 
    0.04336585f, -0.03836251f, 0.05107349f, 0.03996920f, -0.04853143f, -0.03042122f, 0.03408857f, 0.01597634f, 
    -0.02060037f, 0.01016182f, 0.00145722f, -0.03079146f, -0.00533450f, 0.02344117f, -0.03129841f, -0.01010166f, 
    0.01434313f, 0.00086253f, 0.03233676f, 0.02609895f, 0.02185855f, -0.00064414f, -0.02266644f, -0.04650755f, 
    -0.03212054f, 0.03258383f, 0.00568319f, -0.06220785f, 0.03926344f, 0.02465518f, -0.02305847f, -0.05912741f, 
    -0.00974092f, 0.02686320f, 0.04309976f, -0.01881843f, -0.05310434f, -0.03125980f, 0.00183729f, 0.02127629f, 
    0.01576697f, -0.03313913f, -0.04939475f, 0.02953802f, 0.04218385f, 0.02381384f, -0.03718541f, 0.02281384f, 
    -0.04755282f, 0.02065603f, 0.01281443f, 0.02885889f, 0.00551348f, -0.02578882f, -0.00865339f, -0.01838710f, 
    -0.05581251f, -0.01387786f, -0.05501902f, -0.05529126f, -0.04782845f, 0.01908778f, -0.01320308f, -0.03326873f, 
    -0.04114864f, 0.04121318f, 0.01087175f, 0.01908644f, -0.03038231f, 0.01699805f, -0.03460211f, -0.01904909f, 
    -0.00931037f, -0.04258912f, -0.05098531f, -0.05160755f, -0.00467578f, -0.01387095f, -0.01245679f, -0.05352283f, 
    0.01492325f, 0.01963431f, 0.03521077f, -0.03535819f, -0.03217471f, -0.02143476f, 0.01482515f, -0.00310362f, 
    0.00174941f, 0.01006568f, 0.02502157f, -0.05151077f, 0.02961286f, -0.00227168f, -0.01603358f, 0.01953856f, 
    0.03708672f, -0.04801784f, -0.01528294f, -0.03328852f, -0.05347110f, -0.02687082f, 0.01486426f, 0.03321590f, 
    0.01262185f, -0.03880894f, 0.03308390f, -0.01713933f, -0.05793535f, -0.05236802f, -0.02018576f, -0.04415882f, 
    -0.00514332f, 0.00279499f, -0.01672686f, -0.05851699f, -0.05903146f, -0.03253787f, 0.01405211f, 0.01885184f, 
    -0.02701312f, -0.04671954f, -0.04019969f, 0.03699967f, -0.03949681f, 0.00008235f, -0.05714785f, 0.02330604f, 
    0.01594147f, -0.02613964f, -0.01005324f, -0.06147797f, -0.00863487f, -0.03646624f, -0.00927379f, 0.03119068f, 
    0.02897859f, -0.03434739f, -0.00452412f, -0.02959375f, 0.00482422f, -0.01343601f, -0.05305043f, 0.03964575f, 
    -0.00221648f, -0.03845119f, 0.04306329f, 0.04130790f, 0.04119205f, 0.01191761f, 0.04081752f, -0.02218059f, 
    -0.02265887f, -0.02531955f, -0.05972977f, -0.01145583f, -0.05933879f, 0.00749378f, -0.03521222f, -0.03726754f, 
    0.01472112f, -0.00010651f, 0.03964911f, -0.03370097f, -0.02415327f, 0.00732110f, -0.01943006f, 0.04605566f, 
    -0.00286961f, 0.00282903f, 0.03618383f, -0.05490387f, -0.03895840f, 0.03045219f, 0.01600210f, -0.03584449f, 
    0.02735881f, 0.03678007f, -0.04602987f, 0.01170054f, -0.05931520f, -0.04751093f, 0.02687562f, -0.04931552f, 
    -0.04544796f, -0.02629141f, 0.02853986f, -0.03472725f, -0.00981846f, -0.03157092f, -0.02480248f, -0.05193212f, 
    -0.04547078f, -0.04940189f, 0.01820418f, 0.03316985f, -0.03171163f, -0.04085989f, -0.01184246f, -0.03008731f, 
    -0.03929643f, 0.00462763f, 0.03340569f, -0.02028497f, 0.00172567f, 0.04727351f, -0.02320906f, -0.03825533f, 
    -0.01591230f, -0.02211354f, 0.03145993f, 0.00826462f, 0.00702731f, -0.05105474f, -0.05500920f, -0.03580205f, 
    -0.03489377f, -0.02533779f, 0.02442391f, -0.04357539f, -0.00427569f, 0.04069825f, 0.04648956f, -0.01488335f, 
    -0.02711871f, -0.00166579f, 0.00905580f, 0.03360653f, -0.01389202f, 0.02482534f, 0.01036728f, -0.06259707f, 
    -0.00175740f, 0.04454526f, -0.05901710f, -0.05305069f, -0.01123381f, -0.03862090f, -0.01951103f, -0.06273413f, 
    -0.01550106f, 0.02568808f, -0.02346325f, -0.05745639f, -0.05065358f, -0.04837952f, -0.00754442f, -0.05581139f, 
    0.01466995f, -0.14957419f, 0.26670739f, 0.29185954f, 0.03190463f, -0.19292401f, -0.01022354f, -0.01267837f, 
    0.00565639f, 0.07944288f, 0.00464694f, -0.10630758f, 0.09769521f, 0.16234595f, 0.03269295f, 0.12673624f, 
    0.01241927f, -0.15334609f, -0.03635333f, -0.03372785f, -0.28320971f, 0.18447693f, 0.56979501f, 0.15979259f, 
    -0.15451369f, 0.06889359f, -0.00123276f, 0.00587260f, 0.02767429f, -0.00872393f, 0.11968831f, 0.04649225f, 
    -0.06261026f, 0.06777941f, -0.18434776f, -0.10107715f, 0.01976255f, -0.03668588f, 0.05590739f, -0.10035682f, 
    -0.05153195f, 0.05943615f, 0.08835768f, 0.25591078f, 0.16053647f, 0.15339640f, 0.09689969f, -0.12175164f, 
    0.06697163f, 0.09940684f, -0.16122028f, 0.01960480f, -0.14217591f, 0.14670923f, 0.26736507f, -0.15874350f, 
    0.09148523f, 0.15221307f, -0.11002823f, -0.07586490f, 0.16877820f, 0.14053273f, 0.45933339f, 0.28117558f, 
    0.12716073f, 0.20680664f, 0.15995017f, -0.05793204f, 0.01592598f, 0.23028857f, 0.02105462f, 0.07256874f, 
    0.09132529f, -0.03773452f, 0.04494104f, -0.08218939f, -0.03982105f, 0.01977574f, -0.04963615f, 0.10652034f, 
    -0.01563556f, -0.23108332f, -0.04094914f, 0.22115108f, 0.17019635f, -0.22323585f, -0.06514641f, 0.03464350f, 
    0.05788831f, -0.00616964f, -0.06951549f, -0.21192996f, 0.04528884f, -0.07026204f, 0.12809965f, 0.02119804f, 
    0.20270404f, -0.01563494f, 0.03645530f, 0.15104944f, -0.53661931f, 0.46512786f, -0.12892796f, -0.04794390f, 
    -0.03372135f, 0.01623798f, 0.00153688f, 0.03082639f, 0.10751388f, -0.01258204f, -0.03044067f, 0.06375036f, 
    0.01239094f, 0.05194683f, 0.07049341f, -0.05770867f, 0.11863054f, -0.05748592f, 0.06210157f, -0.03630371f, 
    -0.76849675f, 0.11157978f, 0.33964601f, 0.12313077f, 0.03464926f, -0.03596029f, 0.13663359f, 0.09461682f, 
    0.12562399f, 0.14602855f, -0.01855487f, -0.02350097f, -0.01651735f, 0.04690857f, -0.08755639f, -0.05936446f, 
    0.06368648f, -0.05779555f, 0.04152583f, 0.10098653f, 0.05875653f, -0.05219892f, 0.19137149f, 0.18825209f, 
    0.52184927f, -0.12917961f, -0.10824114f, -0.20159961f, -0.01205978f, 0.18899992f, 0.09095916f, 0.06259726f, 
    0.20901826f, -0.03976709f, 0.14237124f, -0.08555684f, -0.07923202f, -0.07158504f, 0.23232096f, -0.02220338f, 
    -0.15156901f, 0.57216126f, 0.18278635f, -0.17903067f, -0.19448505f, 0.13844314f, 0.06118885f, 0.14322653f, 
    -0.09327178f, -0.13580330f, 0.14658734f, -0.13419086f, -0.00301473f, -0.12237491f, -0.04478316f, 0.16063862f, 
    0.11279439f, 0.03235647f, 0.19186102f, 0.07923450f, -0.51985645f, -0.30438790f, -0.11998153f, -0.01236803f, 
    -0.12710628f, 0.13812235f, -0.01003583f, 0.01357988f, 0.18414006f, -0.19661158f, -0.01138702f, 0.14214462f, 
    -0.08885941f, 0.03858533f, -0.00586996f, -0.01697402f, 0.07570490f, 0.13953075f, -0.14078619f, -0.02770695f, 
    -0.33045855f, 0.25604361f, -0.12736012f, -0.23771894f, -0.10026941f, 0.18222298f, 0.07667124f, 0.10111598f, 
    0.02055266f, 0.05629402f, 0.03250199f, 0.15647608f, -0.05151876f, 0.14418437f, 0.03897844f, 0.06846562f, 
    0.08750326f, 0.11182587f, 0.01739088f, -0.19840539f, 0.42793953f, -0.16633455f, 0.11069403f, -0.18621366f, 
    0.04429258f, -0.21842504f, -0.00980710f, -0.22186856f, -0.04492557f, -0.00117433f, 0.01837403f, -0.07960236f, 
    -0.00653700f, 0.01535837f, 0.02177418f, -0.02266411f, -0.03880786f, 0.06164281f, 0.03758378f, 0.01294326f, 
    0.42537493f, -0.18978679f, 0.13991006f, 0.18013075f, 0.21702942f, -0.02955656f, -0.26799741f, 0.07180265f, 
    -0.08447719f, -0.17271249f, -0.00398957f, 0.01322450f, -0.00046429f, 0.01191606f, -0.04791548f, 0.11908826f, 
    0.00903392f, 0.14076501f, -0.01648363f, 0.17683277f, 0.28478640f, 0.11008900f, 0.11702540f, -0.08499180f, 
    0.46260095f, -0.14295715f, -0.09552741f, -0.00516604f, -0.03559516f, -0.02929599f, -0.03283427f, 0.10323615f, 
    0.05052086f, -0.01484104f, 0.02266485f, -0.02998202f, -0.01854042f, -0.06198215f, 0.05729051f, -0.00895314f, 
    0.27265522f, 0.10100998f, -0.10467356f, 0.15464553f, -0.39507988f, -0.12121702f, 0.06738046f, -0.10627685f, 
    0.03694720f, -0.09084859f, 0.03994746f, 0.03500118f, -0.10295314f, 0.02781306f, -0.11100993f, 0.05825477f, 
    -0.07864969f, -0.06565262f, 0.00770940f, -0.03881215f, -0.13728549f, -0.00186802f, 0.40601835f, 0.10165493f, 
    0.19637966f, -0.00006010f, -0.09989450f, -0.01846761f, -0.00836738f, -0.03654550f, 0.02734842f, -0.07955686f, 
    -0.13698298f, 0.08562889f, 0.07885424f, 0.06138955f, -0.05625306f, 0.07911971f, 0.17295381f, -0.04992771f, 
    0.04122021f, -0.02605799f, -0.08071953f, -0.03760323f, 0.02027561f, 0.04523161f, 0.02928202f, -0.05706022f, 
    -0.05922469f, -0.04202963f, 0.04746678f, -0.01382680f, 0.04457206f, 0.00769188f, 0.00719070f, 0.02023138f, 
    0.02731342f, -0.05135112f, 0.01462309f, -0.04821682f, -0.00918039f, -0.00772428f, -0.00558587f, -0.04852204f, 
    -0.04012907f, 0.04060666f, -0.06339754f, 0.04213908f, 0.02922777f, -0.04889147f, 0.03729143f, 0.03046161f, 
    0.01594328f, -0.01615383f, -0.04778729f, 0.01321524f, 0.04226684f, -0.03629615f, -0.05838719f, -0.03355815f, 
    -0.06924611f, 0.03414195f, -0.06743182f, -0.04926394f, 0.02628995f, -0.00586677f, -0.04872084f, 0.01366998f, 
    0.02970362f, -0.04855366f, 0.00540225f, 0.02398443f, 0.01955449f, -0.00410304f, 0.04172986f, -0.03273007f, 
    -0.02462672f, 0.01779178f, -0.01377278f, 0.02654468f, 0.03530582f, -0.02506730f, -0.05217626f, 0.00453183f, 
    -0.07237023f, -0.00542580f, -0.04211698f, -0.06959204f, 0.00224194f, -0.04497320f, -0.02837000f, -0.04796815f, 
    -0.00254842f, -0.05514005f, 0.02579059f, -0.00646151f, -0.00678796f, -0.03319237f, 0.00196577f, -0.02011195f, 
    -0.01443098f, -0.03285966f, -0.04850354f, 0.05473565f, -0.06520773f, 0.04333237f, 0.02755712f, 0.05219005f, 
    0.02162024f, -0.01227435f, 0.01012226f, -0.00295900f, 0.03202011f, -0.02852236f, -0.06376649f, -0.03846129f, 
    -0.01754051f, 0.02081171f, 0.04485594f, -0.03499733f, -0.04986916f, -0.01679922f, -0.03968843f, 0.01239045f, 
    -0.02274307f, -0.00146696f, 0.03198344f, -0.02380832f, -0.02488548f, -0.06142655f, -0.03399278f, -0.03375123f, 
    0.00538588f, 0.02573142f, 0.02426905f, 0.01517757f, 0.03265660f, -0.00153048f, -0.04046968f, 0.03140976f, 
    0.02100567f, -0.00295084f, -0.07195200f, -0.00857962f, 0.02648478f, -0.04018563f, -0.06076585f, -0.03380296f, 
    0.03684173f, -0.03817535f, 0.02714090f, -0.02796762f, -0.02127155f, 0.04172702f, 0.03489392f, -0.01026707f, 
    -0.04002375f, -0.06371646f, -0.05749082f, -0.00704397f, -0.00282086f, 0.03257297f, -0.01459245f, -0.01435660f, 
    0.04629688f, 0.01909945f, -0.05919669f, -0.00389987f, -0.03424658f, -0.04887183f, -0.00354197f, -0.02895051f, 
    -0.04078142f, 0.01373858f, -0.00870680f, 0.01893918f, 0.03068271f, 0.01367326f, 0.04652523f, 0.01806328f, 
    0.01431438f, 0.05413033f, 0.04444873f, -0.01633308f, 0.00237578f, -0.05436405f, -0.00134965f, -0.02952085f, 
    -0.00322624f, 0.04010472f, -0.03365013f, -0.04129265f, 0.01519592f, -0.01360429f, 0.03801952f, 0.01728869f, 
    0.00245419f, -0.02001770f, 0.01716004f, -0.00947322f, 0.02928501f, 0.00950949f, -0.05196651f, -0.01899378f, 
    0.02486716f, -0.04486485f, 0.00405872f, 0.01403796f, -0.01548818f, 0.04034715f, 0.01403066f, 0.03108421f, 
    0.01282544f, 0.03507131f, 0.00832342f, -0.00475205f, -0.00465065f, -0.02089872f, 0.00805361f, 0.02751684f, 
    -0.06920002f, 0.05683720f, -0.03926303f, -0.00762348f, -0.00267839f, -0.03903706f, 0.02022751f, -0.06314038f, 
    -0.03895902f, 0.02947713f, -0.04128623f, 0.00390228f, -0.02592534f, -0.03745507f, 0.04473067f, -0.03277230f, 
    0.00676644f, -0.02517000f, -0.02484643f, -0.06550701f, -0.01701832f, -0.00495172f, 0.00369965f, -0.06370587f, 
    -0.00265289f, -0.02732300f, 0.00007055f, 0.04361761f, -0.05198659f, 0.03065014f, -0.05844832f, -0.00309898f, 
    0.00793931f, -0.00871376f, 0.03712094f, 0.02944472f, -0.01341381f, -0.04966110f, -0.03434656f, 0.04110468f, 
    0.04945271f, -0.05153784f, 0.05696226f, -0.01428447f, -0.05567969f, -0.04650091f, 0.01868460f, 0.01388258f, 
    -0.04578060f, 0.03936537f, 0.00331916f, -0.05368064f, -0.01818321f, 0.02723542f, -0.02100308f, -0.03953074f, 
    0.02133544f, 0.04681245f, 0.00133217f, 0.02203906f, 0.01343937f, 0.01108443f, -0.02315869f, -0.03689389f, 
    -0.00360944f, 0.02044892f, 0.04379717f, -0.04749081f, -0.04962909f, -0.03922611f, 0.04728514f, -0.06548112f, 
    -0.02119774f, -0.01912151f, -0.02651545f, -0.00869458f, 0.02361202f, -0.03211735f, 0.03668750f, 0.02424894f, 
    -0.04112152f, 0.04019849f, -0.00035768f, -0.00107439f, -0.00381992f, 0.00579808f, -0.06175813f, -0.00332255f, 
    0.04308598f, 0.01141317f, -0.05148935f, 0.04080227f, -0.05265429f, -0.01510745f, 0.03726122f, -0.03980923f, 
    0.00163140f, -0.05964283f, -0.03980728f, 0.00253001f, 0.03244188f, -0.04358258f, 0.01950289f, -0.01290028f, 
    -0.02959619f, 0.02926382f, 0.03081105f, 0.04233969f, 0.03023565f, -0.01342402f, 0.02239187f, 0.03339830f, 
    -0.01438605f, -0.04353705f, -0.01901574f, 0.04028706f, -0.04213980f, 0.02031230f, -0.01502536f, -0.01090018f, 
    -0.19804038f, -0.13942018f, 0.04354501f, 0.19953337f, 0.12553698f, -0.09206681f, -0.03238022f, -0.20722787f, 
    0.03079486f, 0.00205725f, 0.02770271f, -0.07403592f, -0.10719297f, 0.15603550f, 0.01949096f, -0.10049910f, 
    0.04652848f, 0.13655788f, 0.02609617f, 0.00705257f, 0.52568078f, -0.22721876f, 0.05321125f, 0.22959627f, 
    -0.29161218f, 0.01430176f, -0.24263282f, 0.11021481f, -0.14899932f, 0.19128618f, -0.03264554f, 0.08598193f, 
    0.00293231f, -0.06226268f, 0.09440137f, -0.07141875f, 0.12531573f, 0.02427188f, -0.09850843f, -0.07721224f, 
    0.15389520f, -0.18703899f, -0.05798553f, -0.03050852f, 0.17536412f, -0.15313682f, -0.01874067f, 0.06740545f, 
    -0.04118600f, -0.20790157f, 0.01850916f, 0.07140590f, 0.09866901f, 0.16507487f, 0.15511057f, 0.09723161f, 
    -0.10561170f, 0.04255782f, 0.11514828f, -0.16082701f, 0.02517951f, 0.35601777f, -0.33658898f, 0.08039089f, 
    0.38712001f, 0.05729419f, 0.02012067f, -0.06563692f, 0.14794843f, -0.10827407f, 0.10989049f, 0.09387571f, 
    0.06329808f, -0.00902966f, 0.00163514f, 0.08908504f, -0.02715426f, 0.09358755f, 0.12581775f, 0.03813507f, 
    -0.06733241f, 0.37443271f, -0.02038299f, 0.23120037f, -0.05841806f, -0.02879995f, 0.05556942f, -0.06419516f, 
    0.04113268f, 0.18350340f, 0.05259950f, -0.09335273f, 0.09684038f, 0.02187456f, -0.03941293f, 0.01312188f, 
    0.00519632f, -0.17745814f, 0.12333417f, 0.02083447f, -0.27164245f, 0.05285748f, 0.20243958f, -0.01740551f, 
    0.10682790f, 0.10452823f, 0.19633378f, 0.04341066f, -0.04956922f, -0.29271746f, -0.06297414f, 0.05291120f, 
    -0.05110827f, -0.02408674f, 0.00301195f, -0.17409000f, -0.12502129f, 0.05257824f, -0.05120060f, -0.05334097f, 
    0.04997773f, 0.18705131f, 0.15437996f, -0.23486753f, 0.01157484f, 0.04647379f, 0.13850524f, 0.17295998f, 
    0.00493515f, -0.25140586f, -0.13662779f, 0.10653042f, 0.13507658f, -0.14271258f, -0.03905312f, -0.06278162f, 
    -0.08583215f, 0.08241265f, 0.06054665f, 0.13079774f, -0.00237458f, 0.00560112f, 0.51382911f, 0.46553719f, 
    -0.33801714f, 0.02886608f, -0.08479465f, 0.17181072f, -0.09351719f, -0.09064324f, 0.03744005f, 0.16864778f, 
    -0.18066208f, 0.03079593f, 0.05455828f, -0.02608537f, -0.00296045f, 0.05121644f, 0.04348039f, 0.05116539f, 
    -0.03730163f, -0.37679330f, 0.09743600f, 0.03692976f, 0.09115080f, 0.03897798f, 0.17306063f, 0.08570012f, 
    -0.06196646f, -0.04962053f, -0.03815499f, -0.06758502f, 0.13334513f, 0.19898844f, 0.04868529f, 0.00795127f, 
    0.05442719f, 0.01750856f, -0.04899875f, -0.03382629f, -0.53817099f, 0.20603222f, 0.00651427f, -0.25993735f, 
    0.30013472f, 0.23519628f, 0.08084313f, 0.10065188f, -0.01578937f, 0.02906180f, 0.09084762f, 0.01094525f, 
    -0.00440270f, -0.01313049f, 0.00924955f, -0.11122210f, -0.12159435f, -0.05876791f, 0.10536958f, -0.14337018f, 
    -0.68172848f, -0.02140166f, 0.14276741f, -0.00030246f, 0.39362907f, 0.10556204f, 0.13053855f, 0.06548984f, 
    -0.03668768f, -0.10494235f, -0.00038472f, 0.02565798f, 0.13890062f, 0.03325845f, -0.10000703f, 0.03203185f, 
    -0.04420131f, -0.06307700f, 0.13693754f, 0.06163284f, -0.21537755f, 0.62054199f, -0.05454345f, -0.07568093f, 
    0.00643956f, 0.00088741f, 0.05932894f, -0.09592418f, -0.19846234f, 0.08393448f, -0.01284261f, -0.00463015f, 
    0.14447732f, -0.12980230f, -0.09427719f, 0.03571284f, 0.10296778f, -0.02040287f, -0.02156004f, 0.02654749f, 
    0.06774651f, 0.40253076f, 0.16032805f, 0.06371138f, -0.22467802f, -0.01363451f, -0.01421319f, 0.02320114f, 
    0.06867333f, 0.13051271f, -0.01458189f, 0.21683185f, 0.02160458f, -0.11226300f, 0.07169499f, -0.05343486f, 
    0.02551686f, -0.08743462f, 0.09330641f, -0.08556530f, 0.08953109f, 0.42018706f, -0.32259825f, 0.36689201f, 
    -0.25490868f, 0.13362569f, 0.11521512f, 0.04002134f, 0.04279506f, 0.02601574f, 0.02474828f, 0.00069608f, 
    0.06457681f, -0.06090146f, -0.02609659f, 0.16916616f, 0.01330382f, 0.06487621f, -0.02520803f, -0.00059307f, 
    -0.40064594f, 0.07994338f, -0.12640916f, 0.05045425f, 0.42924434f, 0.05193011f, -0.11413402f, 0.00145909f, 
    0.04131966f, -0.16688846f, -0.09462297f, -0.12394156f, -0.04986332f, 0.01977351f, 0.05178307f, -0.00360588f, 
    -0.15300556f, -0.06451357f, -0.16900380f, -0.05156368f, 0.19029434f, 0.01434306f, 0.00272263f, 0.30082297f, 
    -0.26573756f, -0.01196664f, -0.01176788f, 0.09162141f, 0.12111015f, -0.04431425f, 0.06728278f, -0.11889285f, 
    0.08869019f, 0.06497460f, -0.06258082f, 0.09637003f, 0.00414446f, 0.03156349f, 0.03333030f, -0.05873266f, 
    0.13088016f, 0.20703119f, -0.12579821f, -0.13867475f, 0.00092484f, 0.04260557f, 0.07018062f, -0.01222085f, 
    0.03943758f, -0.00418294f, 0.06564100f, 0.11847313f, 0.06951173f, -0.05127371f, -0.05949711f, 0.12145920f, 
    -0.02130743f, 0.12523694f, 0.01732291f, -0.04966295f, -0.02956042f, 0.40641242f, 0.01426066f, 0.21583459f, 
    0.03097122f, 0.03745183f, 0.04074177f, -0.16252717f, 0.04500942f, -0.01846512f, 0.05459305f, 0.08415415f, 
    0.03316223f, 0.14600697f, 0.09997892f, -0.02905843f, -0.06397517f, -0.13498251f, 0.07274003f, 0.09094141f, 
    0.16485134f, 0.09587935f, 0.01700872f, 0.15706758f, 0.21416906f, -0.06890897f, -0.08218401f, 0.01066277f, 
    0.01971904f, -0.11604806f, 0.12372145f, 0.01921872f, -0.03773436f, 0.01344540f, 0.15254837f, 0.04032881f, 
    0.23478091f, -0.08906438f, 0.06693298f, -0.10950156f, 0.11593469f, 0.02748859f, 0.28539664f, 0.38932896f, 
    -0.17932142f, 0.05094443f, -0.08234584f, -0.02356436f, -0.10125402f, -0.03836431f, 0.08491166f, 0.12508631f, 
    -0.00776746f, -0.03048608f, 0.08192136f, 0.04088424f, 0.03557268f, 0.00538457f, -0.03467667f, -0.03420648f, 
    0.26786259f, -0.29778358f, -0.28199798f, -0.16001323f, 0.10769515f, 0.13473225f, 0.16738100f, 0.08112625f, 
    -0.01300548f, -0.13830292f, -0.07571039f, -0.04679586f, -0.06403983f, -0.12335680f, 0.06183910f, 0.06967321f, 
    -0.02998495f, 0.17789069f, 0.08167227f, 0.12580158f, 0.05355177f, 0.47642246f, 0.22644076f, 0.22170065f, 
    0.02596203f, -0.04327798f, -0.13734819f, 0.03239767f, -0.01427704f, 0.12921943f, -0.02042568f, -0.05972214f, 
    0.01020069f, -0.00388139f, -0.06305984f, -0.00903199f, 0.01821745f, 0.00928940f, 0.08216097f, -0.06903976f, 
    -0.12643008f, 0.16020535f, 0.37852567f, 0.01197638f, 0.11271413f, -0.17312306f, -0.11806940f, 0.03236965f, 
    0.07587871f, -0.04512705f, 0.12457116f, 0.12791811f, -0.07238502f, 0.13956735f, 0.04761422f, 0.10121086f, 
    -0.03286345f, 0.04083600f, 0.05936345f, -0.16317600f, 0.08207544f, -0.38598457f, -0.32497153f, 0.17102101f, 
    0.14413425f, -0.11323038f, -0.00557377f, -0.21143973f, -0.01439604f, 0.06167984f, 0.06764121f, 0.01018967f, 
    0.13469450f, -0.07426536f, 0.21134311f, -0.02071588f, 0.06030001f, 0.07969090f, 0.00145986f, 0.04252411f, 
    0.11424259f, 0.37196845f, 0.22916546f, 0.04504847f, 0.18644260f, -0.15143360f, -0.09135087f, 0.02798686f, 
    0.11003743f, 0.07481588f, -0.22936030f, -0.13573045f, -0.01294394f, -0.06615672f, -0.06087717f, -0.18001489f, 
    -0.11814443f, 0.01709278f, 0.01026305f, -0.03719460f, 0.09035648f, 0.18010166f, 0.11834583f, 0.14135022f, 
    0.01770431f, -0.06953453f, 0.04738008f, -0.07383022f, -0.04221307f, -0.01450479f, -0.04663964f, 0.19038577f, 
    -0.07523453f, -0.06112062f, 0.00590641f, -0.00628018f, 0.16620739f, 0.04947290f, -0.06344146f, 0.12735054f, 
    0.03742179f, -0.14719978f, 0.30130249f, 0.06395314f, -0.07973013f, -0.19220068f, -0.08759604f, -0.12347540f, 
    -0.27974319f, -0.01979886f, -0.13570224f, 0.10651921f, 0.06815613f, 0.04137997f, -0.00625895f, 0.06310351f, 
    0.00358947f, 0.04626286f, -0.05578481f, -0.10705417f, -0.31118023f, 0.39651862f, -0.25390020f, 0.09285350f, 
    0.15259393f, 0.14568922f, 0.20879257f, 0.28567201f, 0.05918177f, 0.05863858f, 0.10111764f, 0.01077316f, 
    -0.05724803f, -0.04594994f, 0.17348300f, -0.02690894f, 0.11283638f, 0.09512707f, 0.08907521f, 0.17180528f, 
    -0.09398576f, -0.53484136f, -0.15675737f, -0.36137554f, -0.15681836f, 0.19465999f, 0.06024467f, -0.02667594f, 
    -0.04194432f, -0.21831410f, 0.00268552f, -0.02670424f, 0.00844177f, 0.06406160f, -0.04347066f, -0.00481309f, 
    -0.00349854f, 0.15360485f, -0.00407099f, 0.07859511f, -0.21516274f, 0.17360991f, -0.00219589f, -0.02882235f, 
    -0.00659969f, 0.14459917f, 0.11336362f, 0.00758502f, -0.01910016f, -0.00944137f, 0.11457716f, 0.13021371f, 
    0.02429432f, -0.07737304f, 0.11769357f, 0.12700048f, 0.02661115f, 0.06247089f, 0.05399194f, -0.01236576f, 
    -0.25886744f, 0.07715094f, -0.06985301f, -0.11286081f, -0.27520713f, 0.02567651f, 0.01743701f, -0.06384733f, 
    0.09788987f, -0.06360644f, 0.12012016f, 0.07359035f, 0.04771702f, 0.05558227f, 0.01006576f, 0.14626943f, 
    0.05383680f, -0.00812399f, 0.01631526f, -0.20181455f, 0.01909409f, -0.18434668f, 0.14142516f, -0.14445677f, 
    -0.12071944f, 0.08661631f, 0.09139317f, -0.12864225f, 0.10476013f, -0.11502920f, -0.04503937f, -0.07432330f, 
    -0.03831656f, -0.06666944f, -0.03285056f, 0.13298327f, 0.13668783f, -0.03464904f, 0.07166465f, 0.12716450f, 
    0.01888734f, -0.07799317f, -0.20258552f, -0.02907920f, 0.09939912f, 0.16269983f, 0.06583679f, 0.04763713f, 
    -0.04645270f, -0.02018509f, 0.09028623f, 0.04471549f, -0.00790575f, -0.13717718f, 0.05171749f, -0.11640808f, 
    -0.18332182f, 0.46529928f, 0.17339078f, 0.02558973f, 0.12701416f, 0.48599753f, 0.13917427f, -0.08615817f, 
    0.07219917f, -0.04192076f, 0.03094094f, 0.13284296f, 0.05238579f, -0.06221599f, -0.13490491f, -0.09443856f, 
    0.07730626f, 0.06140567f, -0.02317956f, 0.03591969f, 0.04404894f, -0.24138319f, 0.09219353f, 0.00668857f, 
    -0.27085611f, 0.12084846f, 0.31581619f, 0.25475180f, -0.07380839f, 0.02782971f, -0.00613607f, 0.08477022f, 
    -0.06667375f, 0.15492555f, 0.03094906f, -0.01657851f, -0.01537836f, -0.18431176f, -0.34082568f, 0.04692488f, 
    -0.25035122f, 0.07502884f, 0.33889863f, 0.07064783f, 0.32167855f, 0.19732036f, 0.14902863f, 0.12364944f, 
    0.11976933f, -0.12220037f, -0.06574793f, 0.03070748f, -0.09791045f, -0.11129156f, -0.08129693f, -0.19465905f, 
    0.00006987f, -0.04240863f, 0.06730561f, 0.24050561f, 0.16759501f, 0.31587476f, 0.30184275f, 0.10706277f, 
    -0.11078443f, -0.25624737f, 0.11583964f, 0.13052814f, 0.13972314f, -0.22238827f, -0.07617509f, -0.08555424f, 
    0.05642874f, -0.08010182f, 0.01668180f, 0.19688745f, -0.03238669f, -0.15834439f, -0.15278395f, -0.08267285f, 
    -0.12782626f, -0.04772177f, -0.15510350f, -0.06140744f, 0.05836277f, -0.14308311f, 0.17823550f, 0.17692627f, 
    -0.10241857f, -0.05552793f, 0.07530088f, -0.05179492f, -0.17635037f, 0.04100987f, -0.16258126f, 0.08237825f, 
    -0.03528909f, 0.16920310f, -0.06706215f, -0.00874476f, -0.01844759f, 0.17704889f, -0.19064350f, 0.00100373f, 
    0.11150161f, 0.28489491f, 0.26245269f, 0.06388997f, 0.10033420f, 0.03700148f, 0.04589935f, -0.15610950f, 
    0.12034082f, 0.04743576f, -0.02744372f, -0.05790915f, 0.05796181f, 0.07432272f, 0.16539730f, -0.05408907f, 
    0.18978326f, 0.10739545f, 0.21323493f, -0.07738199f, 0.12709242f, 0.29849315f, -0.02658283f, -0.30889255f, 
    0.19536373f, 0.24371943f, 0.10855198f, 0.16134074f, 0.02141114f, -0.04854636f, 0.03172014f, -0.11278767f, 
    -0.01333110f, -0.13651337f, -0.19797139f, 0.10289901f, 0.29125226f, 0.14385602f, 0.03958372f, 0.21420765f, 
    -0.23815188f, -0.42227900f, -0.11459707f, 0.16379622f, -0.01715454f, 0.18264472f, -0.01163977f, -0.04928251f, 
    0.06778551f, 0.22638974f, -0.11759263f, 0.02202598f, 0.18003346f, 0.30351296f, 0.13468091f, -0.00297996f, 
    0.10980798f, -0.07240617f, 0.00551248f, 0.03152296f, 0.42381528f, 0.19505347f, 0.16848555f, 0.32361150f, 
    0.10389551f, -0.10103711f, -0.08511213f, -0.07513325f, -0.07264660f, 0.24510576f, 0.03332748f, -0.07551815f, 
    0.05859226f, 0.06857256f, 0.20644628f, 0.02915452f, 0.04688297f, -0.02627018f, 0.23045892f, -0.19283977f, 
    0.67719311f, 0.12194502f, -0.10186622f, 0.08383770f, -0.08144458f, 0.08535898f, -0.10621953f, 0.08945879f, 
    0.06683722f, 0.15319447f, 0.01854150f, -0.09881534f, 0.13298160f, -0.16294532f, 0.04205238f, -0.01186953f, 
    -0.00338517f, 0.09960376f, 0.27769095f, -0.07028684f, 0.61608720f, -0.36512813f, 0.02424854f, -0.02930744f, 
    -0.18680021f, -0.00470103f, 0.04261665f, 0.01074355f, 0.06106339f, 0.00666337f, -0.06837641f, 0.16297945f, 
    0.01752742f, -0.03816649f, 0.10492392f, -0.03652157f, -0.05532398f, -0.02683809f, -0.10847242f, -0.08593175f, 
    0.01118571f, -0.11139663f, -0.09943757f, -0.05136550f, 0.05596826f, -0.15284960f, -0.17387199f, 0.10872804f, 
    0.14613110f, -0.09951025f, 0.06136548f, 0.10513635f, 0.02825955f, -0.01671084f, -0.19371331f, 0.03042337f, 
    0.14902334f, -0.28289628f, -0.16263455f, -0.10360930f, 0.26938149f, 0.29110664f, -0.06409093f, -0.12563765f, 
    -0.10842369f, -0.00515261f, 0.03279017f, -0.00862840f, 0.19490600f, 0.08460947f, -0.18113130f, 0.00284954f, 
    -0.05357156f, 0.10622962f, -0.10947180f, -0.01026925f, 0.14785320f, 0.01316658f, -0.00417839f, 0.20714092f, 
    0.43553811f, -0.27554911f, -0.13725613f, -0.37244594f, -0.06302608f, 0.06023123f, 0.00949889f, 0.00319596f, 
    -0.02067915f, -0.16788159f, -0.19250102f, 0.06238633f, -0.08016653f, -0.04343300f, -0.00532261f, 0.00540973f, 
    -0.01631308f, 0.08770763f, -0.03151229f, 0.01358331f, 0.38441268f, 0.08366433f, -0.10310054f, -0.07421654f, 
    0.28539333f, -0.00221567f, -0.00291825f, 0.25377834f, -0.06267931f, -0.03224234f, 0.03947560f, 0.03068040f, 
    0.06608009f, 0.01954865f, -0.03146159f, -0.05365961f, -0.02557266f, -0.29638115f, -0.07596396f, -0.08240850f, 
    -0.05808707f, -0.03745631f, -0.00245975f, -0.04203633f, 0.01802534f, -0.01045919f, -0.03312819f, -0.03165602f, 
    -0.01815696f, 0.01290849f, -0.02711667f, 0.03236688f, 0.00715838f, -0.04119585f, -0.02633308f, -0.02863643f, 
    -0.04351902f, -0.03725951f, -0.02701648f, -0.01803588f, -0.01241180f, -0.01306498f, 0.02219666f, 0.00696675f, 
    -0.05481671f, -0.02620955f, -0.03263110f, 0.04428840f, 0.02205732f, -0.00286845f, -0.06152874f, -0.02390090f, 
    -0.06144943f, -0.00610362f, -0.03355062f, -0.02056408f, -0.03392784f, 0.02249023f, -0.00948415f, 0.02732866f, 
    -0.04515239f, 0.03502501f, -0.01279189f, -0.01182482f, -0.01888590f, 0.02740252f, 0.00499684f, 0.00784813f, 
    0.00248807f, 0.04408201f, -0.04822363f, 0.03370127f, 0.04280068f, 0.03212503f, 0.03589317f, -0.03646304f, 
    0.04491119f, -0.04156649f, 0.04825930f, -0.00052432f, -0.03688274f, 0.05541350f, 0.04536300f, 0.02537186f, 
    0.03866804f, 0.02403849f, 0.04708468f, -0.04222061f, -0.02485165f, -0.00960428f, 0.03537969f, -0.02249729f, 
    -0.00675640f, 0.03820503f, 0.02989734f, 0.05307812f, -0.01664476f, 0.01775536f, -0.03177807f, -0.04036673f, 
    0.01239430f, 0.02190145f, 0.04876386f, 0.01061490f, 0.04981049f, 0.02890949f, -0.03108647f, -0.04141252f, 
    -0.01086151f, -0.01871378f, 0.01273492f, 0.03382083f, 0.01118082f, -0.03224666f, 0.00839121f, 0.04293808f, 
    -0.03433231f, 0.00076692f, 0.02558943f, -0.03437441f, -0.03728925f, -0.05188758f, -0.01060672f, 0.03681568f, 
    -0.05276523f, -0.01065233f, 0.01689621f, -0.02814716f, 0.03697143f, -0.00001833f, -0.05228894f, 0.02152895f, 
    -0.03983095f, -0.01345293f, -0.03766304f, 0.00974921f, -0.00912577f, -0.02579292f, -0.03742420f, -0.03885340f, 
    0.02920198f, -0.05183591f, -0.05427737f, 0.01000901f, 0.00304983f, -0.05155196f, 0.00318859f, 0.05345900f, 
    -0.00760967f, 0.00715413f, -0.05776452f, -0.03384558f, 0.02754814f, -0.04479251f, -0.02677288f, -0.03089505f, 
    -0.02163093f, -0.01945399f, 0.04021266f, -0.00993943f, 0.00592183f, 0.02345170f, 0.00771146f, 0.01147848f, 
    -0.04086410f, -0.02970696f, 0.00297988f, 0.01557023f, 0.03336804f, 0.00332877f, -0.02896209f, -0.01617982f, 
    0.02949951f, 0.03611675f, 0.03731400f, -0.02936886f, 0.01517353f, 0.03202000f, -0.02590046f, -0.03694125f, 
    -0.01141232f, 0.02263004f, 0.03587731f, 0.02803369f, 0.03801463f, 0.03535974f, -0.03371930f, 0.00401299f, 
    0.02837285f, 0.02931426f, 0.00734529f, -0.02012593f, 0.00779777f, 0.02802257f, -0.00215205f, -0.02480068f, 
    -0.02233392f, 0.00931781f, -0.02794511f, 0.00361486f, 0.02352694f, 0.00134350f, -0.05862434f, -0.03639726f, 
    -0.05623186f, -0.05037335f, -0.03524728f, -0.05882121f, -0.00433733f, 0.01434913f, 0.04183452f, 0.01671746f, 
    -0.02990246f, -0.01694375f, 0.04482680f, -0.03144558f, -0.02434391f, -0.04577894f, -0.01073146f, 0.01191115f, 
    -0.00921694f, -0.01260562f, -0.01900049f, 0.02465257f, -0.03687954f, 0.04384449f, -0.03957526f, 0.00396835f, 
    0.00959366f, 0.00820148f, -0.03477186f, -0.05433133f, 0.04195400f, -0.03728864f, -0.01744257f, 0.04249186f, 
    0.04676169f, -0.05070176f, -0.03411071f, 0.02693718f, -0.01453843f, -0.03305631f, -0.05804589f, 0.04279526f, 
    -0.05303451f, 0.02243304f, 0.00191520f, -0.06190465f, 0.02117072f, 0.02231546f, 0.03941241f, -0.01236754f, 
    -0.03622553f, -0.02309185f, -0.04816204f, 0.04305214f, -0.04638699f, -0.05653683f, -0.04584445f, -0.05701969f, 
    -0.00866146f, 0.04598573f, 0.04223152f, -0.05147893f, 0.00318000f, 0.02131158f, -0.03137726f, -0.01611606f, 
    -0.05979065f, 0.03349727f, 0.01772755f, -0.04124452f, -0.06116880f, 0.04611291f, 0.02282905f, -0.06080903f, 
    0.02645537f, -0.04324021f, 0.01480913f, -0.05238640f, 0.00515124f, 0.03369936f, -0.05346910f, -0.02701635f, 
    -0.04641451f, -0.04704119f, -0.05303043f, -0.00011703f, 0.03064085f, 0.03990551f, -0.01395395f, -0.04835263f, 
    0.04447532f, -0.03778947f, 0.01358059f, 0.00701598f, 0.03504517f, -0.04590173f, -0.01623324f, 0.01658779f, 
    -0.00804611f, 0.02872810f, -0.04915062f, -0.01319365f, 0.04160320f, -0.05341377f, -0.04930519f, -0.01887184f, 
    -0.01641283f, -0.05830600f, -0.03495428f, 0.03378621f, -0.01232545f, 0.00871802f, 0.04986227f, -0.02989238f, 
    -0.03200870f, -0.03374085f, -0.01050217f, -0.03661724f, -0.03454369f, 0.02591459f, 0.03874531f, -0.04699325f, 
    0.02522333f, -0.01181298f, -0.03057411f, -0.00676121f, -0.05834249f, 0.03648756f, 0.03504189f, -0.05308812f, 
    0.00118878f, -0.00168302f, 0.04387034f, -0.01124858f, 0.00707244f, -0.04534462f, 0.00144138f, 0.03639669f, 
    -0.19358872f, -0.36843354f, 0.25359383f, 0.08117332f, 0.00448380f, -0.00222461f, 0.00311405f, 0.06650738f, 
    0.00739218f, -0.05713889f, 0.07282453f, 0.04658146f, 0.14513567f, 0.01006541f, -0.05299231f, -0.06853539f, 
    0.04308284f, -0.03963561f, 0.04466622f, 0.07162132f, 0.55115879f, 0.06830793f, 0.08266706f, 0.00207460f, 
    0.06271306f, 0.11952719f, 0.06046715f, 0.05151167f, 0.00651534f, 0.03224847f, 0.06870140f, 0.01405258f, 
    -0.10465314f, 0.02246881f, 0.04747913f, 0.06661309f, 0.07398108f, -0.07358001f, -0.11858480f, 0.03354142f, 
    0.19599970f, -0.45097661f, 0.33870450f, 0.16738109f, -0.06185809f, 0.02746295f, 0.04597821f, -0.15561782f, 
    0.07250438f, 0.15937178f, -0.21239142f, 0.15590017f, 0.03885425f, -0.19651248f, 0.13689397f, -0.15518452f, 
    -0.01366516f, -0.03550250f, 0.07986321f, -0.10465202f, 0.18471144f, -0.02789306f, 0.33685744f, 0.47479555f, 
    -0.00577362f, 0.18012924f, 0.07133012f, -0.01848512f, -0.01292857f, -0.02574591f, -0.16253786f, 0.02379344f, 
    0.15384166f, 0.16405381f, 0.04772456f, -0.03871233f, 0.05063047f, -0.05904906f, -0.07052876f, 0.11359970f, 
    -0.68619478f, -0.14537811f, 0.19851592f, -0.47596037f, -0.22287638f, -0.22252430f, 0.09560282f, -0.03502092f, 
    0.10859615f, -0.01559936f, -0.09079550f, -0.16326073f, -0.06420895f, 0.00278600f, 0.10258745f, -0.08858600f, 
    0.15175080f, 0.27729803f, 0.04195515f, 0.07875069f, -0.59759325f, 0.43518770f, 0.30783573f, 0.01468389f, 
    0.04344201f, -0.01485400f, -0.10592549f, -0.06093515f, -0.02451592f, -0.04515699f, 0.13587181f, 0.18278122f, 
    -0.04051369f, -0.09360133f, -0.08724165f, -0.06132378f, -0.01808432f, 0.13534315f, 0.05463856f, -0.11225087f, 
    -0.03252848f, -0.19619432f, 0.38822037f, 0.04477132f, -0.14830524f, -0.05517008f, 0.17631632f, 0.07558759f, 
    0.13908435f, 0.11311387f, -0.14415626f, 0.14068840f, -0.01278529f, 0.01532934f, -0.06987781f, -0.04515218f, 
    -0.10048334f, 0.10719994f, 0.06774066f, 0.10597156f, -0.06318004f, -0.41434124f, 0.51630074f, 0.08583987f, 
    0.23604059f, 0.03896628f, -0.05197161f, -0.17301203f, -0.10893342f, 0.14017995f, -0.00516964f, -0.03422746f, 
    -0.11168963f, -0.12772322f, 0.03211314f, -0.06250677f, -0.00924764f, 0.00994794f, -0.16060597f, 0.00342557f, 
    0.58667064f, 0.30674329f, 0.21629722f, 0.16595069f, 0.10635393f, 0.25536141f, -0.00652841f, -0.03632905f, 
    -0.10857040f, -0.02282011f, 0.16568418f, 0.08692053f, -0.05945674f, 0.06194424f, -0.15043865f, 0.00981095f, 
    0.11644402f, 0.00250909f, 0.09628589f, -0.06374357f, 0.25694868f, 0.00827403f, -0.10899732f, 0.21984470f, 
    -0.01558989f, 0.04913818f, 0.23436630f, -0.21954702f, 0.27391872f, -0.00394109f, -0.05189927f, 0.00826599f, 
    -0.05772736f, -0.00762605f, -0.02131027f, -0.05832393f, -0.00236816f, -0.05990993f, -0.03354768f, 0.03617341f, 
    0.17918396f, -0.03347215f, 0.31117427f, 0.12488783f, -0.00110846f, 0.21936357f, 0.24844404f, -0.21346554f, 
    0.22524409f, 0.07608127f, 0.04973387f, 0.02808429f, 0.05757482f, 0.12385743f, -0.03837546f, 0.11252138f, 
    0.01187212f, 0.02576976f, 0.03212149f, -0.18922092f, -0.04641990f, -0.29310608f, 0.08153338f, -0.24563205f, 
    0.06252659f, -0.13050857f, 0.05700714f, -0.10014456f, -0.03262220f, 0.00946945f, -0.14522851f, -0.07461797f, 
    0.11069868f, 0.09733425f, 0.04797187f, 0.07702034f, 0.13634269f, 0.09224523f, 0.09608886f, -0.07979952f, 
    -0.06152856f, -0.05892619f, -0.01629581f, -0.25828627f, -0.17006242f, 0.02916832f, -0.09571190f, -0.03422760f, 
    -0.04893224f, -0.08761559f, -0.07519794f, -0.05837297f, 0.02532391f, 0.19622433f, -0.15431888f, -0.02387379f, 
    -0.04404312f, 0.03252270f, -0.09857381f, 0.13011491f, -0.12644695f, -0.07863196f, 0.26343215f, -0.15650335f, 
    0.43721345f, -0.02158915f, -0.16626957f, 0.07337213f, 0.01302519f, -0.09012536f, -0.03397656f, 0.05733630f, 
    0.12654793f, 0.09169916f, -0.07715085f, 0.08465686f, -0.01004791f, 0.01087820f, 0.07395811f, -0.03099133f, 
    0.12677768f, 0.03715139f, -0.08749769f, -0.17185940f, -0.50197667f, 0.08171503f, 0.05990798f, 0.01551940f, 
    -0.00645478f, -0.05150036f, -0.05869986f, 0.03113145f, -0.19765103f, 0.01882301f, -0.01835078f, -0.00352007f, 
    -0.11497959f, 0.01477563f, -0.02933598f, 0.10484329f, -0.27651492f, -0.02383066f, 0.17154069f, -0.20577155f, 
    0.13785224f, 0.13282293f, -0.05348922f, 0.07182896f, -0.06719372f, 0.10814575f, -0.15969686f, -0.00880069f, 
    -0.03725650f, 0.04435488f, 0.09480601f, 0.04850059f, 0.08220372f, 0.04121467f, -0.01730330f, 0.01130506f, 
    -0.44654307f, -0.28524685f, -0.06205824f, -0.12739834f, -0.05565457f, -0.14377572f, 0.05556719f, 0.16239157f, 
    0.06885949f, 0.05499772f, 0.05271435f, 0.11673733f, 0.02995309f, 0.10627501f, 0.07423947f, 0.09445725f, 
    -0.02378690f, -0.18776172f, 0.13392393f, -0.00175466f, 0.12926748f, -0.27217814f, 0.05321828f, 0.04650426f, 
    0.17149833f, -0.09012330f, 0.07895076f, 0.09766807f, -0.12660462f, -0.05894149f, 0.10746305f, 0.00934738f, 
    0.14929511f, 0.13127035f, 0.05273334f, 0.13963373f, -0.05064831f, 0.08962964f, -0.00548636f, 0.04355797f, 
    -0.19555567f, -0.45142931f, -0.13225380f, -0.19698288f, -0.09951411f, -0.14787453f, -0.04736464f, -0.07731672f, 
    0.08644794f, -0.02307061f, 0.11223356f, -0.02550087f, 0.05354485f, 0.03392082f, 0.28105822f, -0.08637130f, 
    -0.00074862f, 0.00926606f, -0.04088040f, -0.04434432f, -0.10759500f, -0.25160733f, -0.16326110f, -0.21240826f, 
    -0.34973729f, 0.07767534f, -0.15374549f, 0.02975241f, 0.04395724f, 0.04544453f, 0.05410158f, 0.05432044f, 
    0.15516447f, 0.29533440f, 0.18421923f, -0.04951843f, 0.14656474f, 0.04846479f, -0.14488965f, 0.02213170f, 
    0.96669453f, 0.67281151f, 0.21779917f, -0.04217205f, 0.20395851f, 0.10217564f, -0.02740084f, -0.00725550f, 
    -0.09568951f, 0.01758057f, 0.01960518f, 0.00876600f, 0.09025464f, 0.04691395f, 0.10289841f, -0.02356590f, 
    0.09295771f, 0.11469242f, 0.01206777f, 0.07011574f, -0.30630860f, -0.10321157f, -0.08228470f, 0.00580509f, 
    -0.04812609f, 0.15857030f, 0.07689154f, 0.01133305f, 0.04630028f, 0.14465940f, 0.09449711f, 0.06874560f, 
    0.03803002f, -0.07065572f, 0.05963964f, 0.02783433f, -0.03631938f, 0.06200157f, -0.00012517f, -0.04689538f, 
    -0.36661375f, -0.49048299f, -0.37665737f, 0.04230057f, -0.08259840f, 0.06775650f, 0.05320977f, 0.11464018f, 
    -0.02175811f, -0.04400955f, 0.00995727f, 0.10797251f, -0.02987742f, 0.03979522f, 0.08045626f, 0.01990803f, 
    -0.04045489f, 0.05685847f, -0.07468730f, 0.08342523f, 0.53207654f, -0.12978454f, -0.13295652f, 0.03990734f, 
    -0.15712640f, -0.35885769f, -0.02387724f, -0.07513177f, -0.01488060f, 0.05453347f, 0.30805448f, -0.11120090f, 
    0.20545240f, -0.00813855f, 0.20776995f, -0.03067807f, 0.15865619f, 0.08448744f, 0.05077972f, -0.08977357f, 
    0.25944683f, 0.12894677f, 0.13609822f, -0.00305729f, 0.05429108f, 0.22421159f, 0.16789529f, -0.02451061f, 
    0.06586809f, 0.17243537f, 0.15327071f, 0.11205237f, -0.12694150f, 0.06086067f, 0.09106419f, -0.03628012f, 
    0.01986126f, -0.02536205f, 0.04162548f, -0.01760487f, -0.56499398f, 0.34493321f, -0.27295515f, 0.07987992f, 
    -0.15155651f, 0.05452838f, 0.10705329f, 0.12858109f, 0.27291155f, 0.04333747f, 0.06068780f, -0.03488452f, 
    0.04928388f, -0.07803009f, 0.04745085f, 0.05630486f, -0.16925693f, -0.02461438f, 0.00787052f, -0.01478245f, 
    -0.15375707f, -0.12481529f, -0.04858522f, 0.02599495f, -0.24838462f, 0.16454048f, 0.29067609f, -0.20816462f, 
    0.14027400f, 0.17336918f, -0.01179617f, -0.11553700f, -0.02028983f, 0.00855021f, 0.04497540f, 0.02702507f, 
    0.16969582f, -0.04838504f, -0.16376907f, 0.08767912f, -0.28596234f, 0.49211445f, 0.14816289f, -0.15185365f, 
    -0.34293097f, 0.01358318f, -0.11212169f, -0.08522331f, 0.05441168f, -0.06298967f, -0.06127411f, 0.04176105f, 
    0.06993702f, 0.04652322f, 0.14124569f, -0.01472859f, -0.00393320f, -0.01787399f, 0.15062474f, -0.11407409f, 
    0.65532261f, 0.50307727f, 0.30420682f, 0.09935192f, 0.30268762f, 0.07745599f, 0.11040782f, -0.03749778f, 
    -0.01406879f, 0.05339694f, 0.02856171f, 0.13062543f, 0.07933521f, -0.09658988f, -0.03073051f, 0.01234247f, 
    0.15353416f, 0.01799062f, 0.00364680f, 0.10595519f, 0.26476529f, 0.20880629f, 0.19803254f, -0.05163353f, 
    0.21869501f, 0.10620089f, -0.08908506f, 0.07726250f, 0.12929358f, -0.05659725f, -0.00239410f, 0.04876188f, 
    0.08752091f, -0.05116862f, 0.12264353f, 0.04082861f, 0.13377209f, 0.16200109f, 0.03791656f, -0.01313181f, 
    0.35129508f, 0.03339747f, 0.15817507f, -0.08105634f, -0.31962293f, 0.10249880f, 0.09959765f, 0.14355737f, 
    0.03870437f, 0.05093452f, 0.01857298f, -0.05949595f, 0.06257650f, 0.19407248f, -0.04893186f, 0.16963780f, 
    0.04707510f, 0.04090432f, -0.02531542f, -0.05590238f, 0.04697659f, 0.15293506f, 0.28999788f, 0.15621109f, 
    0.21338129f, 0.12784626f, 0.02937118f, 0.04604147f, -0.09942328f, -0.00031131f, 0.00423675f, -0.01249294f, 
    0.08273698f, 0.04554506f, 0.00638689f, 0.03989483f, 0.00924171f, 0.00697855f, 0.01517303f, -0.03454335f, 
    -0.04096638f, -0.01421747f, 0.04392975f, -0.06766165f, -0.00792365f, -0.02168311f, -0.01220894f, -0.05201033f, 
    0.02261496f, -0.01366384f, -0.00880496f, 0.00258252f, -0.04236449f, 0.01358573f, 0.04178235f, 0.03715064f, 
    -0.03501573f, -0.03434692f, -0.05060249f, -0.02901202f, -0.03475381f, 0.04002385f, -0.06957982f, 0.00235147f, 
    -0.02794626f, -0.01081530f, -0.05274924f, -0.00094673f, 0.01992886f, 0.01463618f, -0.04526467f, 0.04151014f, 
    0.02129108f, 0.04708036f, 0.01580739f, 0.03703732f, 0.03275237f, -0.03562024f, -0.03628041f, 0.01616280f, 
    -0.06178054f, 0.01821934f, -0.02890933f, 0.00164940f, 0.02536055f, -0.02453179f, 0.03939340f, 0.02293654f, 
    0.02518363f, -0.03633039f, -0.03646032f, 0.00847185f, -0.05509268f, 0.03358125f, -0.00502767f, -0.01157099f, 
    0.03310449f, 0.00460247f, 0.04170429f, -0.01445610f, -0.05357943f, 0.00990346f, 0.02580193f, 0.03053612f, 
    -0.01583780f, -0.00472931f, -0.05093805f, -0.00909360f, -0.05653569f, -0.02925623f, -0.03764682f, -0.03228281f, 
    0.02494677f, -0.01349529f, -0.02878342f, -0.04669152f, -0.01875125f, -0.01039016f, -0.04108394f, -0.04333194f, 
    -0.00261223f, 0.03663751f, 0.01944555f, -0.03491395f, -0.05921687f, 0.05083290f, 0.02471468f, -0.01339595f, 
    -0.03675790f, -0.03970316f, 0.01660842f, -0.05227132f, 0.00847834f, -0.00356513f, 0.02722561f, -0.00992278f, 
    -0.05300647f, 0.04226776f, 0.01006040f, -0.06325115f, -0.01351119f, 0.02431419f, 0.04565524f, 0.03739933f, 
    -0.03121205f, -0.02772452f, -0.04679099f, -0.00960644f, -0.04470371f, -0.04861389f, 0.02415823f, -0.03731944f, 
    0.04613724f, -0.02495583f, -0.04536958f, 0.03631688f, -0.00525516f, -0.00012864f, -0.01013837f, -0.04504253f, 
    -0.00030263f, -0.00982432f, 0.02891949f, -0.07150213f, 0.01340870f, -0.01349490f, -0.03796467f, 0.01273702f, 
    -0.05349169f, -0.04769827f, -0.03776691f, 0.02298643f, -0.03534521f, 0.04714385f, 0.00209102f, -0.02918794f, 
    0.00222390f, -0.03087237f, -0.02577149f, -0.05017950f, 0.04178176f, -0.03739064f, 0.02738368f, 0.00818813f, 
    -0.05038902f, -0.03835687f, -0.01713499f, 0.02992182f, 0.00814912f, -0.06005813f, -0.00427958f, 0.03771877f, 
    -0.04717057f, 0.00046626f, -0.00981245f, -0.01380668f, -0.00537545f, -0.03802793f, -0.04857767f, 0.02384589f, 
    0.04283369f, 0.03777928f, 0.00882102f, -0.01850993f, -0.04208833f, 0.00477330f, -0.05969099f, -0.02157407f, 
    0.03351049f, -0.00410619f, 0.02152749f, 0.01963135f, -0.00050802f, 0.03072006f, -0.00254133f, 0.02163039f, 
    0.03816120f, -0.05692695f, -0.00485155f, 0.04043951f, -0.02488164f, -0.05622073f, -0.00312340f, 0.01425709f, 
    -0.05451743f, -0.01888046f, 0.03999138f, -0.04122556f, -0.03945395f, 0.02075298f, -0.02719569f, 0.01345627f, 
    -0.02521912f, 0.04890261f, -0.00037040f, -0.02060021f, 0.02665811f, -0.00507331f, -0.03355736f, 0.03849810f, 
    -0.03267283f, 0.01149664f, 0.02184324f, 0.02368127f, 0.03224885f, 0.04003115f, -0.00769064f, -0.06058902f, 
    0.01900360f, 0.01047842f, -0.06139867f, -0.04962210f, 0.04588310f, 0.04714996f, -0.01491725f, 0.00963984f, 
    -0.02763739f, 0.01162378f, -0.02098276f, 0.03933650f, -0.02830532f, -0.00024940f, 0.02866067f, -0.05462369f, 
    -0.05932026f, -0.05353632f, 0.03721335f, -0.01996347f, -0.02322532f, -0.04462156f, 0.03729400f, 0.03488694f, 
    0.01022140f, -0.01234921f, 0.01846891f, -0.06254216f, 0.01315198f, 0.03001395f, 0.04429841f, 0.01683190f, 
    0.00799303f, 0.04907377f, -0.00437189f, -0.00316327f, -0.05518154f, -0.04585954f, 0.02643977f, 0.00032584f, 
    -0.04294451f, -0.02527873f, 0.04534153f, 0.03020657f, -0.06592722f, -0.01684953f, -0.06472586f, -0.02960009f, 
    -0.06290008f, 0.03721157f, 0.00561234f, 0.01109848f, 0.02176012f, 0.00154095f, -0.01830260f, -0.04374414f, 
    -0.00344116f, -0.04129045f, -0.01920389f, 0.00624984f, -0.02521294f, -0.01012096f, -0.00935349f, 0.04932916f, 
    0.04203779f, -0.04132187f, 0.01016904f, -0.04007114f, 0.02069041f, 0.00060993f, -0.02114915f, -0.05993982f, 
    -0.03269903f, 0.00880695f, 0.04848331f, 0.00449328f, -0.00136562f, -0.03907945f, 0.01850284f, 0.02227413f, 
    -0.06122712f, -0.06402519f, -0.00235850f, 0.03483424f, -0.01326181f, 0.01929021f, 0.01467748f, -0.01527513f, 
    -0.02269030f, -0.02599146f, 0.02761296f, -0.04470544f, -0.03414014f, 0.02293199f, -0.01927839f, 0.01126151f, 
    -0.02097076f, -0.00728323f, 0.03268228f, 0.04634076f, 0.00276072f, 0.04037521f, 0.04531888f, 0.00240755f, 
    0.01860829f, -0.03014050f, 0.00849411f, -0.00254669f, 0.00364886f, 0.02478306f, 0.03397993f, 0.00908144f, 
    0.22732724f, -0.07160363f, 0.07926177f, 0.27930069f, 0.20407805f, -0.00501466f, -0.09597393f, 0.02704789f, 
    0.07758370f, 0.03835266f, 0.01063785f, 0.09659368f, 0.02362408f, 0.03928230f, 0.18384367f, 0.16158783f, 
    0.10894600f, -0.07290938f, -0.10496932f, -0.10809617f, -0.68086964f, 0.36671379f, -0.15235238f, -0.13554585f, 
    -0.02007218f, -0.16789114f, 0.18897694f, -0.03901451f, -0.00457200f, 0.12180054f, -0.10240214f, 0.13007036f, 
    0.19422841f, -0.06883661f, -0.13128898f, 0.14431481f, -0.00161980f, 0.03736711f, 0.00885821f, -0.01775280f, 
    0.03387834f, 0.36272907f, -0.17969847f, 0.24857774f, -0.02744297f, 0.11799830f, 0.07039206f, 0.03043642f, 
    0.04745702f, -0.07412418f, -0.06113515f, 0.09462984f, 0.05674456f, 0.04388513f, 0.03192877f, 0.13098817f, 
    -0.05894969f, 0.13093337f, -0.03045962f, 0.04278675f, -0.09173241f, -0.16297854f, -0.03705778f, 0.07026833f, 
    0.26332349f, 0.01368280f, -0.14524807f, 0.06033167f, 0.05797148f, -0.02959345f, 0.09452662f, 0.05429278f, 
    -0.07807986f, 0.00719524f, -0.13220413f, -0.04195419f, -0.08212685f, -0.07232709f, 0.16751650f, 0.00505585f, 
    0.35000423f, -0.16878113f, -0.13591450f, 0.27180523f, 0.35246304f, -0.13940205f, -0.25308833f, 0.08498717f, 
    0.01240552f, 0.14168367f, 0.19113806f, 0.15022615f, 0.08254559f, 0.01399710f, 0.00303420f, 0.01599016f, 
    0.13538508f, -0.02339038f, -0.08072010f, 0.03114316f, 0.38009095f, -0.07274015f, 0.00496077f, -0.11791592f, 
    -0.21734892f, -0.10165180f, 0.12357257f, 0.20903546f, 0.03191112f, -0.05132210f, -0.04624509f, 0.00285682f, 
    0.08705024f, 0.02212661f, 0.00811907f, -0.06602827f, 0.17335726f, -0.08868349f, 0.00271640f, 0.08001564f, 
    -0.00368816f, 0.24422616f, -0.08098402f, -0.03875974f, -0.25734210f, 0.07299730f, -0.07961397f, -0.01550496f, 
    0.13298130f, -0.12779458f, -0.09299478f, 0.01344371f, 0.02324651f, 0.04640447f, 0.03579007f, 0.12372194f, 
    0.01537500f, 0.00932229f, -0.22910303f, -0.01415792f, -0.04511893f, 0.66177249f, -0.23481935f, 0.26010451f, 
    0.03419361f, -0.09669872f, 0.07262767f, 0.04828601f, 0.03362070f, 0.05900907f, 0.08000182f, 0.11785909f, 
    -0.06283148f, 0.17430279f, 0.25004190f, 0.00704588f, -0.06948584f, -0.07421662f, -0.02766248f, -0.09014909f, 
    -0.21300176f, 0.17840885f, 0.07436550f, -0.11357475f, -0.16085808f, -0.08135001f, 0.17938159f, 0.00211514f, 
    -0.01462744f, -0.18999505f, -0.03755522f, 0.10191241f, -0.09319077f, -0.11057524f, 0.04053636f, 0.08586644f, 
    0.09234343f, -0.05681623f, -0.03550874f, 0.04124487f, -0.64596778f, 0.29815084f, -0.06055296f, -0.10367592f, 
    -0.24965008f, 0.12587604f, 0.05773456f, 0.09133845f, -0.04245800f, -0.05819186f, 0.07937985f, -0.08917073f, 
    0.07386224f, 0.12940495f, -0.06674083f, -0.05339068f, -0.01736626f, 0.03934401f, -0.07918075f, 0.00851379f, 
    0.17147067f, 0.50497735f, -0.00023011f, -0.19286636f, -0.11857539f, 0.04470130f, 0.02222034f, -0.02753510f, 
    -0.15588138f, 0.01965210f, 0.12914330f, -0.12142973f, -0.13611220f, 0.04838388f, -0.03205504f, 0.05333201f, 
    0.17720719f, -0.03133636f, -0.20421296f, -0.10157567f, 0.06614196f, 0.23612690f, 0.05058276f, -0.13259789f, 
    0.40156120f, 0.02856961f, -0.00455450f, 0.03672373f, 0.08240259f, -0.04287640f, -0.06082990f, 0.11511943f, 
    -0.04612908f, 0.02580137f, 0.10854931f, -0.01358730f, -0.03742922f, -0.03480250f, -0.03520025f, 0.05484516f, 
    0.02574646f, 0.09053269f, -0.05143892f, 0.12771247f, 0.00551864f, -0.22198148f, -0.21238808f, -0.05473382f, 
    -0.00566665f, 0.28713688f, 0.05454842f, 0.00833678f, 0.06516568f, -0.11797160f, 0.27894306f, 0.06183948f, 
    0.03761563f, 0.17694506f, 0.10473511f, 0.11867581f, 0.57348305f, -0.19075748f, 0.00318032f, -0.00965076f, 
    -0.01549327f, -0.08913275f, -0.00825268f, -0.09695655f, 0.04770524f, 0.05579839f, 0.04153498f, -0.06430203f, 
    -0.06994521f, -0.09612315f, -0.08680222f, -0.11500674f, 0.07852486f, -0.17718586f, 0.09038266f, -0.03724748f, 
    -0.52412814f, -0.25294828f, 0.35901093f, 0.10908009f, -0.09956218f, -0.00176177f, -0.09857652f, -0.02454997f, 
    -0.08617693f, 0.24934003f, 0.04581624f, 0.01169159f, 0.01378802f, -0.14132550f, 0.05072453f, 0.02675329f, 
    -0.09841938f, 0.01115313f, 0.05319747f, -0.13692966f, 0.00126517f, 0.30227223f, 0.00803909f, 0.07815485f, 
    0.07166671f, -0.00387755f, 0.07655487f, 0.13365071f, -0.11008128f, 0.15908791f, 0.16140860f, 0.05268710f, 
    -0.00359828f, -0.09554619f, 0.05298432f, -0.09445582f, -0.03812799f, 0.20902970f, -0.05801753f, -0.05772769f, 
    0.01767595f, 0.37992558f, -0.09916512f, -0.13518456f, 0.22091164f, 0.01826984f, -0.05840719f, 0.06949295f, 
    0.16202869f, 0.05138802f, -0.17622228f, 0.05342227f, 0.03027265f, 0.00046393f, -0.11935344f, 0.10640797f, 
    0.00182502f, -0.17054093f, 0.07290122f, 0.12195428f, -0.05788209f, -0.58387464f, 0.08329001f, 0.08418178f, 
    0.08064772f, 0.24270330f, 0.08745486f, -0.14063372f, -0.15181930f, 0.04750441f, 0.01461525f, 0.03380514f, 
    0.03824545f, 0.01940199f, 0.07336484f, 0.00133714f, -0.01341848f, 0.26235235f, 0.05818909f, 0.14892568f, 
    -0.04114115f, -0.22637382f, -0.17986254f, -0.31265512f, 0.13209330f, 0.17905226f, -0.00957330f, 0.11444887f, 
    -0.00288692f, 0.09697226f, 0.13789266f, -0.04771957f, -0.04183422f, 0.06363873f, 0.03142607f, 0.10640706f, 
    0.29445657f, 0.05770849f, -0.05918239f, 0.21747668f, 0.20231646f, 0.18454580f, 0.28056353f, -0.37426338f, 
    0.25234786f, 0.09078220f, 0.12635709f, -0.02978496f, -0.00515249f, 0.15321139f, -0.05556196f, -0.09097861f, 
    -0.04160337f, -0.00385247f, 0.03196264f, -0.07892546f, -0.03632836f, -0.17125680f, -0.09396603f, 0.00706799f, 
    0.29226533f, 0.10491122f, -0.15194182f, -0.23177980f, -0.26913238f, 0.28353783f, 0.04807378f, -0.14073770f, 
    -0.06899308f, 0.00220428f, -0.09056228f, 0.06147140f, 0.03353613f, 0.12592728f, -0.02119705f, 0.08435505f, 
    0.06985479f, 0.01368048f, -0.10508698f, -0.00938795f, 0.33251879f, -0.03562614f, -0.41048792f, 0.16256903f, 
    0.19512406f, -0.01061458f, 0.11576037f, 0.01751307f, 0.12346317f, 0.12875904f, 0.10975053f, -0.04044610f, 
    0.05403933f, -0.10208283f, -0.01806052f, 0.03875279f, 0.01647904f, -0.13281433f, 0.03030548f, -0.02196583f, 
    0.23086523f, 0.28555885f, -0.05417260f, 0.23704913f, 0.29502356f, 0.05852129f, -0.00922365f, 0.04935678f, 
    -0.14505142f, 0.02521650f, 0.16849454f, 0.02294084f, 0.06071153f, 0.10645816f, 0.01552745f, 0.00268993f, 
    -0.02398670f, -0.06891486f, -0.06145478f, 0.06716061f, 0.19088815f, -0.33463842f, -0.12562309f, -0.19142693f, 
    -0.13065180f, 0.02217468f, -0.07069720f, -0.04474721f, 0.23658565f, -0.03305051f, -0.04565948f, -0.05270415f, 
    0.14127895f, 0.10914142f, -0.09146347f, 0.08518898f, -0.10839743f, -0.09988602f, 0.08305028f, 0.02524104f, 
    -0.11171591f, -0.05393342f, -0.08024523f, -0.05248380f, -0.28948295f, -0.10214013f, 0.11718980f, -0.03798598f, 
    -0.08907678f, -0.00259413f, -0.06517652f, 0.10842187f, 0.01540015f, -0.11759052f, 0.02498833f, -0.02255016f, 
    -0.05979031f, 0.02928132f, -0.05280793f, 0.01954329f, 0.26131749f, -0.09642056f, 0.37271228f, -0.18928279f, 
    0.18159723f, 0.13267691f, -0.04660888f, 0.12980582f, -0.03623149f, -0.05447816f, 0.00200857f, 0.05531301f, 
    0.07061502f, -0.08245219f, 0.03769258f, 0.17586023f, 0.04350539f, -0.04103686f, -0.07684986f, 0.18276030f, 
    0.09973048f, -0.17406139f, 0.26894045f, 0.04525913f, 0.01193293f, -0.01199868f, 0.03134939f, 0.05075920f, 
    0.06400185f, -0.16562928f, -0.11882801f, 0.09453306f, -0.07891799f, 0.05922058f, -0.03254851f, -0.01524956f, 
    0.03020080f, -0.01983792f, -0.13245913f, 0.16974443f, -0.35011804f, 0.26106116f, 0.03573976f, 0.17670752f, 
    0.38374221f, 0.13684481f, 0.20083527f, -0.12767103f, 0.15704301f, -0.09041210f, 0.08067218f, 0.03411622f, 
    -0.03483691f, 0.23518218f, -0.06855763f, 0.03323576f, 0.12063561f, -0.03205565f, -0.03836615f, 0.07727073f, 
    0.16849321f, -0.05956213f, -0.05382816f, 0.05165284f, -0.02359254f, 0.03955958f, 0.05190840f, 0.03662955f, 
    -0.12798442f, -0.00583420f, 0.01535819f, -0.17898540f, -0.12572873f, -0.07305550f, 0.06747812f, 0.09889032f, 
    -0.04104775f, 0.05102114f, 0.08497268f, 0.00248860f, -0.36830315f, 0.23329422f, 0.14906180f, 0.05870922f, 
    0.19050756f, -0.01253830f, 0.12378589f, -0.03199605f, -0.05969681f, -0.07772510f, 0.11985534f, -0.01122416f, 
    -0.07055398f, 0.07301175f, 0.09173366f, 0.06953570f, -0.03237356f, -0.03799428f, 0.04208995f, 0.01335919f, 
    0.50006181f, -0.04161155f, -0.08386242f, 0.25930962f, 0.31153765f, -0.11313768f, 0.06021440f, 0.09355909f, 
    0.05782318f, 0.11705914f, 0.09425526f, 0.04353139f, 0.11451241f, 0.08856247f, 0.02372142f, 0.03402688f, 
    0.13215098f, 0.22076030f, 0.11745128f, 0.00821792f, -0.52123004f, -0.25084752f, 0.01762334f, 0.13934089f, 
    -0.21488835f, 0.03235059f, -0.06601254f, -0.25193945f, -0.09786059f, -0.02722064f, -0.04003039f, 0.09328592f, 
    -0.20658384f, -0.01407437f, -0.08421140f, -0.03151770f, 0.13183606f, 0.00180707f, -0.03590297f, 0.09466992f, 
    -0.01330063f, 0.05005936f, -0.03652979f, -0.01920926f, -0.02048297f, 0.01044318f, 0.01880210f, -0.03556411f, 
    0.01483511f, 0.01104093f, 0.03047990f, -0.04251285f, 0.02517511f, 0.00506206f, 0.00643663f, -0.05535236f, 
    0.03480218f, 0.00375050f, -0.03373457f, 0.02462311f, 0.01221111f, 0.04992600f, 0.03764577f, 0.00700740f, 
    -0.04980173f, 0.00537243f, -0.03053673f, 0.04137442f, 0.01073977f, 0.00442392f, -0.00015192f, 0.02172522f, 
    -0.01572443f, 0.04309624f, 0.03827776f, 0.00271629f, -0.01980155f, -0.05198282f, -0.03906699f, -0.02389924f, 
    -0.04162152f, -0.05778083f, 0.02121336f, 0.04449045f, 0.00365498f, 0.00025523f, 0.02992998f, -0.04079816f, 
    0.00020159f, -0.01510311f, 0.04075660f, 0.00426104f, 0.01069787f, -0.03047401f, 0.00622268f, -0.04863210f, 
    -0.06205942f, 0.02131161f, 0.00556659f, -0.05222359f, -0.02750751f, -0.02890826f, -0.02652949f, 0.02541317f, 
    0.03102002f, -0.03245084f, 0.03735748f, -0.03395440f, -0.02215680f, 0.03446645f, 0.00250232f, -0.02835025f, 
    -0.05134536f, -0.04070398f, 0.01766841f, -0.04354207f, 0.00070755f, -0.03092236f, -0.01083485f, -0.03988995f, 
    0.01280754f, -0.04657099f, -0.04810790f, 0.02410649f, 0.03311650f, -0.03616786f, -0.02032270f, -0.01147875f, 
    -0.05765124f, -0.03191628f, -0.02993837f, -0.02181052f, 0.00055399f, -0.01553149f, 0.04317579f, 0.03125380f, 
    0.03378830f, 0.02947661f, -0.03122922f, 0.01540244f, 0.01754784f, 0.00232243f, 0.04042914f, -0.01480884f, 
    0.01250115f, -0.04308920f, -0.05956941f, 0.01886472f, -0.06079054f, 0.03760070f, 0.05302075f, 0.00389759f, 
    -0.00281800f, -0.05540635f, 0.00582261f, -0.00135020f, -0.05438825f, -0.00338685f, 0.00112921f, -0.04907721f, 
    -0.04633979f, -0.02368396f, 0.01075867f, 0.00951010f, 0.04411082f, -0.03573235f, 0.01936953f, 0.04045030f, 
    -0.02129498f, 0.00678961f, -0.01583679f, -0.02481037f, -0.04296186f, -0.03038616f, -0.05767708f, 0.01568153f, 
    0.00863519f, -0.05569396f, 0.01146820f, -0.04606156f, -0.03554301f, -0.01549410f, 0.02151314f, 0.03458596f, 
    0.02203261f, -0.01925853f, 0.03305283f, -0.00674944f, -0.04584749f, -0.03941148f, -0.02369811f, -0.03374625f, 
    0.03728464f, -0.03599064f, -0.03392784f, -0.05234917f, -0.01149152f, 0.02338135f, 0.02980910f, -0.02683426f, 
    -0.02822393f, -0.01508247f, 0.00439682f, -0.00708292f, -0.05432393f, 0.04992820f, -0.01284605f, 0.02513834f, 
    -0.02805817f, 0.02595184f, -0.03278803f, -0.03260896f, 0.00331607f, -0.02775265f, -0.02871867f, 0.03545414f, 
    -0.05151258f, 0.03176203f, 0.01905915f, 0.04837030f, -0.04689054f, 0.01807931f, -0.00892178f, 0.00148827f, 
    -0.01625667f, -0.02764511f, -0.01643662f, -0.00472996f, 0.04349260f, 0.04623276f, 0.04528462f, -0.00293868f, 
    -0.02138780f, -0.00298796f, -0.02842277f, 0.00686006f, -0.00282717f, -0.00440870f, -0.06065433f, -0.06090036f, 
    -0.03770589f, 0.02753564f, -0.06152283f, 0.04822894f, -0.05588796f, 0.03246912f, -0.03060356f, -0.04655985f, 
    -0.01485831f, 0.01532865f, -0.04240968f, -0.04174571f, -0.05040279f, 0.00085501f, 0.04629519f, -0.01303772f, 
    0.02098293f, -0.06499902f, -0.03561705f, -0.04236817f, 0.03509647f, -0.01018770f, -0.03508332f, -0.02132192f, 
    0.03839027f, 0.03782145f, -0.02270540f, -0.01602600f, 0.03943078f, -0.00567336f, -0.06062028f, 0.02737435f, 
    -0.02163284f, -0.05644757f, 0.01763791f, -0.04835871f, 0.04427672f, -0.03954832f, -0.03554484f, -0.05525784f, 
    -0.05148182f, -0.00009748f, -0.01173304f, -0.01529485f, -0.03768348f, -0.00604864f, -0.02781970f, -0.06724694f, 
    -0.04113042f, -0.05505827f, -0.04899610f, 0.00166028f, -0.03472162f, 0.02964833f, 0.00706063f, -0.03246771f, 
    -0.05449970f, -0.00761537f, -0.06072374f, -0.01166676f, 0.01736565f, 0.01423917f, -0.00231873f, -0.03621921f, 
    -0.00838654f, 0.00218851f, 0.03682664f, -0.01745300f, 0.04246071f, 0.00976779f, 0.04215152f, -0.00060155f, 
    0.04119838f, 0.01738245f, -0.02966299f, 0.00347527f, -0.04786986f, 0.01595957f, -0.01830789f, 0.03796751f, 
    -0.04635627f, -0.04854200f, -0.04192498f, 0.04305651f, -0.05124058f, -0.03399833f, -0.02163514f, 0.03888045f, 
    -0.05622539f, -0.05577417f, -0.04142538f, 0.02854685f, 0.03617740f, -0.05321942f, 0.02240687f, 0.04461096f, 
    0.02096529f, 0.03384690f, 0.04751877f, -0.01797785f, -0.05319395f, 0.04249715f, -0.00802085f, 0.04292049f, 
    0.04421610f, 0.01278652f, 0.03044662f, -0.02853677f, 0.01757587f, 0.02328562f, -0.05166550f, 0.03538147f, 
    0.00959540f, -0.05197458f, -0.02145570f, -0.06135462f, -0.03518968f, -0.02631490f, 0.03926928f, -0.03864105f, 
    0.04248847f, -0.04200855f, 0.00078884f, -0.03440092f, -0.02207307f, 0.01612723f, -0.04037286f, -0.05329916f, 
    -0.03294858f, -0.00946228f, 0.05144655f, -0.02163019f, -0.04730798f, -0.01809552f, -0.02253777f, 0.05517969f, 
    -0.02973881f, -0.05121255f, -0.00792041f, -0.02340867f, -0.01659282f, 0.01275041f, -0.05251738f, -0.05469610f, 
    0.02421042f, 0.02247806f, -0.00394881f, -0.03534416f, 0.00926074f, 0.00290161f, -0.00552471f, 0.05081864f, 
    0.03794011f, -0.04590158f, 0.01061801f, 0.05168607f, 0.04843592f, -0.05225060f, 0.01108225f, -0.00833621f, 
    -0.00552476f, -0.01252818f, -0.04900554f, -0.03346458f, -0.05320825f, -0.04504223f, 0.03488887f, -0.04883774f, 
    0.01555369f, -0.04028680f, -0.01591826f, -0.01399015f, -0.02922216f, 0.04665566f, -0.00310812f, 0.05458692f, 
    -0.04829159f, 0.04697029f, 0.02109628f, -0.05162753f, 0.03700059f, 0.04568313f, 0.02193417f, -0.00358549f, 
    -0.02375276f, -0.05256629f, 0.04411222f, 0.03718035f, 0.05071305f, -0.05026400f, 0.00246682f, -0.01313180f, 
    -0.03189091f, -0.04814944f, -0.02108797f, 0.04925863f, -0.03285662f, 0.00544454f, 0.01001422f, 0.03600410f, 
    -0.05428744f, -0.03426430f, 0.00078345f, 0.00269602f, 0.01230460f, 0.01858212f, 0.03932638f, 0.02126711f, 
    0.01260149f, -0.02358752f, 0.01823643f, 0.04021525f, -0.00074387f, 0.05286349f, 0.03978668f, -0.04961458f, 
    -0.02245673f, -0.02324141f, -0.02888009f, 0.02252579f, 0.01261581f, -0.02894774f, -0.03939939f, -0.00428898f, 
    0.04484803f, -0.04998633f, 0.00255769f, -0.03505476f, -0.04366342f, -0.02201154f, -0.02108931f, 0.03439377f, 
    -0.02191955f, 0.01981068f, -0.02770377f, 0.04677832f, -0.02885335f, -0.00608108f, -0.03093130f, 0.02846248f, 
    -0.01928654f, 0.05557430f, -0.02849713f, 0.05004619f, -0.01302833f, 0.04813652f, -0.02695052f, 0.01076239f, 
    0.00484540f, 0.00000738f, 0.04127201f, -0.02848070f, -0.01941957f, -0.02724441f, 0.01080197f, -0.03319580f, 
    -0.01353205f, -0.00909725f, -0.01959743f, 0.01858463f, -0.03437890f, -0.05382819f, -0.05201866f, 0.01518565f, 
    -0.03697605f, 0.02532137f, -0.03781158f, -0.04346967f, -0.03313046f, 0.02384437f, -0.03602900f, 0.00983099f, 
    -0.02658420f, -0.04863049f, 0.04279850f, -0.03355454f, -0.00541883f, -0.02359329f, -0.00158367f, 0.01574375f, 
    -0.03961511f, -0.04031984f, -0.03314801f, -0.03730306f, 0.01620315f, -0.00485692f, 0.03633363f, -0.04379685f, 
    -0.02407955f, -0.01415938f, 0.03925171f, 0.04430687f, -0.02206523f, 0.00365822f, 0.04634141f, -0.03812494f, 
    -0.04922663f, -0.04885096f, -0.01118985f, 0.02020236f, 0.02791486f, -0.03570778f, -0.00574489f, -0.01050157f, 
    -0.01172375f, -0.05525417f, 0.02419894f, -0.01393335f, -0.02518827f, 0.04588608f, -0.01543875f, -0.04863835f, 
    0.04378871f, -0.01452546f, -0.02084238f, -0.03868479f, -0.03822014f, -0.02196263f, 0.03869577f, -0.04614811f, 
    0.02320846f, 0.02376951f, -0.04589839f, -0.00896168f, -0.02396580f, -0.00437420f, -0.03126220f, -0.03631902f, 
    -0.05084575f, -0.02134460f, 0.02229860f, -0.02975637f, -0.02875340f, 0.04562001f, -0.05076623f, -0.04055922f, 
    0.00677266f, -0.01940877f, -0.05441048f, 0.01949327f, 0.04804217f, 0.03275136f, 0.00238590f, 0.03636219f, 
    0.00562086f, -0.01900763f, 0.01639601f, -0.02348508f, 0.00463771f, 0.00150152f, 0.03423318f, 0.03647279f, 
    0.04885539f, -0.02816116f, -0.03620075f, 0.02888020f, -0.01369209f, 0.03278507f, -0.02383718f, 0.04565377f, 
    -0.00021048f, -0.04077695f, 0.00407412f, -0.04168336f, -0.04026510f, -0.01868096f, -0.04128863f, -0.00069253f, 
    -0.02732909f, -0.05219391f, -0.03979754f, -0.02148645f, -0.00836477f, 0.03115518f, -0.02290735f, 0.01378873f, 
    0.03692409f, 0.00634966f, -0.00129500f, -0.00548749f, 0.04188760f, 0.02517157f, 0.00798488f, 0.00032752f, 
    0.02340615f, 0.03802872f, -0.05012394f, -0.04889386f, 0.02060815f, 0.03534863f, 0.02771456f, 0.02740210f, 
    -0.00407812f, -0.02454984f, 0.01219943f, 0.04659948f, -0.04137146f, -0.01969869f, 0.04871648f, 0.04949696f, 
    0.03996588f, -0.00301774f, -0.04603513f, 0.02362135f, 0.03654724f, 0.04721287f, -0.05557127f, -0.01497490f, 
    -0.03870426f, -0.02859141f, -0.00892333f, -0.03974244f, -0.01835600f, -0.05281368f, 0.01645513f, 0.03848523f, 
    0.01050487f, -0.04945460f, 0.04798241f, 0.02624542f, 0.01444590f, 0.02528743f, 0.03761486f, 0.03416586f, 
    -0.02871106f, 0.00100950f, 0.05150131f, 0.00837171f, -0.03778782f, -0.01956546f, -0.01423988f, 0.01094934f, 
    -0.05170949f, 0.00300428f, 0.04031339f, -0.05368710f, -0.02763960f, 0.02557816f, 0.00672340f, -0.05024966f, 
    -0.04827512f, -0.04500025f, -0.05233248f, 0.02902480f, -0.03024184f, -0.02502068f, 0.03878934f, -0.00805080f, 
    0.03963367f, -0.00040542f, 0.04391710f, -0.03725795f, -0.01149195f, 0.01897266f, 0.00201996f, 0.03358948f, 
    0.03126161f, -0.04465394f, -0.01477278f, 0.00060196f, -0.00863669f, -0.01853203f, -0.04475180f, 0.05383403f, 
    0.01475528f, -0.00434748f, 0.04558067f, -0.01320951f, -0.05229080f, -0.06411512f, 0.01884436f, -0.04667427f, 
    0.00009051f, 0.00007394f, -0.05342046f, -0.01908107f, 0.02660347f, 0.04366141f, 0.03373251f, 0.02803856f, 
    -0.02737700f, -0.02102794f, -0.00420425f, 0.03068662f, -0.03479690f, -0.01743340f, -0.05529292f, -0.00373608f, 
    -0.00612124f, 0.01400055f, -0.04011547f, -0.01097546f, 0.04394517f, 0.02835228f, 0.00209996f, 0.03220828f, 
    0.02752117f, -0.05751639f, 0.03578137f, -0.02515164f, -0.00915440f, -0.00231135f, -0.02772622f, -0.06273063f, 
    0.02710003f, -0.01922337f, -0.04212831f, 0.04073552f, 0.05552617f, -0.04230794f, -0.00000352f, 0.01099610f, 
    -0.04800863f, 0.01416916f, -0.03976199f, 0.02182767f, 0.00292622f, 0.01155511f, 0.01698557f, -0.00057808f, 
    0.00994397f, -0.04166650f, 0.00135381f, 0.03655726f, -0.03321389f, 0.03013149f, -0.00766670f, 0.01967830f, 
    0.00530817f, -0.03969228f, -0.01608197f, -0.01310272f, 0.03778854f, 0.03355242f, 0.01721965f, 0.00990287f, 
    0.02924521f, -0.02344808f, -0.02653590f, 0.02517228f, -0.06010273f, 0.03169036f, -0.01926323f, -0.00250647f, 
    0.01798766f, -0.05607428f, -0.04281281f, -0.01338473f, 0.04266488f, -0.01067085f, 0.04748811f, -0.00519411f, 
    -0.03352344f, 0.03728878f, -0.05351127f, 0.01114025f, -0.05153922f, 0.02716702f, 0.01863590f, 0.04314386f, 
    0.03074271f, 0.03296911f, 0.01092772f, -0.05174799f, 0.01109452f, -0.02941844f, -0.00168722f, 0.04144435f, 
    -0.03261279f, -0.02787357f, -0.00983896f, 0.01010291f, 0.04661315f, -0.03691855f, 0.03278343f, 0.02842968f, 
    0.02886206f, 0.00046640f, 0.04929142f, 0.01783730f, 0.00127096f, -0.01658231f, 0.01076851f, 0.01312579f, 
    0.05210198f, -0.02660400f, -0.06058249f, -0.02171019f, -0.04477452f, -0.03824117f, 0.03473614f, -0.05924318f, 
    -0.04847632f, -0.04881361f, -0.06117209f, 0.04771635f, -0.04004699f, -0.02086792f, 0.02389671f, -0.04356455f, 
    0.00240214f, -0.04041197f, 0.04591002f, 0.00901838f, 0.04431589f, -0.01616150f, -0.03879332f, 0.02120083f, 
    0.03547482f, -0.05811707f, -0.00355372f, 0.03297515f, 0.02393290f, -0.03349141f, 0.03905693f, 0.00713149f, 
    -0.02339872f, -0.02866537f, -0.00755962f, 0.04210877f, -0.01014869f, 0.04526166f, 0.01327347f, -0.02462704f, 
    0.01507412f, -0.02678799f, 0.02673102f, -0.03423226f, 0.02163576f, 0.02121137f, -0.01723968f, -0.04923498f, 
    0.00716275f, -0.04296430f, 0.03264854f, 0.00810725f, 0.03143287f, -0.03599315f, -0.01058271f, -0.03520301f, 
    -0.00667800f, -0.04549891f, 0.03140127f, -0.00888298f, -0.02351526f, 0.04076163f, -0.05098077f, -0.00789270f, 
    0.01848360f, 0.05521127f, -0.03933581f, 0.00458133f, -0.00012219f, -0.04189110f, -0.02654188f, -0.03664543f, 
    0.01204965f, -0.01318402f, -0.00618596f, -0.01671918f, -0.00309902f, 0.01907451f, 0.00524204f, 0.03054624f, 
    -0.00302901f, -0.05568606f, 0.00046719f, -0.05633989f, -0.05187045f, -0.02872576f, -0.00491856f, 0.01480068f, 
    0.02182750f, -0.05340352f, 0.00263314f, 0.01925379f, 0.01555808f, -0.05385042f, -0.03837329f, 0.04695405f, 
    0.02562618f, 0.02691848f, -0.01013047f, -0.00095356f, 0.04843566f, 0.04809372f, -0.05809922f, -0.00324882f, 
    -0.00157179f, -0.04041887f, 0.04632120f, 0.01998660f, 0.03968603f, -0.00006092f, -0.02311727f, -0.00494276f, 
    -0.05228608f, -0.05226285f, -0.05014661f, -0.05118791f, -0.05103644f, -0.02800679f, -0.01502058f, -0.01922436f, 
    -0.03244924f, 0.04611093f, -0.03047860f, -0.00430529f, -0.00902263f, 0.00349223f, -0.00368454f, -0.05949760f, 
    -0.00718975f, 0.01464784f, -0.01341478f, 0.00923825f, -0.00002684f, -0.00543838f, -0.01068645f, -0.04849828f, 
    -0.05447442f, 0.04579727f, -0.01312976f, -0.03661592f, -0.05595399f, -0.04579531f, -0.04102613f, -0.05528879f, 
    0.00168031f, -0.02346036f, -0.00188044f, -0.00348865f, -0.04770212f, -0.00602786f, 0.00061806f, -0.01756019f, 
    -0.05894224f, -0.04498890f, -0.01097986f, -0.05981894f, -0.01790056f, -0.02608779f, 0.00766745f, -0.02573810f, 
    -0.05140285f, -0.00601556f, -0.02337279f, -0.05453801f, 0.00248545f, -0.05871372f, -0.01886450f, 0.03565584f, 
    0.04439534f, -0.05699758f, 0.00687363f, 0.03098406f, -0.02747108f, -0.01080379f, 0.03233919f, -0.02341658f, 
    0.01081095f, -0.03317582f, -0.00940237f, -0.03330544f, -0.03715691f, 0.01725572f, -0.03230107f, 0.01396546f, 
    0.00136677f, -0.02469997f, -0.02036489f, -0.04445577f, -0.00481079f, -0.01053805f, -0.03665006f, -0.04079003f, 
    -0.03482611f, -0.04626108f, -0.00744952f, -0.03520981f, -0.03484299f, -0.00994033f, -0.02362769f, -0.03841405f, 
    -0.05041027f, -0.03372921f, 0.01767686f, -0.04628764f, -0.04707885f, 0.04560672f, 0.05275362f, -0.05369332f, 
    -0.04021331f, 0.01726742f, 0.03096719f, -0.02064270f, 0.05028812f, 0.03754017f, -0.04277420f, -0.02939027f, 
    0.02396742f, 0.00700829f, 0.04799613f, -0.04886591f, -0.00379267f, -0.06017041f, 0.02500554f, 0.04313347f, 
    0.00330659f, 0.01615200f, 0.00070575f, -0.02689558f, -0.05324315f, 0.01055190f, 0.00539383f, -0.03499414f, 
    -0.00015580f, -0.02394167f, -0.03076089f, -0.04946787f, -0.04946310f, -0.04003954f, 0.02163403f, 0.00511848f, 
    -0.05664979f, 0.01687732f, -0.03716377f, 0.00440805f, -0.04392840f, 0.03376957f, 0.00501163f, 0.04676268f, 
    0.00824549f, -0.00606072f, -0.05285365f, -0.03134895f, -0.02952147f, 0.03678429f, 0.00827045f, -0.02980341f, 
    0.02910136f, -0.04102114f, -0.02196611f, -0.00928727f, -0.00871728f, 0.05242140f, -0.03068552f, -0.02674878f, 
    0.01853556f, 0.03321464f, -0.02488212f, -0.02392980f, -0.04160369f, -0.02569920f, -0.02840440f, 0.01501807f, 
    -0.00534661f, 0.04795242f, 0.03478036f, 0.01789850f, 0.01959410f, -0.01473602f, -0.03172089f, -0.00334238f, 
    -0.03336290f, 0.00002806f, 0.03002214f, -0.05655409f, -0.02032478f, -0.02308131f, 0.03335855f, 0.02076025f, 
    -0.03968303f, -0.04676452f, -0.05034712f, 0.03330793f, 0.04460040f, 0.00140075f, 0.01954981f, 0.00560571f, 
    0.01252960f, -0.05981187f, 0.00978188f, 0.03813324f, -0.04425573f, 0.00991428f, 0.03209675f, -0.01441367f, 
    -0.05425888f, -0.00823844f, 0.03807454f, -0.05503899f, 0.03534820f, -0.03121375f, 0.00951552f, 0.04436512f, 
    0.02356270f, 0.00902278f, 0.02338053f, -0.00821858f, 0.00565035f, 0.01561899f, -0.03875738f, -0.03809329f, 
    0.03311014f, 0.02362391f, 0.03648565f, -0.03962293f, 0.01988227f, -0.04100123f, -0.01484609f, -0.01243422f, 
    0.04685288f, 0.04867507f, -0.02942029f, 0.02458228f, -0.00035355f, -0.03311468f, 0.02015242f, -0.05188920f, 
    0.03143293f, 0.03789594f, -0.02425141f, -0.04957842f, 0.03842656f, 0.02599085f, 0.03852402f, -0.03092446f, 
    -0.00953266f, 0.01513653f, -0.05716489f, -0.04414194f, 0.03540795f, -0.04964228f, -0.02372052f, 0.01019740f, 
    -0.00589728f, -0.03515044f, 0.00535254f, 0.05090179f, 0.02356228f, 0.00426051f, 0.02233516f, 0.03727956f, 
    0.04890863f, 0.04757151f, 0.00771031f, 0.04668991f, -0.04133468f, 0.02883079f, -0.00931119f, 0.04873383f, 
    0.04027477f, -0.02462297f, 0.01193797f, 0.03123599f, -0.03740259f, -0.02166127f, -0.00054543f, 0.04475924f, 
    -0.00403336f, -0.04890873f, -0.03606544f, -0.05261194f, 0.00629996f, -0.06710270f, -0.02565352f, 0.01333830f, 
    0.02039683f, 0.01445016f, -0.02912838f, -0.02166284f, 0.04247614f, 0.02681211f, -0.05064048f, -0.03257003f, 
    0.04770590f, 0.01229529f, -0.02428737f, -0.02172248f, -0.03856259f, -0.05671404f, -0.01762883f, 0.04435353f, 
    0.04801282f, 0.01574328f, -0.03310075f, -0.06522823f, -0.05118465f, -0.00191487f, -0.05567013f, -0.03860391f, 
    -0.00189099f, -0.00749013f, 0.04306238f, -0.05448863f, 0.02343500f, -0.03339626f, -0.04370566f, -0.00579186f, 
    -0.06874113f, -0.02896953f, 0.04177564f, 0.00660061f, 0.02160853f, -0.05849422f, 0.03277451f, -0.04655602f, 
    -0.03463645f, 0.04834577f, 0.05148844f, -0.02169647f, -0.00350229f, 0.03922758f, -0.02384925f, -0.01789963f, 
    0.04030724f, -0.03313897f, -0.06062885f, 0.02975244f, 0.04015329f, -0.06410065f, 0.00197856f, 0.01226602f, 
    0.01308562f, -0.05660132f, -0.00770303f, 0.02015465f, 0.02578272f, 0.03400600f, 0.02127337f, 0.03392949f, 
    -0.00492999f, -0.05789141f, -0.05370404f, -0.02371587f, -0.06447720f, 0.04152769f, -0.02938182f, -0.03482203f, 
    0.01222394f, 0.02096062f, 0.02048868f, 0.03887159f, -0.04237760f, 0.01144180f, -0.00262329f, 0.01269706f, 
    0.03949053f, 0.03913282f, 0.01437501f, -0.01073556f, -0.01142430f, 0.01730813f, 0.01565115f, -0.00158440f, 
    -0.00655019f, 0.03172065f, 0.00942034f, 0.03185604f, 0.00486096f, -0.05625620f, -0.00421007f, 0.03093593f, 
    0.04479793f, -0.03303108f, -0.03226640f, -0.04287543f, -0.03951858f, 0.00081405f, 0.01119130f, -0.04845662f, 
    -0.03062447f, -0.01168708f, -0.03631447f, -0.05211964f, 0.04117068f, 0.02261784f, 0.01310520f, 0.01669930f, 
    -0.00765229f, -0.01308164f, -0.02076841f, 0.04794032f, -0.02076238f, 0.02166984f, 0.01695030f, 0.01726912f, 
    -0.00864594f, 0.02429016f, 0.02938246f, -0.04120276f, 0.01691465f, -0.01697582f, -0.05281820f, 0.02930257f, 
    0.00249086f, -0.02666477f, 0.03029728f, 0.00571909f, -0.00846133f, 0.01717398f, -0.01523141f, -0.05965050f, 
    0.00081443f, -0.03112140f, 0.04415091f, 0.03536716f, -0.00911084f, 0.03437570f, -0.01972555f, 0.04200343f, 
    0.04950787f, -0.05056162f, 0.04100508f, -0.05711525f, 0.02926692f, -0.05035190f, -0.01288429f, -0.03621271f, 
    -0.01400981f, -0.01312254f, -0.03263913f, 0.04260080f, -0.00605180f, -0.01989534f, 0.01806323f, -0.01072280f, 
    0.00656922f, -0.00772631f, 0.02242846f, -0.04368586f, 0.01262982f, 0.03329172f, -0.00313174f, 0.02882232f, 
    -0.00453188f, -0.02305802f, -0.01620612f, -0.01817741f, -0.02737665f, 0.04478779f, 0.03791804f, -0.00210699f, 
    -0.02092866f, -0.02597327f, -0.00898291f, 0.03427557f, -0.05672248f, 0.02203677f, 0.00852523f, -0.04096796f, 
    -0.04959221f, 0.03170381f, 0.00018555f, 0.03455678f, -0.02853568f, 0.00646923f, -0.05175727f, -0.03912834f, 
    0.00976690f, -0.03902948f, -0.01024066f, -0.03542409f, 0.00911148f, -0.03269653f, 0.02078581f, 0.02698732f, 
    -0.03452277f, 0.05936269f, 0.02236298f, 0.03636129f, 0.01047826f, -0.01970614f, 0.05496700f, -0.03941334f, 
    0.04264548f, 0.04452228f, -0.05682125f, 0.00204121f, 0.01774313f, -0.00863601f, -0.05568994f, -0.05669619f, 
    -0.01025361f, 0.00845277f, 0.03178485f, 0.04232605f, -0.00199879f, 0.01102870f, 0.03498517f, -0.00851569f, 
    0.03026978f, 0.04250634f, 0.01100362f, -0.00554770f, 0.03172869f, 0.00828192f, -0.01674763f, -0.05117437f, 
    -0.01342741f, -0.05204995f, -0.00991210f, -0.03506616f, -0.06416541f, -0.04773932f, -0.04157821f, -0.02233456f, 
    0.03719895f, -0.05080887f, 0.03310238f, 0.02325295f, -0.01755465f, 0.00269399f, 0.00885908f, -0.00610630f, 
    -0.00058063f, 0.04675015f, -0.03972903f, -0.06551123f, -0.01003263f, 0.02055383f, -0.00676856f, -0.01472642f, 
    0.01909778f, 0.00102037f, -0.01095462f, -0.03707975f, -0.01584333f, 0.00209251f, -0.03612488f, -0.04446622f, 
    0.02781728f, -0.00721356f, 0.01240302f, 0.00156880f, 0.01679254f, -0.04357807f, -0.05860947f, -0.03324003f, 
    0.02573333f, 0.03170747f, -0.03860309f, -0.04811734f, -0.05630008f, -0.00487342f, -0.00505297f, 0.03568262f, 
    0.00826402f, -0.05712763f, -0.05585219f, -0.04873919f, 0.01084757f, -0.05864635f, 0.00040850f, -0.01096718f, 
    -0.02999615f, -0.00627014f, 0.02919951f, -0.01929733f, 0.01487057f, -0.04166387f, 0.00198618f, -0.05888000f, 
    -0.04956106f, -0.01625073f, -0.00635540f, 0.01429372f, -0.03373588f, 0.01086840f, -0.02219475f, 0.01819863f, 
    -0.04603308f, -0.01371263f, 0.05151181f, 0.03187439f, -0.00941612f, 0.00965376f, 0.03324453f, -0.03737205f, 
    -0.01441439f, -0.02179387f, -0.03413459f, 0.04067447f, -0.00305539f, -0.04630852f, 0.04429970f, -0.06497335f, 
    -0.01275515f, -0.00183150f, -0.02458624f, 0.04005744f, 0.03684939f, 0.00756589f, -0.01800893f, -0.03550816f, 
    0.03597656f, -0.03399096f, 0.00024376f, -0.01783551f, -0.03025381f, 0.00884449f, 0.02001580f, 0.02558666f, 
    -0.00834495f, -0.05695260f, -0.06036625f, 0.01994585f, -0.02103483f, 0.01378701f, 0.02672171f, -0.02183765f, 
    0.00060392f, -0.03267803f, -0.03515957f, -0.02157122f, 0.00695051f, 0.00850094f, -0.04296602f, -0.05388527f, 
    -0.04954489f, -0.03811061f, 0.03246002f, -0.04378370f, -0.01005101f, -0.03888694f, -0.05964333f, -0.00664709f, 
    -0.00750214f, -0.04720480f, 0.01353719f, 0.00296740f, -0.06288467f, -0.02722616f, -0.04947878f, -0.06067953f, 
    0.03589815f, 0.00360035f, -0.00095493f, 0.01616873f, 0.01296121f, -0.01531469f, 0.02507352f, 0.02963674f, 
    -0.03449871f, 0.03738569f, 0.04103386f, -0.02409589f, -0.01812077f, 0.04017475f, 0.00342486f, 0.03802921f, 
    0.01502733f, -0.01201251f, 0.00038087f, 0.04047910f, 0.02768538f, 0.04837222f, 0.00603572f, -0.01422281f, 
    0.00594991f, 0.01043194f, 0.05210640f, -0.02275753f, 0.01854125f, 0.01202377f, -0.02178941f, -0.04265451f, 
    0.04600292f, -0.05351724f, 0.03077828f, 0.03863511f, -0.01718584f, -0.02366145f, -0.01098656f, 0.05066072f, 
    0.04953736f, 0.04086977f, -0.02014017f, -0.03976707f, -0.05312597f, 0.04362169f, 0.04239958f, 0.02475954f, 
    0.03117731f, -0.01546954f, -0.00950907f, -0.05659746f, -0.03548798f, -0.02533039f, 0.04371740f, -0.04279978f, 
    0.02412642f, 0.00700814f, -0.01721198f, -0.03707495f, -0.03878172f, 0.03852070f, -0.03711252f, -0.00251763f, 
    -0.00223903f, -0.06021513f, 0.04003357f, -0.03108720f, -0.05491650f, 0.03508785f, 0.00698366f, 0.03839893f, 
    0.01985593f, -0.00517280f, 0.02513202f, -0.04260959f, 0.03954974f, -0.01359919f, 0.00225426f, -0.03916391f, 
    -0.05946161f, -0.00449646f, -0.02427957f, -0.04312117f, 0.03558592f, -0.05701334f, -0.04112493f, 0.00897940f, 
    0.03492701f, -0.05023085f, -0.05065030f, 0.02203371f, -0.04440260f, 0.00795941f, 0.00405519f, -0.03738671f, 
    0.01747430f, 0.01723733f, -0.03583133f, 0.01282276f, -0.03713094f, -0.06030821f, -0.04089375f, 0.00233215f, 
    0.01757086f, -0.03586203f, -0.01349453f, 0.03923076f, -0.03584011f, -0.05378961f, -0.05397261f, 0.02132374f, 
    0.01487132f, -0.01350525f, 0.02550624f, -0.00879716f, 0.00960894f, 0.03518229f, -0.04541327f, -0.00009681f, 
    0.00645531f, -0.01916249f, 0.01949556f, 0.00656252f, 0.01983536f, -0.01343248f, 0.02598847f, 0.00753211f, 
    -0.00410098f, 0.02909954f, 0.05446443f, 0.04708679f, 0.01521413f, -0.04010493f, -0.05942333f, -0.03249685f, 
    -0.02426773f, -0.01384510f, -0.00091018f, -0.02568251f, -0.02833208f, -0.03763344f, 0.02710146f, 0.00156860f, 
    -0.01281236f, -0.03115012f, -0.04178848f, -0.01744553f, -0.04409513f, -0.03615746f, -0.00640795f, -0.05572813f, 
    0.01941290f, -0.01857154f, -0.02162888f, -0.04372225f, 0.02896539f, -0.02577434f, -0.05792509f, -0.02136105f, 
    -0.02054342f, 0.02822966f, -0.05932384f, -0.03895979f, 0.00713857f, -0.05558439f, -0.04073413f, 0.00494131f, 
    -0.01321527f, -0.03785674f, 0.02249451f, -0.00739055f, 0.04030448f, -0.04611811f, 0.01146219f, 0.01714140f, 
    -0.00386695f, -0.02019156f, -0.02406848f, 0.04118179f, -0.02172375f, -0.04444229f, -0.01671171f, -0.05962602f, 
    -0.02124383f, -0.00347207f, 0.02387933f, 0.02579558f, 0.04224772f, -0.02679357f, -0.01564408f, -0.03329802f, 
    -0.05596253f, 0.03434192f, -0.02965721f, -0.02714935f, 0.02902023f, 0.02814984f, 0.05162848f, -0.03952517f, 
    0.01399550f, -0.05450106f, -0.05083295f, 0.00006192f, 0.01506777f, 0.04171567f, -0.01140403f, 0.03117830f, 
    -0.00923433f, -0.01572876f, 0.02933458f, -0.00569191f, 0.01372765f, -0.01971549f, 0.02733185f, -0.01765277f, 
    -0.04652789f, -0.04038826f, 0.01050939f, -0.05544020f, -0.02947064f, -0.04988578f, -0.05460636f, 0.04091046f, 
    0.00928987f, -0.04184536f, -0.02620248f, -0.01370567f, -0.04377479f, 0.04932788f, -0.02118702f, -0.03845124f, 
    0.03057441f, 0.04740141f, -0.05519710f, 0.04859992f, 0.02348929f, 0.00717906f, 0.01430141f, -0.02551438f, 
    0.00064852f, -0.04991168f, -0.04812486f, -0.02603995f, -0.04081281f, -0.04016884f, -0.03318245f, -0.04113968f, 
    -0.00629471f, -0.05392293f, -0.04860483f, -0.01568940f, -0.02698125f, -0.01558966f, 0.01385586f, 0.01604901f, 
    0.02563544f, -0.04258858f, 0.00255037f, -0.00805996f, 0.04852105f, -0.00753864f, 0.04664471f, 0.04611399f, 
    0.04274483f, 0.01208218f, 0.02417695f, -0.04642476f, 0.04170498f, 0.01714820f, 0.03150671f, 0.03166342f, 
    -0.04882044f, -0.00457976f, -0.01734813f, -0.05019504f, 0.02774375f, -0.04476150f, 0.04403191f, -0.04746986f, 
    -0.04665032f, -0.04495176f, -0.04394285f, 0.02315796f, -0.01026379f, -0.03851239f, 0.04455324f, 0.00526114f, 
    -0.04495240f, -0.00993504f, 0.02260867f, 0.01258340f, 0.02352804f, -0.00906263f, 0.03136944f, 0.04639097f, 
    -0.00982196f, -0.01017169f, -0.04997402f, 0.02216737f, 0.00448500f, 0.01577856f, -0.01826306f, 0.04659577f, 
    -0.06043087f, 0.01092141f, -0.04368188f, 0.01349957f, 0.00403084f, -0.01012494f, 0.04059983f, 0.03732088f, 
    -0.02988035f, 0.04675151f, -0.02858099f, -0.03529687f, -0.00938827f, 0.01703207f, -0.00242330f, 0.02721941f, 
    -0.00421531f, -0.03805104f, 0.00709365f, -0.05158174f, -0.00544267f, 0.05039465f, -0.00151192f, 0.01100264f, 
    -0.05961444f, 0.02453447f, 0.03083950f, 0.00678177f, 0.03234021f, 0.01260509f, 0.03221279f, 0.04653325f, 
    0.01682285f, 0.03021857f, 0.04654500f, -0.04691336f, -0.00415310f, -0.03240089f, -0.03647365f, -0.00042019f, 
    -0.05196750f, -0.03509822f, 0.02305333f, -0.03876309f, 0.01884421f, 0.04996478f, -0.00499236f, 0.01697224f, 
    0.04637874f, -0.04580183f, -0.04113536f, 0.02841107f, 0.00129545f, 0.04313428f, 0.02596553f, -0.03588361f, 
    -0.01898159f, -0.02790836f, -0.01827576f, -0.00307135f, 0.03925161f, -0.05275363f, 0.03802690f, -0.05644531f, 
    -0.00214387f, 0.00524541f, 0.01022973f, -0.06051853f, 0.04661186f, 0.03330835f, -0.05029538f, -0.02853098f, 
    0.01889163f, -0.04412403f, -0.01038180f, -0.00587142f, -0.02398856f, -0.05578679f, -0.03713041f, -0.03519767f, 
    0.39245766f, 0.07693042f, 0.28033388f, 0.34328115f, 0.24395640f, -0.07321803f, 0.21629989f, -0.03611069f, 
    0.01870102f, 0.17775609f, -0.01793675f, -0.02428897f, -0.18280353f, 0.13394073f, -0.05705699f, 0.05937946f, 
    0.25770134f, 0.26763925f, 0.09845351f, -0.08757237f, 0.27717203f, -0.39559209f, 0.17046811f, 0.16298674f, 
    -0.06319535f, 0.11924532f, -0.12412500f, 0.00913549f, -0.01235291f, -0.05728045f, 0.15779507f, 0.07841915f, 
    -0.06070933f, 0.09400201f, 0.09203061f, -0.06553958f, 0.03477610f, 0.01130360f, 0.05941225f, 0.01263826f, 
    0.28452301f, 0.18043046f, 0.14824812f, 0.13862988f, 0.33017775f, 0.04773297f, 0.10322753f, 0.05771177f, 
    -0.01092916f, 0.09907033f, 0.01547816f, 0.12013356f, -0.01398338f, -0.04664545f, 0.08333272f, 0.18585758f, 
    0.16149291f, 0.04944195f, 0.20259775f, -0.09209834f, 0.19553351f, -0.22586335f, 0.22015956f, 0.29524580f, 
    0.19541775f, 0.04301550f, 0.04854565f, 0.06545690f, -0.21137099f, 0.04588335f, 0.07170843f, 0.03855759f, 
    0.03692986f, -0.02381841f, 0.18166982f, 0.13448244f, -0.04385731f, 0.12033254f, 0.02849793f, 0.20093076f, 
    -0.25424019f, 0.08461959f, -0.01968945f, -0.18732822f, -0.45414114f, 0.01564375f, 0.10310712f, -0.09446919f, 
    0.20077151f, 0.11939209f, 0.04005276f, -0.09454583f, -0.12685490f, 0.05044964f, 0.07243677f, 0.10102902f, 
    -0.09912531f, 0.03109702f, -0.05239408f, -0.12177702f, -0.17334802f, 0.02575416f, -0.07560395f, -0.08651392f, 
    0.04813757f, 0.08064152f, 0.14938791f, 0.01291132f, 0.02754591f, -0.02224891f, 0.06042802f, 0.04006429f, 
    0.07559677f, -0.12055211f, 0.03784142f, -0.02164224f, 0.01691392f, 0.14848922f, -0.06749677f, 0.01187862f, 
    0.16251501f, 0.35286641f, 0.07078637f, -0.02109715f, 0.05730391f, -0.07093508f, -0.06698748f, 0.15684155f, 
    0.02358236f, -0.28018865f, 0.00135971f, -0.00338245f, 0.13007435f, -0.21919453f, 0.02034838f, -0.05847298f, 
    -0.13674988f, 0.23661900f, 0.01410247f, 0.18784977f, 0.10151798f, -0.06420340f, 0.46125799f, -0.05830442f, 
    0.00802109f, -0.09692725f, -0.07651743f, -0.09708603f, 0.07052142f, 0.06101360f, -0.12232735f, 0.18037838f, 
    -0.15344568f, -0.18692476f, 0.13404873f, -0.03753169f, 0.04439294f, 0.07512368f, 0.06293103f, 0.12869030f, 
    0.48562256f, -0.15985377f, 0.05910661f, -0.23915644f, -0.42114758f, -0.00306122f, 0.15813830f, 0.00153690f, 
    0.12327489f, -0.17707284f, -0.10387359f, -0.06874625f, 0.12150272f, 0.16738674f, 0.03273943f, 0.06011084f, 
    -0.03738725f, 0.00249179f, -0.22793627f, 0.08998993f, -0.38161677f, 0.24942370f, -0.46452871f, -0.27222776f, 
    -0.08127259f, 0.24051926f, -0.04449811f, 0.04542844f, -0.09125154f, -0.08494786f, 0.01320275f, 0.07258070f, 
    0.09597939f, -0.11329906f, 0.10181291f, 0.03608017f, 0.06343705f, -0.01217752f, 0.08340716f, 0.07729643f, 
    -0.15911596f, -0.11915826f, 0.04392906f, -0.23286827f, 0.01648536f, -0.21538511f, -0.04031932f, -0.14951044f, 
    0.08290745f, -0.32288271f, -0.03350325f, 0.18049704f, 0.01735184f, 0.06657032f, -0.05549332f, -0.06778619f, 
    0.01925142f, -0.06536260f, 0.12607905f, -0.04949220f, -0.55344385f, 0.11944868f, 0.20322347f, 0.30977252f, 
    0.55666345f, 0.07293943f, 0.14733192f, 0.06384705f, 0.00916987f, 0.15349644f, 0.04715812f, -0.06796046f, 
    0.14242452f, 0.01859282f, -0.05826500f, 0.03562630f, 0.27846593f, -0.15598582f, -0.04382913f, 0.03475203f, 
    -0.44717517f, -0.14484882f, 0.01722217f, 0.00177960f, -0.43656588f, 0.06312916f, -0.03266971f, 0.10105345f, 
    -0.00417971f, -0.02002714f, 0.06498975f, -0.02563833f, -0.10527447f, 0.05496847f, 0.09473864f, 0.01904500f, 
    -0.00646991f, -0.13715656f, -0.06381503f, -0.07184810f, -0.53857726f, 0.23367183f, 0.09180629f, 0.38501605f, 
    0.33462656f, 0.07138690f, 0.19226727f, 0.20426732f, -0.02812412f, 0.01130500f, 0.09776895f, 0.02517409f, 
    0.09961130f, 0.06592783f, -0.11457448f, 0.33249000f, 0.02059046f, 0.21342221f, -0.13183461f, 0.15164527f, 
    0.12760079f, -0.36856100f, -0.10467872f, 0.21931766f, 0.23986812f, 0.12061214f, 0.12796105f, 0.13994332f, 
    0.19431050f, -0.06172272f, -0.27424133f, 0.12402099f, -0.01641149f, 0.15124781f, 0.10762547f, 0.09137332f, 
    -0.02881707f, 0.15102404f, 0.04370397f, 0.01570219f, -0.43353167f, -0.32397562f, 0.15801722f, 0.03860500f, 
    -0.39307952f, 0.07939883f, -0.04127428f, 0.06161045f, 0.12560216f, 0.03662577f, 0.07249880f, -0.06794806f, 
    0.05619147f, 0.03656962f, -0.00139331f, -0.05350273f, 0.02785221f, -0.05374084f, -0.01491989f, -0.11625139f, 
    -0.14722252f, -0.20453793f, 0.02952239f, 0.10062112f, 0.08351225f, -0.09609435f, 0.05533235f, 0.28085396f, 
    0.12076645f, 0.02649914f, 0.00348140f, 0.04926271f, -0.02573465f, 0.01115500f, 0.13058029f, -0.19801664f, 
    0.04091155f, -0.30987307f, -0.11230610f, -0.01425012f, -0.39952525f, -0.02901533f, -0.25915399f, -0.34240183f, 
    0.08148863f, -0.01490616f, 0.21199153f, -0.02094077f, 0.01902241f, -0.02176869f, -0.15205419f, 0.01521581f, 
    0.10652412f, -0.00520522f, 0.12563388f, 0.03805687f, -0.10381407f, 0.11208132f, -0.17921329f, 0.11904550f, 
    0.00448505f, -0.24905987f, 0.03183362f, -0.08790316f, -0.06593044f, -0.14818312f, 0.02876754f, 0.13261768f, 
    0.12020097f, 0.01511233f, -0.00195731f, -0.11500069f, 0.09130826f, 0.05956685f, 0.07581587f, -0.14737807f, 
    0.09589252f, -0.08362642f, -0.03783398f, 0.32387400f, -0.12184371f, -0.03844218f, -0.17842053f, -0.10853992f, 
    0.01021463f, -0.10890527f, -0.00366985f, 0.05910593f, 0.17672701f, 0.06880479f, 0.05960916f, 0.12352555f, 
    0.15262935f, 0.25428283f, 0.09535338f, 0.00933388f, 0.13757943f, -0.14908782f, 0.01446552f, 0.13501422f, 
    0.16343950f, 0.04359588f, 0.43087378f, -0.16079132f, -0.13750862f, 0.13114868f, -0.05226917f, -0.06954262f, 
    -0.15138158f, 0.19840513f, -0.05028893f, -0.03994756f, -0.02503946f, 0.12528129f, 0.21093391f, 0.02558733f, 
    0.00563384f, -0.12038994f, -0.02270390f, -0.01931782f, -0.15696104f, -0.21277183f, -0.22039744f, 0.19757247f, 
    -0.00755877f, 0.30752358f, -0.10395526f, -0.05667062f, 0.03092359f, 0.09408299f, 0.08167055f, -0.04554247f, 
    0.01488452f, -0.15673809f, 0.00624227f, 0.05558995f, -0.05137808f, 0.00856772f, -0.02346672f, -0.00874885f, 
    -0.11206269f, -0.19319434f, -0.56606567f, 0.16956349f, 0.29840493f, 0.17212947f, -0.08877006f, -0.00375069f, 
    -0.07283498f, 0.18654539f, 0.03663428f, -0.01966274f, 0.01442593f, -0.05201398f, -0.04000634f, 0.00964069f, 
    0.01225063f, -0.02120563f, -0.22201391f, -0.07147519f, 0.37205198f, -0.18455763f, 0.02414590f, -0.00716599f, 
    -0.36528960f, -0.24440220f, 0.17237616f, 0.15664659f, 0.12445993f, 0.05454733f, 0.24124570f, -0.13234973f, 
    0.11813992f, 0.09660813f, -0.02786237f, 0.06236206f, 0.06903999f, -0.07760181f, -0.12623113f, 0.00953719f, 
    -0.50042838f, -0.00515174f, -0.32769862f, 0.02107911f, -0.04048301f, 0.08560929f, 0.10678981f, 0.15141943f, 
    -0.03150810f, 0.03710025f, 0.16618247f, 0.22652125f, 0.04537412f, 0.01869250f, 0.01877797f, -0.03852723f, 
    -0.23392838f, 0.02171707f, -0.01799194f, -0.05638586f, 0.14621234f, 0.13692500f, -0.30345839f, 0.21837953f, 
    0.07091597f, -0.02888059f, 0.06003687f, 0.02056332f, 0.14152910f, 0.12494304f, -0.11221743f, 0.05923166f, 
    -0.07426321f, -0.00554082f, -0.07202604f, 0.13193975f, -0.00352833f, -0.01823163f, -0.01416849f, 0.09073845f, 
    0.24467860f, -0.12019971f, -0.26812512f, 0.23146237f, -0.00357346f, -0.00329789f, 0.03288847f, 0.06631493f, 
    0.09336863f, 0.01511160f, 0.03940438f, -0.13772874f, 0.03162806f, -0.12107780f, -0.07829784f, -0.02296771f, 
    0.11224494f, -0.09008196f, -0.15533492f, -0.06292268f, 0.03549739f, -0.28869835f, 0.34365857f, 0.15380968f, 
    -0.10282782f, 0.00232055f, 0.02051018f, -0.11208734f, -0.11647091f, -0.05928065f, -0.06962088f, 0.01552559f, 
    -0.17250277f, 0.14294425f, 0.12778728f, -0.02215668f, -0.11251245f, 0.14074984f, -0.10075817f, -0.09761811f, 
    0.19003150f, 0.33857179f, 0.11841362f, -0.16597025f, 0.01180188f, -0.03170112f, 0.23760407f, -0.01696345f, 
    0.03891282f, 0.14829989f, 0.12048761f, -0.03541809f, -0.01361618f, -0.00952541f, 0.04966054f, -0.00431600f, 
    -0.11927386f, 0.01480107f, 0.05633515f, 0.06295984f, -0.03497003f, 0.07839155f, 0.34815431f, -0.18150480f, 
    -0.21942158f, 0.19366658f, 0.02281518f, 0.15501603f, -0.01090413f, 0.01625225f, 0.01735862f, -0.03459551f, 
    -0.00801483f, -0.02153401f, 0.12210657f, -0.06740240f, 0.14865798f, 0.08471581f, -0.04344580f, 0.07758863f, 
    0.16089557f, -0.02862689f, 0.07380511f, 0.00877231f, -0.03206433f, 0.22882882f, 0.01780758f, 0.12976466f, 
    0.07688373f, 0.21683697f, 0.08952392f, -0.10995955f, 0.11400418f, -0.01858832f, -0.03137202f, 0.12331364f, 
    0.27914205f, -0.10730882f, 0.04512527f, 0.18961567f, -0.14568359f, -0.07479732f, 0.09317148f, -0.10275919f, 
    -0.00309984f, 0.18164842f, 0.25986135f, -0.06478272f, -0.02594130f, 0.09458768f, -0.11958240f, 0.17241614f, 
    0.03228920f, -0.08483186f, 0.15073651f, 0.04649108f, 0.00045843f, 0.05003593f, -0.03161485f, 0.07683425f, 
    0.44751659f, 0.15407437f, 0.14822945f, 0.20477492f, -0.03130288f, 0.11188120f, 0.05117412f, 0.09241591f, 
    -0.00130884f, 0.00820105f, -0.02163524f, 0.02682888f, 0.02560791f, 0.04117657f, 0.08318153f, -0.02925543f, 
    0.10767816f, -0.14233598f, -0.11329522f, 0.00569115f, -0.65832293f, 0.27150136f, -0.27939680f, -0.23634906f, 
    -0.11246030f, -0.00801723f, 0.10051553f, -0.00487062f, 0.09292436f, -0.08284555f, -0.06099530f, -0.05244913f, 
    0.06511217f, -0.01479596f, -0.00872973f, -0.01822628f, -0.01524639f, 0.07698908f, -0.14141051f, 0.06325199f, 
    0.23769872f, 0.48475322f, 0.10642345f, 0.28755954f, 0.00458008f, 0.17541377f, 0.03604394f, 0.08461022f, 
    -0.00828018f, 0.11534588f, -0.11868773f, 0.04101557f, 0.01386329f, 0.09457986f, -0.09841242f, 0.00794621f, 
    0.02021573f, 0.08234803f, 0.07022578f, 0.21594715f, -0.07124357f, -0.01205768f, -0.01737563f, 0.04353514f, 
    0.21003675f, -0.03922521f, 0.12244632f, 0.21169582f, 0.01471427f, 0.12912938f, 0.06799314f, 0.07834841f, 
    -0.00889014f, -0.07291392f, -0.14899164f, 0.00558882f, -0.14926420f, -0.12754087f, 0.16479954f, -0.00767954f, 
    -0.35684821f, -0.40451524f, 0.12247166f, 0.16727650f, 0.02774451f, 0.01626879f, -0.10518976f, 0.11265960f, 
    -0.01023886f, -0.05191676f, 0.11860834f, 0.04597984f, 0.02226011f, 0.13992496f, 0.00008646f, 0.07821385f, 
    0.03740128f, -0.11321740f, -0.06222259f, -0.10439302f, 0.25865805f, -0.14523748f, -0.09293500f, -0.01472998f, 
    -0.02957471f, 0.01544795f, 0.03275847f, 0.08689415f, 0.08653304f, -0.03616441f, 0.06370369f, -0.01147256f, 
    0.00823334f, 0.07039574f, 0.04446391f, 0.06637995f, 0.11151081f, -0.08055386f, 0.08036559f, 0.08807879f, 
    0.09451429f, 0.28324851f, -0.08175644f, 0.05421219f, -0.01083384f, 0.07509222f, -0.04237545f, -0.12027890f, 
    0.09673853f, 0.10545722f, 0.01821160f, -0.19634753f, -0.00803606f, -0.01811258f, 0.04310878f, 0.07816809f, 
    0.09681290f, -0.06883220f, 0.01592181f, 0.03522628f, -0.33438697f, 0.52234960f, -0.11596759f, 0.18728398f, 
    0.07280572f, 0.17872326f, 0.15559073f, 0.17681356f, 0.05151262f, -0.02056949f, 0.03014739f, 0.03347163f, 
    -0.08036888f, 0.24839075f, -0.00025625f, 0.11316891f, -0.07891238f, -0.10804051f, -0.14033622f, -0.02264615f, 
    -0.40287793f, 0.03656249f, -0.17903407f, -0.01059152f, -0.10151615f, -0.11365200f, -0.06554130f, 0.06322203f, 
    0.03277200f, -0.04929190f, 0.17164822f, 0.13586435f, -0.00013632f, -0.10556394f, 0.03510325f, 0.09078470f, 
    -0.06473913f, 0.02879346f, -0.04959148f, -0.03571713f, 0.24129301f, -0.37185630f, -0.03723406f, -0.01461963f, 
    -0.09408234f, 0.10543211f, -0.02147721f, -0.05698134f, 0.00360015f, 0.01707827f, 0.10230820f, -0.02701398f, 
    -0.01552904f, 0.11596173f, -0.06804940f, 0.06561869f, 0.04442202f, 0.00195109f, -0.02753395f, 0.03934817f, 
    0.06516164f, 0.26724058f, -0.31879100f, -0.09691076f, 0.07833055f, 0.02786878f, -0.07762872f, 0.15310988f, 
    -0.01834842f, 0.08225865f, 0.07765920f, 0.08211641f, -0.05902609f, 0.05675375f, 0.04998004f, 0.11482400f, 
    -0.13320747f, 0.04291247f, -0.06876821f, -0.09648030f, 0.41035679f, -0.46119249f, -0.04864785f, 0.08274346f, 
    0.17162871f, -0.07789713f, -0.07178314f, 0.13079643f, -0.04386647f, -0.06797399f, -0.03206260f, 0.04579144f, 
    -0.05936095f, -0.01628227f, -0.04206939f, 0.04984432f, 0.02264348f, 0.15181096f, -0.05426291f, 0.03508603f, 
    -0.21521862f, -0.10544714f, -0.01267888f, 0.17501852f, 0.01611697f, -0.10196283f, -0.07347693f, 0.02487916f, 
    0.04095078f, 0.09245997f, 0.03385868f, -0.08241223f, 0.11561628f, 0.00351448f, 0.22102270f, 0.01597755f, 
    0.02477688f, 0.10768714f, 0.06433214f, -0.04070781f, 0.10351960f, -0.43383873f, -0.03260184f, -0.05331062f, 
    -0.07294457f, -0.00929634f, -0.01995287f, 0.03329981f, -0.08633068f, 0.08214375f, 0.06374232f, -0.14147995f, 
    -0.05257155f, 0.07623140f, -0.06803472f, -0.06793211f, -0.08378350f, -0.04009078f, 0.09875387f, 0.02104288f, 
    -0.60765421f, -0.17518851f, 0.22741428f, 0.11146882f, 0.05812220f, -0.01284462f, 0.05813517f, -0.01373714f, 
    -0.02472367f, 0.16679746f, 0.14481078f, -0.01389944f, 0.04691250f, -0.11566906f, 0.17665035f, -0.00696965f, 
    0.09795259f, -0.11992216f, 0.12684180f, 0.01159439f, -0.01352957f, 0.12613061f, -0.19564414f, -0.11070223f, 
    -0.11650690f, -0.02921967f, 0.10311503f, -0.02736024f, -0.00317522f, 0.05027990f, 0.00599676f, 0.15124424f, 
    -0.02631197f, -0.00558770f, 0.13925411f, -0.09343996f, -0.04236890f, 0.20879774f, -0.02766963f, 0.03343837f, 
    0.13745531f, 0.27068189f, -0.24257722f, -0.25231704f, -0.00823533f, 0.14995724f, -0.03080660f, -0.10066943f, 
    0.09113265f, -0.12473147f, 0.12108812f, 0.08437229f, 0.06453651f, 0.03805684f, 0.00243809f, -0.01137385f, 
    0.10899507f, 0.09776082f, 0.03723921f, 0.08761577f, 0.33483171f, 0.06287789f, -0.33259177f, 0.07473959f, 
    0.17564403f, -0.04336463f, -0.04924424f, -0.09511937f, -0.01615667f, 0.15007932f, -0.05313686f, 0.10514198f, 
    -0.01804472f, -0.11110180f, 0.22123586f, -0.01235349f, 0.14175358f, 0.04446734f, -0.12174743f, 0.13357292f, 
    0.18835369f, 0.04499478f, 0.02114580f, -0.17613639f, 0.00145022f, -0.00853580f, -0.03158449f, 0.19908167f, 
    -0.01388039f, -0.07982798f, 0.21006401f, 0.07497226f, 0.13347577f, 0.03268331f, -0.11743357f, 0.18917900f, 
    -0.12537402f, -0.08948775f, 0.04668149f, 0.04657871f, -0.02323522f, 0.34834185f, -0.17242756f, 0.03981320f, 
    0.06873442f, -0.06589091f, 0.02947871f, 0.04753979f, 0.09172137f, -0.28390163f, 0.11853097f, 0.06842753f, 
    -0.16063237f, -0.11723454f, -0.13462633f, 0.00536309f, 0.02698274f, -0.11868396f, 0.10646426f, -0.09151443f, 
    -0.32141945f, 0.02003400f, -0.21419849f, -0.16245842f, -0.03145560f, 0.21101379f, 0.13429458f, -0.08178522f, 
    0.00909525f, -0.00715888f, 0.16183037f, 0.15355989f, 0.03649291f, -0.02337735f, -0.15155862f, 0.06175510f, 
    -0.05156671f, 0.02170621f, 0.10993174f, -0.09437310f, 0.43718579f, 0.11102327f, 0.22649200f, 0.11338416f, 
    -0.03806600f, -0.14735031f, 0.10629478f, 0.07231103f, -0.08603259f, -0.10404047f, 0.02152371f, -0.09230243f, 
    -0.00665563f, 0.05586552f, -0.01098931f, -0.06276371f, -0.14488427f, -0.00229255f, 0.03222013f, 0.00122424f, 
    0.47436470f, 0.30001971f, 0.15151726f, -0.10765292f, -0.01491643f, 0.03776629f, -0.00442581f, -0.02549207f, 
    -0.08686599f, -0.06398550f, 0.14421499f, 0.05866369f, 0.01743302f, -0.00236314f, -0.04896932f, -0.01376222f, 
    0.06150146f, 0.03143825f, 0.08668768f, -0.11385462f, -0.48568121f, -0.01856473f, 0.24237867f, 0.15878806f, 
    -0.25035295f, 0.22106865f, 0.04649430f, 0.10421673f, -0.09516279f, -0.06352959f, 0.03095475f, 0.09945935f, 
    -0.20126870f, 0.09584564f, -0.00577325f, 0.10983589f, 0.02257491f, -0.01362430f, -0.07690830f, -0.10878788f, 
    0.19789143f, -0.44552049f, -0.01067653f, 0.19428697f, 0.33605060f, -0.19886380f, -0.03780208f, 0.00305434f, 
    0.03697497f, 0.10504123f, -0.22398122f, 0.02833575f, 0.06398899f, 0.07403008f, 0.09703584f, -0.09806453f, 
    -0.05975862f, 0.08224680f, -0.08876917f, -0.04528292f, 0.24913907f, 0.14023705f, 0.50778890f, -0.18466650f, 
    0.38119352f, -0.09311253f, 0.15178226f, 0.05564709f, -0.25432986f, 0.19476086f, 0.00177211f, -0.09764007f, 
    0.08141067f, 0.05763803f, 0.05075107f, -0.05705189f, 0.05442355f, -0.09715981f, 0.01208440f, 0.00746672f, 
    -0.01073225f, -0.18989740f, 0.46283993f, 0.29237601f, 0.37639821f, -0.07261270f, -0.09968984f, 0.04961522f, 
    -0.00866768f, 0.01256273f, -0.04689563f, 0.01985192f, 0.16816202f, 0.00399995f, 0.02155484f, -0.02917406f, 
    -0.06586363f, -0.01306076f, 0.08691474f, 0.17049186f, -0.30737132f, 0.26870891f, -0.28482246f, 0.01050055f, 
    0.06811459f, 0.21126318f, 0.19563682f, 0.08002429f, -0.04807466f, -0.05457119f, 0.06072588f, 0.14038417f, 
    0.07877342f, 0.06130378f, -0.08596465f, 0.06464738f, 0.15534775f, 0.00958146f, 0.04433942f, -0.01790274f, 
    -0.33284622f, 0.02070967f, -0.16104017f, -0.17999491f, -0.19964501f, 0.05403269f, 0.15647669f, -0.12157542f, 
    0.04102902f, 0.10055206f, 0.05707319f, 0.07772326f, 0.03827145f, 0.02199733f, -0.03132114f, -0.15229301f, 
    -0.03416699f, -0.03691656f, 0.12571216f, -0.10470375f, -0.21598890f, 0.13196389f, -0.23661871f, 0.24043833f, 
    -0.49762347f, 0.04684211f, 0.17244492f, -0.01235053f, 0.00404041f, -0.04377909f, 0.17409033f, -0.03477557f, 
    -0.07500105f, -0.02312250f, 0.07966962f, 0.02170406f, 0.04863666f, -0.10115217f, 0.03593891f, -0.06264066f, 
    -0.46825206f, 0.15062246f, -0.08961484f, -0.05543498f, 0.48159862f, 0.00503853f, -0.14205910f, 0.00624372f, 
    -0.02132133f, -0.01154090f, 0.12064864f, 0.02745532f, 0.04741045f, 0.06467579f, 0.15078059f, -0.12470084f, 
    -0.00065355f, 0.08852950f, -0.01249262f, 0.08479339f, 0.29450947f, 0.09967061f, -0.39397183f, 0.04381033f, 
    -0.14767416f, -0.04767603f, 0.04817742f, -0.06432129f, 0.10402147f, 0.08199355f, 0.05781562f, -0.04813023f, 
    0.09746262f, -0.02769574f, -0.08221215f, 0.10632015f, 0.02173638f, 0.06845327f, -0.00025138f, 0.03608312f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04512629f, -0.03919566f, 0.03650751f, -0.03993984f, 0.00707819f, -0.06356548f, -0.00841037f, -0.04004828f, 
    0.05299700f, -0.04547475f, -0.04218047f, -0.04025656f, 0.03572673f, -0.04224636f, 0.02459544f, -0.11017631f, 
    -0.00789755f, -0.08114136f, 0.08351825f, -0.00660183f, 0.07428028f, 0.12208591f, -0.03674627f, -0.05374422f, 
    0.01757008f, -0.00972233f, -0.03121409f, 0.00297719f, 0.06496587f, 0.17366946f, 0.06363502f, -0.03008757f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13751602f, 0.03124810f, -0.36722964f, 0.14467958f, -0.11303268f, 0.12480094f, 0.17044447f, 0.07914970f, 
    -0.67842805f, -0.07452592f, -0.11908206f, 0.37927616f, 0.06681598f, -0.17042083f, -0.08159497f, 0.07510301f, 
    -0.11881346f, 0.54435670f, 0.33687463f, -0.09630542f, 0.20070480f, -0.27543145f, 0.11190838f, 0.14211610f, 
    0.02128996f, -0.12217835f, 0.06464431f, -0.07923763f, 0.24827617f, -0.30158865f, -0.31912714f, -0.63576549f, 
    0.33325815f, 0.13773702f, -0.40580949f, -0.09679344f, 0.14184509f, 0.09185407f, -0.13084310f, 0.10864167f, 
    -0.25777668f, 0.45237535f, 0.10244159f, -0.03152211f, 0.13646805f, -0.44449505f, -0.48403671f, 0.16544928f, 
    -0.04997829f, -0.19189833f, 0.17518829f, 0.07832260f, 0.25572181f, 0.12667003f, -0.14065741f, -0.08276080f, 
    -0.14669918f, 0.07276714f, 0.07734869f, -0.07459403f, -0.59723073f, 0.46279964f, 0.23599385f, -0.37546837f, 
    -0.11405992f, -0.02109291f, -0.32268587f, -0.01617307f, 0.16946721f, 0.40581766f, 0.02762724f, 0.16945207f, 
    0.46882847f, 0.47234678f, -0.06248149f, -0.81255460f, 0.02149680f, -0.22791560f, 0.29753089f, -0.00264013f, 
    -0.15747748f, 0.12928213f, 0.04140102f, 0.08254436f, -0.25411391f, -0.65966952f, 0.15042512f, 0.10441869f, 
    0.07789946f, -0.02739675f, -0.09595916f, -0.01988978f, -0.31777602f, -0.17159303f, 0.01085003f, 0.19137913f, 
    0.16094345f, 0.16704348f, 0.27291065f, 0.17479965f, 0.14839675f, -0.14548588f, -0.06944474f, -0.12356023f, 
    0.13012390f, -0.03313256f, 0.03467012f, 0.35787919f, 0.15772158f, -0.69035900f, 0.26953125f, 0.46426919f, 
    -0.15561578f, -0.25173011f, -0.57763571f, -0.07238534f, 0.02180941f, -0.06739746f, 0.15503320f, -0.00285218f, 
    -0.06143585f, 0.03863532f, -0.00082078f, 0.01778179f, 0.06053133f, -0.48005173f, 0.32171917f, -0.28499606f, 
    -0.02493800f, -0.15078710f, 0.52558178f, 0.05139196f, -0.14400111f, -0.06951468f, -0.02848232f, -0.07598945f, 
    0.38355726f, -0.61072510f, 0.15505213f, 0.05673799f, -0.17281152f, 0.28759262f, -0.17301649f, 0.25711921f, 
    -0.03855981f, 0.27539632f, 0.03962048f, 0.12242150f, -0.03091911f, -0.66747117f, -0.16300891f, -0.16940922f, 
    0.10253797f, -0.08290477f, 0.01730634f, -0.14502300f, -0.27253637f, 0.14284968f, 0.09936982f, 0.03388898f, 
    0.20395340f, -0.03868643f, -0.05839900f, -0.15629138f, -0.07603214f, -0.37393761f, -0.13598064f, 0.17552994f, 
    0.30603024f, 0.14735441f, 0.05000764f, 0.42322844f, 0.14954293f, 0.25650519f, -0.08038766f, -0.76670617f, 
    -0.04682219f, -0.03831337f, 0.20497537f, 0.09624591f, 0.12317927f, 0.07792228f, 0.01094247f, 0.05291779f, 
    0.13293822f, 0.07334311f, 0.05377727f, -0.03087950f, 0.18181072f, 0.15741061f, 0.01822516f, -0.53735822f, 
    -0.16959909f, -0.00749685f, -0.54076600f, -0.05869102f, -0.04519383f, 0.28133965f, -0.10192793f, -0.02009690f, 
    0.29028791f, -0.28638986f, 0.04374324f, -0.45453021f, -0.08995599f, 0.48029256f, -0.77333367f, 0.06892943f, 
    0.02219287f, -0.45058647f, -0.05939719f, -0.04263700f, -0.09722310f, 0.17109428f, -0.15716210f, -0.10036543f, 
    -0.13395140f, 0.11920891f, 0.12606043f, 0.03234817f, 0.44679052f, -0.21417023f, -0.03238227f, 0.27025327f, 
    -0.34889850f, 0.15018329f, 0.16331387f, -0.04009113f, -0.05174052f, -0.33522859f, -0.12994148f, -0.07768661f, 
    0.01002612f, 0.44267386f, -0.15885183f, 0.05238320f, -0.08797837f, 0.22946700f, 0.31468794f, 0.14526416f, 
    0.10983124f, 0.51149613f, -0.34611282f, -0.10608879f, -0.45690015f, 0.27105317f, -0.13446869f, -0.09169483f, 
    0.05579830f, -0.08957206f, -0.04022583f, -0.07169683f, -0.09986843f, -0.59410036f, -0.29989800f, 0.21570365f, 
    0.27747238f, -0.13316487f, -0.14394976f, 0.17161070f, -0.11653395f, 0.15197195f, -0.04627066f, 0.08233412f, 
    0.07935514f, -0.33997387f, -0.14212684f, -0.05222214f, 0.11373931f, -0.00131848f, 0.31431288f, -0.43652043f, 
    -0.00063196f, -0.37269050f, 0.31155446f, -0.04706237f, -0.13097638f, 0.33387786f, 0.14630486f, 0.13764000f, 
    0.02873367f, -0.08459745f, -0.12449269f, -0.01990713f, -0.85088670f, -0.58265382f, -0.49962541f, 0.44504198f, 
    -0.41806474f, 0.15722236f, 0.17273164f, 0.15025483f, -0.00313721f, 0.06377361f, 0.15102544f, -0.04737227f, 
    0.00645467f, -0.16507283f, -0.09723681f, -0.14581421f, 0.05043211f, -0.16456527f, 0.03232794f, 0.07650623f, 
    -0.04821668f, 0.37251246f, 0.27868059f, 0.03992147f, -1.07841146f, 0.34021616f, -0.16287588f, -0.04532759f, 
    0.02786575f, -0.01267077f, -0.09906298f, -0.05276178f, 0.26804850f, 0.44268766f, -0.62508601f, -0.24847488f, 
    0.41025639f, -0.00065477f, -0.12586574f, -0.16885115f, -0.09969853f, 0.07670581f, -0.00651465f, -0.12448361f, 
    -0.67160028f, -0.28253785f, -0.15050766f, -0.36423218f, -0.09874292f, -0.50245869f, 0.22013001f, -0.57931405f, 
    -0.07449109f, 0.39938751f, -0.51274413f, -0.12389348f, 0.20599492f, 0.21469815f, 0.11104099f, -0.12785743f, 
    -0.08564385f, 0.03065428f, 0.11766350f, 0.03366150f, 0.32846346f, 0.15973921f, 0.43904838f, 0.35307559f, 
    -0.30141914f, -0.05074299f, 0.42956886f, 0.15818033f, -0.16003488f, -0.42674595f, -0.05618544f, -0.01308766f, 
    -0.55403447f, 0.24988200f, 0.10696653f, -0.46170762f, 0.01827737f, 0.18704681f, 0.34152871f, 0.13063656f, 
    -0.03548370f, -0.84586823f, 0.19631675f, 0.01217749f, 0.43720582f, 0.10884645f, -0.01753674f, -0.14271264f, 
    0.16500342f, 0.11814741f, 0.13041252f, -0.16054739f, 0.18804944f, 0.18544848f, -0.20512368f, 0.11265613f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04031201f, 0.03442431f, 0.02632372f, -0.13786425f, -0.08977482f, 0.03730840f, 0.05960229f, -0.24641754f, 
    0.01836649f, 0.07442782f, 0.00866350f, 0.08361366f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
