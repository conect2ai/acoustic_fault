#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.61736453f, -0.46289027f, -0.12857340f, -0.14417355f, 0.06086592f, 0.60882926f, 0.22249991f, 0.02697695f, 
    -0.34232348f, -0.24820343f, -0.19357555f, -0.21281949f, 0.72083384f, -0.59974647f, -0.21266414f, -0.46916148f, 
    0.16502699f, 0.39585099f, -0.10312552f, -0.02099717f, 0.01679517f, 0.09114973f, -0.29997331f, 0.21887620f, 
    -0.02946229f, 0.32378614f, -0.56440306f, 0.09232619f, 0.25485778f, 0.08404882f, 0.37091264f, -0.38490042f, 
    0.20800230f, -0.04093323f, 0.16789447f, -0.08470973f, 0.09270985f, -0.02790324f, -0.45201203f, 0.46941045f, 
    0.02549198f, -0.20870848f, -0.15766929f, -0.00469790f, -0.08541724f, -0.09833335f, -0.22601636f, 0.17269142f, 
    0.31901634f, 0.38972855f, -0.74667275f, -0.45919392f, -0.80403399f, -0.61940229f, -0.84162360f, 0.60720390f, 
    0.28142372f, 0.31067580f, 0.12142878f, 0.26166296f, 0.21977222f, 0.49850857f, -0.18576436f, -0.00324227f, 
    -0.10325792f, -0.06895687f, 0.37449959f, -0.12120143f, -0.29889458f, -0.12293394f, -0.17488047f, -0.14348020f, 
    -0.23093577f, 0.12045573f, -0.14974047f, -0.73389912f, -0.27745822f, -0.56607962f, -0.34730995f, -0.49285084f, 
    -0.07288559f, 0.48870310f, 0.74023354f, -0.43500125f, -0.39220566f, 0.20197776f, -0.01798443f, -0.21356064f, 
    -0.44503257f, -0.06958351f, 0.26054734f, 0.06434737f, -0.14051194f, -0.03047937f, -0.31061661f, 0.16766515f, 
    -0.00045983f, -0.01419766f, -0.00818095f, 0.03968631f, -0.46273914f, 0.23951301f, 0.69385976f, -0.22825427f, 
    -0.21845345f, -0.15785192f, -0.06598068f, 0.15650001f, -0.22632781f, -0.08352011f, 0.01465712f, -0.28551635f, 
    -0.19215079f, -0.06584848f, 0.44901720f, -0.12283345f, 0.21478643f, -0.03644651f, -0.05820844f, -0.47987828f, 
    0.03041650f, -0.05196555f, -0.18855721f, -0.42202204f, -0.58075589f, -0.23200616f, 0.23166472f, -0.12027539f, 
    -0.98181999f, 0.87439686f, 0.47067145f, -0.03099393f, -0.39251024f, -0.58442324f, -0.67683905f, 0.14368927f, 
    0.49301121f, 0.27086431f, 0.18212274f, -0.16422598f, -0.41914678f, -0.00426184f, 0.01501750f, 0.11480238f, 
    0.10401940f, 0.17034265f, 0.07985530f, -0.52150905f, -0.10797998f, 0.17052130f, 0.39120501f, -0.51751953f, 
    -0.08821044f, 0.91252351f, -0.58643210f, -0.39482814f, 0.14819771f, -0.40130231f, -0.17849940f, -0.21038865f, 
    -0.16791391f, 0.23387380f, 0.31926593f, -0.30995798f, 0.45752305f, -0.10819431f, 0.31156659f, -0.13311827f, 
    0.12007375f, -0.14023302f, -0.20326999f, -0.16003156f, 0.05038849f, -0.18665215f, -0.09280299f, 0.00909747f, 
    0.34166712f, -0.41130343f, -0.59476656f, -0.48918641f, -0.37255350f, -0.11495966f, 0.34688985f, -0.09628934f, 
    0.07413902f, 0.00917162f, 0.47383881f, 0.32688347f, 0.46457452f, -0.04632831f, -0.09629434f, 0.16078542f, 
    -0.46337393f, -0.23112163f, -0.05479002f, 0.29523501f, -0.16698691f, -0.00098784f, 0.12897085f, 0.15856357f, 
    -0.60852557f, -0.47079727f, -0.40318397f, -0.76503658f, -0.46767190f, 0.35181886f, 0.05262965f, 0.11351867f, 
    0.46827817f, -0.01177949f, -0.51460439f, -0.34324533f, -0.20726307f, 0.38099530f, -0.50944352f, -0.01002199f, 
    -0.04751495f, 0.08923987f, 0.41768935f, -0.04049250f, -0.19403040f, -0.06490333f, 0.05129722f, -0.25807470f, 
    -0.25878897f, 0.05729847f, 0.12806572f, 0.10298701f, -0.38622338f, 0.33540159f, -0.10995155f, 0.47686493f, 
    -0.60750872f, -0.05208014f, 0.12828974f, 0.45026663f, -0.35281697f, -0.05076043f, 0.08825041f, 0.20857149f, 
    0.40286535f, -0.26277849f, -0.04058997f, 0.21135715f, -0.31843224f, -0.21134999f, 0.32651865f, -0.07332949f, 
    0.25710064f, -0.23288356f, -0.16409609f, 0.28659192f, -0.25175801f, 0.27162138f, 0.49043176f, -0.10413448f, 
    0.38398799f, -0.33597815f, -0.06378081f, 0.02067783f, -0.19949770f, 0.07056222f, -0.05577751f, -0.03820020f, 
    0.09930713f, 0.23397531f, -0.33908695f, -0.28822568f, 0.03941057f, 0.23677109f, -0.25337067f, 0.04286984f, 
    0.34022135f, -0.30674264f, -0.17802070f, -0.28110680f, -0.01373933f, -0.26093492f, -0.55839711f, -0.27398777f, 
    -0.05934689f, -0.26850143f, -0.04355694f, 0.15557377f, 0.06090900f, -0.31347641f, -0.42024848f, -0.13460279f, 
    -0.33650416f, -0.13212596f, 0.05000750f, 0.12370740f, 0.03397550f, 0.30784458f, 0.14023329f, 0.08605065f, 
    0.52001208f, 0.35831946f, 0.15584816f, 0.35219145f, -0.00131788f, 0.15581688f, 0.04810224f, 0.32077035f, 
    -0.04834079f, 0.24191865f, 0.07108119f, -0.05383313f, 0.06831903f, 0.32223818f, 0.01472197f, 0.22213441f, 
    0.22123152f, 0.09647305f, 0.26578501f, -0.10824183f, 0.05086436f, 0.15413710f, 0.12436586f, -0.03732150f, 
    0.09900431f, 0.15245239f, 0.32464564f, 0.41224590f, -0.21720143f, -0.12231664f, 0.24363995f, -0.28522727f, 
    -0.35388106f, -0.01823429f, -0.61925179f, -0.47652867f, -0.40470973f, -0.59782225f, -0.54094481f, 0.17401174f, 
    0.55517018f, -0.03254703f, 0.63364530f, -0.17989260f, 0.20674771f, -0.37504804f, -0.13655369f, -0.15969233f, 
    -0.51917791f, -0.20144683f, 0.03384999f, 0.05696520f, 0.09280650f, -0.46877316f, 0.75216925f, -0.45277700f, 
    -0.04252711f, 0.02275120f, 0.25659132f, 0.52269566f, 0.05877610f, 0.40765965f, -0.19524270f, -0.00913785f, 
    -0.43680915f, 0.51866156f, 0.07402054f, -0.32139596f, -0.04153966f, -0.18992980f, 0.09992898f, 0.23541468f, 
    -0.23668672f, 0.08050211f, 0.13479947f, -0.17064728f, 0.18888532f, -0.14329626f, -0.02724151f, -1.09584212f, 
    -0.04677563f, -0.10176495f, 0.19374537f, 0.49540508f, 0.23449031f, 0.08204062f, -0.28432399f, -0.12322543f, 
    0.40720180f, -0.18928997f, 0.17551397f, -0.59563136f, 0.12371909f, -0.62070316f, 0.31653452f, 0.39544746f, 
    0.31330276f, 0.16695109f, -0.17891897f, -0.07953719f, 0.05643795f, -0.11927091f, -0.25329030f, -0.03308549f, 
    -0.74810177f, -0.77037984f, 0.64635962f, 0.20650584f, 0.77096432f, -0.90264827f, -0.31041491f, 0.10245062f, 
    0.60251069f, 0.23829699f, 0.25946683f, 0.01320080f, 0.19800144f, -0.02585466f, 0.20600687f, -0.04040708f, 
    -0.17025493f, -0.10464589f, -0.33420250f, -0.22711426f, 0.10060193f, -0.04135487f, 0.03378718f, 0.10609954f, 
    0.14320771f, 0.04021808f, -0.72785503f, -0.03433662f, -0.48956117f, -0.40076190f, -0.17060325f, -0.24806918f, 
    -0.39059186f, -0.22548057f, -0.13111466f, -0.09760789f, -0.35931134f, 0.10840210f, 0.26435345f, 0.64772701f, 
    -0.13938636f, 0.09874343f, -0.17132887f, -0.45308372f, -0.05157642f, 0.26011640f, -0.18168095f, 0.36181584f, 
    -0.02231093f, -0.31798106f, -0.56799513f, -0.25715947f, -0.30359274f, 0.04477185f, 0.07169122f, -0.08359545f, 
    -0.31801456f, -0.35490280f, -0.32437804f, -0.59235322f, 0.54796851f, -0.32762703f, 0.12696061f, 0.35878244f, 
    -0.23219322f, -0.26322067f, 0.21859241f, -0.30182180f, -0.20544729f, -0.24305613f, -0.19142322f, 0.35012779f, 
    0.39251944f, 0.20108211f, 0.17931986f, -0.97561902f, -0.51489902f, -0.33322284f, 0.08637841f, 0.13806267f, 
    0.57532716f, 0.35696387f, -0.28403065f, -0.57452548f, -0.28276855f, -0.49883893f, -0.07221004f, -0.23599339f, 
    -0.28024849f, -0.33289027f, -0.07087675f, -0.38117233f, -0.37746075f, 0.19303301f, -0.06179608f, 0.17024617f, 
    -0.00549231f, -0.13708732f, 0.15343252f, -0.33005589f, 0.85503429f, 0.83960807f, -0.24498963f, -0.90266293f, 
    -0.50635993f, 0.31964707f, 0.09979853f, 0.34114680f, -0.38896969f, 0.06868350f, -0.52261436f, 0.02631414f, 
    0.29778963f, -0.03195524f, 0.11809254f, 0.11614538f, -0.00591484f, 0.11410452f, -0.30442652f, -0.01103754f, 
    0.20025994f, -0.00401312f, -0.13779975f, -0.02381440f, -0.07133428f, 0.17141435f, 0.03108768f, 0.14882457f, 
    0.09307827f, -0.65279019f, -0.23745461f, -0.34073132f, -0.53812623f, -0.44456673f, -0.47353795f, 0.34831232f, 
    -0.13834302f, -0.22823060f, -0.36685240f, -0.20608640f, 0.22370353f, 0.44955641f, 0.38580796f, 0.20925741f, 
    0.07797255f, -0.19274060f, -0.17179570f, -0.16809610f, -0.15646230f, 0.11414639f, 0.27668521f, -0.55866385f, 
    -0.37662461f, -0.27286112f, -0.32081199f, -0.06084494f, 0.22508362f, -0.28764626f, -0.14018370f, 0.45480072f, 
    -0.35944027f, -0.46552557f, -0.18745056f, -0.04111693f, 0.49437404f, -0.03869689f, 0.04370785f, -0.01807200f, 
    0.26014289f, -0.33133423f, -0.24636751f, -0.21624121f, -0.10838318f, -0.44918880f, -0.28798470f, -0.85211754f, 
    -0.27881041f, 0.31530479f, 0.36442360f, -0.30776194f, 0.16726537f, 0.41758284f, -0.21683548f, -0.15103963f, 
    -0.29799312f, -0.09262404f, 0.02230939f, 0.63112688f, -0.41741276f, -0.27483410f, 0.52416241f, -0.21907820f, 
    0.17371957f, -0.38215721f, -0.20763712f, 0.16167267f, 0.14118861f, -0.15853167f, -0.18823543f, 0.22481734f, 
    -0.15993649f, 0.09879764f, 0.18151253f, 0.23265034f, 0.34177208f, -0.15427558f, -0.39441982f, 0.05844686f, 
    0.22197804f, 0.05401886f, 0.11363662f, -0.25681233f, 0.08993430f, 0.40343654f, -0.31711808f, -0.08552925f, 
    0.36567351f, -0.15517655f, -0.35588109f, -0.37992212f, 0.15076298f, 0.25183821f, -0.10618974f, 0.29427794f, 
    0.24444574f, 0.21939535f, -0.31726772f, -0.07863028f, 0.12718824f, 0.04121982f, 0.90227449f, -0.39420748f, 
    0.27406853f, -0.10758410f, 0.17927843f, -0.00807770f, 0.25703996f, -0.28579330f, -0.09507328f, 0.16622289f, 
    -0.00827144f, -0.38962662f, 0.02906973f, 0.19038248f, -0.02049600f, 0.00026446f, 0.26971334f, -0.12302867f, 
    -0.14245594f, -0.07448281f, 0.71594989f, 0.85409486f, 0.55533689f, -0.10999937f, -0.11517828f, -0.63931632f, 
    -0.54902768f, -0.14206189f, 0.38757709f, -0.67107916f, -0.23800136f, -0.01507763f, 0.11359394f, 0.27399895f, 
    -0.00233300f, 0.23188886f, -0.13544045f, 0.12426668f, 0.02712035f, 0.04374914f, -0.07760222f, 0.27477032f, 
    0.05323623f, 0.20825672f, -0.15232153f, 0.67042321f, 0.48726884f, 0.14702666f, -0.27923587f, 0.08909284f, 
    -0.09055708f, 0.16510758f, -0.15571645f, -0.18682469f, 0.25237244f, 0.04411835f, -0.08683363f, -0.23032165f, 
    -0.34832186f, 0.21208912f, -0.15087634f, 0.01975564f, 0.12579586f, -0.21376945f, 0.08059853f, -0.20607276f, 
    -0.30593300f, -0.54407692f, -0.30041042f, -0.54415679f, -0.55740285f, -0.32432991f, 0.52309096f, -0.20583445f, 
    0.21065658f, -0.37510827f, -0.57397234f, -0.31831121f, -0.11172591f, 0.25763112f, -0.04502361f, -0.21584724f, 
    0.19781092f, 0.31871867f, 0.09406283f, 0.04979014f, -0.11398451f, -0.01162001f, -0.03467209f, -0.08335004f, 
    -0.28066263f, 0.08911577f, -0.18666522f, -0.14186147f, -0.33046955f, -0.27983406f, 0.16563766f, -0.18400294f, 
    -0.12547511f, 0.07568550f, 0.50604945f, -0.08974146f, -0.10682137f, -0.32049319f, -0.02804502f, -0.21795830f, 
    -0.41135779f, -0.26527750f, 0.59407902f, 0.27303764f, -0.18573888f, -0.24241118f, -0.09729252f, 0.12629476f, 
    -0.09309714f, 0.18416043f, -0.37475216f, -0.31578434f, 0.32463557f, 0.43817872f, -0.36272937f, -0.93747526f, 
    -0.27587798f, 0.60990524f, 0.65703803f, 0.12764300f, 0.34274298f, -0.62275934f, -0.67816252f, -0.40814352f, 
    -0.05226056f, -0.28129852f, 0.32134712f, 0.02035690f, 0.33256930f, -0.17618732f, -0.25856945f, -0.06825268f, 
    -0.04268733f, -0.18296237f, 0.44316670f, -0.17986484f, -0.10829107f, -0.07704089f, 0.02457810f, -0.98612213f, 
    -0.49304223f, -0.29163474f, 0.37521061f, 0.48899293f, 0.66278708f, 0.13527264f, 0.45837823f, 0.49882084f, 
    0.40221411f, 0.04132859f, -0.19378725f, 0.12245957f, 0.40387401f, 0.01199959f, -0.11705840f, -0.09158299f, 
    -0.12483402f, -0.29771087f, -0.37082714f, 0.32005703f, -0.27803835f, 0.14276761f, 0.28084806f, -0.19869439f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.40453792f, 0.31327283f, 0.14029288f, -0.03068702f, 0.01254946f, 0.24614373f, 0.14981459f, 0.32212806f, 
    -0.28041098f, 0.06503213f, 0.23683800f, -0.34149697f, -0.22425340f, 0.00504826f, 0.39827350f, 0.16917162f, 
    0.32764709f, -0.23106146f, 0.08418605f, 0.00960160f, 0.33822119f, -0.05172757f, 0.05414064f, 0.27298456f, 
    0.28159532f, 0.32448813f, 0.29535902f, -0.08818425f, 0.01509581f, 0.31819639f, 0.01167567f, 0.07878495f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18694369f, 0.11499755f, -0.03596991f, 0.31932813f, -0.05386186f, -0.13397270f, -0.08289871f, 0.07758783f, 
    0.18795395f, 0.19536768f, 0.12454842f, 0.14198935f, -0.06873924f, 0.18540080f, -0.22000183f, 0.33383411f, 
    -0.08765858f, -0.07610247f, 0.01392878f, 0.02988238f, 0.11358307f, 0.09515765f, 0.09270521f, 0.26005477f, 
    0.05146246f, 0.07540371f, 0.03733066f, -0.02124526f, 0.08435363f, 0.11147677f, 0.04165890f, 0.00250526f, 
    0.07307449f, 0.08500951f, -0.14216286f, -0.04599675f, 0.11392103f, 0.08022007f, 0.22973560f, 0.04556024f, 
    -0.05285061f, 0.23368673f, 0.08268856f, -0.07924917f, -0.04230904f, -0.11776983f, -0.14942664f, -0.08684536f, 
    -0.03133293f, -0.07107223f, 0.20897628f, -0.23109853f, 0.10818097f, 0.03059364f, 0.11862174f, 0.02912767f, 
    -0.04895221f, 0.10930480f, -0.12515229f, -0.18062100f, 0.27155343f, -0.12128554f, -0.01155520f, -0.05207163f, 
    -0.03360705f, -0.21935937f, 0.07390314f, 0.25635761f, 0.03888438f, -0.05512217f, 0.03290506f, 0.09324029f, 
    -0.12667955f, 0.13957815f, -0.04061774f, -0.03659894f, -0.02177230f, 0.13406047f, 0.10816079f, -0.06009525f, 
    0.21876264f, -0.00966074f, 0.07546220f, -0.00332290f, 0.04937341f, -0.45436686f, -0.00438218f, -0.09590447f, 
    -0.09012450f, 0.10634397f, 0.16298589f, -0.10111657f, 0.06309875f, -0.10440277f, -0.07885008f, 0.09953482f, 
    0.14303389f, 0.41579467f, 0.09602556f, 0.08646785f, 0.00540131f, 0.04658965f, 0.09222104f, -0.08568408f, 
    -0.00316917f, 0.00278800f, 0.06220394f, 0.02104418f, 0.05978270f, -0.02225899f, -0.01422380f, 0.05090901f, 
    -0.13382456f, 0.00298629f, -0.06603031f, 0.19272695f, 0.01564745f, 0.11010399f, 0.35707307f, 0.03941473f, 
    0.10955431f, 0.21287252f, -0.14050131f, 0.19084448f, 0.03247288f, 0.09768872f, 0.03325524f, -0.01200522f, 
    -0.14491826f, 0.09622481f, 0.13582407f, -0.10742947f, 0.02727999f, 0.25193214f, 0.17684527f, 0.25669947f, 
    0.04717305f, 0.06559268f, -0.22484243f, -0.03227065f, -0.11071025f, -0.09104602f, -0.11648043f, -0.11902077f, 
    -0.14325589f, -0.02118159f, -0.08372658f, -0.03553142f, -0.02506930f, -0.03775882f, -0.00745441f, 0.02871382f, 
    -0.03710370f, 0.15740551f, 0.10321016f, 0.00615421f, -0.15397932f, -0.60029477f, -0.23144238f, -0.24237084f, 
    0.03853340f, 0.10489884f, -0.03488496f, 0.09884153f, -0.02161080f, -0.04026429f, -0.04738094f, 0.18206291f, 
    0.20284800f, -0.07678953f, -0.10486425f, 0.17685249f, -0.15821338f, -0.07309657f, -0.07638460f, 0.09422714f, 
    0.02620623f, 0.19846885f, 0.03693793f, 0.19269651f, -0.30319884f, 0.23798758f, -0.06341550f, 0.00534471f, 
    0.13558774f, 0.09336860f, 0.11843427f, -0.07953016f, 0.05275954f, -0.04369341f, -0.04494542f, 0.14445613f, 
    0.03673826f, 0.15423736f, -0.25553906f, -0.09827431f, -0.13416207f, 0.07158113f, -0.07633857f, 0.08479821f, 
    0.08201928f, 0.19315368f, 0.15554403f, 0.03966337f, -0.21831454f, -0.09231371f, 0.13536085f, -0.23783557f, 
    0.10884187f, -0.12673555f, 0.00110541f, -0.10030479f, -0.07797576f, 0.01040771f, 0.00967393f, -0.05426958f, 
    -0.23703595f, -0.06045899f, -0.16480502f, -0.04208310f, 0.11346187f, -0.05641044f, 0.22905175f, 0.01735349f, 
    -0.22416396f, -0.08345011f, -0.06517404f, 0.04080959f, 0.22600672f, 0.02056558f, 0.07924020f, 0.24403556f, 
    -0.07735249f, -0.10688624f, 0.28503096f, -0.04366249f, 0.07071279f, -0.06081778f, -0.16048731f, 0.02451142f, 
    0.32734910f, -0.44815919f, 0.39433128f, -0.11778262f, -0.03691202f, -0.08589675f, 0.05179571f, 0.04405995f, 
    -0.06667499f, 0.21226399f, 0.05478207f, 0.02673030f, -0.20071155f, -0.12523641f, -0.12866697f, -0.37726608f, 
    0.03530909f, -0.03280609f, -0.10771713f, -0.11971736f, 0.10722139f, -0.04765456f, -0.10474449f, -0.02651306f, 
    -0.10261941f, 0.16189837f, -0.03180165f, 0.15710926f, 0.16312635f, 0.13954969f, -0.02998818f, 0.09930392f, 
    0.19487448f, 0.22297545f, 0.10927890f, -0.12332074f, 0.12634897f, -0.10942764f, 0.04708016f, 0.10387932f, 
    0.01963485f, 0.16192596f, 0.19733641f, 0.05221897f, 0.00917694f, -0.00777278f, 0.07224596f, 0.14297681f, 
    -0.16490352f, -0.03314105f, -0.04827034f, -0.10977119f, 0.00444097f, 0.03499435f, 0.14240800f, 0.05217230f, 
    0.01112908f, 0.13578942f, 0.08190309f, 0.14122687f, -0.08602401f, 0.19028144f, -0.17921548f, 0.15152323f, 
    0.00621629f, -0.03308335f, 0.04706015f, 0.05527171f, 0.11259380f, 0.20664707f, 0.25060046f, 0.23642227f, 
    0.11693691f, -0.20881535f, 0.32062203f, -0.13218480f, -0.07057542f, -0.03638895f, 0.01293768f, -0.05486411f, 
    -0.13330682f, -0.00777660f, -0.02189035f, 0.19110598f, 0.00203201f, -0.05206705f, -0.01336716f, -0.09531091f, 
    -0.03483520f, -0.00973003f, -0.26977450f, 0.02049309f, -0.31735399f, -0.05493302f, -0.28263307f, -0.09897422f, 
    0.08043287f, 0.05328393f, -0.13677445f, 0.02769335f, 0.03850212f, -0.04742549f, 0.12245645f, 0.07439326f, 
    0.07304207f, -0.02414590f, -0.00391224f, -0.09709864f, -0.09861212f, -0.09211471f, 0.00026647f, 0.12467550f, 
    0.28756422f, -0.01575311f, 0.03516208f, -0.09878523f, 0.38329837f, 0.01842385f, 0.24368307f, 0.15563196f, 
    -0.13209543f, 0.21345147f, -0.26551887f, 0.06194399f, -0.09949718f, 0.02212951f, 0.03326008f, -0.15030330f, 
    -0.06760334f, -0.12179592f, -0.00922008f, 0.07905533f, -0.61865211f, -0.39055425f, -0.05130360f, 0.10865062f, 
    -0.07377926f, 0.03090203f, 0.11390623f, 0.10484068f, 0.04165281f, -0.10314417f, 0.13734695f, 0.10835733f, 
    -0.03352097f, -0.01082762f, -0.04471885f, -0.01201816f, 0.00030866f, -0.05658953f, -0.03093222f, -0.05134497f, 
    0.02342079f, -0.03811599f, 0.01533388f, 0.01273962f, -0.02738586f, -0.00384057f, 0.01584930f, 0.00643532f, 
    0.02044219f, -0.03305660f, 0.03269035f, 0.00258875f, 0.04489398f, -0.04065547f, -0.03323061f, -0.04008694f, 
    0.03814592f, -0.05609420f, -0.04103875f, -0.03082336f, 0.00098532f, 0.01986485f, 0.03117041f, 0.00196596f, 
    -0.04460118f, 0.01787072f, -0.04666127f, -0.00591536f, -0.03940247f, -0.01626894f, -0.02767586f, 0.04480113f, 
    0.02061526f, 0.00649324f, 0.00835157f, -0.04741869f, -0.01065401f, 0.03539735f, -0.01427029f, -0.00502681f, 
    0.02168414f, 0.01400477f, -0.04032541f, 0.00991028f, -0.04864131f, -0.05534654f, -0.01380054f, -0.01951756f, 
    -0.02832775f, -0.02329493f, -0.03161368f, 0.02098899f, -0.00946293f, 0.01739935f, 0.04129958f, 0.00088139f, 
    -0.01440645f, -0.01017236f, -0.04874258f, -0.01565806f, 0.00824883f, 0.03660470f, -0.00083612f, 0.02526381f, 
    0.03863184f, 0.00745880f, -0.01057301f, -0.04658807f, 0.03289287f, -0.04298195f, -0.03325575f, 0.03545823f, 
    0.04397489f, 0.04030398f, 0.03139721f, -0.00496952f, -0.05379925f, -0.03319740f, -0.01948695f, -0.00720318f, 
    0.04178392f, 0.00644818f, 0.02568396f, 0.04021929f, -0.04819207f, -0.04262180f, -0.01392805f, -0.04950315f, 
    0.02768679f, 0.03492571f, 0.01664093f, -0.01312570f, -0.01738746f, 0.02731056f, -0.01316719f, -0.01054936f, 
    0.02616566f, -0.04725556f, 0.02619268f, 0.00471659f, 0.03281192f, -0.04776702f, -0.04403475f, 0.02383405f, 
    -0.04894213f, -0.00595700f, -0.01909285f, 0.02470234f, 0.02891730f, -0.05201286f, -0.05608983f, 0.03261758f, 
    0.01953557f, 0.02364022f, 0.04317592f, 0.00725372f, -0.00847697f, -0.05703377f, 0.01670943f, -0.02197777f, 
    0.01534213f, 0.02609843f, 0.01753134f, -0.05552287f, -0.01936163f, -0.04886983f, -0.04557086f, -0.00443169f, 
    0.02114805f, 0.01823832f, -0.01199013f, 0.04072622f, 0.03272416f, -0.03174722f, 0.01846504f, -0.02477401f, 
    0.02924387f, 0.02724017f, 0.03975548f, -0.01318343f, 0.02095387f, -0.00603380f, -0.02985490f, 0.01089114f, 
    -0.05369877f, 0.01769534f, 0.00474620f, -0.05441042f, 0.03186622f, -0.01582787f, -0.03285602f, -0.02323076f, 
    -0.00427954f, -0.02509573f, -0.05314181f, -0.04329022f, 0.04129588f, -0.03083183f, 0.03871881f, -0.03955631f, 
    -0.04449892f, -0.00295519f, -0.01527019f, -0.00221859f, -0.03193708f, -0.03641755f, -0.05545319f, -0.00120799f, 
    -0.05371807f, 0.01975079f, -0.02074427f, 0.04363037f, 0.02687314f, -0.03942974f, 0.03555018f, -0.05450583f, 
    -0.03804075f, 0.02769200f, -0.00617364f, -0.00364494f, 0.01649665f, -0.01044669f, 0.04318222f, -0.00853171f, 
    0.02900678f, 0.03560759f, 0.03228909f, -0.04576310f, -0.03049074f, -0.02378108f, -0.03306556f, 0.00625863f, 
    0.04117584f, 0.02660018f, 0.02044531f, -0.00416083f, 0.00288846f, -0.01335991f, 0.04074012f, -0.04214153f, 
    0.01920803f, -0.02911983f, 0.03866275f, -0.00432829f, -0.05459558f, 0.04308625f, -0.05053757f, -0.03596535f, 
    0.00589616f, 0.02638607f, -0.01255184f, -0.02944625f, -0.03728165f, -0.04167269f, 0.01173677f, 0.04456653f, 
    -0.01857478f, -0.05280647f, -0.01294618f, 0.04055913f, -0.05042829f, -0.00883514f, -0.04893639f, 0.00600410f, 
    -0.01813887f, -0.04119582f, -0.04328252f, -0.05074605f, 0.02073862f, -0.04782752f, -0.01586899f, -0.04696484f, 
    -0.02736942f, -0.02728927f, 0.01729925f, -0.02690704f, -0.02702679f, -0.05542660f, 0.02658973f, 0.02257960f, 
    -0.01893737f, -0.05193028f, -0.05574741f, 0.02961976f, -0.03612301f, -0.03339012f, 0.03813843f, -0.04676703f, 
    0.04072393f, 0.01386458f, -0.00807759f, -0.01800120f, -0.04298669f, -0.01226428f, -0.02916554f, 0.04162944f, 
    0.01831833f, -0.00686795f, 0.00697437f, 0.04450306f, -0.04304535f, -0.02723219f, -0.05378627f, -0.00881990f, 
    0.02218669f, 0.04190233f, 0.01933481f, -0.02280674f, 0.01305729f, 0.04407677f, -0.04865623f, -0.01738030f, 
    -0.01582067f, 0.01334700f, -0.04366045f, -0.04864303f, -0.05542326f, -0.00156467f, -0.04891677f, -0.01392524f, 
    0.02176904f, 0.00151407f, -0.00653421f, 0.00542559f, 0.02530801f, -0.01768382f, -0.02553980f, 0.00164839f, 
    0.02710035f, -0.02945313f, -0.00843396f, 0.01497000f, -0.00293446f, 0.00594374f, 0.03188404f, -0.00055691f, 
    0.03874670f, -0.02061965f, -0.03957422f, -0.01223209f, -0.00240552f, -0.03234798f, 0.00741856f, 0.01092653f, 
    0.00164529f, -0.01056090f, 0.01475221f, 0.03340079f, -0.02791942f, -0.03085193f, -0.04242849f, -0.00471349f, 
    -0.04809318f, -0.01472434f, 0.00741760f, -0.03967623f, 0.04158711f, -0.00059214f, 0.02608803f, -0.01005474f, 
    0.03368424f, 0.04262838f, -0.04722297f, 0.01835787f, -0.04238591f, -0.05122034f, -0.01267519f, 0.03055384f, 
    -0.05245082f, -0.00017766f, 0.03111757f, -0.04416678f, -0.03792434f, 0.00239141f, -0.00609423f, -0.00211399f, 
    -0.00030047f, -0.05463482f, -0.00637518f, -0.01160227f, 0.01073872f, -0.02353469f, 0.03668202f, 0.01427819f, 
    0.03319324f, -0.02191887f, -0.00095880f, -0.01178949f, 0.00198170f, 0.03294577f, 0.00057695f, -0.01319520f, 
    -0.03571863f, -0.02077834f, 0.02831892f, 0.01007312f, -0.00571796f, -0.00120622f, -0.05339846f, -0.03046451f, 
    0.03487425f, -0.01117986f, 0.03189010f, -0.03902875f, -0.03113314f, 0.01427055f, -0.05216520f, -0.04041174f, 
    -0.01973963f, 0.03602974f, -0.01199325f, -0.00888523f, -0.01327428f, 0.01251906f, -0.02197980f, -0.01084655f, 
    -0.04274647f, -0.55065864f, 0.31780633f, -0.06127580f, -0.12388080f, -0.05741571f, 0.12467019f, 0.07562120f, 
    -0.04905502f, 0.01830869f, -0.12707929f, 0.01927230f, -0.10209846f, -0.05169976f, -0.14857885f, 0.05398911f, 
    0.10744344f, -0.03941464f, 0.06103851f, 0.01645516f, -0.15459757f, -0.08779236f, -0.02608978f, -0.10034370f, 
    0.19732185f, 0.20340054f, 0.19631290f, -0.01279882f, 0.03094279f, -0.09702655f, 0.03331050f, -0.02693211f, 
    -0.06116250f, -0.09769119f, 0.07642711f, 0.00273951f, -0.03085699f, -0.08946776f, 0.07887926f, -0.00120791f, 
    -0.07633805f, 0.01528991f, -0.09195466f, 0.09820633f, -0.14305252f, -0.09937834f, 0.02119030f, -0.01023531f, 
    -0.10228077f, 0.09703356f, -0.31314090f, 0.10525887f, 0.00310068f, -0.14626049f, 0.05482261f, -0.01919273f, 
    0.08074048f, -0.09001697f, 0.17777088f, 0.20465992f, 0.11337232f, -0.16288903f, -0.08768309f, 0.11489078f, 
    -0.09794185f, 0.04132555f, 0.09933009f, -0.13661267f, 0.12695087f, 0.18757412f, 0.01852896f, -0.18056345f, 
    0.13438688f, 0.19113256f, 0.21964359f, -0.12685433f, 0.05741457f, -0.04254236f, 0.08482616f, 0.09468801f, 
    0.02725332f, -0.08523560f, 0.08741451f, 0.00286466f, 0.04466774f, 0.18748011f, 0.19219899f, -0.11508081f, 
    -0.00081755f, 0.03143080f, -0.07234867f, 0.00908395f, -0.06733347f, -0.06998989f, 0.06385884f, -0.11409032f, 
    -0.29674801f, -0.02652537f, 0.00395316f, 0.03241450f, 0.01526044f, -0.09705848f, -0.07739840f, -0.01623342f, 
    -0.01260700f, -0.03245211f, -0.01526037f, 0.10538054f, 0.04128911f, 0.06159120f, -0.14323097f, 0.22309506f, 
    0.18761365f, 0.03034024f, -0.00795452f, 0.04158553f, 0.03787900f, 0.03096393f, -0.20703799f, -0.02717791f, 
    -0.10307451f, -0.13572644f, 0.12898166f, 0.00727893f, -0.06137724f, 0.09762056f, -0.13686886f, -0.06637245f, 
    0.08139215f, 0.08063520f, 0.05294094f, 0.24421783f, -0.11030519f, 0.03510268f, 0.07286515f, 0.04470260f, 
    -0.05858848f, -0.15313697f, 0.00722188f, 0.00496705f, -0.08353506f, -0.12879401f, -0.10648503f, -0.12843961f, 
    0.05119223f, 0.15504661f, -0.04660994f, 0.03043281f, 0.17399752f, 0.12060452f, 0.08285425f, 0.01205972f, 
    0.10543764f, 0.04838121f, -0.14115445f, 0.04109262f, -0.00524359f, 0.18260482f, 0.18634111f, 0.10782114f, 
    -0.06042514f, -0.00849043f, 0.05144958f, -0.03326425f, 0.06933562f, 0.13654740f, -0.02364706f, 0.05063583f, 
    -0.08978176f, -0.09474634f, -0.08369979f, -0.07743218f, 0.01351108f, 0.00904263f, -0.06000178f, -0.00584656f, 
    0.04553843f, -0.01440137f, -0.00288471f, 0.00204640f, 0.00885734f, -0.17494163f, 0.09122065f, 0.33470452f, 
    -0.14759926f, 0.03162098f, -0.05733149f, -0.06448431f, 0.13192576f, -0.06108968f, -0.02008775f, -0.14859197f, 
    -0.40280724f, 0.11943179f, 0.09433987f, 0.09444370f, 0.04708159f, -0.06830304f, 0.14511256f, -0.26491144f, 
    0.02651455f, -0.03744239f, 0.17978372f, 0.12435273f, -0.02195950f, 0.15806334f, 0.04382125f, 0.07979640f, 
    -0.16469198f, -0.08357973f, -0.08991497f, 0.01036161f, 0.11734735f, -0.09401657f, 0.07125022f, 0.15348482f, 
    0.06199868f, 0.14096507f, 0.04813156f, 0.16785949f, -0.09946202f, -0.04488831f, -0.05597476f, -0.02022057f, 
    0.02006746f, -0.02649330f, -0.01574145f, 0.10390057f, -0.17306805f, -0.26588038f, 0.02382902f, 0.13599028f, 
    -0.05418099f, 0.08047916f, -0.17781712f, -0.08002481f, 0.11895792f, 0.01813581f, 0.03301371f, 0.17499779f, 
    -0.19885643f, -0.03334743f, 0.05763797f, -0.35322434f, -0.14403912f, 0.06582318f, -0.09673616f, -0.10085338f, 
    -0.04647047f, 0.09066425f, 0.03522855f, 0.11359049f, 0.14014870f, 0.15514752f, 0.00338167f, 0.08666258f, 
    0.00667203f, 0.08476494f, -0.07290463f, 0.10141061f, 0.01255400f, -0.02952168f, -0.05907185f, -0.14614961f, 
    -0.04123027f, 0.07693337f, -0.07454451f, 0.00817412f, -0.02210959f, 0.06497736f, -0.00212885f, 0.03484424f, 
    0.09026708f, 0.14867800f, 0.06052845f, 0.17814618f, 0.03719400f, -0.01335145f, -0.00003034f, 0.20220789f, 
    -0.23698910f, 0.15855262f, 0.00005796f, -0.08836059f, 0.02340826f, -0.06823734f, -0.01169530f, -0.07306794f, 
    -0.11767194f, 0.02269192f, -0.16916457f, 0.15517728f, 0.11940724f, 0.01357177f, -0.11636472f, 0.08629745f, 
    -0.01513725f, -0.15752950f, -0.10154354f, -0.33992174f, 0.02295362f, 0.05355518f, -0.01618747f, 0.20455830f, 
    0.03416679f, -0.04855580f, 0.03735854f, -0.07700790f, 0.06128980f, 0.00732132f, -0.07131290f, -0.05649419f, 
    0.26135102f, 0.21125905f, -0.28632054f, 0.04227993f, 0.21869895f, 0.19326711f, 0.01419252f, 0.09934674f, 
    -0.09895030f, -0.06090174f, -0.11668915f, -0.10101566f, 0.11505903f, 0.17685525f, -0.28223270f, -0.09499776f, 
    -0.02845924f, 0.07775947f, 0.12686945f, -0.17567180f, -0.00814086f, 0.08583796f, 0.15831956f, 0.24550638f, 
    -0.16726506f, 0.03015761f, -0.05981858f, -0.00592215f, -0.08227948f, -0.02969451f, 0.08827815f, 0.02587687f, 
    0.07378581f, 0.09994040f, 0.02338313f, 0.20165697f, 0.02727273f, -0.16166911f, 0.01459560f, 0.20468751f, 
    -0.06461542f, 0.11767632f, -0.15593205f, 0.07096610f, 0.02715855f, 0.10916337f, -0.09703091f, -0.02559517f, 
    -0.07142562f, -0.32656887f, 0.06962010f, 0.10405257f, -0.06110260f, 0.03788028f, -0.01853535f, -0.07594772f, 
    0.10410416f, 0.03199854f, -0.04741248f, 0.06462064f, 0.08421225f, 0.17004684f, -0.02618036f, 0.52065873f, 
    -0.01879065f, -0.11507016f, -0.07183465f, 0.03114931f, 0.19535945f, 0.05180785f, -0.09399430f, -0.00298722f, 
    -0.02903328f, 0.24140915f, -0.03372693f, 0.02397806f, -0.03516490f, 0.04002919f, -0.07799638f, 0.00553902f, 
    -0.06451666f, 0.28440565f, -0.06611427f, 0.06852745f, -0.08966818f, -0.06565864f, 0.09421594f, 0.09496270f, 
    0.16118422f, -0.18232033f, -0.12307969f, 0.02584139f, 0.01433339f, -0.05057874f, -0.21009503f, 0.06878246f, 
    -0.50885963f, 0.11836527f, -0.40613431f, -0.17040971f, 0.05932825f, 0.15402566f, 0.01341097f, -0.06778265f, 
    -0.07382037f, 0.00477425f, 0.06131129f, 0.00985865f, -0.06781641f, 0.27227148f, -0.02677604f, -0.04757355f, 
    0.12616375f, 0.11617149f, 0.17127560f, 0.05772518f, -0.02767598f, -0.00984586f, 0.09884523f, 0.03948642f, 
    -0.02868973f, 0.14103635f, 0.09807108f, 0.16021927f, 0.17121211f, 0.25979844f, -0.20486845f, 0.22497299f, 
    0.11693656f, 0.30759284f, 0.11847246f, -0.25306323f, -0.07349996f, 0.29666686f, 0.18994489f, -0.22808722f, 
    -0.25088346f, 0.30574301f, 0.19141833f, -0.03942225f, 0.10731598f, -0.00355129f, -0.05405290f, 0.12892421f, 
    0.21023703f, -0.07600103f, -0.14853647f, 0.33898166f, -0.01435992f, -0.12375950f, 0.15351614f, 0.08617981f, 
    -0.07620768f, -0.01210582f, 0.00432039f, 0.22768173f, 0.23798199f, 0.06817127f, 0.01185986f, 0.00436978f, 
    0.03158777f, -0.05107177f, 0.01637084f, 0.12578954f, 0.03252558f, 0.17712952f, -0.08540636f, 0.11474232f, 
    0.30376536f, -0.09809956f, -0.04666189f, -0.10457737f, 0.19611092f, 0.05856455f, 0.10869862f, 0.00626932f, 
    0.02689927f, 0.07196142f, 0.13174093f, 0.17681766f, -0.13864014f, 0.10979468f, -0.22671661f, -0.02186704f, 
    -0.06680468f, -0.16491300f, 0.02121406f, 0.04688231f, 0.20002760f, -0.04276998f, 0.22142541f, 0.00870548f, 
    -0.15213276f, 0.30044955f, -0.00974391f, 0.28316298f, 0.02847111f, -0.05714215f, -0.07903039f, 0.08155207f, 
    0.09451502f, -0.04459893f, 0.04504761f, -0.06534375f, 0.13454862f, 0.02740658f, 0.03697678f, -0.18355328f, 
    0.01752607f, -0.03580429f, -0.00023167f, -0.06478797f, -0.01320811f, -0.03257618f, 0.00369577f, -0.04984057f, 
    -0.12606266f, -0.05776452f, -0.13832833f, -0.02950377f, -0.05463888f, 0.01962722f, -0.06970105f, -0.08729617f, 
    0.15341727f, 0.16866639f, -0.09083126f, -0.11032379f, 0.08324523f, 0.02748078f, 0.04620627f, -0.23144482f, 
    -0.04954641f, -0.02299380f, 0.03314641f, -0.00970839f, -0.09175429f, 0.10933850f, 0.12513661f, 0.06715005f, 
    -0.03271207f, -0.02559452f, -0.29555693f, 0.02485747f, 0.00215584f, 0.15138149f, -0.06161152f, 0.02870738f, 
    -0.11707786f, 0.00784860f, -0.02252887f, 0.02027990f, -0.23697512f, 0.29584283f, 0.17862247f, 0.03994966f, 
    0.15070462f, -0.03724940f, 0.33184943f, 0.03732350f, -0.10969594f, 0.12879725f, 0.26742181f, 0.06184828f, 
    0.20234153f, -0.34084243f, 0.21295421f, 0.33260909f, 0.13448453f, -0.24596156f, -0.07322954f, 0.06988115f, 
    0.14724277f, 0.16302961f, 0.15141571f, -0.08348601f, 0.05339689f, -0.08135259f, 0.10860340f, 0.05767867f, 
    0.24109809f, -0.05166811f, 0.17625670f, 0.03392255f, 0.25080511f, -0.02850218f, -0.08428346f, 0.01124542f, 
    0.06470340f, 0.02606975f, 0.08989634f, 0.01377056f, -0.13425687f, 0.04782692f, 0.05191923f, 0.03664175f, 
    0.14744751f, -0.00559809f, -0.05012608f, -0.09916357f, -0.34646595f, 0.37033799f, 0.03228167f, -0.01935584f, 
    -0.01333088f, 0.05515039f, 0.22222422f, -0.12834448f, 0.05331235f, 0.10655311f, 0.05662699f, 0.06151567f, 
    0.05763047f, -0.17921211f, 0.15357724f, -0.31124103f, 0.02938656f, 0.25823620f, 0.00785499f, 0.03975684f, 
    0.01693477f, 0.08320706f, 0.04998047f, 0.06133287f, -0.01098004f, 0.15318474f, 0.31967500f, 0.07768720f, 
    -0.22304626f, -0.18101695f, 0.12149758f, 0.10936777f, -0.02669429f, -0.09606727f, 0.07397587f, 0.04012378f, 
    0.03851855f, -0.08015451f, -0.07298741f, 0.09876660f, -0.03545902f, -0.08980235f, 0.04371929f, 0.25552452f, 
    0.19870450f, -0.08656640f, 0.21886845f, 0.05833408f, -0.39338908f, 0.07071071f, -0.14639932f, 0.23040135f, 
    0.18481612f, 0.03129676f, 0.10962652f, 0.24117674f, 0.04140657f, 0.28296536f, 0.03533382f, 0.02036282f, 
    0.02114617f, -0.12720667f, 0.13541459f, -0.05962446f, 0.02305928f, -0.13926838f, -0.06504582f, -0.00628161f, 
    0.00452038f, 0.08077365f, 0.00170716f, -0.00025986f, -0.21672849f, -0.01043105f, -0.20207590f, -0.12400557f, 
    0.04659727f, 0.17509818f, -0.03658579f, -0.01922778f, 0.20887305f, 0.02552775f, 0.18511538f, 0.17280123f, 
    0.48394743f, -0.30128786f, 0.26786324f, 0.09491260f, 0.36104563f, 0.09404740f, -0.14679077f, 0.02845189f, 
    -0.11363980f, 0.01714870f, -0.02626313f, 0.07006690f, 0.01976357f, -0.03399021f, -0.07454116f, 0.11940537f, 
    0.02836711f, 0.07312902f, -0.07400469f, 0.06328846f, -0.04690935f, 0.06348616f, -0.09907076f, -0.30433869f, 
    -0.04954858f, -0.10338444f, 0.28075024f, -0.07910019f, 0.06198553f, -0.08579029f, -0.06645736f, 0.16836913f, 
    0.26786187f, 0.16199276f, 0.07835511f, 0.09434088f, 0.04684047f, 0.07393831f, 0.28360531f, -0.09063897f, 
    0.16919307f, -0.22317003f, 0.03229641f, 0.09673052f, 0.11601590f, -0.16078348f, -0.02172424f, 0.42133284f, 
    0.03299375f, 0.20915879f, -0.06805196f, 0.02423974f, -0.06987801f, -0.10702618f, 0.16748500f, 0.06756381f, 
    0.03139466f, -0.01454073f, 0.09310362f, 0.08747981f, -0.81238669f, -0.37252945f, -0.06242407f, 0.25701466f, 
    0.17194788f, -0.12760086f, -0.07656118f, -0.09996208f, 0.07289315f, -0.04079655f, 0.19258097f, 0.18483014f, 
    -0.36654344f, 0.23818240f, 0.19005975f, -0.16709518f, -0.08802000f, 0.06269410f, -0.00241161f, -0.00288985f, 
    -0.13737969f, 0.02458971f, 0.00675595f, 0.02732025f, -0.24827231f, 0.10692257f, -0.03052135f, -0.18333559f, 
    0.05064500f, 0.01228246f, -0.02409738f, 0.08078718f, -0.28225160f, -0.00293473f, -0.11046340f, -0.20298406f, 
    0.04141054f, 0.02048542f, 0.24963307f, 0.22033317f, -0.06786027f, -0.15455179f, 0.04971647f, 0.00607367f, 
    -0.05035670f, 0.04034241f, -0.10787595f, 0.05588090f, 0.06787198f, -0.10532966f, 0.09041575f, 0.08355314f, 
    0.01449671f, -0.17653061f, 0.04446391f, 0.00104991f, -0.07093047f, -0.05936190f, 0.17732263f, -0.08517788f, 
    0.20424257f, -0.00892605f, -0.12443428f, -0.01628321f, 0.03822072f, -0.01674135f, -0.03605526f, 0.05800871f, 
    0.13314128f, 0.24630685f, 0.15814023f, 0.33959696f, -0.34587973f, -0.21742035f, 0.38866982f, 0.08956777f, 
    0.03629075f, 0.06193933f, -0.00394379f, -0.25733751f, -0.08013567f, -0.03617327f, -0.12188792f, -0.06429464f, 
    -0.12049846f, 0.05366758f, -0.23708279f, 0.16443798f, -0.07404252f, -0.00107675f, 0.11303798f, 0.06333356f, 
    0.08688513f, 0.03606327f, -0.03748033f, 0.11096627f, 0.23706397f, 0.13002227f, 0.26584411f, 0.01933790f, 
    0.03024133f, 0.01522978f, 0.10288151f, 0.07496888f, 0.00105549f, -0.03619123f, -0.07579392f, -0.14046994f, 
    0.16801654f, -0.16265185f, -0.00265133f, 0.20486705f, 0.05762355f, 0.02283033f, -0.04304606f, 0.12320426f, 
    0.00991267f, 0.09736755f, 0.15446401f, 0.29444021f, 0.18706541f, 0.05650431f, -0.21988213f, 0.25474292f, 
    0.04163255f, 0.16851188f, 0.09170011f, -0.04562316f, -0.10698056f, -0.00215988f, 0.13058870f, -0.07702801f, 
    -0.00820803f, 0.01256881f, -0.26493636f, 0.14029409f, -0.02017394f, -0.00471149f, -0.16038363f, 0.03989926f, 
    -0.00601598f, 0.01083530f, 0.19072746f, 0.24379836f, 0.23640707f, -0.09821132f, 0.05466718f, 0.15141831f, 
    -0.06568482f, -0.07184987f, -0.09926933f, -0.12223334f, -0.02033718f, -0.20420587f, -0.02340413f, -0.20887023f, 
    -0.11708979f, -0.01044495f, -0.08217514f, -0.06267865f, 0.13100763f, 0.17288324f, 0.09046426f, -0.02371080f, 
    0.01950107f, -0.02455077f, -0.12239671f, 0.03130562f, 0.04073684f, -0.14260362f, 0.11171561f, 0.05875465f, 
    -0.05846423f, -0.00263985f, -0.03452365f, 0.12392442f, 0.06332693f, -0.01152006f, 0.08198670f, -0.02984638f, 
    -0.25290364f, 0.01108265f, -0.19567482f, -0.11050861f, 0.03970876f, 0.09052508f, 0.19523141f, 0.12648065f, 
    -0.08281919f, -0.00148629f, -0.12019955f, 0.11900417f, 0.13071820f, 0.01344080f, -0.06070696f, 0.22382805f, 
    -0.06920136f, -0.04631525f, 0.06615139f, -0.02389725f, -0.12620032f, 0.13431178f, 0.07528690f, 0.12169865f, 
    -0.13080887f, 0.29035014f, -0.03089035f, -0.17586911f, 0.18445212f, -0.12112017f, -0.00175375f, -0.11080989f, 
    0.01194191f, 0.08671768f, 0.05678294f, 0.01866240f, -0.11028864f, -0.08964357f, -0.09638190f, 0.06914195f, 
    -0.19247696f, -0.06555947f, 0.04001051f, 0.02173816f, 0.08727946f, 0.01363577f, -0.03108256f, -0.02805709f, 
    0.07188326f, -0.14857051f, -0.03443267f, 0.14592345f, -0.02743981f, -0.00131884f, -0.19329174f, -0.03764069f, 
    -0.05521816f, -0.13855530f, -0.02811914f, -0.08027992f, -0.31564602f, -0.09771077f, -0.16648336f, 0.11520970f, 
    -0.03877940f, 0.15286928f, -0.18651631f, -0.05863846f, -0.09275780f, -0.08674300f, 0.11500735f, 0.19383708f, 
    -0.12790135f, 0.15936786f, 0.18286923f, -0.15468267f, -0.05438806f, 0.20343289f, -0.05376730f, -0.05463511f, 
    -0.05213400f, 0.04116109f, 0.20484534f, 0.11697649f, -0.07326648f, -0.14338093f, 0.06211927f, 0.26242793f, 
    -0.20116611f, -0.03243113f, 0.06245302f, -0.04767152f, 0.12227295f, 0.01775992f, -0.13700283f, 0.00999821f, 
    -0.11931554f, -0.01117788f, -0.22714625f, 0.04721798f, -0.03535415f, -0.06138308f, 0.03189739f, 0.05272828f, 
    0.21656293f, 0.17873873f, 0.15385284f, 0.34770453f, -0.17101710f, 0.04887946f, 0.16094464f, 0.07710034f, 
    -0.06643438f, 0.07436506f, -0.03506746f, -0.11975794f, -0.08429129f, 0.13952632f, 0.00534180f, -0.08084586f, 
    0.09734798f, -0.07297554f, -0.05804421f, -0.03122703f, 0.02831041f, -0.08725629f, -0.13010170f, 0.10871401f, 
    -0.08556782f, -0.14005050f, -0.14728203f, -0.36090040f, -0.31999320f, 0.11735653f, -0.10338483f, 0.01028381f, 
    0.09506854f, 0.01184135f, 0.06923087f, -0.00703429f, 0.05301148f, -0.11193112f, 0.08680580f, -0.05821888f, 
    0.51460505f, -0.22590145f, 0.43970141f, -0.09791349f, 0.17118184f, 0.05207385f, 0.05608400f, 0.16883789f, 
    -0.08479469f, -0.12844564f, 0.03745363f, -0.07178076f, 0.10054490f, -0.07408911f, -0.09424841f, -0.02416721f, 
    -0.13828674f, -0.01770086f, 0.05479451f, 0.01301173f, 0.24730375f, 0.36514261f, 0.15409029f, 0.34056151f, 
    -0.19871023f, 0.01088650f, -0.09319302f, 0.06935487f, -0.05240976f, 0.09932479f, 0.06473412f, -0.04649482f, 
    0.10167422f, 0.12094402f, 0.13816388f, 0.24170229f, 0.06206153f, 0.05779227f, 0.01795629f, 0.25231674f, 
    0.03218299f, -0.06974424f, 0.00811636f, 0.03998420f, -0.17100281f, -0.05120016f, -0.17760298f, -0.06301338f, 
    -0.25531250f, 0.08191644f, -0.24403557f, 0.37328464f, 0.06959064f, 0.05966125f, 0.01782726f, -0.05264128f, 
    -0.03312939f, -0.04755854f, -0.07874238f, -0.08043009f, 0.05703400f, 0.36710370f, -0.12479776f, 0.09333997f, 
    0.17437795f, 0.06345839f, -0.01568021f, 0.05186746f, -0.05050981f, 0.14978631f, -0.08594490f, 0.10457711f, 
    -0.37528917f, 0.53713554f, -0.12617341f, -0.14733632f, 0.06274686f, -0.01474091f, 0.00138229f, -0.13653508f, 
    -0.01341681f, -0.01977728f, 0.12550755f, -0.17638241f, -0.43830606f, 0.02776274f, -0.05179485f, -0.21048871f, 
    0.07303119f, -0.07211935f, -0.07326262f, -0.05600817f, -0.20946026f, 0.06550971f, -0.18891928f, -0.19963363f, 
    0.07433394f, -0.10688650f, 0.14931028f, 0.27878338f, 0.10677385f, 0.02268417f, 0.09465086f, -0.08642489f, 
    -0.02685005f, 0.08052743f, -0.08830972f, 0.21931815f, 0.06557629f, 0.05287507f, -0.05969580f, 0.10776297f, 
    0.13531788f, -0.03023783f, -0.08647544f, -0.10832967f, 0.02664521f, -0.02867968f, 0.17648825f, -0.02712268f, 
    0.37664327f, 0.06073979f, 0.18782388f, 0.16493382f, 0.11669882f, -0.06167973f, -0.14793952f, 0.09713484f, 
    0.11695260f, 0.13925792f, 0.02069406f, 0.23552994f, -0.06806272f, 0.09073841f, 0.01818136f, 0.00531940f, 
    0.17425251f, -0.11584669f, -0.03282303f, 0.01306159f, 0.06856458f, -0.05741673f, -0.12979706f, -0.08343285f, 
    0.00177893f, 0.03465548f, -0.05124151f, 0.26429847f, -0.06776482f, -0.05412255f, -0.00862741f, 0.12882985f, 
    -0.00959828f, 0.07206252f, -0.09638457f, 0.07426768f, 0.05632084f, 0.06987406f, -0.11889011f, 0.15893930f, 
    0.03290376f, 0.03922820f, -0.03201381f, 0.02283717f, 0.03784426f, 0.03675183f, -0.18225114f, 0.00851325f, 
    0.10243949f, -0.08532999f, 0.01423495f, 0.24420603f, 0.01005008f, 0.04717686f, -0.08445812f, -0.05599013f, 
    0.08948520f, 0.17537250f, 0.24977928f, 0.16114794f, -0.02536343f, -0.11145517f, -0.05593332f, 0.02022361f, 
    0.07767212f, 0.10480763f, -0.04933037f, -0.12278347f, -0.09362613f, -0.22361135f, 0.04427169f, 0.05826586f, 
    -0.16903368f, 0.18557082f, -0.20013374f, -0.00083809f, -0.03236834f, 0.05046595f, -0.16789491f, -0.00076776f, 
    -0.15415025f, -0.15859179f, 0.12374672f, 0.17048040f, 0.19160500f, -0.05929281f, 0.05868126f, 0.13697198f, 
    -0.00253114f, 0.06788405f, -0.06384745f, 0.09341594f, 0.13526739f, 0.01636577f, 0.14643683f, -0.05045268f, 
    -0.24627174f, -0.18955924f, -0.11774899f, -0.04190964f, 0.14346910f, 0.03469825f, -0.15124370f, -0.20018001f, 
    -0.02617224f, -0.07085826f, -0.27147934f, -0.14396119f, 0.13728437f, 0.11385722f, 0.02569841f, 0.04675042f, 
    0.08380943f, 0.00036802f, 0.00284921f, 0.12237085f, 0.00993846f, -0.13328440f, 0.14729652f, -0.00875304f, 
    -0.39376560f, 0.03738837f, -0.26741564f, -0.27284968f, 0.13988771f, 0.01430323f, 0.19716312f, -0.13091150f, 
    0.09459172f, 0.04605235f, -0.05052492f, 0.01294807f, 0.22448796f, 0.07916662f, -0.12490296f, -0.09381995f, 
    0.02036803f, 0.09954569f, -0.06941248f, 0.04439054f, -0.24591354f, 0.20073204f, 0.07330251f, 0.11142845f, 
    0.25219819f, 0.06303504f, 0.10133447f, -0.16117999f, -0.00380038f, 0.01626595f, -0.12603922f, 0.03018119f, 
    -0.15396880f, -0.00359998f, -0.10684078f, -0.14997075f, 0.07459657f, -0.09120107f, -0.12025619f, 0.13081822f, 
    -0.06826193f, 0.07030032f, 0.20089236f, 0.14393207f, 0.00582615f, 0.11702652f, -0.06446721f, 0.05060192f, 
    0.10640333f, -0.00223804f, -0.02970512f, 0.06959171f, 0.16560037f, 0.22720766f, -0.03762662f, -0.03957511f, 
    0.02332038f, -0.05168431f, -0.00862790f, -0.13685897f, -0.08427073f, 0.23535044f, -0.18856907f, -0.06332265f, 
    0.11651875f, 0.08133562f, -0.08114757f, 0.07439696f, -0.13928623f, 0.01213172f, 0.18274556f, -0.05137328f, 
    -0.42333701f, 0.41412854f, -0.16676918f, 0.21849017f, 0.03216958f, -0.03169077f, -0.21497610f, -0.10749167f, 
    0.18127577f, -0.00179422f, 0.11694445f, -0.12700617f, -0.03570642f, -0.07276015f, 0.05678890f, 0.19306150f, 
    -0.00689949f, 0.15065141f, 0.03477132f, 0.15630852f, 0.12245100f, 0.12296441f, 0.00349487f, 0.05105754f, 
    -0.06357784f, 0.03889720f, 0.10663716f, 0.15018952f, 0.08099094f, -0.01668322f, 0.04492170f, 0.02991178f, 
    0.03573624f, 0.05938149f, 0.07082197f, 0.27371746f, 0.06414863f, 0.08836147f, -0.05477252f, -0.10974841f, 
    0.17284848f, -0.08547790f, -0.16341096f, 0.07927123f, -0.07820003f, -0.10484668f, 0.05495505f, 0.08110184f, 
    0.08427700f, -0.28632209f, 0.10526757f, 0.01895517f, -0.05066333f, -0.04300925f, -0.07516673f, -0.03221671f, 
    -0.09700353f, -0.02521805f, -0.18119386f, -0.15918408f, -0.38173082f, -0.11082942f, -0.04367852f, -0.16344105f, 
    0.03878962f, -0.04423579f, -0.05764755f, 0.05555565f, 0.05504798f, -0.05910302f, 0.00580246f, -0.02452274f, 
    -0.21468233f, -0.32324398f, 0.37055308f, 0.17247975f, 0.04869610f, 0.06738229f, -0.08179228f, 0.00011204f, 
    0.04063504f, -0.11486106f, 0.07543035f, -0.24036618f, -0.25043154f, 0.00871699f, -0.04731394f, 0.07797372f, 
    0.01850636f, -0.00799666f, -0.01706600f, -0.02777698f, 0.20640071f, 0.23506996f, -0.01825471f, 0.14721094f, 
    0.14444327f, 0.09268578f, 0.09641077f, 0.04749178f, -0.03081723f, 0.14358360f, -0.12636560f, -0.02141330f, 
    -0.09398758f, -0.00939705f, 0.12765218f, 0.06974170f, 0.06060253f, 0.13467826f, -0.17700312f, 0.13342877f, 
    -0.05204562f, -0.07204061f, 0.13485116f, 0.16358504f, -0.14125377f, -0.19056824f, -0.16712108f, -0.15496399f, 
    0.12902346f, 0.35526121f, -0.27748314f, 0.08238274f, 0.09275281f, 0.03352636f, -0.02262590f, 0.10099795f, 
    -0.12958075f, -0.09877305f, -0.14893548f, -0.12278159f, 0.24486700f, 0.37588832f, 0.06467433f, -0.06198383f, 
    0.12523866f, 0.08321942f, -0.08378750f, -0.04917348f, -0.00250870f, -0.06177766f, -0.07353579f, 0.17721395f, 
    -0.00252102f, 0.02018817f, 0.02435720f, -0.05078363f, 0.02636998f, -0.05068444f, 0.03641048f, -0.03000059f, 
    0.02647119f, 0.02088914f, -0.02922083f, -0.01049151f, 0.00627722f, 0.03637556f, 0.00044639f, -0.01117946f, 
    0.04104687f, -0.04036252f, 0.01551689f, -0.01013377f, -0.00005291f, -0.01242576f, -0.04897262f, -0.03957798f, 
    0.02344199f, -0.03284966f, 0.00897734f, 0.04321995f, -0.02810725f, -0.04524290f, -0.03060246f, 0.01046675f, 
    0.01531270f, -0.04421381f, 0.04550848f, 0.00793900f, -0.00832800f, 0.02584878f, 0.02526602f, 0.04385676f, 
    0.03483218f, -0.03813186f, -0.05412592f, -0.03784023f, 0.01166827f, -0.04000142f, -0.04314568f, 0.03057232f, 
    0.02451306f, 0.00351329f, -0.05598982f, -0.01665403f, 0.04346544f, -0.00265746f, -0.06349092f, 0.01690734f, 
    0.02955630f, -0.05123278f, 0.02028490f, -0.01288496f, 0.02849550f, -0.00556821f, 0.01137693f, 0.01948493f, 
    -0.04936118f, -0.03867055f, -0.03536128f, -0.01242111f, -0.01230619f, 0.04020930f, -0.02429641f, 0.03213877f, 
    -0.00395107f, -0.03395884f, -0.03786055f, -0.00961102f, 0.03282949f, -0.02567042f, 0.01993497f, -0.04798289f, 
    0.01390870f, -0.02449869f, 0.04430810f, 0.02522205f, 0.01476251f, -0.03865381f, -0.01683754f, -0.04560861f, 
    -0.05644414f, 0.00824705f, 0.03744702f, -0.01478583f, 0.00578513f, 0.03073487f, 0.03608331f, -0.03754686f, 
    -0.00557291f, 0.01564713f, -0.04181872f, -0.04697233f, -0.01229891f, -0.05116573f, -0.02994369f, 0.03418990f, 
    -0.05426332f, -0.05547011f, 0.03646886f, -0.04924196f, 0.03394084f, -0.05764614f, -0.04347043f, 0.00842701f, 
    -0.04590970f, 0.01583545f, -0.04154292f, -0.01552904f, 0.02584394f, -0.04124188f, 0.04298599f, 0.01485553f, 
    -0.05300459f, 0.01598444f, -0.04301744f, -0.00027838f, -0.04697195f, 0.00117063f, -0.00359972f, 0.02867919f, 
    0.01504220f, 0.02177593f, 0.02989307f, 0.01925645f, 0.03584077f, -0.03621330f, -0.02856688f, -0.01803025f, 
    0.02705002f, 0.02065424f, -0.03111577f, 0.02282898f, 0.00289378f, 0.03420761f, -0.01078275f, 0.01116715f, 
    0.02344182f, -0.06231204f, 0.02974915f, -0.01963578f, -0.05499030f, -0.04355671f, 0.00740748f, 0.03682223f, 
    -0.03179207f, 0.01456384f, -0.05220262f, -0.04203622f, 0.01429661f, -0.05765657f, -0.05629575f, 0.02756288f, 
    0.00475352f, -0.04194092f, -0.04159686f, 0.03596772f, 0.01910948f, -0.04860390f, -0.03545873f, -0.00700661f, 
    -0.06271277f, -0.03414539f, 0.04153582f, -0.02313473f, 0.03805859f, 0.02944006f, -0.01666408f, -0.04019552f, 
    -0.04441329f, 0.01801760f, -0.03613924f, -0.04765262f, 0.02868871f, 0.00127948f, 0.00604146f, 0.00449827f, 
    0.04624040f, 0.01401135f, -0.03625398f, 0.02266178f, -0.05249931f, 0.00889479f, -0.00126017f, -0.00975054f, 
    -0.02423951f, -0.03411526f, 0.02423565f, 0.00379038f, -0.04368546f, 0.00261198f, 0.02656486f, -0.00506805f, 
    -0.01785079f, -0.04570076f, -0.00663032f, -0.01750090f, -0.03022586f, -0.05612490f, -0.02477898f, 0.02699781f, 
    0.01778188f, -0.00274844f, 0.01399498f, -0.00209890f, -0.02800536f, 0.01938577f, -0.04667515f, -0.04572000f, 
    -0.00106191f, -0.01304856f, -0.01292794f, -0.03219143f, 0.02941579f, -0.01221652f, 0.01355557f, -0.03132739f, 
    -0.02250666f, -0.05561518f, -0.01540890f, -0.04864827f, -0.05017506f, -0.03275456f, 0.00873848f, -0.00801860f, 
    -0.04989549f, -0.02335023f, -0.00573419f, -0.04160219f, -0.06178799f, -0.00693393f, 0.01501937f, -0.05248316f, 
    0.00087176f, -0.04992409f, 0.01320872f, 0.00328527f, -0.03634579f, 0.02852859f, 0.02801026f, -0.02578827f, 
    -0.03579398f, -0.02190803f, -0.00396224f, 0.03617281f, -0.01597512f, 0.00259085f, 0.01852366f, -0.04308473f, 
    -0.05226070f, -0.03021489f, -0.03134625f, -0.02036372f, 0.04046341f, -0.03039410f, -0.01809220f, -0.05475307f, 
    0.04544437f, 0.04350608f, 0.04998250f, -0.03961784f, 0.03422075f, -0.00368164f, 0.00326578f, -0.05674385f, 
    -0.03867918f, 0.00795119f, -0.02738962f, 0.00619448f, -0.02597103f, 0.03784725f, -0.04986935f, -0.06037886f, 
    0.01255675f, 0.00386095f, 0.03407026f, 0.00610437f, 0.00411181f, -0.00176675f, -0.00422786f, -0.04346942f, 
    -0.02449239f, -0.03508953f, -0.05240516f, -0.02816644f, 0.01897630f, 0.03808578f, 0.01872577f, -0.04103076f, 
    -0.00712099f, -0.05077978f, 0.00570695f, 0.03338975f, -0.00080493f, -0.05760516f, 0.00917480f, -0.00399389f, 
    0.03520034f, 0.03862599f, -0.01873095f, 0.00547838f, 0.04328141f, 0.01529391f, 0.03019414f, -0.04403228f, 
    0.03565930f, -0.02361774f, 0.03338636f, 0.00273594f, -0.04719215f, -0.02552244f, -0.03771548f, -0.05107091f, 
    0.01171524f, -0.02483674f, -0.05154153f, -0.00156935f, 0.01980828f, 0.02636105f, -0.01380713f, -0.01208558f, 
    -0.02396550f, -0.00260140f, 0.01967353f, 0.04038910f, 0.01023682f, -0.02338601f, -0.00704448f, 0.02808663f, 
    0.00461111f, -0.04894524f, 0.02946418f, 0.02523431f, -0.05737507f, -0.03950537f, -0.04601420f, -0.03856227f, 
    0.04492432f, 0.02726327f, 0.03872116f, -0.01086454f, 0.02405728f, -0.05678886f, 0.02396033f, -0.02517132f, 
    0.03110828f, 0.04012161f, -0.05162703f, -0.03286592f, 0.02715879f, -0.00775949f, 0.02751922f, 0.03423771f, 
    -0.04659839f, 0.03827796f, 0.03696553f, 0.01230787f, 0.03008855f, 0.01868008f, -0.05440714f, -0.03773592f, 
    -0.02379870f, 0.02532904f, -0.02810515f, 0.02698736f, -0.02248917f, 0.01529874f, 0.02072855f, -0.01363886f, 
    -0.00716269f, -0.05390460f, -0.00184503f, 0.03595329f, 0.02079249f, 0.00095144f, 0.03106098f, 0.00754295f, 
    -0.10654973f, 0.34114465f, -0.16482693f, 0.12267023f, -0.06892876f, 0.05932891f, 0.02469937f, -0.10457822f, 
    0.00476670f, -0.12523617f, 0.17345305f, -0.19012494f, 0.00219213f, 0.08474300f, -0.09812871f, -0.12049510f, 
    0.10209385f, 0.00028093f, -0.03337261f, -0.09256910f, 0.05175612f, 0.05751571f, -0.07163862f, 0.10000161f, 
    -0.02464448f, -0.48250246f, -0.28711221f, 0.43031323f, 0.12024424f, 0.13037102f, 0.16401197f, 0.13101825f, 
    -0.05861065f, -0.04162500f, -0.06923887f, 0.01244216f, 0.35553917f, -0.09779235f, -0.12302972f, 0.18474624f, 
    0.15142670f, 0.04073166f, -0.01595889f, 0.01708632f, -0.10735509f, -0.05254542f, -0.01836293f, 0.02836923f, 
    -0.09492264f, -0.11544677f, 0.13507849f, 0.01388006f, 0.08972184f, -0.19223449f, -0.04812561f, 0.03625724f, 
    0.13182054f, 0.19294852f, -0.09251522f, 0.22239016f, 0.23291539f, 0.32025075f, 0.01914186f, 0.26681879f, 
    -0.17249410f, -0.03692440f, 0.02674397f, 0.28604060f, -0.05403526f, -0.03172456f, 0.08332049f, -0.05753072f, 
    0.12390573f, 0.02674370f, 0.07066169f, 0.30602834f, 0.00729441f, -0.05987859f, 0.11282927f, 0.19485575f, 
    0.00743745f, 0.13355634f, -0.00327205f, -0.05224750f, -0.10190242f, -0.39389309f, -0.00988932f, 0.19079831f, 
    0.05401458f, 0.14686733f, 0.26378930f, 0.12784161f, -0.09829554f, 0.00537565f, -0.05837347f, 0.03496074f, 
    0.29514217f, -0.09937482f, -0.07668041f, 0.18693814f, 0.10136987f, 0.08893485f, 0.07293072f, 0.13096686f, 
    0.00440849f, 0.00973176f, 0.13559297f, -0.04237020f, -0.11032028f, 0.13168955f, 0.08451357f, -0.06654994f, 
    -0.07604939f, 0.11814255f, -0.08170770f, 0.10194051f, 0.05299925f, 0.05181930f, 0.04178470f, 0.11252379f, 
    0.03135403f, 0.03782274f, -0.09899013f, -0.27708727f, -0.02700506f, -0.02192199f, -0.07148929f, -0.11070257f, 
    -0.01581994f, 0.05486943f, -0.05083854f, 0.22644721f, 0.20724803f, 0.06171597f, 0.19052345f, 0.43583372f, 
    0.09755988f, 0.06150226f, -0.15323991f, -0.06911155f, -0.00605285f, 0.02106354f, -0.05995749f, -0.03046550f, 
    -0.02921597f, 0.10685252f, 0.10283078f, -0.07352506f, 0.14224984f, 0.11362994f, 0.06957538f, 0.04689651f, 
    0.14027782f, 0.14585908f, 0.02226707f, 0.03952671f, 0.24833564f, 0.03974611f, 0.01914517f, 0.21426672f, 
    -0.03091247f, 0.06633942f, 0.00785857f, 0.28227499f, -0.08132650f, 0.11680769f, 0.16664062f, 0.05035213f, 
    -0.14658354f, 0.05285187f, -0.03171275f, -0.00259147f, 0.05014728f, 0.07101420f, 0.08362094f, -0.05186677f, 
    0.07214624f, 0.15262620f, 0.14547861f, 0.09607121f, 0.38980645f, 0.28863552f, -0.13664562f, -0.23428583f, 
    0.00481369f, 0.00474795f, -0.09943205f, -0.13361906f, -0.07934234f, -0.05978141f, -0.12500231f, -0.02527481f, 
    0.54768729f, 0.01183901f, 0.09927591f, -0.62289006f, 0.13692586f, -0.05294848f, -0.09316871f, -0.10282838f, 
    0.03277789f, 0.09084685f, 0.18305370f, -0.01374016f, 0.07799927f, -0.01150326f, 0.01860884f, 0.10856016f, 
    -0.04511169f, 0.00652547f, 0.20989259f, 0.27142379f, 0.01920641f, 0.00758449f, -0.09229183f, 0.00386929f, 
    0.18858458f, 0.00933004f, -0.01828631f, 0.28795564f, 0.17051128f, 0.27205029f, 0.04001163f, 0.17170343f, 
    0.04810992f, 0.06302443f, 0.00968176f, 0.03148670f, 0.35348070f, 0.13759533f, -0.28582948f, -0.14163329f, 
    0.03500989f, -0.01156563f, 0.10711969f, 0.15481019f, -0.14815478f, -0.14951999f, 0.07848983f, 0.09239258f, 
    -0.82727218f, -0.15638468f, 0.03276939f, 0.58898693f, -0.04898934f, 0.17669994f, -0.05679091f, -0.09298381f, 
    -0.18212865f, -0.11943939f, 0.28259879f, -0.07635240f, 0.10935996f, 0.09570663f, 0.23515476f, 0.33101943f, 
    0.11518121f, 0.03576975f, -0.01271029f, 0.15141140f, -0.00319924f, 0.02105171f, 0.00255772f, -0.07330721f, 
    -0.29742298f, -0.04527978f, -0.06933716f, 0.09107446f, 0.08173954f, -0.02472502f, -0.01029606f, 0.18011518f, 
    0.04116801f, -0.00071873f, -0.07263632f, 0.09749717f, 0.28188872f, 0.17532580f, -0.16668141f, -0.02558149f, 
    0.09713284f, -0.10288648f, 0.20426774f, 0.18659660f, -0.04873984f, -0.03963884f, -0.02048003f, -0.08720655f, 
    0.13234664f, 0.03202502f, 0.16641906f, -0.02017223f, 0.16314775f, -0.03058179f, -0.15946840f, -0.03496863f, 
    -0.02593742f, 0.10562103f, 0.07618866f, 0.13149555f, -0.20462349f, -0.07662132f, 0.03187261f, -0.08630054f, 
    -0.01071587f, 0.01177950f, 0.01137651f, 0.06945981f, 0.02317119f, 0.01460113f, 0.02330981f, 0.04433805f, 
    -0.24021654f, 0.07488462f, 0.43368974f, 0.21051189f, -0.01594096f, -0.15819770f, -0.29787785f, 0.13319796f, 
    0.08241262f, 0.03667710f, 0.07944040f, -0.04387313f, -0.49206039f, 0.03064955f, 0.13967036f, 0.14463858f, 
    -0.04155444f, -0.03918122f, -0.15130170f, -0.03414408f, 0.01344284f, 0.20103477f, 0.09744767f, 0.05793563f, 
    0.11058473f, 0.02444386f, 0.03888944f, -0.10947676f, 0.11825296f, -0.03642761f, -0.09048040f, -0.06023432f, 
    0.07892419f, 0.03987899f, 0.09769099f, -0.07424295f, 0.08191143f, 0.19395176f, -0.23366244f, -0.04538434f, 
    0.09546027f, -0.04035130f, -0.01999251f, 0.08747849f, -0.08224620f, -0.06527157f, -0.02426613f, -0.20907000f, 
    0.39002147f, 0.41041678f, -0.22364409f, -0.09609509f, 0.07241181f, 0.15554796f, 0.07432805f, 0.01495281f, 
    -0.05279736f, -0.08118119f, -0.04242381f, -0.02347227f, 0.43760943f, -0.03722372f, -0.31162673f, -0.45989922f, 
    0.07579616f, 0.08381838f, 0.12063265f, -0.03091523f, 0.07427576f, -0.15881114f, -0.18791281f, 0.04214997f, 
    0.09062897f, 0.03305265f, 0.28557852f, 0.06919862f, 0.09674744f, -0.09626956f, 0.06889240f, 0.14714234f, 
    0.02604380f, 0.12038320f, 0.09083942f, 0.16502158f, 0.05136338f, 0.21756332f, -0.00273546f, -0.01093426f, 
    0.00248872f, -0.01865470f, 0.11699658f, 0.03207181f, -0.13930823f, 0.10105935f, -0.04379000f, -0.33264753f, 
    0.30489227f, -0.02481491f, 0.39314228f, 0.01452119f, -0.09410129f, -0.21228921f, -0.02824589f, 0.27095041f, 
    0.03418080f, 0.23070790f, -0.02139751f, 0.10003307f, 0.02295860f, -0.24220401f, 0.21823433f, 0.02348433f, 
    -0.13392529f, -0.13094303f, -0.05574739f, -0.03354471f, -0.04266467f, -0.03970717f, 0.03904646f, -0.08614903f, 
    0.30295199f, 0.13050619f, 0.03549393f, 0.09654633f, -0.13504155f, -0.04315153f, 0.14737019f, -0.10413527f, 
    0.15473507f, -0.01868628f, 0.06109132f, 0.22598469f, -0.25203085f, -0.42188343f, 0.35405266f, 0.12734501f, 
    0.16934125f, -0.12063621f, 0.06192595f, -0.08437312f, 0.03801329f, 0.00615199f, -0.17539915f, -0.09752450f, 
    -0.20982297f, 0.15202110f, 0.01617686f, -0.06935228f, -0.12130772f, 0.04081340f, 0.07932848f, -0.02291852f, 
    0.07483268f, -0.06768665f, 0.12958276f, -0.01822929f, -0.14661814f, -0.02217887f, 0.13370949f, -0.09454248f, 
    -0.01301295f, 0.11853202f, 0.00481035f, -0.01909276f, 0.12860283f, -0.17699683f, 0.09618743f, 0.04073476f, 
    0.01231843f, 0.06146641f, 0.03537322f, 0.22288834f, -0.10343521f, -0.08174151f, -0.01963380f, -0.05710087f, 
    0.01999984f, 0.04150534f, 0.07865783f, 0.06300025f, 0.26177919f, -0.01175181f, 0.06213789f, 0.16810924f, 
    -0.04404033f, 0.01889098f, 0.08350687f, -0.01894239f, -0.14304575f, 0.05629078f, 0.18261781f, -0.09528439f, 
    0.32644555f, 0.12131334f, 0.06834922f, 0.14307803f, -0.01839573f, 0.03902696f, -0.05393248f, -0.07543428f, 
    0.01063420f, 0.02551428f, 0.21931599f, 0.06323897f, -0.06403433f, -0.14967720f, -0.20184477f, -0.18336421f, 
    -0.13078891f, 0.05504472f, -0.02687350f, 0.09495635f, -0.05373411f, -0.05757750f, -0.13359645f, -0.15020144f, 
    0.09958415f, 0.10885292f, -0.04513587f, -0.04013510f, 0.13094766f, -0.02103860f, 0.01863606f, -0.09436394f, 
    0.00555627f, -0.10261343f, -0.05289137f, -0.04154241f, -0.11326959f, -0.16472979f, 0.05387055f, 0.18540813f, 
    0.03385904f, 0.03377381f, -0.03213991f, 0.13199554f, 0.16640562f, -0.03660375f, -0.01811533f, 0.10643155f, 
    0.40183434f, 0.23203795f, 0.10309771f, 0.16275719f, 0.02946952f, 0.02511392f, -0.01644545f, 0.11028564f, 
    0.12275661f, 0.10231224f, -0.17353295f, 0.06464720f, 0.03548998f, -0.14591014f, -0.23953921f, 0.18352647f, 
    0.03752037f, 0.17186655f, -0.00478558f, -0.02548419f, 0.16096202f, 0.01032811f, -0.11802009f, 0.19502942f, 
    -0.60695696f, 0.52516395f, -0.30778497f, 0.09309647f, 0.05885002f, 0.01988039f, 0.02929678f, -0.12833486f, 
    -0.05312089f, -0.05216322f, 0.00959900f, 0.07227824f, -0.24634796f, 0.07029054f, 0.08915684f, -0.03981764f, 
    -0.24353220f, -0.11129046f, -0.04020562f, -0.22997674f, -0.00957646f, -0.06895888f, 0.03870304f, 0.00589321f, 
    -0.16424045f, -0.07685605f, -0.12220447f, 0.15128650f, 0.02810013f, -0.18619065f, -0.07905185f, 0.03680278f, 
    -0.22893010f, -0.23888850f, -0.04360759f, -0.04887870f, -0.10552792f, -0.38644630f, -0.05055761f, 0.21178474f, 
    0.07865255f, 0.13483563f, -0.20717108f, 0.10089254f, -0.04785308f, -0.00647090f, 0.02494955f, 0.13576326f, 
    0.34744835f, 0.12384567f, 0.15421511f, 0.03772939f, -0.15088898f, -0.08737643f, 0.19714516f, 0.06398302f, 
    0.24061075f, 0.22855686f, -0.01206397f, 0.25037560f, -0.13488919f, -0.36714125f, -0.14283344f, -0.02596157f, 
    -0.08015831f, -0.08153325f, -0.05061069f, -0.09041268f, 0.04128326f, 0.03530457f, -0.15301678f, 0.14157635f, 
    0.04411153f, 0.19610627f, -0.03142765f, 0.13052730f, 0.04298824f, -0.10718709f, 0.02795847f, -0.09493855f, 
    0.06700094f, 0.33492768f, 0.19630264f, 0.21282658f, -0.15103838f, -0.07399888f, 0.20411788f, 0.15540990f, 
    -0.12676793f, 0.15592632f, -0.06461535f, -0.07272108f, -0.11864316f, -0.04762492f, 0.16449253f, 0.09384287f, 
    0.04940940f, 0.09943683f, -0.05066826f, 0.13227582f, 0.07674735f, -0.01754540f, 0.05234564f, 0.03637217f, 
    -0.05606045f, -0.03950960f, -0.15567482f, -0.24741276f, 0.19902261f, 0.19198652f, -0.00450700f, 0.13257246f, 
    0.08097111f, 0.00454462f, 0.02636906f, -0.01669646f, -0.06585341f, -0.00916958f, -0.03078146f, -0.09774356f, 
    0.63106370f, 0.09655596f, 0.08113134f, -0.13053931f, -0.00985484f, 0.13152139f, 0.23271509f, 0.06578646f, 
    -0.03992410f, -0.05123816f, -0.03448097f, -0.07643623f, 0.36116064f, 0.16471681f, 0.13746530f, -0.07732848f, 
    -0.14169411f, 0.01912640f, 0.07222061f, -0.00090276f, 0.22370665f, 0.23990941f, 0.17658120f, 0.60559785f, 
    -0.01217319f, 0.05072985f, -0.20290636f, 0.32677603f, 0.11657912f, 0.02060607f, 0.14925827f, -0.00216810f, 
    -0.07217109f, 0.15611196f, 0.16541597f, 0.21354038f, -0.03950665f, -0.12775007f, 0.02129604f, 0.32744646f, 
    0.01204659f, 0.11920977f, 0.24586509f, -0.15223902f, 0.05911352f, -0.03134755f, 0.05380414f, -0.02293333f, 
    -0.54497766f, -0.07198050f, -0.06678984f, 0.32138723f, 0.01415776f, 0.00774094f, -0.06455459f, 0.00226866f, 
    0.01258702f, -0.05268201f, 0.04125804f, -0.16111171f, 0.09129377f, 0.33864519f, 0.08438830f, 0.40937266f, 
    0.02557591f, 0.06727182f, 0.00325275f, -0.02027174f, -0.17394957f, -0.14462425f, 0.05199589f, 0.03402848f, 
    -0.42042744f, 0.42245752f, 0.16171309f, -0.15199573f, 0.07260954f, 0.09003643f, -0.13345611f, -0.02169273f, 
    -0.09488025f, 0.13424037f, 0.08720124f, -0.11439512f, -0.15983504f, 0.02563990f, -0.03477038f, 0.00038157f, 
    0.01400434f, -0.02977589f, -0.09310015f, 0.17556633f, 0.06596565f, -0.05031363f, 0.00405836f, 0.07761062f, 
    -0.36735362f, 0.19013913f, 0.14487532f, 0.28329811f, -0.03162048f, -0.02233836f, 0.07714256f, 0.07894278f, 
    0.01690905f, -0.05423435f, -0.16106565f, 0.01395607f, -0.15031861f, 0.09725696f, 0.07301217f, 0.03378667f, 
    0.04281068f, -0.13525689f, 0.10336640f, 0.00080318f, 0.04385682f, -0.03275824f, 0.06173504f, -0.04124817f, 
    0.18629642f, 0.11104753f, 0.06160383f, 0.03526722f, 0.06235537f, -0.01588185f, -0.11115500f, -0.00228272f, 
    0.08474527f, 0.24307166f, 0.07140459f, 0.03428484f, -0.25924066f, -0.04452124f, 0.38202837f, -0.15852758f, 
    0.13072737f, 0.16428898f, -0.09306433f, -0.04724870f, 0.02359336f, -0.07425282f, -0.06911746f, 0.13154425f, 
    -0.00327021f, -0.19363497f, -0.27525705f, 0.31603238f, 0.08093821f, 0.14679240f, 0.03780667f, -0.02974058f, 
    -0.05430333f, 0.09536289f, -0.06224406f, 0.10577767f, 0.33862624f, 0.13910164f, 0.04112445f, 0.14065504f, 
    -0.00192158f, -0.06899418f, -0.06246082f, 0.02443858f, 0.00874646f, 0.12448150f, -0.13402647f, -0.02904499f, 
    -0.08291454f, -0.17115358f, 0.16536058f, 0.13061848f, -0.04173647f, 0.06113176f, 0.05948797f, 0.05857050f, 
    -0.18839976f, 0.07387902f, 0.05117361f, 0.13672175f, 0.00177968f, 0.15363765f, -0.11878536f, 0.04136067f, 
    0.24731873f, -0.11326123f, 0.03316235f, -0.06313215f, 0.14064306f, 0.08932991f, 0.11167753f, 0.21100123f, 
    0.06123868f, 0.24521844f, -0.14999324f, 0.24270092f, -0.04420590f, 0.03601720f, 0.11295954f, 0.11647195f, 
    -0.04714308f, -0.07983723f, 0.06729634f, 0.14897858f, -0.03520432f, -0.22886378f, 0.00395511f, 0.12009808f, 
    0.01915050f, -0.06751273f, 0.01432255f, 0.01580957f, 0.02919105f, -0.01583038f, 0.13885885f, -0.07476117f, 
    -0.23667336f, -0.13284101f, -0.09375459f, 0.03305652f, -0.11588480f, -0.07733859f, -0.01050376f, -0.06081110f, 
    0.05098475f, 0.04970607f, -0.18901865f, -0.07929242f, -0.15142722f, -0.19307368f, 0.10943189f, -0.06816971f, 
    0.12287366f, -0.01593273f, -0.00988208f, -0.11640663f, -0.05945191f, -0.07636766f, -0.02374431f, -0.10863674f, 
    -0.50120968f, -0.01027810f, -0.17377664f, -0.08043056f, -0.04115544f, 0.16885312f, 0.08256429f, 0.11197765f, 
    0.12479830f, 0.07759584f, 0.02330347f, 0.00561737f, -0.04519466f, 0.01737194f, 0.10859307f, 0.16503699f, 
    0.02615954f, 0.00136117f, 0.08831061f, 0.17068598f, -0.28605282f, 0.18668339f, 0.20951854f, 0.09784594f, 
    0.49262807f, -0.26891190f, -0.19210503f, -0.00712475f, 0.01472983f, -0.07167539f, 0.07899437f, 0.08695938f, 
    -0.05223980f, 0.10175151f, 0.02614987f, 0.00640550f, -0.10103734f, -0.33717367f, -0.13277270f, 0.10580309f, 
    0.06121961f, 0.08380772f, 0.19514421f, -0.01026579f, -0.01759693f, -0.02466312f, -0.11763072f, -0.01867696f, 
    -0.08748872f, -0.15300234f, -0.00932286f, -0.00736364f, -0.00239538f, -0.00940550f, -0.14753912f, -0.20230462f, 
    0.08546545f, -0.08886136f, -0.13872476f, -0.07635646f, -0.37939575f, 0.00767162f, 0.01668023f, 0.05234955f, 
    -0.00094068f, -0.00050765f, -0.05234782f, -0.10340477f, -0.09865115f, 0.01239671f, 0.06783487f, -0.11074477f, 
    0.11626394f, 0.23134218f, 0.21714108f, -0.20196463f, 0.07688547f, 0.04655043f, -0.10507775f, 0.10775859f, 
    0.09956668f, 0.03084553f, 0.15301554f, -0.00114954f, -0.13942055f, -0.13533911f, 0.14789557f, 0.28730437f, 
    0.05183589f, -0.05640538f, 0.03254850f, -0.02871512f, -0.00825616f, -0.09621800f, -0.00214050f, 0.03631443f, 
    -0.05938971f, -0.10040688f, -0.09037586f, 0.11978420f, -0.01102295f, -0.06482392f, 0.19480744f, 0.18829633f, 
    0.02754362f, -0.10139564f, 0.01880741f, 0.12287118f, -0.04291402f, -0.07995921f, 0.06788962f, 0.06904906f, 
    0.32021192f, -0.04724247f, -0.04722618f, -0.01544901f, 0.04257418f, 0.13895273f, 0.08570392f, -0.05295079f, 
    0.22314493f, -0.10823036f, 0.02651958f, -0.15004528f, -0.04325872f, -0.02033128f, -0.14082938f, 0.06320539f, 
    -0.03803522f, 0.02105474f, -0.01142897f, 0.02174124f, -0.34367603f, -0.02468575f, -0.08968490f, -0.03677213f, 
    0.03519027f, 0.04419262f, 0.00000216f, 0.13637143f, 0.17702685f, -0.02494903f, 0.13830973f, 0.04291943f, 
    0.13915953f, -0.26275069f, 0.36240286f, 0.05452758f, 0.11816055f, 0.11252636f, 0.03537121f, 0.06915887f, 
    -0.02468696f, -0.16537522f, 0.01973125f, -0.04690886f, 0.01727511f, -0.24119113f, -0.26234606f, -0.05628540f, 
    -0.02654163f, -0.00887275f, -0.11038321f, 0.00630070f, 0.25874475f, 0.17640047f, -0.01608672f, -0.01363932f, 
    -0.07503728f, -0.23320839f, 0.11846870f, 0.15109468f, -0.03912786f, 0.01685657f, -0.01433169f, -0.08606727f, 
    0.05468057f, -0.03889207f, 0.06353504f, 0.11768134f, -0.07494603f, 0.20694773f, 0.14174226f, 0.04909208f, 
    0.11825424f, -0.05964312f, 0.11474673f, 0.22111455f, -0.06449272f, 0.02789097f, -0.09480666f, 0.21170093f, 
    0.01482500f, 0.11077126f, -0.10622656f, 0.24332088f, 0.01274124f, 0.00802149f, -0.08320723f, 0.09044238f, 
    -0.11548315f, 0.02172180f, -0.03107855f, -0.08622851f, -0.26163393f, -0.10953898f, -0.05575182f, -0.09244270f, 
    0.02801654f, -0.06117008f, -0.04822851f, 0.12957275f, 0.01012053f, 0.09521170f, 0.11867950f, 0.20632520f, 
    0.02189976f, -0.09688016f, 0.05505002f, 0.01645344f, -0.07482363f, -0.13347940f, -0.07894156f, 0.16786195f, 
    -0.00080682f, 0.00156742f, -0.00091027f, 0.06269317f, -0.21337622f, 0.09832399f, -0.25768688f, -0.04338924f, 
    0.00155561f, 0.01094689f, 0.02650922f, -0.11999144f, -0.23956989f, 0.16984040f, 0.03349556f, 0.12620094f, 
    0.40254045f, 0.04954091f, 0.10510466f, -0.02681559f, 0.08408424f, -0.21398808f, 0.10159997f, 0.04622149f, 
    0.04022507f, -0.09258211f, -0.06786817f, -0.12508033f, 0.32466877f, 0.14166145f, 0.28301495f, 0.23096794f, 
    0.01952233f, -0.00309664f, -0.00645443f, -0.04133801f, 0.03066024f, -0.01383766f, -0.01497019f, 0.04598005f, 
    0.04885912f, -0.15648106f, -0.11491969f, -0.07913903f, -0.03630407f, -0.09501445f, 0.04233204f, -0.01122828f, 
    0.07578999f, -0.21836047f, -0.19166256f, 0.15659034f, 0.30999893f, -0.00378219f, 0.04510196f, 0.10830860f, 
    0.11586867f, -0.02236391f, 0.09073649f, 0.29929206f, 0.09756752f, 0.10174865f, 0.11379915f, -0.02399225f, 
    -0.15382303f, 0.18995440f, 0.35655352f, 0.11037896f, 0.04954391f, 0.12875395f, 0.05343211f, 0.18756165f, 
    -0.15550300f, 0.00817028f, 0.13279329f, 0.01510638f, 0.07519080f, -0.12628151f, 0.15694234f, 0.02233967f, 
    -0.07012708f, 0.03425246f, 0.15454029f, 0.09062242f, -0.08617043f, -0.09766507f, -0.12439049f, 0.01324378f, 
    -0.15610881f, 0.36355209f, 0.16953929f, 0.05842577f, 0.06244769f, 0.06050798f, 0.03364467f, 0.03501885f, 
    0.11501426f, 0.13154019f, -0.11390212f, -0.21981734f, -0.20608503f, -0.08989231f, 0.15163252f, 0.01296332f, 
    -0.17464054f, 0.08830402f, -0.13855861f, 0.22405356f, 0.05896328f, -0.10914306f, 0.05215535f, 0.11599119f, 
    -0.17321697f, -0.27233684f, -0.07157497f, -0.19731563f, -0.07452766f, -0.03583023f, -0.00378714f, 0.04512710f, 
    -0.05415584f, -0.04937884f, -0.05953584f, 0.07360397f, 0.06044436f, 0.16228519f, 0.24972695f, 0.35656595f, 
    -0.02896100f, 0.04287859f, -0.08171219f, 0.08244073f, 0.08006640f, -0.01012032f, -0.00221655f, 0.00722738f, 
    -0.18436153f, 0.00211757f, -0.22616729f, -0.38072553f, 0.11069069f, -0.02618055f, 0.01444287f, -0.01531794f, 
    -0.12778705f, -0.07072938f, 0.09185065f, 0.03371796f, 0.01633871f, 0.23604809f, 0.13090697f, 0.22202787f, 
    0.15615988f, 0.16025089f, 0.02326448f, -0.00561875f, 0.00097089f, 0.04624478f, -0.00682989f, 0.09826593f, 
    -0.18174578f, -0.12245812f, -0.21788089f, 0.10619387f, -0.15967567f, -0.26339725f, -0.24184766f, 0.03309619f, 
    -0.07006255f, 0.05380648f, 0.06856659f, 0.03546850f, -0.01530315f, 0.05280202f, 0.12054238f, 0.05842312f, 
    0.07090715f, 0.09806821f, -0.04331423f, 0.01272864f, 0.03560296f, -0.06548160f, -0.01160219f, -0.13480313f, 
    -0.33982977f, -0.01151882f, -0.02532781f, -0.08684125f, -0.19563590f, 0.19623168f, 0.12117268f, -0.12686156f, 
    0.01903529f, 0.05144083f, -0.05206445f, -0.01263799f, 0.09756789f, 0.24441555f, 0.33703890f, 0.18212326f, 
    -0.13756935f, -0.01968369f, 0.01584428f, 0.12805237f, -0.07848953f, -0.04410591f, -0.11413728f, -0.00198315f, 
    0.23143777f, 0.49768472f, 0.26444995f, 0.38129365f, -0.01155958f, 0.14658941f, 0.10957744f, 0.11163824f, 
    -0.02705796f, 0.03661764f, 0.09008661f, 0.07515036f, 0.03811460f, 0.04535205f, 0.31625664f, 0.29939026f, 
    0.10919788f, 0.01864864f, -0.10299499f, 0.14687377f, -0.02642825f, 0.03387409f, -0.07373608f, 0.01763003f, 
    -0.15794599f, -0.19746165f, -0.09434754f, 0.07779506f, -0.15628274f, -0.05596509f, -0.00210581f, -0.04173252f, 
    -0.08398345f, 0.02413947f, 0.06067409f, 0.06321833f, 0.05934990f, 0.11737016f, 0.20368697f, 0.09106489f, 
    0.17139781f, 0.19550261f, -0.02059600f, 0.01952537f, 0.05986851f, -0.07359531f, 0.02420147f, -0.02236185f, 
    -0.15759212f, 0.23720835f, 0.05502341f, 0.07716811f, 0.08253554f, 0.11224841f, 0.01648612f, 0.05655321f, 
    0.01257600f, 0.05288780f, -0.08088921f, -0.08486526f, 0.39474532f, 0.24687561f, 0.26942310f, 0.04350941f, 
    -0.06981891f, -0.04323652f, 0.07088090f, -0.01086290f, -0.15085599f, -0.12621397f, -0.05309857f, 0.11277907f, 
    -0.32219598f, -0.13124958f, -0.19429490f, -0.03059251f, -0.05439730f, 0.17927603f, 0.14665878f, 0.02877910f, 
    0.00635080f, 0.05571349f, 0.08575089f, 0.09259575f, -0.16345963f, -0.04567268f, -0.23098044f, 0.12820621f, 
    -0.15310977f, -0.08364540f, -0.01143675f, -0.02965713f, -0.18466657f, -0.07737683f, -0.06470472f, -0.03661443f, 
    -0.28231540f, -0.16191828f, -0.27054685f, -0.35729820f, -0.18201865f, 0.11590737f, -0.07161770f, -0.17346708f, 
    -0.01762220f, 0.11924904f, 0.06368639f, -0.01628512f, -0.05524637f, 0.18663673f, -0.20722923f, -0.10359409f, 
    0.04275860f, -0.10154694f, -0.08123871f, -0.14607042f, -0.09793534f, -0.10425229f, 0.00625921f, 0.01539206f, 
    -0.05375744f, 0.08479294f, -0.08794218f, 0.04284030f, 0.00529655f, 0.03412481f, 0.06351414f, -0.00570052f, 
    0.00662590f, -0.05987436f, -0.10713940f, 0.09924811f, 0.13629095f, 0.01996136f, 0.00826775f, 0.21044433f, 
    -0.01272687f, 0.13101347f, -0.01338730f, 0.19068711f, 0.02404170f, 0.08267472f, 0.08797224f, -0.15914583f, 
    0.04445846f, 0.26080015f, 0.15370500f, 0.07401912f, 0.06567494f, 0.04501440f, -0.18621346f, 0.10903456f, 
    0.15835321f, 0.07087888f, 0.00427150f, 0.21855998f, -0.08126234f, 0.07307966f, -0.02233092f, -0.13191506f, 
    -0.11715707f, -0.04947481f, -0.06111106f, 0.04952982f, 0.13404816f, 0.05182476f, -0.00555458f, -0.03059248f, 
    0.05762571f, 0.09883656f, 0.16231292f, -0.19408928f, -0.02627102f, -0.02702646f, -0.04643940f, 0.04088409f, 
    -0.10037169f, -0.01941273f, -0.06767771f, 0.00945040f, 0.00785020f, -0.19295977f, 0.18749861f, -0.35835204f, 
    0.01917584f, 0.06850271f, 0.00091178f, -0.09386493f, -0.04939174f, -0.05775451f, -0.02705362f, -0.09353074f, 
    -0.12544735f, -0.03527068f, 0.07350061f, 0.05041369f, -0.05767344f, -0.10503359f, -0.01830713f, 0.11390162f, 
    -0.06119766f, -0.03124407f, 0.01856141f, 0.14151262f, -0.15781336f, -0.00376053f, -0.23293503f, -0.01062230f, 
    0.09277579f, -0.15902802f, 0.01201240f, 0.14824151f, -0.07580858f, -0.04495127f, 0.04895115f, 0.06149560f, 
    0.05135434f, 0.13314834f, -0.15818354f, 0.34615535f, 0.04921611f, 0.11022578f, 0.00541953f, 0.09471697f, 
    0.09161476f, 0.01619500f, 0.22621462f, 0.10984803f, -0.31047481f, 0.14409608f, 0.22021605f, -0.00306444f, 
    0.13518623f, 0.17312567f, -0.13608265f, -0.03580721f, 0.10122648f, 0.02868857f, -0.02927661f, -0.03310953f, 
    0.16356361f, -0.14435992f, 0.03420995f, -0.00902291f, 0.16765863f, -0.00163823f, -0.09046832f, 0.07810760f, 
    0.07844092f, 0.10700873f, -0.01030041f, 0.05514283f, -0.06649230f, 0.45782027f, -0.12479593f, 0.15011431f, 
    -0.01440176f, -0.06786708f, -0.03835689f, -0.08734221f, -0.00425006f, 0.00858212f, -0.16207182f, -0.30677313f, 
    -0.15027991f, -0.31511098f, -0.09158543f, -0.02882438f, -0.06702583f, -0.00881978f, -0.08658601f, 0.16524640f, 
    0.05982919f, 0.01311711f, -0.01306932f, 0.14913756f, -0.18712829f, -0.11952859f, -0.04036480f, -0.19877633f, 
    0.12814100f, -0.01865515f, 0.10421563f, -0.21849807f, 0.10924152f, -0.12487260f, -0.11108287f, -0.05507119f, 
    -0.05123594f, 0.10674660f, 0.09318053f, -0.10986428f, -0.02344391f, -0.12338202f, 0.02962754f, -0.04036614f, 
    0.04571310f, -0.15086237f, 0.07263352f, 0.08429535f, -0.23870988f, -0.21386462f, -0.08707886f, -0.03095069f, 
    0.02689235f, 0.00311251f, 0.13409784f, 0.10056818f, -0.14342539f, -0.11963473f, 0.28113574f, 0.15683296f, 
    -0.02135403f, -0.21485177f, -0.08814232f, -0.15608487f, 0.03069765f, 0.04728173f, 0.15646785f, 0.09772123f, 
    0.12445667f, -0.13130908f, 0.03024117f, 0.02235298f, -0.07415148f, 0.45484453f, 0.15704137f, 0.23130651f, 
    0.03730938f, -0.06007166f, 0.07769364f, -0.05096292f, 0.04943914f, -0.02386024f, -0.00661245f, -0.06989381f, 
    -0.20808035f, 0.04357781f, 0.14411120f, -0.32159084f, -0.03040813f, -0.00743349f, 0.19730766f, -0.06899656f, 
    0.06751213f, -0.07512537f, 0.04043335f, 0.11099891f, -0.05365475f, -0.25432441f, 0.14297438f, 0.04231706f, 
    -0.03026401f, 0.03130963f, 0.01343414f, 0.09813909f, 0.03547794f, 0.18779458f, -0.00401768f, -0.03006364f, 
    0.16283648f, -0.24976642f, 0.17501946f, 0.39218307f, 0.07376216f, -0.06403650f, -0.14828293f, -0.13359900f, 
    0.13540648f, 0.02114868f, 0.00342761f, -0.09843671f, 0.16603962f, -0.04779470f, -0.17361708f, 0.21246023f, 
    0.18472554f, 0.22925974f, 0.11452065f, 0.16135874f, 0.14291775f, -0.05959882f, -0.04726440f, 0.10425569f, 
    0.07541248f, -0.09471704f, 0.16348204f, -0.04260627f, 0.04012267f, -0.00136513f, -0.06645832f, 0.14374536f, 
    0.04088539f, -0.11459445f, 0.03512828f, -0.11154066f, -0.24345490f, 0.06480204f, -0.02304138f, -0.25133067f, 
    0.12513779f, 0.10951792f, -0.18151145f, 0.13272718f, 0.17119445f, 0.10806195f, 0.17831196f, 0.02435010f, 
    -0.18391658f, 0.41814542f, -0.24518488f, -0.02731106f, 0.08701010f, -0.11457665f, -0.04606485f, -0.10203363f, 
    0.13277316f, 0.02594238f, 0.07880283f, 0.06600750f, 0.04293283f, -0.02980892f, -0.00968582f, 0.24148035f, 
    0.07825395f, 0.15776649f, 0.20114717f, 0.21220638f, -0.09850115f, 0.14884396f, 0.03357551f, 0.09038404f, 
    0.16726491f, -0.25288141f, 0.06324437f, -0.15205713f, -0.05096443f, 0.07563034f, -0.02490213f, -0.02167945f, 
    0.13729958f, -0.08865605f, 0.03218945f, 0.15034197f, -0.10815606f, 0.15401401f, -0.08950600f, 0.00017630f, 
    0.08245590f, 0.01195733f, -0.04568631f, 0.08845246f, 0.12555690f, 0.07932337f, -0.09540056f, 0.10060260f, 
    -0.02218914f, -0.08200055f, -0.09394028f, -0.06179686f, -0.06414453f, 0.05394030f, -0.10576317f, -0.20347321f, 
    -0.14948845f, -0.22589807f, -0.18271825f, -0.13329831f, 0.06787233f, -0.09787188f, 0.26900989f, -0.36600962f, 
    -0.01095884f, -0.06837297f, -0.11574592f, -0.08425110f, 0.14759643f, -0.03394236f, 0.00566534f, -0.04185075f, 
    -0.41762248f, 0.32281122f, -0.44123742f, 0.24248073f, 0.13762717f, 0.02212651f, 0.04145541f, -0.05489450f, 
    0.04000885f, -0.18175048f, -0.02930197f, -0.37254754f, -0.07323664f, -0.33187786f, -0.15438607f, -0.05889934f, 
    0.03390673f, 0.09425946f, 0.27901247f, 0.05396264f, 0.19711918f, 0.04228779f, 0.17594977f, 0.12366781f, 
    0.03249703f, -0.00906951f, 0.12838094f, 0.09784488f, 0.05582685f, 0.05780298f, -0.08137282f, -0.02064838f, 
    0.09828599f, 0.01971937f, 0.12491287f, 0.17866059f, 0.17027578f, 0.16839233f, 0.02316875f, -0.08586779f, 
    -0.16411865f, 0.00818359f, 0.06766377f, 0.04963648f, -0.13525821f, 0.04031604f, -0.06025418f, 0.04620805f, 
    0.21152979f, -0.23684971f, 0.33977231f, -0.03758434f, 0.17658773f, 0.07821035f, 0.07707716f, 0.23966227f, 
    -0.08528274f, 0.04403812f, -0.15533130f, -0.07478379f, 0.55297405f, 0.31916609f, 0.18812224f, 0.07462802f, 
    -0.18670158f, 0.01079424f, -0.29466683f, -0.10085330f, 0.10450079f, 0.13461058f, 0.00561789f, 0.08424948f, 
    -0.02391166f, 0.02587212f, -0.01621376f, -0.05272365f, -0.00147758f, 0.02610555f, -0.02998115f, 0.00615236f, 
    0.01430247f, 0.01774844f, -0.02168981f, 0.02686997f, -0.01227384f, -0.02606896f, 0.01144090f, -0.00537570f, 
    0.02643564f, 0.02949504f, -0.03534796f, -0.02229834f, 0.04191557f, -0.00946226f, -0.01343825f, -0.01371681f, 
    0.04916807f, 0.00520895f, -0.01669186f, 0.01465390f, -0.04218889f, 0.01120607f, -0.00137076f, -0.00484512f, 
    0.00058570f, 0.01168807f, 0.01011659f, 0.02338353f, -0.04445878f, 0.01820064f, 0.02211228f, 0.01228803f, 
    -0.01763429f, 0.03215060f, -0.02909832f, 0.00552823f, 0.00730912f, 0.02225160f, -0.03096030f, -0.01800141f, 
    -0.00637266f, 0.00604160f, 0.00159587f, 0.00710064f, 0.03999563f, -0.04687213f, -0.00314990f, -0.03981814f, 
    0.01200588f, -0.02732949f, -0.01601341f, -0.00589094f, 0.03109647f, -0.03611049f, -0.04684948f, -0.03149402f, 
    0.02726858f, 0.03731979f, -0.01616968f, 0.02981764f, -0.00851386f, 0.00774972f, 0.04844030f, 0.02349938f, 
    0.02451219f, -0.04963159f, -0.01884916f, -0.03579931f, 0.03867309f, 0.00008652f, 0.04043255f, 0.03061476f, 
    0.02207466f, 0.02841114f, 0.00031177f, 0.01588260f, 0.02929131f, -0.05333233f, 0.00790529f, 0.01655285f, 
    0.02840822f, 0.02216705f, 0.01839635f, 0.00078380f, -0.03137985f, 0.00682876f, 0.02594314f, -0.03713077f, 
    -0.02836787f, -0.03197336f, -0.03666259f, -0.00739782f, -0.00118440f, -0.01616245f, -0.02080991f, -0.04488591f, 
    -0.03425907f, -0.02965804f, -0.00425541f, 0.00837557f, -0.04414056f, 0.04352346f, 0.03553846f, 0.03603086f, 
    -0.01207884f, -0.01249437f, -0.00608603f, -0.02694840f, -0.00305884f, -0.05399053f, 0.04553037f, -0.03075115f, 
    -0.01572088f, -0.01405090f, -0.05791292f, -0.04363345f, 0.02155420f, 0.00118303f, 0.01764644f, 0.00999729f, 
    -0.01416618f, -0.00107117f, -0.03777713f, 0.00236752f, 0.03897008f, 0.00109440f, 0.03785372f, -0.04443885f, 
    -0.02155833f, 0.03055366f, -0.04972173f, -0.06431060f, 0.02096662f, -0.04532837f, -0.00548987f, 0.03647336f, 
    -0.03349477f, 0.03249074f, 0.01311802f, 0.04267072f, 0.03245370f, -0.02645410f, -0.02469993f, -0.05129807f, 
    -0.00732364f, 0.03522195f, 0.00508266f, -0.03584410f, -0.03656755f, -0.05394349f, -0.01818450f, -0.00916838f, 
    -0.01201198f, 0.02981064f, 0.01965795f, -0.03714564f, 0.01251212f, 0.00569124f, 0.02458715f, -0.04793962f, 
    -0.04827133f, 0.02387517f, -0.02480896f, -0.03254732f, -0.02711378f, -0.03404855f, -0.05461822f, 0.02620912f, 
    0.03838171f, 0.01505893f, 0.01633222f, 0.03237304f, 0.00177343f, 0.02723664f, 0.02714957f, 0.03287348f, 
    0.00871194f, 0.04118834f, 0.01496516f, -0.05435571f, -0.03651764f, -0.00119601f, -0.01355042f, 0.01084630f, 
    -0.06133157f, -0.03690291f, 0.01288093f, -0.05720071f, 0.00925135f, 0.03774204f, 0.01563927f, -0.02015558f, 
    -0.00422519f, 0.00013361f, -0.02700949f, 0.03900936f, 0.03996430f, 0.00062625f, -0.04294256f, -0.02281863f, 
    0.01365563f, 0.00682191f, -0.01990417f, -0.00572760f, 0.00343872f, 0.02835141f, 0.04327136f, -0.00123074f, 
    0.02576957f, -0.00248461f, 0.03610801f, 0.03350117f, 0.04213182f, -0.03123691f, 0.00799023f, -0.04082189f, 
    -0.02566930f, 0.03455740f, 0.03577358f, 0.03321527f, -0.00512391f, -0.01199268f, -0.01031437f, -0.02862971f, 
    0.01711845f, 0.00719861f, 0.03420096f, -0.02012446f, 0.01191080f, -0.00093008f, -0.00377929f, -0.04644757f, 
    -0.01470333f, 0.00447092f, -0.05932767f, 0.03544500f, -0.02920204f, -0.02800499f, -0.05847535f, -0.00810595f, 
    -0.01395843f, -0.00851085f, -0.00500187f, 0.02552331f, 0.01294603f, 0.02170273f, 0.03311823f, 0.01575229f, 
    0.03695438f, 0.01546188f, 0.00223058f, 0.00616064f, 0.03997368f, -0.04315671f, 0.03073108f, -0.04748809f, 
    -0.01198991f, 0.00826185f, 0.01153859f, -0.02715825f, -0.02571597f, 0.02351753f, -0.01214484f, -0.05153317f, 
    0.01215867f, -0.02430559f, -0.01327153f, -0.01002427f, 0.01040469f, 0.01782713f, 0.00028769f, 0.03938546f, 
    -0.05131280f, -0.02773070f, 0.01846803f, 0.01590352f, 0.00311213f, -0.00315012f, -0.01104766f, 0.02243818f, 
    -0.03499644f, -0.03572740f, 0.03478617f, -0.02635950f, 0.03759648f, -0.01759679f, -0.04262878f, -0.03289911f, 
    0.03681935f, 0.03885854f, -0.04087658f, 0.01277173f, -0.03971588f, -0.01872038f, -0.03736017f, 0.01136960f, 
    -0.02011449f, -0.01216300f, -0.00664646f, -0.00944491f, -0.03376380f, -0.03009678f, -0.02882663f, -0.02525049f, 
    -0.01534787f, 0.02756662f, -0.00435865f, 0.03650476f, -0.02563894f, -0.01287935f, -0.02566796f, -0.01597133f, 
    -0.04021084f, -0.01413251f, 0.01021980f, -0.04588438f, 0.03495677f, 0.01340898f, 0.00423195f, -0.03491060f, 
    -0.04164279f, -0.02413642f, -0.01020308f, -0.01030539f, -0.06262898f, 0.02411113f, 0.02752624f, 0.01024991f, 
    -0.01478579f, -0.04521175f, -0.03712022f, -0.04592617f, -0.01396033f, -0.04648585f, -0.00566983f, -0.03024518f, 
    0.01206431f, 0.01308234f, 0.03865718f, 0.03449894f, 0.02053617f, -0.05874629f, -0.01527869f, -0.01486177f, 
    -0.02825122f, 0.04013031f, -0.03319384f, -0.03297813f, 0.03929135f, 0.00068997f, -0.05610771f, -0.01802331f, 
    0.01171796f, 0.00534173f, -0.01264670f, -0.00435345f, -0.03970127f, -0.01147948f, 0.01038556f, -0.03348577f, 
    -0.01160678f, 0.00292020f, -0.03945728f, -0.02101045f, -0.02381283f, -0.03935570f, 0.00891164f, -0.03557751f, 
    -0.03307177f, 0.00098889f, 0.01295684f, -0.05211709f, -0.05942881f, 0.02632851f, -0.02053712f, 0.03454346f, 
    -0.11638214f, -0.24271539f, 0.33928102f, 0.04212023f, -0.08886833f, 0.04150201f, -0.10390355f, 0.09796812f, 
    0.01898573f, 0.18475410f, 0.07752775f, -0.05813266f, -0.08250681f, -0.06952237f, -0.07198489f, 0.11353297f, 
    0.07175792f, -0.03131392f, -0.08302208f, -0.06216531f, -0.05337207f, -0.15016346f, 0.08716153f, 0.11398835f, 
    -0.16327710f, 0.29820809f, 0.11348899f, -0.39810440f, 0.02940173f, -0.04570746f, -0.24948277f, 0.13746285f, 
    -0.06676171f, -0.12441241f, 0.12389151f, -0.11070193f, -0.14999506f, 0.25729969f, 0.20934319f, -0.09342939f, 
    0.17720976f, 0.12381589f, -0.23147307f, 0.25679520f, 0.02177079f, -0.23546813f, 0.04795843f, 0.09983159f, 
    -0.07522456f, 0.34918582f, 0.00221718f, 0.05208258f, -0.02901812f, 0.11598060f, -0.10794242f, 0.01900757f, 
    0.06333274f, 0.03691321f, -0.00026104f, -0.09673826f, 0.14209856f, 0.17141661f, -0.03863449f, -0.37903872f, 
    0.03433803f, 0.24394649f, 0.03587962f, 0.10161061f, 0.14210877f, 0.11575168f, 0.03752591f, -0.06432676f, 
    0.30017245f, 0.09304361f, 0.28079346f, 0.01698636f, 0.28128323f, 0.09649608f, -0.01874322f, 0.16266876f, 
    -0.01716541f, -0.02015197f, 0.05516546f, 0.06724779f, 0.11721037f, 0.17406434f, -0.00515624f, -0.20527190f, 
    -0.10498650f, -0.06677070f, 0.03222870f, -0.03210071f, 0.03049947f, 0.12040312f, -0.08908828f, -0.08934537f, 
    -0.19215876f, 0.29345986f, 0.08168531f, -0.05223000f, 0.06491294f, -0.31976724f, -0.07312094f, -0.05095570f, 
    0.05225596f, -0.07404079f, 0.08571226f, -0.05944188f, -0.13353579f, 0.01972328f, 0.06648592f, 0.06101595f, 
    0.22295624f, 0.03173502f, -0.05865277f, -0.05094145f, 0.17106158f, 0.08102192f, -0.06899511f, 0.24742228f, 
    -0.11731537f, 0.15279752f, 0.18343763f, -0.00386784f, -0.05247050f, 0.06150476f, 0.08890329f, 0.02636007f, 
    0.08255658f, -0.08821396f, -0.07120904f, 0.08487260f, -0.11061555f, -0.10296929f, -0.06366517f, -0.07142022f, 
    -0.17057000f, -0.19155361f, 0.14382678f, 0.01186078f, -0.23240845f, -0.07125615f, 0.06372859f, 0.02799449f, 
    -0.05764557f, -0.01543009f, -0.04992021f, -0.03772040f, -0.04402178f, -0.03166004f, -0.06079174f, -0.14762141f, 
    0.18541688f, 0.19151540f, 0.04226993f, -0.10876846f, 0.01280905f, 0.28903854f, 0.17755069f, -0.26157275f, 
    0.08199997f, 0.02142427f, 0.08715028f, -0.23625757f, -0.08450063f, -0.03842981f, -0.17836092f, -0.00573577f, 
    -0.28969726f, -0.01457046f, 0.00889561f, 0.11746263f, -0.12275676f, 0.09246477f, -0.19349025f, 0.03926020f, 
    0.09216641f, 0.07081123f, 0.16708714f, -0.06869687f, -0.29370713f, -0.03590404f, 0.21751805f, 0.33281603f, 
    0.12334944f, -0.00303597f, 0.03193138f, 0.06188238f, -0.15039958f, 0.00711596f, 0.17246795f, 0.07887999f, 
    0.09588837f, -0.23501399f, 0.28762239f, 0.53951615f, 0.01390751f, -0.03308692f, 0.21886291f, -0.20693062f, 
    0.06033336f, -0.04793797f, 0.09014904f, 0.01244874f, 0.18370612f, 0.24790324f, -0.02197681f, 0.10509117f, 
    0.11688904f, -0.01678920f, -0.00438472f, 0.03151745f, -0.00615520f, -0.02327442f, -0.11761635f, -0.00131107f, 
    0.04883696f, 0.27330393f, -0.00452492f, 0.09619199f, -0.08105664f, 0.12652682f, -0.12296688f, -0.03999338f, 
    0.15239340f, -0.09315238f, -0.03226532f, 0.08887892f, -0.49167874f, 0.26885554f, 0.24163228f, 0.17438468f, 
    0.05537768f, 0.22123513f, -0.05658628f, -0.05476112f, 0.26073766f, 0.04838537f, -0.04665194f, 0.06790937f, 
    -0.19335672f, 0.13399576f, 0.17302543f, -0.36693779f, 0.01143805f, -0.09118197f, -0.08346762f, -0.01663189f, 
    0.11952702f, 0.20301524f, -0.06454674f, 0.12814488f, 0.17529516f, 0.20988810f, 0.06139849f, -0.10988958f, 
    0.09235540f, -0.08555244f, -0.04815311f, 0.09432723f, -0.11106724f, 0.10926282f, 0.20446667f, -0.12360530f, 
    0.17767131f, 0.17802459f, 0.22349031f, -0.03344219f, -0.12031946f, -0.05913439f, -0.07499165f, 0.20119843f, 
    0.14410242f, 0.02474395f, 0.12151781f, 0.03726628f, 0.08562764f, 0.15032969f, 0.04579697f, 0.15856768f, 
    0.19180329f, 0.16834761f, -0.16271019f, 0.19623621f, 0.16372997f, -0.18412437f, 0.06691628f, 0.15947543f, 
    0.03785501f, -0.06909920f, -0.14140007f, 0.09468263f, 0.12933542f, 0.18161331f, -0.02732135f, -0.02351651f, 
    0.13142195f, 0.01852153f, 0.03769939f, -0.02723377f, -0.04412455f, 0.06862661f, -0.02704623f, 0.22829188f, 
    0.09343016f, 0.10906459f, -0.07034963f, 0.03522298f, 0.15445681f, 0.10861930f, 0.07556378f, 0.10622792f, 
    -0.10648309f, -0.05187221f, -0.37238121f, 0.12245317f, 0.39816219f, 0.25286478f, 0.04185244f, 0.08498618f, 
    -0.05163812f, -0.08127805f, -0.15534081f, -0.04396861f, -0.10344364f, 0.08393965f, -0.29274660f, -0.19917718f, 
    -0.02250171f, 0.21345684f, 0.01078170f, -0.17424770f, 0.19692692f, 0.08597503f, -0.10348362f, -0.09430695f, 
    -0.01783106f, 0.08053131f, 0.36079976f, 0.08736090f, -0.04630906f, -0.15071408f, 0.01338004f, 0.01544448f, 
    0.06636070f, 0.06987434f, -0.03044766f, 0.02319461f, 0.14618702f, 0.12287308f, 0.08433637f, 0.06561980f, 
    0.11025722f, 0.07154407f, -0.10265828f, 0.21878421f, 0.18895175f, 0.04502709f, 0.03915739f, 0.21486801f, 
    0.08842377f, 0.09967348f, 0.08811614f, -0.09041966f, 0.00030532f, 0.02359403f, -0.07239539f, 0.07325478f, 
    -0.03270387f, -0.04500897f, -0.09125126f, -0.00300261f, -0.18683112f, -0.00875304f, 0.21117058f, 0.84085876f, 
    0.12293471f, -0.27386448f, -0.28109369f, -0.11962873f, 0.03296669f, 0.00751944f, 0.06709334f, 0.08807645f, 
    0.26200983f, -0.16341217f, -0.02404548f, -0.05734253f, -0.03198643f, -0.03873820f, 0.09040882f, 0.05586338f, 
    -0.05642641f, -0.01043840f, -0.05182347f, 0.02830898f, -0.02532476f, -0.08465399f, -0.04524913f, -0.16259415f, 
    0.06829835f, 0.15195851f, -0.00697572f, -0.25684264f, -0.20311785f, 0.01621938f, -0.03398395f, -0.12413045f, 
    0.52901345f, -0.07122317f, 0.02593513f, -0.12391976f, 0.14450996f, -0.01799532f, -0.06961185f, -0.04583747f, 
    0.01109338f, -0.02157760f, 0.06460489f, 0.04016308f, 0.17706753f, 0.16964656f, 0.06907954f, 0.09676128f, 
    0.11906386f, -0.05389107f, -0.15732308f, -0.08599599f, -0.02923910f, 0.05242568f, -0.05512793f, 0.01707634f, 
    -0.08887260f, 0.02037753f, -0.07917973f, 0.01664799f, -0.01331819f, 0.01113183f, 0.00551876f, 0.02621552f, 
    0.05581137f, -0.12551382f, 0.00976320f, 0.26048389f, 0.29731345f, 0.21647753f, -0.08190081f, 0.14430031f, 
    0.13897564f, 0.04383762f, 0.06802195f, 0.21688111f, 0.05995582f, 0.04178101f, 0.02332234f, -0.10426535f, 
    0.15023270f, 0.14799297f, 0.33332169f, -0.17502125f, -0.02337134f, -0.07581921f, -0.00217163f, 0.15238638f, 
    -0.11283460f, -0.10422863f, 0.07096092f, -0.00459675f, -0.14184031f, 0.13913952f, 0.02188756f, 0.14292464f, 
    0.01231396f, 0.06912290f, 0.08690245f, 0.02108604f, 0.05551474f, 0.00106637f, -0.01558473f, 0.04134348f, 
    -0.01009286f, 0.10994769f, -0.02081426f, 0.01857416f, -0.03141093f, -0.01562621f, -0.07636558f, -0.01526671f, 
    0.08207794f, -0.05383897f, -0.03183226f, -0.12798233f, -0.08670983f, -0.18657783f, 0.12553117f, -0.05079328f, 
    -0.04649103f, 0.11383139f, -0.05558018f, 0.07093194f, 0.01422294f, -0.16252838f, -0.07259444f, -0.09822346f, 
    -0.16886750f, -0.18718268f, 0.01579190f, -0.29348993f, -0.05710298f, -0.10612668f, -0.12759142f, -0.09334282f, 
    0.00890099f, -0.01842566f, -0.03356129f, 0.05640844f, 0.14454177f, 0.19932647f, 0.12212452f, 0.13834868f, 
    -0.10282581f, 0.07320395f, 0.05687824f, 0.08227278f, 0.08418167f, -0.05894501f, -0.03143582f, 0.00595716f, 
    0.01372758f, -0.00922855f, -0.00288964f, -0.10054420f, 0.16642767f, 0.07264517f, 0.07506045f, 0.02652965f, 
    0.08342910f, -0.00798062f, 0.11017125f, 0.06577695f, 0.16801220f, 0.42792422f, 0.07287464f, 0.28488043f, 
    -0.03943025f, -0.03472362f, 0.03349148f, 0.13378626f, -0.03511799f, -0.00955231f, -0.00624015f, -0.01465976f, 
    0.13346191f, -0.13974328f, -0.09393737f, -0.12817493f, -0.01150250f, -0.01002945f, 0.00919071f, -0.09246514f, 
    0.03530554f, -0.03941931f, 0.04225296f, -0.07839265f, 0.19293851f, -0.04023053f, 0.15241094f, 0.07231713f, 
    -0.06149683f, 0.11216589f, -0.11928806f, 0.02970393f, 0.13402720f, -0.09597278f, -0.00478215f, 0.00921407f, 
    -0.37271181f, 0.21791336f, 0.26284295f, 0.29165289f, -0.03491093f, 0.05132373f, 0.01584593f, -0.16275392f, 
    0.13075906f, 0.03180828f, -0.05561455f, -0.00362663f, 0.18342239f, 0.24902657f, 0.21233428f, 0.17425215f, 
    -0.06800413f, 0.09439761f, -0.13268706f, 0.09473424f, 0.05374977f, 0.00054451f, -0.00425219f, -0.01464976f, 
    0.19363292f, 0.34044924f, 0.20708577f, 0.31938803f, -0.08412591f, 0.06255058f, 0.06593756f, 0.18429139f, 
    -0.00760328f, -0.09156491f, 0.06045044f, 0.01344726f, 0.00459933f, 0.07440037f, 0.13474961f, 0.00791704f, 
    -0.02276468f, 0.02905249f, -0.14715484f, 0.11742745f, 0.01538969f, -0.01613658f, -0.04466354f, 0.04011024f, 
    -0.27319077f, -0.07839782f, -0.31219769f, 0.06443510f, -0.14132355f, -0.02240902f, 0.04070703f, -0.20047718f, 
    0.02901139f, 0.09020396f, 0.06870311f, -0.02353403f, 0.23930427f, 0.17822023f, 0.10875735f, -0.06376637f, 
    -0.01511184f, 0.08282375f, -0.01900471f, 0.15527824f, -0.01760785f, 0.03230145f, 0.04193320f, -0.04105220f, 
    0.00822927f, 0.05453246f, 0.26159814f, -0.01032849f, -0.02455361f, -0.04635740f, -0.14916940f, -0.12952396f, 
    -0.02069700f, -0.03434550f, -0.00373786f, 0.14171590f, 0.07470415f, 0.32956320f, -0.06813056f, 0.01071099f, 
    -0.16837254f, 0.07314842f, -0.03954368f, 0.19078127f, -0.03492823f, -0.16115299f, -0.07898437f, 0.16640486f, 
    -0.26877052f, -0.10325877f, -0.05257813f, 0.21656492f, 0.02610339f, 0.00885088f, -0.00498384f, -0.02324612f, 
    0.00029548f, -0.14151293f, 0.02509196f, -0.07373244f, 0.08378808f, -0.09074866f, -0.03048011f, -0.09172144f, 
    -0.05819198f, -0.07415934f, 0.04619294f, -0.00028208f, -0.05217542f, -0.00162653f, -0.06049304f, -0.09108193f, 
    -0.35492435f, 0.03120385f, -0.51873207f, 0.04612534f, -0.06634043f, 0.06929199f, 0.04167627f, 0.09819414f, 
    0.11534106f, 0.03395589f, 0.00945661f, -0.14658657f, -0.16202949f, -0.00056771f, -0.09836344f, -0.05941904f, 
    -0.05978384f, -0.05606066f, 0.00511644f, -0.06675202f, 0.05306751f, 0.04059174f, 0.06801647f, 0.19152647f, 
    -0.01931759f, 0.22352973f, 0.02850198f, 0.02128548f, 0.06352272f, -0.00390910f, -0.04509591f, 0.05711262f, 
    -0.08210347f, 0.07009344f, 0.01082694f, -0.02513499f, 0.23937538f, -0.07374592f, 0.02340652f, 0.18091075f, 
    -0.01595324f, 0.05073842f, -0.06413502f, 0.06232170f, -0.03201964f, -0.04439761f, -0.01601708f, -0.26964656f, 
    0.14962992f, 0.05261003f, 0.33760273f, -0.14148463f, 0.10463725f, 0.07078297f, 0.03534967f, 0.03165182f, 
    0.11779904f, -0.03259990f, -0.07818928f, 0.09340103f, 0.23374601f, 0.30105698f, 0.17428082f, 0.29593346f, 
    -0.02534191f, 0.05094177f, -0.08612418f, -0.06860376f, -0.02570913f, -0.11373855f, -0.08539883f, -0.05055484f, 
    0.00790333f, -0.01129808f, 0.03067977f, 0.03675026f, -0.00781853f, 0.01261989f, -0.01203589f, -0.05105678f, 
    -0.01816890f, -0.01261827f, 0.04301051f, 0.01901638f, 0.02267662f, 0.03564169f, 0.01253576f, -0.05436251f, 
    -0.01245596f, 0.00285006f, 0.00478742f, -0.04256760f, 0.00602254f, -0.01639528f, 0.01292655f, 0.04173715f, 
    0.01211649f, 0.03793612f, 0.01699277f, 0.00821564f, -0.02721394f, 0.01498805f, 0.01465530f, 0.02300363f, 
    -0.01819643f, -0.03943897f, 0.02999970f, -0.03873434f, -0.02457975f, -0.03508380f, -0.03943951f, -0.02908206f, 
    -0.03680060f, -0.03241312f, 0.01132063f, -0.01670695f, -0.00655871f, 0.03839375f, 0.01855903f, -0.03355774f, 
    0.00661655f, 0.01918174f, 0.01817077f, 0.02966207f, -0.05233813f, -0.03943488f, -0.00219131f, 0.02455617f, 
    0.01677579f, -0.03830386f, -0.05099389f, 0.00913965f, -0.02162726f, -0.05308685f, 0.00000695f, -0.02726196f, 
    0.02118358f, -0.00617421f, -0.04190679f, -0.01942134f, 0.00142868f, 0.00234643f, -0.01544284f, -0.03853299f, 
    0.03469287f, 0.00960747f, 0.00819666f, -0.02837165f, -0.03285470f, -0.02930310f, -0.04247045f, 0.02903225f, 
    0.01974135f, -0.03724929f, -0.04602949f, -0.05948114f, -0.01317693f, -0.03952359f, -0.05386446f, 0.00655916f, 
    -0.00666457f, -0.01056782f, -0.04027443f, 0.02632699f, -0.00161566f, -0.03600873f, 0.02215646f, 0.00756952f, 
    0.01320299f, -0.02061433f, -0.05309996f, 0.03718233f, -0.06062008f, -0.00317785f, 0.00701540f, 0.02658436f, 
    -0.03005845f, 0.00994519f, -0.01936177f, -0.05926235f, -0.05695238f, 0.04216475f, -0.01155259f, -0.05672721f, 
    0.03857194f, -0.03189389f, 0.04652708f, -0.03457290f, -0.00778052f, -0.01319645f, 0.01069215f, -0.05091948f, 
    0.01260843f, 0.03402913f, -0.04416604f, -0.04440660f, 0.01347644f, -0.00373847f, -0.03076942f, 0.03885004f, 
    -0.03128447f, -0.06095200f, 0.01155150f, 0.05031228f, 0.01666433f, -0.00773070f, -0.04943351f, 0.03792209f, 
    0.04070295f, 0.03213720f, 0.02977017f, -0.04169742f, -0.03575198f, 0.03759626f, -0.04724830f, -0.02176351f, 
    0.02618593f, -0.01559359f, -0.01994360f, -0.04067283f, -0.02220578f, 0.02284408f, 0.04588176f, 0.02862090f, 
    0.03278963f, 0.02632937f, -0.04097416f, -0.01088611f, 0.03655337f, 0.00272338f, -0.01046704f, 0.02415424f, 
    0.02751945f, -0.01069043f, -0.01203533f, 0.03820849f, -0.03971065f, -0.03759059f, -0.00750091f, -0.02014295f, 
    0.00816333f, 0.02837399f, -0.03495218f, 0.00795342f, -0.03012656f, -0.04309545f, 0.00747590f, -0.01705858f, 
    -0.04104689f, -0.04561252f, 0.04871254f, 0.01893728f, -0.05785949f, -0.02856614f, -0.03688354f, -0.05680532f, 
    -0.02289518f, -0.03976457f, 0.01320860f, -0.02338468f, -0.04709024f, -0.01752973f, -0.01479453f, -0.02718513f, 
    -0.00337012f, -0.04866470f, -0.04547208f, 0.03668009f, 0.00729182f, -0.00680915f, -0.02719925f, -0.00972174f, 
    0.02688385f, 0.02784525f, -0.02888285f, -0.05915674f, -0.00712682f, -0.01759732f, -0.02510033f, 0.00094982f, 
    -0.03529846f, 0.00212709f, 0.02818969f, -0.00669487f, 0.02333144f, -0.06080582f, 0.01724631f, -0.01229183f, 
    0.04271315f, -0.01208132f, -0.04279512f, -0.04117518f, -0.01983360f, -0.03344460f, -0.02412990f, -0.03195331f, 
    0.03638939f, 0.04070077f, 0.00987215f, 0.03810546f, -0.02315319f, 0.03301180f, -0.05953656f, -0.01269778f, 
    -0.05810232f, 0.02195173f, 0.03958378f, -0.03897948f, -0.02646163f, -0.03280418f, -0.04231500f, 0.01271323f, 
    -0.04249023f, -0.03608533f, -0.06042662f, -0.01211493f, -0.00427879f, 0.02381154f, -0.02445553f, 0.05458758f, 
    -0.02066192f, -0.03586804f, 0.02965206f, 0.01200738f, 0.01759452f, 0.03964320f, 0.02965086f, -0.02360788f, 
    0.03514380f, 0.03836153f, 0.02627539f, 0.03039548f, 0.02746919f, 0.00007161f, 0.02517454f, -0.01804957f, 
    -0.04088912f, -0.03277576f, -0.03240360f, -0.06446536f, -0.00489544f, 0.00901298f, 0.00055126f, 0.02892436f, 
    0.02474571f, 0.00948224f, 0.01627358f, -0.02372535f, -0.02340603f, 0.01486961f, -0.05958094f, 0.01496474f, 
    -0.04674307f, 0.03061495f, -0.04917230f, -0.02768615f, -0.01827379f, 0.02811278f, 0.00882533f, 0.01185084f, 
    -0.00302582f, -0.01662507f, -0.03156503f, 0.03257150f, 0.02062151f, 0.03277291f, 0.00263664f, -0.01427463f, 
    -0.02410776f, -0.01457986f, 0.01394847f, 0.01310200f, -0.03208015f, -0.03976533f, -0.02738137f, 0.02583704f, 
    -0.03089838f, 0.01737954f, -0.00230679f, -0.01599095f, -0.02613196f, -0.02896602f, 0.03424457f, -0.01812351f, 
    0.01719988f, -0.03522587f, -0.04101560f, -0.03215972f, 0.00412350f, -0.02007419f, 0.01125779f, -0.00487356f, 
    -0.03117749f, -0.01058391f, -0.04161851f, -0.01617262f, -0.06151302f, -0.02686099f, -0.05926393f, -0.04028733f, 
    -0.02405314f, -0.00964493f, -0.01371315f, 0.00398747f, -0.01149285f, -0.04580721f, -0.03514261f, -0.03323342f, 
    -0.05363250f, 0.01339420f, 0.02065074f, 0.02210782f, -0.00238406f, -0.04205793f, 0.03904099f, 0.02692784f, 
    0.03706229f, 0.02794298f, 0.03022665f, -0.03936827f, -0.02950344f, -0.04556701f, -0.02071114f, 0.01713412f, 
    -0.04747077f, -0.04130482f, 0.00976993f, 0.00990582f, -0.00264706f, 0.01439499f, -0.02895170f, 0.00112467f, 
    0.03400379f, -0.01936772f, -0.05686416f, -0.02934464f, -0.00659831f, -0.04541457f, -0.01708991f, -0.01668756f, 
    0.04798713f, 0.00129778f, 0.02274643f, 0.03026856f, -0.05891304f, -0.05628318f, 0.03198748f, -0.02533417f, 
    0.01427672f, -0.00657474f, 0.03479301f, -0.04912377f, -0.04270928f, 0.02535213f, -0.02374254f, 0.03987689f, 
    -0.02111994f, -0.04653699f, -0.04676270f, 0.02732692f, 0.02346297f, 0.01917067f, 0.00104431f, -0.05076927f, 
    -0.03460852f, 0.03687633f, 0.03505988f, -0.00138660f, -0.05199382f, -0.04896118f, 0.04065350f, -0.01576365f, 
    0.02739403f, -0.05208183f, -0.03595413f, -0.01145057f, -0.01910651f, 0.02337195f, -0.05828969f, -0.05273687f, 
    0.04260658f, -0.00339350f, 0.00862709f, -0.02223922f, 0.01147125f, -0.03987197f, 0.01972347f, 0.00050333f, 
    0.02746164f, 0.01264390f, -0.05580978f, 0.01572952f, -0.02340956f, 0.04399199f, 0.00161940f, -0.01513212f, 
    0.01659157f, -0.05931477f, -0.05543717f, -0.04302442f, 0.02681290f, 0.02471937f, -0.01319661f, -0.01979419f, 
    -0.02675743f, 0.01115209f, -0.01952634f, 0.02034985f, 0.02611218f, 0.02975795f, 0.01748891f, 0.00677065f, 
    0.00282782f, -0.05204652f, 0.02366029f, -0.03441707f, 0.02508913f, 0.00161299f, -0.05508775f, -0.04687217f, 
    0.00960985f, -0.02783095f, -0.04521288f, 0.02652114f, 0.01560257f, 0.01052277f, -0.03760983f, -0.00753433f, 
    0.02623442f, 0.02067222f, 0.01963841f, -0.04906501f, -0.02435494f, -0.06081512f, -0.03016573f, 0.00354838f, 
    -0.04848832f, -0.00144276f, 0.01066901f, -0.02264130f, 0.02622450f, -0.01905767f, -0.05719119f, 0.03396645f, 
    -0.00430766f, 0.03104791f, 0.02066319f, 0.00791673f, -0.02294018f, -0.03973605f, 0.02584268f, 0.01269978f, 
    -0.02137095f, -0.01207572f, -0.03360026f, -0.04765287f, 0.01202045f, -0.01050180f, 0.00024582f, -0.00016195f, 
    0.00165478f, -0.05112946f, -0.05525732f, 0.02903967f, -0.04422456f, 0.03059249f, 0.01530134f, -0.00798999f, 
    0.00266424f, 0.00197728f, -0.00546839f, -0.04934063f, -0.05542223f, -0.02677179f, 0.02241016f, 0.01566698f, 
    0.02436431f, 0.03222637f, 0.01873395f, -0.03195602f, -0.03408079f, 0.01315307f, -0.03220547f, -0.03808796f, 
    0.01289171f, -0.04922245f, -0.03139841f, -0.05479357f, 0.03431134f, 0.05153984f, 0.02041963f, 0.04714921f, 
    0.03114072f, -0.02119138f, 0.00252699f, -0.05361530f, 0.02350998f, -0.04981349f, 0.02685264f, -0.04188053f, 
    0.02117973f, -0.05437836f, -0.03558351f, -0.03397395f, 0.01405319f, 0.02307181f, 0.03182693f, 0.01374755f, 
    0.02570187f, -0.04886571f, -0.02441519f, -0.02196731f, 0.02667717f, -0.03347245f, -0.03305100f, -0.00871249f, 
    0.02074994f, -0.00914846f, 0.02118015f, 0.00371857f, 0.00704429f, 0.00510311f, -0.04005186f, -0.02604120f, 
    0.00025161f, -0.01886537f, 0.04026022f, -0.02827613f, -0.00057928f, -0.02259268f, 0.03433711f, -0.04470295f, 
    -0.01953712f, -0.04483151f, -0.04421301f, 0.01800437f, 0.02521612f, 0.03661799f, 0.03917306f, 0.02362209f, 
    -0.03910151f, 0.03673979f, 0.00102556f, 0.02007615f, -0.05681922f, 0.03012988f, -0.04491843f, -0.02184673f, 
    0.00534217f, -0.05343124f, -0.02636242f, -0.03941807f, -0.01755962f, -0.03997070f, -0.04509854f, -0.02364158f, 
    -0.00686795f, -0.01881453f, -0.05028381f, -0.04903264f, -0.04405754f, 0.04027662f, -0.03392927f, -0.01095519f, 
    0.02561056f, -0.06052963f, -0.01634565f, 0.01685633f, -0.02991027f, 0.01452483f, -0.03007019f, 0.01523571f, 
    0.02099888f, 0.02070214f, 0.02508863f, -0.05628946f, 0.03385688f, 0.00589038f, 0.00916014f, 0.03019323f, 
    0.03241202f, -0.01906029f, 0.01109476f, -0.00014249f, -0.03693818f, 0.04055990f, 0.03542439f, -0.00956286f, 
    -0.00937710f, 0.01811235f, 0.02571904f, -0.02514099f, -0.00974820f, -0.01868590f, 0.03098949f, 0.02322518f, 
    0.03218588f, 0.03259312f, 0.00851293f, -0.00503743f, -0.05651330f, 0.03061806f, -0.00954567f, 0.00169175f, 
    0.00891248f, 0.03994644f, -0.04629682f, -0.03446710f, 0.00424329f, 0.02281906f, -0.03141161f, -0.03324427f, 
    -0.01971791f, 0.03754241f, -0.00319519f, -0.04772197f, -0.02084415f, 0.00097516f, 0.03453770f, -0.04247690f, 
    -0.04310852f, -0.05319212f, 0.04344602f, -0.03275111f, -0.04896089f, -0.02353243f, -0.02300351f, 0.03460688f, 
    -0.00893514f, -0.02894833f, -0.00885561f, -0.04347466f, -0.05202013f, -0.00689959f, -0.03364890f, 0.00175677f, 
    -0.01292554f, -0.02979461f, -0.04061352f, 0.02312734f, 0.00221119f, -0.01769767f, -0.01641528f, 0.01436767f, 
    0.01382830f, 0.04030552f, 0.01914723f, 0.03758201f, -0.05649633f, -0.01690258f, -0.02748116f, -0.02875104f, 
    0.01328620f, -0.04953263f, 0.03532707f, 0.00714356f, -0.00801031f, 0.03997090f, 0.02609849f, 0.00180743f, 
    -0.03099339f, 0.02922314f, 0.00638039f, -0.02656483f, -0.06132860f, -0.05180787f, 0.01604884f, 0.02936440f, 
    0.00742775f, -0.04118704f, 0.01198793f, -0.02352579f, 0.00830147f, -0.02632013f, 0.00546839f, 0.04104992f, 
    0.01369905f, -0.00452108f, 0.03491934f, 0.00171080f, -0.02847844f, -0.03893117f, 0.03351077f, -0.00985602f, 
    0.03957852f, -0.05193251f, -0.01818324f, 0.02130909f, 0.03779140f, 0.03683121f, 0.02586474f, -0.03480925f, 
    0.02385514f, 0.02971024f, -0.03427466f, -0.05135223f, -0.01656403f, -0.00612087f, -0.05547143f, -0.05862901f, 
    -0.03987038f, 0.02346599f, 0.03432023f, -0.04019828f, -0.03012249f, 0.00789682f, -0.02541415f, -0.02323245f, 
    -0.02440128f, 0.03031420f, -0.03724593f, 0.03469756f, -0.00971034f, 0.02621940f, -0.01897278f, 0.04476744f, 
    0.03140919f, -0.01466442f, 0.01045233f, 0.02279528f, -0.00675197f, 0.00307731f, -0.00600283f, -0.00453288f, 
    -0.04593695f, 0.01739482f, -0.05598138f, -0.02928899f, -0.02298826f, -0.00897114f, -0.00105338f, -0.02211280f, 
    -0.05260070f, 0.00584082f, 0.03502935f, -0.04645266f, -0.01938430f, -0.03998141f, 0.03889736f, 0.01541070f, 
    0.46335617f, 0.02907307f, 0.08619097f, 0.08007303f, -0.05394128f, 0.00247875f, 0.10652341f, 0.09901553f, 
    0.08159441f, 0.09524672f, 0.06056538f, -0.02882603f, 0.18435176f, 0.18606165f, 0.06908143f, 0.07105344f, 
    0.00762414f, -0.10504976f, 0.02385019f, -0.11066828f, -0.05532533f, 0.06867375f, -0.10832472f, -0.02927736f, 
    0.19311129f, -0.02851115f, -0.12393338f, -0.41759306f, 0.00036768f, -0.18904209f, -0.08191992f, 0.00216046f, 
    0.18864608f, -0.00694794f, -0.07972731f, -0.09241639f, 0.03064512f, 0.02085957f, 0.22962323f, 0.09350114f, 
    0.02936986f, 0.00801959f, 0.06718974f, -0.08979440f, -0.05963038f, -0.06052784f, -0.10997123f, -0.05000184f, 
    -0.20884369f, 0.09955672f, 0.07055502f, 0.02028025f, -0.03176560f, -0.08527734f, 0.09514382f, -0.11742321f, 
    0.00855180f, -0.11983665f, -0.17525652f, -0.11776315f, 0.04772043f, -0.02749673f, 0.11901215f, 0.05994196f, 
    0.02060273f, -0.02793896f, -0.00502484f, 0.28782699f, 0.07766716f, 0.05701772f, -0.04509311f, -0.05349197f, 
    -0.12483210f, 0.14640051f, 0.22620519f, -0.02677887f, -0.12239553f, -0.07486685f, 0.13155310f, 0.06614055f, 
    -0.04578966f, -0.09583887f, 0.03265362f, -0.06511576f, -0.36033961f, -0.41026965f, -0.26049396f, -0.13029380f, 
    0.04776696f, 0.14510573f, 0.08587694f, 0.04780754f, 0.19464807f, -0.08677063f, -0.05285244f, 0.13225897f, 
    -0.07808175f, 0.13318419f, -0.02241102f, -0.03564533f, -0.01847292f, -0.05857207f, 0.05676299f, -0.07155789f, 
    -0.00535401f, -0.22484282f, -0.02240983f, -0.11347150f, 0.12957110f, 0.00598895f, 0.02492553f, 0.09432901f, 
    -0.03441180f, 0.08444247f, -0.08423352f, 0.13154127f, -0.04757960f, -0.13647351f, 0.14896920f, -0.15004501f, 
    0.16092263f, 0.27545056f, 0.14894752f, 0.07626146f, -0.02127904f, -0.06145164f, -0.16972418f, 0.02100332f, 
    0.00890346f, 0.16607696f, 0.15862273f, -0.02426378f, 0.00962597f, 0.23593071f, 0.09379068f, -0.03813539f, 
    -0.01520266f, 0.14568950f, -0.06489547f, -0.13436317f, -0.06300367f, -0.08902729f, -0.13087298f, -0.02937363f, 
    0.11605179f, 0.10745496f, 0.07337286f, -0.00941462f, 0.10663345f, 0.01086467f, 0.04231280f, 0.00778023f, 
    -0.03643318f, -0.06491268f, -0.07426279f, -0.09047112f, -0.06886669f, -0.04439593f, 0.17802858f, 0.29351047f, 
    -0.04155135f, 0.04245039f, 0.05196872f, 0.19089542f, 0.03204967f, -0.04824289f, -0.12872320f, -0.01048879f, 
    0.52600783f, 0.16158995f, -0.01235540f, 0.13511120f, 0.00333684f, -0.02035187f, -0.04716799f, 0.02208984f, 
    0.08415457f, 0.04207742f, -0.03874058f, -0.03687584f, -0.15964369f, 0.01131571f, 0.04243454f, -0.11896256f, 
    -0.01793257f, 0.20476452f, -0.09773094f, -0.06358136f, 0.03898495f, -0.17957121f, -0.01187710f, 0.04800517f, 
    -0.49895281f, -0.05373214f, -0.29241425f, 0.22818588f, -0.08496395f, 0.10690084f, 0.16321675f, 0.01708338f, 
    0.12103216f, 0.06346252f, -0.07631276f, 0.11941019f, -0.16810265f, 0.18269090f, 0.37544316f, 0.12241937f, 
    -0.14675568f, -0.14411467f, 0.01152773f, -0.15546903f, -0.02098418f, -0.09537229f, -0.03246956f, -0.03603143f, 
    -0.08641367f, 0.06027637f, 0.13216196f, 0.36740801f, 0.09271589f, -0.06266198f, 0.12610801f, 0.21051705f, 
    0.00096654f, -0.17247617f, 0.01701601f, -0.06950266f, 0.02233992f, -0.16605024f, 0.18640344f, 0.24078937f, 
    0.00536823f, 0.03993597f, 0.09541568f, 0.25741196f, 0.01890256f, -0.02235416f, -0.06536274f, 0.07282466f, 
    0.13149326f, -0.05705998f, -0.03838860f, 0.23111883f, -0.01725095f, 0.04934830f, -0.01910498f, 0.04922954f, 
    0.09088586f, 0.22181240f, -0.08276644f, -0.00094229f, 0.13442858f, 0.08818501f, 0.20015077f, -0.20524874f, 
    -0.04168743f, -0.12027815f, -0.04682726f, 0.09974658f, -0.10654663f, -0.16420071f, -0.16743138f, -0.08262854f, 
    -0.06580099f, 0.05544891f, 0.13427673f, 0.07537143f, 0.04761178f, 0.00235397f, 0.01534618f, -0.13336964f, 
    -0.10751017f, 0.07879721f, 0.00544956f, -0.03666982f, -0.17452367f, -0.03445861f, -0.02966495f, 0.22086217f, 
    -0.08668165f, 0.14289406f, 0.08333166f, 0.17237338f, -0.07672941f, 0.02451264f, 0.16266963f, 0.05269855f, 
    0.07653226f, 0.17386639f, 0.15732716f, 0.15046328f, 0.06289875f, -0.08516514f, -0.01611072f, -0.00362275f, 
    -0.00410750f, -0.09495080f, -0.07802583f, -0.05677553f, 0.23811968f, 0.10719661f, -0.05217630f, 0.08767993f, 
    0.03868151f, -0.03879305f, 0.01013174f, 0.05562578f, -0.05059515f, -0.05763010f, -0.02969259f, -0.05824179f, 
    0.35568997f, 0.22568075f, -0.02643575f, 0.00618636f, -0.11456496f, -0.21098273f, -0.20773290f, -0.00922866f, 
    -0.11277670f, 0.09377529f, -0.06091382f, 0.01205792f, 0.22898586f, 0.18020715f, 0.20458689f, 0.05171056f, 
    -0.02558429f, 0.08030501f, -0.02963262f, -0.00472116f, 0.02155233f, -0.00840046f, -0.11014321f, 0.15144056f, 
    -0.09135151f, -0.04974013f, -0.06955110f, 0.21893470f, 0.06488656f, -0.06203803f, 0.12530743f, 0.09697187f, 
    -0.13820371f, 0.04057505f, -0.01729809f, -0.06701701f, 0.00790367f, -0.15450604f, 0.08927798f, 0.28616717f, 
    0.12092776f, 0.04877981f, 0.13541126f, 0.07469328f, 0.14307255f, -0.09520044f, 0.01524829f, -0.01126357f, 
    -0.29440200f, -0.00262059f, 0.33742961f, 0.02772436f, -0.01913354f, -0.05989721f, 0.11157516f, 0.17615788f, 
    0.11869521f, -0.05966746f, 0.07028937f, -0.00473598f, -0.14197260f, -0.11400283f, -0.19995473f, 0.15782924f, 
    0.02973589f, -0.01721686f, 0.06471138f, 0.00467461f, -0.08916381f, -0.20848288f, 0.03605216f, -0.08658554f, 
    0.17297637f, -0.46545094f, 0.08884255f, 0.13091496f, -0.00784610f, -0.00638042f, -0.01512016f, 0.02052081f, 
    -0.00660062f, -0.06577593f, -0.08484887f, 0.11480481f, -0.06310616f, -0.08602069f, 0.07331989f, 0.03037955f, 
    0.10171051f, 0.05396495f, -0.04344073f, -0.09901638f, 0.00976847f, -0.12998582f, 0.11224346f, 0.12833878f, 
    0.00956708f, -0.10045772f, -0.28946614f, -0.20194311f, -0.00133591f, 0.07943010f, -0.03259506f, 0.03532417f, 
    -0.02372688f, -0.01006227f, 0.16334976f, -0.06872926f, 0.03130784f, 0.01994335f, -0.17407914f, -0.08444130f, 
    0.03657952f, 0.03155132f, -0.14201425f, 0.11320861f, -0.05901799f, -0.12313143f, -0.01543690f, 0.06788180f, 
    -0.22880135f, -0.02148710f, -0.10222446f, 0.05969642f, -0.13513324f, -0.05112266f, 0.03327040f, 0.13135384f, 
    0.04913787f, -0.09581672f, 0.25810525f, 0.07430063f, 0.19320382f, 0.31532580f, -0.32603747f, 0.06383409f, 
    -0.04287201f, 0.09641754f, 0.05871898f, 0.12865198f, 0.21152781f, 0.07125420f, 0.07925762f, -0.03479762f, 
    0.12069633f, 0.13938387f, 0.25950369f, -0.18565604f, 0.13479608f, -0.00559423f, -0.01845781f, 0.13274756f, 
    0.01013977f, 0.09130105f, 0.00041700f, 0.06163390f, -0.02001749f, 0.06794348f, 0.08593556f, -0.08427422f, 
    -0.02752776f, 0.02978680f, 0.04229114f, 0.01180185f, 0.09167975f, 0.06312606f, -0.08239903f, -0.15455623f, 
    -0.06408126f, -0.09522050f, -0.08710478f, -0.23729709f, 0.03743415f, -0.05208089f, -0.08060137f, 0.08813255f, 
    -0.02650675f, 0.02567711f, -0.11576274f, 0.01890980f, -0.28570697f, 0.07024795f, 0.14349397f, 0.05702894f, 
    0.09471666f, 0.15002944f, 0.04212792f, -0.24998996f, -0.02700757f, 0.04652075f, -0.18968335f, 0.06505516f, 
    -0.30808863f, -0.13377008f, 0.20661579f, -0.14525712f, -0.00245500f, 0.07905876f, 0.13808742f, -0.03914038f, 
    0.01580214f, -0.07271650f, 0.03047115f, 0.17083263f, -0.15564156f, 0.12567620f, -0.00705543f, -0.09304455f, 
    0.09230430f, -0.04555090f, 0.00239262f, 0.02567162f, -0.07964317f, -0.04396462f, 0.03165966f, 0.09650774f, 
    0.17927617f, 0.15317349f, 0.12719651f, -0.05615488f, -0.02070387f, 0.01476933f, -0.03168568f, 0.00112696f, 
    -0.12446658f, -0.17096820f, 0.07213662f, -0.01875388f, 0.14801793f, 0.44047052f, 0.03423639f, 0.10524658f, 
    -0.02221837f, 0.01946548f, 0.00558200f, -0.00198736f, 0.01701806f, 0.13231018f, -0.07335201f, -0.02305840f, 
    -0.19477642f, 0.00344896f, 0.21111830f, 0.07577815f, 0.04597284f, -0.07819029f, -0.16009903f, -0.04211623f, 
    -0.04839559f, -0.04791097f, 0.19803768f, -0.05799984f, 0.05977776f, 0.05290405f, 0.13729824f, -0.00917614f, 
    -0.02841647f, 0.05989300f, 0.05889788f, 0.09467412f, 0.06123067f, -0.02413126f, 0.07240602f, -0.13063169f, 
    -0.25845838f, 0.08404627f, 0.62488347f, 0.12818101f, -0.13395885f, 0.04330800f, 0.12898904f, -0.10974776f, 
    0.04993193f, -0.12313798f, 0.06028516f, 0.08312222f, 0.26949701f, 0.26633486f, -0.09435734f, 0.02206133f, 
    0.09692135f, 0.17954610f, -0.07156090f, 0.22308455f, 0.07710468f, -0.04336586f, 0.04592232f, 0.07644687f, 
    0.13182184f, 0.16092101f, 0.07113981f, -0.01224896f, 0.02698529f, 0.13523287f, -0.01579852f, 0.04600782f, 
    -0.02061189f, 0.09266371f, 0.03169762f, -0.02366600f, 0.16967306f, 0.11219512f, -0.08867860f, -0.13779548f, 
    0.10139821f, 0.05187200f, 0.07132435f, 0.02895585f, 0.02095164f, 0.04726170f, -0.02693391f, 0.15106370f, 
    -0.32165918f, 0.04487536f, -0.44423410f, 0.04970136f, 0.01803126f, -0.03209491f, 0.03522362f, -0.02165090f, 
    0.05876495f, -0.09143875f, -0.03232347f, 0.08258368f, 0.26837158f, 0.28897762f, 0.07949694f, 0.04439748f, 
    0.16051985f, 0.16202082f, 0.09723137f, 0.07384092f, -0.07296567f, 0.07877277f, 0.13025582f, 0.00347422f, 
    0.05296311f, 0.10268011f, -0.03143664f, -0.15718670f, 0.03730971f, -0.02405650f, 0.05057482f, 0.01130684f, 
    -0.05077662f, -0.01759520f, -0.04123193f, 0.13992728f, 0.13604526f, 0.12978388f, -0.01032146f, -0.10125080f, 
    0.00574822f, -0.03804697f, 0.13916716f, 0.01048411f, 0.09749435f, -0.10158724f, -0.04932717f, -0.01594328f, 
    -0.23711531f, 0.06504820f, 0.09563249f, 0.14813250f, 0.07469647f, 0.19065063f, -0.07144723f, -0.15256439f, 
    -0.10837494f, -0.00510827f, -0.04357868f, 0.04682741f, 0.08424911f, -0.07617173f, 0.36489388f, 0.14713158f, 
    -0.09325137f, -0.05009254f, 0.02721593f, -0.13961907f, 0.02540604f, 0.03489860f, -0.04870106f, -0.09827326f, 
    -0.20372875f, 0.33386719f, -0.51668924f, 0.01739999f, 0.13236751f, 0.10563675f, -0.03646890f, 0.06266600f, 
    0.04979571f, -0.00478687f, -0.14214717f, -0.16394539f, -0.12263122f, 0.04172662f, -0.29727039f, 0.11636839f, 
    -0.03793054f, -0.03588786f, 0.21979101f, 0.02163106f, -0.07737007f, -0.08557365f, 0.22546212f, 0.06746845f, 
    -0.04675764f, 0.08275336f, 0.12888891f, -0.17384462f, 0.01480019f, -0.03118159f, 0.04476042f, 0.02142712f, 
    0.01530706f, 0.03682611f, -0.06248479f, 0.13372828f, 0.08831660f, 0.02827865f, -0.00457389f, -0.06440295f, 
    -0.12464353f, -0.00723707f, -0.13596700f, 0.05005852f, 0.01515133f, -0.05224268f, -0.02469246f, 0.12644728f, 
    0.20530495f, -0.04553619f, 0.13011532f, -0.23490909f, 0.01830241f, 0.03724517f, 0.05085747f, 0.04446480f, 
    -0.00858237f, -0.01002315f, -0.03347301f, 0.12561330f, 0.21330406f, 0.05572895f, 0.07722059f, 0.06658548f, 
    -0.14484811f, -0.01885304f, -0.15835197f, -0.13678840f, 0.15231055f, 0.07212193f, -0.03504926f, -0.05519574f, 
    0.01636630f, 0.06247481f, -0.38047037f, 0.04869658f, -0.06245545f, -0.04359404f, -0.14436944f, -0.08565520f, 
    0.07723509f, 0.12388232f, -0.06912820f, 0.10220127f, -0.23411040f, 0.01373480f, 0.04738203f, 0.03828896f, 
    -0.00142001f, 0.04027925f, 0.02474338f, -0.21383721f, -0.09405778f, -0.26659665f, -0.01070234f, -0.20915754f, 
    0.19680996f, 0.01066149f, -0.09816784f, -0.11952313f, 0.05457176f, 0.20614697f, -0.13108997f, -0.10014437f, 
    -0.01101003f, 0.02987836f, 0.01721836f, -0.02368254f, 0.17102802f, 0.04280012f, -0.07763661f, -0.11454677f, 
    -0.02009975f, 0.08326024f, -0.04702793f, 0.01456291f, -0.07248604f, -0.11634731f, 0.03251238f, -0.02240774f, 
    0.02142418f, -0.12461957f, 0.03219573f, -0.13273866f, -0.22091012f, 0.00923602f, -0.16258107f, 0.09068366f, 
    0.02978924f, 0.16978721f, 0.13501668f, 0.20463271f, 0.12091118f, 0.20703287f, -0.35904652f, 0.01408191f, 
    -0.05705779f, -0.00460729f, 0.03406505f, 0.07578557f, 0.10982453f, -0.12161795f, -0.06047919f, -0.02659560f, 
    0.00010230f, 0.02957522f, -0.01192670f, -0.14332035f, -0.05471755f, -0.07516024f, -0.04263043f, 0.06514622f, 
    0.04327085f, -0.01814489f, -0.09820916f, 0.09058826f, 0.08279530f, -0.04939529f, 0.00394672f, -0.03590716f, 
    -0.00197298f, 0.03974750f, -0.02747602f, -0.08258381f, -0.04158912f, 0.02252662f, -0.19755232f, 0.11022974f, 
    0.28850526f, 0.04746553f, 0.03089364f, 0.01704410f, -0.01396213f, 0.10183240f, -0.01578038f, -0.05312551f, 
    0.12819658f, 0.10602134f, 0.00868815f, -0.03723370f, -0.17315243f, -0.09390774f, 0.28175598f, 0.20488873f, 
    -0.18037133f, 0.13943280f, 0.06882432f, -0.44650185f, -0.24116354f, -0.08597109f, 0.01104548f, 0.03727939f, 
    -0.41397965f, -0.07861613f, -0.05476620f, 0.23089835f, 0.10361513f, 0.08503814f, 0.07168181f, 0.03979326f, 
    -0.10535394f, 0.00806745f, -0.00027312f, 0.05829360f, 0.09520780f, 0.16588672f, 0.07215189f, -0.15883924f, 
    -0.01088956f, 0.04933776f, -0.11201619f, 0.06441356f, -0.08586470f, -0.03390148f, -0.18772386f, -0.09558327f, 
    0.15619820f, -0.08431405f, 0.03634019f, -0.13818191f, -0.11555381f, -0.10677671f, -0.13401131f, -0.13978821f, 
    -0.26021808f, -0.14204501f, -0.08484563f, -0.08759659f, 0.19314227f, 0.15212932f, -0.11457091f, -0.10413362f, 
    -0.09710862f, 0.02583321f, -0.10331516f, 0.06064651f, -0.03812369f, -0.01539317f, -0.07226151f, 0.03096223f, 
    -0.03540099f, 0.30263808f, 0.27372548f, 0.28047305f, -0.10030939f, -0.17527747f, -0.14438982f, -0.13914093f, 
    -0.04203827f, 0.11015853f, -0.00899532f, -0.02721017f, 0.21395792f, 0.28943866f, -0.08026476f, -0.08871900f, 
    0.09377965f, 0.03506836f, 0.09837581f, 0.04391468f, 0.04560229f, 0.13779400f, 0.02900327f, 0.01916138f, 
    -0.16678564f, 0.30236620f, 0.35955548f, -0.20240049f, 0.08469637f, 0.11272720f, -0.03439185f, 0.17264189f, 
    0.06619451f, -0.05827373f, 0.06910309f, -0.17816550f, 0.22192642f, 0.13106717f, -0.01932419f, -0.12495058f, 
    0.04721462f, 0.12232103f, -0.09441783f, 0.01457338f, 0.00452591f, -0.03914046f, 0.04850910f, -0.06521161f, 
    0.09998404f, 0.09955419f, -0.05630021f, -0.18224837f, 0.07427311f, 0.03234577f, -0.07020371f, -0.03555258f, 
    -0.00492864f, -0.06999475f, -0.01297006f, -0.19512902f, 0.38947383f, 0.23791513f, -0.21317016f, -0.20134993f, 
    0.13115749f, -0.03177789f, 0.11648738f, 0.01910426f, -0.12298369f, -0.00819358f, -0.03178200f, -0.08815991f, 
    -0.10060707f, -0.27223480f, -0.26070851f, 0.32623458f, -0.09310801f, -0.03931881f, 0.16922608f, -0.16302988f, 
    -0.02566587f, 0.04444923f, -0.06617238f, 0.10309991f, 0.06208227f, -0.05083399f, -0.11080089f, -0.23598841f, 
    0.05085442f, 0.02856619f, -0.02372481f, 0.03208977f, -0.00681671f, 0.14790492f, -0.04835332f, 0.04434751f, 
    0.17092286f, 0.11008190f, 0.04845648f, -0.00157360f, 0.04017116f, -0.04205677f, -0.07148261f, -0.10661570f, 
    0.09498765f, 0.10899040f, 0.07110939f, 0.14858252f, 0.13825235f, 0.15042946f, -0.06395022f, -0.21254122f, 
    0.05726419f, -0.03847118f, 0.08703550f, 0.15822716f, 0.10467736f, -0.02106803f, -0.03521352f, -0.08449163f, 
    -0.41767254f, -0.14086755f, 0.24184500f, 0.07622287f, 0.06868954f, 0.08438627f, -0.00894136f, 0.08123093f, 
    0.09634715f, -0.12435482f, 0.00551591f, -0.07915198f, 0.00503951f, 0.15023327f, 0.24188662f, 0.11066419f, 
    -0.08693838f, -0.06207047f, 0.14215188f, 0.04435846f, -0.12569737f, 0.08679242f, 0.03765602f, 0.00321974f, 
    -0.20497717f, -0.25347632f, 0.14329737f, -0.07894068f, -0.04035770f, -0.19580764f, -0.01491694f, -0.00771576f, 
    0.10033531f, -0.13838135f, -0.01296647f, -0.23039339f, -0.41300279f, -0.11749295f, -0.01588974f, 0.20272736f, 
    -0.21643707f, -0.09718471f, -0.08745059f, -0.05398196f, 0.05721574f, 0.07871576f, 0.07349095f, 0.02319819f, 
    0.28520644f, 0.08681591f, 0.03845799f, -0.15967706f, 0.14513007f, -0.00359897f, -0.07642858f, -0.10852372f, 
    0.07555208f, -0.01470493f, 0.17950401f, 0.00105492f, 0.13447477f, 0.00952092f, -0.00068814f, -0.05513897f, 
    0.00976185f, -0.09958984f, -0.02020387f, -0.11349671f, -0.07138657f, -0.20786533f, 0.13148770f, 0.04278660f, 
    0.12954956f, 0.23969562f, -0.12641977f, -0.10723981f, 0.05073231f, -0.06502066f, 0.11809111f, -0.06109755f, 
    0.00125959f, -0.06330546f, -0.01082889f, -0.04801480f, 0.15316993f, 0.01072768f, 0.23551185f, -0.03277580f, 
    0.06506602f, -0.04603985f, -0.07463472f, -0.12559004f, -0.10791726f, 0.00712376f, -0.03330733f, -0.01553524f, 
    0.04301875f, 0.01334405f, 0.00949985f, -0.03826247f, -0.00269732f, 0.02442654f, 0.00785694f, -0.00462245f, 
    -0.00164799f, -0.04688288f, 0.01704355f, -0.04103776f, -0.04737455f, -0.04830017f, -0.04968416f, 0.00468032f, 
    -0.03216718f, 0.02120496f, 0.01869692f, -0.01889581f, 0.03089111f, 0.02955595f, -0.02811689f, 0.03602684f, 
    -0.00358661f, 0.00756203f, -0.02168144f, 0.02624836f, -0.03333100f, 0.01052861f, -0.02454583f, -0.04362976f, 
    -0.02791842f, -0.00898003f, -0.04555827f, 0.01765227f, -0.04296195f, -0.00140569f, -0.05538281f, -0.03246622f, 
    0.00248093f, 0.00745971f, 0.02608627f, 0.03962194f, -0.00890849f, 0.02132028f, -0.01799888f, -0.05624026f, 
    0.04513837f, 0.02765665f, -0.00719568f, 0.02680549f, -0.06025901f, 0.01434976f, -0.03504061f, 0.03365617f, 
    -0.02378816f, 0.04034144f, -0.00502421f, 0.00111022f, -0.05167007f, -0.05079079f, -0.04682069f, -0.05170213f, 
    -0.04290641f, -0.02640297f, 0.03529986f, -0.01783184f, -0.02491140f, 0.03718668f, 0.03898298f, -0.03030756f, 
    -0.02350754f, -0.05682136f, -0.01544132f, -0.03727518f, -0.00947713f, -0.03269833f, 0.03284887f, -0.05137081f, 
    -0.03217959f, -0.05071131f, 0.02999355f, -0.02869601f, 0.01790143f, 0.03038537f, 0.00471525f, 0.02915470f, 
    -0.00946605f, -0.05312686f, 0.03478891f, 0.00326565f, 0.02066532f, -0.04467232f, -0.04405314f, 0.01858008f, 
    0.01459838f, -0.05157557f, 0.02478226f, -0.04862128f, 0.03358780f, 0.02815885f, -0.02949481f, -0.02076890f, 
    0.03382692f, -0.02225838f, 0.01548187f, -0.00940058f, 0.03360141f, 0.02633516f, 0.03865628f, -0.01069324f, 
    -0.00346947f, -0.00614163f, -0.05267086f, 0.03326815f, -0.04307203f, -0.03987159f, 0.02915482f, -0.01784565f, 
    -0.05330639f, -0.00326084f, -0.05031521f, 0.04011048f, -0.00645526f, -0.02221207f, -0.03044246f, -0.00432536f, 
    -0.00512354f, 0.02069638f, 0.02034497f, 0.03286659f, -0.03055282f, -0.02637810f, -0.00985309f, 0.02488710f, 
    -0.01277344f, 0.01730631f, -0.03698255f, 0.00200615f, 0.01769869f, -0.03345403f, -0.00036824f, -0.02480420f, 
    -0.03085410f, 0.02203619f, -0.01160561f, -0.00614173f, -0.01445606f, 0.03766937f, -0.05873056f, 0.01200322f, 
    -0.03337677f, 0.00100976f, -0.02540467f, 0.00186213f, -0.00244997f, 0.01301199f, -0.03915928f, -0.03592709f, 
    -0.03157882f, -0.03777585f, -0.01421007f, 0.02680937f, -0.04594634f, 0.03386736f, -0.00136344f, 0.02663794f, 
    0.00527966f, 0.04100337f, -0.03976054f, -0.02819662f, 0.03666268f, -0.03242740f, -0.01813156f, -0.00116414f, 
    -0.00991737f, -0.02783294f, -0.00130053f, 0.01653982f, -0.02905248f, 0.00058885f, -0.05431792f, 0.02796054f, 
    -0.03641429f, 0.03189800f, -0.02204092f, 0.03586194f, -0.00784355f, -0.03741483f, -0.05438972f, -0.01594411f, 
    -0.04229884f, -0.02630612f, -0.03503577f, 0.04392248f, -0.05932680f, 0.00259115f, -0.04750026f, -0.02235589f, 
    -0.06003205f, 0.01729016f, 0.02576596f, -0.00323079f, -0.00180978f, 0.01091257f, -0.04215270f, 0.00174467f, 
    0.03046737f, 0.00857604f, -0.00503794f, -0.02497070f, -0.04053453f, 0.03901918f, 0.03629431f, 0.00524778f, 
    -0.00745548f, 0.02745912f, -0.04872392f, -0.03090698f, -0.02860954f, -0.00964965f, 0.01451626f, -0.05258314f, 
    -0.00661817f, 0.03022639f, 0.02417070f, 0.00699746f, 0.02978260f, -0.00265331f, 0.03129659f, -0.02130758f, 
    -0.04519686f, -0.00450970f, 0.03501030f, -0.00348681f, 0.00996123f, -0.04267343f, 0.02807567f, -0.04291413f, 
    -0.04319976f, 0.03310072f, -0.04704703f, 0.00738900f, -0.05912269f, -0.05366917f, 0.00092307f, -0.04171893f, 
    0.03242993f, -0.00354960f, -0.01323539f, -0.05236108f, 0.01092352f, -0.02565084f, -0.05336962f, -0.04101847f, 
    0.00279892f, -0.00379000f, -0.02028370f, -0.03192307f, -0.05472779f, -0.02128765f, 0.00196880f, -0.01850519f, 
    -0.05203993f, 0.02076086f, -0.02077906f, -0.02177806f, 0.02851060f, -0.02380853f, 0.03766883f, -0.01607249f, 
    -0.03543441f, -0.03578553f, -0.00352787f, 0.02739755f, 0.02278215f, 0.01974397f, 0.03012217f, 0.02472232f, 
    0.03105924f, -0.05514244f, 0.00776929f, -0.02025301f, 0.02525233f, 0.03697527f, -0.00439756f, -0.00390060f, 
    0.02224757f, 0.03744588f, 0.00715630f, -0.00676466f, 0.04265776f, -0.01998891f, 0.01067323f, -0.02157418f, 
    0.00547159f, 0.00771949f, -0.01797733f, 0.02327515f, -0.01372573f, -0.03140966f, -0.03611001f, -0.01993361f, 
    -0.01340362f, 0.02436251f, -0.05298550f, -0.03009658f, 0.02467884f, -0.04101883f, 0.02248107f, -0.02074777f, 
    0.03156032f, -0.05790464f, 0.03783103f, 0.02988936f, -0.02103601f, -0.04364073f, -0.01042229f, -0.00237681f, 
    0.03398784f, -0.03142527f, 0.01388447f, 0.00326259f, 0.01755690f, -0.01032010f, -0.05377886f, -0.04695632f, 
    0.02894910f, 0.00475199f, 0.00486412f, 0.02934431f, -0.00464114f, 0.02861432f, 0.00349020f, 0.03022614f, 
    -0.00564429f, -0.00165874f, 0.03071876f, -0.00737766f, -0.00816740f, -0.02874719f, 0.02690559f, 0.01865423f, 
    0.03389090f, -0.05221554f, 0.02831690f, 0.01160810f, -0.04683051f, -0.03007749f, -0.00803558f, -0.01246359f, 
    -0.03749454f, -0.02825143f, -0.03006097f, 0.00533498f, -0.04325455f, 0.00616927f, 0.04069910f, 0.00418742f, 
    0.02266485f, 0.02528721f, -0.00482035f, -0.02443745f, -0.05824097f, 0.00923532f, 0.02331711f, -0.01199483f, 
    -0.04160738f, 0.01139910f, -0.04856124f, -0.04653649f, 0.03637481f, -0.05308355f, -0.02716708f, -0.00450981f, 
    -0.00841257f, -0.02719507f, 0.02535815f, 0.01368565f, -0.03433570f, -0.01227702f, 0.01444236f, 0.03131623f, 
    -0.05504511f, -0.00960434f, 0.00081069f, -0.04778741f, 0.03345670f, -0.02759910f, -0.01777006f, -0.04510684f, 
    -0.03067754f, 0.04079369f, -0.03906201f, -0.02590715f, 0.02812870f, -0.02332862f, -0.05414432f, -0.00194306f, 
    -0.04433475f, -0.01991158f, -0.04401518f, -0.00280639f, 0.03203190f, -0.03505446f, -0.04984517f, -0.03698371f, 
    -0.01632493f, -0.01760199f, 0.01002131f, -0.02709273f, -0.04392356f, 0.02313273f, 0.04963886f, -0.02642472f, 
    -0.00651035f, -0.05152278f, 0.00060543f, -0.00270589f, -0.03818610f, 0.01052179f, -0.00168876f, -0.02679788f, 
    0.04280005f, 0.01843834f, 0.00401595f, -0.00089308f, -0.00399916f, -0.02385706f, -0.04901812f, -0.03016501f, 
    0.02038957f, -0.00085341f, 0.01741047f, -0.00873954f, -0.02048322f, -0.01071793f, -0.02091149f, -0.04948946f, 
    -0.02286885f, -0.04648365f, -0.03017222f, 0.04494177f, -0.05309073f, -0.01161638f, -0.01780025f, -0.00093705f, 
    -0.01171943f, -0.02578774f, -0.03070538f, -0.00686279f, 0.01580348f, -0.04220242f, -0.01532554f, -0.03106888f, 
    0.02151340f, -0.03670743f, -0.02297867f, 0.00206603f, -0.02966984f, 0.00984740f, 0.03916541f, -0.02309990f, 
    0.02023948f, -0.05399819f, 0.01274155f, 0.02545289f, -0.01059369f, -0.00744868f, -0.04732341f, 0.04347148f, 
    -0.02980114f, 0.01492153f, -0.02205604f, -0.00625096f, 0.02211175f, -0.02395901f, 0.02260449f, -0.05250093f, 
    0.01930078f, -0.02235643f, 0.02395456f, -0.04883172f, 0.04166144f, -0.00832589f, -0.03762085f, -0.04519751f, 
    -0.05581666f, 0.01525386f, -0.03725979f, -0.02066923f, 0.04087004f, 0.00795921f, -0.03673213f, -0.02287678f, 
    0.03093964f, 0.02938779f, -0.05581500f, 0.01677958f, -0.03278342f, -0.04646655f, 0.04101260f, 0.00657099f, 
    0.02363286f, -0.00892545f, 0.02970887f, 0.01766858f, -0.04083199f, -0.01981078f, -0.04777825f, -0.01469343f, 
    -0.03381474f, -0.05710417f, -0.05634511f, -0.00405392f, 0.02764342f, 0.02704990f, 0.01088203f, 0.04340505f, 
    -0.01566355f, 0.01833001f, -0.01137509f, 0.03483991f, 0.01669833f, -0.03790445f, 0.02096064f, 0.03712098f, 
    0.01548233f, 0.03425854f, -0.00570337f, 0.03818211f, -0.03401114f, -0.04827376f, 0.02511937f, -0.02074519f, 
    0.01735441f, -0.05680693f, -0.03541397f, 0.00343738f, 0.00077528f, -0.01988278f, -0.00439184f, -0.02425112f, 
    -0.02971460f, 0.03681644f, -0.01792976f, 0.00965756f, 0.00277029f, -0.02893330f, 0.03496647f, 0.01075024f, 
    0.02614019f, -0.03542977f, -0.05368738f, -0.03876543f, -0.04637822f, 0.01140594f, 0.03886373f, 0.00609286f, 
    -0.04741439f, -0.05359944f, 0.00719112f, -0.05812218f, -0.04100505f, 0.04344167f, -0.02289751f, -0.01504126f, 
    0.03473908f, -0.02831116f, 0.04433967f, -0.04311039f, 0.02651707f, -0.02146546f, 0.03981521f, 0.02181814f, 
    0.03741799f, -0.02396287f, -0.04136150f, -0.04991382f, 0.03348630f, 0.03865853f, 0.00227086f, -0.03362506f, 
    -0.03977392f, -0.05173162f, 0.02800359f, 0.04132180f, 0.00359944f, -0.03399085f, 0.03176553f, 0.03061629f, 
    -0.02295253f, -0.00645197f, -0.02489044f, -0.03260859f, 0.03713436f, -0.04153681f, -0.04236693f, -0.01520835f, 
    -0.04638284f, -0.03306567f, -0.04348739f, -0.04988234f, -0.01263725f, -0.04243704f, 0.04198842f, -0.05344079f, 
    -0.03818279f, 0.01413947f, 0.03946715f, -0.04668959f, -0.05095607f, 0.00595358f, -0.03011887f, 0.03495086f, 
    -0.01473178f, -0.03132665f, 0.03288807f, -0.05565540f, 0.04219502f, -0.00234798f, 0.01687767f, -0.00459334f, 
    -0.04044919f, -0.02417219f, 0.03969875f, -0.04372646f, 0.03995534f, 0.01621312f, 0.01119584f, -0.02559852f, 
    0.00781934f, 0.02597929f, -0.02317351f, 0.00144624f, 0.02803819f, -0.02443917f, 0.01387959f, 0.00782969f, 
    -0.03467516f, -0.03900687f, -0.03935001f, -0.02555079f, -0.03373335f, -0.02891446f, -0.02405255f, -0.03137536f, 
    0.01011028f, 0.01067013f, -0.01534993f, -0.02529920f, -0.03294480f, 0.04106158f, 0.03307750f, -0.03331101f, 
    0.03480649f, -0.01543179f, 0.04861379f, -0.00524093f, -0.00309903f, -0.00500290f, 0.00246091f, 0.02113149f, 
    -0.02216137f, 0.01477142f, 0.03986448f, -0.04399554f, 0.02710179f, -0.01748318f, -0.04676602f, 0.02488315f, 
    -0.00684049f, 0.03804849f, -0.05725258f, 0.03154257f, 0.02196913f, -0.02797702f, 0.04030614f, -0.01733891f, 
    0.03431239f, 0.01191526f, 0.02537268f, 0.00558519f, -0.03811141f, 0.00347435f, -0.04047395f, -0.00293858f, 
    -0.02778565f, -0.04320873f, 0.02738981f, -0.02600358f, -0.05116848f, 0.03040002f, -0.04587616f, 0.04439236f, 
    0.01793573f, 0.04204060f, -0.04858569f, -0.00341419f, 0.00047388f, -0.05800280f, -0.02719266f, -0.02007145f, 
    -0.03457842f, 0.00650018f, 0.02175098f, 0.02474682f, 0.00793729f, 0.02738900f, -0.03223085f, -0.05652722f, 
    -0.05106068f, 0.00520162f, 0.00346253f, -0.01602524f, -0.00373232f, -0.04682775f, -0.00451984f, -0.03042562f, 
    -0.00542751f, 0.00610720f, 0.02915894f, -0.02435862f, -0.03212151f, -0.00906448f, -0.03588164f, -0.00300258f, 
    -0.00053779f, -0.01474382f, 0.03924364f, -0.04604617f, -0.03106403f, -0.02570372f, 0.03069936f, 0.04501515f, 
    0.00119127f, 0.02857194f, -0.05158566f, 0.03387873f, 0.02218851f, 0.02277943f, -0.01789077f, 0.04362147f, 
    0.02356728f, 0.04841092f, 0.03810685f, 0.03213841f, 0.04141707f, -0.01450194f, -0.01113518f, -0.05472647f, 
    0.01887682f, -0.04877840f, -0.01513443f, 0.00639226f, 0.01530297f, -0.01544879f, 0.00527530f, -0.04282358f, 
    -0.01500539f, -0.02225511f, -0.00110236f, 0.03070733f, -0.05130706f, 0.02554912f, 0.03180267f, -0.03395662f, 
    0.18702580f, 0.34070420f, 0.32505277f, 0.59535140f, 0.00375399f, -0.02091797f, -0.01849703f, 0.12687656f, 
    0.20409976f, 0.11896589f, 0.07410239f, 0.32962829f, 0.15172847f, 0.12798923f, 0.09941385f, 0.18962364f, 
    0.00251428f, -0.03786216f, -0.07981528f, 0.09920883f, 0.21269354f, 0.10697076f, 0.18986264f, 0.18962337f, 
    -0.46325785f, -0.21625572f, -0.27444631f, -0.23683982f, 0.00559374f, 0.03651512f, -0.05230066f, 0.30580753f, 
    0.08270424f, -0.05932108f, 0.01890340f, -0.19421795f, -0.12492634f, -0.15066403f, -0.08228582f, 0.02384759f, 
    0.04764804f, 0.03430004f, -0.01578460f, 0.31956151f, -0.00746601f, -0.02434186f, -0.18265371f, 0.16772397f, 
    -0.04221527f, -0.05504043f, 0.22387044f, -0.10538481f, 0.01483139f, 0.09462572f, 0.14304879f, 0.20391470f, 
    -0.02468459f, 0.10422313f, -0.17825718f, -0.30459529f, -0.02326837f, 0.06501592f, 0.26316664f, -0.08444301f, 
    0.00426553f, 0.44718465f, 0.29764891f, 0.22602791f, 0.06329007f, -0.03864825f, 0.24299270f, 0.16458184f, 
    -0.24919520f, -0.08156507f, -0.08301817f, 0.11364266f, 0.18719019f, 0.34315586f, -0.06003402f, -0.00962063f, 
    -0.09114279f, 0.11390485f, 0.08760823f, 0.07311665f, -0.10511731f, -0.26462623f, -0.05064113f, -0.04211385f, 
    -0.05232239f, 0.04075199f, 0.26584876f, 0.15202416f, -0.02511232f, 0.12661079f, -0.00178734f, 0.17069064f, 
    0.06805785f, 0.21244489f, -0.14516054f, -0.28451249f, 0.11304305f, -0.15623990f, 0.20469786f, 0.07420639f, 
    -0.07158295f, 0.07283222f, -0.15560579f, -0.24212044f, -0.07335608f, 0.03536357f, 0.19317864f, -0.09207845f, 
    -0.06837632f, 0.03901011f, 0.03022236f, 0.09766345f, 0.14236987f, 0.25984493f, 0.16667829f, 0.09220470f, 
    0.30870914f, 0.27001879f, 0.25985762f, 0.19105831f, -0.03582811f, 0.00167248f, 0.10360332f, 0.03671818f, 
    0.07779302f, 0.04366308f, -0.15860309f, -0.16699892f, -0.13643959f, -0.12803996f, -0.16686593f, 0.02721081f, 
    0.03893418f, -0.06912730f, 0.12955062f, -0.08282093f, -0.11338682f, 0.00123477f, -0.04721874f, -0.04287818f, 
    0.00071133f, 0.04819193f, -0.02536428f, -0.11516782f, -0.24112871f, -0.08768403f, -0.07555275f, -0.09345730f, 
    0.02360826f, 0.17748988f, 0.20046569f, 0.01243595f, -0.22009318f, -0.20466185f, -0.05494784f, -0.10618113f, 
    0.17360905f, 0.20986804f, 0.16717008f, 0.01119390f, 0.00318332f, -0.07115840f, -0.03279315f, 0.09368107f, 
    0.12764445f, 0.13149346f, 0.27661470f, 0.24058633f, -0.07341749f, -0.07956859f, -0.10079704f, 0.02417967f, 
    0.11892161f, -0.00887812f, 0.20007947f, 0.19570543f, -0.22103867f, 0.30111602f, 0.04635166f, -0.14650981f, 
    0.29748341f, 0.05270073f, 0.11368985f, 0.19433931f, -0.11048758f, -0.10606234f, 0.15499702f, 0.10499284f, 
    0.42302534f, -0.15176907f, 0.11360783f, 0.11238553f, -0.04561105f, -0.11107570f, -0.00539953f, -0.03244737f, 
    0.05337173f, 0.21128096f, 0.20104842f, 0.15051328f, -0.13615321f, -0.04260761f, -0.17342275f, -0.07454079f, 
    0.33125293f, -0.06516541f, 0.20714068f, 0.06543589f, 0.00581706f, 0.06592905f, -0.04613707f, -0.07935878f, 
    -0.20197932f, -0.00730554f, -0.21372528f, -0.03505689f, 0.05017764f, 0.05234645f, 0.17641725f, 0.06550109f, 
    -0.06383319f, 0.18143266f, 0.05331314f, 0.06654321f, -0.05787185f, 0.10182025f, -0.01976741f, -0.10320734f, 
    0.01623544f, 0.00166880f, 0.17004012f, 0.17223845f, 0.04570792f, 0.13043630f, -0.06503783f, -0.00266904f, 
    0.31358540f, 0.12251427f, 0.29514176f, 0.41856834f, 0.02402529f, 0.11030132f, 0.33078992f, 0.07578793f, 
    0.01109168f, -0.03428209f, -0.09698274f, 0.05682435f, -0.18043049f, -0.13277353f, -0.10893857f, -0.02003159f, 
    0.14212982f, -0.01580168f, 0.02721768f, -0.14291342f, -0.02130472f, -0.05632721f, 0.14509773f, 0.01359243f, 
    0.02401725f, 0.01413928f, -0.00467244f, -0.10931975f, 0.10144538f, 0.05373029f, 0.03884794f, 0.20639257f, 
    0.10744184f, -0.04521408f, -0.11020040f, -0.28345820f, 0.09360918f, -0.19047521f, 0.27808580f, 0.08319575f, 
    0.17519796f, 0.09467711f, 0.08048648f, 0.23679703f, 0.04439988f, -0.03892093f, 0.07037850f, 0.18596770f, 
    0.11915996f, 0.24948925f, 0.09052420f, -0.06981627f, -0.10389618f, 0.00610786f, 0.01781776f, -0.00626299f, 
    -0.00403727f, 0.15932408f, 0.04299928f, 0.12222238f, 0.14508434f, 0.09562775f, 0.05071238f, 0.08243018f, 
    -0.04970342f, -0.02257828f, -0.09408516f, -0.04741854f, 0.16248991f, 0.12187992f, 0.19716033f, 0.21277137f, 
    0.16467828f, 0.18156323f, 0.13831070f, -0.01940044f, 0.13577284f, -0.00808249f, -0.12114638f, 0.04639316f, 
    -0.17790675f, -0.04377414f, 0.00848177f, 0.08012635f, -0.02403601f, 0.11042590f, 0.08415926f, 0.00536628f, 
    0.01414168f, -0.00756791f, -0.07320607f, 0.01584456f, 0.10489780f, -0.12626201f, -0.12410420f, -0.43464386f, 
    -0.04611640f, -0.14123847f, 0.08675636f, -0.11731427f, 0.04113960f, 0.02204043f, 0.05892155f, 0.13070172f, 
    0.07775086f, 0.11310270f, -0.11176355f, -0.15077695f, -0.09714608f, 0.25344518f, 0.15117434f, -0.10456072f, 
    0.18016444f, 0.08944980f, 0.21673530f, -0.04744873f, 0.24599154f, 0.14317752f, 0.16980299f, 0.18732266f, 
    -0.17334542f, 0.19969665f, -0.06326345f, -0.09850141f, -0.06017207f, 0.23561208f, 0.00162783f, 0.09802909f, 
    0.01404103f, 0.13949609f, 0.12698966f, 0.08423240f, -0.08441588f, 0.15462457f, 0.00843000f, -0.19282682f, 
    -0.08442888f, -0.09240345f, -0.09491762f, -0.04416330f, -0.00877097f, 0.06577406f, 0.26938874f, 0.14241356f, 
    0.03978340f, -0.04996910f, -0.04235778f, 0.02499303f, -0.01735806f, -0.02608405f, -0.05561931f, 0.01069249f, 
    0.03825755f, 0.03870995f, -0.01766528f, 0.00818930f, 0.01371841f, 0.03816473f, 0.03693742f, 0.03796938f, 
    -0.05497511f, 0.02108223f, -0.03739926f, 0.03167719f, 0.02061599f, -0.00572768f, -0.03379161f, 0.03384584f, 
    -0.01087563f, -0.03824702f, -0.04038685f, 0.04359084f, 0.00193361f, -0.02663334f, 0.00268506f, -0.05643651f, 
    -0.04398789f, -0.05126785f, -0.00371104f, 0.01692328f, 0.01812793f, -0.01380326f, -0.04960195f, -0.02404599f, 
    0.00964138f, 0.00626178f, -0.00895910f, -0.00730077f, -0.04791860f, -0.05532304f, 0.01087856f, 0.03101459f, 
    0.03945338f, -0.02095078f, 0.03132128f, 0.00570503f, 0.01220863f, 0.02502804f, 0.02465167f, -0.02617310f, 
    -0.03352948f, 0.04967987f, 0.04097966f, -0.00561996f, -0.00749453f, 0.00061350f, 0.03684930f, -0.01311473f, 
    -0.03894427f, -0.04191008f, 0.03788115f, 0.01603220f, -0.03018071f, -0.00698164f, -0.00217289f, -0.05389095f, 
    0.03731489f, -0.01002567f, 0.01530879f, 0.02427590f, -0.05060588f, -0.04557652f, -0.02809251f, 0.03566070f, 
    0.04198495f, -0.04229878f, -0.03427280f, 0.00517840f, 0.02590695f, -0.04027775f, -0.03130095f, -0.02518083f, 
    0.01302153f, 0.04374453f, 0.01536101f, -0.04860571f, 0.04430310f, -0.00307711f, 0.00588372f, 0.03660433f, 
    -0.01347632f, -0.03574378f, 0.00148903f, 0.03533787f, -0.03371292f, 0.03853584f, 0.04253323f, 0.00600299f, 
    -0.02472615f, 0.01158513f, -0.02128391f, -0.05128544f, -0.03632028f, -0.00569791f, 0.01248062f, 0.00116346f, 
    -0.03136257f, 0.01984795f, 0.02863283f, -0.01334074f, -0.05281784f, 0.00200872f, -0.00604551f, -0.04283158f, 
    0.02542952f, 0.02254179f, -0.05306799f, -0.01258181f, -0.04343795f, -0.02863888f, 0.00983377f, 0.04136015f, 
    -0.01489462f, -0.01624563f, -0.05120186f, -0.02030409f, -0.05414570f, -0.01373305f, 0.00659219f, -0.03376656f, 
    -0.03343409f, 0.02389308f, 0.02333972f, -0.02121796f, -0.03860459f, 0.01786091f, -0.02768956f, -0.03094875f, 
    0.00457977f, -0.02793784f, -0.00460286f, 0.01187478f, -0.02342223f, 0.01784081f, -0.00006253f, 0.01910017f, 
    0.00551166f, -0.01573252f, 0.04172350f, 0.00583626f, -0.00123897f, 0.00885860f, -0.02931730f, -0.03574442f, 
    -0.01576960f, -0.01693472f, -0.05250979f, 0.00218380f, 0.01115929f, -0.04777851f, -0.01889487f, 0.01520041f, 
    -0.00424373f, -0.00538483f, 0.02650587f, 0.00059473f, -0.04188222f, 0.02979049f, -0.04515132f, -0.00040451f, 
    0.02825928f, -0.02792602f, -0.01837967f, -0.04211025f, 0.00368915f, -0.00761231f, -0.01861998f, -0.03227413f, 
    -0.00512827f, 0.00197579f, -0.03285726f, -0.01747459f, -0.05103696f, 0.01048610f, -0.01119818f, -0.03614708f, 
    -0.02099335f, 0.04081709f, 0.04397743f, -0.00227363f, 0.02592064f, 0.02690657f, -0.00712591f, -0.03847749f, 
    -0.04128169f, -0.05172157f, 0.00383507f, 0.01776778f, -0.03389488f, 0.00268597f, 0.01890651f, -0.01194446f, 
    0.02598277f, -0.04149234f, -0.01613036f, -0.00483131f, 0.04402291f, -0.04964813f, -0.02672774f, -0.00419192f, 
    0.01539000f, -0.02404379f, 0.03657397f, 0.00034402f, -0.02128901f, 0.04225897f, 0.00116981f, -0.01372718f, 
    -0.00356563f, -0.00168398f, -0.05044502f, -0.03582582f, -0.05200374f, 0.01686644f, -0.03842489f, -0.05536036f, 
    -0.00205410f, 0.01297285f, 0.01368544f, 0.01965011f, 0.04284364f, -0.00059832f, 0.00561376f, -0.01322787f, 
    0.02263613f, 0.01922016f, -0.04278643f, 0.01622657f, -0.03382070f, -0.02200986f, -0.04535160f, -0.03877306f, 
    0.00090566f, -0.03562808f, -0.05592734f, 0.00694570f, -0.05633105f, -0.01976064f, 0.03351973f, 0.00376422f, 
    0.03148566f, -0.05410888f, -0.00673595f, 0.03124028f, 0.01231889f, 0.02528885f, 0.03722762f, -0.04475972f, 
    -0.02218772f, -0.05628232f, -0.00829457f, 0.04507527f, 0.03908095f, 0.00211767f, -0.04837288f, -0.01794317f, 
    -0.02803302f, 0.04728928f, -0.00945409f, -0.05039693f, -0.01626266f, -0.00391970f, -0.04435556f, -0.03578495f, 
    -0.05032345f, 0.01892552f, -0.00965550f, -0.04177141f, 0.01498233f, 0.03779619f, -0.00838256f, 0.02592485f, 
    -0.02693707f, -0.00080598f, 0.01487501f, -0.01274282f, -0.05599927f, -0.01228243f, 0.03362461f, -0.01290261f, 
    0.00985777f, 0.02915039f, -0.00126894f, -0.00205383f, -0.04841027f, 0.01567023f, -0.04875658f, 0.04019508f, 
    -0.04774575f, -0.01298639f, -0.01972746f, 0.04478146f, 0.02250163f, -0.01818653f, 0.01048312f, -0.04366653f, 
    -0.01503572f, 0.04530271f, 0.02087571f, -0.05007454f, 0.04309673f, -0.02637477f, 0.04325847f, 0.01405022f, 
    -0.03632623f, -0.01306308f, -0.03953911f, -0.03081381f, 0.02324076f, -0.05221352f, 0.03481768f, 0.02781730f, 
    0.01238318f, -0.03063495f, 0.02128690f, 0.00440344f, -0.05400584f, -0.00063129f, 0.01249308f, 0.01419106f, 
    0.00833275f, 0.00939229f, 0.02938651f, -0.01896903f, -0.00382585f, -0.04373646f, -0.04975636f, -0.04145131f, 
    0.02023380f, -0.00394324f, 0.02093797f, -0.02420831f, -0.00528601f, -0.03473751f, 0.01336606f, -0.01412388f, 
    -0.03356822f, -0.00873201f, -0.01134459f, -0.05573063f, 0.03178594f, 0.01804810f, -0.04195897f, -0.00555300f, 
    0.04424582f, -0.03793095f, 0.03496663f, 0.00820583f, 0.04526149f, 0.02374363f, 0.03596153f, -0.00377840f, 
    -0.02596543f, 0.02182223f, 0.00135869f, -0.04806164f, 0.01054172f, -0.01024251f, -0.03517756f, -0.04466625f, 
    -0.02536944f, -0.03885665f, 0.03158226f, -0.00159728f, -0.03728498f, 0.00201499f, 0.03143233f, -0.00070067f, 
    -0.03104535f, 0.08487033f, -0.03093971f, -0.22365068f, 0.11980203f, 0.06376689f, 0.02963854f, -0.07227692f, 
    -0.03576994f, 0.10370443f, -0.08791752f, -0.06241865f, -0.00976630f, -0.22529517f, 0.14752589f, -0.14475466f, 
    0.02686094f, 0.12261978f, -0.01063227f, 0.04154396f, -0.03541292f, -0.00436947f, -0.12360623f, -0.06203935f, 
    -0.12798311f, 0.30137697f, 0.34431314f, 0.32271582f, -0.17839842f, -0.06841552f, 0.17907538f, -0.01598698f, 
    0.00088918f, 0.02059524f, -0.01153958f, 0.20463017f, -0.32999370f, 0.29087847f, -0.06724776f, -0.05720466f, 
    0.02629954f, -0.08395381f, 0.26687822f, -0.10974003f, -0.03492701f, -0.06333763f, 0.03323428f, 0.02030645f, 
    0.06081881f, 0.12643644f, -0.12242286f, 0.32553902f, 0.07439385f, 0.08540463f, 0.00044706f, -0.08565959f, 
    0.20525604f, 0.15580702f, 0.26279891f, 0.20025496f, -0.24978107f, 0.18566848f, 0.06850535f, -0.08342377f, 
    0.24801095f, 0.00875849f, -0.19122764f, 0.02077520f, -0.03423867f, 0.02709581f, -0.06268986f, 0.07318924f, 
    0.24511538f, -0.21461076f, -0.16823290f, -0.00765235f, 0.03712075f, -0.07173771f, -0.04141426f, -0.08710505f, 
    0.14225969f, 0.05241904f, -0.00706917f, 0.05085482f, 0.21399952f, 0.40017760f, -0.13433775f, 0.11608917f, 
    0.02640906f, -0.02284008f, -0.04086319f, -0.00275663f, 0.11475059f, 0.03093950f, -0.19362424f, -0.20534830f, 
    -0.11204146f, -0.23724467f, 0.18566141f, 0.14762585f, -0.06545058f, -0.00711486f, -0.03289999f, 0.11282856f, 
    -0.00042318f, -0.02105255f, 0.08618793f, 0.32598820f, -0.13581876f, -0.13449575f, -0.19777200f, -0.11425643f, 
    0.20393327f, -0.03842841f, 0.00303071f, 0.09986304f, 0.09263054f, -0.06674767f, 0.07188205f, -0.08604819f, 
    -0.03224613f, -0.04631229f, -0.06139046f, 0.13586786f, -0.00228692f, -0.12912865f, 0.04012985f, 0.07475474f, 
    0.03652878f, -0.04944156f, 0.29067212f, 0.09455281f, -0.30780160f, -0.13195907f, 0.03906155f, -0.08351038f, 
    0.11887918f, 0.13655877f, 0.10614786f, 0.18825720f, -0.18892042f, -0.13624547f, 0.06584390f, -0.06059738f, 
    -0.08101171f, -0.32016701f, -0.06400024f, 0.05709286f, -0.02383265f, 0.11390775f, 0.12934914f, 0.08696772f, 
    0.02597414f, -0.10195788f, -0.11137141f, -0.04724200f, 0.04195679f, 0.07058765f, -0.03102583f, 0.06619067f, 
    0.13296224f, -0.11225188f, 0.01016240f, -0.13175020f, 0.02312904f, -0.04785430f, 0.04799148f, -0.08662882f, 
    -0.11392955f, -0.09889475f, 0.09582348f, -0.39191690f, 0.01527432f, 0.15016288f, 0.19016641f, 0.00901608f, 
    0.20836647f, 0.03669228f, 0.04975446f, 0.12074760f, 0.03607579f, -0.27639273f, 0.27544236f, -0.07955958f, 
    -0.04731960f, -0.04056387f, -0.02318576f, 0.12141214f, -0.01207696f, 0.17212367f, 0.03018707f, 0.09480013f, 
    0.21446556f, -0.11084799f, -0.01101100f, 0.38613379f, 0.01068874f, -0.13732329f, -0.22371380f, 0.01970673f, 
    0.00581378f, 0.09015018f, -0.02116997f, 0.04842760f, 0.15836149f, -0.21838741f, -0.04172337f, 0.08861168f, 
    0.13563204f, 0.21855527f, 0.17237616f, -0.00736862f, 0.04812641f, -0.03093964f, -0.01136296f, -0.02606262f, 
    -0.01619807f, -0.23630537f, 0.18662329f, -0.20573123f, 0.07712229f, -0.02983946f, -0.09928877f, -0.06918081f, 
    -0.03999248f, -0.20855625f, -0.17764615f, -0.19095060f, -0.21823731f, 0.11172552f, 0.15748517f, -0.09151410f, 
    0.05894329f, 0.03699156f, -0.08885168f, -0.04692210f, 0.09431917f, 0.15120979f, 0.18430519f, 0.08043402f, 
    0.10685458f, 0.26782766f, -0.12343882f, -0.20597179f, 0.11955019f, -0.11078866f, -0.04330643f, 0.16178966f, 
    0.29586196f, 0.15668869f, 0.08453264f, 0.11221730f, -0.07757946f, 0.02148976f, -0.04089009f, 0.09759258f, 
    0.04624792f, 0.10015392f, 0.13430248f, 0.19458605f, 0.00359117f, 0.12851147f, 0.02817918f, 0.13110401f, 
    0.16809104f, -0.17454769f, 0.03836589f, -0.06045538f, -0.03529007f, 0.08500233f, 0.04193567f, 0.06587013f, 
    0.17866319f, 0.01352599f, 0.16330990f, 0.19960320f, -0.08705825f, 0.10718445f, -0.12039109f, 0.04348107f, 
    0.09063118f, -0.07642705f, -0.00865271f, 0.01504030f, 0.16491897f, 0.18115526f, 0.01187223f, 0.05865030f, 
    0.12402567f, -0.13467048f, 0.01779458f, -0.06393724f, -0.04736426f, 0.10598819f, -0.05299274f, 0.02302878f, 
    -0.21764290f, -0.23388474f, -0.18214519f, -0.11913183f, 0.09393177f, -0.09706701f, 0.13606960f, -0.29773152f, 
    0.11695189f, 0.00692136f, -0.05076391f, -0.01852329f, 0.27950868f, 0.00220424f, 0.09488070f, 0.15228103f, 
    -0.34904006f, 0.04678705f, -0.13809177f, 0.11830387f, 0.09142765f, -0.02556704f, 0.04552311f, -0.17197680f, 
    0.08422057f, -0.15241513f, -0.08577245f, -0.16940442f, 0.00163261f, -0.42706817f, -0.18535747f, 0.00033690f, 
    -0.03915034f, -0.04878764f, 0.07940502f, 0.05189359f, 0.32578811f, 0.14616904f, 0.11318430f, 0.23981687f, 
    0.12147359f, -0.08354217f, 0.05561358f, 0.17614973f, 0.05141030f, 0.16344416f, -0.14401284f, -0.05553848f, 
    0.17916667f, 0.04156323f, 0.12769817f, 0.11977713f, -0.02340296f, 0.02358939f, 0.08393814f, -0.03841663f, 
    -0.04764688f, -0.08315351f, -0.00348442f, 0.01022082f, -0.09963201f, 0.01417592f, -0.04878054f, 0.09559464f, 
    0.32119709f, -0.25463435f, 0.25087976f, -0.03447264f, 0.19672492f, -0.03707157f, 0.04862740f, 0.30467874f, 
    -0.12796736f, -0.12705140f, -0.08976310f, -0.12747662f, 0.38282654f, 0.09601546f, 0.33958608f, 0.02463619f, 
    -0.21760991f, 0.01038779f, -0.16172251f, -0.03927190f, 0.04006653f, 0.13712323f, 0.13617072f, 0.14295462f, 
    -0.00206957f, -0.04580314f, 0.01335669f, 0.02354928f, -0.00941934f, -0.02780670f, -0.05228444f, 0.02135025f, 
    -0.02481514f, 0.00336573f, -0.03140208f, -0.06268669f, -0.05820274f, -0.00554575f, 0.03673588f, -0.00627853f, 
    0.02084843f, -0.02247221f, -0.03296562f, 0.04443853f, -0.02212140f, 0.00771770f, -0.03508334f, -0.03811064f, 
    -0.00050880f, 0.02175793f, 0.03416640f, 0.01496720f, -0.05378428f, -0.06201602f, -0.02849765f, -0.01852094f, 
    0.04129118f, -0.04651114f, -0.02402068f, 0.03317817f, -0.04688270f, -0.04202537f, -0.02810300f, -0.01230547f, 
    -0.05840107f, -0.00740762f, 0.02293713f, -0.05310852f, -0.03077520f, 0.01108239f, -0.01475143f, 0.03746445f, 
    -0.05478162f, -0.03819351f, 0.00285083f, -0.03283804f, 0.02272842f, -0.04052418f, -0.03011294f, 0.00383707f, 
    -0.04788965f, -0.06219304f, 0.00270253f, -0.01465508f, 0.01735520f, -0.00348132f, -0.06058904f, -0.05558459f, 
    -0.04436228f, 0.02346093f, -0.04993549f, -0.00655100f, -0.05773175f, -0.03109211f, 0.03431590f, 0.01243918f, 
    -0.00612626f, -0.01228348f, -0.05126217f, -0.02842429f, 0.02415517f, 0.03155667f, -0.06382120f, 0.02634909f, 
    0.01254647f, -0.02690718f, 0.03579617f, -0.00144764f, 0.01513300f, 0.00795218f, -0.03657341f, 0.01048008f, 
    -0.04071185f, -0.02074278f, 0.01761192f, -0.00088741f, -0.02061096f, -0.05672161f, 0.03542843f, -0.02204302f, 
    0.03260725f, 0.01587663f, -0.04942070f, 0.01428751f, -0.00263441f, -0.03689397f, 0.01943950f, 0.00434873f, 
    -0.01526120f, 0.01985355f, -0.03670368f, -0.05995502f, -0.03083632f, -0.01478561f, -0.00784446f, 0.04855095f, 
    0.01432417f, 0.01241680f, -0.05563077f, -0.02288145f, 0.01004264f, -0.01849107f, 0.04441545f, -0.03864390f, 
    0.00591221f, -0.05789907f, -0.04620640f, -0.05222820f, -0.00938018f, 0.03823313f, -0.05151389f, 0.00224450f, 
    -0.00116264f, -0.01415274f, -0.06262177f, -0.05519508f, -0.04187286f, -0.03211533f, 0.04162871f, -0.06507199f, 
    -0.04202344f, -0.02973954f, -0.03135451f, -0.04606356f, 0.02661407f, -0.00688625f, 0.01346568f, -0.01266511f, 
    0.03238810f, 0.00211046f, -0.00738277f, 0.00262045f, 0.02654150f, -0.02433152f, -0.00526838f, 0.03957069f, 
    0.00336323f, 0.02981940f, 0.00892471f, 0.05237135f, -0.03662291f, 0.00853770f, -0.04167833f, 0.01078590f, 
    0.01104305f, -0.04087939f, 0.01837841f, -0.05162076f, 0.00994882f, -0.03170686f, 0.02057850f, -0.00700404f, 
    -0.01135151f, 0.02381480f, -0.04139231f, -0.03532869f, -0.02842359f, 0.03037405f, 0.02397513f, 0.02476920f, 
    -0.00305401f, -0.03626917f, -0.01534387f, 0.02590058f, 0.00972575f, -0.02026231f, -0.06700681f, 0.00175117f, 
    -0.06111450f, -0.03800491f, 0.00952192f, -0.00308727f, -0.02364280f, -0.01862396f, -0.02329409f, 0.01190029f, 
    0.00881320f, -0.02511599f, -0.03490559f, -0.00271452f, 0.01248958f, 0.02585913f, 0.02524807f, -0.00050315f, 
    -0.06244683f, -0.01730965f, -0.00891176f, -0.04063973f, 0.00468400f, -0.01288219f, -0.06583814f, -0.00691457f, 
    -0.03016938f, -0.04711812f, -0.04865163f, 0.03443409f, 0.01630389f, -0.05794312f, -0.02408556f, -0.01457131f, 
    -0.01792512f, -0.02074698f, -0.00295030f, -0.02809204f, -0.00072592f, -0.06400345f, -0.02469205f, -0.01593985f, 
    0.00993671f, 0.00367209f, -0.01066417f, -0.00950971f, -0.06382258f, -0.04158247f, -0.02253372f, -0.02621847f, 
    -0.05344441f, -0.05867298f, -0.01237789f, 0.03308963f, -0.02332536f, 0.00811491f, -0.00494873f, 0.02956968f, 
    0.01648182f, -0.05443060f, -0.03348005f, -0.03355679f, -0.03011704f, -0.01876384f, -0.03861825f, -0.03242297f, 
    0.02909483f, -0.03912707f, 0.00149085f, -0.03049132f, -0.04822835f, -0.04044297f, -0.05125120f, -0.05424447f, 
    0.00108942f, 0.01282074f, -0.05828676f, -0.04163338f, -0.04592522f, -0.04849165f, -0.02443068f, -0.04648795f, 
    -0.04388509f, 0.03825601f, -0.05408889f, -0.05053448f, -0.04361878f, 0.02561645f, -0.05092248f, -0.01794609f, 
    -0.04531612f, 0.02636801f, -0.03929666f, 0.03031534f, -0.00523447f, -0.02875843f, -0.00068818f, -0.05274658f, 
    -0.02067167f, -0.04265101f, -0.05400123f, -0.03734668f, 0.01302307f, -0.01317222f, 0.01462073f, 0.02409691f, 
    0.01747495f, -0.05450932f, 0.02499207f, -0.02137222f, 0.01136646f, -0.04222636f, -0.02054284f, -0.00980677f, 
    -0.05366743f, -0.01243045f, 0.00681781f, -0.01089232f, -0.04236955f, -0.03808152f, -0.03990300f, -0.02708142f, 
    -0.00020674f, -0.02657348f, 0.01092263f, 0.02319864f, -0.03116579f, -0.04294167f, 0.02287692f, -0.01123750f, 
    -0.01937320f, 0.00181677f, -0.05067506f, -0.01047977f, -0.04466202f, -0.05047444f, -0.04763078f, 0.03419685f, 
    -0.03024713f, 0.00386787f, -0.03739477f, 0.00435409f, -0.00486646f, 0.00551976f, -0.02103313f, 0.00154561f, 
    0.03523986f, -0.02952408f, -0.03261383f, -0.01733994f, -0.04627187f, -0.03554723f, 0.01621574f, -0.01861459f, 
    -0.06030529f, 0.02642814f, -0.04235992f, -0.04107718f, 0.01786730f, 0.01990748f, 0.03438870f, -0.04700567f, 
    0.01740933f, 0.03034531f, 0.00376040f, 0.02620342f, -0.01112909f, 0.02176837f, -0.01404485f, -0.03024636f, 
    -0.01815661f, -0.03318424f, -0.02800068f, 0.02221311f, -0.04920607f, -0.05619495f, 0.03199352f, -0.04979897f, 
    -0.03581029f, -0.00887667f, -0.00126340f, -0.04229419f, 0.01270420f, -0.05046530f, -0.03637156f, 0.01912731f, 
    -0.00893745f, 0.01250859f, 0.00519924f, -0.03961287f, -0.06323665f, -0.03628546f, -0.01129876f, 0.02435186f, 
    0.00805669f, 0.02861406f, 0.01337015f, 0.00029360f, 0.02784960f, -0.03096409f, -0.04624526f, -0.01951980f, 
    0.36724436f, -0.12597805f, -0.22349744f, -0.12414784f, -0.01572610f, 0.00946769f, 0.08484914f, 0.06282011f, 
    0.21931256f, 0.02342818f, 0.05540905f, -0.07915813f, 0.16066259f, -0.10055139f, -0.33071652f, 0.25369048f, 
    -0.14022560f, 0.10811637f, 0.14451787f, -0.19612806f, 0.02235972f, 0.06708399f, -0.03930296f, -0.12946840f, 
    0.41103244f, 0.37478843f, 0.37822303f, 0.19958730f, -0.04554969f, 0.00815742f, 0.25579035f, -0.08255526f, 
    0.11433634f, -0.03272153f, -0.04334072f, 0.20671219f, -0.07594585f, 0.35505307f, 0.34288925f, -0.00589019f, 
    -0.00123482f, 0.12042727f, 0.15980789f, -0.35180047f, -0.02560881f, 0.04380576f, -0.12605377f, -0.08589121f, 
    -0.09818407f, -0.10794280f, -0.08735790f, -0.08097333f, 0.17155394f, -0.00988510f, -0.03314444f, -0.24359301f, 
    0.07910124f, 0.05235279f, 0.12038816f, 0.17188333f, 0.29833820f, -0.10494979f, -0.37327406f, 0.12577300f, 
    0.24945040f, -0.22234260f, 0.05648983f, 0.26121575f, -0.06924421f, 0.10134070f, -0.08104853f, -0.00430619f, 
    0.03189567f, -0.07570601f, 0.04576036f, -0.26468089f, -0.05545045f, -0.03939604f, 0.17967707f, -0.12961893f, 
    0.07832944f, -0.03243314f, 0.12850863f, -0.08508611f, 0.18107422f, -0.07356528f, -0.14883077f, -0.00401818f, 
    0.01774062f, 0.22268523f, 0.03542629f, 0.04475746f, -0.00590878f, -0.09640100f, -0.07556871f, 0.06895765f, 
    -0.29376739f, 0.35444003f, 0.35816962f, 0.27101904f, -0.08911920f, 0.14885266f, 0.05149999f, -0.04327834f, 
    -0.02230213f, -0.19365372f, 0.02872127f, -0.06133294f, 0.07551016f, -0.25218165f, -0.12181318f, 0.05182227f, 
    0.02013543f, -0.21115872f, -0.08675023f, 0.33311418f, 0.05936897f, -0.03089673f, 0.16147067f, -0.00031509f, 
    0.10224660f, -0.24832380f, -0.16115883f, -0.01387707f, 0.05192469f, -0.09277546f, -0.08485320f, -0.00056091f, 
    0.00301732f, 0.19099441f, 0.07661947f, -0.01954799f, -0.38729453f, 0.11819849f, 0.14627245f, -0.04928857f, 
    0.03620962f, 0.15747340f, -0.14996020f, 0.05855344f, -0.17063624f, -0.10333125f, -0.22018677f, -0.18578470f, 
    -0.30084538f, -0.03000177f, -0.05251143f, 0.00576427f, -0.01920542f, -0.09524821f, -0.07225523f, 0.05739808f, 
    -0.08781231f, -0.09339664f, -0.06063879f, -0.09586363f, -0.03622254f, -0.30671880f, -0.31411433f, -0.06053305f, 
    0.08434578f, -0.03436171f, -0.03964844f, -0.00332996f, 0.10261505f, 0.04804244f, 0.04066048f, 0.10178901f, 
    0.59261703f, -0.12629168f, -0.12338752f, -0.23147769f, -0.21094437f, -0.08631691f, 0.04767974f, -0.01057788f, 
    0.18364692f, 0.07314031f, -0.05010505f, -0.07843074f, 0.02034510f, -0.28700042f, 0.04126009f, 0.04774459f, 
    0.12892365f, 0.05986037f, -0.04708987f, 0.00549304f, 0.28011775f, -0.02202366f, -0.12311417f, 0.22380957f, 
    -0.04543366f, 0.18872580f, -0.48876569f, 0.15337224f, -0.01688109f, -0.04027531f, -0.22441886f, 0.02340157f, 
    -0.09626620f, 0.14462471f, 0.01547481f, 0.24005671f, 0.01903441f, -0.06042235f, 0.36558649f, -0.11667053f, 
    -0.12668818f, 0.11589810f, -0.16240653f, -0.20729883f, -0.00355724f, -0.00811469f, 0.00179682f, -0.09676022f, 
    -0.00774606f, -0.05400867f, 0.11850082f, -0.25562516f, 0.09365928f, -0.13296737f, 0.16707213f, 0.02001428f, 
    -0.02776566f, -0.11052675f, -0.01122014f, -0.06788572f, 0.23362713f, -0.15247670f, 0.37502435f, 0.22761756f, 
    -0.04646807f, -0.08995589f, 0.13158666f, -0.00067078f, 0.09602054f, -0.04073899f, -0.00022968f, -0.00913651f, 
    0.40191427f, -0.15632211f, 0.13552737f, -0.16993032f, -0.10804991f, 0.07327218f, -0.03901121f, 0.06932929f, 
    0.03103734f, 0.14652462f, 0.02086770f, 0.13077644f, -0.16892652f, 0.05287664f, -0.06411313f, -0.37669948f, 
    0.09453225f, 0.11265940f, -0.13795041f, -0.01078730f, 0.11556935f, 0.04957249f, 0.06113785f, 0.16684541f, 
    0.04013992f, -0.04275193f, 0.16030315f, -0.01927665f, 0.11100011f, 0.23887920f, -0.10451029f, -0.11956765f, 
    0.00643281f, 0.11575431f, 0.12834261f, 0.08630969f, 0.28166747f, 0.13553938f, -0.15140456f, 0.05256112f, 
    -0.05079815f, 0.00060808f, 0.16579299f, -0.01894344f, 0.01776431f, 0.06870467f, 0.09611340f, 0.09702003f, 
    -0.35092026f, -0.14656489f, -0.14193793f, -0.00515400f, 0.14749210f, 0.01404938f, 0.19988656f, 0.19852395f, 
    -0.15587586f, -0.22417344f, -0.02790272f, -0.08162110f, 0.31535876f, 0.06691343f, -0.32655498f, -0.11396429f, 
    0.01756363f, -0.20678782f, 0.02663769f, 0.11522575f, 0.00534244f, 0.00484228f, -0.09233116f, 0.17791474f, 
    -0.35586995f, -0.27226758f, 0.10811058f, -0.06337176f, -0.09700012f, 0.04576261f, -0.04278423f, -0.11442208f, 
    -0.04243755f, 0.01970143f, -0.09448935f, 0.06930137f, 0.08654176f, -0.06277274f, 0.02643046f, -0.11590941f, 
    0.04356815f, -0.19908148f, -0.18826708f, -0.08118434f, -0.03698965f, 0.07572827f, -0.02119712f, 0.34918913f, 
    0.10288727f, -0.04258305f, -0.22031832f, 0.13721722f, 0.00060812f, 0.01525874f, 0.00770982f, 0.01499896f, 
    -0.00403395f, 0.02518348f, 0.12749520f, -0.04623863f, 0.05175424f, -0.29002154f, 0.03797925f, 0.01700863f, 
    0.10810231f, 0.05546178f, -0.04625687f, 0.10917335f, 0.07158780f, -0.02944091f, 0.06267811f, -0.13432489f, 
    0.22162059f, -0.25038394f, 0.11667154f, -0.12038717f, 0.08810013f, -0.08693478f, 0.10469478f, -0.01074227f, 
    0.14585893f, 0.05267461f, -0.02877024f, 0.01975100f, -0.06703342f, -0.19166139f, 0.44676030f, 0.24884671f, 
    -0.23359153f, -0.05423990f, 0.18206073f, 0.14901596f, 0.00513048f, -0.06126072f, 0.01551997f, -0.14149204f, 
    -0.23427649f, 0.14935157f, 0.21459092f, 0.12055806f, 0.09166975f, 0.03261796f, 0.02150443f, 0.14455563f, 
    0.03017825f, 0.07787958f, -0.09056114f, 0.20389089f, 0.04465263f, -0.04800851f, 0.02909605f, -0.05380291f, 
    0.03740964f, -0.08279788f, -0.00105355f, 0.27522832f, 0.10565244f, 0.01135559f, 0.16587968f, 0.05515989f, 
    -0.13124081f, -0.00012767f, 0.07212151f, 0.42457840f, -0.18414021f, 0.16210707f, 0.08449815f, 0.06555789f, 
    -0.04573011f, -0.02350814f, -0.12646510f, -0.11882857f, 0.13449824f, -0.34748077f, -0.15107022f, 0.04137900f, 
    -0.29003632f, -0.15636148f, 0.13057920f, 0.21622111f, -0.04908944f, -0.03679284f, 0.02658454f, -0.19086984f, 
    0.14428565f, -0.13236347f, -0.10860946f, -0.02643573f, -0.08431143f, -0.03005737f, -0.05587538f, 0.15280761f, 
    0.01427561f, 0.14109488f, 0.18127546f, 0.17737226f, -0.15463498f, 0.09251431f, 0.21933326f, 0.12434225f, 
    -0.14341086f, -0.01122237f, 0.09000285f, -0.15261875f, 0.02984968f, 0.06448990f, -0.00637340f, -0.05551996f, 
    -0.21029937f, 0.00783417f, -0.12606023f, 0.13647962f, 0.02439593f, 0.16430429f, 0.07958491f, -0.11684304f, 
    0.04956057f, 0.11105266f, -0.20046528f, 0.15097532f, 0.21732402f, 0.27800542f, 0.23144095f, 0.02140188f, 
    0.00012974f, 0.02339784f, 0.02408647f, 0.00621204f, -0.03387739f, -0.04956238f, -0.10231226f, -0.15697765f, 
    0.26148015f, -0.12706561f, -0.04720582f, 0.10476819f, 0.03696442f, 0.15669091f, -0.00266108f, 0.16847414f, 
    -0.14695452f, 0.22179781f, -0.10046580f, 0.13763259f, 0.11128632f, -0.03550751f, 0.08295304f, -0.09029525f, 
    0.03798812f, 0.06105168f, 0.09591679f, -0.18566273f, -0.02541126f, 0.10763142f, -0.09125731f, -0.04661368f, 
    0.09177181f, -0.06825630f, 0.06119646f, 0.12793529f, -0.04076662f, 0.01695135f, 0.14286534f, -0.05130104f, 
    0.05868674f, -0.03777076f, 0.20209230f, 0.16765307f, -0.13619933f, -0.29785022f, -0.11957271f, -0.10421081f, 
    0.00834897f, 0.04374152f, 0.05292496f, 0.05941684f, -0.21870118f, -0.19521634f, -0.05927609f, 0.01060998f, 
    -0.05040311f, -0.18479179f, -0.08761813f, -0.16884574f, -0.22915007f, -0.07666365f, -0.15033765f, -0.02701152f, 
    -0.17577490f, -0.21310003f, -0.22362681f, 0.04730197f, 0.07268232f, -0.06337052f, -0.05940485f, -0.07412805f, 
    -0.03521707f, 0.04095590f, -0.00362429f, 0.00306982f, 0.07227551f, 0.14383636f, 0.09369116f, -0.05044819f, 
    -0.33532748f, 0.11459556f, 0.06064343f, 0.00122156f, 0.04344793f, -0.04799828f, 0.09562892f, 0.04151645f, 
    0.02344888f, 0.03462324f, -0.09128458f, 0.10527193f, 0.38833359f, 0.22937812f, -0.06648879f, 0.07023149f, 
    -0.07178902f, 0.02204188f, 0.22358170f, 0.16778937f, -0.08239967f, 0.01368159f, 0.02624088f, -0.10082819f, 
    0.40744397f, 0.06690979f, -0.04957712f, -0.21903732f, -0.01306547f, 0.02374149f, 0.07760841f, 0.14240484f, 
    -0.00210492f, -0.01488812f, 0.21486123f, 0.18767375f, -0.04289424f, -0.07413919f, -0.28937054f, -0.11519851f, 
    -0.07873424f, -0.05718586f, 0.04402930f, 0.00000177f, 0.04176229f, -0.06240653f, -0.02700053f, 0.08210625f, 
    0.03675450f, -0.27998638f, -0.14987244f, -0.14685613f, -0.17029792f, -0.09837266f, -0.23535438f, -0.10315252f, 
    -0.01752405f, 0.15022855f, -0.09597448f, -0.04713341f, 0.41998634f, -0.20620887f, -0.32790890f, -0.16198689f, 
    -0.16232939f, -0.13430895f, -0.07166292f, 0.05193493f, -0.12164311f, 0.05541902f, 0.05609467f, 0.00208908f, 
    -0.17450234f, 0.09182526f, 0.19775367f, 0.14939252f, 0.23572876f, 0.08370855f, 0.06775254f, 0.07669207f, 
    0.02757009f, 0.07514125f, -0.00247412f, 0.10616039f, -0.21998577f, -0.07561235f, -0.10246114f, 0.18201375f, 
    0.03942464f, 0.10401269f, 0.08447440f, -0.09904639f, 0.05947767f, 0.02373820f, -0.09186886f, -0.07009295f, 
    -0.03439362f, 0.05304381f, -0.21618703f, 0.04562573f, 0.04875016f, 0.05829662f, 0.30556011f, 0.14661507f, 
    0.09655285f, 0.02990235f, -0.03100383f, 0.05184260f, 0.17867164f, 0.01933797f, 0.29788652f, 0.10278108f, 
    -0.06942167f, 0.01845116f, 0.06097027f, -0.04080859f, 0.06835085f, 0.24037319f, -0.12089712f, -0.13771015f, 
    0.04258782f, 0.06457973f, -0.03900395f, -0.29738209f, 0.06551822f, -0.08316777f, -0.02932938f, -0.02480478f, 
    -0.19813292f, 0.03821536f, -0.01203854f, -0.03629258f, -0.24875882f, -0.05479599f, 0.24754757f, -0.10801274f, 
    -0.04402369f, -0.07107012f, 0.17182748f, -0.08899914f, 0.14370915f, 0.05615321f, 0.06143006f, -0.05824986f, 
    -0.10955492f, 0.20783673f, 0.20658372f, -0.15686458f, 0.15617554f, -0.09000057f, 0.09251582f, -0.11632363f, 
    -0.09691022f, -0.09591331f, 0.05572997f, 0.00228871f, -0.11540882f, -0.16346367f, -0.00842742f, -0.03910650f, 
    0.05453773f, -0.05417932f, 0.09496858f, 0.01620251f, -0.06258173f, 0.15775065f, 0.22167869f, 0.06758954f, 
    0.08893670f, -0.04841157f, -0.17367399f, -0.16529158f, -0.07654502f, 0.05272279f, 0.08099181f, 0.06713801f, 
    0.10655983f, -0.01467118f, 0.05333818f, 0.16096583f, 0.00517767f, 0.12630159f, 0.27325642f, -0.06560817f, 
    -0.03857996f, -0.11246964f, 0.08886801f, 0.03148212f, -0.12546335f, 0.04576254f, 0.15747169f, 0.07245712f, 
    0.01648393f, -0.23502061f, -0.22980791f, 0.21494491f, -0.08435952f, 0.03984838f, 0.01227317f, -0.09951033f, 
    -0.07016242f, 0.07404090f, 0.09368219f, 0.05908872f, 0.18785019f, 0.01925246f, -0.11626077f, -0.34330845f, 
    -0.08375838f, 0.06465149f, 0.06904080f, 0.05178269f, 0.10063412f, 0.27418995f, 0.09208602f, 0.07986201f, 
    0.00466330f, 0.00673636f, 0.01520116f, 0.01084099f, 0.04428862f, 0.02268117f, 0.00161094f, -0.04543548f, 
    -0.01969904f, 0.01041494f, -0.04852651f, 0.01162854f, -0.04185686f, 0.04026255f, -0.05107944f, 0.00494809f, 
    -0.05051998f, -0.02532092f, 0.01206130f, 0.00643210f, -0.06272154f, -0.02108208f, 0.00562983f, -0.07016229f, 
    -0.02300690f, -0.03100349f, -0.01216041f, -0.03338843f, -0.03316157f, -0.09891482f, -0.02853857f, -0.11248956f, 
    -0.05227960f, 0.01846229f, 0.03079416f, 0.04165986f, -0.02716951f, -0.07712458f, -0.06954014f, -0.00061517f, 
    0.00740644f, -0.03221975f, -0.02656872f, -0.05431063f, 0.01548180f, -0.00762476f, 0.02757768f, 0.00210887f, 
    -0.04459454f, 0.02281014f, 0.01739278f, 0.04489426f, 0.00358626f, -0.00919208f, 0.05260597f, -0.00658274f, 
    -0.00439446f, -0.03199896f, -0.04670849f, -0.02204262f, -0.05465481f, -0.07404072f, -0.01935837f, 0.02195608f, 
    -0.08335947f, -0.04209103f, -0.05013189f, -0.04054757f, -0.05948138f, -0.04639633f, -0.02865022f, 0.05058013f, 
    -0.08011542f, -0.04503159f, -0.02080979f, -0.06892772f, -0.08397342f, -0.08978435f, -0.01867861f, -0.03641497f, 
    -0.01601814f, -0.03545614f, 0.04150359f, -0.02382243f, -0.01330767f, -0.03542044f, -0.07100070f, -0.06305696f, 
    0.00655062f, 0.01643414f, -0.05800194f, -0.09575529f, -0.03749042f, -0.01476194f, -0.05060548f, 0.01512246f, 
    0.01316560f, -0.08896226f, -0.09345133f, 0.00571269f, -0.06625303f, -0.06302927f, -0.04476169f, -0.08888422f, 
    0.03948574f, 0.02043461f, 0.04869413f, -0.02430770f, 0.01031603f, -0.01511161f, -0.04466505f, 0.00310248f, 
    -0.03855120f, -0.01315561f, 0.02905002f, -0.02059428f, -0.02395480f, 0.00808989f, -0.08571089f, -0.06914544f, 
    0.01754918f, 0.02303799f, 0.02390886f, -0.06433593f, 0.03519122f, 0.01987145f, -0.01880491f, -0.03987672f, 
    -0.03116124f, 0.00035087f, -0.00264156f, -0.04966126f, -0.05545501f, -0.06459333f, -0.08326934f, -0.06123176f, 
    0.02137535f, -0.04841580f, -0.06639227f, -0.03545021f, -0.04566412f, 0.03746692f, 0.00028246f, 0.00281024f, 
    -0.01360478f, 0.02303086f, -0.02090430f, 0.04997014f, -0.03887282f, -0.03997004f, -0.06268350f, -0.08460243f, 
    -0.08628336f, -0.10217685f, -0.09868177f, -0.00546185f, -0.07147501f, -0.08099020f, -0.00171230f, -0.06433041f, 
    -0.06843356f, -0.09880849f, -0.05115239f, 0.00088992f, -0.02452575f, -0.02218443f, 0.01255018f, -0.02490618f, 
    -0.02370528f, -0.04250125f, 0.01002153f, -0.03605929f, -0.03252812f, -0.01092705f, -0.05807675f, -0.00749582f, 
    -0.05408448f, -0.00992040f, -0.03350692f, 0.00503749f, -0.07211216f, -0.08696848f, -0.03550641f, -0.00339294f, 
    -0.02018227f, -0.04149390f, -0.06409069f, -0.05745537f, 0.01727093f, -0.00156579f, -0.02387087f, -0.01732933f, 
    0.04312944f, -0.00326001f, 0.02031904f, -0.01082472f, -0.04175038f, 0.00854207f, 0.00635744f, 0.02448499f, 
    -0.02400064f, -0.01661022f, -0.00727570f, -0.08722629f, -0.01282338f, -0.00710004f, -0.05315758f, -0.00245024f, 
    -0.00838890f, -0.05744733f, -0.09022972f, 0.00329323f, 0.02451388f, -0.01144974f, 0.01246103f, -0.04094708f, 
    -0.01264369f, -0.07152741f, -0.03952226f, -0.08114395f, -0.05359754f, -0.08324214f, -0.08615081f, -0.02247920f, 
    0.01180304f, -0.03818053f, -0.06082319f, -0.01620051f, -0.04716774f, -0.04897948f, -0.06765775f, -0.05698725f, 
    -0.03397645f, -0.00991949f, 0.02953358f, -0.01013766f, -0.02232743f, 0.00031827f, 0.02849891f, 0.05216216f, 
    -0.01776849f, 0.05833379f, -0.03599012f, -0.04314015f, 0.00780188f, 0.04847101f, 0.00729838f, -0.06690568f, 
    -0.00818524f, -0.00793479f, -0.05390723f, -0.05306120f, -0.04501044f, -0.05974216f, -0.06516122f, -0.11067306f, 
    0.00278318f, -0.06045092f, -0.05580289f, 0.02746046f, -0.00107216f, -0.04433295f, -0.03962009f, -0.00940519f, 
    -0.03779032f, 0.01769456f, -0.05471645f, -0.06242808f, -0.01785920f, -0.03808162f, -0.05148096f, -0.05821845f, 
    0.02602534f, 0.01098245f, -0.02178905f, 0.04376951f, 0.01634786f, -0.08787987f, -0.06988244f, 0.00255381f, 
    -0.02341617f, -0.01136591f, 0.03773030f, -0.01033541f, -0.03502270f, -0.07670727f, -0.06177913f, -0.06490450f, 
    -0.00192010f, -0.02817011f, 0.02739753f, -0.04698768f, -0.04216245f, -0.07392355f, 0.00947610f, -0.03035763f, 
    -0.03847333f, -0.04405452f, -0.09736120f, -0.08628420f, -0.03288567f, 0.05200614f, 0.02259976f, 0.01366655f, 
    0.01995920f, -0.02624349f, -0.03572067f, -0.04271152f, -0.03273239f, -0.02531144f, -0.05162860f, -0.03854375f, 
    -0.04310868f, -0.03074461f, 0.02586013f, 0.04228298f, -0.02122519f, -0.07112241f, -0.06227307f, 0.00349181f, 
    -0.02914235f, -0.04761717f, -0.00469425f, -0.00105869f, 0.04592708f, -0.02101132f, -0.04198318f, 0.03455491f, 
    0.01091548f, 0.05365919f, -0.03670966f, -0.03778859f, -0.08949378f, 0.00092886f, -0.02311895f, -0.02308486f, 
    -0.07865521f, -0.05490318f, 0.02457109f, -0.01694443f, -0.02874436f, -0.04146902f, 0.00662532f, 0.00592500f, 
    -0.04746752f, 0.04811034f, -0.03985667f, -0.02852335f, -0.05591006f, 0.01883788f, -0.03732885f, 0.00243501f, 
    -0.01187357f, -0.01051306f, -0.00161568f, -0.03105948f, 0.02183413f, -0.03473243f, 0.02184630f, -0.00903922f, 
    0.00557577f, -0.05291361f, -0.04903547f, -0.00305782f, -0.01779646f, 0.02182346f, -0.02376381f, -0.01095654f, 
    -0.01847687f, -0.04818726f, 0.01649724f, -0.03144665f, 0.01328214f, 0.01737308f, -0.03601446f, 0.03545052f, 
    0.01055958f, 0.01146038f, 0.02137137f, 0.05010826f, 0.00291034f, 0.00403966f, -0.08443110f, -0.08116128f, 
    -0.04096690f, -0.00236350f, 0.03548502f, -0.01881209f, 0.01495281f, 0.01509558f, -0.00798778f, -0.03964375f, 
    -0.01996921f, 0.02966434f, -0.02016413f, -0.01279458f, -0.05022595f, -0.04900130f, -0.00558782f, -0.00872132f, 
    -0.00436216f, -0.00048241f, 0.00441928f, -0.04950705f, 0.03666761f, 0.00129080f, 0.04236486f, 0.03210563f, 
    -0.00946692f, -0.02097391f, 0.01706575f, -0.02332476f, -0.00753399f, -0.01432736f, 0.01007577f, 0.04529209f, 
    -0.05401180f, -0.04600976f, 0.02952256f, 0.01020678f, -0.04755906f, -0.04639718f, -0.05098408f, 0.00389384f, 
    -0.03422453f, -0.04242046f, 0.00346420f, 0.02256736f, 0.02447220f, 0.02504911f, -0.02507064f, -0.04618215f, 
    0.01356539f, 0.01384480f, -0.01699308f, -0.01782025f, 0.02286341f, -0.05378408f, -0.02376902f, 0.03674695f, 
    -0.01848215f, -0.02676513f, -0.02666642f, -0.01116215f, 0.01805684f, -0.05639188f, 0.03957413f, -0.02590678f, 
    0.00907010f, -0.02571242f, -0.03932865f, -0.05154769f, 0.03274541f, 0.04236233f, -0.01845178f, -0.03327412f, 
    0.01981371f, -0.04812746f, -0.03135678f, -0.03567329f, -0.05486722f, -0.03190133f, -0.01290085f, -0.05137066f, 
    0.03426359f, -0.03819834f, -0.00679002f, 0.02964876f, -0.00373343f, 0.00876866f, -0.04582918f, -0.05275760f, 
    -0.00042784f, -0.01579877f, -0.04755918f, 0.00330295f, 0.03522524f, -0.02937405f, -0.03927934f, -0.05068412f, 
    -0.01324043f, -0.02729424f, 0.02206915f, 0.02943895f, -0.03828565f, 0.04029896f, 0.03810938f, -0.00818072f, 
    0.00324122f, 0.01949655f, 0.03167887f, -0.03369337f, -0.04847591f, 0.01475550f, 0.02691090f, -0.00522679f, 
    0.00235689f, 0.03986150f, -0.03933690f, -0.00764627f, 0.02016674f, -0.04442510f, -0.01515752f, -0.00145078f, 
    0.01818914f, -0.05017756f, -0.00617180f, -0.05199483f, 0.02332801f, -0.04531863f, -0.03363754f, -0.02331659f, 
    -0.01154451f, -0.04837737f, -0.00105230f, -0.04534577f, -0.01315684f, -0.00445549f, -0.05805203f, 0.03493319f, 
    -0.05368921f, -0.01769635f, -0.04092189f, 0.03143486f, 0.01542570f, 0.02514634f, 0.05098248f, -0.03251386f, 
    -0.02273064f, 0.00804210f, 0.00656117f, 0.01810679f, -0.02546637f, -0.03858764f, 0.01982767f, 0.03722303f, 
    0.02054290f, 0.00948110f, 0.03387970f, 0.01782370f, -0.00281505f, -0.04449989f, 0.04082654f, 0.00822255f, 
    0.00096322f, -0.02965154f, -0.04921966f, 0.03784759f, -0.04520024f, -0.03954456f, -0.01608974f, 0.03100201f, 
    -0.01731472f, 0.01622743f, 0.01101858f, 0.02307620f, 0.01863768f, 0.00211614f, -0.05694919f, -0.02824788f, 
    0.03503647f, -0.00386586f, -0.03085827f, -0.03088723f, 0.03638644f, 0.03160042f, -0.03033275f, -0.02698365f, 
    0.01666739f, -0.05017655f, -0.02256535f, -0.00041684f, 0.04141924f, -0.04654415f, 0.03391591f, -0.03145256f, 
    0.03769015f, -0.02877382f, -0.04448987f, 0.01592046f, 0.00195039f, -0.02887605f, 0.01330479f, 0.03329697f, 
    0.03637425f, -0.04945567f, 0.02645196f, -0.05147948f, -0.01541786f, 0.03683420f, 0.03876935f, 0.01530271f, 
    0.02942484f, 0.03136562f, -0.01526025f, -0.02984091f, -0.02323410f, -0.05299731f, -0.04406619f, -0.04294704f, 
    -0.05069912f, -0.04855459f, -0.04421938f, -0.03927878f, 0.00486753f, -0.00290539f, 0.02719342f, -0.00344744f, 
    0.00312881f, -0.04574652f, 0.03389677f, 0.02376078f, 0.04265410f, 0.00737375f, -0.02853943f, 0.00555210f, 
    0.02167320f, -0.00907226f, -0.00057684f, 0.04004655f, -0.02857732f, 0.03124940f, -0.01911465f, 0.02153977f, 
    0.00546401f, 0.01155833f, 0.00953822f, -0.02553690f, -0.03780790f, -0.00039038f, -0.01792264f, 0.02791587f, 
    -0.01788920f, -0.00808591f, -0.02668680f, -0.05473617f, 0.02890905f, 0.03671580f, -0.00757252f, 0.03571539f, 
    0.02616595f, -0.02535456f, 0.00683349f, 0.02955607f, -0.02277637f, 0.00888388f, -0.01784336f, -0.01542481f, 
    0.02127642f, 0.01187405f, -0.03634851f, 0.02281179f, 0.00699030f, 0.00304181f, -0.05604996f, 0.04255594f, 
    0.03060693f, -0.00892073f, -0.03553072f, -0.01340124f, -0.02016386f, 0.04124410f, 0.00897565f, -0.04097103f, 
    -0.01659100f, 0.01814569f, 0.00822942f, -0.03759737f, -0.02105155f, -0.05815016f, -0.05039224f, -0.01470433f, 
    0.02503094f, 0.00694101f, 0.02243525f, -0.05287815f, 0.01825734f, 0.00511492f, 0.01264067f, -0.01148769f, 
    0.03702283f, 0.04002531f, -0.04624334f, -0.02635352f, -0.03189440f, -0.04891418f, 0.03273161f, 0.00715436f, 
    -0.03710374f, -0.05804601f, -0.02089627f, 0.03093486f, -0.00988229f, -0.05174523f, -0.00411408f, 0.03942146f, 
    -0.03266829f, -0.05631856f, -0.03411344f, 0.03920793f, -0.05695417f, -0.04861781f, -0.04339087f, 0.00955967f, 
    -0.04670506f, -0.00934120f, -0.04018246f, 0.02950251f, 0.03142738f, -0.04053858f, 0.02844862f, 0.00701394f, 
    -0.04802266f, -0.04191324f, -0.00059021f, 0.01050013f, -0.03605980f, 0.02556942f, -0.00121133f, -0.01875170f, 
    -0.01529240f, -0.03183994f, -0.02767097f, 0.00026047f, -0.03899482f, -0.03137113f, -0.00318637f, 0.02981535f, 
    -0.02896679f, 0.01717921f, -0.01341573f, 0.04089154f, 0.03030698f, -0.04437900f, 0.02532900f, -0.04750152f, 
    0.02814099f, -0.05203267f, -0.03573060f, 0.00047076f, -0.05630535f, -0.03097538f, -0.01959272f, -0.01442618f, 
    0.02073308f, 0.02291653f, 0.02136413f, 0.02536685f, 0.01909153f, 0.01092492f, 0.00385310f, 0.01490010f, 
    0.02326087f, -0.03480439f, -0.04270856f, -0.01242384f, -0.00684999f, -0.02925228f, -0.05610215f, -0.05391176f, 
    0.02586079f, -0.00010318f, -0.05836611f, 0.02920428f, 0.02934596f, -0.00420314f, -0.01940846f, -0.05530076f, 
    0.02206403f, 0.02234622f, -0.05053002f, -0.05786543f, -0.00399404f, 0.03575623f, -0.00992859f, -0.04376693f, 
    -0.05678929f, 0.02303274f, -0.01693078f, -0.05211998f, 0.00905907f, -0.03881781f, 0.03248691f, 0.01050699f, 
    -0.00355739f, -0.05022242f, -0.05493285f, -0.03797398f, -0.02944824f, -0.00256929f, 0.01686064f, -0.04616049f, 
    -0.04474324f, -0.05537950f, -0.04233565f, -0.00592581f, -0.03676215f, -0.04842496f, 0.00393945f, -0.04025485f, 
    0.01016203f, 0.01370784f, -0.05319729f, -0.04803482f, 0.01252555f, -0.04315306f, 0.03708949f, -0.05182758f, 
    0.00407130f, 0.00852462f, -0.02083111f, -0.00106277f, -0.05742984f, -0.00953835f, -0.05203847f, -0.02244501f, 
    -0.02509789f, 0.03233804f, 0.02933205f, -0.05534421f, -0.01134367f, -0.02700377f, 0.00856212f, 0.02927670f, 
    0.03181829f, 0.00740191f, -0.00338167f, -0.05038704f, -0.04374121f, 0.00675190f, 0.01832863f, -0.04604292f, 
    0.00380059f, -0.01695439f, 0.01711212f, 0.01551016f, -0.00345107f, -0.04585901f, 0.02571128f, 0.01126918f, 
    -0.04983932f, -0.02527021f, 0.01520947f, -0.01950252f, -0.01500202f, 0.00487336f, 0.03302088f, -0.01525129f, 
    0.02169752f, 0.02387505f, -0.05492490f, -0.02302085f, -0.05720323f, 0.01711662f, 0.00075390f, 0.04241354f, 
    -0.01857337f, 0.02222975f, 0.01906169f, 0.04312771f, -0.00166173f, 0.02875893f, -0.00099172f, 0.02925359f, 
    -0.02341628f, -0.00990791f, -0.04667494f, -0.02067911f, -0.05534083f, 0.01169547f, -0.02240661f, 0.03949317f, 
    -0.04530420f, 0.03107484f, -0.03944983f, 0.02969572f, -0.00915397f, 0.00016134f, 0.01364161f, 0.03900133f, 
    0.03398021f, -0.05561886f, 0.04430788f, 0.03817496f, -0.05499978f, -0.03373619f, 0.01753454f, -0.02164041f, 
    -0.00246651f, -0.04296430f, 0.03793553f, 0.01797744f, -0.04212051f, 0.00026348f, -0.01240556f, -0.02530258f, 
    0.02887827f, -0.00488192f, 0.04322767f, -0.01435971f, -0.04517809f, -0.03041744f, -0.04023705f, 0.01176492f, 
    -0.00910133f, -0.01683461f, 0.03470766f, 0.03681442f, 0.00879194f, -0.02435023f, -0.04613302f, 0.03730368f, 
    -0.01792654f, 0.00458955f, -0.02099491f, -0.05237138f, 0.00051511f, -0.05182846f, -0.03825960f, 0.04330751f, 
    -0.01224057f, 0.00795886f, -0.00084164f, 0.04296924f, -0.05502450f, 0.02490488f, -0.04209846f, 0.00099637f, 
    0.02895251f, -0.01942790f, 0.02440293f, -0.00441947f, 0.00269552f, -0.02428368f, -0.00563596f, 0.04132345f, 
    -0.01673893f, -0.00547886f, -0.02305784f, -0.00720761f, -0.01612795f, 0.02179612f, 0.01418405f, 0.01905615f, 
    -0.01077367f, 0.01712262f, -0.05686665f, 0.02875885f, -0.02396597f, -0.03982913f, 0.00898406f, 0.00760478f, 
    0.00594065f, 0.01020346f, 0.02617029f, 0.00750466f, -0.05650706f, -0.03145372f, -0.00301418f, -0.05684720f, 
    -0.04986349f, 0.03031512f, -0.02161046f, -0.00126894f, 0.03452880f, -0.04251552f, 0.00840666f, -0.05324338f, 
    0.04080646f, -0.00858687f, -0.03155287f, -0.03559704f, 0.00967715f, -0.01250512f, -0.04153038f, 0.02427422f, 
    0.00099363f, 0.01591828f, 0.00856959f, -0.03838940f, -0.03308982f, 0.02041088f, -0.01792279f, -0.00834173f, 
    0.00356406f, -0.03370872f, -0.04279438f, 0.00743865f, 0.01890741f, -0.00124193f, -0.00275096f, 0.02023952f, 
    0.00568536f, -0.00087827f, -0.03085014f, -0.00601330f, -0.02515109f, -0.03147680f, -0.00100212f, -0.03991832f, 
    0.03042601f, 0.00117082f, 0.02017380f, 0.02608986f, 0.02548321f, -0.02813318f, 0.03393387f, -0.03783561f, 
    -0.04510421f, 0.01695986f, 0.02304382f, -0.00907238f, -0.00670298f, 0.01457385f, -0.05327550f, -0.03970329f, 
    -0.01865198f, -0.04019237f, 0.03467862f, 0.02220933f, 0.00216273f, 0.01252559f, -0.04308612f, -0.04569066f, 
    -0.01502941f, 0.01342499f, -0.04192208f, 0.01289772f, -0.02817860f, 0.01663661f, 0.03668787f, -0.00820265f, 
    -0.05693942f, -0.01286089f, -0.04502495f, -0.01410991f, -0.03681537f, -0.02434541f, -0.05381664f, -0.01747834f, 
    0.01196382f, 0.00316763f, -0.05650772f, 0.03945322f, 0.01094409f, 0.02659260f, 0.03384612f, 0.01535531f, 
    0.00824698f, -0.00899825f, -0.00584078f, 0.02202040f, 0.01427803f, -0.05692948f, -0.04376628f, 0.00356306f, 
    0.02545034f, -0.02377501f, 0.04192948f, -0.03907989f, -0.00134613f, 0.00087321f, 0.01406778f, 0.02328661f, 
    0.04336972f, 0.01171959f, 0.04659825f, -0.05541648f, -0.01342706f, 0.01791122f, -0.04544018f, -0.02983459f, 
    0.04395629f, -0.04189415f, 0.00582286f, -0.04692258f, 0.04445106f, -0.03953936f, -0.02325873f, -0.00126137f, 
    0.00299547f, -0.04508464f, 0.00423819f, -0.03460092f, -0.03713294f, -0.00570265f, 0.01968639f, 0.04258066f, 
    -0.04591502f, 0.00455773f, -0.03263868f, -0.03265646f, 0.02965832f, -0.04779216f, 0.03175585f, -0.01455242f, 
    0.03204140f, -0.01850331f, 0.02323856f, -0.03805509f, -0.04555397f, -0.05090151f, -0.02861315f, 0.01683859f, 
    -0.05532930f, -0.00792612f, 0.02085802f, -0.03069126f, -0.01338213f, -0.01192835f, -0.05584456f, -0.02904226f, 
    0.03038404f, -0.01360064f, 0.00786754f, -0.04831676f, -0.05131960f, 0.00620460f, -0.02899164f, -0.03348358f, 
    -0.03438256f, 0.04078067f, -0.03992741f, -0.00735732f, 0.00961860f, 0.04145613f, 0.01592311f, -0.00370773f, 
    -0.01500243f, 0.01151293f, 0.02132602f, -0.01342694f, 0.03506773f, 0.02248652f, -0.05697187f, 0.01448284f, 
    -0.02616216f, -0.01362051f, 0.01649444f, 0.04195132f, -0.01166004f, -0.04214957f, -0.02626153f, -0.04450449f, 
    0.02190793f, 0.00679257f, -0.01922099f, -0.04244129f, -0.01193022f, 0.00474123f, -0.05517847f, 0.01573038f, 
    -0.12629592f, -0.50825697f, 0.07071242f, -0.35195598f, 0.18703109f, 0.04650719f, 0.07758104f, 0.04720455f, 
    -0.01292335f, -0.00584750f, -0.05511732f, -0.09274758f, -0.05578153f, -0.22232080f, 0.08038290f, 0.13586660f, 
    0.01896192f, 0.09664725f, 0.06635620f, 0.09219239f, -0.03900646f, -0.02813132f, -0.00283839f, 0.01536846f, 
    -0.02528676f, 0.40930635f, 0.40112168f, -0.01372981f, -0.02890912f, -0.08576965f, 0.06043663f, -0.12469307f, 
    -0.06732181f, 0.02053935f, 0.22234076f, -0.00100891f, -0.22083701f, 0.09349478f, 0.09354453f, -0.10981626f, 
    -0.11084738f, -0.04081899f, 0.02256698f, -0.05545569f, 0.04986775f, 0.04060434f, 0.07598017f, -0.04054558f, 
    0.04397957f, 0.05065141f, -0.36131579f, 0.03711306f, 0.01698918f, 0.07060685f, -0.02775455f, -0.07294182f, 
    0.04034089f, -0.11225904f, 0.27616045f, 0.15606913f, -0.04030110f, -0.13231263f, -0.04669625f, -0.12227257f, 
    0.14038087f, -0.13764089f, -0.09772101f, -0.25907761f, 0.06784751f, 0.10185130f, -0.00454881f, -0.09450459f, 
    0.19054681f, 0.04553704f, 0.03365500f, -0.20518541f, 0.02665085f, 0.03463745f, -0.06615524f, -0.05661030f, 
    -0.01313955f, -0.00782849f, 0.00147767f, 0.01691413f, 0.32881528f, 0.57507813f, 0.07459208f, -0.05501109f, 
    0.10594577f, -0.07216789f, -0.24155763f, -0.01060431f, 0.11649340f, 0.13594915f, 0.11272730f, -0.13111305f, 
    -0.40330476f, -0.08194858f, 0.21836482f, 0.10264210f, -0.03571958f, 0.08711251f, -0.06517991f, -0.00294532f, 
    -0.07832290f, 0.08604782f, -0.00604348f, 0.13982317f, -0.00966709f, -0.04188411f, -0.16658759f, 0.15595536f, 
    0.25401440f, 0.05089017f, 0.11716273f, -0.02367205f, 0.10737903f, -0.02199685f, -0.17760366f, 0.01721456f, 
    -0.10918301f, -0.25051340f, 0.08824857f, 0.17944065f, 0.06463555f, 0.07702546f, 0.04000723f, 0.09940308f, 
    0.07619093f, -0.05125444f, 0.10955320f, 0.13728887f, -0.11406097f, -0.06472170f, -0.07826552f, -0.14900929f, 
    -0.00162793f, -0.09489042f, 0.16512753f, 0.11686241f, 0.11828852f, 0.11662057f, 0.15308361f, 0.07751784f, 
    0.04967997f, -0.01406696f, 0.01715308f, 0.17903954f, 0.13935365f, 0.10546459f, 0.09033461f, 0.02638939f, 
    0.07334351f, -0.02210207f, -0.00195183f, 0.06161293f, 0.00254413f, 0.29022583f, 0.14957866f, -0.07680292f, 
    -0.04441296f, -0.06528964f, 0.02417376f, -0.27362281f, 0.02865182f, 0.10582573f, -0.06925675f, -0.09563918f, 
    -0.17373614f, -0.11077641f, -0.00890738f, -0.14907251f, 0.12300017f, 0.11003464f, 0.05186266f, 0.00982041f, 
    0.03446729f, -0.01280160f, 0.06555478f, 0.00061129f, -0.04573194f, -0.41793159f, 0.24280168f, 0.32821956f, 
    -0.21023063f, -0.06945734f, 0.01787121f, 0.01188172f, 0.02817516f, 0.08245964f, 0.16674368f, -0.03640269f, 
    -0.38780656f, 0.05649780f, 0.15146133f, 0.33327338f, -0.00637262f, 0.08075687f, 0.06324834f, 0.07333060f, 
    -0.05945551f, -0.24435546f, -0.09930476f, 0.17407142f, 0.14299068f, 0.08203726f, 0.03281596f, 0.00893472f, 
    -0.07534195f, 0.13287137f, -0.08324139f, -0.05937965f, -0.06433118f, -0.05417916f, 0.07823912f, 0.07854763f, 
    -0.05238876f, -0.01642319f, 0.17236573f, -0.17954443f, -0.10140914f, -0.09903707f, -0.17770937f, -0.14353956f, 
    0.11688291f, -0.02507845f, -0.01559403f, -0.02069601f, -0.40133080f, -0.25667566f, 0.26393768f, 0.06025074f, 
    0.01123135f, 0.05520597f, -0.06805144f, -0.25456858f, 0.00906027f, 0.08327089f, 0.06724209f, 0.02629304f, 
    0.31347322f, 0.23832618f, -0.13685986f, -0.57246417f, 0.09976236f, -0.16879727f, -0.10429185f, 0.07668741f, 
    0.15949494f, 0.10470991f, 0.04488261f, -0.01629446f, 0.12829119f, 0.18976630f, -0.10198418f, -0.02498720f, 
    0.05113778f, 0.08234645f, 0.10672364f, 0.01996325f, -0.00858411f, -0.00814910f, 0.13385440f, 0.01429565f, 
    0.17116334f, 0.00017424f, 0.03887270f, -0.10534053f, -0.12899514f, -0.03426743f, 0.06570052f, -0.07382935f, 
    -0.08529278f, -0.04867685f, 0.02142606f, 0.21153416f, -0.04301488f, 0.01660019f, 0.06041322f, -0.05677341f, 
    -0.13724363f, -0.03440604f, -0.14833361f, -0.34822142f, 0.05504254f, 0.09423330f, 0.05774230f, -0.03468052f, 
    0.00898233f, -0.04968847f, -0.08510447f, 0.13472889f, 0.00746998f, 0.12838669f, 0.04063898f, 0.09256631f, 
    0.05990747f, -0.11881173f, -0.05479859f, -0.01602922f, 0.04515587f, -0.05337811f, 0.00367567f, -0.00147598f, 
    0.09920193f, 0.02176176f, 0.00671100f, -0.01677709f, 0.05545838f, 0.09398943f, -0.08768853f, 0.03446914f, 
    0.11278284f, -0.09222148f, -0.39147279f, 0.03322842f, 0.01632802f, 0.25534227f, 0.28807819f, 0.01895324f, 
    0.18976615f, -0.00130641f, -0.05156396f, 0.02080614f, 0.26824170f, -0.11079491f, -0.25057012f, -0.15014318f, 
    0.02011411f, 0.02266348f, 0.25386387f, 0.00475812f, -0.01276110f, -0.01959220f, 0.13542125f, 0.15392579f, 
    -0.19078965f, 0.07461118f, -0.00639066f, 0.14295098f, -0.09333657f, 0.01772870f, 0.06271505f, 0.02317403f, 
    -0.07229931f, -0.07389610f, -0.01837169f, 0.22614980f, 0.00800324f, -0.11877537f, 0.08466174f, 0.13848920f, 
    -0.16185111f, -0.06396051f, -0.07602490f, 0.02204895f, -0.12893423f, 0.16397922f, -0.10208881f, 0.03866178f, 
    -0.06697353f, -0.47569343f, 0.24088344f, 0.04732323f, 0.10206632f, -0.08389158f, -0.12711766f, -0.03764382f, 
    -0.07220262f, 0.04108566f, 0.00806264f, -0.02562724f, -0.06425012f, 0.08378086f, 0.23265113f, 0.39647013f, 
    0.01750301f, 0.03724858f, 0.00990986f, 0.03587361f, 0.09562266f, 0.28512233f, 0.06915509f, -0.01577117f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.20076022f, 0.00542418f, 0.03477201f, 0.20382842f, -0.04465957f, -0.07019652f, 0.01508661f, -0.10167181f, 
    0.11334935f, 0.15664674f, -0.07039328f, 0.01024363f, 0.02982124f, 0.16891629f, -0.06999054f, 0.01319622f, 
    -0.00471991f, 0.14346835f, -0.04200208f, -0.10758554f, 0.01123564f, -0.05324734f, 0.27194312f, -0.04421246f, 
    0.04688922f, 0.02658513f, 0.14586146f, -0.03838762f, -0.03883968f, -0.03759473f, 0.04033340f, 0.01440543f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01437779f, -0.16948509f, -0.30325237f, 0.03844480f, -0.02109871f, 0.21094647f, -0.04456083f, 0.53813666f, 
    -0.06501456f, 0.16476375f, 0.10140628f, -0.18244748f, 0.06893206f, -0.01454631f, -0.03014033f, 0.14933062f, 
    0.13792288f, -0.15307215f, 0.22478463f, 0.69133651f, -0.14805262f, -0.03544102f, 0.29867658f, 0.04159746f, 
    -0.26162204f, -0.13010037f, -0.68826735f, 0.38403764f, 0.08152077f, 0.10808521f, 0.09319358f, -0.12111630f, 
    0.09578709f, 0.13426034f, 0.14044984f, 0.02676080f, 0.23151399f, 0.13647224f, -0.07060344f, 0.04894547f, 
    0.09086103f, 0.25342271f, -0.25910488f, -0.09080108f, -0.14331557f, 0.06725629f, -0.13678773f, -0.12946948f, 
    -0.16320160f, 0.08067685f, -0.16213866f, 0.13068093f, 0.09342337f, 0.12762362f, -0.22758141f, -0.09454520f, 
    0.46079096f, -0.15161501f, 0.66439271f, 0.28896466f, 0.13980743f, 0.14672944f, 0.01633954f, 0.20002811f, 
    -0.45532289f, -0.03017833f, 0.16655135f, -0.18598659f, 0.13568744f, 0.29760727f, -0.00739821f, 0.19690619f, 
    0.21688494f, -0.30313015f, -0.03739806f, 0.54692447f, 0.02702718f, 0.19154307f, 0.37517476f, -0.05112237f, 
    0.01886490f, -0.01373658f, 0.30385795f, 0.75293314f, 0.03993734f, -0.02747131f, -0.13896704f, 0.09796114f, 
    0.11534550f, -0.03356999f, -0.30040482f, 0.28043699f, 0.02187476f, 0.15424353f, 0.07677784f, -0.28688285f, 
    0.39611632f, -0.16627835f, -0.23765546f, 0.21651049f, -0.77969527f, -0.22318847f, 0.17530809f, 0.09521212f, 
    -0.30086678f, -0.29397541f, -0.05023134f, -0.13305029f, 0.16572715f, 0.15275553f, 0.09680594f, -0.04005623f, 
    -0.17213717f, -0.06074816f, 0.13065574f, 0.42840916f, -0.06347585f, 0.12774615f, 0.10393765f, -0.00483677f, 
    -0.08060038f, -0.09620266f, 0.38404885f, -0.17567888f, -0.08141081f, 0.12695657f, 0.03533504f, 0.03188669f, 
    0.34543717f, 0.06636143f, -0.17536694f, 0.07002395f, -0.56889772f, -0.12816806f, 0.03534572f, 0.09082784f, 
    -0.06625805f, -0.30932489f, 0.08944977f, -0.12917529f, 0.00343016f, 0.10266772f, 0.12691091f, 0.01275277f, 
    0.14352837f, 0.03046120f, -0.14082669f, 0.02749391f, -0.08942376f, -0.14339070f, 0.16742347f, 0.15068558f, 
    0.18224812f, -0.14641930f, 0.71337807f, -0.09688445f, 0.06633395f, 0.04390203f, 0.11148698f, -0.28695428f, 
    0.37068585f, 0.11254126f, 0.00901029f, 0.24550849f, -0.01983713f, 0.05656462f, -0.05614959f, 0.14469568f, 
    -0.07723207f, 0.22223815f, 0.24866591f, -0.43212247f, 0.05148499f, 0.33884811f, -0.14733197f, 0.06344551f, 
    0.10781049f, 0.08569250f, 0.09770112f, -0.39894336f, 0.13653041f, -0.05111805f, 0.10868936f, 0.10023587f, 
    -0.40703019f, -0.02525273f, -0.06931326f, -0.24767451f, 0.12881047f, -0.10630181f, -0.02084558f, -0.26022935f, 
    0.07286903f, -0.01270900f, 0.00927810f, 0.17153634f, 0.05471922f, -0.04141349f, -0.12647551f, 0.12839431f, 
    -0.24992082f, -0.32801399f, 0.14213617f, -0.15209123f, -0.10051906f, 0.12208049f, 0.28831974f, -0.17311339f, 
    -0.01106148f, 0.30310267f, 0.30523607f, 0.36073005f, -0.16507551f, 0.08089139f, -0.22384216f, -0.05251518f, 
    -0.13953528f, -0.02434346f, 0.11712267f, -0.10626028f, 0.07886649f, -0.14041579f, 0.09481523f, -0.00940333f, 
    0.10466291f, -0.00277949f, -0.09377632f, -0.01714849f, 0.04127388f, 0.06545413f, -0.17376868f, -0.13114496f, 
    0.04758528f, -0.00271348f, 0.15707189f, -0.05674741f, 0.00428636f, -0.10697776f, -0.09299998f, -0.00532256f, 
    -0.14288363f, -0.04705468f, -0.12912402f, 0.07980759f, -0.04819852f, -0.06628085f, -0.15961410f, -0.11659898f, 
    0.00723359f, -0.04794109f, 0.01946761f, 0.07050571f, -0.03412757f, 0.05934221f, -0.07120449f, -0.01533757f, 
    0.08636957f, 0.08253428f, 0.01805469f, 0.06425115f, 0.15681221f, 0.01892449f, -0.11869895f, -0.22700556f, 
    -0.14825743f, -0.00881974f, -0.14038420f, 0.06293757f, -0.07734960f, -0.18641135f, 0.01629031f, 0.15047923f, 
    -0.00207439f, -0.20143987f, 0.13367146f, 0.02338466f, 0.07819302f, 0.00748535f, 0.05732343f, 0.04482492f, 
    -0.10202605f, -0.04677748f, 0.09898005f, -0.14961231f, -0.00712579f, -0.14368877f, 0.13029331f, -0.14843735f, 
    -0.24061489f, -0.16198911f, 0.03090813f, -0.01110150f, -0.02913570f, -0.36689764f, -0.12834249f, -0.01152543f, 
    0.25677785f, -0.39601117f, -0.56384277f, 0.50747484f, 0.17558430f, -0.25294226f, 0.13487077f, 0.01544815f, 
    0.05508997f, 0.23490049f, 0.44373673f, 0.33528411f, -0.07416499f, 0.05083716f, 0.23137404f, -0.02354294f, 
    0.31574449f, -0.14727549f, -0.44417334f, -0.04657229f, 0.04207067f, 0.05623797f, -0.06683514f, 0.00916477f, 
    0.07631033f, -0.16310734f, -0.26565829f, 0.09134348f, 0.45850977f, 0.30718368f, 0.03129814f, 0.04241893f, 
    0.26758194f, 0.28165305f, -0.23401077f, 0.15492551f, 0.14360133f, -0.02594008f, 0.08322846f, 0.11225546f, 
    -0.08190645f, -0.29680359f, -0.38579878f, 0.17091128f, 0.10219635f, -0.17203580f, 0.09512875f, 0.09921815f, 
    0.08398587f, 0.14055941f, 0.25949165f, 0.11107542f, -0.06427126f, 0.14042211f, -0.05157392f, -0.05806964f, 
    0.10127471f, 0.15099341f, -0.04724690f, 0.00100557f, 0.01143278f, -0.08774765f, -0.02868224f, -0.08817352f, 
    0.01681696f, -0.01829902f, -0.79670370f, -0.00470947f, 0.06361192f, 0.03361924f, -0.52254707f, -0.02018444f, 
    0.15913175f, -0.32959080f, 0.33132857f, -0.12740773f, -0.10390422f, -0.16745350f, 0.19748563f, 0.16932772f, 
    0.32319176f, 0.06254997f, 0.12223627f, 0.25319925f, -0.05525525f, -0.14062606f, -0.06372079f, 0.11250233f, 
    -0.10865980f, -0.12808073f, -0.40303957f, 0.19107983f, 0.00661506f, 0.30913123f, -0.02515603f, 0.30804396f, 
    -0.46997705f, 0.26604164f, -0.12303460f, 0.29597595f, -0.15926088f, 0.06243736f, -0.07237204f, 0.10361479f, 
    -0.08654542f, -0.02645685f, 0.09265370f, 0.31076863f, -0.11022095f, 0.11735476f, 0.12687020f, 0.04513725f, 
    0.29294842f, -0.05996531f, -0.16639924f, 0.07141896f, -0.07994241f, -0.15971474f, 0.10854286f, -0.46309793f, 
    0.18706660f, -0.12289332f, 0.42576367f, 0.24082087f, 0.25409439f, -0.28501546f, 0.06739910f, -0.12428050f, 
    0.13401826f, -0.04628130f, -0.07449397f, -0.17343608f, 0.00278235f, 0.33776417f, 0.04248589f, 0.08416924f, 
    0.07408131f, 0.13326585f, -0.08580960f, -0.47454020f, 0.11862793f, -0.07720681f, 0.11736644f, 0.09970701f, 
    -0.31627950f, 0.04862294f, -0.28389722f, 0.12497903f, 0.00723600f, 0.10033394f, 0.09113120f, 0.01796361f, 
    0.01403444f, 0.13376680f, 0.35874271f, 0.20471254f, 0.25768507f, 0.25644967f, 0.01382108f, 0.15169793f, 
    -0.00115860f, -0.02288990f, 0.27778172f, 0.22784534f, 0.08175541f, 0.22894430f, 0.26287377f, -0.03380985f, 
    0.14940344f, 0.35618982f, 0.03562152f, -0.52233028f, 0.09204008f, -0.08984201f, -0.18788221f, 0.11346491f, 
    -0.11772834f, 0.15753719f, -0.25628191f, -0.47788817f, -0.14724509f, -0.08474590f, -0.07048851f, -0.07717928f, 
    0.07335757f, -0.03853142f, 0.20628005f, 0.22056054f, 0.07399895f, -0.31041527f, -0.04078970f, -0.22996862f, 
    0.19340909f, -0.23007505f, -0.09552790f, -0.05228769f, 0.14701600f, 0.14182277f, 0.06958621f, 0.05017899f, 
    0.08419938f, 0.36466846f, 0.11341622f, -0.40098923f, -0.05124300f, -0.02346398f, 0.05543585f, -0.10073019f, 
    -0.10169391f, 0.05808723f, -0.00020961f, -0.23073566f, -0.17629372f, 0.17049171f, 0.07302258f, -0.08020510f, 
    -0.29953066f, 0.14705558f, 0.14524463f, 0.16822064f, 0.00046332f, 0.29628947f, 0.15768388f, 0.16396505f, 
    -0.00687393f, -0.26385263f, 0.27107444f, 0.00931934f, -0.02336796f, -0.13093866f, 0.28650901f, -0.16234450f, 
    -0.03739475f, -0.15537731f, 0.28233215f, 0.40691093f, -0.06667140f, -0.09322259f, -0.25243074f, -0.08253912f, 
    0.15579924f, -0.07062085f, -0.02132301f, 0.15709215f, 0.13098238f, 0.04120259f, 0.17025879f, -0.04330508f, 
    -0.15987904f, -0.10666457f, 0.19188838f, 0.39717367f, 0.20227098f, -0.01386059f, -0.03979534f, -0.27426705f, 
    -0.03443581f, 0.47708955f, -0.15880172f, 0.22537327f, -0.11560789f, 0.40476039f, -0.21325207f, -0.06261755f, 
    0.11129797f, -0.30357128f, -0.11505692f, -0.65553522f, -0.09611879f, 0.10692851f, 0.20245533f, 0.05937702f, 
    0.41282183f, 0.01376406f, -0.22904359f, 0.29874754f, 0.15293746f, 0.01612348f, -0.10913388f, 0.08127337f, 
    0.22445942f, 0.09625117f, -0.24845874f, 0.20366405f, 0.09400252f, 0.09621731f, -0.02564992f, -0.09011149f, 
    0.24930339f, 0.32564399f, 0.18825589f, -0.32512966f, 0.10823155f, 0.10155409f, -0.10605118f, -0.00137862f, 
    0.07784286f, 0.13585968f, -0.24324386f, -0.06444735f, 0.13802117f, -0.05616533f, 0.26266816f, 0.14569575f, 
    -0.07892051f, 0.04079726f, -0.11970955f, -0.11975814f, -0.01310464f, -0.08642310f, 0.07860163f, -0.40705165f, 
    -0.10589236f, 0.00524537f, 0.31262895f, -0.13962552f, -0.41785043f, -0.26908711f, -0.05131937f, -0.21117684f, 
    -0.08962936f, 0.03871123f, 0.21717027f, 0.04245494f, -0.15633802f, 0.26762325f, 0.15394492f, 0.04985690f, 
    0.14641687f, 0.08901294f, 0.32153580f, -0.05735129f, 0.12506731f, 0.16076198f, 0.18108562f, 0.01526681f, 
    0.01223382f, -0.12356456f, 0.26529640f, -0.05790039f, -0.14510778f, -0.10646595f, -0.12318672f, 0.26547265f, 
    0.04866625f, -0.09560525f, 0.22023626f, -0.21498479f, -0.28673017f, -0.23102884f, -0.09138360f, 0.15397954f, 
    0.23724179f, -0.19310729f, 0.25008515f, -0.08855814f, 0.05257350f, 0.04149936f, 0.16878872f, 0.04226768f, 
    -0.12236379f, 0.40481707f, 0.10321443f, -0.42028573f, 0.09322158f, -0.06510997f, 0.28336880f, -0.04601249f, 
    -0.34280273f, -0.02753639f, 0.09092361f, -0.15828693f, 0.15928531f, 0.08022029f, 0.08721092f, -0.21895811f, 
    0.10593300f, -0.03899051f, -0.05380961f, 0.04130444f, 0.34272879f, -0.01995437f, -0.15684099f, -0.02936187f, 
    0.44004411f, 0.10123894f, 0.05849306f, -0.21099044f, 0.14120355f, -0.02625978f, 0.19312251f, -0.05252828f, 
    -0.12122343f, 0.37349507f, -0.34996077f, -0.33840576f, 0.09699201f, 0.11345448f, -0.10922104f, 0.16174671f, 
    0.06712948f, 0.13427003f, 0.34462413f, -0.35546464f, 0.16478194f, -0.15107566f, -0.12417055f, -0.25095230f, 
    0.19286263f, -0.08675790f, -0.06114752f, 0.09090247f, 0.10114034f, -0.22111110f, -0.14427061f, 0.05420507f, 
    0.09189347f, 0.36255941f, -0.54120064f, 0.18947750f, 0.05309931f, -0.21546164f, -0.50284922f, 0.07892605f, 
    -0.00284901f, 0.04331595f, -0.21482603f, -0.54748070f, 0.02397972f, 0.00028194f, 0.18111719f, -0.16471900f, 
    0.04648466f, 0.09870998f, -0.15265878f, 0.57221395f, 0.02168514f, 0.07737031f, -0.11775108f, -0.17428608f, 
    -0.30096743f, -0.05418006f, 0.05774631f, 0.15421560f, -0.18158317f, 0.10079465f, 0.17226014f, 0.10679765f, 
    -0.24654937f, 0.36841390f, -0.01495736f, 0.44649082f, 0.01514007f, 0.08475963f, 0.16345392f, 0.02008648f, 
    0.15583879f, 0.05959152f, -0.07275455f, -0.66920882f, 0.06424846f, 0.04444282f, -0.04338281f, -0.05302745f, 
    0.40876442f, 0.13629797f, 0.12533265f, -0.40556511f, 0.12066667f, 0.02519594f, -0.03748984f, 0.25678521f, 
    -0.11634684f, -0.01809309f, 0.28054640f, -0.08339049f, 0.12611517f, 0.23736879f, -0.14019497f, 0.34945378f, 
    -0.17756857f, -0.12928890f, 0.30263698f, -0.03182540f, -0.05261206f, -0.05219419f, 0.12971792f, -0.13198271f, 
    -0.13606265f, -0.09120174f, 0.30789474f, 0.55916440f, -0.12718581f, -0.03854315f, -0.40235680f, 0.08459165f, 
    0.03099519f, -0.04345779f, 0.32639331f, 0.07178606f, -0.06806777f, -0.14195447f, -0.16819625f, -0.14677103f, 
    -0.12835161f, -0.01773536f, -0.12877099f, -0.21262191f, -0.60386348f, -0.05695015f, -0.02905037f, -0.06922346f, 
    -0.00137903f, -0.14753966f, 0.20946553f, 0.49289364f, 0.16458435f, 0.20699525f, 0.27211204f, 0.07322413f, 
    -0.00428887f, 0.15225802f, 0.39089781f, 0.12256600f, 0.06571537f, 0.13160896f, 0.16643849f, 0.07285803f, 
    0.23767769f, 0.05192072f, 0.07225785f, -0.47703189f, 0.16286246f, 0.02235896f, -0.03543455f, 0.19355164f, 
    0.31367108f, 0.07845663f, 0.03568036f, -0.01823462f, -0.15657568f, -0.15082008f, 0.16756147f, -0.02231985f, 
    -0.29656458f, -0.24738656f, 0.25181428f, -0.37563086f, -0.08722261f, -0.11021530f, -0.05307651f, -0.13138759f, 
    -0.11592404f, -0.18007118f, 0.00058354f, 0.05691151f, -0.09838025f, 0.16065365f, -0.11359777f, 0.11771372f, 
    0.00619423f, -0.13118249f, 0.30649617f, 0.00711999f, -0.05851167f, -0.07046896f, 0.03601770f, 0.24450585f, 
    0.08485661f, -0.06277991f, -0.20582204f, -0.17341127f, 0.14684148f, -0.16615008f, 0.13654503f, 0.03328796f, 
    -0.28105888f, 0.13418619f, -0.07679559f, 0.05465395f, 0.06694867f, 0.10583093f, 0.15912534f, 0.12715815f, 
    0.14449623f, -0.16063955f, -0.12433994f, 0.10130227f, -0.11071791f, 0.04255603f, -0.25877622f, 0.13784048f, 
    -0.13972722f, 0.10648719f, -0.20913178f, -0.05762585f, -0.08998293f, 0.03456336f, 0.13662605f, 0.12137291f, 
    0.11434136f, 0.15667273f, 0.41403309f, -0.10477860f, 0.65677863f, 0.17608449f, 0.15772507f, -0.17449573f, 
    0.36579919f, 0.25201225f, -0.13272372f, 0.25070828f, -0.11704917f, -0.01403728f, -0.08457901f, 0.12788408f, 
    -0.08965453f, -0.09326705f, -0.08261219f, -0.59753996f, -0.16280049f, 0.01517312f, -0.08291333f, 0.08787333f, 
    0.28232270f, 0.14239120f, 0.22573081f, 0.21173358f, -0.09285479f, -0.02838279f, 0.11230610f, 0.32624739f, 
    0.08668612f, -0.17048590f, 0.03480451f, 0.16409327f, -0.21857245f, 0.02684339f, -0.03142353f, -0.18589258f, 
    -0.06361185f, -0.12448225f, 0.00751148f, -0.06971426f, -0.03937295f, -0.20685397f, -0.21182567f, 0.17007367f, 
    0.08305955f, -0.20062995f, -0.12549640f, -0.10724191f, 0.04341336f, -0.00909181f, -0.12709849f, 0.07813948f, 
    0.02158945f, -0.13958852f, 0.02594278f, -0.01156041f, -0.10633978f, -0.07933168f, -0.12118842f, -0.06919294f, 
    -0.10047175f, -0.03994609f, 0.09259197f, 0.10817081f, 0.10130735f, 0.23788127f, 0.08158302f, -0.11776629f, 
    -0.07575003f, 0.23708223f, -0.14513943f, 0.05196549f, 0.05986344f, -0.20735686f, -0.28676417f, -0.00596066f, 
    0.13140930f, 0.11376203f, -0.25452402f, -0.34676012f, 0.07103594f, -0.07478259f, -0.09758866f, -0.09128062f, 
    0.11377405f, 0.12108954f, 0.12414504f, 0.24740559f, 0.04088807f, -0.15975694f, 0.16251579f, 0.21733071f, 
    -0.03965835f, 0.13366663f, 0.28165284f, 0.02597824f, 0.30657566f, 0.04661967f, -0.10127485f, 0.03991416f, 
    -0.16782935f, 0.22749563f, -0.00219303f, 0.20942718f, -0.12973900f, 0.34435895f, 0.17079942f, -0.10178118f, 
    0.14674219f, -0.50904995f, 0.36968106f, 0.69344002f, -0.00206265f, -0.13643445f, -0.01482093f, -0.04427031f, 
    -0.04119107f, 0.05912685f, -0.20741609f, -0.12361106f, 0.05549712f, -0.10287721f, 0.16449413f, 0.14487442f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05471602f, 0.01209550f, 0.06798682f, 0.13392626f, 0.44069344f, 0.12911254f, -0.01682699f, 0.04116986f, 
    -0.04561931f, 0.05751489f, 0.01410400f, 0.04539956f, 0.10035190f, -0.00465259f, 0.17011152f, -0.00603336f, 
    -0.27537578f, 0.25467652f, -0.02300792f, 0.02101620f, 0.05499659f, 0.04663793f, 0.23620853f, -0.03515674f, 
    -0.25664893f, 0.11613765f, -0.23587570f, 0.08710365f, 0.18476959f, -0.15317325f, 0.04837358f, -0.15277965f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.16270722f, 0.00910333f, 0.09443867f, 0.21839847f, 0.03439731f, 0.02532339f, 0.15965469f, 0.00788340f, 
    -0.12106787f, -0.42126721f, -0.20394090f, -0.08014661f, 0.00856986f, -0.43475050f, -0.13944876f, -0.13867991f, 
    0.26823142f, -0.53364259f, -0.30135834f, 0.01262255f, -0.10296657f, -0.35420144f, -0.26348716f, -0.19989765f, 
    0.35122648f, 0.03003957f, 0.14863026f, 0.27968469f, -0.30852786f, 0.06802795f, -0.02441871f, 0.24132954f, 
    -0.26741266f, -0.13035698f, -0.51142442f, 0.38271061f, 0.36679152f, 0.12891118f, 0.18245253f, 0.03170668f, 
    -0.04303286f, 0.31626540f, -0.17264134f, 0.14653707f, -0.42646417f, -0.06354514f, -0.02414246f, 0.24288757f, 
    -0.06222649f, -0.37738827f, 0.14413980f, 0.02985989f, 0.32899621f, 0.38317686f, 0.01436843f, -0.17320769f, 
    -0.02416275f, -0.05329406f, 0.25281096f, -0.01808693f, -0.18289821f, -0.08582130f, 0.17659734f, -0.26870099f, 
    -0.43935397f, 0.37545520f, -0.10058363f, 0.11690722f, 0.36004424f, 0.10048586f, -0.67160004f, -0.12813056f, 
    0.13426618f, -0.59114665f, 0.15739346f, -0.15664327f, -0.17616823f, -0.10640854f, -0.14409737f, -0.22717339f, 
    -0.62602252f, -0.01873915f, 0.12895837f, 0.02646660f, -0.10023505f, 0.32800472f, -0.09258953f, 0.09993970f, 
    -0.55228698f, 0.03224936f, -0.09197254f, -0.03534660f, 0.15031491f, -0.13154626f, -0.02863025f, -0.20897815f, 
    0.25213024f, -0.14295812f, -0.01941056f, -0.18370408f, -0.11916016f, 0.07218148f, -0.06631153f, -0.07982326f, 
    -0.16527058f, -0.08404356f, 0.22699702f, -0.66479278f, 0.36426932f, -0.31538993f, 0.18058267f, -0.47830400f, 
    0.06704547f, -0.20025215f, 0.25136906f, -0.55202925f, -0.07984951f, 0.16676016f, -0.21597673f, 0.08935696f, 
    0.07123039f, -0.17346643f, -0.47095382f, -0.29411775f, -0.17241092f, -0.21387236f, -0.37474188f, 0.06457122f, 
    -0.07814045f, 0.01587464f, -0.11512984f, -0.28555948f, -0.10397635f, 0.06684493f, -0.05257537f, -0.07883128f, 
    -0.16979983f, -0.02585369f, -0.18263462f, -0.16501763f, -0.24681921f, -0.14312620f, 0.21683587f, -0.07423944f, 
    0.20852913f, -0.14393103f, -0.43896925f, 0.15909326f, 0.14208238f, -0.04557249f, -0.06290653f, 0.31154227f, 
    0.28222451f, 0.03021813f, -0.35234353f, -0.06053934f, 0.10891926f, -0.19260879f, 0.06122115f, -0.00097106f, 
    -0.14346682f, -0.28812546f, -0.35228923f, 0.18159176f, 0.12506612f, 0.16755706f, 0.01049662f, 0.07893357f, 
    0.04287306f, -0.02075411f, -0.28897050f, -0.01296078f, 0.28664806f, -0.11410032f, 0.09118886f, 0.06065847f, 
    -0.13979159f, 0.12720205f, 0.14236623f, 0.23421453f, -0.04567382f, -0.24624014f, -0.36238262f, 0.28479180f, 
    -0.26021692f, 0.20440505f, -0.35110617f, 0.08318752f, -0.43992406f, 0.04011481f, 0.02144240f, 0.19630593f, 
    -0.44160298f, 0.17247142f, -0.44300014f, -0.19776969f, -0.69921523f, -0.22370262f, -0.50035793f, 0.12695816f, 
    -0.04514314f, -0.04344596f, 0.12762243f, 0.30530772f, -0.48548880f, -0.04237796f, -0.89372742f, 0.07251163f, 
    -0.62848943f, 0.34690824f, 0.08187710f, -0.08661554f, -0.58199471f, -0.16373001f, 0.27790949f, -0.09873297f, 
    -0.01944553f, -0.42354190f, -0.22487475f, -0.13210513f, 0.16575271f, 0.14929143f, -0.01445435f, 0.05632478f, 
    0.14269572f, -0.15025450f, 0.36040497f, -0.19748919f, -0.51626998f, -0.47897375f, -0.39235324f, -0.01147037f, 
    -0.01967758f, 0.40046993f, 0.00182251f, -0.11739451f, 0.31674707f, -0.30368349f, -0.31885469f, -0.10634831f, 
    -0.12525503f, -0.09894843f, -0.20234278f, 0.09575879f, 0.16601653f, -0.29449105f, 0.20706964f, 0.12399436f, 
    -0.36092108f, 0.14887941f, -0.72355986f, -0.15817344f, -0.13217518f, -0.09929474f, -0.11886033f, -0.61571878f, 
    0.40987524f, -0.07383057f, -0.22047246f, 0.19867173f, 0.26365685f, 0.22017898f, -0.44773522f, -0.17663129f, 
    -0.08567370f, -0.11443702f, -0.13735838f, 0.01162930f, 0.37685394f, -0.01807384f, -0.48930645f, -0.11803417f, 
    -0.40974626f, 0.06948145f, -0.11105186f, -0.39554617f, 0.11498376f, -0.64217085f, 0.31473038f, -0.33431819f, 
    -0.46862814f, -0.46591353f, -0.06746591f, -0.04770037f, -0.41413334f, -0.13038182f, 0.04516613f, -0.35938606f, 
    -0.74155754f, 0.03250543f, 0.27664560f, -0.60277081f, -0.14567696f, -0.16762835f, -0.24024376f, -0.14411141f, 
    -0.17933255f, 0.12733708f, -0.12058958f, -0.11092658f, -0.49860165f, 0.07544988f, 0.10145625f, 0.19546983f, 
    0.03606120f, 0.18850820f, -0.35971385f, 0.07056175f, -0.25544086f, -0.07143764f, -0.30995446f, 0.02015450f, 
    -0.49365947f, 0.08620230f, -0.17369550f, -0.28439218f, 0.17400861f, -0.02881092f, -0.19251332f, 0.17364067f, 
    0.30646148f, -0.63370824f, 0.12621185f, -0.17036954f, -0.03150706f, 0.27829501f, -0.20316119f, 0.02618242f, 
    -0.05058165f, -0.65277684f, -0.13684890f, -0.82433248f, -0.67455912f, 0.22300547f, 0.08747003f, 0.02759938f, 
    -0.22456454f, -0.09348396f, 0.27496889f, 0.24702029f, 0.46014416f, -0.16743846f, -0.13305613f, -0.75563997f, 
    -0.35221779f, 0.00110233f, -0.00959382f, -0.05409814f, -0.20409518f, -0.03395176f, -0.22861487f, 0.06700061f, 
    0.02534275f, 0.02514364f, -0.40831572f, -0.40356144f, -0.41482937f, 0.28839245f, 0.05627120f, -0.12103128f, 
    0.10927233f, -0.23279522f, -0.10718860f, -0.25200814f, -0.17699592f, 0.30116999f, 0.07435901f, 0.33000821f, 
    -0.44164509f, 0.21535675f, 0.36952907f, -0.54307008f, -0.14747314f, 0.23243012f, 0.09669357f, -0.31285053f, 
    -0.61443663f, -0.64519131f, 0.02913439f, -0.15714872f, -0.01218701f, -0.00583022f, -0.22785282f, 0.03488243f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19035569f, 0.14079162f, 0.19286375f, -0.12037478f, 0.00560194f, 0.14651319f, -0.07615601f, -0.01789732f, 
    0.01902726f, -0.00818028f, -0.13716505f, -0.11126101f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
