#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.21901861f, 0.05338616f, -0.51474667f, -0.88104278f, -0.31920251f, -0.52304024f, 0.27245775f, 0.72958928f, 
    0.81691211f, -0.42401391f, -0.56938791f, -0.47649986f, -0.73238808f, -0.35271204f, 0.50089306f, -0.57117343f, 
    -0.53603774f, -0.56349188f, -0.16447127f, 0.31901145f, -0.13889913f, 0.41129059f, 0.63371408f, 0.70294285f, 
    -0.14131534f, -0.67172390f, -0.48458049f, 0.27624810f, 0.35353684f, 0.28752330f, -1.04535139f, -0.03922413f, 
    0.46309933f, -0.54751921f, 0.11210642f, 0.66619021f, -0.74433792f, 1.06413639f, -0.50080043f, 0.62215638f, 
    -0.18683089f, 0.26166558f, 0.28445011f, -0.18890484f, 0.48605803f, -0.91885197f, -0.34931213f, -0.04796382f, 
    -0.79701430f, -0.87489390f, -0.86977887f, -0.06500321f, -0.51075554f, -0.68119287f, -0.96982425f, -0.14196745f, 
    -0.58320874f, 1.33331060f, -0.40043017f, -0.74644190f, -0.17130096f, -0.13293079f, -0.47047231f, -0.15740941f, 
    -0.22561100f, 0.53101057f, 0.47827879f, 0.10345981f, 0.99928236f, 0.13443588f, 0.07262924f, -0.24901865f, 
    -1.60185373f, -0.08257034f, 0.54099613f, 0.07121108f, 0.89708531f, 0.26681238f, -0.38117164f, -0.00427571f, 
    -0.13808566f, -0.72173005f, -0.57145935f, 0.80457652f, -0.23444013f, 1.02537894f, -1.20255780f, 0.16645625f, 
    -0.05538813f, -0.16369706f, 0.90112042f, 0.78377950f, 0.35647613f, -0.02300689f, 0.32778203f, 0.02761415f, 
    -0.09299242f, -0.35172558f, -0.41484475f, -0.79249626f, -1.05665922f, -0.93959683f, 0.99885142f, 0.62702656f, 
    0.19779028f, 0.08023157f, -0.53218216f, -0.24213520f, -0.84529924f, -0.69852906f, -0.42979759f, -0.18666548f, 
    0.89802527f, -0.78766149f, 0.56237113f, 0.22831801f, 0.12525015f, 0.84681934f, 0.69686669f, 0.70817226f, 
    0.29712877f, -1.13370657f, -0.63810343f, 0.29402888f, -0.39459655f, 0.28286752f, -0.13779253f, 0.83754838f, 
    -0.27760684f, 0.21064870f, 0.13866140f, -0.51818848f, 0.43850374f, 0.76654553f, -0.79053658f, 0.13643980f, 
    -1.39070165f, -1.58520448f, 0.61837721f, 0.27669898f, 0.30298436f, 0.46778563f, -0.01653880f, 0.39441895f, 
    -0.05302025f, 0.11638842f, 0.44051951f, 0.52062321f, 0.24247214f, 0.52485150f, 0.22672705f, 0.49887463f, 
    0.08526411f, 0.47491682f, 0.73545337f, 0.24135531f, -0.17454296f, -0.22074367f, -0.04421512f, -0.13181315f, 
    0.79152143f, 0.60140419f, 0.75756180f, -0.00417476f, -0.72162515f, 0.35553744f, 0.51347631f, 0.41783226f, 
    -0.36664569f, 0.79993159f, -0.18566754f, 0.12387753f, -0.70034677f, 0.37680805f, -0.89501131f, -0.68196744f, 
    -0.85368037f, 0.51483101f, -0.55993015f, 0.80813956f, -0.66203028f, 0.50434947f, 0.65240186f, 0.46326512f, 
    0.49412939f, 0.01518726f, -0.61602163f, -0.76467705f, -0.28851274f, 0.69638151f, 0.63991094f, -0.48961547f, 
    -0.36476389f, -0.22477975f, 0.87745517f, 0.23866698f, -0.13615432f, -0.13200048f, -0.31544477f, -0.23947608f, 
    0.25442326f, -0.75867254f, -0.36878112f, 0.12788747f, 0.43840820f, 0.71715301f, 0.19256261f, -0.11351666f, 
    0.08335083f, 0.08927691f, 0.87791133f, 0.10865568f, -0.63385475f, 0.30722085f, 0.50480562f, 0.55253053f, 
    -0.77772433f, -0.63197553f, 0.36253411f, 0.56295359f, -0.96217722f, -1.33816516f, -0.56100565f, 0.56648523f, 
    0.25683132f, -0.26061657f, -0.61492658f, -0.29007262f, 0.20456775f, -0.58543456f, -0.52328837f, 0.32958257f, 
    0.90226305f, 0.32519978f, 1.22741628f, -0.34001470f, -0.60430592f, 0.14625058f, -0.06635436f, -0.03386274f, 
    -0.08181430f, 0.27869579f, -0.02084348f, 0.54568529f, -0.16050585f, -0.15899065f, -0.34673220f, 1.11694729f, 
    -0.80040866f, -0.26689377f, -0.15724340f, -0.16989593f, -0.32150108f, -1.03319383f, 1.38005447f, -0.16221881f, 
    -0.37365890f, -0.26260561f, -0.31985199f, 0.11620590f, 0.53044003f, -0.96220618f, 1.11950719f, -0.16599257f, 
    -0.60887057f, 0.51471525f, 0.14199896f, 0.16204545f, -0.24248114f, -0.16837701f, -0.06879849f, -0.18626162f, 
    0.18879364f, 0.70602322f, -0.87177861f, 0.60800725f, 0.60385019f, -0.48708647f, -0.26889968f, 0.09891274f, 
    -0.67039019f, -0.87745214f, 0.30018839f, 0.42807987f, -0.72309405f, -0.73101789f, -0.64177835f, -0.45113283f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13846740f, 0.18284129f, 0.26172277f, 0.16095872f, 0.10703173f, -0.12834132f, -0.09383322f, -0.23044457f, 
    0.07895504f, -0.07078724f, 0.10302094f, 0.34592924f, 0.08937965f, 0.32954726f, 0.04309455f, 0.56156355f, 
    0.24756946f, -0.14918344f, 0.43695432f, 0.06229111f, -0.01432069f, 0.59914523f, 0.29381698f, 0.04364881f, 
    0.07869901f, 0.28635341f, 0.50404978f, -0.13114217f, -0.14639717f, 0.14349544f, 0.30797553f, 0.04249107f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.17401001f, 0.09127377f, 0.09946878f, 0.12485165f, -0.03485597f, -0.22778855f, -0.07092652f, -0.21735887f, 
    -0.25356477f, 0.04542814f, -0.14745678f, -0.04833507f, 0.05193005f, 0.06582993f, 0.20784828f, 0.07980318f, 
    0.07042779f, 0.06929129f, -0.11805563f, -0.00147757f, 0.04804033f, 0.19976747f, 0.09566063f, 0.03009194f, 
    0.00256976f, 0.15721944f, 0.03242965f, 0.12894733f, 0.13799268f, 0.03331911f, -0.14341883f, -0.13853709f, 
    -0.02777653f, 0.18994656f, 0.00893386f, -0.24606431f, -0.16990414f, -0.12121493f, -0.24494416f, 0.10956151f, 
    0.07473110f, -0.00102021f, -0.02549601f, -0.01575589f, -0.13554555f, 0.20596936f, 0.22005104f, 0.22199355f, 
    0.04760261f, 0.13984129f, 0.06034612f, 0.03888425f, -0.02147389f, 0.13763271f, 0.05919571f, -0.22428285f, 
    -0.23608863f, 0.00472609f, 0.08776532f, 0.20266064f, 0.08631440f, 0.05087423f, 0.23888150f, 0.02948483f, 
    -0.08681889f, -0.21231861f, 0.01721423f, 0.15844996f, 0.16912739f, 0.12846927f, -0.12049472f, 0.01622148f, 
    -0.05820468f, 0.25314128f, -0.38287562f, 0.20147194f, -0.02315672f, 0.18267281f, 0.06993746f, -0.04187717f, 
    -0.10679779f, 0.16055892f, 0.05010282f, -0.29559767f, 0.10231687f, -0.04333787f, -0.09670183f, 0.06483245f, 
    -0.05628571f, 0.17188646f, -0.20108716f, 0.29544666f, 0.23450920f, 0.11272668f, 0.01630387f, 0.08962742f, 
    0.13409469f, 0.04052540f, -0.01533501f, 0.17008242f, -0.13938083f, -0.20274267f, 0.05447925f, 0.03271542f, 
    0.26815358f, 0.08455718f, 0.12226643f, 0.10849766f, -0.03919575f, -0.13946332f, -0.42019981f, 0.04727546f, 
    0.12769999f, 0.02254927f, 0.19919087f, -0.20097129f, -0.17167620f, 0.27173868f, 0.25400031f, 0.11760641f, 
    0.12377361f, -0.05591574f, 0.02063519f, 0.01976578f, 0.08531848f, -0.08635805f, -0.19552664f, 0.08907945f, 
    -0.33575544f, 0.11017894f, -0.01578090f, 0.20261720f, -0.16262725f, -0.07050698f, -0.01421192f, -0.12644316f, 
    -0.44462287f, -0.19848239f, 0.23677456f, -0.08872107f, -0.00143607f, -0.21114427f, -0.00818255f, -0.11799026f, 
    -0.00622142f, -0.07185101f, -0.09054072f, 0.13874118f, 0.10589150f, 0.12472995f, -0.11787067f, -0.16053572f, 
    -0.10885441f, 0.10293241f, 0.14532828f, 0.02028637f, 0.08117069f, 0.02691029f, -0.00417433f, 0.05981857f, 
    -0.04650506f, -0.28075117f, -0.28373203f, 0.01694362f, -0.24104959f, 0.12852904f, 0.18129590f, 0.14013408f, 
    0.00414549f, -0.04323687f, -0.05604443f, 0.12442599f, -0.13027844f, -0.09614674f, 0.35539541f, 0.23891036f, 
    -0.05749603f, -0.02222919f, 0.05019881f, -0.25560412f, -0.01453995f, 0.18376493f, 0.19553834f, 0.14196473f, 
    0.02142953f, 0.05219138f, 0.08268946f, 0.15762196f, 0.00122899f, -0.02480022f, 0.09951370f, -0.07958393f, 
    0.09817167f, -0.01694593f, -0.13944592f, 0.20495819f, 0.05081407f, -0.09303533f, 0.14484295f, -0.04920861f, 
    0.03303783f, 0.00632834f, -0.08225068f, -0.20858780f, -0.07377207f, -0.29581252f, -0.06056419f, -0.04286782f, 
    0.01396087f, -0.14403152f, 0.03476208f, 0.08068296f, 0.07260811f, -0.17254816f, -0.28110895f, -0.31969514f, 
    0.13327232f, 0.07771864f, -0.22979265f, 0.33160359f, 0.03718945f, -0.01321718f, 0.00831742f, 0.04618415f, 
    -0.01648889f, 0.10472168f, -0.05975339f, -0.07142682f, 0.10415313f, -0.11761487f, -0.19804016f, 0.05211591f, 
    -0.17388515f, -0.06252524f, -0.29150683f, 0.14644261f, -0.03861044f, 0.12118465f, -0.12285837f, -0.12340926f, 
    0.18791912f, 0.14068015f, -0.11958755f, -0.23560973f, 0.36377043f, 0.20695060f, 0.26442909f, -0.00098342f, 
    0.04580666f, 0.20665613f, 0.31134793f, 0.17416266f, 0.38844612f, 0.05998001f, -0.49235708f, 0.13954999f, 
    -0.06541117f, -0.37006131f, -0.16576593f, -0.29052037f, -0.12584935f, 0.14860174f, 0.32071540f, -0.13354555f, 
    0.13243610f, 0.08268891f, -0.11097495f, 0.12064054f, 0.15911055f, 0.21500185f, 0.27413979f, -0.06852304f, 
    -0.10984912f, -0.07774887f, 0.07069397f, 0.09106983f, 0.11577706f, 0.17175382f, -0.35062206f, 0.06182639f, 
    -0.04739003f, 0.10162447f, 0.14849663f, -0.11499742f, -0.02655854f, 0.03704599f, 0.18107767f, 0.19440299f, 
    0.02495286f, -0.05971046f, 0.03601056f, 0.01611459f, 0.02932594f, 0.03696575f, 0.04697214f, -0.02851915f, 
    -0.06782517f, -0.03921053f, -0.03902343f, -0.01809993f, 0.01691381f, 0.03709356f, -0.00787755f, -0.05716474f, 
    0.01980031f, -0.03593620f, 0.03016102f, 0.02087335f, -0.03030730f, 0.02100799f, 0.01439769f, 0.01819639f, 
    -0.04576638f, -0.04140540f, -0.00320257f, -0.02254855f, -0.05251407f, 0.03484000f, 0.04367120f, 0.05550671f, 
    -0.00826927f, -0.03623904f, -0.00064840f, -0.05578016f, -0.05271375f, 0.01205997f, 0.02489823f, -0.04582335f, 
    0.03017575f, -0.01717412f, 0.04795905f, -0.02226880f, 0.03649494f, 0.03456779f, -0.02908008f, 0.01098054f, 
    0.00834684f, 0.00160210f, -0.04520546f, -0.00889220f, -0.00697043f, 0.01945810f, -0.05863458f, 0.01927112f, 
    -0.02841092f, 0.00923207f, -0.00365295f, 0.04053372f, 0.04303756f, 0.04209842f, 0.00261956f, -0.04719810f, 
    0.03571235f, -0.03723629f, -0.03505877f, -0.00937658f, -0.05065490f, -0.02551983f, 0.04195999f, -0.06626897f, 
    0.00606878f, 0.04508507f, -0.03246938f, -0.04056932f, 0.05361307f, -0.03696284f, -0.03228979f, 0.04531340f, 
    0.03306972f, -0.05136173f, -0.05948412f, 0.04258103f, 0.00653830f, -0.03495216f, -0.05985016f, -0.01376771f, 
    -0.05501992f, 0.01168717f, 0.01228529f, 0.02678973f, -0.01454115f, 0.00987406f, 0.04545147f, -0.00990588f, 
    -0.02434061f, -0.01376653f, -0.04560259f, -0.03526307f, 0.04594004f, -0.04287048f, -0.05195167f, 0.03012001f, 
    -0.06091969f, -0.03764242f, -0.00718097f, -0.01794042f, -0.02369482f, 0.00702016f, 0.03674112f, -0.02676683f, 
    -0.00775760f, 0.01761137f, 0.03719645f, 0.00792316f, 0.04454144f, 0.01886730f, 0.01066012f, 0.04740669f, 
    0.04418541f, -0.02361689f, 0.04950782f, -0.01243645f, 0.01221521f, 0.00813552f, 0.02107610f, -0.04042726f, 
    0.03629079f, -0.04932764f, -0.01566874f, 0.04514923f, -0.02525864f, -0.01317560f, 0.03439235f, 0.05005106f, 
    -0.05468217f, 0.04009554f, -0.03730556f, -0.03184686f, 0.01258210f, 0.02590233f, 0.03538703f, -0.02175609f, 
    -0.04562106f, -0.05284309f, -0.06701267f, 0.03788673f, 0.05201663f, -0.05607784f, -0.06815734f, 0.03304948f, 
    -0.02085514f, 0.03248736f, -0.03462609f, 0.04780785f, 0.00672725f, -0.05670076f, -0.02896657f, -0.06114592f, 
    -0.02664520f, 0.02287070f, 0.04138592f, 0.00488644f, -0.03356646f, 0.03749452f, -0.01136465f, -0.06004871f, 
    -0.06314708f, -0.01180383f, -0.04441602f, -0.00608440f, 0.02447874f, 0.02116911f, -0.03628610f, -0.05065808f, 
    -0.06333945f, -0.06295108f, 0.02150760f, 0.00438173f, -0.04443319f, -0.02259737f, -0.06109413f, 0.00655336f, 
    0.00549202f, -0.01114365f, -0.00968482f, 0.05625675f, -0.04090709f, -0.01326532f, 0.04712083f, 0.02902638f, 
    0.00471728f, -0.02137609f, -0.01173947f, -0.05541394f, 0.01997868f, 0.02027004f, 0.03307141f, -0.01732335f, 
    0.00659253f, 0.03632804f, -0.00169687f, 0.03022239f, 0.04841657f, 0.01555097f, -0.05453406f, -0.02100089f, 
    0.01808735f, -0.00844763f, 0.04164644f, 0.00441709f, 0.00401907f, -0.00840522f, -0.05955981f, -0.05338288f, 
    -0.00777964f, 0.05058989f, -0.00904552f, 0.02425944f, 0.02237768f, -0.06053072f, 0.00500464f, 0.01124494f, 
    -0.02976348f, -0.03381082f, -0.02590362f, -0.00693811f, -0.00440544f, -0.02021051f, 0.01681123f, -0.03638408f, 
    -0.05004511f, -0.04544631f, -0.05067572f, 0.01880324f, 0.01894387f, 0.03594143f, -0.00952903f, -0.02683420f, 
    -0.02478491f, -0.01265780f, -0.00096214f, 0.02700458f, -0.05841508f, -0.01417054f, -0.03136119f, -0.06111923f, 
    0.00153946f, -0.04074530f, 0.01825970f, 0.04214991f, 0.02656836f, -0.04534144f, -0.01112669f, -0.01674842f, 
    0.01575425f, 0.03379768f, -0.05366937f, -0.05857763f, -0.02941937f, -0.00069146f, -0.06292755f, 0.00750038f, 
    -0.05930289f, -0.03996689f, -0.05852634f, -0.02988882f, -0.00246664f, -0.01585822f, -0.04475750f, 0.01381993f, 
    -0.06019936f, -0.04398111f, -0.03372294f, -0.04837751f, 0.04517492f, 0.02176728f, 0.01806332f, -0.04474536f, 
    0.02830179f, -0.06027592f, 0.03300683f, 0.00782881f, -0.02311292f, 0.00483107f, -0.04810599f, -0.01184743f, 
    -0.31610888f, -0.21052638f, -0.07525851f, -0.15861644f, -0.04114384f, 0.05516332f, -0.10440441f, -0.18084866f, 
    0.07852396f, 0.06238889f, -0.13887706f, -0.20096259f, 0.02681178f, -0.07684422f, -0.02305136f, 0.07535250f, 
    0.20296848f, 0.03339003f, 0.04842287f, 0.07168094f, 0.16454194f, -0.07810800f, 0.17242301f, -0.02900701f, 
    0.03478484f, -0.01560074f, 0.01346473f, -0.38709587f, 0.06796569f, -0.26035520f, -0.00974683f, -0.15881912f, 
    0.08422270f, -0.02035735f, -0.02921674f, 0.07213186f, 0.29059944f, -0.32772136f, -0.30108652f, -0.07524258f, 
    0.16911297f, -0.00312091f, 0.18696576f, 0.07195088f, 0.00113869f, 0.09290940f, -0.02796840f, -0.10916959f, 
    -0.08206162f, -0.19421890f, -0.18816251f, 0.03746576f, 0.17643957f, 0.05911030f, 0.08612503f, -0.13412066f, 
    -0.20252714f, 0.02009199f, -0.15645126f, 0.05603114f, 0.10633698f, 0.05170344f, 0.07045367f, -0.16001268f, 
    -0.11164852f, -0.08168929f, -0.11451802f, 0.11074502f, 0.11635552f, 0.13599998f, -0.16837941f, 0.20738418f, 
    0.61793959f, 0.20195054f, -0.57040870f, -0.17440002f, 0.07933857f, 0.11372261f, 0.18652807f, 0.12819538f, 
    0.04816789f, 0.06177399f, -0.14514659f, 0.12770453f, -0.00970481f, -0.39107114f, -0.02570925f, 0.13836220f, 
    0.12729712f, -0.06318302f, -0.71224266f, 0.35083917f, 0.19606543f, -0.06422597f, 0.04331615f, -0.03470522f, 
    -0.02049853f, -0.12578568f, -0.08617205f, 0.39582872f, -0.08781917f, -0.35411480f, -0.11126796f, 0.17309995f, 
    0.27588376f, 0.16632843f, 0.05898514f, -0.00637414f, 0.32728457f, -0.23379993f, -0.14386421f, 0.08620466f, 
    0.15007254f, 0.21256375f, 0.24079368f, -0.02376806f, 0.00631332f, -0.40636912f, -0.04595106f, 0.22801062f, 
    -0.05010191f, 0.02875637f, -0.02867291f, 0.04255144f, 0.04389308f, -0.06633732f, -0.06430183f, -0.01211473f, 
    0.18035379f, -0.07572889f, 0.17087142f, 0.12570556f, 0.00844911f, 0.09370492f, -0.08961485f, 0.35031471f, 
    -0.36781037f, -0.41634527f, 0.03509864f, -0.06877363f, 0.22263631f, 0.05353395f, -0.07286993f, 0.01230555f, 
    -0.02178728f, 0.04662447f, 0.07990556f, -0.09197149f, -0.05858428f, -0.02768555f, 0.18149036f, -0.12392119f, 
    0.04552997f, -0.31703708f, 0.20195498f, 0.04100242f, -0.10632978f, -0.22300559f, -0.20862086f, -0.24639523f, 
    0.05990481f, -0.04389125f, -0.46657234f, -0.10794768f, 0.11978192f, -0.03784717f, 0.12586905f, 0.11028497f, 
    0.20158382f, 0.12203053f, 0.21901743f, 0.32195866f, -0.30490410f, 0.00775639f, 0.02338549f, -0.15886840f, 
    0.01248633f, -0.05739477f, 0.15462063f, 0.08583694f, 0.21074751f, 0.17930363f, -0.06811555f, -0.05352132f, 
    0.05980282f, -0.04123153f, 0.09508616f, -0.03662395f, 0.00697585f, -0.61982125f, 0.03619264f, 0.21140862f, 
    0.01678939f, 0.21144657f, 0.09416013f, 0.10469814f, 0.03754938f, -0.14251651f, 0.08574791f, -0.30692938f, 
    -0.21503599f, -0.03154380f, 0.07230436f, -0.00113070f, -0.00974269f, -0.11823601f, 0.04601360f, -0.14329860f, 
    -0.05236989f, -0.07188502f, -0.04670554f, 0.00879493f, 0.07981244f, 0.10113981f, 0.13461596f, -0.11889882f, 
    0.04690167f, -0.09794361f, -0.01745932f, -0.10112851f, 0.03213113f, -0.05825093f, -0.09097247f, -0.02328974f, 
    -0.01522836f, 0.02773932f, -0.22612424f, -0.11513659f, -0.11007097f, 0.07782525f, -0.02718440f, 0.01815658f, 
    -0.09969176f, 0.00194382f, -0.49823526f, -0.05803365f, 0.22920404f, 0.00210900f, 0.00308341f, -0.04117873f, 
    0.09075999f, 0.25591373f, -0.02886684f, -0.66179001f, -0.23685430f, 0.70686519f, 0.05331950f, 0.13422495f, 
    -0.08547854f, 0.05068401f, 0.12084856f, 0.07991203f, 0.66033256f, -0.50139326f, -0.37925425f, -0.07360204f, 
    -0.32321066f, -0.07637631f, -0.08974896f, 0.07211717f, -0.24031787f, 0.82517594f, -0.15928636f, -0.07077672f, 
    -0.19765426f, 0.39796168f, -0.19061844f, 0.13153297f, 0.03985633f, 0.00680749f, -0.20595808f, -0.15231457f, 
    -0.08737709f, 0.18001603f, 0.06386007f, 0.06069588f, 0.12886377f, 0.34797159f, -0.14880973f, 0.10092608f, 
    -0.06284816f, 0.11249603f, -0.01918703f, -0.10982285f, 0.04711801f, -0.13257664f, 0.10945854f, -0.03092895f, 
    -0.36943707f, -0.01432019f, -0.03596868f, 0.34716174f, 0.03700044f, -0.03745531f, 0.01528124f, 0.11667435f, 
    0.17103323f, -0.89865083f, -0.36219257f, -0.78377467f, -0.07510760f, -0.07897909f, -0.10976840f, 0.07180073f, 
    0.06290377f, 0.00687005f, 0.08032674f, 0.12936302f, 0.14869134f, -0.21878760f, 0.01895849f, -0.15354358f, 
    0.06559423f, -0.26006505f, -0.19309786f, -0.07490045f, 0.08991173f, 0.16061036f, 0.09668048f, 0.02191428f, 
    0.09380839f, 0.16643915f, -0.08699023f, 0.20796154f, 0.09025270f, 0.08617380f, 0.16083504f, -0.30291352f, 
    0.05837367f, -0.17553236f, 0.01574903f, -0.08444669f, -0.10715987f, 0.38071766f, 0.03314985f, -0.79776800f, 
    -0.17315780f, -0.10356109f, -0.05083491f, -0.04149790f, 0.24234271f, 0.20102286f, -0.85563707f, -0.59935337f, 
    -0.55501664f, -0.22056706f, -0.18158138f, 0.03904097f, 0.02830021f, -0.08638725f, -0.22077118f, 0.15088016f, 
    0.09196396f, 0.18528293f, -0.25805068f, -0.11904220f, -0.13632745f, -0.11879532f, -0.09307912f, -0.15387107f, 
    0.06583101f, -0.01589020f, 0.22876713f, -0.12100847f, 0.01144952f, -0.08504631f, 0.09040278f, -0.10150930f, 
    -0.15918604f, 0.06762942f, -0.31843916f, -0.57025993f, -0.13057344f, 0.02693906f, 0.32790583f, -0.03077336f, 
    0.09615897f, -0.18779607f, 0.20408008f, 0.19550215f, 0.20843539f, 0.04781511f, 0.08267991f, 0.16354543f, 
    0.01947643f, -0.25897720f, 0.00180321f, -0.09506351f, -0.57945669f, -0.42094067f, -0.31260568f, -0.06998678f, 
    -0.47728974f, -0.11157536f, -0.02522650f, -0.08512306f, 0.10083645f, 0.04817359f, -0.06621666f, 0.07592431f, 
    0.04308708f, 0.04929425f, 0.02629024f, -0.04275946f, -0.00458689f, 0.07594232f, 0.09300499f, -0.06330144f, 
    0.02341163f, 0.02284305f, 0.18670692f, -0.02904553f, 0.04892167f, -0.24670285f, 0.04030440f, -0.14972609f, 
    -0.03922631f, -0.02076255f, 0.10586174f, 0.25410777f, 0.16746587f, -0.04190536f, 0.00772796f, 0.32888743f, 
    -0.20303856f, -0.54811317f, 0.02323089f, 0.05333621f, -0.05896332f, -0.03659854f, -0.02028995f, 0.06030916f, 
    0.13639636f, 0.15254401f, 0.23315874f, 0.01166016f, -0.00586373f, -0.06371413f, 0.01734755f, -0.00875118f, 
    0.03136800f, -0.09358536f, 0.13556059f, 0.16047630f, 0.11464768f, 0.00747060f, 0.05774784f, 0.13973701f, 
    -0.11029556f, 0.00315249f, 0.19807172f, 0.18184353f, 0.23301756f, -0.00124058f, -0.27624497f, -0.24267992f, 
    0.13550919f, -0.15943161f, 0.00309997f, 0.72641701f, 0.44070980f, -0.57069528f, -0.19350383f, 0.13261329f, 
    0.00748475f, -0.12435322f, 0.09161045f, -0.02032140f, 0.09532172f, 0.14847723f, 0.20063142f, -0.00783104f, 
    0.07596757f, 0.11741398f, 0.05280327f, -0.18984406f, -0.25927320f, 0.06700975f, 0.21722107f, 0.07605299f, 
    0.07639469f, -0.09337966f, 0.07359855f, 0.11187355f, -0.06366459f, 0.12760396f, -0.20228925f, -0.09948871f, 
    0.07906365f, 0.29410732f, -0.12689327f, 0.05173014f, 0.13363798f, 0.03097023f, 0.17279047f, 0.11323896f, 
    0.00645460f, 0.15374173f, -0.27064186f, -0.23678020f, -0.02277094f, 0.05098799f, 0.02158282f, -0.03957717f, 
    0.17184351f, -0.16106284f, -0.54951280f, -0.07850236f, -0.09301958f, 0.05541804f, -0.05622849f, 0.10460368f, 
    0.04844099f, 0.03080757f, -0.18490876f, -0.27190453f, 0.18098946f, 0.00270114f, -0.00390048f, 0.05723199f, 
    0.07017472f, 0.15116639f, 0.10319121f, 0.15407462f, 0.11795562f, 0.07952686f, -0.24779975f, 0.02686522f, 
    0.31107357f, 0.19333506f, 0.29035535f, 0.02781632f, -0.20478415f, 0.14953142f, -0.06517875f, 0.01853478f, 
    -0.02802632f, 0.10600756f, -0.34463462f, -0.11874690f, -0.30249402f, -0.01591575f, -0.63726658f, -0.02844158f, 
    -0.02213038f, 0.11797480f, -0.04972949f, 0.02383866f, -0.11088220f, -0.17410952f, 0.14235932f, 0.21253176f, 
    0.26955649f, 0.15403418f, 0.28444085f, 0.45489258f, 0.04274946f, -0.00578677f, 0.08694647f, 0.00503540f, 
    0.02029331f, 0.07130326f, 0.22330551f, 0.07828435f, -0.14523004f, 0.19583042f, -0.15621978f, -0.30922741f, 
    -0.46852598f, -0.43515199f, -0.11422253f, -0.08374935f, -0.22235033f, -0.21149348f, -0.11541454f, 0.12679836f, 
    -0.05404328f, -0.00978978f, -0.01243879f, -0.03767749f, -0.04800505f, -0.02507215f, -0.04359322f, -0.02560857f, 
    0.05355416f, -0.04345850f, -0.06466459f, -0.05755434f, -0.02667027f, 0.02450483f, -0.00161163f, 0.02128601f, 
    0.03195265f, -0.02247525f, 0.01319050f, -0.03901588f, 0.00866303f, 0.03516522f, 0.04294230f, -0.05977185f, 
    -0.01146713f, -0.04788695f, 0.03638898f, 0.03503620f, 0.02026818f, -0.00228911f, -0.01609650f, -0.06701870f, 
    -0.06163406f, 0.04853236f, 0.03401742f, 0.04821176f, -0.04814883f, -0.04818820f, -0.05609280f, 0.03166235f, 
    0.01995633f, 0.02133918f, -0.01062576f, -0.04935667f, 0.01450463f, -0.01356656f, -0.03502949f, -0.05189007f, 
    -0.05208748f, -0.01818255f, 0.03453202f, 0.04681344f, 0.02560716f, -0.04829305f, 0.02387672f, 0.03095919f, 
    0.01526815f, -0.00519213f, -0.04112472f, 0.05700480f, -0.01675126f, -0.02584605f, -0.00672452f, -0.03222822f, 
    0.02773436f, -0.01326301f, 0.01336006f, -0.02666100f, 0.00648064f, -0.03476549f, 0.04199675f, -0.04394369f, 
    -0.02731233f, 0.01741094f, -0.01475467f, -0.00478234f, 0.01732406f, 0.00597354f, 0.02223645f, -0.01902583f, 
    0.03582445f, -0.02692525f, 0.00090751f, 0.01305853f, 0.03006009f, -0.04630477f, -0.06398199f, 0.04812444f, 
    -0.02857382f, 0.03712508f, -0.03370697f, 0.00479642f, -0.03009262f, -0.05866607f, 0.00609014f, 0.03371867f, 
    -0.03324343f, -0.04254963f, 0.02209228f, 0.00107238f, -0.06390675f, 0.01473226f, -0.00733267f, 0.04049514f, 
    0.05098145f, -0.03773802f, -0.02160294f, 0.03143053f, 0.01602759f, -0.01881352f, -0.04455959f, -0.00475460f, 
    0.01140222f, -0.00390122f, 0.01336093f, 0.01996372f, -0.00197029f, 0.00247716f, 0.04428466f, 0.00402042f, 
    -0.05444211f, 0.01470887f, -0.02918478f, -0.00024886f, -0.02616153f, -0.04241868f, -0.02291879f, 0.02811248f, 
    -0.00036112f, 0.00892408f, -0.04917057f, 0.05043161f, -0.02206485f, 0.04420412f, -0.04113967f, 0.03381856f, 
    -0.04702596f, -0.05503955f, 0.04612342f, -0.06164373f, 0.02648013f, 0.01310502f, -0.01906416f, 0.01391468f, 
    -0.04606465f, 0.04236718f, 0.03921104f, 0.00152726f, 0.01181847f, 0.02532004f, -0.03887315f, -0.05037078f, 
    0.02521445f, -0.01934238f, -0.02048016f, 0.03393927f, -0.04250634f, -0.05875646f, 0.01473091f, 0.03395703f, 
    0.03053491f, 0.01009991f, 0.04238582f, 0.02304924f, -0.00698532f, -0.03738154f, -0.02250697f, -0.02739280f, 
    0.03541827f, -0.02676222f, 0.03460440f, 0.02038263f, -0.02500156f, 0.05343451f, -0.01932012f, 0.04310254f, 
    -0.04521658f, -0.01700807f, -0.04116562f, -0.02640964f, -0.04912879f, -0.05253702f, -0.04764684f, -0.00304270f, 
    0.04359643f, -0.01527121f, 0.02309132f, -0.00615681f, -0.04004783f, -0.00549147f, -0.03797387f, 0.01985554f, 
    0.02826869f, 0.01876427f, 0.04199766f, -0.04229393f, -0.04425595f, 0.03087831f, -0.06425582f, -0.02556135f, 
    0.04172105f, -0.00053681f, 0.00518248f, 0.00230460f, 0.00847281f, -0.01015945f, 0.00026212f, -0.03550705f, 
    -0.01494009f, -0.05495064f, -0.07082389f, 0.03264369f, 0.04867028f, 0.00788774f, -0.00550873f, -0.03487187f, 
    -0.00769057f, -0.02806442f, -0.00884129f, 0.04897499f, -0.01169112f, -0.00550115f, 0.00319493f, -0.03354245f, 
    0.01213151f, -0.06226790f, 0.04068574f, -0.06436931f, -0.04759140f, 0.04089640f, -0.04130225f, 0.03234358f, 
    -0.06089166f, -0.06150106f, -0.01335341f, 0.04938842f, -0.00426085f, -0.04914649f, -0.02679251f, -0.01998287f, 
    0.02564930f, -0.03327809f, -0.03433333f, -0.03270545f, -0.04068845f, -0.00642109f, -0.02775011f, 0.02570382f, 
    0.04557723f, -0.04393393f, -0.00081155f, 0.03123676f, 0.04187755f, -0.01259214f, 0.03328492f, 0.01193883f, 
    0.02011727f, -0.04320787f, -0.05107478f, -0.06931701f, -0.06179135f, 0.00070216f, -0.03347208f, -0.04456408f, 
    -0.00735022f, 0.04461716f, -0.01200884f, -0.00171023f, -0.05743216f, 0.04545814f, -0.03705683f, -0.03471615f, 
    0.04371565f, -0.05569836f, 0.02119596f, -0.00742762f, 0.01599084f, -0.04389209f, 0.00587781f, -0.00231906f, 
    0.03267706f, 0.00196482f, -0.01694013f, 0.02492746f, -0.06010096f, 0.03925914f, -0.05392813f, 0.03082658f, 
    0.22701596f, -0.03283494f, -0.34550256f, 0.14772710f, 0.01646418f, -0.09407349f, 0.05565759f, 0.04987409f, 
    -0.03183524f, 0.14422701f, 0.03061790f, -0.00719393f, -0.22185709f, 0.01664368f, -0.01602994f, 0.10873901f, 
    -0.08322090f, 0.33120513f, 0.01766780f, 0.15180203f, 0.08126103f, -0.08754789f, -0.09384044f, -0.10991297f, 
    0.13711846f, -0.03654450f, 0.09776875f, -0.13628416f, -0.45213717f, -0.16774772f, -0.08493678f, 0.12004884f, 
    0.18179014f, 0.08743205f, 0.05662977f, 0.25245878f, -0.25587294f, -0.01626494f, -0.10552106f, -0.03419773f, 
    0.03674450f, 0.11366250f, 0.12176870f, 0.01503410f, 0.00286233f, -0.09483921f, -0.04284550f, 0.10804124f, 
    -0.06950682f, -0.00519696f, 0.02538783f, 0.04961354f, 0.07387366f, 0.14193258f, -0.43941197f, 0.01336486f, 
    -0.35673779f, -0.29544073f, -0.27904379f, 0.11891734f, 0.12268391f, 0.27125403f, 0.09552681f, -0.11451624f, 
    -0.12513921f, -0.16972330f, -0.01683812f, -0.09148416f, -0.04652773f, -0.02731648f, 0.02790627f, -0.04049844f, 
    -0.55362254f, 0.16554165f, 0.26256037f, -0.24588428f, -0.21076727f, -0.04971472f, 0.14284830f, 0.09878080f, 
    0.10810454f, -0.39836946f, -0.43044376f, 0.07322561f, -0.22916804f, -0.27850801f, -0.10534188f, 0.17058262f, 
    -0.07337622f, -0.01690539f, -0.22259875f, -0.07145055f, -0.10220769f, -0.06570099f, -0.03195998f, -0.02033688f, 
    -0.02080874f, 0.04473548f, 0.14228967f, -0.03382419f, 0.31789461f, 0.17940363f, -0.33985326f, -0.00496916f, 
    -0.05947269f, 0.10444760f, 0.15630156f, 0.06072549f, -0.77908641f, 0.11943414f, 0.21170579f, -0.16103433f, 
    0.18652143f, 0.06145413f, 0.13330553f, 0.00031173f, -0.06607042f, -0.22113790f, -0.14515327f, -0.25622559f, 
    0.13291383f, 0.29797235f, -0.08074309f, 0.15549980f, 0.02384020f, -0.03433126f, -0.20444103f, -0.29933292f, 
    -0.17172189f, 0.08846017f, -0.15077877f, 0.02058527f, 0.06197930f, -0.00412942f, 0.16528302f, 0.15237343f, 
    0.32112756f, 0.10249323f, -0.09255022f, 0.21488661f, -0.00330145f, 0.11265704f, 0.09449436f, 0.12060764f, 
    -0.00185869f, -0.02898760f, 0.04560359f, 0.15043791f, -0.07658748f, 0.17512512f, -0.01823458f, 0.03423390f, 
    0.08528963f, -0.06071885f, -0.33617043f, -0.25194696f, -0.19385625f, -0.13144501f, 0.09326756f, -0.01831269f, 
    -0.14223298f, -0.06885008f, 0.19084474f, 0.12940261f, -0.07087152f, 0.07334872f, 0.03709798f, 0.00756040f, 
    0.04968435f, 0.02142477f, 0.32145718f, 0.33886898f, -0.57097626f, -0.48191053f, -0.05498981f, 0.15920210f, 
    -0.01207444f, 0.16264200f, 0.05434749f, -0.06375308f, -0.30277082f, 0.17986166f, 0.13156496f, -0.03938815f, 
    -0.21348061f, -0.04990330f, -0.09663290f, 0.12619607f, 0.24991587f, 0.33302489f, 0.05124486f, -0.02525136f, 
    0.04803346f, 0.04430658f, -0.03579000f, 0.24824560f, 0.05838909f, -0.02735154f, 0.12957534f, 0.15344483f, 
    -0.01068777f, -0.10752860f, -0.08814589f, -0.12873688f, 0.04992238f, 0.03843091f, 0.08312329f, -0.22929372f, 
    -0.18136798f, 0.13867837f, -0.01215937f, -0.07924739f, 0.03409932f, 0.20779349f, -0.01829173f, 0.14106189f, 
    -0.25597534f, -0.55813962f, -0.09131044f, 0.23618242f, -0.09784231f, -0.08167131f, 0.17344512f, -0.04889476f, 
    0.14309469f, -0.06111088f, 0.00121011f, 0.14041927f, 0.06762802f, 0.06807224f, -0.11434951f, -0.00531880f, 
    0.03600922f, 0.12291775f, 0.71199840f, 0.09950800f, -0.48831642f, 0.13697086f, 0.03842876f, -0.14505672f, 
    0.15991871f, 0.01406004f, 0.13434671f, -0.52022249f, -0.79175735f, -0.09733009f, 0.01368211f, -0.06270023f, 
    0.08769774f, 0.01202715f, 0.09745589f, 0.05304256f, 0.29737157f, -0.97196406f, -0.34525457f, 0.01483259f, 
    -0.11602601f, 0.00490597f, 0.21844068f, -0.17366906f, 0.00111721f, -0.33299428f, 0.13235654f, -0.43707070f, 
    0.00955140f, -0.16786849f, 0.10340869f, 0.37994638f, 0.09709030f, 0.18515991f, 0.14266287f, 0.20818827f, 
    -0.14168657f, 0.22905847f, 0.13775943f, 0.18851075f, -0.01445281f, 0.19699767f, 0.04206063f, 0.01514543f, 
    -0.07198339f, -0.20652594f, -0.07452880f, -0.10810142f, -0.09633520f, 0.10198735f, 0.02828563f, 0.16978708f, 
    -0.28744233f, -0.07020297f, -0.05391593f, 0.15666515f, 0.14200643f, -0.17103766f, -0.03587281f, -0.03228061f, 
    -0.04520999f, -0.08343495f, -0.15282509f, 0.27542776f, 0.11810485f, -0.06142263f, 0.15197341f, 0.17979395f, 
    0.18800998f, 0.24710375f, -0.02752094f, 0.06404783f, 0.04369203f, -0.10792328f, 0.11850258f, 0.01367493f, 
    -0.03652714f, 0.00020687f, -0.05457221f, -0.34678477f, 0.07010181f, -0.34520805f, 0.08296825f, -0.14258099f, 
    0.13851449f, -0.17880209f, 0.06079746f, -0.05069878f, 0.03963137f, 0.12316575f, -0.05409474f, 0.01242390f, 
    -0.00679350f, -0.02233773f, 0.19746029f, 0.02398694f, -0.08091994f, -0.32859379f, -0.06284816f, 0.11627628f, 
    -0.00261063f, -0.23456818f, 0.18501908f, 0.14374131f, 0.06467489f, 0.30261469f, 0.04580887f, 0.02240561f, 
    -0.25369421f, -0.15398221f, -0.07886051f, 0.19846410f, 0.14345594f, 0.16717371f, 0.07868176f, -0.17225882f, 
    0.17532925f, -0.02117362f, -0.05700951f, 0.05696516f, -0.00200293f, 0.06342545f, 0.13644014f, 0.01914944f, 
    0.01156607f, 0.16780221f, -0.19619544f, 0.08082120f, 0.00807897f, -0.07719570f, 0.23993935f, -0.11577732f, 
    -0.11986662f, -0.12668496f, -0.27063280f, -0.13078992f, -0.00716945f, -0.14235787f, -0.05819888f, -0.04099251f, 
    -0.05372385f, -0.09610131f, -0.04462099f, 0.07741522f, -0.05748156f, -0.04971168f, -0.07614493f, -0.01643601f, 
    -0.02246182f, 0.08474614f, -0.03531586f, 0.13085513f, -0.34980291f, 0.17531492f, -0.05393111f, 0.01613105f, 
    0.09192682f, 0.04331058f, 0.16063486f, 0.10506847f, -0.19521992f, -0.65804231f, 0.03746692f, 0.04446862f, 
    0.12664919f, -0.20559449f, -0.12306818f, 0.03293195f, -0.07099777f, 0.10235154f, -0.33978447f, -0.44914654f, 
    0.04452015f, 0.05230872f, 0.09233380f, -0.04716704f, -0.06766023f, 0.02527209f, -0.05597460f, -0.01897332f, 
    0.06805251f, 0.10608477f, 0.19920689f, 0.18787475f, -0.07316159f, -0.00240614f, -0.00492456f, 0.16765754f, 
    -0.33478737f, 0.39199930f, 0.04478902f, 0.06276875f, 0.00344002f, -0.04937708f, -0.00700270f, 0.05727111f, 
    -0.01911915f, 0.12018377f, 0.09660774f, -0.09712152f, 0.06092312f, -0.07221633f, 0.19266388f, 0.13342328f, 
    -0.00088979f, -0.09749544f, -0.03563787f, -0.19400130f, -0.02917679f, 0.06885108f, 0.13894956f, 0.04822958f, 
    0.13428921f, -0.16540459f, 0.05081408f, 0.02117431f, 0.22369364f, -0.05300327f, -0.05278722f, -0.06186799f, 
    0.28388494f, 0.12569050f, 0.09234171f, -0.02511864f, -0.26593098f, 0.06149621f, 0.01737156f, -0.29385924f, 
    0.05915892f, 0.07425570f, -0.18247953f, 0.04959843f, 0.01777705f, 0.04379161f, -0.09986269f, -0.17988390f, 
    -0.18149659f, -0.04520099f, 0.11086265f, -0.19926506f, 0.03059036f, -0.24735816f, 0.08807961f, 0.05674619f, 
    0.02244232f, 0.01591047f, 0.14777927f, 0.06247047f, 0.19850360f, -0.10265135f, -0.06718555f, -0.04358510f, 
    -0.02083549f, 0.04371344f, 0.18906136f, -0.09360444f, 0.01504645f, -0.00144054f, -0.03366007f, -0.02378159f, 
    -0.09548354f, -0.02572266f, 0.01589381f, 0.09362212f, -0.11290973f, 0.12017927f, 0.20929316f, 0.02804214f, 
    -0.08564628f, -0.04438351f, -0.04249318f, -0.19712332f, 0.04614339f, 0.09907752f, 0.20761700f, 0.08227858f, 
    0.17874566f, -0.22193672f, -0.28988281f, 0.18796414f, 0.01606526f, 0.14874966f, -0.27661347f, 0.01365835f, 
    -0.13692358f, 0.00429546f, -0.02729286f, 0.14353269f, 0.33592078f, 0.26998207f, -0.05103179f, 0.33764681f, 
    0.00969407f, 0.05582894f, -0.01236881f, 0.17161116f, -0.08018194f, 0.25697729f, 0.17609078f, 0.03160283f, 
    -0.06921136f, 0.34829876f, 0.01208963f, -0.07793155f, -0.17757595f, -0.29433545f, -0.23592758f, -0.10212386f, 
    0.03325447f, 0.06134211f, -0.15473047f, -0.16302522f, -0.07556305f, 0.19319591f, -0.17071317f, -0.12730379f, 
    0.10795353f, 0.23088403f, 0.09651381f, -0.07262378f, 0.14927290f, -0.14242332f, 0.15539396f, -0.10696454f, 
    0.04999276f, 0.00367558f, -0.01895104f, 0.12748332f, 0.02062356f, -0.14064687f, -0.11707829f, 0.07962201f, 
    -0.11853243f, 0.15307704f, -0.09512264f, 0.18961087f, 0.10971921f, 0.23826034f, 0.33221710f, 0.27812809f, 
    -0.00409637f, -0.06318159f, 0.03709232f, -0.00897218f, -0.03277411f, 0.00108264f, 0.03949742f, -0.01488697f, 
    0.00440092f, 0.01538896f, 0.04156692f, -0.04614137f, -0.01388065f, -0.00605619f, -0.00439842f, 0.05333556f, 
    -0.03527274f, 0.03812137f, -0.00728348f, 0.01628865f, -0.06413710f, -0.00077434f, 0.03992977f, -0.03615168f, 
    -0.01847590f, -0.02759307f, 0.02190789f, -0.05809140f, 0.03653463f, 0.05283227f, 0.00087207f, -0.05665950f, 
    0.02892575f, -0.02364061f, 0.04149575f, -0.04685902f, -0.00472803f, -0.03114203f, -0.05123435f, 0.05052475f, 
    0.03711747f, -0.01858079f, -0.03494681f, -0.05696727f, -0.02190972f, -0.00788310f, -0.06113481f, -0.01286501f, 
    0.04085109f, 0.04276097f, 0.02067526f, -0.02154200f, 0.00759220f, 0.05060410f, -0.04754658f, -0.04289484f, 
    -0.06238085f, -0.02257168f, 0.04302408f, -0.01431378f, 0.01894559f, -0.01118006f, -0.01411046f, -0.04191034f, 
    -0.03088973f, 0.02721894f, 0.04528125f, -0.00085394f, -0.01166592f, -0.05718757f, 0.00538993f, 0.05207964f, 
    -0.03962909f, -0.04876038f, 0.02340769f, 0.00937961f, -0.04533293f, -0.01841938f, 0.00602705f, 0.05051484f, 
    0.03392991f, 0.01521449f, -0.05787659f, -0.03878478f, 0.03531512f, 0.04070799f, -0.03359916f, -0.04697683f, 
    0.01729879f, -0.05542134f, -0.05840651f, 0.02717950f, -0.02238349f, 0.05332678f, -0.01281091f, -0.04108346f, 
    -0.00906232f, 0.04080320f, 0.00159240f, 0.01309698f, 0.02726196f, -0.00857993f, -0.06056863f, -0.02271713f, 
    0.03746551f, -0.00594398f, -0.03304020f, -0.02037732f, -0.05989875f, -0.05361189f, -0.00824975f, 0.04016075f, 
    -0.00714205f, -0.05203798f, 0.01000345f, 0.00036952f, -0.04181998f, -0.04840086f, -0.01160538f, -0.04359540f, 
    -0.02041145f, -0.06287906f, -0.02281708f, -0.04973004f, -0.01645361f, 0.03226415f, -0.00742486f, -0.01322240f, 
    -0.02307873f, -0.05662599f, 0.00032632f, 0.05185274f, 0.02439431f, 0.00634017f, 0.03445948f, -0.06233998f, 
    -0.02617463f, 0.01294159f, 0.03520950f, 0.00684383f, -0.06304805f, -0.06226720f, -0.04959497f, 0.02171514f, 
    0.04261966f, -0.05034600f, 0.04163129f, -0.03020413f, 0.03890611f, -0.01962785f, -0.00109496f, -0.01094574f, 
    -0.01581368f, -0.03581455f, 0.01119709f, -0.03851699f, 0.01346600f, -0.03623927f, 0.01551566f, 0.03222112f, 
    -0.04131740f, -0.01842717f, -0.03937398f, 0.03004602f, -0.01432179f, 0.04196718f, -0.05930042f, 0.05016918f, 
    -0.03219753f, -0.00320498f, -0.02270141f, -0.02621705f, -0.06340874f, 0.00200046f, -0.03552303f, 0.03412486f, 
    0.03633933f, -0.00809777f, 0.03869972f, -0.00087966f, -0.05204561f, -0.02635633f, 0.01634672f, -0.01963625f, 
    -0.04678190f, -0.04931742f, 0.04404283f, -0.04419277f, -0.02182380f, 0.00247159f, -0.03526591f, 0.04881228f, 
    -0.02848563f, -0.06332546f, 0.02363089f, 0.01516114f, -0.05363955f, -0.03619587f, -0.00031032f, 0.01606042f, 
    -0.02633514f, 0.02945773f, -0.02872694f, -0.01178584f, -0.01889748f, 0.03724421f, -0.01519510f, -0.00571819f, 
    -0.00034817f, 0.04221465f, 0.03598944f, -0.00076560f, 0.01160319f, -0.05895067f, -0.04370246f, -0.00312984f, 
    0.02789470f, 0.00750792f, -0.06047553f, 0.03230506f, 0.03332583f, -0.02257000f, -0.01578095f, 0.00799290f, 
    -0.00448640f, 0.03161444f, -0.04875939f, -0.02338168f, 0.05109837f, -0.03391474f, 0.01179693f, -0.01484717f, 
    -0.03843995f, -0.05264148f, -0.00240314f, -0.04412755f, 0.04070365f, -0.02917259f, 0.04769301f, -0.03409121f, 
    0.00489795f, -0.04005318f, -0.05525702f, 0.04788360f, 0.03083724f, 0.02710029f, -0.03775403f, -0.03330078f, 
    -0.04782616f, 0.03902236f, -0.04684129f, -0.01909325f, 0.05301007f, -0.04564969f, -0.02296634f, -0.02687920f, 
    -0.03426035f, 0.02118937f, -0.05611920f, -0.02668170f, -0.06023195f, -0.00236698f, -0.01662415f, -0.04853375f, 
    -0.00741340f, -0.02830113f, -0.04621059f, 0.00813639f, -0.04820177f, 0.03125259f, -0.05278501f, -0.03404640f, 
    -0.01176467f, -0.04918380f, -0.05293734f, 0.03522012f, -0.02721210f, 0.00815740f, 0.05024237f, -0.03283301f, 
    -0.04607875f, 0.00084842f, 0.01917844f, -0.02814774f, -0.03625138f, 0.01135512f, 0.05034641f, -0.02857379f, 
    0.16309734f, 0.19545324f, -0.10588787f, -0.02868404f, -0.11786858f, 0.00745758f, -0.43483606f, -0.60259044f, 
    -0.07856579f, 0.09403775f, 0.26503879f, 0.05037743f, 0.00810940f, 0.06975044f, -0.03507726f, -0.01577463f, 
    0.11290052f, 0.08263821f, 0.07216636f, 0.01773937f, 0.19913825f, 0.03923614f, 0.04641272f, -0.04432929f, 
    -0.14256509f, 0.11706392f, 0.13725936f, -0.27307144f, 0.11610398f, -0.04974074f, -0.03359798f, 0.16030291f, 
    0.03648273f, 0.15164772f, -0.18299158f, -0.08510265f, -0.02587558f, -0.04670881f, 0.08502737f, -0.00393713f, 
    0.08778542f, 0.13357070f, -0.09328105f, 0.01248170f, -0.20919918f, 0.11636010f, 0.10369154f, -0.30056161f, 
    0.23061483f, 0.04450172f, -0.19642514f, -0.11586635f, 0.00774356f, 0.01752339f, 0.13404907f, -0.20700416f, 
    0.00176699f, 0.00739034f, 0.19081026f, -0.23679012f, 0.02190831f, 0.21930920f, 0.13221650f, 0.06345174f, 
    0.13405941f, 0.47451964f, -0.06878191f, -0.04395227f, 0.07970857f, -0.16288695f, -0.03773749f, 0.03590925f, 
    -0.02224761f, -0.12869972f, 0.12293954f, -0.34408244f, 0.17382152f, 0.18678039f, 0.07276239f, -0.16128862f, 
    0.11017511f, 0.46834415f, -0.10791308f, -0.05591251f, 0.01033187f, 0.27598798f, 0.09241793f, 0.23133041f, 
    0.11909205f, 0.09042457f, 0.22634715f, -0.07429352f, -0.04116720f, 0.00907865f, 0.11068318f, 0.08353120f, 
    0.17192061f, 0.02562045f, 0.05794309f, 0.08248489f, 0.02981621f, 0.28644124f, 0.06996990f, 0.02483549f, 
    -0.32046959f, 0.14407204f, 0.21268964f, 0.25703871f, 0.15621203f, 0.01234534f, -0.04797916f, -0.08562670f, 
    0.13505866f, 0.13952182f, 0.37753394f, -0.17375900f, -0.25719452f, 0.14419404f, 0.21823210f, -0.12064119f, 
    -0.05291637f, 0.01816126f, 0.04034896f, -0.05827572f, 0.13854714f, 0.11300998f, -0.06196611f, -0.15188374f, 
    0.12937848f, -0.05119660f, -0.13191356f, -0.05182329f, -0.07143293f, -0.27086577f, -0.03261746f, 0.23909415f, 
    0.06548704f, 0.33583546f, 0.18755227f, 0.01937447f, -0.15083724f, 0.09375150f, 0.08303253f, -0.02297969f, 
    -0.06222849f, 0.04811010f, 0.10283699f, 0.04590014f, -0.00783814f, 0.03105800f, -0.14051659f, -0.27589849f, 
    -0.20007105f, 0.00767234f, -0.02625725f, 0.01621133f, 0.17429850f, -0.06359838f, -0.01204624f, -0.31898347f, 
    -0.29345635f, 0.03525036f, -0.04768163f, -0.01225410f, 0.14452536f, 0.06625736f, -0.13683771f, -0.02857367f, 
    0.16627030f, -0.20531163f, 0.04486240f, -0.23808150f, 0.17378543f, -0.30575919f, -0.16794674f, -0.10079599f, 
    -0.18451753f, -0.02963413f, -0.03452128f, -0.01775368f, 0.08504307f, -0.09578700f, -0.13683826f, 0.14397322f, 
    0.09468434f, 0.10341348f, -0.02747839f, 0.01277074f, -0.01843543f, -0.16773202f, 0.14753854f, 0.17572244f, 
    0.13471839f, 0.15046148f, 0.03675546f, 0.09020283f, -0.01497338f, 0.24551049f, 0.02708273f, 0.19401844f, 
    -0.01106068f, -0.08641554f, 0.03900605f, -0.06158764f, -0.04064481f, -0.60798323f, -0.08035032f, 0.05441001f, 
    -0.11004236f, 0.05747873f, 0.09954775f, 0.00744592f, 0.11100906f, -0.60467541f, -0.40823528f, -0.23585433f, 
    0.13438572f, -0.04586775f, -0.14194147f, 0.06905841f, 0.06227541f, -0.13235465f, -0.08153955f, -0.02227111f, 
    0.01162091f, 0.12470113f, -0.05219969f, -0.06330314f, 0.06471449f, 0.01842210f, 0.07196316f, -0.22138916f, 
    -0.31120893f, -0.16987324f, -0.06868865f, 0.13842835f, -0.14449696f, -0.06298542f, 0.09009869f, 0.07753719f, 
    0.18487744f, 0.16295584f, 0.07696244f, -0.13991690f, -0.34614512f, 0.18308190f, 0.10985374f, 0.08135716f, 
    0.27638021f, 0.18687247f, 0.11747637f, -0.16393575f, -0.13130830f, 0.49598423f, -0.27773699f, 0.00247389f, 
    0.13089111f, -0.18137467f, 0.10046281f, 0.23587854f, 0.02613560f, -0.43928328f, 0.10437084f, -0.08721580f, 
    -0.02535951f, 0.24348101f, 0.18624088f, 0.18740259f, -0.00587548f, -0.11520408f, -0.04731296f, 0.16273375f, 
    0.13460591f, 0.00846142f, 0.14913157f, 0.04117852f, 0.06191712f, 0.19032624f, -0.14631803f, 0.05819840f, 
    -0.00231901f, -0.03059922f, 0.37826157f, 0.00888724f, -0.07277127f, -0.05031664f, 0.09469369f, 0.16693027f, 
    0.22522047f, 0.35691276f, 0.17224164f, 0.00702987f, 0.08713779f, -0.17907563f, 0.12950161f, -0.04052162f, 
    -0.39996740f, 0.04625094f, -0.06424160f, 0.00456620f, 0.04525799f, -0.06645200f, 0.38154301f, 0.00714508f, 
    -0.03870909f, -0.00441857f, -0.00309501f, -0.14381674f, -0.58629978f, 0.19673403f, -0.03938489f, 0.12605494f, 
    -0.09574375f, -0.03407239f, 0.16094299f, -0.13332878f, -0.34527907f, -0.61712301f, -0.02639941f, -0.05717758f, 
    -0.09949943f, -0.13700941f, 0.07097975f, -0.03139293f, 0.15196064f, -0.19027884f, -0.00243137f, -0.00346942f, 
    0.04664341f, 0.12688255f, -0.19782117f, -0.05850185f, -0.04208241f, 0.19363667f, 0.44653061f, 0.39781928f, 
    -0.06879584f, 0.12407180f, 0.31394786f, -0.08226179f, 0.02730536f, -0.12073996f, -0.10439952f, -0.01701872f, 
    0.28567880f, -0.08679003f, -0.07269024f, 0.03147958f, -0.06700473f, -0.21579492f, 0.11132572f, 0.50350624f, 
    0.49616686f, -0.33171511f, 0.23505299f, -0.35069874f, 0.03840477f, -0.21818462f, -0.05529436f, 0.22275110f, 
    -0.06107337f, -0.15720429f, 0.20515124f, -0.02655162f, -0.01839173f, -0.00375621f, 0.05365745f, -0.02049999f, 
    0.10884004f, -0.04843924f, 0.04164049f, 0.57044870f, -0.02132303f, 0.00449147f, -0.02689479f, -0.08545576f, 
    -0.18449120f, -0.13069806f, 0.06505191f, -0.19271913f, -0.18246648f, 0.09234244f, -0.19450077f, -0.21762425f, 
    0.02786424f, 0.01677049f, 0.08362392f, 0.15453957f, 0.04538241f, 0.09034050f, 0.02871170f, 0.03105162f, 
    0.12654473f, 0.07386800f, -0.09272522f, 0.07942481f, 0.31276643f, 0.19586527f, 0.46910796f, -0.09946235f, 
    -0.02394821f, -0.06533027f, 0.14554338f, -0.20135470f, -0.09402325f, 0.16920516f, -0.39784956f, -0.13495833f, 
    0.07769256f, 0.06740918f, 0.03813160f, 0.12706740f, 0.06189419f, -0.09387264f, -0.03580070f, -0.07444552f, 
    -0.48686227f, -0.13373838f, 0.02953476f, -0.05965497f, 0.12673049f, 0.14294939f, -0.12249851f, 0.15728422f, 
    0.16535573f, 0.03256056f, -0.09929176f, -0.04867588f, -0.16518895f, 0.04662812f, -0.23797566f, 0.02075870f, 
    0.19275793f, 0.10720945f, -0.10466006f, -0.02770245f, -0.16037256f, -0.14198984f, -0.12769823f, 0.15335158f, 
    0.04253129f, 0.27830911f, -0.09659860f, -0.09301323f, -0.07033838f, 0.06225431f, -0.02163102f, -0.01587968f, 
    0.05014826f, -0.23340434f, -0.56928360f, 0.27548239f, -0.50469136f, -0.15807408f, 0.17034316f, -0.10056485f, 
    0.01694096f, 0.00765373f, 0.13733409f, 0.24849568f, 0.36487943f, 0.29451725f, 0.29663932f, -0.07324883f, 
    -0.20321925f, 0.05345954f, 0.01012339f, 0.02422936f, 0.04513990f, -0.38868877f, 0.02530839f, -0.04489821f, 
    0.09001884f, -0.06097154f, 0.08212020f, -0.10415314f, 0.16578586f, 0.04463776f, 0.11842003f, -1.18475378f, 
    -0.04670634f, -0.16986205f, -0.11979017f, 0.08040492f, 0.30599892f, -0.05811335f, 0.03191240f, 0.15363345f, 
    0.04898098f, 0.19116771f, -0.09624043f, -0.09737565f, -0.01001135f, -0.11385435f, -0.23802401f, -0.15451208f, 
    -0.23951644f, 0.04945042f, -0.03131944f, -0.05638886f, -0.01666677f, -0.05209054f, -0.06186088f, -0.21410713f, 
    0.25629821f, 0.23591620f, 0.23477241f, -0.14133263f, 0.04549056f, -0.05570503f, -0.07328959f, 0.03466157f, 
    -0.11610253f, 0.32216153f, 0.29908645f, 0.20590080f, 0.16393362f, 0.06213658f, -0.19431427f, 0.16369484f, 
    -0.19953574f, -0.13047054f, -0.36828119f, 0.17001158f, -0.51694256f, 0.05767547f, 0.00369578f, -0.24189746f, 
    0.17037420f, -0.04718257f, -0.08534136f, 0.02223000f, 0.38236338f, -0.03120286f, -0.03590401f, -0.12709561f, 
    -0.39324549f, -0.09679820f, 0.00266540f, 0.30880469f, 0.30471250f, 0.22083119f, -0.12063420f, 0.03080829f, 
    0.09338156f, -0.00189152f, 0.06649678f, 0.00341255f, -0.14160849f, 0.33410987f, 0.21636251f, 0.17111173f, 
    -0.20754340f, 0.12135629f, 0.21114466f, -0.08547152f, -0.17340395f, 0.11704362f, -0.14445294f, 0.25360641f, 
    -0.06539594f, 0.13133250f, -0.14088428f, 0.21577665f, -0.17129421f, -0.05701523f, 0.12820785f, 0.09226751f, 
    0.19209491f, 0.09698176f, -0.05723331f, 0.02043686f, 0.05733849f, 0.03731989f, 0.06043151f, 0.02036126f, 
    0.04337977f, 0.36901003f, 0.42989528f, 0.13291372f, -0.02168272f, 0.08209912f, 0.07859556f, -0.04310735f, 
    -0.20359857f, -0.09947973f, -0.04423051f, -0.11163783f, 0.14837614f, -0.17874748f, -0.01994796f, 0.09214762f, 
    0.17395061f, 0.11922166f, -0.07083462f, 0.11836765f, -0.00605731f, -0.16849631f, -0.23740111f, -0.07298419f, 
    0.14794642f, 0.00240412f, -0.04287337f, -0.59174502f, 0.24688829f, -0.40751344f, 0.03857706f, -0.17783496f, 
    0.18464522f, -0.17037627f, 0.03976501f, 0.07540191f, -0.17876720f, 0.05830599f, 0.10510106f, 0.02888303f, 
    0.12763239f, -0.14862269f, 0.01290759f, 0.18679138f, -0.09455439f, -0.02565890f, -0.08404744f, 0.43884772f, 
    -0.01991785f, -0.13082157f, -0.05042514f, 0.19515035f, 0.10438900f, 0.02457381f, -0.11527853f, -0.47527149f, 
    0.44423997f, -0.18140347f, 0.10765175f, -0.24919851f, 0.02479239f, 0.05274266f, 0.01805856f, 0.05161703f, 
    0.44261578f, 0.21146838f, -0.28947645f, 0.04350754f, -0.08194948f, 0.03010917f, 0.09044521f, -0.12152895f, 
    -0.17823823f, 0.15193483f, -0.12654418f, -0.11861219f, -0.08295725f, -0.36651799f, -0.04866777f, -0.02303717f, 
    -0.07951879f, -0.26080942f, 0.35441095f, 0.20420811f, -0.06822564f, 0.08725951f, -0.33211216f, -0.24564023f, 
    0.14247198f, -0.07219962f, -0.31216016f, -0.12142508f, 0.04086165f, 0.06792124f, -0.02067482f, 0.01872571f, 
    0.17232352f, -0.07583690f, 0.02378877f, -0.12661548f, -0.09294651f, 0.34270182f, -0.17265373f, -0.19380601f, 
    -0.28352356f, 0.03727695f, -0.03823783f, 0.00792510f, -0.04298047f, 0.15372263f, 0.56895071f, -0.00723069f, 
    -0.08363574f, -0.09711228f, 0.03811230f, 0.11515230f, 0.16087878f, -0.50845373f, 0.18511012f, 0.26083103f, 
    0.10226966f, -0.03552506f, -0.04808928f, 0.01474105f, -0.04249893f, -0.11514205f, -0.02826230f, 0.29368719f, 
    -0.16113366f, -0.20976670f, 0.33659235f, -0.03886611f, 0.08055007f, 0.05966618f, -0.12652229f, -0.27574772f, 
    -0.14927500f, 0.48956373f, -0.06520439f, -0.10284739f, -0.09635708f, -0.04413273f, 0.04107175f, 0.03470207f, 
    -0.04556138f, 0.19269718f, 0.13145363f, -0.12871638f, -0.08885189f, -0.02355530f, 0.09337597f, -0.01932190f, 
    -0.04560964f, 0.02317040f, 0.18664908f, 0.04262210f, 0.21862543f, -0.00762653f, 0.10150484f, 0.16610172f, 
    0.09217284f, -0.07374857f, -0.24605989f, 0.02677291f, 0.12691702f, -0.21641611f, -0.37024802f, -0.19193575f, 
    0.06959365f, 0.05190118f, 0.14612274f, 0.24546060f, 0.45671621f, 0.75613213f, -0.00913140f, 0.15525550f, 
    0.17614356f, 0.02756591f, -0.14789957f, -0.17250828f, -0.09866472f, 0.05308111f, -0.09430742f, 0.01780700f, 
    0.05993734f, -0.10148167f, -0.07654880f, -0.06447277f, 0.12737615f, -0.49000287f, -0.04186318f, -0.14789468f, 
    0.13912772f, -0.01782028f, 0.09427033f, -0.25437593f, 0.14618188f, -0.01107981f, 0.17028137f, 0.03550553f, 
    0.14508095f, 0.03039331f, 0.09607833f, 0.05972532f, 0.08989986f, 0.05510563f, -0.12502950f, 0.10760906f, 
    -0.08080602f, -0.02066486f, -0.06352222f, -0.02395041f, -0.14355558f, 0.14488228f, -0.04388384f, 0.06183457f, 
    -0.02637534f, 0.14659002f, 0.22004063f, -0.10487737f, 0.00404042f, -0.08183782f, 0.10520771f, -0.01500777f, 
    -0.06702496f, 0.22681348f, -0.12486186f, 0.26061615f, 0.06551901f, 0.02882517f, 0.07324539f, 0.15303479f, 
    -0.12331251f, 0.04383176f, -0.37560147f, -0.22570994f, 0.05397569f, -0.02131380f, -0.09168671f, 0.24095517f, 
    0.09132186f, 0.23820941f, 0.10637180f, 0.44546050f, 0.21060255f, 0.35890922f, 0.22246855f, -0.36397323f, 
    0.07488699f, 0.02430167f, -0.01720788f, -0.08907135f, -0.34677598f, 0.22844063f, -0.28612861f, -0.07547940f, 
    0.18593648f, 0.01644099f, -0.03408583f, 0.17138739f, -0.21008176f, -0.22887382f, -0.31222972f, -0.09185443f, 
    0.05429332f, 0.14711849f, 0.07801221f, -0.02090014f, 0.00545116f, -0.01927596f, -0.46115416f, 0.00128599f, 
    0.17919950f, 0.05070551f, -0.17100529f, -0.16436350f, 0.07805341f, -0.04791463f, -0.14988303f, 0.08474545f, 
    -0.01960846f, 0.28306130f, 0.07930170f, 0.00593468f, -0.09345086f, 0.09649569f, 0.14825308f, -0.00605608f, 
    0.11776976f, -0.06184835f, -0.62939709f, -0.24978571f, 0.05967754f, -0.03513749f, 0.10122427f, -0.03607623f, 
    -0.51456839f, 0.15213689f, 0.38866085f, -0.09101981f, -0.13728701f, -0.02992162f, -0.01302170f, 0.03959646f, 
    -0.12903987f, 0.20526747f, -0.04823094f, 0.04034241f, -0.02301425f, -0.11112126f, -0.02044383f, -0.09951464f, 
    0.12473305f, 0.11787468f, 0.25637650f, 0.17103723f, -0.16612992f, -0.06583818f, 0.02377325f, -0.10405490f, 
    0.12369884f, 0.00623714f, 0.02353829f, -0.10743505f, -0.08061510f, -0.05035475f, -0.03469928f, 0.03292480f, 
    -0.32777175f, 0.37558004f, 0.16115449f, -0.03280395f, -0.02586850f, -0.43568936f, 0.29261652f, -0.35136682f, 
    -0.15053755f, -0.10757378f, -0.17276627f, -0.03467336f, -0.20726617f, 0.14715472f, -0.21815291f, -0.30888432f, 
    0.19197886f, -0.08170706f, -0.09260719f, -0.13928714f, -0.05642777f, 0.18829376f, 0.13700067f, -0.18763460f, 
    -0.01878356f, -0.10728490f, -0.04857776f, 0.16233975f, -0.20186169f, 0.13242723f, 0.00641698f, 0.14266424f, 
    -0.10075230f, -0.21327290f, 0.21716137f, -0.05256866f, 0.02552024f, 0.05404127f, -0.01930685f, 0.09847089f, 
    0.07316221f, -0.45213231f, -0.82862836f, 0.14193591f, 0.08884113f, -0.05696680f, -0.20184042f, 0.19820279f, 
    -0.06758567f, 0.29502222f, 0.03959320f, -0.02608604f, 0.01988216f, 0.02247065f, 0.06405478f, -0.00659794f, 
    -0.00696895f, -0.16664001f, 0.12734209f, -0.24711399f, 0.12948690f, 0.59019566f, 0.04501900f, 0.10317173f, 
    0.12844718f, 0.07036237f, 0.09695576f, 0.22275256f, -1.02429068f, -0.35400438f, 0.53350759f, -0.03611645f, 
    0.07152007f, -0.03875807f, 0.02220081f, -0.08644306f, -0.00690530f, 0.20042360f, 0.00226927f, 0.21619983f, 
    0.11779220f, 0.13036098f, -0.05850656f, 0.09475560f, -0.15708792f, -0.04608304f, 0.25582179f, -0.31820256f, 
    0.11212295f, 0.14805545f, 0.09500921f, -0.28562099f, 0.08408557f, -0.05985437f, 0.10013271f, -0.44224381f, 
    0.68291610f, 0.58743918f, -0.11844307f, 0.22390595f, 0.13672294f, 0.05306757f, 0.03252319f, 0.06923709f, 
    -0.01613105f, -0.04496010f, -0.07358300f, -0.12317407f, -0.12299141f, 0.07821461f, 0.12567466f, 0.01993045f, 
    0.08124234f, 0.18703276f, -0.15487458f, -0.01096319f, 0.04702245f, -0.18005456f, -0.06148017f, -0.12084813f, 
    -0.19099653f, -0.08675811f, 0.02226798f, 0.10119862f, 0.05138441f, 0.21504685f, 0.08466662f, 0.14577852f, 
    0.12983777f, 0.02799493f, 0.21259563f, -0.63438261f, -0.54230773f, -0.51558650f, -0.05631414f, -0.06837971f, 
    -0.12085500f, 0.09020700f, -0.01733680f, -0.14502215f, 0.09275812f, -0.01141555f, 0.04518435f, -0.25680327f, 
    -0.00869524f, -0.01558274f, 0.08604258f, 0.15963373f, 0.20283347f, 0.18311106f, 0.03330313f, 0.11905785f, 
    0.21594900f, 0.07422524f, 0.06260473f, 0.12991334f, 0.16633072f, 0.17452209f, 0.04831789f, -0.07532568f, 
    -0.03795581f, -0.26836532f, 0.06914069f, 0.04634235f, 0.09760825f, 0.08876797f, -0.18496893f, -0.07324272f, 
    -0.00668409f, 0.02658027f, -0.03495897f, -0.05049459f, 0.03548612f, -0.01355428f, 0.07511020f, 0.01060026f, 
    -0.60929835f, -0.35442311f, -0.19493409f, -0.00451256f, 0.05724147f, -0.14831939f, 0.09285115f, -0.03640989f, 
    0.15721194f, -0.61179680f, 0.11337057f, 0.14381480f, -0.20379287f, 0.03760713f, -0.04940525f, 0.00687455f, 
    0.02806893f, -0.12629226f, 0.16426659f, 0.44077364f, -0.08560756f, 0.16536221f, 0.07536656f, 0.20984562f, 
    -0.00859092f, 0.28534731f, -0.10289790f, -0.41283998f, -0.43828556f, 0.17551714f, -0.04623038f, 0.08231649f, 
    -0.09353168f, 0.29697612f, -0.25616834f, 0.01919921f, -0.21222489f, -0.53168917f, -0.40945107f, -0.29862738f, 
    0.14095549f, 0.04836264f, 0.18415208f, -0.12203445f, -0.06814895f, 0.03870432f, -0.34754804f, -0.07667001f, 
    -0.10264117f, -0.12251382f, 0.11213914f, -0.09028789f, 0.03874853f, 0.04836737f, -0.12450214f, 0.07145500f, 
    0.22486226f, -0.10229556f, 0.12332705f, 0.02975162f, 0.09414366f, -0.06702493f, 0.10191154f, -0.14123045f, 
    -0.10879631f, -0.03961609f, -0.13101490f, 0.02895236f, 0.00617290f, 0.00833417f, 0.09866621f, 0.32367569f, 
    0.02595473f, 0.01708210f, -0.01618503f, 0.05536045f, -0.01728022f, 0.03943033f, -0.02948925f, -0.01747146f, 
    -0.04181375f, 0.03420341f, 0.04506753f, -0.02534878f, 0.04403856f, -0.00705352f, -0.03841849f, -0.06209106f, 
    -0.03456429f, -0.03505016f, 0.02763617f, 0.05165138f, -0.03814726f, 0.02789743f, 0.06318077f, -0.01728639f, 
    -0.03212635f, -0.04179608f, 0.03932434f, 0.01937133f, 0.00622547f, -0.05896623f, -0.03869003f, 0.01962505f, 
    0.01168421f, 0.01832202f, 0.02965900f, -0.00085231f, -0.04091843f, 0.00509991f, -0.03377783f, 0.03344456f, 
    -0.04540660f, 0.00887201f, -0.02664406f, -0.02758628f, -0.06493586f, 0.03429984f, -0.02007872f, -0.05106487f, 
    0.01151972f, 0.01575042f, -0.02802166f, -0.00214622f, 0.00283416f, -0.04375242f, -0.07476100f, 0.03132263f, 
    0.05347170f, -0.07113027f, 0.05005811f, 0.01227637f, -0.00332174f, 0.01071065f, -0.03183237f, 0.01455487f, 
    -0.05058075f, 0.03217287f, 0.06289069f, 0.06779324f, 0.03377970f, -0.03288125f, -0.05429876f, -0.02950246f, 
    -0.01039190f, -0.06705657f, -0.01043717f, -0.02681975f, 0.00511985f, 0.04248943f, -0.02429660f, 0.01892303f, 
    0.04418353f, -0.04000629f, 0.05483204f, 0.03147211f, 0.04674752f, 0.03482156f, 0.01468276f, 0.02379655f, 
    0.01786296f, -0.06307085f, 0.00744793f, -0.01459169f, 0.00980472f, 0.03521717f, 0.02137507f, 0.01712388f, 
    -0.04227392f, 0.04285101f, 0.00582375f, -0.02348815f, -0.00751664f, -0.03952377f, -0.02346021f, -0.04661888f, 
    -0.04108315f, -0.01423830f, 0.01074481f, -0.02629366f, 0.01785375f, -0.03745326f, -0.05607109f, -0.01334438f, 
    0.03480807f, 0.01514493f, 0.02436467f, 0.01335056f, 0.01140792f, 0.00707037f, -0.05688684f, -0.01661139f, 
    0.00619183f, -0.01565166f, 0.02311008f, -0.05765283f, -0.01959269f, 0.02939135f, -0.06540438f, 0.00046676f, 
    -0.00655074f, 0.01132254f, -0.04140833f, -0.04485042f, -0.03533845f, 0.03059112f, 0.04556622f, 0.03862705f, 
    0.01180784f, -0.01984072f, 0.04170170f, 0.03284281f, -0.03750623f, -0.05923491f, 0.02978106f, -0.02167195f, 
    -0.00892978f, -0.04082836f, -0.05999733f, -0.03652178f, 0.03061866f, -0.05344840f, -0.05343512f, 0.01921644f, 
    0.05036940f, -0.04664912f, 0.02265322f, -0.04059021f, -0.04758466f, 0.03979570f, -0.00641618f, 0.03563387f, 
    -0.04256687f, 0.01535655f, -0.00431776f, -0.05968824f, -0.04627040f, -0.04716437f, 0.05876970f, 0.01608227f, 
    -0.04318773f, -0.04654947f, 0.02900135f, -0.01183819f, -0.03914452f, 0.04464653f, -0.00800601f, 0.02156951f, 
    0.03886031f, -0.04817192f, -0.01617449f, -0.04498653f, -0.05307696f, -0.03223862f, -0.03559077f, 0.00756806f, 
    0.00977571f, 0.01805151f, 0.03648998f, 0.01298321f, -0.00399122f, -0.02945220f, 0.00926271f, 0.03125979f, 
    -0.00542828f, 0.00964780f, -0.02208897f, 0.03850849f, -0.01859635f, -0.03421160f, 0.04318974f, 0.03501076f, 
    -0.06097646f, 0.01452629f, -0.01061241f, 0.04501259f, 0.02735697f, -0.01423975f, 0.05035824f, 0.02148355f, 
    -0.06545023f, 0.01449040f, -0.06015104f, -0.05753234f, 0.03362639f, 0.00917970f, 0.03711725f, -0.00586694f, 
    -0.01002579f, -0.02961055f, 0.03478389f, -0.04736019f, 0.03358464f, -0.04265581f, -0.02449956f, -0.04290562f, 
    -0.00994620f, -0.06342600f, -0.04995816f, 0.01194783f, 0.03382436f, -0.05375629f, 0.03645026f, -0.05044653f, 
    0.03507868f, -0.03303951f, -0.05603456f, -0.04262684f, -0.00243992f, -0.00671265f, -0.02029946f, -0.02466168f, 
    -0.00218712f, 0.01733853f, 0.04332248f, 0.03911825f, -0.03669709f, -0.04749513f, -0.00859453f, -0.04022329f, 
    -0.05107522f, -0.02943417f, 0.01355400f, 0.00693496f, -0.04298589f, -0.02854872f, -0.00424289f, -0.04056190f, 
    0.03782283f, 0.03170067f, 0.04257208f, 0.03566484f, 0.02207675f, -0.04456767f, 0.01519733f, 0.02900135f, 
    -0.02078121f, -0.06467792f, -0.04969722f, 0.02589278f, -0.01500978f, -0.05472258f, 0.04879501f, -0.03151542f, 
    -0.03687961f, 0.02908455f, -0.06149140f, -0.05065406f, -0.05525991f, -0.04651383f, -0.02888704f, -0.03095284f, 
    -0.00612421f, -0.04240005f, -0.01368691f, 0.01135633f, 0.02250023f, 0.00899827f, 0.05047778f, -0.02747295f, 
    0.05754006f, -0.22497909f, -0.10157188f, 0.22901671f, 0.01300349f, 0.27297023f, 0.09554931f, 0.02111992f, 
    0.13721943f, -0.01183936f, -0.06640106f, -0.27244163f, 0.00883204f, -0.02769759f, -0.10337231f, -0.03858213f, 
    0.08906595f, 0.02955962f, -0.15934710f, -0.04274780f, -0.00840442f, -0.00607415f, 0.13470189f, 0.04615223f, 
    0.02358776f, -0.42190355f, 0.02393638f, 0.09722267f, -0.06116711f, 0.03773651f, 0.17109869f, 0.23781069f, 
    -0.02750987f, 0.16867790f, -0.04324142f, 0.35301033f, 0.03590254f, -0.01843898f, 0.07722300f, 0.11171629f, 
    0.13187608f, 0.10093997f, -0.08893836f, 0.03535690f, -0.08698712f, -0.05306097f, -0.33049846f, -0.39161125f, 
    0.12290546f, 0.00898756f, -0.12336973f, 0.04436338f, 0.07239725f, -0.15248206f, -0.11315717f, -0.04494946f, 
    0.13940226f, -0.16586009f, -0.04806579f, -0.09925933f, -0.14998727f, 0.17131792f, -0.16801435f, -0.12001237f, 
    -0.05394058f, -0.10961978f, 0.03152858f, 0.02412596f, 0.02257183f, -0.10070526f, -0.03020570f, -0.08758967f, 
    0.26145682f, -0.23101237f, -0.09145237f, 0.05039101f, 0.09004492f, 0.06567474f, 0.08190194f, -0.23942798f, 
    0.01743728f, 0.15737677f, 0.25796461f, -0.04785373f, -0.21101387f, 0.10465103f, -0.03928904f, 0.02155481f, 
    0.34749010f, -0.33019152f, -0.03004192f, -0.04277148f, 0.05213411f, -0.01586424f, -0.00043415f, -0.03128253f, 
    0.04072092f, -0.05204918f, 0.09015969f, -0.15768418f, -0.12597124f, -0.17038299f, -0.14757472f, 0.05928823f, 
    -0.21863347f, -0.11855023f, -0.13008463f, 0.08590653f, 0.15612526f, 0.22303306f, -0.02624879f, -0.22770236f, 
    0.22487554f, 0.07971741f, -0.06197470f, -0.01137084f, -0.13962446f, -0.43344700f, -0.12115254f, 0.29948592f, 
    -0.01643137f, 0.06248550f, -0.03274864f, -0.02730950f, 0.24680598f, 0.01749170f, -0.08040812f, -0.11776822f, 
    0.16196771f, -0.10894614f, 0.04036131f, 0.17044413f, -0.02648843f, 0.11062238f, -0.07263711f, 0.01079492f, 
    0.23566876f, -0.11005265f, -0.04395048f, 0.06728120f, 0.10322704f, -0.09582973f, 0.03413132f, 0.11814699f, 
    -0.04641503f, 0.01943628f, -0.08231616f, 0.06759249f, -0.05981656f, -0.12034686f, 0.05221992f, -0.02192914f, 
    0.14285864f, -0.19324964f, -0.10984290f, -0.03657991f, 0.11777013f, -0.02517996f, 0.01888667f, 0.07664179f, 
    0.10821132f, 0.16210921f, 0.09745604f, 0.03156443f, 0.08391492f, 0.15172824f, 0.05579626f, 0.16114627f, 
    0.04251030f, -0.20065081f, 0.18884635f, -0.14080608f, 0.10466494f, -0.11714403f, 0.01496859f, 0.14882462f, 
    -0.02723390f, 0.06066462f, 0.37752005f, -0.03747422f, -0.08429576f, -0.04749014f, -0.04279426f, -0.01252381f, 
    0.06678246f, -0.09832703f, 0.08097504f, -0.18928330f, -0.25190923f, 0.07584278f, 0.17024232f, 0.04694816f, 
    -0.00212569f, 0.12027464f, 0.12398323f, -0.07034117f, 0.07545862f, 0.20772541f, 0.12158292f, -0.17384437f, 
    0.00958083f, 0.16002399f, 0.01378537f, 0.19743969f, 0.07394943f, 0.06456155f, 0.10637320f, -0.00562452f, 
    0.09912943f, -0.02756517f, -0.03286054f, -0.04506408f, 0.10845041f, 0.07044701f, 0.10589486f, 0.15960620f, 
    0.10691611f, -0.08990464f, -0.00955477f, -0.05691620f, -0.07191514f, 0.10957862f, 0.02996063f, 0.03263766f, 
    -0.14799687f, 0.04250422f, -0.00251876f, 0.17309184f, 0.08138028f, -0.03996238f, 0.13935539f, 0.04088654f, 
    0.03760520f, -0.01633890f, -0.05161662f, 0.12225822f, 0.07787900f, 0.18101047f, 0.07146855f, 0.31101206f, 
    0.01287516f, 0.25522393f, 0.40906054f, -0.28704125f, -0.30538067f, 0.16672611f, -0.11644039f, 0.02889775f, 
    -0.11008510f, 0.06354580f, 0.00416801f, -0.19697022f, -0.03736018f, 0.56379604f, -0.01560775f, -0.08423192f, 
    0.04238562f, 0.04878992f, 0.20687003f, 0.13904414f, -0.29654893f, 0.12316366f, 0.06328557f, -0.06750834f, 
    0.08107609f, 0.08944695f, 0.00131219f, 0.01929433f, -0.32431814f, 0.14378221f, -0.10213401f, 0.11523543f, 
    0.12022481f, 0.16227205f, 0.15859966f, 0.15402345f, 0.06238516f, 0.64779836f, -0.07200554f, -0.12443233f, 
    -0.25498229f, -0.04067720f, -0.00478915f, -0.02747020f, -0.09889495f, -0.15409103f, -0.12854254f, 0.19687200f, 
    0.10889105f, 0.05773858f, -0.08695498f, 0.02770762f, -0.11817677f, 0.01450296f, -0.30090356f, 0.01421515f, 
    -0.41396132f, 0.16147646f, 0.25031173f, 0.10690839f, 0.01973030f, 0.16313034f, -0.06454244f, -0.02279488f, 
    -0.07444948f, 0.07323159f, 0.05474290f, -0.15023005f, 0.19184574f, 0.13152982f, 0.16072558f, 0.07424036f, 
    -0.12144045f, -0.01171845f, 0.00568199f, -0.38318101f, -0.26047882f, -0.17450744f, 0.36369666f, -0.11311404f, 
    -0.02449480f, 0.05462956f, 0.07230901f, -0.15228119f, -0.12362952f, 0.07958525f, -0.24545883f, -0.03893839f, 
    0.09308404f, 0.05821135f, 0.11493205f, 0.27179861f, 0.19808935f, 0.22756952f, 0.26147035f, 0.07420818f, 
    0.14143945f, -0.13851540f, -0.10758322f, -0.04850362f, -0.08570462f, 0.04555863f, 0.28534359f, 0.39782882f, 
    -0.05740461f, 0.16242269f, 0.15202214f, 0.02436671f, -0.28615305f, 0.01314303f, 0.19897643f, 0.12041501f, 
    -0.39153185f, -0.12072201f, 0.09909520f, 0.05784097f, 0.06049971f, 0.15106934f, 0.29033011f, 0.02339850f, 
    0.08338752f, -0.18331510f, 0.09185004f, -0.01054386f, 0.08152232f, 0.19538218f, -0.01868765f, 0.12960285f, 
    0.11658009f, 0.33027562f, 0.29933700f, 0.04077239f, -0.10421944f, 0.02400527f, 0.03674079f, 0.19324544f, 
    -0.04512673f, 0.27066931f, -0.41039759f, -0.09633001f, -0.22838479f, 0.13645020f, 0.16679735f, 0.06929974f, 
    -0.03097777f, -0.08981653f, -0.05073095f, 0.09460998f, 0.22025256f, 0.20940703f, 0.24759322f, 0.16885328f, 
    0.21826398f, 0.14172669f, 0.18564416f, -0.04971117f, -0.11610364f, -0.22477958f, 0.03393792f, 0.01463808f, 
    0.14009404f, 0.14136684f, -0.00743098f, -0.10841380f, -0.16826293f, -0.05647232f, -0.42532283f, -0.19788238f, 
    -0.16741590f, -0.32806519f, -0.18330336f, 0.14250368f, 0.12603343f, 0.03054902f, 0.01690220f, -0.50169933f, 
    0.10366233f, -0.19990510f, 0.07119403f, -0.05745874f, 0.11665584f, -0.29200548f, -0.04628239f, -0.10808523f, 
    0.13462368f, -0.00478722f, 0.01454712f, 0.20504095f, 0.15680148f, 0.25911197f, 0.07806256f, -0.12674265f, 
    -0.18147671f, -0.11957761f, -0.14948773f, -0.00238334f, -0.09015889f, -0.13819548f, 0.05281005f, -0.00417535f, 
    -0.15950796f, -0.33870533f, -0.01133910f, -0.31958818f, 0.19674815f, -0.19380322f, -0.27581412f, -0.12862916f, 
    0.19766895f, -0.10297378f, 0.26449937f, -0.12938295f, -0.18647580f, -0.10040423f, -0.02484851f, 0.24048483f, 
    0.01423403f, 0.12384607f, -0.30050114f, 0.04157275f, 0.00028781f, -0.40756848f, -0.02470672f, -0.24611557f, 
    -0.04871920f, 0.08187273f, 0.09000009f, -0.05731001f, 0.30977783f, -0.00523249f, -0.11832046f, -0.00158205f, 
    0.12536828f, 0.12891120f, 0.01576381f, 0.07859294f, -0.04580216f, -0.18392093f, 0.01784830f, -0.09216361f, 
    0.06433491f, 0.18719217f, 0.06021624f, 0.00292359f, 0.14658134f, -0.04153386f, 0.07477072f, 0.09454054f, 
    -0.19361947f, -0.01655952f, 0.01716634f, -0.19229349f, -0.15785517f, -0.22445634f, -0.18656068f, -0.19407181f, 
    -0.26046723f, -0.13836053f, 0.18471739f, 0.00670027f, 0.09253924f, -0.46387848f, -0.06986949f, -0.10655943f, 
    0.06718332f, 0.10683592f, 0.12057099f, 0.09497672f, -0.25263268f, 0.23228392f, -0.22719778f, -0.05266411f, 
    -0.09066744f, -0.13558179f, -0.05865936f, -0.06034113f, 0.01397643f, -0.05257663f, 0.03720133f, -0.17612778f, 
    -0.17370978f, -0.22589065f, 0.15055041f, 0.49055737f, 0.06510990f, -0.06787440f, -0.19502717f, -0.12669480f, 
    0.03510546f, 0.19373617f, -0.07905649f, 0.02709497f, 0.09169231f, -0.36122063f, -0.37653905f, 0.09298605f, 
    0.20766523f, 0.04201600f, -0.00449159f, -0.09815874f, -0.10027654f, -0.00484694f, 0.01592225f, 0.12510654f, 
    -0.19295686f, -0.02640050f, 0.36219513f, -0.01656238f, -0.10715696f, -0.16645290f, -0.33468774f, -0.29549077f, 
    -0.04967945f, 0.04706771f, -0.18220054f, 0.06292595f, -0.00049009f, -0.07457078f, 0.07717630f, -0.23450157f, 
    -0.17691748f, -0.05411442f, 0.16257009f, -0.34745002f, 0.42074671f, 0.05762961f, 0.04101882f, 0.11930071f, 
    0.20520540f, 0.10566307f, 0.12866224f, 0.06039036f, 0.10925365f, 0.04209920f, 0.12684231f, -0.02311240f, 
    0.02547052f, -0.00737023f, 0.03194511f, -0.02456508f, 0.00680586f, -0.00886769f, 0.02028717f, -0.02593928f, 
    0.00790791f, -0.00955676f, 0.01489607f, -0.02888260f, -0.06061441f, -0.02631713f, -0.05243772f, -0.06987916f, 
    0.02283845f, -0.02536258f, -0.02849126f, 0.01513116f, 0.02715868f, 0.03613869f, 0.02910866f, -0.04199941f, 
    0.05010150f, -0.04669434f, 0.02823729f, 0.01261885f, 0.04724479f, -0.04592532f, -0.03140519f, 0.00110955f, 
    -0.03919734f, -0.02884236f, -0.04242578f, -0.01861887f, 0.01131176f, -0.02549807f, -0.01898714f, -0.06664314f, 
    -0.01775387f, -0.01091645f, 0.00780390f, 0.02061048f, -0.00857436f, -0.00304590f, -0.02133419f, 0.04160890f, 
    -0.00126194f, -0.01174939f, 0.03658145f, 0.03321768f, -0.04314125f, -0.02206928f, -0.06556387f, -0.04988281f, 
    0.03720358f, -0.05984025f, 0.04182625f, -0.05932904f, 0.05372150f, -0.00130993f, 0.02844512f, -0.04015099f, 
    0.02631679f, -0.05061649f, -0.01713934f, 0.03759564f, 0.02167011f, 0.03211050f, 0.01979038f, -0.03371410f, 
    -0.05241797f, -0.06176752f, -0.06708075f, 0.03675786f, -0.02020286f, 0.04045837f, 0.00115962f, 0.01329205f, 
    0.03932437f, -0.01410434f, -0.01021530f, -0.05835901f, 0.01221964f, 0.03122868f, 0.03538368f, 0.05273651f, 
    -0.00276367f, -0.01462673f, 0.01243923f, 0.00070106f, 0.02274407f, 0.03538180f, 0.02049982f, 0.03107579f, 
    -0.03170627f, -0.04308282f, -0.00745854f, 0.00132339f, 0.01379005f, -0.06319026f, 0.01666306f, 0.03559264f, 
    -0.03069582f, 0.04425328f, -0.03511412f, -0.06405166f, -0.03124041f, 0.04128905f, 0.03922224f, 0.01756663f, 
    -0.02433582f, 0.00225878f, 0.03596178f, 0.02889070f, 0.01870350f, -0.01411862f, 0.03612156f, -0.06339928f, 
    -0.04084338f, -0.00279556f, 0.04261832f, -0.07055333f, -0.00667342f, 0.02149476f, -0.02801031f, -0.00159131f, 
    -0.01425153f, -0.04156296f, -0.04142098f, -0.01759269f, 0.01675143f, 0.03042310f, 0.04081611f, -0.00513706f, 
    -0.01089277f, 0.01313337f, -0.03204473f, 0.00014917f, -0.06147733f, 0.01139066f, -0.00797023f, 0.01864137f, 
    -0.05941489f, -0.02309403f, 0.00954307f, -0.06527703f, -0.02037437f, 0.03691211f, -0.05622517f, -0.00925678f, 
    0.02495960f, -0.05833830f, -0.06426962f, 0.02977132f, -0.03775696f, -0.05098972f, -0.00706044f, 0.00068402f, 
    0.02074493f, -0.02552885f, -0.03152653f, -0.05694455f, -0.06300190f, -0.00946784f, -0.06147716f, -0.02759248f, 
    0.03430825f, 0.01840606f, -0.02631854f, -0.01298661f, -0.07908402f, -0.04903331f, -0.05896674f, -0.04127234f, 
    -0.07324541f, -0.04622929f, 0.02629447f, -0.01048962f, -0.03524784f, -0.04426485f, 0.03124148f, 0.03225541f, 
    -0.02575487f, 0.04122709f, 0.02269826f, -0.01968123f, -0.07315580f, -0.06123577f, -0.06413961f, 0.00862856f, 
    -0.02133975f, -0.02262098f, -0.05607889f, -0.02471066f, 0.00584730f, -0.00438729f, 0.05309852f, -0.01526789f, 
    -0.01549501f, 0.03463548f, -0.06932799f, 0.02768725f, -0.04954684f, 0.04630020f, -0.04751963f, 0.03493379f, 
    0.02171359f, -0.02802029f, -0.03978278f, 0.04207442f, -0.04039822f, -0.00382681f, -0.03854983f, -0.00419718f, 
    0.01745805f, -0.00450220f, -0.05270030f, -0.02132230f, 0.02494696f, 0.03904538f, -0.02832311f, 0.00157752f, 
    -0.02889636f, 0.02148937f, -0.02989456f, -0.06535159f, -0.05830175f, 0.00243562f, -0.04557559f, 0.04659040f, 
    0.05152740f, -0.06219945f, -0.05395041f, -0.01736929f, -0.01225634f, 0.00958815f, 0.01931666f, -0.05415337f, 
    0.04681747f, 0.04643546f, 0.03035661f, -0.02125609f, 0.04103617f, -0.03868166f, 0.03376862f, 0.03263386f, 
    -0.05929981f, 0.02132116f, -0.07070387f, 0.02512636f, -0.07555929f, -0.05378645f, 0.03404567f, -0.02571129f, 
    -0.01081293f, -0.03563875f, -0.06663664f, -0.06044186f, 0.02311926f, -0.03910246f, 0.01384135f, 0.03881693f, 
    -0.03592956f, 0.05169631f, -0.03701834f, 0.00518605f, -0.01859170f, -0.04390982f, 0.04769753f, -0.02716629f, 
    -0.00108790f, -0.07327628f, -0.03777027f, -0.04546972f, 0.01571323f, -0.01029489f, 0.00298336f, -0.05739467f, 
    -0.04484751f, 0.03400775f, -0.04452582f, -0.01086630f, 0.05051845f, -0.01028627f, -0.04347605f, 0.00846491f, 
    -0.21735021f, -0.17839542f, 0.04401635f, 0.10835923f, 0.02509335f, -0.12606619f, 0.17539117f, 0.17359477f, 
    -0.01276828f, 0.57120031f, 0.01477374f, -0.00557024f, 0.06556388f, -0.08780141f, 0.04382720f, 0.11411035f, 
    0.11541194f, 0.05571893f, -0.12488007f, -0.00227683f, -0.10371715f, -0.13390203f, 0.09843548f, -0.17049073f, 
    -0.02532514f, -0.18964340f, 0.36339650f, 0.55215621f, 0.05017323f, 0.60796332f, 0.23442554f, 0.17650995f, 
    -0.06443517f, 0.07170405f, 0.37445176f, 0.03291356f, -0.06679126f, -0.15915284f, -0.27144858f, 0.08664680f, 
    -0.02557645f, 0.15697467f, 0.08986223f, -0.09930203f, -0.06725901f, 0.18352768f, 0.08176246f, -0.36712033f, 
    -0.20113467f, -0.11571015f, -0.01160955f, 0.10059390f, 0.09659067f, 0.13113174f, -0.49916449f, -0.03453567f, 
    -0.57356292f, -0.09497914f, -0.20824350f, 0.16063784f, 0.11610624f, -0.04572696f, 0.08942903f, -0.00574901f, 
    -0.07276298f, 0.06774969f, -0.05474564f, -0.06940335f, -0.10652198f, -0.15955773f, -0.31313074f, 0.03300493f, 
    0.08879542f, -0.46188647f, -0.55881292f, 0.06421147f, 0.10811610f, -0.01845822f, -0.04670045f, -0.07781875f, 
    -0.06963717f, -0.62367517f, -0.59604412f, -0.72052747f, 0.02382896f, 0.22193131f, 0.13515981f, 0.08556080f, 
    -0.06575204f, -0.04747833f, 0.33340487f, 0.20589592f, 0.29381868f, -0.13233449f, -0.07394398f, -0.17502064f, 
    0.02397320f, 0.10205951f, 0.12341258f, -0.36453679f, -0.49393943f, -0.76616180f, -0.22655632f, 0.12064063f, 
    0.10700080f, -0.07421108f, -0.10805340f, 0.14191958f, -0.18418901f, -0.18265387f, -0.44299367f, -0.16831139f, 
    0.12016734f, 0.14020120f, 0.13459823f, -0.01635675f, -0.04771117f, 0.64748144f, 0.63830572f, 0.33717167f, 
    -0.08426908f, -0.32893881f, -0.32699376f, 0.06050496f, 0.13857950f, 0.14927052f, 0.12291366f, 0.31190017f, 
    -0.08551700f, -0.20040408f, -0.06760872f, -0.29026884f, 0.22729567f, 0.14676799f, 0.24641511f, -0.45246848f, 
    -0.47565329f, -0.36010915f, -0.29716724f, 0.18758194f, 0.10238849f, -0.03410875f, 0.01594535f, -0.03781236f, 
    0.08675770f, 0.03753087f, -0.09919339f, -0.05330167f, 0.01443153f, 0.04090441f, 0.04765330f, -0.11527804f, 
    -0.00332521f, 0.32987350f, 0.19284363f, 0.14805263f, -0.00167365f, -0.02841514f, -0.01004346f, 0.04779087f, 
    0.21864864f, -0.14373383f, 0.14996120f, 0.01126428f, 0.07996091f, -0.08635985f, 0.21500997f, -0.03892819f, 
    -0.14384082f, -0.04698174f, 0.01078659f, -0.15255201f, -0.02357139f, 0.53119618f, -0.06760431f, -0.25752002f, 
    -0.21678467f, 0.07281557f, 0.12879793f, 0.08498099f, -0.17695668f, -0.05942516f, -0.11840182f, -0.00920113f, 
    -0.02756935f, -0.03820727f, 0.12003031f, 0.10534146f, 0.19760439f, 0.27980953f, 0.23485465f, 0.20559263f, 
    -0.12199159f, 0.09059206f, -0.15186085f, -0.12727353f, 0.15255572f, 0.16477403f, -0.18722787f, -0.36325616f, 
    -0.05627878f, 0.27660364f, 0.10299406f, -0.04835240f, 0.10650580f, 0.12945561f, 0.03335122f, -0.08633131f, 
    0.06163395f, -0.20191671f, -0.03449159f, 0.09345892f, 0.01503129f, 0.23357400f, -0.02799942f, -0.00293533f, 
    -0.05036195f, 0.26340827f, -0.22317739f, -0.05014956f, -0.23899671f, -0.03233222f, 0.07503785f, -0.04770359f, 
    0.06092132f, -0.31438202f, -0.17540747f, -0.30884930f, 0.01581812f, -0.04252213f, 0.02874138f, 0.13363157f, 
    -0.17440394f, 0.09787687f, 0.42881387f, 0.14559457f, -0.00054980f, 0.12343753f, 0.33937463f, 0.23641862f, 
    -0.17181885f, 0.11389376f, 0.13426529f, -0.28894311f, -0.10336734f, -0.55932599f, -0.09062300f, -0.02857794f, 
    -0.15598471f, -0.20712821f, -0.08053210f, -0.10950144f, -0.18700312f, -0.35234544f, -0.11076744f, -0.00790697f, 
    -0.03853416f, 0.34041181f, 0.08079394f, 0.24757318f, -0.03713416f, -0.03159241f, 0.20544107f, -0.19477545f, 
    0.01894205f, 0.11687231f, -0.09164569f, 0.21059936f, 0.20942570f, 0.06438650f, 0.04834376f, 0.14191291f, 
    0.01444646f, -0.06186823f, 0.00529846f, 0.03391567f, 0.10527863f, 0.06654917f, 0.05374621f, -0.38362625f, 
    -0.12786663f, -0.82848680f, -0.07001631f, 0.20083591f, 0.00674534f, 0.03204887f, -0.08155819f, 0.02676591f, 
    0.43907863f, 0.29008895f, -0.08184632f, -0.04586508f, 0.12032969f, 0.10761038f, 0.09974343f, 0.16853124f, 
    0.16622826f, 0.08690843f, 0.18953562f, 0.40983015f, -0.19878046f, -0.06908942f, 0.16315208f, 0.07332271f, 
    0.11881191f, 0.07173779f, 0.08791818f, -0.01383527f, 0.13239181f, -0.06156928f, -0.01409857f, -0.09073211f, 
    0.09055691f, -0.08352352f, 0.06383866f, -0.17756145f, -0.35224265f, 0.03041605f, -0.17376438f, -0.01987892f, 
    -0.15818430f, 0.13520603f, 0.08812635f, 0.00806907f, 0.12254103f, -0.06803715f, -0.27460799f, 0.01893095f, 
    -0.03481909f, -0.26075169f, -0.03598715f, 0.24862806f, -0.06069286f, 0.29800436f, 0.15597036f, 0.18990375f, 
    -0.20047396f, -0.04890206f, 0.02050431f, 0.06615613f, 0.06780698f, 0.07176324f, 0.12126483f, -0.03527497f, 
    -0.41293463f, -0.06772565f, -0.07999077f, 0.10180667f, -0.03541311f, 0.04523311f, 0.02617114f, 0.16622084f, 
    0.06088256f, -0.05926528f, -0.07024077f, -0.08048713f, -0.04130890f, -0.05705442f, -0.06619877f, -0.08073919f, 
    0.41626081f, -0.14996715f, 0.02402861f, -0.14849912f, -0.22249262f, -0.10276199f, -0.12720232f, -0.12782089f, 
    -0.03096951f, -0.19380377f, 0.02777272f, -0.28605321f, -0.09903624f, -0.36458099f, 0.20788731f, -0.16527027f, 
    0.03139928f, 0.04680055f, -0.57427394f, -0.30377099f, -0.05027292f, 0.06762931f, 0.09022406f, 0.00176391f, 
    0.03295130f, -0.09558427f, 0.05786714f, 0.29731679f, 0.05144083f, 0.28223678f, 0.01849297f, -0.17667174f, 
    -0.03784370f, -0.02090264f, -0.00905089f, 0.13563931f, 0.07439180f, 0.07552448f, 0.22947951f, 0.11779995f, 
    0.02636912f, 0.05533932f, -0.21725591f, 0.14419755f, 0.06757950f, -0.38163289f, -0.61431348f, 0.24670129f, 
    0.04979934f, 0.12793468f, -0.15052490f, 0.08032700f, -0.03688385f, 0.10478690f, -0.53803194f, -0.35927516f, 
    -0.13662937f, 0.12533027f, -0.08775020f, -0.05616210f, 0.17729703f, -0.16978097f, 0.27264050f, -0.03261610f, 
    0.14507893f, -0.00005445f, 0.04862377f, -0.12576590f, 0.07342798f, -0.04584128f, 0.04491197f, 0.15553604f, 
    -0.01920689f, 0.08968356f, -0.06937958f, 0.04894868f, -0.03850265f, -0.03582220f, 0.09020594f, 0.11410814f, 
    -0.01166421f, -0.09318040f, -0.12242359f, -0.10277224f, -0.04662488f, -0.03095255f, 0.01419014f, -0.00390352f, 
    0.05253111f, -0.08496563f, 0.08970500f, -0.08780756f, -0.25721782f, -0.19971474f, -0.01713403f, 0.14697227f, 
    0.27422675f, -0.11658111f, 0.12922359f, 0.37591076f, 0.09885423f, -0.14296098f, -0.19457826f, 0.16785498f, 
    -0.06074207f, -0.02151188f, -0.06016259f, -0.11501577f, -0.15609507f, -0.02927911f, 0.00600709f, -0.07869355f, 
    0.00736403f, 0.02784128f, 0.14930025f, -0.06884745f, -0.04005910f, -0.31369066f, -0.28007203f, -0.05566121f, 
    -0.21781954f, 0.02992043f, -0.13747570f, 0.14556000f, 0.09199460f, 0.15458414f, 0.11720344f, 0.10029145f, 
    0.03137446f, -0.10383747f, -0.02615658f, -0.06519286f, 0.21864006f, -0.02507213f, 0.07279677f, -0.15329680f, 
    0.02916627f, 0.00691525f, 0.09962720f, -0.10088927f, -0.03788582f, 0.07346205f, 0.35113016f, 0.05764107f, 
    0.00438846f, 0.24454355f, 0.24951825f, -0.23296998f, -0.05992821f, 0.01515364f, -0.00701506f, 0.05387477f, 
    -0.01054017f, -0.02689067f, 0.28177971f, 0.09211399f, 0.02368574f, 0.12079927f, 0.06412464f, 0.14473097f, 
    0.22539850f, 0.10902408f, -0.05905366f, -0.13597851f, -0.33611712f, -0.26130182f, 0.07181910f, 0.24200790f, 
    0.12505919f, 0.16098090f, 0.20032658f, -0.40604857f, -0.24518426f, -0.79183358f, -0.07846238f, -0.04547809f, 
    0.20359254f, 0.17443550f, 0.03437269f, -0.06932225f, -0.01676973f, 0.01937459f, -0.35036212f, -0.29198158f, 
    -0.13913159f, 0.16904664f, -0.06375485f, 0.10244183f, -0.30141822f, -0.11844432f, -0.50282651f, -0.06836984f, 
    0.17583282f, -0.09382648f, -0.04153436f, -0.05133085f, -0.03586988f, 0.26737845f, -0.18076767f, -0.05387574f, 
    -0.12231056f, 0.01020670f, 0.05477361f, 0.06112480f, 0.14468431f, 0.12840608f, -0.11095461f, 0.01650604f, 
    0.06267194f, -0.24747910f, -0.04214450f, 0.06992654f, 0.19915564f, 0.00186728f, 0.01289412f, -0.04412803f, 
    0.21086495f, 0.35939676f, 0.22160119f, 0.00574239f, 0.09758857f, 0.14133930f, 0.01580833f, -0.03739726f, 
    0.09892830f, 0.02698308f, -0.17230719f, -0.04743968f, -0.13138324f, -0.09828203f, 0.09010189f, 0.23986451f, 
    0.16220026f, 0.06756882f, 0.25313526f, 0.07072499f, 0.16702229f, -0.07401203f, -0.16246916f, -0.03409731f, 
    0.15151770f, 0.12304927f, 0.16334817f, 0.25098893f, -0.64073205f, 0.11562004f, -0.08683088f, -0.01192034f, 
    -0.05205548f, 0.09452699f, -0.04560232f, 0.18703626f, 0.06957646f, 0.05689085f, -0.30700248f, -0.09405988f, 
    0.15001787f, -0.18766400f, -0.09161493f, 0.11763714f, -0.03607032f, -0.05938981f, 0.04539411f, 0.25303349f, 
    -0.02013811f, -0.11766802f, 0.03853629f, 0.10982313f, 0.05453692f, 0.11369375f, -0.31814042f, 0.12991460f, 
    -0.70432961f, 0.12564312f, -0.16110188f, -0.07997803f, 0.11853088f, 0.17782195f, -0.08424910f, 0.25958994f, 
    0.04197348f, -0.06089865f, -0.15596788f, -0.25898963f, -0.21963991f, 0.03177903f, -0.13335989f, -0.22912283f, 
    0.38617301f, -0.19184308f, 0.34788203f, -0.01547023f, -0.33899981f, 0.18302865f, 0.08112439f, -0.05439123f, 
    -0.02166472f, -0.67310899f, 0.21611851f, -0.31755936f, 0.10789369f, -0.21719576f, 0.09792936f, 0.05244654f, 
    -0.20751657f, -0.17009625f, 0.03747139f, -0.02440971f, 0.13705406f, 0.03697949f, 0.04281303f, -0.04002792f, 
    0.02322811f, -0.04918485f, 0.09344425f, -0.02150276f, -0.57092148f, -0.22944599f, 0.11713892f, -0.24668822f, 
    0.17496651f, 0.05987958f, 0.08456700f, 0.04694514f, -0.45876700f, 0.06460062f, -0.18859059f, 0.05415381f, 
    -0.21673493f, -0.00516571f, 0.07887176f, -0.00265885f, -0.09603403f, -0.15835992f, -0.27656338f, -0.02728325f, 
    0.14258751f, -0.04894369f, -0.13130869f, -0.00928029f, -0.09119136f, -0.02760240f, -0.08468314f, 0.46825415f, 
    -0.15049775f, 0.23860438f, -0.27706733f, -0.02120053f, 0.24505377f, 0.15108077f, -0.05106026f, -0.25598529f, 
    0.03052841f, -0.61456883f, 0.03346426f, -0.03346890f, 0.11001506f, 0.11761408f, 0.12943541f, 0.08269322f, 
    0.16646461f, -0.00195408f, -0.07233392f, 0.06559909f, -0.22502850f, -0.19687073f, 0.04177140f, -0.05048946f, 
    -0.03568285f, 0.12853537f, -0.22654688f, 0.04888646f, -0.00570822f, -0.01408430f, 0.13884710f, -0.02333919f, 
    0.19602452f, 0.04744732f, 0.07780705f, 0.10722293f, -0.24386865f, -0.16492012f, 0.20691404f, 0.06274580f, 
    0.07376119f, 0.10283086f, 0.11495990f, 0.04993148f, 0.21581870f, -0.01872406f, -0.10577835f, 0.08287030f, 
    -0.22019280f, -0.02934370f, -0.12846594f, -0.10559138f, 0.06660177f, 0.06595768f, 0.18216899f, 0.03693199f, 
    -0.12858969f, -0.09688918f, -0.25960362f, -0.11981328f, 0.25247312f, -0.03656719f, -0.06733076f, -0.06495871f, 
    -0.06639666f, 0.22185393f, -0.13548332f, 0.08014805f, 0.11575107f, -0.09035800f, -0.27629507f, 0.06237350f, 
    0.44335276f, -0.20029560f, 0.07135516f, -0.02404666f, 0.06745195f, -0.00739804f, 0.09568524f, 0.10984414f, 
    0.03218501f, -0.13333762f, 0.09685767f, -0.22850661f, -0.03358367f, 0.05837956f, 0.14177857f, 0.09047461f, 
    -0.53579342f, 0.64812130f, -0.15580502f, 0.03257812f, -0.13338877f, -0.10618165f, -0.00445464f, 0.01667573f, 
    0.03941678f, -0.29131162f, 0.54329681f, -0.04837679f, -0.04320729f, -0.02356626f, 0.04931119f, 0.02408304f, 
    0.07204272f, 0.02799700f, 0.15441385f, 0.32730317f, -0.50485849f, -0.20711894f, 0.37552842f, 0.12442958f, 
    0.12742786f, -0.05729472f, -0.13774993f, -0.20745124f, 0.73694742f, -0.46630463f, -0.07285102f, 0.09759914f, 
    0.13857326f, 0.10958979f, 0.09752878f, 0.11304849f, -0.82386541f, 0.02715358f, 0.19393574f, 0.25654900f, 
    0.13884762f, -0.03253288f, 0.00396491f, 0.01179995f, -0.06868964f, 0.13621616f, 0.14154291f, 0.08310442f, 
    -0.00875006f, -0.05778385f, -0.03306414f, -0.14026666f, 0.17816249f, 0.11414716f, 0.02505669f, 0.47833788f, 
    -0.07858349f, 0.01096040f, 0.11283045f, -0.39040554f, -0.07492767f, 0.12233938f, -0.00646452f, -0.08430089f, 
    -0.22378948f, -0.60728741f, -0.03939539f, 0.06507343f, 0.18748723f, 0.14251640f, 0.04554916f, -0.03185001f, 
    0.22009256f, 0.19936872f, 0.49867851f, -0.15675078f, -0.02223269f, 0.05359926f, -0.08274113f, -0.05471716f, 
    -0.01370465f, -0.00521278f, 0.11150520f, -0.07642152f, 0.21242370f, 0.18483284f, 0.12233825f, 0.22462732f, 
    0.10721007f, -0.01763400f, -0.43309805f, -0.21411332f, -0.44150704f, 0.01096535f, -0.03254034f, -0.07369961f, 
    -0.00742020f, 0.10333353f, 0.05707269f, 0.09112430f, -0.36008891f, -0.67250621f, 0.15589339f, -0.01272890f, 
    0.01013622f, 0.19055037f, 0.07344680f, -0.14604461f, -0.28053501f, -0.31290135f, -0.53482711f, -0.02919799f, 
    0.04014436f, -0.04420742f, 0.33471990f, -0.02994620f, 0.05829329f, -0.02644803f, 0.01452165f, 0.37724382f, 
    0.02620633f, 0.05538828f, 0.00786894f, 0.16650562f, 0.09779075f, -0.05946343f, -0.67813826f, -0.13987115f, 
    -0.01378672f, 0.07044182f, -0.28171188f, 0.00261756f, 0.17221348f, -0.15135328f, 0.01042516f, -0.31031939f, 
    -0.61887783f, -0.63730735f, -0.08409350f, 0.07155322f, -0.11930437f, -0.13126926f, 0.11482927f, 0.08505379f, 
    -1.08924389f, -0.07351932f, -0.37235177f, 0.15887515f, 0.09455372f, 0.03922859f, 0.10202208f, 0.02689054f, 
    0.09668089f, -0.48578912f, -0.29401949f, 0.07210242f, 0.07621313f, -0.16617160f, 0.00897493f, -0.04184454f, 
    -0.04871994f, -0.06939290f, 0.36252859f, -0.13032399f, 0.36038825f, 0.21289009f, -0.05411520f, 0.09718875f, 
    0.17858320f, 0.05549875f, 0.11358155f, -0.24230942f, -0.02695584f, -0.08535881f, 0.02753774f, 0.06446160f, 
    -0.00145524f, 0.03955353f, -0.04144410f, 0.02561156f, 0.11671443f, -0.20016928f, 0.30256972f, 0.06554493f, 
    0.09272849f, 0.10496385f, -0.03737744f, -0.01065603f, 0.00838738f, 0.27216268f, -0.39554641f, -0.15391615f, 
    -0.11747155f, 0.04926354f, 0.12315082f, -0.07150017f, -0.09287737f, 0.02485363f, -0.08317509f, -0.17410007f, 
    -0.38556024f, 0.02721689f, 0.18544319f, -0.19281739f, -0.07945859f, 0.29550880f, -0.08053356f, 0.05383946f, 
    -0.33326659f, -0.05995635f, 0.03317540f, -0.01346794f, -0.00403924f, 0.05123584f, 0.05178341f, 0.03298867f, 
    -0.24756815f, -0.40712607f, -0.27400437f, 0.07531460f, 0.08010235f, 0.02987533f, 0.15094458f, 0.15250601f, 
    0.31492490f, 0.04225437f, -0.22404437f, 0.07549612f, -0.32416272f, 0.13468528f, -0.10429788f, -0.03250406f, 
    0.07587984f, 0.18186562f, -0.18020982f, -0.61787748f, -0.50774688f, -0.02250439f, 0.08242211f, -0.14210175f, 
    0.14112608f, 0.08296544f, 0.07644054f, 0.24349420f, 0.05677079f, 0.31771326f, -0.00700765f, 0.00126762f, 
    0.05264976f, 0.03079855f, -0.19129114f, -0.07798504f, -0.60889560f, -0.00345847f, 0.29371217f, 0.08788749f, 
    -0.22519210f, 0.09766799f, -0.11078694f, 0.00098689f, -0.12906530f, 0.66126961f, -0.29769936f, -0.29416463f, 
    0.01724025f, -0.19279525f, -0.03033142f, 0.01548381f, 0.16773695f, -0.01998626f, 0.29852259f, 0.00375587f, 
    0.31063104f, -0.03010513f, -0.11069997f, -0.06633915f, 0.11903980f, -0.17239034f, 0.08355392f, -0.30226928f, 
    -0.09846391f, -0.26641330f, -0.06180037f, 0.00653418f, -0.12661025f, 0.19729279f, 0.06825174f, 0.31789929f, 
    -0.16846707f, -0.02360776f, 0.64549744f, -0.00210079f, -0.05593567f, -0.03656913f, -0.07749636f, 0.06680049f, 
    0.02424219f, 0.21574882f, 0.06900848f, 0.45942047f, -0.02854313f, 0.17716637f, -0.00346624f, 0.03162965f, 
    -0.14055361f, 0.18918522f, 0.43431938f, -0.13036920f, -0.44828397f, 0.14021635f, 0.10842443f, 0.07502966f, 
    0.26557794f, -0.10375538f, 0.02477339f, -0.07333778f, -0.25182101f, 0.09216286f, 0.19264047f, -0.05950977f, 
    0.00603165f, 0.18211533f, -0.06797706f, 0.08837477f, 0.18561973f, -0.43294537f, -0.00897209f, 0.11151385f, 
    0.09187342f, 0.20348801f, -0.11682288f, 0.08296525f, -0.04014409f, 0.11605746f, 0.34774694f, -0.46573037f, 
    0.00127830f, 0.12137647f, -0.12900843f, -0.02678319f, 0.03746771f, -0.25871676f, -0.13742317f, -0.25002226f, 
    -0.11607283f, 0.13442025f, 0.19750819f, -0.13748515f, -0.02461821f, -0.12047642f, 0.24474509f, -0.04834063f, 
    0.21458757f, 0.08168591f, 0.14297320f, -0.10552607f, 0.05088438f, -0.02752913f, 0.18386695f, -0.10014661f, 
    -0.47184911f, 0.09962404f, -0.16331863f, 0.15032263f, 0.04803823f, 0.03739570f, 0.05536969f, -0.12822695f, 
    -0.01087402f, -0.53886002f, -0.76335490f, -0.70286804f, -0.15605713f, -0.01593078f, -0.02344319f, 0.14982413f, 
    0.20585190f, 0.23924981f, 0.03421560f, 0.11068410f, 0.06533367f, -0.08792113f, -0.15026663f, 0.05547861f, 
    -0.00245088f, -0.12792216f, 0.08086795f, -0.25541914f, -0.30217397f, -0.35749653f, -0.10495163f, 0.07219207f, 
    -0.05365302f, 0.04005563f, 0.18500012f, 0.15878457f, 0.37902254f, -0.04015134f, -0.18311557f, -0.09475423f, 
    0.10855687f, 0.16962771f, 0.11539932f, -0.07880671f, -0.11696056f, -0.34542039f, -0.37564075f, -0.53646612f, 
    -0.06883642f, -0.10451439f, -0.02788603f, 0.10019782f, 0.07288312f, 0.11304443f, 0.11185418f, -0.76531011f, 
    -0.13159928f, -0.09790548f, -0.01006996f, 0.05673951f, 0.20675108f, 0.06800075f, 0.09645061f, 0.13432269f, 
    0.14423075f, -0.11345924f, -0.26994255f, -0.31939456f, -0.37323627f, -0.19043088f, -0.20616426f, 0.04741191f, 
    0.45668021f, 0.12071109f, -0.40826192f, -0.36483195f, -0.16858885f, -0.08656859f, -0.04243232f, -0.10085136f, 
    0.02453016f, -0.40901080f, -0.30645639f, -0.17090814f, -0.12288302f, -0.10924654f, 0.02410813f, 0.20534623f, 
    -0.04260347f, 0.11536299f, 0.15366001f, 0.10442028f, -0.00734676f, 0.13091007f, 0.00396802f, -0.02823982f, 
    0.18264329f, -0.13549204f, -0.02001238f, -0.27036974f, -0.45150107f, -0.55829710f, -0.16160260f, -0.21098299f, 
    -0.00495009f, 0.05892246f, 0.09272780f, 0.06769139f, 0.17699313f, 0.36536783f, 0.19507594f, -0.18056852f, 
    0.10102440f, 0.09438560f, 0.15977183f, -0.08076470f, -0.08963838f, -0.09700535f, -0.13099565f, -0.08489027f, 
    0.11363757f, 0.04119496f, -0.06733029f, 0.03784673f, 0.18162021f, 0.16379845f, 0.67175978f, -0.08000630f, 
    0.32748562f, 0.08382228f, -0.11931723f, 0.13369603f, -0.10966815f, -0.04967463f, 0.07622742f, -0.02392133f, 
    0.10515356f, -0.30228820f, 0.05968810f, 0.21382917f, 0.19058967f, 0.06241865f, 0.08235934f, 0.02923687f, 
    0.12684859f, 0.09395613f, -0.02076098f, -0.32081857f, -0.23796776f, -0.19471332f, -0.00759992f, -0.06353906f, 
    0.00485631f, -0.10002805f, -0.02485316f, -0.23760705f, -0.04211424f, -0.05471630f, -0.00566824f, -0.15041849f, 
    0.09660553f, 0.02094673f, 0.07434564f, 0.14169136f, -0.00551902f, 0.04097559f, -0.23835756f, -0.09724654f, 
    0.11159015f, 0.03493302f, -0.06164216f, -1.35186851f, -0.52321208f, -0.16951413f, 0.01588153f, 0.05858727f, 
    0.02916218f, -0.03923094f, -0.07822348f, -0.06981440f, 0.03369108f, -0.00743970f, -0.02249438f, -0.04554070f, 
    -0.02962574f, -0.18304564f, -0.15202987f, -0.27490321f, 0.02041121f, 0.18775479f, 0.14818791f, 0.10925642f, 
    0.23401883f, -0.13063154f, 0.13382986f, 0.07840816f, 0.14412640f, 0.01323931f, -0.22207734f, -0.04104299f, 
    0.22906274f, 0.05884719f, 0.19171292f, 0.03492099f, 0.02485767f, -0.08213440f, -0.06541966f, 0.10980266f, 
    0.16856182f, -0.01851558f, 0.06514477f, 0.02573048f, 0.17398182f, 0.24837717f, -0.01928980f, 0.00468150f, 
    -0.73904216f, -0.31612393f, -0.09271210f, 0.16136310f, -0.09510285f, -0.07211498f, 0.06686043f, 0.16946037f, 
    0.22834629f, -0.15057078f, 0.35358241f, 0.34053564f, 0.28972974f, 0.22071166f, 0.02247440f, 0.00649620f, 
    -0.13032590f, -0.06822721f, 0.52035624f, 0.23612565f, -0.14989160f, 0.20469345f, -0.20126590f, 0.15526326f, 
    0.23197600f, 0.02054635f, 0.11326800f, 0.01432914f, 0.26668230f, 0.44728008f, 0.19964974f, -0.11003460f, 
    0.07834492f, 0.05440213f, 0.09484561f, 0.22025296f, -1.06756365f, 0.17747977f, 0.13476123f, 0.00517063f, 
    -0.02489720f, -0.05169843f, -0.01728704f, 0.22705016f, 0.04137705f, 0.53852284f, 0.16502792f, -0.07755505f, 
    -0.15009700f, 0.08875108f, 0.01923487f, 0.14559506f, -0.02880156f, -0.05352176f, 0.15332463f, 0.10006896f, 
    0.07003815f, 0.04655185f, 0.18389747f, -0.23824701f, 0.10913409f, 0.07588206f, -0.09437209f, -0.55319911f, 
    -0.41117349f, 0.00190805f, -0.09410842f, -0.06700973f, 0.15251905f, -0.04386566f, 0.24492945f, 0.08813392f, 
    0.06274609f, -0.11239667f, -0.01127968f, 0.06959702f, -0.00050875f, -0.05696976f, -0.04168784f, -0.13074876f, 
    -0.29092953f, 0.14872821f, 0.04520874f, 0.19476543f, 0.06812308f, 0.18035904f, 0.16985577f, 0.14749399f, 
    0.03452455f, -0.03336652f, 0.19403532f, -0.11641666f, -0.20636742f, 0.01829568f, 0.07426628f, 0.06664225f, 
    0.16511105f, 0.00716743f, 0.03485796f, 0.08693349f, 0.05863589f, -0.15082353f, -0.02210347f, -0.02278749f, 
    -0.00151176f, 0.05640908f, -0.17299245f, -0.22858053f, -0.05966294f, 0.03132484f, 0.19466844f, 0.04140245f, 
    0.21062011f, 0.10477227f, -0.01760756f, -0.15706006f, -0.00853277f, -0.15884218f, 0.24418139f, 0.38743839f, 
    0.07957474f, 0.08410218f, 0.09559561f, -0.06565056f, 0.07093839f, -0.09040441f, 0.14780903f, 0.27685726f, 
    0.02775056f, 0.02856235f, 0.05744908f, 0.08808888f, 0.05484885f, 0.09345885f, 0.31448269f, 0.03334588f, 
    0.10206974f, -0.04666492f, -0.03452445f, 0.13254794f, -0.12852383f, 0.07244032f, 0.11605372f, -0.18070222f, 
    0.25569049f, 0.12817635f, -0.08236591f, -0.15798336f, -0.07752728f, 0.07456179f, 0.10214459f, 0.00806950f, 
    0.13465238f, 0.37716991f, 0.22944191f, 0.16116166f, 0.21420671f, 0.08013543f, -0.23035266f, -0.08525186f, 
    0.19498582f, 0.32312095f, -0.06791361f, 0.03940104f, -0.05379554f, 0.06206895f, -0.02555710f, -0.00689787f, 
    0.13315658f, -0.02147380f, 0.07473632f, -0.00563948f, 0.22493124f, 0.13011569f, 0.02631762f, 0.05535062f, 
    0.16920590f, 0.14078555f, -0.11927938f, 0.12537959f, -0.26240829f, -0.11945289f, 0.09839630f, -0.03169376f, 
    0.05644452f, 0.03481201f, 0.03428143f, -0.19301823f, -0.09065316f, -0.30299258f, 0.15225498f, -0.06687572f, 
    0.02715885f, -0.08719103f, 0.09436333f, 0.07672950f, -0.01892674f, 0.13389511f, -0.01402456f, -0.21925239f, 
    -0.15794206f, 0.01228782f, -0.21749887f, 0.16097963f, 0.06441378f, -0.22844104f, -0.03662132f, -0.29446176f, 
    0.07798461f, 0.42762297f, 0.02613869f, 0.03439410f, 0.02380461f, 0.08061537f, -0.00011641f, 0.10937101f, 
    0.08137956f, 0.08582456f, 0.06177531f, -0.04513213f, 0.08052312f, -0.00323540f, -0.09887225f, 0.03210521f, 
    -0.14448245f, 0.02003341f, -0.02787059f, -0.04354359f, 0.08919911f, -0.15874028f, -0.14380544f, -0.10994945f, 
    -0.12735909f, -0.43901169f, 0.20337583f, -0.08820527f, 0.32869500f, 0.00777849f, -0.07061370f, 0.30824253f, 
    -0.01522713f, 0.22679250f, 0.03655227f, -0.36454865f, 0.14570078f, -0.17001200f, -0.12839957f, 0.17110634f, 
    0.09844497f, -0.11339220f, -0.06322774f, 0.10371370f, 0.22673455f, 0.01349883f, 0.05977587f, 0.18405971f, 
    0.07129053f, -0.04429819f, 0.28166831f, 0.23283111f, 0.29204530f, 0.15752134f, -0.05429367f, 0.07912603f, 
    0.04869366f, -0.01897081f, -0.00031518f, 0.08264463f, 0.19593698f, 0.07611109f, 0.24757589f, -0.06403760f, 
    -0.08347565f, 0.02577245f, -0.02704114f, -0.15037024f, 0.02477874f, 0.01140608f, -0.33657712f, 0.02360935f, 
    -0.04236417f, -0.02899032f, 0.05190792f, -0.18072912f, 0.05885781f, -0.24657319f, -0.13825849f, -0.17387880f, 
    0.06099743f, 0.12630369f, 0.18090521f, -0.01112476f, 0.09317426f, -0.02057228f, 0.09383447f, 0.20403987f, 
    0.02745746f, -0.13041072f, -0.10494038f, 0.00649923f, 0.07778236f, -0.13818637f, -0.08417828f, 0.05691405f, 
    0.11298767f, -0.23350909f, 0.07233953f, 0.16409878f, 0.52349669f, -0.01736118f, -0.01851397f, 0.14983794f, 
    0.22818105f, 0.29920959f, 0.19475095f, 0.25865555f, -0.21815103f, 0.44188437f, -0.08671777f, 0.01475375f, 
    -0.24499390f, 0.02522478f, 0.05093512f, 0.30046320f, -0.26964071f, 0.32579350f, -0.27796543f, -0.36701876f, 
    0.08515760f, -0.09306312f, -0.02233214f, 0.00559471f, -0.25586656f, 0.31726664f, 0.00988504f, 0.13348028f, 
    0.03075565f, -0.07016852f, 0.00017973f, 0.12990084f, -0.08561237f, 0.37642983f, -0.29056963f, 0.18368369f, 
    0.08974155f, 0.05544184f, 0.09503073f, 0.08844424f, 0.17695771f, 0.25444579f, 0.44602796f, 0.23747125f, 
    0.18561308f, 0.15617304f, 0.07287370f, 0.13679700f, 0.09565770f, 0.31216460f, 0.06260140f, 0.16293015f, 
    -0.02380826f, -0.00980140f, -0.13222036f, 0.13756339f, 0.12805608f, -0.16177191f, 0.15594500f, 0.08219462f, 
    0.14787404f, -0.23277959f, 0.02770940f, -0.07579107f, -0.12816964f, -0.15259571f, -0.09096735f, -0.16587561f, 
    -0.07095182f, 0.03708990f, -0.10419506f, -0.01641187f, -0.08267374f, 0.18623213f, -0.03082228f, 0.04164022f, 
    -0.17180465f, -0.05577261f, -0.43338463f, 0.29245722f, 0.12958212f, 0.31350067f, 0.18363076f, 0.12386630f, 
    0.10938156f, 0.14006405f, 0.15985852f, 0.22919309f, 0.07025087f, 0.19410029f, 0.04434103f, 0.02707285f, 
    -0.15863170f, 0.25992370f, 0.08567058f, 0.19852033f, 0.14912052f, -0.29536894f, -0.32954958f, -0.17544684f, 
    -0.12435962f, -0.08376835f, -0.09459189f, 0.10872783f, 0.08264607f, -0.01015347f, -0.21328168f, 0.06122367f, 
    0.19758722f, 0.14475317f, -0.04016611f, -0.22501579f, -0.08863497f, -0.10989578f, -0.20136951f, -0.20435068f, 
    -0.05601243f, -0.22008577f, 0.11844862f, -0.01542156f, -0.13281691f, -0.20536223f, -0.01138221f, -0.07888065f, 
    -0.05351474f, -0.27878049f, 0.18437950f, 0.45568264f, 0.33253533f, -0.00502087f, 0.03185092f, -0.01386359f, 
    -0.05087753f, -0.15368681f, 0.04136560f, 0.59971011f, 0.19584055f, 0.08591304f, -0.19248211f, 0.01532828f, 
    0.00512197f, 0.25310701f, -0.01645733f, 0.08377940f, 0.08398838f, -0.09239740f, -0.10239166f, -0.11223847f, 
    -0.03064818f, -0.04377164f, -0.17708096f, -0.17402737f, -0.37194845f, -0.14884476f, 0.10732135f, 0.19741713f, 
    -0.19182321f, -0.14280783f, -0.22244947f, -0.05743822f, -0.18497103f, -0.00277981f, 0.29391447f, 0.11370270f, 
    -0.07382636f, -0.10333376f, 0.07361643f, 0.30671382f, 0.10911664f, 0.10408664f, 0.23108917f, 0.26063463f, 
    -0.08983398f, 0.12849516f, -0.00941375f, -0.05172965f, 0.10071651f, -0.07385818f, -0.07410357f, 0.30743179f, 
    0.19921158f, 0.34621716f, 0.31002027f, -0.06796253f, -0.25468212f, 0.41847003f, -0.03603873f, -0.24575368f, 
    -0.25645974f, -0.03374898f, -0.06445664f, 0.22691122f, -0.02604669f, -0.00516794f, 0.00652711f, 0.07376301f, 
    0.01421954f, 0.00710651f, -0.03726920f, 0.10115290f, 0.09990213f, 0.03371267f, -0.01131873f, 0.15513775f, 
    0.08034232f, 0.04829118f, 0.05819025f, 0.06932142f, 0.10043180f, 0.08182430f, -0.27991000f, -0.06178546f, 
    0.04236768f, -0.06328564f, 0.09675716f, -0.01859485f, 0.12936805f, 0.01627316f, 0.21628259f, 0.21432029f, 
    -0.05065862f, -0.16968514f, -0.05363360f, -0.20342968f, 0.13725328f, 0.06437010f, -0.00488577f, 0.17017213f, 
    0.04029636f, 0.13348319f, 0.11124979f, 0.12456386f, -0.07775211f, 0.04427857f, 0.10160680f, 0.01029169f, 
    -0.04932317f, -0.01264940f, -0.26628458f, -0.10232202f, -0.46915141f, 0.02696425f, 0.07749617f, 0.18627593f, 
    -0.04625249f, 0.03772000f, 0.25457177f, -0.01573814f, -0.10494912f, 0.06034170f, 0.09768708f, 0.02575674f, 
    0.04894332f, 0.05573467f, 0.00731234f, -0.06405409f, 0.23119122f, 0.08942147f, 0.15495931f, -0.08912718f, 
    0.01022279f, -0.05638028f, 0.04583047f, 0.01150911f, -0.08199020f, 0.20826009f, 0.11803253f, 0.00840287f, 
    -0.24564573f, -0.08422003f, 0.06679092f, -0.24287380f, 0.10599256f, -0.13475537f, 0.24261646f, -0.06280129f, 
    0.12010020f, -0.11554570f, 0.06176298f, -0.19536480f, -0.26155287f, -0.01958195f, -0.02599437f, 0.23877041f, 
    0.05632277f, 0.04015514f, 0.31104988f, 0.04481377f, 0.34009805f, 0.01148637f, 0.21868213f, 0.16944148f, 
    -0.05595143f, 0.06807273f, 0.10480667f, -0.18571085f, -0.08916600f, 0.15175098f, 0.12479852f, -0.08140120f, 
    0.14117835f, -0.19526218f, 0.19082335f, -0.21291476f, -0.52240062f, 0.41870898f, 0.44228038f, 0.00837856f, 
    0.23910104f, 0.32129127f, 0.06667019f, 0.04235104f, 0.16773263f, 0.23738420f, 0.27188125f, 0.28583351f, 
    -0.03542119f, 0.01287654f, 0.21749084f, 0.01629463f, 0.32234251f, 0.07693312f, 0.11651105f, 0.20404492f, 
    0.29844466f, -0.07706071f, 0.16295370f, 0.05862008f, -0.24967122f, -0.14931178f, 0.14532380f, -0.17321104f, 
    -0.04935158f, 0.00025005f, -0.02752049f, -0.07032061f, 0.09079253f, -0.10966656f, -0.10853122f, -0.15919060f, 
    0.02713553f, -0.13570604f, -0.02231168f, 0.04349587f, -0.12652406f, -0.15834256f, 0.05977411f, 0.03627597f, 
    0.04894469f, -0.09915345f, -0.04957758f, -0.06354152f, -0.04731279f, -0.01887586f, 0.00981874f, 0.05411075f, 
    0.12755094f, 0.18407120f, 0.14624278f, -0.08906089f, -0.09681092f, -0.08339870f, -0.20691292f, -0.07375017f, 
    -0.10667882f, 0.19641195f, 0.09893303f, -0.01021826f, 0.00298390f, -0.22479305f, 0.00351598f, -0.03754138f, 
    0.04362446f, 0.02829877f, 0.27603930f, 0.01925012f, -0.33201787f, 0.13945448f, 0.10486139f, -0.05387754f, 
    0.08162110f, 0.27921945f, 0.13803184f, 0.06260157f, 0.18465549f, -0.13758162f, -0.02997142f, 0.16008538f, 
    -0.06816632f, 0.05426994f, -0.08619910f, 0.13029346f, 0.08713336f, 0.06475399f, -0.35088661f, 0.13221177f, 
    0.30896819f, -0.05416621f, 0.12705065f, -0.08252140f, 0.07915656f, 0.27568129f, 0.15220127f, 0.02018620f, 
    0.15749580f, -0.07366045f, -0.17061898f, -0.23491502f, -0.26381990f, -0.00568349f, -0.03359728f, 0.03586403f, 
    -0.06798276f, 0.22556059f, 0.08789153f, -0.05260559f, -0.00789045f, -0.41512856f, -0.13915256f, -0.02750978f, 
    0.09947106f, -0.56023860f, -0.14708698f, 0.82640243f, 0.01065315f, 0.19946155f, -0.34207636f, -0.07934698f, 
    -0.01351163f, 0.05979365f, 0.00632759f, -0.03938604f, -0.08826260f, -0.10506728f, -0.11745321f, -0.28836507f, 
    0.11074282f, 0.05471641f, 0.06870652f, -0.14361246f, 0.09679055f, -0.27926734f, -0.03928969f, 0.01255650f, 
    -0.03200736f, -0.22698104f, 0.13126905f, 0.08227276f, -0.41477248f, -0.08588990f, 0.47306070f, -0.03295741f, 
    -0.01795348f, -0.08463211f, 0.07886190f, 0.11628570f, 0.11725871f, -0.06859751f, -0.01850406f, 0.17803934f, 
    -0.08408923f, 0.01789952f, -0.28332692f, 0.13755906f, 0.04652490f, -0.02461563f, -0.28211954f, 0.31904525f, 
    0.44262984f, 0.21597928f, 0.10084464f, -0.12010154f, 0.16509189f, 0.17454448f, -0.03348595f, -0.21046549f, 
    -0.00123138f, -0.40891281f, 0.17856683f, 0.04394311f, 0.11805417f, -0.01355753f, 0.05760669f, -0.07626922f, 
    -0.13649075f, -0.06059648f, -0.24326311f, 0.03165149f, 0.11852656f, -0.05159852f, 0.13479222f, 0.06989900f, 
    0.07055218f, 0.07657859f, -0.02445142f, -0.12356623f, -0.21840183f, -0.20391399f, -0.41353780f, 0.01210535f, 
    0.00980341f, 0.11600583f, 0.13969143f, -0.30148420f, 0.06316739f, 0.00144483f, -0.00027294f, 0.36470801f, 
    0.03809907f, -0.01317812f, 0.24204494f, -0.18070038f, -0.22074603f, 0.28566733f, 0.17689949f, -0.04208282f, 
    -0.12654735f, -0.03663408f, 0.15127416f, 0.04051014f, -0.14595686f, 0.03469994f, 0.05804835f, 0.03876273f, 
    -0.11697057f, -0.10558379f, -0.12344745f, 0.04919466f, -0.04806985f, 0.33697659f, -0.23488271f, -0.01190361f, 
    -0.02796373f, -0.04289585f, -0.01607530f, 0.05455067f, 0.14891939f, 0.06417027f, -0.04542814f, 0.14179672f, 
    -0.07537118f, 0.24982688f, -0.07315753f, -0.03780424f, 0.12544560f, 0.09364666f, 0.16893752f, -0.18994020f, 
    -0.11528381f, -0.12548260f, -0.04058057f, 0.11962052f, -0.08842178f, 0.30116650f, 0.01836965f, 0.09605033f, 
    -0.18249363f, -0.35882959f, 0.38682720f, -0.01549250f, 0.17098883f, -0.23749512f, 0.13796891f, 0.12906623f, 
    0.28111586f, -0.16477421f, -0.15156759f, 0.00439833f, -0.12091369f, 0.14810145f, -0.11494690f, 0.13281561f, 
    0.00560433f, 0.11894929f, 0.59749287f, -0.36933181f, 0.02436524f, -0.01391742f, 0.10957139f, 0.45854819f, 
    0.19928190f, -0.08106443f, -0.15970340f, 0.00381348f, -0.19327495f, 0.79769093f, -0.17347044f, -0.00060166f, 
    0.11489752f, 0.24280651f, -0.01457772f, 0.22330642f, -0.63448393f, -0.61836529f, 0.19933726f, 0.03297971f, 
    0.04679507f, -0.05185388f, 0.05917141f, 0.07428116f, 0.23867925f, -0.30758134f, 0.55026245f, 0.16908234f, 
    -0.16905718f, -0.18851024f, 0.31362844f, -0.14545238f, 0.24580996f, -0.22700918f, 0.02269058f, 0.16801754f, 
    0.34347481f, -0.02670057f, 0.16199827f, -0.01659479f, -0.02287312f, -0.00612950f, -0.00074511f, 0.00269958f, 
    0.16143763f, 0.17037857f, -0.02564063f, -0.02118402f, 0.03456804f, -0.06232055f, 0.17329660f, 0.03250387f, 
    0.06697671f, 0.10360335f, 0.01166581f, -0.06702194f, -0.00534796f, -0.03879313f, -0.15562472f, -0.08796152f, 
    0.09631698f, 0.08713501f, -0.01565414f, -0.01365071f, 0.14086904f, 0.00069593f, -0.09117886f, 0.03675605f, 
    0.00394899f, -0.00982896f, -0.00869158f, -0.27630574f, -0.06574930f, 0.14826030f, 0.09087329f, 0.14996845f, 
    -0.29759845f, -0.11964624f, 0.09114079f, -0.22684608f, -0.11924289f, 0.16806526f, -0.18899687f, -0.16916741f, 
    -0.13187413f, 0.23155388f, 0.05017819f, 0.00247268f, -0.02083743f, 0.01708958f, 0.05750976f, 0.15190272f, 
    0.03630318f, 0.24811171f, -0.10918032f, -0.13778716f, 0.09603881f, 0.23667334f, 0.40979040f, 0.09433315f, 
    0.19093007f, -0.15738121f, -0.04134048f, 0.03592496f, -0.03267641f, -0.25399351f, 0.04228503f, 0.00766769f, 
    0.00160082f, 0.00275253f, -0.04662862f, 0.12835631f, 0.03551476f, 0.03643363f, 0.18656182f, 0.12402990f, 
    -0.00351222f, 0.28579572f, 0.14130123f, 0.01576469f, 0.18062648f, -0.16454202f, 0.03344620f, 0.20236416f, 
    0.22980240f, -0.10379143f, 0.06458667f, -0.26672861f, 0.12305914f, 0.11798444f, -0.15750304f, -0.10975476f, 
    0.20899203f, 0.02345420f, 0.16900031f, 0.29891434f, -0.01171924f, -0.10498677f, 0.12185628f, -0.03304639f, 
    -0.06185919f, 0.08587059f, -0.27019373f, -0.54155982f, -0.08926509f, 0.06653936f, 0.08945845f, 0.08654237f, 
    0.17266729f, 0.10477395f, 0.06960452f, -0.05696366f, -0.11478420f, -0.36288390f, 0.00537945f, 0.25826731f, 
    0.06496228f, -0.03956855f, 0.18437022f, 0.04945334f, 0.03281539f, 0.01727563f, 0.19657981f, 0.01287275f, 
    0.03672301f, -0.10127845f, 0.21996664f, 0.09119180f, -0.02022646f, -0.24972565f, -0.34902114f, 0.14769289f, 
    0.08019330f, -0.01889488f, 0.17930909f, 0.11776471f, 0.14770366f, 0.04066645f, 0.13652092f, -0.12630601f, 
    -0.02132736f, -0.24870372f, 0.16278364f, 0.39103347f, -0.05377128f, 0.11348616f, -0.03053775f, -0.12830001f, 
    -0.18820508f, -0.29097813f, 0.06567870f, 0.03760743f, -0.07875717f, 0.13155407f, 0.02218287f, 0.20643912f, 
    0.00259025f, 0.03334501f, 0.07696355f, 0.10963584f, 0.12877968f, 0.11854336f, -0.17212740f, -0.00615322f, 
    0.02264205f, -0.03605474f, 0.03548265f, 0.15938874f, -0.01435472f, 0.20172837f, 0.14096349f, 0.09719433f, 
    0.10091691f, 0.13795960f, -0.25510171f, -0.16577519f, 0.01201314f, -0.05456014f, 0.11265912f, -0.08142499f, 
    -0.05470659f, 0.05616549f, 0.11837491f, 0.26714155f, 0.01780976f, 0.38714078f, 0.24221858f, -0.04517087f, 
    0.13636495f, 0.01603710f, -0.20803632f, 0.18309781f, -0.05541440f, -0.32789236f, -0.23227035f, 0.08290999f, 
    0.05269766f, 0.11637731f, -0.07970246f, -0.14833213f, 0.03601165f, -0.14705665f, -0.45043448f, -0.13503549f, 
    0.02502499f, -0.18144491f, -0.07360896f, -0.18127753f, 0.15538397f, -0.01048797f, 0.05107005f, 0.03602957f, 
    -0.00864725f, -0.01585307f, 0.16857989f, -0.19613940f, -0.09226608f, -0.01706512f, -0.01496442f, 0.05802270f, 
    -0.07260056f, -0.02516177f, 0.17080875f, 0.15368360f, 0.02088912f, 0.07303686f, -0.07560669f, -0.13319804f, 
    0.27443683f, 0.15965630f, -0.49183559f, 0.06915366f, -0.20774227f, 0.14949842f, -0.05510708f, 0.03858370f, 
    0.10845058f, 0.11143961f, 0.03480174f, -0.19571094f, 0.27953327f, 0.09743381f, -0.18246986f, 0.15022799f, 
    0.18138064f, 0.06052160f, -0.31948924f, -0.34437275f, -0.01822176f, -0.11141148f, -0.21471651f, -0.13850878f, 
    0.14382826f, -0.13322011f, -0.12363330f, -0.03340955f, 0.17553027f, 0.08285519f, 0.05100113f, -0.04943387f, 
    -0.19248363f, 0.06619851f, -0.08107689f, 0.33997139f, 0.06682234f, -0.05561493f, -0.04852207f, 0.09665135f, 
    -0.19671638f, 0.03927179f, -0.11979057f, -0.12721837f, -0.04760906f, 0.24336645f, -0.06046965f, 0.55319357f, 
    -0.04585037f, -0.15755874f, 0.28212699f, -0.24334881f, 0.07510865f, 0.01116922f, -0.11244434f, -0.25630322f, 
    0.11677803f, 0.05261287f, -0.06863116f, 0.03890999f, -0.25923184f, -0.07192613f, 0.05671684f, 0.10931748f, 
    0.30815724f, -0.42668495f, -0.12863378f, -0.21573438f, -0.00502654f, 0.01464467f, 0.05146845f, -0.07432331f, 
    -0.05298632f, -0.03195894f, 0.00106009f, -0.00223129f, -0.03761337f, -0.03772219f, -0.01699569f, -0.01869340f, 
    0.00507539f, 0.04530492f, 0.03477665f, -0.01268197f, -0.05158738f, -0.03909671f, -0.01367139f, -0.05756995f, 
    0.00326439f, 0.01045507f, 0.01059346f, -0.04946457f, 0.04985118f, -0.01802723f, -0.05817936f, -0.04562363f, 
    -0.04474639f, -0.04917603f, -0.03550784f, -0.01499865f, 0.03501928f, -0.01298952f, 0.03994818f, -0.03939641f, 
    -0.04028394f, 0.04386681f, 0.03029343f, 0.03559919f, -0.03079766f, 0.00357840f, -0.06260920f, -0.02914377f, 
    0.00262380f, 0.01729519f, -0.04211964f, 0.02243619f, 0.02443560f, 0.03931299f, 0.02609190f, -0.06336386f, 
    0.02220454f, -0.00694356f, -0.02512617f, 0.00401375f, 0.02012034f, -0.06324110f, -0.05539708f, 0.04646540f, 
    0.02796782f, -0.05787963f, -0.03721410f, -0.04227290f, -0.00321296f, -0.03695053f, -0.00576654f, -0.04794539f, 
    0.03204136f, -0.00269158f, -0.05245467f, 0.03864473f, 0.02093014f, 0.01834289f, 0.02241909f, 0.03289288f, 
    0.02568800f, 0.04457581f, 0.00220116f, 0.04077621f, -0.01090198f, -0.01338402f, 0.05176995f, 0.04789773f, 
    0.00343425f, -0.06266276f, -0.03187399f, 0.00646019f, -0.00053684f, -0.04130033f, -0.05093209f, -0.01526013f, 
    0.04217785f, 0.01329800f, -0.00540071f, 0.04134101f, 0.01787050f, 0.03055562f, 0.00386608f, -0.04019543f, 
    -0.05006633f, 0.04544041f, -0.06660034f, -0.03384860f, -0.00279268f, 0.01214906f, -0.05709684f, -0.04889604f, 
    0.04889285f, 0.04890157f, 0.01844274f, -0.02498474f, -0.05468173f, -0.00585122f, 0.04838028f, -0.00889058f, 
    -0.03768432f, 0.02801428f, 0.00654967f, 0.02574482f, -0.00120056f, -0.01397042f, 0.02605697f, 0.03255990f, 
    -0.01080164f, -0.03073711f, -0.01110202f, 0.04518256f, -0.04206298f, -0.04636022f, -0.03311472f, -0.02454708f, 
    -0.06323543f, -0.00878134f, -0.01460544f, 0.00790701f, -0.06326345f, -0.04469728f, -0.06292892f, -0.05118596f, 
    0.03658310f, -0.02439606f, -0.02239283f, -0.01056019f, 0.03746805f, -0.05286568f, -0.04182206f, -0.01751573f, 
    -0.00406299f, 0.01799138f, 0.03992317f, -0.01031971f, -0.06006868f, 0.04680573f, 0.01118775f, 0.00863723f, 
    -0.04104222f, 0.00528446f, 0.00576388f, -0.04053306f, -0.00315033f, 0.02029407f, 0.00268808f, 0.04089087f, 
    0.03528240f, -0.01811792f, 0.03998793f, 0.03251852f, -0.01205231f, -0.04099033f, 0.04826840f, -0.03303346f, 
    0.04782626f, 0.01922323f, 0.01381292f, -0.02845443f, -0.01989516f, 0.02522447f, 0.00920566f, -0.01204720f, 
    -0.04326694f, -0.00757533f, 0.01698517f, 0.02979322f, -0.00726400f, -0.00624666f, -0.05313509f, 0.04843411f, 
    -0.05091043f, -0.02448603f, -0.05026583f, -0.04537670f, -0.06776839f, -0.04889554f, 0.02479949f, -0.05776013f, 
    -0.06110659f, 0.01384482f, 0.04619945f, -0.01990577f, 0.04866662f, -0.01883476f, -0.01310560f, -0.02510073f, 
    -0.06675731f, -0.04401890f, 0.00054140f, -0.04502102f, -0.05065595f, -0.05220427f, -0.02108385f, 0.02204953f, 
    0.02069080f, -0.05202756f, 0.01543285f, -0.02812807f, 0.03003950f, 0.04220686f, 0.02293656f, -0.00041074f, 
    0.03303884f, -0.05124409f, -0.05716058f, 0.04828395f, 0.04215100f, -0.05660828f, 0.03081176f, 0.03670179f, 
    -0.05576930f, -0.01996890f, -0.05681203f, -0.04811770f, 0.05116154f, -0.04196864f, 0.02089929f, -0.02316219f, 
    -0.06375182f, -0.03815397f, 0.00299100f, -0.01574100f, 0.03361384f, -0.00949729f, -0.00045456f, -0.03691151f, 
    -0.05611041f, -0.01843369f, -0.06730802f, -0.00580379f, 0.00037961f, -0.06707150f, 0.00163291f, -0.00667582f, 
    0.00280908f, 0.05021775f, 0.04828658f, 0.01986773f, -0.05445523f, -0.04517582f, -0.04259588f, -0.02740144f, 
    0.00707089f, -0.03829463f, 0.04051966f, 0.04529053f, 0.01113311f, 0.04492214f, 0.01626295f, -0.00003513f, 
    0.03118571f, 0.02781828f, -0.04850407f, -0.01992447f, 0.00582939f, 0.03347825f, -0.05020233f, 0.05343406f, 
    0.01487252f, -0.00314003f, -0.05473736f, 0.03153995f, -0.02526415f, 0.04351409f, 0.04831313f, -0.01496709f, 
    0.00579606f, -0.05923163f, -0.05374464f, -0.05535463f, 0.00409539f, 0.00800692f, -0.01427882f, -0.02288662f, 
    -0.14904021f, -0.02231397f, 0.00995763f, -0.08446547f, 0.17780460f, -0.00894335f, 0.12485965f, 0.16131096f, 
    0.33213493f, 0.25517666f, 0.14161305f, 0.07597852f, -0.00199219f, -0.07591671f, 0.09698388f, 0.03176756f, 
    0.09458577f, -0.28558317f, -0.12786466f, -0.05753313f, 0.05464938f, 0.23090747f, 0.12409388f, 0.15440269f, 
    -0.18673055f, -0.35605630f, -0.34529623f, 0.09123614f, 0.02024615f, 0.42869791f, 0.02742982f, 0.11280477f, 
    -0.06493895f, 0.25032705f, 0.09356777f, 0.07504314f, 0.00492413f, 0.19334455f, -0.01141206f, 0.03624405f, 
    -0.06171833f, 0.25914708f, 0.20050648f, 0.28409374f, 0.13100915f, 0.29145509f, 0.28634712f, -0.20733109f, 
    0.17507747f, -0.06105022f, 0.18425275f, 0.01895603f, -0.11263268f, -0.18430743f, 0.27523947f, 0.53816473f, 
    -0.23939811f, 0.07142798f, 0.08403656f, 0.05778562f, -0.17802596f, -0.24781504f, 0.08567549f, -0.03179962f, 
    -0.10867886f, -0.01723432f, 0.09072651f, 0.14096348f, -0.20243184f, -0.10208277f, -0.20978011f, -0.03962163f, 
    0.10208402f, 0.06683905f, 0.18223758f, 0.15159866f, 0.03011074f, 0.04504333f, -0.09213864f, -0.04010083f, 
    -0.14173639f, 0.34941897f, 0.36194849f, 0.07365216f, 0.08462169f, -0.07018459f, -0.01473475f, -0.05755994f, 
    0.03176295f, 0.36011788f, -0.20087637f, -0.10983840f, 0.01495014f, -0.15230662f, 0.03539568f, 0.05473182f, 
    -0.24852455f, -0.13031872f, -0.38332048f, 0.15534683f, -0.12169386f, -0.37395680f, -0.06562293f, -0.09094004f, 
    -0.15050764f, -0.10399214f, -0.21906298f, 0.02867149f, 0.09134652f, 0.10541749f, -0.07102849f, -0.07044049f, 
    -0.19248503f, 0.02660814f, 0.03108629f, 0.10484501f, 0.23509717f, -0.50336874f, -0.04012970f, 0.05940078f, 
    -0.13895811f, 0.02425652f, 0.09629744f, -0.05508986f, 0.15421075f, -0.01680142f, 0.12100653f, 0.14713106f, 
    0.13456336f, 0.25559846f, -0.07323521f, 0.24192254f, 0.23587877f, 0.09632647f, 0.06941131f, -0.05220708f, 
    -0.07158209f, -0.31810474f, -0.24786310f, 0.03517209f, -0.04750901f, 0.05318628f, -0.15036653f, 0.10565997f, 
    -0.04839415f, -0.04166095f, 0.04295894f, -0.04479660f, -0.07008690f, -0.10771409f, 0.01319055f, 0.03514512f, 
    0.11239287f, -0.21803676f, 0.07020004f, 0.01906883f, -0.07300524f, -0.00245763f, -0.07824959f, 0.09694343f, 
    0.12923518f, 0.19336312f, -0.04117326f, -0.08436844f, 0.13380542f, 0.15001976f, 0.17475209f, -0.16345768f, 
    -0.05916067f, -0.09499958f, -0.02245083f, 0.12980480f, 0.14685023f, -0.15114103f, 0.11962440f, 0.08228724f, 
    0.11870947f, 0.16580911f, 0.14969173f, 0.08535274f, -0.17061990f, -0.04805524f, 0.01384426f, -0.05618349f, 
    0.15740643f, 0.18892577f, -0.35918251f, -0.56188589f, -0.38038835f, -0.09791011f, -0.12806186f, -0.02374665f, 
    0.14602157f, -0.20738424f, 0.01234782f, -0.16504647f, -0.06583171f, 0.02471750f, -0.01336084f, 0.09348980f, 
    0.07253926f, -0.26508451f, 0.09914795f, -0.14159521f, 0.09170543f, 0.19336970f, 0.20960097f, -0.00102181f, 
    -0.03224282f, 0.05528350f, -0.02868011f, -0.05243230f, -0.04217574f, 0.14041024f, 0.21428277f, 0.09841924f, 
    0.33891746f, 0.26807421f, -0.30491149f, 0.09396839f, -0.04255612f, 0.14378160f, 0.01031848f, -0.00866718f, 
    -0.05743464f, 0.11600654f, 0.10864825f, -0.22041830f, -0.10376055f, 0.02978921f, 0.02979816f, 0.07102661f, 
    0.06905455f, 0.18155576f, -0.20523039f, -0.05848408f, 0.15569818f, 0.12874182f, 0.06095570f, -0.05083409f, 
    -0.12977692f, -0.08910123f, 0.06484500f, -0.34798989f, -0.17144786f, -0.23200569f, -0.03087497f, 0.19324000f, 
    0.14530747f, -0.06733833f, -0.07155482f, -0.04865820f, 0.29428098f, 0.19029030f, -0.10371186f, 0.20615467f, 
    -0.04561827f, 0.11311170f, 0.21192846f, 0.20299560f, -0.03829740f, -0.05382544f, 0.16281052f, 0.46463773f, 
    -0.22625284f, 0.02747756f, 0.19383007f, -0.12592177f, 0.18173157f, -0.11605752f, -0.05820008f, 0.02120870f, 
    0.06839857f, -0.02852474f, 0.15816766f, 0.08932797f, 0.06928953f, 0.15831116f, 0.07346639f, 0.06822895f, 
    0.06729481f, -0.19291210f, -0.05351217f, 0.05078508f, -0.05092174f, 0.14132567f, -0.20640485f, -0.19603470f, 
    0.01929285f, 0.08614118f, -0.06236985f, -0.07784706f, 0.12395553f, -0.19187652f, 0.21650408f, 0.12661435f, 
    0.27111673f, -0.06839116f, 0.16263403f, 0.36696449f, 0.03803132f, 0.18025130f, -0.01565304f, 0.07376412f, 
    0.10801112f, 0.01629938f, -0.28328276f, -0.27165109f, 0.17690510f, -0.13785920f, -0.12771891f, -0.24123935f, 
    0.09065969f, -0.05427971f, 0.07295829f, -0.48606852f, -0.73673767f, 0.16253760f, 0.05490629f, -0.11298910f, 
    -0.06016472f, -0.00798109f, 0.14970633f, 0.23196024f, -0.04137245f, 0.11736507f, -0.52934200f, -0.16540991f, 
    -0.34914187f, 0.30452099f, -0.00369707f, -0.08067853f, 0.04658974f, 0.17121740f, 0.11475030f, 0.16999705f, 
    0.01782835f, -0.01426834f, -0.12359309f, -0.02651742f, 0.07315483f, 0.05797280f, 0.02197769f, 0.15452583f, 
    0.13796516f, -0.09576742f, 0.07205671f, 0.01626346f, 0.18507902f, 0.04684190f, -0.00559765f, 0.42576286f, 
    -0.13299814f, 0.39418906f, -0.80243194f, -0.01245568f, -0.06285904f, 0.22614613f, 0.10091133f, 0.27686140f, 
    -0.84509116f, -0.84623224f, 0.30620095f, -0.40361968f, -0.10065615f, 0.33104143f, 0.05525907f, 0.23719712f, 
    0.02324206f, 0.21571510f, -0.54619765f, 0.27461690f, -0.10581402f, -0.05935875f, 0.14339064f, -0.13341674f, 
    0.02451941f, -0.15302050f, 0.52612448f, -0.56604171f, -0.06073109f, -0.05629594f, -0.19788842f, -0.47587025f, 
    0.05904262f, 0.05890261f, -0.18458784f, 0.33236122f, -0.31561631f, -0.17713778f, -0.10732256f, 0.03534805f, 
    -0.05795604f, 0.02305016f, 0.03996116f, -0.07908713f, 0.25503036f, 0.09481114f, 0.21747647f, -0.02422084f, 
    0.06879723f, -0.21326210f, -0.08530933f, 0.17625548f, 0.05353763f, 0.06825911f, -0.93857861f, -0.54824519f, 
    -0.20437141f, -0.06148152f, -0.24815565f, -0.04032671f, -0.07400139f, 0.18682049f, 0.38646036f, -0.92198223f, 
    -0.01672721f, -0.14564079f, -0.01023949f, 0.17447752f, -0.24560292f, 0.24809226f, 0.07591790f, 0.45820534f, 
    -0.19077131f, -0.54943395f, -0.01305209f, -0.08584741f, -0.01571424f, 0.03601822f, -0.01456447f, 0.08187639f, 
    0.06907400f, -0.10454417f, -0.38191119f, -0.33238688f, 0.20581059f, 0.37083289f, 0.14477246f, 0.17496397f, 
    0.02648745f, -0.04877011f, 0.01957630f, -0.48955366f, 0.20283531f, 0.18236902f, -0.09396742f, 0.11183656f, 
    0.28055379f, 0.07867586f, 0.39644098f, -0.31840938f, -0.17328334f, 0.11308500f, -0.16317286f, -0.22531494f, 
    -0.01093032f, -0.01638377f, -0.22966743f, -0.29977643f, 0.27554238f, 0.19181326f, -0.24548930f, 0.12466261f, 
    -0.05046817f, -0.05147861f, -0.03975557f, 0.05822298f, -0.91944307f, -0.45199221f, -0.37218526f, -0.04048409f, 
    -0.21801095f, -0.04091075f, 0.21327813f, -0.06677278f, -0.35554659f, -0.33146659f, -0.10049836f, 0.12710075f, 
    -0.10737690f, -0.24045072f, 0.02279164f, -0.12005287f, -0.02686739f, -0.06370311f, -0.26243356f, 0.07446808f, 
    0.30309683f, -0.15454698f, 0.15066497f, 0.05282154f, 0.04125449f, 0.10926343f, 0.22147809f, -0.05016093f, 
    -0.04270461f, -0.42329925f, 0.00891330f, -0.06445233f, 0.13792087f, 0.09286686f, 0.15223372f, 0.11017535f, 
    0.31288090f, 0.19332083f, 0.26579708f, -0.09629866f, -0.08759613f, 0.06989345f, 0.03639957f, -0.06854414f, 
    0.01046696f, 0.22082964f, 0.35676739f, 0.29143927f, 0.00054772f, -0.04885388f, -0.18956581f, 0.20309311f, 
    0.07029749f, 0.11955302f, 0.45414820f, -0.47245917f, -0.88469428f, -0.00318918f, -0.06963158f, -0.07587500f, 
    0.12600833f, 0.02948367f, -0.08311326f, -0.17964093f, -0.76668894f, 0.34634480f, 0.25967333f, -0.41350451f, 
    -0.29359478f, 0.00334097f, 0.20037803f, -0.08225145f, 0.06499192f, 0.18314077f, -0.09032004f, 0.04484434f, 
    0.22160573f, 0.55676532f, 0.09886256f, 0.11597200f, 0.11005509f, -0.90158808f, -0.47813883f, 0.29012993f, 
    0.12005148f, 0.08861665f, -0.04134322f, 0.34961304f, 0.17107561f, 0.16134122f, 0.02261034f, -0.83143067f, 
    0.47311977f, -0.26299259f, -0.06141184f, -0.01108184f, 0.04464526f, -0.24441841f, -0.07666979f, 0.19986984f, 
    -0.00012618f, 0.22723792f, 0.18485723f, 0.01486030f, 0.01979319f, 0.17410818f, -0.04281814f, -0.00608593f, 
    0.03694944f, -0.02469848f, 0.06290489f, -0.01256127f, 0.03511063f, -0.01756372f, 0.04690858f, -0.02768289f, 
    0.00352215f, -0.02462863f, 0.04036686f, 0.01485134f, -0.00381700f, 0.04712067f, 0.01193842f, -0.04114696f, 
    0.01799401f, -0.02778302f, 0.03475596f, 0.04306791f, 0.04824090f, 0.04076977f, 0.02344350f, -0.02095674f, 
    -0.04518033f, -0.00609748f, 0.02275900f, 0.00697777f, 0.02144177f, -0.00490845f, -0.05348721f, 0.02868804f, 
    -0.03678521f, -0.00183701f, 0.01905822f, 0.04917058f, -0.06617666f, 0.01849107f, -0.01964421f, -0.03064250f, 
    -0.05747522f, 0.04913605f, 0.02029989f, 0.05004021f, 0.01907319f, -0.00869366f, 0.00839018f, 0.02064212f, 
    -0.00810338f, -0.02441562f, -0.03791862f, 0.01588807f, -0.01237448f, -0.01384125f, 0.04706521f, -0.02155358f, 
    0.03971993f, -0.00124682f, 0.03812286f, 0.04499486f, 0.00645545f, -0.02276387f, -0.00088160f, 0.02555965f, 
    0.02084767f, -0.00809038f, -0.01782794f, 0.01061436f, -0.00152345f, -0.01723542f, -0.00919434f, -0.01268555f, 
    0.00559331f, -0.02194996f, 0.02044566f, -0.03261656f, -0.02010925f, 0.01628624f, -0.06007903f, 0.01908343f, 
    -0.06715611f, 0.03674990f, 0.03870381f, -0.00728320f, 0.03201783f, -0.05264610f, 0.00692109f, 0.01959374f, 
    -0.03841573f, -0.05018819f, 0.02482630f, 0.00340853f, -0.05152280f, -0.04551000f, -0.04545751f, -0.02375360f, 
    -0.05420484f, 0.02543998f, 0.04022772f, -0.05147149f, -0.01591592f, -0.05509067f, 0.00748430f, -0.02912855f, 
    -0.01341491f, -0.04868774f, -0.01395300f, -0.02665126f, -0.04131556f, -0.01749155f, 0.00337298f, 0.00918135f, 
    0.04954435f, 0.01311131f, -0.06481022f, -0.04542931f, 0.03668118f, -0.00956091f, -0.03067230f, -0.02539691f, 
    0.02950270f, 0.05172475f, -0.05309239f, -0.05130190f, 0.04499498f, -0.01593425f, 0.03757043f, 0.00074370f, 
    -0.02756734f, -0.03438253f, -0.04793094f, 0.03144058f, -0.03163722f, 0.02878208f, -0.01049732f, -0.04176611f, 
    0.01062174f, -0.06321293f, -0.05521339f, -0.03482659f, 0.04851890f, -0.03949376f, -0.05680250f, 0.02254437f, 
    0.02090937f, -0.04427161f, -0.06024880f, -0.02755120f, -0.03948982f, -0.00743272f, 0.02477879f, 0.04421750f, 
    -0.00986504f, -0.05848950f, 0.01901760f, 0.04398220f, -0.02878701f, 0.02754587f, -0.05050407f, 0.01777537f, 
    0.01275008f, 0.01176936f, -0.00449391f, 0.00263503f, -0.03543929f, 0.01763418f, -0.01965947f, 0.00412571f, 
    0.00909976f, 0.02938035f, 0.01939229f, 0.03235307f, -0.01282669f, -0.01555804f, -0.03267117f, 0.03172400f, 
    -0.05754144f, 0.05254376f, 0.03722039f, -0.03392750f, 0.03198215f, -0.04368870f, 0.04211927f, -0.03832232f, 
    -0.05597695f, 0.02651568f, -0.00779016f, -0.02097822f, 0.02215964f, 0.03025462f, -0.04795680f, 0.04000201f, 
    -0.03483183f, -0.02940655f, -0.06112845f, -0.05866416f, 0.01471091f, 0.04003068f, -0.02394079f, 0.00243885f, 
    -0.05681010f, -0.05896571f, 0.03436759f, -0.05696645f, -0.03978817f, 0.02850164f, -0.05984567f, 0.00235434f, 
    -0.02477122f, 0.01406572f, 0.04066384f, 0.04404812f, -0.04821663f, -0.04948986f, 0.01860184f, -0.06582594f, 
    0.01702262f, -0.05784950f, 0.00411164f, 0.01406756f, -0.02330501f, -0.06169391f, -0.04807286f, -0.04259137f, 
    0.03356127f, -0.00632836f, -0.02770100f, -0.00925471f, 0.01961309f, 0.00230881f, -0.05549790f, -0.02136300f, 
    0.01828966f, -0.00370084f, -0.05736497f, 0.03858473f, -0.02665156f, 0.00014849f, -0.05963927f, -0.04362947f, 
    0.04679245f, 0.03709744f, -0.03426978f, 0.03733042f, 0.01221157f, -0.04893751f, -0.04308782f, 0.04329922f, 
    0.00958470f, 0.06177050f, 0.01414503f, -0.02750154f, 0.01396688f, -0.00749065f, 0.04471203f, -0.05043840f, 
    0.00094329f, -0.03941283f, -0.01874572f, -0.01619956f, -0.00525087f, 0.02091254f, -0.05901456f, -0.04049810f, 
    0.00139075f, -0.06480187f, 0.04794734f, -0.04152228f, -0.05704810f, -0.01907207f, -0.01589187f, 0.04351395f, 
    -0.06511793f, 0.03044431f, -0.00066705f, -0.01265258f, 0.04334187f, -0.03717688f, 0.04194887f, -0.03290760f, 
    0.00568386f, 0.02609904f, -0.04377726f, -0.06460226f, -0.06144259f, -0.00373616f, -0.05800178f, -0.03138103f, 
    0.24932577f, 0.09898292f, 0.11806872f, -0.13952710f, -0.08709101f, -0.18676046f, -0.00159738f, 0.17964742f, 
    0.17255346f, 0.18832523f, 0.20909856f, 0.34933403f, 0.18857801f, 0.21365015f, -0.05511403f, 0.01809829f, 
    -0.02014408f, -0.26913461f, 0.14215378f, 0.31099612f, 0.14829490f, -0.02389588f, 0.01098106f, 0.01751515f, 
    0.00243255f, 0.09833129f, -0.15422551f, 0.01500789f, -0.14212355f, -0.04879957f, -0.03120371f, -0.19993736f, 
    -0.27971211f, 0.20632648f, 0.16496140f, 0.09253242f, -0.26491600f, -0.00850372f, -0.13680415f, -0.06831323f, 
    -0.14123827f, -0.04140757f, -0.02559264f, -0.02846514f, 0.12044813f, 0.12430003f, 0.17205651f, 0.04818409f, 
    0.15734982f, -0.01426475f, -0.23598498f, 0.02047217f, -0.06789531f, -0.01583222f, 0.54332763f, 0.63559413f, 
    0.14566430f, 0.08269011f, 0.22744367f, -0.14882654f, 0.08837521f, 0.00808799f, -0.10513006f, 0.04379283f, 
    -0.10046883f, -0.00893443f, 0.00563585f, 0.04619091f, -0.11783312f, -0.09238083f, 0.12034183f, -0.06413675f, 
    -0.09379129f, -0.46241575f, 0.19333197f, 0.08371209f, -0.06275029f, 0.07162429f, 0.00132675f, 0.04368328f, 
    0.16872731f, 0.57719600f, -0.01824298f, -0.12647766f, 0.00041415f, -0.31278029f, 0.12022956f, -0.15910569f, 
    -0.11661512f, -0.16515209f, -0.36490887f, -0.32424957f, -0.32849067f, 0.09860190f, 0.03372052f, 0.06769459f, 
    -0.02550879f, 0.04212104f, 0.05590433f, 0.38335901f, 0.07034855f, -0.06900155f, 0.20231645f, 0.01184074f, 
    -0.03150212f, -0.13486716f, -0.07920459f, -0.28463766f, 0.31149697f, 0.11054737f, -0.06194444f, 0.19639617f, 
    0.23879375f, 0.05162203f, -0.16098684f, 0.04589215f, 0.18363507f, -0.20684586f, -0.28788903f, -0.57642692f, 
    -0.19297330f, -0.42540017f, -0.02716158f, 0.02692765f, 0.10598360f, 0.09351550f, -0.18184282f, -0.04288509f, 
    0.15492032f, 0.05365883f, -0.21005267f, -0.03886065f, -0.40504462f, 0.04022348f, -0.01363074f, 0.24494378f, 
    -0.05213442f, -0.26883397f, 0.27267456f, 0.23466565f, -0.02631275f, -0.12045078f, 0.12939332f, -0.14900349f, 
    -0.17802976f, -0.20276988f, -0.11173818f, -0.08824376f, 0.08622693f, 0.03834834f, -0.13116659f, -0.03590547f, 
    -0.08262526f, 0.00389389f, -0.10392372f, -0.09824614f, 0.09181143f, -0.03183778f, 0.01794194f, 0.05637698f, 
    0.06390566f, 0.00323659f, -0.07525770f, -0.27022430f, -0.18883736f, 0.11125827f, -0.10875987f, 0.00731748f, 
    0.03877448f, -0.07284761f, -0.18938586f, 0.21932940f, 0.51075274f, -0.01063232f, -0.22653039f, -0.10690796f, 
    -0.21347049f, -0.10200295f, 0.17874053f, 0.07912440f, -0.23012039f, 0.03622569f, 0.11534961f, -0.10032193f, 
    -0.04555890f, -0.00678530f, 0.11209504f, 0.10717635f, -0.03464241f, -0.38373420f, 0.03541108f, -0.28647035f, 
    -0.00261929f, -0.10221256f, 0.01244656f, -0.08103427f, -0.02427616f, -0.09106579f, 0.00821106f, 0.09700163f, 
    0.22674817f, -0.06128019f, 0.10189570f, -0.02342561f, 0.09683336f, 0.09746359f, 0.17093854f, 0.03844847f, 
    -0.15890022f, -0.10496853f, -0.01625998f, 0.07940833f, 0.13313408f, -0.08698172f, 0.10884673f, 0.09949819f, 
    0.29801837f, 0.37763125f, 0.30043224f, -0.02046437f, -0.15015960f, 0.17146225f, -0.10909548f, 0.02931537f, 
    0.03374720f, 0.24323981f, 0.33307007f, 0.30616939f, 0.04293805f, 0.16035998f, -0.08669334f, -0.29567209f, 
    0.18333565f, 0.18219738f, 0.17280385f, -0.27974266f, -0.55137670f, 0.06039985f, 0.03474088f, -0.15557249f, 
    0.02674571f, -0.14340858f, -0.00284856f, -0.19866687f, -0.59581941f, 0.11218330f, -0.19797219f, -0.10839912f, 
    0.04774122f, -0.00528269f, 0.12526971f, -0.17088620f, 0.51905680f, 0.28445739f, -0.18136998f, -0.23525193f, 
    0.47063017f, 0.09210458f, -0.11201483f, 0.21709388f, -0.04946594f, -1.25296986f, -0.59709352f, 0.23307618f, 
    -0.03077562f, -0.26019409f, 0.09597278f, 0.15576810f, -0.02576495f, 0.09384362f, -0.22174132f, -0.14720543f, 
    -0.14213802f, -0.07790801f, -0.05295659f, -0.07226068f, 0.15759474f, -0.03211285f, -0.24066301f, 0.31352362f, 
    0.18445934f, 0.07695567f, 0.11959814f, 0.05312904f, -0.13125223f, 0.05302439f, -0.12845382f, -0.12883130f, 
    -0.46560878f, -0.68716240f, 0.08229412f, 0.21092550f, -0.05601316f, -0.09545364f, -0.02344328f, 0.20386779f, 
    0.10033529f, 0.00225220f, 0.02287033f, -0.01395606f, 0.06601831f, -0.05562649f, -0.18278758f, 0.13835502f, 
    -0.01379656f, 0.01615281f, -0.19675958f, 0.04834124f, 0.03353581f, -0.05807905f, -0.18811716f, -0.03440257f, 
    0.09159703f, -0.10743185f, -0.17002878f, -0.68520385f, -0.39589557f, -0.02592398f, 0.14720690f, -0.06759904f, 
    -0.14554134f, 0.11398148f, 0.27514803f, 0.22003661f, -0.04209782f, -0.13565561f, 0.12370379f, -0.12360158f, 
    0.11860731f, -0.06553330f, 0.05067876f, 0.18618159f, 0.21995252f, -0.23835106f, -0.00976751f, -0.00819352f, 
    0.08549362f, -0.07643931f, -0.08025032f, 0.10990768f, 0.11313549f, 0.08415478f, -0.30306256f, 0.33279395f, 
    0.49366167f, 0.05109197f, -0.12414031f, 0.06591796f, 0.00544786f, -0.13598359f, -0.30375612f, -0.37305328f, 
    -0.41897735f, -0.00898804f, -0.77097118f, -0.60540003f, -0.65017790f, -0.06638122f, -0.11993587f, -0.02622973f, 
    -0.01330349f, 0.19809563f, 0.05014602f, 0.04581627f, -0.15368780f, 0.10234343f, 0.03925552f, 0.03073385f, 
    -0.15996076f, -0.24474195f, 0.43785685f, 0.12648821f, 0.00568089f, -0.16059278f, -0.10909163f, 0.19515376f, 
    -0.02251997f, 0.12076027f, -0.37309670f, -0.01242161f, -0.18574719f, -0.12033371f, -0.16869150f, 0.05845396f, 
    -0.10493873f, 0.03814695f, 0.06986166f, -0.12209319f, 0.73311275f, 0.28604057f, -0.06072402f, -0.00949552f, 
    -0.19979136f, 0.10160753f, -0.00684692f, 0.03232472f, -0.31147131f, 0.29631642f, -0.03650886f, 0.16271645f, 
    -0.04301598f, 0.12977153f, 0.10429598f, 0.10590907f, 0.18854302f, -0.66244912f, -0.02897612f, -0.71793890f, 
    0.04604794f, -0.15156285f, -0.07133488f, 0.08967412f, 0.23428833f, 0.32835871f, -0.20753156f, 0.23245627f, 
    -0.12571783f, -0.39322320f, 0.08347218f, 0.07645373f, -0.19815862f, 0.10527343f, 0.30473372f, -0.05699786f, 
    0.37280244f, 0.06412053f, -0.03211258f, -0.02922053f, -0.02876936f, 0.09270025f, 0.15585251f, 0.20926684f, 
    -0.19103937f, -0.12181496f, 0.04257778f, -0.20195736f, 0.10304023f, -0.05050268f, 0.03471323f, 0.13073140f, 
    0.23150498f, -0.56485707f, -0.14878029f, -0.16720130f, -0.06238760f, -0.16272381f, -0.20633312f, -0.09265821f, 
    -0.17552063f, 0.05124175f, 0.13819319f, 0.12453374f, -0.04757850f, -0.01633362f, 0.15179202f, -0.03679112f, 
    -0.02992229f, 0.02713857f, 0.13368620f, -0.46791172f, -0.23698470f, 0.25491875f, 0.02324668f, -0.15288720f, 
    -0.10059077f, -0.04969777f, 0.30962932f, 0.04634041f, -0.06144819f, -0.11801258f, 0.03379112f, -0.10364185f, 
    -0.01503026f, 0.12717976f, 0.06468456f, -0.14843930f, -0.42938355f, 0.17303500f, 0.10803524f, 0.20337683f, 
    0.36839542f, 0.03139834f, -0.12736090f, -0.00196072f, 0.13124822f, 0.22039409f, 0.29358089f, -0.51144302f, 
    0.28558373f, 0.10750479f, -0.10614967f, 0.08681968f, 0.09372105f, 0.18622796f, 0.14605054f, -0.13148202f, 
    0.03371090f, -0.18841679f, -0.15921517f, -0.03013827f, 0.12859529f, 0.13791668f, 0.30549124f, 0.21873544f, 
    -0.29713461f, 0.19806281f, 0.45390815f, -0.01250681f, -0.09651731f, 0.02650885f, 0.11695491f, 0.05316000f, 
    -0.11314272f, -0.21908484f, -0.29467300f, 0.06319863f, 0.04743354f, -0.03144815f, 0.09769412f, 0.07283589f, 
    0.22040635f, 0.10521079f, 0.73512673f, -0.32566622f, -0.13682005f, 0.25835440f, -0.14581832f, -0.04042793f, 
    -0.08667426f, 0.16945028f, 0.14089164f, -0.45525897f, -0.10103092f, 0.17880350f, -0.10901596f, -0.17760015f, 
    -0.28194872f, -0.27652934f, 0.13382381f, -0.17265324f, 0.09635951f, -0.49641401f, -0.11514495f, -0.28211007f, 
    -0.10228509f, -0.01685546f, -0.28603619f, 0.13454781f, -0.02233770f, -0.02417580f, -0.13059814f, -0.35299706f, 
    -0.14542842f, 0.04121435f, 0.10629223f, 0.04293527f, -0.04221277f, 0.21820696f, -0.15176295f, -0.23584296f, 
    -0.16150300f, -0.22188869f, 0.28031859f, 0.04327910f, 0.10523430f, -0.02208229f, 0.29077423f, -0.18963602f, 
    0.45545137f, 0.12137802f, 0.03144537f, -0.01316028f, -0.18793017f, 0.10538476f, 0.11123455f, -0.15705886f, 
    0.05583067f, 0.36590055f, -0.20026979f, 0.03837810f, -0.24764046f, 0.03188790f, 0.03276661f, -0.01965140f, 
    -0.15497936f, -0.05648670f, -0.18504584f, -0.19508140f, 0.07572548f, -0.07226555f, 0.08348574f, 0.07807258f, 
    -0.02093095f, 0.15771116f, 0.04525965f, 0.07178919f, -0.06339217f, -0.12027872f, -0.22392046f, 0.04404931f, 
    0.06666954f, 0.11709283f, 0.29949942f, -0.52445674f, -0.23882428f, -0.35886329f, 0.11739351f, -0.17503968f, 
    -0.09807345f, -0.25325674f, -0.12668605f, -0.00266012f, -0.04756463f, 0.12353791f, 0.04294854f, -0.18680374f, 
    0.05855845f, 0.00214134f, 0.17992328f, 0.02495489f, 0.06244090f, 0.04469942f, 0.01329192f, 0.20341298f, 
    -0.04105825f, -0.06992340f, -0.03831174f, 0.15468435f, 0.00587697f, 0.09525979f, -0.43677664f, -0.24526002f, 
    0.10058720f, -0.21006817f, 0.11062028f, -0.17585844f, 0.08233365f, 0.01363714f, 0.17360561f, 0.15194078f, 
    0.19231369f, 0.15448315f, -0.62401062f, -0.03559761f, -0.01339403f, 0.18061231f, 0.15575790f, -0.01896768f, 
    -0.39342427f, 0.38590586f, -0.08710036f, -0.22495054f, 0.09279218f, -0.32001710f, 0.04894490f, 0.02314395f, 
    -0.04262729f, -0.91729879f, -0.03005753f, -0.00510916f, -0.20285220f, 0.02149564f, -0.40602797f, -0.14678392f, 
    -0.03460366f, 0.00571052f, -0.04520024f, -0.08718926f, 0.01200955f, 0.08188991f, 0.03138034f, -0.07284886f, 
    0.03219788f, -0.03924492f, 0.23067094f, 0.10630801f, -0.05251126f, 0.04375119f, -0.04989811f, 0.00622975f, 
    -0.26177236f, -0.03178294f, 0.10185903f, 0.02334693f, -0.00627849f, 0.11124206f, 0.34098724f, 0.01056953f, 
    -0.26831180f, -0.21338804f, 0.05386277f, 0.11756221f, 0.03481100f, 0.14130208f, -0.37297180f, -0.04008118f, 
    0.10704376f, 0.02606708f, -0.10542910f, 0.05602382f, -0.22793718f, 0.06953469f, -0.01920974f, 0.03755540f, 
    0.09048049f, -0.13007464f, 0.32823381f, 0.06005088f, 0.11229242f, 0.07977280f, -0.05702865f, 0.26968506f, 
    0.11875293f, 0.09373766f, 0.05359710f, -0.19209632f, -0.16805993f, 0.01076095f, 0.10769523f, 0.16704197f, 
    -0.00393616f, 0.06466870f, 0.07466049f, -0.23245084f, 0.12501529f, -0.09947466f, 0.22929214f, 0.11825041f, 
    0.02023028f, 0.01566955f, -0.08842867f, -0.13382475f, 0.05693711f, 0.13014410f, 0.04238528f, 0.02819389f, 
    0.01867107f, 0.03170960f, 0.00288994f, 0.00585233f, 0.02845828f, -0.05926950f, -0.37396783f, -0.10450977f, 
    0.12083690f, 0.25249338f, 0.11225969f, 0.11928476f, 0.35075575f, 0.07167499f, 0.02807604f, -0.16131404f, 
    0.04059633f, 0.03156790f, -0.21678840f, -0.16018069f, -0.11088098f, 0.11012265f, -0.08369017f, -0.16805178f, 
    -0.09095681f, -0.11869168f, -0.07730408f, -0.02137969f, 0.35686442f, -0.04969501f, -0.12922941f, -0.23564976f, 
    -0.02564068f, 0.17093447f, 0.10003290f, -0.00600729f, 0.19573861f, 0.15409692f, 0.07547198f, 0.17335524f, 
    0.22286332f, -0.04899075f, 0.04754373f, 0.10627114f, -0.03795687f, 0.02243026f, -0.03640391f, -0.07573493f, 
    -0.02073630f, -0.04800902f, -0.14887829f, 0.06266760f, 0.00111220f, 0.18956803f, 0.08119066f, 0.06151016f, 
    -0.22377554f, 0.02934831f, -0.21735087f, -0.23009151f, 0.04913862f, -0.08971820f, 0.19256142f, 0.00193849f, 
    0.24254782f, 0.26024097f, 0.24815518f, 0.12005761f, -0.10727713f, -0.09870049f, -0.06008741f, 0.14089432f, 
    -0.00198296f, 0.06303328f, 0.23843710f, -0.19964249f, -0.24199845f, 0.20272671f, -0.11048233f, 0.24884598f, 
    -0.01971578f, 0.02645230f, 0.01121364f, 0.07018432f, 0.19251306f, 0.26247492f, 0.06480470f, -0.01908424f, 
    -0.02629256f, -0.04017382f, 0.03412907f, -0.00662168f, -0.87198758f, -0.11043034f, -0.43979660f, -0.02447341f, 
    0.12609139f, -0.14229330f, -0.02872830f, -0.22920884f, 0.12450115f, -0.20146023f, -0.04993336f, 0.09120812f, 
    -0.10103864f, 0.07125867f, 0.19912231f, 0.01731394f, 0.10338801f, 0.14221169f, -0.05649025f, 0.06358960f, 
    0.37251431f, 0.08308774f, -0.01641929f, -0.10634068f, 0.05199099f, -0.13279410f, 0.01048417f, 0.11856932f, 
    -0.07572982f, -0.19630083f, 0.00334486f, -0.08958477f, 0.10476177f, 0.10555933f, 0.08863500f, 0.09029844f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.09559910f, -0.05608334f, 0.05654525f, 0.27272061f, -0.02162940f, 0.47648451f, 0.21100144f, -0.03255051f, 
    -0.03985650f, 0.01604810f, -0.00210182f, 0.17310822f, -0.00444059f, 0.22186932f, -0.12020986f, 0.03254098f, 
    0.22595693f, 0.03694781f, 0.15992787f, 0.15741439f, 0.13774455f, 0.25027290f, 0.31388620f, 0.14581424f, 
    -0.23348814f, -0.06615838f, 0.03758850f, -0.06101191f, 0.02085018f, -0.21106091f, 0.32946408f, 0.13857612f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07856603f, -0.14275289f, -0.05846351f, 0.16928674f, -0.19047497f, -0.12567531f, -0.49595496f, 0.00062954f, 
    0.25938007f, 0.13272420f, -0.40694913f, -0.15018979f, -0.16289048f, -0.16508910f, 0.09861630f, -0.05541870f, 
    -0.04649300f, 0.25706396f, -0.17179567f, -0.42374036f, 0.07102331f, -0.15609168f, -0.25116616f, -0.51383066f, 
    0.13223967f, 0.00130679f, 0.29628271f, 0.71973270f, 0.12084918f, 0.49857995f, -0.65654993f, -0.10857077f, 
    -0.29895049f, -0.11058742f, -0.58819044f, 0.26278272f, -0.14708333f, 0.01257001f, -0.05286427f, 0.07719336f, 
    0.01870652f, -0.64149272f, -0.22619393f, -0.30553675f, -0.06460780f, 0.40123373f, 0.24051476f, -0.01650723f, 
    0.20214219f, 0.02490289f, 0.02340223f, -0.01740673f, 0.20397106f, -0.01828053f, 0.07339269f, -0.15914699f, 
    -0.37553769f, 0.15696192f, 0.01155723f, 0.47957924f, 0.09231693f, 0.57886463f, 0.21611378f, -0.26989442f, 
    0.01907020f, -0.15459949f, -0.14770485f, 0.26349691f, -0.09152948f, 0.15037534f, -0.07074998f, 0.01867626f, 
    0.27303717f, -0.24353229f, -0.40178981f, 0.40741554f, 0.04084976f, 0.03631763f, 0.08891899f, 0.01402590f, 
    -0.58074683f, -0.24178420f, -0.38918984f, -0.37704313f, -0.10824789f, 0.16022789f, -0.14843506f, -0.26108453f, 
    0.07354929f, -0.05730326f, -0.23659305f, -0.77007377f, -0.12898265f, -0.36629385f, 1.02852976f, -0.36990225f, 
    0.24789938f, -0.09029891f, 0.74147224f, 0.49929437f, -0.04264349f, -0.20367114f, -0.26358932f, -0.12840788f, 
    0.06880099f, 0.04296997f, 0.39886352f, -0.77817285f, 0.01650162f, 0.33089036f, 0.43877026f, 0.08364879f, 
    -0.70732665f, 0.28541946f, -0.25943729f, -0.18843374f, -0.57282847f, 0.19094342f, -0.76081187f, -0.19601706f, 
    0.22261356f, 0.12453326f, 0.12069282f, -0.92552483f, 0.07556651f, -0.27669865f, -0.19394550f, -0.44078639f, 
    0.15854503f, -0.09656437f, -0.19520213f, 0.13215457f, 0.07080076f, -0.40270674f, 0.32215005f, 0.15525478f, 
    -0.00364198f, 0.37453365f, 0.48712623f, -0.13476937f, 0.16755046f, -0.42866433f, -0.35075739f, -0.02951908f, 
    -0.10659523f, 0.07362095f, -0.00531311f, 0.31759873f, 0.04513937f, -0.04057448f, -0.17561826f, -0.25320145f, 
    0.02266453f, -0.10100552f, -0.36668348f, 0.34662440f, 0.02800410f, -0.01062201f, -0.21455210f, 0.40694639f, 
    0.01003088f, -0.01418629f, -0.79257900f, 0.00343762f, -0.01397943f, 0.19806848f, -0.37409171f, -0.08683738f, 
    -0.31096372f, 0.43195918f, -0.48496187f, -0.35959101f, -0.16673046f, -0.27633345f, -0.33514550f, -0.16418232f, 
    -0.05169429f, -0.12757093f, 0.25841355f, 0.67350030f, -0.19196171f, -0.07111616f, 0.23572858f, 0.36989525f, 
    0.21658233f, -0.06980095f, 0.37136331f, 0.11785806f, -0.03549876f, -0.20331059f, 0.08868293f, -0.07828838f, 
    0.13939908f, -0.09180203f, -0.26306301f, -0.35375908f, 0.02539637f, 0.52437985f, 0.05096365f, 0.11591464f, 
    0.22782196f, -0.68031120f, -0.82647729f, 0.80637223f, -0.14450999f, -0.11626957f, 0.02496794f, 0.15387771f, 
    -0.52554059f, -1.08727503f, -0.07292953f, -0.62656420f, 0.16323210f, -0.09397589f, -0.08111745f, 0.26919198f, 
    -0.03485485f, 0.07411873f, -0.42209071f, -0.23223804f, -0.12684469f, -0.79563481f, -0.33167925f, 0.38313222f, 
    -0.20660754f, 0.13567494f, 0.87733400f, -0.19546449f, 0.04595153f, -0.55298734f, 0.02066625f, -0.00954703f, 
    -0.12737057f, 0.42985606f, -0.05294490f, 0.00689025f, -0.12155027f, -0.01220282f, 0.40902218f, -0.17953219f, 
    0.18764912f, -0.40666607f, 0.47507590f, -0.53076762f, 0.52782518f, -0.30387658f, -0.05948045f, -0.15723245f, 
    -0.02378578f, 0.16213396f, -0.03725747f, -0.00494029f, -0.14633827f, -0.12250022f, -0.45131987f, 0.07921261f, 
    0.05590351f, -0.16731304f, 1.01093984f, -0.13235904f, 0.14318539f, 0.17363523f, 0.18550870f, -0.07855169f, 
    -0.55593127f, -0.04140586f, -0.19840366f, 0.06250200f, 0.12590654f, 0.20208853f, -0.89742565f, 0.07595690f, 
    0.21500421f, 0.02005262f, -0.31374031f, -0.56196308f, -0.06230370f, -0.28563643f, 0.18096143f, -0.15652354f, 
    -0.12589146f, -0.16802768f, 0.47144338f, -0.61358178f, 0.05471262f, 0.25775203f, 0.18185104f, -0.37509027f, 
    0.31727737f, 0.11737775f, -0.26632044f, 0.16607165f, -0.00588253f, 0.21997280f, 0.49052247f, -0.06649717f, 
    0.18883568f, -0.14016716f, 0.02424552f, 0.08221576f, -0.01442229f, -0.13687451f, -0.17853682f, 0.00899054f, 
    -0.47953644f, 0.58820063f, 0.54759079f, -0.05675757f, -0.40094322f, 0.01673851f, -0.16726850f, -0.23581046f, 
    -0.66068584f, 0.14127213f, -0.48037478f, -0.11569618f, -0.02481963f, -0.47630888f, -0.44101155f, 0.54574788f, 
    -0.49730328f, -0.13609201f, -0.35301307f, -0.51501590f, 0.08365814f, -0.38951501f, 0.28587770f, 0.05991366f, 
    -0.35676911f, -0.20792404f, 0.53106821f, -0.39167410f, -0.07908347f, 0.09721883f, -0.47855479f, -0.09406369f, 
    -1.04041445f, -0.51995391f, -0.22185522f, -0.94437462f, 0.30794382f, -0.12194853f, 0.32952499f, 0.39702111f, 
    0.35107797f, -0.13516533f, 0.35778666f, 0.23051250f, -0.10854573f, -0.09597635f, 0.32602569f, 0.30952886f, 
    -0.28483421f, 0.16144733f, -0.60121232f, -0.44156429f, -0.05819452f, -0.49094123f, 0.02401087f, -0.02886523f, 
    -0.02846815f, -0.39207062f, -0.08853756f, 0.22300492f, 0.12052983f, 0.09385650f, 0.07949812f, -0.07978592f, 
    0.54157889f, -0.27624854f, -0.73655242f, 0.19804487f, -0.33126199f, 0.37540364f, 0.21413758f, 0.55258340f, 
    0.01614058f, -0.06999275f, -0.36293268f, -0.49699712f, -0.08318423f, -0.61191213f, -0.82932490f, -0.27038056f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.31381255f, 0.05330655f, 0.11729938f, 0.06704737f, -0.03589496f, 0.21889462f, 0.04398020f, -0.50204098f, 
    -0.03463668f, 0.23689969f, 0.04911731f, 0.15979606f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
