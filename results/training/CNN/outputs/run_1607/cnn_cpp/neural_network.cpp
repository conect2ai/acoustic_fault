#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.01509844f, -0.22226271f, -0.08595268f, 0.48541668f, -0.13564757f, 0.27503186f, -0.15327795f, -0.40716785f, 
    -0.20593116f, 0.08404142f, 0.07197411f, 0.10331740f, -0.25685295f, 0.06867684f, 0.28475419f, 0.09906348f, 
    -0.16485581f, -0.23430310f, 0.08343712f, 0.05810373f, -0.33729193f, 0.31318983f, -0.02937330f, -0.19585377f, 
    0.10414910f, -0.02897622f, 0.45463943f, 0.30335906f, -0.47181901f, -0.79775262f, -0.14216734f, -0.35746825f, 
    -0.30036947f, -0.10558654f, -0.48616818f, 0.09066806f, 0.15478170f, -0.19701637f, -0.16078798f, -0.01026672f, 
    -0.00273200f, 0.16913877f, -0.20345417f, -0.15659176f, -0.25893119f, 0.28922606f, 0.28650111f, 0.11321929f, 
    0.29066396f, 0.14023055f, -0.32388642f, -0.44103503f, -0.38719866f, 0.08406532f, -0.37579897f, 0.63385129f, 
    -0.54968601f, -0.28300548f, 0.38047904f, 0.08664628f, 0.31363565f, -0.15529121f, -0.28936636f, -0.27448604f, 
    -0.33289260f, -0.08954449f, 0.17622130f, 0.32123926f, 0.07065852f, 0.17942484f, 0.07118177f, -0.07189031f, 
    0.02873223f, 0.09452401f, -0.17863601f, 0.78062183f, -0.61674714f, -0.67626339f, -0.29320228f, -0.47663638f, 
    0.25867882f, 0.42389217f, 0.53948385f, 0.17786680f, 0.18287207f, -0.14176674f, 0.08308686f, -0.38893801f, 
    -0.28952551f, -0.04700138f, -0.04820975f, 0.21155310f, 0.16127692f, 0.16305661f, -0.20932968f, 0.01825084f, 
    -0.14081331f, -0.23044559f, -0.13037416f, 0.18411055f, -0.91935098f, -0.21611515f, 0.29047173f, 0.44437149f, 
    0.28014416f, -0.88012129f, -0.53839266f, -0.11021524f, 0.68738520f, 0.02595155f, -0.23475279f, -0.10725836f, 
    -0.52236402f, 0.22290184f, 0.26564220f, -0.09795213f, -0.24693891f, 0.04143645f, -0.49867621f, -0.49002457f, 
    -0.04726272f, -0.04259752f, -0.19739339f, -0.34520838f, -0.12488507f, 0.42351598f, 0.19466327f, 0.11000283f, 
    -0.53662503f, -0.50318152f, -0.02006365f, 0.13884883f, -0.22522174f, 0.01090700f, -0.26161611f, -0.29004449f, 
    -0.37817174f, 0.08612131f, 0.26644149f, 0.06672382f, -0.14248985f, -0.14595048f, -0.26304817f, 0.01716045f, 
    -0.36761224f, -0.50411671f, 0.00931790f, -0.41099253f, -0.49743780f, -0.59268636f, -0.79530489f, 0.22261648f, 
    -0.09998531f, -0.54174691f, -0.45431259f, 0.14474951f, -0.04394967f, 0.42646956f, -0.03536940f, -0.07298607f, 
    0.04828592f, -0.37180051f, 0.06208711f, 0.03823663f, 0.16335487f, 0.15191162f, 0.11890309f, 0.01061425f, 
    0.21044029f, -0.06582635f, -0.28175360f, -0.28829861f, 0.15866143f, -0.37081075f, -0.21459480f, -0.22544886f, 
    -0.52892447f, -0.26630643f, -0.26695716f, -0.59311748f, -0.46256167f, -0.30749157f, -0.57487005f, -0.36736020f, 
    -0.59904122f, 0.00268276f, 0.25694457f, -0.19359979f, -0.21421514f, -0.30428123f, -0.31203642f, -0.05411382f, 
    -0.08497085f, -0.11403955f, -0.15036646f, -0.36877674f, -0.01276238f, -0.02398333f, 0.01335352f, -0.11307961f, 
    -0.16333430f, 0.19138582f, -0.41127563f, 0.09372369f, 0.13907950f, 0.08113009f, 0.39771885f, -0.19102001f, 
    -0.08317864f, -0.07907073f, -0.03215792f, 0.31082168f, -0.36531386f, -0.10796498f, -0.01335159f, 0.13612580f, 
    -0.28603372f, -0.03257795f, -0.05155248f, 0.13261004f, -0.35790652f, 0.17696333f, 0.19041909f, 0.26187015f, 
    -0.13219720f, -0.06280826f, -0.27265981f, -0.18319029f, 0.31309274f, 0.32519785f, 0.22296944f, 0.06995839f, 
    0.13964739f, 0.36293226f, 0.17775322f, 0.15562217f, 0.13652402f, -0.11868480f, 0.01800706f, -0.18599404f, 
    -0.16076730f, 0.13993354f, -0.02069500f, 0.07564599f, -0.29535598f, 0.00412519f, 0.12779763f, 0.00412443f, 
    -0.12343943f, 0.07354973f, -0.47004893f, -0.24135219f, -0.03953402f, -0.71532536f, -0.36745992f, -0.41644225f, 
    -0.28416526f, -0.04467628f, -0.08496643f, 0.02924802f, 0.28942856f, 0.35164493f, -0.04783490f, -0.08630703f, 
    -0.22792764f, 0.18955524f, -0.25299683f, -0.22405300f, -0.08674883f, -0.31720686f, 0.12553458f, -0.31877503f, 
    -0.25604132f, -0.21292801f, -0.34468052f, -0.59066129f, -0.80134040f, -0.27674109f, 0.00797297f, -0.14792064f, 
    0.55514550f, 0.61243361f, 0.34254155f, 0.01138294f, -0.05960881f, -0.00032222f, -0.15522896f, 0.12813555f, 
    0.07534678f, 0.23151749f, -0.08914047f, 0.12239629f, -0.28512248f, -0.23573659f, 0.22521295f, 0.18086194f, 
    -0.22610345f, 0.33076847f, -0.03476945f, -0.03191489f, 0.17965288f, -0.28559834f, -0.32340974f, -0.08018582f, 
    0.02558111f, 0.35969266f, -0.15890734f, 0.12281665f, -0.05990871f, 0.18747102f, -0.08876297f, 0.45735589f, 
    -0.48955154f, -0.04811320f, -0.25442970f, 0.11632135f, 0.13894311f, 0.08176973f, 0.07581280f, -0.17182395f, 
    -0.02036756f, -0.04818206f, -0.07178852f, -0.06778039f, 0.04712325f, -0.83268893f, -0.56025904f, -0.25242916f, 
    -0.40351519f, -0.47735244f, 0.00795441f, 0.37277639f, -0.50517875f, -0.52416271f, 0.50312537f, -0.03871810f, 
    -0.05798761f, 0.15464178f, -0.16961467f, -0.15337729f, -0.22849485f, -0.19789855f, -0.14613530f, -0.14714560f, 
    -0.26948449f, -0.00386026f, -0.00979795f, 0.13367973f, -0.04933237f, 0.07856481f, -0.41017064f, -0.64291853f, 
    -0.18645297f, -0.01060713f, 0.12772493f, -0.30732054f, -0.60648757f, -0.54886329f, -0.57473242f, -0.20701057f, 
    -0.11498038f, 0.51825106f, 0.34058937f, 0.05343125f, -0.14044456f, -0.32503256f, -0.06749506f, -0.40501007f, 
    -0.41695982f, -0.42132029f, 0.05829354f, 0.16169459f, 0.05453188f, -0.12946005f, -0.22596475f, -0.80784929f, 
    -0.25399074f, -0.58734846f, -0.70064425f, -0.41556740f, 0.18036318f, 0.25748599f, 0.38591725f, 0.31897426f, 
    0.23300499f, 0.30437148f, 0.35258830f, 0.20512706f, -0.01431650f, -0.04608894f, -0.10809402f, -0.18754102f, 
    -0.05935350f, 0.06981825f, -0.21375436f, 0.03061525f, -0.08772761f, -0.12450872f, -0.06013265f, -0.24992795f, 
    -0.30352533f, -0.49698034f, -0.15977708f, -0.27724761f, 0.37884146f, -0.05898413f, 0.28130305f, 0.13597201f, 
    0.16041343f, -0.04525808f, 0.18527564f, -0.15876995f, 0.24992716f, -0.56681913f, -0.08306777f, 0.05452562f, 
    -0.05375720f, -0.12302611f, 0.15625021f, 0.06294409f, -0.01933938f, -0.17346792f, -0.02491067f, -0.30300272f, 
    0.01239877f, -0.12684090f, -0.51322502f, 0.25212631f, 0.62132394f, -0.13494869f, 0.02390578f, 0.03702989f, 
    -0.09964526f, -0.38809347f, 0.19848482f, -0.43679288f, -0.14629939f, 0.08130468f, 0.22213286f, -0.05225023f, 
    -0.05752234f, 0.22001259f, 0.03357842f, 0.24255267f, 0.12945583f, 0.08571322f, 0.11582953f, -0.19995132f, 
    -0.02154623f, -0.36912611f, 0.22589916f, -0.35897684f, -0.33811361f, 0.13409562f, 0.32960868f, -0.05966007f, 
    0.16405223f, 0.16751675f, 0.16715635f, -0.20518053f, -0.15234953f, -0.04142591f, -0.05087986f, -0.02131937f, 
    0.29823324f, -0.28624377f, -0.05491933f, 0.17504433f, 0.05762851f, -0.01333604f, 0.22175692f, -0.14672586f, 
    -0.38658443f, 0.13282339f, 0.13347067f, 0.20890094f, 0.27556214f, 0.01759372f, 0.06449294f, 0.12600996f, 
    -0.16135603f, 0.11964779f, -0.26718175f, -0.25405329f, -0.13769703f, 0.05888001f, 0.11510338f, 0.21593745f, 
    -0.21903500f, 0.35006678f, 0.22261789f, -0.30544516f, -0.03429792f, -0.04558947f, 0.18197645f, -0.14951533f, 
    0.25072446f, -0.05741471f, 0.07745718f, -0.07266203f, -0.61488557f, -0.11946414f, 0.30231905f, 0.30654779f, 
    0.18555608f, 0.03009306f, 0.68542337f, -0.90258634f, -0.41696134f, 0.29124418f, 0.00457194f, -0.09416874f, 
    0.06285833f, -0.33482161f, -0.25702384f, -0.05359678f, -0.23967457f, -0.21371847f, 0.07936193f, 0.36791298f, 
    0.00565152f, -0.13687818f, 0.11889230f, -0.16489042f, -0.18236786f, 0.24751799f, 0.03500830f, -0.05516813f, 
    -0.16316076f, -0.13606496f, -0.75354183f, -0.72957450f, -0.01044089f, -0.70700544f, -0.80669528f, 0.21467878f, 
    0.23087896f, -0.22558667f, -0.12973511f, 0.18196298f, -0.01044632f, 0.28546518f, -0.28068945f, -0.01149167f, 
    0.14278740f, -0.21584249f, -0.16380657f, -0.13725992f, -0.12788132f, 0.08664125f, 0.28154996f, 0.28824854f, 
    0.27779970f, -0.26135415f, -0.33926830f, 0.05713554f, 0.20057185f, -0.06178375f, -0.04061221f, 0.04470348f, 
    0.16762573f, 0.11788632f, -0.32347599f, -0.08758493f, 0.04061515f, -0.14306834f, -0.17972344f, -0.01358715f, 
    -0.26594982f, 0.28143659f, -0.15589541f, -0.19581042f, -0.01395799f, 0.01538918f, 0.30789077f, 0.55185187f, 
    -0.72821820f, 0.35047010f, 0.17373218f, 0.02003948f, -0.06309554f, 0.07995022f, 0.11960463f, 0.08320021f, 
    -0.38194296f, -0.05015658f, -0.14720790f, 0.12059159f, -0.11259439f, -0.01702135f, 0.13366874f, -0.13391151f, 
    0.17996012f, 0.17107074f, -0.09592061f, -0.17225441f, 0.08181094f, -0.09665762f, 0.06556123f, -0.23475382f, 
    0.03635538f, -0.56105870f, -0.09387898f, 0.33837762f, 0.38740578f, -0.54959279f, -0.71041793f, -0.51584285f, 
    -0.15708281f, 0.03353103f, 0.35949457f, 0.04094604f, 0.35229862f, 0.42909846f, 0.20908397f, 0.26168007f, 
    -0.28573218f, -0.08938392f, -0.38129732f, -0.08192733f, -0.06411666f, 0.21902180f, -0.26207432f, -0.07439182f, 
    0.23692153f, 0.07440387f, 0.36288854f, 0.13618004f, 0.26288211f, 0.12203729f, -0.31965342f, -0.00984750f, 
    0.15280078f, -0.14791453f, -0.03795293f, 0.26722741f, 0.00197099f, -0.02142587f, -0.16316436f, -0.04256833f, 
    0.17307545f, -0.03096564f, 0.06081569f, -0.14537163f, -0.25564611f, 0.09094237f, 0.01804972f, -0.22026296f, 
    -0.26461822f, -0.34309292f, 0.55750412f, 0.47039163f, 0.70695829f, -0.25004977f, -0.49844873f, -0.78589028f, 
    -0.41014266f, 0.06245792f, -0.12856394f, -0.02231854f, 0.02002808f, 0.14126711f, -0.11025871f, 0.32625213f, 
    0.13062702f, -0.27179822f, -0.12941425f, 0.19851758f, -0.26235053f, 0.04898527f, 0.01870668f, -0.07533677f, 
    0.08922864f, -0.29452258f, -0.06828467f, 0.66907227f, 0.84535223f, 0.57746917f, -0.07284254f, -0.49983707f, 
    -0.03800015f, -0.06645531f, -0.24340332f, -0.26673704f, -0.23604274f, -0.00881772f, -0.12767217f, 0.18545370f, 
    -0.00643924f, -0.29909095f, -0.00540097f, 0.08456018f, -0.25760782f, 0.23841763f, 0.07351116f, -0.24681626f, 
    0.01119247f, 0.04997496f, 0.01020924f, 0.16436209f, 0.48600090f, -0.12378120f, 0.22727871f, 0.62227178f, 
    0.44368637f, -0.48577556f, -0.30776072f, -0.49782324f, 0.05275704f, -0.43234625f, -0.31135029f, -0.20321372f, 
    0.25561336f, -0.18138708f, -0.01403069f, 0.07939727f, 0.04859151f, -0.01272433f, -0.10246108f, 0.07732131f, 
    -0.09540093f, 0.07358427f, -0.13701448f, 0.10625327f, -0.06430843f, -0.54175079f, -0.30201969f, -0.57383293f, 
    -0.51549351f, -0.15171571f, -0.28259256f, -0.39540839f, -0.36684936f, -0.59666336f, -0.52212596f, 0.01808608f, 
    0.15927556f, 0.29998773f, -0.21953773f, -0.31536329f, -0.17919779f, -0.27215606f, 0.01194232f, -0.25183085f, 
    0.09518774f, -0.27996951f, -0.27871838f, -0.05163053f, -0.02270283f, -0.09297851f, -0.06492280f, 0.25291839f, 
    -0.19669369f, -0.10794499f, -0.12971455f, 0.30208296f, 0.28297901f, 0.08306575f, -0.16062386f, -0.37796402f, 
    0.23587367f, -0.22407411f, 0.12003024f, 0.23987336f, -0.25372928f, -0.21094148f, -0.03257455f, -0.20357181f, 
    0.18236139f, 0.12825783f, 0.03938235f, -0.22730625f, -0.32566494f, 0.01009989f, 0.42592868f, -0.04351856f, 
    0.27703342f, -0.51724869f, -0.68323326f, -0.59829354f, 0.03186615f, 0.20216928f, -0.14299825f, -0.44267824f, 
    0.54699105f, -0.03926198f, 0.40874121f, -0.06320433f, 0.07406166f, 0.20999481f, 0.07251915f, 0.06516357f, 
    -0.07908223f, 0.00710823f, 0.02832718f, 0.17178793f, -0.32856625f, -0.42470458f, 0.16887814f, 0.09565959f, 
    0.37714672f, -0.48289260f, -0.27740282f, -0.49040842f, -0.52924043f, 0.54364949f, 0.13921121f, -0.06296664f, 
    -0.37540865f, 0.21964863f, 0.13760804f, 0.33485058f, -0.31650633f, -0.40703213f, -0.02734018f, -0.24861477f, 
    -0.25549084f, -0.11636814f, -0.55393308f, 0.07233947f, -0.41708350f, -0.24560063f, 0.17946211f, -0.14225827f, 
    -0.52028257f, 0.29693460f, 0.14974539f, 0.05020836f, 0.00077763f, -0.13234124f, 0.18109833f, -0.19249344f, 
    0.16977097f, 0.06114911f, -0.24155325f, 0.10332457f, 0.22078212f, 0.06740236f, -0.39048648f, 0.02237207f, 
    -0.25410628f, 0.05998871f, -0.08935965f, 0.21594314f, -0.13899918f, 0.34863481f, 0.14892380f, -0.20717625f, 
    -0.04458610f, -0.33741707f, -0.59571588f, -0.79525155f, -0.15684800f, -0.10059404f, 0.42791060f, 0.21111594f, 
    -0.00622038f, 0.11266644f, 0.65566355f, -0.01105124f, -0.12439587f, 0.08579146f, 0.02384365f, 0.01416671f, 
    0.14321943f, 0.19744733f, 0.05604596f, -0.16310500f, -0.09558185f, -0.32756147f, -0.04704643f, 0.42676237f, 
    -0.12293151f, -0.14282039f, 0.31363025f, -0.65837240f, -0.09691848f, -0.43874156f, -0.23008260f, -0.00308775f, 
    0.23088981f, 0.14252229f, 0.15454054f, -0.05986770f, 0.10597730f, 0.23083331f, 0.17774779f, 0.25492194f, 
    0.12143189f, -0.05392086f, -0.13313799f, -0.30149832f, -0.19937237f, 0.10809828f, -0.17611757f, 0.06767371f, 
    0.22248250f, 0.22774570f, 0.24375813f, 0.14616206f, -1.00786650f, -0.61249417f, 0.24389754f, 0.37204233f, 
    0.16077124f, 0.76217282f, -0.29852054f, -0.42592955f, 0.10320765f, 0.85807878f, 0.29580000f, 0.04496507f, 
    -0.09881484f, -0.07292358f, 0.08086086f, -0.29928195f, -0.20609617f, 0.21103923f, -0.17697485f, -0.16420478f, 
    0.04539192f, 0.01968092f, 0.11852493f, 0.23370747f, 0.12956020f, 0.85924792f, -0.06337684f, -0.17483163f, 
    -0.00614413f, -0.21818416f, 0.26546991f, 0.47887951f, 0.51066941f, -0.47889242f, -0.46516213f, -0.31677985f, 
    0.00883625f, 0.06924443f, -0.22881077f, -0.20781939f, 0.04012769f, -0.03255797f, 0.31817329f, -0.17899118f, 
    -0.08654412f, 0.14579332f, -0.12103013f, -0.14684474f, 0.18089090f, -0.12607525f, 0.75916827f, -0.43704501f, 
    -0.45161298f, -0.33623755f, -0.07623690f, 0.21711083f, 0.75771928f, 0.01122956f, 0.14397791f, -0.53337806f, 
    -0.24785766f, -0.25034767f, 0.05435865f, -0.25843212f, 0.09652317f, -0.16530752f, 0.04918785f, 0.10908329f, 
    0.22381249f, 0.17195109f, 0.01055393f, -0.21308471f, -0.00883391f, -0.07213584f, 0.13406442f, 0.38317353f, 
    -0.49481699f, -0.12886234f, -0.14492281f, -0.27332541f, 0.45431426f, 0.35062650f, -0.19615264f, 0.30649582f, 
    0.10943117f, -0.07375944f, 0.11225139f, -0.03239366f, 0.12643749f, -0.25363749f, -0.27113342f, -0.25671533f, 
    0.17961185f, 0.12702630f, 0.05516866f, 0.06836668f, -0.13868752f, -0.15919665f, 0.28915170f, 0.06030042f, 
    0.78807229f, 0.14168501f, -0.27969238f, 0.20668253f, -0.58609205f, -0.74877906f, -0.32370791f, 0.08632418f, 
    0.14046285f, 0.42852631f, -0.07867790f, -0.12164270f, 0.53700066f, -0.06147492f, -0.30817840f, -0.19572647f, 
    0.14818279f, 0.14892456f, 0.12642068f, -0.13966651f, 0.20865485f, -0.05839333f, -0.04111254f, 0.32256916f, 
    -0.18896297f, 0.46715921f, 0.03839097f, -0.04164071f, 0.08802040f, -0.23381965f, 0.20784496f, 0.11366887f, 
    0.05497428f, 0.14732790f, 0.11676212f, 0.17792903f, 0.05423880f, 0.16128756f, 0.04533330f, -0.13022552f, 
    0.08291169f, -0.12731853f, 0.11315412f, 0.09336397f, -0.37376681f, -0.13827050f, 0.19119114f, 0.06477972f, 
    0.04727022f, 0.07449619f, -0.17810248f, 0.14222936f, 0.12930627f, 0.16393755f, 0.11440254f, 0.27308431f, 
    0.20015578f, -0.11000552f, -0.01852516f, 0.28761253f, 0.28440782f, 0.10461214f, -0.04467154f, -0.47187808f, 
    -0.23721477f, -0.19710760f, -0.22102676f, -0.02997772f, -0.00764895f, -0.03640746f, 0.14993992f, 0.14676367f, 
    0.16660029f, -0.17286675f, -0.26066020f, 0.79341090f, -0.34151429f, -0.32421303f, 0.07337153f, -0.73178166f, 
    0.24350148f, 0.06386489f, -0.30218366f, -0.09385351f, 0.06393467f, 0.39998570f, 0.11025303f, -0.04988594f, 
    -0.09987290f, 0.40615025f, 0.06910715f, -0.02220765f, -0.05619836f, 0.00687413f, -0.36686236f, -0.19363132f, 
    -0.06156692f, 0.18435539f, 0.02976422f, -0.10347266f, -0.48598856f, -1.05545008f, -0.65708542f, -0.05423370f, 
    0.55101603f, -0.10198931f, 0.04414070f, 0.48958227f, -0.17868428f, 0.12412358f, 0.17077024f, 0.02422955f, 
    0.13182348f, 0.10670876f, 0.16505846f, 0.06324115f, 0.07905138f, -0.01855198f, 0.09827830f, 0.04429138f, 
    -0.24948929f, -0.04817150f, 0.12028791f, 0.15704557f, -0.08587417f, -0.53105086f, -0.43594623f, -0.03872602f, 
    0.63532585f, 0.45047733f, 0.13084258f, 0.18094543f, -0.14136848f, -0.17189737f, -0.10993563f, -0.23195663f, 
    0.54371840f, -0.15899153f, -0.26132917f, 0.09185617f, -0.10791665f, 0.43738377f, 0.19439822f, -0.27802154f, 
    -0.04435389f, 0.36415204f, -0.28700966f, -0.41313401f, -0.11328554f, 0.28943646f, -0.11295927f, 0.27767536f, 
    0.37931201f, -0.18520622f, -0.09502572f, -0.59257030f, -0.27385381f, 0.25624549f, 0.34271395f, -0.11084765f, 
    0.12572373f, -0.18897727f, -0.22746474f, 0.19850826f, -0.29781306f, 0.07577442f, -0.20313071f, -0.26672632f, 
    0.23391943f, -0.12296285f, 0.26505274f, -0.10591011f, -0.02287981f, -0.02337503f, -0.35241389f, 0.54633635f, 
    -0.22053236f, -0.14488243f, -0.45321590f, -0.16857728f, -0.31038141f, 0.06432480f, 0.04876541f, 0.17441766f, 
    0.10869780f, -0.04177611f, 0.52477717f, 0.02968883f, -0.27775097f, 0.00767661f, -0.12269499f, -0.10737418f, 
    -0.01972541f, -0.16546644f, -0.42572606f, -0.18219469f, 0.29689738f, 0.23078379f, 0.01528486f, 0.20653547f, 
    -0.21758640f, -0.17853248f, -0.42811340f, -0.26354614f, -0.59522140f, -0.43438661f, -0.47973016f, -0.09179831f, 
    -0.32558981f, -0.45463079f, -0.19908047f, -0.16897832f, 0.32691795f, -0.17734699f, -0.03620540f, 0.21631226f, 
    -0.02383088f, 0.10551496f, 0.05642531f, -0.26970625f, 0.24232073f, 0.25842518f, 0.13108946f, -0.04971470f, 
    0.43485606f, -0.65333545f, 0.49180105f, 0.37550035f, -0.38089660f, -0.59929937f, 0.34436533f, 0.19696698f, 
    0.20704550f, 0.01050063f, -0.02715062f, -0.26521909f, -0.10589091f, 0.05815095f, -0.46637017f, 0.06177087f, 
    0.37894985f, 0.22864088f, -0.18382899f, -0.09612449f, 0.01498671f, -0.08622570f, 0.10189340f, -0.08235531f, 
    -0.16660742f, 0.33026031f, -1.02886057f, -0.65737772f, -0.16025652f, -0.74493909f, -0.71969962f, 0.87251431f, 
    0.26895383f, -0.57585424f, -0.36719084f, 0.36306867f, -0.15617067f, -0.15526246f, -0.05008269f, 0.03849341f, 
    -0.03956923f, 0.13609855f, 0.03706508f, 0.00851907f, -0.08417069f, -0.28618050f, -0.22502445f, -0.17610158f, 
    -0.02624537f, -0.22228642f, 0.11059922f, -0.77848715f, -0.49975094f, -0.04194843f, 0.13103902f, 0.38505992f, 
    0.44782066f, -0.20199583f, -0.08207795f, 0.25731105f, -0.00138575f, -0.25566268f, 0.04224810f, -0.31418699f, 
    0.17230278f, -0.27578476f, -0.07982619f, 0.16239731f, 0.01480515f, 0.29333323f, 0.20236588f, 0.10747240f, 
    -0.24468675f, -0.22010675f, 0.30313718f, -0.02867890f, -0.13491918f, 0.15902637f, 0.51022136f, -0.78292209f, 
    -0.37604079f, -0.23336995f, -0.09353883f, 0.27611190f, 0.37175640f, 0.06683218f, -0.38516805f, -0.26704475f, 
    0.15869634f, 0.12468398f, -0.29349402f, 0.25486934f, -0.03423969f, -0.12294899f, -0.27726424f, -0.12314830f, 
    -0.37105229f, -0.48169079f, -0.27314967f, -0.52728677f, -0.65510696f, 0.45937306f, -0.05252822f, -0.24436975f, 
    -0.59733915f, -0.76704431f, 0.53183520f, 0.67364484f, -0.18940121f, -0.64759362f, -0.29406795f, 0.14112592f, 
    -0.07410376f, 0.20094706f, 0.28515989f, 0.15215409f, 0.00220966f, -0.26505491f, 0.05227328f, -0.10105433f, 
    -0.29468027f, 0.09143735f, -0.12882385f, 0.11323415f, 0.36570060f, 0.13675089f, 1.05647588f, -0.17984851f, 
    -0.22385715f, -0.44907114f, -0.17549023f, -0.12952790f, -0.15957120f, 0.65466022f, -0.02652153f, -0.42523432f, 
    -0.33184010f, 0.13585526f, -0.10077074f, 0.00350286f, 0.48431715f, 0.22577429f, -0.04871905f, 0.13536355f, 
    -0.24513915f, -0.12318871f, 0.02507870f, -0.16177684f, -0.05531940f, 0.08333849f, -0.12392484f, -1.15459061f, 
    0.32382277f, 0.03701800f, -0.46534765f, 0.52882075f, 0.48822683f, 0.49309734f, -0.11305079f, -0.58404309f, 
    0.23535949f, -0.20615803f, -0.41155538f, -0.32579544f, -0.22501984f, 0.15187244f, 0.17539640f, -0.08572778f, 
    -0.21856996f, 0.01493609f, -0.00971183f, 0.16070202f, 0.01140389f, -0.38259530f, -0.18446498f, -0.50009000f, 
    1.08875000f, -0.52533257f, -0.43258300f, -0.65315735f, -0.85420746f, 0.75921953f, 0.00027785f, 0.10497355f, 
    0.41220105f, -0.02292651f, 0.03685386f, 0.03296142f, -0.01619061f, -0.12427142f, -0.09453558f, 0.07464956f, 
    0.08760785f, -0.20616452f, -0.00428781f, 0.07908601f, 0.17523985f, 0.10857967f, -0.17908096f, -0.05036696f, 
    0.27744427f, -0.53452379f, 0.19569229f, 0.67797250f, -1.07773650f, -0.86225963f, 0.22482909f, 0.30767950f, 
    0.13872352f, 0.26755920f, 0.35773394f, 0.25197428f, -0.10117989f, 0.14756608f, -0.45268703f, -0.19016501f, 
    -0.28649539f, 0.00839032f, -0.11987530f, -0.07325602f, -0.01026441f, -0.16597764f, 0.29624075f, 0.17403920f, 
    0.04515914f, 0.09518857f, -0.44920275f, -0.14461623f, 0.15205137f, 0.12082372f, 0.30605099f, -0.64094800f, 
    0.57158029f, -0.45781535f, 0.53220445f, -0.01965472f, -0.08758414f, -0.10161240f, 0.03303215f, 0.05020113f, 
    0.08382624f, 0.21795437f, 0.00820566f, -0.13376713f, -0.15177187f, 0.01767938f, -0.26309326f, -0.06564363f, 
    0.31189618f, -0.15101884f, 0.06669957f, 0.39733261f, 0.16485882f, 0.21715835f, -0.20215678f, -0.38535896f, 
    -0.01803162f, 0.10662302f, 0.13680252f, 0.05509841f, -0.06691536f, 0.08153731f, 0.16933106f, -0.23662880f, 
    -0.24646904f, -0.30726436f, 0.17433305f, 0.01479636f, 0.14405663f, 0.01734053f, -0.04008237f, 0.01102590f, 
    -0.24571867f, -0.11959405f, 0.04357035f, -0.18222618f, -0.34955758f, 0.50460374f, -0.23052868f, 0.26515812f, 
    -0.17140330f, -0.39120820f, -0.10349352f, 0.10426196f, 0.06641559f, 0.33209017f, -0.22566779f, -0.25323662f, 
    -0.20612098f, 0.44653183f, -0.30371016f, 0.32411197f, 0.20728138f, 0.11936519f, -0.16244476f, -0.07875572f, 
    -0.35393825f, -0.13668360f, 0.16394101f, -0.12168588f, -0.04515798f, 0.11816457f, -0.43804014f, -0.58778411f, 
    0.44785595f, 0.51005137f, 0.62592548f, 0.16196549f, -0.04750232f, -0.15388265f, -0.49839202f, -0.28957552f, 
    0.15362670f, 0.03335888f, 0.16510244f, -0.18652008f, 0.14775614f, -0.38098732f, 0.02495215f, 0.04293067f, 
    -0.03493476f, -0.08992676f, 0.32850173f, 0.13095903f, -0.34956324f, -0.11268009f, -0.17656411f, -0.40115887f, 
    -0.16093555f, -0.07024759f, 0.75755960f, -0.48731393f, 0.11018251f, -0.40887100f, -0.04027972f, 0.42157418f, 
    -0.11216136f, -0.40418276f, 0.31622019f, 0.32996014f, -0.05554570f, -0.06788113f, -0.35915592f, 0.16830969f, 
    0.29747009f, 0.14250484f, -0.17458326f, -0.44875163f, 0.23687576f, 0.24081202f, -0.11912216f, -0.57521987f, 
    0.48674703f, -0.01999039f, -0.60108668f, -0.00784774f, -0.30283603f, 0.36219117f, 0.31895754f, 0.40603423f, 
    -0.23464240f, 0.02547610f, -0.38339376f, -0.09833296f, -0.17063120f, 0.03366189f, 0.00596433f, -0.22544095f, 
    0.20065811f, 0.13081340f, -0.01102804f, -0.03913092f, 0.18355913f, -0.04793965f, 0.06981833f, 0.08872715f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20178390f, 0.03602498f, -0.08331513f, -0.08265568f, 0.02020589f, -0.31440201f, -0.04213339f, -0.03891552f, 
    -0.08763684f, -0.20939122f, 0.11144984f, -0.00944603f, 0.13311720f, -0.37042013f, 0.06216428f, 0.05312366f, 
    0.23177262f, -0.09309866f, 0.22259028f, 0.00908177f, 0.06880653f, -0.15421367f, 0.32023865f, 0.00862901f, 
    0.39083067f, -0.12088914f, 0.23365064f, 0.38998291f, 0.06095057f, -0.40443555f, 0.37678346f, 0.15999554f, 
    0.12865689f, 0.22320351f, 0.11573625f, -0.10664991f, 0.38403550f, 0.26913872f, 0.05423879f, 0.13935709f, 
    0.17153876f, -0.07142254f, 0.15820269f, 0.05119289f, 0.24397714f, 0.15816763f, 0.31389076f, 0.27583909f, 
    -0.19195420f, 0.02470315f, -0.15904474f, 0.07431125f, -0.12843736f, 0.34623405f, 0.03002927f, 0.14463781f, 
    0.27817234f, 0.02524139f, 0.33324236f, -0.07479075f, 0.01215850f, 0.13739140f, 0.24996647f, 0.04917963f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05882913f, 0.01107732f, -0.02282302f, -0.09523742f, -0.15465328f, -0.03803122f, -0.01637604f, -0.18892533f, 
    -0.02800968f, 0.00828174f, 0.00252195f, -0.06282271f, 0.22689326f, -0.01286959f, -0.09118563f, -0.12002297f, 
    -0.03089899f, 0.15854225f, -0.13167349f, -0.02563387f, 0.02768246f, -0.05682160f, -0.02936820f, -0.06215686f, 
    0.24110909f, 0.17324592f, 0.08570080f, -0.18360946f, 0.12936890f, 0.10846580f, -0.04610506f, -0.02697607f, 
    0.02957869f, 0.12184243f, 0.01899068f, -0.00409076f, -0.01397191f, -0.09713986f, -0.23322210f, 0.02161681f, 
    0.05062427f, 0.05599367f, 0.06141837f, -0.01772840f, 0.03578402f, 0.12879126f, -0.08183777f, 0.00297585f, 
    -0.11732794f, 0.12733760f, 0.38913664f, -0.22594079f, -0.10028420f, -0.03600979f, 0.06344827f, 0.02272957f, 
    -0.05694097f, -0.11094203f, -0.07801888f, -0.00041782f, 0.00566639f, -0.10228690f, 0.00388105f, -0.01958366f, 
    -0.05208775f, -0.04467831f, -0.28106984f, -0.12512486f, -0.01531429f, -0.06399644f, 0.09125935f, 0.13442643f, 
    0.02430918f, 0.05850759f, 0.09246999f, 0.01919379f, 0.04592803f, 0.19928694f, -0.06299894f, 0.17064786f, 
    -0.12452381f, 0.09833307f, 0.03590049f, -0.01997237f, 0.30449980f, 0.12688221f, -0.05335692f, -0.18808830f, 
    0.18415058f, 0.06103082f, -0.01719692f, 0.03263408f, -0.05832331f, -0.08428129f, -0.02457450f, -0.08268345f, 
    -0.03376864f, 0.03259996f, 0.02516855f, 0.02882293f, -0.06466122f, -0.00348017f, 0.03224904f, 0.05156824f, 
    -0.01525965f, -0.07250927f, -0.04668496f, 0.02721858f, 0.02292882f, 0.06472525f, 0.02649517f, 0.06431595f, 
    0.04594190f, 0.06400599f, 0.00353106f, 0.06412883f, -0.08044721f, -0.04085176f, -0.14693053f, -0.19879656f, 
    0.10663148f, 0.14775380f, 0.02303883f, -0.03326838f, -0.04711929f, 0.01360419f, -0.05643146f, 0.12624593f, 
    -0.07036714f, -0.05525756f, -0.05217878f, -0.00993649f, 0.16998568f, -0.10945410f, -0.24674615f, 0.09798995f, 
    0.09857474f, 0.09200951f, 0.02042122f, -0.01546971f, -0.04430820f, -0.05932665f, -0.10601106f, -0.02071933f, 
    -0.02963847f, -0.10301136f, -0.00957575f, -0.04289562f, -0.07133884f, -0.00888461f, 0.05317572f, -0.11622677f, 
    -0.02327383f, 0.07726697f, 0.03325795f, -0.06369762f, 0.29729044f, 0.22420940f, -0.06390718f, -0.03361523f, 
    0.15500344f, 0.03914053f, 0.15486452f, 0.01739342f, -0.06952213f, -0.06265523f, -0.08307052f, -0.04171669f, 
    0.31191257f, 0.25379461f, -0.01449268f, -0.18159124f, 0.07141762f, 0.06913687f, 0.02128534f, -0.03378548f, 
    -0.03429022f, -0.09568713f, -0.03416217f, -0.03011648f, 0.09287133f, 0.01731783f, -0.00036637f, 0.07141602f, 
    0.09972964f, 0.08610787f, 0.06837701f, -0.00252785f, 0.03087924f, 0.04015632f, -0.02399725f, 0.08115962f, 
    0.16715707f, -0.00945475f, -0.05602442f, -0.08681960f, -0.04925814f, -0.01545353f, 0.01802879f, -0.05580230f, 
    -0.01170139f, 0.00000548f, 0.19822001f, -0.04823514f, 0.14662363f, -0.06418809f, 0.10012707f, -0.05700113f, 
    -0.04342213f, -0.10972669f, 0.02548224f, -0.07990801f, 0.01567241f, 0.05679853f, -0.03384783f, 0.03109840f, 
    -0.15595888f, -0.19341773f, -0.07816781f, -0.02268921f, -0.01108175f, 0.02257778f, -0.00387461f, -0.01114088f, 
    0.07716302f, -0.04260825f, -0.08113731f, -0.04606306f, -0.02425739f, 0.02296099f, -0.01266596f, 0.04920127f, 
    -0.12761894f, -0.16712511f, 0.01098323f, -0.01512485f, -0.02101458f, 0.06119036f, 0.03520967f, -0.00268164f, 
    0.43538257f, 0.35235488f, -0.09830783f, -0.08666687f, -0.07714154f, -0.16332306f, 0.06247264f, -0.08258089f, 
    -0.04310445f, -0.01489802f, -0.00676765f, 0.04558629f, 0.22964096f, 0.04022664f, -0.07906923f, -0.17251880f, 
    0.13435748f, -0.08247244f, -0.04181549f, 0.27221754f, 0.00928955f, 0.13147111f, -0.03442002f, -0.06190672f, 
    -0.18260814f, -0.45023003f, 0.05405308f, -0.01036908f, -0.02857095f, 0.00010750f, 0.05868928f, 0.04824173f, 
    -0.10265451f, -0.04308360f, -0.01073604f, -0.09958559f, -0.17345122f, -0.62263000f, 0.24479219f, -0.06884744f, 
    -0.00486752f, 0.00628141f, 0.08106121f, -0.08451592f, -0.01707862f, 0.01329265f, 0.02546330f, 0.03809940f, 
    0.18925026f, 0.22787876f, -0.00760487f, -0.39169431f, -0.12887868f, -0.05749988f, -0.01356104f, -0.16922934f, 
    0.00020784f, 0.00911247f, -0.01043293f, -0.12519655f, -0.18942888f, -0.04348195f, 0.03459305f, 0.02087264f, 
    0.01019451f, 0.07999732f, 0.02901223f, 0.02015500f, -0.01212742f, 0.02916805f, -0.00731703f, 0.12328219f, 
    -0.15371954f, -0.05605493f, 0.07503691f, -0.16217962f, -0.09055424f, 0.01776102f, -0.08359306f, 0.02694801f, 
    -0.00100968f, 0.04795682f, 0.02220932f, 0.03792260f, -0.46366215f, -0.18475576f, -0.47179925f, 0.06735303f, 
    -0.01305944f, 0.01832075f, -0.03172109f, 0.02197370f, -0.04878205f, 0.02597681f, -0.01912386f, 0.07849366f, 
    -0.27987838f, -0.00755909f, 0.32379973f, -0.05996291f, -0.04018254f, -0.03124142f, -0.19702892f, 0.06707628f, 
    0.05479789f, 0.01545544f, 0.01095038f, 0.02791119f, 0.34064052f, 0.22608666f, -0.09241774f, -0.09330528f, 
    0.16357718f, 0.13654776f, 0.08744127f, 0.00944824f, -0.01217250f, -0.07188201f, 0.02705629f, -0.01628091f, 
    -0.08323478f, -0.32142907f, -0.23243706f, -0.06663308f, -0.03566698f, -0.07630153f, -0.09765892f, 0.05388220f, 
    -0.03553386f, -0.11535283f, -0.28923416f, -0.17568158f, 0.19637166f, 0.03697249f, -0.07207220f, 0.06430787f, 
    0.09433941f, 0.12331030f, -0.14910665f, -0.09433407f, -0.04145841f, -0.03491956f, 0.05437785f, 0.06480401f, 
    0.25827026f, 0.03322985f, -0.17885736f, 0.05813158f, -0.02781324f, -0.06633703f, -0.07309847f, -0.11110070f, 
    0.00682472f, 0.00434022f, -0.16524661f, -0.06901515f, -0.17547286f, -0.13411596f, -0.14796422f, 0.00996443f, 
    0.02258058f, 0.00754586f, 0.01316337f, 0.00129171f, -0.08653692f, 0.06178238f, 0.00012388f, -0.01368493f, 
    -0.14947358f, 0.21546806f, 0.05462694f, -0.04653659f, -0.05488694f, 0.10805096f, 0.14809443f, -0.09048847f, 
    -0.15601833f, 0.04559969f, -0.15768050f, -0.13028981f, 0.08825963f, 0.09210359f, 0.05573920f, 0.04024750f, 
    0.11913003f, 0.08900971f, 0.03928038f, -0.01618012f, -0.14456247f, -0.10262895f, -0.10267528f, -0.00414741f, 
    0.11408568f, 0.01814204f, 0.31613231f, -0.15143023f, -0.00759882f, 0.08110071f, -0.02240916f, 0.00521448f, 
    -0.00140867f, -0.13108121f, -0.14555892f, 0.01262667f, -0.11718056f, -0.59718525f, -0.24670930f, 0.06246830f, 
    0.00019251f, 0.00329597f, -0.02325339f, 0.01082551f, 0.06301140f, -0.04188499f, 0.03333150f, 0.02545337f, 
    0.13890341f, -0.38265097f, -0.09714276f, -0.03742630f, -0.06433146f, -0.02062943f, 0.03175475f, -0.06368165f, 
    0.02063262f, 0.01442419f, -0.06270016f, 0.00813403f, 0.01284393f, -0.17594621f, -0.37769389f, 0.11455911f, 
    0.06962417f, 0.04393141f, 0.06481272f, -0.05736082f, 0.14626263f, 0.03390357f, -0.16381420f, -0.16186607f, 
    -0.08856683f, 0.14827771f, 0.09010053f, -0.19541855f, -0.06459717f, -0.01365915f, -0.08468268f, -0.14257820f, 
    -0.00196228f, -0.06788694f, -0.00591950f, 0.09362196f, 0.00078202f, -0.04543620f, 0.00509752f, 0.04097990f, 
    0.05164519f, 0.03777787f, 0.05254509f, 0.03217687f, -0.26001740f, -0.33160290f, -0.28654483f, -0.12648982f, 
    -0.21492894f, -0.38197905f, 0.03580073f, -0.00028426f, 0.05306241f, -0.04539135f, 0.10745091f, 0.03414332f, 
    0.03544133f, 0.03960912f, 0.07354163f, 0.03779116f, 0.05363576f, -0.08679808f, -0.20904085f, 0.16056144f, 
    0.00521766f, -0.05420247f, 0.04221632f, 0.06201629f, -0.08849750f, 0.10926011f, -0.09837152f, 0.03327180f, 
    0.41335115f, 0.19355753f, -0.11155300f, 0.04346419f, 0.12049939f, 0.02469574f, 0.10613766f, -0.24218197f, 
    -0.08820982f, -0.04777246f, -0.03557466f, 0.00461237f, 0.05111965f, 0.18477090f, -0.05455223f, -0.17606208f, 
    -0.18908444f, -0.06621402f, 0.08376972f, 0.02573294f, -0.12277400f, -0.09647302f, 0.04228155f, -0.12016518f, 
    -0.50695330f, -0.22476761f, 0.24223359f, 0.07627830f, -0.07769798f, 0.03710515f, -0.06379942f, 0.03505014f, 
    0.02348302f, -0.00990239f, -0.03855917f, 0.05909309f, -0.06822523f, -0.14602791f, -0.19638553f, 0.04424960f, 
    -0.01411210f, 0.00081443f, -0.05085812f, -0.10490376f, -0.16471933f, -0.18287706f, -0.17144619f, -0.04267183f, 
    0.22021960f, 0.20956668f, -0.03563536f, -0.15587728f, 0.14136998f, 0.04286532f, 0.08122569f, 0.02577901f, 
    -0.00881220f, -0.02586061f, -0.01919374f, 0.00061540f, -0.08682227f, 0.25007406f, -0.00984483f, -0.16040497f, 
    0.00415506f, -0.01263843f, -0.03991881f, -0.00557942f, -0.01006135f, 0.02823827f, 0.12702668f, -0.21886991f, 
    0.33570272f, 0.19987240f, -0.10939176f, -0.11866736f, 0.05556924f, 0.13610122f, 0.07643356f, 0.04323842f, 
    -0.04784573f, 0.00999308f, 0.05004653f, 0.07314117f, 0.30279410f, 0.11513836f, 0.01510093f, -0.21279557f, 
    0.05122237f, 0.04094796f, 0.06419007f, 0.05238659f, -0.00813631f, 0.02684155f, -0.03285272f, -0.15966482f, 
    -0.24555252f, -0.13127802f, 0.08088814f, 0.04139869f, 0.01021915f, 0.06312169f, -0.11153308f, 0.06195897f, 
    0.03674988f, -0.04570076f, 0.07896590f, 0.16901843f, 0.24902914f, -0.26474780f, -0.21081151f, 0.08906759f, 
    0.03131054f, 0.03402540f, -0.20120078f, -0.27518755f, -0.16536060f, -0.14598250f, -0.07545663f, 0.00147925f, 
    -0.12498974f, -0.11598288f, 0.09112924f, 0.03907125f, -0.06486300f, -0.17091848f, 0.02751534f, -0.04323972f, 
    -0.04635110f, 0.02565554f, 0.02679022f, -0.14186430f, 0.24078843f, 0.21754234f, -0.31833509f, -0.07338496f, 
    -0.01903334f, 0.08909069f, -0.04077660f, 0.01906685f, -0.11211487f, -0.03390343f, 0.02729315f, 0.05110197f, 
    0.01621611f, -0.27317816f, -0.37104887f, -0.00887619f, -0.00728853f, -0.01314855f, -0.01268511f, -0.12520383f, 
    -0.02294590f, -0.02364003f, 0.01559012f, 0.00649004f, -0.09839736f, -0.47038314f, 0.14480022f, -0.03628772f, 
    -0.03709705f, 0.09457120f, -0.00011296f, -0.05427245f, 0.03778923f, -0.03312668f, -0.17349482f, -0.16194922f, 
    -0.12282153f, 0.13645649f, 0.17240307f, -0.21883589f, -0.06060916f, -0.07659583f, 0.00415251f, -0.05779186f, 
    -0.04060886f, -0.03345867f, -0.24895173f, -0.04076590f, -0.17765166f, -0.04294086f, -0.00242964f, 0.00992159f, 
    0.00607904f, 0.07431875f, -0.01347466f, 0.01140772f, -0.04468358f, -0.12583894f, -0.04241569f, 0.04185973f, 
    -0.43745583f, 0.11805920f, 0.12686585f, -0.08428154f, 0.05556038f, 0.03864573f, -0.05491950f, 0.02996453f, 
    0.02689492f, 0.04091954f, 0.08284979f, -0.08814879f, 0.24692154f, -0.24039631f, -0.47240415f, 0.16975865f, 
    -0.08171698f, 0.01789188f, 0.13793834f, -0.06509960f, -0.11178687f, -0.01184364f, 0.03687911f, -0.09593123f, 
    0.13644899f, 0.23227501f, 0.05639544f, 0.00680617f, 0.05043296f, -0.14617747f, -0.16997734f, -0.21215856f, 
    -0.12885620f, -0.08713841f, 0.02281997f, 0.02064717f, -0.05895273f, 0.00546564f, 0.14467536f, 0.01058040f, 
    -0.13212922f, 0.13024303f, -0.04466965f, -0.07936937f, 0.05745735f, -0.00072118f, 0.02878941f, -0.01789858f, 
    -0.02107169f, 0.04595967f, -0.11506474f, 0.07281497f, 0.10950508f, 0.02625904f, 0.01057301f, 0.04299404f, 
    -0.08882397f, 0.14863876f, 0.10613440f, 0.01272602f, -0.05294891f, 0.03609379f, 0.06052603f, -0.14203215f, 
    -0.03248682f, -0.18167122f, -0.07635645f, 0.18120399f, -0.08688872f, -0.01917814f, -0.07370064f, 0.10793058f, 
    0.13837171f, 0.27071452f, -0.12419682f, -0.14143246f, -0.01331864f, -0.08776265f, -0.12357903f, 0.07988534f, 
    -0.06452235f, -0.02034758f, -0.05913325f, -0.06544475f, 0.58519399f, 0.06705476f, -0.08224245f, -0.07127865f, 
    -0.04108469f, -0.00723032f, 0.05998204f, -0.28229752f, 0.07237491f, -0.18356064f, -0.26806837f, -0.05901380f, 
    -0.60848111f, 0.18590358f, -0.23967925f, -0.33279169f, -0.01812970f, 0.06600232f, -0.01165185f, 0.06627940f, 
    0.00806062f, 0.13234723f, -0.25596052f, -0.06727856f, 0.13014479f, -0.02307107f, 0.13326758f, 0.03729918f, 
    0.09660871f, 0.06461179f, -0.19470613f, 0.01756102f, -0.37425169f, -0.07872753f, -0.13225234f, -0.14259261f, 
    -0.11622366f, -0.02237402f, 0.07215197f, -0.05493695f, 0.11435918f, 0.09653107f, -0.14557201f, -0.20021288f, 
    0.00143315f, 0.14666040f, -0.04902467f, -0.05467102f, 0.09630191f, 0.05847913f, 0.00498914f, 0.00209489f, 
    -0.00946557f, 0.01416229f, -0.10957549f, 0.04826864f, -0.03396003f, 0.01858817f, -0.04093558f, 0.03020904f, 
    -0.00434918f, -0.04077985f, -0.04801841f, 0.05832046f, -0.02962658f, -0.09220792f, 0.00245035f, 0.05187107f, 
    0.01441733f, 0.04032595f, -0.09146523f, -0.00775681f, 0.11012994f, 0.08378135f, 0.09538073f, 0.12342143f, 
    -0.01695800f, -0.00284937f, -0.01247429f, -0.02791002f, -0.02447209f, 0.02283544f, -0.01556550f, 0.08596183f, 
    -0.16747566f, -0.21861403f, -0.01112905f, -0.00553417f, 0.01592757f, 0.14998113f, -0.13042606f, 0.26846492f, 
    -0.00624306f, 0.01258903f, 0.04019965f, -0.00038991f, -0.00695416f, -0.19077229f, 0.13530327f, 0.00173425f, 
    -0.05500473f, -0.02826721f, 0.04241204f, -0.09307664f, 0.03015022f, -0.07079280f, 0.12960510f, -0.05647888f, 
    0.17100926f, 0.00579713f, -0.05621403f, -0.02473651f, -0.08114796f, -0.04534501f, -0.02286067f, -0.01160652f, 
    -0.02421255f, -0.08470111f, -0.16291761f, 0.11223085f, 0.25244480f, 0.12607995f, 0.19167541f, 0.00527423f, 
    -0.01912155f, 0.08344475f, 0.01183471f, 0.03569368f, -0.00444603f, 0.00684046f, -0.02553388f, -0.00877368f, 
    -0.34060490f, -0.00148409f, -0.03292961f, 0.18281165f, -0.07042149f, 0.13396275f, 0.07197637f, 0.27032730f, 
    -0.09004612f, -0.00098625f, -0.00221045f, 0.09965224f, -0.11609491f, -0.22573507f, -0.15878475f, -0.11989319f, 
    -0.02188537f, 0.04093038f, -0.03331405f, 0.06412716f, 0.05609295f, 0.01521804f, 0.05654131f, 0.00956477f, 
    -0.11632868f, -0.08429515f, -0.03253960f, 0.08415296f, -0.06411131f, 0.06086963f, 0.01229676f, -0.03837882f, 
    0.07376278f, -0.01721982f, -0.25378931f, -0.05300521f, -0.09755453f, 0.12043808f, -0.05480435f, -0.02452846f, 
    -0.08911870f, 0.11151502f, -0.05122586f, 0.10219089f, 0.06597227f, -0.13972637f, 0.11086151f, -0.04008095f, 
    0.14306442f, 0.06662999f, 0.07099871f, 0.16319752f, -0.02934424f, -0.00312336f, 0.02963327f, -0.01260910f, 
    0.12244126f, 0.08108116f, -0.05897319f, -0.00377968f, 0.13998386f, -0.01536663f, -0.01701311f, -0.01089026f, 
    -0.00383142f, 0.02460039f, -0.01478148f, 0.04513494f, -0.05449174f, 0.00787689f, 0.05162702f, 0.01621357f, 
    0.33137530f, -0.11146600f, -0.30518800f, -0.26687634f, -0.06931185f, 0.15387602f, -0.08620825f, -0.09764246f, 
    -0.04056492f, 0.06647891f, -0.00649441f, -0.06110218f, -0.02729800f, 0.03967911f, -0.27491000f, -0.25464842f, 
    -0.18498631f, -0.06717432f, 0.00758813f, -0.07871895f, -0.01111348f, 0.01148399f, -0.03932435f, 0.17487822f, 
    0.33846492f, 0.14552392f, 0.25811648f, 0.01815015f, -0.02313028f, -0.00049948f, 0.03692815f, 0.02189020f, 
    0.10200384f, 0.01829234f, -0.10874119f, -0.04438559f, 0.06017720f, 0.01459603f, -0.05385114f, -0.07951465f, 
    -0.02327362f, 0.05864171f, -0.02020314f, -0.08179318f, -0.01305369f, 0.01802005f, 0.07473274f, 0.03406341f, 
    -0.40084708f, -0.07011468f, -0.39501908f, 0.00837685f, -0.03814428f, -0.04556844f, 0.13018933f, 0.08582030f, 
    -0.04696315f, 0.00207056f, 0.09007154f, 0.10481330f, 0.07809485f, 0.07197973f, 0.07427438f, 0.09363344f, 
    0.01600631f, -0.02310244f, 0.00360707f, 0.02634351f, 0.01216908f, 0.03572045f, -0.02928728f, 0.08319970f, 
    0.16881460f, -0.08594665f, 0.06715081f, -0.21779495f, -0.06960692f, -0.01853532f, -0.16897684f, 0.11457190f, 
    0.05491595f, 0.01011969f, 0.01657750f, 0.04620641f, 0.42360160f, 0.10537363f, 0.18178268f, -0.08506081f, 
    -0.06211845f, -0.00723149f, -0.00309763f, -0.03685951f, -0.01436171f, -0.03988203f, 0.03045146f, 0.00746319f, 
    0.05760054f, 0.29399347f, -0.41701451f, -0.11651922f, -0.04400566f, -0.02224193f, -0.02819139f, -0.11822928f, 
    0.00595128f, 0.00598587f, 0.02132713f, 0.05385489f, 0.01787383f, 0.08625112f, 0.09855133f, 0.27994636f, 
    -0.01339200f, 0.04504227f, -0.04917100f, -0.08378077f, 0.02306182f, 0.03187263f, 0.03095055f, 0.05993857f, 
    0.02557558f, -0.08080474f, 0.09753087f, 0.06218220f, 0.01219477f, 0.01997906f, 0.07737263f, -0.02032420f, 
    0.14942785f, -0.07334927f, 0.20172888f, 0.01206115f, -0.01445001f, -0.12676427f, -0.04135274f, -0.04796239f, 
    0.12447307f, 0.07640812f, -0.16284148f, -0.07542414f, 0.12462959f, 0.01246086f, -0.07069615f, -0.00014628f, 
    0.17395318f, -0.02194266f, -0.02168729f, -0.17942983f, -0.01377789f, 0.00001874f, -0.04267263f, 0.09347828f, 
    -0.02951609f, -0.18824211f, -0.32205361f, -0.29057932f, 0.16121684f, 0.01140540f, 0.09636672f, 0.11480056f, 
    0.01887711f, -0.06485336f, -0.03169632f, -0.00840820f, -0.01603940f, 0.00913362f, -0.02153493f, 0.10822716f, 
    -0.17455442f, 0.09613100f, -0.17892870f, 0.12849541f, 0.00925231f, 0.00948868f, 0.01897469f, -0.03094004f, 
    -0.19706436f, 0.10760149f, 0.07496148f, -0.06821766f, -0.09036758f, -0.03904946f, -0.01121147f, 0.02049861f, 
    0.00516988f, 0.01542595f, 0.05311066f, 0.05708658f, -0.07479264f, -0.00385886f, 0.03892383f, 0.03650387f, 
    -0.00138929f, 0.20838082f, -0.15092219f, -0.04766923f, -0.08582074f, -0.00937196f, 0.02379753f, 0.12878542f, 
    -0.09182208f, -0.00486532f, 0.02831193f, -0.02517971f, 0.87979603f, -0.02977546f, 0.35612950f, 0.04233553f, 
    -0.05691999f, -0.04021797f, 0.03873058f, 0.03743104f, -0.07434972f, 0.00640554f, -0.05220326f, 0.14859833f, 
    0.54463875f, -0.08087101f, -0.16733746f, 0.22360958f, -0.06644184f, -0.06160522f, 0.06814811f, -0.15150620f, 
    0.07911373f, -0.09467778f, -0.04722256f, -0.14508907f, 0.28721327f, -0.01829957f, -0.19950223f, 0.03100809f, 
    0.00034566f, -0.03317418f, 0.04164055f, -0.01500012f, 0.08009516f, 0.15677917f, 0.17354330f, -0.00072943f, 
    -0.01569097f, -0.07250901f, 0.19475290f, -0.07881579f, 0.04500831f, -0.17313375f, -0.16247882f, -0.02690979f, 
    -0.09153201f, -0.07294668f, 0.14015166f, 0.06440923f, 0.08149952f, 0.04178578f, 0.07348288f, 0.06029471f, 
    -0.00868965f, -0.00538194f, 0.03429498f, -0.02500473f, -0.08086138f, 0.10772397f, 0.09556680f, 0.00812037f, 
    0.24183372f, 0.15342209f, 0.15457465f, 0.23593761f, 0.02093939f, 0.01575583f, -0.01091503f, 0.05008771f, 
    0.02342787f, -0.00435280f, 0.00499156f, 0.03894134f, 0.07674000f, -0.15664256f, -0.11270869f, -0.16263399f, 
    -0.02320594f, 0.04608728f, -0.01881157f, 0.05605477f, 0.15200159f, 0.12236702f, 0.25190181f, -0.03677610f, 
    -0.15946335f, -0.04719884f, -0.11502123f, 0.04244177f, -0.05664680f, 0.05425671f, 0.15716071f, -0.13412663f, 
    -0.04840259f, -0.01729466f, 0.08249043f, -0.03050934f, -0.06481926f, -0.01825140f, 0.15056823f, 0.02880756f, 
    0.04331660f, -0.03258210f, 0.04888491f, -0.00809704f, 0.35454801f, -0.14706051f, -0.26492354f, 0.18745099f, 
    0.15505794f, -0.15193547f, 0.07347917f, 0.08699405f, -0.03960743f, 0.02195666f, -0.00415887f, 0.06212045f, 
    0.07540027f, -0.05322773f, 0.10718537f, -0.13032728f, 0.17748325f, -0.00050372f, -0.00491116f, -0.22374941f, 
    -0.07194873f, 0.08775063f, 0.04685741f, 0.10831643f, 0.00889000f, 0.05800973f, -0.16059294f, 0.01093703f, 
    -0.00371113f, 0.21693315f, 0.10086593f, 0.06450564f, -0.18448728f, -0.00191269f, -0.09017900f, -0.10502054f, 
    -0.03970494f, 0.01724330f, -0.00275335f, -0.00391812f, -0.06151989f, 0.11377262f, 0.02743156f, 0.06586871f, 
    -0.01901220f, -0.02984398f, -0.01331094f, -0.05145891f, 0.02940220f, -0.00444115f, -0.27098417f, -0.09152516f, 
    0.32518867f, 0.21260560f, 0.23997568f, 0.13255255f, 0.16492139f, -0.02074626f, -0.22848096f, -0.05962604f, 
    0.05028541f, 0.02583398f, 0.00897537f, -0.12896954f, -0.13098821f, 0.04388243f, -0.01456350f, -0.08613437f, 
    -0.10364410f, -0.06776595f, -0.07278440f, 0.07651103f, 0.06038794f, -0.11965305f, 0.02619879f, 0.00418363f, 
    -0.07527737f, -0.01815893f, 0.07181235f, -0.04410361f, 0.12044803f, 0.05601306f, -0.13091080f, -0.05743771f, 
    -0.32308567f, -0.07663653f, -0.07303159f, -0.34632388f, 0.20139693f, -0.62297052f, 0.13824564f, -0.15182391f, 
    -0.02696504f, 0.04898744f, 0.10458110f, 0.18008603f, 0.14378448f, -0.02884376f, 0.09653847f, -0.00692143f, 
    0.47094551f, 0.00016512f, 0.06215247f, -0.13546565f, -0.14180380f, 0.20170860f, -0.01405557f, -0.26934484f, 
    0.00572154f, 0.15983003f, -0.21367660f, 0.03856560f, 0.11252542f, -0.36725584f, -0.07358942f, 0.10444303f, 
    0.05589041f, -0.01343419f, -0.09827573f, 0.07413089f, -0.09174570f, -0.11451799f, -0.02728803f, -0.24821271f, 
    0.58575612f, 0.02093820f, -0.47849882f, -0.23803379f, 0.01370958f, 0.02841295f, -0.03080850f, -0.03909151f, 
    -0.02379102f, 0.07694080f, -0.05844525f, -0.24872129f, 0.03584348f, -0.08140194f, -0.28337708f, -0.64635611f, 
    -0.02787511f, -0.00721007f, -0.06435704f, 0.02460674f, -0.27870122f, 0.08660056f, -0.12247365f, -0.10687654f, 
    0.00712657f, -0.00198572f, -0.01170013f, 0.02980042f, -0.01411538f, 0.00994143f, -0.03235199f, 0.07934684f, 
    -0.00154125f, 0.15917897f, 0.06874763f, -0.02694496f, 0.13028164f, -0.02904838f, 0.09215921f, 0.03358608f, 
    -0.03952834f, -0.03355240f, 0.05522423f, -0.00091381f, 0.08712317f, -0.10308879f, 0.16063936f, 0.10996973f, 
    -0.22505875f, 0.05343460f, 0.03326389f, 0.06051465f, 0.10241567f, 0.02001605f, -0.02956933f, -0.04851818f, 
    0.30444273f, 0.03583432f, -0.17516747f, 0.06995900f, 0.39986876f, -0.07447957f, 0.06663658f, 0.22915690f, 
    -0.08183853f, -0.18571039f, 0.06613007f, 0.10535529f, -0.18238716f, 0.20786847f, 0.00410141f, 0.06217891f, 
    -0.17941211f, 0.18569131f, -0.00452020f, 0.08597645f, 0.00025733f, -0.01288551f, 0.06866150f, 0.05935975f, 
    0.16532324f, 0.09889720f, 0.14197241f, -0.27818528f, -0.15568548f, 0.03310315f, 0.04943883f, -0.16302215f, 
    -0.03099965f, 0.09454378f, 0.00631330f, -0.17763695f, -0.02594484f, 0.00445917f, -0.04844141f, -0.09395380f, 
    -0.08214267f, 0.12090748f, -0.06444328f, 0.03582006f, 0.13977189f, -0.17340839f, -0.05040261f, 0.03704983f, 
    0.06136465f, -0.02383001f, 0.02626703f, 0.05003530f, -0.26941249f, -0.21694441f, 0.11644536f, -0.52198333f, 
    0.07198971f, -0.05495013f, -0.08938998f, 0.00891785f, -0.00760930f, -0.03254778f, -0.19229449f, 0.04825965f, 
    -0.30071470f, 0.28113085f, 0.02457831f, 0.04334747f, -0.02982309f, -0.06129424f, 0.07108700f, 0.07163581f, 
    -0.03228885f, 0.02565239f, -0.01707659f, 0.04750448f, -0.16072233f, 0.43956956f, 0.26949558f, -0.00898582f, 
    -0.08120739f, 0.00325384f, -0.11353790f, -0.20705228f, 0.01965483f, 0.01994958f, -0.00018118f, 0.10943761f, 
    -0.15044299f, -0.15050207f, -0.31449598f, 0.19875559f, 0.00088365f, -0.03179627f, -0.05850443f, 0.00976449f, 
    -0.07646647f, 0.04479264f, -0.09170051f, 0.11454493f, -0.20976284f, -0.01041280f, 0.09749127f, -0.08761049f, 
    -0.03107600f, -0.01961135f, 0.02030191f, -0.15804029f, 0.07958684f, 0.03740244f, 0.05228907f, -0.07763927f, 
    0.13443890f, 0.04528817f, -0.02231119f, 0.00134400f, 0.03588867f, -0.06124409f, 0.19469911f, -0.10314626f, 
    -0.01593939f, 0.07487448f, 0.09396905f, 0.10196119f, -0.64206254f, -0.05086308f, -0.17316195f, -0.29471514f, 
    -0.08880320f, 0.00971032f, 0.02918375f, -0.01633633f, -0.02231539f, -0.00135631f, -0.03664665f, -0.03534400f, 
    0.08749310f, -0.08930749f, -0.04154213f, -0.11505172f, 0.07847625f, -0.14779685f, 0.02056867f, -0.01849926f, 
    -0.06827307f, 0.02503921f, -0.11248466f, 0.06456170f, -0.17146146f, -0.11089671f, -0.03495221f, 0.04032226f, 
    -0.01479419f, -0.00454569f, 0.01171712f, 0.06246386f, -0.09078811f, -0.01204652f, 0.03556259f, -0.00228278f, 
    0.13748084f, 0.18160169f, -0.06637812f, 0.13522626f, 0.04418262f, -0.03014041f, 0.02353541f, -0.09811231f, 
    -0.00356157f, 0.05016681f, -0.06289206f, 0.14277151f, 0.00387613f, -0.15805520f, 0.46003580f, 0.12166277f, 
    -0.02078660f, -0.00716252f, 0.14474130f, 0.04190502f, 0.07331818f, -0.02452525f, -0.08169945f, -0.05061534f, 
    -0.10313208f, 0.03156782f, 0.05764279f, 0.03175843f, 0.02461491f, -0.04270212f, -0.08925743f, -0.07917447f, 
    0.05784776f, 0.01468170f, -0.05907621f, 0.15811358f, -0.05714059f, -0.35322356f, 0.32808900f, 0.26881361f, 
    -0.13434578f, 0.10902835f, -0.04854068f, 0.07054808f, -0.02026872f, 0.00151038f, 0.02440128f, -0.10217327f, 
    0.08716518f, -0.39186034f, -0.23023525f, -0.03735035f, -0.05270840f, -0.07971998f, 0.05382627f, -0.01474182f, 
    0.02261177f, -0.03751319f, -0.07676428f, -0.06532289f, 0.16163372f, 0.36116132f, 0.24401817f, 0.26568624f, 
    -0.04073208f, -0.00571621f, 0.05095365f, -0.04077962f, -0.13848960f, -0.05399996f, 0.06613856f, 0.10369450f, 
    0.03189930f, -0.00360752f, -0.03039828f, 0.10698831f, -0.02620413f, -0.01049621f, 0.06510838f, 0.11048475f, 
    0.14473011f, 0.05762139f, 0.13005470f, 0.11018524f, 0.05604091f, 0.05021722f, -0.01090495f, 0.04466603f, 
    -0.00476071f, -0.14388041f, -0.08405101f, 0.02081789f, 0.07557721f, -0.05019529f, 0.01408218f, -0.01364153f, 
    -0.03965874f, 0.02255425f, 0.00019985f, 0.09320349f, -0.07485470f, 0.06541978f, 0.01077536f, 0.14089577f, 
    0.05508053f, 0.15229332f, 0.00626001f, -0.14240155f, -0.07475104f, -0.08293369f, 0.01645798f, -0.03166797f, 
    -0.06571544f, -0.12515666f, -0.09439608f, 0.05959057f, 0.01876435f, 0.01284884f, -0.01069015f, -0.00384371f, 
    0.21560553f, 0.12058970f, -0.04400609f, -0.16248854f, 0.04124750f, 0.10918001f, -0.07742224f, 0.09383539f, 
    -0.05862758f, 0.05014677f, 0.06537029f, -0.07286721f, -0.46505052f, -0.28139964f, -0.34419149f, -0.06733949f, 
    0.04985441f, 0.00311171f, -0.09742116f, -0.25331870f, 0.04521707f, 0.02048402f, -0.05025970f, 0.00708555f, 
    -0.10758220f, 0.10833908f, -0.03849372f, -0.29423076f, 0.08098114f, 0.00012047f, -0.04233646f, 0.01856918f, 
    -0.03818750f, 0.07576624f, -0.10744427f, -0.01419396f, -0.13024884f, 0.15650396f, -0.15322843f, 0.09003694f, 
    -0.00509680f, -0.03073419f, -0.01922801f, 0.05569423f, 0.02785440f, 0.02931731f, 0.07785349f, -0.00354780f, 
    -0.30297402f, -0.22279936f, -0.18832767f, 0.09308494f, 0.00769649f, -0.04252321f, -0.18015762f, -0.02810243f, 
    0.03142832f, 0.03961006f, -0.05153229f, -0.02168239f, -0.10916853f, -0.05811042f, -0.03572230f, -0.07749134f, 
    0.02060101f, -0.01074653f, -0.07437457f, 0.04253910f, -0.01834095f, -0.07934357f, -0.00797515f, 0.12803128f, 
    -0.24508509f, -0.01815923f, 0.23728295f, -0.13113397f, -0.06019581f, -0.13834575f, -0.05757940f, -0.12511235f, 
    0.08128785f, -0.01380848f, 0.01885903f, 0.04757944f, -0.40480652f, 0.05417592f, 0.47526020f, -0.71160746f, 
    0.01486394f, -0.00836621f, -0.04497752f, 0.05012187f, 0.02206895f, -0.01343274f, 0.01305275f, 0.00336819f, 
    -0.52333939f, 0.31222865f, 0.06149230f, 0.06249284f, -0.00768459f, 0.00115442f, 0.10308028f, 0.11999737f, 
    -0.03513914f, -0.03756362f, -0.00159576f, -0.01998121f, -0.51606262f, -0.21235791f, -0.21037647f, -0.13453147f, 
    -0.15822917f, -0.09423695f, 0.03734877f, -0.02492126f, 0.02817579f, 0.05753325f, 0.02778446f, -0.05841404f, 
    0.08519729f, -0.02848113f, -0.08681052f, -0.20157497f, -0.02746289f, -0.00464704f, -0.00898708f, 0.15366532f, 
    -0.14095689f, 0.00233105f, 0.02816683f, -0.09067816f, 0.24123514f, -0.08091269f, 0.16361380f, -0.06422672f, 
    -0.03122998f, 0.02003647f, -0.11317138f, -0.06017921f, 0.01845990f, 0.09696542f, -0.01691844f, 0.04688085f, 
    -0.04359037f, -0.01119008f, 0.17822050f, -0.02365340f, -0.04973079f, -0.05805005f, 0.13961910f, -0.04779445f, 
    0.08400723f, 0.10437687f, -0.09912492f, 0.02480493f, -0.02264297f, -0.00995971f, -0.05695253f, -0.05098063f, 
    -0.00998410f, -0.06159905f, -0.02544286f, 0.06332083f, 0.02591107f, -0.07950876f, 0.01422422f, 0.15039411f, 
    -0.11415330f, -0.16091467f, 0.10039161f, 0.21150586f, 0.01862824f, 0.02220958f, 0.00729061f, 0.06951670f, 
    0.10563246f, -0.02515090f, -0.03790353f, 0.14817540f, -0.02142373f, -0.11182705f, 0.01149709f, 0.03355851f, 
    0.02018645f, -0.00191579f, 0.01620167f, -0.01095740f, -0.07959368f, -0.19247270f, 0.01609059f, -0.01458007f, 
    -0.04161580f, -0.16017321f, 0.07847962f, 0.11998132f, 0.12839538f, 0.01811803f, 0.03537316f, 0.10358503f, 
    -0.20113248f, -0.04928987f, 0.01655775f, 0.07261902f, -0.14976229f, -0.18780027f, -0.14093487f, -0.32408607f, 
    -0.02104422f, -0.03413610f, 0.02652130f, -0.01342269f, -0.02346940f, 0.02685373f, 0.05944214f, -0.05343328f, 
    -0.24285431f, 0.18969560f, 0.12611732f, -0.08448237f, 0.07369503f, -0.08171628f, -0.02727096f, -0.04141681f, 
    0.07317105f, 0.00394338f, -0.02587610f, -0.22856702f, -0.29451293f, 0.20059983f, 0.01897523f, -0.04061794f, 
    0.04531438f, -0.00210347f, 0.03134910f, 0.01077522f, -0.17344472f, -0.12142454f, 0.11315382f, -0.15984006f, 
    -0.49164823f, 0.20947514f, -0.05378937f, 0.05505916f, -0.08747107f, 0.16181342f, -0.03819917f, -0.08694538f, 
    0.03302703f, -0.05110740f, 0.07657242f, -0.02224526f, -0.25689831f, 0.03044229f, -0.01007336f, 0.01413436f, 
    -0.01755672f, -0.00561181f, -0.03028740f, -0.00280000f, -0.04078226f, -0.17042741f, 0.14576644f, 0.05942548f, 
    -0.00225241f, -0.15008174f, -0.15750101f, -0.15215266f, 0.05401108f, -0.04227167f, 0.01083463f, 0.03037341f, 
    0.04767694f, -0.05984766f, 0.03729054f, -0.06095518f, -0.23154931f, 0.18405770f, 0.19139814f, -0.12961589f, 
    -0.03003362f, -0.01292403f, -0.03276574f, -0.24404572f, 0.14440803f, 0.04543122f, -0.00271943f, 0.17117959f, 
    0.08622878f, -0.02459400f, 0.21228668f, 0.08179689f, -0.03026622f, -0.00261417f, 0.01821742f, 0.03198554f, 
    0.03658876f, 0.04528200f, 0.14037065f, 0.01360080f, 0.11347941f, -0.07519749f, -0.17417912f, 0.03674567f, 
    0.07108031f, 0.00567615f, -0.04567401f, 0.18090597f, 0.05851704f, 0.10073102f, -0.10250415f, 0.10303413f, 
    0.04387466f, 0.03213857f, -0.10095085f, 0.05466058f, -0.01301528f, 0.04048651f, 0.03752905f, 0.01143564f, 
    0.04618704f, 0.00586946f, 0.00254629f, 0.09459224f, -0.04635846f, 0.07087966f, -0.21857922f, 0.00997239f, 
    0.01990609f, 0.11353700f, -0.02190382f, -0.12090389f, 0.13281816f, 0.14306609f, -0.18708234f, 0.13507178f, 
    -0.46074131f, -0.25150013f, -0.30965465f, -0.15960975f, -0.15060246f, 0.09149348f, 0.09658493f, -0.14615700f, 
    -0.00397439f, -0.05363405f, 0.02889317f, 0.00778460f, 0.12551390f, -0.00360328f, 0.03470026f, 0.05431859f, 
    -0.02800093f, 0.02599958f, -0.11307663f, 0.06964388f, -0.03459476f, 0.04747547f, -0.00563673f, -0.00198744f, 
    0.09381229f, 0.00483541f, 0.68039042f, 0.48586625f, -0.06127921f, 0.05762782f, -0.07094554f, 0.06080133f, 
    0.05554543f, -0.00265408f, 0.01296949f, 0.07764873f, -0.01501903f, 0.01682153f, 0.04312610f, 0.14295465f, 
    -0.00396887f, -0.11036064f, 0.07219175f, 0.16039944f, 0.01928429f, 0.05295757f, -0.03764472f, -0.02252631f, 
    0.10048285f, 0.04321369f, -0.09176253f, 0.12950546f, -0.04145791f, -0.02838445f, 0.06316151f, -0.18336652f, 
    0.04081654f, 0.15144444f, 0.16142222f, -0.01243313f, -0.20916699f, -0.14796363f, 0.24472560f, -0.05431012f, 
    -0.04225860f, -0.04429511f, 0.00121835f, -0.18382940f, -0.02789925f, -0.13505146f, 0.02622791f, -0.03294316f, 
    -0.19699214f, 0.11676798f, 0.13701092f, -0.06182520f, -0.18096048f, 0.04735183f, -0.17213437f, -0.18206918f, 
    0.02844723f, 0.11065968f, 0.00074093f, -0.00931505f, 0.12951499f, -0.29402462f, 0.18565331f, 0.22608925f, 
    0.07846632f, -0.04165127f, 0.05178829f, -0.04671833f, 0.02404999f, -0.02882210f, -0.00631708f, -0.02947086f, 
    -0.45592293f, 0.58965915f, 0.23245446f, 0.00866643f, 0.02809668f, 0.04690836f, -0.16811609f, 0.06683960f, 
    0.01786862f, 0.01485744f, -0.12202196f, 0.14671749f, 0.23916456f, 0.56063545f, 0.06880619f, 0.13985291f, 
    0.09459688f, -0.03414472f, -0.26896745f, 0.14607890f, 0.01182647f, -0.00320188f, -0.02548269f, -0.02530566f, 
    0.11231748f, -0.06529295f, -0.27159417f, 0.08566836f, 0.08299978f, 0.09655159f, 0.06518122f, -0.00190898f, 
    -0.03253108f, 0.02311360f, 0.05146028f, 0.18438527f, -0.07060000f, -0.00595079f, -0.03837435f, -0.08921467f, 
    0.01026639f, -0.02417556f, 0.00649032f, -0.03155175f, 0.09237255f, 0.06710912f, 0.03882020f, 0.02252069f, 
    0.02949519f, -0.22768393f, -0.03719239f, -0.00039754f, 0.05160818f, 0.02449050f, 0.04434857f, 0.03551624f, 
    -0.07945044f, -0.00241157f, 0.23120824f, 0.10937715f, 0.02949638f, 0.11798067f, -0.32319647f, -0.25034308f, 
    0.04648697f, -0.13078871f, 0.09223257f, 0.03106705f, 0.03963100f, 0.01922276f, 0.09876324f, -0.09196209f, 
    0.05960662f, -0.07787790f, -0.07454275f, 0.14239350f, -0.20092309f, -0.00244643f, -0.05902970f, 0.04588306f, 
    0.02030424f, 0.01272655f, 0.11136180f, -0.26924625f, 0.00387890f, 0.07217634f, 0.04191651f, 0.01204850f, 
    0.03826530f, -0.04102536f, -0.09480617f, 0.02806051f, -0.03648051f, -0.03957248f, 0.03830292f, -0.08997905f, 
    -0.10813607f, 0.12864408f, -0.16171673f, 0.15135707f, 0.03227740f, -0.12447573f, -0.23948690f, 0.05847644f, 
    -0.04038153f, -0.14805785f, 0.08197957f, -0.07961649f, 0.14599545f, 0.00857089f, 0.14773056f, 0.18390514f, 
    0.05010449f, 0.00869120f, -0.04135634f, 0.07146208f, 0.06974275f, 0.11382168f, -0.08362813f, 0.02605917f, 
    -0.09894319f, -0.20754263f, 0.12618697f, -0.04587366f, 0.01295495f, 0.03688731f, 0.05569221f, -0.01801310f, 
    -0.01146138f, 0.03282893f, -0.06925093f, 0.10708215f, -0.15441678f, 0.01979924f, 0.08463848f, 0.17673589f, 
    0.06822960f, 0.06631695f, 0.04637997f, 0.08078025f, -0.03254683f, 0.05329504f, 0.00145126f, 0.05150444f, 
    0.27552766f, 0.11816445f, -0.21686168f, -0.39709404f, -0.10830368f, -0.20207623f, 0.00217911f, 0.02098228f, 
    -0.06622081f, 0.03469627f, 0.09974753f, 0.03532503f, 0.06204880f, -0.13720049f, 0.19948202f, 0.19102740f, 
    -0.15843457f, -0.06751107f, -0.03083543f, 0.10183825f, 0.10442999f, -0.03505211f, 0.10799656f, -0.00995016f, 
    0.38089490f, -0.01243164f, 0.07822355f, 0.12786092f, 0.12182117f, -0.03992782f, 0.01914139f, -0.21800207f, 
    0.01150600f, -0.00676937f, 0.11900971f, 0.08766191f, -0.08633003f, -0.12247591f, -0.05277066f, 0.14847530f, 
    -0.01543988f, -0.00142291f, 0.09504206f, 0.03945151f, -0.02163493f, 0.00804303f, -0.06701234f, -0.03099207f, 
    -0.16659424f, 0.19983405f, -0.45336598f, -0.09718040f, -0.00562798f, 0.04538626f, -0.12264223f, 0.02733110f, 
    -0.15768884f, -0.04546376f, 0.31731251f, 0.10358189f, -0.13757965f, -0.24260233f, -0.12084904f, -0.32539874f, 
    0.04003525f, 0.04604759f, 0.11296960f, 0.04173655f, -0.14290315f, 0.00834527f, -0.03517402f, 0.05945443f, 
    0.04140497f, -0.08527985f, -0.05555433f, 0.07845879f, 0.02205938f, 0.01456119f, -0.00369160f, -0.00204185f, 
    -0.00879072f, 0.06047210f, 0.09263150f, 0.05868011f, -0.21219967f, 0.33547273f, 0.02473486f, -0.03669312f, 
    0.28937945f, 0.07168882f, 0.11143424f, 0.02565697f, -0.12963168f, 0.05916322f, -0.06644150f, -0.05197975f, 
    0.07016637f, -0.06196338f, -0.05512089f, -0.01575425f, 0.03786954f, 0.01897448f, 0.08030266f, 0.05484083f, 
    -0.06702451f, -0.04993374f, 0.10894613f, -0.02402595f, 0.10730327f, -0.13412961f, -0.05155728f, 0.18073064f, 
    0.00831839f, -0.04478618f, -0.04446564f, -0.13565344f, 0.00339132f, 0.08477743f, 0.03322326f, 0.09339186f, 
    0.04054034f, -0.06157480f, -0.14613263f, 0.08255539f, 0.07053465f, -0.02484461f, 0.11525514f, 0.23314972f, 
    -0.00549429f, -0.04735094f, -0.11514664f, -0.03018996f, 0.19038081f, -0.17571440f, 0.02027394f, 0.25027815f, 
    0.13317521f, 0.07990911f, 0.08485346f, -0.03487029f, -0.06941082f, -0.02722457f, -0.05729844f, 0.00088639f, 
    -0.02053111f, 0.32404795f, -0.21360087f, -0.24214715f, 0.16122216f, 0.04305915f, 0.00830549f, -0.11532290f, 
    -0.02577284f, 0.00117562f, -0.09911309f, -0.13693297f, -0.24050446f, 0.54419178f, 0.04338967f, 0.34597313f, 
    -0.05623709f, -0.05723574f, 0.03311246f, -0.18483268f, -0.03280120f, -0.02809692f, 0.06479871f, 0.22748190f, 
    0.19188924f, 0.57841128f, -0.13722490f, -0.19924434f, 0.00879347f, -0.17537449f, 0.06242347f, -0.03784163f, 
    -0.15805057f, -0.00715212f, -0.09252317f, -0.08254078f, -0.27698949f, -0.16443150f, -0.00079633f, 0.05467504f, 
    0.05786841f, -0.04074720f, -0.11254464f, 0.05570643f, -0.02620746f, 0.04703231f, 0.04027802f, -0.02631889f, 
    -0.22943839f, 0.14411494f, -0.08833890f, 0.03555756f, 0.01056511f, -0.05469029f, 0.02307002f, 0.03116307f, 
    -0.00407811f, -0.14158593f, 0.06756556f, 0.03328522f, -0.06097482f, -0.22857100f, 0.15558621f, 0.23845701f, 
    -0.04574526f, 0.19640079f, 0.04175044f, 0.18504587f, 0.09295949f, -0.09981348f, -0.16009407f, 0.03298971f, 
    -0.31062201f, -0.05851031f, -0.03453598f, 0.01614819f, -0.09933587f, -0.23206559f, -0.14070979f, -0.08128642f, 
    -0.06360828f, -0.00789776f, -0.10004280f, -0.15516222f, -0.69638526f, 0.50867510f, 0.02924412f, 0.42373785f, 
    0.00035102f, -0.09921037f, 0.00980316f, -0.14858174f, -0.02755466f, 0.05365394f, 0.02160579f, 0.04784621f, 
    0.03906092f, -0.06379587f, -0.11831781f, 0.07414871f, 0.11616834f, -0.08299907f, -0.08687831f, 0.13466345f, 
    0.05897033f, -0.02819931f, 0.05938520f, -0.12727807f, -0.02610069f, -0.19481863f, 0.01187710f, -0.12617321f, 
    -0.05402645f, 0.06178066f, 0.06659061f, 0.11805808f, 0.10606466f, 0.18686259f, -0.00219302f, 0.02663599f, 
    -0.13301171f, -0.06700943f, 0.31522983f, -0.07263606f, -0.09263714f, 0.11426263f, -0.11433215f, -0.07571089f, 
    0.06220245f, -0.12817742f, -0.06850514f, -0.03490982f, -0.25287277f, 0.03285285f, 0.46682590f, 0.20208204f, 
    -0.07303551f, -0.18252940f, -0.19715415f, -0.00533626f, 0.06677403f, 0.00556935f, 0.02879864f, 0.03330909f, 
    -0.03731861f, 0.09952268f, 0.02175651f, 0.36616164f, -0.10776892f, -0.14198479f, 0.14047006f, -0.04486195f, 
    -0.00892901f, 0.17043613f, 0.03297914f, 0.02118834f, -0.08673912f, -0.19977540f, -0.07196984f, 0.10388201f, 
    0.10600726f, -0.01048757f, 0.09881670f, 0.05376864f, -0.06272426f, 0.01259753f, -0.00181038f, -0.01595321f, 
    -0.17805636f, -0.15957828f, -0.12820503f, 0.03432389f, 0.09665325f, -0.01192006f, 0.04050954f, -0.08199608f, 
    0.05155689f, -0.03989241f, 0.00670595f, -0.22098480f, -0.22683471f, -0.14559637f, -0.01541712f, 0.38674840f, 
    -0.02027166f, -0.12400773f, 0.04381889f, -0.15907572f, -0.12151296f, -0.09452386f, -0.07916987f, 0.03362875f, 
    -0.36134255f, -0.06580834f, -0.03699322f, 0.18985951f, 0.00045265f, 0.07113138f, 0.10232340f, -0.04339442f, 
    0.04764484f, 0.04589435f, 0.05628447f, 0.05221887f, -0.26013130f, -0.26365864f, -0.07530433f, 0.00571480f, 
    -0.11152779f, 0.18739785f, -0.08805045f, -0.18002211f, -0.01617249f, -0.05997532f, -0.11989028f, -0.04419501f, 
    0.01834383f, 0.05570786f, -0.19929323f, -0.20955281f, 0.11748939f, 0.04147689f, -0.12083235f, 0.09733732f, 
    -0.14608084f, 0.03064688f, -0.11736821f, -0.02585646f, 0.08560757f, -0.10009519f, -0.02938944f, 0.17658016f, 
    0.03240499f, -0.04937924f, 0.03275659f, -0.12046346f, 0.01998017f, 0.06784159f, 0.11948787f, -0.07335776f, 
    -0.12940577f, 0.05105234f, -0.07435635f, -0.40157172f, 0.17290117f, -0.06788614f, -0.04076995f, 0.00069993f, 
    -0.19687195f, 0.02234489f, -0.06694636f, -0.07583149f, -0.05371572f, 0.39837515f, 0.07582686f, 0.19675584f, 
    0.10830748f, -0.01796230f, 0.08366150f, -0.00552200f, -0.04186487f, 0.07146244f, 0.05352984f, -0.03763541f, 
    -0.11058161f, 0.62500113f, -0.18100931f, 0.16187514f, 0.13118599f, -0.07131109f, 0.07104091f, 0.03675004f, 
    0.05321499f, -0.16754912f, -0.05789998f, -0.19601953f, -0.47402430f, -0.08171477f, -0.22162516f, -0.02430766f, 
    0.25513193f, 0.04067896f, 0.03958333f, 0.00287583f, -0.06531721f, -0.06404594f, 0.12890042f, 0.00679945f, 
    -0.06378912f, 0.05587799f, -0.17109527f, 0.12662607f, -0.11089766f, -0.07267816f, 0.11317490f, -0.12369586f, 
    0.02762730f, 0.03920836f, 0.00241495f, 0.03914999f, -0.54343015f, -0.33145604f, -0.24403593f, -0.07657964f, 
    0.08900195f, -0.00580889f, 0.00023272f, -0.08994007f, -0.04881664f, 0.05511672f, 0.07574772f, -0.20380665f, 
    -0.18307710f, -0.07698996f, -0.12551257f, -0.38402522f, 0.00079259f, 0.11833984f, 0.01822560f, 0.01267396f, 
    -0.06001160f, -0.02822442f, 0.02143067f, -0.08110597f, -0.54440844f, -0.23676890f, 0.17061694f, 0.28313324f, 
    -0.06351773f, 0.12135632f, 0.07352867f, -0.12507558f, 0.07681405f, 0.11570787f, -0.03058023f, -0.04957998f, 
    -0.13252594f, 0.14946915f, -0.22680995f, -0.12946168f, 0.09681131f, 0.00723459f, -0.03818011f, -0.23596950f, 
    -0.11973339f, -0.07879712f, -0.02555764f, -0.00886802f, -0.08023185f, 0.43681404f, -0.34493169f, -0.21833596f, 
    -0.01425073f, -0.07579181f, 0.01059622f, 0.04711207f, -0.26152164f, 0.11046743f, -0.20292212f, 0.00620477f, 
    0.10391150f, -0.03930079f, 0.06907101f, -0.43520898f, -0.14426117f, -0.09232594f, -0.04967668f, 0.03985247f, 
    0.00799271f, -0.02288089f, 0.06961409f, -0.15737043f, -0.21150748f, 0.09088784f, -0.08858220f, 0.07058047f, 
    -0.04014098f, -0.10560408f, 0.04261192f, -0.13265082f, -0.06574266f, 0.16877970f, 0.06419713f, -0.11612250f, 
    0.03001333f, -0.12922676f, 0.00482817f, 0.14367408f, -0.03244033f, 0.01836896f, -0.16978572f, -0.02380149f, 
    0.04696492f, 0.09077160f, -0.08596440f, -0.16316557f, 0.47024772f, -0.24011941f, 0.33557063f, 0.28977066f, 
    0.09514083f, -0.09383231f, -0.02832780f, 0.04419132f, -0.18146244f, 0.10441030f, 0.13964213f, 0.02010011f, 
    -0.08601698f, -0.11651590f, 0.04736298f, 0.24363503f, 0.09100772f, -0.05249818f, -0.06997437f, -0.02634572f, 
    -0.02157343f, 0.10800298f, -0.05436715f, 0.10038015f, -0.03810341f, 0.32623968f, -0.09615252f, -0.38000292f, 
    0.06477219f, 0.06699552f, -0.01739405f, -0.03569213f, -0.27806082f, -0.00411087f, 0.06264862f, 0.07217418f, 
    0.37709969f, -0.08964831f, 0.10828301f, 0.03735741f, -0.04122439f, 0.07478291f, 0.01883430f, 0.02655023f, 
    -0.06412710f, 0.07559785f, 0.15796140f, 0.09226069f, -0.30271932f, -0.03087231f, -0.04657296f, 0.33302739f, 
    0.07907088f, 0.05078931f, -0.00202790f, 0.07097048f, 0.04383474f, -0.01831121f, 0.06834824f, -0.10506294f, 
    -0.20478727f, -0.07483298f, 0.04905732f, 0.09825189f, -0.06548711f, -0.02782139f, 0.09140300f, 0.02401697f, 
    -0.19621013f, 0.09079863f, 0.08308019f, -0.03899546f, 0.27443460f, 0.02485220f, -0.09032919f, -0.00800352f, 
    0.08916564f, 0.00991375f, 0.07020292f, -0.09075804f, -0.20451425f, -0.11656225f, 0.00355634f, -0.02562509f, 
    -0.43619981f, -0.00435429f, 0.16936353f, 0.26121092f, -0.02517744f, 0.04215351f, 0.01531546f, -0.08500126f, 
    0.02016848f, 0.00867789f, 0.00217853f, 0.14531510f, 0.64880979f, -0.06325901f, 0.17155305f, 0.39658883f, 
    0.13529724f, -0.09062411f, -0.16999489f, 0.05918670f, 0.00160399f, 0.01877354f, 0.02526882f, 0.06441232f, 
    0.33482558f, 0.15941389f, -0.29336590f, -0.63872337f, -0.07494992f, -0.05796385f, 0.00323424f, -0.03580033f, 
    -0.16471320f, -0.07235290f, -0.04501615f, -0.32390395f, -0.10819256f, -0.03407725f, 0.08712004f, -0.05890279f, 
    0.04675922f, 0.00090408f, 0.09724043f, 0.13680935f, 0.06391262f, 0.20027184f, 0.09933372f, 0.01999288f, 
    0.38488761f, 0.17762375f, -0.04662756f, -0.06096305f, -0.28741109f, 0.04822538f, 0.02425387f, -0.14706011f, 
    -0.24257748f, -0.06495376f, 0.19935459f, -0.05649772f, 0.30934921f, 0.54158640f, -0.34313652f, -0.07651629f, 
    0.08869173f, 0.16138582f, -0.37773561f, 0.11199339f, -0.02731818f, 0.00863810f, 0.18556450f, -0.08687760f, 
    -0.19943894f, -0.09065560f, -0.51033813f, -0.17334741f, 0.01166929f, -0.08053396f, 0.14147490f, -0.21025436f, 
    0.15135343f, -0.11405243f, -0.09014689f, -0.01977210f, 0.89336073f, -0.21487311f, -0.00407336f, 0.11838041f, 
    0.08393118f, -0.04419317f, -0.06558000f, -0.01374981f, 0.00015752f, -0.09022985f, 0.12438154f, -0.04039375f, 
    0.08137064f, -0.12997949f, 0.09969108f, -0.00750272f, -0.03700413f, -0.09944771f, -0.04489195f, -0.02903366f, 
    -0.09394804f, -0.03846114f, -0.19334905f, -0.01847158f, 0.06362318f, 0.18294208f, 0.05657583f, 0.26766083f, 
    0.19756220f, 0.01948308f, 0.06596608f, -0.05926440f, -0.00182036f, -0.02957463f, 0.03250020f, -0.09653486f, 
    0.02019694f, -0.03810296f, 0.11698736f, 0.15076700f, -0.02576931f, -0.02785238f, 0.01162226f, -0.01294338f, 
    0.05210958f, -0.05168678f, -0.03744615f, 0.02607286f, -0.12205572f, -0.01128894f, -0.01568168f, -0.03430441f, 
    0.05874706f, 0.10678630f, -0.11474146f, 0.07082120f, 0.01266000f, 0.01537815f, -0.00586381f, 0.07008045f, 
    -0.06762251f, -0.19006214f, -0.17272133f, 0.07615530f, -0.05621555f, 0.10451651f, -0.06250331f, -0.14962997f, 
    -0.04229049f, -0.10531814f, 0.06792349f, 0.23444784f, -0.03118779f, 0.27334246f, 0.02351836f, 0.06253183f, 
    0.00377784f, 0.01019883f, 0.05454165f, -0.05608348f, -0.00908111f, 0.03153732f, 0.05767562f, 0.38672152f, 
    -0.05389697f, -0.04695603f, 0.01190312f, 0.06942875f, -0.13367803f, -0.08156215f, -0.05731328f, -0.09596480f, 
    -0.17070158f, -0.05829151f, -0.00469360f, 0.13902324f, -0.04682764f, 0.08006705f, 0.12380465f, 0.12131676f, 
    -0.01034563f, -0.07077304f, 0.02776585f, -0.00273149f, 0.01439650f, 0.03852538f, 0.07525286f, -0.01447615f, 
    0.06322850f, -0.02075998f, -0.07038835f, 0.07374863f, 0.06616455f, 0.04848913f, -0.07032704f, -0.05137144f, 
    -0.03404490f, -0.09286973f, 0.03317319f, -0.10004111f, 0.11458614f, 0.03805779f, -0.05257967f, 0.01279346f, 
    0.05481170f, 0.02202577f, 0.02881307f, 0.05975470f, 0.01165264f, -0.05062542f, -0.15509242f, -0.07058072f, 
    0.06685065f, 0.08085690f, 0.11202966f, 0.16063312f, 0.00986599f, -0.07907359f, -0.02331776f, -0.18833579f, 
    0.08082926f, 0.03366081f, -0.00020195f, 0.08089493f, 0.28528717f, -0.26720825f, 0.05613052f, -0.12819844f, 
    -0.07420222f, -0.05334092f, 0.02252450f, 0.04794085f, 0.07933874f, -0.03020651f, -0.06458784f, 0.07720219f, 
    -0.11666776f, -0.06321843f, -0.06225830f, 0.10135946f, -0.08941319f, 0.10527177f, 0.01498943f, -0.06434479f, 
    0.03105551f, 0.03688521f, -0.09067930f, -0.16989964f, -0.02370517f, 0.15338491f, -0.02121667f, 0.21848644f, 
    -0.04537860f, -0.06615651f, 0.03215984f, -0.10951908f, 0.01440507f, -0.01321193f, -0.00272426f, 0.01787774f, 
    0.06254874f, 0.11488011f, 0.14758480f, 0.05448020f, -0.03203493f, 0.00965168f, -0.00780350f, -0.07389908f, 
    0.04740553f, -0.00382723f, 0.03680606f, -0.02363414f, 0.07555745f, 0.13093460f, 0.08931197f, 0.07508463f, 
    0.02196493f, -0.02997813f, 0.03788829f, 0.07633080f, 0.11275357f, -0.06588835f, -0.09282165f, 0.06510529f, 
    -0.19961317f, -0.21329021f, 0.06227425f, 0.05225585f, -0.14213338f, 0.06271609f, -0.07689061f, 0.07501246f, 
    -0.10824615f, -0.05897066f, -0.07932448f, -0.06939649f, -0.01770558f, -0.06264687f, 0.10514350f, 0.08915197f, 
    -0.04786975f, 0.08766631f, -0.05802820f, -0.07265912f, 0.01005995f, 0.02028919f, -0.07500383f, 0.01091595f, 
    -0.05904873f, -0.15170591f, 0.04991629f, -0.10381558f, 0.05633214f, 0.08636604f, 0.00983177f, -0.01726996f, 
    -0.04198350f, -0.00799573f, -0.05499254f, -0.15575255f, 0.03911161f, 0.01668208f, 0.04070552f, 0.06983409f, 
    0.11265950f, 0.19529220f, 0.04291723f, 0.01986537f, 0.05827857f, 0.00172278f, 0.00957319f, 0.02823800f, 
    0.01184978f, -0.14036310f, 0.02156229f, 0.07147054f, -0.02021505f, -0.09885520f, 0.08346853f, -0.16559064f, 
    -0.08039451f, -0.02755021f, -0.04868836f, 0.05880648f, 0.14535011f, 0.39260581f, 0.21849580f, 0.23271923f, 
    -0.04210386f, 0.16079538f, 0.02121924f, 0.05022258f, 0.06675172f, -0.04135820f, 0.07660367f, -0.10339852f, 
    -0.28410167f, -0.02273165f, -0.23811896f, -0.05134241f, 0.07047141f, 0.04764058f, -0.04178445f, 0.01662871f, 
    -0.10410139f, 0.03857167f, -0.00281060f, -0.00410161f, 0.21259764f, -0.23690768f, 0.00715631f, -0.29986811f, 
    0.02824013f, 0.01233990f, -0.00934333f, 0.12582506f, 0.01172832f, -0.01905694f, -0.03504798f, 0.04524174f, 
    0.08915902f, 0.09972224f, 0.33234739f, 0.16398695f, -0.13651948f, -0.01184132f, -0.08815078f, 0.07150388f, 
    -0.03176688f, -0.04076849f, -0.03683183f, -0.01746921f, 0.01874936f, -0.03174120f, 0.06457370f, 0.03552900f, 
    0.04020529f, -0.08095378f, 0.05308605f, -0.07062475f, 0.15665914f, -0.05306119f, 0.09909830f, 0.15647234f, 
    -0.14095873f, -0.03756924f, -0.12819037f, 0.27285269f, -0.06741426f, -0.03728803f, -0.12530823f, -0.04154046f, 
    0.05391635f, 0.00164502f, 0.01857618f, -0.02774244f, 0.23860638f, 0.16841769f, -0.34489316f, 0.29633474f, 
    0.03119610f, 0.12711729f, 0.07085419f, 0.06048068f, 0.07754231f, 0.00002142f, 0.00863628f, -0.05553432f, 
    0.36782038f, -0.07295031f, 0.42525670f, 0.11167358f, -0.05983768f, 0.16524290f, 0.01853464f, 0.17785205f, 
    0.05851094f, -0.03064888f, 0.05131317f, 0.02083966f, 0.00638762f, 0.09457624f, 0.13253802f, 0.10122817f, 
    -0.12825133f, -0.14498255f, -0.02941447f, 0.07053857f, -0.00962392f, 0.02928590f, 0.04855935f, 0.05086347f, 
    -0.22102927f, 0.00263035f, -0.01013248f, -0.07862660f, -0.00096703f, 0.06433602f, -0.20928910f, 0.02500120f, 
    -0.13776506f, 0.06858084f, -0.19131571f, -0.24047969f, 0.03288307f, 0.13873664f, 0.07686388f, 0.12727214f, 
    -0.01981482f, -0.10200096f, -0.09804878f, -0.16722761f, -0.07699632f, 0.07728417f, 0.01395671f, -0.04007568f, 
    0.05996417f, 0.09957452f, 0.05864720f, 0.09650080f, 0.03548436f, -0.12178004f, -0.06702437f, 0.01464428f, 
    -0.01309736f, -0.09581271f, 0.01842712f, 0.16151328f, 0.04039834f, 0.01889978f, -0.08188175f, -0.16392209f, 
    0.08378915f, -0.01280237f, 0.03667228f, 0.00433590f, 0.06164221f, 0.03416505f, -0.04095307f, -0.09550519f, 
    0.26964480f, -0.19187945f, -0.02669095f, 0.06222023f, -0.08681855f, -0.04642988f, -0.08938382f, 0.03308181f, 
    0.06710202f, -0.12677790f, 0.00274430f, -0.11145188f, 0.18210822f, 0.16630796f, 0.00474657f, 0.00981334f, 
    -0.00295168f, -0.03646785f, -0.03563986f, 0.06235674f, 0.21851495f, -0.11666574f, 0.01147068f, 0.00439446f, 
    0.17523120f, 0.20661816f, -0.45511952f, 0.11840118f, 0.06227097f, 0.02981694f, 0.09476835f, -0.15349008f, 
    -0.10964011f, -0.02440186f, -0.13836028f, -0.20336020f, -0.21448095f, 0.04477387f, -0.33431372f, -0.33220387f, 
    0.09033442f, 0.01587266f, 0.04601133f, 0.02090079f, 0.06625549f, 0.01006291f, -0.02516917f, -0.08913373f, 
    -0.27495101f, 0.04725153f, 0.02492917f, -0.05378658f, 0.10526737f, 0.08380232f, -0.09418289f, 0.05484127f, 
    -0.09233080f, 0.09559914f, 0.06752589f, 0.03068980f, 0.01456654f, 0.02068318f, 0.08451823f, -0.02750839f, 
    -0.10883927f, 0.04382107f, -0.03189271f, 0.14613640f, -0.20282722f, -0.14444588f, -0.27950847f, 0.04606923f, 
    -0.23654629f, -0.01951405f, -0.03955719f, 0.03388980f, -0.05855179f, 0.06804725f, 0.06765445f, -0.00656932f, 
    0.04745333f, -0.00204612f, -0.08809349f, -0.05468197f, 0.04019585f, 0.03884589f, 0.01140781f, 0.01563844f, 
    0.02978038f, 0.08065725f, 0.05951232f, 0.03745056f, 0.07709832f, -0.01366805f, -0.08231074f, 0.06184302f, 
    0.12610553f, -0.03620787f, -0.46174538f, -0.09946298f, 0.09002820f, 0.02966686f, 0.04771403f, -0.02007782f, 
    -0.07464712f, -0.01461742f, -0.08355936f, 0.01223456f, 0.18097445f, -0.03466225f, 0.08954244f, -0.02251302f, 
    0.13201378f, -0.02808576f, -0.02150705f, -0.08420471f, 0.08059572f, -0.12308373f, -0.17602536f, -0.00556090f, 
    -0.18635254f, -0.10478029f, 0.10027667f, 0.06928082f, -0.16267183f, -0.02724473f, -0.16097291f, -0.05347304f, 
    -0.14375594f, -0.03488901f, 0.02201292f, 0.05088588f, 0.04813129f, -0.28970054f, 0.06406190f, 0.25245053f, 
    -0.09256049f, 0.09206726f, 0.00095134f, -0.04696710f, -0.25172639f, -0.06905645f, 0.08651224f, -0.17532815f, 
    -0.00360807f, -0.23771811f, -0.44068301f, -0.06610859f, 0.05908628f, 0.02003120f, -0.03981808f, -0.03221098f, 
    0.06711558f, -0.02019567f, -0.01686352f, 0.00600231f, -0.12923031f, -0.15102169f, 0.13849071f, 0.03687829f, 
    0.06688349f, -0.06984398f, 0.05025731f, -0.05071087f, -0.03470456f, -0.11589731f, -0.08565082f, -0.17156336f, 
    0.06763334f, 0.10978764f, 0.18680736f, 0.17780754f, -0.04175516f, -0.04840593f, 0.11720359f, 0.12962732f, 
    0.02604803f, 0.00079270f, -0.00576778f, 0.01660536f, 0.16102296f, -0.32119828f, -0.35398030f, -0.14630444f, 
    0.01143366f, -0.05575236f, 0.11820357f, -0.02419324f, 0.01192324f, -0.07102019f, 0.15554099f, -0.23139057f, 
    -0.08103923f, -0.03894274f, 0.00322998f, 0.09403098f, -0.07089541f, -0.08686680f, -0.06351046f, -0.19029307f, 
    -0.02277399f, 0.01451731f, 0.08941725f, -0.01543421f, -0.14248054f, -0.34560558f, 0.26294762f, 0.20335092f, 
    -0.31073907f, 0.05853727f, 0.00491677f, -0.00112073f, -0.06302439f, 0.05465594f, -0.10146031f, -0.06578322f, 
    -0.16290374f, 0.12358161f, -0.05247533f, -0.07178812f, -0.02311347f, -0.11424046f, 0.09676863f, -0.08597983f, 
    0.05736513f, -0.01320062f, 0.08004556f, 0.30797285f, 0.20662066f, 0.22943985f, -0.11841823f, 0.06269997f, 
    0.01672686f, -0.13901731f, -0.00785150f, -0.13668887f, -0.09707669f, 0.02565004f, 0.05686389f, 0.08984675f, 
    0.09732882f, 0.15197590f, -0.07441597f, -0.04211275f, -0.11652556f, 0.06699093f, 0.07602578f, -0.19836150f, 
    0.04722038f, -0.03095671f, 0.03021733f, 0.06032106f, -0.13104732f, -0.34984046f, -0.10217341f, -0.08363707f, 
    0.06279618f, -0.04447500f, -0.01493068f, -0.03848112f, 0.13300905f, 0.12600698f, -0.02372407f, 0.14049688f, 
    0.01184973f, -0.00550081f, 0.24729151f, 0.08360774f, 0.01226055f, -0.10627033f, -0.14654021f, 0.03755928f, 
    0.03877550f, -0.04503136f, -0.05233578f, -0.00444401f, -0.10895127f, 0.21086788f, -0.10309197f, 0.16648260f, 
    0.01020867f, -0.03735100f, 0.12141468f, -0.18497796f, -0.03714465f, -0.38990250f, 0.08956466f, -0.00989943f, 
    -0.10888232f, -0.18773039f, 0.05422209f, -0.02760207f, -0.04340058f, -0.07655631f, 0.03727391f, -0.07586125f, 
    -0.04388875f, -0.21266831f, -0.07727949f, 0.07150548f, 0.11487170f, 0.03241165f, -0.08954790f, -0.02892438f, 
    0.07194574f, 0.02868905f, -0.00302463f, 0.05013513f, 0.10340691f, -0.08389794f, -0.08200310f, -0.01533651f, 
    -0.00528533f, -0.12790936f, -0.00149238f, -0.07763153f, -0.05760151f, -0.00083493f, 0.09169202f, -0.04966694f, 
    -0.00539295f, 0.03147820f, -0.16430965f, 0.00156925f, -0.34507611f, -0.83836508f, 0.77439755f, -0.02119270f, 
    -0.00199692f, 0.06355822f, -0.15310729f, -0.09645291f, 0.12642567f, -0.12518638f, 0.03941086f, 0.15987025f, 
    -0.31690148f, -0.07756048f, 0.14078768f, -0.03996583f, -0.18331575f, -0.05834251f, -0.23723805f, -0.06316822f, 
    -0.32716393f, -0.03794908f, -0.13691139f, 0.10458698f, -0.10495494f, -0.04140493f, -0.10114823f, 0.01116160f, 
    0.03952875f, -0.07940653f, -0.25322250f, 0.06182054f, 0.09023764f, 0.05919726f, -0.01604018f, -0.07445981f, 
    0.03551839f, 0.02632188f, 0.04472569f, -0.05602431f, -0.00620950f, 0.05432297f, 0.20902027f, 0.03665834f, 
    0.18961704f, -0.06378864f, -0.13610673f, 0.10447600f, 0.03113753f, 0.09321634f, -0.06528719f, -0.14224795f, 
    -0.10306546f, 0.04919548f, 0.02512003f, 0.11231636f, 0.05850034f, 0.08254224f, 0.13569632f, 0.00156998f, 
    -0.07011621f, -0.09934530f, -0.01411352f, -0.00596894f, -0.05416021f, 0.05731139f, 0.10956480f, 0.00158336f, 
    -0.01695115f, 0.07034881f, 0.13623011f, 0.07763307f, -0.03081939f, -0.21654862f, -0.13610928f, -0.06017393f, 
    -0.07125499f, -0.08649208f, -0.01529313f, 0.15161002f, -0.02973399f, -0.21648569f, 0.08089127f, -0.04613617f, 
    0.01495839f, -0.29872859f, 0.51946372f, 0.40181881f, 0.08310500f, -0.01888970f, 0.01978292f, 0.01214588f, 
    0.07536870f, 0.05188439f, -0.23872112f, -0.21833944f, 0.01410187f, -0.02624810f, -0.27128044f, -0.22685455f, 
    0.01252731f, 0.10229325f, 0.16565399f, 0.03592761f, 0.04489665f, -0.07646125f, -0.08763706f, -0.62145311f, 
    -0.14664000f, 0.17591329f, -0.14216565f, -0.12841883f, -0.08043181f, -0.06167763f, -0.00179037f, 0.00842085f, 
    0.12105553f, -0.23909965f, -0.02704644f, -0.12051696f, 0.13690971f, 0.21502589f, 0.10489543f, 0.05038858f, 
    0.06898579f, 0.12261902f, 0.14263874f, -0.09603781f, 0.05463713f, 0.00865274f, 0.05045668f, 0.04215383f, 
    0.06339803f, -0.00638587f, 0.03978001f, -0.07754710f, -0.06208175f, 0.01456754f, 0.06319813f, -0.12598206f, 
    0.23754250f, -0.05366816f, -0.14433314f, -0.02808165f, -0.02803104f, -0.02701306f, -0.01307256f, -0.02298528f, 
    0.04151870f, -0.08954818f, -0.00951581f, -0.00687468f, -0.03721153f, -0.16316733f, 0.17822352f, 0.00493398f, 
    -0.00241242f, 0.05372937f, 0.04532202f, -0.08487087f, -0.00797277f, -0.01669899f, -0.01781325f, -0.02363255f, 
    -0.08870944f, -0.24645148f, -0.07943603f, -0.09325121f, -0.29350662f, -0.01224225f, -0.42932713f, -0.06572390f, 
    0.05067994f, 0.02744617f, -0.12498274f, 0.03521112f, 0.03058844f, 0.18644565f, -0.04754230f, -0.06201286f, 
    -0.07939436f, 0.00823141f, -0.05240214f, -0.07933264f, 0.13082802f, 0.03515624f, -0.11326559f, 0.12078123f, 
    -0.03282454f, -0.07782555f, 0.15842175f, 0.13684408f, -0.21278945f, -0.02226765f, -0.00494458f, -0.22258422f, 
    0.10196991f, 0.09389111f, 0.00588288f, 0.12041312f, 0.06334440f, -0.00608764f, 0.04918212f, 0.00221663f, 
    0.19141363f, 0.05209021f, 0.19669656f, -0.04081146f, 0.04668193f, -0.11660223f, 0.01222988f, -0.09297483f, 
    0.06707057f, 0.01276619f, 0.10982803f, -0.02079470f, -0.28415519f, -0.09796017f, -0.26199111f, -0.15372291f, 
    0.03967805f, -0.01997839f, 0.08299340f, -0.00838489f, -0.04948444f, -0.11057281f, 0.12860757f, -0.16364300f, 
    -0.01381479f, 0.01997836f, 0.02019230f, -0.08032938f, 0.10396355f, -0.05804292f, 0.04508065f, 0.03619868f, 
    -0.10660528f, -0.03438188f, 0.00994573f, 0.23835289f, 0.17003267f, -0.20798771f, -0.01068335f, 0.02765011f, 
    -0.08252417f, -0.10504482f, 0.01407962f, 0.17302281f, -0.12131803f, 0.23366083f, -0.05084956f, -0.10593232f, 
    -0.22020309f, -0.26436511f, 0.02426841f, -0.08282594f, 0.00560013f, -0.00430371f, 0.01474983f, 0.01322294f, 
    0.00545756f, -0.02161720f, 0.12865676f, 0.09080520f, -0.18413927f, -0.01482326f, -0.15812345f, 0.01010582f, 
    0.02435676f, -0.11265080f, 0.13268033f, 0.03011900f, 0.11470725f, -0.01636371f, -0.02605739f, 0.04348834f, 
    -0.43095535f, -0.05505518f, 0.26437762f, 0.05397527f, -0.06615940f, -0.18227601f, 0.03081927f, 0.30146572f, 
    0.10781370f, -0.03166179f, -0.05202202f, -0.01906964f, 0.10229204f, -0.01007799f, 0.10652181f, -0.02139462f, 
    0.18982653f, -0.15796238f, -0.14214194f, -0.23225234f, -0.02600230f, -0.03521806f, 0.08491119f, 0.00239678f, 
    -0.06563969f, -0.05412991f, -0.34058270f, 0.08466939f, 0.10484169f, -0.04217213f, -0.01619653f, 0.02211073f, 
    0.12192530f, -0.04479535f, 0.09414633f, 0.27813181f, 0.39823931f, -0.05165574f, -0.08613928f, 0.04178730f, 
    0.02638333f, 0.02505166f, -0.01640023f, -0.07162632f, -0.03044472f, -0.01657793f, -0.11892429f, -0.05140779f, 
    0.23105633f, 0.14320122f, 0.25733370f, 0.00869023f, 0.07613676f, 0.16068791f, 0.07942501f, -0.07475565f, 
    0.01566872f, -0.11590207f, -0.08266788f, 0.04957069f, -0.05753297f, -0.01441882f, -0.05439113f, 0.08964100f, 
    0.08551453f, -0.04146942f, -0.02779224f, 0.03726160f, -0.07024856f, 0.04195969f, 0.01385857f, -0.28373134f, 
    -0.18521230f, -0.10984097f, -0.18742348f, 0.32719764f, 0.10535099f, -0.03470646f, 0.13009600f, -0.03417908f, 
    -0.15418322f, 0.06324548f, -0.06373002f, -0.07225959f, 0.12597707f, -0.05853346f, -0.67466581f, 0.19339775f, 
    0.14937322f, 0.01298383f, 0.02148624f, 0.01595803f, 0.11768933f, 0.01028125f, -0.00377881f, 0.07820649f, 
    -0.09909496f, -0.35449126f, 0.09322716f, 0.02076486f, -0.01295443f, 0.02228922f, 0.04954151f, -0.02194235f, 
    0.00413474f, -0.04896267f, 0.02742008f, 0.01023693f, 0.04770721f, 0.11159132f, 0.10699788f, -0.06850438f, 
    0.14921726f, 0.19964701f, -0.04798773f, -0.16039757f, 0.06847417f, 0.00623565f, 0.01463999f, 0.06507035f, 
    0.17545015f, 0.20365834f, -0.32094300f, 0.01919913f, -0.06638265f, 0.02420741f, 0.04810059f, -0.13787669f, 
    0.01877420f, -0.01403608f, 0.03158117f, 0.31356788f, -0.03023667f, 0.19990870f, -0.09837294f, -0.14994119f, 
    -0.00928185f, 0.08832283f, 0.09666301f, 0.20656569f, -0.04797305f, -0.05001594f, 0.04324644f, -0.01955555f, 
    0.11758763f, -0.04055876f, -0.09494319f, -0.14516470f, 0.01991240f, 0.11297943f, -0.00741844f, -0.09093290f, 
    -0.06521576f, 0.02883313f, 0.19223171f, -0.07653031f, -0.03685453f, -0.19816352f, -0.14438091f, 0.10568003f, 
    -0.04829466f, 0.05400022f, -0.06521287f, 0.05804705f, 0.11617642f, -0.05835664f, 0.15676989f, -0.01623206f, 
    -0.11900311f, -0.39463291f, 0.16164407f, -0.08855782f, 0.03443186f, -0.04062819f, 0.07410245f, -0.03238323f, 
    0.22597142f, -0.12498286f, -0.00522846f, 0.08019809f, -0.15346029f, 0.00742407f, -0.05211164f, -0.09869499f, 
    -0.08239683f, -0.01654254f, 0.01397194f, -0.11578740f, 0.01225103f, 0.14301221f, -0.07263333f, -0.10361389f, 
    -0.24438249f, -0.22202271f, 0.25841588f, 0.03139939f, -0.13553137f, 0.04212338f, -0.04389244f, 0.02183568f, 
    0.27902573f, 0.08324063f, 0.04471027f, 0.01582744f, -0.26368728f, -0.00701263f, -0.38001880f, -0.01099979f, 
    0.02550742f, 0.06691756f, -0.03799519f, -0.01067798f, -0.00639889f, 0.01996727f, 0.02380092f, -0.07404961f, 
    0.04691135f, -0.07642735f, -0.25767672f, -0.28650868f, -0.13686436f, 0.02877151f, -0.04213472f, -0.03730028f, 
    0.01124988f, 0.08473976f, -0.05394385f, 0.18924375f, -0.10106925f, -0.08072329f, 0.25411585f, -0.15556611f, 
    -0.08666068f, 0.00442939f, -0.01175562f, -0.10272795f, 0.11826038f, -0.03956169f, 0.01658800f, 0.00200946f, 
    0.41804594f, -0.09292639f, -0.07011136f, -0.05186995f, 0.05778171f, 0.13271014f, -0.12402344f, 0.15510586f, 
    0.07815249f, 0.12320427f, 0.01220610f, -0.07331205f, 0.01807518f, -0.08836260f, -0.06412444f, 0.04767876f, 
    -0.01555441f, -0.02159724f, -0.02581593f, -0.06585714f, 0.19952197f, -0.00838522f, -0.08191027f, -0.01081034f, 
    -0.30915657f, -0.16574372f, -0.24108219f, 0.00786658f, -0.03897054f, -0.02573393f, -0.05440130f, -0.00367285f, 
    0.01263442f, 0.02846464f, 0.07332847f, 0.01589875f, 0.07605338f, 0.08550188f, -0.10680626f, -0.13331902f, 
    0.07395346f, 0.05314410f, -0.02193345f, -0.00044627f, -0.04898657f, 0.00223010f, -0.14458703f, -0.19984122f, 
    0.05233362f, -0.00846223f, -0.04065458f, -0.11574448f, 0.01293171f, -0.03884307f, -0.04086166f, 0.18109217f, 
    0.17026669f, -0.09110580f, -0.06498871f, 0.03028567f, 0.07195379f, -0.12302481f, 0.11918346f, -0.06641579f, 
    0.05852859f, -0.14330798f, -0.10061882f, 0.04963333f, 0.02566421f, -0.17887610f, 0.28555053f, 0.17146231f, 
    -0.11662108f, 0.17499727f, -0.03945053f, 0.14627436f, 0.03879724f, -0.08926404f, 0.10983749f, -0.04805344f, 
    -0.00305442f, 0.06083057f, -0.07005826f, 0.04558995f, 0.11072394f, 0.09349670f, -0.06405399f, -0.04040622f, 
    -0.06189636f, -0.05483177f, -0.07776802f, 0.04044232f, 0.21559452f, -0.10316142f, 0.14127910f, 0.01184039f, 
    0.06527425f, 0.05524146f, 0.01855471f, 0.02510990f, 0.32935059f, 0.15270154f, 0.10503140f, 0.13204868f, 
    0.06516035f, 0.01118593f, 0.04895037f, 0.12301037f, -0.22089563f, 0.20383406f, -0.22858751f, -0.17143516f, 
    0.10580100f, -0.05281505f, 0.05268592f, -0.00715073f, -0.01786672f, -0.07121909f, -0.00893814f, 0.34259027f, 
    -0.28386605f, 0.07685608f, -0.06799689f, -0.39364684f, 0.03821664f, 0.04980890f, 0.01185492f, 0.00217827f, 
    0.02347240f, -0.07232881f, -0.04851746f, 0.00780259f, -0.12501585f, -0.10373972f, -0.02297580f, 0.01586038f, 
    0.15244624f, 0.03109168f, 0.04151638f, -0.14209419f, 0.00294359f, 0.12877844f, -0.01936799f, 0.04447664f, 
    -0.01481466f, -0.07554108f, -0.09073222f, 0.02705866f, -0.01091554f, 0.02774785f, 0.01453934f, 0.02974690f, 
    0.05065126f, -0.31532925f, -0.33631599f, -0.36417565f, -0.14690615f, 0.19231640f, -0.21589489f, -0.25634384f, 
    0.07045510f, 0.15651596f, -0.11708765f, -0.02514381f, 0.18926068f, 0.07965295f, -0.11194927f, -0.11703923f, 
    -0.11105536f, -0.11714678f, -0.13707647f, 0.03058282f, 0.20893613f, -0.14454813f, -0.05813210f, 0.23623610f, 
    0.16775075f, -0.32405227f, -0.00052153f, 0.04933373f, -0.59582126f, 0.47063681f, 0.22468789f, -0.20470071f, 
    -0.04461360f, -0.07842118f, 0.06316674f, 0.04891555f, 0.06570233f, -0.04060956f, -0.31013533f, -0.14473043f, 
    0.04265065f, -0.17751972f, -0.01673880f, -0.19056547f, 0.05241007f, 0.09985682f, -0.10716706f, 0.00626834f, 
    0.12582746f, -0.10269785f, 0.04228650f, 0.10076203f, -0.32932740f, -0.18071358f, -0.34778437f, -0.11485016f, 
    0.02020709f, -0.10462444f, 0.13135196f, 0.02783580f, 0.20484802f, 0.03579682f, 0.00773106f, 0.08056478f, 
    -0.29211968f, -0.25628442f, 0.13766080f, 0.35240540f, -0.04390076f, 0.01082417f, -0.02745737f, 0.08514246f, 
    0.11391157f, -0.07384019f, -0.01159035f, 0.08474571f, 0.04504076f, 0.00272718f, -0.19908486f, 0.07066290f, 
    0.02237273f, -0.02946117f, -0.03038101f, 0.00218560f, -0.04241870f, -0.16025031f, -0.21661595f, -0.04260376f, 
    0.20684685f, -0.22737628f, -0.06298926f, 0.14429808f, -0.05009163f, 0.00654244f, -0.06863856f, 0.09783201f, 
    -0.17582799f, 0.01299767f, 0.09135653f, -0.06142611f, -0.04754274f, 0.45953000f, -0.28204864f, -0.26076278f, 
    0.01353861f, 0.00381003f, 0.10279434f, -0.06521335f, 0.06105730f, -0.10032881f, -0.14278416f, -0.22616915f, 
    0.14825588f, -0.22805384f, 0.22884817f, -0.05246800f, 0.03662736f, 0.00654592f, 0.06477512f, 0.26278570f, 
    -0.01304274f, 0.00315901f, -0.10788481f, 0.16334735f, -0.14974380f, 0.07917616f, -0.05938277f, 0.12326431f, 
    0.01962399f, -0.03034797f, 0.17384699f, 0.04216746f, 0.03548889f, -0.00764290f, 0.00491072f, 0.16977493f, 
    0.00152952f, -0.12897129f, -0.10902880f, 0.20803750f, 0.11847056f, -0.01218204f, 0.13252866f, 0.09342337f, 
    0.00743328f, -0.10720558f, 0.02326435f, -0.02270026f, -0.37163833f, -0.47603372f, -0.06977908f, -0.72770363f, 
    0.01546402f, -0.29323170f, -0.10277941f, -0.30558547f, 0.01578385f, 0.01389602f, 0.00437196f, -0.14162175f, 
    -0.37827072f, -0.43458650f, -0.02757805f, 0.21558695f, -0.06759220f, -0.01864162f, 0.00072726f, -0.23288609f, 
    -0.00022408f, 0.07009766f, 0.04686956f, -0.12084839f, -0.21947396f, 0.24156287f, -0.07614543f, 0.20329580f, 
    0.00293858f, -0.03023188f, 0.18631627f, 0.06550760f, 0.06111734f, 0.12786430f, 0.15962437f, 0.07853212f, 
    -0.05945798f, 0.00685638f, -0.60422677f, -0.30776331f, -0.13468862f, 0.00928481f, 0.05443730f, 0.01723308f, 
    -0.09970508f, -0.02105750f, 0.17581557f, -0.03775758f, 0.04276422f, -0.05157871f, -0.00918987f, 0.01915503f, 
    -0.01953140f, 0.04091851f, 0.08295830f, -0.01813202f, 0.02879405f, 0.03379724f, 0.10597900f, 0.22764891f, 
    -0.15402423f, -0.00360831f, -0.08691587f, 0.11862892f, -0.03948151f, -0.06072941f, 0.12160739f, 0.04332577f, 
    0.08118906f, 0.06073834f, -0.01883506f, 0.03085236f, -0.41039112f, -0.73806673f, -0.22059365f, -0.07501908f, 
    -0.14083125f, -0.00168172f, -0.12914811f, -0.32475945f, -0.03762756f, -0.05169716f, 0.04636256f, 0.00584578f, 
    -0.03014229f, -0.08641367f, -0.03385270f, 0.09347938f, -0.00718997f, 0.05339316f, -0.10967703f, 0.11996256f, 
    -0.06272782f, 0.03762660f, 0.11893901f, -0.06117041f, -0.06630784f, 0.01841669f, 0.09765492f, -0.02267699f, 
    0.00824261f, 0.02753378f, -0.05632053f, 0.07513067f, -0.00625240f, 0.01953749f, -0.05272370f, -0.03561203f, 
    -0.18836990f, -0.14418231f, 0.00482636f, -0.06446204f, -0.12511455f, 0.08533946f, 0.11827793f, -0.04338619f, 
    -0.00284646f, 0.11779401f, 0.03848428f, -0.06451014f, -0.43551233f, 0.16570339f, 0.19967939f, 0.08055174f, 
    -0.01456874f, -0.02376765f, -0.08073601f, -0.15416411f, -0.10887358f, -0.01251896f, 0.02254224f, 0.11206709f, 
    -0.02896719f, -0.03659646f, 0.10707246f, 0.19776183f, 0.14553550f, 0.01282971f, 0.03058434f, 0.10886651f, 
    -0.02035055f, 0.06156927f, 0.07864667f, -0.10536183f, -0.60432744f, -0.60445726f, -0.07520510f, -0.38440976f, 
    -0.03072684f, -0.18886141f, 0.07788126f, -0.11493592f, -0.04272204f, 0.00797187f, -0.02038036f, 0.06009859f, 
    -0.73601335f, -0.47938567f, -0.23263372f, -0.25431791f, -0.08075044f, -0.07847500f, -0.33971685f, -0.23242863f, 
    -0.03800050f, 0.07649851f, -0.04937740f, 0.00759549f, -0.19975597f, 0.31739828f, 0.29375511f, 0.02172317f, 
    -0.05496748f, 0.06529079f, -0.01448029f, -0.07995434f, -0.00268674f, 0.08260819f, -0.09886718f, 0.13557954f, 
    -0.04542786f, 0.18205184f, 0.19292232f, 0.12455197f, -0.03280191f, -0.04200252f, -0.03195632f, 0.12238444f, 
    0.05876196f, 0.10892023f, 0.05252626f, -0.13693623f, -0.09397279f, -0.09960730f, -0.10413310f, 0.08377055f, 
    -0.00439700f, 0.09847700f, -0.02873090f, -0.05171812f, -0.09147480f, 0.01393098f, -0.05156505f, 0.00382776f, 
    -0.09914327f, 0.12006344f, -0.05274144f, -0.00146524f, 0.07797900f, -0.07017338f, -0.00442948f, -0.04778314f, 
    -0.06584975f, -0.12400061f, -0.04393455f, 0.11646686f, -0.04048530f, -0.10126185f, -0.09503663f, 0.06990211f, 
    -0.01280171f, -0.05152954f, 0.05628024f, -0.03281259f, -0.00811683f, -0.06548455f, -0.03857470f, -0.05203809f, 
    0.00695494f, -0.45375192f, -0.19281447f, 0.25249803f, 0.03851369f, 0.13057156f, 0.01935878f, -0.09148524f, 
    0.04492566f, 0.02807664f, 0.03321577f, 0.12364398f, -0.33955744f, -0.31222045f, -0.45803207f, -0.10619846f, 
    -0.16467333f, 0.08494744f, 0.10459707f, -0.31048918f, 0.05061115f, -0.01247162f, 0.10674791f, -0.02081896f, 
    0.12575769f, 0.06092945f, 0.02709219f, 0.02790070f, 0.02814874f, 0.01895005f, 0.07632005f, 0.00901618f, 
    -0.06122416f, -0.02428738f, 0.02920772f, -0.04290017f, -0.17310335f, 0.02609432f, 0.03237168f, -0.02319354f, 
    0.06419233f, 0.11748666f, -0.01519298f, -0.02964988f, -0.03116076f, 0.02289403f, 0.01954748f, 0.09447911f, 
    -0.40667799f, -0.30478108f, -0.45437035f, -0.01357511f, -0.10059857f, -0.17074203f, -0.07643151f, 0.05260364f, 
    0.08038840f, 0.03606167f, -0.02054620f, 0.00764854f, 0.14393540f, -0.00839880f, -0.08135163f, -0.08152904f, 
    0.03954534f, -0.02774661f, 0.09235217f, 0.07007863f, -0.00982189f, -0.03691402f, -0.17532586f, -0.22985154f, 
    0.34159502f, -0.21691746f, -0.35994321f, -0.09370815f, -0.04745935f, 0.05512964f, 0.25324330f, 0.06703413f, 
    -0.05391777f, -0.02039794f, -0.02531217f, -0.01328276f, 0.10530338f, -0.26000044f, -0.06100699f, -0.28612283f, 
    0.00995806f, 0.07433818f, 0.09736902f, -0.05695048f, -0.02068399f, 0.00443185f, -0.03763823f, 0.08294979f, 
    -0.82579976f, -0.32078999f, -0.48463103f, 0.14331691f, 0.04247835f, 0.16365828f, 0.11274043f, -0.14729543f, 
    0.01577358f, -0.03607026f, 0.02124386f, 0.05088788f, -0.43868122f, -0.58424401f, -0.18457918f, -0.14623006f, 
    -0.17052521f, -0.07611798f, -0.14634533f, -0.29233244f, -0.02114241f, -0.04288001f, -0.05888639f, 0.07210403f, 
    -0.12387159f, 0.06010604f, 0.21458147f, -0.15676802f, 0.11140919f, -0.11791217f, -0.00071509f, -0.06469665f, 
    0.04531544f, -0.02874242f, -0.03865027f, 0.05373330f, 0.18793100f, -0.06266711f, -0.03693213f, 0.02081415f, 
    -0.00508775f, -0.16603507f, 0.02181326f, 0.20511031f, 0.04128495f, -0.04481776f, -0.02829700f, -0.03423865f, 
    -0.19003381f, 0.13885310f, 0.02964792f, 0.16371639f, 0.05714626f, 0.08049506f, -0.00807861f, -0.04018451f, 
    0.07164468f, 0.04916467f, 0.25061384f, 0.19941357f, 0.12706143f, -0.01452826f, 0.01598965f, -0.10521451f, 
    0.04309560f, -0.00055154f, 0.05400039f, -0.06728407f, -0.04691387f, -0.07702857f, 0.03631118f, 0.06348936f, 
    -0.27155986f, 0.07932414f, 0.24311514f, -0.28628668f, 0.04787978f, -0.04864668f, -0.03422520f, 0.11929738f, 
    -0.06162341f, 0.13379118f, 0.13054594f, 0.00435138f, -0.30144000f, 0.17549847f, 0.21738406f, -0.01858945f, 
    -0.08017355f, -0.11447994f, -0.09176250f, -0.06634114f, -0.10569545f, -0.00313415f, -0.05870279f, 0.01626475f, 
    -0.21900396f, -0.24438792f, 0.26179057f, 0.23612477f, -0.03805439f, -0.02563445f, -0.04994359f, 0.10771621f, 
    0.12167861f, 0.07110178f, 0.02051199f, -0.06722928f, -0.23915216f, 0.05296382f, 0.14741488f, -0.28331214f, 
    0.07551337f, 0.04595581f, 0.05024681f, -0.11426225f, 0.03285960f, 0.07872159f, -0.04953289f, 0.09111317f, 
    -0.46140510f, -0.01540377f, 0.17070483f, 0.24118374f, 0.05210781f, 0.02996452f, 0.03067197f, 0.04737647f, 
    0.06490316f, -0.02022322f, 0.03782840f, 0.14439785f, -0.13193160f, 0.13705324f, 0.08518818f, 0.11208830f, 
    0.05137192f, -0.13163498f, 0.04176854f, 0.06813124f, -0.06740173f, 0.02534506f, -0.17092367f, -0.00956111f, 
    0.71516234f, -0.13864608f, -0.82892245f, -0.20995218f, -0.22411638f, -0.02492669f, 0.32761765f, 0.07960383f, 
    0.02196310f, 0.10077275f, -0.09467584f, -0.05179466f, 0.17071342f, 0.10908847f, -0.03571564f, -0.07662534f, 
    0.02497136f, -0.08035949f, 0.03980357f, 0.04396354f, -0.10698270f, -0.08675843f, -0.21313806f, -0.12364870f, 
    0.04609853f, -0.02112097f, -0.04529279f, 0.01336676f, 0.04928229f, 0.00903014f, -0.05569109f, -0.00802332f, 
    0.00253383f, 0.01718085f, 0.01828843f, 0.02997588f, 0.31321174f, 0.19772853f, -0.05858942f, -0.12267027f, 
    0.01459111f, -0.04895101f, -0.01664519f, -0.09852208f, 0.09613731f, 0.00643868f, 0.15929511f, 0.03107414f, 
    -0.46224678f, 0.32731709f, 0.07894272f, -0.10112913f, -0.15883140f, -0.03127016f, -0.04349624f, 0.31029439f, 
    -0.01278934f, 0.07639056f, 0.06199185f, -0.02400596f, -0.04941304f, -0.09590527f, 0.01968225f, 0.12853529f, 
    0.01152161f, -0.00628847f, 0.10771342f, -0.02450679f, -0.03441892f, 0.10758045f, 0.03304742f, 0.09824989f, 
    0.11218168f, 0.10233533f, -0.14764287f, -0.18407740f, 0.05362556f, 0.03916201f, 0.00708050f, -0.06888474f, 
    -0.06377746f, 0.01675810f, 0.04556441f, -0.13525374f, 0.27037963f, 0.11771757f, -0.19312452f, -0.12976414f, 
    0.06117668f, -0.17319563f, 0.05835808f, 0.14521490f, -0.00733270f, 0.13838287f, 0.00167354f, -0.10650353f, 
    -0.49943674f, -0.53927583f, -0.46660018f, -0.45749408f, -0.06167942f, -0.42614472f, -0.12273646f, -0.41190284f, 
    -0.00781657f, 0.01042328f, -0.07701574f, 0.00591496f, -0.01353022f, 0.03817326f, 0.22855237f, -0.00034512f, 
    0.04024050f, -0.03611958f, 0.06962899f, -0.01919717f, -0.00407683f, 0.03130154f, 0.08499692f, -0.02536163f, 
    -0.70986331f, -0.36879215f, 0.20338254f, -0.38982847f, -0.05746980f, -0.13923109f, 0.02786625f, -0.09398728f, 
    -0.05165147f, 0.04937522f, 0.02655309f, 0.05717641f, -0.06775855f, -0.02747899f, -0.04599168f, 0.24656817f, 
    0.02821931f, -0.11629716f, -0.00642748f, 0.02807053f, -0.00247418f, 0.02889873f, 0.06653902f, -0.03563282f, 
    0.14271821f, 0.07147597f, -0.00623334f, -0.11256678f, -0.03559677f, 0.03197964f, -0.00778212f, 0.11271112f, 
    0.06590486f, 0.11966947f, 0.05895561f, 0.10601662f, 0.39156061f, 0.33435479f, 0.14298762f, -0.13344614f, 
    0.02593709f, -0.26384339f, -0.02049233f, -0.07899900f, -0.17971700f, 0.02062232f, 0.05949366f, 0.07682335f, 
    0.25321424f, 0.27584779f, -0.06805172f, -0.25371790f, -0.10102624f, 0.01839287f, 0.21324167f, 0.04882511f, 
    0.07430095f, -0.02843571f, 0.26249504f, 0.04211671f, 0.06697704f, -0.05589705f, 0.04534305f, -0.20374902f, 
    0.01954558f, 0.03598560f, 0.13568912f, 0.01354949f, 0.04999472f, 0.09682482f, 0.11713483f, 0.12150314f, 
    -0.03506445f, 0.33373246f, -0.17173918f, 0.29020852f, 0.16373296f, -0.12364343f, 0.21348776f, -0.00853671f, 
    0.11554665f, 0.01964207f, 0.04438112f, -0.06989652f, -0.00351066f, -0.12264071f, 0.35844404f, 0.59467745f, 
    0.04040562f, 0.00472032f, 0.03141174f, -0.05074741f, -0.00970331f, 0.04897356f, -0.00562043f, -0.01558995f, 
    0.03841750f, 0.00382388f, 0.00825214f, 0.11978593f, -0.12696527f, 0.04905031f, -0.05426909f, 0.09207337f, 
    0.02087881f, 0.04045180f, 0.08295345f, 0.04999435f, 0.09858702f, 0.00754649f, -0.02732603f, -0.02509841f, 
    0.03037158f, 0.01296007f, 0.03085825f, 0.00402195f, -0.04937224f, 0.13150257f, 0.07224517f, 0.01340989f, 
    -0.00984804f, 0.07770702f, -0.13072871f, -0.06717402f, -0.09982158f, 0.09658513f, 0.06597485f, 0.21422741f, 
    0.06283478f, -0.01245685f, -0.01897974f, -0.01184601f, -0.24823174f, -0.09133108f, 0.17383119f, 0.15758184f, 
    0.13511746f, -0.01102813f, 0.04954934f, -0.04564658f, 0.03162163f, 0.04972568f, -0.06149520f, -0.02240313f, 
    -0.00514589f, -0.04998779f, -0.11140034f, -0.00044697f, -0.11053818f, -0.15871359f, 0.06563565f, 0.21668284f, 
    0.04758564f, 0.06224692f, -0.03762771f, 0.18429074f, -0.17144528f, -0.10897128f, -0.05420745f, 0.07079131f, 
    -0.15797396f, -0.04333172f, -0.00585540f, 0.02062736f, 0.04186296f, 0.01854667f, 0.00213686f, -0.02136226f, 
    -0.01588856f, -0.14505035f, 0.09887050f, -0.17544599f, -0.11138462f, -0.03364169f, -0.00471345f, -0.00521164f, 
    0.01435610f, 0.01801154f, 0.00048111f, -0.04876557f, -0.77901262f, 0.37505230f, -0.25456861f, 0.70031607f, 
    -0.03831472f, 0.18742643f, 0.11183145f, -0.03462255f, 0.02372526f, -0.00603274f, 0.02751584f, -0.01863876f, 
    -0.04752764f, -0.34025770f, 0.24327059f, -0.33624518f, -0.25707391f, 0.18865432f, -0.08441541f, 0.09466055f, 
    0.03648562f, -0.04510832f, -0.04882931f, -0.01356011f, -0.15943058f, -0.39142027f, -0.13085492f, 0.15948816f, 
    -0.01246096f, 0.04251683f, 0.06597999f, -0.04765324f, -0.08953246f, 0.06910754f, 0.04690037f, 0.01251331f, 
    0.31525722f, -0.15082969f, 0.11858587f, 0.21576013f, -0.06638087f, -0.03616472f, 0.00145910f, -0.14547753f, 
    0.02902163f, -0.02066784f, -0.06546926f, -0.00919798f, -0.16160569f, 0.17179495f, -0.21954435f, 0.23756623f, 
    -0.15867603f, 0.07098235f, 0.04342772f, 0.01874380f, -0.00922664f, 0.01571963f, 0.00301153f, 0.01268886f, 
    0.03269564f, -0.04329000f, -0.15495196f, -0.03238126f, 0.11822818f, -0.04860911f, 0.05348221f, 0.04128621f, 
    0.04730266f, -0.08677097f, -0.07129933f, -0.03776719f, -0.49361774f, -0.35047632f, -0.11617533f, 0.22723880f, 
    -0.01128298f, -0.16711110f, 0.03940197f, 0.06804660f, -0.01091079f, -0.08222929f, -0.07747476f, -0.05859454f, 
    0.02111900f, 0.13883282f, 0.06243297f, -0.03655940f, 0.05106666f, 0.05564237f, 0.05019974f, -0.00405566f, 
    -0.04765105f, 0.01933075f, 0.01617594f, -0.01006944f, 0.11883066f, 0.04061237f, 0.02349092f, -0.15714513f, 
    0.01135825f, 0.02096662f, 0.04068274f, -0.05638748f, -0.05463001f, -0.17290151f, -0.17078117f, -0.20560095f, 
    -0.29892364f, -0.43889177f, -0.42361656f, 0.00803708f, 0.04922369f, 0.03409479f, 0.05232295f, 0.00436236f, 
    0.14702372f, 0.00909489f, 0.07183184f, 0.02596088f, 0.27809456f, 0.08720499f, -0.37693164f, -0.02472871f, 
    -0.04626382f, -0.05686090f, -0.05209322f, 0.00243783f, -0.01297721f, 0.09327603f, 0.02190598f, 0.10207793f, 
    -0.01227404f, -0.05561540f, 0.14441776f, -0.08413368f, -0.01430563f, -0.02293574f, 0.00340484f, -0.05092930f, 
    0.04182408f, -0.11806684f, 0.05619918f, -0.06799684f, 0.04500932f, -0.53410876f, -0.18669544f, -0.27973682f, 
    0.13637026f, -0.08091223f, 0.01549972f, 0.04987720f, 0.05522726f, 0.00731376f, -0.01576980f, 0.02054730f, 
    -0.14127226f, -0.50124609f, 0.29173371f, 0.14682969f, 0.02243898f, 0.03937593f, 0.05281169f, 0.03749900f, 
    0.03368489f, -0.11012270f, 0.06070414f, -0.00210432f, 0.56634623f, -0.52098304f, -0.22972395f, -0.15956092f, 
    0.02438867f, -0.03144454f, 0.00598440f, -0.04536502f, 0.18039893f, 0.06133436f, 0.00171876f, 0.08542125f, 
    0.10946766f, 0.12537788f, -0.11325783f, -0.06319914f, 0.01465707f, -0.09232963f, -0.04812991f, -0.08618418f, 
    -0.08866856f, -0.11537521f, -0.02235871f, -0.07705497f, 0.11962565f, -0.13749257f, -0.02754489f, -0.10996848f, 
    0.08759318f, -0.00140468f, -0.04186878f, -0.09460773f, -0.02860143f, 0.02386607f, 0.06356917f, 0.07451379f, 
    0.08804198f, -0.05088436f, -0.01135208f, -0.08021607f, -0.00714959f, 0.03641694f, -0.01882819f, -0.09022801f, 
    -0.08385606f, 0.11284582f, 0.02851828f, -0.05291469f, -0.02168261f, 0.01365176f, 0.00835638f, -0.05846989f, 
    -0.03702000f, -0.06436195f, 0.02863933f, 0.03405663f, -0.00548435f, 0.01562860f, 0.02414049f, 0.01051250f, 
    0.21778543f, 0.25624415f, 0.01788045f, -0.11994242f, 0.04563832f, -0.16732183f, -0.03082587f, -0.01343414f, 
    -0.05514670f, 0.03772985f, 0.01423314f, -0.04630382f, -0.51136082f, 0.30425182f, -0.31027904f, 0.26905772f, 
    0.12933923f, -0.00211284f, 0.18673147f, 0.04485010f, -0.00285458f, 0.05889251f, -0.08176631f, -0.05946190f, 
    -0.09754850f, 0.03963708f, -0.01463090f, -0.01477051f, -0.03414812f, 0.04190310f, 0.00598124f, -0.08713553f, 
    -0.00937330f, 0.06605517f, 0.06502894f, -0.15391736f, 0.02061420f, 0.02057827f, -0.13893685f, -0.00526461f, 
    0.06393542f, -0.09575836f, 0.02045796f, -0.06452519f, 0.00400737f, -0.00093513f, 0.07264853f, 0.01853422f, 
    -0.58718091f, -0.58450526f, 0.19374357f, 0.13479191f, -0.04299589f, 0.05933299f, 0.01997905f, -0.03738832f, 
    -0.01118765f, 0.02279561f, -0.01185299f, -0.03946530f, 0.02948025f, 0.05017257f, 0.06311735f, -0.03374618f, 
    -0.08826783f, 0.01953426f, 0.06478620f, 0.00379997f, 0.08119129f, -0.00982701f, -0.02002699f, 0.03782489f, 
    -0.10331947f, 0.13222250f, -0.18059729f, -0.01156237f, -0.06224178f, 0.05791670f, -0.08140718f, 0.03130485f, 
    0.02027047f, 0.06524417f, 0.04734536f, -0.06013484f, -0.15221095f, 0.16605571f, -0.13750415f, -0.08885603f, 
    0.00156688f, 0.02078865f, -0.00656898f, -0.04782302f, 0.02590059f, 0.08328835f, 0.04547179f, 0.02533051f, 
    0.10373244f, -0.22801685f, -0.01534316f, -0.22692242f, -0.03746184f, -0.26711938f, -0.14201206f, -0.15433174f, 
    0.00821508f, 0.04322510f, 0.01851818f, 0.03764399f, -0.37382603f, -0.42502746f, -0.18643855f, -0.05587085f, 
    0.11421052f, -0.03631937f, 0.06281860f, 0.20604184f, -0.01353994f, -0.04703328f, -0.04226170f, -0.01999820f, 
    -0.07114266f, 0.13609502f, 0.00678216f, 0.02278747f, -0.06027106f, 0.04345849f, 0.01893855f, 0.05935844f, 
    -0.22058049f, 0.11268329f, -0.12244069f, 0.08193364f, -0.14878365f, -0.04373987f, -0.01789363f, -0.02096566f, 
    0.11863285f, 0.02421248f, 0.15149106f, -0.08879675f, 0.00595963f, 0.07359274f, 0.02985452f, 0.02762204f, 
    -0.07849772f, -0.05891412f, 0.18513265f, -0.03516063f, -0.04978333f, -0.10918996f, 0.01424694f, 0.05014779f, 
    0.08736920f, 0.02601059f, 0.12042997f, -0.03144208f, -0.01221301f, 0.11654253f, -0.00325507f, -0.10415575f, 
    -0.00381146f, -0.00082273f, 0.01336170f, -0.04281702f, 0.05995725f, 0.05863136f, 0.01905987f, -0.09610731f, 
    0.34656817f, -0.02407282f, -0.16360144f, -0.26594317f, -0.05499373f, 0.04158900f, -0.01900657f, -0.05017405f, 
    0.13693461f, -0.03306020f, -0.02340149f, -0.01367769f, 0.26980844f, -0.00084987f, -0.11223243f, -0.05059372f, 
    0.05903193f, -0.02466176f, 0.01885638f, -0.02707991f, 0.01226639f, 0.07599743f, 0.07313815f, 0.05068508f, 
    0.33969033f, -0.19237716f, 0.19328988f, -0.48387706f, -0.04135640f, 0.09368823f, -0.02417847f, 0.01845828f, 
    -0.02749941f, 0.06972548f, -0.02873584f, -0.04066661f, 0.09117220f, 0.17646191f, -0.10814072f, 0.20997404f, 
    0.04943690f, 0.01123186f, 0.08829178f, -0.05000925f, 0.00444444f, 0.02759526f, 0.11199016f, 0.00438260f, 
    -0.26666233f, -0.04550029f, 0.21597037f, 0.18544999f, -0.01335110f, 0.06259274f, 0.18166420f, 0.04693758f, 
    -0.06408659f, 0.04384630f, 0.00617094f, -0.05287160f, 0.03411389f, -0.00206362f, 0.04900693f, -0.12333927f, 
    0.04882009f, 0.08351307f, 0.01467101f, -0.00265591f, -0.09640133f, -0.07038474f, -0.22545922f, -0.15147284f, 
    -0.74527502f, -0.50194639f, -0.04182879f, 0.21089005f, -0.03814254f, -0.00391186f, -0.08326980f, -0.14566201f, 
    0.02784633f, -0.01596226f, -0.04841738f, 0.03292618f, 0.00536718f, -0.04250656f, 0.00394257f, -0.10750779f, 
    0.00779591f, -0.01698238f, 0.00749119f, -0.04145605f, 0.00576347f, -0.26030165f, -0.10057042f, -0.11511483f, 
    0.06189724f, 0.04955036f, 0.03309915f, -0.19022276f, 0.04447691f, 0.04400062f, 0.01693273f, -0.00781280f, 
    0.04256423f, 0.02715794f, -0.00853560f, -0.13313735f, -0.03775606f, -0.19752610f, 0.17578915f, -0.01534240f, 
    0.06302526f, 0.03186520f, 0.04158251f, 0.00171578f, -0.11731444f, -0.14074983f, 0.06996991f, 0.11175699f, 
    0.49138758f, -0.21876819f, -0.17963132f, -0.18809029f, 0.02638566f, -0.08419105f, 0.08288053f, -0.00383871f, 
    0.06981873f, 0.09774785f, 0.03782895f, -0.04673332f, 0.10657657f, -0.02940472f, 0.13170195f, -0.16415662f, 
    -0.00361097f, 0.04958000f, -0.00665619f, -0.12047415f, -0.21941106f, 0.01157480f, -0.12126996f, -0.10842984f, 
    -0.11611824f, 0.06953301f, 0.11593692f, -0.02048663f, -0.11336032f, 0.05930196f, -0.08103979f, -0.01449687f, 
    0.01052814f, 0.04244515f, -0.11291032f, 0.04521982f, -0.37129521f, -0.31155965f, 0.00113801f, 0.08573098f, 
    -0.04266537f, 0.00731819f, -0.00948614f, -0.03683497f, -0.01198258f, -0.21278694f, 0.20204444f, -0.02627593f, 
    -0.35607603f, -0.41535416f, -0.32118300f, 0.20091182f, 0.16354735f, 0.00292960f, 0.05765233f, -0.00874538f, 
    0.07143646f, 0.04388051f, -0.03156189f, -0.01003546f, 0.02942375f, 0.27319416f, -0.17078218f, 0.21152273f, 
    0.01643162f, 0.14378500f, 0.00154564f, 0.07070327f, 0.00184235f, 0.00841603f, -0.06231273f, 0.04838345f, 
    0.03493334f, -0.55070311f, -0.18607156f, -0.56348217f, -0.06402189f, 0.04385309f, -0.00303148f, 0.24695736f, 
    0.06202396f, -0.00646285f, 0.02939807f, -0.00814696f, 0.32065001f, -0.17120947f, 0.04331364f, -0.31107962f, 
    -0.13997839f, 0.17585583f, -0.27117091f, 0.10926333f, -0.03501214f, -0.00220644f, -0.12612450f, 0.04990236f, 
    -0.09748393f, 0.03140695f, -0.15421492f, 0.15196301f, -0.10232895f, 0.11087839f, 0.00808377f, 0.00156546f, 
    0.09588771f, 0.02476078f, 0.03378804f, 0.06943659f, -0.19515027f, 0.48231107f, 0.12761401f, 0.05447973f, 
    0.02767774f, -0.01488331f, 0.05386126f, 0.05043433f, -0.02421833f, 0.03882710f, 0.04280580f, 0.03587172f, 
    0.04167950f, 0.23943910f, -0.17022341f, 0.14518738f, 0.16646703f, -0.06346098f, 0.09161407f, -0.06045727f, 
    -0.10919444f, 0.12866980f, 0.02938916f, -0.20300764f, 0.24630567f, -0.10854898f, -0.10347964f, 0.18975857f, 
    0.03011292f, -0.02232828f, -0.07327124f, 0.06856550f, -0.06178705f, -0.04272709f, 0.10937786f, 0.06589759f, 
    -0.48206866f, -0.21576349f, -0.26636332f, -0.01684385f, -0.04282934f, -0.03681820f, 0.31627816f, 0.05439810f, 
    0.01524662f, -0.02134228f, -0.04754511f, 0.02372076f, -0.33740541f, -0.10514575f, -0.13016486f, -0.28179747f, 
    -0.03201888f, 0.24753974f, 0.01152900f, 0.02457882f, 0.04363547f, 0.04214027f, 0.01694846f, -0.13358282f, 
    0.27962074f, -0.03004021f, -0.16259167f, -0.05840373f, -0.11933904f, 0.00361526f, 0.08157577f, -0.18808506f, 
    -0.11605749f, 0.08344381f, -0.00726112f, -0.25410315f, -0.00110911f, 0.13156164f, 0.07715952f, 0.06056444f, 
    0.00438354f, 0.04494856f, 0.02171370f, -0.02427338f, 0.03780335f, 0.01495915f, 0.01448136f, 0.06787119f, 
    0.13358143f, 0.12189232f, 0.08505784f, 0.01037249f, -0.02300051f, 0.04073781f, -0.03732473f, -0.14995070f, 
    -0.18681467f, -0.05934377f, 0.00657178f, 0.03321712f, -0.01447975f, -0.08090658f, 0.01319509f, -0.28958565f, 
    0.07086462f, 0.00130072f, 0.15841892f, 0.10393945f, 0.14251541f, -0.00377792f, -0.05088289f, -0.07324276f, 
    0.30128995f, -0.09545963f, 0.06518812f, -0.23664132f, -0.00637155f, 0.11142039f, -0.03709392f, -0.08817570f, 
    -0.08643445f, -0.01930476f, 0.06742480f, -0.16892339f, 0.03371313f, 0.05118655f, -0.05647727f, 0.09372737f, 
    0.03778335f, 0.03654433f, 0.13634475f, -0.07173283f, -0.04573030f, -0.00255707f, 0.05115386f, 0.03881215f, 
    0.08919293f, -0.07540865f, 0.09753431f, -0.02463919f, -0.05048078f, 0.05001369f, -0.00431634f, -0.05452077f, 
    -0.04139490f, 0.12239519f, 0.04516685f, -0.01002579f, -0.50031167f, -0.19973356f, -0.00991233f, 0.20234030f, 
    0.07885516f, -0.03114133f, -0.28634927f, 0.11017579f, 0.02373230f, 0.11479758f, 0.12304059f, 0.07890458f, 
    0.01810372f, -0.02947238f, -0.45846403f, 0.12825830f, 0.23613115f, -0.15276602f, 0.12238915f, 0.07763210f, 
    -0.01541009f, -0.06374781f, -0.01543775f, 0.00638829f, -0.10806862f, -0.24803534f, 0.19742434f, 0.21748067f, 
    -0.02400402f, 0.04524011f, -0.03186266f, -0.04984589f, 0.02450980f, 0.02994903f, -0.12830843f, 0.02394382f, 
    0.47466132f, 0.02146381f, -0.00857329f, -0.42977431f, 0.13231039f, 0.05491688f, -0.00159484f, 0.03773495f, 
    0.07426524f, 0.03464074f, 0.17131670f, -0.16753648f, -0.13480417f, 0.00925158f, 0.04257764f, 0.14988904f, 
    0.13306838f, 0.08478627f, -0.15791662f, 0.06817540f, -0.18186694f, -0.00859386f, -0.19990465f, -0.27448598f, 
    -0.08874682f, -0.12856561f, -0.04284178f, 0.00837311f, 0.08517393f, 0.12899065f, -0.04182586f, 0.16683199f, 
    -0.26396301f, 0.03023526f, -0.10171689f, -0.21249570f, -0.02866000f, -0.35062841f, -0.32652065f, -0.15609382f, 
    -0.04984248f, -0.10305023f, -0.05181050f, -0.21020399f, 0.02843195f, 0.01592034f, 0.03643079f, 0.03879521f, 
    0.07113846f, -0.01696705f, 0.01632743f, -0.05839460f, -0.15956888f, -0.02681331f, 0.01998788f, -0.06631246f, 
    0.03783017f, 0.11404284f, 0.08656191f, 0.10012499f, -0.11367642f, -0.04411868f, -0.07843594f, -0.10420392f, 
    -0.02482926f, -0.03587135f, 0.03554663f, -0.05365003f, 0.08578452f, 0.04193741f, 0.00868407f, 0.07344364f, 
    0.11453228f, -0.05976248f, -0.13538779f, 0.12087397f, 0.09212675f, 0.10462260f, 0.07407406f, 0.05914538f, 
    -0.15872476f, -0.20553254f, -0.22304559f, -0.25496423f, -0.17330235f, -0.36228439f, -0.08449262f, -0.20240606f, 
    -0.11049012f, 0.17876396f, 0.13566180f, 0.07717899f, 0.14007369f, -0.00779330f, 0.09441161f, 0.04064576f, 
    0.00555149f, 0.00970574f, -0.09562886f, 0.06928088f, 0.01481443f, 0.04219133f, 0.04985161f, -0.01194614f, 
    -0.00793671f, 0.07690866f, -0.14390044f, 0.03419790f, -0.40354919f, -0.44312102f, -0.38585129f, -0.07407345f, 
    0.14829022f, 0.00169443f, 0.05379025f, 0.09433783f, 0.05236357f, -0.00948535f, 0.00404009f, 0.10286452f, 
    0.11478630f, -0.49073082f, -0.43943506f, -0.18255836f, -0.05214064f, 0.14521872f, -0.08202749f, -0.00613172f, 
    0.01108565f, 0.20654660f, 0.01753915f, 0.07684993f, -0.27208477f, -0.16576113f, -0.12183756f, -0.05357936f, 
    -0.03160485f, 0.10230473f, 0.08112708f, 0.04804063f, -0.14628586f, -0.06205478f, -0.08247214f, -0.11216480f, 
    0.13520490f, -0.08706463f, -0.17579092f, -0.09761908f, 0.00192818f, 0.06295342f, 0.08302461f, 0.05614004f, 
    -0.04941547f, 0.02441614f, -0.13179941f, -0.12399674f, 0.07033578f, 0.05339832f, 0.05713295f, -0.01645628f, 
    0.07592466f, 0.01161851f, 0.08175138f, -0.16458215f, -0.04385170f, -0.02074471f, 0.07654659f, 0.11620058f, 
    0.10437842f, -0.01188289f, 0.10692305f, -0.03383465f, 0.02144590f, 0.02247174f, 0.07811874f, -0.01513361f, 
    0.01915401f, -0.01527525f, 0.13499011f, 0.04672237f, -0.08259873f, -0.03199674f, 0.06008002f, -0.02454397f, 
    -0.09636278f, 0.06788334f, -0.05563648f, -0.03834242f, 0.03486462f, 0.05778509f, 0.04053273f, 0.04445431f, 
    0.27710447f, 0.31937855f, 0.13968864f, -0.21989444f, -0.00515448f, 0.09345044f, -0.01087141f, -0.04479687f, 
    -0.02643984f, 0.03124191f, -0.04469992f, 0.02569382f, -0.10185453f, 0.14300267f, -0.04031959f, -0.00164676f, 
    -0.08746192f, 0.03041223f, 0.06273094f, -0.18463780f, -0.00098075f, -0.05121020f, 0.04237759f, -0.02786028f, 
    -0.16455966f, 0.09041262f, -0.00541901f, 0.12134930f, 0.01497464f, -0.00923033f, -0.03481005f, 0.01764848f, 
    -0.01171577f, -0.07533561f, 0.15465379f, -0.05342864f, 0.19678970f, 0.01907303f, 0.14046638f, 0.05685494f, 
    -0.02591481f, -0.02594056f, -0.12915893f, -0.07489555f, -0.00476304f, -0.15259840f, -0.05921705f, -0.02705152f, 
    0.52075350f, -0.20020081f, -0.10942314f, -0.10164440f, 0.09597265f, 0.04951279f, 0.00954134f, -0.07155057f, 
    0.09265319f, 0.12223947f, 0.09869268f, 0.04225349f, -0.14457868f, 0.04662263f, -0.04791273f, -0.14186680f, 
    -0.09319552f, -0.01385745f, -0.05150344f, -0.08558118f, -0.23264800f, -0.04419291f, -0.08236728f, -0.19967893f, 
    -0.12751457f, 0.13873820f, -0.01293536f, 0.12334936f, 0.22916873f, -0.07506221f, -0.07650342f, 0.02951022f, 
    -0.01768318f, -0.01450504f, 0.07105045f, -0.01739980f, -0.62145817f, 0.09356751f, 0.11532721f, 0.26432538f, 
    -0.05349559f, -0.04269620f, -0.09183780f, -0.07659619f, -0.04143685f, 0.02426325f, -0.01357711f, -0.04052543f, 
    0.06226495f, 0.00784555f, 0.06408034f, 0.06678569f, 0.13360693f, 0.00023211f, -0.09821229f, -0.31744859f, 
    0.04844513f, 0.03789617f, -0.01540200f, -0.03830143f, -0.05891302f, -0.41136298f, -0.38514170f, -0.30408344f, 
    -0.21181454f, -0.12284617f, 0.05289933f, -0.11041580f, 0.00888943f, -0.03028905f, -0.00754554f, 0.02609937f, 
    -0.03988278f, 0.07887468f, 0.23816428f, 0.04535275f, -0.02367817f, 0.06832905f, 0.11792314f, 0.02473850f, 
    0.07944110f, 0.00956993f, 0.20106991f, -0.00236502f, -0.16293974f, -0.24286324f, -0.00946018f, 0.06338417f, 
    -0.14121829f, 0.08627819f, 0.16575763f, 0.09962594f, -0.23906960f, -0.05628666f, 0.02487542f, 0.00819405f, 
    -0.12215881f, -0.28170615f, 0.11735339f, 0.11973556f, 0.03867339f, 0.15198880f, 0.12575515f, 0.05764998f, 
    -0.15560962f, -0.19235800f, -0.15677392f, -0.34855241f, -0.13083673f, 0.05905267f, 0.19558185f, 0.07538100f, 
    -0.06786261f, -0.02870650f, -0.00092653f, 0.02936780f, -0.09234909f, 0.04844331f, -0.04661371f, -0.00290128f, 
    0.00725415f, -0.23078528f, -0.28076461f, -0.27125257f, 0.01790896f, -0.05967413f, 0.06031775f, 0.03077119f, 
    0.05807602f, 0.12328252f, -0.07941436f, 0.06218669f, -0.06826117f, -0.16214375f, -0.14627968f, -0.03641428f, 
    -0.05234596f, 0.08629084f, 0.08252967f, 0.05391682f, 0.11156234f, 0.05601454f, 0.09643479f, 0.03465581f, 
    -0.01085350f, -0.22827423f, -0.28537789f, -0.15451804f, 0.01471135f, -0.01307745f, 0.07060794f, 0.03023585f, 
    0.17409304f, 0.01218112f, 0.16418757f, 0.17837216f, -0.54599696f, -0.10916211f, 0.13103256f, 0.07019397f, 
    -0.09738880f, 0.00244140f, -0.08292351f, -0.08332284f, 0.07061125f, -0.07866760f, -0.09028455f, 0.05297018f, 
    -0.02678449f, -0.21633820f, 0.05249450f, 0.09776063f, -0.07583059f, 0.08122280f, -0.12121060f, -0.00521842f, 
    0.00105100f, -0.00680639f, 0.09091873f, 0.16772559f, 0.02873302f, 0.07577902f, 0.07718980f, 0.12521876f, 
    -0.03388750f, 0.01007834f, 0.08484565f, 0.03839789f, 0.16934878f, -0.00800011f, 0.13400637f, 0.08229061f, 
    -0.04452771f, 0.01047096f, -0.22886634f, 0.19470870f, 0.27501127f, -0.03010778f, 0.04474035f, -0.12965146f, 
    -0.01705848f, -0.08059693f, 0.11845541f, 0.13529406f, -0.19229014f, -0.01246045f, -0.09607867f, 0.00418929f, 
    0.03396768f, 0.04914311f, 0.03717152f, 0.00690321f, 0.06519345f, 0.10782737f, 0.04084184f, 0.08383229f, 
    -0.06050787f, 0.05940479f, 0.07956212f, -0.01418427f, -0.10477594f, -0.06776263f, 0.02531144f, -0.03358320f, 
    -0.08613847f, 0.04479543f, -0.00317635f, 0.03543083f, -0.15358846f, -0.15662006f, 0.07680275f, 0.13852276f, 
    -0.02643163f, -0.08006458f, -0.09178437f, 0.13203718f, -0.02168801f, -0.22547108f, -0.15294662f, -0.13708669f, 
    0.10006851f, -0.15309440f, -0.45070904f, -0.13941878f, -0.06714784f, -0.02498994f, 0.07088295f, 0.05475456f, 
    0.16907419f, -0.26059771f, -0.06772699f, -0.00014153f, 0.12913334f, 0.13974394f, -0.18338935f, -0.22849186f, 
    -0.06029480f, 0.09027746f, 0.06015677f, -0.16943921f, 0.05033678f, -0.01332162f, -0.04680442f, 0.02034187f, 
    0.22436137f, 0.17723589f, 0.07239176f, 0.11088441f, 0.03703869f, -0.00112570f, -0.02405879f, -0.00407305f, 
    -0.00212592f, 0.00522493f, 0.14003026f, -0.03142821f, -0.02794895f, 0.03262610f, 0.00947332f, 0.07490026f, 
    0.11291118f, 0.03623265f, 0.00010867f, 0.01550283f, 0.09316932f, 0.09195511f, 0.07123315f, 0.33436361f, 
    -0.34181875f, -0.48272634f, -0.31542093f, -0.08756756f, -0.01537514f, -0.10291509f, -0.08980990f, 0.06967304f, 
    -0.02952482f, 0.02372494f, 0.01656180f, 0.08167006f, -0.13479979f, 0.13085397f, 0.06144399f, 0.37509078f, 
    -0.13591613f, -0.17365822f, -0.15372181f, -0.00358764f, -0.04567566f, 0.06738164f, 0.02989915f, -0.01298423f, 
    -0.30934039f, -0.36358267f, -0.48498526f, 0.09827992f, 0.01036784f, 0.00103144f, 0.12385666f, -0.02842670f, 
    -0.07213710f, -0.02472558f, -0.05065579f, -0.04382976f, 0.21587214f, 0.21485057f, -0.14952281f, -0.15510555f, 
    0.02840132f, -0.14608519f, 0.06309105f, -0.05999559f, 0.13502035f, -0.02101016f, 0.13166380f, 0.04286652f, 
    -0.03453698f, -0.01495194f, -0.01386688f, 0.09998058f, 0.05558834f, 0.02329007f, -0.06723748f, 0.16611743f, 
    -0.19663657f, -0.00460623f, -0.03671526f, -0.40929562f, -0.56327182f, -0.22701457f, 0.09473016f, 0.12885371f, 
    -0.00357784f, 0.09283855f, 0.04008374f, 0.12424240f, 0.12582187f, 0.07528494f, -0.04433601f, 0.06536247f, 
    -0.32447064f, -0.25865105f, 0.06607667f, -0.00170339f, 0.11807045f, 0.07255485f, -0.04548835f, 0.05433957f, 
    0.05899610f, -0.19198111f, 0.01056585f, -0.04859251f, -0.00430331f, 0.05438185f, -0.01087581f, -0.14291117f, 
    -0.04873829f, -0.01912960f, 0.03409629f, 0.04543220f, -0.03223601f, 0.12841299f, -0.00347335f, -0.08870581f, 
    -0.37425092f, -0.19912609f, 0.13982812f, 0.39122346f, 0.05787677f, 0.00135705f, 0.06148812f, -0.16254538f, 
    -0.06740238f, 0.11719777f, 0.12594710f, 0.11834862f, -0.38447660f, 0.14147337f, -0.13327447f, 0.53390002f, 
    0.04930834f, 0.18109481f, -0.05216451f, 0.14621101f, 0.05284884f, 0.12429367f, -0.02092901f, -0.01111083f, 
    0.26610482f, -0.00858442f, -0.10830106f, -0.15756522f, 0.16163392f, 0.00950458f, -0.06145532f, 0.04187857f, 
    0.21637940f, -0.01669255f, 0.04392304f, 0.24997547f, -0.33013979f, -0.03320345f, -0.04507038f, -0.02203784f, 
    -0.05333336f, 0.02509742f, -0.13803241f, -0.06131915f, -0.21419242f, -0.07752790f, -0.18135822f, -0.13606679f, 
    0.07471418f, -0.02832391f, 0.04226380f, -0.13327567f, 0.01102718f, 0.04048571f, -0.08452371f, -0.12341645f, 
    -0.06073758f, -0.06233275f, 0.03600787f, -0.00010392f, 0.12579818f, -0.11809561f, -0.12743072f, -0.18980083f, 
    -0.22490759f, 0.00729765f, 0.01345881f, -0.12853916f, 0.05219963f, -0.00059937f, 0.02350807f, 0.08501033f, 
    0.36388320f, -0.05775033f, -0.07355472f, -0.07872660f, 0.07513919f, 0.05154460f, -0.00209615f, -0.07156873f, 
    0.12107401f, -0.18853056f, 0.06619763f, 0.10515095f, 0.02734441f, -0.05333307f, 0.00534225f, 0.00913916f, 
    -0.06843230f, 0.00884007f, -0.02287035f, 0.08589014f, 0.00534010f, 0.01970993f, -0.00774751f, 0.07870582f, 
    0.32691544f, -0.28326815f, 0.05460243f, -0.20493795f, -0.11689101f, 0.01525371f, -0.19403228f, 0.00068296f, 
    0.00549872f, -0.05221738f, -0.10718238f, -0.13351750f, -0.15741783f, 0.14418170f, -0.40787324f, 0.04514662f, 
    -0.12979233f, -0.01201293f, 0.15673520f, -0.08475214f, 0.10381060f, 0.05510372f, -0.05183192f, -0.11983941f, 
    0.16479950f, -0.13964227f, 0.25137517f, -0.19630171f, -0.04442305f, 0.03089066f, -0.20097770f, -0.04833796f, 
    0.07281012f, -0.04454743f, -0.08299409f, 0.10230295f, 0.23110414f, -0.09239622f, 0.33943808f, -0.10556977f, 
    0.06593680f, -0.07380697f, -0.11569114f, -0.03370986f, -0.02004508f, 0.09951919f, 0.01831276f, -0.06163858f, 
    -0.16967925f, 0.01105147f, -0.10624877f, 0.32735401f, 0.09680644f, -0.01992762f, 0.09264778f, -0.13632096f, 
    0.04788372f, -0.01352825f, 0.09233519f, 0.05213948f, 0.05116519f, 0.11423100f, -0.06780626f, -0.25405374f, 
    0.06034419f, -0.07454291f, 0.11939983f, 0.11436139f, 0.15704772f, 0.13147649f, 0.09736601f, 0.28389367f, 
    -0.01345919f, 0.03091162f, 0.01052487f, -0.03504414f, -0.16470249f, -0.14771269f, -0.09936935f, -0.04035789f, 
    0.13663907f, 0.02809088f, 0.09976526f, 0.07306808f, -0.08244549f, -0.01108273f, 0.20159312f, -0.08274246f, 
    -0.01669504f, -0.11423489f, -0.00827865f, 0.17017815f, 0.04110179f, 0.07307821f, 0.08483380f, -0.02770131f, 
    -0.15047415f, -0.00199534f, 0.06591422f, -0.24103814f, 0.18282142f, 0.07532544f, -0.02331992f, -0.04715334f, 
    -0.03650509f, -0.13064720f, 0.05726330f, -0.00137274f, 0.04403128f, -0.19651544f, 0.20302424f, 0.19415621f, 
    0.05427112f, 0.00220435f, -0.02568632f, -0.04443324f, 0.12808433f, 0.13509370f, 0.05806970f, 0.00746825f, 
    -0.17565449f, 0.17931120f, 0.23291080f, -0.12769890f, 0.03065851f, -0.05428734f, -0.05002457f, -0.08530207f, 
    0.02527143f, 0.05352061f, 0.01011001f, -0.02601693f, 0.13352828f, 0.31151131f, 0.04246740f, 0.29496706f, 
    0.04714194f, -0.07092907f, -0.26857832f, -0.07278173f, 0.00611342f, -0.17227572f, 0.10871860f, 0.08012559f, 
    0.27887315f, -0.09182592f, 0.13569541f, -0.12205982f, 0.00865982f, 0.00900448f, 0.04043686f, 0.04846232f, 
    0.12066188f, 0.17972241f, -0.12437788f, -0.10788505f, -0.18307677f, -0.08004186f, -0.21030936f, -0.33249182f, 
    -0.25633791f, 0.01056707f, -0.13091972f, -0.01466187f, 0.04562470f, -0.04578191f, 0.00742610f, 0.04196086f, 
    -0.20224930f, 0.03421844f, 0.05450193f, 0.14293112f, -0.10272345f, -0.11432422f, -0.05252436f, -0.02949806f, 
    0.07655076f, 0.03143223f, 0.02459313f, -0.00609464f, 0.04224956f, 0.17138080f, 0.30236804f, 0.01959810f, 
    0.03518473f, -0.20493233f, -0.10570088f, -0.15329018f, -0.02160878f, 0.05757651f, 0.10646380f, 0.16520235f, 
    -0.04518062f, -0.07993505f, 0.20559847f, 0.05415300f, 0.10529305f, -0.13082770f, -0.09043450f, -0.04265395f, 
    0.07177617f, 0.05337649f, 0.03083386f, 0.11158593f, 0.03059486f, -0.27732515f, -0.04497045f, -0.06638774f, 
    0.17504826f, 0.02975130f, -0.05441493f, 0.00894774f, 0.19279818f, -0.06141382f, -0.05292640f, 0.05723260f, 
    0.07064588f, -0.17202634f, 0.14447342f, -0.05838143f, 0.03957926f, -0.09747266f, 0.02851517f, 0.01948116f, 
    -0.14197627f, -0.00470853f, 0.00798225f, 0.08149806f, 0.16721812f, -0.15475385f, -0.06524836f, -0.22244743f, 
    0.14118995f, 0.10536702f, 0.07495714f, -0.05511919f, 0.11477244f, -0.21362808f, -0.08449454f, 0.00671432f, 
    -0.54200906f, -0.76042533f, -0.00612284f, -0.18966031f, 0.09805220f, 0.16103292f, -0.06983546f, 0.07338785f, 
    -0.02792826f, -0.00787457f, -0.00448132f, 0.01690688f, -0.14200218f, 0.03420445f, -0.34709391f, -0.16180581f, 
    0.13470136f, -0.07399599f, 0.13296954f, 0.17720237f, -0.04140750f, 0.09005349f, -0.00682516f, -0.02608285f, 
    -0.11665158f, -0.15928678f, -0.16017585f, -0.09123233f, -0.15145780f, 0.05634153f, 0.03776558f, 0.01700286f, 
    -0.06264295f, 0.05372190f, 0.02686656f, -0.03665959f, -0.15684664f, -0.19267735f, 0.04650201f, -0.03383129f, 
    0.15745829f, 0.03332751f, 0.06133439f, 0.02698925f, -0.01810621f, -0.02657915f, 0.05095658f, 0.02125114f, 
    0.02820933f, 0.05032256f, -0.01488290f, -0.04962856f, 0.00090804f, -0.12446567f, 0.14904405f, -0.05651633f, 
    0.00738769f, -0.00467080f, 0.00816242f, -0.06757784f, -0.14234023f, -0.02957984f, -0.09858784f, 0.06201757f, 
    -0.01362859f, 0.18460126f, 0.11892531f, 0.00578313f, 0.21113451f, 0.04727019f, 0.05913552f, -0.02601675f, 
    -0.00268443f, 0.39107653f, -0.48000133f, 0.01990801f, -0.02039506f, 0.06033908f, 0.19241682f, 0.01850801f, 
    0.08314588f, -0.03566704f, -0.03511044f, 0.05279486f, -0.30975804f, -0.01126708f, -0.43704414f, 0.05468474f, 
    0.10377361f, 0.05685036f, 0.19203773f, 0.15221825f, -0.02027137f, 0.00217031f, -0.07478574f, 0.01066382f, 
    0.13341701f, -0.62494272f, -0.53746516f, -0.05885601f, 0.22321792f, 0.08378559f, 0.18995789f, 0.18738371f, 
    -0.01205892f, -0.06791701f, 0.00369524f, -0.06547423f, -0.50037569f, 0.16222972f, 0.24038443f, -0.23677869f, 
    -0.12748583f, -0.08239374f, 0.02289458f, 0.18764780f, 0.01254566f, 0.04536656f, 0.05597606f, -0.01370441f, 
    0.00510916f, -0.06839316f, 0.10137452f, 0.10938957f, -0.03998806f, 0.04165575f, 0.01356710f, 0.11845227f, 
    0.04960033f, 0.06992716f, 0.04375427f, -0.04209744f, -0.18498583f, 0.26356035f, 0.24481513f, -0.31309682f, 
    -0.17976885f, -0.13582835f, 0.06057263f, -0.10971677f, -0.00116840f, 0.10691141f, 0.07751807f, 0.04786742f, 
    0.16062897f, -0.16401406f, 0.26154307f, -0.50243938f, 0.03039341f, 0.05568253f, -0.05822054f, 0.04131309f, 
    -0.02241997f, -0.01502919f, 0.01586365f, 0.05900976f, -0.10826230f, -0.08112975f, -0.02805224f, 0.00067972f, 
    0.03435832f, 0.21606590f, 0.02186313f, 0.02986677f, 0.17001717f, 0.04333803f, -0.11476135f, -0.00780237f, 
    0.14870617f, 0.25973666f, 0.15321578f, 0.48086044f, 0.01784023f, -0.11129519f, -0.11184689f, -0.02502840f, 
    -0.01520044f, -0.04768933f, -0.11536126f, 0.06236699f, 0.14491636f, 0.20193376f, 0.15686928f, 0.06404540f, 
    0.07170645f, -0.08863974f, -0.08473515f, -0.10268494f, -0.06774084f, -0.10704597f, 0.03588603f, 0.10521341f, 
    0.06888781f, -0.17093253f, 0.26681897f, 0.11596745f, -0.05799978f, -0.01447972f, -0.26051626f, -0.23691550f, 
    -0.07709193f, 0.08006881f, -0.05376012f, 0.10920221f, -0.11296613f, -0.15858775f, 0.11204141f, -0.14256798f, 
    0.04064028f, -0.02783680f, -0.02737870f, 0.06441640f, -0.00019393f, -0.01953426f, -0.04448625f, 0.02869860f, 
    0.20913029f, -0.41399285f, -0.05753405f, -0.57740474f, 0.11111366f, -0.08572495f, -0.00110771f, 0.05876489f, 
    0.01969470f, -0.02993108f, -0.02628680f, -0.01295371f, 0.11780866f, -0.14608097f, 0.11117596f, -0.14492658f, 
    0.05602055f, 0.08006008f, -0.12318327f, -0.08770914f, -0.15866423f, -0.00903267f, -0.01937885f, 0.13765258f, 
    -0.24001953f, 0.51449168f, -0.06679440f, 0.00468581f, 0.12556559f, -0.10176824f, -0.05877634f, -0.15857708f, 
    -0.04647453f, -0.02633402f, -0.03090654f, -0.00174612f, 0.09391535f, -0.04918164f, 0.15645020f, -0.01602959f, 
    0.06007543f, -0.06271113f, -0.03640109f, -0.03252051f, 0.09103670f, 0.12770250f, 0.00421013f, 0.07452259f, 
    -0.11045724f, -0.20491080f, 0.19697779f, 0.15824167f, -0.00312034f, 0.12010027f, -0.00578729f, -0.09025301f, 
    0.03893656f, 0.11487161f, -0.03097272f, -0.03381572f, 0.29379323f, -0.14669582f, 0.24713135f, -0.31575033f, 
    -0.11706609f, -0.07194437f, -0.12216059f, 0.04550689f, -0.09553231f, 0.08692344f, 0.00964670f, 0.02078459f, 
    0.15537779f, -0.12523022f, 0.25953677f, 0.51645893f, 0.11386748f, -0.13890183f, -0.12143507f, -0.14005154f, 
    0.00864828f, -0.02636277f, 0.07747573f, 0.05157365f, -0.00146679f, -0.18902557f, 0.10176465f, 0.09044515f, 
    0.04736919f, 0.05305919f, -0.01416193f, -0.11364111f, -0.02206685f, 0.07475873f, -0.00984756f, -0.15057276f, 
    -0.25859529f, 0.01555298f, -0.53156912f, 0.18596728f, -0.00091677f, 0.06215136f, 0.09528874f, 0.00976464f, 
    0.08771490f, -0.03488752f, -0.01479955f, 0.05473334f, -0.05609658f, 0.03432403f, 0.32808372f, -0.22368589f, 
    0.02308876f, -0.21463475f, -0.01222431f, -0.09556162f, 0.07664213f, -0.08401318f, -0.09536301f, -0.00438678f, 
    -0.18809417f, 0.14089899f, -0.10875233f, -0.16213040f, -0.15081353f, -0.12787572f, 0.02167161f, 0.10428157f, 
    0.03652547f, 0.00304935f, 0.02729760f, -0.03033532f, -0.36188036f, 0.03517660f, -0.44946164f, -0.03834514f, 
    -0.07129475f, 0.03683631f, 0.09277524f, 0.07057476f, 0.18011868f, -0.07370130f, -0.10349885f, -0.01814969f, 
    -0.16004279f, -0.29836971f, -0.50678170f, -0.34122887f, -0.27505562f, 0.14135650f, 0.02946296f, 0.16037691f, 
    0.13778210f, -0.00835295f, 0.01717396f, 0.05292267f, -0.12941132f, -0.02199336f, -0.00056741f, 0.09002658f, 
    0.04567344f, -0.03555914f, -0.02716523f, -0.01982250f, 0.05304755f, -0.07143130f, -0.04794946f, 0.11742384f, 
    -0.04600407f, 0.17273057f, -0.01948539f, 0.10652664f, 0.02364844f, -0.11183176f, 0.01770665f, 0.02582739f, 
    0.01137619f, 0.09366402f, 0.16882585f, 0.21761642f, 0.11990574f, 0.11159974f, 0.03072821f, -0.36985216f, 
    -0.09173765f, 0.05386233f, -0.07500982f, 0.06257539f, 0.05708269f, 0.04997106f, -0.10352446f, -0.01300094f, 
    -0.22780864f, -0.18104099f, -0.05127543f, -0.11653781f, 0.14066894f, -0.14124836f, 0.06059463f, -0.05764174f, 
    -0.09452086f, 0.00488484f, -0.02586414f, 0.00529904f, -0.22890219f, -0.10083164f, 0.05397757f, 0.16596712f, 
    0.01227751f, 0.05463490f, -0.09174279f, -0.06126161f, 0.04883328f, 0.04934035f, 0.12184501f, 0.10265779f, 
    0.11763935f, -0.16405405f, 0.28215644f, -0.91830212f, -0.03825121f, -0.04339687f, 0.02106392f, 0.00326944f, 
    -0.12294079f, 0.01872120f, 0.09469865f, -0.12515606f, -0.21682499f, 0.23641898f, -0.07879374f, -0.64848924f, 
    -0.15889817f, -0.11337727f, 0.03058276f, -0.04748148f, 0.03289543f, -0.06032599f, -0.05527697f, 0.05286789f, 
    -0.31751132f, 0.22206646f, -0.06215441f, 0.00638527f, 0.23487578f, -0.10179771f, -0.11358670f, -0.00792127f, 
    -0.06696989f, -0.04141764f, 0.03624537f, -0.16860151f, -0.12473036f, 0.00388610f, -0.03568252f, -0.07865623f, 
    -0.01762083f, 0.06085694f, 0.10107698f, -0.06396366f, 0.03968314f, 0.14536150f, 0.04880358f, -0.08907655f, 
    -0.15968300f, 0.03135886f, -0.38134870f, 0.11205146f, 0.16306314f, -0.16457795f, -0.02353392f, -0.11974081f, 
    0.08658729f, 0.04529104f, -0.00822349f, 0.06560531f, -0.14629349f, -0.16875145f, 0.24370576f, -0.09798557f, 
    0.09968925f, -0.06631649f, -0.32329991f, 0.05678365f, 0.08664962f, 0.08946823f, 0.00723415f, 0.07142913f, 
    -0.20826019f, -0.24569488f, 0.15977044f, -0.00064865f, 0.13736278f, -0.01473343f, -0.04493167f, -0.15223436f, 
    -0.00659634f, -0.10054500f, -0.08639990f, 0.12624991f, -0.11087174f, -0.08958477f, -0.02957566f, -0.05997202f, 
    0.13237770f, -0.17838798f, 0.07393679f, -0.02863694f, 0.02210927f, -0.06383516f, -0.06648954f, 0.01585403f, 
    -0.13054708f, 0.08208556f, -0.09250014f, 0.06069499f, 0.06045074f, 0.13484737f, -0.01539494f, -0.15409650f, 
    0.02051351f, 0.09559298f, 0.20795116f, 0.02059974f, 0.12945895f, -0.18600953f, 0.14177485f, -0.00021413f, 
    -0.15210371f, 0.01693738f, 0.15409920f, -0.06241477f, 0.06728557f, 0.04032906f, 0.17278345f, 0.21858394f, 
    -0.19923189f, -0.01996362f, -0.42122996f, 0.18124260f, 0.12581609f, -0.02338005f, 0.02164138f, -0.03990826f, 
    -0.11410879f, -0.08978521f, -0.05947137f, -0.07430434f, -0.17857802f, -0.02639194f, -0.10152158f, -0.00008696f, 
    0.10463134f, -0.01573598f, -0.13616331f, 0.01957691f, 0.05830438f, -0.11782461f, -0.03076867f, -0.27919513f, 
    -0.16211881f, 0.18364199f, -0.26034680f, -0.16758800f, -0.07613165f, 0.05855581f, 0.11342104f, 0.01483860f, 
    -0.13890222f, -0.10016600f, -0.10073230f, -0.19162022f, 0.09017701f, -0.10288132f, 0.03886278f, -0.04208446f, 
    -0.02541520f, -0.17913337f, 0.09935471f, 0.02906915f, -0.13791786f, -0.19452123f, -0.34949329f, -0.41251910f, 
    0.22301266f, -0.23129208f, 0.10541817f, 0.11109737f, 0.04884018f, -0.08890676f, -0.01949820f, 0.12755500f, 
    -0.13325095f, 0.05945168f, -0.14743236f, -0.05035383f, -0.17739366f, -0.19587100f, -0.06564648f, 0.06080809f, 
    -0.08203194f, -0.08028226f, -0.07029385f, -0.00390541f, 0.03317589f, 0.09199578f, 0.02495121f, -0.03416372f, 
    -0.03129261f, -0.06058790f, 0.34910646f, 0.01571859f, 0.00620744f, 0.08306944f, 0.00418149f, -0.01364074f, 
    -0.01317498f, 0.10341503f, 0.09384208f, 0.22744513f, -0.26214513f, -0.03919308f, -0.28697655f, -0.14009467f, 
    -0.12982908f, 0.01851520f, -0.02439980f, -0.07825658f, 0.07319013f, 0.02768800f, -0.03130238f, 0.06472490f, 
    0.03635675f, -0.17519189f, 0.01454193f, -0.16522551f, 0.05351594f, -0.04015945f, -0.02611620f, 0.05874064f, 
    -0.00758116f, -0.04729818f, -0.19192490f, -0.08712903f, 0.04405911f, 0.29012382f, 0.01431016f, -0.07978892f, 
    0.07151398f, -0.13602002f, -0.10213857f, 0.19633733f, -0.13372061f, 0.14681713f, -0.01311349f, -0.03258781f, 
    -0.09233604f, 0.09160268f, 0.11445222f, 0.16436765f, 0.09661441f, 0.00887351f, -0.08996765f, -0.00551925f, 
    -0.05176732f, -0.03885774f, 0.14335544f, -0.02534702f, -0.08829700f, -0.01076214f, 0.05986455f, -0.02968904f, 
    -0.09683906f, -0.03984779f, 0.00678766f, 0.12476004f, -0.05006003f, 0.10887853f, 0.10981038f, 0.00709840f, 
    -0.32721981f, 0.04546164f, -0.06880251f, 0.12216785f, 0.07038600f, 0.08827981f, -0.03746456f, 0.01023131f, 
    -0.01077896f, 0.22246735f, 0.01879086f, 0.09101102f, 0.23344694f, -0.23813567f, 0.02311789f, -0.12697439f, 
    0.00992255f, -0.04986251f, -0.12141933f, 0.03640533f, -0.11930364f, -0.07439715f, -0.16498430f, -0.26344231f, 
    -0.02562229f, 0.09431460f, 0.19285022f, 0.04796956f, 0.02761514f, 0.09498690f, 0.01187350f, 0.02837354f, 
    0.01067851f, -0.06476232f, 0.02606639f, -0.02138183f, -0.24115884f, -0.03890428f, 0.01404313f, -0.06413253f, 
    -0.04350362f, 0.06107832f, -0.07638685f, 0.00956730f, 0.00129624f, -0.01295621f, -0.01149123f, -0.09488372f, 
    -0.17687184f, 0.30896452f, -0.10516987f, -0.08890221f, 0.04380377f, 0.01594739f, -0.12214538f, 0.03727804f, 
    0.13368385f, -0.04170473f, 0.18137984f, 0.06296860f, -0.16928342f, -0.16707712f, 0.16641808f, -0.08067822f, 
    -0.04794501f, -0.07094896f, 0.02990182f, -0.05126192f, -0.04275148f, 0.02729814f, 0.23549409f, 0.06364909f, 
    -0.10783239f, -0.24395233f, 0.30494627f, 0.05169115f, 0.03637718f, 0.04427146f, -0.08534665f, 0.03572584f, 
    0.05993791f, -0.09974150f, -0.08673279f, 0.02088461f, -0.27438524f, -0.25101742f, 0.01629375f, -0.12801863f, 
    0.03271586f, -0.00700784f, -0.07948967f, -0.03242445f, -0.09112190f, 0.15286784f, 0.05852385f, -0.12026688f, 
    0.08688203f, -0.16301729f, 0.18387419f, -0.05223742f, -0.01638124f, -0.06168163f, 0.01370820f, -0.06562523f, 
    0.15146095f, -0.02625863f, 0.11932085f, 0.04211452f, -0.26736566f, 0.13643637f, -0.06370446f, -0.13059407f, 
    -0.12525405f, -0.03239495f, 0.06276680f, 0.38884372f, -0.05992782f, -0.04434048f, -0.05282075f, -0.09930532f, 
    -0.37611911f, 0.03715409f, -0.19367881f, 0.05204294f, 0.02702062f, 0.11041096f, -0.03433911f, -0.10394300f, 
    -0.02722969f, 0.19617127f, 0.02675784f, 0.08469067f, -0.05108208f, -0.14678690f, -0.11162393f, -0.11731651f, 
    -0.14474083f, -0.08066387f, -0.04546577f, -0.07233057f, -0.18830012f, -0.24243884f, -0.14284648f, -0.08178976f, 
    -0.19921139f, -0.36751172f, -0.00165207f, -0.18022433f, -0.05919654f, -0.18114488f, 0.13441756f, 0.05860480f, 
    -0.10022411f, 0.05217130f, 0.02895701f, -0.00307461f, 0.14278309f, -0.26773474f, -0.03223031f, 0.03376043f, 
    -0.25102952f, 0.04148117f, -0.01292598f, -0.13353074f, -0.00914564f, 0.05614260f, 0.02067749f, -0.03221636f, 
    -0.32692969f, 0.17537892f, -0.06550233f, -0.00188704f, -0.16055590f, 0.09253205f, -0.34338245f, 0.03278933f, 
    -0.03933262f, -0.00820402f, 0.08451696f, -0.11063768f, -0.12126005f, -0.46670550f, -0.08413677f, -0.04928076f, 
    -0.06851069f, -0.07125774f, -0.10365313f, 0.04147596f, 0.05248615f, 0.08824720f, 0.03778365f, -0.05335902f, 
    0.25949013f, -0.01078614f, 0.05599137f, 0.13255313f, -0.09361913f, 0.01299736f, 0.14830862f, -0.02246922f, 
    0.15581985f, -0.01193829f, 0.15819332f, -0.02700403f, -0.06135139f, -0.06758717f, 0.20846008f, 0.05735393f, 
    0.02761330f, 0.00959937f, 0.14898513f, 0.07250139f, 0.02626732f, -0.06244447f, 0.11662127f, -0.10622110f, 
    -0.15611134f, 0.20484555f, -0.03644600f, 0.16842386f, 0.06976855f, -0.01332623f, -0.05777704f, 0.14962271f, 
    -0.07404955f, -0.09753401f, -0.43601862f, -0.32673898f, -0.02974259f, -0.04252324f, 0.01321269f, 0.08742087f, 
    -0.02265240f, -0.08600190f, -0.01627944f, 0.01637550f, -0.08740839f, -0.02446488f, -0.04520648f, -0.09764713f, 
    0.05601775f, 0.28652132f, -0.08347381f, -0.18635061f, -0.05777004f, 0.07657744f, 0.13728720f, -0.08057034f, 
    -0.03892449f, 0.05371248f, 0.02490950f, -0.03705124f, 0.10212819f, 0.04621097f, 0.02715309f, -0.03897502f, 
    -0.06220279f, 0.02553403f, 0.05893306f, 0.04043941f, -0.03574803f, 0.15152812f, 0.12849031f, 0.06661592f, 
    -0.16562448f, 0.14647946f, -0.22112527f, -0.00501770f, 0.02616095f, 0.04249683f, 0.10657648f, -0.07816284f, 
    -0.02281083f, 0.03616367f, 0.03201550f, 0.15186267f, -0.13838407f, -0.02477483f, 0.10958482f, 0.21570809f, 
    -0.07787824f, 0.03858595f, -0.21803147f, 0.06058707f, -0.06266616f, -0.20576704f, -0.06439453f, 0.09310471f, 
    -0.15394327f, 0.27269384f, 0.39658427f, 0.08546156f, 0.06437338f, -0.05127275f, -0.09092548f, 0.07446008f, 
    0.11912003f, 0.14173502f, 0.06292041f, 0.14559759f, -0.07287500f, 0.14915247f, 0.18154554f, 0.07070388f, 
    0.04792446f, -0.08689128f, -0.12577736f, 0.03080634f, 0.00504980f, 0.06429502f, 0.00899257f, -0.02049493f, 
    -0.13257670f, 0.01096927f, 0.05937622f, 0.20618916f, -0.08896483f, 0.09353000f, 0.04593897f, 0.16423261f, 
    -0.00582530f, 0.04486684f, 0.07309704f, 0.17850164f, -0.08734827f, -0.16008253f, -0.15041690f, -0.03302775f, 
    -0.07286278f, 0.05959303f, -0.03708614f, -0.10232341f, -0.09070183f, 0.04342369f, 0.06108639f, 0.07615889f, 
    -0.14202093f, -0.10634255f, 0.11864157f, 0.06076511f, -0.04964919f, -0.10746244f, -0.06379942f, -0.02979977f, 
    -0.00815468f, -0.09527220f, -0.04336995f, 0.00913847f, -0.37962765f, 0.28964505f, -0.07515551f, 0.31607625f, 
    0.03211147f, 0.14540055f, -0.05594195f, 0.01539093f, -0.39294186f, -0.00676394f, -0.10259701f, -0.04365645f, 
    -0.52838796f, 0.07642061f, 0.17365175f, -0.05505448f, -0.03879842f, 0.11344606f, -0.18630536f, 0.07747378f, 
    -0.03153127f, 0.14296973f, -0.03503978f, -0.00460188f, -0.18050900f, -0.04392815f, 0.00816322f, 0.04443190f, 
    -0.05440734f, 0.12079915f, -0.35382199f, 0.19316466f, -0.08929223f, -0.08525795f, 0.08686838f, -0.17163084f, 
    -0.07671265f, 0.09103217f, 0.16313252f, -0.10494640f, -0.17104219f, 0.00398813f, -0.00688537f, 0.10747688f, 
    -0.01687543f, 0.12729847f, -0.09176397f, 0.08778814f, -0.11561853f, 0.03450927f, 0.13840818f, -0.09242263f, 
    -0.09715632f, -0.03661406f, 0.12510209f, 0.13135558f, -0.08921885f, -0.13879725f, 0.12328997f, 0.22444074f, 
    -0.16536729f, -0.23191667f, 0.08412421f, 0.09083606f, -0.06640102f, 0.04988325f, -0.01326324f, 0.11973222f, 
    0.03931569f, 0.05228730f, 0.16365364f, 0.11987413f, 0.41165829f, -0.64133739f, 0.34439582f, 0.10014294f, 
    -0.15094076f, 0.26008585f, 0.04830452f, 0.04628798f, -0.04472513f, -0.01932426f, -0.00785036f, 0.03818443f, 
    0.09323999f, -0.09712067f, -0.22500990f, 0.11133470f, 0.08399256f, -0.15736163f, 0.04575552f, -0.03364655f, 
    -0.13255148f, 0.04788908f, 0.04843465f, -0.09062509f, -0.20128696f, 0.08606775f, -0.11189821f, 0.11417265f, 
    -0.02967726f, 0.00827687f, -0.04912845f, -0.17107278f, -0.07417199f, 0.01478343f, 0.16280898f, -0.26235229f, 
    0.09656934f, 0.10392635f, 0.02917947f, -0.06032180f, -0.01802265f, -0.12480865f, -0.01233994f, 0.11156365f, 
    -0.12878902f, -0.16225711f, -0.44670758f, -0.21770571f, 0.29675010f, 0.06769928f, 0.05645208f, 0.21195042f, 
    0.03183222f, 0.08491886f, -0.10301249f, 0.08802239f, 0.02747753f, 0.10582707f, -0.02203403f, 0.09975703f, 
    -0.31593108f, 0.13642661f, -0.02041157f, 0.00515447f, 0.16130523f, 0.00392223f, -0.28766039f, 0.25012013f, 
    -0.10754372f, -0.06575647f, -0.11373377f, -0.03874163f, 0.28178301f, -0.10931205f, 0.11510590f, -0.00501773f, 
    -0.01383194f, 0.01639792f, 0.01849621f, 0.03154972f, 0.01797163f, -0.02085388f, -0.10061397f, -0.17913789f, 
    -0.00069801f, 0.16141663f, -0.01658078f, 0.22446802f, -0.10155748f, -0.01188680f, -0.05620265f, 0.13151385f, 
    -0.05516113f, -0.03117417f, -0.08143352f, -0.11318095f, 0.44595820f, -0.35248020f, 0.32059047f, -0.09269514f, 
    -0.16450214f, -0.06210141f, 0.14529367f, -0.06450341f, -0.16590051f, -0.08273951f, -0.20103885f, 0.07204442f, 
    -0.10050751f, 0.29791719f, 0.43059668f, 0.04430605f, -0.00187123f, 0.11793048f, 0.15141809f, 0.09989193f, 
    -0.06238097f, 0.10891695f, -0.02072638f, 0.10220458f, 0.04893474f, 0.03118899f, 0.02683575f, -0.10028619f, 
    -0.00330056f, -0.12605998f, -0.18307553f, -0.04113265f, -0.04485161f, -0.16366556f, -0.06025562f, -0.12053572f, 
    0.07368629f, 0.32789281f, 0.11484117f, -0.14066893f, -0.18615192f, 0.01181358f, 0.14789426f, 0.17320307f, 
    -0.01773544f, 0.03552695f, -0.17046376f, -0.04057513f, -0.26849312f, 0.15256691f, -0.21270902f, 0.21166000f, 
    -0.06564211f, 0.03645441f, 0.06934454f, -0.15916403f, -0.05274057f, 0.01010068f, -0.13295007f, 0.12587197f, 
    -0.39140686f, 0.08555567f, 0.05552355f, -0.04476415f, -0.01117870f, 0.28037935f, -0.05982218f, -0.05050365f, 
    0.10645798f, -0.05398064f, -0.05610150f, 0.13326168f, 0.20468649f, -0.04428823f, 0.16504571f, 0.05382506f, 
    -0.11108483f, 0.13551557f, 0.06125116f, 0.08167797f, -0.00584414f, -0.01346254f, -0.02282829f, 0.16355446f, 
    -0.15023248f, 0.32406038f, -0.03964945f, 0.03324584f, 0.03380335f, -0.03977998f, -0.03663493f, 0.03747529f, 
    0.06597251f, -0.11965031f, 0.07316601f, 0.00664712f, -0.09171968f, -0.25903359f, 0.09618245f, -0.11160427f, 
    -0.07826069f, 0.01476350f, 0.07821709f, -0.21769781f, 0.04051174f, 0.04940729f, -0.08396143f, -0.01162663f, 
    0.10914754f, -0.05360261f, 0.20709009f, 0.25329369f, 0.01655644f, 0.01229477f, 0.04643897f, -0.13403954f, 
    -0.03436520f, 0.04851828f, 0.03375699f, -0.05836467f, -0.30239129f, 0.08558260f, -0.10045428f, -0.06762794f, 
    0.07894856f, 0.02762181f, -0.00324618f, 0.13130641f, -0.23449267f, 0.01660307f, 0.15992349f, 0.14084086f, 
    0.04495002f, -0.13463376f, -0.06105385f, 0.02363756f, 0.18623377f, -0.02505627f, -0.07328357f, 0.01306315f, 
    0.06368431f, 0.07466894f, 0.28149307f, 0.10498545f, 0.03387747f, 0.05179041f, 0.01744109f, -0.28310519f, 
    0.02184037f, -0.02978581f, -0.05733689f, 0.12877755f, 0.13449629f, 0.17318299f, 0.12500641f, 0.03539416f, 
    0.13969927f, 0.00627406f, 0.24062155f, -0.07854321f, -0.21451673f, -0.02908806f, -0.00047103f, 0.12446328f, 
    0.00595400f, -0.07179894f, 0.01907176f, 0.02031887f, -0.09161074f, -0.26184866f, -0.31311727f, -0.10703558f, 
    -0.16785946f, -0.06491818f, -0.02552650f, 0.02364636f, -0.00446474f, 0.06733384f, -0.03077183f, -0.00505808f, 
    -0.06777396f, 0.08512843f, -0.23157144f, 0.14505254f, 0.12728181f, 0.07677242f, -0.06488542f, -0.10841858f, 
    -0.05068610f, 0.03778894f, 0.04416754f, 0.01529328f, -0.17940255f, 0.04586615f, -0.17249644f, 0.18309963f, 
    0.06385817f, 0.08572075f, 0.05558457f, 0.07244645f, 0.10942800f, 0.06776731f, 0.05253966f, -0.04028888f, 
    -0.08501011f, -0.13782845f, -0.13479902f, -0.39424723f, -0.01489498f, -0.04328683f, 0.07201546f, -0.07276044f, 
    0.05888618f, 0.13624367f, 0.13718876f, 0.09256899f, -0.57061964f, -0.20298961f, -0.10685793f, -0.04581524f, 
    0.10375139f, 0.01765555f, 0.02435766f, 0.01414219f, -0.16208088f, -0.15494265f, -0.17101382f, -0.11395742f, 
    -0.10060581f, 0.21531430f, -0.16504647f, 0.13342346f, -0.01624132f, -0.00726621f, -0.05705452f, 0.03798839f, 
    -0.02890122f, -0.01585159f, 0.08368309f, 0.04433275f, -0.09209996f, 0.07870702f, -0.46963009f, 0.01202125f, 
    -0.21808040f, -0.10689074f, 0.02109974f, -0.19037394f, 0.05640965f, 0.05952203f, -0.04084528f, -0.04818463f, 
    -0.38541111f, -0.38475654f, 0.05686319f, 0.00005170f, -0.12847374f, -0.20545243f, -0.06521502f, -0.28157094f, 
    0.01424996f, -0.02135720f, 0.00146935f, -0.00607109f, -0.06845943f, -0.36258718f, -0.28615767f, -0.28237545f, 
    0.00491818f, -0.02746594f, 0.02086253f, -0.11901710f, -0.03090006f, 0.11106227f, 0.03825884f, -0.03146109f, 
    -0.00059615f, -0.07489656f, -0.05254381f, -0.16751258f, 0.04697658f, 0.05040924f, -0.01716226f, -0.14037064f, 
    0.05007931f, 0.16323982f, 0.22930638f, -0.04014375f, -0.11451590f, 0.12495861f, -0.10182760f, 0.02297041f, 
    0.10406976f, 0.00589556f, 0.27767918f, 0.06682861f, 0.01841367f, -0.09723753f, -0.08169991f, 0.01657391f, 
    -0.18129006f, 0.02507685f, -0.24971870f, 0.13786501f, 0.02846137f, 0.11253054f, -0.01647240f, 0.02227505f, 
    0.04915712f, 0.02819258f, -0.00793438f, 0.04611906f, 0.26614779f, 0.32912633f, 0.07421548f, -0.05033549f, 
    -0.04747563f, 0.03329580f, -0.09762937f, 0.02165627f, -0.05133288f, -0.01969032f, 0.00957631f, 0.05101708f, 
    -0.71086800f, 0.17111506f, -0.15163445f, 0.37727463f, 0.05197102f, 0.03478225f, 0.12115561f, -0.22055960f, 
    0.03108626f, 0.05365665f, -0.01307488f, -0.05758188f, 0.05767995f, -0.28225544f, 0.30510217f, -0.13433059f, 
    -0.25339666f, -0.15775989f, -0.26102871f, 0.04049389f, 0.09279549f, 0.01220151f, 0.00387102f, 0.09797770f, 
    0.08067100f, 0.00356116f, 0.14539945f, 0.00992102f, -0.02366329f, 0.04108939f, 0.09615924f, -0.01015302f, 
    -0.05791708f, 0.15979923f, 0.00300855f, -0.05123720f, 0.13299465f, 0.10461406f, 0.10461216f, -0.01251689f, 
    -0.06062156f, -0.11126491f, 0.02293824f, 0.13911384f, 0.00513683f, 0.05372929f, -0.03104593f, -0.04180738f, 
    0.02421369f, -0.12963958f, 0.10467040f, -0.03992898f, 0.06313814f, -0.02355673f, -0.10303611f, -0.02552783f, 
    0.02271955f, 0.00697187f, 0.11267050f, 0.01356113f, 0.10880823f, 0.15361390f, -0.00886837f, -0.12456646f, 
    -0.00234590f, 0.08094106f, 0.04799441f, -0.00255657f, -0.02577994f, 0.03216482f, 0.10272806f, -0.09761187f, 
    0.41471091f, 0.07651301f, 0.47560409f, -0.01305777f, 0.10801115f, 0.06306291f, 0.05004800f, -0.05231394f, 
    -0.14550760f, -0.04365991f, 0.03768405f, 0.10627812f, 0.40418780f, -0.02159072f, 0.55336010f, -0.12084793f, 
    0.00161294f, 0.02623305f, -0.08096927f, -0.01097366f, -0.19530351f, 0.02737844f, 0.11172388f, 0.00587967f, 
    0.52846342f, 0.30120656f, 0.19627924f, -0.15915327f, -0.04771719f, -0.08307307f, -0.03230104f, 0.10425755f, 
    -0.06002862f, 0.03113819f, -0.10223363f, -0.09167022f, -0.26783630f, -0.19344528f, 0.03227653f, -0.05763242f, 
    -0.15455694f, -0.13687389f, -0.13711762f, -0.06175909f, 0.02781389f, 0.09900912f, -0.03751488f, -0.13249843f, 
    -0.00516289f, 0.02324947f, 0.07428844f, 0.04563295f, 0.05630371f, 0.04359213f, -0.09392583f, 0.07735936f, 
    -0.10689040f, -0.01458515f, -0.09375913f, 0.01222417f, -0.21107756f, 0.33746734f, -0.03356414f, -0.01713060f, 
    0.02955940f, -0.15945156f, -0.07110838f, -0.03306981f, 0.05832824f, 0.00777251f, -0.06629974f, 0.02188510f, 
    -0.48274302f, 0.04919650f, -0.41218635f, 0.04906885f, -0.10959269f, -0.06047992f, 0.08597276f, 0.01557197f, 
    -0.08832784f, 0.14631684f, 0.11339172f, 0.08402863f, -0.03027369f, 0.12915526f, 0.11811867f, 0.01626956f, 
    -0.06436004f, 0.00116833f, 0.07860996f, -0.04222262f, -0.01459861f, 0.03250566f, -0.09146554f, -0.01512849f, 
    -0.28164154f, -0.31476367f, 0.12126548f, 0.15038434f, 0.07809063f, 0.01875232f, -0.02165927f, -0.02398086f, 
    -0.03095008f, -0.11932214f, 0.13329495f, -0.09952816f, -0.14003952f, -0.07700574f, -0.04643736f, -0.01695360f, 
    0.05814552f, -0.05277092f, -0.06157738f, 0.08097608f, -0.02337868f, 0.03725292f, -0.18071072f, -0.15771246f, 
    -0.50646091f, 0.08554044f, -0.53521991f, 0.29054308f, 0.15245193f, -0.18691583f, 0.13054672f, -0.18039064f, 
    -0.02343629f, -0.11106425f, 0.01388938f, -0.08032682f, 0.18370938f, 0.15712547f, -0.02162407f, -0.01904457f, 
    -0.08489618f, 0.03151308f, -0.04860817f, 0.14558558f, -0.09195694f, 0.06276692f, 0.08119897f, -0.08541039f, 
    -0.30648303f, 0.13186690f, -0.01262398f, 0.13239734f, -0.01430779f, 0.18444210f, -0.07559463f, 0.06398425f, 
    -0.26589707f, -0.00547365f, 0.00708914f, 0.01615215f, -0.31346634f, -0.07149915f, -0.09078508f, 0.19428293f, 
    0.09010743f, 0.05387523f, -0.04275154f, 0.02903181f, -0.10421441f, 0.07586649f, -0.13355190f, 0.05374878f, 
    0.42161372f, -0.30616239f, 0.62072402f, -0.04073671f, 0.06918643f, -0.05261205f, 0.09661209f, 0.18193963f, 
    -0.08115699f, -0.00784765f, 0.04340998f, -0.15484332f, 0.05483279f, 0.01855340f, 0.03867758f, 0.10704585f, 
    -0.04944255f, 0.08623653f, 0.06745140f, 0.08296784f, -0.08228615f, 0.04534876f, 0.03277076f, -0.08150084f, 
    -0.18231750f, 0.12537690f, -0.12096941f, 0.01863817f, -0.05071867f, 0.03414479f, 0.06008451f, -0.06710219f, 
    0.02585006f, -0.04908602f, -0.00452266f, -0.08205444f, -0.48695758f, 0.11326998f, -0.12370453f, 0.38682842f, 
    -0.08348068f, -0.00375797f, 0.20496827f, 0.13090323f, -0.07089800f, -0.06303648f, 0.06340794f, 0.23688973f, 
    -0.28470537f, -0.00968878f, 0.23494755f, 0.00177320f, 0.08024599f, 0.09602823f, -0.13475564f, -0.00453239f, 
    -0.04598242f, 0.03748494f, -0.02723042f, -0.05761369f, -0.34387422f, 0.23237056f, -0.26649466f, 0.09980329f, 
    0.07871605f, -0.00333107f, 0.11256930f, -0.08793687f, 0.09703509f, 0.20635812f, 0.14649969f, 0.01018302f, 
    0.24018891f, -0.16820250f, 0.34814921f, 0.06126095f, 0.08825210f, 0.05452162f, 0.04457210f, 0.01240936f, 
    -0.09280623f, -0.04062283f, 0.01572168f, 0.05897025f, 0.02140541f, -0.05422268f, -0.08595031f, 0.22300397f, 
    -0.02216002f, 0.16150112f, 0.04138238f, 0.12170239f, -0.33547199f, -0.01741326f, 0.15925354f, -0.20644352f, 
    0.01335843f, -0.14320831f, -0.01971976f, -0.23506208f, -0.06186412f, -0.09131628f, -0.13154888f, -0.18351321f, 
    0.04714777f, -0.00062803f, -0.13765699f, -0.14316365f, -0.22694816f, -0.12019823f, 0.12754185f, -0.42957312f, 
    0.01671850f, 0.07861482f, 0.02959943f, -0.02884084f, 0.02917626f, -0.05603508f, 0.14778970f, 0.04266015f, 
    -0.31062624f, 0.27318931f, -0.11119955f, 0.13081977f, -0.25970322f, -0.00961101f, 0.14623351f, 0.01624122f, 
    -0.08097383f, 0.01250255f, 0.02649117f, 0.08375538f, -0.13406111f, -0.11555856f, -0.02165040f, 0.05372598f, 
    0.15628448f, 0.15566471f, 0.12947135f, -0.02665051f, -0.17025356f, -0.08250457f, 0.00915615f, 0.05589795f, 
    0.17623883f, -0.04251365f, 0.13237303f, -0.22052784f, 0.02618159f, 0.01265029f, 0.13747486f, 0.04768575f, 
    0.06548427f, 0.08881410f, 0.13783737f, 0.00186947f, -0.48275250f, 0.07768406f, -0.09532645f, 0.08733302f, 
    -0.01301651f, -0.02152481f, 0.15905802f, -0.00873308f, -0.18309747f, -0.04676453f, -0.19935322f, 0.03652972f, 
    0.03524895f, -0.27736998f, 0.09743287f, 0.22374088f, 0.00860273f, 0.02736828f, -0.06128092f, 0.22270845f, 
    -0.03220444f, 0.03647369f, -0.06326178f, 0.14445740f, -0.40756765f, 0.29096919f, -0.15718640f, 0.07831191f, 
    -0.07219738f, 0.09166662f, 0.10520916f, -0.10570002f, 0.03636191f, -0.00932753f, 0.18098739f, 0.17533602f, 
    -0.31756002f, -0.31734768f, 0.27321640f, 0.02496451f, -0.07329191f, 0.18733816f, 0.02466769f, 0.13538516f, 
    -0.05481875f, 0.05470021f, -0.10300907f, -0.06472188f, -0.19313772f, 0.01774186f, 0.08367068f, -0.43443283f, 
    0.11629254f, 0.07805923f, 0.17108375f, -0.09541310f, -0.05924920f, 0.11593317f, 0.12464163f, 0.01039116f, 
    -0.00894425f, -0.13092346f, -0.14266275f, 0.13718489f, 0.11205557f, 0.07207991f, 0.05687042f, -0.15496999f, 
    0.10887562f, 0.13435219f, 0.07335974f, -0.15148358f, 0.02766912f, -0.07271358f, 0.04992118f, 0.03320351f, 
    -0.00083967f, -0.02453471f, 0.03002906f, 0.13198954f, -0.05691475f, 0.07210772f, 0.08713172f, -0.01590841f, 
    0.25259510f, -0.22736920f, 0.19268854f, -0.03045819f, -0.04113322f, -0.22433966f, -0.08469883f, 0.06646156f, 
    -0.07669999f, 0.10790046f, 0.22364715f, -0.12485050f, -0.48387995f, 0.09039341f, -0.09716899f, 0.16536030f, 
    0.08617526f, 0.17531671f, -0.07927506f, 0.08083504f, -0.01611188f, -0.24208567f, -0.00359964f, -0.06348732f, 
    0.09818596f, 0.01476960f, -0.18493867f, 0.22987789f, 0.04920099f, 0.09853879f, 0.05516816f, -0.04966466f, 
    -0.05737060f, 0.18993697f, -0.11055195f, 0.04672753f, 0.28918126f, 0.01108486f, 0.01110156f, -0.12084550f, 
    0.14754103f, 0.01099014f, -0.02862484f, 0.05552026f, -0.19946834f, -0.11379234f, -0.04117791f, -0.07044341f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15253486f, 0.09442804f, 0.07024824f, -0.08261526f, -0.11756770f, 0.09000527f, -0.00971511f, -0.08372527f, 
    0.08204705f, 0.03790484f, 0.01971787f, -0.02072230f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
