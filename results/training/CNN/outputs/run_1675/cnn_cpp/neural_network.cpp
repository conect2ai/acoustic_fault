#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.81736994f, 0.59836459f, 0.27205670f, -0.26078874f, 0.04291115f, -0.02566832f, 0.47945029f, -0.16788304f, 
    -0.50771511f, -0.55260837f, 0.04063772f, 0.17630224f, 0.15862353f, 0.19819646f, -0.03277098f, -0.16374607f, 
    -0.16871114f, -0.14315324f, -0.00652546f, -0.01569430f, 0.28835037f, 0.10364809f, -0.04985973f, -0.16083439f, 
    -0.26725218f, -1.05880487f, -0.75434029f, -0.13577142f, -0.25316566f, 0.13814892f, 0.18714854f, -0.46327844f, 
    -0.95500666f, -1.05943525f, -0.59909475f, -0.21424057f, -0.29945907f, -0.36893633f, -0.40308958f, -0.63663089f, 
    -0.34960938f, -0.47974804f, -0.32118213f, 0.11012400f, -0.15567440f, -0.11616100f, -0.00159540f, -0.02310157f, 
    -0.06324741f, -0.12671012f, 0.28993002f, 0.76121247f, -0.05064820f, -0.32510939f, -0.59532326f, -0.28827623f, 
    -0.21018793f, -0.01356945f, 0.46299833f, 0.11762931f, -0.02410973f, 0.21613088f, 0.11400104f, -0.25805655f, 
    0.12049087f, 0.26125187f, 0.35273713f, -0.11652412f, -0.36701614f, -0.35181090f, 0.03404920f, 0.46990860f, 
    0.04447303f, -0.37726933f, -0.12917194f, 0.07976978f, -0.19238202f, 0.34310302f, -0.01091504f, 0.07587041f, 
    0.48673055f, 0.31293529f, -0.05613034f, 0.37164456f, 0.29487091f, 0.08349282f, -0.16673841f, 0.23187967f, 
    0.15791030f, -0.20916110f, -0.13245927f, -0.26852342f, -0.28931803f, 0.20513833f, -0.28496924f, 0.18135577f, 
    0.35111997f, 0.26007941f, -0.26851800f, -0.38036042f, -0.28412306f, -0.52999943f, -0.64521688f, -0.53118473f, 
    -0.75147986f, -0.65615004f, -1.02773798f, -0.57924831f, -0.63847911f, -0.87845433f, 0.34977445f, 0.37338588f, 
    0.36486328f, 0.35140151f, 0.13940717f, 0.20280264f, 0.14515166f, -0.05869164f, -0.05792754f, -0.29003760f, 
    -0.18098868f, 0.09815466f, 0.31274489f, -0.15491223f, -0.20569819f, 0.03848106f, 0.92329466f, 0.77003342f, 
    -0.16294223f, -0.02677771f, -0.32671914f, 0.02356760f, 0.00091132f, -0.14196469f, -0.18953092f, 0.08469342f, 
    0.01148399f, 0.10398071f, -0.43528450f, -0.36733979f, -0.14393401f, 0.21254243f, -0.12021525f, 0.06800170f, 
    -0.12283588f, -0.15295501f, 0.39107001f, 0.17539619f, -0.18621363f, -0.32622069f, -0.28840479f, 0.73818833f, 
    0.34189904f, -0.21249111f, -0.08630026f, 0.10744713f, -0.11185556f, -0.64898092f, -0.97356331f, -0.59893489f, 
    0.74674839f, -0.43857455f, -0.27421895f, -0.13474597f, -0.08749861f, -0.19349906f, -0.26896831f, -0.25042343f, 
    0.05694466f, -0.25818533f, 0.25006428f, -0.35108572f, -0.29874328f, -0.43933362f, -0.27079880f, 0.96731156f, 
    0.59139371f, -0.28396788f, -0.51083821f, 0.01440268f, -0.55184883f, 0.33817607f, -0.70630568f, -1.03562808f, 
    -0.98262894f, -0.24333239f, 0.41717181f, -0.18632165f, -0.39605078f, 0.00327186f, 0.06386460f, 0.11741225f, 
    0.27384573f, 0.35947382f, -0.23123859f, -0.20982812f, 0.08632111f, 0.29109672f, 0.06609141f, -0.02304660f, 
    0.96517467f, -0.65330130f, -0.84818560f, -0.70269346f, -0.34727824f, -0.13711688f, -0.29171482f, -0.11813901f, 
    0.12128255f, -0.02190473f, 0.42796543f, 0.45588133f, 0.32754859f, -0.24553846f, 0.17404515f, 0.17081772f, 
    0.00859446f, 0.07809117f, -0.02936206f, -0.01076331f, 0.08770695f, -0.54702073f, -0.13726276f, 0.28849384f, 
    -0.35176983f, 0.64322364f, 1.09291184f, 0.14052898f, -0.62496322f, -0.68922961f, -0.57561553f, -0.39168105f, 
    -0.01955862f, -0.15611513f, -0.05948137f, -0.03683352f, 0.06781896f, 0.29873413f, 0.60752720f, 0.09130774f, 
    -0.19786318f, 0.25970322f, -0.33381563f, -0.33696365f, 0.01306553f, 0.02925640f, -0.18088289f, -0.14741206f, 
    -0.15038399f, 0.19915618f, -0.39739645f, -0.07099579f, -0.77317512f, -0.30964017f, -0.74863178f, -0.31857571f, 
    -0.04359629f, -0.34664276f, -0.46656290f, 0.65314806f, -0.21768764f, -0.04316191f, -0.54507756f, -0.49346814f, 
    0.44088501f, 0.27425617f, 0.39816731f, 0.07333972f, 0.11869798f, -0.34892979f, -0.20743327f, -0.23053424f, 
    -0.37617287f, -0.29064202f, 0.05009717f, 0.06921601f, -0.67502451f, -0.51158971f, -0.13806997f, 0.04154982f, 
    0.48513207f, 0.39885390f, -0.19519983f, 0.41210586f, -0.05067559f, 0.09475535f, 0.18864863f, -0.00362761f, 
    -0.51491582f, -0.41133875f, -0.29997745f, 0.08629023f, 0.07750697f, 0.04252765f, 0.12424470f, 0.07012734f, 
    0.14226255f, 0.14050581f, 0.46335536f, 0.15766050f, -1.12723696f, -0.65653849f, -0.32361236f, -0.87904340f, 
    -0.91235572f, 0.84428263f, 0.44803351f, 0.22458556f, 0.36030832f, 0.40537140f, 0.29857001f, 0.04889181f, 
    -0.08432052f, 0.13194731f, -0.10171218f, -0.12292200f, 0.08609249f, -0.19828366f, -0.00729498f, -0.08571085f, 
    -0.18006690f, -0.27594724f, 0.15862304f, -0.03806627f, -0.32374382f, 0.28104869f, 0.21753789f, 0.24496301f, 
    -0.08044367f, 0.19487798f, 0.32649627f, 0.38189173f, 0.10514898f, 0.06562305f, 0.09502671f, 0.15589689f, 
    0.23675621f, -0.05656676f, 0.02475299f, 0.30403468f, 0.03561215f, -0.00482966f, 0.25845939f, 0.18429478f, 
    -0.12136278f, 0.08020396f, -0.20384611f, -0.08227409f, 0.11512700f, -0.15956435f, -0.72712445f, -1.00896132f, 
    -0.92337531f, -0.17202593f, 0.74543506f, 0.12736554f, 0.22261295f, -0.15430576f, -0.10476297f, -0.37677953f, 
    0.43546191f, 0.22415017f, 0.63139212f, -0.04082495f, 0.46912360f, -0.14125541f, -0.48658040f, -0.37906715f, 
    -0.09742445f, -0.19150127f, 0.24077736f, -0.02444501f, 0.22022445f, 0.17238931f, 0.12825604f, -0.27158493f, 
    0.59250891f, 0.16487156f, -1.02382565f, -0.63114715f, 0.30026627f, 0.59321737f, 0.07149957f, -0.30256763f, 
    -0.59623140f, -0.07565221f, -0.17990164f, -0.08170634f, -0.26725841f, 0.36792386f, -0.48538697f, -0.46327010f, 
    -0.39997432f, -0.39354905f, -0.37968609f, 0.08883982f, -0.34616923f, 0.20118110f, -0.38610148f, -0.36727270f, 
    0.58305448f, -0.77920395f, -1.29689670f, -1.27948034f, -1.01100898f, 0.29144230f, 0.30817831f, 0.61026949f, 
    0.19261530f, -0.19331051f, 0.06540238f, 0.21560188f, -0.16139001f, -0.50096583f, 0.19482985f, -0.26047748f, 
    -0.04626587f, -0.17807701f, -0.16112766f, -0.25651470f, -0.25785106f, 0.15534294f, -0.29861110f, 0.34559894f, 
    0.30505258f, 0.33122560f, 0.88468868f, -0.44887117f, -0.57363296f, -0.57729065f, 0.00413238f, -0.08824178f, 
    0.40001690f, -0.01249038f, 0.18519740f, -0.24049312f, -0.33860996f, 0.61249959f, -0.18209268f, -0.22124435f, 
    0.03018536f, 0.13407744f, 0.04750925f, -0.34877422f, -0.15216805f, -0.29725420f, -0.30142048f, -0.53479099f, 
    -0.17490250f, -0.13826390f, -0.76220912f, -0.09726547f, -0.44717097f, -0.09914022f, -0.11945889f, 0.50444877f, 
    -0.22179957f, -0.10949691f, 0.22741309f, 0.67452675f, 0.11264446f, 0.29511175f, -0.20042260f, -0.01474569f, 
    -0.29187906f, -0.45579588f, -0.45960420f, 0.06549103f, 0.22833209f, 0.32652748f, 0.07604278f, 0.08273572f, 
    0.08156171f, 0.09731771f, 0.09573427f, 0.96199697f, -1.24326527f, 0.05435763f, 0.54910403f, 0.45721316f, 
    -0.22602579f, -0.47115219f, 0.22803047f, -0.16033293f, 0.02051778f, 0.01447066f, -0.15618254f, 0.03457134f, 
    -0.41617709f, 0.29340413f, -0.14142475f, 0.00344385f, 0.06160107f, 0.04167390f, -0.02472264f, -0.17095320f, 
    -0.02131926f, -0.18616468f, 0.06882065f, 0.24967340f, -0.70642042f, -0.11913401f, 0.01688967f, -0.21145207f, 
    0.34867060f, 0.71198440f, -0.48877564f, -0.39367673f, -0.15644783f, 0.51790059f, -0.21459331f, 0.09315518f, 
    -0.22651987f, 0.19800979f, -0.49513164f, -0.20610401f, -0.20445135f, -0.05515214f, -0.35033187f, -0.74831867f, 
    -0.30118522f, 0.18115567f, -0.27282777f, -0.01375595f, -0.01237485f, -0.09535491f, -0.47853360f, 0.21331775f, 
    0.00392876f, 0.36675039f, -0.04732310f, -0.28694212f, -0.32514611f, 0.23144911f, 0.23986271f, -0.31561607f, 
    0.28098887f, -0.39821669f, 0.14445823f, -0.01921734f, 0.25864315f, 0.12558025f, -0.64277577f, -0.15838788f, 
    0.15363646f, -0.50159699f, 0.31311789f, 0.00791198f, -0.17430627f, 0.23635581f, 0.51496983f, -0.90979278f, 
    0.21715255f, 0.02954552f, 0.17089385f, 0.02723825f, -0.28917846f, -0.17016190f, 0.10339435f, -0.13092247f, 
    -0.55373925f, -0.41268322f, 0.01730453f, 0.19544765f, 0.22158192f, -0.15917858f, -0.00258086f, -0.23535897f, 
    0.04955385f, -0.21963079f, -0.51447195f, -0.47149071f, -0.37441733f, -0.69681770f, -0.91186213f, 0.44220784f, 
    0.58100212f, 0.63248318f, 0.01898677f, 0.11323551f, -0.23497853f, -0.46752423f, 0.54957259f, -0.44517326f, 
    -0.45729497f, -0.25277773f, -0.14200404f, -0.21962184f, -0.25062403f, 0.14816211f, -0.03734464f, 0.06050182f, 
    -0.04919875f, 0.00454149f, 0.14522995f, -0.27259782f, -0.01107698f, -0.42916259f, 0.01743273f, -0.00627780f, 
    0.80796784f, -0.42517522f, -0.66371119f, -0.40567118f, -0.22137330f, 0.07869751f, 0.23851864f, 0.20928441f, 
    0.02076759f, 0.02172624f, -0.17633614f, 0.00976644f, -0.07415082f, -0.30364513f, 0.20640263f, -0.55455691f, 
    -0.15264821f, 0.15259157f, 0.06226896f, -0.18575896f, 0.33821920f, 0.33009556f, -0.05948948f, 0.19456390f, 
    0.35876098f, -1.56858873f, 0.04387725f, 0.73638523f, -0.46589366f, 0.00044493f, -0.14656267f, 0.45510444f, 
    0.52275574f, 0.26529109f, 0.39278138f, -0.22562847f, -0.46617642f, -0.22819021f, -0.37576550f, -0.26469553f, 
    0.34882078f, 0.19984958f, -0.26789579f, 0.06168405f, 0.15390994f, -0.12917840f, -0.19991124f, -0.10754063f, 
    -0.31807336f, -0.34646785f, -0.55209541f, -0.79801470f, 0.22441354f, 0.57768482f, 0.23998356f, 0.70585018f, 
    0.82614672f, -0.31943056f, -0.56962723f, 0.18637614f, -0.24734312f, 0.06018021f, -0.09107831f, -0.11539659f, 
    -0.25006238f, -0.28906721f, -0.14513285f, -0.31621835f, 0.08984062f, 0.44086090f, 0.10575643f, -0.33062392f, 
    0.12603053f, 0.27579296f, -0.32892874f, 0.13491143f, -0.16579461f, 0.34819868f, 0.48137692f, -0.52775002f, 
    -0.33926800f, -0.70759857f, -0.27573809f, 0.27428764f, 0.25513414f, 0.29571530f, -0.11984316f, -0.20113041f, 
    0.21884470f, -0.34837165f, -0.39089987f, 0.04822102f, 0.41305327f, 0.24277368f, -0.08131511f, -0.26336035f, 
    -0.55856007f, -0.23884499f, 0.15902090f, 0.16756459f, -0.72318155f, -0.35985443f, -0.61153275f, -0.92009896f, 
    -0.66827124f, -0.14639969f, -0.03483461f, -0.07677002f, 0.63526446f, -0.02646598f, -0.18718554f, -0.31231597f, 
    -0.04319825f, -0.24444833f, -0.24624927f, 0.28914380f, -0.20744832f, -0.04851435f, 0.20898522f, -0.03828557f, 
    0.18701991f, -0.01038129f, -0.15727372f, -0.19760373f, -0.20012079f, -0.56232077f, 0.12839356f, -0.30388305f, 
    0.34652889f, 0.39756075f, 0.12357861f, -0.22786354f, -0.02788163f, -0.07413791f, 0.35053965f, 0.11662920f, 
    -0.09681235f, -0.28783730f, 0.27562135f, 0.08538368f, 0.15724210f, -0.43371859f, 0.04033905f, -0.07783914f, 
    -0.54602110f, 0.06430982f, 0.25243944f, 0.16107646f, 0.23282869f, 0.19581287f, -1.15264881f, -0.94701624f, 
    -0.73948842f, 0.11806569f, 0.01388479f, -0.45710030f, -0.08719034f, -0.13247356f, -0.60842454f, -0.74403095f, 
    0.38010576f, -0.54711449f, -0.22271244f, 0.28473243f, 0.15258403f, -0.13316098f, 0.27655417f, -0.08323241f, 
    0.20078160f, 0.13087341f, -0.00172927f, -0.31497481f, 0.49518535f, 0.22507097f, -0.15670995f, -0.48283985f, 
    0.07118839f, 0.10502952f, 0.23112179f, 0.15615709f, -0.63328171f, -0.68623328f, 0.61438948f, 0.25691840f, 
    0.43821818f, -0.40727875f, -0.07965075f, 0.20066865f, 0.57913393f, -0.51071405f, -0.24163111f, 0.25213224f, 
    0.12583484f, -0.08684934f, 0.00076890f, -0.11760250f, 0.03950638f, -0.07985667f, -0.14991494f, 0.33108041f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02665100f, -0.30366337f, 0.44938475f, 0.47538361f, -0.30185470f, 0.24869525f, -0.31258267f, 0.26648754f, 
    0.53592575f, 0.15515177f, -0.23505911f, 0.00714226f, 0.08079550f, -0.01158249f, 0.45576912f, 0.02563444f, 
    0.40589035f, 0.13394412f, 0.29064968f, 0.35588536f, 0.05154788f, 0.28104624f, 0.04710146f, 0.07972837f, 
    0.07589473f, -0.00951411f, 0.46830532f, 0.33420083f, 0.05692486f, 0.42980498f, 0.01316842f, 0.51090568f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09766835f, -0.25843766f, -0.60381061f, 0.07924641f, 0.03152604f, 0.06386017f, -0.05205084f, 0.05220085f, 
    -0.02798752f, 0.09452369f, 0.04064146f, -0.03495906f, 0.57382566f, 0.31463411f, -0.24856038f, -0.24462339f, 
    0.10013234f, 0.16772249f, 0.15173836f, 0.17625704f, -0.06894561f, -0.07878072f, -0.13060258f, -0.07524886f, 
    -0.15013216f, -0.68969119f, -0.10668520f, -0.03641389f, -0.19010872f, -0.09143445f, -0.24754700f, -0.05081452f, 
    -0.13442548f, -0.21569639f, -0.10027163f, -0.24808992f, -0.38981855f, -0.44588447f, -0.22575325f, 0.04372692f, 
    -0.00998847f, -0.07334966f, 0.06296550f, 0.01335617f, -0.14743182f, 0.04336362f, -0.08794481f, 0.01740803f, 
    0.51365167f, 0.18200514f, -0.04585315f, -0.21448991f, 0.05793549f, 0.21393363f, -0.04756542f, 0.08916143f, 
    0.02303604f, 0.06608085f, 0.03223355f, 0.06213862f, -0.65164655f, -0.33791414f, -0.12778547f, 0.08303856f, 
    -0.00503465f, -0.08217356f, 0.06638048f, 0.06488086f, 0.00637878f, 0.02134494f, 0.02357754f, 0.01363039f, 
    0.10291418f, 0.18334503f, -0.34865287f, 0.06988310f, -0.25565156f, -0.10578296f, -0.07335095f, -0.00429053f, 
    -0.02343703f, -0.01236453f, 0.09452230f, 0.02983435f, 0.13860548f, -0.01962300f, -0.44140509f, -0.07087204f, 
    0.06944133f, -0.20420808f, -0.01295073f, -0.06809800f, -0.01493884f, 0.08721414f, -0.00160041f, -0.02526858f, 
    0.28474650f, 0.07796583f, -0.23047434f, -0.00276981f, 0.09040973f, 0.05663956f, -0.29526365f, -0.13134654f, 
    -0.08137972f, -0.03292858f, 0.01807012f, 0.08693113f, 0.17049517f, -0.28446257f, -0.04954003f, -0.04818994f, 
    -0.12718619f, -0.00708403f, -0.34905744f, 0.00410055f, -0.08082425f, 0.04071242f, 0.11213573f, -0.23692988f, 
    0.26304781f, 0.31056029f, 0.03439035f, -0.03954854f, 0.15086007f, 0.17706014f, 0.00378513f, 0.13850330f, 
    -0.06975615f, 0.01639444f, 0.11239088f, 0.00588503f, 0.10592636f, 0.06543079f, -0.24294798f, 0.01975656f, 
    0.04455778f, 0.04659640f, 0.03626213f, -0.06246984f, 0.06911944f, 0.01370972f, -0.00393790f, -0.10790887f, 
    0.10494062f, -0.06688943f, -0.08763261f, -0.03506499f, 0.18075755f, 0.26185188f, 0.04653790f, -0.00773687f, 
    -0.00188218f, 0.07104442f, -0.05191108f, 0.08549977f, -0.00035096f, 0.03345107f, 0.06678972f, 0.10898861f, 
    -0.02805033f, 0.04309628f, 0.04379394f, 0.08697180f, -0.40469632f, -0.34211302f, -0.13702774f, -0.11374615f, 
    0.24459058f, 0.30012047f, -0.26664379f, -0.12421080f, 0.09999894f, 0.03206804f, 0.08833414f, -0.19511658f, 
    -0.04490793f, -0.21511306f, -0.07887261f, -0.07366609f, 0.03852969f, -0.29118231f, -0.28002930f, -0.05936923f, 
    0.03981943f, 0.04267518f, -0.25298551f, -0.00301888f, -0.12255690f, -0.17255603f, -0.09432648f, 0.07704917f, 
    0.21768256f, -0.05798176f, -0.29746294f, -0.04174553f, 0.11839417f, -0.04824265f, -0.20413779f, -0.17891060f, 
    -0.07365878f, -0.18593037f, -0.00669096f, 0.01154742f, -0.64867342f, -0.62155658f, 0.04805053f, 0.11255482f, 
    -0.00324019f, 0.07030875f, -0.21159500f, 0.04495808f, -0.11574072f, -0.15416209f, -0.09787153f, 0.11195605f, 
    0.03537310f, 0.00812589f, 0.00851913f, -0.04885514f, -0.05457550f, 0.03833408f, -0.00163023f, 0.06750610f, 
    -0.04119100f, 0.02618627f, -0.05049129f, -0.11455901f, -0.37883455f, -0.40888262f, 0.20443708f, -0.16572808f, 
    -0.12293546f, 0.04600994f, 0.08231310f, -0.03108791f, -0.03320427f, 0.05786423f, 0.06150299f, -0.04256045f, 
    0.02717829f, 0.09655092f, 0.05603974f, -0.22340213f, -0.08978849f, 0.04223040f, 0.07527249f, -0.08159530f, 
    -0.05704010f, 0.12535481f, 0.10833696f, -0.03677035f, -0.11349481f, 0.23205477f, 0.04428485f, -0.27086031f, 
    -0.27599376f, -0.05623430f, 0.12300161f, -0.15411900f, -0.07161126f, 0.02696169f, -0.29025137f, -0.25820929f, 
    0.04474526f, -0.08887089f, 0.05521711f, -0.15106744f, -0.01737103f, -0.07326492f, -0.06159265f, -0.03053139f, 
    0.01152731f, 0.03917874f, -0.00315459f, 0.23531140f, -0.48798236f, -0.07920624f, 0.06582792f, 0.02334202f, 
    0.03408467f, -0.01176300f, -0.04212194f, 0.03335186f, 0.01075367f, 0.10110066f, 0.06837547f, -0.02562942f, 
    0.03548076f, -0.03269822f, -0.28568852f, 0.17961708f, 0.04509275f, 0.10953417f, -0.29941082f, -0.10100031f, 
    -0.07706311f, -0.22830065f, -0.18331988f, -0.02367796f, 0.08121517f, 0.11527193f, 0.09753209f, -0.17487042f, 
    0.01913789f, 0.13836622f, 0.07000899f, 0.11326635f, 0.05459311f, 0.04852797f, 0.17104557f, 0.07454126f, 
    0.78474510f, -0.16039293f, -0.18386324f, -0.31091544f, 0.03198776f, -0.07263830f, 0.14881684f, -0.15265699f, 
    0.00349775f, -0.14957972f, 0.08801156f, -0.00002783f, 0.01841342f, 0.21067682f, 0.04634394f, -0.44498599f, 
    0.01664052f, -0.03918011f, -0.01155351f, 0.03167849f, 0.05943209f, -0.14531989f, -0.04895130f, 0.11242995f, 
    0.18405011f, 0.13809957f, -0.01426351f, -0.08753806f, 0.15049553f, 0.32905465f, 0.11374809f, 0.07663853f, 
    0.01445603f, -0.02151203f, 0.04909173f, -0.01829191f, -0.16456418f, 0.12911417f, 0.09659714f, -0.04731327f, 
    -0.00711758f, -0.08192550f, 0.10871155f, -0.03549744f, -0.08240866f, -0.06741861f, -0.17923129f, -0.12203898f, 
    0.52768850f, 0.00988746f, -0.12100094f, -0.38097683f, 0.13713738f, 0.13493927f, 0.02773800f, 0.02832482f, 
    -0.03507019f, 0.05835785f, -0.00885814f, -0.02821231f, -0.61936313f, -0.01477030f, 0.23463804f, -0.19780420f, 
    -0.03519300f, -0.02535531f, -0.04705493f, 0.06215828f, -0.06765456f, -0.37657276f, -0.14260484f, -0.09967776f, 
    0.31172010f, 0.14307372f, 0.06626893f, 0.10709566f, -0.03331545f, -0.16512015f, -0.16236819f, 0.03759040f, 
    -0.05193457f, -0.09168958f, 0.02821781f, 0.09458788f, 0.15374197f, 0.04553576f, 0.18664356f, 0.35097924f, 
    0.13943964f, 0.05253727f, 0.17170539f, 0.13188161f, 0.04780871f, 0.10901520f, -0.06418028f, 0.01524182f, 
    -0.06128255f, -0.20462769f, 0.33224437f, -0.25248888f, 0.06472999f, 0.03576038f, -0.04332684f, 0.18622491f, 
    -0.02641944f, 0.05003493f, -0.27209291f, 0.10888250f, 0.32578671f, 0.19399524f, 0.12210240f, 0.17731079f, 
    -0.10540477f, -0.02526887f, -0.04049584f, 0.06536561f, -0.14346489f, 0.03631053f, -0.03176236f, -0.02369729f, 
    -0.27109337f, 0.06861559f, 0.19895206f, 0.17848560f, -0.19797006f, 0.07040443f, -0.09717535f, 0.14955510f, 
    -0.04773692f, -0.06992065f, 0.02823044f, 0.04335049f, 0.54700625f, 0.05560383f, 0.33771715f, 0.08944295f, 
    0.04429825f, -0.15445143f, -0.04008175f, 0.03081199f, -0.06059976f, 0.05702443f, -0.06495351f, 0.02397054f, 
    -0.01634277f, -0.75805259f, -0.28177574f, -0.74555701f, 0.08852227f, -0.12198436f, 0.01447042f, 0.31026149f, 
    0.00234387f, -0.07339934f, -0.01733262f, -0.08993919f, 0.46548545f, -0.25954458f, -0.40705660f, -0.42449117f, 
    -0.37790257f, -0.05754565f, -0.05134223f, -0.03054466f, -0.13116646f, 0.03313318f, 0.02793621f, 0.03713649f, 
    0.07144305f, -0.27007940f, -0.04966810f, 0.00159956f, 0.00704110f, 0.12192079f, 0.10935397f, -0.13710906f, 
    0.28537694f, -0.05276879f, -0.02222242f, 0.05639149f, 0.01437822f, -0.44180381f, -0.08881248f, -0.23068632f, 
    -0.05862547f, 0.08336303f, 0.10702061f, 0.07105900f, -0.00563319f, 0.02776403f, 0.06224798f, 0.19946319f, 
    0.04955450f, 0.02480086f, 0.28947163f, -0.02536704f, 0.04886580f, 0.13236949f, -0.44451910f, -0.49295241f, 
    0.03883258f, 0.02249573f, -0.10815528f, -0.05818823f, 0.10370064f, -0.01358945f, -0.22486696f, -0.01330019f, 
    0.23301739f, -0.09610245f, -0.00328924f, -0.01699085f, -0.06809624f, -0.00532102f, -0.20791784f, -0.08330061f, 
    0.22644319f, 0.06108782f, -0.13929984f, -0.21788375f, -0.06946392f, -0.00298166f, -0.02927347f, -0.01290069f, 
    -0.03051831f, 0.06487169f, 0.11173388f, -0.00144306f, 0.09555740f, 0.05916159f, 0.11525445f, 0.11155499f, 
    0.00858331f, -0.03719215f, 0.00098103f, -0.06875206f, 0.11104415f, -0.07689446f, 0.01980024f, -0.14606372f, 
    -0.59352660f, -0.53230309f, -0.16275775f, 0.17621125f, -0.10937432f, 0.09830243f, 0.10798740f, 0.09169142f, 
    -0.02802693f, 0.07639568f, 0.10593956f, 0.10444397f, -0.14405495f, -0.61721933f, 0.56194592f, -0.26490894f, 
    0.02994513f, 0.03705656f, -0.05435811f, 0.09933943f, -0.02342974f, -0.31096920f, -0.18462022f, -0.26565778f, 
    0.29165378f, 0.17155315f, -0.23353665f, -0.19255917f, 0.14660221f, 0.20228921f, 0.24106717f, -0.08510074f, 
    0.06071332f, 0.07495812f, -0.14041649f, -0.04941338f, 0.11861251f, -0.27891418f, 0.14708616f, -0.14969379f, 
    0.12868233f, 0.02670707f, -0.12482817f, -0.02231508f, -0.06431656f, -0.03580922f, -0.30871752f, -0.00650894f, 
    -0.08287537f, 0.15369686f, -0.16645662f, -0.20568942f, -0.00721041f, -0.00224930f, 0.02041991f, 0.05828536f, 
    -0.07689673f, 0.04897790f, -0.12124038f, 0.00087999f, 0.16441815f, 0.28463730f, -0.13599165f, 0.08118960f, 
    -0.04234674f, 0.03548234f, -0.02928764f, -0.15462768f, -0.00476873f, 0.02048963f, 0.01199684f, 0.06691379f, 
    0.04116907f, -0.05141033f, -0.71901435f, 0.42959851f, 0.01394608f, 0.10072939f, 0.02754461f, 0.11302627f, 
    -0.01693665f, -0.25976598f, -0.36708894f, -0.08270487f, 0.02600384f, 0.20037432f, -0.20368332f, 0.19673248f, 
    0.09492306f, -0.00957325f, -0.05202619f, 0.11850514f, -0.20434555f, 0.08895927f, 0.02957228f, 0.19403218f, 
    0.02493104f, -0.03102230f, -0.04054283f, 0.01502800f, 0.07631665f, 0.15383814f, -0.09936914f, -0.10149778f, 
    -0.41872716f, -0.04858267f, 0.10250019f, -0.46389139f, 0.38800406f, 0.02009248f, 0.27393928f, 0.01429981f, 
    0.03621604f, -0.04057917f, -0.05129204f, -0.09474315f, -0.07068903f, 0.04518164f, -0.06326744f, 0.04444753f, 
    0.47347906f, 0.17927761f, -0.01982885f, -0.15695979f, 0.04532124f, -0.00923225f, -0.04694946f, 0.02089112f, 
    -0.14674763f, 0.00877330f, 0.04121143f, -0.18147181f, -0.12728037f, -0.16444176f, 0.06220075f, 0.04854992f, 
    0.03853305f, -0.03847948f, -0.09303619f, -0.16829564f, -0.03197397f, 0.00252792f, -0.55444229f, -0.02713722f, 
    0.61590213f, -0.05948296f, 0.24656096f, -0.07000702f, -0.11225440f, -0.03313675f, 0.07179575f, -0.02792324f, 
    0.10734595f, 0.16443463f, 0.16978520f, 0.10521819f, -0.22358081f, 0.05432892f, 0.21157639f, -0.44042501f, 
    -0.00264156f, 0.07457686f, -0.14638129f, -0.05040137f, 0.17179365f, -0.15574470f, 0.00727871f, 0.03385731f, 
    -0.06931528f, 0.18602337f, 0.00388396f, 0.02044158f, -0.03555529f, 0.08214956f, -0.17383422f, -0.01325110f, 
    -0.10236252f, -0.05612458f, -0.08180974f, -0.17645863f, -0.09558264f, -0.03811649f, 0.05662326f, 0.12489800f, 
    0.04088540f, -0.02882816f, 0.03166730f, -0.00643296f, -0.05351062f, 0.04185566f, -0.04836130f, -0.08095327f, 
    -0.12227147f, 0.01689950f, 0.47916281f, 0.02397443f, 0.17087592f, -0.11787064f, 0.43108624f, -0.20913827f, 
    -0.03263962f, -0.07683377f, 0.01668364f, -0.02004157f, -0.80985749f, 0.21789335f, 0.13550617f, -0.03122342f, 
    0.11097705f, 0.09640563f, -0.00880525f, -0.07502150f, 0.22938827f, 0.10190431f, 0.04349454f, 0.11710955f, 
    -0.16782205f, -0.07244589f, -0.05571693f, -0.30537856f, 0.00745888f, -0.19335529f, -0.02483029f, 0.02416977f, 
    0.04984461f, -0.07599247f, -0.01244410f, -0.01796479f, -0.67918050f, -0.25959089f, -0.12679960f, -0.31053418f, 
    -0.08890208f, -0.18618846f, -0.06040908f, 0.02299624f, -0.00675896f, -0.05106915f, 0.01292544f, -0.14327903f, 
    0.06646556f, -0.04231721f, 0.00815340f, -0.00419843f, 0.10027576f, -0.00441117f, -0.04497079f, 0.06216439f, 
    0.09997024f, 0.08771974f, -0.25756541f, 0.38027045f, -0.25081366f, -0.02729564f, -0.05621783f, 0.14558849f, 
    0.05813850f, -0.01356777f, 0.09578189f, 0.07496709f, -0.01144025f, -0.26977900f, 0.20813796f, -0.12578329f, 
    -1.05061448f, -0.48515844f, -0.36625049f, -0.51680493f, -0.11506123f, -0.11642331f, 0.26692885f, -0.34196633f, 
    0.02945929f, -0.06609009f, -0.00933204f, -0.03182570f, -0.10176822f, 0.03529792f, 0.29920641f, -0.43914747f, 
    0.05943378f, -0.09495731f, 0.07849137f, 0.03404393f, -0.01365913f, -0.08005324f, 0.04569443f, 0.03487625f, 
    -0.03549135f, 0.02296441f, 0.28858814f, -0.68811995f, 0.17306878f, -0.03911679f, -0.34759590f, -0.07251659f, 
    0.01284189f, -0.00661243f, -0.01437119f, 0.09116820f, -0.60895908f, -0.31892651f, 0.25533080f, -0.39269522f, 
    -0.29756358f, -0.06254693f, -0.22864856f, -0.26217037f, 0.13546953f, -0.08796073f, 0.02070257f, -0.00268574f, 
    -0.22546405f, 0.23265721f, 0.03723077f, 0.08127140f, -0.09396894f, -0.05643971f, 0.13366984f, -0.13452362f, 
    0.01093588f, 0.14794670f, 0.07053250f, 0.08425672f, -0.27652195f, -0.15824580f, 0.19842380f, -0.09827060f, 
    -0.21168202f, -0.04647746f, -0.42279682f, -0.35516000f, 0.05203350f, 0.01758073f, -0.25243405f, 0.08030751f, 
    -0.15524410f, -0.31583413f, 0.27597836f, -0.08344655f, 0.06604771f, 0.04592120f, -0.14199480f, -0.05521070f, 
    -0.03580702f, -0.00082675f, 0.04413611f, 0.09900841f, -0.08405244f, 0.05657541f, 0.10073552f, -0.05450475f, 
    -0.04947207f, -0.25594246f, -0.03671559f, -0.01259978f, 0.00176558f, -0.01909892f, 0.05510125f, -0.17251484f, 
    0.14252597f, 0.45394492f, 0.53681827f, 0.31291848f, -0.09454311f, -0.09398821f, 0.17732406f, -0.01369149f, 
    0.01811536f, -0.05656255f, -0.05633336f, 0.12080540f, -0.08996539f, -0.12884690f, -0.00177362f, -0.03235739f, 
    0.01264565f, 0.03625728f, 0.07020245f, 0.04970576f, -0.00741754f, 0.00848343f, -0.00544131f, 0.11094622f, 
    0.13284804f, -0.23156862f, -0.00841158f, 0.12129260f, 0.00474287f, -0.03870751f, 0.03583065f, 0.07999641f, 
    -0.12792356f, 0.01101271f, -0.06324928f, -0.05524074f, 0.21518417f, 0.04439639f, 0.14213546f, -0.07155914f, 
    0.02096676f, -0.01367594f, 0.10603264f, -0.00307846f, -0.08338670f, 0.09289398f, -0.01680031f, -0.11648858f, 
    -0.20068465f, 0.76371962f, 0.64714092f, 0.18822409f, -0.19668919f, 0.05023245f, 0.00351521f, -0.09452234f, 
    -0.01052492f, 0.01934966f, -0.16451582f, 0.00136108f, 0.06707105f, 0.13607308f, -0.04199984f, 0.18431081f, 
    -0.02574261f, -0.01140637f, 0.05989217f, -0.15818329f, 0.05597597f, 0.20404895f, 0.19644642f, 0.09024699f, 
    0.26394472f, 0.16080916f, -0.06411546f, 0.25033271f, 0.14638655f, 0.06098325f, -0.03756759f, 0.14380558f, 
    0.16259103f, 0.08456170f, -0.05024592f, -0.04814738f, -0.44856721f, 0.42300144f, -0.46982694f, 0.49350798f, 
    -0.07754844f, 0.04889961f, 0.00509859f, -0.03119357f, -0.00639504f, 0.07727712f, -0.06081203f, -0.02799548f, 
    -0.18922421f, -0.29866877f, 0.24846666f, 0.31017628f, -0.02163223f, -0.02258245f, -0.07831325f, -0.00116647f, 
    -0.06609114f, -0.35137269f, 0.00394484f, 0.06399135f, 0.05622393f, -0.03462206f, -0.31549254f, 0.13749409f, 
    -0.03736851f, 0.12850086f, -0.08107676f, 0.13823546f, -0.03441624f, 0.04345637f, -0.05327069f, 0.19714388f, 
    -0.03661626f, 0.06451907f, 0.01130739f, 0.14851832f, -0.06230426f, -0.00582243f, -0.07877446f, -0.08318176f, 
    0.11683342f, 0.20165910f, 0.04323268f, 0.00373090f, -0.19414707f, 0.01923382f, -0.21695347f, -0.05343083f, 
    -0.03875393f, -0.02752036f, 0.04772847f, 0.05674843f, -0.00194886f, -0.02786358f, -0.05181009f, 0.00910527f, 
    -0.28321919f, 0.08870614f, 0.18941639f, -0.00269409f, -0.16388161f, 0.19183958f, -0.19956593f, 0.02108776f, 
    -0.04378439f, -0.07685742f, -0.21886961f, -0.15145135f, 0.31013888f, 0.07162610f, -0.17428653f, 0.10303764f, 
    -0.04369137f, 0.00403764f, -0.14018996f, -0.13066703f, 0.02422574f, 0.01148271f, 0.03231925f, 0.09752524f, 
    0.11779582f, -0.13534456f, 0.01607496f, -0.05622153f, 0.08628208f, -0.11056391f, 0.12251105f, 0.09362813f, 
    -0.03779482f, 0.10953614f, 0.08086850f, -0.14194930f, -0.24359004f, 0.18145339f, -0.03412947f, -0.09341339f, 
    -0.00118929f, 0.09700674f, 0.09853034f, -0.12879230f, -0.11974795f, -0.00740166f, 0.16370213f, -0.01184656f, 
    -0.14367576f, 0.79282409f, 0.24002881f, 0.55796105f, -0.04356788f, -0.06820874f, 0.13238093f, 0.03575486f, 
    0.02046041f, 0.01147250f, 0.04690556f, 0.04489148f, 0.00809755f, -0.16431978f, -0.10646970f, 0.14596641f, 
    0.19590887f, 0.05336313f, 0.07521114f, -0.00471745f, -0.06551318f, -0.04875988f, 0.00743499f, 0.04547737f, 
    -0.24213623f, -0.19816455f, 0.12225534f, -0.18991758f, -0.12738833f, -0.09458741f, 0.26131529f, 0.12726100f, 
    0.01931030f, 0.00699083f, 0.04930962f, -0.00264732f, -0.04036260f, 0.05520672f, -0.19244921f, 0.17253891f, 
    -0.13503316f, 0.09913103f, 0.01663851f, 0.03791026f, -0.04276748f, -0.14039984f, 0.09644677f, -0.11103664f, 
    -0.68460143f, -0.11316878f, 0.34843767f, 0.32057950f, -0.15135075f, -0.06065903f, -0.09982361f, 0.05164035f, 
    0.08810288f, -0.16530974f, 0.07566587f, -0.09308144f, -0.17829579f, -0.00656044f, -0.13614950f, 0.22433993f, 
    -0.00591604f, 0.01276613f, 0.02355411f, 0.04264154f, -0.00759005f, -0.04709001f, -0.09003982f, -0.03121044f, 
    -0.04445630f, 0.02946898f, -0.02045420f, 0.03758170f, -0.16532357f, -0.02660045f, -0.32606938f, -0.03634733f, 
    -0.12391046f, -0.06070661f, -0.25650933f, -0.02185165f, -0.13938598f, -0.18913816f, -0.05167098f, -0.29233935f, 
    0.03229188f, 0.26564535f, -0.07519775f, 0.07827434f, 0.00450797f, -0.25708631f, 0.00806812f, -0.22300208f, 
    0.04254925f, -0.34323642f, -0.13917203f, 0.24241793f, 0.09295618f, 0.10001022f, -0.01284573f, 0.11480540f, 
    0.00222838f, -0.04719780f, -0.00643150f, -0.07963513f, -0.04539944f, 0.01737365f, 0.36846977f, -0.02855218f, 
    -0.26510790f, -0.01526116f, -0.19916251f, 0.16191936f, 0.12344953f, 0.01170713f, -0.05105965f, -0.00877488f, 
    -0.05719367f, -0.02511693f, 0.28002581f, 0.12645745f, 0.05686569f, 0.18539253f, 0.05373070f, 0.06779610f, 
    0.02004060f, 0.01369569f, 0.10791213f, 0.16704574f, -0.17363837f, -0.16526882f, 0.31651491f, 0.37727684f, 
    -0.09586123f, 0.03901119f, -0.03485562f, 0.03902821f, 0.04550928f, -0.11563073f, -0.12831993f, 0.01224354f, 
    -0.37974295f, 0.00965507f, -0.09144390f, 0.20123194f, -0.07546829f, 0.04322455f, 0.27845275f, -0.13931639f, 
    0.00937700f, -0.05022083f, 0.14818224f, 0.03739551f, -0.18257232f, 0.09769079f, 0.42067602f, -0.07778543f, 
    -0.06092879f, 0.03397634f, -0.09327399f, 0.08406547f, 0.07264507f, -0.10477512f, -0.13266104f, -0.08968042f, 
    0.08445191f, -0.40436777f, -0.11763743f, 0.14786923f, -0.02572012f, -0.04285827f, -0.01269070f, -0.02042442f, 
    0.08542177f, 0.08866805f, 0.04689074f, 0.09527884f, -0.13217220f, 0.26807147f, -0.17172949f, 0.05046967f, 
    0.35644820f, 0.09368362f, 0.10880350f, -0.00453681f, 0.01714178f, 0.09728748f, 0.14033924f, 0.13115357f, 
    0.33454692f, -0.28175056f, 0.10731828f, 0.19209646f, 0.28081125f, 0.18862090f, 0.09710681f, -0.09849775f, 
    -0.11552840f, -0.03057916f, -0.03252754f, 0.01715814f, -0.45174065f, -0.27663803f, -0.52456737f, 0.14799605f, 
    -0.04465113f, -0.08462892f, 0.03870204f, -0.15898059f, -0.07490790f, 0.06679602f, -0.05995813f, 0.01558856f, 
    -0.04292766f, 0.17061193f, -0.25920138f, -0.17908338f, 0.11968476f, 0.02840491f, 0.10071694f, -0.04345204f, 
    0.04082038f, 0.06336331f, 0.01601765f, -0.17861807f, 0.34999558f, -0.09860991f, 0.03607062f, 0.43142709f, 
    -0.13754976f, -0.03556515f, -0.13693026f, 0.01204634f, -0.09796319f, 0.05089712f, 0.19774137f, 0.04486807f, 
    -0.07758647f, -0.05407863f, -0.04033040f, 0.35576212f, 0.08519793f, -0.06935708f, 0.08078444f, -0.07746170f, 
    0.06863514f, 0.13244440f, 0.03656816f, 0.05498594f, 0.04709222f, -0.16451953f, -0.14702494f, 0.14963360f, 
    -0.13682963f, -0.03951711f, -0.17285821f, -0.06552321f, 0.04370238f, 0.00980977f, 0.10588570f, -0.03422913f, 
    0.17833233f, -0.19494678f, -0.20547114f, -0.21158272f, 0.19573909f, 0.02153100f, -0.10539706f, -0.13734765f, 
    -0.06243152f, -0.07860929f, 0.02573255f, -0.12024536f, -1.17361569f, 0.87372684f, -0.44124874f, 0.28971371f, 
    -0.09833319f, -0.33086759f, -0.20209070f, -0.09400795f, 0.00998108f, 0.13701525f, -0.09625594f, 0.04167226f, 
    -0.04005810f, -0.01731453f, -0.23935528f, -0.06481333f, 0.18076910f, -0.06144121f, -0.01214735f, -0.14076978f, 
    -0.15901856f, 0.03627137f, -0.02201002f, 0.03697716f, -0.15097591f, 0.07331732f, -0.40808374f, -0.45661053f, 
    -0.43642545f, -0.03682459f, -0.23454657f, 0.15458326f, -0.13308814f, -0.02265122f, 0.19328268f, 0.11349509f, 
    -0.29844263f, 0.07261449f, -0.09768800f, 0.15688893f, -0.05116672f, 0.05104754f, 0.05497120f, 0.02707879f, 
    0.02196428f, 0.05900313f, 0.00674815f, 0.02027254f, -0.11339565f, -0.27656558f, 0.34477028f, -0.05798606f, 
    -0.13006975f, -0.00700697f, -0.07510762f, 0.18261637f, 0.15975837f, 0.03309856f, 0.05489293f, 0.09704430f, 
    -0.03008659f, 0.35133412f, 0.07667939f, 0.40216157f, 0.00079871f, -0.18510273f, 0.13896175f, -0.21908319f, 
    0.04929537f, 0.18026662f, 0.20590273f, 0.19194067f, 0.88903081f, 0.13284948f, 0.15802772f, -0.18583383f, 
    0.24122807f, 0.11753421f, -0.07371625f, -0.04428765f, -0.16656718f, -0.02785660f, 0.15845883f, 0.03840712f, 
    -1.01374722f, 0.87652099f, -0.44520319f, -0.62600309f, 0.13620062f, 0.22275658f, 0.06366075f, -0.11411331f, 
    -0.37653694f, -0.09664932f, 0.06574074f, 0.08329696f, -0.13457519f, 0.01189604f, 0.04137849f, 0.19897719f, 
    -0.30304646f, 0.02937512f, -0.26391435f, -0.16382836f, -0.16390933f, 0.19894698f, -0.21322666f, -0.03263618f, 
    0.37414384f, -0.19250095f, -0.03862420f, 0.16849901f, 0.00074878f, -0.13175622f, -0.11033542f, 0.00787283f, 
    0.08618318f, 0.03173796f, 0.09661545f, 0.10140707f, 0.38736916f, 0.07516140f, -0.12277828f, -0.27670121f, 
    -0.00991031f, -0.14029300f, 0.01892435f, -0.18069214f, -0.06390699f, -0.04871655f, 0.19032592f, 0.00240363f, 
    -0.06598933f, -0.02004826f, -0.23732817f, 0.03348585f, 0.04503300f, 0.05587828f, -0.16186191f, -0.22469963f, 
    0.11181282f, -0.10550994f, 0.03908537f, -0.05208055f, 0.30651197f, -0.24759234f, -0.17003722f, -0.40085313f, 
    -0.21137151f, -0.00357073f, -0.14948848f, -0.00182436f, -0.04999518f, -0.03774788f, 0.07799910f, -0.17393467f, 
    -0.00638734f, -0.05776068f, -0.27766061f, 0.18344365f, 0.14824012f, 0.07032911f, 0.15554565f, -0.00622266f, 
    0.11639030f, 0.08746850f, 0.03045019f, 0.02978702f, -0.06646327f, -0.16498289f, 0.17089207f, 0.10641982f, 
    -0.00645168f, 0.00099085f, -0.05804916f, -0.12607697f, -0.02317000f, 0.00697299f, -0.00300863f, 0.17659669f, 
    -0.07304290f, -0.04575820f, -0.26034400f, -0.10535368f, -0.17728844f, 0.07110821f, 0.11175818f, -0.24988998f, 
    0.03183965f, -0.22472313f, 0.03448397f, -0.28989476f, 0.13913305f, 0.11624524f, -0.07965812f, -0.09590186f, 
    0.00654276f, 0.02948416f, 0.02680407f, -0.06118892f, 0.10689641f, -0.10426386f, -0.32340172f, -0.06592385f, 
    0.11528432f, 0.24806063f, 0.41824660f, 0.22044517f, -0.18221699f, -0.17436454f, 0.12796883f, 0.23810838f, 
    0.18774880f, 0.02412650f, 0.09248734f, 0.01278151f, 0.42512995f, -0.15416008f, -0.30480191f, 0.09023351f, 
    -0.00030233f, 0.01852154f, 0.13253213f, -0.05658972f, 0.15211816f, -0.09051036f, 0.03979234f, -0.04682307f, 
    0.38191128f, 0.30125690f, -0.10709374f, 0.42031610f, 0.28329065f, -0.05643465f, -0.00323865f, -0.14070752f, 
    -0.08492899f, 0.10932881f, -0.04252419f, -0.03786925f, 0.03411778f, 0.37938055f, -0.00661866f, 0.04409464f, 
    0.21214697f, 0.09682114f, 0.06304414f, -0.03482946f, 0.04215819f, -0.06551155f, 0.04820198f, -0.12019157f, 
    0.16486958f, -0.03864035f, 0.07639766f, 0.06092311f, 0.09939706f, -0.05456430f, -0.18041001f, -0.05728341f, 
    -0.01481637f, -0.05667133f, -0.04628944f, -0.00159259f, -0.24561563f, 0.13135335f, -0.29063708f, 0.25045767f, 
    0.07622881f, 0.20520897f, -0.31223294f, -0.06627762f, 0.01182569f, 0.09231992f, 0.03016719f, -0.22428067f, 
    0.08024023f, 0.07580975f, -0.06244469f, 0.17291869f, -0.01516405f, 0.13794908f, 0.04455670f, -0.18308279f, 
    -0.00904446f, 0.04592870f, -0.10227407f, 0.06540249f, 0.09896626f, -0.06098082f, 0.13083351f, -0.03178588f, 
    -0.20656657f, 0.09587091f, -0.08154838f, 0.01605755f, 0.03761566f, -0.00113295f, -0.17433944f, 0.00800511f, 
    -0.00366812f, 0.25197357f, 0.18298139f, 0.12503774f, -0.03977276f, -0.24089999f, 0.06087596f, 0.01827495f, 
    -0.03091582f, -0.12609085f, -0.09349958f, 0.11330129f, 0.06998622f, 0.00792280f, 0.00803306f, -0.00450056f, 
    0.20477784f, 0.09323236f, 0.03174764f, 0.03223210f, -0.09496263f, -0.07684057f, 0.01272702f, 0.08315835f, 
    0.31541848f, -0.04075485f, 0.16793267f, 0.09043621f, -0.05978926f, -0.03837060f, -0.18728098f, 0.04452487f, 
    0.23789859f, 0.04220458f, -0.09370423f, 0.11711601f, -0.02174363f, 0.03439377f, -0.25510973f, 0.02504119f, 
    -0.03506616f, -0.16050133f, -0.03986239f, -0.07227302f, 0.04515745f, -0.02745492f, 0.03971131f, 0.12891266f, 
    -0.10927970f, 0.03277837f, 0.12338057f, 0.06681994f, -0.12809491f, -0.05545961f, -0.08841699f, -0.31231126f, 
    -0.06747513f, -0.02331574f, -0.02114907f, 0.02757788f, -0.11613200f, -0.01111905f, -0.09790514f, -0.28246599f, 
    -0.03649310f, -0.12668966f, -0.03358743f, 0.00624800f, -0.00554451f, -0.01537732f, 0.03543331f, 0.23891032f, 
    0.11972938f, 0.22544871f, -0.25407878f, 0.03092883f, -0.07278916f, -0.05826488f, 0.06708120f, 0.00560249f, 
    0.04680797f, -0.16796213f, -0.35558224f, -0.04555566f, 0.37210622f, -0.48411089f, 0.36132082f, -0.23722015f, 
    0.06336627f, -0.05360437f, 0.08937176f, 0.05059731f, -0.01966455f, -0.03004815f, -0.01495556f, -0.07466944f, 
    0.14411156f, 0.07940196f, -0.09798738f, 0.22391891f, -0.00469256f, -0.03424222f, 0.01940356f, -0.17565924f, 
    0.06203501f, -0.16594198f, -0.03120449f, 0.02869029f, -0.10320404f, -0.23669484f, -0.02804011f, -0.04793962f, 
    -0.21153589f, -0.01581352f, 0.05255977f, -0.14092860f, 0.09130750f, -0.13180296f, -0.18079531f, -0.21447369f, 
    -0.05019031f, 0.04169927f, 0.12271368f, -0.10889263f, -0.07258121f, 0.00048439f, -0.01515348f, -0.01634360f, 
    0.21315522f, 0.14447504f, -0.08702719f, 0.49713013f, 0.26162973f, 0.39381140f, -0.48292235f, 0.03547094f, 
    0.02290122f, 0.08050758f, 0.09998418f, -0.02469036f, 0.04128798f, 0.01414504f, 0.08248760f, 0.05282026f, 
    -0.17759226f, -0.08534656f, 0.19926023f, -0.11846742f, 0.06734513f, 0.03702143f, -0.04614172f, 0.07226195f, 
    0.08630281f, -0.01809707f, -0.08350476f, -0.11450149f, -0.35448071f, -0.30038866f, -0.23126124f, -0.13572857f, 
    -0.02433840f, -0.13885631f, 0.26171088f, -0.01317572f, -0.15992226f, 0.07252650f, 0.15341970f, 0.08847043f, 
    0.07412192f, -0.54152077f, 0.16467117f, -0.05636699f, -0.03493191f, -0.00490235f, -0.06969110f, -0.06636709f, 
    -0.13317789f, 0.05727944f, -0.20820372f, 0.06612134f, -0.02213211f, -0.26993993f, -0.07789362f, 0.20983867f, 
    -0.35860521f, -0.14413123f, -0.16469072f, 0.26443645f, -0.04188785f, 0.08713401f, -0.08077037f, -0.06138207f, 
    -0.27368647f, -0.09078897f, -0.03120194f, 0.15014678f, -0.15646930f, -0.01902137f, -0.21057533f, -0.11005290f, 
    0.05160189f, 0.00576681f, -0.03820436f, 0.00846162f, 0.07427979f, -0.07249493f, -0.01864616f, 0.12407358f, 
    -0.03735825f, 0.07225464f, -0.10556219f, 0.05259053f, -0.02760118f, -0.27681825f, -0.23346710f, -0.07392507f, 
    -0.01753606f, 0.03878925f, 0.11906492f, 0.17528170f, -0.29392213f, -0.14916538f, -0.06789931f, 0.11785658f, 
    0.00041891f, 0.00037690f, -0.04171218f, 0.09531804f, 0.02444846f, -0.42443186f, -0.06462807f, -0.01495825f, 
    -0.11103511f, -0.06963180f, 0.02857235f, -0.15290564f, -0.09477012f, -0.26098675f, -0.23899384f, -0.09999682f, 
    -0.04065568f, -0.18585692f, -0.42849249f, 0.07058021f, 0.01945807f, -0.06481310f, 0.07511903f, -0.00959341f, 
    -0.00345035f, 0.03168703f, -0.06689543f, -0.15689360f, -0.06282055f, 0.32783949f, 0.26426750f, -0.21195692f, 
    0.08131517f, -0.02488153f, 0.06333935f, 0.02969034f, 0.09404798f, 0.10500717f, 0.02652178f, -0.03934225f, 
    0.31039828f, 0.23421727f, -0.34288409f, 0.16619498f, 0.21509588f, -0.19587974f, 0.03981328f, 0.06386685f, 
    0.16407624f, 0.05249711f, 0.37418523f, 0.10502385f, -0.32518616f, -0.26418775f, -0.04418686f, -0.11411230f, 
    -0.01736726f, -0.01691974f, 0.01563798f, -0.09674977f, -0.01298824f, 0.19019328f, 0.21348713f, -0.03412003f, 
    0.05516158f, 0.16117021f, 0.00080351f, -0.15422538f, 0.35152563f, 0.14610589f, 0.12816054f, -0.34015560f, 
    -0.03193263f, -0.06298493f, 0.04772377f, -0.00496489f, -0.72143406f, -0.04454211f, -0.39180088f, 0.28679153f, 
    0.07282814f, -0.07396621f, -0.02770457f, 0.09566502f, 0.09316368f, -0.00968229f, 0.00398178f, -0.06046515f, 
    -0.13965949f, 0.43278509f, 0.09422898f, 0.04905904f, -0.03771047f, -0.14921813f, -0.04778288f, -0.03508623f, 
    -0.01905961f, -0.25435254f, -0.14506485f, -0.04441906f, 0.00306394f, 0.24961531f, 0.02100880f, -0.14985852f, 
    0.25814828f, -0.02312125f, 0.31041795f, 0.26763508f, 0.03800090f, 0.06293532f, 0.01785252f, -0.00593378f, 
    0.16475132f, 0.01885579f, 0.00272491f, -0.28798562f, 0.00469122f, 0.06505878f, -0.13124852f, 0.17997707f, 
    -0.05720434f, 0.05720013f, 0.02124317f, -0.11562276f, 0.01851617f, 0.16890933f, -0.20917478f, 0.30052340f, 
    0.11039265f, 0.01186932f, 0.05368742f, -0.25095791f, -0.12702015f, 0.00195367f, -0.06417511f, 0.03805191f, 
    -0.04448647f, 0.18569742f, 0.08292783f, -0.09399498f, 0.05411663f, -0.19902697f, -0.04435523f, 0.34226683f, 
    -0.01672929f, -0.15881224f, 0.07514253f, 0.07424608f, -0.14933814f, -0.13622718f, 0.12338856f, -0.06870318f, 
    -0.34416822f, 0.20521840f, -0.03368146f, -0.17585550f, 0.06619161f, 0.01865761f, 0.12975942f, 0.07916324f, 
    -0.66358948f, -0.16272968f, -0.54782671f, -0.35057369f, -0.03869795f, 0.00655809f, -0.13340543f, -0.01709603f, 
    0.08473812f, -0.01606771f, -0.00929085f, -0.22172189f, -0.08131207f, -0.11848564f, -0.11496581f, -0.01211631f, 
    -0.02049795f, -0.00815579f, -0.06045887f, 0.02327088f, 0.14957231f, 0.15647942f, -0.09564644f, 0.13756365f, 
    0.18677095f, 0.14812028f, 0.01538865f, -0.32483611f, 0.04195425f, 0.00954942f, 0.05242805f, 0.00427582f, 
    0.01421709f, 0.03588308f, -0.11181708f, -0.02602952f, -0.13194394f, 0.50349045f, -0.31230298f, -0.19399482f, 
    0.06081296f, 0.04682903f, 0.04726159f, 0.04326140f, 0.07638986f, 0.07064895f, 0.01069742f, -0.27632061f, 
    0.12097985f, -0.18939899f, -0.05839936f, -0.30870867f, -0.07922860f, 0.08372366f, -0.14326751f, 0.33164054f, 
    0.07404436f, -0.14626297f, -0.01031525f, -0.00044735f, 0.35996875f, 0.10424288f, -0.27983120f, -0.02859503f, 
    -0.02310864f, 0.16391876f, 0.00769339f, -0.10242116f, -0.04853109f, -0.45369232f, 0.00909019f, -0.10197135f, 
    -0.61888158f, -0.57038814f, 0.18670426f, 0.05798721f, -0.10394303f, 0.05285495f, -0.04034996f, -0.07699839f, 
    -0.00530817f, 0.05337915f, 0.35813975f, 0.06023836f, 0.06859843f, -0.39538798f, 0.44873857f, 0.17161809f, 
    0.28522173f, 0.00157521f, -0.04742166f, 0.01105337f, 0.07183865f, 0.02038908f, -0.01372604f, 0.10937352f, 
    -0.46557069f, -0.18338779f, 0.36075169f, -0.59773618f, -0.00105494f, 0.03608260f, 0.14303635f, 0.09424065f, 
    0.15776621f, -0.07270648f, 0.05569403f, -0.01318053f, -0.11121516f, -0.39306873f, 0.43708259f, 0.00758222f, 
    0.13687420f, 0.02520957f, 0.02879172f, -0.01840887f, 0.20828214f, -0.17945983f, -0.03287037f, 0.01813282f, 
    0.13522130f, -0.12116382f, 0.02862861f, -0.13029949f, -0.00276734f, -0.03829696f, 0.05212845f, -0.06736453f, 
    -0.14150967f, -0.27604273f, -0.22694886f, -0.81084830f, -0.28179944f, -0.41862139f, -0.27122280f, 0.26649576f, 
    0.04833861f, -0.00375787f, -0.08936362f, 0.05939076f, -0.03984178f, 0.06012556f, -0.00338176f, 0.01934156f, 
    -0.19304779f, -0.35014218f, -0.14038748f, 0.01699463f, -0.10536132f, -0.02374437f, -0.11891200f, -0.11057510f, 
    0.14678738f, 0.06535881f, 0.10073512f, 0.10252077f, -0.62614024f, 0.07722446f, -0.14574066f, -0.04562624f, 
    -0.04404812f, -0.04666928f, 0.00716077f, 0.19178224f, -0.07274804f, -0.23441255f, -0.30069220f, -0.12583421f, 
    -0.53720337f, -0.06880327f, -0.06490207f, 0.26155514f, -0.04623787f, -0.14811477f, 0.01752148f, 0.22954960f, 
    0.21012150f, 0.03239278f, -0.13423496f, -0.18909267f, 0.22939412f, -0.08949384f, -0.09636206f, 0.30127010f, 
    0.32808316f, -0.08880933f, -0.17528097f, -0.02302740f, 0.01842870f, 0.03311084f, 0.03222073f, -0.03115877f, 
    -0.04225726f, 0.01611174f, -0.01840755f, -0.18264225f, 0.24688716f, -0.02813275f, 0.22028296f, -0.01556374f, 
    -0.00164376f, -0.00798130f, -0.01734113f, 0.10357857f, -0.16708623f, 0.04775081f, 0.27197671f, -0.06494873f, 
    -0.15683524f, 0.04607594f, -0.02581196f, 0.03175238f, 0.13096786f, 0.13730231f, 0.09914415f, 0.22560038f, 
    -0.03570464f, 0.21443152f, -0.07295801f, 0.01249750f, 0.21444036f, 0.19567087f, 0.17301396f, -0.03714949f, 
    0.09858495f, 0.03707471f, 0.00449723f, 0.04563190f, 0.25274977f, -0.24304086f, 0.12877601f, 0.43669373f, 
    0.02359535f, -0.08787175f, -0.00959927f, 0.17182021f, -0.05376644f, 0.24253963f, 0.00949936f, 0.08275883f, 
    0.09936845f, -0.17134625f, 0.05252092f, -0.01556836f, 0.02041388f, 0.12431845f, 0.10142405f, -0.12445542f, 
    -0.07045075f, -0.02587267f, -0.12194555f, -0.01591621f, -0.38609731f, -0.74865937f, -0.61185873f, 0.10812984f, 
    -0.13978840f, -0.19986878f, -0.21508253f, -0.43704477f, -0.13023761f, 0.04113568f, -0.01397464f, -0.01816968f, 
    0.45651466f, -0.13206472f, -0.12248008f, -0.14121474f, -0.13287887f, -0.02056137f, 0.02419187f, 0.14705218f, 
    0.03153382f, 0.28068727f, 0.03854062f, -0.33953705f, 0.08493230f, 0.02130131f, -0.00803248f, -0.17646152f, 
    -0.03722900f, 0.05414211f, -0.01538107f, 0.01576960f, 0.14218692f, 0.09717004f, 0.10782363f, 0.28120312f, 
    -1.27370191f, -0.78017801f, -0.39425156f, -0.38974476f, -0.36728427f, -0.11463489f, -0.36884248f, -0.49201730f, 
    0.09494537f, -0.02045073f, -0.03417717f, -0.03933845f, 0.00378459f, -0.13470541f, -0.28243572f, -0.43784752f, 
    -0.04661706f, 0.19349158f, -0.09331456f, -0.03839027f, 0.00128532f, 0.10626884f, -0.02257505f, -0.02770993f, 
    -0.25104603f, -0.68255591f, -0.11924960f, 0.04519321f, 0.10453407f, 0.08745299f, 0.09952433f, -0.26857641f, 
    -0.03669147f, 0.12190451f, 0.05988987f, 0.14473781f, -0.49142781f, -1.08510947f, 0.01220760f, -0.02928761f, 
    0.10389994f, 0.16591278f, 0.09743435f, -0.22338533f, 0.04142265f, 0.01778322f, -0.02070415f, 0.01787628f, 
    0.23995385f, 0.43547919f, -0.47399274f, -0.23057316f, 0.01328869f, 0.12425101f, -0.04781675f, 0.09246647f, 
    0.00861859f, 0.00376433f, 0.01533207f, -0.11311349f, 0.57046413f, 0.09022607f, -0.37663728f, -0.34698910f, 
    0.10277753f, -0.05413010f, 0.17157619f, 0.11180733f, 0.09686353f, -0.07190587f, -0.03342646f, -0.01357542f, 
    -0.51633161f, -0.42553058f, -0.45587373f, 0.07891037f, -0.36857998f, -0.10378932f, 0.09998727f, 0.06031428f, 
    0.02085720f, 0.02416835f, 0.14286137f, -0.07982574f, -0.22531283f, 0.01567983f, -0.03600957f, 0.13734199f, 
    0.03212007f, -0.21744621f, -0.14625986f, 0.07849269f, -0.06941445f, -0.04382426f, -0.17156613f, -0.22810848f, 
    -0.57626885f, 0.13127117f, 0.47745061f, 0.18651006f, -0.12346919f, 0.00963175f, -0.13125345f, -0.09105793f, 
    -0.06428475f, 0.07850394f, 0.04526353f, 0.06405148f, 0.06303573f, -0.06227806f, -0.10212412f, -0.02140030f, 
    0.01590804f, -0.05390084f, -0.01218046f, 0.00120576f, -0.14818773f, -0.02565970f, -0.11041808f, -0.19592105f, 
    -0.82465261f, 0.86198694f, 0.55653393f, 0.02527840f, -0.00276401f, -0.05508865f, -0.10873288f, 0.02171252f, 
    -0.15482073f, 0.03899297f, 0.09792534f, 0.05549471f, 0.06227909f, -0.07207052f, 0.12889664f, -0.07966428f, 
    -0.02625290f, 0.01673167f, 0.07685936f, -0.05809365f, 0.10800707f, -0.01232617f, 0.28113309f, 0.24239378f, 
    -0.36968094f, 0.65792906f, -0.19358730f, 0.49291754f, -0.13336638f, -0.11723153f, 0.03405482f, 0.04555701f, 
    0.12661324f, -0.07047610f, 0.20106031f, -0.10062671f, 0.36807656f, 0.14605615f, -0.03337144f, -0.00532085f, 
    -0.08275840f, -0.11548752f, 0.10491166f, 0.26074931f, -0.02126423f, 0.31495860f, -0.03615045f, 0.15590173f, 
    -0.44127122f, 0.03368543f, 0.39035159f, 0.43091348f, -0.07813537f, -0.00590914f, 0.05251553f, -0.12105432f, 
    -0.06739549f, -0.01943461f, -0.02744720f, 0.11725443f, -0.23226687f, -0.12883988f, -0.11865804f, 0.37338272f, 
    0.02217447f, 0.05562450f, 0.10399557f, 0.19890152f, 0.01029537f, -0.14855136f, 0.10894530f, -0.05769257f, 
    0.03848618f, -0.44987130f, 0.02065061f, -0.18360069f, -0.09929371f, -0.07167140f, -0.07888502f, 0.09138606f, 
    0.13416570f, 0.38958651f, 0.09263870f, 0.08048534f, 0.38789356f, -0.06985807f, -0.30328429f, 0.33541656f, 
    -0.01836967f, 0.09346008f, 0.02317117f, 0.23011574f, -0.03260577f, -0.18409413f, 0.27827168f, -0.14600271f, 
    -0.10083078f, 0.01355455f, -0.11918164f, 0.12692609f, -0.04154116f, 0.00062105f, 0.08682338f, 0.05022858f, 
    0.07128700f, -0.08414498f, 0.10571707f, 0.14465576f, -0.15293586f, -0.05902621f, 0.08326458f, -0.05762812f, 
    0.03256702f, 0.09579718f, 0.07226463f, -0.17452583f, -0.05226269f, 0.03711354f, 0.07180089f, 0.03768269f, 
    -0.21196191f, 0.14917040f, -0.02253574f, -0.13993812f, -0.04758045f, -0.31590632f, 0.09312750f, 0.12170050f, 
    0.04197909f, -0.16525647f, -0.03718395f, -0.06157547f, -0.01682678f, -0.04365031f, 0.06876512f, 0.05647759f, 
    -0.11373352f, -0.01139196f, 0.11675238f, -0.08670480f, -0.01959497f, 0.09709492f, 0.26920125f, 0.09790727f, 
    -0.09506264f, -0.24114317f, 0.14824016f, 0.20628725f, 0.06493259f, 0.06328619f, -0.02535530f, -0.01617888f, 
    0.06793653f, -0.02033700f, 0.09800294f, 0.15759382f, 0.11051382f, 0.02419924f, -0.29208732f, 0.11357708f, 
    0.09617619f, -0.01454864f, 0.24303068f, 0.19012514f, 0.00696016f, 0.30368614f, -0.12595077f, 0.04288538f, 
    -0.77746254f, -0.73391879f, -0.32527038f, 0.25661838f, -0.16464965f, -0.00171917f, -0.02074694f, -0.17892726f, 
    0.02497813f, 0.11600111f, 0.02026834f, 0.03992828f, -0.04443298f, -0.07133165f, -0.06434518f, 0.07730637f, 
    0.08561181f, -0.29434755f, -0.04464066f, 0.09867816f, -0.06223869f, 0.06107415f, -0.06373359f, -0.28106591f, 
    -1.03047371f, -0.84715712f, -0.61677182f, -0.14389667f, -0.17450257f, -0.14697713f, -0.27861476f, -0.41022205f, 
    -0.03491553f, -0.02088668f, -0.02106157f, -0.04955686f, 0.00396888f, 0.07289024f, -0.05979888f, -0.04603168f, 
    -0.22969972f, -0.01753272f, 0.06346988f, 0.22272816f, -0.19432947f, 0.09213644f, -0.10957837f, 0.17291823f, 
    -0.07416612f, 0.14597836f, 0.18174386f, 0.03796043f, -0.03204035f, -0.01450769f, 0.13057850f, 0.01286064f, 
    0.09089232f, -0.00286567f, 0.00386821f, -0.08366480f, -0.22497532f, -0.34633830f, 0.75469828f, -0.00592696f, 
    -0.10814550f, 0.05812186f, -0.19780166f, 0.27252579f, 0.00251316f, -0.16002898f, -0.03638947f, -0.00987495f, 
    -0.19778557f, 0.06125711f, -0.07657298f, 0.15566191f, -0.21430756f, 0.10563315f, 0.04309406f, -0.06016904f, 
    0.03223662f, -0.27393505f, -0.02544964f, 0.00671019f, 0.13437977f, -0.02939944f, 0.04585914f, -0.25839019f, 
    0.05439607f, -0.00760640f, -0.01406304f, -0.04978722f, 0.07103232f, -0.07935159f, -0.29437336f, -0.26057035f, 
    -0.70254755f, -0.47274050f, -0.10859859f, 0.56761479f, 0.21758702f, 0.15367837f, -0.01390382f, 0.00002689f, 
    0.01711117f, -0.03967226f, -0.05268572f, -0.01625250f, -0.09364255f, 0.20050120f, -0.23335235f, -0.06356926f, 
    -0.00901347f, -0.00522143f, -0.06110847f, -0.06678991f, 0.07310294f, 0.05558206f, 0.07764751f, -0.00077237f, 
    -0.25756523f, 0.55336678f, 0.00615688f, 0.04245371f, -0.24286267f, -0.13044064f, -0.08037488f, 0.26719654f, 
    -0.01321021f, 0.06276653f, 0.07818122f, 0.09705658f, -1.04922378f, 0.84679067f, 0.23924769f, 0.01794082f, 
    0.10029926f, -0.16929719f, -0.04461739f, -0.05427729f, 0.03328058f, -0.02701775f, 0.06415494f, 0.05145883f, 
    -0.34859124f, -0.16831551f, -0.08358482f, -0.13187389f, -0.10632852f, -0.14513735f, 0.16887054f, -0.08891011f, 
    -0.09129582f, 0.07780574f, -0.01192800f, 0.00448095f, -0.43552446f, 0.07102145f, -0.22812308f, 0.17344564f, 
    -0.00873106f, 0.01921961f, 0.28617513f, 0.20270467f, 0.09746058f, -0.02096914f, -0.06369913f, -0.00152463f, 
    -0.51070273f, -0.20815431f, -0.48116371f, -0.16098407f, 0.06647466f, 0.13953054f, 0.14058885f, -0.00332268f, 
    0.06369105f, 0.03425022f, -0.06797606f, -0.13924880f, 0.04994230f, -0.07208338f, -0.01168315f, -0.07183729f, 
    -0.36687309f, 0.24347980f, 0.24447519f, 0.11650416f, 0.10604321f, -0.08541737f, -0.03338696f, -0.01392824f, 
    0.69640470f, -1.04754972f, -0.27639875f, -0.28371444f, -0.14955290f, -0.05889018f, -0.19897519f, 0.12067588f, 
    0.19433504f, -0.02183213f, -0.06412254f, 0.10208499f, 0.01427499f, 0.09871436f, 0.08886279f, -0.06217282f, 
    -0.03771305f, 0.00455683f, -0.04644223f, 0.00264302f, -0.08327084f, -0.24666835f, 0.01179973f, -0.04698909f, 
    0.50120103f, -0.48796248f, 0.49097329f, -0.01032754f, 0.15698610f, -0.02539869f, 0.05516661f, -0.07758734f, 
    0.07711861f, 0.11050175f, 0.13670088f, 0.06105443f, -0.15431578f, 0.65801740f, -0.36627078f, 0.38841981f, 
    0.05864925f, 0.14517403f, -0.07919734f, -0.04014308f, -0.13502704f, 0.01666796f, -0.07242601f, -0.01341633f, 
    -0.83753806f, -0.47397962f, -0.87166178f, -0.27994102f, -0.22630385f, -0.36150712f, 0.12785523f, -0.23193109f, 
    -0.00133915f, 0.01863759f, 0.09769614f, -0.01047846f, -0.24088588f, 0.12712136f, -0.29470715f, 0.22639282f, 
    -0.01646182f, 0.10465603f, 0.10895107f, 0.02951536f, 0.06090866f, 0.09725454f, -0.07011764f, -0.08521799f, 
    0.49000826f, -0.10585274f, -0.02346497f, -0.40932825f, 0.00831719f, 0.02626530f, -0.12521307f, 0.05764846f, 
    -0.17468856f, -0.11538856f, -0.01702699f, 0.01468343f, 0.23654720f, -0.28419837f, 0.03571787f, -0.25811398f, 
    0.06419063f, -0.04217215f, 0.00023905f, -0.10146519f, 0.03923399f, -0.04569112f, 0.06670957f, -0.06666613f, 
    0.60985535f, -0.27127555f, 0.49726009f, -0.44670233f, 0.03000724f, -0.04370221f, -0.08396465f, -0.00480371f, 
    0.04478819f, 0.17802168f, 0.12293186f, 0.03516203f, -0.01141104f, -0.23167461f, 0.00914970f, -0.25947732f, 
    0.00520082f, -0.07237490f, -0.13190740f, -0.26018393f, 0.02828874f, 0.00065942f, 0.02905733f, -0.11074215f, 
    0.04768183f, -0.30701035f, -0.04998125f, -0.09706623f, -0.12503986f, -0.08540159f, -0.06379872f, -0.09101730f, 
    0.02380196f, 0.09795817f, 0.11274659f, 0.12894331f, 0.12069150f, 0.18265639f, -0.22911127f, -0.05664168f, 
    0.03531430f, -0.10895836f, 0.00557034f, -0.07613932f, 0.00508986f, 0.07357854f, 0.07229227f, -0.00665020f, 
    0.02976577f, -0.10877825f, 0.06873780f, -0.05386484f, 0.00460221f, 0.22593614f, 0.37722138f, -0.01626827f, 
    -0.00940915f, 0.06349143f, -0.00510648f, -0.03096516f, 0.27040613f, 0.22519504f, -0.10798409f, 0.24039569f, 
    0.08850107f, -0.02810342f, -0.17219353f, -0.01698008f, 0.10807336f, 0.10320061f, -0.04914544f, 0.11596985f, 
    0.20708674f, 0.14944489f, -0.04043537f, -0.12511052f, 0.10394897f, 0.09203887f, -0.04015540f, 0.02446607f, 
    -0.22947031f, 0.06911429f, -0.05821328f, -0.34124550f, -0.06450706f, -0.02019732f, 0.15394643f, -0.02782046f, 
    -0.31924504f, 0.10327507f, -0.22225575f, 0.07598304f, -0.12293110f, -0.01148067f, -0.00422533f, 0.00441999f, 
    -0.26490143f, -0.30812958f, -0.44334042f, -0.50103009f, -0.02885097f, 0.12010253f, 0.05191211f, 0.05107373f, 
    0.09458578f, -0.01340444f, -0.11492111f, 0.06657876f, 0.23945704f, 0.04731343f, 0.07434277f, -0.17124026f, 
    -0.09266140f, -0.07613691f, 0.07103712f, -0.04991643f, 0.04399486f, -0.03893898f, -0.05718326f, -0.12462312f, 
    0.56310743f, -0.59113258f, -0.27755606f, -0.17510737f, -0.05855091f, -0.11264297f, -0.14226447f, 0.08491595f, 
    0.07313018f, 0.07217395f, -0.03405446f, -0.05944049f, 0.29039663f, -0.04365254f, -0.17491740f, -0.11694489f, 
    0.01387255f, 0.13548470f, -0.11801080f, -0.27370286f, -0.21981446f, -0.11427719f, -0.01131165f, -0.16081186f, 
    -0.49798182f, 0.01980815f, 0.12654999f, -0.15714420f, -0.04004341f, 0.03131944f, -0.05313475f, -0.07869759f, 
    -0.17057982f, -0.01296599f, -0.06105166f, 0.06706172f, 0.47485903f, -0.23718469f, -0.71641070f, -0.73205727f, 
    -0.32327056f, -0.53779459f, -0.07238439f, -0.36393055f, 0.03630717f, 0.04387182f, 0.01129606f, 0.01665538f, 
    -0.35679793f, 0.24818392f, 0.07934806f, 0.29658645f, 0.17573653f, -0.09822953f, -0.15130678f, -0.06293439f, 
    -0.15202320f, 0.26020488f, 0.10357536f, 0.32095322f, -0.19606552f, 0.04559015f, -0.08125184f, -0.15743175f, 
    -0.05880304f, 0.03627247f, 0.07535879f, -0.07111248f, 0.05994503f, 0.14647517f, -0.01095939f, 0.18236966f, 
    -0.36000896f, -0.58938545f, -0.39439970f, -0.01636663f, 0.14796454f, -0.07504488f, -0.15968142f, 0.02764635f, 
    -0.06595506f, -0.00151977f, -0.04536304f, -0.01844092f, -0.11654310f, 0.33041888f, 0.11756046f, -0.07460520f, 
    -0.01808185f, -0.02128012f, -0.18202145f, -0.05261812f, -0.15438926f, 0.00063874f, -0.13403507f, 0.04233208f, 
    -0.10283539f, 0.32011247f, -0.31419399f, -0.41679817f, 0.04236858f, -0.00913895f, 0.03220755f, -0.11793879f, 
    -0.12925567f, 0.10974562f, -0.00399227f, -0.17129536f, -0.57282788f, -0.00366760f, 0.28914687f, 0.41130880f, 
    -0.03906468f, 0.21044597f, -0.21690144f, -0.17224222f, -0.02297331f, -0.06538860f, 0.01566692f, 0.12528837f, 
    -0.15753083f, -0.32120547f, -0.08987094f, 0.22852382f, -0.05394959f, -0.21014321f, -0.01555890f, 0.13624920f, 
    -0.04438077f, -0.28757721f, -0.08978637f, -0.13462454f, -0.51644140f, 0.21996503f, 0.14964616f, 0.16450141f, 
    0.11350124f, -0.13009301f, -0.08921370f, 0.10870484f, 0.01291674f, -0.04382760f, 0.15457448f, 0.02580177f, 
    -0.12222801f, -0.39197338f, 0.05032326f, 0.04459402f, -0.07965002f, 0.07487383f, 0.24692935f, -0.14009076f, 
    -0.08216660f, 0.00092088f, -0.05875374f, -0.17818674f, -0.08853273f, -0.03421789f, -0.05925509f, 0.17647721f, 
    -0.03002919f, -0.20322272f, 0.08939560f, 0.02001842f, 0.12959640f, -0.00934687f, 0.18813285f, 0.21437061f, 
    -0.38729677f, -0.34714893f, -0.19082168f, 0.05885109f, -0.02519900f, 0.15669368f, 0.11962509f, 0.29445532f, 
    -0.09147397f, 0.09796528f, -0.11084899f, -0.09888885f, -0.23509240f, -0.13770731f, 0.03132397f, -0.14698422f, 
    -0.02412030f, -0.02818541f, -0.06132261f, 0.06952576f, 0.00208008f, 0.05089090f, 0.04293364f, 0.01523239f, 
    -0.01798605f, -0.75978601f, -0.41596121f, -0.32762048f, -0.14749396f, -0.01713956f, 0.01452913f, 0.03055370f, 
    0.08040221f, 0.09899225f, -0.04503062f, -0.05194210f, -0.68489999f, -0.35849115f, 0.04730206f, 0.02268406f, 
    0.03681608f, 0.15084380f, -0.00236733f, 0.18185173f, 0.11731200f, 0.23831487f, -0.18076177f, -0.42378634f, 
    -0.33547291f, -0.82040483f, -0.13505091f, 0.35067064f, 0.19938634f, 0.29321158f, 0.20157497f, 0.08704446f, 
    0.05300842f, -0.04746891f, 0.09557411f, 0.18678190f, -0.34821346f, -0.19599187f, -0.01539968f, 0.31654930f, 
    0.00137592f, -0.07360550f, 0.01290100f, 0.16604625f, -0.33509195f, -0.00500066f, -0.01109133f, -0.25862789f, 
    0.04071947f, -0.31434894f, -0.33340856f, 0.17018712f, 0.07182567f, 0.11818285f, 0.16672494f, 0.11913636f, 
    0.02565006f, 0.02531822f, 0.03585592f, -0.17431436f, 0.55628502f, 0.12741593f, -0.11934057f, -0.23125945f, 
    0.04403998f, -0.00125028f, 0.04646719f, -0.14319108f, 0.07108090f, -0.03982349f, 0.06196133f, -0.01167770f, 
    -0.01510681f, -0.32730535f, -0.09301711f, -0.14970924f, 0.06783991f, 0.14760888f, 0.06270747f, 0.10547856f, 
    0.10170846f, 0.33936664f, 0.10917623f, -0.09419931f, 0.50307405f, 0.12381312f, 0.21215108f, -0.19772612f, 
    0.05211423f, -0.20266683f, 0.02511350f, -0.21001390f, -0.08289191f, 0.15506315f, 0.05757772f, 0.20560418f, 
    0.23570170f, 0.09995095f, 0.00685414f, 0.08299344f, 0.09294706f, 0.10563298f, 0.05911537f, 0.16335268f, 
    -0.08390993f, -0.29733741f, -0.24292932f, -0.43275872f, -0.50624853f, 0.19685137f, 0.11662227f, -0.01210495f, 
    -0.05836253f, -0.10422866f, -0.08056277f, -0.22428642f, -0.05875601f, -0.15818636f, -0.08197590f, -0.11293282f, 
    -0.32939407f, -0.22628982f, 0.00604783f, 0.00243366f, 0.19494183f, 0.09846907f, 0.16478042f, -0.09665102f, 
    0.05396255f, 0.12211470f, 0.17336158f, 0.28649062f, 0.22306605f, -0.00400200f, -0.18149622f, -0.10835814f, 
    -0.09182567f, 0.05069593f, -0.10774051f, 0.11858146f, 0.07428213f, 0.00067628f, 0.04038594f, -0.46135256f, 
    0.18853091f, 0.13200139f, -0.04250998f, -0.14990722f, -0.25205523f, -0.05892463f, 0.06121040f, -0.04236690f, 
    0.20337987f, -0.16922961f, 0.25175107f, -0.09511413f, 0.28534716f, 0.27534395f, -0.12491302f, -0.06120911f, 
    0.30329260f, -0.02135801f, 0.12316524f, -0.12605920f, -0.02133180f, -0.17300154f, 0.10027305f, -0.06569974f, 
    0.21436271f, -0.45718625f, -0.49997926f, 0.24242683f, 0.10628834f, 0.22518797f, 0.16284922f, 0.04981408f, 
    -0.06739932f, -0.06169496f, -0.09900251f, -0.11065529f, 0.15915954f, -0.01227898f, -0.10629291f, -0.16143160f, 
    0.00976403f, 0.02858311f, -0.06376649f, 0.02395963f, 0.00918920f, 0.26794344f, 0.15333197f, 0.22414191f, 
    0.21943505f, 0.10888527f, -0.41224426f, -0.32438761f, -0.14790961f, 0.23217733f, 0.00102434f, 0.02852713f, 
    0.07145149f, -0.05070150f, 0.00810602f, 0.10721735f, 0.44326898f, 0.12193144f, -0.23745216f, 0.01014401f, 
    0.22735591f, -0.01737609f, 0.09575970f, -0.06119496f, 0.07252913f, -0.04248703f, 0.10763180f, 0.30187038f, 
    0.00519816f, -0.00003725f, 0.02784428f, -0.37550673f, 0.11058541f, 0.13087083f, 0.19876023f, 0.08980861f, 
    0.16589509f, 0.13878129f, -0.00638777f, 0.06503167f, -0.39079443f, -0.39058968f, -0.01187890f, -0.13250995f, 
    -0.17610238f, 0.13336660f, -0.09492985f, 0.09816226f, 0.14743169f, 0.02877540f, 0.17382203f, 0.04327925f, 
    -0.27552477f, 0.46174303f, -0.36544165f, -0.11493904f, -0.06259108f, -0.01771879f, -0.07022325f, -0.26564154f, 
    0.22056630f, 0.05101027f, -0.05715853f, -0.10140531f, 0.06104649f, 0.00693602f, 0.17772135f, 0.32959539f, 
    0.00706635f, 0.06420130f, -0.16679342f, -0.22960670f, 0.01049146f, -0.09592461f, -0.03302305f, 0.06322949f, 
    -0.34619534f, 0.29155579f, 0.02606614f, -0.26652905f, -0.19536856f, -0.09920437f, 0.18351617f, 0.32881442f, 
    -0.02674268f, 0.07062830f, 0.00285374f, -0.06976709f, -0.27101102f, -0.33912519f, -0.22018605f, 0.28229719f, 
    0.16952316f, 0.18061106f, 0.17854272f, 0.07496427f, 0.07735021f, -0.18236630f, 0.04258731f, 0.03849525f, 
    -0.48859787f, -0.28151974f, 0.10660534f, 0.00956588f, -0.11405864f, 0.17816013f, 0.09434066f, -0.02102024f, 
    0.07624365f, 0.11826447f, -0.03320829f, -0.20991318f, 0.33357862f, -0.04614014f, -0.08621309f, -0.53963673f, 
    -0.04992730f, -0.09538688f, -0.05833962f, 0.25995326f, 0.02647179f, 0.05518286f, -0.13446826f, -0.06014349f, 
    0.07714214f, 0.12044342f, 0.86772352f, -0.44147834f, 0.00310416f, -0.21661845f, -0.04515670f, -0.10493490f, 
    -0.03248257f, 0.03164318f, 0.05421707f, 0.02100766f, -0.22766674f, 0.77326894f, -0.34668174f, -0.31866837f, 
    -0.06761528f, -0.30636990f, 0.08925758f, 0.04532833f, 0.11033897f, -0.14527801f, 0.06081422f, -0.18641958f, 
    0.10147295f, 0.09617465f, 0.36239457f, -0.12573327f, 0.09612292f, -0.15458860f, 0.02029473f, -0.03804209f, 
    0.05736916f, 0.04431545f, 0.02601035f, 0.03349779f, 0.32674676f, -0.17962265f, 0.46330568f, -0.25638312f, 
    0.14290717f, -0.01383534f, -0.03755767f, 0.10823346f, -0.08558927f, -0.03157027f, -0.09326192f, 0.02843065f, 
    0.06124017f, 0.25883043f, 0.09455534f, 0.01803781f, -0.08915652f, -0.13322246f, -0.26240784f, -0.22823754f, 
    -0.00254408f, -0.12063050f, 0.12764148f, 0.13227902f, -0.08363826f, -0.14645226f, 0.03856613f, -0.03718657f, 
    -0.00933435f, 0.16196911f, 0.09742652f, 0.01271866f, 0.22413005f, 0.05947373f, 0.19482963f, 0.06773787f, 
    0.01428144f, -0.09538566f, 0.37208736f, 0.19684444f, -0.02111666f, -0.23378055f, -0.10661536f, -0.22683452f, 
    -0.19393203f, -0.00749146f, 0.02050821f, 0.05924059f, -0.25710830f, 0.06883980f, 0.03447665f, -0.17480537f, 
    -0.10277368f, 0.07583959f, 0.03116121f, 0.01525741f, 0.09861028f, 0.22372371f, 0.01560201f, 0.29642397f, 
    0.30588374f, -0.30713084f, 0.44828743f, -0.71865046f, 0.15963207f, -0.38753167f, -0.02688162f, 0.09223246f, 
    -0.16550931f, 0.01519385f, -0.05246534f, 0.03264269f, -0.12548733f, 0.53216821f, 0.00491717f, -0.19297510f, 
    0.15624823f, -0.26581511f, 0.07324293f, -0.09848527f, 0.01555904f, 0.17408811f, 0.07107171f, 0.04527964f, 
    0.08243834f, -0.01130167f, 0.50192797f, -0.34018239f, 0.06664385f, -0.13976105f, -0.20142421f, -0.32432243f, 
    0.07946102f, 0.02510447f, -0.08341261f, 0.23550121f, -0.09861377f, -0.66321075f, -0.05511497f, -0.39504188f, 
    0.18063554f, 0.05441106f, 0.02397405f, 0.00300134f, -0.23492843f, -0.15821257f, 0.03101089f, -0.17782825f, 
    0.29583725f, -0.42664784f, 0.18486914f, -0.07325202f, -0.04978846f, 0.01917762f, -0.02212228f, -0.20861238f, 
    0.00016315f, 0.19797461f, 0.03987117f, -0.05914387f, -0.47644743f, -0.09530225f, -0.06740376f, -0.03593099f, 
    0.08093222f, 0.02514226f, -0.14367943f, -0.13425989f, 0.12713803f, -0.07059442f, -0.14643736f, -0.29603541f, 
    0.09698851f, -0.10321270f, 0.11602889f, -0.09242203f, 0.05275120f, 0.04346322f, 0.07142065f, -0.04253224f, 
    0.22241870f, 0.15379247f, 0.13899608f, 0.40161008f, -0.52137357f, -0.18354985f, -0.28892979f, 0.20378910f, 
    0.13589303f, 0.11405495f, 0.12541960f, 0.22691445f, -0.07333759f, -0.10216492f, 0.03999161f, -0.01846239f, 
    0.39562944f, -0.26077387f, 0.15581210f, -0.65371388f, 0.09388895f, -0.47818509f, 0.04896876f, -0.02336816f, 
    -0.18968889f, -0.06542496f, -0.16508338f, -0.08605173f, -0.65186471f, 0.26954636f, 0.05822057f, 0.42115438f, 
    0.03017869f, -0.03608081f, -0.15978567f, -0.09437727f, 0.17841773f, -0.04769623f, 0.12776783f, 0.08992691f, 
    -0.30085230f, -0.30300915f, 0.15352841f, 0.03959234f, 0.00781813f, 0.21825732f, -0.52857018f, 0.06612459f, 
    -0.05411990f, -0.23214187f, 0.08930083f, 0.16661537f, 0.11414283f, -0.25365233f, -0.29285997f, 0.05201782f, 
    -0.11321678f, 0.10261045f, 0.10298725f, 0.00500817f, 0.01156449f, -0.00461782f, 0.02394079f, 0.13016826f, 
    -0.33600432f, -0.14443271f, 0.17226608f, -0.31925219f, 0.16759305f, -0.05328203f, 0.07651333f, -0.08246505f, 
    0.09587237f, -0.00344416f, 0.08633601f, 0.03876531f, 0.03865653f, -0.09838472f, 0.07162268f, 0.13446133f, 
    0.05024818f, 0.13854910f, -0.03419683f, -0.21031632f, -0.01634769f, -0.13962428f, -0.08523356f, -0.31329957f, 
    -0.40237731f, -0.30904686f, 0.13417770f, 0.12658145f, 0.11235660f, -0.04827460f, -0.34368399f, 0.42809254f, 
    -0.04498337f, -0.04106068f, 0.01156559f, -0.02881968f, -0.07054488f, -0.01635833f, -0.47897345f, 0.27930593f, 
    0.19340421f, -0.16624774f, 0.08543392f, -0.27136829f, 0.12507842f, -0.15412737f, -0.10516433f, -0.00741501f, 
    -0.03424816f, -0.61491388f, 0.15544941f, -0.24551442f, -0.15506108f, -0.07842218f, 0.16385768f, 0.13909049f, 
    -0.13098225f, -0.01976661f, -0.14605230f, -0.16301297f, -0.14061847f, -0.42621279f, -0.65415239f, 0.12423827f, 
    0.10270543f, -0.06344000f, -0.11811933f, 0.06480476f, 0.10476759f, 0.10152196f, -0.15873519f, -0.08422896f, 
    -0.01211534f, 0.12208213f, 0.07323894f, 0.06381015f, -0.01411245f, -0.03290021f, 0.21177176f, 0.02653887f, 
    -0.16921310f, -0.10215586f, 0.01094873f, 0.23260909f, 0.05653732f, 0.14256324f, 0.01069517f, -0.19844185f, 
    0.10021431f, -0.30385789f, 0.11633754f, -0.01835761f, -0.11954134f, 0.19513810f, -0.14877224f, 0.07084958f, 
    -0.32021639f, -0.16515343f, -0.40378058f, 0.21482873f, 0.00541549f, -0.25430346f, 0.00908634f, -0.04053409f, 
    -0.00543223f, 0.03693714f, -0.12376885f, 0.01583729f, 0.10475296f, -0.35846385f, -0.14459589f, 0.01233913f, 
    -0.32562813f, -0.10879239f, -0.05211840f, -0.11861492f, -0.08688553f, 0.12100914f, -0.11688655f, 0.05326739f, 
    0.20642830f, -0.60626650f, -0.16069703f, 0.24634859f, -0.24108249f, 0.03632493f, 0.15227668f, -0.10470062f, 
    0.18231367f, 0.00064796f, -0.36478066f, -0.19243462f, -0.03505182f, -0.24069332f, 0.27599692f, 0.17830719f, 
    0.03780068f, 0.05308851f, -0.13707279f, 0.01963789f, -0.04817712f, 0.00059041f, 0.07143515f, -0.04605076f, 
    -0.40238261f, 0.27706459f, -0.21799788f, 0.31893584f, -0.05119102f, 0.18834202f, -0.34683236f, 0.27457976f, 
    -0.12197589f, -0.06996374f, -0.06616034f, 0.01659954f, -0.07701813f, -0.55140436f, -0.13311416f, -0.17580630f, 
    -0.10945902f, 0.08023894f, 0.29690430f, -0.11990873f, -0.32752568f, 0.13520129f, 0.06674918f, 0.03830130f, 
    -0.22605874f, 0.10171486f, -0.09854310f, 0.09412353f, -0.08362596f, 0.00437435f, 0.14993961f, 0.08323432f, 
    0.10355093f, -0.02461905f, -0.00221752f, -0.20342827f, -0.05389000f, 0.32309014f, 0.10717748f, 0.25735468f, 
    -0.17731251f, -0.17047742f, -0.04217282f, -0.08328747f, -0.18202369f, -0.13501450f, 0.12855569f, 0.16730550f, 
    0.25021002f, 0.00102173f, -0.16657363f, -0.05264522f, 0.17363206f, -0.26989433f, -0.03168805f, 0.04171199f, 
    -0.18808255f, 0.20738655f, -0.21248044f, -0.24252371f, -0.10333413f, -0.19728833f, -0.15291549f, -0.52345312f, 
    -0.05332985f, 0.12381028f, -0.00180885f, -0.00209677f, -0.02835433f, 0.08471476f, 0.02333957f, -0.19694640f, 
    -0.29114506f, 0.33359769f, -0.00818693f, 0.22845897f, -0.11185621f, 0.25609562f, -0.03486574f, -0.13864188f, 
    0.05018084f, -0.04202059f, 0.20205244f, 0.05618985f, 0.61699647f, -0.17897364f, 0.24676599f, 0.14195697f, 
    -0.00799612f, 0.06396456f, -0.00197768f, 0.14557457f, -0.05629329f, -0.13845582f, -0.39589307f, -0.23331800f, 
    -0.11626524f, 0.00314154f, 0.04286746f, 0.13494413f, -0.12583274f, 0.02005721f, 0.01823737f, 0.08733837f, 
    0.11061858f, 0.07000561f, 0.04121089f, -0.05553207f, -0.01221073f, 0.15484576f, 0.27517840f, 0.44206730f, 
    0.08840793f, -0.11595239f, 0.18270952f, -0.04765054f, -0.09486704f, -0.22144982f, -0.18362628f, -0.24317741f, 
    -0.14857885f, 0.38584930f, 0.08091935f, 0.11521448f, -0.01453817f, -0.07383142f, 0.18478346f, 0.06902950f, 
    -0.07723821f, 0.00015840f, 0.02672975f, -0.20234589f, -0.72140110f, 0.41637233f, 0.22925420f, -0.01577625f, 
    -0.18509975f, 0.04022066f, -0.18319370f, 0.50836033f, -0.01484062f, 0.00128351f, 0.29052320f, -0.05264739f, 
    -0.12680037f, 0.69662803f, -0.07676961f, 0.21334931f, -0.03406656f, -0.00274290f, 0.24555725f, 0.06166432f, 
    -0.09027839f, 0.00460938f, -0.12490743f, -0.15794949f, -0.41436607f, 0.32865509f, 0.13384123f, 0.32086796f, 
    -0.07944917f, -0.15467271f, 0.46945584f, 0.10046497f, -0.03464812f, 0.19290666f, 0.24342424f, -0.02235435f, 
    -0.16533831f, 0.27721873f, -0.19255576f, -0.07268605f, -0.02333234f, -0.06960240f, 0.09576689f, 0.20357831f, 
    -0.10888930f, -0.29557878f, -0.32094911f, -0.64217198f, -0.08083939f, -0.66580015f, 0.27618629f, -0.15503097f, 
    -0.36063945f, -0.16915140f, 0.06634261f, -0.22406285f, -0.03076321f, 0.04634042f, -0.08794092f, -0.12428596f, 
    -0.06249065f, 0.34215477f, 0.09047751f, 0.13643768f, -0.07476608f, 0.08186121f, 0.27189517f, 0.17311971f, 
    0.18334997f, 0.11293007f, 0.21531527f, 0.24626414f, 0.36515224f, -0.34905082f, 0.44413158f, -0.42595473f, 
    -0.02053423f, -0.09286451f, -0.02131206f, -0.02194405f, -0.16397458f, -0.04880107f, -0.28072450f, -0.29952189f, 
    -0.36006209f, 0.05551344f, 0.25634280f, 0.03349224f, 0.07567326f, 0.10542393f, -0.22716784f, 0.05873743f, 
    -0.06561075f, 0.12327467f, -0.17048837f, -0.09246931f, -0.36317143f, 0.04904256f, -0.16604297f, -0.14795893f, 
    0.13993226f, 0.08792240f, 0.17898144f, -0.14516337f, 0.08669817f, 0.00189419f, -0.19633833f, -0.17214891f, 
    -0.05483434f, 0.01896364f, 0.16073731f, -0.01053740f, -0.10582007f, -0.16826096f, -0.24534282f, 0.01912070f, 
    -0.03879914f, 0.13740624f, -0.09250570f, -0.28362474f, -0.03684032f, 0.20309447f, -0.12276255f, -0.02505755f, 
    -0.13864796f, 0.14418113f, 0.25041434f, -0.11645007f, 0.15413117f, 0.25639334f, 0.09064926f, 0.24988662f, 
    -0.50947326f, -0.01877481f, -0.38913673f, 0.42166224f, -0.10347091f, -0.05965729f, -0.10893885f, 0.18497369f, 
    -0.05962389f, 0.11044877f, 0.04623515f, 0.19464546f, -0.15316252f, 0.47747567f, 0.32612887f, 0.07621806f, 
    -0.06563902f, -0.02249569f, 0.06922899f, 0.04593889f, -0.03676441f, 0.10669050f, 0.06675530f, -0.05860565f, 
    0.22703680f, 0.15009980f, 0.12195124f, -0.14675564f, -0.16313073f, 0.22486179f, -0.14044961f, -0.00606728f, 
    -0.03383551f, -0.01604224f, 0.16558342f, 0.17312011f, -0.08839045f, -0.89622539f, -0.15003556f, -0.00420049f, 
    -0.38567296f, -0.04004465f, -0.09385778f, -0.39096817f, 0.07224204f, -0.05567150f, -0.05773572f, -0.01945075f, 
    -0.05109169f, -0.22068419f, 0.44795588f, -0.05604935f, 0.14247616f, 0.16595303f, 0.13478561f, -0.08222545f, 
    -0.12691438f, 0.13921596f, 0.36448017f, -0.05975465f, -0.31144336f, -0.04079983f, -0.22303507f, 0.13645397f, 
    0.01856683f, 0.01139524f, 0.12401339f, -0.13510446f, -0.02686796f, -0.10153496f, 0.07075032f, -0.03125928f, 
    -0.24835472f, -0.54818332f, 0.08326894f, -0.51756334f, -0.17661622f, -0.14818947f, -0.22841465f, -0.25023699f, 
    -0.02730313f, -0.01128800f, -0.10066554f, -0.04407028f, 0.18773529f, 0.23229741f, 0.32958159f, -0.14761905f, 
    -0.12843025f, 0.07568857f, -0.09897182f, -0.06012779f, -0.15268309f, -0.06484488f, 0.03794919f, -0.20043467f, 
    -0.35887250f, -0.15084483f, 0.19765088f, -0.00918073f, -0.11416002f, 0.24609187f, -0.22363231f, -0.01073088f, 
    0.09267299f, 0.18080962f, 0.21175520f, 0.22037725f, 0.36208728f, 0.05914100f, 0.12167093f, 0.18581088f, 
    -0.21280159f, 0.12476184f, -0.38592559f, -0.04093479f, -0.02357432f, 0.08486340f, -0.01846668f, -0.09706428f, 
    -0.13794920f, -0.51902390f, 0.07528660f, 0.38640973f, -0.08642931f, -0.04289598f, 0.07152809f, 0.15532972f, 
    -0.06541985f, 0.19975775f, -0.11699666f, -0.19104655f, 0.60145134f, -0.47221178f, 0.82520884f, -0.22912876f, 
    0.24379459f, 0.12042277f, -0.09066593f, -0.03754913f, -0.16978508f, 0.02337802f, 0.11082459f, 0.28708991f, 
    0.06136189f, 0.18344910f, -0.60723901f, -0.49163395f, -0.29367518f, -0.30072784f, 0.14183457f, 0.05918893f, 
    0.01761437f, 0.11952085f, 0.02215729f, 0.01421100f, -0.26501513f, 0.03450612f, 0.12426122f, 0.01830101f, 
    0.21564111f, 0.24260822f, -0.07917627f, 0.23305795f, -0.36467361f, -0.02968734f, -0.07417642f, -0.33464852f, 
    -0.24819073f, -0.01500443f, -0.20500126f, -0.03467441f, 0.05805587f, -0.02860878f, 0.18704654f, -0.07728529f, 
    -0.10286427f, 0.07340907f, -0.05010298f, 0.01847289f, -0.04899342f, 0.08116629f, -0.26414415f, -0.03152284f, 
    -0.04186168f, 0.10252154f, 0.04843237f, -0.01474864f, 0.02897299f, 0.11840796f, -0.05177217f, -0.02816164f, 
    -0.44891256f, -0.32538983f, -0.14460605f, 0.32492775f, -0.11679927f, -0.14320430f, -0.08670839f, 0.00348140f, 
    0.10464226f, -0.13551664f, -0.07106707f, -0.25381392f, -0.60079253f, 0.08996366f, -0.15243290f, -0.42860243f, 
    -0.02313215f, 0.04240720f, 0.04636264f, -0.10492883f, 0.09482273f, -0.02708691f, 0.02713621f, 0.11929969f, 
    -0.25349358f, -0.11717266f, 0.02999752f, -0.45871940f, -0.22278510f, -0.07528548f, 0.00080211f, 0.13656825f, 
    -0.16153494f, 0.05045719f, -0.09526233f, -0.15766646f, -0.01699007f, 0.03925041f, 0.49723530f, -0.47162136f, 
    0.02743690f, -0.02100819f, -0.11764897f, 0.34950271f, 0.08865899f, 0.34531441f, 0.21810673f, -0.05195649f, 
    -0.07039104f, 0.05838937f, -0.26084614f, 0.12988451f, 0.08168557f, -0.05378934f, 0.07973078f, 0.10093324f, 
    0.09466614f, 0.10025437f, -0.00436309f, -0.08877654f, -0.01193070f, 0.35814884f, -0.13864626f, -0.04079542f, 
    -0.08468013f, -0.10073136f, 0.07352643f, 0.18876587f, -0.01804353f, 0.01993348f, -0.04938379f, -0.10788982f, 
    -0.60554165f, 0.35440880f, -0.43262604f, 0.28631064f, 0.09855983f, -0.17365709f, -0.03470400f, -0.06203434f, 
    -0.13554601f, -0.05134482f, -0.06515562f, 0.03840526f, -0.00328772f, 0.17172588f, -0.05704574f, 0.10332649f, 
    0.15396252f, 0.05990673f, 0.09849107f, -0.01101675f, 0.07802282f, -0.01912540f, 0.05841841f, -0.13503502f, 
    -0.03836915f, -0.10973813f, -0.00621252f, 0.16158101f, 0.15610994f, -0.22188023f, -0.05259434f, 0.11352713f, 
    0.21517570f, 0.17066808f, -0.00214250f, 0.14708354f, 0.60258293f, 0.15926652f, 0.34509557f, -0.46637914f, 
    -0.10277086f, 0.00188671f, -0.21442845f, 0.14853214f, -0.09988143f, 0.10886794f, -0.13852803f, 0.01433891f, 
    -0.26818410f, -0.02254268f, -0.32786882f, 0.09663249f, -0.00917332f, 0.22892465f, 0.00442108f, 0.14206651f, 
    -0.25107673f, -0.18306288f, -0.06570965f, -0.21947604f, -0.02934863f, -0.15891935f, 0.02079160f, -0.09061899f, 
    0.23537818f, 0.19896993f, 0.28770199f, -0.21212037f, 0.19486250f, 0.03100915f, 0.37551335f, 0.08916250f, 
    -0.61393207f, 0.28578538f, -0.73553318f, 0.29597262f, 0.24296597f, -0.09205219f, 0.18384530f, -0.01609444f, 
    -0.06227154f, 0.01331885f, -0.16956241f, 0.30669734f, 0.30795330f, -0.32507518f, 0.36309892f, 0.41858137f, 
    0.10506961f, -0.26663747f, 0.36583924f, -0.06471633f, -0.00202580f, -0.00362546f, -0.03721846f, -0.02657249f, 
    0.40608299f, 0.10912275f, 0.37175575f, -0.55174285f, 0.04597826f, 0.11075705f, 0.17715944f, 0.07230596f, 
    0.07620557f, 0.03934779f, 0.20531783f, 0.07216163f, -0.07955345f, 0.02895442f, -0.31447870f, 0.00297318f, 
    0.15878935f, -0.06825134f, -0.17095366f, 0.15069680f, -0.09217728f, -0.22826877f, 0.02270363f, -0.09351342f, 
    0.02855651f, 0.09225944f, 0.33566004f, 0.07383486f, -0.06893690f, 0.01709097f, -0.32708201f, 0.03734668f, 
    0.01077113f, -0.04975126f, -0.02196413f, -0.14008740f, 0.43468115f, -0.43910173f, 0.39961502f, -0.23596358f, 
    0.18125336f, -0.04984786f, 0.07284388f, 0.26820830f, -0.03278857f, 0.26291117f, 0.25204509f, -0.17044650f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.23897231f, 0.17500313f, 0.10290041f, -0.12935613f, -0.15824845f, 0.12214637f, 0.05120446f, -0.16807270f, 
    0.06555780f, 0.00917387f, 0.02934684f, -0.03581181f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
