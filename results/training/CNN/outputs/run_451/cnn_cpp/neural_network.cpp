#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.57245123f, 1.17411125f, 0.42897502f, 1.65626979f, 1.87879479f, 0.88515341f, -0.29057273f, -0.63641965f, 
    0.36112627f, -0.05155071f, -0.38043514f, -0.08601762f, -0.02707629f, 0.33508080f, -0.07806841f, 0.14246358f, 
    0.00098360f, 0.34890828f, -0.05817243f, 0.30910930f, 0.25109294f, 0.08340898f, 0.19017404f, -0.26241741f, 
    -0.14399806f, -0.05618312f, -0.79987890f, -1.28166056f, -0.48248318f, -0.54173458f, 0.68657207f, 0.05851628f, 
    0.05944075f, 0.95217061f, 0.81684536f, -0.52232289f, -0.52920520f, 0.22671622f, -0.31810078f, -0.58218569f, 
    -0.22832005f, 0.27671608f, 0.27888396f, -0.00638023f, -0.25975823f, 0.01029072f, 0.19944797f, -0.29483250f, 
    0.13080710f, 0.15660225f, 0.52316773f, 0.73314947f, -0.84681535f, -0.95462418f, -0.79803967f, 0.36218905f, 
    -0.33909601f, -0.68919975f, -0.24799222f, -1.09607375f, -0.26545161f, -0.63294029f, 0.29810312f, 0.47177359f, 
    -0.40489841f, -0.02988492f, -0.09888299f, -0.50275594f, -0.36175147f, 0.24438785f, -0.06471428f, 0.22551301f, 
    0.33351234f, -0.12531236f, -0.44711939f, -1.23948300f, -0.90093052f, -0.54562491f, -0.52513748f, -0.51816815f, 
    -0.69308597f, -0.63427687f, 0.05727981f, -0.12490889f, 0.17521676f, -0.88272244f, -0.01571033f, 0.01077420f, 
    -0.13721162f, -0.60244089f, 0.28583685f, 0.08360991f, 0.52055204f, 0.27383515f, -0.02667117f, -0.09628076f, 
    -0.06579330f, -0.64906776f, -0.14112182f, 0.53443754f, 1.73169982f, 0.78467536f, 0.58657014f, -0.66953415f, 
    -0.02057643f, 0.64011383f, -0.36951447f, 0.44757104f, 0.80711478f, 0.92847908f, -0.47807503f, 0.32410029f, 
    -0.14195016f, -0.47888252f, -0.31303412f, -0.20818123f, 0.01413517f, -0.46241194f, -0.42696130f, -0.06196010f, 
    -0.41177806f, -0.17803738f, 0.08926911f, -0.29071632f, -0.45041087f, -1.65024328f, 1.24950457f, -0.03624484f, 
    -1.06605673f, -0.53007030f, 1.01771200f, 0.43799138f, 0.20974343f, 0.96391833f, 0.93104953f, 0.02976991f, 
    -0.32291433f, -0.58125865f, 0.07125905f, 0.00945084f, 0.08232134f, 0.17901471f, -0.27225980f, 0.08350150f, 
    0.07850768f, -0.31868139f, 0.17505972f, -0.03601129f, -0.10807477f, -0.10816702f, 1.22202814f, 1.04166603f, 
    -0.13594952f, -0.76828331f, 0.81178683f, -0.71382660f, -1.34807110f, -0.02155160f, -0.14467800f, 0.17868797f, 
    -0.13828194f, 0.49546212f, 0.14675348f, 0.29639304f, -0.10620275f, 0.26818302f, 0.26699406f, -0.07331719f, 
    0.61518425f, 0.76894653f, -0.11784041f, 0.41999784f, -0.24369472f, -0.10975097f, 0.60375971f, 1.09403396f, 
    0.64555752f, -0.75881892f, -0.04691248f, -0.10406546f, -1.11200714f, 0.59145832f, 1.06994176f, 0.77652580f, 
    -0.11699358f, -0.29781970f, -0.21384019f, 0.30373994f, -0.22743177f, 0.62854218f, -0.18366818f, -0.49226835f, 
    0.25562173f, -0.14994077f, 0.32825720f, 0.56325299f, 0.15832472f, -0.31658119f, -0.01696409f, -0.37531325f, 
    -1.59679329f, 1.52016377f, -0.34351858f, -0.66145921f, 1.00011325f, -0.53689677f, 0.80702984f, -0.01129639f, 
    -0.39962903f, -0.82905751f, -0.30990034f, -0.19849175f, 0.40487960f, -0.07242442f, 0.20111518f, 0.06608482f, 
    0.00130039f, -0.25266314f, 0.18020657f, 0.15472403f, 0.08978134f, -0.19939098f, -0.09229173f, 0.05512476f, 
    0.07633365f, 0.07279877f, -0.28907779f, -0.15768705f, 0.31032181f, 0.19054401f, -1.73475432f, -0.73056185f, 
    -0.77883130f, -1.04072034f, -0.30050981f, 0.13110954f, 0.72530717f, 0.12893307f, 0.26676446f, -0.69355518f, 
    -0.53494328f, -0.21610267f, -0.20689958f, -0.14598311f, -0.32490122f, 0.07241716f, -0.05723609f, 0.34244898f, 
    -0.12120052f, -0.22378144f, 1.18532300f, -0.46525699f, -1.19853580f, -1.27513075f, -0.79564339f, 0.17047645f, 
    0.94822001f, 0.44003803f, 0.47245032f, 0.04736191f, -0.09807300f, 0.63680959f, -0.74983001f, 0.09828638f, 
    -0.13599432f, 0.02742049f, 0.18129507f, 0.05760048f, 0.17144765f, 0.07369048f, -0.18646744f, 0.23120026f, 
    0.28353688f, 0.01874417f, -0.00077609f, -1.60843849f, -1.21272755f, 0.01332884f, 1.40753210f, 0.60260409f, 
    0.72358233f, 0.62585038f, 0.65439039f, 0.47162551f, -0.74675393f, 0.27497011f, 0.05098920f, -0.01537541f, 
    0.61619556f, -0.00690798f, 0.00860587f, 0.13023290f, -0.18848215f, -0.08287220f, 0.17499597f, 0.11449813f, 
    0.20635751f, -0.04428485f, 0.00518187f, -0.10080212f, 1.21597433f, 0.74351114f, 1.97049010f, 0.70879769f, 
    0.17201397f, 0.26251632f, -0.26480523f, -0.08517028f, 0.28278750f, -0.28554171f, 0.11993980f, -0.01477962f, 
    -0.05877810f, 0.29712358f, 0.31418008f, -0.25774401f, -0.35444015f, -0.12693749f, -0.27596551f, -0.03216255f, 
    -0.34587854f, -0.13773245f, 0.16630551f, 0.05144796f, -0.13253595f, -0.15289778f, 0.23726191f, 0.79561138f, 
    -0.83465856f, 0.40796891f, -0.25233123f, 0.13153549f, -0.13150322f, 0.33061659f, -0.52175581f, 0.57948613f, 
    0.83177775f, 0.33504602f, 0.14809042f, 0.11566752f, 0.79270649f, 0.28291386f, -0.50546706f, 0.20194560f, 
    0.18970136f, -0.17150149f, -0.20740779f, 0.01095840f, -0.07433773f, 0.84911251f, 0.82782173f, 0.73549622f, 
    0.62863594f, -0.83116627f, -0.88070995f, 0.19725318f, 0.20392133f, 0.18007419f, -0.29193690f, 0.17746803f, 
    0.84278905f, 0.28875315f, -0.13365470f, 0.52440327f, -0.06541092f, 0.44309586f, -0.38587111f, -0.27778766f, 
    -0.18466957f, 0.41899818f, 0.42300284f, 0.87700939f, 0.02797723f, 0.12835594f, 0.19860034f, -0.80614078f, 
    -1.63808405f, -0.96082199f, -0.15409040f, -0.36001045f, -0.69942403f, 0.56394655f, 0.48364845f, -1.08006668f, 
    0.46896991f, 0.74859220f, 0.20241372f, 0.09201904f, -0.14819403f, 0.30208036f, -0.22771598f, 0.01469024f, 
    -0.08798386f, -0.14974731f, -0.28624058f, -0.11682220f, -0.32679114f, 0.20065181f, -0.19793904f, 0.10583155f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28660572f, 0.04547421f, 0.36697173f, -0.00591205f, 0.09196757f, 0.08191265f, 0.32169086f, 0.41245186f, 
    0.21085568f, 0.45152920f, 0.52269804f, 0.45372120f, 0.56029749f, 0.20144728f, 0.09896148f, 0.29516244f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.37886927f, -0.09165926f, 0.13713805f, 0.56813127f, -0.16345568f, -0.05623267f, -0.03833774f, 0.14517680f, 
    0.09716949f, 0.07894074f, -0.08848965f, -0.07826626f, 0.59736681f, 0.11983631f, -0.41897291f, -0.34268743f, 
    0.24020354f, 0.12281730f, 0.11070400f, 0.06163393f, 0.02750424f, 0.11732396f, -0.04566668f, 0.13834955f, 
    -0.54505283f, -0.06916030f, 0.20826131f, -0.44292539f, -0.26989570f, -0.01491388f, 0.15753254f, 0.03156412f, 
    0.04242650f, -0.11239019f, -0.21638276f, -0.06273366f, 0.08437384f, -0.09279500f, -0.21657398f, 0.13994294f, 
    0.01340540f, -0.05035181f, -0.00093057f, 0.08466942f, -0.19159424f, 0.05214554f, -0.25334921f, 0.14987101f, 
    0.63783062f, -0.12227166f, 0.12365555f, -0.23291259f, -0.12352237f, -0.14007622f, 0.11506044f, 0.21247020f, 
    -0.02596587f, 0.08423915f, 0.07976292f, 0.14432162f, 0.90184355f, -0.02072675f, 0.04626786f, -0.12587146f, 
    -0.05823848f, 0.07667144f, 0.18535893f, -0.20321557f, -0.01323250f, -0.12977453f, -0.00850409f, -0.03701413f, 
    0.19822319f, -0.00116905f, 0.37844443f, -0.73381287f, 0.05692047f, 0.02872290f, -0.02071875f, 0.22434072f, 
    -0.03839440f, -0.18778142f, 0.03328143f, 0.09482955f, -0.73280418f, 0.31508410f, -0.23411576f, -0.14994049f, 
    -0.04331774f, -0.08953462f, -0.18256511f, -0.01853641f, 0.08012555f, -0.02716682f, 0.24746324f, 0.25908223f, 
    -0.28529996f, 0.08445957f, 0.19693936f, -0.11421402f, -0.13066795f, 0.00006039f, 0.01488754f, -0.05352007f, 
    0.01875292f, -0.15310276f, -0.06093598f, -0.02856417f, -0.09626640f, -0.44439125f, 0.09861232f, 0.20123713f, 
    -0.21399316f, 0.05204508f, 0.12860475f, 0.06328162f, 0.02999966f, 0.04611713f, -0.10740013f, -0.08373570f, 
    0.06515826f, -0.08317505f, 0.02510043f, -0.82122207f, -0.06133103f, -0.06031508f, 0.02944947f, -0.20920512f, 
    -0.13837577f, 0.00147190f, 0.00941164f, -0.18165939f, -0.62572330f, 0.22742918f, -0.23458295f, 0.43515360f, 
    -0.02150412f, 0.02879297f, -0.01923626f, -0.07827343f, 0.03458335f, -0.10562994f, 0.04263175f, 0.02831464f, 
    0.29082051f, -0.12578431f, -0.29195118f, 0.16311063f, -0.10134710f, -0.20539683f, -0.07784171f, 0.06114656f, 
    -0.02381303f, -0.18050750f, 0.04413310f, -0.05604286f, -0.44016999f, -0.24266848f, 0.23222674f, 0.02163556f, 
    -0.09341287f, 0.06014914f, -0.28230277f, 0.16328423f, 0.26870349f, -0.01440849f, 0.04689640f, -0.22389139f, 
    -0.50856137f, -0.12663537f, 0.01416374f, -0.12190916f, -0.01170785f, 0.27548185f, 0.00182569f, -0.14022158f, 
    -0.15303229f, -0.04104408f, 0.06343728f, 0.22181995f, -0.69450700f, -0.01452980f, -0.08590353f, -0.02498878f, 
    -0.00989294f, -0.01663038f, -0.15218492f, 0.13296007f, 0.03899989f, 0.08857472f, -0.10211260f, 0.00663299f, 
    0.42893952f, -0.32778063f, 0.12874265f, 0.34501925f, -0.02129678f, -0.14246596f, -0.02927111f, 0.07032219f, 
    -0.01731408f, 0.00851931f, 0.01325893f, 0.02639474f, -0.20789230f, -0.31816226f, 0.03386708f, -0.39517292f, 
    0.22837049f, -0.08098246f, -0.27039263f, 0.12530926f, 0.20516868f, -0.04368992f, -0.02946507f, -0.12032899f, 
    -0.14891519f, -0.56607151f, -0.02360930f, -0.47717997f, 0.04795203f, -0.33104831f, 0.08292614f, 0.18875854f, 
    -0.36526573f, 0.16813467f, 0.03813854f, 0.00785412f, -0.09022096f, -0.12563260f, 0.21320133f, -0.13068929f, 
    0.12690446f, -0.01484527f, 0.05189149f, 0.09374199f, 0.12811998f, 0.15518032f, 0.22617303f, -0.09145719f, 
    0.40350914f, 0.18696468f, 0.36580306f, 0.01581747f, 0.08592194f, -0.19040926f, 0.00294154f, -0.10539228f, 
    0.10300919f, -0.09900055f, -0.00226940f, -0.20748335f, -0.81183344f, 0.06279413f, -0.16994593f, -0.18914928f, 
    0.06858592f, -0.09932335f, -0.13705900f, -0.04975444f, 0.12249133f, 0.16086377f, -0.11643732f, -0.15370171f, 
    0.33365399f, -0.20605734f, 0.19637015f, -0.24152240f, -0.00356024f, -0.05354764f, 0.18048964f, 0.05052646f, 
    0.07479005f, 0.19666371f, 0.05449208f, 0.09079387f, 0.45744544f, -0.26359650f, 0.05821502f, 0.17464879f, 
    -0.08549695f, -0.02173136f, -0.14763388f, 0.20592724f, -0.03533059f, 0.00920015f, -0.29006833f, 0.17374910f, 
    -0.20445426f, 0.09303997f, -0.49583876f, -0.74605811f, 0.07710421f, 0.20692739f, -0.18231015f, -0.13285643f, 
    0.01742337f, 0.11679646f, 0.02518927f, 0.05779871f, -0.39656889f, -0.39935520f, -0.24109039f, -0.04794325f, 
    0.06362581f, -0.17681025f, 0.01932390f, 0.17823428f, -0.08658589f, -0.05062746f, -0.10587770f, -0.13349824f, 
    0.42645141f, -0.68538576f, -0.00712095f, -0.56289208f, 0.28287461f, -0.03321659f, 0.09602432f, 0.08632335f, 
    -0.09550633f, -0.06176348f, 0.03083395f, 0.13080791f, 0.02591511f, 0.31552291f, -0.48248732f, 0.27729917f, 
    -0.02838106f, 0.15361881f, -0.05800594f, 0.11107072f, -0.21457975f, 0.07690954f, -0.08006582f, -0.09780698f, 
    0.18494588f, 0.25845397f, 0.22669803f, 0.30241099f, -0.06018546f, -0.13470510f, 0.17404611f, -0.00156075f, 
    -0.06956533f, 0.02027725f, 0.11585991f, 0.07985789f, -0.34651089f, 0.08209242f, -0.01770319f, 0.05022892f, 
    -0.06278936f, 0.01927196f, -0.02577907f, 0.10067704f, 0.21412310f, 0.08019000f, -0.19383308f, 0.08536674f, 
    0.08226731f, 0.03397669f, -0.18989702f, -0.24157088f, -0.06700285f, -0.03674876f, -0.09472784f, 0.13189496f, 
    -0.06504657f, 0.01133139f, -0.05759060f, -0.06445915f, 0.55420309f, -0.00571527f, -0.26834488f, 0.10530596f, 
    -0.11116127f, 0.05924154f, 0.03550055f, 0.04080087f, -0.15126048f, -0.24606813f, 0.09565131f, 0.03007467f, 
    0.32929465f, -0.44760984f, 0.15906090f, -0.05621538f, 0.21680957f, -0.18526687f, 0.00562138f, -0.23893145f, 
    0.01638655f, -0.03937520f, -0.04992601f, -0.06180459f, 0.01691786f, 0.14465915f, 0.17507400f, 0.49073252f, 
    -0.15386665f, -0.27384377f, -0.04917355f, 0.01044368f, -0.14169285f, 0.00585522f, -0.14596385f, 0.22929248f, 
    -0.84496772f, -0.00842437f, -0.30286163f, -0.60372800f, 0.22509417f, 0.08143509f, 0.08296563f, -0.14386849f, 
    0.07646538f, -0.00512016f, -0.10391811f, -0.16802569f, -0.07086709f, -0.34916958f, -0.40720546f, 0.23603998f, 
    -0.25144324f, -0.19761135f, 0.12435474f, -0.03619071f, 0.06301370f, 0.05534881f, -0.09595757f, 0.05604253f, 
    0.15167673f, -0.06667364f, 0.08534075f, -0.11638120f, 0.05741431f, -0.03975826f, 0.24295107f, 0.13123137f, 
    -0.14923434f, 0.11356883f, 0.03716085f, -0.09295801f, 0.72367537f, 0.38818455f, -0.07010584f, -0.01263338f, 
    0.05128710f, 0.01894813f, 0.13064897f, 0.07439496f, -0.40067312f, -0.00884778f, 0.11335059f, -0.07479967f, 
    -0.35148945f, 0.05294177f, -0.02200527f, -0.27600601f, 0.17058921f, 0.04498928f, 0.34149900f, -0.01812225f, 
    -0.07735351f, -0.08561153f, 0.11444442f, -0.11560332f, 0.23150288f, 0.25529692f, -0.49114197f, 0.20585296f, 
    -0.06291285f, -0.06157274f, 0.17884158f, 0.14565404f, 0.07424078f, -0.13610150f, 0.11128484f, -0.17431603f, 
    0.11689636f, -0.23731621f, -0.37544379f, -0.35693678f, 0.21812429f, 0.07687695f, -0.00876387f, -0.24723063f, 
    -0.04669046f, 0.05139902f, -0.18244362f, 0.06917868f, 0.06991092f, 0.22326887f, -0.33192223f, -0.45001605f, 
    0.00056605f, 0.03280383f, -0.14179666f, -0.15741898f, -0.11736755f, -0.05884679f, 0.08415718f, -0.15488169f, 
    -0.19983357f, 0.02830464f, 0.01106179f, 0.15588713f, -0.29495376f, -0.37893283f, 0.22381175f, 0.06975336f, 
    -0.03119247f, -0.14085831f, 0.07605456f, 0.07347775f, 0.41500327f, -0.34933197f, -0.14886747f, 0.06164271f, 
    -0.23858722f, 0.15023591f, -0.07990585f, -0.09200388f, 0.14343964f, -0.18262020f, -0.09678609f, -0.11403953f, 
    -0.04445136f, 0.25349301f, -0.29508969f, -0.11562100f, -0.20086828f, 0.04435642f, -0.08715867f, 0.10970771f, 
    0.02907092f, 0.11374499f, -0.12703212f, 0.04348248f, 0.36704814f, 0.13524158f, -0.11332670f, 0.15696010f, 
    0.12361553f, -0.11589953f, -0.04636402f, -0.12106257f, -0.04178350f, -0.22970916f, 0.04837117f, -0.44804192f, 
    -0.39526734f, 0.10912590f, 0.11487958f, -0.21220675f, -0.15631056f, 0.03457866f, 0.08377370f, 0.01362183f, 
    0.01905741f, -0.12486818f, -0.06566764f, 0.10088705f, 1.06920111f, -0.28967804f, 0.11382516f, 0.11579935f, 
    -0.40691370f, -0.00599289f, -0.08655821f, 0.04867238f, -0.08310744f, 0.11590664f, 0.11546572f, -0.08844040f, 
    0.15794204f, -0.66744161f, -0.24608310f, 0.44554049f, -0.06456226f, 0.06824923f, -0.09996433f, -0.35649392f, 
    0.02743646f, -0.26660803f, 0.04210722f, -0.03839399f, -0.17702490f, -0.09572619f, -0.05445134f, -0.29566506f, 
    -0.38447991f, -0.04650323f, 0.19227485f, 0.01363073f, -0.06207787f, 0.02988100f, 0.08908562f, -0.02023518f, 
    0.47274736f, 0.12758085f, 0.13325025f, 0.04360066f, -0.05888962f, 0.15263350f, -0.04893791f, -0.02574852f, 
    0.08103665f, -0.11138938f, 0.00498737f, 0.00651907f, 0.11971043f, -0.13679349f, 0.22994885f, -0.10815126f, 
    -0.09313329f, -0.25983688f, 0.03582227f, 0.01326484f, -0.25274962f, -0.07214658f, 0.04062374f, 0.19835052f, 
    -0.54728884f, -0.35507071f, -0.57613057f, 0.13170262f, -0.17791541f, 0.01525012f, 0.11864227f, 0.10354794f, 
    -0.00234118f, 0.21464591f, -0.13032046f, 0.01932581f, -0.44512212f, 0.58463490f, 0.05412582f, -0.45364588f, 
    -0.17538044f, 0.10340003f, -0.13017471f, 0.23240750f, 0.10080682f, -0.15323201f, -0.01153320f, 0.15437898f, 
    -0.02003725f, -0.31238738f, -0.44518462f, 0.07046092f, -0.04474433f, 0.22313210f, 0.22763652f, 0.08117777f, 
    0.09412961f, -0.07662744f, -0.28913382f, 0.02821803f, 0.17427199f, -0.40515876f, 0.05398320f, -0.01143542f, 
    -0.10158497f, 0.04574454f, 0.06468365f, -0.00240356f, -0.33852983f, -0.10593084f, 0.21816194f, 0.14189905f, 
    0.39959890f, 0.70926309f, 0.24572340f, -0.03104477f, 0.08138929f, 0.19800684f, 0.25512868f, 0.23153597f, 
    0.02054588f, 0.00054474f, -0.09687628f, 0.01488473f, 0.03079230f, 0.49264121f, 0.31093952f, 0.21427299f, 
    0.22199993f, 0.26262367f, -0.21172521f, -0.05663069f, 0.11208476f, 0.00106260f, -0.14371537f, -0.10459075f, 
    0.12019029f, -0.33874947f, -0.06662830f, 0.23666772f, -0.16769435f, 0.08462761f, 0.01271627f, -0.02666050f, 
    -0.27306271f, 0.10703213f, -0.12037632f, 0.20721351f, 0.00634047f, 0.05478774f, 0.05538955f, 0.10012507f, 
    -0.19885148f, -0.14760914f, 0.02676204f, -0.00009607f, -0.06476288f, -0.02700640f, 0.11906134f, -0.10567889f, 
    -0.60704869f, -1.03121936f, -0.40392432f, 0.03673830f, -0.15191969f, -0.11840238f, 0.10389239f, -0.08240766f, 
    0.04362656f, 0.02365879f, 0.07358289f, -0.10388813f, -0.27817255f, 0.04315011f, 0.17445171f, 0.17440806f, 
    0.00437811f, -0.13694032f, 0.18935826f, -0.16767436f, 0.07361733f, 0.06885857f, -0.16991717f, -0.35262200f, 
    -0.21818461f, -0.05361508f, 0.17851029f, 0.02704369f, -0.14189550f, -0.33037639f, -0.18735845f, 0.18527552f, 
    0.04700891f, 0.15827180f, -0.10527916f, -0.15439904f, 0.32757023f, -0.22794236f, 0.19296922f, -0.06469001f, 
    -0.07724016f, -0.13417645f, -0.19189686f, 0.06156417f, 0.06595366f, -0.05955206f, -0.07157838f, 0.01754148f, 
    0.45781267f, 0.11060884f, -0.12414940f, 0.18723631f, 0.02591495f, 0.17972526f, 0.07086714f, 0.14762101f, 
    -0.09314586f, -0.08941625f, -0.00464721f, 0.11740033f, -0.86896122f, -0.17603126f, 0.07679012f, 0.45707992f, 
    0.16990460f, -0.06781562f, -0.14234814f, 0.09010723f, -0.19434710f, 0.00875475f, 0.06630640f, -0.11611511f, 
    0.22922288f, 0.16852744f, -0.07473042f, 0.04948128f, 0.01690975f, -0.05394580f, 0.22296564f, -0.12470250f, 
    -0.09150070f, 0.00300063f, 0.00003738f, 0.15477279f, 0.04744608f, -0.15321504f, 0.26894373f, 0.23494411f, 
    0.06199649f, -0.16511056f, -0.23324847f, 0.32150754f, 0.01637053f, 0.04138463f, -0.01065536f, 0.15022567f, 
    -0.48212945f, -0.56285316f, 0.12445971f, 0.07822171f, 0.03718617f, 0.08688710f, -0.09554650f, 0.06034518f, 
    0.03458846f, 0.12594467f, 0.08880576f, 0.18925929f, 0.53449267f, 0.05385739f, 0.08090917f, 0.22049890f, 
    -0.00164734f, 0.03420445f, 0.00827511f, 0.22121508f, 0.09591972f, -0.02411554f, 0.08511730f, 0.16233197f, 
    -0.17111920f, -0.55525196f, -0.17613317f, 0.28793639f, -0.31603336f, -0.16805062f, 0.02820078f, -0.10391037f, 
    0.07094844f, -0.08102087f, -0.04686665f, -0.17279173f, 0.40884507f, -0.33124411f, -0.06314662f, -0.08281226f, 
    -0.08347311f, -0.00010884f, -0.06963307f, -0.44399363f, 0.05262982f, -0.04425777f, -0.02361133f, -0.18408735f, 
    -0.11244065f, 0.31811592f, 0.05995348f, -0.18247157f, 0.03077410f, -0.16011463f, 0.12848194f, 0.00792858f, 
    -0.05484718f, -0.21323104f, -0.08512361f, -0.03859776f, -0.28575417f, -0.32466421f, 0.37395602f, 0.17279898f, 
    0.13664131f, 0.02665938f, -0.13007095f, -0.32933518f, -0.19044803f, -0.01121793f, -0.01479879f, 0.15369162f, 
    -0.63522255f, 0.34382844f, 0.36373204f, 0.06532019f, 0.05031694f, 0.07218786f, 0.03751347f, -0.05145634f, 
    0.07598986f, 0.07169236f, 0.17556743f, -0.10900573f, -0.67020071f, 0.21086623f, -0.19149928f, -0.51321810f, 
    0.01272511f, 0.01822942f, 0.19396748f, 0.11874159f, 0.09062831f, -0.26244175f, -0.02737151f, 0.00443552f, 
    -0.39849949f, 0.04332210f, 0.24638072f, -0.08730679f, -0.02161598f, -0.02616469f, -0.13871659f, 0.21974985f, 
    0.13454492f, 0.02999453f, 0.14900523f, 0.15120137f, 0.09409702f, -0.14570209f, -0.20481966f, -0.17077054f, 
    -0.20548883f, -0.06535520f, 0.13863876f, -0.13884291f, -0.27844536f, -0.01843419f, 0.24865282f, -0.15954664f, 
    -0.16856767f, -0.39322978f, 0.13181271f, -0.23337136f, 0.09955058f, -0.20921814f, 0.01923145f, -0.14376007f, 
    -0.19442013f, 0.05102473f, -0.05885697f, -0.16767134f, -0.59596860f, 0.07367793f, -0.08008377f, -0.06260418f, 
    0.14091071f, 0.11830170f, 0.11925538f, 0.12171014f, -0.07507265f, 0.15318207f, -0.00974554f, -0.02656203f, 
    -0.13376297f, 0.06231497f, 0.41024116f, -0.32903033f, 0.08469414f, -0.00285789f, 0.14445491f, -0.05865379f, 
    0.13592963f, 0.24160403f, 0.04111113f, 0.33348429f, 0.16795959f, -0.15789236f, -0.53187156f, -0.16838230f, 
    0.10975153f, 0.23181495f, -0.13755061f, -0.13343915f, -0.06560236f, -0.26059863f, -0.03545450f, 0.07340095f, 
    -0.06574000f, -0.16011244f, 0.14670059f, 0.27106348f, -0.08300567f, 0.22830121f, 0.08594234f, 0.12842143f, 
    0.31221625f, -0.03584118f, -0.03027741f, -0.23085925f, -0.08844884f, 0.06685426f, -0.08465479f, 0.11746705f, 
    0.31395832f, 0.32281551f, -0.01851847f, -0.22372499f, 0.04421529f, -0.17900084f, 0.10243135f, -0.09843829f, 
    0.31965530f, 0.00151113f, -0.06395030f, -0.05546132f, 0.02938589f, -0.19930933f, -0.19778052f, -0.27558607f, 
    -0.18685222f, -0.39774981f, -0.24784924f, -0.20168974f, -0.14977834f, -0.20519897f, 0.17776242f, -0.08496448f, 
    0.04320961f, -0.16444044f, -0.06610864f, -0.33539355f, -0.09966856f, -0.06996389f, -0.05905758f, -0.11614925f, 
    -0.12931356f, 0.21624254f, 0.28073776f, 0.02875456f, -0.16624157f, 0.01907274f, 0.00129036f, -0.14824718f, 
    -0.22334184f, -0.08209728f, 0.17752628f, 0.24345671f, 0.09030729f, -0.00608245f, 0.15855820f, -0.07920664f, 
    0.01350068f, -0.18007472f, 0.00155990f, 0.06399652f, -0.04521236f, 0.03554862f, 0.08732884f, -0.42376453f, 
    -0.40554073f, -0.36130926f, 0.28900260f, 0.41068414f, -0.06335188f, 0.01902727f, -0.01652148f, -0.06659341f, 
    0.15975647f, 0.15841147f, 0.09744170f, -0.04268927f, 0.00270459f, -0.06442858f, 0.05944396f, 0.34570721f, 
    -0.14680202f, -0.25399286f, -0.00666935f, 0.07984138f, 0.07460375f, -0.22801062f, 0.17507923f, 0.30106255f, 
    -0.11105548f, -0.36404797f, -0.32468981f, 0.09154494f, 0.00671829f, -0.11038893f, 0.04290391f, 0.02324010f, 
    0.19435041f, 0.13511065f, -0.24046981f, 0.15250768f, -0.84877813f, -0.14209148f, 0.13058157f, -0.44087845f, 
    0.14990766f, -0.03289541f, 0.15675409f, -0.22677107f, -0.01472917f, 0.17605415f, 0.05812043f, -0.00844568f, 
    0.11533262f, -0.03274496f, 0.20109387f, 0.58452040f, -0.15509230f, 0.25782469f, 0.24409874f, -0.00888820f, 
    -0.20667577f, -0.08470298f, -0.09655333f, -0.21288332f, 0.06121422f, 0.11196654f, 0.13782008f, -0.19492683f, 
    0.03635963f, 0.13428102f, -0.03159306f, -0.01699448f, -0.31774843f, -0.02632538f, -0.11794034f, 0.56216967f, 
    0.03366751f, 0.33660069f, 0.00068790f, 0.08364042f, 0.06906567f, -0.29957673f, 0.23916480f, 0.03645628f, 
    0.28277266f, 0.21726036f, -0.03678095f, 0.02749138f, -1.10068130f, -0.37094510f, -0.41137818f, -0.16476624f, 
    0.09326807f, -0.05882620f, 0.04500663f, 0.13791914f, 0.21998605f, -0.20133589f, -0.09179178f, 0.14786042f, 
    -0.13066123f, 0.32864118f, 0.28275132f, -0.84203994f, -0.31109658f, 0.18945049f, 0.03238712f, 0.08858847f, 
    0.05079895f, -0.05731081f, 0.01179903f, -0.21743922f, -0.29698464f, 0.15500049f, -0.15628137f, -0.32235175f, 
    -0.38825884f, 0.04024182f, 0.19780068f, -0.25807670f, -0.03775465f, 0.24811704f, 0.04879776f, 0.23656869f, 
    0.25501615f, -0.26188654f, -0.22054863f, 0.38387573f, 0.20081308f, 0.01131980f, -0.16021493f, -0.29858571f, 
    -0.10062760f, 0.02906201f, -0.04176984f, 0.33146080f, -0.44728550f, -0.39054185f, -0.46338755f, -0.40312219f, 
    -0.06744206f, -0.12066169f, 0.00368787f, -0.06296350f, 0.04006693f, -0.05675369f, -0.21220216f, 0.15360914f, 
    -1.13053501f, 0.29963678f, -0.10293739f, 0.48820657f, -0.12544037f, 0.22801296f, 0.11683819f, 0.13271284f, 
    0.02255151f, 0.18189451f, 0.07794906f, 0.29491845f, -0.01925618f, -0.22431637f, -0.30205011f, 0.12284454f, 
    -0.07040805f, 0.05393578f, 0.23816043f, 0.05527334f, -0.27858758f, 0.03894236f, 0.30816224f, 0.02525685f, 
    -0.01944202f, 0.29684308f, 0.14239265f, 0.09011602f, -0.11471940f, 0.15198104f, 0.06945159f, -0.02238728f, 
    0.06239070f, -0.23078199f, -0.10255134f, -0.15761369f, -0.42007959f, 0.06376223f, -0.01425805f, 0.10172126f, 
    0.13829461f, -0.00888502f, 0.10710689f, 0.02034202f, -0.01586677f, -0.16485064f, 0.09684349f, 0.10245168f, 
    -0.11298808f, -0.12418769f, 0.07104975f, 0.24993975f, 0.17714153f, -0.08284408f, -0.00252056f, 0.05859909f, 
    -0.08558732f, -0.07152734f, -0.17504559f, -0.00425913f, 0.10379757f, -0.00009129f, -0.23900393f, -0.10522111f, 
    0.15324606f, 0.11743698f, -0.05141878f, 0.00919672f, 0.03384707f, -0.02983116f, -0.02696606f, 0.00432365f, 
    0.07171590f, -0.16608366f, -0.16767928f, 0.24971479f, 0.19988687f, -0.07898682f, -0.16286083f, -0.05377102f, 
    0.16705868f, -0.09573933f, 0.16678670f, -0.22009298f, 0.52270871f, -0.81716681f, -0.03665251f, 0.07655975f, 
    -0.02352116f, 0.11861512f, -0.10473234f, -0.11413683f, 0.10667692f, -0.08716485f, 0.05736247f, -0.18043980f, 
    -0.18952478f, 0.19337617f, 0.09644461f, -0.04834191f, -0.06377293f, -0.04965298f, -0.02623997f, 0.02697264f, 
    -0.00561353f, 0.14333570f, -0.05554535f, 0.07816028f, -0.22749682f, -0.11237851f, -0.00751890f, 0.28489771f, 
    -0.06062338f, 0.12281620f, -0.11501731f, -0.11246429f, 0.12338414f, 0.07769368f, 0.14336129f, -0.22776459f, 
    -0.51103050f, 0.14490341f, -0.34783924f, 0.38741481f, 0.23753403f, 0.27920419f, -0.10005721f, 0.14806271f, 
    -0.15143572f, -0.39503881f, -0.13154311f, -0.30279458f, -0.09252344f, 0.06242839f, 0.03623919f, -0.30464458f, 
    -0.01610265f, 0.09066434f, 0.05357758f, 0.06655067f, 0.16992824f, 0.08423261f, 0.19840622f, 0.03717382f, 
    -0.88402176f, 0.58937889f, -0.01115639f, -0.17832680f, -0.01989209f, 0.19168834f, -0.03814727f, -0.16463861f, 
    -0.23076566f, 0.06607175f, -0.05844496f, -0.04558464f, 0.39195436f, 0.39992446f, -0.00891570f, 0.41868812f, 
    0.16331412f, 0.30431092f, 0.18624374f, -0.00142684f, -0.22283018f, 0.14915743f, 0.04199104f, -0.17861767f, 
    0.08177343f, 0.50109088f, -0.18684654f, 0.57360774f, -0.06494889f, -0.03631271f, -0.06685621f, -0.05996993f, 
    0.01236716f, -0.07571875f, -0.11216839f, -0.03823083f, 0.22900167f, 0.10554148f, 0.10103310f, 0.30444267f, 
    0.26626632f, 0.15443867f, 0.06648234f, -0.04157403f, -0.09189839f, -0.01341931f, -0.17073055f, -0.10962140f, 
    0.16947164f, -0.01477690f, -0.21475655f, -0.26980126f, -0.13771386f, -0.01346968f, -0.07907216f, 0.00123880f, 
    -0.01770549f, -0.05834951f, -0.04244726f, -0.10410288f, -0.35985279f, 0.26578915f, -0.00972000f, 0.09385606f, 
    0.14621714f, -0.00111678f, 0.01463844f, -0.00970534f, 0.05852264f, -0.01306072f, -0.02980546f, -0.04244604f, 
    -0.16235997f, 0.05472785f, -0.53808212f, 0.07437531f, -0.02172334f, -0.19198674f, -0.28832614f, 0.10733301f, 
    -0.06293882f, 0.01619175f, -0.15031205f, -0.18809307f, 0.12566665f, 0.08949991f, -0.07200824f, -0.28958237f, 
    -0.15298897f, 0.06332832f, -0.03931718f, -0.37290344f, 0.04031023f, 0.04650012f, 0.00466835f, -0.11811625f, 
    0.11507129f, -0.26134789f, 0.25257659f, 0.43659082f, -0.05328482f, -0.07398175f, -0.07097714f, -0.02164121f, 
    -0.05086685f, 0.04872521f, -0.25786135f, -0.00251767f, 0.27019238f, -0.37317929f, 0.00209360f, 0.07276038f, 
    -0.35382026f, -0.16962771f, -0.23089537f, -0.19271360f, -0.01091210f, -0.10244679f, 0.03896939f, -0.01127843f, 
    -0.20176952f, 0.14107926f, -0.00431465f, 0.32662529f, -0.04941197f, 0.07227640f, -0.07736699f, -0.03180608f, 
    0.03095480f, 0.09920964f, -0.10637849f, -0.18605550f, -0.01068482f, -0.63645923f, 0.35050243f, -0.23673511f, 
    0.16555560f, -0.01163713f, -0.12293302f, -0.21499217f, -0.23996726f, 0.02022372f, -0.02433434f, -0.08953733f, 
    -0.09235910f, -0.20789589f, -0.38741326f, -0.48292518f, 0.03609494f, -0.08875273f, -0.03163833f, -0.17640460f, 
    -0.10819617f, -0.04632971f, 0.12267058f, -0.08366481f, 0.19173145f, -0.41845044f, 0.01706181f, 0.22662728f, 
    -0.02191003f, -0.01993075f, -0.06941944f, -0.03078395f, 0.20817724f, -0.27039033f, 0.12113021f, -0.05457221f, 
    -0.01930936f, -0.03642226f, -0.13974427f, -0.07846205f, -0.06257145f, 0.30273157f, 0.09839772f, -0.20338023f, 
    0.05602211f, -0.11219944f, -0.08736393f, 0.05083803f, 0.37532160f, 0.26139241f, 0.41634968f, 0.00180999f, 
    0.03383026f, -0.07120599f, 0.05754503f, -0.15862036f, -0.01539455f, 0.12072629f, -0.15779157f, -0.01806407f, 
    -0.14080001f, -0.22711246f, 0.14612168f, 0.52055925f, 0.21122684f, -0.08421532f, -0.07958612f, -0.01483849f, 
    -0.01898922f, 0.10287809f, 0.20926239f, -0.18404807f, -0.34721223f, 0.08299569f, 0.39486691f, 0.13627389f, 
    -0.15693815f, 0.24074703f, -0.06117573f, 0.28273109f, 0.05777154f, -0.10549692f, -0.19692352f, -0.03396194f, 
    -0.13946868f, 0.03274199f, -0.28165013f, -0.35850644f, -0.09636557f, -0.09587067f, -0.20594241f, 0.08157637f, 
    0.12344304f, -0.17647690f, 0.00478911f, -0.11916387f, -0.37669221f, -0.39085120f, 0.28119189f, -0.58171076f, 
    0.15732090f, 0.17345284f, -0.26106527f, -0.21644554f, 0.07117758f, -0.16499740f, 0.12889530f, -0.24718012f, 
    0.48922861f, 0.26641148f, -0.16122448f, -0.16288684f, 0.16941597f, -0.21212721f, -0.35296470f, -0.09620561f, 
    -0.08762906f, 0.12940526f, -0.37856439f, 0.29144561f, 0.01173922f, 0.17029922f, 0.11980260f, 0.32783699f, 
    0.00256683f, -0.28080723f, -0.00996645f, 0.07240295f, 0.03274979f, -0.08339678f, 0.01390730f, -0.09526029f, 
    -0.33701435f, -0.04603263f, -0.51364750f, -0.36399713f, 0.04205975f, 0.04175631f, -0.41867310f, 0.01418354f, 
    0.07677329f, 0.07000971f, 0.20088398f, 0.16377512f, 0.06229356f, -0.00223560f, -0.09132044f, -0.18890433f, 
    0.18011686f, 0.02767239f, -0.28741679f, 0.17474769f, 0.00895130f, 0.15273452f, 0.03315765f, -0.16116390f, 
    -0.25469214f, -0.08183292f, -0.18473990f, -0.30032814f, -0.11469175f, -0.13245441f, -0.25589511f, -0.34012580f, 
    0.02030045f, 0.08698667f, 0.05238974f, -0.10324879f, -0.10287992f, -0.15031184f, -0.48646367f, -0.66805857f, 
    -0.05574026f, -0.20273922f, 0.18301338f, -0.05074037f, 0.03250215f, -0.06534065f, -0.01792578f, -0.00460868f, 
    0.29101935f, 0.49577641f, -0.29979998f, -0.00907675f, -0.23311529f, 0.28373063f, -0.01697203f, -0.02492799f, 
    0.19782811f, -0.09888300f, -0.11824495f, 0.03440949f, -0.31200939f, -0.42324471f, 0.25625899f, -0.05538411f, 
    -0.12521179f, -0.08734352f, 0.12483273f, -0.18685737f, -0.17548630f, 0.10069682f, 0.08461772f, 0.03936945f, 
    0.11590768f, -0.08296151f, 0.02859297f, 0.20688786f, 0.28455362f, 0.11466650f, -0.17339900f, -0.06131171f, 
    -0.06646743f, -0.07767558f, 0.03470132f, -0.29613853f, 0.09496158f, -0.02529472f, -0.02584377f, -0.15313153f, 
    0.07553384f, 0.00194348f, -0.11111568f, -0.07942274f, -0.11936000f, -0.04542590f, 0.12651025f, 0.31600609f, 
    0.35891470f, 0.40950584f, -0.39835221f, 0.08173481f, 0.07211568f, -0.01513268f, 0.10484142f, -0.00397512f, 
    0.18111666f, 0.02181045f, -0.01258998f, 0.15327919f, -0.20556143f, 0.07395726f, 0.24097469f, -0.24751630f, 
    0.06909012f, -0.00149568f, 0.03187506f, -0.14074430f, 0.11789110f, 0.01236735f, 0.27386719f, 0.24066301f, 
    -0.78861654f, 0.57633370f, -0.52729976f, -0.51303983f, 0.02730560f, 0.07540931f, -0.11066731f, -0.16240163f, 
    -0.16963957f, -0.20012915f, -0.12995580f, -0.10630223f, -0.07368760f, -0.15950187f, 0.20167811f, -0.18985568f, 
    0.33298406f, -0.17746174f, 0.10904840f, 0.15166022f, -0.06505119f, 0.21290426f, -0.08745775f, 0.11797724f, 
    -0.50264442f, 0.10406274f, 0.23904902f, 0.07298893f, 0.03849367f, 0.06076410f, -0.40140262f, 0.01218744f, 
    -0.03940773f, -0.10638994f, 0.09416319f, -0.10813846f, 0.37544504f, -0.08642249f, -0.16343194f, -0.18354279f, 
    0.06283130f, 0.11313615f, 0.15142567f, 0.01169532f, -0.03265503f, 0.08155718f, -0.07397542f, 0.18784039f, 
    0.23249464f, 0.31211537f, 0.02553252f, 0.32776967f, -0.09681883f, 0.14640900f, -0.05612660f, 0.06633448f, 
    0.24340960f, 0.12204964f, 0.12126293f, -0.03991415f, -0.38239771f, -0.76751542f, 0.20260750f, -0.17410645f, 
    -0.06130902f, 0.14664792f, -0.02007721f, 0.02524477f, 0.16202287f, -0.25820333f, 0.15140590f, 0.11590149f, 
    -0.04041047f, -0.00635084f, 0.26510599f, -0.12601638f, -0.14100626f, -0.04045085f, -0.07140646f, -0.01944424f, 
    -0.04885472f, -0.09180795f, -0.15874694f, -0.32791284f, -0.17718072f, -0.04801134f, 0.18951856f, 0.18647872f, 
    0.18032879f, 0.12956026f, 0.06053652f, -0.03818996f, 0.01147106f, -0.09787157f, -0.04767192f, 0.03878630f, 
    1.04487908f, -0.96917653f, -0.41767964f, -0.16968565f, -0.16241087f, -0.20532711f, 0.20605239f, 0.04913205f, 
    -0.27764642f, -0.15060718f, 0.15314762f, -0.19272590f, -0.37243390f, -0.04890295f, 0.07889609f, -0.06677912f, 
    -0.25701168f, 0.04337756f, 0.08086181f, 0.03046932f, -0.15453756f, 0.12145060f, 0.03275223f, 0.12572400f, 
    -0.15105385f, 0.28804192f, 0.14585608f, 0.30855176f, 0.01368659f, 0.07520209f, -0.13024659f, 0.36004746f, 
    -0.25461611f, -0.17653021f, 0.01411765f, 0.00743305f, 0.67763102f, 0.30994281f, -0.41160247f, 0.49279401f, 
    0.13126014f, -0.05047970f, -0.06434309f, 0.12127121f, -0.02565720f, -0.12899105f, 0.09915703f, -0.00164424f, 
    0.27381679f, -0.30605385f, 0.02074008f, -0.48507774f, 0.03064319f, 0.17010634f, -0.08012258f, -0.09959740f, 
    0.10431568f, 0.07191217f, 0.03578975f, 0.05128952f, 0.32288322f, 0.02844138f, 0.09122953f, -0.10969826f, 
    0.05577075f, -0.23884967f, -0.00992604f, 0.07204001f, -0.02656185f, -0.01617427f, 0.02904024f, -0.26715079f, 
    0.31211257f, -0.15510322f, 0.34861338f, 0.03363388f, -0.05491875f, 0.04971367f, 0.02788727f, -0.38991970f, 
    -0.06616456f, 0.08913460f, -0.10992585f, 0.31018183f, -0.24852063f, -0.76357049f, -0.23175485f, 0.01505556f, 
    0.07724774f, -0.00337842f, -0.08782741f, -0.07466511f, 0.07830105f, 0.19928433f, 0.17546099f, -0.25624698f, 
    -1.24450719f, -0.71804398f, -0.46930975f, -0.56683636f, 0.10475987f, -0.42537868f, -0.07739343f, 0.17768966f, 
    0.08150362f, -0.00543353f, 0.11567155f, 0.10515590f, 0.24747261f, 0.12750138f, 0.11714996f, -0.10280419f, 
    -0.17833500f, -0.07953811f, -0.06708324f, -0.24062636f, 0.20143536f, -0.04150462f, -0.09304159f, -0.07997862f, 
    -0.40391007f, -0.20856224f, 0.24740185f, -0.09995180f, 0.10474431f, -0.10477586f, 0.02521484f, 0.11877402f, 
    0.02081360f, 0.13348477f, 0.05842509f, -0.16864838f, 0.09808647f, 0.22944297f, -0.01954410f, -0.24522942f, 
    -0.15742533f, 0.23081991f, -0.25267974f, -0.09209607f, -0.09440555f, -0.03661864f, 0.03403422f, -0.18796226f, 
    -1.12906408f, -0.72504205f, -0.15349370f, -0.13274567f, 0.22008173f, 0.11380927f, -0.04306427f, -0.43779859f, 
    -0.04946947f, -0.40315041f, -0.27837455f, -0.03816425f, -0.15599941f, -0.02614708f, -0.30957034f, -0.18552624f, 
    -0.05307365f, -0.14598052f, 0.03185416f, -0.05101912f, 0.01372607f, 0.03675333f, -0.27491593f, -0.13137434f, 
    -0.36072624f, -0.20564142f, 0.24602945f, -0.11186273f, 0.23212259f, 0.14966027f, 0.10892058f, 0.08929700f, 
    0.07495012f, 0.21503426f, 0.18026754f, 0.25317386f, -0.24940564f, -0.09822305f, 0.12126461f, 0.04061119f, 
    -0.07996471f, 0.24987356f, 0.00032423f, 0.21715406f, 0.01961460f, 0.39536554f, -0.17617647f, -0.01574872f, 
    -0.16480854f, -0.11770877f, -0.35323381f, 0.07166275f, 0.16918606f, -0.01547956f, -0.22680148f, -0.26335543f, 
    0.20164144f, 0.14647891f, 0.16706014f, 0.20880492f, 0.69774663f, 0.24743012f, 0.15516251f, -0.10345242f, 
    0.17934354f, 0.21142595f, 0.26121211f, 0.22365482f, -0.03162281f, -0.00662409f, 0.01197882f, 0.12625760f, 
    0.02387214f, 0.03373586f, 0.17458746f, -0.10672911f, -0.39516640f, 0.02492937f, 0.17658003f, -0.06884968f, 
    0.37536538f, -0.05221430f, 0.00344438f, -0.27841794f, 0.66426522f, 0.28365856f, -0.03349056f, 0.05611988f, 
    -0.02252304f, -0.16819736f, 0.07028242f, 0.38368285f, -0.00799450f, 0.14006034f, -0.09137066f, 0.04441794f, 
    -1.23819363f, -0.28025860f, 0.06317698f, -0.32110286f, 0.15982176f, 0.15082273f, 0.01387132f, -0.11901445f, 
    0.07780790f, 0.10656334f, -0.29779261f, 0.03142093f, 0.06889185f, 0.21203600f, -0.08459529f, -0.23314460f, 
    0.16649191f, 0.05802048f, 0.06868151f, 0.13587493f, 0.17180800f, 0.04287964f, 0.04789590f, 0.51946068f, 
    -0.54422182f, -0.20032625f, 0.11814259f, 0.10087404f, -0.07080771f, -0.04982606f, -0.06548267f, 0.03244933f, 
    0.09575108f, 0.06275464f, 0.13906665f, 0.21007548f, 0.12629567f, 0.17303140f, -0.06418423f, -0.00244952f, 
    -0.12945850f, 0.03295876f, -0.02537407f, -0.00125219f, 0.03276266f, -0.14563155f, -0.08081178f, 0.17130134f, 
    0.42088833f, -0.36865571f, -0.42980558f, -0.14593181f, 0.08737597f, 0.05151952f, 0.02510913f, -0.01123810f, 
    0.03058240f, -0.04322552f, 0.02537963f, -0.04619722f, 0.21141438f, -0.17864271f, -0.21719436f, 0.06940820f, 
    -0.15896812f, -0.15379655f, 0.03851741f, -0.01485356f, 0.14524589f, -0.01539518f, 0.05942828f, -0.15773116f, 
    0.30237505f, -0.12573785f, -0.36706892f, 0.16009001f, 0.06404746f, -0.13034193f, 0.01954451f, -0.01928664f, 
    -0.00605237f, -0.05859969f, 0.07522642f, 0.21113776f, 0.07843460f, 0.53605092f, -0.31670344f, -0.13308957f, 
    -0.50725281f, -0.13386913f, 0.10454799f, -0.21826410f, 0.16437210f, 0.07480774f, 0.02754254f, -0.26204154f, 
    -0.15832907f, 0.03992066f, -0.18006618f, -0.17002092f, -0.01757177f, -0.01921514f, -0.04640670f, 0.11945550f, 
    0.00223272f, -0.13898566f, 0.19003886f, -0.01749663f, -0.55749160f, -0.34854755f, 0.05374334f, 0.13664833f, 
    -0.12643732f, 0.14236681f, 0.08838235f, 0.02776237f, -0.10813338f, 0.25889289f, -0.10642298f, -0.00338049f, 
    0.43711463f, 0.41287255f, -0.48614123f, 0.56585348f, 0.23182864f, -0.10048243f, -0.19780074f, -0.16314515f, 
    0.15084888f, 0.12550749f, -0.18214098f, -0.25161496f, -0.96139747f, 0.60696274f, -0.07887096f, -0.02711277f, 
    0.19148803f, -0.08658436f, 0.04780146f, 0.13910545f, 0.01769420f, 0.04996394f, -0.07571537f, 0.12168012f, 
    -0.37349653f, -0.04257222f, 0.31275862f, 0.26611429f, -0.15621674f, 0.03110767f, -0.04596043f, 0.11695558f, 
    -0.20606209f, -0.26407874f, 0.16353387f, 0.09848594f, -0.06143365f, 0.22545472f, -0.47307551f, -0.06816214f, 
    0.10629960f, -0.07825472f, 0.15586823f, 0.12742902f, 0.09902854f, 0.06758559f, 0.22961766f, -0.14444268f, 
    -0.35149905f, -0.01215010f, 0.10761771f, 0.06315784f, 0.13317353f, -0.02682927f, -0.00984172f, -0.21780501f, 
    -0.27878127f, -0.03301178f, 0.04773976f, -0.06399205f, -0.12781456f, 0.02742989f, 0.35865059f, -0.30429929f, 
    0.08085097f, 0.03225685f, -0.07095461f, -0.04112833f, 0.06497304f, 0.05701481f, 0.06597028f, 0.18829642f, 
    0.58794940f, -0.24018389f, -0.34737870f, -0.33101481f, 0.07618356f, -0.12873781f, -0.13093595f, 0.00403054f, 
    0.19120532f, -0.20812240f, 0.06490766f, -0.07452876f, -0.13870557f, -0.14509396f, 0.12436791f, 0.16083775f, 
    -0.07016727f, 0.02896408f, -0.09461194f, 0.11097489f, -0.23321812f, -0.06852335f, -0.20962025f, -0.33093017f, 
    0.61971176f, -0.51556385f, -0.03393658f, 0.07627184f, 0.02492744f, 0.09858721f, -0.13709818f, 0.01551371f, 
    0.15635660f, 0.02507904f, 0.31385306f, -0.09465680f, -0.26389387f, 0.39669511f, -0.01682591f, 0.24271317f, 
    0.09457117f, -0.03647478f, 0.04165893f, -0.12312095f, -0.21275660f, 0.03713209f, 0.07229753f, -0.09763700f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06627356f, 0.11338327f, -0.03830438f, 0.02269625f, 0.04864600f, 0.00171261f, -0.01185027f, -0.16655846f, 
    0.02527957f, 0.06528045f, 0.19216503f, -0.02161953f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
