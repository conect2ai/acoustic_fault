#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.55993021f, -0.15232946f, 0.12187850f, 0.09489081f, -0.10616469f, 0.23971610f, -0.04669584f, -0.27654105f, 
    0.44839543f, -0.13968864f, 0.34398174f, -0.54878336f, -0.01265126f, -0.06904418f, 0.14463949f, -0.12068877f, 
    0.17062820f, 0.01663727f, -0.07168242f, 0.00856159f, 0.02017657f, -0.24426544f, -0.15960580f, -0.16802257f, 
    -0.44626957f, -0.08334380f, -0.18094234f, -0.49931991f, -0.46240675f, -0.31114140f, 0.15711889f, -0.16050993f, 
    0.12708430f, -0.07094302f, 0.21756735f, -0.14926292f, 0.12481469f, -0.04295088f, -0.25691688f, -0.00892172f, 
    -0.24380617f, -0.23482525f, -0.06106957f, -0.34719631f, -0.25512454f, -0.02698049f, 0.43385547f, 0.34967735f, 
    0.06110559f, 0.43610653f, -0.68745691f, -0.88495523f, -0.30431086f, 0.45907575f, 0.67406046f, 0.69433552f, 
    0.33094946f, 0.28466979f, -0.12916829f, 0.41295624f, -0.19691411f, -0.18230256f, -0.31590933f, -0.23064546f, 
    -0.01454019f, -0.17791574f, 0.27271238f, -0.06693335f, -0.13889328f, 0.08236297f, 0.09084189f, -0.15038045f, 
    -0.27884012f, 0.04166018f, 0.05020190f, -0.13062702f, -0.07667518f, -0.38079888f, 0.05184209f, 0.97641665f, 
    -0.38297740f, -0.06087628f, -0.16234539f, 0.20628884f, 0.67650235f, -0.12911619f, 0.38476571f, -0.30499771f, 
    -0.14534339f, 0.01398296f, 0.05181066f, -0.35192874f, 0.37843674f, 0.06920087f, -0.41188589f, -0.43980950f, 
    0.26114908f, -0.18387467f, -0.26350877f, 0.02253674f, 0.13299724f, 0.61749947f, 0.39093435f, 0.32421073f, 
    0.25368920f, -0.09851000f, -0.35005528f, 0.24210772f, 0.04877269f, 0.06359118f, 0.31896102f, -0.08077102f, 
    -0.19867489f, -0.30155680f, 0.13620028f, -0.03084662f, 0.29766554f, -0.29738376f, -0.08767371f, -0.26379383f, 
    0.06517897f, 0.25182801f, -0.04622832f, -0.14862747f, -0.10182496f, -0.89257586f, -0.06034390f, -0.65667945f, 
    -0.29317722f, 0.45567402f, 0.03189251f, -0.09762122f, 0.72249383f, 0.50626183f, 0.26679677f, 0.51732284f, 
    0.08144230f, 0.25678748f, -0.16894755f, 0.00767015f, 0.12393452f, -0.22357413f, -0.11945505f, -0.29673183f, 
    0.00241425f, 0.02195049f, -0.06950333f, 0.13040930f, -0.07621258f, 0.08288366f, 0.21216014f, 1.06814659f, 
    0.00294631f, -0.43431529f, 0.61321956f, -0.79433537f, -0.47508761f, 0.36589018f, -0.34562358f, -0.46870559f, 
    -0.24818696f, 0.21504699f, 0.17664145f, -0.38652217f, -0.25521746f, 0.20286410f, -0.16542190f, 0.08623298f, 
    0.01879130f, 0.22334307f, -0.17871477f, 0.06869671f, -0.04986950f, 0.24624035f, -0.00249155f, 0.34669840f, 
    0.10538585f, -0.23193024f, -0.11713056f, 0.23011354f, 0.07874458f, -0.36854517f, 0.18105009f, -0.12762485f, 
    -0.18108878f, 0.01042444f, 0.10437623f, -0.45766002f, 0.47612059f, -0.02364855f, 0.12900238f, -0.10328815f, 
    -0.11402034f, 0.14134511f, -0.28587806f, -0.20726322f, 0.44158041f, 0.25130513f, 0.09557114f, 0.32894230f, 
    0.37952751f, 0.67022097f, 0.51262546f, -0.06384441f, 0.31354794f, -0.47598460f, -0.44115707f, -0.17689711f, 
    -0.20601016f, -0.43037429f, -0.32318732f, -0.13948646f, -0.25265568f, -0.02202411f, 0.27100530f, -0.07401714f, 
    -0.08795730f, 0.03529081f, 0.14416224f, 0.27145281f, -0.12265291f, 0.00857126f, -0.30859804f, -0.07877262f, 
    -0.10943209f, -0.50403577f, -0.38519362f, -0.34714726f, -0.38392311f, -0.43200189f, 0.40027392f, -0.52891463f, 
    -0.55564082f, -0.37149391f, -0.45999607f, 0.29688302f, 0.07147203f, 0.19131139f, 0.44465846f, 0.34925705f, 
    0.20497726f, -0.14287652f, -0.24367395f, -0.17197539f, -0.29201981f, -0.29874071f, 0.42660975f, 0.43617538f, 
    -0.28300622f, 0.08911794f, 0.75909209f, -0.58814752f, -0.57602960f, -0.69956911f, -0.95155168f, 1.03789306f, 
    0.82822216f, 0.44295225f, -0.40585849f, -0.00019708f, 0.06607492f, 0.47746217f, 0.01317260f, -0.09360854f, 
    -0.14768641f, -0.06530505f, 0.00793944f, 0.12281144f, 0.02023209f, -0.01073652f, 0.08345752f, -0.03364617f, 
    -0.23171568f, 0.16740289f, -0.14355801f, -0.04208222f, -0.17819555f, -0.00703054f, -0.03001383f, 0.40827554f, 
    -0.28920951f, 0.16157006f, 0.30518255f, -0.28643051f, 0.05862072f, -0.16440155f, 0.12363252f, 0.70916361f, 
    -0.42360875f, -0.36396345f, -0.07269059f, 0.26251593f, -0.02375394f, -0.07553498f, -0.07076360f, 0.30215302f, 
    -0.46078619f, 0.22853579f, 0.24385382f, -0.16860108f, -1.17056930f, 0.26743829f, 0.37576416f, 0.21326999f, 
    0.39322171f, -0.47962815f, -0.52216989f, 0.38939866f, 0.14798719f, 0.29646376f, -0.46097511f, 0.20308420f, 
    -0.40278435f, 0.68270946f, -0.11165961f, -0.01827171f, -0.03191874f, 0.00063700f, -0.31425774f, -0.31033242f, 
    -0.10033256f, 0.25454831f, 0.15432836f, 0.21671587f, 0.07208878f, 0.11146454f, -0.26586613f, -0.45648253f, 
    0.10406907f, 0.43401366f, -0.09606238f, -0.22981805f, -0.05373795f, -0.07284837f, 0.11990391f, -0.33808756f, 
    -0.30571809f, -0.07327800f, -0.05660407f, 0.40842685f, -0.12413066f, -0.16999693f, -0.16639425f, -0.08243287f, 
    -0.22297846f, -0.21637355f, -0.22064039f, -0.29001349f, -0.38520572f, -0.62718838f, 0.56648231f, 0.30799896f, 
    -0.01955791f, 0.29686216f, -0.47229132f, -0.30393943f, 0.14644338f, 0.39917663f, -0.40845910f, 0.14810504f, 
    0.55834466f, -0.14646977f, -0.42891797f, 0.00272393f, 0.21099710f, 0.23691919f, 0.09188022f, -0.24697149f, 
    -0.05847657f, -0.19852157f, 0.07249128f, -0.08467120f, -0.03111841f, 0.22830312f, -0.00371447f, -0.70396101f, 
    -0.42986953f, -0.62425512f, -0.38641420f, -0.49750492f, 0.19789542f, -0.04135012f, 0.38411459f, -0.20994627f, 
    0.08267372f, 0.21233372f, -0.07538925f, -0.21174113f, 0.36255658f, -0.17887890f, -0.22867896f, -0.00995652f, 
    -0.22406206f, -0.20881923f, -0.25994143f, -0.44788203f, -0.12404548f, -0.06724823f, 0.17047644f, -0.00745221f, 
    -0.73519731f, 0.27047932f, -0.74802673f, -0.70719182f, -0.10068168f, 0.21308066f, 0.34465432f, -0.19985127f, 
    0.14090790f, 0.31340680f, 0.17112739f, 0.59671301f, -0.19707203f, 0.03085536f, -0.30410069f, 0.16874209f, 
    -0.00997107f, 0.23388584f, 0.20148194f, 0.10594127f, 0.08955158f, 0.09595339f, -0.25978470f, -0.06716001f, 
    0.07215741f, -0.65262258f, -0.22748818f, 0.20334364f, 0.15326546f, 0.20049998f, 0.31342310f, 0.97057337f, 
    -0.09585197f, -0.09738811f, -0.50486034f, 0.10300561f, 0.31803182f, 0.09999959f, -0.01485035f, -0.24730352f, 
    0.13395679f, -0.50187051f, -0.20546463f, 0.29276100f, 0.27382690f, -0.12941605f, 0.14385585f, 0.21419930f, 
    -0.01480666f, -0.00653002f, -0.43631685f, -0.51476580f, -0.30266884f, -0.43863523f, -0.39299178f, 0.25339460f, 
    -0.33521408f, -0.12067042f, 0.18114886f, 0.02753957f, 0.07269367f, -0.21958728f, -0.23327708f, -0.09619559f, 
    -0.48666471f, 0.03728241f, 0.08283340f, 0.13082942f, 0.26505461f, 0.12994222f, -0.32917371f, -0.47635752f, 
    -0.23819220f, -0.20910160f, -0.27496940f, 0.52024043f, 0.01460505f, -0.11197256f, 0.24671902f, 0.58983743f, 
    -0.31391078f, -0.23272784f, -0.31043395f, -0.12320890f, -0.25763056f, -0.39967880f, 0.09594148f, 0.13391402f, 
    -0.01806421f, -0.06854194f, 0.00394922f, -0.17734788f, 0.11946323f, 0.22167128f, -0.24694365f, 0.27810520f, 
    0.14765771f, -0.09920898f, -0.06477222f, 0.18494642f, -0.60979813f, -0.70321423f, 0.16142125f, 0.53441948f, 
    -0.10250862f, -0.07129796f, -0.40113303f, -0.61004311f, 0.23496008f, -0.67446566f, 0.22651866f, 0.01461044f, 
    -0.34876138f, -0.18630913f, -0.68975645f, -0.35488483f, -0.13716951f, -0.07721797f, -0.20476659f, 0.02560594f, 
    -0.09010243f, 0.14506955f, 0.07791458f, -0.32822782f, -0.12884453f, 0.47160837f, 0.31067252f, 0.39945975f, 
    -0.48188210f, -0.59674817f, 0.34024486f, -0.39377114f, -0.02009787f, 0.59523439f, -0.14844571f, -0.06557273f, 
    -0.22113755f, 0.00624699f, 0.43977720f, -0.20459123f, -0.18856955f, 0.27033013f, -0.31399018f, 0.07041150f, 
    0.13005354f, 0.23835385f, 0.17651609f, 0.01211478f, -0.49737653f, -0.45610231f, 0.21825801f, -0.47057286f, 
    -0.14966758f, -0.37173110f, 0.43020537f, 0.26872337f, 0.25683805f, 0.38633111f, -0.37132794f, 0.07094763f, 
    0.15979181f, -0.27231464f, 0.13390130f, 0.12969163f, 0.17788276f, -0.22969800f, 0.24708754f, -0.20289235f, 
    -0.30545136f, -0.14357385f, 0.22851551f, -0.31316450f, 0.28379017f, 0.06599625f, 0.17970295f, 0.07187903f, 
    0.25860387f, 0.12620665f, 0.21017772f, 0.11026499f, 0.22686607f, 0.07166395f, -0.23187596f, -0.09809466f, 
    0.08070635f, 0.25843915f, 0.25499314f, -0.02179008f, -0.42311755f, 0.21332636f, -0.16230515f, -0.05086320f, 
    -0.09452584f, -0.13365674f, 0.20535100f, 0.23650922f, 0.12808371f, -0.07451707f, 0.17693773f, -0.27329907f, 
    -0.07666325f, 0.20535912f, -0.16812283f, -0.16613263f, -0.08062930f, 0.12871812f, 0.16657972f, -0.01198297f, 
    -0.24709551f, 0.08515598f, 0.43923432f, -0.47928736f, 0.43248197f, -0.18687813f, -0.12443080f, -0.11363006f, 
    0.06267770f, 0.14056365f, -0.07325232f, 0.09713697f, 0.01057700f, -0.33850664f, 0.28936133f, 0.19875498f, 
    0.03001424f, -0.73333186f, -0.25814718f, -0.58225715f, -0.20578606f, 0.06735855f, 0.28057259f, 0.00516680f, 
    0.06679580f, -0.34662566f, -0.39939520f, -0.18181968f, -0.23423305f, -0.17808767f, -0.33955565f, -0.06287939f, 
    -0.27681673f, -0.17422706f, -0.24481548f, -0.36846635f, -0.49948567f, -0.00866086f, 0.02744063f, 0.09528915f, 
    -0.31296045f, -0.23399216f, -0.65559429f, -0.30732197f, -0.48789623f, -0.25047782f, 0.01016625f, 0.08848448f, 
    0.07945539f, -0.34425750f, -0.17069371f, -0.34109235f, -0.45301172f, -0.27055281f, -0.08080885f, -0.40249124f, 
    -0.40296569f, 0.08864182f, 0.29978418f, -0.17356424f, 0.14235313f, 0.09639282f, 0.06572539f, 0.10821299f, 
    0.15501113f, 0.13082989f, 0.12681645f, 0.29761878f, 0.00703264f, -0.60768718f, -0.47210371f, 0.64314109f, 
    -0.55197120f, -0.33560476f, -0.34250659f, -0.54430032f, -0.19476290f, -0.04834494f, 0.01420268f, 0.19711529f, 
    0.02871384f, -0.00299842f, -0.29164430f, 0.00856380f, -0.45868692f, 0.10799580f, 0.04378118f, -0.22158353f, 
    0.13272372f, -0.04004845f, 0.18929580f, 0.31153584f, 0.14815888f, 0.90822887f, 0.37885782f, -0.42426586f, 
    -0.64413685f, -0.52781266f, -0.46291032f, -0.13372955f, -0.35224354f, -0.48881787f, 0.22833942f, 0.32289556f, 
    -0.06254510f, 0.20267825f, 0.22562881f, 0.04113350f, 0.08662543f, 0.11543883f, -0.17481662f, -0.16102210f, 
    0.27340513f, 0.06912392f, -0.08815300f, -0.14764507f, -0.08717304f, -0.25612241f, -0.02719389f, -0.41858068f, 
    -0.04470117f, -0.17716123f, -0.05956780f, -0.34774867f, -0.13904457f, -0.25264961f, 0.06449647f, 0.46838665f, 
    0.17442401f, 0.37523475f, -0.16291192f, 0.13787764f, 0.24178037f, 0.33479518f, 0.20940234f, -0.03174404f, 
    0.19936243f, -0.04469823f, -0.47427306f, 0.14082797f, 0.18644859f, -0.43702027f, 0.40565601f, 0.45662996f, 
    0.25727659f, 0.14072439f, -0.18812954f, -0.18747579f, -0.03260384f, 0.09065630f, -0.05901077f, 0.04569727f, 
    0.33547273f, 0.22488265f, -0.09375747f, -0.48975921f, -0.07112388f, -0.11728806f, -0.03272162f, 0.17383976f, 
    -0.02544868f, -0.22989789f, -0.08242743f, -0.26418376f, -0.26490226f, -0.13952371f, -0.56153291f, -1.05879319f, 
    0.29799896f, -0.30667865f, -0.78949475f, -0.48727655f, 0.85741979f, -0.20234835f, -0.02946960f, 0.45283180f, 
    0.30650446f, -0.35549945f, -0.58390743f, 0.09473763f, -0.31345508f, -0.16778386f, -0.01436707f, -0.17163269f, 
    0.03620153f, 0.13663001f, -0.01385184f, -0.12460059f, 0.20457940f, -0.15793845f, -0.10977052f, 0.13451667f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29182684f, 0.25467101f, 0.06558646f, 0.27919593f, -0.12700494f, 0.26406485f, 0.23350012f, 0.11644152f, 
    -0.04635309f, -0.00523892f, 0.56507319f, 0.30712992f, 0.16063733f, 0.00264223f, 0.43781695f, 0.16136254f, 
    0.31278843f, 0.22054388f, -0.13371816f, 0.13630159f, 0.32886416f, 0.00360822f, 0.06928714f, 0.29673371f, 
    0.09427584f, -0.17274997f, -0.14371458f, 0.05504673f, 0.05066481f, 0.03898591f, 0.06854085f, 0.25185710f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12305104f, -0.00532064f, 0.03383307f, -0.10222211f, 0.01241811f, 0.05844837f, -0.01551698f, 0.04437602f, 
    0.31266525f, 0.11128543f, 0.09186497f, 0.11726767f, -0.15987615f, -0.15035781f, 0.01687777f, 0.22512166f, 
    0.13336016f, -0.06811106f, 0.06260864f, -0.00189829f, 0.15486972f, 0.10704858f, 0.14496563f, 0.06547516f, 
    -0.11413851f, 0.40236047f, 0.06406402f, -0.36392784f, 0.11735764f, -0.01974208f, 0.02117567f, 0.06530225f, 
    -0.16109599f, 0.14933202f, 0.09592742f, 0.14683835f, 0.43875101f, -0.15222511f, -0.05715504f, -0.03293650f, 
    0.12668593f, -0.12373243f, 0.02803192f, 0.08963904f, 0.16810663f, 0.13065024f, 0.23435274f, 0.18972664f, 
    -0.06569695f, -0.09274273f, -0.00255615f, -0.27077550f, -0.11214405f, -0.19026837f, -0.10652134f, -0.09841862f, 
    0.07340690f, -0.15331234f, -0.05248001f, -0.17066570f, 0.35665733f, 0.01537545f, -0.06588157f, -0.11694580f, 
    -0.04340831f, -0.07883883f, 0.13139272f, 0.03446719f, 0.22193111f, 0.15358388f, 0.00988338f, -0.06697021f, 
    -0.02727116f, -0.06551356f, 0.34649387f, 0.15929213f, 0.00441365f, 0.11049752f, 0.17730327f, 0.11099627f, 
    0.03195382f, -0.02784366f, 0.04470446f, -0.02775920f, -0.24843924f, -0.13539562f, 0.08044208f, -0.28028738f, 
    0.04073348f, 0.09119582f, -0.09633198f, 0.07485265f, -0.06991185f, -0.08706398f, 0.15030265f, 0.05057555f, 
    -0.09972633f, -0.03120932f, 0.33688211f, 0.21570441f, -0.03442927f, 0.18928984f, 0.13449177f, -0.03659333f, 
    0.05612623f, -0.04772237f, 0.01675457f, 0.03960285f, -0.24808756f, -0.24062386f, 0.00097359f, 0.06548727f, 
    0.10827578f, 0.03163272f, 0.09306318f, 0.15650892f, -0.00915857f, -0.01063161f, -0.01625904f, 0.05447762f, 
    -0.59906685f, 0.35295025f, 0.33140925f, 0.39649928f, 0.07787482f, 0.01874330f, 0.23314664f, -0.01552504f, 
    0.06013031f, -0.05180915f, 0.02876582f, 0.06188611f, 0.01741987f, 0.13960205f, -0.28099874f, -0.12034850f, 
    -0.00397968f, 0.10421258f, -0.00703611f, -0.02278490f, -0.10714397f, 0.20377934f, -0.08716246f, -0.11624200f, 
    0.91209471f, 0.21651813f, -0.18836527f, -0.02284847f, -0.17347997f, 0.01786942f, -0.06057991f, 0.08719548f, 
    -0.09833902f, 0.22000790f, 0.12115030f, 0.09454186f, 0.00221497f, 0.05284609f, -0.05650254f, 0.18745051f, 
    0.05859864f, 0.04545764f, 0.00404329f, 0.15375260f, 0.24306537f, 0.08074618f, 0.13465211f, 0.17039502f, 
    0.15599699f, 0.13413650f, -0.17969763f, -0.05846257f, -0.01899141f, -0.25662810f, 0.04138731f, 0.02251304f, 
    0.02098750f, -0.01332357f, -0.09351000f, 0.03809479f, -0.28885975f, -0.00368644f, 0.07325463f, 0.12158395f, 
    -0.01809926f, -0.01386353f, 0.06525408f, 0.21077003f, 0.06632673f, 0.06848612f, -0.07802978f, 0.08756615f, 
    0.17272869f, -0.01169262f, 0.03820669f, 0.35426751f, 0.15143825f, 0.03668121f, 0.30451024f, 0.17418076f, 
    0.01389898f, -0.04106078f, 0.00068497f, -0.08277528f, -0.00185063f, 0.09524676f, -0.09577698f, -0.11678702f, 
    -0.23297070f, -0.03167001f, -0.08075398f, -0.06514604f, -0.01830493f, -0.10151713f, 0.20006734f, -0.08987237f, 
    -0.18888101f, -0.30449948f, -0.04316638f, 0.14146586f, 0.00819688f, 0.05145955f, 0.08202122f, 0.13495994f, 
    -0.08539584f, 0.04844649f, -0.00288477f, 0.12743114f, -0.28866196f, -0.18968128f, 0.16889924f, 0.02406945f, 
    0.08374511f, -0.03115798f, -0.01126694f, -0.07678927f, -0.06638705f, 0.00589884f, -0.06362413f, 0.07155105f, 
    -0.15313607f, -0.11572771f, 0.16347253f, 0.21537486f, 0.03551655f, 0.22866036f, 0.00505608f, -0.08615533f, 
    -0.09847324f, 0.11110046f, 0.21855475f, 0.23005714f, 0.02372728f, 0.32208806f, 0.22193135f, 0.17914386f, 
    0.04146451f, 0.17840292f, -0.08068611f, -0.23268284f, 0.06759560f, 0.10785607f, 0.03516305f, 0.10674198f, 
    -0.18928689f, 0.17110348f, -0.02262506f, -0.27337512f, -0.03599353f, -0.05526859f, 0.00806459f, 0.09382306f, 
    -0.03116332f, 0.00534076f, -0.02839329f, 0.14923692f, -0.10434311f, -0.18036655f, 0.07800440f, -0.24131109f, 
    -0.13564780f, -0.04379107f, -0.09655749f, -0.08839753f, -0.09368565f, -0.15314837f, 0.01193704f, -0.08286343f, 
    0.00802506f, 0.09518149f, -0.07395499f, 0.22629797f, 0.11051212f, 0.13523386f, -0.04079894f, -0.07621033f, 
    0.11589967f, -0.08174018f, 0.13789122f, -0.14507326f, -0.13494571f, -0.05372302f, -0.07606668f, -0.06468221f, 
    0.01545933f, 0.05217437f, 0.07424787f, 0.07043821f, 0.02115538f, 0.10354421f, 0.07429196f, 0.03236691f, 
    -0.21554264f, -0.25949332f, -0.17641668f, -0.00493720f, 0.07529747f, -0.04934585f, -0.03717022f, -0.07626279f, 
    -0.08009835f, 0.05241944f, 0.02640983f, 0.09779473f, -0.30100414f, -0.18761583f, 0.20770651f, 0.21282086f, 
    0.21600191f, 0.17975940f, 0.07917114f, -0.08660382f, 0.03520294f, 0.04986130f, -0.05223861f, -0.10086934f, 
    0.08217647f, -0.06112170f, 0.11798663f, 0.10787911f, 0.25422934f, 0.08045736f, -0.04877005f, 0.09560082f, 
    0.00042356f, -0.06436252f, 0.00819982f, -0.07380018f, 0.02072251f, -0.08387933f, 0.04104618f, 0.06062684f, 
    0.14726065f, 0.16189462f, 0.13516390f, -0.05509821f, 0.08579881f, -0.01199363f, -0.04314052f, -0.02916470f, 
    -0.11581989f, 0.07143575f, -0.08563253f, -0.01403708f, -0.01355107f, -0.03821487f, 0.01104243f, 0.05573252f, 
    0.13402265f, 0.24785343f, -0.03094294f, 0.02260948f, 0.36896357f, -0.43754366f, 0.10632489f, 0.29805771f, 
    0.15304032f, -0.10111130f, -0.02433184f, 0.24470317f, -0.04705271f, 0.04939285f, -0.01621626f, 0.13975345f, 
    0.02980351f, 0.02570183f, -0.04213063f, -0.05143119f, -0.03703524f, -0.02626234f, -0.01826709f, 0.00829445f, 
    -0.01495787f, 0.02390588f, 0.04445566f, -0.03959440f, 0.04558771f, 0.00894572f, -0.04083570f, -0.03178737f, 
    -0.03845425f, 0.01188961f, -0.04479064f, -0.03255808f, 0.00404505f, -0.00988867f, 0.00017286f, 0.00040118f, 
    0.04168289f, -0.03009760f, -0.05785973f, -0.00922125f, 0.00305746f, -0.05230740f, 0.01755287f, 0.01946799f, 
    0.01392267f, 0.00307229f, -0.05868416f, -0.04446147f, 0.03676782f, 0.01844309f, -0.01876745f, -0.01227135f, 
    0.03205233f, -0.03748468f, 0.03420264f, 0.02366089f, 0.04113612f, -0.00636064f, 0.00925829f, 0.02068599f, 
    -0.04128964f, -0.05154074f, -0.01439354f, -0.04918827f, -0.01164707f, -0.05037423f, -0.03101853f, -0.04294968f, 
    0.02437053f, 0.03262543f, -0.00015322f, 0.00550676f, 0.03622490f, -0.05586373f, -0.03942508f, 0.02419923f, 
    0.04497955f, -0.03247401f, -0.03202704f, -0.05520629f, -0.00476360f, -0.03302434f, 0.00204462f, 0.00887819f, 
    -0.05535419f, 0.01556664f, 0.02110162f, 0.00503898f, 0.03796945f, -0.01142334f, 0.01294189f, -0.03814530f, 
    -0.00282352f, -0.03144256f, 0.02947799f, 0.02032613f, -0.02878631f, -0.05499437f, 0.03579818f, -0.02983205f, 
    0.00982129f, -0.01575010f, -0.00394066f, 0.00942480f, -0.05651577f, -0.02137094f, 0.00897154f, 0.00951749f, 
    0.00846911f, 0.01161704f, -0.00892455f, 0.02975807f, -0.00800174f, -0.03188970f, 0.04664460f, 0.03063314f, 
    -0.02913469f, 0.05041475f, 0.00954670f, -0.01050579f, 0.00923335f, 0.03160869f, 0.01453460f, 0.00480830f, 
    0.01205864f, 0.02040033f, 0.00077267f, -0.03786059f, 0.03099702f, 0.01808212f, 0.03034498f, 0.04829510f, 
    -0.05872630f, 0.04194575f, -0.05001640f, 0.02678914f, -0.04107529f, 0.02433424f, 0.03178104f, 0.04082845f, 
    0.00339327f, 0.01904120f, -0.00599595f, -0.01883313f, -0.00334381f, 0.01278293f, 0.03119583f, 0.01615662f, 
    -0.03640933f, 0.00594695f, 0.03962903f, 0.00008061f, -0.02144124f, 0.03328825f, 0.01269681f, -0.05988182f, 
    -0.02903008f, -0.01063833f, -0.03713433f, -0.02689353f, -0.03793634f, 0.01894582f, -0.02325658f, -0.02105491f, 
    0.00968310f, -0.01262253f, 0.02609640f, -0.03324258f, -0.04192407f, -0.02738007f, -0.00454954f, -0.02311308f, 
    -0.01381422f, -0.01709205f, -0.01211639f, 0.03029223f, -0.02079952f, 0.05106242f, -0.00183340f, 0.00064707f, 
    0.02102564f, 0.00933507f, -0.00228575f, -0.03623924f, 0.04169672f, 0.00464439f, -0.01915840f, -0.04388912f, 
    -0.04909683f, 0.00297004f, -0.02317086f, -0.04480208f, -0.01861404f, -0.05239261f, -0.01169978f, 0.01109519f, 
    -0.03626849f, -0.00258667f, -0.01964539f, 0.01409284f, 0.00697990f, 0.02359738f, -0.01197317f, -0.01776985f, 
    -0.03056618f, -0.05402958f, 0.03896928f, -0.01333322f, -0.02023478f, 0.03918296f, 0.00986727f, -0.05232800f, 
    -0.05163823f, 0.04018656f, 0.02072725f, -0.03444152f, 0.03293606f, 0.03316090f, 0.03288702f, -0.02887121f, 
    -0.02029570f, -0.00285421f, -0.03175125f, 0.00340503f, 0.00781664f, -0.04613224f, 0.01652396f, -0.01859885f, 
    -0.04896445f, 0.03997244f, 0.03683078f, 0.03487883f, -0.01799814f, -0.00608633f, -0.01085449f, 0.03551205f, 
    0.02445145f, -0.02899003f, -0.04466125f, -0.04721531f, -0.01316645f, -0.01827121f, 0.03011231f, -0.00229034f, 
    -0.00936921f, -0.01708063f, 0.01203207f, 0.04435978f, 0.01695071f, -0.02652092f, -0.02724517f, -0.02836094f, 
    0.00631263f, 0.03184969f, 0.02933473f, 0.00154763f, 0.04900257f, -0.03339798f, -0.04592186f, -0.03302481f, 
    -0.02455406f, 0.00538261f, -0.00819578f, -0.02426722f, -0.04830300f, 0.03998715f, -0.00963114f, -0.01369698f, 
    -0.01998889f, -0.04847026f, 0.01591950f, 0.03202021f, 0.00876248f, -0.00980615f, -0.03646637f, 0.03039944f, 
    -0.05177477f, 0.00478326f, -0.00507724f, 0.04031689f, -0.01810761f, -0.02913458f, 0.00659327f, 0.04112547f, 
    -0.04154859f, 0.03560171f, -0.01649510f, -0.00273786f, 0.03699327f, 0.01579504f, -0.05004200f, 0.02373270f, 
    -0.03954828f, -0.00483299f, -0.00580124f, -0.03553466f, -0.03759362f, -0.05607819f, -0.02163674f, 0.05183429f, 
    -0.05079442f, -0.04526911f, -0.01782571f, -0.03426715f, -0.02810271f, 0.00934739f, -0.02922976f, 0.03886328f, 
    -0.02102589f, -0.04262877f, -0.02713591f, 0.02854969f, 0.02360286f, 0.04623822f, 0.02753645f, -0.00873633f, 
    -0.00149265f, -0.05263545f, -0.00985934f, 0.03835304f, 0.01959224f, 0.03765561f, 0.01529873f, -0.01535209f, 
    -0.00227133f, -0.01805837f, -0.04333049f, 0.02075239f, -0.03294088f, -0.05637374f, -0.02613489f, -0.03404823f, 
    -0.05118411f, 0.02489372f, -0.03030645f, -0.03646491f, -0.00852864f, 0.01757210f, 0.00161287f, 0.01634023f, 
    -0.00923547f, -0.00461428f, 0.01702849f, 0.02956440f, -0.04093167f, -0.03431574f, 0.03838460f, -0.01914462f, 
    -0.03738546f, 0.00987855f, 0.01425681f, -0.01949529f, -0.05951466f, -0.03222848f, -0.03090806f, 0.03997918f, 
    0.00620546f, -0.03322125f, -0.01414938f, 0.01195428f, -0.02422017f, 0.02507764f, -0.03279609f, 0.00489489f, 
    -0.00087196f, 0.00056074f, -0.03269237f, 0.00227108f, -0.03079065f, 0.00208278f, 0.02365435f, 0.01533447f, 
    0.02823767f, -0.05244262f, -0.02666773f, 0.03962980f, -0.02397342f, 0.01360117f, 0.01521663f, -0.00021720f, 
    0.01831082f, -0.00750509f, -0.01810987f, 0.02534508f, 0.02251414f, 0.01662741f, -0.00343103f, -0.02702184f, 
    -0.04770902f, -0.00394377f, 0.03656616f, 0.00723019f, 0.03308187f, -0.01414683f, 0.01785162f, 0.00576838f, 
    -0.16381973f, 0.02914228f, 0.00842181f, 0.05297795f, 0.00849586f, -0.04197054f, 0.02591779f, -0.03880540f, 
    0.17594156f, 0.00556083f, 0.03705953f, 0.13225269f, -0.05912543f, -0.06405074f, 0.01482914f, 0.18075967f, 
    0.00280051f, -0.01449698f, -0.12849022f, -0.10495201f, 0.17164646f, 0.02048901f, -0.04758747f, -0.12609690f, 
    -0.43926495f, 0.43619782f, 0.04902693f, -0.32822588f, 0.17622556f, 0.08783670f, 0.09180844f, 0.03951208f, 
    -0.28731760f, 0.09858280f, 0.05445200f, 0.27835673f, 0.11691178f, -0.16713421f, -0.16250832f, 0.22337618f, 
    0.22848022f, -0.12582013f, -0.11927793f, -0.07706431f, -0.02779625f, -0.11546129f, 0.24334568f, 0.09573147f, 
    -0.15771754f, 0.01862935f, -0.07327124f, -0.14974806f, 0.03809558f, 0.09890101f, 0.03874011f, 0.03935070f, 
    0.13357157f, -0.01404294f, 0.01003467f, -0.12888184f, 0.21648549f, -0.06455306f, -0.12065646f, 0.05808195f, 
    0.11526681f, 0.02448885f, 0.06234833f, 0.12921573f, 0.14857107f, 0.10139142f, 0.05120502f, -0.03821985f, 
    0.31842881f, -0.03061480f, 0.66090840f, -0.00304905f, -0.08741602f, 0.14448944f, -0.19291794f, 0.18268836f, 
    0.13272944f, 0.00288627f, -0.06260699f, -0.06981844f, -0.08937920f, -0.13189764f, 0.08924658f, -0.14036879f, 
    0.15978138f, 0.16066431f, -0.08391588f, 0.14570457f, 0.04634815f, -0.03914258f, 0.13661239f, -0.07217102f, 
    0.18226971f, -0.06822285f, 0.42878127f, 0.06648237f, -0.12625442f, 0.13567081f, 0.16218770f, -0.01287680f, 
    0.10294396f, -0.05101401f, -0.04226721f, 0.08876013f, 0.00982923f, -0.13848281f, 0.09757329f, 0.06516106f, 
    -0.04651731f, 0.01131589f, 0.01673060f, -0.00587921f, 0.09935149f, -0.03362461f, 0.02375365f, 0.07197714f, 
    -0.71885830f, 0.50020915f, 0.24300650f, 0.24156536f, -0.00639471f, -0.10897945f, 0.20929307f, -0.16971940f, 
    0.05807889f, -0.02106204f, -0.00335922f, -0.11329810f, 0.11952497f, 0.15078415f, -0.06042049f, -0.23838158f, 
    0.09908119f, 0.24097444f, -0.06487781f, 0.02815134f, -0.03750036f, 0.00021506f, -0.03502519f, -0.19164218f, 
    0.49847144f, 0.04032477f, -0.28949490f, -0.09219978f, -0.01003366f, -0.01571915f, -0.10670005f, -0.10324286f, 
    -0.19745789f, 0.01500838f, -0.06575861f, 0.02325641f, -0.03560601f, -0.02378793f, -0.15369199f, 0.03550534f, 
    -0.04374381f, -0.06828392f, -0.11221715f, 0.06928392f, 0.06016257f, 0.15393752f, 0.10198665f, 0.19972058f, 
    -0.03817545f, 0.09951248f, -0.19353603f, 0.01391684f, 0.02665178f, -0.19324338f, 0.08309425f, 0.07822954f, 
    0.13949130f, 0.06371246f, -0.04682114f, 0.01014897f, -0.13763402f, 0.01887636f, 0.08661673f, 0.14929707f, 
    -0.00873906f, -0.11716193f, -0.07511854f, -0.10563783f, -0.05131276f, 0.00711482f, -0.06591693f, 0.10248312f, 
    0.26694390f, 0.18416063f, -0.09595459f, 0.21915555f, 0.13351373f, -0.03113673f, -0.05089928f, -0.00991567f, 
    0.13792659f, 0.11131805f, 0.16026990f, -0.04207731f, -0.18124111f, 0.05764994f, -0.23787850f, -0.04415566f, 
    0.00921530f, 0.11886694f, -0.01619135f, -0.03607332f, 0.03649389f, -0.13301983f, -0.02717568f, -0.12456737f, 
    -0.08886186f, -0.20186530f, 0.11039907f, 0.06573882f, -0.04579447f, 0.02532044f, 0.13004686f, 0.11705689f, 
    -0.06964632f, 0.15168764f, 0.07114715f, 0.08230534f, 0.08815652f, 0.01915701f, 0.23416030f, 0.04560442f, 
    0.18208265f, 0.08759824f, 0.00385870f, 0.08080324f, 0.07639617f, 0.06202266f, -0.05950053f, 0.04921986f, 
    -0.18503626f, -0.19778728f, 0.12088181f, 0.25867933f, -0.14201593f, 0.13237728f, 0.00260155f, -0.16195467f, 
    -0.09146153f, -0.06329548f, 0.13088073f, 0.04999435f, -0.08271929f, -0.06445120f, 0.23466936f, 0.28697115f, 
    -0.01226723f, -0.05713942f, -0.00464172f, -0.35968781f, 0.12376403f, -0.08414318f, 0.01373655f, 0.13319784f, 
    -0.19206885f, 0.08985185f, -0.14560920f, -0.04192520f, 0.05501286f, 0.07300569f, 0.09204932f, -0.02709620f, 
    -0.06169143f, 0.03877586f, -0.04269155f, 0.18243930f, -0.17194568f, 0.01972864f, -0.01842227f, -0.25827381f, 
    -0.01741268f, 0.01196736f, 0.03849217f, 0.00392200f, -0.00689942f, 0.03550615f, 0.02890381f, 0.12377848f, 
    0.01959571f, 0.10949958f, 0.00616156f, 0.07991441f, 0.09089524f, 0.15993175f, -0.09445024f, -0.05495774f, 
    0.23278353f, 0.05806461f, 0.04583310f, -0.08268814f, -0.13248532f, -0.00738259f, 0.04055790f, 0.00042661f, 
    -0.13643187f, -0.02216237f, -0.03137102f, -0.25141752f, -0.13503960f, -0.08904463f, 0.01168487f, 0.03574485f, 
    -0.13404439f, -0.17016894f, -0.01804598f, -0.07765134f, 0.02981398f, -0.01715666f, -0.00703561f, -0.04718441f, 
    0.01372332f, 0.03420804f, 0.09979197f, -0.04385847f, -0.06232307f, -0.00957311f, 0.32129627f, 0.05919965f, 
    0.13325818f, 0.22414453f, 0.00528447f, -0.01301946f, 0.07316802f, 0.10399179f, -0.12685291f, -0.11843043f, 
    0.07204483f, 0.12282743f, 0.34459531f, 0.09259685f, 0.16573375f, 0.02100397f, -0.00774044f, 0.05731233f, 
    0.09030652f, -0.09541679f, -0.01574215f, -0.06974084f, 0.30084586f, 0.10866684f, 0.15258028f, 0.12123186f, 
    0.01022453f, -0.13634154f, 0.04443671f, -0.11572737f, 0.22711989f, 0.16056427f, 0.00304446f, 0.03861102f, 
    -0.12382786f, 0.04570084f, -0.12298375f, -0.04417020f, -0.07296397f, -0.11989821f, -0.00156401f, -0.06314341f, 
    0.04787128f, 0.15643334f, -0.03441202f, 0.04570561f, 0.43577775f, -0.30515876f, 0.01279399f, 0.13707985f, 
    0.17256591f, -0.08381023f, -0.15910694f, 0.19898915f, 0.06529900f, -0.05056981f, 0.06707428f, 0.13327441f, 
    0.02815815f, -0.03243483f, 0.02688757f, -0.04977325f, 0.01066612f, -0.00706888f, -0.02531850f, -0.05236293f, 
    -0.03311822f, 0.04192072f, -0.01905052f, -0.02740022f, -0.00685200f, 0.01504077f, 0.00775558f, 0.01731900f, 
    0.02094632f, -0.00235393f, 0.04169904f, -0.02173457f, -0.04865094f, 0.00472919f, 0.03407998f, -0.03504563f, 
    -0.03115214f, -0.02039988f, -0.02023809f, 0.02972539f, -0.04717527f, 0.04406020f, -0.04331595f, 0.02486011f, 
    -0.02798081f, -0.02062376f, -0.02554969f, 0.00637259f, 0.01172386f, 0.03789715f, -0.04431380f, -0.01307257f, 
    -0.00255998f, 0.02500938f, 0.04646179f, 0.01605642f, 0.03695277f, 0.03925046f, 0.03754534f, 0.01371451f, 
    -0.03274101f, 0.03289564f, -0.02077070f, 0.00857278f, -0.01041174f, -0.02798095f, 0.00818841f, -0.00464519f, 
    0.03747808f, -0.03837088f, -0.04304573f, -0.01826696f, -0.04806501f, 0.03911843f, -0.02347902f, -0.04672527f, 
    -0.04512995f, 0.03063896f, -0.00093060f, 0.01569469f, 0.02254523f, 0.04088299f, -0.02269153f, 0.00885363f, 
    0.02938129f, 0.01165020f, 0.03801363f, 0.04669689f, -0.02324775f, -0.02733300f, -0.02588313f, 0.00169051f, 
    -0.01012299f, -0.02044472f, -0.02291476f, -0.04114361f, 0.00944399f, 0.01453043f, -0.02187049f, 0.03504174f, 
    -0.02727693f, -0.04607554f, 0.03400259f, -0.04435772f, 0.00311985f, 0.01041656f, -0.04765679f, 0.00208543f, 
    -0.03225085f, -0.02053609f, 0.02380079f, 0.02921442f, -0.04171805f, 0.00933372f, 0.01859777f, 0.03361243f, 
    -0.03924372f, -0.02591305f, -0.03883888f, -0.02630699f, -0.01799868f, 0.01562654f, -0.04745847f, 0.03928330f, 
    0.01371413f, -0.05399351f, 0.04531663f, 0.02561333f, -0.05370775f, -0.00525089f, -0.01476234f, 0.04611395f, 
    -0.01342305f, 0.03333314f, 0.02159707f, 0.02219897f, 0.01739144f, -0.02532520f, -0.04345291f, 0.02764318f, 
    -0.00551324f, 0.03432146f, 0.00211938f, 0.00504165f, 0.02246692f, 0.02295173f, -0.03431597f, 0.03264317f, 
    0.02749138f, -0.04862825f, 0.01323005f, -0.01510535f, -0.02979913f, -0.02036761f, -0.01635078f, 0.01187236f, 
    0.00692910f, -0.04005793f, 0.04399889f, -0.02303639f, 0.00701299f, -0.01571679f, 0.04648989f, -0.00781495f, 
    -0.01749984f, 0.03243975f, -0.04968034f, 0.03763871f, -0.03568036f, -0.01649988f, 0.02198379f, -0.01583588f, 
    -0.00087142f, -0.03678753f, 0.03804970f, -0.00796226f, -0.02061204f, -0.01418248f, -0.01392619f, -0.00743757f, 
    -0.01735301f, -0.01653099f, -0.04870896f, -0.05188835f, 0.02561002f, 0.03143537f, -0.04921667f, -0.04566176f, 
    -0.02087901f, -0.02219832f, -0.01190437f, 0.01545312f, -0.02446540f, -0.00365157f, -0.02374292f, -0.00602526f, 
    0.03579476f, -0.03514472f, -0.02166811f, -0.04714137f, 0.02158565f, 0.04102724f, 0.00915970f, 0.01584504f, 
    -0.02708075f, 0.00581294f, -0.02090854f, -0.02481557f, 0.01777004f, -0.02999352f, -0.01740527f, -0.04491270f, 
    -0.03791037f, 0.00760914f, -0.01910831f, -0.01065148f, 0.04007269f, -0.02841941f, -0.03886503f, -0.05186392f, 
    -0.05045376f, 0.01396882f, -0.02246537f, -0.02002225f, -0.05487996f, 0.02902984f, -0.03336263f, -0.03974109f, 
    0.03123068f, 0.03416818f, -0.03589367f, 0.01473698f, -0.00500753f, 0.02124417f, 0.02532232f, -0.01921472f, 
    0.04249423f, -0.03784975f, -0.04925643f, -0.03200543f, 0.04155977f, -0.03674373f, -0.04478003f, -0.00280394f, 
    0.01131050f, -0.01746120f, 0.00947053f, -0.00452754f, -0.01998568f, -0.05183324f, -0.02173312f, -0.04364907f, 
    -0.02238960f, 0.02881281f, 0.04413168f, -0.03057367f, -0.01730226f, -0.02324539f, 0.02050580f, 0.01303753f, 
    0.00200379f, -0.03708513f, 0.01905392f, 0.00501612f, 0.02668303f, -0.00944123f, 0.03448330f, 0.01319374f, 
    0.03841539f, -0.00170633f, 0.00915825f, -0.00471242f, 0.00330291f, -0.04823829f, 0.04043319f, -0.01125650f, 
    -0.01868695f, -0.00155590f, -0.02483045f, -0.02225840f, -0.01825068f, 0.02877595f, -0.05701211f, -0.02074476f, 
    -0.05470891f, -0.02618067f, 0.01788426f, 0.03450476f, -0.04338117f, 0.01192240f, 0.02835037f, 0.03098499f, 
    0.02144030f, 0.01508135f, -0.00581938f, 0.00964615f, -0.01289564f, 0.00657090f, -0.02250015f, -0.00504525f, 
    -0.01714866f, 0.03968227f, -0.05123508f, 0.00076556f, -0.04705202f, -0.01782609f, -0.00656109f, 0.01873777f, 
    0.00629964f, -0.05261646f, 0.01437211f, -0.00360403f, 0.03920962f, -0.01922495f, 0.04782969f, -0.00483074f, 
    0.02281147f, -0.03561378f, 0.02149367f, -0.02363620f, -0.02207870f, -0.04356984f, 0.03805982f, -0.01801023f, 
    0.01909692f, 0.00312094f, -0.04991054f, -0.02096433f, -0.05389362f, -0.04210343f, 0.00659990f, -0.03839120f, 
    -0.03667578f, 0.03049647f, -0.01182823f, 0.00022894f, 0.01405918f, -0.04791432f, -0.04772997f, -0.03414723f, 
    0.04157755f, -0.02898028f, 0.02442681f, -0.05134380f, -0.04165180f, -0.04250579f, 0.01084378f, 0.03277924f, 
    0.04768722f, 0.01731394f, -0.04675251f, -0.04465782f, -0.05663912f, -0.01310149f, -0.02261944f, 0.03448492f, 
    -0.00330159f, -0.02441725f, -0.05175574f, 0.00887550f, 0.00521048f, 0.02264284f, 0.04258471f, 0.02204934f, 
    -0.01872351f, -0.02733855f, -0.02395443f, -0.00951937f, 0.01738637f, -0.04145156f, -0.05589482f, -0.03932447f, 
    -0.04612856f, -0.05606274f, 0.01468810f, -0.03531639f, 0.03008140f, 0.03088054f, 0.04566468f, 0.02549848f, 
    -0.01921745f, 0.00835231f, -0.00056879f, 0.01988472f, -0.03304812f, -0.00997378f, 0.00038720f, -0.00498664f, 
    -0.00324213f, -0.03521542f, -0.04658292f, 0.03032348f, -0.03955254f, -0.03104815f, -0.04934409f, 0.01472984f, 
    0.08314453f, 0.16039255f, -0.09017991f, 0.11027952f, 0.00716769f, 0.03480745f, 0.02736286f, 0.05434852f, 
    0.06928144f, 0.03685926f, 0.11365416f, -0.08135861f, 0.08308626f, 0.03160984f, 0.02364644f, -0.25474089f, 
    0.01929355f, -0.05119112f, 0.15721926f, 0.26352248f, 0.05573077f, 0.11657627f, 0.00316617f, 0.06797802f, 
    -0.30493045f, -0.04646099f, 0.17882927f, 0.41882914f, -0.08968589f, -0.14401826f, -0.10533967f, -0.03407777f, 
    0.12596272f, -0.16035374f, 0.08917378f, 0.09626471f, 0.08613127f, 0.27905181f, -0.04619445f, 0.20193376f, 
    -0.07781136f, 0.03806806f, 0.13590281f, 0.28730884f, 0.15978812f, 0.04067922f, -0.05819497f, 0.10438532f, 
    0.12164718f, 0.16011004f, -0.08644152f, 0.11993121f, 0.02639005f, -0.04576375f, 0.00219106f, -0.10031637f, 
    -0.14372504f, -0.09911230f, -0.06777600f, -0.09571996f, -0.56918323f, 0.13549715f, 0.22232787f, 0.24988136f, 
    -0.06382704f, -0.07325495f, -0.12036175f, -0.00076183f, -0.06159582f, -0.00916251f, 0.11977468f, 0.10248303f, 
    -0.11254043f, -0.52851367f, -0.12782976f, -0.27247569f, 0.05630897f, 0.19797401f, 0.14113660f, -0.08677131f, 
    -0.08403772f, -0.00947114f, 0.04827622f, 0.09506264f, 0.03656334f, -0.18204488f, -0.01202104f, -0.09533446f, 
    -0.06506657f, 0.07301875f, -0.13146226f, 0.01435497f, 0.07847576f, 0.08407759f, -0.03146206f, 0.06805494f, 
    0.02255054f, -0.40455741f, -0.17559560f, -0.13929181f, 0.21036431f, 0.16370860f, 0.23080747f, 0.07761133f, 
    -0.06045383f, -0.14959243f, -0.12570351f, -0.01283478f, -0.36802596f, 0.10493628f, -0.07377169f, -0.12126057f, 
    0.01450341f, -0.09161416f, 0.12438685f, -0.06119812f, -0.05340394f, -0.04696637f, -0.01337310f, -0.02076750f, 
    0.42389950f, -0.08142370f, -0.00023025f, -0.17536940f, 0.06849647f, 0.07602818f, -0.04545907f, 0.03011671f, 
    -0.02577097f, 0.13722302f, 0.10007689f, 0.06955305f, 0.08490526f, -0.18484874f, 0.13342893f, 0.16134273f, 
    0.01057616f, 0.00018380f, -0.13046753f, 0.31395835f, -0.09594513f, 0.19445822f, 0.11283185f, 0.09895945f, 
    -0.42511174f, -0.04192216f, 0.21288764f, 0.23493211f, 0.09018338f, 0.06982284f, -0.00198705f, 0.05962659f, 
    0.14302523f, 0.02028813f, 0.11220792f, 0.01428277f, -0.08110373f, 0.07171461f, 0.01341429f, -0.13011263f, 
    0.01226918f, 0.08639768f, 0.12865861f, 0.14909679f, -0.00327096f, 0.00197138f, -0.00740647f, -0.18335657f, 
    0.39405420f, 0.02714658f, 0.14992051f, 0.02491412f, -0.00875856f, 0.02510720f, 0.11938391f, -0.00764724f, 
    -0.01913082f, -0.07194500f, 0.13616982f, 0.02069657f, -0.10594080f, 0.13592820f, 0.13397248f, -0.11474203f, 
    0.00451285f, -0.01367135f, 0.00129498f, 0.12964319f, 0.06318604f, 0.02008942f, 0.08957084f, -0.02045209f, 
    -0.40130487f, -0.00584711f, 0.34528828f, -0.25338101f, -0.02713614f, 0.04008546f, 0.06471206f, 0.22074990f, 
    -0.14009444f, 0.15953243f, -0.05741467f, 0.01760455f, -0.21707180f, -0.22132242f, 0.22426528f, 0.03583005f, 
    0.23629652f, 0.05717551f, 0.03038357f, -0.06263233f, 0.11772153f, 0.05605871f, 0.03887708f, 0.09062719f, 
    -0.03491499f, 0.14787529f, -0.15990736f, -0.05939445f, -0.03777557f, -0.11669905f, -0.09961256f, -0.13578425f, 
    0.09354213f, 0.08246490f, 0.02462203f, -0.03007389f, -0.01988790f, -0.03903197f, -0.37389803f, 0.08056321f, 
    -0.01236391f, 0.23251273f, 0.08022282f, -0.03851850f, -0.02374938f, -0.05775826f, 0.00444987f, 0.01702328f, 
    -0.02186869f, 0.01427363f, -0.05912016f, 0.14328142f, 0.10168198f, 0.07806306f, 0.03529406f, -0.03617426f, 
    0.12279810f, 0.14620793f, 0.09874432f, 0.11753035f, 0.45161796f, 0.00798557f, -0.07273847f, -0.24006067f, 
    -0.13456555f, -0.01041781f, 0.16181649f, 0.17766792f, -0.03130876f, 0.14291143f, 0.14520544f, -0.27522677f, 
    -0.12361148f, 0.00193479f, 0.15066279f, -0.04093413f, -0.01013380f, -0.09531935f, -0.09162181f, 0.15604337f, 
    0.00821989f, 0.09294845f, 0.14727563f, -0.02328390f, 0.11014041f, -0.02553525f, 0.02266181f, 0.28636029f, 
    0.01077436f, 0.06663890f, 0.09354085f, 0.02211838f, 0.04850869f, -0.04042660f, -0.05113520f, -0.09501548f, 
    -0.05349822f, -0.19881247f, 0.18004368f, 0.17407407f, -0.04648574f, 0.04556214f, -0.06198400f, 0.20246515f, 
    -0.04486124f, 0.00080983f, -0.05914704f, 0.06292631f, -0.17652066f, 0.08004241f, 0.11590222f, 0.05718278f, 
    -0.07998731f, -0.13607153f, -0.09563506f, -0.05964069f, 0.09557442f, 0.00853503f, 0.07274146f, 0.08124645f, 
    -0.11755838f, 0.04095735f, 0.05243881f, 0.15812142f, 0.04562094f, -0.01099345f, 0.10107189f, -0.09065089f, 
    -0.06134520f, -0.04028185f, 0.07799621f, 0.05968085f, 0.03039039f, -0.15970434f, -0.20610330f, -0.23463589f, 
    -0.01362711f, -0.12788366f, -0.06602765f, -0.04915432f, 0.07357006f, 0.06274306f, 0.07214255f, 0.10101552f, 
    0.26411349f, -0.36516508f, -0.16818739f, -0.44434237f, 0.01132755f, 0.09946077f, 0.21819924f, 0.09783193f, 
    -0.16179612f, -0.04251162f, 0.06272811f, 0.13521779f, -0.29439595f, -0.08174171f, -0.04850052f, -0.10274213f, 
    -0.17908973f, 0.20978501f, -0.07483124f, 0.06144444f, -0.01841693f, -0.07940123f, 0.01242675f, -0.05181981f, 
    0.29026011f, -0.04630498f, 0.01212908f, 0.06866108f, -0.03401244f, 0.10337358f, 0.01642304f, 0.06190435f, 
    -0.15021306f, -0.06068666f, -0.05474093f, -0.16269970f, -0.37476557f, 0.21440558f, 0.21777508f, 0.17994964f, 
    0.05617170f, 0.03251346f, 0.13802600f, -0.04413164f, -0.06686474f, 0.10583558f, -0.04592323f, 0.07778711f, 
    -0.04457669f, -0.05328151f, -0.01239289f, 0.01970124f, -0.02910373f, -0.00125521f, -0.05676436f, 0.00009171f, 
    -0.01843069f, 0.02235973f, 0.02190829f, -0.00480221f, -0.01615982f, -0.02740407f, -0.03470400f, -0.02074949f, 
    0.03192882f, -0.05829003f, -0.04747628f, 0.03160156f, -0.05967815f, 0.01343910f, -0.01384522f, -0.01979226f, 
    -0.03076997f, -0.02314132f, -0.00825249f, -0.05540759f, 0.01307557f, -0.01523614f, 0.03164151f, -0.04312352f, 
    -0.02385784f, 0.01409518f, 0.03786198f, 0.03891215f, -0.00057037f, 0.01091181f, -0.03643075f, -0.03419511f, 
    -0.00762484f, 0.00285643f, -0.01447098f, -0.02317852f, -0.02436067f, 0.02069848f, -0.03149654f, -0.00062139f, 
    -0.01907376f, 0.02775827f, -0.01293575f, 0.00889391f, 0.03787848f, 0.03874200f, -0.00282083f, -0.03025192f, 
    0.01441242f, 0.01134791f, -0.01443481f, 0.00193700f, 0.00779861f, 0.01084108f, -0.03285297f, -0.05387667f, 
    -0.00834160f, -0.03413372f, 0.01628930f, 0.02817174f, 0.01058158f, -0.05918096f, 0.02434512f, -0.03522389f, 
    -0.00237378f, -0.06153459f, -0.00415975f, 0.01962155f, -0.01478883f, -0.04335683f, -0.01006887f, -0.03322461f, 
    -0.03548850f, -0.02168853f, -0.04205805f, 0.00994086f, 0.00001477f, -0.04831320f, 0.01333738f, 0.00328454f, 
    -0.05202731f, -0.00039534f, -0.05813105f, 0.03117797f, -0.02241767f, -0.05444572f, 0.00895416f, -0.01201029f, 
    0.03034659f, -0.00955425f, -0.02899408f, -0.02060909f, 0.01054515f, -0.04142280f, -0.02317747f, 0.00777071f, 
    -0.04426561f, 0.00490075f, 0.01131067f, 0.00625851f, -0.03471101f, 0.02287545f, 0.01085629f, -0.02255373f, 
    -0.01380423f, -0.03028327f, 0.02225047f, -0.05419750f, -0.00858312f, -0.00661628f, -0.00350705f, -0.05894629f, 
    -0.01910190f, 0.00562312f, 0.02189408f, 0.02272019f, 0.00859950f, -0.01137571f, 0.00546761f, -0.06319919f, 
    0.02916146f, 0.02911612f, -0.04628620f, 0.01499964f, 0.01069476f, 0.01073624f, -0.01319832f, -0.05577588f, 
    -0.05539665f, -0.03366173f, 0.01738240f, -0.04346124f, 0.01999767f, 0.03100520f, 0.03963257f, -0.04619286f, 
    -0.03314330f, -0.03763109f, -0.03911556f, -0.05000751f, -0.02052960f, -0.04402183f, -0.04024307f, -0.01952781f, 
    -0.03003655f, 0.03137677f, 0.03892166f, -0.05680037f, -0.04613578f, 0.01710551f, 0.00849101f, 0.04120392f, 
    -0.03997641f, -0.00797783f, -0.00466102f, 0.00190021f, -0.03868195f, -0.01186247f, -0.03096886f, 0.01339323f, 
    -0.01023902f, -0.05393902f, -0.04821393f, -0.03661346f, -0.03207560f, -0.02183825f, 0.02634593f, -0.06260098f, 
    -0.04125650f, -0.00133920f, 0.02079928f, -0.05046944f, 0.00962513f, -0.02466344f, 0.02440365f, -0.03482980f, 
    -0.05296031f, -0.03179180f, -0.00121756f, 0.02589073f, 0.01196109f, -0.03653491f, -0.01715582f, -0.04971226f, 
    -0.00737647f, -0.01925315f, 0.03342362f, -0.01602968f, -0.00031788f, -0.01721902f, -0.02864278f, -0.01650545f, 
    0.00042104f, -0.01399979f, -0.03955548f, -0.03679794f, 0.04028742f, -0.02847970f, -0.04610350f, -0.03029222f, 
    0.01282650f, -0.04382349f, -0.00766521f, 0.01045237f, 0.01486825f, -0.03918708f, 0.00102305f, 0.04278708f, 
    0.03497893f, -0.00750633f, -0.02331822f, -0.05474914f, -0.02646753f, -0.05760649f, -0.00790869f, -0.02362306f, 
    -0.02938554f, -0.02708809f, -0.04978892f, -0.01854037f, 0.03234492f, 0.00444073f, 0.00723580f, 0.03172799f, 
    -0.02068703f, -0.01028689f, 0.00035061f, -0.04592716f, 0.01364759f, -0.03907417f, 0.00499726f, 0.01014947f, 
    -0.02062900f, -0.01766723f, -0.03646855f, -0.03617570f, 0.00460327f, -0.01988879f, 0.00114164f, 0.00294455f, 
    -0.02923104f, -0.00318063f, 0.04007455f, 0.01431557f, 0.03810705f, -0.03018300f, -0.03678730f, -0.05532920f, 
    -0.00683712f, -0.00697306f, -0.04875633f, 0.03800455f, -0.02519224f, 0.03988855f, -0.01497264f, 0.00382580f, 
    0.03774474f, 0.04060178f, -0.00464458f, 0.02499462f, 0.03534217f, -0.01051595f, -0.02277872f, -0.04103426f, 
    0.03714641f, -0.00131802f, -0.02422444f, -0.01385921f, 0.02127037f, -0.01066898f, -0.02156626f, 0.02002990f, 
    -0.00512118f, 0.02322263f, 0.01807031f, 0.01141209f, -0.02054870f, 0.03269172f, 0.04023825f, -0.01600888f, 
    0.02137761f, 0.00699717f, -0.03215226f, 0.00371159f, -0.01568381f, -0.00922505f, -0.03881963f, -0.00621502f, 
    -0.05352636f, -0.04532632f, -0.02010985f, -0.01615955f, -0.00943647f, -0.04279855f, 0.02307834f, -0.02976044f, 
    0.02387507f, -0.01499298f, -0.03179017f, 0.04137797f, 0.00680692f, 0.02973416f, -0.03316500f, -0.05056670f, 
    0.02321475f, -0.00735818f, -0.01805461f, 0.02657225f, 0.01935012f, -0.02550578f, -0.00571869f, -0.05210811f, 
    0.02327021f, -0.02304374f, 0.00176639f, 0.04013357f, -0.01482707f, -0.05413117f, 0.03765206f, 0.01458786f, 
    -0.00907206f, 0.01874229f, 0.01974803f, 0.03831416f, -0.03908307f, 0.01160867f, 0.04422585f, 0.01683547f, 
    0.02553500f, 0.00438636f, -0.05024759f, -0.03280612f, -0.01449527f, -0.03034548f, 0.02016013f, -0.00819087f, 
    -0.00458445f, -0.03511337f, -0.03749735f, -0.05839773f, -0.00149850f, -0.03850108f, 0.02501428f, 0.02025495f, 
    -0.03784249f, -0.01652216f, -0.02886303f, -0.05526909f, -0.01817796f, 0.01548661f, -0.01151600f, -0.02360171f, 
    -0.02503628f, 0.01198569f, 0.04542630f, -0.03719719f, -0.00787902f, 0.00533537f, -0.01662120f, 0.01584435f, 
    -0.02600634f, 0.04005532f, 0.01985834f, 0.00861203f, -0.01885782f, 0.02570470f, -0.05490217f, -0.03120530f, 
    -0.01243191f, 0.03677187f, 0.01203306f, -0.01568029f, 0.02639460f, 0.02536190f, 0.03029720f, -0.02241080f, 
    0.05428962f, 0.31805325f, -0.04744604f, 0.09888025f, 0.03360331f, 0.01722825f, -0.02590713f, -0.00976907f, 
    0.06202750f, 0.03495461f, 0.07831299f, -0.15694952f, -0.06356262f, -0.14843319f, 0.02352831f, -0.05738510f, 
    -0.11404198f, -0.06998567f, 0.05640977f, 0.01919321f, 0.03824148f, -0.07616291f, 0.15192308f, 0.16845523f, 
    0.06312067f, -0.03110745f, 0.28222853f, 0.27423275f, -0.06712079f, -0.12217541f, -0.20081471f, -0.10813920f, 
    0.03704409f, 0.09603192f, -0.00656988f, -0.12359572f, 0.13879780f, 0.28626409f, 0.13341610f, -0.08722152f, 
    -0.12485895f, -0.14182507f, 0.25019497f, 0.03258073f, 0.14731707f, -0.05038970f, 0.04931037f, 0.10556797f, 
    0.19665125f, -0.17746933f, -0.04123092f, 0.10828131f, -0.03646579f, -0.04927400f, 0.00948760f, -0.24562685f, 
    -0.11976443f, -0.08340763f, 0.02241211f, -0.05322616f, 0.08279467f, 0.36147517f, 0.34269920f, 0.24632494f, 
    -0.07763401f, -0.12060263f, 0.04286704f, -0.11696639f, 0.05845317f, -0.10870397f, -0.07413764f, 0.24176799f, 
    -0.43870988f, -0.38544089f, -0.32537052f, -0.01382869f, 0.06286563f, 0.12211381f, 0.55260199f, 0.05121771f, 
    0.00431462f, 0.00944986f, 0.19418222f, -0.07312823f, -0.07114456f, 0.09973920f, -0.00205885f, 0.03815766f, 
    -0.21467192f, -0.03037684f, 0.03122734f, -0.08660752f, 0.13879405f, 0.26074532f, 0.05484772f, 0.05672904f, 
    -0.41876686f, -0.21841404f, -0.18267676f, 0.14876264f, -0.12356223f, 0.12398468f, 0.28653181f, -0.00392959f, 
    0.02098534f, -0.11368075f, -0.04260725f, -0.13248010f, -0.43640748f, -0.13756771f, -0.43329853f, 0.02481117f, 
    0.06811461f, -0.14869349f, 0.08919273f, -0.02487957f, -0.02135238f, 0.10323808f, -0.04881585f, 0.07117236f, 
    0.08187960f, 0.04542924f, 0.46491104f, 0.22060059f, 0.14786778f, -0.04158242f, -0.07746429f, 0.06285668f, 
    0.12645543f, -0.09704725f, -0.08934940f, 0.05713405f, -0.18745136f, -0.24756962f, 0.08919431f, 0.10978735f, 
    0.02005655f, 0.14053063f, -0.08814834f, 0.10367537f, -0.01434590f, 0.06554486f, 0.10813377f, 0.09331035f, 
    0.23116565f, 0.47255003f, 0.09381916f, 0.21246845f, -0.13746257f, 0.00632312f, -0.03134882f, -0.03282596f, 
    -0.12180316f, 0.07947607f, 0.02329047f, -0.14803016f, 0.01178478f, 0.28530645f, -0.05270485f, -0.08351975f, 
    -0.10668097f, -0.00044551f, 0.12043082f, 0.03389791f, 0.10364412f, -0.27070758f, -0.08124142f, -0.01453544f, 
    0.30722532f, -0.04597961f, 0.11481961f, -0.01957860f, 0.03509789f, 0.01983085f, 0.03457304f, -0.07992137f, 
    0.04472112f, 0.00933510f, 0.01238363f, -0.05197608f, -0.24055745f, 0.26043719f, 0.16858213f, -0.03640504f, 
    -0.08552097f, 0.03599243f, -0.09612492f, 0.24387670f, -0.01545929f, 0.21427459f, -0.05931369f, -0.22180137f, 
    -0.13841979f, -0.00685006f, 0.50269789f, -0.00412005f, -0.01986682f, 0.07587565f, 0.33556080f, 0.11211861f, 
    0.03851615f, 0.14588691f, 0.07883879f, -0.00119403f, 0.08928145f, -0.00916088f, 0.49792492f, -0.22071338f, 
    -0.05472098f, 0.07753963f, -0.06669492f, 0.09061557f, 0.18105397f, -0.02979615f, 0.09884690f, 0.00471976f, 
    -0.24632704f, -0.14322823f, -0.28261250f, 0.04293664f, 0.06036654f, -0.21745202f, -0.06351752f, -0.01854166f, 
    -0.07064217f, 0.09403642f, -0.07663677f, -0.16868268f, -0.44961929f, -0.20079294f, -0.05344817f, 0.16965145f, 
    0.05887355f, 0.16891605f, 0.16462748f, -0.08465315f, 0.03937089f, 0.00964788f, 0.01364989f, 0.00398518f, 
    -0.08408291f, 0.45909077f, -0.07094865f, -0.11814271f, 0.12836508f, 0.12332521f, -0.01187501f, 0.05283999f, 
    -0.13254176f, 0.08902981f, 0.10508798f, 0.17446303f, 0.39755511f, 0.64529628f, -0.31293696f, -0.02872321f, 
    -0.13822986f, 0.04296132f, 0.06428967f, -0.05020015f, -0.05681306f, 0.09562104f, -0.01890739f, -0.08216538f, 
    -0.14396088f, 0.25840780f, 0.12122732f, 0.01124061f, 0.12794299f, -0.07556780f, -0.05080995f, 0.11221289f, 
    0.14367160f, 0.04200729f, 0.04970220f, 0.10793331f, 0.00303366f, -0.25756747f, 0.28299206f, 0.15533954f, 
    0.05182163f, 0.05240963f, 0.03535761f, -0.06044536f, 0.02590290f, -0.01056123f, 0.03141056f, -0.11807474f, 
    0.02226173f, -0.25938475f, 0.12642278f, 0.29551315f, -0.08360830f, -0.00606102f, 0.05437432f, -0.01975590f, 
    0.07997382f, -0.06544463f, -0.03142278f, 0.17972685f, -0.17547908f, -0.22484511f, -0.42138922f, -0.01777885f, 
    0.07972775f, 0.03022843f, -0.01526314f, 0.12602510f, -0.03307539f, 0.00132293f, -0.01637035f, 0.06804295f, 
    -0.34879065f, -0.36299202f, -0.21156351f, 0.11541052f, 0.00913483f, 0.05798021f, -0.05049732f, -0.13320066f, 
    -0.05859127f, -0.01459273f, -0.03366542f, 0.04227157f, -0.36693671f, -0.23529467f, -0.32584783f, 0.00923979f, 
    0.10715914f, -0.02425775f, -0.07231039f, -0.09208310f, 0.06138214f, 0.03223331f, 0.07388455f, -0.00269921f, 
    0.20372540f, -0.43536618f, -0.18364841f, -0.00552659f, 0.05885924f, 0.13240504f, 0.19810610f, -0.20358309f, 
    0.04425412f, -0.14311278f, -0.02845784f, -0.11659683f, -0.28383496f, -0.15665558f, -0.09065413f, -0.08605461f, 
    0.08060881f, 0.33680829f, -0.05853243f, 0.09783994f, 0.01134248f, -0.03737209f, 0.05122992f, 0.03025602f, 
    0.10765978f, 0.09749933f, -0.00717617f, 0.03445609f, -0.05440054f, 0.06681543f, -0.01492016f, -0.03037028f, 
    0.18804373f, 0.01344210f, -0.17107747f, -0.31690797f, -0.21974210f, -0.38637698f, 0.29419425f, 0.27157751f, 
    -0.00057603f, -0.12874821f, 0.03942815f, -0.06620122f, -0.03563651f, 0.06670751f, 0.04097220f, -0.05545683f, 
    -0.05045207f, -0.16758297f, -0.28455397f, -0.08262122f, 0.15321381f, 0.09270390f, -0.03694588f, 0.05116397f, 
    0.25088680f, 0.06458554f, 0.17154381f, 0.33887184f, 0.25784728f, 0.07853355f, 0.13005900f, 0.06258279f, 
    0.14027748f, -0.05015985f, -0.04353922f, -0.01118410f, 0.03683110f, -0.05221619f, -0.10796328f, -0.17067008f, 
    -0.27615187f, 0.17055562f, 0.41426149f, 0.16036698f, 0.12872611f, 0.02361201f, -0.11063747f, 0.05540459f, 
    -0.10081480f, 0.14425825f, 0.08641902f, 0.25282225f, 0.18614294f, -0.47854230f, -0.05390899f, 0.27664933f, 
    0.06762011f, -0.25782552f, -0.09028272f, 0.22972198f, 0.12085758f, 0.00509959f, 0.20479286f, 0.15041874f, 
    -0.30408481f, -0.21944502f, -0.29769999f, 0.14096090f, -0.06051514f, -0.03161501f, -0.06348646f, 0.00450010f, 
    0.23252323f, 0.03383413f, -0.02787100f, -0.06436420f, -0.16748148f, 0.36576056f, 0.21339434f, 0.36919254f, 
    0.03034248f, -0.16448908f, -0.07343277f, 0.02039254f, 0.24487202f, 0.09202739f, 0.07498825f, 0.03606225f, 
    -0.00736029f, 0.29757014f, 0.05290418f, -0.03913053f, 0.17495009f, 0.18057454f, -0.08822601f, 0.09822843f, 
    0.21156336f, -0.11333693f, -0.05621798f, -0.14044783f, -0.08513789f, -0.48145282f, -0.05075140f, -0.16786516f, 
    0.27098683f, 0.23625185f, -0.04224031f, 0.13618006f, 0.11137090f, -0.28022695f, -0.00354879f, -0.20703849f, 
    0.01018191f, -0.07246209f, 0.29071924f, 0.37692732f, 0.03624076f, 0.15730771f, 0.12678134f, 0.02232835f, 
    0.06682943f, 0.01822196f, -0.12667181f, -0.04101982f, 0.19625951f, 0.24237119f, 0.29710057f, -0.01429673f, 
    -0.02330558f, 0.04621717f, 0.12531306f, 0.07442543f, 0.21183597f, -0.22948033f, -0.10447776f, -0.05855599f, 
    -0.29492530f, 0.62212831f, 0.49852291f, -0.25174576f, 0.11254881f, 0.02855469f, -0.11126713f, -0.09382459f, 
    0.15582669f, 0.03197860f, 0.11536891f, 0.12408391f, 0.04338999f, -0.20405504f, -0.09350667f, -0.27396691f, 
    0.11058305f, 0.07004160f, -0.02753115f, 0.15443304f, -0.13084228f, -0.01061360f, -0.26164800f, -0.10417644f, 
    -0.35430640f, -0.27181426f, 0.11568864f, 0.47674060f, 0.16912383f, -0.15414171f, -0.04924760f, -0.18215419f, 
    -0.03151115f, -0.04964544f, -0.25657433f, 0.00373917f, -0.11350365f, -0.07459091f, 0.28693658f, 0.22810397f, 
    -0.00653106f, -0.08644778f, 0.00984548f, 0.12947239f, 0.12106802f, 0.01377147f, -0.04887287f, 0.30083615f, 
    -0.03445857f, -0.18810883f, -0.36804119f, -0.04794782f, 0.19215776f, -0.15542553f, 0.07247685f, 0.02007423f, 
    0.12895420f, 0.13417912f, 0.00339307f, -0.04512622f, 0.06873079f, 0.36285153f, 0.32864702f, 0.25145835f, 
    0.01326466f, -0.00862629f, -0.01876270f, -0.03746994f, 0.15173097f, -0.08141796f, 0.16336523f, 0.19566801f, 
    -0.01107131f, 0.29437271f, 0.18602575f, -0.08840663f, 0.19974224f, 0.02674183f, 0.09335200f, 0.12553471f, 
    -0.11121056f, 0.05090478f, 0.27321929f, 0.16707906f, -0.38909298f, 0.14391489f, -0.01049507f, -0.03374323f, 
    0.28345072f, -0.03829584f, -0.28376883f, 0.04351841f, 0.25271156f, -0.01231793f, -0.01312171f, 0.13382822f, 
    0.00447351f, 0.03840265f, 0.30666769f, 0.11587575f, 0.15667391f, 0.09217593f, 0.23022600f, 0.08367758f, 
    -0.08810469f, 0.19312271f, 0.21076304f, 0.31435195f, -0.07987016f, -0.31166214f, -0.08019944f, -0.06386396f, 
    0.31756985f, 0.14813735f, 0.15147579f, 0.17379813f, 0.03691386f, -0.14609838f, -0.21695039f, -0.00027628f, 
    0.14734833f, -0.00083044f, 0.42282262f, 0.30835682f, -0.07935527f, 0.36526573f, 0.08787218f, -0.03127209f, 
    0.05721005f, 0.04636971f, 0.02234386f, 0.11381781f, -0.03760731f, 0.06843929f, -0.25770223f, -0.03866559f, 
    0.14597251f, 0.02443489f, -0.08737084f, -0.09964583f, 0.18470742f, -0.00154428f, 0.16122383f, 0.06873234f, 
    0.30872080f, -0.10503773f, -0.13857281f, -0.17772698f, 0.07637604f, 0.07113849f, -0.12334718f, 0.12965402f, 
    -0.11070991f, 0.16442592f, 0.06249558f, -0.01846237f, -0.14064486f, -0.12658149f, -0.25757957f, -0.08777898f, 
    0.10678453f, 0.11568310f, -0.10296817f, -0.05194319f, 0.09537264f, -0.05901313f, 0.08559345f, 0.00411081f, 
    -0.02377536f, 0.14138997f, -0.01739875f, 0.10438092f, 0.08263601f, 0.22576074f, -0.02361521f, -0.01929845f, 
    -0.01673835f, -0.01062781f, -0.16218920f, -0.06088464f, -0.03597880f, 0.27913544f, 0.27335447f, 0.13169052f, 
    0.06964282f, 0.16723880f, 0.12919739f, 0.07475808f, 0.21305518f, -0.00825206f, 0.20894352f, 0.16345800f, 
    -0.20816880f, 0.16979541f, 0.33852452f, 0.07387904f, 0.05945336f, 0.03378085f, 0.13541931f, 0.10758701f, 
    -0.04722156f, 0.02127053f, 0.11561015f, 0.10428083f, 0.00525657f, 0.11468930f, 0.22115532f, -0.20925106f, 
    0.23157670f, 0.01488199f, 0.01746740f, -0.06995445f, 0.05763479f, -0.16728592f, -0.13443249f, -0.17649958f, 
    0.09520211f, 0.35000509f, -0.06499772f, 0.10374150f, 0.13644898f, 0.11824566f, 0.03791362f, -0.10330562f, 
    -0.02473585f, 0.01224296f, -0.17071322f, -0.21164502f, 0.18567722f, 0.03884344f, 0.15604767f, -0.10486674f, 
    0.13270518f, 0.05004887f, 0.00037994f, 0.02475073f, 0.02655912f, 0.21494626f, 0.20005520f, 0.14163356f, 
    -0.11557556f, -0.20037539f, -0.47921574f, -0.04721456f, -0.07970178f, 0.08673034f, 0.01066349f, -0.14390136f, 
    0.35308111f, 0.21487597f, 0.25224337f, 0.17311797f, 0.02516066f, -0.08787097f, 0.08853650f, 0.10820746f, 
    0.03654885f, -0.09335145f, 0.02417356f, 0.10187806f, 0.04631195f, -0.06643625f, -0.07819368f, 0.29296625f, 
    -0.02409100f, 0.01641351f, -0.00938688f, 0.08361915f, 0.01115938f, -0.12626521f, 0.00501506f, 0.04244164f, 
    0.01976220f, 0.08532012f, -0.06941793f, -0.03469291f, -0.08456984f, 0.07818253f, -0.06093591f, 0.08182903f, 
    0.03753479f, 0.15560746f, 0.03507944f, 0.10499597f, -0.02167076f, 0.11195730f, -0.03249468f, -0.01515664f, 
    -0.06299632f, -0.20177597f, -0.20062092f, -0.21384789f, -0.10244875f, -0.01277456f, 0.04120116f, -0.09066877f, 
    0.14365725f, -0.17417003f, -0.12722461f, -0.01061247f, -0.45528203f, 0.47670883f, -0.19503663f, 0.15348524f, 
    -0.02792914f, 0.30796862f, -0.05812026f, 0.23568548f, -0.06651028f, 0.12126587f, 0.06899784f, 0.09621619f, 
    0.31966138f, 0.37917778f, 0.45097688f, 0.15140146f, 0.04999265f, -0.08483923f, -0.07303102f, 0.02133018f, 
    -0.08089596f, 0.00684209f, -0.00404500f, 0.07815792f, -0.24930701f, -0.29451877f, -0.20171762f, -0.16588014f, 
    -0.06242378f, 0.10669380f, 0.02325689f, 0.13782696f, 0.02279343f, 0.07480591f, 0.10041036f, -0.00968453f, 
    0.37277001f, -0.17386466f, 0.37148738f, -0.03977821f, -0.11268815f, 0.11933646f, -0.20373733f, 0.08737464f, 
    -0.10436090f, -0.00638009f, -0.04247177f, 0.02644924f, 0.15324831f, 0.05695348f, 0.15736631f, 0.13015978f, 
    0.00323761f, 0.12770827f, -0.09638326f, -0.02963673f, 0.00841124f, 0.03375735f, -0.06751665f, 0.12678544f, 
    0.47904548f, 0.22673781f, 0.06784888f, -0.25501314f, -0.01080892f, -0.13050063f, -0.10412700f, -0.05377617f, 
    -0.09109940f, -0.01642026f, -0.09530598f, -0.06063445f, -0.31184435f, -0.01335970f, 0.09001553f, 0.21938111f, 
    0.28212139f, -0.03476914f, -0.17040646f, -0.07956645f, -0.02619396f, -0.01572064f, 0.01608039f, 0.01760134f, 
    0.33155483f, -0.17939670f, -0.57410097f, 0.10689081f, -0.06467703f, -0.03892166f, 0.16004466f, 0.08837175f, 
    -0.09345584f, 0.11094008f, -0.02059949f, -0.17442118f, 0.20058870f, 0.14016919f, 0.15972218f, 0.11134417f, 
    0.05370557f, -0.17596696f, 0.03684282f, 0.15573621f, 0.04622453f, 0.16886030f, 0.19133754f, 0.08020400f, 
    -0.29867691f, -0.28147224f, 0.15792675f, -0.11158747f, 0.11617620f, 0.18116234f, 0.07789566f, 0.07148928f, 
    0.02620905f, 0.02375904f, 0.16482398f, 0.23975068f, 0.01786681f, 0.14067483f, -0.15930822f, -0.11501493f, 
    -0.01238941f, 0.13362759f, -0.02963303f, 0.08136573f, -0.00070886f, 0.11989049f, 0.01735876f, -0.14270812f, 
    0.16398138f, 0.30423379f, 0.33636087f, 0.29981270f, 0.01176985f, 0.00172010f, 0.15226404f, 0.01493797f, 
    -0.01496229f, -0.10805744f, 0.13915733f, 0.13098599f, -0.04780553f, 0.07482421f, -0.00863395f, -0.14248440f, 
    0.02035386f, 0.04788642f, 0.17763820f, 0.02247432f, 0.13773179f, -0.01190082f, 0.02252856f, 0.07801960f, 
    -0.16693203f, -0.08041493f, -0.21354061f, 0.05973316f, -0.14817607f, -0.13352090f, -0.00422238f, 0.22756349f, 
    -0.01695803f, 0.00110881f, -0.20076185f, -0.11930428f, 0.15716955f, -0.06823834f, -0.02154610f, 0.08559141f, 
    -0.06963380f, -0.10050054f, 0.20562215f, 0.01550258f, 0.10008031f, 0.25102347f, 0.06403919f, -0.10447943f, 
    0.10245606f, 0.33519623f, -0.03165744f, 0.07917448f, -0.08349266f, 0.03443509f, -0.07094117f, 0.03710782f, 
    0.03449143f, -0.03166095f, 0.03971589f, -0.05214076f, 0.11205152f, 0.21414438f, -0.00294740f, 0.06537287f, 
    -0.29581040f, 0.05658577f, -0.10646513f, -0.04479266f, -0.04518819f, 0.08211201f, 0.12884007f, -0.01546256f, 
    0.04733551f, -0.02347790f, -0.05214954f, -0.17373399f, 0.06744356f, -0.07498632f, 0.08050578f, 0.02173228f, 
    0.00013836f, 0.04829850f, 0.01294089f, 0.03066481f, 0.09906659f, -0.25802374f, 0.30232054f, 0.29757196f, 
    -0.13297518f, 0.02428786f, -0.11311464f, 0.10228085f, -0.02932787f, 0.13523565f, -0.03471321f, -0.18661706f, 
    -0.02273031f, -0.02749118f, 0.05536053f, 0.08829055f, -0.21608986f, 0.04596623f, 0.15937217f, 0.06140630f, 
    0.04857607f, -0.00440957f, 0.24202608f, -0.05271758f, 0.22056128f, 0.33426645f, 0.12334445f, 0.12438577f, 
    -0.09170639f, -0.11117148f, -0.02638897f, 0.02728577f, -0.00765295f, 0.00963271f, 0.07961498f, 0.07939593f, 
    -0.11292973f, -0.06572402f, 0.20084859f, -0.03808528f, 0.06658565f, -0.04154146f, 0.03206496f, 0.14136359f, 
    0.01197005f, 0.02206927f, 0.09795193f, 0.03706904f, -0.08060268f, -0.03902681f, 0.17146650f, -0.20704895f, 
    -0.02618150f, -0.07472068f, -0.02487664f, 0.05168559f, 0.05657189f, 0.18401116f, 0.00169361f, -0.00338578f, 
    0.18743360f, 0.15082948f, 0.09354205f, 0.03831381f, 0.10595259f, 0.06841918f, 0.15283430f, -0.14138585f, 
    -0.03018134f, -0.04425799f, -0.06651749f, -0.12718578f, 0.15327166f, -0.12016860f, -0.07478676f, 0.01349942f, 
    -0.14166132f, 0.16005716f, -0.15125473f, 0.22480129f, -0.06805716f, 0.01261220f, 0.04770007f, 0.07956016f, 
    0.02522887f, -0.54328185f, 0.31841090f, -0.18021436f, 0.18323819f, -0.08579770f, 0.07683606f, 0.20794755f, 
    -0.19014335f, 0.03696398f, 0.10236306f, 0.25379619f, -0.11668061f, -0.05885759f, -0.05669914f, 0.08597534f, 
    -0.07333623f, -0.08996864f, 0.06337740f, 0.00930460f, -0.04820499f, 0.00812608f, -0.11111580f, -0.05141212f, 
    0.22256400f, 0.02656191f, 0.16940755f, -0.01902224f, -0.01039499f, -0.15811214f, -0.05871464f, 0.03641421f, 
    -0.15521577f, -0.17566471f, -0.00036314f, -0.01822464f, -0.32478365f, 0.55895287f, 0.04469525f, 0.16296610f, 
    0.04218271f, 0.01357185f, 0.00558909f, 0.01368459f, -0.10089137f, 0.08669293f, -0.05117961f, -0.08069045f, 
    -0.01858028f, -0.00116640f, -0.05253230f, -0.01741582f, -0.04442224f, 0.04142859f, 0.02709957f, 0.00732348f, 
    -0.01228483f, 0.00660566f, -0.00892608f, 0.02231138f, -0.00307567f, 0.03383879f, -0.05725781f, 0.03822474f, 
    0.02934128f, -0.00408662f, 0.02713527f, -0.03396737f, 0.04251856f, -0.03659416f, 0.02357290f, -0.03508266f, 
    -0.02893571f, -0.03865105f, -0.02216641f, -0.02056317f, 0.01805269f, -0.01082704f, 0.02194777f, 0.00879756f, 
    0.01058347f, -0.01302354f, 0.01237327f, 0.04436602f, 0.02090494f, -0.01481973f, 0.01481331f, -0.04746291f, 
    -0.05332519f, 0.03240829f, -0.02335924f, 0.01967894f, -0.02810288f, 0.03330958f, 0.00304802f, 0.03755971f, 
    0.00733841f, 0.01044867f, -0.00368977f, 0.03302304f, -0.05845131f, -0.00155519f, -0.05089231f, 0.01345170f, 
    -0.04177425f, 0.01543444f, -0.03907843f, -0.02743628f, -0.04496621f, 0.03087278f, -0.03044689f, -0.03945477f, 
    -0.01333834f, -0.03837037f, 0.02014336f, -0.03715710f, -0.02224102f, -0.03180077f, 0.03875485f, 0.02743686f, 
    0.04180772f, 0.03231062f, -0.04274454f, -0.04624004f, -0.05568459f, -0.01794028f, -0.03888933f, -0.02768377f, 
    0.03237404f, 0.01294743f, -0.00822306f, 0.01475066f, -0.05493585f, -0.05446883f, 0.03644897f, 0.03273040f, 
    -0.05853427f, -0.05711658f, 0.00583038f, -0.04628971f, 0.01986876f, 0.03069331f, -0.02971283f, 0.03585564f, 
    -0.02402698f, -0.00606488f, -0.03948568f, 0.03596908f, -0.02528428f, 0.01269526f, -0.01535631f, -0.03713894f, 
    0.02238017f, 0.02104560f, 0.01609491f, -0.03042765f, -0.01380395f, 0.03157104f, 0.04054474f, 0.00119942f, 
    0.03810885f, 0.00867821f, -0.04680778f, -0.03002052f, 0.03000677f, -0.03601421f, -0.02855444f, 0.01613295f, 
    -0.01348118f, -0.01287908f, -0.00276001f, -0.05037564f, 0.01253684f, -0.04366380f, -0.03053217f, -0.03424067f, 
    -0.04416309f, 0.01786495f, -0.04719430f, -0.01831702f, -0.00617530f, -0.02552951f, -0.02633766f, -0.03231330f, 
    -0.01356882f, -0.01401815f, 0.00188925f, -0.05399681f, -0.01421830f, -0.03332685f, -0.00430810f, -0.01842467f, 
    0.00519477f, 0.02496735f, -0.05557436f, -0.05266260f, 0.02208939f, 0.02893980f, -0.03386287f, -0.00621640f, 
    0.02289573f, 0.04124511f, 0.03809509f, -0.02638873f, -0.01634338f, 0.00585378f, 0.00996522f, 0.02749986f, 
    -0.00094668f, 0.03916242f, -0.02580754f, -0.04396855f, -0.04453357f, -0.00253272f, -0.04782985f, -0.01907896f, 
    -0.01274723f, 0.03000753f, -0.00255310f, -0.05459410f, -0.00852226f, -0.03600992f, 0.00820705f, -0.04018511f, 
    -0.00986400f, -0.01163519f, -0.02051909f, 0.01460204f, 0.00376280f, 0.03496764f, -0.01523088f, 0.04121986f, 
    0.01932146f, 0.03347597f, 0.04008375f, 0.04789918f, -0.00875431f, -0.00324459f, -0.04291968f, 0.03366321f, 
    0.01682066f, -0.04680645f, -0.05627063f, -0.00104299f, -0.05814406f, 0.03964390f, -0.05503293f, -0.00232191f, 
    -0.03043355f, 0.00853121f, -0.02939233f, 0.02465522f, -0.03210383f, 0.04177498f, -0.05428845f, -0.03814097f, 
    -0.04851984f, -0.01779505f, -0.03459948f, 0.02634497f, -0.02536951f, -0.02755023f, -0.04407753f, 0.00923207f, 
    0.02656052f, -0.00534591f, -0.04974828f, -0.04653282f, 0.04216025f, -0.05042293f, 0.04469696f, 0.04505616f, 
    -0.03976702f, 0.04077937f, 0.03071751f, -0.03954874f, -0.04551554f, -0.02446662f, 0.00474017f, -0.02050483f, 
    0.02358650f, -0.01166864f, -0.00624020f, -0.05191861f, 0.04059076f, 0.01990215f, 0.01532110f, 0.00112933f, 
    0.02404711f, -0.02257821f, 0.01854204f, 0.00273096f, -0.02036482f, 0.02248186f, -0.04067842f, -0.05161988f, 
    -0.03807206f, 0.04199588f, -0.01646524f, -0.01221627f, -0.02563093f, 0.03878975f, -0.00627551f, -0.01154247f, 
    0.04378748f, -0.00136199f, -0.04266374f, -0.03443620f, 0.00530868f, 0.04381739f, 0.04898800f, 0.02435680f, 
    -0.02550137f, 0.02006253f, 0.01913702f, 0.03364866f, 0.01380472f, 0.02480011f, 0.01547178f, -0.02231823f, 
    0.00995740f, -0.01001196f, -0.01526431f, 0.03761318f, -0.02361484f, 0.01111804f, -0.03998451f, 0.03619755f, 
    -0.03041746f, -0.05383602f, 0.00427653f, -0.01592324f, -0.01142232f, -0.05766104f, 0.03036545f, -0.01326338f, 
    0.00885165f, 0.00258261f, -0.05766523f, -0.04459000f, -0.03737344f, 0.03997468f, -0.00427913f, 0.00614840f, 
    0.03485604f, -0.03175748f, 0.02591191f, 0.03225777f, 0.05249547f, 0.01352705f, -0.04649960f, -0.00338562f, 
    -0.02821757f, -0.03139778f, 0.04027605f, -0.03493772f, 0.02093005f, 0.00320003f, 0.02834723f, -0.02831333f, 
    -0.04671603f, -0.05354010f, 0.00823780f, -0.02171452f, 0.00994578f, 0.04740407f, 0.04293249f, -0.03552346f, 
    -0.02722033f, -0.00236529f, 0.04490109f, 0.03041945f, -0.01447257f, 0.01176234f, -0.00441032f, 0.01864719f, 
    0.03702139f, -0.03881700f, -0.03380954f, 0.01105012f, -0.00499722f, -0.00096318f, 0.01489425f, -0.04907319f, 
    -0.04128194f, -0.00417976f, -0.00705112f, 0.00983956f, 0.03882586f, 0.02941213f, -0.02722225f, -0.01100766f, 
    -0.04300929f, 0.01874711f, 0.01542885f, 0.04391121f, -0.01978633f, 0.02773965f, -0.05253774f, -0.00539287f, 
    -0.01753119f, 0.02989865f, -0.01818347f, -0.00921120f, 0.01159280f, 0.01907536f, -0.01688842f, -0.02085550f, 
    -0.01173484f, 0.04733980f, -0.04585431f, 0.04208019f, 0.02418111f, -0.03901614f, -0.03292625f, 0.02348164f, 
    0.00549650f, 0.02573512f, -0.01886987f, -0.04093156f, 0.03163522f, 0.01779289f, -0.01640045f, -0.04175051f, 
    0.00960592f, -0.04447491f, 0.02622575f, -0.00590580f, 0.02363369f, -0.04530057f, 0.00765114f, -0.05114116f, 
    -0.04377097f, -0.04777073f, -0.01657672f, -0.01652037f, -0.02285182f, -0.01821172f, -0.02126697f, 0.04337526f, 
    -0.00527597f, 0.04162858f, 0.00881409f, -0.03653726f, 0.02453081f, 0.01578046f, -0.01058255f, -0.02851338f, 
    -0.03255917f, -0.01253563f, -0.03144181f, -0.02946698f, 0.00803421f, -0.01981764f, -0.05568996f, 0.01803152f, 
    0.00069971f, -0.01830521f, 0.02008061f, 0.01024889f, -0.00673162f, -0.00510794f, 0.04069638f, 0.01000638f, 
    -0.05053067f, 0.00303170f, 0.02544212f, 0.03557292f, 0.01266999f, 0.03733634f, 0.04560849f, 0.00040728f, 
    -0.02484460f, 0.03746855f, -0.00395580f, -0.02656305f, -0.02135251f, -0.03237209f, -0.02561836f, 0.01624429f, 
    -0.03578484f, 0.04229791f, -0.01045521f, -0.04897048f, 0.00725047f, 0.02083256f, -0.05444061f, -0.01525197f, 
    0.04633405f, -0.00423956f, 0.00395232f, -0.02275595f, 0.00838523f, -0.04462793f, 0.02487664f, -0.04474435f, 
    0.02106530f, -0.01968156f, -0.02260391f, -0.04225042f, -0.04313882f, -0.00935912f, 0.01679400f, 0.03830606f, 
    -0.00170049f, 0.04099498f, 0.02519959f, -0.00312188f, -0.02819117f, 0.02304316f, -0.01028048f, 0.04361091f, 
    -0.04500384f, -0.03252761f, -0.01261771f, 0.03512309f, 0.01608813f, 0.00308026f, 0.01358577f, 0.04526880f, 
    -0.02003684f, -0.03139100f, 0.04464195f, -0.01238372f, -0.05365391f, -0.04349268f, -0.02017966f, 0.04357182f, 
    0.02345766f, 0.00319743f, -0.03385507f, -0.00812103f, -0.01029960f, -0.03595639f, -0.03987237f, 0.03908120f, 
    0.03043645f, 0.01088578f, -0.02471272f, -0.01461009f, -0.04599383f, 0.03330846f, -0.04561457f, 0.00621608f, 
    -0.00771290f, -0.02830850f, 0.03857104f, 0.01680904f, -0.02012303f, 0.00686209f, -0.03424923f, 0.00942247f, 
    -0.05002905f, 0.01159090f, 0.01251245f, 0.02157248f, -0.03523543f, 0.02629483f, 0.01192292f, 0.04457602f, 
    0.00948036f, -0.02575551f, 0.03509377f, -0.01150804f, 0.00774494f, 0.02210591f, -0.04076455f, -0.03861466f, 
    0.03217001f, 0.02386920f, 0.04365317f, -0.03832693f, -0.04223588f, 0.01817229f, -0.00401560f, 0.00380530f, 
    -0.05383152f, -0.02359685f, -0.00919786f, -0.03000374f, 0.03787648f, -0.02823085f, -0.01481938f, -0.02036176f, 
    -0.04373967f, -0.03536351f, 0.02032696f, -0.05011355f, 0.01504319f, -0.02702626f, -0.01707125f, -0.02375346f, 
    -0.03362167f, 0.04666756f, -0.01946927f, 0.02907137f, -0.00009558f, -0.04491079f, -0.01529796f, 0.02714160f, 
    0.00395961f, -0.03159617f, -0.03269161f, 0.02183768f, -0.02314102f, -0.02919393f, -0.05178999f, 0.03721368f, 
    -0.03935937f, -0.01624519f, 0.01162211f, -0.01917950f, -0.00691702f, -0.02075091f, -0.03631405f, 0.04177253f, 
    -0.01557345f, 0.02824108f, -0.03425108f, -0.02110043f, 0.02308798f, -0.01917273f, 0.02165298f, -0.02244498f, 
    0.01879688f, -0.02385085f, -0.03020730f, -0.04581148f, -0.01617995f, -0.02909188f, -0.01321114f, -0.02971008f, 
    -0.00000924f, -0.02228819f, -0.03308025f, -0.03683329f, 0.02388632f, -0.00837056f, 0.03828014f, -0.02216797f, 
    -0.03175022f, -0.01289513f, -0.00590061f, -0.01667124f, 0.01169006f, 0.04425864f, -0.03639236f, 0.01932801f, 
    0.00732984f, 0.00888661f, -0.02587181f, 0.03837789f, 0.01074994f, 0.04566001f, -0.04244954f, -0.05452809f, 
    0.00121122f, -0.02294119f, 0.02094731f, -0.02281148f, 0.02516648f, -0.04022811f, -0.05477150f, -0.02012019f, 
    0.01281487f, -0.04426812f, -0.02158588f, -0.04509700f, 0.02615285f, -0.03764084f, 0.00835104f, 0.01952448f, 
    -0.00749860f, -0.02153396f, 0.01042131f, -0.02169111f, -0.00702844f, 0.00052806f, -0.04639718f, 0.02003384f, 
    -0.02690434f, 0.02342633f, 0.04506904f, -0.04787611f, 0.02095402f, 0.00003980f, 0.04324861f, -0.04393784f, 
    -0.00265216f, -0.01572125f, 0.00976391f, -0.04731144f, -0.02477925f, 0.01297858f, -0.01001604f, 0.02650161f, 
    0.00033136f, 0.03463943f, 0.04173259f, 0.03649642f, -0.05552713f, -0.03807303f, -0.02113523f, -0.02418728f, 
    0.02292364f, 0.01275135f, -0.01998121f, -0.04839756f, 0.00048730f, -0.01177137f, -0.04991015f, -0.02211623f, 
    -0.02106922f, -0.02535198f, 0.03245150f, 0.00818492f, 0.03192544f, 0.00333119f, -0.04722065f, -0.02728503f, 
    -0.02192506f, -0.04039813f, 0.00679546f, 0.00889471f, 0.01347652f, 0.04082491f, -0.00682620f, -0.02100780f, 
    -0.02791202f, 0.00761920f, 0.02261847f, -0.04227958f, -0.03741747f, -0.01813957f, -0.03246955f, 0.02647798f, 
    0.01570162f, -0.03791239f, -0.01021899f, 0.03528857f, 0.00915491f, -0.04956257f, -0.04188538f, -0.04246408f, 
    0.01622430f, 0.02805322f, -0.01461449f, 0.00648994f, -0.01985707f, 0.02409173f, 0.02774102f, 0.00941861f, 
    -0.01687695f, 0.03583170f, 0.04076516f, -0.03805945f, -0.00935861f, -0.00058540f, 0.00619608f, -0.03016875f, 
    -0.02089699f, -0.02430430f, -0.05520192f, -0.04341253f, 0.00214270f, -0.04557844f, -0.03248455f, -0.03314323f, 
    0.02327849f, -0.00889007f, -0.01414225f, 0.01933943f, -0.00201028f, -0.05543003f, -0.04724961f, -0.05398075f, 
    -0.00601515f, 0.00113922f, -0.00336203f, -0.00134233f, -0.04443732f, -0.02808429f, 0.01872249f, 0.04249151f, 
    0.02604047f, 0.00122454f, -0.02041812f, 0.01207043f, -0.03009643f, -0.00586834f, -0.01487754f, -0.04120811f, 
    -0.03625350f, -0.03588168f, 0.04377421f, -0.02546099f, -0.02311470f, 0.02823969f, -0.03364595f, 0.00336172f, 
    -0.04157066f, 0.02434922f, 0.03490974f, -0.01846870f, 0.00799914f, 0.03211877f, -0.02431889f, 0.03946946f, 
    -0.01090785f, -0.05290076f, -0.05454911f, 0.01473679f, 0.03409648f, -0.02090436f, 0.03618102f, -0.00424070f, 
    0.05350050f, -0.04744773f, -0.14459753f, 0.02680506f, 0.04348862f, 0.06810860f, 0.02452657f, 0.14730437f, 
    -0.03171727f, 0.06400848f, -0.13475932f, 0.01867970f, 0.18016283f, 0.12910721f, 0.03212222f, -0.03648458f, 
    0.06559754f, 0.14052713f, 0.01769882f, 0.07400020f, 0.02688512f, 0.01820492f, -0.12011222f, -0.12626816f, 
    -0.24939796f, -0.30735296f, 0.01035339f, 0.15045044f, -0.09815305f, 0.01508640f, -0.02716067f, -0.05509670f, 
    0.06860925f, -0.09812344f, -0.22127205f, 0.01416085f, -0.49104163f, 0.37115797f, -0.03508242f, 0.21089351f, 
    -0.06854495f, 0.28358060f, 0.08791472f, 0.28093213f, 0.04372967f, -0.16534224f, -0.04431661f, 0.15872192f, 
    0.09552523f, 0.07499894f, 0.18361750f, 0.22711597f, 0.03546718f, -0.04577530f, -0.01460611f, -0.03357187f, 
    -0.06830377f, -0.00955679f, 0.02304329f, 0.11390837f, -0.33030879f, -0.10010378f, -0.01838272f, 0.17964545f, 
    -0.07654484f, 0.03212255f, 0.03796085f, 0.09417437f, 0.06316540f, -0.18955284f, 0.10337786f, 0.08959031f, 
    0.21320689f, 0.10617780f, 0.02205886f, -0.06323641f, 0.09686852f, 0.28603697f, -0.07648870f, 0.07865363f, 
    -0.04870218f, -0.00186877f, 0.02765595f, -0.00429632f, 0.06100629f, -0.03188295f, 0.12294596f, 0.14060819f, 
    -0.03591331f, 0.03899583f, 0.01419192f, -0.04696067f, -0.00994439f, 0.05555301f, -0.07148801f, 0.01637570f, 
    0.21707718f, 0.19300440f, 0.04288715f, 0.02854276f, 0.01755990f, -0.06372318f, -0.12179203f, -0.04437731f, 
    -0.10260359f, -0.01308016f, -0.12158708f, -0.02323404f, -0.00328756f, 0.42045897f, 0.10009239f, -0.00108559f, 
    0.37608042f, 0.01735660f, 0.04724076f, -0.13755496f, 0.07019123f, -0.16666667f, -0.12415527f, -0.03791375f, 
    0.46694946f, -0.22446616f, -0.34758341f, -0.19666287f, 0.16565230f, -0.06129455f, -0.16462654f, 0.00339657f, 
    0.11330228f, 0.05191183f, -0.07710236f, -0.25246483f, 0.21069261f, -0.13575910f, 0.18794192f, 0.06837216f, 
    0.08196554f, -0.13577688f, -0.02719186f, 0.14627637f, -0.08816219f, -0.04916141f, 0.11962252f, 0.01918272f, 
    -0.85575897f, -0.27876425f, 0.63196355f, 0.33704606f, 0.05734281f, 0.11398419f, 0.08445053f, 0.01165397f, 
    0.03645344f, -0.07485244f, -0.04896818f, 0.15317805f, -0.03333690f, 0.01168257f, 0.08212247f, -0.11498346f, 
    -0.00201829f, 0.05202245f, 0.06101243f, 0.13803539f, -0.04723800f, -0.00728136f, -0.20146360f, -0.15916617f, 
    0.21659069f, -0.03403607f, 0.11237288f, 0.26946482f, 0.17580043f, 0.03731568f, 0.09952355f, -0.03498951f, 
    0.01300887f, -0.02801161f, 0.05718693f, 0.20650186f, 0.07358524f, 0.28777662f, 0.07327215f, -0.09690149f, 
    0.01461712f, 0.06113692f, 0.04576253f, 0.02767932f, 0.26877147f, -0.14469342f, -0.02707829f, -0.08752933f, 
    -0.37975150f, 0.06735990f, 0.05705167f, -0.09478198f, 0.13854945f, 0.02989917f, 0.07616808f, 0.21724027f, 
    -0.07746495f, -0.16122755f, -0.02229234f, 0.03146772f, 0.00574469f, -0.03296405f, 0.04241931f, 0.12798229f, 
    0.03031128f, -0.08213884f, 0.18400429f, -0.03036981f, 0.06810679f, 0.23676774f, 0.00044433f, 0.05342213f, 
    -0.01098161f, 0.30698234f, 0.04248719f, -0.02041554f, 0.00504097f, -0.11733304f, -0.11184122f, -0.04377670f, 
    -0.01986271f, -0.05451041f, -0.02105541f, -0.03112743f, 0.16906314f, 0.11987693f, 0.02371036f, 0.12578167f, 
    -0.11688121f, 0.11807933f, -0.06885800f, 0.07709172f, -0.02095426f, -0.07627097f, 0.08880165f, -0.00558505f, 
    0.25998315f, 0.05012901f, 0.20513384f, -0.04171227f, 0.02697683f, 0.11479941f, 0.17410058f, -0.04103085f, 
    0.06320108f, 0.04212873f, -0.05953693f, 0.06524286f, 0.16182230f, -0.17367853f, -0.22042422f, -0.06502648f, 
    -0.00443892f, -0.02879620f, -0.23177493f, 0.28658631f, -0.01673196f, -0.03677572f, 0.05799321f, -0.28309053f, 
    0.13417059f, -0.19936126f, 0.06990218f, 0.11351804f, -0.16681103f, 0.05108086f, -0.02576678f, 0.12935919f, 
    0.08329722f, 0.14930753f, 0.04476769f, -0.15885606f, 0.09158850f, 0.13579968f, -0.03900680f, 0.16628073f, 
    -0.01983382f, -0.10360147f, 0.00136817f, 0.09774065f, 0.07599291f, -0.01300472f, 0.10448824f, 0.02215307f, 
    -0.05445137f, -0.05097830f, 0.12488577f, 0.14087784f, -0.00521577f, 0.10763302f, -0.01954444f, -0.02812977f, 
    -0.15753023f, 0.04089161f, -0.03016562f, 0.09851415f, 0.02412432f, 0.19786848f, 0.17220052f, -0.10734714f, 
    -0.05118895f, -0.04982853f, 0.12792596f, 0.06709819f, 0.25332904f, 0.01491099f, 0.06415379f, 0.03965817f, 
    -0.05793257f, 0.36036158f, 0.27268881f, 0.09347562f, 0.15632667f, 0.04492354f, 0.06864303f, -0.11292517f, 
    -0.08928324f, 0.01252500f, 0.06051305f, 0.07125242f, 0.13467410f, 0.09981780f, 0.05698523f, -0.20213677f, 
    -0.01163872f, 0.18466999f, -0.12127373f, -0.03010044f, -0.04851257f, 0.00715831f, -0.07154825f, 0.06309628f, 
    0.19693096f, -0.17877670f, 0.03705927f, 0.08117977f, 0.23548031f, 0.04044589f, 0.09424378f, 0.01731337f, 
    -0.27678478f, 0.00584617f, -0.08540726f, 0.05356545f, -0.03759326f, 0.07602177f, 0.04141759f, -0.04556759f, 
    0.25141689f, 0.12577032f, 0.00868139f, 0.15340929f, -0.18945263f, 0.00201062f, 0.02298699f, -0.01028927f, 
    0.14570743f, -0.22503002f, -0.02877654f, 0.08341645f, 0.01700506f, 0.05928849f, -0.02838594f, -0.00959616f, 
    0.09541237f, -0.25182581f, 0.06245296f, -0.09314088f, -0.62758982f, 0.34270909f, 0.11332227f, -0.00078980f, 
    0.01390511f, -0.08418097f, 0.13496466f, -0.00268579f, -0.07290829f, -0.00339405f, -0.07319566f, -0.06216988f, 
    0.00761943f, -0.03550626f, 0.04310283f, -0.01133892f, 0.03657128f, -0.02403920f, -0.01209516f, 0.00356999f, 
    0.03991257f, -0.00535715f, -0.02504987f, 0.02768437f, 0.02444054f, -0.04210322f, -0.02915749f, -0.05605300f, 
    -0.00200026f, -0.04355148f, 0.01852732f, -0.01561742f, 0.01564983f, 0.01847302f, -0.05186633f, 0.04100883f, 
    -0.02206994f, 0.02243904f, -0.05273413f, 0.03523779f, -0.05004117f, -0.04339972f, -0.02096960f, -0.00447245f, 
    0.03839472f, -0.03024231f, 0.00714938f, -0.04989169f, -0.04124938f, 0.01507751f, -0.01580755f, 0.00762301f, 
    0.00504903f, 0.01063353f, -0.04486340f, -0.05855426f, -0.01863625f, 0.02819243f, 0.01987671f, 0.03359699f, 
    0.03185038f, 0.02865815f, -0.03969494f, 0.03034699f, -0.00833211f, -0.03556861f, -0.00533891f, -0.00208861f, 
    0.03575809f, -0.02475349f, -0.04878424f, -0.04134967f, 0.01896402f, 0.02849206f, -0.04555449f, 0.01250475f, 
    -0.00721413f, 0.01351293f, 0.03649883f, 0.04440142f, -0.00222062f, 0.02550671f, 0.01554209f, -0.00954731f, 
    -0.01886394f, 0.00596000f, 0.03180697f, 0.04015966f, 0.01594666f, -0.01979651f, 0.00048089f, -0.00065404f, 
    -0.00761958f, 0.00925528f, -0.04663353f, -0.04471281f, -0.00606206f, -0.04318033f, -0.03589351f, -0.02933044f, 
    -0.04355967f, -0.03975732f, -0.02129192f, 0.03812345f, 0.00864111f, 0.00916705f, -0.02611308f, 0.00910100f, 
    -0.03083791f, -0.03154688f, -0.03637592f, 0.02035394f, -0.02690826f, -0.04405816f, -0.04880819f, 0.03863123f, 
    -0.03551987f, -0.05674069f, -0.01203309f, 0.02155922f, -0.05518184f, 0.02376417f, 0.01081296f, 0.00577101f, 
    -0.04302827f, -0.05021285f, -0.00149571f, 0.03229420f, -0.04283834f, 0.01073837f, 0.00206848f, -0.01840437f, 
    0.02522459f, 0.01572813f, -0.00286577f, 0.00733962f, 0.03549261f, 0.00602791f, -0.05559304f, 0.02962492f, 
    -0.04209082f, -0.01156395f, -0.02242006f, 0.04561658f, 0.02955219f, 0.01771922f, -0.02479108f, 0.02855119f, 
    -0.04045036f, -0.03944214f, -0.01500843f, 0.01030398f, 0.01571770f, 0.02036003f, 0.01763146f, -0.01766344f, 
    0.01716398f, -0.03659693f, 0.04618111f, -0.02992786f, -0.03139601f, 0.02571976f, -0.00383521f, 0.00939760f, 
    -0.01816445f, -0.02900708f, 0.03027549f, 0.01096991f, 0.00528906f, -0.01841148f, 0.01475072f, -0.03662613f, 
    -0.01860938f, -0.04740198f, 0.02282001f, 0.00796387f, 0.03119530f, -0.01238457f, -0.00015308f, -0.02293519f, 
    0.00447466f, 0.05588039f, -0.02745599f, 0.03496156f, -0.01528256f, 0.03844381f, 0.01021814f, 0.00668555f, 
    -0.03805290f, 0.00121329f, -0.05891982f, 0.04002992f, -0.04868608f, -0.01926980f, -0.04012750f, -0.05109154f, 
    -0.01228297f, -0.03038068f, -0.02038241f, -0.01928130f, -0.05495750f, 0.02687934f, 0.00218042f, 0.03532729f, 
    0.01678127f, 0.03067140f, 0.04411875f, -0.03202079f, 0.00806121f, -0.02498939f, -0.00199446f, 0.00794803f, 
    -0.04549998f, -0.02603772f, -0.03994805f, -0.01507593f, -0.03360735f, -0.00840775f, 0.03151445f, 0.03847845f, 
    0.02862733f, -0.01075169f, 0.00109058f, 0.02876524f, 0.02689453f, 0.00164363f, -0.03394663f, -0.04925161f, 
    0.01668640f, -0.03345754f, 0.04196147f, -0.02464408f, -0.01484006f, 0.02443760f, 0.01145413f, 0.03704862f, 
    -0.02231285f, -0.05390851f, 0.00482384f, -0.05354123f, -0.01462386f, -0.01487345f, -0.00422132f, -0.00964057f, 
    -0.05411101f, -0.00023189f, 0.03972937f, -0.05255418f, 0.00765653f, -0.04970868f, 0.02688618f, 0.00969609f, 
    -0.02289699f, 0.03340973f, 0.02070139f, -0.05078256f, -0.02599380f, 0.03295755f, -0.03200775f, -0.00831785f, 
    0.00735682f, 0.03748057f, -0.01974621f, 0.03109269f, 0.02605768f, -0.04208139f, -0.02914139f, -0.04172945f, 
    0.02590690f, 0.03073285f, -0.00782434f, 0.03587674f, -0.00424894f, -0.05697739f, 0.02665514f, 0.00626126f, 
    0.00806253f, -0.03882954f, 0.03079023f, -0.05323661f, -0.02381429f, -0.01201059f, 0.04338226f, -0.04626948f, 
    0.03667285f, -0.01789971f, 0.02713553f, 0.00849965f, -0.00508267f, -0.04293206f, -0.05772104f, -0.02433334f, 
    -0.01704586f, 0.01738118f, -0.03792597f, -0.05422879f, 0.01241816f, -0.05161123f, 0.00624211f, 0.02276418f, 
    -0.00973350f, -0.00253415f, -0.03174299f, -0.03846207f, -0.02400879f, -0.04047076f, -0.02294669f, 0.01941944f, 
    -0.02557995f, 0.04179526f, -0.00178110f, -0.03691084f, -0.00763551f, -0.03762199f, -0.04636820f, 0.03760606f, 
    0.02721217f, -0.02698676f, 0.02554501f, -0.04178747f, 0.01833905f, -0.04037003f, -0.02902735f, -0.05281587f, 
    -0.01489792f, -0.00096165f, -0.02372571f, 0.03014213f, 0.00732850f, -0.00648709f, 0.03434791f, 0.00902639f, 
    -0.00440780f, -0.03381306f, -0.05516806f, 0.02310316f, 0.00531911f, -0.00339577f, -0.02274185f, -0.01734645f, 
    0.01978947f, 0.01758617f, -0.04435876f, 0.00148244f, -0.04632898f, 0.01128687f, 0.00364332f, -0.05992015f, 
    -0.02883602f, -0.02605445f, 0.02106113f, -0.02483651f, -0.04605462f, -0.03035809f, -0.03826077f, -0.02355720f, 
    -0.05407605f, -0.02015262f, -0.04917058f, -0.03383380f, 0.03157303f, 0.00425896f, 0.04157523f, -0.00546466f, 
    0.01366476f, -0.00790103f, -0.03896343f, -0.05549350f, 0.03115255f, 0.01461705f, -0.00946491f, -0.01961061f, 
    0.04398456f, 0.00322433f, -0.05946459f, 0.02387875f, 0.03547048f, -0.00358840f, -0.01083077f, -0.03588445f, 
    -0.00365487f, 0.01366500f, -0.01912885f, 0.02662995f, 0.03499131f, 0.00005479f, -0.02775548f, -0.04278552f, 
    0.03024924f, -0.05389795f, 0.00343627f, 0.03312377f, 0.01497315f, -0.01304504f, 0.04184178f, -0.04970352f, 
    -0.21428496f, 0.16708110f, -0.00250807f, 0.01059930f, -0.04399836f, -0.19150284f, -0.07053718f, 0.04071154f, 
    -0.23907095f, 0.24575430f, 0.03971372f, 0.21810342f, 0.12985700f, 0.28500658f, 0.11311635f, 0.44373229f, 
    -0.07036187f, 0.12508245f, -0.10914426f, -0.04463167f, -0.14722151f, -0.12071767f, -0.05846857f, 0.04968072f, 
    0.04575973f, -0.27067548f, 0.06464041f, 0.15824217f, -0.01211408f, 0.06780439f, 0.07407501f, -0.05993312f, 
    0.17465281f, 0.16093327f, -0.16229214f, -0.16136956f, -0.33144674f, 0.44835579f, -0.27767122f, 0.02203073f, 
    -0.19004916f, 0.05111854f, -0.15884210f, 0.06795681f, -0.20824923f, 0.08032809f, -0.07002693f, -0.13911976f, 
    -0.41477486f, -0.61144614f, -0.12387703f, -0.24288757f, -0.02224514f, -0.05570568f, 0.02492147f, -0.02040729f, 
    0.06498247f, 0.02864419f, 0.04827615f, 0.24073619f, 0.15616594f, 0.15313977f, -0.16296342f, 0.07626404f, 
    -0.05661306f, 0.09790360f, 0.06167721f, 0.13479553f, -0.16721329f, 0.08496510f, -0.10612865f, -0.01874219f, 
    -0.10156885f, -0.40118891f, 0.16361903f, -0.02479005f, -0.07055087f, -0.09224261f, -0.04549866f, -0.11045007f, 
    -0.01937675f, 0.03979695f, 0.04689566f, -0.01243194f, 0.02305296f, 0.09247938f, -0.05140954f, 0.13214295f, 
    -0.08575054f, 0.06367326f, 0.04105591f, -0.02563693f, -0.07513461f, -0.02619960f, -0.00681429f, 0.12958851f, 
    -0.26900026f, 0.28674543f, -0.07777337f, -0.38114280f, -0.09361301f, -0.10782984f, -0.21893248f, -0.15066579f, 
    0.07874894f, 0.05870537f, 0.09062474f, -0.02285327f, 0.10300754f, -0.05652073f, 0.16267899f, 0.53903878f, 
    -0.01582059f, -0.01469830f, -0.18781492f, 0.11361334f, -0.03651322f, 0.03445764f, 0.04774943f, 0.08920161f, 
    0.40808129f, 0.02141015f, 0.32852921f, 0.51502758f, 0.16065292f, -0.10173947f, 0.03008385f, 0.04862377f, 
    -0.11661464f, -0.00046133f, -0.04015954f, -0.07711530f, -0.25417635f, -0.13068548f, -0.18671855f, 0.01018732f, 
    -0.08223984f, -0.10220082f, 0.18257958f, -0.15198286f, 0.12030414f, -0.00008046f, 0.01829174f, -0.00243172f, 
    -0.10166442f, 0.40867704f, -0.34262729f, -0.16607746f, -0.08719936f, 0.10104293f, 0.07755651f, 0.04071819f, 
    -0.11081031f, -0.07438756f, 0.02307233f, 0.09073886f, 0.05616938f, 0.15447694f, -0.19177088f, 0.11625229f, 
    -0.09991472f, 0.04004852f, -0.18393467f, -0.12032559f, -0.11020361f, 0.12837569f, 0.04087560f, 0.36525264f, 
    -0.67337847f, -0.62011892f, 0.07236399f, -0.02456857f, 0.02014623f, 0.01377079f, 0.03643955f, -0.18113884f, 
    -0.09848343f, -0.01918522f, 0.04714876f, 0.28106117f, 0.28102556f, 0.24803093f, 0.31813848f, 0.20921756f, 
    0.03065068f, -0.01874040f, 0.14703491f, 0.14045365f, -0.10074316f, 0.12816215f, 0.14159171f, 0.07094190f, 
    0.53223920f, 0.15380818f, 0.05694943f, 0.35758850f, -0.09534103f, -0.07714350f, -0.01773530f, 0.07257558f, 
    0.06916931f, -0.00905900f, -0.01412551f, 0.04069814f, 0.32802182f, -0.03869184f, 0.18597558f, -0.37611881f, 
    -0.06006069f, -0.09486816f, 0.19473134f, 0.13261700f, -0.25889406f, 0.02514545f, 0.10683446f, -0.14172573f, 
    0.01285483f, 0.29779729f, 0.08551060f, 0.19841641f, 0.20422901f, 0.06737261f, -0.09084622f, 0.08221859f, 
    0.02738967f, 0.08653197f, 0.13617279f, -0.03946987f, -0.41625488f, 0.01694043f, -0.16943043f, -0.00165844f, 
    -0.17744075f, 0.06417230f, -0.09354316f, 0.05422517f, 0.04111688f, 0.05504865f, 0.10325458f, -0.08734601f, 
    -0.18918581f, 0.19498795f, -0.24129571f, -0.15253228f, 0.05400664f, -0.23179448f, 0.10550496f, 0.10763308f, 
    -0.09421087f, -0.05234926f, -0.17097521f, 0.06235371f, -0.29308847f, 0.23654342f, 0.19621788f, 0.23547381f, 
    -0.01670990f, -0.18036506f, -0.20014878f, 0.10909387f, 0.17886519f, 0.02173091f, -0.05275230f, 0.23860109f, 
    -0.10374285f, 0.10826809f, -0.00502736f, 0.16402076f, -0.05924157f, 0.06327056f, 0.14079756f, 0.04857030f, 
    0.10883991f, -0.14413388f, 0.19832443f, -0.20461580f, -0.16809613f, -0.09386681f, -0.07835680f, -0.23354596f, 
    0.03159914f, -0.05156633f, 0.09705390f, -0.03366658f, -0.09452961f, 0.03216926f, -0.03974296f, 0.21628776f, 
    0.02358448f, -0.13518758f, 0.10439539f, -0.03186331f, -0.01620894f, -0.27203196f, 0.24101844f, -0.01706099f, 
    -0.14720276f, 0.10090021f, 0.01397044f, 0.10278635f, 0.09827808f, -0.27116477f, 0.12224342f, 0.30512539f, 
    0.09879236f, 0.01717438f, -0.04382643f, 0.04831729f, -0.12192608f, 0.00756975f, -0.09795951f, 0.09721988f, 
    0.18426932f, -0.15770152f, 0.06817511f, 0.29811361f, -0.09642249f, 0.11149289f, 0.10876710f, 0.12088747f, 
    -0.01806489f, -0.00037051f, -0.11201235f, -0.18533896f, 0.04414652f, -0.08923299f, -0.24071193f, 0.41324893f, 
    -0.13592210f, 0.05735040f, 0.03922566f, 0.14895488f, -0.03130675f, -0.05346716f, 0.04122269f, -0.10034665f, 
    -0.18991436f, -0.70363545f, 0.23306218f, -0.30420548f, 0.07174072f, 0.15881188f, -0.17291856f, -0.07589824f, 
    0.13085917f, -0.10616013f, -0.05764508f, 0.14336666f, -0.07446057f, -0.12702721f, -0.02086846f, 0.24675380f, 
    0.01230985f, -0.03306516f, 0.01472048f, -0.00329325f, -0.01780527f, 0.11520953f, -0.01761977f, 0.15178560f, 
    -0.24050671f, -0.01967611f, 0.09056903f, -0.22210388f, -0.05352896f, -0.15908414f, -0.12107320f, -0.00614929f, 
    -0.03194892f, -0.15418024f, -0.06504300f, 0.12732063f, 0.29985085f, 0.34262872f, 0.22467747f, 0.49462157f, 
    -0.10450736f, 0.22921647f, -0.04248273f, 0.05577097f, -0.07158395f, 0.10141603f, -0.02113279f, -0.14491752f, 
    -0.17468426f, -0.21071082f, -0.15408844f, -0.14784414f, 0.04071927f, 0.05668645f, -0.02644476f, -0.13838059f, 
    -0.09798075f, -0.04748591f, -0.08344869f, -0.20045736f, 0.16840364f, 0.16265832f, 0.08320829f, 0.18666707f, 
    -0.06785678f, 0.22956999f, 0.17951852f, 0.04202633f, 0.11603517f, 0.26030275f, 0.06749948f, 0.05259926f, 
    -0.18969181f, -0.04018774f, 0.07511588f, 0.12296542f, -0.03157192f, -0.13015562f, -0.05796970f, -0.12349606f, 
    0.21984234f, -0.05334666f, -0.29774985f, -0.12186538f, -0.19587265f, -0.05530920f, 0.16776468f, 0.13880911f, 
    -0.03306062f, -0.07576966f, -0.13026355f, 0.14967176f, -0.00495858f, -0.26940313f, -0.01410023f, 0.09742329f, 
    -0.19695266f, 0.07825298f, 0.13261190f, 0.31365910f, 0.05526533f, -0.06702530f, -0.16677950f, -0.04387078f, 
    -0.02127423f, -0.02471290f, -0.17192298f, 0.08497660f, -0.21887067f, -0.35874230f, -0.37251979f, -0.11381843f, 
    -0.00860751f, -0.11603677f, -0.04196556f, -0.15459247f, 0.13962203f, -0.02459362f, 0.02793194f, 0.23992935f, 
    0.16660608f, 0.10934559f, 0.16322049f, 0.20116247f, 0.18562314f, 0.09430266f, -0.17513606f, 0.20009582f, 
    -0.01039740f, -0.00593322f, -0.03629719f, 0.04551585f, 0.02495803f, -0.19215305f, -0.05543188f, -0.13590820f, 
    0.02283441f, 0.19901337f, 0.06075801f, -0.15746966f, 0.20209284f, 0.13259086f, 0.04741514f, 0.19418439f, 
    -0.19139975f, -0.26600841f, 0.09154439f, 0.01962452f, 0.20030206f, -0.03601437f, -0.20644695f, 0.09780076f, 
    -0.13740569f, 0.03539493f, -0.19632468f, -0.19938414f, 0.20937449f, 0.25761417f, 0.31307670f, 0.11444680f, 
    0.14462198f, 0.10564762f, 0.22182778f, 0.19138025f, -0.04630016f, -0.05097202f, -0.04675182f, 0.04378253f, 
    0.34371850f, 0.17466882f, -0.33555055f, -0.16402581f, -0.06800266f, 0.18593304f, 0.00604827f, 0.07933745f, 
    0.15075068f, 0.13146275f, 0.13150716f, -0.07621817f, 0.08340678f, -0.02477959f, -0.13965678f, 0.07303885f, 
    0.20252565f, -0.06978020f, 0.17132314f, 0.07466576f, 0.26319167f, 0.08435467f, 0.17604452f, 0.08371782f, 
    -0.22102901f, -0.33321151f, 0.21127620f, 0.15435618f, 0.23185389f, -0.20342299f, -0.00316752f, 0.08038665f, 
    0.15281445f, 0.07684067f, 0.02366016f, 0.21750432f, 0.08977408f, -0.11425283f, 0.14908621f, -0.08151308f, 
    0.01630273f, -0.07477513f, -0.04186578f, -0.03018485f, 0.04890849f, -0.00685510f, -0.23670138f, -0.48162866f, 
    -0.31205270f, 0.03818521f, -0.08833244f, 0.23418613f, 0.05007929f, 0.01951750f, -0.02982307f, -0.14206438f, 
    0.03969207f, 0.03786796f, -0.05453076f, 0.35292983f, 0.17786175f, 0.11199541f, -0.08567683f, -0.03970261f, 
    0.14280616f, 0.06599552f, 0.13773462f, -0.00614408f, 0.12342256f, -0.14091039f, -0.15791561f, -0.08646432f, 
    -0.07832874f, 0.08452765f, -0.26458552f, -0.21762095f, -0.05219689f, -0.00513395f, 0.06519540f, 0.04127136f, 
    0.01475651f, -0.10023223f, -0.05669685f, -0.03985697f, 0.06670796f, 0.02228933f, -0.37815145f, -0.22289981f, 
    0.03160867f, 0.07067181f, 0.13731037f, 0.01799433f, 0.08990254f, 0.21832934f, -0.02419247f, 0.27146077f, 
    0.27404076f, 0.43437618f, 0.09192079f, 0.01098875f, 0.07547169f, 0.00304403f, 0.12497785f, 0.11513878f, 
    -0.07325960f, -0.09948512f, 0.00367884f, -0.13956270f, 0.07031055f, -0.05550013f, -0.10183544f, -0.05687435f, 
    -0.01321215f, 0.02289430f, -0.10801031f, -0.00010560f, 0.03111251f, 0.04553389f, 0.06393472f, -0.03385595f, 
    0.17800027f, 0.23835939f, 0.25425214f, 0.18593383f, 0.03538597f, -0.04009447f, 0.09373800f, 0.25489897f, 
    0.00123592f, -0.00879639f, -0.13846619f, 0.03689454f, -0.05905294f, -0.34847143f, -0.03067634f, 0.04943383f, 
    0.00853248f, 0.00800818f, -0.12836005f, 0.16181095f, -0.12322013f, 0.16015103f, -0.13881557f, -0.37537816f, 
    -0.05568701f, -0.06088798f, -0.15031448f, -0.03476187f, -0.19096808f, -0.14484763f, 0.06243248f, 0.01041578f, 
    -0.01125535f, 0.04641112f, 0.05150505f, 0.08780279f, -0.05264443f, 0.06492230f, -0.04772328f, 0.00543155f, 
    -0.01589332f, -0.08322942f, -0.16544256f, 0.04357387f, 0.05618743f, 0.05295950f, 0.03348638f, 0.06246340f, 
    -0.05986866f, -0.01062528f, -0.08334590f, -0.18284167f, 0.10521690f, 0.08519413f, 0.15053454f, 0.02529535f, 
    0.24472910f, 0.05655141f, 0.11250029f, 0.01945633f, 0.14678115f, 0.35919169f, 0.34196556f, -0.04640288f, 
    -0.03403960f, -0.07813916f, 0.17149070f, 0.09367614f, 0.12059383f, -0.04689424f, -0.17231992f, -0.13655964f, 
    0.13360164f, 0.45383343f, 0.30743051f, 0.10869134f, -0.08059996f, -0.03150903f, 0.19885345f, -0.00945668f, 
    0.01509671f, -0.00568773f, 0.03032547f, 0.01838399f, 0.38525191f, 0.24046639f, 0.23462859f, 0.12940358f, 
    -0.00324823f, 0.09039974f, 0.18351184f, 0.06586564f, 0.03791723f, 0.08072793f, -0.07280949f, 0.04549784f, 
    -0.14586638f, 0.08924808f, 0.13856867f, 0.02303293f, 0.19911122f, 0.04812855f, -0.08205661f, 0.23527756f, 
    -0.04346759f, 0.18981402f, -0.04201144f, 0.15908113f, -0.11743436f, -0.03865434f, -0.13806093f, -0.26685426f, 
    -0.09237204f, -0.08287561f, 0.16306297f, 0.07421826f, -0.05188920f, 0.05793184f, 0.09952630f, 0.03325500f, 
    -0.18534087f, -0.03128231f, -0.05213694f, 0.05956768f, 0.13701516f, -0.03915901f, -0.17842919f, -0.10116189f, 
    -0.11033518f, -0.29347372f, -0.06006819f, -0.32982871f, -0.05181267f, 0.48305339f, 0.04390918f, 0.09043653f, 
    0.21398045f, 0.31646332f, 0.08143666f, 0.04791619f, -0.03410198f, 0.00116483f, 0.00718311f, 0.04624991f, 
    -0.12973870f, 0.07554148f, 0.06086045f, 0.03437183f, 0.00875707f, -0.02525272f, -0.01704987f, -0.10088057f, 
    0.15785874f, 0.21015304f, 0.05439449f, -0.14282823f, -0.10374662f, 0.07652414f, 0.00066533f, 0.10992247f, 
    -0.00176054f, 0.02010801f, 0.00493513f, 0.08941089f, -0.03505996f, 0.05558282f, -0.11202332f, -0.04867975f, 
    -0.10660920f, 0.34045982f, -0.04840679f, 0.01535140f, -0.02045820f, 0.01633798f, 0.00332967f, -0.23918299f, 
    0.20372988f, -0.01804963f, -0.02853684f, 0.05360503f, 0.14653264f, 0.24326107f, -0.15809081f, 0.06874379f, 
    0.00136608f, 0.05552319f, -0.18784286f, 0.12914996f, 0.08501916f, 0.20147744f, 0.06163507f, 0.05763945f, 
    0.21755080f, 0.36619717f, 0.26330686f, -0.16495259f, -0.11215274f, -0.10571980f, -0.04494807f, 0.05293768f, 
    -0.15577407f, -0.03246050f, -0.09886167f, -0.03098461f, -0.25244105f, 0.05332562f, -0.07709367f, -0.01721161f, 
    0.03283733f, -0.03998043f, -0.07650079f, -0.02536898f, -0.04746747f, 0.21512656f, 0.11080900f, 0.16392326f, 
    0.51851904f, -0.47646320f, 0.57074428f, -0.17489058f, -0.12671767f, 0.04839710f, 0.08611190f, 0.09130260f, 
    -0.12878516f, 0.07922170f, -0.09761436f, 0.04378178f, 0.24465024f, -0.03234486f, -0.08686455f, -0.05239560f, 
    0.05858657f, 0.10965472f, -0.21550338f, 0.02626618f, -0.06658120f, 0.04700476f, 0.04897092f, 0.07407692f, 
    0.25836900f, -0.32463264f, 0.03927078f, -0.42761230f, -0.16787335f, -0.07136030f, -0.09063587f, 0.01609794f, 
    -0.12233368f, -0.13479267f, -0.00178831f, -0.06164084f, -0.43842232f, -0.23616114f, 0.02833496f, 0.03581640f, 
    0.16025071f, 0.08366433f, -0.08240338f, 0.08596548f, -0.19988348f, 0.11120744f, -0.00377092f, -0.06030354f, 
    0.25087482f, 0.00564562f, 0.14328031f, 0.31896424f, -0.11257955f, 0.00579632f, 0.18619063f, 0.01933316f, 
    -0.02665962f, 0.19997659f, 0.15168944f, 0.07261895f, 0.12734218f, 0.09277258f, 0.00700196f, 0.17069063f, 
    0.12861957f, 0.04701631f, 0.23172867f, -0.00082227f, 0.24725522f, 0.14839607f, 0.12076497f, 0.14981954f, 
    0.31420574f, -0.02875485f, -0.36022744f, -0.22072908f, -0.14068218f, -0.01161361f, -0.04923262f, 0.13226457f, 
    0.05847254f, -0.02942695f, 0.23980582f, 0.12487312f, 0.03889697f, 0.02816060f, -0.12114617f, -0.04945795f, 
    0.03719106f, 0.03614903f, -0.08423530f, 0.04808965f, 0.00575783f, 0.16647421f, 0.08084214f, -0.21533215f, 
    0.38634342f, 0.36355305f, 0.23144703f, -0.00546038f, -0.12604980f, -0.02324144f, 0.02904806f, -0.04101406f, 
    0.15170498f, -0.05757026f, 0.13330767f, 0.14473452f, -0.10419530f, -0.12251059f, 0.03621696f, 0.04015150f, 
    0.11383285f, -0.04180022f, 0.13163224f, 0.07445458f, 0.05306967f, 0.13333553f, 0.11070143f, 0.08804204f, 
    -0.02650554f, -0.00571373f, -0.02909132f, 0.16771577f, 0.03486601f, 0.07167638f, -0.01301747f, 0.07883905f, 
    0.02003248f, 0.04164721f, -0.08067070f, -0.12097555f, -0.13317077f, -0.25349593f, -0.11248501f, 0.08997129f, 
    -0.09825867f, 0.10820890f, 0.14084196f, -0.03245238f, -0.03349129f, 0.12959455f, 0.09401634f, -0.08073653f, 
    -0.00345912f, 0.04538707f, 0.00319515f, -0.01067670f, 0.08559938f, -0.02552749f, -0.01134354f, -0.06509752f, 
    0.05268028f, -0.10552522f, -0.00138404f, -0.05763411f, 0.19497959f, 0.29582888f, 0.01088544f, 0.08812219f, 
    -0.19487593f, -0.04215039f, -0.05680923f, -0.11947557f, -0.09777438f, 0.06918029f, 0.08402960f, -0.00224476f, 
    -0.31833750f, -0.03080402f, -0.19831520f, 0.05519931f, 0.11785495f, 0.01621314f, 0.04731544f, 0.13738209f, 
    0.11106402f, 0.13961159f, 0.04953234f, 0.09339573f, 0.15756708f, 0.00138407f, 0.42987889f, 0.07839640f, 
    0.03366985f, -0.06415834f, 0.02754600f, 0.12217534f, 0.08068153f, 0.28670478f, 0.09810169f, -0.03103977f, 
    -0.23929320f, -0.10045511f, 0.05630994f, -0.07974210f, 0.02115311f, -0.03509700f, 0.19509017f, -0.09273372f, 
    0.16047670f, -0.07788061f, 0.10824900f, 0.01314361f, 0.12046985f, 0.26450205f, 0.12560424f, 0.12380265f, 
    -0.02403609f, -0.09191735f, 0.11800249f, 0.04883858f, -0.07692775f, 0.15813063f, -0.05037236f, 0.02115735f, 
    0.00344417f, -0.14007451f, 0.03985785f, -0.18469225f, 0.11487297f, 0.01593596f, 0.19130170f, 0.13477561f, 
    0.15730657f, 0.01961121f, 0.15957128f, -0.02316302f, -0.26816630f, -0.16980484f, 0.12710239f, -0.11378293f, 
    -0.03557158f, -0.15353192f, 0.00012157f, 0.03214553f, -0.01387044f, 0.10775361f, -0.03262883f, -0.05107446f, 
    0.03444286f, -0.04651004f, -0.09248377f, 0.03444836f, -0.02019327f, 0.05893863f, 0.06552986f, -0.07289615f, 
    -0.03154668f, -0.06274741f, -0.15357187f, -0.19930854f, -0.05672330f, -0.32287717f, -0.08665315f, 0.12887189f, 
    -0.00307250f, 0.12372392f, 0.09610484f, 0.08154372f, -0.04598052f, 0.07724958f, 0.02157404f, -0.02111024f, 
    -0.02631143f, -0.34991229f, 0.23243350f, -0.46891937f, 0.14277740f, -0.02714957f, -0.09318349f, 0.17702837f, 
    0.04837454f, -0.10283101f, 0.06825760f, 0.17412859f, -0.29278585f, -0.16089956f, -0.06613300f, 0.01935088f, 
    -0.03848955f, -0.01721190f, 0.19373879f, -0.01436035f, 0.30577993f, 0.05133411f, -0.16564468f, -0.18246701f, 
    0.06639498f, 0.06369791f, 0.36372137f, -0.22029971f, -0.06598935f, -0.09025447f, -0.11146560f, -0.08228297f, 
    -0.15430410f, -0.02666731f, -0.19740728f, -0.18702550f, 0.18020779f, 0.25176427f, 0.08296318f, 0.33545589f, 
    0.21899985f, -0.02061971f, -0.04373989f, -0.10215990f, -0.12484203f, 0.06099078f, 0.08770635f, 0.02166552f, 
    -0.02936178f, -0.01692184f, 0.02326598f, -0.02614198f, 0.03733391f, -0.04524316f, -0.00111836f, -0.04362408f, 
    -0.04775968f, 0.02631339f, -0.04839676f, 0.00399598f, -0.04367764f, -0.03497675f, -0.03550925f, -0.04906103f, 
    0.00710918f, -0.04823733f, -0.01052508f, -0.05044794f, -0.04033485f, -0.02671318f, -0.00346830f, -0.02552649f, 
    0.04124682f, 0.00481137f, -0.04866651f, 0.02980117f, -0.04303101f, 0.04408563f, 0.01787989f, 0.00526214f, 
    -0.01012793f, -0.03504565f, -0.00317202f, -0.05088383f, -0.01251812f, -0.04783303f, -0.02891196f, 0.00706594f, 
    -0.04977407f, -0.02271271f, 0.01641355f, -0.00373194f, 0.04214321f, -0.02343024f, -0.02824530f, 0.00732772f, 
    -0.03067299f, 0.03929155f, -0.04235476f, 0.00989394f, -0.01874249f, -0.01340822f, -0.02420759f, 0.04175044f, 
    0.01464279f, 0.03774974f, 0.00834487f, -0.00679833f, -0.04529552f, -0.00419810f, 0.01069910f, -0.00938902f, 
    0.02668196f, -0.01558310f, 0.03531392f, 0.01789436f, -0.02209315f, 0.04271696f, 0.00233235f, 0.02849041f, 
    0.01286437f, -0.03591349f, 0.01476770f, 0.04927192f, -0.04707531f, -0.00820251f, -0.04919226f, 0.04662974f, 
    0.00416759f, -0.01469042f, -0.03093989f, -0.04938206f, 0.00252029f, 0.00689744f, -0.04467170f, 0.00557158f, 
    0.01247655f, 0.01688226f, -0.01675358f, -0.02142392f, -0.01571117f, 0.00688278f, -0.02298275f, -0.02902123f, 
    0.01232479f, -0.02004748f, -0.00370221f, 0.00525981f, 0.00434212f, -0.03446717f, 0.01799787f, -0.01177078f, 
    -0.01147618f, 0.04319637f, -0.00557853f, 0.04164178f, 0.03881342f, -0.04575456f, -0.02325038f, 0.02773478f, 
    0.01851464f, -0.03436594f, -0.02554107f, 0.02450144f, 0.02289375f, -0.05065979f, 0.03965540f, -0.04369992f, 
    0.02008216f, 0.00498057f, -0.00414496f, 0.02137282f, -0.03409534f, -0.02394690f, -0.04374710f, 0.00486206f, 
    -0.04168905f, -0.01813797f, 0.04909742f, -0.04281443f, -0.02196322f, -0.02566830f, -0.00140350f, 0.02070876f, 
    0.00881279f, 0.00181488f, 0.01978618f, 0.05078523f, 0.03077560f, -0.03260669f, -0.04457073f, -0.04770003f, 
    0.03269365f, -0.04914151f, 0.03250342f, -0.03365707f, 0.03674432f, -0.00529433f, 0.00791854f, -0.04590614f, 
    0.00682372f, 0.01773229f, 0.03013349f, 0.03842446f, 0.00474327f, 0.02629579f, 0.03501237f, -0.04437196f, 
    0.00232988f, 0.00540067f, 0.00713411f, -0.00843657f, 0.03089027f, 0.01436862f, 0.00016180f, -0.03953760f, 
    0.02687010f, -0.03614056f, -0.03241570f, 0.01927423f, 0.03559945f, -0.03504798f, -0.03513101f, 0.04183110f, 
    0.00143498f, -0.00396136f, -0.04292302f, 0.03712255f, 0.01408552f, -0.01572610f, -0.04917916f, -0.00698994f, 
    -0.01667006f, -0.00073839f, -0.01327964f, 0.04410639f, -0.00791447f, -0.00014061f, 0.03046129f, 0.00896442f, 
    -0.02601741f, -0.04088057f, -0.02051443f, 0.03669274f, -0.00600059f, -0.00109732f, 0.02931743f, 0.03693702f, 
    -0.01797591f, 0.00299823f, 0.04072394f, 0.01864389f, -0.04235327f, 0.00313210f, 0.04689353f, 0.00538299f, 
    -0.01441398f, 0.01546474f, 0.01778912f, -0.01722922f, -0.03667956f, 0.03207506f, -0.01033556f, -0.01722115f, 
    0.00114214f, -0.03583242f, -0.03718772f, 0.03550009f, -0.03388577f, 0.00331835f, 0.04785164f, -0.00757768f, 
    -0.04278508f, -0.00750846f, -0.03023218f, -0.00634889f, -0.03979550f, -0.01901540f, 0.01085986f, -0.01847811f, 
    -0.00728279f, 0.02051006f, 0.04317474f, -0.02474398f, 0.01390480f, -0.02942549f, 0.02896221f, 0.02203522f, 
    0.03682116f, 0.02934494f, 0.03101218f, -0.03387077f, -0.01695093f, 0.04313169f, -0.01452450f, -0.03498316f, 
    -0.00131714f, 0.00511935f, -0.01359197f, -0.02912312f, 0.04956548f, 0.00738347f, -0.05013690f, 0.01772839f, 
    -0.01682360f, -0.03246381f, -0.03706184f, -0.03109591f, -0.04730069f, 0.03662263f, -0.04626226f, 0.02232091f, 
    0.03775439f, -0.01561430f, 0.03642998f, -0.04370620f, -0.00532262f, 0.02170360f, -0.00774488f, -0.03954826f, 
    0.01504592f, 0.00614963f, -0.01284894f, 0.03607431f, -0.04354823f, -0.02545662f, 0.01809254f, -0.00013828f, 
    -0.01348540f, 0.04796889f, -0.01214716f, -0.03528795f, -0.03229931f, -0.04254221f, -0.02814840f, -0.03548841f, 
    0.05036316f, -0.04393280f, 0.00043464f, -0.00713125f, -0.02374491f, -0.00742195f, 0.04130457f, 0.01434952f, 
    0.01446534f, -0.01495916f, 0.01260353f, -0.01420329f, 0.00043491f, -0.00108030f, -0.03043062f, -0.00247421f, 
    0.04166531f, -0.05038419f, 0.00926335f, -0.02077878f, -0.01386030f, -0.00392386f, 0.04457558f, 0.03355774f, 
    0.01560745f, 0.00757350f, -0.03352653f, 0.02814347f, -0.03252182f, -0.04924056f, 0.00141578f, 0.03950231f, 
    -0.02787751f, -0.03841948f, -0.00739040f, 0.02501878f, -0.02307331f, -0.01340566f, -0.01660661f, 0.00724017f, 
    -0.00045961f, -0.02792849f, 0.02311914f, -0.01295426f, 0.00015321f, -0.00644379f, -0.03888179f, 0.00311010f, 
    0.03397612f, 0.04318941f, 0.03003771f, -0.01582748f, -0.02489223f, 0.02690719f, -0.00803097f, -0.03488831f, 
    0.01599845f, 0.03017042f, 0.01101271f, 0.00672947f, -0.01753505f, 0.01060882f, -0.00051493f, -0.00693298f, 
    -0.03788085f, 0.05030322f, 0.00329796f, -0.00334265f, 0.04875980f, 0.03691038f, -0.01735337f, 0.01526662f, 
    -0.04129465f, 0.04481488f, -0.04475719f, -0.04222905f, 0.03152940f, 0.02523459f, 0.04207931f, -0.01423926f, 
    -0.04367629f, -0.02155896f, -0.00663177f, -0.04804594f, 0.02052592f, -0.01234234f, -0.01555789f, 0.01769205f, 
    0.02667103f, -0.04798227f, -0.01731954f, 0.04702401f, -0.04466647f, 0.02284932f, -0.01529416f, 0.03248278f, 
    0.17867720f, -0.19044675f, 0.18150982f, -0.10915613f, -0.28726369f, 0.05030698f, 0.16070148f, 0.07030874f, 
    -0.11625969f, 0.07797807f, 0.10266825f, 0.15750015f, 0.07702564f, -0.06288449f, -0.04739554f, -0.12769589f, 
    0.01399501f, 0.06364994f, -0.07299751f, -0.11457447f, -0.08958396f, -0.25896972f, -0.12500708f, -0.04930491f, 
    0.34867585f, 0.12613098f, -0.13357572f, 0.07662219f, -0.17725451f, -0.12436450f, -0.15372072f, -0.11325806f, 
    0.19786857f, 0.08259503f, 0.16654646f, 0.03380163f, -0.02172537f, -0.02093297f, 0.33466354f, 0.02066400f, 
    0.03582887f, -0.00490498f, -0.04321145f, -0.53116322f, 0.13009238f, -0.02305252f, -0.02145141f, -0.02051876f, 
    0.11192483f, -0.11879727f, 0.08334351f, 0.26414412f, -0.16441110f, 0.14308314f, -0.00754220f, -0.19328669f, 
    0.01613322f, 0.04018022f, -0.09947310f, 0.06431972f, 0.39486319f, -0.16826257f, 0.11285001f, 0.04493140f, 
    0.04305359f, 0.04430848f, -0.17633079f, -0.46810415f, 0.08620335f, 0.03104470f, 0.02238772f, -0.00633816f, 
    -0.10696825f, 0.49360880f, -0.18042853f, 0.27855772f, 0.11771054f, 0.01099519f, 0.25981441f, 0.09822626f, 
    -0.00207459f, 0.00008866f, -0.10618674f, -0.14715387f, -0.12241367f, 0.16486618f, -0.12766281f, 0.11453121f, 
    0.03173462f, -0.24115922f, 0.17545083f, -0.14440052f, -0.33470935f, -0.27264863f, -0.40508988f, -0.65574205f, 
    0.25768939f, 0.49243906f, 0.09484690f, 0.07376656f, 0.01956413f, -0.05123897f, 0.15133491f, 0.17217167f, 
    0.09013611f, 0.01899950f, 0.01559956f, 0.06107979f, 0.55163080f, 0.21014145f, -0.03056296f, -0.06457826f, 
    -0.11820839f, 0.15608993f, 0.04425672f, 0.11451498f, 0.12887116f, 0.03119548f, 0.08315473f, -0.03789365f, 
    0.09243661f, -0.33473724f, -0.14943090f, -0.12746391f, -0.03040550f, 0.00077332f, -0.13310990f, -0.03455620f, 
    0.08917435f, -0.03922033f, 0.00126057f, 0.05188321f, -0.40855831f, 0.25213966f, 0.07434865f, -0.06262629f, 
    0.06464867f, 0.01212701f, 0.02785854f, -0.31618223f, -0.07096303f, -0.14387424f, -0.16915593f, -0.13574319f, 
    -0.18266097f, 0.36443317f, 0.37875563f, -0.01701922f, -0.01359246f, 0.16626427f, 0.05391649f, -0.25486061f, 
    -0.07606642f, -0.26370707f, -0.11318665f, -0.16309361f, 0.22970289f, 0.12759717f, 0.14944002f, 0.16692927f, 
    0.06361899f, 0.13921264f, 0.12135627f, -0.08896682f, 0.01110040f, -0.06050194f, 0.03486971f, 0.21679839f, 
    -0.10506788f, -0.03201486f, 0.16221145f, 0.00411663f, -0.08036837f, 0.09943023f, -0.07317635f, 0.09504172f, 
    -0.25324735f, 0.11088978f, -0.17743917f, -0.18022977f, 0.32351705f, -0.19893171f, -0.21267736f, 0.22103532f, 
    0.03446904f, 0.09707473f, 0.00386353f, -0.00306786f, 0.08672860f, 0.04928185f, 0.10310659f, 0.06290332f, 
    0.25800517f, -0.25308606f, -0.22006796f, -0.13504228f, 0.00797174f, -0.07942214f, -0.14942950f, -0.28450337f, 
    0.07650595f, -0.01275136f, 0.02461687f, 0.15355177f, 0.24831136f, 0.26034957f, -0.10441858f, -0.00627985f, 
    -0.16410740f, 0.00361625f, -0.17246668f, 0.05494410f, 0.00498510f, -0.05887181f, 0.02336617f, 0.09094784f, 
    0.19313332f, -0.05900276f, 0.00949145f, -0.07848498f, -0.04255585f, 0.01776144f, 0.07577232f, 0.07951412f, 
    0.22921783f, 0.14566664f, 0.10929412f, 0.15984981f, 0.23142056f, -0.03233159f, 0.22993998f, -0.06585238f, 
    0.14222006f, -0.09873000f, 0.11619505f, -0.12212584f, -0.16278701f, -0.23884518f, -0.35797483f, -0.36033967f, 
    0.21580844f, 0.11079640f, 0.02826134f, 0.05091400f, 0.02866294f, -0.11585369f, 0.05184521f, 0.23015422f, 
    0.01216780f, 0.03474323f, 0.03600699f, -0.07072939f, -0.30443743f, -0.07595874f, -0.11898631f, 0.14173168f, 
    -0.06213553f, 0.06348795f, 0.04149761f, 0.09838630f, 0.11094918f, -0.12737389f, 0.04530540f, 0.28674796f, 
    0.17825061f, 0.06663732f, -0.04215499f, 0.20285060f, -0.08813455f, 0.11093859f, -0.27217269f, -0.51491284f, 
    0.05290342f, -0.15571441f, -0.03660562f, -0.09174605f, 0.18176588f, 0.01834100f, 0.02144917f, -0.05866209f, 
    -0.05429143f, -0.05400294f, -0.21884234f, -0.10121013f, -0.04495618f, -0.03355771f, -0.04348456f, -0.08319697f, 
    0.00031575f, 0.14780007f, -0.28627291f, -0.21918623f, 0.04956417f, -0.08944438f, -0.04861484f, -0.01508591f, 
    -0.21281439f, 0.08295869f, -0.04111509f, -0.16124645f, 0.37288409f, 0.12988739f, -0.11276972f, 0.22233643f, 
    0.18900418f, 0.22294174f, 0.00477908f, 0.18351685f, -0.04017401f, -0.04271441f, 0.04850514f, 0.06133271f, 
    0.22273380f, 0.03220201f, -0.11948440f, -0.11687605f, 0.07877516f, -0.01750713f, -0.05087087f, 0.30162513f, 
    -0.08275671f, -0.01239868f, 0.11320697f, 0.04429397f, 0.13418561f, 0.34315410f, -0.04124105f, 0.04172525f, 
    -0.06579946f, -0.04878557f, 0.16763990f, 0.14479746f, -0.16429764f, -0.10261466f, -0.07047992f, -0.17616971f, 
    -0.05436263f, 0.75237679f, -0.17885520f, 0.37335256f, -0.05565432f, -0.07652317f, -0.00186270f, 0.09434139f, 
    -0.03045103f, -0.02259499f, -0.10467509f, -0.05200746f, 0.36806938f, 0.13296786f, -0.03329374f, -0.16479775f, 
    0.19241795f, 0.02633383f, 0.06369849f, 0.09638788f, -0.05907685f, 0.09465311f, 0.12269479f, 0.03732581f, 
    -0.06886230f, 0.09344867f, 0.14520758f, 0.15644746f, -0.11512787f, 0.19833227f, 0.17236631f, 0.16993737f, 
    0.17068358f, 0.14933127f, 0.09676407f, 0.33236027f, 0.17827637f, -0.19651715f, -0.22026882f, -0.42768812f, 
    -0.12319955f, 0.10407312f, -0.08296292f, -0.10072736f, 0.14848939f, 0.06640410f, 0.00116991f, -0.08450884f, 
    0.03320682f, -0.02259101f, 0.04648626f, -0.01370493f, 0.03881373f, -0.05939706f, 0.03162890f, 0.02877716f, 
    -0.01675178f, -0.02575962f, -0.05883061f, -0.04043118f, -0.02470355f, -0.02834234f, 0.02211744f, 0.02005632f, 
    -0.03296375f, -0.00063835f, 0.01765509f, 0.04315843f, 0.01912444f, 0.03211775f, 0.03727667f, -0.04834929f, 
    0.04175026f, 0.00387010f, -0.03501669f, 0.02343720f, 0.00006054f, 0.02156501f, -0.05013813f, -0.00771142f, 
    -0.05312187f, 0.01770728f, -0.03098211f, -0.05938642f, -0.01369715f, 0.00188616f, -0.04615209f, -0.04930830f, 
    0.03248464f, -0.01099570f, -0.03757816f, 0.03023914f, 0.02706919f, -0.00855293f, -0.02155558f, -0.04585782f, 
    -0.05410870f, -0.01741877f, 0.04835143f, -0.04658804f, -0.02436084f, -0.04977494f, 0.02054399f, -0.02965231f, 
    -0.01313446f, 0.00491864f, -0.01534918f, -0.03749504f, 0.02729234f, -0.00025457f, 0.02832450f, 0.03169185f, 
    -0.02844353f, 0.02341851f, -0.03742678f, 0.01257093f, 0.01691963f, -0.01999886f, -0.04732417f, -0.03024918f, 
    -0.04970407f, -0.02893496f, 0.03837367f, -0.02620500f, 0.02127630f, -0.04953437f, -0.05438368f, -0.01453291f, 
    0.03269860f, -0.01404709f, 0.03437777f, -0.04069634f, -0.01952091f, -0.03980213f, -0.04960676f, 0.04134005f, 
    0.00121882f, -0.04776371f, 0.04127924f, 0.02041084f, 0.03404314f, -0.00157008f, -0.05298023f, -0.00740490f, 
    -0.00392929f, -0.04904270f, 0.03560988f, -0.04178440f, 0.03362183f, -0.03781409f, 0.00678000f, -0.03166769f, 
    0.01400348f, 0.03089273f, -0.00305831f, 0.04132754f, 0.01010616f, 0.04063338f, -0.00722939f, -0.02586791f, 
    0.03595374f, 0.02875630f, -0.02177777f, -0.04141627f, -0.03328325f, -0.04228370f, -0.00248204f, 0.02293018f, 
    0.03957509f, 0.00233215f, -0.00580493f, 0.01739717f, -0.04395838f, 0.00720316f, 0.00465318f, 0.03950523f, 
    -0.03621742f, 0.00727120f, -0.04434625f, -0.02647765f, 0.00436541f, -0.01167429f, 0.02740968f, -0.03600657f, 
    0.01198533f, 0.01157769f, -0.01315617f, -0.01645286f, -0.01990370f, 0.03048424f, -0.04682472f, -0.02517557f, 
    -0.03276135f, 0.01996098f, -0.04422795f, -0.05255594f, 0.00319663f, 0.00233968f, 0.02622129f, 0.02863988f, 
    -0.04049924f, 0.01925039f, -0.00111543f, 0.01561854f, 0.02419129f, -0.01881110f, 0.01384175f, -0.03456412f, 
    0.01011754f, -0.03167729f, -0.03632891f, -0.02838819f, -0.03768331f, -0.04042692f, -0.00608373f, 0.03683223f, 
    -0.04046873f, -0.01662051f, 0.04045998f, -0.01906438f, -0.04337252f, 0.04096314f, 0.02560855f, 0.00511006f, 
    0.04389629f, 0.02609314f, 0.04325459f, -0.00764236f, -0.04492554f, -0.01740744f, -0.00116464f, 0.04694413f, 
    0.02059392f, 0.01389593f, 0.01101037f, -0.02674970f, 0.01385808f, 0.01348041f, 0.04352135f, -0.01712473f, 
    0.00344830f, -0.00451545f, 0.01581780f, 0.01846191f, 0.03213764f, -0.00923669f, -0.02410598f, -0.02448893f, 
    0.03033323f, -0.00414880f, -0.02719113f, 0.03524010f, 0.01646083f, -0.03642689f, -0.00360569f, -0.03288209f, 
    0.02838411f, -0.00310812f, -0.00242075f, -0.02495548f, 0.04412647f, -0.04974896f, 0.02597316f, 0.03703572f, 
    0.01360299f, -0.04317154f, -0.03852702f, -0.02045367f, -0.01935923f, -0.03176392f, -0.00549444f, -0.01303122f, 
    0.00390742f, 0.03763845f, -0.01328009f, -0.04383484f, -0.03826441f, 0.02918681f, -0.04918787f, 0.04345212f, 
    -0.03725911f, -0.01232903f, -0.01902470f, 0.02375602f, 0.00669289f, 0.04087081f, 0.01845079f, 0.03266700f, 
    0.00087086f, 0.01048828f, 0.00756856f, -0.05812001f, 0.01391735f, -0.03958525f, -0.04902695f, -0.00135646f, 
    0.00671158f, 0.02641056f, -0.02397930f, -0.01985281f, -0.02974098f, -0.02636215f, -0.05573698f, -0.00688576f, 
    -0.00203063f, -0.00583528f, -0.01049687f, 0.00840584f, 0.00775164f, 0.00418840f, 0.02828480f, -0.02264408f, 
    -0.01064186f, -0.04922572f, -0.03623367f, -0.00659970f, -0.01019698f, -0.05686346f, 0.01215800f, -0.03101309f, 
    -0.02654398f, -0.04649840f, -0.04925504f, -0.04439500f, 0.01489229f, -0.03616928f, 0.00452341f, 0.00440168f, 
    0.04292626f, -0.05044258f, -0.00138226f, -0.03940798f, -0.01696223f, 0.02477363f, 0.00987937f, -0.04934252f, 
    -0.02094971f, 0.03031945f, -0.01738673f, -0.00672921f, 0.01960965f, -0.00646839f, -0.01967082f, -0.03615729f, 
    0.03074371f, 0.03830205f, 0.00255555f, -0.01897129f, -0.01771584f, 0.01531035f, -0.00804712f, 0.01765032f, 
    -0.03202895f, -0.06160863f, -0.04980430f, -0.00371807f, 0.03437606f, 0.04070261f, -0.00855968f, 0.03440205f, 
    -0.00146369f, 0.02011267f, -0.01270823f, 0.02374479f, -0.04194626f, -0.02098591f, -0.02836531f, 0.00307423f, 
    -0.02773242f, -0.02713423f, -0.04514313f, -0.01826126f, -0.00990150f, -0.01356462f, 0.01298844f, 0.04231755f, 
    -0.05867814f, -0.04867987f, 0.00161434f, 0.02463504f, 0.04437329f, -0.01945098f, -0.02443730f, -0.02314385f, 
    0.01019670f, 0.01351816f, 0.03226434f, 0.01127315f, 0.02478851f, -0.03073845f, 0.04191417f, -0.04848183f, 
    0.02093785f, -0.03843693f, 0.05138779f, -0.03320125f, -0.00017439f, -0.00061891f, -0.02362030f, -0.04829811f, 
    0.04079271f, 0.00283101f, 0.02800989f, 0.00061029f, 0.00274321f, -0.01390273f, -0.03151349f, 0.04078408f, 
    0.00844620f, 0.00111385f, -0.02755734f, -0.04741594f, 0.04308916f, -0.04509253f, -0.04485933f, -0.05370370f, 
    -0.01171109f, -0.03114810f, -0.02120533f, -0.03835337f, -0.01768080f, 0.03119741f, -0.05363285f, -0.03935825f, 
    0.04065800f, -0.00053168f, -0.05054668f, -0.02989538f, 0.02585147f, -0.01497761f, -0.02121264f, -0.04441099f, 
    -0.04006676f, 0.02140705f, 0.13203394f, 0.02217548f, -0.12218831f, 0.06475654f, 0.05044759f, -0.01031872f, 
    0.21217228f, 0.18421258f, 0.00326497f, 0.17548347f, -0.03884964f, -0.01099301f, -0.08013849f, 0.02844863f, 
    -0.03471674f, 0.14975704f, 0.00571421f, -0.12501632f, -0.08255010f, 0.00297898f, -0.17749935f, -0.10255300f, 
    -0.25596300f, 0.19398968f, -0.06167785f, 0.12478692f, 0.06447386f, 0.13137427f, -0.09291048f, -0.04127658f, 
    0.10093275f, -0.15405388f, 0.12056740f, 0.05084097f, 0.12048990f, 0.04467138f, 0.06841572f, 0.20275654f, 
    0.19766206f, 0.20450115f, -0.18274604f, -0.32972166f, 0.03422214f, -0.02579975f, 0.21396428f, -0.04377592f, 
    0.13715552f, 0.21708696f, 0.16010331f, 0.16393569f, -0.15380859f, 0.01743940f, -0.03121013f, 0.01271325f, 
    -0.00929700f, -0.08718973f, -0.13642733f, 0.15962021f, 0.16035466f, -0.02418903f, -0.03333912f, 0.04948819f, 
    0.00078706f, 0.07980966f, -0.05145938f, -0.01389685f, 0.00274405f, 0.09755115f, -0.02247620f, 0.15027343f, 
    0.60019630f, 0.03302947f, 0.76774162f, 0.17404510f, -0.13275424f, 0.05627657f, 0.03357944f, 0.20742285f, 
    -0.06348205f, -0.05699876f, -0.09264114f, -0.04354236f, 0.15740666f, -0.06123026f, -0.01809266f, 0.08146255f, 
    0.11167140f, -0.00813402f, -0.16944484f, -0.01982891f, -0.17787993f, -0.10248513f, 0.05663656f, -0.11580741f, 
    0.54817539f, 0.19485213f, 0.31626728f, -0.18103914f, -0.08304895f, -0.07805002f, 0.02326157f, 0.16303557f, 
    0.01490344f, -0.06631459f, -0.08410396f, 0.03546369f, -0.19679277f, -0.35314372f, 0.11132135f, 0.18643862f, 
    -0.02933989f, 0.00164224f, -0.09898061f, 0.08397091f, -0.03758128f, -0.07120144f, -0.05328134f, 0.01098618f, 
    -0.17710322f, -0.08200725f, 0.32858914f, 0.04409640f, -0.14513753f, -0.04397272f, 0.23407942f, 0.15366533f, 
    -0.14220248f, 0.11524847f, 0.05456079f, -0.00619328f, 0.01902876f, 0.15580958f, 0.11194818f, 0.04608628f, 
    0.23207460f, 0.08771988f, 0.11427554f, -0.21219331f, 0.18518770f, -0.03078922f, 0.04782472f, 0.06474026f, 
    0.25575799f, 0.06757671f, -0.40397015f, 0.10354113f, 0.04319530f, 0.13717782f, -0.05888505f, -0.17739436f, 
    0.04530491f, -0.15440783f, 0.07685909f, 0.14535432f, 0.12052716f, 0.04073224f, 0.02442043f, 0.20102392f, 
    0.16974053f, 0.11396889f, -0.05877862f, 0.04601288f, 0.11145873f, 0.08569075f, -0.03923457f, 0.06387197f, 
    0.00310396f, 0.16975541f, 0.24618624f, 0.21475461f, -0.18900047f, 0.06135451f, 0.11630219f, 0.06905938f, 
    0.01923454f, 0.10446066f, -0.11174177f, 0.15278971f, -0.03243541f, -0.32965070f, -0.11128236f, 0.14651032f, 
    0.05917538f, -0.10320940f, 0.14083283f, 0.16404405f, 0.10478052f, 0.03148231f, 0.08364053f, 0.18518873f, 
    0.15757675f, 0.01374708f, -0.05288506f, 0.08475228f, 0.17428955f, -0.03254109f, -0.10668824f, -0.19283801f, 
    -0.11106352f, -0.04902801f, 0.04347509f, 0.13910714f, -0.00192490f, 0.11282443f, -0.15505756f, 0.19283362f, 
    -0.08746327f, 0.12371402f, 0.03839692f, 0.04307209f, 0.00653737f, 0.05855021f, 0.24271385f, -0.09966125f, 
    0.00770536f, -0.01505971f, -0.00256675f, 0.04338451f, -0.03342192f, -0.14910161f, 0.10034576f, 0.03817622f, 
    0.07353790f, 0.10806932f, 0.14434072f, 0.32161576f, 0.40038764f, 0.15406592f, 0.24579558f, -0.03364944f, 
    -0.07367865f, -0.06065534f, -0.02238347f, 0.06684308f, -0.13642022f, -0.06488308f, -0.02651949f, -0.02914094f, 
    -0.26735345f, -0.16131443f, -0.25591168f, 0.24395467f, 0.17318429f, 0.02858615f, 0.11772361f, 0.19983102f, 
    0.16464858f, -0.01752865f, 0.01741450f, 0.12882707f, -0.26107597f, 0.10827117f, 0.05118203f, 0.29575786f, 
    0.11918287f, -0.08560548f, 0.21017246f, 0.08037804f, 0.17115228f, 0.17274271f, -0.05646200f, 0.12404557f, 
    0.10523491f, -0.21615763f, 0.05914650f, 0.06678675f, -0.14891711f, 0.17046258f, 0.10205872f, -0.14399575f, 
    -0.02256043f, -0.02083582f, -0.01131139f, -0.08483466f, 0.10497720f, 0.36966449f, 0.14484657f, -0.12608235f, 
    -0.09978646f, -0.00251826f, -0.02914549f, 0.06357989f, -0.01553402f, 0.03029570f, -0.02217926f, 0.21734110f, 
    -0.09307086f, 0.14331518f, 0.00842203f, -0.16201282f, 0.08103579f, 0.10901902f, 0.02305005f, -0.00585932f, 
    -0.10998195f, 0.14225003f, 0.11783142f, -0.08826784f, -0.24191935f, -0.11781787f, 0.11912215f, 0.08383561f, 
    0.08112638f, 0.02171729f, 0.06155513f, 0.18972327f, 0.20845482f, 0.12853207f, 0.06551347f, -0.00356870f, 
    -0.14363077f, -0.23758513f, -0.04446901f, -0.08579646f, -0.12021296f, -0.02398768f, -0.04466977f, 0.18644646f, 
    -0.09072998f, -0.03879143f, -0.04080784f, -0.09762393f, -0.14936893f, -0.26569071f, 0.08344200f, 0.07061754f, 
    0.01157174f, 0.19129863f, 0.35096139f, 0.16779961f, -0.02578300f, 0.07553983f, -0.09804707f, -0.18352947f, 
    -0.41883320f, 0.43099487f, 0.20954032f, 0.02758633f, 0.16242872f, -0.07429834f, -0.10357419f, 0.01075845f, 
    -0.09474639f, -0.13490584f, -0.05180442f, 0.10116869f, -0.06563913f, -0.15725030f, 0.14518294f, 0.11813621f, 
    0.13668211f, -0.08452938f, 0.11754467f, -0.13935332f, 0.04196263f, 0.16865933f, -0.02262203f, -0.02810088f, 
    -0.12483592f, 0.05948627f, 0.26913494f, -0.02846166f, -0.09736151f, 0.02646269f, 0.01514715f, -0.05142118f, 
    0.16049667f, -0.00498566f, -0.04792224f, 0.10038226f, 0.24168189f, -0.02034392f, -0.09599589f, 0.22661009f, 
    0.09499490f, -0.02315982f, -0.01394416f, 0.01137964f, -0.03916240f, -0.02833122f, -0.00653505f, 0.04214247f, 
    -0.01775078f, -0.05056769f, -0.05503802f, -0.05406259f, -0.05659005f, -0.05965468f, 0.00986707f, -0.05905167f, 
    0.04191785f, -0.09085322f, 0.00684205f, -0.06521004f, -0.05192624f, 0.01995735f, -0.09952376f, -0.11294214f, 
    -0.03846154f, -0.08948823f, -0.05296762f, -0.02916546f, 0.04036785f, -0.02759350f, -0.04718294f, 0.02875934f, 
    0.01290416f, -0.00677777f, -0.00007588f, -0.04387505f, -0.02437592f, 0.00083137f, -0.03396130f, 0.01968758f, 
    -0.07664702f, -0.02737323f, -0.02176878f, -0.06310826f, -0.04541066f, -0.02559202f, -0.03943977f, -0.01308930f, 
    0.02205113f, 0.00708603f, -0.01442004f, 0.00113422f, 0.01341083f, -0.05574694f, 0.05372603f, -0.08415551f, 
    0.05590298f, 0.01317130f, 0.07865096f, 0.05774714f, -0.04285120f, 0.00812538f, -0.00632318f, -0.03937010f, 
    -0.02839040f, 0.04368306f, 0.03274757f, -0.02956515f, 0.04422221f, -0.04882810f, -0.06105620f, -0.07339191f, 
    -0.04605755f, -0.06016866f, 0.03898099f, -0.04457486f, 0.00649092f, 0.04244890f, 0.03000291f, 0.03957229f, 
    -0.00726095f, 0.00611495f, -0.05193986f, -0.05221786f, -0.10914333f, -0.10701706f, -0.00088269f, -0.00848142f, 
    0.00468607f, 0.00351485f, -0.00054852f, 0.04630112f, -0.00206852f, 0.03294364f, -0.00289003f, 0.00589356f, 
    0.04565724f, 0.01895478f, 0.05096331f, -0.01114474f, -0.00631795f, -0.01531741f, 0.00910634f, -0.05544663f, 
    0.00332354f, -0.04265296f, -0.05126002f, 0.06591009f, -0.00136344f, -0.05934773f, -0.04868456f, -0.10536471f, 
    0.04376665f, 0.02755353f, -0.00896259f, 0.00146811f, -0.02866260f, -0.06836553f, -0.05227753f, -0.08342773f, 
    -0.07396983f, -0.02156679f, -0.04959559f, 0.02470709f, 0.03075977f, 0.00885632f, 0.00280919f, -0.03804704f, 
    0.03565158f, -0.01858252f, 0.00237041f, 0.00265953f, -0.01985808f, 0.03880475f, -0.01788923f, -0.01376493f, 
    -0.05448539f, -0.01276519f, 0.02806047f, 0.02442945f, -0.00468011f, 0.02051134f, -0.02248277f, 0.03150220f, 
    -0.06100989f, -0.01178085f, 0.01823668f, -0.00755332f, -0.03958961f, 0.01663200f, -0.02836011f, 0.01386799f, 
    0.01968410f, -0.02473849f, -0.00615650f, -0.01626434f, -0.03947173f, -0.04304229f, -0.02890420f, 0.03242128f, 
    0.02136154f, -0.01716765f, -0.04805698f, -0.04193199f, -0.03750054f, -0.05740855f, -0.05910579f, -0.02309958f, 
    -0.07888737f, -0.05985533f, -0.06658420f, 0.00210148f, -0.04974011f, -0.01687626f, -0.00166912f, 0.00472389f, 
    -0.01031768f, 0.00726367f, -0.02030765f, -0.00289485f, -0.01461005f, 0.05303400f, -0.03848310f, -0.01592040f, 
    -0.01578678f, 0.03588216f, -0.01324078f, -0.03721403f, -0.07780893f, -0.06003253f, -0.06501280f, -0.07150389f, 
    -0.08406264f, -0.10143428f, -0.01367491f, -0.03622683f, -0.07819454f, 0.00534111f, 0.00450217f, -0.00032196f, 
    -0.05288534f, -0.05266762f, -0.06031290f, -0.04424483f, 0.01495404f, -0.01760603f, -0.03845874f, 0.04715674f, 
    -0.06750832f, -0.04532213f, 0.01219325f, -0.00075241f, 0.00342919f, 0.01082788f, 0.05537173f, -0.02556703f, 
    -0.00837570f, -0.03325244f, -0.02801660f, -0.02974142f, -0.06429622f, -0.02900614f, 0.00574990f, -0.02836724f, 
    -0.07364187f, -0.02352185f, -0.01701412f, -0.01695366f, -0.07251295f, -0.06488480f, -0.09089308f, 0.01607820f, 
    -0.06245551f, -0.09058990f, -0.00236405f, -0.03544514f, -0.05100593f, 0.02829672f, 0.02151396f, -0.03936232f, 
    -0.02007449f, -0.07070553f, -0.03428908f, -0.00878744f, 0.01342351f, -0.03774107f, 0.01503613f, 0.03020246f, 
    -0.08743665f, -0.10009689f, -0.07650949f, -0.07459099f, 0.00714153f, 0.00531365f, -0.08153959f, -0.02475443f, 
    -0.05524161f, -0.04256042f, -0.07452545f, -0.03522437f, 0.00141700f, 0.04123510f, -0.06074742f, -0.03714721f, 
    -0.07566155f, 0.05188620f, -0.02999403f, -0.01178009f, -0.04700482f, -0.01934300f, 0.00648953f, 0.02606240f, 
    0.04741065f, 0.04376056f, -0.00078691f, 0.01446402f, -0.05317737f, 0.02234062f, 0.03682930f, 0.02693025f, 
    0.03628183f, 0.03183977f, -0.01375584f, -0.09312964f, -0.00765970f, -0.04375547f, -0.01801657f, -0.00766246f, 
    -0.02374722f, 0.02375829f, 0.01675934f, 0.03840294f, 0.03324807f, 0.01532427f, -0.02999458f, -0.03506230f, 
    -0.03127065f, -0.04786400f, 0.02591428f, -0.00417939f, -0.02530933f, -0.04354825f, -0.07068792f, -0.00752044f, 
    -0.01921379f, -0.01195927f, 0.05584849f, -0.01084407f, -0.01917188f, -0.09811391f, 0.03353175f, -0.00368625f, 
    -0.03631959f, -0.03356794f, -0.04034582f, -0.03330057f, -0.06819800f, 0.00588999f, -0.04587854f, 0.02503806f, 
    -0.08927226f, -0.08535334f, -0.07422778f, -0.06227633f, -0.04215370f, -0.04088313f, -0.06601422f, -0.03830874f, 
    -0.00256508f, -0.02474841f, -0.01760419f, 0.01327418f, -0.07196409f, -0.01190794f, -0.02705101f, -0.07510110f, 
    -0.00286869f, -0.04084419f, -0.07949803f, -0.05936074f, 0.00193254f, -0.05402560f, 0.00091314f, -0.02087403f, 
    -0.07945275f, -0.06023979f, -0.07771422f, -0.04552542f, -0.05299938f, 0.06210361f, -0.04732928f, -0.07858486f, 
    -0.01895217f, -0.00424601f, -0.01201867f, 0.04855340f, -0.04772429f, 0.00158038f, 0.01272944f, 0.03436907f, 
    0.02006013f, 0.04729522f, -0.09459908f, 0.03790366f, -0.07343633f, 0.02444569f, 0.01627839f, 0.02721217f, 
    0.02536641f, 0.01907657f, -0.05110468f, -0.00947541f, -0.06155137f, -0.02473801f, -0.02488401f, -0.03254915f, 
    0.03941650f, 0.00828664f, 0.04232698f, -0.00883657f, -0.00531509f, -0.03514230f, -0.01019911f, -0.07569622f, 
    -0.02264133f, -0.10973381f, -0.02030049f, -0.07001670f, -0.02943465f, -0.04233175f, 0.00683341f, -0.07415793f, 
    0.04809780f, 0.05785186f, -0.17204544f, 0.01326972f, -0.09902240f, -0.03277642f, -0.03824923f, 0.00003931f, 
    -0.17561017f, -0.03103215f, 0.04505626f, 0.25209156f, 0.38269225f, 0.18290488f, 0.18760119f, 0.01056337f, 
    -0.08408661f, -0.10872163f, 0.00748725f, 0.05379907f, 0.02183845f, -0.15708950f, -0.00806206f, 0.01513205f, 
    0.19581042f, -0.12663932f, 0.34026408f, 0.31285849f, 0.01228777f, 0.04695947f, -0.18439372f, -0.09713827f, 
    0.04592755f, 0.03654224f, 0.09281293f, 0.03789848f, 0.03934457f, -0.04724813f, 0.03599919f, -0.04119195f, 
    0.03061821f, -0.04449948f, 0.07971013f, -0.16410524f, -0.12563378f, -0.11048290f, -0.07152645f, -0.00093745f, 
    -0.26939955f, -0.26111937f, -0.26934701f, 0.13809980f, -0.11100980f, 0.07854658f, 0.13017647f, -0.08686117f, 
    0.02169459f, -0.01766592f, 0.12142427f, 0.08631414f, 0.05752784f, 0.24546941f, 0.26118025f, 0.15580934f, 
    -0.04516029f, -0.10114595f, -0.09198709f, -0.17883006f, 0.07670298f, -0.04067569f, -0.05872417f, 0.14918898f, 
    -0.30491552f, 0.15504806f, -0.31333882f, 0.06654936f, 0.10744783f, 0.07624984f, 0.09826282f, -0.01821255f, 
    0.13899764f, -0.09984560f, -0.02932535f, -0.15097421f, -0.01081468f, -0.06226174f, -0.01152106f, 0.06031450f, 
    0.04571193f, -0.04907624f, 0.09201556f, 0.02399893f, 0.04172923f, 0.06973501f, -0.07625306f, -0.13882327f, 
    0.04716315f, 0.24870628f, -0.23403661f, 0.11034088f, -0.08214404f, -0.03614423f, 0.15421768f, 0.04506953f, 
    0.15182255f, -0.01173716f, 0.02304124f, -0.01943259f, 0.43590954f, 0.34216362f, 0.00087093f, 0.19968952f, 
    -0.22559366f, -0.06594604f, 0.09422520f, 0.16302179f, 0.04807935f, -0.08920516f, -0.01209544f, -0.01021091f, 
    0.19454475f, 0.04318665f, 0.44999355f, -0.07134987f, 0.04355002f, -0.08213244f, -0.14456096f, 0.19066171f, 
    -0.04518365f, -0.03056780f, -0.08199830f, 0.01457744f, -0.31908372f, -0.18174286f, 0.08319726f, -0.12018109f, 
    -0.01524565f, 0.14190522f, -0.16797014f, -0.01792254f, 0.03303453f, -0.08623029f, -0.02392898f, -0.01039982f, 
    -0.22871165f, 0.37411973f, 0.29524308f, 0.19167094f, 0.20689729f, 0.12163945f, 0.00897567f, -0.28182974f, 
    -0.02100410f, -0.20475259f, -0.08216316f, -0.04212749f, -0.01718405f, 0.11194745f, 0.06210777f, 0.08242176f, 
    -0.01144948f, 0.03646026f, 0.07440340f, -0.10555863f, -0.03134108f, -0.27186936f, -0.02512768f, 0.25065565f, 
    -0.38972512f, -0.45298994f, 0.00973962f, -0.09102282f, -0.10749746f, 0.16739720f, -0.06021143f, 0.02743978f, 
    -0.18161404f, 0.09911010f, -0.05003778f, -0.13872302f, 0.25303960f, 0.14445126f, 0.05961562f, 0.23872136f, 
    -0.00621523f, 0.04225632f, 0.02223777f, 0.01825604f, -0.04687022f, -0.06381222f, 0.02537646f, 0.01333654f, 
    -0.00462073f, 0.09560059f, 0.29355213f, -0.16100726f, 0.00329406f, -0.02488584f, 0.06395679f, -0.01725906f, 
    -0.04278224f, -0.00389535f, 0.15486547f, 0.14786851f, -0.02151059f, 0.23358203f, 0.33290604f, -0.04170895f, 
    0.07810032f, 0.05485683f, -0.27719411f, -0.00979920f, 0.12170893f, 0.03801982f, 0.00741418f, 0.15334056f, 
    0.10434885f, 0.10341221f, 0.00945964f, 0.17926762f, 0.14814612f, 0.00962634f, -0.03109379f, 0.00830840f, 
    -0.01963716f, 0.11187210f, 0.06492888f, 0.09503904f, -0.15362619f, -0.34112984f, -0.14926657f, -0.15193546f, 
    0.13430484f, 0.01862745f, 0.11650463f, 0.09771841f, 0.02695631f, -0.07486127f, -0.12845761f, -0.05482439f, 
    0.10798609f, 0.13491796f, -0.04028681f, 0.00714742f, -0.01204371f, -0.00722846f, -0.01906331f, 0.04992224f, 
    0.03910997f, -0.02117854f, -0.09908846f, -0.03782648f, -0.09479170f, 0.28535929f, -0.47353956f, -0.01549187f, 
    0.03695568f, -0.23118067f, 0.23804064f, 0.14407049f, 0.10027499f, 0.00059550f, -0.05176445f, 0.14675649f, 
    0.30919459f, 0.04406523f, 0.10467324f, 0.18921891f, 0.05225748f, 0.05060168f, -0.22625092f, -0.02598289f, 
    -0.03455364f, 0.03204110f, 0.08304388f, -0.06794523f, -0.12362602f, -0.23035549f, -0.07813565f, -0.06926530f, 
    0.02970939f, 0.17339192f, -0.00565037f, -0.11508543f, -0.00532973f, -0.09818491f, 0.02139149f, 0.08197974f, 
    0.10150325f, -0.06736492f, 0.01391927f, 0.14074872f, -0.05122278f, 0.01703493f, 0.09731875f, 0.04966267f, 
    -0.16905187f, 0.10643046f, -0.16201375f, 0.09129068f, 0.16024588f, -0.07812055f, -0.10868496f, 0.41204533f, 
    0.21190512f, 0.28474668f, 0.00723063f, 0.00706984f, 0.06487399f, -0.07053510f, 0.02903583f, 0.05597902f, 
    -0.04535215f, 0.07205260f, 0.17900725f, 0.31675565f, -0.02733529f, -0.00354826f, -0.11828730f, 0.18239367f, 
    0.02453960f, 0.03003645f, 0.04979941f, 0.01900844f, 0.14319585f, 0.27668461f, -0.06333350f, 0.01970134f, 
    -0.00786561f, -0.18889000f, 0.00392147f, 0.10464886f, 0.03377311f, -0.12943010f, 0.06598009f, -0.01156667f, 
    -0.04701797f, 0.42521557f, -0.16544092f, 0.17590140f, -0.08031471f, 0.12185267f, 0.17690870f, -0.07547981f, 
    0.04331647f, 0.03717782f, -0.03058183f, -0.18632562f, 0.00235974f, 0.01482707f, -0.00130475f, 0.02379338f, 
    0.16430198f, 0.11574484f, -0.11296038f, 0.16743597f, -0.20117252f, 0.04794161f, 0.17931078f, 0.07218949f, 
    -0.18461965f, -0.17217128f, -0.20801960f, 0.05501493f, -0.04850594f, 0.15495481f, 0.08280475f, -0.06041441f, 
    0.20197928f, -0.02303186f, 0.06438261f, 0.15775280f, 0.05644432f, -0.01930445f, -0.01026722f, -0.05209384f, 
    -0.12861459f, 0.03228258f, 0.05358477f, -0.01408913f, 0.16445725f, -0.03371971f, -0.00234882f, 0.03910787f, 
    -0.05085989f, -0.02475929f, -0.01875999f, -0.00932583f, -0.02204372f, -0.03400631f, 0.00737514f, -0.05331201f, 
    -0.02904408f, 0.01332231f, 0.00030164f, 0.01621490f, 0.01957200f, 0.03462257f, -0.02493287f, -0.01424630f, 
    -0.03041742f, -0.01333162f, -0.03551003f, -0.04293435f, -0.01779007f, -0.03807919f, -0.01757447f, 0.00073313f, 
    -0.00797823f, -0.01355643f, 0.02638133f, -0.02480011f, 0.01492162f, -0.03822412f, 0.04348053f, 0.02879172f, 
    0.03645991f, -0.05662075f, -0.01465817f, 0.02343800f, -0.02242864f, 0.04586403f, -0.04291204f, 0.04597670f, 
    0.00960920f, 0.03286560f, 0.01147151f, 0.05152412f, -0.03751637f, -0.00845107f, 0.03963675f, 0.02351502f, 
    -0.00048943f, -0.01533615f, 0.04201670f, -0.05159958f, 0.04071842f, -0.03034820f, -0.02435376f, -0.02308683f, 
    -0.00412579f, 0.02703476f, 0.02837902f, -0.02210601f, 0.02691072f, -0.02150998f, -0.03146308f, -0.03906580f, 
    0.02013510f, -0.03434290f, -0.00839196f, -0.01338473f, -0.03974297f, 0.02567476f, -0.00234923f, -0.05345334f, 
    0.02072615f, -0.01004681f, -0.02174735f, -0.03149876f, -0.03723690f, 0.02845759f, -0.02355344f, 0.01948163f, 
    0.00548026f, 0.01212100f, 0.03324972f, 0.04553310f, -0.00872202f, 0.02039525f, -0.01780371f, -0.02400799f, 
    -0.00328186f, 0.04080888f, -0.02970188f, 0.03294331f, -0.01751139f, -0.05049999f, 0.02865611f, -0.01421751f, 
    0.02462390f, -0.02349002f, 0.03548308f, 0.02258499f, 0.04773608f, -0.02032050f, -0.04064198f, 0.02236791f, 
    0.00273501f, -0.02257374f, 0.01001100f, -0.03690970f, -0.04708623f, 0.01337080f, -0.04702157f, 0.02933668f, 
    -0.04995124f, -0.05138616f, 0.03784139f, -0.05949351f, -0.02997802f, -0.04647882f, 0.00863606f, -0.00071802f, 
    -0.05092216f, -0.02858676f, 0.00127161f, -0.05220610f, -0.05406709f, 0.04352326f, 0.04120224f, -0.05951965f, 
    -0.03489033f, -0.02373746f, -0.00749068f, -0.02159579f, 0.03382660f, -0.00937064f, 0.01527292f, 0.01801411f, 
    -0.05718783f, 0.01811303f, -0.05394176f, -0.02053319f, 0.01913085f, 0.02912435f, 0.02373844f, -0.05350415f, 
    -0.01430567f, -0.00923514f, 0.03679674f, 0.02139646f, 0.02641954f, 0.02098591f, -0.04054141f, 0.00943880f, 
    0.00958058f, 0.04825391f, -0.00848616f, 0.03841768f, 0.01453368f, 0.04118975f, 0.05015970f, 0.02811355f, 
    -0.02247145f, 0.00484534f, 0.03970463f, 0.04557838f, 0.00001189f, 0.03937609f, 0.02472141f, -0.00001403f, 
    0.02033560f, -0.01132489f, 0.02520985f, 0.01857957f, -0.00032182f, -0.03683019f, 0.03186337f, 0.04381114f, 
    -0.01046443f, 0.01859590f, 0.01987733f, -0.01240718f, -0.02564736f, -0.01408007f, -0.05900039f, 0.01012019f, 
    -0.05095799f, -0.03779173f, -0.00163858f, -0.03320386f, -0.05697420f, 0.03057123f, -0.00924206f, -0.02598061f, 
    -0.00094902f, 0.04522599f, -0.02039879f, 0.01819096f, -0.04455681f, 0.04033767f, -0.03196967f, 0.00009823f, 
    -0.04911007f, 0.00886822f, 0.02620657f, -0.05675418f, 0.02365124f, 0.00143185f, -0.04103712f, -0.03668090f, 
    0.02152512f, 0.03646478f, 0.02135160f, -0.05460487f, -0.05298040f, 0.01945294f, 0.02588774f, -0.00741537f, 
    -0.01161282f, -0.02616793f, -0.00138861f, 0.00252300f, -0.01750611f, 0.04682344f, -0.00424902f, 0.00914563f, 
    -0.04934565f, -0.00007632f, 0.03649078f, 0.03924645f, -0.00579499f, -0.05167216f, -0.03093939f, -0.05076525f, 
    -0.05618444f, -0.01844089f, -0.05032565f, 0.02795878f, -0.00235549f, -0.00291410f, -0.01605893f, 0.04568334f, 
    0.01704693f, 0.03438036f, -0.03389728f, -0.02237568f, -0.01124651f, 0.01207012f, 0.04096423f, -0.00272648f, 
    -0.00110468f, 0.02903042f, -0.05249744f, 0.00324605f, -0.02495179f, -0.00571498f, -0.02845691f, 0.01715186f, 
    0.01904294f, -0.03276433f, -0.03626671f, 0.01002163f, -0.01899291f, -0.02251970f, -0.02598081f, 0.01425095f, 
    -0.00258239f, 0.00447847f, -0.00278395f, -0.00947687f, 0.03430368f, -0.00373347f, 0.01369120f, 0.01897550f, 
    -0.03952743f, -0.03468274f, -0.04013056f, 0.04647899f, -0.04589344f, 0.01456312f, -0.00922756f, -0.04182241f, 
    -0.02739184f, -0.01201906f, -0.03523946f, -0.01246818f, -0.04644677f, 0.04190348f, 0.02288615f, -0.02842967f, 
    0.01739756f, -0.01737302f, -0.04179610f, 0.03422210f, 0.01661303f, -0.00877926f, 0.02181517f, -0.04022684f, 
    -0.03557229f, -0.02653820f, -0.00459597f, -0.03966283f, -0.00790226f, 0.02066437f, 0.01432213f, -0.00651704f, 
    0.01139189f, 0.00929074f, -0.02422092f, -0.05599176f, -0.04023058f, 0.02172606f, -0.01077991f, 0.01831078f, 
    -0.05297263f, 0.02373013f, 0.02121137f, -0.01305943f, 0.03280853f, -0.04331299f, 0.01042522f, 0.01353592f, 
    0.03898222f, -0.02745436f, -0.04565917f, 0.04021999f, 0.02016186f, 0.02261840f, -0.01644125f, 0.02789596f, 
    0.01827124f, -0.02672187f, 0.02519406f, -0.00641592f, 0.04464635f, -0.02295520f, -0.01879782f, 0.03665921f, 
    -0.00354640f, -0.03215506f, -0.01410975f, 0.01488870f, -0.01662711f, -0.03566328f, 0.02041707f, 0.03561761f, 
    -0.04942495f, 0.00195073f, -0.04049375f, -0.03576014f, -0.00394276f, 0.01991541f, 0.01894036f, -0.00437047f, 
    0.03386140f, -0.00024031f, -0.00434350f, -0.02467600f, -0.03386014f, -0.01165684f, 0.04203021f, 0.03325760f, 
    -0.05479261f, -0.03189407f, -0.01534729f, 0.00506429f, -0.02155483f, 0.01762023f, -0.05361825f, -0.05024307f, 
    -0.01624580f, 0.02723595f, 0.00247414f, -0.06030840f, -0.03455685f, -0.04412808f, -0.02906356f, 0.03502500f, 
    -0.03562578f, 0.03985186f, -0.00683454f, 0.04399399f, 0.04546651f, 0.02414306f, -0.02875306f, 0.00459874f, 
    0.04906251f, -0.01745469f, -0.00308151f, -0.04741248f, -0.00836874f, -0.01725987f, -0.02963801f, 0.01512990f, 
    -0.01452352f, -0.05462700f, 0.04506790f, -0.03468598f, 0.03665969f, -0.04134941f, 0.01855925f, -0.02739171f, 
    -0.04653086f, -0.04496326f, 0.03301338f, -0.01340814f, -0.03688471f, -0.02354279f, -0.04249237f, 0.02139965f, 
    -0.01952425f, -0.00743685f, -0.04163236f, 0.03051394f, -0.03686057f, -0.05181786f, -0.01883169f, 0.02018394f, 
    0.03246418f, -0.03197922f, 0.00627850f, -0.03838886f, 0.03755267f, -0.03876131f, -0.00843082f, 0.01413718f, 
    -0.00797867f, -0.04670618f, -0.03135225f, 0.03863382f, 0.01154412f, -0.00571615f, 0.03154752f, -0.01926019f, 
    -0.02067924f, -0.00988967f, 0.01303770f, -0.03530786f, -0.00175985f, 0.02996259f, 0.01700107f, 0.01046010f, 
    -0.03914519f, 0.04230031f, 0.02252191f, 0.03490889f, -0.01418709f, -0.02536208f, -0.00452905f, -0.04418505f, 
    0.03690919f, -0.05159219f, -0.04514877f, -0.04161208f, -0.05011871f, 0.01678197f, -0.04702763f, -0.00186388f, 
    -0.05320935f, -0.05289153f, -0.00046639f, -0.03852655f, 0.03558813f, -0.04971151f, -0.03008680f, -0.03917103f, 
    -0.05099811f, -0.02471733f, -0.04380552f, -0.02817674f, -0.00678054f, 0.00771660f, -0.03307743f, 0.01000780f, 
    -0.01870935f, 0.02475174f, -0.04519028f, 0.00959466f, 0.02967754f, -0.04479979f, 0.00756282f, -0.04452756f, 
    -0.03422830f, 0.00377227f, 0.01830025f, -0.04361109f, -0.02047084f, -0.03217533f, -0.00264346f, -0.00883011f, 
    0.01583052f, -0.04019416f, -0.01837292f, 0.00150370f, -0.00895788f, 0.04175369f, -0.05151106f, 0.00975435f, 
    0.03545694f, -0.03966305f, -0.04432393f, -0.00104163f, 0.02535531f, 0.00181550f, 0.01097398f, -0.02010576f, 
    0.04349837f, -0.02060528f, -0.01982625f, -0.03001404f, 0.01818756f, 0.03895351f, -0.05248649f, -0.00323152f, 
    -0.04654267f, -0.01062212f, 0.03612762f, 0.01474224f, 0.01451716f, 0.02036153f, -0.04097937f, 0.03513961f, 
    0.03611673f, -0.00496074f, 0.02569679f, 0.04278659f, -0.02830322f, -0.01818961f, -0.04448961f, -0.05630441f, 
    0.02621632f, 0.00350102f, 0.02411808f, -0.00134014f, 0.05355600f, 0.03906485f, 0.03232065f, -0.00352950f, 
    -0.01827616f, 0.04007315f, 0.02267239f, 0.00975152f, -0.01594938f, 0.03079167f, -0.02620701f, 0.02375095f, 
    -0.01112826f, -0.03034663f, 0.03872886f, -0.02997583f, 0.00096635f, -0.03241676f, -0.04088629f, -0.02323837f, 
    -0.00498451f, 0.03672953f, -0.01542504f, 0.02356028f, -0.04443479f, 0.01291952f, -0.01556045f, 0.02741265f, 
    0.00015578f, -0.00665984f, -0.00434863f, -0.03623402f, 0.01572196f, -0.01196523f, -0.03849245f, 0.01833389f, 
    0.00578106f, -0.03789708f, -0.05751233f, -0.05360008f, 0.03848695f, 0.04197939f, -0.04109456f, -0.03055000f, 
    0.01161433f, -0.03477302f, 0.04424653f, 0.04248944f, -0.03632882f, -0.01134878f, 0.03735509f, -0.04939695f, 
    -0.04686188f, -0.01779886f, -0.00985869f, -0.01781126f, -0.04558364f, -0.03970196f, 0.04838723f, 0.02732358f, 
    -0.01237406f, -0.01786199f, -0.05239349f, -0.02315840f, 0.04747137f, 0.02808529f, -0.04565633f, 0.02503896f, 
    -0.00328177f, 0.01406189f, -0.05914719f, 0.00702573f, -0.01320861f, 0.01255582f, -0.00515995f, -0.04632050f, 
    0.00633218f, 0.03906633f, -0.05256199f, -0.00621110f, 0.03543023f, 0.01329039f, -0.01129890f, -0.03882055f, 
    -0.03270381f, 0.02819471f, 0.02437181f, -0.03824808f, 0.00106753f, -0.05001032f, -0.03413085f, -0.00022794f, 
    0.01297642f, 0.01956000f, -0.01402149f, -0.05191765f, -0.03734085f, -0.04797630f, 0.02477032f, 0.00032292f, 
    -0.04884426f, -0.00471639f, 0.03579323f, 0.04171090f, -0.02284007f, 0.04495988f, -0.00982894f, 0.01609094f, 
    -0.00034564f, -0.05250791f, -0.02878764f, 0.03704125f, -0.05326670f, -0.01101112f, 0.02063208f, 0.02867750f, 
    -0.01341473f, -0.02791760f, -0.03938945f, 0.02987739f, -0.00361600f, -0.02821980f, -0.02207648f, -0.00528854f, 
    -0.03672765f, -0.04717040f, 0.03359500f, -0.05479110f, -0.02731417f, -0.02739325f, -0.02718301f, 0.01793340f, 
    -0.02587915f, -0.03121475f, 0.01975504f, -0.03097902f, -0.03923218f, -0.02044923f, 0.01924015f, 0.00301336f, 
    0.00584315f, -0.00647017f, 0.04705837f, -0.01005242f, 0.02540981f, 0.00909755f, -0.03240221f, 0.01176044f, 
    0.03242311f, 0.00580090f, 0.02009429f, -0.00322658f, -0.03821965f, -0.04010589f, -0.01327330f, 0.04261370f, 
    -0.04195506f, 0.03734967f, -0.04002557f, -0.01840812f, -0.00469910f, -0.03748886f, -0.00275862f, -0.02454892f, 
    0.01186257f, -0.02502585f, -0.00727111f, 0.02123361f, -0.05308646f, -0.01567908f, 0.03500039f, 0.02266320f, 
    -0.00445993f, -0.04152882f, 0.03319447f, -0.00404704f, -0.02410177f, -0.03802837f, 0.00122680f, 0.00763567f, 
    -0.03381764f, -0.00427387f, 0.03637225f, 0.00741947f, -0.04007006f, -0.03612307f, -0.04235082f, 0.03996884f, 
    0.04004357f, -0.05138595f, -0.02149198f, -0.01153327f, -0.04201271f, -0.02929880f, -0.02566922f, -0.04171002f, 
    0.02807256f, -0.04593232f, 0.00572375f, 0.00842161f, -0.01170202f, 0.02600364f, 0.04692345f, -0.01839901f, 
    -0.01454694f, -0.01726721f, -0.02434995f, -0.04822948f, 0.04103773f, 0.01159609f, -0.04440011f, 0.01836913f, 
    -0.00037142f, -0.02439407f, -0.02816073f, -0.03902467f, 0.00209630f, -0.00365574f, -0.02275822f, 0.01126904f, 
    0.02594986f, 0.01317179f, -0.04230526f, -0.01151392f, 0.02823783f, 0.04020382f, -0.04489284f, 0.03400659f, 
    -0.04644177f, 0.00260031f, -0.02959709f, -0.05191869f, 0.03424229f, -0.01402837f, -0.03107462f, 0.04310802f, 
    -0.02469180f, 0.01733186f, -0.03643923f, 0.01130990f, -0.01464158f, -0.01988900f, -0.03056293f, 0.02275826f, 
    0.02888119f, 0.02818578f, 0.02605488f, 0.00273031f, 0.01539777f, 0.02598015f, 0.03208202f, 0.04410019f, 
    0.02497383f, 0.01989128f, -0.03467056f, -0.01438246f, -0.03047118f, 0.00167112f, 0.01178151f, 0.02132315f, 
    -0.00807704f, -0.02919002f, 0.02855237f, -0.03410346f, -0.05153136f, 0.02675262f, 0.04217137f, -0.03371357f, 
    0.03345079f, -0.03151156f, -0.01866872f, 0.02103420f, 0.04420245f, -0.03688281f, -0.02440685f, 0.00123678f, 
    0.01761018f, 0.01353947f, -0.00631538f, 0.03024600f, 0.01359649f, -0.03523650f, -0.00966431f, 0.01449524f, 
    0.03908627f, -0.00318027f, -0.02099625f, 0.02133767f, 0.00985653f, -0.05296329f, -0.04892402f, 0.02595153f, 
    -0.00029069f, 0.01741547f, -0.00829876f, -0.01258310f, -0.00478486f, -0.05101987f, -0.04569213f, -0.00383253f, 
    -0.01615300f, -0.00382119f, 0.00865966f, -0.00844067f, 0.01842414f, 0.03387757f, -0.03075069f, 0.00683952f, 
    0.01772164f, 0.00477251f, -0.00697418f, 0.01458603f, -0.04235049f, 0.03370344f, -0.04323976f, 0.03028645f, 
    0.03624251f, -0.04391590f, -0.00973759f, -0.03171984f, 0.03664630f, 0.02365126f, -0.02950018f, -0.03988450f, 
    -0.01576632f, -0.01705827f, -0.04113985f, 0.00439248f, -0.02640557f, 0.04097602f, 0.02895391f, -0.01984565f, 
    0.01250208f, -0.04126175f, 0.02240371f, -0.01249981f, -0.05582389f, -0.00991014f, 0.00463365f, 0.01499589f, 
    -0.00738685f, 0.04291035f, -0.03999659f, -0.01564460f, -0.03760132f, -0.03145808f, -0.03052027f, -0.01111159f, 
    -0.00250546f, 0.01597861f, 0.04040395f, -0.05349844f, 0.03286034f, -0.00950391f, -0.05313943f, 0.00380407f, 
    -0.03824696f, 0.04040147f, -0.02988040f, 0.00380709f, -0.02012490f, -0.03449178f, 0.01962925f, 0.03530010f, 
    0.03845106f, -0.02614827f, -0.05192249f, -0.01083918f, 0.04157782f, -0.05174634f, -0.04590195f, 0.00677205f, 
    -0.00685794f, -0.04296566f, 0.03377679f, -0.05579349f, -0.03624985f, -0.04427836f, -0.02683794f, -0.01856347f, 
    0.04265063f, -0.00678555f, 0.01400081f, -0.04704238f, -0.00759594f, 0.03769002f, 0.03749913f, -0.02079393f, 
    0.02207474f, 0.00743991f, -0.00230327f, 0.03715875f, -0.02095521f, 0.00102016f, 0.00041624f, -0.04435487f, 
    0.01434089f, 0.04294197f, -0.01241992f, -0.03454841f, -0.01126591f, 0.02603522f, -0.02338134f, -0.04436460f, 
    0.01070353f, -0.01518088f, -0.04409922f, 0.00402790f, -0.04590542f, 0.01015890f, -0.05453669f, 0.04223910f, 
    0.01663287f, -0.04834920f, -0.05136679f, -0.02036554f, 0.04035797f, -0.03143483f, 0.01358196f, -0.03009651f, 
    -0.01756444f, -0.00493686f, 0.00509410f, -0.00790591f, -0.05358625f, -0.04906691f, -0.02127151f, -0.05560674f, 
    -0.05073668f, -0.01890187f, 0.00196522f, -0.02722821f, 0.01752653f, 0.02859478f, 0.02726744f, -0.05318399f, 
    0.03771307f, -0.05141202f, 0.00491591f, -0.05077319f, 0.02009110f, 0.01268701f, -0.02629159f, 0.02410039f, 
    -0.00177231f, 0.03608932f, 0.03973571f, 0.04391536f, 0.02771059f, -0.03664681f, 0.00035239f, 0.04225528f, 
    0.00041029f, 0.00503144f, 0.01277452f, -0.01863736f, -0.01008252f, 0.02237024f, 0.01977187f, 0.03532461f, 
    -0.02846993f, 0.00068659f, -0.05315853f, 0.02438035f, -0.02503045f, -0.04400105f, -0.02987427f, 0.00243590f, 
    -0.05185970f, -0.01796079f, 0.03319364f, 0.03474218f, -0.02287100f, -0.00764715f, -0.04230994f, -0.01501110f, 
    0.01021690f, -0.00383256f, -0.03058490f, 0.02908659f, -0.05568626f, 0.03946880f, 0.02013530f, -0.03684570f, 
    -0.04116096f, 0.03165616f, -0.03229233f, -0.04681874f, -0.00600120f, -0.02644271f, -0.00562105f, 0.02309280f, 
    -0.02992404f, -0.02119903f, -0.00606223f, 0.02793078f, -0.05525474f, -0.05232507f, -0.00616334f, 0.01578254f, 
    0.02490797f, -0.04162653f, -0.00416343f, -0.03577946f, 0.03970684f, -0.01147588f, -0.04813867f, 0.00859169f, 
    -0.03770083f, -0.03833699f, -0.01234728f, 0.03710297f, -0.03755391f, 0.03857687f, -0.00546207f, -0.03425347f, 
    0.01975926f, -0.01489000f, -0.02331427f, -0.01175235f, 0.01362545f, 0.01345912f, -0.05205911f, 0.01046263f, 
    0.00708109f, -0.04084103f, -0.02863108f, -0.01983783f, 0.00100754f, 0.01991635f, 0.04207644f, -0.05142777f, 
    -0.04522705f, -0.02675631f, -0.02578514f, 0.01495967f, -0.03623912f, -0.02344929f, -0.00157940f, 0.00255545f, 
    0.00639963f, 0.00750659f, -0.02124135f, -0.02294961f, 0.01125980f, -0.00577274f, -0.02315126f, -0.02175361f, 
    -0.03695006f, -0.04716567f, 0.02044531f, -0.01624638f, -0.02752663f, 0.03524118f, -0.00299335f, -0.03158276f, 
    -0.05616793f, 0.03783356f, 0.02967887f, 0.01249900f, 0.01612176f, -0.01567501f, -0.02679691f, -0.00026630f, 
    -0.05419157f, 0.00131000f, 0.00581180f, 0.02732247f, 0.02979839f, -0.00719275f, 0.01216208f, -0.00329441f, 
    -0.01922219f, -0.04831445f, 0.01590658f, 0.02901172f, 0.00402877f, 0.03954321f, -0.02928187f, 0.02700264f, 
    -0.04497410f, -0.01883429f, -0.02917389f, -0.01066754f, -0.04074210f, 0.02772628f, -0.03063220f, 0.01905966f, 
    -0.03032100f, -0.04048187f, -0.00923150f, -0.04727913f, 0.02868288f, -0.02613254f, -0.01635236f, -0.02067116f, 
    -0.00921254f, 0.01342434f, -0.02646989f, -0.04331645f, 0.00653804f, -0.00098620f, 0.00044892f, -0.02676141f, 
    -0.00847574f, -0.03142060f, -0.04102239f, -0.02789718f, -0.05299248f, 0.02424439f, 0.03823691f, -0.05295198f, 
    0.00310837f, -0.02771421f, -0.05279966f, -0.03039989f, 0.03328216f, -0.02949673f, 0.01308895f, -0.02470557f, 
    0.12365780f, 0.07843662f, -0.07461275f, 0.00788934f, 0.06452497f, 0.02191087f, 0.04809554f, -0.02137951f, 
    -0.09167967f, -0.04637149f, -0.02420257f, 0.05454233f, 0.12345299f, -0.02396843f, 0.00194560f, -0.07525760f, 
    0.06206921f, 0.01746187f, 0.06169826f, -0.07407173f, 0.00214469f, -0.08878855f, 0.15905540f, 0.21099544f, 
    0.42316192f, -0.46107957f, 0.09556887f, 0.16901147f, -0.11549864f, 0.00285941f, -0.02736339f, 0.10829266f, 
    0.20904863f, 0.08235776f, 0.05040493f, -0.09348807f, -0.13758400f, 0.07740434f, 0.19713485f, -0.14585167f, 
    -0.14491260f, -0.06015747f, 0.28293082f, 0.01309523f, -0.08195666f, -0.01107579f, -0.07281175f, 0.00607036f, 
    -0.05005081f, -0.04566550f, -0.08204194f, 0.13835359f, 0.04361609f, -0.04983594f, 0.04178295f, -0.01563682f, 
    -0.01816566f, -0.01655421f, 0.08960938f, 0.14673156f, -0.14013450f, 0.06819095f, 0.10711007f, 0.04226396f, 
    -0.05434109f, 0.07528741f, -0.01660953f, -0.00571444f, 0.01260643f, -0.20555584f, 0.01567904f, 0.15551217f, 
    -0.33365175f, 0.23890860f, -0.57126570f, 0.05374239f, 0.10284224f, 0.03030636f, 0.16132089f, 0.06762275f, 
    0.07767017f, 0.03832217f, 0.11755577f, -0.03084903f, 0.00080183f, 0.18539564f, -0.08275297f, 0.06134608f, 
    -0.14416808f, -0.09102551f, 0.13195999f, -0.04439329f, 0.05108208f, 0.08954787f, -0.08129986f, 0.06122465f, 
    -0.34120432f, 0.15598407f, -0.25022262f, 0.14090063f, -0.01830347f, -0.13707034f, -0.06615894f, 0.10555515f, 
    -0.00613907f, 0.05991980f, 0.07008918f, 0.05084153f, 0.18874754f, 0.24819256f, -0.18154901f, -0.09545316f, 
    0.07725064f, -0.07488100f, 0.05928212f, -0.06445140f, 0.05333904f, 0.06575748f, -0.02119829f, -0.03438940f, 
    0.24127829f, -0.29339755f, -0.00182388f, -0.11690311f, 0.04367677f, 0.13248003f, -0.21556734f, 0.09958412f, 
    0.08730004f, -0.00081479f, -0.00706991f, 0.03234806f, -0.05526042f, -0.15446809f, 0.17489935f, 0.00841623f, 
    -0.10297529f, 0.08742271f, 0.01258676f, 0.02035352f, -0.01240798f, -0.08972999f, 0.11017943f, -0.00187250f, 
    -0.30997023f, 0.11172666f, 0.34798974f, 0.18239942f, -0.00777002f, -0.04994329f, 0.10027664f, -0.01031953f, 
    0.05395925f, -0.01062287f, -0.11783643f, 0.04475840f, 0.00441140f, 0.04034432f, 0.13877450f, -0.02960139f, 
    -0.14593406f, -0.07762299f, 0.13205872f, -0.05392210f, -0.03315767f, -0.22319679f, -0.06785412f, 0.03937612f, 
    -0.14607881f, -0.16242325f, 0.15868960f, -0.01620628f, 0.11411288f, 0.19657086f, -0.14863496f, 0.01996639f, 
    -0.02336608f, 0.03583188f, 0.12824979f, -0.03434021f, 0.16120501f, 0.10057376f, -0.01292881f, -0.02099787f, 
    0.04603809f, 0.10074530f, 0.00669467f, 0.08436883f, -0.10024187f, 0.00578709f, -0.05523461f, -0.04719172f, 
    -0.07598231f, -0.03250606f, 0.15129873f, -0.18127280f, -0.05478065f, 0.08432741f, 0.20809673f, 0.07924237f, 
    -0.01637151f, 0.05070695f, 0.11456263f, 0.06821766f, 0.09249071f, -0.08489252f, 0.19012605f, -0.14055622f, 
    0.12198047f, 0.02779701f, -0.06633368f, -0.02618630f, 0.05603858f, -0.03941854f, -0.13275605f, 0.13050313f, 
    0.01274769f, 0.05796795f, 0.01414471f, -0.02747896f, 0.02721098f, 0.07071472f, -0.05722250f, -0.01599308f, 
    -0.00187218f, -0.05939182f, -0.09357921f, -0.13543689f, -0.14462326f, -0.05880957f, -0.09982111f, -0.03448383f, 
    -0.06945956f, -0.02345968f, 0.13923839f, 0.05585964f, 0.04305583f, 0.02997873f, 0.02943592f, 0.03341012f, 
    0.28211209f, 0.21402793f, 0.01575358f, -0.15434101f, -0.02876487f, -0.06775500f, -0.00450444f, -0.05655376f, 
    0.00596537f, -0.01544635f, -0.09362264f, -0.04415622f, 0.07811527f, 0.11959682f, -0.32904682f, -0.11390527f, 
    0.12438459f, -0.09274413f, 0.12225722f, 0.02600018f, -0.05906400f, 0.00422262f, -0.02109363f, 0.06135187f, 
    0.08285423f, -0.08251984f, 0.05361432f, 0.01991883f, 0.07982973f, 0.00978277f, -0.09845957f, -0.02467877f, 
    0.11293193f, 0.06956639f, -0.02149392f, 0.06509473f, 0.03203575f, -0.17847554f, 0.04541325f, 0.15625814f, 
    0.08828389f, 0.13086008f, -0.04619629f, -0.00475136f, -0.01081321f, 0.00263839f, 0.01498394f, -0.01826838f, 
    0.05400823f, -0.14505692f, -0.04767958f, 0.00222474f, -0.08697560f, -0.01785346f, 0.02862588f, 0.08753543f, 
    -0.11929421f, -0.02627378f, -0.06370044f, 0.17696129f, 0.12147360f, 0.02846745f, -0.09682798f, -0.01029712f, 
    0.11483271f, 0.08108463f, 0.11235113f, 0.03839133f, -0.08172468f, -0.00539683f, 0.03099976f, 0.09687301f, 
    0.08933814f, 0.13366134f, -0.01802003f, 0.03480755f, 0.00535934f, -0.04659917f, -0.02883269f, 0.06481539f, 
    -0.03279133f, -0.03981274f, 0.03561721f, 0.13894136f, 0.11510554f, 0.22089204f, -0.19451013f, -0.17578807f, 
    0.00018175f, -0.16456041f, -0.16355932f, 0.01375415f, -0.02992045f, -0.04180646f, 0.12279957f, 0.11880198f, 
    -0.02195234f, 0.14715776f, -0.23798144f, 0.13854495f, -0.11930608f, -0.03302288f, 0.17539114f, -0.08612634f, 
    0.04481838f, 0.15482755f, 0.05139303f, -0.17162357f, 0.06155074f, 0.09260550f, -0.02080025f, -0.07226504f, 
    0.09068084f, 0.07443873f, -0.16134639f, 0.18398267f, -0.14209305f, -0.04551348f, 0.09754079f, -0.01422552f, 
    0.00300131f, -0.04851087f, -0.10750995f, 0.13584787f, 0.09220327f, 0.06655159f, 0.04282058f, 0.02340479f, 
    0.04931959f, -0.07126252f, 0.05993047f, 0.01810108f, -0.28069359f, 0.09085640f, 0.04358426f, -0.18072695f, 
    -0.14986494f, 0.05518444f, 0.15074492f, -0.01903026f, 0.06803739f, -0.00207237f, 0.02533596f, 0.00878992f, 
    -0.04963008f, 0.02187519f, 0.02614795f, -0.03974163f, -0.02794584f, 0.00238000f, 0.01327086f, -0.05529978f, 
    -0.03920122f, -0.01474992f, -0.04922833f, 0.01593460f, -0.01022236f, -0.00542838f, -0.03057776f, 0.01295586f, 
    -0.03882128f, 0.01924475f, 0.00286293f, -0.00043361f, 0.01683177f, 0.03560653f, -0.05328441f, -0.04990100f, 
    0.03397323f, 0.04821626f, -0.05591659f, 0.00448096f, -0.04206702f, -0.00690290f, -0.03226653f, -0.04024313f, 
    0.00984296f, 0.04097278f, 0.00033794f, 0.01413979f, 0.03537559f, -0.03445881f, 0.00922219f, 0.02560424f, 
    0.04013988f, 0.01134822f, 0.02513584f, 0.00056999f, -0.00201752f, 0.04675492f, 0.03509394f, -0.04616834f, 
    -0.01406914f, 0.04203582f, -0.02312287f, -0.03556511f, 0.03232359f, -0.00021446f, 0.04467871f, -0.02356155f, 
    -0.03746238f, 0.04242269f, -0.03653076f, 0.02661200f, 0.03078622f, -0.02335335f, 0.03361805f, -0.01280144f, 
    -0.01528043f, -0.00599201f, 0.03810373f, 0.03138667f, -0.03819947f, -0.03609987f, -0.00909073f, -0.01703331f, 
    0.00990751f, 0.01687775f, 0.04009811f, 0.03565340f, -0.01989336f, -0.04108538f, -0.02281852f, -0.04453509f, 
    0.03019004f, -0.01904905f, -0.03848054f, 0.00625073f, -0.05468652f, -0.01885685f, -0.05027789f, -0.04216475f, 
    0.04234198f, 0.03112311f, 0.03993564f, -0.00385284f, 0.03650903f, -0.00816840f, 0.02047783f, 0.03648569f, 
    0.04441853f, -0.02934116f, -0.03509222f, -0.04508818f, -0.00219997f, -0.01203623f, -0.05474106f, -0.05545332f, 
    -0.04052274f, -0.00744243f, 0.01840783f, 0.04200763f, -0.03040687f, -0.02216762f, -0.02528041f, -0.04048320f, 
    -0.00684769f, -0.04973364f, 0.02658478f, 0.01226758f, 0.04150456f, 0.03555648f, 0.01550501f, 0.03589013f, 
    -0.00213194f, -0.04108305f, -0.05475863f, -0.04326153f, 0.03596289f, -0.00182889f, 0.04399932f, -0.00286968f, 
    -0.04940351f, -0.01275269f, 0.01270412f, -0.01990831f, -0.03032749f, 0.01981684f, 0.03150574f, -0.01434722f, 
    -0.01290079f, -0.04242045f, 0.03006802f, -0.03718811f, 0.02856951f, 0.01897139f, 0.01808527f, -0.05219510f, 
    -0.01801542f, 0.02037062f, -0.01650548f, 0.01966971f, -0.03918152f, -0.00349330f, -0.01566769f, -0.03366098f, 
    -0.03106526f, 0.02059151f, 0.01265854f, -0.03796324f, -0.01254630f, -0.01109154f, 0.00603787f, -0.04031663f, 
    0.01428218f, 0.01323066f, 0.02532155f, -0.03696274f, -0.04382429f, -0.05215847f, 0.02011264f, 0.04083423f, 
    -0.02798758f, -0.04315506f, -0.02307570f, -0.01397811f, 0.02235918f, -0.01672689f, 0.02704114f, 0.00187783f, 
    0.02859704f, -0.01767167f, 0.04368701f, -0.04360964f, -0.03034227f, 0.03030363f, -0.01916487f, -0.04491074f, 
    0.01776084f, 0.04364606f, 0.00616186f, -0.04974623f, 0.05323851f, -0.04941751f, -0.03230514f, -0.03625317f, 
    0.01350065f, -0.02336840f, -0.04977524f, 0.03958783f, -0.01837140f, -0.02605065f, -0.02612415f, -0.00892458f, 
    0.03235222f, 0.00751409f, -0.03269481f, -0.01872310f, 0.02686748f, -0.02474969f, 0.03690788f, -0.03870776f, 
    -0.01237653f, 0.00415997f, -0.02078707f, -0.02424126f, -0.05224358f, 0.02162746f, -0.00184961f, -0.03327847f, 
    0.01441288f, 0.00308402f, -0.03547724f, -0.01082136f, 0.02321213f, -0.00179481f, 0.03426006f, 0.04045163f, 
    -0.04914327f, 0.01551290f, -0.00767830f, 0.01812141f, -0.04240940f, -0.04194914f, 0.03747929f, -0.00404665f, 
    -0.01662863f, -0.03686824f, 0.01379243f, -0.02757815f, -0.03752482f, -0.04283427f, -0.02867696f, 0.00206056f, 
    -0.04639931f, 0.02990283f, 0.00215959f, 0.03845288f, 0.02492132f, 0.03511269f, -0.00341779f, 0.02562382f, 
    0.02886293f, -0.05204180f, 0.04785559f, -0.04057303f, -0.00340874f, -0.01587416f, -0.02703101f, 0.03403841f, 
    -0.03966191f, -0.02465674f, 0.03406616f, -0.02468299f, 0.04475250f, -0.05233367f, -0.02478041f, -0.04591908f, 
    0.01135741f, 0.02011131f, -0.03147142f, -0.02514538f, -0.04746193f, 0.00713417f, -0.05224658f, -0.02929986f, 
    0.00341326f, 0.01435034f, -0.00818135f, 0.02956984f, -0.02584543f, -0.01488914f, -0.00231914f, -0.04058156f, 
    -0.01300517f, -0.02348853f, 0.00846608f, -0.04203605f, -0.03967841f, -0.00618024f, -0.03293579f, -0.00973552f, 
    -0.02089918f, -0.00840691f, -0.03138852f, -0.04114024f, -0.01461765f, -0.05424429f, -0.03022500f, 0.02077974f, 
    0.00585179f, -0.03689703f, -0.00817762f, -0.01418975f, -0.02370506f, -0.02789285f, 0.03224077f, 0.02328636f, 
    0.02326383f, -0.04087459f, 0.01442114f, 0.04282055f, 0.01365955f, -0.03550121f, 0.01532485f, 0.00567679f, 
    -0.04827103f, 0.00032247f, -0.03133713f, 0.01312943f, -0.01039329f, -0.00267937f, 0.03572430f, -0.01684818f, 
    -0.00154174f, -0.02214689f, -0.01338910f, -0.03952423f, 0.03538520f, -0.05608211f, -0.00909148f, 0.00714068f, 
    0.04599456f, 0.02521199f, -0.00779352f, 0.04000068f, 0.02862346f, 0.00292007f, -0.01644018f, 0.00141417f, 
    -0.02518035f, -0.02182147f, -0.00874244f, -0.01979353f, -0.02607298f, 0.03324078f, -0.03270688f, 0.04336618f, 
    0.01361689f, -0.00625810f, -0.02053350f, 0.01149712f, 0.02616314f, -0.02844309f, 0.03250894f, 0.03462804f, 
    -0.00305484f, 0.01183329f, -0.02550551f, -0.05091810f, 0.02007485f, 0.03016408f, 0.01609656f, 0.03618889f, 
    -0.02533058f, -0.02954908f, 0.04629309f, -0.03029476f, 0.02798177f, 0.01348260f, 0.01809682f, 0.04076407f, 
    -0.03138007f, -0.04889608f, -0.02695889f, -0.04028680f, -0.00065847f, -0.00470949f, -0.03601377f, -0.05811130f, 
    0.03093067f, 0.03312055f, 0.02253198f, 0.03540007f, -0.04588189f, -0.00596451f, -0.02837490f, 0.03817368f, 
    -0.01632648f, 0.01008656f, -0.04484104f, 0.02656539f, -0.02518998f, -0.02812368f, -0.00417311f, -0.02266380f, 
    0.02969391f, -0.03958498f, 0.00075855f, 0.03897330f, -0.04763191f, 0.02769159f, 0.04991417f, 0.00228356f, 
    0.01986030f, 0.03085298f, -0.02708380f, -0.03807735f, -0.02090082f, -0.01505982f, -0.03279551f, 0.03396455f, 
    -0.03409326f, -0.02554621f, -0.03662621f, 0.00578539f, 0.02885471f, -0.03807602f, 0.04477877f, -0.03300150f, 
    -0.01301343f, 0.00442065f, -0.04016237f, 0.03965534f, -0.00559052f, -0.01748713f, 0.01296238f, 0.02987605f, 
    -0.02784279f, -0.02096035f, 0.02109986f, -0.00319282f, -0.03813028f, 0.04541899f, -0.05574759f, -0.00235565f, 
    -0.02378558f, -0.03058653f, 0.02994737f, -0.00658011f, 0.00749520f, -0.04235800f, 0.01864199f, -0.04700194f, 
    0.02355718f, 0.00883163f, -0.00403825f, 0.01517825f, 0.01869227f, -0.01792870f, -0.01997843f, -0.02901396f, 
    0.02586987f, -0.05156257f, 0.01772952f, 0.00501680f, -0.00951683f, -0.00098386f, 0.04697766f, 0.02396001f, 
    0.01358421f, 0.01960957f, 0.00120685f, -0.02332405f, -0.06140087f, 0.01853107f, 0.02225333f, -0.00688833f, 
    0.02482362f, 0.02959300f, -0.03400751f, 0.02830863f, -0.05913342f, 0.00714408f, 0.03353661f, -0.03477003f, 
    -0.01640403f, 0.03373629f, 0.00789636f, 0.04039298f, -0.01350087f, -0.02059392f, -0.01896631f, 0.03549293f, 
    0.03435789f, -0.04165292f, -0.04111124f, -0.02207975f, 0.03729797f, 0.00794144f, 0.02377729f, -0.04037831f, 
    0.01168956f, 0.02378665f, -0.00958273f, 0.03057000f, -0.01614021f, -0.04287532f, 0.01902990f, -0.04647801f, 
    -0.02596359f, -0.03826953f, -0.05711636f, -0.03573297f, -0.04693622f, -0.02551669f, 0.00238256f, -0.02736747f, 
    0.02293580f, -0.00688142f, 0.03316263f, 0.01779096f, 0.01049564f, 0.00365138f, -0.02210928f, -0.00544320f, 
    0.01160125f, -0.01936997f, -0.02634349f, -0.03477360f, 0.03781728f, -0.01441311f, 0.04011726f, -0.00667536f, 
    0.01357732f, 0.00702759f, -0.04696565f, 0.01090859f, -0.03174276f, 0.03544787f, -0.03816542f, 0.04249462f, 
    0.00911293f, 0.03513131f, 0.03455772f, -0.05325100f, -0.01440789f, -0.05293328f, 0.01538923f, 0.03131248f, 
    -0.03322901f, 0.01920301f, -0.04665307f, -0.00482955f, 0.04228820f, -0.01788657f, 0.03974455f, 0.00414730f, 
    0.02277125f, 0.00732540f, -0.04158843f, -0.02358118f, -0.04604108f, 0.00487680f, 0.02236979f, 0.02426043f, 
    -0.02041475f, -0.01374321f, -0.02467379f, 0.03942815f, -0.05765760f, -0.02328542f, 0.00549254f, 0.02781893f, 
    -0.02301734f, 0.02538892f, 0.04031761f, 0.01288166f, 0.01940465f, 0.02437270f, -0.00298341f, 0.01419131f, 
    -0.01162289f, -0.01905948f, -0.01275306f, 0.03145966f, -0.04910384f, -0.05980545f, 0.03838482f, -0.05452231f, 
    -0.00912524f, -0.05273342f, 0.00308805f, -0.02475205f, -0.04104793f, -0.01564403f, 0.00969260f, -0.03688107f, 
    0.01922841f, -0.05300641f, 0.01707061f, 0.01283283f, -0.04330434f, 0.03658264f, -0.03495148f, -0.03192793f, 
    -0.02437290f, 0.01972316f, -0.02528334f, 0.01692272f, -0.05458299f, -0.05698193f, -0.02100049f, -0.00666626f, 
    0.01452000f, 0.04696486f, 0.02512177f, -0.04629389f, 0.02810430f, -0.00507399f, -0.02378655f, -0.03514524f, 
    -0.03395078f, -0.05666373f, -0.03144038f, 0.00586439f, 0.01443629f, -0.04733071f, -0.05342153f, -0.03038677f, 
    -0.04848214f, -0.00642417f, -0.05735445f, -0.04242741f, -0.04160102f, 0.01138949f, 0.01006219f, 0.03952619f, 
    0.01319426f, -0.01855760f, 0.04582906f, 0.01948597f, -0.05712027f, 0.01517292f, 0.02491247f, -0.04816210f, 
    0.02003953f, 0.00194003f, 0.00666984f, -0.02644240f, 0.00665338f, -0.03563047f, 0.03447895f, 0.04730638f, 
    0.01566727f, 0.03187878f, -0.04241604f, -0.01866961f, 0.01353989f, -0.04174272f, 0.01427504f, -0.00617048f, 
    0.00095474f, -0.04851577f, -0.02179170f, 0.02518877f, -0.02539142f, 0.04027573f, -0.02311132f, -0.02622960f, 
    -0.01670631f, 0.02581540f, 0.04342402f, 0.02680283f, -0.04424405f, -0.05286396f, 0.01913521f, -0.03997239f, 
    -0.01953204f, -0.00659456f, -0.05204113f, 0.01640540f, 0.03691953f, -0.03732503f, -0.01420301f, 0.00426253f, 
    -0.01376882f, 0.00386854f, 0.00875892f, -0.03758638f, 0.02285253f, 0.00171020f, -0.00109084f, 0.01322938f, 
    -0.00091247f, 0.03377301f, -0.04913542f, -0.04263353f, -0.01675002f, 0.04046616f, -0.00318929f, -0.02409272f, 
    -0.04545902f, 0.02905022f, -0.02323630f, 0.02377417f, -0.02759664f, -0.04673091f, -0.00187150f, 0.03073559f, 
    -0.00345291f, 0.00349356f, 0.02491914f, -0.04288732f, -0.01615370f, 0.02175591f, -0.00467265f, 0.04306716f, 
    -0.02517143f, -0.04759756f, 0.03850808f, -0.05151904f, -0.04109783f, -0.01281977f, 0.00472524f, -0.00247950f, 
    0.02879561f, -0.01924321f, -0.04798855f, -0.04918057f, 0.02881589f, 0.01817460f, -0.03281596f, 0.00070240f, 
    -0.03821724f, -0.04867396f, -0.00514404f, -0.03962909f, -0.04833636f, 0.03693885f, -0.04654172f, -0.00027622f, 
    -0.01129138f, -0.02467681f, 0.04076742f, 0.02455044f, 0.03651664f, 0.03681064f, -0.01493273f, 0.04555395f, 
    -0.04921756f, -0.02718005f, 0.04756867f, -0.02915152f, 0.03760182f, 0.03707850f, 0.01595146f, -0.02786455f, 
    -0.00224199f, 0.00921971f, -0.02219071f, -0.00272404f, -0.05446995f, -0.03307456f, 0.01995089f, 0.02638395f, 
    -0.05914610f, 0.03438815f, 0.00573449f, 0.02399634f, -0.04026675f, 0.00111629f, -0.04485697f, -0.01203459f, 
    0.02978841f, -0.04647617f, -0.02711664f, -0.01845282f, 0.03113662f, -0.03819261f, -0.04758027f, 0.00938600f, 
    0.07412522f, -0.10298997f, -0.04839635f, 0.04065248f, 0.06302080f, 0.03543141f, 0.08137505f, 0.03436571f, 
    0.35184759f, 0.00288156f, 0.08629567f, 0.08587345f, -0.09775318f, -0.14307503f, 0.02238129f, -0.29907379f, 
    0.12241433f, -0.02881591f, 0.01677247f, -0.07650908f, 0.06714980f, 0.05811111f, -0.05411006f, -0.14727247f, 
    -0.23802976f, 0.13827541f, -0.07677276f, 0.01733904f, 0.00042473f, -0.04908969f, -0.02481067f, 0.11123644f, 
    -0.04725299f, 0.09082855f, 0.24952100f, 0.19026046f, 0.31708452f, -0.03826698f, 0.11603668f, 0.32117036f, 
    0.12343692f, 0.06451215f, 0.01245710f, -0.02754287f, 0.31411198f, 0.03478093f, 0.28928530f, 0.05388411f, 
    -0.09291693f, 0.15354475f, -0.09273118f, -0.06593548f, -0.08631886f, -0.02827019f, -0.02535515f, -0.01967175f, 
    -0.12846850f, -0.11617329f, -0.09106936f, -0.16007747f, 0.00846345f, 0.07969448f, 0.26059774f, 0.11721829f, 
    -0.01491046f, -0.10808685f, -0.05748431f, -0.00056428f, 0.11550147f, 0.01240674f, 0.04659991f, -0.06063878f, 
    0.14996682f, 0.03387196f, 0.08744879f, -0.06596887f, 0.03209309f, 0.18429704f, -0.10558197f, 0.17507514f, 
    -0.02408330f, 0.00262493f, 0.00089454f, -0.00066514f, -0.09108228f, -0.13677883f, 0.04479287f, -0.22763956f, 
    0.04718355f, 0.13849694f, -0.08137967f, 0.14050063f, 0.06323165f, -0.09483776f, 0.09137653f, -0.10025374f, 
    0.09615827f, -0.16359390f, 0.23853569f, 0.06405704f, 0.11926822f, 0.09735811f, 0.18092552f, 0.04760851f, 
    -0.05078351f, -0.02062283f, -0.09988192f, 0.07224975f, -0.22429051f, 0.01292356f, -0.03738127f, -0.27660245f, 
    -0.06481139f, -0.01623520f, 0.23073614f, -0.31064233f, 0.04074740f, -0.10162676f, -0.06489922f, -0.09552859f, 
    -0.57358563f, 0.08555354f, -0.05944050f, -0.18171088f, -0.21221405f, 0.00164363f, 0.16598898f, 0.03660601f, 
    0.09529541f, -0.04258776f, -0.01250666f, 0.02816533f, 0.29253739f, 0.00269887f, 0.16273431f, -0.01016468f, 
    0.04902799f, 0.20001146f, -0.14560793f, 0.29224145f, -0.08146064f, -0.00591469f, 0.06980509f, -0.15461384f, 
    0.31590128f, -0.09928431f, 0.15962075f, 0.19578373f, 0.11241494f, 0.07282846f, -0.04975656f, -0.02435371f, 
    0.01651619f, 0.02728790f, 0.03980538f, -0.03897092f, -0.03263670f, -0.14188850f, 0.11941089f, -0.02541867f, 
    0.09920183f, -0.01303958f, 0.03302997f, 0.09394887f, 0.20141774f, 0.05563725f, 0.07858206f, 0.08781754f, 
    0.32731983f, 0.26089510f, -0.13538784f, 0.04670786f, -0.01958978f, -0.07609122f, 0.15194459f, 0.08202744f, 
    0.05516462f, -0.02458076f, 0.02099708f, -0.04244870f, -0.18312612f, 0.08089701f, 0.05020165f, -0.05509613f, 
    -0.10396725f, -0.13883774f, -0.11804747f, 0.06490209f, 0.11550096f, -0.05571780f, 0.00416585f, -0.05264322f, 
    -0.20537557f, 0.19948098f, 0.07964213f, -0.12224951f, 0.10065968f, 0.07078371f, -0.00903120f, 0.10593347f, 
    0.04328382f, 0.04917001f, 0.03465862f, 0.04100266f, -0.30776659f, 0.02253800f, -0.09452501f, 0.06185103f, 
    -0.03892823f, -0.06308459f, 0.03425577f, 0.02835712f, 0.15717883f, -0.05365233f, 0.05386260f, -0.02969482f, 
    -0.03285274f, -0.19505499f, -0.03462318f, -0.10138605f, -0.04079810f, 0.07651643f, 0.27967313f, 0.09239493f, 
    0.00400769f, 0.01955573f, 0.07830872f, 0.18358876f, 0.15342997f, -0.12327446f, 0.05149461f, -0.15617664f, 
    0.17814110f, 0.06647321f, -0.06089653f, 0.03947349f, -0.05776209f, 0.02287455f, -0.04379368f, 0.03271872f, 
    0.10728502f, -0.14364968f, 0.25910386f, 0.30574098f, -0.01287951f, 0.26894560f, -0.01760095f, -0.21488936f, 
    0.07983302f, -0.02826416f, 0.18239690f, -0.04214045f, 0.06872285f, -0.07558559f, -0.02809862f, 0.00477757f, 
    0.09144516f, 0.03724201f, 0.29552513f, -0.13561353f, 0.01375012f, -0.03920516f, 0.16396981f, -0.09781435f, 
    -0.06652364f, -0.03504224f, -0.09177411f, -0.16648203f, -0.05170706f, 0.09790467f, -0.09833913f, 0.04992523f, 
    -0.11186339f, 0.20350157f, -0.17572396f, 0.20955825f, -0.02978952f, 0.09131178f, 0.00328885f, -0.05697908f, 
    -0.08977993f, 0.02605476f, 0.11891074f, 0.11999884f, 0.05829919f, -0.01269058f, -0.03825528f, -0.07167115f, 
    -0.00123160f, 0.09351446f, 0.04173371f, 0.09832147f, 0.00479152f, 0.20099470f, -0.12656964f, 0.18255420f, 
    0.08375888f, -0.06153094f, 0.05802444f, -0.00313419f, -0.03483501f, 0.19394876f, 0.04849062f, -0.19204004f, 
    -0.10293501f, -0.06695831f, 0.00519879f, -0.14390701f, 0.11558471f, -0.07360284f, 0.08218863f, -0.03671538f, 
    -0.28068155f, -0.09102410f, -0.00392327f, -0.19337414f, 0.16700569f, -0.08751184f, -0.06441310f, -0.00690993f, 
    -0.06038268f, -0.05851809f, 0.03806376f, 0.05590175f, 0.00296975f, -0.06536404f, 0.20951167f, -0.38401544f, 
    0.16536573f, 0.05031342f, -0.03801557f, -0.17547667f, 0.10388861f, 0.08386666f, -0.06557473f, -0.04808932f, 
    0.00457819f, 0.18707667f, -0.09344669f, 0.14919339f, 0.14196949f, -0.02324277f, 0.06847907f, 0.04618490f, 
    -0.10273924f, -0.11199643f, -0.05187995f, -0.01242161f, 0.00498821f, -0.04956799f, 0.00452763f, -0.05903668f, 
    -0.03155771f, 0.05525942f, -0.00266662f, -0.00331205f, 0.08488870f, 0.06349576f, -0.03167360f, -0.01014414f, 
    0.01069489f, 0.00134790f, -0.18608932f, -0.02846948f, 0.04186159f, 0.01452796f, 0.09184949f, 0.02451177f, 
    0.01709276f, 0.11128895f, 0.09152264f, 0.07637481f, -0.09953664f, -0.24167690f, 0.07703616f, -0.01342705f, 
    0.25088510f, -0.12467726f, 0.09065313f, -0.00937864f, 0.11976874f, -0.10142510f, 0.01407046f, 0.25743642f, 
    -0.18313804f, -0.04391807f, 0.00733782f, -0.12225198f, -0.04947309f, -0.02129246f, 0.02305115f, -0.08697213f, 
    -0.08630001f, -0.04593093f, -0.14050920f, -0.42457145f, -0.06291914f, -0.14757963f, -0.03921556f, 0.03113016f, 
    -0.06899418f, -0.00095769f, 0.07235990f, -0.05684779f, 0.17913143f, 0.27103645f, 0.19878183f, 0.11635253f, 
    0.22194467f, 0.55461317f, -0.35023141f, -0.41891041f, 0.08590471f, -0.09274969f, -0.10286047f, -0.06496610f, 
    -0.09722028f, -0.20285389f, 0.04003073f, -0.04765301f, 0.01097276f, 0.24648577f, 0.22438829f, -0.25823611f, 
    0.03734578f, -0.06588446f, 0.16014300f, -0.22501321f, 0.03438875f, -0.19499183f, -0.04308140f, 0.16050601f, 
    -0.07644698f, 0.06621204f, 0.21868008f, 0.07767734f, -0.09037002f, 0.02675861f, -0.08525001f, -0.03370302f, 
    -0.10795635f, 0.04081295f, 0.12281598f, 0.11127789f, 0.35040405f, -0.40769058f, -0.02472807f, -0.29126498f, 
    0.06568340f, -0.05133468f, 0.06652930f, -0.20365295f, 0.12776303f, 0.05674792f, 0.11546723f, 0.07074828f, 
    -0.02860445f, -0.22687601f, 0.15152021f, 0.32642102f, -0.01020948f, -0.15421444f, 0.12844729f, 0.05341606f, 
    -0.01816161f, 0.06908634f, 0.01090293f, 0.08313372f, -0.03716293f, 0.13399364f, -0.00243014f, -0.08749010f, 
    -0.02177660f, -0.10161764f, 0.04124650f, -0.14296734f, 0.22425334f, 0.24430071f, 0.12898526f, 0.10450467f, 
    -0.35989761f, -0.37193638f, 0.26794216f, 0.03567650f, -0.17605563f, -0.17212348f, -0.03905569f, 0.12496981f, 
    -0.01368630f, -0.05713476f, -0.00200966f, -0.03495815f, 0.02949364f, -0.14221950f, -0.29597691f, 0.00568747f, 
    0.06132853f, 0.16725345f, 0.24971700f, 0.21675901f, -0.17408684f, 0.15184253f, -0.02916859f, -0.03125499f, 
    -0.14864437f, -0.31637061f, -0.40050218f, 0.21528707f, -0.10947027f, 0.29404172f, 0.03443705f, 0.25696346f, 
    0.11966501f, 0.12112240f, 0.11773561f, 0.03566362f, -0.05086571f, 0.18791233f, 0.13829739f, 0.15588263f, 
    0.04234593f, 0.09026904f, 0.12660377f, -0.11606634f, 0.05254698f, 0.04194022f, 0.13123225f, 0.22862363f, 
    0.73897326f, 0.56238341f, 0.32644162f, -0.24365430f, 0.01962205f, -0.10193525f, -0.01164813f, 0.03399200f, 
    0.03050757f, 0.25210565f, 0.12796225f, -0.01060066f, 0.09481584f, 0.15714748f, 0.01310574f, -0.05640244f, 
    0.04665348f, -0.01366398f, 0.04647940f, -0.03170335f, -0.03636120f, -0.16849957f, -0.10099146f, -0.39339599f, 
    -0.06206224f, 0.17082439f, 0.19482139f, 0.11061464f, -0.08362934f, 0.10516637f, -0.03910206f, 0.01272750f, 
    0.07659540f, 0.04569985f, 0.09371088f, 0.13918819f, -0.16668205f, -0.30355307f, -0.33728752f, -0.09123192f, 
    0.07124715f, 0.12067222f, -0.06083462f, 0.17425704f, -0.02994466f, 0.10316358f, -0.17105101f, -0.08805555f, 
    -0.05432990f, -0.19853064f, -0.05784345f, -0.10656870f, 0.05883500f, 0.05915226f, 0.21385129f, -0.07881372f, 
    -0.06759534f, -0.09343880f, -0.04435879f, -0.03962888f, 0.08149161f, 0.22072579f, -0.16228889f, -0.18173528f, 
    -0.04032120f, 0.20125371f, 0.13037600f, -0.01223879f, -0.01709866f, 0.09975515f, 0.07047387f, 0.15632989f, 
    0.17869268f, -0.10213979f, -0.15673070f, -0.00273592f, 0.09594970f, -0.09312703f, 0.03555144f, 0.01831292f, 
    -0.01188328f, -0.25568560f, -0.18652590f, -0.06749882f, -0.01511543f, -0.04249860f, 0.03938678f, -0.02777921f, 
    0.03185254f, -0.02785099f, -0.07416916f, -0.18289809f, 0.01143452f, 0.18883888f, 0.06842721f, 0.15261884f, 
    0.03183115f, 0.24679421f, -0.03136330f, 0.06490995f, 0.05844432f, -0.00062487f, 0.03457996f, 0.26171690f, 
    0.01288666f, 0.02141811f, -0.11765264f, 0.05720222f, 0.01648392f, -0.19291610f, -0.11141759f, 0.23546001f, 
    -0.16033798f, 0.05106835f, 0.28787374f, 0.22359206f, -0.07059499f, 0.18045512f, -0.12395377f, -0.23393269f, 
    -0.19505341f, 0.23778161f, -0.08710202f, 0.11091743f, 0.02034842f, -0.02731321f, 0.01333875f, -0.01335654f, 
    0.19644605f, 0.04359728f, -0.02496824f, 0.29391101f, -0.09777118f, -0.05507935f, 0.25348982f, 0.02764097f, 
    -0.14374797f, 0.03920211f, -0.01616609f, -0.08256166f, 0.04701446f, 0.13893498f, 0.02145921f, -0.04021204f, 
    -0.08889556f, -0.09380222f, -0.07276908f, 0.20758565f, 0.12309035f, 0.09301778f, 0.18674879f, 0.08835844f, 
    0.28798398f, -0.03259388f, 0.13366236f, 0.09475679f, 0.26754528f, 0.15473197f, -0.28675789f, -0.02775638f, 
    -0.03597511f, -0.00413299f, 0.06216438f, 0.12348261f, -0.03653615f, 0.09552965f, -0.08375711f, -0.01989909f, 
    0.35585296f, 0.15819426f, -0.24946682f, 0.05328837f, 0.04150656f, -0.01688536f, -0.01080477f, 0.00251465f, 
    -0.01616316f, 0.01308138f, 0.01158146f, 0.12214736f, 0.19579001f, 0.15893385f, 0.03459270f, 0.27484849f, 
    0.01060020f, -0.01458044f, 0.21602172f, 0.01829568f, -0.02865220f, 0.08411004f, 0.04259911f, 0.12160777f, 
    -0.06083322f, 0.11970457f, 0.13568951f, 0.11220159f, -0.04025065f, 0.05093776f, 0.07938781f, 0.23344560f, 
    -0.18230785f, 0.05162088f, 0.12276529f, 0.06251889f, -0.17245932f, -0.00241919f, 0.01854525f, -0.15827920f, 
    0.05196851f, 0.15034458f, 0.16550301f, 0.11096456f, 0.02636308f, -0.06420850f, -0.05127981f, -0.10663728f, 
    -0.40312874f, 0.10618866f, 0.16495727f, 0.08487498f, -0.05627148f, 0.02649429f, -0.03395659f, -0.04090009f, 
    0.01532657f, -0.01228673f, -0.19361626f, -0.09351315f, 0.26358300f, -0.23904240f, -0.15507157f, -0.12668850f, 
    0.28010917f, 0.11393537f, 0.08116727f, -0.00517180f, -0.05528667f, 0.11391103f, 0.02540610f, -0.01692815f, 
    -0.24406554f, 0.08554815f, 0.08587380f, -0.03476549f, -0.07270359f, 0.02676671f, -0.05668147f, -0.12913339f, 
    -0.07700969f, 0.07203251f, -0.04179804f, -0.16471837f, 0.08773755f, 0.05364395f, -0.02895231f, 0.15330487f, 
    -0.06992736f, 0.24014547f, 0.10063151f, -0.02528007f, 0.08644164f, 0.09992927f, 0.04563764f, 0.17515865f, 
    0.39137435f, 0.02460139f, 0.13381384f, 0.02121615f, -0.06695091f, -0.15676540f, -0.09060659f, -0.11989274f, 
    0.30866635f, 0.05110122f, -0.10494772f, -0.07885309f, -0.07247616f, 0.22225356f, 0.18271047f, -0.08120684f, 
    -0.09298177f, 0.00169868f, 0.05775664f, 0.13770384f, -0.05281426f, 0.02298929f, -0.14014821f, 0.10705194f, 
    -0.11005875f, -0.10954724f, 0.12878092f, 0.15957907f, -0.03630675f, -0.16254003f, -0.13402174f, -0.16302785f, 
    -0.15631467f, -0.17957149f, -0.13328819f, 0.15617402f, -0.13197361f, -0.29799002f, -0.26729137f, -0.06588089f, 
    -0.03291246f, -0.01369423f, -0.00337245f, -0.19022033f, -0.00055372f, 0.04557502f, 0.03474476f, 0.21473202f, 
    -0.03381178f, -0.13498235f, 0.02232856f, 0.20026551f, 0.15363786f, -0.01278712f, 0.14866742f, 0.06942850f, 
    -0.08320162f, 0.06349648f, 0.02855880f, 0.06185862f, -0.01712175f, 0.06114136f, -0.07557281f, -0.00816963f, 
    -0.05914747f, -0.01246118f, 0.02389138f, -0.12846085f, -0.01695401f, 0.14344758f, -0.00562497f, 0.27067998f, 
    -0.38290009f, -0.00476653f, 0.01728933f, -0.18030031f, 0.01574617f, -0.06810639f, -0.22286497f, 0.04490265f, 
    0.07763450f, -0.01293388f, -0.10109978f, -0.15747105f, 0.08976337f, -0.06430369f, -0.13764194f, 0.10620895f, 
    0.09918819f, 0.19211201f, 0.01093810f, 0.06640136f, -0.16235892f, 0.15036380f, 0.01817930f, 0.12809816f, 
    0.45350000f, -0.07604261f, -0.20452902f, 0.15566148f, 0.02192118f, 0.21075016f, -0.00084326f, 0.13951910f, 
    0.04641708f, 0.08319379f, 0.03887175f, 0.04592735f, -0.10392549f, -0.05951046f, -0.17462194f, 0.13348620f, 
    0.09637331f, -0.00280470f, 0.21969745f, -0.09300113f, 0.15324096f, 0.18739474f, 0.15593153f, 0.17067863f, 
    0.15959847f, 0.21064380f, 0.11376423f, -0.04023436f, 0.07520379f, -0.10629831f, 0.00821898f, 0.16180952f, 
    0.02833627f, 0.12676789f, 0.15698954f, 0.12162133f, 0.13033907f, 0.11247248f, 0.03334638f, -0.02133711f, 
    -0.00508870f, 0.05880125f, 0.02876232f, -0.11753077f, 0.03377170f, 0.10259306f, -0.02264749f, -0.33722299f, 
    -0.39122531f, -0.17859836f, 0.20822927f, 0.05933779f, -0.05707691f, 0.02742438f, -0.11586232f, -0.15310878f, 
    0.02501822f, -0.02771202f, -0.03638957f, 0.24419473f, 0.09946822f, 0.00157679f, -0.12694390f, -0.00882475f, 
    0.12358680f, 0.23996483f, 0.19083007f, 0.04378744f, -0.00368151f, -0.01808403f, -0.02362666f, -0.08324634f, 
    0.08754177f, -0.06862190f, -0.16554043f, -0.03394537f, -0.04435220f, 0.02727055f, 0.15698813f, 0.03906881f, 
    -0.02456335f, -0.06119133f, -0.07530470f, 0.02395028f, 0.23292707f, 0.01738027f, -0.23809090f, -0.42460820f, 
    -0.01574568f, -0.04890195f, 0.24583848f, 0.10770951f, -0.07347390f, 0.13497102f, 0.06547538f, 0.03665356f, 
    0.09027249f, 0.26926014f, -0.13161962f, -0.07533044f, 0.17572403f, 0.08393351f, -0.06521676f, -0.00479065f, 
    0.02182542f, -0.07007366f, -0.02771016f, -0.20272568f, -0.20762157f, 0.11315919f, -0.09664313f, 0.03199640f, 
    -0.12964758f, -0.08798279f, -0.00399669f, 0.02760411f, -0.07653751f, -0.00052389f, 0.00101009f, -0.03415002f, 
    0.06172642f, 0.30549192f, -0.19344164f, -0.27332675f, 0.16322473f, -0.08205757f, 0.13203545f, 0.24232157f, 
    0.00108352f, 0.04391787f, -0.06768313f, 0.01605227f, -0.08946813f, 0.03565719f, 0.06467092f, 0.18180749f, 
    -0.12353961f, -0.02867298f, -0.07366838f, 0.18648106f, 0.09272747f, 0.22525249f, -0.03093752f, -0.06363440f, 
    -0.11191840f, 0.01456968f, -0.05224459f, 0.10127427f, -0.13298561f, -0.20381975f, 0.09834676f, -0.10954046f, 
    0.18880574f, -0.02773397f, 0.02985348f, -0.02045648f, -0.06825538f, -0.10167677f, 0.08328146f, 0.01005532f, 
    -0.01621598f, -0.13504292f, -0.14345479f, -0.03782531f, -0.08659355f, 0.00355646f, -0.09512237f, -0.05808441f, 
    -0.07312430f, -0.23691064f, -0.16757916f, -0.21086033f, 0.06484531f, -0.06406688f, 0.18592204f, -0.00588960f, 
    0.13064678f, 0.06285067f, 0.08546831f, 0.13765992f, 0.17074336f, 0.04808925f, -0.02805385f, -0.07741617f, 
    -0.00717925f, 0.04252362f, 0.09824274f, 0.12180349f, 0.05276083f, 0.08441079f, -0.16645777f, -0.09959122f, 
    0.30713865f, 0.17773095f, -0.08816653f, 0.01544654f, -0.10406293f, 0.01116610f, 0.19318129f, -0.01073041f, 
    0.05250599f, 0.03205444f, -0.06977388f, -0.07499173f, 0.18272740f, -0.02607788f, -0.17809860f, 0.18637520f, 
    -0.05058412f, 0.06059190f, 0.15360868f, 0.12665810f, -0.01760045f, 0.01382624f, 0.04003490f, 0.09077065f, 
    -0.06807266f, -0.37613633f, 0.23106505f, -0.16274521f, 0.06762114f, 0.05050837f, -0.11978610f, 0.06582295f, 
    0.08529016f, 0.17882760f, -0.08805392f, 0.23400025f, -0.29668683f, -0.16112424f, -0.18502821f, -0.14591466f, 
    0.03020129f, 0.04370383f, 0.19944422f, 0.09803581f, -0.06488813f, 0.05910899f, 0.10306209f, 0.04604787f, 
    -0.23451962f, 0.09828061f, 0.22786437f, 0.05837838f, 0.05574609f, -0.05312676f, -0.22540824f, -0.04551206f, 
    -0.09676120f, -0.16939712f, -0.21291052f, -0.18416026f, 0.16010129f, 0.32825986f, 0.04629314f, 0.11393065f, 
    0.06548379f, 0.18228759f, 0.05363429f, -0.00423117f, -0.03791010f, 0.22202589f, -0.00514650f, -0.08911758f, 
    0.25094634f, -0.01516603f, 0.19386901f, -0.04444172f, 0.05313924f, 0.00099507f, 0.07529861f, 0.08225212f, 
    0.25329322f, 0.09613743f, 0.19693142f, 0.35104284f, 0.08641268f, 0.13425566f, 0.08058090f, -0.17691937f, 
    0.06967802f, 0.08180013f, 0.27065194f, 0.06903525f, -0.10814113f, -0.18319578f, -0.11324031f, -0.10378671f, 
    0.35960150f, -0.40362012f, 0.26228470f, 0.51471806f, -0.17006372f, 0.00521965f, -0.11980838f, 0.05446378f, 
    0.20226648f, 0.14017509f, 0.11406316f, 0.00439283f, 0.13260236f, -0.25804451f, 0.32815832f, 0.12115880f, 
    -0.03304731f, 0.19541542f, -0.18719332f, -0.06697906f, 0.12114210f, 0.17996140f, 0.01332509f, -0.17495614f, 
    0.23529628f, 0.16319716f, 0.11387151f, 0.15683907f, -0.09320963f, -0.04830198f, -0.07470263f, 0.02630590f, 
    0.09169248f, 0.02115157f, -0.03440240f, 0.07188097f, 0.08378208f, 0.39808697f, 0.14722151f, 0.07318313f, 
    -0.01548772f, -0.05105246f, -0.08382142f, 0.01746253f, -0.06684870f, 0.01324259f, -0.06937549f, 0.16624461f, 
    0.00351892f, 0.44777027f, -0.26854244f, -0.14028518f, 0.09040411f, 0.03555528f, 0.09833516f, -0.16653509f, 
    -0.05067386f, -0.00399688f, 0.01183325f, 0.05423389f, 0.14586169f, 0.07471939f, 0.00305642f, 0.08051105f, 
    -0.06424700f, -0.11298305f, 0.21651721f, 0.14113119f, -0.21611734f, -0.16247027f, -0.10995333f, -0.12226193f, 
    0.49581984f, 0.43544778f, -0.43127784f, -0.01407726f, -0.00890506f, -0.07386661f, -0.02008802f, 0.12104291f, 
    0.02542907f, 0.12188877f, 0.04743575f, 0.13150750f, -0.16980509f, -0.02509864f, 0.41765454f, -0.04464693f, 
    -0.01657020f, -0.05678356f, -0.04894727f, -0.09906550f, 0.08318260f, -0.06054348f, 0.08608715f, -0.09551556f, 
    0.30570939f, -0.00351042f, 0.54110688f, -0.41850623f, -0.04904029f, -0.14335875f, -0.00265900f, -0.00381493f, 
    0.02782558f, -0.02372269f, 0.03731982f, 0.18664645f, 0.02563036f, 0.06726508f, 0.01147922f, 0.15239102f, 
    -0.03579490f, -0.09595517f, 0.10671113f, 0.14125910f, 0.19630866f, -0.05842017f, 0.01464418f, 0.05445015f, 
    -0.24936993f, -0.31545466f, -0.26122689f, 0.46160561f, -0.12064060f, 0.05621682f, 0.09159017f, -0.00193909f, 
    0.09162620f, -0.19417660f, 0.07214779f, 0.00977843f, -0.07970010f, -0.17505416f, 0.11804904f, 0.20332853f, 
    0.01879931f, -0.01614306f, -0.03667013f, -0.01438448f, -0.01649106f, 0.11317773f, 0.03514576f, 0.16470940f, 
    0.31157622f, 0.08821220f, 0.17403461f, -0.05743824f, -0.05284018f, 0.08539254f, -0.03859443f, 0.08940627f, 
    0.11243506f, 0.01448539f, 0.05593050f, -0.06446797f, 0.17257348f, 0.01640126f, 0.08534355f, 0.00485434f, 
    -0.15874657f, -0.11469474f, 0.08078518f, 0.03300823f, 0.14450318f, -0.01105711f, 0.25155076f, 0.15295123f, 
    0.01853248f, 0.08641575f, 0.14391485f, -0.15970963f, -0.06048731f, -0.02741828f, -0.17021248f, -0.01014952f, 
    -0.03115407f, -0.06594197f, 0.01218629f, 0.19088240f, 0.08063702f, -0.01089423f, 0.13704215f, 0.19262718f, 
    -0.00712056f, -0.03748169f, -0.01899173f, 0.02822759f, 0.05024426f, 0.08319232f, 0.09480716f, 0.03254808f, 
    -0.25249302f, 0.04960207f, 0.22503847f, -0.05533853f, -0.15336987f, -0.01255622f, -0.02387263f, 0.14635897f, 
    0.08587675f, -0.05348438f, 0.01039694f, 0.16281401f, 0.31314325f, 0.14066742f, 0.17003672f, 0.03667279f, 
    -0.08452179f, -0.12164644f, 0.11095341f, 0.06485485f, -0.01948208f, -0.11059389f, -0.01343683f, -0.07511099f, 
    -0.16507448f, -0.23587455f, -0.05032373f, 0.07605157f, 0.09693548f, -0.01873757f, 0.00042762f, -0.03643951f, 
    0.12676176f, -0.01395117f, -0.02025027f, -0.15755318f, -0.12636779f, 0.52074385f, -0.07279545f, -0.32783440f, 
    0.15647840f, 0.09467742f, -0.10589818f, 0.15422951f, 0.11906315f, -0.05540533f, 0.26836669f, 0.27710447f, 
    0.31996512f, -0.16671030f, 0.13517140f, 0.03494098f, -0.04502572f, 0.04338677f, -0.01809513f, -0.06467616f, 
    0.09217836f, 0.12799779f, 0.07896620f, -0.10816981f, 0.25817105f, 0.21374559f, 0.04326891f, 0.09712001f, 
    0.05195963f, 0.01258065f, 0.02673549f, 0.07198608f, 0.06813280f, -0.00119522f, -0.04014821f, 0.03286870f, 
    0.05489847f, 0.16684528f, 0.01461119f, -0.24602079f, -0.18948539f, -0.01980357f, 0.11819445f, 0.06902885f, 
    -0.16239846f, 0.01514747f, 0.00385982f, 0.02112485f, -0.32533509f, -0.07601555f, 0.35247704f, 0.08783662f, 
    0.12408367f, -0.02066133f, -0.07223546f, 0.13771421f, 0.12957750f, 0.01812697f, 0.07499457f, -0.00000217f, 
    -0.32348782f, -0.11383465f, 0.16582891f, -0.15190759f, -0.08614434f, -0.00817496f, -0.05004166f, 0.21674062f, 
    -0.05928535f, -0.09665536f, -0.08028755f, -0.18604746f, -0.15148354f, -0.20517665f, 0.00589767f, -0.19324525f, 
    -0.02267497f, -0.04375566f, 0.06775748f, 0.06867720f, -0.06059973f, -0.03333562f, -0.03288299f, -0.03637377f, 
    -0.20703356f, 0.46626812f, -0.33264568f, 0.06438565f, 0.03520982f, -0.01691787f, 0.05570435f, -0.11184320f, 
    0.03312599f, -0.00497578f, -0.03729238f, -0.04305583f, 0.00099855f, -0.09421200f, 0.05700424f, 0.02731369f, 
    0.25600052f, 0.09861689f, -0.00588197f, -0.02736503f, -0.08244369f, -0.01695109f, -0.00512014f, -0.02460718f, 
    0.30300397f, -0.01637873f, 0.15915586f, -0.13743638f, -0.04131264f, 0.08633588f, 0.08772538f, -0.00824569f, 
    0.29671621f, 0.08247285f, 0.26483878f, 0.29995900f, -0.28712562f, 0.28032097f, 0.02126329f, -0.02559973f, 
    -0.23880370f, 0.04666185f, 0.05421950f, 0.03730414f, 0.06329586f, -0.15757604f, -0.08951115f, 0.00829959f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06460324f, -0.04696273f, -0.08504016f, 0.01707057f, 0.30432314f, 0.00481542f, 0.16823514f, 0.10471400f, 
    0.14308755f, 0.03742920f, 0.00668963f, 0.30109888f, -0.02821687f, -0.02611275f, 0.07852325f, 0.20700631f, 
    0.01949294f, -0.07647663f, -0.04169014f, 0.09719832f, -0.06299639f, 0.01154359f, 0.03098670f, 0.01037204f, 
    -0.05071001f, 0.07922183f, -0.03827247f, -0.02568464f, 0.11526246f, -0.01664964f, 0.11717004f, 0.19228956f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05106839f, 0.16115986f, -0.06866024f, 0.00017818f, -0.03590830f, -0.00151368f, -0.15275243f, -0.10106320f, 
    -0.18235594f, -0.05930607f, 0.00645127f, 0.02029633f, -0.14686309f, 0.05898301f, -0.08157589f, -0.08193459f, 
    -0.09292164f, 0.02016522f, -0.11035189f, -0.09451456f, -0.17610481f, 0.04035908f, -0.12318736f, -0.16547506f, 
    -0.17583032f, 0.00232023f, 0.09128668f, 0.12553489f, -0.17283179f, -0.06861399f, -0.00285016f, -0.07441958f, 
    0.17640507f, 0.11615320f, 0.00333783f, -0.05766574f, -0.13815524f, -0.13791481f, 0.26775795f, -0.15368506f, 
    -0.02170131f, -0.10356758f, 0.02637493f, 0.17489520f, 0.17086099f, 0.03934859f, 0.25746524f, -0.07815389f, 
    -0.00831412f, 0.18866721f, -0.15133621f, 0.10490234f, 0.07762089f, 0.00491292f, -0.00936448f, -0.17299046f, 
    -0.00085012f, -0.20348100f, -0.05946961f, 0.11283562f, -0.02121521f, 0.61531305f, 0.18998162f, -0.38763124f, 
    0.44141707f, -0.00260529f, 0.09082311f, 0.03288179f, -0.09479980f, -0.18075109f, 0.08203658f, -0.08696026f, 
    0.25767121f, 0.10970169f, 0.04056927f, 0.18182956f, 0.00904012f, -0.42147657f, -0.02276203f, 0.11237864f, 
    -0.04417955f, -0.27767602f, -0.11505824f, -0.04445289f, -0.15744342f, -0.59547776f, -0.06736800f, 0.03985695f, 
    0.11699674f, 0.03250610f, 0.15686375f, -0.09257785f, 0.32442197f, 0.09107871f, 0.20626077f, 0.02046854f, 
    0.24292763f, -0.06977142f, -0.04951656f, -0.12150832f, 0.42285720f, 0.02745918f, 0.52616143f, -0.03318030f, 
    0.09218349f, -0.04687737f, -0.11901025f, 0.15215707f, -0.05533374f, 0.40521970f, -0.23931116f, 0.51936388f, 
    0.07925470f, -0.74166656f, -0.04490136f, 0.14021574f, 0.06001050f, -0.04063932f, -0.05885977f, -0.09986760f, 
    0.06192127f, -0.10747764f, -0.07521656f, -0.00405758f, -0.11399198f, 0.10948245f, -0.02509420f, -0.25537178f, 
    0.14754362f, 0.13046885f, 0.19401896f, -0.00155105f, 0.13965712f, -0.07297520f, 0.05064845f, -0.44686869f, 
    -0.03824949f, 0.15585969f, -0.05809397f, 0.14410494f, 0.15588492f, 0.04780734f, -0.18335854f, -0.14167175f, 
    -0.08010605f, -0.38444537f, 0.16639759f, -0.01567119f, -0.03174131f, -0.23205259f, 0.08294502f, 0.14291660f, 
    0.17538783f, 0.21961446f, 0.09842274f, 0.00502128f, 0.03245287f, -0.23139404f, -0.04837948f, -0.26308161f, 
    -0.03235008f, -0.11555270f, 0.13571936f, 0.15614517f, 0.18431850f, -0.10052123f, -0.33807409f, 0.10590191f, 
    -0.14564329f, -0.06190372f, -0.11566725f, -0.01402648f, -0.11124058f, -0.27185982f, 0.33787718f, 0.30681041f, 
    0.07987159f, -0.41380349f, -0.16433528f, 0.18377094f, 0.00869459f, -0.23009987f, 0.06081390f, 0.18293464f, 
    0.02230082f, -0.31045592f, -0.13161279f, -0.01588085f, 0.19148648f, 0.23050854f, 0.19242489f, -0.12099971f, 
    0.10042316f, 0.11695585f, 0.14962736f, -0.11972047f, -0.41342998f, -0.14310299f, -0.70648307f, 0.39563560f, 
    0.14533010f, -0.03092611f, 0.11647502f, 0.08582693f, -0.08555661f, 0.08671007f, 0.27395037f, -0.18885723f, 
    -0.16153707f, 0.37614155f, 0.05940461f, -0.15219018f, 0.11115492f, 0.02033707f, -0.10242558f, -0.16123857f, 
    -0.11542352f, 0.03182482f, 0.06763956f, 0.17468362f, -0.27995962f, 0.06510468f, -0.07890686f, -0.09430974f, 
    -0.26000237f, -0.02906070f, 0.00433701f, 0.10047342f, -0.00963251f, 0.01266558f, -0.29921764f, -0.11982629f, 
    0.26174557f, -0.12768443f, 0.12119443f, 0.22432265f, 0.13563839f, 0.29653150f, 0.05139923f, 0.25396487f, 
    0.08928569f, 0.54516721f, -0.03015807f, 0.34728575f, 0.01001467f, 0.21871814f, -0.12094533f, -0.05079662f, 
    -0.09685693f, -0.12745483f, 0.14308988f, 0.07269488f, -0.16040778f, -0.03479972f, 0.02768920f, 0.07753463f, 
    0.05819152f, 0.00280262f, 0.21678357f, 0.10101490f, -0.14589997f, -0.03675461f, -0.22059569f, 0.08704725f, 
    0.29188988f, 0.15416607f, -0.14226970f, 0.30067804f, -0.08567325f, 0.39263502f, 0.20840093f, 0.19265397f, 
    0.06839506f, -0.27774400f, 0.03000728f, 0.05333434f, -0.05121325f, -0.03868906f, -0.02764253f, 0.16072074f, 
    -0.13996702f, -0.11052264f, -0.14118250f, -0.08985981f, -0.27726814f, -0.17651431f, 0.26517838f, -0.10334287f, 
    -0.17127088f, 0.01877391f, 0.22732654f, -0.14971475f, -0.09600825f, -0.09874965f, -0.13613951f, -0.19451219f, 
    0.07420806f, 0.14028846f, 0.03418826f, -0.09966241f, -0.02975995f, 0.10603814f, -0.20335914f, -0.19242045f, 
    0.04786495f, -0.06836746f, 0.08909349f, -0.10440680f, -0.15894458f, -0.10351377f, 0.07701230f, 0.10019248f, 
    0.06028049f, -0.04764897f, -0.05187255f, -0.12492699f, -0.15127018f, 0.08713359f, -0.08055676f, -0.30130944f, 
    0.31509513f, -0.07479471f, 0.16579932f, -0.07904758f, 0.07608136f, 0.05635739f, 0.41669920f, 0.27242348f, 
    -0.14727715f, 0.03943727f, -0.07650831f, -0.03591093f, -0.13924469f, -0.23387434f, -0.07006667f, -0.33449638f, 
    0.17526253f, 0.11161969f, 0.05761928f, -0.18409787f, 0.13874304f, 0.50502503f, -0.09888231f, -0.14706200f, 
    0.06485713f, 0.21611342f, 0.14120646f, 0.13043866f, 0.20896554f, 0.11070225f, -0.31793088f, -0.00953482f, 
    0.16909817f, 0.11319307f, -0.15195474f, -0.13749808f, 0.23905937f, -0.08711622f, -0.23212039f, 0.07485230f, 
    0.00722341f, -0.14175262f, -0.08083155f, 0.09326891f, -0.06610649f, 0.06049933f, 0.16958055f, 0.35660493f, 
    0.06241662f, -0.46296903f, -0.09124972f, 0.21900894f, 0.18601613f, -0.20253763f, -0.11877116f, -0.07063454f, 
    0.16478653f, -0.14584938f, 0.11368679f, 0.01610524f, 0.24922892f, -0.20000775f, -0.03148219f, 0.43440789f, 
    0.09514147f, -0.10242727f, -0.30132106f, -0.12298029f, 0.35113451f, 0.00535762f, 0.08992173f, -0.06180490f, 
    -0.43616056f, -0.06486081f, -0.09152430f, -0.06660219f, -0.06189178f, -0.35775760f, -0.22299835f, -0.06576938f, 
    -0.00197597f, 0.40138602f, -0.08674414f, 0.11926304f, 0.11413933f, 0.26368889f, 0.03284296f, -0.06597977f, 
    0.16064340f, 0.08907903f, -0.08050225f, -0.10183867f, 0.03959600f, 0.11845779f, -0.23038398f, 0.23167980f, 
    0.08054872f, -0.04785588f, -0.01810333f, 0.16272712f, -0.08781234f, -0.16416647f, -0.01935873f, -0.16918556f, 
    -0.27923062f, -0.05200309f, -0.08036367f, -0.09032977f, 0.04533420f, -0.09541926f, -0.01423866f, -0.10330291f, 
    0.10310457f, -0.07745594f, -0.03892281f, 0.02334347f, -0.06059189f, 0.02541846f, -0.18033464f, -0.15610291f, 
    -0.15737534f, 0.00457388f, -0.00721789f, -0.04254686f, -0.05991487f, -0.16231593f, 0.07512391f, -0.23252119f, 
    -0.03338078f, 0.01207408f, -0.10303539f, -0.04258673f, -0.09528653f, -0.11383365f, 0.11481503f, -0.20436130f, 
    -0.00674395f, -0.07772819f, -0.14186129f, -0.17969587f, 0.05557492f, 0.10082644f, -0.18126528f, 0.02920730f, 
    -0.16567618f, -0.11620726f, 0.04913375f, -0.18380409f, 0.13007720f, 0.06081649f, 0.15875006f, 0.06448596f, 
    0.02883552f, 0.00389318f, 0.04525910f, 0.05999790f, -0.18246178f, -0.01364106f, 0.10321280f, -0.11650508f, 
    -0.23374389f, 0.05192083f, 0.13452876f, -0.02499234f, 0.00532369f, -0.11014969f, 0.00754968f, -0.01011940f, 
    -0.07417570f, -0.03917417f, -0.07178497f, 0.16614178f, -0.01803472f, -0.29692417f, -0.36010966f, 0.20377466f, 
    0.09463135f, 0.32759342f, -0.14661327f, 0.08691690f, 0.16122603f, 0.07839496f, 0.03297843f, -0.01137267f, 
    0.14967532f, 0.05423255f, 0.05095343f, -0.07164720f, 0.24139142f, 0.13159554f, -0.34810987f, 0.35575640f, 
    0.02048033f, -0.08943359f, -0.10586386f, 0.13489521f, -0.08448394f, 0.08621863f, -0.10651736f, 0.09769262f, 
    -0.12581839f, 0.09220133f, -0.02688368f, -0.05251691f, -0.07374402f, -0.11259399f, -0.01340778f, 0.00202423f, 
    0.05965170f, -0.05199040f, 0.00027364f, -0.12623163f, -0.12465969f, 0.12560757f, 0.16039565f, 0.12603796f, 
    -0.09236433f, -0.16966850f, 0.03047428f, 0.15461990f, -0.01735069f, -0.17482634f, -0.07544521f, -0.08749714f, 
    -0.11183456f, 0.03409584f, -0.16246296f, 0.08053457f, -0.10970654f, -0.09729142f, 0.39631662f, -0.09057181f, 
    0.00977223f, -0.08391324f, 0.08045448f, -0.02814835f, -0.16282998f, 0.33790898f, 0.04855274f, -0.14096928f, 
    -0.15181248f, 0.40993547f, 0.01404445f, 0.01040852f, -0.07239243f, 0.37423891f, -0.09155286f, 0.15929972f, 
    0.06282365f, 0.37093467f, -0.16017121f, -0.12043312f, -0.21728596f, 0.15743792f, 0.46726546f, 0.26779053f, 
    -0.02810883f, -0.00247807f, -0.13015741f, 0.06587967f, 0.15969034f, 0.09824206f, 0.08761345f, -0.21520838f, 
    -0.10019485f, 0.15954682f, -0.06230707f, 0.23778844f, -0.04075130f, -0.52083033f, -0.22572863f, 0.14447320f, 
    0.04607559f, 0.29221368f, 0.04059197f, 0.07712079f, 0.03739293f, 0.09553120f, 0.05003136f, 0.11105551f, 
    -0.06606868f, -0.07109898f, 0.03890954f, -0.08705741f, 0.06669149f, -0.04554079f, -0.03372594f, 0.27562395f, 
    -0.19817501f, -0.13112085f, -0.03213070f, 0.02451541f, 0.08012159f, -0.12159790f, 0.14734031f, -0.21888594f, 
    0.06269164f, -0.05024455f, -0.08353733f, -0.09357671f, 0.00413655f, -0.17797658f, 0.08643440f, 0.07158653f, 
    0.04006606f, -0.00061971f, 0.10418964f, -0.12705342f, 0.21985649f, -0.26843870f, 0.17206299f, -0.04951243f, 
    -0.13965358f, 0.17621875f, 0.11462727f, 0.06324977f, 0.00279013f, 0.12229732f, 0.21156763f, 0.22236809f, 
    -0.29050535f, 0.12798074f, -0.41273430f, 0.08714737f, 0.39251342f, -0.08506155f, 0.28851908f, 0.23405506f, 
    0.01554233f, -0.15260243f, 0.03450132f, 0.37437373f, 0.03406596f, -0.18111283f, 0.23136988f, 0.17645162f, 
    -0.14833711f, -0.18805900f, -0.08295731f, -0.08224679f, 0.14569715f, 0.08767686f, -0.06258573f, 0.01421796f, 
    -0.01818788f, 0.05991296f, 0.14589907f, -0.01559492f, -0.17372037f, -0.27777329f, 0.19563760f, 0.24301013f, 
    0.24264392f, 0.07187036f, 0.17414793f, 0.01469770f, 0.12395126f, -0.03450238f, 0.14027485f, 0.13429949f, 
    -0.00665795f, 0.01495574f, 0.10466795f, -0.21820775f, 0.18419102f, -0.01390965f, -0.30156511f, 0.37378868f, 
    -0.15449372f, -0.03095588f, -0.03587493f, 0.11912121f, -0.11400699f, -0.26205349f, 0.00982461f, 0.09447534f, 
    0.09961534f, -0.47175843f, 0.04437169f, -0.13433261f, 0.22530068f, -0.08992124f, 0.07664433f, -0.00680783f, 
    -0.02529132f, 0.04498069f, -0.15288781f, -0.11324067f, -0.13381636f, -0.04856680f, -0.10479592f, -0.05151289f, 
    -0.20083784f, -0.17090045f, 0.05640581f, -0.11826850f, 0.06766671f, -0.09691744f, -0.04833054f, -0.13577391f, 
    0.03395350f, -0.15133637f, 0.09726788f, 0.07837588f, -0.09788517f, -0.12097528f, 0.05049108f, -0.05790791f, 
    0.09450422f, -0.09910771f, 0.13034332f, 0.16280612f, -0.03000439f, 0.03565998f, -0.00451464f, 0.08206869f, 
    -0.26636821f, 0.11855485f, -0.03568533f, -0.11591398f, 0.13146962f, 0.06512784f, 0.03166076f, 0.20944460f, 
    0.05150577f, -0.03479888f, 0.16430601f, 0.17588694f, 0.11921058f, 0.15198609f, 0.29105070f, 0.10131793f, 
    -0.07431149f, 0.05286904f, 0.05076182f, 0.01669478f, -0.14382474f, 0.18392558f, 0.11051745f, -0.06134537f, 
    0.02284008f, 0.11016752f, -0.03474860f, 0.14847814f, 0.09737557f, 0.26667199f, 0.38874245f, -0.51694632f, 
    0.41657862f, -0.13577805f, 0.29393598f, -0.11857751f, -0.24385688f, 0.10919854f, -0.25744209f, 0.24385856f, 
    -0.38540053f, 0.12795077f, 0.17100723f, -0.24411477f, -0.06986994f, -0.15636046f, -0.17146483f, 0.14985089f, 
    -0.02511942f, 0.04413567f, -0.00126365f, 0.23560078f, 0.03578499f, 0.15163223f, -0.10059430f, -0.09483956f, 
    0.10605247f, -0.39543435f, -0.00398310f, -0.11984197f, 0.05049764f, 0.04722834f, -0.12893145f, 0.11815977f, 
    0.39329183f, -0.02746914f, 0.14937289f, -0.07834359f, -0.40166217f, 0.15064788f, 0.11592074f, -0.15804374f, 
    -0.17375074f, 0.11792614f, 0.07822160f, -0.13394797f, 0.03748517f, 0.39564472f, -0.00741872f, 0.27352288f, 
    -0.02098850f, 0.34597963f, 0.16203819f, 0.04220277f, 0.06893244f, -0.25269639f, -0.12775388f, 0.06753767f, 
    0.08918004f, 0.01709181f, 0.15205653f, 0.07320446f, -0.19768719f, 0.36621031f, 0.32704458f, -0.10482379f, 
    -0.00229529f, 0.11098563f, 0.08820195f, -0.02214042f, -0.26463655f, -0.11409833f, -0.17669407f, 0.37094072f, 
    -0.34896910f, -0.05882410f, -0.17565733f, 0.24639326f, 0.01245252f, 0.11027994f, 0.07277335f, -0.33507967f, 
    0.11888629f, 0.49363637f, 0.03141931f, 0.27771550f, -0.02765276f, 0.39192533f, -0.03170636f, 0.07145852f, 
    0.13963825f, 0.00817519f, -0.15642047f, 0.14386094f, 0.11559017f, -0.30584481f, -0.05883070f, 0.20487967f, 
    0.44477344f, -0.13726965f, 0.19047639f, -0.09214848f, -0.40128735f, 0.01181572f, -0.26275671f, 0.23616672f, 
    -0.19960827f, 0.02594408f, -0.07402539f, -0.14430632f, 0.03422283f, 0.15323015f, -0.12997173f, 0.22785096f, 
    0.15416770f, 0.01060417f, 0.08390822f, 0.30754498f, 0.07880516f, -0.00069997f, 0.09158652f, 0.02606617f, 
    -0.08174727f, -0.55174029f, 0.03207054f, -0.02203163f, 0.26115304f, -0.53744727f, -0.32193875f, 0.28143173f, 
    0.12849392f, -0.13525867f, -0.05291134f, 0.05550110f, -0.17794915f, 0.08515529f, -0.27378410f, -0.25414777f, 
    0.32203251f, 0.00668449f, 0.14090049f, -0.16097653f, -0.08129392f, -0.36156374f, -0.07559137f, 0.25665039f, 
    0.01399461f, 0.47137633f, -0.16901188f, 0.34625855f, 0.03468079f, -0.50430608f, -0.12775443f, 0.05441266f, 
    0.16739048f, -0.20952514f, -0.07473609f, 0.10713218f, 0.21562353f, 0.42874569f, -0.10542330f, 0.06832831f, 
    -0.15173711f, 0.16996667f, 0.15530212f, 0.15994531f, -0.17681096f, 0.06553641f, 0.25320441f, -0.22766925f, 
    -0.09829742f, 0.08205159f, -0.06756563f, -0.04623020f, -0.13926631f, 0.04089196f, -0.10036492f, 0.12692021f, 
    -0.13284636f, -0.19736406f, 0.04697905f, -0.20615664f, 0.00147355f, 0.06361397f, 0.04634507f, -0.05662102f, 
    -0.06975548f, 0.15044488f, -0.16633560f, -0.02522632f, -0.04198612f, 0.04537951f, -0.00110589f, -0.06011799f, 
    -0.27002707f, 0.09612208f, -0.13676670f, 0.08807360f, 0.19074647f, 0.04976796f, -0.60647720f, -0.16971382f, 
    0.02824081f, 0.11733977f, -0.11553092f, -0.08350034f, 0.14809817f, 0.30010623f, 0.21474604f, 0.25765446f, 
    0.14001170f, -0.36871019f, -0.16518116f, 0.01323334f, 0.06021711f, 0.08827167f, 0.14348954f, -0.10736503f, 
    -0.08381917f, -0.09182660f, -0.10461536f, -0.00665879f, -0.36996993f, -0.19202389f, 0.28910258f, 0.18386759f, 
    0.07397776f, 0.01783374f, 0.19501466f, -0.07596745f, 0.42134264f, 0.08719182f, -0.16861601f, 0.09943780f, 
    0.25931585f, -0.01918672f, 0.12173371f, 0.31059331f, 0.01037233f, -0.41181988f, 0.07195786f, 0.16711240f, 
    -0.09382851f, -0.50256240f, -0.02991883f, 0.03479447f, -0.13299273f, -0.16383281f, 0.09027886f, 0.08972052f, 
    -0.07263177f, 0.06234615f, -0.18080643f, -0.03592629f, 0.37159956f, 0.01128105f, -0.11561086f, 0.17358238f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21671776f, -0.12268817f, -0.05634568f, 0.33944139f, 0.18225089f, 0.08463924f, 0.10631713f, -0.10191660f, 
    0.18547398f, -0.10347231f, -0.14394148f, 0.36538878f, -0.04492248f, -0.03740682f, -0.02505057f, -0.03540546f, 
    -0.14433442f, 0.07690363f, 0.05854445f, 0.10059082f, 0.21109800f, 0.15743078f, 0.08293106f, -0.13210486f, 
    -0.17260818f, 0.00220235f, 0.18734394f, -0.06984697f, -0.02319598f, -0.11023768f, -0.00399705f, 0.10612091f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.00127726f, 0.09309044f, -0.16054180f, -0.50205088f, 0.07364677f, -0.50585324f, 0.18005764f, 0.10193782f, 
    -0.03268175f, 0.11876009f, -0.00748590f, -0.65780264f, 0.21726848f, 0.01098470f, -0.03436648f, -0.04695308f, 
    -0.04310096f, 0.21314077f, 0.13149844f, -0.08580647f, -0.08977722f, -0.38604009f, 0.08412196f, 0.22443648f, 
    -0.64828622f, 0.21573733f, 0.22205275f, -0.60341078f, -0.38064015f, -0.03132036f, -0.09508826f, -0.43055007f, 
    -0.00469058f, -0.10478066f, -0.15094784f, 0.05508095f, 0.23223476f, -0.00734169f, 0.02544914f, 0.26508200f, 
    0.09641828f, -0.09604991f, -0.43810365f, 0.18619195f, -0.14684509f, -0.07711311f, -0.06322584f, 0.23149218f, 
    0.04450909f, 0.09842937f, 0.22114225f, 0.01722544f, 0.27028933f, -0.16743176f, 0.03089686f, 0.03836047f, 
    -0.69869816f, -0.13074291f, -0.31917626f, -0.54496455f, 0.18830425f, -0.11318501f, 0.76727688f, -0.02628602f, 
    -0.00663247f, -0.56590313f, -0.00622927f, 0.06662965f, 0.19989425f, 0.04383482f, -0.60265326f, -0.13506719f, 
    0.14146534f, 0.00241874f, -0.21586879f, 0.27148280f, -0.54365867f, -0.15026639f, -0.10231030f, -0.11863893f, 
    -0.03469488f, 0.08164970f, -0.46655950f, -0.01981648f, 0.02499068f, 0.21346989f, -0.01276352f, -0.23109777f, 
    -0.01728041f, 0.02247187f, 0.25147745f, 0.38097832f, -0.54928327f, 0.19735622f, -0.23367588f, -0.04190888f, 
    0.07905567f, 0.29214191f, -0.30909643f, -0.10893845f, -0.49720058f, 0.15389262f, 0.24956848f, -0.01151374f, 
    0.07633053f, -0.49595621f, 0.00341212f, -0.21283321f, -0.33482715f, 0.04444844f, 0.01282978f, -0.39850539f, 
    -0.10308468f, -0.19259898f, -0.21375959f, -0.41003567f, -0.44081703f, 0.12867397f, -0.01681600f, 0.01526568f, 
    0.30232772f, 0.49301115f, -0.11099745f, 0.26308030f, -0.09452159f, -0.07070977f, 0.06564293f, -0.33846635f, 
    -0.03862527f, -0.35137501f, 0.17667653f, -0.25553337f, -0.15890495f, -0.41652423f, 0.20828946f, 0.03154646f, 
    0.16597475f, -0.14361838f, 0.16829848f, -0.15400590f, -0.46251747f, -0.10077185f, 0.02343038f, -0.03860468f, 
    -0.15034236f, 0.07108602f, -0.15006262f, 0.09261736f, -0.10527319f, -0.62632990f, 0.04026570f, -0.13408510f, 
    0.02226201f, -0.22491820f, 0.31683668f, 0.30344930f, 0.10972407f, -0.09069880f, -0.57145393f, -0.03115712f, 
    0.06037900f, 0.14363377f, 0.17381315f, -0.28676096f, -0.08412828f, 0.31708327f, 0.16731210f, -0.21484020f, 
    0.01046204f, 0.16380402f, 0.14597699f, 0.12722160f, 0.19910756f, -0.04497758f, -0.11065694f, -0.26238295f, 
    0.16738704f, -0.14821786f, 0.05755506f, -0.06888811f, 0.25642160f, -0.23241344f, -0.01160379f, 0.16216874f, 
    -0.34554461f, -0.41318890f, 0.05510956f, -0.50332463f, -0.10434677f, 0.11926179f, -0.68672472f, 0.18959767f, 
    -0.02426463f, -0.78339487f, 0.15665010f, 0.30539298f, -0.03990268f, -0.15631458f, -0.59799743f, -0.69963694f, 
    -0.34174961f, -0.04990481f, 0.23507477f, 0.09641644f, -0.08125363f, -0.23226213f, 0.01885981f, 0.04699818f, 
    0.01079927f, -0.41574267f, -0.02625719f, 0.10108770f, 0.11230998f, 0.27155444f, 0.16080897f, -0.48324892f, 
    0.08144715f, -0.45790496f, -0.30742025f, 0.16503502f, -0.30530074f, -0.12668726f, 0.13871557f, 0.14580749f, 
    -0.20423211f, 0.04399871f, 0.12954977f, -0.34648979f, -0.19668315f, -0.29061666f, -0.20109259f, -0.02345389f, 
    -0.51007134f, -0.19062248f, -0.09738270f, -0.03246666f, -0.01108073f, -0.04151867f, 0.13401507f, 0.21552980f, 
    -0.12328434f, 0.01409017f, -0.03950707f, 0.15766439f, -0.33435002f, -0.07888781f, 0.01744055f, -0.56775397f, 
    0.10411302f, 0.36760524f, 0.03096550f, 0.22338451f, 0.34136504f, 0.13775860f, -0.07679737f, -0.16730291f, 
    -0.04449498f, 0.09029232f, 0.27175629f, 0.19773141f, -0.03696084f, 0.26751253f, -0.41702947f, -0.34375480f, 
    0.01751673f, -0.35694045f, -0.40838000f, 0.01519051f, 0.15434887f, -0.10451801f, -0.20291567f, -0.39246929f, 
    -0.12533858f, -0.13283537f, -0.31062317f, -0.01375183f, -0.43734014f, -0.12837386f, 0.02109017f, -0.00666441f, 
    -0.03029142f, 0.48666963f, -0.84287769f, -0.18834826f, 0.33710101f, -0.32613611f, 0.05953811f, -0.03934963f, 
    0.10778322f, -0.77659017f, -0.59539974f, -0.19876134f, 0.04596482f, -0.01307933f, -0.19339763f, -0.21155609f, 
    -0.49769029f, -0.58955801f, 0.27902427f, 0.07445285f, 0.32630500f, -0.18784474f, -0.00154677f, 0.13921593f, 
    -0.12205770f, 0.11587520f, 0.09856261f, 0.08819744f, 0.02340738f, -0.07814608f, 0.11856024f, 0.03688244f, 
    0.23890293f, -0.61221564f, 0.28918013f, 0.05383872f, -0.14340134f, -0.08853056f, 0.04193967f, -0.16912626f, 
    0.13220640f, 0.25144562f, -0.16972420f, 0.50765282f, -0.59465510f, -0.17741087f, -0.63172352f, 0.06826027f, 
    0.09120516f, -0.28301337f, 0.09598864f, -0.04324985f, -0.35110152f, -0.21147966f, -0.20349289f, -0.59953201f, 
    -0.06420333f, 0.22621287f, -0.47267434f, -0.77859104f, 0.02803223f, -0.03513694f, 0.05460081f, 0.16701239f, 
    -0.37192360f, 0.07047316f, -0.33101517f, -0.58233935f, -0.39538816f, -0.70400727f, -0.31588081f, -0.15788369f, 
    -0.00302254f, -0.32736883f, 0.12614962f, -0.05333994f, -0.16343021f, 0.31385851f, 0.02783794f, 0.30669877f, 
    0.01411794f, 0.02823432f, -0.26539356f, 0.17541222f, -0.46050686f, -0.02389624f, 0.08855125f, 0.07427917f, 
    0.05524076f, -0.89449298f, -0.22359507f, -0.43341821f, -0.35152259f, 0.18572550f, 0.02476444f, -0.07155915f, 
    -0.08044921f, -0.41816938f, -0.08400258f, 0.28383625f, 0.23885055f, -0.15867421f, -0.27226311f, 0.25483134f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.16502573f, 0.01893404f, 0.10932020f, -0.23516820f, -0.06563248f, -0.02700419f, 0.10322663f, -0.07922372f, 
    -0.12060382f, -0.06791721f, -0.06371846f, -0.07788638f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
