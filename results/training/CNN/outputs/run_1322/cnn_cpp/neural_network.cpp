#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.21267290f, -0.45159751f, -0.35175806f, 0.00407193f, -0.30904883f, -0.00306770f, -0.70574266f, -0.70143002f, 
    -0.81520694f, -0.61824232f, 0.13615678f, 0.24454315f, -0.18076059f, 0.36197674f, -0.40603492f, 0.18818758f, 
    0.19245104f, -0.05261288f, -0.03029088f, -0.31862164f, -0.48130983f, 0.45913908f, -0.14684251f, 0.02827851f, 
    0.07091260f, -0.38148603f, -0.47568133f, -1.01945889f, -0.51766795f, -0.18858185f, 0.47914270f, 0.31117836f, 
    -0.07962724f, -0.15665390f, 0.67495537f, -0.39362398f, 0.34331414f, -0.37282464f, -0.17672150f, -0.38436136f, 
    0.21950708f, -0.07898638f, 0.21992029f, 0.15039669f, 0.30759016f, 0.12937590f, -0.44403994f, -0.45674282f, 
    -0.59802318f, -0.12449358f, 0.90072888f, 0.64195758f, 0.03875023f, 0.12200647f, -0.91270226f, 0.15906610f, 
    -0.09697764f, -0.18702561f, 0.08131989f, 0.08366130f, -0.03862733f, -0.51333970f, -0.16245072f, 0.08209427f, 
    -0.03361726f, 0.29653862f, -0.05879574f, -0.29417416f, 0.06169460f, -0.34943315f, -0.34742156f, -0.15984991f, 
    -0.45056516f, -0.35977241f, -0.35898453f, -0.04866354f, -0.60583937f, -0.89488351f, 0.43633929f, 0.13782194f, 
    -0.23623922f, 0.34829026f, -0.39574108f, -0.86485386f, -0.87969410f, -0.39559990f, -0.29835454f, 0.31488752f, 
    -0.22776346f, -0.35246381f, -0.13846985f, -0.36286250f, 0.14809689f, 0.11454497f, -0.01114890f, 0.10445888f, 
    -0.12579489f, -0.21035832f, -0.15990554f, -0.35163817f, -0.60290021f, -0.46191388f, -0.09675990f, -0.51190615f, 
    -0.94420940f, 1.39269769f, -0.21517807f, -0.62810677f, 0.24731277f, 0.32539436f, 0.12035442f, -0.30165851f, 
    0.03406962f, -0.15510060f, -0.13798510f, 0.12920792f, 0.05308804f, -0.07408126f, -0.14787966f, -0.12792338f, 
    -0.31230500f, -0.13270415f, 0.03849341f, 0.12138788f, 0.07716320f, 0.58123380f, 0.18759897f, 0.12581766f, 
    -0.11322099f, 0.28368822f, -0.18423209f, 0.29614064f, 0.22490273f, 0.50380892f, 0.00789334f, -0.09906584f, 
    0.11016460f, 0.20121591f, 0.23178877f, 0.14692639f, -0.18904774f, -0.08701696f, 0.06852643f, -0.25121313f, 
    -0.38808724f, -0.13405627f, 0.43350786f, 0.20226105f, -0.24885897f, 0.13224263f, 0.73567951f, 0.41187453f, 
    0.28258371f, -0.27684206f, -0.31824020f, -0.33329046f, 0.25470576f, 0.45550153f, -0.12460274f, -0.34736514f, 
    -0.41081065f, -0.01452773f, 0.79316324f, -0.21742885f, -0.64180487f, 0.20143910f, -0.15901962f, -0.01016073f, 
    -0.18761322f, -0.11608750f, -0.10055700f, 0.00777982f, -0.24863288f, -0.06478950f, 0.44668719f, -0.22260870f, 
    0.15821451f, 0.06757004f, 0.20613827f, -0.26626545f, -0.51203412f, 0.07618737f, 0.37715331f, -0.19363463f, 
    -0.13137177f, -0.12281742f, 0.14078267f, -0.18647252f, 0.22147895f, 0.00803958f, -0.28022739f, -0.47252658f, 
    0.34514469f, -0.00093191f, -0.35664022f, 0.03179448f, 0.33145896f, 0.25029114f, 0.35139132f, 0.50433058f, 
    -0.28982064f, -0.52566165f, -0.48482916f, -0.44633153f, -0.44166502f, -0.04996497f, -0.47180966f, -0.38935480f, 
    -0.27969772f, 0.43444884f, 0.23644491f, 0.38028663f, 0.49390462f, 0.47940856f, 0.54978162f, -0.17612752f, 
    -0.30282804f, 0.10023810f, -0.00403147f, -0.53786677f, 0.04061976f, -0.12195497f, 0.21528669f, -0.02464224f, 
    -0.13224778f, -0.64598125f, -0.06842550f, 0.22294131f, -0.05563731f, 0.64235872f, 0.57256591f, 0.44061235f, 
    0.43090174f, -0.25171188f, -0.18863350f, 0.39987528f, -0.34962577f, 0.03354565f, -0.03148390f, -0.25723132f, 
    0.15543525f, -0.04477663f, -0.33147523f, 0.02007296f, 0.11945155f, 0.25635761f, -0.34267175f, -0.26016358f, 
    0.27976194f, -0.09975036f, -0.23428190f, 0.31119427f, -0.63239604f, 0.27787611f, -0.46029624f, -0.54588205f, 
    -0.12988982f, -0.25851914f, 0.23243845f, -0.48309687f, -0.13910629f, -0.06524199f, -0.04226385f, -0.82144070f, 
    -0.15070269f, -0.02411901f, 0.00314035f, -0.10977651f, -0.39394468f, -0.01033248f, -0.65686184f, -0.23973548f, 
    -0.12769392f, -0.01985401f, -0.27710164f, -0.96675956f, -1.07785630f, -0.77866066f, -0.12976965f, 0.11762322f, 
    0.68608403f, 0.35013381f, 0.21944436f, -0.20125476f, 0.65972453f, 0.37499315f, 0.13404752f, 0.05372287f, 
    -0.00089632f, 0.28930801f, 0.08439952f, 0.14507122f, -0.12579352f, 0.22229461f, -0.19794898f, -0.09531455f, 
    0.01322498f, 0.04608412f, -0.07609641f, -0.05241502f, 0.76749182f, 0.17769510f, -0.26206595f, -0.00695412f, 
    0.29124233f, 0.18293215f, -0.19550325f, 0.11654212f, -0.45914307f, -0.44934657f, -0.20158090f, 0.56917804f, 
    -0.30709490f, 0.06320643f, 0.32245994f, 0.01621574f, 0.14460641f, 0.25945982f, -0.33195007f, 0.26460615f, 
    -0.12732118f, -0.30829695f, -0.22339758f, 0.67049217f, 0.02723417f, 0.14588030f, 0.10839967f, -0.94503522f, 
    -0.77882326f, -0.69551688f, 0.38151515f, 0.43993965f, 0.44787338f, -0.13064030f, -0.48611754f, -0.07335023f, 
    -0.05751595f, 0.07472893f, -0.12207212f, -0.31537831f, -0.06754174f, -0.50589538f, -0.27818200f, 0.09102054f, 
    -0.52339953f, 0.28260109f, 0.22487673f, 0.34981272f, 0.11859202f, 0.25646219f, -0.19356573f, -1.19781423f, 
    -0.50044912f, 0.67287344f, 0.91813582f, -0.52545619f, -0.57689381f, -0.48544466f, 0.25423893f, -0.40930966f, 
    0.11669314f, 0.02705310f, 0.10303346f, -0.20477185f, -0.25597322f, 0.09582742f, 0.04710980f, 0.15578684f, 
    -0.35260826f, -0.20478033f, 0.11378988f, 0.26955205f, 0.09509180f, -0.08947390f, 0.49902186f, -1.16478074f, 
    0.21725832f, -0.02634352f, -0.40059373f, -0.36118090f, 0.02789980f, 0.10092197f, 0.35237634f, 0.65319353f, 
    0.50929719f, 0.22921887f, -0.05480576f, 0.43116271f, -0.52291667f, -0.08519024f, -0.30077580f, -0.04107212f, 
    0.15324517f, -0.22344224f, 0.02629862f, -0.05749472f, 0.46819967f, -0.29399526f, -0.17338021f, 0.54543012f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05953031f, 0.31628260f, 0.39165327f, -0.12705366f, 0.37724802f, 0.29926667f, 0.57069439f, 0.07418218f, 
    0.17576483f, 0.57590175f, 0.52562010f, 0.01324986f, 0.21332501f, -0.08197484f, 0.32887387f, 0.34809530f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.34343868f, 0.22385757f, 0.26454550f, -0.25402078f, 0.01343824f, 0.01518213f, 0.21091761f, 0.09156061f, 
    0.08374005f, -0.00727865f, 0.03953077f, 0.14738666f, 0.09304697f, 0.06056848f, 0.06747331f, -0.10259709f, 
    -0.04529487f, 0.04274695f, 0.01904577f, -0.07808106f, -0.01410951f, -0.13031955f, -0.02849512f, 0.17177311f, 
    -0.04790420f, -0.00528019f, -0.11075389f, -0.14174591f, 0.13647193f, 0.04689389f, 0.02296190f, 0.05612359f, 
    -0.10012888f, -0.00628264f, 0.09000980f, 0.16728558f, 0.09115071f, 0.13473766f, 0.16086465f, -0.20693013f, 
    0.11575559f, -0.05960243f, 0.06585895f, 0.04982742f, 0.06357839f, 0.07950721f, 0.08423731f, 0.07214031f, 
    0.19693679f, 0.20096998f, -0.27229446f, -0.35710216f, -0.02137467f, 0.02351267f, 0.15021752f, -0.02190091f, 
    0.02532103f, -0.10025082f, 0.05007352f, -0.03002860f, -0.20667571f, -0.30095190f, -0.16834588f, 0.11875352f, 
    0.07024183f, 0.03084585f, -0.08794048f, -0.08376290f, 0.08066041f, 0.13231106f, 0.08100201f, -0.08605709f, 
    0.00346096f, -0.11689214f, -0.37946630f, 0.01192530f, 0.04025808f, 0.01745600f, 0.03038026f, -0.10515207f, 
    -0.01944059f, -0.03283240f, -0.11278930f, 0.14128186f, -0.21705657f, -0.08793057f, 0.15605330f, 0.05624763f, 
    0.12315241f, 0.06046414f, 0.00005278f, 0.10941355f, -0.01807699f, -0.05529690f, -0.07225805f, 0.05796866f, 
    0.32232597f, 0.18248650f, 0.23031054f, -0.08889155f, 0.06672810f, 0.22066687f, 0.13783297f, -0.03203885f, 
    0.09808812f, -0.05161690f, 0.02777410f, -0.01278755f, -0.20071356f, -0.05440412f, -0.02148213f, 0.03266685f, 
    -0.00786030f, -0.10341278f, -0.07960182f, 0.02631545f, -0.05378683f, 0.01847030f, 0.02428864f, 0.07866208f, 
    0.20532981f, 0.27655742f, 0.14317995f, -0.04009311f, -0.12475584f, 0.01046027f, 0.06481059f, 0.10136244f, 
    0.03828898f, -0.10096312f, 0.04506471f, -0.01106684f, 0.19258080f, 0.11306877f, -0.06247274f, 0.02264981f, 
    0.07124929f, 0.13454311f, 0.03821833f, 0.01109616f, 0.11881950f, -0.11088884f, -0.05552619f, 0.13568042f, 
    0.07978625f, 0.01096396f, -0.36717626f, -0.13485222f, -0.05341060f, 0.19031699f, -0.15293275f, -0.09703555f, 
    -0.04743049f, -0.19546296f, 0.05508760f, 0.03188426f, -0.03299065f, 0.13206097f, -0.06799740f, -0.19336639f, 
    0.06374106f, 0.12841713f, -0.05373649f, -0.16643304f, -0.03603009f, -0.02649947f, -0.01708648f, -0.10795730f, 
    0.29448679f, -0.11927276f, 0.43826270f, -0.17358574f, 0.17942178f, -0.07191021f, 0.19974609f, -0.05254701f, 
    0.17227279f, 0.03015321f, 0.04763152f, 0.09318895f, -0.53626436f, -0.08022253f, -0.08698012f, 0.03044443f, 
    -0.14800993f, -0.09117479f, -0.06711460f, 0.04007731f, 0.07928238f, -0.10960235f, -0.17021199f, 0.08505141f, 
    0.06794959f, -0.05066979f, 0.04556232f, 0.02770979f, -0.01241072f, -0.01893625f, 0.06102223f, 0.07220937f, 
    0.04217042f, -0.06916257f, -0.03875409f, 0.03342362f, -0.01129253f, 0.04709771f, 0.06125107f, 0.05560350f, 
    0.05478024f, 0.02309148f, -0.07918497f, 0.05718530f, -0.05453236f, -0.06739973f, -0.03878360f, -0.02679720f, 
    -0.02657114f, 0.01741514f, -0.06543480f, -0.05716161f, 0.03343058f, 0.04675469f, -0.06423873f, -0.01867628f, 
    0.05124891f, 0.06051238f, -0.00716459f, 0.05595551f, -0.02132085f, -0.00625712f, -0.04663569f, -0.06327354f, 
    0.04293099f, -0.05848834f, 0.05534502f, -0.07212260f, -0.03753761f, -0.01707185f, -0.07792495f, 0.03776800f, 
    -0.06584328f, -0.06110417f, 0.02455084f, 0.01207339f, -0.00588343f, 0.05143023f, -0.01081718f, 0.01041045f, 
    -0.07768451f, 0.03530568f, -0.01710893f, 0.04350653f, -0.03343906f, -0.04691217f, -0.00181491f, -0.06966692f, 
    -0.06694068f, 0.05121941f, -0.00244735f, -0.00186126f, 0.06539357f, -0.01570242f, -0.04523470f, -0.06997960f, 
    -0.06209214f, 0.02683802f, 0.03399576f, 0.04451611f, -0.02303142f, -0.05208588f, -0.03090788f, -0.05754849f, 
    -0.04716953f, -0.07777624f, -0.03160166f, -0.04060237f, -0.04386354f, 0.00702895f, -0.07543538f, 0.00089256f, 
    0.04839204f, -0.02525484f, -0.05287937f, 0.04716716f, -0.03469194f, 0.05381411f, -0.00087547f, -0.04826624f, 
    -0.01938295f, -0.06859965f, 0.05806473f, -0.06510213f, -0.02548351f, 0.00882357f, -0.06759910f, 0.05887352f, 
    -0.07499137f, 0.02988601f, 0.05017905f, 0.02772322f, 0.04815275f, -0.04425322f, 0.02405889f, 0.03903668f, 
    0.05988382f, -0.06894549f, -0.01001236f, 0.01265341f, 0.00858946f, 0.03580465f, 0.04150501f, -0.04719596f, 
    -0.00089896f, 0.02496171f, -0.02475693f, -0.07952914f, -0.01320060f, 0.01889554f, -0.07346170f, -0.05912189f, 
    -0.03617225f, 0.00440741f, 0.02365691f, 0.05676590f, -0.03685996f, 0.05891474f, 0.02566338f, -0.04297723f, 
    -0.02694669f, 0.03380471f, 0.03166559f, -0.05756749f, 0.00061476f, 0.05151000f, 0.01759389f, -0.06152686f, 
    -0.06642620f, -0.00532272f, -0.07686718f, -0.06508188f, 0.00218544f, -0.07420182f, -0.06130418f, -0.05010616f, 
    -0.07662132f, -0.06383081f, 0.04144518f, -0.06639013f, 0.04772167f, 0.05350582f, -0.04912348f, 0.05027182f, 
    -0.00142390f, -0.02587075f, 0.04695256f, -0.01699058f, -0.07823625f, 0.05747478f, -0.03860451f, -0.00090075f, 
    -0.07589388f, 0.04428387f, -0.01163141f, 0.00521918f, -0.00299724f, -0.07883516f, -0.00348422f, -0.07710189f, 
    0.05795383f, 0.03553903f, -0.01995262f, 0.03098580f, 0.06280006f, -0.07436787f, -0.05240848f, 0.03201162f, 
    0.01946987f, -0.07033022f, -0.06987722f, 0.00947491f, -0.00658021f, 0.00264291f, -0.02923698f, -0.04706338f, 
    0.04654591f, 0.04257115f, -0.01030764f, -0.01526930f, -0.04557860f, -0.05093026f, -0.05629959f, -0.06404617f, 
    -0.00787788f, 0.03079310f, -0.06113556f, -0.02888091f, 0.04513635f, -0.02496984f, -0.06469268f, 0.04230481f, 
    0.03687830f, -0.03797080f, -0.03589043f, 0.02691174f, 0.02556627f, -0.00299396f, 0.05187412f, -0.00885307f, 
    -0.05304973f, 0.02846167f, -0.00180394f, 0.04651942f, -0.06207746f, 0.02054239f, -0.06559846f, -0.05737774f, 
    0.03265543f, -0.02340662f, -0.05539215f, -0.02196928f, -0.05935062f, -0.02635436f, 0.01060986f, -0.03446521f, 
    0.01233053f, -0.02507818f, -0.06806025f, -0.04776774f, 0.01442489f, -0.06257197f, 0.06359354f, 0.06454115f, 
    -0.04718138f, -0.05901910f, 0.00787508f, -0.04367949f, 0.00242349f, 0.02003556f, 0.00918549f, 0.01449246f, 
    -0.01679982f, 0.02745040f, 0.05746041f, -0.00138002f, -0.06861289f, -0.01485981f, 0.02403579f, -0.07749535f, 
    -0.05020965f, -0.06824590f, -0.03848208f, 0.06222177f, -0.01187089f, -0.04019031f, -0.04867454f, -0.00168899f, 
    0.05038251f, 0.02427168f, 0.00939563f, -0.04668438f, 0.00843243f, -0.01312376f, -0.00653420f, -0.05504870f, 
    0.02606307f, 0.00994720f, -0.07468782f, -0.06751025f, -0.01769807f, 0.05695322f, -0.04831636f, -0.00889817f, 
    0.04510061f, -0.01855771f, -0.07670952f, -0.07597496f, -0.05136841f, -0.05464098f, 0.01370279f, 0.00170116f, 
    0.05678023f, 0.00857404f, -0.01938833f, 0.00008350f, -0.00486581f, 0.05203626f, -0.07343328f, 0.01725557f, 
    -0.06954727f, -0.03837736f, 0.00962447f, 0.03359239f, 0.04284154f, -0.00695267f, 0.01367441f, -0.00288992f, 
    0.03258381f, 0.04772970f, -0.06029399f, 0.00672156f, 0.01482742f, 0.00004005f, 0.03770817f, -0.04800748f, 
    0.06361081f, -0.07166486f, 0.02518089f, 0.04583344f, -0.03708584f, -0.07531565f, 0.01127932f, 0.04820358f, 
    -0.07302405f, -0.02634984f, 0.00304251f, -0.01884310f, -0.02223896f, 0.06078220f, 0.04097160f, 0.00004630f, 
    0.04996967f, -0.01636044f, -0.04178580f, 0.06099259f, 0.01169850f, -0.04656718f, 0.00167638f, -0.04527962f, 
    -0.08067362f, -0.04355528f, 0.01034015f, 0.05750621f, -0.00270216f, 0.03212770f, 0.04171037f, -0.05028941f, 
    -0.07397176f, 0.02707467f, -0.07802126f, 0.02035797f, -0.00547859f, 0.01550092f, 0.04554945f, -0.00860164f, 
    -0.04901051f, -0.05529143f, -0.03903380f, 0.04747592f, -0.06305191f, 0.06311834f, -0.01210020f, -0.04779458f, 
    -0.07173747f, 0.03781817f, -0.07897303f, 0.04100082f, 0.05812818f, -0.06909610f, -0.05762381f, 0.02016554f, 
    -0.01436262f, 0.01431006f, 0.04928198f, 0.01096914f, -0.04839106f, 0.00437891f, 0.04371159f, 0.02770627f, 
    -0.05121248f, -0.00428036f, 0.05929205f, -0.05698080f, 0.02084077f, -0.07260033f, -0.01575531f, -0.06349261f, 
    -0.15808985f, 0.07570989f, 0.35829207f, 0.43007076f, -0.14841829f, 0.03813346f, -0.22027884f, 0.21638918f, 
    0.03865803f, -0.11952974f, 0.01666301f, -0.03931380f, 0.08116319f, 0.23174560f, 0.27121753f, -0.01180367f, 
    -0.06049665f, -0.04327944f, -0.27171865f, 0.11499356f, 0.09451396f, 0.04209667f, -0.04972462f, 0.11405648f, 
    -0.14940111f, -0.04963898f, -0.23470485f, -0.19791199f, -0.04057781f, -0.07125000f, -0.12824753f, 0.03398823f, 
    0.08499080f, 0.08256974f, 0.01351750f, 0.17092177f, -0.11834263f, 0.11632582f, 0.21840349f, 0.12340248f, 
    -0.10359878f, -0.10662988f, -0.13556492f, 0.30048737f, 0.04694485f, -0.06456182f, 0.16355489f, -0.00447478f, 
    0.03209616f, 0.28241274f, -0.03422312f, 0.06562116f, 0.02514238f, 0.11532158f, -0.04185562f, -0.01434624f, 
    -0.00723007f, -0.04458260f, 0.02115399f, 0.13266252f, -0.10999167f, -0.34947398f, -0.29026103f, 0.01564962f, 
    -0.12110373f, -0.01055655f, 0.02007694f, -0.04077699f, 0.12109622f, -0.03054131f, 0.05059129f, 0.01541953f, 
    0.14577693f, -0.26774830f, -0.06925657f, -0.07399703f, 0.05238970f, -0.08393358f, -0.03468750f, 0.01526176f, 
    0.05801881f, -0.10590012f, -0.01191670f, -0.14889410f, 0.09094042f, -0.05712617f, 0.09272380f, 0.13781598f, 
    0.14201079f, 0.01771691f, 0.07503232f, -0.04381089f, -0.03256936f, -0.04698518f, -0.10477391f, -0.29093125f, 
    0.02667503f, -0.02170078f, 0.27676165f, 0.27946860f, 0.07663988f, -0.17035744f, 0.04008018f, 0.01409809f, 
    0.05841059f, 0.00914312f, -0.00114555f, 0.00303760f, -0.46900499f, -0.21413173f, -0.31782886f, 0.05493153f, 
    0.11122607f, 0.11226369f, 0.12158463f, 0.08491714f, 0.01278997f, 0.03283427f, 0.05533006f, 0.06125334f, 
    -0.08297163f, 0.04734535f, 0.19570246f, 0.17997088f, -0.03536255f, -0.04404337f, -0.08727874f, 0.04646628f, 
    -0.02344780f, 0.09761579f, -0.21073291f, 0.11241174f, 0.15251392f, -0.13837275f, 0.13149507f, 0.24546219f, 
    0.10069843f, -0.11454397f, -0.13693990f, 0.05164323f, -0.04461928f, -0.00066333f, 0.11823616f, 0.06739227f, 
    0.36973548f, 0.02119396f, -0.18696401f, -0.07080492f, 0.01637549f, 0.09346893f, 0.35467640f, 0.11695892f, 
    -0.05000455f, 0.18358463f, -0.09112538f, -0.03001772f, 0.38502121f, 0.23690131f, 0.27298370f, 0.11756285f, 
    0.07916784f, -0.00595997f, -0.04661139f, 0.03700514f, 0.12352842f, -0.06949048f, 0.00567414f, -0.01611014f, 
    -0.12856691f, 0.31235605f, 0.25880396f, 0.25948453f, -0.24091144f, -0.04093885f, 0.03876800f, -0.09175415f, 
    -0.13804598f, -0.01168041f, -0.03411092f, -0.06815049f, 0.20028509f, 0.12486289f, -0.28442311f, -0.07895764f, 
    0.20583676f, 0.11983035f, 0.04088321f, 0.03501708f, -0.06254935f, 0.00951902f, 0.07472565f, 0.07571020f, 
    0.45710158f, 0.24798310f, 0.11546511f, 0.00790067f, 0.07652941f, 0.08598007f, 0.01719835f, 0.21968944f, 
    -0.04438909f, 0.15478779f, 0.09185685f, -0.09904348f, 0.03862738f, 0.10904260f, 0.01612507f, -0.07399599f, 
    0.01415095f, 0.19021732f, 0.15984906f, 0.02442181f, 0.14509754f, 0.16708383f, 0.22657041f, 0.22194700f, 
    -0.22727473f, 0.07567805f, -0.06138021f, 0.07279161f, -0.11157036f, -0.07500497f, 0.09289277f, 0.14560281f, 
    -0.06085832f, 0.28733876f, 0.33454168f, 0.34548277f, 0.23635839f, -0.00820589f, 0.14990310f, 0.01459116f, 
    0.11823668f, 0.13731942f, 0.18957467f, 0.18907528f, 0.14795911f, 0.09567013f, 0.06137478f, 0.13231355f, 
    0.13891186f, 0.11485824f, -0.23771876f, -0.25691494f, -0.01239803f, 0.01547564f, 0.09601095f, 0.05325511f, 
    -0.01954467f, 0.10338689f, 0.14705873f, -0.00379631f, -0.12017065f, -0.13856590f, -0.42686659f, -0.08237626f, 
    0.13564231f, -0.23243211f, -0.06561355f, -0.32178184f, 0.07937642f, -0.13264789f, -0.19290999f, -0.04340745f, 
    -0.31901991f, -0.00674268f, -0.08055127f, -0.01930581f, -0.06152686f, -0.11130472f, -0.21094571f, 0.04734017f, 
    -0.18724994f, -0.09023788f, -0.09292106f, -0.02814079f, -0.20916468f, 0.21240740f, 0.08548706f, 0.00304652f, 
    -0.04280033f, -0.08735812f, 0.17157118f, -0.00088236f, -0.29217544f, -0.29654911f, -0.35339209f, -0.39948252f, 
    0.39331606f, 0.27608308f, 0.18950142f, 0.03206108f, -0.12927970f, -0.12573405f, -0.05564938f, 0.03840241f, 
    0.15730919f, 0.03365657f, -0.04097460f, 0.27621379f, -0.37227568f, -0.34432021f, 0.07399182f, -0.00819728f, 
    -0.20545121f, 0.04518718f, -0.13592403f, -0.20535083f, -0.12686373f, -0.07741187f, -0.04751004f, 0.05522431f, 
    0.06994611f, 0.17312539f, 0.07787731f, 0.09287520f, 0.07660544f, 0.01157773f, -0.04357738f, 0.18745483f, 
    -0.00457600f, 0.03677997f, 0.15485352f, 0.15126853f, 0.50237238f, 0.27174497f, -0.11906552f, 0.21761106f, 
    0.05864359f, 0.10029622f, 0.03917990f, -0.24886718f, 0.11595476f, 0.03003342f, 0.00647492f, 0.20767112f, 
    0.62401575f, 0.18955889f, -0.40996927f, -0.04743208f, 0.13802867f, -0.05589755f, -0.11746080f, 0.17291836f, 
    -0.09710777f, -0.01287585f, -0.18924224f, -0.74291617f, 0.03937749f, -0.04393132f, -0.08119587f, 0.00354493f, 
    0.03527186f, 0.12935108f, 0.01769438f, -0.02390230f, -0.00481529f, -0.07017546f, -0.26062268f, -0.09295125f, 
    0.26748911f, -0.09566886f, 0.18979253f, -0.15454650f, 0.22277415f, 0.06539959f, -0.05511668f, -0.12912197f, 
    -0.33548892f, -0.14814717f, -0.11250629f, -0.16889489f, -0.08327980f, -0.08151352f, 0.20410419f, -0.13278687f, 
    -0.19852400f, -0.14461094f, 0.00057175f, -0.38237125f, -0.01149711f, -0.10611347f, -0.01061158f, -0.04308578f, 
    0.12485963f, 0.06986439f, -0.02613968f, 0.14489090f, 0.11754227f, 0.18099381f, 0.03194823f, 0.27502736f, 
    0.01299017f, 0.22979103f, 0.04376912f, -0.11211291f, 0.04680767f, 0.03706115f, 0.20629372f, 0.18177192f, 
    0.16885288f, 0.15729937f, 0.02972928f, 0.07195963f, 0.06019862f, 0.21626978f, 0.04700827f, 0.07769760f, 
    -0.07559562f, 0.08441067f, -0.37161770f, 0.00346669f, -0.08338679f, -0.17592965f, 0.00999570f, 0.00231604f, 
    0.02658392f, 0.29072061f, 0.09138875f, 0.41325560f, -0.01896434f, -0.33390692f, 0.03113128f, 0.15933467f, 
    0.17112356f, 0.27158061f, 0.06579886f, 0.00266862f, 0.16686827f, 0.01410226f, 0.04362168f, 0.17926948f, 
    0.10326637f, 0.01729085f, -0.30044377f, 0.08854055f, 0.17095715f, 0.13335328f, -0.02182527f, -0.06372218f, 
    0.02567676f, -0.05697002f, 0.08636855f, 0.10294375f, -0.07519444f, -0.06215607f, -0.18169159f, -0.21840665f, 
    0.00315001f, -0.29837117f, 0.11255480f, -0.18458772f, -0.17354067f, -0.25338796f, -0.03942642f, 0.05798138f, 
    -0.12028710f, 0.02442744f, 0.04924928f, -0.09308604f, -0.14875849f, -0.17948431f, -0.22721870f, 0.09144755f, 
    -0.11862149f, -0.21316537f, 0.09411661f, -0.04153401f, -0.15179007f, 0.12233707f, 0.32434273f, -0.01952084f, 
    -0.05782575f, 0.01014476f, 0.06003863f, -0.08642286f, -0.11362627f, -0.25013265f, -0.08942086f, -0.40774363f, 
    0.14561757f, 0.38209775f, 0.07765567f, 0.01764901f, -0.20674962f, -0.03346409f, 0.19195782f, 0.05380696f, 
    0.03036311f, -0.01141778f, -0.10860639f, 0.21767995f, 0.13838318f, -0.01096344f, 0.21411908f, 0.01089209f, 
    0.15558445f, 0.14577009f, -0.24755788f, -0.10542813f, -0.08194923f, 0.10922620f, 0.01349991f, -0.13506372f, 
    -0.07683929f, 0.05182387f, -0.10755808f, -0.02025891f, 0.10842633f, -0.00733145f, -0.00005982f, 0.14488420f, 
    -0.00931494f, 0.10605825f, 0.08236472f, 0.18044348f, 0.15593648f, 0.27598473f, 0.36486316f, 0.20012161f, 
    0.20387344f, -0.06871936f, -0.15274601f, 0.00370156f, 0.04124414f, 0.16215014f, 0.03314211f, -0.04561065f, 
    0.12193189f, -0.24884979f, 0.14410704f, 0.05860860f, 0.15656267f, -0.01336459f, -0.10999055f, 0.02871067f, 
    -0.02269077f, -0.05055140f, -0.00352160f, -0.44200072f, 0.16466370f, -0.04604676f, 0.15951659f, 0.30923429f, 
    0.22180052f, -0.24945146f, -0.12446538f, -0.05249686f, 0.08325713f, -0.13689026f, -0.15046944f, -0.09753224f, 
    -0.13876440f, 0.18925801f, -0.26510519f, 0.01952414f, 0.11553826f, 0.05403334f, -0.18015990f, -0.01593996f, 
    -0.29143569f, -0.11261541f, -0.21277273f, 0.09236402f, 0.39229435f, 0.35949469f, 0.51920861f, 0.07225014f, 
    -0.12304822f, -0.06130302f, 0.27640876f, -0.14488307f, -0.04855472f, -0.14117394f, -0.11656169f, 0.02353229f, 
    0.04115980f, -0.13398694f, -0.00172458f, 0.40923300f, 0.00461809f, -0.00745041f, -0.08506154f, -0.11339726f, 
    -0.12126013f, -0.01252827f, -0.09183339f, 0.00357391f, 0.17706533f, -0.11073625f, -0.25293347f, 0.07859349f, 
    0.05463634f, 0.10388887f, 0.20323323f, -0.02314450f, 0.02140626f, -0.06853182f, -0.04129118f, 0.04098896f, 
    -0.19174512f, -0.13090913f, 0.32332781f, 0.14062342f, -0.05388979f, -0.11634377f, -0.18775789f, 0.01606844f, 
    -0.05197605f, 0.09173364f, 0.17227527f, -0.05052045f, 0.13618529f, 0.11730172f, -0.19278234f, 0.34978953f, 
    0.11202341f, -0.01672159f, 0.17511550f, -0.17329875f, -0.07591886f, 0.00304785f, -0.15058707f, -0.01182805f, 
    0.14402102f, 0.18984202f, 0.02110817f, 0.07958472f, 0.05480269f, -0.06083925f, 0.20301002f, 0.01772614f, 
    -0.04959888f, -0.01175382f, 0.00424149f, -0.11137749f, 0.00852734f, 0.19156535f, 0.15127629f, -0.17892955f, 
    0.02558709f, 0.04947912f, -0.02841568f, 0.12898673f, -0.03347057f, 0.10644560f, -0.09944355f, 0.20611890f, 
    0.32697025f, 0.06572594f, 0.23155577f, -0.04444855f, -0.07840221f, 0.02220571f, 0.07554779f, -0.06978024f, 
    -0.13063003f, 0.08411743f, -0.01138476f, -0.04293426f, 0.14000346f, 0.18758819f, -0.08041055f, -0.07119292f, 
    0.21282637f, -0.09357818f, 0.19392300f, 0.03928835f, -0.07995671f, 0.00355965f, 0.17459001f, 0.04691308f, 
    -0.21518351f, -0.40940776f, -0.07775506f, 0.11532993f, 0.08339651f, 0.10926256f, -0.01164098f, 0.24289337f, 
    0.17617571f, -0.04373946f, 0.05855569f, -0.06421599f, 0.20116907f, -0.06678155f, -0.02022424f, -0.26324841f, 
    0.00568408f, -0.00549722f, 0.12437040f, -0.00114775f, 0.10211615f, 0.07119507f, 0.13388136f, 0.06579418f, 
    -0.04678026f, -0.09242084f, -0.13733591f, -0.06467097f, 0.07934600f, -0.04614229f, -0.04744501f, 0.00920653f, 
    0.03122377f, 0.20716752f, -0.03979201f, 0.21823208f, -0.13512371f, -0.06388964f, -0.27330923f, -0.14035434f, 
    -0.01217393f, 0.04068251f, 0.06538489f, -0.13906573f, -0.10233404f, -0.11226677f, 0.00082442f, 0.00815900f, 
    0.02899630f, 0.08220387f, 0.16403669f, -0.00259663f, -0.03922617f, -0.15188101f, 0.29787225f, -0.06355499f, 
    0.09687965f, -0.01157809f, -0.14562264f, 0.07952026f, 0.08583640f, -0.00724819f, 0.07826564f, 0.43014035f, 
    0.02414908f, 0.00444927f, 0.09268162f, 0.06593269f, -0.07561707f, -0.01101576f, -0.00782694f, 0.08347805f, 
    -0.00268803f, 0.16015607f, -0.24540222f, 0.04408050f, 0.03684600f, -0.27878392f, 0.07213315f, 0.00354729f, 
    -0.05438610f, 0.08456495f, -0.02827696f, -0.05466049f, 0.34997550f, 0.16601346f, 0.03606718f, 0.02354567f, 
    0.04968738f, -0.00440682f, -0.06096672f, -0.08285252f, 0.06884557f, 0.14934321f, 0.14187664f, -0.03779587f, 
    -0.06667498f, 0.03378196f, 0.21880937f, 0.15565644f, -0.09398582f, 0.11092670f, 0.03706447f, 0.07036552f, 
    0.10306576f, 0.00978909f, 0.05331535f, -0.14788339f, 0.00288912f, -0.20299107f, 0.33410197f, 0.18705863f, 
    -0.06512675f, -0.05735679f, -0.02287517f, -0.01224556f, -0.02946247f, 0.08474694f, 0.03780207f, 0.01617492f, 
    0.24313733f, 0.05052263f, -0.32532173f, -0.00504617f, -0.02782091f, -0.00135260f, 0.07589609f, -0.01896143f, 
    0.03678128f, 0.04981246f, -0.03259454f, 0.03196876f, -0.36023554f, -0.08328836f, 0.04092672f, 0.00353286f, 
    0.06039074f, 0.17179932f, -0.02549303f, -0.03085844f, 0.06563584f, 0.10609112f, -0.08808557f, 0.18639508f, 
    -0.32890111f, -0.33628365f, -0.27163050f, -0.00227831f, 0.02679384f, 0.01404304f, 0.11850370f, -0.07546469f, 
    -0.05046872f, -0.16761634f, 0.00539109f, -0.07112535f, -0.11307945f, 0.10452189f, -0.10618737f, -0.21397473f, 
    0.10258564f, -0.10764830f, 0.02263053f, -0.04550820f, 0.04216556f, 0.02067241f, 0.13463169f, 0.13125788f, 
    -0.36883348f, 0.18501736f, -0.20821758f, -0.05483539f, 0.09340783f, -0.13571903f, 0.12192401f, -0.04756131f, 
    0.02693791f, -0.06524595f, -0.15169851f, -0.02497046f, -0.08087428f, 0.03059497f, -0.09049716f, -0.08428568f, 
    0.28668690f, -0.02407290f, 0.03566605f, 0.09652609f, 0.06296562f, -0.09340566f, -0.14832838f, 0.01916364f, 
    0.19892944f, 0.32941175f, 0.10972360f, 0.02646127f, -0.12130560f, -0.06658069f, 0.09765493f, 0.18161735f, 
    0.09793126f, -0.08010430f, -0.04776591f, 0.11961869f, 0.00611925f, 0.29487181f, 0.25032517f, 0.02605850f, 
    0.06721550f, -0.06690088f, -0.15631287f, -0.06334315f, -0.18543278f, 0.22791971f, 0.19793999f, -0.02841640f, 
    -0.14638698f, 0.04487969f, -0.06670459f, 0.11594263f, 0.00979698f, 0.04249666f, 0.08516959f, 0.24078538f, 
    -0.02828606f, 0.10408872f, 0.14038937f, -0.00216716f, -0.13855650f, 0.23349525f, 0.42762819f, 0.07594546f, 
    -0.06425146f, -0.05750035f, -0.19737224f, 0.03269034f, 0.12934382f, 0.13009256f, 0.10022864f, 0.06301834f, 
    -0.25538313f, -0.28457215f, -0.05133790f, -0.17372632f, 0.18549162f, 0.01379455f, 0.16560882f, -0.00357811f, 
    0.02050961f, -0.29669887f, 0.02138383f, -0.14216676f, -0.07409597f, -0.01426959f, 0.00617651f, 0.03521504f, 
    0.01840618f, -0.23662287f, -0.03865743f, 0.05840383f, -0.01839025f, 0.02086488f, 0.09621087f, 0.02901660f, 
    -0.05231595f, -0.32408881f, 0.08185222f, -0.00570236f, 0.08273925f, -0.01699157f, -0.09933080f, 0.14738581f, 
    0.04286566f, 0.03034722f, -0.09141734f, 0.09763385f, 0.03118521f, 0.17035241f, 0.35492578f, 0.32804269f, 
    -0.04429127f, -0.40172914f, 0.17111190f, -0.17764273f, 0.04065743f, 0.04782581f, -0.04318401f, 0.22145616f, 
    -0.15784097f, -0.23325875f, 0.31567991f, -0.09264402f, -0.11793911f, -0.06722753f, -0.13698135f, 0.01665805f, 
    0.04735503f, -0.23612076f, -0.04286428f, -0.20634162f, -0.27448183f, -0.08559897f, 0.24136497f, -0.07240009f, 
    0.09591226f, 0.01225287f, 0.31185314f, 0.32378507f, -0.01001639f, 0.01556892f, 0.18475315f, 0.31082675f, 
    0.27153078f, -0.14158936f, -0.16577472f, -0.14880487f, -0.17941764f, 0.08324319f, 0.14410621f, 0.13740453f, 
    0.12982215f, 0.29939178f, 0.34180707f, 0.30791026f, -0.36500910f, -0.01981773f, 0.10478936f, -0.01775224f, 
    -0.08485965f, 0.08296100f, 0.01017000f, 0.28778982f, 0.17403558f, 0.01523809f, -0.15238209f, -0.03029154f, 
    -0.43518004f, -0.08672689f, 0.35973412f, 0.28372529f, -0.05651396f, -0.08319697f, 0.12009618f, 0.12926902f, 
    0.04208663f, -0.04780802f, -0.12858668f, -0.02695792f, 0.18055409f, 0.08448794f, -0.22352901f, -0.27651140f, 
    0.03288003f, 0.11395236f, -0.18039766f, -0.02588458f, -0.00018325f, 0.01408938f, 0.11613881f, 0.09547177f, 
    -0.12971549f, 0.35234195f, -0.04501190f, -0.21486448f, 0.12820053f, -0.09317984f, -0.00180938f, -0.16471416f, 
    -0.10860374f, 0.12905505f, -0.01592554f, -0.06968670f, 0.20979939f, 0.10367537f, -0.29073930f, 0.13246302f, 
    0.19153722f, -0.21441315f, -0.12896797f, -0.23063885f, -0.00610016f, -0.06357473f, -0.31826973f, -0.00873366f, 
    0.17227735f, 0.15992118f, 0.18074745f, 0.13743855f, -0.10426319f, -0.12080377f, 0.03953613f, 0.20787509f, 
    0.07115825f, 0.03876333f, -0.33407360f, -0.01756397f, -0.29578602f, 0.08617226f, -0.14674322f, -0.29707035f, 
    0.02191205f, -0.00259089f, 0.00202280f, 0.17357665f, 0.06506301f, 0.21321115f, 0.17543355f, 0.18919559f, 
    -0.00559679f, -0.23043071f, 0.18550628f, 0.02338118f, -0.03561644f, -0.11717428f, 0.14739823f, 0.12481713f, 
    0.21456215f, 0.28915900f, 0.34425223f, 0.06088825f, -0.34259892f, 0.10000634f, 0.46383801f, 0.12515816f, 
    -0.20043361f, 0.09746342f, 0.09644892f, 0.27075776f, 0.20644294f, -0.03474583f, -0.02745096f, 0.08964536f, 
    0.04771094f, -0.00481347f, -0.20465350f, -0.00204479f, -0.02443371f, 0.13174537f, 0.11243513f, 0.25349134f, 
    -0.15456432f, -0.12192550f, -0.11774178f, -0.02622400f, -0.39256832f, 0.01480926f, 0.09032365f, -0.39137027f, 
    -0.06119732f, -0.11082057f, -0.21136601f, -0.03220475f, -0.04281585f, -0.07138117f, 0.11242086f, -0.09110700f, 
    0.11112598f, -0.53291965f, 0.35871279f, 0.09418885f, 0.00744198f, -0.04264895f, -0.25754914f, -0.05006202f, 
    0.10603561f, 0.04139696f, 0.00902911f, -0.13649258f, 0.01101298f, 0.01471678f, 0.01021599f, 0.08654173f, 
    0.03329728f, -0.26804990f, 0.16357020f, 0.18635705f, 0.09255536f, 0.19616011f, 0.08997672f, -0.02158912f, 
    0.10632747f, -0.03815040f, -0.00662745f, -0.21844153f, -0.08523449f, 0.03962730f, 0.05715685f, 0.12235373f, 
    0.11423555f, -0.01384869f, 0.08193447f, 0.00442592f, -0.11225040f, 0.08896595f, 0.28065309f, -0.14077587f, 
    -0.06317513f, -0.03323096f, -0.23901619f, 0.03452111f, 0.12276054f, -0.09009983f, -0.04165855f, -0.03594824f, 
    0.29784817f, 0.15742870f, -0.32906103f, -0.13825679f, 0.18372959f, -0.10214912f, 0.14836909f, -0.15820575f, 
    -0.06153616f, 0.10276842f, -0.02072351f, 0.24736825f, -0.15217413f, -0.18506116f, 0.19162092f, -0.21857481f, 
    0.00671773f, -0.04895253f, 0.04399245f, 0.13624623f, 0.14808795f, -0.04799240f, 0.11109862f, -0.06274556f, 
    0.33625218f, 0.30898803f, -0.11701164f, -0.16530743f, -0.13111494f, 0.13148153f, 0.01466679f, 0.09420384f, 
    0.08906144f, 0.02162403f, 0.11316276f, -0.07088089f, 0.01224337f, -0.11299519f, 0.07841168f, 0.04770703f, 
    -0.06318137f, -0.14807124f, 0.00278316f, -0.19325125f, 0.16197821f, 0.07840133f, -0.00010115f, 0.10951601f, 
    0.20388612f, 0.07101315f, 0.03612357f, -0.04445711f, -0.08475630f, -0.05852610f, 0.08264247f, -0.11890705f, 
    0.13203458f, 0.02208226f, -0.18898810f, 0.04007617f, -0.11825410f, 0.06297763f, 0.17591134f, -0.01219060f, 
    -0.03569982f, 0.10075332f, -0.10398893f, 0.03725637f, -0.03447251f, -0.03649479f, -0.08317114f, -0.00488059f, 
    0.05626046f, 0.18840882f, 0.32158178f, -0.00286251f, -0.06956071f, 0.04225550f, -0.01899664f, 0.02695388f, 
    -0.03647266f, 0.06000233f, 0.02968589f, -0.00785504f, -0.10762079f, -0.18752393f, 0.25101227f, 0.44703883f, 
    -0.00950923f, -0.00110562f, -0.18593758f, -0.08707350f, 0.18168707f, 0.09668101f, 0.07713081f, 0.02978789f, 
    -0.03178279f, 0.23298849f, 0.11351650f, 0.01311109f, 0.00744087f, 0.30381230f, 0.00401868f, 0.06644984f, 
    0.07133286f, -0.13096209f, 0.00347383f, 0.04119775f, 0.19048037f, -0.11302876f, 0.23291904f, 0.10855541f, 
    -0.19949642f, 0.03041325f, -0.26253855f, -0.06049941f, 0.09125141f, -0.06880666f, 0.14231291f, 0.13565181f, 
    0.37677595f, -0.04019826f, -0.25342396f, -0.26848191f, 0.02347510f, 0.11802739f, 0.05191422f, -0.01212789f, 
    0.06362012f, 0.01335811f, 0.08132496f, -0.08258975f, 0.16623227f, 0.13881712f, 0.35236743f, -0.41223860f, 
    -0.15894368f, -0.10913572f, 0.09192067f, -0.00748070f, -0.12106921f, -0.14497000f, -0.15632780f, 0.00944690f, 
    -0.16431044f, -0.00138880f, -0.09516115f, -0.03355271f, -0.05714459f, -0.10455508f, 0.13519479f, 0.04654024f, 
    -0.05522521f, -0.14929415f, 0.00477047f, 0.03655636f, -0.38155496f, 0.34439433f, 0.06957524f, -0.11727340f, 
    -0.09677335f, 0.04923243f, -0.01224227f, -0.24054593f, 0.14765780f, -0.09631572f, -0.02710562f, 0.17267510f, 
    0.12168914f, 0.15376621f, -0.23416996f, 0.23580617f, 0.13727833f, 0.00547786f, 0.07343002f, -0.01794261f, 
    -0.15886860f, 0.14123502f, 0.03851505f, 0.22544959f, 0.20404366f, 0.16417795f, -0.13002533f, -0.00915107f, 
    0.08754561f, 0.03831976f, -0.19098969f, -0.14480488f, 0.07766920f, -0.02070425f, -0.15272744f, -0.09887027f, 
    0.07830145f, 0.01057630f, 0.33539003f, 0.21534529f, 0.00071773f, -0.10061479f, -0.02830848f, -0.18568675f, 
    -0.20323572f, -0.26824918f, -0.32500559f, -0.22749922f, 0.35342345f, 0.02320372f, -0.05666317f, 0.19996215f, 
    0.05634730f, 0.02733316f, 0.14143027f, -0.08091772f, -0.12455387f, -0.03864394f, 0.17269385f, 0.05701778f, 
    0.43646321f, 0.25465101f, -0.04935225f, -0.01729785f, 0.10207518f, 0.04603578f, -0.01738737f, 0.06279715f, 
    -0.01742930f, 0.10939433f, 0.15938918f, 0.04439538f, 0.06148597f, 0.04363527f, 0.16205201f, 0.15198138f, 
    -0.15605107f, 0.01111960f, -0.08392016f, -0.07736962f, 0.00553868f, 0.15808931f, -0.07611998f, -0.00271814f, 
    0.33984643f, -0.04970479f, 0.11930156f, 0.19505225f, -0.15445225f, -0.07750966f, 0.10943682f, -0.11295737f, 
    -0.10812094f, -0.06493642f, -0.09036373f, 0.10340364f, -0.17358685f, -0.13660386f, 0.02251675f, -0.15631288f, 
    0.01619972f, 0.22471437f, -0.06579967f, -0.09784534f, -0.11236125f, 0.07198517f, 0.13966149f, -0.03760064f, 
    -0.15846834f, -0.18302312f, -0.11291926f, -0.11630876f, 0.13388483f, 0.22025757f, -0.05308073f, 0.00907096f, 
    -0.02182686f, -0.01205981f, 0.16957588f, -0.05080878f, 0.20162474f, -0.11974163f, -0.03697014f, 0.06243338f, 
    -0.04240343f, 0.02375978f, 0.11238211f, -0.18942766f, 0.15054505f, -0.03667232f, 0.04996992f, 0.05237087f, 
    0.13424055f, 0.12712426f, 0.05604874f, 0.06608330f, 0.02983616f, 0.33173111f, 0.01422943f, -0.09325697f, 
    -0.07951532f, -0.06724028f, -0.32447568f, 0.09923035f, 0.25622475f, -0.09849050f, -0.48389563f, -0.23591889f, 
    -0.01896226f, -0.07159057f, -0.06685410f, -0.21191932f, -0.06436329f, 0.13049239f, 0.09343405f, -0.01187463f, 
    0.21857668f, 0.04164490f, 0.21998259f, 0.00536519f, -0.00735745f, -0.23018199f, 0.07884375f, -0.13149568f, 
    0.10444491f, 0.21630344f, 0.01608180f, -0.10576005f, 0.38879654f, 0.05326445f, -0.00720110f, 0.30138218f, 
    0.02771856f, 0.11287446f, 0.29270390f, 0.13987228f, -0.02010760f, 0.03190645f, -0.00263632f, 0.18194674f, 
    -0.22044052f, 0.46648437f, -0.30260229f, 0.11049506f, -0.00927905f, 0.16174528f, 0.24809806f, 0.15102164f, 
    -0.05676332f, -0.08303759f, -0.02462150f, 0.03292529f, 0.03657990f, -0.04199176f, 0.12928659f, -0.13894674f, 
    -0.10056661f, 0.18948409f, -0.20329165f, -0.17312998f, 0.03428435f, 0.10160856f, 0.20375209f, -0.01372655f, 
    -0.42674431f, -0.39031261f, -0.13656779f, 0.28531012f, 0.04185245f, 0.12162197f, -0.13401158f, 0.21899462f, 
    -0.00745572f, -0.00265799f, -0.04355014f, -0.16205496f, 0.21569186f, -0.06866542f, 0.08459910f, 0.12586288f, 
    0.10919791f, 0.00639904f, -0.00767750f, 0.11173886f, 0.19638535f, 0.03930308f, 0.19408762f, 0.17921971f, 
    -0.22284772f, -0.00542924f, 0.23758173f, 0.10398047f, -0.01353048f, 0.00933027f, -0.02054580f, -0.00515590f, 
    0.08282807f, 0.22491229f, 0.07758144f, 0.16058207f, -0.18456124f, 0.04901614f, -0.11304506f, 0.00584684f, 
    0.01800010f, -0.02638345f, 0.02819753f, 0.23783877f, -0.02956813f, -0.07460555f, 0.05743021f, -0.04658893f, 
    0.04872579f, 0.01818300f, 0.16148947f, 0.28649041f, -0.06442317f, -0.01897851f, 0.03247472f, 0.10677189f, 
    -0.02405363f, 0.16628774f, -0.02006646f, 0.17349476f, -0.00798314f, 0.10397314f, -0.03264684f, -0.04232028f, 
    0.01408165f, -0.01589691f, 0.02567415f, -0.03743127f, -0.03093169f, -0.12830094f, -0.04683499f, 0.05682563f, 
    0.02347230f, 0.30172566f, 0.28932020f, 0.03628311f, 0.09576757f, -0.03930703f, -0.06193526f, -0.01926157f, 
    -0.05351748f, -0.02154631f, 0.09242941f, -0.21036454f, 0.17444727f, 0.04931361f, -0.17970695f, 0.01419526f, 
    0.24039257f, 0.15979014f, 0.06531828f, 0.02105162f, 0.01246791f, -0.03604520f, 0.02872693f, -0.00947183f, 
    -0.01725944f, -0.32406500f, 0.06434096f, 0.26361024f, -0.08548263f, -0.21516193f, -0.08475704f, 0.16926719f, 
    -0.17552125f, 0.04313546f, 0.03767817f, 0.05350621f, 0.00174090f, 0.12730688f, -0.03102599f, -0.11271092f, 
    0.01604645f, -0.05537590f, 0.01598765f, 0.11044420f, 0.07721390f, 0.04601058f, 0.17917462f, 0.07794980f, 
    -0.00585388f, -0.18186775f, -0.06800497f, 0.01361625f, 0.27228099f, -0.04955969f, 0.08166318f, -0.08286889f, 
    0.03967158f, 0.11432230f, 0.02331195f, 0.04159432f, 0.13658966f, -0.24994917f, 0.27125421f, 0.20769295f, 
    -0.08251737f, -0.06638644f, -0.07895255f, -0.05563955f, 0.06530278f, -0.08248299f, 0.16686444f, -0.00165512f, 
    -0.10277119f, -0.00251224f, 0.14384291f, 0.04557691f, 0.13275485f, -0.04589156f, 0.28611842f, 0.30641669f, 
    0.03471071f, 0.04205718f, -0.18016113f, 0.07067721f, -0.09364941f, -0.09489419f, 0.24347897f, 0.08581729f, 
    -0.09333817f, 0.00440868f, 0.04103162f, 0.13313220f, -0.08704937f, -0.16806147f, 0.01409932f, -0.04457391f, 
    -0.08392896f, -0.09459992f, -0.23292141f, 0.24287224f, 0.05853433f, -0.22460291f, 0.05578822f, 0.14369513f, 
    -0.05271226f, -0.03387207f, 0.00376697f, -0.12087658f, 0.65310204f, 0.34680417f, -0.23973703f, 0.19069184f, 
    0.24483995f, 0.16369794f, -0.15835898f, -0.06325493f, 0.08088284f, 0.22943100f, 0.06977793f, 0.03582596f, 
    -0.08959598f, -0.03832597f, -0.05333733f, -0.02697333f, 0.04731989f, 0.03662500f, -0.05059544f, -0.00476263f, 
    -0.06785002f, 0.01585371f, 0.03757465f, -0.02249380f, -0.03382284f, -0.08180013f, 0.03725709f, 0.00956087f, 
    -0.02152880f, -0.07979947f, -0.04333854f, 0.03655135f, 0.00106332f, 0.04349367f, -0.02684890f, 0.02659150f, 
    -0.08736585f, -0.03980428f, -0.02360837f, -0.05302643f, 0.01869458f, -0.02901871f, -0.05512296f, -0.07170119f, 
    0.02965477f, -0.00841715f, -0.09322421f, -0.09455805f, -0.03690511f, -0.04003477f, 0.02185406f, -0.06891381f, 
    0.02502709f, -0.02946286f, -0.05736888f, 0.02027285f, -0.01608092f, 0.00241854f, -0.04724880f, -0.01674230f, 
    -0.01403060f, -0.02441060f, -0.06806374f, -0.05904111f, -0.06337087f, -0.08687498f, -0.01344423f, 0.01839818f, 
    -0.03798236f, -0.04587872f, -0.02744377f, -0.06650336f, 0.03653082f, -0.04335754f, -0.05711772f, -0.03145108f, 
    0.04147947f, 0.03803120f, 0.00691187f, -0.02737941f, 0.04356322f, -0.06004976f, -0.06032940f, 0.06048192f, 
    0.02212570f, 0.05952016f, -0.05707965f, -0.02629984f, -0.05407977f, 0.05404998f, 0.06174692f, 0.05714102f, 
    -0.07500098f, -0.08773166f, -0.00937026f, 0.01250132f, -0.01996387f, -0.07881471f, -0.00741772f, 0.00405668f, 
    -0.07578252f, 0.00558042f, -0.00033789f, 0.03278817f, 0.03689980f, 0.04635906f, -0.07800045f, -0.04500313f, 
    0.03866423f, -0.04556394f, -0.05828539f, 0.00887861f, 0.04374933f, -0.06272320f, -0.02145011f, 0.00006835f, 
    -0.07514563f, -0.06735046f, 0.07555211f, 0.03756196f, -0.02073620f, 0.02501722f, -0.05555823f, -0.06261479f, 
    -0.07033762f, -0.03924400f, 0.04203860f, -0.00058784f, 0.02609114f, -0.04866068f, 0.00362373f, 0.05143206f, 
    -0.00539032f, 0.03098890f, 0.05283029f, -0.03073626f, -0.06435602f, -0.02536866f, -0.04036994f, 0.04014537f, 
    0.02879212f, 0.04016072f, 0.00644726f, 0.00205171f, 0.01627036f, -0.06619778f, -0.02064743f, 0.00820450f, 
    -0.05264002f, -0.09593251f, -0.08400559f, -0.03671887f, -0.05191628f, 0.04571791f, -0.00604441f, -0.03170335f, 
    -0.08634216f, -0.00199082f, 0.02663588f, -0.04873693f, -0.02697962f, 0.05683289f, 0.03570184f, -0.00976942f, 
    0.02007319f, -0.02643559f, -0.07067236f, -0.05416818f, -0.01371825f, -0.02318936f, 0.02034955f, 0.03460326f, 
    -0.09883582f, 0.03384795f, 0.00565632f, 0.03129548f, 0.05270558f, -0.04309122f, -0.00525625f, -0.01170919f, 
    -0.07837872f, 0.02624770f, 0.00207802f, -0.08640079f, 0.00462880f, 0.04208067f, 0.02238843f, -0.02776454f, 
    0.02875292f, 0.02625865f, 0.02934111f, 0.00850755f, 0.01062397f, -0.03501436f, -0.06406704f, -0.07108311f, 
    0.00447234f, 0.00231933f, 0.04085829f, -0.07408713f, 0.02452222f, -0.03067346f, -0.05010127f, 0.05034820f, 
    -0.28527087f, -0.02281084f, -0.02327407f, -0.09046309f, 0.04712443f, 0.08699211f, 0.02669325f, -0.01814709f, 
    0.09961803f, -0.05015092f, 0.08898824f, -0.04614823f, 0.06273306f, -0.02467851f, 0.16022968f, 0.04276092f, 
    0.08433563f, 0.02669455f, 0.03374668f, 0.16746140f, -0.01549260f, 0.03810727f, 0.13465254f, -0.05698061f, 
    0.16703482f, 0.22068541f, 0.06015282f, 0.19117716f, -0.02660984f, 0.02320552f, 0.06813969f, -0.04707010f, 
    0.08249279f, 0.08667856f, -0.14617068f, -0.10206363f, -0.28650045f, 0.00663071f, -0.09607589f, -0.10032623f, 
    -0.16080980f, 0.07687470f, -0.13364723f, 0.09661444f, 0.01662067f, 0.12363004f, 0.12073352f, -0.02105968f, 
    -0.34335434f, -0.28127551f, 0.10185558f, 0.34787706f, 0.19302715f, -0.00909847f, -0.05208267f, -0.03584444f, 
    0.11796579f, -0.02095990f, 0.04851753f, 0.16722281f, -0.07509846f, 0.08745339f, -0.10796078f, -0.07363139f, 
    -0.01447997f, 0.05333368f, -0.09051194f, -0.09316070f, -0.05087637f, -0.00884497f, 0.11709465f, 0.23604801f, 
    -0.10194786f, 0.19989210f, 0.29996851f, 0.16001831f, 0.06556042f, -0.01652465f, -0.09224533f, 0.09760632f, 
    -0.02018655f, -0.08328300f, 0.14262904f, 0.09033757f, -0.05956032f, -0.19779903f, -0.09511049f, -0.04127233f, 
    0.09221931f, 0.00957024f, -0.17477421f, -0.00931592f, 0.15102524f, 0.10518822f, 0.06279413f, 0.18003185f, 
    -0.05563060f, -0.07734685f, 0.03057935f, -0.10120858f, -0.16424067f, -0.18526119f, 0.01647824f, -0.00278659f, 
    -0.11317795f, -0.11011610f, -0.08675073f, -0.07451999f, -0.13616990f, 0.03429156f, 0.07694888f, -0.04155792f, 
    -0.08453413f, -0.06905861f, -0.04399288f, 0.10246647f, 0.27788126f, 0.25826588f, 0.26529655f, 0.19558699f, 
    0.13538460f, -0.08965635f, 0.19174467f, -0.00410229f, 0.13766955f, 0.03249489f, 0.26433897f, 0.04077944f, 
    0.28180256f, 0.05073402f, 0.19653927f, -0.06250317f, -0.39214912f, -0.15611313f, 0.11609364f, -0.16528398f, 
    -0.14369862f, -0.17540629f, -0.03849051f, 0.16683078f, 0.14770968f, 0.03300717f, 0.01693570f, -0.23989470f, 
    -0.31136423f, -0.04073089f, 0.05828897f, 0.03197561f, 0.02199212f, 0.12853047f, -0.01960116f, 0.18499656f, 
    0.07063510f, -0.15617588f, 0.03587387f, 0.07373624f, -0.32924670f, -0.14422120f, 0.08552942f, -0.29208779f, 
    -0.12298029f, 0.25555933f, -0.22896788f, 0.08289107f, 0.05847630f, 0.03458115f, 0.04915500f, -0.10070375f, 
    0.11375260f, -0.16145061f, -0.02233367f, 0.23841925f, 0.02712434f, 0.09816448f, 0.06571431f, 0.18168487f, 
    0.09445454f, 0.15559354f, 0.00776197f, 0.12916183f, -0.31473541f, 0.03592490f, -0.08027522f, 0.36226776f, 
    0.13271856f, -0.05207436f, 0.01846647f, 0.01644726f, 0.08557607f, 0.16944651f, 0.21007410f, 0.15551907f, 
    -0.11111806f, -0.01899085f, -0.00032587f, -0.11432991f, -0.10423078f, 0.04286692f, 0.02106269f, -0.07908384f, 
    0.05988663f, 0.05589843f, 0.06246904f, -0.03729432f, -0.09644572f, -0.07656778f, -0.07539450f, 0.01244405f, 
    -0.00121741f, -0.09334202f, -0.08531824f, -0.08229887f, -0.04597460f, -0.00364393f, 0.03644286f, -0.10623527f, 
    -0.07554010f, -0.08306815f, -0.03539871f, -0.03485690f, -0.00061628f, 0.04322735f, -0.01817502f, -0.00895480f, 
    -0.01355606f, 0.03101960f, -0.10580117f, -0.12706001f, -0.15822212f, -0.03222283f, -0.15032808f, -0.01079402f, 
    -0.08102568f, -0.02415918f, -0.02294290f, -0.04893894f, 0.04043924f, 0.01529342f, 0.05920102f, 0.01851664f, 
    -0.05436135f, -0.10177992f, -0.09601683f, -0.02463688f, -0.09892555f, -0.08766586f, -0.01936106f, -0.04946266f, 
    -0.03815220f, -0.03907578f, -0.04230672f, -0.07326279f, -0.00208175f, -0.09008166f, -0.06500442f, -0.08225026f, 
    -0.05506783f, -0.00932684f, -0.04949503f, -0.02462806f, -0.04493476f, 0.02312734f, -0.09230208f, -0.00684266f, 
    -0.06773686f, -0.08892842f, -0.03232247f, -0.07749487f, -0.02714379f, -0.05827706f, 0.02485712f, 0.03108793f, 
    -0.01235750f, -0.08526824f, -0.00879044f, -0.00280573f, 0.01851830f, -0.01011446f, -0.04597661f, 0.02099432f, 
    -0.00303356f, -0.01672708f, -0.02115898f, 0.01867999f, -0.05358144f, -0.00067208f, 0.04220800f, -0.02358821f, 
    0.07821094f, -0.06888815f, -0.03851319f, -0.08228808f, 0.02574045f, 0.03930639f, 0.02751753f, -0.15161105f, 
    0.01658382f, -0.04113618f, -0.03038241f, -0.01621203f, 0.00334567f, -0.09262169f, 0.03297993f, -0.04205896f, 
    -0.01530545f, 0.02575799f, -0.00011846f, 0.02132568f, -0.04642829f, -0.12595995f, -0.09274386f, -0.04779138f, 
    -0.00115991f, -0.10762138f, -0.09342698f, -0.03482702f, -0.14204453f, -0.02992148f, -0.11491710f, -0.06657009f, 
    -0.00932043f, -0.09955446f, -0.06678966f, -0.02927690f, 0.04536089f, -0.05065022f, 0.02613442f, 0.05223867f, 
    -0.01857114f, 0.05110079f, -0.06365189f, -0.01017761f, 0.01034187f, 0.09454586f, 0.05863333f, 0.02361702f, 
    -0.00873113f, -0.01145887f, 0.02502039f, -0.08111621f, -0.07589377f, 0.01470192f, -0.00675705f, -0.00034287f, 
    0.05616633f, -0.05401843f, -0.04280554f, 0.02086964f, -0.14229035f, -0.10101178f, -0.09094036f, -0.07999887f, 
    -0.00870107f, -0.06595972f, -0.07683070f, -0.02162578f, -0.08241590f, -0.01201359f, 0.00034136f, -0.02445789f, 
    -0.05343866f, -0.09664834f, -0.01799892f, -0.04254841f, -0.01121559f, -0.12012935f, -0.04110112f, -0.10618046f, 
    -0.05401376f, 0.04868780f, 0.04659851f, 0.01106530f, -0.08236693f, -0.10210436f, 0.03776537f, 0.00087244f, 
    -0.00250164f, -0.03442390f, -0.03558346f, -0.08019029f, 0.00580732f, -0.03165373f, -0.05353536f, -0.03885389f, 
    -0.00672631f, 0.03151705f, 0.01326139f, 0.00228310f, -0.04892747f, -0.06647763f, -0.02958147f, 0.04833248f, 
    -0.01060409f, 0.07020330f, 0.00462802f, -0.10095464f, -0.09029843f, 0.04042470f, -0.04153839f, -0.09775553f, 
    -0.00818171f, 0.04523671f, -0.03929158f, -0.06926128f, 0.02814481f, 0.00424002f, 0.01142415f, -0.09777132f, 
    0.01494148f, -0.06422617f, 0.01228842f, -0.01258705f, -0.03763865f, -0.04544253f, -0.04749775f, -0.03169705f, 
    -0.09468085f, -0.09093481f, -0.07134768f, -0.03141318f, -0.06665204f, 0.03799522f, -0.00722954f, 0.03057813f, 
    0.03446401f, -0.04748878f, -0.06141406f, -0.04163372f, -0.03166788f, 0.01602606f, -0.02693254f, -0.00266460f, 
    -0.02157753f, 0.01008837f, 0.03624953f, -0.06854897f, 0.03088298f, 0.03056940f, 0.03669066f, -0.02236669f, 
    -0.07785549f, -0.09065683f, -0.01188572f, 0.03343249f, -0.08638377f, -0.01442303f, -0.04280687f, 0.01326851f, 
    -0.00694599f, 0.00382965f, -0.00208206f, -0.03987036f, -0.07960150f, 0.02114190f, -0.06729318f, -0.06390741f, 
    -0.09253827f, -0.04316636f, -0.08682856f, -0.07659058f, -0.07068304f, -0.10088988f, -0.04345263f, 0.01113946f, 
    -0.09799089f, -0.08736035f, -0.00210367f, -0.07552200f, 0.00876236f, -0.05709632f, -0.08423043f, 0.00580985f, 
    -0.07572820f, -0.00641710f, 0.05466183f, -0.03318292f, -0.03608673f, -0.02905088f, -0.03398218f, -0.03994982f, 
    -0.06451865f, -0.02198949f, -0.07693776f, -0.00303660f, 0.00298864f, -0.04613810f, -0.03353804f, 0.01110067f, 
    -0.02406547f, -0.06788985f, 0.00662625f, -0.00465825f, -0.01833448f, 0.02829545f, -0.04658199f, -0.01649632f, 
    -0.05064014f, -0.07877473f, 0.01210380f, -0.06560861f, -0.08320512f, 0.01562143f, 0.02873839f, -0.01043037f, 
    -0.04198049f, -0.03861559f, 0.03507570f, -0.08330253f, -0.01715709f, -0.00029457f, -0.04388550f, -0.09314471f, 
    0.01686805f, -0.07247319f, -0.07717609f, -0.07772581f, 0.01329713f, -0.04693114f, -0.01434077f, -0.04634208f, 
    -0.06364268f, -0.07025889f, 0.04916169f, -0.04415008f, -0.09856876f, 0.00604562f, -0.07367991f, -0.06335025f, 
    -0.01924956f, -0.00089788f, -0.09625480f, -0.10225464f, 0.01538734f, -0.01632402f, -0.02846069f, -0.10245604f, 
    -0.04291629f, -0.03894944f, -0.01184542f, -0.00143431f, 0.00734803f, 0.01691717f, -0.02559341f, 0.04213808f, 
    -0.07968359f, 0.04068626f, -0.02739081f, -0.00940305f, -0.06252868f, -0.05801536f, -0.03926163f, 0.01179761f, 
    0.02292581f, -0.08734713f, -0.09294989f, 0.01344697f, 0.02872928f, 0.02509490f, 0.03903905f, 0.01855504f, 
    0.02854394f, 0.04178813f, -0.01223719f, -0.04053926f, -0.04969338f, -0.00168271f, -0.02986977f, 0.04423461f, 
    -0.09511083f, -0.06639755f, -0.08182945f, -0.04255162f, -0.03130493f, -0.06525759f, -0.03030938f, -0.04886677f, 
    0.04794984f, 0.00957371f, -0.27695182f, 0.24463968f, 0.09101195f, 0.01196536f, 0.11223236f, -0.10740376f, 
    -0.06812025f, 0.01610805f, 0.03785317f, 0.05772051f, 0.36639372f, 0.12032460f, -0.33697972f, 0.14945218f, 
    0.17120522f, 0.02259610f, 0.20700713f, -0.04080728f, 0.02791080f, 0.12048047f, 0.17359281f, 0.05106421f, 
    -0.49639398f, -0.23198809f, 0.30267799f, 0.17253724f, -0.08503610f, -0.07240836f, -0.20380840f, 0.05632744f, 
    -0.08747750f, 0.00163255f, -0.00261294f, -0.12191802f, 0.35526198f, 0.11840383f, -0.20429941f, 0.31254250f, 
    0.08347318f, 0.03387073f, 0.11407693f, -0.04376449f, -0.07272716f, 0.07906684f, 0.01516097f, -0.12612209f, 
    -0.06533258f, -0.04283513f, 0.06493329f, 0.32539925f, 0.21896432f, 0.04823986f, -0.00148099f, 0.01199734f, 
    -0.07976031f, 0.05451817f, 0.02885321f, 0.08937455f, -0.19401206f, 0.03255132f, -0.02822522f, -0.02147309f, 
    -0.02411886f, 0.09444281f, -0.04667168f, 0.01442778f, -0.04846792f, 0.11698829f, -0.03853487f, 0.10708231f, 
    -0.02055747f, 0.05564909f, 0.51635438f, 0.14450881f, 0.03812326f, -0.09604385f, -0.12745182f, -0.00480927f, 
    -0.23387361f, 0.01363744f, 0.04891233f, 0.00981646f, 0.13433701f, -0.07977910f, 0.01838079f, 0.00553383f, 
    0.12541524f, -0.14007200f, -0.03427491f, -0.00290704f, 0.07178099f, 0.08342925f, 0.09605294f, 0.01181733f, 
    0.05109321f, -0.17156573f, -0.24427286f, 0.03208702f, 0.10486157f, 0.06141847f, 0.04662782f, -0.04606279f, 
    -0.02415765f, -0.16854939f, 0.00251726f, -0.00943898f, -0.02281013f, -0.07787827f, -0.09325507f, -0.23619850f, 
    0.01577326f, -0.08959439f, 0.04002893f, 0.12991837f, 0.00853784f, 0.09560155f, 0.25148183f, 0.16832106f, 
    0.13622333f, -0.10057029f, 0.05051468f, -0.01400938f, 0.16306683f, 0.00240947f, 0.06554403f, -0.01690523f, 
    -0.01347284f, 0.09580928f, -0.08850784f, 0.20790455f, -0.24945967f, 0.07564719f, -0.23353848f, 0.09536797f, 
    0.12708879f, 0.05622162f, 0.10298432f, -0.05129828f, 0.05429245f, 0.05681672f, -0.14675251f, -0.04546600f, 
    -0.25697076f, -0.01914789f, 0.12367842f, 0.19818811f, -0.11452603f, -0.23089793f, 0.00309436f, 0.07833065f, 
    -0.01819072f, 0.03432525f, -0.07284537f, 0.02765809f, 0.13621166f, -0.04004985f, -0.16586898f, 0.40592802f, 
    0.02648867f, 0.27757299f, -0.15928939f, 0.04205633f, -0.16353443f, -0.12619752f, 0.06327870f, -0.04135287f, 
    0.24229392f, 0.32422647f, -0.16668287f, 0.05940617f, 0.08589080f, 0.04446503f, 0.02814120f, -0.02325117f, 
    0.02199285f, 0.01496817f, -0.04840385f, 0.01562675f, -0.00375161f, -0.03804808f, 0.06023853f, 0.11431094f, 
    0.22109428f, -0.04731338f, -0.02417604f, 0.13490170f, 0.12146847f, 0.16673426f, 0.07934151f, -0.00238155f, 
    0.02912742f, 0.00467015f, 0.54204196f, -0.02350564f, -0.19201092f, 0.00985648f, -0.03573865f, 0.03477195f, 
    0.00134640f, -0.08649335f, 0.01801367f, -0.09407821f, -0.27207875f, -0.02290783f, 0.17618649f, -0.17001134f, 
    -0.03786643f, -0.00291207f, -0.16836570f, -0.04422558f, -0.05961924f, -0.04391553f, 0.07549980f, 0.17992087f, 
    0.68772733f, 0.21898764f, -0.16928247f, -0.04629406f, -0.02009480f, 0.04950008f, 0.18918534f, 0.07897923f, 
    0.12998413f, 0.05374580f, 0.24708228f, 0.15486594f, -0.22690667f, -0.00035800f, 0.31056851f, -0.17584348f, 
    -0.02179260f, -0.12174626f, -0.16100782f, 0.09630965f, 0.14377776f, 0.10645494f, 0.04398263f, 0.02182424f, 
    0.03411187f, 0.06052577f, -0.00791314f, -0.23692191f, -0.14495687f, -0.05042961f, 0.09165133f, -0.01902450f, 
    -0.02906222f, -0.02090395f, 0.07104217f, -0.19440272f, 0.37309632f, 0.01961200f, 0.11871120f, 0.05289749f, 
    0.06405119f, 0.02638971f, -0.04181119f, -0.05257184f, 0.04063268f, -0.04147042f, -0.02678577f, -0.02253349f, 
    0.32598603f, 0.02239922f, -0.05154121f, -0.19714776f, 0.13905087f, 0.00939548f, 0.10396781f, -0.04835029f, 
    0.09157916f, 0.18232663f, -0.16674489f, -0.04968108f, 0.09898975f, 0.03923379f, 0.00027350f, 0.01817695f, 
    0.06011188f, -0.12206136f, 0.16852120f, 0.07339806f, -0.06723509f, -0.06878742f, -0.12763561f, 0.01057648f, 
    -0.10767139f, 0.05700319f, 0.26715967f, 0.02720735f, -0.09311313f, -0.07595170f, 0.06626625f, 0.13526385f, 
    0.06609380f, 0.18858042f, 0.10240263f, 0.06067768f, -0.17326196f, 0.15540563f, 0.07713238f, 0.20217854f, 
    0.10813328f, 0.08605773f, 0.02328087f, -0.06948812f, 0.03497475f, 0.00729403f, -0.03806090f, -0.07821651f, 
    -0.11057857f, -0.00856084f, 0.04450219f, 0.08253546f, -0.04488021f, -0.01684123f, -0.01030397f, 0.10045923f, 
    0.16018996f, 0.00809999f, 0.16862933f, -0.06943657f, -0.11442359f, -0.11131580f, 0.08902083f, -0.00975112f, 
    -0.15038283f, -0.08117460f, -0.02072388f, -0.06272096f, 0.07789347f, -0.09529926f, 0.11759029f, 0.03499198f, 
    0.44365042f, 0.02811125f, -0.19101121f, -0.01715693f, 0.21758816f, 0.22906516f, 0.00519884f, 0.09881248f, 
    0.06004863f, -0.12316541f, -0.09175280f, 0.02722988f, 0.01971032f, 0.20405327f, 0.22005863f, -0.29375029f, 
    -0.09205747f, -0.03824818f, -0.09507615f, 0.17462927f, 0.01992186f, 0.10257681f, 0.04894755f, -0.17274822f, 
    -0.05208800f, -0.24319524f, 0.49849924f, 0.15454181f, -0.00442067f, -0.16547538f, -0.04851091f, 0.11864870f, 
    -0.00127589f, -0.07787503f, 0.12157059f, -0.12114287f, -0.01236398f, 0.05957699f, -0.24189261f, -0.12691353f, 
    -0.12045372f, -0.14545543f, 0.01983472f, 0.08856276f, -0.06215840f, 0.01686786f, 0.03293522f, 0.06310230f, 
    0.28821406f, 0.21699230f, 0.30809718f, -0.14415552f, 0.02049166f, -0.06764134f, 0.10068110f, -0.05375659f, 
    0.05605583f, 0.00125543f, -0.07142507f, 0.10274346f, 0.03128534f, 0.30772734f, 0.12774466f, 0.17111151f, 
    -0.07412245f, 0.05285085f, 0.00269844f, 0.11302020f, 0.16127078f, 0.00921238f, -0.11469451f, 0.11464375f, 
    -0.00808420f, 0.03572799f, -0.07188140f, -0.17297432f, 0.07052305f, 0.05384438f, -0.17244449f, -0.07477340f, 
    -0.08817608f, -0.12642968f, -0.10986411f, 0.07941192f, 0.15378752f, -0.03856774f, 0.21255141f, -0.11332022f, 
    0.07741825f, -0.01737334f, 0.08030550f, -0.07157084f, 0.07950604f, -0.02478617f, 0.10198846f, 0.01240312f, 
    0.32421392f, 0.51630062f, 0.22409919f, -0.02010198f, -0.01000104f, -0.02377782f, 0.10264481f, 0.23698132f, 
    -0.00247119f, 0.00897252f, 0.06463534f, 0.07795969f, -0.28793254f, -0.61253184f, -0.29046005f, -0.00147915f, 
    -0.02722217f, 0.13714366f, 0.06301039f, -0.03654405f, 0.14649613f, -0.06932481f, -0.04341324f, -0.02645580f, 
    0.11712252f, -0.34385991f, -0.22072755f, -0.11440762f, -0.09467047f, 0.15087222f, -0.03279879f, -0.14062069f, 
    0.02967284f, -0.16332604f, -0.06222033f, -0.04734613f, -0.36272311f, -0.01376934f, 0.10019294f, 0.03319671f, 
    -0.03354596f, 0.14133444f, 0.01814215f, -0.00240087f, -0.16270776f, -0.10451644f, -0.02723797f, -0.17824256f, 
    0.30579162f, 0.20302987f, 0.28015482f, 0.14027087f, -0.06848821f, 0.08087002f, -0.02866209f, 0.17878416f, 
    0.04760871f, 0.06396812f, 0.07312803f, -0.02949311f, -0.24779381f, -0.31121767f, -0.19246691f, 0.03974645f, 
    -0.13354605f, -0.04321570f, -0.00542086f, -0.02257898f, -0.01559120f, 0.08276817f, -0.14068078f, 0.04156047f, 
    0.13675874f, 0.32505584f, 0.02031408f, 0.16522460f, 0.04795095f, 0.03720873f, -0.11387303f, -0.05610812f, 
    0.01434437f, -0.12979156f, -0.08350606f, -0.01678792f, 0.29864368f, 0.19728963f, 0.07581262f, 0.19160889f, 
    -0.04080539f, -0.05737018f, 0.03208300f, 0.07304578f, 0.18166912f, -0.10678545f, -0.03487352f, 0.05414008f, 
    -0.01490032f, 0.01722566f, -0.50898987f, -0.18170598f, -0.00963670f, 0.02827746f, 0.08177163f, -0.15389086f, 
    -0.04748432f, -0.00373018f, 0.05407111f, 0.01923854f, 0.08905334f, 0.32852221f, 0.26523170f, 0.02569167f, 
    -0.01965342f, 0.21073128f, 0.09723157f, -0.12830056f, -0.05608651f, -0.12044983f, -0.17456023f, -0.11794800f, 
    0.24194816f, 0.01039990f, 0.36345983f, 0.01806918f, -0.07249646f, 0.04919175f, 0.16741569f, -0.06028535f, 
    0.01783130f, 0.00075932f, -0.02724796f, -0.15694924f, -0.24690890f, 0.16923991f, -0.11371216f, -0.07831215f, 
    -0.10197967f, 0.22665095f, -0.00896136f, -0.00184094f, 0.02355704f, -0.01698589f, -0.02728543f, 0.00575237f, 
    0.03517675f, 0.00775987f, -0.34137157f, 0.33412784f, 0.02673932f, -0.11924413f, -0.04193990f, -0.16435929f, 
    -0.06152711f, 0.00949771f, -0.01244610f, 0.10556254f, 0.17766932f, 0.40000618f, -0.23728950f, 0.23479995f, 
    -0.00576884f, -0.01228868f, -0.08810419f, -0.07741046f, 0.12710980f, 0.03032829f, -0.06849125f, 0.00952465f, 
    -0.22724129f, -0.13027079f, 0.15513198f, 0.03500973f, -0.04864335f, -0.01547183f, -0.10917057f, 0.07429250f, 
    -0.12373774f, -0.04993136f, 0.03114075f, 0.08498437f, 0.25628957f, -0.09423565f, -0.19215560f, 0.35005072f, 
    0.01218371f, 0.01871177f, 0.21127880f, -0.17706172f, -0.07734701f, -0.02573937f, 0.00197035f, 0.01103987f, 
    0.37721524f, 0.38297006f, 0.36945012f, 0.36919817f, 0.17313328f, -0.06868466f, -0.01377048f, 0.00175196f, 
    -0.17826183f, 0.11828504f, -0.00948028f, -0.02053722f, -0.01715153f, -0.10476723f, -0.00238161f, -0.04869075f, 
    -0.10911063f, 0.10110262f, -0.01635204f, 0.15080856f, -0.11611959f, 0.08582275f, -0.02801832f, -0.00297018f, 
    0.34398687f, -0.00450885f, 0.51996386f, -0.33773464f, -0.13768630f, 0.02350420f, 0.03431837f, 0.12828708f, 
    -0.07111284f, -0.02819694f, 0.10411929f, 0.14708544f, -0.02494188f, 0.06003487f, 0.10091349f, -0.16786005f, 
    -0.16218217f, 0.04147853f, 0.05451790f, -0.06162945f, -0.15724796f, -0.03147195f, 0.06544173f, -0.11754038f, 
    -0.25386781f, 0.02947425f, -0.19434977f, 0.29261300f, 0.14217728f, 0.07993924f, -0.08784350f, 0.00115245f, 
    0.12084098f, -0.00369091f, 0.00152831f, -0.06621259f, -0.05340794f, -0.35336390f, -0.00902539f, -0.09865772f, 
    -0.03862247f, 0.09207414f, 0.23053925f, 0.09118817f, 0.11000310f, 0.07823732f, 0.03472250f, 0.08508831f, 
    -0.05035931f, -0.08763421f, 0.03658765f, 0.07219750f, 0.11733250f, 0.11190229f, 0.02277940f, -0.08798824f, 
    -0.07974185f, 0.16218591f, -0.14059794f, 0.18934859f, -0.09741882f, 0.34241569f, -0.26689532f, 0.27775899f, 
    0.00283649f, -0.06548712f, 0.14109647f, 0.00982366f, -0.23293772f, -0.04443094f, -0.14678322f, -0.09939311f, 
    0.10187043f, -0.00213264f, 0.12654781f, 0.19561982f, -0.13727742f, -0.20817049f, 0.06718186f, -0.15710600f, 
    -0.15034629f, 0.22725125f, -0.00383961f, 0.06278730f, 0.42935458f, 0.01059650f, 0.17845769f, 0.41820592f, 
    0.00805885f, 0.01000588f, 0.03608071f, -0.03465558f, -0.00814745f, -0.10733011f, -0.17300002f, 0.02789204f, 
    -0.29815945f, 0.43805304f, -0.30401689f, 0.15005474f, -0.07105678f, 0.09120674f, -0.02206544f, -0.00172384f, 
    -0.04733759f, -0.04035714f, -0.03465969f, 0.01590627f, 0.02820735f, 0.19671826f, 0.22402443f, -0.23838519f, 
    0.02288732f, 0.14475153f, -0.09879896f, 0.03341487f, -0.03293808f, 0.03957048f, 0.05329656f, -0.16424941f, 
    -0.02254973f, -0.06393285f, 0.02485542f, 0.01153470f, 0.03023515f, 0.03774497f, -0.03514773f, -0.03336946f, 
    0.02317785f, -0.06296266f, -0.03240050f, 0.00939647f, 0.00155021f, 0.03988065f, -0.01259804f, -0.00546069f, 
    -0.02741960f, -0.01895573f, -0.00616181f, -0.05961233f, -0.03785546f, -0.01566384f, -0.07143977f, 0.00737699f, 
    0.02598830f, 0.00365676f, 0.00996044f, 0.03218561f, -0.01201865f, -0.01651862f, 0.03239392f, 0.00294315f, 
    -0.00017599f, -0.00055716f, -0.02334199f, 0.04696614f, -0.05109840f, -0.02897646f, -0.00090728f, -0.01851022f, 
    0.06021205f, -0.05383899f, -0.02192046f, -0.00619163f, -0.05756542f, 0.01926465f, 0.02357680f, 0.01988255f, 
    -0.00184158f, -0.03922672f, 0.05167558f, -0.01619401f, 0.03301371f, 0.05561582f, -0.06199045f, -0.02300686f, 
    0.04556089f, -0.04960515f, -0.06618308f, -0.03756058f, -0.07414888f, -0.03622472f, 0.06226971f, -0.05255343f, 
    -0.07450286f, 0.02334849f, -0.07911983f, -0.00888726f, 0.05193179f, 0.02120236f, -0.05895571f, 0.02840108f, 
    0.00470105f, -0.05462961f, 0.06097688f, -0.07211861f, -0.05732509f, 0.00424703f, -0.06104572f, -0.01422506f, 
    0.03244466f, -0.05329661f, 0.03572351f, 0.01616805f, 0.03172804f, -0.05970474f, -0.05906343f, -0.05699603f, 
    0.01007980f, 0.00066029f, 0.01933935f, 0.04928352f, -0.05451600f, -0.00722574f, -0.00706665f, 0.04815622f, 
    -0.06955796f, 0.03405952f, -0.05450647f, -0.06894746f, -0.01829611f, 0.01898327f, -0.00959249f, 0.00281459f, 
    -0.05997983f, 0.03045705f, 0.00707498f, 0.03115696f, -0.01804250f, -0.00819443f, 0.00255646f, 0.06022617f, 
    0.02133300f, -0.00669746f, -0.07942396f, -0.06920081f, -0.04720540f, 0.02433481f, -0.01494176f, 0.01986432f, 
    -0.00271994f, -0.06362739f, 0.01638852f, -0.07019921f, 0.00750488f, -0.06530238f, -0.06751281f, -0.06384788f, 
    -0.01863108f, -0.06737850f, 0.03444965f, -0.07732221f, 0.00143805f, -0.04718505f, 0.05691213f, -0.06856731f, 
    -0.01874948f, -0.06170734f, 0.04556261f, 0.01508791f, -0.06902866f, 0.00141267f, -0.02417758f, 0.03768298f, 
    0.00197680f, 0.01166700f, -0.05093900f, -0.03964972f, -0.00501528f, -0.04424640f, -0.05434031f, -0.05036953f, 
    -0.05842264f, -0.03381115f, 0.00671759f, -0.02495239f, 0.04852265f, -0.06699525f, -0.07118437f, -0.04442123f, 
    0.03721705f, -0.01502175f, 0.00072316f, 0.01851207f, 0.00559382f, 0.03440360f, -0.02232029f, -0.01417460f, 
    -0.07459600f, -0.04103784f, -0.01562673f, -0.04387618f, -0.05252908f, 0.05720896f, -0.06087365f, -0.05969845f, 
    0.05876751f, -0.06648120f, -0.02155493f, 0.03995715f, -0.00748409f, -0.06094192f, -0.00356827f, 0.00795148f, 
    -0.00823335f, -0.00861996f, -0.02701741f, 0.03894202f, -0.02022549f, 0.05257095f, 0.00461683f, 0.04642522f, 
    -0.35733697f, -0.23584643f, 0.22369535f, 0.13061553f, 0.13034920f, 0.06564201f, 0.06195931f, -0.04811411f, 
    -0.00210141f, -0.18259037f, 0.01435240f, 0.12735541f, -0.17174092f, -0.21609522f, 0.28741279f, 0.35437986f, 
    -0.03811054f, -0.04586096f, 0.00386641f, 0.15511014f, 0.04046714f, 0.00505326f, -0.02616974f, 0.06495516f, 
    0.26747710f, 0.14637043f, -0.01696156f, 0.02847465f, 0.02035834f, 0.04335541f, -0.15419747f, -0.05582580f, 
    0.25769210f, 0.19713326f, -0.11350771f, 0.09529582f, -0.36181107f, -0.01999574f, 0.06960478f, -0.04410388f, 
    0.16955224f, -0.07449181f, -0.04849571f, -0.05700390f, -0.07425672f, 0.00884899f, 0.15049611f, -0.01640595f, 
    -0.17599259f, 0.02004422f, 0.46768275f, 0.32740590f, 0.08069412f, 0.11685900f, -0.07034174f, 0.20192082f, 
    0.02362643f, -0.01051110f, -0.03127868f, 0.09778507f, -0.04910672f, -0.32927829f, -0.04480006f, 0.06262657f, 
    -0.33578184f, -0.22850908f, -0.11660904f, -0.01934703f, 0.05149647f, -0.20726748f, -0.00098025f, -0.09076902f, 
    0.28868800f, -0.02054988f, -0.28634083f, -0.15517026f, 0.00904242f, -0.10414422f, -0.03148151f, -0.15261799f, 
    0.11270352f, 0.01372609f, 0.10826360f, -0.05267187f, -0.15254591f, -0.12747827f, -0.33803910f, -0.24085334f, 
    0.12501840f, 0.11933466f, 0.01060917f, -0.18562724f, -0.33729622f, -0.28524604f, -0.02338722f, -0.15981157f, 
    -0.10630327f, -0.06683492f, 0.09920065f, 0.03181794f, -0.23863323f, 0.15366909f, 0.09528442f, 0.08208977f, 
    0.03577454f, -0.08585064f, 0.08447331f, -0.08100693f, 0.20937300f, 0.23840402f, -0.19922176f, -0.26107571f, 
    0.16677020f, -0.21243872f, 0.01115187f, -0.04872140f, 0.17278093f, 0.16159940f, 0.02225755f, -0.00752907f, 
    -0.17668007f, 0.04347493f, -0.06307494f, 0.24651839f, -0.02302948f, 0.13727783f, 0.06452101f, -0.02851952f, 
    -0.00018283f, 0.09649191f, 0.03225320f, -0.09184781f, -0.02594379f, -0.02361312f, 0.52284324f, -0.10949696f, 
    -0.03164583f, -0.25246221f, -0.00884106f, 0.33499452f, 0.12272721f, 0.04708221f, 0.02710832f, 0.01671723f, 
    -0.43088832f, -0.12742743f, 0.14662740f, -0.05297080f, -0.13177982f, -0.22151001f, 0.16145894f, -0.07399274f, 
    0.03661847f, -0.01285108f, 0.06669518f, 0.12488005f, -0.24679506f, 0.30074817f, 0.21679214f, 0.10587604f, 
    0.19135904f, -0.11239504f, 0.14115293f, -0.17792039f, 0.02853834f, -0.09968075f, 0.03956194f, -0.00130315f, 
    -0.17794657f, 0.05546004f, 0.05878427f, 0.12138879f, 0.03491322f, 0.26498362f, 0.07061396f, 0.04879065f, 
    -0.14357676f, -0.11602058f, -0.00387624f, 0.05746733f, 0.15108825f, 0.11389545f, -0.15568109f, 0.16351199f, 
    0.08576857f, 0.22843525f, -0.05364196f, 0.16239913f, -0.04457962f, -0.06168029f, -0.10755447f, 0.16453037f, 
    -0.02649903f, -0.07749384f, 0.04001224f, -0.01709043f, -0.06425647f, 0.02338831f, 0.06533529f, 0.02111249f, 
    0.04888866f, -0.07460810f, 0.06574546f, 0.06433953f, -0.05047200f, 0.04279093f, 0.01187520f, -0.01584800f, 
    -0.04615434f, -0.00796773f, 0.05402651f, -0.01995930f, 0.04874699f, -0.06766803f, -0.01831713f, -0.06339229f, 
    -0.07297102f, -0.05888131f, -0.02316213f, 0.03365913f, -0.07118136f, 0.05101048f, 0.02271486f, 0.03319306f, 
    0.04027170f, 0.00048962f, -0.05327257f, -0.01139389f, 0.00737465f, -0.02044082f, 0.03391715f, 0.00338389f, 
    -0.07100423f, 0.05332559f, 0.04406356f, 0.02611661f, -0.00338615f, -0.00064428f, -0.02817232f, 0.00663599f, 
    -0.04392145f, 0.00525675f, 0.04641231f, 0.00355533f, 0.01332715f, 0.03250462f, -0.00961458f, -0.06933203f, 
    -0.06913562f, -0.01342848f, -0.01252355f, -0.00225836f, -0.06288257f, -0.03228530f, -0.05597409f, 0.04415409f, 
    0.06312533f, 0.01880506f, 0.00632698f, -0.04448519f, -0.00006351f, 0.05675859f, -0.01653062f, 0.06610090f, 
    -0.02125508f, 0.06353964f, 0.04882405f, -0.02570085f, -0.01563810f, -0.00989235f, -0.04243479f, -0.01632877f, 
    0.00016462f, 0.00447228f, -0.03431811f, 0.00573591f, 0.04531093f, -0.00734857f, -0.03961253f, -0.06903111f, 
    0.02067796f, -0.04657343f, 0.06372878f, -0.05516986f, -0.00879632f, 0.03904818f, 0.04929689f, -0.00223318f, 
    0.02416137f, -0.01048836f, 0.02012566f, -0.01081596f, -0.02425881f, -0.01183051f, 0.05812688f, 0.01643536f, 
    0.01672968f, -0.03712700f, 0.00667676f, -0.06142422f, 0.01871050f, 0.00418837f, -0.04259139f, -0.04825010f, 
    -0.07517236f, -0.07388799f, -0.03243276f, -0.06378080f, 0.01445359f, 0.02736187f, 0.01521304f, 0.01578443f, 
    -0.06625962f, -0.04995040f, 0.04739615f, 0.05056634f, -0.01831958f, 0.03108418f, 0.00705814f, -0.04403235f, 
    0.02747731f, 0.00227108f, -0.00125958f, 0.01028430f, 0.01838090f, -0.04605427f, -0.04150295f, 0.05722219f, 
    -0.07553690f, 0.01033775f, -0.05095536f, -0.04404159f, -0.07045979f, -0.05501522f, -0.01666578f, -0.02892430f, 
    0.05003148f, -0.01971308f, 0.06126315f, -0.07528470f, -0.07004153f, 0.05610732f, -0.03828861f, 0.01521921f, 
    -0.04509430f, -0.03606997f, 0.03677860f, 0.00664240f, -0.01182667f, -0.05775272f, -0.04114733f, 0.03804605f, 
    -0.05554136f, -0.01545941f, -0.07352400f, 0.06154389f, 0.00337607f, -0.02550116f, 0.03072607f, -0.05198366f, 
    0.03330343f, 0.03902387f, -0.05447594f, -0.02247935f, -0.03218951f, -0.07129704f, -0.06162985f, -0.07319286f, 
    -0.03637430f, 0.00287793f, 0.00411004f, -0.06234733f, 0.06546424f, 0.05423200f, -0.02506710f, -0.07384974f, 
    0.02510770f, -0.03717447f, 0.00644525f, -0.05667774f, -0.00989532f, -0.07051479f, -0.06342363f, -0.06403617f, 
    0.32191855f, 0.26187646f, 0.03533619f, -0.22735862f, 0.10572764f, 0.04113239f, 0.03032725f, -0.11104003f, 
    -0.00726109f, -0.00079185f, 0.10529950f, -0.04823578f, -0.10467606f, 0.11550152f, -0.01124115f, -0.04969945f, 
    0.12501915f, 0.13076355f, 0.22425340f, 0.26580024f, -0.14050861f, 0.07468998f, 0.08805191f, -0.05881921f, 
    0.18479742f, -0.04778060f, -0.51657110f, 0.06168417f, -0.11690491f, -0.13464667f, 0.13495106f, 0.02148874f, 
    0.01886672f, 0.06915677f, -0.01790613f, 0.08440969f, 0.12716570f, -0.05872311f, 0.02840023f, 0.03003755f, 
    0.08249805f, 0.20872381f, 0.01194729f, 0.01101853f, 0.00530968f, 0.08867826f, -0.13496448f, -0.01965418f, 
    -0.20346719f, -0.20010903f, -0.12452993f, 0.14611520f, 0.06585650f, -0.12699169f, -0.01168094f, -0.01269285f, 
    0.01726717f, 0.01415214f, -0.17747647f, -0.19562165f, 0.12010300f, 0.08765971f, -0.17634077f, -0.28709137f, 
    0.12141024f, -0.08319813f, 0.12829094f, -0.00868967f, -0.03779985f, 0.04391918f, 0.15956707f, 0.11909939f, 
    -0.28355724f, 0.08284029f, 0.05897704f, 0.12021677f, 0.07698478f, -0.08052289f, -0.09963721f, 0.14824189f, 
    -0.13668841f, -0.01453777f, 0.04099729f, -0.01112517f, -0.13033722f, 0.00439896f, 0.06690851f, 0.08205217f, 
    -0.07732745f, 0.16446319f, 0.03432322f, -0.00712922f, 0.09665515f, -0.07542098f, -0.22153983f, 0.03700058f, 
    0.20651306f, 0.65972036f, -0.11349609f, -0.04910751f, 0.07713965f, -0.00735338f, 0.03745227f, 0.06513353f, 
    0.02942813f, 0.04580610f, -0.29294172f, 0.08972266f, 0.23870493f, 0.19033125f, 0.28908306f, -0.06201434f, 
    0.07510515f, 0.09180913f, -0.23719993f, -0.17690767f, -0.02256150f, 0.00053098f, -0.14498736f, 0.18913382f, 
    0.02678125f, 0.14784902f, 0.10155623f, -0.03213244f, -0.11307108f, 0.04958114f, 0.20668313f, 0.13393299f, 
    0.03263645f, -0.01411152f, 0.24612227f, 0.04739571f, -0.03683320f, 0.71755570f, -0.26906857f, -0.14453700f, 
    -0.02945490f, 0.05852097f, -0.02797845f, 0.08381327f, -0.00775029f, 0.01243754f, -0.05912097f, -0.01003292f, 
    -0.14355858f, -0.18730406f, -0.06797244f, -0.01469892f, 0.15566881f, 0.23143345f, -0.23498671f, 0.12101833f, 
    -0.06713398f, 0.00144393f, 0.19696300f, -0.42357612f, -0.00752516f, -0.18017875f, -0.11165489f, -0.03869749f, 
    0.08812776f, 0.01586716f, -0.18849725f, 0.13442992f, -0.03403591f, -0.01624250f, -0.10189643f, 0.06961895f, 
    0.19158043f, -0.07661200f, 0.16233002f, -0.15241762f, 0.14826699f, 0.29014838f, -0.16523281f, -0.14742841f, 
    -0.15479669f, -0.07580114f, -0.07763327f, 0.01044930f, 0.00538505f, -0.06029826f, 0.53234529f, -0.12373263f, 
    -0.32217142f, -0.27887359f, 0.42176867f, 0.04785310f, 0.02666253f, -0.10234260f, 0.04486384f, -0.14448331f, 
    -0.02825374f, 0.02341834f, -0.02573215f, 0.00634091f, -0.01430376f, 0.02227521f, 0.06614681f, 0.02911410f, 
    -0.05714244f, 0.03284014f, -0.06140243f, 0.04281622f, -0.01748524f, 0.03410874f, -0.01793659f, 0.03957906f, 
    0.01208035f, -0.06709711f, -0.05975201f, -0.05382875f, -0.06448161f, 0.03775100f, 0.05129977f, 0.01060952f, 
    -0.05511989f, -0.04708342f, -0.07086912f, 0.01814089f, -0.06945781f, 0.01469492f, -0.00626474f, -0.06157408f, 
    -0.02801968f, 0.05738438f, -0.00788704f, 0.00941339f, -0.01897513f, -0.06098403f, 0.02268821f, -0.05056753f, 
    -0.04275558f, -0.03022339f, -0.04540410f, -0.05219779f, -0.00260913f, 0.02943190f, -0.03633033f, 0.04537816f, 
    0.01166010f, 0.05796697f, -0.01115895f, 0.04899067f, 0.02563436f, -0.03867337f, 0.02448240f, -0.02119920f, 
    0.04592573f, 0.00889420f, 0.01449914f, 0.05168089f, 0.02171288f, 0.00833298f, 0.01615053f, -0.02075784f, 
    -0.01375043f, -0.03680533f, 0.06208629f, -0.01437936f, -0.02626486f, -0.06372352f, 0.05543274f, -0.00557792f, 
    -0.06989331f, -0.04187079f, -0.06612182f, 0.01161281f, 0.06849947f, -0.01435081f, -0.04278930f, -0.01103770f, 
    -0.04784982f, -0.04826254f, -0.06916475f, -0.03630387f, -0.06180812f, 0.01430968f, -0.04216391f, -0.01073863f, 
    0.02049095f, -0.05548322f, -0.01787213f, 0.05240874f, -0.04679945f, 0.05460037f, -0.02361915f, -0.03061217f, 
    -0.01520657f, 0.05426056f, -0.04405975f, 0.06212138f, 0.01559042f, -0.01593373f, -0.05572112f, 0.02697346f, 
    0.01241502f, 0.06293376f, 0.03927235f, 0.02443844f, 0.06802771f, 0.05051928f, -0.00518236f, -0.03823023f, 
    0.00329240f, -0.05065581f, -0.04784130f, -0.04867649f, -0.03597584f, -0.04743633f, 0.01182675f, 0.06578617f, 
    0.00383415f, -0.02374008f, -0.06631956f, 0.03310796f, 0.04672527f, -0.04860832f, 0.03541234f, -0.02268174f, 
    -0.04607503f, 0.01555772f, 0.00005783f, -0.03612367f, -0.00124129f, -0.04247570f, -0.05032244f, 0.05911708f, 
    -0.03227979f, -0.02966794f, 0.07152345f, 0.04732670f, -0.00529251f, 0.04415027f, 0.00038258f, -0.00543605f, 
    0.03703902f, 0.01175554f, -0.03887608f, -0.01324453f, 0.00555525f, -0.05749837f, 0.00383283f, -0.04624295f, 
    -0.06690571f, 0.00338807f, -0.00704337f, -0.02392310f, -0.03584092f, -0.05454253f, -0.07149215f, -0.00730721f, 
    0.04468253f, 0.01294068f, -0.05957105f, 0.02716685f, -0.00724291f, -0.04748463f, -0.02988289f, -0.04851916f, 
    -0.05002768f, 0.04604720f, -0.04894565f, -0.01367560f, 0.01721813f, 0.04063757f, -0.05387757f, -0.03370854f, 
    0.05425550f, -0.02848491f, -0.02427795f, 0.03407999f, -0.00618734f, -0.00444721f, 0.01454191f, -0.07050953f, 
    -0.01321298f, -0.04599797f, 0.03914050f, -0.04619268f, -0.00367776f, 0.02970114f, -0.03792347f, -0.05816412f, 
    -0.13489993f, 0.13359776f, -0.02380095f, 0.20490608f, 0.03542877f, -0.16487463f, -0.00389774f, -0.26960459f, 
    0.01262267f, -0.00178234f, -0.06924240f, 0.15574610f, -0.03951776f, 0.19812335f, -0.33711001f, -0.06380097f, 
    0.11200001f, 0.01072744f, -0.08764858f, 0.04382041f, 0.07810350f, -0.07248793f, -0.09179206f, 0.06733416f, 
    0.51911759f, 0.07327597f, 0.28816733f, 0.16151334f, -0.01460819f, -0.03724675f, 0.08869702f, 0.10906783f, 
    -0.08302990f, -0.04222595f, -0.14838958f, -0.09410084f, -0.01521917f, -0.02766901f, -0.02563182f, 0.13475482f, 
    -0.17149408f, -0.10196969f, -0.01204730f, -0.02558795f, -0.04134107f, -0.00544114f, 0.16160718f, 0.12147063f, 
    0.13937782f, 0.25508204f, 0.46930441f, 0.33369857f, 0.14401758f, -0.05042877f, 0.03815141f, 0.12607919f, 
    0.01655378f, 0.06611887f, 0.05041451f, -0.03278815f, 0.27702421f, -0.00086709f, 0.03510435f, -0.10400404f, 
    -0.13073024f, -0.02332156f, -0.00811938f, 0.00729542f, -0.04504119f, 0.17144555f, 0.02330924f, 0.01896766f, 
    0.64216679f, 0.16793361f, 0.61332220f, 0.09410983f, -0.08124883f, 0.02977604f, 0.04188371f, -0.00266622f, 
    -0.07199404f, 0.07603416f, -0.01925992f, 0.15548739f, 0.03049981f, -0.05823299f, -0.03052469f, -0.17422760f, 
    0.01442333f, 0.12101065f, -0.08532076f, -0.02139312f, 0.00884484f, 0.04342123f, 0.02725559f, 0.10329898f, 
    -0.42885751f, -0.26198861f, -0.12847419f, -0.02154949f, -0.00411121f, 0.03196122f, -0.07810012f, 0.23518866f, 
    0.08050977f, -0.00575457f, -0.03614273f, -0.14771193f, -0.02075779f, -0.13163775f, -0.05039010f, -0.00599628f, 
    -0.08196981f, 0.03538640f, 0.10464758f, -0.13626131f, 0.12913634f, 0.02970253f, 0.02400098f, 0.13961048f, 
    0.05840003f, 0.03222451f, 0.14728737f, 0.03188186f, 0.09748193f, 0.15966287f, 0.20108154f, 0.12117805f, 
    0.05429188f, 0.06432420f, -0.01795965f, 0.09236825f, -0.31071281f, 0.02618347f, -0.59238672f, -0.31132755f, 
    -0.13471839f, -0.19080898f, -0.05447313f, 0.14367789f, -0.15680428f, 0.00175540f, 0.02000754f, -0.11627761f, 
    0.20584787f, 0.08315549f, 0.21751387f, -0.03412142f, -0.05396805f, 0.05302310f, 0.11531464f, -0.04787214f, 
    -0.06124567f, 0.06421778f, 0.04057502f, 0.11252031f, 0.20108104f, 0.11967672f, 0.19759108f, -0.10913518f, 
    -0.16149031f, 0.15367424f, 0.17665313f, 0.26353028f, -0.03616656f, -0.03045950f, -0.03657734f, 0.09217329f, 
    -0.40883750f, 0.26160556f, -0.12036578f, 0.41361582f, -0.08838113f, 0.16358678f, 0.20142369f, 0.10120512f, 
    0.00136470f, 0.07885651f, 0.11529501f, 0.03943557f, -0.05204422f, -0.11327270f, 0.13880008f, -0.23825134f, 
    -0.21091612f, 0.03487547f, -0.04835214f, 0.00593086f, 0.05532864f, 0.07748891f, 0.26621470f, -0.05858871f, 
    -0.02825064f, -0.06184117f, -0.04244208f, -0.01228956f, -0.02780503f, -0.01440327f, 0.00687187f, -0.01487227f, 
    -0.01882680f, 0.04732489f, -0.02066912f, -0.06492760f, 0.00584278f, -0.01172939f, -0.06691326f, 0.03399250f, 
    0.05653523f, 0.02603820f, -0.06217176f, -0.07223386f, -0.04899835f, 0.03895039f, -0.05521820f, -0.02722790f, 
    -0.00607452f, -0.02083045f, -0.06954464f, -0.06124481f, 0.02017317f, -0.06368818f, 0.01090822f, 0.05551643f, 
    -0.06658848f, 0.05646215f, -0.06237294f, 0.01069351f, -0.04837220f, 0.05676385f, 0.04045619f, -0.04594180f, 
    0.03961281f, -0.00927675f, -0.05736957f, 0.02842171f, -0.00983504f, -0.07493073f, -0.00626138f, -0.05702243f, 
    0.02694132f, 0.03398684f, -0.07070765f, -0.01882818f, 0.00811068f, -0.04591142f, -0.05360429f, 0.01628171f, 
    -0.00699509f, -0.02395577f, 0.02358207f, -0.07191058f, -0.03437250f, 0.05613757f, -0.01503426f, -0.02977129f, 
    -0.07884399f, -0.07543353f, -0.03105982f, 0.02622651f, -0.07209048f, 0.00521915f, -0.05812883f, -0.05336418f, 
    -0.00311274f, -0.02003155f, -0.05566152f, -0.06126083f, 0.05644412f, -0.08271281f, 0.00960054f, 0.00754106f, 
    -0.07790332f, 0.01199124f, -0.04244942f, -0.03996618f, -0.01288239f, 0.06991249f, -0.00281087f, -0.01545991f, 
    0.04541537f, 0.05120743f, 0.01535593f, 0.02610608f, 0.02150224f, 0.03696758f, -0.00210650f, 0.00397644f, 
    0.04775108f, 0.01817122f, -0.05782159f, -0.07997376f, -0.03117876f, 0.00241704f, 0.01161133f, 0.01343315f, 
    0.03383799f, 0.04649924f, 0.03937809f, -0.06043276f, -0.01930176f, 0.04333883f, 0.01256859f, -0.00465748f, 
    0.05372411f, -0.03985105f, -0.03762323f, -0.07028017f, 0.06387870f, 0.05338697f, -0.02160728f, -0.00930089f, 
    0.04058464f, -0.04541196f, -0.03278881f, 0.06115560f, 0.00900659f, -0.06227747f, -0.00756506f, 0.04697539f, 
    0.02402920f, 0.04630161f, 0.03444138f, -0.05774419f, 0.03782362f, -0.06437942f, -0.00455954f, -0.00983081f, 
    0.05538968f, -0.02428999f, 0.01168801f, 0.01361700f, -0.03762258f, 0.03554308f, 0.00025805f, -0.06434329f, 
    0.06142354f, 0.01765057f, 0.02524369f, 0.04577979f, 0.05650182f, -0.05057882f, -0.05869866f, 0.03674126f, 
    -0.03162405f, 0.06306164f, -0.04742420f, -0.08000801f, -0.03546043f, -0.01388012f, -0.00692383f, -0.05452325f, 
    -0.01895023f, 0.01542643f, 0.06337625f, 0.02330982f, -0.05000404f, 0.03987956f, 0.04486315f, 0.06517806f, 
    -0.08089529f, -0.07545770f, -0.03931377f, 0.05677352f, 0.02968488f, 0.02970628f, 0.01781669f, 0.05627627f, 
    -0.01917300f, -0.03903224f, 0.05070661f, 0.00479437f, -0.06990554f, 0.00494523f, 0.03198538f, -0.04935176f, 
    -0.03399502f, 0.05999549f, 0.00295719f, 0.02787042f, -0.07544012f, -0.01937044f, -0.05688091f, -0.00562482f, 
    0.03759518f, -0.01430832f, -0.10363697f, 0.04553969f, 0.10314164f, 0.03354214f, 0.19850296f, 0.07293942f, 
    -0.02182754f, 0.14342465f, 0.13654056f, 0.07792380f, 0.27884197f, -0.17525019f, -0.03786678f, -0.00803559f, 
    0.15949804f, 0.07967621f, 0.06443997f, 0.18192250f, -0.07641868f, -0.10457177f, -0.19321629f, -0.19028971f, 
    -0.20071667f, -0.09781641f, 0.13883486f, 0.11835758f, -0.13355871f, 0.04078627f, -0.01864085f, -0.02838531f, 
    0.08686139f, -0.13956417f, -0.22601511f, -0.37065822f, 0.21291845f, 0.33535507f, -0.01910146f, 0.10559833f, 
    0.18725273f, 0.00666307f, 0.00009410f, 0.05123813f, 0.06890174f, -0.02994743f, -0.03754504f, -0.11464117f, 
    -0.10598854f, -0.31298655f, -0.19719404f, -0.04331427f, -0.03287793f, 0.07215907f, -0.13225080f, 0.12402858f, 
    0.11671294f, -0.15423498f, -0.09361739f, 0.07987255f, -0.26197487f, 0.17607912f, -0.06787222f, -0.05261465f, 
    -0.01757747f, -0.09387124f, 0.02070196f, -0.10473244f, 0.04941323f, 0.08643515f, 0.14842707f, 0.22448504f, 
    -0.20380045f, 0.16496497f, -0.06397174f, 0.70863605f, -0.05524358f, 0.04183953f, 0.00699360f, -0.03116953f, 
    0.02176174f, -0.09415627f, 0.13038598f, 0.30856651f, 0.02218252f, -0.00903267f, -0.05851301f, 0.07960984f, 
    0.07017441f, 0.19573809f, -0.14571175f, -0.07313580f, 0.10361919f, 0.13283135f, 0.19741781f, 0.27274844f, 
    0.04262363f, -0.30285013f, -0.13744549f, -0.22283061f, 0.10833445f, 0.05813166f, 0.13696551f, 0.09472595f, 
    -0.16475613f, -0.28172258f, -0.08194260f, -0.10387366f, 0.07109211f, 0.16812891f, 0.11225384f, -0.00936327f, 
    -0.15207887f, -0.08166852f, -0.11811428f, -0.02609420f, 0.12354622f, 0.14920563f, 0.14584203f, 0.07216734f, 
    0.20139483f, -0.02535229f, 0.03187487f, 0.06958744f, 0.19859269f, 0.10644907f, 0.03914410f, 0.14115420f, 
    0.07158768f, -0.14357522f, -0.11931878f, -0.08845465f, 0.20745485f, -0.43982843f, -0.01453603f, -0.26930618f, 
    -0.04861981f, -0.04982167f, -0.15991646f, 0.07533228f, 0.00258365f, 0.05207511f, -0.09498349f, -0.14161593f, 
    -0.53384620f, -0.06406478f, 0.03832834f, -0.21414514f, 0.05321285f, -0.11278751f, -0.09536541f, -0.07306857f, 
    0.03902500f, -0.08269441f, 0.21917577f, 0.03958828f, 0.04376434f, 0.01083991f, -0.09784009f, 0.07274576f, 
    0.00429186f, 0.17274959f, 0.14458489f, 0.19300459f, 0.10297099f, 0.09553365f, 0.04460829f, 0.15644580f, 
    0.14736556f, 0.05532394f, -0.16009310f, 0.12059711f, 0.10734361f, 0.10838260f, 0.33852214f, 0.02878452f, 
    0.13306308f, 0.10200981f, 0.03860672f, 0.11431887f, 0.15622306f, -0.03314251f, 0.05661570f, 0.23082912f, 
    -0.01392213f, -0.01906068f, 0.02830805f, -0.00991395f, 0.14403287f, 0.05005858f, 0.09774505f, 0.18020999f, 
    0.07005052f, 0.20557642f, 0.08031068f, -0.15850902f, -0.01174014f, 0.12139127f, 0.09328982f, 0.05927170f, 
    0.08783715f, -0.14447759f, -0.03389983f, -0.01971802f, 0.09472712f, 0.09484701f, 0.02796714f, -0.24988893f, 
    0.03901304f, -0.03516053f, -0.18408643f, 0.13451676f, 0.07446167f, -0.09144735f, -0.04803426f, -0.12418871f, 
    0.23728737f, -0.00238157f, -0.07519722f, -0.12473808f, -0.09471730f, 0.04080983f, 0.07374085f, 0.06723210f, 
    -0.06645811f, -0.14967437f, -0.28220993f, -0.26881760f, 0.05119206f, 0.15488361f, 0.21831280f, -0.22060721f, 
    -0.07826795f, -0.08568648f, -0.09514355f, 0.16827576f, 0.02812044f, -0.09009079f, -0.10012197f, -0.06527422f, 
    0.04021529f, -0.02858597f, -0.10980218f, -0.06478091f, 0.00686833f, 0.06845428f, 0.08948039f, 0.03435825f, 
    0.11237247f, -0.06004155f, -0.10318874f, 0.01135543f, 0.20188865f, 0.09102011f, 0.02889920f, 0.04911896f, 
    -0.22713117f, -0.15833807f, -0.09097714f, -0.19482253f, 0.12413803f, 0.15928653f, 0.06553382f, 0.10465706f, 
    0.25901392f, 0.15992531f, 0.20198551f, 0.41720083f, -0.02357464f, 0.02878567f, 0.05147544f, 0.03886720f, 
    0.16148999f, -0.01652119f, -0.06636653f, 0.26282233f, 0.01800209f, -0.32425794f, 0.18632691f, 0.04609093f, 
    0.09677354f, 0.14124210f, -0.07695413f, 0.02026867f, 0.04816273f, 0.09067222f, -0.11922900f, 0.09947166f, 
    -0.01747398f, 0.02347759f, 0.19388048f, -0.18250035f, 0.03542225f, -0.14515445f, -0.03921175f, -0.11931297f, 
    -0.19164446f, -0.08928481f, -0.01390350f, -0.02493510f, -0.18854737f, -0.07218709f, 0.10085757f, 0.40521988f, 
    -0.28090271f, -0.09091955f, -0.07974405f, -0.01975807f, 0.31170592f, -0.00200173f, 0.01290872f, 0.14802155f, 
    0.21880105f, 0.17486253f, 0.28023008f, -0.09049480f, 0.04765327f, 0.18288663f, 0.06541620f, 0.13360433f, 
    0.16547261f, -0.20158993f, -0.00669594f, -0.14903042f, -0.19918329f, -0.22855221f, -0.07695173f, -0.04480910f, 
    -0.04526960f, -0.14477974f, -0.19923751f, -0.01052442f, -0.01271238f, -0.02090243f, 0.03016447f, 0.05863270f, 
    -0.14231198f, -0.22733501f, -0.25176454f, -0.29248029f, 0.09577432f, 0.31557542f, -0.01297064f, 0.03195783f, 
    0.09309458f, 0.07269938f, 0.10121274f, 0.24627294f, 0.10418999f, 0.02067540f, 0.22596596f, -0.40060484f, 
    -0.24174559f, 0.12365519f, 0.03547879f, 0.10723060f, -0.10032510f, -0.01995304f, -0.04734688f, -0.00586015f, 
    0.15284054f, 0.08645984f, 0.07445542f, 0.16626638f, 0.11798393f, 0.06362030f, 0.22832121f, 0.03806784f, 
    0.20048934f, 0.07352172f, 0.10876925f, 0.17410958f, -0.40903053f, -0.09549136f, -0.18416746f, 0.08555934f, 
    -0.00538633f, -0.03235823f, -0.03502206f, 0.07954542f, 0.02607726f, -0.02748689f, 0.10806254f, 0.08930767f, 
    -0.19520916f, 0.01433247f, 0.15758389f, 0.31848806f, -0.14089918f, 0.02932216f, -0.14894480f, -0.04214624f, 
    0.00895079f, 0.03292325f, -0.01985665f, 0.02123239f, -0.12420010f, 0.01640643f, 0.12361063f, 0.02567416f, 
    0.05830073f, -0.14916021f, 0.01004357f, 0.05129383f, 0.15861951f, -0.00442578f, -0.05790462f, -0.12999520f, 
    0.27600047f, 0.07909399f, -0.03923422f, -0.01201424f, -0.06024265f, -0.13346240f, 0.08450637f, -0.04544383f, 
    0.08202105f, 0.07064057f, 0.09832068f, 0.17656855f, -0.24055561f, -0.29060343f, 0.07909749f, 0.16037795f, 
    -0.00593135f, 0.11209115f, 0.11065920f, -0.05089342f, 0.03274344f, -0.09082645f, 0.03653821f, 0.06540097f, 
    0.22272141f, 0.22873063f, 0.12682153f, 0.11667662f, 0.02038145f, -0.00568609f, 0.11033959f, 0.08068254f, 
    -0.09396105f, 0.05397069f, 0.06930698f, -0.08777095f, 0.16909558f, 0.16717632f, 0.03444165f, -0.24987841f, 
    0.01144879f, -0.05065883f, -0.00053653f, -0.05959255f, 0.08521365f, -0.07313864f, 0.02563912f, -0.03399911f, 
    0.21978845f, 0.14721534f, 0.13981418f, -0.46187547f, 0.04405072f, -0.02694927f, 0.02477834f, -0.00044638f, 
    0.07700220f, 0.13120098f, -0.13366412f, -0.05028103f, 0.12294846f, 0.20901465f, -0.05164339f, -0.14170550f, 
    -0.10259370f, -0.02311521f, 0.10625187f, 0.08757981f, 0.03611185f, -0.07215729f, -0.01637937f, -0.03320623f, 
    -0.13330913f, 0.12619297f, 0.03442707f, 0.13443235f, -0.01010838f, -0.06492548f, -0.17002454f, 0.19856019f, 
    0.04199534f, 0.15158932f, 0.08465333f, 0.11576230f, 0.06311799f, -0.07038116f, 0.16274582f, 0.07975324f, 
    0.00156500f, 0.08248270f, -0.01979258f, -0.17402261f, 0.07411092f, 0.11643775f, -0.05223930f, 0.03936211f, 
    -0.16597231f, -0.09398271f, -0.09430479f, 0.08149352f, -0.03813297f, 0.09347887f, 0.04546307f, 0.01407095f, 
    -0.01070619f, 0.09579203f, 0.14645503f, 0.02513503f, 0.09742586f, 0.10147914f, 0.04488724f, 0.03269511f, 
    -0.04092779f, -0.03722926f, -0.10531799f, -0.07011420f, -0.13466169f, 0.02988224f, 0.28316963f, 0.09769373f, 
    0.30655813f, 0.05406025f, 0.27269599f, -0.02819116f, 0.11743277f, 0.10495847f, 0.16973424f, -0.03596685f, 
    0.07978310f, 0.09590420f, 0.04866523f, -0.15594295f, 0.12748580f, 0.02585823f, 0.31256914f, -0.04882665f, 
    -0.01006125f, -0.23466407f, 0.17032261f, 0.18690482f, -0.08270130f, 0.02623298f, -0.05066162f, 0.06562270f, 
    -0.43351686f, -0.06492858f, -0.14182270f, 0.24306406f, -0.12328915f, -0.04114018f, -0.12348013f, 0.18769860f, 
    -0.15960662f, -0.07081529f, -0.01022410f, -0.02022623f, 0.52756751f, 0.27885163f, 0.25750157f, -0.17078814f, 
    -0.10075660f, -0.01307520f, -0.05566134f, -0.21325016f, -0.03729944f, 0.00258776f, 0.01418466f, 0.05957664f, 
    0.13325940f, -0.54351997f, -0.05020518f, -0.20036499f, -0.05255796f, -0.12786542f, -0.02108220f, -0.10817561f, 
    -0.09352440f, -0.04843184f, -0.10287740f, 0.09236839f, -0.07696076f, -0.22290958f, -0.30724549f, 0.21551166f, 
    -0.04241706f, 0.05340796f, 0.17063713f, 0.02791203f, -0.06077105f, 0.01060042f, 0.05279753f, 0.08165388f, 
    0.00290836f, 0.13161567f, 0.13101155f, 0.10905807f, 0.00967951f, -0.01303785f, -0.03542664f, 0.04012727f, 
    0.18698472f, 0.18588926f, 0.20451207f, 0.17585944f, 0.41756570f, 0.00592118f, -0.18558617f, 0.05184348f, 
    0.33205810f, 0.08539302f, 0.12203044f, -0.07061324f, -0.12563507f, 0.00423828f, -0.08865113f, 0.09600145f, 
    -0.02970256f, -0.08176984f, 0.22872145f, 0.16820467f, 0.10010867f, -0.09056406f, 0.14015153f, 0.10334330f, 
    -0.06925582f, 0.07132741f, 0.00900000f, -0.12269627f, 0.03399540f, 0.20848100f, 0.16624083f, 0.02504428f, 
    -0.05704785f, 0.02193707f, 0.06374653f, 0.12272909f, 0.07148883f, -0.02193891f, -0.12416518f, 0.14622821f, 
    0.24654926f, 0.12508750f, 0.15143782f, 0.01650659f, -0.08176620f, 0.10481106f, 0.05230524f, -0.11293834f, 
    0.00467835f, 0.08182907f, -0.06113007f, 0.07760146f, 0.04239505f, 0.20300478f, -0.07860146f, -0.12241766f, 
    0.01547348f, -0.20652309f, 0.20378892f, 0.02622918f, -0.00786298f, 0.00568994f, 0.00979139f, -0.04157335f, 
    -0.15259476f, -0.24374881f, -0.27620044f, -0.00628832f, -0.08708289f, 0.15158579f, -0.16423261f, 0.26667064f, 
    0.09492955f, 0.03769692f, 0.13658202f, -0.03779691f, 0.31346118f, -0.00902747f, -0.02936303f, -0.19696304f, 
    0.14723456f, -0.04796349f, 0.02090447f, 0.01415276f, 0.22196187f, 0.13791250f, -0.00857255f, 0.02502050f, 
    0.06297167f, -0.18785107f, -0.19653358f, -0.01872335f, -0.09056822f, -0.07267347f, 0.04321354f, -0.05169408f, 
    -0.02232382f, 0.07516102f, 0.13775745f, 0.12602402f, -0.08423274f, 0.12624007f, -0.22479786f, -0.27193394f, 
    -0.06055664f, 0.02675740f, 0.08596926f, -0.05811644f, -0.01855027f, -0.10073469f, 0.04231844f, -0.05064128f, 
    -0.05937632f, 0.07039776f, -0.03413256f, 0.01952373f, -0.11167347f, -0.16202484f, 0.19303103f, 0.07762480f, 
    0.25002465f, -0.04690320f, -0.06951580f, 0.03778687f, -0.60223019f, -0.42910066f, -0.20785925f, 0.35123348f, 
    0.05343934f, -0.19350332f, 0.13887116f, 0.14768246f, -0.09642890f, 0.05766709f, -0.10809296f, -0.03060089f, 
    0.18852107f, -0.18692020f, -0.17872790f, -0.28780535f, 0.04063987f, 0.03856379f, -0.18195991f, -0.00998171f, 
    0.00108675f, 0.07908726f, -0.02457765f, -0.11998160f, 0.00771374f, -0.00618522f, -0.11809812f, 0.15589528f, 
    0.07690518f, 0.03626116f, -0.07074155f, 0.01532360f, 0.00810837f, 0.00056011f, 0.07284360f, 0.12239217f, 
    0.01718179f, 0.08640748f, 0.17877184f, -0.00214857f, -0.28117555f, 0.05567391f, -0.11723452f, 0.20694946f, 
    0.00171930f, 0.00223346f, 0.05973935f, -0.04964598f, -0.33847439f, -0.26500332f, -0.15857443f, -0.32845896f, 
    0.02271901f, -0.14784865f, -0.03421712f, 0.05525128f, -0.12724274f, -0.25558573f, 0.06067959f, 0.28287870f, 
    0.31954759f, -0.09380846f, 0.00317961f, 0.01892318f, -0.01773314f, -0.05296757f, 0.12874478f, 0.16190091f, 
    0.10340652f, 0.14457342f, 0.27936989f, 0.15858845f, -0.09777740f, -0.28005421f, 0.00344859f, 0.08498161f, 
    -0.03657041f, 0.06392443f, -0.15350863f, 0.15908743f, -0.02104294f, -0.05611481f, -0.10800719f, -0.05039486f, 
    -0.15643483f, -0.31283766f, -0.30930305f, -0.31072083f, -0.36128280f, -0.16160449f, 0.16951171f, 0.14828752f, 
    -0.09736855f, -0.17383382f, -0.04982318f, -0.14514790f, 0.31900373f, 0.19590616f, 0.19702654f, 0.13554448f, 
    0.02277769f, -0.01639337f, -0.03264889f, -0.03732114f, 0.09093917f, 0.03646807f, -0.00036445f, -0.00537500f, 
    0.50443745f, 0.37398633f, 0.42221156f, 0.21729130f, 0.06631451f, -0.05294735f, 0.05266728f, 0.02383951f, 
    0.05478369f, 0.19140960f, 0.03508916f, 0.01852583f, 0.13978648f, 0.02652580f, 0.07401039f, 0.06833538f, 
    0.16807897f, 0.12346515f, -0.03020598f, -0.00654934f, -0.17268446f, -0.02126911f, -0.13475581f, -0.07400513f, 
    -0.35002759f, -0.12175494f, -0.13809508f, -0.13299499f, 0.06134289f, 0.07275885f, 0.07276238f, 0.11666884f, 
    -0.03038684f, 0.15167680f, -0.02327067f, -0.00409902f, 0.09780407f, 0.08003065f, 0.09425054f, 0.21934129f, 
    -0.01924339f, 0.08066732f, 0.01320662f, -0.01569024f, 0.13602687f, -0.04153049f, 0.11650898f, 0.13735965f, 
    -0.23930790f, -0.46979514f, 0.05754623f, -0.27761295f, 0.02986433f, 0.00006462f, 0.08696325f, 0.07737233f, 
    0.10208885f, 0.19368704f, 0.20591845f, 0.08092658f, -0.13157330f, -0.15794246f, -0.21564403f, -0.08093309f, 
    -0.03447424f, 0.05842825f, -0.03893308f, 0.06463219f, -0.03486360f, -0.23028770f, -0.07762023f, 0.05281180f, 
    0.38151115f, 0.05996086f, 0.03100415f, 0.18307710f, 0.14925048f, 0.24968414f, 0.16007933f, 0.18674864f, 
    0.04767916f, 0.16331628f, -0.19840416f, 0.06887606f, 0.16110161f, -0.21445715f, 0.00392698f, -0.37228984f, 
    0.07894748f, -0.11523045f, -0.01453740f, 0.24019472f, -0.01625830f, -0.01164635f, -0.05182802f, -0.06359852f, 
    -0.31308916f, -0.17726776f, -0.00835736f, -0.00203773f, 0.22752123f, -0.06468138f, -0.06710488f, 0.01396130f, 
    0.01502632f, -0.11369071f, 0.02119649f, -0.09728676f, 0.07282046f, 0.11818115f, -0.10006736f, -0.32696968f, 
    -0.10867941f, -0.07592171f, 0.06666693f, 0.10272776f, 0.01347571f, 0.14502646f, 0.13425148f, -0.15245356f, 
    0.05214452f, -0.07810403f, 0.05810018f, -0.00317870f, 0.02766598f, -0.06839354f, -0.03634090f, -0.00423598f, 
    -0.06336332f, -0.04970380f, -0.01185828f, -0.03043482f, -0.07554206f, -0.01209296f, 0.03904368f, 0.02911738f, 
    -0.02548549f, -0.03490420f, -0.02192611f, 0.05590698f, -0.05226014f, -0.06894861f, -0.06027121f, -0.05783641f, 
    0.04841894f, -0.03761493f, -0.02987061f, 0.04626552f, 0.03201418f, 0.00081755f, -0.01873245f, 0.02531910f, 
    0.04905926f, -0.02590576f, -0.02583358f, 0.03202282f, 0.03742288f, -0.06651346f, 0.05495346f, 0.04577691f, 
    -0.07870598f, 0.02413064f, 0.04634331f, -0.01064137f, 0.04962876f, -0.02138117f, 0.01145614f, 0.04196506f, 
    -0.06110895f, -0.02815364f, 0.04642047f, 0.03908709f, -0.05766801f, -0.03520191f, -0.06781130f, 0.02518228f, 
    -0.01915767f, -0.00933530f, -0.05453007f, 0.00624751f, -0.04098382f, -0.06221171f, -0.00583962f, 0.02802731f, 
    -0.05838519f, -0.03668200f, -0.04967065f, -0.05154432f, 0.05842924f, -0.01782588f, 0.04219716f, -0.01305336f, 
    0.06031295f, -0.04350775f, 0.05720289f, -0.05649804f, 0.01706448f, 0.03042270f, -0.04087595f, -0.02560612f, 
    -0.04808303f, -0.01058396f, -0.00159735f, -0.02209185f, -0.02179221f, -0.06642850f, 0.04503214f, 0.05937585f, 
    -0.07364403f, 0.03705149f, 0.00311228f, -0.04217460f, 0.03957815f, 0.01994861f, 0.04195036f, -0.05769428f, 
    0.01287317f, -0.04419063f, -0.01533059f, 0.05718911f, -0.00907296f, -0.01011489f, -0.04368880f, -0.05305207f, 
    -0.03616419f, -0.05447455f, -0.05082927f, 0.05057983f, 0.02065555f, 0.02136502f, 0.02324716f, -0.05029126f, 
    0.03398626f, -0.00553736f, -0.03646774f, 0.00811000f, 0.03727407f, 0.00056476f, -0.05333395f, 0.01288107f, 
    0.01265841f, 0.05424331f, -0.07224516f, 0.01209883f, 0.02450071f, -0.02670898f, 0.02133786f, -0.04903461f, 
    -0.02692226f, -0.04576657f, -0.00353461f, -0.00040476f, -0.06009060f, -0.04985937f, 0.04384714f, -0.06300361f, 
    0.03708137f, 0.00633815f, 0.05248633f, -0.01754070f, -0.07075775f, 0.03756968f, 0.03421219f, -0.07240601f, 
    0.00265677f, 0.03896098f, -0.08417010f, -0.08455911f, -0.00656045f, -0.03898495f, 0.04432464f, 0.04804030f, 
    0.04888697f, -0.05482156f, 0.04040164f, -0.01936143f, -0.00325173f, -0.04337394f, -0.01914010f, -0.06084040f, 
    -0.05349876f, -0.00183850f, -0.06773977f, 0.04647031f, -0.05406399f, -0.00435541f, -0.02820041f, -0.06797546f, 
    -0.04197239f, -0.04444643f, -0.05955563f, -0.03608364f, -0.04023356f, -0.03753768f, -0.05857166f, -0.04837438f, 
    0.05167046f, 0.02568093f, 0.01153052f, 0.03499943f, -0.06688500f, 0.05631185f, 0.04546608f, -0.06703602f, 
    -0.02304300f, -0.06327584f, -0.04396310f, -0.00156682f, -0.07971755f, -0.01442008f, 0.01789681f, 0.01291232f, 
    -0.11989331f, -0.01720740f, -0.10563170f, 0.47163618f, 0.08580787f, 0.13580644f, 0.03489409f, 0.07542666f, 
    -0.00771767f, 0.05644069f, 0.05965994f, 0.02261211f, 0.04185247f, -0.26794252f, -0.02070105f, 0.21527192f, 
    0.15828496f, -0.06047010f, -0.06067570f, 0.04714860f, -0.03654933f, -0.11468878f, -0.06936295f, -0.20389988f, 
    -0.16197175f, 0.04528612f, -0.06226670f, 0.18581027f, -0.12777431f, -0.06842975f, -0.03686399f, -0.00276702f, 
    0.09238060f, 0.07514448f, -0.13934524f, -0.22505030f, -0.14673637f, -0.04567388f, -0.09614830f, 0.36624497f, 
    -0.02727450f, 0.08801495f, -0.17412552f, -0.13454166f, -0.08297534f, -0.12705788f, -0.00612217f, 0.13995661f, 
    -0.11431330f, -0.36828387f, -0.07920568f, 0.20304503f, 0.24517666f, 0.14018466f, -0.00054428f, -0.07091110f, 
    -0.10925918f, -0.15163003f, 0.06456894f, -0.03898742f, -0.31190249f, 0.28549471f, 0.01964279f, -0.20688415f, 
    0.05182790f, -0.12237961f, -0.04148397f, -0.10081828f, -0.01066429f, 0.08002919f, 0.15495013f, 0.14370400f, 
    -0.37553287f, -0.01695272f, -0.04834696f, 0.05418012f, -0.04181205f, 0.01103263f, -0.03708758f, -0.07912220f, 
    -0.01008483f, -0.08224300f, 0.04796834f, -0.09937850f, 0.12842363f, 0.23057477f, 0.08772109f, -0.06958678f, 
    0.00707898f, 0.03490952f, -0.01149148f, -0.03947983f, 0.18165161f, 0.04780460f, 0.19047047f, 0.12150177f, 
    -0.14783797f, 0.03048750f, -0.14923105f, 0.06501054f, 0.02166275f, -0.08061599f, 0.02128517f, 0.23443829f, 
    -0.07294757f, -0.05888959f, 0.00629134f, -0.00647184f, 0.14825003f, 0.19379507f, 0.19920138f, -0.07308845f, 
    0.10431906f, 0.07605947f, -0.07864527f, -0.18518385f, -0.03670663f, 0.01498513f, 0.07545376f, -0.07153144f, 
    -0.16184534f, -0.10509257f, -0.04747641f, 0.16963528f, 0.07302392f, 0.07763781f, 0.10279480f, 0.07519908f, 
    -0.01286387f, 0.07879156f, -0.00896646f, -0.11603608f, 0.02765461f, -0.06082684f, 0.00969870f, -0.23719534f, 
    0.08658570f, -0.05338113f, -0.11175334f, -0.02450432f, -0.01538629f, 0.18689524f, 0.12223219f, -0.10488135f, 
    -0.26896563f, -0.05878701f, 0.38249958f, -0.09443668f, 0.20023432f, 0.02855522f, 0.13631074f, -0.05684373f, 
    0.16435090f, -0.02242024f, 0.24791941f, -0.15365268f, 0.25940409f, -0.05864984f, 0.11845350f, 0.41475844f, 
    0.01291499f, -0.13497441f, 0.23202060f, 0.12429226f, -0.03433685f, 0.04168749f, 0.16582897f, 0.27156195f, 
    -0.15011445f, 0.17994301f, -0.19533999f, 0.17698903f, 0.00948040f, 0.06624934f, -0.02389754f, 0.16495977f, 
    0.01005138f, 0.04936789f, -0.04887959f, 0.15601256f, 0.68797594f, -0.12261719f, 0.23050219f, -0.05105225f, 
    0.06469569f, -0.09604375f, 0.07994913f, -0.07272016f, 0.01411757f, -0.04426252f, 0.07900019f, 0.13625330f, 
    0.02996409f, 0.13216734f, 0.24991918f, 0.26329970f, 0.04249506f, 0.01280876f, -0.09616690f, -0.12359530f, 
    0.08925274f, 0.05732795f, 0.01211976f, 0.13189623f, -0.15341717f, 0.40571684f, -0.13015780f, -0.04773019f, 
    -0.04261024f, -0.01397684f, -0.25480667f, -0.07089997f, 0.05766395f, 0.00975064f, 0.06983788f, 0.13330828f, 
    0.19323286f, 0.04914108f, 0.03030698f, 0.02256816f, 0.05229506f, 0.05558215f, 0.04473723f, -0.04298650f, 
    0.05472480f, -0.02559769f, 0.11878713f, 0.23609066f, -0.04955856f, -0.13957368f, 0.09644642f, 0.01182404f, 
    -0.21107806f, -0.05671296f, -0.08475871f, 0.09237917f, 0.10124256f, 0.02348730f, 0.17624149f, -0.01788834f, 
    0.01461933f, 0.51336485f, 0.13662185f, 0.38170671f, 0.18514124f, -0.07977896f, 0.21921563f, -0.02039822f, 
    -0.12542987f, -0.08313920f, -0.01240320f, 0.04482445f, 0.16725215f, -0.09701537f, -0.05354672f, -0.01027995f, 
    -0.02600591f, 0.01597877f, -0.05860460f, -0.01116176f, -0.09812565f, 0.05175575f, 0.00408545f, -0.15084232f, 
    0.58402175f, -0.02208116f, 0.49901223f, -0.07334699f, -0.07438754f, 0.07259154f, -0.16142814f, -0.00245158f, 
    -0.07128662f, -0.07482395f, 0.06327403f, 0.04095759f, 0.05462394f, -0.17119628f, -0.01329665f, -0.05366913f, 
    0.08721118f, -0.02991289f, 0.00959281f, 0.02215717f, -0.05744144f, -0.04241102f, -0.12103318f, -0.16811359f, 
    -0.23829828f, 0.05088958f, 0.06093634f, 0.23872124f, 0.06331367f, -0.09872361f, 0.00576975f, 0.03681128f, 
    0.11142863f, 0.17865327f, -0.09167990f, 0.02085018f, -0.10681464f, -0.22913396f, -0.00475363f, -0.00885124f, 
    -0.07494477f, 0.02095681f, 0.02549514f, -0.02900912f, 0.01076262f, 0.02409829f, 0.03460648f, 0.22410540f, 
    0.02738321f, -0.09884710f, 0.15218145f, 0.00750495f, 0.08576875f, 0.06544936f, -0.00147679f, -0.16350144f, 
    0.19513975f, 0.14295696f, 0.09507097f, 0.12106179f, -0.16952254f, 0.14716357f, -0.25312218f, 0.03769838f, 
    -0.03755437f, -0.03075390f, -0.04200764f, -0.01506860f, 0.03778872f, -0.11150547f, -0.00339165f, -0.01253171f, 
    0.31458235f, 0.01107401f, -0.09636671f, 0.17436990f, 0.03862119f, 0.22421511f, 0.02603229f, 0.16550417f, 
    -0.11902346f, 0.19398719f, -0.09958418f, 0.10224199f, 0.27176970f, 0.03200705f, 0.20806774f, -0.13905333f, 
    -0.07597397f, 0.24069850f, -0.25278038f, 0.06625006f, -0.06233828f, 0.00535202f, -0.02968976f, -0.14095619f, 
    -0.16240081f, 0.19906235f, 0.20007227f, 0.26960793f, -0.02255605f, -0.05079250f, 0.02690912f, 0.00357136f, 
    -0.01013081f, 0.01174521f, 0.05662424f, -0.13272245f, -0.06157302f, 0.05222409f, -0.22879864f, -0.29112369f, 
    -0.05510617f, -0.00082985f, -0.08125498f, 0.04904984f, -0.11750752f, 0.01698554f, 0.16902311f, -0.07738564f, 
    0.33415437f, 0.18121547f, 0.24799891f, -0.09569478f, 0.07563516f, -0.02302618f, 0.13770707f, -0.01112225f, 
    0.06196593f, -0.01092352f, 0.00406054f, -0.02810710f, 0.01535282f, -0.19260561f, -0.29333264f, -0.15306598f, 
    0.06370822f, 0.13945664f, 0.26201820f, 0.09941085f, -0.22559978f, 0.04904860f, 0.19433108f, 0.06147126f, 
    0.10006291f, -0.05141856f, 0.12852854f, 0.17363176f, -0.02217804f, 0.03128003f, 0.01859530f, 0.18791190f, 
    0.25507796f, -0.23624323f, 0.04387472f, -0.08221982f, 0.39318153f, 0.53953499f, 0.04369189f, 0.21296641f, 
    -0.08742720f, -0.02497869f, -0.06119653f, 0.10671534f, -0.08974408f, -0.00935964f, -0.09106207f, 0.16253774f, 
    -0.39161682f, -0.55148488f, 0.02996084f, -0.12172721f, 0.03692631f, 0.11052429f, -0.13455980f, 0.02951859f, 
    0.13492489f, -0.02449745f, 0.01074228f, 0.13159558f, 0.08071026f, -0.00975677f, -0.05193970f, 0.05052676f, 
    0.01277411f, -0.06564365f, -0.05927919f, -0.01700705f, -0.00174585f, -0.07609427f, 0.03012330f, -0.09289078f, 
    -0.12180689f, -0.11523253f, -0.18695389f, 0.43068656f, 0.08333205f, -0.03557821f, -0.03851210f, -0.03891006f, 
    -0.07451655f, 0.17215496f, -0.07152562f, 0.18522948f, 0.12896495f, 0.00977437f, -0.05494234f, 0.14051004f, 
    -0.02773521f, -0.01492356f, 0.17219344f, -0.16451748f, -0.08378790f, 0.08867152f, -0.17728162f, 0.00528455f, 
    0.20333187f, -0.08980509f, -0.16080037f, -0.09181426f, 0.13560705f, 0.06241923f, -0.04293903f, -0.00409123f, 
    0.12031981f, 0.08905243f, 0.02487634f, -0.04226759f, -0.12964286f, 0.27514237f, -0.19658399f, -0.16505307f, 
    0.03933708f, 0.10768019f, 0.05214963f, -0.02997807f, -0.12884292f, -0.04330819f, -0.10504005f, -0.03368203f, 
    0.19945346f, 0.01263325f, 0.09508311f, 0.06667306f, -0.16809487f, -0.17652699f, 0.07246556f, 0.10309100f, 
    0.10186962f, -0.05995809f, -0.02164154f, 0.00949718f, -0.00293588f, -0.04366458f, -0.43990874f, -0.24887702f, 
    0.13456991f, 0.19300060f, 0.14424294f, 0.01654632f, 0.14363612f, 0.13289617f, 0.00361203f, 0.05426190f, 
    -0.14613311f, 0.12880434f, -0.07098842f, -0.06151492f, 0.02045410f, 0.08260900f, -0.27122223f, -0.00416509f, 
    0.01093405f, -0.08350278f, 0.07020286f, -0.09044503f, -0.07691342f, 0.06334013f, -0.37632093f, 0.23801778f, 
    0.17902595f, 0.23808503f, -0.05216102f, -0.01744205f, 0.05659144f, 0.05633853f, 0.15328912f, 0.16594622f, 
    0.65919590f, -0.00320143f, 0.53091198f, -0.19260855f, 0.07818485f, 0.19678929f, -0.00265697f, -0.13852897f, 
    0.15085264f, 0.02878092f, -0.00693081f, -0.05946852f, 0.03117131f, -0.61408865f, -0.01709975f, -0.06608211f, 
    0.06330751f, -0.00594011f, -0.01595807f, 0.03170056f, -0.02609133f, 0.12456740f, -0.09533342f, 0.05146402f, 
    -0.09383877f, -0.23009969f, 0.16142106f, 0.27306893f, 0.06633127f, 0.15288596f, -0.12834804f, 0.26395643f, 
    -0.03113624f, 0.04804279f, -0.03812910f, -0.19070692f, -0.08746528f, -0.08432779f, -0.00484977f, 0.24089801f, 
    -0.00936944f, 0.10789291f, 0.17328404f, 0.16729376f, 0.01850425f, 0.13683455f, 0.08594196f, 0.13369957f, 
    -0.28582287f, 0.10084245f, 0.34247681f, 0.20527306f, 0.08317874f, 0.22480230f, -0.11555157f, 0.11708330f, 
    0.08439173f, 0.28287610f, 0.27942795f, 0.32335171f, 0.00731652f, 0.02821868f, 0.02682455f, 0.06602443f, 
    0.12835929f, 0.15958431f, 0.17615664f, 0.24129842f, -0.01712999f, 0.06368539f, -0.09700660f, -0.03182768f, 
    -0.08011132f, 0.00239724f, 0.12724614f, 0.25898921f, -0.08101880f, 0.11961426f, 0.04687911f, 0.11132284f, 
    -0.07438051f, 0.07853255f, -0.00690062f, 0.20930488f, 0.05375104f, -0.07908024f, -0.05043375f, -0.02426112f, 
    -0.01713103f, -0.03741483f, -0.44964999f, -0.22086418f, -0.16676630f, -0.27953985f, -0.27434286f, -0.13913602f, 
    -0.01625434f, 0.26334560f, 0.23309775f, -0.00518603f, -0.01828378f, 0.03909003f, -0.24040613f, 0.01012578f, 
    -0.20777686f, -0.09941227f, 0.03181352f, -0.28107706f, 0.04832272f, 0.34385461f, -0.20198779f, 0.16214129f, 
    0.11036196f, -0.25843546f, 0.02394607f, -0.16311944f, -0.37603739f, -0.29307517f, -0.14738229f, -0.44984651f, 
    0.16502121f, -0.11191401f, -0.03992041f, 0.27724671f, -0.22393897f, -0.12984104f, 0.06270807f, 0.03454555f, 
    0.16768293f, 0.04601523f, -0.09750849f, -0.03577425f, 0.07393730f, 0.16681199f, -0.22077808f, -0.36879283f, 
    -0.22687052f, -0.18323694f, -0.03370739f, 0.14932403f, -0.12939723f, 0.06921725f, -0.06238125f, -0.12579606f, 
    -0.02163440f, -0.08942237f, -0.01693554f, 0.08583251f, 0.15298319f, -0.05687125f, 0.04630519f, 0.06591282f, 
    0.08288907f, 0.13899595f, 0.05646565f, 0.03407072f, 0.44379848f, -0.31611666f, 0.19727434f, 0.29355130f, 
    0.03549565f, -0.07847910f, 0.06290326f, 0.01250859f, 0.10759573f, -0.03246365f, 0.05546588f, 0.01651533f, 
    -0.04330823f, 0.45690420f, 0.18168297f, 0.26186100f, 0.09162638f, -0.23512347f, 0.17156319f, 0.01969214f, 
    -0.32242152f, -0.22687279f, -0.25679252f, -0.36030543f, -0.15717570f, 0.04310939f, -0.05381320f, 0.37442148f, 
    0.06650479f, 0.05725534f, 0.06875494f, 0.02845945f, 0.05224101f, -0.15797205f, 0.04812943f, -0.06750403f, 
    0.04124814f, -0.16879159f, 0.12442208f, -0.04239728f, 0.11600021f, 0.05340927f, -0.10227561f, 0.07054470f, 
    -0.26823094f, 0.08714982f, -0.01383756f, -0.10432020f, 0.86412132f, 0.19795761f, -0.26402065f, -0.15321846f, 
    0.01351704f, -0.05219471f, -0.09433593f, -0.07440867f, 0.01987929f, -0.04233834f, -0.01841215f, -0.08635217f, 
    0.25806659f, 0.37708929f, 0.14620076f, 0.10580497f, -0.06961431f, -0.10914189f, 0.11887342f, 0.16059117f, 
    0.02164771f, 0.06488728f, 0.01509639f, -0.01274938f, 0.13982539f, 0.19150822f, -0.03688682f, -0.18716079f, 
    0.13494079f, 0.04449410f, 0.06812855f, 0.11888826f, 0.03580578f, -0.13150743f, -0.11929539f, 0.05119109f, 
    0.14959307f, -0.30916420f, -0.30618984f, -0.12587391f, -0.07125415f, 0.01803066f, 0.05444508f, 0.04016055f, 
    -0.20839936f, -0.40125263f, -0.16427152f, -0.10703219f, 0.17447005f, 0.12261949f, 0.21360761f, 0.07642798f, 
    -0.05449320f, 0.11791261f, -0.04187402f, 0.15313746f, -0.02179402f, -0.07760670f, -0.05223456f, 0.22378276f, 
    0.17224900f, 0.06661899f, -0.09843836f, -0.31250700f, 0.09111422f, 0.07326480f, 0.06204361f, 0.03731342f, 
    -0.05699004f, -0.17679051f, 0.05339414f, 0.04819563f, 0.07266843f, -0.26102814f, -0.17664792f, -0.15259661f, 
    -0.07244270f, -0.00122003f, 0.03900898f, -0.08809493f, 0.01964092f, 0.08678222f, 0.14888206f, 0.08900513f, 
    -0.23936795f, -0.29959550f, -0.25797400f, 0.24784158f, -0.16561826f, -0.13011713f, 0.03412638f, 0.04914210f, 
    0.06328333f, -0.13578618f, -0.02858246f, 0.14286716f, -0.14019462f, -0.07032120f, 0.19018340f, 0.05499383f, 
    -0.10129005f, 0.17876796f, -0.01714872f, -0.10738261f, 0.05988451f, 0.12960804f, 0.04564479f, 0.09387081f, 
    0.14455177f, 0.43372858f, 0.25258872f, 0.01962964f, -0.00878753f, -0.04637471f, -0.01251823f, 0.09196376f, 
    -0.09248757f, -0.05480224f, -0.13151436f, -0.06960615f, -0.29464358f, -0.11967805f, -0.05570425f, 0.16586560f, 
    0.02139020f, 0.12381659f, -0.05875159f, -0.07882994f, -0.04582484f, 0.02781462f, 0.04782159f, 0.05353373f, 
    0.11815020f, 0.29641178f, 0.18507847f, 0.02234236f, 0.00607577f, 0.09191310f, 0.03817203f, 0.16194825f, 
    -0.08806551f, -0.12855613f, -0.20017515f, -0.11869975f, 0.04812611f, 0.10433538f, -0.29912618f, -0.08719932f, 
    0.10438693f, -0.07882513f, -0.05593170f, -0.01569193f, -0.09613120f, 0.09710838f, 0.06093606f, 0.06919313f, 
    0.10738102f, -0.22727858f, -0.06711755f, -0.16757122f, 0.16194631f, 0.09683376f, 0.02586113f, 0.11255983f, 
    0.06046582f, 0.06117921f, 0.10778823f, -0.11103544f, 0.40725684f, 0.16860646f, 0.15092610f, 0.00735284f, 
    0.12879670f, -0.07570507f, 0.18863192f, 0.01620589f, 0.03856383f, -0.00829286f, -0.02184692f, 0.22977163f, 
    -0.14449503f, 0.18527161f, 0.20935632f, 0.03505374f, -0.08061057f, 0.06706722f, 0.14232914f, 0.02590094f, 
    0.03263757f, -0.01250765f, -0.05049431f, 0.03426488f, 0.05870406f, -0.20424920f, 0.21036069f, -0.18158333f, 
    -0.05954035f, -0.02260011f, 0.12915148f, -0.11234790f, 0.04412270f, 0.14832145f, 0.10200365f, 0.16763911f, 
    0.08812308f, -0.06798134f, -0.23226528f, -0.07444306f, -0.03892607f, -0.08534762f, 0.04497893f, 0.21519424f, 
    -0.13948338f, 0.09568259f, -0.01585319f, 0.02641956f, 0.09388314f, 0.11310771f, 0.03724008f, -0.06435392f, 
    0.18792138f, 0.06940690f, 0.30096945f, -0.03381788f, 0.04326627f, 0.08881491f, 0.15709071f, 0.16139290f, 
    -0.21885166f, -0.16159208f, 0.16884878f, -0.11010328f, -0.22676308f, 0.03794988f, 0.19075273f, 0.09768756f, 
    -0.09967571f, 0.08079257f, 0.27921751f, 0.09831469f, 0.24775006f, 0.16231188f, -0.02702671f, 0.08800527f, 
    0.17117907f, 0.02646345f, 0.19728586f, 0.20080657f, -0.02445197f, 0.11047296f, -0.01430166f, 0.13826416f, 
    0.16697234f, 0.00346543f, -0.09424547f, -0.37717181f, -0.26130095f, 0.16885304f, -0.06524248f, 0.13210319f, 
    0.18268964f, 0.07756263f, 0.06560620f, 0.05297303f, 0.10331700f, 0.05340281f, -0.10785765f, 0.05023849f, 
    -0.02213682f, -0.36131278f, 0.03931744f, -0.42341352f, -0.20607406f, -0.04256034f, -0.18541746f, -0.08604377f, 
    -0.11980860f, 0.24527687f, -0.01066655f, 0.26501995f, 0.01550450f, -0.17693667f, 0.07301927f, 0.01411648f, 
    -0.03299598f, 0.13072388f, 0.06654169f, 0.03055285f, -0.17408518f, 0.08648646f, 0.00367790f, 0.17661659f, 
    -0.14920565f, -0.04281410f, -0.05997701f, -0.23724195f, -0.11162482f, -0.02792663f, -0.23841435f, 0.02405851f, 
    0.22198281f, 0.04935856f, 0.01766760f, -0.21054302f, 0.11375369f, -0.05456453f, -0.08351431f, -0.13424319f, 
    -0.03801642f, -0.06692962f, 0.07138537f, 0.11091502f, -0.06880759f, 0.15238719f, 0.16320877f, 0.06942809f, 
    -0.05225912f, 0.00937262f, -0.19569296f, -0.06881139f, -0.04268271f, -0.28941253f, 0.14414042f, -0.05778597f, 
    -0.02047561f, 0.02179701f, 0.01206355f, -0.03527023f, 0.12673648f, 0.08598800f, -0.08446667f, 0.07026558f, 
    -0.07064113f, 0.06713756f, -0.06500228f, 0.13237269f, 0.54522449f, -0.12769680f, 0.11267067f, 0.07165584f, 
    0.25977901f, 0.07264102f, -0.24996251f, -0.17986763f, 0.09629855f, -0.11158188f, 0.00865192f, 0.13869828f, 
    0.30801281f, -0.04603764f, 0.27071932f, -0.07679434f, 0.08983703f, -0.13354248f, -0.19798726f, 0.15527686f, 
    -0.24111131f, 0.04666234f, -0.07950855f, -0.35892999f, 0.06746472f, -0.00316633f, -0.13648254f, -0.10361935f, 
    0.01602889f, -0.01409684f, 0.18227963f, 0.02926392f, -0.16576046f, 0.15841499f, -0.24816303f, 0.16591264f, 
    -0.05486150f, 0.11100341f, -0.15152754f, 0.04811034f, 0.17921160f, -0.10083751f, 0.14871126f, 0.05942607f, 
    -0.06617904f, -0.24860349f, -0.18457423f, -0.32881799f, 0.28287309f, 0.00784605f, 0.15236309f, -0.13824458f, 
    -0.07250425f, 0.13745107f, -0.16528752f, -0.36888468f, 0.14070809f, 0.11873854f, -0.07149662f, -0.02884308f, 
    -0.01797427f, 0.27984089f, 0.21125562f, -0.20600437f, 0.05548691f, 0.12131099f, 0.31703526f, -0.05118889f, 
    0.04417023f, -0.02418210f, 0.00439539f, 0.02183661f, -0.07080916f, -0.10660082f, 0.14420561f, -0.15329720f, 
    -0.07653402f, 0.20607127f, 0.25329658f, 0.23311527f, -0.29489136f, 0.00610019f, 0.05365771f, -0.00987548f, 
    0.20477806f, -0.06350359f, -0.19317676f, -0.14736240f, -0.00232372f, 0.05092797f, 0.14914268f, 0.00414627f, 
    0.03187897f, 0.06351189f, 0.14704470f, -0.24828663f, -0.22674352f, 0.21361344f, -0.04281857f, -0.17441386f, 
    0.13818897f, 0.05240693f, -0.19581866f, -0.10432807f, -0.06550726f, -0.00554155f, 0.03676153f, 0.11256772f, 
    -0.43591622f, -0.25698239f, -0.07337517f, -0.42374402f, -0.06697690f, 0.20366977f, 0.22777078f, -0.14190798f, 
    -0.02912115f, -0.08442183f, 0.06618394f, 0.03516542f, 0.17365845f, 0.08503543f, 0.10056103f, 0.21515487f, 
    0.03682452f, 0.05023465f, -0.03448215f, 0.01985276f, 0.02885309f, -0.03143068f, -0.02928816f, -0.14420331f, 
    0.09562600f, -0.25294065f, -0.73240799f, 0.03526505f, -0.02249569f, 0.11436332f, 0.04759912f, -0.05843407f, 
    0.20220625f, 0.02423601f, 0.24712352f, 0.06185418f, 0.07629747f, -0.07830560f, 0.17915113f, 0.05893086f, 
    -0.18498747f, -0.16718434f, -0.00384602f, 0.04621291f, 0.03071452f, 0.05656738f, -0.07091396f, 0.09628318f, 
    0.15867431f, 0.07036798f, 0.06642647f, -0.11401002f, 0.14079320f, 0.08922550f, 0.19235569f, -0.20970199f, 
    0.11332136f, -0.09927305f, -0.01134466f, -0.04193131f, -0.00935877f, 0.27136159f, -0.01588527f, 0.12977079f, 
    0.03017049f, 0.04161731f, -0.04909913f, 0.02811062f, -0.21377958f, -0.32277313f, -0.17717554f, -0.12386879f, 
    -0.13911824f, 0.07717492f, -0.19275691f, -0.12272741f, -0.16209072f, -0.13112968f, 0.04705999f, 0.10845178f, 
    -0.10176022f, -0.08681985f, 0.02075655f, -0.09669330f, 0.02902872f, -0.08278695f, 0.11626477f, -0.17373820f, 
    0.10264973f, -0.00299347f, 0.03685138f, 0.03719888f, -0.05089600f, 0.19503713f, -0.01011385f, 0.02073868f, 
    0.00750846f, 0.01303402f, -0.06298865f, 0.08822345f, 0.12170763f, 0.22815205f, -0.03226047f, 0.03677049f, 
    -0.02219778f, -0.14332676f, 0.12307703f, -0.09757438f, -0.03739157f, 0.26817191f, -0.36031818f, -0.08498122f, 
    0.07972717f, -0.21152142f, -0.16887134f, -0.27743611f, 0.18717603f, 0.11777429f, 0.22537255f, 0.13783212f, 
    -0.01011107f, -0.00485710f, 0.46909067f, -0.23753287f, -0.08244428f, -0.03017848f, 0.04129260f, 0.03149833f, 
    0.06039143f, -0.03781242f, 0.07196946f, 0.09896517f, 0.03433567f, -0.33801049f, -0.03885416f, 0.12266184f, 
    -0.04190504f, 0.09304157f, 0.16109604f, 0.14118668f, 0.08835105f, -0.02647766f, 0.03232238f, 0.31838137f, 
    0.05094329f, 0.11870157f, 0.18897493f, 0.17439759f, 0.01181972f, 0.15301396f, 0.16775329f, 0.13854396f, 
    -0.04863706f, -0.09320585f, 0.04804562f, -0.00465852f, 0.24831443f, 0.12811932f, 0.18286759f, 0.09522720f, 
    0.05973223f, -0.07623706f, -0.09879278f, 0.13275780f, -0.00336869f, -0.15454011f, 0.06193369f, 0.11137949f, 
    0.04030604f, -0.20308432f, -0.18849279f, -0.10165605f, -0.22437556f, 0.07656545f, -0.12584291f, 0.00783941f, 
    0.15247330f, -0.05018711f, 0.00575391f, -0.03181951f, 0.10075597f, 0.51642805f, 0.22768386f, 0.10908569f, 
    0.09827745f, -0.03026383f, -0.09125015f, 0.26536900f, 0.03539802f, 0.05226364f, 0.05666531f, 0.00099000f, 
    0.02165414f, 0.06233542f, 0.06405853f, 0.09574269f, 0.02916515f, 0.17652464f, 0.12039072f, -0.17592669f, 
    0.02086720f, -0.11449794f, -0.03475390f, 0.07930897f, -0.11973114f, -0.34007806f, -0.35071370f, 0.12440169f, 
    -0.19003001f, -0.21053012f, -0.06221251f, -0.15329963f, 0.10736419f, 0.05898948f, 0.08238519f, -0.05779397f, 
    0.17671210f, -0.11711800f, -0.35049495f, 0.15217027f, -0.06753517f, -0.01668659f, -0.00775751f, -0.04325371f, 
    0.16029960f, 0.02679643f, 0.04313063f, 0.10959423f, 0.13105303f, -0.28308454f, -0.05919296f, 0.07521268f, 
    0.14255412f, 0.13009410f, 0.07141575f, 0.06914807f, 0.10836811f, 0.09939506f, -0.42212784f, -0.22543977f, 
    0.02264904f, -0.13586751f, 0.17149200f, 0.17439091f, 0.00762618f, -0.10043119f, -0.12598968f, -0.02214484f, 
    -0.13298802f, -0.15072969f, 0.17278573f, -0.00166782f, -0.40739289f, 0.01777482f, -0.15691261f, 0.09609309f, 
    0.19701187f, 0.03050227f, -0.08230259f, -0.10572565f, -0.00305135f, 0.09082152f, 0.03786287f, 0.08903039f, 
    0.21006888f, 0.12845904f, 0.22371307f, 0.23251206f, -0.00173280f, 0.05844155f, 0.12754411f, 0.09175243f, 
    -0.07192274f, 0.00271078f, -0.16540858f, 0.12077227f, -0.09736625f, -0.15036313f, 0.15437575f, 0.18840060f, 
    0.08991830f, -0.26208639f, -0.24923684f, 0.02244511f, -0.03456419f, -0.14493072f, 0.05488030f, 0.16435309f, 
    -0.11267898f, -0.31726894f, -0.26442775f, -0.18866125f, 0.00686105f, 0.05528685f, 0.20426776f, 0.15465961f, 
    -0.08477264f, 0.04520351f, -0.04644403f, 0.08596203f, 0.15216585f, 0.40010002f, 0.08371470f, 0.02277936f, 
    0.10142972f, 0.06522652f, -0.04023737f, 0.06498951f, 0.13187924f, -0.02219079f, 0.08633595f, -0.19704577f, 
    0.15489258f, 0.28518003f, 0.41695634f, 0.15766443f, -0.20469750f, 0.09579220f, 0.15301180f, 0.07086190f, 
    0.10376205f, -0.03685663f, -0.05684242f, 0.03237422f, -0.20757574f, -0.29882455f, -0.24755545f, -0.00074789f, 
    0.19886123f, 0.01700843f, -0.25293258f, 0.06584949f, -0.17194566f, -0.08233517f, 0.06350740f, 0.15604566f, 
    -0.06552065f, -0.27206558f, -0.47128636f, -0.11957379f, 0.07230246f, 0.04027293f, 0.09020013f, 0.02470483f, 
    -0.02550651f, -0.00113208f, -0.03661383f, 0.00175669f, 0.16745351f, 0.26806065f, 0.16313216f, 0.08844917f, 
    -0.04573536f, -0.01788068f, 0.16084997f, -0.06075392f, 0.14537303f, 0.15480125f, -0.02301625f, -0.01350048f, 
    0.02522806f, -0.11710467f, -0.01894449f, -0.13588813f, -0.03854945f, 0.06260364f, 0.11082783f, -0.02698858f, 
    -0.28578931f, 0.13831744f, 0.19986807f, 0.08608235f, 0.08667888f, -0.18086609f, -0.19146419f, 0.09646132f, 
    0.12226693f, 0.04690613f, 0.27167970f, -0.05381779f, 0.03925306f, 0.02421430f, -0.07030965f, -0.04788125f, 
    0.48991841f, 0.27135628f, 0.02493198f, -0.14371511f, -0.02880511f, -0.02333049f, -0.01377736f, 0.21186920f, 
    -0.11354223f, 0.14596467f, -0.01356496f, 0.01307215f, -0.07040753f, -0.13502806f, -0.00002764f, -0.06650049f, 
    -0.05222871f, -0.07558801f, 0.07004522f, -0.02678569f, -0.08417308f, 0.08123817f, -0.02557545f, 0.09227553f, 
    0.04136654f, 0.19059806f, 0.27959538f, -0.35827485f, -0.00063072f, 0.06414585f, 0.14023665f, 0.03732984f, 
    -0.08342835f, 0.03718557f, -0.04454344f, 0.17220180f, -0.18066148f, -0.11219758f, 0.08202448f, -0.00231414f, 
    -0.07054851f, 0.13026090f, 0.02639937f, 0.00981629f, 0.01504112f, -0.05301797f, 0.05498966f, 0.10337842f, 
    0.06248259f, 0.11928033f, 0.00768513f, -0.03404643f, -0.07245699f, 0.03380430f, -0.16213374f, 0.13119662f, 
    -0.05683526f, 0.00285710f, 0.03421157f, 0.13461231f, 0.03966029f, -0.16908662f, 0.19732328f, 0.15654138f, 
    0.02340242f, -0.12631588f, 0.07483017f, 0.04805807f, 0.33429709f, 0.14799897f, 0.27470389f, 0.15763798f, 
    -0.00173845f, -0.01065180f, -0.13000117f, -0.13808681f, 0.14405179f, 0.14911807f, -0.13844743f, -0.03945443f, 
    -0.18167418f, 0.06006077f, -0.09381834f, 0.18906999f, -0.14730556f, 0.26896405f, 0.25493258f, 0.18177269f, 
    -0.04243707f, 0.08363207f, -0.06795593f, -0.02519268f, -0.19393225f, -0.02940657f, 0.20013154f, 0.05739643f, 
    0.07059199f, -0.11747780f, 0.07787653f, -0.04387621f, -0.05867173f, -0.24940616f, 0.06759389f, -0.14732303f, 
    -0.03595401f, 0.03741746f, -0.10769864f, 0.06715839f, 0.17598432f, -0.04977775f, 0.04384092f, -0.24709024f, 
    0.03796040f, -0.08215891f, 0.09236128f, -0.01695449f, -0.08885372f, -0.06270880f, -0.15817668f, -0.05810123f, 
    -0.38788021f, 0.15155202f, -0.61147606f, 0.05096591f, 0.01170945f, -0.07961936f, 0.09871987f, 0.03390720f, 
    -0.07311804f, 0.00982391f, -0.01077923f, -0.01250202f, -0.34456906f, 0.37624979f, 0.49340272f, 0.08952272f, 
    -0.03594660f, -0.02782660f, -0.06383374f, -0.05011313f, 0.06498617f, 0.14682916f, -0.05117195f, 0.05658823f, 
    -0.04738417f, 0.01401777f, 0.04100551f, -0.01776869f, -0.05789026f, 0.03421443f, 0.00454832f, 0.00198594f, 
    0.06332762f, -0.03987405f, -0.02583268f, -0.03634985f, 0.04051170f, -0.00732446f, -0.07657237f, -0.02091364f, 
    0.00475575f, -0.00955275f, -0.06704012f, 0.01897897f, -0.06271565f, -0.05132077f, -0.08081238f, 0.03687863f, 
    0.01117982f, -0.07326278f, 0.02685910f, -0.03623189f, 0.01849081f, 0.01267346f, -0.06848706f, -0.00211739f, 
    0.05599487f, 0.01394247f, -0.03281434f, 0.02590333f, -0.01533961f, -0.07313528f, -0.02684461f, 0.05868217f, 
    -0.02090359f, -0.00410848f, -0.04209328f, -0.01787115f, 0.06500175f, 0.05334760f, -0.04071026f, 0.04631673f, 
    0.04837476f, -0.05294120f, -0.03774830f, -0.04268347f, -0.00975373f, 0.00050698f, 0.01159425f, -0.02479484f, 
    -0.02102190f, 0.02383701f, 0.01735164f, -0.00629041f, -0.01997526f, -0.00110162f, 0.00651360f, -0.01080045f, 
    0.04048332f, -0.02461900f, -0.00084753f, -0.05840729f, 0.01689654f, 0.06306601f, 0.01873299f, 0.01670408f, 
    -0.03474015f, 0.05095667f, 0.01191674f, -0.07457458f, 0.02062824f, -0.04914836f, 0.02986219f, 0.01669517f, 
    0.01459080f, -0.02744068f, 0.04717940f, -0.00076758f, 0.01513675f, 0.04816937f, -0.06249525f, -0.03405746f, 
    -0.07585763f, 0.04132150f, -0.02719000f, 0.03381473f, -0.04588410f, -0.04986202f, -0.03217839f, -0.01168527f, 
    0.01385812f, 0.00004098f, -0.03611277f, -0.05129151f, -0.06446762f, -0.05595522f, 0.03219693f, 0.02839328f, 
    -0.06312858f, -0.06442646f, -0.00745434f, -0.05381306f, 0.00586695f, -0.00660963f, 0.00153907f, -0.06753465f, 
    0.00570431f, 0.04968955f, -0.06073079f, -0.00862457f, -0.06372461f, -0.04158868f, -0.00579741f, -0.04461747f, 
    0.01426020f, -0.05485879f, -0.07083371f, -0.08092736f, 0.03472602f, 0.01992945f, -0.00636256f, -0.00762823f, 
    0.05851438f, -0.06281376f, -0.00867764f, 0.03509192f, 0.02069862f, 0.04300538f, -0.07146575f, 0.05551317f, 
    0.04244203f, -0.07083684f, -0.00628242f, 0.04513611f, 0.04764982f, -0.02517275f, 0.03190996f, -0.06493953f, 
    -0.04339610f, -0.00089069f, -0.04798452f, -0.06979527f, -0.06205662f, -0.02530420f, 0.04760846f, -0.00188369f, 
    0.01599885f, -0.04240346f, 0.03275729f, -0.04452286f, -0.00146079f, -0.01278654f, 0.05196259f, 0.02450320f, 
    0.05949182f, -0.00349300f, 0.00940278f, 0.00345368f, -0.03870786f, -0.00925532f, -0.05959441f, 0.05139856f, 
    0.04631808f, -0.00333572f, -0.04643037f, 0.02975628f, -0.01410742f, 0.01653340f, -0.01220886f, 0.04506835f, 
    -0.00790899f, 0.01041868f, -0.02103637f, 0.00368977f, 0.02835951f, -0.00991292f, -0.07867876f, -0.05098208f, 
    0.01159673f, -0.06815937f, -0.00349547f, -0.03582773f, -0.06008203f, 0.02095693f, -0.00062956f, -0.05944839f, 
    -0.20140585f, -0.06018552f, -0.07833092f, -0.08638771f, 0.03588170f, -0.04346976f, 0.21704215f, -0.31005186f, 
    0.01704502f, -0.11112432f, -0.05428560f, 0.08446548f, -0.02965119f, -0.01541325f, 0.07680538f, 0.12792654f, 
    -0.00343363f, -0.00369930f, 0.01465801f, -0.05312442f, 0.04432983f, 0.01096800f, 0.03167783f, -0.13701700f, 
    0.50812405f, 0.11328456f, -0.11750512f, -0.11851738f, -0.10004448f, 0.05657853f, 0.15457679f, -0.08448588f, 
    0.08213625f, 0.09839497f, -0.05214057f, -0.17224315f, -0.13014285f, -0.00523031f, -0.10213950f, 0.03731433f, 
    -0.09187082f, -0.03345820f, -0.00693101f, -0.20517583f, -0.00220498f, 0.05080494f, 0.04615628f, 0.11483921f, 
    -0.01974951f, 0.06501415f, 0.25276867f, 0.05533976f, 0.21115322f, 0.07777783f, 0.12034694f, -0.00354669f, 
    0.03789369f, 0.09631563f, -0.01148681f, 0.02526349f, 0.18494406f, 0.06070696f, 0.17007104f, 0.07020741f, 
    -0.07640351f, -0.09389810f, -0.06049207f, 0.05051963f, 0.02329712f, 0.15639737f, 0.10347068f, 0.06040309f, 
    0.47473562f, 0.07962218f, 0.03057052f, -0.10418497f, -0.04862723f, 0.09076419f, 0.08906563f, -0.05236590f, 
    0.11103967f, 0.08352821f, 0.02088823f, 0.23280682f, -0.20787123f, -0.24236251f, -0.10162353f, -0.15535793f, 
    -0.05962164f, -0.07710720f, -0.16598730f, -0.13078862f, -0.03350821f, 0.07010658f, -0.01360979f, 0.19044180f, 
    -0.21700099f, 0.13769417f, 0.00296422f, -0.10607591f, -0.20836456f, -0.05433067f, -0.07937907f, 0.07905754f, 
    0.01941859f, -0.01820756f, -0.08629687f, -0.13066980f, 0.18853027f, 0.12755398f, 0.14158554f, 0.09150080f, 
    0.14716704f, -0.13368869f, -0.01432913f, -0.08783080f, 0.37894487f, 0.31174627f, 0.26208514f, 0.21104589f, 
    0.04856636f, 0.09852829f, 0.07061930f, 0.04548499f, -0.03758413f, 0.20173837f, 0.13776527f, 0.06164066f, 
    0.00062747f, 0.09469814f, 0.01692646f, -0.00781486f, -0.65006125f, 0.16987352f, -0.02347802f, -0.33366573f, 
    -0.11058160f, -0.01011370f, -0.02142739f, 0.11949079f, -0.19564635f, 0.13248593f, 0.06270517f, -0.06211514f, 
    -0.09676966f, -0.17406696f, -0.01728210f, -0.10368500f, 0.17738120f, -0.03940516f, 0.16227569f, -0.18895054f, 
    0.11013754f, -0.17726828f, 0.11046666f, 0.09495471f, -0.04930118f, 0.11309965f, 0.11827303f, -0.30853388f, 
    0.04192425f, -0.04745195f, 0.11171503f, 0.04284779f, 0.05702725f, 0.12665048f, 0.07167160f, -0.04567908f, 
    -0.39606678f, 0.13907164f, -0.15305838f, 0.23304658f, -0.10612075f, 0.09583231f, 0.11163659f, 0.22534949f, 
    -0.06605785f, -0.03705904f, -0.00727300f, 0.13169248f, -0.61727244f, -0.02753617f, 0.25026366f, 0.46637180f, 
    -0.03269159f, -0.14860788f, 0.03935703f, 0.02342283f, -0.00721483f, 0.19136177f, 0.20703217f, 0.27167761f, 
    0.01425580f, -0.04609242f, -0.25927123f, 0.08123577f, 0.08074851f, -0.11953672f, 0.08156605f, -0.14087841f, 
    0.02600142f, -0.06470883f, -0.01717915f, 0.06893551f, 0.21678136f, -0.02088115f, -0.31497034f, 0.09454625f, 
    0.23374774f, 0.02497735f, 0.38588044f, 0.11478124f, -0.14623725f, -0.03657094f, 0.15550286f, 0.01399076f, 
    -0.02069931f, -0.11749233f, 0.42209199f, 0.08646265f, -0.21869111f, 0.04288487f, -0.11642864f, 0.09665793f, 
    0.06470729f, -0.05640484f, 0.13281679f, -0.20498744f, 0.22814268f, 0.24885373f, -0.27855092f, 0.20299295f, 
    -0.02119856f, 0.00423468f, 0.13118938f, -0.04466157f, -0.12996882f, 0.07723150f, 0.02225183f, -0.08044185f, 
    -0.24534668f, -0.31758425f, 0.15540378f, 0.19476104f, 0.12191194f, 0.08984641f, 0.09467421f, 0.03022068f, 
    0.11398622f, 0.06233285f, -0.12283628f, 0.11435174f, -0.05150131f, 0.08227412f, -0.08615913f, -0.02119478f, 
    0.00401517f, -0.02706534f, -0.08410349f, 0.01318924f, -0.15112233f, 0.11085074f, 0.03632498f, 0.09391952f, 
    -0.00202629f, 0.06760059f, 0.29683432f, 0.34206766f, -0.01406782f, 0.01534844f, -0.06420505f, -0.06390666f, 
    -0.00566094f, 0.08117227f, 0.14917095f, 0.20220898f, 0.09103676f, -0.19327560f, -0.19999880f, 0.01191825f, 
    0.19032183f, -0.08171917f, 0.02743224f, -0.06917398f, 0.10970297f, 0.11169387f, 0.01470864f, 0.05312933f, 
    -0.22894986f, -0.29458895f, -0.35745445f, -0.13264401f, 0.15416840f, -0.03613828f, -0.03404202f, -0.01668536f, 
    -0.06589520f, -0.06936081f, 0.03273494f, -0.09496430f, -0.09677378f, 0.24007598f, -0.04708402f, -0.44208029f, 
    0.00311243f, -0.05846284f, 0.05575583f, -0.06231203f, 0.03291949f, 0.01733310f, 0.20266151f, 0.11196471f, 
    0.09086065f, -0.15210477f, 0.08141482f, 0.01398047f, 0.04152828f, -0.09780839f, 0.20027919f, 0.12043027f, 
    0.04043178f, 0.13887039f, 0.05510835f, 0.12747128f, -0.59577817f, 0.02807964f, -0.30486056f, -0.21570377f, 
    -0.08376938f, -0.05737861f, 0.01707603f, 0.02232811f, 0.04871177f, 0.03727327f, -0.02789810f, -0.01087231f, 
    -0.29972365f, -0.18459293f, 0.17244561f, 0.06791855f, 0.00909229f, -0.02658909f, -0.19073623f, -0.07871079f, 
    -0.05070644f, -0.03650162f, 0.00543057f, 0.13519910f, -0.06970111f, -0.15095504f, -0.18131039f, 0.16482382f, 
    0.12656181f, 0.30041793f, -0.12036164f, 0.12064677f, -0.08234774f, -0.01926323f, 0.15128434f, -0.01054324f, 
    0.30641398f, 0.15997882f, -0.07048311f, 0.11101522f, 0.11320890f, 0.14407602f, 0.09475141f, -0.01420637f, 
    0.12512676f, 0.01985986f, 0.12032888f, -0.02714951f, 0.01074709f, -0.25477466f, -0.01148894f, 0.13642824f, 
    0.14038561f, -0.09446599f, -0.03893913f, 0.11771902f, 0.14438365f, 0.14102951f, 0.17061612f, 0.03303926f, 
    -0.06690993f, -0.29414746f, -0.63681781f, -0.33814046f, -0.06148460f, 0.34909976f, 0.02291677f, 0.19369869f, 
    -0.04397409f, 0.07781068f, 0.00841914f, 0.08899041f, -0.10987262f, -0.22819996f, -0.20147492f, -0.29073280f, 
    -0.21669924f, -0.00582765f, -0.38953626f, -0.13062409f, 0.03956952f, -0.17433986f, -0.12728599f, 0.31974626f, 
    0.31127074f, 0.07969958f, -0.12418765f, 0.13160524f, -0.05010941f, -0.03878344f, 0.04854438f, 0.19194792f, 
    0.04291145f, 0.29012799f, 0.08730877f, 0.10287556f, -0.06339544f, -0.37277752f, -0.28680521f, -0.36133736f, 
    0.25116131f, 0.21120584f, -0.10713302f, 0.13768114f, -0.09531824f, -0.00610852f, -0.02373854f, 0.05019822f, 
    -0.21605100f, -0.49306661f, -0.91019529f, -0.39072952f, -0.09451095f, -0.04034160f, -0.01292054f, 0.08670402f, 
    0.09972092f, -0.10063165f, -0.08592655f, -0.17884973f, 0.20828097f, 0.11098535f, 0.29738560f, 0.13888356f, 
    -0.03282194f, -0.05045373f, -0.00816486f, 0.04893655f, 0.05754277f, 0.04117843f, -0.02853311f, 0.14896882f, 
    0.60893470f, 0.25503111f, 0.13644487f, 0.40398213f, 0.00564180f, -0.08502389f, 0.04297977f, -0.00396443f, 
    -0.00334700f, -0.02548776f, 0.04252122f, 0.23920693f, 0.00029384f, 0.05786361f, 0.15526748f, 0.18586473f, 
    0.05031909f, 0.00157018f, -0.02186822f, -0.15176986f, -0.12394793f, -0.06680262f, -0.13011186f, -0.02244654f, 
    -0.16003290f, -0.09887245f, -0.16570975f, -0.65104681f, 0.03423586f, 0.21729112f, 0.21169397f, 0.17543040f, 
    0.38660610f, -0.00226806f, -0.03224112f, -0.10517383f, 0.25964457f, 0.11547302f, 0.17637095f, 0.21976525f, 
    -0.04585567f, 0.06990226f, 0.04329198f, -0.02921034f, 0.20636807f, 0.13990065f, -0.03964339f, 0.08444855f, 
    -0.04723307f, -0.03639451f, -0.15499614f, -0.17184007f, 0.15248600f, 0.18485165f, -0.02698792f, 0.23695657f, 
    0.03446578f, 0.03180056f, 0.09445018f, 0.24712156f, 0.00665622f, 0.06102692f, -0.21253775f, -0.18749611f, 
    -0.07783434f, 0.07021518f, 0.04389811f, 0.12548557f, 0.02777351f, 0.11496717f, -0.16931877f, -0.03598377f, 
    0.14077112f, -0.00438835f, -0.01339308f, 0.05635700f, 0.04679542f, -0.04332001f, 0.17870103f, 0.10931794f, 
    -0.03976874f, 0.09908520f, -0.04689305f, -0.02828510f, -0.06600127f, -0.56656343f, -0.30070487f, -0.04841653f, 
    0.23133746f, -0.12340053f, 0.14778312f, 0.10471759f, -0.05768376f, 0.08814169f, -0.00924527f, -0.08515848f, 
    -0.63752103f, -0.08943357f, -0.38663298f, -0.37652853f, 0.25839528f, 0.23510563f, -0.04127419f, -0.24237520f, 
    -0.06986750f, -0.10946275f, 0.00617077f, 0.11779601f, -0.10820268f, 0.18563342f, 0.00963243f, -0.07814439f, 
    -0.15467712f, -0.16110232f, 0.10487140f, -0.04197913f, -0.11805400f, 0.13928619f, 0.11761959f, -0.04733077f, 
    0.00609682f, -0.06603424f, -0.27557439f, -0.16106702f, -0.08645511f, -0.25694886f, -0.17432517f, -0.39959437f, 
    -0.01849441f, -0.00298103f, -0.00661027f, -0.02528513f, -0.20521221f, 0.05437492f, -0.17785478f, 0.17825286f, 
    -0.01471833f, 0.05369278f, 0.26211163f, -0.06836430f, 0.07415007f, 0.22784692f, 0.09841555f, 0.02102108f, 
    -0.03649227f, 0.09371082f, 0.28518280f, 0.12964387f, -0.01485869f, -0.09330222f, 0.01649910f, 0.06124151f, 
    -0.09128751f, 0.19567995f, 0.23371707f, 0.08167381f, 0.05485374f, -0.40125084f, -0.31272048f, 0.11442205f, 
    -0.13037138f, -0.04147892f, 0.17709380f, -0.22569449f, -0.04328990f, 0.08400329f, -0.08162496f, -0.08869049f, 
    -0.12050729f, 0.19516113f, 0.59867638f, 0.42107105f, 0.13573417f, -0.18387125f, 0.11978973f, 0.08158284f, 
    -0.13313679f, 0.12946483f, 0.07495385f, 0.02441427f, 0.12608965f, 0.21148086f, -0.03307706f, -0.11801226f, 
    0.01564121f, 0.10526261f, -0.01822875f, 0.08563884f, -0.04659229f, 0.10990914f, -0.05991814f, 0.20619918f, 
    0.22666825f, 0.26079878f, 0.46019113f, -0.20970419f, -0.01772684f, 0.04665644f, 0.06936181f, 0.04066342f, 
    -0.01800645f, 0.11471219f, -0.04019960f, 0.06974524f, 0.00288342f, -0.03228788f, -0.15584050f, -0.15713885f, 
    0.11575050f, -0.09392860f, 0.05420575f, 0.09125960f, -0.04555136f, -0.01820971f, 0.02207069f, -0.06156156f, 
    -0.18565777f, 0.01644509f, -0.15870084f, 0.05855686f, -0.11869149f, -0.01466826f, -0.15778308f, -0.00805671f, 
    -0.03278876f, 0.04456712f, -0.07760309f, -0.04107163f, 0.07426391f, -0.06516538f, 0.09855578f, -0.09304267f, 
    -0.02807359f, -0.06012182f, 0.19103120f, 0.04417647f, 0.32320088f, 0.06357254f, 0.22945753f, 0.19173196f, 
    -0.11496794f, -0.25460345f, 0.01850753f, -0.09499290f, 0.00042175f, 0.09570800f, 0.13656871f, -0.10702312f, 
    -0.02107504f, 0.04903597f, 0.24621962f, 0.04237356f, -0.33674210f, 0.08808785f, -0.06380854f, 0.00075972f, 
    -0.10547598f, 0.02560739f, 0.11407741f, -0.04907838f, -0.07884711f, -0.10031474f, 0.16902620f, -0.01813393f, 
    -0.00611714f, 0.08464254f, 0.08454402f, 0.14206898f, 0.04251829f, -0.04969794f, 0.16737691f, 0.15971993f, 
    0.02896364f, 0.00666957f, -0.12179842f, 0.11622246f, -0.36228782f, -0.18663153f, -0.00132701f, -0.21741553f, 
    -0.26531619f, -0.04704203f, -0.19828333f, 0.17485341f, -0.01489256f, -0.00112558f, -0.16002376f, -0.03557995f, 
    0.07267467f, -0.08205709f, -0.18408269f, 0.18405402f, 0.05552630f, -0.23183252f, -0.09464849f, -0.03481925f, 
    -0.03704280f, 0.02934650f, -0.02863257f, -0.13195847f, -0.26222867f, 0.15322448f, 0.00605904f, 0.18796639f, 
    0.01310600f, -0.02569691f, -0.05977637f, 0.08266059f, -0.02004128f, 0.12210776f, 0.06644000f, -0.04903936f, 
    0.12819029f, 0.04749246f, -0.01644495f, -0.23610970f, -0.00548230f, 0.09843095f, -0.00595542f, 0.21434635f, 
    0.02988224f, 0.00187970f, -0.00230561f, -0.01629748f, -0.00097288f, 0.12540807f, 0.12871769f, -0.25514066f, 
    0.06263913f, 0.01268037f, -0.05083584f, 0.07116014f, 0.10696314f, -0.12251185f, -0.03678169f, 0.00707425f, 
    -0.12849163f, 0.00772368f, -0.08791208f, -0.13794586f, 0.15213124f, 0.02670087f, -0.00483846f, -0.03365010f, 
    -0.03748339f, -0.03132881f, -0.04939546f, 0.11957496f, 0.05937686f, 0.02891057f, 0.23631218f, -0.19454955f, 
    0.11845724f, -0.00122265f, 0.07773118f, 0.16193037f, -0.02415443f, -0.08067077f, 0.03801469f, -0.08538503f, 
    0.19413415f, 0.25096926f, -0.06692725f, -0.31152943f, -0.21056075f, 0.04794766f, -0.09544762f, 0.11971632f, 
    0.19675137f, -0.05220785f, -0.07410923f, -0.04660457f, 0.12167642f, -0.15547347f, 0.07432241f, 0.07102872f, 
    -0.02036281f, -0.06011358f, 0.14878854f, -0.09474363f, 0.12965533f, 0.01246825f, 0.09068867f, -0.05368351f, 
    0.03739103f, 0.11597885f, -0.12295175f, 0.14490132f, -0.06507661f, 0.06132166f, 0.05115107f, 0.04661825f, 
    0.13021256f, -0.08668321f, 0.00476983f, 0.11751723f, 0.00406044f, 0.07808366f, 0.16948980f, 0.13475482f, 
    -0.21997817f, 0.22543083f, 0.01435889f, -0.03844560f, -0.05307987f, -0.07808322f, -0.09503248f, -0.02448810f, 
    0.23691440f, 0.10601777f, 0.17494833f, -0.17630573f, -0.00834615f, 0.10003292f, 0.06346845f, -0.12688719f, 
    -0.06232174f, -0.02320920f, -0.04294787f, 0.00131727f, 0.10888498f, -0.10578660f, 0.09778009f, 0.32874441f, 
    -0.07675480f, 0.01832782f, -0.09466787f, -0.04646650f, 0.06897819f, -0.08972529f, -0.21633333f, -0.13377218f, 
    0.08286660f, 0.24506314f, 0.10996396f, 0.07881168f, 0.02739951f, 0.22123207f, 0.01782438f, 0.08858645f, 
    -0.04153352f, -0.14379342f, -0.02324312f, -0.04383861f, 0.58407491f, -0.07417599f, -0.00439804f, 0.01548255f, 
    -0.06225046f, -0.01318290f, -0.02714550f, 0.05854201f, -0.03337125f, -0.06484061f, 0.04860111f, 0.06322131f, 
    0.09823430f, 0.06411341f, -0.19420126f, -0.14748523f, -0.08831678f, 0.20915107f, -0.09814034f, 0.07977679f, 
    -0.05232003f, 0.03920281f, 0.09138700f, 0.03803392f, -0.05797141f, 0.03897656f, 0.00875886f, -0.26432049f, 
    -0.02718236f, -0.09982071f, 0.11085539f, -0.04953929f, -0.01890501f, -0.13434738f, -0.20922203f, 0.00240476f, 
    0.06184363f, -0.07575613f, 0.16783337f, -0.09664562f, 0.02897074f, 0.12255780f, 0.11814453f, 0.00277669f, 
    -0.07488030f, -0.05789581f, -0.05063156f, -0.07020782f, -0.04787645f, 0.11481958f, -0.02348269f, -0.04482261f, 
    -0.06420692f, 0.25792539f, -0.00460760f, -0.02930344f, 0.05603303f, -0.10305677f, -0.05655227f, 0.04432124f, 
    -0.06219606f, -0.03727319f, -0.04430037f, 0.05128306f, 0.00856712f, -0.00052312f, 0.06754667f, -0.05345672f, 
    0.05214333f, 0.00585462f, 0.06767668f, 0.02683363f, -0.00315829f, 0.00408664f, 0.03740288f, 0.06905017f, 
    -0.05961883f, -0.06719390f, 0.03826141f, -0.05843993f, 0.03389299f, -0.01088506f, 0.01077466f, -0.04358491f, 
    -0.05646815f, -0.03044832f, -0.03675993f, 0.03948891f, -0.04596328f, -0.05037462f, -0.04330642f, -0.08211179f, 
    0.02376244f, 0.01347316f, -0.00086530f, 0.01861627f, -0.02739331f, -0.01716374f, -0.00867245f, -0.06026988f, 
    0.02656670f, 0.00730922f, -0.04971536f, -0.06208638f, -0.06273420f, -0.07705497f, 0.04379435f, -0.02550223f, 
    -0.03748980f, -0.04296882f, -0.06754259f, 0.03116174f, -0.00657362f, -0.07200675f, -0.06926391f, -0.00200708f, 
    0.00624724f, -0.06261344f, -0.01917974f, 0.04484101f, 0.03638228f, -0.02418966f, 0.00625777f, 0.01414743f, 
    0.04966493f, -0.03396166f, -0.03573730f, 0.03200443f, -0.05978098f, 0.02216299f, -0.03571833f, -0.01908098f, 
    0.07415177f, 0.04545845f, 0.01345202f, -0.01826377f, 0.02765164f, 0.06045380f, -0.03098403f, 0.05922228f, 
    -0.02663227f, 0.04126364f, -0.01045536f, -0.05593554f, 0.06549644f, -0.03617306f, 0.05473382f, -0.00863792f, 
    0.03649797f, -0.05512676f, 0.04601602f, -0.06314397f, -0.05082456f, 0.00784400f, 0.02829829f, -0.09085007f, 
    0.00118803f, -0.04390397f, -0.02994658f, -0.04618881f, -0.00954018f, -0.00854948f, 0.03410752f, -0.02418563f, 
    -0.04217149f, -0.04426836f, -0.00114879f, -0.05355295f, -0.07347946f, -0.08251734f, 0.01065274f, 0.04965146f, 
    -0.06929430f, 0.02836612f, 0.03821152f, -0.04526322f, 0.02278689f, -0.02070801f, 0.01532783f, -0.02416625f, 
    -0.07360806f, 0.03028008f, 0.02026852f, -0.01192788f, -0.02773540f, -0.07148990f, 0.02822092f, -0.03401397f, 
    0.05717979f, 0.04087880f, 0.07541250f, 0.06189575f, -0.04592942f, 0.04627874f, 0.05482560f, 0.03376453f, 
    -0.07447716f, -0.00711466f, -0.00451070f, -0.05857867f, 0.01620258f, -0.01997892f, 0.00288368f, 0.00453260f, 
    -0.01038240f, -0.01911970f, 0.01502239f, -0.06866767f, 0.03853532f, 0.06780937f, -0.03915893f, -0.03438029f, 
    -0.04879167f, 0.05278632f, -0.02674749f, -0.04053765f, 0.03339724f, -0.01062857f, -0.00592491f, 0.05428105f, 
    0.06813654f, 0.05311064f, -0.03681675f, 0.03178994f, -0.04315921f, 0.00661354f, 0.01314982f, 0.02698094f, 
    0.04637796f, -0.07975524f, -0.04995299f, 0.03254166f, -0.06035246f, 0.08372934f, -0.02871568f, -0.02713022f, 
    -0.03135228f, -0.05490801f, -0.01012172f, -0.05970492f, -0.01538759f, -0.08617601f, -0.00817628f, -0.08164174f, 
    0.02756820f, -0.07203796f, -0.07887093f, 0.03170922f, 0.03541584f, 0.02285587f, -0.03980567f, -0.07246030f, 
    0.06576176f, -0.03605723f, -0.02568555f, -0.43587801f, 0.00250646f, 0.11323524f, 0.09864174f, -0.05618888f, 
    0.03527737f, -0.15612067f, 0.04536614f, -0.00111800f, -0.01628759f, -0.04000513f, 0.51242197f, 0.20949180f, 
    -0.14220679f, 0.00138224f, 0.15813611f, 0.03130025f, -0.14271307f, 0.06673267f, 0.11167838f, 0.19469011f, 
    0.16748911f, 0.18628348f, -0.25013489f, -0.28240353f, -0.09368811f, -0.05481088f, 0.09196861f, 0.03354291f, 
    0.17398797f, 0.17359103f, 0.09037573f, 0.31675428f, -0.15034245f, -0.08591105f, -0.01981590f, -0.21184888f, 
    0.15772733f, 0.04844895f, 0.10752717f, -0.11759795f, -0.00045630f, 0.10287552f, 0.03835160f, 0.16670014f, 
    0.01765269f, 0.11516689f, -0.02896344f, -0.23204955f, -0.04379416f, -0.07241198f, -0.09007161f, 0.05882676f, 
    0.12713173f, -0.06298011f, -0.00010399f, 0.02128030f, 0.04162572f, -0.08110727f, -0.04340785f, 0.08669876f, 
    -0.00483610f, -0.21809623f, 0.07532859f, 0.01092210f, 0.11344227f, -0.04918711f, 0.18048570f, 0.21673691f, 
    -0.26950470f, -0.01634436f, -0.45334172f, -0.02494963f, 0.12135476f, -0.07883268f, 0.09283724f, -0.20029463f, 
    0.11069848f, -0.01282481f, 0.02357009f, 0.15223004f, -0.41161063f, -0.29123122f, -0.07582572f, -0.06303269f, 
    0.29052439f, 0.00404991f, 0.01899538f, 0.01509028f, 0.00551019f, -0.23067652f, -0.41607508f, -0.05304149f, 
    0.25689328f, 0.32219958f, 0.18702385f, -0.23792006f, -0.12156194f, 0.05139678f, 0.11879408f, 0.06166593f, 
    0.17506164f, 0.08703511f, 0.06594342f, 0.10935154f, 0.27347890f, 0.23044811f, 0.24807186f, 0.09746784f, 
    0.16014923f, -0.23128133f, -0.16817406f, 0.00733579f, 0.10303653f, 0.09690303f, 0.13589716f, 0.15724182f, 
    0.05685127f, 0.19034585f, -0.03539091f, -0.05601923f, 0.04355722f, 0.04822284f, -0.03075913f, 0.04890301f, 
    -0.02323044f, 0.07443158f, 0.25069085f, 0.04630827f, -0.15112913f, 0.27549663f, 0.68197685f, 0.04070480f, 
    -0.27828810f, -0.17434353f, -0.24886678f, -0.05233662f, 0.02299382f, 0.03702106f, 0.08828417f, 0.20804249f, 
    -0.25104246f, -0.43804550f, -0.57368767f, -0.22773665f, 0.03753849f, -0.00634520f, 0.04028122f, -0.02018605f, 
    0.18628043f, -0.19104584f, -0.02516284f, 0.13261710f, -0.29478946f, 0.22664943f, 0.02476649f, -0.43190664f, 
    0.08845586f, -0.17847618f, -0.16475309f, -0.06844509f, -0.00611443f, -0.11276446f, -0.06319424f, -0.09593970f, 
    0.08340821f, -0.43847641f, 0.08483826f, -0.16334987f, 0.12059637f, 0.09208152f, -0.04004098f, 0.09700660f, 
    -0.11489864f, -0.13175966f, -0.02128544f, -0.03640480f, -0.34686568f, 0.32281899f, 0.24150717f, 0.48706636f, 
    -0.11876094f, -0.07574382f, 0.10529520f, 0.03383877f, -0.07466178f, -0.06121152f, -0.15425381f, 0.22699116f, 
    -0.02062256f, -0.02664674f, 0.04701065f, -0.05930407f, -0.03783520f, 0.04120585f, -0.05476486f, -0.03723647f, 
    0.06695329f, -0.05004578f, -0.06324403f, -0.06538810f, -0.01448333f, -0.02763390f, -0.00292886f, -0.05023470f, 
    0.06185011f, -0.06252477f, 0.00686883f, 0.03450530f, 0.01571752f, 0.04928638f, 0.06435512f, 0.02372992f, 
    -0.03875299f, -0.01694142f, -0.04220306f, -0.01892744f, -0.05403407f, -0.07231829f, -0.04833562f, 0.05367797f, 
    0.06547831f, 0.04131906f, -0.04223993f, -0.02291436f, 0.01179209f, -0.07357112f, -0.00615018f, 0.03203921f, 
    0.00533171f, 0.00617297f, -0.00495430f, 0.00312837f, 0.00971820f, -0.04204703f, -0.01843691f, -0.06859557f, 
    -0.05927047f, -0.05999355f, 0.05383529f, -0.03275884f, 0.03764870f, 0.00543731f, -0.01778386f, -0.02516609f, 
    0.00614126f, -0.02787699f, -0.04680362f, -0.04637657f, -0.06043216f, 0.01042525f, -0.06510180f, 0.06560877f, 
    -0.05701456f, -0.02031615f, -0.03936135f, -0.07569111f, 0.06522350f, -0.00996229f, 0.01473740f, -0.05369283f, 
    -0.05248252f, -0.04151716f, -0.06570185f, -0.06156848f, 0.05227439f, -0.02798840f, 0.00633722f, -0.01474709f, 
    0.02906600f, -0.06691052f, 0.01943217f, -0.06692576f, -0.07242472f, 0.02023459f, -0.04545053f, -0.05992297f, 
    -0.02436752f, -0.05458005f, -0.04639562f, -0.05689304f, 0.04578600f, 0.00171479f, -0.03661798f, -0.02140162f, 
    -0.00664712f, -0.03485588f, -0.03412052f, -0.02373743f, -0.01574378f, -0.06247423f, 0.01950993f, -0.00337669f, 
    0.03893302f, -0.02413431f, -0.07275950f, 0.05615470f, 0.00727302f, 0.04383679f, -0.01450288f, 0.00511649f, 
    -0.01155590f, -0.07614373f, -0.05900210f, -0.04427907f, 0.05815071f, 0.00959241f, 0.06463054f, -0.02141973f, 
    -0.02350230f, -0.06492174f, -0.00161090f, 0.05081903f, -0.06960959f, 0.04007662f, -0.03377400f, 0.04738276f, 
    0.04226178f, 0.05200690f, -0.02969249f, -0.06423728f, -0.01064938f, -0.04073086f, 0.02613902f, 0.01910531f, 
    -0.00208641f, -0.04854942f, -0.06932531f, -0.00566966f, -0.01576939f, -0.03600905f, -0.06661814f, 0.03281468f, 
    0.05165354f, 0.05743066f, 0.03119411f, -0.03856585f, -0.06413081f, 0.06656380f, -0.06345812f, 0.04641920f, 
    0.02725280f, -0.02019264f, 0.00430645f, -0.06276538f, 0.04978379f, 0.04141014f, -0.07184219f, -0.00793514f, 
    -0.04152031f, 0.04274417f, -0.01093132f, 0.06647230f, -0.06205881f, 0.06614838f, 0.06500075f, -0.02121882f, 
    0.02763094f, -0.04429233f, -0.04797551f, -0.04054507f, -0.03397584f, -0.06186556f, 0.03921425f, 0.04632355f, 
    0.02321456f, 0.00479303f, -0.04960988f, -0.05558319f, -0.03829180f, 0.05978311f, 0.01015446f, 0.02480855f, 
    -0.00397096f, -0.00964747f, -0.01470303f, -0.04587432f, -0.02174764f, -0.00014966f, 0.00888315f, 0.01594064f, 
    0.03775476f, -0.05957466f, 0.04372094f, -0.05265212f, -0.07852205f, 0.02508824f, -0.00782857f, 0.03618634f, 
    -0.06412265f, -0.06002340f, 0.05727009f, 0.02783762f, -0.02962298f, -0.04840639f, 0.04471067f, -0.06232711f, 
    -0.01466809f, -0.03344845f, -0.04630874f, -0.01097267f, 0.01110894f, 0.01202326f, -0.07833096f, 0.02826650f, 
    0.05798129f, -0.00776649f, -0.06484599f, -0.06374048f, 0.02128311f, 0.05029381f, -0.07785559f, -0.01912708f, 
    0.00880171f, -0.02158650f, -0.04615227f, -0.03139227f, 0.03434335f, -0.03376975f, 0.02403895f, 0.00116635f, 
    0.04510066f, 0.03437814f, -0.02615945f, 0.04607539f, 0.03693962f, -0.03157159f, 0.05695979f, 0.07152061f, 
    0.00733205f, 0.02384206f, -0.05627065f, -0.06226345f, 0.03528504f, 0.01088357f, 0.05683404f, 0.03235867f, 
    0.03186876f, -0.07216052f, 0.02990706f, 0.03064136f, -0.05341707f, -0.02793261f, -0.07401294f, -0.01959299f, 
    0.05724509f, 0.00989493f, -0.00794785f, 0.03536401f, -0.04873050f, -0.05940552f, 0.03122331f, -0.01065172f, 
    0.00414741f, -0.03682379f, 0.03317065f, -0.00590930f, 0.02979725f, -0.04376046f, 0.03453611f, 0.02376146f, 
    -0.02860705f, 0.03311681f, 0.03339253f, -0.06895575f, 0.00551654f, 0.00156551f, 0.04647159f, 0.01675818f, 
    -0.01435161f, -0.01475796f, -0.04885311f, -0.04549571f, 0.01877147f, -0.05957270f, 0.04067044f, -0.01019014f, 
    -0.02895464f, -0.04426337f, -0.04643612f, -0.05188246f, 0.06221490f, 0.01867092f, 0.02285499f, 0.01018650f, 
    -0.02652719f, 0.02991420f, 0.03419064f, 0.04233965f, -0.05100604f, 0.01752204f, -0.00716644f, 0.01856123f, 
    -0.04418042f, -0.07561693f, 0.02572106f, -0.02632510f, 0.00510883f, 0.00610723f, 0.01492883f, 0.00317455f, 
    0.06471681f, 0.02783317f, -0.00303748f, -0.02762803f, 0.00220849f, -0.04687177f, 0.06025184f, -0.06889643f, 
    -0.07271598f, -0.06247280f, -0.07210056f, 0.00992159f, 0.03928917f, -0.00552787f, 0.06058447f, -0.02364530f, 
    0.08386173f, -0.05349881f, -0.02337132f, -0.02432605f, -0.04548239f, -0.00662509f, 0.05494768f, -0.01893467f, 
    -0.04543447f, 0.00336756f, -0.06004540f, 0.02138205f, -0.05986347f, 0.01312205f, 0.01898661f, 0.03697875f, 
    -0.03929016f, 0.04198035f, -0.01814819f, -0.04063418f, 0.01980213f, -0.01354598f, 0.03988928f, -0.01161125f, 
    0.04884681f, 0.02509343f, -0.07816531f, -0.05467873f, -0.02139771f, 0.01076432f, 0.00121301f, -0.05263967f, 
    -0.03135832f, -0.05556349f, 0.03317928f, 0.04401509f, 0.01214358f, 0.02819955f, -0.06660105f, 0.02959034f, 
    -0.01129803f, 0.05135328f, -0.04914751f, 0.02385018f, 0.05916065f, 0.03389574f, -0.00210177f, -0.02505606f, 
    0.00142937f, -0.03876238f, -0.00959910f, 0.00603903f, -0.06429286f, -0.05916535f, -0.04420238f, -0.03054122f, 
    -0.01579972f, -0.04322487f, 0.06021401f, 0.02328628f, -0.00825022f, 0.02569782f, -0.03237336f, 0.01211016f, 
    -0.07896447f, -0.03576917f, -0.00312878f, -0.06996633f, 0.02849814f, -0.03524862f, -0.08040877f, -0.05098902f, 
    -0.00409690f, -0.02227749f, -0.03983999f, -0.05322731f, 0.02973930f, -0.02236675f, -0.01136606f, -0.06042891f, 
    -0.05348175f, -0.06270575f, 0.03808167f, 0.05860814f, -0.06550326f, -0.06703649f, -0.01227794f, -0.04894640f, 
    -0.03163133f, 0.06413002f, -0.03575669f, 0.03645696f, 0.02801376f, 0.05648066f, -0.00810243f, -0.03882751f, 
    -0.02361713f, 0.05862116f, -0.07924523f, -0.01256229f, -0.03337336f, 0.03199572f, -0.01724668f, 0.05048672f, 
    0.01226774f, -0.07365090f, -0.07793351f, 0.03266972f, -0.06019960f, -0.04969116f, 0.03454203f, 0.02432848f, 
    0.03690977f, -0.05936431f, -0.03887035f, 0.01152554f, 0.02535545f, 0.03188614f, -0.02795725f, -0.05231039f, 
    0.02307513f, -0.07698029f, 0.03330836f, 0.05984721f, -0.03882174f, -0.04406602f, 0.00210595f, 0.03633454f, 
    0.05026131f, -0.07749361f, 0.00930815f, -0.05788007f, -0.04035858f, 0.02472659f, 0.03376873f, 0.05009806f, 
    -0.02605031f, 0.01473837f, 0.00707657f, 0.03480625f, 0.03977405f, -0.05442794f, -0.03006756f, -0.06682976f, 
    0.00956564f, -0.07804096f, -0.02956516f, -0.05089462f, -0.00477991f, 0.00260378f, -0.00121617f, 0.04651996f, 
    -0.01165017f, -0.05279996f, 0.01752189f, -0.03220922f, -0.01211535f, 0.01287762f, 0.03671419f, 0.05645160f, 
    -0.01459252f, 0.03950761f, 0.01685731f, -0.02676198f, -0.00115500f, 0.00770911f, 0.01529291f, 0.01805537f, 
    0.05158522f, 0.03711015f, -0.05109378f, 0.05577468f, 0.01544734f, -0.05053493f, 0.00497570f, -0.00734169f, 
    -0.06992869f, -0.04996365f, -0.06972297f, 0.05565546f, -0.06968604f, -0.06043884f, -0.04701094f, 0.02282223f, 
    -0.01558929f, 0.00758084f, -0.01486012f, -0.00984552f, -0.04692754f, -0.01566623f, 0.00903767f, -0.07586183f, 
    -0.01158983f, -0.07614161f, -0.07241874f, -0.06008358f, 0.06424112f, -0.06091782f, -0.05901863f, -0.00480074f, 
    0.02495362f, 0.06296221f, -0.07312404f, 0.02488415f, -0.03033933f, -0.04242747f, -0.00577676f, -0.05563810f, 
    0.05939465f, -0.06748538f, -0.06933744f, 0.01267671f, -0.01697368f, -0.01865792f, 0.03856161f, -0.02185606f, 
    0.04905753f, 0.00202630f, 0.02169046f, 0.03725816f, 0.05111282f, 0.04883816f, 0.00638294f, -0.06496427f, 
    0.05614270f, -0.01281700f, 0.03992309f, -0.00895414f, -0.02826433f, 0.00227561f, 0.05526320f, 0.03975341f, 
    0.05403433f, -0.07702397f, 0.00567212f, -0.07976802f, 0.03330243f, 0.04134773f, -0.04203916f, 0.01834208f, 
    -0.01140777f, -0.02808578f, -0.07766135f, -0.00054087f, 0.02113416f, -0.00826039f, -0.00398911f, 0.02377596f, 
    -0.18355677f, -0.17803717f, 0.05898023f, -0.18769658f, -0.00952746f, -0.00435626f, 0.21462125f, 0.06226978f, 
    -0.00881422f, 0.02426963f, -0.08952055f, 0.04012778f, 0.11570635f, -0.11704833f, 0.09522510f, -0.06878289f, 
    -0.01757018f, 0.06302558f, -0.05007078f, -0.07692315f, 0.05284270f, 0.08846284f, -0.16264977f, 0.10341275f, 
    0.17845021f, -0.10953448f, 0.07742792f, -0.23278566f, 0.01585121f, 0.12579179f, 0.07409462f, 0.01315564f, 
    0.13340782f, -0.05739110f, 0.02312431f, -0.09034260f, -0.00688709f, 0.31562310f, 0.05734842f, -0.04932548f, 
    0.20088601f, -0.09623709f, 0.00414492f, 0.07513697f, 0.01320486f, -0.05203806f, 0.00870241f, -0.03762151f, 
    -0.03980688f, -0.07034767f, 0.06013853f, -0.34430221f, -0.05538343f, 0.12194166f, -0.10836270f, 0.16127811f, 
    0.22471178f, 0.16421407f, -0.20263077f, 0.08343433f, -0.03771716f, -0.11416710f, -0.03640581f, 0.18157062f, 
    -0.04146125f, -0.10030114f, -0.07416365f, -0.00131735f, -0.04820200f, -0.02597300f, 0.05544253f, -0.04999489f, 
    0.17175570f, 0.04973710f, -0.28871721f, 0.29818666f, 0.09806892f, 0.00722670f, 0.13921052f, -0.06612253f, 
    0.06524970f, -0.04306824f, 0.06440718f, 0.11381026f, -0.03879967f, 0.05912384f, -0.09708803f, 0.06356379f, 
    0.03842875f, 0.13864475f, 0.07072629f, -0.12809055f, 0.00946148f, 0.04984934f, -0.01039002f, 0.18137665f, 
    0.07747028f, -0.13195974f, 0.11856123f, -0.23731670f, -0.01492482f, 0.09630001f, 0.14206244f, 0.07198951f, 
    -0.00316517f, -0.03758058f, 0.03194780f, -0.08495200f, 0.00988304f, 0.19041355f, -0.12059944f, 0.12013468f, 
    -0.05894558f, -0.17573096f, 0.03506838f, -0.07719865f, 0.25804985f, 0.04150710f, 0.00806939f, -0.07839245f, 
    0.15411986f, 0.01859653f, -0.00800322f, 0.05043016f, 0.00692633f, 0.05024697f, -0.03481780f, 0.05838798f, 
    -0.06696784f, -0.03038420f, -0.20039916f, -0.09655532f, 0.07644955f, -0.20970224f, 0.18055074f, -0.17844920f, 
    0.03347769f, 0.01025501f, -0.01307896f, 0.03655730f, -0.05184400f, 0.02208146f, 0.01261399f, 0.01913901f, 
    -0.19104594f, 0.02841460f, -0.18561029f, -0.13920626f, -0.03915527f, -0.13534972f, 0.21085069f, -0.04990720f, 
    0.00270851f, -0.10497964f, 0.04842034f, 0.08922043f, -0.21117698f, 0.12064213f, -0.06484830f, -0.19306350f, 
    0.08279742f, 0.01630805f, 0.32712761f, 0.04998131f, 0.06425972f, 0.05990919f, -0.00182022f, -0.03662449f, 
    0.05541842f, 0.03513273f, 0.04803203f, -0.05591396f, 0.07833054f, 0.13436814f, 0.28321967f, 0.09558459f, 
    0.05733769f, 0.16457969f, 0.00527906f, -0.03497488f, -0.13732085f, -0.04671035f, 0.13368927f, 0.43145242f, 
    0.10140785f, 0.13943507f, -0.03941195f, -0.07226339f, -0.17084572f, -0.01764752f, 0.03055370f, 0.24780016f, 
    0.06104311f, 0.10143511f, -0.17883560f, -0.29375029f, 0.21701296f, 0.05805660f, 0.18142889f, -0.11148196f, 
    -0.05439130f, -0.04877440f, 0.02583038f, 0.15703146f, 0.16097362f, 0.22531255f, -0.07533637f, 0.29641974f, 
    -0.07323413f, 0.15326294f, -0.07496373f, -0.07289261f, -0.12942792f, -0.12883319f, -0.06398542f, -0.13966578f, 
    -0.11701101f, 0.17680688f, 0.06406593f, 0.18359439f, 0.00805861f, -0.02933863f, -0.17723636f, -0.21171311f, 
    -0.00651321f, -0.12161721f, -0.23494413f, -0.10114405f, 0.11070682f, -0.04354606f, -0.29836074f, -0.24564970f, 
    0.06171862f, -0.05573269f, 0.16182980f, -0.15197884f, -0.14550261f, -0.07505135f, 0.09916345f, -0.19660997f, 
    0.13529591f, 0.34939069f, 0.27817905f, 0.59470761f, 0.40045947f, 0.01092921f, 0.07114989f, 0.06484028f, 
    -0.07046197f, -0.02256748f, 0.06967837f, 0.04407646f, -0.12914374f, -0.10563599f, 0.10651466f, 0.18588087f, 
    -0.04616466f, 0.12573832f, 0.00274133f, 0.02884030f, -0.00343406f, 0.13417406f, 0.12967566f, 0.23744245f, 
    0.38643643f, -0.05560482f, 0.08969507f, 0.19563164f, -0.05029110f, 0.11590832f, -0.08132191f, -0.06025906f, 
    0.10147022f, -0.08894652f, -0.04037955f, 0.16504858f, -0.08012605f, -0.15096611f, -0.05079224f, -0.07205810f, 
    -0.03650153f, -0.05504702f, -0.14028393f, 0.03307008f, -0.06622325f, -0.12108777f, 0.07703261f, -0.07210726f, 
    -0.13903661f, -0.17807379f, -0.16336338f, -0.16582292f, -0.04729374f, 0.23654504f, -0.09263752f, -0.06640907f, 
    0.07659128f, -0.13820527f, -0.06048048f, -0.10803130f, 0.14215577f, -0.08141589f, -0.03951007f, 0.00484140f, 
    -0.03211637f, -0.07049531f, 0.14044924f, 0.03014035f, 0.35239610f, 0.25826624f, 0.01689458f, 0.10958415f, 
    0.29212743f, 0.20223305f, 0.02809167f, 0.15526244f, 0.05793197f, 0.18771696f, 0.28619874f, -0.10884150f, 
    0.03239051f, -0.10855803f, -0.01564321f, 0.02177793f, -0.26623467f, 0.08179656f, -0.01207815f, -0.03688926f, 
    -0.08830705f, -0.04850262f, 0.10773300f, 0.16460140f, 0.04961561f, -0.09695899f, -0.09874020f, -0.06713793f, 
    -0.20925906f, -0.02635336f, -0.01240543f, 0.13374299f, -0.18884966f, -0.13153926f, 0.07058789f, -0.06532975f, 
    0.06100880f, 0.11594269f, 0.12957595f, 0.21730146f, 0.02301067f, 0.13551150f, 0.10150835f, 0.21544431f, 
    -0.12291248f, 0.42227462f, 0.15961333f, -0.12576360f, -0.03570316f, -0.02694173f, -0.12992117f, -0.18445240f, 
    0.24348882f, 0.22247133f, -0.17571583f, 0.00504767f, -0.01380375f, 0.26894578f, 0.09528837f, 0.11101885f, 
    -0.12729508f, 0.01274857f, -0.00184000f, 0.07994770f, -0.27240297f, 0.07012166f, -0.10426345f, 0.18798411f, 
    -0.06913605f, 0.12802887f, -0.09509962f, 0.07263106f, 0.02598924f, -0.02456354f, 0.14760461f, 0.10569067f, 
    0.29149562f, 0.10030785f, 0.07894728f, -0.08472767f, -0.04313032f, 0.08230621f, 0.11144493f, 0.22962177f, 
    0.05422135f, -0.01637446f, -0.01804096f, 0.07379486f, 0.19151141f, -0.02434060f, -0.08164395f, -0.30282119f, 
    0.11030611f, -0.04401606f, -0.04795146f, 0.08976620f, -0.07462727f, -0.06313556f, 0.11913610f, 0.13904116f, 
    -0.09772406f, -0.17710680f, -0.04661853f, 0.00681499f, -0.07975120f, 0.11489353f, -0.00878584f, 0.08248886f, 
    0.02176483f, 0.02481930f, 0.13604398f, -0.07332837f, 0.26930818f, 0.46418408f, 0.13256353f, -0.10178664f, 
    0.19913262f, -0.01115816f, -0.05732308f, 0.40419668f, -0.01829033f, 0.13119733f, -0.04533000f, 0.03876380f, 
    -0.08330769f, -0.17835625f, -0.20463474f, -0.47467521f, -0.22709113f, 0.15424047f, -0.11208969f, 0.05834619f, 
    0.11087492f, 0.02866026f, -0.07341617f, 0.07553772f, 0.06457555f, -0.05139463f, -0.14896145f, 0.26785010f, 
    0.05224475f, -0.14198367f, -0.11786364f, -0.11999070f, 0.08563330f, 0.03293389f, 0.01190065f, 0.02279318f, 
    -0.18515517f, 0.05256627f, -0.17408352f, 0.56634557f, 0.20084211f, -0.12252870f, 0.08919084f, 0.09326898f, 
    0.12067135f, 0.11370839f, 0.00410785f, 0.28446615f, -0.02762913f, -0.12633508f, -0.06532095f, 0.22062279f, 
    0.07921167f, 0.03701565f, -0.01470350f, -0.19752549f, -0.02208712f, 0.12990163f, -0.39838433f, 0.07239484f, 
    0.28911299f, -0.13019061f, 0.12430146f, -0.08509749f, 0.12695050f, -0.03084059f, -0.03888320f, -0.07012687f, 
    -0.10283079f, -0.03372122f, 0.01451177f, -0.08317863f, -0.34726191f, 0.24116096f, -0.03258341f, 0.14890786f, 
    -0.16439602f, 0.01882855f, -0.13466752f, -0.07801882f, -0.05773198f, 0.00633166f, 0.07820185f, 0.01226103f, 
    0.17001575f, 0.07393774f, 0.12400422f, 0.03086807f, 0.10577538f, -0.11460832f, -0.09550732f, 0.10865162f, 
    0.05266474f, -0.00265741f, -0.01724331f, 0.09987915f, 0.39218187f, -0.36898905f, -0.04333569f, 0.07222848f, 
    0.24149610f, 0.02839672f, -0.12630448f, -0.07459241f, 0.16910057f, -0.08635262f, 0.12259312f, 0.12015978f, 
    -0.10420291f, -0.03110964f, -0.19672790f, -0.14980450f, 0.01950335f, 0.02214487f, -0.02622909f, 0.04164036f, 
    -0.09351198f, -0.00647099f, -0.04631881f, -0.06581181f, 0.09875159f, 0.21337996f, -0.25119802f, -0.08119642f, 
    0.21397567f, 0.07170491f, 0.08113428f, -0.04170346f, 0.04044904f, 0.10431889f, -0.01352863f, 0.07923072f, 
    0.28841093f, -0.04450629f, 0.25555882f, -0.02930670f, 0.14899686f, -0.02316873f, 0.24713714f, -0.08127057f, 
    0.06729592f, -0.16987355f, 0.08299837f, -0.01806404f, -0.02387029f, -0.28958529f, -0.20539132f, -0.02545026f, 
    0.15057173f, -0.07878458f, -0.25479636f, -0.05425731f, -0.03619817f, 0.03619647f, -0.06828731f, 0.03031916f, 
    -0.46168959f, -0.46840966f, -0.31841680f, -0.02960346f, 0.00608091f, 0.00253793f, -0.04820431f, 0.07056213f, 
    0.00520158f, 0.00977634f, -0.14794055f, -0.02662115f, 0.08525976f, -0.00327521f, -0.15035373f, -0.15820342f, 
    -0.01422323f, -0.25479916f, 0.07198048f, 0.22814274f, 0.25133824f, 0.27686280f, 0.15932474f, 0.26255798f, 
    0.37816036f, -0.06560592f, 0.24322456f, 0.02665072f, -0.04491410f, 0.04117380f, 0.10591008f, 0.13508247f, 
    0.04523305f, 0.17371465f, 0.31338528f, 0.19380301f, -0.17163739f, -0.01183283f, -0.08743383f, -0.04159244f, 
    -0.00789605f, -0.02532590f, 0.16866788f, 0.23372161f, -0.00378799f, 0.08330578f, 0.00092635f, -0.07451319f, 
    -0.04391909f, 0.05116992f, 0.42249987f, 0.03185864f, -0.07677693f, -0.10234790f, -0.22577158f, 0.06683668f, 
    0.05427665f, 0.11272175f, 0.01884635f, 0.04390378f, 0.16385335f, -0.06163640f, -0.03307375f, 0.00525903f, 
    -0.00755713f, -0.00885882f, -0.02705314f, 0.08468416f, -0.00793072f, -0.13122241f, -0.02873005f, -0.16349657f, 
    0.30137679f, 0.36117265f, 0.54537982f, -0.11607865f, 0.02398732f, -0.01749241f, 0.04676460f, 0.05604647f, 
    -0.12317190f, -0.01974274f, 0.09348024f, -0.08601376f, -0.00504591f, -0.08611306f, -0.14553128f, -0.00698565f, 
    0.29136133f, 0.21907334f, 0.04260867f, 0.00207479f, -0.05590685f, 0.05720738f, -0.06809407f, -0.12189782f, 
    -0.11162151f, -0.12583813f, -0.09194615f, 0.15653637f, -0.26235917f, -0.22175756f, -0.11473926f, 0.19889326f, 
    -0.00170409f, 0.10545320f, 0.08427290f, 0.08854282f, 0.02163077f, 0.15556993f, -0.02298991f, -0.08011030f, 
    0.07625055f, -0.00619058f, 0.04239047f, 0.09839291f, 0.06509225f, 0.24353310f, 0.17290194f, 0.15832633f, 
    -0.18768023f, -0.24030003f, 0.00614070f, -0.06469857f, 0.09347263f, 0.01009578f, 0.05261742f, -0.03632423f, 
    -0.03566957f, 0.05372678f, -0.10094399f, 0.10995355f, -0.07589855f, 0.12202963f, 0.11996517f, -0.03203431f, 
    -0.08418103f, -0.18599571f, -0.01755940f, -0.08865475f, -0.20072736f, 0.08389299f, 0.26564386f, 0.02574400f, 
    0.05233833f, 0.06589296f, 0.02005884f, 0.02232906f, 0.01011748f, -0.05370743f, 0.23241970f, 0.17079504f, 
    0.02458292f, 0.12057233f, -0.09950570f, 0.04489402f, -0.26276484f, -0.02535719f, 0.15720141f, -0.31329036f, 
    -0.08486491f, -0.05727110f, 0.10274610f, 0.15295847f, 0.03384573f, -0.07859519f, -0.10007761f, -0.05488154f, 
    -0.51435888f, -0.15538393f, -0.19402799f, 0.20115057f, 0.11388430f, 0.08562876f, 0.18113433f, 0.05048412f, 
    0.04519352f, 0.10800532f, -0.03711100f, -0.16238351f, 0.25383478f, -0.02773084f, 0.25395802f, 0.21056451f, 
    0.11455078f, 0.03832620f, -0.14671406f, -0.01891327f, -0.13707736f, 0.27589884f, 0.07017235f, -0.02160078f, 
    0.01892515f, 0.18799481f, 0.32320461f, -0.20790225f, -0.03009837f, 0.08094700f, 0.09844849f, -0.03454339f, 
    0.03214585f, -0.09734733f, 0.01328852f, -0.00068574f, -0.18603447f, 0.01884084f, 0.10518811f, -0.12177208f, 
    -0.01540271f, -0.02854787f, -0.14583702f, 0.17733490f, -0.01569071f, -0.26912525f, -0.03844443f, -0.10717253f, 
    0.37736589f, 0.21059220f, -0.38982636f, 0.06793573f, -0.00310588f, 0.02114229f, -0.14318055f, -0.28246894f, 
    0.05581205f, -0.06739435f, -0.22172198f, -0.09715334f, -0.14708428f, -0.05532113f, 0.27925360f, -0.18569300f, 
    0.03568328f, 0.10378104f, -0.10945892f, 0.07684284f, 0.12121254f, -0.14726864f, 0.01211639f, -0.07664144f, 
    -0.04478586f, 0.05116817f, 0.13072500f, 0.15372761f, 0.00495155f, 0.05300332f, 0.01984370f, -0.01926849f, 
    0.05043984f, -0.09135738f, -0.02711406f, -0.04815799f, -0.04047613f, -0.08269959f, 0.01762574f, -0.02769065f, 
    -0.10617856f, -0.04225270f, 0.04367686f, -0.07257676f, 0.19346039f, 0.14582355f, 0.29060927f, 0.23646869f, 
    0.13123821f, 0.00002301f, -0.15334462f, 0.16034709f, -0.01488848f, 0.06801733f, 0.01592534f, 0.01654399f, 
    0.20581406f, -0.13565862f, 0.00706774f, 0.24093589f, -0.02356106f, -0.12461971f, -0.03169354f, -0.03793874f, 
    -0.06412396f, 0.24659877f, -0.11413980f, 0.11312865f, 0.05863052f, 0.08352195f, -0.10017100f, -0.00643054f, 
    -0.03348393f, 0.09051396f, 0.08309892f, -0.06424650f, -0.01378290f, -0.00052155f, 0.07464243f, 0.09074245f, 
    -0.10659120f, -0.02924621f, -0.03209844f, -0.07626091f, 0.03386955f, -0.00221960f, 0.08019400f, 0.34506878f, 
    -0.11849922f, 0.07512486f, -0.11605791f, -0.13466412f, 0.10667968f, 0.16686139f, -0.15289657f, 0.11638487f, 
    0.17564127f, 0.23589355f, 0.19715098f, 0.17408317f, -0.03002252f, 0.12013961f, 0.10628578f, 0.13774689f, 
    0.02427250f, -0.21058169f, 0.17845987f, -0.22027075f, -0.01516387f, -0.21590716f, -0.13660449f, -0.12603277f, 
    -0.28806484f, -0.22321253f, -0.16093384f, 0.25136501f, 0.15505989f, -0.03884232f, -0.02384893f, -0.05640282f, 
    -0.40058637f, -0.11609613f, -0.19102071f, -0.33902532f, 0.01681279f, 0.35925129f, 0.03644351f, 0.11712819f, 
    0.07387346f, -0.08686315f, 0.44412145f, 0.15240337f, -0.08460587f, 0.14238937f, 0.19729067f, -0.16087647f, 
    -0.16413581f, 0.08147714f, 0.06237284f, 0.10548671f, 0.14025827f, -0.06357786f, 0.00150285f, -0.14358455f, 
    0.02615202f, -0.09590244f, 0.32022113f, 0.03368672f, 0.06697668f, 0.17180318f, 0.12819071f, 0.13369021f, 
    0.06724179f, 0.05097741f, 0.04553271f, 0.06623615f, -0.48458800f, 0.03134891f, -0.18635003f, -0.11603408f, 
    -0.15763928f, -0.01838058f, 0.07856093f, 0.09682431f, 0.01964016f, -0.13643627f, 0.06173577f, 0.17051281f, 
    0.01400541f, -0.02140599f, -0.06612229f, -0.05004490f, -0.02384377f, 0.04670222f, 0.02351721f, -0.04474062f, 
    0.05064684f, -0.03112949f, -0.07127227f, -0.05807802f, -0.06664702f, -0.07372399f, 0.03470857f, -0.08109973f, 
    -0.07173802f, 0.03984834f, 0.02307810f, 0.05908848f, 0.00845763f, -0.05979727f, 0.00687549f, -0.06415167f, 
    -0.07354118f, 0.01327311f, 0.00730204f, -0.05429795f, -0.00335001f, 0.02362057f, 0.02555604f, 0.04352032f, 
    0.04648661f, -0.05425820f, -0.05892390f, -0.05166051f, 0.05201208f, -0.01709182f, -0.07496151f, -0.06073392f, 
    0.05884155f, -0.04718217f, -0.07239478f, -0.01459616f, -0.08276329f, 0.03357681f, -0.05614374f, 0.05052283f, 
    -0.06158724f, 0.06061452f, 0.01071315f, 0.02315561f, -0.02580357f, 0.03313984f, -0.01578096f, -0.06628436f, 
    -0.01579970f, -0.05775553f, -0.04001094f, -0.05259795f, -0.03567668f, -0.03900062f, 0.05973105f, -0.06002463f, 
    0.01762167f, 0.01733660f, -0.02231148f, -0.02127019f, 0.00942874f, 0.04930039f, 0.00405694f, 0.00927468f, 
    0.06156395f, -0.00911785f, 0.02905418f, -0.03368376f, 0.05669933f, 0.01772034f, 0.04658497f, -0.01195245f, 
    -0.06622559f, -0.03948907f, -0.03242766f, 0.04234368f, -0.05046360f, 0.01093602f, 0.03950854f, 0.00848226f, 
    -0.03199688f, 0.01533799f, -0.05285319f, -0.01571945f, -0.01216073f, -0.08016292f, -0.08110286f, 0.02551801f, 
    -0.05814064f, 0.04249083f, 0.04074955f, -0.08242526f, -0.06320509f, 0.00956186f, 0.01249990f, -0.01241815f, 
    -0.07397728f, 0.05428096f, 0.02858838f, 0.02214029f, 0.05430268f, 0.05449819f, 0.04223786f, 0.01251842f, 
    0.01190334f, -0.02138063f, 0.04145589f, 0.03563754f, -0.05059304f, 0.01815661f, -0.02412208f, -0.01986567f, 
    -0.02624353f, 0.05531409f, 0.06369063f, 0.05347914f, 0.01614282f, -0.04660092f, -0.06895108f, 0.01450742f, 
    0.04145092f, 0.02924613f, 0.00117716f, -0.06206201f, -0.07263051f, 0.00136448f, -0.01586675f, 0.05568839f, 
    0.01706465f, -0.05730257f, -0.04340869f, 0.03032793f, 0.01184116f, 0.00644863f, -0.01376900f, 0.01254144f, 
    -0.01118576f, -0.03866921f, -0.02999352f, -0.04196017f, -0.01417475f, -0.04840638f, -0.01540985f, -0.07311657f, 
    0.01798921f, -0.05523349f, -0.04491321f, -0.00552427f, -0.04867710f, -0.01313982f, -0.07964955f, 0.05681158f, 
    0.04909703f, 0.00727398f, -0.01939162f, 0.02013330f, 0.03175578f, -0.00860345f, 0.03808929f, -0.06878610f, 
    0.03272166f, -0.03670244f, 0.04092605f, 0.03417464f, -0.01785073f, 0.03950007f, -0.04105469f, 0.04761139f, 
    -0.07816555f, -0.03070981f, 0.03905903f, -0.01303900f, 0.00074193f, -0.00926108f, 0.01477339f, -0.02403642f, 
    0.00755209f, -0.03522658f, -0.05460158f, -0.01866037f, -0.06918738f, -0.04468445f, 0.05988122f, 0.05991939f, 
    0.23082198f, 0.17321591f, 0.28536034f, -0.11996726f, 0.00757417f, -0.01980773f, -0.02631339f, 0.31448409f, 
    0.06750073f, -0.03414884f, 0.10702129f, -0.11893765f, -0.21297057f, -0.18190271f, 0.06684949f, -0.04043422f, 
    -0.02690525f, 0.07641315f, -0.02589103f, 0.20449923f, 0.07213740f, 0.13901812f, 0.05152842f, 0.19279881f, 
    -0.12693772f, 0.07023248f, -0.25696823f, 0.20823628f, -0.02452447f, 0.10614745f, 0.10465974f, -0.04625604f, 
    0.04562963f, 0.12972347f, 0.08379929f, 0.30987397f, 0.08345239f, 0.21497908f, 0.26337236f, -0.11432186f, 
    0.16941656f, 0.15085198f, 0.00541045f, 0.25831318f, 0.27859110f, 0.14553200f, -0.07861463f, 0.03421085f, 
    -0.19469826f, -0.28771961f, -0.14200874f, 0.04678308f, -0.15250736f, 0.07137655f, -0.06448533f, 0.08835054f, 
    0.19539946f, 0.06500015f, -0.11207885f, -0.02239482f, 0.08940555f, -0.12110429f, -0.16187195f, -0.00939202f, 
    0.06847981f, -0.13626793f, 0.00289145f, -0.32138336f, 0.00663400f, -0.15519838f, 0.12298134f, -0.01238891f, 
    -0.37062183f, 0.19088192f, -0.23627687f, 0.25255245f, 0.23648828f, -0.09322643f, -0.05681166f, -0.00151799f, 
    -0.10700227f, -0.02958468f, -0.02999272f, -0.13247328f, -0.17685749f, 0.23948197f, 0.02771569f, 0.29930452f, 
    0.29281586f, 0.05934937f, 0.14948988f, -0.19091341f, -0.27609742f, -0.29529446f, -0.68077898f, -0.46219119f, 
    0.36727589f, 0.36293468f, 0.10530624f, -0.06398313f, -0.18828915f, -0.03816462f, -0.01025504f, -0.09689517f, 
    0.10851438f, 0.05275408f, -0.23050168f, 0.05363309f, 0.00840042f, 0.35176688f, -0.04360560f, -0.07261486f, 
    -0.13513288f, -0.09991696f, -0.25679639f, -0.18544053f, -0.03221113f, -0.00173685f, -0.25960907f, 0.03932537f, 
    0.16351399f, 0.14445142f, 0.10807936f, 0.23456852f, -0.02702307f, -0.06116539f, -0.08272680f, 0.10645738f, 
    0.05015837f, 0.05988881f, 0.12582585f, -0.16360590f, 0.64717305f, -0.03025357f, 0.15360682f, 0.25235659f, 
    -0.14735228f, 0.05685041f, -0.18670292f, 0.11145255f, 0.22981283f, 0.12927449f, 0.09302197f, 0.17932333f, 
    -0.23407684f, 0.19891953f, -0.05135847f, -0.07987837f, 0.10600299f, 0.04923979f, 0.19219226f, -0.02972287f, 
    -0.24949123f, 0.02461980f, -0.01342467f, -0.45073316f, -0.03103364f, 0.04796424f, -0.10851414f, 0.02953584f, 
    0.08241270f, -0.07731441f, 0.11254502f, 0.09673040f, -0.07285871f, -0.08838236f, -0.01661163f, -0.05714388f, 
    0.27026373f, -0.15120114f, 0.53483897f, -0.20462549f, 0.05987659f, 0.21959022f, -0.13648728f, 0.06240178f, 
    -0.24336867f, -0.21471387f, 0.01603707f, -0.13045903f, 0.24194500f, 0.04518481f, 0.04877770f, -0.09848959f, 
    -0.28147763f, -0.07298405f, 0.08944424f, -0.11260958f, 0.15419616f, -0.16710246f, -0.06185634f, -0.04982248f, 
    -0.35268050f, -0.27073517f, 0.19253230f, 0.22862743f, 0.01971477f, 0.11003561f, -0.05764400f, 0.05580581f, 
    0.16523331f, 0.00442996f, -0.00159948f, -0.05476246f, -0.00161073f, -0.33017701f, 0.23353846f, 0.31715044f, 
    0.01005541f, -0.06189350f, 0.03475926f, 0.10037304f, 0.04851379f, 0.03258198f, -0.01291925f, -0.02963348f, 
    0.06209165f, 0.26313826f, -0.06081108f, 0.24046671f, 0.01390851f, -0.04055402f, 0.00359871f, -0.05182905f, 
    0.08118769f, 0.13921361f, -0.02687782f, -0.03845828f, -0.30372241f, -0.09800724f, 0.07244979f, 0.05353801f, 
    0.01692242f, 0.11676332f, -0.08368711f, -0.03504716f, 0.12614293f, -0.02275756f, 0.02537876f, 0.07864576f, 
    -0.23645206f, -0.27749354f, 0.06719094f, 0.18377499f, 0.10512784f, 0.02755952f, 0.00188717f, 0.04119736f, 
    0.07932714f, 0.06462647f, -0.03309526f, 0.11614214f, -0.40424404f, -0.07197179f, -0.03410046f, -0.28857529f, 
    -0.05047291f, -0.24734597f, -0.14842974f, -0.12246823f, -0.02431435f, -0.16085599f, -0.06562146f, 0.12332889f, 
    -0.29532304f, 0.15019380f, -0.07045592f, -0.05832125f, -0.04601146f, -0.12850861f, 0.08147240f, -0.05198927f, 
    -0.06059832f, -0.00785489f, -0.02726568f, -0.17882435f, -0.04926673f, 0.23585519f, -0.18278137f, -0.08550256f, 
    0.16714615f, -0.04065085f, 0.11606546f, 0.09224066f, 0.03410446f, 0.01226420f, 0.06224638f, 0.04297348f, 
    0.00497137f, -0.01606359f, 0.11448803f, 0.14449602f, -0.05199781f, 0.07523636f, 0.12881099f, 0.29492787f, 
    0.14728494f, -0.02740483f, 0.02188440f, 0.05382713f, 0.13155755f, 0.15924451f, -0.10085747f, -0.24252845f, 
    0.06262971f, -0.15172146f, -0.17397206f, -0.03760357f, 0.03224280f, 0.13923287f, -0.02580844f, -0.13203466f, 
    -0.07832660f, -0.13994007f, -0.18840228f, 0.10330689f, 0.13459206f, 0.01408947f, 0.17810519f, 0.09354078f, 
    -0.00741846f, 0.06361138f, 0.07773788f, -0.06184657f, -0.00917821f, -0.16896105f, 0.49674344f, 0.03938650f, 
    -0.04891891f, -0.09499556f, -0.01837763f, 0.06689106f, 0.18549483f, 0.14842753f, 0.04159344f, 0.06134761f, 
    -0.44395807f, -0.21655771f, 0.14328758f, -0.16262713f, 0.02844675f, -0.21445623f, 0.25186595f, -0.15229499f, 
    -0.00520057f, -0.27580044f, 0.04216425f, -0.08581702f, -0.12169066f, -0.05666384f, 0.20722947f, 0.20264873f, 
    -0.03768670f, -0.13858998f, 0.16818993f, 0.08058347f, 0.09048420f, 0.01180370f, 0.18215373f, 0.13410090f, 
    -0.09527753f, -0.10500029f, -0.01631616f, 0.15916388f, -0.02647400f, -0.02932164f, -0.18904014f, 0.22395599f, 
    -0.06491083f, 0.16606317f, -0.01660469f, 0.23600256f, 0.47018778f, 0.28838551f, 0.02144911f, 0.19646226f, 
    0.10102625f, -0.08720379f, 0.09448528f, -0.12791245f, 0.00905806f, 0.13132633f, 0.03887079f, 0.25249586f, 
    0.27551258f, 0.07333712f, 0.05314312f, 0.14694986f, -0.06676457f, -0.02332266f, -0.01832623f, -0.00234990f, 
    0.00041723f, -0.08325009f, -0.06016441f, 0.19545825f, 0.29441163f, 0.24181074f, -0.13996442f, 0.21025600f, 
    -0.05905468f, 0.19067642f, 0.09877445f, -0.09619605f, 0.01809735f, -0.12787265f, -0.21236980f, 0.13444497f, 
    -0.56592077f, -0.40897989f, 0.10094665f, -0.16166005f, 0.04385007f, -0.03644982f, -0.13731810f, 0.09519956f, 
    -0.21286152f, -0.13810177f, -0.00596650f, 0.00838974f, 0.26249632f, 0.10885621f, -0.04683187f, 0.14497261f, 
    0.11482828f, -0.12577227f, 0.14859515f, -0.18473455f, -0.01714504f, -0.02786585f, -0.09557754f, 0.04442003f, 
    0.49985093f, 0.28878042f, -0.13843276f, -0.23033613f, -0.06577538f, 0.07076907f, 0.14413738f, 0.21788414f, 
    0.00007432f, -0.07570545f, -0.06102308f, -0.21134077f, -0.35088935f, -0.30122668f, -0.06927062f, -0.05276690f, 
    -0.03173069f, -0.02586378f, 0.08785806f, 0.02042461f, 0.06935164f, 0.06903400f, -0.07154533f, 0.00991000f, 
    -0.14754811f, -0.21929878f, -0.09555677f, -0.17900248f, -0.09007332f, -0.00856832f, 0.07363655f, -0.05743396f, 
    -0.06573576f, 0.01462522f, -0.02789665f, 0.09389117f, -0.04256552f, 0.15020354f, 0.20627454f, 0.05249790f, 
    -0.08622527f, -0.06166187f, 0.10936622f, 0.05375924f, -0.00901256f, -0.01104851f, 0.18923508f, -0.01528258f, 
    0.13499413f, 0.01392588f, 0.08792958f, 0.12031335f, 0.19464917f, 0.27266684f, 0.18318206f, 0.28815201f, 
    -0.02055909f, -0.10129231f, 0.11277822f, 0.01293661f, -0.13140891f, -0.18921392f, -0.14076401f, -0.10315790f, 
    -0.02052322f, -0.05709499f, -0.02716479f, -0.08649105f, -0.22884063f, -0.00008932f, -0.00362766f, -0.15954441f, 
    0.14428671f, 0.07056576f, -0.10762431f, -0.04807034f, 0.04138196f, 0.05040964f, -0.10410724f, -0.01238897f, 
    0.00633451f, 0.11070682f, -0.11652625f, 0.26954463f, 0.24376297f, -0.01592628f, -0.20463145f, 0.12104756f, 
    0.09043287f, 0.21044342f, 0.13660207f, -0.02623480f, -0.04179360f, -0.13323325f, -0.10574567f, -0.05681597f, 
    0.03380281f, -0.07330425f, -0.15469976f, -0.06290859f, -0.20227332f, -0.09472242f, -0.10255325f, -0.37516949f, 
    0.00110978f, 0.05788772f, 0.04390837f, 0.00666172f, 0.22916448f, 0.22445786f, 0.12861724f, 0.35612354f, 
    0.18782134f, 0.18596153f, 0.22990286f, -0.06064573f, -0.09436631f, -0.05052857f, 0.08465855f, 0.08986971f, 
    0.21385948f, 0.26272365f, -0.01335464f, -0.03815821f, -0.08189538f, -0.28524360f, 0.12575328f, -0.07426570f, 
    0.13303444f, 0.01452994f, -0.05798487f, -0.00458884f, -0.00055723f, 0.18179296f, -0.03516778f, -0.03608681f, 
    -0.03910205f, 0.08705614f, -0.05236628f, 0.00963739f, 0.08330056f, 0.11390331f, -0.12834868f, -0.09348493f, 
    0.11860309f, 0.10171998f, -0.09691550f, -0.39751908f, 0.02594255f, 0.10686118f, 0.11922151f, 0.09207211f, 
    0.05205132f, 0.02676775f, 0.04687744f, 0.03006242f, 0.02936019f, -0.15090138f, 0.04289461f, -0.00695292f, 
    0.04890947f, 0.15935804f, -0.12064866f, 0.10340242f, -0.02818760f, -0.14093421f, 0.02654175f, -0.10371470f, 
    -0.46686620f, 0.14978802f, 0.01320198f, 0.08296322f, 0.09644286f, 0.00626141f, -0.13696888f, -0.09465496f, 
    -0.02374589f, 0.04698282f, -0.29382154f, -0.09189839f, 0.06315452f, -0.04015617f, 0.10394122f, -0.38306364f, 
    0.04335528f, -0.05848384f, -0.01494695f, 0.04545005f, -0.04472211f, -0.15189300f, 0.00553384f, -0.06927366f, 
    0.04658057f, -0.08718549f, -0.17319757f, 0.13458018f, 0.06874588f, 0.09923149f, -0.05685015f, 0.05613039f, 
    0.14209682f, -0.05517323f, -0.02295650f, 0.12820724f, -0.18531311f, 0.01593386f, -0.05117561f, 0.14863791f, 
    0.00457265f, 0.02232835f, 0.03990890f, -0.11146700f, 0.07128830f, 0.00072190f, 0.07484893f, 0.27506569f, 
    -0.19859211f, 0.03261820f, -0.20719147f, 0.55995566f, 0.08803495f, 0.08593735f, -0.04064618f, 0.00591415f, 
    0.06580207f, -0.25041366f, 0.11316635f, 0.10448287f, -0.11809914f, 0.02782991f, -0.04860615f, 0.04820935f, 
    -0.05771061f, 0.23369336f, -0.15707132f, -0.07659738f, 0.09964351f, -0.00052651f, 0.11195388f, -0.03121957f, 
    0.23935361f, 0.00061641f, 0.07632873f, -0.12938507f, 0.06720144f, 0.04580162f, 0.11135921f, -0.14540707f, 
    -0.10004105f, -0.12497020f, -0.05824522f, -0.08491398f, 0.12842196f, -0.01877912f, 0.00019911f, 0.11964752f, 
    -0.09738624f, 0.01841439f, -0.00626814f, 0.12685154f, 0.00584207f, 0.09252075f, -0.08901270f, 0.08990356f, 
    0.29137474f, 0.16997421f, 0.11873832f, 0.12418615f, 0.12096667f, 0.12842304f, 0.19339810f, -0.03291024f, 
    -0.02209145f, -0.13367681f, 0.00630995f, -0.02330648f, 0.44785607f, -0.24177723f, 0.04893161f, 0.02476446f, 
    0.06266431f, -0.05440013f, 0.06134883f, 0.15811865f, 0.29585820f, -0.02065970f, -0.06691150f, -0.13578959f, 
    -0.27392510f, 0.15298718f, 0.01443389f, 0.00765168f, -0.06177246f, -0.02269772f, -0.09808405f, 0.17182872f, 
    0.13449007f, -0.02938180f, 0.22143824f, 0.08544901f, -0.15175173f, 0.02042306f, -0.14480907f, -0.10603144f, 
    -0.10215113f, 0.27465883f, 0.14719649f, -0.13639350f, 0.05175573f, -0.11822140f, -0.01165388f, 0.12964481f, 
    0.32752213f, -0.21440852f, 0.08163793f, -0.30153158f, 0.15933116f, 0.26737154f, 0.18091708f, 0.05051145f, 
    -0.03202321f, -0.02994709f, -0.06330937f, 0.16996419f, 0.03980047f, 0.03577110f, -0.27083179f, 0.16052164f, 
    0.01369517f, 0.22584495f, 0.15376669f, 0.05884529f, 0.22949931f, -0.02176514f, 0.01018203f, 0.04913925f, 
    0.08347144f, 0.27069288f, -0.08994965f, -0.14332646f, 0.17223661f, 0.06164032f, 0.07256792f, -0.09713555f, 
    0.01162838f, -0.00790462f, 0.10395870f, -0.04736302f, -0.24409227f, 0.11439265f, 0.07416631f, -0.13716611f, 
    0.07685065f, 0.05218022f, 0.21522258f, 0.24380915f, -0.19093822f, 0.17452565f, 0.21834129f, -0.07315995f, 
    0.34957653f, 0.11730289f, -0.23756370f, 0.12832637f, -0.03818833f, 0.10282442f, 0.07956191f, 0.02200719f, 
    0.10204233f, 0.04378325f, 0.00431885f, 0.08439018f, -0.17390667f, -0.04251316f, 0.01839199f, 0.05715772f, 
    -0.14461055f, 0.15214905f, -0.00559698f, 0.07951581f, -0.07131524f, 0.04387847f, 0.08825185f, 0.11282214f, 
    -0.39533022f, -0.19801253f, 0.08300077f, 0.24555627f, 0.19474334f, -0.01170830f, -0.03130113f, -0.14229299f, 
    -0.10335074f, -0.12888052f, 0.03497173f, 0.09881172f, 0.05505379f, -0.05206759f, -0.04873957f, -0.04029273f, 
    0.07995175f, -0.03248282f, -0.06748710f, -0.05249230f, 0.00940503f, -0.01442612f, 0.10395318f, -0.12066028f, 
    -0.17127025f, -0.05401104f, 0.09906531f, -0.07878855f, 0.02153885f, -0.09530705f, -0.00347249f, -0.00460013f, 
    -0.06124261f, -0.08364862f, 0.04829597f, -0.06537534f, -0.07248231f, -0.18473375f, 0.11390229f, 0.01792500f, 
    0.06112771f, -0.03860285f, -0.08588894f, -0.00504902f, 0.04429306f, -0.01561524f, -0.13873056f, -0.01485643f, 
    0.08858268f, 0.45708928f, -0.03476734f, 0.02389807f, 0.02997423f, -0.09365004f, -0.06649648f, -0.22241350f, 
    0.08355781f, -0.02329894f, -0.15174146f, 0.03485705f, -0.10966107f, 0.03401574f, 0.00863668f, 0.03896797f, 
    0.12712844f, 0.06792700f, -0.00117487f, -0.01812408f, -0.05025499f, -0.04803465f, -0.10878523f, 0.03872250f, 
    -0.06582143f, 0.07910312f, 0.20891875f, 0.05307659f, -0.20059928f, -0.00013591f, 0.18210065f, 0.06311616f, 
    -0.10511977f, -0.10129292f, 0.21339318f, -0.17364374f, -0.28651398f, 0.27515811f, 0.19765906f, -0.06342788f, 
    0.10581041f, -0.05310348f, -0.03096145f, 0.08889388f, -0.01232441f, 0.18923721f, 0.00593704f, -0.00406423f, 
    0.01452498f, -0.09030434f, 0.08616103f, 0.04819757f, 0.12314150f, 0.26359832f, -0.21777070f, 0.08114512f, 
    -0.05049411f, -0.00458738f, 0.05195525f, -0.13663018f, 0.04659148f, 0.05664297f, -0.01642051f, -0.10815091f, 
    0.16822825f, 0.01404043f, -0.30975083f, 0.00520145f, 0.07954532f, 0.09411625f, 0.02509186f, -0.07824241f, 
    0.16105917f, -0.02575024f, 0.25501308f, -0.02212906f, -0.01239025f, 0.30353990f, -0.13944347f, -0.00069489f, 
    -0.02989113f, -0.04649593f, 0.09675523f, -0.00599310f, -0.15632147f, -0.24960338f, 0.26374167f, 0.09089797f, 
    -0.09487491f, -0.06799121f, 0.15368013f, 0.04760106f, 0.01559171f, -0.10681202f, 0.02886973f, 0.05778428f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04372431f, -0.02696108f, -0.02910387f, 0.04129974f, -0.02537700f, 0.03070099f, -0.00410616f, 0.07517024f, 
    0.13826509f, 0.26067626f, 0.08058101f, 0.11707846f, 0.03120918f, 0.18293418f, -0.00294924f, -0.02712682f, 
    -0.09331527f, 0.07164420f, -0.02576842f, -0.02058074f, 0.04477133f, 0.02429176f, 0.02110361f, 0.03813433f, 
    -0.06581808f, 0.19115345f, 0.02882354f, 0.03188355f, 0.21055688f, 0.07026277f, 0.10201244f, 0.14779462f, 
    0.03133782f, -0.09286779f, 0.06971689f, -0.11953880f, -0.01554414f, -0.10405722f, 0.00163998f, -0.03860677f, 
    0.15015653f, 0.08603322f, 0.00134558f, 0.29739419f, 0.00001812f, 0.24325241f, 0.07501590f, 0.10837592f, 
    -0.06023739f, 0.23373528f, -0.04236003f, -0.02882900f, -0.07000322f, 0.13599421f, 0.17282327f, -0.06668392f, 
    0.18539242f, 0.24560322f, -0.00761696f, -0.17428289f, 0.11199211f, -0.23758012f, 0.14442046f, -0.00180692f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.19540471f, -0.06317031f, -0.10699667f, -0.10567964f, 0.37930036f, 0.18209639f, -0.08629462f, -0.28123915f, 
    -0.47937360f, -0.10513665f, 0.11590631f, -0.33158860f, -0.01754671f, -0.46944535f, -0.00303926f, 0.05811866f, 
    0.12989001f, -0.43081072f, 0.16360673f, 0.04809499f, 0.02815975f, -0.41997212f, 0.11351314f, 0.36463675f, 
    -0.02136326f, -0.33825576f, -0.07061456f, 0.01554899f, -0.23576194f, -0.32044446f, -0.17668286f, -0.21511944f, 
    -0.04449647f, -0.30792731f, -0.12101721f, 0.16261864f, -0.02372189f, 0.15911178f, 0.47653729f, 0.06457146f, 
    -0.02699034f, 0.15231544f, 0.10253154f, -0.49014083f, -0.01589192f, -0.40989673f, -0.05292311f, 0.28476056f, 
    0.09274730f, 0.08318660f, 0.00612585f, 0.10115547f, -0.02030037f, -0.04271758f, -0.00812594f, 0.25048903f, 
    -0.29243541f, -0.45235610f, 0.03145258f, 0.18865526f, -0.63805050f, 0.28631589f, 0.15375286f, 0.03491160f, 
    0.06049325f, -0.10280406f, -0.08309133f, 0.13545664f, -0.14993793f, -0.13293871f, 0.12556393f, -0.38953915f, 
    -0.63710010f, 0.33807427f, 0.41388348f, -0.08448830f, -0.11307741f, -0.11380702f, -0.10336122f, -0.05868990f, 
    -0.00831409f, 0.06384792f, 0.23794591f, 0.14025943f, 0.11653168f, -0.00333373f, -0.02240277f, -0.80328548f, 
    -0.10673651f, 0.20784952f, -0.05586601f, -0.06994909f, 0.11406758f, -0.00913713f, 0.06869733f, 0.18507838f, 
    -0.09869301f, -0.16282232f, 0.18069996f, -0.22608811f, -0.37024829f, 0.15146500f, 0.05932761f, -0.11995921f, 
    0.05744500f, 0.09943929f, -0.11014826f, 0.12194274f, -0.18308800f, 0.34630334f, 0.00290759f, 0.08676741f, 
    -0.02993050f, -0.29995102f, 0.05085863f, 0.03862901f, -0.05729575f, 0.08043662f, 0.16218996f, -0.13073879f, 
    -0.02943728f, 0.03653655f, -0.02542170f, -0.86495006f, -0.11998200f, 0.26793617f, -0.03489158f, -0.22062227f, 
    -0.11545929f, 0.01664637f, 0.02884757f, 0.10409349f, -0.66230839f, -0.00665068f, -0.10791272f, -0.26564541f, 
    0.05784646f, 0.11726390f, -0.19698736f, 0.26068705f, 0.00382239f, 0.09563079f, -0.15028244f, -0.05343366f, 
    0.00217702f, -0.06284676f, 0.03025046f, 0.07409008f, -0.12434451f, 0.58319569f, -0.03248440f, -0.85324466f, 
    -0.04734813f, -0.16481636f, -0.04087719f, 0.08147015f, -0.14268868f, -0.02464406f, -0.01328948f, -0.63262945f, 
    0.09657362f, -0.12144031f, -0.00031590f, -0.58127934f, 0.33586904f, -0.78675187f, -0.10068637f, -0.10101131f, 
    0.00951345f, 0.15742229f, 0.08837726f, -0.04021075f, -0.04863134f, -0.80374086f, 0.08030131f, 0.13554296f, 
    0.07142693f, 0.20376393f, 0.11137544f, -0.03546698f, -0.06056101f, 0.12619461f, 0.38929123f, -0.34027237f, 
    0.15704024f, 0.10077117f, -0.06976227f, -0.15894602f, 0.14775708f, -0.19340135f, 0.21927810f, 0.02815109f, 
    -0.26566228f, 0.09308572f, -0.01130857f, 0.17879795f, -0.06359914f, 0.13035253f, 0.36447638f, 0.05268591f, 
    -0.22197479f, -0.66013032f, 0.07138525f, 0.18261562f, -0.00006706f, -0.14581189f, -0.04764919f, 0.02604584f, 
    0.28986141f, -0.29596981f, -0.16033100f, 0.15167628f, -0.08946550f, 0.11170218f, 0.01014219f, -0.23759644f, 
    0.04015005f, -0.14373888f, -0.05292888f, 0.15613140f, -0.40550688f, -0.08857486f, 0.13697340f, -0.63143188f, 
    0.09592973f, 0.36133805f, -0.00529065f, 0.18812072f, 0.29977185f, 0.00251231f, 0.05798944f, -0.07784989f, 
    0.13210729f, -0.14915782f, -0.10243604f, -0.24906228f, 0.25547808f, -0.19550687f, -0.57313842f, -0.55066103f, 
    -0.12867820f, -0.38673580f, 0.07454988f, 0.05447097f, 0.07677317f, -0.04510209f, -0.02261107f, 0.09593654f, 
    0.19386466f, -0.65303600f, -0.02262838f, -0.06171798f, 0.26175702f, 0.14002004f, -0.22246388f, -0.02143470f, 
    0.05156863f, 0.06219041f, -0.10577664f, 0.19239473f, 0.26300132f, 0.22598815f, -0.00573820f, 0.26859018f, 
    0.09041063f, -0.02843397f, -0.30560315f, -0.12882982f, -0.07176448f, -0.11096373f, -0.00045287f, -0.03987992f, 
    -0.09319568f, 0.22289951f, 0.16109744f, -0.13220835f, -0.05621697f, 0.03921796f, -0.05251140f, 0.26294297f, 
    -0.00751451f, -0.28503877f, -0.00013146f, -0.48768139f, -0.25864378f, 0.03999578f, 0.01145922f, 0.20079066f, 
    -0.02549256f, -0.06782375f, 0.17038305f, 0.05523650f, 0.22316606f, 0.03156980f, -0.33072826f, 0.15953374f, 
    -0.01225168f, -0.38461563f, 0.03420568f, -0.35675237f, -0.37116322f, 0.08233781f, -0.07960691f, 0.05320795f, 
    0.04175603f, 0.08509539f, -0.04292244f, 0.00376269f, -0.06333230f, -0.24594475f, -0.01539535f, -0.18955958f, 
    -0.41666138f, 0.15798913f, 0.04720281f, 0.34031436f, 0.19339654f, -0.07361401f, 0.04592136f, 0.17297973f, 
    0.18671815f, -0.06499173f, 0.08380792f, -0.00136454f, -0.35411471f, -0.29741591f, -0.30871972f, 0.12047617f, 
    0.01421235f, -0.01325183f, -0.10349089f, -0.31343573f, -0.08726310f, 0.12166435f, -0.00036809f, 0.08267115f, 
    -0.05225655f, 0.09729001f, 0.04246366f, -0.29591617f, 0.10415956f, -0.02519537f, 0.06739666f, 0.16796948f, 
    -0.06421757f, 0.00018715f, -0.03571537f, 0.24885058f, 0.36011317f, -0.31031677f, -0.18912660f, -0.22395679f, 
    0.08871920f, -0.17182299f, -0.02464061f, 0.28471270f, -0.68704486f, 0.15662126f, -0.37941235f, 0.18465325f, 
    0.23959830f, -0.20810153f, 0.06928463f, 0.18792473f, 0.12111349f, 0.04613347f, -0.13012953f, 0.08629251f, 
    0.05535230f, 0.22876853f, 0.02581054f, 0.05028004f, 0.10661473f, 0.21861696f, 0.09850673f, 0.31401494f, 
    -0.09698465f, 0.46389368f, -0.02577278f, -0.02520075f, -0.16609296f, -0.09700242f, 0.10570306f, 0.15495941f, 
    -0.12361585f, -0.01626901f, -0.03562883f, -0.64311486f, -0.34267259f, 0.13932616f, 0.07633445f, 0.39557973f, 
    0.35810438f, 0.02254715f, -0.46104047f, -0.02647743f, 0.01380654f, 0.03296124f, 0.00954330f, -0.02110182f, 
    -0.16012099f, 0.15475027f, -0.63661522f, -0.20388058f, -0.10606281f, 0.22904859f, -0.05539588f, 0.55278116f, 
    0.09548946f, -0.04575029f, 0.08257023f, -0.36412904f, -0.52291381f, 0.20476714f, 0.17951837f, -0.16076937f, 
    -0.10140970f, 0.02842106f, -0.16348989f, -0.23676586f, -0.38086411f, -0.74605274f, -0.17989917f, 0.00412073f, 
    -0.98217279f, 0.27042803f, -0.05817794f, 0.51998174f, 0.08559141f, -0.33674845f, 0.21976943f, -0.20136933f, 
    0.02132469f, 0.44861132f, -0.01363201f, -0.07024726f, -0.01375891f, 0.05538657f, -0.16204457f, -0.78640598f, 
    0.16932005f, -0.14841372f, 0.00642313f, -0.39976513f, 0.21376422f, -0.39600721f, -0.48614994f, 0.20104742f, 
    -0.45605662f, 0.06699365f, 0.04169128f, -0.57631016f, -0.05387570f, -0.57637346f, 0.12175076f, -0.32430854f, 
    0.21917434f, -0.10850491f, -0.20017770f, 0.09689555f, -0.10360973f, -0.30086565f, 0.03054894f, -0.01401714f, 
    -0.29922196f, 0.11241001f, -0.29546592f, -0.25249347f, 0.10557754f, 0.29230276f, 0.00647129f, -0.32970092f, 
    0.07639144f, -0.01130883f, 0.08707850f, 0.16261008f, -0.18650861f, 0.18618904f, 0.12256047f, 0.04873477f, 
    0.04152673f, 0.18353298f, -0.34007838f, 0.30810061f, 0.45028400f, -0.20545182f, 0.34335402f, 0.02772708f, 
    -0.36169827f, -0.41775021f, 0.06823260f, -0.40710869f, -0.13647069f, -0.03518293f, -0.11785545f, 0.25775686f, 
    -0.05345267f, -0.50920457f, -0.10859410f, 0.02268613f, 0.01514613f, 0.23143728f, -0.35734296f, 0.40190560f, 
    -0.01330862f, 0.27986667f, 0.02808098f, 0.59143901f, 0.26932308f, -0.07313173f, 0.10549436f, -0.22928128f, 
    0.03610282f, 0.03693903f, -0.02031467f, -0.65947568f, -0.42741120f, -0.60782278f, 0.29144910f, 0.09817044f, 
    -0.05368644f, -0.35889935f, 0.00732874f, 0.18868601f, 0.06037439f, 0.32785448f, -0.02637146f, 0.07548882f, 
    0.32090279f, -0.31340498f, -0.16575204f, -0.17364953f, -0.05907859f, -0.52619863f, -0.03664787f, -0.03819801f, 
    0.07374549f, -0.03882232f, -0.03213812f, 0.52085239f, 0.03141195f, -0.19228742f, 0.17090678f, -0.29630062f, 
    0.00898131f, 0.19896752f, -0.20181257f, 0.05245832f, -0.00189858f, -0.58308548f, -0.44180194f, -0.34594068f, 
    -0.60196280f, -0.10814507f, 0.11519827f, -0.11657951f, 0.30035299f, -0.19770348f, 0.18075025f, -0.19523488f, 
    -0.00991718f, -0.40819359f, -0.06699160f, -0.06584425f, 0.03029492f, -0.05897361f, 0.27633983f, 0.03110024f, 
    -0.19667649f, 0.11469883f, 0.09445769f, -0.25803709f, 0.36400056f, 0.14474031f, 0.35788092f, -0.36084685f, 
    0.13085914f, -0.09522190f, 0.08966298f, 0.21649440f, 0.22439836f, 0.22850783f, -0.20221692f, 0.40279955f, 
    0.23744349f, 0.45854327f, -0.72856909f, 0.20142619f, 0.04980696f, 0.06611958f, 0.00820127f, -0.09582747f, 
    -0.35200512f, 0.23453672f, -0.30969334f, -0.57295388f, 0.08424624f, -0.25733173f, -0.07266935f, -0.22542103f, 
    -0.01235741f, -0.43051773f, -0.07649821f, 0.00341318f, 0.14853662f, 0.10448045f, -0.41980493f, 0.18963809f, 
    0.07751829f, -0.06700372f, -0.14363714f, -0.61450183f, 0.04270706f, 0.02021175f, 0.36830372f, -0.13836874f, 
    0.07365400f, 0.19705141f, 0.06118597f, -0.22837913f, -0.44692883f, 0.03921132f, -0.22667998f, 0.18763706f, 
    -0.08421250f, 0.23019330f, 0.02293576f, -0.08546112f, 0.06832283f, 0.03693907f, -0.59445554f, 0.33023864f, 
    0.10486346f, -0.09516191f, -0.07052168f, 0.17149983f, 0.18466571f, -0.25596622f, -0.11627740f, -0.04527704f, 
    -0.60042596f, -0.11695265f, 0.11481202f, -0.11910599f, -0.58183616f, 0.30639449f, -0.16321507f, 0.09144869f, 
    -0.43330339f, 0.11776155f, 0.38750279f, -0.19682051f, 0.01561592f, 0.11701930f, -0.01859367f, -0.07605878f, 
    0.02816446f, -0.44434583f, -0.32884493f, 0.31448135f, -0.01986246f, -0.16273619f, -0.12726226f, 0.53090978f, 
    -0.05324896f, 0.34667680f, -0.04256159f, 0.20294085f, 0.08101067f, 0.30871651f, -0.72055203f, -0.23168318f, 
    -0.00501066f, 0.54666454f, 0.09133232f, -0.50387245f, -0.53439164f, 0.31897196f, -0.12855709f, -0.14447987f, 
    -0.27659059f, 0.15326047f, 0.08201196f, 0.19622737f, -0.07632943f, -0.39643764f, -0.15490143f, -0.07113484f, 
    0.01107212f, -0.67639536f, -0.00103995f, 0.00871474f, -0.08794295f, -0.34085342f, 0.07271611f, -0.87328529f, 
    -0.02546940f, 0.22950442f, -0.06703999f, -0.38916156f, 0.20162845f, -0.26172879f, 0.02216346f, 0.32591432f, 
    -0.29164565f, -0.02471778f, -0.01525220f, 0.19598822f, 0.13259974f, -0.38357756f, 0.13840747f, -0.51582855f, 
    0.38616428f, -0.23347327f, -0.18439581f, 0.17060658f, -0.13236104f, 0.14039558f, 0.06613617f, -0.04813050f, 
    0.20905043f, 0.16510144f, -0.25312474f, 0.30101070f, -0.09689699f, -0.47439522f, -0.07692038f, -0.03582270f, 
    -0.11467063f, 0.32161626f, -0.10474516f, -0.43221518f, 0.04524041f, 0.06221164f, -0.01533485f, 0.19241132f, 
    -0.08992815f, -0.40569058f, 0.52077162f, 0.09501946f, 0.13096613f, -0.23135738f, -0.06278450f, -0.38988635f, 
    -0.14444335f, 0.01700301f, -0.04009838f, -0.13468173f, 0.28435254f, -0.34974590f, 0.35080993f, -0.20582469f, 
    0.12690225f, -0.56861556f, -0.01609638f, -0.13093631f, 0.03606630f, -0.23956995f, 0.02286552f, -0.15815650f, 
    0.31282538f, -0.25042433f, 0.11623751f, -0.53054959f, -0.41378698f, -0.49976909f, -0.44947270f, 0.15082923f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.22002564f, 0.02820198f, 0.11280209f, -0.00596509f, 0.05079045f, -0.01479315f, 0.08534155f, -0.10451049f, 
    0.02767055f, -0.03336097f, -0.05648503f, -0.03742701f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
