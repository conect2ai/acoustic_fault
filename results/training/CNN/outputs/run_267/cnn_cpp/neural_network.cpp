#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00406758f, 0.35724533f, 0.20106252f, 0.35961038f, 0.37201902f, 0.35756940f, 0.35820180f, -0.42023161f, 
    0.41535419f, 0.60750288f, 0.62721175f, 0.30544904f, 0.02779267f, -0.43470919f, -0.29235500f, 0.17218703f, 
    -0.07768910f, 0.25756097f, -0.47955236f, -0.52258009f, -0.41030812f, 0.68243855f, 0.58808935f, 0.26542327f, 
    0.04397083f, -0.29014203f, -0.05933704f, 0.36846572f, 0.40208042f, 0.24644001f, 0.05395747f, -0.44890422f, 
    0.11130953f, -0.11718352f, 0.38188040f, 0.44109780f, 0.51849091f, 0.09897663f, 0.65582556f, 0.39538768f, 
    -0.02945425f, -0.12385628f, 0.34956342f, 0.16339105f, -0.24904731f, 0.36205265f, -0.43417546f, 0.46201298f, 
    0.53377384f, -0.23344028f, 0.25657681f, -0.28842986f, -0.44145977f, -0.22570685f, 0.54048187f, 0.23062441f, 
    0.46278518f, 0.36899570f, -0.43298197f, 0.36301577f, 0.27675399f, 0.16820677f, -0.00581373f, -0.56152260f, 
    -0.17651713f, -0.18722972f, -0.09286865f, 0.60659242f, -0.40720612f, 0.00340729f, 0.03568403f, -0.38353574f, 
    -0.14444177f, -0.70426178f, 0.45916858f, 0.38559887f, -0.13893647f, 0.69308937f, 0.32907379f, -0.18534264f, 
    -0.00700863f, 0.52851582f, -0.69940972f, 0.31411946f, 0.14967196f, 0.31852576f, 0.34372652f, -0.03471882f, 
    -0.18068577f, -0.14897053f, -0.31646883f, -0.40921059f, -0.40349245f, -0.16661268f, 0.66518503f, 0.05568304f, 
    -0.13100211f, -0.29236594f, 0.24760644f, 0.49867293f, 0.24988461f, -0.70547825f, 0.00089739f, -0.00809586f, 
    -0.36670750f, -0.27984956f, -0.29160419f, 0.29105392f, -0.03460786f, 0.63574409f, 0.37133443f, 0.65830392f, 
    0.15837124f, -0.44798329f, -0.19501674f, 0.13435082f, -0.37360010f, 0.21459436f, -0.52326250f, -0.39402658f, 
    -0.48062637f, 0.25001115f, -0.40219399f, -0.05134568f, 0.02577412f, 0.15154618f, -0.53487253f, 0.61311269f, 
    -0.26137894f, -0.21840206f, 0.40034291f, -0.28014153f, 0.04970891f, 0.14164267f, -0.02181664f, 0.15655355f, 
    -0.35594094f, 0.65769416f, 0.53852135f, 0.10678686f, -0.14127463f, -0.38565624f, 0.04474724f, 0.48534545f, 
    0.51260841f, 0.34480384f, 0.49707782f, 0.14711317f, 0.33877239f, 0.48613915f, -0.54857719f, -0.03260080f, 
    -0.24792925f, -0.03492761f, -0.34664464f, 0.23621398f, -0.75268531f, 0.39344838f, 0.13761950f, 0.32008627f, 
    0.37098756f, 0.32038867f, -0.45422587f, -0.02170628f, 0.57863516f, 0.43809304f, -0.04598195f, -0.03607000f, 
    0.03420326f, -0.15336050f, -0.27317685f, -0.23778491f, 0.10232274f, -0.05754701f, 0.60197026f, -0.25125670f, 
    -0.57670271f, -0.29897600f, -0.45117140f, 0.11179275f, 0.28452340f, 0.23388824f, 0.25908405f, -0.51513046f, 
    -0.78173262f, 0.08877995f, -0.04544929f, 0.01805858f, -0.35668874f, -0.66681266f, 0.37971801f, 0.50997633f, 
    -0.30957413f, 0.13022369f, -0.31883076f, 0.20808576f, -0.08047252f, -0.22830868f, -0.48277977f, -0.58030033f, 
    0.10837939f, 0.23070221f, -0.03687557f, -0.51264143f, 0.41492927f, 0.06840254f, -0.09023321f, 0.38962850f, 
    0.52113926f, 0.31328237f, -0.07495584f, -0.23819859f, 0.55892158f, 0.15600967f, -0.27511415f, 0.01842281f, 
    0.39716995f, -0.37364596f, -0.28517863f, -0.77144814f, -0.41823214f, -0.06504514f, 0.24814543f, 0.18865950f, 
    0.18168323f, 0.04754583f, -0.56553257f, 0.04042206f, 0.53887671f, -0.03924297f, -0.06796229f, 0.04567044f, 
    0.29274848f, 0.28443056f, -0.27629629f, 0.58691698f, -0.21781878f, 0.16074878f, 0.42584965f, 0.20110312f, 
    -0.31308925f, 0.12998140f, 0.23100773f, -0.02202274f, 0.67343783f, -0.54338706f, -0.19504955f, -0.36029813f, 
    -0.06062549f, 0.33468163f, -0.11989769f, -0.24305211f, 0.76454383f, 0.63588059f, -0.23218496f, 0.23823811f, 
    0.29171887f, -0.09637837f, 0.01859310f, 0.11287854f, -0.21277912f, 0.45086533f, 0.11964620f, 0.32864842f, 
    0.55110693f, 0.27192175f, 0.16892309f, 0.24282624f, 0.28974018f, -0.27156347f, 0.70459121f, -0.64475471f, 
    0.02798223f, 0.26944071f, -0.40366596f, -0.18912947f, -0.02321659f, 0.45278400f, 0.16905640f, 0.13755752f, 
    -0.90932268f, -0.53213900f, 0.04228343f, -0.30301148f, 0.11349398f, 0.19567300f, -0.17932203f, 0.02400565f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17298211f, -0.21722074f, -0.02424437f, -0.33306020f, -0.00497510f, -0.19995323f, -0.22333151f, 0.21432251f, 
    0.08747835f, -0.01812640f, -0.31162819f, 0.19278833f, -0.02634471f, -0.08576299f, -0.04884202f, 0.09177886f, 
    -0.00522975f, -0.23870674f, -0.39676252f, -0.30492577f, -0.21446042f, 0.14310534f, 0.08406756f, 0.27113938f, 
    -0.24055094f, 0.16667551f, -0.10034721f, -0.19952047f, 0.15221018f, -0.29265660f, -0.22687639f, 0.05664555f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.09279382f, 0.09201543f, -0.07361320f, -0.02078499f, -0.00197160f, 0.03676199f, 0.01426987f, -0.03358900f, 
    -0.10250041f, -0.28380382f, 0.03529747f, -0.16879934f, -0.01715106f, 0.01160561f, 0.11381133f, 0.09451470f, 
    -0.01927647f, -0.09275474f, 0.30365503f, 0.12053302f, -0.05829279f, 0.01461553f, 0.01816323f, 0.18983811f, 
    0.10931639f, 0.20166036f, 0.01445169f, -0.22497655f, -0.03599404f, -0.05808929f, 0.05156022f, -0.08716127f, 
    -0.09570936f, -0.19733757f, -0.01910715f, 0.00677194f, -0.29835826f, -0.11647730f, -0.04818462f, 0.09597339f, 
    0.10018767f, -0.09323813f, -0.01892130f, -0.01380936f, 0.04962872f, -0.03463353f, 0.10798298f, 0.15289322f, 
    0.04775373f, 0.11312908f, -0.04739558f, -0.00226087f, 0.08836580f, -0.02506938f, -0.35002738f, -0.02196889f, 
    -0.00182537f, 0.09692885f, 0.06318342f, -0.05889202f, -0.04327246f, -0.15336719f, -0.08738172f, 0.14941324f, 
    0.08244196f, 0.11342455f, 0.12494774f, 0.00715888f, 0.12779297f, 0.10498288f, 0.01003295f, 0.04806536f, 
    0.21769531f, 0.06037417f, -0.00930003f, -0.02547222f, -0.03391274f, -0.02831894f, 0.04082830f, -0.05586202f, 
    0.06796206f, -0.03304326f, -0.03078023f, -0.01579316f, 0.04853265f, 0.16243817f, -0.00536544f, 0.01707004f, 
    -0.01951848f, -0.06110841f, 0.07520137f, -0.06035414f, -0.07120697f, -0.08056226f, 0.01657140f, 0.07922680f, 
    -0.03974136f, 0.06367998f, 0.17547166f, -0.05049894f, -0.09329876f, -0.00727404f, 0.01384990f, 0.10457655f, 
    0.16976972f, 0.01869060f, 0.10155378f, -0.09944605f, -0.15957990f, -0.00182451f, 0.00388208f, 0.13886262f, 
    0.02400042f, 0.16128677f, 0.06102061f, -0.00449057f, 0.06861308f, -0.08937574f, -0.20942234f, 0.19551280f, 
    0.17164595f, 0.06059902f, 0.12398706f, 0.00440901f, -0.15529172f, 0.05112757f, 0.10355484f, 0.07785828f, 
    0.01637915f, 0.01951892f, 0.13498537f, -0.05357779f, 0.10134289f, -0.00638644f, 0.02412466f, -0.07713573f, 
    0.05200199f, -0.07446509f, 0.02445913f, -0.03249479f, -0.09786836f, -0.07881457f, 0.07732300f, 0.05841932f, 
    -0.14534394f, 0.11036166f, 0.07914463f, -0.02742580f, -0.01495091f, 0.07211647f, 0.10427703f, -0.09452625f, 
    0.18349880f, -0.19913733f, 0.17733009f, 0.04357825f, -0.07394817f, -0.00872554f, 0.07002082f, -0.01500489f, 
    -0.04310867f, -0.09462355f, 0.12114616f, -0.13182110f, 0.00594790f, -0.04872829f, -0.04335679f, -0.02745349f, 
    -0.01765056f, -0.08114260f, -0.20285542f, -0.06839490f, -0.23200999f, -0.04250722f, 0.12496245f, 0.01478814f, 
    0.08879389f, 0.11313903f, 0.08893880f, 0.00250884f, -0.01877594f, 0.15183234f, -0.10522491f, -0.01259741f, 
    0.08268332f, -0.05086716f, -0.07151981f, -0.10711288f, -0.09281990f, 0.14006735f, 0.16787694f, -0.15841509f, 
    -0.03881796f, 0.14170058f, -0.16222024f, 0.03219083f, 0.05949698f, -0.09014053f, 0.08452978f, 0.04331848f, 
    -0.01303817f, -0.11904520f, -0.00259110f, 0.05347456f, 0.06575133f, -0.03796339f, -0.06101733f, -0.13442308f, 
    0.02799261f, 0.02147420f, 0.11873329f, 0.12763031f, 0.00628641f, 0.07538953f, -0.10831378f, -0.05893601f, 
    0.02005477f, -0.16650926f, -0.05554870f, 0.03636395f, 0.12206888f, 0.02338041f, -0.03447608f, 0.03540040f, 
    0.08603326f, 0.10687862f, 0.12393498f, -0.03924508f, -0.09291895f, 0.01879000f, -0.11511593f, -0.08943003f, 
    0.10339398f, -0.04678968f, -0.09467757f, 0.13087048f, 0.07929485f, 0.05025586f, 0.08554505f, -0.06788576f, 
    -0.08261258f, -0.03624955f, 0.08410136f, -0.22506447f, 0.04590371f, -0.13245340f, 0.02607366f, 0.04592376f, 
    -0.00964350f, -0.02321869f, -0.19401757f, -0.08897117f, -0.26228499f, -0.00145253f, -0.00616359f, -0.07091915f, 
    0.01306539f, 0.10860228f, 0.12131730f, -0.06058427f, -0.13625845f, -0.34920844f, 0.08504574f, -0.09050315f, 
    0.03434747f, 0.04779142f, -0.07392958f, 0.14398663f, -0.14835572f, -0.08747116f, 0.04377028f, -0.12730797f, 
    0.05442399f, -0.00486765f, 0.11332144f, 0.14375542f, -0.15306404f, 0.02956816f, 0.06403138f, -0.01424959f, 
    -0.25116122f, 0.03774609f, 0.02754696f, 0.10390567f, -0.07289971f, 0.06041953f, -0.03315856f, -0.01470006f, 
    -0.02178868f, 0.00004077f, -0.00300910f, -0.04694198f, 0.00752386f, 0.01634756f, -0.06772026f, -0.06061348f, 
    0.01876400f, 0.04455389f, -0.00223641f, 0.00035918f, 0.04650187f, 0.04896760f, -0.01304265f, 0.04293379f, 
    -0.03699375f, 0.04406175f, -0.02534233f, 0.00400279f, 0.04348329f, -0.04323971f, -0.04166906f, -0.07039431f, 
    -0.02077436f, -0.02189660f, 0.03593681f, -0.03834141f, -0.01381967f, 0.04330501f, 0.02549253f, -0.04046975f, 
    0.00142909f, -0.00076527f, -0.04510408f, -0.01170744f, -0.02044990f, 0.03804315f, 0.01293296f, -0.03970959f, 
    -0.01566178f, -0.06892361f, 0.01642518f, -0.05157704f, -0.06142535f, -0.01610391f, -0.02522297f, -0.04742172f, 
    -0.06196771f, 0.02973155f, -0.00506219f, -0.04037897f, 0.02733927f, 0.04446276f, 0.00867260f, 0.01203485f, 
    -0.02600105f, 0.01240936f, 0.00786844f, 0.02802920f, 0.00164336f, -0.03222451f, 0.02328091f, 0.00214286f, 
    0.02721117f, -0.03380357f, -0.06145140f, -0.01724150f, 0.03222547f, -0.05704190f, -0.00793888f, 0.04262598f, 
    0.00063176f, 0.04749811f, 0.02787086f, 0.02736833f, -0.06362598f, -0.01132893f, 0.04196552f, 0.01142706f, 
    -0.00685220f, -0.04273558f, 0.01124403f, 0.01644071f, -0.00723837f, 0.03382802f, -0.02857845f, -0.03767854f, 
    -0.05600671f, -0.04235771f, -0.00388126f, 0.02029428f, 0.01777958f, -0.00057191f, 0.02765191f, -0.02363621f, 
    0.00548343f, -0.00500085f, 0.05289668f, 0.04085233f, -0.03955406f, -0.04136556f, -0.02341702f, -0.05695331f, 
    -0.06636643f, 0.02640008f, 0.02083882f, -0.05165626f, -0.03392607f, -0.03211376f, 0.00606398f, -0.00312907f, 
    0.00793908f, -0.02148543f, -0.04255450f, 0.04375743f, 0.02658476f, 0.00769894f, 0.00051388f, -0.02446985f, 
    0.01840749f, -0.02437536f, 0.01283890f, 0.00097297f, 0.01355018f, -0.05111845f, 0.00903395f, -0.02048776f, 
    0.04007239f, -0.00222292f, 0.04852973f, -0.04439105f, 0.03964897f, 0.01348487f, 0.04006755f, -0.06098715f, 
    0.01839936f, 0.03720443f, -0.03440380f, -0.05087572f, -0.04217122f, -0.02497549f, 0.05214278f, -0.03040876f, 
    0.00143920f, 0.01205250f, -0.04963482f, 0.04052455f, 0.01094788f, 0.01651639f, -0.03105613f, 0.03983175f, 
    -0.03654408f, -0.01015887f, 0.05259945f, -0.01340267f, 0.01408573f, -0.04515172f, -0.02830785f, 0.04626634f, 
    -0.03034152f, -0.00673432f, -0.02819739f, -0.03871294f, 0.03165236f, -0.00196498f, -0.04113645f, -0.06693923f, 
    -0.01046446f, -0.02580694f, 0.01135397f, 0.05339379f, 0.03309832f, -0.06353726f, 0.03579111f, -0.04270859f, 
    -0.05384042f, -0.04482862f, -0.05587247f, 0.00868613f, 0.02705893f, 0.01032052f, -0.00599569f, 0.04202748f, 
    0.00034998f, -0.02613647f, 0.04652758f, 0.00267645f, -0.03907107f, -0.06076225f, -0.00462261f, -0.03627720f, 
    -0.02433755f, -0.05530776f, -0.05958708f, 0.02127203f, 0.04228771f, -0.03110722f, 0.04639006f, 0.01773307f, 
    0.04926889f, -0.04360656f, 0.00497380f, -0.00848060f, -0.06116353f, -0.05082532f, -0.01615332f, 0.01816148f, 
    -0.02699067f, 0.05017380f, -0.03052549f, -0.04850732f, -0.01195303f, 0.02530843f, 0.00814281f, -0.02806926f, 
    -0.01058803f, 0.02293995f, 0.05086006f, -0.02826948f, -0.00347595f, -0.02764143f, 0.00878835f, -0.04805851f, 
    0.03934560f, -0.00303655f, 0.03189672f, 0.05310859f, -0.05540805f, -0.03113845f, -0.05706188f, 0.03826960f, 
    0.03814624f, -0.05096484f, -0.06530356f, 0.03815208f, -0.00986816f, -0.00273582f, -0.01496404f, 0.00045174f, 
    -0.03568700f, 0.03039290f, 0.01519434f, -0.06158277f, -0.02261455f, -0.03625441f, -0.03496239f, -0.05116091f, 
    0.02882838f, -0.00081420f, 0.04373899f, 0.01967296f, -0.00087174f, -0.03633624f, -0.01581375f, 0.00344890f, 
    -0.04192442f, -0.03796742f, 0.02107050f, 0.03226887f, -0.03138858f, -0.05694839f, 0.03065161f, -0.04366481f, 
    0.05032016f, -0.02769767f, -0.00274579f, -0.06126502f, 0.00593741f, -0.03792272f, 0.03853312f, -0.06047655f, 
    0.05207789f, 0.01962695f, -0.02634400f, 0.01416459f, -0.01027493f, -0.04707054f, -0.04818363f, -0.00391506f, 
    0.01402956f, -0.02040952f, 0.00673209f, 0.02475003f, -0.05519453f, -0.01722282f, -0.03807940f, 0.00013218f, 
    -0.02922749f, 0.05033326f, -0.06262842f, 0.01098289f, -0.00679890f, -0.04021097f, -0.04727056f, 0.04046130f, 
    -0.01140716f, 0.01101294f, 0.05811917f, 0.01782655f, -0.00914644f, -0.02407506f, -0.03049889f, 0.01499016f, 
    0.03605530f, 0.01190067f, -0.02922497f, -0.01257361f, -0.05023136f, 0.01190708f, -0.02518337f, -0.02079172f, 
    0.04649435f, -0.03210577f, 0.02325950f, 0.00170068f, -0.05459880f, -0.06089092f, 0.01105913f, -0.05202304f, 
    -0.02899672f, 0.03097580f, -0.04496906f, 0.03459420f, -0.02538876f, -0.05381577f, -0.03385665f, 0.02476713f, 
    -0.03668036f, 0.03168737f, -0.03242915f, 0.02469743f, -0.01623498f, -0.02663669f, 0.05165738f, 0.01690716f, 
    -0.00955170f, 0.00869735f, -0.01231308f, -0.00123021f, -0.02720737f, -0.04574738f, -0.04934173f, 0.05263691f, 
    -0.02683230f, 0.01357729f, 0.04335253f, 0.05602875f, -0.06750710f, 0.01823485f, -0.01694608f, 0.01069103f, 
    0.02111430f, -0.00748662f, -0.05589312f, 0.00237555f, -0.06306177f, 0.01826953f, -0.05675396f, -0.06034622f, 
    0.03455468f, -0.03935965f, 0.01820677f, -0.02851367f, 0.01549963f, 0.05070134f, -0.03102531f, -0.01707547f, 
    -0.02026837f, -0.02584210f, 0.02298656f, 0.02547459f, -0.03659007f, -0.01064512f, -0.04873754f, -0.01582905f, 
    -0.05993982f, 0.01290325f, -0.03235741f, -0.05348565f, -0.02968007f, 0.00769162f, -0.01917933f, 0.00106829f, 
    -0.05002505f, -0.02498892f, 0.00852793f, -0.03210970f, -0.03110503f, -0.05642721f, -0.04029963f, 0.00701930f, 
    -0.06949632f, 0.01916899f, -0.03998458f, 0.03561492f, 0.02198389f, 0.01675576f, -0.04480383f, 0.01765751f, 
    0.03594429f, 0.03958566f, -0.00282324f, -0.05506391f, 0.03410839f, -0.03842327f, -0.04236675f, -0.03658587f, 
    0.05540457f, 0.05259243f, 0.03555471f, 0.01163602f, -0.01566070f, -0.01734022f, 0.00745993f, -0.01741435f, 
    0.03927973f, -0.05307479f, -0.02129756f, -0.03685980f, -0.06124713f, -0.05742553f, 0.01521012f, -0.02840636f, 
    -0.04554777f, -0.03236513f, -0.03720947f, 0.03706782f, 0.02252177f, 0.01272142f, 0.03548993f, -0.05739057f, 
    -0.03375920f, -0.05657845f, -0.01538784f, 0.01358549f, -0.02861172f, -0.03441227f, -0.01041250f, 0.05024803f, 
    -0.02724800f, 0.03186116f, 0.05346904f, 0.02591021f, 0.05043565f, -0.04137167f, -0.01018616f, -0.03749254f, 
    -0.01742783f, 0.00393146f, -0.05699062f, -0.03267393f, 0.04953495f, 0.01382828f, 0.00812823f, -0.00880301f, 
    -0.05713223f, -0.05706188f, 0.02110527f, 0.05121782f, 0.04357685f, 0.00361826f, -0.05853149f, -0.04488343f, 
    -0.00971190f, -0.01463246f, -0.04887268f, -0.01978284f, -0.00362937f, 0.02860839f, -0.05978782f, -0.00316035f, 
    0.01156347f, -0.03365325f, -0.00629494f, 0.00921226f, 0.03687678f, 0.00943724f, 0.02832485f, 0.03432522f, 
    0.02083691f, -0.05531499f, -0.05818133f, -0.06901529f, 0.04510854f, -0.06507781f, -0.03897255f, 0.00951559f, 
    -0.00096740f, 0.03911888f, -0.01284493f, 0.03852872f, 0.03672296f, 0.02982223f, -0.07258833f, -0.00302503f, 
    0.04146094f, 0.05268358f, 0.01621307f, -0.00958409f, 0.00339903f, -0.00282870f, -0.02872859f, -0.00539245f, 
    0.01226528f, -0.03967689f, 0.03309064f, -0.00508745f, 0.01739601f, 0.01245805f, 0.02170037f, -0.04773455f, 
    0.00959426f, -0.00120528f, -0.01819998f, 0.00734575f, -0.04092990f, -0.04539655f, -0.02019735f, 0.04553524f, 
    -0.04845348f, -0.01273955f, -0.01611540f, -0.06673613f, -0.00035783f, 0.02711773f, 0.02551016f, 0.00168487f, 
    -0.00018668f, -0.04213617f, 0.01074138f, -0.02967850f, -0.06508714f, -0.06600180f, 0.02340241f, -0.07104997f, 
    0.03336542f, -0.06194521f, -0.02273928f, 0.00025066f, 0.02361412f, -0.04050551f, -0.03222117f, 0.04296062f, 
    -0.04650946f, -0.03540443f, 0.04550673f, 0.02880410f, -0.04051752f, -0.02420807f, 0.03672910f, -0.00138249f, 
    0.03782638f, 0.05077316f, -0.01983376f, 0.00085162f, -0.00541283f, -0.05624849f, 0.00174160f, -0.02485888f, 
    0.04612972f, 0.03732282f, 0.03047475f, 0.05273216f, -0.05412450f, 0.04517142f, 0.01751435f, -0.06413906f, 
    -0.04239834f, -0.04496865f, 0.04741807f, 0.04023048f, -0.06527992f, -0.02285454f, -0.03812736f, -0.03979213f, 
    -0.08234023f, 0.01798240f, -0.03189799f, 0.08940463f, -0.09169611f, -0.00968344f, 0.04484156f, 0.01469317f, 
    -0.00062988f, 0.06281695f, -0.13214999f, 0.05269594f, -0.08754548f, -0.02288236f, 0.00073761f, 0.03594196f, 
    -0.02244083f, -0.04570951f, 0.10051449f, 0.03346490f, 0.19561005f, -0.07220472f, -0.00968098f, 0.00747923f, 
    -0.06303925f, -0.00240683f, -0.00580041f, 0.02249779f, -0.08124439f, 0.07914365f, 0.05312107f, 0.01225985f, 
    0.01244421f, 0.04144468f, 0.16146785f, -0.01153088f, -0.23401442f, 0.02349523f, -0.00191168f, -0.03689204f, 
    -0.04083880f, 0.07437564f, 0.03810232f, 0.00746323f, 0.05376368f, -0.24983810f, -0.09663942f, -0.10129126f, 
    0.03871679f, 0.01376746f, -0.05533472f, -0.13018475f, 0.00617494f, 0.12437116f, -0.26396623f, -0.13536698f, 
    -0.04039800f, -0.02363975f, -0.03169140f, 0.16455609f, 0.01749586f, 0.07456584f, -0.07976654f, 0.09048381f, 
    -0.00390387f, 0.15306126f, -0.06387596f, -0.06084177f, 0.10439056f, -0.01148682f, 0.07581142f, -0.05552153f, 
    -0.01135487f, -0.04350056f, -0.08216333f, 0.01069906f, -0.10773277f, -0.02038248f, 0.01371816f, 0.10107281f, 
    -0.01919553f, -0.13741852f, -0.10565912f, -0.00139205f, -0.11015207f, 0.00055513f, -0.02478621f, 0.05734855f, 
    0.06487849f, -0.02772146f, 0.04399344f, 0.03099381f, 0.21636768f, -0.12413336f, 0.03308358f, 0.08779863f, 
    -0.00404590f, -0.15387420f, 0.13743795f, 0.12361626f, -0.03759987f, 0.15989225f, -0.06885923f, 0.11510634f, 
    -0.01406069f, -0.00993326f, -0.16208497f, -0.05755834f, 0.22447997f, -0.06595586f, 0.05581788f, 0.05783696f, 
    -0.07052613f, 0.11105958f, -0.08619754f, 0.09977417f, -0.03214314f, 0.08263737f, 0.02745332f, 0.21323901f, 
    0.03853148f, 0.02633637f, -0.01118349f, 0.06190155f, -0.12528892f, -0.04880453f, 0.20353742f, 0.03667914f, 
    0.12284438f, -0.05046094f, -0.17221077f, 0.06307895f, -0.10258885f, 0.06280992f, 0.02419685f, -0.18480319f, 
    0.07932372f, -0.02028264f, 0.17007586f, -0.05154718f, 0.01412584f, -0.00397153f, 0.10754219f, 0.02073723f, 
    -0.16067888f, 0.02124939f, -0.13318007f, 0.17048407f, 0.02567039f, 0.16672274f, -0.02053184f, -0.05110398f, 
    -0.02360852f, 0.01913268f, 0.01684687f, -0.02582650f, 0.03552047f, -0.08667841f, -0.11165237f, 0.05640643f, 
    0.06397737f, 0.08216406f, -0.05832348f, -0.25910839f, -0.00882954f, 0.06146092f, -0.17486408f, 0.05692115f, 
    -0.10129169f, 0.03842195f, 0.03417889f, -0.11106295f, -0.10380880f, -0.06741361f, 0.05396563f, 0.01039703f, 
    0.02318887f, -0.17879646f, -0.11624718f, 0.00049598f, 0.01825871f, -0.03356005f, -0.13655131f, 0.02566794f, 
    0.04725576f, -0.11323149f, 0.04725731f, -0.11623909f, -0.02003957f, 0.14191262f, 0.09784988f, 0.13525459f, 
    0.02868202f, 0.01887778f, -0.01972221f, 0.02399959f, 0.02084960f, -0.17075817f, -0.02424730f, -0.01034502f, 
    0.09472880f, 0.08279594f, 0.12514591f, -0.11725544f, 0.01050851f, -0.02307571f, 0.03907404f, -0.13246046f, 
    -0.04634520f, -0.05984592f, 0.05033105f, 0.05477443f, 0.12681976f, -0.05668925f, -0.03116918f, -0.06407787f, 
    0.17764534f, -0.04127886f, 0.05011743f, -0.09228471f, -0.01928834f, -0.12433625f, 0.14892006f, 0.05183375f, 
    -0.19682381f, 0.02247185f, -0.03681884f, -0.01326530f, 0.06933042f, -0.02741830f, -0.01340250f, -0.06687286f, 
    0.07807668f, 0.08224392f, 0.09343286f, -0.01522769f, 0.01529386f, 0.10299223f, -0.03265100f, 0.02646401f, 
    -0.01067170f, -0.10380096f, 0.11943951f, 0.03355692f, -0.00792958f, 0.09970018f, -0.01225325f, -0.02943549f, 
    0.06796291f, -0.08477376f, -0.07315322f, -0.05662698f, -0.00039752f, -0.14386088f, 0.20425722f, -0.00050144f, 
    -0.06846045f, 0.08815706f, -0.03276895f, 0.04245524f, 0.04328139f, -0.16731420f, 0.08043139f, -0.05677101f, 
    -0.03776615f, -0.01938436f, 0.14044058f, 0.11537298f, -0.01473878f, -0.13004853f, 0.04615568f, -0.10320920f, 
    -0.00714907f, 0.00724649f, -0.10510508f, -0.02079090f, 0.01770661f, -0.01238614f, 0.12086838f, -0.10432259f, 
    -0.12441013f, -0.04184132f, -0.07917401f, -0.12569037f, -0.02856483f, -0.04913260f, 0.11327165f, 0.03879489f, 
    0.01525942f, -0.04091275f, -0.03646282f, 0.03171253f, 0.01222989f, -0.01874981f, -0.02071442f, -0.00016277f, 
    -0.02251864f, 0.01555354f, -0.05395314f, 0.03715746f, -0.01551697f, -0.03172337f, 0.05626536f, -0.00922950f, 
    -0.04365961f, 0.00655499f, -0.00178959f, -0.04565751f, -0.00193773f, -0.05101836f, -0.06199252f, -0.01958910f, 
    0.05622107f, -0.06092917f, -0.04772477f, -0.02059214f, -0.01536653f, -0.01605588f, -0.05868174f, -0.02081661f, 
    0.02751268f, 0.03363136f, -0.00670082f, 0.06121079f, -0.04337996f, -0.02983921f, -0.05246258f, -0.05565059f, 
    -0.00814284f, -0.03660670f, -0.02003256f, -0.05379719f, 0.00541187f, 0.00008161f, 0.05381554f, 0.05000815f, 
    0.03197651f, -0.02649662f, 0.01904831f, 0.03262462f, -0.01583820f, -0.06987113f, 0.05903118f, 0.04114964f, 
    -0.04630627f, -0.00709153f, 0.05815147f, 0.01670971f, -0.03188556f, 0.00442427f, -0.02814690f, -0.01638725f, 
    -0.03504669f, 0.02026703f, -0.06737795f, 0.02836368f, 0.05276934f, 0.00114377f, -0.00816621f, -0.03497392f, 
    0.00231653f, 0.03017893f, -0.00206766f, -0.00964384f, 0.02365157f, -0.02468321f, 0.03679085f, -0.06314976f, 
    -0.05272840f, 0.02051890f, 0.05298632f, 0.04663373f, 0.04521940f, -0.04635198f, -0.02455486f, 0.04523136f, 
    -0.03238582f, 0.05085703f, -0.02528461f, -0.00054863f, -0.02995531f, -0.06176122f, -0.03356107f, 0.00424607f, 
    -0.02961092f, 0.01930543f, -0.01978932f, 0.03901355f, 0.02984112f, -0.01153076f, -0.04761860f, -0.02230735f, 
    -0.04467089f, -0.04543766f, -0.02288797f, 0.00526631f, 0.03527576f, -0.01725621f, 0.04874974f, -0.00426056f, 
    -0.05182821f, -0.06005900f, -0.00495341f, -0.06418274f, -0.04827489f, -0.00517794f, 0.00608584f, 0.02595529f, 
    0.00600311f, -0.02693349f, -0.02852682f, -0.06061105f, -0.02566326f, -0.00436622f, -0.03400312f, -0.04658178f, 
    0.00707038f, 0.00108352f, 0.05189465f, -0.01965189f, -0.04405306f, 0.03570280f, 0.01830260f, -0.05119834f, 
    -0.06183743f, 0.00900503f, -0.05824761f, 0.01918055f, -0.04034735f, -0.03956341f, -0.06005207f, -0.02885822f, 
    0.04788135f, -0.04539026f, -0.01100775f, 0.03031005f, 0.05221972f, 0.03903938f, -0.05024714f, -0.05058783f, 
    -0.02375033f, -0.01470957f, 0.02195359f, -0.02502445f, -0.04583736f, -0.02558765f, -0.01731761f, -0.03064159f, 
    -0.01222462f, -0.02708683f, -0.00078650f, 0.02803310f, -0.02520989f, -0.04391758f, 0.03226658f, -0.06941184f, 
    0.00602545f, -0.02683826f, -0.07032639f, 0.04238459f, -0.05404715f, -0.06200896f, -0.02326063f, -0.03514447f, 
    -0.00782662f, 0.02459942f, -0.04983490f, -0.03829625f, -0.00116110f, -0.00282772f, 0.00369176f, 0.02588144f, 
    -0.04701492f, -0.04465392f, 0.06134340f, 0.02531939f, 0.02918687f, 0.01326211f, 0.02986555f, -0.02422990f, 
    -0.02408194f, 0.05674251f, 0.03872825f, -0.00107988f, 0.01206868f, -0.04934229f, 0.00568390f, -0.03862628f, 
    0.01300723f, 0.00739461f, 0.00867322f, -0.03361564f, 0.04971762f, 0.01481925f, 0.02529617f, -0.05228292f, 
    0.02272468f, 0.06276521f, 0.03505200f, -0.04299989f, 0.00642457f, 0.04418320f, 0.00099515f, 0.02498422f, 
    -0.00561317f, 0.04799305f, -0.02281121f, 0.03326970f, 0.01349416f, -0.01137853f, -0.02190919f, -0.04337383f, 
    -0.04396248f, 0.05159790f, -0.03448386f, 0.03319879f, -0.05950757f, 0.00632445f, -0.00396260f, -0.02418536f, 
    -0.04105568f, -0.02087064f, 0.03084039f, 0.01333061f, -0.05606863f, -0.00712066f, 0.01902293f, 0.02897871f, 
    -0.02329526f, -0.03345896f, -0.04188742f, 0.05420066f, -0.05122203f, 0.04890432f, 0.04185499f, 0.03052250f, 
    0.02547061f, -0.04274663f, -0.02580614f, 0.03088524f, 0.06504364f, -0.01878058f, -0.00946981f, 0.01758599f, 
    0.00542773f, -0.05219581f, 0.04989688f, 0.03949014f, 0.00741638f, 0.02175627f, 0.04976229f, -0.03163566f, 
    -0.05156120f, 0.02899450f, -0.03805252f, -0.00597074f, 0.04313604f, -0.05893384f, -0.00864852f, -0.01191200f, 
    0.02796896f, 0.01973666f, -0.00133048f, 0.03148913f, 0.04420110f, -0.00309673f, -0.00788848f, 0.02252021f, 
    -0.03726136f, -0.01531074f, -0.04628567f, -0.05698228f, -0.05511780f, -0.01965297f, 0.02305301f, 0.02393230f, 
    0.25110427f, 0.10737131f, 0.17686141f, 0.00501949f, -0.12334336f, -0.02799992f, 0.05037955f, 0.00374532f, 
    -0.04015888f, -0.15282284f, -0.00917644f, 0.11443830f, 0.05756732f, 0.07857575f, -0.03741226f, -0.00082048f, 
    -0.01308859f, -0.01354600f, -0.03711533f, 0.00652561f, -0.03858752f, -0.08203772f, -0.03576354f, -0.08714677f, 
    0.12997486f, 0.05436873f, -0.13179336f, 0.08859125f, -0.13079605f, -0.00930438f, -0.03257583f, 0.04190920f, 
    -0.03551981f, 0.01018227f, 0.11839786f, -0.01112161f, 0.06345285f, 0.08908187f, 0.10600384f, -0.05019654f, 
    -0.04655913f, -0.01236005f, 0.06916643f, 0.02214514f, 0.11408462f, 0.19097108f, 0.10623509f, 0.04131691f, 
    -0.05885036f, 0.06351434f, 0.00841713f, 0.07607115f, 0.07986613f, 0.00210777f, 0.09537529f, 0.12362287f, 
    0.09067562f, 0.03041146f, -0.02292035f, 0.02132040f, -0.00395601f, -0.02472850f, 0.16073793f, -0.28749752f, 
    -0.29475549f, -0.02308611f, 0.04619901f, 0.07210993f, 0.08040155f, -0.00559675f, -0.03944312f, -0.01538251f, 
    0.22544214f, -0.08821679f, -0.05076789f, -0.05607739f, 0.00158133f, 0.07199031f, -0.00897839f, 0.01182899f, 
    -0.12094042f, 0.10665344f, -0.02097443f, -0.01912760f, 0.05998706f, -0.17459671f, -0.14244226f, -0.04178779f, 
    0.07958391f, -0.03247669f, -0.25362676f, -0.01955181f, -0.08408652f, -0.03705540f, -0.08600164f, -0.05546778f, 
    0.01747553f, -0.04946739f, -0.18371469f, -0.03319925f, -0.03879295f, -0.24293341f, 0.05419909f, -0.03838818f, 
    0.04215071f, -0.03279606f, -0.04307724f, -0.02991463f, -0.04839284f, -0.05727557f, 0.15234055f, 0.12113082f, 
    -0.11345873f, -0.15425804f, 0.01164440f, 0.12594123f, -0.03271389f, 0.16863252f, 0.07515339f, -0.07516808f, 
    0.03891639f, -0.10784649f, 0.05813425f, -0.10660802f, -0.04650004f, 0.00534891f, -0.23604046f, -0.34352508f, 
    -0.19584344f, 0.01533290f, 0.12171066f, 0.24513051f, 0.00131264f, 0.02776635f, 0.06521082f, 0.03369553f, 
    -0.03525515f, 0.01867434f, 0.03854856f, 0.00637525f, 0.01432031f, 0.03933611f, 0.10953842f, -0.12147911f, 
    0.13920355f, -0.04883008f, 0.07118918f, 0.10842038f, 0.03500728f, -0.01905216f, 0.06879911f, -0.05943809f, 
    -0.01278524f, -0.19532199f, 0.06347582f, -0.03884714f, 0.01540862f, -0.01220714f, -0.03937041f, -0.00657703f, 
    0.02503919f, 0.11734547f, -0.07104932f, -0.04395919f, 0.02309350f, 0.05555095f, -0.09602675f, -0.15556604f, 
    0.05739235f, -0.10097896f, 0.03251702f, -0.25730079f, -0.03966761f, 0.01241913f, -0.00469318f, -0.01693194f, 
    0.06519973f, -0.06137222f, 0.10126067f, -0.16896792f, -0.09793919f, -0.16325074f, -0.03918786f, 0.03683568f, 
    -0.05010051f, 0.20972915f, 0.18052848f, 0.00504048f, 0.20569421f, -0.20408463f, -0.19963431f, 0.03123209f, 
    0.06372919f, 0.02877768f, -0.07754781f, -0.05571971f, -0.08390074f, 0.05903590f, -0.19563647f, -0.03421758f, 
    0.02866645f, -0.00221547f, -0.01773082f, -0.01868217f, -0.01364512f, -0.00108955f, 0.22592133f, 0.10515623f, 
    0.00434365f, 0.16509031f, 0.02547051f, 0.04648638f, 0.02794905f, 0.07712747f, 0.00631477f, 0.02553848f, 
    -0.03898030f, -0.11135229f, 0.00648206f, 0.01822640f, -0.01074539f, 0.08878946f, -0.09171052f, 0.03702706f, 
    0.12661546f, 0.05060383f, -0.00890399f, -0.05280691f, 0.07415918f, 0.00069287f, 0.08400072f, 0.06651112f, 
    0.03114349f, 0.08764195f, 0.09496228f, -0.05038422f, -0.27848533f, 0.03986648f, -0.05133198f, -0.13846549f, 
    -0.06399891f, 0.12963721f, 0.08287913f, 0.11580859f, -0.22545789f, -0.25711429f, -0.05849183f, -0.10084184f, 
    0.21230532f, 0.12025470f, -0.13754238f, 0.01722347f, -0.02985421f, -0.00272840f, -0.00888655f, -0.00945488f, 
    0.05065482f, -0.08839918f, 0.02340229f, 0.00047390f, 0.10644315f, 0.16794798f, 0.18698874f, 0.04866768f, 
    -0.06318001f, -0.10948590f, 0.00099508f, 0.05057941f, -0.04282175f, 0.17915115f, 0.26111519f, 0.13385093f, 
    -0.05418127f, 0.19350158f, -0.09233849f, -0.07566686f, -0.01962369f, -0.03156383f, -0.00646352f, 0.02131143f, 
    0.35107082f, 0.02523519f, 0.07645778f, 0.05694534f, -0.03988643f, -0.02763803f, -0.06316656f, 0.05758080f, 
    -0.05985457f, -0.09003321f, 0.13594908f, -0.01652431f, -0.03759277f, -0.06682612f, 0.06789450f, -0.02668199f, 
    0.11150175f, -0.06289605f, -0.15199533f, 0.02888021f, 0.14235669f, 0.06095726f, -0.02224864f, -0.10691868f, 
    -0.01720328f, 0.08193656f, 0.11767162f, 0.13081892f, 0.05586728f, -0.04848874f, 0.08445866f, 0.00973406f, 
    -0.02304020f, 0.02871308f, 0.07884966f, 0.07893443f, -0.45537478f, 0.04699264f, 0.15679923f, -0.03115142f, 
    -0.08670180f, -0.00308236f, -0.04937859f, 0.01898104f, -0.32734922f, -0.20951927f, 0.09796089f, -0.03786008f, 
    0.04604292f, 0.06560296f, 0.01980673f, -0.02329777f, 0.04045905f, -0.13472663f, -0.18652032f, -0.01718975f, 
    0.06555528f, 0.09302901f, 0.03257471f, -0.05882187f, -0.01555782f, -0.06797492f, -0.22203232f, -0.29774654f, 
    -0.08315849f, 0.14357908f, -0.07591036f, 0.08872086f, 0.00686613f, -0.06029347f, -0.05081951f, -0.01170537f, 
    0.14143388f, 0.10162211f, 0.02994163f, 0.02264717f, 0.03040384f, -0.04784824f, -0.01039927f, -0.00770451f, 
    0.10817587f, -0.00417016f, 0.11566147f, -0.01272646f, 0.06641307f, -0.05732129f, -0.08301964f, -0.01272984f, 
    -0.02329806f, -0.02800108f, -0.16014050f, -0.09069312f, 0.07790913f, 0.15236939f, 0.05015529f, 0.10309364f, 
    0.00954032f, 0.01966217f, 0.03781809f, 0.02711429f, -0.06772135f, 0.10899399f, -0.06924757f, 0.07080639f, 
    0.09747996f, 0.04014979f, -0.06708938f, -0.05196191f, 0.03957863f, 0.05577473f, 0.00267200f, -0.02546500f, 
    -0.09135891f, 0.05308378f, 0.01092483f, 0.02810029f, 0.37445757f, -0.06544016f, -0.25099626f, -0.08697635f, 
    -0.04498938f, -0.07514127f, -0.06522049f, -0.06972861f, 0.12324475f, -0.00605579f, 0.11829332f, -0.01440319f, 
    0.05461885f, -0.02594522f, -0.00084293f, -0.05191732f, 0.04045407f, -0.06888843f, 0.23541042f, 0.02937781f, 
    0.03020359f, 0.03460441f, 0.00001880f, -0.04368105f, -0.11013692f, -0.12475004f, -0.11827958f, -0.13767929f, 
    -0.15139852f, 0.05012038f, 0.03381453f, 0.02394121f, -0.05719046f, 0.05928057f, 0.07017053f, 0.00173879f, 
    -0.06696445f, 0.06912384f, 0.17768730f, 0.04316177f, -0.00033940f, 0.16156632f, -0.04898349f, 0.03550585f, 
    -0.02973918f, -0.16113333f, -0.00032734f, 0.15089306f, -0.11210718f, -0.10019267f, -0.11607163f, -0.07439658f, 
    0.07153864f, -0.07208824f, 0.11198649f, -0.07039127f, -0.09734068f, -0.10156159f, -0.18110175f, 0.00406200f, 
    -0.11039865f, -0.16666922f, 0.12750308f, 0.32348895f, -0.09143923f, -0.02711468f, 0.00366590f, -0.07991204f, 
    -0.05373506f, 0.04961594f, 0.02126286f, 0.00206065f, -0.19391060f, -0.24831757f, -0.05344584f, 0.10113595f, 
    -0.01927963f, 0.10949806f, -0.01249057f, -0.07043375f, 0.05053715f, 0.13274617f, 0.06564967f, 0.14478038f, 
    0.05864698f, 0.02415071f, 0.03517002f, 0.05102249f, -0.06788745f, -0.03362393f, 0.00240788f, 0.05098855f, 
    0.05749551f, -0.05666569f, -0.05494517f, 0.02445821f, -0.06298216f, -0.00024147f, 0.02816968f, -0.13936049f, 
    -0.21081536f, 0.06918897f, 0.00167608f, 0.08817942f, 0.02394091f, -0.03555162f, 0.00689905f, 0.02443757f, 
    0.12483307f, 0.01239089f, -0.17645606f, -0.12972838f, -0.05199682f, -0.00610432f, 0.06462451f, 0.03656890f, 
    -0.04483023f, 0.11984933f, -0.03070165f, -0.08000915f, 0.03589245f, 0.03980386f, 0.04237867f, -0.05622403f, 
    0.08796147f, 0.09659766f, -0.07582779f, -0.09298043f, -0.03753021f, 0.11365996f, 0.00660250f, -0.13714479f, 
    0.02655116f, -0.05890576f, 0.01914646f, 0.11467666f, -0.01941128f, -0.10352298f, 0.08884447f, 0.08975123f, 
    -0.01180625f, -0.11735767f, 0.02195100f, -0.13936532f, 0.02167643f, -0.07412802f, -0.28840825f, -0.08288723f, 
    0.00857557f, -0.14674632f, -0.04923033f, 0.04072020f, 0.01518718f, -0.22427437f, 0.11192551f, -0.10269526f, 
    -0.02618110f, 0.01454932f, -0.02899943f, 0.06340015f, -0.06733664f, -0.03593584f, 0.14487115f, 0.00500686f, 
    -0.18660581f, 0.04911728f, -0.02693980f, -0.04918370f, -0.00343270f, 0.06299010f, 0.04772854f, 0.04459371f, 
    0.04772073f, -0.24285971f, 0.05282290f, -0.05394273f, 0.00606340f, -0.03402722f, 0.07783597f, 0.04344890f, 
    -0.10667083f, -0.06140262f, -0.04211733f, -0.00234343f, 0.01658586f, 0.06185918f, 0.02640772f, 0.08195917f, 
    -0.07646053f, 0.03195785f, 0.06187924f, -0.04318304f, 0.04362589f, 0.08873817f, 0.05180329f, -0.06052999f, 
    0.13627629f, 0.03236520f, -0.08591652f, -0.12782909f, 0.21634670f, -0.03421967f, -0.05163822f, 0.06554031f, 
    -0.03308851f, 0.03595639f, 0.14048971f, -0.08175337f, -0.06192172f, 0.11913164f, 0.01394349f, 0.01152388f, 
    -0.02577511f, -0.15676960f, 0.02807088f, 0.05593772f, -0.10188017f, -0.08393107f, -0.05185441f, -0.05991425f, 
    -0.00828811f, -0.01209182f, -0.00262805f, 0.04503618f, -0.08133231f, 0.06382371f, 0.05915550f, 0.01693774f, 
    -0.12621951f, 0.08442108f, -0.04856430f, 0.07749279f, 0.03750477f, -0.14050265f, -0.11650034f, -0.06923258f, 
    -0.02461667f, -0.00764919f, 0.08293294f, 0.06509769f, -0.10732679f, -0.06436647f, -0.08836070f, 0.01142460f, 
    0.12908185f, 0.11634090f, -0.00191056f, -0.13058634f, 0.03454543f, -0.10566570f, 0.00586637f, 0.08129728f, 
    0.05065619f, 0.02333033f, -0.06104953f, -0.04997091f, 0.00167848f, -0.03632171f, -0.00831347f, -0.01870023f, 
    -0.06499002f, 0.05755670f, 0.06111391f, -0.05318172f, -0.08512995f, 0.09605968f, 0.07533527f, -0.00578242f, 
    -0.00092471f, -0.09997465f, -0.11045358f, 0.02005836f, 0.24601191f, 0.01261033f, -0.26847246f, 0.15384865f, 
    0.10613491f, -0.01420301f, 0.02888733f, 0.12190890f, 0.04669968f, -0.03058821f, 0.00658348f, -0.11155716f, 
    -0.09718040f, -0.02246395f, -0.07610989f, -0.02864813f, 0.11799075f, -0.03475044f, -0.03338400f, -0.00255077f, 
    -0.02075723f, 0.08709643f, -0.05122772f, 0.03884861f, -0.08109248f, 0.03889221f, 0.08681709f, 0.08997063f, 
    0.01203516f, -0.20727159f, -0.05677139f, 0.02696023f, -0.09292845f, 0.02313279f, 0.30013925f, 0.15324564f, 
    -0.00965667f, -0.18678640f, -0.03302781f, 0.05136399f, 0.01885940f, 0.01726774f, -0.03084951f, 0.00241614f, 
    -0.05367715f, 0.03165651f, 0.08265235f, 0.15103322f, 0.03268940f, 0.07329928f, 0.17370248f, -0.11638894f, 
    -0.07513183f, -0.10149647f, -0.05101117f, 0.05556798f, 0.09139752f, 0.14506502f, -0.02631585f, 0.02254639f, 
    -0.15885514f, -0.04122284f, -0.04100734f, 0.02639005f, -0.08741385f, -0.13219476f, 0.02517773f, -0.04779460f, 
    0.02391106f, -0.06789934f, -0.04015713f, -0.25806600f, -0.06544660f, -0.07796626f, -0.03402048f, 0.09642577f, 
    0.14975630f, -0.05199930f, -0.04455683f, 0.01781018f, -0.09995946f, 0.06949504f, 0.02016723f, 0.03011864f, 
    0.03509229f, -0.04860898f, 0.09244526f, 0.12746005f, -0.04617508f, -0.09549762f, -0.14782976f, -0.02312116f, 
    0.16744341f, -0.04673355f, 0.14435327f, -0.14796631f, -0.04101460f, 0.15702543f, 0.08236876f, 0.05407509f, 
    -0.09068195f, -0.13441615f, 0.02039002f, -0.02389597f, -0.01550182f, -0.04015325f, -0.03706066f, -0.15797804f, 
    0.00283534f, 0.09121093f, 0.02559369f, 0.07746182f, -0.00294742f, -0.11079783f, -0.01076670f, -0.01633084f, 
    -0.00500700f, -0.24743266f, 0.03680851f, 0.12551187f, 0.12658004f, 0.04003481f, -0.04828949f, -0.15837738f, 
    0.10401334f, 0.00912759f, 0.01790175f, -0.02252615f, 0.10593784f, -0.15524940f, -0.06608462f, 0.10400245f, 
    0.07059442f, -0.00907870f, 0.00445830f, 0.01686077f, 0.00975750f, -0.02669843f, 0.04508046f, 0.01761509f, 
    0.05033912f, -0.13228233f, 0.06373136f, 0.16026925f, 0.20891821f, 0.09242231f, -0.02870564f, -0.01704508f, 
    -0.05295156f, -0.05277513f, -0.17581922f, 0.01855578f, 0.01782889f, 0.02729584f, 0.00216445f, 0.14089702f, 
    -0.08127318f, 0.00292781f, -0.00730068f, 0.09066294f, 0.07663779f, 0.06313062f, -0.04261378f, -0.09371071f, 
    -0.10504952f, 0.07172406f, -0.02632851f, 0.07187910f, -0.07737371f, -0.12166101f, -0.02248009f, -0.05340646f, 
    -0.01120999f, 0.07951009f, 0.06822474f, -0.05622106f, -0.01798213f, -0.15787762f, 0.12828018f, 0.08764841f, 
    -0.06595882f, 0.11780703f, -0.11664008f, 0.08222111f, 0.05363306f, 0.13952470f, -0.05638400f, 0.08856950f, 
    -0.13731362f, -0.09853970f, -0.13774723f, -0.03568818f, 0.09413704f, -0.09382289f, 0.11832178f, -0.11934537f, 
    0.01984020f, -0.12082169f, -0.04539676f, 0.03428748f, 0.08055765f, 0.08639831f, 0.14171107f, -0.02487660f, 
    -0.08166488f, -0.02197874f, 0.14315125f, 0.21296217f, -0.09205613f, 0.04578280f, -0.08330952f, -0.09655917f, 
    -0.05661075f, 0.00660415f, -0.01284734f, -0.31332445f, -0.29466891f, 0.21936677f, 0.07417094f, 0.00564027f, 
    -0.02586988f, -0.06944223f, 0.03960095f, -0.09715897f, 0.14657836f, -0.01424739f, -0.13041304f, -0.06705298f, 
    -0.15814969f, -0.06196180f, -0.02604803f, -0.20051536f, 0.12622440f, 0.02475589f, 0.04839896f, -0.11301946f, 
    -0.09827945f, 0.11100840f, -0.00717628f, 0.07420326f, 0.07274839f, 0.16699353f, 0.03085784f, -0.09534277f, 
    0.02323731f, 0.05172855f, 0.02057221f, -0.07870193f, 0.02685921f, 0.00276407f, -0.13573511f, 0.09012588f, 
    0.07799523f, -0.04763061f, -0.02327999f, 0.08575879f, -0.07618099f, 0.03403324f, -0.17707431f, -0.06603592f, 
    -0.20215861f, -0.19457299f, 0.07380942f, 0.14472097f, -0.02274399f, 0.06224968f, 0.00124854f, -0.02730774f, 
    0.35923392f, -0.05922563f, -0.25312147f, 0.03024353f, 0.04721901f, 0.16489458f, 0.05138355f, 0.02159571f, 
    -0.05484268f, 0.49604586f, -0.02546857f, -0.10493856f, 0.00573031f, 0.01804628f, 0.01758349f, -0.05128054f, 
    -0.03044416f, 0.02904653f, 0.03381637f, -0.08872394f, -0.15166517f, 0.04001159f, -0.05718067f, 0.03812809f, 
    -0.12528324f, -0.11592542f, -0.14880922f, -0.01637180f, 0.05295103f, 0.18674713f, 0.06952983f, 0.01860736f, 
    -0.05816846f, 0.12122572f, 0.16299535f, 0.04744006f, -0.03761522f, 0.06503469f, -0.07934266f, 0.10883190f, 
    0.01039712f, 0.00736837f, 0.02924636f, 0.05242733f, -0.04533353f, -0.13963352f, 0.08464864f, -0.24553379f, 
    0.08299150f, 0.06040776f, -0.12009831f, -0.00496813f, -0.02729291f, -0.06093644f, 0.07464270f, -0.28245646f, 
    -0.08543976f, -0.09967896f, 0.10065895f, -0.04072044f, -0.07068491f, -0.05898627f, -0.02826461f, -0.03821690f, 
    -0.08264409f, 0.04998680f, 0.06461645f, -0.02205786f, 0.01286166f, 0.14829692f, 0.03669964f, -0.01306006f, 
    -0.10071935f, 0.16440105f, 0.24967965f, 0.14063925f, 0.01542224f, 0.05708780f, 0.07923718f, -0.03714762f, 
    0.04639242f, -0.10764620f, -0.20729233f, -0.02636285f, 0.01322581f, 0.02925802f, 0.02842506f, -0.13895789f, 
    -0.06339616f, -0.11954239f, 0.17172748f, -0.16004632f, -0.14940481f, 0.02552414f, -0.14663287f, -0.07086221f, 
    -0.05925251f, -0.04236639f, -0.04042324f, -0.22652039f, -0.02864692f, -0.19467211f, 0.04637695f, 0.07368553f, 
    -0.01330476f, 0.09289977f, 0.13260084f, 0.13340501f, 0.00058002f, 0.14477707f, 0.15934744f, -0.16818470f, 
    -0.04441420f, 0.06908431f, -0.12315065f, 0.13375717f, 0.12549339f, 0.09371603f, -0.05487417f, 0.07520790f, 
    0.01258801f, 0.09424344f, -0.09246185f, 0.09393635f, 0.00576643f, 0.01205151f, 0.03430215f, 0.09288807f, 
    -0.32945704f, 0.14045775f, -0.02183779f, -0.01044917f, 0.13287257f, -0.07314848f, 0.07026608f, -0.07722098f, 
    0.11039486f, 0.15102246f, -0.01854099f, 0.09011941f, -0.00322155f, 0.01945484f, 0.08840491f, 0.00699690f, 
    -0.23753408f, -0.14034395f, -0.20456214f, 0.01729780f, 0.05131623f, -0.02842689f, 0.04410315f, 0.01693210f, 
    -0.03463196f, 0.01821640f, -0.09828576f, -0.15808269f, 0.01351800f, -0.10378419f, -0.00499797f, 0.05468133f, 
    -0.01197098f, -0.06346606f, 0.25150108f, -0.12919801f, 0.13844323f, 0.00215583f, -0.00912764f, 0.15744065f, 
    0.00744789f, 0.02329423f, -0.08235199f, -0.15585546f, -0.07426350f, 0.23481582f, -0.03502563f, -0.03750818f, 
    -0.01934099f, 0.03619799f, -0.02371521f, 0.14801636f, -0.13056013f, 0.26655906f, 0.26919708f, -0.05220811f, 
    -0.01212812f, -0.03716407f, 0.00806080f, 0.04912044f, -0.01568661f, -0.18141916f, -0.17444867f, -0.03703486f, 
    -0.02593642f, -0.04604866f, 0.02915018f, 0.03334622f, -0.01625963f, 0.06063918f, 0.10670580f, 0.01099660f, 
    -0.22711463f, -0.01123390f, -0.01727504f, -0.18959075f, -0.08234144f, 0.09608800f, -0.10653342f, 0.15836549f, 
    -0.06287047f, -0.22183348f, -0.03136009f, 0.00292399f, 0.03707488f, 0.04147267f, 0.05326581f, 0.02712625f, 
    0.00481124f, 0.09515648f, -0.02056765f, 0.03239610f, 0.02775724f, -0.01568541f, -0.01160169f, -0.05282827f, 
    -0.03877500f, -0.20808463f, 0.17160821f, 0.13619845f, -0.06781203f, -0.06115721f, 0.00620735f, -0.11860649f, 
    -0.11900338f, -0.08997606f, 0.46298957f, 0.41643265f, 0.06389634f, 0.05543618f, 0.05416450f, -0.02682057f, 
    0.13285355f, 0.03573026f, 0.04903365f, -0.21664536f, -0.14688514f, 0.05544327f, -0.09328220f, 0.07812939f, 
    0.10676838f, -0.11766703f, -0.22654480f, 0.07129976f, -0.01830908f, 0.16679591f, 0.09330213f, -0.07277837f, 
    -0.12079714f, -0.08857181f, -0.06713235f, 0.12081777f, 0.06179895f, 0.00811407f, -0.01836096f, 0.05534903f, 
    0.05720767f, 0.04550110f, 0.00461300f, 0.07486611f, 0.06349725f, -0.06178836f, -0.21218799f, 0.01738289f, 
    -0.01904263f, 0.07469240f, -0.00513641f, 0.09084389f, -0.09499449f, -0.04356305f, 0.00001533f, 0.12492875f, 
    0.03648156f, 0.14119633f, 0.14333262f, -0.07673389f, 0.03942290f, 0.01612535f, -0.03661579f, -0.12745586f, 
    0.01757028f, 0.03188372f, -0.03940399f, 0.12990247f, 0.05769515f, -0.02557633f, 0.05784692f, -0.04142426f, 
    -0.05121151f, -0.09215055f, 0.02766962f, -0.19718374f, 0.02752392f, 0.08182005f, -0.11482534f, 0.02937169f, 
    -0.06672944f, 0.00184272f, 0.04459696f, 0.36279425f, -0.09334533f, 0.03296107f, -0.11083195f, 0.06085896f, 
    -0.01776977f, 0.10589956f, 0.02777882f, -0.06570235f, -0.16428104f, 0.05364621f, -0.04147507f, 0.01817081f, 
    -0.01657980f, -0.10008182f, -0.12043478f, -0.07564861f, -0.07125999f, 0.08155554f, 0.14224458f, 0.13556100f, 
    0.03952006f, 0.07191790f, 0.01717906f, 0.16410282f, -0.01367655f, -0.25529543f, -0.18263470f, 0.19880302f, 
    -0.02647182f, 0.11917421f, 0.01201508f, 0.04970068f, -0.07240128f, -0.09167845f, 0.20946582f, -0.00552075f, 
    0.04647286f, 0.07423282f, 0.05837996f, 0.01063553f, -0.02053909f, -0.04305842f, -0.22333674f, 0.06294761f, 
    0.00846924f, -0.10500303f, 0.00498018f, -0.01108741f, 0.04399427f, -0.03893259f, 0.03418470f, 0.00932449f, 
    0.13072696f, 0.09865344f, -0.03364829f, -0.17178810f, -0.04132272f, -0.03400161f, 0.06525810f, 0.13490449f, 
    0.11041600f, -0.33973625f, -0.12010954f, -0.14058547f, -0.02278403f, 0.00613059f, 0.06211841f, 0.06161463f, 
    0.02648331f, -0.06589705f, -0.22792874f, 0.09336424f, 0.24952695f, 0.07357062f, 0.07757460f, -0.12978928f, 
    -0.01149700f, 0.07092411f, 0.02225290f, 0.21453515f, -0.18016125f, -0.07179391f, 0.08045206f, -0.07606824f, 
    0.08796015f, -0.00669560f, -0.00775098f, -0.06407582f, -0.13676603f, -0.23502944f, 0.05575581f, -0.07163833f, 
    -0.21607304f, 0.01734874f, -0.11142706f, -0.01286430f, 0.17921954f, -0.23516141f, 0.20339434f, -0.07908032f, 
    -0.04918092f, -0.04498127f, -0.03431102f, 0.03350347f, 0.07273134f, 0.03644440f, -0.11771946f, 0.00575215f, 
    0.06892082f, -0.03133067f, -0.02706128f, -0.12248066f, -0.03162775f, 0.04633670f, -0.00083315f, 0.03348076f, 
    0.03804013f, -0.01995517f, -0.12722103f, -0.12346326f, -0.12035013f, -0.05161941f, -0.08937699f, 0.02248541f, 
    -0.30260652f, -0.34666434f, 0.03253018f, 0.06463534f, 0.05603756f, 0.00742819f, 0.00993208f, 0.07805865f, 
    -0.00866730f, 0.19892563f, -0.02308519f, -0.08774877f, -0.00284090f, 0.06177682f, -0.04032994f, 0.09488307f, 
    0.05799851f, -0.00376789f, 0.23150843f, 0.03299934f, 0.01912884f, -0.02274136f, 0.19027872f, -0.10757986f, 
    0.02066906f, -0.24140945f, 0.11111695f, -0.11456133f, -0.23165464f, 0.05474808f, -0.03144475f, 0.02809325f, 
    -0.04808939f, 0.02573665f, -0.02054067f, -0.05080216f, -0.10169864f, -0.02730309f, 0.04231821f, -0.01761838f, 
    0.00866353f, -0.05090626f, -0.03481100f, 0.04956533f, 0.00024965f, 0.02003844f, 0.14515550f, -0.08208041f, 
    0.07716559f, -0.07563178f, -0.04978598f, 0.13387346f, 0.20410068f, 0.18172909f, 0.12363667f, -0.18112721f, 
    0.01876200f, -0.01180481f, -0.00011256f, -0.16278157f, 0.02885817f, -0.09289052f, 0.06769212f, 0.10574616f, 
    0.10063152f, -0.15002343f, 0.08956368f, 0.00868638f, -0.05959181f, 0.05071674f, 0.12443365f, -0.04654054f, 
    -0.00026133f, 0.00209082f, -0.05636828f, -0.05276572f, -0.04927382f, 0.02652380f, 0.04540899f, -0.06188304f, 
    0.02581780f, -0.05106600f, 0.00388188f, -0.00345471f, 0.05346591f, -0.03241189f, 0.02512837f, 0.06599341f, 
    -0.01783385f, -0.04965395f, -0.07311518f, -0.04900633f, -0.00257693f, -0.02849543f, 0.01715410f, 0.04913684f, 
    0.01480561f, 0.03003424f, -0.06391168f, 0.02902519f, -0.00286684f, 0.04441581f, -0.00347863f, -0.02632777f, 
    -0.05239445f, 0.00236246f, -0.06570157f, 0.02749684f, 0.02635307f, 0.05674856f, -0.02655359f, -0.00374012f, 
    0.02279950f, -0.05599064f, -0.03290940f, -0.06612246f, 0.03275799f, 0.05950746f, 0.01774898f, 0.05264976f, 
    -0.07271957f, -0.06888448f, -0.01009299f, 0.01833770f, 0.05802954f, -0.07377160f, 0.02728038f, 0.03824402f, 
    0.04567768f, -0.04299911f, 0.02536832f, -0.05439791f, -0.01746349f, -0.01491058f, -0.06958869f, 0.03144190f, 
    -0.06679239f, 0.00355338f, -0.03871481f, 0.05156327f, 0.03797283f, 0.05336525f, -0.07393105f, -0.02568602f, 
    0.04574588f, 0.00958233f, 0.04552030f, -0.04577208f, 0.02310463f, -0.02184739f, 0.00478555f, -0.01609724f, 
    -0.00521663f, -0.06022961f, 0.00505776f, -0.01694545f, 0.02132954f, 0.01362092f, -0.05474238f, -0.01024215f, 
    0.04001844f, 0.02585815f, -0.03729562f, -0.08213986f, 0.02618030f, -0.03198725f, 0.00023766f, 0.03072029f, 
    0.06719396f, -0.01023130f, -0.03559838f, -0.03825199f, -0.02891911f, -0.05405986f, -0.04904280f, -0.02547920f, 
    -0.01570579f, 0.03862022f, 0.02758287f, 0.00183599f, -0.03431316f, 0.04720050f, -0.05547445f, -0.02652196f, 
    -0.02493265f, -0.03283091f, -0.03505234f, -0.04400519f, -0.06661607f, 0.01712997f, 0.05164661f, -0.04740685f, 
    0.03752321f, 0.02458100f, 0.02158996f, -0.03913687f, 0.02559742f, 0.03771444f, 0.04148092f, -0.01400224f, 
    -0.01316301f, -0.00868269f, 0.00339773f, -0.02664089f, 0.03100207f, 0.02839656f, 0.02526805f, -0.05376245f, 
    -0.00680539f, -0.04103172f, 0.04393567f, -0.06625278f, -0.01946297f, -0.03249126f, -0.04426262f, -0.06154814f, 
    -0.01470715f, 0.00055797f, 0.01000541f, -0.03228823f, -0.00020514f, -0.07471386f, 0.02531999f, -0.02594344f, 
    -0.05145752f, -0.01684438f, -0.07260595f, 0.02069641f, -0.02940050f, -0.01660819f, -0.04577947f, 0.01081411f, 
    -0.02309701f, 0.02463150f, 0.05014019f, 0.08120573f, 0.01449845f, 0.00223054f, -0.01267708f, -0.01090929f, 
    0.04576501f, -0.00875410f, 0.00463657f, -0.03758452f, 0.03533487f, -0.03977423f, 0.05835230f, -0.04525796f, 
    0.00444508f, 0.00235354f, -0.02739952f, 0.06331860f, -0.02691278f, 0.04874392f, 0.04744194f, -0.01503957f, 
    -0.00022800f, -0.04020558f, -0.04132240f, 0.01790001f, -0.06086690f, -0.00901873f, -0.06068011f, -0.00019233f, 
    0.03077005f, -0.03562445f, -0.01069545f, -0.02344806f, 0.01732758f, 0.02146108f, -0.06758921f, -0.02429036f, 
    0.00793978f, -0.04574109f, -0.02775108f, 0.02331076f, -0.01751445f, 0.01372953f, -0.02303264f, 0.02414508f, 
    0.03435684f, -0.01962793f, 0.00507405f, 0.01918291f, 0.02211685f, -0.03645087f, 0.00875425f, -0.04217482f, 
    -0.01570773f, -0.02552595f, -0.00334417f, -0.00141888f, 0.01275946f, -0.00187658f, -0.03356768f, 0.02312258f, 
    0.01740971f, -0.01140506f, -0.06362005f, -0.00809229f, -0.04609265f, -0.04095002f, 0.01355740f, 0.03651258f, 
    -0.06571056f, 0.03219638f, 0.03950887f, 0.05095160f, 0.00176355f, -0.05894125f, 0.00699747f, -0.02095134f, 
    0.00495903f, -0.03014576f, 0.01226221f, -0.03542633f, 0.00985862f, -0.03666226f, 0.01135643f, 0.02823870f, 
    0.04158184f, -0.05039226f, 0.04467157f, 0.00115867f, -0.02246952f, 0.05480043f, 0.00596745f, -0.07039125f, 
    -0.01310434f, -0.00676053f, -0.05198272f, -0.02806622f, 0.00817051f, 0.02509810f, -0.05381963f, -0.06987842f, 
    0.04120401f, -0.05504444f, -0.01215718f, 0.03436828f, 0.02283395f, -0.03316895f, 0.02283244f, 0.02066833f, 
    0.04000463f, -0.01737329f, 0.00772421f, -0.05104516f, 0.00462705f, -0.02037463f, -0.05277468f, -0.03631668f, 
    -0.01257238f, 0.02893678f, -0.00567472f, -0.02758252f, -0.01587598f, -0.00381019f, -0.01962983f, 0.04053366f, 
    -0.10980041f, 0.04394967f, -0.15142153f, -0.01229298f, -0.03009663f, -0.13706537f, 0.02860268f, -0.04173148f, 
    -0.01605766f, 0.01306137f, -0.28384617f, 0.18023679f, 0.09079751f, -0.02303957f, 0.08349487f, 0.09761278f, 
    -0.11697729f, -0.05412238f, 0.27743876f, 0.27148399f, 0.02949580f, -0.01236087f, -0.07253591f, -0.05545658f, 
    0.08253807f, 0.08969882f, 0.13862330f, -0.05608362f, -0.05279087f, 0.01972472f, 0.09249761f, 0.00050374f, 
    -0.09702118f, 0.04070577f, -0.01656665f, 0.10149492f, -0.25918210f, -0.19693010f, 0.10891032f, -0.02685746f, 
    -0.02045410f, 0.10291807f, 0.06994224f, -0.05865627f, 0.05351131f, -0.13978353f, -0.15989041f, -0.13939933f, 
    -0.01372584f, 0.07902650f, -0.08941918f, -0.04555174f, -0.14056353f, 0.02427374f, -0.31970024f, -0.31900609f, 
    -0.13317162f, 0.13550846f, -0.03103691f, 0.01017134f, -0.05156561f, -0.16975373f, 0.02765610f, 0.02946170f, 
    0.17320627f, 0.16638029f, 0.03522289f, 0.01108367f, 0.12053058f, -0.05258799f, -0.05045795f, 0.03064404f, 
    0.17669922f, 0.13171783f, 0.04320028f, 0.03934521f, 0.00504502f, -0.05161813f, 0.05567224f, 0.14679891f, 
    0.05579036f, 0.10915086f, 0.05397373f, -0.07084654f, -0.07627497f, 0.03799619f, -0.15401417f, 0.09541899f, 
    0.12816229f, 0.15427265f, 0.10150226f, 0.02966308f, -0.02229495f, 0.00769401f, 0.03887750f, 0.08335336f, 
    -0.07881982f, -0.03984185f, -0.16759023f, 0.10045886f, 0.05847918f, 0.01310461f, 0.03746206f, 0.11646151f, 
    0.10403083f, -0.05439680f, -0.08688948f, -0.04933444f, 0.01512125f, 0.01789739f, -0.07666407f, -0.04570433f, 
    -0.01978873f, 0.00620337f, -0.10850810f, -0.06172532f, 0.02246264f, 0.11735174f, 0.14717852f, -0.00884346f, 
    0.16469353f, 0.00769299f, 0.09321813f, -0.08990476f, -0.06707677f, -0.12958978f, 0.14475502f, -0.00218785f, 
    -0.04321137f, -0.03218909f, 0.07540181f, -0.01217791f, -0.07247466f, -0.09714448f, -0.17230290f, -0.15563835f, 
    0.13467583f, -0.02746526f, -0.02330317f, -0.00858620f, -0.09477667f, 0.05010024f, -0.03101381f, -0.00426033f, 
    -0.10476312f, -0.08564349f, -0.00999772f, 0.13224170f, 0.01958689f, 0.02465144f, -0.15965013f, 0.06003219f, 
    -0.00065938f, -0.16076574f, 0.09531173f, 0.11841705f, -0.03419030f, -0.12355886f, -0.08927716f, 0.06249850f, 
    -0.05510727f, 0.07251620f, -0.33424711f, 0.03048137f, -0.04157429f, 0.07377094f, -0.16926420f, -0.09348428f, 
    -0.14545400f, 0.07604787f, 0.05752979f, 0.09861303f, -0.14174812f, -0.15276837f, -0.02021570f, 0.03318357f, 
    -0.02821157f, -0.03011965f, -0.03220086f, 0.08671777f, 0.01038465f, -0.17268638f, 0.06666802f, -0.00479420f, 
    -0.05090232f, 0.21585269f, -0.02123324f, -0.10740004f, 0.11678486f, 0.01657063f, 0.08748641f, -0.04293593f, 
    0.15296353f, 0.02128685f, 0.06275863f, -0.12316702f, 0.07028336f, -0.08090878f, -0.01869385f, 0.20374265f, 
    0.13433821f, 0.07483780f, 0.08047230f, 0.07542875f, 0.02309159f, 0.06471252f, 0.02446978f, -0.18896647f, 
    -0.21303068f, -0.03485323f, 0.05729850f, -0.03444207f, -0.00565192f, 0.03687044f, 0.04729633f, 0.08014787f, 
    0.08027615f, 0.08401602f, -0.09987562f, -0.20837216f, -0.08613390f, 0.13560037f, 0.09516288f, -0.05151423f, 
    -0.09895653f, 0.10448369f, 0.14211766f, 0.06223896f, -0.00991243f, 0.07450425f, -0.06338569f, 0.02800268f, 
    0.04322343f, 0.07054786f, -0.10904641f, -0.15421464f, -0.01243267f, -0.04707323f, 0.06938082f, 0.00923255f, 
    -0.10119606f, -0.00603048f, 0.17051762f, 0.13441925f, -0.02410239f, -0.06337684f, 0.08848888f, 0.03001614f, 
    0.17232756f, 0.02897376f, -0.00225787f, -0.18878448f, -0.13664645f, -0.09319685f, -0.07631474f, -0.09191935f, 
    0.01995463f, -0.00951142f, 0.11039619f, -0.03602925f, -0.06300162f, -0.19726098f, -0.13002448f, 0.04120476f, 
    -0.11235123f, -0.03312631f, -0.10715021f, 0.17472424f, -0.09601571f, 0.05687620f, 0.08016916f, 0.00499748f, 
    -0.11549474f, 0.08747520f, 0.04016615f, -0.00811488f, 0.01333172f, 0.02576332f, -0.07409890f, 0.07738822f, 
    0.17681253f, -0.13274831f, 0.08019476f, -0.07489236f, 0.09501006f, -0.04412615f, 0.13988064f, 0.06765786f, 
    -0.06647366f, 0.09436617f, 0.01333891f, 0.01341108f, -0.03710357f, -0.14326009f, -0.06215821f, 0.12178650f, 
    0.12133105f, 0.19270234f, -0.00956298f, -0.18994145f, 0.18043755f, -0.07028408f, -0.05956860f, -0.06901285f, 
    -0.09606285f, -0.12548749f, 0.21472612f, 0.08855981f, 0.00583796f, 0.06972560f, 0.05609503f, -0.15029655f, 
    0.04337139f, -0.00108899f, -0.09175134f, 0.06029437f, 0.03465208f, -0.21486640f, -0.04091036f, -0.05251671f, 
    -0.14756265f, 0.03055753f, -0.15804426f, 0.11752065f, 0.31240317f, -0.03900372f, -0.00092933f, -0.04332540f, 
    -0.11276603f, 0.02070719f, -0.18338019f, 0.08540440f, 0.05248070f, -0.08975576f, 0.02427748f, 0.03059936f, 
    -0.04242368f, 0.10394105f, -0.14166977f, -0.06393024f, 0.07450420f, -0.01147774f, 0.08009435f, 0.03964973f, 
    -0.09610310f, 0.02239056f, -0.17386068f, -0.14401929f, -0.18018678f, 0.11742406f, 0.12091517f, 0.08402807f, 
    0.14299676f, 0.00632775f, 0.09855258f, 0.17149059f, 0.12683710f, 0.18791518f, -0.10838211f, -0.08170626f, 
    0.00983370f, 0.32410505f, 0.01817647f, -0.10403076f, 0.00163900f, 0.08505529f, 0.18040913f, 0.07665539f, 
    0.00243540f, -0.03950358f, 0.08928616f, 0.02964628f, 0.02027514f, -0.02520225f, -0.06999080f, 0.05178067f, 
    0.00842886f, 0.03252672f, 0.07145859f, -0.01641985f, 0.03209974f, 0.15716632f, -0.01273309f, -0.09494551f, 
    0.01941091f, -0.13334064f, -0.11781501f, 0.05788150f, 0.05603036f, 0.06847972f, 0.18967521f, 0.09112236f, 
    0.20338573f, -0.01895635f, 0.08521618f, -0.00454286f, -0.00104186f, -0.11122464f, -0.01279340f, 0.07644973f, 
    -0.18636186f, 0.00217411f, -0.01580599f, 0.00881838f, -0.01129770f, -0.04392603f, -0.01742372f, -0.02740340f, 
    0.15136530f, 0.02638488f, 0.12911852f, 0.00576268f, -0.05975118f, -0.01708391f, -0.08648408f, -0.03299977f, 
    -0.15618926f, 0.00682288f, 0.23687801f, 0.01203338f, 0.08513948f, -0.12188650f, -0.03756691f, -0.11727794f, 
    0.14608933f, 0.01154806f, -0.11354403f, 0.04940823f, -0.02318021f, 0.08993436f, 0.01076805f, 0.12755080f, 
    -0.02113772f, -0.08314809f, -0.02980872f, 0.04910346f, -0.14366819f, -0.19943599f, 0.01275856f, -0.00480424f, 
    0.02106576f, -0.01802298f, -0.00273009f, -0.16343601f, -0.04915357f, -0.06838566f, 0.03376435f, 0.03633395f, 
    0.09099190f, 0.18179438f, -0.04348229f, 0.05449155f, -0.00957400f, -0.02797637f, -0.01955101f, 0.07254446f, 
    -0.03781395f, 0.07237059f, 0.03424491f, -0.13209705f, -0.07934454f, 0.02384954f, 0.08286994f, 0.03935018f, 
    -0.11306348f, 0.07777260f, 0.04318355f, 0.04918015f, 0.10057216f, 0.15558690f, -0.01882886f, 0.15547438f, 
    -0.07219782f, 0.06300686f, 0.02366738f, 0.18857527f, 0.03642680f, 0.05566822f, -0.09297860f, -0.01129418f, 
    0.01289515f, 0.04387489f, 0.01808188f, -0.00834774f, 0.06657461f, 0.12577946f, -0.07081620f, -0.06924233f, 
    0.10685747f, -0.05242598f, 0.11432572f, 0.25989658f, 0.01541454f, -0.00183174f, -0.06322467f, 0.14344822f, 
    0.03448845f, -0.09360687f, 0.03380283f, -0.12259085f, -0.05835572f, 0.04223070f, 0.05338473f, 0.09848284f, 
    -0.05527563f, -0.21005037f, 0.04445356f, 0.31932813f, -0.00905585f, 0.04995751f, -0.08315665f, -0.05533136f, 
    0.03712354f, 0.01913168f, -0.04835390f, 0.19911093f, 0.07203834f, 0.05742205f, 0.16903418f, 0.02468625f, 
    0.04006328f, 0.03074160f, 0.03169076f, -0.01902553f, -0.10204789f, 0.18207584f, -0.03682141f, -0.05648175f, 
    -0.02221406f, -0.10876451f, 0.23888513f, 0.08552437f, -0.14737524f, -0.11392606f, 0.08091835f, 0.10463298f, 
    0.29226425f, -0.09481222f, -0.08635283f, -0.07449712f, 0.07721147f, 0.05167525f, -0.08307013f, 0.09878288f, 
    -0.00685596f, -0.02454976f, 0.02032744f, -0.04640727f, 0.10135172f, 0.18794399f, -0.02151236f, -0.12596743f, 
    0.00199529f, -0.11844750f, -0.12294537f, -0.21662991f, 0.09155859f, 0.18972838f, 0.05597925f, -0.13755850f, 
    0.06202613f, 0.13673019f, -0.10967711f, 0.08893812f, -0.00874666f, 0.01454297f, -0.00194523f, 0.28023347f, 
    0.10307691f, 0.11861085f, 0.09087952f, 0.03705790f, 0.04441703f, 0.15604228f, -0.02294965f, 0.13297310f, 
    0.00586062f, -0.05389823f, -0.05728773f, -0.00612966f, -0.08247498f, -0.00707210f, -0.07119530f, 0.01346696f, 
    0.02866622f, -0.05314080f, -0.07340836f, -0.01179396f, -0.04533754f, -0.05634262f, -0.00448169f, -0.06637708f, 
    -0.05954405f, 0.02784373f, 0.02407755f, 0.02722418f, -0.07315782f, 0.02880967f, -0.02728236f, -0.02408986f, 
    -0.05319704f, -0.04232902f, -0.05220812f, -0.04524444f, -0.06852510f, 0.02961606f, -0.05827852f, -0.03648316f, 
    -0.02146597f, -0.05592319f, 0.00548986f, 0.00610746f, -0.00706293f, -0.03122781f, -0.07810752f, -0.01591497f, 
    -0.00276894f, 0.01877559f, -0.05689277f, -0.07395995f, 0.01618120f, -0.02333291f, -0.06722420f, -0.02851730f, 
    -0.03717085f, -0.00419864f, -0.07599051f, 0.01055238f, -0.03865961f, -0.06537600f, 0.02050597f, -0.07704932f, 
    -0.04138840f, -0.05726585f, -0.07158139f, -0.07108880f, 0.02369778f, -0.04701150f, -0.07623374f, -0.04340705f, 
    -0.06300389f, -0.06910069f, -0.08012066f, -0.02829813f, -0.03302116f, -0.03448970f, -0.06551168f, -0.01416253f, 
    -0.04484261f, -0.01208835f, -0.06155412f, -0.08155661f, -0.03213523f, -0.01793961f, -0.01808570f, 0.01895630f, 
    -0.01685991f, -0.05788645f, -0.03342964f, 0.02873814f, -0.04462306f, -0.07696156f, 0.00901625f, -0.02867246f, 
    -0.02626569f, 0.01214489f, -0.03818772f, -0.05617290f, -0.00136763f, -0.05668338f, -0.02549251f, -0.04720275f, 
    -0.01804521f, -0.06288245f, -0.02364818f, -0.04675816f, 0.01784412f, -0.07346878f, -0.08302945f, -0.03328021f, 
    -0.03768279f, -0.06198458f, -0.00356731f, -0.07027184f, -0.01641745f, -0.07155293f, -0.02932084f, -0.01319593f, 
    -0.04351379f, -0.04583253f, -0.02930474f, -0.05316344f, -0.07743877f, -0.04777718f, 0.00717846f, -0.07590554f, 
    -0.05226569f, -0.07214077f, -0.04577667f, -0.02085287f, -0.03069023f, -0.02897161f, -0.04910154f, -0.05325381f, 
    -0.02357550f, 0.00301729f, 0.03374936f, 0.02677547f, -0.07345953f, -0.01029861f, 0.02729463f, -0.03222004f, 
    0.02716361f, -0.01230273f, -0.06744364f, 0.01023942f, -0.02659253f, -0.04334314f, 0.02816991f, -0.05597591f, 
    0.04580454f, -0.01162946f, -0.06001909f, -0.07216334f, -0.05168582f, 0.01983846f, 0.00518144f, -0.01003864f, 
    -0.02652383f, -0.06302891f, -0.08014122f, 0.01606270f, 0.02278909f, 0.00863205f, -0.05432521f, -0.06329250f, 
    0.01875754f, -0.07464287f, -0.00729686f, -0.00347533f, 0.00358685f, 0.05597853f, -0.04031720f, -0.05124289f, 
    -0.03908706f, 0.01896827f, -0.04194617f, -0.02075553f, 0.02168377f, 0.04176814f, -0.04357484f, 0.00925535f, 
    0.04625888f, -0.04406690f, -0.04420962f, 0.01166379f, -0.01048325f, -0.07267449f, -0.05894405f, 0.00954875f, 
    -0.04095262f, -0.05353519f, 0.05849704f, -0.04619792f, -0.06965995f, 0.00349502f, -0.04577036f, -0.00252485f, 
    0.00507676f, -0.05034631f, 0.00721399f, 0.03036164f, -0.04564195f, -0.01358287f, 0.01324880f, -0.05830772f, 
    0.01026001f, -0.03790125f, -0.02584341f, -0.03516185f, -0.05743460f, 0.03604119f, -0.01577973f, -0.03744342f, 
    -0.06489938f, -0.05764685f, 0.01173141f, -0.00292712f, -0.06064164f, -0.05474174f, 0.03172172f, -0.05415876f, 
    0.02617754f, 0.02007414f, -0.01917630f, -0.03122873f, -0.03237895f, 0.04839428f, 0.05018828f, -0.05075585f, 
    -0.05151853f, 0.02743893f, 0.00125154f, -0.01808530f, -0.01050722f, 0.02505975f, 0.03361999f, -0.07809885f, 
    -0.03096551f, -0.05370262f, 0.00547933f, -0.01530890f, -0.04744494f, -0.03278115f, -0.06190194f, 0.01248231f, 
    -0.02728800f, -0.05544856f, 0.01809950f, 0.03019927f, 0.00718754f, -0.02888362f, -0.03191308f, -0.01750059f, 
    0.01453796f, -0.03467224f, -0.02930383f, -0.03521715f, -0.02717954f, 0.03266419f, 0.02007144f, -0.03929233f, 
    -0.06312000f, -0.03253834f, -0.08418635f, 0.01621425f, -0.05288866f, -0.02262368f, -0.03776394f, 0.00606600f, 
    0.00433908f, -0.01800668f, -0.02362120f, -0.04158691f, -0.00039627f, 0.01401113f, -0.01986446f, 0.00485975f, 
    -0.07954627f, -0.06812065f, -0.08355983f, -0.03312745f, -0.02437326f, -0.00297227f, -0.03519731f, -0.07717896f, 
    0.02691542f, -0.05516899f, -0.04955502f, -0.07093627f, -0.01037163f, -0.02165849f, 0.02639530f, -0.04735588f, 
    -0.24658862f, -0.15329655f, -0.12294821f, 0.12165365f, -0.04354144f, 0.10965204f, 0.03629548f, 0.09877513f, 
    -0.15252526f, 0.38192973f, 0.21121542f, -0.02191635f, 0.09069122f, 0.00400756f, -0.02600650f, 0.05741557f, 
    0.15526789f, -0.02187740f, -0.22781400f, -0.16809669f, 0.14260519f, 0.19134995f, 0.03545365f, 0.12135585f, 
    -0.10129292f, 0.00722032f, 0.13096006f, 0.08363306f, -0.01663150f, -0.10469180f, 0.07910310f, 0.09212694f, 
    -0.00633301f, 0.08275060f, -0.05787908f, -0.14573325f, 0.08614584f, -0.09137517f, 0.01608666f, 0.02657015f, 
    0.13514365f, 0.01111415f, 0.05574053f, 0.04792692f, 0.04017219f, 0.03524541f, -0.09687425f, -0.21772552f, 
    0.07885310f, 0.01878753f, 0.04432791f, 0.11577067f, 0.03878932f, -0.01311070f, 0.07335383f, -0.12610176f, 
    -0.04322163f, 0.04089801f, 0.10177918f, 0.00534703f, 0.06060545f, 0.01115418f, -0.04646077f, -0.23781902f, 
    0.02948165f, 0.07966974f, 0.04317743f, -0.17793818f, 0.03428699f, -0.13118733f, 0.11676644f, 0.09877291f, 
    -0.13316481f, -0.10531931f, 0.12307182f, 0.11582287f, 0.16101013f, 0.10755392f, -0.00354897f, 0.11181850f, 
    0.04218414f, -0.13911182f, -0.00257088f, -0.10374445f, 0.15531063f, 0.03765449f, 0.14065178f, 0.01882683f, 
    -0.03135559f, -0.05631874f, -0.20023659f, 0.08053352f, -0.01879237f, 0.01055067f, 0.03650115f, -0.01461133f, 
    -0.15993679f, -0.07650658f, -0.01805916f, 0.21643822f, 0.19301482f, 0.16473034f, -0.01446916f, 0.02026053f, 
    -0.03752423f, 0.08541812f, -0.05929070f, 0.11043005f, 0.11953557f, -0.06363342f, -0.17937444f, 0.18284129f, 
    -0.02190949f, -0.00046178f, 0.06825808f, -0.00273836f, 0.08575583f, -0.02298080f, 0.12961912f, 0.01168353f, 
    0.03662460f, -0.05764749f, 0.06740540f, -0.01696420f, -0.05767659f, 0.13733269f, -0.09929396f, 0.21044324f, 
    0.19246082f, -0.04153744f, 0.00038818f, -0.00182198f, -0.03207669f, -0.08060294f, 0.06600295f, 0.00124554f, 
    -0.04111538f, -0.20285361f, 0.00260602f, 0.06694761f, 0.05100354f, 0.00075609f, -0.01448264f, -0.00399138f, 
    0.06977720f, 0.08177841f, -0.08391739f, 0.16642407f, 0.07788926f, 0.06973724f, 0.15822966f, 0.02344403f, 
    0.10630622f, -0.21883319f, 0.08112182f, -0.03407914f, 0.08265322f, 0.02776826f, 0.14145143f, 0.14849451f, 
    -0.06126152f, -0.25160518f, 0.10736485f, -0.28727105f, -0.04064975f, -0.08574253f, 0.17814794f, -0.13577670f, 
    -0.11668485f, -0.06566273f, -0.06752878f, -0.01686994f, -0.12061463f, -0.10968165f, -0.04928280f, -0.01644631f, 
    -0.04376392f, -0.03072344f, 0.02611405f, 0.10497778f, 0.06668022f, 0.12640412f, -0.09376270f, -0.05586607f, 
    0.08987985f, -0.05302272f, 0.06726082f, 0.02693452f, 0.13093901f, -0.01419405f, 0.03560944f, 0.03149081f, 
    0.00434006f, -0.03038266f, 0.02849524f, -0.08583266f, 0.11500772f, 0.04995404f, -0.03257935f, -0.14344043f, 
    0.04088583f, 0.15426905f, -0.04502281f, 0.11238081f, 0.01584457f, 0.05455174f, -0.12872669f, 0.17328760f, 
    -0.04032601f, -0.03613750f, 0.09863844f, 0.02901719f, 0.07653029f, 0.11609273f, 0.02388544f, 0.04084185f, 
    -0.12689430f, 0.18400981f, -0.12386871f, 0.11465108f, -0.00042374f, -0.00187536f, 0.18316257f, -0.07748754f, 
    0.02716453f, -0.10627794f, -0.12325832f, -0.08442218f, -0.05507251f, 0.16729677f, 0.15149444f, -0.00954721f, 
    -0.08177710f, -0.14519383f, -0.13062288f, 0.10480041f, 0.16179548f, 0.08667459f, 0.24207807f, -0.12897985f, 
    0.04662099f, -0.03963105f, -0.02676583f, 0.13496436f, 0.08680650f, 0.06189731f, -0.05356420f, -0.13448827f, 
    -0.01667028f, -0.01581651f, 0.10489052f, 0.02858246f, 0.24095593f, 0.07150218f, 0.05997167f, 0.13931888f, 
    0.05921467f, -0.07314613f, 0.13367997f, 0.08314381f, 0.02432240f, 0.00881481f, -0.21737060f, -0.09098958f, 
    0.02807481f, 0.16165970f, 0.06317124f, 0.04121241f, 0.13040067f, -0.02313490f, 0.00994533f, -0.08385194f, 
    -0.17959154f, -0.15289402f, 0.01443655f, 0.01985785f, 0.05189522f, -0.11520986f, -0.00375149f, -0.00389196f, 
    0.11463895f, 0.14011219f, 0.13173552f, 0.02936292f, -0.02023777f, 0.00142977f, 0.03773640f, 0.03587392f, 
    -0.06721922f, -0.11189307f, -0.06557674f, 0.06777070f, 0.03247515f, 0.14940163f, 0.00088324f, 0.05664706f, 
    0.00332067f, -0.34955546f, 0.08764324f, -0.11827622f, 0.04632396f, -0.02084141f, -0.12477113f, 0.00542806f, 
    0.17399198f, -0.00502541f, 0.16456801f, 0.08457745f, -0.15484501f, 0.07938986f, 0.14665872f, 0.10907211f, 
    0.05071351f, -0.01157666f, -0.12822899f, -0.25614259f, -0.10071205f, 0.07066962f, 0.03770931f, -0.11561405f, 
    -0.19244677f, -0.00591887f, 0.03224948f, -0.10150734f, -0.22928986f, 0.06723216f, -0.06880189f, 0.12358660f, 
    0.02008275f, 0.03300643f, 0.02220492f, 0.14814822f, 0.05261266f, -0.04985378f, 0.02207111f, 0.19333149f, 
    0.07610919f, 0.01035997f, 0.00730802f, -0.06511623f, -0.09575247f, -0.06867397f, -0.17790054f, -0.22184713f, 
    -0.19007798f, 0.06597073f, -0.01825566f, -0.03784252f, -0.09425323f, 0.04752596f, 0.08232482f, 0.08044068f, 
    0.14343168f, -0.06447843f, -0.08777269f, 0.04466242f, 0.03149930f, -0.01051423f, 0.00307505f, 0.09090403f, 
    0.15121759f, -0.10261778f, -0.03765337f, 0.02906522f, 0.06864158f, -0.03961825f, -0.06818136f, 0.01643020f, 
    -0.06634077f, 0.02822403f, 0.00709702f, 0.04938342f, -0.04908691f, -0.01931656f, -0.02152663f, 0.00738362f, 
    0.00064795f, -0.15496643f, 0.05644781f, -0.03838430f, -0.11759324f, 0.02692639f, 0.00193071f, 0.07621618f, 
    0.06157473f, -0.07381427f, -0.08076222f, -0.21572393f, 0.10828997f, 0.21685714f, 0.09518747f, 0.08001563f, 
    0.08167476f, 0.01258849f, 0.09741668f, 0.04730787f, -0.06107311f, 0.11097563f, -0.16194154f, 0.07362821f, 
    -0.03259607f, 0.16257073f, -0.00142441f, 0.09400310f, -0.01828061f, -0.00519840f, -0.01101966f, 0.11571217f, 
    0.08557902f, -0.03766880f, 0.06455082f, 0.04985577f, -0.10776533f, 0.15090927f, 0.08733933f, 0.19432774f, 
    -0.12878555f, 0.03828039f, -0.07787807f, -0.01302124f, 0.11270114f, 0.06675439f, 0.05110000f, 0.08333404f, 
    0.07971599f, 0.09160107f, 0.07460419f, -0.00837807f, 0.07729944f, 0.11097734f, 0.06552798f, -0.00781085f, 
    0.05297963f, -0.23369245f, 0.14300002f, 0.02286485f, 0.10757751f, 0.03752872f, 0.03088702f, -0.11884210f, 
    0.03956306f, 0.02002935f, -0.04135925f, -0.05861992f, 0.09228491f, 0.05415611f, -0.08162941f, 0.04874809f, 
    0.05302771f, 0.07833337f, -0.07476610f, -0.19759645f, 0.18052126f, -0.07680205f, -0.07938367f, 0.07995180f, 
    -0.08676438f, -0.18160485f, 0.08032289f, -0.00068296f, -0.00225693f, -0.18709368f, -0.04836028f, -0.12163393f, 
    0.10092191f, 0.01928367f, 0.04379086f, -0.06170382f, -0.01530948f, -0.04601371f, 0.10919225f, -0.00832798f, 
    0.04849987f, -0.11649297f, 0.02775333f, -0.00192478f, 0.13538627f, 0.08717384f, 0.10168274f, 0.02549288f, 
    0.05229720f, 0.00710451f, 0.10964373f, 0.01290473f, 0.13538693f, 0.10644647f, 0.09918232f, 0.09002707f, 
    0.04890274f, -0.09232039f, -0.08735611f, 0.15298207f, -0.07140814f, 0.03196853f, 0.16454804f, -0.10915431f, 
    -0.22364396f, 0.03284349f, -0.04234525f, 0.02330738f, 0.01475061f, -0.05576824f, 0.08895592f, -0.00109414f, 
    0.10286512f, -0.11815232f, -0.10310925f, -0.00499186f, 0.07219197f, -0.04436557f, -0.07602497f, -0.00831605f, 
    0.05580021f, 0.03583336f, 0.00379321f, -0.02966691f, 0.03842818f, -0.05089313f, -0.05802919f, 0.02805508f, 
    0.10031731f, 0.11861432f, -0.09694976f, 0.10895862f, -0.12266061f, 0.12466412f, 0.04482786f, -0.09383803f, 
    -0.01571902f, -0.00526889f, -0.14816357f, 0.09848553f, 0.14458425f, 0.01180292f, -0.11486196f, -0.06873846f, 
    -0.08474348f, -0.01479722f, -0.00799830f, -0.04123044f, -0.34401509f, -0.06001034f, -0.09823667f, 0.01834352f, 
    0.00521081f, 0.01503705f, 0.08450233f, 0.00161462f, 0.02831685f, -0.09931508f, 0.10464045f, -0.12128680f, 
    0.01832681f, 0.02830181f, -0.07728478f, 0.15825292f, 0.06152170f, 0.00258986f, -0.16501954f, -0.06401533f, 
    -0.21096922f, 0.08345722f, 0.03951070f, -0.12850961f, -0.08367370f, -0.00895732f, -0.03619951f, -0.00906325f, 
    -0.05966347f, -0.06143762f, 0.02576411f, -0.03934619f, -0.09996220f, -0.01102594f, 0.17006242f, -0.01066093f, 
    0.05186572f, 0.07996029f, 0.00441058f, -0.05690309f, -0.08800414f, -0.00341918f, 0.10149359f, 0.01419545f, 
    -0.04688065f, 0.06077567f, 0.12191165f, 0.10174176f, 0.05168165f, -0.08888770f, 0.05053907f, 0.02088976f, 
    -0.07235337f, 0.12239968f, -0.05965126f, 0.03592965f, -0.46644413f, -0.12143505f, 0.00735335f, -0.00242682f, 
    -0.00732140f, 0.15825374f, -0.17029527f, 0.31833574f, 0.19880129f, 0.04966731f, 0.00358437f, -0.02333091f, 
    0.00802397f, 0.00603877f, -0.05850682f, 0.27730829f, -0.01375015f, -0.02723455f, 0.29291230f, 0.15278922f, 
    0.17331217f, -0.13083814f, 0.04818303f, 0.03354893f, 0.04808434f, -0.13140896f, 0.14389090f, 0.14762355f, 
    -0.00190716f, 0.14353010f, 0.03839900f, -0.12629458f, -0.05043594f, -0.10996404f, 0.05402496f, 0.18679972f, 
    0.17623158f, 0.12005125f, 0.03263918f, -0.03460810f, 0.18022533f, -0.03122688f, 0.12106729f, 0.04472819f, 
    -0.09319869f, -0.06825987f, 0.03991954f, 0.11086801f, 0.04479327f, 0.03803620f, -0.07081444f, -0.15913682f, 
    -0.35815838f, -0.06580766f, 0.03915012f, -0.07963412f, -0.06263650f, -0.02113227f, 0.05637973f, 0.04034389f, 
    0.04485967f, -0.06441850f, -0.00054148f, -0.02141212f, 0.02206250f, 0.02199791f, -0.06626011f, 0.00554399f, 
    -0.05038935f, 0.03585862f, -0.44196704f, -0.15545131f, -0.25823951f, 0.09725570f, 0.09167257f, 0.06537627f, 
    0.01981392f, -0.08302858f, 0.07481679f, -0.03478873f, -0.03961635f, 0.05848798f, -0.04053525f, -0.10466219f, 
    -0.02931622f, 0.05835028f, -0.15612724f, 0.07620811f, -0.03156591f, -0.04844730f, 0.09050746f, 0.15722947f, 
    0.02725009f, -0.17316248f, 0.01241451f, 0.03749099f, -0.00815852f, -0.15387942f, 0.07580057f, -0.04519527f, 
    0.13728882f, 0.03650894f, -0.05544133f, 0.03390870f, -0.05812816f, -0.04543148f, -0.36343810f, -0.10666560f, 
    0.00623664f, -0.04904567f, 0.01218152f, -0.00550352f, -0.01512704f, -0.03342194f, -0.08018317f, -0.11823642f, 
    -0.12970285f, 0.14406601f, 0.03208289f, 0.02824248f, -0.03193508f, -0.01406860f, 0.04958238f, 0.03534079f, 
    0.15161106f, 0.22697793f, -0.00085723f, 0.08260949f, 0.05513094f, 0.06263085f, 0.00208707f, 0.14535496f, 
    -0.04832089f, 0.13650346f, 0.11115408f, -0.04393079f, -0.10183983f, -0.05435619f, 0.08691832f, 0.07523370f, 
    -0.06486193f, 0.01032117f, -0.19101360f, -0.26547039f, 0.10898382f, 0.15605575f, -0.02828263f, -0.24786152f, 
    0.10913096f, -0.05856326f, -0.02822817f, 0.07476688f, -0.20514812f, 0.07787891f, -0.04801684f, 0.10564419f, 
    -0.02814244f, 0.14864527f, 0.13229208f, -0.05776839f, 0.18913977f, 0.29395786f, -0.01027009f, 0.13875215f, 
    -0.08441972f, 0.08907708f, -0.16070543f, -0.07157188f, 0.15762003f, -0.04668830f, -0.06749035f, -0.05884632f, 
    -0.03107098f, 0.07458266f, -0.05393730f, 0.04626931f, -0.00276798f, 0.03131118f, 0.03138645f, -0.03413767f, 
    -0.08403294f, 0.01176997f, 0.00152503f, 0.09253076f, 0.05798136f, 0.12469474f, -0.06288325f, 0.03840697f, 
    0.17105602f, 0.07117864f, 0.01789778f, -0.00967392f, 0.02755042f, 0.04003314f, 0.02369349f, -0.00399459f, 
    -0.08299432f, 0.23114140f, 0.09838594f, -0.13998950f, -0.18157181f, 0.11200344f, 0.10856399f, 0.04439247f, 
    -0.03702755f, -0.29472542f, -0.23148617f, 0.13170835f, -0.09387857f, 0.15871939f, 0.04956897f, 0.02978728f, 
    0.04649502f, -0.00919168f, -0.17689312f, 0.00503382f, 0.01470720f, -0.13133259f, 0.03849014f, -0.13418208f, 
    -0.06163359f, -0.00664791f, 0.11303896f, -0.14932367f, -0.11074091f, 0.06827980f, 0.11322779f, -0.08257546f, 
    -0.12384790f, 0.00005845f, -0.11618976f, -0.07680408f, -0.08827788f, -0.20802537f, -0.02272236f, 0.09068072f, 
    0.25816664f, -0.06899951f, -0.09791760f, 0.07966172f, 0.01493859f, -0.03319457f, -0.15857022f, 0.23848084f, 
    0.05738591f, 0.10572610f, -0.09523927f, 0.04228553f, 0.10106359f, -0.00630753f, -0.12187184f, -0.36089504f, 
    -0.01153864f, 0.12666461f, 0.01931652f, -0.02873864f, 0.09308345f, -0.05108888f, 0.11735650f, -0.41497272f, 
    0.01438370f, -0.29980794f, 0.04441952f, 0.01504292f, -0.14907393f, 0.09574955f, 0.09864328f, 0.01449235f, 
    0.08166882f, -0.05881784f, 0.07943183f, -0.05235028f, 0.00250368f, -0.07311139f, -0.03067679f, 0.01055534f, 
    -0.00388227f, -0.22603288f, 0.12881568f, -0.05737256f, -0.03810266f, -0.05676794f, -0.25174889f, -0.13751335f, 
    0.01989487f, 0.09535001f, -0.10673620f, 0.16771878f, 0.27751556f, 0.16109802f, 0.14411773f, 0.02215449f, 
    0.02721551f, -0.00635839f, 0.09920377f, -0.18300140f, 0.20197135f, -0.14215484f, -0.10677987f, 0.08309948f, 
    -0.07088213f, 0.01622446f, -0.07464149f, 0.08376899f, 0.01051856f, 0.04161253f, -0.12211181f, 0.09395065f, 
    -0.06528961f, 0.04837383f, 0.07612753f, -0.07001299f, -0.07073939f, 0.41575262f, 0.01627517f, -0.12805952f, 
    -0.06757448f, -0.01143392f, 0.11596479f, 0.12850672f, -0.08203560f, -0.24576695f, -0.02694118f, 0.07229073f, 
    -0.06804445f, -0.01640863f, -0.02298218f, 0.02920966f, -0.15891750f, -0.07629256f, -0.02860128f, -0.14871116f, 
    0.14922303f, 0.24409135f, 0.15191017f, 0.08249329f, 0.09874447f, -0.01643240f, -0.08712359f, 0.09868845f, 
    -0.05157510f, -0.04566968f, -0.06552927f, 0.04537820f, -0.05541800f, 0.03500703f, -0.05659981f, -0.01629432f, 
    -0.01955492f, 0.00248455f, -0.01821927f, -0.01351309f, -0.04235554f, -0.00118942f, 0.03191556f, -0.01095758f, 
    0.07742655f, -0.03495105f, 0.09726526f, 0.04155494f, 0.41461107f, 0.12436392f, 0.03534967f, 0.02798054f, 
    -0.10268934f, 0.03782446f, 0.19082013f, 0.02669004f, 0.05897797f, -0.02160960f, -0.02261603f, -0.07949343f, 
    -0.15318374f, -0.12063583f, 0.06361493f, 0.15048926f, -0.23220375f, 0.11878539f, -0.28765297f, 0.02177506f, 
    -0.17187855f, 0.15493925f, 0.13865499f, 0.13033338f, 0.05424313f, 0.19583121f, 0.02710785f, 0.04612735f, 
    -0.04268782f, -0.00842054f, 0.08027184f, -0.14435351f, -0.02716381f, -0.15895821f, 0.01773244f, -0.14396189f, 
    -0.06905416f, 0.14532703f, 0.00579405f, -0.04587351f, -0.07722937f, 0.02916553f, 0.00676970f, 0.06688559f, 
    -0.05877176f, -0.27035829f, -0.06305557f, -0.04461788f, 0.04563503f, -0.00736575f, -0.05931520f, -0.05590658f, 
    0.20680779f, -0.03298238f, 0.14331190f, -0.01261786f, 0.03940802f, 0.02443251f, 0.03684807f, 0.06427536f, 
    0.10927602f, 0.03454756f, -0.37839961f, -0.04407933f, -0.14507754f, 0.00977146f, -0.00347366f, 0.04569900f, 
    -0.02958351f, -0.04660014f, 0.06851920f, 0.15700343f, -0.16825297f, 0.02795542f, 0.06873262f, 0.02246012f, 
    -0.02166146f, 0.06395536f, 0.21661361f, -0.00620530f, 0.10358882f, -0.08330245f, -0.06591579f, -0.11138079f, 
    0.03981759f, 0.04798491f, 0.08276246f, 0.02473523f, -0.07142505f, -0.02887849f, -0.28887498f, 0.08931118f, 
    0.08478205f, -0.03888753f, -0.01910045f, 0.01038531f, 0.03824802f, 0.08766842f, -0.10925735f, -0.00645957f, 
    -0.01977263f, 0.06196798f, -0.16895337f, -0.00097948f, 0.04538821f, 0.11457549f, -0.06606354f, 0.11394192f, 
    0.02035832f, 0.02143315f, -0.00972800f, 0.07812691f, -0.04880137f, -0.05674651f, 0.09293176f, 0.02288246f, 
    -0.04234245f, -0.04393531f, -0.09778447f, 0.05715061f, -0.04672145f, -0.20442699f, 0.03140313f, 0.00039046f, 
    0.26323622f, 0.14458840f, -0.07180154f, -0.10564473f, 0.12508006f, -0.03246752f, -0.01669485f, 0.07930564f, 
    -0.10331953f, -0.02957465f, -0.10203291f, -0.15560344f, 0.03601337f, 0.00288858f, -0.04149885f, 0.03898887f, 
    -0.05492934f, 0.08166122f, 0.05729628f, 0.06638576f, -0.07682807f, -0.02474411f, 0.08131745f, -0.08181489f, 
    0.14852564f, 0.13768621f, -0.09242973f, -0.51070493f, 0.05939112f, 0.08695634f, -0.01696852f, -0.07342158f, 
    0.04308618f, -0.01412242f, 0.07977961f, -0.02999559f, -0.03650439f, 0.20005536f, 0.07708378f, -0.02019887f, 
    -0.05816301f, -0.08322610f, 0.08149769f, 0.11128721f, 0.01269776f, 0.22977468f, 0.03968011f, -0.04497807f, 
    -0.09442028f, -0.00118792f, -0.02913501f, 0.10488992f, 0.00741536f, -0.00057135f, 0.17832038f, 0.06320591f, 
    -0.22680494f, -0.15076901f, 0.04439932f, -0.06298753f, 0.00462122f, -0.06690644f, 0.00585900f, 0.08001018f, 
    0.01929881f, 0.24107791f, -0.05381881f, 0.00287659f, 0.12435448f, 0.10718956f, 0.05386440f, -0.06542099f, 
    -0.05589037f, -0.08133175f, 0.00775809f, 0.04150348f, 0.02574230f, -0.07000666f, -0.01164272f, -0.05483861f, 
    0.04581879f, 0.00461448f, 0.04595644f, -0.07382826f, -0.02536201f, 0.00738396f, 0.05598236f, -0.03210225f, 
    -0.05331178f, -0.02560159f, 0.02144295f, 0.00773642f, 0.03236041f, -0.02998998f, -0.05305196f, -0.03651522f, 
    -0.02829232f, 0.01551560f, -0.00565186f, -0.03991543f, 0.01855246f, -0.01891882f, -0.06177375f, 0.04155104f, 
    -0.02848594f, -0.06347200f, -0.00713022f, 0.00931193f, -0.05672137f, -0.05850682f, 0.01917019f, -0.00188038f, 
    -0.01083133f, -0.04695027f, -0.01745082f, -0.04605172f, 0.04590844f, -0.01014585f, -0.02876250f, -0.05264189f, 
    0.02798727f, 0.01591813f, -0.06433342f, -0.07642962f, -0.06108783f, -0.06368286f, -0.01149918f, -0.03566463f, 
    -0.03105537f, -0.05754909f, -0.04569137f, 0.01873784f, -0.03760361f, -0.01065139f, -0.04110269f, -0.01562319f, 
    0.04764660f, -0.02133269f, 0.03345785f, -0.00941929f, 0.01905144f, 0.05375257f, 0.02797562f, -0.01512750f, 
    0.00329080f, 0.00410733f, -0.04201971f, 0.00255429f, 0.04781837f, -0.03555863f, -0.04507880f, 0.02482256f, 
    -0.05651220f, 0.00880846f, 0.01824720f, -0.04824104f, 0.03905658f, -0.05919122f, -0.02695278f, -0.01770588f, 
    -0.03145134f, -0.01990992f, -0.01244457f, -0.02164179f, 0.03196296f, 0.02809300f, -0.00625332f, -0.04462403f, 
    -0.02111595f, -0.04333226f, -0.03436230f, 0.01345191f, 0.01834845f, 0.02763698f, -0.05826858f, -0.00892880f, 
    0.01158237f, 0.05023643f, -0.04514163f, 0.04304842f, -0.03506856f, -0.05207140f, -0.03859531f, 0.01591073f, 
    0.02003255f, -0.02138260f, -0.02172401f, 0.03782913f, 0.03227117f, 0.04765046f, 0.00817841f, -0.00801033f, 
    0.03808479f, 0.02392681f, -0.07032351f, -0.05799541f, 0.00301778f, -0.04352326f, -0.00457544f, 0.04989594f, 
    0.02589576f, 0.04778219f, 0.05856887f, -0.04542272f, 0.01048097f, 0.01975600f, -0.03165222f, 0.00621033f, 
    -0.04155749f, -0.06353830f, 0.03912146f, -0.00628841f, -0.04550217f, 0.01370293f, -0.06640421f, 0.03207345f, 
    -0.02189924f, -0.02376242f, -0.03679231f, 0.00467065f, 0.02057343f, -0.03795434f, 0.00050123f, 0.05142188f, 
    0.02754909f, -0.05357902f, -0.06908895f, 0.00066006f, 0.05550478f, -0.06579241f, -0.04259567f, 0.03774463f, 
    0.00881429f, -0.00194603f, 0.02406878f, -0.01917493f, 0.04339608f, 0.01001983f, -0.05736285f, -0.01854681f, 
    -0.01292880f, 0.02586736f, -0.04924873f, -0.02857452f, 0.02945354f, 0.02790924f, -0.05665922f, 0.01836986f, 
    -0.04776314f, -0.02413500f, -0.01402650f, -0.03050584f, -0.03703536f, 0.02029352f, 0.02772650f, -0.04779316f, 
    -0.06356599f, -0.00525240f, -0.05850283f, -0.00103137f, -0.00873171f, -0.05542512f, -0.01474622f, -0.02546513f, 
    -0.05541761f, 0.04766708f, -0.05125183f, 0.05590747f, -0.05512140f, 0.04321375f, 0.02358317f, -0.03473181f, 
    -0.03986834f, 0.01643176f, 0.03426008f, 0.05140003f, 0.00973147f, 0.00663907f, -0.02093304f, -0.03107075f, 
    -0.01042524f, -0.07899376f, -0.03172045f, 0.01459431f, -0.04393945f, 0.00239176f, -0.04373085f, 0.01808619f, 
    0.03948548f, 0.03825200f, 0.02400300f, -0.03122944f, 0.00732248f, 0.03933755f, 0.03154090f, 0.02292392f, 
    0.03935469f, 0.01676496f, -0.03777202f, 0.01872691f, -0.04735660f, -0.04680332f, 0.01439263f, -0.06076833f, 
    0.02166008f, -0.01983947f, 0.02843568f, 0.03957957f, 0.00546639f, -0.01391658f, -0.02560512f, -0.03479176f, 
    -0.01676044f, -0.03144584f, -0.02013970f, 0.04387731f, 0.00492677f, -0.01251618f, -0.02325724f, -0.04769967f, 
    0.01549750f, 0.03912948f, -0.02036824f, -0.01329506f, 0.04159625f, -0.02641585f, -0.05380519f, 0.00353891f, 
    -0.06702953f, -0.04405602f, 0.02485949f, -0.06458703f, -0.03078043f, 0.01803576f, 0.04183329f, 0.01129753f, 
    -0.06717692f, -0.05065000f, -0.01403319f, 0.03494705f, -0.03970223f, 0.00862151f, 0.01415664f, 0.02755998f, 
    -0.07453292f, -0.04513675f, 0.01808505f, -0.04882289f, -0.00260239f, 0.01532056f, 0.03683029f, 0.05382610f, 
    -0.02609625f, -0.03953086f, -0.04630895f, -0.01317821f, 0.00026696f, 0.03407721f, -0.02778454f, -0.04981336f, 
    0.00698436f, 0.09876154f, -0.04774969f, -0.08669887f, -0.01262443f, 0.01400381f, 0.15201890f, 0.03850445f, 
    -0.09218238f, -0.04752500f, 0.00165035f, -0.01747965f, -0.11937959f, 0.00327597f, 0.07579173f, -0.09667294f, 
    0.11886857f, -0.01095232f, 0.07524430f, 0.03371654f, -0.32754970f, 0.05315768f, 0.07106265f, 0.05877215f, 
    0.10259682f, -0.04836882f, -0.07798827f, 0.05021501f, 0.08749503f, 0.06942566f, -0.10060117f, -0.05367906f, 
    0.02771430f, -0.12634216f, 0.05285624f, 0.00515621f, 0.09120286f, 0.05907100f, 0.07240328f, -0.05949217f, 
    -0.11628134f, -0.09664840f, 0.08078816f, 0.02990868f, 0.11758047f, 0.22822380f, 0.05056035f, 0.15515539f, 
    -0.15220717f, -0.11061770f, -0.12093388f, 0.13795140f, 0.14819600f, 0.15678093f, 0.09597979f, 0.10343334f, 
    0.17519665f, -0.00138691f, -0.11029996f, -0.01155266f, -0.03567294f, 0.05212488f, 0.08448445f, -0.02813814f, 
    -0.24631990f, -0.02645035f, 0.12538965f, 0.21374206f, 0.02909838f, -0.10068631f, -0.02471316f, -0.10856142f, 
    0.00117863f, -0.01503762f, 0.03836676f, 0.03638985f, -0.04525899f, 0.02134337f, 0.06964161f, -0.01422466f, 
    -0.01219308f, 0.23379965f, -0.02327781f, 0.09172798f, -0.04876966f, -0.03494129f, 0.01511852f, 0.01263225f, 
    0.01637332f, 0.15954988f, -0.11757182f, 0.05892438f, -0.32382488f, 0.04877514f, 0.02906371f, 0.15891236f, 
    -0.26045495f, 0.02556189f, -0.17771314f, 0.00353474f, -0.13944656f, 0.01945255f, 0.06556845f, -0.02787622f, 
    -0.00378308f, -0.00756269f, -0.06020875f, 0.01782999f, -0.11430208f, -0.01307205f, -0.00549617f, 0.07805074f, 
    -0.06773008f, -0.05590625f, 0.06804389f, 0.06970395f, 0.00379905f, -0.08552427f, 0.02164319f, -0.08777069f, 
    0.13378716f, 0.18638989f, -0.07875977f, -0.05232556f, -0.13175800f, -0.06650100f, -0.13042623f, -0.35088900f, 
    -0.08623342f, 0.02053376f, 0.06147669f, 0.21054879f, -0.09918969f, 0.00408924f, -0.11840949f, -0.06752925f, 
    0.01936556f, 0.16474199f, -0.12407371f, -0.00614975f, -0.10158964f, -0.05265861f, 0.11189599f, -0.01574154f, 
    0.11064254f, 0.04376664f, 0.12239940f, 0.05945697f, -0.00508719f, -0.14524770f, -0.03505247f, 0.09929522f, 
    0.08530207f, 0.00632912f, -0.12270998f, -0.00272817f, 0.00301005f, 0.06317089f, -0.06084035f, -0.05458606f, 
    -0.13152856f, 0.00047101f, -0.20058380f, -0.12600398f, 0.06599542f, 0.00921750f, 0.02432469f, -0.03167273f, 
    0.06264874f, -0.07286942f, 0.07316084f, -0.07536793f, -0.07214849f, 0.24705362f, 0.01793877f, -0.01519514f, 
    -0.00292969f, 0.07012057f, 0.08436529f, -0.09010546f, 0.13520117f, 0.17599520f, 0.24509929f, -0.15177630f, 
    0.03220084f, -0.08697524f, 0.15301616f, 0.09591237f, 0.26944527f, -0.16043836f, -0.15767786f, -0.03620829f, 
    -0.02656868f, 0.05665195f, -0.02772699f, -0.10303556f, 0.05036858f, -0.05596497f, -0.24120378f, -0.15232925f, 
    0.01911409f, 0.08473726f, 0.18527246f, -0.04910992f, 0.04172073f, -0.03506391f, 0.06345086f, 0.03637889f, 
    0.09677272f, 0.26252410f, -0.00517271f, -0.04186875f, 0.04043077f, 0.03876007f, 0.03241287f, 0.05696084f, 
    -0.13244243f, -0.11638390f, 0.04760100f, 0.01656941f, 0.05810330f, 0.01364167f, 0.01086880f, -0.04008251f, 
    0.15908527f, -0.06658575f, -0.12083099f, -0.09850011f, 0.00805388f, 0.07518017f, -0.01942877f, -0.02744105f, 
    0.02132286f, -0.05288549f, 0.23278907f, -0.00974245f, -0.17466646f, -0.01786376f, -0.06302044f, -0.06003167f, 
    0.02478303f, 0.02788910f, 0.07611001f, 0.13842547f, -0.05386165f, 0.03801189f, 0.01639209f, -0.08755472f, 
    0.01455911f, 0.00588049f, -0.05193394f, 0.10095701f, 0.03910090f, 0.05420738f, 0.09446722f, -0.11544514f, 
    0.05160769f, -0.02426981f, -0.07620504f, -0.00111401f, 0.01468670f, -0.03260996f, 0.00319770f, -0.00966156f, 
    -0.13416186f, -0.08488701f, -0.11190359f, 0.06897698f, 0.08917512f, 0.00004834f, 0.08571463f, -0.11229456f, 
    -0.13838065f, -0.03992488f, 0.01727673f, -0.02920121f, 0.06165637f, -0.06398850f, -0.00902099f, -0.01808265f, 
    0.00811735f, -0.14957404f, 0.10573599f, 0.04256986f, -0.04676887f, -0.02688556f, 0.02378137f, -0.03248092f, 
    -0.06109545f, -0.06520032f, -0.08843303f, 0.12914439f, 0.01323065f, 0.07417267f, -0.05000810f, -0.15920800f, 
    0.03977938f, -0.04479424f, 0.12737635f, 0.17893827f, -0.08860718f, 0.11267693f, 0.12498730f, -0.10381780f, 
    0.03614097f, 0.05170127f, -0.10509145f, -0.11989833f, 0.00579687f, 0.15881042f, -0.02142782f, 0.07099521f, 
    0.01268998f, -0.01201332f, 0.04175061f, -0.04453348f, 0.21233018f, 0.10522536f, -0.01336018f, -0.02437242f, 
    -0.03486809f, 0.04385475f, -0.12231451f, -0.01772774f, -0.08141304f, 0.08281567f, 0.08933672f, -0.08791351f, 
    0.07784957f, 0.04989032f, -0.08128900f, 0.04999515f, -0.13811052f, -0.17532043f, 0.11108869f, -0.11316007f, 
    0.03260175f, -0.00421878f, -0.11236999f, 0.08864898f, 0.00040212f, -0.11490639f, -0.17483202f, 0.20387574f, 
    0.24685089f, 0.01026296f, 0.15162031f, -0.05614856f, -0.14602140f, 0.02433273f, -0.11128368f, 0.13150291f, 
    0.04982448f, -0.07501124f, 0.00719808f, 0.06540907f, -0.02605696f, -0.14416856f, 0.00414566f, -0.01497718f, 
    -0.11069556f, -0.19006173f, 0.04805630f, 0.05745090f, -0.03103019f, 0.01301500f, 0.06414357f, -0.22420166f, 
    -0.11984736f, 0.22542626f, -0.07119367f, -0.10037156f, -0.01417141f, -0.08127174f, 0.08014708f, 0.15650545f, 
    -0.08092356f, -0.04108602f, 0.07717554f, -0.20431744f, 0.08109832f, -0.06109808f, -0.02505251f, 0.07733226f, 
    -0.08918653f, -0.04174536f, 0.15034689f, 0.03132115f, -0.11702530f, -0.02199395f, 0.06220872f, -0.03633947f, 
    -0.06406730f, 0.08352423f, -0.00927929f, 0.14771898f, 0.19994882f, 0.06026891f, 0.09339720f, 0.11201914f, 
    -0.00838608f, 0.00244991f, -0.01703860f, 0.14096752f, -0.15484187f, 0.03314020f, 0.06748211f, -0.00001767f, 
    0.02809272f, -0.05777808f, -0.04432819f, 0.03265749f, 0.04171237f, 0.19781774f, 0.25749978f, 0.18490379f, 
    -0.10782772f, 0.10291242f, 0.05471516f, 0.01734154f, -0.08610575f, -0.03343914f, 0.09304226f, 0.07007210f, 
    -0.22994231f, 0.03469085f, 0.06885689f, 0.02366922f, 0.08900287f, 0.04129556f, 0.07684086f, -0.01838082f, 
    -0.15289432f, 0.21064237f, 0.11814693f, 0.13475208f, 0.05016598f, 0.07589637f, 0.02902549f, -0.08425432f, 
    -0.11725171f, 0.16103947f, 0.04391649f, -0.01717177f, 0.03791504f, 0.03279728f, 0.18581232f, -0.03584921f, 
    -0.01014775f, -0.12956350f, 0.24082540f, -0.25863814f, 0.01905227f, -0.06791006f, -0.19672343f, 0.00328434f, 
    0.09779865f, -0.15764666f, -0.02877708f, 0.18222706f, -0.19664706f, 0.05573109f, -0.02291302f, -0.09737104f, 
    0.00420298f, 0.05201525f, 0.07380155f, 0.09789263f, -0.07635546f, 0.01260378f, 0.26532632f, 0.11208095f, 
    -0.04529109f, -0.00777001f, 0.04729527f, 0.05229473f, -0.11826801f, 0.33226281f, -0.04296528f, 0.21316351f, 
    0.08620268f, -0.04860181f, -0.03870851f, 0.01984592f, -0.04155816f, 0.02273376f, 0.10942173f, 0.02522817f, 
    0.04975964f, 0.08754589f, -0.14997375f, 0.04993994f, 0.09576525f, -0.17631750f, -0.03803659f, -0.24098530f, 
    0.00108385f, 0.14423008f, 0.00753060f, 0.00481284f, -0.03366597f, 0.03560679f, 0.02019373f, 0.07618198f, 
    0.10935137f, -0.00763659f, -0.03933747f, 0.13231395f, 0.08889019f, 0.03804919f, -0.03602520f, 0.22071074f, 
    -0.07045215f, -0.09276247f, -0.25193506f, 0.00143934f, 0.02022451f, -0.09049946f, 0.02722335f, -0.02413025f, 
    -0.08600019f, -0.10631938f, 0.13489479f, -0.01495580f, 0.00400175f, 0.07157969f, 0.08997248f, -0.15103337f, 
    -0.11313877f, 0.06051263f, 0.03135534f, -0.02673211f, -0.06616630f, 0.11481246f, 0.14028093f, -0.03826071f, 
    -0.00425421f, 0.08015524f, -0.00365058f, -0.04566379f, -0.12232800f, 0.20363459f, 0.02001614f, 0.05879995f, 
    -0.12483928f, -0.00493183f, 0.02798076f, -0.03618191f, 0.00648537f, -0.33511779f, -0.08605990f, 0.05959529f, 
    -0.06655692f, 0.00562708f, 0.12369473f, -0.10447922f, -0.05773321f, -0.10895801f, 0.15642704f, -0.13675299f, 
    -0.09584658f, -0.01561476f, -0.13224459f, 0.00030649f, 0.02968380f, 0.06588407f, 0.01855003f, -0.00517677f, 
    -0.06167737f, 0.09074835f, -0.01545401f, 0.00797708f, 0.05667837f, 0.00710299f, 0.05961241f, 0.09793718f, 
    0.00255322f, -0.01647827f, -0.07582993f, -0.04805604f, 0.03613460f, -0.03095041f, -0.04477968f, -0.02241468f, 
    0.02831687f, 0.00221219f, -0.02749839f, -0.04502387f, 0.03167025f, -0.05438576f, 0.02389196f, -0.04047011f, 
    -0.01215182f, -0.02460283f, -0.03486227f, -0.06825725f, 0.04168636f, 0.02196295f, 0.01579125f, 0.00809414f, 
    0.04250816f, 0.03537172f, -0.03042550f, -0.03750011f, -0.00160023f, 0.03211463f, -0.00725247f, -0.00503814f, 
    -0.00052205f, -0.01184440f, -0.04037629f, -0.06497783f, 0.02615570f, -0.02558216f, 0.02967562f, 0.01533663f, 
    -0.05073505f, 0.04090269f, 0.02322660f, -0.00938108f, 0.03564636f, -0.05296865f, 0.00578166f, 0.03372758f, 
    -0.01507884f, -0.01950282f, -0.00695193f, -0.04396664f, -0.03532524f, -0.02032170f, 0.04270374f, 0.00320494f, 
    0.03077196f, -0.04456133f, -0.02759485f, -0.00229213f, 0.02391185f, 0.05312191f, 0.00257370f, -0.00436966f, 
    0.03793883f, -0.01010306f, 0.00594804f, -0.01253012f, 0.03213327f, 0.00093785f, -0.05865214f, -0.05319988f, 
    -0.03108105f, 0.03251468f, 0.01981874f, 0.01667665f, -0.00244126f, -0.02096350f, 0.05102061f, -0.02778770f, 
    -0.01840848f, 0.04275502f, 0.00822738f, 0.01933444f, 0.04254292f, 0.02644457f, -0.03785280f, -0.00230973f, 
    -0.01882622f, 0.01172407f, 0.03605275f, -0.03558682f, 0.04894622f, -0.00162855f, 0.00615590f, 0.02415055f, 
    -0.04891282f, -0.02089793f, 0.01843836f, -0.01284801f, -0.01311012f, 0.00292777f, 0.01267633f, 0.01652334f, 
    -0.00828519f, -0.02056805f, -0.02418813f, 0.00885302f, -0.05154390f, -0.07007140f, -0.05760618f, -0.00120942f, 
    0.00678460f, 0.01429115f, -0.06794575f, -0.03731795f, 0.01094144f, 0.00175940f, -0.03301348f, 0.02571085f, 
    0.02382812f, 0.00907002f, -0.05572062f, -0.04502485f, 0.02351361f, 0.04353977f, -0.00330667f, 0.01314631f, 
    -0.00024425f, -0.02942803f, -0.04639883f, -0.02246255f, 0.02886098f, -0.04739418f, -0.00856536f, -0.01347494f, 
    -0.02045236f, -0.06191730f, -0.01579894f, 0.03017073f, -0.00893843f, -0.05687691f, -0.01481990f, 0.03264369f, 
    0.01855331f, -0.02545951f, -0.05062614f, 0.02045853f, -0.02325434f, 0.01342136f, 0.04097784f, -0.05919668f, 
    -0.01399484f, 0.02740288f, 0.02596132f, -0.06521545f, 0.01951980f, -0.03969774f, 0.00892033f, -0.00976600f, 
    -0.06139759f, 0.02335551f, 0.05300001f, -0.01464817f, -0.02875921f, 0.00999179f, -0.01023951f, -0.03022551f, 
    0.02241284f, 0.04456284f, -0.02658293f, -0.02353189f, -0.05141063f, 0.00813421f, 0.04534317f, -0.04854927f, 
    -0.00845828f, -0.01649322f, -0.03913862f, -0.03259183f, -0.02061310f, 0.05535007f, 0.02080866f, 0.03154763f, 
    -0.00611303f, -0.00785286f, 0.03713918f, -0.04127165f, -0.02749178f, 0.01541973f, -0.04674058f, 0.02305939f, 
    -0.02931364f, -0.01037605f, -0.00721113f, -0.06764184f, 0.05188335f, -0.04357381f, 0.01840925f, -0.02278062f, 
    -0.06748324f, 0.01625598f, -0.03763898f, -0.04323967f, 0.01490204f, -0.03071765f, 0.03414085f, -0.03815811f, 
    -0.02984519f, 0.00824076f, -0.02913081f, -0.04632326f, 0.02250472f, -0.06562237f, -0.01837488f, 0.01501562f, 
    -0.04788220f, -0.05390836f, -0.05022727f, -0.01598410f, 0.02798020f, -0.00517709f, -0.03378883f, -0.02416577f, 
    -0.04440620f, -0.01813754f, 0.01870447f, -0.06376128f, 0.01250944f, -0.04827889f, -0.00120864f, -0.00400159f, 
    0.03778306f, -0.00839738f, -0.01500005f, -0.04563920f, -0.00580338f, 0.03802880f, 0.01140675f, -0.03380445f, 
    -0.04784459f, -0.04136177f, -0.06192546f, 0.01801087f, -0.03185808f, -0.05817886f, 0.00848497f, -0.03674318f, 
    0.00891575f, -0.01177417f, -0.05982931f, -0.04840101f, -0.01090063f, 0.00178605f, 0.01367484f, 0.04307754f, 
    -0.02622894f, 0.03127111f, 0.04301237f, 0.05270442f, 0.00532518f, 0.01884769f, -0.02538495f, -0.04011787f, 
    -0.02329241f, -0.03961942f, 0.01550551f, -0.03767765f, -0.01830863f, -0.06397691f, -0.01936532f, -0.02183067f, 
    0.00817614f, -0.03358296f, 0.03478196f, -0.03742841f, -0.05783756f, 0.02562741f, 0.03674862f, 0.03951572f, 
    -0.02960212f, -0.03309521f, 0.02774589f, -0.04376045f, 0.01610295f, 0.03810917f, 0.04331483f, 0.01722191f, 
    -0.06534609f, 0.01135620f, -0.03412563f, -0.07666796f, -0.00522860f, -0.03732412f, -0.08191568f, -0.02397963f, 
    0.04023236f, -0.03006517f, -0.09306961f, 0.02972492f, -0.03858759f, -0.05864502f, 0.04297293f, -0.01957397f, 
    0.05406153f, -0.01108782f, -0.10976022f, -0.07786697f, -0.04490557f, -0.03194263f, -0.04282472f, 0.02517138f, 
    0.00853739f, 0.04661081f, -0.08888762f, 0.00566145f, -0.01332553f, -0.07093696f, -0.09433779f, 0.06799456f, 
    0.01255676f, -0.07488111f, -0.08184975f, 0.03111408f, -0.05484651f, -0.01896056f, -0.01402805f, -0.07664706f, 
    -0.03936939f, 0.03547533f, -0.08388902f, -0.07414389f, 0.00862950f, -0.08980171f, 0.03320672f, 0.03688545f, 
    -0.00153125f, 0.00317507f, -0.00550196f, 0.02857815f, 0.01454137f, -0.05125825f, -0.08654790f, 0.01892886f, 
    -0.04597980f, -0.09584826f, 0.03056910f, -0.01910610f, -0.09065679f, -0.01849565f, -0.03477976f, -0.05089125f, 
    -0.14541401f, -0.01857943f, 0.03001674f, -0.05982445f, 0.01302929f, 0.02501740f, 0.01668329f, -0.09746059f, 
    -0.04660350f, -0.11447061f, -0.01663052f, -0.03686003f, 0.02802489f, -0.05378405f, -0.06171755f, -0.05470670f, 
    -0.01605999f, -0.07219283f, -0.00266922f, -0.00964018f, -0.03741152f, -0.01949692f, 0.02348478f, 0.04320489f, 
    -0.05576091f, -0.00775121f, -0.04371407f, -0.06122304f, -0.11730345f, -0.06663443f, -0.09286386f, -0.04742718f, 
    -0.03124371f, -0.04029502f, -0.00335043f, -0.07828911f, -0.14299473f, -0.07053167f, 0.02303784f, -0.02382697f, 
    0.01655949f, -0.00722887f, -0.05694174f, -0.03216152f, -0.00896969f, -0.02041120f, -0.04744443f, -0.01244271f, 
    -0.01468707f, -0.09322283f, -0.04292918f, 0.00101117f, 0.02584749f, -0.01428009f, -0.13490224f, -0.08379503f, 
    0.00555552f, -0.12443049f, -0.01557626f, 0.00241055f, -0.07281712f, -0.07229787f, -0.12397904f, -0.10710869f, 
    -0.03913764f, -0.03180324f, 0.04239734f, -0.01190069f, -0.10435398f, -0.01619824f, -0.00310120f, -0.02674307f, 
    -0.06417628f, -0.04027276f, -0.03366105f, -0.08605884f, -0.01979163f, -0.03087715f, -0.03737615f, -0.00493822f, 
    -0.01907626f, -0.00939623f, -0.00857976f, -0.04231947f, 0.03451071f, 0.02236695f, -0.04835553f, -0.04960656f, 
    0.02554508f, -0.08053689f, 0.00502576f, -0.03292108f, 0.00970374f, -0.00780563f, 0.03707923f, -0.03703260f, 
    0.03728479f, -0.06924877f, -0.07764779f, -0.07037874f, 0.01403848f, -0.05850576f, 0.03192805f, -0.05141308f, 
    -0.00871838f, 0.03759096f, -0.05209072f, -0.04068806f, -0.08293349f, -0.12083996f, 0.00550185f, -0.06569751f, 
    -0.08336288f, 0.02292560f, -0.00777565f, -0.00012743f, -0.03493396f, -0.00439687f, -0.03036119f, -0.02913045f, 
    0.04069187f, -0.09845962f, 0.03029276f, -0.03140602f, -0.06458911f, 0.02571754f, -0.11946990f, -0.06411915f, 
    0.00810273f, 0.02291736f, -0.01357646f, -0.06288996f, 0.00586057f, -0.07051066f, -0.09516175f, -0.03886304f, 
    -0.05524193f, 0.00726804f, 0.01564566f, -0.13757053f, -0.06260333f, -0.02190087f, 0.00980992f, -0.05552394f, 
    0.01587065f, 0.03186218f, -0.05614977f, -0.06161524f, -0.06337500f, -0.06942435f, 0.04401913f, -0.00255321f, 
    -0.02307879f, -0.02445334f, -0.08792841f, -0.03348454f, -0.07536344f, -0.04836181f, -0.02145428f, -0.08594210f, 
    0.01135750f, -0.10644425f, -0.06448830f, -0.04829644f, -0.08999392f, -0.05642105f, -0.04165331f, 0.00034245f, 
    -0.02497440f, 0.01465549f, -0.11962479f, 0.00863229f, 0.01986384f, -0.06346401f, 0.01212322f, -0.01120198f, 
    -0.02021704f, -0.04013925f, -0.02544435f, -0.02430105f, -0.06975120f, -0.07186224f, -0.11231191f, -0.03656626f, 
    -0.00537611f, 0.01630552f, -0.02665649f, -0.04752332f, -0.11806419f, -0.09995977f, -0.04133133f, -0.11593157f, 
    -0.05788599f, -0.05281542f, -0.00267880f, 0.01106828f, 0.01321877f, -0.06412579f, -0.04893189f, 0.01702131f, 
    -0.03320375f, 0.04215685f, 0.01105342f, -0.07941239f, 0.01035297f, -0.07210815f, -0.11755197f, -0.10498253f, 
    0.00218673f, -0.06231065f, -0.00571115f, -0.06535059f, 0.00910433f, -0.03001885f, -0.04274501f, -0.09647133f, 
    -0.14727902f, -0.09297998f, 0.02242233f, -0.04893844f, -0.01723147f, -0.01926102f, -0.01650093f, 0.01667102f, 
    -0.01209207f, -0.01328131f, -0.25223514f, 0.14372855f, 0.06617242f, -0.00609592f, 0.07134675f, 0.12191533f, 
    0.10906543f, -0.23535940f, 0.13248888f, 0.02589147f, -0.11718623f, 0.06255556f, -0.06609242f, -0.06653596f, 
    -0.01686355f, 0.09737028f, 0.15229362f, 0.14824553f, 0.01654614f, 0.13278846f, 0.08096910f, 0.04363998f, 
    0.09821948f, 0.00067697f, 0.04169893f, -0.01558438f, -0.01964210f, -0.04196610f, -0.15463555f, -0.08105945f, 
    0.09112787f, -0.09980012f, 0.04171911f, 0.00865975f, -0.14233048f, 0.01848816f, -0.06433301f, -0.05370133f, 
    0.10499124f, 0.01130263f, -0.00977165f, -0.09536508f, 0.10571148f, 0.20042184f, -0.10913739f, 0.02617057f, 
    -0.13420802f, 0.00864536f, -0.07962684f, -0.00986413f, -0.00897592f, 0.00912718f, -0.07593320f, -0.02685075f, 
    -0.06304091f, -0.01917585f, 0.07337675f, 0.02510021f, 0.02108730f, -0.04131204f, -0.05032782f, -0.05665598f, 
    0.06385652f, 0.11893388f, 0.08259985f, -0.05053220f, -0.08585536f, -0.00482206f, -0.15447384f, -0.08666500f, 
    0.23436131f, -0.05610162f, -0.09721016f, -0.07425998f, 0.13360651f, 0.00406288f, 0.02906169f, -0.05185999f, 
    0.12057895f, 0.20024481f, -0.06842683f, -0.19677076f, 0.06480842f, -0.03885279f, -0.01767281f, -0.02957761f, 
    -0.05427646f, 0.06307713f, -0.03326451f, -0.00619211f, 0.00285912f, 0.06786213f, -0.01047556f, 0.06100984f, 
    0.06811833f, -0.02908345f, 0.00650863f, 0.01756373f, 0.06873503f, 0.16499598f, 0.00674777f, -0.03531814f, 
    0.03913297f, -0.06901821f, -0.04536638f, 0.05356088f, -0.01199158f, 0.07040871f, 0.00852108f, 0.00931293f, 
    0.02834658f, -0.00342479f, -0.01068344f, -0.02544368f, 0.04634634f, -0.27422386f, -0.12743945f, 0.20984335f, 
    0.15604739f, -0.05486714f, 0.00431839f, -0.01421471f, -0.01502162f, -0.00796338f, -0.06707895f, 0.07251988f, 
    0.19867979f, -0.09829854f, -0.03143595f, -0.07435603f, -0.04529723f, -0.12297330f, 0.07450933f, 0.15160739f, 
    -0.06822215f, -0.18095124f, -0.09483519f, 0.00915745f, -0.04431552f, -0.03600051f, 0.20991831f, -0.02702218f, 
    -0.00103718f, 0.01560703f, -0.03508624f, 0.05919732f, -0.00286101f, -0.01297848f, 0.16937473f, 0.06017561f, 
    0.06351025f, -0.32833117f, -0.16381481f, -0.06388704f, 0.06449861f, 0.01623116f, -0.03676634f, 0.05056775f, 
    0.08546418f, 0.08155784f, -0.07377777f, 0.02218183f, -0.14218552f, -0.07335646f, 0.02181189f, -0.01124101f, 
    -0.15442769f, -0.14191021f, -0.00068836f, -0.06621074f, 0.11354388f, -0.02765064f, 0.06032029f, -0.12880930f, 
    -0.12247898f, 0.06805453f, 0.08890741f, 0.04097205f, 0.04660219f, -0.09152622f, 0.16782628f, -0.23120017f, 
    -0.03697498f, -0.04444745f, 0.09856455f, 0.21956870f, -0.01237035f, -0.13385540f, 0.10664125f, 0.01701115f, 
    -0.04429310f, -0.06908891f, -0.08231989f, 0.08586685f, 0.04403829f, 0.01249077f, -0.22369882f, -0.13044599f, 
    0.00740155f, 0.12285171f, -0.01015467f, -0.03784452f, 0.03641212f, 0.12578708f, 0.08663914f, -0.10639124f, 
    0.00224744f, -0.11956484f, -0.05957983f, 0.03022252f, 0.02272959f, 0.13578005f, 0.01087932f, 0.04714743f, 
    -0.12756652f, -0.20465022f, 0.10043317f, -0.16066942f, 0.00074064f, -0.04469124f, -0.14598359f, 0.05397231f, 
    0.10681011f, -0.07794146f, -0.06395674f, -0.04298314f, 0.01198900f, 0.05167746f, -0.01014575f, 0.05023943f, 
    0.20340969f, -0.01997724f, -0.01989932f, 0.15701847f, 0.05318748f, -0.08852565f, -0.00713722f, 0.09118180f, 
    0.08875982f, -0.05811386f, -0.13929987f, 0.01665543f, 0.06414312f, 0.21325748f, -0.19086106f, -0.08941700f, 
    -0.01212045f, -0.04144088f, 0.06771573f, -0.02479498f, -0.04396845f, 0.07496366f, -0.03453814f, 0.02476677f, 
    -0.00426119f, 0.06670168f, 0.02365133f, -0.08117691f, -0.07621837f, -0.16539678f, 0.01477567f, -0.16031215f, 
    0.09333032f, 0.14258130f, 0.05565766f, 0.02819598f, 0.05690978f, 0.02024389f, -0.11991234f, 0.08569328f, 
    0.05512334f, -0.17884894f, -0.02923078f, 0.04565479f, -0.18652231f, 0.03425970f, 0.06633767f, -0.06053843f, 
    -0.07879546f, 0.06962989f, 0.07987459f, 0.00895713f, -0.09982270f, 0.02370655f, 0.06678338f, 0.08086620f, 
    -0.10361150f, -0.10208558f, 0.00397147f, -0.03988031f, 0.07601824f, 0.11026280f, -0.06827510f, 0.02248076f, 
    -0.04544207f, 0.46888664f, 0.07519262f, 0.01739035f, 0.12391586f, 0.12588543f, -0.01165398f, 0.15359239f, 
    0.08123481f, -0.00244099f, 0.03931996f, 0.03295681f, 0.17247769f, -0.23980285f, -0.10288323f, -0.00173083f, 
    -0.07776026f, 0.03185726f, 0.05289468f, -0.05705015f, -0.04129420f, -0.04335743f, 0.23001811f, 0.01046151f, 
    0.12036481f, 0.06495984f, 0.10900584f, -0.15050068f, 0.11212336f, -0.00405935f, -0.08995007f, 0.11669069f, 
    0.07378770f, 0.04634178f, 0.05589106f, -0.04231225f, -0.06277156f, -0.15292704f, 0.10046648f, -0.13097574f, 
    0.09045360f, 0.02872675f, 0.15147290f, -0.06212715f, -0.09366236f, 0.05133587f, -0.05722393f, -0.16807176f, 
    -0.05215402f, 0.14410745f, 0.11768937f, 0.02039164f, 0.01158962f, 0.00926260f, -0.06787051f, 0.02174336f, 
    0.00578905f, -0.00922695f, -0.06083469f, -0.05027866f, 0.03204032f, -0.12643915f, 0.05804335f, 0.04757436f, 
    0.03475874f, 0.03653248f, -0.02801724f, -0.05237858f, 0.09659831f, 0.14443733f, -0.05385680f, 0.06678662f, 
    0.09043738f, -0.24843082f, 0.16030784f, 0.01503666f, 0.13737664f, -0.05663912f, 0.16660625f, -0.00582330f, 
    -0.08608557f, -0.08605131f, -0.01800788f, -0.16707894f, -0.03896060f, -0.24510162f, 0.17331859f, -0.06098944f, 
    0.01188510f, 0.08879913f, 0.01610428f, 0.03970591f, 0.15588209f, 0.01133216f, 0.19474015f, 0.07339643f, 
    -0.02028774f, -0.00330408f, 0.01682121f, -0.03801265f, -0.00882740f, -0.12253822f, -0.17277603f, 0.04577158f, 
    -0.01486087f, 0.04877556f, 0.08220044f, -0.04677235f, -0.05928868f, -0.11698333f, -0.05083399f, -0.06501888f, 
    0.07323449f, -0.13161425f, -0.03380454f, 0.11110471f, 0.03226750f, -0.03419445f, 0.21509279f, -0.03891185f, 
    -0.01258646f, -0.00393097f, -0.07936629f, 0.02719723f, -0.00112167f, 0.06347128f, -0.08432233f, -0.05592249f, 
    0.02226708f, 0.09649420f, -0.01712763f, -0.00024875f, 0.07524729f, 0.10233727f, -0.25720376f, -0.04190481f, 
    -0.32581934f, 0.02095318f, -0.15032411f, 0.18206580f, 0.10476884f, 0.09929222f, -0.10650761f, -0.09042844f, 
    -0.02464092f, 0.22801927f, 0.15111884f, -0.15504189f, -0.16057785f, -0.04313542f, -0.04373782f, -0.06371753f, 
    0.12409294f, -0.03381922f, -0.07507841f, -0.19586255f, -0.22836344f, -0.04465532f, -0.07415666f, -0.01119243f, 
    -0.13867423f, 0.08651697f, 0.08734553f, -0.11336841f, -0.43577421f, 0.14223011f, -0.05525259f, 0.05454933f, 
    0.00034322f, 0.03538078f, -0.13746083f, -0.08829845f, 0.34431723f, -0.02100670f, -0.12136369f, 0.09677684f, 
    0.07640772f, 0.01392359f, 0.01030503f, 0.14462087f, 0.05319639f, 0.19957623f, 0.06433995f, 0.00106502f, 
    0.01935436f, -0.12076037f, -0.03598034f, -0.01104114f, 0.00761906f, 0.07573495f, -0.04369108f, -0.05864856f, 
    -0.09258687f, 0.03266587f, 0.04462554f, -0.07082191f, -0.06101323f, 0.03177201f, 0.05478671f, 0.14142972f, 
    -0.05403693f, -0.02332130f, 0.07212655f, 0.14797184f, 0.06855102f, -0.16740853f, -0.06134626f, -0.06602155f, 
    0.03055127f, 0.10840926f, -0.09212004f, -0.02832064f, -0.09239268f, 0.02683835f, 0.14114647f, 0.14030135f, 
    -0.05262461f, 0.08285225f, -0.15080343f, 0.06447313f, 0.07145905f, 0.10362201f, -0.05230751f, -0.07482186f, 
    -0.19106837f, 0.02252360f, -0.08448739f, 0.02538357f, -0.01846227f, -0.05503497f, -0.00813965f, 0.01367348f, 
    -0.07254276f, -0.02132168f, -0.10987607f, 0.34783742f, 0.09493588f, 0.00815588f, 0.23857768f, 0.00987700f, 
    0.00602454f, 0.08231248f, 0.08058943f, -0.03107888f, 0.03967376f, 0.10744041f, 0.05719750f, 0.11091639f, 
    0.10185074f, -0.11354038f, -0.00967409f, -0.09391668f, 0.10271099f, -0.13135219f, -0.00801475f, -0.13815650f, 
    -0.00675237f, 0.02234969f, 0.09784033f, -0.02454486f, -0.06656045f, -0.04115371f, -0.14224018f, -0.17914025f, 
    -0.12431634f, 0.06926967f, -0.08221109f, 0.00445684f, 0.01496509f, 0.06792595f, -0.12416348f, 0.01410587f, 
    -0.03332998f, 0.02384747f, 0.04325481f, -0.01079589f, -0.02899350f, -0.12830153f, 0.01721407f, -0.08989648f, 
    -0.02912000f, 0.00736083f, -0.05127609f, 0.00630552f, 0.04676489f, 0.06205110f, -0.06780502f, -0.02701506f, 
    -0.03486169f, -0.04523491f, -0.03676553f, -0.06537668f, -0.01216693f, 0.01972948f, -0.01134614f, -0.04138395f, 
    -0.01610347f, 0.03225800f, -0.01656878f, -0.01729215f, -0.03104536f, -0.02185565f, -0.06118864f, -0.00884878f, 
    -0.04035131f, 0.02582274f, 0.04226630f, -0.03057096f, 0.02231347f, -0.04518608f, -0.06121054f, 0.00559647f, 
    -0.00355196f, -0.04751313f, 0.02835957f, -0.06982789f, -0.02651372f, 0.00861371f, -0.00728530f, -0.02981647f, 
    -0.06788687f, 0.01648436f, -0.07119710f, -0.02196888f, -0.03422030f, 0.03882796f, -0.03362408f, 0.04897564f, 
    0.04488330f, -0.03877474f, 0.04972485f, 0.03300321f, -0.00278380f, 0.03473802f, 0.03012453f, -0.01594699f, 
    -0.00782565f, 0.01682541f, 0.03881101f, 0.04533797f, -0.00341809f, 0.05089537f, -0.02346701f, -0.04959537f, 
    -0.02009426f, 0.05000438f, -0.01393452f, 0.02217773f, 0.02394558f, -0.06465324f, -0.06827972f, -0.01691683f, 
    -0.02911764f, -0.00565115f, -0.01073332f, -0.04490840f, 0.01356145f, -0.02131141f, -0.06728076f, -0.02784336f, 
    0.02742992f, 0.03585622f, 0.01399093f, -0.00433378f, -0.06977206f, 0.05151717f, -0.03353010f, -0.06045882f, 
    0.01171213f, 0.01014343f, -0.03140073f, -0.00175707f, 0.01793128f, -0.02715761f, -0.05747012f, -0.04640756f, 
    -0.02204465f, -0.03332828f, -0.01771214f, -0.03508686f, -0.04828239f, -0.06425937f, 0.00786438f, -0.06636962f, 
    -0.01014007f, -0.03662560f, -0.00003663f, -0.00058847f, -0.03733244f, 0.01284542f, -0.03826128f, -0.04926566f, 
    0.01922199f, -0.02055276f, -0.01492210f, -0.02001864f, 0.02087897f, 0.05213352f, 0.06178220f, 0.03757787f, 
    -0.04160688f, -0.05132378f, 0.00194560f, 0.02933140f, 0.00630699f, -0.01013106f, -0.00230232f, 0.05662820f, 
    0.00269426f, 0.02402280f, 0.01454988f, 0.03947439f, -0.00783394f, -0.03879521f, 0.01967982f, -0.04818761f, 
    -0.03030632f, -0.04794901f, -0.01670086f, -0.01193374f, -0.04098194f, -0.03749041f, 0.04630991f, -0.00432756f, 
    -0.03902061f, -0.06580157f, -0.04369497f, 0.03444722f, -0.04819190f, -0.00826619f, 0.01040353f, 0.00854590f, 
    -0.00199677f, 0.03524022f, -0.02088014f, -0.06006386f, -0.04857930f, -0.06343066f, 0.04386914f, -0.03897809f, 
    -0.00373944f, -0.05678556f, -0.03664551f, -0.01011240f, 0.00689997f, 0.03952872f, -0.00805493f, -0.02380101f, 
    -0.06542823f, 0.02192654f, 0.00485923f, 0.06711152f, 0.03138096f, -0.03234756f, 0.04789829f, -0.00192053f, 
    0.02151588f, 0.04252161f, 0.01736885f, -0.02200585f, 0.01299722f, 0.00413451f, 0.01871045f, 0.04604455f, 
    -0.05018425f, -0.04173879f, -0.04721138f, -0.01116828f, 0.02996311f, 0.05089902f, -0.04879352f, -0.02392679f, 
    -0.02432929f, 0.03859045f, 0.01847619f, -0.06469444f, -0.02565562f, -0.05991808f, 0.04709632f, 0.00485868f, 
    -0.06552785f, 0.00442134f, -0.02061665f, 0.01862903f, -0.02499514f, -0.00379212f, -0.07057544f, -0.05410656f, 
    -0.01648465f, -0.01774531f, 0.01506093f, -0.03516275f, 0.03826360f, 0.00462272f, 0.02983693f, -0.06016888f, 
    0.03138488f, 0.04292248f, -0.03220154f, 0.03018449f, -0.04740953f, 0.00167949f, -0.05080859f, -0.07519749f, 
    0.02496148f, 0.05629912f, -0.06493600f, -0.00244362f, 0.01220629f, -0.05756467f, 0.00110176f, -0.07176606f, 
    0.01937540f, -0.06763329f, -0.03035904f, 0.00591645f, -0.00654160f, -0.00381409f, -0.03363498f, 0.03958446f, 
    -0.01790566f, -0.00027671f, 0.03992049f, -0.06782559f, 0.04023769f, -0.04076931f, 0.01165331f, 0.04131708f, 
    0.01650712f, 0.00097215f, 0.03955743f, -0.03051046f, -0.02131013f, -0.03428378f, -0.06691987f, -0.06800076f, 
    -0.04361133f, -0.01671926f, 0.01757418f, -0.05637959f, 0.06034535f, 0.03422214f, -0.03857643f, 0.01454646f, 
    -0.03587814f, -0.06791407f, 0.03302764f, -0.05564846f, 0.02061788f, -0.04888869f, -0.02785410f, -0.01630482f, 
    -0.05802919f, 0.01814480f, -0.01422851f, -0.03849392f, 0.00569172f, -0.01857734f, 0.04599793f, -0.02062180f, 
    -0.06161809f, -0.06423167f, 0.03902018f, -0.06410178f, 0.02325187f, -0.03980500f, 0.02770244f, 0.00482829f, 
    0.03680063f, 0.06229283f, 0.07345781f, -0.04365586f, 0.00313556f, -0.01627050f, 0.00346861f, 0.13674235f, 
    0.05834539f, 0.04628658f, 0.00598938f, 0.05574887f, 0.06624568f, -0.03628686f, -0.04393918f, -0.05639659f, 
    0.02698369f, -0.03001650f, 0.29479891f, 0.13657792f, -0.03724885f, -0.12457117f, 0.01079878f, -0.10451702f, 
    0.03265449f, 0.05307908f, -0.07380883f, -0.08330031f, 0.15895280f, 0.00134999f, 0.09147949f, -0.05123764f, 
    -0.12018615f, -0.06007583f, 0.02965145f, 0.03853467f, -0.10505743f, 0.06727591f, 0.14425410f, -0.03812265f, 
    0.06947065f, -0.06230470f, -0.04747468f, -0.03354346f, 0.00115551f, -0.25236368f, 0.17599082f, 0.05306993f, 
    0.07957086f, 0.02347701f, -0.05538632f, -0.11926226f, -0.01814005f, -0.02944678f, -0.18998864f, -0.00069960f, 
    0.08806628f, 0.08485378f, -0.00868626f, 0.04742501f, -0.00337770f, -0.13704441f, 0.03268662f, 0.05452415f, 
    -0.07113761f, -0.21221019f, 0.08207785f, -0.02631203f, 0.05407851f, -0.01328938f, -0.04883376f, -0.03515379f, 
    -0.06284156f, 0.15486296f, 0.04680601f, -0.10417444f, -0.08293212f, -0.11541061f, 0.02156766f, 0.00147357f, 
    0.03522050f, 0.03684068f, 0.13555050f, -0.01935088f, -0.02097831f, -0.06650961f, -0.08459712f, 0.04402272f, 
    0.00456823f, 0.02644442f, 0.24819459f, -0.06362282f, -0.25227639f, -0.03759840f, 0.13011345f, -0.06865451f, 
    0.00839106f, 0.00749988f, 0.01445688f, 0.17786652f, -0.16915780f, -0.05763068f, -0.06455982f, 0.01737481f, 
    -0.00545697f, -0.06889523f, -0.01123096f, -0.02300765f, 0.12401813f, -0.21592695f, 0.05938319f, -0.05013017f, 
    0.06867465f, 0.02901391f, -0.06812277f, 0.05970272f, -0.12189918f, 0.21595789f, -0.24726471f, -0.08694690f, 
    -0.05939285f, 0.15657336f, 0.03913568f, -0.02960140f, -0.11309394f, -0.02855655f, 0.00983893f, -0.18444768f, 
    -0.43711725f, 0.02360247f, -0.09350290f, 0.17819387f, 0.02953962f, -0.02061587f, -0.01319566f, -0.01110869f, 
    -0.05068008f, 0.12354374f, -0.06334104f, -0.03613748f, -0.02264841f, 0.01424927f, 0.00044686f, 0.11323989f, 
    -0.03627139f, 0.06725233f, -0.02990972f, 0.01939373f, -0.02492713f, -0.11497021f, -0.02861303f, 0.12642065f, 
    0.00115482f, 0.39062765f, 0.00299580f, -0.09824723f, -0.10630139f, 0.03102945f, -0.04020454f, -0.02154935f, 
    0.13020450f, -0.05502979f, 0.09349973f, -0.08660425f, -0.02089295f, -0.17423697f, 0.05821327f, -0.08465335f, 
    0.09953865f, -0.03201903f, -0.14242846f, -0.28130278f, -0.21203780f, -0.01447326f, 0.10507604f, 0.12992907f, 
    0.02531121f, -0.03946023f, 0.10041234f, -0.01707092f, -0.17748116f, 0.12447490f, -0.22123578f, 0.08329301f, 
    -0.05642033f, 0.09686448f, -0.04368475f, -0.03762640f, 0.17110445f, 0.08373635f, -0.07643738f, -0.10757129f, 
    0.01865532f, 0.10574070f, 0.04216245f, -0.10909781f, -0.02420604f, 0.05969638f, -0.07828482f, -0.16777372f, 
    -0.06610239f, 0.01097847f, 0.01378528f, -0.01504884f, 0.01939787f, -0.04117742f, -0.00453628f, -0.00022996f, 
    0.10049193f, 0.01002645f, 0.08876208f, -0.02461661f, 0.05202866f, 0.06078156f, 0.06578507f, 0.05145896f, 
    0.37396884f, -0.00340856f, -0.05500238f, 0.07651867f, 0.02977500f, 0.19574873f, -0.08054394f, -0.02988063f, 
    0.12236838f, 0.07416256f, -0.00597345f, 0.06325360f, -0.13687822f, -0.03177600f, 0.00985109f, 0.02446166f, 
    0.01666841f, 0.06479622f, 0.05943264f, 0.08458705f, -0.03378712f, -0.04055863f, -0.01155124f, -0.01630291f, 
    -0.05106156f, -0.02453701f, 0.16168256f, 0.12494178f, -0.19472821f, -0.21522550f, 0.05596480f, 0.01895484f, 
    0.04035176f, -0.00325476f, -0.08067656f, 0.10364318f, 0.18774340f, -0.14547446f, 0.02698375f, 0.06036539f, 
    -0.03930141f, 0.01378768f, -0.08495262f, 0.07498991f, 0.04316689f, -0.10079811f, -0.01352462f, 0.04405721f, 
    0.09602225f, -0.01180791f, -0.07839724f, -0.07703143f, 0.07792059f, 0.00712338f, -0.26455942f, 0.00979163f, 
    0.04048863f, 0.04496749f, -0.02976556f, 0.05707411f, 0.04454540f, 0.00480636f, -0.09172419f, -0.02594751f, 
    0.08046766f, -0.04542999f, -0.13417618f, -0.00370091f, -0.01437011f, 0.05336614f, 0.02928264f, 0.02212394f, 
    -0.03396327f, 0.03187973f, 0.02655534f, -0.00596782f, -0.04202398f, 0.04024815f, 0.01720288f, -0.05787794f, 
    0.03338876f, -0.02177171f, -0.01275141f, -0.02109549f, 0.04272380f, -0.06551220f, -0.05293090f, 0.02614086f, 
    0.04471103f, -0.01157923f, -0.03990622f, -0.05413336f, -0.04775189f, -0.04489419f, -0.06851202f, -0.03672878f, 
    0.05508425f, 0.03631653f, 0.04592748f, 0.03534629f, -0.05179936f, 0.02402879f, -0.04491127f, 0.00949389f, 
    0.02563426f, -0.05525267f, -0.01791318f, -0.03694265f, 0.01056806f, -0.03524224f, -0.06576701f, 0.02366725f, 
    -0.06955013f, 0.01980566f, -0.01815693f, -0.05426877f, -0.06175142f, -0.06444411f, -0.02017262f, 0.02605680f, 
    0.00928543f, 0.01046537f, 0.05004026f, -0.05014316f, -0.06412700f, 0.01359777f, -0.05693920f, -0.06078243f, 
    0.00142402f, 0.02275242f, -0.05150902f, -0.02915360f, -0.03266533f, -0.04164943f, -0.00070695f, -0.01448273f, 
    0.00019284f, -0.05001589f, 0.03225131f, -0.01497873f, -0.03279552f, 0.04280236f, -0.02353211f, -0.03606800f, 
    0.03818361f, 0.04174342f, -0.00996746f, -0.05323119f, -0.00911659f, -0.03206518f, -0.05296433f, 0.04192719f, 
    -0.06868290f, 0.01821481f, 0.00775618f, -0.03713696f, 0.04551609f, 0.03120227f, -0.01145389f, 0.00232388f, 
    0.03654022f, 0.01305990f, 0.00335831f, -0.02793944f, 0.02879347f, -0.02807574f, 0.00799060f, 0.01609943f, 
    0.01781396f, -0.06866599f, 0.02117462f, -0.05998280f, -0.05722854f, -0.04067967f, 0.02679475f, 0.01135508f, 
    -0.05763920f, -0.02811455f, -0.04786675f, -0.03704963f, -0.02166473f, 0.03411552f, -0.04886295f, 0.01609521f, 
    0.00529216f, 0.02824783f, -0.05064435f, 0.04002154f, 0.03778452f, -0.05006065f, -0.06595794f, -0.04754404f, 
    -0.04821176f, 0.02844086f, 0.02537754f, 0.02268201f, 0.03866408f, -0.01930517f, -0.02008458f, 0.04885977f, 
    0.01806708f, -0.06649063f, 0.01015643f, 0.00130632f, -0.01122098f, -0.03591108f, 0.01886077f, 0.02756551f, 
    0.02555872f, -0.03150928f, -0.02775140f, 0.02082236f, 0.03886339f, 0.02397846f, -0.00884253f, -0.05886864f, 
    -0.02317177f, -0.00379470f, -0.06920353f, 0.01796329f, 0.04515329f, 0.02256561f, 0.01057015f, -0.03230950f, 
    -0.04101493f, 0.02861190f, -0.04583073f, -0.04893463f, -0.01630655f, -0.07229653f, 0.01489758f, 0.04695840f, 
    0.04552022f, -0.00937986f, 0.04080547f, -0.02622016f, -0.01516921f, 0.03182891f, -0.00030606f, 0.02591075f, 
    -0.02312169f, -0.04857289f, 0.00837886f, -0.05322085f, 0.02305396f, 0.04127024f, -0.00868499f, -0.05179748f, 
    0.04684560f, 0.04020927f, -0.00748914f, 0.02970485f, 0.00862597f, 0.02236592f, 0.04448600f, 0.01206149f, 
    0.02032455f, 0.02788906f, -0.01669054f, -0.01892992f, 0.03408766f, -0.04109181f, 0.03928506f, 0.01781594f, 
    -0.05070709f, 0.01710523f, -0.00148468f, -0.06336639f, -0.05844574f, -0.03761829f, -0.01031503f, -0.00135361f, 
    -0.01122442f, 0.01731495f, 0.05036909f, -0.03385305f, 0.03747456f, 0.01483403f, -0.00067348f, 0.03424161f, 
    -0.03290741f, 0.01509069f, -0.05697122f, 0.03542029f, -0.05208978f, -0.03099663f, -0.02269823f, -0.00796064f, 
    0.02443907f, 0.01368220f, -0.00766373f, -0.00396652f, 0.02298569f, -0.01975610f, -0.03529265f, 0.00593068f, 
    -0.03224532f, -0.06961239f, -0.05095466f, -0.02517318f, 0.03965293f, 0.03472329f, 0.03876429f, 0.02422143f, 
    -0.05649091f, -0.05112899f, 0.01288041f, 0.02926889f, -0.04736079f, -0.02230696f, 0.00410264f, -0.01214306f, 
    -0.00939814f, -0.01599691f, -0.00959184f, 0.00949776f, 0.02255493f, -0.02333461f, -0.05088419f, 0.04106077f, 
    -0.06196692f, -0.03716429f, 0.05272932f, 0.02123682f, -0.02898919f, -0.02741240f, 0.03686740f, 0.03883743f, 
    -0.02153442f, -0.05005833f, -0.02688581f, 0.00573153f, -0.04523233f, -0.07115903f, -0.01127315f, 0.02081919f, 
    -0.02097852f, -0.01747105f, -0.02382286f, 0.02009272f, -0.00057120f, 0.01636603f, 0.00028742f, -0.05443718f, 
    0.03425197f, -0.01769631f, -0.00004043f, 0.03653987f, 0.03703256f, -0.03811895f, 0.01599772f, -0.04456789f, 
    -0.00581496f, 0.03479472f, -0.06429151f, -0.03839621f, -0.07560682f, -0.03496133f, -0.02438449f, 0.02258157f, 
    0.04962460f, -0.01156123f, -0.02396989f, -0.03984106f, -0.05165860f, -0.02149988f, -0.00815737f, -0.01396900f, 
    -0.01910369f, -0.03105940f, 0.02097373f, 0.04300266f, 0.01713801f, -0.05458651f, -0.02719394f, -0.06166369f, 
    0.02669382f, -0.05218950f, -0.02968879f, 0.01787456f, -0.01526967f, -0.02086054f, -0.01818301f, 0.02164008f, 
    0.05166982f, -0.03282807f, -0.05549841f, -0.00432025f, -0.00896981f, 0.02167887f, 0.03535654f, -0.03555311f, 
    -0.02735588f, -0.06264073f, -0.05228741f, 0.02168880f, 0.00960132f, -0.02430077f, -0.02920565f, -0.04690324f, 
    -0.04979668f, 0.04774713f, -0.02086060f, 0.01656691f, 0.04968620f, -0.05886305f, -0.01430357f, -0.06048854f, 
    -0.04594271f, 0.00005270f, -0.02275769f, 0.02072351f, -0.06216742f, -0.04841869f, 0.04200745f, 0.03644594f, 
    -0.03206293f, -0.02427211f, -0.05332033f, -0.02792932f, 0.01762114f, 0.02291222f, -0.00535055f, -0.01294230f, 
    0.00896823f, 0.00179660f, 0.04183974f, -0.00397371f, -0.06342881f, 0.04564029f, -0.05859336f, -0.03101557f, 
    -0.03864018f, 0.03314731f, -0.00790905f, 0.00884700f, -0.05015912f, 0.01935010f, 0.04986643f, -0.02546518f, 
    0.00534002f, 0.01237234f, -0.02749688f, -0.06440633f, -0.00043501f, -0.03802205f, 0.01824037f, -0.02793364f, 
    0.00502589f, -0.03155061f, -0.02240645f, 0.00862854f, 0.03865205f, -0.01775427f, -0.01916394f, 0.03033301f, 
    0.04614250f, 0.04412523f, -0.00563772f, -0.02149606f, -0.06430443f, 0.02942396f, -0.00328112f, -0.06407988f, 
    0.00492139f, 0.02145416f, 0.01130063f, 0.04413029f, 0.03092282f, -0.05853758f, -0.02537698f, 0.00758583f, 
    0.02673650f, -0.05444482f, -0.05475400f, 0.03812744f, 0.04864992f, 0.00416480f, -0.00994615f, 0.03422636f, 
    -0.04650746f, -0.00140861f, -0.01460729f, -0.04673932f, -0.00309221f, 0.03489209f, 0.05225175f, -0.05856515f, 
    -0.02811712f, -0.03527787f, -0.02315718f, -0.02100402f, -0.02633610f, -0.01156555f, 0.03041463f, -0.01033073f, 
    0.02052978f, -0.02464344f, -0.00795281f, -0.05781342f, 0.00707334f, -0.05595435f, -0.05271617f, -0.05756267f, 
    0.01124741f, -0.02470558f, 0.02120699f, -0.05401568f, 0.00611329f, 0.00646655f, -0.02695985f, -0.02296954f, 
    0.00911483f, -0.05850269f, 0.01460517f, -0.05541296f, -0.00777048f, 0.02576411f, 0.01736510f, 0.03823703f, 
    0.02980597f, -0.04053902f, -0.00238947f, -0.06048802f, -0.02038424f, 0.00129051f, -0.02853522f, 0.03548187f, 
    -0.02173079f, -0.00031123f, 0.02569418f, 0.05321735f, 0.01390704f, 0.04763487f, -0.01374128f, -0.02127773f, 
    0.01285925f, 0.02013129f, 0.00013165f, -0.00532534f, 0.01563504f, -0.02095513f, -0.05369895f, 0.01919765f, 
    -0.04257689f, -0.00236562f, -0.02072523f, -0.05197411f, -0.00328007f, -0.05567360f, -0.06411540f, 0.01606985f, 
    0.00553353f, -0.05531911f, -0.04320872f, 0.02247601f, 0.01382940f, -0.05921088f, -0.03377277f, -0.05620359f, 
    -0.00427782f, -0.05546784f, 0.04262560f, -0.02562643f, 0.04879195f, 0.04227480f, 0.01562538f, 0.00465977f, 
    -0.05301518f, -0.01069499f, -0.01210019f, -0.04558460f, 0.03717789f, 0.01012195f, -0.04818388f, -0.03878066f, 
    0.04736466f, -0.00633697f, -0.01342841f, -0.05710439f, 0.02969916f, -0.05988890f, 0.03812745f, 0.03925216f, 
    -0.04264615f, -0.03900579f, 0.01444514f, 0.05178048f, 0.03599105f, -0.05957907f, 0.04829296f, -0.00321370f, 
    0.03162822f, 0.00153852f, 0.05024533f, 0.00559668f, 0.03238807f, -0.03689152f, -0.06408518f, 0.03068041f, 
    0.04169900f, 0.04241019f, -0.05451331f, -0.05422212f, -0.05972837f, 0.03569385f, -0.06306445f, 0.03760216f, 
    0.00797010f, 0.03780300f, -0.05790770f, -0.01459161f, -0.02132941f, 0.03571135f, 0.03885601f, 0.00354776f, 
    -0.01695682f, -0.05161451f, -0.04723287f, 0.04111245f, -0.00154538f, 0.03144751f, -0.06330197f, -0.06238997f, 
    0.03647111f, 0.03243515f, -0.03533799f, -0.00687982f, 0.00094612f, 0.02791569f, -0.01471741f, -0.03192655f, 
    0.04124475f, 0.02258843f, -0.00309110f, -0.03919760f, -0.06049150f, -0.00977456f, -0.01287061f, 0.04859755f, 
    -0.04952647f, -0.02502664f, -0.05472945f, -0.01427391f, 0.03430590f, -0.01898770f, -0.00294173f, -0.06117220f, 
    0.08165383f, -0.02863197f, 0.05420589f, 0.00340546f, -0.05544597f, 0.09230389f, 0.07723805f, -0.00580864f, 
    -0.04798466f, 0.23798327f, 0.15977150f, -0.23013346f, -0.19551009f, -0.11953599f, -0.12664732f, 0.20076947f, 
    0.02760475f, 0.01451200f, 0.26007435f, -0.09872036f, -0.04497845f, -0.02268605f, -0.02570742f, 0.19022706f, 
    -0.01006046f, -0.09271590f, 0.09605831f, 0.21511224f, 0.16962621f, -0.24067114f, -0.12710874f, 0.06142746f, 
    -0.09553928f, -0.01329103f, 0.00269059f, -0.07451951f, 0.17219192f, 0.24561785f, -0.05362599f, 0.08330961f, 
    -0.12198672f, -0.05731589f, 0.06589068f, 0.09668656f, -0.03729954f, 0.09135821f, -0.06854384f, 0.01722048f, 
    0.02366757f, -0.09832849f, 0.14894576f, -0.15516642f, -0.04962803f, -0.00543990f, 0.20046853f, 0.17828313f, 
    -0.12923369f, 0.01347443f, -0.08427632f, 0.06052116f, -0.00811812f, 0.12163351f, -0.01519357f, 0.12347742f, 
    -0.24497791f, -0.02676048f, 0.08278552f, 0.09338807f, 0.14597557f, -0.00301556f, -0.05870776f, 0.09405334f, 
    0.23534362f, -0.04006664f, 0.24022184f, 0.02377584f, -0.00424733f, 0.11200886f, -0.10888693f, -0.08521535f, 
    -0.01367726f, 0.01318805f, -0.17088918f, 0.20976004f, -0.10400269f, 0.00775610f, 0.01165452f, 0.03740690f, 
    0.03929944f, -0.09152214f, 0.03986955f, -0.13424088f, -0.02225162f, -0.02069274f, 0.13222623f, 0.11250082f, 
    0.08339731f, -0.10612344f, 0.04267553f, 0.03427191f, 0.04357529f, -0.20459576f, 0.02027525f, 0.07329527f, 
    0.02601247f, 0.01981569f, 0.09432373f, 0.15320604f, -0.25282004f, 0.10784660f, -0.08700745f, 0.08017284f, 
    -0.03501819f, 0.03169834f, -0.05798380f, 0.04608099f, 0.13271336f, -0.10218700f, 0.02440278f, -0.32121736f, 
    0.12685190f, -0.01731175f, 0.01734999f, -0.03250356f, -0.06648976f, -0.04644497f, -0.09780684f, -0.44517255f, 
    -0.30472293f, 0.12501991f, -0.04776904f, 0.04057929f, -0.04491358f, 0.10602783f, 0.07174075f, -0.10965162f, 
    0.20324461f, 0.04308967f, 0.09646375f, 0.01601979f, 0.10304856f, -0.08542353f, -0.03169395f, 0.07087953f, 
    0.15994263f, -0.22882329f, 0.02751008f, -0.00579057f, 0.00337391f, -0.07445131f, -0.03475408f, 0.00006130f, 
    -0.03474565f, -0.03417277f, -0.34033355f, -0.01094852f, 0.09206831f, -0.01717166f, -0.14695960f, -0.00297921f, 
    -0.11081016f, 0.00577309f, -0.19387905f, 0.22912374f, 0.22306593f, 0.13947396f, -0.00836593f, -0.07638025f, 
    -0.00962210f, 0.09833291f, 0.21848533f, -0.19826947f, 0.00798859f, -0.23849083f, -0.03936685f, -0.12696417f, 
    0.09910185f, 0.00110488f, -0.07676275f, 0.12563992f, 0.27726728f, 0.05938931f, -0.06246958f, -0.03733113f, 
    0.02187906f, 0.12630779f, 0.20209976f, -0.02377136f, -0.01586185f, -0.03625967f, -0.20042174f, 0.05008467f, 
    -0.01730098f, 0.01705811f, -0.01867188f, 0.03476297f, 0.06910082f, -0.10310826f, -0.27695921f, 0.12956943f, 
    0.03627780f, 0.03970901f, 0.05779066f, -0.03600540f, -0.10437091f, -0.06488153f, 0.04681670f, 0.13302173f, 
    0.14535569f, 0.01084862f, -0.01965586f, 0.07425080f, 0.01209738f, -0.01600364f, 0.06578834f, -0.02955560f, 
    0.22303528f, -0.14885882f, -0.12784435f, 0.05314123f, 0.05574647f, -0.03856653f, -0.00622081f, 0.09376136f, 
    -0.12515569f, -0.00993859f, 0.00325497f, -0.12706868f, 0.07087824f, 0.04016026f, 0.01216436f, -0.10430734f, 
    -0.12101163f, 0.01648838f, 0.15392546f, -0.25937957f, -0.35950008f, -0.01425361f, 0.03368368f, -0.02210887f, 
    0.02746721f, 0.00156776f, 0.11408333f, -0.17719382f, 0.19233461f, -0.36461285f, 0.08263242f, 0.00577484f, 
    -0.00839466f, 0.00405017f, -0.11387579f, 0.01248043f, 0.11102901f, 0.10201986f, -0.22021046f, -0.10795678f, 
    0.09366792f, 0.10241291f, 0.04246438f, 0.03430184f, 0.12483220f, 0.02699017f, 0.08290991f, -0.24420108f, 
    -0.10541877f, -0.11834373f, 0.01986975f, 0.12785596f, -0.00511008f, -0.03479262f, 0.23031022f, 0.17676756f, 
    -0.24593936f, 0.11680324f, -0.16820392f, 0.04249374f, 0.01308897f, -0.02936820f, 0.01114474f, 0.09917282f, 
    0.04127440f, -0.03026083f, 0.01079391f, -0.08029617f, -0.01805515f, -0.02975684f, -0.04328674f, -0.14759324f, 
    0.04542126f, -0.03001789f, 0.01231372f, 0.09123486f, -0.06172947f, 0.10374364f, 0.11211811f, -0.11604707f, 
    -0.05718820f, -0.02093198f, 0.02282668f, -0.20324184f, 0.07181346f, -0.08520740f, 0.07819156f, -0.00636039f, 
    -0.04143883f, -0.16089118f, 0.06222979f, -0.01615782f, 0.32361570f, -0.06429075f, -0.06254169f, 0.06031168f, 
    0.00515474f, 0.00273189f, 0.22488843f, 0.13136984f, -0.10295725f, -0.20220743f, 0.05577063f, 0.04879994f, 
    -0.04717635f, 0.00720748f, 0.02852383f, -0.05148743f, -0.16524464f, 0.04686121f, -0.19624421f, 0.08661333f, 
    0.17650793f, -0.00871060f, -0.01083694f, -0.20397738f, -0.03681381f, 0.00770977f, -0.03208617f, -0.33204114f, 
    -0.04509260f, 0.07248508f, 0.00081617f, 0.03023201f, -0.10828816f, 0.14559087f, -0.10332596f, -0.02679490f, 
    0.06587999f, 0.14411533f, 0.08718122f, -0.08728902f, -0.04554124f, 0.00295954f, -0.02821242f, -0.06710152f, 
    -0.00567749f, 0.12341105f, -0.00823269f, -0.03327339f, 0.05866591f, -0.08112777f, 0.04734763f, -0.02030972f, 
    0.13056327f, -0.05988821f, -0.01585574f, 0.03500808f, -0.04959750f, 0.02821598f, 0.06128474f, -0.00523622f, 
    -0.01246826f, -0.17146583f, 0.09045120f, -0.16740505f, -0.08682130f, 0.03966784f, 0.00843997f, 0.06156328f, 
    0.01666543f, 0.00539854f, -0.23072989f, -0.00380978f, 0.15241171f, -0.06010615f, -0.01310045f, 0.04475052f, 
    0.05533509f, -0.10455755f, 0.03213057f, 0.22190107f, 0.09853603f, 0.07368425f, 0.03521134f, 0.08732154f, 
    -0.06225241f, 0.03576133f, -0.03468951f, 0.07817468f, 0.26752925f, -0.01394009f, -0.15819131f, -0.00354232f, 
    -0.09782799f, 0.04960979f, 0.12294611f, 0.01230912f, -0.10944603f, -0.05199287f, 0.00863220f, 0.19164559f, 
    -0.03928943f, -0.07401706f, 0.00784784f, -0.00684868f, -0.07995739f, 0.02110688f, -0.01876487f, 0.10108264f, 
    -0.01079281f, 0.01583889f, -0.03293721f, -0.00195253f, 0.06218771f, 0.04938710f, -0.00283561f, 0.02542487f, 
    -0.11890302f, -0.17866068f, -0.05338353f, -0.05522222f, 0.16066751f, 0.00271218f, 0.00945434f, -0.03241799f, 
    -0.00874390f, 0.14608134f, -0.03802128f, 0.04924567f, 0.14982861f, -0.01046319f, 0.00262821f, -0.00644721f, 
    -0.01722562f, -0.08010374f, 0.08024065f, -0.05992695f, 0.04771654f, -0.02955042f, -0.06668696f, -0.17946477f, 
    0.15091337f, 0.08351707f, 0.15666004f, -0.05400644f, -0.29115173f, 0.05998711f, 0.09029582f, 0.01310433f, 
    0.08074858f, -0.13056323f, 0.03776158f, 0.13914979f, -0.20069708f, -0.10251178f, 0.07999475f, 0.04906417f, 
    -0.00106298f, 0.03535856f, -0.06315650f, 0.01433723f, -0.04068761f, 0.01380791f, -0.17497236f, 0.01508343f, 
    -0.00494516f, -0.06021278f, 0.09778752f, 0.11686694f, 0.00469971f, 0.06082261f, 0.16568521f, -0.07635949f, 
    0.00867958f, 0.03632350f, -0.12003064f, 0.02998973f, -0.07622260f, 0.02910140f, 0.02928710f, -0.05424695f, 
    -0.03333036f, 0.13302858f, 0.07414988f, 0.02138997f, -0.07074919f, 0.01224250f, 0.06135390f, -0.06398076f, 
    0.01775884f, -0.02595710f, -0.00245807f, 0.04654775f, -0.01354488f, 0.03472890f, -0.03191146f, -0.10150240f, 
    0.09435959f, 0.04027146f, -0.03784823f, -0.00885333f, 0.01165973f, -0.14175600f, -0.02211654f, 0.00314069f, 
    0.00731857f, -0.17492262f, -0.01767336f, -0.04247548f, -0.01979688f, -0.02008947f, -0.01115652f, -0.02726744f, 
    -0.00910259f, 0.04075987f, -0.07233894f, 0.19959451f, 0.11894467f, 0.07494965f, -0.06663305f, 0.08611463f, 
    0.06836311f, 0.05560727f, -0.14801557f, -0.11523176f, 0.19281548f, -0.10348277f, 0.02598177f, -0.06719366f, 
    0.07672687f, 0.03193784f, -0.06111136f, -0.00786292f, 0.19168286f, 0.11951438f, 0.13090155f, 0.04377066f, 
    -0.05879503f, -0.03884846f, -0.04889572f, 0.01442056f, -0.07252639f, 0.02936596f, 0.02941146f, -0.05810985f, 
    0.09345580f, 0.15766288f, 0.07227470f, 0.02131408f, -0.10752739f, 0.05038819f, 0.03506475f, -0.06091402f, 
    -0.08613975f, -0.07464866f, 0.04047190f, -0.10489257f, 0.02253446f, -0.07991976f, -0.05343138f, -0.04791253f, 
    -0.13593589f, 0.02017915f, -0.07606362f, 0.18820693f, -0.13513727f, -0.00553142f, 0.04763604f, 0.04257728f, 
    0.18445142f, 0.09949944f, 0.12582481f, -0.00533657f, 0.04747124f, 0.00668195f, -0.01535415f, 0.06103858f, 
    0.04253053f, -0.28131062f, 0.03304557f, -0.02660859f, 0.04091753f, 0.10357314f, -0.01815389f, -0.05951790f, 
    -0.03072991f, 0.04689994f, 0.18228972f, 0.13155429f, 0.22682746f, -0.25589979f, -0.00426519f, -0.14031650f, 
    0.01525593f, 0.01127512f, 0.03775882f, -0.08792661f, 0.12510492f, -0.03790020f, -0.00480579f, 0.00273006f, 
    0.03025058f, 0.02188213f, 0.01126436f, 0.05848290f, -0.06521741f, 0.07885577f, 0.08266003f, -0.03129086f, 
    0.03874663f, 0.01512284f, 0.04829820f, -0.06936153f, -0.00273232f, -0.19223776f, 0.09297691f, 0.00333629f, 
    -0.01367618f, 0.00764003f, 0.03522582f, -0.08031306f, -0.03174167f, -0.09349892f, -0.14583455f, 0.02012948f, 
    -0.00869345f, 0.00410676f, 0.03003489f, 0.03069152f, 0.04922181f, 0.05610225f, 0.03921134f, -0.04802584f, 
    -0.10577886f, -0.14336844f, 0.02388102f, 0.01945294f, 0.01217089f, 0.10464681f, -0.00452812f, -0.09628554f, 
    -0.03734450f, 0.11826470f, 0.03377449f, 0.05043849f, 0.01240668f, -0.12772846f, 0.05452670f, 0.00282959f, 
    0.06037193f, -0.15551084f, 0.08183314f, 0.05214618f, -0.03697204f, -0.11056321f, -0.05333974f, 0.10760629f, 
    -0.03328133f, 0.03028096f, -0.04282368f, 0.01640227f, 0.14810275f, 0.15916476f, 0.13713597f, 0.10209239f, 
    0.02637275f, -0.05685104f, 0.03253406f, -0.24621011f, 0.02246109f, -0.19662350f, -0.00788887f, -0.02501900f, 
    0.02290981f, 0.04824496f, -0.03956107f, -0.00307991f, 0.03774059f, -0.16767244f, -0.18211836f, -0.07713252f, 
    0.04557909f, -0.05758613f, 0.05749467f, -0.10091306f, 0.01041451f, -0.02753524f, 0.16855732f, 0.05500094f, 
    -0.05638878f, -0.04965835f, 0.00776524f, 0.02553005f, -0.01298970f, -0.01498254f, -0.08511735f, -0.06898135f, 
    -0.44389614f, 0.03940451f, 0.00222605f, 0.04930776f, 0.05648500f, -0.01848200f, -0.07892133f, 0.08609547f, 
    -0.08140878f, 0.00100080f, -0.08096280f, 0.00578755f, -0.12981062f, 0.06424516f, 0.06528836f, 0.01372985f, 
    0.07398287f, 0.04445212f, 0.01879097f, 0.05151387f, 0.10581598f, 0.07582854f, -0.03477304f, 0.09388085f, 
    -0.08336368f, 0.30898747f, -0.02920605f, 0.04560717f, -0.05803215f, -0.02493942f, 0.09718434f, -0.01719407f, 
    0.03916380f, 0.07606532f, 0.05082505f, -0.04713021f, -0.08038949f, 0.01761239f, -0.00357251f, -0.00011683f, 
    0.01245122f, -0.10473252f, -0.04324093f, -0.09331964f, -0.24508001f, -0.22687015f, -0.04822008f, 0.03698032f, 
    0.02298172f, 0.01487053f, 0.05309189f, 0.07321402f, -0.15768889f, -0.12572283f, -0.33213896f, 0.08460384f, 
    0.07472078f, 0.08570888f, 0.00495226f, -0.07571772f, -0.12029842f, -0.08190756f, -0.09984612f, -0.24372460f, 
    0.03314469f, 0.04247374f, 0.03578312f, 0.05054183f, -0.01341055f, 0.00842339f, 0.06085036f, -0.19083001f, 
    0.25682306f, 0.00343241f, 0.01720759f, -0.02917576f, 0.15077913f, -0.03636343f, 0.08140954f, 0.04438477f, 
    0.04822988f, 0.06682472f, 0.11497153f, 0.08345125f, 0.00408808f, -0.00151257f, -0.01437356f, 0.09274237f, 
    0.12857711f, 0.24863310f, -0.07651588f, -0.00397474f, -0.02390289f, 0.09415047f, -0.07605212f, -0.10239699f, 
    -0.02088965f, 0.03299755f, 0.05348332f, 0.18146014f, -0.17149004f, -0.00210996f, -0.11607828f, 0.08592919f, 
    0.09355444f, -0.01203792f, 0.25381210f, 0.07626271f, -0.10471088f, -0.03117487f, -0.11837108f, 0.03761959f, 
    -0.02230425f, 0.05554843f, 0.02356770f, -0.27907118f, -0.06547906f, -0.32133839f, 0.07611999f, -0.02041052f, 
    0.02250677f, 0.09593958f, 0.03288165f, -0.10191347f, -0.07833549f, -0.00458558f, -0.06439663f, 0.03622317f, 
    0.04960565f, 0.02768579f, -0.02842182f, -0.03566279f, -0.03721574f, 0.02760188f, -0.01062829f, -0.04723521f, 
    0.00076017f, 0.05112494f, 0.02135895f, 0.13957451f, -0.00024839f, 0.02989298f, -0.29300919f, 0.15346169f, 
    0.06550337f, -0.04964981f, -0.04367556f, -0.12242100f, -0.04211724f, 0.09281769f, -0.16111501f, -0.20264652f, 
    0.25244546f, 0.26850635f, -0.06291953f, -0.08140926f, -0.12942205f, 0.05846447f, 0.06647011f, -0.02021025f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07362719f, 0.01827196f, 0.00762839f, 0.04347498f, -0.00421017f, 0.08097798f, 0.03687954f, -0.00672311f, 
    0.14769228f, -0.01175137f, 0.01312700f, 0.03689336f, 0.16940521f, -0.03341084f, 0.16911587f, 0.04306011f, 
    0.05827282f, -0.10322194f, 0.03381216f, 0.05179225f, -0.00161758f, -0.02962803f, -0.05255806f, 0.07043883f, 
    -0.00948218f, -0.02886043f, -0.00812342f, -0.02538352f, -0.03344388f, 0.05162529f, -0.06725493f, 0.00536539f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09761476f, -0.15569815f, -0.11246678f, 0.41914105f, -0.04857795f, -0.24874105f, 0.39325956f, 0.26425114f, 
    -0.10486194f, 0.07870881f, -0.02614499f, 0.08624531f, 0.13214743f, 0.16697134f, 0.06858266f, 0.30712417f, 
    -0.00522227f, 0.12161239f, 0.01575930f, -0.10941722f, 0.10082222f, -0.11856931f, 0.00971310f, -0.00036534f, 
    0.13691111f, 0.08669699f, -0.25271398f, 0.05615100f, 0.05498915f, 0.06901930f, 0.29970503f, -0.17952502f, 
    0.11835922f, 0.14297722f, 0.09718383f, 0.14529672f, 0.12334187f, 0.22476934f, -0.13407496f, 0.25508553f, 
    -0.19399822f, 0.11578848f, -0.10341295f, -0.19604956f, -0.01857699f, 0.07733295f, -0.11414574f, 0.32683867f, 
    -0.22195823f, 0.15316662f, 0.11364928f, 0.06445749f, -0.07158709f, 0.04633001f, -0.10274572f, -0.18979703f, 
    0.01901818f, 0.02249457f, 0.24342479f, -0.09944083f, 0.17295246f, 0.30321625f, -0.14380115f, 0.03821900f, 
    0.30111936f, 0.02962742f, -0.09586719f, 0.04520547f, -0.16811962f, -0.32629889f, 0.01090438f, 0.32127944f, 
    0.08947625f, -0.04739957f, -0.11171117f, -0.15395723f, 0.01277241f, 0.11482706f, 0.13461365f, 0.24949697f, 
    -0.19007042f, 0.07384891f, 0.14546758f, -0.06295193f, 0.27327535f, -0.05785039f, -0.08601566f, 0.20326522f, 
    0.05679201f, -0.09213575f, -0.18710619f, 0.03798585f, 0.13839349f, 0.01700259f, 0.38854063f, -0.08068465f, 
    -0.15046111f, 0.01480286f, 0.09619828f, -0.09163812f, -0.00509249f, 0.09371765f, 0.15131462f, -0.02834386f, 
    -0.01477031f, -0.14888766f, -0.12232300f, 0.10504801f, -0.05819333f, 0.14103688f, 0.00920786f, -0.05257500f, 
    -0.03992045f, 0.02969942f, -0.10322785f, -0.06668736f, -0.00193259f, 0.04011591f, 0.09747764f, -0.06021408f, 
    -0.15080561f, -0.11766184f, -0.17978832f, -0.17171843f, -0.11676635f, 0.04735185f, -0.10040328f, 0.05816696f, 
    0.27666390f, -0.02581292f, -0.13713254f, 0.12663023f, 0.09810944f, -0.08291823f, 0.02113511f, 0.03470693f, 
    -0.33375987f, 0.28481895f, -0.00032631f, 0.25968379f, 0.11116669f, -0.17090653f, -0.03739387f, 0.34342223f, 
    0.37585139f, -0.21006216f, -0.07631383f, -0.06084653f, -0.06062116f, 0.02847622f, 0.11730446f, 0.13754904f, 
    -0.05476028f, 0.10607798f, -0.13457711f, 0.11762802f, 0.14182667f, 0.07804415f, -0.03066672f, 0.04553581f, 
    0.21661258f, 0.09305098f, 0.00754641f, -0.14671563f, -0.00897459f, 0.06994009f, -0.21024485f, -0.28842363f, 
    0.30509800f, -0.17284383f, -0.17581634f, 0.02815899f, 0.06032709f, -0.05646986f, 0.19129321f, 0.26184788f, 
    0.16165619f, -0.29625762f, 0.17017788f, 0.21511380f, 0.02844917f, -0.14480773f, -0.17797756f, 0.14965242f, 
    -0.24931829f, 0.07079171f, 0.02635086f, -0.11819371f, 0.13644704f, 0.22029176f, -0.24133684f, -0.09808759f, 
    -0.16122381f, 0.01595650f, 0.01621627f, -0.17519316f, 0.03298596f, -0.02659271f, 0.02960086f, -0.02353583f, 
    0.07616271f, 0.00915199f, -0.07886630f, 0.20202032f, -0.05355354f, -0.11256247f, 0.07243802f, -0.10687455f, 
    -0.03119784f, -0.07325725f, -0.17570829f, -0.10433650f, -0.08995893f, -0.06304264f, -0.14209698f, -0.22595513f, 
    -0.01078321f, 0.14650004f, 0.01144693f, -0.14772405f, 0.05662064f, -0.02775035f, 0.00145203f, 0.05376529f, 
    0.14785106f, 0.04561124f, -0.01593215f, -0.15278272f, -0.04056056f, 0.33786878f, -0.32218084f, -0.17555737f, 
    0.09444029f, 0.22159880f, -0.13399494f, -0.07457542f, 0.22122248f, -0.04430072f, -0.11702917f, 0.11403864f, 
    -0.33822584f, -0.13979366f, 0.04122291f, 0.23226136f, -0.24712208f, -0.04609276f, -0.18190838f, 0.06502676f, 
    -0.08265412f, 0.04978377f, 0.09776985f, 0.09017786f, 0.07586785f, 0.29195496f, -0.06467746f, 0.22123867f, 
    0.01007115f, 0.14142132f, 0.01311878f, 0.00229786f, -0.13351491f, -0.10148306f, -0.04638641f, 0.24183330f, 
    -0.28496331f, 0.22586213f, 0.05221602f, 0.06850111f, 0.02507265f, -0.12116115f, 0.14742881f, -0.26091903f, 
    0.16801251f, -0.05288057f, 0.05720196f, -0.08497548f, -0.04232592f, -0.13578458f, -0.05332641f, 0.18879285f, 
    -0.38745451f, 0.04483978f, -0.14491227f, -0.08128492f, 0.12011647f, -0.16658901f, -0.15262954f, 0.09321750f, 
    0.21995267f, 0.14135866f, 0.07465703f, -0.04852134f, 0.18590988f, 0.10242135f, -0.12892939f, -0.14331460f, 
    -0.14707288f, 0.13522145f, 0.12162261f, 0.13755026f, 0.28280008f, 0.08467118f, -0.05318763f, 0.24764584f, 
    0.01727184f, -0.26677486f, 0.04898940f, 0.08040950f, -0.44652185f, 0.03785494f, 0.10510167f, 0.17591906f, 
    0.27372697f, 0.05245408f, 0.10878994f, 0.09286699f, -0.09724282f, 0.34529641f, -0.30707866f, -0.08712032f, 
    0.28663498f, 0.14035983f, 0.16519146f, 0.33342972f, -0.11857535f, 0.10108040f, 0.08826362f, 0.21108329f, 
    -0.12341776f, 0.17262881f, -0.05705807f, 0.19332176f, -0.05911690f, 0.05062844f, -0.21723020f, 0.10221857f, 
    -0.16962956f, -0.11151130f, -0.12408052f, -0.12661038f, 0.07852889f, 0.12306352f, 0.17198659f, -0.09166194f, 
    0.32489991f, 0.06375841f, 0.19428474f, -0.15043783f, 0.10064716f, 0.12378884f, 0.16439545f, 0.25389740f, 
    -0.19776349f, 0.14219327f, 0.12270783f, 0.03083883f, -0.09904822f, -0.19272061f, 0.22217716f, -0.03976702f, 
    0.25104195f, 0.08050317f, -0.02785452f, -0.11444128f, -0.10977513f, 0.08852731f, 0.20939443f, 0.05202419f, 
    -0.28360665f, 0.18678196f, -0.04648393f, 0.17738312f, 0.12080830f, -0.11835419f, 0.03744127f, 0.53313816f, 
    0.24989079f, -0.00287434f, -0.35053855f, 0.15456489f, -0.01990676f, 0.10300451f, 0.36372808f, -0.26789528f, 
    -0.27906540f, -0.02535422f, 0.07533747f, 0.06781596f, 0.07282405f, -0.09888977f, -0.28002131f, -0.02441308f, 
    0.23908335f, 0.16841915f, 0.07923385f, -0.15162791f, 0.22465450f, -0.15187046f, 0.24338488f, -0.08802909f, 
    0.15147863f, -0.18170922f, 0.05497056f, 0.28790438f, 0.00555609f, 0.06296702f, 0.10660399f, -0.11342028f, 
    0.11525737f, -0.09426634f, 0.30586320f, -0.13934943f, -0.09415988f, 0.20626816f, -0.41474235f, -0.14059772f, 
    0.09066492f, 0.01273009f, -0.11900128f, 0.16839693f, -0.07167469f, -0.24380216f, 0.05297715f, -0.04163218f, 
    -0.21301286f, 0.21845791f, 0.10993411f, 0.17041366f, -0.08433842f, -0.09915946f, -0.03189282f, 0.02781592f, 
    -0.27524215f, 0.56812119f, 0.04120733f, -0.44519177f, -0.13846865f, -0.05655237f, -0.00751176f, -0.01165104f, 
    0.07126126f, 0.10529996f, -0.35506278f, -0.03150961f, -0.03289304f, 0.09764849f, 0.11713940f, -0.09407518f, 
    -0.11013496f, -0.13037984f, 0.02051720f, -0.10196111f, 0.00453555f, -0.04447338f, -0.11584341f, -0.08867659f, 
    -0.12184848f, 0.08827079f, 0.03744196f, 0.00850422f, -0.17854749f, 0.14892247f, -0.13990891f, 0.09699014f, 
    -0.13479945f, 0.06251371f, -0.08894765f, 0.09782080f, -0.21532096f, -0.16960861f, 0.17027913f, -0.09573045f, 
    0.00355088f, 0.02606521f, -0.09661421f, 0.02353369f, 0.11054254f, 0.09693753f, -0.08909126f, 0.10082778f, 
    -0.25736395f, -0.00719621f, -0.14161226f, -0.11194830f, 0.13340251f, 0.18727212f, -0.51579934f, -0.23543610f, 
    -0.03249481f, -0.34318307f, 0.12154429f, 0.07775100f, 0.23680559f, 0.01882225f, 0.30780801f, -0.04865812f, 
    0.08822799f, -0.35747615f, -0.10877134f, -0.22195956f, 0.01432758f, 0.04796406f, -0.12756452f, -0.05496358f, 
    0.28498727f, 0.10654157f, 0.31228319f, -0.01018855f, -0.11093464f, -0.01337395f, -0.06221021f, 0.20583372f, 
    -0.06067256f, 0.11215453f, 0.06733831f, 0.02829163f, 0.01443272f, -0.14722127f, 0.09910223f, -0.10480112f, 
    -0.10645933f, 0.07433850f, -0.02057114f, -0.07986300f, -0.01836482f, 0.08231619f, -0.06616379f, -0.06928398f, 
    -0.06944874f, -0.05887807f, -0.01598600f, -0.10019510f, -0.13258009f, -0.17419453f, 0.06010231f, 0.13519596f, 
    0.01069174f, -0.06482647f, 0.02113186f, 0.03354811f, 0.12970808f, 0.04602671f, -0.08501737f, 0.14500512f, 
    0.27610070f, -0.03986289f, -0.13384259f, 0.32737800f, 0.16932765f, -0.28041470f, 0.34397247f, 0.21823622f, 
    -0.14056268f, -0.10650332f, -0.05899373f, 0.29776749f, 0.13336284f, -0.04474277f, 0.15079504f, 0.09278349f, 
    0.09291165f, -0.11489794f, -0.05465269f, -0.22582366f, 0.03901735f, 0.06599488f, -0.06869794f, -0.27312645f, 
    0.40434325f, 0.04103518f, 0.12163923f, 0.16878994f, 0.00353281f, -0.15592976f, 0.01023712f, -0.02227734f, 
    0.28723216f, -0.06289208f, 0.03679620f, 0.16980501f, 0.15257275f, -0.06360709f, -0.11102752f, 0.04227591f, 
    -0.23457851f, 0.26251316f, 0.18645267f, -0.00149517f, 0.14319776f, 0.02318577f, -0.20294639f, 0.20246856f, 
    0.15400761f, 0.31353727f, 0.12283134f, -0.14710473f, 0.09534094f, -0.09733672f, -0.03780168f, -0.31049073f, 
    -0.13118330f, 0.11451206f, 0.51579660f, 0.11624837f, -0.01938081f, 0.28317943f, -0.13486949f, 0.24984644f, 
    0.05615805f, -0.09374420f, -0.07236300f, -0.37426123f, 0.13592532f, 0.07249632f, 0.05280270f, -0.27139345f, 
    0.43838033f, -0.46608561f, -0.13933513f, 0.13219970f, 0.01565129f, -0.14704557f, 0.26906866f, -0.11618955f, 
    0.21750529f, -0.16904677f, -0.11839682f, 0.27175620f, 0.20661779f, 0.09388789f, 0.05856291f, -0.05994854f, 
    -0.00905941f, -0.11474747f, 0.08095717f, -0.04166306f, 0.02832016f, 0.20871563f, -0.22499506f, 0.08908250f, 
    -0.00587010f, 0.09947638f, 0.17539126f, 0.30440384f, 0.02136009f, -0.06853355f, 0.20573664f, 0.22619586f, 
    -0.24403027f, -0.36893430f, -0.09688561f, 0.30457887f, -0.10020795f, 0.17042029f, 0.15453836f, 0.05003731f, 
    0.05085511f, 0.12239207f, 0.11921066f, -0.44182250f, 0.17064761f, -0.06394182f, 0.01549429f, -0.45118999f, 
    0.12696858f, 0.16552630f, 0.38885111f, 0.10893158f, -0.06655153f, 0.24188627f, 0.20501433f, 0.05270996f, 
    -0.08316150f, 0.11313535f, 0.06783167f, 0.33256102f, 0.08792877f, 0.40994734f, 0.24843845f, 0.40748966f, 
    0.02057439f, 0.35009867f, 0.07661522f, -0.12352575f, -0.07173098f, 0.05245685f, -0.23966631f, 0.09087692f, 
    0.26359823f, -0.36043602f, 0.05807470f, 0.15624166f, -0.01797486f, -0.00988802f, 0.11071435f, -0.34803826f, 
    0.05576791f, 0.09379737f, -0.00419446f, 0.01935289f, -0.09518001f, -0.29473791f, 0.16580407f, 0.15433250f, 
    -0.18938917f, 0.01493886f, 0.09879345f, 0.09571484f, -0.07862253f, -0.22971246f, -0.45772776f, 0.20120595f, 
    -0.02252182f, -0.20725362f, 0.00188217f, -0.32718226f, 0.25977024f, 0.13180476f, 0.27071887f, -0.05413417f, 
    0.17085043f, -0.04978884f, 0.15014936f, -0.05340129f, 0.32434443f, 0.12310453f, 0.06898685f, 0.04192857f, 
    0.34577981f, -0.05719549f, 0.40045106f, -0.17388935f, -0.02686486f, 0.29244974f, -0.00511027f, 0.10112264f, 
    0.01685881f, -0.05877754f, 0.08732297f, -0.04847666f, -0.13310231f, 0.07239845f, -0.07840248f, -0.13743667f, 
    -0.12146703f, 0.00546488f, -0.05452969f, -0.21479717f, -0.17358044f, 0.05057965f, 0.18271486f, -0.10075991f, 
    0.08637251f, -0.14861207f, -0.03544703f, -0.05691085f, 0.03840984f, -0.07865638f, 0.05182153f, 0.23021993f, 
    0.03262790f, -0.16680142f, 0.07217786f, 0.17739458f, -0.13485488f, -0.25139269f, 0.16260022f, 0.13714856f, 
    -0.08761058f, 0.13033056f, -0.09492478f, 0.26138258f, 0.15981656f, -0.25893611f, -0.00880613f, -0.01650036f, 
    -0.25801408f, -0.20549221f, 0.13284612f, 0.34671485f, -0.03664411f, -0.06608227f, 0.20894630f, -0.00201995f, 
    0.57664609f, -0.28408700f, -0.02064371f, -0.03772679f, 0.26596245f, 0.01947056f, 0.18340093f, -0.01204198f, 
    0.31951597f, -0.15291229f, 0.20109481f, 0.12620363f, -0.10796406f, -0.19560023f, -0.06741362f, -0.02848491f, 
    0.40134326f, 0.07291671f, -0.11654494f, -0.10260070f, 0.14109795f, 0.02439385f, 0.04202432f, 0.04237073f, 
    0.05321730f, 0.17421056f, -0.13476786f, 0.26647764f, 0.14341927f, -0.16734628f, 0.10438317f, 0.41743174f, 
    0.16890556f, -0.18364140f, -0.01148608f, -0.13247849f, -0.17854628f, 0.06939530f, 0.01409113f, 0.46482760f, 
    -0.09062178f, -0.15540595f, 0.11687623f, 0.12273508f, 0.14835510f, 0.00677204f, -0.12570234f, -0.18842842f, 
    -0.08140959f, 0.13189279f, 0.09115720f, -0.10509995f, -0.14068718f, 0.13949008f, 0.02753837f, -0.25944006f, 
    -0.11026157f, 0.41285697f, -0.07831969f, 0.14850952f, 0.25136793f, 0.15603332f, 0.05442871f, -0.07571213f, 
    -0.08341715f, -0.17137587f, 0.05020354f, 0.23841822f, -0.26385558f, -0.10079154f, -0.10805734f, 0.03855583f, 
    -0.10189744f, -0.06362294f, 0.24160099f, -0.09572299f, -0.00364922f, 0.40011710f, -0.36935648f, -0.06251325f, 
    -0.03062418f, -0.01130331f, 0.10718597f, 0.06010597f, 0.11485469f, 0.33888412f, -0.03077202f, -0.25506455f, 
    -0.25928622f, 0.14555368f, -0.04347313f, 0.44733158f, 0.08406439f, -0.07094781f, -0.16647990f, 0.22090258f, 
    0.17642812f, 0.02702276f, -0.05107040f, -0.02933021f, -0.21279003f, -0.10926756f, 0.00769994f, 0.01244302f, 
    0.12633424f, -0.03367648f, 0.19879261f, 0.14583835f, 0.06159967f, 0.18759063f, -0.24430732f, 0.20010644f, 
    0.18611968f, -0.08382014f, -0.01102735f, 0.06826270f, -0.12171492f, 0.14931759f, -0.01147372f, -0.30567420f, 
    -0.19656715f, 0.34862486f, 0.14543286f, 0.35426673f, 0.21479103f, -0.08647618f, -0.04152178f, 0.14929873f, 
    0.36222193f, 0.06363846f, 0.02473148f, 0.17803730f, -0.16601327f, -0.07746700f, -0.20455113f, 0.17598088f, 
    -0.30743763f, 0.00187040f, -0.00997569f, 0.11305968f, 0.05180843f, -0.04352691f, -0.39184552f, 0.10780283f, 
    -0.37121159f, 0.12821603f, -0.12002427f, 0.02549269f, 0.16672742f, 0.31048730f, 0.17846376f, -0.12058527f, 
    -0.10553741f, -0.28031918f, 0.03953784f, 0.18300863f, 0.11086462f, 0.04847092f, 0.17393506f, -0.28377765f, 
    0.28021321f, 0.40644729f, 0.07534704f, 0.00504756f, 0.16536760f, -0.01356531f, -0.01016213f, -0.43608785f, 
    0.04133054f, 0.09635787f, 0.00807577f, -0.06483873f, 0.13452296f, -0.00901764f, 0.19441110f, 0.27030742f, 
    0.09696496f, -0.12316597f, -0.03546759f, 0.22782692f, -0.16305707f, 0.27287039f, 0.19454350f, 0.07125546f, 
    -0.08606237f, -0.18218556f, -0.08416891f, 0.28215423f, -0.01436059f, -0.07932841f, -0.05915820f, 0.20415114f, 
    0.03174501f, 0.03935811f, -0.12586859f, -0.30438584f, -0.04641934f, -0.13109317f, 0.13462816f, -0.25879046f, 
    0.25400314f, -0.01651766f, 0.36092722f, 0.05449842f, -0.09887253f, 0.00802810f, 0.04126627f, 0.15575697f, 
    -0.15213083f, 0.17155570f, 0.15251996f, -0.22631550f, -0.00869629f, 0.22796254f, -0.21447855f, -0.02208728f, 
    0.31490201f, 0.01862147f, -0.13898854f, -0.06710380f, 0.14400876f, -0.16785045f, -0.02049218f, 0.02925519f, 
    -0.19325554f, 0.32157177f, -0.06375129f, 0.23826021f, -0.02296733f, -0.09601261f, 0.04841077f, -0.03560362f, 
    -0.29306200f, -0.12993203f, -0.01113492f, 0.00578309f, 0.15323137f, 0.13502988f, -0.08026052f, 0.41540676f, 
    0.30661124f, 0.16309521f, -0.08784797f, -0.32359648f, -0.10413012f, 0.21928930f, 0.24221897f, -0.33028483f, 
    0.00100552f, 0.28311589f, -0.09333047f, 0.18080378f, 0.06241050f, -0.09569476f, -0.08117227f, 0.25905129f, 
    0.50418741f, -0.29559135f, 0.16325942f, 0.32934639f, 0.08153729f, -0.01443148f, -0.07630219f, 0.36044973f, 
    -0.26054409f, 0.08358683f, -0.17861852f, -0.06406928f, 0.12818378f, -0.10304919f, -0.21382810f, -0.15617649f, 
    0.26207793f, 0.01146013f, -0.13873264f, 0.20717013f, 0.04591343f, 0.02119213f, 0.48184758f, 0.27001768f, 
    0.07604033f, -0.02118542f, -0.13706917f, -0.14394185f, -0.06825583f, 0.10975467f, 0.01555250f, 0.23901466f, 
    0.09296628f, 0.04202698f, 0.15584494f, -0.04188151f, 0.21169245f, 0.00426365f, 0.15246004f, 0.16737036f, 
    -0.22354241f, -0.15098576f, -0.25746471f, -0.13939193f, -0.17234805f, 0.04096582f, 0.04440401f, -0.13659255f, 
    0.35019851f, 0.04871922f, -0.04525346f, 0.09331333f, 0.02892376f, -0.33510470f, -0.01513826f, 0.23117974f, 
    0.05490258f, -0.16198339f, 0.05666170f, 0.14417554f, 0.10152561f, 0.11058112f, -0.09778348f, 0.29885325f, 
    0.23166683f, -0.07749090f, -0.01917519f, -0.07999418f, 0.27172762f, 0.08515630f, -0.13698137f, 0.29133391f, 
    0.17003846f, -0.09418337f, 0.17494197f, 0.16543867f, -0.00028998f, 0.18269794f, -0.34430087f, -0.26531434f, 
    0.25032780f, -0.00450341f, -0.13733576f, 0.14384530f, 0.10863589f, 0.01507359f, 0.24444516f, -0.03440087f, 
    -0.09407113f, -0.08411818f, 0.14163494f, 0.01620511f, 0.15452546f, -0.11638637f, 0.21430488f, 0.27155432f, 
    -0.56473362f, 0.34644383f, 0.13434054f, -0.31283826f, -0.11257405f, 0.15373488f, 0.07218641f, 0.19564296f, 
    -0.03004484f, -0.07261705f, -0.43611285f, 0.08530863f, -0.03286131f, 0.01701990f, 0.55041319f, 0.16138072f, 
    -0.14833860f, 0.15872250f, 0.05331497f, 0.08129255f, -0.02371326f, 0.10025550f, -0.03951483f, -0.19363512f, 
    -0.03933470f, 0.03681140f, 0.05961872f, 0.44451073f, 0.13123208f, -0.09389432f, -0.20247038f, 0.10681579f, 
    -0.05789203f, 0.38802212f, 0.15431137f, 0.17155397f, -0.19030708f, 0.15401781f, 0.03626155f, -0.15982918f, 
    -0.06748582f, -0.10102695f, 0.28474173f, -0.15071933f, 0.10983083f, 0.16679870f, 0.06437684f, 0.39455056f, 
    0.05172815f, -0.12893063f, -0.14324287f, -0.18581209f, -0.09346761f, -0.18225181f, -0.14423361f, 0.12199839f, 
    -0.12657899f, -0.14651158f, -0.11394862f, -0.02627876f, 0.11135156f, -0.06146878f, -0.12549002f, 0.02402680f, 
    -0.14921880f, -0.17097236f, -0.09307990f, 0.04205647f, -0.00454366f, 0.06687940f, 0.08414037f, -0.05981399f, 
    0.07037498f, -0.05631080f, -0.08679529f, -0.11968219f, -0.10990100f, -0.09656961f, -0.04896343f, -0.14646603f, 
    -0.15127048f, 0.04591279f, -0.12401716f, -0.11711385f, 0.08908015f, -0.15584138f, -0.06415028f, 0.11595036f, 
    -0.09866600f, -0.06142676f, 0.05903513f, 0.15122718f, -0.13828412f, 0.12040996f, -0.16296111f, 0.13292167f, 
    -0.03213522f, 0.07186281f, 0.03705791f, -0.05855779f, -0.12060281f, 0.12326913f, -0.16637783f, -0.04042927f, 
    0.05413658f, -0.17586438f, -0.18187682f, -0.02922105f, 0.07001409f, 0.16093862f, -0.15169232f, 0.10090634f, 
    -0.18044417f, 0.14225958f, 0.01118147f, -0.13583729f, 0.17293735f, 0.05929269f, 0.13028525f, 0.07055842f, 
    0.05149246f, -0.09695526f, 0.04635603f, 0.17058274f, -0.02290190f, 0.16749257f, -0.17929846f, -0.12934692f, 
    -0.06315718f, -0.08025766f, 0.07071395f, -0.18127742f, -0.07366341f, 0.03171524f, -0.13637547f, 0.10000709f, 
    0.09374477f, -0.01287177f, -0.11786412f, 0.15745328f, 0.02324439f, -0.03467665f, -0.12080397f, 0.03071163f, 
    0.33300248f, 0.09066067f, -0.05826472f, 0.08652629f, -0.12380862f, 0.22180653f, 0.07063150f, -0.11616876f, 
    -0.33145416f, 0.10862812f, 0.09913700f, 0.15739107f, 0.06385230f, 0.03874743f, 0.12900814f, 0.30492383f, 
    0.29331356f, -0.38606521f, 0.17744967f, -0.11431986f, 0.01050670f, -0.11914225f, 0.16521490f, -0.23820379f, 
    0.26666042f, -0.09696233f, 0.38637665f, -0.18930711f, -0.13659072f, -0.18627878f, -0.16745865f, 0.21937057f, 
    0.00295801f, -0.05795817f, -0.12338272f, -0.11097357f, -0.02031219f, 0.25936773f, -0.37142885f, -0.28845060f, 
    0.30240104f, -0.35802487f, 0.13200741f, -0.04696511f, 0.14123617f, -0.13608451f, 0.29367629f, -0.20038366f, 
    0.08445525f, -0.21381396f, 0.11570066f, 0.22034912f, 0.18888773f, 0.09582548f, 0.04047399f, -0.06250415f, 
    0.01685387f, -0.15088639f, -0.15206142f, -0.05818811f, -0.11643769f, 0.03389382f, 0.12376308f, 0.13635644f, 
    0.18572591f, -0.12295648f, 0.09780696f, -0.06102996f, 0.01545755f, -0.04235703f, 0.32105759f, 0.21480106f, 
    0.06650755f, 0.06609438f, 0.10052858f, 0.12832294f, -0.06524115f, -0.16886672f, 0.26317072f, 0.08343045f, 
    -0.05008907f, -0.02065059f, -0.09691603f, 0.04926573f, 0.24431033f, -0.07895927f, 0.03073915f, 0.00122217f, 
    -0.13794562f, -0.03464432f, -0.19444515f, 0.09912129f, 0.15960996f, 0.13454872f, 0.06594013f, -0.33850488f, 
    -0.34172100f, -0.10170332f, 0.00280236f, 0.22812660f, -0.12014372f, 0.42442304f, 0.05065281f, 0.01466597f, 
    -0.07753325f, 0.18139075f, -0.13774543f, 0.08028544f, -0.10415879f, -0.11009640f, 0.11140255f, -0.12809293f, 
    -0.02296731f, 0.34538499f, 0.14245254f, -0.08245447f, 0.21195401f, 0.13161689f, 0.05533045f, -0.21877608f, 
    0.25546685f, -0.17619500f, -0.00348616f, 0.09385370f, -0.16651323f, -0.27462167f, 0.28069228f, -0.10715092f, 
    0.26732171f, -0.08286110f, 0.08457258f, 0.26854354f, 0.18004085f, 0.21472076f, -0.41599697f, 0.22564544f, 
    0.04896393f, 0.17114586f, 0.16523048f, -0.33842427f, -0.09440132f, 0.11248095f, -0.08263078f, 0.10897945f, 
    -0.24602251f, 0.38088277f, -0.10554157f, -0.13830897f, 0.01947049f, 0.10438874f, -0.09228589f, -0.30107346f, 
    0.01385179f, -0.11154182f, 0.43174499f, 0.14682253f, -0.07465825f, 0.18647428f, 0.05368433f, 0.28123450f, 
    0.02977021f, -0.07664843f, -0.08022647f, 0.09233806f, 0.04451959f, 0.12150605f, -0.05605966f, -0.15596445f, 
    -0.00146203f, -0.16453531f, -0.07869858f, 0.10004118f, -0.00138662f, 0.08154064f, 0.29962805f, 0.21876986f, 
    -0.16387619f, 0.13366541f, -0.02604702f, -0.22047915f, -0.25978205f, 0.10681914f, 0.10101701f, -0.00792935f, 
    -0.00501048f, -0.09294140f, -0.08413681f, 0.08934883f, -0.16755460f, -0.16143484f, -0.03343187f, 0.35758698f, 
    -0.00700644f, 0.06013812f, -0.10958245f, -0.20733027f, -0.11176720f, 0.17526819f, -0.33833984f, -0.14835456f, 
    0.32912555f, -0.33450142f, -0.02025875f, 0.03751263f, 0.16859792f, -0.14154242f, 0.08932183f, -0.08878196f, 
    -0.05741756f, 0.01168533f, -0.12133114f, 0.02132534f, 0.04005270f, -0.00516623f, 0.13345280f, -0.31684566f, 
    0.08775310f, -0.12374873f, 0.24224162f, -0.16376700f, -0.00584289f, 0.25114161f, -0.12823129f, 0.22531043f, 
    -0.11429717f, -0.12634498f, 0.10589726f, 0.39258030f, -0.12260354f, -0.06316564f, -0.16780204f, 0.23555544f, 
    0.19963665f, -0.18599445f, 0.17253083f, -0.05082526f, 0.14932664f, 0.01054844f, 0.26281685f, -0.04033944f, 
    -0.41143280f, 0.08573002f, 0.09321672f, -0.31186423f, 0.02063836f, 0.14401756f, -0.11083405f, 0.22993073f, 
    0.45092720f, -0.02251789f, -0.13205793f, 0.10945286f, -0.07927390f, -0.05902484f, 0.50602388f, -0.02709388f, 
    0.03013377f, -0.02414631f, 0.01501437f, 0.40632191f, -0.01597705f, -0.08560617f, 0.09329066f, 0.11054825f, 
    -0.16991115f, 0.12909862f, -0.01330354f, 0.35907239f, 0.18455280f, 0.10292146f, 0.11911747f, 0.10795352f, 
    -0.19350620f, -0.05099604f, -0.00645343f, -0.35378382f, -0.12553898f, 0.01801981f, -0.12137526f, -0.28361961f, 
    0.48726192f, -0.17541052f, 0.36746308f, -0.09159701f, 0.04252470f, 0.04653101f, 0.02716810f, 0.21991719f, 
    0.13241446f, 0.07900050f, 0.04927520f, -0.10553972f, -0.15776880f, 0.24547996f, -0.23496276f, 0.12070966f, 
    -0.07102171f, 0.21987586f, 0.08104920f, -0.42404881f, 0.20137058f, -0.04972408f, -0.16937412f, -0.09520758f, 
    -0.28948712f, 0.54989243f, -0.16146189f, 0.14678524f, 0.21186201f, -0.02157550f, -0.03170834f, 0.12529171f, 
    -0.43974125f, -0.16220348f, 0.20258148f, -0.13743703f, -0.16402997f, 0.17539816f, 0.09087499f, 0.35535353f, 
    0.03496635f, -0.10811830f, 0.17137861f, -0.18132018f, 0.06924679f, 0.05216556f, -0.28882641f, -0.01308560f, 
    0.32606104f, -0.12513210f, 0.03197915f, -0.44574404f, 0.17373380f, -0.01719937f, 0.24334267f, -0.23743293f, 
    -0.13034409f, -0.06219828f, 0.03671581f, 0.26898170f, 0.30371773f, -0.03029644f, 0.04200812f, 0.07655290f, 
    -0.02524973f, 0.02947358f, -0.18875080f, -0.04618181f, 0.07546290f, 0.13137741f, 0.06390963f, -0.07924866f, 
    0.32160211f, -0.02915747f, 0.03808231f, 0.08546007f, 0.10813036f, -0.07552245f, -0.15233970f, -0.15732852f, 
    -0.04144046f, 0.20951283f, -0.02909604f, -0.30698964f, 0.09452502f, 0.04536028f, 0.21762940f, 0.37324974f, 
    0.23504576f, -0.20631053f, 0.03045506f, 0.08316268f, 0.11867388f, 0.03778855f, -0.19627194f, -0.27206561f, 
    -0.02684506f, 0.08457606f, -0.10605071f, 0.07483787f, 0.10453014f, 0.11439607f, -0.19580759f, -0.36193815f, 
    -0.23552650f, -0.16831563f, 0.03096686f, -0.32918715f, -0.10537253f, 0.07241562f, -0.26859754f, -0.15960714f, 
    0.39289066f, -0.24109428f, 0.05195066f, -0.27607965f, 0.13512209f, -0.17029190f, 0.22385705f, -0.25811401f, 
    0.00008122f, 0.20466295f, 0.09324481f, 0.01219022f, 0.41938144f, 0.07166664f, -0.12302941f, -0.03271632f, 
    -0.02296968f, -0.05733842f, 0.16069034f, -0.01214917f, -0.15102482f, 0.12981699f, -0.09718700f, -0.17501682f, 
    0.32681677f, -0.07845729f, 0.02650285f, -0.12991631f, 0.07272439f, 0.11383734f, -0.02991715f, -0.06130155f, 
    0.24721950f, 0.16426203f, -0.12978698f, -0.17428248f, -0.11177457f, 0.06786396f, -0.03256210f, 0.08737266f, 
    0.27066502f, 0.28462443f, -0.17794172f, 0.34522596f, 0.25656003f, 0.11806738f, 0.12342865f, 0.10996465f, 
    -0.36260426f, 0.10499798f, 0.29051760f, -0.06122450f, 0.13164550f, 0.00962299f, -0.35369229f, 0.23564547f, 
    0.20947178f, -0.01509610f, 0.06502066f, 0.20155790f, 0.07600560f, -0.16311356f, 0.31418249f, 0.41847566f, 
    0.08084545f, 0.18845382f, -0.10074616f, 0.02087903f, -0.18055755f, -0.16411708f, 0.12411783f, 0.01530892f, 
    0.02564333f, -0.03064090f, 0.16832873f, 0.23110524f, 0.35659939f, 0.01576661f, -0.11135904f, -0.01156235f, 
    -0.19022422f, 0.15220539f, -0.03474831f, -0.08335642f, 0.02931325f, 0.26511055f, -0.01280773f, -0.34164813f, 
    0.16095671f, 0.09061150f, 0.07401231f, -0.00400884f, 0.02805237f, 0.22587766f, 0.23600805f, -0.03734342f, 
    0.10207436f, 0.43548796f, -0.11921449f, 0.28203034f, 0.13243300f, 0.11406580f, -0.08580065f, 0.17279929f, 
    0.09384865f, 0.35900694f, 0.03745127f, -0.14757645f, -0.15278023f, 0.13257287f, 0.00851887f, 0.53560781f, 
    0.08212200f, 0.10753319f, -0.36063904f, -0.04293968f, -0.13432235f, -0.21474676f, 0.34524983f, 0.03774257f, 
    0.07544954f, -0.10606094f, 0.14814438f, 0.04562862f, -0.14183694f, -0.15905656f, 0.08892345f, 0.02686551f, 
    0.37186792f, -0.29150265f, 0.06854070f, -0.01572094f, 0.00392606f, -0.14705482f, 0.28796712f, -0.14377694f, 
    -0.12225111f, 0.05131691f, -0.05758389f, -0.11586022f, 0.01142241f, -0.05704278f, 0.15407489f, -0.10138641f, 
    0.09703019f, 0.02236438f, -0.17620943f, 0.10486253f, -0.06169607f, -0.04379660f, -0.07700230f, -0.25780895f, 
    0.02439635f, 0.07461061f, 0.09511331f, 0.07437853f, -0.08249485f, -0.09056338f, -0.09144569f, 0.17398138f, 
    0.27763569f, -0.05693728f, 0.10666774f, -0.26488811f, 0.03822105f, -0.03529856f, 0.34431550f, 0.15110992f, 
    0.12251285f, -0.27146071f, 0.05021168f, -0.04693188f, 0.12093075f, -0.00610477f, 0.15560009f, 0.32784206f, 
    0.02876913f, -0.02224033f, -0.27901235f, -0.15896605f, -0.11783500f, -0.19554952f, -0.08100693f, -0.12823978f, 
    0.24986757f, 0.06842411f, 0.04120231f, 0.26805288f, 0.02509874f, -0.09572966f, 0.36559364f, -0.01144442f, 
    -0.20934154f, 0.34737712f, 0.10324961f, -0.07970537f, -0.16597816f, 0.07943231f, 0.01473830f, 0.11323547f, 
    -0.02783708f, 0.47945210f, 0.14095131f, -0.08941110f, 0.17150931f, -0.03775682f, -0.01674641f, 0.31214720f, 
    -0.18991901f, 0.13757376f, -0.29250434f, 0.04370809f, 0.15179889f, -0.04895970f, 0.12045340f, 0.12615228f, 
    -0.14580122f, 0.07326405f, -0.14906384f, -0.12536037f, 0.11041418f, 0.06793661f, 0.65283084f, -0.01908188f, 
    0.38509151f, -0.14121275f, -0.05936827f, 0.41199154f, -0.17598422f, 0.03011620f, -0.00947772f, -0.16156662f, 
    0.07297619f, 0.10849996f, 0.11692633f, 0.20153719f, 0.29099110f, 0.11871831f, -0.08790341f, 0.56698054f, 
    0.03082662f, 0.04349770f, -0.16529603f, 0.11752032f, 0.00985262f, -0.09337182f, 0.20227511f, -0.18737307f, 
    -0.04345098f, -0.14280990f, -0.12969021f, -0.02459810f, -0.08766681f, -0.11556300f, -0.05655373f, 0.02960207f, 
    -0.08588275f, -0.05974805f, -0.17884623f, -0.04822624f, -0.17012906f, -0.14802726f, -0.14377397f, 0.12839800f, 
    -0.11778601f, -0.00772590f, 0.16934070f, -0.08961588f, 0.01494239f, 0.02176479f, 0.09583095f, -0.09070138f, 
    0.06417576f, 0.00878178f, 0.12585509f, 0.09670646f, -0.13158666f, -0.09083632f, 0.01964104f, 0.11586787f, 
    -0.12378448f, -0.15601100f, -0.01062214f, -0.13039248f, -0.16212887f, 0.35792655f, -0.22137305f, -0.33228481f, 
    -0.19776127f, 0.25482017f, -0.13980168f, 0.09183414f, 0.35209468f, -0.12663619f, 0.21310928f, -0.05820812f, 
    0.11381125f, -0.01247018f, -0.09330224f, -0.12741143f, -0.27526754f, 0.09874648f, -0.06062001f, -0.00992413f, 
    -0.04550227f, -0.00882299f, -0.26069272f, -0.17822114f, 0.14455210f, -0.24223532f, 0.02228162f, 0.36496714f, 
    0.10901331f, 0.00784208f, -0.10291842f, -0.01446843f, -0.07928370f, 0.10158131f, -0.02162209f, -0.06596019f, 
    -0.14934674f, 0.11222422f, -0.03297498f, 0.14864726f, -0.09329068f, -0.02353958f, -0.12305024f, -0.07913392f, 
    -0.03080558f, -0.01565810f, -0.05913921f, -0.03847205f, -0.13709474f, -0.07265908f, -0.13096234f, -0.15204309f, 
    0.00669219f, 0.06333245f, 0.09535923f, 0.01449305f, 0.00641135f, -0.19962578f, -0.04571733f, -0.04434671f, 
    0.20202912f, 0.03659014f, -0.12402309f, 0.42817661f, -0.16033749f, -0.38645342f, 0.03011854f, 0.34498289f, 
    -0.00291651f, -0.11889042f, -0.12421773f, 0.11675309f, -0.03487876f, 0.04931104f, 0.15976523f, 0.21199252f, 
    -0.14086911f, 0.00056132f, -0.07643424f, -0.22081295f, 0.03568147f, -0.09732655f, 0.08034510f, 0.09627510f, 
    0.21377417f, 0.09175692f, -0.07229649f, 0.03134954f, -0.15695405f, 0.15744510f, 0.23755768f, 0.03718508f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11351088f, -0.13727733f, 0.05732511f, -0.10565075f, 0.11550288f, 0.18892029f, -0.07370170f, 0.13575853f, 
    0.08261645f, 0.01317596f, -0.07552233f, 0.26058435f, 0.26040497f, -0.22030447f, -0.09967401f, 0.17678957f, 
    -0.12101412f, -0.03523144f, -0.07595421f, 0.33513883f, 0.03006246f, 0.01290064f, 0.12887137f, -0.05241727f, 
    0.15227790f, 0.03056628f, -0.05228731f, 0.07435369f, 0.25256455f, 0.11247935f, -0.03927287f, 0.21198511f, 
    0.27820078f, 0.06610624f, 0.32963049f, -0.10446007f, -0.13552861f, -0.08536290f, -0.17134285f, -0.11388832f, 
    0.00375111f, 0.14618123f, 0.15080953f, -0.17092389f, 0.04025938f, 0.09561958f, 0.05537874f, 0.02332400f, 
    0.00687838f, 0.10140536f, 0.17237541f, 0.20111176f, 0.16892326f, -0.02348040f, 0.08562084f, 0.08715825f, 
    0.06357504f, 0.11898831f, 0.06116762f, -0.12083514f, -0.07235861f, 0.27499467f, 0.05173753f, -0.08684634f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04119598f, -0.19863683f, 0.08943988f, -0.09830989f, 0.12707420f, 0.16369905f, 0.01820014f, -0.29482713f, 
    0.01927166f, 0.01013609f, 0.01631599f, -0.17846461f, 0.07234608f, -0.19957812f, -0.07500962f, 0.17853311f, 
    -0.01345425f, 0.22227946f, 0.03584076f, 0.29617614f, 0.22852300f, -0.18853194f, 0.02211944f, -0.07032147f, 
    0.48520413f, 0.06175915f, -0.10151194f, 0.19605850f, 0.04357739f, 0.30221167f, 0.31183526f, -0.22414477f, 
    0.15135466f, 0.02954465f, 0.32034937f, -0.23552360f, 0.20050965f, 0.03069545f, -0.04526306f, 0.05685626f, 
    0.26361397f, -0.01735306f, 0.01047121f, -0.33396518f, -0.50560534f, -0.14647432f, 0.18852031f, -0.19678214f, 
    0.15535583f, -0.39539835f, 0.04718867f, -0.02755695f, 0.08986977f, -0.06007773f, 0.02019115f, -0.14462285f, 
    0.10056853f, -0.02296856f, -0.23147370f, 0.18093462f, 0.01875875f, -0.24865706f, -0.05517526f, 0.08670451f, 
    0.22492723f, -0.00500019f, 0.33171985f, 0.07567903f, 0.05322267f, 0.04576905f, -0.10300663f, -0.15273570f, 
    0.28379574f, -0.04425803f, 0.06027134f, 0.44815582f, 0.10789569f, -0.28623050f, -0.06443324f, -0.11098450f, 
    -0.12805723f, -0.02316727f, -0.18979537f, 0.06814647f, -0.17554447f, 0.01513287f, 0.20053865f, 0.24389301f, 
    -0.03692716f, 0.00702504f, -0.06054881f, -0.26777878f, -0.06870344f, -0.16417530f, -0.25566849f, -0.08155784f, 
    0.02146165f, 0.29324800f, 0.25594506f, 0.23744024f, -0.44849586f, -0.02279256f, 0.01730085f, 0.02570772f, 
    -0.18079399f, -0.06673839f, 0.35292396f, -0.11497219f, 0.02193363f, -0.25039700f, 0.01515271f, 0.38263538f, 
    -0.10075408f, 0.22390108f, 0.23626766f, 0.17429149f, 0.10145538f, 0.05632288f, 0.29871306f, 0.15281987f, 
    0.26964954f, 0.30784285f, 0.27453506f, 0.22133131f, 0.03696733f, -0.25128406f, 0.13292708f, 0.27742079f, 
    0.20890827f, 0.22177660f, -0.05038943f, 0.02998821f, 0.07873135f, -0.03137290f, 0.05323933f, 0.13436025f, 
    -0.25226840f, 0.29152232f, 0.32287991f, -0.21712688f, -0.18096916f, 0.74296868f, -0.07390103f, 0.08604304f, 
    -0.10302622f, 0.28029749f, 0.11518952f, -0.15413803f, 0.22522189f, 0.17490791f, -0.15815149f, 0.05924708f, 
    -0.10154811f, 0.04848413f, 0.09172942f, 0.29118466f, 0.15224162f, 0.10603992f, 0.40075865f, -0.26394182f, 
    -0.04053950f, -0.03825565f, 0.00649582f, 0.14178124f, 0.28600591f, 0.10509426f, 0.12193610f, 0.03666821f, 
    0.27108935f, -0.01670334f, -0.02569384f, -0.11071309f, 0.02321277f, 0.12116744f, -0.10763213f, 0.04768612f, 
    0.25356466f, -0.30747360f, -0.23273773f, -0.03911778f, -0.41698033f, -0.18365073f, -0.06223955f, 0.16882639f, 
    -0.07599397f, -0.25819066f, -0.12655005f, -0.29517043f, 0.08774190f, 0.11515438f, 0.08585411f, 0.23902275f, 
    0.24347083f, -0.06001334f, 0.15832475f, -0.00014620f, 0.14448127f, 0.12723583f, 0.04282162f, -0.00009804f, 
    -0.15726665f, 0.22648109f, 0.14552842f, 0.21985604f, -0.21921448f, 0.64299148f, -0.07662562f, -0.20075329f, 
    -0.00382352f, 0.20689635f, -0.01306086f, -0.06472708f, -0.15999384f, -0.02987421f, -0.10827530f, 0.07420046f, 
    -0.20854227f, 0.24034846f, 0.04888173f, 0.28874317f, 0.21941039f, -0.44240299f, 0.17228705f, 0.06472324f, 
    0.20470008f, 0.02968837f, 0.17407653f, 0.31296018f, 0.15553735f, -0.08606003f, 0.08080703f, 0.12695926f, 
    0.26787150f, -0.22827975f, -0.03246516f, -0.42169797f, -0.11641194f, 0.02186731f, -0.11366113f, -0.03108522f, 
    0.00809353f, -0.10350248f, -0.27247432f, 0.12048566f, -0.40052408f, -0.05802524f, -0.07235004f, 0.36289269f, 
    -0.13607824f, -0.14056662f, 0.46603686f, 0.00663165f, 0.05732543f, 0.14653130f, 0.10439982f, 0.11856692f, 
    0.29107052f, 0.15895240f, 0.13537253f, 0.02922493f, 0.00471220f, -0.10661556f, 0.17418793f, 0.09145059f, 
    -0.34125447f, 0.17069231f, 0.06715651f, 0.11725168f, -0.20235497f, -0.40183264f, -0.01037804f, 0.04324340f, 
    0.06268121f, 0.13426825f, -0.27069178f, -0.13072038f, -0.11854425f, 0.22977151f, -0.07805613f, 0.10583057f, 
    -0.27369854f, 0.13705270f, -0.16345313f, 0.10322517f, 0.03308906f, -0.00811255f, 0.28841060f, -0.08766380f, 
    -0.03992977f, 0.02043693f, -0.08771004f, 0.46683127f, -0.04620694f, -0.03149220f, -0.08269650f, -0.09352964f, 
    0.23581150f, 0.07319003f, -0.00009981f, 0.36156341f, 0.05287135f, 0.53954643f, 0.09062238f, 0.59459949f, 
    0.36797813f, -0.25999352f, -0.00303404f, 0.11666101f, -0.29197735f, -0.41603285f, -0.24658842f, 0.29770958f, 
    0.25271136f, 0.21005207f, -0.02830658f, -0.22292669f, 0.04853857f, 0.70125550f, -0.11464199f, 0.24367803f, 
    0.21178523f, -0.33025557f, 0.21093789f, 0.06283806f, 0.04668515f, -0.30438390f, -0.04056353f, -0.32069626f, 
    -0.09952933f, -0.13105506f, 0.24309951f, -0.06947158f, -0.40907592f, 0.45289329f, -0.02290922f, -0.26187468f, 
    -0.11791818f, 0.09469111f, 0.14500304f, 0.05783236f, 0.42013291f, 0.04614395f, -0.00113734f, -0.06698530f, 
    -0.02060266f, 0.06446012f, -0.46884492f, -0.01179122f, 0.05358148f, 0.32278728f, 0.30035618f, -0.15424284f, 
    -0.16736913f, 0.22970024f, 0.04562505f, 0.22947466f, 0.17314275f, -0.08141176f, 0.11562663f, -0.06835721f, 
    -0.01124300f, -0.19295180f, 0.14197958f, 0.18603224f, -0.02357451f, 0.10000525f, -0.06110321f, 0.00783185f, 
    0.22271295f, -0.01448865f, -0.28240886f, -0.19224669f, -0.15491545f, -0.01309186f, 0.01580995f, 0.31302747f, 
    -0.10087314f, -0.11962575f, 0.57486188f, 0.45630637f, -0.03808244f, -0.20138183f, -0.03117320f, 0.02651108f, 
    -0.03409432f, 0.11865780f, -0.12920588f, 0.03626754f, 0.10169657f, -0.07794745f, 0.04666586f, 0.46377307f, 
    -0.11763403f, 0.20012183f, 0.13369367f, 0.08118721f, 0.04974245f, 0.42486724f, -0.08942227f, 0.02863939f, 
    -0.06823805f, -0.16614616f, 0.25543541f, -0.13267128f, -0.41443643f, -0.08710168f, 0.08207785f, 0.05564098f, 
    -0.31272635f, 0.09338898f, 0.38109055f, 0.32851377f, 0.21625373f, 0.10756038f, -0.23810489f, 0.32233664f, 
    0.04583983f, -0.02810661f, -0.13234654f, 0.26328346f, 0.47316697f, 0.07360241f, -0.03107360f, 0.01600890f, 
    -0.02745397f, -0.01632589f, -0.22046809f, -0.08996873f, 0.11982856f, -0.00796710f, -0.11670448f, 0.01471315f, 
    0.06336051f, 0.53262359f, 0.11712717f, -0.08056757f, -0.09384383f, 0.21071926f, -0.14738956f, 0.27012300f, 
    -0.23719600f, -0.02651509f, 0.56282252f, -0.18724552f, -0.12169684f, 0.86269730f, -0.02623857f, -0.19349259f, 
    0.07354012f, -0.01137180f, 0.08380767f, 0.01065527f, -0.10989518f, 0.06788733f, -0.04175347f, -0.01052604f, 
    0.03758135f, -0.08955100f, 0.03943099f, -0.07264018f, -0.09729139f, -0.02857950f, -0.00678797f, -0.06151279f, 
    0.05663922f, -0.02168120f, 0.00293376f, -0.01588702f, -0.03232146f, -0.00372985f, 0.01858337f, -0.02530877f, 
    -0.14394331f, -0.10168646f, 0.10957669f, 0.06210642f, -0.15209009f, 0.01819338f, 0.05675951f, 0.04060661f, 
    -0.05166401f, 0.02911414f, -0.08742309f, -0.12751170f, -0.09343578f, -0.08749603f, 0.09557453f, -0.07917649f, 
    -0.02743574f, 0.04292138f, 0.06262369f, -0.04492121f, -0.14223346f, 0.06441180f, 0.06587519f, 0.06435483f, 
    -0.11919108f, 0.00050282f, -0.04650703f, 0.07986146f, 0.04037864f, 0.02212570f, -0.07785349f, 0.08359037f, 
    -0.10267446f, -0.11444174f, -0.01444658f, -0.03347955f, 0.07657783f, 0.06758010f, -0.07347171f, -0.16020513f, 
    0.01801730f, 0.28231919f, -0.03332902f, 0.10664335f, 0.09520567f, -0.18890114f, -0.00818631f, 0.05094468f, 
    0.03269646f, -0.11730593f, -0.02429789f, -0.06321619f, -0.06282471f, 0.32297778f, 0.11410633f, -0.38164264f, 
    0.01354084f, 0.04034168f, 0.38656685f, -0.07596272f, 0.08051613f, 0.05571492f, 0.10216004f, -0.20345171f, 
    -0.16874094f, -0.07115246f, 0.00411887f, -0.00628400f, -0.00824418f, 0.23610435f, 0.05152239f, 0.09444994f, 
    0.12933542f, 0.17758302f, 0.05688229f, 0.10039447f, -0.11671079f, -0.07605818f, 0.02595848f, -0.09497163f, 
    0.00858684f, -0.15356660f, 0.22929592f, 0.31959704f, 0.28097773f, -0.24945547f, -0.22703269f, -0.14922337f, 
    -0.06488755f, 0.59980583f, 0.17278081f, 0.17143151f, 0.13723500f, 0.19776741f, 0.28456181f, 0.00538301f, 
    -0.11203022f, -0.27056944f, 0.54414123f, -0.07790370f, 0.00571208f, -0.08485582f, -0.08686618f, 0.10363621f, 
    0.06761687f, 0.05243297f, -0.06157421f, -0.04465860f, 0.03761449f, -0.03429607f, -0.07958670f, 0.02535664f, 
    0.04531175f, 0.00460342f, 0.05511329f, 0.05736559f, -0.02634414f, 0.00749827f, 0.05520945f, 0.06095097f, 
    -0.01491527f, 0.08199780f, 0.00824168f, -0.08621421f, -0.13613789f, -0.02373548f, 0.03793693f, -0.02047609f, 
    -0.02242335f, 0.05421994f, 0.02832751f, -0.06170028f, -0.09567279f, -0.01661376f, -0.12793559f, -0.01591681f, 
    0.01319164f, -0.09709466f, 0.00609392f, -0.07593574f, -0.00405524f, -0.10015844f, -0.05694313f, 0.09770157f, 
    -0.07580405f, -0.00400047f, -0.12856437f, -0.09987636f, -0.06233067f, 0.07179906f, -0.07898637f, -0.02903325f, 
    0.03522706f, -0.00586351f, -0.15577804f, 0.05365642f, -0.12843867f, 0.06624389f, 0.07583624f, -0.01780180f, 
    0.05640770f, 0.07613017f, -0.11391363f, 0.12447214f, -0.04863060f, -0.00226253f, 0.12841387f, -0.07124267f, 
    0.23380221f, -0.10882582f, 0.29738358f, 0.05057307f, -0.03244834f, 0.13902645f, -0.07035332f, -0.05622420f, 
    0.20536304f, 0.01876094f, 0.02035603f, 0.38304836f, -0.05555666f, -0.64508694f, -0.09268104f, 0.18218412f, 
    -0.05870000f, 0.18635873f, -0.32052070f, 0.01279451f, 0.03844677f, 0.40375388f, 0.20485084f, 0.15814175f, 
    0.05532144f, 0.12850282f, -0.30880630f, -0.39854836f, -0.24613200f, 0.09293097f, -0.12634794f, -0.14344290f, 
    -0.17826679f, 0.12506700f, -0.05360343f, 0.29469156f, -0.41033858f, -0.03947053f, 0.02961837f, -0.08124202f, 
    -0.10417926f, 0.17660140f, 0.12060177f, 0.30823067f, -0.07900053f, 0.13477233f, 0.00109024f, 0.54547459f, 
    -0.01772729f, -0.17642276f, 0.21795554f, 0.01081493f, 0.25618720f, -0.19223134f, 0.06441027f, 0.09828944f, 
    0.40228090f, 0.32812914f, -0.08900279f, 0.06752995f, 0.05081132f, -0.20996201f, 0.06461815f, 0.28309724f, 
    0.00071700f, 0.37414172f, -0.19861940f, -0.00407918f, 0.15667675f, 0.12082670f, -0.02858178f, 0.03474817f, 
    -0.19204099f, 0.15621865f, 0.23662828f, -0.36073261f, 0.17167684f, 0.43788406f, 0.05932775f, 0.05660980f, 
    -0.07712178f, 0.19446942f, 0.42979228f, 0.01962182f, 0.51136291f, -0.28912485f, 0.16893457f, -0.22184387f, 
    0.29618153f, -0.00667104f, 0.26289445f, 0.47953480f, 0.20033574f, 0.15691736f, 0.41374922f, 0.07062554f, 
    0.22842032f, 0.09267271f, 0.12975438f, -0.20939940f, 0.25494474f, 0.00928423f, 0.08655535f, -0.02819708f, 
    0.56809866f, -0.07065240f, 0.04581586f, -0.01135211f, 0.06111238f, -0.07531686f, 0.13550970f, -0.43090034f, 
    0.28385174f, -0.06817280f, -0.18863709f, 0.16797730f, -0.03918982f, 0.17494933f, 0.14482999f, 0.04305652f, 
    -0.18754184f, -0.05983641f, -0.11841178f, -0.23886389f, -0.06863905f, 0.05535579f, -0.04624749f, -0.13999540f, 
    -0.37110445f, -0.17194295f, -0.26576072f, 0.00311347f, -0.16226767f, 0.24291560f, 0.09785355f, 0.18815657f, 
    -0.03425683f, -0.03952882f, -0.15646172f, -0.25368604f, 0.04942657f, -0.56231457f, 0.08703597f, 0.31556773f, 
    -0.03606579f, -0.26895124f, -0.20363808f, 0.16006435f, -0.26232168f, -0.11053279f, 0.02338085f, -0.02980522f, 
    -0.07334148f, 0.12696782f, 0.21314237f, 0.27202505f, 0.03931215f, 0.29197028f, 0.18277030f, 0.26599994f, 
    0.12026475f, -0.20019504f, -0.10830739f, -0.08282333f, 0.02370036f, -0.08566976f, 0.04043897f, 0.06141433f, 
    0.22050883f, 0.26762584f, 0.12514623f, 0.28762683f, -0.02345228f, -0.09984785f, 0.29694006f, -0.16071326f, 
    -0.04200374f, 0.13249920f, -0.00087054f, -0.07167560f, 0.33808455f, 0.16241767f, -0.13503571f, 0.23355579f, 
    -0.02906953f, -0.00497105f, -0.30818474f, 0.16394971f, -0.03900434f, 0.59773892f, 0.10129764f, -0.50192016f, 
    0.13894981f, 0.25436613f, 0.11551030f, -0.06861363f, -0.15817927f, -0.09926353f, 0.11128826f, 0.14736916f, 
    -0.04927131f, 0.04769555f, 0.34475502f, -0.00493215f, 0.00205913f, 0.13486338f, 0.09635124f, 0.23056945f, 
    0.08781853f, 0.23815484f, 0.12481165f, 0.07919718f, 0.37280566f, 0.22030872f, 0.21102281f, -0.25525823f, 
    0.04537752f, -0.11637797f, -0.31032041f, 0.01542945f, -0.18032327f, 0.15277098f, 0.25599095f, 0.11276405f, 
    -0.33262151f, -0.04005354f, -0.03827916f, 0.23431963f, 0.19108576f, -0.06409177f, -0.04907149f, -0.02640778f, 
    0.23631746f, -0.05107579f, -0.03848481f, 0.43317649f, 0.28754380f, 0.42875913f, 0.10466447f, 0.38124010f, 
    0.19151072f, 0.02904347f, 0.08820584f, 0.01585470f, 0.04104551f, -0.01319408f, 0.01522439f, -0.08575282f, 
    0.42500782f, -0.02461717f, 0.01721607f, -0.11284743f, 0.07779162f, -0.17094271f, 0.07793766f, 0.18866713f, 
    -0.16024271f, -0.17989890f, -0.23826511f, -0.06497093f, 0.02881904f, 0.05042870f, 0.03610245f, 0.13842036f, 
    -0.01550566f, 0.09954572f, -0.26682064f, -0.26389134f, 0.11776668f, -0.48134121f, -0.06569021f, 0.09245162f, 
    -0.12473803f, -0.02460003f, -0.04389641f, -0.01694077f, -0.17608021f, 0.40818080f, -0.12888633f, 0.13659868f, 
    0.09614176f, -0.04592399f, 0.15351927f, 0.37617987f, 0.28757069f, 0.42264712f, 0.00267109f, 0.25800803f, 
    0.25384244f, -0.12072308f, -0.36230835f, 0.00527439f, 0.25201559f, 0.03944682f, -0.07073550f, -0.07152683f, 
    0.18647648f, 0.00719234f, -0.15232144f, 0.53143805f, -0.13139570f, 0.12343194f, -0.01650547f, -0.17231992f, 
    0.02291926f, 0.13089402f, 0.10869200f, -0.00484746f, 0.01174793f, 0.08703545f, -0.15811555f, 0.32302594f, 
    -0.19057898f, -0.04332035f, 0.03692856f, 0.23303770f, -0.03140002f, 0.73655421f, -0.03343906f, -0.48875859f, 
    -0.09949014f, -0.20055507f, -0.00229757f, 0.07411216f, 0.19689262f, 0.43692732f, -0.06608320f, 0.26468170f, 
    -0.05116709f, 0.34968582f, 0.00812124f, 0.27788410f, 0.23812811f, -0.05104399f, -0.07140125f, 0.27861083f, 
    -0.08917675f, -0.07887961f, 0.00295801f, 0.31682056f, -0.25608698f, -0.53296131f, 0.16517530f, 0.06477470f, 
    0.04165258f, 0.27916428f, 0.12257470f, 0.27819461f, 0.10101371f, -0.34037217f, 0.03447149f, -0.05221627f, 
    0.37448260f, -0.08678263f, 0.34425148f, -0.07701899f, -0.02691371f, -0.09369571f, -0.07290112f, -0.11323078f, 
    -0.08628571f, 0.02875564f, 0.01175981f, -0.48375916f, -0.27885339f, -0.19833231f, 0.13099490f, -0.07205942f, 
    0.10504924f, -0.12721609f, 0.03286820f, 0.18656555f, -0.05294004f, -0.02843013f, -0.10883818f, 0.14129190f, 
    -0.10676234f, 0.15497580f, -0.13904099f, 0.12888372f, 0.10962775f, -0.19862244f, -0.02644273f, -0.03277010f, 
    0.02364487f, 0.07094584f, 0.06974400f, -0.04911046f, 0.15275778f, -0.16157019f, -0.10432701f, -0.30136865f, 
    0.03966431f, -0.32084471f, 0.21380372f, 0.21638973f, -0.34290832f, 0.45320356f, 0.03124922f, -0.26375028f, 
    0.07069856f, 0.00778498f, 0.02364221f, -0.14539044f, 0.13981681f, 0.18776043f, -0.02990791f, -0.35032809f, 
    0.20800532f, 0.11597578f, -0.40526283f, -0.03597627f, -0.12460559f, 0.12623009f, 0.22611892f, -0.19158816f, 
    0.00784389f, 0.31765044f, 0.12087727f, 0.14054176f, 0.05567992f, -0.10890540f, 0.03173878f, -0.03058875f, 
    -0.10541414f, -0.16974185f, 0.20793769f, 0.16113617f, -0.18180323f, 0.05838177f, -0.32669058f, 0.20122100f, 
    -0.00479685f, -0.06396686f, -0.13108008f, -0.08725772f, -0.27317128f, -0.03534555f, 0.10686903f, 0.11291018f, 
    -0.17844296f, -0.05008529f, 0.43946937f, 0.53966552f, 0.03583413f, -0.30103198f, 0.05151191f, 0.17554051f, 
    0.05206335f, -0.06643995f, 0.05246995f, 0.10382079f, -0.07995237f, 0.06270500f, -0.10180515f, -0.02122411f, 
    -0.12433036f, 0.06606390f, -0.07581581f, -0.10713904f, -0.02470393f, -0.02061157f, -0.10945730f, 0.09933980f, 
    0.07604769f, -0.00016829f, -0.11061807f, -0.00568471f, 0.04166646f, -0.09915493f, 0.04286839f, 0.11784361f, 
    0.01017947f, -0.13166569f, -0.02232852f, -0.12624344f, -0.12972085f, -0.12713063f, -0.10113632f, 0.02271058f, 
    -0.12761126f, -0.10164724f, -0.02903494f, 0.04224837f, 0.10536058f, 0.02191673f, 0.07564832f, 0.00058630f, 
    -0.01693097f, -0.06396984f, -0.02577894f, -0.11805396f, 0.00994883f, 0.03030702f, -0.05261592f, -0.09945539f, 
    0.01680025f, 0.08825639f, 0.02414115f, 0.05517713f, -0.07823234f, -0.02427495f, -0.03025671f, 0.04130872f, 
    -0.11185476f, 0.01014635f, 0.00069496f, -0.09999461f, 0.11829683f, 0.06045013f, 0.02542645f, 0.02776872f, 
    0.07998130f, 0.07841808f, -0.06230741f, -0.01080580f, -0.12696457f, 0.07860596f, 0.06082882f, 0.01712269f, 
    -0.05770962f, -0.05560324f, -0.12418164f, 0.04687274f, -0.10010582f, -0.04247097f, -0.07289898f, 0.06656158f, 
    -0.05900432f, -0.02634102f, -0.03860626f, -0.05577015f, -0.11729243f, 0.00693288f, 0.10562955f, 0.02023134f, 
    -0.08114128f, 0.09611553f, -0.07613903f, 0.05646700f, 0.07271768f, -0.11641215f, 0.12092428f, 0.00501985f, 
    -0.10208983f, 0.00772967f, -0.05093300f, 0.12067761f, -0.00186629f, -0.07156290f, -0.01584928f, -0.00248058f, 
    -0.09849764f, -0.12411913f, -0.06983188f, 0.04984916f, -0.10074177f, -0.04665686f, -0.09800254f, -0.09627400f, 
    0.04890639f, 0.10769659f, -0.04090935f, -0.08882511f, -0.06639492f, 0.03010481f, -0.09863316f, -0.05429078f, 
    0.11044117f, -0.06301048f, -0.01630029f, 0.10558050f, -0.03412811f, -0.03087677f, 0.04017726f, -0.11394622f, 
    -0.13064405f, -0.26506618f, -0.19632186f, 0.07371896f, -0.13546693f, -0.20660873f, 0.03653423f, 0.06267397f, 
    -0.00810072f, 0.02899904f, -0.13014686f, 0.16953538f, 0.17287701f, -0.25713912f, 0.10072894f, 0.36419874f, 
    0.01744075f, -0.14739886f, -0.15057637f, 0.14418280f, 0.12372092f, -0.19443688f, 0.31266218f, 0.07986449f, 
    0.16124690f, -0.25199148f, 0.02205397f, 0.17860194f, -0.09098084f, 0.38317916f, -0.13103266f, 0.17577344f, 
    -0.21691187f, -0.51343793f, -0.27837616f, -0.06868061f, 0.26902837f, 0.08707324f, -0.08143076f, 0.09184951f, 
    -0.08826142f, 0.20277271f, -0.32855415f, 0.32769570f, 0.02190373f, 0.00469505f, 0.20870639f, 0.40062407f, 
    0.25210392f, 0.06604483f, 0.00928806f, -0.21707201f, 0.29177654f, -0.17888410f, -0.32659313f, -0.19709808f, 
    0.13330987f, -0.08449104f, -0.53361416f, 0.07615330f, 0.09540558f, 0.53685349f, 0.10140885f, -0.11446468f, 
    0.22928694f, -0.08922888f, 0.07353739f, 0.02531537f, 0.08875527f, -0.22949846f, 0.09767346f, -0.13993929f, 
    -0.03653487f, -0.19530654f, 0.01699306f, 0.15388685f, -0.41678342f, 0.47569612f, -0.00191702f, -0.27101371f, 
    0.05053505f, 0.11472207f, 0.04749322f, -0.06990904f, 0.37836283f, 0.26539207f, -0.17545979f, -0.57704324f, 
    -0.00687289f, 0.01696674f, -0.03012171f, -0.01297950f, -0.18431172f, 0.22737181f, 0.33203948f, -0.13880333f, 
    -0.26275524f, 0.01108449f, 0.00853053f, 0.22768036f, 0.28895435f, 0.04679339f, 0.08971523f, 0.00207845f, 
    -0.22865567f, -0.18410805f, 0.05141193f, 0.34452862f, 0.00956829f, -0.17166620f, -0.15520161f, 0.16571978f, 
    0.05452574f, 0.00741784f, -0.17587969f, -0.25888968f, -0.02712725f, -0.44277358f, 0.11685086f, 0.19099446f, 
    0.27099651f, -0.54690081f, 0.27615407f, 0.34445104f, 0.06933872f, -0.15988261f, 0.09957404f, 0.06828696f, 
    -0.03068596f, -0.06427914f, 0.03977866f, -0.01450929f, -0.15258262f, 0.21896812f, 0.09264398f, -0.27299342f, 
    0.16167922f, -0.10791701f, -0.29622611f, 0.18792760f, 0.19013448f, -0.47441363f, -0.02362239f, 0.06249937f, 
    -0.03838365f, 0.15502633f, -0.29578030f, 0.38244054f, 0.21705745f, -0.16522413f, 0.02795646f, 0.13608332f, 
    0.14711776f, 0.11910381f, -0.17524043f, -0.41616091f, -0.10884628f, 0.14993691f, -0.10748620f, -0.05600475f, 
    0.06438497f, 0.22233564f, 0.18636355f, 0.00913895f, -0.42222494f, -0.02289740f, 0.11519874f, 0.11869381f, 
    -0.12181453f, 0.36534742f, 0.29579416f, 0.17438111f, -0.22301951f, 0.05347497f, 0.24325018f, 0.09647474f, 
    -0.12233721f, -0.24261320f, 0.40752792f, 0.27281278f, 0.52450413f, -0.02195242f, 0.33978820f, -0.15559907f, 
    0.55190992f, 0.47928929f, -0.25271297f, 0.46336612f, -0.04062925f, -0.32689354f, 0.00706359f, 0.09608882f, 
    -0.14391018f, -0.06395454f, 0.07688724f, 0.10852517f, 0.03327516f, 0.06848739f, -0.04706430f, 0.00472983f, 
    -0.01132613f, 0.05970874f, -0.06567723f, -0.01937680f, -0.05992281f, -0.03100349f, 0.00878939f, -0.02148781f, 
    -0.09813586f, -0.05164618f, -0.10543381f, -0.14234208f, -0.10812238f, 0.04050131f, -0.02150733f, 0.11941541f, 
    -0.04881288f, -0.10675194f, 0.05992890f, -0.06768128f, 0.07175270f, -0.09207487f, -0.01308060f, -0.01156694f, 
    0.09306937f, 0.08716253f, -0.09168457f, -0.02394303f, -0.03166473f, -0.05036335f, 0.02025907f, -0.11578321f, 
    -0.11715420f, 0.01158580f, 0.03562164f, -0.00081987f, -0.00660853f, -0.04558820f, -0.05186778f, 0.01041187f, 
    0.08555021f, -0.10220550f, 0.05002191f, 0.03474774f, -0.01398169f, -0.07233901f, -0.11734384f, 0.02884177f, 
    -0.05787066f, -0.07299196f, -0.06061883f, 0.05013139f, 0.09322980f, -0.06372539f, 0.11247382f, -0.04063143f, 
    -0.06921847f, -0.10682943f, -0.03495097f, -0.06850104f, 0.23205085f, -0.11424414f, 0.11991800f, -0.08397564f, 
    -0.14081179f, 0.06650023f, 0.05159890f, -0.26871952f, -0.13131274f, 0.35462719f, -0.09832457f, -0.00238002f, 
    -0.09339669f, 0.23297010f, 0.17565195f, -0.00252962f, 0.04473894f, 0.09415231f, 0.12623234f, -0.24028981f, 
    0.31992170f, 0.01488373f, -0.28534415f, 0.33009371f, 0.06924679f, 0.09588958f, 0.35659593f, -0.03754873f, 
    0.21938246f, -0.08683618f, 0.04152600f, 0.14096135f, 0.27009439f, -0.02038975f, -0.02212319f, -0.10887629f, 
    0.40065259f, 0.06107712f, -0.21349482f, 0.07066437f, -0.00351956f, 0.15672293f, 0.10470714f, 0.08633990f, 
    0.21886854f, -0.23511116f, -0.21568212f, -0.11217049f, -0.17897388f, 0.03901887f, -0.19416495f, 0.33293632f, 
    -0.27554885f, -0.08732029f, 0.14273997f, 0.01077352f, -0.05457237f, 0.27331641f, -0.08237848f, 0.14132245f, 
    0.18519694f, -0.32385343f, 0.06629907f, -0.06231816f, 0.01993162f, -0.11426739f, -0.08224778f, -0.52100456f, 
    0.24602540f, -0.30138424f, -0.10542370f, 0.05337606f, -0.12416095f, 0.27440393f, -0.10520996f, -0.30907232f, 
    -0.00917060f, 0.07133009f, 0.21782708f, -0.11243471f, 0.10556333f, -0.09975652f, -0.12061158f, -0.14334619f, 
    0.20089039f, 0.14991923f, -0.20475034f, 0.04860501f, 0.19059543f, 0.43060356f, 0.09979111f, 0.02530872f, 
    0.12785448f, 0.07283431f, 0.04355932f, -0.04536819f, 0.21593882f, 0.05150056f, -0.10052398f, 0.04491924f, 
    -0.00547550f, -0.27436760f, 0.15232006f, 0.35510081f, -0.16219437f, -0.05933621f, -0.37831238f, -0.11496265f, 
    -0.05518550f, 0.17898712f, -0.16722840f, -0.11731216f, -0.03931757f, 0.28155798f, 0.03449757f, 0.18840174f, 
    -0.30023178f, -0.23150724f, 0.46355566f, 0.37082735f, -0.04854825f, -0.10961190f, -0.06861632f, 0.09310070f, 
    -0.04238811f, -0.02477332f, -0.13276246f, 0.05231526f, -0.05146759f, 0.01269679f, -0.00373992f, -0.10101578f, 
    -0.04491819f, 0.02616354f, 0.02035047f, -0.13754015f, -0.02174917f, -0.03937975f, 0.11977123f, 0.07955550f, 
    0.05262245f, -0.06942868f, -0.13437299f, -0.03711462f, 0.04160762f, 0.02976874f, -0.02854061f, -0.10428590f, 
    0.15372030f, -0.00477060f, -0.07662181f, -0.15431131f, -0.06519815f, 0.10161680f, -0.05201172f, 0.10874345f, 
    -0.12122993f, -0.05618340f, -0.05895686f, 0.02081358f, 0.05877817f, -0.00006975f, -0.01624790f, 0.01602849f, 
    -0.10369947f, -0.01766733f, 0.00255422f, 0.10759065f, 0.00231585f, -0.06123662f, 0.03180098f, -0.16279109f, 
    -0.11992408f, 0.02132288f, -0.03826953f, -0.06842031f, -0.11299948f, 0.09202188f, 0.03513905f, -0.03936216f, 
    0.12295224f, 0.08821641f, -0.00696187f, -0.12274421f, 0.10734108f, -0.09313557f, 0.10961168f, -0.13239808f, 
    0.09994913f, 0.02192691f, -0.01659704f, 0.03146640f, -0.00212722f, -0.27339956f, 0.05544866f, -0.14040880f, 
    -0.03039032f, -0.04844270f, 0.11576546f, -0.12755540f, -0.32389966f, 0.61899370f, -0.08028483f, -0.30907312f, 
    -0.02044254f, 0.07629947f, 0.23196906f, -0.14131914f, 0.25097662f, -0.09569941f, -0.23074780f, -0.16607626f, 
    -0.07866307f, 0.00704212f, -0.17968515f, 0.00380600f, 0.12927239f, 0.23412800f, 0.20521553f, -0.10890587f, 
    -0.16179669f, 0.03751246f, 0.03800943f, 0.07520261f, 0.21939720f, -0.05578644f, -0.04422897f, 0.04732528f, 
    -0.02898547f, -0.06733254f, -0.02085173f, 0.26060572f, 0.08178101f, -0.05409820f, -0.01093231f, -0.09181631f, 
    0.14657709f, 0.12871252f, -0.27550402f, -0.01621290f, -0.26808310f, -0.00632111f, 0.02005820f, 0.18590130f, 
    0.25610638f, -0.17542054f, 0.37799346f, -0.13191746f, 0.08075458f, 0.14797528f, -0.04106589f, 0.20324813f, 
    0.11792451f, 0.13469057f, -0.14443342f, -0.02245199f, 0.26240820f, 0.05345153f, -0.06888179f, 0.24746245f, 
    -0.18767165f, 0.29927030f, 0.19103299f, -0.09336270f, 0.04375045f, 0.35651612f, -0.05841777f, 0.06726658f, 
    0.05416478f, 0.16254605f, 0.17622155f, -0.17788450f, 0.11425194f, -0.12727204f, -0.06159168f, 0.03039048f, 
    0.05774142f, 0.24242039f, 0.43467981f, 0.53984678f, 0.15384269f, -0.09976945f, 0.21008821f, -0.33874884f, 
    0.09867720f, 0.06241626f, 0.17555971f, 0.10829383f, 0.00521785f, 0.03141025f, 0.02553087f, 0.01190842f, 
    0.22487020f, -0.01765911f, 0.03872433f, 0.10874653f, -0.02646126f, -0.14436220f, -0.13905612f, -0.13557492f, 
    0.18631531f, -0.22305299f, -0.13231479f, 0.17851475f, -0.21116324f, -0.05145323f, 0.01969059f, 0.12916873f, 
    -0.23432168f, -0.08207921f, 0.02865149f, -0.36409944f, 0.12526363f, 0.42156857f, 0.10244711f, 0.05182271f, 
    0.10535389f, -0.27893341f, -0.04376387f, -0.04331032f, 0.18782808f, 0.11463889f, 0.04024552f, -0.08004000f, 
    0.10697236f, 0.09820678f, -0.33187243f, 0.16974831f, 0.13391225f, -0.40652663f, 0.07727710f, 0.19075729f, 
    -0.07266581f, -0.04216931f, -0.28166488f, 0.21373926f, -0.31509116f, -0.16663177f, 0.04491352f, 0.31413281f, 
    0.27904263f, 0.20545426f, 0.02592375f, 0.16184446f, 0.20869727f, 0.26497996f, -0.21281733f, 0.10014237f, 
    0.44897321f, 0.17997298f, 0.10968486f, -0.02996460f, -0.11945385f, 0.05554971f, 0.08894160f, -0.06270822f, 
    -0.04503593f, 0.16389397f, -0.02032555f, 0.17926688f, -0.50758880f, 0.16548163f, -0.00136417f, 0.00627086f, 
    -0.15515718f, -0.23468187f, -0.05492968f, 0.14105719f, 0.01860362f, -0.00677831f, -0.14408539f, 0.29982102f, 
    0.06324737f, 0.27431461f, 0.18233736f, 0.44671667f, 0.04659574f, 0.78047675f, -0.02724899f, -0.17669718f, 
    0.04813416f, 0.25454307f, 0.09234061f, 0.04128700f, -0.08587918f, -0.09265164f, 0.03973393f, 0.01471075f, 
    -0.09055278f, 0.08206632f, 0.17372230f, -0.21442761f, 0.12891750f, 0.27548116f, -0.11496317f, -0.00313143f, 
    -0.03738657f, 0.11620579f, 0.34102547f, 0.05442926f, 0.48714718f, 0.02874383f, 0.10949015f, -0.24746668f, 
    -0.09773973f, -0.05389602f, -0.04903620f, 0.12628508f, -0.06093661f, 0.06186387f, 0.36330602f, 0.04658331f, 
    -0.36398527f, -0.04964972f, 0.14381507f, 0.00544509f, 0.19112204f, -0.08054388f, 0.04438687f, 0.10397554f, 
    0.11070264f, -0.06175384f, -0.02923931f, 0.20198262f, 0.50846171f, -0.02752714f, 0.19292273f, 0.12389755f, 
    0.25484952f, 0.18216284f, -0.01238317f, 0.13120681f, 0.22776292f, 0.18759793f, 0.07759313f, -0.27869120f, 
    0.23086582f, -0.15883604f, 0.01357063f, -0.28146425f, 0.04374777f, -0.39689526f, -0.06722275f, 0.14487877f, 
    -0.03184906f, -0.02842446f, -0.08023857f, -0.04603297f, 0.01567385f, -0.08439614f, -0.02814475f, -0.09046347f, 
    0.04448998f, -0.08697942f, 0.10754782f, -0.07444295f, -0.08339226f, -0.02079791f, 0.00302745f, -0.08167626f, 
    0.05755560f, 0.01508315f, 0.01491641f, 0.02980424f, -0.11739489f, 0.08124578f, -0.07066464f, -0.05795790f, 
    0.05462877f, -0.05530107f, -0.09054175f, 0.07576229f, -0.07621297f, -0.05679613f, 0.06509554f, 0.10176884f, 
    -0.04483850f, -0.06840119f, 0.07664348f, 0.01082858f, -0.08886695f, 0.08238928f, 0.08664076f, -0.02262147f, 
    0.04952206f, 0.01665825f, 0.00057751f, -0.06908089f, -0.05061178f, 0.04202130f, 0.10255747f, 0.01207016f, 
    0.01054668f, -0.02395983f, 0.02501307f, 0.06199990f, -0.11977257f, -0.03464927f, -0.10467114f, 0.01047274f, 
    -0.01226942f, -0.08756949f, -0.10112014f, 0.12444100f, 0.09083174f, -0.10875261f, -0.09086232f, -0.09960525f, 
    -0.13267575f, 0.10424264f, -0.02690879f, 0.03541817f, 0.17572702f, 0.14853747f, -0.05285807f, 0.38080883f, 
    -0.11221622f, 0.43407017f, -0.07595173f, 0.06370652f, 0.08732174f, -0.07618427f, 0.00594937f, 0.10861206f, 
    0.08208326f, -0.07517687f, 0.12099983f, 0.09794638f, -0.24499597f, -0.45855540f, 0.01612448f, 0.04106854f, 
    -0.33296177f, 0.18405035f, 0.51697481f, 0.42344218f, 0.19843251f, -0.08034275f, 0.00046338f, 0.21911158f, 
    0.13451529f, -0.17168243f, -0.06282371f, 0.13417894f, 0.27388442f, -0.03116310f, -0.04955443f, 0.04589416f, 
    -0.16155382f, 0.21528189f, -0.07146512f, -0.29935920f, 0.05266770f, 0.12945454f, 0.21829136f, -0.05912540f, 
    0.03415955f, -0.03560939f, 0.21234837f, 0.03712770f, 0.00957287f, -0.05551465f, -0.15116854f, -0.00010073f, 
    -0.08519819f, -0.06734705f, -0.25768721f, 0.10675176f, -0.09038383f, 0.32488737f, -0.00565634f, -0.08175799f, 
    0.02136444f, 0.04063765f, 0.28107342f, 0.12555842f, 0.14160605f, 0.22746961f, 0.09672197f, -0.12446980f, 
    0.18165819f, 0.12207933f, -0.20590284f, 0.15920985f, -0.04058283f, -0.03526577f, -0.07932672f, -0.04387899f, 
    -0.09793892f, 0.09255466f, 0.08485112f, 0.17288251f, -0.33503395f, -0.28088400f, 0.10629626f, 0.13447009f, 
    0.14881404f, 0.15121013f, -0.17923170f, -0.06134291f, 0.11585610f, -0.23826769f, -0.05407815f, -0.14892444f, 
    0.35612318f, 0.25470209f, 0.28719035f, 0.05132947f, -0.26345608f, -0.05927061f, 0.08640385f, -0.03729309f, 
    0.23284940f, -0.03117579f, 0.19240098f, -0.05006059f, -0.08403201f, -0.01719455f, -0.03192260f, -0.05903270f, 
    -0.23501672f, -0.13247809f, 0.07478035f, 0.43700793f, 0.17162715f, 0.22427644f, 0.04204992f, 0.12474085f, 
    -0.06672369f, 0.26866379f, 0.20742157f, -0.36143363f, -0.03503012f, -0.18718475f, 0.02763316f, 0.09831661f, 
    0.27841932f, 0.10479938f, 0.18932286f, 0.02339877f, 0.00270651f, -0.08407562f, 0.09728257f, -0.06814686f, 
    0.03774712f, 0.08335511f, 0.15704322f, 0.30427659f, 0.21994552f, 0.01037319f, -0.07897874f, 0.07463787f, 
    -0.08474962f, 0.30126294f, 0.13995753f, -0.16569862f, 0.21506846f, 0.15441512f, 0.25989634f, 0.11586224f, 
    0.09741707f, 0.09778776f, 0.08562011f, -0.14581206f, -0.10647476f, -0.16964939f, -0.05291072f, -0.16082403f, 
    -0.12038571f, -0.01009774f, 0.26628658f, -0.02944585f, -0.08538909f, -0.02107854f, -0.01529268f, -0.11861233f, 
    0.04268342f, -0.04242370f, 0.07544503f, -0.05001275f, 0.09712508f, 0.01538898f, -0.12306621f, 0.47487697f, 
    0.24704744f, -0.12193925f, 0.06986464f, 0.11519492f, -0.14447813f, -0.18192185f, 0.18173350f, 0.07555015f, 
    0.28349775f, 0.20428735f, 0.00446249f, -0.44848758f, 0.04009364f, -0.26308933f, 0.11551378f, 0.36334655f, 
    0.05871546f, -0.00236706f, 0.07429698f, -0.02414522f, -0.08890852f, 0.05772875f, -0.01251581f, 0.02194546f, 
    -0.03538656f, -0.00315307f, -0.01100621f, -0.05318384f, 0.02146141f, -0.10155408f, -0.08989546f, -0.06841223f, 
    0.09636803f, -0.06484810f, 0.02932508f, 0.11257786f, -0.00911030f, -0.12050645f, -0.02074909f, 0.04829061f, 
    -0.10511455f, -0.10547774f, -0.11612879f, -0.05015074f, -0.09859203f, 0.05259216f, 0.01485053f, 0.05362611f, 
    -0.11523868f, 0.05584726f, -0.02499074f, -0.06651162f, -0.06858344f, 0.06093545f, -0.06476870f, 0.04709606f, 
    -0.00247185f, -0.02407704f, -0.08751212f, 0.01377767f, -0.10167149f, 0.06781873f, -0.06756333f, -0.05671625f, 
    0.02095783f, -0.06059195f, -0.11040585f, -0.01159398f, 0.00109749f, -0.00863896f, -0.11629723f, 0.07496461f, 
    -0.00202842f, -0.07034612f, 0.02181780f, -0.01460072f, -0.07581097f, -0.03107922f, 0.06897432f, -0.02900054f, 
    0.18372850f, 0.02070678f, -0.11736095f, 0.00781981f, 0.24782032f, 0.12688151f, -0.01984202f, 0.09184871f, 
    0.08920717f, 0.32440796f, 0.09721164f, -0.09705375f, 0.21398436f, -0.33588877f, -0.11635280f, -0.01527928f, 
    -0.04797595f, -0.00536919f, 0.09772246f, 0.08749637f, 0.07963002f, -0.21800597f, 0.20846924f, -0.19949721f, 
    0.42848292f, 0.21981466f, 0.39865628f, 0.38691849f, 0.11139505f, -0.18178281f, 0.16715997f, -0.34833586f, 
    0.19395882f, -0.05971242f, 0.29216191f, -0.28674120f, -0.10620833f, -0.03940155f, 0.11971010f, -0.08361243f, 
    0.31071746f, -0.09749487f, 0.12924884f, -0.22668654f, -0.14922532f, -0.21473038f, 0.02491618f, -0.26911181f, 
    0.17488694f, -0.16352038f, -0.16225755f, 0.13457721f, -0.10009005f, -0.01821544f, 0.23048870f, -0.02294102f, 
    -0.20273313f, -0.10751317f, -0.09020144f, 0.02704431f, -0.10261333f, -0.14716394f, -0.01387568f, 0.12313033f, 
    -0.02966502f, -0.11750530f, 0.02289273f, 0.06032510f, -0.06348085f, -0.08182932f, -0.00019075f, -0.07264117f, 
    -0.06011471f, -0.00305062f, -0.10963949f, -0.02657465f, -0.15702565f, -0.01482503f, -0.09728453f, 0.01756409f, 
    -0.09657907f, 0.09227703f, -0.08077929f, -0.06047003f, 0.00707788f, 0.09012268f, -0.04998729f, 0.02428465f, 
    -0.00684910f, -0.02484592f, 0.07523811f, -0.10751536f, 0.00368933f, -0.01270176f, -0.05835593f, 0.05414864f, 
    0.06775852f, -0.13052817f, -0.06922667f, -0.06963129f, -0.10269935f, 0.04135317f, 0.00297982f, 0.08660890f, 
    -0.05177430f, 0.02374790f, 0.05942297f, -0.04279086f, -0.01513267f, -0.10876508f, -0.03563577f, 0.01557225f, 
    0.05372692f, -0.08473079f, -0.00409506f, -0.13284472f, -0.02415591f, 0.00515809f, -0.04869711f, 0.07729855f, 
    -0.09673560f, 0.00439959f, -0.13331103f, -0.02906672f, -0.02860366f, -0.14379071f, -0.08098489f, -0.00323537f, 
    -0.10698170f, 0.08880585f, 0.06904411f, 0.06092530f, -0.09927647f, 0.03437343f, 0.11106130f, 0.10535360f, 
    0.08865961f, -0.00898533f, -0.10993423f, -0.10032719f, 0.02335647f, -0.08159091f, -0.09390949f, -0.11668192f, 
    -0.04753502f, -0.00255775f, -0.02893707f, -0.05408547f, -0.05075989f, -0.07136825f, 0.06010988f, 0.05197664f, 
    -0.04621886f, 0.00064534f, 0.02592264f, -0.03473003f, 0.01513659f, -0.06445371f, 0.09109950f, -0.01782853f, 
    -0.07353969f, 0.08809486f, -0.00078599f, -0.12676211f, -0.12001048f, -0.01358151f, -0.00186369f, -0.01939572f, 
    0.06931533f, -0.11440340f, -0.08223423f, -0.10549289f, -0.09835181f, 0.01591720f, 0.02179909f, -0.10163137f, 
    0.03110220f, 0.01951821f, 0.01130030f, 0.00171919f, -0.07469548f, -0.05963778f, -0.13465318f, 0.04168564f, 
    -0.05222826f, 0.01703252f, 0.10406104f, 0.05467925f, 0.03587286f, -0.02699189f, 0.02949120f, -0.13895914f, 
    -0.05551059f, 0.37458092f, -0.15338574f, -0.05914292f, 0.09983351f, -0.04402475f, -0.02141222f, 0.42432520f, 
    -0.40315193f, 0.17738698f, 0.18828472f, -0.26708409f, 0.09396466f, 0.04738773f, -0.05072564f, 0.05549379f, 
    0.06278080f, -0.06281839f, 0.29725823f, 0.06512900f, -0.01852374f, -0.07297242f, -0.05692611f, -0.17385785f, 
    -0.27926874f, 0.14534937f, 0.36143255f, 0.25922376f, 0.10825562f, -0.12876515f, 0.10358697f, 0.28124386f, 
    -0.08157682f, -0.12945853f, 0.06433310f, 0.11426406f, 0.45170355f, -0.02154563f, -0.09573763f, 0.04761849f, 
    0.17415181f, 0.04727445f, -0.03095836f, -0.43384284f, 0.23406294f, 0.12719224f, 0.20407592f, -0.17517668f, 
    0.26416883f, 0.33917677f, -0.00354611f, 0.07420122f, -0.25516650f, 0.03557297f, -0.20414984f, 0.11197043f, 
    -0.50917393f, -0.24185507f, -0.02972418f, -0.43992147f, 0.12558149f, 0.40526465f, 0.08109363f, -0.03758835f, 
    -0.11832882f, -0.06384042f, -0.00789560f, -0.11742386f, 0.02167386f, -0.06971484f, 0.01983027f, -0.08718722f, 
    0.10482304f, -0.08739007f, -0.02476715f, -0.00279890f, -0.00803034f, 0.03513622f, 0.10856402f, 0.06976959f, 
    -0.01064114f, -0.03501271f, 0.02332120f, 0.04385616f, -0.03203046f, 0.11607356f, 0.10914817f, -0.12267956f, 
    -0.05553629f, -0.09349683f, -0.07173398f, -0.09806043f, -0.01746349f, -0.04259276f, 0.09838471f, 0.00768720f, 
    0.00797962f, -0.08135070f, -0.10450235f, 0.00438218f, -0.04726973f, -0.08137272f, 0.02414367f, -0.11752132f, 
    0.00629002f, -0.12186325f, -0.11831737f, 0.04162768f, 0.04593265f, -0.10482004f, 0.06803201f, 0.02777536f, 
    -0.08415666f, -0.05796300f, 0.00385097f, -0.10400452f, -0.04303075f, -0.10324004f, 0.03665580f, 0.03519525f, 
    -0.06656902f, -0.01018785f, 0.11336403f, -0.00879492f, -0.03794174f, -0.07701996f, 0.00598888f, 0.11072399f, 
    -0.05903957f, -0.09362178f, 0.11613337f, 0.00909161f, -0.21360442f, -0.14572103f, 0.08126721f, -0.19903165f, 
    0.00756011f, -0.18515402f, -0.15563208f, 0.05229280f, 0.14880379f, 0.03733734f, -0.07412447f, 0.31628543f, 
    0.05540307f, -0.02769586f, -0.07779957f, 0.10350695f, 0.33193451f, 0.06863116f, 0.22280616f, 0.01037806f, 
    0.24492660f, -0.24637303f, -0.14572249f, -0.25370768f, -0.18275601f, 0.45513448f, 0.01664764f, 0.10727732f, 
    -0.49060246f, -0.19561206f, -0.10039572f, 0.09992805f, 0.01330008f, -0.07130133f, 0.08960784f, 0.05560299f, 
    -0.15534015f, 0.22269063f, -0.02968485f, 0.58931327f, 0.28955862f, 0.11900477f, 0.20512323f, 0.41311765f, 
    0.22153799f, 0.03288929f, 0.23298965f, -0.00368590f, 0.39641502f, -0.25775528f, -0.08839059f, -0.11881752f, 
    0.34184310f, 0.08310051f, -0.12333701f, -0.05268065f, -0.07170966f, 0.22280169f, 0.05374252f, 0.11060950f, 
    -0.11656084f, 0.05913215f, -0.01123300f, 0.09473789f, -0.03614034f, -0.10852447f, 0.11204684f, 0.04190833f, 
    -0.14259513f, -0.13980566f, -0.07522205f, -0.13109976f, 0.05707848f, -0.07293558f, 0.09388459f, -0.09289563f, 
    -0.06668290f, -0.02289781f, 0.07371251f, 0.05746655f, 0.07601923f, 0.08116221f, -0.04759319f, -0.06255098f, 
    0.10106702f, -0.03861167f, -0.05532642f, -0.01594474f, -0.10917674f, -0.03732195f, -0.06002634f, -0.07360265f, 
    -0.05965932f, 0.08625104f, -0.01110810f, -0.05369981f, -0.09068656f, 0.03918889f, 0.11775039f, 0.09080289f, 
    0.07626153f, -0.06106536f, 0.05238528f, 0.08116928f, -0.01302922f, 0.01525238f, -0.01776282f, -0.04403459f, 
    -0.03256991f, 0.04781871f, -0.10991839f, -0.14163715f, 0.08160957f, -0.00309725f, -0.02215597f, 0.06304076f, 
    -0.01711687f, -0.02939911f, 0.03081821f, -0.08303233f, -0.02603279f, 0.01378744f, -0.07022530f, -0.14616488f, 
    0.00278092f, 0.04106027f, -0.07460318f, 0.01884952f, -0.02206296f, -0.02500830f, 0.04089311f, 0.02958449f, 
    -0.08571693f, -0.08111355f, -0.04798532f, 0.10522674f, -0.07071167f, 0.09510291f, 0.09578393f, 0.00105379f, 
    -0.08935955f, 0.08579555f, 0.02269785f, -0.07770685f, -0.00819337f, -0.12932922f, 0.03070413f, 0.06102391f, 
    -0.05867729f, 0.02006297f, -0.00003648f, -0.04941467f, -0.12462620f, 0.11583500f, 0.09708613f, -0.11116156f, 
    0.09056088f, -0.05497763f, -0.08255710f, -0.09305996f, -0.06588165f, 0.03339452f, 0.06353396f, 0.02693674f, 
    -0.04037890f, 0.10606610f, 0.08679372f, 0.09395100f, -0.02235711f, 0.01432105f, -0.12100418f, -0.10592823f, 
    -0.02899135f, -0.02985894f, -0.11998481f, 0.00344724f, -0.06035011f, 0.11908485f, -0.06259944f, -0.00702800f, 
    0.03370826f, 0.02823103f, -0.10544979f, -0.13512157f, 0.08364689f, -0.01188172f, 0.06684287f, 0.11057997f, 
    0.04294468f, 0.21132153f, -0.09650991f, 0.01635475f, 0.18191133f, 0.16026375f, -0.09467085f, 0.11568569f, 
    -0.08322642f, 0.25664094f, -0.15112936f, -0.16053942f, 0.20731765f, -0.49001339f, -0.01506136f, -0.01040837f, 
    -0.07153878f, 0.09169536f, 0.16594152f, 0.17733127f, -0.09167869f, -0.28646657f, 0.03075065f, -0.04003964f, 
    0.24613622f, 0.06026986f, 0.34898096f, 0.27678946f, 0.21234190f, -0.09519538f, -0.06770696f, -0.19016927f, 
    0.20194207f, 0.09536403f, 0.19100392f, 0.00745957f, 0.01158038f, 0.13282138f, -0.04266085f, 0.00084694f, 
    0.31397721f, 0.01260231f, 0.08699945f, -0.29165432f, -0.27469882f, 0.19272527f, 0.09621085f, -0.25632140f, 
    0.17056295f, -0.01470236f, 0.05279345f, 0.43133950f, -0.05010895f, -0.09726889f, 0.22213764f, -0.15286587f, 
    0.05078967f, 0.27473935f, -0.15987514f, -0.31121734f, -0.02413395f, 0.31868672f, 0.00092076f, -0.04643745f, 
    0.02899497f, 0.42982200f, 0.12311403f, -0.11095404f, -0.16685729f, -0.00755210f, -0.11297332f, 0.30242100f, 
    -0.08989929f, -0.17621593f, 0.27498215f, -0.05441641f, -0.07728840f, 0.54664445f, 0.04551648f, -0.16454631f, 
    -0.02642438f, -0.16696842f, 0.10084924f, 0.13017343f, 0.03625096f, 0.12731816f, -0.07795958f, -0.10298382f, 
    -0.29271629f, 0.06353865f, 0.01978930f, -0.13651344f, -0.16403560f, -0.12980363f, 0.23838682f, 0.37774983f, 
    -0.08008631f, 0.14763997f, 0.00336810f, 0.26933807f, 0.14930668f, -0.10828013f, -0.10698359f, -0.04089569f, 
    -0.09086859f, -0.05103052f, -0.08597755f, -0.12617850f, 0.59587216f, 0.02712268f, 0.24604267f, 0.03576377f, 
    0.06172667f, 0.48550090f, 0.00895262f, -0.11077747f, 0.07378306f, 0.20983361f, 0.07870929f, -0.10872297f, 
    -0.09962669f, -0.00533658f, 0.26508799f, -0.09323407f, -0.10368344f, -0.20328143f, 0.04480463f, 0.03833762f, 
    0.06879887f, -0.09110424f, 0.00746474f, 0.11683509f, -0.11861460f, 0.06759105f, -0.09007104f, -0.06036723f, 
    0.12195787f, -0.10044161f, -0.06596104f, -0.01054828f, 0.09819676f, 0.02049295f, -0.05680279f, -0.01017132f, 
    -0.06700484f, -0.12345906f, -0.02041123f, -0.12365172f, -0.11072490f, -0.10842325f, 0.01684013f, 0.12463410f, 
    0.06903225f, 0.08290538f, -0.11836312f, 0.06848197f, -0.00704438f, -0.08664533f, 0.01025565f, -0.13084461f, 
    -0.08364522f, -0.12658285f, 0.00812832f, -0.00631159f, -0.07365844f, -0.08038747f, 0.11403613f, -0.01205093f, 
    0.01872389f, -0.04691964f, 0.07180772f, 0.01486492f, 0.03087877f, -0.07282480f, -0.06213988f, 0.05827873f, 
    0.04911529f, 0.04644625f, -0.00876586f, 0.01972413f, -0.06275918f, -0.10686156f, -0.11819860f, 0.08918726f, 
    -0.05546613f, -0.07981434f, -0.06264926f, -0.08386405f, 0.03381461f, 0.01412266f, 0.11818939f, -0.02313185f, 
    -0.08626310f, -0.23103166f, 0.21765916f, -0.07378690f, 0.05204049f, 0.26277360f, -0.11632873f, 0.25332427f, 
    0.37638229f, -0.03999262f, -0.42891076f, 0.34803313f, 0.21204311f, -0.28754821f, -0.02069312f, -0.02243520f, 
    -0.08015904f, -0.25427276f, -0.18161410f, 0.18119828f, -0.57131463f, -0.57057822f, 0.06882267f, 0.11053902f, 
    -0.10387786f, 0.07829426f, 0.18015361f, -0.20259295f, 0.16353196f, -0.29835457f, -0.43194777f, 0.34281096f, 
    0.32360405f, 0.18171589f, 0.23644072f, 0.05389761f, -0.02071231f, 0.04835777f, 0.04272158f, -0.11298519f, 
    -0.44168037f, 0.26617759f, 0.18144454f, -0.35092404f, -0.11497298f, -0.32707548f, 0.06275161f, -0.19025797f, 
    -0.37124020f, 0.37958187f, 0.36114517f, 0.20288540f, 0.39983296f, 0.29383734f, 0.34785062f, 0.12240179f, 
    0.04252328f, 0.28410068f, 0.22394611f, 0.35111773f, 0.02674875f, 0.05537938f, -0.11490338f, -0.00979934f, 
    0.09635472f, 0.25749278f, 0.32484755f, 0.09603269f, -0.00699765f, 0.06535760f, 0.00301546f, 0.06011029f, 
    0.06347638f, 0.14597209f, 0.11130997f, 0.23395966f, -0.14973189f, -0.02471216f, 0.02264488f, -0.09761246f, 
    -0.09792519f, 0.07589073f, 0.12265848f, 0.02307397f, -0.02438304f, -0.12069444f, 0.00560388f, -0.07323363f, 
    -0.12831609f, 0.16110183f, -0.25007784f, -0.07503550f, 0.00554967f, -0.35748559f, -0.14689739f, -0.05712805f, 
    -0.01087584f, 0.35238943f, 0.17605947f, 0.16768235f, -0.42776415f, -0.08913083f, 0.02929386f, -0.11560385f, 
    0.07657617f, 0.05103434f, 0.11532266f, 0.02418703f, 0.16416200f, -0.13959411f, -0.17451054f, 0.27761853f, 
    0.05729356f, 0.23870692f, 0.18634452f, 0.08911924f, -0.02390262f, 0.11229548f, 0.25782037f, 0.20818412f, 
    -0.21608190f, 0.22748175f, 0.36176723f, -0.18452504f, 0.00146589f, -0.26840386f, -0.03424750f, 0.21770400f, 
    -0.14070582f, 0.16730636f, -0.08540348f, 0.00535764f, -0.18648618f, 0.20759703f, 0.01525237f, 0.38586965f, 
    -0.27772906f, 0.26416358f, 0.23566085f, -0.05790472f, 0.12433367f, 0.44110295f, 0.09870245f, 0.09530718f, 
    -0.08549500f, -0.12426274f, 0.23615411f, 0.02245480f, 0.02395040f, -0.21639895f, 0.09057195f, -0.02096170f, 
    -0.44593117f, -0.08875354f, 0.39597720f, 0.31628850f, 0.10618535f, 0.11110089f, 0.14672118f, 0.48503277f, 
    -0.18170288f, -0.04728349f, -0.08923688f, 0.28261217f, 0.59251428f, -0.06293388f, -0.11465915f, -0.06138902f, 
    -0.25787172f, 0.04773507f, 0.06013737f, -0.40435398f, 0.37920880f, 0.03111811f, 0.24296317f, 0.03412702f, 
    0.15731466f, 0.44525588f, 0.16942742f, -0.14801981f, 0.16801508f, -0.02310269f, -0.11134002f, -0.08943896f, 
    -0.09357011f, -0.29534984f, -0.25722447f, -0.01118894f, -0.10678166f, -0.18010493f, 0.08193479f, 0.10267976f, 
    0.18224709f, -0.16240805f, -0.02559637f, 0.10417919f, 0.25145710f, -0.01317930f, 0.16043244f, -0.33331260f, 
    -0.11250711f, -0.10837632f, 0.04929860f, -0.14602859f, 0.01709088f, -0.34110323f, 0.04307880f, 0.12935793f, 
    -0.00786108f, 0.45090312f, 0.10736271f, -0.04361124f, 0.53680342f, 0.27132988f, 0.17747052f, 0.02971477f, 
    0.39663848f, -0.04304121f, -0.05950705f, 0.10052739f, 0.12657940f, 0.32572424f, 0.22177164f, -0.47113648f, 
    -0.10405309f, 0.01573361f, 0.10007457f, 0.16901052f, -0.22137074f, -0.02300143f, 0.00084793f, 0.07772347f, 
    0.43806860f, 0.03724545f, 0.17359670f, 0.24518709f, -0.28187919f, 0.35302612f, -0.05681135f, 0.17574644f, 
    0.42545354f, -0.54146427f, -0.12965283f, 0.10839158f, 0.01050601f, -0.36143056f, -0.07817820f, -0.16079561f, 
    0.22372581f, 0.21793957f, -0.27624324f, -0.19470294f, 0.09884987f, 0.43250287f, 0.05885263f, 0.25694919f, 
    0.09741373f, -0.16657837f, 0.09350982f, -0.06340846f, 0.11763895f, 0.00161765f, -0.11762977f, -0.22100765f, 
    0.12034295f, 0.07071843f, -0.16323304f, 0.22430982f, 0.15219285f, -0.58947694f, 0.05458516f, -0.02276206f, 
    -0.06604283f, 0.28724009f, -0.19220205f, -0.11767994f, 0.00228746f, 0.42278090f, 0.15512954f, 0.22573780f, 
    0.48137215f, 0.08452050f, -0.02186328f, 0.00539438f, 0.15158749f, -0.07998399f, -0.19945957f, -0.16921751f, 
    0.05351577f, 0.21504399f, 0.17126606f, 0.06342454f, -0.22750260f, -0.07259507f, -0.05075366f, -0.09618077f, 
    0.09755632f, 0.05398583f, 0.21315013f, -0.03512034f, -0.41027263f, -0.05366045f, -0.32432532f, 0.21582909f, 
    0.15082346f, -0.33428562f, -0.04717322f, 0.02182669f, -0.21662882f, 0.02601106f, 0.20613150f, 0.13181379f, 
    -0.01053067f, 0.26580039f, 0.14138354f, 0.20434107f, 0.00135567f, 0.12203159f, 0.11713696f, 0.16007915f, 
    -0.03225426f, 0.13616675f, 0.01138055f, -0.09979473f, -0.02438007f, 0.02197045f, 0.01367144f, -0.14485678f, 
    0.10379314f, -0.10816505f, 0.01029782f, 0.06698935f, -0.00081545f, -0.11735918f, -0.09494399f, 0.01963673f, 
    -0.04520988f, -0.02986030f, -0.01901162f, 0.01840510f, -0.04359828f, 0.03472101f, 0.07154592f, -0.01210796f, 
    0.03810583f, -0.01900864f, -0.07410014f, -0.05330387f, -0.12953790f, 0.02405992f, -0.13304286f, -0.12989435f, 
    -0.05185649f, 0.05993828f, -0.12888354f, -0.12960295f, -0.21273150f, 0.02561365f, -0.10466728f, 0.00815201f, 
    0.01049162f, -0.03240135f, -0.13780524f, 0.11800581f, 0.05889120f, 0.06614385f, -0.14341426f, 0.06341764f, 
    -0.08892325f, -0.20372650f, -0.08407454f, -0.05171325f, -0.07962190f, -0.18700333f, -0.15257926f, 0.03282901f, 
    -0.00436976f, 0.07351448f, 0.04359740f, -0.03899249f, 0.10616209f, 0.08831231f, 0.07788965f, -0.01508787f, 
    0.28428891f, 0.27039090f, 0.19984615f, -0.06427468f, 0.21029130f, -0.00074038f, -0.14623204f, -0.25418177f, 
    0.06166844f, -0.00769278f, 0.19879012f, 0.00464756f, -0.08654840f, -0.12404419f, 0.04064844f, -0.02499734f, 
    -0.13516566f, 0.26875883f, 0.23332500f, 0.00858535f, 0.11191598f, 0.17677942f, -0.07730855f, 0.07669456f, 
    0.41363326f, 0.15217648f, -0.08339082f, -0.14825881f, 0.17496945f, -0.09013664f, 0.17881417f, -0.12449656f, 
    0.22704971f, 0.21475247f, 0.23154213f, 0.15955956f, -0.29709205f, -0.08450020f, -0.10684648f, -0.04572389f, 
    0.34365919f, -0.15078756f, 0.18740182f, -0.07392684f, 0.15830784f, -0.09506915f, -0.29386219f, -0.06648619f, 
    0.13260920f, -0.09159034f, 0.00615935f, 0.25679407f, -0.20999281f, 0.09985214f, 0.18435390f, -0.01387392f, 
    -0.20347196f, 0.10430031f, 0.31742498f, -0.29566926f, 0.09774826f, -0.26360679f, -0.08972149f, 0.24486205f, 
    0.00528809f, -0.02151992f, 0.04682393f, -0.03284473f, -0.08334976f, 0.08582740f, -0.07093479f, -0.10410694f, 
    0.00754446f, 0.09492573f, -0.13912970f, -0.03609204f, -0.04970988f, -0.09847081f, -0.08725853f, -0.12381616f, 
    -0.00063230f, -0.01686273f, -0.13492385f, -0.05494491f, 0.08284558f, -0.09444409f, 0.01594419f, -0.07987805f, 
    0.01248726f, -0.10829690f, 0.04574633f, -0.08691776f, -0.13159846f, -0.06268577f, 0.06536610f, 0.08506740f, 
    -0.12753753f, 0.00738173f, -0.06602130f, -0.01939359f, -0.05585470f, -0.04557854f, -0.03874598f, 0.05020392f, 
    0.05631857f, 0.01950058f, -0.07731009f, 0.05166442f, -0.01185964f, 0.11105331f, 0.04650090f, -0.06677754f, 
    0.07116269f, -0.01429061f, 0.08567454f, 0.09045842f, -0.12403819f, -0.08678368f, 0.04526393f, -0.09972572f, 
    -0.03817953f, 0.09013199f, -0.13936739f, -0.08661585f, 0.06843820f, -0.07731854f, -0.07006516f, -0.01387575f, 
    -0.02307233f, 0.00454856f, -0.00528216f, -0.09750362f, -0.11529826f, 0.01827754f, 0.08375682f, 0.03062029f, 
    -0.12211725f, -0.09656371f, -0.06292666f, -0.03085203f, 0.00401956f, -0.10029751f, 0.07318333f, -0.07427901f, 
    0.04817513f, 0.06947893f, -0.05263095f, -0.07329562f, -0.04222822f, -0.06308021f, 0.06810978f, -0.05705692f, 
    0.01722066f, 0.09028645f, 0.11772192f, -0.10989203f, -0.02439691f, -0.07966863f, -0.09834526f, -0.02111374f, 
    0.05695462f, -0.00517929f, -0.03536831f, -0.10054134f, 0.07240561f, 0.03151610f, -0.01799455f, 0.09127274f, 
    0.05896220f, -0.06163409f, -0.12395038f, -0.06686112f, -0.09631194f, 0.04133078f, 0.00132827f, -0.10798551f, 
    0.11575538f, 0.08213148f, -0.11681397f, -0.04472457f, -0.07252546f, -0.01409456f, 0.00303032f, 0.00085905f, 
    0.00319119f, 0.04298970f, -0.03492413f, -0.10667235f, -0.00331317f, 0.08700188f, -0.09058891f, 0.11328593f, 
    -0.16760045f, 0.10333759f, 0.05574499f, -0.03539302f, -0.15082842f, 0.22048855f, -0.08852705f, 0.01665434f, 
    -0.01335751f, -0.08225976f, -0.08540509f, -0.18298712f, 0.22695991f, -0.17790738f, -0.04008634f, 0.31803563f, 
    -0.07428237f, 0.01586836f, 0.12367239f, 0.13449165f, 0.20272759f, -0.34005597f, 0.20385516f, -0.17266202f, 
    0.05267646f, 0.10205238f, 0.01452337f, 0.05658274f, 0.04431646f, 0.21046986f, 0.08494110f, 0.21735860f, 
    -0.05247039f, -0.06800237f, 0.14173229f, -0.14131571f, 0.06310708f, -0.07573775f, 0.01197624f, -0.07121811f, 
    -0.09550001f, 0.17430480f, 0.01307139f, -0.01936344f, 0.26042345f, 0.15083675f, 0.35463589f, -0.01649074f, 
    0.02245022f, 0.22126615f, 0.18257634f, 0.20856871f, 0.24977501f, 0.20554459f, 0.00839355f, -0.39155757f, 
    0.18636124f, -0.04215898f, -0.26865318f, -0.11394532f, -0.09717777f, -0.27939549f, -0.01934769f, -0.02839035f, 
    -0.06578247f, -0.17661510f, -0.07923599f, 0.09133087f, -0.11536974f, 0.35779023f, 0.00200246f, 0.20987727f, 
    0.23046346f, -0.09547853f, -0.26962134f, 0.09293985f, 0.21126112f, -0.37984103f, -0.02865932f, 0.19972056f, 
    -0.01546944f, -0.08327042f, -0.00428861f, 0.36896825f, -0.30792102f, -0.53869891f, 0.22570452f, -0.03642841f, 
    0.11875965f, 0.06149990f, -0.02006107f, -0.08036666f, 0.16860695f, 0.28484902f, -0.11968386f, 0.55228597f, 
    0.25374913f, -0.01661060f, 0.17180522f, -0.04654227f, 0.10450146f, 0.01513518f, -0.10278238f, 0.08849735f, 
    0.00155111f, 0.39838740f, 0.02435087f, -0.09178729f, 0.02287277f, 0.13693225f, 0.38510746f, -0.15414268f, 
    -0.29969347f, 0.19325775f, 0.31261513f, 0.02197353f, 0.61780423f, 0.41310024f, -0.08031762f, -0.02926246f, 
    0.05355987f, 0.32312930f, -0.21040750f, 0.11177968f, 0.02911708f, 0.35453215f, -0.04573694f, -0.21720152f, 
    0.08858611f, 0.17398928f, 0.12443329f, 0.00980164f, 0.02419532f, 0.14193530f, -0.09364492f, 0.14260127f, 
    0.22861543f, -0.04161144f, 0.20110729f, 0.15206093f, 0.08638698f, 0.10609525f, 0.09850954f, -0.21709785f, 
    -0.09310473f, 0.00624493f, 0.15390246f, 0.06786963f, 0.21977416f, -0.26617473f, 0.12245195f, -0.23277171f, 
    -0.18005170f, 0.07355095f, 0.09604605f, -0.16294399f, -0.05745144f, -0.25190517f, 0.03564515f, 0.02755277f, 
    -0.05867503f, 0.30478483f, 0.26767457f, 0.05912353f, 0.00694391f, -0.10409441f, 0.07699102f, -0.12786824f, 
    -0.05222481f, -0.01163501f, 0.19073139f, -0.24798445f, 0.33227706f, -0.42922583f, 0.09358503f, 0.03047157f, 
    -0.10007861f, 0.16405024f, 0.05476959f, 0.02297120f, 0.19743906f, 0.31221390f, 0.33252463f, -0.28035089f, 
    -0.03785956f, -0.16986348f, 0.23014373f, 0.12383162f, -0.02943802f, -0.65508777f, 0.09002860f, 0.18971030f, 
    0.10055860f, -0.09955801f, 0.20536323f, 0.03513929f, 0.09531493f, -0.08488572f, 0.10525901f, -0.06666519f, 
    0.07497562f, -0.15758820f, 0.23841333f, 0.19325228f, -0.36642867f, 0.43685001f, -0.09149007f, -0.28674242f, 
    0.07437544f, 0.07192160f, -0.04737166f, 0.02303424f, 0.16075680f, -0.05244345f, -0.19120876f, 0.21559851f, 
    -0.26335430f, 0.05342615f, -0.28166696f, 0.17018056f, -0.09725054f, -0.13194688f, 0.17781518f, -0.13205901f, 
    -0.14783193f, 0.23535162f, 0.09561680f, 0.31954578f, 0.13083443f, -0.03469913f, -0.06120491f, -0.00484317f, 
    -0.07596458f, -0.04810136f, 0.08133110f, 0.31750727f, -0.04739833f, 0.17877457f, -0.18446188f, 0.12018622f, 
    0.09643360f, 0.00527980f, -0.17980407f, -0.14361560f, -0.20451102f, 0.13176936f, 0.05725778f, 0.35175946f, 
    -0.07403192f, -0.13279606f, 0.52545714f, 0.47522345f, 0.08083867f, -0.23866054f, -0.09498693f, 0.26978874f, 
    -0.11067395f, 0.04358789f, -0.03119250f, 0.11704595f, -0.10156323f, 0.10617705f, 0.09251647f, -0.00433031f, 
    0.04909496f, 0.02578707f, -0.11053969f, -0.04345354f, 0.00654311f, -0.08536437f, -0.04410662f, -0.03057465f, 
    0.07410377f, 0.00960541f, -0.07896967f, -0.06061716f, 0.10391603f, 0.07346176f, -0.10506856f, -0.09828061f, 
    -0.02322040f, 0.11685956f, -0.00784282f, -0.09776288f, -0.04002556f, 0.07286818f, -0.09629402f, -0.06083523f, 
    -0.09512475f, 0.09634049f, -0.11553061f, -0.01055685f, -0.01035029f, -0.07221472f, 0.10551432f, -0.12267286f, 
    0.06943984f, -0.09747942f, 0.01753147f, 0.07799625f, -0.06252457f, -0.06237091f, -0.02269824f, -0.08516034f, 
    -0.03408751f, -0.09115858f, -0.12435704f, 0.00746819f, 0.06578216f, 0.00045110f, -0.08562233f, -0.12188429f, 
    0.08770712f, 0.05592670f, -0.10241707f, 0.12353587f, 0.07099760f, -0.09837566f, 0.06585526f, 0.02933411f, 
    0.32320857f, -0.32153171f, -0.01717728f, -0.01144707f, -0.03416860f, -0.05563168f, 0.14060935f, -0.13278922f, 
    -0.14049706f, 0.07201694f, -0.19007966f, 0.48140192f, -0.01590697f, 0.14022402f, 0.02275385f, -0.15163371f, 
    -0.01501891f, 0.03841941f, -0.20539436f, 0.07543134f, -0.11816500f, -0.03536530f, 0.03316973f, 0.18514946f, 
    -0.16212779f, -0.08645450f, 0.09955042f, -0.05155138f, 0.05084799f, 0.29400066f, -0.27048457f, 0.17588203f, 
    0.00189338f, 0.23546855f, -0.01720001f, 0.17366563f, 0.18248864f, -0.05265552f, -0.00740688f, 0.01515706f, 
    -0.48142266f, 0.03141877f, 0.15946288f, 0.32315809f, -0.44814807f, -0.21598300f, 0.05014328f, 0.12331076f, 
    -0.11447431f, -0.00090264f, 0.17602287f, -0.01839066f, 0.31013986f, -0.08490552f, 0.27528775f, 0.31535131f, 
    0.15908474f, -0.03485277f, 0.03385279f, 0.59818047f, -0.07539476f, 0.12306093f, 0.05135616f, 0.06195888f, 
    0.10730971f, -0.04028638f, 0.33483768f, 0.08617377f, -0.13622572f, 0.18017967f, -0.02117212f, 0.15809254f, 
    -0.05210266f, -0.09518222f, -0.14221317f, 0.44835335f, 0.15220371f, -0.52982497f, -0.03936921f, -0.07944100f, 
    -0.04606853f, -0.08608413f, -0.37185317f, 0.06125451f, -0.28187066f, -0.11560843f, 0.04303440f, 0.40096438f, 
    -0.26368466f, 0.03883496f, -0.05324314f, -0.32830545f, -0.01738112f, -0.12682626f, -0.29240009f, 0.17370060f, 
    -0.12279552f, 0.13608009f, 0.06698720f, 0.14035895f, -0.28360760f, -0.01166618f, 0.11946375f, 0.11146363f, 
    -0.40439579f, 0.18109427f, 0.28443930f, 0.05049144f, -0.19132896f, -0.04599198f, 0.05983293f, 0.57786971f, 
    0.05708639f, -0.07562977f, 0.25567684f, -0.01154325f, 0.22032963f, -0.14158675f, 0.19837888f, 0.14286995f, 
    0.25435579f, 0.34762248f, -0.14432529f, 0.25459000f, 0.05570304f, -0.01732242f, 0.00631850f, 0.29991344f, 
    0.02968076f, 0.00061299f, -0.03040895f, 0.11022288f, -0.09903938f, -0.11370855f, 0.01250139f, -0.06825102f, 
    0.08263125f, 0.04053441f, 0.06214472f, 0.04204920f, -0.02087540f, -0.59828198f, 0.06585972f, 0.19135799f, 
    0.00536087f, 0.34199673f, 0.08687749f, 0.00564295f, 0.56640184f, 0.14884160f, 0.24075520f, -0.13545233f, 
    0.34739798f, 0.11462361f, -0.05067826f, 0.04589523f, -0.20907184f, 0.07660495f, 0.32524499f, -0.19397666f, 
    -0.40108871f, -0.15032385f, 0.08591000f, 0.03013176f, -0.11082467f, -0.00617661f, -0.10072617f, 0.04901103f, 
    0.18479098f, 0.10300428f, -0.05186225f, 0.20203756f, 0.12649943f, -0.00426676f, 0.11321624f, 0.37790635f, 
    0.37397623f, -0.14578988f, -0.00501565f, -0.09342752f, 0.08689308f, -0.15194453f, -0.09361284f, -0.32858330f, 
    0.28471351f, -0.00512089f, -0.30166203f, -0.11087663f, -0.00183288f, -0.19453676f, 0.07212920f, 0.19347249f, 
    0.12466600f, 0.59076571f, 0.01931637f, 0.00216857f, 0.24962944f, -0.07605107f, -0.07717508f, 0.14804287f, 
    -0.37271985f, 0.16872278f, 0.54895824f, -0.04168846f, 0.04141342f, 0.61672211f, -0.05073779f, -0.03389587f, 
    0.01791592f, 0.01438561f, 0.49143112f, -0.19642909f, 0.18749331f, 0.08838829f, 0.19644514f, -0.31496474f, 
    -0.09526994f, 0.15494463f, 0.27297765f, 0.39338654f, 0.06541426f, -0.07850339f, 0.22156504f, 0.08433858f, 
    -0.14740945f, -0.07460768f, 0.07720904f, 0.06148409f, 0.27273011f, 0.11888100f, 0.03304437f, 0.07825343f, 
    0.24373722f, -0.18166219f, -0.07782749f, -0.01838364f, 0.59122092f, 0.02647258f, -0.03468090f, -0.01865755f, 
    0.38586313f, 0.31993565f, -0.13220301f, 0.02866904f, -0.15277462f, -0.02570291f, 0.05825156f, 0.08776791f, 
    -0.28294829f, -0.17464411f, 0.26907492f, -0.57035553f, -0.04080455f, -0.23696791f, -0.00803647f, 0.06918058f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.22623797f, 0.26535332f, -0.06338878f, 0.11158511f, -0.00979337f, 0.10471232f, 0.00390758f, -0.08934412f, 
    0.18997970f, -0.05643236f, 0.14185929f, -0.02142000f, 0.15721999f, -0.03766957f, 0.04948878f, 0.24650043f, 
    0.02331955f, 0.04538532f, 0.07258226f, 0.20533057f, -0.13521275f, 0.24273255f, -0.10811640f, 0.08185214f, 
    -0.12663160f, -0.10695371f, -0.16259474f, 0.02866528f, 0.10560086f, -0.05390962f, -0.01602520f, 0.00285268f, 
    0.17686076f, 0.13625507f, -0.11106710f, 0.11329760f, -0.09710792f, -0.13096540f, 0.04047603f, -0.04868609f, 
    0.06862498f, -0.14293304f, -0.03946459f, 0.02104738f, 0.08189671f, -0.01883262f, 0.29031628f, 0.04226699f, 
    0.11031824f, 0.11644808f, 0.20218998f, -0.01860168f, 0.11691568f, 0.07896382f, 0.05567896f, 0.10818186f, 
    0.19583704f, -0.01123870f, -0.10600974f, -0.11929266f, 0.01775888f, 0.17725153f, 0.09545051f, -0.01123432f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.37195495f, 0.16197243f, -0.03972081f, 0.20392491f, -0.09318221f, -0.46947688f, 0.24159266f, -0.14792579f, 
    0.23171736f, 0.11463320f, -0.12137370f, -0.03965713f, -0.68652445f, -0.24241696f, -0.38857156f, 0.06024931f, 
    -0.38007468f, 0.09557694f, -0.04385840f, -0.27322572f, -0.30201238f, -0.30098268f, 0.05250955f, -0.30285940f, 
    -0.38633594f, 0.02350565f, -0.28687471f, 0.10108889f, -0.20281813f, -0.14237289f, 0.02635409f, 0.16402823f, 
    0.03180845f, 0.14793514f, -0.00333109f, 0.17416832f, 0.06483010f, 0.05864241f, 0.16293631f, -0.09905465f, 
    -0.60774475f, -0.11608104f, 0.07058916f, 0.13108924f, 0.16906205f, -0.13548487f, 0.22101772f, 0.19960925f, 
    0.13812053f, -0.41579410f, 0.02638372f, -0.08843295f, 0.12364609f, 0.01005057f, 0.05365622f, -0.15797979f, 
    -0.14698647f, 0.22926225f, -0.12541549f, 0.09615408f, 0.08316408f, 0.15098867f, -0.56055576f, 0.28200042f, 
    -0.07139868f, -0.26587337f, 0.11366619f, -0.14542961f, -0.11433490f, 0.28353366f, 0.08148426f, -0.05324284f, 
    0.10295556f, 0.04933378f, -0.40183559f, 0.23789625f, 0.36153895f, -0.11885781f, 0.05074226f, 0.05252611f, 
    -0.10895770f, 0.05261303f, -0.01990901f, -0.30746609f, 0.00816405f, -0.00843429f, -0.03299060f, -0.05334998f, 
    -0.02794081f, -0.09373823f, 0.42476335f, 0.07057498f, -0.05354761f, 0.04700670f, -0.02356403f, 0.29442295f, 
    0.02451169f, -0.38620755f, -0.03407225f, 0.03726124f, -0.02247269f, 0.08684153f, 0.19395819f, -0.03078148f, 
    -0.37524492f, -0.03068935f, -0.06825784f, 0.14933918f, 0.14555213f, -0.04147372f, 0.08793624f, -0.09422621f, 
    0.24369268f, -0.36801377f, -0.51801640f, -0.01889776f, -0.17996909f, 0.07195191f, 0.07746519f, 0.18789689f, 
    0.16078594f, 0.07502922f, -0.01721573f, 0.05310088f, -0.35177416f, -0.26166609f, -0.52381450f, 0.05771560f, 
    0.04881725f, -0.24999389f, -0.28392002f, -0.55471098f, -0.44837922f, -0.08626507f, -0.03167208f, 0.04416220f, 
    0.03690951f, -0.00830854f, -0.09713399f, 0.13797051f, -0.11461946f, 0.34266660f, -0.34081340f, -0.06034087f, 
    -0.18424152f, -0.00785195f, 0.10071084f, 0.22262320f, -0.14274801f, -0.16286038f, 0.02413364f, 0.02327684f, 
    -0.11207917f, -0.04724750f, -0.16480184f, -0.23862827f, -0.65176326f, 0.42209104f, 0.01804388f, 0.09150080f, 
    -0.33173442f, 0.05670528f, -0.00262544f, 0.02959866f, 0.07604805f, 0.02880215f, 0.12167389f, -0.05932793f, 
    0.30896190f, -0.06830957f, -0.10260135f, -0.14443499f, 0.24993640f, -0.02551815f, -0.08497542f, -0.14003852f, 
    0.29759550f, -0.11873569f, -0.30690652f, -0.11456169f, -0.22877239f, 0.06657566f, 0.11574124f, 0.27431548f, 
    0.06723677f, 0.23465385f, -0.34630740f, -0.04727276f, -0.60335028f, -0.37313196f, 0.39651212f, 0.31311342f, 
    0.28794983f, 0.03896089f, 0.13154210f, 0.11114890f, 0.03080489f, 0.25590429f, -0.54575551f, 0.09920740f, 
    0.01610874f, -0.04591973f, -0.01756046f, 0.14637886f, -0.10067216f, -0.08180378f, 0.10695345f, -0.17282663f, 
    0.26604372f, 0.00378965f, 0.05603013f, -0.36052489f, 0.22160903f, 0.03654843f, -0.09035502f, 0.09719738f, 
    0.12230127f, 0.00730259f, -0.05082271f, 0.07813225f, -0.10320821f, -0.10998370f, 0.00471383f, -0.33339962f, 
    -0.13487086f, 0.03840434f, -0.12180118f, 0.23738888f, 0.03667202f, -0.04714289f, -0.35823801f, 0.11391070f, 
    -0.33576432f, -0.00514276f, -0.01850391f, -0.10637129f, -0.15117997f, 0.03198044f, -0.39516231f, -0.02305128f, 
    -0.35422066f, 0.17164156f, 0.23920988f, -0.09997174f, 0.18566172f, -0.07312449f, 0.09302741f, -0.50622326f, 
    -0.60714775f, 0.15853684f, 0.11652546f, -0.09312455f, 0.05213776f, -0.12974307f, 0.16987842f, 0.00537307f, 
    -0.27304170f, 0.17224698f, -0.53296161f, 0.02205333f, 0.22495112f, 0.06729931f, 0.00867606f, -0.05030836f, 
    0.23269425f, 0.06490381f, 0.19550760f, -0.19645374f, -0.02084205f, 0.14666589f, 0.07667747f, -0.22848366f, 
    0.08228087f, 0.03571335f, -0.09575825f, -0.28381437f, -0.43350053f, 0.07261354f, 0.06534973f, -0.01774908f, 
    0.10262392f, -0.02546342f, -0.25300324f, -0.19212149f, -0.00444509f, -0.08736743f, 0.09336771f, -0.24613433f, 
    0.12630498f, 0.05630257f, -0.04280050f, -0.29570022f, 0.06096938f, 0.10582292f, -0.14781806f, -0.08111398f, 
    0.14798196f, -0.02712241f, 0.06257579f, -0.05023024f, 0.13753872f, 0.11114067f, 0.06498571f, 0.23105685f, 
    -0.31540781f, -0.04106516f, 0.11663729f, -0.05929188f, 0.18891874f, 0.01085397f, 0.05746622f, -0.07775883f, 
    -0.00000619f, -0.02551107f, 0.04801110f, -0.04091077f, -0.07692125f, 0.13757001f, -0.11900875f, -0.09495059f, 
    0.18600722f, -0.10940433f, -0.31839433f, 0.05787782f, -0.34703735f, -0.19003345f, 0.04999173f, 0.06300814f, 
    -0.10073670f, 0.10477205f, -0.18121424f, 0.14187521f, 0.20388624f, -0.50786614f, 0.19781213f, 0.16025458f, 
    -0.29560739f, -0.04715644f, 0.00719383f, 0.25361514f, -0.14006945f, 0.02265156f, 0.05150688f, 0.09287341f, 
    0.35646862f, -0.01431547f, -0.02471739f, 0.14876822f, 0.30881345f, -0.41961569f, -0.02385028f, 0.14706482f, 
    0.13370907f, -0.09431317f, 0.08285491f, 0.29980937f, -0.04347945f, 0.07615506f, -0.19037171f, 0.10876039f, 
    0.08252370f, -0.09956688f, -0.00302504f, 0.09879256f, -0.57447475f, -0.00514449f, 0.21275526f, -0.11679938f, 
    -0.31044599f, -0.03704024f, 0.17616162f, 0.07772072f, -0.03510414f, 0.06835796f, 0.02444501f, -0.08232062f, 
    0.16060275f, -0.12911332f, -0.14030671f, -0.06053670f, 0.12280551f, -0.10757343f, -0.13692860f, -0.27587029f, 
    0.44560987f, 0.16231179f, -0.23724426f, -0.45253110f, -0.60980803f, -0.61938059f, -0.46169350f, -0.10828379f, 
    -0.02340349f, 0.05849729f, 0.06166527f, 0.04388830f, -0.25717580f, -0.08813435f, -0.61004210f, 0.09360394f, 
    -0.50141943f, -0.01302458f, -0.06950156f, -0.48598057f, -0.08348157f, 0.39462534f, -0.09787605f, -0.32959530f, 
    -0.42230773f, 0.00527894f, -0.10691094f, -0.49628949f, 0.02793093f, -0.03473163f, 0.04868944f, -0.10051779f, 
    0.16624114f, 0.00467072f, 0.07980476f, 0.01702995f, -0.13148855f, 0.06764115f, -0.44852722f, 0.07974951f, 
    -0.00783379f, -0.09259962f, -0.07815784f, 0.13037452f, 0.00606740f, -0.14580581f, 0.25215903f, 0.00864982f, 
    -0.11097705f, 0.06268271f, 0.03759650f, 0.06853493f, 0.05041357f, 0.10098950f, -0.09825791f, 0.25711024f, 
    0.24393420f, 0.24701403f, -0.68353188f, 0.11251488f, 0.06307838f, 0.11154304f, -0.05707712f, -0.49062005f, 
    -0.46979445f, -0.08609659f, 0.21570173f, 0.12351701f, -0.03277912f, 0.26897591f, -0.02552836f, -0.06075935f, 
    0.26677203f, -0.08533144f, -0.20260783f, 0.08186670f, -0.04871725f, 0.08499990f, -0.08594029f, -0.59767801f, 
    0.26538065f, -0.08133832f, -0.08346120f, 0.09993245f, 0.41326249f, -0.47593576f, 0.07811300f, 0.15037197f, 
    0.28126416f, -0.01323644f, 0.33082324f, 0.02593394f, -0.31056866f, 0.15775578f, 0.01295288f, -0.25547618f, 
    -0.11293785f, 0.05797563f, 0.03600672f, -0.31970090f, -0.01593358f, 0.06850413f, -0.16102216f, 0.10557295f, 
    0.18545714f, 0.02161075f, -0.09462941f, -0.56760120f, 0.18130347f, -0.10241845f, -0.24316053f, 0.01886650f, 
    -0.07239845f, -0.09294687f, -0.15811251f, -0.14211488f, 0.03397404f, -0.02888718f, 0.09489278f, -0.15295903f, 
    -0.25335217f, 0.12174822f, 0.17005976f, 0.09880979f, 0.21474555f, -0.30693820f, -0.19848889f, 0.23928258f, 
    0.00952590f, -0.72026932f, 0.07232382f, -0.07535727f, 0.12334116f, -0.04599671f, 0.33988276f, 0.09667854f, 
    -0.08655895f, -0.01777260f, -0.46910554f, 0.22249335f, 0.22096564f, 0.03936578f, 0.50244820f, -0.23168170f, 
    -0.07408173f, -0.01728461f, -0.12336919f, 0.42231184f, -0.01488052f, -0.30493736f, -0.10758879f, 0.24146712f, 
    0.02974705f, 0.05304718f, -0.17483599f, -0.09818948f, 0.08146288f, -0.14659920f, -0.00279433f, 0.15359148f, 
    -0.50684488f, -0.51356405f, -0.04587030f, -0.21828036f, -0.12729421f, 0.11496557f, 0.24049523f, 0.10081166f, 
    0.17886259f, 0.04136805f, -0.05565165f, 0.10731346f, -0.00408038f, -0.06914279f, -0.09909046f, -0.64063680f, 
    0.21835370f, 0.19550481f, -0.11537397f, -0.12635666f, -0.35992813f, 0.09435568f, 0.11898093f, 0.10300556f, 
    0.15588711f, -0.55518574f, -0.31291091f, 0.08705430f, 0.09262239f, -0.50014579f, -0.10263458f, -0.04165035f, 
    -0.31407103f, 0.17282374f, -0.25485167f, 0.10052835f, 0.14313543f, -0.07026347f, 0.01723914f, 0.11098716f, 
    -0.26774487f, -0.02803948f, 0.30513856f, -0.78976721f, 0.06889528f, 0.00798285f, -0.14505780f, 0.08363971f, 
    -0.19392848f, -0.07903883f, -0.09328736f, 0.41245466f, -0.03202764f, 0.18160757f, -0.01215343f, -0.44804344f, 
    -0.16113634f, 0.06060014f, -0.09945653f, -0.51908112f, 0.13736944f, -0.36545482f, 0.12149955f, 0.19244538f, 
    -0.06096695f, -0.03555500f, 0.10680987f, -0.58625305f, 0.10740050f, -0.11887894f, -0.31914780f, 0.07790413f, 
    0.28275114f, -0.04588627f, -0.02052342f, -0.23305327f, 0.13094009f, -0.02349092f, 0.23932441f, -0.00897070f, 
    0.12120852f, -0.63614094f, -0.02654045f, -0.09119861f, -0.35379660f, -0.01774091f, -0.09659019f, -0.08455023f, 
    0.12778696f, 0.01074172f, 0.29281831f, -0.06858145f, 0.41690332f, 0.45179775f, -0.24598846f, -0.59380609f, 
    0.21113797f, -0.25169104f, 0.35256872f, 0.24672160f, 0.35020089f, 0.01894093f, -0.10582466f, 0.08855706f, 
    -0.58515072f, 0.11616511f, -0.06817733f, 0.18947701f, -0.08465638f, 0.12111329f, -0.07361799f, 0.18107182f, 
    -0.14736025f, 0.10568122f, -0.01723052f, -0.41290298f, -0.20289221f, -0.45879582f, -0.05051285f, 0.37470132f, 
    -0.30977401f, 0.07491604f, -0.02361982f, 0.23147726f, 0.00929995f, -0.12149151f, 0.10058182f, 0.14710224f, 
    0.07550829f, 0.06846795f, -0.00673027f, 0.07123690f, 0.07419571f, -0.09749125f, 0.17857522f, -0.03071468f, 
    -0.58908302f, -0.05401616f, 0.02775573f, 0.04011121f, -0.11112013f, -0.08466695f, -0.36437815f, -0.02975140f, 
    -0.04633855f, 0.12037246f, 0.03357527f, 0.01033963f, 0.04717235f, -0.01607032f, -0.12023142f, -0.19196831f, 
    -0.18662235f, -0.22041316f, -0.08500193f, 0.00703268f, -0.60016620f, -0.46202511f, -0.00008131f, 0.12496445f, 
    0.00915393f, -0.08327437f, -0.00887625f, -0.22767758f, 0.30846846f, -0.25953034f, -0.40418166f, 0.01359288f, 
    -0.38718924f, -0.08119976f, 0.20028029f, -0.00433996f, -0.57343304f, 0.21568866f, -0.13180329f, -0.13544951f, 
    -0.50463337f, -0.11528856f, -0.04189370f, -0.04212020f, -0.30955964f, 0.11854008f, -0.00738052f, -0.06872728f, 
    -0.45551229f, -0.01840999f, -0.25107437f, 0.09792303f, -0.09242346f, 0.11282315f, -0.09846009f, 0.00902588f, 
    -0.10762961f, 0.29906183f, -0.07263920f, 0.10288271f, -0.06745294f, 0.09369927f, -0.21644099f, -0.02221341f, 
    0.29860061f, -0.07239667f, -0.09095332f, 0.11040228f, -0.43221509f, 0.08424222f, -0.32502171f, -0.09474879f, 
    -0.19907157f, 0.43061820f, 0.14131810f, 0.10189928f, -0.01950985f, -0.06313250f, 0.00401595f, 0.03247010f, 
    -0.20299625f, -0.16308634f, -0.31275952f, -0.00135043f, -0.03382998f, 0.11203170f, 0.37090823f, 0.01552236f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.08731082f, 0.07580223f, -0.00898329f, -0.03634255f, 0.21784474f, 0.04516974f, 0.15928064f, -0.25993142f, 
    -0.08914136f, 0.00465054f, -0.00739998f, -0.05844683f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
