#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.32114211f, 0.45867902f, 0.03954836f, -0.19673735f, 0.48655561f, 0.09158032f, -0.55297661f, 0.35777721f, 
    0.35823724f, 0.55946803f, -1.07966948f, 0.51906496f, 0.58637267f, -0.37965471f, -0.13663389f, 0.19906917f, 
    -0.21416157f, -0.07501277f, -0.83174413f, -0.42616603f, -0.53508699f, 0.60160893f, 0.19053212f, -0.27335972f, 
    -0.16450356f, -0.50637579f, -0.21013260f, -0.48694164f, 0.17552561f, 0.35921851f, 0.24092315f, 0.45549527f, 
    -0.09789485f, 0.39495066f, 0.24525495f, -0.55789840f, 0.41138980f, -0.73365778f, -0.73409003f, 0.44247669f, 
    -0.29047883f, 0.52111912f, -0.10746505f, -0.01705013f, -0.53231531f, -0.56498075f, -0.77857375f, -0.15930571f, 
    0.18780139f, 0.54249835f, 0.12278618f, 0.08839011f, -0.14086825f, -0.31648490f, -1.16501558f, 0.68121600f, 
    0.34460256f, -0.23895743f, -0.16147582f, 0.72437072f, 0.32178587f, -0.45829991f, -0.20847343f, -0.64284891f, 
    0.84814268f, -1.02439225f, 0.16907288f, 0.35475954f, -0.03295179f, -0.33112231f, -0.28499112f, -0.24412525f, 
    0.31351236f, -0.34102386f, -0.39625010f, -0.18453808f, -0.41243970f, -0.96875709f, 0.69590783f, -0.35114327f, 
    0.33609307f, 0.48057333f, -0.77241015f, -0.16276897f, -0.70630652f, -0.06690117f, -0.48070368f, -0.42791456f, 
    -0.28212556f, -0.02053654f, -0.34677812f, -0.66224396f, 0.04557617f, 0.21791719f, -0.96082646f, -0.60919130f, 
    0.03502684f, 0.10864205f, 0.58711284f, 0.61504120f, -0.09142610f, -0.10494618f, -0.64632916f, 0.84484124f, 
    -0.60554880f, -0.03152043f, -0.09409036f, 0.30191189f, -0.21734808f, -0.00301153f, -0.60221481f, -0.56892806f, 
    -0.57552469f, -0.53475314f, -0.13984619f, -0.48164520f, -0.29406214f, -0.63765961f, 0.03737741f, -0.94393027f, 
    0.54080206f, 0.47513705f, -0.30047143f, -0.25363609f, 0.70082659f, -0.01191032f, -0.81442684f, -0.38342020f, 
    -0.13032393f, 0.63681269f, -0.27240929f, -0.50269425f, -0.40712324f, -0.34774622f, -0.22505563f, -0.09640735f, 
    0.07285140f, 0.42538080f, -0.25170225f, 0.88366467f, -0.21476409f, -0.13909565f, 0.00173175f, 0.12146526f, 
    -0.56501389f, -0.65280300f, -0.64479625f, 0.14074673f, 0.21854447f, 0.26603258f, 0.57931358f, -0.04094978f, 
    -0.12335537f, 0.49766293f, -0.16390285f, 0.01406734f, -0.10086983f, 0.18529116f, 0.15729274f, 0.56931323f, 
    -0.47386429f, 0.34844768f, 1.00050724f, -0.39238083f, -0.47729144f, 0.74691188f, 0.15002672f, 0.69867986f, 
    -0.52709919f, -0.43050468f, -0.55922508f, 0.59286410f, -0.46213132f, 0.08290776f, 0.73103654f, -0.07279801f, 
    -0.49304482f, -0.01056159f, 0.24018696f, 0.15274495f, -0.34823218f, 0.36459103f, -0.44488844f, -0.51919109f, 
    -0.55034465f, -0.83663529f, 0.03566989f, 0.42045483f, -0.35043794f, 0.67857879f, -0.81380719f, -0.83935183f, 
    0.12532839f, 0.27742067f, 0.69234121f, -0.06792656f, 0.14059137f, 0.24459150f, 0.60908765f, -0.06023007f, 
    0.45869943f, 0.26775476f, -0.43541458f, -0.24420215f, 0.49944380f, -0.32438889f, -0.17227219f, -0.13938700f, 
    1.28953624f, 0.54976296f, -1.00676274f, -0.24239315f, -0.15430257f, -0.40311012f, 0.22706480f, -0.14070909f, 
    0.51388025f, 0.59813523f, 0.44987532f, -0.39310145f, 0.23170564f, -0.25789547f, 0.41964862f, 0.03070175f, 
    -0.22471078f, -0.15684214f, 0.67859071f, 0.06701458f, -0.60568541f, -0.53371072f, -0.02792467f, 0.35145140f, 
    0.23416293f, 0.60874903f, 0.10182621f, -0.87292510f, -0.58571893f, -0.64231259f, -0.53104061f, 0.01274308f, 
    0.61777812f, -0.12941732f, 0.42099133f, -0.58684611f, 0.81897551f, -0.03141875f, 0.39770195f, 0.12686889f, 
    -0.64978421f, -0.01452977f, -0.25452021f, 0.42993167f, -0.90731102f, -0.95741439f, 0.06566019f, 0.43545222f, 
    0.41924536f, 0.54694337f, 0.08243957f, -0.38096115f, 0.49257374f, -0.43300289f, -0.49681100f, 0.18913431f, 
    0.41430208f, 0.42439422f, -0.05791682f, 0.04613306f, -0.01374027f, 0.31551936f, -0.80949765f, -0.50913566f, 
    -0.41137156f, 0.14070214f, -0.62883765f, -0.47487384f, 0.30246869f, -0.14935493f, 0.02734937f, 0.62358648f, 
    0.82597089f, 0.58107615f, -0.70439243f, -0.44159868f, 0.00782758f, -0.07219659f, -0.44455677f, 0.14564134f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.24751419f, 0.14474045f, -0.03199532f, 0.04619465f, 0.11123849f, 0.10810843f, 0.22458640f, 0.01414787f, 
    -0.11462525f, 0.20973217f, 0.40603250f, 0.00973074f, -0.31948623f, -0.09062120f, 0.12891008f, 0.01797366f, 
    0.38090906f, -0.39325288f, 0.00362265f, -0.16119920f, -0.20935716f, -0.12463686f, 0.29200083f, 0.24158795f, 
    -0.14043041f, -0.13427630f, 0.02313005f, 0.25049543f, -0.05570095f, -0.06891227f, -0.25062767f, 0.16725600f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04463137f, -0.24175534f, -0.04841566f, -0.01010174f, -0.07994367f, -0.18608779f, 0.00401773f, -0.15188867f, 
    -0.06526612f, -0.07347219f, -0.08122647f, -0.08512729f, -0.12823819f, -0.11380740f, -0.00681315f, 0.01451908f, 
    0.17844041f, 0.06066329f, 0.07358088f, -0.06841241f, 0.28353572f, 0.66306233f, -0.33752155f, 0.22873250f, 
    0.21151580f, 0.19402793f, -0.12145700f, 0.21696694f, 0.25617158f, 0.30130851f, 0.03365964f, -0.04540670f, 
    -0.03905918f, 0.03713958f, 0.11329991f, -0.01359492f, 0.01340509f, 0.09449025f, 0.28924540f, 0.15712951f, 
    -0.10424352f, 0.17636564f, 0.05332782f, 0.04872914f, 0.13022216f, 0.01749061f, 0.00168307f, 0.18096036f, 
    -0.04497550f, -0.12224665f, -0.11189672f, 0.11639289f, -0.07933719f, -0.16277336f, -0.03109477f, 0.00053165f, 
    -0.12758984f, -0.09651094f, -0.07171337f, -0.09833749f, 0.24505842f, -0.11956467f, 0.01758365f, -0.11849540f, 
    -0.09759683f, 0.00019096f, -0.23695599f, -0.03314893f, 0.08660880f, -0.07252368f, 0.08582594f, 0.13828517f, 
    -0.03100112f, 0.15524083f, 0.13336462f, -0.03958916f, 0.04603612f, 0.12648775f, 0.01899395f, 0.04567344f, 
    0.00120758f, 0.36944413f, 0.02619465f, 0.16347347f, 0.23672606f, 0.01258441f, 0.09498352f, 0.06099085f, 
    -0.14583853f, -0.04582001f, -0.01745385f, 0.04924224f, -0.08960037f, -0.14253546f, 0.04592499f, -0.00042652f, 
    -0.09625030f, -0.04543765f, -0.02243996f, -0.05881714f, 0.07000083f, 0.04418709f, 0.05551990f, -0.18767609f, 
    0.12850890f, -0.07091760f, -0.05048144f, 0.09027271f, 0.12441581f, -0.10380823f, -0.08120349f, 0.05656587f, 
    -0.00338290f, -0.05979658f, -0.01228034f, -0.02301548f, -0.10930735f, 0.04495994f, -0.10226627f, -0.09203441f, 
    0.12207226f, 0.04097362f, 0.17032230f, 0.00897573f, 0.22974567f, -0.09234893f, -0.03858801f, 0.06214961f, 
    0.10197914f, 0.15934840f, -0.06544999f, 0.04215394f, -0.13981211f, 0.16593224f, 0.12015852f, 0.21765640f, 
    -0.06164335f, 0.15421639f, -0.10910546f, 0.08115996f, 0.06113471f, 0.28596210f, 0.21250142f, 0.00044447f, 
    -0.12364861f, -0.11338268f, -0.01868277f, 0.38458097f, 0.02577035f, -0.05768223f, 0.03415142f, 0.03047809f, 
    -0.17119662f, -0.11262381f, -0.06040666f, -0.00843874f, -0.14175765f, 0.02583285f, -0.01049235f, -0.19119403f, 
    -0.23791690f, 0.31622243f, -0.14347543f, 0.12903886f, -0.19944248f, 0.02359426f, -0.04888099f, 0.06804570f, 
    0.00949875f, -0.09826925f, -0.14873080f, 0.12258793f, 0.08777077f, 0.17622641f, 0.03451288f, 0.11141822f, 
    -0.03056212f, -0.11229498f, 0.06951726f, 0.24854571f, 0.01469878f, 0.12799923f, 0.13511404f, 0.11636861f, 
    -0.17433104f, 0.03496080f, 0.23472565f, 0.01067221f, 0.00562905f, 0.04101890f, -0.00804285f, 0.01488676f, 
    -0.01670282f, 0.01570994f, -0.00562083f, 0.05387230f, -0.02167707f, -0.15627417f, -0.02682482f, -0.15065527f, 
    -0.03646148f, 0.07967192f, 0.05984855f, 0.13177186f, 0.00441354f, 0.19089553f, 0.06934578f, 0.02154877f, 
    0.04457342f, 0.02788711f, 0.03679657f, 0.11227471f, 0.11824914f, 0.09259996f, 0.03431434f, 0.03117592f, 
    0.04024774f, -0.02824509f, 0.16175359f, 0.20960401f, -0.12499201f, -0.24761231f, 0.22985663f, 0.32592940f, 
    0.04393382f, -0.16081616f, 0.06098070f, -0.29355881f, -0.11467344f, 0.11785108f, -0.31947464f, -0.06093929f, 
    0.22310807f, 0.07633109f, 0.01195042f, -0.01790443f, 0.06610951f, 0.06085805f, 0.13978367f, 0.22500327f, 
    -0.13661946f, 0.11651788f, -0.06809022f, -0.08263926f, -0.25412619f, 0.02353668f, 0.01387738f, 0.10283234f, 
    -0.19301961f, -0.22464293f, 0.03223893f, -0.00194306f, -0.02649401f, -0.02735522f, -0.01307203f, 0.05895873f, 
    0.05097772f, -0.07966211f, -0.14443244f, -0.27000210f, 0.12191750f, 0.05817492f, 0.26023421f, 0.06352674f, 
    -0.07728670f, 0.01861640f, -0.13749847f, 0.20243743f, 0.17674738f, -0.03334294f, -0.06890313f, 0.02835136f, 
    0.06885158f, -0.06406367f, -0.06813942f, -0.03389216f, 0.09269226f, 0.06746740f, 0.11350521f, 0.04581976f, 
    -0.10748617f, 0.17360336f, 0.14121552f, 0.13092504f, 0.09787587f, 0.07907940f, 0.02188634f, 0.04142598f, 
    -0.02530155f, -0.16264425f, -0.07616501f, 0.02887836f, -0.01054120f, -0.07335170f, 0.01788988f, 0.05460414f, 
    -0.09965738f, -0.21741535f, -0.06832218f, -0.06065032f, 0.18583994f, -0.04893789f, 0.27379107f, -0.02763856f, 
    -0.02257502f, -0.18942958f, -0.25206307f, -0.16670308f, 0.01748102f, -0.03985513f, -0.04154604f, -0.00550629f, 
    -0.03682124f, 0.13749385f, -0.01173752f, 0.08906971f, 0.01514032f, 0.09597965f, -0.02742760f, 0.03752653f, 
    -0.13501227f, 0.09057926f, -0.31718847f, -0.05966178f, 0.19040194f, -0.12758696f, 0.08559877f, 0.05340924f, 
    0.15234268f, 0.05051872f, -0.01146287f, 0.05609165f, -0.00265927f, -0.01705189f, -0.07115037f, -0.01197186f, 
    -0.00830395f, 0.04287815f, -0.01815840f, -0.02801967f, -0.11870098f, -0.21894270f, -0.12049780f, 0.25009012f, 
    0.04917847f, -0.25463426f, -0.09144353f, -0.15540425f, -0.08335406f, -0.05956756f, -0.23267987f, -0.12126337f, 
    0.10591724f, 0.26212212f, 0.10199946f, -0.10187808f, -0.05089118f, -0.07085703f, 0.13159631f, 0.08684501f, 
    0.01746321f, 0.22485945f, 0.18116906f, 0.41802499f, 0.04869138f, -0.12108068f, -0.01696095f, -0.22403874f, 
    -0.13326024f, -0.10784774f, 0.17747666f, 0.10714231f, -0.11938078f, 0.12381131f, 0.19510087f, 0.01217709f, 
    -0.14523490f, 0.04184072f, 0.06793906f, -0.25940660f, -0.10799252f, 0.12682439f, -0.31560695f, 0.13185425f, 
    -0.08909503f, -0.04497122f, -0.25005087f, -0.15794046f, 0.10780151f, 0.04105053f, 0.00880985f, -0.04749125f, 
    -0.02082755f, -0.07945392f, 0.08347073f, -0.07757915f, 0.10218379f, -0.04431999f, 0.19208451f, 0.07089127f, 
    -0.12874770f, 0.02471892f, 0.23423263f, -0.13537440f, -0.27036050f, 0.15960440f, 0.03247123f, 0.24219696f, 
    0.10104795f, -0.29029125f, -0.06808847f, 0.04273251f, 0.03940258f, 0.05630819f, 0.18115267f, 0.07570710f, 
    -0.09052633f, 0.08013155f, -0.07002085f, -0.06546352f, -0.01435846f, -0.12511541f, -0.15535563f, 0.07033156f, 
    0.04627707f, -0.06195658f, -0.08351296f, -0.07274894f, 0.01835016f, -0.01856096f, 0.20598781f, -0.01131724f, 
    0.10163138f, 0.06071628f, -0.05590555f, -0.06847044f, 0.06631838f, -0.06698649f, 0.16186406f, 0.04268148f, 
    -0.29594964f, 0.16409253f, -0.07685177f, 0.12831049f, -0.07815757f, 0.05471038f, -0.15390775f, -0.01647182f, 
    0.08319413f, 0.03652655f, -0.09584858f, -0.02547511f, 0.04877749f, -0.00272858f, 0.06312796f, 0.03076873f, 
    -0.07795343f, 0.11276092f, 0.09280082f, 0.08848175f, -0.04691750f, -0.37501743f, 0.47620454f, 0.22546130f, 
    -0.10106217f, 0.04443581f, -0.00664088f, -0.11339246f, 0.15220164f, -0.03206394f, -0.13678323f, 0.06114604f, 
    -0.06222254f, -0.01780785f, -0.03356597f, 0.05506266f, -0.05157141f, -0.01830073f, 0.07572664f, -0.08135846f, 
    -0.33465105f, -0.10226567f, 0.40531448f, 0.08601116f, -0.10815220f, -0.01084908f, -0.19008814f, -0.19535999f, 
    -0.18076526f, -0.18500309f, -0.20182469f, -0.08641125f, -0.05829763f, -0.00683489f, -0.03143468f, 0.09674001f, 
    -0.03304033f, 0.09633266f, -0.07966583f, -0.03181842f, -0.04259736f, -0.26945764f, 0.01146210f, -0.01548996f, 
    -0.20510918f, -0.10221910f, -0.01554059f, -0.01236108f, -0.06043442f, 0.00992918f, -0.14732245f, 0.01674816f, 
    0.03683749f, 0.18601649f, -0.05232103f, -0.00152787f, 0.10009591f, 0.18261580f, 0.08879270f, 0.41527975f, 
    -0.04720152f, 0.06386600f, -0.27751014f, 0.19419675f, 0.12824158f, -0.06202425f, 0.21385942f, 0.03246146f, 
    0.06703927f, -0.04377745f, -0.03828028f, 0.01187872f, 0.02985032f, 0.13306089f, 0.00869503f, 0.02888781f, 
    0.03342887f, -0.04041784f, -0.04179312f, 0.25741488f, 0.23477077f, -0.03267540f, 0.11185624f, 0.13639608f, 
    0.05098224f, 0.14666994f, -0.07903202f, 0.16315675f, 0.19409597f, 0.09982185f, 0.12573804f, -0.06020515f, 
    0.06673015f, 0.14941178f, 0.16886866f, 0.01365902f, 0.13496852f, 0.02311098f, 0.11615468f, 0.28111127f, 
    0.13857026f, -0.38463494f, 0.02358241f, -0.15546653f, 0.03008778f, -0.17724206f, -0.23678036f, 0.06875756f, 
    0.00599357f, 0.02834651f, -0.05028431f, 0.16400157f, -0.02908684f, 0.04902685f, -0.05935610f, 0.02258177f, 
    -0.04756533f, 0.06333214f, -0.04831354f, 0.04086774f, 0.13541353f, -0.20952193f, -0.10124024f, -0.04618384f, 
    -0.08032811f, -0.07408266f, -0.15683387f, -0.02176273f, 0.07520159f, 0.02741082f, 0.05797578f, 0.14018314f, 
    0.08657605f, 0.03657529f, 0.03746855f, 0.06918687f, 0.04648690f, -0.04845227f, 0.07940436f, 0.13620196f, 
    -0.13950221f, 0.37684101f, -0.04191243f, 0.10820061f, 0.08991867f, 0.03488782f, 0.09388449f, 0.08914723f, 
    -0.07878260f, -0.19532432f, -0.06077171f, -0.02545968f, -0.08107993f, -0.04141328f, 0.03397637f, 0.00706216f, 
    0.02235591f, -0.04491332f, 0.01600464f, 0.12461600f, -0.13659349f, -0.25303811f, 0.19293252f, 0.15730688f, 
    -0.05518275f, -0.08967063f, -0.08155012f, -0.14572226f, -0.00977822f, 0.01267390f, -0.25084659f, -0.00737851f, 
    -0.07627749f, 0.04968006f, -0.01372360f, 0.06447062f, -0.20130989f, 0.04995996f, -0.09535002f, -0.02498963f, 
    0.21192551f, -0.19071768f, 0.19120787f, -0.30192599f, 0.07557527f, -0.01637593f, 0.12578988f, -0.07934734f, 
    0.07667346f, 0.07470250f, -0.08801767f, 0.14968990f, 0.07990319f, -0.12066057f, 0.02775055f, 0.05438768f, 
    0.07988842f, -0.06300054f, -0.10488860f, -0.20066816f, -0.66071916f, 0.51591158f, -0.11126860f, 0.59370112f, 
    -0.40976435f, 0.27574655f, -0.16551675f, 0.19799596f, 0.03931839f, 0.01490326f, -0.09577572f, -0.06324284f, 
    -0.13800006f, -0.00166870f, 0.01275118f, 0.14193103f, -0.10670612f, 0.01752989f, 0.01190397f, 0.11580663f, 
    -0.16518568f, -0.04056063f, 0.06669051f, 0.24974591f, 0.18985637f, 0.10029231f, -0.03440527f, 0.01631284f, 
    -0.06573810f, 0.10998449f, 0.00963888f, 0.03179789f, 0.12203298f, 0.00542498f, -0.02296644f, 0.05942385f, 
    0.18348883f, 0.08748741f, 0.11051730f, 0.06792156f, -0.13797998f, -0.09009920f, -0.13138069f, -0.06414641f, 
    -0.14877619f, 0.07531705f, -0.03900288f, 0.06762815f, -0.16045924f, 0.14864789f, -0.11768223f, 0.07839424f, 
    0.15189394f, 0.01117469f, 0.11506512f, -0.02618914f, -0.07790148f, -0.09972092f, 0.01100252f, 0.01098322f, 
    -0.17128891f, 0.31175989f, 0.11900000f, 0.23358151f, 0.01639956f, 0.04765296f, 0.08716666f, -0.09124293f, 
    -0.01763134f, 0.00295974f, -0.00351886f, -0.07327431f, 0.05067607f, 0.04930895f, 0.15211594f, 0.06749452f, 
    0.17436148f, 0.03657024f, 0.01312805f, 0.04259991f, -0.24014220f, 0.20580578f, 0.19649796f, 0.17777824f, 
    0.16115394f, 0.03147037f, 0.00472653f, -0.04942179f, -0.11816288f, 0.07183224f, -0.06423652f, 0.01052368f, 
    0.08713079f, 0.02901362f, -0.03792625f, -0.02943065f, -0.00436858f, 0.07943808f, -0.08512716f, 0.02401603f, 
    0.23457438f, -0.23495622f, -0.15331540f, -0.12156414f, 0.12532279f, 0.03639973f, -0.09026756f, 0.03973725f, 
    0.06214485f, 0.15843818f, -0.01393821f, 0.04776008f, 0.02408769f, 0.18235432f, 0.03058789f, 0.06535472f, 
    0.04894654f, 0.08738729f, 0.02100465f, -0.04742622f, 0.12267106f, -0.32407126f, 0.12725583f, 0.09128443f, 
    0.13392961f, 0.15288758f, 0.07606652f, -0.05432476f, 0.23637414f, 0.09728775f, -0.06779751f, 0.06295189f, 
    0.18885596f, 0.12738663f, -0.03873264f, 0.22144146f, 0.12657818f, 0.21147101f, 0.24463411f, 0.25876683f, 
    -0.08621825f, -0.01868985f, -0.16231328f, 0.36960790f, 0.10462116f, -0.02619205f, -0.17731334f, 0.01128669f, 
    0.11526027f, 0.10020285f, 0.05710069f, -0.13283284f, -0.03429766f, 0.11370680f, 0.01761834f, -0.01014657f, 
    -0.11187865f, -0.00068051f, 0.03397442f, 0.00548060f, -0.19579928f, 0.09381621f, -0.13471390f, 0.22572663f, 
    0.15314116f, -0.13045371f, 0.07629435f, -0.16614707f, 0.21975368f, -0.15021954f, -0.06678045f, 0.05326920f, 
    0.02165775f, 0.11730662f, 0.08365741f, 0.06206526f, 0.03215078f, 0.21889305f, -0.03752423f, 0.01381490f, 
    -0.17829794f, 0.05601982f, -0.03515061f, 0.34689900f, 0.19070220f, 0.05228100f, -0.10806200f, 0.09464107f, 
    0.01753944f, -0.00090263f, -0.10708492f, 0.00017884f, -0.05440314f, 0.00661546f, -0.02449848f, 0.00505913f, 
    -0.07823488f, -0.01683437f, -0.04338295f, -0.11954097f, 0.35534766f, -0.02983695f, -0.14145403f, 0.30539951f, 
    -0.02772879f, 0.03218661f, 0.17252934f, -0.13176972f, 0.31047466f, -0.10815483f, -0.03940117f, -0.04599657f, 
    0.05102796f, -0.14955024f, 0.06326018f, 0.01009244f, 0.04658593f, 0.10446795f, 0.19686499f, -0.04436851f, 
    -0.07395753f, -0.16042286f, -0.24857160f, 0.14049301f, 0.35888734f, -0.16935267f, 0.01179843f, -0.00452172f, 
    -0.06577190f, -0.06959803f, -0.07330462f, 0.16898382f, 0.06993953f, 0.01607506f, -0.00183191f, 0.17867364f, 
    0.04739310f, 0.06225059f, 0.04099581f, 0.11309258f, -0.06676152f, 0.17270315f, 0.41735542f, 0.47082272f, 
    0.09599315f, 0.03969761f, -0.00979832f, -0.29720801f, 0.17614409f, 0.10453689f, -0.02471840f, -0.05190907f, 
    -0.04201206f, -0.01804169f, 0.09339416f, 0.03102438f, -0.11344986f, 0.01632723f, -0.07024001f, -0.12729260f, 
    -0.14715017f, -0.10326689f, -0.06740461f, 0.30886182f, 0.14541115f, 0.06761144f, -0.02282416f, 0.08702991f, 
    -0.11651810f, 0.00877006f, -0.03824929f, 0.05727039f, 0.03972434f, 0.03969825f, -0.06368241f, 0.08088741f, 
    0.16462505f, 0.12834890f, 0.17748445f, 0.08081345f, 0.05895693f, -0.15635094f, 0.15508804f, -0.17628692f, 
    -0.00499092f, 0.12967220f, 0.05837434f, 0.18206346f, -0.00792576f, 0.01932376f, -0.00604823f, -0.01215455f, 
    -0.13591848f, -0.20815489f, 0.13656406f, 0.06372343f, 0.10197224f, -0.01121055f, 0.04174367f, -0.27944580f, 
    -0.15872690f, 0.25382319f, 0.19791321f, 0.28076759f, 0.11532696f, -0.00063292f, -0.07418798f, -0.15349479f, 
    0.01039420f, 0.09268667f, -0.04681996f, 0.11649399f, 0.07480233f, 0.01093312f, -0.13559943f, 0.06506873f, 
    0.01875802f, 0.06766939f, 0.01228318f, 0.03323520f, -0.03952808f, -0.10866171f, 0.10452311f, 0.29194424f, 
    -0.07345884f, -0.12558316f, 0.19803849f, 0.00380390f, 0.01891835f, 0.05127934f, -0.04502762f, 0.06821901f, 
    0.14321485f, 0.11310659f, -0.02977073f, -0.06219718f, -0.09871538f, -0.13329449f, -0.01327776f, -0.17530127f, 
    -0.20307635f, 0.19043528f, 0.00125430f, 0.08287818f, -0.24275021f, -0.01842630f, 0.08466785f, -0.07440975f, 
    -0.02512768f, -0.08741950f, -0.08566885f, -0.06675561f, 0.03758975f, 0.10572968f, 0.06258772f, 0.16309021f, 
    0.03577391f, 0.01136358f, 0.00535851f, -0.02990324f, -0.14073507f, 0.01988494f, -0.30961832f, 0.07846292f, 
    -0.28567588f, 0.13600692f, 0.01037586f, 0.21448252f, 0.13255949f, 0.04618542f, -0.25597006f, 0.06763998f, 
    0.06124802f, 0.07965743f, 0.09418506f, 0.13096185f, 0.02216755f, 0.00139266f, -0.12763321f, -0.25860783f, 
    -0.15938534f, -0.13408783f, -0.01654718f, 0.21911372f, 0.34946117f, -0.05748869f, -0.09955273f, 0.03901558f, 
    0.03218841f, 0.00541935f, 0.00151318f, 0.08237203f, 0.05787798f, 0.02344259f, -0.01228922f, 0.05224559f, 
    -0.01729102f, 0.07980403f, 0.09074431f, 0.03997808f, -0.20806888f, 0.18170957f, 0.17370895f, 0.01159632f, 
    -0.00770970f, -0.02828780f, 0.11444837f, -0.30681923f, 0.19275777f, 0.05194250f, 0.03000153f, -0.18814760f, 
    0.00042900f, -0.04464466f, 0.03510931f, -0.06175218f, -0.09422354f, -0.08680049f, -0.08573376f, -0.13006189f, 
    0.13908046f, -0.02795803f, 0.14701954f, 0.24413744f, -0.22115459f, 0.08602598f, -0.11555484f, 0.07320167f, 
    -0.03866781f, 0.06123661f, -0.02500498f, 0.01225330f, -0.04800429f, -0.02334248f, 0.08189689f, 0.08900578f, 
    0.05056944f, 0.08387505f, -0.01474289f, 0.09597378f, 0.68721360f, -0.32428920f, 0.34196994f, -0.10175347f, 
    0.37407368f, -0.06265136f, 0.08769634f, -0.06785425f, 0.00963285f, -0.08677799f, -0.14018029f, -0.05482653f, 
    -0.03900182f, -0.06044096f, 0.05902458f, -0.05086901f, 0.10654845f, 0.03121523f, 0.08249998f, 0.16483822f, 
    0.33861664f, -0.12578760f, 0.25074282f, -0.00410539f, -0.09656753f, -0.01407189f, -0.00567022f, -0.01595888f, 
    -0.07201862f, -0.00794132f, -0.01653317f, 0.00380407f, -0.03892790f, -0.06367803f, 0.07433207f, 0.10745780f, 
    0.12305510f, -0.06464888f, -0.15162763f, 0.04270934f, -0.00921518f, -0.01753646f, 0.13967706f, -0.08770058f, 
    0.13136455f, 0.04964194f, 0.08378285f, -0.03937213f, -0.00676685f, -0.02463761f, -0.02478418f, -0.05137032f, 
    0.06317696f, 0.10480520f, 0.19219096f, -0.12330648f, -0.15717743f, -0.05934848f, -0.05845106f, -0.09762228f, 
    -0.14972694f, 0.03840813f, 0.17452006f, 0.42341447f, 0.26753995f, -0.10634769f, -0.07166467f, -0.05213154f, 
    0.01749762f, 0.04106095f, 0.10023954f, 0.09386560f, 0.04004642f, 0.00015157f, -0.04667431f, -0.01930377f, 
    -0.03606863f, -0.11752444f, 0.06634947f, 0.02141109f, 0.10724300f, -0.27025148f, 0.16045995f, 0.05946689f, 
    -0.01799936f, 0.11709810f, 0.17065401f, 0.07836837f, -0.14836469f, 0.12292760f, -0.02305005f, 0.16185044f, 
    -0.01441824f, 0.00832455f, 0.03221760f, -0.06147298f, 0.19763979f, 0.06382586f, -0.06787325f, -0.14671724f, 
    -0.21262188f, 0.08719283f, 0.29130560f, 0.04071728f, -0.00733442f, 0.08462968f, 0.00130530f, -0.02496954f, 
    -0.14070815f, 0.25486061f, -0.03161148f, -0.05160113f, 0.01864932f, 0.02352519f, 0.03233599f, -0.07600978f, 
    -0.12348782f, -0.05703659f, -0.16740355f, -0.06647029f, -0.17901249f, -0.00485184f, 0.09831110f, 0.02283920f, 
    -0.02458990f, 0.15110593f, -0.02218211f, 0.01856703f, -0.13743965f, 0.12659745f, -0.06275513f, -0.02465233f, 
    0.03603794f, -0.06063052f, -0.05139837f, -0.11771011f, -0.16723868f, -0.12852478f, -0.12526964f, -0.15451586f, 
    -0.17490503f, -0.05706081f, -0.08545500f, 0.38322273f, 0.23080257f, -0.17554216f, -0.26620722f, -0.13255522f, 
    -0.24997413f, 0.03910225f, -0.07303636f, 0.22105448f, 0.03186930f, -0.01712603f, -0.05240357f, 0.10184375f, 
    0.06577007f, -0.02849144f, -0.09721617f, -0.00417861f, 0.47556409f, -0.20590355f, 0.16292635f, -0.18699023f, 
    0.15386131f, -0.18248099f, 0.00454583f, -0.12059727f, 0.02289942f, -0.17810622f, -0.09474831f, 0.07105590f, 
    -0.00980976f, -0.16613594f, -0.03425047f, 0.04342256f, 0.07968604f, 0.09854351f, 0.00762644f, 0.01346536f, 
    -0.02540135f, -0.02647845f, -0.00471876f, 0.00118219f, 0.00546749f, -0.04155867f, 0.01320326f, 0.01812928f, 
    0.02839810f, 0.00687386f, -0.03639571f, 0.01929073f, -0.04086503f, -0.00063527f, -0.00536494f, -0.01517363f, 
    0.00308829f, 0.01531572f, -0.00007600f, -0.04071403f, -0.00077954f, -0.01914589f, 0.01439948f, 0.01762285f, 
    -0.00008670f, 0.01686374f, 0.01668905f, 0.00426278f, 0.03024810f, 0.01621161f, -0.03781802f, 0.01685863f, 
    0.02011254f, -0.00687312f, 0.00641002f, 0.01500007f, -0.02711032f, -0.02486683f, 0.02390930f, 0.00824464f, 
    0.02306719f, -0.00197857f, 0.02308691f, -0.01729012f, -0.00825994f, 0.00721109f, -0.03563650f, -0.01754705f, 
    -0.02451094f, -0.03849841f, -0.03468331f, 0.00111228f, -0.02037960f, -0.04497419f, -0.01512123f, -0.03150772f, 
    -0.04009988f, -0.01454083f, -0.00795025f, 0.01448975f, 0.00411412f, -0.01742866f, -0.00343811f, -0.00144060f, 
    -0.00348042f, -0.00568832f, 0.01779225f, 0.02598780f, -0.04037617f, 0.03393931f, -0.00548052f, -0.01121159f, 
    -0.03001872f, -0.00972867f, -0.01193993f, -0.03095020f, 0.03854480f, -0.03175575f, 0.02917533f, -0.00816687f, 
    0.00177821f, -0.00880202f, -0.00745558f, 0.03337136f, -0.01474309f, 0.01898135f, -0.03820924f, -0.01095549f, 
    0.02898999f, 0.02649348f, -0.03888111f, 0.02530951f, 0.02689338f, -0.00352957f, -0.01529321f, -0.02349084f, 
    0.01142125f, -0.01178442f, 0.01060961f, -0.01642570f, -0.00664966f, -0.02760811f, 0.00986676f, 0.03028599f, 
    0.01449703f, -0.04219911f, -0.01414243f, -0.04022112f, -0.00314719f, -0.04329986f, 0.01944207f, -0.02761471f, 
    -0.02573683f, 0.00882041f, 0.03421615f, 0.02356941f, -0.03274149f, 0.02303789f, 0.02698489f, -0.01522645f, 
    0.02968548f, 0.00305137f, -0.02838685f, 0.02737883f, -0.02234726f, -0.01935102f, -0.01396020f, 0.02982466f, 
    -0.01302500f, -0.04271049f, 0.02140944f, -0.02259672f, 0.00475061f, -0.02283630f, 0.03435414f, -0.02116262f, 
    0.01126881f, 0.02705249f, -0.03940107f, -0.04030677f, -0.04188335f, -0.01069424f, 0.00863316f, 0.03191780f, 
    0.02185050f, -0.00309239f, -0.00911214f, 0.01952424f, -0.02044090f, 0.02636864f, -0.03811408f, 0.03292575f, 
    -0.03412827f, -0.00445239f, 0.01907717f, -0.00813270f, 0.01063479f, -0.03493188f, -0.00774301f, -0.03038439f, 
    -0.02584030f, -0.03692997f, -0.01371660f, 0.01453609f, -0.00908893f, 0.00898082f, 0.01235419f, -0.01511947f, 
    0.00273995f, -0.01621407f, 0.02516948f, 0.02310763f, -0.04036281f, 0.00253817f, -0.04534769f, -0.00815305f, 
    -0.00435121f, -0.01949291f, -0.00974409f, -0.02545971f, 0.01429628f, 0.03057294f, -0.02082366f, -0.00015041f, 
    0.02158801f, -0.04290104f, -0.03531036f, -0.04090248f, -0.03904552f, -0.01263282f, 0.00456259f, -0.02924162f, 
    -0.00567478f, 0.00211868f, 0.01029861f, 0.00474165f, -0.01013563f, 0.02333462f, -0.03225404f, -0.00734028f, 
    0.00174961f, 0.02775585f, 0.03307707f, 0.03689930f, 0.02666707f, -0.02682738f, -0.04201932f, -0.00812205f, 
    -0.00120725f, -0.03639113f, -0.02224210f, 0.01866468f, -0.03582049f, -0.04029503f, 0.03276596f, 0.03192320f, 
    -0.00494276f, -0.03148043f, 0.01585985f, 0.02146848f, -0.01853543f, 0.03078439f, 0.00176462f, -0.03522127f, 
    0.00647365f, -0.02788855f, 0.01610465f, 0.00614653f, 0.00254459f, 0.02619099f, -0.02211944f, 0.01310709f, 
    0.03276839f, -0.00211879f, 0.00939681f, 0.03660467f, -0.03285092f, 0.00886918f, 0.01635034f, -0.02963129f, 
    -0.00084226f, 0.02623411f, -0.02358665f, 0.04073119f, -0.01470517f, 0.02680387f, 0.02431675f, 0.01710539f, 
    0.01034561f, 0.01715229f, -0.04034718f, 0.02242498f, -0.00311100f, -0.04016010f, -0.01692682f, -0.02813128f, 
    -0.02384253f, 0.00760880f, -0.02660191f, 0.00064027f, -0.00990337f, -0.00138208f, -0.04364572f, 0.01420066f, 
    -0.01598657f, 0.00838264f, -0.00843789f, -0.02771587f, 0.00941232f, 0.00221309f, -0.01250170f, 0.00204418f, 
    -0.02647819f, -0.02533853f, 0.01540400f, 0.02769454f, 0.00250797f, 0.02815961f, -0.02120251f, -0.00168675f, 
    0.02219730f, -0.03554942f, -0.00486634f, 0.02807137f, 0.03523112f, 0.02603495f, 0.02518180f, -0.02988410f, 
    -0.00686583f, 0.02461290f, 0.00181150f, 0.00950121f, 0.01413323f, 0.01141057f, -0.00160456f, -0.02002932f, 
    -0.01321110f, -0.00853613f, -0.04094744f, 0.00658966f, 0.01200647f, 0.01820689f, -0.04140343f, 0.03258696f, 
    0.01853776f, 0.00640950f, 0.01758981f, 0.01982212f, -0.03481057f, -0.00774186f, 0.00317439f, -0.00385896f, 
    0.00768165f, -0.03006458f, -0.00780450f, -0.00537369f, 0.00242051f, 0.01910173f, 0.02407495f, 0.03212976f, 
    -0.03081238f, -0.01939547f, -0.03396270f, -0.03831226f, -0.01998560f, -0.01887007f, 0.03226443f, -0.01482999f, 
    -0.04254927f, 0.01715754f, -0.03470023f, -0.03058304f, 0.01390044f, -0.03598528f, 0.03016750f, -0.00698028f, 
    0.02678918f, 0.03120287f, 0.00052176f, -0.00818307f, -0.03262248f, -0.00624971f, -0.01551577f, 0.02126673f, 
    0.00800813f, -0.02494912f, 0.00031418f, -0.04044912f, 0.01480147f, -0.01721191f, 0.01223440f, 0.00686204f, 
    0.00415460f, 0.02791857f, 0.02444416f, 0.02795322f, -0.00583797f, -0.02715006f, 0.02365568f, -0.01401220f, 
    0.01353787f, -0.00700629f, 0.01818239f, 0.01106356f, -0.01993919f, 0.00968822f, -0.00138996f, -0.02181554f, 
    -0.03985511f, -0.04166048f, 0.02360831f, -0.00460734f, 0.00483245f, -0.02324781f, 0.00607842f, -0.01781679f, 
    -0.02384013f, 0.00461528f, -0.00522832f, 0.01834491f, 0.01150895f, 0.03073511f, 0.01018081f, 0.01987231f, 
    0.02388749f, 0.02390958f, 0.01705960f, -0.01845915f, -0.04414285f, -0.01552672f, 0.00683316f, -0.04232237f, 
    -0.00727119f, -0.02045324f, -0.02056092f, 0.00797333f, -0.02655930f, -0.01490223f, -0.01117099f, 0.01114996f, 
    0.02574648f, -0.02824556f, 0.01627776f, -0.03575983f, 0.03387038f, -0.04443842f, 0.00948206f, 0.02506411f, 
    -0.02786913f, -0.03960597f, 0.02062942f, -0.02658303f, -0.04291303f, 0.01427997f, 0.00747611f, -0.00429240f, 
    -0.00092565f, 0.02902057f, -0.02432085f, 0.02740493f, -0.02288053f, 0.03147825f, 0.01324100f, -0.00650290f, 
    0.02219978f, -0.01318053f, -0.02967034f, -0.00434272f, -0.00993898f, 0.02922861f, 0.02576114f, -0.00238748f, 
    -0.02203550f, 0.02735992f, -0.01946460f, -0.04481156f, -0.01161275f, -0.02810415f, 0.00388521f, -0.00429083f, 
    0.00613080f, -0.01261068f, 0.00685067f, 0.03147287f, -0.04305246f, -0.00655794f, -0.04390210f, 0.03226712f, 
    0.02616354f, 0.03353308f, -0.04169786f, -0.00415146f, -0.02313339f, -0.02151993f, -0.01847686f, 0.03400292f, 
    -0.01212721f, -0.00150586f, 0.01062922f, -0.00156158f, 0.03249578f, 0.02888907f, -0.00717187f, -0.01189735f, 
    0.02760681f, -0.01008493f, 0.00776783f, 0.02395674f, 0.00731876f, -0.03620189f, 0.02222144f, 0.03258818f, 
    -0.00373230f, -0.02962068f, 0.01097834f, 0.00516163f, -0.03091711f, -0.00548736f, -0.02094227f, 0.01172313f, 
    -0.03436308f, -0.01056996f, 0.00879279f, 0.01463618f, 0.03085175f, 0.02989001f, -0.03458067f, -0.02133648f, 
    -0.00505618f, -0.00502451f, 0.01389918f, 0.00406727f, 0.01161713f, -0.00399197f, -0.01237880f, -0.00034668f, 
    0.02006462f, 0.02864442f, 0.02935787f, 0.01247688f, -0.01152015f, -0.01862186f, -0.03795483f, -0.04430440f, 
    0.01785401f, -0.02823453f, 0.02832462f, -0.00269030f, 0.01516134f, 0.01160178f, -0.00357718f, 0.04051556f, 
    0.03293851f, -0.02849546f, 0.00573508f, 0.02169660f, 0.02086019f, -0.04457586f, -0.04153144f, -0.01796876f, 
    0.00788091f, -0.01235881f, 0.01380549f, -0.00148344f, 0.03316777f, -0.03185389f, -0.04146826f, 0.01535878f, 
    -0.00223197f, -0.02228731f, -0.02116967f, -0.04583601f, -0.03187902f, -0.04256987f, -0.04245343f, -0.00870535f, 
    -0.00516674f, 0.00845953f, 0.00108487f, 0.01540078f, 0.00051624f, -0.02462147f, 0.01034420f, -0.02059854f, 
    -0.00069497f, -0.03586233f, -0.03896295f, 0.02236092f, -0.02736519f, 0.00364699f, 0.03425406f, -0.02162510f, 
    0.02908625f, 0.04191668f, 0.00656401f, -0.02668462f, -0.03009573f, -0.03753150f, 0.01437121f, -0.03175500f, 
    0.01198925f, 0.03215582f, -0.03387221f, -0.04311532f, -0.03266463f, 0.03121068f, 0.02925374f, -0.02768408f, 
    -0.03321234f, -0.02010645f, -0.01970057f, 0.00379699f, -0.00156813f, 0.03447259f, 0.02125659f, 0.01704240f, 
    -0.00935229f, -0.00774679f, -0.04142134f, -0.02999383f, 0.00715548f, -0.00752861f, -0.00434830f, 0.00452241f, 
    0.02685430f, 0.02869861f, -0.00792763f, 0.00341950f, 0.00278440f, -0.00436932f, 0.01722542f, -0.02653707f, 
    0.01401629f, 0.03207540f, 0.02768943f, 0.02092959f, -0.00819587f, -0.01283000f, -0.02782460f, -0.01488125f, 
    0.02914060f, 0.02726999f, 0.02084983f, -0.03700715f, 0.00430624f, -0.03320010f, -0.00836355f, -0.03608532f, 
    0.00948236f, 0.01901941f, -0.02160039f, -0.03669576f, 0.00998724f, 0.00864202f, -0.03250898f, -0.01803174f, 
    -0.01880458f, 0.02944739f, -0.00455528f, 0.01848415f, 0.02561010f, 0.02612547f, 0.00294465f, 0.01811718f, 
    -0.02706266f, -0.01859269f, -0.00706381f, -0.00447645f, -0.01802900f, 0.00897842f, 0.01797841f, -0.02833187f, 
    0.02449260f, 0.01181465f, -0.03629601f, 0.01120795f, 0.01382503f, 0.00650592f, 0.02741688f, -0.00358036f, 
    -0.00620395f, -0.00420806f, -0.03146097f, 0.01335663f, -0.03045157f, -0.01076946f, -0.03903203f, 0.01519588f, 
    0.04629524f, -0.02153442f, 0.01521104f, -0.00714348f, -0.00938870f, -0.01676864f, -0.02187998f, -0.03464288f, 
    -0.02540701f, 0.01674935f, -0.02817214f, -0.02476696f, -0.01490412f, -0.00865836f, -0.03554949f, -0.03372152f, 
    0.00408802f, 0.00977786f, 0.00715776f, -0.00818022f, -0.01158742f, -0.02895223f, 0.00469678f, 0.01676178f, 
    -0.01746645f, -0.00151214f, -0.00512699f, -0.00265647f, -0.00345017f, 0.02614847f, 0.00012577f, 0.02340726f, 
    -0.04047736f, 0.00597974f, 0.01629567f, -0.04136677f, -0.02517505f, -0.00830919f, -0.02726724f, -0.03147687f, 
    -0.01521125f, 0.02250419f, -0.00360890f, -0.00030826f, 0.00913749f, 0.03076433f, 0.02835569f, -0.01131569f, 
    -0.01764916f, 0.01393567f, 0.00716717f, 0.02752761f, 0.01706534f, 0.00822297f, 0.02425876f, 0.02018797f, 
    0.02540350f, -0.02519382f, -0.04422386f, 0.00508228f, -0.01501390f, 0.03201678f, 0.01233086f, -0.02262061f, 
    -0.03881868f, 0.02920837f, -0.02410537f, 0.03466160f, -0.01936152f, -0.01418883f, -0.00307580f, -0.00516303f, 
    -0.00398337f, -0.03583737f, -0.00725314f, -0.03192018f, 0.01335018f, 0.02499147f, -0.01504154f, 0.00876616f, 
    0.01379686f, -0.00177540f, -0.02763613f, 0.03191128f, -0.00173022f, -0.01040674f, 0.00427321f, 0.00189790f, 
    -0.03606510f, -0.01637135f, -0.01073239f, 0.02913720f, -0.01774002f, -0.03951025f, 0.02783724f, -0.01230551f, 
    0.02249139f, 0.03230706f, -0.04080733f, -0.02609578f, -0.00542001f, 0.01603707f, -0.02329855f, 0.01784681f, 
    -0.03944056f, 0.02199912f, -0.04096013f, -0.01068208f, -0.03192740f, 0.00835157f, -0.01162011f, 0.02018921f, 
    0.00430953f, 0.01409320f, -0.03890911f, 0.02343925f, -0.03998762f, 0.01512939f, 0.00488860f, 0.02370111f, 
    0.00925735f, -0.00764411f, -0.03972637f, -0.01294359f, -0.01035003f, -0.03625512f, -0.02865108f, 0.01545217f, 
    0.01016219f, -0.01227854f, 0.02334802f, 0.03351856f, 0.02394864f, -0.00416535f, -0.03319975f, -0.03937772f, 
    -0.03337169f, 0.02170170f, -0.01894042f, 0.02392538f, -0.02000923f, -0.01116399f, 0.01951357f, 0.01494278f, 
    -0.02259461f, -0.00911678f, 0.03337709f, 0.00250198f, 0.01648867f, 0.02697090f, -0.01971887f, 0.00664372f, 
    -0.03324696f, -0.03770249f, 0.00067140f, -0.01877482f, 0.01232371f, 0.00994038f, -0.03092455f, -0.02783620f, 
    -0.02113148f, 0.00221390f, 0.01971229f, 0.02282053f, -0.03556212f, 0.01862606f, -0.02261551f, -0.01069801f, 
    -0.03592547f, -0.00797869f, 0.01057324f, -0.01489069f, -0.01423258f, 0.01485327f, 0.02586198f, 0.01074171f, 
    0.01596384f, 0.01307957f, -0.03518223f, -0.00362947f, -0.01029308f, -0.03204029f, 0.01269549f, 0.01932880f, 
    -0.03443045f, 0.01654998f, 0.02437182f, -0.00656921f, -0.00794520f, -0.00999581f, 0.00029478f, 0.01810411f, 
    -0.00779813f, 0.00700854f, -0.01874882f, 0.02107581f, -0.01128070f, -0.02611675f, 0.02989940f, -0.00988050f, 
    -0.03176396f, 0.00640098f, 0.00638267f, -0.03869499f, 0.01559980f, -0.03415521f, -0.02596904f, -0.03100168f, 
    0.01041548f, -0.04107527f, -0.03101883f, 0.00530069f, 0.02577393f, 0.00378972f, -0.01436369f, -0.00512405f, 
    -0.00981845f, -0.04145437f, -0.00808910f, 0.01453420f, 0.02598703f, -0.01071183f, -0.01705349f, 0.02451846f, 
    0.00547906f, 0.00226010f, -0.02312389f, -0.04186931f, -0.00292173f, -0.02651016f, 0.00793669f, -0.00612707f, 
    0.01353561f, -0.03499497f, -0.03980876f, -0.02329900f, -0.01086761f, 0.01725978f, -0.02227170f, -0.02564534f, 
    0.03314193f, 0.02384078f, -0.02227518f, 0.03063110f, 0.02604451f, 0.00307470f, -0.04022938f, 0.03014496f, 
    0.02148199f, 0.01594053f, -0.00851129f, 0.01983669f, 0.01861059f, -0.02949973f, 0.02165856f, -0.00147207f, 
    -0.00866013f, -0.01644072f, -0.00325158f, -0.02788555f, -0.02531040f, 0.00548919f, 0.00497555f, 0.02357271f, 
    0.01448872f, -0.01453216f, -0.04391240f, 0.01473536f, -0.02783046f, -0.01228655f, 0.01936525f, 0.03522411f, 
    0.01719849f, 0.01461937f, 0.01663568f, -0.02470272f, 0.00872179f, -0.00218411f, -0.04028221f, 0.01655362f, 
    -0.02546765f, -0.00658012f, 0.01503546f, 0.02786133f, -0.00089643f, 0.03276549f, -0.03585589f, -0.00817206f, 
    -0.02114837f, 0.02446122f, 0.01399923f, -0.03597699f, 0.01240758f, -0.00169179f, 0.02351545f, -0.03208441f, 
    0.02747938f, -0.02321015f, -0.01296265f, 0.00946494f, -0.00078189f, -0.00424655f, -0.00827521f, -0.00005023f, 
    -0.02643743f, 0.02047469f, 0.00378825f, -0.02342173f, -0.00367851f, 0.01146522f, -0.04435683f, -0.03269667f, 
    -0.03982197f, -0.00230449f, -0.04483260f, -0.00198923f, -0.01633961f, -0.03718898f, -0.01208175f, -0.00064312f, 
    0.00833327f, 0.03342624f, -0.02758205f, -0.02828635f, 0.02148884f, -0.03027907f, -0.00200554f, -0.01298740f, 
    -0.03773432f, 0.00092021f, 0.01520745f, -0.00759440f, 0.02621054f, -0.01854193f, -0.01818288f, -0.01850658f, 
    -0.01365166f, -0.02091377f, 0.00355756f, -0.02505074f, 0.03304486f, -0.02919753f, -0.02724185f, 0.00095408f, 
    -0.03054271f, 0.02630374f, 0.03100653f, -0.01708259f, 0.00154406f, -0.02801202f, 0.00934121f, 0.01543443f, 
    -0.00007175f, -0.01166276f, 0.01978843f, 0.01455553f, -0.03703040f, -0.02579803f, 0.02927150f, -0.01363869f, 
    -0.00132290f, -0.04063211f, -0.01518878f, -0.01410265f, 0.00909365f, 0.02724196f, -0.04138290f, 0.00549218f, 
    0.03416600f, -0.03735476f, 0.00090343f, -0.02243931f, 0.00689854f, 0.00893438f, -0.02671830f, -0.00063701f, 
    0.01928168f, 0.00673195f, 0.02103409f, 0.00460973f, 0.00947898f, -0.02327380f, 0.01044842f, -0.00101340f, 
    -0.00738119f, -0.03445492f, 0.00685799f, 0.04177902f, -0.02296621f, -0.04076637f, -0.02398735f, 0.03450614f, 
    -0.01812579f, 0.01829233f, -0.01526860f, -0.03787507f, -0.04169555f, -0.01920371f, -0.02439173f, 0.01556058f, 
    0.00824186f, 0.01234276f, -0.02860812f, -0.04428631f, 0.02128042f, -0.02541644f, -0.02337753f, -0.03146800f, 
    0.00247797f, 0.02590646f, 0.02166261f, 0.01470506f, 0.03307579f, -0.02198051f, -0.00622027f, 0.02374315f, 
    0.01001615f, 0.03257057f, -0.01514698f, 0.00640588f, 0.00203841f, -0.04227187f, -0.01505942f, -0.02256416f, 
    -0.02799261f, -0.00186183f, -0.00774894f, 0.03250861f, 0.02982504f, 0.01381174f, -0.03070902f, 0.04188270f, 
    -0.00136936f, -0.00636411f, 0.00486977f, 0.02208594f, 0.00276411f, -0.01253406f, -0.00218144f, 0.01369150f, 
    0.03226471f, -0.01964420f, -0.04076247f, -0.04452275f, -0.01897978f, -0.02695103f, -0.01276233f, 0.01016862f, 
    -0.02021267f, 0.01824710f, -0.03816735f, 0.00585823f, 0.01722219f, -0.02322171f, 0.00131859f, -0.04122987f, 
    -0.03190567f, 0.00223559f, 0.01373224f, -0.00954038f, -0.00844132f, -0.01189799f, 0.00935758f, -0.00930925f, 
    -0.03977354f, 0.02375811f, -0.01656140f, -0.02056001f, -0.00940399f, 0.03105021f, 0.01134862f, -0.04136825f, 
    0.01581090f, 0.04268844f, -0.01886431f, 0.00430599f, -0.03645794f, 0.01374701f, -0.00988339f, -0.03592101f, 
    -0.03140188f, 0.04540708f, 0.01311989f, -0.04187733f, 0.00553215f, 0.00083173f, -0.01420873f, 0.02604633f, 
    -0.02865253f, -0.01248087f, -0.02130598f, 0.01287830f, -0.02985303f, -0.00816222f, 0.02434331f, 0.03833416f, 
    -0.02829361f, 0.00175118f, -0.01116016f, -0.04275774f, 0.00033899f, 0.02401994f, -0.01877076f, 0.01151854f, 
    0.02630104f, -0.02675068f, 0.02451801f, 0.04327017f, -0.00685486f, -0.01399770f, -0.02814236f, 0.01206677f, 
    0.02891557f, -0.00870290f, 0.01563259f, -0.01568956f, 0.00679555f, 0.03317298f, -0.01235978f, -0.02697573f, 
    0.01818837f, -0.03053653f, 0.01043019f, -0.03164946f, -0.04168141f, 0.02920322f, -0.03298857f, -0.00395997f, 
    -0.01162079f, 0.00935087f, 0.00490234f, -0.02062018f, -0.02639855f, 0.02785992f, -0.00795547f, 0.01423912f, 
    0.02774209f, -0.03678390f, -0.02853135f, -0.01549865f, -0.02806344f, 0.00724820f, -0.00616990f, -0.03692294f, 
    0.01797855f, 0.02895923f, 0.02287920f, -0.01959449f, -0.01817235f, 0.01179825f, -0.02089898f, -0.04390664f, 
    0.01853650f, -0.02430460f, -0.02813073f, 0.00856850f, 0.02060487f, -0.02420081f, 0.00277745f, 0.00798610f, 
    -0.01273931f, -0.04243775f, 0.01885567f, 0.03131007f, 0.00208498f, -0.00234979f, 0.02682344f, -0.01123702f, 
    0.01610204f, 0.03796386f, -0.04462619f, -0.00317584f, 0.02959184f, 0.01491902f, 0.01281645f, 0.00627269f, 
    -0.01445869f, -0.01564639f, -0.04452943f, 0.00364823f, 0.00840011f, 0.00260780f, 0.00332835f, 0.01788854f, 
    0.00586705f, 0.01013264f, -0.03592448f, -0.00300923f, -0.03175673f, -0.02584237f, 0.04455438f, -0.00827755f, 
    -0.02371757f, 0.03347229f, 0.02763586f, -0.01252555f, 0.02442306f, -0.02291054f, 0.02288625f, -0.02391670f, 
    -0.04413493f, -0.02032627f, -0.01833318f, 0.01880124f, -0.04057273f, 0.03250747f, -0.04075997f, 0.01694424f, 
    -0.03715178f, -0.00701572f, 0.01179798f, -0.00042183f, 0.03575242f, 0.00433769f, 0.03339371f, 0.01065246f, 
    0.02590764f, 0.02901947f, 0.00834264f, 0.01599210f, -0.03827783f, 0.00498152f, 0.00416184f, -0.02832047f, 
    -0.03655512f, -0.02648441f, -0.03883523f, -0.02644718f, -0.01948128f, 0.03319359f, -0.03342775f, 0.00680716f, 
    0.08837074f, 0.10443865f, 0.13559976f, -0.11416446f, 0.16567759f, 0.03820750f, -0.04447699f, 0.02897937f, 
    -0.01287137f, -0.03647541f, 0.07908690f, -0.13641800f, 0.03547552f, -0.07536575f, -0.14564206f, -0.03863838f, 
    -0.05715618f, 0.00518813f, 0.00269240f, -0.00894606f, 0.22788717f, 0.16279981f, 0.15350975f, 0.09650354f, 
    -0.17588450f, 0.26107961f, 0.20869750f, -0.17039250f, 0.16784665f, 0.21233483f, 0.04394456f, 0.07419472f, 
    0.07148874f, 0.02208013f, 0.09159549f, 0.09061001f, 0.18763492f, -0.10441729f, 0.13578160f, 0.08883071f, 
    -0.39946195f, -0.21939641f, 0.25765550f, 0.18944462f, -0.07451094f, -0.00796689f, -0.17224438f, -0.06700300f, 
    0.06514017f, -0.00567333f, 0.05616902f, 0.07361148f, 0.01289897f, 0.03332192f, -0.11062837f, -0.00662411f, 
    0.01917887f, 0.05435397f, 0.03718998f, 0.11055563f, 0.07013620f, -0.06565192f, 0.06030879f, 0.09551507f, 
    0.14248560f, 0.10184083f, 0.03113269f, -0.06039682f, 0.00410809f, 0.04450362f, 0.13923076f, 0.04617960f, 
    0.11625476f, 0.10548314f, 0.11263093f, 0.14534378f, -0.01451685f, -0.00920455f, 0.02417557f, -0.10006018f, 
    -0.09138901f, -0.03034543f, 0.11796793f, 0.12995741f, -0.12578931f, 0.03972164f, -0.02283813f, 0.00493111f, 
    0.20474234f, 0.00747125f, 0.06191232f, 0.09527392f, 0.19851209f, -0.05394614f, 0.09134394f, -0.06279224f, 
    0.16054556f, 0.12987472f, 0.08734548f, 0.07876911f, -0.31749895f, -0.05346410f, 0.35887226f, 0.22839361f, 
    0.16411510f, -0.15572722f, -0.05221262f, -0.09253930f, 0.03037626f, 0.01735742f, 0.09057325f, 0.07026700f, 
    0.17663108f, -0.08762687f, 0.06301522f, 0.10250276f, -0.01821974f, 0.01647794f, 0.05276923f, 0.06640531f, 
    -0.20253457f, 0.20206806f, -0.36107004f, 0.36408666f, 0.31496218f, 0.04050932f, 0.14382678f, -0.14989129f, 
    -0.04086148f, 0.19466726f, 0.07830136f, 0.03915589f, 0.25508568f, 0.07185293f, -0.03758830f, -0.00059968f, 
    0.24196886f, -0.05476578f, 0.28602308f, 0.07057212f, -0.11863305f, -0.21508263f, 0.25303081f, -0.10587250f, 
    0.17269751f, 0.12478265f, -0.18492976f, -0.07760529f, 0.03762709f, 0.09712655f, 0.01179680f, 0.05966131f, 
    0.02377637f, 0.05154741f, 0.04640667f, -0.10251743f, -0.00238846f, 0.16929020f, 0.17516613f, 0.17078823f, 
    -0.26665992f, -0.30998188f, -0.06338634f, -0.06129538f, -0.08991443f, 0.05835682f, -0.13982131f, -0.09602480f, 
    -0.03400474f, -0.15854262f, -0.03109759f, 0.03163615f, -0.09517123f, -0.00351935f, -0.03787007f, -0.02812649f, 
    0.00626506f, -0.00694678f, -0.13310260f, -0.04257606f, -0.07156131f, -0.12334698f, -0.09514271f, 0.08979705f, 
    -0.01110716f, -0.00545304f, 0.09560385f, -0.00518907f, 0.08460582f, -0.00999948f, 0.09732002f, 0.00041613f, 
    -0.00072346f, 0.04799042f, 0.16674249f, -0.01918689f, 0.10372805f, 0.02324476f, -0.00458395f, 0.09390403f, 
    -0.31188443f, -0.20388144f, -0.00587945f, 0.23483476f, -0.11815106f, -0.13288374f, 0.01461785f, 0.00821889f, 
    0.02730288f, -0.16221683f, 0.01566343f, 0.15881978f, 0.05828753f, -0.04838332f, 0.00986061f, 0.04923471f, 
    0.03098276f, 0.11331946f, -0.02458524f, -0.05467848f, 0.26394814f, -0.03380917f, -0.20986161f, -0.07402784f, 
    0.29629093f, 0.23928824f, 0.22593728f, -0.05290955f, 0.04608036f, 0.01593101f, 0.26750299f, -0.13750176f, 
    -0.02788657f, -0.07361784f, 0.04091809f, 0.01755444f, 0.09814940f, -0.13393620f, 0.06624851f, 0.08115131f, 
    -0.18816297f, -0.20195541f, -0.11881095f, 0.11728652f, -0.10848296f, -0.06748798f, -0.11388581f, 0.00238227f, 
    -0.03295488f, -0.15044725f, -0.05790521f, -0.00421714f, 0.00174135f, 0.05875965f, 0.08192015f, -0.01620628f, 
    -0.03876862f, -0.11874498f, 0.07386717f, 0.21353319f, -0.27895904f, -0.10023547f, 0.71033847f, -0.06539097f, 
    -0.13767144f, -0.04329829f, -0.24983726f, -0.14685459f, 0.08580554f, -0.11060948f, 0.16709478f, 0.30860481f, 
    -0.01783321f, 0.17841172f, 0.03385512f, 0.07697099f, -0.17620677f, 0.07602832f, -0.03164673f, -0.03610412f, 
    -0.25730038f, -0.22328028f, 0.06743474f, 0.25465515f, -0.12783453f, 0.05187008f, -0.01350902f, 0.03694873f, 
    0.06208491f, -0.07166634f, 0.05678309f, 0.02269757f, 0.02843898f, 0.15831476f, -0.18534839f, -0.00123974f, 
    0.11323685f, 0.08582395f, 0.05929339f, 0.02089549f, 0.12668188f, 0.02146239f, 0.04899205f, -0.02515828f, 
    0.28412774f, 0.08970642f, 0.03419968f, -0.01172870f, -0.03486705f, 0.02963218f, 0.07518889f, -0.08623013f, 
    -0.03104291f, -0.10544516f, -0.04938923f, 0.13631611f, 0.04146320f, 0.01831036f, 0.05228304f, 0.01569099f, 
    -0.16127650f, 0.17841710f, 0.50958031f, 0.18649900f, 0.00074503f, -0.00776939f, -0.06722839f, -0.09462982f, 
    0.14345296f, 0.13117117f, 0.09000246f, 0.21739474f, 0.27174884f, 0.01535251f, 0.03081364f, 0.04925893f, 
    -0.01227682f, 0.02789183f, 0.03163783f, 0.02593094f, 0.13138488f, 0.01702526f, 0.03971319f, -0.01360262f, 
    0.00537399f, -0.00981704f, -0.02063948f, -0.02396512f, -0.06034563f, -0.01988700f, 0.16080470f, -0.18553340f, 
    0.01188715f, -0.08713359f, 0.00948231f, 0.05036371f, -0.10344113f, -0.09217171f, -0.08681010f, 0.00059485f, 
    0.07842059f, 0.05313982f, 0.04086750f, -0.13865456f, 0.49470535f, -0.01118771f, -0.04883499f, -0.03200200f, 
    -0.07312266f, -0.07827407f, -0.11578764f, -0.07228982f, -0.04730592f, -0.06852476f, -0.08276197f, 0.10488272f, 
    0.15608305f, 0.03864735f, 0.03504797f, 0.13966815f, 0.10620295f, -0.01994549f, -0.01211042f, -0.04564930f, 
    -0.00919861f, 0.14822674f, -0.08820488f, 0.05255944f, -0.06104337f, -0.04354839f, 0.09847640f, 0.02669295f, 
    0.04716140f, 0.15016176f, 0.04094214f, 0.13210744f, -0.00994249f, 0.08234885f, -0.09388386f, -0.07051997f, 
    -0.24262337f, -0.28673223f, -0.07876799f, 0.01082643f, 0.01581403f, -0.01695502f, -0.06381735f, -0.05408502f, 
    0.01400310f, -0.15954149f, -0.00312860f, 0.08228545f, -0.04475312f, -0.04822338f, -0.06227226f, 0.03552602f, 
    -0.02239848f, 0.05344531f, 0.20759487f, 0.00138476f, -0.02049003f, 0.32290545f, 0.39800569f, -0.06072947f, 
    0.04000271f, -0.08480447f, -0.10932162f, -0.09561828f, -0.14731608f, -0.20840514f, 0.09528104f, -0.04019012f, 
    0.11435725f, 0.00461958f, 0.12622121f, -0.06872324f, -0.07808208f, -0.05434146f, -0.02180557f, -0.01282380f, 
    0.53676027f, 0.08027306f, -0.00469606f, -0.05504100f, 0.10181672f, 0.14880566f, 0.09833802f, 0.07901779f, 
    -0.04586539f, 0.24575090f, -0.01943107f, 0.02389012f, -0.04283651f, 0.01337393f, -0.08639643f, 0.05878146f, 
    -0.08513128f, 0.01648917f, 0.02834524f, 0.08624309f, 0.24924609f, -0.07814614f, -0.28014520f, -0.00750195f, 
    0.28067571f, 0.04960185f, 0.26469818f, 0.23615755f, 0.00063965f, 0.08732445f, -0.03512155f, -0.04634800f, 
    -0.05189010f, -0.04804836f, -0.00240409f, 0.11473200f, -0.05499791f, 0.05519287f, 0.17833391f, 0.18626460f, 
    0.36357999f, -0.08829650f, 0.07843623f, -0.08642360f, 0.19041766f, 0.08863055f, 0.00602387f, 0.08066358f, 
    -0.03133764f, 0.14272863f, -0.01520977f, -0.09063517f, -0.08069953f, -0.09602575f, -0.16683964f, -0.02333329f, 
    -0.20009124f, -0.16109288f, 0.02052584f, -0.01417755f, -0.07779175f, 0.03530304f, -0.13631010f, -0.06771182f, 
    0.14417399f, -0.01433733f, -0.19420806f, -0.15604402f, 0.03191315f, -0.07096851f, 0.05493917f, -0.13032922f, 
    -0.11789057f, -0.00665912f, 0.03497256f, -0.04599836f, -0.08674118f, -0.06548759f, -0.08466160f, -0.19256854f, 
    -0.37966302f, -0.10043401f, 0.03914903f, 0.20805441f, -0.13357408f, -0.06747293f, -0.12421551f, 0.09401698f, 
    0.00958616f, 0.06759912f, 0.09724399f, 0.13150887f, 0.11902190f, -0.03238171f, 0.00437141f, -0.00589651f, 
    0.04046669f, -0.04274829f, 0.11009985f, -0.16895232f, 0.08450262f, -0.05023153f, 0.10753255f, 0.17286372f, 
    0.19891253f, 0.08459147f, 0.17985450f, 0.13403709f, -0.01600886f, 0.10327641f, 0.16681218f, 0.09688812f, 
    0.00981495f, 0.02231338f, 0.13454716f, 0.10125313f, 0.15230522f, -0.00141855f, 0.13849635f, -0.01690454f, 
    -0.07400995f, 0.18002824f, 0.28562632f, 0.30702096f, 0.08738010f, -0.09450094f, -0.12754197f, -0.20607883f, 
    -0.10982990f, -0.06105573f, 0.02539166f, -0.02500064f, 0.21157998f, 0.08646434f, 0.12016002f, -0.03072925f, 
    -0.09262107f, -0.08896209f, -0.05222328f, 0.00916687f, 0.04876661f, 0.05287544f, 0.27151573f, 0.10979833f, 
    0.07625784f, -0.04075315f, -0.03022450f, -0.09361718f, -0.04234316f, -0.11183413f, 0.00987866f, 0.03088505f, 
    0.16418372f, 0.09309975f, 0.11228322f, 0.03022422f, -0.09688040f, -0.12423601f, -0.04812435f, -0.04990633f, 
    -0.33653918f, -0.25806260f, 0.13972391f, 0.31349048f, -0.30402040f, -0.21795361f, -0.19687116f, 0.08551656f, 
    -0.01340828f, 0.02623421f, -0.06640723f, 0.11078868f, 0.02073434f, -0.04336431f, -0.07728284f, -0.03019548f, 
    -0.00246201f, 0.04633781f, 0.00289153f, -0.13334267f, 0.47131971f, 0.06429374f, -0.32577890f, -0.14460805f, 
    0.11815646f, -0.00053249f, 0.13748196f, 0.18160716f, -0.05014569f, -0.01804243f, -0.07264312f, -0.02705745f, 
    -0.10358820f, -0.06513609f, -0.05731431f, 0.06043951f, -0.01061302f, 0.02964569f, 0.09104811f, 0.14872622f, 
    -0.16118096f, 0.09225744f, -0.09775183f, -0.01014792f, -0.09748748f, -0.07531515f, 0.10846959f, -0.16946287f, 
    0.09999552f, -0.02217650f, 0.01947602f, -0.00662296f, 0.11793026f, 0.01908541f, 0.16729070f, 0.13035527f, 
    0.07782689f, 0.15277871f, -0.06928337f, -0.09305421f, -0.10944834f, 0.05378586f, 0.09582296f, 0.04996475f, 
    -0.04410499f, -0.12598917f, -0.25995567f, 0.05765166f, -0.13802543f, -0.20958523f, -0.20709512f, -0.08676462f, 
    -0.00694173f, 0.02799119f, -0.15965085f, 0.15278693f, 0.01638018f, -0.05868130f, -0.11628859f, -0.06063496f, 
    0.07819294f, 0.00752048f, 0.06486572f, 0.25061303f, 0.03016184f, 0.01010244f, 0.24654128f, 0.11266834f, 
    0.15980610f, 0.01178120f, -0.10093410f, -0.06261103f, 0.04877101f, 0.13682319f, 0.16538207f, 0.03174215f, 
    0.05552529f, 0.11512166f, -0.05895533f, -0.05478565f, -0.05814946f, 0.26524308f, -0.17386441f, -0.21656348f, 
    0.07809801f, -0.02180271f, 0.03398022f, 0.08565787f, -0.03147363f, -0.05231880f, -0.01579068f, 0.05393565f, 
    -0.00650874f, -0.07221613f, 0.01165352f, -0.02599516f, -0.04312645f, -0.15900448f, 0.00809575f, 0.14189640f, 
    -0.21511160f, -0.11366690f, 0.38441947f, 0.01218401f, 0.15432176f, 0.19776784f, 0.03397891f, 0.10741430f, 
    0.01409468f, -0.03161411f, -0.00782062f, -0.07292516f, 0.08953904f, 0.16326000f, 0.22926596f, 0.13939762f, 
    0.01543739f, -0.09562384f, 0.00577267f, -0.01473802f, -0.02545306f, 0.15899961f, 0.02900933f, 0.14315043f, 
    0.01467103f, 0.16697566f, 0.24166299f, 0.10418364f, 0.15521425f, 0.09186957f, -0.08163157f, -0.02939460f, 
    0.03207549f, 0.09276876f, 0.22155835f, -0.09342019f, 0.05539755f, 0.09345716f, -0.09187133f, 0.11778815f, 
    0.69078702f, 0.02374478f, -0.13467763f, -0.05822913f, -0.14884673f, 0.04337993f, 0.09633747f, -0.03387690f, 
    0.04868456f, -0.01210956f, 0.00070089f, -0.02677009f, -0.03682683f, 0.17963544f, -0.19823855f, -0.08107154f, 
    -0.01127211f, 0.14155976f, -0.06911927f, 0.18282478f, 0.64368534f, -0.21624711f, -0.25185686f, 0.33195421f, 
    -0.30157200f, 0.05068707f, 0.08885089f, -0.00104879f, 0.13374406f, 0.11057379f, -0.02770530f, -0.05824859f, 
    0.07219495f, -0.12018994f, -0.01027245f, -0.04624622f, 0.13640743f, 0.01189048f, 0.10703410f, -0.00360926f, 
    0.13307762f, -0.02315959f, 0.46389377f, 0.32615390f, 0.15422423f, -0.02622291f, 0.08190301f, 0.11236571f, 
    0.19341080f, 0.33637166f, 0.04582954f, -0.01045873f, 0.07886174f, -0.11511755f, -0.03358579f, -0.06029882f, 
    0.01866563f, -0.05630024f, 0.26603034f, 0.10272995f, 0.15211427f, -0.02937084f, 0.30754432f, 0.21385057f, 
    0.30934370f, -0.02570736f, -0.12839940f, 0.02328965f, 0.16686261f, 0.07392423f, -0.09892532f, 0.10511213f, 
    0.04518066f, -0.10921013f, -0.08135825f, 0.04557901f, 0.12491037f, -0.10815205f, 0.02485343f, -0.00184349f, 
    0.40583307f, -0.11340223f, 0.13589276f, 0.08721512f, 0.10550510f, 0.09748082f, 0.05622460f, 0.20437253f, 
    0.07495234f, 0.32979617f, -0.13854158f, 0.08223946f, -0.12135219f, -0.02691432f, 0.00600054f, 0.11276204f, 
    -0.10362251f, 0.03128868f, 0.03951413f, -0.08636048f, -0.45854822f, 0.07824119f, 0.10017927f, -0.01971727f, 
    -0.00781004f, 0.29117215f, -0.02856838f, 0.01977058f, 0.08397215f, 0.06300727f, -0.15784580f, -0.00689984f, 
    -0.01934998f, 0.03210580f, 0.01316099f, -0.02580373f, -0.04850026f, 0.02232732f, 0.17622076f, -0.19890304f, 
    -0.01308591f, -0.21556045f, 0.17050761f, 0.42354521f, 0.35288322f, -0.05591168f, 0.00440593f, 0.00246081f, 
    0.11909890f, 0.27009001f, 0.02474869f, 0.03177319f, -0.02921579f, -0.05887641f, -0.04588785f, 0.15664613f, 
    0.20220122f, 0.04691277f, -0.04571155f, 0.00108936f, 0.69762009f, -0.11823910f, -0.21349390f, -0.01744517f, 
    0.20150693f, -0.09202959f, 0.01080603f, 0.12400846f, 0.19995746f, 0.07207238f, -0.01362618f, -0.17281909f, 
    0.02739957f, -0.15848930f, -0.00433130f, 0.07935848f, -0.10512640f, 0.02860872f, -0.00442513f, -0.04946890f, 
    -0.03531164f, -0.08430734f, 0.29552740f, 0.16157588f, 0.09623455f, -0.13021007f, 0.10194939f, 0.00372272f, 
    0.00680889f, 0.03634540f, -0.07475345f, -0.06526332f, 0.00706941f, 0.03569796f, 0.07858978f, 0.07534379f, 
    0.13510229f, 0.16239035f, -0.01878609f, 0.01969633f, -0.16488130f, 0.21246575f, -0.18199357f, 0.00851454f, 
    -0.17924055f, 0.05875396f, -0.07989561f, -0.10584002f, 0.02493354f, -0.15526077f, -0.09373693f, 0.06374177f, 
    -0.04954835f, -0.06997085f, 0.26715642f, -0.05281358f, 0.03606791f, -0.04409627f, 0.11164245f, 0.01237604f, 
    0.29127893f, -0.18914460f, -0.09054166f, 0.08320433f, 0.07120388f, 0.08722157f, 0.04232299f, 0.02148444f, 
    0.14117189f, 0.00620605f, 0.03836096f, -0.01549057f, 0.02471161f, 0.00615251f, -0.00216747f, -0.08173576f, 
    -0.02020354f, 0.02214365f, -0.06940199f, -0.01328207f, -0.26560706f, -0.05533749f, 0.05953490f, 0.01541759f, 
    -0.18453591f, 0.04563851f, 0.05895307f, 0.01869247f, -0.00068235f, -0.18278944f, 0.05250652f, 0.08520097f, 
    0.03600010f, 0.19342384f, 0.00005832f, 0.21415786f, 0.03027297f, 0.17538017f, -0.07991423f, -0.16770451f, 
    -0.49329400f, -0.05423507f, -0.01195447f, -0.03849529f, -0.12124988f, 0.02926419f, 0.02940259f, 0.01999773f, 
    -0.04530651f, -0.10941215f, -0.10993101f, 0.10660001f, 0.08961457f, 0.15310295f, 0.06202706f, -0.06774011f, 
    0.04217019f, -0.01300519f, 0.14957912f, 0.10677677f, -0.28704658f, 0.07778040f, 0.13808289f, -0.14167769f, 
    -0.03246076f, -0.17861278f, 0.03428415f, -0.04244895f, 0.03267801f, -0.03923603f, -0.07397631f, -0.13653573f, 
    -0.02480354f, -0.06735004f, -0.01125332f, 0.13991375f, -0.00650389f, -0.09922782f, 0.13216695f, -0.08453838f, 
    0.15821004f, 0.02755105f, 0.40804628f, 0.36277020f, 0.30641013f, 0.06928084f, -0.02112703f, 0.24251397f, 
    -0.01394352f, 0.38660428f, -0.02632263f, 0.13420250f, -0.02458413f, -0.03848097f, -0.12989873f, 0.04896968f, 
    0.10920124f, -0.11237600f, 0.10051364f, 0.03073390f, -0.28398383f, -0.38857844f, 0.35183445f, -0.04386501f, 
    -0.05317475f, -0.02119374f, -0.02016612f, 0.20346941f, -0.04608610f, -0.10058243f, 0.03605819f, 0.06255423f, 
    0.06238693f, -0.03786840f, 0.21466960f, -0.07101181f, -0.10612822f, 0.01466640f, -0.03632782f, -0.03423030f, 
    -0.30020908f, 0.01433860f, 0.14568780f, 0.03807051f, -0.13080163f, -0.01695478f, -0.10359108f, 0.03689522f, 
    -0.00649143f, -0.09814221f, 0.02850457f, 0.00159274f, -0.02541287f, -0.08880927f, -0.10234804f, 0.00811430f, 
    0.11334509f, -0.01372480f, -0.05791192f, 0.02452921f, 0.28473198f, 0.38390771f, 0.21585281f, 0.45674747f, 
    0.02536083f, 0.03208141f, 0.05364983f, -0.23422255f, 0.00661222f, 0.07577583f, 0.04620997f, -0.00308500f, 
    0.12934551f, -0.02408139f, -0.01215530f, -0.00858366f, 0.04047180f, 0.14935553f, -0.06564167f, 0.11843646f, 
    -0.45302972f, 0.18043992f, 0.14402683f, 0.08694878f, -0.11597558f, -0.04636589f, 0.03358188f, -0.05269078f, 
    0.08839486f, -0.05665838f, 0.09059552f, 0.00806910f, 0.09040482f, 0.08179223f, 0.00481735f, 0.07447807f, 
    0.05435584f, 0.08688987f, -0.10278317f, -0.02350547f, 0.05561631f, 0.17405376f, 0.04622862f, 0.11462960f, 
    -0.21737742f, 0.18678455f, 0.10908961f, -0.01823579f, -0.13453874f, 0.01412684f, -0.00578972f, 0.03033274f, 
    0.17002872f, -0.15678084f, 0.01093775f, 0.01811636f, -0.04445057f, -0.01584868f, -0.07644819f, -0.07960442f, 
    0.46599844f, -0.34266022f, 0.21132226f, 0.13289851f, 0.26912194f, 0.19864276f, -0.01232816f, 0.03963777f, 
    0.08817681f, 0.12543853f, -0.11634322f, -0.02623904f, 0.01522831f, -0.15983091f, -0.01774996f, -0.07899827f, 
    -0.03247884f, 0.01972232f, 0.09704818f, 0.03903404f, 0.29457003f, 0.10853337f, 0.10717352f, -0.25131249f, 
    -0.18606825f, -0.06279724f, -0.04941196f, -0.28637159f, -0.00806918f, 0.21927349f, -0.08021072f, 0.12619886f, 
    -0.00830593f, -0.16061752f, 0.16910963f, 0.04577621f, -0.19116516f, -0.34532180f, -0.05743980f, 0.04962691f, 
    0.24238831f, 0.05318134f, -0.27653155f, -0.09663784f, -0.14341724f, -0.00226096f, 0.06110371f, 0.03209736f, 
    0.16352940f, -0.09101389f, 0.14700063f, 0.01498820f, -0.05972865f, 0.00791776f, 0.07574669f, -0.07038204f, 
    -0.08943054f, 0.03738031f, -0.11858037f, -0.06967328f, 0.05406655f, 0.03114402f, -0.23763977f, -0.07447208f, 
    -0.05636441f, -0.02321865f, -0.01856305f, -0.00325504f, -0.03544665f, -0.01263118f, 0.07444940f, 0.06375684f, 
    -0.07332228f, -0.08541879f, 0.03513511f, -0.03360355f, -0.07310535f, -0.03834386f, -0.01673463f, -0.01330381f, 
    0.02729769f, -0.27134496f, 0.02035169f, 0.13181876f, 0.32309818f, 0.02145997f, -0.02791824f, -0.12774958f, 
    0.20359454f, 0.13453248f, -0.00035880f, 0.02409277f, -0.07173092f, 0.08036187f, -0.08164440f, 0.03548902f, 
    0.05471777f, 0.00746188f, -0.03737961f, 0.02754608f, -0.19505315f, 0.11881580f, 0.27770045f, 0.35091594f, 
    -0.08398645f, 0.05099776f, 0.02623443f, -0.19598290f, -0.03894706f, -0.03451315f, 0.12295658f, 0.02325509f, 
    0.11504765f, -0.06918243f, -0.00310785f, -0.09396449f, -0.00359161f, 0.15208988f, -0.04376541f, -0.00468212f, 
    0.22499004f, 0.13274246f, 0.18981160f, 0.14477706f, 0.09696114f, 0.04483878f, -0.05684152f, 0.08140942f, 
    0.06157674f, 0.05050163f, 0.03322719f, 0.08396587f, 0.07879581f, 0.03517912f, -0.01023635f, -0.19285171f, 
    -0.16018552f, -0.19810426f, -0.07655337f, -0.01999875f, -0.05202837f, -0.20963930f, 0.19072515f, 0.27725747f, 
    -0.02015134f, -0.18685730f, 0.22614674f, 0.30741456f, -0.06690867f, -0.10619186f, 0.20464227f, 0.23655659f, 
    0.09030908f, 0.06128038f, 0.17424843f, 0.00690005f, 0.07479208f, -0.26400775f, -0.12690234f, 0.07843225f, 
    0.14742744f, -0.16715652f, -0.37137592f, -0.27123725f, -0.27565449f, 0.02589308f, 0.02758124f, -0.12586503f, 
    0.00527568f, 0.16464697f, -0.05485578f, -0.08457737f, -0.02925323f, -0.00125715f, -0.08658855f, 0.11877497f, 
    0.04075650f, 0.08812077f, 0.09308107f, 0.09927189f, 0.01152020f, 0.01781577f, 0.17104718f, 0.16876398f, 
    -0.00983385f, -0.09517146f, 0.10438765f, 0.02650953f, -0.02538043f, -0.00357631f, 0.13292018f, 0.05069857f, 
    0.22270896f, -0.02831994f, 0.04245705f, -0.10454073f, -0.08743719f, -0.01422163f, 0.09308959f, -0.15767208f, 
    -0.05990300f, -0.21274433f, -0.32538605f, -0.07434048f, -0.42425385f, 0.04724824f, 0.08779604f, -0.06403121f, 
    0.10408507f, 0.10685510f, -0.06260662f, -0.19805121f, 0.02434250f, 0.04517880f, -0.03084524f, 0.01836251f, 
    0.04706682f, 0.09005736f, 0.04153934f, 0.26118299f, -0.03123323f, -0.13057916f, -0.39258343f, -0.03297333f, 
    -0.46446145f, -0.05434782f, -0.04373376f, -0.03830542f, 0.01153281f, -0.02402462f, -0.04850652f, -0.16896440f, 
    0.11622807f, 0.03664095f, -0.14850767f, -0.06950609f, -0.03250834f, -0.00753590f, 0.10929365f, -0.00260530f, 
    -0.16127531f, 0.01975595f, 0.30507898f, 0.11084517f, 0.05452530f, -0.07169571f, 0.01231285f, 0.25624841f, 
    0.12548925f, 0.21137899f, 0.08291110f, 0.02883093f, 0.21051838f, -0.09842667f, 0.14398195f, -0.01082790f, 
    0.32291797f, -0.19953419f, 0.42516920f, -0.16326165f, -0.72712654f, -0.09673154f, -0.04632814f, -0.21177368f, 
    0.35488313f, -0.05586641f, 0.09124181f, -0.06170379f, 0.04607889f, 0.07046961f, -0.07835282f, 0.00814228f, 
    0.05768818f, 0.30904979f, 0.00714167f, 0.34338656f, 0.04885961f, -0.00488771f, 0.10437506f, 0.28132197f, 
    0.03610377f, -0.27258763f, 0.03866753f, 0.01298315f, 0.06750184f, 0.04033463f, -0.04923248f, -0.01131381f, 
    0.05921913f, -0.03071597f, -0.04755874f, 0.00746235f, -0.09686968f, -0.16427819f, 0.00856142f, -0.00406342f, 
    -0.10599765f, 0.32072049f, -0.07377033f, -0.28529581f, -0.39002687f, 0.03810079f, -0.29602757f, -0.24026021f, 
    0.05091237f, 0.01109190f, -0.14737031f, 0.02582507f, 0.14617008f, -0.06078270f, -0.08141778f, -0.08819917f, 
    -0.07970549f, 0.08438332f, -0.00395319f, -0.02766406f, -0.05725974f, 0.24556260f, 0.12381543f, 0.05376947f, 
    -0.32570052f, -0.04646633f, 0.28331909f, -0.06928246f, 0.01182736f, -0.00641350f, 0.04781571f, -0.13776717f, 
    0.08692420f, -0.10453958f, 0.05852777f, -0.07930003f, -0.08293888f, -0.07960147f, -0.02827122f, -0.07844201f, 
    0.02171582f, 0.10500415f, -0.02611868f, -0.09330698f, 0.32808444f, 0.14596762f, 0.10396519f, 0.12519254f, 
    0.01691045f, -0.02846069f, -0.03213865f, 0.26228708f, 0.27759913f, -0.12986533f, 0.07864530f, 0.09689392f, 
    -0.09281456f, -0.05663328f, -0.07126841f, 0.11358614f, 0.00527547f, -0.03000221f, -0.12412513f, 0.11590445f, 
    0.36295447f, 0.19423105f, -0.23310637f, -0.24207383f, 0.08924295f, 0.00434585f, 0.03693363f, -0.05153750f, 
    0.10301747f, 0.15826963f, -0.15270495f, -0.10294206f, -0.04543458f, -0.05197556f, -0.07182978f, -0.14111027f, 
    -0.11395205f, 0.07641611f, 0.14545305f, 0.08373551f, -0.41246280f, 0.37686363f, -0.04371331f, 0.39672688f, 
    0.00708869f, -0.05965286f, -0.10490401f, -0.24411722f, -0.10255715f, -0.04248770f, -0.06561524f, 0.04559812f, 
    -0.19671965f, 0.08419245f, 0.09580591f, -0.01517549f, -0.16064660f, 0.16667019f, -0.13821891f, 0.03835525f, 
    0.13896857f, -0.15448326f, -0.22855625f, -0.23773141f, -0.07297935f, 0.10703573f, 0.03569989f, -0.02293749f, 
    0.06997221f, 0.17318401f, -0.03502225f, -0.09437399f, -0.01363643f, 0.01993155f, -0.06788745f, -0.03499315f, 
    0.12878312f, 0.01687412f, 0.12387119f, 0.01409675f, 0.11200736f, 0.06692473f, 0.05386016f, 0.16044323f, 
    0.19956829f, -0.06394389f, 0.06595632f, 0.20382652f, -0.08109356f, -0.02364996f, 0.13622776f, 0.08134806f, 
    0.09510231f, -0.00547773f, -0.08768858f, 0.01563980f, -0.01265636f, 0.03446412f, -0.04884867f, -0.12523736f, 
    -0.05184310f, 0.04007823f, -0.10500485f, 0.02926729f, -0.51750916f, 0.02820953f, -0.06905197f, -0.04371849f, 
    -0.09381382f, 0.03407187f, -0.09270133f, -0.04507203f, 0.17171161f, -0.03286138f, -0.03960343f, -0.06021630f, 
    -0.03521051f, 0.03219123f, 0.12736022f, -0.03489728f, 0.16515739f, 0.01503239f, 0.13632788f, 0.05101884f, 
    -0.02487237f, 0.00975516f, -0.04821201f, 0.02133150f, 0.01948277f, 0.02887489f, -0.01154437f, 0.07256967f, 
    -0.05596239f, -0.08261465f, 0.04805150f, -0.23499897f, -0.11153417f, -0.11879202f, -0.16447975f, -0.05445055f, 
    0.37075591f, 0.09790958f, -0.02383167f, 0.12216283f, 0.09078759f, -0.14989519f, -0.05543359f, 0.01818088f, 
    0.04891695f, 0.00757795f, -0.02368794f, 0.17731191f, 0.23394805f, 0.08874106f, 0.07236435f, 0.24646637f, 
    0.14158249f, 0.05416159f, 0.01565322f, 0.07367883f, 0.09920175f, 0.09778546f, 0.15807113f, 0.11782031f, 
    0.06940048f, -0.02609020f, 0.02059566f, 0.13538957f, 0.05574961f, -0.02079426f, -0.03832028f, 0.16760312f, 
    0.09896258f, 0.17719311f, 0.09006538f, -0.03188711f, -0.17792378f, -0.06837171f, -0.23500828f, -0.07674942f, 
    0.06903180f, 0.10238820f, -0.31919548f, 0.18320380f, 0.10382650f, -0.22000331f, -0.02672352f, -0.17841743f, 
    0.01997852f, 0.14790565f, -0.01418383f, -0.04202102f, -0.03869736f, -0.08497674f, -0.04500706f, -0.05329502f, 
    -0.09346026f, 0.22651510f, 0.04844914f, -0.08948969f, 0.11333452f, -0.01727320f, -0.28349233f, 0.02016950f, 
    -0.21961245f, -0.11936310f, -0.09675568f, 0.04489176f, -0.00429591f, 0.02640182f, -0.11653210f, -0.00259852f, 
    0.05010375f, -0.01070749f, -0.17543763f, -0.11846155f, -0.09941483f, -0.00376374f, -0.09759308f, 0.03994672f, 
    0.49499378f, 0.09549960f, 0.13017099f, 0.08014209f, -0.01564381f, -0.15483117f, 0.07848219f, 0.07148864f, 
    -0.01653161f, 0.04062904f, -0.08453486f, -0.01657690f, -0.02162562f, 0.05792625f, 0.07613052f, 0.04679655f, 
    0.08932196f, -0.01337802f, -0.09767142f, 0.03757072f, 0.39472514f, 0.09711548f, 0.02006520f, -0.10044651f, 
    0.04122952f, -0.11582743f, -0.10956720f, 0.30235758f, -0.05827619f, 0.01270955f, -0.11194945f, -0.11424781f, 
    -0.00568372f, 0.05025332f, -0.02330241f, 0.11911918f, 0.24802314f, -0.11649670f, 0.06061250f, 0.14840445f, 
    0.52727616f, 0.06667894f, 0.02966668f, 0.10542281f, -0.01821352f, -0.03800620f, -0.01633498f, 0.10717686f, 
    0.05054815f, 0.03126205f, -0.05803741f, -0.02110843f, 0.01645963f, -0.03020408f, 0.01507836f, 0.03470269f, 
    0.04401943f, -0.20663160f, -0.02533350f, 0.06677743f, -0.11024717f, -0.18122210f, 0.14891365f, -0.03141474f, 
    0.01411044f, 0.00112731f, 0.07892957f, 0.04925255f, 0.11296134f, 0.03071484f, -0.02986579f, -0.10143299f, 
    -0.03955327f, 0.00170859f, 0.11412998f, -0.06560508f, -0.11589471f, -0.15702461f, -0.07395798f, -0.13105971f, 
    -0.21474051f, 0.07715971f, 0.25858942f, 0.00984687f, -0.23483770f, 0.04722651f, -0.13654971f, 0.06287444f, 
    0.04600757f, -0.02394896f, 0.02320611f, 0.10366768f, -0.02017125f, -0.04982716f, -0.00998300f, -0.08339769f, 
    -0.09209643f, -0.01976853f, 0.08655094f, -0.15564071f, -0.16355965f, 0.10857146f, 0.13426472f, 0.09481711f, 
    0.11365752f, -0.02950700f, 0.14597620f, 0.12385175f, 0.04365198f, -0.18579888f, 0.06516232f, 0.08369104f, 
    0.07189493f, 0.07508630f, -0.14633077f, 0.13020840f, 0.03864554f, -0.04194615f, 0.20099404f, -0.02576995f, 
    -0.15248308f, 0.25008425f, 0.03972238f, -0.13348442f, -0.33487210f, 0.04447732f, -0.05769671f, 0.01179750f, 
    -0.07324979f, -0.00350890f, -0.17439826f, -0.17152321f, -0.03444839f, 0.09490664f, -0.07433829f, -0.07927445f, 
    -0.06986195f, -0.17675678f, -0.00855474f, -0.04461171f, -0.07517780f, 0.16269068f, -0.00205966f, 0.02975948f, 
    -0.10409330f, 0.04806602f, -0.05541550f, 0.03344125f, -0.05169906f, -0.06982889f, -0.09538882f, -0.04362445f, 
    -0.00744779f, 0.10388226f, -0.02210784f, -0.11970322f, -0.12287497f, -0.12955129f, -0.13639259f, -0.09041625f, 
    0.25314617f, 0.10602494f, 0.08127565f, -0.27293512f, -0.22673704f, -0.07951155f, 0.04781523f, -0.06034649f, 
    -0.00581192f, 0.23689438f, -0.07679163f, -0.04419331f, -0.00626475f, -0.17373769f, -0.00482696f, -0.07684537f, 
    0.00876235f, 0.06447516f, 0.01136078f, -0.07841116f, 0.49505022f, 0.15444937f, 0.11476229f, -0.08591694f, 
    -0.03302400f, -0.08573920f, -0.11305621f, 0.08189592f, 0.01268849f, -0.02738937f, -0.06106788f, -0.02915426f, 
    -0.07601900f, -0.00226473f, 0.01757446f, 0.07604361f, 0.23483098f, -0.05475791f, 0.02599634f, 0.10658441f, 
    -0.02141101f, 0.03341362f, 0.02535578f, 0.02456891f, -0.02126087f, 0.01513242f, -0.03482308f, -0.02739036f, 
    0.03803037f, -0.02154066f, 0.00767458f, -0.04444468f, -0.03463348f, -0.04848133f, -0.02311255f, -0.02679045f, 
    0.00587996f, -0.01360261f, 0.00549409f, 0.02312730f, 0.03237966f, 0.02083188f, 0.02502808f, 0.00707987f, 
    -0.03427318f, -0.04303049f, 0.01527840f, -0.00881000f, -0.01227114f, -0.02479617f, 0.02283602f, 0.00247702f, 
    0.02880288f, 0.02462586f, 0.00764598f, 0.02716797f, -0.03176647f, -0.01363689f, -0.03117904f, -0.04075586f, 
    0.00425619f, -0.00673028f, -0.02912864f, 0.02597990f, 0.02244477f, -0.03894105f, -0.03012735f, 0.00320287f, 
    -0.02883131f, -0.02703886f, 0.00217834f, -0.03702864f, 0.00207721f, -0.02329736f, 0.00105342f, -0.03255097f, 
    -0.02978159f, -0.03029791f, -0.00471306f, 0.00655841f, -0.02154322f, -0.02111930f, -0.02805997f, -0.00588228f, 
    0.02580759f, -0.03964085f, 0.00856466f, 0.00507893f, -0.03833446f, -0.01850698f, -0.03916585f, 0.01490411f, 
    -0.02184172f, 0.02591864f, -0.00558392f, 0.01038475f, 0.00765406f, -0.01754739f, 0.00916294f, -0.04157414f, 
    0.01704747f, 0.02895761f, 0.00616284f, -0.01670799f, -0.00601067f, -0.01338463f, -0.00778718f, 0.02539027f, 
    -0.00817681f, 0.00926133f, 0.01173627f, -0.03125055f, -0.01227955f, -0.02598536f, 0.03360571f, -0.02022077f, 
    -0.01531178f, -0.03734494f, 0.03295118f, -0.03694256f, -0.02916991f, 0.00294493f, -0.02620826f, 0.01687224f, 
    -0.02039477f, -0.03376769f, 0.02394210f, -0.03026867f, 0.00904477f, 0.00207987f, -0.03302450f, 0.00969493f, 
    -0.00808932f, -0.00682617f, 0.00806974f, -0.03501543f, 0.02301688f, -0.01064243f, -0.03990673f, -0.00750889f, 
    0.02271107f, -0.03582304f, 0.00136338f, 0.01017041f, -0.02163189f, -0.04631272f, -0.04259951f, -0.03911668f, 
    -0.03763023f, -0.03867003f, 0.00340248f, -0.03546311f, -0.03235641f, -0.02687354f, -0.01535096f, 0.02870052f, 
    0.01926236f, 0.00959189f, 0.01975257f, 0.02002290f, -0.04321352f, -0.02834023f, 0.00513342f, -0.00408579f, 
    0.00099633f, -0.03364622f, 0.00360472f, 0.01104144f, -0.03280439f, -0.03299062f, -0.03052202f, -0.01709723f, 
    -0.00491727f, 0.00286859f, -0.02562101f, 0.01651847f, -0.02372400f, -0.01412017f, 0.02091645f, -0.00434113f, 
    -0.00531403f, -0.01783551f, 0.01212963f, -0.00494282f, -0.03862022f, 0.01001075f, -0.01871835f, 0.00323691f, 
    -0.04736989f, -0.00318463f, -0.03756463f, 0.02294582f, 0.03338686f, 0.00174554f, -0.02654181f, -0.01766430f, 
    -0.02693063f, -0.02756972f, 0.01936847f, -0.00256526f, -0.00052384f, 0.00699987f, 0.01508030f, -0.00509834f, 
    -0.01358917f, 0.02548284f, -0.01975574f, -0.02101815f, 0.00211353f, 0.00335897f, 0.02242729f, -0.00092940f, 
    0.02877905f, 0.00198016f, -0.04511782f, -0.04505335f, 0.00859956f, -0.01371338f, -0.00009348f, 0.00552713f, 
    0.00537340f, 0.02178891f, -0.03953858f, 0.02532869f, 0.02798277f, -0.01137880f, 0.02755463f, 0.02922509f, 
    -0.01477514f, 0.02213552f, -0.02611759f, -0.02013360f, 0.01181808f, -0.03384450f, 0.01843710f, -0.01010519f, 
    0.00320944f, 0.03474550f, -0.00366692f, 0.02277812f, -0.00536230f, -0.00593692f, -0.03157810f, 0.03219355f, 
    -0.00605378f, -0.00499110f, -0.01252594f, 0.01177804f, -0.02783501f, 0.01257311f, 0.01304474f, -0.03482198f, 
    0.01457185f, 0.00550997f, -0.00289535f, -0.02418065f, -0.02071092f, 0.02555423f, -0.00704392f, -0.00845822f, 
    0.01837723f, -0.01413871f, 0.00854363f, 0.00475595f, -0.01663337f, -0.00643609f, 0.02962443f, -0.02068115f, 
    -0.01192278f, 0.02611474f, -0.01702005f, 0.00568230f, 0.03232686f, -0.01131906f, -0.00776932f, -0.03043380f, 
    -0.01847601f, 0.00536008f, 0.02467335f, -0.01697160f, 0.03181870f, 0.04516503f, -0.04401249f, 0.01668443f, 
    -0.00729031f, -0.04173924f, -0.01743626f, 0.01070103f, 0.03462103f, 0.00931505f, 0.03138499f, -0.03609280f, 
    -0.04083624f, -0.01454725f, -0.02160156f, -0.03536506f, -0.03596603f, -0.01129507f, 0.02871926f, 0.01432031f, 
    -0.03741742f, -0.02232528f, -0.02374243f, 0.00997536f, -0.00275303f, -0.01142773f, 0.01485207f, 0.02120041f, 
    0.01510226f, -0.04655121f, -0.03929918f, -0.01947907f, -0.02322224f, -0.02150873f, 0.00529068f, -0.03550899f, 
    -0.02959692f, 0.01972860f, 0.02690929f, -0.03796121f, -0.02106899f, -0.00765570f, -0.00914315f, 0.02872863f, 
    0.00685603f, -0.01513352f, 0.00409684f, 0.01391335f, -0.02244678f, 0.03408815f, -0.00985409f, -0.01921119f, 
    -0.01075346f, -0.02301987f, 0.03455262f, -0.00058920f, 0.01625447f, 0.00964020f, -0.01965869f, -0.01186631f, 
    0.02808757f, -0.02597786f, -0.02148969f, 0.01042531f, -0.02241294f, 0.01053101f, -0.00616945f, -0.02002428f, 
    0.00631550f, 0.00878092f, -0.01617112f, -0.04020826f, -0.00200074f, -0.04320573f, -0.00155295f, 0.02928459f, 
    0.02877219f, 0.01063699f, -0.01241489f, -0.03633378f, -0.02056238f, -0.02427615f, -0.00321594f, -0.02621515f, 
    0.02396642f, -0.04076727f, -0.02014720f, -0.00620729f, -0.01514647f, -0.02506175f, 0.02016678f, -0.02626838f, 
    -0.01595056f, -0.01845780f, 0.01806966f, -0.00332169f, -0.02701271f, 0.01753151f, -0.02576375f, 0.00769362f, 
    0.02286552f, -0.03118933f, -0.01133917f, -0.04859984f, -0.03448704f, 0.03098832f, -0.02368450f, 0.01567861f, 
    0.01979737f, -0.00950956f, -0.04331561f, 0.03282173f, -0.04444040f, -0.01163848f, 0.03402527f, 0.00842542f, 
    -0.01735706f, 0.00372981f, -0.02843943f, -0.00472958f, -0.01004032f, -0.03171977f, -0.01626379f, -0.01658838f, 
    0.02509637f, 0.01804861f, -0.02764948f, -0.02506659f, -0.03100130f, 0.01137445f, 0.01038923f, -0.01242377f, 
    0.01309027f, 0.02154735f, -0.01176648f, 0.02854591f, -0.00193095f, 0.00133818f, -0.00831381f, 0.02435035f, 
    -0.01126077f, 0.02811012f, 0.00588395f, -0.01387954f, -0.00956301f, -0.01401588f, 0.01741429f, -0.01226443f, 
    -0.00864637f, 0.01899373f, -0.02989072f, -0.03304520f, -0.01706797f, -0.04080435f, 0.01709434f, -0.03692006f, 
    0.00073327f, -0.02892257f, -0.04248553f, -0.03921069f, -0.02070243f, 0.03011116f, 0.00871485f, -0.03419690f, 
    0.00484874f, -0.01039097f, 0.02518340f, 0.02017630f, -0.03581661f, 0.00807494f, -0.01792626f, -0.02764376f, 
    0.00260544f, -0.01157457f, 0.00962194f, 0.02065158f, -0.00063988f, 0.00212326f, 0.02778111f, 0.01183379f, 
    -0.00743385f, 0.03109182f, -0.02859288f, 0.00743270f, -0.04202468f, 0.02942072f, 0.00628502f, -0.00007704f, 
    0.01783955f, -0.01954990f, -0.00231292f, 0.00793755f, -0.01572042f, -0.00611079f, 0.02277393f, -0.02038672f, 
    -0.04831348f, -0.04949489f, -0.04042799f, 0.01165670f, -0.04834055f, -0.02625225f, 0.00206139f, 0.00815589f, 
    0.02691352f, -0.03541559f, -0.02284136f, 0.00571839f, -0.03453520f, 0.01270743f, -0.00466176f, 0.02633729f, 
    -0.00573447f, 0.01658210f, -0.02938612f, -0.02470281f, -0.02079912f, 0.00953924f, 0.00035147f, -0.00274645f, 
    -0.02761001f, -0.01930735f, -0.02436365f, -0.00179173f, 0.00155657f, 0.01096428f, -0.03628702f, 0.03050927f, 
    -0.02505670f, 0.03747766f, -0.02094203f, -0.00576689f, -0.00932231f, -0.00517546f, -0.04209795f, 0.03107980f, 
    0.01511910f, 0.00028367f, -0.02293600f, 0.01449975f, 0.02849608f, -0.02463079f, 0.03769026f, 0.01235418f, 
    0.01602347f, 0.02071550f, 0.01484203f, -0.00589560f, 0.02349696f, -0.00269205f, 0.01357233f, 0.01449081f, 
    -0.03568714f, -0.00152273f, 0.03888519f, 0.01458934f, -0.01886972f, 0.03169905f, -0.03562742f, -0.00883098f, 
    0.00268881f, -0.01587668f, 0.01077505f, -0.04667021f, 0.00991409f, -0.04062217f, 0.01497719f, 0.03120865f, 
    -0.03183952f, -0.02670159f, -0.04129587f, -0.03727981f, -0.04204591f, 0.02244087f, -0.00397430f, 0.00825351f, 
    0.02067899f, 0.02057698f, -0.03656386f, 0.03407476f, -0.02250455f, 0.01678001f, 0.02718355f, -0.00883968f, 
    -0.03728811f, -0.00581757f, 0.00598600f, 0.00476177f, -0.04016925f, -0.03598623f, -0.02457907f, -0.02366366f, 
    -0.01633704f, -0.03962348f, -0.04283579f, 0.01958246f, -0.00831414f, 0.00904634f, 0.00310392f, -0.01867095f, 
    -0.03046983f, 0.03872284f, 0.00599607f, -0.03856195f, 0.03277159f, -0.03711883f, -0.03281176f, 0.03075634f, 
    -0.04195510f, 0.00971397f, -0.00804341f, 0.00386053f, 0.00367803f, 0.02894717f, 0.00628079f, 0.01863519f, 
    -0.02140510f, 0.02238106f, -0.00635780f, -0.01118350f, -0.00553082f, -0.03729286f, 0.03247324f, 0.00823743f, 
    0.00423854f, -0.02954618f, -0.02631381f, -0.03835985f, -0.04262787f, -0.00413491f, -0.02920342f, -0.00945450f, 
    0.00691034f, -0.01654815f, -0.01417957f, -0.03421388f, -0.01703439f, 0.00037688f, 0.01496929f, 0.01216441f, 
    -0.03767598f, -0.03581559f, 0.02533815f, -0.02880948f, 0.00966397f, -0.04730593f, -0.03039498f, 0.00160796f, 
    0.01648266f, 0.02617850f, 0.00135262f, 0.03310698f, 0.01775043f, -0.00272825f, -0.02627845f, -0.01388572f, 
    -0.02518544f, 0.00874243f, -0.01219046f, -0.00150728f, 0.02203417f, -0.03401439f, 0.02573861f, 0.01119966f, 
    -0.01031692f, -0.02557641f, 0.00512059f, 0.02060199f, -0.02649224f, -0.01192599f, -0.04104900f, -0.03819694f, 
    -0.03177668f, -0.05019013f, 0.00555593f, -0.04587863f, -0.03311336f, -0.03942280f, -0.04255742f, 0.01173031f, 
    0.00567492f, 0.01475837f, -0.01580431f, 0.00331801f, 0.01559715f, 0.02325432f, -0.00177888f, -0.02932699f, 
    -0.01836520f, -0.01837080f, 0.02440407f, -0.00932887f, 0.01568845f, 0.03045737f, -0.01734593f, 0.02441672f, 
    -0.00318985f, 0.00661171f, 0.02658453f, -0.04015805f, -0.01256315f, -0.03317940f, -0.03540708f, 0.03124422f, 
    0.00253820f, 0.02920649f, -0.00855649f, -0.01636359f, -0.00481379f, 0.02828583f, 0.02655723f, 0.00184886f, 
    -0.00791024f, 0.01388838f, -0.03689020f, 0.00437686f, -0.00813384f, 0.01535753f, 0.04026806f, 0.00138410f, 
    -0.03856765f, 0.00118604f, -0.02172994f, -0.03599505f, -0.02487642f, 0.02674736f, -0.01596976f, -0.03741460f, 
    -0.00115412f, -0.02191679f, -0.01767332f, -0.02108767f, -0.00895017f, 0.00846713f, -0.02748564f, -0.01165911f, 
    -0.03213291f, -0.02906676f, 0.01019613f, 0.01530922f, -0.00899017f, -0.02725997f, 0.02666869f, -0.04259831f, 
    0.01122151f, -0.01518556f, 0.01978029f, -0.02264855f, -0.00885484f, 0.00737322f, 0.02830196f, 0.00664990f, 
    -0.02057790f, 0.02198314f, 0.01360546f, 0.02129733f, -0.01044613f, -0.00025460f, 0.02545962f, -0.01886966f, 
    0.00466516f, -0.00867509f, 0.03381237f, -0.01635668f, -0.03006417f, 0.03304122f, -0.00106704f, -0.01311096f, 
    0.03025356f, 0.03326976f, -0.04686215f, -0.04420410f, -0.01254303f, 0.00838881f, -0.02278008f, -0.04196366f, 
    0.02447671f, -0.00971714f, -0.04027264f, -0.01090319f, 0.00389999f, 0.01443875f, -0.03314615f, -0.00024687f, 
    0.01173673f, 0.01730237f, 0.01893971f, 0.00635948f, -0.01935558f, 0.00891004f, -0.00154205f, 0.00341581f, 
    0.00979341f, 0.02153668f, 0.02037255f, 0.00244103f, -0.00774494f, -0.00322241f, -0.02559959f, 0.00754842f, 
    -0.00845302f, 0.02175436f, -0.03477163f, -0.03349709f, 0.00615276f, -0.00493874f, -0.03310101f, -0.02394212f, 
    -0.02592513f, -0.00756135f, 0.00305377f, 0.00773247f, 0.00278795f, 0.00925049f, -0.02855291f, 0.02940731f, 
    -0.03184300f, -0.04264207f, -0.03119667f, 0.01232241f, -0.02547018f, 0.00099788f, 0.00751969f, -0.02505628f, 
    -0.00550670f, -0.03441804f, 0.01683510f, -0.04029266f, 0.01591708f, 0.02837076f, 0.00708743f, -0.04520800f, 
    0.00659407f, -0.03698542f, -0.02290228f, -0.00490441f, -0.00308143f, -0.00079123f, -0.04119317f, -0.01101723f, 
    -0.03919637f, -0.04520924f, 0.00660307f, -0.02349947f, -0.01874501f, -0.01846774f, 0.02912151f, -0.00295285f, 
    -0.03722567f, -0.01174219f, 0.02204894f, 0.02323920f, 0.00191466f, 0.01678025f, -0.02612043f, 0.03054551f, 
    -0.02729122f, -0.03687720f, 0.00408564f, -0.01200941f, -0.03525463f, -0.04498133f, 0.00762822f, -0.02582503f, 
    0.02631156f, 0.01146497f, 0.00334278f, 0.01656401f, 0.02607175f, -0.00694203f, 0.00777230f, -0.01857368f, 
    -0.01849517f, -0.02012932f, 0.02758412f, 0.01543097f, -0.00274626f, -0.00801357f, -0.01311467f, -0.00545676f, 
    0.01363013f, 0.01466385f, 0.01323572f, 0.02993888f, -0.01162162f, 0.01751831f, 0.03114822f, 0.02385541f, 
    0.03491611f, -0.00992507f, -0.00702948f, -0.00473533f, -0.03401618f, -0.01862812f, -0.00862498f, 0.00768673f, 
    -0.02642054f, 0.03006638f, 0.00110579f, -0.01553550f, -0.04053830f, -0.02602650f, 0.01246476f, -0.03496755f, 
    0.01738873f, -0.01348848f, -0.02747475f, 0.01544754f, 0.02266270f, -0.02234252f, -0.02891535f, 0.00100588f, 
    0.00327397f, 0.00974184f, -0.00612997f, -0.01756945f, -0.02173506f, -0.00969043f, 0.00921272f, -0.03569249f, 
    -0.00975281f, -0.01284633f, 0.01851359f, -0.03350493f, -0.00208163f, -0.00757051f, 0.02938956f, 0.00272103f, 
    0.02958867f, -0.03415610f, -0.03520419f, 0.01878427f, -0.01587777f, -0.02108220f, -0.03308512f, -0.01238481f, 
    0.02469731f, -0.04229710f, 0.00707050f, 0.01948435f, 0.01805343f, 0.02439250f, 0.02681538f, 0.01140225f, 
    -0.03519863f, 0.00972305f, -0.00409980f, -0.00149693f, -0.02217299f, -0.02242215f, 0.01052190f, -0.01862189f, 
    -0.03948458f, -0.04229302f, -0.02886405f, 0.02230002f, -0.02852592f, -0.02364384f, -0.00818149f, -0.04159150f, 
    -0.00298910f, 0.02534331f, 0.02275375f, -0.03418088f, -0.02467233f, -0.00825345f, 0.01234227f, 0.00786249f, 
    -0.03744095f, 0.00290281f, -0.03995021f, 0.00612454f, 0.01172745f, -0.03696572f, 0.02384119f, 0.00077582f, 
    -0.01679114f, 0.00852785f, -0.02592346f, -0.03125446f, 0.00155193f, -0.02836754f, -0.02455518f, 0.01969826f, 
    -0.01549627f, -0.02049821f, 0.02682764f, -0.02179924f, 0.00796851f, -0.01259242f, 0.02605416f, 0.00966864f, 
    0.02734589f, -0.01216172f, 0.03097061f, -0.03053129f, 0.03203153f, -0.03586370f, 0.03310116f, 0.00480117f, 
    -0.01836961f, 0.02198851f, -0.01152305f, 0.01124769f, 0.02165187f, -0.02423546f, 0.02567992f, -0.04131246f, 
    -0.00454568f, -0.00796193f, 0.02919924f, -0.02322921f, -0.03359150f, 0.00450153f, -0.01667354f, -0.04358431f, 
    -0.01866417f, 0.00073868f, -0.02300201f, -0.01394110f, 0.00788828f, -0.03623708f, 0.02579577f, 0.01418266f, 
    0.02745671f, -0.00186592f, -0.01763947f, 0.01275173f, 0.01764257f, 0.02313250f, -0.02927150f, -0.03658377f, 
    -0.03492255f, 0.01392120f, -0.03693916f, -0.02787567f, 0.01354036f, -0.02282921f, 0.01281748f, -0.03388764f, 
    -0.03584887f, 0.02444617f, 0.03095628f, 0.00520884f, -0.00921667f, 0.00167492f, -0.04381217f, 0.03238971f, 
    -0.01282565f, -0.02424981f, -0.00724221f, -0.02846612f, -0.02000731f, -0.00249299f, 0.02464798f, 0.03213493f, 
    -0.02516950f, -0.02698603f, -0.03066660f, -0.01334832f, 0.01782209f, -0.03235958f, 0.00009168f, -0.00905859f, 
    -0.01991072f, 0.01316465f, -0.01987967f, -0.00810986f, -0.01304551f, 0.00874863f, -0.04230767f, 0.01743340f, 
    0.00074747f, -0.01543249f, 0.02343983f, 0.01433281f, -0.03147880f, -0.00117851f, -0.02103377f, 0.02171661f, 
    0.02688129f, -0.03429314f, -0.03662159f, -0.00215942f, -0.00494594f, 0.01384219f, 0.00986057f, -0.04468763f, 
    -0.02023185f, -0.04165797f, -0.00755493f, 0.00641085f, 0.02651506f, 0.02875794f, -0.00910976f, 0.00175760f, 
    -0.04035485f, 0.02593717f, -0.03739028f, 0.02827822f, 0.02801570f, 0.01311887f, 0.02103302f, 0.01193621f, 
    0.00280237f, 0.00466928f, -0.02053537f, 0.00812794f, -0.00233912f, 0.02160695f, -0.00954059f, -0.04490335f, 
    0.03295245f, -0.00819403f, 0.03309431f, 0.03237061f, -0.03265715f, 0.00326374f, 0.02812169f, -0.00493132f, 
    -0.01956252f, -0.03090736f, -0.00086444f, 0.01241967f, -0.02134566f, -0.01045875f, 0.01307701f, -0.01003546f, 
    -0.01745971f, -0.01562709f, 0.02977766f, -0.04197607f, 0.01018888f, -0.00839287f, 0.01305458f, 0.01184683f, 
    -0.00819500f, -0.00261815f, -0.02489406f, 0.02165647f, -0.02276577f, 0.02202766f, -0.00605789f, 0.01910612f, 
    -0.02979815f, -0.02020085f, 0.00809105f, -0.03736631f, -0.03500386f, -0.03155708f, 0.02016470f, 0.01320154f, 
    0.02789563f, 0.00619636f, 0.01597859f, 0.00277566f, -0.02374852f, -0.04013669f, 0.03005619f, 0.00518151f, 
    0.01421742f, 0.02396351f, -0.03713458f, -0.03353358f, 0.01948409f, -0.03915898f, -0.03063848f, 0.01925870f, 
    0.00161674f, -0.02119356f, -0.04033217f, -0.04546553f, -0.01259954f, 0.02851360f, -0.00349282f, -0.02003066f, 
    -0.00672767f, -0.02593237f, 0.01623520f, 0.02604721f, 0.03190324f, 0.02214991f, 0.00645331f, -0.01323387f, 
    -0.00297472f, 0.02187569f, 0.01551028f, -0.00768840f, 0.01217615f, -0.01040104f, -0.02830870f, 0.02862720f, 
    -0.00345044f, 0.02724506f, 0.01344815f, -0.04475336f, -0.02050749f, 0.02892297f, -0.01925054f, -0.02553870f, 
    -0.03969481f, -0.00868572f, 0.01002313f, 0.00367649f, 0.01544111f, -0.01498630f, 0.00891235f, -0.00725486f, 
    -0.02789055f, -0.00311554f, 0.03109130f, -0.02370762f, 0.01828410f, 0.01361709f, 0.00556610f, -0.02241436f, 
    0.01531851f, -0.03011934f, 0.00373875f, -0.01899194f, -0.03655218f, 0.01358162f, -0.03409110f, -0.01368107f, 
    -0.02810010f, 0.02517174f, 0.01550726f, -0.01099003f, 0.03359051f, 0.01879368f, -0.01080655f, 0.00013991f, 
    0.02859185f, -0.02948338f, -0.03667856f, -0.00888615f, 0.02094344f, -0.04463949f, 0.03250586f, -0.00162562f, 
    -0.00565542f, -0.02783161f, 0.02358377f, -0.03478730f, -0.02026729f, -0.03412815f, -0.03551418f, 0.01379841f, 
    -0.03700879f, -0.04082716f, 0.00461824f, -0.03432614f, 0.01626216f, 0.00365023f, 0.01591355f, -0.03857379f, 
    -0.01389945f, -0.02986013f, -0.04149131f, -0.04882013f, -0.01251070f, -0.02095914f, -0.00341733f, -0.01276932f, 
    -0.02190166f, 0.01720330f, -0.01742905f, -0.01884830f, -0.01173283f, 0.00404382f, -0.00090308f, 0.00361156f, 
    -0.04451056f, -0.04449588f, -0.00511994f, -0.04020082f, 0.00045306f, 0.01740857f, -0.01327753f, -0.02826455f, 
    0.00448404f, 0.01035765f, -0.03385345f, -0.01129816f, -0.00006493f, -0.01524481f, 0.00621147f, -0.02768981f, 
    0.02914421f, -0.03314891f, -0.00406812f, -0.03985185f, -0.00571281f, 0.01547120f, -0.04097079f, -0.02724324f, 
    -0.02989693f, 0.01543918f, -0.00739619f, -0.02589859f, -0.03079757f, 0.02868210f, -0.00802084f, -0.00747461f, 
    0.01286381f, -0.01581081f, -0.00486371f, 0.02583104f, -0.02040236f, 0.03158930f, -0.01585061f, -0.03885722f, 
    -0.02200655f, -0.00708084f, -0.03247928f, 0.02361776f, 0.02012524f, 0.02473113f, 0.00041502f, -0.02990507f, 
    -0.16572917f, -0.08584373f, -0.19870958f, 0.04093331f, -0.07630464f, 0.06458811f, 0.06577103f, 0.06331135f, 
    0.00603627f, -0.01093498f, 0.00114105f, 0.15010278f, 0.07424658f, 0.15395398f, 0.14551765f, 0.03273714f, 
    0.12341151f, -0.03482201f, 0.00802686f, 0.10960929f, -0.32335958f, -0.21306436f, -0.05670968f, -0.39406538f, 
    0.08331420f, -0.19555791f, -0.06438385f, 0.01807311f, -0.08964390f, -0.17289759f, -0.05444698f, 0.10637047f, 
    -0.02004087f, -0.02848358f, 0.05269277f, 0.03149521f, -0.13650027f, 0.21952455f, -0.15471500f, -0.23989095f, 
    0.37135500f, 0.24237466f, 0.13845567f, -0.08354423f, 0.08916326f, 0.07708846f, 0.11176572f, 0.14228159f, 
    0.13613288f, 0.02277053f, -0.02027469f, -0.04278390f, -0.08036492f, -0.07903273f, 0.08327750f, 0.00404294f, 
    -0.03677141f, 0.11865707f, -0.00521604f, -0.10679007f, -0.23250680f, -0.03261990f, -0.18559013f, -0.02333708f, 
    0.00461821f, -0.11119216f, 0.10120317f, 0.07883961f, 0.00417374f, 0.05868139f, -0.10079150f, 0.02530626f, 
    -0.00855357f, 0.06576263f, -0.02135430f, -0.04813905f, -0.00648380f, 0.04707638f, 0.06762771f, 0.06503747f, 
    0.32121652f, 0.14550951f, 0.00544635f, -0.07020764f, 0.02581165f, -0.00080554f, -0.01966835f, 0.08548632f, 
    -0.09215249f, 0.07139656f, -0.00104601f, -0.12389820f, 0.03526313f, 0.06007503f, 0.01823564f, 0.08359258f, 
    -0.05483083f, -0.10238613f, -0.02915170f, -0.02052581f, 0.30504033f, 0.17194614f, -0.14684308f, -0.05427521f, 
    0.06306143f, 0.23123372f, 0.14018749f, 0.18740615f, 0.05861598f, 0.15002781f, -0.03817391f, -0.09159006f, 
    -0.17548573f, -0.04148683f, -0.14246236f, -0.01412278f, 0.05422170f, -0.03368954f, 0.01083313f, 0.01144174f, 
    -0.34848902f, -0.14779493f, 0.15391979f, -0.28956643f, -0.00947039f, 0.01155583f, -0.01667897f, 0.21871340f, 
    0.04913204f, -0.08376712f, 0.09439987f, 0.07237031f, -0.04691223f, -0.11057236f, 0.04709351f, 0.09883528f, 
    -0.10165641f, 0.08579426f, 0.06946465f, 0.02483441f, -0.04434793f, 0.27130753f, 0.08110895f, 0.14238286f, 
    -0.01493216f, 0.03021572f, 0.03404370f, -0.06793341f, -0.08744732f, -0.06945682f, -0.01538339f, -0.06686815f, 
    0.01063170f, 0.02629606f, 0.13007003f, 0.04163731f, 0.00794444f, -0.20330106f, -0.14279430f, -0.13307698f, 
    0.25791427f, 0.30778882f, 0.08452567f, -0.15129399f, 0.11344977f, -0.10106926f, 0.02474096f, 0.08667056f, 
    0.06107479f, -0.01837276f, 0.08914690f, -0.04271541f, 0.10667668f, -0.03662523f, 0.00838318f, -0.04128591f, 
    -0.01502161f, 0.13069500f, 0.04815311f, 0.01228756f, 0.04116070f, 0.05658865f, 0.08621790f, -0.08699028f, 
    -0.02960296f, 0.05493566f, -0.16178599f, 0.05904223f, -0.10875694f, 0.08549304f, -0.02816517f, 0.00456433f, 
    0.02105278f, -0.09211173f, -0.07377075f, -0.04000983f, -0.11167175f, 0.03601185f, 0.04235541f, 0.07048039f, 
    0.19225544f, 0.27503121f, -0.02932228f, -0.03668657f, 0.12315405f, 0.01659297f, 0.01445443f, -0.05796892f, 
    0.05011046f, 0.02962891f, 0.08957759f, -0.21798342f, -0.02694776f, 0.02812172f, -0.08523154f, -0.01157181f, 
    0.01510762f, 0.12863830f, 0.08071215f, 0.09241764f, -0.09218971f, 0.24561472f, -0.21284275f, -0.03690439f, 
    -0.20842324f, -0.14512503f, -0.30735242f, 0.28758791f, -0.05755771f, 0.04325970f, -0.06348669f, 0.12401727f, 
    0.01152119f, 0.02232764f, 0.03081968f, -0.02866193f, -0.08769301f, 0.03249296f, -0.05592947f, -0.01445605f, 
    0.24715060f, 0.20918208f, 0.12193482f, -0.07295440f, 0.04604748f, 0.17445230f, -0.02034528f, 0.04631168f, 
    0.02316801f, 0.13040645f, 0.04039915f, -0.08590174f, -0.04432878f, -0.14202292f, -0.05989813f, -0.06284108f, 
    -0.06769595f, 0.18139306f, -0.04025807f, -0.02608098f, -0.03034875f, 0.11187146f, -0.66456163f, 0.03898932f, 
    0.27127668f, 0.06480410f, 0.24905616f, 0.18723084f, -0.07589563f, 0.05783539f, -0.12850001f, -0.15433909f, 
    -0.04441807f, -0.12678050f, -0.03794723f, -0.03055398f, 0.05542894f, -0.08309973f, 0.08025574f, 0.07850878f, 
    0.32714990f, 0.25585601f, 0.07173572f, -0.13757797f, 0.11361008f, 0.06213348f, 0.03635747f, -0.00247938f, 
    0.08819775f, 0.07204446f, 0.07659259f, -0.01473180f, -0.00939937f, -0.07333146f, 0.21512558f, -0.06286764f, 
    -0.12770998f, 0.05427056f, -0.04839249f, -0.12079488f, -0.24945365f, -0.25159410f, -0.28767267f, 0.05815272f, 
    -0.04726705f, 0.02553742f, 0.09058671f, -0.00231960f, 0.03483129f, 0.07131007f, -0.03887282f, 0.09693506f, 
    0.21770103f, 0.10186502f, -0.05597030f, -0.11728128f, -0.02651208f, -0.05015040f, -0.00110152f, 0.11699631f, 
    0.08493244f, -0.02343809f, -0.12660588f, -0.07085013f, 0.03719136f, 0.19735715f, 0.12858640f, 0.18541016f, 
    -0.12539092f, 0.02416078f, -0.14099951f, -0.20479409f, -0.09510817f, -0.03595581f, 0.02985341f, 0.01613893f, 
    0.00604792f, -0.04502909f, -0.05971788f, 0.00256771f, -0.08104129f, -0.04701849f, 0.01061918f, -0.11670008f, 
    -0.02496091f, -0.09549417f, -0.02706223f, 0.04425313f, 0.01200558f, -0.01585145f, -0.03880415f, 0.22503869f, 
    -0.05651444f, -0.01765214f, 0.11448639f, -0.13985939f, 0.13627183f, 0.12509559f, 0.03237091f, 0.00561000f, 
    0.63440919f, 0.02945792f, -0.04760684f, -0.11140918f, -0.33313382f, -0.01261540f, -0.03814289f, 0.05474187f, 
    0.06492158f, 0.06886498f, 0.04664091f, 0.12943222f, 0.02484006f, 0.02428362f, -0.03033964f, -0.08445311f, 
    -0.05919318f, 0.05774564f, 0.11518148f, 0.10374594f, 0.00079166f, -0.04379767f, 0.05079580f, -0.17941484f, 
    -0.04562403f, -0.02918337f, 0.00240238f, -0.04995270f, -0.02592808f, -0.07259574f, -0.04022935f, 0.04118400f, 
    0.02440361f, -0.14092331f, 0.12150155f, -0.03792911f, -0.03653803f, 0.10875868f, 0.05641378f, 0.07953964f, 
    0.26207227f, 0.28092942f, -0.04093577f, 0.02853917f, 0.01486791f, 0.07334118f, 0.02920284f, -0.19874667f, 
    0.10882214f, 0.21993493f, 0.06479347f, 0.00261890f, -0.03894281f, 0.09193465f, 0.07518460f, -0.04935881f, 
    0.01604419f, -0.04769168f, -0.08993737f, 0.09498137f, 0.22999448f, -0.16542695f, -0.36648259f, 0.19725575f, 
    -0.07843833f, 0.09521452f, 0.12259752f, 0.14304839f, 0.01692551f, 0.06201956f, -0.05390925f, 0.06827503f, 
    -0.02114065f, -0.19588484f, 0.00409937f, 0.00025479f, 0.12229680f, 0.04151268f, -0.02487497f, 0.02433693f, 
    -0.47240826f, -0.25417364f, -0.01463887f, -0.23143183f, -0.08609341f, -0.21611252f, -0.01385903f, -0.08959322f, 
    0.01471930f, -0.11050931f, 0.02539595f, -0.00544643f, 0.06788079f, 0.06386851f, 0.11092929f, 0.03573709f, 
    0.12333091f, 0.06933469f, 0.05744644f, -0.12444703f, -0.45879218f, -0.13870424f, -0.02864813f, -0.37297729f, 
    -0.28336769f, -0.13802691f, -0.16705464f, -0.13653623f, 0.07936213f, 0.01621742f, 0.06434706f, 0.02512020f, 
    0.00994684f, 0.04886181f, -0.00930152f, -0.10100523f, 0.03991158f, -0.15021557f, -0.06710063f, -0.06103356f, 
    -0.24916284f, 0.00602132f, -0.33610541f, 0.08834412f, -0.09512414f, -0.11992025f, 0.09004246f, -0.04254126f, 
    0.02893549f, 0.03470855f, -0.00328267f, 0.04723700f, 0.03384500f, 0.10248556f, 0.03227685f, 0.03028997f, 
    0.16879784f, 0.04960994f, 0.08910835f, -0.05779175f, 0.07379250f, 0.16315348f, 0.10644142f, -0.08564644f, 
    -0.05876235f, -0.06410045f, 0.06572531f, 0.06135149f, -0.00448924f, 0.06229439f, 0.01402047f, 0.12803841f, 
    0.07068033f, 0.10220107f, -0.01446173f, -0.08274664f, 0.10457338f, 0.02648574f, 0.02680652f, 0.05046414f, 
    0.19024576f, 0.26210088f, 0.05639523f, -0.11133023f, 0.16812728f, 0.00256812f, 0.03442186f, -0.02564717f, 
    0.01072568f, 0.00945804f, -0.06791262f, -0.06930182f, -0.01368228f, -0.04883303f, -0.02590893f, -0.03993919f, 
    -0.05358322f, 0.05134331f, -0.07987349f, 0.14745937f, -0.32004952f, 0.16604543f, -0.13909219f, -0.09207340f, 
    -0.05038784f, 0.02846062f, -0.05021299f, -0.17003247f, 0.00549426f, -0.01958527f, -0.02345509f, -0.02179404f, 
    -0.03576399f, 0.00057946f, -0.08863204f, -0.06852317f, 0.06596933f, -0.03258183f, -0.10366441f, 0.07427831f, 
    -0.16895932f, -0.09046493f, -0.21029554f, -0.04788770f, 0.08449765f, 0.13495757f, 0.18668666f, 0.25743908f, 
    0.08062910f, 0.06473214f, -0.05248928f, -0.10924558f, -0.02599503f, -0.04205649f, -0.14036813f, 0.00120601f, 
    0.08217529f, 0.04418240f, 0.04524833f, 0.01524619f, -0.18181467f, -0.01101830f, -0.24290192f, -0.04661838f, 
    0.06395600f, 0.06009322f, 0.04481134f, 0.14526002f, 0.03510008f, 0.07852943f, -0.04602817f, 0.02148899f, 
    -0.05881748f, -0.04415240f, -0.09488411f, -0.02418996f, 0.07713810f, 0.09712314f, 0.05651106f, -0.01959063f, 
    0.26092339f, 0.17406808f, -0.01473206f, -0.12873895f, 0.22388546f, 0.14855877f, 0.13151053f, 0.05688329f, 
    0.09853964f, -0.04002929f, 0.11817583f, -0.14769836f, -0.09608535f, -0.06605583f, 0.01333289f, 0.00751722f, 
    -0.03797492f, 0.08293661f, -0.09575354f, 0.07828219f, -0.55654860f, -0.31553984f, -0.03863711f, -0.21762048f, 
    -0.15345554f, 0.01725516f, -0.12733123f, -0.07800933f, 0.02396314f, 0.10860378f, 0.10720909f, 0.02466697f, 
    0.07416154f, 0.08087084f, -0.01318169f, -0.03502534f, 0.10521059f, -0.05781621f, -0.04554914f, -0.20588309f, 
    -0.02756711f, -0.00436998f, -0.03407570f, 0.02749008f, 0.02295761f, -0.01368566f, 0.01612555f, 0.02989482f, 
    0.01426233f, -0.02728605f, 0.00516961f, 0.00279088f, 0.02379014f, -0.00800090f, -0.02017886f, 0.03220506f, 
    -0.00578131f, 0.00732165f, 0.01295496f, 0.01395763f, -0.03505389f, -0.00556574f, 0.01467350f, -0.04034517f, 
    -0.00966679f, -0.00056736f, 0.02249316f, 0.02876771f, -0.01323586f, -0.04066471f, 0.00722234f, 0.00828127f, 
    -0.01233152f, -0.00002733f, -0.00792344f, -0.04220058f, -0.02652551f, -0.00313156f, -0.04436992f, 0.01341248f, 
    0.02665519f, 0.01985945f, -0.01294708f, 0.00221211f, 0.02316890f, -0.04229801f, -0.03800571f, -0.02047843f, 
    -0.00300044f, -0.00066246f, -0.04512417f, -0.04163512f, 0.02839331f, -0.02860376f, -0.01603873f, -0.01564018f, 
    -0.02867464f, -0.00022839f, -0.00836987f, -0.02679222f, 0.02132287f, 0.02242468f, -0.04497095f, -0.00766157f, 
    0.02487739f, 0.02570512f, -0.03800001f, 0.00961119f, -0.02045750f, -0.00135759f, -0.02328605f, -0.03774133f, 
    0.02039717f, -0.02775461f, -0.00080907f, 0.01929600f, 0.00587295f, -0.02358015f, 0.02415039f, -0.01133437f, 
    0.00001744f, -0.04243028f, 0.03077332f, -0.04140181f, 0.02117585f, 0.01727639f, 0.02913461f, 0.02616795f, 
    -0.00683081f, -0.02998232f, -0.00051596f, -0.01932885f, -0.03186468f, -0.03107449f, -0.00171971f, -0.02375226f, 
    0.02101404f, 0.00777917f, -0.00902642f, 0.02204874f, -0.04397842f, -0.02253431f, -0.04446876f, 0.01379842f, 
    0.02591586f, -0.01347153f, 0.02581701f, -0.00287266f, -0.01008742f, 0.00352630f, 0.01262110f, 0.00493954f, 
    0.02998991f, -0.01957149f, 0.01588445f, 0.03080864f, -0.00771427f, -0.02030455f, -0.04325650f, -0.04460797f, 
    0.00556269f, -0.00247095f, -0.01610684f, -0.01903917f, -0.03375308f, -0.02809816f, -0.00092236f, -0.01485839f, 
    0.02519741f, -0.00331221f, -0.03789826f, -0.03200678f, -0.02647053f, -0.02126238f, 0.00028252f, 0.00737849f, 
    -0.01001555f, -0.03650550f, 0.00211260f, -0.03510218f, -0.03257163f, 0.03286203f, -0.00929305f, -0.02840851f, 
    -0.03256145f, -0.01398490f, 0.00641477f, -0.04210791f, 0.00146167f, -0.04071403f, 0.02185685f, -0.00915041f, 
    0.00115102f, 0.02708599f, -0.01992653f, -0.00031269f, 0.00486529f, -0.01530684f, 0.02433558f, 0.02321632f, 
    0.00047982f, 0.00826584f, 0.00170368f, -0.03720706f, -0.02415196f, 0.03132842f, -0.00812033f, 0.00882635f, 
    -0.02703219f, -0.00799012f, -0.03512103f, -0.01721186f, -0.01583375f, 0.01787036f, -0.00250891f, -0.03010699f, 
    -0.03514149f, -0.00730827f, -0.00415581f, 0.01437540f, 0.00954637f, -0.02707826f, -0.04547127f, -0.01694406f, 
    0.02606817f, 0.00643326f, 0.01201712f, -0.01924071f, 0.00308870f, -0.00774625f, 0.01841561f, 0.02659809f, 
    0.02158999f, -0.02397738f, 0.03130789f, -0.03378091f, 0.02912142f, 0.02660949f, -0.00779328f, 0.03190703f, 
    0.02893538f, -0.02371670f, -0.00092860f, -0.00147402f, -0.03978562f, -0.01210076f, -0.02703648f, 0.00781607f, 
    0.02992381f, 0.00969369f, 0.01167212f, -0.00235687f, -0.02119860f, -0.00435720f, -0.03416095f, 0.03342644f, 
    0.02531974f, 0.02699596f, -0.04503072f, -0.02639320f, -0.00594697f, -0.00338167f, 0.00890499f, 0.02822572f, 
    -0.00478991f, -0.03106446f, -0.03618357f, -0.02192971f, -0.02354773f, -0.00859467f, -0.01896892f, -0.02480998f, 
    -0.02660944f, 0.01845731f, 0.00500798f, -0.01405483f, 0.00554308f, 0.00242836f, -0.01153539f, -0.01737926f, 
    0.02316088f, -0.03714874f, -0.00459867f, 0.03239239f, -0.04005341f, 0.00015913f, 0.02851021f, 0.01850403f, 
    -0.03187964f, 0.02369645f, 0.01940416f, -0.01294096f, -0.00251661f, -0.01325339f, 0.02704323f, -0.02714997f, 
    -0.03588912f, 0.03029596f, -0.02289450f, 0.00375804f, -0.02738531f, 0.02295624f, -0.04214534f, 0.02044710f, 
    -0.03551015f, -0.03279838f, -0.03694046f, 0.01650462f, 0.01527383f, -0.04237989f, -0.03769081f, -0.04054540f, 
    0.01388337f, 0.01857953f, 0.01269483f, -0.00651320f, 0.01129965f, -0.04200493f, 0.02760060f, -0.00026848f, 
    -0.01134724f, -0.01148922f, -0.00917062f, -0.02993818f, 0.01083220f, -0.01530571f, -0.00061981f, -0.02765912f, 
    -0.01326811f, -0.02399316f, -0.01462687f, -0.03109361f, 0.01252061f, 0.00068028f, -0.01840209f, -0.04334265f, 
    -0.01742493f, -0.02550851f, 0.00514120f, -0.00925231f, 0.00029567f, -0.04156153f, 0.03040863f, 0.00038133f, 
    0.00003031f, -0.01830940f, 0.01189731f, -0.03392459f, 0.02206884f, -0.00109608f, 0.01302411f, 0.01984579f, 
    0.01125022f, -0.02115984f, -0.04105300f, 0.01471585f, 0.00721339f, -0.02129612f, -0.00154180f, -0.03734505f, 
    -0.00007760f, 0.00435097f, -0.03308648f, 0.01001648f, -0.00552278f, -0.03903779f, 0.03094817f, 0.02562514f, 
    -0.03569563f, -0.03128649f, -0.00235955f, 0.01858013f, -0.00685869f, -0.04515458f, 0.03127918f, 0.00233507f, 
    0.01934247f, -0.04525671f, 0.02124324f, -0.00141992f, -0.02811780f, -0.00354484f, 0.00073359f, -0.01307437f, 
    -0.00244953f, 0.02254270f, 0.01756983f, -0.00455183f, 0.02712650f, -0.03056221f, -0.02189008f, 0.01601672f, 
    0.00145113f, 0.00040782f, 0.03045834f, 0.01097993f, 0.02614367f, 0.01717771f, 0.00576580f, -0.00989337f, 
    0.01494740f, 0.03303204f, -0.01579297f, -0.04055930f, -0.00882150f, 0.02665126f, 0.01291228f, 0.02125086f, 
    -0.02307519f, -0.04235150f, -0.01785807f, -0.02868398f, -0.03445891f, -0.04467543f, -0.04067662f, -0.03123355f, 
    -0.00756742f, -0.00853455f, 0.02602786f, -0.01161833f, 0.01306063f, -0.03988950f, 0.02105989f, -0.01519766f, 
    0.00942690f, -0.02075238f, 0.02837609f, -0.03356040f, -0.00391886f, 0.01919451f, 0.00009262f, 0.02842626f, 
    -0.01518140f, -0.03048680f, 0.01807895f, 0.02830829f, 0.01276729f, 0.01509721f, 0.00173181f, -0.01034669f, 
    -0.00804689f, -0.01272989f, -0.01416135f, 0.00607276f, -0.03852027f, 0.01493172f, 0.03334504f, -0.03961553f, 
    0.00237821f, -0.03084231f, 0.00445672f, -0.04103602f, -0.00489711f, 0.02817634f, 0.02459345f, -0.02389043f, 
    -0.03063651f, 0.03243850f, 0.01842033f, -0.03420463f, -0.04270884f, 0.01981713f, -0.00491012f, 0.00927980f, 
    0.01375068f, -0.03249051f, -0.04547997f, -0.02990298f, -0.00355211f, -0.00134402f, 0.01419462f, -0.01506338f, 
    0.00520179f, -0.03699395f, -0.00856155f, -0.00359866f, 0.01333254f, -0.00824034f, 0.00593199f, -0.00359637f, 
    -0.01073637f, 0.00903835f, -0.03211751f, -0.00663425f, -0.02850346f, -0.04437289f, -0.04112732f, 0.02828320f, 
    0.01045451f, 0.01020174f, -0.02600681f, -0.00648717f, 0.00097726f, 0.02594381f, -0.03288732f, -0.04162197f, 
    0.01310855f, -0.01247066f, -0.02045771f, -0.00087481f, 0.02081770f, 0.02461059f, -0.02218871f, -0.02256964f, 
    -0.02639167f, -0.03408520f, -0.00064115f, -0.04287418f, -0.04478142f, -0.02364437f, -0.02671503f, -0.04342364f, 
    -0.02027760f, -0.04285266f, -0.01832343f, -0.02239221f, -0.01594655f, 0.03133048f, -0.02176888f, 0.00886929f, 
    -0.03368792f, 0.01403178f, -0.03735273f, -0.03570499f, -0.04393599f, 0.00256697f, -0.00928964f, -0.03498857f, 
    0.01737297f, 0.02279765f, 0.00927124f, -0.02354095f, 0.02945979f, -0.01194657f, 0.00645620f, -0.01523189f, 
    0.01848970f, -0.04183601f, -0.02067928f, -0.03112707f, 0.02634916f, -0.01615300f, -0.04004038f, 0.00939221f, 
    -0.04179275f, 0.02546293f, -0.01388272f, -0.03017334f, -0.00218123f, 0.01021230f, 0.03082043f, 0.02345957f, 
    -0.02398612f, 0.01528810f, -0.03465170f, -0.02031309f, 0.02681801f, -0.01936855f, -0.01411649f, -0.03468132f, 
    0.01519366f, -0.00074161f, -0.02332030f, 0.00488365f, -0.01451540f, -0.01490566f, -0.00825538f, 0.02844432f, 
    -0.01579546f, -0.00100703f, -0.01176331f, 0.01648064f, -0.02042320f, 0.00674473f, -0.02781774f, -0.01917494f, 
    0.01283304f, -0.00144117f, -0.04274208f, 0.01010184f, 0.00478946f, 0.00954767f, 0.00016900f, 0.02540597f, 
    -0.03351476f, -0.00881015f, 0.00732642f, -0.04274133f, 0.03221886f, 0.00138753f, 0.01634129f, -0.03087127f, 
    -0.04321469f, -0.03171748f, 0.00272502f, 0.02698686f, -0.03563461f, -0.02319248f, 0.03032956f, -0.03246854f, 
    -0.02177284f, -0.00554255f, -0.00749346f, 0.02331057f, 0.01723128f, -0.04298066f, 0.01776787f, 0.00288699f, 
    0.02124863f, -0.00539441f, -0.00279496f, 0.01216355f, -0.01240721f, -0.00737480f, -0.03910374f, 0.03120225f, 
    0.02544071f, 0.01250095f, 0.02020849f, 0.00408362f, -0.04361108f, -0.02824911f, -0.00663099f, -0.02516279f, 
    -0.01733749f, -0.03839792f, 0.02888672f, 0.02888585f, 0.02621361f, 0.01210259f, 0.01171030f, -0.01159165f, 
    -0.00174676f, -0.01269758f, -0.00088336f, -0.01709838f, 0.01050802f, 0.01525153f, 0.02731286f, -0.04006496f, 
    0.02665028f, -0.01865348f, -0.03859128f, -0.04162753f, 0.02417970f, 0.00203184f, -0.02422635f, -0.01256442f, 
    -0.00740726f, -0.02549646f, -0.03574323f, 0.02429877f, -0.01945156f, -0.01311963f, 0.01901310f, 0.02879924f, 
    0.01957863f, 0.02030309f, 0.01790027f, 0.00210204f, -0.03980037f, 0.01121571f, -0.03529659f, -0.02003650f, 
    0.00736229f, -0.01421016f, -0.01639220f, 0.01134283f, 0.02228872f, -0.04318924f, -0.00711465f, 0.03016361f, 
    -0.01906961f, -0.01766278f, -0.03785893f, 0.02711953f, 0.01372240f, 0.00311936f, 0.02717089f, -0.04299364f, 
    -0.02232859f, 0.01814537f, -0.03050834f, -0.03638107f, -0.03902562f, -0.03196744f, -0.00471235f, -0.00726338f, 
    -0.01953894f, -0.02946394f, -0.02681409f, 0.03383704f, 0.01450373f, -0.00088715f, 0.00797922f, -0.01738810f, 
    0.01528179f, -0.00721832f, 0.02138380f, 0.02868821f, -0.01776070f, 0.00265734f, -0.03640401f, -0.02613930f, 
    -0.04651482f, 0.01510153f, 0.03682068f, 0.01209830f, 0.01797952f, 0.00279189f, -0.04261826f, 0.03440200f, 
    -0.03399856f, -0.03132756f, 0.02969939f, -0.02057895f, -0.02142110f, -0.02032512f, -0.03108475f, 0.01100327f, 
    -0.00122487f, -0.03199554f, 0.01487355f, -0.01038703f, 0.02633942f, -0.03215099f, -0.02487084f, 0.01222484f, 
    0.03133688f, -0.01632218f, 0.01137659f, 0.00321459f, -0.01201677f, 0.02369023f, 0.01918146f, 0.00750702f, 
    -0.04299135f, 0.02244346f, -0.04537165f, -0.02107136f, -0.02267809f, 0.01219395f, -0.03036142f, -0.00470696f, 
    0.01007893f, -0.00934123f, -0.03384052f, -0.01274101f, 0.00406557f, 0.01641754f, -0.02330740f, 0.00103191f, 
    0.00958634f, -0.02280137f, -0.02131492f, -0.02405544f, -0.00969468f, -0.01530252f, -0.02859356f, -0.02510633f, 
    0.00695936f, -0.03527893f, 0.03012550f, 0.00987861f, -0.01054015f, 0.00748328f, 0.02541877f, 0.00399376f, 
    -0.02480418f, -0.02122591f, -0.00244654f, -0.01038627f, -0.01386192f, 0.01053435f, 0.01073238f, -0.03596637f, 
    -0.00594770f, 0.01264181f, -0.03882520f, 0.03631620f, 0.02150883f, -0.02588176f, -0.00967875f, 0.02133957f, 
    -0.00758076f, 0.03003624f, -0.02034631f, -0.00711729f, -0.01633432f, 0.00912028f, 0.01290014f, -0.02808366f, 
    -0.00639839f, -0.03454295f, 0.00714851f, 0.01752850f, -0.01677816f, -0.00331067f, 0.02087408f, 0.00450033f, 
    0.01060892f, 0.00640413f, 0.00151926f, -0.02542959f, -0.03937468f, -0.00059889f, -0.01978927f, 0.00561188f, 
    -0.03001404f, -0.00854249f, 0.01482335f, -0.02434861f, -0.04328780f, -0.02453065f, -0.02259861f, -0.02567943f, 
    -0.00115398f, -0.02020473f, -0.02105680f, -0.01047547f, -0.00265400f, -0.03028956f, 0.02672756f, 0.03070956f, 
    0.01675046f, 0.02492927f, -0.02873701f, -0.01599269f, 0.00481691f, -0.03017998f, -0.00689095f, -0.03692192f, 
    -0.01170159f, 0.01785733f, -0.00378582f, -0.03100211f, 0.02217159f, -0.02816871f, -0.04157229f, -0.02903800f, 
    0.00514610f, -0.01544675f, 0.00663180f, 0.01776010f, -0.01551568f, -0.00317457f, 0.00514058f, -0.02503208f, 
    -0.00850553f, 0.00103216f, -0.02650953f, 0.02412683f, 0.00796956f, -0.02925866f, -0.02012264f, -0.03497299f, 
    -0.00379647f, 0.03184744f, 0.02760123f, -0.00782102f, 0.01642463f, 0.03239927f, 0.03195874f, -0.02465522f, 
    0.00873533f, -0.04234105f, -0.03121863f, 0.00883094f, 0.03202951f, 0.01739569f, -0.01215990f, -0.00612334f, 
    0.00290974f, -0.00012649f, 0.01760760f, -0.04308274f, 0.03354728f, 0.02370244f, -0.02374801f, 0.00619065f, 
    -0.04309372f, 0.02551151f, -0.01796941f, -0.01239680f, -0.00896662f, -0.01106943f, 0.00596463f, -0.03929863f, 
    0.01026341f, -0.02251825f, -0.00931324f, 0.02962020f, -0.03288256f, -0.01901556f, -0.01272793f, -0.01087347f, 
    0.00600081f, -0.00021687f, -0.04172917f, -0.01859236f, -0.04282980f, -0.01751597f, 0.02115361f, 0.03206883f, 
    -0.00938430f, -0.01949912f, -0.02732241f, -0.04298224f, -0.02436339f, -0.01235807f, -0.00307065f, 0.01837750f, 
    0.01188431f, 0.03278507f, -0.00098850f, 0.00066075f, -0.00826695f, 0.02540970f, 0.00073621f, 0.00294930f, 
    -0.01851753f, -0.02068743f, -0.02597552f, 0.01713710f, 0.04119562f, 0.01747721f, 0.03990009f, 0.01534119f, 
    0.02139678f, 0.01062655f, -0.03450534f, 0.03093965f, 0.02584470f, 0.02481973f, 0.00722317f, -0.02180275f, 
    -0.04162546f, -0.00792800f, 0.00552352f, -0.04802801f, -0.00373927f, 0.03521440f, -0.01215485f, -0.00355943f, 
    -0.00642791f, 0.04316548f, -0.04297637f, 0.02965942f, 0.00085755f, 0.04205587f, 0.00722216f, 0.00595668f, 
    -0.01941907f, 0.02439807f, 0.01093038f, -0.01541240f, -0.02289896f, -0.03298258f, 0.02757070f, -0.01862127f, 
    0.01332971f, -0.01328223f, -0.01912726f, 0.02031600f, -0.03389741f, -0.03008383f, -0.02161043f, 0.01050515f, 
    0.00918179f, 0.03692872f, 0.02949112f, -0.01670562f, 0.02387255f, -0.03020468f, 0.01241868f, -0.02425300f, 
    -0.02747516f, -0.02913886f, 0.00855997f, -0.04043652f, 0.02302810f, -0.04035765f, 0.03038556f, 0.02803601f, 
    0.00179343f, 0.02520114f, 0.02344042f, -0.00523121f, 0.02551088f, 0.01346217f, 0.01971714f, -0.03839602f, 
    0.01878007f, -0.01425222f, -0.04809533f, -0.01950222f, -0.00457946f, -0.00324320f, -0.02567745f, 0.01757445f, 
    0.01413983f, -0.00530509f, 0.01160238f, -0.02077547f, -0.02536605f, 0.00827276f, 0.02991428f, -0.03951229f, 
    -0.04507392f, 0.03085769f, -0.03152706f, 0.00750517f, -0.03484142f, 0.02425719f, -0.00157811f, -0.04265516f, 
    0.02060659f, -0.04822639f, 0.00103059f, -0.04258287f, -0.00214858f, -0.03523038f, 0.00205373f, -0.01945401f, 
    -0.00623247f, 0.00671079f, 0.00670069f, -0.03948038f, 0.02222219f, -0.03027365f, -0.04107057f, 0.01564863f, 
    -0.01185776f, 0.03468216f, 0.00094403f, 0.00267085f, -0.02860654f, 0.00598814f, 0.02916268f, -0.00521878f, 
    0.01271792f, -0.00662344f, -0.00487412f, 0.02994531f, -0.01773560f, -0.03746456f, -0.02334496f, -0.02281392f, 
    0.02115760f, 0.01392800f, 0.03265196f, 0.00399005f, -0.04107754f, 0.01294208f, 0.01779041f, -0.01706965f, 
    0.01129475f, 0.01219640f, 0.01277483f, -0.03748615f, -0.02359919f, -0.04250123f, 0.01125777f, 0.02267002f, 
    -0.01474057f, -0.00456621f, 0.01700737f, -0.02172819f, 0.02067273f, 0.02399267f, 0.00597050f, -0.03246927f, 
    -0.01956965f, -0.03390079f, 0.04477930f, 0.02527380f, 0.00057219f, -0.01071306f, -0.03039446f, -0.00294779f, 
    0.01133562f, -0.01168161f, -0.00675864f, -0.00812883f, 0.03097140f, -0.03665781f, -0.02922100f, 0.00698550f, 
    0.03468320f, 0.02023115f, -0.01359227f, -0.03549015f, -0.01819720f, 0.02957533f, -0.01467275f, 0.00511213f, 
    0.02338561f, -0.03565077f, 0.02680490f, -0.00344249f, 0.02674337f, -0.00266919f, 0.02906265f, -0.00728115f, 
    0.00076108f, -0.02928347f, -0.02797279f, -0.01868483f, -0.02301485f, -0.02039730f, -0.01340307f, -0.02817505f, 
    0.02735468f, -0.01988518f, -0.03593278f, -0.01745484f, -0.03030567f, 0.01595320f, -0.03560721f, 0.01589565f, 
    0.01927436f, -0.02463838f, 0.00310899f, -0.02166814f, 0.01991106f, -0.02705892f, -0.03906172f, -0.02373106f, 
    0.00418516f, -0.03091378f, -0.04299893f, 0.01778240f, -0.02671823f, 0.01462066f, 0.02429518f, -0.01434914f, 
    -0.03804377f, 0.00523622f, 0.00548139f, -0.03163368f, -0.02981188f, -0.04277429f, -0.00398187f, 0.00743436f, 
    0.01921086f, -0.03346360f, -0.01688535f, -0.00816697f, 0.03270952f, -0.00899292f, 0.03227695f, -0.03285231f, 
    -0.01447341f, 0.00367829f, 0.01270648f, 0.00492085f, -0.00670807f, 0.02288428f, -0.03900183f, -0.03696327f, 
    -0.00274791f, -0.01623838f, -0.01064546f, -0.01282692f, -0.01156321f, 0.00385714f, -0.03843039f, -0.02748836f, 
    -0.04056544f, -0.03095958f, 0.01063575f, 0.00374391f, 0.02002293f, -0.00906967f, 0.02933846f, -0.02608619f, 
    0.00649192f, -0.04346554f, 0.01988097f, 0.04166330f, -0.02723926f, -0.00919311f, 0.00418712f, 0.00199449f, 
    -0.04512509f, 0.02402444f, -0.00264447f, -0.03333387f, -0.04015358f, 0.00358618f, 0.03389085f, 0.01104596f, 
    -0.03972218f, -0.00906052f, 0.03175516f, 0.01248871f, -0.01173023f, 0.00067603f, 0.01693420f, 0.02523411f, 
    0.00807963f, -0.03152136f, -0.03136090f, -0.01706388f, 0.04398052f, -0.01046985f, 0.01411051f, 0.01355595f, 
    0.02630653f, 0.01442595f, -0.00031986f, -0.02901344f, -0.00200340f, -0.02682346f, 0.01788063f, 0.01019397f, 
    0.02456384f, 0.00185725f, 0.03058812f, 0.00916792f, 0.02734417f, 0.01665078f, -0.01823085f, 0.01294346f, 
    0.01058429f, 0.01039123f, -0.03652301f, -0.01352768f, 0.00235757f, 0.02001592f, -0.02459222f, -0.02981500f, 
    0.00223011f, 0.02507886f, -0.04461551f, -0.03090256f, 0.00265662f, 0.01566391f, -0.00117902f, -0.00067835f, 
    0.02216656f, 0.02013356f, -0.02995063f, 0.02780489f, 0.03656235f, 0.03905363f, 0.00053467f, 0.02382952f, 
    -0.00991507f, -0.02456478f, 0.00289053f, 0.02344613f, 0.03143856f, -0.00640040f, -0.01754538f, -0.02179872f, 
    0.01094709f, -0.00158080f, -0.04173630f, 0.00277081f, -0.03359499f, -0.00732451f, 0.02176518f, 0.00942776f, 
    -0.00325006f, -0.01658370f, -0.04449523f, 0.02232020f, 0.01427262f, -0.03770246f, 0.02518433f, 0.00098047f, 
    0.03713211f, 0.01689268f, 0.00589709f, -0.03479293f, 0.01568718f, -0.01057430f, -0.00079642f, -0.03241964f, 
    0.02343392f, 0.04418210f, -0.03536877f, -0.00576758f, 0.00373746f, -0.03732895f, 0.02604248f, -0.02021951f, 
    -0.03885189f, -0.03698710f, -0.03730563f, -0.01040849f, -0.02612035f, -0.02591627f, -0.01863658f, -0.01234310f, 
    0.00947597f, 0.00821926f, -0.02320469f, -0.03022128f, -0.00696583f, -0.04612449f, -0.02776714f, 0.02568529f, 
    -0.03049053f, -0.00774421f, -0.04531458f, 0.04287093f, -0.01384190f, 0.00516459f, 0.00587476f, 0.01638342f, 
    -0.02644273f, 0.01785639f, -0.02183411f, -0.01512722f, 0.01660485f, -0.04148825f, -0.02620979f, -0.01739822f, 
    0.04983464f, 0.06988823f, 0.13929951f, 0.00520762f, -0.06227710f, -0.08509337f, -0.15817837f, -0.04399453f, 
    0.03636011f, -0.12386786f, -0.11642348f, -0.03684890f, -0.05739315f, -0.05588501f, -0.13657342f, 0.02325845f, 
    -0.03754213f, -0.14679219f, -0.06002242f, -0.02774453f, -0.18958475f, 0.43821856f, 0.43426004f, 0.07583805f, 
    0.18685494f, 0.10669731f, -0.03765376f, -0.09846389f, 0.09166261f, 0.11264159f, -0.01992209f, 0.10656457f, 
    0.22779691f, 0.16650027f, 0.10293636f, -0.03253981f, 0.11589095f, 0.03097814f, -0.01818816f, -0.18362381f, 
    0.18957193f, -0.07934803f, 0.07748692f, 0.01147310f, 0.15855482f, 0.06041154f, -0.06013820f, -0.02107598f, 
    0.13746262f, -0.03182894f, -0.01073108f, 0.06059211f, -0.02141233f, -0.03883968f, -0.01830484f, 0.08783330f, 
    0.05148666f, 0.02789634f, 0.02557060f, 0.05037156f, 0.14576441f, 0.07371084f, 0.01771939f, -0.23640673f, 
    -0.29929668f, -0.05226035f, 0.01474558f, 0.02931147f, 0.05753384f, -0.05187375f, 0.10281092f, -0.05596125f, 
    0.12502100f, -0.00233264f, 0.07365762f, -0.04465559f, -0.02648509f, -0.09173422f, 0.17070687f, 0.01871619f, 
    0.13318084f, 0.08171486f, 0.08111879f, -0.11450040f, 0.22631642f, 0.09900153f, -0.01645185f, 0.13399301f, 
    0.07211286f, 0.11922240f, 0.06118272f, 0.04909647f, 0.05291523f, 0.04255404f, 0.01534126f, 0.03671119f, 
    0.11973027f, 0.12648672f, -0.03970581f, -0.03784291f, 0.06668810f, 0.02155323f, 0.00543305f, -0.08257505f, 
    0.21230344f, -0.03839262f, 0.01553388f, -0.01948714f, 0.15249081f, -0.01067900f, -0.00919072f, 0.02529270f, 
    0.03605227f, -0.04369283f, 0.01842556f, 0.07372674f, 0.02054110f, -0.03109512f, 0.03047932f, -0.10745931f, 
    0.61543655f, 0.18642266f, -0.07209925f, -0.19989674f, 0.05499355f, 0.09106569f, 0.06823335f, 0.06216388f, 
    0.08772334f, 0.01900352f, -0.09382793f, 0.14689718f, 0.14216988f, -0.00900154f, 0.01099743f, 0.01713960f, 
    -0.04251838f, -0.11479371f, 0.17848200f, -0.02836310f, 0.12628023f, -0.13646868f, 0.02200693f, 0.10201639f, 
    0.29228935f, 0.03692150f, 0.10031284f, 0.03906993f, -0.03063770f, -0.05012594f, -0.06063839f, 0.03374383f, 
    0.04350006f, 0.03239038f, 0.09034957f, 0.11952067f, 0.06327495f, -0.04477654f, 0.19034542f, 0.04828311f, 
    -0.20694764f, -0.24288198f, -0.23436090f, -0.13758595f, 0.02081966f, 0.03410088f, 0.05976910f, 0.01835229f, 
    -0.04878136f, -0.16835248f, 0.15111166f, -0.07799912f, -0.09634113f, -0.00703167f, -0.01757305f, 0.01143769f, 
    0.02284839f, 0.22506876f, 0.17865367f, 0.07502648f, -0.09686263f, -0.11057290f, -0.25885972f, 0.12137884f, 
    -0.15088499f, -0.04710685f, -0.05001915f, 0.14383475f, -0.07404156f, -0.02099212f, -0.00293551f, -0.01801210f, 
    -0.07354272f, -0.05131223f, 0.04015855f, 0.09190160f, 0.02483381f, 0.20158932f, 0.08460212f, 0.04699742f, 
    -0.02343573f, -0.35770988f, -0.15582767f, 0.07435933f, -0.01819740f, 0.06004050f, 0.00659563f, -0.05020332f, 
    0.06413901f, -0.11760155f, 0.08820219f, 0.03761694f, -0.07772511f, -0.01735557f, -0.02653269f, -0.02230672f, 
    0.08587894f, 0.17136881f, 0.01719393f, 0.09534021f, 0.06171299f, 0.23004964f, -0.05138300f, 0.27797362f, 
    -0.03248163f, -0.06044185f, -0.05636056f, 0.06759972f, 0.03104795f, -0.00593541f, -0.01218762f, 0.02675641f, 
    -0.01537372f, -0.13111271f, -0.06703109f, 0.13843943f, 0.13404842f, -0.10251445f, 0.07459961f, 0.07730129f, 
    -0.04120832f, -0.24531931f, -0.35111085f, -0.11582970f, -0.03680735f, 0.00577247f, 0.05623472f, 0.03474086f, 
    -0.11450560f, -0.11283828f, -0.03185908f, -0.04078324f, -0.06719370f, -0.16671906f, -0.06516007f, -0.02413147f, 
    0.02498394f, 0.05912698f, 0.06192117f, 0.07088646f, -0.05437447f, -0.05513485f, -0.15030344f, 0.15293035f, 
    0.22848779f, -0.10761518f, -0.02569255f, 0.04646776f, 0.09387933f, -0.04956658f, 0.07871782f, -0.00465879f, 
    -0.15554871f, 0.06669174f, 0.11648422f, 0.02551602f, -0.03578354f, -0.11575281f, 0.09558219f, 0.01593169f, 
    0.15007740f, -0.00423115f, -0.01850311f, 0.01837625f, 0.11352400f, 0.16755348f, 0.00080931f, -0.05674250f, 
    0.09721404f, 0.05285222f, -0.00765307f, 0.12325324f, -0.07232992f, -0.02560064f, -0.02796802f, 0.04297787f, 
    0.01542261f, 0.12184215f, 0.06708580f, 0.06025382f, 0.14842428f, 0.24580352f, -0.18768409f, 0.01199288f, 
    -0.10247257f, -0.09153415f, -0.02282334f, -0.05631894f, -0.10092175f, 0.10064563f, 0.03010773f, -0.01733789f, 
    0.22896330f, -0.06938121f, -0.11603777f, 0.13152562f, 0.03747877f, -0.17253248f, 0.17228939f, 0.08042889f, 
    -0.03095848f, -0.00395379f, -0.05082485f, -0.18647291f, 0.22708187f, 0.03818783f, -0.05583210f, 0.07321412f, 
    0.16284424f, 0.00827233f, 0.02297430f, 0.03074186f, 0.03987673f, -0.06202265f, 0.00037121f, 0.00881716f, 
    0.05526826f, -0.00366154f, -0.02085940f, -0.05161840f, -0.00933291f, 0.07170401f, -0.14058663f, -0.06075872f, 
    -0.04917314f, -0.11292534f, -0.15706652f, -0.21723205f, 0.08974383f, -0.02027120f, -0.02368614f, -0.10126527f, 
    0.05738205f, -0.10525110f, -0.08352893f, -0.31868345f, -0.19609936f, -0.03548076f, -0.04507415f, -0.00314603f, 
    -0.02500267f, 0.27454278f, 0.32242128f, 0.15770616f, 0.09579995f, -0.04238581f, -0.02773576f, 0.04550793f, 
    -0.09795994f, 0.04329649f, 0.06898315f, -0.01333803f, 0.14840263f, 0.10143040f, 0.16154908f, 0.05465690f, 
    -0.03919421f, -0.08928704f, -0.01086739f, -0.08267599f, -0.12397484f, 0.07374484f, -0.02820016f, -0.13809592f, 
    -0.20135596f, -0.04849872f, -0.13868414f, -0.02027740f, -0.01063551f, -0.04547240f, -0.16319063f, 0.01161965f, 
    -0.07608887f, 0.14791095f, -0.08839340f, 0.06296649f, -0.02294119f, -0.00582976f, 0.01602778f, -0.11503260f, 
    -0.07651665f, -0.28050295f, -0.28365245f, -0.09846832f, 0.03488987f, 0.02550769f, 0.07682879f, -0.18090266f, 
    0.10501391f, -0.20052770f, 0.07207320f, -0.13121873f, -0.07326657f, -0.05346863f, 0.05685439f, -0.02932220f, 
    0.00456875f, 0.02397356f, 0.09135686f, 0.07618413f, 0.00277150f, 0.28407875f, -0.12137523f, -0.05517994f, 
    0.22082338f, -0.06668802f, 0.05968622f, 0.19075273f, -0.03749003f, 0.07957769f, 0.06832132f, 0.13530497f, 
    -0.06521425f, -0.04114024f, 0.00337380f, 0.01047862f, -0.11262804f, -0.01046339f, 0.05672884f, -0.12585008f, 
    -0.04926666f, 0.13617207f, 0.53601438f, -0.13511565f, 0.08319676f, -0.04788335f, 0.01702864f, -0.22242410f, 
    -0.08263472f, -0.02598485f, 0.01147858f, -0.04158311f, 0.06092660f, 0.14770120f, 0.01555628f, -0.05582044f, 
    0.03788226f, 0.10009462f, 0.00228107f, -0.09675395f, 0.17239246f, -0.13613357f, 0.61515415f, -0.30474234f, 
    0.13118112f, -0.21236245f, 0.04721883f, -0.10497180f, 0.01121799f, -0.06923141f, -0.10176557f, -0.01783004f, 
    -0.01241642f, 0.03869553f, 0.03150461f, -0.07140170f, 0.01496909f, -0.08143660f, 0.03505998f, 0.07119305f, 
    0.06102024f, 0.10155954f, 0.21004841f, -0.20034271f, -0.14017889f, -0.08652318f, -0.19028887f, -0.35403714f, 
    -0.02906931f, -0.19751157f, -0.13229476f, -0.12566943f, -0.02119115f, -0.11886012f, -0.15963252f, -0.13035332f, 
    -0.03817945f, 0.04743657f, 0.02831908f, -0.01776149f, 0.28363463f, -0.29673016f, -0.14111175f, -0.25440246f, 
    -0.00511955f, 0.04862668f, -0.03383423f, -0.11947314f, 0.06179790f, -0.09789622f, -0.06838159f, -0.12511885f, 
    -0.03285561f, -0.05990453f, -0.03060799f, -0.17804942f, 0.02623881f, 0.04247503f, 0.04189705f, 0.17845106f, 
    -0.04419069f, -0.19780788f, -0.37592372f, 0.01224045f, 0.05158111f, -0.01751488f, 0.04888024f, 0.11387262f, 
    0.04893119f, 0.00325503f, 0.08572423f, 0.05928195f, 0.01043985f, 0.01536364f, 0.02668378f, 0.05453902f, 
    0.03427232f, 0.18751465f, -0.01690980f, 0.04586177f, 0.04842315f, 0.05391055f, 0.25580153f, -0.26125023f, 
    0.21770558f, -0.00678326f, 0.09425989f, 0.04595896f, -0.00382748f, -0.09450057f, 0.06604572f, 0.11393472f, 
    0.09546921f, 0.02320999f, -0.03054363f, -0.00475529f, 0.06194811f, 0.08820459f, 0.00830410f, 0.11113394f, 
    -0.00827323f, 0.16752696f, 0.05299975f, -0.11775723f, 0.18909468f, -0.07695667f, 0.02439643f, -0.00132731f, 
    0.05888990f, -0.04806634f, 0.00151162f, 0.03213275f, 0.06718393f, -0.04668337f, 0.02304136f, 0.00057675f, 
    0.04052551f, -0.07497782f, -0.00279873f, -0.05559776f, 0.01488764f, 0.09789301f, 0.06263366f, -0.16939248f, 
    -0.03583402f, -0.06451649f, -0.04218408f, 0.03119527f, 0.10334150f, -0.03330822f, 0.06951731f, 0.04193291f, 
    0.11524741f, -0.09295186f, -0.06557705f, -0.02557306f, 0.01934705f, -0.15070646f, 0.03959488f, -0.05476253f, 
    -0.05173182f, -0.20279039f, -0.16630553f, -0.05650110f, -0.01378615f, 0.03946353f, -0.10186882f, -0.05145866f, 
    0.13774391f, -0.21987748f, -0.07259174f, -0.01059461f, -0.05870296f, -0.06196147f, 0.00303918f, -0.01557161f, 
    0.04186402f, 0.20621696f, 0.00275907f, 0.11528891f, -0.12402947f, -0.04647346f, 0.44272220f, -0.20278190f, 
    -0.02397808f, -0.13906530f, 0.04681580f, -0.11077031f, -0.08129773f, -0.04716299f, -0.03649607f, -0.04951298f, 
    -0.02600684f, -0.03192696f, -0.05046577f, 0.03815394f, 0.00047167f, 0.01967946f, -0.11089053f, -0.03387956f, 
    -0.04254099f, 0.02634474f, 0.00943084f, -0.02033889f, -0.00185186f, -0.00500432f, -0.01281453f, 0.00581086f, 
    0.00437997f, -0.02751787f, 0.00463764f, 0.00122192f, -0.00410766f, -0.04837874f, -0.01054704f, -0.02694203f, 
    -0.00140811f, 0.02886809f, 0.01657324f, 0.02127151f, 0.02777780f, -0.02447362f, 0.01917782f, 0.00711931f, 
    0.01645658f, -0.03275174f, 0.00691843f, 0.02563262f, 0.01997426f, 0.01148361f, 0.02974198f, -0.03591524f, 
    -0.02919260f, 0.03223922f, -0.00566767f, -0.04185109f, 0.00931497f, -0.00130849f, -0.01522207f, 0.01664201f, 
    0.02293759f, -0.03661185f, 0.02451240f, 0.00694745f, -0.02400545f, -0.02333237f, -0.00484764f, -0.01875147f, 
    0.00201963f, -0.00469004f, 0.03592113f, -0.03582706f, 0.02923767f, 0.00126298f, 0.01500623f, -0.02308523f, 
    -0.01082030f, 0.00829354f, -0.01216104f, 0.00983752f, 0.00482896f, -0.03044502f, -0.04023083f, 0.01906486f, 
    0.00573801f, 0.02291767f, -0.00334658f, 0.02645860f, 0.02864933f, 0.01629653f, -0.01078150f, -0.03620074f, 
    -0.01749501f, -0.02739856f, 0.03182400f, 0.02552070f, -0.00572396f, 0.00911986f, -0.00214824f, 0.01293755f, 
    -0.01049419f, -0.00221434f, 0.02942856f, 0.01855898f, -0.01670607f, -0.00619603f, -0.04454063f, -0.01772608f, 
    -0.02526474f, -0.00697124f, -0.01290616f, 0.00164579f, -0.03386042f, -0.01211186f, -0.02645813f, 0.00922890f, 
    -0.02873574f, -0.03909375f, 0.03244959f, -0.01124164f, -0.01652909f, -0.03250401f, -0.03869102f, 0.02415103f, 
    -0.01878215f, -0.02171657f, 0.02487229f, -0.01994242f, 0.03475467f, -0.04190556f, -0.03249669f, -0.02780896f, 
    -0.03666728f, 0.00331603f, 0.02571085f, -0.04320468f, -0.04005496f, -0.00611770f, -0.04002916f, -0.04196708f, 
    0.01389784f, -0.03034126f, -0.04455754f, -0.01024885f, 0.00701535f, 0.02182137f, 0.01722687f, 0.01639608f, 
    -0.00965186f, -0.01628534f, -0.00643836f, 0.03007753f, 0.02762255f, 0.02590236f, -0.03273994f, -0.02133421f, 
    -0.01521211f, 0.00774407f, 0.02882730f, 0.00534884f, -0.00322740f, -0.03564857f, -0.00237035f, 0.00249397f, 
    0.01534831f, -0.03369675f, 0.01819693f, -0.02205554f, 0.01719034f, 0.00591909f, 0.01004911f, -0.02407976f, 
    -0.02733426f, 0.02201058f, 0.00887685f, 0.00705496f, -0.01957480f, 0.01715931f, 0.02479815f, -0.04284344f, 
    0.00947954f, -0.00178808f, -0.03854333f, -0.00336505f, -0.02775188f, 0.00316471f, -0.03360486f, 0.00139026f, 
    0.02758297f, -0.01698029f, -0.03805627f, 0.03213010f, -0.01139594f, -0.00272233f, -0.00166347f, -0.01412847f, 
    0.01032916f, -0.00409511f, -0.04216412f, 0.02227163f, -0.01663610f, 0.00660865f, 0.00053769f, -0.02099226f, 
    0.00090725f, 0.01169454f, 0.00350573f, 0.00617689f, -0.00233831f, -0.03465261f, -0.03951119f, 0.01708372f, 
    -0.01954355f, 0.02551304f, -0.00296355f, -0.02936941f, 0.00847793f, 0.01491929f, 0.00775171f, 0.03317029f, 
    -0.02434747f, -0.00153141f, -0.04663647f, -0.01572896f, 0.01796112f, -0.02103649f, -0.00451424f, -0.02699808f, 
    -0.00155324f, 0.01993835f, -0.02988349f, 0.02074186f, 0.01655608f, -0.03643442f, -0.03222627f, -0.01600707f, 
    0.00003571f, 0.02888145f, -0.03131375f, -0.03088330f, -0.01322251f, -0.01802402f, 0.00038452f, -0.01171470f, 
    -0.00531308f, 0.00338733f, 0.00029217f, 0.00357725f, -0.02508882f, 0.00537338f, -0.02364038f, -0.03402128f, 
    0.00829600f, 0.01178871f, 0.02739114f, -0.04574600f, -0.00608246f, 0.01988114f, 0.03028203f, 0.02202055f, 
    -0.00707628f, 0.02620424f, -0.04120065f, -0.02513002f, -0.02978427f, -0.00125520f, -0.03661429f, 0.01960599f, 
    0.01701577f, 0.03364738f, -0.02570510f, -0.01216560f, -0.01259851f, -0.03849227f, -0.02812901f, 0.02053794f, 
    -0.03362894f, -0.00256223f, 0.01152092f, 0.03060707f, 0.02565916f, 0.00112237f, 0.00927219f, -0.00925676f, 
    0.00414654f, -0.02066099f, -0.03021926f, -0.02217055f, -0.04789884f, 0.00404514f, 0.01814574f, 0.00582027f, 
    0.00536961f, 0.01411029f, -0.02765115f, -0.02725383f, -0.00704530f, -0.01046649f, 0.01723147f, -0.04904576f, 
    0.01951606f, 0.00672482f, -0.03046941f, -0.02046414f, -0.03007352f, 0.01894572f, 0.00616499f, -0.01236054f, 
    -0.03908082f, 0.01613883f, 0.02990284f, -0.03609779f, 0.00247279f, -0.04220399f, -0.01536067f, 0.01273656f, 
    0.03434148f, -0.00396661f, -0.00561823f, 0.02370164f, -0.03632570f, 0.02673301f, -0.01958789f, -0.02471728f, 
    0.02034320f, 0.02168339f, 0.01283901f, -0.01902674f, -0.03837420f, -0.02560575f, -0.03649971f, -0.00254198f, 
    0.02760452f, 0.00494037f, 0.01648634f, -0.02841449f, -0.00333506f, -0.00641207f, 0.01729404f, 0.00103141f, 
    0.02283658f, 0.00148899f, -0.01298604f, -0.00590943f, 0.00314714f, -0.00645550f, -0.02567461f, 0.00072925f, 
    0.02731869f, -0.01088845f, -0.01412911f, 0.03240767f, -0.04054369f, -0.04116357f, -0.03187258f, 0.01541488f, 
    -0.02098452f, -0.04025362f, -0.04138616f, -0.04327318f, -0.02839431f, -0.00943640f, -0.02952585f, -0.00926947f, 
    0.03152943f, -0.02879383f, -0.04077011f, 0.01777893f, 0.01522224f, -0.02955112f, -0.04171689f, 0.03098088f, 
    -0.02265135f, -0.03979494f, -0.00102999f, -0.03424104f, -0.04321812f, -0.01181682f, -0.01797870f, 0.00891214f, 
    0.02777121f, 0.01607496f, -0.00886785f, 0.02926104f, -0.00275966f, -0.04002598f, -0.04430200f, -0.03908557f, 
    -0.01015280f, -0.03607554f, 0.01094677f, -0.02870016f, 0.01743267f, -0.04708480f, 0.02588566f, 0.00710924f, 
    -0.02654354f, 0.03459524f, 0.00716190f, 0.00279418f, 0.00537717f, 0.03155426f, -0.01927418f, 0.00126691f, 
    0.00682685f, 0.01575287f, 0.00026403f, -0.00704684f, 0.02185693f, 0.02541106f, -0.00696882f, 0.01872871f, 
    0.04074832f, -0.02894972f, 0.00344364f, -0.02140343f, -0.01470405f, 0.01619148f, 0.00872685f, 0.01778740f, 
    0.00571442f, -0.04669588f, -0.02777681f, 0.02512085f, 0.01103594f, 0.00092317f, 0.01618384f, -0.00212659f, 
    0.00534738f, 0.00696374f, -0.01936530f, -0.00500672f, -0.02161236f, 0.01994850f, 0.03566684f, 0.01991575f, 
    -0.00976703f, -0.03364984f, -0.01701368f, 0.00853139f, 0.00704995f, -0.02764132f, -0.00970314f, 0.02709634f, 
    -0.00045069f, 0.00398851f, -0.02036084f, -0.00148945f, -0.02466565f, -0.03630777f, -0.03834471f, -0.02184176f, 
    0.00948209f, -0.01018566f, -0.02050661f, 0.01264308f, 0.02408566f, -0.01357451f, -0.04240058f, 0.01643576f, 
    -0.00380085f, 0.00304471f, -0.00427559f, -0.00119125f, 0.00512898f, -0.04667684f, 0.01635223f, -0.01491013f, 
    -0.03355151f, 0.01916073f, 0.00661715f, -0.00675748f, -0.00785290f, -0.00256135f, 0.01363074f, 0.01587326f, 
    0.01134835f, -0.01557002f, -0.01434622f, -0.01384305f, -0.01539453f, 0.00502497f, -0.00858619f, 0.02586287f, 
    0.00680824f, 0.03380810f, -0.02100861f, -0.03396140f, -0.01455570f, -0.00829006f, 0.00527569f, 0.01250824f, 
    -0.03914088f, -0.01511548f, -0.01061410f, -0.03765992f, 0.01239003f, 0.02961217f, 0.01728173f, 0.00726343f, 
    0.00174692f, -0.00117011f, -0.03429035f, -0.01076389f, -0.02706566f, -0.03712512f, -0.02754389f, -0.01246048f, 
    -0.02702107f, 0.01007100f, -0.02226352f, 0.00120503f, -0.00463476f, 0.00018816f, -0.02081435f, 0.02923142f, 
    -0.00175101f, -0.00560537f, -0.04359699f, -0.00656699f, -0.01065906f, -0.01396273f, -0.00911271f, -0.03387715f, 
    -0.00114138f, 0.00378225f, 0.01177566f, -0.03645011f, 0.00507819f, 0.00921866f, -0.00406621f, -0.00949551f, 
    -0.03797767f, -0.03921526f, -0.01212837f, -0.04788818f, -0.02820216f, -0.04247828f, -0.04162363f, -0.00658407f, 
    -0.00740658f, 0.02782445f, -0.01002598f, -0.04245258f, -0.03991241f, 0.02984590f, -0.02913496f, 0.01541300f, 
    -0.03182903f, 0.01979657f, 0.02832229f, -0.01526704f, -0.01198427f, 0.01926473f, 0.01782643f, 0.02094287f, 
    -0.02803612f, -0.03552081f, 0.02507921f, 0.00445597f, -0.00570431f, -0.02912201f, -0.03275760f, -0.02357801f, 
    0.02520452f, -0.00849495f, -0.01113554f, 0.00645945f, -0.03170883f, -0.02931931f, -0.03313345f, -0.00955268f, 
    0.03022576f, -0.00304434f, -0.02941763f, -0.00946512f, -0.00505348f, 0.02353856f, -0.02050354f, -0.01541013f, 
    0.03606930f, -0.01113344f, -0.00484799f, -0.00336044f, 0.02830090f, 0.00199407f, -0.04755063f, 0.00489652f, 
    0.02276064f, 0.01250253f, -0.01515936f, -0.03789849f, -0.02326665f, 0.00001719f, -0.01777380f, -0.03693491f, 
    -0.03092270f, -0.04077062f, -0.01001480f, -0.04567156f, 0.00912658f, 0.02732921f, -0.01719686f, -0.03774861f, 
    -0.03503748f, 0.01693213f, -0.02058553f, -0.01069625f, -0.03547456f, -0.04734871f, 0.02643997f, -0.02308664f, 
    0.03229352f, 0.01766610f, -0.01256000f, 0.00657403f, -0.01768039f, -0.01717485f, 0.02718844f, 0.00530999f, 
    -0.00032204f, 0.03144408f, -0.00706748f, 0.00009797f, -0.03055044f, -0.03081069f, 0.00218403f, -0.01879553f, 
    -0.03406977f, 0.02109184f, -0.01719048f, 0.02020312f, 0.03281855f, 0.03898675f, -0.04161335f, 0.02675421f, 
    -0.03725027f, -0.03794708f, 0.02549102f, -0.03756373f, -0.03169822f, -0.00359043f, -0.01006058f, -0.01108487f, 
    0.01231880f, 0.00589873f, -0.02954977f, -0.00537137f, 0.01685854f, 0.01460870f, -0.01973235f, -0.00270579f, 
    -0.04385093f, -0.02187320f, 0.01099685f, 0.02020919f, 0.00885028f, -0.02381244f, -0.04518417f, -0.02032389f, 
    -0.23855025f, 0.27151200f, -0.20032199f, 0.05258796f, -0.02768200f, 0.05156525f, -0.19836532f, 0.03116015f, 
    -0.13974583f, -0.34892505f, 0.04577725f, -0.11684072f, 0.00540485f, 0.08414712f, 0.08941384f, 0.01106672f, 
    -0.05165559f, -0.07414525f, -0.04923525f, -0.31912550f, -0.65911347f, -0.06036968f, 0.16525437f, -0.21909276f, 
    0.17797409f, -0.13860856f, 0.01026761f, -0.08226487f, -0.12532690f, -0.27707964f, -0.10371350f, 0.20682895f, 
    -0.06908669f, -0.09599384f, -0.01000660f, -0.09101318f, 0.27806029f, -0.01162753f, -0.22216347f, 0.11066319f, 
    0.32159477f, 0.00121278f, -0.14711517f, -0.04397296f, 0.16600773f, -0.01464671f, 0.05843687f, -0.13518424f, 
    -0.07379984f, -0.02209953f, 0.05231261f, 0.09847517f, 0.11511934f, 0.05689858f, 0.06917585f, 0.03773053f, 
    0.06663471f, 0.09083088f, 0.10871771f, 0.11408408f, 0.10916425f, 0.24138302f, 0.08840704f, 0.01035704f, 
    -0.01575341f, -0.09165624f, -0.06997102f, 0.08814047f, -0.15294945f, -0.12902254f, -0.16617136f, -0.16453554f, 
    0.05778079f, -0.04312100f, -0.05963716f, 0.12899704f, -0.03121638f, -0.40251759f, -0.01743292f, 0.14012523f, 
    0.06356097f, -0.10334500f, 0.05410982f, -0.10743960f, 0.09584222f, 0.07101663f, -0.05759057f, -0.06240402f, 
    -0.11088298f, 0.06687681f, -0.00957209f, -0.05922911f, 0.03381310f, 0.07071767f, 0.13683183f, 0.13168006f, 
    0.05944933f, 0.12630638f, 0.08297902f, 0.19327509f, 0.15558322f, 0.08958425f, -0.06580113f, 0.04076760f, 
    0.13551469f, 0.10514783f, 0.00715177f, 0.04907186f, -0.07236101f, 0.04478188f, -0.02926796f, -0.03126843f, 
    0.02037606f, 0.07262278f, 0.12490690f, -0.03766635f, 0.13287005f, 0.00090019f, 0.10188829f, 0.23978819f, 
    0.44424623f, -0.19555257f, 0.20680596f, -0.16690409f, -0.14965884f, 0.00116742f, 0.10536454f, 0.13609916f, 
    -0.04154432f, -0.30858824f, -0.03750926f, -0.06625872f, -0.05477309f, -0.03059686f, -0.00756329f, -0.02242894f, 
    0.06928234f, 0.00476293f, 0.05932995f, 0.14951840f, 0.23922093f, -0.33279294f, -0.21061879f, 0.16270714f, 
    -0.10929203f, -0.08514699f, 0.10582964f, -0.11728965f, -0.05488632f, 0.03375757f, 0.03191237f, -0.06253999f, 
    0.10087928f, 0.04324498f, 0.07144692f, 0.08138006f, 0.21253532f, 0.14925843f, 0.06638803f, 0.17732702f, 
    0.21246698f, 0.11544316f, 0.01632765f, 0.00162686f, 0.06424963f, -0.06692130f, 0.11749883f, 0.08089451f, 
    0.04898645f, 0.27208713f, 0.11515555f, -0.06463958f, 0.17970252f, -0.18102723f, -0.10366645f, -0.20017204f, 
    -0.18000352f, -0.02982386f, 0.01174432f, -0.11840691f, -0.07438224f, 0.08505216f, -0.01547660f, -0.06250909f, 
    0.09631718f, -0.01449193f, -0.11418161f, 0.10746876f, 0.03470692f, 0.11924044f, -0.16249819f, 0.07900864f, 
    -0.06452744f, -0.11994975f, -0.11034235f, -0.02594504f, 0.08248985f, -0.04501551f, 0.03212532f, 0.05053715f, 
    0.07436129f, 0.11732076f, -0.14630605f, -0.19469416f, 0.10031464f, -0.00841431f, 0.00479852f, -0.01657886f, 
    -0.00589596f, 0.06365319f, -0.07780852f, -0.02960837f, -0.09997767f, 0.02559232f, -0.08777312f, -0.05803352f, 
    -0.17409013f, -0.10015748f, -0.09692897f, -0.22958818f, -0.49657238f, 0.47708851f, 0.26474455f, -0.05084791f, 
    -0.41347051f, 0.07556479f, -0.23561904f, 0.38235506f, -0.01325620f, 0.04734711f, 0.04050273f, 0.07677269f, 
    -0.23831329f, -0.09344646f, -0.04281056f, -0.11406382f, 0.04912240f, -0.07519910f, -0.11078394f, -0.25854632f, 
    0.18948229f, 0.01624557f, -0.01730966f, -0.09563897f, 0.20401640f, 0.01706748f, 0.12066317f, 0.00280419f, 
    0.11904173f, 0.31990948f, -0.05935613f, -0.03802536f, -0.03569144f, -0.03837892f, -0.02712721f, -0.04287504f, 
    0.01448848f, 0.10458890f, 0.08593751f, 0.04846029f, 0.51656294f, -0.07101368f, -0.43138185f, 0.12293579f, 
    0.25803167f, 0.11524203f, 0.05476880f, -0.20182124f, -0.17518768f, -0.10106871f, -0.03310021f, -0.07160659f, 
    -0.00637411f, 0.13011643f, 0.07427926f, -0.05321745f, 0.11966935f, 0.01269558f, 0.07329100f, 0.10928774f, 
    0.25499618f, 0.09942464f, -0.12911339f, -0.15365171f, 0.09115602f, -0.10888773f, 0.09386123f, -0.06824181f, 
    -0.01142758f, 0.13387521f, -0.01192397f, 0.02156576f, -0.00780188f, -0.12320346f, 0.02539907f, -0.13325368f, 
    -0.03843015f, 0.16492940f, 0.04890578f, 0.06947867f, -0.11685317f, 0.15937069f, 0.06772013f, 0.15913518f, 
    -0.24340943f, 0.06272820f, -0.12073393f, 0.10175250f, -0.14932379f, -0.33524218f, -0.04937865f, -0.05961137f, 
    -0.03804689f, -0.04457953f, 0.06437168f, -0.10949354f, 0.09989861f, -0.00854495f, 0.00657044f, -0.02871844f, 
    0.25036600f, -0.02662813f, -0.03514692f, 0.03063080f, 0.15205781f, 0.10426173f, -0.04148391f, -0.07747488f, 
    -0.13291255f, -0.20335962f, -0.02899685f, -0.00596385f, 0.04411406f, 0.06842828f, 0.10767425f, 0.12822260f, 
    -0.07038209f, 0.03710547f, 0.00326668f, 0.11183625f, -0.03672186f, 0.11407058f, -0.06282113f, -0.47908729f, 
    -0.26405835f, -0.09917007f, -0.11043376f, 0.17567533f, -0.20584832f, -0.55478692f, 0.16236459f, 0.18556058f, 
    0.02737173f, -0.10898662f, -0.07598016f, -0.19182658f, 0.06390678f, 0.19567055f, -0.06117836f, -0.44405422f, 
    -0.06290757f, 0.02061435f, -0.04209834f, 0.12706436f, -0.16090325f, 0.13843411f, -0.12499255f, 0.12186775f, 
    0.13361995f, 0.15001369f, 0.06619189f, -0.03134668f, 0.03665401f, 0.11745633f, 0.07875948f, -0.03747416f, 
    0.21737313f, 0.10962906f, 0.11155768f, 0.17244127f, -0.02906804f, -0.09970631f, 0.37233138f, -0.10448424f, 
    0.12394121f, -0.10883854f, 0.00167886f, -0.10530126f, -0.12142283f, -0.14392264f, -0.12694822f, -0.04097078f, 
    -0.04624765f, -0.04068929f, 0.02751481f, -0.04878562f, -0.10338774f, -0.13052411f, -0.01059278f, -0.00380549f, 
    0.22313510f, 0.16880547f, -0.14058110f, -0.02612809f, 0.21080363f, 0.00518295f, 0.08231050f, -0.05376212f, 
    0.12296399f, 0.33766270f, 0.10624791f, -0.01345162f, 0.05128292f, -0.04425527f, -0.21124353f, 0.02646614f, 
    -0.04676697f, -0.07971873f, -0.14597823f, 0.11177008f, 0.24109897f, 0.28810868f, 0.04795570f, 0.16846780f, 
    -0.04540395f, -0.02283473f, -0.13188705f, 0.07158805f, -0.30197406f, -0.51980716f, -0.00165108f, 0.02975012f, 
    -0.05207597f, 0.02770988f, 0.22212078f, 0.14225382f, -0.06724752f, 0.06517433f, 0.13562979f, -0.22804055f, 
    -0.33532602f, -0.23452802f, 0.35429445f, 0.05498991f, 0.16327618f, -0.16285038f, 0.02888821f, -0.02471900f, 
    -0.07046866f, -0.14774901f, -0.08887916f, -0.03117698f, -0.21259703f, -0.07620543f, -0.10596789f, 0.07945666f, 
    0.07074847f, 0.03810006f, -0.06078868f, 0.02103481f, 0.10045468f, 0.41557705f, 0.32469988f, -0.06914970f, 
    0.13725425f, -0.23538369f, 0.07070059f, 0.08122940f, -0.03467547f, -0.04575221f, 0.04591727f, -0.16299431f, 
    0.02849491f, -0.11184262f, -0.07984814f, 0.08364069f, 0.09631251f, 0.02827436f, 0.08035691f, 0.08016775f, 
    -0.08634789f, 0.21129231f, -0.16493434f, 0.16688775f, 0.09239704f, -0.16523296f, 0.02676045f, 0.02356881f, 
    0.05042810f, -0.08884750f, 0.00722818f, -0.10111604f, -0.00889495f, -0.01880207f, -0.06989425f, 0.16119663f, 
    0.13061491f, -0.02861375f, 0.15309241f, 0.04256592f, -0.09057587f, 0.25630954f, 0.29973167f, -0.05442837f, 
    -0.02307993f, -0.12000019f, -0.01182238f, -0.13783309f, -0.00927381f, 0.07932334f, 0.24139571f, 0.02265511f, 
    -0.03287759f, -0.10087381f, 0.01184149f, -0.21131217f, -0.45042938f, -0.41260061f, -0.09598901f, -0.45425478f, 
    0.21298805f, 0.13166586f, 0.10441522f, -0.18663219f, 0.12211175f, 0.00000844f, -0.02885903f, 0.01318925f, 
    0.03791220f, -0.10087699f, 0.01810283f, 0.13284741f, 0.07321245f, -0.07956902f, 0.11062919f, 0.02114890f, 
    -0.14968203f, -0.11395601f, -0.11788899f, -0.12153403f, 0.19869350f, 0.16141237f, 0.04152682f, -0.19707115f, 
    -0.00273755f, -0.08823365f, -0.11163558f, -0.13671552f, -0.27851453f, -0.09201652f, 0.00100967f, -0.03351101f, 
    -0.07788839f, -0.09855241f, -0.04790837f, -0.00957522f, -0.13231903f, -0.17782526f, -0.09858023f, -0.18635915f, 
    0.14774767f, 0.53152966f, -0.03426952f, -0.10361913f, 0.13509947f, 0.02657104f, 0.12469469f, -0.05860618f, 
    0.02821989f, -0.53309190f, 0.02068652f, 0.04313868f, 0.07242833f, -0.06554731f, 0.07675598f, -0.09645263f, 
    0.13974026f, -0.13580751f, 0.09825104f, -0.07975165f, 0.12364659f, 0.48564413f, -0.02840562f, -0.10571189f, 
    0.04320343f, -0.02940378f, -0.10030204f, -0.07953653f, -0.04073562f, -0.33860040f, 0.01652276f, -0.07666720f, 
    -0.00601503f, -0.01625910f, -0.04961658f, -0.16002099f, 0.11297592f, -0.19158477f, 0.01931859f, -0.10417826f, 
    0.22479144f, 0.01600705f, -0.12500207f, -0.22100851f, 0.31058478f, 0.06539079f, 0.12450217f, -0.10854223f, 
    0.07676218f, 0.05690353f, 0.01760838f, 0.06392090f, 0.16596317f, 0.10594602f, -0.06559147f, 0.05650852f, 
    -0.08834077f, 0.00671060f, 0.05196330f, -0.00841938f, -0.27134722f, 0.25526932f, 0.48236006f, 0.18077546f, 
    0.21201733f, -0.04446904f, 0.04559311f, 0.05639527f, 0.03357915f, -0.07193415f, 0.04141341f, -0.14672531f, 
    0.01949566f, -0.11274121f, -0.01574315f, 0.06259109f, 0.22678572f, 0.01972710f, 0.17558825f, -0.04035692f, 
    -0.03890555f, 0.28056303f, 0.13616143f, 0.09980453f, -0.12083951f, -0.10032302f, -0.11045381f, 0.02572966f, 
    -0.05562736f, -0.03240186f, 0.14605236f, 0.04736767f, -0.07653378f, 0.10331287f, 0.04712441f, -0.09520071f, 
    0.03785677f, -0.03248582f, 0.09996490f, -0.02934967f, 0.75032198f, -0.13560773f, 0.03493361f, -0.16837201f, 
    0.54141510f, 0.16378547f, -0.01719181f, -0.15695684f, 0.21124652f, 0.05630539f, 0.16698915f, 0.15264584f, 
    0.11246151f, -0.17037141f, 0.29807359f, -0.03118294f, 0.11811985f, 0.15346965f, -0.20373906f, 0.04589446f, 
    0.42235970f, -0.30446482f, -0.63661629f, -0.09509514f, 0.27422816f, 0.00398927f, -0.14581075f, -0.05636672f, 
    0.14876978f, 0.06276749f, -0.03423371f, 0.01544721f, -0.06431870f, -0.19254078f, -0.13196817f, 0.03357972f, 
    -0.05373130f, -0.15372449f, 0.04988234f, 0.08540404f, 0.27680025f, 0.02394332f, 0.19216943f, 0.03912530f, 
    -0.20745604f, 0.03901733f, -0.02686107f, 0.02092515f, 0.08348715f, -0.21141306f, 0.10044628f, -0.12731037f, 
    -0.04297831f, -0.23793213f, 0.00755238f, -0.15186426f, -0.12640485f, -0.01527914f, 0.09647073f, -0.05088015f, 
    0.16007045f, -0.43476102f, -0.50793386f, 0.04993831f, 0.55773902f, 0.03533826f, -0.06920174f, 0.09175230f, 
    0.04690852f, 0.10294475f, -0.00247257f, 0.03839615f, -0.13009602f, -0.06292388f, -0.11181647f, -0.04737202f, 
    -0.00005150f, -0.02251900f, -0.15427242f, 0.01445295f, 0.49763688f, -0.50588906f, -0.53095740f, -0.24050485f, 
    0.14932124f, -0.18032204f, -0.11552430f, 0.00517512f, 0.23273683f, -0.03718396f, -0.02040331f, 0.00643822f, 
    -0.12973022f, -0.04830333f, -0.06634235f, -0.00259177f, -0.03079289f, -0.07394207f, 0.02456865f, -0.06691349f, 
    0.60815543f, 0.10800095f, 0.15663050f, 0.10674778f, -0.17392933f, -0.10978243f, 0.33280018f, 0.03659263f, 
    0.05675037f, -0.00275363f, -0.05737282f, -0.02905399f, -0.01003975f, 0.00508271f, 0.29386094f, 0.14416067f, 
    -0.15742312f, -0.03759861f, 0.06161737f, -0.29401338f, -0.11395893f, -0.38266885f, -0.16571683f, 0.04103539f, 
    0.17589624f, -0.21442497f, -0.02173465f, 0.22381893f, -0.08701382f, 0.00570681f, -0.05870835f, 0.05818122f, 
    -0.13844287f, 0.11652889f, -0.04226240f, 0.05716437f, -0.02046801f, -0.01498043f, -0.06863346f, 0.07811259f, 
    0.03475181f, 0.00744245f, -0.17083660f, 0.02659633f, 0.07738949f, 0.18379954f, -0.03180681f, 0.05130368f, 
    0.02384165f, 0.05833288f, -0.01285773f, 0.12383872f, -0.01522606f, -0.02172987f, 0.07080564f, 0.01415841f, 
    0.01935020f, -0.08890820f, -0.09322291f, -0.04816570f, 0.20761165f, -0.10275611f, -0.16591054f, 0.03617277f, 
    0.09877615f, 0.21645027f, 0.27203825f, 0.10275384f, -0.02398992f, 0.15403934f, 0.05099126f, -0.03502103f, 
    -0.02073506f, -0.00610807f, -0.05356743f, 0.01559546f, 0.18728694f, 0.03140559f, -0.15042292f, -0.15526956f, 
    -0.04906375f, -0.04111309f, -0.04912218f, -0.18268031f, 0.01261556f, 0.20085299f, 0.09723219f, 0.00598359f, 
    0.06349602f, 0.11277013f, -0.08925179f, 0.03306900f, 0.09931288f, 0.01714305f, 0.07074680f, -0.05662471f, 
    0.14044540f, -0.03747483f, -0.07333317f, 0.21838732f, 0.02251931f, -0.03281537f, 0.37016058f, 0.10297185f, 
    -0.08187266f, -0.31339961f, 0.20789488f, 0.01499774f, -0.17394446f, 0.10564907f, 0.01181491f, 0.08059578f, 
    0.02340741f, 0.22207284f, -0.00936017f, -0.00052104f, 0.21140876f, 0.04753368f, -0.07906131f, 0.04136182f, 
    -0.16396388f, -0.03968529f, -0.27602032f, -0.02126338f, -0.14226693f, 0.20815553f, 0.10369746f, -0.06001633f, 
    -0.02790047f, 0.03941043f, -0.07283363f, -0.10053795f, -0.06413209f, -0.09832428f, -0.05373400f, -0.06544533f, 
    0.05079597f, 0.02747087f, -0.06809533f, -0.10082503f, 0.53169203f, -0.35144213f, -0.18951564f, 0.05155947f, 
    0.02473018f, -0.23076536f, -0.03938682f, -0.01916820f, 0.01941539f, -0.06082921f, 0.03564385f, -0.07899244f, 
    0.11264788f, -0.02104463f, -0.12903106f, -0.07045876f, 0.08716311f, 0.00723880f, 0.02711839f, 0.06887901f, 
    0.26479858f, -0.06458017f, -0.30536196f, -0.16838717f, 0.13700350f, 0.14503111f, -0.08568497f, -0.03733501f, 
    0.09057774f, 0.19919278f, 0.04270145f, 0.06991313f, -0.05875755f, -0.14348224f, -0.02907841f, -0.04471229f, 
    0.00558585f, -0.09478632f, -0.03439613f, 0.02729524f, 0.14806469f, 0.24656163f, 0.21683800f, 0.08927979f, 
    -0.17586611f, -0.25792962f, -0.01783186f, -0.02650782f, -0.02790741f, -0.07560776f, 0.03762328f, 0.05521713f, 
    0.00869830f, 0.10447718f, 0.06247310f, -0.03276166f, 0.05094455f, 0.07596136f, -0.08440289f, -0.05067380f, 
    0.20826074f, -0.47030136f, -0.56817698f, -0.28920007f, 0.15339537f, -0.12452441f, 0.10782636f, 0.25898159f, 
    0.14224780f, -0.08982086f, -0.02395713f, -0.01541039f, -0.09498109f, 0.06357463f, -0.02899943f, -0.01277705f, 
    -0.03191502f, 0.04442677f, 0.00977003f, -0.09279528f, 0.10386845f, 0.03603818f, 0.07160313f, -0.04421616f, 
    0.02593825f, -0.00758866f, -0.01136507f, -0.09000082f, -0.03192165f, -0.03266007f, 0.13035963f, -0.04196621f, 
    -0.13845798f, -0.01678981f, -0.00231779f, -0.14651160f, -0.09192692f, 0.05007879f, 0.08476937f, 0.00343707f, 
    0.09628920f, 0.11051046f, 0.22665192f, 0.27587670f, 0.16052780f, 0.01538440f, -0.04712252f, 0.02893862f, 
    -0.04776338f, -0.01684579f, 0.28728205f, 0.15804337f, -0.02678129f, 0.20066991f, 0.07986048f, -0.03845166f, 
    -0.06099723f, -0.18592395f, -0.14747012f, -0.00436745f, 0.09081946f, 0.11522253f, 0.16920674f, -0.00766515f, 
    0.07026693f, -0.01381310f, -0.05868498f, -0.08038823f, -0.03114542f, -0.05971010f, 0.30539247f, 0.15111481f, 
    -0.03751841f, 0.07324068f, 0.15183826f, 0.05967581f, 0.00358921f, 0.00753135f, 0.02504848f, 0.03214267f, 
    -0.15254414f, -0.03733526f, -0.02960395f, 0.18712506f, -0.30189940f, 0.07263603f, 0.08228907f, -0.02740888f, 
    0.01924573f, -0.07441246f, -0.11439911f, -0.08926494f, -0.00767291f, 0.02382518f, 0.07672849f, -0.00005690f, 
    0.05338951f, -0.00503126f, -0.08039007f, -0.13377419f, 0.24981330f, -0.15262505f, -0.07589252f, -0.13258517f, 
    0.02375577f, -0.10309979f, 0.01151625f, 0.12498021f, -0.14982633f, 0.10619028f, 0.24553242f, 0.08892406f, 
    -0.05121575f, 0.15845777f, -0.19500035f, -0.09954327f, 0.04433528f, -0.03847077f, 0.12042248f, -0.05974788f, 
    0.29176462f, 0.22864276f, 0.10073388f, 0.12321940f, 0.27213815f, -0.02298558f, -0.11866008f, -0.09964668f, 
    0.04782075f, -0.04578293f, 0.10457279f, 0.05748295f, 0.06413327f, -0.09940735f, 0.04226493f, -0.01887001f, 
    -0.11215895f, -0.09974446f, 0.17316008f, -0.02510512f, 0.23564562f, 0.27679369f, 0.14748597f, 0.07791417f, 
    -0.05993938f, -0.30455413f, -0.04759176f, 0.00323864f, -0.08568581f, -0.05855635f, 0.02014275f, 0.01106467f, 
    0.09599228f, -0.00713757f, -0.01157932f, 0.15639797f, 0.22336788f, -0.23112829f, -0.01525118f, -0.05375162f, 
    0.18389040f, 0.17658293f, 0.07704247f, 0.08108140f, 0.04100520f, -0.09257689f, -0.08313750f, -0.05651924f, 
    -0.04130450f, -0.15402858f, 0.05632665f, 0.04412385f, 0.11612678f, -0.01263794f, 0.01146340f, -0.08653889f, 
    0.00797086f, 0.06027398f, 0.10803630f, 0.00962932f, -0.01513389f, -0.19685712f, -0.08702265f, 0.01611963f, 
    -0.09998453f, 0.04047667f, 0.02245700f, 0.03389530f, -0.00324800f, -0.01470217f, -0.01876710f, -0.00475154f, 
    0.10431679f, 0.04821545f, -0.01789272f, -0.10558882f, 0.08283413f, 0.02218701f, 0.17361175f, 0.17315631f, 
    -0.01124668f, -0.28696015f, -0.57583857f, -0.11960846f, 0.01764901f, 0.02924868f, 0.23237248f, 0.05594410f, 
    0.06108258f, -0.03961530f, -0.03966547f, -0.04188913f, -0.04588916f, 0.07687479f, -0.02891595f, -0.00968092f, 
    0.01713189f, 0.03176930f, -0.24473099f, 0.06761502f, 0.25166088f, 0.16820674f, -0.00909532f, 0.06246204f, 
    -0.03065496f, -0.00376259f, -0.09251069f, 0.20860635f, 0.07767868f, -0.20908363f, -0.02541925f, 0.18314703f, 
    0.21123759f, 0.05223737f, 0.07254115f, 0.27017578f, 0.10184660f, 0.20251347f, -0.04405410f, 0.05023681f, 
    0.51711351f, -0.10291480f, -0.18554464f, -0.14929497f, -0.07986661f, -0.20807903f, -0.12164957f, -0.00035531f, 
    -0.00310000f, -0.02166961f, 0.03292460f, -0.05020861f, 0.07114335f, -0.01862796f, -0.11142719f, -0.03331106f, 
    -0.01029255f, -0.06248541f, 0.12252479f, -0.04971062f, 0.17190158f, 0.04458550f, 0.02694811f, -0.04859369f, 
    -0.16422501f, -0.05227070f, -0.05537059f, 0.03330698f, 0.06611782f, -0.11743993f, 0.05219085f, -0.00187438f, 
    0.08273881f, 0.04273609f, 0.05037931f, -0.02487104f, 0.03320836f, -0.02551057f, 0.11540182f, 0.01686336f, 
    0.17361946f, 0.24558185f, -0.36865494f, -0.31221330f, 0.04085521f, 0.09148628f, 0.04337994f, 0.10321879f, 
    0.10192505f, 0.03561529f, -0.12165260f, -0.04799192f, 0.03461597f, -0.03323505f, 0.07088622f, -0.06149216f, 
    0.00629328f, 0.00997341f, -0.13116743f, 0.07332992f, 0.09601680f, 0.33894044f, 0.14154090f, 0.16990182f, 
    0.06541893f, -0.19984654f, -0.12508066f, 0.00350130f, -0.09785534f, -0.05266260f, -0.03117030f, -0.00460424f, 
    0.09202652f, 0.03533559f, 0.04896744f, 0.19495624f, 0.02342617f, -0.20791948f, -0.11229715f, -0.00217795f, 
    -0.01487784f, 0.00209039f, -0.03788084f, 0.01617981f, -0.00857957f, 0.00328507f, 0.02648954f, 0.00940995f, 
    0.02633741f, -0.01828765f, -0.02605593f, -0.02683089f, -0.01628281f, -0.04602487f, -0.03542793f, 0.01257871f, 
    -0.02063446f, -0.01621594f, -0.00983444f, 0.01546928f, 0.01359045f, 0.00392163f, -0.03531200f, -0.00230170f, 
    -0.03540098f, -0.04224385f, -0.03817387f, -0.00498194f, -0.00908204f, 0.03144172f, -0.00112475f, 0.02017445f, 
    -0.03330870f, -0.02180725f, -0.00881884f, -0.04235111f, -0.01657280f, 0.02562926f, 0.02546274f, 0.01795320f, 
    -0.02581509f, 0.01816295f, -0.02187310f, -0.03489791f, 0.01587556f, -0.00424424f, -0.00652434f, 0.00798427f, 
    -0.01818559f, 0.00409949f, 0.02923404f, -0.03404239f, -0.01026354f, 0.02271409f, -0.01271629f, -0.01448147f, 
    -0.03866473f, -0.04305929f, -0.00610059f, -0.01640288f, 0.01420320f, -0.03036028f, -0.01398910f, -0.01987975f, 
    0.00513171f, 0.00601145f, 0.00806910f, 0.02493360f, -0.03633830f, -0.00149095f, -0.01102159f, -0.04014504f, 
    0.02238423f, -0.00849935f, -0.03450000f, -0.01540043f, -0.02011996f, 0.01420318f, -0.01497410f, 0.00389826f, 
    0.02248284f, -0.03185482f, 0.02914137f, 0.00830821f, -0.02055888f, -0.04461289f, -0.01093270f, 0.03082767f, 
    0.01764461f, -0.04323985f, 0.01013024f, -0.04264868f, 0.00597523f, -0.03082571f, -0.00017842f, -0.03479312f, 
    0.03197017f, 0.00657453f, 0.03001786f, -0.01265471f, 0.02497313f, -0.02954951f, -0.04224502f, -0.01795872f, 
    0.01008858f, -0.02418047f, 0.01232778f, 0.00883158f, 0.02451705f, 0.00867221f, -0.01401113f, 0.00722240f, 
    0.02469042f, -0.02973826f, -0.00152939f, 0.00717729f, 0.02285380f, -0.03739388f, 0.00156569f, -0.04158499f, 
    0.02178742f, -0.02539285f, 0.00085776f, 0.03257637f, 0.02417202f, -0.04145293f, -0.00165511f, -0.02493536f, 
    -0.04089980f, -0.03053249f, -0.03068142f, 0.00537165f, 0.00329246f, 0.00494636f, 0.01223723f, -0.00799290f, 
    -0.03516771f, -0.03286166f, -0.03386018f, 0.02486471f, -0.03763713f, 0.00983782f, 0.01127327f, 0.02651337f, 
    -0.00318689f, 0.00405706f, -0.03703239f, -0.04219937f, -0.02179940f, -0.00477362f, -0.01592653f, -0.01050883f, 
    -0.02435691f, -0.04540037f, 0.01685115f, -0.02379984f, 0.01602091f, 0.02648363f, -0.02615912f, -0.03827324f, 
    0.02629228f, 0.02712938f, -0.00714127f, -0.03118097f, 0.02973572f, -0.01845347f, -0.02306215f, -0.03091529f, 
    -0.01581061f, 0.03003617f, -0.00172077f, 0.00947764f, 0.00887731f, -0.02691146f, -0.02259999f, 0.00984559f, 
    -0.00405434f, 0.01647087f, 0.01615639f, -0.03660692f, -0.03280321f, 0.00833571f, -0.01900079f, -0.02826473f, 
    0.02466581f, 0.01634754f, -0.00858800f, -0.03522206f, -0.01139604f, -0.01124976f, -0.04126507f, 0.03394509f, 
    0.01590559f, -0.04052038f, 0.01882681f, -0.03813846f, -0.03528180f, -0.04317896f, -0.00809130f, -0.01864405f, 
    -0.00797711f, 0.01302070f, 0.01553945f, 0.02901128f, -0.03469945f, -0.01710982f, -0.03867567f, 0.00637329f, 
    0.02707884f, 0.00565204f, 0.02811371f, -0.01427461f, 0.00792444f, 0.01146672f, 0.01395238f, 0.02917610f, 
    -0.04117646f, 0.00265390f, -0.01234782f, -0.03338924f, -0.02062784f, -0.00559462f, -0.04175910f, 0.02324380f, 
    0.00306000f, -0.01049799f, -0.04402813f, -0.00252317f, -0.00750033f, -0.02998054f, 0.03509951f, 0.01018903f, 
    0.00001562f, 0.02554782f, 0.01395482f, -0.04431175f, 0.01204932f, -0.01378459f, -0.04518568f, 0.01040702f, 
    0.01733776f, -0.04408823f, -0.03013566f, 0.00837133f, -0.02628580f, -0.02168173f, -0.03078331f, -0.00889961f, 
    -0.01644087f, -0.00790414f, -0.02516308f, 0.00503773f, -0.02377038f, 0.01633580f, -0.00307776f, 0.01083445f, 
    -0.03477367f, -0.01659140f, -0.04406543f, -0.02824676f, 0.03760357f, -0.01665285f, 0.01156012f, -0.02947418f, 
    0.01560779f, 0.02601895f, 0.00479418f, -0.02761786f, -0.01504985f, 0.00638297f, -0.00971472f, -0.00302842f, 
    0.01706335f, -0.01467662f, -0.02117611f, -0.01258919f, -0.02060777f, -0.00837436f, 0.02063480f, 0.02994572f, 
    -0.01363839f, 0.01766877f, -0.02106056f, 0.02552618f, -0.02796449f, 0.00982516f, -0.00299070f, 0.01284916f, 
    -0.04018535f, -0.03948190f, -0.03059440f, 0.00399269f, 0.03374013f, 0.02776358f, 0.03390558f, -0.00075918f, 
    0.01526314f, -0.01693548f, -0.02200343f, -0.00420105f, -0.01749562f, -0.00857428f, 0.02956926f, 0.02127789f, 
    0.02621710f, 0.01180420f, 0.01365801f, -0.00066451f, -0.02270573f, -0.02936718f, 0.00825033f, -0.02970074f, 
    -0.01473834f, 0.00975737f, -0.00746967f, -0.03729120f, -0.03470584f, -0.03540099f, -0.02890179f, -0.04724484f, 
    -0.02492574f, -0.00008774f, -0.00302963f, -0.01683137f, 0.01757627f, 0.01925020f, 0.02693977f, 0.01619094f, 
    0.00489863f, -0.02209728f, -0.00823792f, 0.00316465f, -0.03438176f, -0.01340303f, 0.00981665f, 0.03294213f, 
    0.02532431f, 0.02119217f, -0.04376667f, 0.00566256f, -0.03939073f, -0.00787286f, -0.01467692f, -0.00344001f, 
    -0.04290280f, -0.02569908f, -0.04557514f, -0.03146507f, 0.01447258f, -0.04370731f, -0.01536971f, 0.00355994f, 
    0.00286999f, -0.03179912f, -0.02584934f, -0.03312191f, 0.00908288f, 0.01870769f, -0.00295573f, -0.03015941f, 
    -0.03611644f, -0.04134478f, -0.04124358f, -0.03558531f, -0.03037238f, -0.01067837f, -0.01094489f, -0.03101926f, 
    0.00909952f, -0.03372354f, -0.00706297f, -0.03601026f, 0.01973448f, 0.01392683f, 0.01569623f, -0.00391548f, 
    -0.00337670f, 0.00055062f, -0.03326882f, -0.01713879f, -0.00965249f, 0.02294686f, 0.03252545f, -0.03660616f, 
    0.00246622f, -0.00757271f, 0.02195964f, -0.00689674f, 0.01136753f, -0.02161955f, -0.01340915f, -0.01024675f, 
    -0.04349402f, -0.00407962f, 0.00462046f, -0.00831922f, -0.00350594f, 0.02704781f, 0.02177384f, 0.01805206f, 
    -0.02912914f, -0.01281635f, -0.02124274f, 0.02039844f, -0.03983967f, 0.02335832f, -0.02103672f, -0.03867412f, 
    -0.03961862f, -0.00664331f, -0.03853573f, -0.02655116f, 0.00814066f, 0.02839860f, -0.01353356f, 0.00937513f, 
    0.00476674f, 0.02768496f, -0.03478822f, 0.00813253f, 0.01402879f, 0.01287497f, -0.02301416f, -0.01796230f, 
    -0.02392829f, -0.01122170f, -0.01044574f, 0.03473113f, 0.00875027f, 0.00023637f, -0.01526513f, -0.00197521f, 
    -0.04390411f, -0.00398306f, 0.01965878f, -0.03765893f, -0.01439934f, 0.02344142f, -0.00439491f, -0.03074405f, 
    -0.02004552f, 0.00211531f, 0.00267471f, -0.01001007f, -0.00989766f, 0.02026594f, 0.00301521f, 0.00346848f, 
    0.00193144f, -0.00492720f, -0.03727645f, -0.03036347f, -0.01676241f, -0.01440457f, -0.02279370f, -0.00306294f, 
    -0.03761910f, -0.00908798f, 0.00768525f, 0.02638530f, -0.02729088f, 0.01871780f, -0.01480035f, -0.02562665f, 
    0.01981606f, 0.02684664f, -0.03877845f, -0.00493259f, -0.00771823f, -0.03224253f, 0.02194935f, 0.00604545f, 
    0.00066082f, -0.02199064f, -0.04460932f, -0.01555394f, -0.02421842f, 0.00335673f, 0.02956630f, -0.00563363f, 
    0.00049514f, -0.03518060f, -0.03199589f, 0.00968537f, 0.00285931f, -0.00059060f, -0.01199711f, -0.01091943f, 
    -0.01037480f, -0.01042345f, 0.01702856f, -0.00238671f, 0.01265417f, -0.02416159f, -0.04078736f, 0.00273843f, 
    -0.02468526f, 0.03049350f, -0.03890411f, -0.02047729f, 0.00315539f, -0.03780003f, -0.03115353f, -0.02592712f, 
    -0.01898376f, 0.01826361f, 0.01897481f, -0.01646144f, -0.00114218f, 0.02536234f, -0.00779193f, -0.03609236f, 
    -0.01127483f, 0.02657956f, -0.01570966f, 0.01401313f, 0.02874210f, -0.02637758f, -0.00337396f, 0.00803495f, 
    -0.04091916f, -0.04364852f, 0.03152215f, -0.03906197f, 0.01769725f, -0.02907540f, 0.01495851f, -0.00562465f, 
    -0.03615934f, 0.00523825f, 0.00343920f, -0.03980823f, 0.03446409f, -0.00795644f, -0.01745108f, 0.02058388f, 
    -0.00144526f, -0.02905848f, -0.04101688f, -0.01365557f, 0.02517998f, -0.02840986f, -0.01395247f, -0.03394402f, 
    -0.00105861f, 0.03104181f, 0.00685753f, -0.03247654f, 0.00944629f, 0.02923241f, -0.02752603f, 0.02432708f, 
    -0.00339710f, 0.01628900f, 0.01027928f, -0.02940252f, -0.02117314f, 0.02135808f, -0.00732616f, -0.01314475f, 
    -0.00790270f, -0.04313381f, -0.03703774f, 0.00086091f, -0.02888825f, -0.03032456f, 0.01948318f, -0.02111332f, 
    0.02417159f, 0.01545338f, 0.02617194f, -0.03198657f, -0.03881477f, 0.00069727f, 0.00179690f, 0.03355440f, 
    -0.00996475f, 0.00316119f, -0.01525685f, -0.02892211f, -0.01195710f, -0.01801517f, -0.02687603f, -0.00668302f, 
    0.03530838f, -0.03174501f, 0.00002440f, -0.04059479f, -0.02231315f, 0.01642280f, -0.04091764f, 0.01823678f, 
    0.01149671f, -0.04281263f, 0.00797179f, -0.02597158f, -0.01719682f, 0.00638322f, 0.00605624f, 0.01475543f, 
    0.01032237f, -0.04226343f, -0.01701177f, 0.01551375f, -0.00634448f, 0.00058395f, -0.00177228f, -0.03210811f, 
    -0.02067095f, 0.02619518f, -0.03013712f, 0.02413217f, 0.01110117f, -0.00898835f, 0.00617595f, 0.00636487f, 
    -0.02732708f, -0.00764377f, 0.02672187f, -0.01931318f, 0.00275235f, 0.02744931f, -0.00419152f, -0.01247730f, 
    0.02336457f, 0.01657973f, -0.02562705f, 0.00503651f, 0.00270470f, -0.02598125f, -0.01518083f, 0.01865074f, 
    0.00679456f, 0.00695100f, -0.01572136f, 0.02310554f, -0.03044390f, -0.02572314f, 0.00077435f, 0.01718071f, 
    0.08618187f, -0.04689877f, -0.06520222f, 0.11371418f, 0.18051834f, -0.06894782f, -0.19558220f, -0.09037627f, 
    -0.22178108f, -0.21841978f, 0.08974756f, 0.01850545f, 0.09127208f, 0.13358316f, 0.00263073f, 0.12320727f, 
    -0.10599189f, -0.02957506f, -0.22727498f, -0.04193775f, -0.43717083f, 0.21369706f, 0.46695003f, -0.08042673f, 
    0.21682122f, -0.08865496f, 0.23867288f, -0.09648515f, -0.18016347f, 0.12154274f, 0.01731422f, 0.11818298f, 
    0.30393404f, 0.26374453f, 0.10948388f, 0.25578487f, 0.28300798f, 0.09395695f, 0.09852991f, -0.19320060f, 
    0.11092190f, 0.21806633f, 0.24406959f, -0.01272822f, 0.00837976f, 0.09873462f, 0.08859856f, 0.07962390f, 
    0.14829436f, 0.10924557f, -0.05935967f, -0.03661343f, 0.00856895f, 0.16811489f, 0.18252838f, -0.00712101f, 
    -0.05957029f, 0.15441546f, 0.02287172f, 0.06858599f, -0.15639654f, 0.34192374f, -0.12620094f, 0.00718814f, 
    0.15477456f, 0.05405037f, 0.15428144f, -0.12691572f, -0.09120008f, -0.09979952f, 0.18843074f, 0.03636085f, 
    -0.06017767f, -0.01126758f, 0.02781666f, 0.03023704f, 0.11660848f, -0.09944021f, 0.07054023f, -0.11468982f, 
    0.27336121f, 0.15563990f, 0.13971871f, -0.19081399f, 0.04326576f, 0.20017403f, 0.01958792f, 0.09066053f, 
    0.14987063f, 0.11072043f, 0.03842933f, 0.02306417f, 0.23283009f, 0.12114109f, 0.15390155f, 0.06533618f, 
    0.04559603f, 0.13172206f, 0.07719259f, 0.08866850f, -0.01372123f, 0.23008320f, 0.11002075f, 0.01680855f, 
    0.04687120f, 0.27125978f, 0.05446945f, 0.08037816f, 0.11696126f, 0.06750730f, -0.01973974f, -0.03068394f, 
    0.09277149f, 0.03597195f, 0.21724783f, -0.04577208f, -0.00138406f, -0.02045879f, 0.01977156f, 0.02888931f, 
    -0.12230763f, 0.33046246f, -0.14245281f, 0.06020371f, 0.04308040f, 0.17684962f, 0.13157620f, 0.09597969f, 
    0.07156440f, -0.01937977f, 0.01363572f, 0.10795376f, 0.06637584f, -0.12837930f, 0.09454411f, -0.05313451f, 
    0.08157224f, 0.10482305f, 0.12362605f, 0.07206337f, 0.10886716f, 0.14719534f, -0.10871840f, 0.12231280f, 
    0.11704857f, 0.07373565f, 0.06976049f, -0.04404062f, -0.02350607f, 0.00115395f, -0.01699276f, -0.07411136f, 
    0.07232059f, 0.07596415f, 0.24235071f, 0.12861960f, 0.04335918f, 0.01660890f, 0.17861986f, -0.05040545f, 
    -0.02473364f, -0.11911139f, -0.09633107f, -0.26030737f, 0.02250417f, 0.00471015f, 0.21713586f, 0.07223485f, 
    0.05279389f, -0.06152022f, 0.08867665f, -0.03373329f, 0.00767577f, -0.02737405f, -0.07695973f, -0.00461735f, 
    -0.00952388f, 0.13910973f, 0.08585229f, 0.10482771f, 0.03806864f, -0.01931028f, -0.04395698f, 0.05857340f, 
    -0.12027707f, 0.03716660f, -0.12351029f, 0.11139405f, -0.03402923f, 0.22919232f, -0.06583293f, 0.01136809f, 
    0.01400807f, -0.05666116f, 0.03411441f, -0.01415507f, -0.05203351f, -0.05962570f, 0.09790516f, 0.21925077f, 
    0.05744727f, -0.10140032f, -0.12149740f, -0.03769203f, -0.06700894f, 0.09184874f, 0.08699147f, -0.04913585f, 
    0.15678798f, 0.01657404f, 0.10183905f, -0.06270668f, 0.00184188f, -0.05031760f, -0.11820444f, 0.01198296f, 
    -0.00334733f, 0.20272270f, -0.01184581f, 0.07233862f, -0.14823985f, 0.42185158f, -0.27826512f, -0.21556152f, 
    0.12167593f, 0.11543035f, -0.03925269f, 0.34623775f, 0.11364014f, 0.07452533f, 0.13601616f, -0.00945383f, 
    0.00320349f, 0.00088020f, -0.02040765f, 0.03288692f, 0.10362636f, -0.13950586f, 0.05980192f, -0.01349940f, 
    0.16332966f, -0.08614578f, -0.00427876f, -0.05792440f, -0.03730565f, 0.06128732f, 0.01536426f, 0.09216624f, 
    0.05936715f, 0.14510423f, -0.06788082f, -0.14275409f, -0.06027926f, -0.15292990f, -0.02543086f, -0.16033268f, 
    -0.07781195f, -0.13411596f, -0.05281550f, 0.02166852f, -0.37552807f, -0.02256134f, -0.26993716f, -0.26313013f, 
    0.07762135f, 0.06146788f, 0.06734493f, 0.13254848f, 0.03028835f, 0.06644662f, -0.01172829f, 0.07870486f, 
    -0.12789458f, 0.03770854f, 0.03778869f, -0.03650450f, -0.01871717f, -0.05543657f, 0.12275831f, 0.07141129f, 
    0.14338425f, 0.20972556f, 0.09409011f, -0.04656905f, 0.07677113f, 0.07289928f, 0.10623496f, -0.06564429f, 
    0.21437319f, 0.16014817f, -0.05593996f, -0.04357226f, 0.00139596f, 0.05503790f, 0.19373834f, 0.00806206f, 
    -0.05011869f, 0.17469066f, 0.05238780f, 0.06741682f, -0.11983526f, 0.04025887f, -0.42075178f, 0.11958094f, 
    0.33205283f, 0.12799375f, -0.10641286f, -0.02590805f, -0.08939788f, -0.07320108f, 0.02113804f, 0.02768054f, 
    0.21468312f, 0.00363917f, -0.04502990f, 0.06239548f, 0.00713556f, -0.15169626f, 0.15344076f, 0.09707524f, 
    -0.00116369f, 0.09892378f, 0.14249633f, -0.07857026f, 0.00841547f, 0.16398710f, -0.03878365f, 0.03980736f, 
    0.01585755f, 0.10172085f, -0.01968677f, -0.00532339f, 0.11991920f, 0.00598998f, 0.14598840f, -0.03349876f, 
    -0.03525309f, 0.03935901f, 0.01321813f, -0.00777268f, -0.25995660f, 0.11436695f, -0.18382621f, -0.41230103f, 
    -0.12169789f, -0.16512331f, -0.30514088f, -0.09275568f, -0.07942963f, -0.29290134f, 0.29792318f, 0.13480127f, 
    0.15129593f, -0.07716463f, -0.05995792f, 0.15833850f, 0.14532240f, 0.16110049f, -0.35545728f, -0.10403770f, 
    0.44124743f, 0.01650267f, 0.05982313f, -0.14100431f, 0.26340839f, -0.12128282f, -0.07211343f, 0.03601733f, 
    0.02530847f, -0.07470948f, 0.09396324f, 0.00318135f, 0.25430721f, -0.17970759f, 0.00692501f, 0.15483566f, 
    0.13065608f, 0.11899815f, 0.16038689f, 0.09412801f, -0.13813518f, -0.21661815f, 0.22675481f, -0.30017856f, 
    0.00892831f, -0.22810632f, 0.01723576f, -0.21807115f, -0.19005933f, -0.29830977f, 0.10232012f, 0.05652408f, 
    0.10566380f, -0.03091550f, -0.14538503f, 0.06610970f, 0.05207896f, 0.11831293f, 0.04742537f, -0.20313118f, 
    0.18353492f, -0.08144051f, -0.09407926f, -0.12596017f, 0.07257543f, 0.13239706f, 0.08395261f, -0.11547257f, 
    0.07739762f, 0.05593711f, 0.05116705f, -0.06153991f, -0.08574632f, 0.01485017f, 0.03079895f, -0.17925215f, 
    -0.04107448f, -0.14798544f, 0.03160746f, 0.09495342f, 0.21818480f, 0.26940462f, -0.08457857f, -0.05072148f, 
    -0.01662567f, 0.06824666f, -0.13482422f, 0.10639456f, -0.12214425f, -0.05067322f, -0.12527476f, 0.23228525f, 
    0.05919265f, -0.18233685f, 0.16628025f, 0.02594936f, -0.03076985f, 0.16785395f, -0.12835816f, 0.08180251f, 
    -0.31579244f, 0.00291813f, 0.33907020f, -0.09377293f, 0.20314604f, -0.13382590f, 0.17226043f, -0.03994138f, 
    -0.13228682f, -0.05037713f, 0.01462776f, 0.02766884f, 0.02684271f, 0.17170665f, -0.03962848f, 0.04911992f, 
    0.12425423f, 0.08120694f, -0.03141978f, -0.14186075f, -0.24985547f, 0.12169725f, 0.30837968f, -0.14057948f, 
    0.05723636f, -0.02212129f, -0.08432589f, -0.10123083f, -0.05564876f, 0.08452081f, -0.06119953f, 0.06003494f, 
    0.00095143f, -0.00424035f, 0.04424963f, -0.08787625f, -0.06169616f, 0.10466506f, 0.01994807f, 0.03971864f, 
    -0.22525723f, 0.07897347f, -0.11499956f, 0.13824332f, 0.10740770f, -0.19423552f, -0.08536505f, -0.17610793f, 
    0.04633132f, -0.00069372f, -0.08337630f, 0.02018977f, -0.09436984f, -0.08533382f, -0.11412326f, 0.02209781f, 
    -0.06733428f, 0.05721564f, 0.02214149f, -0.19554099f, -0.04283373f, -0.01895625f, -0.11491179f, -0.22230998f, 
    -0.05109287f, 0.08956137f, -0.00250751f, 0.02872198f, -0.04792318f, -0.05761269f, 0.00703894f, 0.11969748f, 
    -0.02939562f, -0.14353287f, -0.12509225f, 0.05492424f, 0.02217363f, -0.08635872f, -0.17103779f, -0.16096932f, 
    0.03054816f, 0.00205484f, -0.08018793f, -0.20267403f, -0.07745291f, 0.17672326f, 0.09053762f, 0.02529864f, 
    0.06153183f, 0.13890143f, -0.09188222f, -0.08126853f, 0.03358975f, -0.02542866f, -0.07075365f, 0.06558084f, 
    0.02228062f, 0.10726248f, -0.12579000f, 0.04172295f, -0.38343489f, 0.20788719f, 0.19256444f, -0.15842141f, 
    0.33129239f, 0.07519395f, 0.16807471f, -0.13280448f, 0.05172674f, -0.01821269f, 0.06530647f, 0.02107539f, 
    0.02919617f, -0.01542792f, -0.03294434f, -0.08356942f, -0.05990893f, -0.10669190f, 0.05227307f, -0.03456762f, 
    -0.33748481f, 0.46533024f, -0.06275965f, 0.04787036f, 0.06945223f, 0.27798295f, 0.12230490f, -0.04125253f, 
    0.07442451f, -0.21324044f, -0.08811115f, 0.08025348f, 0.15403505f, -0.00271882f, 0.13929740f, -0.02561359f, 
    0.02652104f, 0.04581039f, -0.00078997f, -0.01968529f, -0.31273359f, 0.09167222f, -0.09812027f, -0.14559549f, 
    0.05153595f, 0.09591108f, 0.03480719f, -0.19025752f, 0.00904945f, -0.08897784f, -0.03235847f, 0.05622358f, 
    0.09299169f, 0.00132223f, 0.04758660f, -0.05752335f, 0.00750597f, -0.02665284f, 0.02137777f, -0.06878308f, 
    0.05278053f, -0.11141428f, 0.03869784f, -0.08020648f, 0.01745213f, 0.20925683f, 0.09483184f, -0.05310540f, 
    0.18726256f, -0.03075954f, 0.08068682f, -0.17984642f, -0.07260794f, -0.02151782f, -0.10233936f, -0.13652673f, 
    -0.04101288f, 0.14375173f, -0.04386698f, 0.05775502f, -0.15411618f, -0.14927156f, 0.17559712f, -0.00501097f, 
    0.17706530f, 0.00369799f, -0.11102610f, -0.05271791f, -0.05169927f, 0.11755778f, 0.10495740f, 0.01724310f, 
    0.04162329f, -0.02951642f, -0.05031932f, -0.15272415f, 0.01677934f, 0.06956010f, 0.05799478f, -0.04321945f, 
    -0.03674893f, -0.03688024f, 0.01928114f, -0.02979028f, -0.02031148f, -0.03272832f, 0.00905082f, -0.02935458f, 
    0.01404507f, 0.03019823f, -0.02721934f, 0.03313665f, -0.02766639f, -0.04429654f, 0.04540031f, -0.00267789f, 
    -0.02375026f, -0.00941479f, -0.02594963f, -0.01483817f, -0.03218293f, 0.02181365f, -0.00387681f, -0.03226547f, 
    0.02422781f, -0.00932382f, 0.02493023f, -0.00024183f, -0.02835649f, 0.00559625f, -0.00978010f, 0.03122958f, 
    -0.02303765f, -0.03649692f, 0.02309126f, -0.01175034f, 0.02038993f, 0.01247568f, -0.01494719f, -0.00261912f, 
    0.00807140f, -0.00103473f, -0.02574082f, -0.02224840f, 0.00299407f, 0.00610769f, 0.02635128f, 0.04349353f, 
    0.01248130f, 0.01313482f, 0.01434832f, 0.01215555f, -0.01700292f, 0.02072679f, 0.01547201f, 0.01131406f, 
    -0.01381596f, -0.04097581f, 0.01170230f, -0.03485690f, 0.00247877f, 0.01217404f, -0.03439159f, -0.03834035f, 
    -0.03082944f, 0.00568863f, -0.01277967f, 0.01038360f, -0.03356265f, 0.03150270f, -0.03766464f, -0.04215642f, 
    -0.04328776f, -0.03145068f, 0.02807581f, -0.03570262f, -0.01035687f, -0.00894656f, -0.03142099f, 0.00833583f, 
    -0.01825957f, 0.01291294f, 0.02690879f, -0.03210052f, -0.00543069f, -0.02739527f, -0.00481400f, 0.01043323f, 
    -0.02411846f, 0.03167608f, -0.02016654f, -0.04344409f, 0.02931685f, 0.03032115f, -0.03211050f, -0.03258865f, 
    -0.01004671f, -0.00117442f, -0.00764431f, 0.01558127f, 0.02647204f, 0.01804461f, 0.03128105f, -0.04414109f, 
    0.00799193f, 0.00685121f, 0.03065336f, 0.02336364f, 0.02709877f, 0.00488673f, -0.02360922f, -0.01915273f, 
    -0.02081122f, -0.02653761f, 0.00837345f, 0.00998124f, -0.03998667f, -0.02363479f, -0.03413048f, 0.01528339f, 
    -0.00212272f, -0.04165360f, -0.02070289f, -0.02642879f, -0.02602481f, -0.02959990f, -0.02175674f, 0.02395346f, 
    -0.01548325f, -0.02335303f, -0.04544889f, 0.02681100f, 0.02383110f, 0.02582175f, -0.03292400f, -0.02831784f, 
    -0.00591945f, 0.00169621f, 0.01689215f, 0.00816404f, 0.01188850f, -0.02140259f, -0.01685733f, 0.03271003f, 
    0.01184367f, 0.01344819f, -0.01963015f, -0.01867341f, -0.03252962f, -0.03908881f, 0.01600400f, 0.02429703f, 
    -0.01769554f, 0.01434485f, 0.02500134f, 0.03122252f, -0.04039594f, -0.01398627f, 0.00872724f, -0.02271792f, 
    0.01996340f, -0.03243011f, 0.00694181f, 0.02651678f, 0.00230268f, -0.01367894f, -0.01519069f, 0.02479657f, 
    0.02590271f, 0.02484110f, 0.02673407f, 0.01217701f, -0.00796300f, -0.01448037f, -0.00337253f, -0.00468298f, 
    0.01995586f, -0.04363699f, -0.00809780f, -0.01697633f, 0.02120548f, -0.01036175f, 0.02631467f, 0.02186335f, 
    0.04367131f, -0.00752339f, -0.03814927f, 0.03437306f, -0.02276154f, -0.02904088f, -0.03160206f, -0.03723722f, 
    -0.01142443f, -0.00590767f, 0.02007615f, -0.03005889f, 0.00599956f, -0.01051028f, -0.03885409f, 0.03197237f, 
    0.00426566f, -0.03098498f, -0.02282698f, -0.03811156f, 0.01554599f, -0.02460337f, 0.01015055f, 0.01172818f, 
    -0.01024001f, -0.01247883f, 0.03332321f, -0.00620565f, 0.03117548f, 0.01862751f, -0.02696741f, 0.00251813f, 
    -0.03824235f, 0.01882620f, 0.01411972f, 0.00095413f, -0.04122248f, -0.02857866f, -0.02151572f, 0.01617198f, 
    0.00210542f, -0.03854433f, 0.00380593f, -0.03521219f, -0.04053044f, 0.02639332f, -0.02427018f, 0.03710393f, 
    -0.04074484f, -0.01928753f, -0.04053864f, -0.01378259f, -0.04343887f, -0.00914018f, 0.02665574f, 0.00701488f, 
    -0.02394559f, -0.03597142f, 0.03355478f, -0.01851867f, 0.03582477f, -0.00119470f, -0.02302711f, -0.00086346f, 
    0.02895840f, 0.00740762f, 0.01725325f, 0.03074136f, -0.03143615f, 0.00735260f, -0.01721614f, 0.03549002f, 
    -0.03724382f, -0.02076071f, 0.00484136f, -0.00002150f, 0.03402809f, -0.02442281f, 0.01762832f, 0.01380112f, 
    -0.03053274f, -0.01572757f, 0.04308550f, -0.01223382f, 0.01808656f, 0.02558837f, 0.00807302f, -0.04322702f, 
    -0.00223214f, -0.04165764f, 0.01873304f, 0.02060617f, -0.02540078f, -0.00739028f, 0.00434223f, -0.03403641f, 
    0.01594615f, -0.00976331f, 0.03561468f, -0.02481134f, -0.01329144f, -0.00231466f, -0.03857620f, 0.03374060f, 
    -0.00988148f, -0.02013757f, 0.02103372f, -0.02443219f, -0.04113147f, -0.04400658f, -0.02052035f, 0.01565709f, 
    0.01666297f, -0.00217957f, 0.02474019f, -0.02051866f, -0.03953200f, -0.00240745f, -0.00837042f, -0.03488483f, 
    -0.04041420f, 0.00686379f, -0.00812712f, -0.04080250f, -0.00655821f, -0.01504659f, -0.00169350f, 0.00351013f, 
    -0.03925962f, 0.04175310f, -0.04090825f, 0.00160235f, -0.01499143f, -0.01507660f, -0.02418089f, 0.00509410f, 
    0.04118438f, -0.02507556f, 0.00012207f, -0.00720115f, 0.01781630f, 0.00124053f, 0.00648883f, 0.04473991f, 
    -0.02021546f, -0.00954883f, -0.04325281f, 0.01652449f, -0.02399737f, -0.00725616f, 0.00484788f, -0.00418398f, 
    -0.04512364f, -0.03473459f, -0.03609824f, 0.01432843f, -0.00036804f, 0.01134622f, -0.02738707f, -0.02640499f, 
    -0.04321447f, -0.00936514f, -0.02712149f, -0.00286179f, -0.02596444f, -0.04328729f, -0.03306730f, -0.02941508f, 
    -0.01936790f, 0.02023475f, -0.01777921f, 0.03177183f, -0.02313485f, -0.01323647f, -0.03003481f, -0.00396859f, 
    -0.02117103f, -0.00543701f, -0.03011715f, 0.00754317f, 0.02074098f, 0.00927782f, 0.01733404f, 0.00699585f, 
    0.01232481f, 0.02278496f, -0.01775616f, -0.02468791f, 0.02058056f, -0.00524422f, 0.02176236f, 0.00988822f, 
    0.01962995f, -0.02511069f, -0.00419040f, -0.02017550f, -0.02281271f, -0.03920387f, -0.00106055f, 0.00413519f, 
    -0.03127760f, -0.02135079f, -0.02577423f, -0.03211613f, -0.04055018f, 0.01150462f, 0.03177259f, -0.03189422f, 
    0.01159550f, 0.02684398f, 0.00073422f, 0.02111127f, 0.01718347f, 0.02481050f, 0.02064818f, 0.02071875f, 
    0.02155629f, -0.00140860f, -0.00794978f, 0.00533663f, -0.01515889f, -0.01265287f, -0.03720541f, -0.03512511f, 
    0.02173629f, -0.00731135f, -0.04127613f, -0.01489398f, 0.00330956f, 0.02892317f, -0.00089296f, -0.03162474f, 
    -0.00359002f, -0.03092382f, -0.03421472f, -0.02411496f, 0.00379314f, 0.00089354f, -0.01511538f, -0.01530588f, 
    0.02504007f, 0.01171213f, 0.00320060f, 0.01969012f, -0.04020010f, 0.02559568f, -0.03432842f, -0.00029675f, 
    0.02052899f, -0.04224091f, 0.02388703f, -0.02572278f, -0.00758011f, -0.02099656f, -0.01660626f, -0.02483449f, 
    0.00294752f, -0.01704886f, -0.00796484f, 0.00439774f, -0.04341206f, 0.00452095f, 0.00912584f, -0.04514205f, 
    0.01010350f, -0.01937133f, 0.00937877f, -0.03511490f, -0.04223472f, -0.02196431f, -0.01814886f, 0.02770650f, 
    -0.01418959f, 0.03101102f, 0.01722190f, -0.03679659f, -0.03200872f, -0.03058490f, 0.01057468f, -0.04193559f, 
    0.01396460f, 0.01380543f, -0.01396632f, 0.00451817f, -0.01318462f, 0.00342546f, 0.00873941f, -0.00027583f, 
    -0.04511378f, 0.00756458f, -0.03057420f, -0.02243583f, 0.02943942f, -0.02694610f, 0.00905894f, -0.01795150f, 
    -0.02126398f, 0.02492690f, 0.02770881f, 0.00748229f, -0.01252329f, -0.01630114f, -0.02305442f, 0.00096295f, 
    -0.00259928f, -0.02887593f, 0.01891510f, 0.02481576f, 0.02735799f, -0.02086961f, -0.01252927f, -0.01124847f, 
    0.01300280f, -0.03732963f, 0.01955554f, -0.02026620f, -0.03229318f, -0.00642452f, -0.04205467f, 0.03293148f, 
    -0.03269652f, 0.01571465f, 0.04016484f, 0.02856510f, 0.01290502f, -0.02187746f, -0.01371428f, -0.02041361f, 
    0.03608981f, 0.00932358f, -0.03777151f, 0.03195126f, 0.03082381f, 0.03641653f, 0.00708725f, 0.00823905f, 
    -0.00338189f, 0.01529132f, 0.02572646f, -0.02968271f, 0.03311532f, -0.02460033f, -0.00879857f, -0.01515073f, 
    0.01953097f, 0.00390688f, -0.01615540f, -0.00174085f, -0.00146425f, 0.00967681f, 0.00446646f, -0.03683279f, 
    0.01108928f, 0.00878816f, 0.00130096f, -0.03547017f, 0.00971088f, 0.00129122f, -0.02119208f, 0.02642150f, 
    -0.00950190f, -0.03208862f, 0.02642438f, 0.01795618f, -0.04498417f, -0.02103248f, 0.02581707f, -0.03489874f, 
    -0.03253672f, 0.01201521f, 0.02815684f, -0.01027292f, 0.02745217f, -0.00152115f, -0.01353988f, -0.03743578f, 
    0.01978500f, -0.03257225f, -0.01578929f, -0.03130996f, -0.04486557f, -0.00797971f, 0.02953028f, -0.00976855f, 
    -0.00705260f, 0.03069839f, 0.01837500f, -0.01729743f, -0.01008692f, 0.02940486f, 0.02278427f, 0.03238676f, 
    0.00529880f, 0.01373141f, -0.00569730f, -0.01285057f, 0.01413003f, -0.03683969f, -0.01100362f, 0.00463050f, 
    -0.02080402f, -0.00321764f, 0.02589256f, -0.02068553f, 0.00811638f, 0.00947927f, 0.02882632f, 0.01150250f, 
    0.01081111f, -0.03514539f, -0.00142821f, 0.03359765f, -0.02472529f, -0.03277699f, 0.03021132f, 0.02491573f, 
    0.00120731f, 0.02045562f, 0.03858341f, -0.03238233f, 0.02145243f, -0.01468954f, -0.02220825f, -0.01708601f, 
    0.02675583f, -0.00099141f, -0.03897556f, 0.00097894f, -0.00272426f, 0.00939439f, -0.01036469f, 0.03264311f, 
    -0.02713630f, 0.01089598f, 0.01081097f, 0.02062847f, 0.02555184f, 0.00135601f, 0.02723386f, 0.01213752f, 
    -0.01829760f, 0.01110744f, -0.03557655f, 0.01072154f, 0.03145564f, -0.00985836f, 0.01670066f, -0.01979575f, 
    0.00475961f, -0.02509159f, -0.03772156f, 0.01434621f, -0.01718748f, -0.00539566f, -0.03450197f, 0.03039505f, 
    0.08315130f, 0.16138832f, -0.14734147f, 0.15859027f, -0.01955987f, -0.01572140f, 0.08325135f, -0.02349793f, 
    -0.03954357f, -0.09855862f, 0.03967825f, -0.00161540f, 0.07081308f, 0.15030035f, 0.08334268f, -0.08138935f, 
    -0.00232643f, 0.00442293f, -0.05743008f, 0.06902124f, 0.79727256f, -0.68117779f, -0.10902281f, -0.23995566f, 
    0.03882308f, -0.18241945f, -0.05627253f, 0.12159894f, -0.01886257f, -0.03491282f, 0.33962956f, -0.09713074f, 
    -0.12980849f, -0.01177179f, 0.09961849f, 0.02605087f, -0.06177440f, -0.00729628f, 0.10995856f, -0.03277042f, 
    0.01295435f, -0.02931659f, -0.16621970f, -0.15476106f, -0.35608870f, -0.14694834f, 0.06602072f, 0.06663629f, 
    -0.05211959f, -0.03108403f, 0.04101018f, -0.09396037f, -0.06133110f, 0.01861160f, -0.02491205f, -0.10236935f, 
    -0.08129935f, -0.15029065f, -0.01510062f, -0.02514162f, -0.07504682f, 0.15386485f, -0.03190168f, -0.00185315f, 
    0.11257775f, -0.00456675f, 0.07559755f, -0.07437600f, 0.03160384f, -0.07729475f, -0.07367384f, 0.10137242f, 
    -0.13614634f, 0.10917331f, 0.00251655f, 0.02289099f, -0.01731121f, 0.01840013f, -0.11992387f, -0.14968082f, 
    -0.05679858f, -0.31071365f, -0.13905559f, 0.04962131f, -0.32667965f, -0.05027622f, 0.09063475f, 0.12075664f, 
    -0.08202790f, 0.01802622f, 0.04296576f, -0.05660589f, -0.18846667f, 0.02348035f, -0.00088620f, -0.08763598f, 
    -0.13299090f, 0.04508053f, 0.10570833f, 0.04235121f, 0.21157475f, -0.30483612f, -0.28869647f, 0.08148431f, 
    -0.38878262f, -0.02129535f, -0.01685765f, 0.00291180f, 0.04644483f, -0.01653143f, 0.11505076f, -0.01988954f, 
    -0.10484724f, 0.07346078f, -0.06677579f, -0.02175062f, 0.01696929f, 0.02778525f, 0.03837148f, -0.01268204f, 
    -0.39806497f, -0.01150329f, 0.32141817f, 0.26858181f, -0.04448014f, -0.04768547f, 0.01899522f, -0.18170047f, 
    0.06620715f, 0.00108836f, 0.01648419f, -0.06182951f, 0.00758638f, 0.04748840f, 0.09808575f, 0.15422875f, 
    -0.12841463f, -0.00041586f, -0.17965284f, 0.01232851f, -0.32834682f, 0.36166942f, 0.00991829f, -0.07196781f, 
    -0.16455005f, -0.11366822f, -0.03429753f, -0.00893144f, 0.00228263f, 0.09380739f, 0.10671043f, -0.05586026f, 
    -0.23738818f, -0.09331596f, -0.07347399f, -0.15220788f, -0.14305724f, -0.06758083f, -0.14772832f, 0.10280712f, 
    0.22338620f, 0.27969545f, 0.67507946f, 0.14904925f, 0.03557118f, -0.06716632f, -0.12421267f, 0.03112390f, 
    0.05329068f, 0.17440239f, 0.02122579f, 0.20724128f, 0.11138299f, 0.00761058f, -0.03552841f, -0.04098226f, 
    -0.01542737f, -0.17312650f, -0.00614878f, -0.11306068f, 0.20907347f, 0.11387306f, 0.46888635f, -0.18549407f, 
    0.10762721f, 0.20831019f, -0.08816344f, -0.00871817f, 0.05191003f, 0.04749650f, 0.00129016f, -0.02510046f, 
    0.01135569f, 0.05127554f, -0.09753409f, 0.11903173f, 0.04298795f, -0.00307071f, 0.08874770f, 0.00923294f, 
    0.25485209f, 0.24777527f, 0.50282067f, -0.01172919f, 0.03795281f, -0.04631499f, 0.00317862f, 0.07444591f, 
    -0.07256010f, 0.13117807f, 0.10160018f, 0.07596134f, 0.10230599f, -0.04418225f, 0.09316416f, -0.03105717f, 
    0.01341910f, -0.23370527f, 0.17925440f, 0.09536128f, 0.14313850f, -0.06085878f, 0.25680014f, -0.21761322f, 
    0.08038376f, -0.13948856f, 0.22466217f, -0.01789514f, -0.03307112f, -0.07003406f, 0.00872792f, 0.00082621f, 
    0.02554612f, 0.24376927f, 0.00132253f, 0.04389069f, -0.25032237f, 0.09373847f, -0.16522709f, 0.11565606f, 
    0.02753532f, 0.35915485f, 0.45569158f, 0.07879928f, -0.12129097f, 0.09308572f, -0.12631696f, 0.01223877f, 
    0.06582895f, 0.15546818f, 0.10734962f, 0.00394805f, 0.05529524f, 0.15192522f, -0.03741488f, 0.08433563f, 
    0.14670208f, 0.04304891f, 0.06260694f, 0.04833912f, 0.36167502f, 0.05835054f, -0.23185490f, -0.20334008f, 
    -0.18496031f, -0.29449755f, 0.17039064f, -0.01753659f, -0.10900392f, -0.00901993f, 0.02425622f, -0.06794021f, 
    -0.03911855f, -0.11450613f, -0.03487834f, -0.06800234f, 0.08262958f, -0.04623714f, -0.15960374f, -0.00189239f, 
    0.00650161f, -0.06189431f, 0.18881194f, -0.09260387f, -0.19072941f, -0.03951910f, -0.00119156f, 0.03838377f, 
    -0.03699883f, -0.01277022f, 0.04743251f, -0.04458025f, 0.07428520f, -0.03949038f, 0.09288511f, 0.15561798f, 
    0.09934079f, -0.09675422f, -0.04220335f, -0.00955476f, 0.07248128f, 0.10063223f, -0.09711403f, 0.16867827f, 
    0.03471617f, -0.01166030f, 0.06029992f, -0.01564552f, -0.06576613f, -0.09397922f, -0.04817917f, 0.05257216f, 
    -0.03089210f, 0.20812684f, 0.00317951f, 0.01523957f, -0.00441928f, 0.00092707f, -0.18796627f, 0.04474212f, 
    0.26877105f, -0.21193522f, -0.17786643f, 0.00506157f, -0.33837262f, -0.03129968f, 0.03125314f, 0.08878392f, 
    0.04649277f, -0.01817070f, 0.07677731f, 0.08837760f, -0.07532839f, 0.00042186f, -0.05716061f, -0.05769683f, 
    0.01501518f, 0.02343178f, 0.05087914f, -0.02299305f, 0.10581001f, 0.04478169f, 0.10347076f, -0.03249863f, 
    -0.05069387f, 0.06931452f, 0.04480222f, 0.10085728f, -0.07055170f, 0.00207066f, -0.02687907f, -0.15071155f, 
    -0.11705629f, 0.03798654f, -0.06479469f, 0.02859428f, -0.06828389f, -0.13103801f, -0.03765520f, -0.01039892f, 
    0.13898312f, -0.36576194f, -0.13998124f, 0.14237867f, 0.09758785f, 0.01418385f, 0.05430541f, 0.11174679f, 
    -0.03171872f, -0.05575592f, -0.02263691f, -0.04088307f, 0.16442432f, 0.14095090f, 0.00298798f, 0.07258260f, 
    0.02775227f, -0.00704466f, -0.04180178f, 0.05917533f, 0.10745677f, 0.11060164f, 0.24951777f, 0.11297966f, 
    0.10330135f, -0.15261106f, 0.14675395f, -0.04264186f, -0.06974653f, -0.01521623f, 0.27091902f, -0.02553703f, 
    -0.05148479f, -0.02675010f, 0.11005678f, -0.09420192f, 0.10647151f, -0.10997116f, -0.07234807f, 0.01326709f, 
    0.02249298f, 0.32078046f, 0.33880162f, 0.20374188f, -0.21374242f, -0.18441650f, -0.03150695f, 0.06024179f, 
    -0.14710300f, 0.28958935f, -0.00597474f, 0.05405135f, 0.12766348f, -0.02872637f, -0.02226317f, 0.01628447f, 
    0.02726873f, -0.06722593f, 0.06980619f, -0.07492865f, 0.04107898f, -0.58283561f, -0.29324803f, -0.10182467f, 
    -0.37572560f, 0.03374818f, -0.08031527f, 0.07239205f, 0.08762167f, -0.09528200f, -0.06618387f, 0.10407642f, 
    -0.01314265f, 0.06784005f, -0.13373807f, -0.02031264f, 0.06917650f, -0.01043438f, -0.09866864f, 0.10177156f, 
    0.28473309f, 0.14280510f, -0.10484274f, 0.12628682f, -0.01642585f, 0.08150718f, -0.08299275f, -0.07728213f, 
    0.04514601f, -0.01276873f, 0.08498596f, 0.02515011f, 0.06151705f, -0.09269504f, -0.05310281f, 0.06714700f, 
    -0.05139722f, -0.05798449f, 0.08684015f, 0.00946788f, 0.02351686f, 0.41442811f, -0.58843666f, 0.44165725f, 
    -0.36686036f, 0.30357692f, -0.08154029f, -0.15950814f, 0.00072678f, 0.03152606f, 0.09609713f, 0.14074846f, 
    0.00225692f, -0.04829314f, -0.04959024f, 0.06326354f, 0.02508190f, 0.21843721f, -0.07340025f, -0.02819447f, 
    0.15497132f, 0.26774189f, -0.10646512f, 0.15271822f, 0.04700483f, 0.01428615f, 0.09762670f, -0.03875125f, 
    0.00488755f, -0.00109668f, 0.07203185f, 0.05476154f, 0.03171334f, 0.02864062f, 0.04373641f, -0.02358419f, 
    0.02950534f, 0.11266089f, -0.00939803f, -0.01342842f, 0.04542641f, 0.13646135f, -0.01601616f, 0.25648728f, 
    -0.09997939f, -0.00901290f, -0.05063390f, 0.15540487f, 0.02416323f, 0.07707163f, -0.05352741f, 0.13538311f, 
    0.15307923f, 0.00719480f, -0.07446765f, -0.04554788f, -0.03660639f, -0.14101058f, -0.08235323f, 0.01495022f, 
    0.23693016f, 0.04831015f, 0.33928365f, 0.12844504f, -0.04132741f, 0.06399595f, -0.09809222f, 0.04396784f, 
    -0.05802228f, 0.00011532f, 0.02635275f, 0.08314722f, -0.04026349f, 0.00778011f, -0.07338547f, -0.02629250f, 
    -0.01601735f, 0.03196926f, -0.00487132f, -0.06578682f, 0.08051983f, 0.13284484f, -0.25864053f, 0.25810382f, 
    -0.12519370f, -0.03383899f, 0.00141094f, -0.00496100f, 0.20966502f, -0.00622510f, -0.10969641f, 0.00175741f, 
    0.01316425f, 0.11890834f, 0.03946553f, 0.06443641f, -0.00411092f, -0.02382044f, -0.01345499f, 0.02594569f, 
    0.38425809f, -0.39415458f, -0.44522297f, -0.07019268f, -0.30820966f, -0.10105982f, -0.07369256f, -0.13158268f, 
    -0.00107870f, -0.06845203f, 0.12918757f, -0.08378351f, -0.02020096f, -0.07532733f, -0.11612240f, 0.06041863f, 
    -0.07563476f, 0.01699258f, -0.03097985f, -0.03948561f, 0.12918615f, -0.09702354f, -0.28704196f, -0.00668375f, 
    -0.09859636f, -0.07533576f, 0.01064267f, -0.05127302f, -0.06073522f, -0.09554367f, 0.09408477f, -0.01980140f, 
    -0.03349405f, 0.07100568f, 0.01351879f, 0.04412051f, 0.01231193f, 0.06623130f, -0.11497314f, -0.06168133f, 
    0.19396521f, 0.26427257f, 0.39987394f, -0.02426686f, -0.18021396f, -0.03070042f, 0.11794081f, 0.18191858f, 
    0.06588876f, 0.17182243f, 0.08138369f, -0.00300458f, 0.07153825f, -0.06967827f, 0.01643583f, 0.01958884f, 
    0.01769941f, -0.06814123f, 0.17958812f, 0.01253148f, 0.35135654f, 0.38524097f, -0.11061016f, 0.36873692f, 
    -0.13730960f, 0.16573903f, 0.01462923f, -0.11182276f, 0.00823375f, 0.04495932f, 0.01855619f, 0.06531015f, 
    0.01809728f, 0.04751096f, -0.05315771f, -0.00667601f, 0.07608248f, 0.08411202f, -0.02514914f, 0.08831022f, 
    0.01098541f, 0.00441549f, 0.01793620f, 0.03345166f, 0.02350195f, -0.04194172f, 0.01565055f, 0.02815024f, 
    0.03311888f, -0.02668929f, -0.04377778f, 0.01897717f, -0.01210972f, 0.01927773f, -0.01064515f, 0.01765062f, 
    0.01887950f, 0.00475549f, 0.01836306f, -0.02265036f, 0.00484555f, -0.01428894f, -0.03123790f, -0.02687829f, 
    0.03262424f, 0.04037201f, 0.02907909f, 0.01564360f, 0.02178684f, 0.02871736f, -0.00511153f, 0.01811136f, 
    0.00849798f, 0.01526769f, -0.02633832f, 0.01737521f, -0.00750568f, 0.01345856f, -0.01182446f, 0.01656609f, 
    0.00899714f, -0.01810008f, 0.02094410f, -0.02360906f, 0.02429322f, -0.03651387f, -0.00769182f, -0.03518467f, 
    -0.02719938f, -0.03917045f, -0.03198739f, 0.01090007f, -0.02053385f, 0.00384697f, 0.00065467f, 0.02342598f, 
    0.00260516f, -0.03368993f, 0.02231303f, -0.01768631f, 0.01345901f, 0.00454457f, -0.03971378f, -0.01131006f, 
    0.01653489f, -0.02829865f, 0.01525833f, 0.00548256f, -0.00749527f, -0.02917424f, 0.01361956f, -0.03637284f, 
    0.00142987f, -0.02432898f, 0.00869558f, 0.02356645f, 0.01601244f, 0.01255661f, -0.03171276f, 0.00973679f, 
    -0.01502935f, 0.00269370f, 0.02275935f, 0.01962018f, -0.01598562f, 0.00202700f, -0.01449600f, 0.01752375f, 
    0.01905974f, 0.02182701f, -0.00856336f, 0.02212562f, -0.00040239f, -0.03678595f, -0.00720997f, 0.01134285f, 
    0.00391818f, -0.02690941f, -0.00299332f, 0.00942432f, 0.02732129f, 0.02238123f, -0.01057772f, 0.00418296f, 
    0.02174601f, 0.03071609f, -0.02781885f, -0.01862191f, -0.02552720f, 0.00419203f, 0.00953902f, 0.01749135f, 
    0.02272732f, -0.00178237f, -0.00891587f, -0.01364937f, 0.03114888f, -0.03475213f, 0.02466336f, 0.03083811f, 
    0.00157903f, -0.01635448f, -0.04184241f, -0.02143625f, 0.03266404f, 0.02511980f, -0.02719758f, -0.00224155f, 
    -0.01463883f, -0.03874408f, 0.00349886f, -0.02633405f, -0.00767764f, -0.01081778f, -0.02436932f, -0.02285144f, 
    -0.00444424f, -0.02765358f, -0.02223702f, -0.01802288f, 0.03088812f, 0.02496410f, -0.01879234f, 0.00216959f, 
    0.02654127f, -0.04218790f, -0.00945586f, 0.02135944f, 0.01283051f, 0.02281614f, 0.00530925f, -0.00670323f, 
    -0.00595713f, 0.00216746f, -0.04508838f, 0.02193092f, -0.01241600f, 0.00398376f, -0.04011365f, 0.01002272f, 
    -0.01685512f, -0.00306738f, 0.00161258f, -0.03057885f, -0.02436708f, -0.02741685f, -0.02402154f, -0.00285711f, 
    0.02013027f, -0.03110551f, -0.04123765f, -0.01364736f, -0.03919176f, 0.02179355f, 0.00624112f, 0.00015870f, 
    -0.00260219f, 0.03032983f, 0.01773257f, 0.02155358f, 0.03110675f, 0.00398940f, 0.00801528f, -0.04335591f, 
    -0.03150949f, -0.04449889f, 0.02226156f, -0.00134433f, -0.03540586f, 0.00714486f, 0.00558653f, 0.00127285f, 
    -0.04434523f, -0.00332223f, -0.03461474f, 0.00555234f, 0.02716127f, -0.01833530f, -0.02764090f, -0.02300677f, 
    0.01543398f, 0.01517541f, 0.00084444f, 0.00242354f, -0.02928591f, 0.01573208f, -0.00987144f, -0.02609789f, 
    0.01991977f, -0.04356167f, 0.01245975f, -0.02860864f, -0.03577656f, 0.02597327f, -0.01171226f, 0.01021792f, 
    0.01668372f, 0.00977164f, 0.03076931f, -0.04231253f, 0.00571789f, -0.02768209f, -0.01032915f, -0.01352206f, 
    0.01623890f, 0.01482963f, -0.03749033f, -0.03776209f, 0.01296464f, -0.01876927f, 0.03322427f, 0.01398739f, 
    0.02568711f, -0.01910575f, -0.01985246f, -0.03839915f, -0.00555359f, -0.01460780f, -0.02615803f, -0.01951294f, 
    0.03350018f, -0.02408888f, 0.00226241f, 0.00574194f, -0.03774983f, -0.00656456f, 0.04225316f, 0.00545259f, 
    -0.03441021f, 0.00937618f, -0.01813637f, 0.00348117f, 0.02945655f, -0.00923894f, -0.01772584f, 0.00868916f, 
    -0.03696189f, -0.03755503f, 0.02343516f, 0.00044468f, -0.04170616f, -0.02124690f, -0.01835397f, -0.01925309f, 
    -0.03064297f, -0.00026015f, 0.00128587f, -0.02887738f, 0.02143906f, 0.01122505f, 0.01081349f, -0.00507548f, 
    0.01961226f, 0.02163282f, -0.01154801f, -0.01934772f, 0.03028641f, -0.00944845f, -0.02066538f, 0.02294701f, 
    -0.02874226f, 0.03279467f, 0.02251382f, 0.00158502f, 0.00571912f, -0.00745607f, -0.04494972f, -0.04191984f, 
    -0.00319566f, 0.01787060f, -0.04145476f, 0.00114911f, -0.03414869f, 0.02806759f, 0.00897605f, 0.01887829f, 
    0.02803090f, -0.01280917f, 0.01477248f, -0.00667046f, -0.00290637f, -0.00390371f, 0.00434452f, 0.01120036f, 
    -0.00969138f, -0.02840561f, -0.02162635f, -0.03238487f, 0.01813950f, -0.01850603f, -0.00394099f, -0.02246994f, 
    -0.03453423f, 0.00562943f, -0.04504012f, -0.01507802f, -0.02502837f, -0.00274735f, 0.01186374f, -0.01177398f, 
    -0.04211522f, -0.02493990f, -0.01504193f, -0.00323377f, -0.02176816f, -0.01085263f, 0.00799051f, -0.03534093f, 
    0.01013331f, 0.00545222f, -0.03429752f, -0.02253442f, -0.03901106f, -0.00053861f, -0.01716459f, -0.00664248f, 
    0.00271981f, 0.02182074f, -0.00705926f, -0.03282271f, -0.04228257f, 0.02873383f, -0.03714608f, -0.00277044f, 
    -0.03044653f, -0.03109528f, -0.04168894f, -0.02807229f, -0.02383690f, -0.02552846f, 0.01308849f, -0.01272705f, 
    -0.03217814f, 0.02052965f, 0.00794895f, 0.01243292f, 0.00020129f, -0.03519754f, -0.00268080f, 0.01914050f, 
    -0.02959096f, -0.03900949f, -0.04094094f, 0.01198818f, -0.01879128f, -0.01772516f, 0.00974297f, 0.00288578f, 
    0.00125897f, -0.03490200f, 0.00636525f, -0.00036418f, 0.00904652f, 0.00923237f, 0.01412338f, -0.04384222f, 
    -0.03681669f, 0.00562461f, -0.01018543f, 0.01752071f, 0.02878356f, 0.00630193f, 0.00724281f, -0.03829331f, 
    0.01689829f, 0.00053603f, -0.01479876f, -0.00070857f, -0.00555872f, -0.01525997f, -0.04379420f, 0.03269883f, 
    -0.02988453f, 0.00477695f, 0.03004219f, 0.01225905f, -0.01377567f, 0.01957077f, -0.03077460f, -0.00451275f, 
    -0.02772101f, 0.01944285f, 0.03848986f, 0.00834319f, -0.00931707f, -0.03534193f, -0.00079758f, -0.02009046f, 
    0.00451916f, -0.03913128f, 0.01897375f, -0.03973695f, -0.00147908f, -0.00275277f, -0.02155623f, 0.00449189f, 
    -0.04117915f, -0.00463990f, 0.02890338f, 0.02884642f, -0.02446807f, 0.02909853f, 0.00306707f, -0.01616298f, 
    -0.01256226f, -0.02575785f, -0.00403302f, 0.00544872f, -0.03075667f, -0.03304917f, 0.02541783f, 0.00452801f, 
    0.01635058f, -0.00841413f, 0.02843724f, 0.01571395f, -0.03158510f, -0.01361076f, -0.00069450f, 0.02047072f, 
    0.01093836f, -0.02508857f, -0.04483268f, 0.01031707f, -0.00112409f, -0.04114510f, -0.00467512f, 0.02910743f, 
    -0.04493979f, -0.00328984f, 0.00150235f, 0.00698714f, -0.01503690f, 0.01116583f, -0.03151212f, -0.01856504f, 
    0.03208729f, -0.02803443f, -0.00485812f, -0.03415662f, -0.03596080f, -0.01198023f, 0.01308705f, 0.02389396f, 
    -0.00539223f, -0.04180709f, -0.03634702f, 0.02739681f, -0.01179694f, 0.01872699f, -0.00314093f, 0.00585005f, 
    -0.02950973f, 0.03289504f, -0.02735765f, -0.03111458f, 0.01181955f, -0.01352387f, 0.00366053f, -0.00924405f, 
    -0.01302304f, 0.02029044f, 0.02903835f, -0.04432192f, 0.02348854f, 0.01446210f, -0.02139170f, -0.03733443f, 
    0.03254295f, -0.03944964f, -0.03600431f, -0.02575778f, -0.04344600f, -0.00884928f, -0.00989158f, 0.00577930f, 
    0.02480103f, -0.01647615f, 0.02429768f, -0.03762442f, -0.00904938f, 0.03259838f, -0.02038449f, -0.01694800f, 
    0.00406612f, 0.01785118f, -0.02167679f, 0.00159521f, -0.02221983f, -0.01824821f, 0.02405499f, 0.00230766f, 
    -0.02957589f, -0.00016935f, 0.03049968f, 0.01108369f, 0.02456483f, -0.01647104f, -0.03075313f, -0.03910080f, 
    0.01541254f, -0.03787563f, -0.04253911f, 0.03051996f, 0.02210593f, -0.02841943f, 0.02673220f, -0.03545046f, 
    0.00182502f, 0.02653636f, -0.00314110f, -0.03762226f, 0.01915870f, 0.00289197f, 0.01082193f, -0.03885956f, 
    0.01545174f, -0.01200127f, -0.03571445f, -0.02640022f, -0.04241090f, -0.02298842f, -0.00499938f, 0.02893784f, 
    -0.03648068f, 0.02872446f, 0.01489560f, -0.02774757f, -0.00341244f, 0.03011350f, 0.00476799f, -0.03823588f, 
    -0.03322634f, -0.03874237f, -0.02005049f, -0.02776609f, -0.03491758f, 0.01999274f, 0.00679549f, 0.00888476f, 
    -0.02434292f, -0.01095054f, -0.01763378f, 0.01202198f, 0.00895809f, -0.00810597f, -0.02476733f, -0.01305361f, 
    0.00208986f, -0.00432905f, 0.01482105f, -0.03687508f, -0.01259102f, -0.00343741f, -0.03167060f, 0.03165099f, 
    -0.01704509f, -0.03051689f, -0.03406727f, -0.04524600f, -0.02103681f, 0.01736741f, -0.01820886f, -0.01513572f, 
    -0.00631920f, 0.01666180f, 0.02263235f, 0.01544456f, 0.02472628f, 0.00436015f, 0.03315904f, -0.01330400f, 
    -0.02285150f, -0.04291742f, -0.01372874f, -0.02452276f, -0.00890954f, -0.00834811f, -0.03826850f, -0.01977387f, 
    -0.02958258f, 0.00046829f, -0.01262663f, 0.00786743f, 0.01871349f, 0.01308848f, -0.00684111f, -0.03643095f, 
    -0.01439986f, -0.00217060f, 0.02606600f, 0.02666036f, -0.02049384f, -0.02075854f, -0.04464857f, -0.02759449f, 
    0.01092083f, -0.02114818f, -0.04518421f, 0.00581125f, 0.01629438f, -0.03762485f, -0.01036193f, -0.01623812f, 
    0.01363099f, -0.03992397f, 0.02176943f, 0.01511053f, -0.03503901f, 0.00622618f, -0.00475945f, 0.01587365f, 
    -0.01533231f, -0.04425683f, -0.03227006f, -0.02129450f, -0.00636465f, -0.01367542f, 0.02798044f, -0.03978702f, 
    0.02524033f, 0.04070830f, 0.22151235f, -0.05128434f, 0.09761413f, -0.03627961f, 0.07801498f, -0.02295325f, 
    0.02389001f, 0.01654891f, -0.05263718f, 0.09036598f, -0.00165794f, 0.14339943f, -0.02537429f, 0.19281197f, 
    0.16943365f, 0.00041045f, -0.02274922f, 0.04459225f, 0.21581310f, 0.26802123f, 0.19520232f, 0.53953749f, 
    -0.24712637f, 0.05156438f, 0.17313732f, -0.11380257f, -0.08498514f, 0.17983063f, -0.01544518f, -0.07659039f, 
    0.30344358f, 0.13508675f, 0.11572286f, 0.23251490f, 0.17890780f, 0.06423224f, 0.06521623f, 0.01248856f, 
    -0.33253551f, 0.10255066f, -0.11552162f, -0.03176297f, -0.04914237f, 0.10081135f, -0.09393066f, 0.03795778f, 
    -0.11209982f, 0.01413651f, -0.00546439f, -0.05163897f, -0.03424672f, 0.16107018f, 0.10037695f, 0.09208497f, 
    -0.01235321f, 0.19732444f, 0.01881525f, 0.09337351f, -0.17555323f, 0.04999962f, -0.08246605f, 0.08682784f, 
    0.00472129f, 0.03148349f, 0.14307581f, -0.04904144f, -0.00794079f, -0.06259631f, 0.36560339f, 0.26715302f, 
    0.13532941f, 0.18041265f, 0.29861963f, -0.07558772f, 0.07235973f, 0.07088036f, 0.14402613f, 0.01520816f, 
    0.07960312f, 0.05796625f, -0.07704463f, -0.04473967f, 0.03169937f, 0.10669162f, 0.02272251f, -0.02090182f, 
    0.26245663f, 0.06975704f, 0.03099648f, -0.04809845f, 0.22757171f, 0.08601880f, -0.02579352f, 0.01366618f, 
    0.12138373f, 0.18094262f, -0.01367435f, 0.01106057f, -0.30313349f, 0.19963342f, -0.01914807f, 0.11406359f, 
    -0.04836706f, -0.00298327f, 0.07720242f, -0.06631603f, 0.01671982f, -0.08193035f, 0.09962864f, -0.06258785f, 
    0.04369703f, 0.07961364f, 0.06571398f, 0.08119113f, -0.03219686f, 0.04305907f, -0.01974507f, -0.06271254f, 
    -0.01399263f, 0.30734283f, -0.26651013f, 0.05092938f, 0.20979030f, 0.06269928f, 0.03667695f, -0.03276603f, 
    0.05637510f, 0.20794931f, 0.19093049f, 0.11496352f, 0.20180905f, -0.05935754f, 0.11230762f, -0.09078974f, 
    0.07971472f, -0.10600302f, 0.15248226f, -0.07358861f, 0.01034573f, 0.17937505f, -0.16566697f, -0.04271531f, 
    0.32610995f, 0.15018716f, 0.08225101f, -0.04899172f, -0.00747970f, 0.01803983f, -0.07698998f, 0.02740799f, 
    0.04151622f, 0.02771831f, 0.09225959f, 0.19289017f, -0.00013572f, 0.04715486f, 0.27456155f, -0.15194255f, 
    -0.04872511f, -0.27677381f, -0.26387200f, -0.15002801f, 0.02235276f, -0.06268006f, -0.15680359f, -0.04413402f, 
    -0.15200874f, -0.28531027f, -0.03524287f, -0.09739734f, -0.06363662f, -0.04700815f, 0.03974696f, 0.04769569f, 
    0.08622658f, 0.23380466f, -0.13082188f, 0.08968501f, 0.08864339f, -0.07112954f, -0.21692124f, 0.10901051f, 
    -0.14171675f, 0.11171446f, -0.06279702f, -0.01884449f, 0.02678622f, 0.00196915f, 0.12113844f, 0.03981927f, 
    0.07657477f, 0.12888053f, 0.18378586f, 0.08854140f, -0.03355785f, 0.15404299f, 0.01029887f, -0.02998006f, 
    0.12766576f, -0.31659007f, -0.06838700f, 0.18017642f, -0.14270058f, 0.02148415f, -0.02372766f, 0.03121612f, 
    -0.01388588f, -0.00611925f, 0.03751777f, 0.11557723f, -0.04932398f, -0.07499809f, -0.00747165f, 0.07356996f, 
    0.11145429f, 0.14466789f, -0.01903667f, 0.09857344f, 0.27885994f, 0.18491624f, -0.53652394f, 0.05291134f, 
    0.31226075f, 0.17285827f, 0.08795713f, 0.01228612f, 0.03207286f, -0.00687867f, 0.03580427f, 0.03670841f, 
    -0.02129135f, 0.00518403f, -0.03808725f, 0.11830663f, 0.21816266f, -0.01748282f, 0.10167703f, 0.11807518f, 
    -0.05118497f, -0.14140761f, -0.19747472f, -0.07139749f, -0.10467024f, 0.02479348f, -0.21328032f, 0.01439874f, 
    0.06697949f, -0.26767281f, 0.03492949f, 0.02993609f, -0.01439475f, 0.05074027f, 0.07414550f, 0.10469706f, 
    0.05114759f, 0.03498825f, -0.13218041f, -0.21639197f, -0.72548038f, 0.23449099f, -0.00192843f, -0.14609708f, 
    -0.08419999f, -0.05836001f, -0.06950767f, 0.02202643f, 0.04034936f, 0.14161706f, 0.10793652f, 0.06719854f, 
    -0.26662669f, 0.03537064f, -0.06673373f, -0.04241013f, -0.07407548f, 0.09357669f, 0.01366204f, -0.01451050f, 
    -0.09310367f, 0.05056119f, -0.07448476f, 0.04869234f, -0.00063964f, 0.13242181f, -0.06861430f, 0.08278763f, 
    0.06633238f, 0.08654354f, 0.07050452f, 0.00496785f, 0.01666665f, 0.13458325f, 0.07952488f, 0.16253202f, 
    -0.04987349f, 0.21006511f, 0.11292902f, 0.00826586f, -0.11667866f, 0.08177781f, -0.21724992f, 0.02262031f, 
    0.20821844f, 0.00155937f, 0.05058813f, -0.05199687f, 0.04413071f, -0.02077322f, 0.08218374f, -0.01130763f, 
    0.06870981f, 0.08918801f, 0.10282368f, 0.36287907f, 0.06321649f, -0.02757256f, 0.13875747f, -0.03776849f, 
    -0.28227520f, 0.10864054f, 0.10602770f, 0.04373290f, -0.08183455f, 0.03085087f, -0.00542506f, 0.03289706f, 
    0.10766330f, 0.12879582f, 0.12883790f, -0.08240800f, 0.10100882f, 0.00473460f, -0.07355849f, -0.07543992f, 
    -0.03253841f, 0.05196184f, -0.04853405f, -0.06127087f, -0.00381805f, 0.06986651f, -0.04231606f, -0.04737872f, 
    0.01768446f, 0.04665143f, -0.02598910f, -0.07496396f, -0.00018333f, -0.02753616f, 0.26103225f, 0.16428526f, 
    0.24280463f, 0.06668118f, 0.06382069f, 0.00800994f, -0.07035819f, 0.08416849f, -0.14612360f, 0.06994096f, 
    0.04086390f, -0.02868287f, 0.13466848f, -0.21718317f, 0.29518947f, -0.12781495f, -0.03077034f, -0.12643754f, 
    -0.07641433f, -0.18801942f, -0.05317420f, -0.06099762f, 0.06233068f, -0.03737191f, 0.00020481f, 0.15147060f, 
    0.03104351f, 0.02866277f, -0.08154976f, -0.15047820f, 0.05443483f, -0.10357620f, -0.08626463f, 0.05894024f, 
    -0.07304143f, 0.00829571f, 0.06395711f, -0.07631286f, -0.11114017f, -0.01482583f, 0.06561641f, 0.11184493f, 
    0.03926532f, 0.21626472f, 0.11123955f, 0.09420905f, 0.12575950f, 0.11262993f, -0.04457569f, -0.00436214f, 
    -0.07720249f, -0.19834593f, -0.10424123f, -0.18174638f, 0.00057820f, -0.03065163f, -0.19375171f, 0.02910598f, 
    -0.00986813f, -0.31945691f, 0.05925864f, 0.02493316f, -0.03888377f, 0.00145616f, 0.10621678f, 0.03865567f, 
    0.05483285f, 0.13238831f, 0.03316529f, -0.11804415f, -0.20072755f, -0.03776501f, -0.00470356f, -0.18245018f, 
    -0.01875959f, 0.09231959f, -0.01819342f, -0.03241058f, 0.12143824f, 0.15510514f, 0.04866207f, 0.26962855f, 
    0.12837259f, 0.07292520f, 0.11519954f, -0.03488147f, -0.09932441f, -0.00387560f, -0.05016683f, 0.04225690f, 
    0.24993826f, 0.18615429f, 0.16305180f, 0.07871763f, -0.05400517f, -0.00629437f, 0.01875352f, 0.06156807f, 
    -0.04855171f, -0.03316491f, -0.00244917f, -0.03409082f, 0.00437059f, -0.00664902f, -0.00323393f, 0.03671321f, 
    0.21249916f, 0.10209353f, -0.07823559f, 0.00289342f, 0.18452236f, 0.00333373f, 0.27800706f, -0.17891943f, 
    0.13090980f, 0.07070518f, -0.03040921f, 0.03152438f, 0.02728858f, -0.07145500f, -0.14128594f, -0.03978071f, 
    -0.06709825f, -0.09539908f, -0.05079098f, -0.07471131f, -0.08470184f, -0.02248049f, 0.02774904f, -0.02902073f, 
    0.10240857f, 0.22570883f, 0.06378999f, -0.06091935f, -0.02746326f, -0.00709655f, 0.00513537f, 0.04326654f, 
    0.01264530f, -0.09139203f, -0.12123828f, -0.06106857f, -0.05482767f, -0.11991642f, -0.08836807f, 0.06848734f, 
    0.07938930f, 0.13574763f, -0.04240198f, 0.03749533f, 0.18689224f, -0.03932573f, -0.01596207f, -0.11170661f, 
    0.01032180f, -0.06789246f, -0.12630223f, -0.08537496f, -0.10378442f, -0.24337798f, 0.04737869f, 0.04919555f, 
    0.05243536f, -0.11306192f, -0.04106450f, -0.03852708f, 0.14437625f, 0.08974674f, 0.02627215f, 0.09195513f, 
    0.01050133f, -0.22120148f, -0.09933454f, -0.02075298f, -0.09761253f, 0.00395266f, -0.12460954f, -0.02224678f, 
    -0.01647796f, 0.09807367f, -0.08975557f, -0.06972591f, -0.09869196f, -0.08049551f, -0.06673872f, -0.01685736f, 
    0.05328378f, 0.07852681f, -0.00832122f, 0.03189453f, -0.29032123f, -0.02895779f, 0.17760417f, -0.00833041f, 
    0.15227734f, -0.04889735f, 0.18817948f, 0.16033967f, 0.02296556f, 0.06280044f, 0.11000028f, 0.09872485f, 
    0.00648353f, 0.09349550f, 0.08776116f, 0.06181940f, 0.10048868f, 0.03723044f, 0.17148519f, 0.12409161f, 
    -0.45358151f, 0.07260372f, -0.12942368f, -0.02344167f, -0.11023019f, 0.02975491f, -0.02589850f, -0.06377780f, 
    -0.00083453f, 0.08489335f, 0.17797816f, -0.03912906f, 0.04031445f, 0.06523587f, 0.04458649f, 0.03563592f, 
    -0.03646277f, -0.05383679f, -0.00219061f, 0.03768009f, -0.26905003f, -0.04783826f, -0.09953354f, -0.00177220f, 
    -0.08754252f, -0.01811177f, 0.09226535f, -0.02739261f, -0.01230041f, 0.04900460f, 0.23523514f, 0.06008326f, 
    0.10543186f, 0.01448914f, 0.00786292f, 0.01461347f, 0.01825297f, -0.02255673f, 0.02832467f, 0.07261696f, 
    -0.32786247f, -0.25061145f, 0.02278115f, 0.00911163f, -0.16692349f, 0.09914383f, -0.25235644f, -0.02035181f, 
    -0.12879306f, -0.17224658f, -0.02082865f, -0.05573313f, -0.07456114f, -0.01249327f, -0.05835435f, 0.01656929f, 
    0.04385881f, 0.09031741f, -0.02380817f, 0.12154544f, 0.16394311f, 0.02165096f, 0.13313241f, -0.15571415f, 
    -0.00104855f, 0.12230820f, 0.01406927f, 0.04967814f, 0.02826507f, -0.00866738f, -0.05516552f, -0.06174927f, 
    -0.07467099f, -0.09380219f, -0.07430455f, -0.03271718f, -0.06015278f, 0.00632163f, -0.05015821f, -0.04353394f, 
    0.02437595f, -0.00739423f, -0.00068743f, 0.01800416f, 0.02320242f, -0.03062224f, 0.01473569f, -0.04356087f, 
    0.01743588f, -0.03064595f, -0.02128080f, 0.00617432f, 0.02156423f, -0.03705551f, -0.00504825f, -0.04386172f, 
    0.00993794f, -0.03044842f, 0.02012313f, -0.01119984f, -0.02722695f, 0.03241682f, 0.02220909f, 0.02098541f, 
    -0.00193158f, -0.03615959f, -0.02387176f, 0.03164968f, 0.01381505f, 0.00251128f, -0.01094794f, -0.02543777f, 
    0.00026158f, -0.00660475f, 0.01148158f, -0.00794898f, -0.03767400f, 0.02844552f, -0.03646539f, -0.02276892f, 
    0.00939870f, -0.03138024f, -0.02919401f, 0.01777316f, 0.00145408f, 0.03127538f, -0.02336945f, -0.03745229f, 
    -0.03174068f, 0.00821790f, -0.01467218f, -0.01582072f, -0.01793236f, 0.00385865f, -0.01317849f, 0.02627424f, 
    -0.04094679f, -0.02283231f, 0.03179830f, -0.00774688f, 0.02975325f, 0.03119249f, 0.01543804f, -0.03019696f, 
    -0.04010447f, 0.01377382f, 0.02942275f, 0.02484962f, -0.03656782f, -0.00083647f, 0.02177421f, -0.00482625f, 
    0.02151496f, -0.01634944f, -0.03559284f, 0.03093668f, -0.01833703f, 0.00568236f, -0.03663386f, -0.04172838f, 
    -0.04240149f, -0.00651520f, -0.00182937f, -0.02328264f, 0.01442443f, -0.02320871f, -0.03636255f, -0.03149135f, 
    -0.01525050f, 0.00450939f, -0.00560744f, 0.01129634f, 0.01159533f, 0.02980687f, -0.03083483f, 0.01678884f, 
    -0.01216417f, 0.03266309f, -0.01731935f, 0.00054338f, 0.01122277f, 0.00172492f, -0.02174837f, 0.02933259f, 
    0.00619632f, -0.02150780f, 0.00379427f, 0.02684309f, 0.02068046f, 0.01339386f, 0.01232488f, -0.01934373f, 
    -0.02796258f, -0.01645323f, -0.03963669f, 0.01316806f, -0.01287850f, 0.01444291f, -0.02780318f, 0.02498779f, 
    -0.00250984f, 0.00123465f, -0.00477722f, -0.02935900f, -0.02490061f, -0.00752103f, -0.04102518f, -0.03275089f, 
    -0.02377672f, -0.01781134f, -0.03841470f, 0.02518327f, 0.01428396f, -0.04579835f, 0.02077201f, -0.01881113f, 
    0.00099175f, -0.04391658f, 0.00099378f, 0.02215708f, -0.03188216f, 0.01054911f, 0.00938281f, -0.01459732f, 
    -0.02226390f, 0.03214261f, -0.02578693f, -0.00940845f, -0.02913985f, -0.01755514f, -0.03258819f, 0.02230343f, 
    -0.00332075f, -0.00641799f, -0.03063181f, -0.00131945f, -0.04123630f, -0.00440290f, -0.01385219f, 0.00858682f, 
    0.02296573f, 0.00786881f, -0.01423852f, -0.02051795f, 0.00503930f, 0.01420313f, -0.03618053f, -0.01628224f, 
    -0.03188692f, -0.01080372f, 0.02669585f, -0.02286491f, 0.02196169f, 0.00781643f, 0.02723530f, -0.01268906f, 
    -0.03858941f, -0.04458165f, 0.01106548f, -0.01127862f, 0.01145552f, -0.00719824f, -0.01331833f, 0.01373661f, 
    -0.01038804f, 0.00226282f, -0.02417524f, -0.01792920f, -0.00078832f, -0.00581573f, 0.02725497f, -0.00096387f, 
    0.02824126f, 0.01818029f, 0.02521461f, 0.01424900f, 0.01566934f, 0.02612988f, 0.02646680f, -0.03426564f, 
    -0.00801455f, -0.00036485f, -0.03827462f, -0.00378079f, -0.00052317f, -0.04482782f, -0.00693737f, -0.02478471f, 
    0.00029242f, -0.03988530f, -0.00465069f, -0.01326004f, 0.00202602f, -0.01399119f, 0.01203351f, -0.02911448f, 
    0.02534207f, -0.02860541f, -0.04149645f, -0.03044459f, 0.01811171f, 0.01172636f, 0.04416610f, 0.00450289f, 
    -0.00356896f, -0.01252392f, 0.00232498f, -0.00242227f, 0.01075965f, -0.00310009f, -0.02683694f, -0.01810043f, 
    0.02499813f, -0.03672149f, -0.02501199f, -0.04762330f, -0.02355179f, 0.00341393f, -0.01243507f, -0.02802854f, 
    0.00648014f, -0.01543808f, -0.01778786f, 0.01756380f, -0.00446764f, -0.03250988f, -0.00516818f, 0.02472187f, 
    0.02889925f, -0.04212306f, -0.01263525f, 0.03270195f, -0.02966745f, -0.02615977f, -0.03580836f, -0.04241835f, 
    -0.03179016f, -0.01918724f, -0.00694639f, -0.03108455f, -0.02989747f, 0.02587357f, -0.03153709f, -0.02481702f, 
    0.00549510f, -0.01377034f, 0.00269385f, -0.01405143f, 0.00448350f, -0.03874239f, 0.03084071f, 0.02594567f, 
    -0.01202320f, 0.03334227f, 0.01092176f, -0.01427208f, 0.02268650f, 0.01883490f, 0.01050458f, -0.04566224f, 
    -0.00697838f, 0.01587704f, 0.00963664f, -0.01386743f, -0.03080739f, 0.00386382f, -0.00286967f, -0.03385430f, 
    -0.04680832f, 0.01410580f, -0.02090637f, 0.02578672f, 0.02187281f, -0.01125762f, -0.00420670f, 0.00550211f, 
    0.00107607f, -0.00584865f, -0.02719753f, 0.01720284f, -0.00350465f, -0.02865522f, -0.00535093f, 0.02025934f, 
    -0.02092076f, -0.03071743f, 0.00217873f, -0.04430953f, -0.00094846f, -0.02644275f, -0.03627527f, 0.01858176f, 
    -0.03847717f, -0.04419795f, -0.01085825f, -0.01046896f, -0.03183961f, 0.01944762f, 0.02321038f, -0.03615765f, 
    -0.02963902f, 0.00293460f, 0.01317133f, -0.03710972f, -0.03622840f, 0.00275275f, 0.00677661f, -0.01382639f, 
    0.00324702f, 0.01797553f, 0.01336100f, -0.01332939f, 0.01730105f, -0.02657834f, -0.01569613f, -0.02981545f, 
    0.00691712f, 0.00485735f, 0.01279072f, -0.02497281f, -0.00096023f, -0.02516895f, 0.00696561f, -0.02886895f, 
    0.01830103f, 0.00238679f, -0.01708238f, -0.03908949f, -0.03719745f, -0.02121212f, -0.00432298f, 0.02997930f, 
    0.01079048f, -0.02901943f, -0.01444648f, 0.01049457f, 0.00391737f, -0.04019627f, 0.01701613f, -0.02987657f, 
    -0.00205186f, 0.00167701f, 0.02917032f, -0.00767288f, 0.00061335f, 0.02724694f, 0.00866165f, -0.03114596f, 
    -0.00949022f, -0.04482920f, 0.00389270f, -0.02947108f, -0.03237913f, 0.01164389f, -0.01360928f, 0.02618386f, 
    -0.02441201f, 0.01533631f, -0.03929231f, 0.00591956f, 0.00750519f, 0.03361680f, -0.00280150f, -0.03301850f, 
    -0.02033951f, -0.02932508f, 0.02191824f, -0.03458005f, 0.02966375f, 0.01810540f, -0.01261128f, 0.01897140f, 
    0.02587987f, -0.01568623f, -0.04143738f, -0.04237515f, -0.04095802f, -0.03415821f, -0.02364267f, -0.01125172f, 
    -0.00594383f, -0.01191573f, 0.02325650f, -0.02585490f, 0.01754028f, -0.00336576f, 0.01448467f, 0.00230015f, 
    0.02426195f, -0.04224208f, 0.02449699f, 0.02122419f, -0.04031077f, 0.01316411f, -0.03583933f, -0.02205821f, 
    -0.02656642f, -0.01252220f, -0.04371854f, 0.02966280f, -0.03602347f, 0.00102986f, 0.02186977f, -0.02801005f, 
    -0.02206462f, -0.03497916f, -0.04615158f, -0.00418604f, -0.01591896f, 0.01568152f, 0.01358755f, 0.02416661f, 
    0.00855778f, -0.04162602f, -0.00214105f, -0.04492975f, -0.04494407f, 0.01100223f, -0.01189301f, 0.02551791f, 
    -0.01137587f, 0.01291030f, -0.01003382f, 0.03326277f, 0.01957851f, -0.02084687f, 0.03240638f, -0.04087118f, 
    0.00188621f, 0.02113590f, 0.01923572f, 0.01379979f, 0.01370494f, 0.01844160f, -0.02659189f, 0.03142130f, 
    0.00838242f, -0.01215854f, -0.00478832f, 0.03009949f, -0.01938978f, -0.02715741f, 0.01847030f, -0.00717771f, 
    0.01305995f, -0.03908167f, -0.01566616f, -0.03257702f, -0.02407493f, 0.00348716f, -0.02284588f, -0.01046293f, 
    -0.01202574f, 0.02845035f, -0.00811936f, 0.02969408f, -0.03570604f, -0.01647244f, 0.01767791f, 0.00274558f, 
    0.02747844f, 0.00126680f, 0.01791601f, -0.02456198f, 0.03175701f, -0.00368898f, 0.03473681f, 0.01478556f, 
    -0.03577976f, 0.02634507f, 0.02415331f, -0.03997637f, 0.03253724f, -0.00136145f, -0.03501095f, -0.04574748f, 
    -0.01549707f, -0.04596720f, -0.01809499f, 0.02547033f, -0.00438129f, 0.00319312f, 0.02933135f, 0.02796696f, 
    -0.01632366f, -0.02700838f, -0.00158361f, 0.01648278f, -0.04116023f, 0.01646002f, 0.02767803f, -0.01502496f, 
    -0.03750566f, 0.01231815f, -0.00472205f, 0.01984574f, -0.02084558f, 0.00154677f, -0.01597308f, 0.02889860f, 
    0.02099506f, 0.02706630f, -0.02522304f, 0.02953108f, 0.02803258f, 0.00660725f, 0.01351075f, 0.01701062f, 
    0.01690456f, -0.03975289f, -0.03304296f, 0.00059221f, -0.00560623f, 0.00073413f, -0.01023485f, -0.03484920f, 
    -0.03309878f, 0.02101829f, -0.02270784f, -0.01283846f, -0.03680981f, -0.02522950f, -0.04293897f, -0.00098463f, 
    -0.00673771f, -0.01536278f, 0.00500645f, -0.01576866f, -0.02883573f, -0.02748180f, 0.02000990f, -0.02402007f, 
    0.02729801f, -0.00630219f, -0.04494773f, -0.01772412f, 0.01527724f, -0.04381875f, -0.02569934f, 0.00187844f, 
    -0.01260407f, -0.01389891f, 0.02770868f, -0.02511774f, -0.00054797f, -0.03844137f, -0.03263130f, -0.01451960f, 
    0.00402162f, -0.02519180f, 0.02947254f, -0.01132886f, -0.00448456f, -0.02698284f, 0.02594687f, 0.01679820f, 
    -0.04646881f, -0.04289462f, -0.03974609f, -0.04051122f, 0.00158981f, 0.03229027f, 0.00990846f, 0.01231898f, 
    -0.03550284f, -0.03286202f, 0.01531587f, 0.01493665f, -0.03578513f, 0.02806589f, -0.02302241f, -0.01188500f, 
    -0.04128033f, -0.00379130f, -0.00350182f, 0.03234475f, -0.00954918f, 0.03188479f, 0.01173616f, 0.02804157f, 
    -0.03599139f, -0.03079509f, -0.03083736f, 0.02266554f, 0.01823850f, -0.02110364f, -0.01883091f, -0.01576763f, 
    -0.03157651f, -0.03529666f, -0.02139160f, -0.00298542f, -0.01512790f, -0.03238275f, 0.01270201f, -0.02837692f, 
    -0.03229354f, -0.02647991f, -0.04155857f, -0.03566499f, 0.01547588f, 0.00999128f, 0.00281107f, 0.03507094f, 
    -0.00533161f, 0.03365238f, -0.01625944f, -0.02258453f, 0.00231998f, -0.03230713f, 0.00383196f, 0.02618817f, 
    -0.04445330f, 0.02431084f, -0.04015627f, 0.00313706f, 0.00940039f, 0.00575357f, 0.00938919f, 0.01597437f, 
    0.20798765f, -0.23705192f, -0.19236687f, -0.11981978f, 0.18512295f, -0.08496127f, -0.12956977f, 0.00484495f, 
    -0.21806006f, -0.07876878f, 0.14715627f, 0.13386036f, 0.05969016f, 0.02238895f, 0.10407171f, 0.14326751f, 
    0.07076813f, -0.03732393f, 0.01545738f, 0.05803968f, 0.15670641f, -0.09842511f, -0.46575686f, -0.46732876f, 
    0.05133430f, -0.03738774f, 0.12241204f, -0.21555273f, 0.14727259f, 0.06241560f, 0.20204370f, 0.05537497f, 
    0.04742282f, 0.05393466f, 0.01519978f, 0.05852119f, 0.02789778f, -0.09956372f, 0.20381957f, 0.06594758f, 
    -0.11574630f, 0.09891772f, 0.60522991f, 0.19288218f, -0.11513706f, 0.00138985f, -0.01720253f, 0.10427661f, 
    0.10030888f, -0.09922617f, 0.15394348f, -0.02125157f, -0.02616723f, -0.15949264f, -0.04108930f, 0.05621604f, 
    0.02956577f, -0.00049542f, -0.10740969f, 0.03494351f, 0.04191131f, -0.25602210f, -0.08316017f, 0.08154580f, 
    0.37637445f, -0.05381766f, -0.07338035f, -0.17950386f, 0.03130232f, 0.06540001f, 0.08566665f, 0.17946985f, 
    0.01308762f, 0.11670875f, 0.08945189f, 0.07630093f, 0.05690231f, 0.02439164f, -0.12799446f, -0.19902922f, 
    0.15385935f, 0.17663833f, 0.13739310f, 0.12176638f, -0.31581661f, -0.09456921f, 0.03540123f, 0.07553287f, 
    -0.01083078f, -0.05652920f, -0.04063994f, 0.02796271f, -0.13950014f, 0.00080397f, 0.03185638f, 0.07457020f, 
    0.03298115f, -0.01233018f, 0.03608336f, 0.06388833f, 0.06138130f, -0.11079378f, 0.38766804f, 0.18777071f, 
    -0.07605996f, 0.03957453f, -0.07655312f, 0.03466380f, 0.10220077f, -0.00274189f, 0.13284692f, 0.05190224f, 
    0.00663719f, -0.07136603f, 0.03030431f, 0.07199821f, -0.00465542f, -0.02200795f, 0.08733046f, 0.01353450f, 
    -0.91093338f, -0.07268474f, -0.04750997f, 0.29006350f, 0.24975416f, 0.05135550f, -0.10471036f, -0.09242279f, 
    -0.03465831f, -0.06331094f, 0.14174303f, 0.08582988f, -0.03514948f, -0.03357302f, 0.15691009f, 0.15334105f, 
    0.11533952f, 0.11556122f, 0.09860907f, 0.07660978f, -0.36229575f, 0.31288049f, 0.50018823f, -0.04520826f, 
    -0.29543975f, 0.05462512f, -0.16035216f, -0.04065943f, -0.01693951f, -0.02761818f, 0.12937161f, -0.04142974f, 
    -0.03999333f, -0.00244904f, 0.02905437f, 0.11247890f, 0.02744924f, 0.01540373f, -0.01536545f, 0.08993795f, 
    -0.11173262f, 0.38683400f, 0.25178990f, -0.12761106f, -0.17120142f, -0.02387205f, -0.11660842f, -0.04330127f, 
    0.20914628f, -0.07538094f, -0.07297105f, 0.09125695f, 0.07620464f, 0.04928773f, -0.08852900f, 0.01963533f, 
    0.08764707f, -0.18833904f, -0.06971046f, 0.03059139f, 0.05756198f, 0.14876415f, 0.24037014f, 0.00431308f, 
    -0.13631220f, 0.10398171f, 0.12038282f, 0.01847727f, -0.03795670f, 0.19533975f, -0.00271117f, -0.07550426f, 
    0.07076627f, -0.00892727f, 0.09727336f, 0.01077266f, 0.07330481f, -0.05069785f, -0.07763237f, 0.08862258f, 
    -0.05471075f, 0.28932893f, 0.12609479f, 0.13067265f, 0.07250725f, -0.02208165f, 0.07903150f, 0.08651322f, 
    0.08123524f, -0.04075387f, -0.03933942f, -0.01472586f, 0.08046637f, -0.04579029f, -0.10507591f, -0.00836499f, 
    0.06758031f, -0.02246375f, 0.00055144f, 0.08947432f, 0.08502202f, -0.37329859f, -0.13702302f, -0.37406424f, 
    0.06473856f, -0.19199178f, 0.13241147f, -0.06812865f, 0.01902497f, 0.07043742f, -0.03730472f, -0.15518701f, 
    0.15265681f, 0.16593589f, 0.11086908f, -0.10998620f, -0.21292381f, -0.10879588f, -0.04081266f, 0.12305855f, 
    -0.11152920f, 0.26444373f, 0.38534242f, 0.13295381f, -0.27199662f, 0.07597151f, -0.07533699f, 0.04359172f, 
    -0.08769578f, 0.07314972f, -0.09027564f, 0.03788182f, 0.03349629f, -0.00759062f, 0.06354987f, -0.04834205f, 
    0.02789635f, -0.00798907f, -0.05397896f, 0.03561186f, -0.03878586f, -0.31628582f, 0.26833621f, -0.24451707f, 
    -0.27029493f, -0.04728430f, -0.14630455f, 0.00937622f, 0.21872124f, -0.05080332f, 0.12427650f, 0.02483091f, 
    -0.00833738f, 0.01714589f, -0.04357674f, -0.03794542f, 0.11399388f, -0.14397712f, 0.00176227f, -0.01206334f, 
    -0.06739067f, 0.09785853f, 0.31126353f, 0.20472071f, -0.09566602f, 0.07225381f, 0.12616539f, 0.11410613f, 
    0.10176046f, -0.04357125f, 0.11280136f, -0.10270417f, -0.00749342f, -0.10533977f, 0.08430424f, 0.08432172f, 
    0.13427393f, -0.10320713f, -0.08141428f, 0.11374501f, 0.14280634f, -0.33993074f, -0.14738658f, -0.15812387f, 
    0.35881037f, -0.06718048f, 0.01236101f, -0.05478512f, -0.05419079f, -0.04416842f, 0.02289363f, 0.10831408f, 
    0.13775961f, 0.07206571f, -0.04189378f, 0.05938988f, 0.02167639f, 0.05084324f, -0.05807032f, 0.12678370f, 
    0.02220604f, 0.18456246f, 0.27680346f, 0.08126931f, -0.14081833f, 0.01766211f, -0.02048758f, 0.13207228f, 
    0.05995673f, 0.07929795f, 0.04539987f, 0.06925520f, 0.01624061f, 0.09572800f, 0.14585683f, 0.00180456f, 
    0.08388929f, 0.04129890f, 0.05396534f, 0.08264107f, -0.07869034f, -0.12155926f, -0.07567693f, -0.18892020f, 
    0.17782284f, -0.27422392f, -0.08949222f, 0.17867005f, -0.11977393f, -0.21517128f, 0.10362650f, -0.07429762f, 
    0.02779142f, 0.10135260f, 0.17579989f, -0.04375275f, -0.02392139f, -0.14335698f, -0.04191381f, -0.09839430f, 
    0.75775468f, -0.05566758f, -0.13814558f, -0.08391520f, -0.03158289f, -0.25761148f, -0.17982402f, -0.09988232f, 
    -0.19243839f, -0.15665324f, 0.00776405f, 0.09531400f, 0.09781728f, -0.03849591f, -0.02905692f, 0.23273756f, 
    0.04398707f, 0.17656693f, 0.13989371f, 0.08215658f, 0.21341613f, -0.12882997f, -0.11268657f, -0.25190514f, 
    0.15717821f, 0.02965385f, -0.18857473f, -0.18024909f, -0.07290036f, -0.24283557f, 0.13496509f, 0.11463694f, 
    0.07518647f, 0.08185671f, -0.03640901f, -0.09932605f, 0.11451671f, 0.01936025f, 0.06835995f, 0.00680486f, 
    -0.09666160f, 0.11820631f, 0.15129989f, 0.07453912f, -0.30046412f, 0.00582700f, 0.05476351f, -0.11156664f, 
    0.10414379f, 0.11755284f, -0.12750880f, 0.04652289f, -0.08091032f, -0.00994466f, 0.01362054f, -0.03189322f, 
    0.04014998f, -0.14024103f, 0.06774431f, -0.00152507f, 0.67435127f, 0.01750172f, 0.06054049f, 0.05673552f, 
    -0.40471739f, -0.22269544f, -0.18571976f, -0.15448835f, -0.03882785f, -0.02338232f, 0.06255210f, -0.01963039f, 
    0.08912250f, 0.03333981f, -0.09234025f, 0.01274221f, 0.11923160f, -0.13678026f, -0.14230026f, 0.03482642f, 
    -0.06928419f, 0.00254633f, -0.37847462f, -0.16258048f, 0.14827220f, 0.01774041f, 0.09112264f, -0.01158386f, 
    0.19662710f, 0.11518702f, -0.09127471f, 0.03791535f, 0.08553544f, 0.04541139f, -0.04552888f, 0.15111548f, 
    -0.10037508f, 0.04095199f, 0.15608013f, -0.02150225f, -0.28219539f, -0.08233434f, -0.45715034f, 0.08532158f, 
    -0.13352689f, 0.23264678f, 0.02943295f, -0.12943418f, 0.08450884f, 0.10801347f, -0.05770976f, -0.00832357f, 
    -0.12078811f, -0.07152132f, -0.06861646f, 0.02230016f, 0.00070812f, 0.04472956f, 0.05777639f, 0.00881634f, 
    -0.04411328f, -0.33913019f, -0.18324466f, 0.15229361f, 0.32758117f, -0.04091502f, 0.06190750f, 0.01235446f, 
    0.12498149f, 0.18099424f, 0.00595444f, -0.07702559f, -0.13892488f, 0.07600614f, -0.13140394f, 0.07597977f, 
    -0.00435869f, -0.02418872f, 0.06157818f, -0.21044648f, -0.51949030f, 0.05953418f, -0.03696928f, 0.14286685f, 
    0.04733827f, 0.00750907f, -0.06319405f, -0.03152532f, -0.02484770f, 0.05970328f, -0.15060709f, -0.02263421f, 
    0.03127900f, 0.09894966f, -0.10641111f, -0.09652719f, -0.13164899f, -0.21074648f, -0.10264193f, -0.20576508f, 
    -0.23397301f, 0.34403327f, 0.11409577f, 0.13427693f, -0.00382044f, -0.02158773f, 0.07590466f, 0.02240373f, 
    -0.00271916f, 0.09130755f, -0.01476347f, -0.01204823f, 0.06246361f, 0.05610317f, -0.07755482f, 0.00555473f, 
    0.08825252f, -0.13057920f, -0.08184432f, -0.00410969f, -0.17344707f, -0.00325042f, -0.21142294f, 0.21719092f, 
    0.12945473f, 0.19183324f, -0.06852839f, -0.16331187f, 0.09822837f, -0.02342457f, -0.05541402f, -0.01769117f, 
    0.05019724f, 0.14440365f, 0.08915059f, -0.03191342f, 0.20651272f, 0.04604749f, -0.03625082f, -0.02372098f, 
    0.02481200f, -0.28467241f, 0.27001193f, 0.28609681f, 0.01585514f, -0.18447085f, -0.19739708f, 0.00615679f, 
    -0.04522005f, -0.07062516f, 0.12592036f, 0.09178434f, 0.09299085f, -0.01408165f, 0.04996007f, 0.10443070f, 
    -0.01022190f, 0.05021084f, -0.07615428f, -0.00851572f, 0.24412178f, -0.26877144f, 0.19487487f, 0.08836486f, 
    0.14923841f, -0.17397200f, -0.09357924f, -0.04376341f, 0.08575445f, -0.08452484f, 0.01469029f, 0.05306418f, 
    0.14140764f, 0.15232533f, 0.07228345f, 0.05228477f, -0.01468630f, 0.04833884f, -0.15023945f, -0.02544802f, 
    0.03164541f, 0.25129494f, 0.34116960f, 0.28863135f, -0.23280218f, -0.04409622f, 0.12233017f, 0.17915004f, 
    0.12721153f, 0.03603212f, -0.01159688f, -0.14715379f, -0.02964463f, -0.14014524f, -0.07009061f, 0.04969049f, 
    0.05789603f, -0.03054354f, -0.19138482f, 0.01146472f, 0.11108250f, -0.12032707f, -0.46931660f, 0.04417747f, 
    0.03695887f, -0.05682527f, -0.03659340f, 0.05091345f, -0.01417529f, 0.19707429f, -0.16087514f, -0.03195990f, 
    -0.05681690f, 0.05706001f, -0.00639834f, 0.00530114f, -0.01847050f, -0.01625281f, 0.02499962f, 0.06988749f, 
    -0.03375171f, 0.06780481f, -0.03115133f, 0.27751023f, -0.14113665f, -0.17544208f, 0.02074918f, -0.11365078f, 
    0.01595431f, -0.10950087f, -0.15956610f, -0.13777095f, -0.09132360f, 0.02212204f, -0.02437119f, -0.03720988f, 
    0.06879344f, 0.08716361f, -0.04816904f, -0.05348267f, 0.35124099f, -0.01451912f, 0.17615995f, 0.36768678f, 
    0.13711320f, -0.11912478f, 0.06872927f, 0.29363179f, 0.02271890f, 0.08468017f, 0.14131138f, -0.00382177f, 
    0.16171409f, 0.20627850f, 0.10550285f, 0.05962231f, 0.06157293f, 0.05388400f, 0.13657461f, -0.04960752f, 
    -0.09156486f, 0.14703414f, -0.52156156f, -0.30694190f, -0.09499275f, -0.03073912f, 0.11023656f, 0.04866242f, 
    -0.14431641f, 0.04015500f, -0.07436230f, 0.02574042f, -0.11472087f, 0.13120478f, 0.15315425f, -0.07232021f, 
    -0.09968249f, 0.02853739f, 0.04801613f, 0.03668966f, -0.11390580f, 0.19939938f, -0.04165497f, 0.01504971f, 
    -0.17084841f, -0.00930811f, 0.03413260f, -0.02618341f, -0.01965984f, -0.17691901f, 0.21594046f, 0.04257803f, 
    -0.08861107f, 0.08941570f, 0.04444380f, -0.18222681f, 0.01806663f, 0.13281639f, 0.05321169f, -0.08999398f, 
    -0.06275910f, -0.19058502f, -0.24719445f, -0.16478154f, 0.22697362f, 0.17940982f, 0.06332134f, 0.04197929f, 
    0.10385017f, 0.04698394f, 0.02273821f, -0.02625136f, 0.06449892f, 0.06199111f, -0.05738349f, -0.01065172f, 
    -0.10840999f, 0.02663754f, -0.00835128f, 0.01136371f, 0.00011788f, -0.00269265f, -0.58875203f, -0.23259354f, 
    -0.22033638f, 0.07181890f, 0.12153105f, 0.15531780f, -0.01800061f, -0.05561566f, -0.03101145f, -0.02791810f, 
    -0.09003305f, 0.15088433f, 0.07619274f, -0.09614404f, 0.05279577f, 0.02232991f, -0.04632500f, -0.07283291f, 
    0.25775051f, 0.33109468f, 0.25643998f, 0.06298380f, -0.05780108f, 0.01079088f, 0.11883365f, 0.06201788f, 
    0.12108370f, 0.10136652f, -0.00057740f, 0.06931617f, 0.05745539f, 0.00907274f, 0.02241561f, -0.10002732f, 
    0.06934503f, 0.03296401f, -0.10676739f, -0.03904659f, 0.14093871f, 0.44966009f, -0.39715979f, -0.04138669f, 
    0.18787172f, -0.12855701f, 0.16040079f, 0.22764845f, -0.00610174f, 0.06803108f, 0.04786664f, -0.01481152f, 
    -0.15057570f, -0.03868553f, 0.04653053f, 0.02693587f, -0.09030310f, -0.07440301f, 0.06406587f, -0.25305018f, 
    0.19197227f, 0.08707029f, 0.15243317f, 0.09665062f, 0.13753453f, -0.08669576f, 0.12678836f, 0.00638708f, 
    -0.16995005f, 0.01708973f, -0.08353835f, 0.04726413f, 0.00530219f, -0.00477143f, 0.04299953f, 0.07343791f, 
    0.02870815f, 0.12661721f, 0.08955146f, 0.10091867f, 0.32716584f, 0.03787713f, 0.15400715f, -0.03228181f, 
    0.01059424f, 0.16960552f, -0.08022565f, 0.08121386f, 0.05817843f, -0.00945637f, 0.05111516f, 0.07225800f, 
    -0.02581995f, 0.03551523f, -0.04483743f, 0.05208248f, -0.07611869f, -0.06516507f, 0.10162462f, -0.13222195f, 
    0.27539650f, -0.07629023f, 0.22867376f, -0.08297173f, -0.05736382f, 0.11564643f, 0.05048542f, -0.01609523f, 
    0.02623148f, 0.11372281f, 0.12281186f, 0.12955047f, 0.04811275f, 0.00121771f, 0.05138581f, 0.04305520f, 
    0.02572226f, -0.05791197f, 0.10802126f, 0.17494005f, -0.08497475f, 0.12475336f, 0.11758375f, 0.30490240f, 
    0.18781838f, 0.10347588f, -0.17811918f, 0.02192190f, -0.06042055f, 0.09022745f, -0.16912837f, 0.03742082f, 
    0.03063858f, -0.01985267f, -0.06754991f, 0.16897635f, 0.18030520f, 0.07432204f, 0.07486218f, 0.18111762f, 
    0.18232664f, 0.11689675f, 0.10817660f, -0.08824165f, -0.13330072f, 0.11854729f, -0.03772757f, 0.01872537f, 
    0.10154873f, -0.08815169f, 0.09498052f, -0.01102759f, -0.04815308f, -0.04517521f, -0.04766760f, 0.09899857f, 
    0.06879083f, -0.06119357f, -0.07499069f, -0.34481767f, -0.27667996f, 0.46137640f, -0.42705506f, -0.06576921f, 
    0.07767623f, -0.03032921f, 0.19896817f, 0.18445005f, -0.19599594f, 0.21010582f, -0.03254780f, 0.05235580f, 
    -0.01876349f, -0.06854367f, -0.00645428f, -0.05824505f, 0.00533589f, 0.11293854f, 0.00496291f, 0.05971698f, 
    0.00010790f, 0.07407188f, -0.04985417f, -0.23223454f, 0.03078376f, 0.06560582f, 0.00813624f, 0.03217933f, 
    -0.05455918f, 0.06195766f, -0.05790244f, 0.01406016f, -0.05385171f, 0.06575754f, 0.17221864f, 0.08869214f, 
    -0.16131596f, -0.07325183f, 0.03075328f, 0.00911004f, -0.12914515f, 0.23598225f, -0.16541050f, 0.24888812f, 
    -0.13163254f, -0.11683807f, -0.17785707f, -0.11104766f, -0.06550702f, -0.13337885f, -0.04292024f, -0.07919298f, 
    -0.05586855f, 0.22437453f, -0.01126097f, 0.05951536f, -0.02492518f, 0.03014932f, -0.01667590f, 0.03058329f, 
    -0.03033776f, -0.24882279f, -0.49723127f, -0.11702216f, -0.09087743f, -0.00055739f, 0.16030541f, 0.12759225f, 
    0.02133512f, 0.06069209f, 0.04026239f, -0.08751269f, -0.00264531f, 0.00039734f, -0.04894089f, -0.08554173f, 
    -0.02457042f, -0.01046539f, -0.02486581f, -0.02990366f, -0.03773925f, 0.05753068f, -0.05836027f, 0.10515438f, 
    -0.14678833f, -0.05164890f, -0.21037671f, -0.18909463f, -0.08332856f, -0.10766130f, -0.13276583f, -0.02324850f, 
    0.05356472f, 0.10889947f, 0.04654505f, -0.01970364f, -0.08184082f, 0.05613408f, -0.08017424f, 0.01546772f, 
    -0.36337954f, -0.02883376f, 0.09354677f, 0.22434607f, 0.26052153f, -0.11908209f, 0.04084552f, -0.09948276f, 
    0.03665581f, -0.06127966f, 0.04625417f, 0.04915662f, -0.00176155f, 0.05950045f, 0.09441035f, -0.02668257f, 
    0.00412016f, -0.09261695f, 0.02059216f, -0.16432165f, -0.11405092f, 0.07079989f, 0.02961466f, 0.15614401f, 
    -0.04552013f, -0.36603469f, -0.02801756f, -0.18097053f, -0.05053252f, 0.02550553f, 0.12228167f, -0.07625683f, 
    -0.01190453f, 0.00627047f, 0.03552116f, -0.18908922f, -0.02341953f, -0.01677019f, 0.01825828f, 0.07908807f, 
    0.22030109f, 0.23596866f, 0.17369971f, -0.08910506f, -0.10270226f, -0.02481022f, -0.04911564f, 0.23064272f, 
    -0.06984837f, -0.14032403f, 0.06834953f, 0.02782158f, -0.03772539f, 0.06924433f, 0.11071242f, 0.08363152f, 
    -0.04677821f, 0.04444474f, -0.12606084f, -0.11236023f, -0.44708088f, -0.47486165f, -0.40081543f, -0.06858195f, 
    -0.09593824f, 0.07014912f, -0.01965426f, 0.08902369f, 0.11661141f, 0.08268648f, -0.01307593f, 0.24949232f, 
    0.11574280f, 0.04255093f, 0.02606019f, -0.04349129f, -0.03034785f, 0.02066727f, 0.03241493f, 0.10210745f, 
    -0.04350745f, 0.11657132f, 0.07897687f, 0.17468074f, -0.11619711f, -0.03191400f, 0.03392804f, 0.02749982f, 
    0.03446177f, -0.19297035f, -0.03343983f, -0.09845319f, 0.00215121f, 0.01607000f, 0.02631545f, -0.01542553f, 
    0.09090903f, 0.04670846f, -0.12580989f, -0.00703158f, -0.05703891f, 0.16321939f, 0.30351514f, 0.22723132f, 
    -0.17747238f, 0.08829454f, -0.00192201f, 0.09442637f, 0.12714127f, -0.08136510f, -0.05941697f, 0.07010917f, 
    -0.08972713f, 0.01374290f, 0.00733383f, 0.05084777f, -0.04737105f, 0.09558871f, -0.05257771f, -0.07389417f, 
    -0.18475974f, 0.23065372f, 0.08516961f, 0.11285976f, -0.15534732f, 0.00445590f, -0.08198113f, -0.06290916f, 
    -0.00342596f, -0.21815249f, -0.20761807f, -0.08752167f, -0.07929270f, -0.09250181f, -0.01166781f, 0.00213604f, 
    0.00667003f, 0.17551270f, -0.04361496f, -0.04450720f, 0.22044361f, 0.00416805f, 0.03307744f, -0.03289773f, 
    -0.30843592f, -0.14700912f, -0.19649184f, -0.09780420f, -0.03969437f, -0.01553744f, -0.07105766f, 0.12675127f, 
    0.08528282f, -0.11577880f, -0.07015282f, 0.05485115f, 0.23278521f, 0.16558819f, 0.03860403f, 0.27500474f, 
    0.43286231f, -0.19683009f, -0.10695974f, -0.07747374f, -0.04165122f, 0.15434034f, 0.07741467f, -0.01205838f, 
    0.05007815f, 0.06646077f, -0.10921817f, 0.05531638f, -0.09974591f, 0.06187712f, -0.05453569f, -0.04948471f, 
    0.03757739f, 0.05906736f, 0.07406879f, 0.14541091f, -0.11948583f, 0.17220573f, 0.02209067f, 0.00476905f, 
    -0.12906878f, -0.14941445f, -0.05651952f, 0.06640384f, 0.20480578f, 0.02068860f, 0.09596430f, -0.07725491f, 
    0.02764307f, 0.12948850f, 0.06258866f, 0.01717472f, -0.09948380f, 0.04094895f, 0.11286419f, 0.29737207f, 
    -0.12586983f, -0.15013486f, -0.56567174f, -0.27851647f, -0.20073594f, 0.05491207f, -0.04239025f, -0.06470507f, 
    0.04186639f, 0.03533981f, 0.03016374f, 0.10598219f, -0.14980836f, 0.06447947f, -0.08555946f, 0.02057920f, 
    0.01601531f, 0.00411626f, 0.03999593f, 0.06315295f, -0.20270036f, -0.04651313f, -0.40794361f, -0.09629367f, 
    -0.24268366f, -0.07678857f, -0.06437149f, -0.04928826f, 0.00556760f, 0.03859653f, 0.13127798f, 0.01477845f, 
    -0.12547995f, -0.00424649f, 0.00293866f, -0.08495234f, 0.03073571f, -0.03135953f, 0.09594061f, 0.10287437f, 
    0.08895640f, 0.03487823f, -0.00186977f, -0.38973856f, 0.03204738f, 0.24973336f, 0.07656605f, 0.02983113f, 
    -0.05351942f, -0.09931897f, 0.01541956f, 0.00997380f, -0.11503923f, 0.00837832f, 0.03017768f, -0.07940290f, 
    -0.05306308f, -0.00814681f, 0.18973576f, 0.06266067f, -0.04830784f, 0.09941527f, 0.31689179f, 0.15941930f, 
    -0.19244799f, 0.15815793f, -0.00522017f, -0.02512148f, 0.09779861f, 0.00773865f, -0.10280927f, -0.01037055f, 
    -0.05925530f, -0.06295015f, -0.00314347f, 0.01481925f, -0.11083555f, 0.03366444f, -0.03863962f, -0.00360455f, 
    0.04004332f, -0.03938168f, -0.02552613f, -0.01092702f, 0.02204906f, -0.02390573f, 0.01314197f, 0.00645104f, 
    -0.03585714f, 0.02112680f, -0.02125926f, 0.01110888f, -0.04164598f, -0.01687110f, -0.01853681f, -0.00302523f, 
    -0.02689619f, -0.00929099f, 0.00127674f, -0.02484434f, -0.00032172f, -0.02275165f, 0.01387117f, -0.02353523f, 
    -0.02399420f, -0.00489236f, -0.00543519f, -0.01043587f, 0.01408075f, 0.01422815f, -0.00183146f, -0.03724083f, 
    -0.01650014f, -0.00368941f, -0.03756532f, -0.02206905f, 0.02135209f, -0.02368168f, -0.02137146f, -0.03845095f, 
    -0.02567630f, 0.01205504f, 0.01272933f, -0.02062284f, 0.02693705f, 0.01012682f, 0.01476068f, -0.04333467f, 
    0.03609088f, 0.02105008f, -0.00713983f, 0.01276969f, -0.02009718f, 0.02731318f, -0.03887517f, 0.00061821f, 
    0.00445930f, -0.04264780f, 0.02738903f, -0.03521112f, -0.01243620f, -0.03416855f, 0.00358717f, 0.01667478f, 
    -0.02927597f, -0.03799300f, -0.02337806f, -0.04445944f, -0.04626099f, -0.01907994f, 0.01768417f, -0.04326006f, 
    0.02299251f, -0.03066598f, -0.03290707f, 0.00548670f, 0.00134495f, 0.02862680f, 0.01916897f, -0.03278698f, 
    0.00494076f, 0.02484860f, 0.02063484f, 0.02919302f, -0.03435453f, -0.00505925f, 0.01337596f, 0.03437573f, 
    0.02641373f, -0.00507558f, 0.00641379f, -0.03684498f, 0.00746715f, 0.00796969f, -0.00868429f, 0.03161717f, 
    -0.00148218f, 0.01921217f, -0.02888959f, 0.02445741f, -0.04037619f, -0.01490567f, -0.04102914f, -0.04371236f, 
    -0.03122498f, 0.01111938f, 0.00333330f, 0.01747998f, 0.00921902f, 0.02670093f, -0.03295584f, 0.01956117f, 
    -0.01217632f, 0.02929441f, -0.04131575f, -0.02490482f, -0.00153100f, -0.01860141f, 0.01541223f, -0.02696626f, 
    -0.02899135f, 0.01352581f, 0.01507940f, -0.02541780f, -0.02337654f, -0.02935539f, -0.00032287f, -0.03377036f, 
    -0.00136325f, 0.01703582f, -0.04191364f, -0.00047655f, 0.02810648f, 0.00561302f, 0.02180261f, 0.01052717f, 
    0.01129291f, 0.02439970f, 0.02831801f, -0.04089551f, 0.00383952f, 0.02885653f, -0.00847625f, 0.01833805f, 
    -0.00882444f, 0.01397629f, -0.01623559f, -0.02407329f, -0.02456842f, 0.01103817f, -0.01366854f, -0.04432245f, 
    0.00610722f, -0.04107722f, 0.03137814f, -0.00310272f, 0.01354275f, -0.02459572f, -0.04498396f, 0.01322392f, 
    -0.02512766f, 0.03142744f, 0.00655154f, -0.04347782f, -0.01676036f, -0.00240265f, -0.03219784f, -0.01788594f, 
    -0.02662784f, -0.01916224f, 0.01506483f, 0.00300997f, 0.04367200f, -0.00807221f, 0.01926851f, -0.02473461f, 
    0.01425498f, -0.04178155f, -0.03527523f, 0.02763755f, 0.01754799f, -0.03476834f, 0.02537537f, -0.00103631f, 
    -0.03729764f, -0.01135212f, -0.00181691f, 0.03954675f, 0.02692045f, -0.01105648f, 0.00806220f, -0.02670510f, 
    0.03520645f, -0.01108292f, -0.01971420f, 0.02186471f, -0.00369968f, 0.02323853f, -0.01833401f, -0.00834182f, 
    -0.03071179f, -0.03391119f, -0.00909061f, -0.03874219f, -0.03939527f, 0.02116322f, 0.02027238f, 0.03050952f, 
    -0.01898155f, 0.00952704f, -0.00884960f, 0.00098739f, 0.02707132f, -0.02249394f, 0.01743902f, 0.02074109f, 
    0.03296015f, -0.03753843f, -0.04269031f, -0.02733082f, 0.02914103f, -0.01867034f, 0.01633778f, -0.03267316f, 
    -0.03933695f, -0.04578777f, -0.04414177f, 0.00870900f, 0.00978629f, -0.02568362f, -0.02579719f, -0.01182689f, 
    -0.01226516f, -0.00403381f, -0.03388235f, -0.04572766f, -0.02540774f, 0.01660336f, 0.03949597f, -0.04350647f, 
    -0.02873707f, -0.03974624f, -0.00688085f, 0.01364844f, 0.01448670f, -0.02390792f, 0.00988417f, 0.04361325f, 
    -0.00136832f, 0.02940458f, 0.00735906f, -0.02594543f, 0.01112161f, -0.04304620f, 0.03563975f, -0.01323170f, 
    0.00522941f, -0.02834810f, 0.00065104f, -0.01491558f, -0.01721552f, 0.02793610f, 0.03255695f, -0.04503575f, 
    -0.02219334f, -0.04546596f, 0.00080757f, 0.01392452f, 0.00778701f, 0.02332028f, 0.00412141f, 0.02958901f, 
    0.01976350f, 0.03207444f, 0.01696408f, -0.04583246f, -0.01250708f, -0.03153841f, -0.02957692f, -0.02730800f, 
    -0.02129563f, -0.04512855f, -0.03528425f, -0.00529527f, -0.00359037f, 0.01451500f, -0.01913530f, -0.00122224f, 
    -0.01466228f, -0.00482865f, -0.03607110f, -0.00660754f, 0.00084981f, 0.00263709f, -0.03751940f, -0.04477050f, 
    -0.04333192f, 0.00655848f, -0.04158679f, 0.00120825f, -0.01688769f, -0.02628643f, 0.00538155f, -0.01406698f, 
    -0.03470535f, 0.02203223f, -0.01706236f, 0.02953264f, -0.03874765f, -0.01506302f, 0.00210167f, 0.01707014f, 
    -0.02325477f, -0.00306700f, 0.03116499f, -0.00305925f, -0.00947851f, 0.02078133f, -0.01020430f, -0.02790218f, 
    -0.02555014f, -0.03364469f, -0.03843207f, 0.00569008f, -0.01726220f, -0.02351606f, -0.01886105f, 0.03149477f, 
    0.01588586f, 0.02000259f, 0.01139868f, 0.00033135f, -0.04493769f, -0.02159611f, -0.04678852f, 0.00846951f, 
    0.03286426f, -0.00280654f, -0.01106969f, 0.02676540f, 0.00100183f, 0.01485601f, -0.02977447f, -0.03345082f, 
    0.03041258f, 0.00478794f, -0.00101423f, -0.02156840f, 0.00247302f, -0.02489203f, -0.01880190f, -0.03197597f, 
    0.02239851f, -0.04072265f, 0.02656724f, 0.00259002f, -0.02825719f, -0.00777196f, 0.01166900f, -0.01102732f, 
    0.02326581f, 0.00566811f, 0.03130095f, -0.03845896f, 0.03049700f, -0.04519445f, 0.03147486f, 0.01392330f, 
    -0.00488319f, -0.03280571f, -0.03198461f, -0.04285693f, -0.02617078f, -0.00528429f, 0.02996125f, 0.02947575f, 
    0.02801220f, 0.02020769f, -0.04192503f, 0.01251058f, 0.00375854f, 0.02459815f, -0.02664996f, -0.03651569f, 
    0.01740197f, 0.01139404f, 0.00955940f, 0.01508755f, -0.04206512f, -0.02481353f, 0.00244181f, -0.03941641f, 
    0.00161390f, -0.02347693f, -0.04442012f, -0.02821594f, -0.03325058f, 0.01729581f, 0.01207951f, 0.03322457f, 
    0.03327840f, -0.01259203f, 0.00173969f, -0.02364914f, -0.02939600f, 0.01960254f, -0.04399735f, -0.01520009f, 
    -0.04174788f, -0.03607943f, -0.00856641f, 0.00422228f, -0.00601330f, 0.02715932f, 0.02192454f, -0.03434128f, 
    -0.00387802f, -0.04494050f, 0.02075893f, -0.02629927f, 0.01724879f, 0.02267493f, -0.00452401f, -0.02847498f, 
    -0.03866753f, -0.04012366f, 0.01442162f, 0.01872150f, -0.04066967f, -0.01117649f, -0.04617742f, -0.04684726f, 
    -0.01933332f, 0.02643265f, 0.00099789f, 0.01378274f, -0.03643195f, 0.01655075f, 0.04672224f, -0.03299776f, 
    0.01250950f, -0.01926337f, 0.01839734f, -0.01473601f, -0.00704437f, 0.00407829f, -0.00066182f, 0.00331934f, 
    -0.00381949f, -0.02323427f, 0.00780968f, 0.01119061f, -0.03276597f, -0.00742144f, 0.02397170f, -0.01811269f, 
    0.01404270f, 0.02796075f, -0.01195784f, -0.01067899f, -0.00357379f, -0.01209499f, 0.02438952f, 0.01722924f, 
    -0.02051651f, 0.02242784f, -0.00405203f, -0.03898945f, 0.00269391f, -0.03174872f, -0.02634901f, 0.00540666f, 
    0.01947138f, -0.00314766f, 0.00762529f, 0.00462549f, 0.02059165f, -0.03744321f, -0.00519394f, -0.03060281f, 
    -0.00657228f, -0.01493001f, 0.03999195f, 0.03584936f, 0.01941439f, -0.00412865f, 0.00312992f, 0.01553033f, 
    -0.03490176f, -0.04237240f, -0.02033651f, 0.01865171f, -0.02409257f, -0.00394149f, 0.00580901f, -0.00127943f, 
    -0.01333512f, 0.00718378f, -0.01055528f, 0.00719209f, 0.00205933f, -0.01940757f, 0.02059964f, 0.03670557f, 
    -0.00153510f, 0.00535169f, -0.02846824f, -0.01065420f, 0.02447689f, -0.04290783f, -0.04299937f, 0.02196332f, 
    0.01533486f, -0.00999175f, -0.00213401f, 0.00875469f, 0.00655069f, -0.04620133f, 0.03162429f, -0.01451419f, 
    -0.00133713f, 0.03103467f, -0.02160700f, 0.00966657f, -0.04465291f, -0.04248044f, 0.02558458f, -0.03324169f, 
    -0.04522004f, 0.01480455f, -0.02233232f, 0.02918481f, -0.02032351f, 0.02929004f, -0.01720906f, -0.02204376f, 
    -0.03277680f, -0.02179218f, -0.00844371f, 0.02523114f, -0.03103143f, 0.03347425f, -0.01793748f, -0.01258691f, 
    -0.02219443f, -0.02445242f, -0.01304772f, -0.03417683f, -0.02696301f, -0.01550749f, 0.02318633f, -0.01229701f, 
    -0.01505896f, -0.04475147f, -0.02891902f, 0.02292367f, 0.02714234f, -0.02197560f, -0.00696605f, -0.02671551f, 
    -0.02832769f, 0.02671200f, -0.01521502f, -0.04187256f, -0.01931299f, 0.01793974f, -0.01816593f, -0.00039464f, 
    0.01275832f, -0.03817194f, 0.01499633f, -0.02271024f, -0.04069391f, 0.03431794f, -0.01225201f, -0.03311114f, 
    0.00007776f, -0.02806301f, -0.03533330f, -0.01942666f, 0.02369676f, 0.00522244f, 0.01868314f, -0.02322713f, 
    -0.01663951f, -0.02160351f, -0.00047300f, 0.00713185f, -0.04650022f, 0.00523417f, -0.03437380f, 0.02114329f, 
    0.01958295f, 0.02518231f, 0.03182982f, -0.03685304f, 0.02248785f, -0.04236966f, -0.04133637f, 0.03196385f, 
    0.02177353f, 0.02658071f, -0.04553504f, 0.01123535f, 0.02900259f, -0.01760349f, 0.01433322f, -0.00039614f, 
    -0.01940768f, -0.03310698f, -0.04007539f, -0.01732076f, -0.03667669f, 0.00210537f, 0.01801916f, -0.04431931f, 
    0.00356229f, 0.03359930f, 0.01555694f, -0.01020544f, -0.01748420f, -0.03107602f, -0.03370018f, 0.01745782f, 
    -0.01946220f, -0.03820790f, -0.04490656f, 0.02433359f, -0.04120478f, -0.02780757f, -0.00821123f, -0.02325154f, 
    -0.03023738f, 0.02305290f, -0.00654227f, 0.00607736f, 0.02396016f, -0.02771701f, -0.03344604f, -0.00236788f, 
    -0.02431521f, 0.01550448f, -0.03408469f, 0.02829950f, 0.00763610f, -0.04277735f, 0.01623816f, -0.01223394f, 
    -0.00442943f, -0.01199139f, 0.00168552f, -0.01146003f, -0.02990082f, -0.00328872f, -0.01293286f, 0.01024761f, 
    0.03173446f, -0.02751481f, 0.00452014f, -0.00146283f, -0.01812445f, 0.02502756f, -0.02376165f, -0.04255403f, 
    0.02119631f, 0.02269742f, -0.02390779f, 0.02527090f, 0.02964400f, 0.02111336f, 0.00978941f, 0.02590985f, 
    -0.00286884f, 0.02877736f, -0.03516950f, -0.02586070f, -0.04157464f, -0.03974236f, -0.03886218f, 0.01040989f, 
    0.00228019f, -0.00046943f, 0.01540101f, -0.03745935f, -0.02791242f, -0.03391011f, 0.02269600f, 0.00337030f, 
    0.02903163f, -0.02479916f, 0.03015585f, -0.02511413f, 0.03057360f, 0.01493811f, -0.03497714f, 0.01392175f, 
    -0.00074637f, -0.00665911f, 0.02069861f, 0.00670061f, -0.01118197f, 0.00645792f, -0.02963799f, 0.01218106f, 
    -0.02019427f, 0.00917989f, 0.01470991f, -0.01118513f, -0.02938375f, 0.02402130f, -0.02348627f, 0.00946676f, 
    -0.03649657f, -0.04124044f, -0.03375109f, -0.02196290f, -0.03239347f, 0.00212216f, -0.04359117f, -0.02873513f, 
    0.01473242f, -0.02128988f, -0.03315333f, -0.01679313f, -0.03050283f, -0.01694817f, -0.00125960f, -0.01324761f, 
    -0.00191285f, -0.01988535f, -0.02006881f, -0.02715152f, -0.00541720f, -0.01493113f, -0.03331561f, -0.02849956f, 
    0.01510096f, -0.01746942f, -0.01601330f, -0.04151460f, 0.02358931f, -0.03377254f, -0.03159120f, 0.01773861f, 
    0.01381634f, 0.01529239f, -0.03137416f, -0.03462036f, 0.01733115f, 0.01560771f, -0.01063003f, 0.01199254f, 
    -0.04235297f, -0.01589401f, 0.00640539f, -0.00433030f, -0.01611096f, -0.00210155f, -0.02579347f, -0.03766481f, 
    0.01839888f, -0.03274034f, -0.04251675f, 0.00810602f, -0.02159826f, -0.02041031f, -0.01653159f, -0.02757952f, 
    -0.04340277f, 0.00378577f, 0.03314717f, -0.04252710f, -0.00285312f, 0.01711142f, -0.04214913f, -0.04466484f, 
    -0.01998635f, -0.02661046f, 0.02474611f, 0.00507354f, -0.03054403f, -0.02881897f, -0.00515985f, -0.04124735f, 
    0.00063290f, 0.03091411f, -0.00678995f, -0.02491918f, 0.00565605f, -0.03017220f, -0.01736425f, 0.03035828f, 
    -0.01616506f, -0.00506106f, -0.02286583f, 0.02402387f, 0.01148503f, 0.03808004f, -0.02908913f, 0.02878219f, 
    0.01524189f, 0.02131965f, 0.03840103f, -0.03218394f, -0.03471017f, -0.03016401f, -0.02423262f, 0.01241656f, 
    0.01266434f, -0.01265840f, -0.01392824f, 0.02625466f, 0.02593078f, -0.00563089f, 0.01078350f, 0.00274955f, 
    0.01331460f, 0.00163772f, -0.03695286f, -0.00321202f, 0.00621203f, 0.00718432f, 0.01879988f, 0.03083364f, 
    -0.00030850f, 0.00248291f, -0.01670963f, -0.00664622f, -0.01815830f, -0.03220326f, -0.02764235f, -0.03669808f, 
    0.02447511f, -0.00186001f, -0.00721868f, -0.01365186f, 0.00929717f, -0.02906105f, -0.02060894f, -0.01108380f, 
    -0.02496503f, -0.02959063f, 0.02484921f, 0.02875005f, 0.02876599f, -0.00530777f, 0.03602028f, -0.01171517f, 
    0.03121867f, -0.01269665f, 0.01855399f, 0.00913655f, -0.01807649f, -0.02848590f, -0.01592970f, 0.02527329f, 
    0.02769849f, -0.03559818f, -0.03621211f, 0.02803276f, -0.01556481f, 0.01852467f, -0.03357471f, -0.03237873f, 
    -0.02451720f, -0.02127185f, 0.00715197f, -0.03671852f, 0.02660684f, 0.02389375f, -0.02531921f, 0.02031683f, 
    0.01043537f, -0.03871799f, -0.04410299f, -0.02121130f, 0.01719958f, -0.03850626f, -0.02366153f, -0.02981062f, 
    0.03312955f, -0.03097838f, -0.03689050f, 0.01292622f, -0.01219915f, 0.02180881f, -0.01931880f, -0.01690379f, 
    -0.01455835f, 0.03067247f, 0.00152156f, 0.00280676f, -0.01767906f, -0.02897031f, -0.00092702f, 0.02480948f, 
    0.02747160f, -0.01756805f, -0.02297821f, 0.02858609f, -0.00021640f, 0.00847600f, -0.02541976f, -0.00457077f, 
    -0.00376096f, -0.00082215f, -0.01744688f, -0.02561471f, 0.00749561f, 0.02398807f, 0.00876265f, -0.02663552f, 
    -0.00515650f, -0.02881932f, -0.03664946f, 0.01471465f, -0.04259393f, 0.01950535f, -0.02839443f, -0.03384564f, 
    -0.02853539f, 0.03599081f, 0.03791431f, -0.03769595f, 0.01940524f, 0.01256932f, 0.03021040f, -0.03382293f, 
    0.01962126f, 0.00246120f, 0.03295441f, 0.01431416f, 0.03198907f, 0.00558768f, -0.04092163f, 0.01262060f, 
    0.01632750f, 0.01039697f, -0.03106696f, 0.00545126f, -0.04138744f, -0.03074328f, -0.00858675f, -0.00073699f, 
    -0.01327352f, 0.02028138f, 0.01364820f, -0.01554268f, -0.03335851f, -0.01101148f, 0.02112214f, 0.00873862f, 
    0.00420131f, -0.03021646f, 0.02660220f, -0.03020273f, -0.01157607f, 0.00530053f, -0.03562162f, 0.03013888f, 
    -0.02089528f, 0.03540297f, 0.00262437f, 0.03577517f, -0.00581573f, 0.00213389f, -0.03246657f, 0.00830130f, 
    0.01485255f, 0.00236616f, 0.00272093f, 0.01862767f, -0.01777380f, -0.01988394f, -0.01891751f, -0.03724712f, 
    0.02220299f, 0.01110940f, -0.01580244f, -0.02781603f, -0.03414514f, 0.01643873f, 0.00791474f, 0.03142845f, 
    -0.02938105f, 0.03112458f, 0.03008604f, -0.02683439f, 0.01517840f, 0.03301113f, -0.04403418f, 0.00454478f, 
    -0.00891238f, 0.00810818f, -0.02492328f, 0.00455294f, -0.04111469f, 0.02730262f, -0.00402539f, -0.03158978f, 
    0.01422160f, -0.00714389f, 0.00749170f, 0.00942419f, 0.00311075f, 0.00439411f, -0.02963391f, -0.00648417f, 
    0.01116690f, 0.01002137f, 0.01785464f, -0.03210028f, -0.01707382f, 0.02070434f, -0.02010457f, -0.00017342f, 
    -0.02215449f, 0.02036113f, -0.01864320f, -0.00370380f, 0.00078456f, -0.00951514f, 0.01382462f, -0.03508309f, 
    -0.03350455f, -0.02306479f, 0.00569045f, -0.02118012f, -0.02966428f, -0.03463631f, 0.02149983f, -0.03644879f, 
    -0.00705987f, 0.02319023f, -0.02143662f, -0.02118947f, -0.03525099f, 0.00824283f, 0.00410232f, -0.00338115f, 
    -0.03618667f, -0.02759895f, 0.02639458f, 0.00092446f, -0.02997759f, -0.02423535f, 0.00884523f, 0.00276923f, 
    0.03561888f, 0.03443172f, -0.03625716f, -0.03299314f, -0.00805117f, 0.00230728f, 0.01751098f, -0.03599435f, 
    0.01947291f, -0.03459091f, -0.02231313f, 0.03566910f, -0.00218914f, -0.04337162f, -0.04345519f, 0.02393249f, 
    0.01929886f, -0.04328236f, -0.02749554f, -0.00076567f, -0.00163902f, -0.01968663f, -0.02958043f, -0.01466180f, 
    0.02301999f, -0.01090032f, 0.03661927f, 0.02564111f, 0.02332949f, -0.02215748f, -0.02915647f, -0.02591407f, 
    -0.00106296f, -0.02251877f, 0.01885349f, 0.03269780f, -0.02120751f, 0.02593137f, 0.02224079f, -0.04343751f, 
    0.00127339f, -0.02291010f, -0.02180461f, -0.01598849f, 0.02317425f, 0.00460368f, 0.02900358f, 0.02071777f, 
    0.02831379f, 0.02848805f, 0.00190309f, -0.00155805f, 0.00742003f, 0.02356515f, -0.03635372f, -0.02804701f, 
    -0.01359251f, -0.02758988f, 0.01978257f, -0.00258156f, 0.02242504f, -0.04140139f, 0.02914587f, -0.03347552f, 
    -0.00535794f, -0.02104938f, -0.03432063f, 0.01913160f, -0.00491983f, -0.00522606f, 0.01202764f, -0.02424617f, 
    -0.02354231f, -0.00701676f, 0.02565345f, -0.01288442f, -0.04355992f, -0.04473372f, 0.02171550f, 0.00875781f, 
    0.01156773f, -0.00964407f, -0.03011292f, -0.03410827f, -0.00004064f, -0.02626043f, 0.00675835f, 0.02002006f, 
    -0.01421586f, -0.03155088f, -0.02110133f, -0.03225968f, -0.01653226f, -0.02429928f, 0.01000416f, 0.00202883f, 
    -0.04080787f, 0.00647999f, -0.03624593f, 0.03294238f, 0.01979120f, 0.03336115f, 0.02361516f, -0.02701226f, 
    0.00643726f, -0.00643010f, 0.01366113f, 0.01572490f, -0.01372576f, 0.00765924f, 0.01572278f, -0.01567141f, 
    0.01701568f, 0.03468987f, -0.03552954f, -0.02167198f, 0.01396511f, -0.00152518f, -0.03542597f, -0.01498101f, 
    0.01203001f, 0.00850004f, -0.03882095f, -0.00868293f, -0.04499764f, 0.02633595f, 0.01033830f, 0.00881045f, 
    0.01148092f, -0.01838350f, -0.00964351f, -0.02602495f, 0.01336374f, 0.02193957f, -0.00045690f, 0.01748301f, 
    -0.04058458f, -0.02318829f, -0.04113578f, -0.04229100f, 0.03315204f, -0.00400169f, 0.03225112f, -0.02238473f, 
    0.02336240f, 0.00568729f, -0.03759158f, 0.00492648f, -0.02175788f, -0.01831719f, 0.01873105f, -0.00400275f, 
    0.03136494f, -0.01482891f, -0.02172566f, -0.03319772f, -0.00545684f, 0.01093997f, 0.02584167f, 0.00482546f, 
    0.00949770f, -0.02648199f, 0.00987338f, -0.00000259f, 0.01121913f, 0.00639969f, 0.01347430f, -0.00192271f, 
    -0.03211193f, -0.03339759f, 0.01193722f, -0.00782729f, -0.00700868f, 0.00913635f, 0.02688377f, 0.01317713f, 
    -0.01902695f, -0.02198220f, 0.02176493f, -0.03816251f, -0.03768841f, -0.03431294f, -0.02986741f, 0.00415754f, 
    -0.00863753f, 0.01866668f, 0.00165452f, -0.02329965f, -0.00286254f, -0.03778003f, -0.02912883f, -0.02790938f, 
    0.01225228f, 0.01866614f, -0.02258711f, 0.00731466f, 0.01006905f, -0.00717443f, 0.03922223f, 0.00719803f, 
    -0.01941222f, -0.00736638f, -0.00061701f, 0.02426932f, 0.00925488f, -0.01944620f, -0.02274909f, -0.03727123f, 
    -0.02773679f, -0.04105214f, -0.03121559f, -0.01649757f, -0.02242030f, -0.04546190f, 0.03068592f, -0.01988364f, 
    0.02911508f, 0.01788406f, 0.00665851f, -0.02485806f, -0.04044951f, -0.02295758f, 0.02366658f, -0.00204163f, 
    0.03341370f, 0.02518340f, -0.01357946f, -0.02916896f, -0.03941660f, -0.00260958f, 0.02202625f, 0.00029230f, 
    0.30975050f, -0.16508307f, 0.00909472f, -0.03987175f, -0.02495919f, -0.00779153f, -0.13397124f, 0.08388779f, 
    -0.07470048f, -0.09707417f, 0.09174348f, 0.12411414f, 0.01901208f, -0.11927877f, 0.03525992f, 0.02092754f, 
    0.11693381f, -0.17343660f, -0.05430056f, -0.03022071f, -0.34166172f, 0.19282080f, -0.15180935f, -0.05039261f, 
    0.21319747f, 0.07861133f, 0.06071784f, 0.15774336f, 0.16666798f, 0.07202422f, 0.05633182f, 0.13243146f, 
    -0.08810200f, -0.09156053f, 0.08129131f, -0.02283610f, 0.02847462f, -0.13623321f, 0.01909536f, 0.08806998f, 
    0.34631091f, 0.08905482f, 0.21119107f, -0.01811944f, 0.20189933f, 0.13408279f, -0.02007517f, 0.05403250f, 
    0.08822075f, -0.04198347f, 0.09743156f, 0.15500300f, 0.01238516f, -0.14896356f, -0.02515292f, 0.13254054f, 
    0.00604557f, -0.01474821f, 0.02353576f, 0.03762897f, 0.19073868f, -0.31685379f, 0.09614690f, -0.11694714f, 
    -0.21453550f, 0.02161137f, -0.13292195f, 0.05289055f, -0.01049888f, 0.05553906f, -0.10589050f, 0.00951326f, 
    0.13612531f, -0.01460150f, 0.03304430f, -0.01436572f, -0.07084032f, -0.10162669f, -0.04406307f, -0.04114649f, 
    0.19427262f, 0.41234216f, -0.13584910f, 0.15512314f, 0.07157669f, -0.00011442f, 0.08705807f, 0.09136481f, 
    -0.10989393f, 0.07814534f, 0.03404700f, 0.04010498f, -0.09476060f, -0.01698704f, 0.07000670f, -0.00159274f, 
    0.02703397f, -0.04629751f, -0.05822716f, 0.05441440f, 0.21999097f, -0.00380708f, 0.04953335f, -0.12602855f, 
    0.10387691f, 0.00909881f, -0.10399560f, 0.05124146f, 0.04246072f, 0.13968429f, -0.04333305f, 0.05158986f, 
    0.03968605f, -0.09020873f, -0.09721273f, 0.03464719f, -0.09182577f, -0.05869435f, -0.00743178f, -0.02932249f, 
    -0.24898627f, -0.26722249f, 0.26872486f, -0.10134692f, 0.18686940f, -0.01289937f, -0.08777814f, 0.17648076f, 
    0.00772761f, -0.07918220f, 0.01584731f, 0.06188362f, -0.09477343f, -0.03751609f, 0.20321205f, 0.22488634f, 
    -0.03536419f, -0.00945275f, 0.09076490f, -0.00255005f, -0.32685721f, -0.00948879f, 0.37845573f, -0.00128597f, 
    -0.08439491f, 0.03991669f, 0.08141048f, 0.14144182f, 0.01045713f, -0.01872461f, 0.06702109f, 0.06727141f, 
    0.02591745f, 0.23664421f, -0.02288248f, 0.20505832f, -0.06290357f, 0.06787763f, -0.02326680f, 0.14604166f, 
    -0.12857960f, 0.29702961f, -0.01636327f, 0.10888183f, -0.09293399f, 0.00531211f, -0.09587732f, 0.01927890f, 
    0.04805169f, -0.09010853f, 0.00994364f, -0.02743799f, 0.00305330f, 0.14063893f, 0.06890256f, 0.00942537f, 
    -0.03337716f, -0.02399535f, 0.04399262f, 0.00881305f, -0.30855095f, 0.11953682f, -0.05976783f, 0.07706361f, 
    -0.02205575f, -0.04857739f, 0.13393433f, -0.05574569f, -0.00133829f, 0.07725746f, -0.05372340f, 0.03465086f, 
    -0.04763859f, 0.09101554f, 0.09069042f, -0.04946416f, -0.01882801f, 0.08006582f, -0.16706936f, -0.14017041f, 
    -0.34790751f, 0.31699273f, -0.09196816f, 0.10850715f, 0.17015457f, 0.07972071f, 0.08828277f, -0.03649491f, 
    0.06254180f, -0.16369313f, -0.03415066f, -0.15018226f, -0.02840792f, 0.08131962f, -0.04500182f, -0.07260429f, 
    -0.03844844f, -0.03744966f, 0.05160668f, 0.14970148f, 0.19030850f, -0.05975884f, 0.19046865f, 0.16790873f, 
    -0.30954993f, -0.32645476f, 0.04337503f, 0.13631213f, 0.03046332f, -0.06139097f, -0.00854820f, -0.01581047f, 
    0.13758916f, -0.01783970f, 0.03994273f, -0.04311620f, -0.01045982f, -0.05474647f, -0.07769287f, 0.05531868f, 
    -0.00864523f, 0.12259081f, -0.07932993f, -0.03978211f, 0.02117025f, 0.02153309f, 0.09505636f, -0.08769931f, 
    -0.15131782f, 0.06826042f, -0.06230387f, 0.02226365f, -0.01174224f, 0.04724209f, 0.12614234f, -0.09216392f, 
    -0.05348266f, 0.10423701f, -0.00442000f, -0.00092140f, 0.08605659f, -0.04758165f, 0.15522246f, 0.24027926f, 
    -0.07898696f, 0.07865939f, -0.04292529f, -0.07460162f, 0.13634990f, 0.01317111f, 0.02717655f, 0.09676210f, 
    -0.04676303f, -0.06756735f, 0.07218233f, -0.07024622f, 0.05558378f, -0.10343571f, -0.01254627f, -0.05153709f, 
    0.14885998f, 0.16236424f, 0.01163185f, 0.08034417f, 0.19198136f, 0.15275609f, -0.02561974f, -0.04314008f, 
    0.09587772f, 0.01177708f, 0.04963757f, 0.01714437f, 0.06524853f, -0.02402177f, 0.05809288f, -0.01358950f, 
    0.02241346f, -0.09795447f, 0.06320725f, 0.03997581f, 0.32039937f, -0.15417030f, 0.28666720f, -0.05969554f, 
    -0.02663434f, -0.15771744f, -0.00716925f, 0.09743530f, -0.14395173f, -0.04003533f, 0.08619220f, 0.09762172f, 
    0.07647550f, -0.04740654f, -0.12298694f, -0.00782439f, 0.07913945f, 0.01888134f, -0.22878802f, -0.10767707f, 
    -0.05159218f, 0.19292657f, -0.17473391f, -0.15945390f, 0.04322928f, -0.00377294f, 0.03332404f, 0.08786400f, 
    -0.01748751f, 0.00989825f, -0.08294706f, 0.09743341f, 0.07327674f, 0.02713960f, 0.00554137f, 0.03336953f, 
    -0.02098435f, 0.06808703f, 0.00190652f, 0.03714477f, 0.05137049f, -0.09731945f, 0.00803384f, 0.05387192f, 
    -0.00702558f, -0.18695739f, 0.06348491f, 0.01037843f, -0.09575138f, -0.06021141f, -0.08979031f, 0.05589249f, 
    0.01686684f, -0.01553039f, 0.08709665f, -0.22133255f, -0.03641977f, 0.00599973f, 0.10386913f, -0.00863499f, 
    0.69465774f, 0.45670187f, 0.04242619f, 0.40525070f, -0.15489526f, -0.00269450f, 0.02539595f, 0.03717206f, 
    -0.05145376f, 0.00551410f, 0.07059105f, -0.04128183f, -0.01253879f, 0.06433633f, 0.01099186f, 0.11263853f, 
    -0.03111522f, 0.04728040f, -0.05484435f, -0.08144117f, 0.16113040f, 0.02064375f, -0.10604157f, -0.01844447f, 
    -0.10220513f, 0.07796892f, -0.20812549f, 0.10415375f, 0.04128321f, -0.07604225f, -0.10045444f, 0.13939904f, 
    0.05118849f, 0.01048014f, 0.03861956f, -0.01304674f, 0.04680310f, -0.03709223f, 0.01538051f, -0.04731802f, 
    -0.03713849f, 0.09799405f, -0.05299764f, 0.16327044f, -0.05783261f, 0.01303052f, 0.04202139f, -0.16025364f, 
    0.12878503f, -0.02803324f, -0.02621461f, -0.08024770f, 0.04430121f, 0.10061350f, 0.11769643f, -0.03920505f, 
    -0.09606384f, 0.04505327f, -0.08256806f, 0.06246157f, 0.46839371f, 0.30668533f, -0.54482687f, -0.00875965f, 
    -0.21565485f, -0.15389670f, 0.01181848f, -0.14403397f, -0.01576420f, -0.01726723f, 0.09748793f, -0.12903894f, 
    -0.09747934f, 0.01326284f, -0.16294800f, -0.00197819f, 0.09741413f, -0.04095708f, 0.02879772f, -0.05133444f, 
    0.02095907f, -0.01545111f, 0.07198964f, 0.03351647f, 0.10848639f, -0.04244770f, -0.06125588f, -0.12713127f, 
    -0.01407232f, 0.01197939f, -0.03736550f, 0.06444818f, 0.08728261f, -0.02987663f, 0.07281524f, 0.07984345f, 
    -0.10912602f, 0.03111451f, 0.08031175f, -0.00239798f, 0.14318915f, -0.44012183f, 0.18025167f, -0.21033119f, 
    0.01257751f, -0.14310151f, -0.02321053f, -0.11307950f, -0.08020790f, -0.15365969f, 0.00176126f, 0.06451325f, 
    -0.00466045f, 0.03682185f, -0.00506889f, -0.01268312f, 0.12268188f, -0.15626824f, 0.07333694f, -0.03443344f, 
    0.37998012f, -0.26265219f, 0.06429880f, 0.14444150f, 0.05634042f, -0.10600904f, -0.06434020f, -0.23650849f, 
    -0.12952217f, -0.10376760f, -0.05501674f, 0.02993838f, -0.00864290f, 0.02840249f, -0.01238344f, 0.02947525f, 
    0.09838790f, -0.10017073f, -0.06659215f, -0.04143938f, -0.23755717f, -0.24471663f, 0.16385293f, -0.13181345f, 
    -0.04179550f, 0.05392696f, 0.14672598f, -0.04010607f, 0.08406959f, 0.07764598f, 0.05053056f, 0.10893151f, 
    -0.05041599f, 0.17192939f, 0.03171003f, -0.09773690f, -0.03158677f, -0.05108376f, 0.18603167f, 0.19977149f, 
    -0.39734966f, 0.37235650f, -0.17492463f, 0.19403972f, 0.22713901f, -0.10286139f, 0.21839757f, 0.05203391f, 
    -0.05158845f, -0.08598405f, 0.13124065f, 0.03690543f, 0.05592180f, 0.07365869f, 0.05334434f, 0.05965579f, 
    -0.05483996f, -0.08510759f, -0.04520753f, 0.06225179f, -0.00082293f, 0.00276617f, 0.08100605f, 0.12686843f, 
    0.08993813f, 0.11530590f, 0.01371995f, 0.09940635f, -0.00458910f, -0.13306981f, 0.04686932f, -0.00232246f, 
    0.04474158f, 0.16084042f, -0.04013636f, -0.04939783f, 0.24050316f, 0.19872832f, -0.12259547f, -0.12162489f, 
    0.03232068f, -0.04944533f, 0.19833371f, -0.27949193f, -0.07389184f, -0.02112644f, -0.07425427f, 0.10163983f, 
    -0.09346233f, 0.07445250f, -0.03538259f, 0.05236023f, 0.04267887f, -0.03728011f, -0.00727889f, -0.03072592f, 
    0.00090954f, -0.06845050f, 0.02041545f, -0.10212237f, 0.04704266f, -0.00212509f, 0.09569220f, -0.21499033f, 
    -0.09772149f, -0.01907149f, -0.04872279f, 0.13888176f, 0.01177851f, -0.07321507f, -0.07386474f, 0.03369238f, 
    0.05566178f, 0.02120576f, -0.07806373f, -0.00526870f, 0.03674103f, -0.08654442f, -0.05052183f, -0.07803850f, 
    0.18008718f, 0.39237696f, -0.12934110f, 0.16270760f, 0.25377640f, -0.06907807f, 0.05656652f, 0.01147935f, 
    -0.04761213f, -0.09469021f, -0.04722823f, 0.03657593f, 0.08284134f, -0.04542815f, 0.09195729f, -0.01267239f, 
    0.04821081f, -0.01055136f, 0.00411988f, 0.04949087f, 0.18868542f, -0.21030851f, 0.00337226f, -0.05653945f, 
    0.11356588f, -0.27262875f, -0.12405995f, -0.09946364f, -0.13380170f, -0.09025394f, -0.04176461f, 0.06664004f, 
    -0.01350885f, 0.05503642f, -0.00128665f, 0.06525303f, -0.00397686f, -0.12238596f, 0.04609768f, -0.05323506f, 
    0.00750027f, -0.03469870f, 0.02026274f, 0.02772712f, -0.01205091f, 0.02541461f, -0.04446468f, -0.02367717f, 
    0.00048424f, -0.04475214f, 0.04051609f, -0.01654535f, -0.02573260f, -0.01585338f, -0.00768405f, 0.00814924f, 
    0.02215723f, 0.00241269f, 0.01671346f, 0.00289330f, 0.00075773f, -0.00100154f, -0.01644497f, -0.01615511f, 
    -0.02372930f, -0.01161202f, -0.02920525f, -0.03675055f, -0.03936324f, 0.02043580f, -0.00626106f, -0.02869598f, 
    0.00951493f, 0.03120560f, 0.00282769f, 0.02002353f, 0.02691275f, -0.01238735f, 0.00999484f, -0.02008070f, 
    0.01081770f, 0.01941521f, -0.04210761f, 0.00740075f, 0.03165765f, -0.00402608f, 0.01273253f, -0.04139431f, 
    0.00059081f, -0.03013358f, -0.03241296f, -0.01055138f, -0.02465096f, -0.03689559f, -0.03549188f, -0.00611924f, 
    -0.01617490f, 0.02255773f, 0.01507298f, -0.02466757f, 0.00077998f, -0.04553536f, -0.01110043f, -0.00467639f, 
    0.00589840f, 0.00235020f, 0.02724651f, -0.02620952f, 0.02935370f, 0.00887132f, 0.00721408f, -0.02825760f, 
    -0.01561784f, -0.01721387f, 0.00969675f, 0.02060492f, 0.02572271f, -0.02222000f, -0.02785672f, -0.03558582f, 
    -0.04546396f, -0.04680314f, 0.00457098f, 0.00003131f, -0.01536570f, -0.02347134f, 0.00707463f, -0.03158733f, 
    0.01507617f, -0.03577957f, 0.02723646f, 0.01802291f, -0.01664197f, -0.02400984f, -0.01763196f, -0.01907966f, 
    0.00820507f, 0.02697828f, 0.00411104f, 0.01070428f, 0.01269656f, -0.01116543f, 0.01595308f, -0.00059934f, 
    -0.03528915f, -0.03918608f, -0.03801329f, -0.00416877f, 0.01649028f, -0.04413422f, 0.01257557f, 0.02271268f, 
    -0.01375326f, 0.00340655f, -0.04027044f, -0.00498169f, -0.02374747f, -0.03543037f, 0.02222866f, -0.00311359f, 
    -0.02746738f, -0.02160406f, -0.04055635f, 0.00748644f, -0.02953202f, -0.02967740f, 0.01592962f, 0.01769514f, 
    0.01004817f, -0.04396565f, 0.00440570f, -0.02243646f, -0.03209171f, -0.04639055f, 0.02137491f, 0.00311299f, 
    0.01793402f, -0.02230758f, -0.03251601f, 0.01508949f, -0.02375754f, 0.02853705f, -0.01599506f, 0.02714520f, 
    0.02422863f, 0.01999396f, 0.02564612f, -0.04629050f, 0.03165725f, -0.03680750f, -0.00752499f, -0.02481182f, 
    0.02891802f, 0.01788081f, -0.03880368f, -0.01271368f, -0.03815416f, 0.02169960f, 0.00181958f, -0.00333374f, 
    0.00332247f, 0.01267796f, 0.02857714f, -0.04322752f, -0.02377023f, -0.04201281f, -0.04136035f, -0.00623050f, 
    0.02042407f, -0.02134950f, 0.01170705f, 0.00470337f, -0.00004544f, -0.03932482f, -0.00394010f, -0.03157668f, 
    -0.02731146f, -0.02920377f, 0.01233039f, 0.01985095f, 0.01504962f, -0.00096811f, -0.00522933f, -0.01732447f, 
    -0.04295561f, 0.02082546f, -0.00921250f, 0.02740028f, 0.01633035f, -0.01153042f, -0.01209837f, -0.02505921f, 
    0.01459645f, 0.02240442f, 0.01551696f, -0.01983176f, -0.04029251f, 0.02008078f, -0.04125966f, -0.01795718f, 
    -0.02000618f, 0.02469802f, 0.02352247f, -0.04103829f, -0.00092535f, 0.02504242f, 0.00848673f, -0.00996836f, 
    -0.00813911f, 0.02367556f, 0.01760955f, -0.00118255f, -0.00902339f, -0.03771308f, 0.02323653f, 0.00383712f, 
    -0.03019534f, 0.03055575f, -0.01950056f, 0.02110853f, -0.00332882f, -0.01517117f, -0.03559407f, -0.02564268f, 
    0.00391987f, 0.01008974f, 0.00987335f, 0.02064091f, -0.03299881f, 0.00129754f, -0.01322333f, -0.03064029f, 
    -0.04173870f, 0.00625416f, -0.03496569f, -0.02561461f, 0.01550747f, -0.00461852f, 0.01899715f, 0.01193532f, 
    0.02809967f, -0.03849918f, 0.02235533f, 0.02069244f, -0.02762310f, 0.00726034f, -0.01702383f, 0.01058222f, 
    0.00252490f, -0.00552072f, -0.01847146f, 0.02833444f, -0.01669137f, -0.00539338f, 0.01603873f, 0.00465843f, 
    -0.04032506f, 0.01873920f, -0.03392281f, -0.00055421f, 0.00477657f, -0.00391312f, -0.04089369f, -0.03294545f, 
    -0.04458820f, -0.02468484f, -0.02816393f, -0.03433759f, -0.00108450f, -0.04004044f, 0.03130603f, -0.03106741f, 
    0.00876161f, -0.01915318f, 0.02834521f, 0.00750220f, -0.03221595f, -0.04170413f, -0.03538592f, -0.04743991f, 
    -0.03816380f, -0.00814110f, -0.04099422f, 0.00234654f, -0.03750594f, 0.02147830f, 0.01817359f, -0.04167860f, 
    -0.00716371f, -0.03378551f, 0.02123192f, -0.02111996f, 0.02916810f, 0.02797349f, -0.00042327f, -0.00026044f, 
    0.00072296f, -0.00642484f, 0.01079740f, 0.01353957f, -0.01584429f, 0.02607314f, -0.01283013f, 0.00701472f, 
    0.00869920f, -0.01774387f, 0.00322033f, -0.02696521f, -0.00108282f, 0.02757523f, -0.02448877f, -0.00086114f, 
    -0.03359516f, -0.04197266f, -0.03672750f, 0.00735138f, 0.02303068f, -0.00843362f, -0.02726108f, -0.01971133f, 
    -0.03207994f, -0.03530153f, 0.01085458f, -0.04566293f, 0.01743414f, 0.00751389f, -0.00486588f, 0.02689911f, 
    -0.02149094f, -0.03182650f, 0.02711183f, 0.03105551f, -0.03568324f, -0.03608488f, -0.01574925f, 0.02514866f, 
    -0.03801422f, -0.03431614f, 0.00495424f, -0.00592979f, -0.02281228f, -0.01986135f, -0.01529241f, -0.02337402f, 
    -0.03686302f, -0.02081456f, 0.00367562f, 0.00163256f, 0.00408159f, -0.00262499f, 0.01812228f, -0.04147470f, 
    0.01538541f, 0.00224321f, -0.01621912f, 0.02981842f, -0.01672583f, -0.01958326f, -0.01820860f, 0.00738895f, 
    0.00380423f, 0.02082651f, -0.03643769f, 0.01353450f, 0.01418013f, -0.04552498f, 0.00455225f, 0.01282331f, 
    -0.03915035f, -0.03215091f, 0.01282621f, -0.02154334f, 0.02949725f, -0.04145495f, -0.04565657f, 0.01573757f, 
    0.02834262f, 0.00004352f, -0.01444804f, 0.00822119f, -0.04355555f, 0.01144839f, -0.00255798f, 0.00601077f, 
    0.01483811f, -0.04441773f, -0.01010984f, -0.00481653f, -0.04402028f, 0.00498219f, -0.03191824f, -0.01974960f, 
    -0.04220577f, 0.02223824f, -0.03461161f, 0.02448472f, -0.00602868f, 0.00975097f, 0.01427871f, 0.02269352f, 
    -0.03312488f, 0.00340413f, 0.01396609f, -0.00351073f, -0.00081819f, 0.01397151f, -0.00091293f, 0.02067398f, 
    -0.02625311f, -0.04176439f, -0.00990392f, 0.01592209f, -0.04428422f, -0.02942787f, -0.03063104f, 0.01992654f, 
    -0.01552299f, -0.00781767f, 0.00667381f, 0.02515237f, -0.04121121f, -0.01289662f, 0.01424219f, 0.01197389f, 
    0.02353842f, 0.01333346f, -0.02316290f, -0.02966237f, 0.00045304f, -0.00195092f, -0.01568879f, -0.04291628f, 
    -0.02114294f, 0.02871575f, -0.00736424f, -0.01174164f, 0.02735167f, -0.00992573f, 0.02593244f, -0.00226227f, 
    -0.02792599f, -0.01215600f, -0.03522886f, -0.01360181f, 0.02521756f, -0.03768250f, 0.03043756f, -0.00248084f, 
    -0.03359229f, 0.00897704f, 0.02198200f, -0.01279117f, -0.03316320f, 0.02884261f, 0.02716986f, -0.03830620f, 
    -0.02816503f, 0.03100486f, -0.04542959f, -0.03414867f, 0.02317545f, -0.03798205f, -0.02366865f, 0.02647414f, 
    -0.02510716f, -0.01156986f, -0.04565460f, 0.02416604f, -0.01284687f, -0.03914481f, 0.01144475f, 0.01768864f, 
    -0.02248904f, -0.02871082f, 0.01014150f, 0.00642585f, -0.00723547f, -0.00629371f, -0.03703392f, 0.00974062f, 
    -0.00669640f, 0.02216009f, -0.00542038f, 0.01237166f, 0.00890956f, -0.03359590f, -0.01978740f, -0.00636890f, 
    -0.01008082f, 0.02336082f, -0.01360575f, 0.00029298f, -0.01851546f, 0.02744570f, -0.04636602f, 0.02686767f, 
    0.00805452f, -0.03538927f, -0.02960261f, -0.02079302f, 0.02069628f, -0.02118520f, -0.00275266f, 0.00505922f, 
    -0.02948590f, -0.02643754f, -0.01117822f, -0.03526957f, 0.02912172f, -0.02550891f, -0.03069017f, -0.02726058f, 
    0.01884306f, -0.01530567f, -0.04349961f, -0.02464260f, -0.03802435f, 0.00309759f, -0.02282793f, 0.03096764f, 
    0.02050089f, -0.02334464f, -0.03149500f, -0.01762274f, 0.01164583f, -0.02156543f, -0.01523926f, -0.00051746f, 
    0.03055624f, 0.00214066f, -0.00062542f, 0.00450137f, -0.04370480f, -0.01533159f, -0.02492074f, -0.04251333f, 
    -0.04417529f, -0.01146549f, -0.02526719f, 0.01112752f, 0.03086989f, -0.01866413f, -0.01867534f, -0.02959025f, 
    -0.02540127f, 0.01678512f, 0.01296232f, -0.01631446f, 0.01952093f, -0.00867384f, -0.04019017f, -0.02822499f, 
    -0.02704879f, -0.00777708f, -0.03377362f, -0.02209317f, 0.02548872f, -0.01331686f, -0.04667513f, 0.00397577f, 
    0.03036360f, -0.02137253f, 0.00170585f, -0.02608876f, 0.03000701f, 0.02976057f, 0.02063899f, 0.02729880f, 
    -0.00129001f, 0.00731591f, -0.04039541f, -0.03437967f, -0.00202040f, 0.02062328f, -0.03281852f, -0.02583067f, 
    0.00952880f, -0.02471037f, -0.03291255f, 0.01259450f, 0.00866643f, 0.01631249f, -0.00612085f, -0.01085559f, 
    0.02096506f, -0.02487401f, -0.03931025f, -0.03529141f, -0.02083488f, -0.03472698f, 0.02303296f, 0.01605590f, 
    -0.01720686f, 0.00298664f, -0.01565312f, 0.01511384f, 0.02694881f, 0.01750688f, -0.04766955f, -0.02848705f, 
    0.00212627f, 0.01971820f, 0.00927015f, -0.00676313f, -0.02759339f, 0.00655631f, -0.01025962f, 0.02971738f, 
    -0.00585579f, -0.03900353f, 0.01525654f, -0.04626576f, 0.01767104f, -0.02634867f, 0.03125823f, 0.02760121f, 
    -0.01196491f, -0.02942855f, -0.02654809f, -0.02815275f, -0.00840042f, -0.02046792f, 0.02541517f, 0.02461664f, 
    0.00245911f, 0.01719562f, -0.03291076f, 0.01679360f, 0.00055647f, -0.04514523f, -0.02806424f, 0.01611970f, 
    -0.01976945f, -0.03685398f, 0.02346527f, 0.02626562f, 0.02857036f, 0.01735650f, -0.00665528f, 0.02041758f, 
    -0.33304274f, -0.03254300f, -0.26505744f, -0.03893752f, -0.11373065f, 0.16461121f, -0.09515948f, -0.02679473f, 
    -0.11490037f, 0.06127332f, 0.00625714f, -0.05777032f, 0.00641989f, 0.03681527f, -0.03413469f, 0.04543201f, 
    -0.19688326f, 0.16143468f, -0.09545588f, -0.06317818f, 0.20007661f, -0.21179929f, 0.45437399f, -0.03372901f, 
    -0.08052301f, -0.04097531f, 0.19122219f, -0.08546052f, -0.02710949f, 0.00439252f, -0.05983762f, -0.04224558f, 
    0.03256033f, -0.00565743f, -0.02080575f, 0.01587176f, -0.03521235f, 0.05654373f, -0.03362677f, 0.21442229f, 
    -0.33036596f, -0.18581177f, -0.25298637f, -0.16592559f, -0.00887063f, -0.10475113f, 0.03791001f, -0.11946221f, 
    0.02471080f, 0.26945093f, -0.13594998f, -0.02826922f, -0.01930755f, 0.15799133f, 0.01762983f, -0.14747484f, 
    -0.00989424f, 0.11685681f, 0.05789495f, -0.02059587f, -0.08743261f, 0.08359346f, 0.20483245f, -0.05723414f, 
    0.04369392f, 0.07881825f, -0.14523113f, -0.02680198f, -0.06026319f, 0.00486158f, 0.12172045f, -0.06533051f, 
    0.11138601f, -0.05913992f, -0.02463878f, -0.05867236f, 0.01183584f, 0.01545837f, -0.10862606f, 0.02985336f, 
    -0.36269870f, -0.25837293f, 0.03881725f, 0.02330250f, 0.14701740f, 0.08674503f, 0.14914216f, -0.00774383f, 
    0.13369954f, -0.07852977f, -0.08525643f, 0.02960023f, 0.14409181f, 0.00632423f, 0.03127262f, 0.00640126f, 
    -0.00411751f, 0.06681673f, 0.19746886f, 0.05031123f, -0.17477553f, 0.05271605f, 0.00708647f, 0.02161316f, 
    0.13031642f, 0.03680778f, 0.08998843f, -0.03454683f, 0.01525277f, 0.02769404f, -0.12007593f, 0.03206974f, 
    0.01684335f, -0.01114625f, 0.05250127f, -0.18369085f, 0.05069283f, 0.08485828f, 0.08637221f, 0.11464987f, 
    0.24184901f, 0.31999826f, 0.03711120f, 0.24575430f, -0.33082619f, -0.13526988f, -0.00379720f, -0.01098281f, 
    -0.04514030f, 0.14783236f, 0.06147537f, -0.02195499f, 0.19852059f, 0.07197065f, -0.14511290f, -0.22050191f, 
    0.18309806f, -0.06034057f, -0.00385901f, 0.01221910f, 0.49846557f, -0.07026883f, -0.27708933f, -0.17590328f, 
    0.09399866f, -0.08271500f, -0.11026861f, 0.08727811f, 0.10570727f, 0.09481779f, -0.00319986f, -0.01120516f, 
    0.02738333f, 0.06289528f, -0.01997395f, -0.24723096f, 0.04771736f, 0.30145928f, -0.05127426f, -0.11876469f, 
    0.17147215f, -0.12390098f, 0.33036289f, 0.17300718f, 0.34652731f, 0.10358793f, 0.35959363f, -0.04036387f, 
    -0.02596362f, 0.13557787f, 0.01579213f, 0.03068258f, -0.17213549f, -0.10736938f, 0.00273510f, -0.07369642f, 
    -0.03038718f, 0.04703480f, 0.01792487f, 0.04684319f, 0.05629764f, -0.06588720f, 0.18610190f, 0.07845649f, 
    0.21642117f, -0.03749404f, 0.16177192f, 0.14133163f, 0.12641001f, -0.06487485f, -0.00397641f, -0.03200789f, 
    -0.06104247f, 0.07473107f, 0.01964542f, 0.00825694f, 0.09080108f, 0.00900341f, 0.08941717f, 0.01363876f, 
    0.08188703f, 0.06574024f, 0.35330224f, 0.00361878f, 0.09895434f, -0.05959645f, 0.08813873f, -0.02321049f, 
    -0.01073295f, 0.07437994f, 0.10661962f, 0.07736793f, -0.14756323f, 0.00840952f, 0.08510880f, 0.03918228f, 
    -0.03084514f, -0.05733555f, 0.15083043f, -0.02969546f, -0.25973397f, -0.13231876f, 0.35926807f, -0.03660252f, 
    0.18544672f, 0.34913701f, -0.02868558f, 0.13041714f, -0.09814223f, -0.04106441f, 0.16420884f, 0.02924719f, 
    -0.17399541f, -0.02303892f, -0.00585094f, -0.00799484f, 0.11072126f, 0.25375277f, -0.16534916f, -0.11929873f, 
    -0.06824461f, -0.10195054f, 0.12443277f, 0.22547764f, 0.18036115f, -0.06483559f, 0.16812576f, 0.06967469f, 
    0.23606649f, -0.04872457f, 0.03294972f, 0.06143841f, -0.00313552f, 0.09358667f, -0.03874719f, 0.13035031f, 
    0.06715392f, 0.06437264f, 0.19431852f, -0.00015207f, 0.08821408f, 0.20397872f, 0.60488504f, -0.38728136f, 
    -0.01029030f, 0.02824095f, -0.00419815f, -0.01308758f, -0.11800633f, 0.13189964f, -0.06421757f, 0.23527449f, 
    0.20240046f, -0.04292482f, -0.11015812f, 0.14137733f, -0.14939898f, 0.35660383f, -0.21029319f, -0.00956904f, 
    -0.30722255f, -0.23339312f, -0.08265021f, -0.15889753f, -0.09529389f, -0.14235675f, 0.02971374f, -0.06076889f, 
    -0.05461499f, 0.05488261f, -0.15194339f, -0.00971858f, -0.00987824f, 0.14230382f, -0.08188257f, 0.04111864f, 
    0.23545140f, 0.14146690f, 0.05238508f, -0.00248223f, -0.17351572f, 0.01374777f, 0.15682562f, -0.12531197f, 
    -0.15935178f, 0.07827340f, -0.10594087f, -0.03767354f, -0.02843846f, -0.03189322f, 0.04076563f, -0.08259078f, 
    -0.13188787f, 0.19372325f, 0.10186376f, -0.06486695f, 0.06762219f, 0.02199177f, 0.06666230f, 0.06194492f, 
    0.00512731f, 0.09211709f, 0.31183001f, 0.15617566f, 0.12234711f, 0.02219230f, 0.02790302f, -0.09028941f, 
    0.07980841f, -0.03069061f, -0.00430244f, 0.02278868f, 0.02111740f, -0.11625490f, 0.04402972f, -0.04496292f, 
    -0.00955839f, -0.02373892f, 0.14291985f, 0.04549130f, -0.00519150f, 0.09180482f, -0.18054764f, -0.20622841f, 
    -0.00713450f, 0.18071918f, -0.13584577f, -0.08512696f, -0.10959452f, 0.15701199f, 0.04396397f, 0.08860606f, 
    -0.06182187f, 0.03072742f, 0.15931623f, 0.30778468f, 0.15315726f, -0.16291425f, -0.07432074f, 0.09587312f, 
    -0.59753394f, -0.00609327f, 0.05530741f, -0.34201607f, 0.21523218f, 0.09188436f, -0.12956373f, -0.08182985f, 
    0.00324232f, -0.07580157f, 0.10394765f, 0.21580279f, 0.06157507f, 0.15651396f, 0.02438202f, -0.11545859f, 
    0.09236413f, 0.00935862f, 0.08907640f, 0.26622084f, -0.18334767f, -0.09218024f, 0.09002721f, -0.20734964f, 
    0.10217771f, -0.13187875f, 0.13550965f, -0.13256463f, -0.18288475f, 0.01584063f, 0.13099800f, -0.09394733f, 
    0.00486529f, -0.01551269f, -0.01459903f, 0.10994623f, -0.17078108f, 0.03162852f, -0.24850935f, 0.09261768f, 
    -0.01808021f, 0.07355399f, 0.30587220f, 0.04079845f, 0.21681868f, -0.00646798f, 0.13910967f, 0.40265203f, 
    -0.00005562f, 0.01342472f, 0.04347045f, 0.13692853f, -0.04067679f, -0.16535307f, -0.11441301f, 0.01906977f, 
    0.03918273f, 0.21197107f, 0.16361602f, -0.14547367f, -0.56415778f, 0.25735605f, 0.36535242f, -0.16592441f, 
    0.38092655f, 0.04289304f, -0.22481070f, -0.05997993f, 0.02893329f, 0.08696445f, -0.06278635f, 0.10655600f, 
    0.05683118f, 0.04172574f, 0.05349949f, 0.00381007f, -0.12519899f, 0.02059035f, -0.02893785f, 0.03150212f, 
    0.07365918f, -0.30128488f, -0.28029388f, 0.03917235f, 0.07940099f, 0.12035545f, 0.21026154f, 0.16381651f, 
    -0.06501041f, 0.06500290f, -0.03942608f, -0.06240349f, -0.11739116f, -0.14850676f, -0.02345238f, -0.04857086f, 
    0.03460281f, -0.02082632f, -0.21795094f, 0.09701596f, -0.26166165f, 0.19284479f, -0.57113022f, 0.61154538f, 
    0.24463888f, -0.00753877f, 0.17129326f, 0.33504033f, -0.08897262f, 0.13664921f, 0.02914229f, -0.08266250f, 
    -0.05763397f, -0.15556848f, 0.00394551f, 0.09853279f, -0.09327114f, 0.22854085f, -0.02018196f, -0.05715880f, 
    -0.29807478f, -0.30237871f, -0.38442367f, -0.20165759f, -0.00806569f, 0.11604810f, 0.14100146f, 0.28740475f, 
    -0.12236951f, 0.08796662f, 0.10985823f, 0.00991022f, -0.04515229f, -0.08760171f, 0.09409089f, 0.04832495f, 
    0.02513457f, -0.00739270f, -0.14314874f, -0.00929125f, -0.08171131f, 0.10230175f, -0.25457788f, 0.15453489f, 
    0.12699297f, -0.13170922f, 0.01643920f, 0.16041547f, -0.14261383f, 0.03671190f, 0.12694155f, -0.06573151f, 
    -0.18489181f, -0.23092750f, 0.03993719f, 0.13615903f, -0.01933676f, 0.08876581f, -0.11224303f, -0.32820371f, 
    0.15992031f, 0.04652924f, 0.41396338f, 0.01392710f, -0.08330195f, 0.12204347f, 0.08697578f, -0.00747127f, 
    0.04943083f, 0.07251274f, -0.12664650f, -0.04469371f, -0.23826979f, -0.12930720f, -0.01617936f, -0.03353051f, 
    0.08219131f, -0.00061007f, 0.30078197f, 0.00957109f, 0.16269477f, -0.01489790f, 0.02288711f, -0.12597232f, 
    -0.16181147f, -0.11214408f, 0.06665214f, 0.03464157f, -0.02591238f, 0.06701517f, 0.18770640f, -0.09592996f, 
    -0.08524231f, -0.05479193f, 0.05333135f, 0.11685565f, -0.16131328f, -0.16960122f, 0.07900015f, 0.07925115f, 
    0.03802638f, 0.56134498f, 0.13626544f, 0.03852904f, 0.16196504f, 0.02346332f, -0.07283698f, -0.28626576f, 
    0.06210621f, 0.24760708f, -0.13489075f, 0.09945404f, -0.12358782f, 0.06925110f, 0.02041596f, -0.12769921f, 
    -0.08636041f, -0.02481168f, 0.06062685f, 0.10262767f, 0.02317370f, 0.19651732f, 0.21662724f, -0.15160733f, 
    0.08766408f, -0.06585156f, -0.02286712f, -0.27441585f, -0.07692925f, 0.09922989f, -0.01784750f, 0.05120623f, 
    -0.04753142f, -0.04862446f, 0.06747407f, -0.00901444f, -0.09948523f, -0.06427308f, 0.00570863f, 0.15553573f, 
    -0.28332284f, -0.22081842f, 0.10345128f, -0.14289753f, -0.08070155f, 0.05133894f, 0.15815380f, -0.04689462f, 
    0.08060467f, 0.13034840f, 0.03660812f, 0.01869434f, -0.08872111f, 0.10310024f, -0.02936169f, 0.01513502f, 
    0.01846492f, 0.02976661f, 0.32894960f, -0.05304236f, -0.20721664f, 0.04504491f, -0.45465332f, 0.34098163f, 
    0.17711376f, -0.01165737f, 0.18888250f, 0.17900796f, -0.02015328f, 0.07773834f, 0.05498606f, -0.01274382f, 
    -0.06480955f, -0.05524633f, 0.03699372f, -0.00126769f, -0.01909783f, 0.02472042f, -0.10452233f, 0.00576969f, 
    0.03081812f, 0.00917679f, -0.00629023f, 0.01722010f, 0.02730648f, -0.00612461f, 0.00860836f, -0.03510753f, 
    0.02987563f, 0.01365925f, -0.00130462f, -0.00852824f, 0.02107711f, 0.00317104f, 0.02899292f, 0.03348941f, 
    0.02526577f, -0.02247986f, 0.00313539f, -0.01885436f, 0.00678264f, -0.03556356f, -0.01416961f, 0.00033681f, 
    0.02172899f, 0.00880444f, -0.02315368f, -0.04325985f, 0.02804531f, -0.03190308f, -0.01027293f, 0.00565743f, 
    0.01844023f, 0.01748884f, -0.00675079f, 0.02246814f, 0.00056522f, 0.01187103f, 0.02674055f, 0.01286861f, 
    -0.03638298f, -0.03768814f, 0.00730890f, -0.03895465f, -0.00637902f, -0.01414763f, 0.02149376f, -0.03679391f, 
    0.01609277f, -0.00271634f, -0.03289708f, 0.02461976f, -0.03181606f, -0.02456867f, 0.00328486f, 0.00864551f, 
    -0.00996387f, 0.02057383f, -0.00543333f, 0.00989124f, -0.03435662f, 0.00803323f, -0.00224721f, -0.04723157f, 
    -0.02116090f, 0.03130658f, 0.01663469f, -0.03705130f, -0.03479041f, -0.00164742f, -0.04009901f, 0.00551703f, 
    -0.00617801f, 0.02705414f, -0.00028767f, 0.01665217f, 0.03145229f, -0.01193361f, -0.02280578f, -0.04371821f, 
    0.00203575f, -0.00822795f, 0.01636343f, -0.01089290f, -0.02854335f, 0.00870402f, 0.02632021f, -0.03425115f, 
    0.01476802f, -0.04620181f, 0.00369670f, -0.01451685f, 0.02178942f, 0.01413719f, 0.00229809f, 0.01651021f, 
    0.00415140f, 0.01510551f, 0.00082614f, 0.01323952f, -0.01422972f, -0.00263414f, -0.00967118f, 0.01110802f, 
    -0.01634655f, 0.01516610f, 0.00097393f, 0.01328626f, -0.02832495f, -0.03221801f, -0.01008590f, -0.00618836f, 
    0.01474807f, 0.00423470f, -0.02125097f, -0.00767595f, 0.02321610f, -0.01611312f, -0.04698190f, -0.02520483f, 
    -0.02344827f, 0.01615717f, 0.01325314f, -0.02481252f, 0.01014907f, 0.01318088f, -0.03957088f, -0.01653866f, 
    -0.00885905f, -0.03146406f, -0.02497782f, 0.01253846f, 0.02271752f, -0.03667621f, -0.00987663f, 0.03198692f, 
    -0.02744078f, 0.01403735f, -0.04279705f, -0.00275272f, 0.00992187f, -0.04720805f, 0.01761172f, 0.01553405f, 
    0.02169544f, 0.01368419f, 0.02131134f, -0.03936844f, 0.00165332f, 0.02660649f, -0.00583954f, -0.02569764f, 
    -0.01817976f, 0.02395624f, -0.04480137f, -0.02419103f, -0.04294084f, -0.01170624f, 0.01495525f, -0.02307224f, 
    0.00894220f, 0.04040179f, -0.03710275f, -0.01997567f, 0.00353375f, -0.00613339f, -0.02034441f, -0.03586273f, 
    0.01653655f, -0.02653635f, 0.01232058f, -0.01178864f, 0.02817384f, 0.01977966f, 0.01419127f, -0.03421880f, 
    -0.01682707f, -0.04583549f, 0.00946445f, -0.01748086f, -0.03269700f, 0.03390777f, 0.00267517f, -0.02870543f, 
    0.00743391f, -0.02389500f, 0.00300602f, 0.00926797f, -0.02663581f, 0.01644414f, 0.01017711f, -0.03620242f, 
    -0.04703711f, -0.00808969f, 0.02718612f, 0.01095246f, -0.03080787f, -0.04858679f, -0.00840543f, 0.02007826f, 
    -0.03317008f, -0.04317575f, -0.02196473f, 0.02299171f, -0.01841140f, 0.02023946f, -0.01964912f, -0.04584086f, 
    -0.01159799f, -0.00745279f, -0.03649776f, 0.02811228f, -0.02365820f, -0.03477967f, -0.03034302f, -0.02421866f, 
    0.01646446f, -0.01775500f, -0.02432069f, -0.03004575f, 0.01266881f, -0.02496886f, -0.02344304f, -0.04062369f, 
    0.01596660f, -0.03117289f, 0.01672304f, -0.01465669f, 0.01282266f, 0.02582275f, -0.04484180f, -0.04537055f, 
    0.02881003f, 0.01526023f, 0.02864300f, 0.00842694f, 0.00555307f, 0.00362944f, -0.01257532f, 0.02934529f, 
    0.00346496f, -0.02532024f, -0.03243971f, 0.01080833f, -0.01553005f, -0.01511970f, -0.01520331f, 0.00838692f, 
    -0.02111042f, -0.04724785f, -0.03832119f, 0.01627783f, 0.01496709f, -0.04249538f, -0.04508193f, -0.02516086f, 
    -0.01823933f, -0.00063554f, 0.02979936f, -0.02794721f, 0.00924627f, -0.00250045f, 0.02805699f, -0.02473996f, 
    -0.01770516f, -0.00205810f, -0.03921792f, 0.02517449f, 0.00135687f, -0.01736869f, -0.00984594f, 0.02800164f, 
    0.00429010f, 0.00467384f, -0.04964941f, -0.02689150f, 0.02712736f, 0.03088972f, 0.00005946f, -0.02190172f, 
    -0.01320846f, -0.01816359f, 0.02575872f, 0.01122086f, -0.02091816f, 0.00478378f, -0.03944040f, -0.04340380f, 
    0.01948831f, -0.04074019f, -0.00835084f, 0.02898688f, -0.04957539f, 0.02104441f, -0.02328507f, 0.02796039f, 
    -0.03196685f, 0.01937582f, -0.03434732f, -0.00469158f, 0.00043844f, -0.01665479f, -0.04639987f, 0.01161821f, 
    -0.04114161f, 0.00620359f, 0.02722609f, 0.01867605f, 0.02488110f, 0.00535258f, 0.01884800f, 0.01891520f, 
    -0.02351296f, -0.01888484f, -0.04599770f, 0.02769812f, 0.03034989f, 0.01756048f, -0.04689537f, 0.02411871f, 
    -0.00057363f, -0.00969292f, -0.02498031f, -0.02937229f, -0.01380585f, 0.02794410f, 0.00147875f, 0.01942224f, 
    -0.02536274f, 0.02313665f, -0.00140036f, -0.01112641f, -0.00648375f, 0.02247147f, 0.00034521f, -0.02307687f, 
    0.02143027f, -0.02694717f, 0.01917381f, -0.00119470f, -0.04658811f, -0.03077766f, 0.00159869f, 0.00218981f, 
    -0.02658955f, -0.02228574f, -0.04094580f, 0.00428841f, -0.02677270f, -0.00687746f, -0.01829117f, 0.01634956f, 
    -0.00375196f, -0.04244624f, -0.00163252f, -0.03332374f, 0.01804161f, -0.00383612f, 0.01490712f, -0.01684554f, 
    0.00388625f, -0.01114344f, 0.02786060f, -0.03079982f, 0.00423942f, -0.03108617f, 0.01369457f, -0.03532238f, 
    0.01415342f, -0.02221607f, 0.01204574f, 0.02958719f, 0.02762039f, -0.03942106f, 0.00577725f, -0.03738314f, 
    -0.00282111f, -0.03114460f, 0.01756335f, -0.01427730f, -0.03764182f, -0.02472986f, -0.04871789f, -0.02226141f, 
    -0.01984298f, -0.00884283f, -0.03835130f, 0.03265147f, -0.02804820f, 0.01625766f, -0.02374016f, 0.03164748f, 
    0.00406758f, 0.02300998f, -0.03378912f, 0.03020073f, -0.00682045f, -0.04057155f, -0.00666871f, 0.01791386f, 
    0.03288807f, -0.02501745f, 0.02470784f, 0.00675537f, 0.02462343f, 0.00917052f, -0.02637045f, -0.01186658f, 
    -0.02033172f, -0.02852811f, -0.02252201f, -0.00023019f, -0.02511932f, -0.01506830f, 0.02757693f, -0.03500735f, 
    -0.00380576f, -0.03046194f, 0.00978879f, -0.03985898f, -0.00455326f, 0.01256356f, -0.02646036f, -0.03093867f, 
    0.02080330f, -0.04479228f, 0.02152514f, 0.00993283f, 0.02458118f, 0.01551327f, -0.01255861f, 0.00349134f, 
    0.01372694f, 0.03187117f, 0.01205993f, -0.00410783f, 0.03185253f, 0.01931909f, 0.00110530f, -0.00399593f, 
    0.02940601f, -0.02679730f, -0.02067200f, -0.02827956f, -0.02805624f, -0.01390037f, -0.04233094f, -0.00945629f, 
    -0.02643100f, 0.00776863f, -0.01949340f, 0.01351088f, -0.03035977f, 0.01733878f, -0.04053264f, -0.03567425f, 
    -0.02705822f, -0.03623396f, -0.02113671f, -0.04795885f, -0.04846117f, -0.04710402f, -0.02940175f, -0.04146804f, 
    -0.00670554f, -0.04409475f, -0.04201975f, -0.04329485f, 0.00388310f, 0.02836575f, -0.03580450f, -0.04838749f, 
    -0.00859263f, 0.00911756f, -0.01250932f, 0.01183121f, 0.00943046f, -0.00181808f, 0.02582663f, -0.00967804f, 
    -0.04062337f, 0.01201428f, 0.00531886f, 0.02634077f, -0.04466395f, -0.04782862f, -0.04742999f, 0.01467167f, 
    -0.00832146f, -0.00891329f, -0.01420976f, 0.03258457f, -0.04036424f, -0.04456034f, -0.01922524f, -0.01456543f, 
    -0.01158758f, 0.02378975f, -0.01006379f, -0.00582939f, -0.02667339f, -0.01974445f, -0.02011049f, 0.03973962f, 
    -0.01521580f, 0.00343996f, 0.00694413f, -0.04378247f, 0.02698104f, -0.03334238f, -0.03995356f, -0.03302276f, 
    -0.00044156f, -0.01550326f, 0.01859112f, 0.00493860f, -0.02408629f, 0.02277075f, -0.01749614f, -0.00030383f, 
    -0.02916381f, 0.03942925f, -0.01794615f, -0.03461818f, -0.03374960f, -0.02373636f, -0.00017193f, -0.02694288f, 
    0.02582328f, -0.03862197f, 0.00740540f, -0.00243965f, -0.01521738f, -0.04859076f, -0.04636364f, -0.04807815f, 
    0.02455186f, -0.02828970f, -0.00029450f, 0.01656784f, -0.04423278f, 0.01496915f, 0.00282218f, -0.03579709f, 
    0.01956742f, 0.00581521f, -0.04893347f, -0.03584723f, -0.02132429f, -0.01437847f, -0.00994693f, 0.02222782f, 
    0.02135660f, 0.00598227f, -0.00345070f, -0.00211398f, 0.02005032f, -0.02991887f, 0.01214878f, -0.00190860f, 
    -0.01252578f, 0.02629717f, -0.02198468f, -0.00952547f, -0.02264451f, 0.01519299f, 0.02897603f, -0.00726910f, 
    -0.03818180f, 0.01932571f, -0.03572013f, 0.02572266f, -0.01994227f, -0.01463685f, -0.04864604f, -0.03768642f, 
    -0.03321557f, -0.04742581f, -0.02396136f, -0.04877368f, -0.00021030f, 0.00623072f, -0.01802808f, -0.04110229f, 
    0.01444284f, -0.03637170f, 0.02083993f, -0.01525683f, -0.02790405f, -0.01726290f, 0.00044476f, -0.00549762f, 
    -0.00397469f, 0.01017309f, -0.01698940f, 0.02304727f, -0.04274049f, -0.01497388f, -0.00643138f, 0.00810989f, 
    -0.03243435f, -0.00966551f, -0.02281829f, 0.02766722f, 0.01946650f, -0.02599307f, -0.01940429f, -0.02149484f, 
    -0.04604416f, 0.01662910f, 0.02136786f, -0.00078324f, -0.01092618f, -0.00327132f, 0.01605695f, 0.02158904f, 
    -0.01554814f, 0.00281084f, -0.01345056f, 0.01123721f, -0.01581874f, 0.01908124f, -0.00757528f, -0.01732468f, 
    -0.03954408f, 0.02762729f, -0.03587534f, -0.02289827f, -0.00744285f, 0.00674305f, 0.01704646f, 0.01509400f, 
    -0.01541114f, 0.01179264f, 0.02656779f, -0.03817376f, 0.00683701f, -0.04915281f, 0.01834884f, 0.00338973f, 
    -0.26307088f, 0.19204369f, -0.22108671f, 0.12236036f, -0.06215069f, 0.05899225f, -0.15642266f, 0.03779848f, 
    -0.15242116f, -0.05711784f, 0.04236178f, 0.00089920f, 0.02239197f, 0.17030214f, 0.15717204f, 0.08542288f, 
    -0.08351680f, 0.10346204f, -0.01376743f, -0.09304509f, 0.43249136f, -0.66476029f, 0.03905394f, -0.49004072f, 
    0.09435117f, -0.16658445f, 0.04100073f, -0.15709437f, -0.11873550f, -0.10961289f, 0.11146397f, 0.07727764f, 
    0.03274814f, 0.03815947f, -0.09025098f, 0.04756051f, 0.05976417f, -0.13231462f, -0.10257699f, 0.11997689f, 
    -0.00174078f, -0.12436838f, 0.00822268f, -0.00942848f, -0.17024058f, -0.10221908f, 0.00410736f, -0.03005560f, 
    0.13327508f, 0.04394288f, 0.01592006f, -0.12988590f, -0.03054805f, 0.03692808f, 0.08234140f, 0.02832857f, 
    0.04816405f, 0.07731741f, 0.00532944f, 0.05136710f, 0.06334494f, 0.06200203f, 0.10700204f, 0.10332449f, 
    0.29185838f, -0.11904537f, -0.10407501f, -0.12139543f, -0.02304982f, -0.01832976f, -0.01092173f, 0.03006411f, 
    0.01367842f, 0.05282055f, -0.07244388f, 0.03058810f, 0.00329858f, -0.15465567f, -0.15903749f, -0.03154947f, 
    -0.06136967f, -0.34475362f, 0.04049099f, -0.04729881f, -0.13237764f, -0.01531537f, -0.00863092f, 0.00164062f, 
    0.09989984f, -0.04879177f, 0.01504765f, -0.01769882f, 0.03446323f, 0.10281390f, 0.07626533f, 0.11695750f, 
    0.04346295f, 0.00034377f, 0.10864748f, 0.07182735f, 0.14289936f, -0.10108066f, 0.06257611f, 0.10137352f, 
    -0.13145912f, -0.00355102f, -0.03732888f, 0.01435391f, 0.00363957f, 0.07104828f, 0.08365830f, 0.01450849f, 
    -0.06705008f, 0.01880059f, 0.10247269f, -0.06148380f, 0.09659432f, 0.02596411f, 0.17643844f, 0.12692013f, 
    -0.32310188f, 0.00990220f, 0.04516904f, 0.22718897f, -0.19493829f, -0.08565170f, -0.03034325f, -0.05016034f, 
    -0.02559905f, -0.09399124f, 0.10434344f, 0.06554212f, 0.09575202f, 0.03059717f, -0.06149669f, -0.02049088f, 
    0.16117667f, -0.07460614f, 0.02245758f, 0.18577789f, -0.07050908f, -0.02131374f, 0.00526349f, -0.05685561f, 
    -0.26128280f, -0.05908352f, -0.13920777f, -0.15652001f, 0.06648918f, 0.05359919f, 0.09928601f, -0.07339255f, 
    0.11198010f, 0.05775123f, 0.06964824f, -0.05567073f, 0.16909119f, 0.04068268f, -0.10251612f, 0.08305506f, 
    0.23241298f, 0.08828918f, 0.47493562f, -0.12309770f, 0.03666744f, 0.08168605f, 0.16676272f, 0.00711459f, 
    0.13065973f, 0.27372277f, 0.04091661f, 0.09635098f, 0.02212778f, -0.13684729f, -0.04923391f, -0.07452633f, 
    -0.01003050f, -0.11422713f, 0.04317099f, -0.02383164f, 0.18653123f, -0.00091612f, 0.29654807f, -0.14283466f, 
    0.15068181f, 0.07012833f, 0.05024013f, 0.05887141f, -0.03063938f, 0.12501496f, 0.02501411f, -0.09138048f, 
    0.02724643f, 0.05884951f, 0.01998768f, 0.02491447f, 0.13799620f, -0.05324269f, 0.05245509f, 0.11768018f, 
    0.11079521f, 0.22627570f, 0.18395066f, -0.16468726f, 0.06915954f, -0.10749038f, 0.12889442f, 0.03170513f, 
    -0.00070530f, 0.08411036f, -0.01304277f, 0.01414390f, -0.02565253f, -0.02664866f, -0.02706149f, -0.05125138f, 
    0.01064794f, -0.05044861f, 0.03266674f, -0.04384563f, -0.39163089f, -0.11844440f, 0.10915556f, -0.41901660f, 
    0.01578794f, 0.14469960f, 0.01919931f, 0.22258849f, -0.12002698f, 0.06883284f, 0.12040299f, -0.02934809f, 
    -0.12287597f, 0.18458818f, 0.11914015f, -0.12649821f, -0.09187552f, 0.02347784f, -0.16233976f, -0.16833831f, 
    0.00868321f, 0.15504232f, 0.40435958f, 0.12401189f, -0.05495879f, 0.00444842f, 0.01910165f, 0.02847294f, 
    0.18064609f, 0.17139471f, -0.00768197f, -0.04842438f, 0.01538926f, 0.19493189f, 0.08838937f, 0.00514288f, 
    0.08966518f, 0.03246803f, 0.14515856f, 0.15864836f, 0.35123053f, -0.04700762f, -0.01744464f, -0.25364956f, 
    -0.17954417f, -0.07250492f, -0.13292749f, 0.01461388f, 0.02194757f, 0.01768439f, 0.02567748f, 0.06378204f, 
    0.10878111f, 0.06415258f, -0.09076965f, -0.03164668f, -0.00978604f, 0.09604455f, -0.04617516f, 0.02730414f, 
    -0.06364710f, -0.12911282f, 0.01469728f, -0.07684557f, -0.13190611f, -0.18426766f, 0.06578134f, -0.02308898f, 
    0.05386241f, 0.07467336f, 0.02444847f, -0.09202098f, 0.00466950f, 0.01871042f, 0.15286180f, 0.02700333f, 
    0.15764394f, 0.06651936f, 0.04184090f, 0.14334397f, -0.11367463f, -0.00613479f, -0.02331014f, 0.03507230f, 
    0.00982777f, -0.00172210f, -0.07969054f, -0.11004566f, -0.01830266f, -0.07339926f, -0.02637164f, 0.05535873f, 
    0.01918421f, 0.11788335f, 0.07582152f, -0.07302061f, 0.08448534f, -0.01921268f, -0.11443982f, 0.03389937f, 
    0.29423007f, -0.02740302f, 0.18858267f, 0.06803907f, -0.14230844f, 0.01493362f, -0.05167906f, 0.00135092f, 
    0.01826949f, -0.01514413f, -0.00059953f, -0.02532325f, -0.03046629f, 0.01283108f, 0.13706653f, -0.04866650f, 
    -0.02457159f, -0.03242377f, 0.06696612f, 0.07381617f, 0.04303501f, 0.09150922f, 0.01755869f, -0.39167431f, 
    0.02185946f, 0.07179628f, -0.12385355f, 0.21953247f, -0.15414424f, -0.03713965f, 0.09883479f, 0.06922262f, 
    -0.14019050f, -0.00533347f, 0.21985206f, 0.15826216f, 0.05804252f, -0.03305306f, -0.16849300f, -0.10048827f, 
    0.01144208f, -0.18560097f, -0.08801395f, -0.24139935f, 0.03357977f, -0.01061621f, -0.26272699f, -0.07350684f, 
    0.03639342f, -0.03957072f, -0.02738443f, 0.13896619f, 0.10943765f, -0.01351187f, -0.05067881f, -0.04659695f, 
    0.13416897f, 0.10911396f, 0.08485562f, 0.23871119f, 0.16436848f, -0.19397545f, 0.32222122f, -0.22950636f, 
    0.32022464f, -0.04466460f, 0.02096952f, -0.19653520f, -0.20323256f, -0.19501175f, 0.25072920f, -0.00555624f, 
    0.05848105f, 0.01109345f, 0.07494884f, -0.03376928f, -0.09139006f, -0.05221099f, -0.26020396f, 0.08293840f, 
    0.03740511f, 0.16737044f, 0.19019972f, 0.09248452f, -0.05405784f, -0.04152255f, 0.08462430f, 0.06264233f, 
    -0.01597548f, 0.23993225f, 0.01434291f, 0.03957976f, -0.00008324f, -0.03159432f, -0.13474242f, 0.00825625f, 
    0.09979896f, -0.02117389f, 0.14966318f, 0.02265385f, 0.17775244f, 0.00055174f, 0.16739264f, -0.16409038f, 
    -0.10621642f, -0.18249169f, -0.20124353f, 0.05682238f, -0.08717068f, -0.13847774f, 0.01276681f, 0.08891060f, 
    0.10048652f, 0.01070890f, 0.03719265f, 0.02886156f, -0.04571183f, 0.02784649f, -0.06111338f, -0.00767059f, 
    -0.00167821f, -0.18295416f, -0.29876617f, -0.00347126f, 0.16547740f, 0.02919690f, 0.06952075f, 0.01780629f, 
    0.05058314f, 0.00821838f, -0.13930948f, -0.09392937f, -0.07697821f, -0.07135233f, -0.14458363f, 0.06382393f, 
    0.07557273f, -0.04350737f, -0.06246138f, 0.06067507f, -0.33435249f, 0.51359123f, -0.61810875f, 0.40968236f, 
    -0.08074986f, 0.19156416f, 0.04553115f, 0.08518230f, -0.04645431f, 0.03797354f, 0.10843107f, -0.04543663f, 
    -0.02865984f, -0.09172781f, -0.07177323f, 0.17494404f, 0.04524302f, 0.11998360f, 0.06359639f, 0.08102746f, 
    -0.28600007f, -0.04946417f, -0.35974497f, 0.17836291f, 0.24019472f, 0.06817033f, 0.14730445f, 0.29449731f, 
    0.04905422f, 0.07144537f, 0.01257483f, -0.01557831f, -0.00665246f, 0.08329504f, 0.09557811f, 0.17734131f, 
    0.03760363f, -0.09472605f, 0.00396059f, -0.03922478f, -0.27451175f, 0.22992218f, -0.13583045f, 0.18462877f, 
    -0.12482156f, -0.15512714f, -0.01426551f, 0.02805871f, -0.00350863f, 0.04637535f, 0.08866707f, 0.08746148f, 
    0.04839220f, -0.17684029f, -0.07241170f, -0.02972276f, -0.16947740f, -0.25292501f, -0.06604622f, -0.39961118f, 
    0.13487932f, 0.12323653f, 0.29688212f, -0.17741972f, -0.07622053f, 0.06296995f, -0.02564542f, -0.02131718f, 
    0.05558873f, 0.10324016f, -0.10862811f, -0.09789854f, -0.01888419f, -0.10465882f, -0.04326934f, -0.03881165f, 
    0.02915438f, -0.05033739f, 0.16884111f, -0.04464624f, 0.12407538f, 0.14594269f, -0.26613161f, 0.02394584f, 
    -0.20859136f, 0.02707625f, -0.17037486f, -0.18407613f, -0.00813020f, 0.01619738f, 0.04709029f, -0.08191640f, 
    -0.02164975f, -0.02397984f, 0.09878641f, 0.08711413f, -0.10487900f, -0.20297070f, -0.04646064f, -0.03179560f, 
    0.33518952f, 0.16999267f, 0.03693182f, 0.13283764f, -0.12115281f, -0.19943635f, -0.09878317f, -0.10238976f, 
    0.07800274f, -0.05254374f, 0.12026738f, 0.07952853f, -0.03987002f, -0.04341673f, 0.02441575f, -0.11342815f, 
    -0.08696285f, 0.03567409f, 0.06366070f, 0.05530933f, 0.24240401f, 0.16527292f, 0.12600163f, 0.04164471f, 
    -0.02535161f, -0.21333940f, -0.13072821f, -0.14523987f, -0.04465631f, -0.09146750f, 0.09105978f, 0.00431522f, 
    0.02009945f, 0.05955565f, 0.01800215f, -0.06904162f, -0.10125736f, 0.00529658f, -0.04419979f, -0.03930148f, 
    0.09504785f, 0.03340057f, 0.17070457f, -0.11298670f, -0.16893212f, -0.04470197f, 0.13984911f, 0.02787987f, 
    0.15299696f, 0.19520554f, 0.08755930f, -0.13521746f, -0.01489526f, 0.09487697f, -0.01378972f, 0.05577842f, 
    -0.00743862f, -0.01442381f, 0.16015728f, -0.03854657f, -0.15147804f, 0.33111343f, -0.44556248f, 0.31366920f, 
    0.07661961f, 0.14686254f, 0.05527541f, 0.15346789f, -0.02997403f, 0.04220390f, 0.00966165f, -0.06901937f, 
    -0.02093604f, 0.07528035f, 0.02187286f, 0.01414329f, 0.13939320f, -0.01624971f, 0.10018324f, 0.03737699f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07864105f, 0.07057413f, -0.01623519f, -0.00133005f, 0.19678038f, -0.00029434f, 0.13356724f, 0.01742001f, 
    -0.03623510f, -0.09883954f, -0.01920932f, -0.03639175f, 0.02847913f, 0.02328200f, -0.16321324f, 0.08136190f, 
    -0.01081683f, 0.05183957f, -0.00468300f, 0.00642787f, -0.02059336f, 0.11719279f, -0.03000749f, 0.17832780f, 
    0.00614664f, 0.00790855f, -0.03689933f, -0.00967592f, -0.01522937f, 0.05592842f, 0.02823229f, -0.01905487f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03979525f, -0.15785979f, 0.09084160f, 0.05175762f, 0.14169574f, -0.16719837f, -0.41047755f, -0.16902266f, 
    0.03371234f, 0.12993824f, -0.08764106f, -0.05659500f, -0.00322803f, -0.14612520f, 0.20314223f, 0.25539657f, 
    0.08813480f, -0.05843307f, 0.16083482f, -0.16919085f, -0.09303574f, -0.15693232f, 0.02730809f, -0.20223135f, 
    -0.03752068f, -0.07027187f, 0.07405749f, -0.12120632f, 0.12866642f, 0.16894427f, -0.02978285f, -0.13938002f, 
    -0.14124785f, 0.29556969f, 0.15954545f, -0.01810268f, 0.24872659f, 0.09451894f, 0.10603876f, -0.13494852f, 
    -0.09651836f, -0.00674615f, 0.02105604f, 0.07678908f, 0.26122022f, 0.04253221f, 0.12514041f, -0.11072484f, 
    -0.16071562f, 0.17548560f, -0.06414341f, -0.44584975f, 0.07250634f, 0.14648281f, -0.09764745f, 0.18176277f, 
    -0.49138114f, -0.04438094f, -0.16098633f, 0.03902975f, -0.17793782f, -0.31844461f, -0.09924185f, -0.09947208f, 
    0.18257940f, -0.13974389f, 0.06810978f, -0.12075447f, 0.22016214f, -0.45530677f, -0.40516147f, -0.12671433f, 
    0.12922041f, -0.12575364f, -0.12496610f, 0.00114899f, -0.03797638f, -0.14797768f, 0.08680365f, 0.06158530f, 
    -0.14399527f, -0.29775041f, 0.07484832f, 0.12533735f, 0.15550582f, 0.00999521f, 0.08011458f, 0.22918060f, 
    -0.13374104f, 0.15015280f, -0.11862075f, -0.03586116f, -0.02114715f, -0.20160294f, 0.16180573f, 0.05386423f, 
    -0.02876233f, 0.02125771f, 0.12157789f, -0.03901852f, -0.13564208f, 0.34825751f, -0.33059469f, 0.09770965f, 
    0.15012057f, 0.23969994f, 0.01582005f, 0.05333626f, 0.01014439f, 0.12769851f, 0.15102017f, -0.45060652f, 
    0.05877629f, 0.33177507f, 0.10553809f, -0.10344016f, -0.17512862f, -0.14492531f, 0.11207115f, 0.34904954f, 
    -0.35444739f, 0.08931568f, -0.14780378f, 0.26786351f, -0.05133182f, -0.24963914f, -0.04391079f, 0.22351581f, 
    0.02450008f, 0.01929097f, 0.07179695f, 0.15623099f, -0.00811504f, -0.07421578f, -0.35528830f, -0.15023328f, 
    0.14192396f, -0.06071203f, 0.04880153f, 0.04171501f, 0.00658618f, 0.16772342f, -0.06715373f, 0.13491242f, 
    -0.17413689f, -0.06762832f, 0.07249618f, -0.15301824f, 0.09150355f, -0.12129780f, -0.01664879f, 0.26411387f, 
    -0.03663360f, -0.06980495f, -0.05405408f, -0.00516633f, -0.09653667f, -0.15493074f, -0.08844997f, 0.03717454f, 
    0.16346046f, 0.23491229f, 0.11156107f, -0.07938420f, -0.22892991f, 0.22234923f, 0.18936889f, -0.16556951f, 
    -0.00137014f, 0.17423448f, 0.11622642f, -0.10769106f, -0.09178291f, -0.11655802f, 0.44366190f, 0.28281453f, 
    -0.00549330f, -0.12378401f, -0.11646461f, 0.00233258f, -0.10088704f, -0.27992958f, 0.04893862f, 0.12152502f, 
    -0.03639929f, -0.07744776f, -0.16844252f, 0.41167143f, -0.04781773f, -0.18541320f, -0.14510979f, 0.04838770f, 
    -0.28329024f, -0.17500013f, -0.02753127f, 0.15826862f, 0.13458933f, -0.08949780f, 0.09605112f, 0.04490261f, 
    -0.09233724f, -0.00943850f, -0.05026064f, -0.10822856f, -0.19110107f, -0.00426561f, 0.15600169f, 0.31137502f, 
    0.06900563f, -0.05636065f, 0.02340945f, 0.05502811f, 0.04810940f, 0.10731687f, -0.02882752f, 0.15547816f, 
    -0.07289625f, -0.11831878f, 0.15048884f, -0.06253274f, 0.06571800f, -0.12748858f, -0.03786256f, 0.19374117f, 
    0.22494088f, 0.21533613f, -0.12385151f, -0.16770694f, -0.16557610f, 0.20144944f, -0.12501377f, 0.08026341f, 
    0.04937142f, -0.09090274f, -0.13288598f, 0.09476244f, 0.16819401f, 0.13642417f, 0.12048174f, -0.04403108f, 
    0.15950952f, 0.20086907f, 0.06996051f, -0.39353341f, -0.04249163f, 0.06766993f, -0.04648756f, -0.23742579f, 
    0.44730031f, 0.13862067f, 0.07332803f, -0.13609864f, -0.13725887f, 0.13119826f, -0.02762279f, -0.17739458f, 
    0.15488645f, 0.34082764f, -0.03554302f, -0.11397615f, 0.11542465f, -0.05122478f, 0.25906044f, 0.00949672f, 
    0.04045208f, -0.00043117f, -0.11952690f, 0.08288500f, 0.02508791f, 0.01798145f, -0.45896381f, -0.13154167f, 
    0.03440212f, -0.06479359f, 0.02941966f, 0.18739262f, -0.10010152f, 0.00028224f, -0.08195573f, 0.08843856f, 
    0.20420466f, -0.09818283f, 0.00473246f, 0.08453628f, -0.08868140f, -0.15871561f, 0.12461983f, -0.11006565f, 
    -0.11402527f, -0.24648905f, 0.00751475f, 0.05625263f, 0.25070325f, 0.06727615f, 0.24735777f, 0.00472188f, 
    0.02102208f, 0.04491782f, 0.02418493f, -0.09132484f, 0.22715002f, 0.15426104f, -0.22273342f, 0.17016171f, 
    0.07252130f, 0.20915802f, -0.11901465f, 0.24887167f, 0.06913538f, 0.28251785f, 0.03421680f, 0.19239518f, 
    0.14393161f, -0.16728504f, -0.15636404f, -0.01052317f, 0.07994965f, -0.39062354f, -0.13754132f, -0.17277595f, 
    0.06206384f, -0.12892668f, 0.14896373f, 0.08241384f, -0.17079332f, 0.22435538f, -0.09845171f, 0.03482836f, 
    0.13539793f, -0.00221535f, -0.05621608f, -0.10321178f, -0.53938711f, -0.09294779f, -0.14169210f, -0.32849318f, 
    0.09984883f, 0.10777560f, -0.15795352f, 0.39301097f, -0.16234514f, 0.07365020f, -0.03957901f, 0.30716118f, 
    0.00354257f, -0.14936936f, 0.10776538f, -0.10029580f, 0.15884539f, 0.13196535f, -0.05919345f, 0.36962995f, 
    -0.18818583f, -0.18744065f, -0.12996908f, -0.07727112f, 0.05873720f, -0.01893623f, 0.08559645f, -0.05157948f, 
    -0.17730580f, 0.22676447f, 0.14792039f, 0.01230049f, -0.13736661f, -0.04914291f, 0.15413697f, 0.15553324f, 
    0.03471930f, -0.04485515f, -0.12894368f, 0.14018482f, 0.09061182f, -0.13319193f, 0.07251621f, -0.32707733f, 
    -0.03121875f, -0.00676947f, -0.03580021f, -0.29345095f, -0.00850134f, 0.15474923f, 0.15235347f, -0.37189323f, 
    -0.27981812f, -0.20764925f, -0.02353359f, 0.00707609f, 0.06528374f, -0.34523168f, 0.30850911f, -0.11100706f, 
    -0.14238714f, -0.01261210f, 0.12970503f, 0.00485238f, 0.18813609f, -0.18464264f, -0.18292303f, 0.21975262f, 
    0.01215689f, 0.10488465f, -0.06402973f, 0.09376804f, -0.04253281f, 0.00870519f, -0.00560763f, -0.05294193f, 
    0.07635807f, 0.04873158f, -0.15464421f, 0.16287544f, 0.04633304f, 0.41860437f, 0.02133194f, -0.05817007f, 
    -0.27330106f, 0.19945864f, -0.03383520f, -0.03653605f, 0.27338547f, -0.20931897f, 0.34042078f, -0.04571730f, 
    -0.16025504f, 0.09880783f, -0.09989841f, -0.14045972f, -0.16084699f, -0.07719748f, -0.11367138f, -0.26652163f, 
    -0.04774477f, 0.12230381f, -0.15653165f, 0.03734184f, -0.16113316f, 0.23414923f, -0.16768543f, 0.11172011f, 
    -0.29785430f, -0.05667822f, -0.09745117f, 0.09753591f, 0.17856389f, 0.07807121f, 0.16419521f, 0.20848681f, 
    0.11725169f, 0.29617974f, -0.01261218f, 0.12734218f, 0.24633281f, 0.07760476f, -0.16921452f, 0.08887453f, 
    0.16545309f, -0.26698363f, 0.00259080f, 0.05339080f, -0.18305728f, 0.04573924f, -0.34345269f, -0.31713539f, 
    0.14219488f, 0.02064985f, -0.00986618f, -0.04436298f, 0.02536854f, 0.27877522f, -0.08861816f, 0.23956957f, 
    -0.02567062f, 0.03870933f, -0.08396118f, -0.27390990f, -0.03232805f, 0.15582554f, -0.06389955f, -0.06863646f, 
    -0.14607547f, 0.02200407f, -0.04306388f, -0.09613197f, 0.05677928f, 0.06130354f, -0.23649779f, 0.12113822f, 
    0.13062616f, -0.01067111f, 0.16520758f, -0.16667704f, -0.16962373f, -0.17484173f, -0.27463210f, 0.02639564f, 
    0.10685945f, -0.00487781f, -0.17578675f, 0.08352791f, -0.02047953f, 0.18526219f, 0.06253836f, -0.10604171f, 
    0.30946970f, -0.13845250f, -0.09396368f, -0.22668111f, -0.02956774f, 0.15158696f, -0.08549307f, 0.27862734f, 
    -0.27367213f, -0.06852325f, -0.02176401f, -0.05991529f, -0.20108943f, 0.24319234f, 0.37936437f, 0.03765024f, 
    -0.09543190f, 0.07038826f, 0.03331041f, 0.04366542f, 0.18889047f, -0.06000796f, 0.29220727f, -0.27682012f, 
    0.00333044f, 0.27932557f, -0.15264326f, -0.08091480f, -0.00490861f, 0.00220115f, 0.10279469f, -0.21347655f, 
    0.35593662f, 0.10652284f, -0.01088472f, -0.17927518f, -0.03927296f, 0.31239465f, 0.00155505f, 0.02025798f, 
    0.45884871f, -0.10823657f, -0.04445683f, -0.09494872f, -0.06338103f, -0.08580159f, -0.21228185f, -0.16630596f, 
    -0.14421631f, 0.27075759f, -0.06735396f, 0.13667975f, -0.11479811f, 0.11193217f, 0.01648175f, 0.07135196f, 
    -0.14309856f, 0.32037637f, 0.10614241f, -0.30036038f, 0.06409150f, -0.12238764f, -0.10595915f, 0.49158823f, 
    -0.01619071f, 0.07383924f, -0.02067128f, 0.26516023f, -0.00132199f, 0.14826773f, 0.12579691f, 0.08711404f, 
    0.13942365f, -0.40588671f, -0.07695886f, 0.03073686f, 0.06049184f, 0.23640858f, -0.31336042f, 0.10081679f, 
    0.03944942f, 0.06600772f, -0.13172311f, -0.04788846f, -0.00804794f, 0.12180889f, -0.09618042f, 0.07265772f, 
    0.13985340f, 0.01131390f, -0.07951616f, 0.38201493f, 0.14180031f, 0.01717317f, -0.04291262f, -0.02881513f, 
    0.34456369f, 0.06406481f, 0.02323048f, -0.11564539f, -0.16158026f, 0.31638339f, -0.01017432f, 0.30640677f, 
    -0.29856822f, 0.13215829f, 0.09787998f, -0.08318215f, -0.27613133f, 0.23970528f, 0.26018465f, 0.07998227f, 
    0.16876128f, -0.03734472f, -0.01467937f, 0.07584121f, -0.20640874f, 0.14751923f, 0.54989356f, -0.05345785f, 
    0.06049483f, 0.15482762f, 0.00290937f, 0.15281850f, -0.10243994f, -0.28344840f, -0.03579469f, 0.14728610f, 
    0.07659736f, 0.03582200f, -0.07841532f, 0.10812581f, -0.13942724f, -0.00470109f, 0.07594559f, 0.43194625f, 
    -0.17541420f, 0.04905859f, 0.14590657f, 0.10172804f, 0.19888501f, -0.29725853f, 0.37377742f, 0.09329553f, 
    0.17089568f, -0.24323462f, -0.02531071f, -0.06785149f, 0.06155444f, 0.00961974f, -0.07395784f, -0.04761647f, 
    0.09510197f, 0.15319706f, -0.03969057f, 0.14498301f, 0.13950890f, -0.02300195f, 0.01183804f, -0.02856437f, 
    0.31660029f, -0.05170372f, 0.04312891f, 0.04980484f, -0.13596530f, -0.22734071f, 0.13102384f, -0.20160767f, 
    -0.13519388f, -0.00052714f, 0.14819206f, 0.08433658f, -0.08239935f, -0.12915443f, 0.01074840f, -0.00290849f, 
    -0.11433572f, -0.03838915f, 0.16388622f, 0.13621792f, -0.01919887f, 0.10980093f, -0.04922390f, -0.08476488f, 
    0.13797550f, 0.12747250f, -0.08609457f, -0.07584806f, 0.11523695f, -0.13516924f, 0.12972349f, -0.02147723f, 
    -0.00353385f, -0.12814014f, 0.12656026f, -0.12698874f, -0.12443275f, -0.13629077f, -0.06858498f, 0.17503390f, 
    0.23628159f, 0.23475307f, -0.12044666f, 0.03672959f, -0.04434308f, 0.11939327f, -0.15408006f, 0.01669289f, 
    -0.05830112f, -0.15103137f, 0.08611622f, 0.12033633f, 0.31418246f, 0.16820148f, -0.27689099f, -0.00310585f, 
    -0.05166626f, -0.08402976f, 0.01874403f, -0.44597620f, 0.08754190f, 0.17818521f, 0.04476053f, 0.12498712f, 
    0.04916750f, 0.05883290f, 0.09773959f, 0.26357353f, -0.11483694f, -0.34847590f, 0.11303748f, -0.17381012f, 
    0.03781885f, 0.43875808f, -0.11438480f, 0.10482961f, 0.17544320f, 0.22185460f, -0.19762893f, 0.00338780f, 
    0.14509581f, -0.28436607f, -0.13490921f, 0.01339580f, 0.08941255f, 0.05959349f, -0.07887754f, -0.09048766f, 
    0.01799283f, 0.10436651f, 0.12450244f, -0.21087644f, -0.04601267f, -0.16195266f, 0.16903961f, -0.02177121f, 
    -0.51967371f, 0.12358093f, -0.02240908f, -0.05407643f, 0.12636836f, 0.04902302f, 0.13021553f, 0.06175077f, 
    0.01818972f, 0.33309215f, -0.08936431f, -0.03364383f, 0.26245737f, -0.16383529f, 0.17973274f, -0.02995505f, 
    -0.12479595f, -0.12758043f, -0.15100273f, 0.01752119f, -0.21601200f, -0.06859624f, -0.59593207f, -0.36874136f, 
    -0.01993424f, 0.22161207f, -0.02132616f, -0.03645096f, 0.08079713f, 0.19640677f, 0.06743635f, 0.40684482f, 
    -0.03844034f, 0.01848830f, 0.12219752f, 0.14577018f, 0.15423915f, 0.03649192f, -0.11156801f, -0.16483006f, 
    -0.18656196f, -0.15465449f, 0.03092131f, -0.00399043f, 0.17400761f, 0.09758601f, -0.24629429f, -0.14969383f, 
    0.17710821f, 0.18502295f, 0.10589003f, 0.07501948f, 0.11858912f, -0.15180703f, 0.32268324f, -0.31030077f, 
    -0.13004526f, 0.31419316f, 0.07983331f, -0.48423800f, -0.16653199f, -0.00321929f, -0.07644112f, 0.17837015f, 
    -0.24938884f, -0.14185730f, 0.15627462f, -0.07667138f, 0.08907760f, 0.00482980f, -0.11178704f, 0.18431419f, 
    -0.07551607f, -0.08934797f, -0.10831190f, -0.10726029f, -0.05925460f, -0.18622160f, 0.04397288f, -0.10256052f, 
    0.08278427f, 0.14810964f, -0.09755103f, 0.09033471f, 0.22091696f, 0.08788917f, -0.03422478f, -0.28897935f, 
    0.00972009f, -0.02518785f, 0.15978755f, 0.09904999f, -0.08233313f, -0.06467264f, 0.11049160f, -0.16375910f, 
    0.23111705f, 0.12305341f, -0.06845765f, 0.02708316f, 0.06612732f, -0.29132804f, -0.12029515f, 0.03427692f, 
    -0.16119106f, 0.51675093f, -0.06747327f, 0.05140075f, 0.20723632f, 0.17862661f, 0.02122590f, 0.17652524f, 
    -0.12076330f, -0.05646861f, -0.07585970f, 0.14092548f, -0.12177532f, -0.14384688f, 0.36780530f, -0.22847313f, 
    0.05071708f, -0.15653013f, 0.04628571f, -0.25114128f, -0.08698946f, 0.07332300f, 0.04011269f, -0.23740545f, 
    -0.24990647f, 0.16034485f, -0.15763383f, 0.06958392f, -0.12004571f, 0.47736812f, 0.12401586f, 0.01050821f, 
    -0.21733369f, -0.18492673f, -0.12147541f, -0.08974058f, 0.21617517f, -0.20641962f, 0.14688896f, -0.04438300f, 
    -0.09434710f, -0.19311421f, -0.15295061f, -0.10735110f, 0.38563302f, -0.07090255f, 0.04892039f, 0.24322444f, 
    0.13130532f, 0.24752800f, -0.08274297f, -0.46541497f, 0.08328111f, 0.09673323f, -0.02836183f, 0.12613916f, 
    -0.40147451f, -0.01928382f, -0.03909630f, 0.16771598f, -0.02839229f, 0.27503550f, 0.08540170f, 0.43980634f, 
    0.18826032f, 0.15704109f, -0.10986770f, -0.02759829f, -0.07570110f, 0.01186487f, 0.11639249f, -0.03751040f, 
    0.12617576f, 0.22572550f, -0.08254351f, -0.09014815f, 0.26387170f, -0.14391944f, -0.02540198f, 0.21395035f, 
    -0.06832158f, 0.17500655f, -0.01599606f, -0.20499802f, 0.11763600f, 0.31067863f, -0.04884129f, -0.30251360f, 
    0.46848181f, -0.06676953f, 0.00485376f, 0.31325120f, 0.11308820f, -0.35784507f, 0.10163803f, -0.39315769f, 
    -0.07521075f, 0.07236960f, 0.01554264f, -0.08523663f, 0.15718746f, 0.22582144f, -0.02403753f, -0.10439356f, 
    0.11486170f, -0.29155788f, 0.09006180f, -0.15598285f, 0.25172338f, -0.16221987f, -0.10277517f, -0.16120784f, 
    0.12937084f, 0.11263280f, 0.14444584f, -0.26505050f, 0.16374142f, 0.04589526f, -0.16141444f, -0.02570716f, 
    -0.00622494f, 0.00347599f, -0.13232890f, -0.15975286f, 0.05580750f, 0.60420889f, 0.13443175f, -0.02082060f, 
    0.31232870f, -0.02678070f, -0.07756181f, 0.08855255f, 0.08152395f, -0.12184064f, -0.09458729f, 0.08628342f, 
    -0.10182767f, -0.21388279f, -0.04436563f, 0.04371136f, -0.03652018f, -0.04523722f, -0.13306139f, 0.00814338f, 
    -0.09000980f, -0.05677544f, -0.11734620f, 0.11545108f, -0.03722338f, -0.12927061f, -0.01920921f, 0.13884565f, 
    0.10680697f, -0.07040235f, 0.13753672f, 0.26862848f, -0.04637597f, 0.13002877f, -0.11287078f, 0.04269592f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.36249846f, 0.21197775f, 0.02700786f, -0.08883663f, -0.04358567f, -0.22325033f, 0.35713658f, 0.22999790f, 
    0.01991981f, 0.00267363f, -0.01841911f, 0.41141114f, -0.08092259f, 0.11766280f, 0.03192485f, -0.06252271f, 
    -0.19630903f, 0.10608271f, -0.12899707f, -0.26143643f, 0.10053160f, -0.04957122f, 0.03317392f, 0.11007375f, 
    -0.12440363f, 0.23025079f, 0.02011902f, 0.01093095f, 0.13408934f, 0.12598394f, 0.07099805f, -0.19679418f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07940206f, -0.35299873f, -0.02949739f, 0.17547858f, -0.24180219f, 0.18347351f, -0.10300096f, 0.04006835f, 
    -0.36834598f, -0.21454468f, 0.10117620f, 0.05870832f, -0.39452532f, -0.01413247f, -0.49167585f, -0.46154308f, 
    0.00359668f, 0.24542110f, 0.08594298f, 0.33345383f, -0.19171217f, -0.17064317f, -0.40611589f, -0.75850797f, 
    -0.37326115f, 0.20212936f, 0.18829998f, -0.30875430f, 0.29026702f, -0.10872553f, -0.49460381f, 0.17153865f, 
    -0.07642227f, 0.16873179f, -0.25585288f, 0.31073183f, -0.14381164f, 0.14689445f, 0.17999630f, -0.52378410f, 
    0.15257026f, 0.20553577f, 0.01075263f, 0.02316629f, 0.23393674f, 0.02325050f, -0.11654215f, -0.20433034f, 
    -0.44574109f, 0.23605829f, -0.20230319f, -0.07198394f, 0.26996174f, 0.04103974f, 0.21826749f, -0.09695130f, 
    0.16009223f, -0.08512893f, -0.10421275f, -0.74062878f, 0.07520062f, 0.08543539f, -0.36329800f, 0.05309998f, 
    0.19052708f, 0.37859416f, -0.06819569f, 0.13448428f, 0.23082632f, -0.31145191f, 0.03682236f, 0.03986721f, 
    -0.23846589f, 0.03488619f, -0.51459426f, 0.24369474f, -0.40053403f, -0.05140844f, 0.19466749f, -0.33509398f, 
    -0.25649190f, 0.13974522f, -0.06232010f, -0.40749821f, -0.85595226f, -0.14332287f, 0.08043928f, 0.45564136f, 
    -0.03492126f, 0.33588710f, -0.03599057f, -0.10023399f, 0.21157283f, -0.30122161f, 0.17206866f, -0.04633990f, 
    -0.86522442f, 0.19026920f, -0.43833646f, 0.20195682f, -0.32826242f, 0.06475210f, -0.04587184f, 0.49144423f, 
    -0.39125216f, -0.32944822f, -0.38022673f, -0.15295340f, -0.47055489f, -0.11231414f, -0.32451859f, -0.05457598f, 
    0.28296161f, 0.11125363f, -0.23819312f, 0.03132803f, -0.04608344f, -0.02492313f, -0.02793366f, -0.02171176f, 
    -0.28633714f, 0.25332624f, -0.90334308f, 0.28139532f, -0.11281643f, 0.18837325f, 0.14870287f, -0.25114733f, 
    0.18206145f, -0.13857046f, 0.06163003f, 0.08467613f, 0.01203265f, 0.16128160f, 0.14420614f, -0.27407506f, 
    -0.11810607f, -0.33107853f, 0.14737028f, 0.32113853f, 0.17111140f, 0.03537607f, 0.02314062f, 0.07409338f, 
    -0.13963626f, -0.02670523f, 0.11301933f, 0.20666319f, -0.02241183f, 0.10507796f, -0.25352803f, 0.21532297f, 
    -0.13105336f, -0.06798787f, -0.40829566f, 0.35283229f, -0.49400398f, -0.38063625f, 0.07414570f, 0.00170080f, 
    -0.08674731f, -0.44987938f, -0.10233168f, 0.05491162f, -0.18938532f, -0.21488799f, -0.05155496f, 0.12653787f, 
    -0.02464632f, -0.06839115f, 0.28611660f, 0.05095648f, 0.02946943f, -0.05100391f, 0.14835167f, 0.16385193f, 
    0.03546504f, 0.20882714f, 0.31881347f, -0.18190829f, 0.08140124f, -0.03196460f, -0.03896930f, -0.47719449f, 
    0.25555524f, -0.02250034f, 0.11758006f, -0.40994003f, -0.39667758f, -0.16653247f, 0.16260637f, 0.19384961f, 
    0.01058135f, 0.11362910f, 0.02353174f, -0.68242490f, -0.30006465f, -0.53871912f, -0.19817193f, -0.23154753f, 
    -0.03182141f, -0.13510683f, -1.08411765f, 0.11290036f, 0.23856911f, 0.31837037f, 0.07882901f, -0.03896333f, 
    0.02324809f, -0.07998091f, -0.28705117f, -0.48620966f, -0.09223650f, 0.05987014f, -0.07042309f, 0.07232237f, 
    0.28829941f, 0.08978841f, 0.14434831f, 0.10791489f, 0.43436503f, -0.21112388f, 0.31886470f, -0.07746235f, 
    0.07275142f, -0.66434687f, 0.32335550f, -0.43024987f, 0.15672462f, 0.03080735f, -0.09740167f, -0.24432682f, 
    -0.09734417f, 0.18823290f, -0.28638482f, -0.08776860f, 0.12022901f, -0.23344876f, -0.26930493f, -0.09872362f, 
    0.37177435f, -0.29841092f, 0.31227142f, 0.32995695f, -0.15073964f, -0.12046879f, -0.16433938f, -0.22151785f, 
    -0.48485121f, -0.24823782f, -0.55396414f, -0.28444579f, 0.21109281f, -0.17712890f, 0.27827743f, 0.15690079f, 
    -0.35567892f, -0.28847873f, -0.05841812f, -0.62895066f, -0.48126417f, -0.11833034f, -0.10761596f, 0.43477046f, 
    -0.02398180f, 0.16666831f, -0.48341241f, -0.21983805f, -0.13505721f, -0.47967172f, 0.11648466f, 0.26628265f, 
    -0.08489993f, -0.32596114f, 0.34893641f, -0.64392537f, -0.36485562f, -0.05924927f, 0.05123992f, -0.20987946f, 
    -0.44662598f, 0.07992066f, 0.22252889f, -0.40662414f, -0.08491853f, 0.30891833f, 0.09458168f, -0.28795826f, 
    -0.09080346f, 0.10173036f, 0.08351936f, -0.09724499f, -0.09735255f, -0.41016728f, 0.29252869f, -0.47821355f, 
    -0.21588740f, 0.07650708f, 0.14213517f, -0.25746274f, -0.01822824f, 0.25116512f, 0.11750638f, 0.16729207f, 
    0.03651788f, -0.21105444f, -0.01937786f, 0.13918032f, -0.25146213f, 0.05349222f, -0.47658712f, 0.09786995f, 
    0.22028437f, 0.11133046f, -0.65152830f, 0.14816017f, 0.16499127f, -0.56911093f, 0.07657374f, -0.28018588f, 
    -0.29681790f, -0.26416558f, -0.22186765f, -0.38310677f, -0.28222805f, 0.24188294f, -0.61076456f, 0.18656863f, 
    0.16053778f, -0.34655857f, -0.29878277f, -0.30325931f, -0.14017944f, -0.36617565f, 0.10761882f, -0.34471244f, 
    -0.42871764f, 0.27913320f, -0.10817511f, -0.38950661f, -0.36359748f, 0.00074306f, 0.16984871f, 0.24110262f, 
    0.08913160f, -0.67237854f, -0.09577810f, 0.33539855f, -0.02325204f, 0.00613296f, 0.13256510f, 0.39474204f, 
    -0.38336939f, 0.13910045f, -0.25193843f, -0.07245500f, -0.06442600f, -0.14890580f, -0.37873957f, 0.11280558f, 
    0.29279062f, 0.13017060f, -0.21689691f, -0.25269860f, -0.09440667f, 0.10309485f, 0.17610291f, -0.18555145f, 
    0.20933984f, -0.70489365f, -0.25685471f, 0.03657606f, 0.16640985f, 0.04433097f, 0.00292465f, 0.04691198f, 
    0.22371930f, -0.44724405f, -0.31902114f, 0.02526130f, -0.43778947f, 0.15964237f, 0.03214289f, -0.29257110f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12913911f, 0.19623438f, 0.15464211f, -0.27947512f, 0.07374317f, 0.18300612f, -0.19610126f, -0.18114637f, 
    0.24667569f, 0.15018581f, -0.00311011f, 0.07305987f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
