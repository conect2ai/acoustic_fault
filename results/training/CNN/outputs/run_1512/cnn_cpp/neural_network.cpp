#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.18514562f, 0.91088045f, -0.46322873f, 0.86797297f, 0.55200195f, 0.77669775f, 0.27929088f, -0.34465793f, 
    0.97198278f, -1.07903707f, -0.44461140f, -0.25000638f, -0.71530986f, -0.87658298f, -0.69616270f, -0.43193117f, 
    0.52357215f, -0.20100766f, -1.16724312f, -1.48742187f, -0.29625368f, 1.25378120f, 0.60311657f, 0.20519684f, 
    -0.11241777f, -0.11256091f, 0.17389286f, 0.96494782f, 1.04787564f, 0.74188751f, -0.04938219f, -1.51025867f, 
    -0.97953337f, 0.20151542f, 0.37512136f, 0.37118733f, 0.84360421f, 0.43324119f, -1.41203201f, -1.01606739f, 
    0.10522367f, -0.28936705f, 0.39081854f, 0.69820583f, 0.94824451f, 2.10931253f, -1.52767265f, -0.12164082f, 
    0.07495224f, 0.54503453f, 0.15615995f, -0.26143458f, -0.17003661f, -0.13004123f, -1.29359257f, 0.57724696f, 
    0.41643611f, -1.25812542f, -0.35014603f, 1.57897580f, 0.24986824f, 0.41035414f, 0.23538686f, -1.65619755f, 
    -0.95168942f, -1.27660108f, -0.34066343f, 0.63916290f, -0.03169648f, 0.33953559f, 0.80146211f, -0.08394498f, 
    0.28456354f, -0.11179733f, -0.54568172f, 0.75548786f, 0.42921928f, 0.41094688f, 0.69869483f, 0.66016573f, 
    0.53312093f, -0.20324168f, -1.23932922f, -1.02234709f, -0.64545274f, -0.22868228f, 0.14084290f, 0.00078699f, 
    -0.45426387f, -0.84235108f, -0.71520954f, -0.04606676f, 0.77741033f, 0.89256805f, 0.27208748f, 0.57345885f, 
    -0.09040771f, -1.05619049f, -0.82807112f, -1.71997690f, 2.08048511f, -0.99755579f, -0.92168516f, -0.65111083f, 
    -0.31170949f, -0.08549099f, -0.18242654f, -0.33979356f, 0.06640888f, 0.47892022f, 0.84723663f, 1.07570088f, 
    -1.13505471f, -0.92523950f, -0.33986318f, -0.28644967f, -0.64765465f, -0.21610132f, -0.67916632f, -0.30525523f, 
    -1.41537404f, -1.13144183f, -1.24694109f, 0.87182450f, 0.04663417f, 0.69368547f, -1.37345552f, -0.71326298f, 
    -0.61632007f, 0.80409098f, 1.27267015f, -0.94394308f, -0.61737317f, -0.68229669f, -0.29773471f, 0.83316076f, 
    -0.36155167f, 0.68866533f, 0.11964934f, 0.48372656f, -0.50185102f, -0.40566418f, 0.17715308f, 0.72056264f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27643105f, -0.97287321f, 0.63437158f, 0.41194579f, 0.82113945f, 0.33082372f, 0.00561003f, 0.72349006f, 
    -0.29925421f, 0.99071103f, 0.50465459f, 0.70985419f, -0.04596275f, 0.02792326f, 0.01374934f, 1.01123977f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.44338065f, -0.02200353f, 0.34812167f, 0.20548216f, -0.18348102f, -0.26074362f, 0.09354831f, 0.08089460f, 
    0.22008757f, 0.52111834f, 0.52169365f, 0.65958315f, -0.15512376f, -0.05171698f, -0.06676017f, 0.17427804f, 
    0.25377151f, -0.03229788f, 0.41918558f, 0.16795884f, 0.01280411f, 0.02942259f, -0.32307982f, 0.22111021f, 
    -0.04793924f, 0.02007383f, 0.00383605f, -0.30390373f, -0.17965716f, 0.31843483f, 0.19693458f, 0.04090267f, 
    -0.34950465f, 0.21274276f, 0.04345328f, -0.19958009f, 0.34215367f, 0.34494203f, -0.85277748f, -0.17823078f, 
    0.15761435f, 0.06965679f, 0.24903028f, 0.06169781f, 0.19606987f, -0.45434171f, -0.03927489f, -0.88299215f, 
    -0.05841145f, -0.07078297f, 0.04359303f, 0.12658791f, 0.06640584f, -0.12213974f, 0.14874251f, -0.70674491f, 
    0.56899440f, -0.12227397f, 0.05284689f, -0.38826266f, -0.07238317f, -0.16874057f, 0.09428418f, -0.03535680f, 
    0.38062924f, -0.00174005f, -0.02784414f, 0.08884859f, 0.00115588f, 0.06997576f, -0.01582715f, 0.07649632f, 
    0.25803962f, 0.13528530f, 0.03387713f, 0.09338760f, 0.22480012f, 0.09282660f, 0.31370458f, 0.32614318f, 
    0.30861315f, 0.04006777f, 0.27857903f, -0.12177867f, -0.20711289f, 0.05328332f, 0.03469680f, -0.07024434f, 
    -0.07908542f, -0.12114548f, 0.21163955f, 0.03079036f, 0.25431672f, 0.10873643f, -0.14695074f, 0.35850555f, 
    -0.16110407f, -0.05263461f, 0.02954195f, -0.09050342f, 0.24935828f, 0.12726527f, -0.22285107f, 0.14424649f, 
    -0.00637395f, -0.12454157f, 0.21689248f, -0.14698671f, -0.60488260f, 0.23614100f, 0.15957786f, -0.10238952f, 
    0.05077166f, -0.20954917f, 0.07363811f, -0.32716349f, -0.03934455f, 0.53678328f, 0.44558245f, 0.31759807f, 
    -0.10529992f, 0.04721099f, -0.10537909f, 0.09381954f, -0.01978933f, 0.00022032f, 0.39384964f, 0.29997084f, 
    -0.23419616f, -0.08949908f, -0.21879168f, 0.29512751f, -0.12678237f, 0.05021532f, -0.33115968f, -0.13166983f, 
    -0.03171897f, -0.36944032f, 0.06107941f, -0.06668027f, -0.27092129f, 0.40175927f, -0.13500950f, -0.14363298f, 
    -0.12087157f, 0.18265396f, 0.02713970f, -0.12203167f, 0.05117653f, -0.18826421f, -0.06889388f, 0.04278618f, 
    -0.05732530f, -0.34784225f, -0.32468784f, 0.05695791f, -0.36827460f, -0.25219283f, -0.10881016f, 0.05112378f, 
    0.18399760f, 0.21339399f, 0.44835246f, -0.06891645f, -0.42964450f, -0.21222533f, -0.11455692f, -0.51991093f, 
    0.01584624f, -0.15969795f, 0.17529152f, -0.07060787f, 0.18666059f, -0.45342296f, 0.04110738f, 0.05547581f, 
    0.12653397f, -0.15898979f, 0.10013671f, -0.00897859f, -0.02084565f, 0.47036186f, 0.37732449f, 0.36175817f, 
    -0.08711977f, 0.35798201f, -0.01158857f, 0.04239121f, 0.10525278f, 0.26022044f, -0.70455045f, 0.23991212f, 
    -0.11358856f, -0.22961569f, -0.16116667f, 0.07720243f, -0.02128598f, 0.19770592f, -0.95465744f, -0.04604595f, 
    -0.25697178f, -0.04355485f, -0.12973654f, -0.12726244f, 0.25535494f, 0.14119646f, -0.04976860f, -0.40845352f, 
    -0.21530518f, 0.37153473f, 0.24087813f, -0.00830281f, -0.08762311f, 0.09465505f, -0.07526229f, 0.10368001f, 
    0.15458798f, -0.16140567f, 0.01069995f, 0.15803272f, -0.11462771f, -0.41750783f, -0.06732382f, -0.00708208f, 
    0.03000664f, 0.28512844f, -0.18313697f, 0.17411351f, 0.06554980f, -0.20466898f, 0.13580151f, 0.05020067f, 
    0.18558206f, -0.05003946f, -0.29288492f, 0.16302308f, 0.03043421f, -0.14834042f, 0.05771471f, -0.20277455f, 
    0.19450338f, 0.08557590f, 0.20767581f, -0.39880675f, 0.49266636f, -0.72068316f, 0.22551611f, 0.27640331f, 
    0.11150731f, -0.06711550f, 0.14392780f, -0.04985193f, -0.43024385f, -0.38700563f, 0.04575251f, -0.00348073f, 
    0.12952048f, 0.06788073f, -0.09289299f, -0.19316815f, -0.05880619f, 0.29737276f, 0.00770524f, 0.07210453f, 
    -0.21125041f, -0.32259434f, 0.05221179f, -0.09576876f, -0.16425073f, 0.06210047f, 0.18749645f, 0.01295039f, 
    -0.54302543f, -0.00330275f, 0.07319698f, -0.50477332f, 0.15246639f, 0.10536521f, 0.00278213f, -0.27351856f, 
    -0.23324861f, 0.38952541f, 0.15184015f, 0.15246125f, 0.20841819f, 0.46516463f, 0.09494782f, 0.19194762f, 
    -1.32518697f, -0.50095564f, -0.34781048f, 0.22571349f, -0.27855137f, -0.00495290f, -0.15725510f, 0.18926597f, 
    0.37227273f, -0.22136232f, -0.25269741f, 0.38147953f, 0.02503986f, 0.27280748f, -0.12855892f, 0.09568965f, 
    -0.27345166f, -0.03225926f, 0.22585797f, -0.04444133f, -0.08039784f, 0.20949893f, -0.05205089f, 0.31009474f, 
    0.10689723f, 0.14418794f, 0.29420409f, -0.24024855f, -0.82294357f, -0.26466715f, -0.35082957f, -0.27042350f, 
    -0.23211440f, 0.00973914f, -0.02915495f, 0.17581420f, 0.29406789f, 0.19319713f, -0.27869418f, -0.05885110f, 
    -0.22548148f, 0.07339358f, -0.12581553f, 0.04312840f, 0.02865295f, 1.16328812f, 0.20274980f, -0.67544663f, 
    -0.07281518f, -0.04924892f, -0.13400128f, 0.06435461f, 0.14827891f, 0.27948147f, -0.11566629f, -1.09929860f, 
    -0.53035909f, -0.12256730f, -0.06016461f, -0.28190926f, 0.06998765f, 0.04534674f, -0.05530550f, 0.11456408f, 
    0.01971832f, 0.00332871f, 0.01179365f, 0.08726818f, 0.27278858f, 0.15539020f, -0.12618229f, -0.03797722f, 
    -0.18966042f, 0.10760764f, -0.34635025f, 0.07094806f, -0.10321001f, 0.05191169f, 0.02035440f, 0.21823131f, 
    -0.23386276f, 0.35446531f, 0.31146923f, 0.34324440f, 0.11602013f, 0.04841416f, 0.17524773f, 0.25614718f, 
    0.16683012f, -0.07260484f, -0.00540825f, 0.05330864f, -0.08383559f, 0.05680032f, -0.04642384f, -0.18506470f, 
    0.03307520f, -0.05269128f, -0.16689205f, -0.67185158f, 0.57613212f, 0.13529177f, 0.08950794f, -0.38735053f, 
    -0.32207313f, -0.08648475f, 0.10180736f, -0.29694703f, -0.49501455f, -0.03166666f, -0.55170768f, -0.25075167f, 
    0.09518853f, -0.14547405f, -0.00487607f, 0.20069441f, 0.01996370f, 0.36824474f, 0.26516801f, 0.22050652f, 
    -0.01721164f, -0.14803118f, -0.13754743f, -0.04739651f, -0.06800366f, 0.14531019f, 0.44163394f, 0.22688828f, 
    0.39096296f, 0.21408242f, -0.00668643f, -0.01273375f, 0.26448533f, 0.21792510f, -0.15085502f, -0.29450285f, 
    -0.01819735f, -0.56999815f, 0.02953266f, 0.15343548f, 0.18718761f, 0.10602140f, -0.10309280f, 0.11026811f, 
    -0.13861196f, 0.06767645f, -0.32076764f, 0.12314530f, 0.07818379f, 0.41080457f, 0.05911452f, 0.18273981f, 
    0.13425009f, 0.10895870f, -0.60504425f, 0.00107720f, -0.35429776f, 0.08067508f, -0.39148489f, 0.02866680f, 
    -0.15157861f, 0.01876053f, 0.13244556f, -0.33056045f, 0.05532093f, 0.18280038f, 0.05257735f, 0.04042350f, 
    -0.03401417f, -0.17185332f, -0.11643246f, -0.54387552f, 0.17798434f, 0.15013674f, -0.00027979f, 0.05229114f, 
    -0.33359140f, 0.27318287f, 0.14167126f, 0.16124754f, -0.31564751f, 0.06949169f, 0.26621130f, 0.10861260f, 
    0.11153428f, 0.20770718f, 0.20929894f, 0.00946912f, 0.20340011f, 0.01973524f, -0.70615852f, 0.15601572f, 
    -0.21778545f, 0.05922273f, 0.73514730f, -0.11741989f, -0.30912828f, 0.17091097f, -0.08374795f, 0.66773230f, 
    -0.65625310f, 0.11771653f, -0.28313866f, -0.01613040f, 0.19805898f, 0.20215261f, 0.24276173f, 0.08198270f, 
    0.02519391f, 0.27336162f, 0.10140328f, 0.07001131f, -0.01250710f, 0.06834057f, 0.04937707f, -0.06322738f, 
    -0.28208995f, -0.31209946f, -0.20635132f, -0.16536933f, -0.07352208f, -0.05490344f, 0.11385576f, 0.06045186f, 
    0.05456599f, 0.26680103f, 0.25911671f, 0.06202228f, 0.08365696f, 0.02085940f, 0.35166007f, -0.03681435f, 
    0.14756154f, 0.33210182f, -0.07391258f, -0.33458170f, -0.02413199f, 0.13695562f, 0.23314942f, -0.30999511f, 
    0.03180703f, -0.19852874f, 0.12900785f, -0.18453863f, -0.29670545f, -0.25388941f, -0.41167137f, 0.15741506f, 
    0.36009371f, -0.07948883f, 0.02802744f, -0.07445167f, -0.25335330f, 0.48580536f, 0.41311362f, -0.11014863f, 
    -0.06494661f, -0.30829564f, -0.04430226f, -0.08113592f, -0.00308642f, -0.72931695f, -0.51688725f, 0.31939748f, 
    -0.23113817f, 0.11666579f, -0.41693413f, -0.01514665f, -0.11575294f, 0.09503943f, 0.08534595f, -0.36444741f, 
    0.51981521f, 0.10280559f, -0.06390775f, -0.56808138f, -0.01558765f, -0.00736568f, 0.09106789f, 0.28819233f, 
    0.33272293f, 0.04457336f, -0.00552067f, 0.26247975f, 0.20855768f, 0.36021066f, 0.08181471f, 0.26825881f, 
    0.02154681f, 0.07333191f, -0.04830987f, 0.01307444f, 0.00812836f, -0.00899774f, -0.08581725f, -0.07246631f, 
    0.00458741f, 0.01643565f, 0.02561688f, -0.02932107f, -0.02183063f, -0.08926114f, 0.02899116f, -0.04756068f, 
    0.08145089f, -0.06679602f, -0.03915107f, 0.02670595f, -0.08138353f, -0.07647790f, -0.00443013f, -0.04126560f, 
    0.00317428f, -0.07529228f, -0.07909090f, -0.05221301f, -0.07707606f, -0.08510748f, -0.00352533f, -0.00898175f, 
    0.03115019f, -0.03495910f, -0.04509324f, -0.04705224f, 0.06253221f, -0.06104155f, -0.03041230f, -0.05814318f, 
    0.05693553f, -0.00590929f, -0.05748457f, -0.01827472f, -0.00384098f, 0.02106551f, -0.09134023f, 0.00031307f, 
    0.02440632f, 0.00911750f, -0.01756387f, -0.10128114f, -0.01856214f, 0.03175449f, -0.02881310f, 0.01785823f, 
    -0.05461311f, -0.04248138f, -0.08129024f, 0.05299893f, -0.03106421f, 0.05284923f, 0.05784989f, 0.03215277f, 
    -0.05644524f, 0.03864632f, -0.05370833f, 0.02135479f, 0.01550780f, -0.01385841f, -0.06724609f, -0.04621646f, 
    0.05762452f, 0.00067338f, 0.03445195f, -0.03350793f, -0.06462887f, -0.04628832f, 0.03961043f, 0.04797491f, 
    -0.00674783f, 0.00137838f, -0.03122836f, 0.04160669f, 0.04446409f, 0.05541592f, 0.00812075f, 0.06577582f, 
    -0.00663374f, -0.08500689f, 0.04322883f, -0.06078001f, -0.04948736f, -0.00866226f, -0.03002138f, -0.04491238f, 
    -0.06711198f, 0.01510143f, -0.04436400f, -0.02955313f, -0.08418445f, -0.04611420f, -0.01851156f, -0.01736594f, 
    0.04997402f, 0.06827936f, 0.02165600f, 0.00786940f, -0.00097268f, -0.06653354f, 0.04176877f, -0.02611606f, 
    0.02682442f, 0.01158078f, -0.03086656f, 0.02430333f, -0.03420375f, -0.01681600f, 0.00253820f, -0.06184933f, 
    0.02005224f, -0.03147545f, -0.07935832f, -0.05348052f, -0.05452358f, -0.09249700f, 0.06014752f, 0.02965585f, 
    -0.02846315f, -0.06880686f, -0.00812411f, 0.03080229f, 0.03484756f, -0.04876814f, -0.07852927f, -0.02766620f, 
    -0.01970914f, -0.05437425f, -0.07842826f, 0.07283688f, -0.07053395f, -0.04374234f, 0.03337036f, -0.02779644f, 
    0.31775412f, 0.30431202f, -0.36856824f, -0.18036079f, 0.12578352f, 0.11173455f, 0.01707620f, -0.21736647f, 
    -0.17545362f, 1.19494593f, 0.60314399f, 0.82026225f, -0.12506661f, -0.11193413f, -0.08101863f, 0.09477933f, 
    0.02323348f, 0.15370177f, 0.25449052f, -0.01858941f, -0.75319880f, -0.39955664f, 0.07168107f, -0.22111139f, 
    0.12132932f, -0.06831556f, 0.01515192f, -0.69138664f, -0.56466007f, 0.44743675f, -0.02601534f, 0.01434843f, 
    0.07156347f, 0.14028622f, -0.16081256f, 0.21707673f, -0.25312769f, -0.27808949f, 0.24926497f, 0.21810845f, 
    0.03796311f, 0.43421438f, 0.10681131f, -0.16924119f, 0.17339534f, 0.47696307f, -0.00596743f, 0.15103096f, 
    -0.06130233f, 0.12646908f, 0.44051176f, 0.02293343f, 0.21265177f, 0.15726788f, 0.15109839f, 0.05911920f, 
    0.20446377f, 0.05787993f, 0.12751575f, -0.14918581f, -0.00897438f, -0.06902473f, -0.08404828f, 0.52868497f, 
    0.29823118f, -0.36831936f, 0.01539097f, -0.00288017f, 0.01399266f, 0.18430983f, -0.02641816f, -0.00130254f, 
    0.23774438f, -0.00750724f, -0.32591388f, 0.05970582f, -0.05708501f, 0.01371686f, 0.19526990f, -0.07427139f, 
    0.02805543f, -0.28262377f, -0.12997529f, -0.72208697f, -0.00596475f, 0.09097209f, -0.00772917f, -0.17263843f, 
    0.10686441f, -0.09314686f, 0.14458118f, -0.09351851f, 0.02991345f, 0.17332259f, 0.06274989f, -0.44820061f, 
    0.07164577f, 0.20052966f, 0.29340932f, -0.35561031f, -0.81297630f, -0.38115984f, -0.03447492f, 0.16119425f, 
    0.26253384f, -0.02581231f, -0.04578115f, -0.10213827f, -0.07240943f, -0.16469143f, -0.10257462f, -0.08479875f, 
    0.07306144f, -0.07236627f, -0.13602038f, -0.08150844f, -0.16152725f, -0.40308905f, 0.03843779f, -0.38769999f, 
    -0.16496928f, 0.03636952f, 0.18039617f, 0.01725626f, -0.16529085f, -0.08959803f, 0.28114212f, 0.08418191f, 
    0.09312816f, 0.02703690f, 0.01269766f, -0.09883178f, -0.06192306f, 0.07022175f, 0.13440125f, 0.11582265f, 
    0.19111298f, 0.23115690f, -0.03378792f, -0.05473726f, 0.12722594f, 0.39641407f, 0.22515544f, -0.00553986f, 
    0.29540217f, -0.00592482f, -0.19643310f, -0.15740699f, -0.40887991f, -0.03218768f, 0.24665114f, 0.19669344f, 
    -0.00739899f, -0.50483686f, 0.32046154f, -0.66712219f, -0.29216570f, -0.10823745f, -0.15258700f, -0.10591730f, 
    -0.17744470f, -0.12767871f, -0.43822420f, 0.21961905f, 0.59158170f, -0.04914147f, 0.07668234f, 0.15445624f, 
    0.20284641f, -0.00140713f, 0.15901200f, 0.24128182f, -0.20134239f, 0.04254486f, 0.16815799f, -0.01919166f, 
    0.00194024f, -0.07661569f, -0.27657720f, 0.17928867f, 0.18063988f, 0.22598775f, -0.47007519f, 0.23930296f, 
    0.19333813f, 0.21501085f, 0.07718062f, -0.12996498f, -0.07629841f, -0.07997932f, 0.12751500f, -0.10085301f, 
    -0.23711634f, 0.07323571f, 0.06888835f, 0.01736157f, 0.21735641f, 0.19183666f, 0.21547970f, -0.37283620f, 
    -0.08049840f, 0.07207604f, 0.01765962f, 0.31203538f, -0.32825038f, 0.20862079f, -0.21293487f, -0.40170830f, 
    0.36458454f, 0.82514799f, -0.00914221f, -0.02272002f, -0.04187789f, 0.15402803f, 0.07741648f, 0.08641009f, 
    0.23083587f, -0.01267683f, -0.08435292f, -0.01855373f, -0.08302140f, 0.23619634f, 0.14225994f, 0.01172509f, 
    0.12965326f, -0.15565681f, 0.20638633f, 0.25533012f, -0.00913743f, 0.09186431f, 0.06823801f, 0.11201163f, 
    0.12857448f, 0.06109213f, 0.20652017f, -0.02810002f, 0.15942718f, -0.33831981f, -0.30170691f, -0.01967955f, 
    0.04613537f, 0.09922516f, 0.44105092f, 0.20475073f, -0.63431162f, -0.39875981f, -0.08373194f, -0.10155284f, 
    -0.23086986f, -0.18847182f, -0.11699678f, 0.36652499f, 0.29951918f, -0.01733314f, 0.06219511f, 0.05660100f, 
    -0.08471154f, -0.16104013f, -0.17605892f, 0.13471647f, 0.09499414f, -0.21908669f, 0.05741401f, -0.58315063f, 
    -0.06696099f, -0.08124468f, 0.14130649f, 0.00795691f, 0.03374958f, -0.48784119f, -1.02860367f, -0.18037276f, 
    0.03035374f, -0.05567671f, -0.13923112f, -0.16160856f, 0.04585147f, 0.00714382f, -0.13203850f, 0.22836865f, 
    0.15402545f, 0.03219102f, 0.19140603f, 0.07607942f, 0.04333922f, -0.24870726f, 0.30339149f, 0.09138448f, 
    0.29253188f, -0.50784296f, -0.27171043f, -0.16232795f, 0.35193768f, -0.05218855f, 0.05176906f, -0.11059400f, 
    0.19312079f, 0.21584201f, 0.15172970f, -0.21947679f, -0.27392995f, -0.31545261f, -0.49816617f, 0.05529474f, 
    -0.11449724f, -0.12234223f, 0.49665204f, -0.41965136f, -0.36470097f, 0.01535972f, 0.29661122f, 0.34258235f, 
    0.17508209f, -0.08117981f, -0.01330692f, -0.99315256f, -0.00847253f, 0.23911867f, -0.12886429f, -0.36627170f, 
    -0.05519618f, 0.07977404f, 0.06931125f, -0.02142740f, -0.57580376f, -0.12542342f, -0.19659661f, -0.01187176f, 
    -0.17727299f, 0.23577195f, -0.09366261f, 0.06109970f, 0.09718215f, -0.22079581f, -0.20990664f, -0.21892294f, 
    -0.07193916f, 0.44414598f, -0.00743567f, 0.24142496f, 0.24430300f, -0.10641964f, 0.57316959f, -0.05463375f, 
    -0.18965572f, -0.43741256f, -0.07104366f, -0.21347323f, 0.25177824f, -0.04288075f, -0.11683113f, 0.62069470f, 
    -0.36232138f, -0.24499536f, -0.05558539f, 0.08461421f, 0.19673653f, 0.19191156f, -0.03916102f, 0.00226070f, 
    -0.26015118f, -0.02609599f, 0.10311665f, -0.15154381f, -0.42922580f, 0.08504593f, 0.09130499f, 0.20640391f, 
    0.07376141f, 0.36858997f, -0.40438733f, -0.51097834f, 0.08441275f, 0.06158942f, 0.39722115f, 0.06494709f, 
    0.24792434f, 0.02355204f, 0.07038196f, 0.05257677f, 0.13141420f, -0.07286102f, -0.21228001f, -0.07638396f, 
    0.18179373f, 0.13977733f, 0.00714529f, 0.52599561f, -0.17502131f, -0.11957455f, 0.05232223f, 0.17140958f, 
    -0.00584052f, 0.04859563f, 0.21956448f, 0.24100670f, -0.58278620f, 0.39162216f, 0.00879747f, 0.01115246f, 
    -0.15763514f, -0.15921979f, 0.28551963f, 0.07001784f, -0.08230557f, 0.10368308f, -0.18018581f, -0.14013778f, 
    -0.08222380f, -0.09281966f, -0.13548681f, -0.15057428f, 0.03658802f, 0.16432811f, 0.37650657f, -0.04990687f, 
    -0.37594938f, -0.13110632f, -0.09148573f, 0.09403824f, -0.03641763f, 0.05329225f, -0.06272998f, 0.12146336f, 
    0.12858945f, -0.02085779f, 0.06740836f, -0.01553791f, 0.05455540f, 0.09569799f, 0.03680167f, 0.03271653f, 
    0.06266232f, 0.01482160f, -0.06663630f, -0.00267934f, 0.04832028f, -0.00976485f, 0.01407124f, -0.04775178f, 
    0.00028126f, -0.05172998f, 0.07101536f, 0.04370268f, 0.00153637f, -0.08365408f, 0.02130895f, 0.02401456f, 
    -0.01306937f, -0.03998266f, 0.03613783f, -0.07399230f, -0.05958469f, -0.08739169f, -0.06195285f, 0.01608085f, 
    -0.02817900f, -0.03356194f, 0.00792839f, 0.02574361f, 0.05666313f, 0.03345180f, -0.08843047f, 0.02087970f, 
    0.02566050f, -0.00933267f, -0.06064983f, -0.01854480f, -0.00691121f, -0.01764077f, 0.00686300f, 0.00317473f, 
    0.02716382f, -0.03605792f, 0.05502413f, -0.04722730f, 0.01634122f, -0.00526644f, 0.06574010f, 0.03146268f, 
    0.07362030f, -0.04256655f, 0.01784777f, -0.05612806f, -0.07332581f, -0.05961805f, -0.07149459f, 0.01976296f, 
    -0.07437580f, 0.03963317f, -0.02564335f, -0.00102839f, -0.02485410f, -0.05473603f, 0.07813504f, -0.06410877f, 
    0.04585868f, 0.05789798f, -0.04767045f, -0.01646224f, -0.01684617f, -0.03194105f, 0.02703166f, -0.06737946f, 
    0.01668163f, 0.04410885f, -0.06256696f, 0.06786748f, -0.09014224f, -0.02617556f, -0.03552780f, -0.06312177f, 
    0.00393883f, -0.05596425f, 0.04308172f, 0.05315612f, 0.04554277f, 0.00126265f, -0.00258597f, -0.05171388f, 
    -0.03554332f, 0.04663547f, -0.07737717f, -0.06650548f, -0.06580927f, 0.02431764f, 0.04143512f, -0.07379596f, 
    -0.04224253f, 0.05919249f, -0.02505942f, 0.06197133f, 0.00777156f, -0.08070637f, 0.06220505f, -0.01745038f, 
    0.06224061f, -0.00450068f, 0.01955148f, -0.07492230f, -0.01743855f, 0.07730388f, 0.06786941f, -0.03327743f, 
    -0.07229684f, 0.00441817f, 0.01114411f, -0.08771187f, 0.05224400f, -0.03992331f, 0.03953461f, -0.08959284f, 
    -0.07830213f, 0.02219456f, -0.08744142f, 0.07317538f, 0.05629789f, 0.05494922f, 0.06418005f, -0.00979718f, 
    -0.07782311f, -0.07385521f, -0.07290051f, 0.04789298f, 0.01540760f, -0.07053536f, 0.00375530f, -0.08247490f, 
    -0.06543523f, -0.04101968f, -0.02757532f, 0.03262941f, 0.03127772f, 0.02224933f, -0.03869148f, 0.06487815f, 
    -0.42907602f, 0.20291074f, 0.13646419f, 0.11059044f, 0.05646216f, 0.01535707f, -0.03382149f, -0.17629826f, 
    -0.10639925f, -0.67037135f, 0.35499454f, -0.28060189f, 0.08237924f, -0.61553985f, -0.72683454f, -0.22385219f, 
    -0.09673285f, -0.25190729f, -0.17910767f, 0.53630871f, 0.44028196f, 0.14227827f, 0.15665890f, 0.20705436f, 
    0.08352599f, 0.14689167f, 0.32814944f, 0.43308142f, -0.46772662f, -0.11281607f, -0.12043685f, -0.10210486f, 
    -0.25448751f, 0.14599955f, -0.04849328f, -0.04757216f, 0.72846365f, 0.00930390f, -0.20922618f, 0.00219213f, 
    0.03588233f, -0.19228157f, 0.03595847f, -0.06009712f, -0.24641089f, -0.03293726f, 0.03257215f, -0.16306581f, 
    -0.26477218f, -0.08642953f, -0.07588749f, 0.34426531f, -0.21495587f, 0.51852810f, -0.49970976f, -0.54984915f, 
    -0.40603480f, -0.46426988f, -0.08628871f, -0.20172673f, 0.36777398f, -0.03858119f, -0.04017058f, -0.72321832f, 
    0.42686656f, 0.92486435f, 0.13276654f, 0.17432623f, -0.18900940f, -0.13820668f, 0.26066214f, 0.04828704f, 
    0.04567222f, 0.12807611f, -0.31302100f, -0.09818871f, -0.06695267f, -0.14207719f, -0.15602581f, 0.05907067f, 
    -0.00507402f, 0.16849250f, -0.12573987f, 0.41496959f, 0.18017183f, 0.40245458f, 0.29069790f, 0.14354295f, 
    0.22055434f, 0.24703693f, 0.25939330f, 0.32865629f, 0.08793812f, -0.10594808f, -0.12867033f, -0.06631317f, 
    0.15241122f, 0.24200457f, 0.42762381f, -0.78794611f, -0.49549899f, -0.78304708f, 0.21316268f, -0.10673793f, 
    0.39568231f, 0.10737790f, 0.00499353f, 0.03869584f, -1.04895437f, -0.34898037f, -0.33317199f, 0.13694511f, 
    0.17591470f, -0.15881774f, 0.13362019f, 0.05695078f, 0.05577464f, -0.71886522f, -0.75628483f, -0.94995141f, 
    -0.14017449f, -0.32858232f, -0.30816221f, -0.01755883f, -0.09731115f, -0.07750681f, -0.42405033f, -0.22095710f, 
    0.30415225f, -0.25779322f, -0.14904879f, -0.29079038f, 0.06784449f, 0.14798635f, 0.29238722f, 0.12509245f, 
    -0.06578932f, 0.09852121f, 0.08269671f, 0.23391712f, 0.14938818f, 0.37036741f, -0.00151832f, 0.20567237f, 
    0.01617101f, -0.16305803f, -0.26412833f, 0.00830442f, -0.17529732f, 0.00604564f, 0.16028368f, 0.00414629f, 
    -0.23584189f, 0.39012426f, 0.58918911f, 0.27264017f, -0.14748254f, 0.04336402f, -0.39683026f, 0.03615284f, 
    -0.19143875f, 0.15973260f, -0.10446633f, -0.43181270f, -0.41904345f, -0.01883898f, -0.16942488f, 0.03294185f, 
    -0.02489199f, -0.18073320f, 0.09995464f, 0.77098823f, 0.63997614f, 0.38348910f, -0.10299776f, -0.12659955f, 
    -0.05478369f, -0.03482815f, 0.10345927f, 0.13702355f, -0.09187131f, -0.10592958f, -0.12817925f, 0.11973947f, 
    0.24677166f, 0.21319631f, 0.11573151f, 0.25916308f, -0.02728335f, 0.41162425f, -0.10234111f, 0.10995882f, 
    -0.07081929f, 0.38974902f, -0.14566784f, -0.19512120f, -0.07647681f, -0.11424459f, -0.03144129f, -0.26072952f, 
    0.05456863f, 0.06836775f, 0.08491782f, -0.20670615f, 0.12700479f, -0.07852937f, 0.10853182f, 0.07351097f, 
    -0.11160628f, -0.40891340f, -0.04776555f, 0.18780346f, 0.19010334f, 0.01629298f, -0.06782048f, 0.05109551f, 
    -0.18680212f, -0.00808744f, -0.03600399f, -0.14793877f, -0.06187369f, -0.02179239f, 0.17415494f, -0.04906162f, 
    0.04394151f, 0.40960178f, -0.21924329f, -0.31063828f, 0.04562997f, -0.02317638f, 0.18244982f, 0.04240339f, 
    -0.09740897f, 0.04503338f, -0.41103330f, -0.28977802f, 0.03059311f, -0.05897070f, -0.14771403f, -0.00915802f, 
    0.39455503f, -0.14688902f, 0.42427009f, -0.20180334f, -0.59194607f, -0.66652310f, 0.14453213f, -0.11576488f, 
    0.20156956f, 0.12281311f, 0.11912892f, -0.02311079f, 0.00409296f, 0.39342496f, 0.42075348f, -0.04443615f, 
    -0.19038220f, 0.02288845f, -0.02295713f, -0.00393555f, -0.01895117f, 0.08700303f, -0.27718258f, -0.27930158f, 
    -0.03956297f, -0.13884704f, -0.26054913f, -0.08913555f, -0.07314134f, 0.20574839f, -0.05847594f, -0.22400962f, 
    -0.66715437f, -0.08443343f, 0.11301030f, -0.00849322f, -0.04821041f, -0.14162076f, 0.03961810f, 0.70463592f, 
    0.36826172f, 0.28360942f, -0.05744831f, 0.04473953f, -0.00945534f, 0.31068623f, 0.08471645f, -0.20085508f, 
    0.23085688f, -0.09370141f, -0.12611187f, 0.11055116f, 0.08534088f, -0.01046287f, 0.09168554f, -0.36174580f, 
    -0.58719504f, 0.24517812f, -0.04505064f, 0.28777176f, 0.30021733f, 0.20453244f, 0.20938924f, -0.03092620f, 
    -0.35954303f, -0.09132993f, 0.29686543f, 0.01539325f, 0.47006753f, 0.01081521f, -0.16379493f, 0.10391009f, 
    -0.02637264f, 0.01640074f, 0.24307443f, 0.20751539f, 0.01406091f, -0.04303834f, -0.06062594f, 0.08770274f, 
    0.05223618f, -0.12451556f, 0.02596138f, -0.28906837f, -0.11912318f, 0.22054185f, 0.21285121f, 0.36946043f, 
    0.09089187f, -0.41412380f, -0.13868073f, -0.33018935f, -0.26229590f, -1.08493686f, 0.25287870f, 0.09821869f, 
    -0.09631853f, 0.11631013f, 0.19852054f, 0.19781646f, 0.30568638f, 0.08481055f, 0.23291011f, -0.16088137f, 
    -0.29123086f, 0.09588212f, 0.13882361f, -0.00866269f, -0.23458377f, 0.12620048f, -0.28905421f, 0.06244544f, 
    -0.40941870f, 0.39527768f, -0.09825149f, -0.01383949f, -0.01677718f, 0.25946206f, -0.07436737f, 0.01495984f, 
    -0.04165133f, -0.06629991f, -0.03636158f, 0.02558753f, 0.02540265f, 0.04080179f, -0.40832871f, -0.42632058f, 
    -0.30748469f, -0.13344067f, 0.06114412f, 0.17943990f, -0.02704996f, 0.12812382f, 0.13306713f, 0.03101247f, 
    0.15581305f, 0.31954461f, 0.08783656f, -0.07465824f, -0.63852042f, 0.12612633f, 0.18625736f, 0.21611397f, 
    0.18821968f, 0.20031120f, -0.10118927f, 0.27902308f, -0.19421445f, 0.16331294f, -0.21686439f, -0.10314084f, 
    -0.07433972f, -0.13701780f, -0.01835214f, 0.19339430f, 0.36519992f, 0.40264645f, 0.34765694f, -0.32797879f, 
    -0.06013226f, 0.19469237f, 0.00333292f, 0.33416438f, -0.06912316f, 0.03994235f, -0.00849230f, 0.00048671f, 
    0.22083583f, 0.04215935f, 0.12268142f, -0.17369956f, -0.09931622f, -0.45297846f, 0.12005767f, -0.03280196f, 
    0.01816555f, 0.02631569f, 0.10155614f, 0.34978026f, -0.14053155f, 0.30314156f, 0.27530223f, -0.08448813f, 
    0.02311715f, -0.14438643f, 0.15228723f, 0.06524746f, -0.18791428f, 0.06860140f, -0.37173080f, -0.12891698f, 
    -0.32829970f, -0.11333781f, -0.21840082f, -0.37051132f, -0.00291933f, -0.12017697f, 0.12375472f, -0.10230795f, 
    -0.05412326f, 0.66026413f, 0.74401349f, -0.14576021f, -0.11472756f, 0.24247690f, -0.30498368f, -0.02098271f, 
    -0.08097244f, -0.00645649f, -0.06722797f, -0.47384292f, -0.00517415f, -0.23446058f, -0.04562597f, -0.28250042f, 
    0.17821173f, -0.04203394f, 0.07047558f, 0.08939750f, -0.57285023f, 0.35118261f, -0.00948753f, -0.08580695f, 
    0.12001877f, 0.07012862f, 0.05340355f, -0.15353422f, -0.02371657f, -0.25667468f, -0.25844067f, 0.00791642f, 
    -0.09259158f, 0.07661518f, -0.09077929f, -0.08243565f, -0.25436738f, -1.45539296f, 0.03195829f, -0.10395835f, 
    -0.00201135f, -0.02464417f, 0.36478579f, -0.05559466f, -0.08603556f, 0.41212577f, -0.58847421f, 0.86034846f, 
    0.05333235f, 0.02811340f, -0.21925741f, -0.30676129f, 0.19719324f, -0.00371895f, 0.23121130f, 0.58397925f, 
    -0.04457118f, -0.14753304f, -0.11627914f, 0.07333380f, -0.12478147f, 0.19364226f, -0.00099719f, -0.10103182f, 
    -0.23151396f, -0.17721942f, 0.00498367f, -0.23283535f, 0.05316639f, 0.10331579f, 0.14349282f, -0.13693742f, 
    0.12221834f, -0.16260177f, 0.10173246f, -0.19743308f, 0.01702854f, -0.00275902f, -0.01252193f, -0.00903648f, 
    -0.12500153f, 0.30193445f, -0.58814901f, -0.03245985f, -0.03398272f, -0.01167416f, -0.04341884f, -0.06064942f, 
    0.20264757f, -0.11062451f, 0.21182705f, 0.20755661f, 0.15171812f, -0.03891199f, 0.13899893f, 0.22564301f, 
    0.28909013f, -0.06694921f, 0.30912885f, -0.04395929f, 0.55997223f, -0.63944888f, -0.16058406f, -0.05858632f, 
    -0.26067218f, -0.03387433f, -0.02198117f, 0.21546446f, 0.07708698f, 0.52674854f, 0.57997227f, -0.25468957f, 
    0.06627411f, -0.07498388f, -0.08501186f, -0.04139759f, -0.20109802f, -0.19821148f, 0.08925904f, -0.21478599f, 
    -0.20932987f, -0.07268467f, 0.04326814f, -0.20258217f, 0.02454163f, 0.12013131f, 0.35943332f, -0.03753555f, 
    -0.07958482f, 0.19801614f, -0.14628838f, -0.18593113f, -0.09594831f, -0.01615233f, -0.13893062f, -0.05391192f, 
    -0.51532060f, 0.02535914f, 0.11308131f, -0.25663540f, -0.01327730f, -0.07322334f, -0.05048096f, 0.14588411f, 
    0.25022441f, 0.06626976f, 0.68354267f, 0.75062555f, -0.47629565f, -0.38921067f, -0.32890552f, -0.01120904f, 
    0.10131700f, 0.04350994f, 0.15194406f, 0.35235095f, 0.56317365f, -0.13322729f, 0.28343818f, 0.04093678f, 
    0.05088114f, 0.08364514f, -0.12667891f, -0.55773723f, -0.50911772f, 0.10463091f, 0.31895855f, -0.16177440f, 
    0.09155778f, -0.15665334f, 0.04353280f, 0.23485546f, -0.52310008f, -0.42346987f, -0.37213227f, 0.24182035f, 
    -0.05137436f, 0.05937769f, -0.32730526f, -0.08308570f, 0.27889678f, 0.00774535f, -0.75109237f, 0.26251638f, 
    0.25081342f, -0.08165923f, 0.11229919f, -0.35356638f, 0.06924000f, 0.16351774f, -0.61933231f, 0.41277421f, 
    -0.41678211f, -0.00412931f, -0.00589074f, -0.13998109f, -0.19357535f, 0.12467420f, 0.08818441f, 0.29264000f, 
    0.29636881f, 0.34691775f, 0.03458202f, -0.07881931f, -0.06704433f, 0.13403650f, 0.15691164f, 0.11178117f, 
    0.19965711f, -0.12993698f, 0.23443303f, 0.14138792f, -0.07199309f, -0.22324498f, 0.11554307f, -0.04179926f, 
    -0.08449821f, -0.00169695f, 0.07159795f, -0.12580575f, 0.12689868f, 0.03284748f, 0.01173569f, 0.10519426f, 
    -0.11614585f, -0.18672881f, -0.56830674f, -0.33422995f, -0.08727363f, -0.24003357f, 0.02573041f, -0.08885028f, 
    0.21387714f, 0.01782382f, -0.14441897f, -0.01663761f, -0.37875593f, 0.53084594f, 0.23295638f, 0.21784785f, 
    -0.07703448f, -0.07049976f, -0.14895441f, 0.05037671f, -0.38525295f, -0.32576120f, 0.24992436f, 0.00143183f, 
    -0.50335109f, -0.17309050f, -0.14838268f, -0.32109329f, -0.29956821f, -0.08426770f, 0.26058921f, 0.39800930f, 
    0.07635191f, -0.06313378f, 0.07123845f, 0.06949750f, 0.00773528f, 0.22589034f, -0.12406074f, 0.58090705f, 
    0.68103749f, 0.10176406f, 0.02691022f, -0.16960488f, 0.33082184f, 0.10118882f, -0.12050902f, -0.50365573f, 
    -0.19386716f, -0.46659833f, -0.18454172f, -0.03877294f, -0.01517965f, 0.16045336f, -0.04241416f, 0.12948777f, 
    -0.27684939f, 0.25694534f, -0.03501801f, 0.00540258f, -0.09172655f, 0.06719210f, 0.01536268f, 0.13297814f, 
    0.24910769f, -0.51619565f, 0.14262365f, 0.15314697f, -0.26832581f, -0.11572516f, -0.00461936f, 0.09885179f, 
    0.00805562f, 0.06848746f, -0.08971505f, -0.28745520f, -0.11705299f, -0.08755150f, 0.02454491f, -0.19626692f, 
    0.03938476f, 0.02566976f, 0.06038302f, 0.11040232f, -0.68640929f, -0.34596708f, 0.02547969f, -0.02036779f, 
    -0.05635211f, -0.00590230f, 0.27584019f, 0.18922766f, -0.07019825f, -0.05911267f, 0.13850431f, 0.22998208f, 
    -0.07196075f, 0.17016520f, 0.25087130f, 0.09584578f, 0.11378339f, 0.82923979f, -0.48009381f, 0.19858962f, 
    -0.13580500f, 0.04923050f, 0.07266128f, -0.03749228f, 0.07652468f, 0.00423796f, -0.11388590f, 0.39089987f, 
    -0.16773237f, 0.39061320f, -0.10069004f, 0.05654700f, -0.02921038f, 0.33955517f, 0.18228777f, 0.05414728f, 
    -0.06015384f, -0.06764454f, -0.03726596f, 0.11816383f, -0.09054791f, 0.11217656f, 0.13118975f, -0.04375688f, 
    -0.26277423f, -0.21773443f, -0.28688374f, -0.16951095f, -0.42569989f, -0.17991827f, -0.13867620f, -0.03592804f, 
    0.23334974f, 0.02743325f, -0.06417145f, -0.04868301f, 0.03108129f, 0.08623677f, 0.01709348f, 0.06213029f, 
    -0.14532061f, 0.07590122f, -0.55426455f, 0.20911406f, 0.12663880f, -0.26509109f, -0.18280317f, -0.10984116f, 
    0.16659902f, -0.38866672f, -0.32517058f, -0.52335805f, 0.08764133f, -0.03427780f, 0.08398563f, 0.43097568f, 
    0.49430737f, 0.17736685f, 0.10286661f, 0.30961287f, -0.32584167f, -0.15172805f, 0.36146933f, -0.05799968f, 
    -0.04670654f, -0.17620771f, 0.06357297f, -0.27437091f, -0.10592740f, -0.02818497f, 0.35197046f, 0.18789704f, 
    -0.15262935f, -0.00858644f, -0.03334372f, 0.09424493f, 0.00544954f, -0.15683205f, -0.58923644f, -0.03564782f, 
    -0.19594420f, -0.26819789f, 0.04910078f, 0.11978892f, 0.13225862f, -0.11348198f, -0.07733940f, 0.09120946f, 
    0.19621187f, 0.17040488f, -0.02691664f, -0.03870109f, -0.05134171f, 0.13427803f, 0.08471984f, 0.26737726f, 
    0.14206304f, 0.14538266f, 0.14505814f, 0.19325556f, 0.18709640f, 0.10260360f, -0.13322198f, 0.21704148f, 
    0.08198661f, -0.11549412f, 0.00852950f, 0.00625562f, -0.00634131f, -0.02211939f, -0.02118373f, -0.05998142f, 
    0.22505754f, -0.08579998f, -0.17600547f, 0.08494410f, -0.29147357f, 0.20242569f, 0.14579690f, -0.05325782f, 
    -0.08076566f, -0.13863565f, 0.02506304f, -0.22384772f, -0.20825638f, 0.42584103f, 0.13624375f, 0.12398097f, 
    0.13036007f, 0.22201303f, 0.19199556f, -0.08929978f, 0.17613016f, 0.21864393f, -0.06780202f, 0.04240667f, 
    0.03287869f, 0.04540201f, 0.30106360f, 0.26908207f, 0.12414955f, 0.17114583f, -0.06512654f, -0.11031699f, 
    0.20626947f, 0.04726347f, -0.03911917f, -0.03447055f, 0.10058584f, 0.24164608f, -0.31200638f, -0.42187354f, 
    0.02345230f, 0.31614187f, 0.02168120f, -0.09062291f, 0.27020270f, 0.08572182f, -0.00006795f, -0.02250479f, 
    0.54066670f, 0.54276019f, 0.22765334f, -0.05153248f, -0.03175593f, 0.21000238f, 0.15656513f, 0.08227374f, 
    0.01593644f, 0.05642154f, -0.10950793f, 0.17438047f, 0.20915323f, 0.06868695f, -0.13453710f, -0.09521862f, 
    -0.23286988f, -0.16188672f, -0.02478401f, 0.23510461f, -0.07535490f, -0.08096897f, 0.07408794f, -0.44771197f, 
    0.10608529f, 0.20877048f, -0.12136088f, -0.10086282f, 0.01287115f, 0.16141674f, -0.13530520f, 0.21046960f, 
    -0.07633043f, -0.02026063f, -0.18558413f, -0.01297148f, 0.46753049f, 0.57415885f, 0.13672510f, 0.11798228f, 
    0.09875622f, -0.16782585f, 0.02097004f, -0.13223638f, 0.25517184f, -0.33938542f, 0.52200204f, 0.20517850f, 
    0.03149450f, 0.17152037f, 0.09536840f, -0.50871795f, -0.16761670f, 0.28243864f, 0.07840544f, -0.00018810f, 
    -0.00020607f, 0.10529719f, 0.09263301f, 0.01623471f, 0.10818386f, -0.10742693f, -0.52701986f, -0.25278530f, 
    -0.16617355f, -0.00141691f, -0.00260464f, -0.00906668f, -0.48247901f, -0.10339157f, 0.01974253f, 0.01876744f, 
    -0.00966671f, 0.19283552f, 0.10446732f, 0.20540670f, 0.22238187f, 0.26646975f, 0.29623181f, 0.14493634f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.17015314f, 0.44444287f, 0.10108365f, 0.23042566f, -0.02213516f, 0.06487641f, 0.21641052f, 0.24723752f, 
    -0.04439336f, 0.65826511f, 0.33213931f, -0.19262761f, -0.10266759f, -0.13979359f, 0.48302412f, 0.47344637f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.42828864f, 0.00119760f, 0.20287479f, -0.52173632f, -0.14896722f, 0.27646276f, -0.11469822f, 0.05212152f, 
    -0.22990619f, 0.00818287f, -0.19683957f, -0.20489983f, 1.15172946f, -0.29355347f, -0.41674590f, -0.24867488f, 
    -0.41624424f, 0.22496256f, 0.71783358f, -0.38514805f, -0.00629200f, 0.40273967f, -0.17952472f, -0.69969547f, 
    -0.20460066f, -0.38537434f, 0.39471728f, -0.56265658f, -1.43915510f, 0.35727015f, 0.22465372f, 0.22012030f, 
    -0.36890981f, -0.68772328f, -0.45705163f, 0.11669125f, -0.21970583f, -0.48394305f, 0.66440427f, 0.21024236f, 
    0.08487297f, 0.36783901f, -1.34116507f, 0.19027102f, -0.38523066f, 0.11802792f, -0.18137877f, -0.02353646f, 
    -0.01514200f, 0.29853192f, 0.02732714f, 0.19643247f, -0.22230591f, -0.20189011f, -0.47494119f, 0.75948083f, 
    -0.19353767f, -1.59164512f, -0.73607367f, 0.64312750f, -0.56378818f, -0.26343063f, -1.15648985f, 0.20674582f, 
    -0.09393012f, -0.39024949f, -0.22440046f, -0.36322495f, -0.20147824f, -0.12104236f, 0.13912348f, -0.56335443f, 
    0.18092203f, -0.44578743f, 0.21511172f, 0.16384998f, 0.29189217f, 0.67020303f, -0.05623738f, 0.07483726f, 
    -0.05867368f, -0.07248982f, 0.35605940f, -0.32349527f, 0.06514064f, -0.46652010f, -0.30816841f, -0.37541467f, 
    -0.21811490f, -0.25709972f, 0.09806908f, -0.39417329f, -0.05151455f, -0.22343782f, 0.33192909f, 0.46261930f, 
    -0.52395278f, -0.38981199f, -1.04604924f, -0.37337837f, -0.18594001f, 0.28047901f, 0.42804754f, -0.50368059f, 
    0.20169751f, 1.06917667f, -0.48573178f, 0.31939200f, -0.03156133f, -1.08449388f, -0.29367995f, -0.15362787f, 
    -0.35582232f, -0.69578439f, 0.09566222f, 0.08993947f, 0.04926296f, 0.60239571f, 0.31378502f, 0.99546099f, 
    0.18926366f, -1.18236876f, 0.39986789f, 0.12297964f, -0.66232014f, -0.13279663f, 0.01341710f, -0.48945752f, 
    0.16783756f, -0.45156920f, -0.74285889f, -0.19424929f, 0.22899517f, -0.27643830f, -0.48417905f, 1.09168077f, 
    -0.03321283f, -0.44932222f, 0.59560984f, -0.81048226f, -0.59852886f, -0.02147864f, 0.27238196f, 0.14182842f, 
    0.28530535f, 1.15518045f, -0.12947819f, -0.65682912f, -0.12822455f, -0.34028900f, 0.26382625f, -0.50445712f, 
    0.03765333f, 0.16921248f, -0.08971734f, 0.47583967f, -0.87212157f, -0.59397703f, -0.13686867f, -0.27430341f, 
    -0.18787406f, 0.39503568f, -0.96211082f, 0.39597270f, 0.03995524f, 0.11083573f, -1.02398372f, -0.52366948f, 
    0.19236089f, -0.14740561f, -1.41134262f, -0.64243060f, -0.42983973f, 0.49071488f, 0.70028526f, 0.26112974f, 
    -0.43815705f, -0.28687122f, -0.44742694f, 0.81592411f, -0.08687049f, -0.45272061f, -0.27014229f, -0.72280961f, 
    -0.20562932f, -0.21344309f, 0.44700935f, 0.20621648f, -0.60568702f, -0.50417095f, -0.04014066f, -0.04289828f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.65665913f, -0.04542012f, 0.62040579f, 0.04096974f, -0.26888847f, 0.19118132f, -0.45216593f, -1.01284707f, 
    -0.02149036f, 0.22387494f, 0.14580427f, 0.32590085f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
