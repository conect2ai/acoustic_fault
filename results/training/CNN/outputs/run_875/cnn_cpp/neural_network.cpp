#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.90281099f, -0.05774686f, 0.25378090f, 0.48152345f, 0.48157713f, 0.52786446f, 0.22597003f, -0.30139247f, 
    0.49332866f, 0.55279648f, 0.34324235f, 0.43314597f, 0.06013729f, 0.60208857f, 0.49953508f, -0.38943034f, 
    -0.10346317f, -0.41517490f, -0.14278798f, 0.43447232f, 0.51002550f, 0.24184929f, -0.20009336f, 0.57638854f, 
    -0.19236650f, -0.05661442f, 0.32360214f, 0.43035299f, -0.27590039f, 0.85609794f, 0.62241858f, -0.18618621f, 
    -0.27702433f, 0.30006486f, -0.14174661f, 0.08428239f, -0.57834965f, 0.22303741f, -0.43999699f, -0.51057047f, 
    0.21694034f, -0.71436560f, -0.02101637f, 0.21825317f, -0.07581163f, 0.57592726f, 0.97871083f, -0.03791852f, 
    0.07688674f, 0.05115535f, -0.24708831f, -0.20066488f, 0.04741621f, -0.08548197f, 0.31501830f, -1.02416325f, 
    0.65036380f, 0.47481197f, -0.05579994f, 0.57196498f, -0.05618342f, -0.27101403f, -0.11871950f, 0.94533604f, 
    -0.49382323f, -0.51077104f, 0.30346376f, -0.27320895f, -0.07357195f, -0.25247976f, 0.04892981f, 0.03592354f, 
    -0.07117343f, 0.13877429f, -0.29710940f, 0.84280199f, 0.45005387f, -0.25671616f, 0.39005432f, 0.27576551f, 
    0.22326340f, 0.34856212f, 0.06354212f, -0.54104841f, -0.87172318f, 0.34079024f, -0.15507703f, 0.05413295f, 
    0.37082797f, 0.34473801f, 0.22842145f, 0.01099866f, 0.78651416f, -0.54711741f, 0.28468758f, -0.13301283f, 
    0.36891878f, 0.29527399f, 0.01858649f, 0.16765305f, -0.14253308f, 0.21998620f, -0.69297069f, -0.95968819f, 
    -0.25230342f, -0.11505434f, 0.18712327f, -0.07076312f, -0.54429334f, -0.04641074f, -0.26484507f, -0.38758889f, 
    -0.14959373f, 0.50400847f, -0.22396535f, 0.04710325f, -0.36757469f, -0.70753092f, -0.38301885f, -0.38158810f, 
    0.04092823f, 0.76829708f, -0.11940850f, -0.16915965f, -0.10876422f, -0.12451270f, 0.27110744f, -0.50280893f, 
    -0.77349061f, 0.38541028f, 0.53259635f, 0.34295911f, -0.04216778f, -0.12626755f, -0.26771927f, -0.72215778f, 
    -0.95474827f, -0.55669558f, -0.37512505f, -0.44982615f, 0.28946850f, -0.01158645f, 0.12954268f, 0.07888637f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02749442f, 0.04296193f, 0.33506566f, -0.30622232f, 0.35564247f, 0.07165116f, -0.11789557f, -0.38882142f, 
    -0.20369135f, -0.27155289f, 0.08803682f, 0.02875187f, 0.16954465f, -0.33372551f, -0.10350114f, 0.01584772f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.11010355f, 0.19969313f, -0.20440748f, 0.03756754f, 0.00167747f, 0.03381498f, -0.01660174f, 0.10746480f, 
    0.03547009f, -0.03366716f, 0.08751386f, 0.28123137f, 0.11292379f, -0.02923069f, -0.02411684f, -0.03184863f, 
    -0.10983075f, 0.21153973f, -0.44745106f, -0.20117103f, 0.09812154f, -0.00142856f, 0.07195268f, 0.11097375f, 
    0.04944141f, 0.10272737f, 0.05227502f, -0.99638647f, -0.15984416f, 0.09851476f, 0.17662084f, 0.06145467f, 
    0.00762718f, -0.09109174f, 0.11601920f, 0.03254626f, 0.14575645f, 0.01325038f, 0.06610893f, -0.01410458f, 
    0.11859544f, 0.14909691f, -0.02300078f, 0.02025804f, -0.14832665f, -0.41454706f, -0.12102250f, -0.12011155f, 
    -0.02388128f, 0.08523214f, 0.07161777f, -0.03219841f, -0.06577047f, -0.01472922f, -0.02449140f, -0.04249325f, 
    -0.12367779f, 0.19220324f, 0.06444146f, -0.11743899f, -0.02656367f, -0.00452877f, -0.00401336f, 0.27337310f, 
    0.10539427f, -0.15603979f, -0.02766528f, -0.04028720f, -0.13479009f, -0.14647259f, -0.25561640f, -0.01940823f, 
    0.21667831f, -0.00163303f, -0.16494679f, -0.11288621f, -0.04788479f, 0.03292041f, 0.15498903f, -0.02371030f, 
    -0.13077694f, -0.11532043f, 0.06767565f, -0.21697731f, 0.05277785f, -0.07250890f, 0.06809556f, -0.06896930f, 
    -0.06273260f, 0.00231686f, -0.19495621f, -0.11670280f, 0.34738702f, -0.04818725f, 0.00950069f, 0.08769554f, 
    -0.04096306f, 0.12672877f, -0.07579532f, 0.49416265f, 0.24191700f, 0.18553390f, 0.16499151f, -0.05868866f, 
    0.04643239f, 0.07853159f, 0.10127663f, -0.01779568f, -0.00597149f, -0.09771122f, 0.09889536f, -0.18795951f, 
    0.03494043f, 0.14351298f, 0.04359525f, -0.14243846f, 0.09022742f, -0.11304673f, 0.08700945f, 0.13957681f, 
    -0.19176878f, -0.19387987f, -0.01100230f, -0.08240446f, 0.09763294f, -0.16104639f, 0.15526368f, -0.05470077f, 
    -0.32769519f, 0.10815230f, 0.07055654f, -0.01265304f, 0.09147259f, 0.12466875f, 0.13449922f, -0.08871484f, 
    0.10577377f, 0.00566181f, 0.00330733f, -0.09219500f, -0.11950513f, 0.02428101f, 0.15708199f, 0.15205471f, 
    0.11547855f, 0.28278527f, -0.18621610f, 0.00106677f, -0.03225880f, 0.03391691f, 0.04756850f, -0.00303107f, 
    -0.07957054f, 0.01813350f, 0.20566717f, 0.20850611f, -0.01094315f, 0.15201959f, -0.06411345f, 0.06302907f, 
    -0.09574100f, 0.23465517f, 0.14256431f, -0.12522881f, -0.07968357f, 0.11217902f, -0.01594395f, 0.04770547f, 
    0.00731616f, 0.08979889f, 0.04597053f, -0.30956838f, -0.04881985f, 0.00191499f, 0.01364149f, -0.08413192f, 
    -0.33931732f, 0.00240045f, 0.02093893f, 0.18375069f, 0.01810836f, 0.24014871f, 0.18574157f, 0.02062086f, 
    0.16099189f, 0.02190543f, 0.09132497f, -0.17623013f, -0.11693473f, -0.17417920f, 0.03029228f, 0.24143244f, 
    0.00325469f, -0.04504320f, -0.04789639f, 0.04214177f, 0.06643550f, -0.18379305f, -0.93746120f, -0.02218167f, 
    -0.14299272f, -0.00352923f, 0.09533557f, 0.09191976f, -0.04334360f, 0.13263795f, -0.10071357f, 0.18660766f, 
    -0.16858065f, -0.44315517f, -0.12906457f, -0.14319628f, 0.03545433f, -0.07572011f, 0.02876062f, 0.12698837f, 
    -0.27377045f, 0.10668923f, -0.02446964f, 0.21055263f, -0.07366019f, -0.04551473f, 0.07607028f, 0.09425599f, 
    -0.13668647f, -0.22583069f, 0.16789901f, -0.11239480f, -0.02731933f, -0.01133023f, 0.05636372f, 0.03336053f, 
    0.13415952f, 0.14494529f, -0.41282678f, -0.17481068f, 0.26900175f, 0.21816483f, -0.00949144f, -0.13017927f, 
    0.15608096f, 0.05086953f, -0.00772300f, 0.02888446f, -0.17032711f, 0.32356969f, -0.25996491f, 0.04030679f, 
    0.09063371f, -0.13437323f, 0.11310313f, 0.14633137f, 0.06050300f, -0.13017789f, -0.36784822f, -0.02310290f, 
    0.09323565f, 0.15500249f, -0.05741923f, 0.08397568f, -0.08424400f, -0.48569021f, -0.22925663f, 0.02570697f, 
    0.02347799f, -0.00453196f, -0.00433317f, -0.06001901f, -0.08911432f, -0.02013765f, -0.16751206f, -0.00051209f, 
    0.09536944f, 0.04018687f, -0.02809056f, 0.01511843f, -0.06426498f, -0.02567050f, -0.02719345f, -0.14146966f, 
    -0.08320586f, 0.08884269f, 0.11411779f, 0.11270222f, -0.14661798f, 0.17184108f, -0.00593893f, -0.06208682f, 
    0.03886640f, 0.05318084f, -0.07512292f, 0.03777488f, -0.06013775f, -0.05226361f, -0.07168951f, -0.05193029f, 
    -0.08160190f, -0.01664408f, -0.03441473f, -0.02331877f, 0.00717492f, 0.00173059f, 0.05238935f, 0.03935932f, 
    -0.08056541f, -0.02786595f, -0.00602112f, 0.05329722f, -0.06850514f, 0.03742002f, -0.00120629f, -0.03560922f, 
    0.08255240f, 0.02942367f, -0.04491277f, 0.00011661f, 0.01432794f, -0.07830699f, 0.07312801f, 0.06501189f, 
    -0.04880136f, -0.06916793f, -0.02612625f, -0.06285292f, -0.05927480f, 0.05175709f, -0.08043374f, -0.06791925f, 
    -0.00468500f, -0.05302516f, 0.01554134f, 0.01574638f, -0.01792788f, 0.01937567f, -0.07960593f, 0.02731519f, 
    -0.00281478f, 0.06024707f, -0.02559946f, -0.03208745f, -0.05770149f, -0.03484125f, 0.04946598f, 0.02931530f, 
    -0.06414200f, 0.05371577f, -0.05121913f, -0.01276284f, -0.06492299f, 0.03247559f, -0.00420261f, -0.07353361f, 
    0.01905723f, -0.02676518f, -0.06918868f, -0.01699907f, 0.05907845f, 0.03939711f, -0.05430079f, -0.02311318f, 
    0.07248083f, -0.01053373f, -0.00999042f, -0.04884017f, -0.00589704f, -0.06315427f, -0.06099846f, -0.02122925f, 
    -0.04467800f, -0.00892221f, 0.06539284f, -0.06979498f, -0.03346518f, -0.06610745f, 0.01523891f, 0.00870152f, 
    -0.07218221f, -0.02385729f, 0.04422238f, 0.03954284f, 0.00642801f, -0.04870393f, -0.07012483f, 0.01771587f, 
    -0.04623863f, 0.01217526f, -0.00654774f, -0.04696217f, 0.03142054f, -0.03286026f, 0.06654605f, 0.07956493f, 
    0.00336261f, -0.06202450f, 0.04815573f, -0.08088903f, 0.01481240f, -0.08079258f, -0.01480449f, 0.06079059f, 
    -0.01949468f, 0.02197708f, -0.05926272f, 0.02077499f, -0.04128365f, -0.04073446f, -0.07593524f, -0.06448944f, 
    0.05067618f, -0.07075682f, -0.03556926f, -0.06208807f, -0.00308556f, -0.03369747f, -0.06396528f, -0.02018191f, 
    0.04753140f, 0.05998086f, -0.03710324f, 0.00356199f, -0.03371715f, 0.07719936f, -0.01454121f, -0.03080366f, 
    0.00215009f, -0.01385779f, -0.02879350f, -0.02249764f, -0.03313084f, -0.04092737f, -0.05437308f, 0.02137681f, 
    0.02389741f, -0.06753421f, -0.08391468f, 0.00646542f, -0.02161877f, 0.01418843f, -0.06743246f, -0.06341016f, 
    0.02678689f, -0.00153501f, -0.00939381f, 0.02262726f, -0.06544722f, -0.05741290f, 0.02540858f, 0.00444243f, 
    -0.07027340f, -0.00769210f, -0.06308088f, 0.05316291f, -0.04552372f, 0.00870199f, 0.05138111f, 0.06861374f, 
    0.07036071f, -0.02394119f, 0.05746904f, 0.06538380f, -0.04180252f, -0.01604583f, 0.02415277f, -0.04962054f, 
    0.03315691f, 0.06084322f, 0.03435258f, 0.00955597f, -0.07054231f, -0.07235883f, -0.06874181f, -0.03699907f, 
    -0.08391872f, -0.08792496f, -0.07185427f, 0.06379555f, 0.01940722f, -0.03556446f, 0.02762572f, 0.01077072f, 
    0.05411309f, 0.02533232f, 0.03614295f, -0.07129564f, -0.02758222f, 0.01850999f, 0.06011745f, 0.00263094f, 
    0.01559147f, -0.01735407f, -0.08108331f, -0.06234458f, 0.01093642f, -0.02987737f, -0.00128272f, 0.07123041f, 
    0.03196070f, 0.02664401f, 0.04391338f, -0.03378022f, 0.04121838f, -0.00830753f, 0.07434644f, -0.05236667f, 
    0.05487905f, 0.04646385f, -0.05098906f, -0.06757490f, 0.06238229f, -0.07673238f, -0.07866907f, -0.04475533f, 
    0.02580742f, 0.00011396f, -0.03308628f, 0.04723772f, -0.08592558f, 0.00051346f, -0.09206798f, 0.01067697f, 
    0.03045427f, -0.01934398f, -0.03939483f, -0.05294289f, 0.06252258f, -0.07233261f, -0.07049240f, 0.04578058f, 
    0.02958496f, -0.07514025f, 0.05509030f, 0.03809074f, 0.05993660f, -0.06039514f, 0.00274269f, -0.01387593f, 
    0.03681156f, -0.04046596f, 0.05674288f, 0.06215650f, -0.04352046f, -0.02968048f, -0.01421653f, 0.03210661f, 
    -0.01725229f, -0.01043789f, -0.00189331f, -0.07463481f, -0.08816456f, -0.04297157f, 0.02201397f, 0.00401105f, 
    0.01224083f, -0.07772935f, 0.04844094f, -0.09291517f, -0.09438664f, 0.01755700f, 0.00430832f, 0.02989784f, 
    -0.03098846f, -0.07411576f, 0.03409837f, -0.07712720f, 0.03069803f, 0.00047595f, 0.03480290f, 0.05154675f, 
    -0.02097393f, 0.00954344f, 0.07711413f, -0.00241833f, -0.07134339f, -0.08169603f, -0.04097746f, -0.06204050f, 
    0.31030580f, 0.23410697f, 0.06404824f, 0.21435833f, 0.11177187f, -0.05852957f, -0.01408009f, 0.07279342f, 
    0.05885596f, 0.10586450f, 0.03283678f, 0.13843557f, -0.20384519f, -0.12677653f, -0.19445014f, 0.12911217f, 
    0.08843586f, 0.04682086f, -0.10036499f, 0.01403975f, -0.00434714f, -0.11972759f, -0.19698445f, -0.01295905f, 
    -0.05289530f, -0.05189656f, 0.22519469f, -0.08197972f, -0.08369561f, -0.34844804f, -0.26183903f, 0.00720801f, 
    0.01722676f, -0.19692056f, 0.15358439f, -0.01917300f, -0.30762297f, -0.37999099f, 0.14824271f, 0.11679641f, 
    -0.04383009f, 0.11510835f, 0.12909707f, -0.12246430f, -0.22552696f, -0.03841086f, 0.19763751f, 0.16793647f, 
    -0.36625803f, -0.01853547f, -0.08561844f, -0.04768278f, 0.08303209f, -0.02535721f, 0.23605397f, -0.03033560f, 
    -0.07367770f, 0.09352792f, 0.09411456f, 0.07309289f, 0.00924118f, -0.17819871f, -0.05400921f, 0.41513363f, 
    -0.23529422f, 0.26719508f, -0.15523820f, -0.17401275f, 0.10239538f, -0.01067274f, -0.02626427f, 0.08596781f, 
    0.16227718f, -0.20813733f, -0.20803942f, 0.29085395f, -0.06692062f, 0.01911999f, 0.10112608f, 0.05059483f, 
    -0.01105502f, -0.40881547f, -0.11727419f, -0.03020276f, -0.12414779f, -0.01352193f, -0.14430204f, -0.07514986f, 
    -0.02157888f, 0.03138816f, -0.14734083f, -0.16072346f, -0.07474764f, -0.12541959f, -0.00337914f, 0.05185385f, 
    -0.01053273f, -0.00180059f, -0.02179724f, 0.08056101f, -0.17141928f, -0.12359770f, -0.22049692f, -0.03388220f, 
    -0.24862315f, 0.10133349f, 0.17980209f, 0.12459067f, -0.04403442f, 0.05590184f, -0.08231168f, 0.16218799f, 
    0.14960843f, -0.00134431f, -0.04432340f, 0.01031078f, 0.21707326f, 0.44060928f, 0.34917864f, 0.48285824f, 
    0.04692876f, 0.00860200f, -0.09012537f, 0.01298835f, -0.04873854f, 0.12896098f, -0.00330224f, 0.10365943f, 
    -0.20270562f, -0.10341594f, -0.07653729f, 0.06988066f, -0.12039216f, 0.06707717f, -0.00195977f, -0.30445483f, 
    0.04868251f, 0.22888526f, 0.12776315f, 0.11077607f, 0.06214533f, 0.03065719f, -0.04262532f, 0.01074679f, 
    0.43392417f, 0.18299134f, -0.29705831f, 0.13919243f, -0.09190723f, 0.16750915f, -0.04873154f, -0.03359263f, 
    0.10170616f, 0.13930351f, -0.12236555f, 0.10357879f, 0.14211585f, 0.05535284f, -0.03405033f, 0.05091434f, 
    0.15460484f, 0.03561187f, 0.03608856f, -0.04706708f, -0.16914010f, -0.01078536f, 0.25918776f, 0.17494950f, 
    -0.16529126f, -0.09367705f, -0.01009947f, 0.20613903f, 0.00625579f, -0.12141366f, -0.02612280f, -0.02179428f, 
    0.16503216f, 0.16227232f, -0.17127976f, -0.00968474f, -0.00178629f, -0.06042134f, 0.00512973f, -0.06966989f, 
    -0.03248383f, 0.21410920f, -0.03737006f, -0.02435636f, 0.03617987f, -0.13076195f, -0.25357378f, 0.21410266f, 
    0.14804325f, 0.00979162f, -0.05691806f, -0.04762407f, 0.12717481f, -0.23620260f, 0.46453562f, -0.07304132f, 
    0.11956376f, -0.14272901f, 0.03385282f, -0.00498661f, 0.04295560f, -0.02857002f, 0.00868712f, -0.11826741f, 
    -0.28764382f, 0.11472334f, 0.11450248f, 0.07187649f, -0.05721475f, 0.11566291f, -0.19516075f, -0.08022817f, 
    0.23072371f, 0.01042608f, 0.08556409f, -0.16225299f, -0.13040173f, -0.21343584f, -0.01202974f, 0.00746405f, 
    0.03087227f, 0.07142238f, -0.16670446f, -0.16267686f, -0.07837496f, -0.16860892f, -0.17049004f, 0.03883932f, 
    -0.01987861f, 0.17951958f, -0.36207035f, -0.00734164f, 0.25955757f, -0.18484661f, 0.12950778f, 0.11693742f, 
    -0.15573891f, -0.07078380f, -0.02814560f, 0.00691904f, -0.16365096f, -0.10774723f, 0.02804840f, -0.01982756f, 
    0.05298690f, -0.03101408f, 0.15782957f, -0.10611211f, 0.04509730f, -0.28759456f, 0.11875934f, -0.07256427f, 
    0.31250101f, 0.05175304f, -0.01342894f, 0.09231967f, -0.01306851f, -0.39223430f, -0.31673068f, -0.33553985f, 
    0.08770168f, -0.01590906f, -0.11642398f, 0.07156584f, 0.03564864f, -0.10780504f, -0.06275178f, 0.26508260f, 
    0.05362685f, 0.12705748f, 0.02323855f, -0.16281588f, -0.08543912f, -0.08724836f, 0.06793556f, 0.02029299f, 
    -0.15174463f, -0.12454912f, 0.01541680f, 0.08812375f, -0.18774320f, -0.14151967f, -0.13860105f, 0.11268678f, 
    0.11722746f, 0.39519605f, -0.00135799f, -0.00662053f, 0.03573453f, -0.07305406f, 0.01456480f, 0.06812089f, 
    -0.04828579f, -0.05926936f, 0.31126344f, -0.08628567f, 0.03823050f, -0.01622850f, 0.11021664f, 0.01744453f, 
    0.17527214f, 0.01693515f, 0.14010003f, 0.06280381f, -0.13864079f, -0.07621540f, 0.04827245f, 0.07576569f, 
    -0.01585103f, 0.04314304f, 0.11557408f, -0.21758069f, 0.06590287f, 0.19962172f, -0.00627738f, 0.03117942f, 
    -0.04061282f, -0.00267205f, 0.01227157f, -0.08188951f, 0.05585999f, -0.03201814f, -0.54388785f, 0.09375470f, 
    0.13707419f, 0.05219037f, -0.06407058f, -0.05087947f, 0.14045535f, 0.27636042f, 0.01092311f, -0.05247920f, 
    -0.27834612f, 0.05389158f, 0.11900003f, -0.14443696f, -0.04135676f, -0.07931452f, -0.21681847f, 0.00814721f, 
    0.01103627f, -0.05044188f, 0.06799360f, -0.09654795f, 0.03699026f, 0.07506771f, 0.06047563f, -0.45794094f, 
    -0.32920849f, -0.40463713f, 0.06680184f, 0.06851662f, -0.13847677f, -0.19985852f, -0.07975148f, -0.16304258f, 
    0.01867411f, -0.39869210f, 0.20590246f, 0.02958525f, -0.12579505f, -0.02161198f, -0.05118518f, -0.04082101f, 
    -0.08464725f, 0.52201855f, -0.12618783f, -0.08744846f, 0.03997571f, -0.01487005f, -0.05437004f, -0.08185712f, 
    0.01889550f, -0.19623242f, 0.06932954f, 0.02369470f, 0.04073691f, 0.04811215f, 0.06766257f, 0.09921689f, 
    -0.01895599f, -0.05851574f, -0.08246255f, -0.54596525f, 0.20649424f, -0.04590348f, 0.06507646f, 0.09747479f, 
    -0.01469738f, 0.00523376f, 0.17391250f, 0.03580581f, -0.07075899f, -0.09899054f, -0.22080985f, 0.04256459f, 
    -0.15191594f, -0.10243336f, -0.13673799f, 0.08615188f, -0.00310132f, 0.31644544f, -0.01767613f, 0.01331529f, 
    0.15177433f, -0.00518035f, 0.04447171f, 0.01442368f, -0.04550396f, -0.00243576f, 0.19005910f, -0.35680744f, 
    -0.00191290f, -0.02172031f, -0.06497299f, -0.03746926f, 0.04447229f, -0.02373318f, 0.19477272f, 0.32839081f, 
    -0.14993265f, 0.36867478f, 0.04232138f, 0.05130906f, 0.08702532f, 0.00544113f, 0.02423012f, 0.15607814f, 
    0.33198261f, 0.12640154f, -0.01820122f, -0.11163183f, 0.16837876f, -0.07713216f, 0.17358366f, 0.06676513f, 
    0.10304658f, -0.30256474f, -0.19566092f, -0.40558016f, 0.06382107f, -0.03445843f, 0.06023856f, -0.08518943f, 
    0.00415112f, -0.02827802f, -0.20321217f, -0.20840742f, -0.17583121f, 0.19612123f, -0.05751980f, 0.27579170f, 
    0.10068926f, 0.09415140f, 0.23432308f, -0.29670987f, -0.26165622f, -0.20764159f, 0.07403746f, -0.06415166f, 
    -0.13357209f, 0.04161940f, 0.03487571f, -0.03834023f, 0.06688514f, -0.29983360f, -0.07789028f, -0.18897294f, 
    0.01262806f, 0.00175446f, 0.02382501f, -0.03078271f, 0.04550320f, -0.21998359f, -0.23503053f, -0.13869782f, 
    0.09558652f, 0.09275568f, 0.10590106f, -0.27031434f, -0.17279102f, -0.05714465f, -0.37228650f, 0.31054354f, 
    0.24537654f, -0.05578296f, -0.14704576f, -0.08905639f, -0.04774347f, 0.15746883f, 0.07059275f, -0.46538499f, 
    -0.03453889f, -0.10457999f, 0.13121450f, -0.32210866f, 0.08545662f, 0.21940923f, -0.16917557f, -0.04345298f, 
    0.28606319f, 0.07647037f, -0.10921271f, -0.01372587f, -0.02367308f, 0.07857907f, 0.03695037f, 0.12613200f, 
    0.13662550f, 0.27356103f, 0.17609201f, 0.02361801f, 0.14828707f, 0.00967019f, 0.04364083f, 0.00629215f, 
    -0.06135891f, -0.10769817f, 0.18767057f, 0.15426452f, -0.20277148f, 0.16795062f, 0.06378266f, 0.12906322f, 
    0.02419015f, -0.09091157f, -0.11813532f, 0.10508636f, 0.09561408f, -0.29540735f, -0.06539840f, 0.09110146f, 
    0.12920420f, 0.01327045f, 0.17032221f, -0.07462315f, -0.09499431f, 0.01414351f, -0.04875800f, -0.02462467f, 
    0.04487893f, 0.04131995f, -0.05819093f, 0.09617883f, 0.02744780f, -0.09934749f, -0.09370456f, 0.01385434f, 
    -0.14610179f, 0.01095790f, -0.02409527f, -0.03060456f, 0.09216910f, -0.24338269f, 0.23109066f, 0.24557938f, 
    0.25086901f, -0.19115090f, 0.02106186f, -0.04826306f, -0.06631000f, -0.06062413f, 0.06371088f, 0.12373525f, 
    0.01188867f, -0.14647453f, 0.05759934f, 0.06234327f, 0.06509219f, -0.04971065f, 0.03324270f, 0.00379619f, 
    -0.01807807f, 0.19122484f, 0.18943880f, -0.11107512f, 0.06843594f, 0.00004220f, 0.04805720f, 0.02519875f, 
    0.07337634f, 0.11161777f, -0.00028437f, -0.02965730f, -0.00363770f, -0.03097550f, -0.22465600f, -0.01244388f, 
    0.26335642f, -0.15266128f, -0.13085799f, 0.15529980f, 0.05547188f, 0.12999813f, 0.04885717f, -0.10626198f, 
    -0.08379997f, 0.10975958f, 0.09480183f, -0.11492998f, 0.09492903f, 0.11479545f, 0.07667065f, 0.05124490f, 
    -0.07594936f, 0.04635493f, -0.13413094f, -0.03119795f, -0.09707917f, -0.12549680f, -0.01170599f, -0.02837067f, 
    0.03272435f, 0.25704783f, 0.07163461f, -0.11908586f, -0.05177781f, 0.10464152f, 0.36330658f, -0.12834111f, 
    0.23701173f, 0.09229590f, -0.00473782f, -0.24710028f, -0.16635533f, 0.02252421f, -0.00254294f, 0.14580242f, 
    0.31878445f, -0.07647122f, -0.08060582f, -0.01918631f, 0.08018119f, -0.02614821f, 0.09293666f, -0.38626108f, 
    -0.35562655f, -0.10488334f, 0.02227676f, -0.06240805f, 0.04026837f, 0.01565701f, -0.13498570f, -0.18916552f, 
    0.05385999f, -0.17314596f, 0.11359771f, -0.14076096f, 0.12262172f, 0.00205005f, 0.10257682f, 0.04142101f, 
    0.04129433f, -0.18755296f, -0.14072986f, -0.01868101f, 0.09932220f, 0.03323374f, 0.05538552f, 0.05000719f, 
    -0.10603862f, 0.08689342f, 0.25676772f, -0.23244122f, -0.14516950f, 0.08872326f, -0.00811169f, 0.02977918f, 
    0.10922109f, 0.21092787f, 0.11556606f, -0.05420616f, 0.03330967f, -0.05676251f, 0.04349094f, -0.01435433f, 
    0.20338398f, -0.16119565f, -0.02045712f, 0.02714643f, -0.14807726f, 0.05058736f, -0.14377365f, 0.21806926f, 
    0.01949229f, -0.09858150f, -0.09928764f, -0.09162279f, -0.09969413f, 0.06032670f, 0.07199106f, -0.34993500f, 
    0.08608388f, 0.06711442f, 0.10105424f, -0.12821855f, -0.15622295f, -0.25041279f, 0.04853540f, -0.11010900f, 
    -0.52515066f, 0.17814793f, -0.20202602f, -0.10514542f, 0.24777074f, -0.09857052f, 0.01859950f, -0.04027383f, 
    0.27197692f, -0.01922334f, 0.13580637f, 0.08218273f, 0.11402448f, 0.19398862f, 0.05473419f, 0.00403586f, 
    -0.07673034f, 0.04982216f, -0.01941816f, -0.09798037f, -0.00415856f, 0.02913611f, -0.08256763f, -0.04442985f, 
    -0.07688881f, 0.04520860f, 0.04284652f, -0.01344631f, -0.03648047f, 0.00261810f, -0.03647108f, -0.03942473f, 
    -0.01768482f, 0.03108068f, -0.07633932f, -0.04972453f, -0.02055092f, 0.01933300f, -0.08390152f, -0.06835753f, 
    -0.08813734f, -0.08193892f, 0.02510050f, -0.09886099f, -0.05740568f, 0.04516373f, -0.06386220f, 0.03821847f, 
    -0.01427969f, -0.07612713f, 0.05667175f, -0.02040030f, -0.06986222f, -0.05894525f, 0.01359084f, -0.00341021f, 
    0.02774061f, -0.03491760f, -0.06090002f, -0.07737040f, -0.02471457f, -0.07040666f, -0.09117705f, 0.01026093f, 
    0.01286273f, -0.01500016f, 0.02294573f, 0.03234667f, -0.09690680f, -0.01607587f, -0.00750313f, -0.09568539f, 
    -0.06903827f, -0.04163405f, -0.07184169f, -0.02660613f, 0.02706255f, -0.03166310f, -0.06715026f, -0.02025114f, 
    0.02011337f, -0.07104401f, 0.02620959f, -0.04020522f, 0.01477678f, -0.03796266f, -0.08214502f, 0.06109923f, 
    -0.05657830f, 0.02030530f, 0.01375461f, -0.09633706f, 0.00014720f, -0.02651243f, -0.03737025f, -0.08453763f, 
    -0.04420377f, -0.09906065f, -0.07228771f, -0.05648612f, -0.03725415f, -0.05524246f, -0.07357931f, -0.04431712f, 
    -0.00020327f, 0.03905037f, 0.01213471f, 0.07390627f, -0.05315203f, 0.04650989f, -0.03952325f, 0.00789368f, 
    0.01855531f, 0.01221761f, -0.04475590f, -0.07751212f, -0.00373396f, 0.04172152f, -0.01535255f, 0.03051776f, 
    0.05432927f, -0.04132020f, -0.04746895f, -0.00335982f, -0.06755705f, 0.00222439f, -0.03052813f, -0.02989856f, 
    -0.02227250f, -0.01722749f, -0.10006803f, -0.10103568f, 0.02914537f, -0.01434629f, -0.02202889f, -0.03672263f, 
    0.03877246f, 0.02225738f, -0.08103752f, -0.08249482f, -0.04512370f, -0.03105303f, -0.04656812f, -0.04983499f, 
    -0.01649632f, -0.01774416f, 0.01194185f, 0.05794338f, -0.06134588f, -0.05329948f, -0.04665608f, -0.07287572f, 
    0.05973752f, 0.02261263f, -0.05268697f, 0.00178573f, -0.03390567f, -0.02503526f, -0.07651342f, 0.00060842f, 
    -0.03007711f, -0.09963737f, -0.07766065f, -0.11257494f, 0.02332023f, 0.03378025f, 0.00916833f, -0.08594365f, 
    0.05500998f, -0.03974438f, -0.08504422f, 0.03885163f, -0.08434582f, 0.01973752f, 0.01521160f, 0.04285497f, 
    -0.00997822f, -0.08423035f, -0.04288190f, -0.11200199f, -0.00089663f, -0.04673867f, 0.04710507f, -0.11257188f, 
    0.04903938f, -0.01066106f, -0.02410919f, -0.04170487f, -0.03872995f, 0.03087406f, -0.10961040f, -0.00698783f, 
    -0.01444408f, -0.02997449f, 0.02639066f, -0.10261714f, -0.04915198f, 0.11094744f, 0.06486730f, 0.03359510f, 
    -0.09482759f, -0.03788621f, -0.11802981f, -0.02964437f, 0.05006459f, -0.07150257f, -0.03416722f, 0.00508991f, 
    -0.02792117f, -0.03225490f, -0.03026918f, 0.06234023f, 0.03395174f, -0.04468860f, 0.02763104f, 0.00917528f, 
    0.03837217f, 0.04739032f, 0.01637037f, 0.04509206f, -0.01349934f, -0.10197536f, -0.01064229f, 0.03018461f, 
    -0.10750972f, -0.09757564f, -0.09374681f, -0.09079708f, 0.01244682f, 0.00174884f, -0.06587388f, -0.05111959f, 
    0.02127749f, 0.01559913f, -0.06667191f, -0.11445681f, -0.08654948f, 0.03250039f, -0.04220552f, -0.07021966f, 
    0.04552648f, 0.08167358f, 0.00201212f, -0.03365619f, 0.02261090f, -0.10404570f, -0.07678934f, -0.03643170f, 
    -0.00624924f, -0.04358001f, -0.02520386f, -0.05679755f, -0.06440611f, 0.03756196f, 0.00763737f, -0.07554092f, 
    0.00660652f, -0.02506127f, -0.04999878f, -0.01834413f, -0.04161661f, 0.09462718f, 0.02655421f, -0.06130458f, 
    -0.03667917f, -0.04328610f, 0.05096616f, -0.06560852f, 0.01151135f, 0.11314046f, -0.02408167f, -0.01005873f, 
    0.00350380f, -0.04105625f, 0.01331476f, -0.07742234f, 0.02118094f, -0.02294386f, 0.03305994f, -0.03282584f, 
    0.05072458f, 0.02116976f, -0.10992600f, -0.01605956f, 0.03391754f, -0.10232975f, 0.04283132f, -0.05769799f, 
    -0.05547209f, 0.04371245f, -0.06272336f, -0.03543904f, 0.04697760f, 0.01195219f, -0.01337001f, 0.03812376f, 
    -0.04554507f, -0.03538929f, 0.10301002f, -0.00487758f, -0.05580149f, -0.03447198f, -0.06592649f, -0.06219286f, 
    0.00591691f, -0.30617598f, -0.19024016f, 0.20062307f, 0.09690718f, -0.04714898f, 0.02264031f, 0.07065779f, 
    -0.25284269f, -0.07672113f, 0.03205800f, 0.08631528f, 0.14865892f, 0.26928869f, -0.03388610f, 0.04458042f, 
    -0.05527506f, 0.10424437f, 0.26776019f, 0.00797100f, 0.03683602f, 0.05411580f, 0.16476835f, 0.16149241f, 
    0.07163077f, 0.09324694f, 0.01416745f, -0.10088903f, -0.14404814f, -0.11209514f, -0.05996567f, -0.10242829f, 
    0.00682443f, 0.02773880f, -0.04692540f, -0.02770349f, -0.07718164f, 0.09931942f, -0.03136562f, 0.11929104f, 
    0.10337971f, 0.08520085f, 0.03077327f, 0.06460635f, 0.06769653f, 0.28888336f, 0.29060858f, 0.39128065f, 
    0.11584798f, 0.07248040f, -0.11362663f, -0.00749603f, 0.04249136f, -0.00670956f, 0.57102001f, -0.18482523f, 
    -0.35776615f, -0.03598150f, -0.02079791f, 0.06851045f, 0.06119930f, -0.03957123f, 0.04301285f, -0.21761742f, 
    -0.35614645f, -0.19273494f, -0.03523518f, -0.21944822f, -0.13976803f, -0.12352829f, 0.09370940f, -0.03882642f, 
    -0.34328702f, -0.32931837f, 0.16917416f, 0.15541497f, -0.15243387f, -0.05301448f, 0.24668801f, -0.07450862f, 
    -0.26379353f, -0.21894147f, -0.05612246f, 0.17418639f, -0.01725233f, 0.02610627f, 0.11336207f, -0.04472838f, 
    0.01105496f, -0.08993221f, 0.18781084f, 0.12083092f, 0.39565924f, 0.07824846f, -0.11515868f, 0.04183923f, 
    0.02026565f, -0.01887781f, 0.10222798f, 0.03155314f, 0.21882848f, -0.01584427f, -0.11753771f, 0.22067057f, 
    0.11094489f, 0.13429239f, 0.14761204f, 0.27182046f, -0.13762170f, -0.28566214f, -0.19065577f, 0.01293930f, 
    0.00917342f, -0.04928888f, 0.07679314f, -0.08830713f, 0.10753191f, -0.19686660f, -0.38094771f, -0.40134722f, 
    -0.21051583f, 0.07149065f, -0.06443884f, 0.02754903f, -0.19950970f, -0.16326721f, -0.08078656f, -0.21935238f, 
    -0.13979770f, 0.05950902f, -0.01084602f, 0.00861699f, -0.16750538f, 0.05551082f, 0.04397524f, -0.26305726f, 
    0.11854703f, -0.32357365f, 0.17998101f, 0.11406010f, -0.08735151f, 0.00734355f, 0.02789699f, -0.04367959f, 
    0.10971361f, -0.05210813f, -0.10047410f, 0.01360471f, 0.04071422f, -0.03663899f, -0.01438048f, -0.07768960f, 
    0.03983640f, -0.02899112f, -0.03833135f, -0.27174824f, 0.08368498f, 0.01700287f, 0.23397052f, 0.11546933f, 
    -0.06903751f, -0.05659413f, -0.02821063f, 0.13530837f, -0.05033374f, 0.02357963f, -0.06682504f, 0.15260677f, 
    -0.07578979f, -0.19438168f, -0.05298957f, -0.07996248f, -0.18079987f, -0.43745887f, 0.10924660f, -0.08095036f, 
    0.04739709f, -0.07787313f, -0.11172688f, -0.08642424f, -0.05010501f, 0.01540405f, 0.07852075f, 0.10543603f, 
    -0.01113505f, -0.11027808f, -0.09851865f, -0.05542737f, 0.14830138f, 0.04712809f, 0.20387734f, 0.00479553f, 
    0.02596830f, 0.19983372f, -0.15958153f, -0.08119781f, 0.01560338f, 0.00292114f, -0.17526074f, 0.02820972f, 
    -0.29872164f, -0.14588419f, -0.13578948f, 0.17167668f, 0.08545355f, 0.04851541f, -0.02686766f, 0.31142035f, 
    0.14744514f, 0.03585708f, -0.31664911f, 0.06912588f, -0.02071585f, -0.07739367f, 0.06386333f, 0.02454162f, 
    0.06478962f, -0.02877789f, 0.32237604f, -0.01470117f, -0.20966497f, -0.02947688f, -0.20301013f, 0.02603296f, 
    -0.12984988f, 0.42147532f, -0.01103621f, 0.09932655f, 0.12878151f, 0.08538495f, -0.14173768f, 0.09244721f, 
    0.06765542f, 0.05737614f, 0.14621732f, -0.02972309f, -0.04177830f, 0.02036726f, 0.11583260f, -0.08946609f, 
    0.02384871f, 0.10292004f, -0.08700404f, 0.18523446f, 0.19065091f, -0.21973054f, -0.07367233f, 0.00952941f, 
    -0.16338491f, 0.10756873f, 0.04312462f, 0.00829448f, 0.06793964f, -0.11466913f, 0.07538779f, -0.01985053f, 
    0.03898828f, -0.01261996f, -0.06998935f, -0.02870825f, 0.00528031f, -0.10070857f, 0.13265394f, 0.50968850f, 
    0.02988784f, -0.04924493f, 0.12146671f, -0.21178107f, 0.15013002f, 0.11530347f, -0.35335225f, -0.16265376f, 
    0.28769511f, -0.11187672f, 0.06426317f, -0.06851069f, -0.08298045f, 0.02581386f, 0.08186240f, 0.11041338f, 
    -0.15249106f, 0.28513590f, 0.12743071f, 0.13087834f, -0.02585956f, 0.06548025f, 0.02496395f, 0.00436633f, 
    -0.12186459f, 0.29739475f, -0.11732960f, -0.00023627f, -0.00091403f, -0.12028104f, 0.04090531f, -0.11245975f, 
    0.06673939f, 0.12838121f, 0.33776355f, -0.21727617f, 0.17361663f, 0.22129059f, -0.08815185f, 0.06827335f, 
    0.11156438f, -0.10951135f, 0.09528127f, 0.12301122f, 0.08497614f, -0.01167570f, 0.03040658f, -0.03919536f, 
    0.04562739f, 0.04071644f, 0.04835299f, -0.03198515f, -0.00776413f, 0.30369708f, 0.11547224f, 0.02317971f, 
    -0.09084244f, -0.11927200f, -0.00258169f, 0.05872662f, -0.03291316f, -0.36155486f, -0.18451904f, 0.02914892f, 
    -0.08816075f, 0.15840371f, 0.13357124f, 0.03562116f, 0.02700904f, -0.17164806f, -0.09232316f, -0.04340763f, 
    -0.26159593f, -0.04129862f, 0.02514223f, -0.00221119f, -0.00607410f, -0.04913287f, -0.26617131f, 0.05278590f, 
    -0.18316206f, 0.15398824f, -0.08389979f, -0.17709750f, 0.10317791f, -0.12549996f, -0.13845398f, -0.26100436f, 
    -0.55348599f, -0.18792380f, -0.14456829f, 0.08747374f, -0.30364823f, 0.08581987f, -0.10362949f, 0.20986387f, 
    -0.27354941f, -0.32527721f, 0.10068882f, 0.06613740f, 0.03207229f, -0.06454131f, 0.10497758f, -0.00057990f, 
    -0.11136331f, -0.02809564f, 0.05617176f, 0.00867737f, 0.00215800f, -0.03503761f, 0.02567985f, 0.15502845f, 
    0.07201385f, 0.21529327f, -0.18173547f, 0.00051854f, 0.02906539f, -0.12407639f, 0.10321783f, 0.18959601f, 
    -0.01733772f, -0.09727388f, 0.12959175f, 0.19399795f, 0.17020862f, 0.07725647f, -0.07127035f, -0.11711163f, 
    0.08067513f, -0.10821912f, 0.03458595f, 0.17549393f, 0.02735801f, 0.19259654f, -0.57194239f, 0.13959682f, 
    -0.10134783f, -0.02128839f, 0.15226477f, 0.15249309f, 0.01819846f, 0.02369699f, 0.06137320f, -0.43969139f, 
    0.07415687f, 0.06149122f, 0.20734000f, 0.02207724f, -0.18189555f, -0.09112688f, -0.03402304f, -0.30096152f, 
    -0.30984622f, 0.05442511f, 0.09988565f, -0.00004589f, -0.00791560f, 0.03656540f, -0.12476794f, -0.63805157f, 
    -0.38611236f, -0.00790187f, 0.06931285f, 0.13462925f, 0.08654819f, -0.02230507f, 0.05700027f, 0.00598024f, 
    -0.21001299f, 0.14673118f, 0.20206600f, 0.16088051f, 0.02099652f, -0.07409944f, 0.02409074f, 0.13884833f, 
    0.12849154f, -0.43464121f, -0.09453321f, 0.08240940f, 0.24246354f, 0.06576116f, 0.01819910f, -0.00784846f, 
    -0.02942024f, -0.01297629f, -0.22470781f, -0.10342599f, -0.02584259f, -0.11648310f, 0.11237390f, -0.09631257f, 
    -0.10008794f, -0.14469732f, -0.02875873f, -0.12632082f, -0.54212719f, -0.06737925f, 0.11320227f, -0.01475804f, 
    0.05829513f, 0.18122520f, 0.24290659f, -0.09588802f, -0.18012960f, 0.26203257f, 0.01892449f, 0.13543233f, 
    0.02822647f, 0.01116464f, -0.02415356f, -0.13862799f, -0.20637208f, 0.66484368f, -0.19365002f, 0.03667586f, 
    0.13002026f, -0.17188786f, -0.07647617f, -0.09569106f, -0.18791464f, 0.11169653f, -0.17548764f, -0.32672706f, 
    -0.08386728f, 0.11583570f, 0.01372778f, -0.03664305f, -0.14273410f, 0.02221028f, 0.17638139f, 0.02809766f, 
    0.00287685f, 0.01046816f, -0.11265791f, -0.18431403f, -0.07411821f, -0.03610998f, -0.03362368f, 0.01320168f, 
    0.09346599f, -0.05197874f, -0.07310518f, 0.03966277f, 0.01986097f, -0.09947635f, 0.02214682f, 0.15510625f, 
    0.17628150f, -0.21681142f, -0.07073458f, -0.13163562f, -0.10261770f, -0.03620804f, -0.00325401f, -0.05525608f, 
    -0.13965765f, 0.01823279f, 0.19521852f, 0.04494543f, -0.08878313f, 0.11391304f, -0.00464327f, 0.09548286f, 
    0.19357336f, 0.08533469f, 0.02552151f, -0.08521492f, -0.19179179f, -0.04807446f, -0.11516476f, -0.14470950f, 
    0.06572577f, 0.06293236f, -0.08258834f, 0.02409901f, -0.10774273f, 0.08826441f, -0.09351257f, 0.01728355f, 
    -0.07092288f, 0.10922556f, -0.14618601f, -0.09271742f, -0.07089918f, 0.19106495f, 0.35971570f, 0.01764911f, 
    0.29053137f, 0.13945329f, 0.07735497f, -0.15703331f, 0.06726933f, -0.06806420f, 0.23191263f, -0.13552120f, 
    -0.02479544f, 0.07871433f, 0.03311986f, -0.18809924f, -0.20147566f, 0.05985706f, 0.05052894f, 0.27001870f, 
    0.27741018f, -0.05441035f, 0.05347119f, 0.12555762f, -0.18498485f, 0.02716547f, 0.22203939f, -0.00758560f, 
    0.18136206f, 0.03370678f, 0.21247588f, -0.05176835f, -0.08222531f, 0.01919823f, 0.00866389f, -0.09385701f, 
    0.01297507f, 0.14171043f, -0.11508818f, -0.02417698f, 0.08474928f, -0.07100020f, -0.00605893f, 0.09664439f, 
    0.06357542f, 0.10691015f, 0.00156011f, 0.21285219f, 0.24662471f, 0.10256561f, -0.07390962f, -0.02493223f, 
    0.07520024f, -0.11538821f, 0.09715615f, -0.14010432f, 0.20265661f, 0.01012728f, 0.16581240f, 0.07638609f, 
    0.02384615f, -0.11288996f, -0.02354356f, -0.12054294f, -0.03336399f, -0.09605512f, -0.54002136f, 0.15318118f, 
    0.18626787f, -0.06253669f, 0.11620466f, -0.03142615f, -0.03387256f, -0.08501498f, -0.10470895f, -0.32537732f, 
    0.04327570f, -0.09694544f, -0.05971616f, -0.05832437f, 0.14135820f, 0.14734760f, -0.06745222f, 0.10456944f, 
    -0.07462637f, -0.06538462f, 0.08465282f, 0.01883060f, 0.03009716f, 0.13518193f, -0.02150704f, -0.21569736f, 
    0.19372553f, 0.17996785f, -0.15212555f, -0.05640139f, -0.05374065f, 0.09388480f, 0.06157758f, -0.12076996f, 
    0.03279512f, 0.03248394f, -0.22364938f, -0.23053217f, -0.15523805f, -0.09437803f, 0.00806908f, -0.15318383f, 
    0.11980971f, 0.04661653f, 0.34619299f, -0.55874950f, 0.01785434f, -0.15227808f, -0.01665077f, -0.03832177f, 
    0.04731332f, -0.08301243f, 0.19042706f, -0.23578680f, -0.00028015f, 0.17066115f, 0.09595055f, 0.10616544f, 
    -0.04164792f, -0.12267239f, 0.06805383f, -0.14262924f, -0.36704832f, -0.13692889f, 0.17236860f, 0.08206682f, 
    0.05734880f, 0.21882668f, 0.04523310f, 0.13623181f, -0.23351181f, -0.25342479f, 0.13850589f, -0.17078792f, 
    -0.02867975f, -0.08049375f, -0.00360938f, -0.06027716f, -0.19857296f, -0.26981091f, -0.11560065f, 0.15894531f, 
    -0.23339607f, -0.18573555f, 0.07484850f, -0.03080441f, 0.08936671f, -0.09369820f, -0.05358067f, 0.14520711f, 
    0.07420444f, 0.05409852f, 0.03759871f, -0.23260066f, 0.16883032f, -0.01326289f, 0.08349895f, -0.67110091f, 
    -0.01305565f, 0.44023257f, 0.06861933f, -0.03418115f, -0.25042224f, -0.03133567f, -0.13533437f, 0.17523715f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.27491692f, 0.15515113f, 0.05381955f, -0.06212521f, -0.05670840f, 0.11258524f, 0.04103570f, 0.00000112f, 
    0.19185875f, 0.04715454f, -0.11211077f, 0.29229486f, -0.13335593f, 0.15064986f, -0.02145184f, 0.03911829f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04254458f, -0.10140429f, -0.10902742f, 0.07559285f, 0.06546650f, 0.48108402f, 0.30237859f, 0.49874935f, 
    -0.27945685f, 0.08653520f, -0.11947490f, -0.23003832f, 0.47333235f, -0.63339651f, 0.36981630f, -0.00151210f, 
    0.27880257f, 0.08997213f, -0.18356118f, 0.17401618f, 0.24429671f, 0.45302373f, -0.37966266f, 0.17442213f, 
    0.09686793f, -0.07119021f, 0.10486257f, 0.09153020f, -0.21537964f, -0.09550349f, -0.23037259f, -0.41479269f, 
    0.49252573f, 0.50899833f, 0.20297843f, -0.01388259f, 0.07003441f, -0.07855118f, -0.35079750f, 0.17780744f, 
    0.27310723f, -0.02944396f, -0.01089399f, 0.05538191f, -0.07958615f, 0.05366688f, -0.47892803f, -0.39804536f, 
    -0.10028982f, 0.33473495f, 0.21148884f, 0.20455670f, 0.36740264f, 0.32523766f, -0.40814772f, -0.21597067f, 
    -0.07119651f, 0.21758050f, 0.21128933f, -0.00185739f, 0.29616025f, -0.11672803f, 0.13763244f, -0.34281650f, 
    0.01049755f, 0.12200087f, 0.09047601f, 0.09385138f, 0.21708414f, 0.61855650f, -0.01267618f, 0.10987015f, 
    0.36261037f, 0.20123155f, 0.03217338f, 0.21733207f, -0.30712721f, -0.43209055f, -0.07131127f, 0.19288000f, 
    0.53723860f, 0.18188088f, 0.13253137f, -0.01286695f, -0.56369811f, -0.09456791f, -0.42156413f, 0.13293250f, 
    0.01819952f, 0.07661817f, -0.12261731f, 0.15289539f, 0.04554911f, -0.00480040f, 0.27260256f, -0.36582831f, 
    0.06703368f, -0.16914204f, 0.14114079f, -0.22234857f, 0.28595248f, -0.24849400f, -0.07185366f, -0.10999256f, 
    0.20349239f, 0.11000852f, -0.01081410f, -0.11854950f, 0.06670848f, 0.31009778f, 0.32385784f, 0.12138259f, 
    0.10192823f, -0.34869823f, 0.11381674f, -0.00599458f, -0.61233479f, 0.11358440f, 0.10813604f, 0.22889642f, 
    0.28776824f, 0.14378694f, -0.10156760f, -0.00183114f, 0.01098765f, 0.06951566f, 0.46285138f, -0.38104668f, 
    -0.05718060f, -0.10539515f, 0.07172409f, 0.20797935f, 0.24851841f, 0.26536840f, -0.23539409f, 0.00410805f, 
    -0.03699104f, -0.03704599f, -0.09305435f, -0.16001157f, -0.28458342f, -0.37598109f, 0.07167589f, 0.53301722f, 
    0.29457852f, 0.36603677f, -0.22644532f, -0.19567730f, 0.37486526f, 0.20319590f, 0.48294425f, -0.52382195f, 
    -0.61845136f, 0.11640191f, 0.07203205f, -0.13400157f, 0.36668262f, -0.05596929f, -0.29703423f, 0.07519696f, 
    -0.32980335f, 0.56248313f, -0.05963141f, 0.23759733f, 0.22263540f, 0.03228386f, 0.34950262f, -0.49411660f, 
    0.24514917f, -0.11742749f, 0.02386915f, -0.01167028f, 0.25961071f, 0.50645483f, 0.24850842f, 0.33786151f, 
    -0.24123244f, 0.71293855f, -0.17707956f, -0.06138217f, 0.38603172f, 0.09717923f, -0.60148734f, -0.06252936f, 
    -0.12173464f, 0.01073927f, 0.21796067f, 0.49148515f, 0.10101403f, 0.18992017f, -0.53244251f, -0.31438047f, 
    0.10185172f, 0.06704085f, -0.08243561f, 0.02144888f, 0.27361584f, -0.04482907f, -0.69661558f, 0.17802224f, 
    -0.02329189f, 0.06971313f, -0.06614827f, 0.62215334f, -0.16015029f, 0.11925939f, -0.21259330f, -0.13034505f, 
    -0.18191813f, -0.10996003f, -0.09315619f, -0.06200030f, 0.35310012f, -0.47114003f, 0.43780291f, -0.47388875f, 
    0.26633835f, -0.21978362f, 0.02045059f, -0.02747004f, -0.20578031f, 0.68018597f, 0.21105194f, 0.19951813f, 
    0.26296476f, 0.02704005f, -0.15386224f, 0.01293659f, -0.17091314f, -0.38004994f, -0.06148798f, 0.54712480f, 
    0.25537398f, -0.19936110f, 0.15357737f, -0.18666285f, -0.05066327f, -0.11231354f, -0.02564961f, 0.60987991f, 
    0.23504338f, 0.29619175f, -0.12683272f, 0.16092530f, 0.10245398f, 0.01870507f, 0.16686796f, 0.54905576f, 
    -0.41981587f, 0.22138670f, 0.04108064f, 0.02260979f, 0.45110157f, -0.50229216f, 0.15713803f, 0.16907191f, 
    0.40180171f, 0.48994681f, -0.20808664f, -0.20291024f, 0.04013775f, -0.08017449f, -0.17472745f, 0.39986452f, 
    -0.38227767f, 0.00550229f, -0.19168331f, -0.25786093f, 0.21146360f, -0.03333254f, 0.19927381f, -0.04328205f, 
    -0.23020555f, 0.34895563f, -0.03464442f, 0.00435554f, 0.30224130f, 0.28427926f, 0.24083115f, 0.21140873f, 
    0.12023108f, 0.26562369f, -0.11944630f, 0.03767937f, 0.00167178f, 0.29334831f, -0.10861643f, -0.14304960f, 
    -0.05316032f, 0.42907363f, -0.20149520f, 0.19822182f, 0.51314312f, 0.15083431f, 0.69859225f, 0.03016614f, 
    -0.20423390f, -0.22540821f, 0.08975060f, -0.07688679f, 0.02443896f, 0.52201390f, -0.40801704f, 0.01735657f, 
    0.02573965f, 0.61732233f, -0.06425253f, 0.02957394f, -0.11278169f, 0.64068401f, 0.01254021f, -0.10865756f, 
    0.16726549f, 0.05482482f, 0.17199853f, 0.02270189f, -0.04193091f, 0.01640784f, -0.02631988f, -0.49776369f, 
    -0.02768342f, -0.49250093f, 0.06838480f, 0.19721025f, -0.24017155f, 0.57617682f, 0.33967841f, -0.56671697f, 
    0.45805320f, -0.11989868f, 0.12791553f, -0.14646320f, -0.11705896f, 0.40081495f, -0.31226051f, -0.41985732f, 
    -0.39654022f, -0.18079725f, -0.21610510f, 0.23711912f, 0.37477255f, 0.02100901f, 0.51486897f, -0.01115511f, 
    -0.02228604f, 0.19428419f, -0.10282928f, -0.11524135f, 0.39203987f, -0.23424588f, -0.05955402f, 0.14490756f, 
    0.15203767f, 0.50660968f, -0.06182513f, 0.19226676f, -0.07354008f, 0.31106883f, 0.23070417f, 0.10027120f, 
    0.13589379f, -0.10261729f, -0.03862859f, -0.12103602f, -0.19731055f, 0.16434322f, -0.09432065f, 0.18546456f, 
    0.08483913f, -0.10643893f, -0.03726193f, -0.21856952f, 0.56061709f, -0.01612997f, -0.18710980f, -0.58058596f, 
    0.12283591f, -0.24644162f, -0.13690589f, 0.40954441f, -0.22720501f, 0.18863054f, -0.19040687f, 0.15231070f, 
    0.08723845f, -0.10807238f, 0.04004300f, 0.08870932f, -0.05385519f, -0.19305028f, 0.18872787f, 0.30415112f, 
    0.42965040f, 0.00501972f, 0.23654477f, -0.21956414f, -0.15065862f, 0.36959299f, -0.35344231f, -0.08152901f, 
    0.46131298f, 0.02277725f, 0.00943571f, -0.22064848f, -0.13134170f, -0.21264772f, -0.29842988f, -0.30351073f, 
    0.21261567f, 0.06144957f, 0.07859555f, 0.33714771f, -0.30584624f, 0.04888299f, 0.11903767f, 0.25197953f, 
    -0.22005753f, -0.10728766f, 0.00444552f, 0.23591420f, -0.23307206f, 0.14608355f, 0.31244817f, -0.52683300f, 
    0.12215761f, -0.08041120f, -0.21054646f, 0.33787903f, 0.12673739f, 0.37551615f, -0.14195995f, -0.28998032f, 
    -0.34819263f, -0.71938515f, -0.04900017f, -0.16145271f, 0.02783683f, 0.35141763f, 0.04114844f, -0.05425894f, 
    -0.07136661f, -0.24518380f, -0.00864153f, -0.05700113f, 0.30685854f, 0.21940492f, 0.09424745f, 0.51143360f, 
    0.11126855f, 0.10423912f, 0.15958104f, -0.08089499f, 0.21931587f, 0.35801265f, -0.02121799f, -0.66482413f, 
    -0.05085921f, 0.05217221f, -0.09960238f, 0.46538776f, -0.07496166f, 0.10541872f, -0.13698426f, -0.28661409f, 
    -0.00005641f, -0.04754832f, 0.21112677f, -0.09750766f, -0.10322237f, 0.02137943f, -0.19617701f, 0.03423765f, 
    -0.12602711f, -0.24893877f, 0.01480344f, -0.15456766f, -0.00097471f, 0.04370794f, -0.05102132f, -0.02123925f, 
    0.09268053f, -0.21082105f, 0.10716939f, -0.09502374f, 0.44125134f, -0.11066442f, -0.20807138f, -0.21297675f, 
    0.42996731f, 0.03914506f, -0.24008234f, 0.25459987f, -0.38001648f, 0.67650783f, -0.22773255f, -0.07717603f, 
    -0.42296103f, -0.04517064f, 0.02964443f, -0.10166409f, 0.08247130f, -0.13692819f, 0.45882499f, -0.03636725f, 
    0.25489286f, 0.05486199f, -0.19915161f, -0.31048900f, 0.21936695f, 0.21141160f, -0.71301115f, 0.28101522f, 
    0.05204129f, 0.55398434f, 0.15379313f, -0.06782760f, 0.31529313f, -0.61877781f, 0.26766226f, -0.31585807f, 
    -0.22898954f, 0.18064007f, 0.18533057f, -0.27755499f, 0.43799219f, 0.19054718f, -0.17211376f, 0.97683400f, 
    0.16177428f, -0.23001176f, 0.03020597f, 0.03035310f, 0.33702365f, -0.03564927f, -0.42361534f, -0.70792317f, 
    0.15369090f, -0.02963873f, -0.23943101f, 0.45315710f, 0.23747669f, 0.46316138f, -0.02275121f, -0.42380801f, 
    0.20581034f, -0.12712482f, 0.06850556f, -0.15826145f, 0.43980739f, -0.48914769f, -0.14293069f, 0.19434172f, 
    -0.35511187f, 0.05876144f, -0.13258930f, -0.06848780f, 0.14135180f, 0.68113589f, 0.51466739f, -0.36674863f, 
    0.22633900f, -0.35701886f, -0.19851226f, -0.20472215f, -0.36892438f, 0.41974884f, -0.26173013f, -0.12484138f, 
    -0.05824601f, -0.11787693f, -0.08645836f, 0.29146466f, 0.28718531f, -0.27331412f, 0.19518563f, -0.53154325f, 
    -0.18499838f, -0.07941160f, 0.06275144f, 0.07429674f, 0.21301629f, -0.00609773f, -0.24513087f, -0.05553320f, 
    0.33787522f, 0.13944273f, -0.15200585f, -0.05273123f, -0.24251042f, 0.62080646f, 0.29696319f, 0.60787213f, 
    0.02259598f, -0.07222161f, -0.15257567f, 0.16602726f, 0.08079509f, 0.01126757f, -0.18651198f, 0.29765081f, 
    0.37683278f, -0.17050442f, 0.10938502f, -0.03180417f, -0.90972143f, 1.05241740f, -0.09246507f, 0.32314971f, 
    -0.17951855f, 0.33480948f, 0.00832757f, -0.10479991f, -0.18052429f, -0.01568249f, 0.49626499f, 0.12108570f, 
    -0.07840211f, -0.19639993f, -0.21785852f, 0.16227078f, 0.16891362f, -0.10023340f, -0.00437815f, -0.25272569f, 
    -0.36480695f, -0.52853996f, -0.02295473f, -0.15105756f, 0.12680820f, 0.14303483f, 0.12002285f, -0.53869808f, 
    -0.16712889f, 0.22298941f, -0.20168509f, 0.05847549f, 0.10154285f, 0.33445284f, 0.02443995f, 0.32768285f, 
    -0.04018817f, -0.11026442f, -0.07103726f, 0.18584499f, 0.12041067f, -0.23867087f, -0.10890163f, 0.00011226f, 
    -0.04538311f, 0.05959764f, -0.00123909f, 0.00734205f, -0.11508471f, -0.13213693f, -0.14505921f, -0.10650008f, 
    -0.13926990f, -0.19476105f, 0.13992751f, -0.13119286f, 0.00184319f, -0.16024022f, 0.49763590f, -0.44617426f, 
    -0.04589839f, -0.11798206f, -0.19221856f, 0.27484709f, -0.23300172f, 0.25650445f, -0.04860421f, -0.17617917f, 
    0.12691784f, -0.20563477f, 0.08976603f, 0.03911618f, -0.11453699f, -0.45113763f, 0.42330420f, 0.29423994f, 
    0.47535712f, -0.01571306f, -0.18101661f, -0.18121938f, -0.23747848f, 0.41823250f, -0.04630049f, 0.53714335f, 
    -0.11637377f, -0.24373503f, 0.09990299f, 0.18865353f, 0.25804588f, -0.19770150f, -0.02295408f, 0.14404918f, 
    0.18705139f, -0.17743376f, 0.15435305f, 0.15116508f, 0.13764033f, -0.46706057f, -0.14786538f, 0.29552701f, 
    0.13284028f, -0.31568861f, 0.12346035f, 0.23791121f, 0.45856902f, -0.20136163f, 0.16197379f, 0.29701570f, 
    0.11323021f, 0.14268573f, 0.25777805f, -0.04624046f, -0.06027286f, 0.22594178f, -0.04991689f, 0.40924868f, 
    -0.16029313f, 0.45726019f, 0.07155642f, -0.24172148f, -0.01568625f, 0.10083815f, 0.24670507f, -0.58339798f, 
    -0.07765668f, -0.09336734f, -0.18639185f, 0.47931191f, 0.07483564f, 0.49228776f, 0.15254007f, 0.17475750f, 
    -0.03322235f, 0.05325764f, 0.14797515f, -0.04628826f, 0.43728882f, -0.24728398f, 0.31893641f, -0.34558669f, 
    -0.02896963f, -0.20469633f, -0.11677188f, -0.06184018f, -0.29616582f, 0.50468183f, 0.02929549f, 0.34775332f, 
    -0.38319531f, 0.50681311f, -0.12194049f, -0.18240449f, -0.47072768f, 0.29161122f, -0.15601002f, -0.06229457f, 
    0.15479816f, -0.02700034f, -0.16861318f, 0.09706981f, 0.10172032f, -0.35559362f, -0.50532693f, 0.47128552f, 
    -0.08614259f, -0.08682234f, -0.15578648f, -0.02835074f, -0.25826496f, -0.06710213f, -0.21641409f, 0.10170349f, 
    -0.24395551f, -0.19789845f, 0.15976310f, -0.04482288f, -0.09504806f, 0.20649225f, -0.07131294f, 0.12492609f, 
    0.37097922f, 0.16519347f, 0.20461303f, -0.21048468f, -0.34325564f, -0.22413968f, -0.18452109f, 0.23782833f, 
    0.05862585f, 0.13449720f, 0.17255917f, -0.16254465f, -0.18535365f, -0.47115156f, -0.02174374f, 0.64386553f, 
    0.27115119f, 0.49393195f, -0.11205170f, 0.10874926f, -0.54642624f, 0.15072952f, 0.01998095f, 0.31318137f, 
    0.14897339f, 0.00309066f, -0.10335086f, -0.44001815f, 0.27419838f, 0.41931221f, 0.57939082f, -0.38386878f, 
    0.13459912f, 0.27234784f, -0.17042825f, 0.11149845f, 0.31376776f, 0.16560362f, 0.57345241f, 0.06428694f, 
    -0.45369413f, -0.17138535f, 0.27157024f, -0.26033804f, 0.28667396f, 0.17413990f, -0.56169397f, 0.18989603f, 
    0.37479442f, -0.02486740f, -0.18098664f, 0.18615216f, -0.05734311f, -0.12195341f, -0.07102188f, -0.16229200f, 
    0.45407519f, -0.17262515f, 0.18518494f, -0.02112948f, -0.34121767f, 0.80720705f, -0.03544597f, 0.10696153f, 
    0.07854915f, -0.53464270f, 0.24988407f, -0.08592081f, 0.52757847f, 0.19554400f, 0.24327002f, 0.35688519f, 
    -0.20805931f, -0.09156743f, -0.25415736f, -0.58671582f, 0.21338995f, -0.37493896f, -0.09124385f, -0.44459152f, 
    -0.17337596f, -0.11337972f, 0.01816779f, -0.02955714f, -0.01135807f, 0.15668598f, 0.30369323f, 0.28312084f, 
    -0.04520709f, -0.06728753f, 0.27231884f, 0.28342211f, 0.04954730f, 0.01859699f, -0.13446373f, -0.38077956f, 
    0.38037717f, -0.41486233f, 0.13724139f, -0.02707838f, 0.14439459f, -0.25323662f, 0.07229485f, -0.00874939f, 
    0.03643562f, 0.13282079f, 0.01902163f, 0.38222584f, -0.29129499f, -0.04116347f, -0.19275984f, -0.15577349f, 
    -0.52970642f, -0.08317471f, -0.11458179f, 0.15856536f, 0.19446951f, -0.02983385f, 0.29202077f, 0.13263026f, 
    0.35263008f, -0.14164084f, -0.07957327f, -0.32667860f, 0.05339380f, -0.08301398f, 0.12452728f, -0.63755447f, 
    -0.28772140f, -0.20655423f, 0.04799172f, 0.06789562f, 0.15499496f, 0.39823827f, -0.16058213f, 0.05111831f, 
    0.34800997f, 0.11964667f, -0.24237865f, 0.13202667f, -0.14563496f, 0.49564815f, 0.42978439f, 0.26711488f, 
    -0.01505278f, 0.08196052f, 0.14301771f, 0.08823213f, 0.14265275f, 0.06556053f, -0.10194191f, -0.03777833f, 
    -0.18875495f, -0.00215510f, -0.15238479f, -0.10085523f, -0.12957458f, 0.05411812f, -0.14342372f, -0.17249088f, 
    0.26989463f, 0.41366169f, 0.00872058f, -0.05044819f, 0.30109036f, -0.11677820f, -0.36228520f, -0.15558004f, 
    -0.12623812f, 0.08576261f, 0.04290562f, -0.23268363f, 0.32171538f, -0.07424778f, -0.20055439f, 0.00825404f, 
    -0.15223728f, 0.21823703f, -0.01722366f, -0.13834816f, -0.08328271f, 0.35272384f, -0.28233099f, 0.18770918f, 
    -0.02530368f, -0.22699679f, 0.02719644f, 0.30301607f, 0.31427714f, -0.70623648f, 0.11438102f, -0.46838444f, 
    -0.18417600f, -0.45462310f, 0.11191052f, -0.00489471f, 0.12765004f, -0.36165896f, -0.08625430f, -0.06634748f, 
    -0.26132113f, 0.01847567f, -0.07474429f, 0.52484065f, 0.46764803f, 0.31561047f, 0.38866624f, 0.00330266f, 
    -0.29276016f, -0.17001973f, 0.12832695f, 0.22995159f, -0.15419166f, -0.16692130f, -0.31796041f, -0.02506839f, 
    0.03163498f, -0.21099550f, 0.14120251f, -0.07246984f, -0.03839221f, 0.18482620f, -0.29435152f, 0.02136109f, 
    0.47180900f, 0.38702685f, 0.22734749f, -0.17137775f, 0.22478513f, -0.43152466f, -0.12606296f, -0.00865674f, 
    0.06402425f, 0.01910297f, 0.20203769f, -0.12766883f, -0.25497112f, 0.10919101f, -0.25016180f, 0.04671790f, 
    0.00794035f, -0.41662022f, 0.02313921f, -0.19941965f, 0.29329810f, -0.01441548f, -0.04404871f, -0.48664197f, 
    -0.03864972f, 0.00671608f, 0.19875149f, 0.36879742f, 0.46448007f, -0.22263683f, 0.23700248f, 0.27195406f, 
    -0.09100995f, -0.17610095f, 0.12943268f, 0.13686091f, -0.05958478f, -0.32297313f, 0.08590789f, -0.11471820f, 
    -0.07930360f, -0.18153742f, -0.12830323f, -0.16843334f, -0.25731915f, -0.18331364f, -0.02649961f, 0.14601661f, 
    0.25950563f, -0.63737446f, -0.17875251f, 0.15131502f, -0.30110821f, 0.29399049f, -0.26493260f, 0.43193752f, 
    -0.17866516f, -0.16584267f, -0.03098520f, 0.18599422f, 0.30314818f, -0.60427874f, 0.19633131f, -0.41706347f, 
    0.07229727f, -0.05706266f, -0.05111876f, 0.10425633f, 0.10775416f, 0.62444276f, -0.02472397f, -0.19585824f, 
    -0.38244370f, 0.17632335f, 0.16661969f, -0.19772983f, 0.44801497f, -0.57765728f, 0.69259155f, -0.05842684f, 
    -0.14135127f, 0.48259744f, 0.15247023f, -0.12088963f, 0.46148998f, 0.02545153f, -0.06926811f, -0.14635272f, 
    0.04415118f, -0.04332826f, -0.09473363f, 0.37693143f, 0.03824656f, 0.44222102f, -0.34056073f, -0.02161857f, 
    -0.18135841f, -0.18439277f, 0.24480259f, 0.00649473f, 0.10656613f, -0.00672299f, -0.02224618f, 0.46952575f, 
    0.33050644f, 0.00184414f, -0.08619216f, 0.09686999f, -0.16485354f, -0.30973992f, 0.05284700f, 0.43240190f, 
    0.16117303f, -0.22378814f, 0.15933156f, -0.23228820f, -0.36771050f, -0.11477960f, 0.41527396f, 0.09715702f, 
    -0.32101795f, -0.08319443f, 0.11285812f, 0.30210572f, 0.10747893f, -0.15291764f, -0.09609309f, -0.13097681f, 
    0.46418354f, -0.11540414f, 0.06143090f, 0.00297841f, 0.04629293f, 0.10679821f, -0.34168473f, -0.43308750f, 
    0.03410071f, 0.14108016f, 0.05217259f, 0.35017312f, 0.10783193f, -0.19689959f, 0.20424010f, -0.07562381f, 
    0.05544101f, 0.22816287f, 0.10600963f, 0.14860934f, -0.11864182f, -0.40041971f, 0.24346875f, -0.00110225f, 
    0.36472750f, -0.09579486f, -0.15895508f, -0.19283684f, 0.06901471f, 0.40389132f, 0.31172088f, 0.54245955f, 
    -0.31533724f, 0.44821233f, -0.07706255f, -0.19403595f, 0.22320110f, 0.50235218f, 0.09304906f, 0.13401538f, 
    -0.19346085f, -0.19421846f, -0.27886635f, -0.02839283f, 0.46790695f, -0.37653238f, 0.22502761f, 0.37796360f, 
    -0.25168040f, -0.46386179f, -0.14070833f, 0.17859358f, 0.59931862f, -0.11630674f, 0.28429812f, 0.33154482f, 
    0.19676761f, 0.06032395f, -0.08984459f, -0.25338772f, -0.24343745f, 0.22977507f, -0.20000102f, 0.25164956f, 
    0.01373544f, 0.29647267f, -0.10332212f, 0.04226934f, 0.04294885f, -0.22856452f, 0.12927465f, 0.17145538f, 
    0.21352275f, -0.15345380f, -0.20238507f, 0.05439333f, -0.25682187f, 0.61873573f, -0.09071447f, 0.55524909f, 
    0.20622450f, -0.00617230f, 0.05348638f, -0.09783980f, -0.01723558f, 1.02556515f, -0.03786967f, -0.30351982f, 
    0.16890207f, -0.23831996f, -0.03860632f, -0.24447648f, -0.06136146f, 0.44191828f, -0.57775891f, 0.61813253f, 
    0.23030394f, -0.28305233f, -0.21793243f, 0.17126204f, 0.25151774f, 0.31861788f, -0.27418441f, -0.30918369f, 
    -0.15325207f, -0.14739372f, 0.20458890f, 0.30406675f, 0.08453058f, -0.17117269f, 0.31197909f, -0.36738241f, 
    0.15585457f, -0.03153223f, -0.07365185f, 0.22027774f, 0.07136870f, 0.23493628f, -0.36616170f, 0.20777935f, 
    0.29567689f, 0.21241985f, -0.12650214f, 0.37509623f, -0.22551805f, -0.54312539f, -0.16336417f, -0.35035190f, 
    -0.02637078f, -0.15042961f, -0.18337777f, -0.19591373f, -0.27857113f, 0.10449070f, -0.00875548f, -0.08258723f, 
    0.03837836f, 0.22410706f, 0.09754968f, 0.01734462f, -0.20652546f, -0.14085434f, 0.01934091f, -0.20547847f, 
    0.25502118f, 0.00359048f, 0.18855834f, 0.05092990f, -0.46842813f, 0.10138833f, 0.33048686f, 0.49767041f, 
    -0.11314076f, -0.08808735f, 0.00145831f, 0.04993283f, 0.17998013f, 0.00065482f, -0.37922931f, -0.26775870f, 
    0.28651342f, 0.10159828f, 0.17524648f, 0.21876578f, -0.11359808f, 0.11510299f, 0.13438660f, -0.31809741f, 
    0.02765829f, 0.08464314f, 0.08340745f, 0.26132351f, -0.18988366f, 0.05302566f, 0.02911239f, -0.28572533f, 
    0.27783704f, 0.10917854f, -0.13304603f, 0.04046902f, 0.06510006f, 0.49175984f, -0.32508156f, 0.37193787f, 
    0.10696870f, -0.06550699f, -0.20592782f, -0.66762763f, -0.22448163f, -0.56623304f, 0.17851806f, -0.04550191f, 
    0.19091891f, -0.22368757f, -0.21332186f, 0.05748147f, 0.41069570f, 0.15014926f, -0.49103948f, 0.38551953f, 
    -0.26947886f, 0.18474153f, 0.14259216f, -0.02481827f, 0.51005399f, -0.16368040f, -0.21108922f, 0.17115523f, 
    0.31594458f, 0.45604074f, 0.21368146f, -0.00847037f, 0.15243487f, -0.42531636f, 0.22630884f, 0.09255445f, 
    0.17304514f, 0.23122561f, -0.14284655f, 0.00219916f, -0.24532162f, 0.57074648f, -0.36094874f, 0.14692359f, 
    0.24957505f, 0.24229072f, -0.03059053f, 0.16637237f, -0.09906095f, -0.25720569f, 0.03201419f, -0.06204878f, 
    0.33563408f, 0.15326358f, 0.03938269f, -0.09013161f, -0.20421661f, 0.43129757f, -0.17059383f, 0.16269511f, 
    0.09343985f, -0.32854384f, 0.20038447f, -0.09021797f, -0.20868181f, -0.47462639f, 0.43913960f, 0.28626716f, 
    0.37389973f, 0.21557447f, 0.02543483f, 0.18513247f, -0.20951585f, 0.90505284f, -0.32275692f, -0.85693592f, 
    -0.34146959f, 0.62191069f, -0.19204640f, -0.19926308f, 0.52875715f, 0.41287848f, 0.10440947f, -0.33331034f, 
    0.02255661f, 0.10174140f, 0.10226395f, 0.53394341f, 0.27633691f, 0.35018805f, -0.08269858f, -0.17211339f, 
    0.27213442f, -0.02084314f, -0.23748896f, 0.17245078f, -0.03630519f, 0.26266164f, 0.15474622f, -0.00632392f, 
    -0.25400883f, 0.22449085f, 0.16141076f, 0.18134265f, 0.13206783f, -0.59505284f, 0.00025859f, -0.40064847f, 
    0.26301673f, -0.47070485f, -0.10693735f, 0.20400786f, 0.29512143f, -0.16043615f, -0.06466571f, 0.00464374f, 
    -0.00880497f, -0.12677698f, 0.01118302f, 0.49135798f, -0.25389716f, 0.24836069f, -0.18479131f, -0.21748303f, 
    -0.17442204f, -0.14249049f, 0.19026580f, -0.12656757f, -0.03179353f, -0.52117032f, 0.01277009f, -0.52201587f, 
    0.41474712f, -0.03395549f, 0.00350524f, 0.30926836f, 0.16314274f, -0.14716946f, 0.18544392f, 0.35608816f, 
    0.15002120f, -0.45874935f, -0.11477497f, 0.07933573f, -0.35282367f, 0.44480649f, -0.11093686f, 0.10286998f, 
    0.07945508f, 0.23006931f, -0.03968653f, 0.13350093f, -0.09256573f, -0.71932805f, 0.31008142f, 0.14625351f, 
    0.05726603f, -0.21697965f, -0.18296126f, 0.00487131f, -0.24260634f, 0.19930741f, -0.05274162f, -0.19018877f, 
    -0.15234688f, -0.22697398f, -0.05057973f, -0.20569727f, -0.06136596f, -0.21280351f, 0.06476706f, -0.21145406f, 
    -0.27577010f, -0.07911903f, -0.17845351f, 0.15821412f, 0.07959449f, -0.16296172f, 0.18329914f, 0.18903758f, 
    -0.09402707f, -0.08744615f, -0.07062409f, 0.35133615f, 0.18769258f, -0.35377014f, -0.48816410f, -0.21227969f, 
    0.21773328f, 0.28052813f, 0.14103422f, -0.15835494f, -0.15857135f, -0.36774325f, 0.36408827f, 0.35032079f, 
    -0.23063056f, 0.11104259f, 0.08422030f, 0.31706819f, 0.16630466f, -0.34232965f, -0.36633456f, 0.18082750f, 
    0.18151975f, -0.74810559f, -0.19273013f, -0.10730311f, -0.12988420f, -0.10589330f, 0.10288233f, 0.48495856f, 
    -0.10248994f, 0.02217895f, 0.13574862f, 0.31264436f, 0.18276587f, -0.15258150f, 0.19037451f, 0.52071822f, 
    -0.43310344f, -0.16858430f, -0.13767293f, -0.14213093f, -0.17332456f, 0.41540453f, 0.51918244f, 0.34975651f, 
    0.00674823f, 0.23158005f, 0.12119536f, -0.17867899f, 0.11927913f, -0.08218664f, 0.41267690f, 0.33539397f, 
    -0.17067698f, 0.51712579f, 0.21119291f, -0.10906903f, 0.20979567f, 0.11343288f, -0.34481150f, -0.43208292f, 
    -0.03276784f, -0.07198643f, -0.12666716f, 0.37898025f, 0.15196005f, -0.17356184f, 0.02926145f, -0.33552882f, 
    0.47936338f, 0.11038238f, 0.13558549f, 0.15047182f, -0.27105680f, 0.16467457f, 0.07420440f, -0.03117435f, 
    -0.11568795f, 0.19909343f, -0.03491966f, -0.21521935f, 0.16428478f, 0.20150591f, 0.26676515f, -0.21532872f, 
    0.12996647f, 0.35542962f, 0.01995286f, -0.18037745f, 0.19133076f, 0.20466086f, 0.27413324f, 0.34289202f, 
    0.02299802f, 0.13855273f, -0.18010989f, -0.29078493f, -0.03647822f, 0.24376835f, 0.08264365f, 0.21152961f, 
    -0.36372688f, 0.21142070f, -0.04513621f, -0.15409699f, -0.30322495f, 0.08345536f, 0.33921507f, 0.70745754f, 
    0.05648037f, -0.09229121f, 0.22387435f, -0.26772916f, 0.32726905f, 0.18217418f, 0.26961356f, 0.54387778f, 
    0.04847379f, -0.14932054f, 0.16870698f, 0.01189873f, 0.24809718f, -0.23817486f, 0.29166681f, -0.26546857f, 
    -0.10105541f, 0.06904107f, -0.07175554f, 0.11727075f, 0.09536926f, 0.70254165f, 0.25067839f, -0.68534976f, 
    -0.19054231f, 0.30970147f, 0.24604261f, -0.13648658f, 0.31348306f, 0.31357184f, -0.55144387f, -0.16489309f, 
    -0.16666210f, 0.19044258f, -0.23401818f, -0.01110959f, 0.57913786f, -0.17239669f, 0.15655752f, -0.08060148f, 
    0.24773641f, 0.03836857f, 0.01564392f, -0.18567057f, 0.39937553f, -0.18566906f, 0.27135181f, -0.33230907f, 
    0.13526826f, 0.04591678f, -0.09012733f, -0.08754861f, -0.06056144f, 0.74868292f, 0.11367860f, -0.01633150f, 
    0.08525042f, 0.34589452f, 0.03429890f, 0.02101312f, 0.07337923f, -0.37557340f, 0.42270225f, -0.16263135f, 
    0.46675408f, -0.01994057f, 0.21451184f, -0.10516226f, -0.09596480f, 0.75387365f, -0.30366817f, -0.28325266f, 
    0.45573893f, -0.08321112f, -0.11654949f, 0.11933622f, -0.28624663f, -0.06073724f, -0.06610267f, -0.36044908f, 
    0.21815264f, 0.06372475f, -0.11134305f, -0.15920109f, 0.21983358f, 0.39680770f, 0.25597697f, 0.08392291f, 
    -0.06039131f, -0.16900566f, -0.07921404f, 0.07959808f, 0.15505859f, 0.03159883f, 0.06566869f, 0.12344097f, 
    0.04379340f, 0.25074375f, 0.05228816f, 0.11842381f, -0.09779001f, 0.75236797f, -0.15489790f, -0.30645460f, 
    -0.19553792f, -0.27374008f, -0.22075120f, -0.18680272f, 0.42873111f, 0.03712851f, 0.23968087f, 0.24683771f, 
    0.29424849f, -0.17841510f, -0.21389738f, 0.03430275f, -0.22696753f, -0.38087836f, -0.05403475f, 0.33551672f, 
    0.01597488f, 0.00239269f, 0.22233665f, -0.07811885f, 0.14632827f, 0.35901806f, 0.39868960f, 0.44440132f, 
    -0.05599144f, -0.19524083f, 0.14360647f, 0.08371183f, -0.59356761f, 0.36469865f, -0.40721527f, 0.03191345f, 
    0.21207096f, -0.13920914f, 0.03431743f, 0.04567769f, -0.29254594f, 0.30965722f, -0.05730388f, 0.30784658f, 
    0.02457312f, -0.13664840f, 0.22203638f, -0.01298481f, 0.29589212f, -0.69487637f, -0.05405376f, 0.42688480f, 
    -0.30577126f, -0.08603047f, -0.02283791f, -0.01216590f, 0.42742354f, 0.23277275f, -0.17670394f, -0.05866741f, 
    -0.00417114f, 0.24028736f, 0.04967358f, 0.40708593f, -0.00568285f, 0.37795269f, 0.35254645f, 0.51822829f, 
    -0.53366947f, -0.10397080f, -0.13939735f, 0.07707676f, 0.15132324f, 0.17516702f, 0.32421651f, 0.27508497f, 
    -0.19319330f, -0.13653377f, -0.04112232f, -0.00981798f, 0.31030270f, -0.56004500f, 0.30833605f, 0.18405034f, 
    0.19116956f, 0.14440984f, -0.00542104f, -0.22601368f, 0.04977683f, -0.37346238f, 0.07474376f, 0.34551063f, 
    0.34161350f, -0.13362524f, -0.21348326f, -0.24167131f, -0.37124187f, 0.66854620f, -0.02334869f, 0.64284980f, 
    -0.01061122f, -0.05935933f, -0.10198531f, -0.13154316f, 0.27609667f, 0.03223366f, 0.09343734f, -0.14695877f, 
    -0.02185725f, 0.01286015f, -0.18800093f, -0.04480821f, -0.22888233f, -0.48251528f, -0.21238711f, 0.63441050f, 
    0.23420221f, -0.02333318f, -0.10038060f, -0.02244352f, 0.05749996f, -0.05136121f, -0.43022555f, 0.13679816f, 
    0.41590896f, -0.10450877f, 0.24890220f, 0.06915685f, -0.00227815f, -0.04428336f, -0.03976017f, 0.08127879f, 
    0.44354296f, 0.08226667f, -0.22389632f, 0.03083694f, 0.09524989f, -0.42723477f, -0.34036532f, -0.08209252f, 
    0.17147401f, -0.14343195f, 0.00348724f, -0.11052915f, 0.40545711f, 0.23694022f, 0.13175380f, -0.14657444f, 
    0.31379020f, 0.17190066f, -0.22589689f, -0.17487252f, -0.54480124f, 0.05844598f, 0.12996273f, -0.00261750f, 
    0.08513550f, 0.22216532f, -0.05176435f, 0.03277615f, -0.30621147f, 0.39403084f, 0.19810361f, -0.18742268f, 
    0.40525642f, 0.20682095f, 0.12388521f, -0.02852528f, 0.51857024f, -0.79009742f, -0.11504226f, -0.25855458f, 
    0.13381797f, -0.20584713f, -0.20211442f, -0.21345253f, 0.13401243f, 0.74736631f, 0.13980584f, 0.10712932f, 
    -0.16586453f, 0.16732758f, -0.11367100f, 0.00175115f, -0.21101451f, 0.46595213f, -0.23245297f, -0.55845165f, 
    0.27319196f, -0.18023840f, -0.13335301f, 0.65638220f, -0.48203996f, 0.44270274f, -0.35073566f, -0.02832050f, 
    0.03437356f, 0.10226686f, 0.18642920f, 0.13123661f, -0.06416964f, -0.10362317f, -0.01986890f, 0.42621005f, 
    0.15963086f, 0.14917907f, 0.03332326f, -0.00471656f, -0.07502618f, -0.65021276f, -0.11428369f, 0.15302761f, 
    -0.28573862f, -0.45351571f, 0.18121344f, 0.16509990f, 0.25536561f, -0.22053148f, 0.41272026f, 0.01368630f, 
    0.12231058f, -0.20418426f, -0.14648592f, 0.44092268f, 0.03842954f, -0.28459200f, -0.16976376f, 0.30112654f, 
    0.42188185f, -0.01521454f, -0.14006862f, 0.07127216f, 0.06875573f, -0.06282546f, -0.33792517f, 0.35158765f, 
    -0.08405967f, -0.08759330f, -0.10982364f, -0.16071251f, 0.61205149f, -0.36871815f, 0.20940167f, 0.14745246f, 
    0.20023257f, 0.04494858f, 0.11167797f, -0.24022152f, -0.20759261f, 0.19721822f, 0.14915022f, 0.15010317f, 
    0.17030677f, -0.04783746f, -0.15448037f, -0.33119470f, -0.09030602f, 0.40018633f, 0.35792223f, 0.49437994f, 
    -0.32532474f, 0.28465939f, -0.11118338f, -0.24206269f, 0.03546897f, 0.43598086f, 0.37831283f, -0.01873459f, 
    -0.13688348f, 0.13128096f, 0.00842719f, 0.51708198f, 0.38180360f, -0.14388908f, -0.04347295f, -0.41531077f, 
    -0.40133929f, -0.17678849f, 0.15143976f, -0.15554860f, -0.24613768f, 0.14172122f, 0.08051376f, 0.55437362f, 
    -0.14417182f, -0.17558920f, -0.17870989f, 0.01715584f, -0.00895783f, -0.39833206f, 0.01074041f, 0.88404155f, 
    0.25364953f, 0.35131907f, -0.13364282f, -0.15789250f, -0.37223125f, 0.31876007f, 0.30693406f, -0.00884133f, 
    -0.17758822f, 0.08015136f, 0.02059755f, 0.08805721f, 0.16691414f, -0.04753187f, 0.01689997f, -0.39045477f, 
    0.06204119f, -0.06419830f, 0.03821278f, 0.20191082f, 0.01113437f, -0.21438137f, 0.25860843f, 0.48059049f, 
    0.44668949f, 0.15909477f, -0.18810676f, -0.28858232f, -0.19229351f, 0.60836816f, -0.17549780f, -0.22146621f, 
    0.26875994f, -0.22920178f, 0.09180743f, -0.20613688f, -0.52207893f, 0.25339690f, 0.43012023f, 0.14676005f, 
    0.05220906f, -0.07343702f, -0.10994899f, -0.08193858f, -0.31473440f, 0.12421448f, 0.14742428f, -0.04697603f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10342117f, 0.62108129f, 0.15676875f, 0.39165142f, 0.55883449f, 0.37652007f, 0.06902284f, -0.08034139f, 
    -0.04686529f, 0.05641124f, 0.11499164f, 0.73961288f, 0.25821280f, 0.00181147f, -0.29651704f, -0.39348444f, 
    0.17301899f, 0.27122599f, -0.11519282f, 0.40074423f, -0.48206005f, 0.02482209f, 0.38859627f, 0.35166410f, 
    0.43412054f, 0.50861144f, -0.01018528f, -0.02812686f, 0.22887106f, -0.17294765f, 0.17853853f, 0.03205650f, 
    -0.09633531f, 0.12747331f, -0.66739434f, 0.35452339f, -0.18274240f, 0.12923777f, 0.29976630f, 0.23155108f, 
    -0.26398855f, -0.02339959f, -0.12441484f, -0.05264451f, -0.21534060f, 0.17468372f, 0.02921068f, 0.11935902f, 
    0.20870183f, 0.47085270f, 0.07278579f, 0.11533895f, -0.08825141f, -0.23738398f, 0.47596449f, 0.61621726f, 
    0.46204498f, 0.20974961f, -0.17984274f, 0.35680300f, 0.04313346f, -0.62753928f, 0.17024845f, 0.58686954f, 
    -0.35096672f, 0.02448584f, 0.23174863f, 0.25147319f, 0.09987882f, 0.20321628f, 0.48943016f, 0.18332714f, 
    -0.15685666f, -0.40311566f, 0.29053682f, -0.01978072f, 0.09357832f, 0.27499321f, 0.56584889f, -0.24337243f, 
    0.28926209f, 0.36571026f, 0.05612320f, 0.28935212f, 0.10431619f, 0.22461405f, -0.09529285f, 0.32946861f, 
    0.48808247f, -0.30405059f, -0.13169220f, 0.15736814f, -0.22717121f, 0.26549736f, -0.33778286f, -0.42002025f, 
    -0.11246412f, 0.67065805f, 0.57752395f, -0.15984163f, -0.10769450f, -0.18116915f, 0.42402038f, -0.31495970f, 
    0.05470249f, 0.41365871f, 0.42545539f, 0.43425444f, 0.13246624f, 0.05249807f, -0.27348271f, 0.17808340f, 
    0.14491715f, -0.01270300f, -0.28427216f, -0.04053881f, 0.70754343f, -0.01980563f, 0.13055374f, 0.42899552f, 
    -0.00907508f, -0.07317826f, 0.12680745f, 0.05887749f, -0.06324297f, 0.36621678f, 0.23635520f, 0.32018340f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24050683f, 0.12333080f, 0.17052844f, 0.09915178f, 0.13792220f, -0.28025439f, 0.20591867f, -0.46723756f, 
    0.50954616f, -0.01404496f, 0.14914696f, 0.21071400f, 0.02794550f, 0.32067996f, -0.15314239f, -0.32668835f, 
    -0.32001010f, 0.06907449f, 0.21231110f, -0.08193287f, -0.96631795f, 0.22158928f, -0.02560972f, 0.30093306f, 
    0.11234508f, -0.04686546f, -0.09954600f, -0.09688970f, 0.02841563f, -0.00678611f, 0.25227597f, -0.93405038f, 
    0.15839835f, 0.15735471f, -0.43203294f, -0.23580416f, 0.15304945f, -0.69904470f, -0.09039088f, 0.41631252f, 
    -0.04976838f, -0.13268284f, 0.02333223f, 0.09175409f, 0.23043056f, -0.07904319f, 0.26214328f, -0.55242282f, 
    -0.00808918f, 0.07982668f, -0.39831883f, -0.10338921f, 0.10925427f, -0.51296753f, -0.05398659f, 0.17969339f, 
    0.38861775f, -0.03593618f, 0.04946366f, 0.17141050f, -0.35527325f, -0.26218891f, 0.05299772f, 0.30029631f, 
    0.00089038f, -0.04657749f, -0.37527123f, -0.32379186f, 0.10040592f, 0.03684590f, -0.17094329f, -0.08056612f, 
    -0.02603905f, -0.27466691f, 0.54627627f, 0.04031049f, -0.54848611f, 0.02794280f, 0.01255543f, -0.04935872f, 
    -0.18183167f, -0.05403915f, -0.42444649f, 0.19092685f, 0.15175515f, 0.07264464f, 0.09210503f, 0.16809992f, 
    -0.11135965f, 0.01383817f, 0.14992562f, -0.20852411f, 0.02349583f, -0.00716407f, -0.28260639f, -0.32949743f, 
    -0.14305957f, 0.09098305f, -0.07907511f, 0.00939301f, -0.39600682f, 0.19510344f, 0.21240239f, 0.17410195f, 
    0.29783052f, -0.07369576f, 0.11217828f, 0.25411993f, 0.12051773f, -0.41042614f, 0.05222556f, -0.00654053f, 
    0.07123828f, 0.15795010f, -0.03835748f, 0.01966226f, -0.20724212f, 0.30318162f, -1.35816073f, 0.01137132f, 
    0.06783535f, -0.24527296f, -0.14476739f, -0.07072416f, -0.08858316f, -0.11662874f, 0.16236174f, 0.02974001f, 
    -0.11342376f, -0.00381132f, -0.22602300f, -0.15077055f, -0.00597858f, -0.50226700f, 0.09884658f, -0.09598959f, 
    -0.11550532f, 0.29719245f, 0.08659906f, -1.13291478f, -0.20981491f, 0.27458635f, -0.04827594f, -0.03360238f, 
    0.02882302f, 0.12015720f, 0.34441885f, -0.03084277f, 0.35345659f, -0.05011855f, 0.08030088f, -0.00595990f, 
    0.04392334f, -0.25992405f, 0.23826855f, -0.58931369f, 0.07345060f, -0.00765040f, 0.07245556f, 0.29999247f, 
    0.38002887f, -0.11460153f, 0.18692276f, -0.27941513f, 0.07878001f, 0.68092650f, 0.04141625f, 0.01911781f, 
    -0.10639390f, 0.41356471f, 0.17572172f, -0.13274108f, 0.09594240f, 0.19555585f, 0.09536684f, -0.56203103f, 
    -0.04438603f, -0.30606258f, -0.02952388f, 0.09337322f, 0.14398251f, 0.01678745f, -0.00248931f, 0.02475300f, 
    0.12609057f, 0.13571694f, -0.05524432f, 0.04833433f, -0.25919804f, 0.02018193f, -0.02721399f, -0.21472560f, 
    -0.03274858f, -0.11147501f, -0.24431391f, -0.00373675f, 0.04317455f, -0.04426819f, 0.04624392f, -0.27568254f, 
    0.14594959f, -0.17483424f, -0.04367340f, 0.09530922f, 0.28923953f, -0.14692941f, -0.08706609f, 0.07834015f, 
    -0.22492167f, 0.02845395f, 0.44010657f, -0.15810636f, 0.05027380f, 0.02176909f, 0.25470811f, 0.09680752f, 
    -0.20109527f, 0.11460581f, 0.08515459f, -0.10581143f, 0.03846670f, -0.11803889f, -0.01747845f, 0.01677400f, 
    0.14628321f, -0.25169566f, -0.03908300f, 0.12063467f, 0.10954218f, 0.12301445f, 0.13380925f, 0.16287425f, 
    0.22399281f, -0.06959793f, 0.18057309f, -0.00027421f, 0.32638478f, -0.53523368f, -0.02701445f, -0.09851395f, 
    0.14454333f, -0.41898793f, -0.12563835f, -0.28730536f, 0.03182367f, -0.05579155f, 0.27336094f, -0.22541159f, 
    0.01665372f, 0.05637714f, 0.01319764f, 0.04057495f, -1.26913345f, 0.03491715f, 0.09835733f, 0.11490656f, 
    0.33267310f, -0.08086857f, -0.19825159f, -0.59813869f, -0.00522346f, 0.17097083f, -0.67683727f, 0.07635117f, 
    0.10950414f, 0.49536046f, -0.13608874f, -1.68437922f, -0.01379073f, 0.25964928f, 0.09490506f, 0.28737256f, 
    -0.10496318f, 0.16727602f, 0.46989313f, -0.18271945f, 0.13371025f, 0.41379264f, -0.00863187f, -0.27305010f, 
    0.07068647f, -0.75368398f, -0.10679868f, 0.33470687f, -0.36747769f, 0.02520426f, -0.29673022f, 0.74747562f, 
    0.28388894f, -1.12257957f, -1.12447739f, -0.02486960f, -0.16779867f, -0.40585738f, 0.44114310f, 0.35249242f, 
    -0.09583233f, 0.12042444f, 0.14377889f, 0.14311527f, 0.14064555f, -0.07138396f, 0.27293143f, -0.21398176f, 
    0.03098805f, -0.26585120f, -0.19405589f, 0.60341734f, -0.72179925f, -0.08231087f, 0.34962657f, -0.01388196f, 
    0.26077411f, -0.19186601f, 0.04234075f, -0.32162714f, 0.10494065f, -0.33231053f, 0.05825233f, -0.24183375f, 
    -0.51385283f, 0.06403837f, 0.17684175f, -0.72262692f, -0.07474227f, 0.16835374f, 0.30053365f, -0.90139621f, 
    -0.17810670f, 0.05528881f, 0.33074266f, -0.00046338f, -0.30833647f, -0.46380794f, -0.05517218f, -0.18321781f, 
    0.39112487f, -0.22836873f, -0.59973222f, 0.06079023f, 0.02396124f, -0.27479598f, 0.08701890f, -0.13237019f, 
    -0.01174694f, -0.12210905f, -0.37317726f, -0.06488880f, -0.04733906f, 0.37722912f, 0.36740968f, 0.26223171f, 
    0.37937224f, -1.45109367f, -0.26275218f, 0.13570212f, 0.34209511f, -0.51041782f, -0.84363884f, -0.30573615f, 
    -0.04517875f, -0.75626063f, 0.13900614f, 0.21852602f, 0.22026318f, 0.06669284f, -0.21727756f, 0.42906964f, 
    -0.04645349f, 0.37933329f, -0.35207418f, -0.40856424f, -0.11070852f, -0.62268835f, -0.73534036f, 0.21690811f, 
    0.32750612f, -0.35526818f, -0.27048892f, 0.22318862f, 0.44265336f, -0.02432813f, 0.19038366f, -0.02650389f, 
    0.03655231f, 0.03638214f, 0.07467812f, 0.02107452f, -0.27143967f, 0.24123074f, 0.00142210f, 0.15692054f, 
    -0.25010353f, 0.45916423f, -0.75214368f, -0.87054843f, -0.41593257f, -0.88811618f, -0.02995165f, 0.14661174f, 
    0.17761259f, -0.54309809f, -0.10303538f, -0.15895307f, -0.71466720f, -0.53346723f, -0.06240492f, -0.10719828f, 
    -0.19148861f, 0.20760763f, -0.67068022f, 0.04716025f, -0.16172513f, 0.05550283f, -0.31510511f, -0.54243171f, 
    0.02192045f, 0.10070211f, -0.21554124f, 0.18536755f, -0.14235628f, -0.58100134f, -0.21313484f, -0.00706946f, 
    -0.12907226f, -1.43739736f, 0.03428605f, -0.13733253f, -0.08487927f, -0.65423590f, -0.14065981f, -1.19899130f, 
    0.03835935f, 0.18021356f, 0.16549735f, 0.34896564f, 0.08893762f, 0.10948909f, -0.17260362f, 0.19052015f, 
    -0.65480858f, -0.42322883f, -0.01418278f, 0.11790868f, -0.13099882f, -0.27602166f, 0.01834750f, 0.22019190f, 
    -0.03572658f, -0.09539963f, 0.28477111f, 0.09914860f, -0.61864692f, -0.24424472f, 0.33230269f, 0.23447625f, 
    -0.08038305f, -0.24351294f, 0.15697724f, -0.18544744f, -0.85328847f, 0.18772663f, -0.06784643f, 0.01459685f, 
    0.23719195f, 0.09647427f, 0.01421979f, 0.12667149f, 0.03335923f, -0.02476633f, 0.02264746f, -0.59061050f, 
    0.23779769f, 0.15596890f, -0.13505836f, 0.12671661f, 0.00896046f, -0.18103029f, 0.18604168f, 0.19081086f, 
    -0.22297983f, -0.19540069f, 0.32793108f, 0.01529736f, -0.25287285f, -0.23651023f, -0.07771528f, 0.01193813f, 
    -0.24598630f, 0.21682152f, -0.31577432f, -0.36022672f, -0.39009586f, 0.13729993f, -0.33169127f, -0.23519054f, 
    -0.01547204f, -0.08690804f, -0.03357431f, 0.24386728f, 0.22949255f, 0.08844585f, -0.36845303f, -0.07528795f, 
    -0.10079198f, 0.16772710f, 0.13189632f, -0.56375736f, -0.17769225f, 0.16680744f, -0.09847535f, 0.30826980f, 
    0.02718064f, 0.10155664f, 0.17329609f, 0.24266607f, 0.01892405f, 0.02782189f, -0.05037967f, -0.18585548f, 
    -0.48159274f, 0.30337888f, 0.16694903f, 0.43113798f, 0.00813480f, -0.40968683f, -0.16927397f, 0.10145967f, 
    0.15619139f, 0.07792684f, 0.25297067f, 0.19046345f, 1.29469991f, 0.03630998f, 0.12508267f, -0.01839614f, 
    -0.11354518f, -0.07288314f, 0.07833160f, -0.04963344f, 0.08068834f, 0.06709214f, -0.17139328f, -0.25777847f, 
    0.02390048f, 0.08124278f, -0.05472211f, -0.05748722f, -0.27835086f, -0.65452307f, 0.07767956f, -0.02858392f, 
    -0.00630520f, -0.98363155f, -0.29603308f, -0.14928927f, -0.23159328f, 0.18697532f, -0.12932011f, -0.08085123f, 
    -0.07955916f, -0.17739110f, -0.00255774f, 0.46431670f, -0.10278822f, -1.46010768f, -0.07280728f, -0.14094210f, 
    0.02526942f, -0.20998578f, -0.14218962f, 0.15609489f, 0.17324224f, -0.04929228f, 0.03032816f, 0.15903558f, 
    -0.05871126f, 0.03066436f, -0.22470686f, 0.05604604f, 0.16190381f, -0.23671220f, -0.10236397f, -0.01561455f, 
    -0.13610741f, 0.14722450f, -1.02728319f, -0.08737759f, 0.52954090f, 0.03412602f, 0.02907215f, -0.07849772f, 
    -0.06670224f, 0.06311971f, -0.52931994f, 0.01117587f, 0.05607030f, -0.00182770f, -0.49294740f, 0.22110452f, 
    0.05614418f, -0.22695990f, -0.14894085f, -0.15187106f, 0.03103213f, -0.08603328f, 0.07704217f, -0.51496392f, 
    -0.11758396f, 0.29476351f, 0.04780539f, 0.08919888f, -0.20785247f, -0.08885385f, 0.15452214f, -0.01678235f, 
    0.07520586f, -0.09792913f, -0.11634474f, -0.24466489f, -0.24686058f, -0.15799417f, -0.02104024f, 0.11022545f, 
    -0.07513914f, -0.00977799f, -0.08411800f, 0.06056764f, -0.06940385f, 0.12213117f, -0.22696327f, -0.09027035f, 
    -0.30868453f, -0.07739558f, -0.14773770f, 0.19623491f, -0.39489284f, 0.14395246f, -0.01646034f, -0.23956615f, 
    -0.12956437f, -0.08406501f, -0.04772102f, -0.11005217f, -0.00606532f, -0.10825424f, 0.18829527f, 0.02382494f, 
    -0.55188793f, -0.17788875f, 0.09454456f, 0.21569476f, 0.14129096f, 0.26749662f, -0.21862052f, -0.54604000f, 
    -0.07801631f, 0.03759117f, -0.01720012f, -0.07019359f, -0.56045926f, -0.30114722f, 0.00679842f, 0.13447423f, 
    0.07430965f, 0.12400001f, 0.12540491f, -0.54048300f, 0.05517768f, -0.06096273f, 0.09660539f, -0.58787167f, 
    -0.24795228f, 0.16405289f, 0.79110885f, -0.04977999f, 0.13642536f, 0.35011974f, -0.09442137f, -0.41531202f, 
    -0.04246748f, -0.17416894f, 0.08477040f, -0.05210543f, -0.03525506f, 0.22000606f, 0.10585562f, 0.08755195f, 
    0.03857100f, -0.31283867f, 0.02926925f, -0.26204950f, 0.20380253f, 0.84079695f, -0.04355805f, 0.07447112f, 
    -0.00140978f, 0.21615185f, -0.08665258f, -0.12454558f, -0.50878733f, 0.17999046f, 0.06057118f, 0.00623911f, 
    -0.14242806f, 0.01308638f, -0.32268840f, 0.10931502f, 0.15165468f, -0.09948638f, -0.10673102f, -0.02865408f, 
    0.12595256f, -0.29261905f, -0.12876640f, 0.08536203f, 0.04690854f, -0.02357388f, -0.02222671f, -0.11372287f, 
    -0.22704659f, 0.08865908f, 0.52529728f, -0.84677237f, 0.13522375f, 0.12135144f, 0.16025558f, 0.05890954f, 
    -0.34798348f, 0.13825047f, -0.05524421f, -0.01772173f, -0.02150320f, 0.03114830f, -0.25256026f, -0.14424726f, 
    0.00244482f, 0.00179654f, 0.00884773f, -0.08940341f, 0.21528083f, 0.27035227f, -0.53637528f, 0.07945050f, 
    0.12065732f, 0.12839667f, 0.20089762f, -0.08121032f, -0.09602375f, -0.07961072f, 0.19534250f, 0.02298930f, 
    0.16095406f, -0.37214702f, -0.06655248f, -0.06909104f, 0.03914441f, 0.32774022f, 0.38138738f, -0.18991831f, 
    -0.11536806f, -0.45886314f, 0.04986580f, -0.13539116f, 0.23208635f, -0.10376079f, -0.00022408f, -0.14032783f, 
    -0.89513856f, 0.08661922f, 0.15733448f, -0.12061026f, 0.03882825f, 0.11313171f, -0.09195089f, 0.16938396f, 
    -0.44862559f, -0.29037610f, -0.05760901f, 0.33003160f, 0.25454435f, -0.11031282f, -0.02564277f, -0.42806664f, 
    -0.72074312f, -0.05009575f, -0.16436265f, 0.03304663f, -0.18865509f, -0.31172442f, -0.03940974f, 0.12638386f, 
    0.07323276f, 0.24039964f, 0.26651114f, -1.33054960f, 0.14029099f, -0.03925499f, 0.12318740f, -0.98532975f, 
    -0.36897552f, 0.19815019f, -1.12197936f, 0.16564313f, -0.24647081f, -0.70882803f, 0.11602841f, -0.21646821f, 
    -0.08978981f, -0.05944916f, -0.00757272f, 0.17383428f, -0.21534653f, 0.10833332f, -0.22162326f, -0.85989982f, 
    0.02832491f, -0.00456423f, -0.21664079f, -0.34598339f, 0.12011057f, -1.27353370f, 0.05402069f, 0.25177008f, 
    -0.91581053f, -0.15624541f, 0.07049747f, -0.32684687f, 0.12757064f, 0.15861060f, 0.05619384f, 0.05429597f, 
    0.00365684f, -0.03831021f, -0.01032674f, -0.96570522f, 0.08717288f, -0.04830137f, 0.20707284f, 0.15778604f, 
    -0.12636070f, -0.67331541f, -0.33089063f, -0.04229154f, -0.81443322f, 0.04124999f, 0.23508428f, -0.03561655f, 
    0.19493760f, 0.23867367f, -0.25077534f, -0.10254402f, 0.12632066f, 0.07044131f, 0.26056916f, 0.10252885f, 
    0.12405990f, 0.18973926f, 0.28407946f, -0.01520774f, -0.08648264f, 0.20478947f, 0.19395456f, -0.03478960f, 
    -0.96462196f, 0.18854061f, -0.04085023f, -0.55294371f, -1.00929570f, -0.12210041f, -0.18433751f, -0.09498239f, 
    0.13778619f, 0.03889025f, 0.07365806f, -0.03584259f, -0.06809580f, -0.13445106f, -0.02383997f, -0.59945709f, 
    -0.18820885f, 0.15922086f, 0.08825830f, -0.07050228f, 0.07471102f, -0.05265782f, 0.24971169f, 0.06360187f, 
    0.13741694f, -0.40022749f, -0.54205203f, 0.19570325f, -0.38040799f, 0.06922549f, -0.13630605f, 0.02146426f, 
    0.21839854f, -0.93946022f, -0.45220605f, 0.13685362f, -0.67989719f, 0.01002371f, 0.12292240f, 0.06498699f, 
    -0.30480880f, 0.09163452f, 0.16965780f, 0.17013943f, -0.81702167f, -0.03440448f, 0.09576655f, 0.31736925f, 
    0.16553847f, -0.27435100f, 0.18746148f, -0.32957864f, 0.45562425f, 0.16828381f, -0.53006089f, -0.56312251f, 
    -0.50711089f, -0.51651847f, 0.27241340f, 0.04804558f, -0.41048157f, 0.00365381f, -0.49454048f, 0.78173429f, 
    0.30196646f, 0.08030003f, 0.44378531f, -0.02541089f, -0.03404185f, -0.06993518f, -0.10423362f, 0.18702549f, 
    -0.12267714f, 0.52544928f, -0.22878835f, 0.06088348f, -0.00790522f, -0.17387423f, -0.17562877f, -0.58213174f, 
    -0.08996750f, -0.21540134f, 0.10545846f, 0.25059640f, -0.40510476f, 0.21039724f, -0.41387221f, -0.74639100f, 
    -0.38582367f, -0.14513732f, -0.01670867f, 0.06796246f, 0.07244439f, 0.50474256f, -0.00892467f, -0.66069871f, 
    0.31894439f, -0.05828818f, 0.04842363f, 0.18911941f, -0.17973721f, -0.26527229f, -0.15180083f, -0.04696378f, 
    0.15988195f, 0.31059685f, -0.77901399f, -0.12124252f, -1.34226513f, 0.04941500f, -0.71989053f, -0.05593270f, 
    -0.13976569f, -0.61176687f, -0.32654083f, 0.19116217f, -0.47646251f, -0.67127383f, 0.36047015f, -0.12979022f, 
    -0.14195289f, -0.34432098f, 0.14050648f, -0.19016603f, 0.03277380f, 0.05024769f, 0.00744669f, 0.22601113f, 
    0.20712434f, -0.12234461f, 0.08839428f, 0.03335769f, 0.18932973f, 0.08264089f, 0.16785702f, 0.04260537f, 
    -0.22823718f, 0.07780696f, -0.26627561f, -0.39762563f, 0.02677240f, -0.00445214f, 0.25180256f, 0.19084243f, 
    -0.52456570f, -0.78133655f, 0.02986610f, 0.22051884f, -0.67708564f, 0.18192108f, 0.01208219f, -0.44296622f, 
    -0.16240093f, 0.33504072f, -0.09516692f, -0.07455122f, 0.06387001f, -0.07240139f, -0.38579509f, -0.23410870f, 
    -0.05119430f, -0.61290562f, -0.27324909f, -0.48787019f, 0.10017058f, -0.40452671f, 0.09034092f, 0.01796424f, 
    0.00890942f, -0.67985362f, 0.18626007f, -0.78253353f, -0.45713151f, 0.19613725f, 0.33535001f, 0.08769479f, 
    -0.31409153f, -0.12505248f, -0.23566779f, -0.17232996f, -0.10709248f, 0.08158339f, 0.07019829f, -0.07764516f, 
    -0.08995083f, 0.10457814f, -0.71686959f, -0.12033456f, -0.44814578f, -0.03332359f, 0.04429299f, -0.64184678f, 
    0.18266964f, -0.11540474f, 0.25485709f, -0.37933528f, 0.37739950f, 0.46009749f, -0.20728387f, -0.23417138f, 
    -0.05926695f, -0.79543239f, 0.24626774f, 0.18801720f, 0.15237816f, -0.12617466f, -0.00518645f, 0.14114375f, 
    -0.04131957f, 0.11989760f, -0.10943864f, 0.08334310f, 0.16431314f, 0.22135396f, -0.38333130f, -0.17199682f, 
    0.23040034f, 0.15812293f, -0.00959672f, -0.42179057f, -0.19876146f, 0.33179328f, 0.00292723f, -0.20889777f, 
    0.11407287f, -0.06375796f, -0.40558594f, -0.31693846f, -0.17216882f, 0.26815692f, -0.84864384f, -0.16642503f, 
    0.33773020f, 0.14521940f, 0.01655610f, 0.20234410f, 0.48239934f, -0.34866121f, 0.03096399f, -0.06533829f, 
    -1.26935518f, -0.13752066f, -0.82965827f, -0.19524319f, -0.01137685f, 0.10815509f, -0.03329045f, -0.22183836f, 
    -0.63168883f, 0.11839797f, 0.26994985f, 0.05946488f, 0.01652217f, -0.21683459f, 0.11912144f, 0.28915426f, 
    0.13395633f, -0.69232929f, -0.41771865f, 0.03049250f, 0.21106775f, 0.31775820f, -0.25804928f, -0.00614362f, 
    -0.10660425f, -0.14154322f, -0.50850570f, 0.16866297f, -0.02629044f, 0.09799974f, 0.35318986f, 0.07208150f, 
    0.17054173f, 0.52238059f, 0.12600037f, -0.07306644f, -0.18792352f, -0.02362808f, -0.04111731f, 0.05683257f, 
    0.11907922f, -0.10904472f, 0.13108650f, -0.20128664f, 0.55863214f, -0.55715489f, -0.05246847f, -0.18076110f, 
    -0.02525400f, 0.17932478f, -0.04287883f, 0.20917130f, 0.21825831f, -0.21718232f, 0.03388538f, -0.60829055f, 
    -0.19619556f, -0.21166421f, -0.10926018f, 0.20978451f, 0.33348781f, -0.54557550f, -0.75075996f, -0.03511711f, 
    -0.37004977f, 0.03229447f, -0.30698958f, -0.03018792f, -0.96768391f, 0.12170210f, -0.16442350f, 0.24701588f, 
    -0.24373095f, 0.03446862f, 0.02280897f, 0.38046816f, 0.22169891f, -0.03680493f, 0.04702767f, -0.50432473f, 
    -0.82179713f, 0.19165941f, 0.17847326f, 0.17880784f, 0.00306976f, -0.15792818f, -0.25201824f, 0.22375721f, 
    0.05701882f, -0.04917673f, -1.04701412f, 0.14646195f, 0.00748155f, 0.08739921f, -0.00325026f, 0.76964396f, 
    -0.02814072f, -0.95331520f, -0.99491334f, -0.19672789f, -0.28918016f, 0.60019916f, -0.00992152f, 0.14920454f, 
    -0.74318159f, 0.20479256f, -0.08289798f, -0.06529051f, 0.35232154f, 0.28768203f, -0.03000598f, -0.10724664f, 
    0.28918904f, 0.01857888f, 0.26877463f, -0.00388530f, 0.10041647f, 0.03320082f, -0.10159339f, 0.12586178f, 
    -0.61021030f, 0.13250817f, -0.47138500f, -0.30090895f, 0.34648898f, 0.19646302f, 0.21559052f, -0.12278525f, 
    -0.41567421f, 0.03587023f, -0.03204680f, 0.30035570f, -0.30327126f, -0.27352083f, -0.81684512f, 0.23826246f, 
    0.11182693f, 0.20968769f, 0.04391105f, 0.11250340f, -0.00960193f, 0.06169382f, -0.16603409f, 0.17880434f, 
    -0.17939420f, 0.29339752f, -0.27256677f, -0.40173572f, -0.32529730f, -0.09954717f, 0.24912956f, -0.22378449f, 
    -0.74019825f, -0.22271922f, -0.03562636f, 0.13324569f, 0.00054765f, 0.00191350f, 0.32341200f, 0.06690723f, 
    -0.55352795f, -0.60291743f, 0.02636756f, -0.10339485f, -0.42502686f, -0.20078394f, 0.23115216f, -0.12189718f, 
    0.17472221f, -0.13821432f, -0.70349962f, 0.22442096f, -0.18744379f, -0.14664736f, -0.60993129f, -0.61706316f, 
    0.02770680f, 0.23754333f, 0.34604067f, 0.02277582f, 0.11485801f, 0.21671720f, -0.02457353f, 0.09033321f, 
    -0.00260429f, -1.03353739f, -0.43601975f, -0.34495860f, 0.19274354f, -0.39823279f, 0.28642821f, -0.00182279f, 
    0.22606830f, -0.01288988f, -0.24460289f, 0.11437675f, -0.91561800f, -0.18823563f, 0.06042528f, -0.42824915f, 
    0.28883535f, 0.06878132f, -0.22339337f, -0.86384720f, -0.69949633f, -0.06236877f, -0.01241787f, 0.02656313f, 
    -0.01387448f, -0.28877020f, -0.56116867f, 0.00207425f, -0.14122383f, -0.00706153f, -0.20701462f, -0.04984058f, 
    -0.10688590f, -0.08102233f, 0.12751986f, -0.01995331f, 0.06274887f, -0.97632372f, -0.21384072f, -0.76650006f, 
    -0.02199360f, 0.31971458f, 0.28359067f, -0.28238538f, 0.17183338f, -0.73531640f, -0.05478938f, 0.04112555f, 
    -0.16036299f, -0.14162295f, -0.11241171f, 0.09729873f, -0.11997136f, -1.28743279f, -0.02838028f, 0.24227291f, 
    -0.73931199f, -0.05259621f, 0.14459847f, -0.27330673f, -0.44545946f, 0.13937913f, -0.06073732f, -0.13665368f, 
    0.05541280f, -0.28202033f, -0.81921703f, 0.06818046f, 0.05095421f, -0.15568931f, 0.17884298f, 0.04240854f, 
    0.32228079f, -0.08805763f, 0.60490823f, 0.09986425f, 0.06829932f, 0.17944928f, 0.11406887f, -0.60145688f, 
    -0.07640921f, -0.15390863f, -0.45784304f, 0.05900157f, -0.04488781f, -0.34028745f, -0.12156744f, -0.01468764f, 
    -0.12342571f, -0.23241372f, 0.18492170f, 0.14186274f, -0.00397797f, -0.82650858f, 0.08334636f, -0.29407626f, 
    0.10138181f, 0.11948409f, -0.03275031f, -0.02989012f, 0.21314514f, 0.23156346f, -0.69919860f, -0.58739465f, 
    0.23047540f, 0.03260166f, 0.18761759f, 0.08002103f, 0.19192317f, -0.03870214f, -0.52328175f, 0.21934035f, 
    -0.53449631f, 0.16476308f, 0.09935164f, -0.43733823f, -0.46649963f, 0.00334319f, 0.37183356f, 0.08000013f, 
    0.22328164f, -0.14219040f, -0.33410391f, 0.13635643f, 0.12537077f, 0.11164027f, -0.02943912f, 0.23165953f, 
    -0.27356797f, -0.48716086f, 0.13767287f, -0.06659205f, -0.31945971f, -0.23458849f, -0.09926204f, -0.02060520f, 
    -0.02014662f, 0.02542510f, -1.22789669f, 0.18507190f, -0.04980045f, 0.03909277f, 0.08453029f, -0.40848649f, 
    -0.11538989f, 0.01789344f, 0.02790353f, -0.12513882f, 0.03559656f, 0.06397133f, -0.33016014f, -0.10052360f, 
    -0.59842777f, -0.07445170f, -0.62340432f, 0.24474669f, -0.03172023f, -0.42803833f, 0.23920585f, -0.57491863f, 
    -0.05217978f, -0.18930367f, -0.07139234f, -0.12941185f, -0.31193468f, 0.10118320f, -0.37676743f, -0.42955023f, 
    -0.01729595f, 0.05437227f, 0.27757326f, -1.36822128f, -0.14587054f, 0.22674420f, -0.02807938f, -0.08919022f, 
    0.71712202f, 0.16160862f, 0.00978752f, -0.09297948f, 0.29385352f, -0.22085010f, -0.04975067f, -0.19480343f, 
    -0.09375530f, -0.00528787f, 0.16848704f, 0.22695433f, -0.44783345f, 0.06685960f, 0.32041511f, 0.01873108f, 
    0.05213734f, 0.06717747f, 0.14576294f, -0.16231689f, -0.26927310f, 0.10590032f, 0.05181324f, -0.00311528f, 
    -0.02689966f, 0.04733111f, -0.17082861f, -0.06507553f, -0.31264684f, -0.05620923f, -0.51543581f, 0.05402317f, 
    0.10793339f, -0.41119182f, -0.08555228f, 0.18571249f, 0.00000921f, -0.15085867f, -0.32480395f, -0.07506894f, 
    0.32030717f, 0.25456905f, 0.22596738f, -0.03076506f, 0.28990096f, -0.07786254f, 0.30173355f, -0.34911340f, 
    -0.11791104f, 0.17761645f, -0.18061291f, 0.03685360f, -1.12526906f, -0.01489865f, -0.09820065f, 0.27826455f, 
    0.01715254f, -0.52589893f, -0.10105539f, -0.07070477f, 0.33102387f, -0.53987765f, -0.35873985f, 0.00667257f, 
    -0.20464404f, 0.00216300f, 0.20407230f, 0.13120344f, -0.10473741f, 0.19667532f, -0.11496462f, 0.29856470f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.25189629f, -0.15201105f, -0.09240630f, 0.06531774f, -0.02673360f, 0.03030398f, 0.02137532f, -0.49669114f, 
    -0.45411688f, 0.00565957f, 0.17890324f, 0.40745410f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
