#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.56344289f, 0.41424513f, 0.06863881f, -0.46247864f, -0.38051391f, -0.24616246f, 0.45199937f, 1.00408351f, 
    -0.60010737f, 0.12954913f, 1.23991013f, -0.56255162f, -0.66529411f, 0.14752541f, -0.19540372f, -0.37932488f, 
    0.40640137f, 0.45194668f, -0.69752795f, -0.07043540f, -0.43044972f, -0.39255887f, -0.51017189f, -0.48943734f, 
    -0.17504674f, -0.88124579f, -0.55232733f, -0.50868648f, -0.20159557f, 0.45830458f, -0.57196075f, -0.95149219f, 
    -1.27007222f, 0.55535805f, 0.41833425f, 0.61818826f, -0.49930483f, -0.11742678f, -0.66163617f, 0.44784921f, 
    1.29714465f, 0.06040139f, 0.03071508f, 0.58715463f, 0.34840542f, -1.25545728f, -0.75486153f, 0.89587468f, 
    -0.12362362f, 0.72673166f, -0.92985129f, 0.17694287f, -0.03923175f, -0.38430727f, -0.06280832f, -0.06154478f, 
    0.52203423f, -0.19985610f, -0.52161682f, 0.97089934f, 0.18135257f, -0.10113329f, 0.79788959f, -0.11537799f, 
    -0.22247022f, 0.54498005f, 0.56924814f, -1.03069520f, -1.10343277f, -0.37146389f, -0.22611067f, -0.57656962f, 
    0.25615257f, -0.70963186f, -0.69874173f, -0.99459177f, -0.55829376f, 0.20454764f, 0.35669366f, -0.12769723f, 
    0.90186816f, 0.30692780f, -0.55780715f, -0.36099833f, 0.47442690f, 0.92163444f, 0.04119734f, 0.58618689f, 
    -0.95276928f, -0.40515289f, -0.73743737f, -0.81402028f, -0.63450998f, 0.75573635f, -0.04696610f, -0.62911081f, 
    -0.38312593f, -0.54151869f, -0.01271037f, 1.09572518f, 0.05308197f, 0.40231249f, -0.09332583f, 0.53095472f, 
    0.09434403f, 0.23060076f, -0.26326400f, 0.75461006f, 0.47034127f, 1.25575352f, -0.48032585f, -0.24522935f, 
    -0.22746389f, -0.05480752f, 0.66205072f, -0.65612447f, -0.39534676f, 0.86637366f, 0.80750912f, 0.35058951f, 
    0.60083055f, -1.05428648f, -0.32745355f, -0.12844056f, -0.19047059f, 0.03822092f, 0.30077350f, 0.70049286f, 
    -0.20235293f, -0.08850209f, 0.86910284f, 0.20899804f, -0.57325447f, -0.74842465f, -0.54351264f, -0.02644186f, 
    0.37525612f, 1.15012050f, 0.27698693f, -0.13906251f, 0.23905395f, -0.27516857f, -0.59145784f, -0.38415253f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09620004f, 0.03550969f, 0.49943212f, 0.33803591f, 0.41054547f, 0.56169355f, 0.60143614f, 0.39586785f, 
    0.23813437f, 0.47155541f, -0.33810785f, 0.01432237f, 0.29248354f, -0.09377056f, 0.43118930f, 0.53579462f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.28083754f, -0.27236453f, 0.09670783f, 0.11590914f, 0.01271185f, 0.06496349f, 0.02226235f, -0.23740135f, 
    0.29654220f, -0.36846384f, 0.05140365f, -0.37704960f, 0.17858940f, -0.00066444f, 0.53130215f, 0.14898896f, 
    -0.24431016f, -0.00593946f, 0.02961539f, 0.01581044f, -0.21653685f, -0.23560014f, -0.08871827f, 0.02268647f, 
    0.10226932f, -0.01798548f, 0.05143850f, -0.49962825f, -0.48357081f, 0.11410725f, 0.21538690f, -0.00162152f, 
    0.07265712f, -0.02482870f, 0.01731880f, 0.18420377f, 0.09205431f, 0.08142718f, -0.16786009f, -0.17880066f, 
    -0.00450975f, 0.08382182f, 0.19594859f, -0.04446343f, -0.15304774f, 0.57388091f, -0.88922608f, -0.73310626f, 
    -0.07072330f, 0.04915472f, 0.07754105f, 0.22339740f, 0.11262941f, 0.00710742f, 0.11512407f, 0.15983362f, 
    0.12737505f, -0.14634913f, -0.00361896f, -0.07526371f, -0.01543685f, -0.05488782f, 0.02282878f, 0.04200682f, 
    -0.22485431f, 0.12692930f, -0.08049584f, 0.14744833f, -0.10299020f, 0.06335071f, 0.00159736f, 0.01736296f, 
    -0.84544915f, -1.05637109f, -0.71355081f, 0.16975072f, 0.02816378f, 0.09575722f, 0.04543476f, -0.07948884f, 
    0.06048020f, -0.07633897f, 0.00801382f, 0.12117319f, -0.15559360f, -0.07426226f, 0.04710481f, -0.29940331f, 
    0.02970187f, -0.10476787f, 0.48118466f, -1.24510169f, -1.02879250f, -0.39914367f, -0.20912866f, -0.12741996f, 
    -0.13660182f, -0.13937199f, -0.01668861f, 0.11773878f, 0.09490132f, 0.20631722f, 0.11621340f, -0.19526550f, 
    -0.13255516f, -0.19531699f, -0.12495156f, -0.13784961f, 0.26043609f, 0.30347300f, 0.36692140f, 0.06600736f, 
    0.15830646f, -0.11526740f, 0.10743141f, 0.14080310f, 0.05445283f, 0.09460957f, -0.04118089f, -0.03415706f, 
    0.04687309f, 0.05614776f, -0.10616858f, 0.07512628f, -0.14335243f, 0.06049303f, 0.15972865f, 0.36631462f, 
    0.23282261f, 0.04100748f, 0.10010618f, 0.33605108f, -0.15131946f, -0.08982300f, 0.30635026f, 0.36303133f, 
    0.22700720f, 0.23441306f, -0.07657408f, 0.10606892f, -0.15568829f, 0.08893026f, 0.02667080f, 0.20817998f, 
    -0.02147913f, -0.10337576f, -0.06651295f, -0.00238702f, -0.07788704f, -0.03156519f, 0.00356843f, -0.01761086f, 
    0.01553993f, -0.10711679f, -0.04722411f, -0.09125701f, -0.08010869f, 0.02071372f, 0.00296988f, -0.02733230f, 
    -0.11232913f, -0.03912653f, -0.04749157f, 0.03465887f, 0.00284525f, -0.08301085f, -0.02087980f, -0.00997770f, 
    -0.00990635f, -0.08196432f, -0.00035763f, 0.04363446f, -0.01392328f, -0.00794974f, 0.00534040f, -0.02408553f, 
    0.02895069f, -0.10145345f, 0.06003133f, 0.01146716f, -0.07662150f, 0.03591280f, 0.02639754f, -0.09014548f, 
    -0.02360416f, 0.04336806f, -0.02513758f, 0.04879249f, 0.05360824f, 0.02619150f, -0.01452791f, -0.00156096f, 
    0.01808480f, -0.07613651f, 0.02364376f, 0.01437315f, -0.02088008f, 0.00988641f, -0.04624362f, 0.05143684f, 
    -0.10249177f, -0.02228763f, -0.07057776f, -0.04737889f, -0.06999561f, -0.02111134f, 0.05645358f, -0.03071566f, 
    -0.01344951f, -0.05163903f, -0.01495739f, -0.00655516f, -0.00302547f, -0.04369125f, 0.00992174f, -0.04315677f, 
    0.01522962f, 0.03012885f, -0.07929460f, -0.08976322f, -0.08646687f, -0.04900489f, 0.03368177f, -0.07903764f, 
    0.04494702f, -0.01332881f, -0.08437835f, 0.04850702f, -0.04694444f, -0.08013558f, -0.06863354f, 0.02426177f, 
    -0.08388162f, 0.05156425f, 0.06993415f, 0.01122071f, 0.04734828f, -0.00627684f, 0.04575322f, 0.00243749f, 
    -0.07030848f, -0.02438366f, -0.03870000f, 0.00455287f, 0.02272683f, 0.04414628f, -0.03397695f, -0.10255703f, 
    -0.04524646f, -0.09948060f, -0.04426136f, 0.00642093f, -0.09245045f, 0.00380266f, 0.01632564f, -0.05935218f, 
    -0.09434160f, 0.04050025f, 0.03350499f, 0.03763943f, -0.04179920f, -0.05760714f, -0.04032055f, 0.03477767f, 
    -0.07539103f, -0.02197996f, -0.07866015f, -0.09538326f, 0.03208248f, 0.06981529f, -0.07310465f, 0.06020584f, 
    -0.01736286f, 0.01043731f, 0.02291277f, -0.00242954f, -0.02358782f, 0.03693887f, -0.05136794f, -0.06095071f, 
    -0.07205777f, -0.05138218f, -0.01962204f, -0.08039270f, -0.09965573f, -0.06536258f, 0.04979973f, 0.01725296f, 
    0.21580133f, -0.10216908f, -0.28829858f, 0.03431744f, -0.09809972f, -0.01722852f, -0.02565938f, 0.08880191f, 
    -0.18014526f, 0.25196630f, -0.55068898f, -0.79761386f, 0.22890298f, 0.14555112f, 0.27734423f, -0.18806066f, 
    -0.21859547f, -0.01382126f, -0.10088803f, 0.15640263f, 0.27833715f, -0.04050362f, 0.04529419f, 0.26692867f, 
    0.05860762f, -0.09870882f, -0.24733278f, -0.03363157f, 0.32950073f, 0.33255833f, -0.12283992f, -0.09634319f, 
    -0.20802216f, 0.05059665f, -0.01736403f, 0.12929001f, -0.86870497f, -0.68609798f, -0.19975756f, 0.00444285f, 
    0.20792019f, 0.05782231f, 0.23403341f, 0.10948689f, 0.19514926f, 0.00028064f, -0.24938425f, 0.09844956f, 
    0.07607704f, -0.14945540f, 0.24318807f, 0.14658123f, -0.01406400f, 0.01102732f, -0.32520667f, -0.18042284f, 
    0.08492173f, 0.12661085f, -0.09313572f, 0.13120863f, -0.03833095f, -0.28350496f, -0.16196951f, 0.07239715f, 
    -0.12420622f, -0.16929385f, 0.00756533f, 0.07146868f, 0.06213992f, 0.04722384f, 0.00299600f, 0.06431346f, 
    0.07797473f, 0.31436670f, 0.16365279f, 0.24180406f, -0.27606234f, -0.06262743f, 0.01483929f, -0.02792477f, 
    0.01404538f, -0.23903124f, -0.59344727f, -0.21630746f, 0.21454573f, -0.07351885f, -0.13762687f, 0.23140873f, 
    0.04728122f, 0.11373128f, 0.18748797f, 0.12984474f, 0.16595912f, -0.05713721f, 0.17738378f, 0.18647078f, 
    0.02610754f, 0.02383208f, -0.05918052f, -0.25945365f, 0.01810018f, -0.08940124f, 0.00775373f, 0.15010744f, 
    0.33072644f, 0.05252547f, -0.26097372f, 0.08205941f, 0.54278719f, -0.15767512f, -0.16339210f, 0.28189522f, 
    0.12722006f, 0.22753483f, 0.11886186f, 0.01291841f, 0.21186125f, 0.66100675f, -0.31849670f, -0.21639854f, 
    -0.02748812f, 0.08547162f, 0.04139033f, 0.04403003f, 0.03826476f, 0.07968692f, 0.15564963f, -0.04157279f, 
    0.05335091f, 0.18958493f, -0.08459219f, -0.29792696f, 0.11548179f, -0.05014579f, 0.19193973f, -0.08913804f, 
    -0.65333825f, -0.08867726f, -0.00537623f, -0.04270368f, -0.29041404f, 0.00471204f, -0.12653950f, -0.00144620f, 
    -0.19649114f, 0.17812444f, 0.44134474f, 0.02645494f, -0.24197806f, -0.09607273f, 0.06434401f, -0.14122619f, 
    0.10477247f, -0.51134741f, -0.41238168f, -0.35369354f, 0.04558524f, 0.08767867f, 0.23913918f, 0.03882563f, 
    -0.14041223f, -0.24492511f, -0.17157477f, 0.34512132f, -0.05865102f, 0.01661090f, 0.19147716f, 0.22441515f, 
    0.10992250f, 0.12745088f, 0.07219679f, -0.40566432f, -0.07074996f, 0.05124976f, 0.09920309f, -0.11425431f, 
    0.00825779f, 0.00238132f, 0.11050352f, 0.10895529f, 0.07531347f, 0.09767547f, 0.52190942f, -0.05696447f, 
    0.18515660f, -0.07444245f, 0.05219404f, 0.15240633f, 0.09881809f, 0.13719052f, -0.15084253f, 0.37496153f, 
    0.16101994f, -0.12722430f, 0.27089658f, 0.05121967f, -0.03306242f, 0.10439535f, -0.18560641f, -0.35330757f, 
    0.31666723f, -0.05829727f, 0.12575752f, 0.09020632f, -0.04233686f, 0.10812896f, 0.03836285f, 0.17797096f, 
    -0.15219276f, -0.17294532f, -0.03131392f, -0.15630378f, -0.02223632f, 0.09237979f, 0.05954725f, -0.06607718f, 
    -0.30805659f, -0.15686449f, 0.27361089f, -0.10489871f, 0.10834573f, -0.08877426f, 0.04170841f, -0.05819461f, 
    -0.00744450f, 0.19785093f, -0.07645182f, 0.26744065f, -0.08581096f, -0.10888789f, -0.24401012f, -0.00452222f, 
    0.01781094f, 0.11784296f, -0.55445391f, 0.31270704f, 0.20011121f, -0.09786432f, -0.06623828f, -0.06994199f, 
    -0.02798370f, 0.10879262f, -0.26173705f, -0.15956415f, -0.14589283f, 0.18442020f, 0.04177834f, -0.04763294f, 
    -0.21927941f, -0.13605720f, 0.00775641f, 0.14475206f, 0.12531686f, -0.02943054f, -0.20544982f, 0.18756087f, 
    0.02853508f, 0.24388744f, -0.09364623f, -0.02186459f, -0.04498900f, -0.06486525f, -0.23887902f, -0.40852693f, 
    0.06773499f, -0.06767101f, -0.21948868f, -0.06979225f, 0.14137013f, -0.14928222f, -0.09346369f, -0.22498095f, 
    0.28043827f, 0.05521999f, 0.03082115f, -0.16914806f, 0.18741146f, -0.02840405f, -0.11976029f, 0.10789105f, 
    -0.52317595f, -0.06550319f, -0.07272032f, 0.06808470f, -0.01832872f, 0.16669083f, 0.07486293f, 0.00198016f, 
    -0.00597896f, -0.18147752f, -0.44604859f, 0.13202851f, 0.15277906f, 0.26712719f, 0.25579122f, -0.04817486f, 
    0.25017300f, 0.09245946f, -0.25581047f, -0.16762240f, 0.13535483f, 0.15685105f, 0.46244705f, 0.01441497f, 
    0.08983231f, -0.02345143f, 0.11588845f, -0.23361017f, 0.03728388f, 0.02520895f, -0.17069533f, 0.08461117f, 
    -0.09552194f, 0.01809834f, 0.07580782f, -0.88585097f, -0.41194466f, -0.03445628f, 0.06849727f, 0.16814186f, 
    -0.43217045f, 0.15857740f, 0.00012997f, -0.01045204f, -0.02484939f, 0.24834576f, 0.16148685f, -0.06083925f, 
    0.20371389f, -0.08012913f, 0.04072078f, -0.02332868f, 0.05177320f, 0.32496333f, -0.18895195f, -0.03282992f, 
    0.17905486f, -0.06521364f, 0.15879072f, -0.27098322f, 0.23180062f, -0.07701041f, 0.27080244f, -0.14724442f, 
    -0.16273771f, 0.22363792f, 0.14181821f, 0.01056744f, -0.22692703f, 0.30670518f, 0.04102477f, -0.06355956f, 
    -0.20208727f, -0.19966045f, -0.09624078f, -0.15387000f, -0.28281513f, 0.16359207f, 0.05323100f, 0.10815524f, 
    -0.29295781f, -0.11805677f, -0.11216176f, -0.01855022f, 0.06997379f, -0.02496540f, -0.00327724f, 0.14823160f, 
    -0.12862009f, -0.21000002f, 0.21397917f, 0.19040193f, -0.01631490f, 0.16205950f, 0.23055181f, 0.00954410f, 
    0.00009696f, 0.21133070f, -0.22651389f, -0.07307152f, 0.41131720f, -0.16900060f, -0.04185717f, -0.05488252f, 
    0.04398751f, 0.11840574f, 0.10649046f, 0.20516270f, -0.11152597f, -0.04195261f, 0.01688092f, 0.22214775f, 
    0.01681523f, 0.09661448f, 0.02894523f, 0.08158382f, 0.16257152f, -0.40469673f, -0.01780425f, -0.12190957f, 
    -0.18165258f, 0.08307627f, 0.09232581f, 0.08272381f, 0.34650907f, -0.19529232f, 0.01750200f, 0.23629703f, 
    0.09520076f, -0.03634397f, -0.07790869f, 0.03347843f, 0.20632122f, 0.12111156f, -0.13740808f, -0.11903974f, 
    -0.16300397f, -0.11558072f, 0.07854412f, -0.09681836f, 0.14249201f, -0.17886598f, 0.29802915f, 0.20172985f, 
    -0.04313791f, -0.16459319f, 0.01124644f, 0.07965396f, -0.18111877f, 0.17091000f, 0.08449404f, 0.01886023f, 
    0.34760243f, -0.08559232f, 0.03278846f, -0.03569419f, 0.00766543f, -0.27540052f, -0.08204072f, 0.09954932f, 
    0.25708193f, 0.53040290f, -0.22354914f, 0.37009436f, 0.13135162f, 0.07534051f, -0.05691274f, 0.11669672f, 
    0.13610061f, -0.15794133f, 0.13570531f, 0.14658120f, -0.20164813f, -0.13939300f, -0.23146385f, 0.13869110f, 
    0.14649075f, 0.14788394f, 0.05094950f, -0.19453074f, -0.03324589f, -0.01210892f, -0.09208985f, -0.04654948f, 
    -0.00329664f, 0.11941728f, 0.02313868f, 0.11142609f, -0.65007812f, -0.19200794f, -0.50321966f, 0.17690569f, 
    0.19894668f, 0.02232846f, 0.03969884f, -0.02098430f, -0.09652624f, -0.09564076f, -0.32036144f, -0.28954324f, 
    0.21822362f, 0.10545580f, 0.38555127f, -0.02119634f, -0.00879717f, 0.10068033f, 0.34686294f, 0.07355767f, 
    0.53919554f, -0.04138000f, 0.30407473f, 0.23026404f, 0.11403690f, 0.18316640f, 0.28192788f, -0.16856797f, 
    -0.23499884f, -0.11829464f, -0.12981221f, -0.16443719f, 0.35959160f, 0.02446033f, -0.06056347f, 0.04228811f, 
    -0.13738656f, -0.41054398f, 0.03764083f, -0.02915289f, -0.09353748f, -0.10441675f, 0.09684923f, 0.16512558f, 
    0.00296042f, -0.35054681f, 0.06927642f, -0.22635208f, 0.18185738f, 0.08567590f, 0.07277474f, -0.09359213f, 
    -0.10357931f, 0.21416028f, -0.20491903f, 0.08779108f, -0.40116689f, -0.51076263f, -0.22071126f, 0.20931330f, 
    -0.09492059f, -0.06309685f, 0.05445491f, 0.52640307f, 0.47181514f, 0.65481603f, -0.34942567f, 0.06084593f, 
    -0.16972670f, -0.14603925f, -0.18437526f, -0.06081652f, 0.32887581f, 0.04171386f, 0.15136780f, -0.20590864f, 
    -0.17846045f, 0.03557485f, -0.11053143f, 0.02835315f, 0.12891398f, 0.44321626f, 0.11540458f, 0.29134238f, 
    -0.04386899f, 0.04459527f, -0.15456374f, -0.12672752f, 0.12350919f, -0.04708532f, -0.39647672f, 0.00525932f, 
    -0.27185610f, -0.03043682f, -0.06631067f, -0.27389732f, -0.21094050f, 0.03483275f, -0.08726114f, 0.13294336f, 
    -0.18343472f, 0.30313119f, -0.21498272f, -0.06481049f, -0.01187624f, 0.02699739f, 0.15118827f, 0.29784966f, 
    0.12340823f, 0.12596929f, -0.21136086f, -0.02226805f, 0.13349222f, -0.20057569f, 0.22677848f, 0.22300628f, 
    -0.21297620f, -0.31108886f, 0.26062855f, -0.07447428f, 0.00284272f, 0.02156346f, 0.14836556f, -0.01044215f, 
    -0.01673948f, -0.17623918f, -0.16646464f, -0.16261303f, -0.49187747f, -0.11297841f, 0.06020515f, 0.01196223f, 
    0.02227980f, 0.02163688f, 0.04048466f, 0.25002646f, -0.08726954f, -0.65690196f, 0.18304045f, -0.08709990f, 
    0.20401123f, -0.12901632f, -0.04980268f, 0.13955183f, 0.15494415f, 0.11413634f, 0.25977036f, -0.14376003f, 
    -0.00585453f, -0.15009208f, -0.05210343f, 0.08083506f, -0.02674297f, -1.05820191f, -0.11786105f, -0.39110279f, 
    -0.17683430f, -0.09392155f, -0.15998755f, 0.12750942f, -0.16164325f, -0.02486405f, -0.17729038f, 0.23963208f, 
    0.11414881f, 0.11627853f, 0.28799918f, 0.29571405f, 0.10013735f, -0.12570368f, -0.09900349f, -0.94453377f, 
    -0.85584021f, -0.39012891f, -0.04181078f, 0.22264697f, 0.14784351f, 0.17849673f, -0.01386766f, -0.02653330f, 
    0.02267980f, 0.31923684f, 0.36225963f, -0.01296960f, -0.43098837f, -0.04593625f, -0.07573844f, -0.06959558f, 
    0.02806064f, 0.48322734f, -0.01594599f, 0.54794842f, -0.07573718f, -0.11234404f, -0.08641902f, 0.02263911f, 
    -0.03596990f, 0.29893684f, 0.26826239f, -0.24119206f, -0.44878173f, 0.01020421f, 0.27623287f, 0.06075324f, 
    0.10365532f, 0.11551522f, 0.04715806f, 0.04628427f, -0.18233572f, 0.16120291f, 0.16889770f, 0.11139901f, 
    0.24736144f, 0.22267325f, 0.13736063f, -0.14121817f, 0.20484498f, -0.39462861f, -0.75115198f, -0.07742751f, 
    -0.01012842f, 0.09764581f, 0.09933392f, 0.11761177f, 0.15133061f, 0.31553331f, -0.50529301f, -0.08946164f, 
    0.32454997f, 0.26235723f, 0.29861832f, 0.14950630f, 0.08616478f, -0.01011650f, 0.41606900f, -0.06760082f, 
    0.06213148f, -0.12307903f, 0.06495511f, -0.04098995f, 0.01362829f, -0.10138430f, 0.22682366f, -0.15077032f, 
    0.01587748f, 0.11256805f, 0.12886608f, 0.22847597f, 0.29004547f, 0.16957463f, -0.03336201f, 0.19257900f, 
    0.34028378f, -0.00953921f, -0.37747332f, 0.18364015f, 0.30033466f, -0.13234457f, 0.24879099f, -0.00753067f, 
    0.22257890f, 0.08768559f, -0.63097000f, -0.11010634f, 0.35720804f, -0.07437588f, 0.25976878f, 0.21721570f, 
    -0.07899278f, 0.02754762f, -0.16117798f, -0.16133612f, -0.25404260f, 0.16593975f, 0.04460414f, 0.16066574f, 
    -0.15236633f, 0.14026235f, 0.16577826f, -0.26644894f, -0.09446829f, -0.38821948f, -0.02568413f, 0.14966245f, 
    0.07046272f, 0.23254074f, 0.17564027f, 0.13243349f, -0.24595110f, 0.22092012f, 0.15489708f, 0.09284761f, 
    0.13753040f, 0.05170527f, 0.00377505f, -0.03517826f, 0.06014092f, -0.07796390f, -0.28917563f, 0.19205397f, 
    0.21257842f, 0.26705232f, 0.08864205f, -0.08162060f, 0.00859148f, 0.14693972f, 0.25487468f, 0.05437832f, 
    0.12067765f, 0.27352938f, 0.16631615f, 0.30068427f, 0.41054672f, 0.29620042f, 0.13310671f, 0.06718714f, 
    -0.32666740f, -0.51211876f, 0.24709123f, 0.28219867f, 0.15423918f, 0.24647793f, 0.01814403f, -0.07557162f, 
    -0.24991749f, 0.39510199f, -0.19296201f, -0.11633153f, 0.05204507f, -0.02835897f, 0.23854578f, 0.17788443f, 
    -0.04316282f, 0.03702510f, 0.34604859f, 0.28321069f, 0.22155882f, 0.35121036f, 0.01179532f, 0.09404720f, 
    -0.22363155f, -0.09704037f, -0.31703162f, -0.14825639f, 0.30837321f, 0.01719068f, -0.07252435f, -0.40282106f, 
    -0.44219285f, -0.18481834f, -0.36386502f, 0.46166846f, -0.20447370f, -0.27702865f, 0.04502402f, -0.12930831f, 
    0.05107581f, -0.00896886f, 0.28075698f, -0.13901749f, 0.12739342f, -0.30584288f, -0.26736271f, 0.13416570f, 
    0.01433648f, -0.00976588f, 0.09573207f, 0.25404996f, -0.00389182f, 0.05128954f, -0.49789959f, -0.13538039f, 
    -0.19288570f, -0.04634863f, -0.05487736f, 0.11695749f, -0.06032363f, -0.02564046f, -0.36417341f, -0.07410154f, 
    0.15112953f, -0.35136598f, 0.12049312f, -0.01697732f, -0.22537962f, -0.15052827f, -0.10356995f, -0.23066731f, 
    -0.04628346f, -0.17041372f, -0.09882696f, 0.17334527f, -0.01162209f, -0.06837202f, 0.21710494f, 0.04531382f, 
    0.03089395f, -0.00630256f, -0.00571222f, 0.02386228f, -0.09594903f, -0.08743889f, 0.06609078f, -0.01772064f, 
    0.01763923f, 0.03159029f, -0.03810468f, 0.04742428f, -0.05874829f, -0.02600794f, -0.06910887f, 0.01144746f, 
    0.01794040f, 0.06356911f, 0.03511541f, 0.06616963f, -0.08687178f, 0.01487620f, 0.04133740f, -0.01929445f, 
    0.06362780f, 0.01815181f, -0.09050537f, -0.01863728f, 0.05255341f, -0.05204806f, 0.04319770f, 0.02004691f, 
    0.02858678f, -0.03260097f, 0.02176374f, -0.09786393f, -0.05498921f, -0.00983853f, -0.06879392f, 0.04509942f, 
    -0.05053779f, 0.00837666f, 0.01559458f, 0.03608546f, -0.04203727f, -0.08722158f, -0.01557840f, -0.03416422f, 
    0.05527824f, -0.00181334f, -0.08063275f, 0.00795397f, -0.05914238f, 0.02895740f, -0.04105436f, 0.00679065f, 
    -0.01977959f, -0.00109713f, 0.03505956f, -0.03656207f, 0.00998481f, 0.05741167f, -0.07596894f, 0.00402350f, 
    0.02339816f, 0.05373945f, 0.05119376f, -0.02902598f, -0.07238479f, -0.05828713f, 0.06089382f, -0.07578978f, 
    0.05707439f, -0.05831774f, -0.03762018f, -0.08898226f, -0.04160108f, 0.03209050f, 0.00157554f, -0.06012635f, 
    -0.01136409f, -0.05813164f, -0.03691816f, 0.00668686f, -0.07768866f, -0.03598159f, 0.00255913f, -0.01589810f, 
    0.04825353f, 0.00582196f, -0.04454576f, -0.01777340f, 0.00389784f, 0.04585233f, -0.00311429f, -0.00654247f, 
    -0.03841425f, 0.00915927f, 0.02708018f, -0.01988751f, 0.05356554f, 0.06050790f, -0.06108512f, 0.03744832f, 
    -0.01088208f, 0.07692203f, -0.06629375f, 0.06348708f, -0.09699282f, -0.00358647f, 0.00530688f, -0.01692237f, 
    0.02658106f, -0.04260933f, -0.08374242f, -0.04295852f, -0.05328909f, -0.03977876f, -0.01814558f, -0.05071293f, 
    0.05225761f, 0.01761554f, -0.02575733f, 0.05615791f, -0.03093641f, 0.06973434f, -0.06486567f, -0.07568481f, 
    -0.09553862f, 0.01594914f, -0.08984298f, 0.00360649f, -0.07688152f, -0.04325427f, 0.05070299f, 0.03437612f, 
    0.02105819f, -0.00316204f, -0.07780118f, -0.06898385f, -0.07520825f, -0.06761362f, 0.03104630f, -0.08173630f, 
    0.19272923f, 0.18559889f, -0.02055059f, -0.27545616f, 0.14147533f, -0.11172971f, 0.23248646f, -0.08601065f, 
    0.02087300f, -0.21497792f, -0.28276619f, -0.52725554f, -0.17738523f, -0.02558807f, 0.12970775f, -0.16485305f, 
    0.12893037f, -0.22819759f, 0.18536091f, 0.26157781f, 0.39101207f, -0.06191247f, 0.12866634f, 0.20707221f, 
    -0.03148311f, 0.03910607f, 0.18690945f, 0.49816614f, 0.15554620f, 0.37914824f, -0.01765706f, -0.16807215f, 
    0.00403211f, -0.13812093f, -0.05891534f, -0.07561971f, 0.13192083f, 0.13237275f, 0.36793813f, -0.34455472f, 
    -0.21930583f, -0.05100472f, 0.13384724f, 0.18019390f, 0.19770704f, -0.23175853f, 0.09181977f, -0.11992454f, 
    -0.21531516f, 0.12607469f, 0.01845432f, 0.16472945f, 0.07431941f, -0.09913722f, -0.43805695f, -0.03612283f, 
    -0.37302989f, -0.11311151f, 0.10732570f, -0.25224653f, 0.08002326f, 0.15867382f, 0.10468150f, 0.00131560f, 
    0.04542923f, 0.33620650f, -0.05418451f, 0.12708659f, 0.06547547f, 0.03408687f, 0.02564318f, -0.06571893f, 
    -0.01562556f, 0.54785484f, 0.29081833f, -0.08645087f, -0.00174338f, -0.04270983f, -0.00962083f, 0.11756804f, 
    -0.18937536f, -0.08891385f, -0.14771411f, 0.13217130f, -0.12867877f, -0.22846040f, 0.05313154f, 0.20983830f, 
    0.17413518f, 0.29902515f, -0.12913842f, -0.07902873f, 0.14208545f, -0.24483436f, -0.43036023f, -0.16774502f, 
    0.10596696f, -0.29596341f, 0.14866525f, -0.05446168f, 0.06361137f, 0.02884703f, 0.21996781f, 0.01883936f, 
    -0.05822480f, 0.45008242f, 0.13491216f, 0.03899430f, 0.21504568f, -0.47234634f, -0.33460674f, 0.16975264f, 
    0.12017293f, 0.10935442f, 0.10469037f, -0.08166900f, 0.14694515f, -0.34052971f, -0.26240209f, -0.46182376f, 
    0.10230801f, 0.02437858f, 0.00396492f, -0.10319582f, -0.23931700f, -0.04680898f, 0.12397961f, -0.31528935f, 
    -0.05605711f, -0.03899023f, -0.15565801f, -0.04874695f, 0.04485368f, -0.07890246f, 0.13057624f, -0.47864023f, 
    -0.34408775f, -0.26326671f, 0.12668128f, -0.03772736f, -0.09570388f, -0.10771738f, -0.08199110f, 0.25449768f, 
    -0.15054752f, 0.22296250f, 0.13055182f, -0.02402888f, 0.25887844f, 0.12555400f, 0.07443761f, 0.22171451f, 
    0.06135083f, -0.01624459f, 0.29389656f, 0.08285128f, 0.12693976f, 0.17345974f, 0.20220952f, 0.18769003f, 
    0.31049973f, 0.26639441f, 0.02971589f, 0.21629260f, 0.05304057f, 0.05882429f, -0.03439974f, 0.24274196f, 
    0.28409162f, 0.17700990f, -0.26756576f, 0.04460827f, 0.36119348f, 0.06993435f, 0.15272902f, 0.14771000f, 
    0.10215505f, 0.07224085f, 0.11863188f, 0.17180136f, 0.20649867f, 0.03095529f, -0.12389573f, 0.28102747f, 
    -0.01823771f, -0.11325513f, -0.02338956f, 0.20491956f, 0.08110549f, -0.13704017f, 0.42417854f, 0.20160511f, 
    0.15701848f, -0.00763119f, 0.28021225f, -0.34927475f, 0.13075791f, -0.23148903f, -0.07844010f, 0.19880079f, 
    0.14171700f, 0.17241977f, -0.11648475f, -0.17273356f, 0.10436931f, -0.04703000f, 0.27773955f, -0.29830292f, 
    -0.17807323f, -0.05949688f, 0.04947958f, 0.17551403f, 0.19976202f, -0.04534201f, -0.15281650f, -0.22689711f, 
    0.38200063f, 0.09515360f, 0.39406380f, 0.15540172f, 0.04937262f, -0.00935862f, 0.29650256f, 0.05773289f, 
    0.06325360f, -0.00868726f, 0.06689479f, 0.04373794f, -0.04265591f, -0.18086964f, 0.02953011f, -0.30863947f, 
    -0.23117284f, -0.35594076f, 0.21623081f, 0.16084076f, -0.29640290f, 0.09413958f, -0.09899700f, -0.14305769f, 
    0.21034229f, -0.11805806f, -0.07169182f, -0.05045864f, -0.16756040f, 0.27340722f, 0.20789772f, 0.20386209f, 
    0.11794730f, -0.02750784f, -0.14319400f, 0.36854103f, -0.12108903f, 0.13747832f, -0.12103254f, 0.16129348f, 
    0.14737448f, 0.04013268f, -0.09690215f, 0.28927466f, -0.05434477f, -0.59250921f, -0.45849946f, -0.02927455f, 
    0.34305355f, 0.21800941f, -0.02292975f, -0.10397562f, -0.20828041f, 0.07614332f, 0.07339838f, -0.02286926f, 
    -0.14018011f, 0.04845548f, -0.16193832f, -0.09673818f, -0.23251443f, -0.32317239f, -0.42669332f, -0.26063806f, 
    -0.29248649f, -0.06628672f, -0.01667492f, 0.03015417f, -0.02373791f, -0.22920515f, -0.17038767f, -0.48207635f, 
    0.26221567f, 0.15942845f, -0.15872410f, 0.14548548f, -0.08764523f, 0.04821911f, 0.06412946f, -0.23118946f, 
    -0.12539133f, 0.19608915f, 0.37033114f, 0.26800793f, -0.17159294f, -0.30554345f, -0.10720763f, -0.05026001f, 
    -0.22583346f, -0.14777392f, 0.11005761f, 0.18355478f, 0.34931439f, -0.05294120f, 0.02754618f, -0.04892141f, 
    0.27380741f, 0.19342753f, 0.27847263f, 0.30673561f, 0.02529472f, 0.10007151f, 0.33219269f, 0.03715340f, 
    0.18856651f, 0.14771485f, -0.22244078f, -0.39729750f, -0.15121469f, -0.26369557f, 0.04816383f, 0.10460915f, 
    0.14146137f, -0.00718047f, -0.19363219f, -0.14636226f, 0.27483422f, 0.09764936f, 0.50989401f, -0.10772227f, 
    0.22271125f, 0.26410183f, 0.14756155f, 0.01084121f, 0.29369089f, 0.23843394f, 0.02076618f, -0.04448384f, 
    -0.48965663f, -0.21533464f, 0.21453701f, -0.09763513f, 0.20106220f, 0.21784499f, -0.01357188f, 0.28008243f, 
    0.54143453f, 0.74133146f, 0.11409688f, -0.00941123f, -0.02246385f, 0.29452515f, 0.22691108f, 0.18862611f, 
    0.28426328f, -0.15169975f, 0.17907777f, 0.10818275f, 0.18066570f, 0.05310214f, 0.12840782f, 0.06613115f, 
    -0.20323579f, -0.19685155f, 0.17344123f, 0.07806789f, 0.04302383f, 0.21182723f, 0.25266322f, 0.23943992f, 
    0.19494383f, 0.20260461f, -0.47011381f, 0.00382612f, -0.11190489f, -0.01220591f, -0.14395761f, -0.23156761f, 
    -0.04739996f, 0.14941403f, 0.07309942f, 0.02162234f, 0.06244489f, -0.01754263f, -0.11509244f, -0.01783063f, 
    -0.02039882f, 0.18451487f, -0.10809442f, -0.30502295f, 0.22230284f, -0.08200556f, -0.14289306f, 0.09099787f, 
    0.00142433f, -0.23294957f, 0.25882441f, 0.13869178f, 0.04684158f, 0.02694989f, -0.01956673f, -0.19859079f, 
    -0.16988412f, -0.11829267f, 0.01772270f, 0.02844265f, -0.01081837f, -0.17918831f, 0.39358941f, -0.06963334f, 
    -0.31501108f, -0.11428320f, 0.16175474f, 0.07270417f, 0.22353604f, 0.04618816f, 0.25993034f, 0.30316195f, 
    0.28915823f, -0.14833005f, -0.04173640f, 0.02249942f, 0.07973850f, -0.00393330f, 0.08965226f, -0.02268077f, 
    -0.14243062f, 0.11840190f, 0.22636254f, 0.30486220f, 0.26752868f, 0.18945685f, -0.08569614f, -0.12307241f, 
    -0.09576707f, 0.33115897f, 0.12845576f, -0.10104335f, 0.08700312f, 0.14628331f, 0.13913161f, -0.18199541f, 
    -0.12115417f, -0.23770265f, 0.19224717f, -0.21270886f, -0.08636267f, 0.01634440f, -0.05531505f, -0.09573967f, 
    0.01767428f, 0.03862718f, 0.19981831f, -0.05912114f, 0.07230899f, 0.09079592f, 0.25443390f, 0.11557178f, 
    0.04375048f, -0.08794958f, -0.22450729f, -0.17992650f, 0.17767121f, 0.17994876f, -0.48928511f, -0.04176630f, 
    -0.31460789f, 0.05626221f, -0.19031115f, -0.16014440f, -0.15435140f, 0.15657370f, -0.02477624f, -0.28333864f, 
    0.10639143f, 0.14068529f, -0.01201733f, 0.15348439f, -0.02058229f, -0.05642882f, 0.18713981f, 0.00682063f, 
    -0.06258933f, -0.03111275f, -0.09290399f, -0.04154419f, -0.15842208f, -0.11512780f, -0.13647602f, -0.12029397f, 
    0.19761589f, -0.04168716f, 0.08057073f, 0.13257673f, -0.05352379f, 0.08670324f, 0.18878600f, 0.19364643f, 
    0.07335481f, -0.47512069f, 0.10717423f, -0.09865882f, 0.16805771f, -0.14654908f, -0.21337435f, -0.10137699f, 
    -0.12763520f, -0.03271778f, -0.09580186f, -0.13901044f, -0.01202852f, 0.13179769f, -0.01150365f, -0.01845407f, 
    0.05929550f, 0.28841925f, 0.29464459f, -0.12133140f, -0.31049597f, 0.12289577f, 0.01723179f, 0.23166777f, 
    0.02303799f, -0.04911109f, 0.12686932f, 0.33262444f, 0.10497094f, 0.12920873f, 0.11573569f, -0.06827030f, 
    0.11040376f, 0.06801393f, -0.12172022f, -0.20995414f, -0.16692911f, 0.56935400f, 0.33038822f, -0.05897405f, 
    0.01856085f, -0.13947527f, -0.11707295f, -0.09307491f, 0.02673284f, 0.66528970f, 0.24861152f, 0.21809733f, 
    0.00439668f, -0.26602814f, 0.10892840f, 0.15798786f, 0.00392898f, -0.03111784f, -0.05666567f, -0.17024505f, 
    0.11237063f, 0.11087191f, 0.18251622f, 0.06977493f, 0.11251070f, 0.26125351f, 0.13941772f, 0.20823643f, 
    0.34110811f, 0.20339146f, 0.09217487f, -0.04527842f, -0.12734735f, 0.04526988f, -0.01209965f, 0.06645938f, 
    -0.36706784f, 0.33905298f, -0.01952000f, -0.08233451f, -0.05202694f, 0.17793563f, 0.08866839f, -0.04646985f, 
    0.33045283f, -0.26319325f, -0.12236043f, -0.14191434f, 0.12497340f, 0.09851210f, -0.02532228f, -0.03936127f, 
    -0.01290051f, 0.11418170f, 0.18777452f, 0.01372890f, -0.22274622f, 0.07821008f, -0.18112241f, 0.12771110f, 
    0.00632333f, 0.07559152f, -0.11574174f, 0.23156951f, -0.03907467f, 0.14228965f, -0.18571538f, 0.05772615f, 
    -0.05776692f, 0.07809082f, 0.09332902f, 0.24984166f, -0.05515004f, -0.15065461f, -0.58006489f, -0.08749719f, 
    0.02891951f, -0.09445248f, 0.21227844f, 0.02938577f, 0.07283431f, 0.52432102f, 0.12492182f, -0.28124338f, 
    -0.04818038f, 0.20046213f, -0.10740859f, 0.14221086f, -0.04273449f, -0.12366080f, -0.16732377f, 0.40786275f, 
    -0.27708310f, 0.10356320f, 0.06868004f, -0.17753778f, 0.07591797f, 0.09351132f, 0.14402169f, -0.10360726f, 
    -0.13301469f, -0.19970435f, -0.37877503f, -0.03149093f, -0.09392170f, 0.00964691f, 0.06904615f, 0.00456407f, 
    0.27552754f, 0.10056073f, -0.12156221f, 0.03212579f, -0.11288571f, 0.04231314f, -0.05644041f, 0.06606534f, 
    -0.06823505f, 0.07811553f, -0.19821726f, 0.63731682f, 0.01218919f, -0.01106050f, -0.14923158f, 0.23469241f, 
    -0.15333617f, -0.05030467f, 0.58986402f, -0.03025656f, -0.08795170f, 0.01376104f, 0.09945097f, -0.31729054f, 
    0.04706170f, -0.00320681f, -0.17743145f, -0.17760646f, 0.24218740f, 0.17127198f, -0.02219120f, 0.19371003f, 
    0.20019972f, 0.05427199f, 0.00627778f, 0.24652635f, -0.37501600f, 0.22347610f, 0.36852804f, 0.21868873f, 
    -0.14416300f, -0.25941896f, -0.08948479f, 0.18055171f, 0.27096447f, -0.80293226f, -0.33715880f, 0.29032505f, 
    -0.13016659f, -0.14090966f, 0.13527179f, 0.09260538f, 0.18442188f, 0.03356663f, -0.25429875f, 0.20506014f, 
    0.10729267f, -0.03366060f, 0.06343620f, -0.27454504f, -0.11627214f, -0.27136916f, -0.10370038f, -0.32626101f, 
    -0.15602553f, 0.15473163f, -0.04016178f, -0.13338220f, -0.01364949f, -0.06024340f, -0.01229288f, 0.02099845f, 
    -0.05168396f, 0.05538359f, 0.03554752f, 0.07868908f, 0.02804381f, -0.07562660f, 0.01723580f, 0.06588127f, 
    0.00102127f, -0.06449856f, -0.04641764f, 0.04017253f, -0.06538254f, 0.04981870f, -0.09776654f, -0.07198856f, 
    -0.07646585f, 0.06637598f, -0.02514167f, -0.07044175f, 0.01537749f, 0.00729225f, -0.05256928f, -0.06497847f, 
    0.04021304f, 0.03850279f, -0.08151940f, -0.02719213f, 0.02886798f, -0.05758877f, 0.01312526f, 0.04294300f, 
    -0.05258648f, 0.06616142f, 0.05286460f, -0.06571258f, 0.02246079f, -0.00293953f, -0.04197704f, -0.03193653f, 
    -0.07409876f, 0.03905204f, 0.06137754f, -0.03600226f, 0.00461733f, -0.08634254f, 0.03567460f, -0.03897220f, 
    -0.06885657f, -0.06514622f, -0.00234276f, -0.00635253f, -0.06307315f, -0.07907241f, 0.06376085f, 0.01255548f, 
    -0.00882199f, 0.05802697f, -0.00217891f, -0.04237806f, 0.01575449f, 0.00098534f, -0.00836381f, -0.02312985f, 
    -0.01938246f, 0.02602801f, 0.06152191f, 0.01443958f, -0.01044113f, 0.04506677f, -0.08454660f, -0.05347794f, 
    -0.05915928f, -0.02673963f, -0.00649128f, -0.08099812f, -0.00222985f, 0.02829086f, 0.03802170f, 0.04391316f, 
    -0.01014125f, -0.07735687f, -0.08456390f, -0.01306680f, 0.06051243f, 0.03305404f, -0.07183402f, -0.02554963f, 
    -0.05901854f, -0.07512176f, 0.03026409f, -0.05825106f, -0.02953962f, -0.04685497f, -0.04965009f, 0.01037160f, 
    0.04670189f, 0.04181475f, -0.02808424f, -0.04303966f, 0.03741360f, -0.03106796f, -0.05908533f, -0.06780675f, 
    -0.06243010f, 0.05957111f, -0.01867791f, 0.01408710f, -0.08666283f, -0.04134489f, -0.08952192f, -0.07634076f, 
    -0.10021894f, 0.04282870f, -0.07838666f, -0.08209766f, 0.02719189f, -0.05876750f, -0.04363317f, -0.03964709f, 
    0.06418855f, -0.09015174f, -0.03280801f, -0.05648746f, 0.03033189f, -0.04067724f, 0.02631063f, 0.02815158f, 
    -0.08207333f, 0.02926430f, -0.07807911f, -0.02528327f, -0.07657619f, 0.02022708f, 0.00535917f, 0.05790237f, 
    -0.08598206f, -0.05133196f, -0.09687318f, 0.05978454f, 0.03677780f, -0.07247801f, 0.02064017f, 0.03741609f, 
    -0.14796737f, -0.13896091f, 0.00877229f, -0.04066254f, 0.03694817f, -0.07263965f, 0.07474206f, 0.17348790f, 
    0.17072760f, -0.00650709f, -0.72497022f, -0.84228480f, 0.11372668f, -0.19300298f, -0.01066327f, 0.24925219f, 
    0.08191799f, -0.20006566f, 0.12506424f, 0.21722624f, 0.25114578f, 0.11143663f, 0.09096530f, -0.02638030f, 
    0.15107808f, 0.08942103f, -0.11499838f, 0.24338336f, 0.43612587f, 0.43348917f, -0.32386109f, 0.04883809f, 
    -0.11976313f, 0.06373210f, -0.07607821f, 0.05679946f, 0.34787998f, -0.33881330f, -0.82025570f, 0.04241941f, 
    -0.10337424f, 0.10603733f, -0.12219648f, -0.14166617f, 0.08732256f, 0.73911721f, -0.05524132f, -0.04212308f, 
    -0.15250196f, -0.10905145f, 0.00877197f, -0.02493705f, -0.04731592f, -0.22087137f, -0.07536004f, -0.42587951f, 
    -0.03057243f, -0.06148470f, 0.19081332f, -0.11851230f, 0.33553103f, 0.19764306f, 0.01261628f, 0.10129067f, 
    0.10439053f, -0.15659283f, -0.12548065f, -0.00930206f, 0.00693183f, -0.01944858f, 0.13965797f, -0.02888463f, 
    -0.00783305f, 0.30570993f, 0.11596651f, -0.10387439f, 0.05887249f, -0.04679546f, 0.00164361f, 0.14680940f, 
    0.15560344f, 0.19133109f, -0.34202367f, -0.42865804f, 0.06244302f, -0.26969931f, 0.20663831f, -0.09687760f, 
    0.04957628f, -0.05266105f, 0.64640456f, 0.33284381f, 0.20899354f, 0.29755974f, 0.08523495f, 0.22877631f, 
    0.19304487f, 0.03282846f, 0.12583244f, 0.29586294f, -0.21698557f, -0.84383917f, -0.12202396f, -0.20232812f, 
    -0.01558503f, 0.04705549f, 0.24516384f, -0.15514894f, -0.35691577f, 0.02727327f, 0.09759013f, -0.08254872f, 
    -0.16677611f, -0.20349547f, -0.10635965f, 0.03215454f, -0.09673728f, -0.41872004f, -0.23114640f, -0.03885835f, 
    -0.18404455f, 0.13694941f, -0.09690955f, -0.05183031f, -0.13424715f, -0.04659702f, 0.38475519f, -0.08876922f, 
    0.38602841f, -0.02230556f, -0.07247606f, 0.04889460f, 0.26769388f, -0.01397042f, 0.15268233f, -0.38629019f, 
    -0.08703540f, -0.15212034f, 0.02866546f, 0.15482678f, -0.10450884f, 0.19301291f, -0.12866592f, -0.06852575f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10980278f, -0.01526710f, -0.15216444f, 0.48937908f, 0.25407612f, 0.29854992f, 0.10185168f, 0.49951899f, 
    -0.09289154f, 0.12472426f, -0.29626140f, 0.29987448f, -0.05449922f, -0.05391195f, -0.06884866f, -0.25839141f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23869528f, -0.15533370f, 0.14806329f, -0.08370528f, 0.33696076f, -0.17625478f, -0.02915389f, 0.49243346f, 
    0.20113622f, 0.00149579f, -0.38888612f, 0.43266284f, 0.15925765f, -0.56345510f, 0.08320802f, -0.28440404f, 
    -0.09529103f, -0.15450519f, 0.32137215f, 0.92961979f, -0.05077015f, 0.31993991f, -0.02185392f, 0.42233330f, 
    0.12589692f, -0.12332566f, 0.07164421f, -0.11514016f, 0.27897060f, -0.30227420f, -0.12114736f, -0.16226557f, 
    0.34291601f, 0.17589878f, -0.06463463f, 0.13886911f, -0.16023463f, -0.66797960f, -0.29376963f, 0.04743015f, 
    0.25836262f, 0.22213784f, -0.30264407f, 0.22613461f, 0.51335347f, 0.58931828f, -0.11983760f, 0.21964796f, 
    -0.20607738f, 0.15448959f, -0.01431945f, 0.15735817f, -0.19700937f, -0.00640161f, -0.00746788f, -0.13640258f, 
    0.09476899f, 0.18592611f, -0.13239488f, -0.28882217f, -0.00487468f, -0.00643656f, -0.02035054f, 0.11228582f, 
    -0.17416431f, 0.12239942f, 0.67146689f, -0.24702372f, 0.36499789f, 0.49574691f, -0.26301292f, 0.47951722f, 
    0.01682069f, 0.20140275f, -0.02948154f, 0.01208350f, -0.15817705f, -0.79490495f, 0.09335276f, -0.00346161f, 
    0.31652638f, 0.07640477f, 0.00538176f, -0.79384965f, 0.28972030f, 0.29276422f, -0.51817930f, -0.11943341f, 
    0.06034952f, -0.11247148f, 0.25607309f, 0.10192091f, 0.01714994f, 0.52116019f, 0.16082504f, 0.09296167f, 
    0.17024423f, -0.08554953f, -0.01687894f, 0.32820368f, -0.26371482f, 0.23668152f, 0.09387916f, 0.32758582f, 
    0.17087343f, 0.14765234f, -0.12832707f, -0.22481416f, 0.20822982f, 0.53976226f, -0.10372443f, 0.38207328f, 
    0.35821876f, -0.07756532f, 0.18535857f, 0.02940274f, 0.32335290f, 0.49463138f, -0.41351116f, -0.18868180f, 
    0.17735125f, -0.20619121f, -0.16394776f, 0.07389013f, 0.27850458f, -0.03700798f, 0.08346449f, -0.68304145f, 
    -0.13037266f, 0.13967426f, -0.00541896f, 0.76851243f, 0.21032254f, -0.53528380f, -0.11010665f, 0.14580849f, 
    0.09579094f, 0.39382172f, 0.11626489f, 0.27095628f, -0.20487492f, -0.01271704f, -0.08082408f, -0.67216635f, 
    0.37052894f, 0.09277178f, 0.41311082f, 0.08902939f, -0.32999906f, 0.31417027f, -0.25068572f, 0.17683426f, 
    0.18611020f, -0.27058062f, 0.36560953f, -0.22199935f, 0.12456167f, 0.39014539f, 0.17291197f, 0.57542646f, 
    -0.00293925f, 0.12275541f, -0.12848623f, 0.10758592f, 0.09951404f, -0.31229272f, 0.31707755f, 0.18350045f, 
    0.21297042f, -0.49879402f, 0.35285825f, 0.00274834f, -0.28045160f, -0.28719267f, -0.04791728f, 0.06875385f, 
    -0.17512244f, 0.08247187f, 0.21727937f, -0.41906875f, -0.63357121f, 0.09339727f, 0.20699988f, -0.21002361f, 
    -0.06828258f, 0.61545449f, 0.22260226f, 0.14619146f, 0.01025375f, 0.26886445f, -0.13246253f, 0.91267061f, 
    -0.64840233f, 0.11547978f, 0.54186189f, -0.19816121f, 0.34952277f, -0.00683294f, -0.36336520f, -0.55300492f, 
    0.15969016f, 0.38292357f, 0.20431571f, 0.28753945f, 0.03589283f, 0.39916080f, -0.06720960f, 0.30701751f, 
    -0.20943323f, 0.01040454f, 0.55116755f, 0.70845264f, -0.26819244f, 0.56379580f, 0.11009040f, 0.08080543f, 
    -0.05485289f, 0.11319670f, 0.03791983f, 0.01211756f, -0.24358812f, -0.08195823f, -0.03613794f, -0.54576093f, 
    0.23826598f, 0.20222993f, -0.16635019f, -0.26122269f, -0.09178390f, 0.56815457f, -0.67144948f, 0.07502906f, 
    -0.18736377f, -0.34231627f, 0.31483591f, 0.15430729f, -0.15997957f, 0.66403586f, 0.06721231f, -0.03987990f, 
    -0.25362068f, -0.10117663f, 0.06894315f, 0.09593981f, 0.13992213f, 0.34150603f, -0.54551190f, 0.52481860f, 
    -0.14029914f, -0.65853912f, -0.02653761f, 0.46420357f, -0.64792138f, 0.14398745f, 0.10296024f, -0.32015529f, 
    -0.17148343f, -0.14926854f, -0.06721830f, -0.03393121f, -0.22136822f, 0.01159490f, 0.17392451f, -0.05761373f, 
    -0.06897057f, -0.13446426f, -0.30767819f, 0.09953696f, -0.25376996f, 0.00656708f, -0.20510569f, -0.15002660f, 
    0.09445251f, -0.08552834f, -0.15453936f, -0.18012391f, -0.22456086f, -0.01345225f, 0.40170038f, 0.09868926f, 
    0.21459515f, -0.92336440f, -0.12178189f, -0.33624867f, 0.31179509f, -0.51266450f, 0.15301317f, 0.13213739f, 
    -0.30981323f, -0.22915097f, -0.31483996f, -0.42447552f, 0.17598720f, 0.38724750f, 0.23742622f, 0.13290584f, 
    0.09996451f, 0.07037991f, -0.14741147f, 0.00299250f, 0.10978784f, -0.53528035f, 0.06181955f, 0.35115889f, 
    -0.11799923f, -0.03935093f, 0.17036292f, 0.11325676f, -0.15034457f, -0.19740747f, 0.17822203f, 0.05636854f, 
    -0.24315913f, -0.01247852f, 0.00368754f, -0.28808433f, -0.12405643f, -0.18621878f, 0.00597930f, -0.07802661f, 
    0.06318559f, -0.03854898f, -0.29600036f, 0.32578379f, -0.04431412f, 0.29927626f, 0.14704326f, -0.23646224f, 
    0.10212072f, -0.11132617f, 0.42157388f, 0.09584044f, -0.28706929f, 0.44332659f, -0.12577647f, -0.44544682f, 
    0.70847851f, -0.06620988f, 0.65408605f, -0.01092867f, -0.05780168f, 0.06993615f, 0.30265638f, 0.05754199f, 
    0.17964651f, 0.07169279f, -0.12831621f, -0.31185746f, -0.01919454f, -0.28973469f, 0.14321430f, 0.33522969f, 
    -0.32488593f, 0.07876131f, -0.14383468f, -0.00087625f, 0.18717410f, -0.22144291f, 0.20292544f, 0.12245011f, 
    0.02880383f, -0.52355194f, 0.17117727f, -0.03991480f, -0.35065994f, 0.34563455f, -0.23657680f, -1.09598684f, 
    -0.18420300f, 0.23967744f, -0.12726213f, -0.34941688f, -0.53954124f, 0.00235322f, 0.05912852f, -0.11984842f, 
    0.05413157f, 0.51327515f, 0.31662768f, 0.10350251f, 0.27740690f, -0.19334354f, -0.20503107f, -0.44514868f, 
    0.00147444f, -0.07794604f, -0.02172406f, -0.10080580f, 0.00931492f, -0.00782576f, -0.39223787f, 0.60424948f, 
    -0.22564450f, -0.13421007f, 0.40736896f, -0.16663684f, -0.72286671f, 0.41151479f, -0.01899227f, 0.24330238f, 
    -0.81542021f, -0.09784434f, -0.35049886f, 0.12167744f, 0.32673451f, -0.27148044f, -0.28505179f, -0.15616924f, 
    0.21614337f, 0.39115182f, -0.33722067f, 0.45896593f, 0.53657633f, -0.33064488f, 0.10052089f, -0.42228270f, 
    -0.35672840f, -0.11137030f, 0.42664388f, 0.47408360f, -0.14622208f, -0.24451390f, -0.03804865f, -0.24698906f, 
    0.16482083f, 0.53954792f, 0.58041185f, 0.12667012f, -0.22158934f, 0.31143358f, -0.22309797f, -0.14712904f, 
    -0.25366536f, -0.24328554f, -0.46130344f, 0.17240694f, -0.16513762f, 0.18047470f, -0.33821115f, 0.08920134f, 
    -0.11725082f, 0.66553551f, 0.31163791f, 0.05453910f, 0.02835786f, 0.42983267f, 0.09331296f, 0.29195288f, 
    -0.87216401f, -0.07755595f, 0.46227801f, 0.60501939f, -0.22076440f, -0.04591054f, -0.17192206f, -0.10407593f, 
    -0.21922016f, 0.37851530f, 0.43294582f, -0.25421873f, -0.37420613f, 0.31688550f, -0.07526347f, 0.46788034f, 
    -0.41208449f, 0.21253195f, -0.63180900f, -0.63843197f, -0.36313134f, 0.34047607f, 0.41928566f, -0.00228400f, 
    -0.24003878f, 0.46431908f, 0.06702227f, 0.21121198f, 0.28806031f, -0.60073590f, 0.06337171f, 0.47605860f, 
    -0.06132650f, 0.04064280f, 0.01391526f, -0.58894378f, -0.02026117f, 0.27244094f, 0.10815917f, -0.09095711f, 
    0.15164500f, -0.07532887f, 0.11602810f, -0.43760028f, 0.14589202f, -0.25848556f, -0.10707135f, -0.44040781f, 
    0.04274252f, 0.11866788f, 0.01466148f, -0.52003247f, 0.36890191f, -0.27935112f, 0.00493580f, 0.47280899f, 
    0.21320288f, -0.06019685f, -0.16249947f, 0.22889934f, -0.12340373f, -0.41388524f, 0.13515028f, 0.16518250f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.85716724f, 0.27379131f, 0.22714217f, -0.07038808f, 0.14511511f, -0.46329010f, 0.35514450f, 0.04360241f, 
    0.21567068f, -0.31153569f, -0.27594236f, -0.31291798f, 0.14608456f, 0.37280732f, 0.22659124f, 0.78409672f, 
    -0.09730272f, -0.39931205f, 0.19824198f, -0.08329806f, -0.30675650f, -0.67314112f, 0.09854697f, 0.03411186f, 
    0.18280359f, 0.29165983f, -0.04725974f, 0.14909351f, 0.10792684f, 0.22460344f, 0.16052216f, 0.08624404f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.73547918f, -0.05711701f, 0.31846929f, -0.09682741f, -0.64597803f, -0.13652387f, 0.15718706f, -0.22356811f, 
    -0.96034247f, 0.26074106f, 0.05143580f, 0.46157074f, 0.23583825f, -0.29635096f, -0.20616043f, -0.46762264f, 
    -0.15003714f, -0.04648343f, 0.20030189f, -0.02100839f, 0.06660590f, 0.05425053f, -0.10233734f, -0.52748966f, 
    -0.41036212f, -0.87303448f, 0.01385811f, 0.16092046f, 0.33468392f, 0.06283238f, -0.63741863f, -0.18731678f, 
    -0.00589501f, 0.23497629f, -0.06602639f, -0.17128573f, 0.01488699f, -0.19602406f, 0.36078069f, 0.29264617f, 
    -0.10657520f, 0.17585456f, -0.18646833f, 0.00814056f, -0.07139787f, 0.14079857f, 0.14960794f, 0.17657244f, 
    -0.11604813f, -0.05857718f, -0.03853822f, -0.11373620f, -0.32575837f, -0.04194477f, 0.21156429f, -0.93212688f, 
    0.41679204f, -1.59440982f, 0.02000475f, 0.07947351f, 0.38881260f, -0.23774156f, 0.05437654f, -0.03251141f, 
    0.24264093f, 0.03244662f, 0.20258114f, 0.13573463f, 0.03169817f, -0.34131810f, -0.28330308f, -0.32250106f, 
    0.43307287f, -0.49420738f, -0.14394629f, -0.81748718f, 0.28160104f, 0.08872905f, -0.38644081f, 0.35991371f, 
    -0.02849211f, 0.43047321f, -0.27873656f, 0.16146474f, -0.06970263f, 0.34742904f, -0.01613230f, -1.54626286f, 
    -0.46460545f, 0.54484546f, -0.01420156f, 0.05832529f, -1.00980294f, -0.47078812f, 0.46549878f, 0.06175012f, 
    -0.23068553f, -0.75622910f, -0.03362350f, 0.08269095f, -0.77401429f, 0.30068126f, -0.14760922f, -0.14911005f, 
    -0.08428370f, -0.24538171f, 0.89746386f, 0.33706442f, 0.33987901f, -0.79313338f, 0.13457224f, -0.02763886f, 
    -0.15243942f, -1.44112778f, -0.13465336f, 0.03338429f, 0.32855362f, -0.06960364f, 0.03833382f, -0.10433187f, 
    -0.15415341f, 0.44554937f, 0.17747432f, 0.17424709f, -0.20921183f, 0.25718766f, 0.08710959f, 0.12017159f, 
    -0.23129918f, 0.03974880f, -0.07288963f, -0.11477063f, 0.11739044f, -0.12490211f, 0.00264086f, -0.12178711f, 
    0.07529025f, -0.04131974f, -0.10933553f, 0.23450445f, 0.11807263f, -0.11942309f, -0.75758851f, -1.20377159f, 
    0.12088030f, -0.14012291f, 0.25123882f, 0.04221328f, 0.09283961f, 0.09238672f, -0.81992871f, 0.12946892f, 
    -0.93518645f, 0.15771902f, 0.30294558f, 0.08684582f, 0.24159987f, 0.07386155f, 0.07323887f, -0.09201609f, 
    -0.06486208f, 0.00002810f, -0.33541045f, 0.04265407f, 0.46938697f, 0.05872769f, -0.32079810f, 0.00915304f, 
    -0.03847486f, 0.01356019f, -0.17509124f, 0.01583905f, 0.21765244f, 0.31764472f, -0.00708772f, 0.26848212f, 
    0.07533476f, 0.00228873f, -0.05536924f, 0.09243412f, 0.04034982f, 0.24791931f, -0.80028552f, 0.44304359f, 
    0.28538638f, -0.45751232f, 0.20688908f, -0.12987161f, 0.20802374f, -0.12717740f, -0.30285063f, 0.05907762f, 
    0.62396944f, 0.01837469f, -0.09429907f, -0.11542678f, 0.37038445f, -0.40975890f, -0.22307001f, -0.23438561f, 
    0.18687890f, -0.43882307f, 0.26858529f, -1.26669550f, -1.51228440f, -0.27891836f, -0.61393774f, 0.44940192f, 
    -0.13566974f, 0.13588348f, 0.32782564f, 0.11163914f, -0.28471264f, -0.44305307f, -0.58649385f, -0.42142320f, 
    -0.52057034f, 0.36580381f, -1.33671653f, -1.13996398f, -0.26547572f, 0.16268849f, 0.07965973f, 0.32414940f, 
    -0.19178079f, 0.01683215f, 0.51404083f, -0.16153118f, 0.06875766f, 0.48326525f, 0.00133733f, 0.41427541f, 
    -0.13420801f, 0.22400364f, 0.33963430f, -0.69991338f, 0.23940638f, -0.53251565f, 0.42402211f, -0.48875678f, 
    0.04354544f, -0.20582502f, -0.26154593f, -0.10214657f, -0.13637887f, -0.02663008f, 0.26732942f, -0.10671422f, 
    0.31946221f, 0.35109705f, -1.28536069f, -0.51294273f, -0.47527483f, -0.60169637f, 0.19003949f, 0.12308916f, 
    -0.13228287f, 0.11457846f, -0.16469151f, 0.01774572f, 0.08239489f, 0.28107655f, 0.12772653f, -0.17754392f, 
    0.14338127f, 0.34982359f, 0.00253000f, -0.29327977f, -0.38005424f, -0.06582791f, 0.47257134f, 0.17119654f, 
    -0.17199902f, 0.08554485f, -0.08806006f, 0.09830444f, 0.17038704f, -0.44930524f, -0.35058847f, -0.17770319f, 
    0.61166978f, -1.01124585f, -0.18573429f, 0.48253447f, -1.20477140f, -0.09735940f, -0.00818458f, -0.06836768f, 
    0.40002939f, 0.12689753f, 0.28757817f, -0.16475081f, -0.07034274f, -0.77409273f, 0.18047492f, -0.22040455f, 
    0.06858143f, -0.60817283f, -0.12269033f, -0.04133168f, -0.28719047f, -0.08335599f, -1.07851696f, -0.96100765f, 
    -0.00027570f, -0.47067019f, 0.21766031f, 0.10719379f, -0.29330724f, -0.04446102f, -0.16307683f, 0.10424817f, 
    -0.65152693f, 0.53241038f, -0.23493171f, 0.11105110f, -0.13732809f, 0.53989905f, -0.04335099f, 0.19658700f, 
    -0.43156886f, 0.10636281f, -0.16890754f, 0.11565968f, -1.03529024f, -0.27193704f, 0.02056012f, -0.30471411f, 
    0.52807933f, -0.24143472f, -0.00218915f, -0.38712752f, -0.13441174f, 0.51915544f, 0.23777358f, 0.29198948f, 
    -0.03958415f, -0.67402464f, -0.27637556f, -0.13299766f, 0.72708142f, -0.32249671f, -0.36650571f, -0.22795966f, 
    0.03607583f, -0.27058274f, 0.37915787f, 0.13324451f, 0.11267557f, -0.34707931f, -0.24091193f, -0.46483710f, 
    0.03687987f, -0.00135130f, -1.01318169f, -0.02051279f, 0.43570203f, 0.04418068f, -0.10088972f, 0.25676781f, 
    -0.40206379f, -0.16619298f, -0.49546948f, -0.02463122f, 0.12518066f, 0.26627856f, 0.15610997f, 0.14507049f, 
    -0.07889189f, -0.70040125f, 0.41960382f, 0.15102984f, 0.04178103f, -0.33658171f, 0.47119400f, -0.50379461f, 
    -0.29261693f, 0.29442501f, -0.43385836f, 0.12160048f, -0.47648117f, 0.51443040f, -0.32516724f, -0.04319331f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15170394f, 0.29246747f, 0.10683544f, -0.04589122f, -0.04521430f, -0.26358214f, 0.27491221f, -0.73625022f, 
    0.12304671f, 0.22635446f, 0.19897367f, -0.24219707f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
