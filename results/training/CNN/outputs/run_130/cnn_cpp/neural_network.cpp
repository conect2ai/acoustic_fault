#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.58892334f, 0.83122563f, 0.99689257f, 0.17402248f, -0.15793724f, -0.56966728f, -0.66121882f, -0.74381226f, 
    -0.42764884f, -0.29881194f, -0.50877732f, 0.00375678f, -0.30528727f, -0.46192753f, 0.00043202f, -0.41184938f, 
    -0.18685593f, -0.41541180f, -0.19876850f, 0.34760651f, 0.51185745f, 0.04094657f, -0.17228802f, -0.55181342f, 
    -0.13046798f, 1.12008965f, 1.01582193f, 0.34597272f, -0.88735038f, 0.79192472f, 0.72469056f, -0.15541065f, 
    -0.41135651f, -0.50592190f, -0.47934979f, -1.09485662f, 0.00990954f, -0.00727089f, -0.08720781f, -0.30791655f, 
    -0.50863224f, 0.25795716f, 0.03485093f, -0.70333427f, -0.28662330f, 0.03316071f, 0.08617654f, -0.20920296f, 
    0.03554039f, -0.32244584f, 0.47780266f, -0.29027003f, 0.40432712f, 0.48600462f, 0.69421595f, -1.09570193f, 
    -1.10989332f, -0.91439480f, -0.96376616f, -0.22588672f, 0.28998360f, 0.27807787f, -0.33342817f, 0.55285829f, 
    0.12780832f, 0.02916978f, -0.53138852f, 0.22869623f, -0.27848241f, 0.09072470f, -0.37663841f, -0.38349852f, 
    0.10861748f, -0.03582568f, -0.22919671f, -0.10198747f, -0.30635104f, 0.32766426f, -0.47497794f, 1.28722143f, 
    1.14790177f, -0.23670286f, -0.87334651f, -0.82304788f, -1.01094949f, 0.56766379f, 0.73808748f, 0.27117446f, 
    0.23639184f, 0.22342579f, 0.24094079f, -0.07247689f, -0.50152695f, -0.00142556f, 0.48425969f, -0.00692319f, 
    0.25553012f, 0.40580130f, 0.51611429f, -0.23576052f, -0.22641088f, -0.76668435f, -0.68283576f, -0.54028004f, 
    -0.37101138f, -0.92291760f, 0.92729372f, -0.92677671f, -0.91810107f, -0.12911294f, 0.49423826f, 0.37419710f, 
    -0.46558088f, -0.17262310f, -0.42234653f, -0.19800919f, 0.42488286f, 0.43994638f, -0.25295743f, -0.63248938f, 
    -0.17722943f, -0.48182434f, 0.26215845f, -0.02885609f, 0.27195391f, 0.85376346f, 0.86511880f, 1.21385384f, 
    1.08670735f, 1.41157782f, 0.03446669f, -0.06621010f, -0.50123507f, -0.48854917f, 0.08154652f, 0.64461541f, 
    0.34676760f, -0.02824524f, 0.57974535f, -0.39901865f, -0.00352844f, 0.25227004f, 0.30375546f, 0.06638449f, 
    -0.01970281f, 0.67127317f, 0.10398749f, -0.17446792f, -0.06452952f, 0.46942937f, -0.45950744f, 0.56374592f, 
    -0.51869273f, -1.35681283f, -1.10829031f, 0.67570657f, -1.15117514f, -0.66470361f, 0.69862658f, -0.54899049f, 
    -0.58479261f, 0.09536062f, 0.24307178f, 0.38749680f, 0.00359682f, 0.31127807f, 0.17226040f, 0.17402008f, 
    0.38960937f, 0.26853132f, -0.05338063f, -0.17185338f, 0.14481144f, -0.04032960f, 0.28227082f, 0.25521943f, 
    1.33765280f, -1.24784839f, -1.01271260f, -0.59536916f, 1.16562164f, 0.77326000f, -0.62297064f, 0.40566394f, 
    0.39433140f, 0.33615601f, 0.05716500f, 0.38881001f, 0.22164489f, -0.04920193f, 0.11748385f, -0.12139864f, 
    0.04577600f, 0.23577188f, 0.12661514f, 0.11481933f, -0.35571536f, 0.01621193f, -0.18793926f, 0.22895829f, 
    1.05546951f, 0.73289007f, 0.80378658f, 1.08383095f, -0.04426092f, 0.05533775f, 0.27088922f, 0.14761373f, 
    -0.71024215f, 0.84192276f, -0.19708604f, -0.08494446f, 0.36407024f, -0.26332271f, -0.12096360f, -0.20258747f, 
    0.36478633f, 0.33819661f, -0.60946232f, -0.24563423f, -0.13701373f, 0.64816225f, 0.35282952f, 0.18390462f, 
    -0.03067678f, -1.41808033f, -1.07691061f, -0.92600131f, -0.35455918f, -0.63115513f, 0.71677387f, 1.79008377f, 
    0.41201201f, 0.32058242f, 0.73577917f, -0.33310837f, -0.43850610f, 0.15154120f, -0.16774023f, 0.04911581f, 
    -0.03808969f, -0.11509821f, -0.15958489f, -0.15300454f, -0.21811102f, -0.09486419f, -0.35483414f, 0.02093019f, 
    -0.18449993f, 0.06016240f, -0.68664491f, 1.74640501f, 0.76827955f, -0.57714218f, -0.46581593f, -1.71825397f, 
    0.60598969f, -0.28917545f, -0.68653190f, -0.50548059f, 0.37002704f, 0.28441551f, -0.22595216f, -0.00755134f, 
    -0.07524969f, -0.04378522f, -0.12526502f, 0.01088508f, -0.10049928f, -0.14704317f, 0.08274023f, 0.04632242f, 
    0.24499984f, 0.25686711f, 0.14790839f, -0.05701578f, -1.56105196f, 0.47640073f, 1.90752208f, -0.29471400f, 
    -1.20218241f, 0.67625540f, 1.08427727f, -0.53280938f, -0.16526163f, 0.59358811f, 0.15696424f, 0.13001174f, 
    0.35688612f, 0.14975676f, -0.23632096f, 0.10580795f, -0.19136868f, -0.01681200f, -0.53942078f, -0.37078679f, 
    -0.06965765f, -0.01136724f, 0.24402277f, 0.13907364f, -1.13627791f, 1.66898811f, 0.56661332f, -0.27398533f, 
    1.32413840f, -0.40605029f, 1.09653080f, 0.75533211f, -0.75130987f, 0.46123925f, -0.39523551f, -0.49316433f, 
    0.24522442f, -0.24203031f, 0.15180412f, 0.38762850f, -0.03032544f, 0.08327030f, 0.30944246f, 0.10729832f, 
    -0.10920192f, 0.22348860f, -0.13273166f, -0.15068112f, -0.06788088f, 0.39417896f, 0.63252574f, -0.18696621f, 
    0.68336630f, 0.28339684f, 0.51637232f, 0.05609861f, 1.08426869f, 1.01816022f, 0.15383707f, -0.84876978f, 
    -0.40331256f, -0.43659148f, -0.88048112f, -0.12390909f, -0.60093325f, -0.11052296f, -0.49394676f, -0.00603500f, 
    -0.51212740f, -0.49988517f, -0.40361282f, -0.81585616f, -0.37320271f, -0.11085342f, 2.04405284f, 0.76469547f, 
    0.44581786f, 0.93628168f, 0.08915404f, 1.04786599f, -0.06845851f, -0.60585612f, 0.70963645f, 0.22172643f, 
    -0.17737569f, 0.30272201f, -0.47484130f, -0.02184641f, 0.08930768f, 0.18196693f, -0.20647947f, -0.08036204f, 
    0.03116268f, 0.00654616f, -0.25664735f, 0.45000312f, 0.33215663f, -0.10861189f, 0.61982483f, 1.08273458f, 
    1.11466432f, 1.05370879f, 0.09777729f, -0.58146310f, 0.19721547f, 0.89903539f, -0.17306177f, -0.61640626f, 
    -0.32272807f, 0.17914027f, 0.39508799f, -0.56421208f, -0.14515476f, 0.65258741f, 0.48044488f, 0.39816159f, 
    0.66212928f, 0.47086298f, -0.13615370f, 0.29696882f, -0.21273385f, -0.62030333f, -0.04925906f, -0.08255061f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.43092594f, 0.00529087f, 0.51965445f, 0.39209357f, 0.55257303f, 0.12465260f, 0.66121912f, 0.01642780f, 
    0.57451099f, 0.18923976f, 0.24745148f, 0.35352722f, -0.11310669f, 0.33118859f, 0.36196828f, 0.29418573f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00260742f, 0.03824121f, 0.03626489f, 0.16726318f, -0.06952303f, -0.01301705f, -0.00469463f, -0.03905327f, 
    -0.00919269f, -0.11925515f, -0.07621109f, 0.09338222f, 0.08917054f, 0.29261547f, 0.08692304f, -0.67536944f, 
    0.07573329f, -0.18847874f, 0.19215694f, 0.19996858f, 0.11694924f, -0.10819347f, -0.13807225f, 0.00888139f, 
    0.26971212f, 0.03381421f, -0.08883051f, 0.17431568f, -0.33562288f, -0.11145896f, 0.20015280f, 0.06985319f, 
    -0.01312925f, -0.01570821f, -0.13494198f, -0.22415400f, -0.28121713f, -0.18026556f, 0.35486844f, -0.35790199f, 
    0.02360882f, 0.14199702f, -0.11050563f, -0.30091494f, 0.12336566f, -0.14444581f, 0.14393966f, 0.13135551f, 
    -0.71874815f, -0.69805348f, 0.10865797f, 0.00037931f, -0.25641686f, -0.01851577f, 0.11611192f, 0.00420662f, 
    -0.07523565f, 0.12117760f, -0.15058023f, -0.08924693f, 0.08508728f, -0.05076847f, -0.00215088f, 0.03516398f, 
    -0.18881842f, -0.21704681f, 0.05035862f, 0.01201553f, -0.05122491f, 0.09016614f, 0.07289403f, -0.05213812f, 
    -0.03113331f, 0.04835556f, -0.08275779f, -0.43040881f, -0.03960029f, -0.02957355f, 0.12101264f, -0.08268309f, 
    -0.10494643f, -0.10523976f, 0.01517238f, 0.12943721f, 0.54639202f, -0.36514843f, -0.13642029f, -0.52007204f, 
    0.07444361f, 0.12356705f, 0.23921852f, -0.15541714f, -0.03133237f, -0.02466897f, -0.14187209f, 0.22379041f, 
    0.20742187f, 0.25800446f, -0.13600574f, 0.27106884f, -0.34681413f, -0.15219586f, -0.16453700f, -0.00252841f, 
    -0.11477911f, 0.14066449f, 0.07246578f, -0.04133173f, 0.53338516f, 0.15020022f, 0.22248274f, -0.58943218f, 
    0.10694266f, 0.25401673f, 0.00933751f, 0.19534698f, -0.03789863f, 0.07400864f, -0.11476489f, 0.14877047f, 
    -0.49900469f, 0.15894163f, -0.04956141f, -0.05504992f, 0.03619076f, -0.03867491f, -0.10679855f, -0.13100129f, 
    -0.17668158f, -0.11895227f, 0.02296277f, -0.11561184f, 0.01855695f, -0.04966492f, -0.36129111f, 0.59102005f, 
    0.13546437f, 0.04373315f, -0.02144683f, -0.36316940f, 0.06881481f, 0.00172984f, 0.01744688f, 0.12175095f, 
    -0.26121101f, -0.05797706f, 0.50335735f, -0.22133391f, -0.23944442f, -0.04383061f, 0.09769071f, -0.19308469f, 
    0.06518627f, -0.10742429f, 0.06372179f, -0.02509287f, 0.08469649f, 0.01412796f, 0.14959961f, 0.22975993f, 
    -0.16237126f, 0.03807446f, 0.10666529f, -0.02414251f, 0.01597857f, -0.02121069f, 0.09165280f, 0.03455322f, 
    0.43989131f, -0.53868324f, -0.21948203f, 0.58294177f, -0.11769339f, -0.10094167f, -0.17746799f, 0.19477005f, 
    0.08644021f, 0.19365773f, 0.02563701f, -0.06314348f, -0.19338614f, 0.43529907f, -0.07321149f, -0.33894640f, 
    -0.40092599f, -0.02386124f, 0.01129539f, -0.05227618f, 0.09357050f, 0.07400624f, 0.04796843f, -0.15785705f, 
    -0.03342295f, -0.07111838f, -0.14680199f, 0.11234030f, -0.24834917f, -0.15834947f, 0.25033334f, -0.16102681f, 
    0.06855506f, -0.09849338f, 0.18514509f, -0.10050039f, 0.36710170f, -0.06195995f, -0.05649289f, -0.20864423f, 
    -0.03367995f, 0.06007580f, -0.08866709f, -0.03060902f, -0.13986254f, -0.22176959f, -0.20877792f, -0.16932182f, 
    -0.29846001f, -0.27703333f, 0.08375524f, 0.00032558f, 0.23219194f, 0.13724773f, -0.13264506f, 0.01060011f, 
    -0.06536422f, 0.01664375f, -0.08403369f, 0.22340342f, 0.05337149f, -0.24774113f, -0.07500280f, -0.21131308f, 
    -0.02485363f, 0.03331910f, 0.12601261f, 0.00142932f, -0.10781385f, 0.17470402f, -0.09827178f, -0.08657727f, 
    0.51778674f, 0.14230892f, -0.54199010f, 0.12282128f, -0.23942854f, -0.07838032f, -0.09535235f, -0.08468863f, 
    0.02070684f, -0.35750085f, 0.25088933f, -0.06001964f, 0.37175226f, -0.09879769f, 0.43127182f, 0.35273200f, 
    -0.17715719f, 0.00922438f, -0.01418028f, 0.14403999f, 0.13907865f, 0.10187268f, 0.06503168f, -0.03442771f, 
    -0.55019432f, -0.18179323f, 0.18209605f, -0.33550736f, -0.05649275f, 0.08313476f, 0.22896510f, 0.21038541f, 
    0.05651617f, 0.22443844f, 0.15119541f, -0.00992107f, -0.14696279f, -0.29993492f, 0.28477496f, -0.34145287f, 
    -0.18550776f, -0.14938422f, -0.11067711f, 0.08503818f, -0.20752186f, -0.10906065f, 0.05677777f, -0.08487878f, 
    0.32458401f, 0.04168242f, 0.21743496f, 0.43672648f, -0.07393761f, -0.03641176f, 0.19514060f, 0.04331297f, 
    -0.05871469f, -0.35973036f, 0.22606592f, -0.17124458f, 0.14358884f, 0.05704058f, -0.23970084f, -0.10957579f, 
    0.04720913f, -0.16140674f, -0.07336327f, -0.08353704f, -0.04321543f, 0.11844007f, -0.10222407f, -0.16085483f, 
    -0.66472900f, 0.37606195f, -0.85274762f, -0.56989497f, -0.09147555f, 0.25177860f, 0.09995274f, -0.09705188f, 
    0.16434529f, 0.02928731f, 0.02355709f, 0.03261823f, -0.57835954f, -0.12968421f, -0.01112721f, 0.43034744f, 
    -0.25888661f, 0.02524014f, -0.22297703f, -0.13220061f, 0.02632237f, -0.16650693f, -0.05824271f, 0.05654065f, 
    0.24514209f, 0.10574817f, -0.24366026f, -0.31930941f, 0.17351061f, 0.07872842f, -0.00278076f, -0.09146853f, 
    0.03656315f, 0.22647621f, -0.11662728f, -0.11108641f, -0.08079809f, 0.12976547f, -0.05591518f, 0.32289517f, 
    0.12873574f, 0.19719782f, -0.22532755f, 0.13266844f, 0.11033948f, -0.14338519f, -0.08256780f, -0.31357706f, 
    0.36140436f, 0.01882560f, 0.32296008f, 0.18457367f, -0.21416514f, -0.11295360f, -0.06700655f, 0.07567044f, 
    -0.14728096f, 0.03070641f, -0.03254655f, 0.02808375f, 0.23060760f, -0.01519946f, 0.06066992f, 0.20516099f, 
    0.03714940f, 0.09018129f, 0.01386858f, -0.06670163f, 0.08474156f, -0.08283447f, -0.12386704f, 0.27301961f, 
    -0.36589989f, 0.03433896f, -0.20375064f, -0.08268449f, -0.13581984f, 0.01776383f, 0.07570878f, -0.19568981f, 
    0.06084340f, 0.07254456f, -0.09588747f, 0.01157881f, -0.31423461f, -0.32627049f, 0.22925055f, -0.14611420f, 
    0.24385348f, -0.12091231f, 0.21212520f, -0.36598364f, -0.08102991f, 0.22424690f, -0.10522756f, 0.34642133f, 
    -0.00835761f, -0.11459030f, -0.15868406f, -0.12475147f, -0.04925851f, 0.10811610f, -0.20433532f, -0.02575336f, 
    -0.08215604f, 0.07823294f, 0.07990134f, -0.27857468f, -0.06603663f, -0.00219292f, -0.03165558f, -0.20249109f, 
    0.02234316f, -0.00588156f, 0.00913773f, -0.12020421f, -0.11317892f, -0.35658649f, 0.04631174f, -0.48538721f, 
    0.32526556f, 0.07267201f, 0.12930915f, -0.31439421f, -0.02470926f, -0.03515657f, -0.18353999f, 0.11073057f, 
    -0.21499258f, -0.05584798f, 0.09232353f, -0.00766903f, 0.14327864f, 0.05847997f, -0.01634134f, 0.27721563f, 
    0.11579848f, -0.02058036f, 0.01568661f, -0.15912417f, 0.00731782f, 0.00643889f, -0.08932384f, 0.09882250f, 
    -1.28720677f, 0.03511032f, -0.40635896f, -0.23878357f, 0.16757201f, -0.14567004f, -0.33214256f, -0.15485275f, 
    -0.24327306f, 0.09941570f, -0.09517186f, -0.09750610f, 0.22504909f, 0.09776334f, 0.23677909f, 0.08249379f, 
    -0.10444192f, -0.12262832f, 0.12536193f, -0.00871207f, -0.11592090f, -0.15160576f, 0.15427282f, -0.10680123f, 
    -0.36069211f, 0.19648193f, 0.12413038f, 0.15331765f, -0.04628967f, 0.13082831f, 0.07887613f, 0.04573466f, 
    -0.07666820f, 0.07579792f, -0.07698292f, 0.02281963f, 0.72112411f, 0.14542869f, 0.39439771f, 0.45937335f, 
    -0.27323154f, -0.51271111f, -0.17563958f, 0.32042891f, 0.08718447f, 0.02892476f, 0.07633666f, -0.15400760f, 
    0.37499064f, 0.12317225f, -0.97501922f, -0.48233485f, 0.20722669f, 0.26937062f, -0.09260260f, -0.14205045f, 
    -0.11630335f, -0.17735103f, -0.01101869f, -0.01665413f, 1.12970161f, -0.16317736f, -0.41346377f, 0.00337969f, 
    -0.23401047f, 0.19210023f, -0.04476155f, 0.00525035f, 0.03404717f, 0.17793401f, 0.15180156f, -0.18470526f, 
    0.23841178f, -0.19163881f, -0.26889053f, -0.00073101f, 0.14347899f, -0.07588007f, 0.03610367f, -0.38873550f, 
    0.00859970f, 0.04181290f, -0.08114917f, -0.04755478f, -0.03702423f, 0.13744885f, -0.30491528f, -0.07658359f, 
    0.10376672f, 0.22819661f, 0.16515738f, 0.15523596f, -0.08231463f, 0.16393200f, 0.06247957f, -0.08251631f, 
    0.31800136f, -0.10402713f, 0.09765385f, -0.23212618f, -0.00359592f, 0.16482811f, 0.05945364f, 0.03277994f, 
    -0.00234915f, 0.14889647f, 0.08571822f, -0.20140727f, -0.24188766f, 0.06914105f, 0.07141210f, -0.24818568f, 
    0.06384937f, 0.07730569f, 0.15975738f, -0.01604148f, -0.05177172f, -0.20021844f, -0.12130459f, -0.23956814f, 
    0.29245546f, 0.13198866f, -0.12446246f, 0.16999471f, -0.12548503f, 0.07129771f, 0.07397062f, -0.02440926f, 
    0.00182793f, 0.17793187f, 0.11653143f, -0.00234014f, 0.25089329f, -0.54516083f, 0.00613749f, -0.14978342f, 
    -0.11157476f, 0.11065438f, -0.03645992f, 0.02836207f, -0.04534011f, 0.09276175f, 0.00854754f, 0.20361733f, 
    -0.01230850f, 0.13082960f, 0.20256284f, 0.43615961f, 0.24507159f, 0.29670984f, -0.00598072f, -0.07412270f, 
    -0.06224924f, -0.11216863f, 0.04938353f, -0.46647832f, 0.44935524f, 0.00415925f, 0.20483693f, 0.40365002f, 
    0.14587063f, 0.05644192f, -0.03688993f, 0.27559617f, -0.03108557f, -0.22963864f, 0.04184901f, -0.21648701f, 
    -0.32000443f, 0.40187693f, 0.27077642f, 0.11837111f, -0.03509067f, 0.07200345f, 0.03598324f, -0.05693202f, 
    -0.01995819f, 0.11482159f, -0.23219264f, 0.24202174f, -0.59936076f, -0.60916674f, -0.29268485f, 0.19271688f, 
    -0.06323028f, 0.07540510f, -0.07506354f, -0.32842439f, 0.01745239f, -0.08964164f, -0.11172458f, -0.00503007f, 
    0.39394060f, -0.11142981f, 0.00574649f, 0.21075369f, 0.13346626f, 0.03173474f, -0.09216404f, 0.12779601f, 
    -0.00759908f, 0.06705935f, -0.06138034f, -0.12064147f, 0.27244306f, 0.25164127f, 0.23795177f, 0.12435022f, 
    -0.21464984f, 0.12766212f, -0.07610218f, -0.01524570f, -0.11051305f, -0.11362243f, -0.11144961f, 0.09267710f, 
    -0.15207487f, -1.21055663f, -0.06855356f, 0.04482324f, -0.00427213f, -0.04057744f, -0.22574310f, -0.00115875f, 
    0.03800904f, 0.02761570f, -0.12971489f, 0.01573044f, -0.33540472f, 0.08887849f, -0.06076520f, -0.34248322f, 
    -0.13489567f, -0.29727930f, 0.04419025f, -0.03871654f, 0.02363510f, -0.16236523f, 0.03532286f, -0.06988831f, 
    -0.54681301f, 0.59793687f, 0.31102556f, -0.18338174f, 0.27639207f, 0.11240862f, 0.04922891f, 0.17946507f, 
    -0.12237502f, 0.17936160f, -0.03611109f, -0.04838240f, -0.11029815f, 0.00613626f, 0.35406122f, -0.28925732f, 
    -0.04133571f, 0.10678815f, 0.17315054f, 0.13661768f, -0.13240431f, -0.03603493f, -0.13484173f, -0.16463424f, 
    -0.42980695f, 0.27824125f, 0.41834709f, -0.06349324f, -0.09072212f, -0.02284402f, 0.11427194f, 0.26479223f, 
    0.22915769f, -0.17653383f, -0.05273245f, 0.04391859f, -0.27214414f, -0.43839803f, 0.18435045f, -0.03105594f, 
    -0.15592644f, -0.17812340f, 0.19024312f, 0.04252221f, -0.24050036f, 0.25199011f, 0.25488696f, 0.11810917f, 
    -0.46362361f, -0.63828605f, -0.76603878f, -0.27283719f, 0.05309024f, -0.07619911f, -0.13288309f, -0.01414371f, 
    0.00268783f, -0.04707305f, -0.01520758f, 0.00851870f, -0.60944122f, -0.02800106f, -0.17999105f, 0.08405190f, 
    -0.15865643f, -0.13500358f, -0.27991652f, 0.18055722f, -0.00454780f, -0.03096708f, 0.26491481f, -0.16969034f, 
    -0.07432721f, -0.19814657f, 0.28704256f, 0.03749340f, -0.08531203f, 0.13726887f, -0.27962849f, 0.04230932f, 
    0.19643503f, -0.16271450f, 0.16992375f, 0.21936692f, 0.32994667f, -0.05062633f, 0.15920143f, 0.08529422f, 
    0.12326963f, 0.15434191f, -0.01657766f, 0.01902097f, -0.02527283f, 0.01712343f, -0.14053012f, 0.09365038f, 
    -0.41333893f, -0.08489210f, 0.35817322f, 0.09248952f, -0.03296394f, -0.15248889f, -0.16190311f, -0.28969625f, 
    0.06586996f, -0.01043951f, 0.02036041f, -0.11036896f, -0.59580928f, 0.17156814f, 0.07546014f, -0.09796337f, 
    -0.04660038f, -0.12180325f, -0.16703543f, 0.01598415f, 0.05008179f, -0.26648343f, 0.10343470f, -0.00511325f, 
    -0.17940463f, -0.19737214f, 0.47705638f, -0.06047084f, 0.07301618f, 0.12809719f, 0.14509436f, 0.27225357f, 
    0.11131097f, -0.06193443f, -0.11777472f, 0.03801675f, -0.39145443f, -0.06023354f, -0.23451780f, 0.26741043f, 
    -0.01722475f, -0.08411674f, 0.09543137f, 0.13069031f, -0.01290473f, -0.04052394f, -0.21990888f, -0.15072770f, 
    0.57550269f, -0.05647413f, -0.06312390f, 0.12778331f, -0.04043677f, 0.08884544f, 0.06568474f, 0.04426837f, 
    0.11904353f, -0.15377025f, 0.03017469f, 0.13996765f, -0.20140399f, -0.38611659f, 0.05710502f, 0.30830511f, 
    0.15043113f, -0.01729869f, 0.06204337f, -0.10289908f, -0.04798590f, 0.12098391f, -0.00719675f, -0.13521372f, 
    -0.21686271f, -0.00121973f, 0.06235007f, -0.12306195f, -0.07083640f, 0.03320109f, -0.16064267f, 0.10013438f, 
    0.34007251f, 0.03346903f, -0.21758597f, 0.27316219f, -0.86188632f, -0.10526098f, -0.10775188f, 0.35004658f, 
    0.18801211f, -0.04703416f, 0.15349939f, 0.17570452f, 0.03350787f, 0.01238599f, 0.06632596f, 0.12270465f, 
    -0.23677136f, -0.07243384f, 0.37999281f, 0.17036444f, -0.21381292f, -0.07915894f, 0.21166013f, -0.22468621f, 
    0.10994857f, -0.03807828f, -0.12166949f, -0.12491663f, -0.80888337f, -0.14900282f, -0.06673547f, -0.17777689f, 
    -0.04933356f, -0.03334296f, -0.11117413f, 0.16609226f, -0.17015831f, 0.03649627f, -0.27332452f, -0.07867335f, 
    -0.06175459f, 0.35344988f, -0.37493655f, 0.19367230f, -0.34664658f, -0.05718631f, 0.06467780f, -0.07403442f, 
    -0.09958535f, -0.20349620f, -0.01876302f, -0.11895695f, 0.25138372f, -0.37695765f, 0.05563089f, 0.15058829f, 
    0.02802610f, -0.07412105f, 0.28413835f, 0.27162418f, -0.24756724f, 0.07550730f, 0.16250810f, 0.09328479f, 
    0.06254105f, 0.48101196f, 0.17910317f, -0.05821021f, -0.09391800f, -0.09538161f, 0.04927208f, 0.02084343f, 
    -0.06296293f, -0.20378588f, 0.05755523f, 0.08264913f, -0.36214352f, -0.10301006f, 0.41097930f, -0.55279768f, 
    0.07472221f, 0.03496826f, -0.06537750f, 0.24687438f, 0.06010004f, 0.25262579f, 0.09304837f, -0.10399389f, 
    0.06564201f, 0.04763419f, 0.07793646f, 0.11192622f, 0.02422476f, -0.17676651f, -0.08600975f, 0.30306602f, 
    -0.46179903f, 0.31698245f, -0.13963374f, -0.15229741f, -0.03903811f, -0.27540550f, 0.35508943f, 0.40633345f, 
    0.01118347f, -0.19192377f, 0.23590532f, 0.02662808f, 0.18404876f, -0.17392780f, 0.14006253f, -0.38379991f, 
    0.23235998f, -0.00791008f, -0.08330566f, -0.15349945f, -0.16880734f, -0.06469946f, -0.00680399f, 0.04546247f, 
    -0.27586153f, -0.05803189f, 0.28060222f, 0.25020924f, -0.23313206f, -0.01381891f, 0.21115062f, 0.31660536f, 
    -0.12799001f, 0.14535739f, -0.05238400f, 0.22265553f, -0.11587614f, 0.19274752f, -0.03276006f, 0.36304143f, 
    -0.31143379f, -0.14869498f, -0.02906613f, 0.17003016f, 0.15948720f, 0.25478426f, 0.02411339f, 0.01236558f, 
    0.06946681f, -0.13816187f, 0.00456592f, 0.10594099f, 0.26213309f, 0.08463110f, 0.17831549f, -0.10397874f, 
    -0.16154495f, 0.26967868f, 0.09858789f, 0.04910887f, -0.16099748f, 0.00945697f, -0.00367442f, 0.32658690f, 
    -0.53538591f, -0.36581209f, 0.09196997f, 0.12706976f, 0.16817649f, -0.25200036f, -0.26839143f, -0.10784132f, 
    -0.00171556f, -0.00900428f, 0.09307856f, -0.01716251f, 0.03193429f, 0.04557785f, -0.42249089f, -0.29370016f, 
    -0.10882811f, 0.01370700f, -0.07026871f, -0.16168113f, 0.11365072f, -0.09625740f, 0.17899364f, -0.22685841f, 
    0.18910968f, -0.09055212f, 0.14988735f, -0.07832608f, -0.26147485f, -0.04415603f, -0.04166336f, -0.02809648f, 
    0.11741462f, 0.07015087f, 0.05271297f, -0.03575636f, -0.76066560f, 0.01419966f, -0.55836254f, -0.33822718f, 
    0.26522467f, 0.12310968f, 0.07659929f, -0.33657447f, 0.12336508f, -0.07929690f, -0.10378243f, -0.16699097f, 
    0.07269890f, -0.02095889f, 0.00911984f, 0.68248659f, -0.28447837f, -0.26804888f, -0.15152839f, 0.14042991f, 
    0.12971203f, 0.11182357f, -0.20217548f, 0.09857456f, -0.25210038f, 0.23442590f, -0.01462809f, -0.37950474f, 
    0.03782676f, -0.03336724f, -0.02567075f, 0.19096580f, -0.00224668f, -0.14103648f, 0.14884521f, -0.07540145f, 
    -0.27074683f, -0.17956999f, 0.29758176f, -0.20380257f, -0.10393461f, -0.11196591f, -0.04383636f, -0.07160363f, 
    0.03958271f, 0.07713445f, 0.15877132f, 0.14046800f, 0.45504439f, 0.25401270f, 0.26511079f, -0.13269070f, 
    0.02613092f, 0.13781396f, -0.20377158f, -0.34576005f, -0.24059604f, -0.05789892f, -0.27445605f, -0.32875526f, 
    -0.06280564f, -0.19057080f, -0.18180081f, -0.06523461f, 0.15357789f, 0.00785554f, 0.16927300f, -0.07543860f, 
    -0.01731234f, -0.03036949f, -0.08496951f, -0.03902759f, 0.13881533f, 0.00655082f, -0.16127352f, 0.13899536f, 
    0.02477205f, 0.16544588f, -0.12394498f, 0.15261433f, -0.01030961f, 0.06792844f, 0.17989676f, 0.13355629f, 
    -0.18067095f, 0.16848081f, -0.13389881f, -0.45283678f, 0.23863304f, 0.23667760f, 0.07441748f, 0.00258817f, 
    0.01576177f, -0.10149729f, -0.05025545f, 0.14701371f, -0.18247154f, 0.25855133f, -0.11392776f, 0.19615811f, 
    -0.30420214f, -0.02504942f, 0.00019828f, 0.07303113f, 0.06231683f, 0.10545845f, 0.13691397f, 0.27873889f, 
    0.26082131f, 0.42011008f, -0.15399666f, -0.40046319f, 0.00218483f, 0.08557621f, 0.03800242f, 0.12130343f, 
    -0.08943088f, -0.12174991f, -0.30116203f, 0.12184638f, 0.23878470f, -0.28324515f, -0.15143599f, -0.03554205f, 
    -0.16377243f, 0.02832158f, 0.06858408f, -0.13259946f, -0.09527925f, -0.16292292f, -0.03228420f, -0.25810790f, 
    -0.19386072f, -0.19477747f, -0.29797202f, -0.14379512f, 0.25790602f, -0.15723075f, 0.00462704f, 0.09926625f, 
    0.05862197f, 0.10548800f, -0.15632032f, 0.04778856f, 0.32711917f, 0.19846216f, 0.37920305f, -0.69626790f, 
    -0.29938275f, -0.11483423f, 0.08158273f, -0.02123155f, 0.20877020f, -0.16938084f, 0.07799611f, -0.06722213f, 
    0.11163812f, -0.04859872f, -0.24857879f, 0.50211936f, -0.18439601f, -0.17175891f, 0.06260359f, -0.29049036f, 
    -0.00093391f, 0.07961206f, -0.11276399f, 0.03121354f, -0.34242237f, -0.11214466f, -0.57829797f, 0.34966534f, 
    0.08292078f, 0.19493003f, -0.05454793f, 0.14121200f, 0.01377075f, 0.08481902f, -0.06962479f, 0.02943007f, 
    0.14555359f, 0.29786265f, 0.26017243f, -0.11626606f, 0.12627998f, -0.02775789f, -0.08650599f, 0.09507294f, 
    -0.23495190f, 0.22211117f, 0.02694506f, -0.03727975f, 0.10880485f, -0.93604743f, -0.22798526f, -0.07082991f, 
    -0.12689978f, 0.14454363f, -0.18568237f, -0.09387481f, -0.02129333f, -0.00641223f, 0.13789673f, 0.34822312f, 
    -0.19980891f, -0.34557968f, -0.04473582f, 0.01236933f, 0.20366490f, -0.02269559f, 0.12893899f, 0.05113695f, 
    -0.22028969f, -0.02313782f, -0.02563423f, -0.01903966f, 0.70787519f, -0.25433499f, 0.39430392f, -0.23447078f, 
    0.08347092f, -0.02717707f, 0.27214670f, -0.15296136f, 0.19521709f, -0.13617742f, 0.11422198f, -0.05187280f, 
    -0.09208275f, 0.00147933f, 0.09082499f, 0.10370855f, 0.03133113f, 0.11552358f, 0.16719455f, 0.14404637f, 
    -0.08995218f, -0.05051358f, -0.17971346f, -0.25006878f, -0.58532524f, 0.10352096f, -0.06859797f, -0.27149519f, 
    -0.12927918f, -0.15803966f, 0.06120099f, -0.03773181f, 0.13010140f, 0.10566141f, 0.02864051f, 0.30077624f, 
    -0.57066637f, 0.28075710f, 0.12625097f, -0.10915919f, -0.38037890f, 0.12113544f, 0.05457788f, 0.09417371f, 
    -0.02296609f, -0.04448744f, 0.03327010f, -0.11204500f, 0.30869904f, 0.13929316f, -0.06626235f, 0.28073341f, 
    0.16781044f, -0.28242397f, 0.12514530f, 0.05521818f, -0.05205020f, -0.19579598f, -0.07352101f, -0.15990007f, 
    -0.14780886f, -0.15086652f, -0.18961219f, 0.22666419f, -0.07947522f, -0.26458979f, 0.04751600f, -0.05467143f, 
    -0.07880331f, -0.02068271f, 0.02842864f, -0.01117966f, -0.07121491f, 0.13604264f, -0.09206625f, 0.06837688f, 
    -0.06494758f, 0.13307215f, 0.03284675f, -0.03333388f, 0.00252920f, 0.08231334f, 0.13866264f, 0.06192539f, 
    -0.03596827f, -0.05278493f, -0.20795208f, 0.17009521f, -0.24068147f, -0.30360988f, 0.12209063f, -0.03788095f, 
    -0.06355158f, 0.18242149f, 0.08692492f, -0.24108772f, -0.23450658f, -0.00897679f, -0.13657710f, 0.06045451f, 
    -0.22903845f, -0.10175529f, -0.17103447f, -0.01078334f, -0.13693188f, -0.01148309f, 0.06553925f, -0.04092641f, 
    0.13951035f, 0.26159292f, 0.30937305f, 0.12815417f, -0.09446425f, 0.00780211f, -0.05336951f, -0.01765638f, 
    0.01427661f, -0.03082413f, -0.37535551f, -0.28960213f, -0.50412846f, 0.07539301f, -0.29735136f, -0.51164329f, 
    0.17069656f, 0.02464221f, 0.07464659f, -0.15069796f, -0.07765394f, 0.10248227f, -0.07080811f, -0.13126123f, 
    0.51047981f, 0.61158389f, -0.08976597f, 0.77443039f, 0.16754442f, -0.24472027f, -0.11345811f, 0.10182451f, 
    0.01147217f, 0.04114054f, -0.06190933f, -0.19124833f, -0.49615136f, 0.50771278f, -0.05348842f, 0.08538317f, 
    0.14093733f, -0.10374749f, -0.06131405f, 0.02010631f, 0.01729018f, -0.07745030f, -0.06754757f, -0.05532373f, 
    -0.22061977f, -0.39230576f, -0.25865439f, -0.51382166f, -0.06705753f, -0.24150939f, -0.14432740f, -0.08777332f, 
    0.01047280f, -0.05723746f, -0.07035913f, -0.05073512f, -0.00329618f, 0.46668488f, 0.32920045f, 0.37972558f, 
    0.26360124f, 0.08184923f, 0.33932930f, -0.03949338f, -0.19717930f, 0.06115001f, 0.14880417f, -0.13139135f, 
    0.49513850f, -0.58155805f, 0.53128153f, 0.41956371f, 0.25253338f, -0.21489750f, -0.07518975f, -0.15318707f, 
    -0.23311317f, -0.27792305f, -0.02292097f, -0.11801204f, 0.75979042f, 0.09056325f, -0.15757602f, -0.27446619f, 
    -0.30360758f, -0.05329681f, 0.01928726f, -0.35343418f, 0.04421188f, -0.02420672f, -0.12791879f, -0.05943114f, 
    0.36409312f, -0.43675226f, 0.35524079f, 0.55731207f, -0.13801138f, 0.11274819f, -0.09958006f, -0.17671292f, 
    0.04582080f, -0.13976265f, -0.13427544f, 0.05816568f, 0.35713217f, 0.17862332f, -0.13851433f, -0.24952820f, 
    -0.17754322f, -0.19067647f, -0.07428057f, -0.22487210f, 0.01431283f, 0.05124722f, 0.05833783f, -0.14816891f, 
    -0.61716890f, 0.10508584f, -0.14655598f, -0.15032966f, -0.22623338f, 0.07506700f, 0.01876985f, -0.05730893f, 
    -0.21686868f, 0.06861655f, -0.13846871f, -0.15293707f, -0.38524270f, -0.22603542f, -0.24108343f, -0.22889863f, 
    0.17512956f, -0.15557140f, 0.18191636f, 0.02933806f, 0.05736572f, 0.07726797f, -0.21814872f, -0.02405777f, 
    0.00201815f, -0.53989309f, 0.05984541f, -0.21405542f, 0.32845348f, -0.01942266f, -0.03970312f, 0.01529348f, 
    0.25944939f, 0.11035208f, -0.29259109f, -0.35521254f, 0.09843118f, 0.03797294f, -0.21783845f, -0.04688713f, 
    0.03001928f, -0.20267168f, -0.27145359f, 0.01866408f, 0.02224854f, 0.26068494f, 0.05917004f, -0.19838177f, 
    -0.33912843f, -0.30538633f, -0.46552223f, -0.14639221f, 0.04857394f, 0.04383769f, 0.12721017f, -0.01881331f, 
    0.03343535f, 0.01241288f, 0.07875927f, -0.20460680f, -0.12037066f, 0.14127240f, -0.52548170f, -0.18153177f, 
    -0.11941531f, -0.07512008f, 0.07770065f, -0.20344204f, 0.15413424f, 0.24600838f, -0.09216447f, 0.12356513f, 
    -0.18427527f, 0.04899666f, -0.42705616f, -0.35373968f, 0.12843278f, 0.11766091f, -0.07144523f, -0.28573230f, 
    0.01640875f, -0.05831325f, 0.19055153f, 0.17005181f, -0.07653784f, -0.10083468f, -0.11910469f, 0.55503786f, 
    0.18641955f, 0.09119106f, -0.12059929f, 0.05185699f, -0.06109178f, -0.14590646f, 0.30028951f, 0.13674530f, 
    -0.22983879f, 0.32472488f, -0.23312311f, -0.77745348f, 0.13880606f, -0.16922872f, -0.20303611f, -0.04712493f, 
    0.17381816f, -0.10454822f, 0.16392268f, -0.20092863f, -0.02357800f, 0.82689351f, -0.39590144f, 0.08650836f, 
    -0.05235175f, 0.00351107f, -0.48942986f, 0.11664017f, -0.04593915f, -0.06996217f, 0.26789817f, 0.14784691f, 
    0.29475862f, -0.16289899f, -0.21692656f, 0.21475713f, 0.15754704f, -0.12053492f, -0.04575196f, -0.17347519f, 
    -0.02507274f, -0.18746866f, 0.14724869f, -0.11693615f, -0.20351988f, -0.17834401f, 0.45527741f, 0.20439216f, 
    -0.34580299f, -0.07849182f, -0.02742510f, 0.20875175f, 0.00202224f, -0.18551825f, -0.23910528f, -0.08179369f, 
    0.11556769f, -0.05903781f, -0.14158905f, -0.57640082f, -0.06804026f, -0.17333511f, -0.04659395f, -0.04507699f, 
    0.15951727f, 0.02012712f, 0.04942723f, 0.16782695f, 0.21986850f, -0.57694608f, 0.26109460f, -0.16033660f, 
    0.07556281f, -0.22386925f, 0.05396370f, 0.05554659f, -0.05123444f, 0.00517851f, 0.09090130f, 0.09299584f, 
    0.26474670f, 0.21728337f, -0.00817010f, 0.35547829f, 0.00291804f, -0.18444653f, -0.30845153f, -0.19038512f, 
    -0.08559324f, 0.19655560f, 0.17724073f, -0.12956123f, 0.18305063f, -0.25047332f, -0.09333082f, 0.05431021f, 
    0.08529469f, -0.30276078f, -0.07366604f, -0.12795000f, -0.18583444f, -0.01087879f, -0.13659139f, -0.37791666f, 
    0.35176665f, -0.04882662f, 0.35872003f, 0.34622318f, 0.20018035f, 0.06713959f, 0.11877809f, -0.22903118f, 
    -0.05933776f, 0.19225137f, -0.19651067f, -0.23230959f, 0.37705022f, 0.00994748f, -0.38444367f, -0.02646341f, 
    0.00604811f, -0.00559406f, 0.04054651f, -0.13618779f, -0.17955711f, -0.03085340f, 0.19659093f, 0.25330520f, 
    -0.01332217f, -0.16964443f, 0.04463160f, -0.20859991f, -0.04703056f, 0.02806780f, 0.03563280f, -0.12683451f, 
    -0.18081932f, 0.08582264f, -0.06556822f, 0.06075110f, -0.44260773f, 0.44638410f, -0.37787202f, -0.06838435f, 
    -0.06921547f, 0.24544564f, -0.33619997f, 0.07930259f, -0.16803040f, -0.01241280f, 0.00222701f, 0.19670182f, 
    -0.28383827f, 0.09263693f, 0.04969990f, -0.54663432f, -0.06635160f, 0.08170977f, -0.02011367f, 0.10541181f, 
    0.28985429f, 0.00595192f, 0.05054073f, -0.06044479f, 0.12383283f, 0.37355393f, -0.46615458f, 0.09875670f, 
    0.19171982f, 0.00260438f, -0.07686505f, 0.19999026f, 0.04849445f, -0.06644755f, 0.01567578f, -0.04578568f, 
    -0.22856259f, -0.14905983f, -0.00703168f, 0.01600337f, 0.00631189f, -0.02681229f, -0.12756476f, 0.20404910f, 
    -0.05863307f, 0.34511307f, 0.13332187f, -0.17447978f, -0.67949015f, 0.42868382f, -0.18794429f, -0.52699369f, 
    0.27227217f, -0.17814161f, -0.15471038f, -0.10204540f, -0.05667401f, -0.05989824f, -0.06713843f, -0.24527137f, 
    -0.44111928f, -0.15371156f, 0.50316292f, -0.30991915f, -0.00929759f, 0.17300402f, -0.00833690f, 0.16690226f, 
    0.04500182f, -0.35105848f, -0.16591783f, 0.05290684f, -0.51938850f, 0.06555359f, 0.70415014f, 0.17450987f, 
    -0.01146914f, 0.02908045f, 0.06417006f, 0.07401593f, 0.12735248f, -0.04458505f, -0.00555425f, 0.02977956f, 
    -0.15173757f, -0.03454297f, -0.29667419f, -0.32517910f, -0.02103568f, 0.13623480f, 0.12974486f, 0.00214366f, 
    -0.18038854f, -0.06900514f, -0.10990845f, 0.00626920f, 0.13674854f, -0.23221740f, 0.03027006f, -0.00430036f, 
    0.14431763f, 0.00625278f, -0.12248550f, 0.04387152f, 0.11013813f, 0.06380185f, -0.01291756f, 0.13074318f, 
    0.39979127f, -0.70725757f, 0.27549809f, -0.35135561f, -0.12797330f, 0.05567087f, -0.08516482f, -0.00370868f, 
    -0.04977944f, -0.06215353f, 0.23992352f, -0.11884532f, -0.17185505f, 0.09388822f, -0.02978721f, 0.04249069f, 
    0.12526260f, -0.13837028f, 0.00549353f, 0.13486500f, -0.05591379f, 0.15753353f, 0.14321756f, -0.02587359f, 
    0.93934810f, -0.80664635f, -0.26304647f, 0.07905225f, 0.07164842f, 0.05839211f, 0.06361229f, -0.02822165f, 
    0.15597625f, -0.06903114f, 0.02581712f, 0.03855378f, -0.26557100f, 0.15748815f, -0.00537411f, 0.08679163f, 
    -0.00882718f, -0.12108143f, -0.03431686f, -0.04233997f, 0.10661859f, 0.25737286f, -0.02534465f, 0.12277591f, 
    -0.16742927f, 0.63922721f, -0.01360409f, -0.57575727f, 0.26274022f, 0.15374489f, -0.13793182f, -0.30714646f, 
    -0.00917737f, -0.07867455f, 0.15743914f, -0.07356539f, -0.10644422f, 0.10828004f, 0.11521364f, 0.30851007f, 
    0.03460639f, -0.10935130f, 0.02760327f, -0.16929515f, -0.14288519f, 0.06762659f, 0.00187621f, -0.24372908f, 
    -0.30998281f, 0.19817060f, 0.37284508f, -0.17394634f, 0.25920904f, -0.08500151f, -0.11523025f, 0.08740610f, 
    0.10213184f, -0.00401282f, -0.11124189f, -0.12423871f, -0.80216479f, -0.28565836f, 0.39425230f, -0.35604423f, 
    0.00912888f, 0.13854612f, -0.04782322f, -0.11692791f, 0.19794577f, -0.22427997f, -0.14086978f, -0.29437801f, 
    0.45674431f, 0.12405974f, 0.11908513f, -0.00165986f, 0.06750912f, -0.15275633f, 0.05880473f, 0.09101465f, 
    0.06673899f, 0.04864497f, 0.05748881f, -0.04812395f, 0.39463717f, 0.34681892f, -0.08244253f, -0.14831358f, 
    0.35811794f, -0.14866723f, 0.40146920f, 0.08709767f, 0.26933911f, 0.21347080f, 0.07550795f, 0.14617199f, 
    0.27159020f, 0.05013952f, -0.04596406f, 0.01041926f, 0.10376423f, 0.08343238f, -0.04294398f, -0.28215635f, 
    0.07031018f, -0.03798739f, 0.29857755f, -0.06810801f, -0.40093735f, -0.12978606f, -0.28976274f, -0.74770331f, 
    -0.07337643f, -0.02507341f, -0.15653040f, 0.12897357f, 0.10626179f, 0.02965798f, 0.22304188f, 0.24781406f, 
    0.08471071f, 0.06781665f, -0.04413017f, -0.09691273f, 0.23786503f, 0.20906247f, 0.20403804f, -0.04818623f, 
    -0.19751287f, 0.28153548f, 0.04128967f, 0.02296562f, -0.24312118f, -0.28144446f, -0.25078058f, 0.25315991f, 
    -0.03064346f, -0.11617791f, 0.07700869f, 0.03220436f, 0.08614742f, -0.12841594f, 0.12072559f, 0.15598559f, 
    -0.90591985f, -0.12030198f, -0.43213493f, -0.32770941f, 0.10952800f, -0.09813167f, 0.17932209f, -0.13472265f, 
    0.04629375f, -0.13786818f, 0.20730686f, 0.19624552f, 0.47514802f, 0.16805311f, -0.25632462f, 0.17401585f, 
    -0.53364199f, -0.26832387f, 0.20809169f, -0.20388186f, -0.05439631f, 0.12567022f, -0.12965617f, -0.07986624f, 
    -0.37072751f, 0.32793561f, 0.08393671f, -0.13301420f, 0.18611769f, 0.13930281f, 0.00850808f, 0.10252552f, 
    0.01822152f, -0.10085640f, -0.11026920f, 0.06749124f, -0.37931052f, 0.14264791f, -0.11859486f, 0.03268409f, 
    0.10348167f, 0.10367307f, 0.14824547f, 0.02940986f, 0.00574822f, -0.10676002f, -0.06618253f, 0.23244001f, 
    -0.71574765f, 0.24226494f, -0.59219956f, -0.29336342f, 0.16673769f, 0.13171446f, -0.43284917f, 0.15406318f, 
    0.11087345f, 0.16537142f, 0.06021292f, 0.19616374f, -0.10234976f, -0.15443386f, -0.32045153f, -0.47307479f, 
    -0.04493523f, 0.10946338f, -0.09174916f, -0.14660977f, 0.14568582f, -0.44346523f, -0.43527487f, -0.12168609f, 
    -1.22551620f, -1.01995420f, 0.19213453f, -0.27926636f, 0.22981586f, 0.04832168f, 0.26892295f, -0.01697134f, 
    0.45821965f, 0.08308151f, -0.00512515f, 0.30900887f, -0.95103478f, -0.70279598f, -0.08369924f, 0.03056203f, 
    0.04734983f, 0.06821027f, -0.33570939f, -0.16305760f, 0.03781660f, -0.02721729f, 0.00473794f, 0.23965728f, 
    0.51928204f, 0.43522295f, -0.12616758f, -0.05620606f, -0.04321676f, -0.03993153f, -0.14944811f, -0.03905532f, 
    0.19963174f, -0.05839090f, 0.20510429f, -0.11895359f, -0.18104210f, 0.04714004f, -0.40648302f, 0.33452231f, 
    0.01574882f, 0.00060497f, -0.02482320f, 0.00791395f, 0.10459569f, 0.25748605f, 0.31645140f, 0.08621529f, 
    0.28779921f, -0.22376738f, -0.23270778f, 0.07383556f, 0.20564952f, -0.18973148f, 0.19754815f, 0.06645811f, 
    0.14857954f, -0.08486375f, -0.14683385f, 0.07606519f, 0.01943718f, -0.27575654f, 0.03683327f, 0.74905825f, 
    -0.13024339f, -0.15495230f, 0.06140703f, 0.07990494f, -0.03413901f, -0.09857897f, -0.05350165f, -0.09752453f, 
    0.24604845f, 0.16008227f, -0.27866629f, 0.01239785f, -0.04095451f, -0.22468443f, -0.00922746f, -0.34722543f, 
    -0.18739757f, -0.06041608f, -0.10472792f, 0.08014331f, 0.45116389f, -0.13526464f, -0.42004502f, 0.08630778f, 
    0.02863960f, -0.00699304f, -0.04320946f, -0.07252623f, -0.16059901f, 0.02175770f, -0.01111144f, -0.07436597f, 
    0.20209187f, -0.23788093f, -0.32320157f, 0.16185586f, -0.34156907f, 0.30949461f, -0.06397033f, -0.08495204f, 
    -0.10198442f, 0.15625539f, -0.18722300f, -0.27057412f, 0.26602730f, -0.60011768f, -0.22140288f, 0.14155139f, 
    -0.08901311f, 0.08049145f, 0.01862066f, 0.05154044f, 0.10038269f, 0.08618458f, -0.13390963f, 0.24933936f, 
    0.25796336f, 0.02307742f, 0.03084195f, -0.43887430f, 0.12277846f, -0.03124027f, 0.01446528f, 0.05838453f, 
    0.15067315f, -0.04169993f, -0.14748232f, -0.19171451f, -0.19478096f, -0.20917785f, 0.12653995f, 0.15222950f, 
    -0.13299237f, 0.08150490f, -0.12977153f, -0.02190543f, -0.10311861f, 0.16529766f, -0.03461347f, -0.07681876f, 
    0.66258293f, -0.02386903f, -0.22672361f, 0.27969289f, -0.19488965f, 0.07956205f, -0.01965694f, 0.20739311f, 
    0.06702715f, 0.01257556f, 0.14819679f, -0.00975225f, -0.67864889f, 0.39032498f, -0.14831558f, -0.02121943f, 
    0.26004407f, 0.02093512f, -0.02683353f, -0.08920207f, 0.00225967f, 0.12017609f, 0.06499096f, -0.02950454f, 
    -1.10577726f, 0.37528586f, -0.20097315f, 0.08386011f, 0.11666174f, -0.20087707f, -0.06992684f, 0.23738685f, 
    -0.23109615f, -0.02520811f, 0.00536640f, -0.05514880f, -0.49576554f, -0.21152245f, -0.27720588f, -0.58996665f, 
    -0.01044271f, 0.02676012f, 0.16702455f, 0.17036177f, 0.16300948f, -0.07040064f, 0.04310906f, 0.00165545f, 
    0.41720867f, -0.28791878f, 0.15610072f, -0.29978880f, 0.19593571f, 0.15005706f, -0.16247602f, -0.04125726f, 
    -0.10419285f, -0.08429734f, 0.01079225f, 0.01078827f, 0.53409493f, -0.25526798f, -0.10112061f, -0.17554069f, 
    -0.15431529f, -0.07115563f, 0.11276613f, -0.21487656f, 0.07509030f, 0.03907585f, -0.25711304f, -0.08244575f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25558072f, 0.16084123f, -0.21363769f, 0.06498992f, -0.04546350f, 0.05014243f, -0.06830267f, -0.18790813f, 
    -0.09183016f, 0.03612937f, 0.28999579f, 0.04321077f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
