#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19224186f, -0.88234901f, -0.49696428f, 0.78657335f, 0.83219075f, -0.06568850f, -0.01043140f, -0.05034914f, 
    -0.16778117f, 0.91674602f, -0.59849870f, 0.71328181f, -0.74072015f, -0.31646970f, -0.59676743f, 0.71788776f, 
    0.42308521f, -0.09681956f, -0.29807207f, -1.03504097f, -0.51506793f, -0.42836329f, -0.59968197f, 0.08170831f, 
    -0.04449777f, 0.46631262f, -0.13470934f, -0.82373548f, -0.83655459f, -0.69733322f, -0.08092098f, 0.31328672f, 
    0.73115969f, 0.54500455f, -0.04478613f, 0.05902588f, -0.68226582f, -1.08182812f, -0.32597035f, -0.29207578f, 
    0.53871828f, 0.75173634f, -0.00086793f, -0.15125257f, -0.04349491f, 0.64942271f, -0.41236153f, -0.24284136f, 
    -0.11899111f, 0.91459370f, 0.26958635f, 0.67368066f, 0.31188607f, -0.50432032f, -0.92761964f, 0.82531881f, 
    -0.51197928f, 0.64610142f, 0.86074615f, 0.37483883f, -0.00683919f, -0.52526832f, -0.43327546f, 1.07055688f, 
    -0.96126562f, 0.99352348f, 0.62254792f, -0.43886998f, 0.42270297f, 0.24944119f, 0.08489682f, -0.66847903f, 
    0.76264107f, 0.34026757f, -0.74094105f, 0.25085190f, 0.98978716f, 0.02381678f, 0.20868202f, -0.03440242f, 
    0.13787413f, -0.55502117f, -0.86546743f, -0.49490035f, -0.77256215f, -0.80865532f, -0.17036293f, 0.28852248f, 
    0.10040864f, 0.29728466f, 0.69798189f, -0.53900582f, -0.14005040f, 0.07475013f, 0.64170587f, -0.25896952f, 
    -0.52243388f, 0.62116069f, -0.42476529f, -0.17204107f, 1.32946765f, -0.72605586f, 0.13462433f, 0.03608963f, 
    0.32912689f, 0.52205193f, -0.45377225f, -0.45800057f, 0.87914479f, 0.96089184f, 0.42461330f, 0.25741556f, 
    -0.98901051f, -0.88342410f, 0.56313306f, 0.07078037f, -0.09359170f, -1.10579002f, 0.22246179f, 0.56046987f, 
    -0.33549654f, 1.00029969f, -0.07148004f, -0.19939619f, 0.60484636f, 0.30557996f, -0.49777970f, -0.59417021f, 
    0.34169808f, -0.51559234f, 0.05828258f, 0.78752065f, 0.15943478f, -0.34309524f, 0.43296197f, -0.64494956f, 
    0.03813868f, -0.79351920f, 0.62012643f, -0.34676436f, 0.50389278f, -0.52394700f, 0.15816548f, -0.08088668f, 
    -0.21666980f, 0.97593039f, -0.16553089f, 0.06226570f, -0.55510414f, 0.00505417f, -0.35448658f, 0.00746467f, 
    -0.22921640f, -0.02705475f, 0.67391706f, 0.48074472f, -1.17576075f, -0.63871664f, -0.23332553f, 0.34110156f, 
    -0.24751526f, -0.33620346f, 1.07347965f, 0.65303051f, 0.42161882f, -0.61652541f, -0.57448810f, 0.19491845f, 
    -0.08669384f, 0.03892925f, 0.46774122f, 0.50806379f, -0.40054360f, -0.91900975f, -0.31571454f, -0.06802133f, 
    -0.12296030f, -0.41331929f, 0.41479054f, 0.58819520f, -0.53752464f, 0.53947985f, 0.74103069f, -0.94631416f, 
    0.62227494f, -0.14468673f, -0.34731686f, 0.06743434f, 0.29506096f, 0.21607174f, -1.03323424f, -0.53383100f, 
    0.21589059f, 0.59979194f, -0.37730175f, -0.34789917f, -0.37199566f, -0.45742136f, 0.72338802f, 0.44735184f, 
    0.83437771f, 0.62713128f, -0.04275667f, 0.29178980f, 0.20470266f, 0.32440245f, 0.47373173f, -0.68621218f, 
    0.04173827f, -0.01576575f, 0.20197202f, 0.46824327f, -0.85533941f, 0.63904488f, -0.42766064f, -0.51444232f, 
    -0.98091674f, -0.05872514f, -0.62507236f, 0.35870898f, -0.49324718f, -0.14040233f, -0.13200502f, 0.26896369f, 
    -0.30339316f, -1.17903817f, 0.53885698f, 0.68060708f, 0.24933092f, 0.68975329f, 0.46046963f, -0.35891175f, 
    -0.02783610f, -0.13782243f, 1.32064319f, 0.17052513f, -0.89632028f, -0.38478005f, 0.29620773f, -0.13508397f, 
    0.05075418f, -0.17492233f, 0.41199338f, 0.24919760f, -0.95929134f, -0.61256659f, -0.02285502f, -0.84303021f, 
    -0.58549136f, -0.18658651f, 0.07103874f, -0.24423365f, 0.38782275f, 0.64507586f, -0.63301945f, -0.44948140f, 
    0.71450448f, 0.90226132f, 0.18946117f, -0.16100951f, 0.27057052f, 0.49238443f, 0.66072267f, 0.87890708f, 
    -0.79926413f, 0.74539924f, -0.39896834f, -0.08914080f, -0.29543847f, 0.46411839f, -0.65626961f, 0.52428246f, 
    0.20681508f, 0.53323287f, -0.05031839f, 0.62696087f, -0.38237637f, -0.37002459f, -0.67657375f, -0.72745019f, 
    -0.77536845f, -0.42031905f, -0.26787248f, 1.20467234f, -0.17226669f, -0.22483927f, -0.19985619f, 0.26577950f, 
    -0.66455299f, 0.56748658f, 0.60910809f, -0.47197339f, 0.45999312f, 0.53732544f, 0.22821324f, -0.23944630f, 
    0.56922805f, -0.05610102f, -0.96813726f, -1.00732338f, -1.01210761f, 0.59659302f, 0.69975656f, 0.35553733f, 
    -0.06088353f, -0.16521105f, -0.83155507f, 1.33470285f, -0.07619768f, -0.39964572f, 0.59850430f, -0.65045464f, 
    -0.10270979f, -0.11834617f, -0.16249169f, 0.31728980f, -1.10236871f, -0.25962773f, 0.86278903f, 0.52020687f, 
    -0.33228907f, -0.01246113f, -0.20161209f, 0.29879662f, 0.82193440f, 0.93235016f, 0.79239714f, -0.35693192f, 
    -0.88338983f, 0.67371333f, -0.26684114f, 0.25759861f, -0.58409899f, -0.35422024f, -0.91714686f, 0.38780829f, 
    -0.74161029f, 0.37423810f, 0.59810144f, 0.04861220f, -0.02265144f, 0.37728769f, -0.21558267f, -0.94867206f, 
    -0.05670463f, -0.45393923f, 0.75419080f, 0.44975686f, -0.37373331f, -0.24025980f, -0.61167282f, 0.21853495f, 
    -0.97431183f, -0.39594796f, 0.41010198f, 0.73936450f, 0.82427019f, -0.45754334f, 0.54657423f, -0.53371525f, 
    0.61786497f, 0.83341181f, 1.01738119f, 0.49250656f, 0.64175552f, -0.50608909f, -0.10791911f, 0.40711850f, 
    -0.15730412f, -0.71832567f, -0.17831655f, 0.88339168f, 0.53383201f, 0.59256870f, 0.48496068f, 0.36419034f, 
    0.39374071f, 0.65669823f, 0.33211929f, 0.87758958f, 0.40979016f, 0.52506936f, 0.26659635f, -0.84431225f, 
    0.21627977f, -0.54897630f, 0.11351707f, 0.20665067f, 0.86172223f, 0.59237045f, 0.81016237f, -0.66152477f, 
    -0.44505557f, -0.21613908f, -0.36056095f, -0.19337331f, -1.01756823f, -0.27186996f, 0.67239678f, 0.31404150f, 
    0.42773196f, -0.75686115f, -0.44411570f, 0.02965001f, -0.24821359f, -0.64554572f, 0.62292087f, 0.08052661f, 
    -0.57522243f, 0.04449555f, 0.38963744f, -0.52269173f, -0.22968747f, -0.34481937f, 0.74943089f, 0.84034896f, 
    0.35672456f, 0.43474844f, -0.25736001f, -0.29564363f, -0.77131790f, 0.14673105f, -0.63345200f, -0.27800962f, 
    -0.74431157f, 0.25819317f, -0.94526225f, 0.10128411f, -0.86014766f, 0.13177213f, 0.29612875f, -0.21420921f, 
    0.88011342f, -0.89341664f, 0.69118905f, -0.27979681f, -0.58937800f, -0.76599908f, -0.43343434f, -0.46173212f, 
    -0.11081314f, -0.34809226f, 0.23786552f, -0.79774523f, 0.93225265f, 0.66342694f, -0.97787255f, -0.02642740f, 
    -0.21794096f, 0.18021902f, -0.80941409f, -0.91555953f, 0.70334983f, 0.68024939f, 0.61297745f, 0.65717816f, 
    -0.01068167f, -0.41575193f, -0.42603245f, -0.63395345f, -0.72927636f, 0.84297097f, 0.24824344f, -0.13542101f, 
    -0.65671688f, 0.00921756f, -0.27119491f, -0.22027220f, -0.70381063f, 0.75056046f, -0.35751319f, -0.76487678f, 
    -0.47487056f, -1.00859928f, -0.06417324f, -0.22756848f, 0.41941801f, -0.69530004f, -0.41509905f, -0.43152159f, 
    0.08970739f, 0.95273465f, 0.70403630f, -0.19058150f, -0.36532864f, 0.06332696f, 0.93999732f, 0.16165546f, 
    -0.41880536f, 0.58608127f, -0.32873082f, -0.33968559f, 0.23081304f, 0.43476501f, 0.23369215f, -0.00718567f, 
    0.35132962f, -0.57606930f, -0.74358481f, -0.96444178f, 0.56515884f, 0.61320680f, 0.26450938f, 0.24285899f, 
    -0.43057922f, -0.97339779f, -0.61348337f, 0.45507807f, -0.13203566f, -0.25777221f, -0.39399758f, 0.15537275f, 
    0.53273058f, -0.71327055f, 0.82678062f, 0.39363030f, -0.88127285f, 0.07065721f, 0.02650735f, 0.33121136f, 
    0.43581593f, -0.57397151f, 0.50115305f, -0.09997804f, 0.76533741f, -0.72943538f, -0.88558567f, 0.40541360f, 
    0.57988900f, 0.76068652f, -0.03505220f, -0.69249386f, -0.70295244f, -0.84242499f, 0.49522597f, -0.41024432f, 
    0.58048481f, -0.12074066f, -0.20086189f, 0.05151821f, -0.44771144f, 0.80526489f, 0.98502445f, -0.43425867f, 
    0.54015553f, 0.17428344f, -0.27504668f, 0.59032488f, -0.59982920f, -0.19579153f, 0.50973201f, -0.72757220f, 
    0.00223997f, -0.40688390f, -0.06844489f, -0.47508371f, -0.42199576f, -0.53294790f, 0.96035039f, 1.05463755f, 
    -0.35376868f, 0.48350212f, 0.37311593f, -0.48036420f, 0.27285478f, 0.27261242f, -0.01650678f, 0.73543233f, 
    0.95793104f, -0.08527286f, 0.59194374f, 0.43571806f, 0.81250614f, 0.19749923f, 0.05184263f, -0.16005406f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.38213119f, 0.01341574f, 0.01331794f, 0.21169451f, 0.30997729f, 0.13096912f, 0.10762379f, 0.09429616f, 
    0.06895777f, 0.14312068f, 0.28929538f, -0.14224944f, 0.02558378f, 0.05068960f, 0.20330815f, 0.15843828f, 
    0.10556651f, 0.02468600f, 0.26606357f, 0.36865199f, 0.27204648f, 0.02967084f, 0.15003678f, -0.13971838f, 
    0.10469294f, 0.29410073f, 0.17092247f, 0.44221547f, 0.32662532f, 0.04098825f, 0.21522334f, 0.22011988f, 
    0.10852609f, 0.07552019f, 0.06231171f, 0.34500226f, 0.09900256f, 0.32094619f, 0.06978505f, -0.09067854f, 
    0.15200061f, 0.26537398f, 0.18013689f, 0.12851067f, 0.10291006f, 0.29723427f, -0.07134996f, 0.08401031f, 
    -0.10193679f, 0.10399757f, 0.21353698f, -0.12851289f, -0.02797721f, 0.23841012f, 0.14626405f, -0.05159424f, 
    0.29978672f, 0.18182167f, -0.06537566f, 0.03794555f, 0.01256108f, 0.23920670f, 0.03477881f, 0.23932505f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00379702f, 0.17570737f, 0.04734375f, -0.08539947f, -0.15686807f, 0.02233851f, 0.00365034f, 0.03437366f, 
    -0.02302648f, -0.09130704f, 0.01363065f, 0.00238535f, 0.01181374f, -0.01148829f, -0.01446482f, 0.03545949f, 
    0.06136051f, 0.04827694f, 0.02994823f, 0.03630665f, 0.18231541f, -0.20989467f, -0.00770147f, 0.15713742f, 
    -0.22370353f, -0.04524233f, -0.04433202f, -0.03379242f, -0.04327788f, -0.00320109f, -0.02558987f, 0.05296773f, 
    -0.05487753f, 0.02187680f, -0.08649424f, -0.01335880f, -0.09859055f, 0.02428597f, 0.07272069f, 0.02707621f, 
    -0.09042185f, -0.55008012f, -0.06419299f, 0.07632379f, -0.16408694f, -0.08056685f, -0.04981367f, 0.05640890f, 
    0.06822915f, 0.07217649f, -0.01026977f, -0.01534280f, 0.05943028f, -0.04225526f, 0.06903680f, 0.09181938f, 
    0.00648952f, -0.02210218f, -0.02693956f, 0.02743129f, -0.13386086f, 0.13359322f, -0.04731192f, -0.04372717f, 
    -0.23702407f, 0.01967369f, 0.06335453f, -0.07055201f, 0.05380346f, 0.03790419f, -0.04055712f, 0.00087697f, 
    -0.06543517f, 0.05647091f, 0.02842357f, 0.06482346f, -0.03303176f, 0.00328982f, 0.08427030f, -0.06517107f, 
    -0.22967595f, 0.16716911f, -0.06522498f, -0.04592406f, -0.21143658f, 0.04563258f, 0.01345858f, -0.02751367f, 
    0.04067890f, 0.01512135f, 0.01569021f, -0.04883863f, -0.00890066f, 0.04500123f, -0.00758625f, -0.00709617f, 
    -0.03568764f, -0.03027158f, 0.02504699f, 0.00914133f, -0.13929124f, 0.14993313f, -0.01125086f, -0.06727012f, 
    0.00199650f, -0.07461435f, -0.03803086f, -0.07567869f, -0.03314499f, 0.05076319f, -0.03222455f, -0.00892550f, 
    -0.00598954f, 0.03168078f, 0.06803712f, -0.02760114f, -0.01978781f, 0.01742122f, -0.04830442f, -0.00959060f, 
    0.38749117f, 0.08761670f, 0.16769515f, -0.10978825f, 0.02401753f, 0.05102317f, 0.01188293f, 0.03331389f, 
    0.00803378f, -0.03344806f, 0.00126238f, 0.00753172f, -0.07145334f, -0.05747717f, 0.09352940f, 0.00028949f, 
    0.07238361f, -0.03405004f, -0.01122517f, -0.03026171f, 0.26829091f, -0.24567957f, 0.03338206f, -0.00944612f, 
    -0.34688246f, -0.10497521f, -0.00974667f, -0.01702143f, 0.03017428f, -0.02534933f, -0.13823308f, 0.05312353f, 
    -0.11044305f, 0.08187003f, 0.02618418f, -0.05868591f, -0.09954403f, 0.03677528f, 0.04744071f, -0.00270843f, 
    -0.20471409f, 0.06395007f, 0.01102113f, -0.12541452f, 0.22317815f, -0.02065362f, -0.01635154f, 0.00134661f, 
    0.04248705f, -0.01781305f, -0.04041142f, 0.10492423f, 0.00547263f, -0.00525212f, 0.01899336f, 0.09711374f, 
    -0.01175660f, 0.06571338f, -0.01630214f, -0.01504693f, -0.24736546f, -0.44712257f, -0.08615848f, 0.12032510f, 
    -0.08773541f, 0.04204845f, -0.01837357f, 0.04892163f, 0.07667252f, 0.01462191f, 0.01255645f, 0.00949414f, 
    -0.05831754f, -0.06070427f, 0.08358285f, 0.06092399f, 0.05967198f, -0.02518632f, 0.05070398f, -0.06932034f, 
    0.02465362f, -0.08671746f, -0.01632945f, -0.09777862f, 0.01795616f, 0.00674477f, -0.11519825f, -0.10676390f, 
    -0.00077846f, 0.05368904f, -0.09576645f, 0.06207678f, 0.10275893f, -0.05171265f, 0.01009959f, -0.05169445f, 
    0.03475866f, -0.03650102f, -0.01690333f, -0.10229162f, 0.26634654f, 0.05898916f, 0.22639875f, -0.18685439f, 
    0.14969032f, -0.14378498f, -0.00535086f, 0.13081387f, -0.02969406f, 0.00177191f, -0.03213722f, 0.11118512f, 
    -0.00958795f, -0.07828837f, 0.11769692f, 0.02215318f, 0.09206387f, -0.00515702f, -0.14164317f, -0.13188957f, 
    0.06981819f, 0.05402776f, 0.05919506f, -0.12800801f, 0.07683197f, -0.12080067f, -0.05495822f, 0.03616990f, 
    0.03665789f, -0.00094618f, 0.07003403f, -0.01634202f, -0.02642995f, 0.01013013f, -0.03037430f, 0.12020902f, 
    -0.00865252f, 0.06981114f, 0.03267411f, -0.04492151f, 0.04193045f, -0.00345413f, 0.06357499f, 0.02313330f, 
    -0.07065612f, 0.02897002f, 0.00750395f, 0.03741782f, 0.06667504f, -0.04729545f, 0.03121291f, -0.00853960f, 
    -0.01461483f, 0.05065411f, 0.03553741f, 0.08154978f, -0.02548532f, 0.04276755f, 0.02073276f, -0.05722496f, 
    -0.19777963f, 0.06890705f, -0.10643297f, 0.09492359f, -0.10633572f, -0.00877213f, -0.01779334f, -0.02880028f, 
    0.01525511f, -0.06038866f, 0.05949651f, -0.03083366f, -0.04897790f, 0.03378949f, 0.05236860f, -0.05339750f, 
    -0.04618635f, -0.02180684f, 0.04953669f, 0.03794840f, 0.17367060f, 0.00375270f, -0.03227471f, -0.09073886f, 
    -0.18228759f, 0.02726890f, 0.02607424f, -0.01794585f, 0.02787179f, -0.03320163f, 0.02559649f, -0.04088488f, 
    -0.04587337f, 0.03460045f, -0.04171010f, -0.01500755f, -0.06664368f, 0.04423699f, -0.05175804f, 0.04204564f, 
    0.00960148f, 0.09700500f, 0.18042301f, -0.04541262f, 0.15385143f, -0.01841098f, -0.10958249f, 0.02599117f, 
    -0.03494602f, -0.00771177f, -0.01566906f, 0.01150612f, -0.03167327f, 0.00636770f, -0.01158797f, -0.03286197f, 
    0.03733558f, 0.04481179f, -0.00814816f, 0.02474423f, -0.01062955f, 0.02199747f, -0.09615506f, 0.01096567f, 
    0.19306910f, -0.06250966f, -0.09456609f, -0.05277734f, -0.02304217f, 0.03896256f, -0.01074556f, 0.00925489f, 
    0.05615516f, -0.05266734f, 0.01036486f, 0.02045214f, 0.02266234f, 0.00515193f, 0.02089308f, -0.02698241f, 
    0.15021457f, 0.05880048f, 0.00578598f, -0.20772280f, 0.03946295f, -0.06395132f, -0.13119133f, -0.16320522f, 
    0.02811193f, -0.02929214f, -0.02232627f, -0.03969975f, 0.01045491f, -0.02696002f, -0.00233298f, -0.00038440f, 
    0.00488910f, -0.02116509f, 0.04296893f, 0.01553291f, -0.11581974f, -0.21516322f, 0.10820437f, -0.03748953f, 
    0.00984720f, 0.01670424f, -0.03964997f, 0.04890500f, -0.05815615f, -0.00114379f, -0.11346497f, 0.11910170f, 
    0.01176518f, 0.01620390f, -0.01167856f, -0.06497343f, -0.05087406f, -0.06887937f, -0.06040237f, -0.01329432f, 
    -0.05362942f, -0.03724528f, -0.02320785f, 0.08132436f, 0.01333718f, -0.06741723f, 0.01839516f, 0.00009759f, 
    0.03331885f, 0.00923490f, -0.00223435f, -0.03048300f, -0.01496217f, 0.04253746f, -0.02753885f, -0.02578788f, 
    -0.00066729f, 0.04190404f, -0.01983158f, -0.02282619f, -0.10938583f, -0.10297682f, 0.11976375f, 0.06510304f, 
    -0.13728279f, 0.05113858f, 0.02223711f, 0.03855537f, -0.04849813f, -0.05105156f, 0.04371038f, 0.04618225f, 
    0.02421884f, 0.04779493f, 0.02024075f, -0.01908950f, 0.02595280f, 0.09232956f, -0.03817327f, 0.03974628f, 
    0.08939830f, -0.10810381f, -0.02940737f, -0.09659903f, -0.07452630f, -0.04588801f, -0.10279858f, 0.01346012f, 
    0.00044398f, -0.02919834f, -0.01381776f, -0.00134599f, -0.08173259f, 0.00735483f, -0.03044020f, -0.02071217f, 
    -0.05878480f, 0.08675672f, -0.08301690f, 0.01352966f, 0.24231485f, -0.16509183f, 0.12595730f, 0.00664268f, 
    -0.11636482f, -0.05163020f, 0.02311840f, 0.01784791f, 0.07762796f, -0.03121529f, 0.05775423f, 0.10699467f, 
    0.07586937f, 0.05666751f, -0.01973723f, 0.10476081f, -0.07721680f, -0.10282902f, -0.06686640f, -0.09409727f, 
    0.13660640f, -0.27892825f, -0.04909157f, 0.01287747f, -0.09695485f, 0.04982720f, -0.05686072f, 0.03843472f, 
    0.00281417f, 0.00707208f, -0.01823986f, -0.05330719f, -0.04972090f, -0.02129318f, -0.03387678f, -0.02379411f, 
    -0.05108522f, 0.02003558f, 0.04443001f, -0.05066653f, 0.08657971f, 0.10958485f, 0.16025147f, 0.10582251f, 
    0.11805221f, -0.00156515f, -0.01877129f, 0.02025424f, -0.02594982f, -0.02605857f, 0.01546896f, -0.07277062f, 
    -0.04266095f, -0.02381060f, -0.02759416f, 0.06697696f, -0.05355206f, -0.06694985f, 0.05299351f, 0.05938705f, 
    -0.16700086f, -0.04796214f, 0.08521200f, 0.05871543f, 0.26804993f, -0.05810301f, -0.03593045f, -0.02402044f, 
    0.13205266f, -0.02079253f, 0.01709266f, -0.04487284f, 0.07462566f, 0.00516213f, -0.08387220f, 0.02244319f, 
    -0.05572566f, -0.06704300f, -0.02745132f, -0.03690293f, -0.03420245f, -0.47509667f, 0.16022560f, 0.07708400f, 
    -0.08602200f, 0.03286154f, -0.02861922f, 0.06137598f, -0.00343111f, 0.01052343f, -0.07195652f, -0.04757053f, 
    -0.07928386f, 0.06573547f, -0.00963500f, -0.00458163f, 0.01294545f, 0.01896677f, -0.07907748f, -0.06092108f, 
    -0.33186802f, 0.10611353f, -0.03345697f, -0.21315902f, 0.13282380f, -0.04076977f, -0.10687409f, -0.07728666f, 
    0.00754508f, -0.04907863f, 0.00578061f, -0.05896892f, 0.05517118f, 0.05647007f, 0.03930574f, -0.05240645f, 
    0.01320479f, -0.07081403f, -0.08006529f, -0.07390400f, 0.13769972f, 0.03401160f, -0.07530507f, -0.03747449f, 
    0.02703419f, -0.15776213f, -0.07788450f, -0.02435591f, 0.06879383f, -0.00017904f, -0.03269570f, -0.04040875f, 
    0.05723339f, -0.08253706f, 0.01915823f, -0.14532402f, 0.03752521f, 0.00154092f, -0.00944945f, 0.04375027f, 
    0.02152466f, 0.05137433f, 0.16374551f, 0.04237452f, 0.02407645f, 0.01600639f, -0.01818081f, 0.10371050f, 
    -0.02748718f, -0.00808454f, 0.00634854f, -0.02696773f, 0.02275502f, -0.00858620f, 0.02119791f, 0.07371300f, 
    -0.02684757f, -0.11785512f, 0.04987942f, 0.04170379f, 0.04768093f, 0.24583651f, 0.03869080f, -0.20484051f, 
    -0.26657721f, 0.03588730f, -0.01846167f, 0.02778883f, -0.00674952f, -0.04958899f, -0.03393911f, 0.04934932f, 
    -0.02576703f, 0.00956136f, 0.01490267f, -0.09263623f, -0.00709659f, 0.12846269f, 0.01397979f, 0.02646206f, 
    -0.09909701f, -0.05110867f, 0.03754832f, 0.04188190f, 0.12084071f, 0.01082421f, -0.06208103f, -0.01820608f, 
    -0.03585241f, -0.05525173f, 0.03270288f, -0.05939275f, 0.05670404f, 0.08579432f, 0.03999960f, -0.04122009f, 
    -0.03330392f, -0.02789424f, 0.00814335f, -0.01796903f, -0.31433621f, 0.27229613f, -0.14319314f, 0.05661054f, 
    -0.22230124f, -0.01570999f, 0.01003518f, -0.00565145f, -0.09013031f, 0.05902028f, 0.00386656f, -0.07728353f, 
    -0.01704995f, 0.04366663f, 0.01911502f, -0.04362016f, -0.16683683f, -0.03506379f, 0.00704961f, -0.04236127f, 
    0.20064090f, -0.04475534f, 0.07743486f, -0.16871537f, 0.14680651f, 0.01844363f, -0.01121493f, 0.01779442f, 
    -0.08512451f, 0.07716713f, -0.03114913f, 0.07180142f, -0.12027024f, -0.00138551f, 0.00877985f, -0.05522822f, 
    -0.05536180f, 0.06241708f, -0.00767438f, -0.00740837f, -0.02290520f, 0.03880813f, 0.03097999f, -0.00540951f, 
    -0.04968860f, -0.02304108f, -0.02745298f, 0.02987648f, -0.06177553f, -0.06053342f, -0.04215417f, -0.00560601f, 
    -0.03615824f, -0.05689833f, 0.03831803f, -0.02103731f, 0.04246458f, -0.02203481f, -0.07068230f, 0.01466260f, 
    0.09716277f, 0.10121293f, 0.07865487f, -0.01867715f, 0.07090419f, -0.07992429f, -0.08354059f, -0.09505574f, 
    0.03932740f, 0.03634512f, -0.04811353f, -0.05030357f, 0.05476696f, 0.01973313f, 0.01391396f, 0.08253410f, 
    0.02721999f, -0.10431004f, -0.00236444f, 0.07688878f, -0.12380143f, 0.06764489f, -0.13848476f, 0.09023231f, 
    -0.17047572f, -0.00294167f, 0.01627758f, 0.01428654f, 0.04637924f, -0.03972986f, 0.01580594f, -0.05611395f, 
    -0.01973933f, -0.03206358f, 0.04702823f, -0.10505625f, -0.01931475f, -0.03201911f, -0.02107144f, 0.06444535f, 
    -0.11928613f, 0.06914527f, -0.03689378f, -0.00306641f, -0.18102695f, -0.09598097f, 0.03450217f, -0.06354058f, 
    0.04413943f, 0.02250147f, 0.08676262f, 0.07637256f, -0.00239560f, -0.02084031f, -0.01170482f, -0.00009063f, 
    -0.01558277f, 0.01206200f, -0.04821924f, 0.03665594f, 0.15414606f, 0.13480876f, -0.10763515f, -0.15261400f, 
    -0.15245353f, 0.04859303f, 0.03196914f, 0.00743398f, -0.03047259f, -0.04163335f, 0.00155114f, -0.00284909f, 
    0.11188022f, 0.01411245f, -0.00591929f, 0.07837062f, 0.05626085f, -0.02669119f, -0.07913599f, 0.09163795f, 
    -0.04454607f, 0.03980539f, 0.02115454f, -0.09561566f, 0.11448019f, -0.04524942f, -0.11349759f, 0.01034423f, 
    0.01613003f, -0.00495901f, 0.03332569f, 0.06445511f, 0.02741474f, 0.04967857f, -0.00115841f, -0.03857332f, 
    0.00457797f, -0.00824143f, -0.07062674f, -0.04068436f, -0.14161462f, 0.04483752f, 0.09679168f, 0.03387702f, 
    -0.06474690f, -0.00140200f, -0.00352311f, 0.02830016f, -0.07724756f, -0.06739016f, 0.00037349f, 0.01924341f, 
    0.01610184f, 0.01561593f, 0.06437582f, 0.01485081f, 0.03575394f, -0.02920511f, -0.03228949f, -0.00802791f, 
    0.10777106f, 0.07403619f, -0.03368962f, -0.04533798f, 0.06408420f, -0.12549157f, -0.10519516f, 0.07800575f, 
    0.01811804f, -0.00923065f, -0.01543468f, 0.03369951f, -0.02378315f, -0.01740583f, -0.03478769f, -0.00999675f, 
    -0.04865185f, 0.05635914f, -0.11460917f, -0.05651925f, -0.03200900f, -0.01836311f, 0.08243169f, 0.00292949f, 
    -0.00554421f, -0.03855108f, -0.18842959f, 0.04191470f, -0.03177773f, 0.05181647f, -0.04746727f, -0.01485179f, 
    -0.08326080f, 0.04071793f, -0.04680511f, 0.05332996f, 0.03233508f, -0.01343149f, -0.10307229f, -0.01725147f, 
    -0.05200215f, -0.10201509f, 0.22220208f, 0.02609559f, -0.17994456f, 0.05354902f, -0.01885145f, 0.08372621f, 
    0.05752070f, 0.04934428f, -0.03261571f, 0.04787272f, -0.03367272f, -0.03098152f, -0.09987834f, -0.01307554f, 
    -0.10553421f, 0.02849353f, -0.03233616f, 0.05667336f, -0.00506759f, 0.03772261f, 0.02966054f, 0.05794815f, 
    0.13834077f, 0.01065653f, -0.03938032f, 0.00186176f, -0.02838065f, -0.04196892f, -0.02570252f, 0.02791135f, 
    -0.00844679f, -0.02897405f, -0.00317489f, 0.03679364f, 0.00316702f, -0.07247159f, 0.04728177f, 0.03986784f, 
    0.18990254f, 0.07672723f, 0.09840906f, -0.06349008f, 0.20410118f, -0.04303066f, -0.17079590f, -0.02639726f, 
    0.11199325f, 0.00524933f, 0.04941075f, -0.01482455f, -0.02348788f, 0.08550240f, -0.03041277f, 0.07442462f, 
    0.08804438f, -0.03421127f, -0.01844678f, 0.05370057f, 0.00139343f, -0.54829884f, -0.13589171f, 0.18518211f, 
    -0.23162702f, -0.03706393f, -0.08346635f, 0.00085558f, 0.09069599f, 0.05099082f, 0.03706801f, 0.07603414f, 
    -0.12364627f, -0.09439272f, -0.07788383f, 0.01973890f, -0.06403285f, -0.02310509f, -0.03152116f, -0.00898945f, 
    0.27322978f, -0.23391435f, 0.13318360f, 0.14903611f, -0.11757113f, 0.03469753f, -0.11488290f, 0.04788635f, 
    0.03245165f, 0.01033597f, -0.16789404f, 0.10902431f, -0.07026225f, 0.06029873f, 0.10753644f, 0.03176404f, 
    -0.09556112f, 0.11120104f, 0.06130596f, -0.01391097f, 0.40941751f, 0.02173581f, 0.00959323f, -0.08554146f, 
    0.10600712f, -0.04954024f, -0.02063383f, -0.02390533f, -0.01949175f, -0.06408755f, 0.08198283f, 0.04943128f, 
    -0.04532395f, 0.05853328f, 0.02526410f, -0.01618543f, -0.00524299f, -0.01325228f, -0.02940475f, -0.03159306f, 
    -0.08212549f, 0.09770553f, 0.22376201f, -0.01293787f, -0.18669565f, 0.04929799f, 0.02933065f, 0.10331828f, 
    0.03403592f, -0.06113979f, 0.00070373f, -0.02162612f, -0.01680771f, -0.03668154f, -0.02236725f, 0.01424104f, 
    0.05832773f, -0.09127488f, 0.07959732f, 0.02514800f, -0.23024559f, -0.30315083f, 0.10280625f, 0.10610332f, 
    -0.15100908f, 0.01920361f, -0.08922730f, 0.10198197f, 0.10432786f, 0.02519276f, 0.01501230f, 0.04861765f, 
    0.02884626f, -0.01199141f, -0.09779564f, -0.01961203f, -0.12796943f, 0.11007438f, -0.04346379f, 0.05772418f, 
    -0.19625905f, -0.17736715f, 0.01982843f, 0.01546424f, 0.06918495f, -0.00618562f, -0.01514547f, -0.04975238f, 
    0.00391773f, 0.06152329f, 0.09356928f, 0.06898811f, -0.00029721f, 0.01464989f, -0.07356928f, -0.00797796f, 
    -0.11034130f, 0.11872359f, -0.00081782f, -0.08851536f, 0.08043692f, 0.17657328f, 0.07610936f, -0.13474418f, 
    -0.15498091f, 0.04144611f, 0.06416541f, -0.05690033f, 0.09093326f, -0.04656843f, -0.03449774f, -0.00640221f, 
    -0.04137687f, 0.04548457f, 0.00754443f, -0.01843098f, 0.04918318f, -0.00745574f, 0.06841335f, 0.02053838f, 
    0.13109007f, -0.23511967f, 0.02811841f, -0.11537855f, 0.18168449f, -0.09654500f, -0.00568787f, -0.06222669f, 
    0.06694321f, -0.00718561f, -0.00057433f, 0.00534997f, -0.02569130f, 0.05820133f, -0.01946045f, 0.07337327f, 
    -0.03760431f, 0.01864522f, 0.04491829f, 0.04231065f, -0.10904311f, -0.21610063f, 0.03494899f, 0.02950137f, 
    0.04793518f, 0.03166460f, -0.01773179f, -0.13382800f, -0.05639421f, 0.01497513f, 0.00402994f, 0.02273854f, 
    0.03499211f, -0.04682267f, 0.02445158f, -0.05114600f, -0.02043324f, -0.00752510f, -0.01383835f, -0.02139945f, 
    -0.05323831f, -0.13481441f, -0.03727783f, 0.03370118f, -0.14014290f, 0.05891544f, -0.00887336f, -0.01206432f, 
    0.04578202f, -0.08317435f, -0.04007753f, -0.02931925f, -0.01402436f, -0.00282295f, 0.05805372f, 0.01125406f, 
    -0.00011882f, 0.02733528f, -0.14135346f, -0.03867647f, -0.18977253f, 0.03837227f, 0.00315565f, 0.04082303f, 
    0.08273540f, 0.00339733f, -0.04811846f, 0.06285445f, -0.05174068f, 0.01280745f, 0.00475281f, -0.03179714f, 
    -0.02040165f, -0.03025403f, -0.05348589f, 0.00081672f, -0.00235883f, -0.01683120f, -0.00366986f, -0.10997992f, 
    0.07691109f, -0.10980930f, -0.12172734f, 0.03612223f, -0.10286120f, 0.01949188f, 0.02276022f, -0.11267239f, 
    -0.03301006f, -0.04355237f, 0.00353080f, -0.02082161f, 0.04486571f, 0.04114516f, 0.01783619f, -0.00526516f, 
    -0.00907268f, 0.02350575f, -0.02912582f, 0.06804939f, 0.18704437f, -0.01039324f, -0.09213687f, -0.08713181f, 
    -0.30159125f, 0.04212555f, 0.07869293f, 0.01499714f, 0.10606778f, 0.04930451f, 0.03230586f, -0.00394475f, 
    -0.03820549f, 0.04887197f, -0.04702887f, 0.07868695f, -0.06420579f, 0.09162411f, 0.05185266f, -0.04563732f, 
    -0.33451575f, 0.06748459f, 0.10746941f, 0.06949080f, 0.20644772f, 0.08041474f, -0.01826714f, 0.02219911f, 
    -0.05680561f, 0.05328570f, 0.02798834f, -0.02844991f, 0.05457180f, 0.05179271f, -0.05778448f, 0.03065102f, 
    -0.08615831f, -0.06165451f, 0.02913186f, -0.07817587f, 0.10333258f, 0.00664154f, 0.06331401f, 0.00349102f, 
    0.05631070f, 0.00622991f, -0.07860649f, 0.00864490f, -0.00241538f, -0.04987459f, -0.01342140f, 0.03335417f, 
    -0.02485781f, -0.04576242f, 0.01687660f, -0.02530519f, 0.02169208f, -0.02316368f, -0.04696351f, -0.02967760f, 
    0.01241856f, 0.05028013f, 0.03266409f, -0.11822918f, 0.30893213f, -0.11352424f, 0.06251306f, 0.06937375f, 
    0.13052492f, 0.02720855f, 0.04916022f, 0.06687672f, 0.04751950f, 0.01303775f, -0.02452853f, -0.00008266f, 
    -0.01696236f, 0.06357570f, -0.01228698f, 0.05461955f, 0.07353577f, -0.10819807f, -0.00807133f, -0.13897860f, 
    0.14514981f, -0.12278612f, -0.04565528f, 0.06379675f, 0.04541462f, -0.03275828f, -0.12064561f, 0.04649018f, 
    -0.01500863f, -0.01104364f, 0.06098748f, 0.02122885f, 0.01663698f, 0.01460000f, -0.10515869f, 0.04886320f, 
    0.16756612f, -0.13245638f, -0.09590659f, -0.01134253f, -0.14085250f, 0.05883741f, 0.05284021f, -0.07744865f, 
    -0.00022757f, 0.01522921f, -0.00437934f, 0.04182749f, -0.00844955f, -0.03458669f, -0.03481232f, 0.03273727f, 
    0.02984883f, -0.04025397f, -0.00845763f, 0.00177370f, 0.00401774f, -0.18424742f, -0.00659579f, -0.00449684f, 
    -0.11998162f, 0.00314257f, 0.04771263f, 0.01356039f, 0.02883856f, -0.07870239f, 0.00287490f, 0.04609606f, 
    0.08753317f, -0.01060099f, -0.03611665f, 0.02513671f, -0.01124461f, -0.11439313f, -0.05822333f, -0.04714675f, 
    0.01781804f, 0.01230618f, 0.04003759f, 0.01950107f, -0.07375746f, 0.06893913f, 0.05352066f, 0.00870484f, 
    0.12877792f, 0.00676048f, -0.15511402f, -0.09322392f, 0.06272348f, 0.09902237f, -0.10043777f, -0.00725894f, 
    0.06136218f, -0.04897014f, -0.09813884f, -0.03954555f, 0.24183621f, 0.07091171f, -0.12650263f, 0.05481455f, 
    -0.15587969f, 0.00862226f, -0.00703718f, -0.01719744f, 0.04124095f, 0.09204701f, -0.00698093f, -0.08264650f, 
    -0.02153793f, 0.01953776f, -0.04221991f, 0.04317634f, 0.07730382f, -0.00241583f, -0.04475616f, 0.09423809f, 
    0.17811404f, -0.03247328f, -0.05873738f, 0.07494617f, -0.19086087f, -0.04491274f, -0.00338009f, 0.03924517f, 
    0.00331461f, 0.01724194f, 0.02046161f, 0.00391059f, -0.04181698f, 0.02523977f, 0.03984771f, 0.02441786f, 
    0.02552583f, -0.03062483f, -0.07877918f, -0.00851601f, 0.33782774f, -0.27721304f, -0.00898462f, 0.01737926f, 
    0.10264993f, -0.06868893f, -0.00028452f, -0.00829533f, 0.06450421f, -0.00216111f, 0.07228886f, -0.06162086f, 
    -0.07700557f, 0.02262681f, -0.09274851f, 0.04748971f, -0.05304788f, -0.02609218f, -0.01166073f, 0.06528485f, 
    -0.29855308f, 0.01339180f, -0.09567153f, -0.00862787f, 0.08339696f, 0.02876421f, 0.05299190f, -0.07530218f, 
    0.04510581f, -0.02468790f, 0.10094748f, 0.03745331f, -0.01118482f, -0.02757947f, 0.13175169f, 0.06586959f, 
    -0.04403210f, 0.04962995f, 0.01577862f, 0.04374536f, 0.15348934f, 0.19355485f, 0.14894232f, 0.02152225f, 
    -0.08490291f, -0.09802490f, -0.06716320f, 0.06001960f, 0.02482524f, 0.09568867f, 0.06603511f, -0.01670469f, 
    0.15899546f, -0.03096762f, -0.00306258f, 0.00243695f, -0.02660067f, 0.01618980f, -0.02443149f, 0.09869692f, 
    0.37942338f, -0.14382875f, 0.07218047f, -0.09171889f, -0.07538522f, -0.01626615f, 0.00973604f, -0.11543608f, 
    0.00905170f, -0.02934026f, -0.03324128f, -0.05116922f, -0.06023548f, 0.00612181f, 0.05417356f, -0.03615703f, 
    0.06459898f, -0.01885954f, 0.01674340f, 0.11780598f, -0.00084912f, 0.02102826f, 0.03644927f, -0.05405350f, 
    -0.08949137f, 0.00781562f, 0.03462095f, 0.06805539f, 0.11004943f, 0.02027874f, -0.12387590f, -0.04606993f, 
    0.03060693f, 0.10498711f, -0.06328645f, 0.02280309f, -0.01243903f, -0.11410996f, -0.03148663f, -0.15618524f, 
    0.29345837f, 0.00275835f, 0.05500452f, -0.04118052f, 0.08038834f, 0.01189156f, 0.02109620f, 0.04368096f, 
    -0.02989162f, 0.05678399f, -0.01509495f, -0.07250635f, -0.03484536f, 0.06980970f, -0.06923138f, 0.09123714f, 
    0.09164043f, 0.01916381f, 0.09021770f, 0.14742544f, -0.05154673f, 0.03741636f, -0.08921291f, -0.13264117f, 
    0.32219023f, -0.08770137f, -0.03698029f, -0.05416925f, -0.10555287f, 0.00155290f, 0.14304307f, -0.14224720f, 
    -0.08192706f, -0.02699248f, -0.02623367f, -0.10184706f, 0.00430881f, 0.01681746f, 0.07782244f, 0.13053213f, 
    -0.00692684f, -0.03787618f, 0.06458428f, 0.04598038f, 0.12929566f, -0.01129433f, -0.04993928f, 0.02772321f, 
    -0.01433333f, -0.04955957f, -0.05549198f, 0.02790017f, 0.12820531f, 0.03450002f, -0.04613234f, -0.08306878f, 
    -0.02068393f, -0.10688975f, 0.00115045f, 0.03224977f, -0.44576833f, 0.14364523f, -0.07583387f, -0.13438638f, 
    0.03428001f, -0.13818428f, 0.08533019f, -0.02200800f, -0.01374643f, 0.05084293f, -0.00828602f, -0.05606943f, 
    0.02239822f, -0.06980262f, -0.15247874f, -0.03669770f, 0.03017160f, 0.05144795f, -0.10345270f, 0.02498127f, 
    -0.01373781f, 0.10936888f, -0.02557625f, -0.03825283f, -0.11495335f, -0.01345697f, -0.02525117f, -0.08903977f, 
    -0.01980616f, -0.00468324f, -0.02160442f, -0.00161779f, -0.03396787f, 0.00019024f, 0.00898164f, 0.03932279f, 
    -0.03889500f, 0.02655417f, -0.00544286f, 0.03443171f, -0.17025344f, -0.01299621f, -0.07683466f, -0.04831956f, 
    -0.04118054f, 0.01281153f, -0.06444435f, -0.07660569f, -0.10076886f, -0.04253081f, 0.14080229f, 0.06117832f, 
    0.04542946f, -0.03485548f, -0.02523026f, -0.06396036f, 0.07382138f, -0.08183146f, -0.02782480f, -0.00875434f, 
    0.03714357f, -0.12192824f, -0.21418913f, -0.07941066f, 0.17112197f, -0.02141985f, -0.00433013f, 0.05649684f, 
    -0.04134621f, -0.01336427f, 0.05757087f, -0.00561472f, 0.02127264f, -0.01212218f, 0.01098406f, -0.04649957f, 
    0.04215316f, -0.01213649f, -0.02660549f, -0.13636771f, -0.07208942f, -0.02401302f, -0.29610413f, -0.18721317f, 
    -0.21096745f, 0.09780607f, 0.01482911f, 0.03271346f, 0.03935965f, -0.01000874f, -0.03849719f, -0.06024199f, 
    -0.03286033f, 0.15262082f, -0.07666053f, -0.06992087f, -0.06147544f, -0.04228583f, -0.06416234f, -0.03857206f, 
    0.17001681f, -0.03089829f, 0.04762702f, 0.10779592f, 0.02951803f, 0.06380666f, -0.08391020f, 0.02951500f, 
    0.00009609f, 0.03246395f, -0.03144346f, -0.00690174f, -0.03390256f, 0.09202827f, 0.03305571f, 0.10470412f, 
    -0.02197482f, 0.04534639f, -0.02763489f, -0.09164772f, 0.08610822f, -0.26404619f, 0.02788161f, -0.12602831f, 
    0.03246247f, -0.00735796f, 0.00046274f, 0.00113170f, 0.07472402f, 0.02578849f, -0.13745201f, -0.07283371f, 
    0.01826111f, -0.03593357f, 0.08403394f, 0.07803547f, 0.03703767f, 0.08681466f, 0.00514938f, -0.16655861f, 
    -0.11350437f, 0.10261023f, -0.13733131f, -0.15854456f, -0.05465560f, -0.01182852f, 0.07235894f, -0.04679148f, 
    -0.01850468f, -0.01481410f, -0.01547250f, -0.07183244f, 0.05570923f, 0.01251063f, -0.06673908f, 0.02208957f, 
    -0.02556135f, 0.05502663f, -0.06299741f, 0.01697241f, 0.22760674f, -0.13732873f, -0.20403758f, -0.14939071f, 
    -0.09411314f, -0.03097333f, -0.03306257f, -0.03074399f, 0.03232243f, -0.04467094f, 0.04950938f, 0.00266939f, 
    -0.05609803f, -0.04930655f, -0.01643662f, -0.06258517f, 0.03416339f, -0.05604897f, 0.00772251f, 0.04149900f, 
    0.04286167f, 0.19349730f, 0.09857658f, 0.06349955f, 0.17910241f, -0.17694449f, -0.06302906f, 0.00970455f, 
    -0.03391063f, 0.07469303f, 0.05729884f, 0.01869083f, 0.08778504f, -0.00475381f, 0.03535479f, 0.03924624f, 
    0.06549265f, -0.01157310f, -0.01382132f, 0.05392498f, -0.15774481f, -0.09968125f, -0.32280463f, -0.13330457f, 
    -0.00682314f, 0.02553843f, 0.05067185f, 0.02289304f, 0.05931518f, 0.00634113f, -0.09767902f, -0.07322333f, 
    -0.03530191f, -0.09408130f, 0.02343019f, 0.02384597f, 0.04626880f, -0.06281621f, 0.04785660f, -0.05423458f, 
    -0.08950250f, 0.06479129f, -0.13507697f, -0.07874965f, -0.00862064f, 0.12357717f, -0.03694099f, 0.03453641f, 
    0.00567543f, 0.05910154f, 0.05297799f, -0.01577341f, 0.01642253f, -0.03091526f, -0.02689204f, -0.02525987f, 
    0.04007584f, -0.04008618f, -0.17904772f, 0.00951536f, -0.27692297f, 0.03289166f, -0.08629882f, -0.07610361f, 
    0.04879522f, 0.04083148f, 0.09448642f, -0.00250796f, -0.01967130f, 0.04745180f, 0.01632238f, 0.07802120f, 
    0.11166184f, -0.07076489f, 0.02985798f, 0.02003765f, -0.10293522f, 0.08443996f, 0.03281285f, -0.01032999f, 
    0.39779833f, -0.41717464f, 0.06007262f, -0.13722375f, -0.09692083f, -0.04250258f, -0.12525786f, -0.02389750f, 
    0.01117887f, -0.01854613f, 0.01704841f, 0.11565665f, -0.14120401f, 0.00634819f, 0.07859442f, -0.05903449f, 
    -0.05684119f, -0.01984602f, -0.05414672f, -0.03708018f, 0.01112629f, 0.03836892f, 0.10760781f, -0.21673614f, 
    0.03672191f, -0.00847105f, 0.06129418f, 0.04758411f, 0.02939519f, -0.01789796f, 0.00399182f, -0.06697100f, 
    0.08480389f, 0.02756064f, -0.02603580f, -0.04977150f, 0.00208858f, -0.19144605f, -0.04128515f, -0.02814488f, 
    0.34832647f, 0.01433922f, 0.07083247f, -0.01574334f, 0.03347662f, -0.05825808f, 0.06890243f, 0.00876752f, 
    0.05774599f, 0.01333083f, 0.03864658f, -0.02380717f, -0.00493558f, 0.06050105f, 0.03666926f, -0.06194252f, 
    -0.07806705f, 0.08370391f, 0.05207183f, 0.11311410f, 0.17884769f, 0.18458614f, -0.02833676f, 0.09548063f, 
    0.27425501f, 0.02231645f, -0.07056075f, 0.00169419f, -0.01182474f, -0.06181958f, 0.09552590f, -0.08306810f, 
    -0.05463436f, 0.01632125f, 0.00477882f, 0.06226179f, 0.02494579f, 0.07866410f, -0.06477487f, -0.01334422f, 
    -0.01738639f, -0.00730664f, -0.07165533f, 0.06555556f, 0.10161450f, -0.01528204f, -0.04137274f, -0.00391299f, 
    -0.02029451f, 0.00859647f, 0.02808087f, 0.12086961f, -0.04095237f, -0.04560912f, 0.08063012f, 0.02371187f, 
    -0.02956656f, 0.07761335f, 0.02113714f, -0.01843658f, 0.20838328f, -0.16210981f, -0.13766138f, 0.01936640f, 
    -0.11813988f, -0.02714367f, 0.02900350f, -0.04524076f, 0.05042594f, 0.08423477f, 0.05327339f, 0.00427541f, 
    -0.03356143f, -0.01903425f, 0.05911493f, 0.04085615f, 0.00300570f, -0.03712230f, -0.13108811f, -0.01924431f, 
    -0.01562361f, 0.10116638f, -0.03695492f, -0.14181478f, -0.08989233f, 0.02452043f, 0.05267177f, -0.02838872f, 
    0.02055561f, -0.04281734f, -0.09201486f, -0.07084388f, -0.02287920f, -0.03099723f, 0.03292278f, 0.07496080f, 
    -0.08054268f, 0.04608378f, 0.00998048f, 0.05205189f, 0.22154546f, -0.28710026f, -0.06076407f, 0.10523318f, 
    0.01245062f, -0.12438128f, 0.05138417f, 0.03867239f, 0.10019500f, 0.00440570f, 0.02313888f, -0.03781567f, 
    0.03004750f, 0.04448164f, -0.01108570f, 0.08141004f, -0.07641491f, 0.04575295f, -0.02598849f, 0.01186478f, 
    -0.20894471f, 0.04353623f, -0.34942579f, -0.20571275f, 0.04425938f, -0.13192646f, 0.00616079f, 0.02887166f, 
    -0.01225122f, 0.10237468f, 0.05996631f, -0.05098176f, 0.14268345f, 0.06491614f, 0.01680090f, 0.06341823f, 
    -0.01237485f, -0.04260429f, -0.07165584f, 0.03457899f, 0.10852405f, -0.25035357f, -0.04338477f, 0.01868734f, 
    -0.15375476f, 0.04609056f, 0.09449403f, -0.06197818f, 0.00569001f, 0.04021916f, 0.07528447f, 0.03013814f, 
    -0.00392709f, -0.00392548f, -0.03955789f, 0.03048424f, 0.04443735f, -0.08551164f, 0.08795822f, -0.05085956f, 
    0.10503197f, 0.08938920f, 0.01613258f, 0.18576236f, 0.09599282f, -0.02048239f, -0.07135649f, 0.06185645f, 
    0.00050662f, 0.03264846f, -0.03995026f, 0.00365946f, -0.03589615f, 0.01312886f, -0.04307754f, 0.02525750f, 
    0.01148726f, 0.03508668f, -0.01914361f, -0.05196882f, -0.02936604f, -0.00463579f, 0.00817946f, 0.04540183f, 
    -0.05371579f, -0.03491890f, -0.05035321f, -0.05833185f, -0.00415533f, 0.00567084f, -0.02274730f, 0.00290279f, 
    -0.08196008f, 0.03866327f, 0.00136003f, 0.02761764f, -0.01560967f, 0.01095466f, 0.00758996f, -0.02273432f, 
    0.10486911f, -0.15525496f, 0.00341402f, 0.02410720f, 0.00865472f, -0.03841078f, -0.04240596f, 0.02203819f, 
    -0.08589168f, 0.00028254f, 0.14657050f, 0.09155301f, -0.15741357f, -0.02448079f, -0.04817518f, -0.02451410f, 
    -0.07324053f, -0.02138736f, -0.06508329f, 0.05854651f, 0.25768477f, -0.17975405f, 0.02683365f, 0.03765325f, 
    -0.09197091f, 0.06214201f, 0.11276597f, -0.03454943f, -0.01547608f, 0.01564837f, 0.10387482f, 0.04319687f, 
    -0.00920813f, 0.07050604f, -0.15167221f, 0.06873780f, 0.10405936f, -0.03098424f, 0.02458491f, 0.04685998f, 
    0.13600625f, 0.21176320f, 0.18321353f, 0.05018554f, 0.23627146f, -0.11197669f, -0.01456669f, -0.01151521f, 
    0.01543725f, 0.03709248f, 0.05359879f, -0.07980637f, 0.01174878f, -0.02209242f, 0.04170339f, -0.04899658f, 
    0.03187882f, 0.00949042f, -0.00084250f, 0.13080840f, -0.25631192f, 0.06672835f, 0.00682972f, 0.02242884f, 
    -0.02291696f, -0.13165618f, 0.01411127f, 0.02577483f, 0.04872776f, 0.05684107f, -0.07482513f, -0.01152523f, 
    -0.03054618f, -0.07784881f, -0.04590699f, 0.12353975f, 0.04032009f, 0.00112828f, 0.01309075f, 0.06014854f, 
    0.07507769f, -0.07417718f, 0.16306461f, 0.00474895f, 0.14768170f, 0.01276843f, -0.05198233f, 0.04831344f, 
    -0.01026660f, -0.03363671f, -0.08112559f, 0.01485432f, 0.05157673f, -0.04059770f, 0.00748155f, 0.02693093f, 
    0.02214325f, -0.02675388f, 0.03613485f, 0.05795629f, 0.07627559f, 0.04422252f, 0.05109548f, 0.01170646f, 
    0.17506067f, -0.02427308f, 0.03384657f, 0.05748464f, -0.00220236f, -0.01185887f, -0.05388755f, 0.00351135f, 
    0.09281481f, 0.03960205f, -0.00805909f, -0.01204634f, -0.06571910f, -0.01309375f, 0.02047336f, 0.08661633f, 
    -0.14169845f, -0.07234384f, -0.14569631f, -0.07730860f, 0.02446214f, 0.01281626f, -0.04134193f, 0.00587568f, 
    -0.02724493f, 0.12354117f, -0.01955535f, 0.01697507f, -0.03362826f, -0.02240966f, 0.00790649f, -0.05129189f, 
    0.00731113f, -0.02308873f, 0.02534704f, 0.01976719f, -0.01774969f, -0.00289532f, -0.11814202f, -0.12968090f, 
    -0.10456638f, 0.04331950f, 0.09446646f, -0.00561363f, 0.03598965f, -0.02277533f, 0.02252690f, -0.02328572f, 
    -0.00768073f, 0.03762003f, -0.00275845f, -0.01086020f, 0.01676786f, 0.06756318f, 0.01438296f, -0.10044052f, 
    0.12870856f, 0.06930748f, 0.11782803f, 0.00706980f, 0.16358809f, -0.06601641f, -0.07299443f, 0.00052103f, 
    -0.02719238f, 0.00532019f, -0.05525058f, -0.02780797f, -0.03464292f, -0.09979900f, -0.05316226f, 0.01214826f, 
    -0.06846388f, -0.09048630f, 0.04981994f, 0.01221388f, -0.05521771f, -0.10716638f, -0.10093927f, 0.04243398f, 
    -0.18811946f, 0.04394728f, 0.01705303f, 0.01369188f, 0.01727072f, 0.05367529f, 0.02829069f, -0.09177343f, 
    0.05156318f, 0.04283177f, -0.02857390f, -0.07035694f, -0.04308088f, -0.17398939f, -0.14432879f, 0.05699580f, 
    0.08035590f, -0.09001118f, -0.00878902f, -0.08913273f, -0.10394985f, -0.06516453f, 0.04356290f, 0.05888297f, 
    -0.06415230f, -0.04792202f, 0.13898028f, -0.11907428f, 0.09267366f, -0.12484193f, 0.04461543f, -0.21615024f, 
    -0.07175968f, -0.20214254f, 0.02778540f, 0.03397605f, -0.32789433f, -0.15267570f, -0.06904508f, -0.03022533f, 
    -0.03661147f, 0.10925369f, -0.12876999f, -0.03491689f, 0.03751124f, 0.00210151f, -0.07129574f, 0.00400673f, 
    0.00417443f, -0.07311622f, 0.09991626f, -0.00113695f, -0.05284446f, -0.12768833f, 0.01222616f, -0.12389567f, 
    -0.06321032f, 0.09899383f, -0.10135799f, 0.10174306f, -0.10021541f, 0.05011964f, 0.01748966f, -0.09277161f, 
    -0.04848391f, 0.13976078f, 0.03802115f, 0.11630853f, -0.12118364f, 0.00637244f, 0.07842372f, 0.01782089f, 
    0.07877326f, 0.02135050f, -0.00264095f, -0.02794496f, -0.33021504f, 0.05098961f, -0.09034930f, -0.02957044f, 
    -0.37333733f, 0.00199897f, 0.02932318f, 0.02534980f, -0.02360582f, -0.06122326f, -0.00493527f, -0.08836216f, 
    -0.03784350f, -0.01213329f, 0.08665586f, -0.04343014f, 0.03912531f, -0.10708395f, -0.02924917f, -0.05757622f, 
    -0.00049683f, -0.15371291f, -0.09178609f, -0.24347164f, -0.04767201f, 0.02261551f, -0.05692063f, 0.10468914f, 
    0.02150904f, 0.04668574f, -0.10333075f, -0.08431131f, 0.14337714f, 0.05090359f, 0.10411122f, -0.11596671f, 
    0.03476122f, -0.13321966f, -0.12495425f, -0.07366520f, 0.07130044f, 0.04042156f, -0.09505311f, 0.00647205f, 
    -0.11090753f, -0.00933881f, 0.02997654f, -0.05493746f, -0.03916066f, 0.05159217f, 0.03108563f, 0.04068552f, 
    0.02758787f, -0.03373488f, 0.07998857f, 0.02143912f, -0.04111861f, -0.01527604f, -0.04408045f, 0.07178129f, 
    0.06903191f, -0.12535235f, 0.13529705f, -0.07751064f, 0.00018526f, 0.01657679f, -0.12601618f, 0.00972253f, 
    -0.04933687f, -0.07818277f, 0.03622092f, 0.02193106f, 0.01530982f, 0.02181637f, 0.00988226f, 0.04479495f, 
    0.01801040f, -0.12216762f, 0.01930754f, -0.09361856f, -0.13433617f, -0.16683480f, 0.02720282f, -0.01820111f, 
    0.04804417f, 0.01155404f, -0.05048909f, -0.03756774f, 0.17663366f, -0.07350802f, 0.00349855f, 0.06180338f, 
    -0.03752040f, 0.00632283f, -0.00362215f, -0.05684996f, -0.06743439f, -0.00694261f, 0.08392137f, 0.03083435f, 
    0.08036990f, -0.03132754f, 0.01132828f, 0.04802803f, -0.05218949f, -0.04845429f, 0.00271339f, 0.12210066f, 
    0.01888311f, 0.05695404f, -0.01616669f, -0.11611135f, 0.07231281f, 0.00843363f, -0.06988474f, 0.04888219f, 
    0.11940905f, -0.09915321f, 0.10392379f, -0.04685177f, -0.23929206f, 0.00968326f, -0.27294779f, -0.14097853f, 
    -0.05382879f, -0.01620472f, 0.03679837f, 0.00146682f, 0.06847369f, 0.03961530f, -0.00537216f, -0.03734758f, 
    0.02828775f, 0.01673445f, -0.08738703f, -0.05486855f, -0.00560870f, 0.05286436f, -0.09237484f, 0.05518157f, 
    -0.33680987f, 0.05979652f, 0.08293245f, 0.01304121f, -0.15584207f, -0.04660593f, -0.00459988f, 0.00781615f, 
    0.04431550f, -0.05517050f, -0.00382296f, 0.06256682f, 0.01995674f, -0.01339755f, -0.08921856f, 0.01530689f, 
    -0.06178815f, -0.00635587f, -0.02690405f, -0.01183583f, 0.06189210f, 0.14169016f, -0.02951227f, -0.01954854f, 
    -0.15517704f, 0.01423365f, -0.04468815f, 0.05568736f, -0.07139599f, 0.04376064f, 0.11148977f, -0.05325328f, 
    0.01251574f, 0.04039330f, 0.02714391f, -0.06485546f, 0.08789304f, -0.16434599f, -0.02628949f, 0.01869034f, 
    -0.22041342f, 0.21172073f, -0.13623604f, -0.08948828f, 0.07622115f, 0.06440948f, 0.04988802f, 0.06862000f, 
    -0.04392012f, 0.08328672f, 0.01398159f, -0.02874712f, 0.01777271f, -0.10054684f, -0.10290845f, -0.07721919f, 
    0.02438399f, 0.07762580f, -0.14091328f, 0.11269721f, -0.16347504f, -0.07468599f, -0.02959213f, -0.22018634f, 
    0.12864257f, -0.00805843f, -0.04214520f, -0.00197329f, 0.02223547f, 0.01364854f, 0.13124451f, -0.04864234f, 
    0.00277980f, -0.04000485f, -0.01176031f, -0.04520688f, -0.04764418f, 0.01454343f, 0.10176276f, -0.12194246f, 
    0.15049362f, -0.08213673f, 0.17679030f, -0.08844388f, 0.05579597f, -0.12349661f, -0.09263916f, -0.03072831f, 
    -0.02373377f, -0.04233906f, -0.10907906f, 0.01728569f, -0.03853490f, 0.02754605f, 0.01609764f, -0.04164119f, 
    0.03760473f, -0.08148681f, 0.03549501f, -0.03417417f, 0.14087878f, 0.09134261f, 0.18135867f, 0.06688777f, 
    0.18407138f, -0.00684885f, -0.01770486f, -0.04595926f, -0.00646712f, -0.04487823f, 0.01682186f, 0.01921241f, 
    -0.02393815f, 0.07418365f, -0.04917820f, -0.08951373f, 0.08613754f, 0.03936035f, 0.02443151f, 0.00760206f, 
    0.09301351f, -0.08848375f, 0.11414971f, 0.06028808f, 0.11161714f, -0.06286875f, -0.06328704f, -0.06187293f, 
    -0.01999184f, 0.01409894f, 0.03252557f, -0.04547979f, -0.04512248f, 0.00063034f, 0.01141186f, -0.05059332f, 
    -0.03516457f, -0.03141680f, -0.00483486f, 0.01963822f, -0.02632768f, 0.13048747f, 0.05347165f, -0.03655239f, 
    -0.02333875f, -0.03404700f, 0.07008739f, 0.03782117f, -0.01659633f, -0.07025529f, 0.03184068f, -0.03246664f, 
    0.00494180f, -0.01266631f, -0.08364704f, 0.02868942f, 0.04932658f, -0.04286414f, 0.16406620f, -0.02201100f, 
    0.22090186f, -0.33965930f, -0.08269848f, -0.05331982f, -0.28265375f, -0.06904564f, 0.00870345f, -0.06109704f, 
    0.02616946f, -0.05838542f, 0.04961972f, -0.00027778f, 0.07054680f, -0.01125496f, -0.01372890f, 0.00688138f, 
    0.00402897f, 0.07225337f, 0.03119905f, -0.03499836f, 0.13063829f, -0.01283995f, 0.14829431f, 0.05760212f, 
    0.10978355f, -0.14620085f, -0.01783133f, -0.04652309f, 0.02186397f, 0.01041497f, 0.00724021f, -0.03576019f, 
    0.02357619f, -0.05430624f, -0.01156516f, 0.00302964f, -0.04973968f, -0.01078301f, 0.03900228f, 0.06149503f, 
    0.18541320f, -0.02961276f, 0.00856026f, 0.11100399f, 0.11000448f, -0.06035050f, 0.02979478f, -0.00331787f, 
    0.04406803f, 0.04431264f, 0.04918015f, 0.01491579f, 0.01718934f, 0.03450848f, -0.02683846f, -0.00122039f, 
    -0.04040814f, -0.05544138f, 0.03268275f, 0.01421824f, 0.07354238f, 0.02132755f, 0.16547403f, -0.10666896f, 
    0.06372739f, -0.00858612f, -0.04445658f, 0.03828695f, 0.01604778f, -0.00168000f, -0.00065624f, -0.05439562f, 
    0.05873632f, 0.03330868f, -0.02217017f, 0.02975923f, -0.08389620f, 0.00877062f, 0.03309867f, -0.02011920f, 
    0.15639603f, 0.08310801f, 0.00148537f, 0.02181247f, 0.07658844f, 0.03285192f, -0.05917246f, 0.03216286f, 
    0.00349085f, 0.04051330f, 0.00350211f, -0.00424073f, 0.02797981f, -0.01796606f, 0.00237779f, -0.03073987f, 
    -0.00484847f, -0.00592145f, -0.07989478f, -0.02553159f, -0.48776612f, 0.14777534f, 0.06201672f, -0.06839044f, 
    0.11350887f, -0.00380746f, 0.04614063f, 0.03992630f, 0.06792605f, -0.00775684f, 0.02992054f, -0.05537866f, 
    0.04224002f, -0.01047858f, 0.08371817f, -0.01044919f, -0.00506562f, -0.07201584f, 0.02197942f, 0.01389553f, 
    0.04729500f, -0.02644333f, 0.07866918f, -0.08524236f, -0.06667407f, -0.02474316f, -0.09168056f, 0.01494830f, 
    0.01822338f, 0.01098319f, -0.06285975f, -0.03771866f, 0.02732936f, 0.04676240f, -0.02356240f, -0.02686465f, 
    -0.15381405f, 0.08816861f, 0.00731953f, -0.01153667f, 0.34141678f, -0.30198032f, -0.11070378f, -0.05206732f, 
    -0.39130837f, -0.08381934f, -0.00590492f, -0.10274608f, -0.06217157f, 0.03033218f, -0.00474937f, 0.05045147f, 
    0.05292306f, -0.05504005f, -0.02606660f, -0.02898451f, -0.00835605f, 0.05990846f, 0.04980096f, 0.01171998f, 
    -0.07225658f, -0.03332144f, 0.07106193f, -0.12062974f, 0.03395134f, -0.06492801f, -0.00820078f, -0.01421634f, 
    -0.00174831f, 0.00573982f, 0.00303189f, -0.01113289f, 0.03391132f, 0.00370185f, 0.01362937f, -0.01178100f, 
    -0.02233770f, -0.05589434f, -0.04393268f, -0.03993360f, 0.09597708f, -0.07738294f, -0.03488820f, -0.04487988f, 
    0.00197817f, -0.02390114f, -0.00591936f, 0.09972813f, -0.04171303f, -0.01622629f, 0.02965636f, -0.04017051f, 
    0.04737863f, 0.03468463f, 0.01173854f, -0.04428497f, -0.07736106f, 0.08988672f, -0.09619141f, -0.04317274f, 
    0.05196751f, -0.07160331f, 0.01036220f, -0.06242966f, 0.08055697f, 0.06234097f, 0.01149900f, 0.04458055f, 
    -0.03707358f, -0.00592481f, -0.00501933f, 0.05528404f, -0.07027206f, -0.07677445f, -0.03438928f, 0.03369654f, 
    0.01512501f, 0.00640045f, -0.11502779f, 0.02517824f, 0.26291522f, 0.00149553f, -0.15966745f, -0.09298255f, 
    -0.10103011f, -0.05016141f, 0.03127120f, -0.02372989f, -0.03997238f, 0.01847695f, 0.00054239f, 0.01207910f, 
    0.00663693f, -0.00368454f, 0.01921282f, 0.01319558f, 0.01311864f, -0.03608545f, 0.06315216f, -0.03966984f, 
    0.20194307f, -0.00504186f, -0.12519431f, 0.06051100f, -0.05822777f, -0.05273482f, 0.01395029f, 0.01079504f, 
    -0.03072663f, 0.03474813f, 0.00560320f, 0.01904987f, 0.01555131f, -0.04474373f, 0.01476877f, 0.03539293f, 
    -0.06742776f, -0.03441770f, 0.09793347f, -0.01797143f, 0.04307931f, 0.09974728f, 0.08572038f, 0.07630585f, 
    0.04679541f, 0.00551060f, -0.05552828f, -0.07449625f, 0.02657512f, 0.02020660f, -0.00700688f, -0.02061474f, 
    -0.05463723f, -0.02598200f, -0.01607027f, 0.03737391f, 0.05586088f, 0.00050169f, 0.03783124f, -0.02054404f, 
    0.00064344f, -0.10873988f, -0.08025308f, -0.08092170f, -0.09577402f, -0.00088535f, 0.03194894f, 0.09069695f, 
    -0.06302691f, 0.01731175f, -0.02719585f, -0.03347770f, -0.03008775f, -0.00702086f, -0.08713541f, -0.00280739f, 
    0.01555829f, 0.06654745f, -0.06011540f, 0.00595073f, -0.03563580f, -0.01877832f, -0.12592515f, -0.09872779f, 
    -0.05898384f, 0.02000204f, 0.08980765f, 0.06948283f, -0.13389181f, -0.08441184f, -0.08910228f, 0.02014734f, 
    0.00880298f, -0.05208983f, 0.01762577f, 0.02789376f, 0.00038898f, 0.00726327f, -0.05084862f, -0.01559367f, 
    -0.22223280f, 0.14262795f, -0.01489927f, -0.08485059f, 0.02299987f, 0.04400998f, 0.02066404f, 0.10268585f, 
    -0.01797414f, -0.02796462f, -0.08701538f, 0.01803314f, -0.02629413f, -0.07123525f, -0.05512565f, -0.05905939f, 
    -0.03074014f, 0.03044216f, -0.00154674f, -0.02307391f, 0.04743144f, -0.02527537f, 0.02315491f, -0.01980275f, 
    -0.19542579f, -0.05202535f, -0.02545663f, 0.03263483f, 0.02044516f, 0.01109845f, 0.00899211f, 0.00815882f, 
    -0.03225610f, -0.03753201f, -0.01320532f, 0.01112092f, -0.01361460f, 0.01262508f, -0.05743709f, -0.01302220f, 
    0.17825055f, 0.07188879f, -0.22950365f, -0.02157609f, -0.11158007f, -0.01252930f, 0.01020854f, -0.00127531f, 
    -0.05887034f, -0.05333589f, -0.03817100f, -0.03853628f, -0.03018717f, -0.00122551f, 0.01042365f, 0.02031151f, 
    0.02257833f, -0.07899691f, 0.00245177f, 0.00003672f, -0.08691746f, -0.26886722f, -0.01759211f, -0.01901743f, 
    0.02915354f, -0.07341664f, -0.05454994f, -0.05680925f, -0.01783812f, 0.03547436f, 0.05535622f, -0.02414813f, 
    0.04688932f, 0.02323460f, 0.05026279f, 0.03480254f, -0.03832160f, 0.05801730f, -0.04859313f, -0.04487426f, 
    -0.09596085f, 0.01153878f, 0.07828303f, -0.02344141f, 0.01528262f, 0.04020853f, 0.05008930f, 0.08188572f, 
    -0.01739536f, -0.02656926f, -0.09287260f, 0.06038961f, -0.02862461f, 0.00159250f, -0.00171396f, -0.01290025f, 
    -0.14227402f, -0.00395163f, -0.06841636f, -0.02319656f, 0.18524319f, -0.24322259f, 0.06248038f, -0.01414081f, 
    -0.10665246f, 0.02046199f, -0.08810837f, -0.04896491f, 0.00373972f, -0.05101565f, -0.05264173f, -0.02329528f, 
    0.01140730f, -0.00477156f, -0.05652474f, 0.08234195f, -0.06963304f, -0.08570642f, 0.09129218f, -0.11187623f, 
    -0.01152929f, -0.13622263f, 0.09444343f, -0.07713070f, -0.02064816f, -0.02418654f, -0.07249884f, -0.00053237f, 
    -0.00884095f, 0.01027999f, -0.04244937f, -0.02535137f, 0.00202488f, 0.01550985f, 0.02265600f, -0.02459920f, 
    0.02164487f, 0.01222895f, 0.06331909f, 0.00546621f, 0.21535084f, 0.04099599f, -0.15069249f, -0.01304838f, 
    0.04549913f, -0.04769485f, -0.04701004f, 0.03563939f, 0.01957610f, 0.05872346f, -0.05016424f, 0.02532074f, 
    -0.02625686f, 0.00873924f, 0.01880951f, 0.00206603f, -0.06073308f, -0.12258735f, 0.00122779f, 0.01728259f, 
    0.03742330f, 0.03769658f, -0.04169222f, -0.09435894f, -0.19839329f, -0.04804255f, -0.08509725f, 0.10235257f, 
    0.03858494f, 0.01027897f, -0.09618460f, 0.04920308f, -0.00158437f, -0.03575308f, 0.00576365f, -0.01094790f, 
    -0.01163657f, 0.05918905f, 0.09324379f, 0.05522551f, -0.30565071f, -0.32919943f, -0.11798546f, -0.10694849f, 
    -0.30142021f, 0.00803866f, 0.01819180f, -0.07767258f, -0.01281176f, -0.04327766f, 0.01324981f, 0.02074207f, 
    -0.01160325f, 0.02478500f, -0.00261762f, 0.00207694f, 0.00966950f, 0.07780825f, -0.01534392f, -0.05787734f, 
    -0.02503781f, 0.00065734f, -0.02721358f, 0.06792463f, -0.02622127f, 0.01074049f, -0.01991751f, 0.01090764f, 
    0.04502293f, 0.02837064f, 0.00532885f, 0.02259840f, 0.02801923f, -0.01205731f, -0.00291626f, -0.02134843f, 
    -0.02413633f, -0.05778053f, -0.01449687f, -0.01351978f, -0.02441590f, 0.11784472f, -0.01434927f, -0.09415455f, 
    -0.01177917f, 0.01870213f, 0.04119650f, 0.05004103f, -0.01660326f, -0.02699592f, -0.03517899f, -0.01638043f, 
    -0.04506861f, -0.04367936f, -0.02276957f, -0.01973039f, -0.01795944f, 0.03213274f, -0.04705269f, -0.02309957f, 
    0.08003525f, 0.03056709f, -0.06596515f, -0.01414528f, 0.05140264f, 0.01253434f, -0.04387409f, -0.00914789f, 
    0.04024747f, 0.02086651f, -0.02212116f, -0.02811636f, -0.00532895f, 0.02626144f, -0.00983095f, -0.03451269f, 
    -0.01426432f, -0.06095760f, -0.04627873f, 0.01698434f, 0.23350354f, -0.03177826f, 0.07247408f, -0.02724752f, 
    0.15403724f, -0.09674945f, 0.02776535f, -0.10983539f, 0.06489261f, 0.04170869f, 0.10276291f, -0.06242159f, 
    -0.03298140f, 0.03100165f, -0.04197850f, 0.01783295f, -0.01274910f, 0.04109968f, -0.00977042f, -0.00630030f, 
    0.09268038f, 0.04679896f, -0.12541248f, 0.03774917f, -0.04874868f, -0.07144556f, 0.00315348f, -0.00151056f, 
    -0.01133322f, 0.02282370f, -0.01901109f, 0.00262551f, 0.03434268f, 0.01701515f, 0.00649044f, 0.00632751f, 
    -0.03597286f, -0.09439342f, 0.08351314f, 0.01238998f, 0.36521932f, -0.05323865f, 0.00374299f, 0.22945777f, 
    -0.16745688f, -0.06912985f, 0.03146175f, 0.02759926f, 0.00097991f, 0.08580329f, 0.02207306f, 0.04950986f, 
    0.06679190f, 0.04666245f, -0.02518577f, -0.00098963f, -0.03295503f, -0.03311336f, 0.05979346f, 0.00829502f, 
    0.06210820f, -0.00009867f, -0.21761164f, -0.14410295f, -0.07677225f, 0.00703215f, -0.00127113f, 0.01721517f, 
    -0.07820298f, -0.00907097f, -0.06033542f, 0.00660508f, -0.01578693f, -0.01149158f, 0.01487627f, -0.04543961f, 
    -0.01540925f, 0.00146132f, -0.01074001f, -0.03371485f, 0.00263045f, -0.05056028f, 0.13297561f, -0.03195637f, 
    0.06164083f, -0.09674399f, -0.07607190f, -0.01559796f, 0.01499520f, 0.06965192f, -0.02833802f, -0.04730697f, 
    -0.01691731f, -0.01154636f, -0.00278522f, -0.03424765f, -0.04287983f, -0.03666825f, -0.01632865f, 0.03611662f, 
    -0.16008155f, 0.06386364f, 0.00271383f, -0.08630840f, 0.07813054f, 0.04410420f, 0.03609382f, 0.02600179f, 
    0.04889370f, -0.06283252f, -0.00533999f, 0.01512304f, 0.02258026f, -0.01586965f, -0.02789322f, -0.02734742f, 
    0.00334322f, -0.03416511f, -0.05045656f, -0.02831034f, 0.24153054f, 0.01310846f, -0.09008520f, -0.00997298f, 
    -0.01150689f, -0.06899206f, 0.03030775f, 0.02409739f, 0.01449964f, 0.03947951f, 0.00996124f, 0.01502571f, 
    -0.03954182f, -0.05165036f, -0.01063696f, 0.01539929f, -0.04434643f, -0.02343228f, 0.05923570f, -0.04023832f, 
    0.12679651f, 0.04197157f, -0.06489365f, 0.10989328f, 0.09665733f, 0.02341956f, -0.03459571f, -0.01634666f, 
    0.07723689f, 0.08800557f, 0.01724223f, 0.06277125f, 0.06372037f, 0.05512170f, -0.02815243f, 0.01660850f, 
    -0.05255148f, 0.00847413f, -0.06477403f, -0.02822166f, 0.10190582f, 0.10148145f, 0.10234406f, 0.07001105f, 
    0.11017975f, -0.07218781f, -0.08473900f, -0.03076896f, -0.00898335f, 0.01694793f, 0.07589182f, -0.02390082f, 
    0.00554234f, 0.03251400f, -0.00283203f, -0.03035645f, -0.03518617f, -0.02231047f, -0.07356542f, 0.01670470f, 
    0.06867618f, -0.09176032f, -0.03110342f, -0.03774778f, 0.04981419f, 0.05776262f, 0.05156480f, 0.08342388f, 
    -0.01793938f, -0.02969263f, 0.01524588f, 0.03996140f, -0.01389640f, -0.04081474f, -0.01027392f, -0.02261633f, 
    -0.13321193f, -0.02586268f, -0.05144194f, -0.02415236f, 0.22062431f, -0.00544804f, 0.01621570f, 0.03517197f, 
    -0.00710347f, -0.14060052f, -0.03296642f, 0.02389744f, -0.02799145f, -0.05830849f, 0.03141223f, -0.04217213f, 
    -0.04433309f, -0.05710576f, -0.01775786f, 0.00123918f, -0.04062688f, 0.02418600f, 0.04773385f, 0.01105187f, 
    0.11296693f, -0.04071720f, 0.03767415f, -0.03802866f, 0.04059833f, 0.06559744f, 0.00265215f, 0.07118972f, 
    0.00070353f, -0.00119331f, -0.01523323f, 0.02221779f, -0.06401028f, -0.02783686f, -0.08337401f, 0.00684385f, 
    -0.11453942f, -0.03509555f, -0.05512850f, -0.05248059f, 0.03077541f, -0.16562536f, 0.05367959f, -0.02350409f, 
    0.02720225f, 0.05244098f, 0.07664401f, 0.00887480f, -0.00698898f, -0.02060369f, -0.02942609f, 0.01490146f, 
    -0.05161027f, -0.01668702f, -0.05011795f, 0.01215486f, 0.01121601f, -0.00821832f, -0.14455017f, -0.03346132f, 
    0.34456024f, -0.18807977f, -0.13635857f, -0.06512156f, -0.04264899f, -0.01703558f, -0.05525391f, 0.02026003f, 
    0.02862366f, -0.00318814f, 0.02651874f, 0.01718149f, -0.01267509f, 0.01897476f, 0.06838197f, 0.02050104f, 
    -0.08984616f, -0.02293300f, 0.03940475f, -0.07433151f, 0.05145863f, 0.03222417f, -0.19592099f, -0.03311072f, 
    -0.01760338f, -0.01817561f, 0.04323329f, 0.00511262f, -0.00910139f, 0.02446805f, -0.02167019f, -0.00791211f, 
    0.04403056f, -0.00023959f, -0.02488279f, -0.05327361f, 0.04137767f, -0.00182180f, -0.03755528f, 0.01080877f, 
    -0.02934856f, -0.19817792f, 0.02596842f, -0.08682396f, -0.01329062f, 0.10416352f, 0.09390619f, 0.03523405f, 
    -0.03491183f, -0.00409189f, -0.00746776f, 0.08988453f, 0.04554850f, -0.05892906f, -0.06836795f, 0.01962817f, 
    -0.01396290f, 0.04846433f, -0.10483333f, -0.01381821f, 0.31953910f, -0.00393852f, -0.07251708f, -0.24774952f, 
    -0.21608676f, -0.07208107f, 0.05487110f, -0.07886261f, 0.02865560f, -0.06011210f, -0.00546152f, -0.08751593f, 
    0.00611433f, 0.03579594f, -0.11203898f, 0.01193527f, 0.11984064f, -0.01152680f, 0.07041333f, -0.08322927f, 
    -0.45999661f, -0.02565184f, -0.10918322f, -0.15647720f, -0.04492985f, 0.05290231f, 0.05842355f, -0.02384935f, 
    0.03533983f, -0.10682295f, -0.05865795f, -0.00130867f, -0.04894965f, -0.02451922f, -0.00663986f, -0.00870148f, 
    0.00330745f, 0.07532466f, 0.01206444f, -0.08845714f, 0.14739470f, -0.11589370f, 0.10490941f, -0.09294809f, 
    -0.07586326f, 0.03207966f, -0.00448645f, -0.07704939f, 0.07071610f, 0.11067158f, -0.02093202f, -0.00449983f, 
    -0.00238714f, 0.02972094f, -0.02869974f, -0.00398886f, -0.12581958f, 0.04282461f, 0.03834018f, -0.00729466f, 
    0.10274821f, -0.01628631f, 0.07743802f, -0.01970665f, 0.11039463f, -0.07551407f, -0.06065640f, 0.00408531f, 
    0.01794027f, -0.01895703f, 0.09222275f, 0.01309980f, 0.01441979f, -0.10866066f, 0.04604820f, 0.03438646f, 
    -0.10087827f, -0.08349508f, -0.04201901f, -0.01448021f, 0.33949298f, -0.37974465f, -0.20963652f, -0.03751304f, 
    -0.19427124f, -0.08512754f, 0.00610177f, 0.03022652f, 0.02976641f, -0.17920205f, 0.09355738f, -0.03478191f, 
    0.00210957f, 0.01493647f, 0.01539296f, 0.13523929f, -0.03863197f, 0.08214927f, 0.04202193f, 0.01305117f, 
    -0.22387779f, 0.05535076f, -0.16882578f, -0.20934743f, -0.21818802f, 0.12373555f, 0.01056548f, -0.00119486f, 
    -0.05794125f, -0.05186336f, 0.02549227f, 0.03929446f, 0.00884636f, -0.01410714f, -0.03163816f, -0.05331590f, 
    0.01529001f, 0.10540588f, 0.00998293f, -0.02705055f, 0.09455009f, 0.03998131f, 0.05758500f, 0.10306689f, 
    0.13598980f, -0.04542224f, -0.05785975f, -0.02529791f, 0.00977452f, 0.01917253f, 0.06592871f, -0.00250624f, 
    -0.01416140f, -0.01107467f, -0.02031448f, -0.02449772f, -0.03268515f, -0.08778182f, -0.02109245f, -0.03153633f, 
    -0.02499110f, -0.00431131f, 0.05035309f, -0.13860092f, -0.10785816f, -0.00945497f, -0.05479217f, 0.05681923f, 
    -0.02324825f, 0.01564561f, -0.09458588f, 0.11794404f, 0.03232003f, -0.05619209f, -0.02565541f, 0.06094439f, 
    -0.08304107f, 0.02016530f, 0.00153227f, 0.02602249f, 0.02513475f, 0.05299896f, 0.05343459f, -0.01219442f, 
    -0.17317598f, 0.02676667f, -0.04044523f, 0.06878228f, -0.06881008f, 0.10686667f, 0.00399194f, 0.06263272f, 
    -0.00001992f, -0.10219140f, 0.00507862f, 0.00148546f, -0.13163500f, 0.11464049f, 0.06877644f, -0.04251596f, 
    -0.00545813f, -0.12641834f, 0.04841051f, -0.03443082f, 0.04815245f, -0.05820909f, -0.04249538f, -0.08454607f, 
    0.01999944f, 0.03947245f, 0.01017479f, 0.01345109f, -0.04459820f, 0.01304625f, 0.01083750f, -0.06704399f, 
    0.00656614f, -0.00682430f, -0.00235721f, -0.04440439f, 0.09959278f, 0.01106174f, -0.15406911f, -0.08088592f, 
    -0.08404681f, 0.01567737f, 0.06525543f, 0.08741419f, -0.08207325f, -0.04996693f, -0.09049062f, -0.06444957f, 
    0.03747861f, 0.02271735f, -0.02038118f, -0.00993895f, 0.01045282f, -0.09766497f, -0.00254809f, -0.01704781f, 
    0.00353219f, 0.13823792f, 0.02302600f, -0.01935091f, 0.00310599f, -0.03104130f, 0.11232258f, 0.08066279f, 
    0.01397440f, -0.08756797f, 0.01154498f, 0.06114476f, 0.04915314f, -0.03811355f, 0.02180070f, 0.01669646f, 
    -0.00230550f, -0.05327361f, 0.04674286f, 0.00342923f, -0.00384493f, 0.07934228f, 0.07173988f, 0.10347287f, 
    0.11716393f, -0.07173873f, -0.06178396f, -0.10609344f, 0.01084582f, 0.04783905f, 0.03826958f, -0.06605440f, 
    -0.04739857f, -0.01131981f, 0.02644239f, 0.00207530f, -0.00383727f, 0.08613652f, -0.02887315f, -0.00078938f, 
    0.27732137f, 0.02632910f, -0.29900998f, -0.02736208f, -0.00125371f, -0.02468135f, 0.03541429f, 0.06448879f, 
    -0.03709850f, -0.05957214f, -0.04641021f, -0.10180368f, 0.05570388f, -0.01756633f, -0.02248032f, -0.09628191f, 
    -0.00458740f, -0.14189030f, 0.00818703f, -0.01837150f, -0.12938833f, -0.11570080f, -0.17441557f, 0.01343731f, 
    -0.10908630f, 0.00738148f, 0.01653689f, 0.00173939f, -0.02792352f, 0.01795079f, -0.03999005f, -0.05290970f, 
    -0.00547378f, 0.03256205f, 0.00491245f, -0.03486196f, -0.04414044f, 0.08473101f, -0.04583015f, -0.01761916f, 
    0.25185779f, -0.11756340f, 0.02919369f, -0.14060283f, -0.05154071f, 0.05292533f, -0.08904608f, 0.09217434f, 
    -0.01957661f, 0.00554961f, 0.00811156f, 0.05083719f, 0.11410412f, -0.06708203f, -0.02878202f, 0.02800677f, 
    -0.07893291f, 0.08175240f, -0.02430012f, -0.05702258f, 0.16383822f, -0.04074957f, 0.04142621f, -0.10747563f, 
    0.00536081f, 0.05315812f, -0.06263758f, 0.05687211f, 0.03190297f, 0.02964121f, -0.00722780f, -0.03389235f, 
    0.08519913f, 0.02282906f, -0.01621709f, -0.03478449f, -0.06451088f, -0.03397894f, -0.04068531f, -0.09393266f, 
    -0.00373845f, -0.06684669f, -0.13494380f, -0.07505548f, -0.05609479f, -0.01054759f, -0.05484620f, 0.01236682f, 
    -0.01983873f, -0.00163471f, -0.02778984f, 0.00307477f, 0.03986904f, -0.00883528f, 0.03886506f, -0.04399903f, 
    -0.02287806f, 0.00369126f, 0.02778431f, 0.00776936f, -0.14014784f, 0.08373541f, -0.06871499f, 0.20470269f, 
    0.09545185f, -0.01480279f, 0.14838324f, 0.07838869f, 0.07791112f, 0.01734605f, 0.00426986f, 0.04103296f, 
    -0.02411203f, -0.16344711f, 0.00987345f, 0.00597783f, -0.02255921f, 0.01031879f, 0.03964144f, -0.11756442f, 
    0.07716794f, 0.12858389f, 0.02079434f, 0.06219641f, -0.06644267f, -0.07218987f, -0.07886771f, -0.11593100f, 
    -0.08306973f, -0.03708532f, 0.04108000f, -0.06201748f, -0.03649661f, -0.01525705f, -0.03029100f, 0.00392827f, 
    0.00090846f, 0.03321058f, 0.03724302f, 0.06086652f, 0.10712928f, -0.05329498f, 0.07675780f, -0.05516388f, 
    -0.08735620f, -0.05397388f, -0.09558081f, 0.03350154f, -0.10075551f, -0.03692167f, 0.01699051f, -0.01734160f, 
    0.03432565f, -0.03363477f, 0.05563470f, 0.01304734f, 0.00788360f, 0.01198513f, 0.03925804f, 0.02795252f, 
    0.07733240f, -0.11697455f, 0.06744932f, -0.01460547f, -0.00267688f, -0.02724828f, -0.06328975f, 0.02253834f, 
    -0.02811534f, -0.00853543f, -0.03713086f, 0.01734742f, 0.00797143f, -0.01020142f, 0.03923197f, 0.00962703f, 
    0.03646358f, 0.05036818f, 0.03879284f, -0.01267517f, -0.08077107f, -0.06551070f, -0.03208047f, -0.00399427f, 
    -0.06938569f, -0.06236219f, -0.05969443f, -0.04582463f, 0.01925479f, 0.02587126f, -0.04567901f, 0.02973950f, 
    -0.03591772f, 0.09513989f, 0.03064192f, -0.05352565f, 0.07301234f, -0.10073459f, -0.00356560f, 0.03074349f, 
    -0.19825318f, 0.20389725f, -0.05300611f, -0.11646563f, -0.14632261f, -0.05238712f, -0.00523808f, 0.05553827f, 
    0.03635054f, -0.04194465f, 0.00434649f, -0.10009509f, -0.00388436f, -0.02812072f, -0.05030727f, -0.02883396f, 
    0.01373918f, 0.01566806f, 0.04766485f, 0.07336832f, -0.03146403f, -0.27334526f, -0.36947119f, -0.02436857f, 
    0.04193413f, -0.06139613f, 0.13575351f, -0.05325633f, 0.01659171f, -0.10171770f, -0.01220891f, 0.11738215f, 
    -0.04773165f, -0.03080897f, 0.02985617f, -0.03484181f, -0.02881729f, 0.07720470f, 0.05836112f, -0.07643144f, 
    -0.02022390f, -0.06984624f, -0.08985642f, 0.01286225f, -0.15203674f, -0.08379216f, -0.05383950f, -0.03076380f, 
    -0.02843213f, 0.03265436f, -0.09746686f, 0.00599295f, 0.02667092f, 0.13068110f, -0.03606337f, -0.00079853f, 
    -0.04736299f, -0.05982666f, 0.00717208f, -0.01339964f, 0.06587474f, 0.09390770f, 0.04757862f, 0.11004592f, 
    0.01575717f, -0.09220937f, -0.08617165f, -0.07404220f, -0.09868387f, -0.02614446f, -0.06388475f, -0.03667681f, 
    0.01986564f, -0.04680622f, -0.00371454f, -0.00413745f, 0.06216734f, 0.06623226f, 0.07202764f, 0.03944633f, 
    -0.02865406f, 0.06430791f, 0.03434607f, 0.04128924f, -0.06647466f, -0.00082944f, 0.00442147f, -0.04299470f, 
    -0.01064657f, 0.02118801f, -0.04113105f, 0.03198972f, 0.09740705f, 0.09057309f, -0.01353918f, 0.04579737f, 
    -0.07562806f, -0.00177820f, -0.00117746f, 0.03999098f, 0.08350270f, 0.30716524f, -0.14760816f, -0.16224775f, 
    -0.02592476f, -0.07109726f, 0.08720863f, 0.04849386f, 0.01831749f, 0.03826868f, 0.00188836f, -0.04875924f, 
    -0.06147389f, -0.02024356f, -0.06381310f, -0.02260333f, 0.02993480f, -0.01016101f, 0.09260993f, 0.00262965f, 
    0.11846322f, -0.05428409f, -0.23308286f, 0.09689493f, 0.09513199f, 0.00564624f, 0.04861240f, -0.01905557f, 
    0.00092163f, 0.00523194f, -0.02422941f, 0.02220581f, 0.00097693f, -0.08274606f, 0.01125366f, -0.02692324f, 
    0.03595750f, 0.09757607f, 0.00394003f, -0.03677567f, -0.25908697f, 0.29525176f, 0.11020773f, 0.04860697f, 
    -0.05372275f, -0.03149768f, -0.03073712f, -0.08695565f, 0.02836613f, -0.07550022f, -0.00850973f, 0.02049916f, 
    -0.09440072f, 0.05885237f, -0.03962133f, -0.01695944f, 0.00607925f, -0.10250563f, 0.06257357f, 0.01338428f, 
    0.10206866f, -0.06903383f, 0.08430637f, 0.00621183f, -0.01969139f, 0.02950864f, -0.06835333f, -0.02439689f, 
    -0.01113963f, -0.04816350f, -0.07568905f, 0.00069349f, 0.00569092f, 0.02490450f, 0.07225384f, 0.03179592f, 
    0.01351004f, -0.01877885f, -0.02444986f, 0.00067187f, -0.08529159f, 0.03054783f, -0.10513812f, 0.03928130f, 
    0.00419863f, -0.09564312f, -0.08941852f, 0.06904430f, -0.00754234f, 0.03203954f, -0.14210036f, -0.06158751f, 
    0.00110403f, 0.02560452f, 0.02338944f, -0.02185098f, 0.02596663f, 0.05192787f, -0.01494988f, -0.02339896f, 
    0.17093304f, 0.02103953f, -0.05971567f, 0.00381069f, 0.10109320f, 0.00171046f, 0.06928537f, -0.04059159f, 
    0.05628646f, 0.08747960f, 0.01919315f, 0.02235823f, -0.09798589f, 0.01292302f, -0.01157589f, -0.00707670f, 
    0.00417990f, -0.01131894f, 0.04331730f, 0.03713564f, -0.22938812f, 0.11408981f, -0.01117716f, 0.19592248f, 
    0.23320746f, 0.14982302f, 0.11396354f, 0.00897654f, -0.02956169f, -0.00120408f, -0.04019186f, -0.03654353f, 
    0.01291763f, -0.09375852f, -0.02162191f, -0.01693859f, 0.01661471f, -0.00861802f, 0.04889798f, -0.06021648f, 
    0.11137531f, -0.41375399f, -0.16218381f, 0.05796855f, 0.15859368f, 0.00860604f, 0.06532825f, 0.04992629f, 
    0.00873142f, -0.08031698f, 0.06349304f, -0.03059896f, -0.03292211f, -0.06011085f, -0.04689290f, -0.00975611f, 
    0.00338542f, 0.03737319f, -0.04030008f, -0.02918490f, 0.12856640f, 0.07439433f, 0.02527181f, 0.01115728f, 
    -0.04634008f, -0.02054670f, -0.00735875f, -0.05487410f, -0.07677130f, -0.01883298f, -0.01006657f, -0.00055979f, 
    0.05421546f, -0.00612232f, 0.05304235f, 0.01916879f, -0.04799269f, 0.01168962f, -0.01410950f, 0.02245199f, 
    -0.24649093f, 0.24959348f, -0.00912526f, 0.06592938f, 0.03888695f, 0.03907310f, 0.04096265f, 0.02310493f, 
    0.04144459f, -0.04198756f, -0.03929944f, -0.01583622f, -0.00777561f, 0.02413813f, -0.05271472f, 0.01287291f, 
    0.01019211f, -0.04754015f, 0.00798545f, 0.01151853f, -0.02719017f, -0.07270895f, 0.03746924f, 0.05432443f, 
    -0.05283378f, -0.09840347f, -0.05961205f, 0.08400109f, -0.06266540f, 0.04116908f, -0.01680581f, 0.06518884f, 
    -0.01520415f, 0.02668088f, 0.04357177f, -0.00546726f, 0.04550688f, 0.05254475f, -0.03837160f, 0.02308473f, 
    -0.22640191f, -0.57071179f, -0.14642525f, 0.01550365f, -0.13471299f, 0.02178742f, -0.03294872f, 0.09279701f, 
    0.02817165f, -0.13560417f, 0.00940908f, -0.06950939f, -0.04923955f, -0.03309609f, -0.01539796f, -0.05456241f, 
    0.02330635f, 0.06982709f, -0.06337453f, -0.03939658f, -0.01654173f, 0.20819350f, 0.07571862f, 0.14072824f, 
    0.03985298f, 0.10060475f, -0.01287008f, -0.00184611f, 0.06945172f, -0.01961923f, 0.10042711f, -0.00482102f, 
    -0.00717625f, -0.02119154f, 0.04318104f, -0.08805302f, 0.04978672f, -0.00599825f, 0.05253645f, -0.09362834f, 
    0.04424253f, 0.10028341f, -0.05033148f, 0.02003691f, 0.05102504f, -0.04633057f, -0.08161958f, -0.00132062f, 
    0.04425551f, 0.01152157f, -0.03046542f, -0.03472992f, 0.02305117f, -0.02467992f, 0.06940877f, -0.03378827f, 
    0.00164943f, 0.04658610f, -0.02868851f, 0.02533412f, -0.24248357f, 0.10128085f, 0.03365867f, -0.09075376f, 
    -0.08237289f, -0.04825294f, -0.06956507f, 0.00880097f, 0.04437637f, -0.04111775f, 0.01592019f, -0.02813562f, 
    -0.04192060f, -0.01076641f, -0.00825440f, -0.01253881f, 0.00465175f, -0.01945702f, 0.06047456f, 0.02472319f, 
    0.07221889f, -0.22130792f, 0.06253463f, -0.01748808f, 0.02712746f, -0.06588849f, 0.04599569f, 0.02888886f, 
    0.00199794f, 0.10781483f, 0.02354756f, 0.03799569f, -0.01116429f, 0.03537562f, -0.05012404f, -0.04134117f, 
    -0.00803766f, -0.04200981f, 0.02805601f, 0.03904951f, 0.09432103f, 0.17177480f, 0.06463449f, 0.09168443f, 
    -0.03102494f, -0.05693029f, 0.05242740f, -0.00480289f, -0.03019035f, 0.02920323f, -0.00973046f, -0.01511762f, 
    -0.07242513f, -0.08144140f, -0.06874748f, 0.00740860f, 0.02061021f, 0.07337901f, -0.01275032f, 0.01476237f, 
    -0.01601530f, -0.17790613f, -0.06356850f, -0.05873810f, -0.09552345f, -0.05267289f, 0.00187758f, 0.01923178f, 
    -0.02772112f, -0.03643350f, -0.00238539f, 0.01295476f, -0.05064705f, -0.00148481f, -0.00761280f, 0.00273791f, 
    0.03216250f, -0.05071388f, 0.01979411f, -0.02282946f, -0.57825053f, -0.00469345f, -0.10229880f, 0.07465044f, 
    0.01244165f, 0.01578786f, 0.03302484f, 0.05104313f, -0.01851469f, -0.06518927f, 0.00277098f, -0.03260846f, 
    0.00457491f, 0.06589641f, -0.00244046f, 0.07061458f, -0.04212179f, -0.00321247f, -0.09617168f, 0.05080101f, 
    -0.20265539f, 0.01554775f, 0.00903613f, 0.01662691f, 0.01466724f, -0.04991006f, -0.05349152f, 0.00442629f, 
    0.03243772f, 0.01844787f, -0.02343417f, -0.00578014f, 0.03916454f, 0.04790790f, -0.01749447f, -0.00650800f, 
    0.03622363f, -0.00547904f, 0.00362420f, 0.05424578f, -0.10771225f, 0.07175661f, -0.00053726f, 0.06053031f, 
    0.01215686f, -0.04245906f, -0.16408181f, 0.05620321f, -0.00338629f, 0.03834025f, -0.01305158f, 0.07632469f, 
    -0.07309737f, 0.02474056f, -0.04962940f, 0.01398317f, -0.03488090f, 0.01129235f, 0.13724460f, 0.00033705f, 
    -0.26441363f, 0.06188619f, 0.04276258f, -0.01455944f, -0.05686712f, 0.03748643f, -0.05765867f, 0.01844233f, 
    0.02082838f, -0.11022797f, -0.00848441f, -0.05444893f, -0.08017803f, 0.01073142f, 0.01372483f, 0.03864250f, 
    0.05439074f, -0.07600982f, -0.02854488f, -0.05341638f, 0.08433817f, -0.19061163f, 0.06670572f, -0.00964028f, 
    -0.04214224f, -0.03524173f, -0.08337997f, 0.04157548f, -0.05962381f, -0.03241981f, -0.03207589f, 0.07418846f, 
    -0.08188950f, -0.02563314f, 0.04598127f, 0.03025705f, 0.04172360f, 0.00924215f, -0.02619395f, -0.00843748f, 
    0.28056857f, 0.23557311f, 0.02883978f, 0.00676034f, 0.04851466f, 0.01754080f, 0.01029236f, -0.03201855f, 
    0.05585830f, 0.02951816f, -0.03153215f, 0.00325079f, 0.00466859f, -0.00218020f, -0.09239220f, -0.02342598f, 
    0.06903662f, -0.06315632f, 0.10532852f, 0.07856207f, -0.00391998f, 0.05588992f, -0.12852909f, -0.03051271f, 
    -0.03664651f, -0.02348246f, 0.03441055f, 0.00626228f, 0.01004226f, -0.04210273f, -0.00869413f, 0.05097498f, 
    -0.01244970f, 0.01049615f, -0.01208443f, 0.01062963f, -0.04252193f, -0.00566017f, -0.03775820f, 0.01536226f, 
    -0.14322865f, -0.50778306f, -0.27510160f, 0.14062999f, 0.13373315f, -0.03315675f, 0.04251600f, 0.00195635f, 
    -0.04566452f, -0.09518099f, 0.03377894f, -0.00068788f, -0.04786685f, 0.01239632f, 0.00382014f, -0.04351193f, 
    -0.10707504f, -0.02453715f, -0.05823148f, -0.00203713f, 0.11496834f, -0.00761976f, 0.08488525f, 0.04091686f, 
    -0.00639192f, 0.01379337f, -0.08837444f, -0.05190423f, 0.01372498f, -0.04719818f, -0.06003601f, -0.02356228f, 
    0.02046190f, 0.00182992f, 0.03394552f, 0.05728767f, 0.02340138f, -0.00030983f, 0.03049434f, -0.04428816f, 
    -0.03618035f, -0.04671257f, 0.07595433f, 0.01318503f, -0.05638610f, 0.01538986f, -0.02070316f, 0.01454692f, 
    -0.02026515f, -0.00674539f, -0.02531934f, 0.03454835f, -0.00501342f, -0.03595503f, 0.02617565f, -0.01913607f, 
    0.09468050f, 0.02972469f, 0.03183761f, 0.08046595f, -0.03857085f, -0.08556575f, -0.09151746f, -0.04215336f, 
    -0.20270213f, 0.01877765f, -0.04600096f, 0.01589603f, -0.05314707f, -0.01807860f, -0.07154276f, 0.01935280f, 
    0.06242663f, -0.03402315f, -0.00214492f, 0.04007609f, -0.03390976f, 0.00308276f, -0.01935096f, 0.05832950f, 
    0.02807271f, -0.19314513f, -0.15913469f, 0.04093926f, -0.04959226f, -0.09758866f, -0.08250050f, -0.00274400f, 
    0.04465774f, -0.04611010f, -0.04236354f, 0.00101575f, 0.01525323f, -0.02199897f, -0.02185407f, -0.01755981f, 
    -0.03125877f, 0.06325892f, -0.04289543f, -0.02506876f, -0.04233567f, -0.04716894f, 0.08066753f, -0.10380028f, 
    -0.12424255f, -0.00889456f, -0.11678527f, -0.02742814f, -0.07204472f, -0.14729103f, 0.05992385f, 0.03997734f, 
    0.04679400f, 0.03379960f, -0.01557231f, -0.03664551f, 0.03015074f, -0.08837944f, -0.03143102f, 0.02287380f, 
    0.21233714f, -0.09989956f, -0.09639914f, 0.07798138f, -0.00715893f, -0.00735238f, 0.00164209f, -0.07944631f, 
    0.00645758f, -0.03508837f, 0.00594620f, -0.03672690f, 0.03727680f, 0.05246548f, 0.01331803f, 0.00991159f, 
    0.04478871f, -0.00720337f, -0.01935754f, 0.02648335f, 0.19222943f, -0.11063731f, -0.26590952f, 0.13382052f, 
    0.06145767f, 0.02451636f, 0.01419769f, -0.03294750f, 0.01631522f, -0.01932781f, -0.00426989f, -0.02613800f, 
    -0.01668227f, 0.01652323f, -0.02107232f, 0.03853402f, 0.03981085f, 0.00942664f, 0.04143355f, -0.02782658f, 
    0.03889987f, 0.05953648f, 0.08185289f, 0.11637107f, -0.01230805f, 0.00305864f, -0.03707452f, -0.04063972f, 
    0.08141701f, -0.01812261f, 0.00314587f, -0.00776763f, 0.03376503f, 0.01074367f, -0.06506004f, -0.06929045f, 
    -0.00229214f, 0.02311814f, 0.05378209f, 0.02915087f, -0.11035200f, 0.10404637f, 0.08100279f, -0.00513639f, 
    0.02945420f, -0.05027762f, 0.02141919f, -0.00454064f, 0.03693448f, 0.00474118f, -0.02732060f, 0.03275881f, 
    -0.03168206f, 0.04835509f, -0.05301854f, 0.02701497f, 0.02661662f, -0.01139153f, 0.02864466f, 0.02541005f, 
    -0.09364986f, -0.41063741f, -0.40012026f, 0.03463900f, 0.13646537f, -0.11333736f, -0.02863079f, -0.00563390f, 
    -0.01027374f, -0.02821904f, -0.04244967f, -0.05395439f, -0.02497119f, 0.11966141f, 0.03004872f, 0.05461157f, 
    0.00252419f, 0.03588929f, -0.01522299f, -0.01214825f, -0.21203256f, 0.33611998f, 0.12181457f, 0.12450951f, 
    0.04879057f, 0.04620729f, 0.01211301f, -0.00236076f, -0.07271502f, -0.02584412f, 0.00558131f, -0.07754974f, 
    -0.04848632f, -0.00042788f, -0.05780985f, 0.00033680f, 0.06942060f, 0.08488033f, 0.04618144f, 0.03709927f, 
    -0.03465661f, 0.07979330f, 0.09364758f, 0.09913149f, 0.05537659f, 0.03224122f, 0.12593909f, -0.02055792f, 
    -0.04648181f, 0.04920045f, 0.07638238f, 0.05464835f, -0.14484890f, 0.02577263f, -0.04990094f, 0.06600868f, 
    0.02579937f, 0.06733105f, 0.06530827f, 0.00207204f, 0.24060971f, 0.09712930f, -0.12735268f, -0.00184920f, 
    0.06241918f, 0.02880338f, -0.02206356f, 0.03007518f, -0.00816966f, -0.05809131f, -0.05392336f, -0.06104865f, 
    -0.05160109f, 0.08712856f, -0.00606605f, -0.03590199f, 0.05320179f, 0.07095117f, -0.02251732f, -0.01224839f, 
    0.03130804f, -0.15360321f, 0.09413183f, -0.10331489f, -0.04492376f, -0.03154602f, -0.13868271f, -0.06028999f, 
    -0.00960373f, -0.00648731f, -0.00735049f, -0.06754032f, 0.03339434f, -0.03006911f, -0.00077635f, -0.00448978f, 
    0.03753856f, -0.02228605f, -0.00979924f, 0.05844989f, 0.02193956f, 0.00073226f, 0.09699742f, 0.06427976f, 
    0.06388497f, 0.03059245f, -0.04224271f, -0.06454625f, 0.02977522f, 0.02271335f, 0.08682626f, 0.08314113f, 
    0.05511078f, -0.05987723f, 0.00145230f, -0.04798197f, 0.03300340f, 0.00558937f, 0.04605822f, -0.09191419f, 
    0.26871791f, 0.28136131f, 0.04923307f, 0.06183721f, 0.01376181f, 0.06458179f, 0.05440334f, 0.04729012f, 
    -0.02284576f, 0.01197509f, -0.00166429f, -0.02949861f, -0.02034233f, -0.02471532f, -0.05703861f, 0.05542477f, 
    -0.02573190f, 0.11165590f, 0.08952074f, 0.07973188f, -0.07065348f, -0.08280960f, -0.01551160f, -0.06049369f, 
    -0.07487320f, -0.02250811f, -0.08953765f, 0.09599818f, -0.00543821f, -0.00207674f, -0.01285710f, 0.00847084f, 
    -0.01314374f, -0.03622289f, -0.03497313f, 0.04611550f, -0.04638558f, 0.05628223f, 0.05317015f, 0.02227757f, 
    0.04361524f, 0.02928480f, -0.20056905f, 0.10179728f, 0.01113659f, -0.00040546f, -0.02975760f, -0.01141376f, 
    0.10099421f, -0.04877210f, -0.05676493f, -0.04303083f, -0.04176082f, -0.03419992f, 0.03694810f, -0.01962262f, 
    -0.02952068f, 0.02880399f, -0.07667514f, -0.04060965f, 0.14394113f, -0.00496695f, -0.00221600f, 0.10793796f, 
    -0.00654608f, -0.03507422f, 0.05504123f, 0.00722607f, -0.07754303f, 0.03724483f, 0.03995342f, -0.04149522f, 
    -0.01267109f, -0.07215679f, 0.05333235f, -0.03954205f, 0.03464124f, -0.11121389f, 0.05131413f, -0.05787515f, 
    0.09880909f, 0.06659134f, -0.12168691f, 0.00615754f, -0.12862004f, -0.06158474f, -0.00798063f, -0.00778297f, 
    0.04072867f, -0.07525127f, -0.04560298f, 0.00184116f, -0.01483771f, -0.03660142f, 0.06447315f, -0.00311782f, 
    -0.09966417f, 0.04451488f, -0.01638641f, -0.05495846f, -0.20146964f, 0.17596030f, 0.06293053f, 0.04400469f, 
    0.10139750f, 0.11948846f, 0.08972631f, -0.03429962f, 0.05518566f, 0.03510750f, -0.00859037f, 0.02410074f, 
    -0.05688120f, -0.00176811f, 0.00580079f, -0.00970437f, 0.02860729f, -0.09340599f, 0.04355611f, -0.04711708f, 
    0.01890439f, -0.06781391f, 0.01210277f, 0.22270206f, 0.18792838f, 0.00768059f, 0.07122094f, 0.04437814f, 
    -0.03101420f, -0.03724968f, -0.05590854f, 0.00529053f, -0.02907753f, -0.08124011f, -0.03117196f, -0.01010274f, 
    -0.02890560f, -0.04404056f, 0.02680417f, -0.12811930f, 0.12149268f, 0.00224682f, -0.08261405f, 0.02101656f, 
    0.01617226f, -0.09602814f, -0.08052302f, 0.06575414f, 0.02302954f, -0.05107316f, -0.10354570f, -0.02123980f, 
    -0.00314175f, -0.01234873f, 0.06939817f, -0.08891946f, -0.03099250f, 0.10249458f, -0.05213084f, 0.01039714f, 
    -0.37417907f, 0.16931039f, -0.02728091f, -0.01722559f, 0.06923597f, 0.00205175f, 0.03154135f, -0.03350367f, 
    0.08508431f, -0.02172739f, -0.00490198f, -0.00506042f, -0.06112517f, 0.03638740f, -0.03273391f, -0.10354780f, 
    -0.03914497f, -0.12592563f, 0.10253494f, 0.08421738f, 0.07568270f, 0.08150372f, 0.03138817f, 0.03672915f, 
    0.04876399f, -0.02841707f, 0.06178873f, 0.04682367f, -0.02336745f, 0.04348116f, -0.03831246f, -0.02183586f, 
    -0.01397121f, -0.01772850f, 0.01315078f, -0.01610767f, 0.01204917f, 0.05594599f, 0.01513880f, 0.02435339f, 
    0.01482139f, -0.13790689f, -0.23669375f, 0.02646797f, 0.04753284f, -0.08519769f, -0.07290146f, -0.01750548f, 
    0.04786279f, 0.00426506f, -0.08743397f, -0.01919822f, -0.03687735f, 0.02628908f, 0.05367849f, -0.04309700f, 
    -0.00234629f, -0.02642366f, -0.00574742f, 0.01122450f, -0.22249635f, -0.30962479f, -0.09491811f, -0.16607131f, 
    -0.09376982f, -0.12347185f, -0.09126373f, -0.04200031f, 0.03005340f, -0.02856139f, -0.03411685f, 0.00084572f, 
    0.04683726f, 0.01945188f, 0.03531557f, 0.05204698f, -0.01768384f, -0.05112120f, -0.02392166f, 0.03253074f, 
    -0.42595720f, 0.11183716f, 0.06777404f, 0.15618552f, 0.03801945f, 0.00998768f, -0.00853016f, 0.03373726f, 
    0.02759794f, 0.01814544f, -0.02997056f, -0.00181063f, 0.01344887f, 0.01914159f, 0.05348047f, -0.00566129f, 
    -0.01371916f, 0.02352107f, 0.05329076f, -0.00224209f, -0.35451594f, -0.29829547f, 0.17475131f, 0.07002723f, 
    0.02237452f, -0.01950472f, -0.03991610f, -0.02911737f, -0.09903037f, 0.02615980f, 0.00449579f, -0.05637433f, 
    0.00355633f, -0.02785566f, 0.04584042f, -0.02597314f, -0.10807062f, 0.01250739f, -0.03798310f, -0.03592557f, 
    -0.07428133f, 0.08243869f, -0.05917883f, 0.14020748f, 0.05284770f, 0.09904330f, 0.05327736f, -0.05895641f, 
    0.10696097f, 0.11920676f, 0.02764140f, 0.08839294f, -0.02332075f, -0.04006147f, -0.06474169f, -0.08334980f, 
    0.02252704f, -0.04834181f, 0.07195338f, 0.02300776f, -0.18894507f, 0.08470992f, -0.13960437f, -0.01651890f, 
    0.16628614f, 0.04481614f, 0.03245878f, 0.01483207f, 0.00475823f, 0.05975580f, -0.00938115f, -0.00805466f, 
    0.05219271f, 0.01097837f, -0.09338477f, -0.02309845f, 0.01654389f, 0.01511058f, 0.00937867f, -0.05040293f, 
    -0.37481180f, -0.02072845f, 0.01815282f, 0.02853229f, 0.14062868f, 0.01703522f, 0.03588569f, -0.02066371f, 
    0.07484981f, 0.07756451f, -0.03788387f, -0.04136574f, 0.00391089f, 0.06223638f, -0.00945404f, 0.00471209f, 
    0.06647535f, 0.02895549f, 0.04003578f, -0.06753676f, -0.26853871f, 0.08874174f, 0.10016528f, -0.11442272f, 
    -0.07231955f, -0.07586588f, 0.13170485f, 0.04562675f, -0.02464050f, 0.01072782f, 0.04703783f, 0.02747348f, 
    0.07559221f, -0.00827300f, -0.02861454f, 0.01250722f, -0.01150825f, -0.02409147f, -0.05269122f, 0.04233278f, 
    0.10111674f, -0.16391097f, -0.14127412f, 0.06406654f, 0.05949108f, 0.06195433f, -0.01209210f, 0.12786092f, 
    -0.01173510f, -0.02423033f, 0.01418730f, -0.03126193f, 0.07561178f, 0.05273845f, -0.03272006f, -0.07211797f, 
    0.04395945f, -0.10358815f, 0.07523002f, -0.00805236f, -0.18739137f, 0.09534649f, 0.13934442f, -0.21956933f, 
    -0.06908658f, 0.13387823f, -0.02671026f, -0.03677770f, -0.05591521f, 0.04330438f, 0.06773199f, -0.06525163f, 
    -0.10287742f, -0.11555371f, -0.07671634f, 0.04934182f, -0.04045350f, -0.13303091f, -0.05978772f, -0.05736844f, 
    0.13133740f, -0.07888658f, -0.00512192f, 0.03527419f, -0.06273573f, -0.00969857f, 0.02796949f, 0.04440679f, 
    0.00394460f, 0.01707352f, 0.02048315f, -0.03271864f, -0.04395002f, 0.02209472f, 0.01449761f, -0.02869148f, 
    -0.01845203f, -0.00759660f, -0.00932078f, -0.05058634f, 0.00180536f, -0.00646887f, -0.07995991f, 0.10904114f, 
    0.09725193f, 0.07702745f, 0.03907147f, 0.00313963f, 0.05977994f, -0.02071756f, 0.13504785f, 0.05076947f, 
    -0.00107600f, -0.06446686f, 0.02195700f, -0.03502808f, -0.04512275f, 0.03405820f, 0.04014683f, 0.03511149f, 
    -0.07517079f, 0.14093459f, 0.14212137f, -0.01133413f, -0.10849114f, 0.06009721f, -0.02781521f, -0.07647538f, 
    -0.06296218f, -0.15406451f, 0.03201050f, 0.09927683f, -0.01918715f, -0.04407390f, 0.03586879f, 0.02422226f, 
    -0.03952505f, -0.07293730f, -0.06529105f, -0.02116352f, 0.08378979f, -0.17748274f, -0.20408300f, 0.02751572f, 
    -0.15970868f, -0.00402252f, 0.02874173f, 0.04527020f, -0.04099780f, -0.01333995f, 0.02226552f, 0.02339776f, 
    0.10540920f, -0.06023154f, -0.17736700f, 0.06827872f, -0.03902655f, -0.07813242f, -0.00670694f, 0.11190865f, 
    -0.22458966f, -0.09198333f, 0.17460647f, 0.14597639f, -0.05148871f, -0.07429840f, 0.04158762f, -0.06010572f, 
    0.01679268f, 0.00696540f, 0.01564906f, -0.02748031f, -0.02606566f, -0.06517420f, 0.05894808f, -0.03381566f, 
    -0.02739536f, -0.03807300f, -0.01623923f, 0.00598473f, -0.19029722f, 0.10761012f, 0.02114530f, -0.05554070f, 
    -0.05863629f, 0.05228738f, -0.06404386f, 0.00894716f, -0.02931997f, -0.01648106f, -0.01180467f, 0.04346362f, 
    -0.03617249f, 0.00580973f, 0.04503859f, 0.00407804f, 0.03312057f, 0.01000083f, 0.02272450f, -0.07436378f, 
    -0.02635989f, -0.07340667f, -0.02526951f, -0.04442305f, 0.12022905f, -0.00686309f, 0.01209014f, -0.01206483f, 
    0.06678363f, 0.02830643f, -0.01740376f, -0.03688002f, -0.04481085f, 0.05708003f, -0.05640189f, -0.04470557f, 
    0.00666075f, -0.07723297f, -0.00124848f, -0.12145566f, 0.03098113f, -0.15740654f, -0.09534953f, 0.07199299f, 
    0.14607437f, 0.04325608f, 0.06046589f, 0.06386107f, 0.04485418f, 0.09820712f, 0.03395537f, -0.02758458f, 
    -0.02095935f, -0.03248340f, -0.00550118f, 0.01374918f, -0.06102785f, -0.02308458f, 0.07846833f, 0.00134838f, 
    0.14621583f, -0.00611411f, 0.00475436f, -0.01303887f, -0.06607062f, -0.09193467f, -0.01450714f, 0.06266829f, 
    0.05344978f, 0.02721941f, 0.02346076f, -0.09163433f, 0.06171760f, -0.06291391f, -0.01498331f, -0.02218153f, 
    -0.02290616f, 0.03542527f, 0.04354731f, 0.06196038f, -0.16804354f, -0.18606864f, 0.05894081f, 0.19304334f, 
    -0.01871902f, -0.05179714f, -0.01479258f, 0.11570071f, -0.07624219f, 0.00904628f, 0.06494927f, 0.06306282f, 
    -0.12419146f, -0.07886294f, 0.09061255f, 0.05734539f, -0.06295920f, 0.01479617f, 0.03595337f, 0.12335587f, 
    -0.01866354f, -0.26274377f, 0.08652516f, 0.13610952f, 0.00406315f, -0.18698722f, 0.02658623f, 0.00172312f, 
    -0.13188145f, 0.00434047f, 0.07419365f, 0.07835054f, -0.00055348f, -0.07648450f, -0.00631765f, -0.12046594f, 
    0.07581997f, -0.02518605f, 0.07690795f, 0.03300690f, 0.17765054f, 0.18082768f, -0.13444316f, 0.12946941f, 
    -0.10316404f, 0.00112015f, -0.00940412f, -0.02082505f, -0.01133365f, -0.05075713f, 0.07471466f, 0.03222733f, 
    0.00549830f, -0.04126207f, -0.01897794f, -0.01953377f, 0.00657941f, 0.00271812f, 0.03938256f, -0.02236302f, 
    -0.29180092f, 0.14918564f, 0.14434271f, 0.09255171f, 0.03189130f, -0.03005836f, -0.08435681f, 0.02149058f, 
    -0.00666196f, 0.00741353f, -0.00841800f, 0.00686882f, 0.00802024f, -0.00986287f, 0.03133524f, 0.05278201f, 
    -0.05405706f, -0.12379074f, -0.02692469f, -0.08687307f, -0.31337273f, 0.15844396f, 0.10833387f, 0.15517184f, 
    -0.06761104f, -0.02064361f, -0.07535040f, -0.06207276f, 0.05342008f, -0.08545306f, -0.06341836f, -0.05391880f, 
    0.01094724f, 0.08329713f, 0.09301368f, -0.02237652f, -0.03632493f, 0.03810221f, 0.06940719f, 0.06766224f, 
    -0.18575138f, 0.02241976f, -0.08593822f, -0.04984204f, 0.15675440f, 0.06415613f, -0.05080232f, -0.19416100f, 
    0.13290736f, 0.01086937f, 0.06675510f, -0.06846061f, 0.07957239f, 0.00240368f, -0.03291896f, -0.03732138f, 
    0.05053259f, -0.08084057f, 0.02577076f, -0.01776966f, -0.14186168f, 0.03144117f, 0.00224101f, -0.23373656f, 
    -0.06518689f, -0.06444610f, 0.04325606f, -0.02221263f, -0.06733082f, -0.01202834f, -0.07512833f, 0.03128194f, 
    0.02114830f, -0.03764265f, 0.03304709f, -0.12659049f, -0.00497765f, -0.05526759f, -0.06197620f, 0.02920351f, 
    0.19758330f, -0.04677836f, -0.01440935f, -0.16552186f, 0.01239836f, 0.02452958f, 0.00583873f, -0.08493542f, 
    0.09092154f, 0.03633691f, 0.05857047f, -0.12379177f, 0.06395800f, -0.00168823f, 0.02065587f, -0.05227332f, 
    0.02978301f, 0.01370967f, 0.03776867f, 0.05384974f, 0.18966766f, 0.10605809f, -0.09323930f, -0.08402698f, 
    0.05051455f, -0.00567798f, 0.00908151f, 0.06853472f, 0.06304774f, -0.02572739f, -0.02990671f, -0.03893701f, 
    -0.01745993f, 0.04492366f, 0.00226231f, -0.00477874f, 0.01307493f, -0.03206743f, -0.02580038f, -0.02674181f, 
    0.29694599f, -0.01901812f, -0.17331867f, -0.13082871f, -0.26940134f, -0.02149227f, 0.00112399f, 0.02147303f, 
    -0.05646503f, -0.08242980f, -0.01162620f, -0.00000362f, 0.03143880f, 0.00696185f, 0.00191441f, -0.03161970f, 
    -0.00565684f, 0.01363834f, -0.02648447f, -0.03160927f, 0.01558866f, 0.14552951f, -0.09761098f, 0.23228680f, 
    -0.01503682f, 0.00622520f, 0.01260612f, -0.00868012f, 0.07591978f, -0.05837929f, 0.07621082f, -0.03108678f, 
    -0.04129434f, 0.00799937f, 0.05751004f, 0.00990374f, 0.01244352f, 0.01339050f, 0.02393431f, 0.10929500f, 
    0.22471203f, -0.17163637f, -0.03261151f, -0.11450864f, -0.00083825f, 0.04921726f, 0.02287402f, 0.02358687f, 
    -0.05129022f, 0.06650749f, -0.01192699f, 0.03561909f, 0.00358281f, -0.00605292f, 0.04626277f, 0.02880839f, 
    -0.06404879f, -0.05430187f, 0.01217875f, -0.05772179f, -0.41642410f, 0.10121532f, 0.02082590f, 0.08051956f, 
    -0.03083185f, -0.04383034f, 0.02708671f, 0.01714912f, 0.00256886f, 0.02215858f, 0.06488728f, -0.03197116f, 
    0.00590825f, 0.01578082f, 0.00372311f, -0.05139932f, 0.05327072f, -0.18766533f, 0.03503843f, -0.00814880f, 
    0.29753855f, -0.05530503f, -0.11700150f, 0.02731610f, 0.11939061f, 0.10572094f, 0.03586590f, 0.07110281f, 
    0.03366422f, -0.01391685f, -0.01512334f, -0.06508756f, 0.06443493f, 0.02259543f, 0.01712386f, -0.07476597f, 
    0.04614486f, 0.00899557f, -0.02782008f, 0.02908064f, -0.59607530f, 0.02127718f, 0.05296495f, 0.06013272f, 
    0.04619157f, 0.02389323f, -0.04474314f, -0.02318064f, 0.02319243f, 0.02024983f, -0.02629532f, -0.04968441f, 
    -0.04304353f, 0.06829930f, 0.03823311f, 0.03154857f, 0.04861426f, 0.07867803f, 0.03051787f, -0.06858444f, 
    -0.04258480f, 0.06737746f, -0.09507875f, -0.00879879f, 0.05624321f, 0.06329376f, 0.01897473f, 0.04214250f, 
    0.03243237f, -0.00357919f, -0.08553229f, 0.02155614f, -0.10357228f, 0.04307950f, -0.01950591f, -0.02145494f, 
    -0.00065672f, -0.17470773f, -0.03053273f, -0.05856210f, -0.10690320f, 0.15243730f, -0.13718873f, 0.03445906f, 
    0.02902493f, 0.06867919f, 0.01879133f, 0.03453165f, 0.05155054f, 0.03009776f, -0.03607145f, -0.02839819f, 
    0.02668714f, -0.00954907f, -0.04584492f, -0.00363721f, 0.05925973f, 0.06713039f, 0.06113505f, -0.15890437f, 
    -0.08858614f, 0.18036267f, 0.09740844f, -0.03086259f, -0.10900691f, 0.03318461f, 0.01030278f, 0.07104217f, 
    -0.09060910f, -0.02252421f, 0.01183884f, 0.09717876f, -0.06904224f, 0.08334179f, -0.01336665f, -0.06957594f, 
    0.07332163f, 0.01398948f, -0.04859275f, 0.00633768f, -0.25864941f, 0.17053416f, -0.00300674f, 0.04796785f, 
    -0.05384412f, 0.02970568f, -0.09685107f, -0.00473983f, -0.03259202f, -0.03764852f, -0.00702489f, 0.00056566f, 
    -0.02783218f, 0.09546627f, 0.02931524f, -0.03917440f, -0.03145980f, 0.15316913f, -0.01544852f, 0.00854096f, 
    0.06811460f, -0.26212490f, 0.09936532f, -0.01962342f, 0.04122678f, -0.16672271f, 0.04755475f, 0.05603937f, 
    -0.04322238f, -0.02680642f, 0.11412991f, 0.01875811f, 0.04986948f, -0.06456608f, -0.06475061f, 0.01393772f, 
    -0.00371080f, -0.07634468f, -0.02984964f, 0.03131145f, -0.19307661f, -0.02090722f, -0.03687690f, -0.05756470f, 
    0.04374349f, -0.02341544f, -0.02390269f, -0.03310194f, 0.05935497f, 0.05238364f, -0.03343774f, -0.04304865f, 
    -0.00406740f, 0.05480118f, -0.02013171f, -0.03542532f, 0.03455557f, 0.01175454f, 0.02996860f, -0.09226216f, 
    -0.45973319f, 0.00914407f, 0.12988873f, 0.09100761f, 0.12474361f, 0.09223581f, -0.01382861f, -0.07315961f, 
    0.04651080f, 0.06956914f, -0.04165998f, -0.07252385f, 0.09354076f, 0.07578927f, 0.04382004f, -0.03355636f, 
    0.13664295f, 0.05953596f, 0.09676865f, -0.12039021f, -0.59905666f, 0.08158086f, 0.07247889f, 0.12016208f, 
    0.09836984f, 0.06229758f, -0.08333076f, 0.06573341f, -0.12736502f, 0.12115403f, -0.01237742f, 0.04854382f, 
    0.07076117f, -0.00931351f, 0.03390509f, 0.06244936f, -0.07064844f, -0.03089124f, 0.08659256f, -0.06429113f, 
    -0.19207969f, 0.15050720f, 0.03708339f, -0.12529272f, 0.03695355f, -0.04514641f, -0.00616259f, -0.01300160f, 
    0.03132808f, 0.00269597f, 0.03838192f, 0.03683346f, -0.03047213f, -0.03065297f, -0.00743793f, 0.09510849f, 
    0.01114790f, -0.00702186f, -0.00193478f, 0.04425114f, 0.06802265f, 0.22227065f, -0.15432186f, -0.15288654f, 
    0.08069319f, 0.12271141f, -0.10249510f, 0.01994421f, 0.08331872f, -0.00498955f, -0.08143450f, 0.03501657f, 
    0.00268343f, 0.06494178f, 0.01387101f, 0.01801817f, -0.01517664f, -0.06163350f, -0.01868177f, -0.00010385f, 
    -0.17585452f, 0.10873881f, -0.02564748f, -0.01626356f, 0.00654131f, -0.03463124f, 0.06768242f, -0.02694160f, 
    0.00029798f, 0.03767072f, -0.02277522f, 0.02736681f, -0.01368741f, -0.00636619f, -0.04344412f, -0.06492466f, 
    0.05693695f, -0.00073592f, 0.02106608f, 0.00444569f, 0.07160775f, 0.09099999f, 0.12131829f, -0.00248370f, 
    0.05749973f, 0.02575899f, -0.00466657f, -0.09750037f, 0.05199829f, 0.03923955f, -0.02618606f, -0.00525926f, 
    0.07150391f, 0.04850769f, -0.09359743f, -0.06091050f, 0.03623955f, 0.02834508f, -0.00446299f, 0.05313487f, 
    0.03401561f, 0.18399353f, -0.14079832f, -0.27669868f, -0.18094447f, -0.08522888f, -0.04794787f, -0.08055237f, 
    -0.00478159f, -0.10844504f, 0.02510986f, 0.04171572f, -0.08312374f, 0.06858277f, 0.03417220f, 0.02093729f, 
    0.01250627f, -0.01399895f, -0.06436207f, -0.01663413f, 0.16594584f, 0.07463596f, 0.08392676f, -0.05882392f, 
    0.01952022f, 0.00968810f, -0.04220079f, 0.10533500f, 0.00309962f, 0.03015855f, 0.04653896f, -0.03452545f, 
    -0.03140976f, 0.03519762f, 0.03849975f, -0.04184989f, -0.03035599f, 0.05283423f, 0.00983140f, 0.01319744f, 
    0.03798896f, 0.08826042f, 0.11696685f, 0.00727780f, -0.05138265f, 0.04317505f, 0.04234984f, 0.08532565f, 
    -0.01118071f, 0.01549374f, 0.07273006f, -0.04160146f, 0.02312914f, -0.00018995f, -0.04949677f, 0.01681217f, 
    -0.02811151f, 0.03164233f, -0.06109756f, -0.00827423f, -0.18143949f, -0.14425746f, 0.01368286f, 0.03924716f, 
    -0.02379414f, 0.01965928f, -0.03871909f, -0.08994683f, -0.02058317f, 0.01775293f, 0.01325962f, 0.06533686f, 
    0.00822019f, 0.00587531f, 0.06720741f, -0.04366537f, -0.05240235f, 0.01536825f, 0.11157806f, -0.06530951f, 
    -0.04628370f, 0.16889015f, 0.07007363f, 0.16560051f, -0.10136601f, 0.08993721f, -0.00057251f, 0.01146220f, 
    -0.04583324f, -0.06377936f, 0.12259852f, 0.01635415f, -0.06884544f, 0.04725813f, -0.04183570f, -0.00515342f, 
    0.09448353f, 0.13043293f, 0.02904029f, 0.07076193f, -0.31195018f, -0.01765908f, -0.01801197f, -0.03194671f, 
    -0.13289329f, -0.01451709f, 0.00634014f, 0.08986014f, -0.04693128f, 0.00897023f, 0.00356024f, -0.06168037f, 
    0.03460183f, 0.03307308f, 0.02430875f, -0.04232305f, 0.07530937f, 0.10131457f, 0.02054575f, 0.06455388f, 
    -0.07735478f, -0.00697058f, -0.20692585f, -0.07160134f, 0.09246743f, -0.04548611f, 0.06183113f, 0.01732968f, 
    0.13381802f, -0.03184538f, 0.02216031f, -0.06007487f, 0.00536539f, 0.01616062f, 0.01279731f, 0.02349398f, 
    0.09664547f, -0.07194318f, -0.02751315f, 0.01291251f, 0.06518728f, 0.13291074f, -0.06958693f, -0.33161145f, 
    -0.14442779f, -0.03972821f, 0.00460069f, -0.07583652f, -0.04853530f, -0.04081302f, 0.02031007f, -0.02906995f, 
    -0.14746913f, 0.09313289f, -0.02621536f, -0.00996469f, -0.00864498f, 0.01534952f, -0.00759668f, -0.00896623f, 
    -0.04696834f, -0.08594702f, 0.19841494f, 0.01043337f, -0.14468041f, 0.03778569f, 0.13659963f, -0.02795524f, 
    -0.04840899f, -0.09180485f, 0.12430020f, -0.02412750f, -0.06387472f, -0.00146081f, 0.03530772f, -0.09082819f, 
    0.05504029f, -0.02422465f, 0.01191457f, 0.08061142f, -0.26990482f, -0.12585573f, 0.01595528f, 0.05921210f, 
    0.11734170f, 0.02895989f, 0.00875433f, 0.06339162f, 0.02645655f, 0.04433603f, -0.02563071f, -0.06137572f, 
    0.04385622f, 0.08106695f, 0.03392541f, 0.01275315f, 0.03925693f, -0.00017519f, 0.05484768f, -0.08506547f, 
    -0.07066853f, 0.00730778f, -0.08319397f, 0.05295947f, -0.17967778f, -0.09206843f, 0.00477359f, 0.02494895f, 
    -0.08096762f, -0.00696554f, -0.01147306f, -0.12491733f, 0.00255731f, 0.00416401f, 0.04363011f, -0.09929158f, 
    0.00210096f, 0.01956023f, -0.03717991f, -0.00297072f, 0.02861899f, -0.14093331f, -0.27173740f, 0.09013736f, 
    -0.08077947f, -0.03692628f, -0.03279979f, 0.03287330f, -0.05400287f, -0.15788125f, 0.04974699f, -0.00687094f, 
    0.00032755f, 0.03516046f, 0.05450142f, -0.07127605f, -0.10342082f, 0.08025720f, -0.13897072f, 0.01898247f, 
    -0.12141357f, 0.09098294f, 0.05251477f, 0.08126138f, 0.04948930f, 0.05519184f, -0.04723823f, -0.07068028f, 
    0.08979127f, 0.05006019f, 0.10328078f, 0.04323503f, -0.09689602f, -0.00604434f, 0.03623784f, 0.03126677f, 
    -0.07444323f, -0.01099928f, 0.07270798f, 0.16168620f, 0.12018273f, 0.02727127f, 0.07148356f, 0.04882909f, 
    -0.00579430f, -0.09620576f, -0.07281672f, 0.09296048f, -0.04854104f, -0.03773643f, -0.00243794f, 0.03676447f, 
    -0.10232165f, -0.01967453f, 0.01359249f, 0.02059226f, -0.02622500f, 0.06216879f, -0.00313563f, -0.01660093f, 
    -0.15642597f, -0.48725203f, -0.02971290f, 0.03944194f, 0.09327982f, -0.06820044f, 0.02624628f, -0.06564596f, 
    -0.16359106f, -0.02933440f, 0.03575977f, 0.06467602f, -0.05830806f, 0.00357766f, -0.01254352f, -0.02780678f, 
    -0.04958417f, -0.02968830f, -0.01067010f, -0.09108535f, -0.24627985f, -0.11541774f, -0.18302633f, 0.12444036f, 
    0.12827265f, 0.03888528f, -0.06385750f, 0.00714782f, 0.06799767f, -0.00988064f, 0.05184758f, -0.00865436f, 
    -0.00257478f, -0.11265773f, 0.02101479f, 0.05127056f, -0.03704371f, -0.03772942f, 0.05666585f, 0.03954392f, 
    0.06081777f, 0.16100879f, 0.05994294f, -0.10103510f, -0.00855374f, -0.16878942f, -0.05430698f, 0.08080089f, 
    -0.00751823f, 0.05134764f, 0.00030886f, 0.06897714f, -0.00443663f, -0.08187883f, 0.03741991f, 0.06719556f, 
    -0.07102434f, -0.06877566f, -0.00056104f, -0.01501808f, 0.11263452f, -0.07818942f, -0.08639903f, 0.05815358f, 
    -0.05429192f, -0.03201036f, -0.04336638f, 0.06981140f, -0.01236903f, 0.00964341f, 0.03202827f, -0.03018489f, 
    0.08219731f, 0.05283910f, -0.01405313f, 0.02402347f, 0.03842741f, 0.05904086f, 0.05172893f, 0.05186704f, 
    -0.12149663f, -0.07488691f, -0.04988929f, -0.02006708f, -0.05350126f, -0.02968690f, -0.05631276f, 0.00082103f, 
    0.12394392f, 0.03304312f, 0.00429681f, -0.09179702f, -0.06174967f, -0.01399725f, 0.06412709f, 0.04588206f, 
    0.07941077f, -0.09142932f, -0.03676314f, 0.00478247f, -0.01893873f, -0.13432480f, -0.11083474f, 0.09334584f, 
    -0.00021099f, -0.00952522f, 0.07599405f, -0.02800635f, 0.02535119f, 0.06371255f, -0.00231464f, -0.06825811f, 
    0.07436901f, -0.02528274f, -0.05365245f, 0.12348391f, 0.01726590f, -0.03656095f, 0.02514555f, -0.06123020f, 
    -0.15205155f, 0.10729285f, -0.19033061f, -0.09360807f, 0.01080943f, 0.06809864f, 0.04194786f, -0.01733535f, 
    0.01057843f, -0.11242966f, 0.04272349f, -0.01666564f, 0.04873791f, -0.04498957f, 0.05530068f, 0.03053392f, 
    0.05009624f, -0.09082627f, 0.04912523f, 0.01521945f, -0.01194695f, -0.01987989f, -0.02574686f, 0.07964010f, 
    0.19515672f, -0.10598312f, -0.11011320f, 0.08242007f, 0.10354729f, 0.10134609f, 0.02286536f, -0.19492260f, 
    0.03788891f, 0.03199660f, 0.11300986f, 0.04543614f, 0.19517876f, -0.03938660f, -0.11809444f, -0.05759907f, 
    -0.32544661f, -0.10098954f, -0.17735690f, 0.03367668f, 0.05000729f, 0.09011861f, -0.08176485f, 0.07179828f, 
    -0.09027189f, 0.12914225f, 0.09039752f, 0.09771818f, -0.04263693f, -0.00970900f, 0.06970344f, -0.00419259f, 
    -0.06230969f, 0.02120066f, -0.12121456f, 0.00458241f, -0.46407133f, -0.17595054f, -0.14725141f, -0.15940864f, 
    -0.02215540f, 0.10866462f, -0.01862853f, 0.01078842f, 0.02235399f, -0.07873535f, 0.00718715f, 0.06014000f, 
    -0.04071663f, 0.02809864f, 0.03446434f, 0.03742499f, 0.04316635f, 0.01833045f, -0.10015817f, 0.05029938f, 
    -0.27866855f, 0.05892027f, -0.24638028f, -0.17498067f, -0.06426731f, 0.10508068f, 0.01299916f, 0.04360330f, 
    -0.02325227f, -0.13813455f, -0.03913335f, 0.06853320f, -0.05125705f, -0.02113279f, 0.01253968f, 0.03190219f, 
    -0.07160153f, 0.01580871f, -0.00496931f, 0.02574951f, -0.23982112f, 0.00150097f, 0.06583725f, -0.01508955f, 
    -0.01608364f, -0.00958358f, -0.10440531f, 0.02146048f, -0.07884657f, -0.08233003f, 0.01297114f, 0.04087596f, 
    -0.10749787f, -0.09108150f, 0.02160459f, 0.03451811f, 0.08839299f, -0.00311511f, 0.06251907f, 0.00739343f, 
    -0.08096696f, 0.25346157f, 0.17033160f, -0.04227534f, -0.13116652f, -0.01645442f, -0.03342917f, 0.05484916f, 
    -0.11018452f, -0.03361696f, 0.07187604f, -0.03889500f, -0.04841607f, -0.04741971f, -0.07558967f, 0.05690099f, 
    -0.06660137f, 0.07211234f, -0.00016602f, 0.00618788f, -0.29428980f, -0.03126200f, 0.01054781f, 0.25338146f, 
    -0.00228599f, -0.04073562f, 0.12063726f, -0.06635227f, -0.01339432f, 0.01787250f, 0.06912503f, -0.05100591f, 
    0.05095704f, 0.02844583f, -0.00713072f, 0.01711437f, 0.01120178f, -0.02124930f, -0.04663077f, -0.15277162f, 
    0.01021175f, 0.17698121f, 0.04916997f, -0.08359987f, 0.09937862f, -0.08053437f, -0.09974796f, 0.03390851f, 
    -0.05736927f, 0.04248236f, 0.11991223f, 0.09516803f, -0.00731284f, 0.00767202f, 0.06678139f, -0.01449099f, 
    0.02356066f, -0.04333859f, 0.05454275f, -0.04253584f, -0.18905514f, -0.11140412f, -0.07512037f, -0.01488468f, 
    0.12306263f, 0.04828037f, 0.03852031f, -0.06889485f, -0.10236553f, 0.08398234f, 0.03066920f, 0.04159210f, 
    0.04536589f, 0.13001439f, -0.00857676f, 0.00492058f, 0.05189033f, 0.02922700f, -0.23526663f, 0.08645773f, 
    -0.20659296f, -0.06668234f, -0.00431481f, 0.07416880f, 0.04554905f, -0.02533916f, -0.03854854f, 0.07187845f, 
    0.01757420f, 0.00418624f, 0.05072700f, -0.12683648f, -0.10790168f, -0.01983440f, -0.00526844f, -0.08186064f, 
    -0.00937097f, 0.02115111f, -0.07157085f, -0.10537829f, -0.00232038f, 0.16437919f, 0.03681553f, 0.16403008f, 
    -0.19892843f, 0.13857232f, -0.12452324f, -0.09457298f, 0.09237392f, 0.15882608f, -0.08735383f, -0.03778684f, 
    -0.06427138f, 0.08718988f, -0.06656177f, 0.00047215f, -0.02807217f, -0.06911488f, 0.09285609f, 0.00943006f, 
    0.06590495f, -0.03395391f, -0.11255168f, 0.09165284f, 0.06292294f, 0.00628954f, -0.00414606f, -0.00110929f, 
    -0.05870906f, 0.02800725f, -0.08405584f, -0.05594911f, -0.04244380f, 0.05465100f, 0.09138998f, -0.02356553f, 
    0.04182813f, -0.03740507f, 0.09315930f, 0.07146699f, -0.10773704f, -0.20884733f, -0.10462803f, -0.03967966f, 
    -0.12167124f, 0.15377225f, -0.06157571f, 0.02273429f, 0.04302190f, -0.01498115f, 0.02540672f, 0.05780886f, 
    0.09436354f, 0.00750502f, -0.03689501f, 0.00810728f, -0.03472191f, -0.03168823f, -0.03329972f, -0.01808545f, 
    -0.14338450f, -0.18974192f, -0.09620599f, -0.04542300f, -0.04432107f, 0.05777343f, 0.03411539f, 0.01771081f, 
    0.02361250f, -0.06217007f, -0.00151255f, 0.01435402f, 0.05003855f, -0.03527762f, -0.04895653f, 0.05499439f, 
    -0.05407772f, 0.03194331f, -0.14024003f, 0.05468718f, -0.15354778f, 0.14269795f, 0.13036200f, -0.21107626f, 
    -0.01010032f, 0.06519230f, 0.16232851f, 0.01186881f, -0.09977476f, 0.00224023f, -0.05702800f, -0.00252859f, 
    -0.01714808f, -0.04786345f, -0.05598278f, -0.01296590f, 0.04089410f, -0.05324921f, 0.03202466f, -0.03501552f, 
    -0.01496164f, 0.02828684f, 0.10114935f, 0.14125814f, -0.16443199f, -0.00985247f, 0.01674815f, -0.06819901f, 
    0.03753871f, 0.03203113f, -0.06496362f, 0.03602199f, -0.01607081f, -0.00467458f, 0.04871410f, -0.05478176f, 
    -0.04187126f, -0.02023773f, 0.07097568f, -0.01319634f, 0.15307570f, 0.00940663f, -0.00957830f, 0.20174161f, 
    0.00058680f, -0.16737850f, -0.03445158f, -0.02205463f, 0.19242792f, -0.01713570f, -0.03865047f, -0.09005506f, 
    0.09496203f, 0.15079108f, 0.18020913f, -0.14827773f, 0.02142556f, -0.00430370f, -0.05683523f, -0.03668807f, 
    0.13089140f, 0.09980415f, 0.04522882f, 0.03516182f, 0.07416711f, -0.05124537f, -0.03232912f, -0.03277926f, 
    0.03352978f, 0.06588072f, -0.05105842f, -0.14021252f, 0.02079996f, 0.09136590f, 0.01651181f, 0.03690153f, 
    -0.05224839f, 0.01488141f, -0.00377725f, 0.07528711f, -0.04014993f, -0.16802976f, -0.03166144f, 0.01496342f, 
    -0.05223210f, -0.07547734f, 0.00216686f, 0.04514714f, 0.01863579f, 0.13502635f, 0.09701397f, -0.01949243f, 
    0.06604216f, 0.04866682f, -0.03292818f, -0.02410878f, -0.03561238f, -0.11001439f, 0.01835850f, 0.05311688f, 
    0.08069990f, -0.06051933f, -0.07547790f, -0.00859887f, -0.25192893f, 0.03770318f, -0.01199065f, -0.02268126f, 
    -0.05519155f, 0.02313314f, 0.01733482f, 0.08025049f, 0.05155650f, 0.02456268f, 0.02217945f, -0.04052220f, 
    -0.07750446f, 0.04483001f, 0.00465901f, -0.00862355f, -0.06364818f, 0.18639623f, -0.37956032f, -0.06160776f, 
    0.11614451f, 0.03311989f, 0.15284716f, -0.02616749f, -0.03082043f, 0.02704407f, -0.00315098f, 0.03363907f, 
    -0.03667929f, -0.02297977f, -0.01829693f, -0.01256023f, 0.09169038f, -0.05192271f, 0.08236173f, -0.09493376f, 
    0.16533716f, 0.01235805f, 0.20092568f, 0.19477794f, -0.02316153f, 0.01152223f, 0.14559872f, 0.15173779f, 
    0.05226727f, 0.04982719f, 0.00629783f, -0.02757073f, -0.07352836f, -0.02257020f, 0.01416870f, 0.03682540f, 
    0.00398205f, 0.06078271f, 0.05168924f, 0.04246094f, -0.07462525f, -0.11911479f, 0.04147353f, 0.01912269f, 
    -0.03832709f, -0.01691482f, -0.03158371f, 0.06671179f, -0.01370492f, -0.14978008f, -0.06225232f, -0.03446868f, 
    -0.05278043f, -0.05263405f, -0.17464080f, -0.05286950f, -0.01067745f, 0.13125440f, -0.02168681f, 0.13921307f, 
    -0.33493668f, -0.00357021f, -0.01616547f, -0.00394265f, -0.04525664f, 0.07289114f, 0.13207301f, -0.03364422f, 
    -0.09491761f, 0.05455152f, 0.00884539f, 0.06571397f, 0.02061791f, -0.02415427f, -0.01382667f, 0.01820236f, 
    0.00588680f, -0.05519640f, -0.03780656f, -0.04668216f, -0.12354476f, 0.03160559f, 0.09048850f, 0.09406490f, 
    -0.18718576f, 0.01168892f, -0.01260633f, -0.01140646f, -0.05027411f, 0.00004114f, 0.07831579f, -0.05395505f, 
    -0.04286014f, 0.01056362f, -0.10141380f, -0.03194930f, 0.02250913f, 0.05261329f, 0.07785941f, -0.03155738f, 
    -0.07792076f, -0.01340960f, 0.08469231f, 0.08614082f, 0.19640769f, -0.10654995f, -0.12343472f, 0.03885759f, 
    -0.07265217f, 0.04501041f, -0.02692469f, -0.06606423f, 0.02099029f, -0.09200212f, 0.03709674f, 0.00842263f, 
    0.02583301f, -0.09700287f, 0.01009543f, -0.00403948f, -0.02363447f, -0.08779415f, -0.21157978f, 0.12961012f, 
    0.05562005f, 0.02950393f, -0.06081644f, -0.08874939f, 0.02505696f, 0.13896210f, 0.01606529f, 0.08874393f, 
    0.11976051f, 0.03155736f, 0.01981963f, -0.06801139f, -0.01228991f, -0.02978741f, 0.04338621f, -0.14836636f, 
    -0.06352109f, 0.09719035f, -0.00898828f, 0.04811642f, 0.05392411f, -0.07057577f, 0.03019879f, -0.01245148f, 
    -0.11532706f, 0.03441948f, 0.10616110f, -0.00913930f, -0.05567692f, -0.03990657f, -0.05168845f, 0.03632458f, 
    0.05073784f, 0.07230373f, 0.06694482f, -0.01449714f, 0.10745797f, 0.03920110f, 0.10477144f, -0.02019592f, 
    -0.17198674f, -0.05459401f, 0.00260820f, -0.00138627f, -0.06113248f, 0.11560266f, -0.04142187f, 0.13029368f, 
    0.08484050f, 0.06940406f, 0.08723742f, -0.03099484f, -0.12800859f, -0.00055726f, 0.04799969f, 0.07620098f, 
    -0.00078563f, 0.13068800f, 0.23966600f, -0.00588534f, -0.16667630f, 0.01707324f, 0.00169644f, -0.00482158f, 
    -0.05932669f, -0.02589446f, 0.05764415f, -0.03436267f, -0.04978511f, -0.02288151f, -0.12381281f, -0.00060928f, 
    0.02166955f, 0.07853188f, -0.00510201f, -0.02047873f, -0.47911409f, 0.01244278f, -0.26678124f, -0.12769344f, 
    0.06821153f, 0.09643816f, 0.08709849f, 0.04207630f, 0.04704405f, -0.05038252f, 0.09445961f, -0.02656430f, 
    0.06955179f, -0.03669526f, -0.00872662f, 0.03287864f, -0.04264215f, -0.11480242f, -0.01824393f, 0.06429492f, 
    -0.13741615f, -0.06733431f, -0.03114468f, 0.06055836f, -0.20420645f, -0.01362594f, -0.06686266f, -0.02996922f, 
    -0.04940078f, 0.00921993f, 0.10034459f, 0.05350627f, 0.07204031f, -0.05397684f, -0.05721543f, 0.00465069f, 
    0.02814968f, -0.00561724f, -0.07501339f, 0.00065182f, -0.48729753f, -0.14784898f, -0.02926104f, -0.17871267f, 
    -0.00528568f, 0.13677877f, -0.05120379f, -0.10952455f, 0.03106050f, -0.13633016f, 0.01823797f, 0.04470268f, 
    -0.12443106f, -0.00175609f, -0.00200913f, -0.01482164f, 0.08949510f, -0.01192191f, -0.10947762f, 0.02910925f, 
    -0.10079642f, -0.10360479f, 0.13997443f, 0.22903362f, -0.24309145f, -0.09027362f, -0.03542805f, -0.02180695f, 
    0.06001838f, -0.03034366f, 0.00883696f, 0.08258777f, 0.06148729f, -0.00775262f, 0.06421848f, -0.06644761f, 
    -0.11425149f, -0.01139592f, -0.00623374f, -0.00801162f, -0.17300406f, 0.08255754f, -0.13432172f, -0.02988131f, 
    0.04205970f, 0.02333489f, 0.01547803f, -0.09272064f, 0.06191989f, -0.06446788f, 0.05255494f, 0.00028612f, 
    0.11879302f, -0.04490745f, 0.07390658f, 0.06041442f, 0.08354200f, -0.08844587f, 0.08885384f, 0.02882232f, 
    0.04352602f, 0.07887403f, 0.04261140f, 0.03200466f, -0.00591993f, -0.06955360f, -0.01567948f, -0.10543906f, 
    0.03155770f, -0.01054673f, -0.01258351f, -0.04281875f, -0.01322068f, 0.09515006f, 0.05869439f, -0.03878862f, 
    -0.02620051f, 0.21566723f, 0.05081790f, -0.04677331f, -0.14541389f, -0.07490520f, -0.07549788f, -0.06641912f, 
    -0.09187185f, 0.09773280f, 0.02299362f, 0.01377297f, -0.00284625f, -0.09343128f, 0.02342864f, 0.07534758f, 
    0.01112903f, -0.06915732f, -0.04472325f, 0.03569475f, -0.10584510f, 0.01319083f, -0.06864507f, 0.07939021f, 
    0.02086209f, 0.26258567f, -0.17969488f, -0.11817042f, -0.06402723f, 0.02950574f, 0.10566626f, 0.05005426f, 
    0.00495114f, -0.13721214f, -0.05229739f, -0.03115568f, -0.13669226f, -0.07555877f, -0.06112186f, -0.02800741f, 
    -0.05010908f, 0.08310333f, 0.00364295f, -0.04236417f, -0.20177342f, 0.16566755f, -0.04383586f, -0.07414506f, 
    0.00101417f, -0.08585234f, -0.00879677f, 0.01162743f, -0.03125999f, -0.16416745f, -0.01013543f, -0.04567415f, 
    -0.06843241f, -0.05037767f, 0.00510336f, -0.10665772f, -0.01644915f, 0.04378130f, 0.07574695f, -0.03771760f, 
    -0.03583098f, -0.11537692f, 0.10843983f, 0.17546752f, -0.10139976f, 0.05655876f, 0.02473059f, -0.00338134f, 
    0.03094333f, -0.01460471f, -0.08649631f, 0.01620856f, -0.00963679f, 0.00076891f, 0.01587619f, -0.04665751f, 
    0.01125333f, 0.03415051f, 0.02121693f, -0.03341086f, -0.21732304f, -0.04581199f, 0.09258849f, -0.01186644f, 
    -0.14816259f, 0.08203998f, 0.00401404f, 0.00490045f, -0.00204147f, -0.03382222f, 0.03530836f, 0.00840417f, 
    0.02148893f, -0.01346757f, -0.02091642f, -0.00399077f, 0.04514660f, 0.10288277f, 0.07504459f, 0.00504556f, 
    0.00240383f, -0.05172011f, 0.04678247f, 0.06695145f, -0.08918685f, -0.01014185f, 0.01743986f, 0.01384766f, 
    -0.00052963f, 0.02704895f, 0.02478412f, -0.01807657f, -0.04146882f, 0.01749740f, 0.03089163f, 0.02789954f, 
    -0.00647722f, -0.03061486f, 0.10518500f, 0.06944313f, -0.05075740f, -0.10136936f, 0.06018085f, 0.10941136f, 
    -0.07904335f, 0.00631601f, -0.02439236f, 0.10182136f, 0.01380164f, -0.03831720f, 0.04604495f, 0.03527482f, 
    -0.00729978f, -0.07838444f, 0.15317054f, 0.01747427f, -0.04305975f, 0.01498244f, 0.11634710f, -0.05114394f, 
    -0.16398825f, 0.12089381f, -0.00203925f, 0.05229025f, -0.11974312f, 0.07432713f, 0.01612915f, -0.03207139f, 
    -0.02348032f, -0.04840522f, -0.04975653f, 0.00521493f, 0.04089189f, -0.15650760f, 0.00746285f, -0.03927895f, 
    0.01695787f, 0.01963986f, 0.09986486f, -0.13108122f, 0.03768444f, -0.02229798f, 0.01007180f, 0.02284413f, 
    0.02384378f, -0.01953346f, 0.06960928f, -0.03662800f, 0.01419006f, 0.09595877f, 0.04442798f, 0.03881377f, 
    -0.00154745f, 0.00159604f, -0.09392886f, -0.06879330f, 0.00706659f, -0.00835306f, 0.02654336f, -0.08833541f, 
    0.02158622f, -0.14096895f, 0.08776607f, 0.11461405f, -0.02709428f, -0.06547808f, -0.09597800f, -0.02113105f, 
    -0.04731890f, -0.06050437f, -0.08778620f, 0.08924668f, 0.03260509f, -0.02601961f, 0.15125416f, -0.07972655f, 
    0.04057980f, 0.02631825f, 0.07035117f, -0.01983157f, -0.07820681f, -0.00477231f, 0.01630425f, 0.05304186f, 
    0.19624108f, 0.05648205f, -0.02734555f, 0.05266208f, 0.06352228f, -0.07783926f, -0.02480131f, 0.05866729f, 
    0.06912601f, 0.06176866f, 0.13679816f, -0.00596058f, -0.04275127f, -0.00226665f, -0.14809951f, 0.07123225f, 
    0.05757847f, -0.02345532f, 0.01268965f, 0.00117176f, 0.21417268f, -0.03774140f, -0.09034593f, -0.04635502f, 
    0.08179548f, 0.12178251f, -0.04944148f, 0.07488965f, 0.04426419f, 0.09296185f, -0.02364450f, 0.03250421f, 
    -0.05670444f, -0.08827019f, -0.08622636f, -0.15832373f, -0.18618533f, 0.03149964f, 0.00531956f, -0.18204613f, 
    0.03335610f, -0.07442290f, 0.06422877f, 0.04165810f, 0.00282269f, -0.01929494f, 0.04747669f, 0.00273816f, 
    0.04528897f, -0.15077502f, -0.09841541f, -0.00426986f, 0.09085157f, -0.21506165f, 0.02238946f, 0.07567748f, 
    -0.13886921f, 0.13508354f, -0.02004218f, 0.02903315f, -0.20051458f, 0.03999608f, -0.03985584f, 0.07290996f, 
    -0.12138276f, -0.05603407f, 0.00160728f, -0.05095719f, -0.04114733f, -0.02093672f, -0.11842503f, 0.02278178f, 
    -0.11539681f, 0.11611993f, 0.08379892f, -0.00823513f, -0.09434666f, 0.16897875f, -0.01870325f, 0.15613645f, 
    0.04069389f, 0.00566302f, 0.01061457f, -0.03834251f, -0.03891668f, 0.04094291f, -0.04446035f, 0.09460822f, 
    0.09688927f, -0.06756610f, 0.02018160f, -0.06462952f, 0.06691739f, -0.06085853f, 0.04207889f, -0.11943918f, 
    0.10401430f, 0.11021038f, 0.05122470f, 0.22980076f, -0.11552801f, -0.04304371f, -0.13316387f, 0.03774060f, 
    -0.13247769f, 0.13359606f, -0.01016647f, 0.03423191f, -0.00232541f, 0.09018447f, 0.07104677f, -0.01365585f, 
    -0.00105473f, -0.22018853f, -0.06191012f, -0.04782066f, -0.10627975f, 0.11863287f, -0.06263424f, -0.07877255f, 
    0.00222534f, 0.06010703f, 0.06417075f, 0.04261494f, -0.08389892f, -0.09503934f, 0.12123113f, -0.00325268f, 
    -0.05713623f, -0.05412132f, -0.00200501f, 0.04139780f, -0.02472081f, -0.01412457f, 0.00920010f, -0.01409802f, 
    0.00448241f, 0.07625444f, -0.01316348f, 0.08797622f, 0.11840448f, 0.00306949f, -0.04863597f, 0.10179792f, 
    0.02443672f, 0.07324591f, 0.04023587f, -0.02906914f, -0.00461183f, 0.00997395f, -0.05445708f, -0.03357455f, 
    0.01207775f, -0.02505746f, 0.09971690f, -0.01888616f, 0.01650058f, 0.00661806f, 0.07269893f, 0.06228600f, 
    -0.04851039f, -0.05584474f, 0.01551307f, -0.00527486f, -0.03907754f, 0.06523085f, -0.08525150f, -0.14164579f, 
    -0.06311329f, 0.15901445f, -0.04114524f, 0.07799806f, 0.09163865f, -0.08310959f, -0.17383792f, 0.08497830f, 
    -0.37241614f, -0.19492228f, -0.22090110f, -0.10500001f, -0.02900588f, 0.02130224f, 0.10598738f, -0.06092728f, 
    0.00779542f, 0.06639574f, -0.02516836f, 0.12103389f, 0.15624252f, -0.05741201f, 0.00537950f, 0.02378584f, 
    0.05864821f, 0.00269778f, 0.06725609f, -0.01943819f, 0.01607930f, -0.03837641f, -0.09407269f, 0.11229609f, 
    -0.00242107f, -0.03444550f, -0.04613371f, -0.02712207f, 0.11406513f, -0.01837230f, -0.02351613f, 0.06549443f, 
    -0.04757506f, 0.12508900f, 0.18860412f, -0.08555562f, -0.01398704f, 0.04092288f, -0.07495409f, -0.04217546f, 
    0.14172207f, 0.03458108f, 0.02427384f, 0.14048643f, 0.02306009f, -0.11373529f, -0.10870906f, -0.02553345f, 
    0.08920797f, 0.08856095f, 0.03155892f, -0.19099183f, -0.04179314f, 0.07629238f, 0.03839825f, 0.00216131f, 
    0.07046404f, 0.02058452f, -0.09354377f, 0.05132127f, -0.26706460f, -0.07099207f, -0.05998570f, -0.15435731f, 
    0.02189267f, 0.13176042f, 0.12394189f, -0.00432533f, 0.00592667f, 0.02827688f, -0.02792006f, 0.07542726f, 
    0.00777472f, -0.01188111f, -0.07228750f, 0.09673698f, 0.10436685f, -0.03908685f, -0.04216955f, 0.07484963f, 
    0.00411718f, -0.10533413f, -0.00497494f, 0.01555864f, -0.21348180f, -0.13205495f, 0.02295216f, -0.11936509f, 
    0.06331731f, -0.07042410f, -0.01845271f, 0.07665837f, -0.06594090f, 0.03888630f, 0.05241679f, -0.01116049f, 
    0.09831087f, 0.05527806f, -0.02285067f, -0.08603115f, 0.09281261f, 0.08572467f, 0.08246224f, 0.03893940f, 
    -0.04108130f, 0.05086071f, 0.09655755f, -0.07413551f, 0.08239929f, 0.12532561f, -0.05679954f, 0.09448286f, 
    -0.04997173f, 0.05427385f, -0.03845104f, -0.09829413f, -0.01595352f, -0.04186779f, -0.08023643f, 0.02482394f, 
    0.01884832f, -0.06112222f, -0.01858658f, 0.13046071f, 0.08028463f, 0.08166809f, 0.04517145f, -0.02589358f, 
    -0.08560891f, 0.08163756f, -0.01063849f, -0.13618538f, 0.00434674f, 0.00579030f, -0.01401465f, 0.00438480f, 
    -0.01542605f, -0.04357900f, 0.08266696f, 0.03292421f, 0.20890254f, 0.20888552f, 0.08933299f, -0.05857943f, 
    -0.08969496f, -0.00670293f, 0.05154015f, -0.07414331f, -0.07412360f, 0.06018510f, 0.02453114f, 0.00042904f, 
    -0.01448999f, 0.03954617f, 0.01922048f, 0.04398041f, -0.00933531f, 0.10341121f, 0.09826490f, 0.03872648f, 
    0.10906608f, -0.24406447f, -0.03544739f, -0.13037939f, 0.04992473f, -0.05587408f, -0.01443600f, -0.02465550f, 
    0.00709033f, -0.01670875f, 0.03663429f, 0.05875561f, -0.01911643f, 0.05774014f, 0.00303367f, 0.02525793f, 
    -0.03781985f, -0.03404988f, -0.11267754f, 0.09192480f, 0.17716181f, 0.16433373f, 0.01336152f, -0.03538615f, 
    0.01021625f, -0.00471034f, 0.00880197f, 0.00835238f, -0.09414394f, 0.03795718f, -0.03508374f, 0.06416606f, 
    -0.09310201f, 0.03974602f, -0.09223714f, 0.04985095f, -0.12825364f, 0.06290662f, 0.06494793f, 0.05546477f, 
    -0.14784341f, 0.07522572f, -0.07118867f, -0.36033377f, 0.10179473f, -0.01100090f, -0.06228057f, 0.02662451f, 
    -0.06151388f, -0.16442896f, 0.04824971f, -0.07929158f, 0.01318821f, -0.06718132f, 0.03570497f, -0.14327368f, 
    -0.04258553f, 0.04585829f, 0.05176676f, -0.02396428f, -0.08874992f, -0.06318987f, -0.00839694f, -0.11845608f, 
    0.03744904f, -0.05571570f, 0.04017355f, 0.03181574f, -0.01261937f, 0.01000455f, 0.00914804f, 0.01061063f, 
    -0.00409708f, 0.01507946f, 0.01694218f, -0.02861175f, -0.06899579f, -0.05386668f, 0.06853269f, -0.03838610f, 
    0.01248643f, -0.21450336f, 0.02685270f, -0.18051156f, 0.04807659f, -0.00221084f, 0.03143772f, 0.03572951f, 
    -0.09686665f, 0.02494743f, -0.01080103f, -0.03218964f, 0.10063431f, 0.02858052f, 0.01505197f, -0.00274218f, 
    -0.03800128f, -0.04326795f, 0.02554654f, -0.00721922f, 0.32709378f, -0.02606903f, -0.00143391f, 0.09351127f, 
    0.13295057f, 0.11628313f, 0.01616315f, -0.05746172f, 0.05918360f, -0.01176382f, -0.09238097f, 0.00964994f, 
    0.08668827f, -0.04171166f, 0.00923824f, -0.12954713f, 0.03732898f, 0.00085164f, -0.09842563f, -0.02527534f, 
    0.04778855f, -0.17058814f, -0.02031401f, 0.16236040f, -0.03425799f, -0.06638125f, -0.00558090f, -0.07981012f, 
    0.03516070f, 0.05868273f, -0.11439352f, 0.03399897f, 0.05962748f, 0.03556107f, 0.03861631f, 0.01660260f, 
    -0.01785221f, -0.00009547f, -0.02559199f, -0.02502538f, 0.10905270f, 0.02255615f, 0.02744926f, 0.08185887f, 
    0.36460927f, 0.01649553f, -0.07075121f, -0.00659504f, 0.00873062f, -0.05817220f, -0.14161466f, 0.09864151f, 
    -0.08133022f, 0.07991185f, 0.06944618f, -0.07523189f, -0.02790400f, 0.07777559f, 0.06210637f, 0.03828387f, 
    -0.25057119f, -0.19676432f, -0.15822224f, 0.25884226f, 0.02206753f, -0.01764875f, 0.00931742f, 0.05886621f, 
    0.04910193f, 0.05037696f, 0.00847993f, -0.07071696f, 0.03168199f, -0.08473353f, -0.11063414f, 0.04829837f, 
    -0.08812532f, 0.00497572f, -0.13040395f, -0.00693842f, -0.14301275f, 0.04424220f, -0.19438766f, -0.23207346f, 
    0.03612920f, -0.04756841f, -0.01856388f, 0.07905458f, -0.01110084f, 0.00024610f, 0.06530058f, -0.03459164f, 
    0.00783829f, -0.01682894f, -0.01251882f, -0.15510114f, -0.05359158f, 0.00579376f, 0.08226744f, -0.04640261f, 
    0.09700722f, -0.23700088f, -0.02458058f, -0.03475327f, 0.02789484f, 0.01820266f, 0.04196127f, -0.03588410f, 
    0.02608925f, -0.03384655f, -0.06860654f, -0.01324380f, -0.03593130f, 0.05617198f, -0.03183231f, -0.04231692f, 
    0.00157206f, 0.01040128f, 0.06939722f, 0.05682740f, -0.15945806f, -0.03611161f, 0.03753773f, 0.26179379f, 
    -0.12393671f, 0.03771023f, -0.08916958f, 0.04084638f, -0.00847697f, -0.07387443f, 0.09032028f, 0.04143419f, 
    0.11346516f, 0.03970272f, 0.06928039f, 0.01238275f, -0.02613483f, 0.04972759f, 0.01608542f, -0.09042692f, 
    -0.04381708f, 0.15850617f, -0.07688364f, 0.00934491f, -0.27340180f, -0.03382529f, 0.05949863f, 0.01332692f, 
    0.06846575f, 0.01074247f, 0.06667997f, 0.08863457f, -0.06336309f, 0.01425103f, -0.10823934f, -0.03563342f, 
    -0.04509776f, 0.03492828f, -0.04818806f, -0.00426164f, 0.18370605f, -0.36575535f, -0.04220435f, 0.16906832f, 
    -0.00357884f, 0.02064170f, 0.06725001f, 0.02521286f, -0.11896721f, -0.04430968f, -0.00570322f, -0.02299598f, 
    -0.00290700f, 0.02043998f, 0.04427438f, -0.03457242f, 0.03264529f, 0.08943938f, 0.06627753f, 0.02314593f, 
    -0.05922073f, -0.20738102f, -0.00912641f, 0.00046446f, -0.01879773f, 0.03159575f, 0.01409657f, 0.04863535f, 
    -0.07551574f, 0.05097307f, 0.05983935f, -0.06014476f, 0.02053316f, 0.00515214f, 0.07566220f, -0.00709779f, 
    0.03773235f, 0.03351327f, 0.07218406f, -0.08262245f, -0.00250657f, -0.04800446f, -0.00624081f, -0.14725848f, 
    0.02884226f, -0.14110233f, -0.11207462f, -0.02537454f, 0.06692350f, -0.00986865f, -0.02220375f, 0.01772061f, 
    -0.04282916f, 0.02573594f, 0.06788669f, 0.01976470f, 0.01862024f, 0.02023174f, 0.02960595f, -0.04322018f, 
    -0.13598253f, 0.21984446f, 0.01287481f, 0.04095327f, -0.04088520f, -0.02557178f, -0.01473542f, 0.02575205f, 
    -0.02687642f, 0.03990622f, 0.04603859f, 0.07749183f, 0.08437563f, -0.02737064f, -0.04570547f, -0.00545979f, 
    -0.07410274f, 0.02440581f, 0.00810522f, 0.02977442f, -0.03197604f, 0.14930359f, 0.04137253f, -0.23143061f, 
    -0.06457370f, 0.07461940f, 0.04634339f, 0.04998504f, -0.12942261f, -0.00375539f, -0.08489751f, 0.03379245f, 
    -0.14906064f, -0.07708748f, -0.10926093f, 0.07745923f, -0.04030933f, -0.01961336f, 0.06047655f, 0.11851806f, 
    -0.11518700f, 0.17839083f, 0.09219974f, -0.00335012f, -0.19432828f, 0.10154038f, 0.11173555f, -0.05841800f, 
    0.05595932f, 0.04133995f, -0.07302201f, 0.09701368f, 0.03718692f, -0.02936864f, -0.05485396f, -0.01557813f, 
    0.06241782f, -0.07180482f, -0.00995770f, -0.11249448f, -0.01150441f, -0.08226047f, 0.08494049f, -0.08838467f, 
    0.15682310f, -0.03374740f, -0.02478652f, -0.03400292f, -0.04021265f, -0.05631278f, -0.09406930f, -0.04582263f, 
    -0.06749837f, -0.00821572f, -0.08373763f, 0.00845011f, 0.03898612f, 0.02059642f, 0.04905902f, 0.00542033f, 
    0.04137640f, -0.10187422f, 0.08939956f, -0.03032106f, 0.05710999f, 0.05819349f, 0.02510895f, 0.07068524f, 
    -0.06089978f, -0.03392095f, -0.02053327f, 0.01037849f, -0.04931760f, -0.05400432f, 0.00002978f, -0.05482898f, 
    0.09079611f, 0.07038510f, 0.06231127f, -0.00956426f, 0.20952015f, -0.20832942f, -0.04835123f, -0.31970346f, 
    0.12881334f, 0.00440233f, -0.04283830f, -0.06135797f, 0.05991297f, -0.14565809f, 0.02986383f, 0.00674087f, 
    -0.03575006f, -0.00229710f, -0.04799462f, 0.13777341f, -0.04853519f, 0.01733333f, -0.11888511f, 0.12831151f, 
    -0.31498620f, 0.23802309f, -0.03501634f, 0.23657364f, 0.03046587f, -0.08841756f, -0.02472184f, -0.09885551f, 
    0.00449265f, 0.05115881f, -0.07797375f, 0.10926159f, -0.00161949f, -0.03845041f, -0.04818476f, 0.02068173f, 
    -0.03454253f, -0.07007538f, -0.04733041f, -0.19681175f, 0.21486990f, 0.11852797f, -0.03961968f, 0.01537388f, 
    0.05020793f, -0.01409008f, 0.01673193f, -0.03242910f, -0.00096889f, 0.03941833f, 0.01764380f, -0.03832173f, 
    0.09150887f, -0.04215813f, 0.15103097f, -0.15317407f, 0.08767459f, 0.10910198f, -0.02703981f, 0.06507947f, 
    0.05574605f, 0.07884234f, 0.04497229f, -0.07889026f, 0.08227859f, -0.13418372f, -0.06544302f, -0.06613072f, 
    0.01105017f, -0.11938985f, 0.04251688f, 0.03986064f, -0.03092884f, 0.01457112f, 0.00716553f, 0.08175267f, 
    -0.04492116f, 0.02185840f, 0.03375148f, 0.02629025f, 0.11778517f, -0.23801365f, -0.09153344f, 0.06271312f, 
    -0.07563893f, -0.01741496f, 0.02177780f, 0.02688935f, -0.06399646f, 0.08158610f, -0.06656026f, 0.03855058f, 
    -0.06003699f, 0.03038031f, 0.06095004f, 0.05718989f, 0.01216428f, -0.03896191f, -0.01389576f, -0.04794518f, 
    -0.16245842f, -0.03204896f, -0.10711198f, 0.21441063f, 0.01557083f, 0.06758401f, 0.10073572f, -0.03672903f, 
    0.05217353f, 0.03770439f, -0.02807778f, -0.05118880f, 0.07334366f, -0.00835958f, -0.21752460f, 0.03641190f, 
    0.00987155f, 0.02731503f, 0.03864192f, 0.00845797f, -0.07523836f, 0.01053841f, -0.19340064f, -0.30326921f, 
    0.09731681f, -0.02409868f, -0.07147931f, 0.03477627f, -0.05737016f, -0.04823429f, -0.03345434f, -0.08059870f, 
    -0.10788720f, -0.03740187f, -0.02478049f, -0.01532657f, -0.04673097f, 0.11792567f, -0.01420502f, 0.05310948f, 
    -0.45443583f, 0.10390998f, -0.02369965f, 0.19715075f, 0.03515498f, 0.07896749f, -0.08083040f, 0.03629610f, 
    0.09412706f, -0.05529922f, 0.05413996f, -0.02626991f, 0.02605030f, -0.03902740f, -0.03890160f, 0.05219202f, 
    0.03212792f, -0.16402750f, -0.01697959f, -0.02796234f, 0.06635306f, 0.19254316f, 0.20850512f, 0.03355315f, 
    -0.14216150f, 0.12659466f, -0.02609662f, 0.05686098f, 0.06628045f, -0.05668264f, -0.07430388f, -0.07503217f, 
    0.01914304f, 0.00662070f, 0.07820204f, 0.11288739f, 0.00753274f, -0.02726792f, 0.05137182f, -0.10989832f, 
    0.08510043f, -0.02676107f, -0.08961277f, 0.01300455f, -0.09129702f, -0.03251894f, -0.01860811f, 0.03861199f, 
    -0.03962298f, 0.03600150f, -0.02565103f, 0.00969415f, 0.04472532f, 0.02645894f, 0.07731313f, 0.13746879f, 
    -0.05505306f, -0.03557441f, -0.03251681f, -0.00293174f, 0.10493001f, -0.21106330f, -0.06055243f, -0.20980005f, 
    0.04530322f, -0.06970780f, 0.04813509f, 0.05573169f, -0.10635173f, -0.11630417f, 0.00367782f, -0.02462424f, 
    0.08459164f, 0.07071891f, -0.02416537f, 0.02535646f, 0.00688924f, 0.05120152f, 0.03456971f, 0.08507761f, 
    0.06133601f, -0.18546773f, 0.02618279f, -0.03193626f, 0.01882599f, -0.05523448f, 0.00144202f, 0.03544265f, 
    0.00394796f, 0.01427613f, 0.01551644f, 0.00229196f, -0.13416146f, -0.10808074f, 0.03127779f, -0.00746515f, 
    0.05410158f, -0.01843727f, 0.09344132f, -0.05556113f, 0.07099943f, 0.04158983f, -0.01392856f, -0.26176462f, 
    0.17505206f, 0.05787157f, -0.05157515f, 0.10823020f, -0.05194316f, -0.01753946f, -0.02237061f, -0.08341614f, 
    0.11471193f, -0.01474687f, 0.01281162f, 0.02742943f, 0.00892267f, -0.11645865f, 0.10334641f, 0.19404054f, 
    0.04017785f, -0.03246236f, 0.05171634f, 0.02235825f, 0.21618748f, 0.09413741f, 0.05491501f, 0.05674867f, 
    0.07641390f, -0.07137039f, -0.04565767f, 0.04464461f, -0.12338127f, 0.00445997f, -0.08071597f, -0.03972965f, 
    0.05379963f, 0.13549379f, 0.11192132f, 0.03527421f, 0.07823583f, -0.24375460f, -0.02948296f, -0.19190252f, 
    0.17456500f, -0.17870274f, 0.00748815f, 0.02053891f, -0.05339738f, 0.04718429f, 0.00901429f, -0.03383077f, 
    0.00162311f, 0.04579576f, -0.04626561f, -0.02305157f, -0.01239123f, 0.04205528f, -0.12144878f, 0.02204159f, 
    -0.29133895f, 0.25013515f, 0.02539334f, 0.07051583f, -0.18978384f, 0.03785743f, -0.07331732f, 0.06314502f, 
    0.07234780f, -0.00314199f, -0.08625207f, 0.02385784f, -0.00350050f, -0.06165335f, -0.00797894f, 0.01219412f, 
    0.02342952f, -0.14655921f, 0.00970289f, 0.04037290f, 0.11444627f, -0.11730309f, 0.00119871f, 0.03854590f, 
    -0.02528027f, -0.00660936f, 0.04936420f, 0.06783628f, -0.07949146f, 0.06660824f, 0.04375158f, -0.09493683f, 
    0.06330487f, 0.01949649f, 0.05356633f, -0.03421631f, 0.05194130f, -0.04557439f, 0.04483091f, -0.04657830f, 
    0.20344308f, -0.25995651f, -0.00698831f, -0.21699390f, 0.04011368f, 0.04270396f, -0.00822112f, -0.00161594f, 
    -0.00455738f, -0.09387822f, -0.08263449f, -0.04488731f, 0.16752633f, 0.03274365f, -0.01282556f, 0.04428380f, 
    -0.03771399f, -0.04684871f, -0.05026910f, 0.08875252f, -0.04686238f, -0.34417760f, 0.09251964f, -0.16347261f, 
    0.08997375f, 0.02698995f, -0.00507968f, -0.03097616f, 0.10511405f, -0.08509821f, -0.02266819f, 0.00638490f, 
    -0.02662823f, 0.08309277f, 0.07273540f, -0.03053710f, -0.04251738f, -0.04128367f, -0.09114120f, -0.04043805f, 
    -0.08811134f, 0.13830274f, 0.04582477f, 0.11508060f, -0.17514120f, -0.01659820f, -0.05411671f, 0.01768922f, 
    0.03768359f, -0.00172168f, -0.03972968f, -0.06862358f, 0.07411268f, -0.02746325f, -0.00519290f, 0.07015912f, 
    -0.01871600f, -0.10674989f, -0.15919940f, 0.00659035f, 0.21861655f, -0.45296091f, -0.15580258f, 0.28201392f, 
    0.00850590f, -0.10077276f, 0.05782692f, -0.03685264f, 0.05917649f, -0.00276630f, 0.05871552f, 0.00146562f, 
    -0.08565514f, 0.02587618f, -0.02108796f, -0.08862185f, -0.00368227f, 0.02548496f, -0.10044023f, -0.11117402f, 
    0.09608901f, 0.12347360f, 0.01679132f, 0.03489618f, -0.12470761f, -0.03295875f, 0.02125023f, -0.01994800f, 
    0.05892771f, -0.06903879f, -0.04624288f, -0.02742605f, 0.09508331f, 0.00681954f, 0.04747823f, -0.00341648f, 
    -0.02362558f, 0.00603144f, -0.08179148f, -0.02206464f, -0.04371774f, 0.23989971f, -0.02796502f, 0.05387845f, 
    -0.17838278f, 0.00666412f, 0.05582003f, 0.02522334f, 0.03491209f, -0.01079830f, 0.02451229f, 0.04932452f, 
    -0.01739725f, 0.06774372f, -0.08957288f, -0.08591225f, 0.10276160f, 0.06322143f, -0.07817284f, 0.00400599f, 
    0.16804314f, -0.20652375f, -0.12279154f, -0.00255466f, 0.06012311f, 0.01115724f, 0.10160141f, 0.00482320f, 
    -0.01001834f, -0.01264318f, 0.00986364f, -0.00456877f, 0.05330532f, -0.06122039f, 0.02022944f, 0.02391348f, 
    -0.01175316f, 0.02939120f, -0.04367072f, 0.09190076f, -0.10899527f, -0.01285237f, 0.00485325f, -0.09757082f, 
    -0.03255165f, -0.00132990f, -0.03920536f, 0.04708758f, -0.04139351f, -0.03844326f, -0.06690627f, -0.00702347f, 
    -0.04493977f, -0.01670521f, 0.02369503f, 0.03066179f, -0.03436083f, -0.00910913f, 0.06136831f, 0.06792562f, 
    -0.28513461f, 0.22624788f, -0.03947069f, 0.11459095f, -0.29878628f, -0.05073213f, 0.01103944f, 0.05723061f, 
    0.09592879f, 0.03723440f, 0.04442109f, -0.02632935f, -0.01140859f, 0.06505730f, 0.02407032f, 0.00066136f, 
    0.01056573f, 0.06573717f, -0.07652966f, 0.13170861f, 0.15876499f, -0.00586112f, -0.16864645f, -0.14288682f, 
    -0.10899110f, 0.01244555f, 0.02245432f, -0.02414000f, -0.14466640f, 0.00369697f, -0.06547720f, -0.03986364f, 
    0.00269791f, -0.11871642f, -0.05012673f, 0.05000861f, 0.02027018f, 0.06307994f, 0.09440526f, 0.03322147f, 
    -0.11052233f, 0.10055106f, -0.04129240f, -0.05089306f, 0.04088121f, -0.06380004f, 0.10083117f, 0.06462236f, 
    0.00608312f, 0.06292265f, -0.06957501f, -0.01775062f, 0.07557901f, -0.12306797f, 0.09885570f, 0.13975152f, 
    -0.06999483f, -0.00042196f, 0.09753576f, 0.10206317f, 0.05584696f, -0.16008607f, 0.02946816f, 0.15271431f, 
    0.14375159f, -0.05746600f, 0.07785369f, -0.09443574f, 0.01534394f, -0.02687306f, -0.08678331f, 0.07358408f, 
    -0.00387274f, 0.02715910f, 0.13764893f, 0.05763386f, 0.01984030f, 0.13220324f, -0.08939380f, 0.05877300f, 
    0.08949501f, -0.34163421f, -0.10047322f, -0.03513226f, -0.01468702f, 0.02492489f, 0.04454004f, -0.03088804f, 
    0.01737619f, 0.01275888f, -0.04859509f, 0.04695996f, 0.02254087f, 0.03396520f, 0.04105069f, 0.02737542f, 
    0.02063597f, -0.02019305f, -0.05650147f, 0.00950367f, 0.13205080f, -0.13106211f, -0.06137398f, -0.13733368f, 
    0.01754126f, 0.01205339f, -0.04522913f, -0.06093653f, 0.05670235f, 0.07651624f, -0.01961772f, 0.05364984f, 
    0.08964900f, -0.09643824f, 0.04880399f, 0.02206164f, -0.01938492f, 0.03956868f, -0.00982979f, 0.12449050f, 
    -0.04864784f, -0.00442545f, -0.04416187f, -0.06282129f, 0.26210412f, 0.05236416f, 0.05665018f, -0.02414167f, 
    0.02340848f, 0.03051759f, -0.18885918f, 0.05938945f, -0.10810254f, 0.01093272f, -0.07241026f, 0.06164179f, 
    0.06000143f, 0.13240294f, 0.11448496f, 0.05273785f, -0.07780826f, -0.29683021f, -0.05257152f, -0.11262421f, 
    -0.06857539f, 0.00460301f, -0.02441008f, 0.01945867f, -0.04831754f, 0.03055097f, -0.04693517f, 0.02006211f, 
    0.01514093f, 0.09739156f, -0.01528527f, -0.01101000f, -0.00931769f, -0.09221341f, -0.00992004f, -0.03509798f, 
    0.01143140f, -0.10555279f, -0.13244851f, 0.06305367f, 0.00053473f, -0.04450952f, 0.16364796f, -0.03891931f, 
    -0.03359843f, 0.06068931f, -0.01373625f, 0.02342911f, -0.05556294f, -0.06264547f, -0.03575734f, -0.02072289f, 
    -0.03263379f, 0.05728648f, -0.13710648f, 0.09709967f, -0.14767456f, -0.02550327f, 0.00758926f, 0.01887379f, 
    -0.00624819f, -0.01153975f, 0.09753655f, 0.00031194f, -0.06982952f, 0.02138127f, 0.01488396f, 0.00568341f, 
    0.06149145f, -0.01711271f, -0.06227280f, 0.05915203f, -0.03987629f, -0.00330611f, 0.07222175f, -0.04110426f, 
    0.05152880f, -0.08567879f, 0.01430376f, -0.24528988f, 0.12537970f, -0.06806256f, -0.02146750f, -0.02975249f, 
    -0.08797271f, -0.12201560f, -0.00000534f, -0.00953082f, -0.06963940f, 0.05678980f, -0.01029040f, -0.04969433f, 
    0.06293242f, -0.03475463f, 0.03107932f, -0.03068644f, 0.05034766f, 0.00743488f, 0.07783735f, -0.01715511f, 
    0.03987041f, 0.10105728f, -0.04249234f, 0.03592055f, -0.07317009f, -0.02715120f, -0.00717063f, 0.00953045f, 
    0.05161637f, -0.02667891f, -0.11906593f, 0.00146607f, 0.03778407f, 0.00955035f, 0.07120437f, -0.01273564f, 
    0.05977371f, 0.15205662f, 0.05439100f, 0.05920860f, -0.03496815f, 0.07250640f, 0.05128718f, 0.07451849f, 
    0.08153084f, -0.04753055f, 0.02755373f, 0.04012457f, -0.02170981f, 0.02169547f, -0.00977590f, 0.04554067f, 
    0.01297584f, 0.04923211f, 0.04780369f, -0.14191784f, -0.17021854f, -0.07599882f, -0.05046043f, -0.31009242f, 
    -0.00184897f, -0.05830985f, -0.04905619f, -0.05811853f, -0.06815591f, -0.04829937f, -0.06502222f, 0.01685031f, 
    -0.05835028f, 0.06585482f, -0.05877656f, -0.04562796f, -0.00017733f, -0.07274238f, 0.06439199f, -0.03093972f, 
    0.01953011f, -0.10239534f, 0.00654831f, 0.02931530f, -0.06350943f, 0.08533001f, 0.00513093f, 0.06177412f, 
    -0.03237313f, 0.02690669f, 0.01910142f, 0.00036850f, 0.04430323f, -0.05077962f, -0.04123000f, 0.02261410f, 
    0.01586378f, 0.00506521f, 0.05864439f, -0.06879269f, -0.09612959f, 0.07293267f, 0.05504623f, 0.07416941f, 
    -0.02747248f, -0.07708336f, -0.05643952f, 0.01345770f, -0.01830039f, -0.01288175f, 0.00588031f, -0.00790353f, 
    0.04425315f, -0.03781603f, 0.00026153f, 0.10598905f, -0.05342147f, 0.03517571f, -0.02710472f, 0.01473722f, 
    -0.16589452f, 0.16493843f, -0.15761882f, 0.18091227f, -0.32319683f, -0.04048492f, 0.03147042f, 0.02646881f, 
    0.07962698f, 0.01557685f, -0.03077764f, 0.05916446f, 0.01246251f, -0.05268530f, -0.03852760f, -0.05721959f, 
    -0.08215982f, 0.00480824f, -0.09744865f, -0.01440951f, -0.33703342f, 0.11267285f, -0.12877181f, 0.18377094f, 
    -0.00047585f, -0.08962921f, -0.01697651f, -0.00659960f, 0.07735739f, 0.00975875f, 0.00154907f, 0.03409344f, 
    0.04427676f, -0.04487548f, -0.03022687f, -0.00339642f, -0.01951731f, -0.18511860f, -0.04557826f, -0.10611791f, 
    -0.08082157f, 0.08182146f, 0.12122013f, 0.00690633f, 0.08461913f, -0.07365848f, 0.08273966f, -0.03819817f, 
    0.01802462f, -0.03334045f, -0.02360749f, 0.03093604f, 0.00388583f, -0.00616139f, -0.06455449f, -0.01968894f, 
    0.00101133f, 0.00338018f, 0.02209594f, -0.02353495f, 0.04749407f, 0.04578821f, -0.19087003f, 0.01499134f, 
    0.17305407f, -0.15394862f, -0.06744695f, -0.05089800f, -0.01760509f, -0.01966204f, -0.01814211f, 0.00049857f, 
    -0.00506929f, 0.03592431f, -0.01159278f, -0.02056105f, -0.02178699f, 0.06561165f, -0.06148139f, 0.07479691f, 
    0.16288297f, 0.08665249f, 0.19296497f, 0.09222247f, 0.15509106f, 0.00902175f, 0.10996529f, -0.02944119f, 
    -0.05439916f, -0.03833969f, -0.04433394f, 0.04778690f, -0.09627561f, -0.01633608f, 0.00236177f, 0.00492680f, 
    0.02228205f, 0.06754728f, 0.05398171f, -0.09130708f, 0.03600876f, -0.01701320f, 0.12000635f, 0.04212020f, 
    0.07145835f, 0.02950723f, 0.03165786f, 0.01692889f, -0.00873611f, -0.03790765f, -0.03078649f, 0.03275458f, 
    0.00525375f, -0.00313981f, -0.04298412f, -0.02979928f, -0.05808123f, 0.01006298f, 0.02725216f, -0.05994496f, 
    0.07355156f, 0.01416424f, 0.13721500f, 0.04618194f, 0.07771531f, 0.03202608f, 0.06215015f, -0.00840526f, 
    0.00795657f, -0.00610980f, -0.01929161f, 0.02615747f, -0.01273183f, 0.01210310f, -0.02392096f, -0.02335306f, 
    -0.00066414f, -0.01376306f, 0.03785117f, -0.05810536f, -0.04565927f, -0.00087031f, -0.01800447f, -0.02883497f, 
    -0.06949071f, -0.08662640f, 0.00984380f, -0.04017035f, -0.02853773f, 0.02098911f, -0.01800654f, 0.05681764f, 
    0.00969154f, 0.01584749f, -0.00718189f, -0.01507014f, -0.00451976f, 0.01953627f, 0.01247311f, -0.05227076f, 
    -0.10205089f, -0.01733723f, 0.05267496f, -0.00360533f, -0.06228233f, 0.01896689f, -0.05169746f, -0.06516459f, 
    -0.01404234f, 0.02108826f, 0.00999840f, 0.00525441f, 0.00783807f, 0.01916386f, -0.05036332f, 0.05218402f, 
    -0.02920324f, -0.02540337f, -0.03322167f, -0.04937817f, -0.14834964f, 0.04898084f, -0.24104623f, -0.04420620f, 
    0.05246470f, -0.00744794f, -0.05433978f, -0.10539335f, 0.02678725f, 0.00623440f, -0.08476003f, 0.00368460f, 
    -0.07287247f, -0.01112666f, 0.00306889f, 0.00398606f, -0.07886160f, 0.01690064f, -0.05059685f, -0.00375731f, 
    -0.17864653f, -0.04334070f, 0.00363323f, -0.02812474f, -0.01418317f, 0.01906310f, 0.03991795f, -0.02338449f, 
    -0.06771149f, -0.06382556f, -0.00897974f, 0.06761251f, -0.04568221f, 0.00741349f, -0.02177582f, 0.00200326f, 
    0.03250466f, 0.00545590f, -0.01793359f, 0.00745710f, 0.07630910f, 0.08990768f, 0.11542456f, 0.06050607f, 
    0.09192628f, -0.00713972f, 0.03369373f, -0.06760723f, -0.09976780f, -0.02031857f, -0.00367502f, 0.01656245f, 
    -0.01946436f, -0.04169333f, -0.02557228f, 0.01273495f, -0.01815806f, 0.02130648f, 0.09826361f, -0.02882071f, 
    -0.04451491f, -0.05197594f, 0.00205660f, 0.01835006f, 0.01452233f, -0.09267054f, 0.01972195f, 0.01376069f, 
    0.00806364f, 0.03197311f, 0.01252432f, -0.02855143f, -0.06557556f, -0.05459930f, 0.01940173f, -0.03600309f, 
    -0.00736115f, 0.00171749f, -0.05374114f, -0.02375972f, -0.29179621f, 0.05251800f, 0.15202336f, -0.01980555f, 
    -0.11256372f, 0.04381383f, 0.03211596f, -0.06973639f, -0.00474464f, -0.00350334f, 0.06948150f, 0.00894779f, 
    0.00607558f, -0.02604729f, -0.01986045f, 0.00476133f, -0.02194026f, 0.00149133f, 0.00526222f, -0.11782922f, 
    -0.22403196f, -0.00380664f, -0.18009010f, -0.06086398f, 0.01612369f, 0.01444128f, -0.06175050f, -0.07848457f, 
    0.00867443f, -0.07529927f, -0.04654796f, 0.02998262f, -0.00893455f, 0.02114939f, -0.02337846f, -0.00748157f, 
    -0.00474279f, -0.00380900f, 0.01447848f, 0.06204982f, 0.17543104f, -0.18595836f, 0.08523580f, 0.02806506f, 
    -0.11034844f, 0.07331076f, -0.00940886f, 0.00796515f, -0.05277816f, -0.02224869f, -0.02185973f, 0.01272753f, 
    -0.00511100f, -0.04964281f, -0.04398568f, 0.01631144f, 0.06114464f, 0.01520559f, 0.04472053f, -0.02845704f, 
    0.09524053f, -0.16378382f, 0.03122033f, 0.00909102f, 0.07135750f, 0.00093097f, -0.03720540f, -0.00085612f, 
    -0.04218271f, -0.00350476f, -0.01663427f, 0.03622980f, -0.03711632f, 0.02891163f, -0.04092623f, -0.06315757f, 
    0.02055116f, -0.03430934f, 0.06332605f, -0.04099544f, 0.14101392f, 0.07207066f, 0.08403739f, 0.07997029f, 
    0.05657057f, 0.05281172f, -0.03234515f, 0.04286874f, 0.00329280f, -0.02427115f, 0.01370761f, 0.02196192f, 
    -0.04525339f, 0.04036574f, -0.05579701f, -0.01901221f, -0.02241014f, 0.04402186f, -0.01008285f, -0.01741082f, 
    -0.05183149f, 0.06256284f, -0.02168143f, 0.00061413f, 0.01830818f, 0.00265825f, -0.07728007f, -0.02072438f, 
    -0.03822864f, -0.04648385f, 0.02313472f, -0.01644849f, -0.00438254f, 0.01916053f, -0.06548122f, 0.00446444f, 
    -0.00506802f, -0.00219332f, -0.03765463f, -0.01043966f, 0.01713697f, -0.14657825f, -0.02945368f, 0.00233055f, 
    0.06769323f, 0.01528056f, -0.04218224f, -0.08226317f, -0.06517524f, -0.04242821f, -0.01215578f, 0.03829852f, 
    0.03057645f, -0.01987168f, -0.00369041f, -0.08599741f, 0.04259670f, -0.02963872f, 0.00455584f, 0.05500526f, 
    -0.12758519f, 0.02608490f, -0.22585332f, -0.08840519f, -0.10318258f, 0.00449745f, -0.03815144f, -0.04510425f, 
    0.01069913f, -0.01516066f, -0.09199809f, -0.01822725f, 0.03469561f, -0.06655356f, 0.01151699f, -0.05442424f, 
    0.03442069f, 0.02388638f, -0.00993672f, 0.04487347f, 0.02638682f, 0.06226166f, 0.04927349f, -0.00860806f, 
    0.08328532f, -0.04807232f, 0.04537363f, -0.02995417f, 0.00880736f, -0.00323777f, -0.02747460f, 0.01371390f, 
    -0.07521100f, -0.00849497f, 0.00323813f, -0.07022493f, 0.00201774f, 0.05617177f, -0.01150547f, -0.00184011f, 
    0.16479117f, -0.31451160f, 0.08710466f, 0.03853403f, -0.06112077f, 0.01563868f, 0.01016710f, -0.01772359f, 
    -0.00985914f, 0.01263678f, -0.00223445f, -0.00180849f, -0.04613144f, -0.00793209f, -0.04523142f, -0.00826377f, 
    0.04143880f, -0.00783143f, 0.01539491f, -0.04002975f, -0.02790971f, 0.08895171f, 0.18547301f, 0.01310981f, 
    0.13956872f, -0.01447195f, 0.10882485f, -0.01467450f, 0.03636396f, 0.01583379f, -0.04441714f, 0.02923264f, 
    -0.06140034f, -0.03590586f, -0.06459601f, 0.00913917f, 0.04129254f, -0.02776462f, -0.03309777f, 0.00040054f, 
    -0.20436874f, -0.00060133f, -0.03822896f, -0.19159545f, -0.12873140f, 0.01498767f, -0.05197645f, 0.01067343f, 
    0.00670454f, -0.06334741f, -0.07085701f, -0.03202027f, -0.04862090f, -0.04949895f, -0.02235889f, -0.02721251f, 
    -0.01323883f, 0.00424323f, -0.00048047f, 0.01623210f, -0.00141741f, 0.14917281f, 0.10174884f, 0.09770411f, 
    0.10243157f, -0.03956482f, 0.03453849f, -0.01070234f, 0.05791122f, 0.05586398f, 0.00037332f, 0.00567917f, 
    0.03038902f, 0.00817678f, -0.04732978f, 0.05336720f, -0.05807835f, 0.05288548f, 0.03914428f, -0.01074688f, 
    0.00487454f, 0.08622953f, 0.10434645f, 0.10052198f, 0.04792234f, 0.06231825f, 0.04181074f, 0.02608874f, 
    0.04142167f, -0.05208199f, 0.02681273f, 0.00928542f, -0.01641055f, -0.01153525f, -0.02921773f, 0.02738237f, 
    -0.00079098f, 0.01738121f, 0.00016967f, -0.02448764f, 0.05497855f, -0.14543179f, 0.02013461f, 0.00787428f, 
    -0.08047148f, 0.04705667f, -0.00746972f, -0.02687092f, -0.04232332f, -0.02577455f, 0.00081930f, -0.04734721f, 
    -0.03373118f, -0.03253464f, -0.06715427f, 0.02081940f, 0.01705263f, -0.00406710f, -0.02820240f, -0.03146191f, 
    -0.08372676f, 0.14669268f, -0.08316743f, -0.14107668f, 0.07986619f, -0.00713178f, 0.08394445f, -0.06460630f, 
    -0.03643246f, -0.05650445f, -0.04040376f, 0.03209903f, -0.02133418f, -0.00719728f, -0.03687111f, -0.00142022f, 
    0.01987897f, 0.01922411f, -0.00159404f, 0.00892420f, 0.02277829f, 0.10227504f, 0.05281583f, 0.03821909f, 
    0.09767693f, 0.00634261f, 0.03330633f, -0.02311265f, -0.02448181f, -0.01408587f, -0.06565127f, 0.01107153f, 
    -0.10146321f, -0.03909162f, -0.06620825f, -0.01142276f, -0.00698126f, 0.04707352f, -0.03306756f, -0.04200673f, 
    -0.03119993f, -0.07329068f, -0.00196338f, -0.07506713f, -0.08459583f, -0.01102824f, -0.00101558f, -0.01404666f, 
    -0.07754771f, -0.00997135f, -0.04315847f, 0.02312482f, -0.00686727f, -0.05061319f, -0.05181508f, 0.01237183f, 
    0.01027030f, -0.03890136f, -0.03307198f, -0.03181180f, 0.11838340f, -0.43147063f, 0.00631202f, -0.11638887f, 
    -0.12785675f, -0.08290976f, -0.01342694f, -0.02183292f, -0.03482425f, -0.06253751f, 0.03304399f, -0.03124851f, 
    -0.04792343f, -0.01354585f, -0.03378221f, -0.00706300f, 0.08365590f, -0.01415938f, -0.01948723f, -0.05053661f, 
    0.03449375f, 0.05103526f, -0.07092924f, 0.02272595f, -0.11024046f, -0.02310344f, -0.01510878f, 0.01724120f, 
    -0.06269929f, -0.01242957f, 0.02886304f, -0.01402839f, 0.00840917f, 0.01362401f, -0.05597973f, 0.02680860f, 
    -0.04980773f, -0.02584705f, -0.05618919f, 0.00290906f, 0.05571928f, 0.08537164f, 0.20025352f, -0.01047656f, 
    0.08751558f, 0.00836227f, 0.06683180f, -0.00769030f, 0.01196099f, -0.01647427f, -0.06009833f, 0.06335378f, 
    0.00507309f, -0.00769410f, -0.03441370f, -0.00607961f, -0.00252980f, 0.05928177f, 0.00962716f, -0.02745610f, 
    0.16582750f, -0.18198815f, 0.08291569f, 0.01999092f, -0.11252955f, 0.03794606f, 0.02417865f, -0.06576061f, 
    -0.05055427f, 0.02939152f, 0.00189424f, -0.03317905f, -0.02886164f, 0.00152187f, -0.03163285f, -0.03926081f, 
    0.04538304f, -0.02222151f, -0.02587216f, -0.00839612f, 0.16619831f, 0.07383883f, 0.17045189f, -0.08327791f, 
    0.10493317f, -0.01337728f, 0.07148502f, -0.04358895f, -0.04208850f, -0.02917868f, 0.01708919f, 0.05903239f, 
    0.01761576f, -0.03308866f, -0.04022618f, 0.01455367f, -0.00597120f, 0.00623782f, 0.05459127f, -0.07680245f, 
    -0.04836412f, -0.07289229f, 0.12159193f, 0.07662654f, -0.04607284f, 0.10732788f, -0.02377295f, -0.01940884f, 
    0.05749296f, 0.00437278f, -0.06867233f, -0.01931366f, -0.04301705f, 0.00058408f, -0.09135965f, 0.03857023f, 
    -0.05075147f, 0.02950750f, -0.06532918f, -0.03093241f, -0.11659990f, 0.05296205f, 0.05773838f, -0.06791159f, 
    0.08313560f, -0.08228169f, 0.02448178f, -0.04643933f, 0.01036760f, 0.00405568f, -0.06291046f, 0.03824449f, 
    -0.06433161f, 0.00080423f, -0.00816807f, 0.01066384f, 0.00227297f, 0.02499389f, 0.01749446f, 0.02871812f, 
    -0.04949515f, -0.10087346f, -0.23291163f, -0.15550427f, -0.14622496f, -0.03293025f, -0.06985959f, -0.06063196f, 
    -0.04678845f, -0.04933736f, -0.09042096f, 0.01463179f, -0.03504888f, -0.06228322f, -0.06558720f, 0.00736133f, 
    0.05615000f, -0.02098250f, -0.01667575f, 0.06953219f, 0.11882336f, -0.12440707f, 0.07230714f, -0.03405058f, 
    0.07009246f, -0.01902397f, 0.00850440f, -0.04252380f, -0.04369434f, -0.02295007f, -0.01964837f, 0.03436078f, 
    -0.04214986f, 0.00205660f, 0.00613204f, -0.05814721f, 0.03685733f, -0.01431560f, 0.04538035f, -0.05031978f, 
    0.12710561f, 0.01514414f, 0.10424764f, -0.03526107f, 0.06595264f, -0.02892957f, 0.04665383f, -0.04798478f, 
    0.03299822f, -0.01856216f, 0.01103725f, 0.02947341f, 0.01378684f, -0.02822766f, -0.01371729f, 0.01174981f, 
    -0.01292180f, -0.02969464f, -0.01932725f, -0.04265637f, 0.08448365f, -0.18293256f, 0.17591985f, 0.01020656f, 
    0.06767207f, -0.04614234f, 0.09975561f, -0.01262228f, 0.07242323f, 0.02561505f, 0.06269172f, 0.04187837f, 
    -0.07567360f, -0.00077890f, -0.01396460f, -0.03565473f, -0.00280283f, 0.05109394f, -0.02803381f, -0.04728951f, 
    -0.04040878f, -0.11205083f, -0.16160582f, -0.06300544f, -0.15366839f, 0.00836445f, -0.05694861f, 0.01820471f, 
    -0.03301397f, -0.12756580f, -0.02224484f, -0.05564871f, -0.04044382f, 0.05715291f, -0.05795149f, 0.05518582f, 
    -0.03349344f, -0.03782415f, 0.00954123f, -0.04832053f, 0.11514036f, 0.01302163f, -0.00474896f, -0.03878991f, 
    -0.01205486f, 0.01905845f, 0.00041898f, -0.02630073f, -0.04494402f, 0.01158203f, 0.02545301f, -0.01158510f, 
    -0.04427869f, -0.01161990f, -0.00612384f, -0.03361357f, -0.06351831f, 0.02447370f, 0.01705024f, -0.00540856f, 
    -0.15152432f, 0.01230962f, -0.14495991f, -0.01901098f, -0.06515016f, -0.04955104f, -0.02564988f, -0.02559648f, 
    -0.00327795f, -0.06359062f, 0.00016684f, 0.01880627f, -0.00718761f, 0.00880525f, -0.04712886f, 0.01068285f, 
    -0.05747443f, -0.01337971f, -0.00486452f, -0.04624134f, -0.00083043f, 0.07415603f, -0.13044629f, -0.03679240f, 
    0.00646919f, -0.00670322f, -0.10676765f, -0.04207358f, -0.03387380f, -0.03109313f, -0.06032521f, 0.04366453f, 
    0.01640427f, 0.02021824f, -0.06484260f, 0.02355323f, -0.03012947f, -0.02775896f, 0.00756305f, -0.01117856f, 
    0.08616342f, 0.04997677f, 0.07680006f, 0.10062995f, 0.07038469f, 0.07218007f, 0.05335962f, -0.00544410f, 
    0.03102040f, -0.00146194f, -0.04799180f, 0.00195575f, 0.00987367f, 0.03911275f, 0.00845707f, 0.01156361f, 
    0.04838416f, -0.03621028f, 0.00345295f, 0.02591138f, 0.06836846f, -0.08561546f, 0.07234558f, -0.01040963f, 
    -0.04822418f, 0.01721213f, -0.02677209f, -0.02610195f, -0.08159054f, 0.02978010f, -0.04621644f, -0.05468205f, 
    -0.04182807f, -0.00627097f, -0.03336968f, -0.00074638f, 0.01946499f, -0.02333975f, -0.03240927f, -0.06200209f, 
    0.09988823f, 0.05217590f, -0.17468947f, -0.03754172f, -0.03472269f, 0.00227936f, -0.07762511f, 0.01626831f, 
    -0.03633844f, -0.08775343f, -0.01269808f, 0.00739748f, -0.01698689f, 0.06381101f, -0.06987529f, -0.00383251f, 
    -0.04316733f, -0.03562858f, -0.01008897f, -0.02874173f, 0.15887247f, -0.03010749f, 0.10775416f, -0.00991843f, 
    0.15977333f, -0.02242365f, 0.01957447f, 0.02352468f, -0.01986577f, 0.02315412f, 0.02471130f, -0.00653737f, 
    -0.01910599f, 0.02221981f, -0.00900781f, -0.04886470f, 0.00279932f, 0.02979910f, -0.01405680f, -0.00050435f, 
    0.02069165f, 0.03718805f, -0.12719657f, 0.06650980f, 0.18621479f, -0.07774820f, -0.11143930f, 0.00796211f, 
    -0.00394733f, -0.00345112f, -0.03964502f, 0.03192607f, -0.09199686f, 0.00308205f, -0.05685214f, 0.01931826f, 
    0.00444160f, -0.07410967f, -0.01066135f, -0.04153402f, -0.20438814f, 0.13396555f, 0.06349066f, 0.00296107f, 
    0.07308875f, -0.01068854f, -0.01248459f, -0.04713453f, 0.06997997f, 0.00812541f, -0.03562193f, 0.04413656f, 
    -0.01740305f, 0.00864688f, -0.08057392f, 0.07460789f, 0.00115397f, 0.04274076f, -0.02014307f, 0.00103870f, 
    -0.02269291f, 0.09163627f, 0.07627294f, 0.02227458f, 0.10136301f, 0.06158051f, 0.01476745f, -0.05189569f, 
    0.03951320f, -0.01281307f, 0.00210596f, 0.02515246f, 0.07515314f, -0.01781512f, -0.03407422f, -0.01942895f, 
    -0.05474059f, -0.01410391f, -0.01942046f, 0.00286834f, 0.11572818f, 0.08908615f, 0.13735609f, 0.09400302f, 
    0.19938056f, 0.03804573f, 0.10735141f, -0.04545850f, -0.01315227f, 0.04940495f, -0.00615154f, 0.01575535f, 
    0.00654408f, 0.00563098f, 0.00849800f, 0.05101727f, 0.00793254f, 0.00453303f, 0.03514065f, 0.05572831f, 
    -0.08092561f, -0.01755780f, -0.00603823f, 0.05972700f, 0.08810045f, 0.08059427f, -0.09588987f, -0.08684535f, 
    0.04568153f, 0.01393786f, -0.00836895f, 0.01416154f, 0.00564698f, -0.07200345f, -0.09580397f, 0.01645004f, 
    -0.08065109f, 0.02093798f, 0.01139936f, -0.01153556f, 0.07095692f, -0.01586194f, 0.09554674f, 0.00916566f, 
    0.02848609f, 0.04359224f, -0.00113215f, -0.00391436f, 0.00172149f, 0.00510016f, -0.02595116f, 0.02791995f, 
    0.02268786f, -0.00861910f, -0.04230482f, -0.02903127f, -0.00232896f, -0.03917976f, 0.01757484f, -0.03290001f, 
    -0.21140346f, 0.11483983f, -0.03701417f, -0.04543689f, -0.08862260f, 0.00125471f, -0.00230257f, -0.06675141f, 
    0.01174019f, 0.01444648f, -0.04606505f, 0.00320050f, -0.03100603f, -0.03857823f, -0.03725104f, -0.01804020f, 
    -0.03324822f, 0.02643932f, -0.02553402f, -0.02718971f, 0.06845907f, 0.08851361f, -0.00251295f, -0.02118186f, 
    0.05413568f, 0.02960272f, -0.04338978f, -0.05600974f, -0.03717677f, 0.01305039f, 0.01130798f, -0.01870651f, 
    0.00986843f, -0.00843110f, -0.00864297f, -0.05288330f, 0.03130941f, 0.02164434f, -0.02404105f, 0.01019328f, 
    0.02124007f, 0.07973728f, 0.12194064f, 0.02952326f, 0.12277357f, 0.00253860f, 0.03405260f, 0.01530344f, 
    0.00234362f, -0.01363749f, -0.03123091f, 0.00476103f, -0.07625438f, -0.00910127f, -0.02023094f, -0.02785434f, 
    0.02834810f, 0.03733348f, -0.00603408f, -0.00530450f, 0.09209080f, -0.15779366f, 0.08577128f, 0.03082102f, 
    -0.10510962f, 0.04993170f, -0.01029033f, -0.04969496f, -0.01583218f, 0.01996217f, 0.00113581f, -0.03902078f, 
    -0.02336180f, -0.03334106f, -0.06441076f, -0.04568680f, 0.04702991f, 0.00100229f, 0.02000233f, -0.03102380f, 
    0.06086535f, 0.09240437f, -0.15677136f, -0.06705707f, 0.05767953f, -0.03102087f, -0.07886329f, -0.04271668f, 
    0.00715285f, 0.03312979f, -0.09049576f, 0.01134108f, 0.03832048f, 0.00608385f, -0.00835586f, -0.07181298f, 
    0.03317121f, 0.01017181f, -0.00644209f, 0.05333661f, 0.00521967f, 0.08629407f, 0.14993447f, 0.10388497f, 
    0.09931701f, 0.06002197f, 0.04274918f, 0.01174696f, 0.05541331f, -0.05770342f, -0.03244569f, 0.00608864f, 
    -0.01283421f, 0.01025364f, -0.04671592f, 0.02914168f, -0.02052598f, 0.02551283f, -0.00198047f, -0.05894775f, 
    0.11116976f, -0.37154409f, 0.05272424f, -0.05936304f, -0.16227619f, 0.08556954f, -0.01749310f, -0.01931323f, 
    -0.01242908f, -0.09016446f, -0.00543401f, -0.07665837f, -0.03608222f, -0.02370389f, -0.06567378f, 0.03356045f, 
    0.09206045f, -0.03961560f, -0.05805312f, -0.06931771f, 0.02267059f, 0.09877539f, 0.02439632f, 0.00080462f, 
    0.04630063f, -0.00361096f, -0.02261487f, -0.05960121f, -0.00350544f, 0.00367926f, 0.00333861f, -0.04093595f, 
    -0.02583505f, 0.02381033f, -0.07332089f, 0.03115379f, -0.06800702f, -0.03749702f, -0.01449377f, -0.02004215f, 
    -0.34585688f, 0.15882352f, 0.05476882f, -0.10135193f, -0.10354014f, -0.00035342f, -0.04219579f, -0.02554716f, 
    0.00155470f, -0.07032967f, -0.04056653f, 0.02446798f, -0.04217911f, -0.00292357f, -0.02051112f, -0.01223433f, 
    0.04889611f, 0.03340121f, 0.00973556f, 0.00323300f, -0.23187715f, 0.06281928f, 0.05459802f, -0.07917736f, 
    -0.15770376f, -0.01041284f, -0.06182436f, 0.01527452f, -0.03028564f, -0.06374252f, 0.02757039f, 0.00397274f, 
    -0.04467020f, -0.02421079f, -0.02052717f, -0.01545097f, 0.01394619f, -0.00284376f, -0.02853704f, -0.03172923f, 
    -0.02035133f, -0.00409293f, 0.12491457f, 0.05748774f, 0.09268743f, -0.10290226f, -0.04728941f, 0.00017112f, 
    0.00940213f, 0.05330872f, -0.04623589f, -0.04942612f, -0.04181282f, -0.00494428f, 0.05107392f, 0.03106775f, 
    -0.03309008f, -0.02119496f, 0.02678951f, -0.03588409f, 0.00470445f, 0.01709594f, -0.15871519f, -0.16182205f, 
    -0.04133627f, 0.10131560f, 0.01074183f, -0.01831021f, -0.05736579f, -0.07007578f, -0.02765357f, 0.03650214f, 
    0.06209531f, 0.02421475f, -0.08817752f, 0.01126943f, 0.05818572f, 0.00149789f, -0.05585438f, 0.04497377f, 
    -0.22107607f, -0.02412656f, 0.12846990f, -0.14951685f, -0.07353042f, -0.00562352f, 0.05202943f, -0.03322514f, 
    -0.04642125f, -0.08406130f, 0.04943172f, 0.01773934f, 0.02359125f, 0.09262037f, -0.00156211f, 0.02725054f, 
    0.02309877f, -0.10072786f, -0.21336035f, 0.04377452f, -0.12848797f, -0.11957321f, 0.15904829f, 0.02475896f, 
    0.14849873f, -0.04055481f, -0.01826179f, 0.01053923f, -0.07280733f, -0.00702702f, -0.00947010f, -0.01952305f, 
    0.01095045f, 0.07341439f, 0.00672552f, 0.00048103f, -0.04620855f, 0.04561022f, -0.04568872f, 0.11260997f, 
    -0.11979555f, -0.12634233f, 0.18152624f, 0.01447466f, 0.14594509f, -0.00513048f, -0.03037385f, 0.08794788f, 
    -0.04334329f, 0.02002546f, -0.00336415f, -0.01228731f, -0.00716807f, -0.03678941f, 0.04520521f, -0.03497785f, 
    -0.00673887f, 0.02342315f, -0.03987438f, 0.06170411f, 0.07405384f, 0.13184306f, -0.12479043f, 0.04716659f, 
    0.03343847f, 0.05281526f, -0.01874009f, -0.05127207f, -0.06859103f, 0.03392443f, 0.04797830f, -0.01877078f, 
    0.01585564f, 0.00559028f, 0.02439023f, 0.01773909f, 0.00951023f, -0.03351177f, 0.03838769f, 0.02454365f, 
    0.06655876f, 0.07391916f, -0.05999424f, 0.05529060f, 0.08588729f, -0.06836350f, -0.08608569f, -0.16056561f, 
    -0.05039453f, 0.02463444f, -0.05377642f, -0.03804640f, -0.03926941f, -0.04944149f, 0.01798978f, 0.03154345f, 
    0.04327616f, -0.00568586f, 0.06641631f, -0.01452381f, 0.01273184f, 0.23083675f, 0.01055043f, -0.02848377f, 
    0.02235606f, -0.00309611f, 0.05004159f, -0.05497820f, -0.11098860f, -0.09263215f, 0.10340521f, 0.01636828f, 
    0.01234553f, -0.00886115f, -0.14234823f, -0.07183640f, 0.03791054f, 0.06949046f, 0.02283382f, -0.13454048f, 
    0.05923339f, 0.15634649f, -0.07894833f, 0.07080703f, 0.01831813f, -0.03488152f, -0.03683883f, -0.03415890f, 
    -0.11787407f, 0.00220473f, 0.01874147f, 0.00336316f, 0.01808338f, -0.00596491f, 0.02070917f, -0.01243046f, 
    -0.04287611f, -0.03958878f, 0.05208875f, -0.02462838f, -0.17641675f, 0.01148536f, 0.11505889f, -0.10503014f, 
    -0.12060941f, 0.01519227f, -0.03433011f, -0.00453167f, -0.03725725f, -0.11795607f, 0.02462597f, 0.00708384f, 
    0.06297816f, 0.08319522f, 0.00061255f, 0.01391828f, 0.00233863f, -0.00533443f, -0.27759665f, 0.02047869f, 
    0.09223112f, 0.10261870f, -0.08704412f, -0.06056102f, 0.01367001f, -0.06911714f, -0.02278884f, 0.06451950f, 
    -0.04614682f, -0.02253110f, 0.07761669f, 0.01952274f, 0.00003756f, -0.04174352f, 0.03532808f, -0.02437858f, 
    -0.04153275f, -0.10559350f, 0.02730728f, -0.05793365f, -0.04412388f, 0.16170025f, -0.11850504f, 0.07789622f, 
    -0.01179998f, 0.06487595f, 0.00975237f, -0.07267095f, 0.00381147f, -0.03880452f, -0.20428018f, 0.03480588f, 
    0.02833243f, 0.03548450f, 0.08286300f, -0.00162497f, -0.03588086f, -0.04590885f, 0.04783596f, -0.11599404f, 
    -0.02513148f, -0.02352323f, -0.06603704f, 0.00373440f, 0.00210692f, 0.10225359f, -0.00090587f, -0.05620763f, 
    0.03040762f, -0.00596002f, 0.03595437f, -0.00509324f, 0.04496661f, -0.00911125f, 0.03144312f, -0.01498520f, 
    0.07567607f, 0.02766262f, 0.08081685f, -0.07892489f, 0.02645827f, -0.07576598f, 0.05690404f, 0.04880694f, 
    0.04425956f, -0.02902964f, 0.01193310f, -0.03641713f, -0.04529757f, 0.00709707f, 0.06499055f, 0.02069976f, 
    -0.04232452f, -0.01620123f, 0.01198695f, -0.00374711f, -0.05380944f, -0.03519717f, 0.04681574f, 0.02253869f, 
    0.04539974f, -0.10751341f, 0.15019055f, -0.05465023f, 0.10556152f, 0.00591568f, 0.03036609f, 0.02205699f, 
    -0.05911001f, -0.03172527f, 0.01807021f, -0.04737270f, 0.04770752f, -0.00751308f, 0.01039535f, 0.03285247f, 
    -0.03852995f, 0.02872665f, -0.16538450f, 0.04964319f, -0.08629160f, -0.07908888f, 0.02862179f, 0.02399838f, 
    -0.02074195f, -0.03638819f, 0.01173105f, 0.03662139f, -0.00249897f, -0.02274347f, -0.01881020f, -0.02359287f, 
    -0.03233609f, -0.03432227f, 0.02256673f, 0.05588553f, 0.03255539f, -0.01274307f, 0.01097013f, -0.00306009f, 
    -0.14302999f, -0.04507237f, -0.09736746f, -0.06677140f, -0.03656830f, 0.07278939f, -0.03294914f, -0.12116981f, 
    0.02394483f, -0.08752695f, 0.00736450f, 0.01678340f, 0.04208720f, -0.04463327f, 0.06141518f, -0.06338058f, 
    0.04393830f, -0.06535811f, 0.03568893f, -0.03742655f, -0.21966268f, -0.06782093f, 0.01292879f, -0.29105306f, 
    0.06605861f, 0.10548632f, -0.00185096f, -0.02923215f, 0.02395726f, -0.11137954f, 0.06719451f, 0.04502760f, 
    0.07486445f, 0.00445125f, 0.02327923f, -0.03238070f, -0.00583731f, 0.00517612f, -0.00085535f, -0.11251533f, 
    -0.05069509f, -0.05116265f, -0.11754307f, -0.06461103f, 0.04771722f, 0.03989778f, -0.00898267f, -0.04655963f, 
    0.00903956f, -0.06110578f, 0.11453281f, 0.01556279f, 0.02659290f, 0.06149075f, 0.00509843f, -0.03885300f, 
    0.05477670f, 0.07525685f, 0.04634886f, -0.02373994f, -0.08207914f, 0.11827088f, -0.05270988f, -0.05917656f, 
    -0.16397725f, 0.00203509f, -0.00905504f, -0.01928713f, -0.00932251f, -0.00768907f, 0.07680808f, -0.03991684f, 
    0.01215660f, 0.05615846f, -0.02684520f, -0.01985130f, -0.01862228f, -0.10040372f, 0.00287296f, 0.09180614f, 
    0.03391724f, -0.02989301f, -0.05352953f, -0.00363302f, 0.04463088f, -0.02109031f, -0.00767160f, -0.02368680f, 
    -0.04417232f, -0.02628193f, 0.00967854f, -0.00232790f, -0.03095810f, -0.00540016f, 0.03102922f, 0.00456749f, 
    -0.01953761f, -0.01980596f, 0.04572641f, 0.02597216f, -0.05945344f, 0.05530214f, 0.14252783f, -0.09549168f, 
    -0.03795870f, -0.02459094f, -0.03103990f, 0.02095120f, -0.00609517f, 0.06205659f, 0.02253849f, -0.00395242f, 
    0.05154038f, -0.01589246f, 0.04210014f, -0.01482160f, -0.02221966f, -0.08087910f, 0.04958151f, -0.06180023f, 
    0.17584300f, 0.10273429f, -0.05832839f, 0.03311908f, 0.11180407f, 0.05321715f, -0.00021791f, -0.05349148f, 
    -0.03287483f, -0.02856533f, 0.04934560f, 0.07000270f, 0.04745608f, -0.00352398f, -0.08805028f, -0.05329347f, 
    0.03976701f, 0.08193062f, 0.04227120f, 0.01436532f, -0.06372616f, -0.19301549f, -0.08533909f, -0.05222474f, 
    -0.12226722f, 0.07968531f, -0.02913205f, 0.00720375f, 0.01564115f, 0.08051821f, -0.00483266f, 0.09428615f, 
    -0.05466905f, 0.10212263f, 0.00284187f, 0.05814848f, -0.00178901f, -0.12814911f, -0.00479599f, -0.06535056f, 
    -0.16376068f, -0.14388055f, 0.04707521f, -0.08036130f, -0.15066332f, -0.00938839f, 0.03122383f, -0.01681487f, 
    -0.04358499f, -0.04622183f, -0.00361100f, 0.02121746f, -0.05361007f, 0.02295836f, 0.00862108f, -0.04082195f, 
    0.04305585f, -0.04210327f, -0.07348871f, 0.03156288f, 0.08073416f, 0.03994643f, 0.01257375f, 0.07397795f, 
    0.11570697f, -0.08291294f, -0.03235188f, -0.01944481f, -0.04894448f, 0.02135474f, -0.04235962f, -0.00019985f, 
    -0.08674291f, -0.08467633f, 0.00702499f, -0.02182423f, -0.01387610f, 0.02585076f, 0.06753555f, 0.01678876f, 
    -0.10146078f, 0.14215852f, -0.19183502f, 0.01198873f, -0.14956819f, -0.03993170f, -0.05415031f, -0.02419430f, 
    -0.10018888f, -0.04476039f, 0.07234953f, -0.02861893f, -0.03163786f, -0.00250055f, 0.03211903f, -0.04410802f, 
    -0.00646541f, -0.05934207f, 0.05244946f, 0.05355765f, -0.15621500f, 0.05255571f, 0.13232106f, -0.14598550f, 
    -0.13637656f, -0.04477103f, 0.01735857f, -0.08806212f, -0.03119412f, -0.04125599f, 0.03536441f, 0.02372243f, 
    0.03811255f, -0.03366321f, -0.03178990f, -0.06829039f, 0.01092635f, -0.13261181f, -0.07409502f, 0.01448699f, 
    0.07559729f, 0.13978375f, -0.10046107f, 0.07841904f, 0.07069398f, 0.03985142f, -0.00594000f, -0.04588228f, 
    -0.07514586f, 0.02955721f, -0.00900034f, 0.05942123f, -0.02374878f, 0.01439866f, 0.01410256f, -0.00046828f, 
    -0.04518835f, 0.04107496f, 0.02754374f, 0.01071719f, 0.05269996f, -0.25262040f, -0.18375196f, 0.12834050f, 
    0.14777812f, 0.00550677f, 0.04688175f, -0.01685014f, -0.03881239f, 0.00973422f, -0.04290901f, 0.02579715f, 
    -0.01920933f, -0.04962367f, 0.03903999f, 0.00079969f, 0.05497216f, 0.00595048f, 0.07716506f, -0.01616706f, 
    0.05514687f, 0.07343062f, -0.00055065f, -0.03003765f, 0.04004499f, -0.00400610f, -0.01748215f, -0.06298551f, 
    -0.02152517f, -0.03845083f, -0.02927722f, 0.00178573f, -0.00683117f, -0.07742739f, 0.01827969f, -0.06168567f, 
    0.04021944f, 0.02118117f, 0.03025458f, 0.00403260f, -0.10938204f, -0.04737604f, 0.13243629f, 0.00097762f, 
    -0.02708003f, -0.03464923f, -0.00166754f, 0.07963931f, -0.11965775f, 0.00554025f, 0.05005054f, -0.05204929f, 
    0.00511090f, -0.03337938f, -0.00586791f, 0.03410031f, -0.07839289f, -0.09901357f, 0.05349984f, -0.00856066f, 
    0.10473394f, -0.03187045f, 0.09423579f, -0.01653546f, 0.10942844f, -0.05282944f, 0.02524634f, 0.00922809f, 
    -0.01805119f, 0.02060931f, -0.02750159f, 0.02446929f, 0.06052729f, -0.02968165f, -0.04158623f, 0.02230443f, 
    0.00893874f, -0.01214895f, -0.02053812f, 0.05228560f, -0.18494128f, 0.13597745f, 0.06140687f, -0.12156034f, 
    -0.01499152f, 0.04616234f, -0.04656830f, 0.02400493f, 0.03195152f, 0.02806742f, 0.02081557f, -0.03657942f, 
    -0.12574293f, 0.04963940f, 0.04760235f, -0.06731282f, -0.02150903f, 0.01183172f, -0.05133596f, 0.08572733f, 
    -0.10090683f, 0.09218552f, -0.26360801f, 0.06190943f, -0.06097216f, 0.01872475f, -0.04589215f, -0.08269713f, 
    -0.06011332f, -0.01029823f, 0.04589425f, 0.00600499f, 0.04374979f, -0.08644672f, 0.06460971f, -0.00076784f, 
    -0.01044817f, -0.04595469f, 0.02972673f, 0.01096477f, -0.01285167f, 0.05007620f, 0.11898606f, 0.00539642f, 
    -0.02481831f, -0.09922860f, -0.01748987f, 0.04626154f, -0.01182320f, 0.02553485f, 0.02556120f, -0.01483932f, 
    -0.03131920f, -0.05925511f, -0.00979597f, -0.06455944f, -0.01767848f, -0.08318627f, 0.07246677f, -0.01580426f, 
    -0.02943161f, -0.04569867f, -0.03161382f, 0.00252682f, 0.14396234f, 0.06699902f, 0.06111822f, -0.04825301f, 
    -0.02276783f, 0.00009030f, 0.05472383f, 0.07547609f, -0.07237420f, 0.07851945f, -0.01664896f, -0.04663194f, 
    -0.00170626f, 0.04720741f, 0.06224364f, -0.01784907f, 0.00452289f, -0.08777750f, 0.15098512f, -0.04665288f, 
    0.04415394f, -0.02772242f, 0.00468537f, -0.00591191f, -0.03881740f, -0.05872064f, 0.01057317f, 0.00105633f, 
    0.06713951f, -0.01700322f, 0.04948180f, -0.00293784f, -0.03675236f, 0.00078892f, -0.06512032f, 0.06088406f, 
    -0.03574165f, 0.05869781f, 0.01997523f, -0.03195692f, 0.02377268f, 0.04074863f, -0.00905438f, 0.09888028f, 
    0.00490436f, 0.01302595f, 0.07306530f, -0.03534874f, -0.09023651f, -0.10234617f, 0.09554935f, -0.00582068f, 
    -0.01608018f, 0.05495362f, 0.03822275f, -0.01840015f, 0.01762296f, 0.06103159f, -0.02494625f, 0.04025638f, 
    0.07894095f, -0.08518880f, -0.08492980f, 0.05996444f, 0.05097036f, -0.04692984f, 0.01348598f, 0.02509984f, 
    -0.09978359f, -0.00205325f, 0.08815025f, -0.01493600f, 0.06536213f, 0.03872343f, 0.03985997f, 0.00569526f, 
    0.15186860f, -0.01409017f, -0.14805149f, 0.08389433f, 0.12255987f, 0.01067270f, 0.02099800f, -0.03399301f, 
    -0.03047965f, -0.03480982f, -0.05246581f, -0.01770461f, -0.03108959f, -0.04627854f, 0.05994832f, -0.03308758f, 
    -0.00819482f, 0.00603752f, 0.09208086f, -0.01444352f, 0.08991400f, -0.06663829f, 0.05463125f, 0.05350386f, 
    0.06680553f, -0.01382897f, 0.02408307f, 0.01001865f, -0.06416111f, -0.03835772f, -0.04449387f, -0.00570664f, 
    0.04595112f, 0.02514301f, -0.06829004f, 0.04152524f, -0.02271475f, -0.01338561f, 0.01132749f, 0.10530730f, 
    0.00641109f, -0.01886613f, -0.09518518f, 0.13292015f, 0.05888908f, 0.07799774f, 0.01589628f, -0.03342530f, 
    -0.03723029f, -0.05209398f, 0.06476734f, 0.01049561f, -0.00440958f, 0.03372076f, 0.00862720f, -0.02724467f, 
    0.03490974f, 0.00649050f, 0.07611527f, -0.03991354f, -0.12140493f, -0.03166952f, 0.01316351f, 0.03126847f, 
    0.09350490f, 0.07550143f, 0.00187397f, -0.06472608f, -0.01627363f, -0.07388292f, 0.10741258f, 0.03177694f, 
    0.03295297f, -0.03057476f, 0.10154685f, -0.06006344f, 0.03864944f, 0.01370705f, 0.06963552f, -0.08095636f, 
    -0.10460249f, -0.18928924f, -0.05040298f, -0.16146189f, -0.16809887f, 0.00330323f, -0.06268457f, 0.00445437f, 
    -0.04019421f, 0.00295295f, 0.05743146f, 0.01057678f, -0.00192815f, 0.00898443f, 0.09028272f, -0.00592992f, 
    -0.03529947f, -0.02993853f, 0.01877776f, -0.03723536f, -0.05462325f, 0.00402186f, -0.05008603f, 0.01408414f, 
    0.01975654f, -0.01366410f, -0.05353215f, -0.05921137f, -0.06062299f, 0.01843690f, -0.00557200f, 0.02926990f, 
    0.01113102f, -0.03641052f, -0.00730056f, -0.08102120f, -0.04080340f, -0.03352002f, -0.01618333f, -0.09356318f, 
    0.03533589f, -0.07564379f, -0.01091317f, 0.06817219f, 0.13296056f, 0.02274922f, 0.02924597f, -0.08064235f, 
    -0.03373260f, 0.00479719f, 0.01495723f, 0.00076345f, 0.02069104f, 0.02206866f, 0.10075805f, -0.12492441f, 
    0.04799605f, 0.00676042f, 0.03416916f, -0.07655747f, -0.09761792f, -0.07035809f, -0.14044181f, -0.25800630f, 
    -0.21146725f, -0.04641661f, 0.01028428f, -0.04819161f, -0.09261522f, -0.00903053f, 0.03338947f, 0.02804623f, 
    0.02362422f, 0.09694377f, 0.00880522f, -0.03176602f, -0.00925788f, -0.02631037f, -0.28154710f, -0.07428243f, 
    -0.10814898f, -0.06609762f, -0.02248492f, -0.05251219f, -0.06614131f, -0.01230714f, 0.02016544f, -0.10643937f, 
    -0.08421047f, -0.11927768f, 0.03067841f, 0.00169124f, 0.06264418f, -0.00776734f, -0.03574136f, -0.06543843f, 
    0.06522845f, -0.01256488f, -0.10140372f, -0.07633346f, 0.05656626f, 0.04976638f, -0.00826186f, 0.01180732f, 
    -0.14218320f, -0.04752291f, -0.00848788f, -0.02950302f, -0.04350360f, 0.04132135f, 0.06071434f, 0.00786727f, 
    0.02582264f, 0.02726652f, 0.04589128f, 0.01346074f, 0.02204302f, -0.08264483f, 0.08154662f, -0.02896169f, 
    0.02736475f, -0.00689497f, 0.07541913f, 0.02273445f, 0.08305274f, -0.05194658f, -0.07440206f, -0.04476466f, 
    -0.07806727f, -0.01362055f, -0.00108558f, -0.02138676f, -0.05399279f, -0.01782926f, -0.01278716f, -0.03119566f, 
    -0.00073595f, 0.05657380f, 0.06843517f, -0.01512464f, -0.14100784f, -0.25626361f, -0.00209960f, -0.18448211f, 
    -0.20547405f, 0.04985133f, -0.04300525f, -0.03637545f, -0.04440066f, 0.04196284f, -0.03873555f, 0.06150929f, 
    0.03818472f, 0.05434373f, 0.01591654f, -0.00038467f, -0.08001233f, -0.01148685f, 0.02267839f, -0.04265285f, 
    -0.16792937f, 0.00569792f, -0.22737598f, -0.25496185f, -0.16678056f, -0.01242493f, -0.09356129f, -0.12064321f, 
    -0.00009253f, -0.04187574f, 0.08604559f, 0.03095491f, 0.09916517f, -0.07526734f, 0.02156111f, -0.03842108f, 
    -0.03409247f, -0.15522897f, -0.01297277f, 0.06289380f, 0.06624330f, -0.07237429f, 0.09603669f, 0.00767789f, 
    0.14583026f, -0.08634016f, -0.02607378f, 0.04091436f, -0.06740876f, 0.05215650f, -0.02932493f, -0.05229412f, 
    -0.06967533f, -0.09047966f, -0.00101935f, -0.01367878f, -0.02727592f, 0.03556009f, 0.02137583f, 0.02930390f, 
    0.06294582f, 0.10770674f, -0.02789741f, 0.03139811f, -0.05781469f, -0.06858069f, 0.07379055f, -0.00242703f, 
    -0.05482468f, -0.01614952f, 0.04449017f, 0.04967209f, 0.05470559f, 0.00108102f, 0.03257263f, -0.05542280f, 
    0.01518261f, -0.05392825f, 0.08739566f, 0.04670095f, -0.06379169f, 0.14879289f, -0.03841693f, -0.10255192f, 
    -0.09942334f, 0.04505375f, -0.08029402f, -0.05646653f, 0.06681477f, -0.00700975f, -0.00091387f, -0.01204291f, 
    0.03378136f, 0.08284076f, -0.02005619f, 0.05791218f, -0.00875807f, -0.03876057f, -0.02729937f, 0.01611243f, 
    -0.16185392f, 0.00255633f, 0.07562773f, -0.03635885f, -0.11365321f, 0.02463042f, 0.00519328f, 0.00809211f, 
    0.00164128f, -0.00959179f, 0.01852602f, 0.02341362f, 0.00744396f, -0.03368974f, -0.00080003f, -0.03012000f, 
    -0.04270337f, -0.10537244f, 0.03614752f, -0.01612544f, -0.02446244f, 0.03864233f, -0.08560608f, -0.04972472f, 
    0.02291786f, 0.06387045f, -0.04288498f, -0.03961257f, -0.04354934f, -0.05927871f, 0.04253042f, 0.00523701f, 
    -0.01667670f, 0.06384628f, -0.00526047f, 0.05413604f, 0.01287770f, -0.03624529f, -0.00501082f, 0.03416930f, 
    0.02139497f, -0.06494092f, -0.04560154f, -0.21081838f, -0.00265236f, 0.09906141f, 0.03115380f, -0.00998407f, 
    -0.02903098f, -0.03879127f, 0.01753061f, 0.03610652f, -0.03925318f, 0.10276070f, -0.06051300f, 0.10378376f, 
    0.00401864f, 0.06180640f, -0.06174779f, 0.06134336f, -0.21518038f, -0.04205687f, 0.16613752f, 0.00146076f, 
    0.04514461f, -0.03940446f, -0.00687399f, -0.00282766f, -0.05531283f, -0.02606821f, 0.01754297f, 0.01564156f, 
    0.03103636f, -0.07197036f, 0.01749379f, -0.03507266f, 0.03259629f, 0.00867411f, -0.03502539f, 0.01864561f, 
    0.13325416f, 0.02168286f, -0.06072790f, 0.10509177f, 0.04167847f, 0.00421565f, 0.04150140f, -0.05963582f, 
    -0.05099478f, -0.06054658f, 0.07008944f, -0.02320180f, -0.07194923f, 0.05583199f, 0.01823181f, -0.01839279f, 
    0.04763007f, 0.01182112f, 0.06906007f, 0.04159261f, -0.05653579f, -0.01003048f, -0.08639564f, -0.03402012f, 
    -0.05819008f, 0.01361569f, -0.02443549f, -0.08653680f, 0.01145339f, -0.03525233f, -0.00016225f, -0.00120398f, 
    0.03019562f, -0.04910564f, 0.01236778f, -0.06546380f, -0.00243577f, -0.09375031f, 0.02685631f, -0.09523250f, 
    0.13662747f, 0.09480792f, -0.13035107f, 0.07980233f, 0.06159948f, 0.00868458f, 0.04330707f, -0.07222809f, 
    -0.05579930f, -0.01340628f, 0.02134626f, -0.00764005f, -0.00238040f, -0.01925139f, 0.02282110f, 0.01326700f, 
    0.02263298f, -0.04207171f, 0.09624717f, -0.04001458f, 0.12562993f, 0.13233702f, -0.10393605f, 0.04666313f, 
    0.03439159f, -0.00475279f, 0.01518213f, -0.09142757f, -0.04607638f, -0.00224976f, -0.03179413f, 0.00726945f, 
    -0.02720569f, -0.04685019f, -0.01468115f, -0.02380539f, -0.00220843f, -0.00767150f, 0.02968975f, -0.04257473f, 
    -0.07061385f, 0.00821312f, -0.07121310f, 0.07783042f, 0.07721326f, 0.12758690f, 0.00128712f, -0.03784925f, 
    -0.04786112f, 0.14502333f, -0.03541588f, -0.01534427f, -0.01536793f, 0.00799235f, -0.05946557f, -0.01241610f, 
    -0.11725232f, 0.02161363f, -0.00127674f, -0.06254689f, 0.11298953f, 0.06068625f, -0.07477482f, -0.27265659f, 
    -0.39746559f, 0.03968022f, -0.01570056f, 0.01646179f, -0.07169998f, -0.02214397f, -0.06760778f, -0.00205992f, 
    -0.03529930f, 0.07421301f, 0.02412411f, -0.08658373f, 0.04341708f, -0.01272387f, 0.12941702f, 0.06139968f, 
    0.04637591f, -0.14057593f, -0.20724322f, 0.11296813f, 0.03607085f, -0.07805949f, 0.10232940f, -0.03403814f, 
    -0.04674235f, -0.04275733f, 0.01256923f, -0.09239406f, -0.08508115f, 0.02481575f, 0.03960165f, 0.06505024f, 
    0.02837051f, 0.01296748f, 0.07189385f, 0.14590813f, 0.13558228f, -0.12318830f, -0.06484181f, 0.14294468f, 
    0.02706065f, -0.05029283f, -0.02416342f, -0.03422663f, 0.03476270f, 0.05750372f, -0.00135384f, 0.00808229f, 
    0.06626911f, -0.08971690f, 0.04458181f, -0.09846003f, 0.01542904f, -0.01271268f, 0.04391837f, 0.02524632f, 
    0.21808232f, -0.02300305f, -0.13673732f, 0.06296447f, -0.00199093f, 0.01402498f, -0.01818296f, 0.00362426f, 
    0.02251491f, 0.04574172f, -0.00634934f, 0.03509138f, -0.02048629f, -0.02013967f, 0.00400608f, 0.01986255f, 
    0.00452182f, 0.01087129f, 0.00078221f, 0.00273079f, -0.16770621f, 0.03519386f, -0.10690720f, 0.10712827f, 
    -0.15281166f, 0.11837401f, 0.01028081f, -0.00374689f, 0.00660232f, -0.02460454f, -0.00633253f, 0.03811438f, 
    0.08963915f, 0.03391627f, 0.02657611f, -0.00959825f, -0.09547073f, 0.00078700f, -0.02005448f, -0.06755207f, 
    -0.02609337f, -0.22417122f, -0.02018981f, -0.02211696f, 0.01747384f, 0.07120931f, 0.04710889f, 0.01443606f, 
    0.02793349f, -0.00071430f, -0.08248843f, 0.01432438f, 0.00426214f, -0.01341120f, -0.02680514f, -0.00579615f, 
    0.03253792f, 0.01160099f, -0.09824739f, 0.09020325f, 0.51705521f, -0.03126913f, -0.19017623f, -0.02288585f, 
    -0.24869931f, -0.00336282f, 0.03557952f, 0.17823792f, 0.04431295f, -0.10090135f, -0.04650114f, -0.00957575f, 
    -0.00701707f, 0.00378992f, 0.03369395f, 0.04644538f, 0.11675943f, -0.00395691f, -0.00654069f, 0.15760547f, 
    -0.33346120f, 0.07200604f, 0.11277305f, 0.00307363f, 0.00555771f, 0.10860234f, -0.00120570f, -0.00537855f, 
    -0.00997524f, -0.12631641f, 0.00093287f, -0.01322833f, 0.02922629f, 0.04321800f, -0.00661555f, 0.01540221f, 
    0.01198353f, 0.03051706f, -0.14293860f, 0.01750409f, -0.04690881f, -0.12897593f, -0.07144536f, 0.16118443f, 
    0.02148332f, -0.06198056f, -0.02965225f, -0.03084483f, -0.02033380f, -0.01813343f, -0.05020430f, -0.01827894f, 
    -0.10539800f, -0.08958045f, 0.02411760f, 0.04613154f, 0.04845395f, -0.01635457f, 0.08466914f, 0.10510104f, 
    -0.23215458f, 0.14888410f, -0.14130364f, 0.04657333f, -0.11624467f, 0.01082807f, -0.01312795f, 0.04970089f, 
    0.03503228f, 0.01670482f, -0.00104015f, 0.02130833f, 0.04250956f, 0.01217428f, 0.10976122f, 0.06515439f, 
    0.00723111f, 0.12036350f, 0.04436139f, -0.02126600f, 0.06055197f, -0.32035232f, 0.17030707f, -0.27818745f, 
    -0.03666072f, 0.01113443f, 0.05067914f, 0.02200788f, 0.14379449f, 0.05499632f, -0.10161703f, -0.01826085f, 
    0.01561425f, -0.12720126f, -0.05299120f, 0.00380900f, 0.03365306f, 0.01396545f, -0.06030127f, 0.00018745f, 
    -0.00704559f, 0.07792623f, 0.16713162f, -0.29494575f, -0.15221672f, -0.05564421f, 0.00671053f, -0.06141928f, 
    -0.05004838f, 0.06225894f, -0.04720877f, -0.08289810f, -0.00500809f, -0.11175399f, 0.04147564f, 0.01267255f, 
    0.03578761f, 0.06168048f, -0.02503695f, -0.00290373f, 0.29366583f, -0.28287816f, 0.15157017f, 0.00188887f, 
    0.14080685f, -0.02121372f, -0.01830307f, 0.01486501f, 0.02883580f, 0.01477639f, 0.00927825f, -0.06095050f, 
    -0.07099879f, 0.01417048f, 0.09552517f, -0.04691060f, -0.00713650f, -0.05375923f, -0.04075141f, 0.05457633f, 
    0.19314589f, 0.06072878f, -0.03733663f, 0.07107406f, -0.04627963f, 0.01235517f, -0.02859307f, 0.05344971f, 
    0.03537201f, -0.04355923f, -0.00696627f, 0.06931552f, -0.00823390f, -0.02534883f, -0.03536290f, 0.08424195f, 
    -0.02909070f, -0.01841221f, 0.01388311f, 0.05438201f, -0.18935888f, -0.12162042f, 0.07955309f, 0.11406453f, 
    -0.09884231f, 0.03155992f, -0.02034393f, -0.02488677f, 0.08755419f, -0.04590274f, -0.05674458f, -0.04482436f, 
    0.03328940f, 0.08123702f, 0.05883656f, -0.01830959f, -0.06594903f, 0.00933647f, -0.04274171f, 0.06319283f, 
    0.01801958f, -0.30079654f, 0.01310253f, -0.08305617f, -0.06545707f, -0.00691226f, 0.07942525f, -0.04094990f, 
    0.03029406f, 0.01115146f, -0.12692742f, 0.01741648f, 0.01210983f, 0.06735440f, 0.02354779f, 0.08809208f, 
    0.04920825f, -0.00785361f, -0.03700580f, 0.00595714f, 0.02331609f, -0.18770145f, 0.16726905f, -0.17449437f, 
    -0.15799411f, -0.14346750f, -0.03867473f, -0.03708848f, -0.01013761f, 0.12797177f, 0.06071486f, 0.10715038f, 
    0.20445906f, -0.12416786f, -0.13241108f, 0.04432193f, 0.01318369f, 0.05037573f, 0.03155850f, -0.05622103f, 
    -0.15049100f, -0.12434516f, 0.06466153f, 0.04343164f, -0.22591034f, -0.02929061f, 0.02008039f, 0.12095996f, 
    -0.06913614f, 0.01814924f, -0.00905547f, -0.07968806f, -0.04521529f, -0.03218408f, -0.02282174f, -0.01095762f, 
    -0.09785603f, -0.03435754f, -0.02162803f, 0.00114034f, -0.34049928f, 0.06151978f, -0.03799279f, 0.08724729f, 
    0.02270712f, 0.10150340f, 0.00762300f, 0.00793309f, 0.00770104f, -0.02243440f, 0.03457343f, -0.03822784f, 
    -0.04863291f, 0.03259967f, 0.02831184f, 0.01265077f, -0.03645310f, 0.08849321f, -0.00256974f, 0.07834590f, 
    0.20209874f, -0.31148064f, 0.18207341f, -0.03420382f, 0.05646099f, -0.00524395f, 0.00505644f, 0.01490460f, 
    0.05299539f, -0.05438450f, 0.04716155f, -0.02722579f, 0.00879467f, -0.01379549f, -0.02836283f, -0.03692251f, 
    -0.01710304f, -0.03449513f, 0.00070436f, 0.02210395f, -0.04026148f, 0.04211215f, -0.23547800f, -0.00284407f, 
    -0.00452615f, 0.05621667f, 0.03781416f, -0.02671596f, 0.05415706f, 0.19457263f, -0.09801028f, -0.03022229f, 
    0.05430718f, 0.07449429f, 0.07704333f, 0.14164385f, -0.04385010f, -0.04828969f, -0.02204727f, -0.09141968f, 
    0.20646456f, 0.04614655f, -0.00650082f, -0.27954036f, -0.18534563f, 0.01576930f, 0.07907059f, 0.00868944f, 
    -0.04832290f, -0.08220654f, -0.03859032f, -0.04672458f, 0.02154463f, -0.02810570f, -0.02880455f, -0.08273744f, 
    0.03197769f, -0.08040031f, 0.00071861f, 0.00023131f, -0.33860576f, -0.03999732f, -0.08909796f, 0.04736523f, 
    0.16194421f, 0.02467748f, -0.00172649f, -0.00526023f, -0.07047863f, 0.10545351f, 0.04558847f, 0.03840222f, 
    -0.02125856f, -0.00988485f, -0.01406886f, -0.00542809f, -0.01719229f, -0.00717875f, -0.00517964f, 0.10170896f, 
    -0.27915946f, -0.23505566f, -0.08001719f, 0.23731144f, -0.07774521f, -0.05329068f, 0.05809238f, 0.08398683f, 
    -0.01314128f, -0.01970636f, -0.10720035f, 0.04323290f, 0.04517974f, 0.03283740f, -0.00360598f, 0.07352651f, 
    0.00475836f, 0.00226536f, 0.06182685f, -0.00125892f, 0.14707574f, -0.14161280f, 0.09660486f, 0.06551080f, 
    0.01260136f, 0.05129343f, -0.02837486f, 0.01926112f, -0.01508834f, -0.05819492f, -0.03359116f, 0.00640871f, 
    0.05770047f, 0.08635847f, 0.01976735f, -0.03685264f, 0.04758084f, -0.11890332f, -0.00969184f, -0.02215856f, 
    -0.53752851f, 0.19291176f, 0.15466112f, 0.00687829f, -0.08981968f, 0.08773044f, 0.06311372f, -0.04458847f, 
    -0.04696313f, -0.05168869f, -0.00971007f, -0.04246178f, -0.01043829f, 0.08843438f, 0.07155238f, 0.02463858f, 
    0.06437180f, 0.07457703f, -0.06563059f, -0.01959951f, 0.00924933f, -0.04069437f, 0.01961748f, -0.07485072f, 
    -0.03133354f, -0.02791393f, 0.08178376f, 0.02672752f, -0.00708855f, -0.01873771f, 0.00327522f, 0.02062028f, 
    0.02995410f, -0.01894104f, 0.05346122f, 0.06116857f, 0.02062398f, -0.02627872f, -0.01466504f, 0.00617922f, 
    0.10122512f, -0.16432795f, 0.07904395f, -0.00415640f, -0.12532794f, 0.03634318f, -0.04545734f, 0.05418973f, 
    0.02443532f, -0.03582141f, -0.09444509f, -0.01314517f, -0.00973542f, -0.02950973f, -0.05489336f, 0.06986474f, 
    0.01411333f, -0.00707193f, -0.06091547f, -0.05766693f, 0.09545034f, -0.38833663f, 0.04250502f, -0.13438736f, 
    -0.07120798f, 0.01674255f, 0.07471250f, -0.09341703f, 0.05501396f, -0.06453441f, -0.01431266f, 0.01601920f, 
    -0.00295016f, 0.00001022f, -0.16328698f, -0.09987196f, -0.06026129f, 0.01531252f, -0.05176107f, -0.04995426f, 
    -0.17115769f, -0.07062352f, -0.11326140f, 0.03256500f, 0.02936165f, -0.02828707f, 0.01406579f, 0.00315578f, 
    -0.00919553f, 0.01823053f, -0.03165211f, 0.05664282f, -0.01317762f, 0.09468254f, 0.01773355f, 0.02529679f, 
    0.03450562f, -0.07073326f, 0.02314433f, -0.02423472f, 0.17149055f, -0.24746287f, 0.01379118f, 0.13638276f, 
    0.07202005f, -0.03515969f, -0.00844621f, -0.09236065f, 0.00188630f, 0.13852845f, -0.08164494f, 0.07083686f, 
    -0.08718856f, -0.01372450f, -0.09302612f, -0.07666785f, -0.06591267f, 0.02115628f, 0.01128251f, -0.02627702f, 
    0.22425792f, -0.08157665f, 0.00605906f, 0.08675492f, -0.04066214f, -0.02812010f, 0.01825898f, -0.03207733f, 
    0.02082746f, -0.02296586f, 0.01831831f, 0.00445899f, 0.05545757f, 0.06454023f, 0.01018183f, 0.02335260f, 
    -0.07456389f, 0.06297711f, -0.02253885f, 0.00550997f, -0.12599242f, -0.08465320f, -0.11128485f, 0.19263336f, 
    -0.09169368f, -0.07540706f, 0.04056827f, -0.04600941f, 0.01659839f, 0.03252801f, -0.05488513f, 0.05809354f, 
    0.09105709f, 0.01798348f, 0.05132720f, -0.02133312f, -0.04997934f, -0.03552832f, -0.05247511f, -0.12985079f, 
    0.16963086f, -0.33063963f, 0.11670437f, -0.10535927f, 0.16270196f, -0.05996888f, 0.00011120f, -0.05445160f, 
    0.01956579f, -0.05654581f, 0.03023053f, -0.10231011f, -0.01974416f, -0.02233002f, 0.03743332f, 0.10466443f, 
    0.08736929f, 0.02867551f, -0.00293312f, 0.04478770f, 0.06578049f, 0.02694171f, -0.04875402f, 0.05676251f, 
    0.02035085f, 0.14884499f, -0.00753797f, -0.01370082f, 0.04613508f, 0.13481995f, -0.07459521f, -0.00256002f, 
    -0.01297761f, 0.03033316f, -0.02219663f, 0.00557196f, -0.06242968f, -0.01717640f, -0.10385183f, -0.09332089f, 
    0.22304253f, -0.19020566f, 0.12689078f, -0.02563579f, -0.28306562f, 0.01259804f, 0.07814448f, 0.00923251f, 
    -0.05111685f, -0.00623783f, -0.05102586f, 0.06453776f, -0.00342222f, -0.07866501f, -0.00027217f, -0.04472272f, 
    -0.02187260f, -0.10469515f, -0.01916235f, -0.07381131f, 0.13329619f, -0.03571776f, 0.02563198f, 0.05310692f, 
    0.01246827f, 0.02187053f, 0.01632823f, 0.00162298f, -0.00750661f, 0.00529635f, -0.06812714f, 0.05297584f, 
    -0.03566166f, -0.01646536f, -0.05072916f, 0.04515915f, -0.00826190f, -0.01312955f, 0.03240429f, 0.01989737f, 
    0.08404309f, -0.04778419f, -0.11322613f, 0.06376954f, -0.13049290f, -0.07317464f, 0.03948174f, 0.00623649f, 
    -0.01236000f, 0.08501066f, -0.10697410f, -0.01383242f, 0.05070360f, 0.08429987f, 0.03488013f, 0.06410450f, 
    -0.00188208f, -0.02348245f, 0.03531513f, -0.02735183f, -0.04946784f, 0.03320632f, -0.14356764f, 0.05780455f, 
    -0.07963981f, 0.01966925f, 0.01751411f, 0.00415891f, 0.00263972f, 0.03333648f, -0.05054192f, -0.06326661f, 
    0.02079444f, -0.00461510f, 0.03358554f, -0.02323238f, -0.08546352f, 0.08751737f, -0.00918750f, 0.00127003f, 
    -0.08895440f, -0.02169320f, 0.08949687f, -0.16701797f, -0.02957762f, 0.06498579f, 0.06898116f, -0.09231891f, 
    -0.00541859f, -0.01645821f, 0.01141625f, 0.08576071f, -0.03779549f, 0.05753642f, 0.00476925f, -0.03829364f, 
    0.04524096f, 0.02010999f, 0.11744994f, -0.06674319f, 0.07850325f, -0.04184456f, -0.03642291f, -0.05927474f, 
    -0.00300738f, 0.07884000f, 0.03202181f, -0.03852627f, -0.08640979f, 0.01030404f, -0.02832171f, 0.01394398f, 
    -0.04492056f, 0.10516120f, 0.01877707f, -0.07533210f, -0.06092492f, -0.13395342f, -0.02206749f, -0.03141223f, 
    -0.24085002f, -0.03058607f, 0.11627330f, -0.18032035f, -0.05677437f, 0.01433998f, 0.06098554f, -0.12867609f, 
    0.03629120f, 0.04156797f, 0.06137629f, -0.06105633f, 0.00585225f, -0.00769105f, -0.02131660f, 0.03041619f, 
    0.01192043f, 0.07797516f, -0.12289686f, -0.05043267f, -0.11305848f, -0.02198230f, 0.06411620f, -0.25523099f, 
    -0.09842961f, -0.08808917f, 0.01324353f, -0.08023898f, -0.01880005f, 0.06483010f, -0.06405095f, -0.10505206f, 
    -0.01001822f, -0.05800273f, 0.03927909f, 0.05334403f, 0.01355455f, -0.04778132f, -0.07322947f, -0.01083279f, 
    -0.06344886f, -0.12250330f, 0.11067510f, 0.05591283f, 0.27773923f, 0.00725662f, -0.02467773f, 0.03230130f, 
    0.01262077f, 0.07237836f, 0.03022492f, -0.06257553f, 0.00815475f, 0.06727119f, -0.00048998f, 0.04060173f, 
    0.09992687f, -0.02708916f, -0.01861933f, -0.00110560f, 0.11047690f, -0.27480441f, -0.05125110f, 0.14009708f, 
    -0.02276346f, -0.04680936f, -0.01588558f, 0.02899118f, 0.00227520f, -0.04060214f, -0.02350651f, 0.05036884f, 
    0.09802305f, 0.00392444f, 0.00842183f, 0.07074833f, 0.05154081f, 0.01393433f, -0.02727325f, 0.02491428f, 
    -0.13692443f, 0.16297840f, 0.04200908f, -0.05838963f, -0.01724921f, 0.00701953f, 0.15014006f, -0.11016209f, 
    0.03998873f, 0.02215369f, -0.10065515f, 0.09052169f, -0.02804818f, -0.05474464f, -0.01501357f, 0.03151361f, 
    0.00328194f, -0.06080551f, -0.07157023f, -0.02055205f, -0.17523156f, -0.02343141f, -0.02027304f, -0.10572948f, 
    0.05150300f, -0.10378484f, 0.03987765f, 0.04841843f, -0.06122808f, 0.02687799f, 0.07808172f, 0.04425093f, 
    -0.04257856f, 0.03208842f, -0.00650116f, -0.03714310f, 0.06652948f, 0.02249244f, 0.11444382f, 0.02735892f, 
    0.12629598f, -0.04925607f, -0.15424058f, -0.28389087f, -0.29380995f, -0.00588048f, 0.06268290f, -0.09620771f, 
    0.09799888f, -0.08038100f, -0.08426735f, -0.06470966f, -0.00937975f, 0.05309076f, -0.07590160f, 0.04388522f, 
    0.11252773f, 0.01475501f, -0.07034020f, 0.08215184f, -0.39456129f, -0.00423630f, 0.11418135f, 0.08156634f, 
    0.15214457f, 0.10117731f, -0.02167449f, -0.06978575f, -0.01850257f, 0.00460609f, 0.08192656f, 0.03934891f, 
    -0.07787110f, -0.01126470f, -0.06376915f, 0.06192106f, -0.06976131f, 0.06126142f, -0.02764252f, 0.05241325f, 
    0.24535356f, -0.00352506f, -0.04168181f, -0.03212424f, 0.05918237f, 0.01536773f, -0.05381193f, 0.05277871f, 
    -0.07975398f, 0.07461666f, 0.01861053f, -0.00330375f, 0.02901843f, 0.07889055f, -0.01454952f, 0.00938641f, 
    -0.01786767f, -0.00103550f, 0.00150586f, -0.00300042f, 0.12926815f, -0.05635316f, -0.20115899f, -0.05775493f, 
    0.19242474f, 0.04325544f, 0.01557117f, 0.08297747f, 0.00884760f, 0.06974532f, -0.00756432f, -0.05147631f, 
    0.03366370f, 0.07729824f, -0.08268212f, 0.01157859f, 0.02487394f, 0.03510088f, -0.03450536f, -0.03197041f, 
    0.04748640f, -0.20761710f, 0.04250630f, -0.05124664f, 0.01110101f, -0.18271093f, 0.04134969f, 0.08661269f, 
    0.10541723f, -0.06888732f, -0.01110308f, -0.11940315f, -0.03133858f, -0.09420625f, -0.07284790f, 0.03968227f, 
    -0.01656397f, 0.10584757f, 0.01849502f, 0.05053664f, 0.10744327f, -0.02954191f, -0.04793159f, 0.07707318f, 
    -0.01441478f, 0.05129104f, -0.05001487f, -0.02814137f, 0.02347423f, 0.04725978f, -0.03266082f, 0.03181824f, 
    -0.00056223f, -0.00933947f, -0.05418734f, 0.02795613f, -0.01991813f, 0.03563100f, -0.02357787f, 0.02691887f, 
    -0.02066039f, 0.27180868f, 0.06057046f, -0.01036634f, -0.06912847f, 0.03354840f, 0.02374897f, 0.02462439f, 
    0.00946273f, -0.05379741f, -0.06693056f, -0.00165497f, 0.04168121f, -0.09478740f, 0.04784402f, 0.01917104f, 
    0.04189882f, 0.01974878f, -0.09398486f, -0.02533610f, 0.07580584f, -0.17969772f, 0.09638247f, -0.15439029f, 
    -0.10044350f, -0.08849271f, 0.01752762f, 0.05855019f, 0.09078553f, 0.06862998f, 0.00378541f, -0.00983635f, 
    0.05868590f, -0.04528636f, 0.04525260f, -0.05097219f, 0.10561297f, -0.02690057f, 0.11730220f, -0.10112809f, 
    -0.07078927f, -0.02784137f, 0.01107237f, 0.10835533f, 0.05668627f, 0.05734273f, -0.03437490f, -0.02081789f, 
    -0.00411823f, 0.05003623f, -0.02467528f, 0.01457604f, -0.08090708f, -0.02259923f, -0.03348305f, 0.01982101f, 
    -0.06256080f, 0.05784731f, -0.07854983f, 0.03796550f, 0.03547964f, -0.30317694f, 0.15241705f, -0.04979469f, 
    0.03737864f, -0.05677907f, 0.02995205f, -0.14101993f, 0.03432043f, 0.08049193f, 0.04324576f, 0.00434129f, 
    0.07017484f, -0.13587953f, 0.03823280f, 0.08787043f, -0.04507298f, -0.05288219f, 0.04740828f, 0.05250279f, 
    0.15349987f, 0.02231415f, 0.11657625f, -0.21928117f, -0.23323841f, -0.01583458f, -0.09201115f, 0.06478426f, 
    -0.07464154f, 0.05889927f, -0.01047731f, 0.01329029f, 0.00278054f, -0.13979571f, 0.02411205f, -0.05667324f, 
    0.03338500f, -0.04774822f, 0.13717739f, 0.05734245f, -0.03900873f, -0.19043583f, -0.03050405f, 0.04664866f, 
    -0.03345169f, -0.04553069f, 0.04537093f, -0.05065735f, 0.08842475f, -0.01891164f, -0.09295110f, -0.04484576f, 
    0.05315892f, 0.05048919f, 0.14079207f, -0.05616104f, -0.06185688f, 0.11342340f, -0.03198286f, 0.04820831f, 
    0.11559118f, -0.47675294f, 0.29989260f, 0.05459679f, 0.06766926f, 0.02461701f, 0.00979110f, -0.09451541f, 
    -0.00409138f, -0.10181007f, -0.03861846f, 0.00710284f, -0.01856830f, 0.03971512f, 0.08714604f, 0.03402559f, 
    0.00954804f, -0.12786387f, -0.00372276f, 0.03745741f, -0.01418837f, -0.06148834f, -0.01519853f, -0.01836453f, 
    -0.00262201f, -0.06131350f, -0.01278683f, -0.01006170f, 0.01842961f, -0.00994595f, -0.08656218f, 0.01802661f, 
    -0.02155605f, 0.00656761f, 0.09565046f, 0.09349813f, 0.05905315f, 0.03897172f, -0.03873697f, 0.10559056f, 
    -0.21531896f, 0.19281121f, 0.22083098f, -0.14649850f, 0.05480721f, 0.03925846f, 0.02808816f, -0.03114640f, 
    -0.08597521f, -0.02861810f, 0.03385069f, 0.03665815f, 0.04402779f, -0.00534432f, 0.00006032f, 0.03863505f, 
    0.00468755f, 0.13764222f, -0.10005771f, 0.06645641f, -0.01831302f, -0.02546440f, 0.12522201f, 0.00169966f, 
    -0.06518560f, 0.03296767f, 0.01644416f, 0.03391813f, 0.00845201f, -0.14197640f, 0.06641392f, 0.06117440f, 
    -0.04529721f, -0.03227201f, 0.09857599f, -0.03120570f, -0.06110940f, 0.00593944f, -0.10299415f, 0.00474493f, 
    0.16018917f, 0.10745102f, -0.04264453f, 0.02512097f, -0.06365663f, -0.09841479f, -0.04321142f, 0.03673112f, 
    0.05940767f, -0.01570111f, -0.01775196f, 0.02923072f, -0.01429416f, -0.05991017f, -0.01515560f, 0.01612041f, 
    0.02639330f, 0.01048332f, 0.00418451f, -0.05576092f, -0.01672401f, 0.07493193f, 0.12631764f, -0.09227814f, 
    -0.19885404f, 0.10730705f, -0.01453598f, -0.06008565f, 0.04812231f, 0.02824103f, 0.02024813f, 0.05773969f, 
    0.03678209f, 0.00100104f, 0.01804893f, 0.05915593f, 0.08918449f, 0.04001035f, -0.01207181f, 0.07844315f, 
    0.15056401f, 0.00863689f, -0.04536466f, -0.21461198f, -0.10450745f, 0.09957072f, 0.03469040f, 0.07630700f, 
    -0.03956610f, -0.01944643f, -0.01399280f, -0.06507734f, -0.01980112f, -0.01067509f, -0.05580993f, 0.04571339f, 
    -0.00527410f, -0.16920735f, -0.11879575f, 0.03308828f, 0.09561219f, 0.02339477f, 0.02868707f, -0.05028787f, 
    -0.06262098f, -0.05533952f, -0.02334605f, -0.03625925f, 0.07532381f, 0.04049239f, -0.00259303f, -0.02340344f, 
    -0.02254360f, 0.04379892f, -0.01214634f, -0.00897834f, 0.09704095f, -0.00017015f, -0.01512846f, -0.03797182f, 
    0.13800418f, 0.00089658f, -0.00313487f, -0.00529855f, -0.01194017f, -0.08173415f, 0.00278743f, -0.00911704f, 
    0.01540669f, -0.04432286f, -0.01943533f, 0.03404639f, -0.01329660f, -0.00821631f, -0.01296490f, -0.06049896f, 
    0.04551420f, 0.00688408f, -0.09649146f, 0.03572777f, 0.03581938f, -0.08513124f, -0.11902546f, 0.00632653f, 
    -0.04280978f, -0.03294259f, 0.01718468f, 0.00645796f, 0.00682915f, 0.03611912f, 0.06461529f, -0.03519392f, 
    -0.02538000f, -0.07796130f, -0.00349331f, 0.02765841f, 0.10430451f, 0.12548256f, 0.09612168f, 0.08224501f, 
    0.02378979f, -0.04082796f, -0.00871422f, 0.02136817f, -0.03741094f, -0.02482405f, 0.01130772f, -0.08021338f, 
    0.01449275f, -0.01075052f, 0.03395569f, 0.06521115f, -0.08296952f, -0.05418999f, 0.11958498f, -0.04799893f, 
    -0.01434657f, 0.02742592f, 0.00871388f, -0.05832691f, -0.41258150f, -0.19564292f, 0.14651132f, 0.07084291f, 
    -0.10179504f, 0.07976399f, -0.01727077f, -0.01948521f, -0.06359956f, 0.07904781f, -0.02417500f, 0.02072778f, 
    0.06735197f, -0.06737521f, 0.06112461f, -0.07187569f, 0.04834750f, 0.04611716f, 0.00860662f, 0.08327498f, 
    -0.04274842f, -0.01081712f, -0.11159173f, -0.05218799f, -0.01946911f, -0.01459257f, 0.05851557f, 0.01924646f, 
    -0.00105132f, -0.05788881f, 0.01070405f, -0.01431634f, 0.00357114f, -0.11762238f, 0.07724731f, 0.00925980f, 
    0.06104623f, 0.02298350f, 0.07069567f, 0.01394834f, 0.17735156f, 0.12915194f, 0.03125573f, -0.10081095f, 
    -0.12956369f, 0.07227498f, 0.02262352f, 0.09457240f, 0.03736520f, 0.00084895f, 0.00715754f, 0.02104792f, 
    -0.01272689f, 0.00361909f, -0.03519803f, 0.06101022f, -0.00251178f, -0.02987498f, -0.13754037f, 0.04928140f, 
    -0.04788989f, -0.01504533f, -0.01607312f, 0.00866619f, 0.01161598f, -0.01744796f, 0.07243354f, 0.00171263f, 
    0.04348754f, 0.04761061f, 0.04591331f, -0.06919207f, 0.03695520f, -0.06057527f, -0.05147048f, 0.02276925f, 
    0.08585493f, 0.07182138f, 0.07404447f, 0.10099201f, -0.21422160f, -0.02454838f, -0.13922019f, 0.03726552f, 
    0.05427691f, 0.07946313f, -0.02823714f, -0.13097771f, 0.00291042f, -0.06223716f, 0.04903077f, 0.02980149f, 
    -0.08590753f, 0.04482635f, 0.11160969f, -0.09069403f, 0.04781050f, 0.07033992f, 0.01450326f, 0.01973302f, 
    -0.28523639f, -0.12398816f, 0.00770797f, -0.12272452f, -0.12655745f, 0.08466776f, -0.01284645f, 0.02844546f, 
    0.01215818f, -0.00463365f, 0.00879255f, 0.01785310f, 0.02535584f, 0.07735304f, -0.04430938f, 0.02542401f, 
    -0.00192898f, -0.09187938f, -0.05508390f, -0.05736498f, -0.09744786f, 0.04406541f, -0.19498144f, -0.00192813f, 
    0.04253782f, -0.01247022f, -0.00278603f, -0.00879199f, 0.01364969f, 0.07682263f, 0.02463803f, 0.03037032f, 
    0.06922343f, -0.03189710f, 0.01335092f, 0.03938873f, 0.01725187f, 0.03359815f, -0.05327887f, 0.07377920f, 
    -0.00168708f, 0.07336389f, -0.02442976f, -0.05278865f, 0.03578861f, -0.02944808f, 0.06779957f, -0.00992187f, 
    0.03946686f, -0.02502658f, 0.03467441f, 0.06920098f, 0.03971219f, 0.05288891f, 0.00109781f, 0.01026649f, 
    0.09053095f, 0.05059108f, -0.01269537f, 0.08346169f, 0.06796139f, 0.04726425f, 0.06205422f, -0.00012894f, 
    -0.05962907f, 0.03248533f, 0.00492786f, 0.04384746f, -0.02581998f, 0.03100609f, 0.02485950f, 0.03306694f, 
    -0.01957735f, -0.04907131f, 0.03167577f, 0.00435675f, -0.01633660f, -0.00370678f, -0.00655225f, 0.06966402f, 
    -0.19813243f, 0.08441883f, -0.02901779f, 0.01656992f, -0.01929506f, 0.05323797f, -0.00845483f, -0.00732780f, 
    0.01972472f, -0.03782238f, 0.03474639f, 0.05476172f, -0.04040551f, -0.04715290f, 0.03037638f, -0.00594624f, 
    -0.00659723f, -0.07284281f, -0.02474968f, 0.03130829f, 0.11899710f, 0.25668550f, 0.19343814f, -0.00010753f, 
    0.02424660f, 0.05757277f, -0.05237200f, 0.04367898f, 0.02498249f, 0.00021633f, -0.07469208f, -0.05491297f, 
    0.01901929f, 0.13223569f, -0.02473894f, -0.02679524f, -0.10401909f, -0.13019069f, -0.15855701f, -0.06683565f, 
    -0.41937381f, -0.11145783f, 0.07345627f, -0.04361602f, 0.00131275f, 0.07827217f, 0.00967802f, 0.02101263f, 
    -0.04778400f, -0.03636087f, 0.02016249f, 0.02603650f, 0.03553924f, 0.14916077f, 0.02412663f, 0.11179972f, 
    -0.00720118f, 0.05314729f, -0.03373898f, -0.02928086f, 0.00486388f, -0.03973022f, -0.02957008f, 0.04136560f, 
    0.12375962f, 0.06182148f, 0.06997108f, 0.02350631f, 0.06136374f, 0.01061699f, -0.04041907f, -0.01668067f, 
    0.03525673f, 0.05696709f, 0.01966688f, 0.02585665f, 0.05729972f, -0.01374447f, 0.05293718f, 0.04630888f, 
    -0.22176142f, 0.02784364f, -0.06146039f, -0.00367283f, 0.10109363f, -0.00115102f, 0.00070430f, -0.02291490f, 
    0.01777212f, 0.05611649f, 0.04287010f, 0.00713169f, 0.04290306f, 0.00484615f, 0.05033833f, 0.08830729f, 
    -0.00167974f, 0.05110620f, -0.02784223f, 0.03135564f, 0.11581647f, -0.04817882f, -0.05048448f, 0.07153658f, 
    -0.13058786f, -0.08645110f, 0.01166802f, 0.04519072f, 0.03132237f, -0.00929413f, 0.00072619f, -0.04245102f, 
    -0.03467408f, -0.11897053f, -0.06689087f, -0.06391496f, -0.05814607f, -0.11054394f, 0.00362233f, -0.04480603f, 
    -0.53078949f, -0.35189128f, -0.09634338f, -0.12862986f, -0.04240036f, 0.04174127f, 0.00030925f, -0.08149339f, 
    -0.08179705f, 0.02925992f, 0.02673151f, -0.07673594f, -0.01545848f, 0.05880377f, 0.05091878f, 0.02168554f, 
    -0.04546518f, 0.06592088f, 0.06495348f, 0.05276572f, 0.01335984f, 0.00212302f, -0.11975062f, 0.06670532f, 
    -0.01171995f, 0.00018424f, -0.02178418f, 0.01147998f, -0.04288414f, 0.04844407f, 0.01360754f, -0.02527341f, 
    -0.10298588f, 0.08600300f, 0.00852681f, 0.03825436f, 0.00112815f, -0.02425599f, 0.03003440f, -0.00062551f, 
    0.08674672f, 0.02781356f, 0.03779743f, 0.03078385f, -0.00490609f, 0.02625030f, -0.01077322f, 0.07020181f, 
    -0.01566590f, 0.00039387f, -0.01878549f, 0.01264625f, 0.00279120f, -0.03517235f, -0.05177034f, -0.04584545f, 
    0.00373945f, -0.06631575f, -0.02369430f, 0.09032440f, -0.11366834f, 0.00226741f, -0.12624453f, -0.00542331f, 
    0.04147060f, 0.05423427f, 0.06510740f, -0.07447661f, 0.01849421f, -0.01577045f, 0.02521253f, 0.05403553f, 
    0.02933745f, -0.03157265f, 0.08597860f, -0.05807440f, -0.02823349f, 0.07314438f, 0.01331724f, 0.02458572f, 
    -0.30281675f, -0.41663325f, 0.07451960f, -0.04345261f, 0.06844381f, 0.09385940f, 0.08774468f, 0.04178036f, 
    -0.06639174f, -0.09923865f, 0.08612241f, -0.01565458f, 0.00738436f, 0.00685296f, 0.05788710f, 0.05156438f, 
    0.02055018f, 0.02095899f, 0.01053453f, -0.01043793f, 0.10642224f, 0.00178803f, 0.00359200f, -0.04905647f, 
    0.00950657f, 0.05326257f, 0.00892180f, 0.07512585f, 0.00212267f, 0.06831876f, -0.02748038f, -0.00820488f, 
    0.06705856f, 0.00437480f, -0.03205972f, -0.02764161f, 0.03762350f, -0.17666097f, 0.00116222f, 0.02967667f, 
    -0.00847499f, -0.05652046f, -0.04861230f, 0.02306912f, 0.16000570f, -0.01458017f, 0.02780930f, -0.01588718f, 
    -0.00698157f, -0.01230978f, 0.00922660f, 0.00001104f, -0.00771996f, 0.05417239f, 0.06627592f, 0.00096029f, 
    0.11192183f, 0.09778616f, 0.03021387f, 0.07102477f, -0.43816954f, -0.29087517f, -0.02404892f, -0.15986294f, 
    -0.12843278f, 0.01976028f, 0.06712585f, -0.06693550f, -0.00297111f, 0.07227205f, 0.00770382f, 0.01859069f, 
    -0.07786381f, 0.03113286f, 0.00907892f, 0.11173042f, 0.01621705f, 0.06842303f, 0.01611535f, 0.05790999f, 
    -0.10275655f, -0.03617394f, -0.02760589f, -0.05288171f, -0.03445924f, 0.01753445f, 0.04068435f, -0.05678196f, 
    -0.00068020f, -0.02379775f, -0.02261588f, 0.02846523f, -0.05838175f, -0.10997118f, 0.03599663f, -0.03539002f, 
    0.02426862f, 0.03816210f, 0.02416410f, 0.03686479f, 0.20600274f, -0.01089109f, -0.13422157f, 0.07133574f, 
    -0.08512492f, -0.13642694f, -0.04389327f, 0.01930289f, 0.00094604f, -0.00286761f, 0.00851840f, 0.02868672f, 
    -0.01781109f, -0.11020715f, -0.02211240f, -0.02158186f, 0.06690365f, -0.09471653f, -0.14406027f, -0.01528231f, 
    -0.11224371f, 0.03259829f, -0.12520388f, -0.07319146f, 0.06159203f, 0.02799521f, 0.06145326f, -0.01809063f, 
    0.03569870f, 0.03029726f, 0.00875049f, -0.00364230f, 0.04664479f, 0.03153842f, 0.03092379f, 0.05039795f, 
    0.07757137f, 0.14251167f, 0.00342311f, 0.10121513f, 0.10950473f, -0.10494714f, 0.01789316f, 0.00926274f, 
    0.12408860f, -0.04215778f, 0.03133655f, -0.04559983f, 0.02783284f, -0.08561826f, 0.00834358f, 0.01159854f, 
    0.00105268f, -0.02676588f, -0.01375504f, -0.10629925f, 0.00398790f, -0.04063521f, -0.12171718f, 0.05345618f, 
    -0.34944278f, -0.00272345f, -0.09728987f, 0.11151917f, 0.08867443f, 0.01363990f, 0.02423000f, -0.10065190f, 
    0.01902204f, 0.04918243f, 0.01333001f, -0.01663757f, 0.04195187f, -0.03907594f, 0.14293462f, 0.04428277f, 
    -0.08165932f, -0.02041618f, -0.09906960f, -0.08439963f, 0.07658646f, 0.10100640f, 0.02867174f, 0.08730783f, 
    -0.04062435f, -0.01007311f, -0.08054126f, 0.07820686f, 0.04639250f, 0.01346580f, 0.03296619f, -0.01458584f, 
    0.03621879f, -0.00373370f, 0.03399483f, 0.04342042f, -0.02376833f, 0.02305457f, 0.06217716f, 0.00950126f, 
    -0.37270936f, -0.05023532f, -0.01355070f, -0.05426332f, -0.15054695f, 0.07216210f, -0.06028990f, -0.05631873f, 
    -0.10239449f, 0.00130430f, -0.01425038f, 0.02472592f, -0.03190026f, 0.10777298f, 0.06258923f, 0.03438505f, 
    0.01935706f, 0.01791272f, -0.01608100f, -0.00905892f, -0.00821933f, 0.03639282f, 0.02768510f, -0.03001356f, 
    0.00908092f, -0.02037568f, 0.02125693f, 0.04190894f, 0.03075213f, -0.02091552f, 0.00167763f, 0.03775463f, 
    0.00304647f, 0.01608449f, 0.01727501f, 0.03329856f, 0.05591228f, 0.01264430f, -0.04708588f, 0.06937613f, 
    0.22808920f, -0.17318782f, -0.05474442f, 0.01527618f, 0.07448391f, -0.10505117f, -0.00581108f, -0.07713974f, 
    -0.01092913f, -0.04548153f, 0.00345679f, 0.01102279f, -0.05050356f, -0.11476746f, -0.00052967f, -0.10357386f, 
    -0.03256796f, -0.00816694f, -0.10330854f, 0.03083504f, 0.17481640f, 0.04448079f, -0.04615493f, -0.04991207f, 
    0.04371651f, -0.13010378f, 0.00462241f, -0.05564399f, 0.07354214f, 0.04076336f, -0.05884920f, -0.00393968f, 
    -0.04160048f, -0.07482988f, 0.01067913f, -0.07203660f, 0.02070318f, 0.04410131f, 0.08371611f, 0.01657135f, 
    -0.45827237f, -0.25830352f, -0.21798423f, -0.16494906f, -0.24360107f, 0.04709994f, 0.05460209f, -0.08080452f, 
    -0.08773204f, 0.02393217f, 0.03330130f, -0.05057616f, -0.00833486f, -0.00587247f, -0.04726763f, -0.04906201f, 
    -0.03848079f, 0.02337035f, 0.05689451f, 0.02539534f, -0.04177129f, 0.09763239f, -0.08688276f, 0.01277396f, 
    -0.02681569f, 0.01130953f, 0.00162390f, -0.03307384f, 0.09540806f, 0.03277170f, -0.03561546f, -0.03315736f, 
    -0.01889067f, -0.04394864f, 0.06869451f, -0.04789680f, 0.04578029f, 0.10869303f, 0.03803574f, 0.10282236f, 
    -0.35647023f, -0.13245215f, -0.06955453f, -0.10149535f, -0.02562602f, 0.12789498f, -0.01945533f, -0.04129665f, 
    -0.01888430f, 0.03700960f, 0.06300052f, -0.02482986f, -0.02200905f, 0.00822642f, 0.01209316f, -0.02909389f, 
    0.00291623f, 0.02619009f, 0.06440183f, -0.01916301f, -0.37859324f, -0.11383220f, -0.02500246f, -0.11131323f, 
    -0.06099667f, 0.05707119f, -0.00891313f, 0.01291677f, -0.05108861f, 0.06134428f, 0.00395918f, -0.01401155f, 
    -0.01922243f, -0.01843820f, -0.03131801f, -0.06202845f, -0.10292108f, -0.00369956f, 0.01786731f, 0.01184159f, 
    -0.07044923f, 0.09132375f, -0.12967628f, 0.06782598f, 0.08792280f, -0.03484880f, -0.00398491f, 0.00238281f, 
    -0.03814230f, 0.02042965f, 0.05365126f, 0.02287559f, 0.01430887f, -0.01705874f, -0.03821429f, -0.02107834f, 
    -0.03619643f, -0.02036798f, -0.07267271f, -0.05146233f, -0.12705931f, 0.01385698f, -0.00398698f, 0.03911050f, 
    0.03409728f, 0.07689323f, 0.04091086f, -0.07187025f, 0.02648626f, -0.00221372f, 0.03090495f, -0.00225382f, 
    0.01929410f, -0.02030267f, 0.05381890f, 0.02215556f, -0.01081206f, 0.01533405f, 0.00348917f, 0.03511138f, 
    -0.54308718f, -0.25087315f, -0.09906586f, -0.13174251f, -0.31920311f, 0.03358297f, 0.05633454f, -0.05515875f, 
    -0.09474956f, 0.06456602f, -0.00118317f, -0.11711927f, -0.07482523f, -0.00163165f, -0.07750132f, 0.02484456f, 
    -0.03855670f, -0.01388103f, 0.02363089f, -0.01242226f, 0.17394759f, 0.09565508f, 0.02544485f, -0.01858688f, 
    -0.11338767f, 0.00464289f, 0.02799611f, 0.03335094f, 0.06820718f, 0.06285366f, -0.04846969f, 0.00544927f, 
    0.00272259f, 0.00707377f, -0.02743610f, 0.11027181f, -0.00919852f, -0.11220782f, -0.11483613f, 0.07846282f, 
    -0.30092716f, -0.02321918f, 0.17850468f, -0.08572983f, -0.26763636f, 0.06794124f, -0.05155171f, 0.02525100f, 
    -0.05369611f, 0.07165378f, -0.03706026f, 0.01246375f, 0.07362697f, -0.09616794f, 0.03001890f, -0.09453109f, 
    -0.04431718f, -0.22541770f, -0.07922092f, -0.05220901f, 0.06583698f, 0.12793128f, -0.11392709f, 0.13720813f, 
    -0.09461820f, -0.02565774f, -0.02439376f, 0.05649952f, 0.00635172f, -0.03186942f, 0.08088773f, -0.01116686f, 
    0.04313076f, -0.05954097f, 0.04576294f, 0.03700010f, 0.03433484f, -0.04683821f, 0.09269529f, -0.03496156f, 
    0.10522298f, 0.07640255f, -0.07761522f, 0.03888392f, -0.01988180f, 0.00460988f, 0.00266941f, -0.02380439f, 
    0.05034618f, 0.02860478f, 0.03523187f, 0.04742172f, -0.04891036f, -0.02851625f, -0.04037686f, -0.08072524f, 
    -0.04473928f, 0.07584748f, -0.02715300f, -0.00472356f, -0.13892922f, 0.08190876f, -0.03578674f, 0.12156104f, 
    -0.03922755f, -0.02467915f, 0.03083744f, -0.11109505f, -0.01852940f, 0.02283753f, -0.03051728f, -0.06601658f, 
    -0.02306534f, -0.02068367f, -0.00484719f, 0.00902611f, -0.07367308f, -0.09949305f, -0.02717105f, 0.01826763f, 
    0.22409354f, 0.13849889f, 0.03150690f, 0.12500513f, 0.12162729f, 0.04405468f, 0.01616495f, -0.04233834f, 
    -0.02555503f, 0.01784193f, -0.03272280f, 0.00537489f, 0.06120433f, -0.02197181f, 0.04412400f, -0.01776375f, 
    0.00670815f, -0.14120786f, -0.13318986f, -0.08849437f, 0.16053432f, 0.00068445f, -0.04514967f, -0.00192803f, 
    -0.01141515f, -0.10811527f, -0.06600934f, -0.03368834f, 0.01687457f, -0.05644093f, 0.01115984f, 0.03410829f, 
    -0.00562348f, -0.02553502f, 0.01934423f, -0.01652339f, 0.00464496f, -0.00184082f, -0.06951883f, -0.03070816f, 
    -0.20577145f, -0.30330980f, -0.06768185f, -0.00636919f, 0.09551091f, 0.08471271f, 0.00010320f, 0.02415323f, 
    0.03200845f, -0.00688410f, 0.03867166f, -0.00031552f, 0.03694091f, 0.05403255f, 0.00046020f, 0.06411406f, 
    0.03385003f, 0.00143918f, 0.10246947f, 0.04043525f, 0.12185381f, 0.08134447f, 0.04580326f, -0.03904179f, 
    0.14411107f, 0.09495077f, 0.00904120f, 0.04438876f, 0.07466275f, -0.05826540f, -0.03599564f, -0.01831991f, 
    -0.00693276f, 0.00844102f, -0.01562647f, 0.05642766f, 0.16278385f, 0.04744730f, 0.06054623f, 0.06667273f, 
    0.10540327f, 0.08491224f, -0.02790984f, 0.06198135f, -0.07678580f, -0.01222416f, -0.10824152f, 0.07911036f, 
    -0.04240421f, 0.02042018f, -0.04920740f, -0.02158222f, 0.07515483f, -0.09199159f, -0.02678772f, 0.02887700f, 
    0.03688847f, 0.01545674f, -0.02325826f, -0.01266581f, -0.06955103f, 0.15523501f, -0.07351427f, 0.00373480f, 
    -0.01298679f, 0.02395855f, -0.02721965f, 0.02612354f, 0.03278017f, 0.02834175f, 0.00084538f, 0.02831523f, 
    0.01847226f, 0.04123627f, 0.02718161f, 0.03086444f, -0.01850619f, 0.01746922f, -0.07687505f, 0.06518296f, 
    -0.02498435f, 0.11769833f, 0.03664909f, -0.04260542f, -0.06801988f, 0.12581643f, -0.01709579f, -0.04543529f, 
    0.01989105f, 0.00339538f, -0.04974686f, -0.00649423f, 0.01683718f, 0.06777749f, 0.00978329f, 0.06497061f, 
    0.05173451f, 0.08004945f, 0.03154063f, 0.08385319f, 0.10570728f, 0.00295063f, 0.06932819f, -0.06833175f, 
    -0.05935922f, -0.08311471f, -0.11982035f, 0.06214748f, -0.00782889f, -0.01616525f, -0.00104626f, 0.03223289f, 
    -0.08253273f, -0.03996617f, -0.05631825f, -0.00876508f, 0.02689927f, -0.07907037f, -0.03674927f, -0.05279110f, 
    -0.40084222f, 0.02794436f, -0.25762171f, -0.08094142f, 0.01142764f, 0.06162816f, -0.00008219f, -0.12190276f, 
    -0.06414803f, 0.04287528f, -0.00102324f, 0.03262210f, -0.06563903f, 0.04300313f, -0.02443115f, 0.01936069f, 
    0.02860695f, 0.04333810f, -0.10213269f, 0.05613237f, -0.12551333f, -0.06924326f, 0.05370798f, 0.04289653f, 
    0.09576476f, 0.03743402f, 0.06255713f, -0.02007772f, -0.00297078f, -0.03948878f, 0.05616611f, 0.02860815f, 
    -0.03989238f, -0.04131658f, 0.01719099f, 0.03068681f, -0.05933456f, -0.09185500f, -0.03165320f, 0.01032171f, 
    -0.45473218f, -0.36594614f, -0.20579438f, -0.08414212f, -0.09698792f, 0.04112184f, -0.00828510f, -0.01108861f, 
    -0.01881136f, -0.03030127f, 0.10517262f, -0.00304158f, -0.00474688f, 0.02468401f, -0.03723538f, 0.05332084f, 
    -0.00651029f, 0.00596702f, 0.07119427f, -0.03406334f, -0.24262239f, -0.16039498f, -0.12224720f, -0.11937959f, 
    -0.00061482f, 0.01936976f, 0.04369972f, -0.08753239f, -0.02571312f, -0.00645838f, -0.02464508f, -0.06110366f, 
    -0.06560563f, 0.00804217f, 0.01176702f, -0.00944430f, 0.05365400f, 0.11448324f, 0.06136936f, 0.06330893f, 
    0.03650413f, -0.09790763f, 0.06991442f, 0.00248391f, 0.02055536f, -0.03470837f, 0.03480400f, 0.07045026f, 
    -0.01635571f, -0.02419835f, -0.07931823f, -0.04773873f, -0.01215866f, 0.01828420f, -0.05124517f, -0.06637708f, 
    -0.00795870f, -0.00929941f, -0.01667313f, 0.02747105f, 0.09638209f, 0.07079102f, -0.08506010f, -0.06356948f, 
    0.30441830f, 0.13929719f, -0.08060741f, -0.01549534f, 0.08432209f, 0.03021716f, -0.00497072f, 0.01741905f, 
    0.07404040f, -0.02638668f, 0.05779719f, -0.01632729f, -0.01296002f, 0.00749565f, -0.06017239f, 0.02582979f, 
    -0.01282827f, 0.11104261f, -0.15903383f, -0.27568042f, -0.02040980f, -0.05728544f, -0.12966014f, 0.03571133f, 
    -0.14576650f, -0.00710387f, -0.08341355f, 0.04951307f, 0.05608519f, -0.06904967f, 0.08548534f, 0.09478060f, 
    -0.07876506f, 0.05487725f, 0.02835697f, -0.15600927f, -0.09132779f, 0.07821681f, 0.06198657f, -0.05791583f, 
    -0.00421496f, -0.03812323f, 0.01051862f, 0.04367019f, -0.13394238f, -0.06019911f, -0.00471874f, -0.02764238f, 
    0.01271740f, -0.08806754f, -0.03278190f, -0.01363932f, -0.07912425f, -0.05069430f, -0.03716405f, -0.06564923f, 
    -0.17753068f, 0.14753871f, 0.07097280f, -0.02071677f, 0.03650342f, 0.01797000f, -0.06535263f, -0.00874870f, 
    -0.03604628f, -0.06991912f, 0.01393280f, -0.03230697f, 0.04886607f, -0.00111396f, 0.00960596f, -0.02356279f, 
    -0.03606682f, -0.02279800f, -0.02605685f, -0.00556909f, -0.12136400f, 0.02888296f, -0.04432360f, -0.02656978f, 
    -0.05848576f, 0.06800551f, 0.09846931f, 0.04664152f, 0.04617963f, 0.08781043f, -0.03710321f, -0.04343168f, 
    -0.00726394f, -0.04116887f, -0.01237404f, -0.04900676f, 0.02356193f, -0.08942994f, -0.02779937f, -0.06633595f, 
    -0.19690038f, -0.17900005f, -0.02197635f, -0.08545268f, -0.10561024f, -0.02483208f, 0.05015865f, 0.01245994f, 
    0.05063583f, 0.06013798f, -0.12229805f, 0.09600545f, 0.03095158f, 0.00457324f, -0.07241939f, -0.07253642f, 
    0.00222462f, -0.03126420f, -0.14878140f, -0.03382312f, -0.06209670f, -0.19656011f, -0.08937245f, -0.16053633f, 
    0.12201369f, 0.10697035f, -0.08680630f, -0.01278173f, 0.05822274f, 0.10333876f, -0.06309790f, -0.01652128f, 
    0.03572746f, 0.03319160f, -0.00219080f, 0.05630716f, 0.05115411f, 0.00918986f, 0.00342870f, -0.06239764f, 
    -0.08300285f, -0.13600814f, -0.08791820f, 0.05697346f, -0.12954499f, 0.12652895f, 0.15159239f, 0.03467635f, 
    -0.00096029f, 0.08102510f, -0.08059435f, -0.09346151f, 0.01836774f, -0.00752866f, -0.03326884f, -0.09010229f, 
    -0.00504731f, -0.02449928f, -0.04160139f, -0.05049935f, -0.09089226f, 0.12630315f, -0.13216698f, -0.24587065f, 
    -0.00843821f, -0.11678597f, -0.08868633f, 0.08965646f, -0.07629857f, -0.04159264f, 0.02004931f, 0.01393813f, 
    -0.00159130f, -0.01807322f, 0.07956578f, 0.06470924f, -0.06492706f, -0.03175086f, 0.08978518f, 0.00511893f, 
    -0.11276314f, -0.04302393f, -0.07061891f, 0.02467299f, 0.00583398f, 0.00293348f, -0.00950065f, 0.07776301f, 
    -0.02136751f, 0.05224773f, -0.01084376f, 0.03626171f, -0.03721247f, -0.05357924f, 0.01948510f, 0.03654086f, 
    0.01811095f, -0.01751576f, -0.01854126f, -0.06213289f, 0.00605749f, -0.23509462f, -0.01167534f, 0.08716516f, 
    -0.00999143f, -0.03670441f, 0.11144507f, -0.03738784f, -0.01546107f, -0.05164204f, -0.04574953f, 0.04493572f, 
    -0.07778309f, 0.02761699f, 0.01339562f, 0.04206105f, 0.00077827f, -0.11891531f, -0.03223099f, 0.03272678f, 
    0.33894244f, -0.02713921f, -0.10742395f, -0.00709314f, 0.00982161f, 0.01806221f, -0.05626666f, -0.09629064f, 
    -0.01436050f, -0.02222923f, 0.04712904f, 0.02249872f, 0.02631061f, 0.03678237f, 0.01529851f, 0.02536129f, 
    -0.02350335f, -0.03168926f, 0.02083365f, 0.05188327f, -0.13964501f, 0.19433399f, -0.01778838f, 0.04671221f, 
    0.02049556f, -0.04654928f, 0.01279869f, -0.05867151f, -0.00745484f, 0.07663499f, -0.06865164f, 0.01732112f, 
    0.03715081f, -0.00157782f, -0.00453036f, 0.04303512f, 0.01080234f, -0.01565447f, -0.01790383f, -0.03953271f, 
    -0.34892559f, 0.21898945f, 0.06069428f, -0.03014944f, 0.13979509f, -0.03810360f, 0.01212307f, 0.05461232f, 
    -0.04559609f, 0.07410902f, -0.00278890f, 0.00315613f, -0.00606021f, -0.06232458f, -0.04711597f, -0.06790609f, 
    -0.03123113f, -0.01782727f, 0.00082794f, -0.04260847f, 0.12839369f, 0.02345284f, -0.02289772f, 0.02946297f, 
    0.05206704f, 0.02377041f, 0.06244839f, -0.00884346f, -0.04609466f, -0.02762423f, -0.08034022f, -0.00005803f, 
    0.11671597f, 0.05577543f, -0.06913635f, 0.03012967f, 0.02049215f, 0.05099063f, -0.04975169f, -0.00016830f, 
    0.00128800f, 0.00677786f, 0.02903943f, -0.00536849f, -0.01786809f, 0.09377202f, 0.05576523f, -0.04900989f, 
    -0.01387650f, -0.09298708f, 0.07727981f, -0.01811212f, 0.03935660f, 0.07025883f, -0.01036877f, 0.03672063f, 
    0.02960813f, 0.03428634f, -0.01916628f, 0.06346574f, 0.37299851f, -0.02332252f, -0.11552177f, -0.02507157f, 
    -0.00151259f, -0.17161523f, 0.08855850f, -0.01396123f, 0.11389852f, -0.09424312f, 0.12887576f, -0.02742445f, 
    -0.06604291f, 0.06678167f, 0.04719498f, 0.02909826f, -0.03719431f, -0.01918277f, 0.05375648f, 0.08303177f, 
    0.18773893f, 0.26974618f, -0.09500610f, -0.09716073f, 0.02171945f, 0.08392756f, -0.03439890f, 0.01408909f, 
    0.05470820f, -0.02437270f, 0.03671565f, 0.09554590f, -0.00856127f, 0.00984345f, 0.06640238f, -0.00393757f, 
    -0.01748434f, 0.05663956f, -0.09723526f, 0.04901518f, -0.07421311f, 0.14611430f, -0.06404487f, 0.04045271f, 
    0.03754108f, 0.04726358f, -0.00568816f, -0.06295323f, -0.09114462f, -0.03287908f, 0.07487249f, 0.07118776f, 
    -0.02059922f, 0.04210327f, 0.04618413f, 0.00760893f, 0.05519262f, 0.02308575f, -0.09909109f, -0.04877850f, 
    0.04866740f, 0.06844237f, 0.00667871f, 0.05689355f, 0.06625473f, -0.04199655f, -0.04686489f, -0.06298126f, 
    0.04190250f, -0.00372846f, 0.00687617f, 0.02025526f, 0.02783879f, 0.02784691f, -0.04231300f, 0.04169609f, 
    -0.01184413f, -0.07976965f, 0.04054938f, 0.05069543f, 0.00882029f, -0.15368290f, 0.04962022f, 0.05546833f, 
    -0.03152535f, 0.02002214f, -0.10388893f, 0.08505890f, -0.13967818f, -0.07640190f, 0.00668304f, 0.03620328f, 
    -0.03556097f, -0.02728162f, -0.05682223f, -0.09526912f, -0.01312733f, -0.04438902f, 0.02087232f, 0.04961596f, 
    0.32512105f, -0.21236905f, -0.28598142f, -0.12488833f, -0.10755165f, 0.06101250f, -0.06207754f, 0.01953763f, 
    0.01559830f, 0.00871332f, 0.08197991f, -0.00433356f, -0.08578388f, 0.01190764f, 0.05979110f, 0.04172669f, 
    -0.01188197f, -0.03216967f, -0.00424410f, -0.04172871f, 0.11774842f, -0.08192499f, 0.00038898f, 0.06538225f, 
    -0.02959200f, -0.02754265f, -0.09455958f, -0.06291237f, -0.02995003f, -0.02959314f, -0.06666882f, 0.02564481f, 
    0.03538367f, 0.03053684f, -0.06819039f, 0.07428896f, -0.08561295f, 0.05289307f, -0.02961534f, -0.01354812f, 
    0.15688561f, 0.00774787f, -0.02317193f, -0.01610586f, 0.00848450f, -0.10808563f, 0.02353046f, 0.00058412f, 
    -0.07459489f, -0.09109564f, -0.01827861f, -0.01195612f, -0.02576137f, -0.00624473f, -0.04553713f, -0.02858357f, 
    -0.01255749f, 0.07274047f, -0.02553293f, -0.05641465f, -0.40209275f, 0.00884243f, 0.04249101f, -0.05937415f, 
    -0.00585590f, -0.00719017f, 0.00614014f, -0.04220270f, 0.06613619f, -0.02432787f, -0.03405044f, 0.00959524f, 
    0.02605090f, 0.02001201f, 0.02344717f, -0.01676316f, 0.07736376f, -0.06080395f, -0.10196757f, 0.01818941f, 
    -0.12833944f, 0.32541314f, -0.01438397f, 0.12699459f, 0.06882954f, 0.19577682f, 0.05883926f, -0.05308757f, 
    0.06784686f, 0.01830811f, -0.00093833f, 0.05347675f, -0.07615555f, 0.00087256f, 0.10241719f, -0.06803618f, 
    0.10136483f, 0.07290588f, -0.01077549f, 0.04389505f, 0.05129116f, -0.03737712f, -0.02251338f, -0.02072394f, 
    0.08802412f, -0.03177610f, -0.15011398f, -0.02357414f, 0.01015986f, -0.00026012f, 0.01407289f, 0.04227805f, 
    -0.01758735f, 0.00816022f, 0.05714453f, 0.03950851f, 0.02870920f, 0.00703482f, 0.06563748f, 0.06699628f, 
    -0.25407785f, 0.02312708f, -0.03304532f, 0.06431992f, -0.17890976f, 0.06294212f, 0.10598563f, 0.05312040f, 
    0.05700732f, 0.07502133f, -0.07604987f, -0.02180383f, -0.02531265f, -0.05513555f, 0.02899873f, -0.02673527f, 
    0.01864554f, -0.00729714f, -0.03307014f, 0.02373622f, 0.32847360f, 0.17379621f, -0.20575777f, -0.01098866f, 
    0.10628498f, 0.08655854f, -0.10174661f, -0.02692783f, -0.02563356f, 0.04499438f, -0.02351228f, 0.05141114f, 
    -0.07765608f, -0.01178677f, 0.00283742f, 0.00388516f, -0.01212930f, 0.04240080f, 0.06867602f, -0.02077044f, 
    -0.24019568f, -0.16754840f, 0.04059918f, -0.06638136f, -0.05551461f, -0.01005034f, 0.04322496f, 0.01996310f, 
    0.04126166f, -0.03545251f, -0.04382866f, 0.02078771f, 0.01606076f, 0.00985636f, 0.01403556f, -0.06467604f, 
    -0.00130550f, -0.02248454f, -0.03650300f, -0.01398552f, 0.05920875f, 0.11248834f, 0.05495641f, 0.01557065f, 
    0.04585475f, 0.08055102f, 0.03480729f, 0.00480370f, -0.06141102f, -0.05745548f, -0.09753136f, -0.03716106f, 
    0.13676943f, -0.07302167f, 0.03445786f, -0.02345195f, 0.05678041f, 0.07997140f, -0.02595796f, -0.02172973f, 
    -0.26159680f, 0.09789173f, 0.04186891f, 0.02648673f, 0.07828005f, -0.04353288f, 0.06433471f, 0.00369526f, 
    0.04507887f, 0.03139787f, -0.05753938f, 0.08774674f, -0.01543937f, 0.01614603f, -0.03033827f, -0.03473389f, 
    0.03898448f, 0.00298870f, 0.01543159f, -0.02144185f, -0.21145488f, 0.22312476f, 0.04452649f, 0.01883549f, 
    -0.03855981f, 0.03632582f, -0.06829488f, 0.00987301f, -0.12631465f, -0.04029343f, -0.00271777f, 0.03901806f, 
    0.03987748f, -0.05682737f, -0.00924968f, 0.02622159f, 0.05730808f, -0.06378291f, 0.10971969f, 0.00785339f, 
    0.01296457f, 0.05177962f, -0.12379526f, 0.07395966f, -0.24907506f, -0.11518878f, -0.00311631f, 0.01769446f, 
    -0.00898982f, -0.04183285f, 0.01380464f, -0.03646414f, 0.11571119f, 0.03504893f, 0.02467377f, 0.07290487f, 
    0.04587451f, -0.06295215f, -0.00977883f, -0.08657819f, 0.12123093f, -0.16522607f, 0.09311058f, 0.05404363f, 
    -0.01781433f, 0.05366203f, 0.00739899f, 0.07571574f, 0.00615914f, 0.01819547f, -0.03039622f, -0.01360734f, 
    -0.03224167f, 0.02437877f, -0.05382754f, -0.06521168f, -0.02667832f, -0.02046588f, -0.07305910f, -0.03685310f, 
    0.23311535f, 0.03977674f, -0.05486375f, -0.18025815f, -0.11315498f, 0.05714918f, -0.00212289f, -0.01793267f, 
    0.02618568f, 0.00273228f, 0.09343970f, -0.04852935f, 0.01678267f, -0.00530294f, -0.01660700f, -0.03470694f, 
    -0.05797849f, 0.01390930f, 0.04121088f, 0.11039422f, -0.29398593f, 0.20389265f, 0.03240410f, -0.03671624f, 
    0.14798468f, 0.01883458f, 0.00515972f, 0.00411242f, -0.00978640f, 0.09382522f, 0.02550264f, -0.01538699f, 
    0.02470192f, -0.02251040f, 0.01032324f, -0.05960133f, -0.00446825f, 0.00026702f, -0.02460115f, -0.03082770f, 
    -0.26075891f, 0.10930631f, -0.02552979f, -0.03652304f, -0.04498975f, 0.04837570f, -0.14448999f, 0.02992960f, 
    0.05851255f, -0.01185490f, 0.02224948f, -0.00011938f, -0.00396512f, 0.06424768f, 0.07766199f, 0.02806821f, 
    0.02388587f, -0.03423471f, -0.04872578f, -0.05634531f, -0.16553803f, -0.06998272f, -0.06925906f, 0.04115484f, 
    -0.02221894f, 0.03264110f, -0.03253915f, 0.03486840f, -0.00924683f, 0.01523183f, -0.03477670f, -0.01304547f, 
    -0.00267927f, -0.01933911f, -0.02862179f, -0.03975764f, -0.02041126f, -0.04941958f, -0.10347687f, -0.06228217f, 
    0.34803465f, -0.12175036f, -0.24837324f, 0.03537252f, -0.16369765f, -0.00615374f, -0.04341831f, 0.05693839f, 
    -0.04863547f, 0.04904414f, 0.05082588f, -0.03720223f, 0.02421692f, -0.02503809f, -0.03055352f, 0.03657098f, 
    0.00325878f, -0.02749142f, -0.00689409f, -0.00465354f, -0.26283628f, 0.04108679f, 0.00927939f, -0.02594648f, 
    0.07939058f, -0.01486258f, 0.06996294f, 0.05465104f, 0.05898492f, 0.01353071f, 0.03665634f, 0.01078945f, 
    -0.00230762f, 0.00168080f, -0.00194363f, -0.02922673f, -0.09005270f, -0.00471038f, -0.03274614f, -0.09672572f, 
    0.14307426f, -0.07428028f, -0.22901714f, 0.05265030f, -0.12890577f, 0.00246774f, -0.00988892f, 0.04014830f, 
    -0.06896640f, -0.03285201f, 0.00735450f, 0.01629901f, -0.02566391f, -0.00522518f, -0.01806717f, 0.00362125f, 
    0.03948098f, -0.04309386f, 0.01455284f, -0.02381448f, 0.15033440f, -0.19099979f, -0.12205211f, -0.02766287f, 
    -0.07083464f, -0.05121005f, 0.02231438f, -0.03619248f, -0.03328899f, -0.05345436f, 0.04417277f, -0.03495078f, 
    -0.02641979f, -0.00235331f, 0.01289984f, 0.02348773f, 0.02192248f, -0.07959556f, 0.01065658f, -0.01770593f, 
    -0.08884358f, -0.00154378f, 0.07252896f, 0.01505470f, 0.10757849f, -0.10414427f, -0.03675613f, 0.04841540f, 
    -0.02688602f, -0.08436300f, 0.02047594f, -0.01968871f, 0.01291894f, 0.07950234f, 0.03683490f, 0.05028862f, 
    -0.01443531f, -0.02192991f, -0.00824769f, 0.05630420f, -0.27726647f, 0.03580324f, 0.00306716f, -0.02083947f, 
    -0.13040754f, -0.02005680f, -0.02779197f, -0.07538079f, 0.02602633f, -0.07771439f, 0.01311410f, -0.04223766f, 
    -0.02436547f, -0.00459627f, 0.03545185f, 0.03009390f, 0.00305743f, -0.02541211f, -0.03712874f, 0.03459264f, 
    0.18471964f, -0.07717057f, -0.15915218f, -0.17658377f, -0.23708618f, 0.10120255f, 0.01963508f, 0.04166818f, 
    0.01396681f, -0.01929484f, 0.05726930f, -0.01417312f, -0.00740951f, -0.08152775f, -0.11144635f, 0.00224488f, 
    0.03198978f, 0.02802878f, -0.03514583f, 0.00965679f, -0.08782402f, 0.05964340f, -0.16593088f, -0.09636200f, 
    0.26601940f, 0.05374700f, -0.13163050f, -0.03782644f, 0.04834020f, -0.09727099f, 0.04614404f, -0.04967057f, 
    -0.00719362f, -0.05698537f, 0.01163455f, 0.00984594f, 0.07429179f, 0.03880586f, 0.10055653f, -0.04611364f, 
    -0.09429429f, 0.01468686f, -0.03220640f, -0.14511554f, 0.31051829f, 0.06155721f, -0.11381891f, 0.03940431f, 
    0.03006175f, 0.02232019f, 0.04062772f, -0.05111359f, 0.05918203f, 0.01581997f, -0.04416093f, 0.03636963f, 
    0.06250003f, 0.03251326f, 0.04601475f, -0.03019506f, 0.20936941f, -0.17422406f, -0.01551436f, 0.08305149f, 
    -0.09428767f, -0.06323959f, 0.10343187f, -0.01426731f, -0.07686539f, -0.00520523f, -0.04087303f, -0.05901251f, 
    -0.05140409f, 0.10694881f, -0.13138308f, -0.08467785f, -0.01239123f, 0.03410124f, -0.08412094f, -0.08954699f, 
    -0.29957324f, -0.09724260f, 0.06797766f, -0.08315144f, 0.05225385f, -0.05067971f, 0.08601088f, -0.00035846f, 
    0.09218264f, -0.12234581f, -0.03407951f, 0.05414700f, 0.07235345f, 0.01514038f, -0.01178077f, -0.00900368f, 
    -0.07537198f, -0.01758759f, -0.10056981f, -0.01339105f, -0.13582809f, -0.05770224f, 0.05919895f, 0.12796144f, 
    0.24895896f, -0.07364990f, 0.01313900f, 0.04755740f, -0.07344310f, -0.06790319f, 0.05941483f, -0.09398333f, 
    -0.06820375f, 0.12618855f, 0.02193552f, 0.03363226f, 0.06688198f, -0.06388828f, -0.03154144f, 0.07668268f, 
    -0.09694731f, -0.07326557f, -0.19133686f, 0.05606058f, -0.04208820f, -0.15623073f, -0.01198479f, -0.01030011f, 
    0.10868037f, -0.11780708f, 0.12403607f, -0.06488855f, -0.01139542f, -0.01077995f, -0.06422291f, 0.07402697f, 
    -0.01482767f, 0.03471287f, 0.03864587f, 0.03134807f, -0.11013889f, 0.01182336f, 0.03897242f, -0.02561983f, 
    -0.01788882f, 0.00113966f, 0.03311812f, 0.02693742f, 0.04465205f, -0.03034986f, -0.06054378f, -0.01289035f, 
    0.01833615f, -0.02675491f, 0.00169527f, -0.06621935f, 0.02773416f, -0.00616165f, -0.05990412f, -0.02760502f, 
    0.05287164f, -0.06415884f, -0.04180590f, 0.02995220f, 0.03320889f, 0.19054641f, -0.06574273f, -0.05804534f, 
    0.03233042f, 0.04892598f, -0.01079912f, 0.02620646f, -0.02811515f, 0.01246510f, -0.00523703f, 0.00101165f, 
    -0.02575670f, 0.00819966f, -0.09228666f, 0.01946133f, -0.15032642f, 0.21660927f, -0.03109090f, -0.10949086f, 
    0.13735296f, 0.08244133f, 0.02852519f, 0.03096767f, -0.04146933f, 0.01678113f, 0.04100758f, 0.08322757f, 
    -0.09695757f, -0.09455572f, -0.01174408f, 0.05423281f, 0.03380206f, -0.02396986f, 0.03985620f, -0.02191261f, 
    0.20523553f, 0.03778860f, 0.00803124f, 0.04046039f, -0.05270746f, 0.02417440f, 0.00647125f, 0.03432971f, 
    -0.01370214f, -0.03892402f, 0.09865576f, -0.04761237f, -0.03112774f, 0.06376555f, -0.02448204f, -0.06769035f, 
    -0.01895505f, 0.04012788f, -0.09847765f, -0.02415782f, 0.22501369f, -0.00150549f, -0.00928926f, 0.08929487f, 
    -0.07752900f, -0.10447789f, 0.10168014f, 0.05686943f, 0.08041193f, -0.01235135f, 0.02615136f, -0.02059378f, 
    0.05705870f, 0.03277414f, 0.08295207f, 0.06101748f, -0.00977504f, 0.00804952f, 0.08527311f, 0.01792722f, 
    0.02694030f, 0.07328478f, -0.07955793f, -0.20096079f, 0.16834657f, 0.09424324f, 0.00665450f, 0.00511298f, 
    0.02507035f, 0.08840913f, 0.05599639f, -0.00368417f, 0.03803933f, -0.03121580f, 0.14822724f, -0.01071015f, 
    -0.06734040f, 0.00679248f, -0.00711365f, 0.00340151f, 0.21043929f, -0.04079849f, 0.06374683f, -0.07062493f, 
    0.06630072f, -0.06738052f, 0.00667582f, 0.01130291f, -0.12043171f, -0.12876844f, 0.01889812f, -0.04739068f, 
    0.08605864f, 0.03308145f, -0.03646543f, -0.02615142f, -0.05259684f, 0.03166781f, -0.05030964f, -0.03130208f, 
    0.23230371f, 0.01668790f, -0.05336717f, -0.01531676f, -0.17807524f, -0.08737281f, 0.03130288f, -0.00284677f, 
    0.03813602f, -0.01483895f, 0.03843135f, -0.03503918f, 0.12351221f, -0.02710306f, 0.04567193f, 0.03442436f, 
    -0.05482962f, -0.04104166f, 0.00016740f, 0.01862597f, -0.04108182f, 0.07183576f, -0.02712397f, -0.04482884f, 
    -0.06526173f, 0.04690123f, -0.01322424f, -0.03123428f, -0.01982928f, -0.00140628f, 0.03445563f, -0.03994529f, 
    0.02179276f, 0.03471335f, -0.04112462f, 0.02053377f, 0.06474498f, 0.00305657f, 0.03579871f, 0.05867798f, 
    0.24136096f, -0.11678662f, -0.13930617f, 0.03797862f, -0.15836285f, 0.06413855f, -0.01731113f, 0.06022279f, 
    -0.08567642f, -0.02841901f, 0.04059540f, 0.02590388f, 0.00121370f, 0.01765785f, -0.05753336f, -0.05656534f, 
    -0.03667215f, -0.00748127f, -0.09063543f, 0.02257404f, -0.18361644f, -0.28287435f, -0.13820037f, -0.03508912f, 
    -0.22148722f, 0.13431530f, 0.04883890f, 0.05504718f, 0.02556315f, 0.04202253f, 0.02551688f, 0.04489712f, 
    0.00044818f, -0.00355840f, 0.00457285f, -0.05656427f, -0.03659646f, -0.00155641f, -0.12285439f, -0.01930251f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06258205f, 0.00520106f, -0.05016214f, -0.03397912f, 0.00030229f, 0.01469899f, 0.00717034f, -0.02492670f, 
    0.00573717f, 0.01428401f, 0.01754653f, -0.00773837f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
