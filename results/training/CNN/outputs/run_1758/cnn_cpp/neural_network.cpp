#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38699919f, 0.38061485f, -0.88878775f, -0.13248740f, 0.60324883f, 0.36864030f, 0.18114066f, -0.48635122f, 
    -0.46321538f, 0.17960458f, -0.06655334f, 0.06986493f, -0.03556172f, 0.03942366f, 0.03677858f, 0.01019449f, 
    -0.34781060f, 0.13461037f, -0.08254374f, -0.43206674f, 0.13580605f, 0.07256542f, 0.37833789f, 0.26016054f, 
    0.19098656f, 0.17491017f, -0.66515476f, -0.19046484f, 0.17569715f, -0.61447096f, 0.06210547f, -0.38483775f, 
    -0.31606084f, -0.23049437f, -0.22047983f, -0.08926348f, -0.19523443f, -0.41490969f, 0.18976827f, -0.15639263f, 
    0.38022384f, 0.10165916f, 0.11319681f, 0.15118439f, -0.11848579f, -0.31698462f, -0.15540135f, -0.34875283f, 
    -0.26564953f, -0.62955010f, 1.21943724f, 0.33660984f, -0.13123918f, -0.23131058f, 0.69158292f, -0.68162513f, 
    -0.56914502f, -0.13514757f, -0.53725708f, -0.58752638f, -0.15400426f, -0.05634592f, 0.08370002f, -0.17317906f, 
    -0.28422678f, -0.01079834f, 0.29897958f, -0.03448732f, -0.11224488f, 0.03284501f, -0.04171583f, 0.02860788f, 
    0.13462402f, -0.03498175f, -0.03031494f, 0.60202646f, 0.41756997f, 0.77648723f, -0.32758063f, -0.23104088f, 
    0.12564699f, -0.00159598f, -0.01516463f, -0.34185603f, 0.05713746f, -0.17124091f, -0.12498268f, 0.17159356f, 
    0.09188437f, -0.41162083f, 0.02886987f, -0.12952805f, -0.31444383f, 0.35649073f, -0.35870421f, -0.08605307f, 
    0.06133919f, -0.33330515f, 0.13521490f, 0.30597740f, -0.73812038f, 0.77126998f, 0.63473070f, -0.79446369f, 
    -0.34750310f, 0.07403585f, 0.39082664f, 0.04995819f, 0.16992815f, 0.02126044f, 0.03430243f, -0.18831344f, 
    0.01189855f, -0.24668221f, -0.19041435f, 0.07776267f, -0.05214709f, -0.17627746f, 0.12556726f, 0.12759337f, 
    -0.01590140f, -0.07211367f, -0.38184977f, -0.24784192f, -0.58229089f, 0.44197723f, 0.22446157f, -0.54492128f, 
    -0.29923883f, 0.28539705f, -0.19394977f, 0.28690794f, 0.35573131f, 0.40247390f, -0.25496310f, 0.05526283f, 
    -0.01508864f, -0.16032764f, 0.33209187f, -0.29173192f, -0.00624464f, -0.24526726f, -0.21389294f, 0.02866468f, 
    -0.21773957f, 0.45174718f, -0.11589453f, -0.13340849f, 0.18236627f, 0.36171585f, 1.25287068f, 0.14870828f, 
    -0.08555602f, -0.09742390f, -0.71783692f, 0.26210713f, 0.26066622f, -0.04327498f, -0.15267079f, 0.40198234f, 
    0.07169152f, 0.27846837f, -0.30038261f, 0.00105657f, 0.13323294f, -0.05071443f, 0.18084827f, -0.05114459f, 
    0.23278873f, -0.30030605f, -0.22661375f, 0.04037042f, 0.00466620f, -0.24273245f, -0.30252692f, -0.43170545f, 
    -0.65858620f, -0.74073011f, -0.63030756f, -0.64742553f, 0.66121423f, 0.09339197f, -0.11742491f, 0.05645624f, 
    0.54411215f, -0.24100159f, -0.53707802f, -0.40296879f, 0.07651436f, 0.22876440f, -0.14822644f, 0.15890296f, 
    0.02519417f, 0.00612691f, -0.26069912f, -0.27025053f, -0.43046904f, -0.05178656f, -0.00600373f, -0.30190343f, 
    0.27938709f, -0.55869174f, 0.01606779f, 0.51917326f, 0.04284934f, 0.55197757f, -0.32318568f, 0.03668818f, 
    0.09204748f, 0.08745861f, 0.33387005f, 0.02437085f, -0.32517454f, -0.20196785f, 0.50124151f, 0.03387354f, 
    -0.34727877f, 0.29743508f, -0.18500203f, 0.07133501f, -0.21790464f, -0.08617065f, -0.04989452f, 0.39882734f, 
    0.52024090f, -0.67367125f, -0.63663703f, -0.26988769f, 0.19635178f, -0.11154836f, 0.03708310f, -0.27057609f, 
    -0.05921008f, -0.42223984f, -0.22278112f, -0.13223119f, -0.39214113f, 0.04787587f, -0.14967979f, -0.33329907f, 
    0.12728097f, 0.14361228f, -0.23607256f, 0.30435634f, 0.02003906f, -0.04859852f, 0.25591704f, 0.41795877f, 
    0.15679379f, 0.25378841f, -1.21230960f, -0.45027089f, -0.18266322f, -0.57515454f, -0.48557922f, 0.95000148f, 
    0.74194133f, 0.03633617f, 0.20187578f, 0.46443990f, 0.33621275f, -0.10201036f, 0.16503133f, -0.11164417f, 
    -0.06761080f, -0.37324706f, -0.35784301f, -0.11468671f, 0.30833760f, -0.11756831f, -0.11829986f, 0.10785384f, 
    0.30185762f, 0.08427387f, 0.01156648f, 0.17258856f, -0.10252208f, 0.07834855f, 0.46162575f, 0.52607328f, 
    0.61860925f, 0.41826221f, 0.20024283f, -0.22843792f, 0.16509880f, 0.64852321f, -0.39699060f, 0.03277669f, 
    -0.41086844f, -0.00675752f, 0.19510794f, 0.02727706f, -0.02796145f, 0.10526448f, -0.40071753f, 0.00161212f, 
    0.01942627f, 0.01432486f, -0.39285266f, 0.05260658f, 0.75597972f, 0.74886221f, -0.07108578f, 0.37945694f, 
    -0.55916798f, -0.40772229f, -0.46801719f, -0.07666869f, -0.08721063f, -0.28014326f, 0.53655672f, -0.40422544f, 
    0.06607042f, 0.21910617f, 0.17481606f, 0.17267847f, 0.29176319f, 0.02355333f, -0.07795532f, -0.40960190f, 
    -0.13902372f, -0.00537918f, 0.30840728f, 0.36474743f, 0.17438141f, -0.24410887f, 0.15772793f, 0.32170594f, 
    0.59163541f, 0.40721568f, -0.33606267f, -0.52197295f, 0.15859395f, 0.56812572f, 0.46658373f, 0.14013512f, 
    0.16987137f, -0.06311642f, 0.01504664f, 0.09500898f, -0.49504671f, 0.22623624f, 0.14019407f, -0.04682994f, 
    -0.34308299f, 0.16706221f, 0.25096533f, 0.30520678f, -0.11068914f, -0.10653715f, -0.61724561f, -0.40428075f, 
    -0.34931630f, 0.26107931f, -0.10557118f, -0.59809083f, -0.55119985f, -0.80026978f, -0.59033418f, -0.13352096f, 
    -0.04211288f, 0.20819975f, 0.57960027f, -0.49197093f, -0.07217892f, -0.21216953f, 0.16294020f, -0.18731271f, 
    -0.37398818f, -0.40800616f, 0.21896622f, 0.07171448f, 0.03703088f, 0.16504060f, -0.09219083f, -0.26850501f, 
    0.73539686f, -0.32451579f, 1.03455198f, -0.51004487f, -0.64799368f, -0.71124977f, -0.10952931f, 0.53302521f, 
    0.46731463f, -0.14063214f, -0.52665442f, -0.17353944f, 0.45118451f, 0.03510226f, -0.08865697f, 0.04879195f, 
    -0.04388233f, 0.11207665f, -0.11520378f, -0.27281287f, -0.08664054f, -0.32915226f, -0.12356789f, -0.27443275f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.39065230f, 0.05346860f, 0.32345182f, 0.26099151f, 0.16611297f, 0.43072712f, 0.36551502f, 0.11102223f, 
    0.47372770f, -0.12942560f, 0.38721311f, -0.03286985f, 0.06658256f, 0.13782932f, 0.13829292f, 0.29043704f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23764803f, 0.08865430f, 0.20133619f, -0.01813500f, -0.00368316f, -0.14475563f, 0.12436585f, -0.17771074f, 
    0.04092982f, -0.10626083f, 0.25068688f, 0.07202857f, -0.03964525f, 0.03449991f, 0.06209135f, 0.17047198f, 
    0.09208941f, 0.09479277f, 0.08924818f, 0.00838616f, -0.06386351f, -0.00379322f, 0.10145156f, -0.00419809f, 
    -0.52677125f, -0.21210067f, 0.01508716f, 0.29314330f, 0.08472443f, -0.07632907f, 0.03280513f, -0.05299420f, 
    0.02942014f, 0.05081891f, 0.06929328f, 0.07945210f, -0.57234895f, -0.17166986f, 0.13972165f, 0.29133657f, 
    0.08117196f, -0.10643160f, -0.24406256f, 0.02107133f, -0.04794214f, -0.01592234f, 0.28085396f, 0.03818575f, 
    0.10597044f, 0.02296945f, 0.06436026f, 0.12781839f, 0.05009931f, -0.04434886f, -0.12591650f, 0.05303884f, 
    0.01055402f, 0.20860128f, 0.02799408f, 0.16584338f, 0.02457166f, 0.12492337f, 0.03203809f, 0.12508346f, 
    -0.05022776f, -0.05920551f, 0.32238919f, -0.13382636f, 0.04199871f, -0.03282341f, 0.13132839f, 0.03976194f, 
    -0.61292458f, -0.07215855f, 0.09476478f, 0.02059064f, 0.06017976f, 0.12247556f, -0.32308477f, -0.07913539f, 
    0.05947480f, 0.04970939f, -0.05814486f, 0.06098201f, 0.43747044f, -0.03322790f, 0.26763630f, 0.10931160f, 
    0.30749926f, 0.18448390f, -0.05461943f, -0.15239711f, 0.09837487f, 0.05601371f, -0.05712710f, 0.07236698f, 
    -0.19654252f, -0.13296120f, 0.03044477f, -0.28020325f, -0.16719416f, -0.08334053f, 0.04537066f, -0.04953690f, 
    0.02883572f, 0.19478191f, 0.06501792f, 0.15362036f, 0.13451909f, 0.51922727f, 0.09398971f, 0.05646015f, 
    -0.04602353f, 0.05855358f, 0.19364262f, 0.24478450f, 0.00242053f, -0.08716142f, -0.04394959f, 0.16578740f, 
    0.55750871f, 0.00390427f, 0.22814055f, 0.08385713f, 0.14898682f, 0.26442242f, 0.06435464f, -0.04125918f, 
    -0.05555094f, 0.02182191f, 0.07550134f, -0.06204755f, -0.20058469f, -0.04676599f, 0.01488415f, 0.01702338f, 
    -0.08199928f, -0.08875970f, 0.03048140f, -0.11695080f, 0.15424165f, 0.01271573f, 0.14132257f, 0.16571636f, 
    -0.75558972f, -0.10063934f, 0.04172240f, -0.06789723f, -0.07763755f, -0.09885553f, -0.14375043f, -0.26131809f, 
    -0.03336442f, -0.03582924f, 0.07508305f, 0.22404975f, -0.06876860f, -0.18886040f, 0.17432655f, -0.27136749f, 
    0.03137301f, -0.01298897f, 0.00965200f, 0.07923799f, 0.18363133f, 0.17224914f, 0.07425500f, 0.20194161f, 
    0.35061553f, 0.13486323f, -0.09680883f, 0.05126457f, 0.18105146f, 0.19330998f, 0.22735976f, 0.34563830f, 
    0.06179172f, 0.02612896f, -0.16852933f, 0.10643471f, -0.47415653f, 0.25194886f, 0.34848556f, -0.27203089f, 
    0.12168122f, 0.04307228f, -0.13189797f, -0.25154206f, 0.01048544f, -0.03253789f, 0.08459413f, 0.10432745f, 
    0.12078483f, -0.13327029f, 0.12454373f, 0.05372506f, 0.03378952f, 0.08795554f, -0.00133769f, -0.18817922f, 
    0.06512072f, 0.03556732f, 0.05005862f, 0.01052024f, -0.01456858f, 0.05803948f, -0.09937175f, 0.39431757f, 
    -0.05359994f, -0.08559093f, 0.11484203f, 0.29988891f, 0.04519103f, 0.15419400f, 0.05234692f, -0.10519724f, 
    0.08135565f, -0.26921856f, -0.04896506f, 0.30335429f, -0.01883430f, 0.00377376f, 0.08895659f, 0.33768266f, 
    0.09198689f, 0.01629945f, -0.04449384f, -0.18955997f, -0.50393414f, -0.06473649f, 0.05512870f, -0.05117669f, 
    -0.16442135f, -0.02134708f, 0.15059413f, -0.09233970f, 0.01272763f, 0.11567092f, -0.06623920f, -0.12433194f, 
    0.31051871f, 0.15932171f, 0.16359788f, 0.08755457f, 0.05241295f, 0.03048971f, 0.12515597f, -0.07090493f, 
    0.15849417f, -0.07209329f, -0.05867014f, 0.09095022f, 0.27196613f, -0.03126279f, 0.06963077f, -0.02182620f, 
    0.18761083f, -0.22404943f, -0.08916040f, 0.05561152f, 0.05874354f, 0.13468949f, 0.20724988f, -0.19031398f, 
    -0.25018466f, 0.02895832f, -0.04999013f, -0.01688577f, -0.17859662f, -0.02687616f, 0.13537934f, 0.12883054f, 
    0.06584415f, 0.04057992f, 0.03076666f, 0.16899157f, -0.19825478f, -0.23738717f, -0.30382040f, 0.15470181f, 
    0.01747437f, -0.05723627f, 0.05686564f, 0.20855834f, -0.04560513f, 0.07924100f, 0.20254159f, 0.20428506f, 
    -0.16754279f, -0.07712490f, -0.08881737f, -0.25324348f, 0.11230544f, -0.09706539f, -0.06173277f, 0.11428624f, 
    -0.22236237f, 0.13468999f, 0.10387971f, -0.24824594f, -0.23585227f, -0.22094673f, -0.24607779f, 0.03413498f, 
    -0.09503645f, -0.09539227f, -0.41511428f, 0.02994739f, -0.01575625f, -0.08781944f, 0.10426795f, 0.09082647f, 
    0.29764715f, -0.22135045f, 0.20213565f, 0.22642942f, -0.01720953f, 0.00167942f, -0.21956205f, -0.03880667f, 
    -0.11170863f, -0.09683343f, 0.07704199f, 0.10122870f, -0.20484675f, -0.02749265f, 0.32824969f, -0.10309172f, 
    0.00645590f, 0.20329016f, 0.03751675f, -0.03116279f, -0.18239085f, 0.24251045f, 0.13821685f, 0.03026700f, 
    0.23255245f, 0.03757541f, -0.37944612f, 0.15496103f, -0.00837735f, 0.20174086f, 0.16460423f, 0.35456496f, 
    0.01299570f, 0.13159257f, 0.05792501f, -0.05346766f, 0.12183327f, 0.16115782f, -0.16961652f, -0.13965335f, 
    -0.06701165f, 0.26545420f, 0.11579693f, -0.23786278f, 0.11018654f, -0.06041852f, -0.01356442f, 0.01908164f, 
    0.00126192f, -0.12142933f, -0.09105980f, 0.20791891f, -0.12181135f, -0.06629336f, -0.08204366f, 0.05362355f, 
    -0.01941112f, 0.06100213f, -0.06405307f, -0.02158289f, 0.69569343f, 0.23223731f, -0.30818960f, 0.03516785f, 
    -0.09856910f, 0.13970090f, 0.39790258f, -0.02550387f, 0.07189608f, 0.11014936f, -0.09393244f, 0.04516212f, 
    0.26878271f, -0.00790139f, -0.00317747f, -0.03090130f, 0.11692102f, -0.14328142f, -0.08133604f, -0.14546771f, 
    -0.02328243f, -0.22980808f, -0.09626381f, -0.23770113f, -0.07334624f, -0.06583928f, 0.12975968f, 0.30227238f, 
    0.07498237f, -0.10777886f, 0.11913890f, 0.21976094f, 0.05591078f, 0.22014427f, 0.30462700f, 0.25753659f, 
    0.33229619f, -0.08404648f, 0.46622351f, 0.20361631f, 0.12716995f, 0.07464293f, 0.12691931f, 0.14294155f, 
    0.08711277f, -0.03841051f, -0.08338059f, -0.03315256f, 0.10844035f, 0.29111540f, 0.25672889f, -0.09923460f, 
    0.07534076f, -0.16343474f, 0.11025374f, -0.10784022f, -0.13484809f, -0.06389040f, 0.06003069f, 0.00155395f, 
    -0.08245831f, 0.18514647f, -0.01702181f, -0.04290757f, -0.04500180f, 0.25311056f, 0.13131452f, 0.02086083f, 
    0.07811346f, 0.00901821f, 0.11013873f, 0.38366672f, 0.26821584f, -0.05039242f, 0.05687853f, 0.04239181f, 
    0.22464117f, -0.12923683f, 0.13414580f, -0.08338180f, -0.01434273f, 0.15871714f, -0.02355620f, -0.17965832f, 
    -0.06739745f, -0.04529566f, 0.02141582f, 0.07041840f, -0.11629298f, -0.02340138f, -0.07203282f, 0.15998407f, 
    0.56417531f, 0.00849148f, 0.02767102f, 0.07340661f, 0.02108658f, -0.23988008f, 0.03133822f, -0.01359674f, 
    -0.02001558f, -0.04911919f, 0.12924428f, 0.15194342f, 0.19421627f, -0.05034820f, 0.16197929f, 0.41719881f, 
    0.15221626f, 0.00378691f, 0.10473360f, -0.10444345f, -0.01848429f, 0.03661179f, 0.02446160f, -0.13136046f, 
    0.00296795f, 0.09862033f, 0.06547119f, -0.10932003f, -0.28988418f, -0.14584076f, -0.00578179f, -0.24914809f, 
    0.17016584f, -0.03742843f, -0.23184413f, -0.04961983f, -0.24187741f, -0.19597559f, -0.07451852f, -0.20302449f, 
    -0.19166531f, -0.15407310f, -0.14804555f, 0.07187355f, -0.07098955f, 0.02749204f, -0.09006669f, -0.00246185f, 
    0.08627049f, 0.07077505f, 0.12184260f, 0.00239193f, 0.13398270f, 0.27874029f, 0.04065436f, -0.29816923f, 
    -0.07821880f, -0.02480598f, 0.07807419f, 0.09646980f, 0.19555701f, 0.31816846f, 0.07796130f, 0.19235134f, 
    0.31917250f, -0.10760850f, 0.03056158f, 0.01875016f, 0.04185181f, 0.21926709f, -0.02874938f, -0.09382124f, 
    -0.16940677f, -0.08064709f, -0.02573103f, -0.21320932f, 0.11069133f, 0.02224483f, 0.29300484f, 0.07765616f, 
    -0.03293638f, 0.28495792f, 0.05722440f, 0.05182108f, 0.10668561f, -0.09719460f, -0.00936302f, 0.00257864f, 
    0.04010399f, -0.14227577f, -0.03648040f, 0.03695149f, 0.31039751f, 0.09082126f, 0.11183673f, 0.20826174f, 
    -0.05553005f, 0.01643875f, -0.01192861f, -0.09212038f, 0.50487041f, -0.29035920f, 0.24014308f, 0.19620782f, 
    -0.11511811f, 0.11479463f, 0.17364106f, 0.15100317f, 0.12334961f, 0.13748375f, 0.35272524f, 0.17213584f, 
    0.04317184f, 0.34015772f, -0.18598750f, 0.15327626f, -0.18874519f, 0.09820905f, -0.01069589f, 0.10020920f, 
    0.07110090f, 0.06069481f, -0.09877568f, 0.15007322f, 0.25579789f, 0.29629201f, -0.04323610f, 0.08003370f, 
    0.06435554f, 0.10266228f, -0.00918842f, 0.21027222f, 0.08315180f, 0.04670542f, -0.16727012f, 0.15314560f, 
    0.65998381f, 0.35534152f, -0.28669479f, 0.01447700f, 0.11357256f, 0.15935865f, 0.17902595f, 0.35993159f, 
    -0.22580591f, -0.15951397f, 0.03749100f, 0.01102041f, 0.52943730f, -0.09430201f, -0.12452880f, 0.12513925f, 
    -0.22303098f, 0.18800204f, 0.28995532f, -0.04198729f, 0.10476027f, 0.12693574f, -0.25460178f, 0.25590980f, 
    -0.59260446f, -0.32338679f, 0.01374757f, -0.16519885f, -0.12999135f, -0.01554305f, 0.06490419f, -0.25153935f, 
    0.09352845f, -0.19422404f, -0.10524841f, -0.06158739f, -0.00651527f, 0.02184298f, 0.24159804f, -0.20225635f, 
    -0.23026617f, 0.16917162f, -0.14708367f, -0.03921723f, 0.25897700f, 0.02691583f, 0.03612687f, 0.02942311f, 
    0.39963678f, -0.26231548f, -0.00837340f, 0.08538857f, -0.01125476f, -0.13167726f, 0.27836031f, 0.07798784f, 
    -0.19058883f, -0.10271807f, 0.23019324f, -0.19701806f, 0.13612761f, 0.37833527f, -0.29441658f, -0.19465844f, 
    -0.03038993f, -0.04798768f, -0.05728316f, 0.45362139f, 0.05489368f, -0.01099483f, -0.11384968f, 0.00625883f, 
    0.21949922f, 0.02183333f, -0.06384131f, 0.25644645f, -0.05943083f, 0.14173894f, -0.08576618f, -0.05363493f, 
    0.24096607f, -0.14895721f, -0.06584205f, 0.04144620f, 0.05732958f, -0.07990123f, 0.20840178f, 0.16153933f, 
    0.16090205f, 0.10583181f, 0.01394411f, 0.04848333f, -0.20976605f, -0.11068848f, -0.12674074f, -0.12861603f, 
    -0.11762026f, 0.08444628f, -0.17565298f, 0.08419578f, -0.16497840f, -0.32096627f, -0.04733416f, -0.09388976f, 
    -0.05321229f, 0.16340889f, -0.12847877f, 0.06027338f, 0.06944633f, -0.19049847f, 0.06911007f, 0.57414061f, 
    -0.14460675f, -0.02564838f, -0.12634054f, -0.27197003f, 0.04286461f, -0.09398713f, -0.11819651f, 0.18455809f, 
    0.40055111f, 0.01144882f, -0.21187577f, 0.17405546f, 0.09499032f, -0.01835842f, 0.20873155f, 0.14824960f, 
    -0.10352051f, -0.00814139f, -0.07607914f, -0.06873174f, -0.36440146f, 0.09512763f, -0.00248589f, 0.00759933f, 
    -0.02125875f, -0.01612343f, 0.02710619f, -0.32848102f, -0.12340016f, 0.17395915f, 0.02247151f, -0.04366645f, 
    -0.19498134f, 0.25340074f, 0.65536982f, 0.30571344f, -0.06849696f, 0.13238135f, -0.12583475f, 0.04258191f, 
    0.02528469f, -0.02874792f, 0.17619278f, 0.09417002f, 0.18347742f, 0.06192690f, -0.05275957f, 0.24733660f, 
    0.05885155f, 0.20257208f, 0.48335764f, 0.00764233f, 0.14307752f, -0.01444537f, -0.06317587f, 0.07313006f, 
    0.01961917f, -0.03762483f, -0.06906846f, -0.05572110f, -0.01331388f, 0.03637339f, 0.04510275f, -0.04773388f, 
    0.03026722f, -0.04935914f, 0.04098652f, 0.02301341f, -0.02178803f, -0.07501185f, 0.02028428f, -0.06271933f, 
    -0.01323149f, 0.01911817f, -0.06424968f, 0.04096092f, -0.02608573f, -0.02991725f, -0.04870086f, 0.05446107f, 
    -0.01936219f, -0.03557656f, -0.07137166f, -0.07803437f, 0.05422084f, 0.02824506f, 0.04047913f, -0.04872338f, 
    0.05335492f, 0.04100327f, 0.02393364f, -0.00269536f, 0.00880838f, -0.00375213f, 0.03721257f, -0.00871642f, 
    0.00982465f, 0.00325983f, -0.06742045f, -0.06493417f, -0.06802181f, -0.01778185f, 0.03001423f, 0.02952444f, 
    0.00632825f, 0.06150206f, -0.04850834f, -0.00896964f, 0.00212306f, -0.02434963f, -0.07655682f, 0.03795152f, 
    -0.05884298f, 0.02507482f, -0.00614245f, -0.05726335f, -0.01073431f, -0.00427489f, 0.00952153f, -0.00825529f, 
    -0.02419451f, 0.02609759f, -0.05044046f, -0.05476300f, 0.04309245f, 0.00750797f, 0.00483803f, -0.03125046f, 
    -0.02717612f, 0.02918483f, -0.07443112f, -0.05041381f, 0.04665508f, -0.03407982f, -0.02877022f, -0.03481234f, 
    -0.01835687f, 0.01603175f, -0.03361919f, -0.00896494f, 0.00399287f, -0.02783421f, 0.01678168f, -0.02310361f, 
    0.01988273f, -0.07028311f, 0.02385776f, 0.02842497f, 0.03205770f, -0.00680466f, 0.04017397f, -0.06784131f, 
    -0.03674177f, 0.05422541f, -0.03637839f, -0.02697074f, 0.02367061f, -0.07372594f, -0.02459229f, 0.03959697f, 
    -0.07694439f, 0.04660257f, 0.05250388f, -0.07523306f, 0.00212222f, 0.03278011f, 0.03195299f, -0.05235957f, 
    0.01616397f, 0.03812416f, -0.00886404f, -0.02895071f, 0.01396872f, 0.02704902f, 0.03539201f, -0.07096475f, 
    -0.03611692f, -0.00090538f, -0.05428028f, -0.02439794f, 0.02712101f, 0.02548288f, 0.02755628f, 0.00041507f, 
    -0.06826111f, 0.01634164f, -0.00954945f, 0.02576947f, 0.05176215f, -0.00868392f, -0.05936071f, 0.04222613f, 
    -0.02353022f, -0.04854500f, -0.06288283f, -0.07100824f, 0.00620658f, -0.03635827f, 0.02726948f, -0.01049770f, 
    -0.03562557f, 0.03904120f, 0.04902794f, 0.01043323f, 0.03940539f, 0.01609144f, 0.04917250f, 0.03627246f, 
    -0.00630118f, 0.04393348f, -0.01065531f, -0.05350584f, -0.01161266f, -0.00977796f, -0.08326814f, 0.02140215f, 
    -0.01856783f, 0.04513228f, -0.02693370f, -0.06855809f, -0.04681361f, 0.03434192f, -0.04046836f, 0.02058897f, 
    -0.07691354f, 0.05214452f, -0.06979184f, -0.05706732f, 0.05501006f, 0.03242061f, 0.02471741f, -0.04790047f, 
    0.01474673f, 0.04121736f, -0.05623595f, -0.06726407f, -0.07292141f, -0.01387876f, 0.05396587f, -0.04303053f, 
    -0.07745261f, 0.04692274f, 0.01462781f, 0.06359524f, -0.03364131f, -0.05243777f, 0.00161505f, -0.00910491f, 
    0.05601839f, 0.03641199f, 0.01441456f, 0.13924539f, 0.04677329f, -0.22278288f, -0.04193688f, 0.12799360f, 
    -0.06594665f, 0.03451437f, -0.14351076f, -0.03966796f, -0.02459721f, -0.17622748f, -0.01782558f, 0.21635450f, 
    0.21957356f, 0.06714874f, 0.22073908f, -0.02266534f, 0.29387876f, 0.05838631f, 0.09441379f, 0.06055452f, 
    0.13921604f, 0.01006083f, 0.33345717f, -0.07235797f, -0.02574464f, 0.02217561f, -0.01506728f, -0.27063927f, 
    -0.07095958f, -0.01326026f, -0.13632105f, 0.06941614f, 0.62671113f, 0.19041137f, 0.45366520f, -0.37101614f, 
    0.08615382f, -0.08419482f, 0.08046570f, -0.16222745f, -0.11768132f, -0.03388792f, 0.09261015f, 0.04359068f, 
    0.29121202f, -0.04035885f, 0.10066912f, 0.04648896f, -0.00550813f, 0.19218539f, -0.07704146f, -0.09690209f, 
    0.11632292f, 0.11767594f, 0.33221447f, 0.14903311f, -0.01428751f, 0.09637970f, 0.06138666f, 0.05576106f, 
    0.17282265f, -0.04080562f, 0.10765295f, 0.05189780f, -0.01426768f, 0.21758188f, 0.10165445f, -0.09802359f, 
    0.15564750f, 0.04374914f, 0.03029162f, 0.21597545f, -0.06752704f, -0.09307123f, 0.03412817f, 0.09571946f, 
    0.15740249f, 0.05446230f, 0.16623439f, 0.04447126f, -0.05359669f, -0.05946011f, 0.06834926f, 0.03671987f, 
    -0.00302680f, 0.11333879f, 0.25383639f, -0.06740874f, 0.14590403f, -0.00095726f, 0.03861190f, 0.13069034f, 
    0.01819676f, 0.20455322f, 0.08066853f, 0.03147963f, -0.01088036f, -0.00621456f, 0.01389573f, -0.04588658f, 
    0.05016770f, -0.04393636f, -0.04608865f, -0.22706117f, 0.08442556f, -0.05043798f, -0.08238603f, -0.23688991f, 
    0.20411341f, -0.12841477f, -0.00117496f, -0.02255807f, -0.13244191f, -0.03096506f, -0.21192043f, -0.18447824f, 
    -0.22017813f, -0.12112970f, -0.13984784f, -0.09353380f, 0.06535984f, -0.15441671f, 0.11888307f, 0.16947575f, 
    0.03041519f, -0.04394951f, 0.01447830f, 0.16077553f, 0.08082605f, 0.31473163f, -0.02052566f, -0.30767402f, 
    0.00611589f, 0.00884712f, 0.02733981f, -0.03684372f, 0.17403637f, 0.06677234f, 0.25539413f, -0.04295221f, 
    0.33407211f, -0.00425949f, 0.14368035f, -0.16502206f, -0.00651658f, -0.07243545f, -0.04288797f, -0.19973177f, 
    -0.06634405f, -0.14249390f, -0.04231196f, -0.03541712f, 0.14226325f, 0.09141680f, 0.09833355f, -0.00957432f, 
    -0.17034701f, 0.16279700f, -0.14450359f, 0.18042864f, -0.18573079f, -0.14375952f, -0.04456007f, -0.15128574f, 
    -0.16033907f, -0.44761771f, -0.44916856f, -0.02443053f, 0.00064265f, -0.03316798f, -0.10085570f, -0.19786707f, 
    -0.10618898f, 0.04758873f, -0.07319317f, -0.05347062f, -0.02680041f, -0.00730058f, 0.26651385f, -0.13847822f, 
    -0.06569149f, 0.15369906f, 0.10400037f, 0.19387637f, 0.17764759f, 0.06706465f, 0.33098787f, 0.03277069f, 
    -0.19468638f, 0.34420970f, -0.17012595f, 0.11390709f, -0.11139020f, 0.00913854f, 0.05180683f, -0.12186871f, 
    0.08121389f, 0.00904901f, 0.10019781f, 0.27257252f, -0.09417629f, 0.00806895f, -0.24430996f, 0.29341915f, 
    0.05392750f, 0.05992524f, 0.19422720f, 0.02180404f, -0.17902277f, -0.12760064f, -0.06403654f, -0.24574731f, 
    -0.01200213f, -0.13902038f, 0.15278576f, 0.44641283f, -0.05098173f, 0.14542584f, 0.00171450f, 0.07191584f, 
    -0.07162633f, -0.06595684f, -0.06129427f, 0.03767749f, -0.19595721f, 0.02884649f, 0.23718645f, 0.07495296f, 
    -0.08613515f, -0.10923455f, -0.08646500f, -0.05909260f, 0.00988535f, 0.18726717f, 0.08928528f, 0.26269418f, 
    0.31469601f, -0.29752254f, 0.32099301f, -0.13636138f, -0.07792706f, 0.13568889f, -0.03008148f, -0.00472191f, 
    0.00777965f, 0.07869674f, -0.10092457f, -0.36408484f, 0.10862521f, 0.33119816f, 0.11798579f, 0.08358429f, 
    -0.05950235f, -0.16622993f, -0.01855411f, -0.00027193f, 0.00989453f, 0.12371973f, 0.37114576f, 0.34681696f, 
    -0.36894509f, -0.06615032f, -0.11263325f, 0.26503727f, -0.10324176f, -0.09402585f, -0.10272118f, 0.15189193f, 
    0.02557451f, 0.13487063f, -0.01424266f, -0.08240096f, -0.06392981f, -0.19151677f, -0.37125152f, 0.08249208f, 
    0.22253458f, 0.10434972f, 0.23660624f, 0.14025477f, -0.10718323f, -0.08937865f, -0.18408778f, -0.13138886f, 
    -0.12705608f, 0.09297551f, -0.06152890f, 0.00271086f, 0.05917639f, -0.09834065f, -0.06624687f, 0.02250054f, 
    0.26727173f, -0.06457610f, 0.20837124f, 0.18707789f, 0.11231736f, 0.08330079f, -0.09029213f, 0.10323730f, 
    0.19479384f, 0.04511417f, -0.12371825f, -0.03610031f, -0.14327824f, -0.01699992f, -0.10955375f, 0.12622336f, 
    0.10472953f, -0.37409890f, -0.18148379f, -0.06150591f, 0.12401829f, 0.25915736f, 0.17544371f, 0.16186914f, 
    0.13843186f, 0.20876803f, 0.14566629f, 0.07668517f, -0.28540298f, 0.18664944f, -0.01605699f, -0.15229730f, 
    -0.09469584f, -0.02573301f, 0.08512091f, -0.17601047f, -0.02135551f, -0.04085661f, 0.20064794f, 0.06044334f, 
    0.21120536f, -0.10579886f, -0.09133881f, -0.07428207f, -0.04594501f, -0.00693906f, -0.05394479f, -0.05028887f, 
    0.06764691f, 0.08167241f, 0.15481170f, 0.15578954f, 0.06572273f, 0.15098396f, -0.02965840f, -0.41968390f, 
    -0.08527517f, -0.08890969f, 0.01900873f, -0.06233080f, -0.04413571f, 0.21213889f, -0.06765547f, 0.08696129f, 
    0.10149407f, -0.11520564f, -0.27917480f, 0.00276250f, 0.08026572f, 0.23071697f, -0.06511202f, 0.19059056f, 
    -0.15800728f, 0.09009589f, 0.04877863f, 0.07831167f, 0.02997838f, 0.13354719f, 0.12641421f, -0.23362789f, 
    0.02557187f, 0.18971074f, 0.14046009f, 0.14054532f, 0.07686917f, -0.07451033f, -0.14230026f, -0.21404089f, 
    -0.18923710f, 0.00184166f, -0.14585952f, -0.05374818f, -0.06242927f, 0.30268604f, 0.08535315f, 0.12205463f, 
    -0.03696226f, -0.02792552f, 0.07562692f, 0.20138028f, 0.18558848f, 0.25653997f, 0.08567468f, -0.15354097f, 
    0.00819186f, 0.12930104f, -0.16977184f, 0.01329042f, 0.11624941f, -0.03978364f, 0.04489421f, 0.07365526f, 
    -0.02888280f, 0.09269021f, -0.01669540f, -0.01431828f, 0.14036897f, 0.14552717f, -0.15399553f, 0.12866533f, 
    -0.06937024f, 0.00578797f, 0.05987053f, -0.02431711f, -0.24784002f, -0.22165075f, -0.17992754f, 0.16428670f, 
    -0.14687423f, -0.00395212f, -0.03288044f, 0.06678931f, 0.06169645f, 0.09978266f, -0.03496719f, -0.10057914f, 
    0.04951762f, -0.08999198f, -0.10128978f, 0.04155415f, 0.02371880f, -0.27893215f, 0.01955127f, 0.04922383f, 
    0.15664405f, -0.03387951f, -0.07118053f, -0.07526197f, -0.14301531f, -0.01498977f, 0.07616856f, -0.13443908f, 
    -0.27764839f, 0.12419672f, -0.04963123f, 0.03737372f, 0.12211856f, -0.07076737f, -0.24901278f, 0.33575940f, 
    -0.13760957f, -0.14260904f, -0.14591034f, -0.07235522f, 0.06532618f, 0.02223622f, -0.18374959f, -0.07622631f, 
    0.03350122f, 0.00902654f, 0.04554943f, 0.05753604f, 0.00836378f, 0.57641697f, 0.25957707f, 0.31150225f, 
    0.26170036f, 0.22908597f, 0.01872269f, -0.06348441f, 0.19537261f, 0.12833293f, -0.01308437f, -0.03612346f, 
    -0.38070112f, -0.04148509f, -0.19840100f, 0.14530922f, -0.02584912f, 0.05724831f, -0.02296576f, 0.10470200f, 
    0.03063163f, 0.02445398f, -0.00858232f, 0.13490881f, 0.12480450f, 0.20108567f, 0.29510662f, 0.45161459f, 
    -0.03104700f, 0.15751366f, 0.40951538f, 0.04605828f, 0.04715087f, -0.03800972f, -0.01623006f, 0.11558431f, 
    0.15803652f, 0.60928452f, 0.39549717f, 0.15756518f, 0.08610453f, 0.01700626f, 0.19118249f, 0.06983146f, 
    0.05800839f, 0.23301162f, -0.03168741f, -0.04033257f, -0.19124104f, -0.31525266f, -0.26041242f, 0.39950988f, 
    -0.07687018f, -0.16737813f, -0.08914399f, -0.02241108f, -0.11521935f, 0.03810226f, -0.08984736f, 0.31856534f, 
    -0.51762503f, -0.25932562f, -0.15166493f, -0.03709993f, 0.11094014f, 0.05082275f, 0.05680197f, -0.17570505f, 
    -0.15412833f, -0.01241952f, -0.02599705f, 0.15041849f, -0.33962831f, -0.05841820f, -0.13773616f, -0.07479301f, 
    0.00634815f, -0.35000944f, 0.06528118f, 0.02474945f, 0.00018471f, 0.06217041f, 0.10258833f, 0.20637606f, 
    0.19465703f, 0.28083760f, 0.42059302f, -0.00100549f, 0.16758890f, 0.15310515f, 0.18587647f, 0.06819945f, 
    -0.00827755f, 0.08882923f, 0.11181072f, 0.20778689f, -0.25006577f, 0.27291426f, -0.04416123f, 0.06511886f, 
    0.07604908f, 0.17935711f, 0.12389787f, -0.11073938f, 0.01171233f, 0.02192712f, 0.02216784f, 0.08830644f, 
    0.26226461f, 0.06691060f, -0.25437620f, 0.31128934f, -0.04480069f, 0.27092361f, -0.11393311f, 0.27232715f, 
    -0.15558663f, -0.14290132f, -0.01977285f, 0.04701249f, 0.26454622f, 0.11197287f, 0.19879153f, -0.10463623f, 
    -0.02421401f, -0.04661956f, 0.00218653f, 0.13680080f, 0.02071937f, 0.01360974f, 0.03258101f, 0.10820886f, 
    0.55195379f, 0.37794429f, 0.12878625f, -0.43360430f, -0.00304293f, -0.03250667f, -0.12834927f, 0.00378898f, 
    -0.11113088f, 0.00144118f, 0.03446231f, -0.03053601f, 0.31437036f, 0.07509820f, 0.18305032f, -0.01842362f, 
    0.00631994f, -0.00742207f, 0.01505562f, 0.07877345f, 0.01175029f, 0.09408654f, 0.10560762f, 0.01987006f, 
    -0.40019563f, -0.25524214f, -0.01100316f, -0.19813411f, 0.10212155f, -0.06173853f, 0.11891615f, -0.01822908f, 
    0.06306341f, -0.04633540f, 0.14362276f, 0.14102383f, -0.08519675f, -0.29000857f, 0.13486664f, -0.01607613f, 
    -0.04220345f, 0.26640716f, -0.28134114f, 0.34670249f, -0.08956774f, -0.22027260f, 0.04302284f, -0.03312792f, 
    0.15672529f, -0.09620318f, -0.16711088f, 0.07856344f, 0.02894559f, 0.01423967f, 0.12863785f, 0.12848748f, 
    -0.10987658f, -0.09213188f, 0.02151228f, 0.07687873f, 0.11539432f, 0.29803020f, 0.24251564f, -0.02295325f, 
    -0.01187480f, -0.17309876f, -0.06366172f, 0.05292828f, -0.07602274f, 0.06351187f, 0.03156606f, 0.06405269f, 
    0.01514780f, 0.19679664f, -0.17491798f, 0.39809105f, 0.00542312f, 0.11882263f, 0.10676569f, -0.05041654f, 
    -0.15288517f, -0.08765740f, -0.02224436f, -0.18602251f, 0.35242099f, 0.13923021f, 0.26376072f, 0.07376175f, 
    -0.03500843f, 0.06122356f, 0.22004648f, -0.15260579f, 0.07227582f, -0.12841216f, 0.00916119f, -0.08978241f, 
    -0.31156099f, 0.47094238f, -0.18913479f, 0.16283700f, -0.11046603f, -0.08007685f, -0.10656286f, 0.02027179f, 
    -0.10987562f, -0.13302143f, 0.00777124f, 0.02808881f, -0.16510007f, -0.03895064f, -0.26223704f, 0.23786686f, 
    0.08949447f, 0.18496431f, -0.03808741f, 0.04287802f, 0.09114832f, 0.20544794f, 0.08097847f, -0.00461474f, 
    0.30695805f, 0.00989324f, 0.08805481f, 0.07417025f, 0.26622328f, -0.09620509f, -0.02509260f, 0.07705572f, 
    0.00311478f, 0.07365295f, -0.00576943f, 0.08931927f, -0.06172708f, 0.25318182f, 0.00186996f, 0.19770600f, 
    0.14389099f, -0.04898446f, 0.10676970f, -0.06959017f, 0.03681363f, -0.21880320f, 0.00539684f, -0.09568030f, 
    -0.01882722f, 0.35369590f, 0.15155263f, 0.00683970f, -0.05675208f, -0.15048030f, 0.06357868f, -0.16598172f, 
    0.02584635f, -0.09458125f, -0.03199972f, -0.05930760f, -0.33671686f, -0.05553581f, 0.03667995f, -0.02437497f, 
    0.21598323f, -0.42813274f, 0.14884394f, -0.01601512f, 0.28817192f, -0.04683386f, 0.04137274f, 0.22592571f, 
    0.03711557f, -0.07816575f, -0.05014122f, -0.35815001f, -0.09003339f, -0.07616605f, -0.06894037f, 0.30212706f, 
    0.10307717f, -0.00009457f, 0.10151479f, -0.19736233f, 0.03867994f, 0.14239238f, 0.27899158f, -0.03347778f, 
    0.02370661f, 0.08059859f, 0.01945152f, -0.02699091f, -0.09342092f, -0.19365393f, 0.03057686f, 0.04870055f, 
    0.27635822f, 0.40184131f, 0.14243418f, -0.20338412f, -0.04258099f, -0.08253724f, 0.07956544f, -0.04642930f, 
    -0.11474743f, -0.03458988f, -0.03796002f, -0.02039255f, -0.05020108f, -0.13594335f, -0.29413635f, 0.02518990f, 
    0.01051892f, 0.03735335f, 0.00817083f, -0.02815347f, 0.00618379f, 0.07646307f, -0.06703787f, -0.06311996f, 
    -0.55084854f, -0.04233596f, -0.19885597f, -0.10106312f, 0.12211096f, -0.14748935f, -0.05135138f, -0.02278818f, 
    -0.17880866f, 0.01032527f, 0.06724294f, 0.05923786f, 0.06776969f, -0.36284167f, -0.14480418f, -0.04396811f, 
    -0.10376177f, 0.03732570f, -0.01551485f, -0.04971131f, 0.20369300f, 0.14044520f, 0.07479807f, 0.13452473f, 
    0.03498183f, -0.21782653f, -0.10159242f, -0.16345392f, 0.12708390f, -0.02182620f, -0.09684442f, -0.12724492f, 
    0.43765506f, 0.05377360f, 0.15834069f, 0.08108233f, 0.14853172f, 0.15620093f, 0.39766735f, -0.07536044f, 
    -0.05729510f, -0.09980287f, 0.05158340f, 0.11884621f, 0.10299716f, -0.18332900f, -0.05012018f, -0.03632092f, 
    -0.03870695f, -0.25430340f, 0.05219620f, -0.05885235f, 0.05018501f, 0.06252319f, 0.11427542f, -0.04018138f, 
    0.10737635f, 0.02121545f, 0.00458650f, 0.26957217f, -0.04116352f, 0.13852257f, 0.39566442f, 0.21379095f, 
    -0.11304810f, 0.19521162f, 0.25388432f, 0.04492639f, 0.07468737f, 0.07070953f, -0.11748857f, 0.06167249f, 
    -0.08343664f, 0.39536038f, -0.03008325f, -0.20377053f, -0.06894355f, 0.01514874f, 0.18594056f, -0.03276967f, 
    0.02060804f, 0.05928542f, 0.03670762f, 0.02126952f, -0.05619697f, -0.24622260f, -0.38124850f, 0.11568820f, 
    0.01433747f, -0.05387091f, -0.01439555f, -0.01496404f, -0.03120061f, -0.02223543f, -0.12281629f, 0.10570735f, 
    -0.05484216f, 0.04956234f, 0.14085791f, -0.09245529f, 0.14621872f, 0.04369579f, 0.04269272f, -0.03834761f, 
    -0.01662352f, 0.03315672f, -0.02111425f, 0.09059228f, -0.20256938f, -0.30623254f, -0.01079457f, 0.15679567f, 
    -0.00028770f, -0.00003216f, -0.02649944f, 0.05836614f, 0.21395987f, 0.11104298f, 0.02097886f, 0.11878008f, 
    -0.01667925f, 0.19901618f, 0.50024825f, 0.23972663f, -0.04795412f, 0.06139066f, 0.23896950f, 0.30620503f, 
    0.11565043f, -0.15249938f, 0.12460795f, 0.02443237f, -0.15579818f, -0.28577411f, 0.27387884f, 0.25797066f, 
    0.00947060f, -0.26923236f, -0.18236499f, -0.02256089f, -0.01494019f, 0.05807703f, 0.02116562f, -0.03704555f, 
    -0.33613703f, 0.14760308f, -0.30839258f, 0.59510231f, 0.07600072f, -0.10191406f, -0.00066919f, -0.02174329f, 
    0.05403947f, -0.13535640f, -0.08515504f, 0.05047858f, 0.11598886f, -0.01732837f, 0.00321800f, 0.17517172f, 
    0.21596377f, -0.04807203f, 0.10313680f, 0.11384638f, -0.01273720f, 0.00834622f, 0.08690647f, 0.05923790f, 
    -0.08807041f, 0.03995901f, 0.30417639f, 0.06974471f, -0.12376302f, -0.01313907f, 0.06296840f, -0.00584361f, 
    -0.08442290f, 0.14737073f, -0.09767181f, 0.01096880f, 0.11548934f, -0.11232352f, 0.52335966f, -0.06942935f, 
    0.22437486f, -0.04717549f, 0.07420664f, -0.07433319f, -0.17135237f, -0.30762067f, 0.24627379f, -0.29756945f, 
    0.41907945f, -0.25145972f, 0.02778120f, 0.05483953f, -0.00059590f, 0.21995600f, -0.08485336f, -0.00512717f, 
    0.07123378f, 0.19418953f, 0.28224775f, 0.03216387f, -0.01517236f, -0.11348192f, -0.15090404f, 0.57412523f, 
    0.09258621f, 0.01607066f, 0.18116261f, 0.21812916f, -0.17714448f, -0.13451229f, 0.15429385f, -0.05718711f, 
    -0.74718469f, -0.00863413f, -0.07254346f, 0.38831750f, -0.28448394f, 0.13411036f, -0.08910888f, -0.13450499f, 
    -0.00699837f, 0.04397119f, -0.02959734f, 0.17157035f, 0.42680210f, -0.00475189f, 0.09815276f, 0.07248926f, 
    0.21191870f, 0.20053685f, 0.16351275f, -0.22567207f, -0.04840190f, 0.06845328f, 0.02777668f, 0.07165322f, 
    -0.20743173f, 0.36456302f, -0.09152421f, -0.36161801f, -0.23791125f, -0.35781714f, 0.06613518f, -0.27859145f, 
    -0.21398135f, 0.04564432f, -0.09488249f, -0.26509976f, 0.39226153f, 0.19002254f, -0.15794493f, -0.11094480f, 
    0.14254534f, 0.04421875f, 0.10835651f, 0.07352945f, 0.07826079f, -0.02109455f, -0.13494220f, -0.09051993f, 
    0.39206991f, 0.00434490f, -0.11831778f, 0.14041568f, 0.17403451f, 0.22701557f, 0.04310951f, 0.15688105f, 
    -0.08067092f, -0.11351777f, 0.22554854f, -0.04632956f, -0.29413363f, 0.11487547f, -0.18252850f, -0.15728252f, 
    0.01595316f, 0.21781673f, 0.03163044f, -0.15717353f, 0.03290628f, -0.02845777f, 0.29634136f, 0.08487779f, 
    0.11732838f, 0.09589490f, 0.57861745f, -0.27101326f, -0.11104717f, 0.01809898f, 0.00440480f, -0.02012470f, 
    -0.14209707f, 0.19984135f, 0.00683869f, -0.00400795f, 0.26995999f, 0.02201762f, 0.44396457f, -0.39058009f, 
    0.13319953f, 0.01300010f, -0.23656113f, 0.06121650f, -0.10781583f, -0.20690349f, -0.19702780f, -0.20902359f, 
    0.23247388f, 0.21892579f, -0.27950346f, 0.00542675f, -0.02469296f, -0.02546696f, 0.12217151f, 0.05430704f, 
    -0.03692955f, 0.05251879f, -0.32978892f, -0.01595387f, -0.41539559f, 0.11848524f, 0.40885308f, -0.54274976f, 
    -0.04259875f, -0.07543090f, -0.35165414f, -0.09722576f, -0.00808271f, -0.17876613f, 0.15743509f, 0.02327736f, 
    0.00924514f, 0.05602858f, 0.01230664f, 0.02570993f, 0.00445702f, 0.03420583f, 0.00192297f, -0.01068867f, 
    -0.03681533f, 0.05763888f, -0.04799220f, -0.03851221f, -0.03134469f, -0.03705243f, 0.05401663f, 0.05822871f, 
    0.05719092f, -0.02647707f, -0.01015370f, -0.03801699f, -0.02218006f, -0.00851967f, 0.04318649f, -0.03419934f, 
    -0.05407244f, 0.06954581f, 0.04613564f, -0.00288865f, 0.01274249f, -0.06788272f, -0.05916857f, 0.01441992f, 
    -0.07780997f, 0.04607006f, 0.00761863f, -0.07217325f, 0.05858451f, 0.03803718f, -0.02209735f, 0.02014529f, 
    -0.00750344f, -0.01066260f, 0.01264513f, -0.00082216f, -0.03427052f, -0.02616982f, -0.03113995f, 0.03919636f, 
    -0.05627666f, -0.02625988f, 0.00035864f, -0.03481568f, -0.02960718f, -0.06310778f, 0.07168936f, 0.01245534f, 
    -0.04572491f, 0.01616864f, 0.04006891f, -0.00693420f, 0.01571962f, -0.00301113f, 0.05821134f, -0.00908970f, 
    -0.07034324f, -0.04783797f, 0.02156082f, 0.00688770f, -0.02538491f, 0.04449517f, -0.07267833f, -0.05068002f, 
    -0.03773074f, 0.04165933f, 0.05800492f, -0.02580016f, -0.07295397f, 0.02344610f, -0.03081966f, 0.01459365f, 
    0.03816133f, -0.03846288f, 0.02611477f, 0.03717867f, -0.04482915f, -0.07154345f, -0.01627148f, -0.06630706f, 
    -0.01611174f, -0.03505741f, -0.06599147f, 0.05360529f, 0.03544598f, 0.01919910f, -0.00859904f, 0.04999423f, 
    0.02946286f, -0.06335630f, -0.06671482f, -0.02344012f, -0.05788528f, -0.01994921f, 0.00919798f, -0.01316543f, 
    0.01978562f, 0.05457732f, -0.03376270f, -0.05286237f, -0.02025475f, -0.06580824f, -0.05498935f, 0.02012364f, 
    0.04023798f, -0.07603550f, -0.01037761f, 0.04282140f, -0.06771069f, -0.07058620f, 0.03294803f, -0.00658315f, 
    0.01259355f, -0.06411596f, -0.04676017f, 0.06136322f, -0.02797552f, 0.03381559f, -0.01572456f, -0.05361870f, 
    -0.00774677f, -0.01245627f, -0.01342410f, -0.06547580f, -0.07068155f, -0.00434905f, 0.05329961f, 0.05760234f, 
    -0.01831689f, -0.06708836f, -0.07824624f, 0.05095284f, -0.03536644f, -0.06622210f, -0.01120666f, -0.02844888f, 
    0.05591660f, -0.01786351f, 0.00507540f, -0.07699113f, 0.05296467f, -0.03764962f, -0.06712906f, 0.05518693f, 
    0.06237011f, -0.04775504f, 0.00967885f, -0.04696912f, 0.04510714f, 0.03258522f, -0.05192428f, -0.01534660f, 
    -0.05009506f, 0.03730921f, 0.06820420f, 0.00673053f, -0.03149154f, -0.05838445f, -0.04777388f, -0.02603302f, 
    -0.06556273f, 0.02658124f, 0.05975049f, 0.01175644f, 0.00402819f, -0.00398926f, -0.05929985f, -0.07646988f, 
    -0.05131986f, 0.01151077f, -0.00636271f, -0.06160766f, 0.03232551f, 0.04757755f, 0.05178853f, -0.04307271f, 
    0.02401349f, -0.05929574f, 0.01975632f, 0.03339689f, 0.03377720f, 0.02479337f, 0.03777066f, 0.02245496f, 
    0.33525828f, -0.41052023f, 0.20254548f, -0.24098280f, 0.17733483f, 0.00075052f, -0.05470107f, 0.03453694f, 
    -0.06885593f, 0.02377005f, -0.05883881f, 0.01671343f, -0.18794434f, -0.09644181f, 0.01994527f, -0.04174014f, 
    0.07704534f, 0.16073094f, 0.08970651f, -0.02352248f, 0.17303516f, 0.06236123f, 0.07253794f, 0.02150814f, 
    -0.12444837f, -0.29692036f, -0.17293227f, 0.02021932f, 0.15183300f, 0.23738566f, 0.33830097f, 0.01168364f, 
    0.05790233f, -0.09019520f, 0.02547429f, 0.11581542f, 0.02579115f, 0.07012995f, -0.32898399f, -0.18624596f, 
    -0.05359314f, -0.06434946f, -0.13566434f, -0.02655178f, -0.04548329f, 0.04883554f, -0.11486781f, 0.03086230f, 
    0.21548168f, 0.19818871f, 0.13531193f, 0.14250956f, -0.00793057f, -0.08668914f, 0.05603246f, -0.06509697f, 
    0.04914866f, 0.10350391f, 0.19029438f, 0.17131266f, 0.00015638f, 0.14900973f, 0.13876896f, -0.19154072f, 
    0.11805627f, -0.24876304f, 0.09723086f, -0.26416743f, 0.16947466f, 0.22016793f, 0.09675768f, -0.08497429f, 
    0.46876690f, 0.07982668f, -0.37945399f, -0.21842603f, -0.00982580f, 0.09137956f, 0.06843337f, -0.20933765f, 
    0.17799546f, 0.17427179f, 0.18291329f, 0.19798473f, -0.35103780f, -0.04841427f, 0.19789003f, 0.20361896f, 
    -0.01043385f, 0.04121029f, 0.04356576f, 0.13032527f, -0.00197096f, -0.10262623f, 0.07375930f, 0.09432122f, 
    -0.01872939f, -0.17288871f, 0.02519580f, 0.00149800f, 0.01483337f, 0.03668221f, 0.09967469f, 0.11593556f, 
    0.19954260f, 0.03252435f, -0.03076132f, -0.06775708f, -0.36360335f, -0.23650375f, -0.04313241f, 0.13952330f, 
    -0.15690921f, -0.12952995f, -0.08141711f, 0.01844206f, -0.06318451f, -0.05946354f, 0.03720878f, -0.11725315f, 
    -0.28150517f, 0.33837169f, 0.81175601f, 0.20797499f, -0.03651298f, -0.09517007f, -0.21464969f, 0.00391524f, 
    0.11649545f, 0.00996391f, 0.19633351f, 0.09358755f, 0.19858052f, -0.01813498f, 0.36907640f, 0.04916383f, 
    0.10332928f, -0.12816675f, -0.26791814f, 0.08665923f, -0.02578411f, 0.19673501f, 0.12755841f, -0.07322527f, 
    0.05386241f, -0.34510559f, -0.54805005f, -0.37108013f, 0.06667857f, 0.18222161f, 0.18533434f, 0.03703652f, 
    0.03071025f, -0.06126005f, -0.11634614f, -0.29311803f, -0.26538375f, -0.13849340f, -0.36291954f, 0.16047950f, 
    0.24610388f, 0.17597659f, 0.00067741f, 0.08359917f, 0.10740619f, 0.08890855f, 0.00961078f, 0.04924474f, 
    -0.28377071f, -0.24549206f, -0.09727692f, 0.07555493f, -0.14596948f, -0.00619386f, -0.04361856f, 0.02211840f, 
    -0.05026363f, 0.01054942f, -0.04794166f, 0.06414338f, 0.19091681f, 0.18048434f, -0.55143344f, 0.30226725f, 
    0.06726188f, 0.09979621f, 0.15248919f, 0.29499629f, -0.02243279f, 0.22870284f, 0.21343952f, 0.15598907f, 
    0.38452810f, -0.07839983f, 0.09676300f, 0.17945640f, 0.08901445f, -0.04109093f, 0.04981830f, -0.09991228f, 
    0.01279070f, 0.05244574f, 0.03433227f, -0.05378680f, -0.19954368f, 0.14676252f, 0.03501813f, 0.21359766f, 
    -0.06647002f, 0.01782765f, -0.13802153f, -0.02465320f, 0.14339288f, -0.03327494f, -0.05088299f, 0.07576613f, 
    -0.00363332f, 0.02845091f, -0.48530903f, 0.17721522f, -0.04104877f, -0.19935334f, -0.00419923f, -0.04645712f, 
    -0.08438122f, -0.05250535f, -0.06371547f, 0.13478990f, 0.33834743f, -0.06400199f, 0.28596744f, 0.09394979f, 
    -0.25338936f, -0.07416756f, 0.01425917f, 0.07414237f, 0.09297607f, -0.07367826f, -0.00643929f, -0.08292603f, 
    0.71953887f, -0.02346028f, 0.01030161f, 0.00014504f, 0.04071118f, -0.18927827f, -0.13406534f, -0.11266721f, 
    -0.16805407f, -0.22310373f, -0.15060186f, -0.11691619f, 0.17777795f, 0.24949616f, 0.25781104f, 0.23188312f, 
    -0.09146077f, -0.01419156f, 0.19233024f, -0.05640002f, -0.01326111f, -0.09794488f, 0.01801908f, 0.08926237f, 
    0.26935437f, 0.10760197f, 0.00035114f, -0.18254641f, 0.06946088f, 0.01693555f, -0.06590930f, -0.21064590f, 
    0.08916768f, 0.19463742f, 0.10266216f, 0.02223858f, -0.04547946f, 0.29048783f, 0.20774965f, 0.33972174f, 
    -0.00069210f, 0.04622609f, -0.04952833f, -0.13013877f, 0.05623868f, 0.05416831f, 0.09486276f, -0.17964731f, 
    0.08084539f, 0.10023872f, -0.15870132f, 0.10214288f, 0.03022331f, -0.14897616f, -0.15784180f, -0.04209848f, 
    0.01927109f, 0.13698824f, -0.12539014f, -0.05197339f, -0.13651903f, 0.09236655f, 0.03772524f, 0.34076062f, 
    -0.25224215f, -0.08389669f, 0.28150743f, 0.05972073f, -0.03155550f, 0.00284147f, 0.04886268f, -0.08466328f, 
    0.27657759f, 0.27179137f, 0.48064408f, 0.05867112f, 0.17745197f, 0.07476327f, -0.07145693f, 0.02626501f, 
    0.00725433f, -0.03188344f, -0.02185764f, -0.03734538f, 0.19233467f, -0.22836135f, 0.21176594f, 0.31290832f, 
    -0.00343236f, 0.10077096f, -0.25440446f, -0.09696712f, 0.06024003f, 0.01285393f, 0.11623395f, 0.00262638f, 
    -0.17701116f, 0.00281595f, -0.03935573f, -0.12864563f, 0.02713783f, -0.09473991f, -0.02281640f, -0.25223047f, 
    -0.11814407f, 0.07929357f, -0.11586794f, 0.10397365f, -0.12995248f, 0.07933822f, -0.10393480f, -0.01009007f, 
    0.02003925f, -0.08804743f, 0.04930844f, 0.02953401f, -0.06023251f, -0.00603570f, -0.04116960f, -0.02489942f, 
    -0.43204194f, -0.27722022f, 0.13249490f, 0.39498609f, -0.28058288f, -0.11197575f, -0.02833713f, 0.11019085f, 
    -0.01079957f, 0.10449325f, 0.02590491f, 0.13996585f, -0.64483678f, 0.38317093f, -0.42198101f, -0.11409965f, 
    0.04441097f, -0.01980877f, -0.16180554f, -0.10224418f, -0.04065314f, -0.00808623f, -0.01022513f, 0.02580444f, 
    -0.17113777f, 0.18675293f, 0.15825440f, -0.31869751f, -0.07261757f, 0.04716577f, -0.06779204f, -0.22028069f, 
    0.16681150f, 0.16077963f, 0.19492376f, 0.16493823f, -0.13133517f, 0.07237647f, 0.08650962f, 0.16097373f, 
    -0.08928566f, -0.12885334f, 0.17982656f, 0.02346293f, -0.20059128f, -0.12963694f, 0.12145175f, -0.21666567f, 
    -0.09228606f, 0.08052240f, 0.41967869f, 0.53058851f, 0.01916226f, 0.22287863f, 0.04219919f, 0.05156157f, 
    0.02161593f, 0.06930542f, -0.07323896f, -0.21384224f, -0.59065843f, 0.14807415f, 0.17041887f, 0.16426155f, 
    -0.04487910f, -0.18876153f, -0.18194865f, -0.01479346f, 0.02267330f, 0.02412501f, 0.10107618f, -0.11256739f, 
    0.26142994f, 0.33844453f, 0.08895009f, 0.06362864f, 0.04742794f, -0.07343284f, -0.03809524f, -0.05151259f, 
    0.04163413f, 0.11367948f, -0.04431153f, -0.07084841f, 0.10625451f, 0.04245610f, 0.00061440f, 0.09001836f, 
    -0.09526756f, -0.11981963f, -0.03397745f, -0.08790466f, 0.05083081f, 0.04373804f, 0.20270810f, 0.14542706f, 
    -0.61112916f, -0.02192588f, 0.14474714f, 0.01744332f, 0.06420878f, -0.02901988f, -0.23406233f, 0.05342009f, 
    0.08042376f, -0.00534576f, -0.15489545f, 0.11830857f, -0.15359528f, -0.29578033f, 0.07548743f, 0.20351177f, 
    -0.07613567f, -0.00401042f, 0.16994801f, -0.02608742f, -0.12965803f, -0.14186430f, -0.14422606f, 0.06748663f, 
    -0.08557936f, -0.01795068f, -0.02219005f, -0.25729689f, -0.02225680f, -0.19745581f, -0.08608955f, 0.04227404f, 
    0.06592806f, 0.15910923f, 0.09789911f, 0.21872807f, -0.25732964f, 0.02487129f, -0.17578691f, 0.06834584f, 
    0.01612230f, 0.05866666f, 0.02436217f, 0.24806331f, 0.08323362f, -0.06885014f, 0.11116255f, 0.24306521f, 
    0.18597350f, -0.22059500f, -0.06259830f, -0.03848602f, -0.06397144f, 0.14387961f, 0.03631824f, -0.01770336f, 
    0.14123668f, 0.11422646f, 0.07556707f, -0.16862984f, 0.02461036f, 0.18166026f, 0.01249124f, -0.25795713f, 
    -0.18224984f, -0.10543200f, 0.06272051f, -0.11084213f, -0.09302485f, 0.10451686f, -0.07979676f, 0.13276605f, 
    -0.19164021f, 0.14919759f, 0.12134407f, 0.26203322f, -0.10108852f, -0.03127560f, -0.25779587f, 0.03016924f, 
    0.00866174f, -0.00468885f, 0.12929128f, 0.13457850f, 0.15009409f, 0.03524674f, 0.07474221f, -0.11070206f, 
    -0.04939191f, -0.10953768f, 0.01003286f, -0.11960152f, 0.06497701f, 0.13181370f, 0.16495652f, 0.23302542f, 
    0.13449375f, -0.18693818f, 0.08483712f, 0.07996024f, 0.17699265f, 0.17611349f, 0.10363744f, 0.22266598f, 
    0.12329807f, 0.00125866f, 0.11299781f, -0.05576384f, 0.54583120f, -0.16453008f, 0.23789276f, 0.20852590f, 
    0.09495214f, 0.02424918f, -0.03348793f, -0.05375167f, -0.11833245f, -0.04127280f, -0.14665028f, -0.14327767f, 
    0.06860609f, -0.01003383f, -0.01163734f, 0.03478032f, -0.00965961f, 0.01931462f, 0.03513477f, 0.01625224f, 
    -0.04039711f, 0.00709689f, 0.02417437f, -0.02528450f, 0.02398614f, 0.04333017f, 0.05097953f, 0.04248345f, 
    0.01660152f, -0.03505118f, -0.07542617f, -0.05408102f, 0.04221565f, -0.02269833f, -0.06851412f, 0.04563335f, 
    -0.00066952f, 0.02591407f, 0.02037267f, 0.05000942f, -0.01010119f, 0.05882094f, 0.00588154f, 0.01818608f, 
    0.05423450f, 0.01087932f, -0.00997830f, 0.06099962f, 0.02918493f, 0.00569686f, -0.00693770f, 0.03043433f, 
    -0.06540147f, 0.01510126f, 0.04089943f, -0.05968906f, 0.00088512f, -0.07347714f, -0.02908403f, -0.02295747f, 
    -0.06548969f, 0.00538401f, 0.05836973f, 0.00746137f, -0.07092034f, 0.06488098f, 0.02538812f, -0.06852888f, 
    -0.05913591f, -0.08307735f, 0.03220449f, -0.00499940f, -0.02437287f, 0.03990390f, -0.07871489f, -0.06760312f, 
    -0.03170715f, 0.06000765f, -0.03169095f, 0.01771314f, -0.05509900f, 0.00870950f, 0.05167026f, 0.02653511f, 
    -0.00219434f, -0.02004008f, -0.01857316f, 0.00400708f, 0.05480017f, 0.03152430f, 0.06120586f, -0.04153996f, 
    -0.02180094f, -0.04136704f, -0.07407095f, 0.01415479f, -0.03399306f, 0.00174183f, -0.00557593f, -0.05836954f, 
    -0.04768024f, -0.06172382f, -0.00438527f, 0.01604503f, -0.01132630f, 0.04460096f, 0.00668908f, -0.01139834f, 
    -0.00124667f, 0.01127941f, 0.00635671f, -0.04029042f, 0.05796982f, 0.05672904f, 0.02372717f, -0.08054464f, 
    -0.07661846f, -0.04470032f, 0.02753348f, -0.03428166f, -0.06064846f, 0.00467275f, 0.02409967f, -0.06557686f, 
    -0.01833273f, -0.01646450f, -0.06007524f, 0.06197174f, -0.00310739f, 0.02054397f, -0.02999077f, 0.04257964f, 
    -0.04914751f, -0.01625668f, 0.04868883f, -0.04280893f, 0.00992172f, -0.00888756f, -0.05566005f, -0.00364950f, 
    -0.03371732f, -0.02564498f, -0.07322975f, -0.06543738f, 0.00327748f, -0.03072661f, 0.00472028f, 0.02816297f, 
    -0.05574898f, -0.02239214f, -0.05748422f, -0.04778504f, -0.05367165f, -0.01811241f, -0.06727820f, -0.05611129f, 
    -0.05756694f, 0.00371526f, -0.04294102f, -0.03385416f, 0.01949673f, -0.05025013f, -0.03787312f, -0.00841784f, 
    -0.07003587f, -0.00862092f, 0.01633641f, 0.04942445f, 0.03881788f, -0.03459693f, -0.07399185f, -0.01075599f, 
    -0.06265908f, -0.01891178f, -0.01577009f, -0.04715176f, 0.00428720f, -0.02517352f, -0.07508961f, 0.04515863f, 
    0.03438841f, -0.04393023f, -0.02907562f, 0.03591955f, -0.05031915f, 0.05221866f, 0.02430174f, -0.04241020f, 
    -0.03230450f, 0.01154195f, 0.05562375f, -0.04386362f, 0.06578176f, -0.05449416f, 0.05515040f, -0.01736978f, 
    -0.00416281f, 0.02430452f, 0.01835460f, 0.06031483f, 0.00048812f, -0.01703193f, -0.06521066f, -0.01676719f, 
    -0.00080456f, 0.05899175f, -0.06507226f, -0.01410410f, 0.01614060f, -0.02078852f, -0.00418722f, -0.00153916f, 
    0.02279592f, 0.01826790f, -0.00930714f, 0.02752090f, -0.04754984f, -0.00998990f, -0.03500329f, 0.02189595f, 
    -0.06191717f, 0.04067823f, -0.08072831f, 0.05377094f, -0.01669949f, -0.06117234f, -0.02208252f, -0.03366177f, 
    -0.03295367f, -0.00113218f, 0.06057701f, 0.06097202f, -0.05924629f, -0.04805795f, 0.02535989f, -0.02679792f, 
    -0.05180101f, -0.01943940f, -0.05729004f, 0.04549748f, 0.01001432f, -0.05021878f, 0.01196735f, -0.07589159f, 
    -0.04849884f, 0.03024738f, 0.05360739f, 0.02749631f, 0.02199752f, 0.02606470f, 0.01809417f, 0.03926735f, 
    0.01872390f, 0.01132326f, -0.05522627f, 0.04254114f, -0.00939546f, 0.05032852f, 0.04502266f, -0.07777375f, 
    -0.05791446f, -0.01798594f, -0.07526612f, 0.05768173f, -0.00405702f, 0.01795682f, 0.03653410f, -0.08296041f, 
    -0.07579587f, -0.06094264f, -0.02767003f, -0.01384956f, -0.05417430f, -0.06187885f, -0.05926149f, -0.01435542f, 
    0.05084995f, 0.01143237f, 0.01213736f, -0.05696463f, -0.04139689f, -0.06892063f, 0.05588881f, 0.06100941f, 
    -0.02221066f, 0.05048625f, -0.05072979f, -0.04921150f, -0.05517982f, 0.02746009f, 0.03717884f, 0.03036492f, 
    0.06000517f, 0.04991373f, -0.07483427f, 0.05289402f, -0.05667476f, -0.04442887f, 0.01513864f, -0.05085885f, 
    -0.03285740f, 0.04182637f, 0.01595579f, -0.07133477f, -0.07204967f, -0.02217677f, -0.05257163f, 0.03045892f, 
    0.00799027f, -0.03825883f, -0.03795554f, -0.00601468f, 0.02774771f, -0.03371911f, -0.04563713f, 0.02507303f, 
    -0.07950094f, -0.04187750f, 0.06328464f, -0.06134978f, -0.00295190f, 0.01245612f, -0.05025654f, 0.00344819f, 
    0.02284528f, 0.05863912f, 0.05008836f, 0.01022399f, -0.01854317f, -0.01642777f, 0.00365774f, 0.05584538f, 
    -0.03841583f, -0.04844502f, 0.01002221f, -0.04975401f, 0.06181332f, -0.07407765f, 0.01513434f, 0.01249896f, 
    0.00760032f, 0.03009965f, -0.07089029f, -0.01440729f, 0.03928500f, 0.03671709f, -0.04846223f, 0.03190556f, 
    0.02117513f, 0.04957683f, -0.05565472f, -0.03244290f, -0.00371247f, 0.06411479f, -0.04934351f, 0.02063561f, 
    -0.03582939f, 0.03246767f, -0.02415830f, -0.06155898f, 0.04502895f, -0.06056023f, 0.04696923f, -0.05973468f, 
    0.02489883f, 0.01880136f, -0.04452681f, -0.02596134f, -0.02949337f, 0.00538488f, -0.04078056f, -0.02824256f, 
    -0.01025432f, -0.07097010f, 0.03468535f, -0.03802117f, 0.05645677f, 0.04345923f, 0.05328446f, 0.03530283f, 
    -0.04120384f, -0.00406554f, -0.06389628f, 0.04926995f, -0.04260765f, -0.01721632f, 0.04530049f, -0.04516014f, 
    -0.04106969f, -0.04742158f, -0.01656672f, -0.04327748f, 0.03251854f, 0.06434129f, -0.06947567f, 0.02520348f, 
    -0.23427121f, -0.11944238f, -0.00939835f, -0.07977065f, 0.22175857f, -0.11241817f, 0.08756307f, 0.17637457f, 
    -0.19609319f, -0.13805315f, -0.05265225f, -0.08512424f, 0.07148283f, 0.00933921f, 0.19402629f, 0.15174659f, 
    -0.03387298f, 0.01382008f, -0.03748336f, 0.10154088f, 0.13041893f, 0.16925135f, 0.03851363f, 0.24132608f, 
    0.11309864f, 0.28871134f, -0.03392561f, 0.06935475f, 0.06025380f, 0.04431123f, 0.07363220f, -0.03791992f, 
    0.02585218f, 0.04682203f, 0.16143592f, 0.01062135f, -0.30777508f, -0.28344494f, -0.52336574f, 0.26970413f, 
    0.00555939f, 0.16708578f, 0.00439672f, -0.09754980f, -0.20679484f, -0.10289654f, -0.05115845f, 0.01657779f, 
    -0.23855340f, -0.19550553f, -0.07179379f, -0.00833059f, 0.04847312f, -0.09538965f, 0.09860674f, -0.09161403f, 
    -0.12037180f, -0.02312683f, 0.05515797f, 0.22268072f, -0.08822089f, -0.19142611f, -0.22743081f, -0.08913221f, 
    0.00474819f, -0.03713331f, 0.10958236f, -0.05480889f, -0.01491473f, -0.29219395f, -0.24421716f, -0.01464437f, 
    -0.02213839f, -0.42294702f, -0.12490923f, -0.28039032f, 0.06716345f, -0.04843418f, -0.00889719f, -0.21736039f, 
    0.06370322f, 0.04079290f, 0.14777701f, 0.10453287f, 0.26132056f, 0.05367209f, 0.14316496f, 0.11799595f, 
    0.14251676f, 0.19703238f, -0.04145699f, -0.00389863f, 0.00536046f, 0.07850630f, 0.06159560f, 0.30658731f, 
    -0.11831373f, -0.21153626f, 0.08830956f, -0.39329204f, 0.03339486f, 0.13520473f, -0.06536436f, -0.12639911f, 
    -0.18397669f, 0.18313199f, 0.00748162f, -0.20887767f, 0.12093624f, 0.09233265f, 0.33286160f, 0.25029635f, 
    -0.01778172f, 0.13614313f, 0.13543209f, 0.08916410f, 0.14799938f, -0.03275592f, 0.01635446f, -0.10128120f, 
    0.23296991f, 0.40364614f, 0.03649854f, -0.00773214f, 0.05302605f, 0.07827729f, 0.07908184f, 0.04228179f, 
    0.03646882f, -0.01077989f, -0.05858887f, 0.08227073f, -0.18620020f, -0.18807943f, -0.03196158f, -0.03469444f, 
    0.11486182f, 0.00676305f, -0.11776114f, 0.02225699f, 0.12036300f, 0.16904047f, 0.09385386f, 0.13687229f, 
    -0.46978647f, -0.04145233f, 0.03772226f, 0.01780443f, 0.17438205f, 0.17585132f, 0.06118358f, -0.06991746f, 
    -0.09749348f, 0.04638095f, -0.01101872f, 0.00198535f, -0.18653040f, -0.47022480f, 0.08215267f, -0.02270420f, 
    0.13615862f, 0.13337331f, -0.03365142f, -0.18091641f, -0.08856279f, -0.05388084f, 0.09004657f, 0.11364283f, 
    0.33752272f, 0.33482152f, 0.27210173f, 0.26618651f, 0.06781524f, -0.03945452f, 0.15729178f, 0.09152872f, 
    0.06473321f, 0.05086885f, 0.04114316f, 0.10388182f, -0.30990082f, 0.03735227f, 0.05769465f, -0.09026193f, 
    -0.09767807f, 0.03606234f, -0.07606876f, -0.25905401f, -0.05976477f, -0.06867156f, 0.23643170f, 0.19985385f, 
    0.36399984f, -0.17046024f, 0.40372550f, -0.15409480f, 0.06791805f, -0.07933965f, 0.06990942f, -0.04709847f, 
    0.12460025f, 0.15312329f, 0.09858058f, -0.10083909f, -0.23919539f, 0.09457802f, 0.14536390f, 0.25769868f, 
    -0.00041794f, -0.03337092f, 0.14549157f, -0.08997680f, 0.08994937f, -0.10342829f, -0.04992162f, -0.06579899f, 
    -0.05180281f, -0.02524724f, -0.04662795f, 0.15907688f, -0.02102514f, -0.06951877f, -0.00759229f, -0.02863703f, 
    -0.01426720f, 0.04267001f, -0.07939721f, 0.06009328f, 0.27870953f, 0.23623450f, 0.35601461f, -0.06928573f, 
    -0.15909246f, -0.09815262f, -0.02972874f, -0.06160015f, 0.02517974f, -0.03568701f, 0.17468204f, -0.10432141f, 
    0.68148261f, 0.15040909f, 0.05504569f, 0.05201409f, -0.02837157f, -0.12765187f, -0.07787246f, 0.00791520f, 
    -0.17732002f, 0.02796805f, 0.08395781f, -0.07054887f, 0.20829462f, 0.31939089f, 0.25062963f, 0.24608430f, 
    -0.03598278f, -0.04026817f, 0.24325737f, -0.08282627f, 0.01756370f, 0.13237303f, 0.18302985f, 0.01985195f, 
    0.16748124f, 0.17560586f, 0.17435510f, -0.04858179f, -0.00994695f, 0.11848405f, -0.14174181f, -0.08862723f, 
    0.07527721f, 0.24715942f, -0.00064333f, 0.09229278f, -0.05445308f, 0.04968315f, 0.24425018f, 0.22891225f, 
    0.02102727f, 0.06819940f, 0.10897686f, -0.10164250f, 0.05300266f, -0.03572378f, 0.02877956f, -0.11507829f, 
    0.16606449f, 0.15958923f, -0.04653805f, -0.06308635f, -0.09812408f, -0.08831126f, 0.00095904f, -0.02072437f, 
    0.12404579f, 0.26072723f, -0.01093366f, 0.15047143f, -0.29912975f, -0.08328857f, -0.12708305f, 0.03790046f, 
    -0.13800326f, -0.05081924f, 0.10994144f, 0.13857472f, -0.01967270f, -0.01714260f, -0.04996610f, 0.02779997f, 
    0.09738197f, -0.06808767f, 0.38181949f, 0.01274452f, 0.02499583f, 0.03680300f, 0.05050183f, 0.01432520f, 
    0.04296593f, 0.01071074f, 0.04479247f, -0.01319555f, 0.30095965f, 0.06409079f, 0.25255305f, 0.00414389f, 
    -0.16841817f, 0.01374245f, -0.07912248f, -0.15364504f, 0.02150433f, -0.09696724f, 0.02001931f, -0.17561041f, 
    -0.25084078f, -0.02490939f, -0.09831286f, -0.18776023f, -0.11420154f, -0.16635828f, -0.07028647f, -0.14070727f, 
    0.03202797f, -0.03841460f, -0.09984458f, 0.10125554f, 0.14684445f, 0.09844616f, -0.08348793f, -0.04873733f, 
    0.01377275f, -0.07593988f, -0.00456737f, 0.15096083f, 0.00647125f, 0.01241359f, 0.00054324f, 0.11148009f, 
    -0.34411407f, -0.45600554f, 0.01279837f, 0.32038683f, -0.22403915f, -0.07986552f, -0.03942920f, 0.09228241f, 
    -0.12482495f, 0.03517596f, 0.10207932f, -0.04331210f, -0.13106202f, 0.29286459f, -0.13864987f, 0.02445791f, 
    0.02908820f, 0.06866446f, -0.03589177f, 0.04415823f, -0.02523127f, -0.06435021f, 0.07943292f, 0.02764653f, 
    0.09163626f, -0.15616241f, 0.17439437f, -0.10866554f, -0.02165170f, -0.22665240f, 0.08904009f, 0.15551612f, 
    0.04032450f, 0.25137678f, 0.04603265f, 0.08910850f, -0.17797296f, -0.01908226f, 0.00885777f, 0.16014475f, 
    0.08407898f, 0.10848132f, 0.23648165f, -0.00471504f, 0.04914739f, -0.15898176f, -0.04549248f, -0.06187154f, 
    -0.05860249f, -0.07444531f, -0.19623177f, 0.03011368f, 0.00282484f, 0.03433134f, 0.03419439f, -0.09819818f, 
    -0.09758646f, -0.12946396f, -0.04436149f, 0.24618290f, 0.56146252f, 0.05843110f, 0.37929979f, -0.06199194f, 
    -0.11807966f, -0.05346693f, -0.03115969f, -0.03063073f, -0.00350694f, 0.05986454f, 0.15583315f, 0.09752075f, 
    0.33044484f, -0.11148017f, 0.02134712f, 0.10636674f, -0.00981935f, -0.06557016f, -0.21033926f, 0.06799100f, 
    -0.23576979f, 0.08563817f, 0.05706789f, -0.13115375f, 0.12200367f, 0.29060772f, 0.18696815f, 0.11257803f, 
    0.01007702f, -0.02886646f, 0.25958583f, -0.06315712f, 0.06940995f, 0.19637328f, 0.30123001f, 0.21787204f, 
    0.13768584f, 0.10463284f, 0.05946799f, 0.11735649f, -0.07733702f, -0.03434588f, -0.13370533f, 0.04757382f, 
    0.05510484f, 0.16195211f, -0.05751453f, -0.13248983f, 0.02450177f, 0.00593546f, 0.06946243f, -0.00373392f, 
    0.14045662f, 0.06415169f, 0.06552625f, -0.15020703f, 0.03476004f, -0.14112000f, -0.05696139f, -0.25631782f, 
    -0.01662466f, 0.29103300f, -0.05648965f, 0.01257248f, -0.08171965f, -0.02159831f, 0.05066635f, -0.04148887f, 
    0.21651220f, 0.19167198f, 0.09220820f, 0.26739588f, -0.09930372f, -0.01589701f, -0.18428083f, -0.02870238f, 
    0.01915306f, 0.07217046f, 0.26244828f, 0.07910355f, -0.01941777f, 0.02825097f, -0.01044974f, 0.05008604f, 
    -0.14844601f, -0.07396519f, 0.04349351f, -0.26226324f, -0.00695251f, 0.11136326f, 0.11312753f, 0.11715297f, 
    -0.00214777f, 0.14470705f, 0.11014964f, -0.06496343f, 0.20505960f, 0.02174087f, 0.00281951f, 0.11271229f, 
    -0.23378243f, -0.12933108f, 0.04461809f, -0.06736941f, -0.04953627f, -0.14390281f, -0.00763165f, -0.11881022f, 
    -0.18784378f, -0.09637031f, -0.02977292f, -0.26311338f, -0.08886926f, -0.28785267f, 0.02367811f, -0.21150593f, 
    -0.06009713f, -0.05787250f, 0.08601262f, 0.22477651f, -0.14534417f, 0.07088447f, 0.02557179f, -0.16390330f, 
    -0.22671233f, -0.09856340f, -0.08627246f, 0.21741271f, -0.03937232f, 0.20263843f, 0.12556604f, 0.06577509f, 
    -0.27057073f, -0.33557826f, -0.12988842f, 0.08454225f, -0.18706155f, 0.12035847f, -0.00930386f, 0.11142182f, 
    -0.08888265f, 0.13756517f, 0.10965920f, 0.17890970f, -0.38295397f, 0.20779890f, 0.04574066f, -0.21184099f, 
    0.13664627f, 0.12133092f, -0.05024427f, 0.24062420f, 0.03443889f, -0.03916148f, 0.08636775f, -0.29194650f, 
    0.00510088f, -0.04798353f, -0.00592725f, -0.05730697f, 0.05337046f, 0.00093829f, -0.07973503f, 0.03175393f, 
    0.05734734f, -0.05768605f, 0.05286194f, -0.04075934f, 0.00377991f, 0.05809550f, -0.01616897f, -0.07525481f, 
    -0.05900633f, -0.03122198f, -0.04898442f, -0.00545130f, 0.01901232f, 0.01341147f, -0.04518622f, 0.06278448f, 
    -0.00042472f, -0.06669167f, -0.06826049f, -0.02336464f, -0.00179414f, -0.02490017f, 0.03958029f, -0.07835845f, 
    0.00552243f, -0.07912358f, 0.05518992f, 0.02578304f, 0.01429347f, -0.06382436f, -0.04291026f, 0.03938944f, 
    0.04010409f, -0.03648562f, -0.02733115f, -0.06843637f, -0.05070223f, -0.03078261f, 0.02994005f, -0.01390703f, 
    -0.01764041f, 0.04399013f, 0.03237253f, -0.04062314f, 0.02341647f, 0.03524472f, -0.04383017f, 0.04674006f, 
    -0.03867117f, 0.01842144f, 0.05232822f, -0.06848824f, -0.01954115f, -0.04244008f, -0.01551663f, -0.02927295f, 
    -0.06841764f, -0.02771310f, 0.06070290f, -0.06837270f, 0.00436415f, 0.04044611f, -0.04068464f, -0.02515305f, 
    -0.00349764f, -0.07012510f, -0.05212114f, -0.06750429f, -0.07854356f, 0.00715957f, 0.01215173f, 0.05843496f, 
    -0.00508508f, -0.02412021f, 0.06029806f, 0.04846858f, -0.01770621f, -0.00580092f, 0.05971783f, -0.03454159f, 
    -0.00071968f, 0.00677362f, -0.06177285f, -0.04317788f, 0.00385078f, -0.02032741f, -0.04444168f, -0.02380688f, 
    0.05604618f, 0.00490306f, -0.04470652f, -0.04677661f, -0.05309668f, -0.05291938f, -0.05911714f, -0.06474540f, 
    0.00917438f, 0.04003560f, 0.05698604f, 0.00783515f, -0.00864018f, -0.04330293f, 0.04006236f, -0.07309046f, 
    -0.06549290f, -0.01143843f, 0.06308040f, -0.03822393f, -0.02985461f, 0.05001624f, -0.01187783f, 0.03589761f, 
    -0.01151961f, -0.03346372f, 0.05617466f, -0.06917043f, -0.07258444f, 0.00005735f, -0.01212233f, 0.02082201f, 
    0.03288215f, -0.06183344f, -0.01850411f, -0.07216761f, -0.04802572f, -0.04211690f, -0.04223765f, -0.07282802f, 
    -0.08053150f, -0.07078665f, -0.01233464f, -0.06732033f, -0.01766854f, -0.04857488f, -0.04707640f, -0.01192612f, 
    0.04776634f, -0.00611691f, -0.01666005f, 0.03395095f, 0.03324715f, 0.01058878f, -0.06914104f, -0.06666975f, 
    0.00592821f, 0.04330076f, -0.00867009f, -0.03564852f, -0.04635622f, -0.02127085f, 0.03946207f, 0.04894453f, 
    -0.06231751f, -0.04986753f, -0.00069521f, -0.01122519f, -0.01517197f, 0.05397890f, -0.06333800f, 0.00261409f, 
    0.00669439f, -0.00753885f, -0.00842396f, 0.00631874f, -0.01944861f, -0.02384192f, -0.04392442f, 0.02585524f, 
    -0.05358147f, 0.00462180f, -0.06280681f, 0.00656063f, 0.03106190f, 0.05292794f, 0.05169423f, 0.03172214f, 
    0.05002950f, -0.02171073f, -0.04619190f, -0.00620965f, 0.03399424f, -0.02442716f, -0.04226755f, 0.02996952f, 
    -0.00235639f, -0.02444048f, 0.04349823f, 0.05543162f, -0.05162812f, 0.02936185f, -0.02760257f, 0.06596714f, 
    -0.01650842f, 0.00648526f, -0.06607609f, -0.03972969f, 0.00157084f, 0.00253724f, -0.01454341f, -0.00372649f, 
    0.05704537f, 0.05768253f, -0.04717593f, 0.00963411f, 0.04257623f, -0.03336867f, 0.01330924f, 0.05443036f, 
    -0.00261522f, -0.02483423f, 0.04738631f, 0.06309303f, -0.01952062f, -0.03611191f, 0.02018615f, -0.06941088f, 
    -0.01010436f, -0.06688242f, 0.06392459f, 0.03142524f, -0.02605430f, -0.06021402f, -0.04519831f, 0.01216270f, 
    -0.04751986f, -0.02392212f, -0.02676298f, -0.01541675f, 0.05412834f, -0.01729820f, 0.02051716f, -0.01261093f, 
    -0.05561114f, -0.05534124f, -0.06366738f, 0.03440857f, 0.05135475f, -0.05559887f, -0.04756125f, -0.00928055f, 
    0.01345387f, 0.03713553f, -0.04413524f, 0.00434623f, 0.01117376f, 0.01170214f, 0.00204762f, 0.06004233f, 
    -0.02483243f, 0.00056545f, 0.05017444f, 0.05393906f, 0.04146807f, -0.06009552f, -0.01097157f, -0.02545135f, 
    0.01943965f, 0.00585052f, -0.04653290f, -0.02470795f, -0.02133296f, -0.04638684f, 0.02636319f, -0.04800547f, 
    -0.05655954f, -0.07298071f, -0.03251432f, -0.03914454f, -0.01369436f, 0.05914452f, 0.04149041f, 0.05722087f, 
    -0.06637979f, 0.01590823f, -0.05608791f, 0.03424800f, -0.03205379f, 0.02727577f, -0.03189346f, 0.04270300f, 
    -0.04368261f, -0.06466587f, 0.05451328f, -0.05209974f, 0.04090751f, -0.04814485f, -0.06922111f, -0.01289512f, 
    -0.05484473f, -0.04637486f, 0.06711389f, -0.02486274f, -0.01174431f, -0.02261426f, 0.04012541f, 0.03330624f, 
    0.04147479f, -0.05246488f, -0.03072932f, -0.05365415f, -0.05694148f, 0.03356266f, -0.02400100f, -0.00398030f, 
    -0.02222274f, -0.05701296f, -0.01255816f, -0.02013033f, -0.06053381f, -0.00208498f, 0.05387570f, -0.04338326f, 
    0.02565720f, -0.07430959f, -0.00388012f, -0.05094133f, 0.05695035f, -0.04144707f, 0.00119433f, -0.05590200f, 
    -0.02039895f, 0.02429112f, 0.03122927f, -0.03023915f, -0.01711394f, -0.03047111f, -0.06634603f, -0.03618879f, 
    -0.01833245f, 0.05463025f, -0.05390158f, 0.05070658f, 0.02989051f, 0.04226884f, -0.02534475f, -0.06494804f, 
    -0.02299668f, -0.05344882f, -0.00968041f, -0.01977788f, -0.05613549f, -0.02903315f, 0.01516175f, 0.03954982f, 
    0.00401095f, -0.05798078f, -0.05067989f, -0.02191418f, -0.01877367f, 0.02482303f, 0.03530040f, 0.01132883f, 
    -0.04386965f, 0.01105587f, -0.01221946f, 0.01973020f, 0.02916323f, 0.01564150f, 0.05784282f, 0.03807023f, 
    -0.03338877f, 0.01844181f, -0.06948802f, -0.07658223f, 0.02720897f, -0.06165545f, 0.00187935f, -0.04442932f, 
    0.04665716f, -0.01226621f, -0.03713752f, -0.06859035f, -0.01615591f, -0.01940771f, -0.00118012f, 0.00554080f, 
    -0.06548947f, 0.04888078f, -0.03323371f, 0.02100591f, 0.03193067f, -0.07162994f, 0.04317294f, 0.06234788f, 
    0.02622657f, -0.07313224f, 0.04870214f, -0.05203910f, -0.02335800f, 0.04033626f, -0.03307793f, -0.07700124f, 
    -0.01094139f, -0.02621302f, 0.03314403f, -0.01219690f, -0.02979106f, 0.01935958f, 0.05626763f, -0.01118672f, 
    -0.07784746f, -0.00404845f, -0.05012548f, -0.00903665f, -0.02124712f, 0.02570425f, 0.04985587f, 0.01906165f, 
    0.05643253f, 0.04749661f, -0.07002878f, 0.02598439f, -0.06925745f, -0.03261062f, -0.04064208f, -0.03024965f, 
    -0.01590752f, 0.01830019f, -0.05824176f, -0.01778366f, 0.01802355f, 0.06079490f, -0.00445536f, -0.01234115f, 
    -0.07489745f, 0.01815180f, -0.00258706f, 0.01886807f, 0.01853092f, 0.01117407f, -0.04020712f, -0.03631032f, 
    -0.04186594f, -0.00955181f, -0.03644986f, 0.01561230f, -0.03866121f, 0.03872633f, -0.00566910f, 0.02164550f, 
    0.05491185f, -0.06963554f, 0.03425848f, 0.07306942f, 0.03663703f, -0.04077918f, -0.05680839f, -0.06053792f, 
    0.01782314f, 0.04133625f, 0.03307955f, -0.05933543f, -0.02236515f, -0.03950706f, -0.05928658f, -0.02662189f, 
    -0.05473613f, 0.03406855f, 0.01954570f, -0.05661774f, -0.04893557f, 0.03491648f, -0.00993607f, -0.07488053f, 
    -0.04527822f, 0.02235644f, 0.00242386f, 0.01103317f, -0.04231418f, 0.01565536f, -0.01147421f, 0.05978592f, 
    0.00384277f, -0.05876663f, -0.08053240f, -0.04577890f, -0.06248739f, 0.00067610f, 0.06117577f, -0.02130204f, 
    0.06209632f, -0.00366898f, -0.02832375f, -0.00194649f, 0.04455797f, -0.06520235f, 0.00037986f, -0.04246931f, 
    -0.02758429f, -0.03297617f, -0.06837107f, -0.00824318f, -0.01191965f, 0.05708857f, 0.03189429f, -0.00970003f, 
    0.06414647f, 0.03799478f, -0.07074190f, -0.05781956f, 0.01210844f, -0.05173135f, -0.01786132f, 0.05997599f, 
    0.02328680f, -0.07344133f, 0.05358930f, 0.01994313f, -0.04435058f, 0.06755932f, -0.02283018f, -0.02592004f, 
    0.02211702f, -0.02338352f, -0.00718457f, -0.02403059f, 0.06987916f, 0.03267980f, 0.03560964f, -0.07803322f, 
    -0.07258558f, -0.06661528f, -0.00723631f, 0.02022455f, -0.05928665f, -0.04243941f, -0.07251588f, -0.03962067f, 
    -0.02058556f, -0.04793115f, -0.01898032f, -0.01744536f, 0.00944044f, 0.02518249f, -0.06373875f, -0.05515616f, 
    -0.03288724f, -0.05418056f, 0.02897689f, 0.03215869f, -0.01686076f, 0.00216276f, 0.05826576f, 0.02395290f, 
    0.00101730f, -0.06761139f, -0.03898968f, 0.01126419f, 0.02296263f, -0.07927646f, 0.06199431f, 0.02895235f, 
    0.02044972f, -0.01818128f, -0.07834619f, -0.06943039f, -0.03443307f, -0.06815441f, -0.02901532f, -0.01293853f, 
    0.00191709f, 0.01221535f, 0.05564444f, -0.00732983f, 0.02806348f, -0.05908975f, -0.03547711f, 0.06303935f, 
    -0.08132182f, -0.01224712f, 0.26818368f, 0.06313305f, 0.24307916f, -0.00612396f, 0.08164037f, -0.01796863f, 
    0.13266134f, -0.10471401f, -0.05585709f, 0.04738471f, 0.21403916f, 0.13075450f, -0.04224693f, -0.33748320f, 
    0.06906968f, 0.24345584f, -0.03971718f, -0.05882009f, -0.16668880f, 0.07896338f, -0.04290956f, 0.05985020f, 
    -0.30271474f, 0.06172818f, -0.36876324f, -0.18675005f, 0.20700243f, 0.04018072f, 0.23642269f, 0.05871546f, 
    0.02136748f, 0.11239722f, 0.11675828f, 0.04253615f, -0.03510121f, -0.14883880f, -0.62634546f, 0.13273373f, 
    -0.03579983f, 0.09067827f, -0.02175933f, 0.04005107f, 0.01711734f, -0.05246868f, -0.07382635f, 0.12259579f, 
    -0.45594451f, 0.15141100f, 0.03200081f, 0.19157027f, -0.02196414f, -0.00461067f, -0.01231564f, -0.00034822f, 
    0.10914651f, 0.06446010f, -0.00485406f, 0.10365517f, 0.01512244f, 0.02255950f, -0.09425430f, 0.01055057f, 
    0.19704455f, 0.04478521f, -0.02132416f, -0.05786200f, 0.19762750f, 0.08079544f, -0.26300564f, -0.10553528f, 
    0.27559069f, 0.04298640f, 0.01501607f, -0.21418650f, 0.03023946f, 0.02561751f, 0.08587409f, -0.01475872f, 
    -0.17051911f, 0.04122745f, 0.00853585f, -0.11996235f, 0.18578085f, 0.07804035f, 0.13527590f, -0.28450087f, 
    0.09870029f, 0.10118574f, -0.06511816f, 0.19005571f, -0.08485378f, 0.10074799f, 0.05081122f, -0.19802262f, 
    0.03186170f, -0.23259211f, 0.04049901f, -0.03614536f, 0.02103371f, 0.19035344f, -0.07731710f, -0.00560534f, 
    -0.07232608f, -0.07963480f, -0.03019316f, -0.03949983f, 0.33879450f, 0.03996731f, 0.06092121f, -0.16543745f, 
    0.09538753f, -0.03904042f, -0.03100546f, -0.02666200f, 0.03661035f, 0.03047619f, 0.09559715f, 0.05152607f, 
    0.35876724f, 0.14493538f, 0.35004568f, -0.04978870f, 0.08390450f, 0.00221447f, -0.01029848f, 0.01318837f, 
    0.06688327f, -0.00689712f, 0.06238348f, 0.28472218f, 0.14751203f, -0.18923850f, 0.37048519f, 0.26243836f, 
    0.14020507f, 0.06145553f, -0.08924503f, 0.06779900f, 0.16397066f, 0.01190912f, -0.21551880f, 0.00409085f, 
    -0.07545208f, -0.04034499f, -0.09094094f, -0.10103149f, 0.02703846f, 0.37596449f, 0.16346171f, 0.08424653f, 
    0.14575735f, 0.07508045f, -0.09105127f, -0.00721002f, 0.07690755f, -0.25114378f, -0.01275016f, 0.22664946f, 
    0.10453574f, 0.12011962f, 0.07513759f, 0.11318621f, 0.10832872f, -0.09627812f, -0.13295092f, -0.16593723f, 
    0.15358125f, 0.28254470f, -0.03878574f, -0.27205405f, 0.08898535f, 0.05643302f, -0.08821473f, -0.17958067f, 
    -0.00585738f, -0.15882833f, -0.13410135f, -0.11775351f, -0.21685764f, 0.19576730f, -0.06877826f, -0.01774949f, 
    -0.25518158f, -0.15733753f, -0.09794677f, -0.07442223f, -0.05169208f, -0.11217783f, -0.07742799f, 0.11871780f, 
    -0.00713206f, -0.17830141f, -0.35076702f, 0.22651733f, 0.02819439f, 0.08554143f, 0.04468827f, 0.25236371f, 
    -0.08124327f, 0.32278451f, -0.02812851f, 0.13531800f, 0.02840926f, 0.10263559f, -0.09071435f, 0.12075882f, 
    0.14198774f, 0.01996003f, -0.01849834f, -0.08477745f, 0.23954628f, -0.09422808f, 0.09358513f, -0.02199946f, 
    0.35919437f, 0.17471096f, -0.04528995f, -0.21979555f, -0.04776357f, -0.04533092f, -0.08148395f, -0.14796306f, 
    -0.21142273f, 0.00709167f, -0.07950296f, 0.10017925f, 0.47524047f, 0.04522311f, 0.46117139f, 0.04425437f, 
    -0.11496402f, 0.03472244f, 0.19540718f, 0.06567416f, -0.03566733f, -0.03782348f, 0.15812227f, 0.01872556f, 
    -0.08790676f, -0.22931397f, 0.02044402f, -0.07105937f, -0.06309460f, -0.13623057f, -0.05561142f, -0.09558919f, 
    0.00824029f, -0.04405271f, 0.08451714f, -0.11892160f, -0.03353149f, 0.16084296f, 0.11451680f, -0.01229358f, 
    -0.24462225f, 0.11130190f, -0.10817871f, 0.13134989f, 0.04044013f, -0.05153045f, 0.20337868f, 0.14565583f, 
    0.13413897f, -0.02066350f, 0.05151886f, 0.18206944f, -0.06185760f, -0.00375556f, -0.07917277f, -0.01662890f, 
    0.02335165f, 0.03113519f, 0.03760909f, 0.07128397f, -0.07528680f, 0.33699903f, 0.14084272f, 0.17262648f, 
    0.01527494f, 0.03401547f, 0.11276552f, -0.12476828f, -0.01718833f, 0.06052732f, 0.09120129f, -0.13918343f, 
    -0.00032522f, 0.22563724f, -0.20500687f, 0.35472250f, 0.08681531f, -0.10978901f, 0.05989219f, 0.07635441f, 
    0.20483464f, 0.09160306f, 0.02821720f, 0.29400328f, 0.28665182f, 0.04687183f, 0.09777758f, 0.17223617f, 
    -0.03447447f, 0.13672513f, 0.40756395f, -0.15231659f, -0.15110967f, -0.04962337f, -0.15147494f, -0.10397029f, 
    -0.55356485f, 0.16682781f, -0.12050384f, -0.01481623f, 0.03794958f, -0.01391396f, 0.13576022f, 0.13474523f, 
    -0.04092724f, 0.09119286f, -0.15492706f, -0.06702618f, -0.04452866f, -0.05217016f, -0.06381057f, 0.27022883f, 
    -0.01060729f, 0.02479177f, 0.01235741f, -0.12395560f, -0.26834545f, -0.10879461f, 0.05060451f, 0.04381031f, 
    -0.02028752f, -0.12069608f, 0.02933597f, -0.12718101f, 0.05476418f, -0.25211141f, 0.16064084f, -0.02805414f, 
    0.05274623f, 0.09878123f, 0.10981714f, 0.23495565f, -0.12744823f, 0.41650608f, 0.03721464f, 0.15053737f, 
    0.10050455f, -0.19336359f, 0.01281701f, 0.16658765f, -0.20207544f, -0.06135921f, 0.06023016f, 0.06584860f, 
    -0.38183153f, -0.25769371f, -0.16646999f, -0.15202606f, 0.01404882f, -0.04922913f, -0.00484412f, -0.06355840f, 
    -0.08845718f, 0.03338013f, 0.07932151f, 0.10568718f, -0.35407937f, 0.37057647f, 0.01695415f, 0.01258978f, 
    0.21999221f, -0.12629069f, 0.05498821f, 0.05668402f, 0.09051199f, -0.13316901f, 0.08161544f, -0.25496778f, 
    -0.09822642f, -0.02749350f, -0.06848093f, 0.03623683f, 0.04073250f, 0.11806096f, 0.12501520f, 0.04275779f, 
    -0.02344337f, 0.04595787f, 0.02190010f, 0.12695749f, -0.17125487f, -0.06018559f, 0.03511120f, 0.21389833f, 
    -0.02582153f, -0.02769281f, -0.04153089f, -0.01405309f, -0.01684350f, -0.04678757f, 0.03862813f, -0.10103050f, 
    0.03003452f, 0.00787301f, 0.59150690f, 0.37527829f, -0.01701915f, 0.29987514f, -0.14061658f, 0.01086233f, 
    -0.01144856f, 0.04617897f, 0.00897556f, -0.00621809f, -0.20655705f, 0.19702555f, 0.45942757f, -0.07480902f, 
    -0.05227924f, -0.08647519f, -0.18417057f, -0.02860842f, -0.01614892f, 0.08767579f, 0.19387367f, -0.20207016f, 
    0.71138936f, -0.00818397f, 0.13710126f, 0.04672756f, 0.09348485f, -0.15176566f, -0.07603098f, -0.02209935f, 
    0.09295779f, 0.15637867f, -0.00124950f, 0.04563161f, 0.07778466f, -0.07139465f, 0.13523069f, 0.14533287f, 
    -0.00184448f, 0.04028730f, -0.12650660f, 0.19823448f, 0.05630906f, -0.07770084f, 0.25392470f, 0.12113441f, 
    -0.50963920f, 0.13460343f, -0.09431171f, 0.16624229f, 0.02640583f, -0.06925077f, -0.23305799f, -0.04937910f, 
    -0.03514525f, -0.05663392f, -0.01723654f, 0.23377143f, -0.32160050f, 0.01365578f, 0.13813448f, 0.38402757f, 
    -0.00441574f, -0.02818778f, 0.23222817f, -0.09458406f, -0.12613262f, 0.04018309f, -0.02828089f, 0.09830828f, 
    -0.25601438f, 0.12495223f, -0.18759860f, -0.05136267f, 0.00460467f, -0.34136054f, 0.03835071f, 0.04777135f, 
    -0.10826560f, 0.10527110f, -0.09412038f, -0.05208617f, -0.21069458f, -0.08940699f, -0.16086191f, 0.20343532f, 
    -0.09168999f, 0.00735265f, 0.05556982f, -0.06494989f, -0.04553380f, -0.00347479f, -0.09854725f, -0.05201359f, 
    -0.05534297f, 0.05523208f, 0.31438458f, 0.38145909f, 0.12828961f, -0.00900554f, 0.09569934f, -0.08821721f, 
    -0.00719000f, 0.09416749f, 0.12614974f, -0.12489046f, -0.32660654f, 0.14505988f, -0.30309099f, -0.21060768f, 
    0.07528524f, -0.11194838f, 0.09164201f, -0.02202774f, -0.10322213f, 0.04117455f, 0.07859671f, 0.09797818f, 
    -0.16216756f, -0.11489694f, 0.17144099f, 0.15886763f, 0.00455926f, -0.04724585f, -0.00887346f, 0.00399942f, 
    0.07756068f, -0.03100416f, -0.01455553f, 0.08558755f, 0.07856090f, 0.27834317f, -0.17750065f, -0.18490063f, 
    0.02291178f, -0.25272271f, -0.02904719f, 0.01296506f, -0.15252469f, 0.00170703f, 0.00476885f, 0.17382111f, 
    0.02997220f, -0.25819254f, -0.17410173f, 0.06739937f, 0.16991962f, -0.06645523f, 0.00962310f, -0.02723617f, 
    -0.10524413f, 0.07868529f, -0.03853453f, 0.05680826f, 0.30275777f, 0.09858350f, -0.07187710f, -0.07005609f, 
    0.06088237f, 0.12692566f, 0.00340856f, 0.14822896f, 0.02594477f, 0.17391901f, 0.01820765f, -0.05473762f, 
    -0.11262638f, 0.29844621f, 0.26327047f, -0.21009439f, -0.16336060f, 0.16279398f, -0.03166533f, 0.02912097f, 
    0.10161595f, -0.07312534f, 0.00027031f, 0.05131120f, 0.07827765f, 0.13021944f, 0.07355069f, -0.25873819f, 
    -0.07863121f, 0.07325323f, 0.13090608f, -0.00324393f, -0.21139170f, -0.24081130f, -0.05542682f, -0.04549660f, 
    0.11849929f, 0.25494942f, 0.08976513f, 0.02413825f, 0.25683814f, 0.23350435f, -0.02498102f, 0.11595503f, 
    0.04759677f, -0.04401475f, 0.08477585f, -0.00337464f, -0.31486458f, 0.19659528f, -0.22858390f, 0.48496038f, 
    0.18513818f, -0.01129944f, -0.05563603f, 0.00853155f, 0.03950628f, 0.06489893f, -0.08870082f, 0.20899005f, 
    -0.53548425f, 0.30582502f, -0.22267333f, -0.05140589f, -0.02731868f, 0.11881463f, 0.01644357f, 0.11621819f, 
    -0.04180102f, 0.08006692f, -0.08945455f, -0.18199269f, 0.07277148f, -0.03958263f, 0.11036127f, 0.14987102f, 
    -0.01394421f, 0.06863993f, -0.03396705f, -0.10462124f, -0.03922855f, -0.14287643f, 0.08435944f, 0.32155988f, 
    -0.15428884f, -0.08432379f, 0.11571945f, -0.04120982f, 0.12698953f, 0.02666243f, -0.09190678f, 0.01327222f, 
    0.13584334f, -0.13425376f, -0.01116006f, -0.15256891f, -0.05470898f, -0.17863820f, -0.02801943f, -0.20242092f, 
    0.07132506f, 0.09311271f, 0.10184945f, 0.00864402f, 0.09869761f, -0.27283233f, -0.11989313f, -0.00015258f, 
    0.21955159f, -0.09469444f, 0.19209597f, 0.01959418f, 0.07467122f, -0.05588973f, -0.04949728f, -0.02190237f, 
    0.23299785f, -0.20347512f, 0.07053366f, 0.23293930f, -0.21032856f, 0.05799809f, 0.01575807f, 0.05056003f, 
    0.14939360f, 0.23312907f, 0.16965824f, 0.03078332f, 0.07841807f, -0.00389162f, -0.03605972f, 0.01843604f, 
    -0.35490915f, -0.20037079f, -0.45648339f, -0.25683579f, -0.08314908f, 0.09823152f, 0.17869814f, 0.03153216f, 
    0.12999836f, 0.03647115f, 0.04472627f, 0.01003381f, 0.03677648f, 0.20130606f, -0.00537158f, -0.14978673f, 
    -0.04184840f, -0.13354456f, -0.04762434f, -0.04107008f, 0.05624220f, -0.02369115f, -0.31683081f, -0.02367619f, 
    -0.11193381f, 0.04592443f, 0.07238424f, -0.07095269f, 0.22083031f, 0.01824454f, -0.34265307f, -0.02191959f, 
    0.06314365f, -0.13911815f, 0.15429904f, -0.01235555f, 0.13630906f, -0.01534842f, 0.11537256f, 0.09456841f, 
    0.02989283f, -0.16784689f, -0.06482289f, -0.07255588f, -0.01307302f, 0.15127440f, 0.09389769f, -0.05826369f, 
    0.01344281f, 0.18853065f, 0.28699231f, -0.04526716f, 0.01335921f, 0.10559004f, 0.13974208f, 0.21629992f, 
    0.17834324f, 0.04486922f, 0.20707405f, 0.00861118f, 0.37549129f, -0.59517318f, 0.30565825f, 0.17362961f, 
    0.08983863f, -0.14136989f, -0.10455481f, 0.13671769f, 0.01147696f, 0.24152349f, 0.02237452f, -0.05484210f, 
    0.07475957f, -0.06259989f, -0.24427927f, -0.04489939f, 0.08811488f, 0.07320795f, -0.14271475f, 0.16885167f, 
    0.01914413f, 0.11044773f, -0.12510878f, -0.07619972f, -0.01654604f, -0.10190910f, 0.07420045f, -0.03621611f, 
    -0.11613256f, -0.11760768f, 0.10007318f, 0.14631023f, 0.00691349f, 0.09682100f, 0.17117016f, -0.14254846f, 
    0.47667274f, -0.07377652f, 0.33083445f, -0.03918061f, 0.09620409f, 0.16364710f, -0.00459647f, 0.05964264f, 
    0.03964267f, -0.03288277f, 0.01713070f, -0.02272487f, -0.02403328f, 0.14394702f, 0.00048720f, -0.26287520f, 
    0.15610699f, 0.00060704f, 0.00218427f, -0.00921660f, -0.03053234f, 0.09973875f, 0.00973701f, 0.06195852f, 
    -0.32280552f, 0.09631763f, 0.08166510f, -0.06631153f, -0.00461514f, 0.08733164f, 0.13350412f, 0.02468101f, 
    0.05525948f, 0.13236929f, 0.21777573f, 0.01414901f, -0.07192624f, -0.16904144f, 0.00650840f, -0.13462876f, 
    0.11602943f, -0.10694133f, -0.14556974f, 0.07063463f, -0.09716861f, 0.13526079f, 0.17612670f, -0.06542315f, 
    0.00512463f, -0.03751353f, -0.06960927f, -0.01509099f, -0.09612881f, -0.13111995f, 0.06368337f, -0.00968449f, 
    0.12886615f, -0.16854161f, 0.14779902f, 0.06888053f, -0.10688819f, -0.13240135f, -0.14567946f, -0.08122817f, 
    -0.05511969f, -0.13090698f, 0.19992192f, 0.15619154f, 0.11470792f, -0.05377816f, 0.14076485f, 0.15499519f, 
    0.06067554f, 0.01702566f, 0.04195875f, 0.15353134f, 0.06479468f, -0.15315562f, 0.07493064f, 0.05561326f, 
    -0.01283802f, -0.12416723f, -0.17200370f, -0.01534384f, -0.08439739f, -0.18161915f, 0.04565463f, -0.06717173f, 
    0.17026892f, -0.05085300f, -0.15846324f, -0.11129124f, 0.03702610f, 0.11720416f, -0.05229874f, -0.09967890f, 
    -0.79289317f, -0.05160954f, -0.20057659f, 0.13580751f, -0.12705405f, 0.01246494f, 0.03505791f, -0.08364844f, 
    0.05898699f, 0.08331390f, 0.09902114f, 0.12825826f, -0.12564047f, 0.19303980f, -0.14407139f, -0.31475025f, 
    -0.00338792f, -0.08764928f, 0.07713065f, -0.01759967f, -0.15324415f, 0.12596977f, 0.09990984f, -0.05285799f, 
    0.45805064f, -0.00767085f, -0.03199501f, -0.18011910f, 0.18730441f, -0.02661695f, 0.00158294f, 0.25546977f, 
    0.11818295f, 0.05561990f, -0.00248320f, -0.10378237f, -0.04538258f, 0.27817851f, 0.05235416f, 0.16571485f, 
    0.14258230f, -0.01879168f, -0.06394082f, -0.12274174f, -0.04394268f, 0.08778620f, -0.03152816f, -0.01311272f, 
    -0.03650606f, 0.02810992f, 0.00207748f, -0.04974819f, -0.06348234f, -0.14533985f, -0.11348822f, -0.08590693f, 
    0.11539591f, 0.13952370f, 0.00833839f, -0.00986139f, 0.68364179f, -0.40502685f, 0.07433528f, 0.40075344f, 
    0.11964340f, -0.02418088f, 0.10551453f, 0.32747746f, 0.19947411f, 0.23945144f, 0.16447972f, -0.01712681f, 
    0.05711832f, 0.04921933f, 0.00456482f, -0.01525156f, 0.05098095f, 0.00648271f, -0.04249012f, -0.07060470f, 
    -0.02416457f, -0.01693863f, -0.06348284f, 0.02549204f, 0.04205425f, 0.00803453f, -0.06252774f, 0.03188110f, 
    0.05696814f, -0.00783998f, -0.01267486f, -0.06459443f, -0.03005173f, -0.01397426f, 0.05699055f, -0.04333362f, 
    -0.06493673f, -0.07598994f, -0.03364136f, -0.07284691f, 0.05103110f, -0.07758895f, 0.00102411f, 0.00935884f, 
    -0.03060834f, -0.04084729f, -0.06120780f, 0.02396904f, 0.04440549f, -0.02311539f, -0.01694500f, 0.00507043f, 
    -0.02991326f, -0.05031849f, 0.05588957f, 0.00954749f, 0.04842891f, -0.02222148f, 0.01657986f, 0.06699216f, 
    -0.03091599f, -0.05760436f, -0.03161114f, -0.08183245f, -0.03773674f, 0.00856393f, 0.02935915f, 0.02461237f, 
    -0.03490305f, -0.03479066f, -0.03531056f, -0.03040502f, 0.06177875f, -0.04657875f, 0.02137510f, 0.05449037f, 
    -0.05231903f, -0.00877085f, 0.05088416f, 0.03164428f, -0.01269710f, -0.03211755f, -0.06738530f, -0.05475122f, 
    0.03011034f, -0.00261160f, -0.07451039f, -0.08538909f, 0.04725377f, 0.05863822f, 0.01385869f, -0.02949061f, 
    -0.04344482f, -0.03487210f, 0.04711838f, 0.02117322f, 0.07841019f, -0.07496746f, 0.02583320f, -0.05434445f, 
    0.00118706f, 0.01617284f, 0.03644250f, -0.07993200f, 0.02053518f, -0.04877470f, 0.06014405f, -0.01979025f, 
    0.05840265f, -0.00350873f, -0.06805619f, 0.05003955f, 0.03745206f, 0.04259168f, 0.05483669f, -0.03799485f, 
    -0.03804838f, -0.03997438f, 0.01679757f, -0.05418154f, -0.03651894f, 0.03651144f, -0.03336335f, -0.07186136f, 
    -0.05549218f, -0.04796955f, 0.05929181f, 0.00116797f, 0.05496951f, 0.03394127f, -0.07152376f, -0.04584825f, 
    0.03968137f, -0.00323532f, 0.03732499f, -0.07028152f, -0.00934858f, 0.06340420f, -0.07594977f, 0.04625602f, 
    -0.03268862f, -0.01680603f, 0.05902198f, 0.00091005f, 0.04062180f, -0.08448377f, -0.06635445f, -0.01756657f, 
    0.05312271f, 0.03542033f, 0.01003268f, 0.06162023f, -0.06658217f, -0.03395325f, 0.04432094f, -0.01853604f, 
    -0.05238052f, -0.07522059f, -0.08189300f, -0.08472348f, 0.04985201f, -0.01363317f, 0.02014041f, 0.05670423f, 
    -0.05896093f, -0.05490353f, -0.01299368f, 0.05910623f, -0.03688799f, -0.03793919f, 0.01968082f, 0.03006075f, 
    -0.07286074f, -0.06808753f, -0.00429225f, 0.00259771f, 0.01980790f, -0.07750759f, -0.02188212f, 0.02839154f, 
    -0.07880360f, -0.01959486f, -0.03957595f, -0.02823373f, 0.03416664f, -0.05090444f, -0.03194465f, -0.05579315f, 
    -0.04429463f, -0.05300499f, -0.00064398f, 0.03617904f, 0.00594576f, 0.03516769f, -0.07251035f, -0.00947101f, 
    -0.02712326f, -0.02990703f, -0.08131478f, -0.03506470f, -0.08060986f, 0.01768870f, -0.07743634f, 0.04360654f, 
    -0.00006368f, 0.14392591f, 0.25009167f, -0.20384790f, -0.16996801f, -0.06109112f, 0.09545667f, -0.09361472f, 
    0.12113364f, 0.07379460f, 0.02513891f, 0.00519548f, 0.21508928f, 0.14900436f, -0.00940311f, -0.07926954f, 
    0.13266334f, 0.02808233f, 0.09148405f, 0.18382518f, -0.02887701f, -0.07614392f, 0.09236367f, -0.00658263f, 
    0.09585129f, 0.19233660f, -0.24492995f, 0.16327049f, 0.18387043f, -0.10779693f, 0.20866619f, 0.04532481f, 
    -0.11176290f, 0.01261170f, -0.01202831f, 0.04013528f, 0.13926484f, -0.02081688f, 0.10141094f, 0.37462384f, 
    -0.05882343f, -0.00957204f, 0.03184127f, 0.03573674f, 0.01439790f, -0.07783986f, -0.16040382f, 0.25700235f, 
    -0.50836611f, 0.27131608f, 0.03711197f, -0.00333965f, -0.04572580f, 0.04753845f, -0.06890404f, 0.04822509f, 
    -0.03893608f, 0.10676327f, -0.07299054f, -0.13566183f, 0.01215506f, 0.15610822f, 0.10842732f, 0.10464813f, 
    -0.16218843f, 0.03617950f, 0.04119455f, -0.18302552f, -0.02031705f, 0.07983432f, -0.03975784f, 0.31428778f, 
    -0.05199462f, -0.11225223f, 0.33884951f, -0.06124518f, -0.13253179f, 0.00808942f, -0.20049778f, -0.06668308f, 
    0.06116506f, 0.12815538f, -0.07827275f, -0.11480921f, 0.48463953f, 0.02135777f, 0.09506159f, -0.20238629f, 
    0.13822079f, 0.05659587f, -0.05187225f, -0.08019869f, 0.12266284f, 0.05721727f, -0.03181332f, -0.09803401f, 
    0.20992301f, -0.12042786f, 0.05988820f, -0.11949899f, -0.08294015f, 0.07179949f, -0.16100492f, -0.21507709f, 
    0.16993113f, 0.02391702f, 0.14390917f, 0.28344518f, 0.16469911f, 0.01968448f, 0.04998055f, -0.14538769f, 
    0.23563929f, 0.20198378f, 0.27884319f, 0.25968069f, -0.01571246f, -0.04781716f, -0.10104088f, 0.05617564f, 
    0.09398071f, -0.46197844f, -0.29009223f, -0.22847620f, -0.06613603f, 0.16882691f, 0.14897579f, 0.04910741f, 
    0.09785011f, 0.11484318f, -0.02411323f, -0.02299999f, 0.16007078f, 0.09465653f, 0.16843320f, 0.14508060f, 
    -0.35707560f, -0.08739336f, -0.07514092f, -0.16862872f, -0.00865516f, -0.15899117f, -0.24449271f, 0.02636323f, 
    -0.22647987f, 0.05378355f, -0.01042761f, -0.11127330f, -0.03501730f, -0.15663436f, -0.11248298f, -0.03880773f, 
    -0.06035262f, -0.27938652f, 0.14080842f, 0.02946087f, 0.13093168f, -0.01025439f, 0.14170498f, -0.09245145f, 
    -0.17006546f, -0.06200629f, -0.09982295f, -0.15575825f, 0.06093012f, 0.09928159f, 0.09434367f, -0.00665090f, 
    -0.04482350f, -0.03470535f, 0.14043581f, 0.04280765f, 0.04467548f, 0.10280792f, 0.18098384f, 0.15585247f, 
    0.16188461f, -0.11378295f, 0.20719492f, 0.03459357f, 0.03072137f, -0.05797081f, 0.44895118f, -0.01347331f, 
    0.26109350f, -0.01849990f, -0.04005321f, -0.04682380f, 0.15024720f, -0.12556098f, 0.06414955f, -0.10429036f, 
    0.15026030f, -0.08292556f, 0.19085743f, -0.01470069f, 0.25688589f, -0.02412731f, -0.11052597f, -0.09011760f, 
    -0.39309481f, -0.30062801f, -0.12876175f, -0.29089922f, -0.07384749f, -0.03402066f, 0.28015876f, 0.16313083f, 
    0.08109464f, -0.03310330f, -0.00948947f, 0.20372905f, 0.16395183f, 0.17000176f, 0.20588684f, 0.18763852f, 
    0.08718794f, 0.12499683f, 0.23910430f, -0.06407076f, 0.00562288f, 0.09472401f, 0.11018080f, 0.11171402f, 
    -0.08037520f, 0.00898826f, 0.05379641f, -0.07671089f, -0.05010067f, 0.20889966f, -0.14901499f, -0.08162797f, 
    0.13936123f, -0.11396153f, -0.26850280f, -0.27184981f, -0.24974290f, -0.15393224f, 0.13331719f, -0.30077210f, 
    0.14471976f, 0.09758659f, -0.04839161f, 0.09681571f, -0.12598166f, -0.03718989f, 0.04893170f, -0.10694729f, 
    0.11115168f, 0.18324162f, 0.18610123f, 0.33187172f, 0.00323954f, -0.24545103f, -0.04017808f, -0.07196258f, 
    0.19472818f, -0.29598019f, -0.07304434f, -0.07716120f, -0.17239799f, -0.12668177f, -0.10133838f, -0.33655077f, 
    -0.08318836f, 0.09325554f, -0.31759307f, -0.45787442f, 0.05019046f, 0.11187603f, 0.13853200f, -0.12138860f, 
    0.20309147f, 0.11877896f, 0.25130370f, 0.40752855f, -0.09361512f, 0.11587296f, 0.16035913f, 0.21367522f, 
    0.04607800f, -0.00189245f, 0.06822434f, 0.27748749f, 0.23716737f, 0.07859870f, 0.07877640f, 0.40506375f, 
    -0.02645711f, -0.22252375f, 0.02874048f, -0.09249543f, 0.05656498f, -0.00628993f, -0.00817283f, -0.06588185f, 
    -0.31296736f, 0.11731555f, -0.11473366f, -0.43195322f, -0.16203827f, -0.20724301f, -0.04740920f, 0.05954322f, 
    -0.02463127f, -0.05045050f, -0.13847651f, 0.13927367f, -0.16055824f, -0.30505297f, 0.00268886f, -0.37793970f, 
    0.30378163f, 0.49469438f, 0.45605859f, 0.36545098f, -0.14636412f, -0.11798780f, -0.14847615f, -0.05350636f, 
    0.00461942f, -0.04107726f, 0.00652183f, -0.05693312f, 0.03108389f, 0.06756645f, 0.13771449f, -0.17661968f, 
    0.18897726f, 0.01560031f, -0.21012248f, 0.15878798f, 0.24687615f, 0.41852427f, 0.26885384f, 0.13232948f, 
    0.06592195f, 0.09672029f, -0.00055570f, 0.16362397f, 0.21892710f, 0.32502991f, -0.02426709f, 0.02472180f, 
    -0.34111968f, -0.06012754f, -0.21214619f, -0.50157756f, 0.11147351f, -0.21310815f, -0.13141075f, 0.16773085f, 
    0.32291111f, 0.31266004f, -0.00196166f, -0.30776688f, 0.14332075f, -0.12835130f, -0.13676859f, 0.00416886f, 
    0.28038326f, 0.13515542f, 0.02306979f, 0.10334006f, 0.13563183f, -0.06625212f, 0.16542692f, 0.01246524f, 
    -0.04974993f, -0.05412715f, -0.12939693f, -0.01174738f, 0.32091853f, 0.01837359f, -0.23806688f, 0.15447220f, 
    -0.03991842f, 0.10335392f, -0.02718561f, -0.00324782f, 0.19629024f, 0.26005554f, 0.21003495f, 0.38857040f, 
    0.26972026f, 0.11054544f, 0.28447795f, 0.19504148f, -0.06883772f, -0.02788224f, 0.07826518f, -0.15255810f, 
    0.07179931f, -0.08662258f, 0.00543646f, -0.11731644f, 0.18820179f, 0.05761372f, 0.01622955f, 0.02451578f, 
    0.11122888f, -0.00628796f, -0.02004967f, 0.15341091f, -0.07851902f, 0.10533095f, -0.05775045f, 0.12982094f, 
    -0.03822829f, 0.00321988f, -0.53108251f, 0.04376584f, -0.07531582f, -0.38509166f, 0.16151269f, 0.13876203f, 
    -0.10047706f, 0.06116979f, 0.00166174f, 0.01034541f, 0.00529296f, -0.20221539f, 0.05443869f, 0.25139287f, 
    -0.16556227f, 0.08694226f, 0.03713530f, -0.13010089f, 0.08470626f, -0.10546332f, -0.04316068f, 0.20577952f, 
    -0.08519766f, -0.01353322f, -0.14054281f, -0.00768235f, -0.09803607f, 0.13011132f, 0.03405225f, 0.04251400f, 
    -0.00495699f, -0.12707782f, -0.05020401f, 0.09124668f, 0.33509457f, -0.00734937f, 0.07612955f, 0.34305090f, 
    0.06097605f, 0.04123980f, 0.16718994f, -0.08572274f, -0.02002134f, 0.00386158f, -0.14515507f, -0.08635072f, 
    -0.00883970f, -0.00980663f, 0.16725038f, -0.19030580f, -0.12272301f, 0.13010097f, -0.07560903f, -0.02334700f, 
    0.04243532f, 0.06820436f, 0.00461782f, -0.02844605f, 0.58051556f, -0.02537271f, 0.14842819f, -0.06259004f, 
    0.11789877f, 0.09979854f, -0.19889416f, -0.16232286f, 0.05338898f, 0.08585922f, 0.08171940f, -0.02822401f, 
    0.16544230f, -0.01115806f, 0.15079151f, -0.17308789f, 0.02679501f, 0.11545083f, -0.12581429f, -0.21424887f, 
    -0.03470104f, 0.11157747f, 0.02975154f, -0.00540391f, 0.20683374f, 0.25343657f, 0.04560814f, -0.25139040f, 
    -0.13924718f, 0.09564310f, 0.06509482f, 0.25218150f, -0.01528251f, -0.03700843f, 0.16163012f, 0.02148944f, 
    0.76563615f, -0.15158181f, -0.19593389f, -0.14155681f, 0.10747331f, 0.05221391f, -0.10307942f, -0.05571754f, 
    -0.07258260f, -0.16507800f, -0.08088712f, 0.05752024f, 0.16477902f, -0.21060722f, 0.40038282f, 0.34658915f, 
    -0.09564732f, 0.05535199f, -0.14082186f, -0.12371837f, 0.24749532f, 0.03292976f, -0.00064238f, 0.07279316f, 
    -0.20218463f, 0.08972955f, -0.04688425f, 0.05809950f, -0.02904931f, 0.07917141f, 0.00291407f, -0.01529228f, 
    -0.09329801f, -0.04200988f, -0.02441415f, -0.07386756f, 0.08669904f, -0.07956225f, 0.14071414f, 0.15161073f, 
    0.02849684f, 0.19476907f, 0.02649836f, -0.16444890f, 0.00644504f, -0.11249300f, -0.07496689f, -0.06574523f, 
    0.06488496f, 0.15551682f, -0.09533617f, 0.03061120f, -0.10635058f, -0.02489878f, 0.14748938f, 0.16902538f, 
    0.16739002f, -0.04215489f, -0.10364459f, -0.00215560f, -0.48532215f, 0.23245192f, 0.04529156f, -0.21565972f, 
    -0.03490280f, -0.13449739f, -0.07878002f, -0.26152611f, 0.09105274f, -0.24376155f, 0.08449154f, 0.05256742f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00900144f, 0.07022576f, 0.01908804f, 0.09142826f, -0.05071316f, 0.10471826f, 0.17060979f, 0.24605721f, 
    -0.03231557f, 0.21484317f, -0.24271151f, -0.04453172f, 0.30743137f, 0.10451962f, 0.06814521f, -0.06880242f, 
    0.01958523f, -0.17180632f, 0.24634007f, 0.29345593f, -0.00129459f, -0.00797852f, 0.02217695f, -0.06638467f, 
    0.24157998f, 0.17353453f, 0.05460450f, 0.07838684f, 0.00633538f, 0.18261498f, 0.00165694f, -0.03787517f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13837467f, 0.13049474f, 0.01854766f, 0.35867125f, 0.04289839f, 0.09821125f, 0.62877202f, 0.17880839f, 
    -0.16410030f, -0.45197397f, 0.00361714f, -0.17006725f, 0.22290868f, -0.09478234f, 0.20364207f, -0.02194871f, 
    0.16405264f, -0.38181913f, 0.01514800f, 0.14364207f, -0.10884350f, 0.00555463f, 0.06748797f, -0.14241184f, 
    0.08579210f, 0.39751905f, 0.00889294f, 0.04789834f, -0.05631911f, -0.08601059f, -0.32757756f, -0.70113307f, 
    0.05680829f, -0.11291066f, 0.11429687f, 0.28331733f, -0.11866861f, -0.16772260f, -0.20630325f, 0.23671322f, 
    0.03828962f, -0.09335788f, 0.12461562f, -0.16973040f, -0.21502446f, -0.44446212f, -0.16684623f, -0.04204346f, 
    0.01059797f, 0.15199733f, -0.68152165f, -0.81240392f, -0.04099828f, -0.16890448f, -0.06595750f, 0.32188371f, 
    -0.19998543f, -0.10896974f, -0.21706547f, -0.32408664f, 0.10492209f, 0.19636358f, 0.25442675f, 0.27583405f, 
    0.04202084f, 0.27296764f, 0.09092057f, -0.05395864f, -0.09720810f, 0.05073661f, -0.07571622f, 0.08797322f, 
    -0.05866152f, -0.11573145f, -0.49435011f, 0.10203671f, 0.16048169f, -0.48820308f, 0.47670385f, -0.17971426f, 
    -0.03226617f, -0.38648069f, 0.05100384f, 0.11621638f, 0.13922225f, -0.09446073f, 0.03011894f, 0.13288324f, 
    -0.03004470f, 0.17579602f, 0.15686692f, 0.01454291f, 0.08778187f, 0.42246407f, -0.04323136f, -0.07755264f, 
    0.31626883f, 0.19630529f, -0.08731225f, 0.18184263f, -0.08779445f, -0.24327859f, 0.54923397f, 0.28180063f, 
    0.24883391f, 0.12083923f, 0.27873659f, -0.12317108f, -0.23988725f, -0.06403448f, 0.10634859f, -0.06321299f, 
    -0.03061121f, 0.30135107f, -0.20672844f, 0.00272322f, -0.05501641f, 0.11164238f, -0.11916093f, -0.06041238f, 
    0.09752420f, 0.08469040f, -0.33402514f, -0.07895458f, -0.08777767f, -0.36611918f, 0.03958258f, 0.19713788f, 
    -0.12111369f, -0.13422251f, -0.10135846f, 0.40482906f, 0.15016365f, -0.16625389f, -0.27558967f, 0.18541986f, 
    -0.09685181f, 0.23668310f, -0.66992825f, -0.14833085f, 0.60145062f, 0.54397058f, -0.18363979f, -0.14811884f, 
    0.05265188f, 0.15213598f, 0.29436600f, 0.20602135f, -0.00407663f, 0.14247236f, 0.01537686f, 0.11808950f, 
    -0.05528161f, -0.34153360f, 0.12758914f, -0.06028105f, -0.05269187f, 0.12844506f, -0.04610137f, -0.05447182f, 
    0.06258398f, 0.07631023f, -0.47995818f, -0.24633192f, -0.06203958f, -0.18389867f, 0.15477525f, 0.08521289f, 
    0.24504516f, -0.13625610f, -0.14529419f, 0.15582384f, -0.26170677f, 0.27918628f, 0.14925846f, 0.10682472f, 
    0.08995638f, -0.13215718f, 0.14945206f, -0.03340722f, -0.12656681f, -0.10469228f, -0.15035762f, 0.29003057f, 
    0.17341539f, -0.15484928f, 0.15570036f, -0.10246315f, 0.08808078f, -0.00735131f, -0.00066953f, 0.28948370f, 
    0.09468169f, -0.15197277f, -0.14463393f, -0.03383576f, 0.01783889f, -0.23794898f, 0.06321131f, -0.17863734f, 
    0.12496348f, -0.08352760f, -0.13495438f, 0.15611942f, 0.02055454f, 0.07055937f, -0.05058037f, 0.17839317f, 
    -0.11137381f, 0.01287692f, -0.26453301f, 0.13695474f, 0.06685469f, -0.15271439f, -0.12038606f, -0.09188988f, 
    0.08944155f, -0.22923966f, -0.18536760f, -0.05067420f, 0.09587036f, -0.13673022f, -0.04162652f, -0.21356086f, 
    0.37490627f, -0.30102682f, 0.26724151f, -0.26924419f, -0.13850613f, 0.34292015f, 0.41790333f, -0.07519493f, 
    -0.13791148f, 0.10512470f, 0.49570575f, 0.16702691f, -0.22656371f, -0.32400388f, 0.20905441f, 0.12483736f, 
    -0.04985945f, -0.07464225f, 0.09440327f, 0.18383941f, 0.06184780f, 0.12461449f, -0.00463582f, -0.11388575f, 
    0.20616424f, -0.03715270f, 0.35481003f, 0.23999856f, 0.04176666f, 0.39830247f, -0.22358792f, -0.28350276f, 
    -0.41018042f, 0.42528301f, 0.32829133f, 0.44433132f, -0.09922224f, 0.18514186f, 0.09975391f, -0.17066129f, 
    0.02567865f, -0.18605486f, -0.30500829f, 0.04483843f, 0.18631630f, 0.13981229f, -0.48338032f, -0.14745374f, 
    0.09026472f, -0.04211096f, -0.08882661f, -0.12858200f, 0.03674895f, 0.14428310f, -0.06914981f, -0.13706984f, 
    0.12254483f, -0.27277932f, -0.20107117f, 0.39607877f, 0.12172913f, 0.04502517f, -0.07960089f, 0.23294501f, 
    -0.49915871f, 0.22884266f, 0.30265158f, 0.50494516f, -0.10457169f, 0.35027310f, 0.35505891f, -0.18258265f, 
    -0.12380723f, -0.10081808f, -0.02042023f, -0.13164501f, 0.28765261f, -0.24791431f, -0.45735925f, 0.14960966f, 
    -0.09533592f, -0.35123068f, 0.05219858f, 0.20822045f, 0.01814478f, -0.00377989f, 0.15672629f, 0.05566062f, 
    -0.03000072f, -0.05657871f, -0.31565610f, 0.17812343f, -0.11567267f, -0.09630386f, 0.05776582f, -0.41371506f, 
    0.28172690f, 0.32478657f, 0.04530661f, -0.07942372f, 0.05139308f, 0.12348975f, 0.55866206f, 0.07233304f, 
    -0.36025608f, -0.33487940f, 0.33173054f, -0.02467443f, -0.01091910f, 0.26665920f, 0.38332018f, -0.11944151f, 
    0.09979441f, 0.04926159f, 0.22285631f, 0.05724331f, 0.11008757f, 0.02218909f, -0.15010643f, -0.05386460f, 
    -0.29570583f, 0.19766495f, -0.41227844f, -0.39226329f, 0.07113209f, -0.04805495f, 0.03848092f, 0.05128066f, 
    0.12166629f, 0.00036407f, -0.09118115f, -0.07102357f, -0.01722804f, 0.16632649f, 0.31039661f, 0.15462443f, 
    -0.12416095f, -0.05533986f, 0.00189271f, -0.05706098f, 0.05568435f, 0.63454986f, 0.30153197f, -0.05656247f, 
    0.00715110f, 0.00875491f, 0.35729498f, 0.27499348f, -0.04224389f, -0.16592264f, 0.16260700f, -0.40367666f, 
    0.12607448f, 0.34516391f, -0.27826115f, -0.35200515f, 0.13383602f, 0.15032290f, -0.29441550f, 0.32463044f, 
    0.31507692f, 0.27530947f, 0.22695924f, -0.03430019f, 0.02242428f, -0.12964624f, 0.21013553f, -0.05374019f, 
    -0.27110189f, 0.12610711f, -0.05240616f, 0.07922788f, -0.02325327f, -0.37843239f, 0.26557297f, 0.06078459f, 
    0.05957310f, -0.10354530f, -0.10226603f, 0.01777354f, 0.11965100f, 0.01315237f, -0.03840398f, 0.05854610f, 
    -0.38610637f, -0.15951504f, 0.08935078f, -0.12173565f, -0.10824846f, 0.29165551f, -0.00521360f, 0.33645022f, 
    0.10608690f, -0.01309846f, 0.24921797f, -0.13154882f, 0.01370908f, -0.19448240f, -0.02247204f, 0.12324077f, 
    -0.06559459f, 0.28044152f, -0.39562368f, 0.02563940f, 0.41256917f, 0.10883236f, 0.49816954f, -0.02969998f, 
    -0.14742595f, -0.12338571f, -0.01012477f, -0.01343810f, 0.08282181f, -0.00272212f, -0.07320692f, -0.20081276f, 
    -0.02494671f, 0.44648975f, 0.37477288f, 0.30712739f, -0.12595074f, 0.13292836f, 0.05290946f, -0.45039058f, 
    0.14724429f, 0.04892570f, -0.25718260f, -0.08264352f, 0.13947408f, -0.11236756f, -0.14833273f, 0.22399774f, 
    0.18296103f, 0.07650146f, 0.34393385f, 0.06911463f, -0.24367848f, 0.24511856f, -0.26294377f, 0.15960421f, 
    0.07745657f, 0.36565149f, -0.23823489f, -0.20206389f, -0.16873373f, 0.14973606f, 0.14343216f, 0.11039326f, 
    -0.24344721f, 0.12892839f, -0.11993866f, -0.27532059f, -0.06550912f, 0.07855518f, 0.25559086f, 0.39104617f, 
    0.26694000f, -0.59476757f, 0.24987057f, -0.11325691f, -0.06416190f, 0.36855033f, -0.10433403f, -0.09789916f, 
    0.10450813f, 0.31443045f, 0.36553001f, -0.08586741f, -0.11303315f, -0.04464825f, -0.08667303f, -0.17498948f, 
    0.14878158f, 0.28899565f, 0.04189549f, 0.16146567f, 0.15551144f, -0.09209353f, -0.01630798f, 0.24661775f, 
    -0.01379304f, -0.39285463f, 0.02568954f, -0.18947038f, 0.05144009f, 0.36982194f, -0.24449404f, 0.48120871f, 
    0.13395214f, 0.27845526f, 0.14611188f, 0.36840314f, -0.15676832f, -0.01107462f, -0.15020889f, -0.29148433f, 
    -0.35869861f, -0.08978006f, -0.35077301f, -0.18807894f, 0.13550055f, 0.03283069f, 0.22345874f, 0.11057256f, 
    -0.16191007f, 0.07310567f, -0.02114127f, -0.00205861f, 0.16705531f, -0.04898595f, -0.02919867f, -0.16836748f, 
    -0.35096434f, -0.48223725f, 0.14014316f, -0.00786838f, 0.13854210f, 0.41823545f, 0.01041030f, 0.67847168f, 
    0.09746335f, -0.16808513f, -0.03930767f, 0.07402827f, -0.14586180f, -0.07632632f, 0.00971301f, -0.19694829f, 
    -0.12883157f, -0.16681084f, 0.00650473f, -0.12099743f, 0.15538782f, -0.17615099f, -0.07262527f, -0.07041255f, 
    -0.00063933f, -0.07768220f, -0.02149563f, 0.08647883f, -0.06462031f, 0.07460148f, 0.08762512f, -0.13350314f, 
    -0.05406227f, 0.12666045f, -0.16920435f, -0.08157779f, 0.14442620f, -0.14838102f, -0.13050847f, -0.20254621f, 
    0.01519509f, 0.16664229f, -0.21346240f, -0.47921121f, -0.01324477f, -0.13966778f, 0.45298406f, -0.05115769f, 
    -0.16837494f, 0.48557439f, 0.10907444f, 0.06766752f, -0.28039333f, 0.07456940f, 0.25228637f, -0.11076470f, 
    -0.01201961f, -0.01344724f, -0.25601384f, -0.22352278f, 0.04905577f, 0.05706740f, -0.15656263f, 0.06021120f, 
    0.16230606f, 0.16679691f, -0.18259150f, -0.12708732f, -0.16827744f, -0.23339637f, -0.10147721f, 0.07081322f, 
    0.29768878f, -0.22041667f, 0.07028095f, 0.10541736f, 0.12994510f, 0.14413841f, -0.00625704f, 0.25664985f, 
    -0.29437611f, 0.09622762f, -0.13077636f, 0.07895597f, 0.11761955f, 0.63946712f, -0.20049134f, -0.13615082f, 
    -0.01603143f, 0.23083691f, 0.16214909f, 0.15702243f, -0.01692038f, 0.04679261f, -0.07610888f, -0.16420057f, 
    0.00623237f, 0.03221548f, -0.24094941f, -0.44761544f, 0.07663629f, 0.20291606f, -0.12640531f, 0.42802680f, 
    0.16980048f, 0.44302192f, 0.31244126f, -0.08059449f, 0.14249767f, -0.14381854f, -0.15095654f, -0.01599284f, 
    -0.14005040f, 0.16711278f, -0.21746638f, 0.18361372f, 0.25216040f, -0.36351663f, 0.16234167f, 0.13170639f, 
    0.14678641f, 0.12330119f, -0.09431003f, -0.37168318f, 0.05848890f, -0.03664316f, -0.13034616f, 0.24886414f, 
    -0.25136560f, 0.06280179f, 0.08216588f, 0.06060921f, 0.09497037f, -0.12357895f, 0.40441582f, 0.15743001f, 
    0.01384183f, 0.26952285f, 0.22972266f, 0.01961074f, -0.15307346f, 0.39675876f, -0.04038301f, -0.33500618f, 
    0.06407910f, -0.05668845f, 0.61591995f, -0.15235656f, 0.00411396f, -0.14421846f, 0.22462744f, 0.12114444f, 
    -0.13455418f, 0.07298797f, 0.01962425f, -0.08991878f, -0.06924055f, -0.08861938f, -0.16385125f, -0.43085879f, 
    -0.32646504f, 0.27749467f, -0.31034085f, 0.34700766f, -0.03180841f, -0.20915981f, 0.55152249f, 0.00590526f, 
    0.00440094f, -0.10328474f, 0.06236123f, 0.38070992f, -0.04801790f, 0.33014724f, -0.13352521f, 0.00427990f, 
    0.25097981f, -0.00194528f, -0.14762127f, -0.03578045f, 0.19637837f, 0.10224676f, -0.30438417f, -0.02366563f, 
    0.09007518f, -0.15735550f, 0.16869441f, 0.03957986f, -0.03768560f, 0.00461587f, -0.04394275f, -0.03229341f, 
    0.29425961f, -0.07172965f, -0.19964334f, 0.24026081f, -0.02523581f, 0.23569295f, -0.03501185f, -0.02010607f, 
    -0.12607849f, -0.02371155f, -0.01234697f, 0.00878786f, -0.15265249f, -0.04759710f, -0.20751606f, 0.06980580f, 
    0.10387626f, -0.00385421f, 0.04274931f, 0.12982695f, -0.13989992f, -0.10444752f, 0.05551539f, -0.02371377f, 
    -0.11306492f, -0.12528279f, -0.04184373f, -0.23392747f, -0.15742238f, 0.04489942f, 0.15547667f, -0.19124688f, 
    0.12345611f, 0.00569271f, 0.17612183f, -0.15668853f, -0.09879556f, -0.07618339f, -0.05697675f, -0.04935469f, 
    -0.00048802f, -0.12576136f, 0.22693814f, 0.30396202f, -0.03704995f, -0.32672599f, -0.01773270f, 0.23518942f, 
    0.21638256f, 0.17424542f, -0.03734815f, -0.11905666f, -0.14579009f, -0.59990054f, 0.01578565f, 0.03806448f, 
    0.16577739f, 0.42849094f, -0.42305663f, -0.38854307f, 0.10994717f, -0.12342498f, -0.13309497f, -0.12119474f, 
    -0.11055040f, -0.00877713f, 0.43039435f, 0.27865800f, 0.06227044f, 0.06633554f, 0.21440096f, 0.02967712f, 
    -0.00978849f, 0.07046582f, -0.06812573f, 0.26084307f, -0.01193997f, -0.24352878f, 0.02110492f, -0.13045017f, 
    0.12643643f, 0.06804151f, -0.63738286f, 0.10462797f, 0.31563023f, 0.03762230f, -0.03948205f, 0.00890202f, 
    -0.15107498f, 0.08785143f, 0.10455024f, -0.17552918f, 0.16875120f, -0.03813768f, -0.12866828f, 0.25790313f, 
    -0.23297931f, -0.19165745f, 0.31358084f, 0.23076774f, 0.00006004f, -0.06784926f, 0.08346473f, 0.15275171f, 
    -0.14174932f, 0.06211307f, -0.02125812f, 0.52944446f, -0.16813688f, -0.04937095f, 0.04303383f, 0.33523998f, 
    0.30403754f, 0.44630447f, -0.26509199f, -0.15410765f, -0.37007356f, 0.07587816f, 0.28101611f, 0.03577656f, 
    -0.04498491f, 0.10030419f, 0.01031834f, -0.06571446f, 0.04969835f, -0.13498659f, 0.15306373f, -0.29679972f, 
    0.31186098f, 0.45621410f, 0.06833233f, 0.15876906f, -0.14558376f, -0.01090388f, 0.01297514f, -0.15094943f, 
    0.15874003f, 0.21553698f, 0.40963349f, 0.00210025f, 0.15035009f, 0.19168761f, -0.47008485f, 0.01642349f, 
    -0.09187950f, 0.00931600f, -0.10164674f, -0.11009531f, 0.30977458f, -0.01833105f, 0.23574480f, -0.02596814f, 
    0.03811011f, 0.17217191f, 0.10854450f, -0.25175929f, 0.01125505f, -0.03440461f, 0.13185675f, -0.24944992f, 
    -0.46160331f, 0.19207291f, -0.27512929f, -0.05626535f, 0.06074278f, -0.18479191f, 0.62316906f, -0.29146409f, 
    0.29989180f, -0.41754448f, -0.27444747f, 0.50308758f, -0.09256407f, -0.22341859f, -0.00903804f, 0.23463862f, 
    0.05531422f, 0.42262220f, 0.06827473f, -0.14060014f, -0.31463167f, -0.13102314f, 0.05669743f, 0.03690366f, 
    -0.11410473f, 0.08165466f, -0.25852412f, -0.02686421f, 0.14086640f, 0.00433528f, -0.10068996f, -0.09186065f, 
    0.04295350f, -0.16998032f, 0.17580645f, -0.21209662f, -0.11422480f, 0.24317791f, -0.00970419f, 0.14379755f, 
    0.12540385f, -0.02466571f, 0.08163004f, -0.29059103f, -0.17309950f, 0.15096024f, -0.27831161f, 0.29085433f, 
    0.18427327f, -0.10457364f, 0.21112290f, -0.14031617f, 0.57991171f, 0.53776795f, -0.46213001f, -0.08544536f, 
    0.13993047f, -0.00977220f, 0.11531401f, 0.03577182f, -0.14200400f, 0.03992415f, -0.04446819f, 0.19804947f, 
    0.28453341f, 0.16386954f, -0.49277568f, -0.06001353f, -0.07341127f, -0.37001312f, 0.52817321f, 0.10216481f, 
    -0.58949733f, 0.04338863f, 0.40124530f, 0.17439908f, 0.00391268f, 0.47886476f, 0.23356837f, -0.36469710f, 
    0.14937632f, -0.12225074f, 0.16110550f, 0.09879251f, -0.18462530f, -0.05191962f, 0.06303874f, 0.00995344f, 
    0.07352906f, -0.18483801f, 0.04418474f, 0.26243895f, 0.14944816f, 0.15306829f, -0.16743700f, -0.08576214f, 
    -0.05391712f, -0.16265956f, 0.42599207f, 0.03856176f, 0.04933211f, 0.07711598f, -0.06891455f, -0.02948065f, 
    0.19537546f, 0.26012388f, 0.18479227f, 0.11767449f, -0.04785945f, -0.12045436f, -0.08689801f, -0.08574409f, 
    -0.06984862f, -0.01591483f, 0.06670722f, -0.14024161f, -0.29055506f, 0.34713751f, 0.29447898f, -0.14240311f, 
    0.12362236f, -0.06154173f, 0.23740995f, -0.02352994f, 0.17026666f, -0.08911680f, 0.15808499f, -0.04132856f, 
    -0.08963965f, -0.05095489f, 0.00558159f, -0.34005302f, -0.02061079f, 0.40304539f, -0.22362091f, 0.84983230f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05531221f, -0.04901019f, 0.43826795f, 0.00460857f, 0.24084036f, 0.01842094f, -0.07746260f, -0.03452938f, 
    0.05329210f, 0.16567355f, 0.02429678f, 0.10534405f, 0.07470725f, 0.39782625f, -0.30878732f, -0.18816246f, 
    -0.26454407f, -0.06102883f, 0.05822318f, -0.00074410f, 0.08735209f, -0.25797829f, 0.36241505f, -0.10357286f, 
    0.11235460f, -0.07507154f, 0.17622365f, 0.09958231f, 0.10538632f, 0.17407602f, 0.27006322f, 0.07763860f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.00606390f, 0.67102748f, -0.19751844f, 0.04690487f, -0.37892541f, 0.06654815f, 0.09556735f, 0.05409072f, 
    -0.37763479f, -0.09655353f, -0.12123128f, -0.37983006f, 0.17377028f, -0.56402338f, 0.26111385f, 0.34335682f, 
    0.02821637f, 0.12925045f, -0.46278048f, -0.00856629f, -0.01547793f, 0.02443612f, -0.08673939f, -0.12205789f, 
    0.15586580f, 0.01044194f, -0.13760835f, -0.29064986f, 0.25007048f, -0.02469150f, -0.40715706f, -0.06146407f, 
    -0.20614079f, -1.08293641f, -0.25060403f, 0.00064939f, 0.28717938f, -0.20582838f, -0.09652735f, 0.11406951f, 
    0.30788052f, 0.14846158f, -0.30154049f, 0.29012933f, -0.33772615f, -0.02384081f, 0.23634568f, 0.27180058f, 
    0.07747256f, -0.09286234f, -0.52486992f, 0.40945998f, -0.60313368f, -0.51217878f, 0.11988540f, -0.10423364f, 
    -0.15487318f, -0.22246945f, 0.09352348f, -0.61615753f, 0.27088732f, 0.00956084f, 0.35497382f, 0.17137825f, 
    -0.28195551f, -1.21602499f, 0.09275087f, -0.28846171f, -0.03678067f, 0.11331211f, -0.01056938f, -0.14067201f, 
    -0.62361848f, -0.36680856f, 0.11388736f, 0.28273776f, -0.16800871f, 0.34687448f, -0.47742602f, 0.00387009f, 
    -0.75594187f, -0.03587413f, 0.04409844f, 0.28906876f, 0.09061661f, 0.04852168f, -0.10354415f, -0.00533308f, 
    -0.81597519f, -0.18302032f, -0.04667599f, 0.45941141f, -0.40909147f, 0.44732904f, -0.67346722f, -0.19019569f, 
    -0.06991410f, -0.51283878f, -0.30781356f, 0.22309417f, -0.76645166f, 0.20486861f, -0.16311441f, -0.02076738f, 
    -0.05808597f, -0.40292889f, 0.34068668f, 0.17354666f, 0.23631978f, 0.08043887f, 0.02270903f, -0.08139045f, 
    -0.06887858f, 0.03085047f, -0.11470289f, 0.11362082f, 0.17137703f, 0.30809984f, -0.57843095f, 0.05706879f, 
    -0.06405718f, -0.42856374f, 0.07693076f, 0.10065226f, -0.16244043f, -0.03700945f, -0.30325776f, 0.03370368f, 
    -0.27613249f, 0.05815196f, -0.29863989f, -0.04057334f, 0.24933083f, 0.24565661f, -0.23995760f, -0.22799566f, 
    -0.58063424f, -0.80288887f, -0.22721238f, -0.28015962f, -0.27597028f, 0.05784035f, 0.06926586f, -0.23638286f, 
    -0.61060685f, -0.09150315f, 0.55833203f, -0.06010651f, 0.14850400f, 0.08623144f, -0.14815231f, -0.03577167f, 
    0.18717375f, 0.14328818f, 0.30364791f, 0.30242404f, -0.01152168f, 0.08561269f, 0.48835140f, -0.23629385f, 
    -0.04489192f, 0.02080300f, 0.13743345f, -0.11317953f, 0.38334432f, -0.28008115f, 0.05955231f, 0.08006397f, 
    -0.16429800f, -0.33213043f, -0.36969644f, -0.20947732f, 0.23747806f, 0.35297385f, -0.34996876f, 0.04893560f, 
    0.15714394f, -0.13855228f, -0.24880289f, 0.03133767f, 0.04637130f, -0.87538964f, -0.06228297f, 0.15729976f, 
    0.35393438f, 0.29684582f, 0.23020513f, -0.23780888f, 0.31868684f, -0.48251525f, 0.04584013f, -0.17421672f, 
    0.33244029f, -0.46005914f, -0.08011948f, -1.07691920f, 0.27951872f, -0.04509612f, -0.03412044f, -0.10301583f, 
    0.24114195f, 0.44555494f, -0.05414286f, -0.27447879f, -0.40087816f, -0.10604131f, -0.16842255f, -0.38813412f, 
    -0.29877472f, 0.09521766f, -0.42006081f, -0.36192745f, -0.01738429f, 0.20562778f, 0.19690917f, -0.06348677f, 
    -0.55370498f, 0.06278390f, -0.65092504f, 0.13841438f, -0.21794719f, 0.41961792f, -0.02255670f, -0.80000836f, 
    -0.43288046f, -0.67678279f, 0.05824203f, -0.51858717f, 0.02329707f, 0.34567520f, -0.18106313f, 0.06908633f, 
    -0.23910949f, 0.00845637f, 0.24709237f, -0.16804256f, 0.49875620f, -0.31277478f, -0.39708504f, 0.11707255f, 
    0.34449992f, 0.13084497f, -0.37388590f, -0.23357520f, -0.08891851f, 0.29275668f, -0.15903905f, -0.09111516f, 
    0.04714894f, 0.12979493f, -0.49280378f, 0.17398100f, -0.03440618f, -0.43019110f, 0.16452818f, 0.44525948f, 
    0.50924730f, -0.20941713f, 0.36914349f, -0.07162327f, -0.36175591f, -0.12692612f, -0.01728758f, 0.35380030f, 
    -0.21067257f, -0.34538773f, 0.05849320f, 0.21772309f, 0.16150674f, 0.27008617f, -0.42169091f, -0.39270002f, 
    -0.15545459f, -0.02932501f, -0.46791717f, -0.34338072f, -0.34888858f, -0.11898217f, -0.05782723f, -0.18386665f, 
    -0.66618276f, -0.26013118f, -0.01124627f, -0.42506808f, -0.14525677f, -0.44516781f, -0.05217877f, 0.10783266f, 
    -0.75540042f, -0.68123651f, 0.16200837f, -0.16814968f, 0.38904932f, -0.06740208f, -0.34865215f, -0.52695048f, 
    0.26775655f, -0.12966770f, -0.20016162f, -0.15559138f, 0.15467831f, 0.05950158f, -0.24361233f, -0.29520303f, 
    0.28685984f, 0.03619184f, -0.17558363f, -0.06826124f, 0.31751665f, 0.05633193f, 0.15716785f, -0.29509759f, 
    -0.00120752f, 0.16377941f, -0.12768511f, 0.07577210f, -0.69337434f, 0.24358295f, -0.33896253f, 0.06630819f, 
    0.46081385f, -0.15827239f, 0.02880637f, 0.18041398f, 0.31267047f, -0.10896768f, 0.14674899f, -0.72123736f, 
    -0.00364806f, -0.20061895f, 0.49437359f, 0.44526267f, -0.19863994f, -0.06146676f, -0.14012624f, -0.71850455f, 
    -0.02098687f, -0.01743361f, -0.76720840f, 0.27825597f, -0.46050662f, -0.56703222f, 0.02770776f, -0.13160205f, 
    -0.47516766f, 0.06507368f, 0.24886997f, -0.49917638f, 0.02289612f, -0.09847206f, -0.50701594f, 0.30011401f, 
    -0.00647988f, 0.08832072f, -0.07830149f, -0.02395991f, -0.63240016f, -0.46977895f, -0.05352249f, 0.01099932f, 
    0.34778282f, 0.22921081f, -0.59051198f, -0.06535258f, -0.51148456f, 0.08201017f, -0.30359599f, -0.35384175f, 
    -0.41826057f, 0.08003163f, -0.19789426f, -0.70899439f, -0.20184925f, 0.39599085f, 0.32641131f, -0.19899926f, 
    0.06697904f, -0.47158113f, 0.52784187f, -0.06134744f, 0.06037690f, -0.16307442f, 0.26448801f, -0.18045010f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.38521290f, -0.08977701f, 0.34033170f, -0.25084570f, 0.09373987f, 0.15447503f, 0.10155567f, -0.12041835f, 
    0.20349506f, 0.10551215f, -0.01604955f, 0.00457967f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
