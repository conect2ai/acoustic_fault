#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.82038891f, -0.69879282f, -0.88807857f, -1.00607884f, -0.22636367f, -1.22877514f, -0.00078044f, -0.44941807f, 
    -0.09119906f, 0.65378112f, -1.15153825f, -0.71504563f, -0.82701838f, -0.06391434f, -0.44124985f, -0.51509184f, 
    1.09055936f, -1.12796903f, -0.03825541f, 1.14078355f, 0.97947991f, -1.16196942f, 0.35573134f, -0.56147957f, 
    -0.23550436f, -0.19697657f, 0.39413539f, -0.54679084f, -0.13120328f, 0.65472740f, -1.15975666f, 0.44565737f, 
    -0.40693271f, -0.03209905f, -0.20784459f, 0.65727276f, -1.42074513f, -0.59595752f, -0.20508829f, -0.19974157f, 
    -0.73900813f, -0.62234616f, -0.75606835f, -0.81145376f, -0.56204486f, 0.39391455f, 0.10924600f, 0.80811262f, 
    -0.41548753f, 0.57141668f, -0.24081796f, 0.30889124f, 1.41381967f, -0.02583553f, 0.49474734f, 0.29064623f, 
    1.01572549f, 0.05174650f, 0.77282381f, 0.23446415f, 0.87453765f, -0.63063586f, -0.26583987f, -0.96817815f, 
    -1.35901439f, -1.39891160f, 0.74163848f, 0.32043299f, 0.18555596f, 0.70676881f, 0.08599403f, 0.63478917f, 
    -0.76380104f, -0.45347878f, -0.39373979f, 0.43952468f, -0.88339084f, -0.77151853f, -0.10026364f, 0.86505336f, 
    0.81249434f, -1.73633265f, -0.84202629f, -0.63202560f, 0.09742858f, 0.35872304f, 0.61412472f, -0.27863604f, 
    0.21004814f, -1.05219615f, -0.40247673f, 0.16346835f, -0.01586452f, -1.09114969f, -1.43631184f, -1.19852698f, 
    0.29693398f, 0.41414624f, 0.24467853f, 0.23651297f, -0.24798900f, -0.26440352f, -0.16410574f, 0.70428038f, 
    1.29344296f, 0.36137003f, 0.39105874f, 1.02693748f, 0.96621388f, -0.34925848f, 0.23293938f, 0.23414861f, 
    -0.60717165f, 1.33539522f, -0.20141627f, 0.56120116f, -1.06825686f, -0.08942658f, 0.27238396f, 0.07780443f, 
    0.91395348f, 0.71636301f, -0.99249405f, -0.50694180f, -0.53040147f, 0.99334067f, 1.22603500f, 1.93912864f, 
    -1.72002411f, -0.60700458f, -0.21254925f, -0.02207751f, -0.21819681f, 0.61462498f, 0.10569929f, -0.21847723f, 
    -0.81214291f, -1.18919230f, 0.74146354f, 0.72672302f, 0.18163659f, -0.57214308f, -0.79724717f, -0.42390433f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.41486561f, 0.26942468f, -0.04132814f, 0.88337493f, 0.74734050f, 0.41507867f, 0.44105926f, 0.68318683f, 
    -0.06188575f, 0.95973015f, 0.61078316f, 0.82514042f, 0.29132733f, 0.30726302f, 0.37486205f, 0.61355025f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.29233077f, 0.25110382f, 0.38690284f, -0.09399658f, 0.10632744f, 0.00248004f, 0.28907251f, 0.06372217f, 
    0.00277662f, -0.00337652f, 0.03048300f, 0.09617677f, 0.07516141f, -0.01095957f, -0.00547589f, 0.16650906f, 
    -0.31797326f, -0.14388530f, 0.03611124f, -0.20342875f, -0.41094062f, 0.25510886f, -0.47734809f, -0.08318346f, 
    0.19607049f, 0.22869460f, 0.19412781f, 0.32867870f, 0.17471159f, -0.23917001f, -0.03935384f, -0.39096227f, 
    0.06491300f, -0.22219884f, 0.05337854f, 0.06204332f, 0.54387873f, 0.18232505f, 0.25473246f, 0.19970560f, 
    0.00552266f, -0.05076508f, 0.15671979f, 0.05891325f, -0.32135960f, 0.26362464f, -0.48580468f, -0.41467696f, 
    -0.03653428f, -0.16139893f, -0.04242894f, 0.24200204f, 0.19968233f, 0.34375313f, -0.19157290f, -0.18485560f, 
    -0.62502342f, 0.27065775f, -0.08887207f, -0.08695910f, -0.02890924f, 0.09478690f, -0.05221153f, 0.06394026f, 
    -0.09467500f, -0.25652209f, -0.08764210f, 0.23403710f, 0.03519471f, -0.13669239f, 0.00700804f, 0.23242332f, 
    -0.11882858f, 0.41335499f, 0.58300787f, -0.07128359f, -0.27655742f, 0.15655378f, -0.04852971f, 0.07376423f, 
    0.13779348f, 0.17351677f, -0.12191745f, -0.17227547f, 0.13391203f, 0.14089701f, 0.29628623f, 0.06830139f, 
    0.08385969f, 0.03001578f, 0.16780975f, 0.24755904f, 0.39599773f, -0.30698866f, -0.46432415f, -0.09527513f, 
    -0.19446178f, 0.04361016f, 0.07878350f, 0.12000862f, -0.77875715f, -0.57248026f, -0.04910646f, 0.05465304f, 
    0.03492732f, 0.34826908f, 0.08242088f, 0.00646136f, 0.23775120f, -0.33835047f, -0.38181686f, 0.17701167f, 
    -0.10827927f, -0.24187335f, -0.16785960f, 0.16226555f, -0.03635159f, -0.28962520f, -0.11947873f, -0.53313309f, 
    0.29802024f, -0.11008071f, 0.08702599f, 0.09440260f, 0.21267885f, 0.17251697f, -0.42324898f, -0.90551049f, 
    -0.94075340f, -0.20329905f, -0.65628868f, 0.09268777f, 0.21741025f, 0.27709597f, -0.16078240f, 0.65250611f, 
    0.03749536f, 0.03876435f, 0.20322800f, -0.14107512f, 0.27675387f, 0.23019226f, 0.02663058f, -0.06803840f, 
    0.18354201f, 0.17327005f, 0.53100044f, 0.09781266f, 0.11707249f, 0.17757577f, 0.06322263f, -0.01556700f, 
    0.03746064f, 0.27803823f, 0.13031366f, 0.52831781f, 0.13974607f, 0.22921677f, 0.14332335f, 0.19527750f, 
    -0.03640522f, 0.04655706f, -0.46045437f, -0.88537461f, -0.01242210f, 0.08504596f, -0.22094585f, 0.15689003f, 
    0.17972645f, 0.09215231f, 0.14807206f, -0.15831755f, -0.17874636f, 0.09356656f, 0.10348583f, -0.02836158f, 
    -0.29598165f, -0.01293996f, -0.05751887f, -0.06354687f, 0.02929896f, 0.12428152f, 0.24830136f, -0.16473101f, 
    0.02968045f, 0.11957953f, 0.02699894f, -0.03595561f, -0.15978464f, 0.10415643f, 0.07791046f, 0.14051811f, 
    0.16651103f, 0.24173999f, 0.22635230f, -0.17904855f, -0.12122348f, 0.04902586f, 0.04689859f, -0.16541249f, 
    0.04385447f, 0.21670426f, -0.03490624f, -0.01112783f, -0.01840081f, -0.11544046f, 0.11355357f, -0.52616692f, 
    -0.09768770f, -0.57270050f, 0.20598547f, 0.06851312f, -0.06888297f, 0.08659801f, -0.02470332f, -0.03820960f, 
    0.08356385f, -0.00747741f, 0.17155717f, -0.08067174f, 0.12220829f, -0.09372517f, 0.14909655f, 0.05725955f, 
    0.03601470f, -0.30842462f, -0.04398815f, -0.51647872f, 0.16063522f, 0.01887991f, 0.11638899f, 0.23773612f, 
    -0.08234805f, 0.09904074f, 0.13147675f, 0.02165854f, 0.25083426f, -0.00400719f, -0.04314431f, -0.09819801f, 
    -0.13353267f, 0.02085271f, -0.02948755f, 0.02874955f, -0.14065845f, 0.07429667f, 0.08415402f, 0.05566370f, 
    -0.09035241f, -0.15057889f, 0.27487952f, -0.27501634f, -0.34442505f, 0.06170096f, -0.10126682f, 0.15143657f, 
    0.03682486f, -0.33633268f, 0.17184207f, 0.01369939f, 0.30373132f, -0.04403315f, -0.26260623f, -0.26924050f, 
    -0.15194975f, 0.20147355f, 0.02650054f, 0.01350632f, 0.07590185f, -0.14324334f, 1.01645970f, 0.03724045f, 
    -0.62472737f, -0.17375991f, 0.21259010f, 0.00651642f, 0.26894873f, -0.07619789f, -0.01844058f, -0.22944772f, 
    0.01119730f, -0.86449164f, -0.00713195f, -0.04414823f, 0.00199050f, -0.06758056f, 0.13134202f, -0.09034654f, 
    -0.89548314f, 0.33100098f, -0.21958967f, 0.06444708f, -0.00290602f, 0.18394573f, 0.15580799f, 0.03479731f, 
    -0.09929830f, 0.17236744f, 0.20457917f, -0.30899140f, -0.05944726f, 0.04649453f, -0.08475330f, 0.02424802f, 
    0.04348325f, -0.44827676f, -0.02172455f, -0.45022252f, 0.20505026f, 0.08056031f, 0.07136786f, -0.26027471f, 
    0.17227548f, -0.06680617f, -0.07300825f, 0.06980400f, 0.22464709f, 0.23156744f, 0.18000102f, 0.20074488f, 
    -0.04056478f, 0.05855770f, 0.14379224f, 0.13700877f, -0.39076892f, 0.08469635f, 0.16034292f, 0.04455920f, 
    0.04109512f, 0.13144068f, 0.02654020f, 0.04406993f, -0.22973737f, -0.04287090f, -0.25737435f, -0.01504614f, 
    0.31776527f, 0.04175040f, 0.08137100f, 0.19102064f, 0.24744186f, 0.20869088f, 0.00747416f, -0.26527658f, 
    -0.02600094f, -0.00604337f, 0.10338431f, 0.07287555f, -0.09088365f, -0.02815726f, -0.16594112f, 0.00172560f, 
    0.23102643f, -0.18144585f, 0.00961578f, -0.09748614f, -0.02869248f, -0.04723693f, 0.19274411f, 0.07214660f, 
    -0.10378916f, 0.06790061f, -0.01982445f, -0.21608956f, 0.14565578f, 0.04340290f, 0.11374062f, -0.13658604f, 
    -0.07113963f, -0.33420348f, 0.31323159f, 0.23811118f, 0.19069239f, -0.11419711f, -0.13118283f, -0.09220894f, 
    -0.01122934f, -0.07984953f, -0.13381685f, 0.03117686f, 0.06204137f, 0.27648702f, 0.31970865f, 0.13390176f, 
    0.04876101f, 0.24323604f, 0.14041018f, 0.17633978f, 0.03879413f, -0.01085266f, 0.23134612f, 0.15354297f, 
    0.12274557f, 0.04827892f, -0.18807094f, 0.11155913f, 0.10752140f, -0.29051358f, -0.16992368f, 0.02059643f, 
    0.22972326f, 0.40896058f, -0.08489445f, -0.37555408f, -0.60141379f, -0.04447364f, 0.00651775f, 0.08234638f, 
    0.03505499f, 0.01461987f, 0.01504915f, 0.18474716f, -0.00831538f, -0.20013863f, 0.17588605f, -0.22674154f, 
    0.04976177f, 0.04621378f, 0.36191431f, 0.23784111f, 0.13331792f, 0.02215768f, 0.11041906f, -0.49601868f, 
    -0.00053852f, 0.01236962f, 0.02142249f, -0.07646263f, -0.33777696f, -0.23275757f, -0.35218576f, 0.13984834f, 
    0.05099485f, 0.01714121f, -0.05382340f, -0.26437637f, 0.05165976f, 0.02011017f, -0.03475253f, 0.12855425f, 
    0.10808980f, 0.31676021f, 0.37656143f, 0.07086631f, 0.15796924f, 0.01530924f, 0.20774549f, 0.08123549f, 
    0.04049104f, 0.21633376f, -0.67138451f, -0.23728238f, 0.29827052f, -0.16573916f, -0.10894947f, -0.08559829f, 
    -0.03721528f, 0.24083886f, -0.21192007f, 0.13658217f, 0.26822019f, 0.58313262f, 0.13722007f, 0.20136374f, 
    0.14096336f, 0.23436795f, 0.38147637f, 0.47701871f, 0.29624131f, 0.10231902f, 0.17428845f, -0.00546977f, 
    -0.04043379f, 0.12882850f, 0.06520438f, -0.11595546f, -0.31709680f, -0.06653588f, -0.16618301f, 0.13140230f, 
    -0.10875785f, 0.19722264f, -0.05301416f, -0.21039565f, 0.22884004f, 0.27069759f, -0.08744009f, -0.21255243f, 
    0.03317080f, -0.18513712f, -0.29222959f, 0.00293578f, -0.49705440f, -0.20056374f, -0.03805740f, 0.05476964f, 
    -0.09362142f, -0.17345834f, -0.16804706f, -0.09485880f, -0.09193993f, -0.05546071f, 0.24828546f, 0.03839963f, 
    -0.01109525f, 0.16165450f, -0.07531996f, -0.23378335f, -0.02087004f, -0.23386845f, 0.12436304f, 0.09816337f, 
    0.15928450f, -0.19015603f, 0.31356677f, -0.01411205f, -0.02745246f, 0.11931215f, -0.02752519f, -0.16578773f, 
    -0.28433257f, -0.08966961f, -0.61037832f, -0.17998590f, -0.49568123f, -0.00184249f, 0.05292186f, 0.19514132f, 
    0.08585247f, 0.36726296f, 0.40096259f, 0.01780413f, -0.21390192f, 0.07124161f, 0.21252802f, 0.22873658f, 
    0.04602909f, -0.00160586f, 0.25558087f, 0.03959486f, 0.02524394f, -0.18660890f, 0.35219342f, 0.16518785f, 
    -0.07896014f, 0.23081321f, -0.27929074f, -0.36689070f, -0.00323130f, 0.14409809f, -0.16974746f, 0.17897061f, 
    -0.07066627f, 0.26303557f, 0.08602600f, 0.05844536f, 0.00217438f, 0.05382049f, -0.18662564f, -0.19564086f, 
    0.38881806f, -0.21482135f, 0.34765592f, 0.05943312f, -0.02300354f, -0.00685080f, 0.29999506f, -0.02563498f, 
    0.15131342f, 0.20002383f, 0.13666387f, -0.03611863f, -0.04818543f, -0.20012167f, -0.18658139f, -0.51859844f, 
    0.06709845f, -0.06192178f, 0.19159065f, 0.38961491f, 0.22737464f, 0.00174935f, -0.00270658f, 0.08079914f, 
    0.09260103f, -0.08120581f, 0.30293155f, 0.15817426f, -0.03596301f, 0.14369130f, 0.15385056f, 0.09869490f, 
    -0.06762670f, 0.15533353f, 0.68535048f, 1.04858041f, -0.20813139f, -0.25653648f, -0.28361267f, 0.15591681f, 
    0.17074165f, 0.21531413f, -0.02785023f, -0.03721826f, 0.12519863f, -0.20007733f, -0.02321562f, -0.35848653f, 
    -0.11723310f, -0.00391771f, -0.20055945f, -0.15100886f, -0.08009217f, 0.17941940f, 0.35089904f, 0.04807466f, 
    -0.16332936f, 0.33267644f, 0.24236165f, 0.11088202f, 0.31372669f, 0.11295533f, -0.15176547f, -0.03346566f, 
    0.11684164f, 0.14495043f, 0.11902601f, -0.39627412f, -0.04676139f, -0.45062006f, 0.44690713f, 0.16391644f, 
    -0.13429697f, 0.21422976f, 0.19191313f, 0.16373010f, 0.26415944f, 0.11039096f, 0.09186855f, 0.14217782f, 
    -0.54971015f, 0.07915120f, 0.05084256f, 0.10436217f, -0.00438154f, 0.09826008f, 0.02093711f, -0.13734475f, 
    -0.10828026f, -0.28600240f, 0.06622434f, 0.03352825f, 0.00764584f, 0.26329711f, 0.15338305f, -0.04606367f, 
    -0.04436358f, -0.04752732f, -0.46683490f, -0.24421039f, -0.04744310f, 0.26762503f, 0.25231388f, 0.20277694f, 
    -0.03842697f, 0.10318553f, -0.11384513f, 0.21524133f, -0.10939758f, 0.37686533f, -0.01112293f, -0.16221403f, 
    -0.15195218f, -0.26397482f, -0.24634217f, -0.27907008f, -0.05601628f, 0.02637893f, 0.13175973f, 0.17637530f, 
    0.06772278f, -0.39217710f, -0.26800767f, -0.45614487f, -0.14238425f, 0.17608389f, -0.26139438f, 0.15218385f, 
    0.19402923f, 0.12374476f, 0.20109504f, -0.03957130f, -0.00507483f, 0.38545287f, -0.15490542f, -0.33442932f, 
    -0.08566234f, -0.11701924f, 0.19659825f, -0.14652048f, 0.17304178f, 0.12748036f, -0.15898401f, 0.38671106f, 
    0.31963548f, 0.05919183f, 0.00936587f, -0.06414338f, 0.28463626f, -0.15441233f, -0.20890215f, -0.14190514f, 
    -0.28988364f, 0.14896826f, 0.14042445f, 0.35077199f, 0.23828882f, 0.03398932f, 0.38141978f, 0.07540199f, 
    0.57444406f, 0.34030107f, -0.04657457f, -0.06610788f, -0.04899961f, -0.30265322f, 0.06254391f, 0.04369721f, 
    -0.12133586f, 0.36925149f, 0.11256377f, -0.21259953f, 0.04082545f, -0.29446790f, -0.35029870f, 0.00461908f, 
    -0.12975542f, 0.01914919f, -0.63501942f, -0.09513446f, -0.15645690f, -0.06291608f, -0.05416619f, -0.09429662f, 
    0.16430983f, 0.12675482f, -0.08058405f, -0.27684033f, 0.17377625f, -0.77649850f, -0.25401792f, 0.44824612f, 
    0.15842046f, -0.12624635f, 0.22911869f, -0.17821752f, 0.43643701f, 0.35758403f, -0.15722699f, 0.11851557f, 
    0.06671263f, -0.15386882f, 0.07274650f, 0.02369699f, -0.05141696f, -0.02609734f, 0.13334674f, 0.20333594f, 
    0.02225373f, -0.10513785f, 0.12127791f, 0.12121610f, -0.20383659f, -0.05532118f, 0.22861254f, 0.15918379f, 
    0.33328238f, -0.02595714f, -0.11233423f, 0.01999679f, 0.10370837f, -0.00517928f, 0.15726353f, 0.08126085f, 
    0.01253169f, -0.21388613f, -0.08958071f, 0.32766297f, -0.28657842f, 0.03119216f, 0.19912523f, 0.09746057f, 
    0.50273114f, -0.08180907f, 0.42862126f, 0.04141151f, 0.17754649f, 0.40986517f, -0.26114678f, 0.02521334f, 
    0.20280328f, -0.09376787f, -0.07150747f, -0.00096284f, 0.00432937f, 0.07471300f, -0.09257576f, 0.17002201f, 
    -0.00499540f, -0.34445420f, -0.05400500f, 0.05510372f, -0.25923824f, -0.12690450f, -0.30464461f, 0.27730134f, 
    -0.16522735f, 0.02524423f, 0.12673244f, 0.05996512f, 0.01140036f, 0.10556466f, -0.14686747f, -0.14117254f, 
    -0.11526547f, -0.07663110f, -0.24793234f, -0.20961985f, 0.30001575f, 0.46601480f, 0.21791142f, -0.14744517f, 
    0.04694441f, -0.25015762f, 0.07907292f, 0.01662274f, 0.10196027f, 0.40166542f, 0.20130922f, 0.48448554f, 
    -0.07822162f, 0.00868044f, 0.04904185f, 0.16216664f, 0.27986261f, -0.03836342f, -0.23410663f, -0.20344704f, 
    -0.33920175f, -0.04815921f, -0.20519018f, 0.04998156f, -0.23766106f, -0.15653609f, 0.15717745f, -0.19494671f, 
    0.09600205f, 0.11940505f, 0.08648784f, 0.10167424f, -0.26485506f, 0.02141609f, 0.13631739f, -0.10851119f, 
    -0.07242581f, 0.16496621f, 0.67295134f, -0.19761041f, -0.00650669f, -0.22780184f, 0.05006376f, 0.14453384f, 
    0.09970737f, 0.08052219f, -0.19903170f, -0.18991955f, 0.02053185f, 0.07015052f, -0.01324080f, 0.01956850f, 
    -0.08728940f, 0.01808937f, -0.23517670f, -0.76654673f, -0.53771776f, -0.01335141f, 0.26226559f, 0.04498369f, 
    -0.19619940f, -0.12368503f, -0.12981251f, 0.11158588f, 0.04008301f, -0.15852655f, 0.30251426f, 0.19505666f, 
    0.13620755f, 0.38702697f, 0.27638930f, -0.06436197f, 0.54885095f, -0.48544365f, -0.31337410f, 0.01497713f, 
    0.07311244f, 0.10716708f, -0.05868008f, 0.13533609f, 0.22348055f, 0.14625627f, -0.10900511f, -0.14019446f, 
    0.01907149f, 0.01056250f, 0.04952095f, -0.09465556f, 0.16102584f, 0.05632461f, 0.04413339f, 0.07918229f, 
    -0.10922800f, 0.07063878f, -0.00482845f, -0.17247166f, -0.06713224f, -0.11833382f, 0.30192801f, -0.96242100f, 
    0.30358803f, 0.37726510f, 0.05729797f, 0.24598803f, -0.11755773f, -0.17253730f, 0.11313129f, -0.12751898f, 
    -0.60640860f, -0.15833509f, -0.28039074f, -0.10632453f, -0.24171588f, -0.35958564f, -0.04529542f, -0.03285352f, 
    -0.01931809f, 0.01992286f, -0.21727474f, 0.07481831f, 0.09565265f, 0.03889437f, 0.15694869f, 0.04334738f, 
    0.07914696f, 0.31191924f, -0.31474352f, -0.29039618f, -1.35208058f, -0.09289759f, -0.01535211f, 0.00998719f, 
    0.04960582f, 0.04874483f, -0.12520245f, -0.12724563f, 0.34779155f, -0.09746979f, 0.18828352f, 0.02394495f, 
    -0.02997545f, 0.05015679f, 0.17091432f, 0.21179947f, -0.04530539f, 0.05002313f, 0.07882498f, 0.13273339f, 
    -0.20288013f, 0.11287481f, 0.25487521f, 0.01026671f, 0.41946533f, -0.49634331f, -0.57203752f, 0.03352571f, 
    -0.01692649f, 0.08598904f, 0.08161387f, 0.33030525f, 0.00628955f, 0.03031052f, 0.90196639f, 0.03896146f, 
    -0.61370808f, 0.14031796f, -0.04999505f, 0.28915524f, -0.01956122f, -0.05773348f, 0.00797214f, 0.04261834f, 
    -0.16367161f, 0.02140045f, 0.10450046f, -0.00370680f, -0.09446628f, 0.17076796f, 0.01708128f, 0.25027457f, 
    0.40883127f, -1.00226808f, -0.55387318f, -0.26552966f, 0.36714095f, 0.10316785f, 0.02215831f, -0.19574022f, 
    -0.12520193f, 0.21113154f, -0.57289004f, -0.06975731f, -0.04711403f, 0.55538327f, 0.47266659f, 0.05293469f, 
    0.01923247f, -0.16469532f, 0.65585929f, -0.01785263f, 0.22493178f, -0.02294289f, -0.07487674f, -0.20596187f, 
    0.06781635f, 0.17262810f, 0.13520156f, 0.02760146f, -0.21581604f, 0.31460217f, -0.00134691f, 0.20406169f, 
    0.05746809f, 0.19653474f, 0.34747401f, 0.10257499f, -0.05250188f, 0.22141959f, -0.06392158f, 0.13875131f, 
    0.02799735f, 0.48443878f, 0.32530364f, 0.06252724f, 0.12890665f, 0.26367372f, 0.27001432f, -0.02597856f, 
    -0.13878921f, 0.01806007f, -0.07087513f, -0.01609907f, 0.18528961f, -0.07076451f, 0.21893995f, 0.43650255f, 
    -0.04967397f, 0.00640073f, -0.14409439f, -0.16052277f, 0.23870866f, -0.11685970f, 0.09918812f, -0.62361550f, 
    -1.00960958f, -0.62402719f, -0.06335710f, 0.20415577f, 0.33573553f, -0.05557600f, -0.23444644f, -0.07626332f, 
    -0.55266207f, 0.37729445f, -0.50496471f, -0.04111802f, -0.12230776f, -0.22151053f, -0.00060572f, -0.00071913f, 
    0.08684334f, 0.22975153f, -1.05716228f, -1.00474834f, -0.09549901f, -0.26029024f, 0.24118552f, 0.16141826f, 
    -0.07782456f, -0.07488995f, -0.45402977f, 0.44535464f, 0.85354811f, -0.05893289f, -0.13165225f, -0.00981519f, 
    -0.02450659f, 0.18355398f, 0.22364256f, 0.09810589f, -0.35579109f, -0.01424556f, 0.03502201f, 0.13718607f, 
    -0.02417909f, 0.16417718f, -0.06483573f, 0.11209708f, 0.03728309f, 0.28395897f, -0.24541168f, -0.08929911f, 
    0.20091225f, -0.43187010f, 0.04024182f, 0.09807020f, 0.09262834f, 0.22833769f, 0.33041224f, 0.05456457f, 
    0.22034946f, 0.04303695f, 0.20179062f, 0.09295524f, -0.10047133f, -0.04984874f, -0.22862218f, 0.07651047f, 
    -0.06658474f, -0.42609403f, 0.50505590f, -0.19994755f, 0.07300658f, 0.12243561f, -0.03132584f, -0.85606712f, 
    -0.62147498f, -0.44380102f, -0.32274994f, 0.06334986f, 0.06801420f, 0.17426068f, -0.16122705f, 0.16027471f, 
    0.07390874f, 0.05663873f, -0.08913378f, 0.06286170f, -0.08991314f, -0.04295327f, -0.09209330f, -0.03292403f, 
    -0.00520168f, 0.05859009f, -0.08144741f, -0.05362021f, -0.03026110f, -0.01390569f, -0.07091110f, 0.04577802f, 
    -0.00061606f, 0.03391265f, -0.01241346f, -0.09137317f, 0.01995488f, 0.04820744f, -0.06322353f, -0.00025918f, 
    0.02156883f, -0.01323841f, 0.00027062f, 0.01259572f, -0.03738631f, 0.00031904f, -0.00494127f, -0.00952247f, 
    -0.00869897f, -0.02891754f, 0.07314648f, 0.04417514f, -0.06395844f, -0.02391792f, -0.06252657f, 0.00326062f, 
    -0.07816338f, 0.01616593f, 0.03926379f, -0.03934320f, -0.02491041f, -0.05397707f, -0.00428389f, 0.01240828f, 
    -0.07318139f, 0.04697110f, -0.07144000f, 0.01932992f, -0.03794176f, -0.03789403f, -0.01346404f, -0.08473570f, 
    -0.04435772f, 0.04259859f, -0.06077148f, -0.00359471f, -0.02461378f, -0.08105380f, 0.04879104f, 0.06488039f, 
    -0.01014606f, 0.00527613f, -0.01231478f, -0.05424879f, -0.08671986f, -0.03557280f, -0.03526523f, -0.04398450f, 
    0.05124449f, 0.06114711f, -0.07936356f, -0.01419976f, -0.01011296f, -0.02165512f, 0.05447128f, 0.01576808f, 
    0.00377598f, -0.09238894f, 0.02823895f, -0.08803426f, -0.08195153f, -0.07236976f, 0.05509974f, -0.06619053f, 
    0.02113178f, -0.01727029f, 0.01343626f, -0.08724454f, 0.02732908f, -0.06379514f, -0.08575248f, 0.04592564f, 
    -0.08563976f, -0.07327721f, -0.00426849f, 0.02283072f, 0.00186231f, 0.01554439f, 0.06940690f, 0.05156623f, 
    0.02322376f, -0.03005116f, 0.04195484f, -0.03581663f, -0.03512582f, 0.04084062f, -0.07626110f, 0.07445566f, 
    -0.04693105f, -0.06150345f, -0.04645507f, -0.03539623f, -0.04567529f, 0.00921309f, 0.07374761f, -0.08249737f, 
    0.06642101f, -0.01554862f, -0.03892487f, -0.09058921f, 0.00591375f, -0.05606070f, -0.00703997f, -0.07079993f, 
    -0.08183590f, -0.05678907f, 0.05884634f, 0.07157958f, -0.04059412f, 0.02013876f, -0.06238578f, -0.04239924f, 
    0.06885844f, 0.01861167f, 0.03998441f, 0.04490792f, -0.04334352f, -0.00152060f, -0.00945543f, 0.05608704f, 
    0.48229620f, 0.24938314f, 0.14394809f, -0.27167991f, -0.21093498f, 0.02437541f, 0.18301120f, 0.20158991f, 
    -0.06186134f, 0.10072064f, -0.28504613f, 0.27716219f, -0.01153907f, 0.02188599f, 0.48299909f, -0.00187578f, 
    -0.09817140f, 0.10764428f, -0.23261131f, 0.25922886f, -0.12612975f, -0.10091791f, -0.08811370f, -0.28498334f, 
    0.16542278f, -0.03923120f, 0.06610814f, -0.32439125f, 0.27172479f, 0.73013264f, 0.12953514f, 0.09106161f, 
    -0.33654079f, 0.13615905f, 0.19507954f, 0.08005813f, -0.19566050f, 0.25476679f, -0.06032308f, -0.48255160f, 
    -0.01891168f, 0.07521196f, 0.10186676f, 0.13052395f, -0.12291376f, 0.27307451f, -0.20872279f, 0.02596667f, 
    0.10876761f, 0.22153658f, -0.02955708f, 0.10382446f, 0.05997214f, -0.07930661f, 0.13519512f, 0.11648426f, 
    0.50452256f, -0.25929186f, -0.09469639f, -0.44865596f, -0.08370812f, 0.32801268f, 0.10212786f, -0.44126821f, 
    -0.14995901f, -0.07276633f, -0.26283836f, 0.30501419f, -0.16688956f, 0.07873391f, 0.04345540f, -0.26862502f, 
    -0.04802836f, 0.13401085f, 0.45763519f, -0.15601696f, 0.16086155f, -0.33982095f, 0.01603638f, -0.13038421f, 
    0.03595003f, -0.24010442f, 0.22217254f, -0.50294602f, 0.06398737f, -0.20654273f, -0.10789738f, -0.00459956f, 
    0.07828392f, 0.37010762f, -0.51890349f, -0.33559215f, -0.10022596f, -0.23012927f, 0.11289322f, -0.29649112f, 
    0.11475024f, 0.18779427f, 0.16048609f, -0.10784245f, 0.14733912f, -0.59698594f, 0.21733074f, -0.13967238f, 
    0.31314245f, 0.08088115f, 0.14253888f, -0.05122118f, -0.25508016f, 0.42328334f, 0.91849363f, -0.11981827f, 
    -0.29616591f, 0.02374079f, -0.29510596f, 0.02383080f, 0.13074216f, -0.16567194f, 0.50277936f, 0.06740422f, 
    -0.00678853f, -0.13502097f, -0.12319648f, 0.29736304f, -0.06315646f, -0.01118051f, 0.22262511f, 0.08267207f, 
    0.44445667f, 0.11140466f, 0.22340269f, 0.42460451f, 0.12502794f, 0.03686793f, 0.06571721f, 0.45670801f, 
    -0.47896171f, -0.34935418f, 0.01962863f, 0.10675396f, -0.20268430f, -0.25491866f, -0.04453688f, 0.02031679f, 
    -0.64642787f, -0.44864589f, -0.33792269f, 0.25801617f, -0.03843410f, -0.17647798f, 0.07712904f, 0.02695918f, 
    -0.03175508f, -0.62716317f, 0.21290800f, 0.80395323f, 0.55166620f, -0.07633893f, -0.10196207f, -0.04391994f, 
    0.08606178f, -0.06707309f, -0.44334480f, -0.48049769f, -0.11515191f, 0.11697711f, -0.12397748f, 0.05744379f, 
    -0.14804642f, 0.20049191f, -0.13837963f, -0.09150215f, -0.50467712f, 0.15711395f, 0.09104593f, 0.17776516f, 
    -0.02634510f, -0.09131426f, 0.01959794f, -0.09602552f, -0.39891911f, 0.11561095f, 0.02188985f, 0.19350515f, 
    0.12723035f, 0.22115010f, -0.18497463f, 0.17827688f, -0.01184922f, 0.07794727f, -0.07999064f, 0.13269521f, 
    0.00267227f, 0.03671085f, 0.09191423f, -0.41605586f, -0.24803419f, -0.30027178f, -0.03929029f, -0.18849367f, 
    -0.09002690f, -0.06984736f, 0.00876925f, -0.11544051f, 0.29778984f, 0.09073675f, 0.08830524f, -0.35299635f, 
    0.74403250f, 0.36485553f, 0.04466707f, 0.23306918f, -0.25351039f, 0.03679515f, 0.03323031f, 0.11934871f, 
    -0.39869699f, -0.42455301f, -0.13740551f, -0.28985274f, -0.00371782f, -0.69281965f, 0.02472974f, -0.36228427f, 
    -0.00590044f, -0.36544231f, 0.32614323f, 0.51437467f, -0.07042455f, -0.13808076f, -0.02263674f, 0.03869921f, 
    0.22201985f, 0.32665470f, -0.18654732f, -0.91819930f, -0.71002632f, -0.32359940f, -0.24799991f, -0.10328816f, 
    0.00201782f, -0.29146838f, -0.18814594f, -0.03570247f, 0.14723217f, 0.16216882f, -0.02757774f, 0.25262257f, 
    0.07464399f, -0.25877830f, 0.01696126f, -0.17472456f, -0.23499930f, -0.37340155f, 0.20602968f, 0.08124204f, 
    0.15295894f, 0.01974815f, 0.25177836f, 0.08058228f, 0.46210179f, -0.39848167f, -0.00474216f, 0.06104399f, 
    0.02758989f, 0.21978639f, 0.27528787f, -0.15422785f, 0.44494060f, 0.10727183f, 0.57758641f, -0.08933508f, 
    -0.00807541f, 0.10382580f, 0.05497302f, 0.20562635f, 0.15264446f, 0.03688731f, -0.20909026f, -0.29843628f, 
    0.14812274f, 0.04623576f, -0.05898394f, 0.08840162f, -0.00248450f, 0.16865931f, 0.21404508f, 0.35613164f, 
    -0.04181088f, 0.33734983f, 0.44950169f, -0.10968558f, -0.03804348f, -0.29561919f, 0.03708242f, -0.00039749f, 
    -0.00515762f, -0.22248864f, 0.27681735f, 0.86705887f, 0.17220558f, -0.01986418f, -0.13539450f, -0.10821607f, 
    0.00480825f, 0.10232691f, 0.07720719f, -1.50146532f, -0.19142482f, -0.15233125f, 0.19649743f, -0.12027266f, 
    -0.18956907f, -0.15528011f, -0.04843404f, -0.54038453f, -0.06223052f, 0.39189312f, -0.12410507f, -0.03416743f, 
    -0.04432379f, 0.15853028f, 0.03509180f, 0.11911220f, -0.14509983f, 0.07825048f, -0.02608718f, 0.09150535f, 
    0.15010045f, 0.06826357f, 0.22502854f, 0.03533362f, -0.12512429f, -0.03366531f, -0.21355583f, 0.32914254f, 
    -0.06025387f, 0.05686679f, 0.21070397f, 0.15164125f, 0.15148373f, 0.52794391f, -0.20662890f, -0.26268378f, 
    0.11930441f, -0.17117938f, -0.05977272f, -0.00599936f, -0.00366357f, 0.06312545f, -0.13526556f, 0.44800892f, 
    -0.02865390f, -0.05351036f, 0.10761305f, -0.09317025f, -0.17666920f, -0.05652653f, 0.15194479f, 0.04637990f, 
    0.28894785f, 0.33068970f, 0.06153991f, 0.04413477f, 0.16848572f, -0.01012369f, -0.00170704f, -0.05786420f, 
    0.11002609f, 0.10482415f, -0.05921295f, 0.31881428f, -0.05915228f, 0.07797509f, -0.05223022f, -0.01115318f, 
    0.01691000f, 0.18973596f, -0.05803549f, 0.07830024f, 0.27823702f, -0.25942323f, -0.11237674f, -0.05308834f, 
    -0.00855744f, 0.09465650f, 0.10583295f, -0.24007273f, -0.47913274f, 0.50463027f, -0.03139007f, -0.01098482f, 
    -0.34383482f, 0.25621897f, -0.05982975f, 0.22306044f, -0.38171318f, -0.57838267f, 0.54400307f, -0.23550653f, 
    -0.32133213f, -0.42067409f, -0.05315245f, -0.15659703f, 0.14179777f, -0.03623959f, -0.92860544f, 0.37086475f, 
    -0.28435284f, -0.19602513f, -0.20231643f, 0.05671833f, 0.03183418f, 0.12408914f, -0.01060426f, -0.71581560f, 
    -1.62212157f, 0.08050808f, 0.09123743f, 0.39087504f, -0.13623081f, 0.02678050f, 0.13899456f, -0.07772107f, 
    -0.38240698f, 0.02343055f, -0.00138116f, -0.07455973f, -0.00578037f, 0.22343615f, 0.16183463f, -0.12248303f, 
    0.05748989f, -0.07755762f, 0.05238482f, -0.07616536f, 0.01610707f, -0.07778715f, -0.03200606f, -0.03000157f, 
    -0.07122751f, -0.08357491f, -0.08575604f, 0.00299285f, -0.06657814f, -0.06825817f, -0.06935164f, -0.04551716f, 
    0.07301693f, -0.07346347f, -0.04521725f, -0.07180186f, 0.00504594f, 0.03118302f, 0.04646146f, -0.04374954f, 
    -0.05885777f, 0.02923692f, -0.02970179f, 0.05105028f, -0.04437742f, 0.00091083f, -0.05459242f, 0.03612571f, 
    0.00689345f, -0.02757239f, -0.00999874f, -0.02568519f, -0.05559843f, 0.01582396f, -0.01937602f, -0.06166223f, 
    0.02991869f, -0.01996166f, 0.03421304f, -0.06687652f, 0.01616214f, -0.08491080f, 0.03105837f, -0.02272597f, 
    -0.02808964f, -0.06495080f, -0.00446563f, -0.05773928f, -0.05278271f, 0.00819570f, 0.05372863f, 0.00907950f, 
    -0.07928806f, -0.03196082f, 0.03289176f, 0.07206278f, -0.03407290f, 0.05731187f, 0.05294923f, -0.04009758f, 
    -0.08793031f, 0.00267594f, -0.07659167f, -0.04653881f, 0.00895933f, 0.02056977f, -0.08262237f, 0.07054771f, 
    0.01877275f, 0.05572581f, -0.04881368f, -0.05788122f, 0.03610544f, 0.02165652f, -0.01753152f, -0.04746395f, 
    -0.06670202f, -0.07052360f, 0.00696126f, 0.01362449f, 0.06630218f, -0.07349203f, -0.08728407f, -0.05290651f, 
    -0.04938280f, -0.05968089f, -0.02859117f, 0.00586594f, 0.04779124f, 0.01106437f, 0.00394048f, 0.04002620f, 
    -0.06791829f, -0.05972855f, -0.02130391f, 0.02627920f, 0.07445966f, -0.08698957f, 0.03276047f, -0.06667203f, 
    0.03237645f, 0.07319482f, -0.04100906f, -0.01363211f, 0.01784828f, -0.04760035f, 0.02357794f, 0.00156090f, 
    -0.04981627f, -0.02767655f, -0.01342656f, 0.00680400f, -0.08718221f, 0.04088468f, 0.04163585f, -0.02063565f, 
    -0.03152008f, 0.01168780f, 0.05783429f, -0.01533784f, -0.06759101f, -0.04280024f, -0.07359646f, -0.08012575f, 
    -0.07283422f, -0.04288745f, -0.04170967f, 0.01498763f, 0.04095213f, -0.03704041f, 0.05858569f, 0.03277497f, 
    0.05370302f, 0.04715637f, -0.00543522f, 0.07319267f, -0.06601092f, -0.01781034f, 0.05833738f, 0.00712333f, 
    -0.75176376f, -0.32212958f, 0.04031158f, -0.05804919f, -0.21354441f, -0.16288048f, -0.04227796f, -0.01747196f, 
    -0.10564585f, -0.07602474f, -0.11212551f, 0.33266488f, -0.08911520f, -0.04788579f, 0.00652376f, -0.01549477f, 
    -0.08990350f, 0.29355881f, -0.48719004f, -0.27126229f, -0.38668448f, 0.02250197f, -0.10477319f, -0.17120974f, 
    -0.45564932f, -0.25041822f, 0.21842538f, 0.56846505f, -0.20331222f, -0.17737643f, 0.25990281f, -0.03305873f, 
    0.18185709f, 0.10581554f, 0.20121387f, 0.45099205f, -0.26892111f, 0.27445146f, 0.31159016f, 0.16195418f, 
    0.02032521f, 0.08574542f, 0.19988132f, 0.20102148f, 0.09683361f, -0.42062575f, -0.42982313f, -0.76480985f, 
    -0.23231353f, -0.38748595f, -0.15180536f, 0.31499717f, 0.02113518f, 0.12589563f, -0.15719795f, 0.06048843f, 
    -0.09702527f, 0.09011340f, -0.11954261f, -0.31284720f, 0.28855711f, -0.04088793f, 0.44762784f, -0.76061392f, 
    0.42298537f, 0.67936945f, 0.18282926f, -0.01285893f, 0.05144413f, -0.05776225f, -0.05311214f, 0.12099358f, 
    -0.58741695f, -0.26852509f, 0.26805249f, 0.02160173f, -0.11053610f, -0.32578146f, -0.09669464f, -0.10123974f, 
    -0.23250999f, -0.47046661f, 0.57423270f, 0.55533201f, 0.11616356f, 0.10346729f, 0.08033256f, 0.19039270f, 
    0.06075713f, 0.20064420f, 0.21780324f, -0.53224993f, 0.32547271f, -0.21212405f, -0.10890687f, -0.37442127f, 
    -0.00635505f, -0.06904898f, -0.13178618f, 0.06089469f, 0.21706347f, 0.35115436f, -0.09296813f, 0.10420384f, 
    -0.02431445f, 0.23996745f, 0.46598393f, 0.24219483f, -0.46459109f, -0.53781265f, -0.40229207f, 0.19867763f, 
    -0.26257357f, -0.33129677f, -0.11132343f, -0.08781379f, 0.15272084f, -0.57151461f, 0.02281741f, -0.01297238f, 
    -0.18841088f, -0.12067322f, -0.18833582f, 0.09604409f, 0.41055259f, 0.06445541f, 0.64871633f, -0.31457371f, 
    -0.15264700f, -0.04763399f, -0.43590716f, -0.16877784f, -0.03573094f, 0.05820753f, 0.22303112f, -0.16627949f, 
    0.42328852f, 0.61866629f, -0.09495069f, -0.02489718f, 0.06693141f, 0.27977467f, 0.23742153f, 0.24726062f, 
    0.03663880f, 0.05054712f, -0.02242986f, 0.03821658f, 0.02855820f, -0.03173922f, -0.04789878f, 0.05110196f, 
    0.06585121f, -0.08101150f, -0.03144790f, -0.03794486f, -0.03666108f, -0.05672085f, 0.07503813f, 0.01810227f, 
    0.03130824f, -0.08788341f, 0.00024209f, 0.01533322f, 0.00193379f, -0.04782010f, -0.05385489f, 0.05916308f, 
    -0.01111429f, -0.04408388f, -0.07455411f, 0.01358540f, 0.06286062f, -0.04155492f, 0.00894745f, -0.08782727f, 
    -0.01592848f, -0.06190612f, 0.01659033f, -0.06104252f, -0.02484017f, -0.02594653f, 0.06136337f, -0.04584179f, 
    0.06603162f, -0.04914669f, -0.06044718f, -0.06544285f, 0.04875042f, 0.02667504f, -0.08015209f, 0.00375630f, 
    -0.03980873f, 0.07120496f, 0.01496325f, 0.07291935f, -0.06977606f, 0.03763438f, -0.07298396f, -0.00235717f, 
    0.07458487f, 0.04030713f, -0.00932610f, -0.04777844f, -0.08810189f, -0.02730531f, -0.07378847f, -0.06133590f, 
    -0.06966659f, 0.06625599f, 0.04375183f, -0.07225148f, 0.02151089f, 0.06368386f, -0.03356146f, -0.02421887f, 
    0.04027175f, 0.00919053f, 0.05741602f, 0.03619638f, -0.07011501f, -0.05107630f, 0.03562742f, -0.04083875f, 
    -0.02427209f, 0.05338668f, 0.03278123f, 0.05849857f, -0.04848031f, -0.05828856f, -0.05419319f, -0.08128261f, 
    0.04381969f, 0.02758903f, -0.06318104f, -0.08296999f, -0.04030034f, 0.03320681f, 0.06255317f, 0.01240929f, 
    0.00288154f, -0.01611496f, -0.04604886f, -0.06514262f, 0.06929354f, -0.05720003f, -0.03581220f, 0.03171705f, 
    0.04311642f, -0.06866898f, -0.02369409f, -0.08238403f, 0.07186475f, -0.06318410f, 0.07076682f, -0.02379475f, 
    0.07487645f, 0.04123601f, -0.08790469f, 0.03704455f, -0.03792708f, -0.03818594f, -0.01584337f, 0.02457825f, 
    0.04816039f, -0.04268068f, 0.01431941f, 0.01486157f, -0.08371444f, 0.02241004f, -0.08653925f, 0.00372452f, 
    0.07346174f, 0.01026537f, -0.07857143f, 0.03648983f, -0.01298567f, -0.00040145f, -0.06837765f, 0.05100156f, 
    -0.00220444f, -0.07857916f, -0.08432109f, 0.02571749f, -0.06193694f, 0.00572489f, 0.04887363f, -0.01509663f, 
    0.15894106f, -0.23866247f, 0.00536811f, 0.03347823f, -0.22717468f, 0.10193494f, 0.05870212f, -0.09985213f, 
    0.02782309f, 0.33084238f, -0.05545102f, 0.08585770f, -0.00409046f, 0.05002719f, 0.34376219f, 0.05412071f, 
    0.05273117f, 0.30440554f, -0.53169262f, 0.15537201f, 0.00806949f, -0.19123933f, 0.29897726f, -0.05772568f, 
    0.13805512f, 0.13732542f, 0.12525256f, 0.28200793f, -0.11316522f, 0.19563805f, -0.31417948f, 0.00210162f, 
    -0.00250361f, 0.17487754f, -0.06109648f, 0.16052623f, 0.40511459f, 0.07695910f, -0.10843750f, 0.05988085f, 
    -0.12326736f, 0.10861795f, 0.09531558f, 0.08545732f, -0.45263830f, -0.16579947f, 0.15964270f, 0.00562132f, 
    -0.07863760f, 0.17698784f, -0.12424474f, 0.13388009f, 0.34726825f, 0.02405293f, -0.38873997f, 0.08617175f, 
    0.27280250f, 0.01252646f, 0.11997809f, -0.01737084f, 0.12632851f, -0.00798197f, 0.05448529f, 0.02276655f, 
    -0.51353955f, 0.23589009f, -0.03577111f, 0.01108845f, 0.00594903f, -0.09974674f, -0.06557256f, 0.07501201f, 
    0.22524765f, -0.13113827f, -0.15631579f, -0.03681840f, 0.11134503f, 0.01844775f, 0.11933607f, 0.15857793f, 
    -0.06779742f, 0.71493298f, -0.09623905f, -0.13931076f, 0.14129290f, 0.07436477f, 0.15961756f, -0.11758190f, 
    -0.00488914f, -0.04540268f, 0.44067028f, -0.31534541f, -0.13091755f, -0.33411366f, -0.08527842f, -0.04036530f, 
    0.09992124f, 0.18083815f, 0.10771121f, 0.05243423f, 0.21111734f, 0.01370437f, 0.04044012f, -0.27468610f, 
    0.07327592f, 0.21745816f, 0.20674051f, 0.17960639f, -0.52156585f, -0.24792473f, 0.02569364f, -0.02294634f, 
    -0.36511430f, 0.10387855f, -0.00443900f, -0.00423733f, 0.11773714f, -0.43748289f, -0.20278049f, -0.15012662f, 
    -0.23834363f, -0.23727892f, -0.41494021f, 0.29792842f, 0.12174327f, -0.05994820f, -0.76854527f, 0.12804769f, 
    0.49396989f, -0.17689823f, -0.09970557f, 0.24664922f, -0.01917766f, 0.14465031f, -0.04646148f, 0.25236419f, 
    -0.10428713f, 0.04659522f, 0.04312965f, -0.08190074f, -0.15371899f, 0.01724466f, 0.09864197f, -0.01688468f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.13615577f, -0.21554901f, 0.41814658f, 0.11358663f, -0.02907299f, 0.06060661f, 0.66843903f, 0.22802967f, 
    0.05016780f, 0.14940503f, 0.35610646f, 0.20818061f, -0.07220881f, 0.46473783f, -0.05931190f, -0.23253810f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.56013924f, 0.26488075f, -0.41612864f, -0.02206808f, -0.12204748f, 0.57033932f, -0.41292143f, -0.33735546f, 
    0.13085987f, -0.41070107f, 0.36392725f, 0.40400618f, 0.01313363f, -1.34000540f, -0.00974963f, 0.22124833f, 
    0.47884786f, -0.20150757f, 0.30957994f, 0.18282524f, -0.53846496f, 0.48281389f, 0.14152499f, 0.22504605f, 
    -0.01988871f, 0.17895985f, -0.38152969f, -0.20527944f, -0.06181468f, -0.09559721f, -0.12345339f, -0.36507371f, 
    -0.70675284f, 0.15528513f, -0.03239567f, 0.09534029f, -0.11487423f, 0.37537861f, -0.28738683f, -0.58023280f, 
    0.21012941f, -0.64207053f, 0.55503416f, -0.75957811f, -0.19439085f, 0.95587456f, -0.08123958f, -0.25454062f, 
    0.25492576f, 0.08549374f, -0.57835174f, -0.19738263f, 0.30992392f, 0.06134177f, -0.40773764f, -0.50825000f, 
    -0.22882681f, -0.10983346f, -1.05347645f, -0.62679219f, 0.09891277f, -0.02857490f, 0.14697804f, 0.70522559f, 
    0.22823635f, 0.10104870f, 0.06217799f, -0.38967076f, 0.38151252f, 0.06073825f, -0.84385389f, -0.41050148f, 
    -0.05972087f, 0.11645212f, 0.05666892f, 0.73455775f, -0.13034499f, -0.32214069f, -0.22300810f, -0.46026662f, 
    -0.01131618f, 0.89459300f, 0.16622093f, 0.39632788f, -0.45436639f, -0.51830351f, -0.04156015f, -0.05888486f, 
    0.16107434f, 0.05510659f, -0.43959808f, 0.05741883f, -0.12319948f, 0.07093512f, -0.10525903f, -0.12502596f, 
    -1.29768753f, -0.48593631f, -0.38009158f, -0.42583796f, 0.10415889f, -0.15033473f, 1.10784078f, -0.37928799f, 
    -0.13609199f, -0.21878514f, 0.79021335f, -0.39335188f, -0.17601819f, -0.01904845f, 0.19067344f, -0.62081075f, 
    -0.34557712f, 0.10332640f, -0.34848058f, -0.20956777f, -0.05203332f, -0.06415315f, -0.55600137f, 0.82249480f, 
    0.04227285f, -0.25771338f, -0.20559205f, -0.79289448f, 0.03612649f, -0.18908606f, -0.07448526f, 0.58123553f, 
    -0.19761410f, -0.74876535f, 0.65299469f, 0.61426514f, -0.52955884f, -0.61291265f, 0.31951922f, 0.56840611f, 
    -0.09626524f, -0.30190703f, -0.96479523f, -0.36138818f, 0.09811505f, -0.16774458f, 0.00124791f, 0.31389755f, 
    -0.28528562f, -0.55615544f, -0.02611617f, -0.78949279f, 0.60983473f, -0.25348645f, 0.14646553f, -0.11012370f, 
    0.18608010f, -0.48015130f, 0.30994907f, 0.33292043f, 0.11623048f, 0.09357174f, 0.00476460f, 0.04420829f, 
    -0.79533875f, 0.07551796f, 0.10539859f, 0.63903391f, -0.54559577f, -0.43135634f, 0.06471735f, -0.79188287f, 
    0.07457966f, 0.06793595f, 0.23873451f, 1.01974034f, -0.19563392f, -0.53089738f, 0.18365166f, 0.34520164f, 
    0.04768516f, -0.12773895f, -0.44614473f, 0.08776501f, -0.17971541f, -0.59053546f, -0.03318944f, -0.33044672f, 
    -0.19872019f, 1.00249887f, 0.20577241f, -1.37417650f, -0.22614616f, 0.12353375f, 0.22934696f, 0.02262484f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.76406866f, 0.37578532f, 0.12622987f, -0.12559783f, -0.12607947f, 0.22310641f, -0.31752074f, -0.79097563f, 
    -0.29724348f, 0.11598300f, 0.04456056f, 0.43834475f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
