#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.84623319f, -0.11209639f, -0.15146554f, 0.03151808f, -0.52125239f, -0.01531227f, -0.16523986f, 0.21978778f, 
    -0.18262208f, -0.25722399f, 0.07816556f, 0.55953062f, -0.23653474f, 0.44203588f, -0.01787405f, -0.08115595f, 
    -0.31938007f, 0.01128769f, 0.09018782f, 0.27707216f, 0.51392156f, 0.15960009f, -0.06528728f, 0.31652802f, 
    -0.22788584f, 0.02397996f, 0.18357553f, -0.21486761f, -0.55309510f, -0.65440464f, -0.78925645f, -0.38442478f, 
    -0.80060232f, -0.56478781f, -0.77942008f, 0.51989853f, -0.01943007f, 0.61589402f, 0.02083144f, 0.10734399f, 
    0.12664361f, -0.30207393f, 0.11902966f, 0.14919730f, -0.01154577f, -0.07285665f, 0.13897960f, 0.06327066f, 
    0.07554334f, 0.23761526f, 1.00570905f, 0.98247331f, 0.59713638f, -0.19650766f, -0.37348658f, -0.27716529f, 
    -0.46276879f, 0.09488339f, -0.10234462f, -0.52151257f, -0.04843370f, 0.26152727f, -0.01427339f, -0.25737378f, 
    -0.33905756f, -0.07224985f, 0.17840432f, 0.16738731f, -0.21353593f, 0.11263134f, -0.19610131f, 0.11747967f, 
    -0.07485697f, 0.26681441f, 0.05219767f, 0.42336878f, 0.38473013f, -0.50815094f, -0.36479592f, 0.84188914f, 
    -0.17166063f, -0.28897914f, 0.07180245f, -0.78882545f, -0.86449379f, -0.08726663f, 0.19617592f, 0.15088718f, 
    -0.02045025f, -0.23887263f, 0.22832951f, -0.06122279f, -0.06247658f, 0.13185404f, 0.05421988f, -0.21129869f, 
    -0.08177119f, -0.26190245f, -0.45272189f, -0.31136426f, -0.79602432f, -0.73276174f, -0.31587154f, 0.73155463f, 
    0.83959705f, -0.15906796f, -0.00304691f, -0.31369987f, -0.11462960f, 0.56496757f, -0.49183676f, -0.28891447f, 
    -0.59829205f, 0.07900736f, 0.21537173f, 0.14220434f, -0.13798279f, 0.15795036f, 0.38648918f, 0.22423549f, 
    -0.20182560f, -0.46954325f, -0.30978033f, -0.42354798f, -0.09080879f, -0.28665888f, -0.50467908f, -0.80694348f, 
    -0.73853773f, -0.76170456f, 0.44016314f, -0.13981648f, -0.50499517f, -0.55731356f, 0.39325479f, -0.15288027f, 
    -0.16262984f, 0.11217762f, 0.39517042f, 0.23480704f, -0.43692726f, -0.39891422f, 0.03136151f, -0.19685203f, 
    -0.32243511f, -0.15447785f, -0.23011485f, 0.07456458f, 0.06546120f, -0.23295294f, 0.64181870f, -1.18078661f, 
    0.22608224f, 0.10234033f, 1.03214490f, -0.54317343f, -0.35827500f, -0.58249474f, -0.09039273f, 0.25477254f, 
    -0.22436631f, 0.31906602f, 0.41176349f, -0.18335629f, -0.13248710f, -0.13270639f, 0.19798970f, -0.06326000f, 
    0.25645888f, -0.27090207f, 0.22294837f, -0.24210359f, -0.08154286f, 0.29404664f, 0.27452499f, -1.16692531f, 
    0.16062230f, -0.62180901f, 0.05744634f, 0.56346935f, -0.08256068f, 0.34310713f, 0.64041829f, 0.08627868f, 
    0.28896603f, 0.18020679f, -0.02499706f, 0.23446055f, -0.13215816f, -0.05047164f, 0.16837005f, -0.10997455f, 
    -0.24883264f, -0.13190395f, -0.33840606f, -0.00062181f, -0.22141287f, 0.16724846f, -0.11785550f, -0.20929624f, 
    -1.05762577f, -0.48710778f, -0.41980478f, -0.80029911f, -0.25812227f, 0.46300164f, -0.28433818f, -0.07940582f, 
    0.15516090f, 0.11672305f, -0.41583708f, -0.30495891f, -0.15636285f, -0.13173346f, -0.18221311f, 0.31230611f, 
    0.16217680f, 0.13219921f, 0.20309377f, 0.01933572f, 0.04416507f, 0.50112194f, -0.01811311f, -0.01018550f, 
    -0.15652947f, -0.06688419f, -0.72254461f, -0.47938704f, 0.58993876f, -0.18218701f, -0.61848348f, -0.35523850f, 
    -0.31505299f, -0.31722197f, -0.76849121f, 0.24932210f, -0.64900666f, -0.14498408f, 0.65044415f, -0.33882028f, 
    -0.19580300f, -0.22412935f, 0.23898934f, -0.51839274f, -0.24055785f, -0.29858136f, -0.08517674f, 0.19175667f, 
    -0.29643217f, 0.05276866f, -1.40839064f, 0.46474478f, 0.81451094f, -1.09645593f, -0.46058914f, 0.40817019f, 
    -0.23083583f, -0.22644860f, 0.23286481f, 0.39237404f, -0.13780300f, -0.39755988f, -0.28162423f, -0.58118910f, 
    -0.00868739f, 0.18336083f, -0.01950043f, -0.15407921f, -0.09430207f, -0.04710849f, -0.05329873f, -0.16810176f, 
    0.03940121f, -0.15489997f, -0.14656010f, 0.35586119f, 0.22254924f, 0.44556049f, 0.41347110f, 0.58315146f, 
    0.36678386f, 0.06550860f, 0.13233075f, 0.27558550f, 0.49710861f, 0.19187416f, 0.36990371f, -0.05309908f, 
    -0.25476658f, 0.30294123f, 0.12269857f, -0.11959544f, -0.11338855f, -0.05645479f, -0.44548142f, 0.19850285f, 
    0.09730387f, 0.00122946f, -0.16052446f, 0.04358130f, 0.35290796f, -0.29628304f, 0.02464163f, -0.28048214f, 
    0.59013873f, 0.76665211f, -0.30999264f, -0.54191095f, -0.33331257f, 0.62261057f, -0.17447093f, -0.13980158f, 
    0.21504837f, -0.01808530f, -0.22481531f, 0.16492282f, -0.41159001f, -0.00783480f, 0.19796516f, -0.11421153f, 
    -0.66984928f, 0.35328951f, -0.37504312f, 0.28358674f, 0.00176391f, -0.12257791f, 0.37890482f, -0.17121880f, 
    -0.30324072f, -0.49280772f, -0.10006660f, 0.36370337f, 0.42895505f, 0.51812434f, -0.05055687f, -0.16803265f, 
    -0.03716592f, 0.71178234f, -0.19498733f, -0.34625810f, -0.26963723f, -0.44959623f, -0.05142712f, -0.30803826f, 
    0.38260031f, 0.29968071f, 0.31753311f, 0.16163665f, -0.24462110f, -0.01346071f, -0.46159014f, 0.02965541f, 
    0.48621562f, 0.06807793f, -0.35140356f, -0.18271990f, -0.17838813f, -0.00195027f, -0.06154098f, 0.26476222f, 
    0.02419542f, -0.00314876f, -0.04683139f, -0.07907914f, 0.33739054f, -0.07033794f, 0.01859090f, -0.28869554f, 
    -0.40024462f, -0.06893416f, 0.34479761f, 0.49407488f, 0.21133722f, 0.38775975f, 0.51423436f, -1.23705304f, 
    0.58901209f, -0.83696687f, -0.42355630f, -0.75236326f, -0.05538548f, 0.20910865f, 0.32005665f, 0.42543331f, 
    0.55455309f, -0.09064180f, -0.03881690f, 0.23378152f, 0.30218777f, 0.21141928f, -0.01888451f, 0.04251543f, 
    -0.10629377f, 0.19341388f, 0.11228829f, -0.18734677f, 0.24836630f, 0.12225046f, -0.24934922f, 0.06106131f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21099359f, 0.03218208f, 0.38806862f, -0.02147051f, 0.17405729f, -0.03386562f, 0.16291231f, 0.14808492f, 
    -0.36900225f, 0.44812870f, 0.22882207f, -0.21866418f, 0.30971709f, 0.45131674f, 0.32432088f, 0.37519014f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13378084f, -0.13425574f, 0.21374239f, 0.08957891f, 0.04305772f, 0.17696850f, 0.02036783f, 0.23435391f, 
    -0.06186885f, -0.00293170f, -0.07772881f, -0.05247596f, 0.60586965f, 0.24893972f, 0.52176923f, 0.38374549f, 
    -0.10991301f, 0.12665574f, -0.20427038f, 0.36571658f, 0.02181345f, 0.01499309f, 0.00195407f, 0.07044261f, 
    0.52691364f, 0.09531518f, 0.25773472f, 0.17742880f, -0.20021491f, -0.19684418f, -0.09557504f, -0.01427086f, 
    -0.01643785f, 0.02263115f, -0.08932149f, 0.04122915f, 0.25035337f, 0.18276922f, 0.03632347f, -0.06121459f, 
    -0.20808199f, 0.31255463f, -0.44182849f, 0.28109848f, -0.12769821f, 0.03806956f, -0.05071593f, 0.04908057f, 
    -0.09385302f, 0.43189922f, -0.20410982f, -0.05263007f, -0.01208893f, 0.03442395f, 0.14630286f, -0.19878982f, 
    0.27854601f, 0.05523697f, -0.04117206f, 0.04593809f, 0.25880104f, 0.13485532f, -0.17957504f, 0.17429614f, 
    0.07056564f, -0.04621490f, 0.18582630f, 0.02268434f, 0.01689478f, -0.08707698f, -0.02162042f, 0.02441818f, 
    0.31516993f, 0.42429104f, -0.02988008f, -0.00924977f, 0.09718227f, -0.09733196f, -0.09183932f, 0.12429021f, 
    -0.07047879f, -0.05072558f, 0.01300475f, 0.02539854f, -0.39663899f, -0.25226128f, -0.31283107f, -0.17380595f, 
    -0.02424236f, -0.01273664f, 0.00083801f, 0.04036750f, -0.08162934f, -0.11969952f, 0.06048742f, 0.11587044f, 
    0.57158548f, 0.18888192f, 0.26630861f, -0.01662445f, -0.20639366f, 0.08586394f, 0.00604785f, -0.04137492f, 
    -0.12115338f, 0.03339629f, 0.09818762f, 0.00008507f, 0.20112538f, 0.00280459f, 0.14606297f, 0.09593679f, 
    0.05111680f, -0.20819274f, 0.18434732f, 0.10536332f, 0.09037352f, -0.07856286f, 0.02616414f, -0.09056436f, 
    0.41326630f, 0.14713629f, -0.17957534f, -0.50107580f, 0.09318525f, -0.17470522f, 0.13140777f, 0.10148614f, 
    0.03153763f, -0.01517567f, 0.08475307f, 0.10550776f, -0.05884882f, 0.26749286f, -0.13406612f, 0.01787698f, 
    -0.00463388f, 0.08378705f, 0.03204230f, -0.00610223f, -0.04632785f, 0.15517490f, -0.06752819f, 0.15027860f, 
    -0.08016367f, 0.28811333f, -0.03642702f, 0.17811570f, -0.10856435f, 0.09192128f, 0.14600654f, 0.08105845f, 
    -0.34527266f, -0.08020069f, 0.05047347f, 0.10103296f, 0.01008773f, -0.46732250f, 0.22422776f, -0.58412027f, 
    -0.01081206f, -0.01388624f, -0.04524410f, 0.08437464f, -0.05216960f, 0.14989240f, -0.15796506f, -0.15312466f, 
    0.01691774f, 0.13891962f, 0.03782143f, -0.02100606f, 0.21001737f, -0.06298340f, 0.12670872f, -0.00087245f, 
    0.06670196f, -0.09910004f, -0.14040701f, -0.01981411f, -0.35525212f, -0.17521214f, 0.14999355f, -0.00417312f, 
    0.06292980f, 0.11949470f, -0.10019583f, 0.03498108f, -0.12602681f, -0.09982820f, -0.10235564f, -0.16359842f, 
    -0.23640546f, -0.01633402f, -0.16428027f, -0.01619353f, 0.15427256f, -0.01093179f, -0.04048430f, 0.25453371f, 
    -0.04863691f, 0.11947313f, 0.25212914f, 0.04243728f, -0.07690413f, -0.48303595f, 0.00670814f, -0.12924956f, 
    0.13834463f, 0.15501346f, 0.02953281f, 0.05244307f, -0.10626516f, 0.08250267f, 0.09493664f, 0.02398726f, 
    -0.05610644f, 0.24271302f, 0.54442060f, -0.05562306f, -0.13594574f, -0.28538990f, -0.25220215f, 0.04346983f, 
    0.02543481f, 0.01018025f, -0.03311053f, 0.11506083f, 0.15209243f, 0.04414814f, -0.22746414f, 0.21953091f, 
    -0.05681607f, -0.04163190f, -0.01391029f, 0.03042588f, -0.11964467f, -0.08589426f, -0.05517127f, 0.08969802f, 
    0.17407525f, 0.35098886f, -0.29647055f, -0.24446099f, 0.05482400f, -0.01920773f, -0.07182990f, 0.07002916f, 
    0.07727079f, -0.10294708f, -0.11663359f, -0.12482005f, 0.08999624f, -0.29939446f, 0.04582363f, 0.31169906f, 
    0.24221297f, 0.19148439f, 0.14955959f, 0.04231946f, -0.14236744f, -0.05695092f, 0.17267936f, -0.11609569f, 
    -0.12568501f, 0.41787583f, 0.03983212f, 0.24405375f, 0.00773051f, -0.02675134f, -0.06741501f, -0.17582744f, 
    0.04898736f, -0.09756873f, 0.13751470f, 0.01373070f, 0.49654874f, -0.20015554f, -0.36046895f, -0.16647026f, 
    -0.05958987f, -0.03894524f, -0.07854883f, -0.27854693f, -0.09112798f, -0.11643121f, -0.07593093f, 0.00046251f, 
    0.34362647f, 0.27921999f, 0.02669607f, 0.21306887f, 0.02900424f, -0.00948504f, -0.13175106f, 0.30063772f, 
    -0.11881068f, -0.04823398f, -0.06444956f, -0.11831012f, -0.12231310f, -0.08769797f, 0.02191828f, -0.11133232f, 
    0.06608669f, -0.07622828f, 0.15549928f, -0.03816800f, -0.03055351f, 0.01074871f, 0.04654390f, 0.02822990f, 
    0.62984216f, 0.32249874f, 0.27397221f, 0.06044479f, 0.23251982f, 0.16567081f, -0.08474741f, 0.27196124f, 
    0.05123648f, 0.07254462f, -0.22773914f, -0.08216079f, 0.03035396f, 0.08113288f, 0.21207695f, -0.03232627f, 
    -0.13777488f, -0.17023797f, -0.23096634f, -0.08306732f, -0.05835943f, 0.03022735f, -0.13921317f, 0.03906522f, 
    -0.02715603f, 0.40088084f, 0.05874244f, 0.29378369f, -0.15980940f, -0.16739838f, -0.03484885f, -0.08277398f, 
    -0.12836057f, 0.08104175f, 0.11253285f, -0.05449733f, 0.27830991f, -0.08168763f, -0.01419191f, 0.29912025f, 
    -0.06216937f, -0.10837600f, 0.06891922f, 0.02249820f, 0.01200429f, 0.23067617f, 0.06535751f, -0.03582672f, 
    0.05794341f, 0.02925324f, 0.01889895f, -0.01764263f, 0.10882407f, 0.14535543f, -0.01449778f, 0.07671994f, 
    -0.08571066f, 0.17787205f, 0.12860239f, 0.19376776f, 0.06766547f, -0.40464059f, -0.10156580f, 0.03890291f, 
    0.11430567f, 0.19124037f, 0.03840015f, -0.26506519f, -0.08952761f, 0.12321271f, 0.04903386f, -0.05718907f, 
    -0.35061687f, 0.19111685f, 0.11677750f, 0.07605269f, 0.00562978f, -0.11203388f, 0.15951408f, -0.09100636f, 
    -0.07491277f, -0.31040245f, -0.10840612f, -0.16459675f, 0.01250393f, -0.07936980f, -0.17833242f, 0.13124762f, 
    0.04089216f, 0.02779603f, 0.00385817f, -0.07544944f, 0.07413993f, -0.07384561f, 0.01484860f, -0.20541091f, 
    -0.09208300f, -0.16293237f, 0.35225195f, -0.09412168f, 0.00992280f, -0.00021797f, 0.10017793f, -0.18911932f, 
    -0.23311070f, -0.04194613f, -0.15260096f, -0.12897952f, 0.01705925f, -0.06465732f, 0.16030771f, 0.42254266f, 
    0.22682326f, 0.07710180f, 0.05158086f, 0.18007310f, 0.21875526f, 0.17421943f, 0.27740049f, -0.04553443f, 
    0.10652481f, 0.08617882f, -0.19933172f, -0.07754837f, 0.09488193f, 0.09231541f, 0.30663413f, 0.06168902f, 
    0.18293263f, 0.12988681f, 0.23301713f, 0.28818050f, 0.13059182f, 0.13472141f, -0.18725944f, 0.08843809f, 
    -0.05086172f, 0.08652356f, 0.04799292f, 0.06510902f, 0.17819889f, -0.00979731f, 0.02056900f, 0.30246842f, 
    -0.37616318f, -0.10046811f, -0.24001044f, 0.02804718f, 0.02448257f, 0.01198934f, 0.13341895f, -0.00945000f, 
    -0.17301367f, -0.07620876f, -0.31454298f, -0.35766891f, 0.49334091f, 0.10805519f, 0.10262082f, -0.22422758f, 
    -0.19629449f, -0.03257683f, 0.10264863f, 0.16281649f, 0.14402169f, 0.22184819f, 0.24804781f, 0.18895373f, 
    0.04979776f, -0.28919068f, -0.15056688f, -0.02421570f, 0.04915910f, 0.36346683f, -0.00730718f, -0.04054922f, 
    -0.04264001f, 0.02403960f, -0.18092841f, 0.17668194f, -0.04548872f, -0.21417181f, -0.14926492f, -0.01736783f, 
    -0.00359554f, 0.01865750f, 0.02342882f, 0.04853008f, 0.06987614f, -0.10298500f, -0.03651695f, 0.09701411f, 
    0.41284800f, -0.19278181f, 0.00993567f, 0.31369871f, -0.03394511f, 0.20180956f, -0.07981944f, 0.07541700f, 
    0.02396269f, 0.05502391f, 0.23200646f, 0.22447471f, 0.01974095f, -0.28821096f, -0.04805597f, -0.35183424f, 
    0.11225379f, 0.12210164f, 0.16219869f, -0.12636504f, -0.17008902f, -0.16520105f, -0.17646472f, -0.08726403f, 
    -0.10919841f, 0.05418387f, -0.22527836f, -0.15843935f, 0.14132193f, 0.06738678f, -0.30983084f, 0.01340736f, 
    -0.16333069f, -0.08367577f, 0.15871990f, -0.02519159f, -0.06036114f, 0.06975365f, 0.01586895f, -0.03729106f, 
    -0.02083004f, 0.12859288f, -0.14942612f, -0.03686338f, 0.04079633f, 0.04682445f, -0.07983290f, -0.08526487f, 
    0.04983883f, -0.12787412f, 0.10365400f, 0.06041552f, 0.05578598f, 0.10981485f, 0.06331684f, -0.14648043f, 
    -0.14284103f, -0.40837198f, -0.32830480f, -0.57666910f, 0.73388970f, 0.14242482f, 0.45678154f, 0.20974255f, 
    0.05539087f, 0.13461323f, 0.13667504f, 0.08197939f, 0.08376459f, -0.03774874f, -0.02792329f, -0.02726555f, 
    -0.06511621f, -0.11546044f, 0.00005790f, -0.04265161f, -0.03041728f, 0.11551500f, 0.10903108f, 0.21034643f, 
    0.29479387f, 0.03959043f, -0.17414394f, -0.08836986f, -0.11276887f, 0.12972704f, 0.09875403f, -0.10409831f, 
    0.23829924f, 0.08388814f, -0.09368043f, -0.20287937f, 0.04859508f, -0.01262984f, -0.04510801f, -0.06869938f, 
    0.11997607f, -0.20605256f, -0.10842728f, 0.00688740f, 0.05643748f, 0.14097385f, -0.07027375f, 0.03315738f, 
    -0.04539912f, -0.09144409f, -0.10554999f, -0.09268329f, -0.14285928f, -0.15373856f, 0.56008446f, -0.13407010f, 
    0.09039639f, 0.16649869f, -0.09357661f, 0.03335468f, 0.08030006f, 0.00917953f, -0.02866493f, -0.01431890f, 
    -0.27442691f, -0.10161415f, 0.28009075f, 0.16978118f, -0.09673142f, -0.01497689f, -0.03362509f, 0.18722627f, 
    -0.13331248f, 0.05182571f, 0.04505028f, 0.10191318f, -0.01166044f, 0.29783243f, 0.26400205f, 0.07482319f, 
    0.09024731f, -0.03600606f, 0.11924496f, 0.00115508f, 0.13303256f, 0.06841613f, -0.10293570f, -0.12414899f, 
    0.00400680f, -0.16820085f, -0.01810046f, -0.07386015f, -0.05253620f, 0.40577817f, 0.04164306f, 0.36683956f, 
    -0.09449440f, -0.04812078f, -0.01200621f, -0.04248046f, -0.47356173f, -0.03171561f, 0.32488361f, 0.05565108f, 
    0.11706324f, -0.11059679f, 0.04263797f, 0.06442221f, 0.17567502f, -0.02832136f, 0.11537109f, 0.06977794f, 
    -0.26654786f, -0.04094601f, 0.22868524f, 0.05997566f, 0.07171395f, -0.15136443f, 0.05113236f, -0.14464219f, 
    0.07200234f, 0.09558709f, 0.05603578f, 0.02298476f, 0.09946613f, 0.18829045f, 0.04825049f, 0.16266684f, 
    -0.03974359f, 0.21210167f, -0.02606509f, 0.07587879f, 0.06115633f, 0.03463620f, 0.09639035f, 0.24418497f, 
    0.03916807f, -0.18114160f, 0.00668734f, 0.12300306f, 0.00227894f, -0.18540049f, 0.33651647f, -0.05073375f, 
    -0.06091373f, 0.01277650f, 0.03954339f, 0.18950199f, -0.41318867f, -0.24523661f, -0.37752679f, 0.01687232f, 
    0.05289423f, -0.03585218f, -0.15426971f, 0.01821166f, -0.04390571f, 0.00409110f, 0.05816203f, 0.19934039f, 
    -0.29548237f, -0.07257622f, 0.17760397f, 0.01769266f, -0.03705653f, 0.16154705f, 0.00039808f, 0.09227131f, 
    0.27918783f, -0.10748038f, 0.07902005f, -0.00586418f, 0.10308515f, 0.12653738f, 0.32750645f, 0.14075261f, 
    0.15725498f, 0.10050488f, 0.04235472f, 0.06522367f, 0.16468178f, -0.16068892f, 0.28053826f, -0.16822964f, 
    -0.05292274f, -0.02002974f, -0.08757532f, 0.01196103f, -0.01632444f, 0.04458175f, 0.04104438f, -0.04590059f, 
    0.05497963f, -0.06971424f, -0.02646763f, -0.04386500f, 0.17547026f, 0.30263075f, 0.20276594f, 0.23851533f, 
    -0.07293972f, 0.01629872f, 0.12756808f, 0.27913451f, 0.18646251f, 0.09271548f, -0.01379690f, -0.07940630f, 
    0.04812120f, -0.19055906f, -0.12755230f, -0.00901503f, -0.24470761f, 0.04043062f, -0.01386407f, 0.17966321f, 
    0.07204080f, 0.21786793f, 0.08446839f, 0.00783083f, 0.27191067f, 0.04524336f, -0.07427401f, -0.05544359f, 
    0.04620896f, 0.06290355f, -0.05556669f, 0.02649985f, -0.06334981f, 0.02713821f, -0.12136092f, 0.13719241f, 
    -0.03082100f, -0.02625212f, 0.07114981f, 0.11131942f, 0.04596808f, -0.02016478f, -0.02681663f, 0.05950700f, 
    -0.14489061f, 0.07514325f, -0.12253714f, 0.12534322f, 0.10414653f, -0.08583142f, -0.37396255f, -0.07100490f, 
    0.12266593f, 0.17665231f, -0.05780312f, 0.02864372f, -0.11547291f, 0.09136278f, -0.09417717f, -0.10523058f, 
    0.26368886f, 0.25679582f, -0.04916460f, -0.31629732f, 0.03022454f, 0.00039371f, 0.26401478f, 0.09249956f, 
    -0.07034766f, -0.02449849f, -0.00118512f, -0.05327244f, 0.14433178f, -0.03629005f, -0.19391705f, -0.20183089f, 
    0.24689905f, 0.01931698f, -0.03325011f, -0.09051333f, -0.07165898f, -0.17145734f, -0.05715340f, -0.11032256f, 
    0.21918580f, 0.40833604f, -0.15714803f, -0.00269321f, 0.17172034f, 0.11240515f, 0.00764909f, 0.23174091f, 
    0.02626186f, -0.03477507f, 0.16823031f, 0.09372573f, 0.13209347f, 0.24125992f, -0.17023641f, -0.11336590f, 
    -0.13017850f, 0.18278788f, -0.02738865f, -0.05156176f, 0.09214636f, -0.03927517f, -0.05668062f, -0.10803033f, 
    0.27786055f, 0.30946416f, -0.01494966f, -0.22493322f, 0.20956662f, 0.26919764f, 0.09435863f, 0.17010367f, 
    -0.19355673f, 0.10557899f, -0.20967038f, -0.19829942f, 0.27833104f, 0.12425475f, 0.05561279f, -0.20731698f, 
    0.15046504f, 0.03332163f, -0.01249637f, 0.00824523f, 0.03080560f, 0.03451103f, -0.00723973f, 0.09884688f, 
    -0.18297784f, 0.34941447f, 0.15323161f, -0.26937616f, -0.07635852f, 0.19329688f, 0.12059242f, 0.33143699f, 
    0.11862857f, -0.00086087f, -0.03178193f, -0.15879589f, 0.12518375f, 0.20508623f, 0.17099646f, -0.02193009f, 
    -0.17910354f, -0.07143041f, -0.13509494f, -0.15973450f, -0.25286767f, -0.08984070f, -0.01813133f, -0.14344107f, 
    0.19129068f, 0.69726658f, -0.23565336f, 0.36935374f, -0.02171937f, -0.04330070f, 0.06098267f, -0.13987322f, 
    0.02287568f, 0.04082018f, 0.04423976f, 0.09610090f, -0.15572615f, -0.20610324f, 0.17689881f, 0.08254396f, 
    -0.17018577f, 0.02720128f, 0.11460521f, -0.15222868f, 0.15068597f, -0.02096167f, 0.19579135f, 0.07694624f, 
    -0.15566400f, -0.34647501f, 0.02650137f, -0.14994711f, 0.20224671f, 0.07716362f, 0.07007985f, 0.11916252f, 
    0.05547174f, -0.02518968f, 0.20861582f, 0.10465719f, -0.24786207f, -0.29713956f, 0.00550782f, -0.19004315f, 
    -0.02934666f, 0.12264591f, -0.02624744f, 0.00480664f, 0.10895720f, 0.16058844f, -0.11088257f, -0.11225715f, 
    0.15568906f, 0.27934185f, 0.32005239f, 0.05172855f, 0.11211358f, -0.09791574f, -0.06563867f, 0.03758676f, 
    -0.12792405f, -0.39586151f, -0.23481558f, 0.10013223f, 0.02820550f, -0.17576176f, -0.16093050f, -0.24562033f, 
    -0.10957855f, 0.02374244f, 0.10511715f, 0.13390134f, -0.01057904f, -0.10798571f, 0.04166084f, -0.10991415f, 
    0.53943402f, 0.03116622f, 0.48306406f, -0.18774654f, -0.19155598f, -0.14788453f, -0.00025149f, -0.14353484f, 
    -0.15817957f, 0.01582986f, -0.04431466f, -0.04569909f, -0.08659353f, -0.21840617f, -0.24065191f, 0.10235957f, 
    0.01256368f, -0.01981976f, 0.15390302f, 0.17266645f, -0.03502143f, 0.02313553f, 0.05943262f, 0.25304377f, 
    0.08701242f, 0.04818156f, -0.20888868f, 0.24432093f, 0.00869724f, 0.09421585f, 0.22312473f, 0.11892894f, 
    0.15273771f, 0.17857750f, 0.22213066f, 0.24424860f, 0.08765026f, -0.05275268f, -0.13035837f, 0.10507492f, 
    -0.32717517f, 0.00518506f, 0.15872078f, 0.23444222f, -0.03723867f, 0.00424075f, 0.15492550f, 0.20174074f, 
    -0.13443781f, 0.15124539f, -0.24567038f, 0.15824094f, -0.08682175f, -0.15511316f, 0.15195620f, -0.06108239f, 
    -0.16593106f, -0.22221646f, -0.26329386f, -0.22986087f, 0.22728696f, -0.04930665f, 0.03287545f, 0.09711578f, 
    -0.01695976f, 0.13372676f, -0.02870642f, -0.00965413f, 0.03797891f, 0.24633993f, 0.28237525f, 0.29468533f, 
    0.20763445f, 0.04457545f, -0.05905357f, 0.15743457f, -0.21664171f, 0.30399981f, -0.10347198f, 0.07041458f, 
    -0.02505211f, -0.11186022f, 0.04364901f, -0.05609817f, -0.37062076f, -0.26025465f, -0.10595247f, -0.08191355f, 
    -0.01403122f, -0.19125527f, 0.20658906f, -0.00423874f, -0.10763466f, 0.00739712f, 0.02558584f, -0.00302487f, 
    0.32410878f, 0.14016540f, -0.18144572f, 0.11535130f, 0.02015724f, 0.23382291f, -0.10825843f, 0.05785049f, 
    0.07027774f, -0.02907556f, 0.22818613f, 0.06419893f, 0.41263956f, 0.20402916f, 0.00183897f, 0.04662869f, 
    0.03496404f, 0.11980365f, 0.03341581f, -0.00572720f, 0.00734141f, 0.01557346f, -0.08740856f, -0.16606544f, 
    0.20448324f, 0.17778163f, 0.14142391f, 0.24447541f, 0.07407189f, -0.13249189f, 0.13890575f, 0.21400693f, 
    -0.20337740f, 0.20302342f, 0.08613463f, -0.04021373f, 0.16850588f, 0.20856772f, -0.03867798f, 0.01641817f, 
    -0.16851524f, -0.07830437f, 0.11479187f, -0.03077589f, 0.01592585f, 0.10085947f, -0.19615357f, 0.04712701f, 
    0.06956259f, 0.20397262f, 0.16748275f, -0.00996552f, 0.03102842f, -0.00383193f, 0.10424517f, -0.01044502f, 
    -0.12904334f, -0.26060927f, -0.08671621f, -0.20985088f, 0.05740159f, 0.34608227f, 0.08231232f, -0.06604759f, 
    -0.05533680f, -0.03656090f, -0.07996238f, -0.16788766f, 0.02001596f, 0.00948147f, 0.08740123f, 0.15548608f, 
    -0.33854720f, 0.03175016f, 0.05017559f, 0.16652016f, -0.01871294f, 0.03233207f, 0.15043746f, -0.08166047f, 
    -0.16609804f, 0.04903378f, -0.20826769f, -0.13667415f, -0.08908603f, 0.30237198f, 0.24707614f, 0.43439829f, 
    0.01930894f, 0.01742505f, 0.10064136f, 0.20862928f, -0.02149539f, -0.07677428f, -0.17752226f, -0.19113839f, 
    -0.26045930f, 0.41073835f, -0.10213890f, 0.28885585f, 0.17742276f, 0.24652982f, -0.10003381f, 0.04776215f, 
    -0.01708257f, -0.15410665f, 0.00494110f, -0.09249552f, -0.06298066f, 0.39625531f, 0.49163979f, -0.03635013f, 
    0.04888337f, 0.19318189f, -0.05203565f, 0.15599880f, 0.25249469f, -0.00269529f, 0.03774894f, -0.08495025f, 
    0.24561709f, -0.26105610f, -0.15471393f, 0.20948061f, 0.09713173f, -0.03379241f, 0.03232702f, 0.01181410f, 
    0.10423306f, 0.10073689f, 0.06769456f, 0.24365370f, -0.25883490f, -0.02059128f, -0.09288150f, -0.13308318f, 
    -0.05421728f, -0.09358156f, -0.01746885f, -0.03366126f, 0.10449234f, -0.04707178f, -0.17183794f, 0.20742230f, 
    0.72603291f, -0.36732131f, 0.47089717f, -0.13308516f, 0.22669548f, -0.11080950f, 0.13207361f, -0.00851924f, 
    -0.11528493f, 0.24428548f, -0.03860132f, -0.00217565f, 0.15794466f, -0.06834274f, -0.23744233f, -0.05779537f, 
    -0.02683602f, -0.03937366f, -0.05039159f, 0.13635659f, 0.25984481f, 0.13096912f, 0.18385984f, -0.09324533f, 
    -0.17440192f, -0.40007868f, -0.04640530f, -0.09392924f, 0.11659051f, -0.02679983f, 0.07713488f, -0.01259026f, 
    0.16252515f, -0.11568577f, 0.07695111f, 0.24731839f, 0.22302128f, -0.09772528f, 0.15500408f, 0.24615800f, 
    0.00900410f, 0.06783215f, -0.11322628f, 0.17740019f, 0.01395445f, -0.00113253f, 0.05556606f, -0.00177618f, 
    -0.15771328f, -0.29401320f, -0.25329483f, 0.27582878f, -0.09877017f, -0.04963207f, 0.10042297f, -0.00092250f, 
    -0.09294985f, -0.00325744f, 0.15733340f, 0.21481581f, -0.20269910f, -0.08369318f, -0.10486052f, -0.48142329f, 
    -0.01103014f, -0.09504929f, -0.08299644f, 0.14881100f, 0.11210083f, -0.01016778f, 0.03644112f, 0.11203364f, 
    0.09281911f, -0.19507203f, 0.29877892f, -0.51758140f, 0.07493515f, -0.05901371f, -0.14355730f, 0.12237545f, 
    0.08536462f, -0.00918443f, 0.12942763f, 0.00635018f, 0.04951135f, 0.01594920f, -0.06341016f, 0.09007727f, 
    0.11421935f, 0.07167139f, 0.10744644f, -0.09685393f, -0.00607967f, 0.18651807f, 0.08384283f, 0.02335283f, 
    -0.14092670f, 0.22170638f, -0.17793337f, 0.07759137f, -0.00327068f, 0.07678150f, -0.15087546f, -0.14902444f, 
    0.02497827f, -0.14449836f, -0.24287860f, -0.03680087f, 0.39374095f, -0.16547176f, -0.21124208f, 0.10294999f, 
    -0.00192587f, -0.09137635f, 0.09624159f, 0.34386545f, 0.00921940f, -0.14239405f, -0.12153818f, -0.01424014f, 
    0.28238332f, -0.05532273f, -0.04967190f, -0.24700959f, 0.02493399f, 0.09741785f, 0.13158962f, -0.08024812f, 
    -0.00389339f, -0.03348136f, -0.09847618f, 0.10267974f, -0.04276746f, 0.28575441f, -0.02753825f, 0.02285052f, 
    0.04966257f, -0.11294975f, 0.06095957f, -0.05391956f, -0.08808319f, -0.06890455f, -0.09788600f, 0.05808233f, 
    -0.16787560f, -0.10199104f, -0.69920897f, 0.06531425f, 0.22425626f, 0.28327847f, 0.20854412f, -0.06261282f, 
    0.19776937f, -0.17890170f, 0.05935188f, -0.06489908f, -0.33753505f, 0.01448645f, -0.20718677f, -0.14862712f, 
    0.25165009f, -0.06657832f, 0.39501733f, -0.03397997f, -0.00850604f, 0.03078358f, 0.11310777f, -0.08480427f, 
    0.03707025f, -0.30730349f, 0.47262597f, 0.24517821f, -0.11069955f, 0.05570770f, -0.14070936f, 0.12829931f, 
    0.01951033f, 0.06781124f, 0.08240088f, 0.12581272f, 0.05188024f, 0.20760766f, 0.18791948f, -0.17650205f, 
    0.01222652f, 0.00005992f, -0.08291911f, 0.10211989f, 0.02877801f, 0.03082695f, 0.01206560f, -0.05587291f, 
    0.37482357f, -0.66459221f, -0.08916177f, -0.24104854f, 0.03601994f, 0.24553190f, 0.01121713f, 0.30100128f, 
    0.12520474f, -0.04608037f, 0.06873478f, 0.05272771f, -0.14903630f, 0.39166516f, 0.54042351f, 0.20803428f, 
    -0.13924697f, -0.04521552f, -0.04120550f, 0.13899960f, 0.20761350f, 0.07847352f, -0.02192148f, -0.12467229f, 
    -0.32378113f, 0.05967004f, -0.02282386f, -0.01272387f, 0.12802893f, -0.07485766f, 0.04983794f, -0.09496210f, 
    0.06511236f, 0.05742453f, -0.11989915f, -0.02351908f, 0.12005468f, 0.14965911f, 0.06303862f, -0.10213808f, 
    0.00882086f, 0.07080924f, 0.01187487f, 0.04605589f, -0.02785457f, 0.09262175f, -0.10397331f, 0.09527121f, 
    -0.64307249f, -0.04110535f, -0.19994707f, -0.02089474f, -0.10055937f, -0.12956437f, 0.20113800f, -0.10772607f, 
    0.13407536f, -0.05734951f, 0.09845755f, 0.08840683f, -0.00636507f, -0.22155091f, -0.02865789f, -0.01978561f, 
    0.02790938f, -0.14706402f, -0.09840061f, -0.03471409f, 0.11518744f, -0.08694112f, 0.20475002f, 0.01102265f, 
    0.46486035f, -0.39639485f, -0.11603794f, 0.16642445f, 0.02597109f, 0.10659932f, 0.03387655f, -0.13843277f, 
    0.44508439f, 0.14937192f, -0.06408684f, 0.21860109f, -0.15968052f, 0.45855215f, 0.05781924f, 0.07358422f, 
    0.01849806f, -0.08590217f, 0.00842453f, -0.02162243f, 0.10769185f, -0.07676275f, 0.12873465f, 0.27546993f, 
    -0.12209227f, -0.11940969f, -0.13630356f, 0.11970196f, -0.01351021f, 0.06495970f, 0.02659297f, -0.03865379f, 
    0.02227772f, -0.09929793f, 0.14614406f, -0.00354441f, -0.31326863f, 0.38424781f, -0.02160268f, -0.09863646f, 
    -0.05106827f, -0.29433164f, 0.04890567f, 0.24028777f, 0.09744953f, 0.07155216f, -0.01835338f, 0.05231865f, 
    -0.04293544f, 0.00964581f, -0.00740819f, -0.00490693f, -0.07355628f, 0.04809873f, 0.00051259f, -0.05211053f, 
    -0.05331328f, -0.02568212f, 0.02189273f, 0.04728307f, 0.07502379f, 0.04047963f, 0.04010529f, 0.02487902f, 
    -0.06390417f, -0.05984776f, 0.05060551f, -0.04475613f, 0.04890432f, -0.04490777f, -0.07855636f, -0.02384720f, 
    -0.05745213f, 0.05342760f, -0.02868621f, 0.04322857f, -0.07826698f, -0.07544863f, -0.06547833f, 0.01373835f, 
    0.05073613f, -0.00663141f, 0.00232000f, 0.06447561f, -0.01327596f, -0.05589808f, 0.04487206f, 0.01021101f, 
    -0.06533059f, -0.03432834f, -0.04172287f, 0.04036306f, -0.05890130f, -0.02661229f, 0.03977502f, -0.05928754f, 
    -0.04485930f, 0.02146287f, -0.04462467f, 0.01845541f, 0.05059658f, 0.01085671f, 0.01222274f, 0.03011819f, 
    0.02807474f, 0.01598977f, 0.04821863f, -0.02402186f, -0.03252439f, 0.05380817f, 0.01537343f, -0.03117263f, 
    0.02290045f, -0.03151434f, -0.03609037f, 0.04408705f, -0.05876974f, -0.05658594f, -0.04545683f, 0.03704280f, 
    -0.03713351f, 0.03264656f, 0.01640991f, -0.02641949f, -0.01007083f, -0.01369637f, -0.04600363f, -0.03316524f, 
    0.00652167f, 0.04244370f, -0.07805596f, 0.06446477f, -0.02230123f, -0.06681672f, -0.00337671f, 0.05059168f, 
    -0.02134026f, -0.04178246f, 0.03247653f, 0.05937169f, -0.04207387f, -0.03802361f, -0.01189909f, -0.01802564f, 
    -0.01397580f, -0.04463454f, 0.06810683f, -0.01511965f, -0.02952793f, 0.02064569f, 0.00252687f, -0.05877221f, 
    0.00043372f, 0.02614065f, -0.07034142f, -0.04814151f, 0.02776870f, -0.01371873f, -0.05988185f, -0.06273034f, 
    0.00596734f, -0.06279401f, -0.03386619f, -0.05400645f, -0.01124913f, -0.06164209f, -0.07295773f, 0.05543437f, 
    -0.00270109f, -0.03642412f, 0.05628761f, -0.07263684f, -0.04036834f, -0.01310916f, 0.03289690f, 0.02878849f, 
    0.02181644f, 0.06838532f, -0.02114371f, 0.00885724f, -0.06723340f, 0.03941078f, -0.08002071f, -0.06287772f, 
    -0.02909791f, -0.00665977f, -0.05740621f, 0.01913477f, -0.04044871f, -0.01119719f, -0.01475274f, -0.04761835f, 
    -0.03319460f, -0.04083074f, -0.04220218f, -0.01396374f, -0.05136775f, 0.06354028f, -0.01231873f, 0.04896872f, 
    -0.03828619f, -0.05438051f, 0.04752661f, 0.05814736f, 0.04646282f, 0.00135114f, 0.04913259f, -0.07440674f, 
    0.02093700f, -0.00135389f, 0.01928347f, 0.05988043f, -0.03328942f, -0.07241333f, 0.03306863f, -0.06475758f, 
    0.03157767f, -0.06725386f, -0.07777594f, -0.05614229f, 0.04543239f, 0.00151140f, 0.00634351f, 0.01238741f, 
    -0.08022479f, 0.06180584f, -0.03526867f, 0.05623440f, 0.04673110f, 0.04150431f, -0.02095441f, -0.04371061f, 
    -0.03079193f, -0.03841199f, -0.07303047f, -0.04191572f, 0.06337814f, 0.01686125f, -0.03364488f, -0.01643212f, 
    0.02993369f, 0.01181874f, -0.01337982f, 0.04596974f, -0.02746649f, 0.04204619f, -0.04587589f, -0.04476594f, 
    -0.03776040f, 0.02121512f, -0.04940189f, -0.03832294f, -0.03501545f, -0.07424738f, 0.00731693f, -0.02546880f, 
    0.01485904f, -0.05746713f, 0.06111791f, 0.06306925f, 0.04263051f, 0.04713671f, -0.00992639f, -0.04851468f, 
    -0.05038612f, 0.01271055f, -0.02505808f, -0.00366045f, -0.05334642f, -0.04820338f, -0.08059455f, -0.00450405f, 
    -0.00925150f, -0.07816889f, 0.02086818f, 0.02870250f, -0.07376549f, -0.01822291f, 0.00034457f, -0.05098564f, 
    -0.08002897f, 0.00728095f, -0.01889950f, -0.00060795f, -0.07416087f, -0.05903686f, -0.06702975f, 0.00392204f, 
    0.03541669f, -0.03301907f, 0.00758718f, 0.00826779f, -0.05422809f, 0.03523546f, -0.00762438f, 0.04154865f, 
    -0.04005488f, -0.04918544f, -0.04595094f, -0.05440180f, -0.07648029f, 0.01729591f, -0.05417151f, -0.03825564f, 
    -0.00169046f, -0.00006085f, -0.05529730f, 0.05926425f, -0.03908977f, -0.07546882f, 0.05525066f, 0.04012096f, 
    0.04374068f, -0.05422098f, 0.02981412f, -0.02805538f, -0.03001882f, -0.05419460f, -0.00034162f, -0.05783452f, 
    0.04056199f, 0.01395063f, -0.01134300f, -0.02154776f, 0.03550014f, 0.02328788f, -0.02927166f, -0.00438736f, 
    0.04285744f, -0.03824724f, 0.06331236f, 0.02069222f, 0.04529055f, -0.05406579f, -0.04144754f, 0.02369031f, 
    0.05129641f, -0.00667336f, -0.04149597f, 0.00703177f, 0.03048958f, -0.02636306f, 0.03609911f, -0.03455865f, 
    -0.00652514f, -0.04562674f, -0.02177575f, -0.05318571f, -0.02233137f, -0.04145821f, 0.05176328f, 0.05445862f, 
    -0.02363276f, 0.01444363f, 0.00260519f, -0.06725886f, -0.07130870f, 0.04522640f, -0.07896147f, 0.04593337f, 
    -0.05565012f, 0.03479361f, 0.02925093f, 0.01783081f, -0.03026756f, 0.00446595f, 0.05610152f, 0.00099204f, 
    -0.01976299f, 0.04089720f, 0.05937261f, -0.02491521f, 0.05720714f, 0.02260800f, 0.00851745f, -0.06190664f, 
    0.00765300f, 0.04515123f, 0.00519658f, 0.02833155f, 0.05853849f, -0.01464144f, 0.02616625f, -0.00924007f, 
    -0.02271987f, -0.03447695f, 0.05723109f, -0.02439409f, -0.00021549f, -0.05209733f, -0.05322544f, -0.00349496f, 
    0.03296335f, -0.04624579f, -0.02914730f, 0.06026312f, -0.05076898f, 0.06252923f, -0.06746075f, -0.00884135f, 
    -0.03125358f, -0.05060815f, -0.00316459f, -0.06834020f, -0.05433725f, 0.03822227f, 0.04196807f, -0.05012700f, 
    -0.05045582f, -0.07558546f, -0.06589553f, -0.02908106f, -0.01111133f, 0.05910524f, -0.01342549f, -0.01469742f, 
    0.04566647f, -0.03164807f, -0.05378471f, -0.02220039f, -0.07746709f, -0.01939822f, -0.07949688f, -0.03579788f, 
    -0.05239797f, 0.04843650f, 0.05602844f, -0.06171261f, -0.02650806f, -0.06265781f, 0.06260204f, 0.03569221f, 
    0.20080031f, -0.11509800f, -0.02685160f, -0.14861009f, 0.16648498f, 0.08396555f, -0.00242199f, 0.07183241f, 
    0.04816894f, 0.13536599f, 0.05655042f, -0.08243798f, -0.28855899f, -0.16811861f, 0.22811575f, 0.25878817f, 
    0.07866637f, 0.11315817f, -0.03721354f, -0.09218699f, 0.01239902f, -0.00845264f, -0.07557800f, 0.24001826f, 
    0.25813088f, -0.24114400f, -0.19167881f, -0.11323460f, 0.01711631f, -0.09996586f, -0.03391521f, -0.09273686f, 
    -0.13133870f, -0.00174272f, 0.08913945f, -0.02876581f, -0.21972007f, -0.04944540f, -0.04593205f, -0.03345809f, 
    0.03522246f, 0.06028524f, 0.27635571f, -0.00620038f, -0.09538846f, -0.05986315f, -0.03405844f, -0.03421527f, 
    -0.45810720f, -0.08233666f, 0.12016881f, -0.10683122f, 0.04927540f, 0.13541913f, -0.37151581f, -0.00649708f, 
    0.03995677f, -0.11068997f, -0.18001729f, -0.20473546f, 0.00538088f, 0.21579863f, 0.32089993f, -0.01813735f, 
    0.10588472f, 0.01775063f, -0.11596774f, 0.15271696f, 0.13075981f, 0.10792237f, -0.00983685f, -0.20563142f, 
    -0.36098558f, -0.18552268f, 0.13412698f, -0.07955868f, -0.01096660f, 0.34987202f, -0.09009361f, 0.31704268f, 
    0.03362781f, -0.18631589f, 0.13975646f, 0.26061127f, 0.10780444f, 0.13909800f, 0.16705313f, -0.27165699f, 
    -0.11097274f, -0.25999951f, -0.00899762f, -0.01145306f, 0.12162337f, -0.17693359f, -0.29303738f, 0.03724057f, 
    -0.35670313f, 0.24373996f, 0.11340789f, 0.07738572f, 0.19936310f, -0.36867094f, -0.06806704f, 0.00296709f, 
    -0.04815060f, 0.00499862f, -0.09267377f, -0.19884019f, -0.15074761f, 0.31056905f, 0.12224042f, 0.10234528f, 
    0.10231868f, 0.13523224f, 0.10930880f, 0.02531902f, 0.10129402f, 0.07520977f, -0.08091259f, 0.01035576f, 
    0.13021399f, -0.07601842f, 0.25000113f, 0.11166603f, 0.29510096f, -0.07866639f, 0.00667658f, 0.07075364f, 
    -0.03535867f, 0.00062789f, -0.11266924f, -0.00004985f, -0.04419931f, -0.18181267f, 0.06685627f, 0.01733866f, 
    -0.10390384f, -0.25755286f, -0.13320336f, -0.14823626f, 0.05077830f, -0.05209468f, 0.01104475f, 0.11585102f, 
    0.17044023f, 0.20219617f, -0.06044164f, 0.27712774f, -0.15272604f, 0.14409070f, 0.14118330f, -0.03017909f, 
    0.24977823f, 0.21487319f, 0.02390680f, 0.09517305f, 0.19262093f, 0.17372733f, 0.12945130f, 0.07237724f, 
    0.04327033f, -0.05739390f, -0.01580501f, 0.05776355f, 0.17517968f, 0.04948295f, 0.13344488f, 0.17301442f, 
    -0.02052666f, -0.16446194f, -0.04408677f, 0.12016654f, -0.16078962f, 0.01755780f, 0.13256161f, 0.17190990f, 
    0.10621174f, 0.03061397f, 0.16817270f, 0.14926447f, -0.19141929f, 0.06765182f, 0.00322656f, -0.17743804f, 
    -0.03696538f, -0.13872361f, 0.27903593f, 0.15665002f, 0.01114835f, 0.07992573f, -0.00204785f, 0.06875482f, 
    0.03510661f, -0.06640203f, -0.02787342f, -0.06033529f, 0.01874722f, -0.04754880f, -0.03452047f, 0.01420098f, 
    -0.06567415f, -0.04898589f, -0.03711758f, -0.06884914f, -0.02014637f, -0.03535091f, 0.03917139f, -0.06920695f, 
    -0.05449468f, -0.01947679f, -0.03006610f, 0.00804874f, -0.05218356f, 0.06807089f, -0.03066335f, 0.00402607f, 
    0.00135764f, -0.07734376f, -0.03582551f, -0.00322726f, 0.01648537f, 0.00245658f, 0.03908071f, -0.01236276f, 
    -0.02242443f, -0.02098468f, -0.04176387f, 0.02017494f, -0.02663687f, -0.04959960f, 0.02470812f, 0.02292422f, 
    -0.02830689f, -0.03381689f, -0.05189397f, -0.03154067f, -0.01133807f, 0.06378508f, 0.00147663f, -0.00422229f, 
    -0.01331386f, -0.04283281f, -0.04059804f, -0.01023973f, 0.02635650f, -0.04119150f, -0.04490969f, 0.04509866f, 
    0.02398944f, 0.05560177f, -0.07533903f, -0.05803630f, -0.03008284f, -0.01693244f, -0.04142730f, -0.05723881f, 
    0.04487319f, 0.03609420f, -0.03623543f, -0.06893522f, -0.07645275f, 0.01830946f, -0.02138311f, -0.00594493f, 
    0.01639296f, 0.02528867f, 0.02862069f, 0.01360451f, 0.01696384f, -0.00060664f, 0.02517606f, -0.00793577f, 
    -0.02805632f, -0.01241561f, 0.04839057f, 0.01438311f, 0.01545579f, -0.04153744f, -0.03034223f, -0.06314409f, 
    0.01891651f, -0.04533532f, 0.00519361f, -0.01434878f, 0.00629720f, -0.03424685f, -0.04746855f, -0.05420094f, 
    -0.02499794f, -0.07274868f, 0.00710286f, -0.04008773f, -0.07371374f, 0.02155515f, -0.05957355f, -0.06623536f, 
    -0.00770026f, -0.03957500f, 0.01881726f, 0.02508942f, -0.06470957f, 0.03318581f, 0.01600782f, 0.05469841f, 
    -0.05788771f, 0.00753578f, 0.05547071f, -0.00997848f, 0.02430272f, 0.03115999f, -0.04135315f, 0.00125065f, 
    0.01831242f, 0.06234303f, 0.00134154f, -0.05045756f, 0.00879541f, -0.01445732f, -0.06144769f, -0.04493616f, 
    -0.04744652f, -0.00279873f, 0.01650219f, -0.04116907f, -0.05447220f, -0.05976484f, 0.04656899f, -0.00473493f, 
    -0.00303858f, -0.06598989f, -0.05292683f, -0.01497042f, 0.03267012f, -0.03867996f, 0.00016288f, -0.01140369f, 
    -0.05253678f, -0.03669650f, 0.02804956f, 0.05772311f, 0.00105820f, 0.00519934f, 0.04732834f, -0.00353983f, 
    0.05639795f, 0.05066963f, 0.02097215f, 0.02887208f, 0.01562915f, 0.05128510f, 0.00757964f, -0.02833381f, 
    -0.05320917f, -0.01248785f, -0.06270833f, -0.04918619f, 0.05233240f, -0.05229245f, 0.06073511f, -0.06868411f, 
    -0.02909302f, 0.02387737f, -0.00275616f, 0.05945848f, -0.06461352f, 0.06068923f, -0.02283983f, 0.02378405f, 
    -0.00294371f, -0.02359575f, 0.02811547f, -0.04822664f, 0.00674154f, 0.00340952f, -0.04601362f, 0.02668338f, 
    0.04260872f, 0.04564474f, -0.01961662f, -0.00911459f, 0.06405797f, -0.01495807f, -0.04775853f, -0.05803059f, 
    0.15183990f, -0.01119073f, -0.15748607f, -0.11763950f, 0.04832321f, -0.03224654f, 0.13010730f, 0.06660773f, 
    -0.10122779f, -0.03644564f, 0.07188898f, 0.05010858f, 0.09320086f, -0.04454382f, -0.18217175f, -0.19274083f, 
    -0.00605050f, -0.06459776f, -0.09520718f, -0.03304608f, -0.00132207f, 0.00731484f, -0.02727090f, 0.05766902f, 
    0.32400766f, -0.04715446f, 0.08497467f, -0.27103674f, -0.07468012f, -0.15938421f, -0.09485941f, -0.05291710f, 
    -0.15126422f, -0.05755399f, -0.04268474f, 0.02639636f, -0.03796970f, -0.03976931f, -0.49829659f, 0.16712680f, 
    -0.02136177f, -0.14989877f, 0.10574472f, -0.03970397f, -0.13039739f, -0.01968562f, -0.02947665f, 0.07794517f, 
    0.11846452f, 0.04514247f, 0.01399694f, 0.03327375f, -0.01381144f, -0.08719314f, 0.10332417f, 0.05927820f, 
    0.23807855f, -0.02674536f, 0.17829029f, 0.05315242f, 0.20400769f, -0.09152690f, 0.12836547f, -0.07459006f, 
    0.09765108f, 0.14106262f, -0.11715335f, 0.11679602f, -0.05786768f, -0.06353975f, -0.00305666f, -0.11448589f, 
    -0.08013860f, 0.05566620f, -0.23645855f, 0.10146375f, -0.11710222f, -0.00305630f, -0.03549055f, 0.06858137f, 
    0.02725606f, -0.20106016f, -0.06111414f, -0.03502747f, 0.11495379f, 0.03331176f, -0.15553223f, -0.00992527f, 
    -0.02434365f, -0.04519902f, -0.01830118f, -0.06906840f, -0.03938516f, 0.04061007f, 0.03646919f, 0.05334641f, 
    0.18210347f, 0.37781337f, 0.12953632f, -0.01921968f, 0.17203003f, 0.23680353f, 0.00783418f, 0.21198364f, 
    -0.13028362f, -0.00954036f, -0.02100685f, -0.20198792f, -0.09818675f, 0.06196011f, 0.15737124f, -0.23467080f, 
    0.07325399f, -0.09229000f, 0.20055951f, -0.15270522f, 0.04423545f, -0.00518186f, -0.02095795f, -0.03889926f, 
    -0.18264890f, 0.51038188f, 0.21347255f, -0.17339090f, 0.19740908f, 0.26659894f, -0.10562659f, 0.23929153f, 
    0.14620237f, 0.08139419f, -0.05169149f, -0.03704971f, 0.25993448f, 0.12483808f, 0.14812122f, 0.18686965f, 
    -0.15468918f, -0.01268654f, -0.06015566f, -0.01423104f, -0.01773736f, -0.06784757f, -0.01589610f, -0.09458570f, 
    0.28187951f, 0.35170448f, 0.09754480f, 0.43389800f, -0.07123248f, -0.11820379f, -0.04202182f, 0.06038468f, 
    -0.05610270f, 0.14032845f, 0.03918353f, 0.06032434f, 0.09515458f, -0.02120538f, -0.11418737f, 0.07377226f, 
    -0.05119856f, 0.01082374f, 0.04733184f, -0.04365366f, -0.01175969f, 0.14616407f, 0.17868373f, 0.21059912f, 
    -0.04048957f, -0.03100933f, -0.03288000f, 0.02428196f, 0.11872738f, -0.00828886f, 0.06326951f, 0.02617485f, 
    -0.08200630f, -0.05096214f, 0.05775657f, -0.06001520f, -0.30454540f, -0.03646786f, -0.04956654f, -0.18959390f, 
    0.01112278f, 0.13101317f, -0.06982495f, -0.05406174f, -0.08590347f, 0.10180226f, 0.10091858f, 0.01835138f, 
    -0.30395904f, -0.25978872f, -0.23396440f, -0.09339283f, 0.06775740f, 0.20703663f, -0.03576094f, 0.17742647f, 
    -0.00378758f, 0.17713346f, 0.23221846f, -0.00529151f, 0.14143325f, -0.15586968f, 0.07156850f, 0.01840630f, 
    0.08991946f, 0.18699785f, 0.02925636f, 0.03649120f, -0.11179840f, 0.09683431f, 0.24422482f, -0.05414723f, 
    -0.34507939f, -0.15304440f, 0.43737426f, -0.17200013f, -0.06016467f, -0.27519220f, -0.33583939f, -0.11770087f, 
    -0.01459722f, 0.07247332f, -0.10918169f, -0.02493021f, 0.36751124f, -0.03404069f, 0.00654654f, 0.23239093f, 
    0.00552577f, 0.09219836f, -0.00781469f, 0.06553935f, -0.14105015f, -0.03754250f, -0.07971289f, -0.02575023f, 
    -0.04543151f, 0.49540064f, -0.05644010f, 0.00647214f, 0.09747884f, -0.04040450f, -0.04270563f, 0.06393266f, 
    0.10939371f, -0.08913725f, -0.15827966f, -0.08953858f, 0.19439876f, -0.12422717f, 0.01610557f, 0.44381052f, 
    0.18143952f, 0.02995754f, 0.01326747f, -0.11460247f, -0.01232976f, -0.01088287f, 0.07307358f, -0.14179549f, 
    -0.05407553f, 0.56994230f, -0.21313107f, 0.08928219f, -0.04597756f, 0.07340692f, -0.01676737f, 0.04565067f, 
    -0.06221806f, -0.04767271f, 0.12452022f, 0.09869856f, 0.01936369f, -0.21118072f, -0.13363403f, -0.18637525f, 
    0.10566479f, -0.04075639f, 0.05826423f, -0.18106592f, -0.09658846f, -0.12367130f, -0.11720303f, 0.16234989f, 
    0.32638982f, 0.16227643f, 0.11182359f, 0.27584377f, -0.03216269f, 0.05313037f, -0.11818553f, 0.03396898f, 
    -0.06069748f, 0.00554910f, -0.01239774f, -0.00620450f, 0.17466559f, 0.12745492f, -0.00206158f, 0.09859410f, 
    0.09299391f, -0.01452340f, 0.09621105f, -0.05522574f, -0.10118968f, -0.01990825f, 0.04727624f, -0.05871306f, 
    0.81151396f, 0.31836605f, 0.31298095f, 0.09641011f, 0.26801047f, -0.03894287f, -0.07348698f, -0.03354570f, 
    -0.12087489f, -0.05180867f, -0.13707583f, -0.14580306f, -0.34156379f, -0.21136828f, -0.10606246f, -0.14883709f, 
    -0.26704219f, -0.13410552f, -0.17317873f, -0.11167519f, -0.06891309f, 0.13636814f, -0.08979981f, 0.23512314f, 
    -0.33243698f, 0.28269169f, -0.11560819f, 0.03304230f, -0.22308631f, -0.18597126f, 0.00289353f, 0.07480517f, 
    -0.14309926f, -0.08839344f, 0.15808637f, -0.02501070f, 0.31870630f, -0.09371887f, 0.10505263f, 0.26002812f, 
    -0.05586434f, 0.11340663f, -0.07748923f, 0.02504488f, 0.13465765f, 0.17550236f, 0.05907245f, -0.07395606f, 
    0.01442360f, -0.09134800f, 0.07652159f, -0.05450220f, 0.22229630f, 0.00983373f, 0.07261921f, 0.14992078f, 
    0.11596206f, 0.18483172f, 0.18447155f, 0.38106576f, 0.16317643f, -0.08433776f, -0.02138901f, 0.22595824f, 
    0.04279549f, 0.17380694f, -0.08133615f, 0.06476548f, -0.00351580f, 0.04760318f, 0.06683522f, 0.12995484f, 
    0.11531566f, -0.01751838f, -0.09175008f, -0.01309080f, -0.08535280f, -0.09019699f, 0.07080287f, 0.00398580f, 
    0.15300629f, -0.03074367f, -0.16565458f, -0.01460531f, -0.28745514f, -0.08911804f, -0.29964069f, -0.39435217f, 
    0.19644861f, -0.06624883f, -0.00847879f, -0.37702441f, 0.03762395f, -0.08648469f, -0.02849703f, 0.03944940f, 
    -0.03870837f, -0.07649324f, -0.29168952f, -0.39186832f, 0.22252928f, 0.24797028f, 0.15993761f, 0.01266201f, 
    -0.02438473f, 0.01042439f, -0.07001009f, 0.06419334f, -0.31299186f, -0.00088230f, -0.11178350f, -0.28780738f, 
    0.09780595f, 0.00102644f, 0.19732922f, -0.10439816f, 0.10386427f, -0.04387753f, 0.05086115f, 0.01316514f, 
    0.13013716f, -0.26873526f, 0.17790474f, 0.07583500f, 0.07764839f, -0.11033574f, 0.32734737f, 0.42852876f, 
    -0.17711698f, 0.15684104f, 0.19399022f, 0.16200472f, -0.05557303f, 0.20887162f, 0.02039699f, -0.25925362f, 
    -0.02350802f, -0.08166564f, -0.21748358f, 0.12035254f, 0.08652531f, 0.00948221f, -0.03812500f, 0.06242860f, 
    0.04779518f, -0.37642407f, -0.15545776f, -0.01051196f, 0.07757487f, 0.11986684f, 0.05591342f, 0.33599788f, 
    0.07606466f, 0.08338051f, -0.02210782f, -0.06444489f, -0.16521871f, 0.45011228f, 0.33608162f, 0.19750024f, 
    0.01745349f, -0.06189929f, 0.00850380f, -0.02700319f, 0.17801641f, 0.30251676f, 0.23130880f, 0.06721879f, 
    -0.34815505f, -0.03515803f, -0.09600750f, -0.14533173f, 0.30894783f, 0.05277926f, 0.33544898f, 0.00807154f, 
    0.06690782f, 0.03700859f, 0.00893383f, 0.03192644f, 0.04486379f, -0.01691246f, 0.05140524f, 0.01618528f, 
    -0.02190556f, 0.28571153f, -0.06015085f, -0.16441506f, 0.09036361f, 0.11838102f, -0.06026272f, 0.04981941f, 
    -0.67291808f, 0.21688627f, 0.28534672f, 0.21835974f, -0.10877199f, 0.17401484f, 0.12500845f, 0.07189168f, 
    0.03646475f, -0.04145793f, 0.08159877f, 0.07176019f, 0.09515929f, -0.17585124f, -0.05382614f, -0.01688978f, 
    0.06540820f, -0.02448687f, 0.02971471f, 0.01313774f, -0.02584121f, -0.18884079f, 0.01880154f, -0.21391283f, 
    0.16362251f, 0.09630595f, 0.30297190f, 0.00454623f, 0.09115816f, -0.07062229f, -0.04078420f, 0.06893864f, 
    0.32498839f, 0.00004032f, -0.25300163f, 0.05484013f, -0.14520863f, 0.11948212f, 0.12076825f, 0.38755324f, 
    0.07365807f, 0.08319440f, 0.02495976f, -0.15291075f, 0.19126444f, -0.17628238f, 0.22920229f, 0.29536638f, 
    -0.12744026f, -0.11868349f, -0.16992407f, -0.13250934f, 0.01527047f, -0.00205173f, -0.00447259f, -0.01037011f, 
    0.07330813f, 0.01387219f, -0.02497995f, 0.01291643f, -0.00916273f, 0.29650110f, 0.08706421f, 0.04549138f, 
    0.07450554f, -0.03613879f, 0.04473130f, 0.09536935f, 0.28069043f, 0.21140532f, 0.00445836f, 0.12799789f, 
    0.13575283f, 0.01684413f, 0.21818036f, 0.00023495f, 0.05881525f, 0.09103657f, 0.16268755f, 0.35211134f, 
    0.08132790f, 0.01477053f, -0.05594174f, -0.11349872f, -0.35519126f, -0.32524532f, 0.21271680f, 0.08427912f, 
    0.07098589f, 0.10309609f, -0.19354674f, -0.13280898f, -0.01552646f, -0.19729494f, -0.17453164f, -0.00045844f, 
    0.39958000f, -0.17526773f, 0.22899227f, -0.19881384f, 0.01171118f, -0.03893574f, -0.03775445f, -0.10659493f, 
    -0.18841301f, -0.01577854f, 0.01225949f, -0.03937050f, -0.28942254f, -0.24448943f, 0.21696085f, -0.24396642f, 
    -0.01806141f, 0.18810751f, -0.09919500f, 0.01834620f, -0.04911901f, -0.11072568f, 0.06666701f, 0.03459027f, 
    -0.50276262f, -0.24579638f, 0.01587537f, 0.05277401f, -0.16040398f, 0.08779930f, -0.03287809f, 0.04434888f, 
    0.13642710f, 0.15019608f, 0.09101669f, 0.06410830f, -0.12316297f, 0.17917112f, 0.20896555f, 0.07761230f, 
    -0.09202785f, -0.23084150f, 0.03420617f, 0.19439788f, 0.10537517f, 0.17581433f, -0.07866769f, -0.15028447f, 
    0.10696327f, -0.19293150f, -0.02186757f, 0.09678590f, -0.10661449f, 0.25616330f, -0.03011878f, 0.41138288f, 
    -0.13944617f, -0.06696253f, 0.13163114f, -0.14292504f, -0.40342978f, -0.01384002f, 0.14919491f, -0.21368954f, 
    0.00945299f, -0.11187983f, -0.00690774f, 0.22748083f, 0.14188020f, -0.10452032f, 0.07035621f, 0.21007340f, 
    -0.21592638f, -0.07933869f, 0.13396314f, 0.11094649f, 0.01651353f, -0.37207279f, 0.03087929f, -0.05078831f, 
    -0.10468908f, -0.06371065f, -0.06997146f, -0.11856947f, -0.31015897f, 0.09732789f, 0.14689407f, 0.28312409f, 
    -0.11754309f, 0.15840313f, 0.07556288f, -0.11832017f, 0.08015753f, 0.08702738f, 0.04618660f, 0.11823399f, 
    0.18016362f, -0.18313654f, 0.20726730f, 0.21480870f, 0.14834031f, -0.15725781f, 0.27962956f, -0.04477383f, 
    -0.10496607f, -0.01164001f, 0.03698644f, 0.19593158f, -0.16183656f, 0.06157860f, -0.33198583f, -0.10680961f, 
    -0.08628713f, -0.08169323f, -0.07459829f, 0.01899811f, -0.02990946f, -0.02653026f, 0.04963415f, 0.07410390f, 
    -0.02029619f, 0.42315385f, 0.20122543f, 0.23387200f, 0.05062191f, 0.17020772f, 0.20786241f, 0.26052377f, 
    -0.00954449f, 0.01725131f, 0.14249314f, 0.02664899f, 0.17196493f, 0.06120740f, 0.28331473f, -0.10261597f, 
    0.01332743f, 0.10727473f, 0.00309329f, 0.02166627f, 0.11620654f, 0.02325736f, 0.02605152f, -0.09085179f, 
    -0.09458366f, 0.07037333f, -0.08388827f, -0.05949227f, 0.04243941f, -0.12858319f, 0.18001270f, 0.03301153f, 
    0.05607478f, -0.01315108f, -0.06023485f, -0.07767113f, 0.06898798f, 0.35170278f, 0.31308991f, 0.09588796f, 
    0.01904490f, -0.00255446f, 0.10600604f, 0.24489941f, 0.08728256f, 0.10573832f, 0.14584151f, -0.01193548f, 
    -0.01463067f, 0.04206201f, 0.05775687f, -0.00767108f, -0.02956154f, -0.03602969f, -0.01672646f, 0.03301116f, 
    -0.02889733f, 0.01045626f, 0.05654843f, -0.02942419f, -0.03238560f, 0.03257203f, -0.03102151f, 0.03533171f, 
    -0.01762232f, 0.07092839f, 0.01890204f, -0.00053645f, -0.07102764f, 0.06119968f, -0.06366657f, 0.04188612f, 
    -0.03920192f, -0.00030066f, -0.05114857f, -0.01073262f, 0.06008273f, 0.03724400f, 0.02347010f, 0.04717098f, 
    -0.03686198f, 0.01678778f, -0.05058925f, -0.00358883f, -0.07183859f, 0.02724975f, 0.01668024f, 0.01239280f, 
    0.00612673f, -0.03284984f, 0.02557926f, 0.01218051f, 0.02066436f, -0.03204134f, -0.02699724f, -0.00515916f, 
    -0.00824851f, 0.04138940f, -0.01485578f, -0.04991499f, 0.02296190f, -0.06786814f, 0.05944755f, -0.06656405f, 
    -0.07418076f, -0.06135193f, -0.00622625f, -0.01294912f, -0.05894570f, -0.05271121f, -0.02734964f, -0.06140506f, 
    0.02347991f, 0.04473842f, -0.00638328f, 0.04465662f, -0.05903130f, -0.03173187f, 0.00269219f, -0.01603157f, 
    -0.04442480f, -0.01198039f, 0.01104132f, -0.06208911f, 0.04134396f, -0.03616895f, 0.00038245f, -0.05054231f, 
    0.04251178f, -0.02774145f, 0.02944123f, -0.02208764f, 0.00391972f, 0.02753938f, -0.04255261f, 0.03788731f, 
    0.06356022f, 0.00303330f, -0.07706811f, 0.04610668f, -0.07556585f, -0.03410153f, 0.06538169f, 0.00770674f, 
    0.04983336f, 0.03911753f, 0.03060828f, 0.05918522f, 0.00835859f, 0.03439777f, 0.06811299f, -0.06263001f, 
    -0.05594057f, -0.04939142f, -0.00462109f, -0.06812838f, -0.02314639f, -0.01046311f, 0.02715507f, -0.02748735f, 
    -0.03677513f, 0.00924433f, 0.01101056f, -0.04355427f, -0.03010118f, -0.07825695f, 0.02248657f, -0.05479493f, 
    -0.03343364f, -0.00448577f, 0.02209732f, -0.05001308f, -0.00466420f, 0.03497304f, -0.02930254f, -0.01973054f, 
    0.06010693f, 0.04760659f, -0.07486729f, -0.06127592f, -0.01346826f, 0.06991436f, -0.06493963f, -0.02083985f, 
    0.03253315f, 0.03614204f, -0.00338078f, -0.02185053f, -0.06290267f, -0.07347863f, -0.05862667f, -0.01368191f, 
    0.05874129f, -0.06833014f, -0.01658959f, -0.06717523f, 0.01691465f, 0.02721819f, 0.00124673f, -0.04856079f, 
    -0.02342955f, 0.04830290f, -0.05030871f, 0.01506796f, 0.00556315f, 0.03602213f, -0.00737932f, -0.01089010f, 
    0.05982510f, -0.05676244f, -0.07833128f, 0.04447606f, -0.03755999f, -0.01228523f, -0.05982701f, 0.03806245f, 
    0.00109870f, -0.04458172f, 0.05483033f, -0.05091554f, -0.04361664f, -0.03855360f, -0.07253582f, 0.05387638f, 
    -0.04185499f, -0.01446938f, -0.07100837f, -0.04713126f, -0.03801427f, 0.01393798f, -0.05315561f, -0.05207813f, 
    0.00078119f, -0.01032967f, -0.02276329f, 0.04906452f, -0.00209457f, 0.02799288f, 0.04665478f, -0.07352667f, 
    -0.09631722f, -0.09981348f, -0.28354022f, -0.00249153f, -0.01489752f, 0.05643451f, 0.06574531f, -0.09585347f, 
    0.04298007f, 0.22296605f, -0.04588196f, -0.14264204f, 0.36572644f, 0.59808499f, -0.05187505f, -0.03707332f, 
    0.27114308f, 0.01951076f, 0.05773151f, 0.02369441f, -0.14959320f, 0.02185403f, -0.07348260f, 0.04526948f, 
    0.03001797f, 0.19649623f, -0.46434939f, 0.21625318f, 0.04825072f, 0.14048314f, -0.17183492f, 0.04056102f, 
    0.13742261f, -0.10298040f, -0.13169014f, -0.02955385f, 0.17785555f, 0.24840680f, 0.01396913f, -0.04572988f, 
    0.13724835f, 0.05867929f, 0.08680981f, 0.18802400f, 0.03357247f, -0.06785719f, -0.12866378f, -0.11134385f, 
    0.28377676f, 0.17756067f, 0.15657592f, 0.01582459f, 0.12838674f, -0.12357975f, 0.11747535f, 0.30501497f, 
    -0.02199479f, -0.03043927f, -0.01323160f, 0.16511244f, 0.02919111f, -0.01215409f, 0.00587018f, -0.03546543f, 
    0.13528228f, 0.02887867f, -0.07691832f, 0.02753757f, -0.11727287f, -0.25104836f, -0.14055471f, 0.07215195f, 
    0.39403200f, 0.03639803f, 0.24628769f, -0.21784735f, 0.14704749f, -0.02943859f, -0.01971564f, -0.08505291f, 
    0.07546750f, 0.16815662f, -0.00509376f, 0.11799161f, -0.29605711f, -0.00135112f, -0.24493410f, -0.09206749f, 
    0.01152182f, 0.08959619f, -0.03449377f, 0.03172357f, -0.03919275f, 0.06036681f, 0.10016944f, 0.03222943f, 
    0.11790000f, 0.07575578f, 0.21787600f, -0.19411655f, 0.06368781f, 0.24299949f, 0.17410730f, 0.09660129f, 
    0.06250630f, 0.02789730f, -0.01451750f, 0.04569054f, 0.57468599f, 0.11967818f, 0.23579636f, 0.04430114f, 
    -0.06189227f, 0.11615386f, -0.12872756f, 0.13038939f, -0.02184606f, -0.07255623f, -0.01884320f, 0.07150154f, 
    -0.41292435f, 0.25014889f, 0.08495718f, -0.18439843f, -0.07748742f, 0.03734217f, -0.01974296f, -0.01830911f, 
    -0.01502431f, -0.04703471f, -0.03601972f, 0.16913661f, -0.29321319f, -0.27023357f, -0.05802337f, 0.05772745f, 
    0.10092163f, -0.08896598f, -0.12062519f, 0.12861489f, 0.18126945f, 0.05879258f, 0.04390745f, 0.01846176f, 
    -0.11974961f, -0.27239671f, 0.12252412f, -0.50475913f, -0.00350624f, -0.16879234f, -0.16858791f, 0.02188866f, 
    0.23165226f, -0.17097786f, 0.04268102f, 0.10216863f, -0.24199493f, -0.14251050f, -0.20289309f, 0.19897623f, 
    0.03260137f, 0.11687240f, -0.07316614f, -0.14091788f, 0.16172962f, 0.19654348f, 0.33494779f, 0.11030163f, 
    0.01321804f, -0.14658755f, -0.12556668f, 0.03188464f, 0.00416764f, -0.07220510f, -0.18778065f, 0.02964343f, 
    0.14780602f, 0.04477989f, -0.13777585f, -0.02788289f, 0.05445217f, -0.44618487f, -0.17974904f, 0.25204530f, 
    -0.07208724f, 0.08194432f, -0.07514175f, 0.07270645f, -0.09074272f, -0.08809327f, 0.00645894f, -0.02976705f, 
    -0.05577189f, -0.01773902f, 0.03791913f, 0.04766379f, -0.03827606f, -0.04868378f, 0.01990248f, -0.04790607f, 
    -0.02898897f, -0.06828614f, 0.00258613f, 0.00709662f, 0.06210392f, 0.00914140f, -0.00526451f, -0.05988381f, 
    -0.06939434f, 0.01995095f, -0.06037913f, 0.00026106f, 0.05479970f, -0.00136371f, 0.00145228f, 0.01283139f, 
    -0.05984348f, -0.03844945f, 0.00657847f, -0.06864107f, -0.03634209f, 0.00124693f, -0.04620803f, -0.02210980f, 
    -0.06977738f, -0.04597530f, -0.04094553f, 0.03788660f, 0.00212950f, 0.05864227f, -0.07681935f, -0.04687550f, 
    -0.00927311f, 0.04659820f, -0.03952587f, -0.06597829f, 0.05191335f, 0.01302308f, 0.06219588f, -0.03723489f, 
    -0.03800527f, -0.02999651f, 0.05666374f, -0.05760112f, -0.06452243f, 0.04097150f, -0.00980584f, 0.04554345f, 
    -0.06446495f, -0.01889945f, 0.02767241f, -0.07251218f, -0.01674788f, 0.04077080f, -0.00471208f, 0.02174759f, 
    -0.07798040f, 0.05018786f, 0.03347251f, 0.05305210f, 0.01575746f, -0.03938064f, -0.06695148f, -0.02694008f, 
    0.04320102f, -0.02758575f, -0.01308472f, -0.07800955f, 0.06459242f, -0.03821591f, 0.02508116f, 0.00393047f, 
    0.00751454f, -0.07156757f, -0.01199055f, 0.01448795f, 0.04491691f, -0.03187537f, -0.07130093f, 0.06376608f, 
    0.00229632f, 0.03822925f, 0.06281511f, 0.03207237f, -0.01794278f, -0.01254065f, -0.01194926f, 0.03550817f, 
    0.04921165f, 0.04061078f, -0.02109855f, -0.04305028f, 0.04592787f, -0.02859932f, -0.05095889f, -0.00977732f, 
    -0.04073404f, 0.03406130f, 0.03501794f, 0.03110003f, 0.01669367f, -0.02564570f, -0.00398611f, -0.03914786f, 
    -0.02265961f, 0.05645221f, 0.04890983f, -0.06786882f, -0.05200443f, -0.06162125f, -0.04538995f, -0.00460167f, 
    -0.05177300f, -0.01316218f, 0.02413962f, -0.04787362f, -0.06498354f, -0.04683569f, 0.02440415f, 0.01033257f, 
    0.05181412f, -0.04695583f, -0.01380006f, -0.04772736f, 0.04811008f, 0.00178648f, -0.07245982f, -0.03775642f, 
    -0.06471115f, -0.00757197f, -0.00404864f, -0.05507454f, 0.05036682f, 0.05255091f, -0.03788685f, 0.02498434f, 
    0.06653585f, 0.02413696f, 0.01869137f, 0.03041772f, -0.06406031f, -0.07693494f, -0.05489558f, -0.01459423f, 
    -0.03367357f, -0.04220781f, -0.03052184f, 0.05403463f, -0.05674009f, -0.00232880f, -0.04575106f, -0.03054234f, 
    0.04851545f, -0.07092580f, 0.04862482f, 0.00127722f, -0.02366049f, 0.03802525f, 0.06296686f, -0.02982540f, 
    -0.00427733f, -0.00951594f, -0.06342156f, -0.02102429f, 0.01587682f, -0.05623661f, -0.03819351f, 0.04155841f, 
    0.02593859f, -0.04214341f, -0.04511016f, 0.03602394f, -0.02487316f, -0.03402402f, -0.03760066f, -0.04770138f, 
    -0.01266651f, -0.05599619f, -0.00521247f, 0.04432375f, 0.05658335f, -0.05732529f, -0.01583266f, -0.07691000f, 
    -0.01125261f, 0.00757949f, -0.04412869f, -0.00033627f, 0.01965512f, 0.03499035f, 0.00180667f, -0.01366198f, 
    -0.05651478f, -0.01636143f, 0.05247656f, 0.02955292f, 0.03071458f, -0.06912412f, 0.01867853f, -0.07358520f, 
    -0.07152634f, -0.00838456f, -0.07156815f, -0.00270383f, 0.04632088f, 0.03419167f, -0.02196457f, -0.05735436f, 
    0.02828438f, -0.05284794f, 0.04139784f, -0.03202200f, -0.04894571f, 0.02052291f, -0.04540621f, -0.02960443f, 
    0.03531136f, -0.03786105f, 0.00892306f, -0.03362987f, 0.03538553f, -0.03705028f, 0.02329263f, 0.01770500f, 
    0.05874620f, 0.06077684f, -0.07301465f, -0.06398910f, 0.03676963f, 0.01851208f, -0.01941524f, 0.02733299f, 
    0.03887822f, -0.03342886f, -0.01786612f, -0.06161057f, 0.03457432f, -0.00624750f, 0.02528307f, 0.00752201f, 
    0.02585498f, -0.03992349f, -0.00605006f, -0.03112521f, 0.02009915f, -0.03704246f, 0.02081885f, -0.03401744f, 
    -0.05259740f, -0.07376887f, -0.04156574f, 0.04418588f, -0.05312571f, -0.07537236f, 0.03792077f, -0.06997266f, 
    0.04101283f, 0.01973386f, 0.04993651f, 0.00222829f, -0.00204408f, -0.01330996f, 0.01623404f, -0.05718346f, 
    0.02468813f, -0.06026896f, -0.04897128f, -0.06897064f, -0.06546693f, 0.04849218f, -0.05949046f, -0.06570409f, 
    -0.08010100f, 0.04844766f, 0.05338525f, 0.01988143f, -0.00040235f, 0.04887385f, -0.03541883f, 0.05392826f, 
    0.02661479f, -0.03644387f, -0.04014340f, 0.05129956f, -0.01114499f, -0.00766698f, -0.03381502f, -0.06768321f, 
    -0.06206291f, 0.04529357f, -0.06003552f, 0.00373567f, 0.01773702f, 0.03881684f, 0.00809554f, 0.00178514f, 
    -0.02321205f, 0.01375370f, -0.01410916f, 0.04562342f, -0.03047713f, 0.01664663f, 0.00338544f, 0.05128603f, 
    0.03238988f, 0.02244295f, 0.00610118f, -0.01018816f, 0.05329326f, 0.01435808f, 0.04580241f, 0.01423301f, 
    0.00675428f, 0.04329134f, 0.01645995f, -0.01348337f, 0.01168064f, -0.01531506f, -0.02282235f, 0.01533746f, 
    0.04775992f, -0.06250266f, -0.07316894f, 0.04188896f, -0.04435080f, -0.04783992f, -0.05515177f, -0.00986026f, 
    -0.07885823f, -0.06821339f, -0.08265439f, 0.01875459f, 0.00761312f, 0.04253824f, 0.00571598f, -0.05096928f, 
    0.03516496f, 0.05884653f, 0.06311643f, -0.00910303f, 0.05181077f, -0.01918782f, -0.06020863f, -0.00873843f, 
    0.02661866f, -0.02341872f, -0.07142781f, 0.05599916f, -0.03542168f, -0.00194058f, 0.01656806f, -0.06587531f, 
    -0.06182753f, 0.01488405f, -0.04287286f, -0.00062493f, -0.03972039f, -0.05872891f, 0.04548352f, 0.01608404f, 
    0.01938255f, 0.00023599f, -0.05658283f, 0.04741005f, -0.05938505f, -0.01190781f, -0.04584106f, -0.05778308f, 
    0.01224725f, 0.04850500f, -0.01928032f, -0.02666925f, -0.03345532f, -0.07001329f, -0.02693607f, 0.04780074f, 
    0.02711075f, 0.05312824f, 0.03171654f, 0.05206179f, -0.05379273f, 0.04066109f, 0.02488775f, 0.03395021f, 
    -0.00975966f, 0.03620486f, -0.02473638f, -0.01473661f, -0.05655747f, -0.04298043f, 0.04140466f, -0.03451102f, 
    0.02165377f, -0.06014926f, 0.04818365f, -0.05766363f, 0.01065390f, 0.03219906f, 0.05985202f, -0.02485794f, 
    -0.02841775f, 0.06164748f, 0.04497389f, -0.00416091f, 0.03266318f, -0.00688824f, -0.04147287f, 0.01912108f, 
    -0.06235591f, -0.03194672f, -0.04939160f, -0.05996192f, -0.05365828f, 0.05819081f, -0.06723160f, -0.06891899f, 
    0.00822877f, -0.07343581f, 0.05345669f, -0.04820423f, 0.03180992f, -0.03609976f, -0.00589480f, -0.02365105f, 
    -0.07781742f, -0.06913944f, -0.04449719f, -0.00691734f, -0.03391440f, 0.02905530f, -0.06611881f, 0.02532031f, 
    -0.05018583f, -0.01949668f, -0.06941031f, 0.03410832f, -0.01547014f, 0.02323044f, -0.04393868f, -0.03571285f, 
    0.03862122f, -0.01318058f, 0.03777266f, 0.03736058f, 0.03639317f, 0.01653215f, 0.04625496f, -0.06533146f, 
    -0.04077932f, -0.01609715f, -0.07334980f, -0.00239415f, 0.04009936f, -0.08178264f, -0.04925500f, -0.05089999f, 
    -0.02981567f, -0.00580958f, 0.02503879f, -0.05654141f, 0.05850533f, -0.04717504f, -0.05853928f, 0.01790745f, 
    -0.02030210f, 0.00893257f, 0.00710736f, 0.05004372f, -0.06208107f, -0.02932609f, -0.06021624f, 0.03814239f, 
    0.02913279f, -0.00980083f, -0.02509397f, 0.01671505f, 0.04238999f, 0.03923940f, -0.00061305f, -0.04802848f, 
    -0.05971056f, 0.00664873f, -0.04856023f, -0.00954738f, 0.01509449f, -0.05692418f, -0.06974962f, 0.03306451f, 
    -0.07229636f, 0.05272484f, 0.04632548f, -0.00194155f, 0.04333293f, -0.06465606f, -0.06073033f, -0.07226071f, 
    0.05893872f, -0.03108214f, 0.02104342f, 0.03500876f, 0.03477471f, -0.02233152f, 0.06481989f, 0.03538038f, 
    -0.03972087f, -0.01602988f, 0.02512618f, -0.05276282f, 0.00564944f, -0.07147684f, -0.06595572f, -0.00675479f, 
    -0.01919601f, 0.03809477f, 0.06338464f, 0.01187005f, 0.00430226f, 0.00364000f, -0.02795283f, -0.06997692f, 
    -0.00047926f, 0.03581921f, -0.02979137f, -0.05398282f, -0.02012613f, -0.03700970f, 0.05850408f, -0.00957634f, 
    0.04433382f, 0.03061470f, -0.07179542f, -0.06670718f, -0.07054719f, -0.04564218f, -0.06670600f, 0.01287254f, 
    -0.01833602f, -0.02107703f, -0.00629891f, -0.03242750f, 0.06444557f, -0.06665800f, -0.03378841f, 0.06089842f, 
    0.04360243f, 0.04006469f, -0.00596178f, -0.02313666f, -0.00093250f, -0.00880183f, 0.01930387f, -0.04169652f, 
    -0.06083183f, 0.04077535f, 0.01781104f, 0.05104351f, 0.00784702f, 0.00601269f, 0.00690726f, 0.05273353f, 
    0.02152068f, -0.05774746f, 0.01521316f, -0.05052642f, 0.00699228f, -0.03417408f, 0.01333780f, 0.01555831f, 
    -0.09479341f, 0.08688179f, -0.28161418f, -0.10084642f, -0.00637657f, -0.01108727f, -0.13190334f, 0.01162742f, 
    -0.02698977f, -0.08980299f, -0.06458142f, 0.16055334f, 0.26481757f, 0.23185748f, -0.03640810f, -0.04000597f, 
    -0.17215073f, -0.01143554f, 0.15351659f, 0.36017528f, -0.04786601f, 0.15380628f, 0.16849427f, -0.09298220f, 
    -0.21507069f, 0.09893547f, 0.01273297f, 0.11340053f, 0.04585944f, -0.10517081f, 0.01112432f, 0.12494698f, 
    -0.04125030f, -0.10917617f, -0.13546380f, -0.00593747f, 0.32733333f, 0.05582243f, -0.34327051f, 0.13087147f, 
    -0.09119698f, -0.05223911f, 0.15920807f, 0.23413971f, 0.03657556f, 0.07620404f, -0.02489554f, 0.15725102f, 
    0.28092584f, 0.06507044f, 0.08096902f, 0.21468322f, 0.08271986f, 0.11839449f, -0.01256275f, 0.07102568f, 
    0.22920929f, 0.17667685f, -0.02802229f, -0.02002293f, 0.35527006f, -0.10627256f, 0.08617318f, 0.05147649f, 
    -0.06103116f, 0.10935410f, 0.19428167f, 0.04739108f, -0.07429829f, -0.11963469f, 0.05388245f, 0.05850800f, 
    -0.10350899f, 0.27390611f, 0.06766235f, 0.04359663f, 0.18421187f, -0.17457087f, -0.02602553f, -0.41877821f, 
    -0.06976973f, -0.00110917f, -0.11888345f, -0.27518848f, 0.02561508f, -0.08147868f, -0.01834368f, 0.57156301f, 
    0.01858953f, 0.07856608f, -0.18351988f, -0.40331078f, -0.01605562f, 0.08596728f, 0.06037927f, 0.09390438f, 
    0.40423670f, 0.30248886f, 0.14587234f, 0.19641189f, -0.11789822f, 0.25324839f, -0.08212332f, 0.13190635f, 
    0.15218987f, -0.15494916f, 0.02184296f, 0.00242648f, 0.14520206f, -0.07506416f, 0.06573486f, -0.16310285f, 
    0.11958253f, -0.12171186f, 0.22387853f, 0.22756013f, -0.11708270f, 0.00102174f, 0.00893126f, -0.18276259f, 
    0.01557048f, 0.48899257f, -0.14895067f, -0.23599479f, 0.09878427f, 0.15129878f, -0.05784229f, 0.03429838f, 
    0.08687302f, 0.09902051f, -0.14526385f, -0.01792469f, 0.14147390f, 0.04058617f, 0.17927794f, 0.25110468f, 
    -0.22951835f, 0.08792698f, -0.01612157f, -0.14333092f, 0.06005116f, 0.07300922f, -0.01751262f, 0.00450550f, 
    0.08673836f, -0.38288301f, 0.20261052f, 0.18296330f, -0.06328082f, -0.31470239f, -0.07146072f, -0.30066407f, 
    -0.15277685f, 0.04480372f, 0.01802996f, -0.14501761f, -0.10048787f, 0.11040757f, -0.07344221f, 0.06021198f, 
    0.10911486f, -0.01592359f, 0.02824775f, -0.00713365f, 0.03182420f, 0.01275565f, 0.05392583f, -0.05871027f, 
    0.03038752f, 0.09132157f, -0.01554539f, -0.26291570f, 0.24093559f, 0.16317591f, 0.00163762f, 0.07958763f, 
    -0.14925930f, -0.01024873f, -0.16226690f, -0.06450490f, -0.17972857f, 0.02574757f, -0.19506738f, -0.05501321f, 
    0.03203712f, 0.01169545f, -0.06621734f, -0.59500331f, 0.01119772f, -0.01008013f, -0.01960195f, 0.11806893f, 
    -0.02821108f, -0.06859217f, -0.01875570f, 0.03807698f, -0.04777991f, 0.06063792f, 0.00528355f, -0.05456231f, 
    0.01578978f, -0.04240843f, -0.01097159f, 0.00502328f, -0.01622359f, -0.04233276f, -0.05676769f, 0.04879171f, 
    -0.05579662f, 0.03156446f, 0.01179272f, 0.03776386f, -0.01200439f, -0.02671294f, 0.06216664f, -0.01410118f, 
    0.00449257f, -0.03801462f, -0.01118633f, -0.01737188f, 0.02255705f, -0.05460553f, 0.04916862f, -0.07475617f, 
    0.05693072f, -0.01681038f, -0.02354196f, -0.05330637f, 0.02881487f, 0.05914735f, -0.04077434f, -0.06071278f, 
    0.06511340f, 0.02656989f, 0.01464675f, -0.05459518f, 0.05339877f, 0.05670903f, 0.04739767f, -0.04158603f, 
    -0.04982257f, -0.08128083f, 0.01164401f, 0.00802502f, -0.03018886f, 0.05179344f, -0.04308531f, 0.02716665f, 
    -0.04595629f, 0.00656123f, 0.00019457f, 0.03722984f, -0.06493257f, -0.06997767f, -0.02855778f, -0.02581934f, 
    0.03278636f, -0.05803287f, 0.01443767f, -0.02969392f, 0.00248178f, -0.01214360f, -0.01115764f, -0.05007867f, 
    0.00257708f, -0.04863034f, -0.02897959f, -0.00365574f, 0.00482099f, 0.02770028f, -0.02731872f, 0.06662912f, 
    0.01333866f, -0.07973098f, -0.08201338f, -0.03891923f, -0.03308618f, -0.00221173f, 0.04076803f, 0.04957428f, 
    0.02098791f, -0.01184685f, -0.00097328f, -0.07825538f, 0.04487051f, -0.02176851f, -0.06544983f, 0.01685564f, 
    0.03246644f, -0.03652753f, 0.04858151f, -0.07816005f, -0.00688486f, -0.02319829f, -0.02847411f, 0.05450038f, 
    0.04822067f, -0.02941390f, 0.04445361f, -0.05851965f, -0.02801961f, -0.03762788f, -0.00406676f, -0.00042141f, 
    -0.07390370f, 0.06164497f, 0.05082412f, 0.04558624f, -0.05930426f, -0.06197257f, -0.04670620f, 0.02590683f, 
    0.01109947f, 0.00177876f, -0.05825276f, -0.04327350f, -0.01882066f, 0.01061489f, -0.04405515f, 0.01994843f, 
    -0.05374098f, -0.07524294f, 0.04392461f, -0.03306618f, 0.03361609f, 0.03564595f, -0.03737311f, -0.01431906f, 
    -0.04740153f, 0.05872554f, -0.04705790f, -0.00551466f, -0.03491421f, -0.01438572f, -0.03370996f, 0.03699606f, 
    -0.02041976f, -0.06550923f, -0.04598856f, -0.00767229f, 0.00177042f, -0.00154341f, -0.01280528f, -0.04535762f, 
    -0.01093458f, 0.00465543f, 0.04764530f, -0.07144093f, 0.05651275f, -0.06201411f, -0.05915588f, -0.07985503f, 
    -0.05145211f, -0.07561725f, 0.02255839f, 0.05988760f, 0.00778024f, -0.03943967f, -0.06134623f, 0.01118300f, 
    -0.02698649f, 0.00185589f, -0.02073863f, -0.07099079f, -0.02444449f, 0.04055757f, 0.06035187f, 0.06301166f, 
    0.00496269f, -0.04784317f, 0.04913286f, -0.07821733f, 0.04131486f, -0.00645268f, -0.01805364f, -0.01557907f, 
    -0.06373402f, 0.04037111f, 0.01765088f, -0.03303271f, 0.05638964f, 0.02123263f, -0.05090469f, -0.00204721f, 
    0.23058338f, 0.01000648f, -0.03382921f, 0.02318374f, 0.11344466f, 0.09326686f, 0.12847923f, 0.18313293f, 
    -0.06990309f, 0.00480582f, 0.14697649f, 0.15936922f, -0.39884382f, -0.02995765f, 0.03056709f, -0.18722413f, 
    -0.02116011f, -0.00629299f, -0.00431116f, 0.14194560f, 0.00557637f, -0.05988943f, -0.01810903f, 0.06265675f, 
    0.11607554f, 0.21000871f, 0.15397906f, 0.16172749f, 0.06232023f, 0.08116040f, -0.01773024f, -0.03975052f, 
    -0.07327716f, -0.07005296f, -0.00244336f, 0.03461197f, -0.15603830f, 0.28042981f, 0.00579889f, -0.12794600f, 
    -0.13431285f, 0.09905681f, -0.01500859f, 0.01980234f, -0.04114890f, -0.15563819f, -0.18067409f, 0.10302981f, 
    0.09075585f, -0.15424952f, -0.03651472f, -0.12498157f, 0.17214066f, 0.08577076f, -0.11170746f, -0.05116027f, 
    0.06709257f, -0.10519759f, 0.23545301f, -0.09752540f, -0.23199621f, -0.15611011f, 0.10245584f, -0.14474431f, 
    0.09737755f, 0.02739103f, -0.09019002f, 0.15270464f, 0.14261054f, -0.02416562f, -0.04317290f, -0.18277112f, 
    0.34554699f, -0.12801090f, 0.06737334f, 0.05342834f, 0.09143338f, 0.11697470f, -0.31890777f, -0.11657394f, 
    0.08937602f, 0.06489506f, -0.10359509f, 0.03510044f, -0.17187658f, -0.13514164f, -0.19817643f, -0.11272864f, 
    -0.06731499f, -0.01066050f, -0.10203274f, -0.06004404f, 0.16449909f, 0.07573410f, -0.02102564f, 0.02178754f, 
    -0.32045850f, 0.10513923f, 0.05387001f, -0.14454111f, 0.20694108f, -0.14413542f, 0.12768036f, 0.18499844f, 
    -0.08219810f, -0.02629876f, 0.01292365f, -0.03912035f, -0.15364827f, 0.09997641f, 0.25373116f, 0.18921801f, 
    0.14141780f, -0.04482589f, 0.23211531f, 0.04762921f, 0.08717026f, 0.02497094f, 0.05448560f, -0.04416145f, 
    -0.48797166f, 0.10940079f, 0.10560929f, 0.02676555f, 0.33508584f, -0.05243750f, 0.09407310f, 0.18770893f, 
    0.06095686f, 0.00146914f, -0.09034891f, 0.14053464f, 0.19848266f, 0.19811895f, 0.08023264f, 0.04389218f, 
    -0.01352050f, -0.01281003f, 0.00308006f, -0.06610990f, 0.04780237f, 0.01983140f, 0.04403723f, -0.01835090f, 
    0.42665333f, 0.43788850f, 0.61216623f, -0.02772575f, 0.11899471f, -0.02543898f, 0.02743087f, 0.08939291f, 
    0.22304271f, 0.25445026f, 0.09416474f, 0.01180998f, 0.29103348f, -0.08412992f, -0.02167128f, 0.17734577f, 
    -0.04375626f, 0.05833417f, 0.17162126f, 0.03112503f, 0.14873931f, 0.26573715f, 0.16864988f, 0.02711866f, 
    -0.10068798f, 0.08129262f, -0.12431730f, -0.06494764f, 0.15293047f, 0.19545719f, 0.07574291f, 0.13981977f, 
    -0.08699451f, 0.07515626f, 0.06944682f, 0.12144273f, -0.21465749f, -0.20625491f, -0.22648722f, -0.10214374f, 
    0.00648409f, 0.00351096f, -0.06878486f, 0.06678381f, -0.10176708f, 0.10274681f, -0.04290676f, -0.03083250f, 
    0.01256415f, -0.04752815f, 0.04428439f, -0.01388845f, 0.00441791f, -0.04705067f, 0.04860703f, 0.06501019f, 
    0.05525955f, -0.06487672f, 0.00208715f, -0.05914615f, 0.04642642f, 0.02346154f, 0.01580737f, -0.06840853f, 
    -0.02571798f, 0.05364881f, 0.04521403f, -0.06345946f, -0.02544606f, 0.00278329f, -0.02779290f, -0.00733084f, 
    -0.01501155f, -0.02479005f, -0.00720774f, -0.03011086f, -0.03414096f, -0.05643823f, 0.04493081f, 0.05884905f, 
    -0.05989960f, -0.03716032f, -0.06681345f, -0.03893523f, -0.04102374f, -0.05686118f, -0.05842785f, 0.06546359f, 
    -0.04174081f, 0.02337778f, -0.06225621f, -0.00775551f, -0.03376947f, -0.06428278f, -0.04017538f, -0.06632767f, 
    0.02104158f, 0.05786241f, -0.01487938f, 0.02854364f, 0.01792934f, 0.03051308f, 0.05409264f, -0.06802871f, 
    -0.04443748f, -0.03807580f, 0.05013483f, -0.06378373f, 0.02831250f, -0.06024766f, -0.04260898f, -0.03943335f, 
    0.03198118f, 0.05338438f, -0.02689922f, -0.03940755f, -0.05782217f, -0.02603043f, -0.06689269f, 0.02148009f, 
    -0.01676262f, 0.04099697f, -0.02220138f, -0.07511296f, 0.04479365f, -0.05443979f, 0.00414421f, -0.00216875f, 
    0.06706321f, -0.04575101f, 0.06352462f, 0.06365825f, -0.01428718f, -0.06894954f, 0.07031000f, -0.04901045f, 
    -0.05278068f, 0.03148417f, 0.01588921f, -0.02601648f, -0.01987386f, 0.01608060f, -0.01422551f, -0.02787921f, 
    -0.00443918f, -0.04467382f, 0.02028300f, 0.00805020f, -0.03680870f, -0.01460168f, -0.01969596f, 0.07476018f, 
    0.06256606f, 0.04804648f, -0.07231138f, -0.02162357f, -0.02429257f, -0.04928799f, 0.03924887f, 0.02871399f, 
    0.04817723f, 0.04122675f, 0.02359157f, 0.06570164f, -0.04193822f, -0.04059811f, -0.05538194f, -0.05003558f, 
    -0.04432621f, -0.00051716f, 0.00048586f, 0.00247762f, -0.02845348f, -0.05652002f, -0.01173585f, 0.00255260f, 
    -0.03272121f, -0.04545003f, 0.04360056f, -0.03235749f, -0.07069519f, -0.03341716f, 0.03423091f, -0.00373139f, 
    0.02677803f, -0.07226336f, 0.06572019f, -0.02324222f, 0.05801844f, -0.02602917f, -0.03489742f, 0.01657839f, 
    0.01957480f, -0.07625426f, 0.01225288f, -0.02977888f, -0.04031261f, 0.00673070f, -0.03259930f, -0.00497628f, 
    -0.00495935f, -0.00529867f, 0.04566108f, 0.05141997f, -0.00253528f, 0.04162860f, 0.04555092f, -0.02134912f, 
    -0.03462190f, 0.04400850f, 0.00458091f, -0.05685724f, -0.04193954f, -0.01726483f, -0.06521444f, 0.00559414f, 
    -0.02923680f, 0.00366655f, 0.04900053f, -0.07026812f, -0.01630289f, -0.07608013f, -0.00709038f, 0.02785661f, 
    0.00725649f, -0.02214389f, -0.04336354f, -0.05615867f, 0.01844869f, 0.00980983f, 0.05353181f, -0.06103293f, 
    0.05804433f, 0.03867784f, -0.05448064f, -0.05313218f, 0.00601162f, -0.02667884f, 0.05670145f, -0.05524057f, 
    -0.06890528f, -0.02778585f, -0.05031128f, -0.00796815f, -0.07521030f, -0.04073031f, -0.01232171f, 0.04795784f, 
    0.00947409f, -0.01309947f, 0.03254149f, 0.04139695f, 0.03313485f, -0.07015999f, 0.00803474f, 0.00912486f, 
    -0.03854670f, -0.01869383f, 0.03677899f, 0.00184263f, -0.05241166f, 0.01066746f, 0.00752586f, -0.02900722f, 
    -0.00381895f, 0.00524095f, -0.07640340f, 0.04638182f, -0.00087122f, 0.03429557f, -0.04770470f, -0.01624290f, 
    -0.06085100f, -0.06392978f, -0.02830449f, 0.01908895f, -0.00758514f, -0.04662029f, 0.01054820f, -0.06213871f, 
    0.03217613f, 0.05896761f, -0.00539937f, -0.07338915f, -0.00612512f, -0.00622644f, -0.02211674f, 0.02963236f, 
    0.00088982f, -0.03881090f, -0.06390833f, 0.06433881f, -0.06769646f, 0.05777548f, -0.07419275f, 0.01805264f, 
    -0.00340781f, -0.04112924f, 0.01563137f, 0.03518372f, -0.06876161f, -0.02863455f, 0.06118959f, -0.05176073f, 
    -0.04342555f, -0.03026287f, 0.01205295f, 0.02167730f, -0.08004230f, 0.00747451f, -0.00834952f, -0.01520924f, 
    -0.06838582f, -0.01558978f, 0.04212086f, -0.00495393f, 0.04152970f, 0.03629107f, 0.01667940f, -0.06659835f, 
    -0.05552298f, 0.05518904f, -0.00502527f, -0.03848668f, -0.01106854f, -0.07422192f, 0.03060054f, 0.06100756f, 
    0.01221853f, 0.06436828f, -0.02837294f, -0.05130085f, -0.00388339f, -0.06881376f, -0.00156581f, -0.01779530f, 
    0.06388719f, -0.08083665f, 0.01060710f, -0.02349322f, -0.01444510f, 0.03932605f, 0.03853927f, -0.06990251f, 
    0.01692646f, -0.04992848f, 0.05772098f, -0.07010769f, 0.04074482f, 0.04416582f, 0.03174350f, -0.02414025f, 
    -0.02075966f, -0.06958853f, -0.07364958f, 0.05595681f, -0.07588530f, -0.07448749f, -0.01200508f, -0.04484795f, 
    -0.00767856f, 0.06272503f, -0.07652184f, 0.04032690f, -0.06328128f, -0.03759537f, -0.00629362f, -0.00867917f, 
    0.04795527f, 0.05971487f, 0.00372077f, 0.03216802f, 0.01983769f, 0.05813481f, 0.06226147f, -0.00361943f, 
    -0.07495505f, -0.05136302f, -0.03459749f, 0.00493471f, 0.04446523f, -0.04042342f, -0.05388993f, 0.04792541f, 
    0.04719106f, 0.03554428f, -0.08104008f, -0.03442520f, -0.08040854f, -0.03246812f, -0.03411446f, 0.06148149f, 
    -0.02783061f, -0.01806765f, -0.02591877f, 0.00105970f, -0.07358181f, 0.00274855f, 0.05822412f, -0.03159098f, 
    -0.01362125f, 0.02134397f, 0.00972297f, 0.05127493f, -0.05405835f, -0.00143903f, -0.03723204f, -0.07033291f, 
    0.03754527f, -0.07864072f, 0.05522996f, 0.04347996f, -0.07315329f, 0.05107664f, 0.04723050f, 0.02005229f, 
    0.01837204f, -0.07359886f, -0.00787952f, 0.05382603f, 0.00147143f, 0.01759115f, -0.03181285f, -0.05529587f, 
    -0.05280357f, 0.03580513f, 0.00149629f, -0.02720252f, -0.00136855f, -0.05737306f, 0.01861616f, 0.05844674f, 
    -0.22818634f, 0.36338171f, 0.16850379f, -0.00839618f, 0.21217726f, 0.03011806f, 0.25287837f, -0.16406927f, 
    -0.16969274f, -0.39036185f, -0.34688532f, -0.05220123f, -0.17177579f, -0.09493699f, -0.05088136f, 0.13458860f, 
    -0.09095261f, -0.06150819f, 0.14932732f, 0.22076409f, 0.04845041f, -0.12695882f, 0.06888922f, -0.29848671f, 
    -0.07833562f, 0.14003690f, 0.20487475f, -0.04430256f, 0.12124611f, 0.04066693f, 0.26226708f, -0.04174843f, 
    -0.15442367f, -0.29163513f, 0.00284201f, -0.15996231f, -0.03714900f, -0.04567134f, 0.35332438f, 0.22126342f, 
    0.14753149f, 0.03276735f, 0.25044850f, 0.08964182f, 0.27553356f, 0.11810341f, 0.15959506f, 0.13492626f, 
    -0.21510272f, -0.25528613f, -0.14152984f, 0.21318774f, -0.00735942f, 0.16024047f, 0.11291714f, 0.04274744f, 
    0.23361155f, 0.25567347f, 0.11835327f, 0.12078688f, -0.05652662f, 0.08630307f, 0.13398267f, 0.22610307f, 
    -0.25021878f, 0.07165274f, 0.21350548f, 0.19251530f, 0.03623792f, 0.08645411f, -0.02145395f, 0.29022995f, 
    -0.04217453f, -0.53621060f, 0.02479856f, 0.13137931f, 0.01960632f, -0.01412943f, 0.08787446f, -0.23003790f, 
    -0.18311954f, 0.00329962f, -0.36947697f, -0.34365830f, 0.27970320f, 0.03565374f, 0.18890809f, 0.20801909f, 
    0.08440644f, -0.19598649f, -0.05398847f, -0.04009098f, 0.24430561f, 0.26261517f, 0.21112444f, 0.18157898f, 
    -0.27772072f, -0.39274225f, -0.01496616f, 0.26097628f, -0.22278591f, 0.01313734f, -0.03905578f, 0.01861117f, 
    0.03668986f, -0.09887793f, -0.01234824f, 0.17379227f, -0.30954850f, -0.22630292f, -0.04770390f, 0.16021380f, 
    -0.08784661f, -0.03497037f, -0.00896821f, 0.12820232f, -0.05319427f, -0.10093236f, 0.08114034f, -0.01392262f, 
    0.26610100f, -0.33194754f, -0.19046183f, 0.41010883f, 0.10376482f, -0.09457096f, -0.11176848f, -0.17663135f, 
    -0.02908640f, 0.05362585f, 0.19023225f, 0.28905192f, -0.05277270f, -0.44458503f, -0.25078282f, -0.34598464f, 
    0.02081203f, 0.05519953f, -0.12418246f, -0.16292804f, 0.01771102f, -0.04849424f, -0.04338641f, 0.00395381f, 
    0.07730564f, -0.51379234f, 0.20347954f, -0.14661773f, 0.25158361f, 0.04414209f, -0.43268389f, 0.11182517f, 
    0.05701692f, 0.11156612f, 0.15752962f, 0.00525174f, 0.08463095f, 0.35381052f, -0.04782179f, 0.06040824f, 
    0.10221834f, -0.00414160f, 0.02465474f, 0.00871075f, -0.08042437f, -0.04898736f, -0.03211642f, 0.04375299f, 
    0.03149366f, 0.22851433f, 0.02363643f, 0.00524983f, -0.06202896f, 0.04582221f, -0.07118346f, -0.19623652f, 
    -0.34698114f, -0.33100471f, -0.43185505f, -0.59560996f, 0.62032115f, 0.40094563f, 0.13980757f, 0.27705780f, 
    0.04328501f, -0.05383759f, 0.11188437f, 0.00524377f, 0.03998837f, -0.12063120f, 0.06163161f, 0.09795496f, 
    -0.02309563f, 0.03847468f, 0.02396187f, -0.02742190f, -0.08632719f, -0.01015154f, -0.05554471f, 0.05638893f, 
    -0.02142237f, -0.06394660f, 0.04965587f, -0.06719837f, -0.04998127f, -0.02194946f, 0.02184573f, -0.01443007f, 
    -0.08307422f, -0.07274876f, 0.04322810f, 0.03573447f, 0.03727766f, -0.01157866f, 0.05597240f, -0.03901305f, 
    -0.08523108f, 0.04036795f, -0.02537030f, -0.05993874f, 0.00352981f, -0.04398098f, -0.05447019f, -0.00212520f, 
    0.05939442f, 0.01107077f, -0.01815324f, -0.03313261f, -0.04829615f, -0.01567701f, -0.04177351f, -0.00882293f, 
    -0.02951532f, 0.04370566f, 0.02380769f, -0.00447679f, -0.04906411f, -0.00906926f, -0.06362239f, -0.00090107f, 
    -0.05543008f, -0.04200241f, 0.03039177f, -0.01410099f, 0.01684037f, -0.03131821f, -0.00188086f, 0.04664080f, 
    0.05402854f, 0.03772669f, -0.06846138f, -0.02114946f, 0.00925636f, 0.01744844f, 0.02567906f, 0.05643958f, 
    -0.00495502f, -0.03928198f, 0.03737845f, -0.06435394f, 0.05430044f, -0.01749173f, -0.08644532f, 0.03738560f, 
    -0.06767898f, -0.05561763f, 0.03072237f, -0.03420427f, 0.04101840f, -0.04932447f, -0.03773202f, -0.03544955f, 
    -0.06620152f, 0.03149298f, -0.06095288f, -0.06311850f, 0.00696175f, 0.02360841f, 0.02258361f, 0.03967093f, 
    0.02668278f, -0.03905343f, -0.01990840f, 0.05662125f, 0.02866794f, -0.01661452f, 0.03269149f, -0.00733054f, 
    -0.02978451f, -0.02103837f, 0.00567152f, 0.01793112f, 0.01569418f, -0.07352913f, 0.04553123f, -0.05734089f, 
    -0.04896768f, -0.07794731f, -0.02748130f, -0.08254998f, -0.03616696f, 0.02189090f, -0.06049032f, 0.07157637f, 
    -0.00967178f, 0.05153454f, -0.00614963f, 0.06911986f, 0.03553540f, 0.05230898f, -0.05375126f, -0.02624949f, 
    -0.04043917f, -0.05817945f, -0.00412137f, -0.02853383f, 0.02045547f, 0.03314298f, -0.04322378f, -0.02779075f, 
    0.02737009f, -0.01099108f, -0.04373208f, -0.01907114f, -0.01907072f, -0.02261956f, 0.02088141f, -0.03073628f, 
    0.04307506f, 0.02951012f, 0.05373552f, -0.03595702f, 0.01304861f, -0.06060141f, 0.01016295f, -0.03754110f, 
    0.03464952f, -0.07625587f, -0.07091857f, 0.00990352f, 0.05385433f, 0.05156669f, 0.01904029f, 0.03181649f, 
    -0.00800255f, -0.02082990f, 0.03520886f, 0.02832047f, 0.04076900f, 0.04699670f, 0.01858591f, -0.03915733f, 
    -0.06040036f, 0.03342604f, 0.05558772f, 0.04131277f, -0.06125852f, -0.01055681f, -0.04577406f, -0.02762957f, 
    0.04046208f, -0.00580667f, -0.05464773f, 0.03927549f, 0.03333224f, 0.04643231f, 0.03232607f, -0.07491003f, 
    0.04358222f, -0.07775377f, -0.05774443f, 0.06020210f, -0.06571972f, 0.04596110f, -0.07371852f, -0.01808851f, 
    -0.00312555f, -0.06106820f, 0.03472171f, -0.07576513f, -0.05825223f, -0.04721065f, -0.00822940f, -0.05777904f, 
    -0.27323708f, -0.32271791f, -0.42874712f, -0.04740147f, 0.09465402f, 0.01734468f, -0.06657924f, 0.03917491f, 
    -0.04261547f, -0.00642238f, 0.24067523f, 0.05974884f, -0.42077994f, -0.43830299f, -0.07570175f, -0.06965403f, 
    0.25052696f, 0.24971834f, 0.01883308f, -0.07464228f, 0.01469174f, 0.10987189f, 0.16203359f, 0.01224130f, 
    -0.49420851f, 0.22584401f, 0.38635087f, -0.05867066f, 0.00907708f, -0.09747043f, -0.25030434f, -0.01360869f, 
    0.12127503f, -0.17125551f, -0.04183342f, 0.12349309f, 0.12719849f, 0.09318756f, 0.05991467f, 0.24856727f, 
    -0.13972145f, -0.05770239f, 0.03621157f, -0.14652337f, -0.06002775f, -0.09506650f, 0.00581933f, -0.00829981f, 
    0.01224941f, 0.14896169f, -0.03168670f, -0.10311882f, 0.06396437f, 0.00328361f, -0.10296902f, 0.10734413f, 
    0.16318926f, -0.07018466f, -0.03180169f, -0.22849944f, -0.20543790f, -0.41026697f, 0.09051614f, 0.33075202f, 
    0.20783566f, 0.45560953f, -0.09234251f, -0.03732174f, 0.03918697f, -0.02023344f, 0.14164045f, -0.05942442f, 
    0.24028321f, 0.18457860f, -0.27614081f, 0.16852413f, 0.05253763f, -0.00546337f, -0.11860949f, -0.33883595f, 
    0.05807786f, 0.06075110f, 0.21052977f, 0.17316689f, 0.24425344f, -0.23041077f, -0.20268111f, -0.21830067f, 
    0.06292524f, -0.07098513f, 0.00074781f, -0.13601075f, 0.13402985f, 0.09971594f, -0.00859074f, 0.06776310f, 
    0.07989493f, 0.12005996f, 0.07099363f, 0.24058133f, 0.21055757f, -0.01459766f, 0.10179227f, 0.17922343f, 
    0.00029660f, 0.06880587f, 0.03368634f, -0.01259021f, -0.01463225f, -0.11594306f, 0.05648932f, -0.10782975f, 
    0.04468200f, 0.12106887f, 0.23726445f, -0.11605646f, 0.15199058f, 0.11255208f, 0.19421178f, 0.19683999f, 
    0.51184511f, 0.22455813f, 0.33494624f, 0.24645141f, 0.26962823f, -0.03233419f, -0.14437251f, 0.12920600f, 
    0.01279087f, 0.25124040f, -0.24411175f, -0.01540079f, -0.19771017f, -0.12554921f, 0.18495646f, 0.03312995f, 
    -0.20448630f, -0.28017798f, -0.20071673f, -0.06169039f, -0.05913959f, -0.10231429f, -0.18259847f, 0.15563597f, 
    -0.06765609f, 0.03108329f, 0.02499826f, -0.03354779f, -0.14414248f, -0.08031913f, -0.16987014f, -0.04968461f, 
    0.12369741f, -0.00577391f, 0.26083449f, 0.08852310f, 0.00154221f, 0.13283844f, -0.03428798f, 0.44489720f, 
    0.03231527f, -0.04548284f, 0.05634808f, 0.02539732f, -0.08472207f, 0.22980800f, 0.18660134f, 0.01716825f, 
    -0.08330846f, -0.09143412f, -0.20802905f, 0.01709602f, 0.21726732f, 0.03158936f, -0.21325804f, 0.07829642f, 
    0.01495799f, 0.08072750f, 0.11165725f, 0.24753103f, -0.05774165f, -0.38994497f, -0.13540329f, 0.25928429f, 
    0.00884069f, 0.25580761f, 0.08735614f, 0.11818403f, -0.09902883f, -0.02005193f, -0.00674632f, 0.07423926f, 
    0.28444779f, 0.02920500f, -0.03237724f, -0.14599572f, 0.03744512f, -0.10043812f, 0.10674732f, 0.10307107f, 
    0.00038017f, -0.02267937f, -0.08646619f, 0.05035440f, -0.18015964f, 0.26508063f, 0.03474847f, -0.10147797f, 
    0.05695680f, 0.01280973f, 0.11911354f, -0.00782852f, -0.04235739f, -0.14805280f, -0.07670568f, -0.01494751f, 
    0.30610844f, 0.05855794f, -0.11135825f, -0.05958692f, -0.06797589f, 0.01931965f, -0.05402508f, -0.09947568f, 
    -0.15795489f, -0.03804993f, -0.02212292f, -0.04483136f, -0.13031936f, 0.21186469f, -0.00090723f, -0.19445512f, 
    0.04508601f, -0.08441284f, 0.14354153f, 0.08228678f, 0.05411534f, 0.05370643f, 0.02587211f, 0.18348414f, 
    0.02424481f, -0.19011697f, 0.07769366f, 0.37865749f, 0.09739016f, -0.12102436f, -0.07655801f, -0.00974993f, 
    0.06442416f, 0.08602078f, 0.11596925f, 0.06653506f, 0.04060100f, 0.11657224f, 0.26395467f, -0.23866439f, 
    -0.07681397f, 0.06147255f, -0.16805503f, 0.10728676f, 0.14560160f, 0.08465017f, 0.01726731f, -0.03638472f, 
    0.18112664f, -0.13959816f, 0.09997278f, -0.14285277f, 0.12317133f, 0.03725569f, -0.08038451f, -0.04461663f, 
    -0.02799442f, 0.00916500f, -0.16030176f, -0.00221546f, -0.29853216f, 0.17648533f, -0.02695289f, 0.10496194f, 
    0.05711079f, -0.13836335f, -0.10137121f, 0.00778014f, 0.07798018f, -0.02954133f, 0.15200844f, 0.05232541f, 
    -0.24451463f, 0.27276105f, 0.24096504f, -0.07562351f, 0.11087780f, -0.07342967f, 0.12607698f, 0.11763367f, 
    0.04323461f, -0.11038041f, 0.11801536f, -0.02679264f, 0.02900303f, 0.14757563f, 0.34381738f, 0.13264333f, 
    0.05829276f, 0.08552147f, 0.05712524f, -0.00738082f, 0.05242231f, -0.03919259f, 0.03648876f, -0.04104247f, 
    -0.57234377f, 0.28890285f, 0.17624086f, -0.06878612f, 0.17338002f, 0.01568558f, 0.12784757f, 0.05470815f, 
    0.01577663f, 0.06667180f, -0.05190542f, 0.21192226f, 0.21008539f, 0.16335392f, 0.05655938f, 0.17453340f, 
    -0.12090651f, -0.05476243f, -0.08676719f, -0.10311925f, -0.02318327f, -0.06883736f, -0.04469062f, -0.10053549f, 
    0.42073393f, 0.04967699f, 0.35439229f, 0.06687823f, 0.00426015f, -0.03055030f, 0.14399424f, 0.04441720f, 
    0.18863967f, 0.03605974f, -0.03244666f, 0.08927931f, 0.08847506f, 0.16230366f, -0.18830812f, -0.11407415f, 
    0.18223718f, -0.06227776f, 0.11215957f, -0.04957705f, 0.14237183f, 0.28318661f, 0.24309736f, 0.11991063f, 
    -0.10803485f, -0.00604942f, -0.05191150f, 0.00817667f, 0.00248389f, -0.01049092f, 0.08594659f, 0.02026383f, 
    -0.02949280f, -0.02170182f, -0.10415715f, -0.14827415f, -0.40113425f, 0.03857512f, -0.29168028f, -0.18246779f, 
    -0.01289396f, -0.19244155f, -0.09215583f, -0.12891695f, -0.03524734f, 0.00210345f, 0.05077216f, 0.06831547f, 
    -0.04708026f, 0.04071520f, 0.01805194f, -0.06239602f, 0.00518072f, 0.06489934f, -0.00661691f, -0.06212658f, 
    0.06312332f, 0.04792051f, 0.03912733f, -0.02112481f, 0.01435314f, -0.01767616f, 0.07000392f, -0.05584143f, 
    0.01924963f, 0.05602251f, 0.04668493f, -0.02183703f, 0.03047728f, -0.07265038f, 0.03059236f, -0.00718321f, 
    0.01603309f, 0.01274173f, 0.01431080f, 0.00341643f, -0.06960201f, -0.03947717f, -0.06630280f, 0.04181188f, 
    0.03500473f, -0.00675039f, -0.06523320f, -0.00824207f, -0.03432973f, 0.02305022f, -0.07609189f, -0.06081408f, 
    0.01711136f, -0.02338441f, -0.00836305f, -0.04916710f, 0.04999942f, 0.02620337f, 0.01598547f, -0.00782383f, 
    -0.01528842f, -0.06696636f, 0.02570770f, -0.00950744f, 0.05602715f, -0.03806065f, -0.04947430f, -0.00120339f, 
    0.02866000f, -0.02024684f, -0.05055661f, 0.02547518f, 0.04926527f, -0.00746423f, 0.07184058f, -0.04723724f, 
    -0.06951442f, 0.00999146f, -0.04515746f, -0.00611785f, -0.05267309f, -0.05848192f, 0.02668883f, -0.04119416f, 
    0.06304774f, 0.06048304f, -0.04088599f, -0.01059680f, 0.03745331f, -0.02048972f, 0.05779915f, 0.05456901f, 
    -0.04046756f, -0.04948642f, -0.07364406f, -0.07176401f, 0.02655533f, 0.06424458f, -0.02752825f, -0.07143490f, 
    -0.00941166f, -0.02357906f, -0.05858746f, 0.05185894f, 0.03506725f, -0.06746229f, 0.03237171f, -0.02715716f, 
    -0.00369256f, -0.05461446f, 0.03586514f, -0.00551966f, -0.07042077f, 0.00242902f, 0.02584998f, 0.05069604f, 
    -0.06583980f, -0.05810385f, 0.01885564f, -0.03838013f, -0.01767760f, -0.05261798f, 0.00374381f, -0.06903005f, 
    0.03649867f, 0.00636680f, 0.06361340f, 0.05659841f, -0.04611668f, -0.06011493f, 0.04099218f, -0.02258903f, 
    -0.06903217f, 0.04713610f, 0.01829942f, -0.00828213f, -0.04457767f, -0.03735076f, -0.04253177f, 0.06162961f, 
    -0.02511148f, -0.03546964f, -0.02157822f, 0.05842225f, 0.03834743f, 0.01746242f, -0.02718129f, 0.01814935f, 
    -0.00286652f, -0.02255207f, 0.03925115f, -0.02193034f, -0.02616827f, 0.03603501f, -0.02818605f, 0.05550566f, 
    0.02522050f, 0.04568736f, -0.01670330f, -0.04867492f, 0.06148946f, -0.05549454f, -0.06784362f, -0.04624512f, 
    -0.07536574f, -0.03794818f, -0.04731197f, 0.00314072f, -0.01448071f, 0.01073277f, -0.04455889f, -0.06229082f, 
    -0.04778060f, -0.05863632f, 0.00188998f, 0.01905401f, -0.03717606f, -0.04287482f, -0.01540246f, 0.00816464f, 
    -0.04917853f, -0.01826738f, 0.02294840f, 0.02501210f, -0.07204989f, -0.06610554f, -0.02981628f, -0.05312990f, 
    -0.05584943f, 0.01834511f, 0.00758376f, -0.02934780f, -0.06656205f, -0.00839407f, 0.05625536f, 0.04642587f, 
    0.06436297f, 0.06579315f, -0.06820483f, 0.00247272f, -0.03954751f, 0.00567753f, -0.07248128f, 0.06441271f, 
    0.04057610f, -0.00094608f, -0.05068338f, 0.05672922f, -0.04429798f, -0.07756495f, -0.00708082f, 0.05429671f, 
    -0.02745851f, 0.04177693f, -0.04324723f, -0.00185374f, -0.04131051f, 0.06181456f, 0.00993166f, 0.01479860f, 
    0.02898716f, 0.01697120f, -0.00669895f, -0.02930528f, -0.01818555f, 0.03185425f, -0.05511772f, -0.07755659f, 
    0.00288852f, -0.07457557f, 0.05314925f, 0.02775021f, -0.03773605f, -0.06864483f, -0.01764591f, -0.05899126f, 
    0.04120133f, -0.03976296f, -0.05814668f, -0.00621516f, -0.07554875f, 0.05595986f, 0.02481567f, -0.06968682f, 
    -0.01670993f, 0.03369969f, -0.04080563f, -0.05668076f, 0.02405586f, -0.02786351f, 0.04218724f, 0.02633116f, 
    -0.01123505f, -0.02546148f, 0.01486436f, -0.07733320f, -0.01435015f, -0.04051863f, -0.07153964f, 0.04088386f, 
    0.01016189f, 0.00367587f, 0.04682864f, -0.02597638f, -0.03938824f, -0.04754249f, 0.02752492f, 0.00122366f, 
    0.05265164f, 0.05936035f, -0.01636947f, -0.00006926f, -0.02194341f, 0.04692381f, -0.04504649f, 0.05870986f, 
    -0.05509662f, 0.04671901f, -0.06193895f, 0.02467286f, 0.01949894f, 0.03101178f, -0.04840441f, 0.01166323f, 
    0.02962988f, 0.06397672f, 0.03408813f, -0.02555299f, -0.00089417f, -0.02587028f, 0.00662117f, -0.03075234f, 
    0.05174283f, -0.02644697f, -0.04437373f, -0.04880710f, -0.06637122f, -0.05823325f, -0.03030991f, 0.00400202f, 
    0.01771178f, 0.02048078f, 0.01482028f, 0.04265621f, 0.04343522f, -0.06918115f, -0.00349229f, -0.00512251f, 
    -0.06611369f, 0.03066808f, 0.01759858f, 0.06023036f, 0.01723415f, 0.05854657f, 0.03158325f, -0.07026166f, 
    -0.02828022f, 0.02502543f, -0.03936316f, 0.01845315f, 0.04586745f, 0.03890771f, 0.02507209f, 0.00358924f, 
    0.05808101f, -0.00775805f, -0.02293238f, -0.02127220f, -0.07942459f, -0.05947349f, -0.06494454f, -0.03568012f, 
    -0.06403737f, -0.00338103f, 0.00266003f, 0.02732271f, 0.01556809f, -0.05457359f, -0.07128727f, -0.04980446f, 
    -0.04550705f, -0.07950736f, 0.02811284f, -0.04735397f, 0.06209504f, 0.00066430f, 0.05264703f, 0.03623969f, 
    0.01783839f, -0.02219189f, -0.06547004f, -0.03681513f, -0.05063757f, 0.06361137f, 0.03132567f, 0.03723982f, 
    -0.06568711f, -0.07736298f, -0.05367206f, 0.00779955f, -0.05165377f, -0.03653951f, 0.00321611f, -0.04670528f, 
    -0.07556739f, -0.02078496f, -0.00403598f, -0.06990066f, 0.01210652f, -0.05304721f, -0.02209421f, -0.06849299f, 
    -0.07398795f, -0.00209761f, 0.05876272f, -0.03499700f, 0.05275416f, -0.06649979f, -0.06989376f, 0.02480573f, 
    -0.04020726f, -0.01969884f, 0.02497275f, 0.04992504f, 0.02537941f, 0.04502692f, -0.06412614f, 0.04231955f, 
    -0.07588566f, -0.02796314f, 0.02250213f, -0.00243932f, -0.07109822f, 0.04991646f, -0.05707476f, -0.04973787f, 
    -0.05555251f, 0.05731379f, 0.03662318f, 0.00355333f, 0.01321250f, -0.00901422f, 0.04425301f, 0.00257297f, 
    -0.03949353f, -0.05663205f, 0.00540903f, 0.04266009f, 0.06102679f, 0.04358840f, -0.03430071f, -0.01766282f, 
    -0.03093119f, 0.04203524f, -0.04512360f, -0.02510579f, -0.06461135f, 0.02967640f, -0.01972969f, 0.03403939f, 
    0.00386745f, 0.02968281f, -0.04426021f, -0.07185861f, 0.04329750f, -0.00846265f, 0.04284522f, 0.03860203f, 
    -0.00659351f, 0.06087739f, 0.04919874f, 0.00541357f, -0.07909201f, 0.00210668f, -0.04513638f, 0.06052028f, 
    -0.07775953f, 0.02814665f, -0.02295333f, 0.02654318f, -0.00850512f, -0.00936287f, 0.04356112f, -0.00287098f, 
    -0.05668094f, -0.01569931f, 0.03324416f, -0.05939819f, 0.03431917f, 0.02473187f, -0.06147309f, -0.04848136f, 
    -0.06493232f, 0.01725267f, 0.04933108f, -0.07707199f, -0.02329379f, 0.06037460f, 0.04657904f, -0.03017101f, 
    -0.05462087f, 0.05504190f, -0.02463454f, -0.05063433f, 0.06076914f, -0.02864752f, 0.00285577f, -0.05816900f, 
    -0.05265780f, -0.00990481f, 0.06282642f, -0.04310609f, -0.01662756f, -0.06107311f, -0.05541640f, -0.06718662f, 
    -0.04444656f, -0.01812193f, 0.04412280f, -0.02529150f, 0.02802283f, 0.04465669f, -0.06320538f, -0.05319781f, 
    0.02263007f, -0.06809506f, 0.02550554f, 0.01976165f, -0.04977116f, 0.00678251f, 0.04165980f, -0.05862971f, 
    0.04311526f, -0.00146166f, -0.02546927f, 0.00960818f, 0.01700215f, -0.00233427f, 0.05287968f, -0.02797464f, 
    -0.04809747f, -0.00269501f, -0.06784597f, -0.02645812f, 0.06218005f, 0.05107580f, -0.01663719f, 0.03437784f, 
    -0.07005057f, -0.01972957f, -0.03870678f, 0.02555997f, -0.03624853f, 0.01677107f, 0.05724952f, 0.01961895f, 
    -0.00847231f, -0.04644778f, 0.05768812f, 0.05646733f, -0.05771508f, -0.03380959f, -0.03207434f, 0.04768521f, 
    -0.00374251f, 0.02792894f, -0.03684840f, 0.04744106f, -0.00462369f, -0.07066079f, 0.04410853f, 0.04121436f, 
    0.04168261f, 0.02780215f, 0.02824371f, -0.07303146f, -0.05706504f, -0.08043071f, -0.04381419f, -0.05590264f, 
    -0.06899518f, 0.05243015f, -0.07893077f, -0.05204035f, -0.07723752f, 0.06380392f, 0.01720029f, -0.07552462f, 
    -0.01518149f, -0.00991186f, -0.05636555f, -0.02028365f, -0.05169024f, -0.05520085f, 0.02815484f, -0.04881922f, 
    0.00162529f, 0.05215033f, 0.04751835f, 0.04456146f, -0.00232560f, -0.07477377f, -0.05645709f, -0.07997468f, 
    0.03975280f, -0.04459486f, -0.02818199f, -0.05756009f, -0.03185011f, -0.00485387f, 0.06024559f, 0.02436900f, 
    -0.06364411f, -0.03851638f, -0.05377157f, 0.00430521f, 0.00479340f, 0.05703968f, -0.07598852f, 0.01966483f, 
    -0.02806281f, 0.00831773f, 0.01024141f, -0.03485204f, -0.07444441f, -0.02632203f, -0.02745652f, 0.00534773f, 
    0.23863499f, 0.11174416f, 0.11221452f, -0.02459397f, -0.02693281f, -0.01608384f, 0.02441943f, 0.15135841f, 
    -0.00647477f, 0.00703768f, -0.23585941f, -0.00875923f, 0.07040785f, 0.17877373f, -0.08215778f, -0.35098779f, 
    -0.33821836f, -0.07359247f, 0.04275035f, 0.06128143f, -0.11183320f, -0.07961575f, -0.00448028f, -0.01030748f, 
    0.13509353f, 0.04648753f, -0.21024573f, -0.20649391f, -0.08680378f, 0.04597402f, 0.04320574f, 0.17282835f, 
    0.01079417f, -0.04470520f, -0.04093073f, 0.05111146f, -0.00539399f, 0.02475644f, -0.29891512f, -0.36313495f, 
    0.01071933f, -0.12090298f, -0.07326151f, 0.12565829f, -0.13508491f, -0.03019164f, 0.01278005f, -0.13752869f, 
    0.18203947f, -0.18395327f, 0.13178450f, 0.39248332f, 0.07927257f, 0.17420903f, -0.12683833f, -0.17731078f, 
    0.37807134f, 0.10544397f, 0.19474089f, 0.00269508f, 0.39025718f, 0.19448981f, 0.20430385f, -0.10337162f, 
    -0.23342730f, -0.15585963f, 0.08012807f, -0.03958341f, -0.08489867f, 0.00708447f, -0.06547657f, -0.08881553f, 
    0.25313342f, -0.02449152f, 0.09660699f, 0.04692164f, 0.01230041f, -0.01900131f, 0.14585799f, 0.04156680f, 
    -0.07825684f, -0.15623052f, 0.07914218f, -0.07195377f, -0.33767605f, 0.00183980f, 0.14676930f, 0.38205788f, 
    -0.01275885f, 0.06070607f, 0.05025959f, 0.02980645f, 0.07353372f, -0.08466998f, 0.12035377f, 0.03017809f, 
    0.05133266f, 0.29347488f, 0.18456377f, 0.15578014f, -0.14710340f, 0.01752943f, -0.09546448f, 0.02373797f, 
    0.08239300f, -0.15573005f, 0.07698366f, 0.03975517f, 0.12119937f, -0.04077969f, 0.30554187f, -0.14566669f, 
    0.11616263f, -0.26710618f, 0.21454427f, 0.10896114f, 0.02771427f, -0.05587030f, 0.09491365f, -0.15191683f, 
    -0.31864098f, 0.46392852f, -0.22995399f, -0.13188116f, 0.06398541f, -0.04062123f, 0.16207500f, -0.06262222f, 
    0.21127170f, 0.04859529f, -0.08250840f, 0.06578852f, -0.00109639f, 0.09188183f, -0.07713174f, 0.28793579f, 
    -0.00060371f, 0.06330960f, 0.01003930f, -0.00358738f, 0.02844308f, 0.04964736f, 0.03014733f, 0.03534073f, 
    0.32168207f, -0.12740952f, -0.01772788f, 0.39880422f, 0.03728145f, 0.00189636f, 0.12291723f, 0.06605338f, 
    -0.16320848f, 0.07096373f, 0.31356055f, -0.10220150f, -0.26901284f, 0.20361814f, 0.04468213f, -0.21269658f, 
    0.21188182f, 0.02062016f, 0.03504973f, 0.05352689f, 0.15398017f, 0.08536506f, -0.18317661f, -0.06595645f, 
    -0.10194732f, 0.07673589f, -0.05885626f, -0.00976305f, 0.07176235f, 0.00184248f, -0.09257109f, 0.10079017f, 
    -0.03624395f, -0.12726231f, -0.30420724f, -0.16311087f, -0.25048140f, 0.49799898f, 0.07649220f, 0.15437797f, 
    -0.09327517f, -0.18131742f, -0.00422273f, -0.17033942f, -0.08711461f, 0.02144208f, 0.11579677f, 0.03135268f, 
    0.24942271f, 0.07722597f, 0.02641052f, -0.02989886f, 0.19620229f, 0.14091147f, 0.09106406f, 0.16384113f, 
    -0.06376817f, -0.07739215f, -0.01996069f, -0.03951748f, 0.01443540f, -0.08678912f, 0.04713233f, -0.27062878f, 
    -0.28691512f, -0.07899420f, -0.01544061f, 0.15193549f, -0.17402706f, -0.08922501f, -0.01707702f, -0.07699668f, 
    0.45068848f, 0.12764017f, 0.27683932f, -0.02044128f, 0.02451070f, -0.03712038f, 0.04257834f, 0.00057715f, 
    -0.03051633f, 0.00987841f, -0.09088533f, 0.09459288f, -0.03137453f, -0.02923188f, -0.15990281f, 0.13076650f, 
    -0.11936779f, 0.04313505f, 0.00448291f, -0.04249693f, -0.01036326f, -0.06212406f, 0.01375793f, 0.24521716f, 
    0.15980399f, 0.21488975f, -0.08759516f, 0.05237209f, -0.01837258f, -0.04699773f, 0.22786199f, 0.00754832f, 
    0.37622011f, 0.10463946f, 0.29081094f, 0.01866481f, 0.03802626f, -0.21361889f, 0.06135991f, 0.07546192f, 
    0.09954269f, 0.04327228f, 0.08755025f, 0.13014036f, 0.01757356f, -0.00533214f, 0.10525455f, 0.08138880f, 
    0.28882879f, 0.12957507f, -0.43002793f, 0.11669184f, 0.10323472f, 0.00699538f, 0.04341263f, -0.13377061f, 
    -0.02813980f, -0.02334142f, -0.15722884f, 0.07832960f, -0.28856057f, 0.01737655f, -0.17500652f, 0.01595005f, 
    -0.00824261f, -0.03989223f, 0.00552448f, -0.01095064f, -0.04110659f, 0.07888423f, 0.14697883f, 0.08603600f, 
    0.09753802f, 0.13169225f, -0.04464647f, 0.07790893f, 0.11667860f, 0.05922654f, 0.08023975f, -0.04195215f, 
    -0.19595726f, -0.07888582f, -0.05534617f, -0.17749983f, -0.16014124f, -0.19607376f, 0.08810828f, 0.01674970f, 
    0.05046997f, -0.28268597f, 0.21771389f, -0.09661981f, 0.08348377f, -0.02568192f, 0.17088048f, 0.13663161f, 
    -0.24053544f, 0.31363329f, -0.00920808f, -0.17596452f, 0.31303602f, -0.02780710f, 0.07647907f, 0.09022927f, 
    0.05275881f, 0.08288861f, 0.07589772f, -0.06608438f, 0.24115828f, 0.25776461f, 0.13237217f, 0.11777417f, 
    -0.10222571f, 0.08411971f, -0.07862195f, -0.12602995f, -0.06414715f, 0.06159605f, 0.09796244f, 0.08604759f, 
    0.38130280f, 0.18661474f, 0.12396931f, 0.35178581f, 0.02887180f, -0.17422712f, 0.02460994f, 0.03319769f, 
    -0.04900942f, 0.20931551f, 0.22337349f, 0.06713350f, 0.07433467f, 0.23752873f, 0.14953890f, 0.02112945f, 
    -0.07194638f, 0.06406332f, 0.12658492f, -0.02194830f, 0.13704208f, 0.30358860f, -0.03421263f, 0.22957534f, 
    -0.08430594f, 0.04367193f, -0.00600596f, -0.04436109f, 0.31967551f, -0.03114499f, -0.00378260f, 0.00930362f, 
    -0.12071386f, -0.07811691f, -0.02259444f, -0.05780463f, -0.59803605f, 0.00122884f, -0.12111793f, -0.14763120f, 
    0.04107478f, 0.13943286f, -0.13468377f, 0.06992161f, -0.03942496f, 0.14100398f, 0.01582906f, -0.02743639f, 
    0.06293389f, 0.01975893f, -0.06328298f, 0.01984899f, -0.00934780f, -0.01867190f, 0.00178017f, 0.00388512f, 
    0.02205795f, -0.04490884f, 0.04158824f, -0.07559320f, -0.00919005f, 0.05356823f, 0.03718792f, -0.05773075f, 
    -0.06762836f, 0.01845971f, -0.05273985f, -0.04949107f, 0.03187541f, -0.04837991f, -0.07705660f, -0.04153780f, 
    -0.05368730f, -0.05565070f, -0.04466080f, -0.07669473f, 0.00753137f, -0.06790927f, 0.00434192f, 0.01157774f, 
    -0.05938115f, 0.00012805f, 0.02627709f, -0.03228686f, -0.03328925f, 0.01391481f, -0.05246557f, -0.01259545f, 
    -0.04903401f, -0.06958720f, 0.00060853f, 0.04565530f, -0.01653214f, -0.04852123f, 0.01974598f, -0.04005651f, 
    0.00903897f, -0.03871369f, -0.02955490f, -0.02422392f, -0.00074114f, 0.03851680f, 0.02894469f, -0.01489581f, 
    -0.03636729f, -0.00799055f, -0.01435120f, 0.04458206f, 0.03144281f, 0.03544375f, 0.01732588f, 0.00976619f, 
    -0.01147006f, -0.06313124f, -0.04337165f, -0.03020905f, 0.05755011f, 0.01135058f, 0.05457430f, 0.04752446f, 
    0.03090778f, -0.06185075f, 0.03307676f, -0.03704141f, -0.05891553f, -0.01590650f, 0.01497950f, 0.02678797f, 
    0.04456950f, -0.00601529f, -0.02054349f, 0.01703353f, -0.01969447f, 0.06165417f, -0.07338824f, -0.06109448f, 
    0.06402948f, 0.05743682f, -0.04304662f, -0.05042593f, -0.02573105f, -0.03069348f, -0.07388791f, -0.05859387f, 
    -0.06473247f, -0.07986847f, -0.02806465f, 0.01278400f, -0.05269019f, -0.05898338f, -0.06197146f, -0.03296763f, 
    -0.03177752f, 0.02258683f, 0.04882978f, 0.02518201f, -0.00149095f, -0.03551440f, -0.03282252f, -0.05632349f, 
    0.02886890f, 0.01190667f, 0.02230011f, -0.06775689f, 0.00641341f, 0.03421617f, -0.02318574f, 0.00042691f, 
    -0.06888758f, -0.07539147f, 0.05488109f, -0.07647868f, -0.01651890f, 0.03485990f, 0.02554765f, 0.02430360f, 
    -0.04360277f, 0.02429149f, -0.07348692f, 0.02237347f, 0.05738027f, -0.07316844f, -0.02406169f, -0.02655942f, 
    -0.07120344f, -0.04423143f, -0.03781984f, -0.02192539f, 0.00465110f, 0.02794987f, -0.05846649f, 0.00921064f, 
    -0.05272700f, -0.02606172f, -0.03803413f, -0.01739354f, 0.06215613f, 0.05048292f, -0.08066230f, -0.07376815f, 
    -0.00803010f, -0.06152250f, -0.00959271f, -0.00043941f, -0.04338196f, 0.04413710f, 0.01870917f, 0.04409465f, 
    0.01040721f, 0.00085853f, 0.03202662f, 0.03968758f, 0.05098081f, -0.00509713f, 0.03880842f, -0.01685275f, 
    0.03459101f, -0.00478547f, 0.00404393f, 0.03286906f, 0.05373397f, -0.01979309f, -0.04223494f, -0.03830358f, 
    0.02470226f, 0.04858719f, 0.05635642f, -0.01172844f, -0.03664900f, -0.00060597f, 0.01168221f, -0.04740607f, 
    -0.04849180f, 0.01580567f, -0.01014709f, 0.03432860f, 0.04976746f, -0.03954180f, 0.00771283f, -0.05581952f, 
    -0.28236887f, -0.07422282f, 0.01390970f, 0.01257293f, 0.00902482f, -0.05315442f, -0.06036400f, 0.07537892f, 
    -0.25182536f, -0.10679486f, 0.15213186f, -0.03134536f, -0.22184351f, -0.53260869f, -0.02375015f, -0.01601186f, 
    -0.01650345f, 0.03523941f, -0.01019513f, 0.02391360f, -0.09759635f, -0.00240981f, -0.03177015f, 0.07047138f, 
    -0.17385803f, 0.03815156f, 0.50602609f, -0.10387598f, -0.16106185f, -0.13150567f, 0.00448215f, -0.04273932f, 
    -0.15380339f, 0.07975818f, 0.11170302f, 0.13138558f, -0.04870287f, -0.21201003f, 0.03051423f, 0.04477695f, 
    -0.07348872f, 0.11667423f, -0.03787584f, 0.02186896f, -0.05618994f, 0.00567829f, -0.18903893f, 0.05368267f, 
    0.07877038f, 0.10430358f, -0.34511760f, -0.08380512f, 0.09723749f, -0.00166934f, 0.20317122f, 0.01951146f, 
    0.27121460f, -0.02355239f, 0.07316182f, -0.00145431f, -0.18923086f, -0.28510860f, -0.18265523f, 0.11097427f, 
    0.04678901f, 0.08716160f, 0.04193542f, 0.06806765f, 0.01361780f, 0.02807511f, -0.04154636f, 0.11960695f, 
    0.12715904f, 0.15025084f, -0.28943720f, 0.34469920f, 0.05138776f, 0.06595875f, 0.02116084f, 0.01483732f, 
    -0.04249321f, -0.06413890f, 0.18289855f, 0.11743508f, 0.35804564f, 0.06129681f, -0.16328967f, -0.32538679f, 
    0.05844463f, 0.05708369f, -0.02514924f, -0.07357477f, -0.00866445f, 0.03688695f, -0.00086840f, 0.07330129f, 
    0.24444358f, -0.07430290f, -0.25783971f, 0.03512797f, 0.01323695f, -0.03713168f, 0.19396470f, 0.14537953f, 
    -0.11224421f, 0.13586922f, -0.10065267f, -0.06904071f, -0.20961748f, -0.09973352f, -0.21642032f, 0.21057881f, 
    -0.14648360f, -0.06118406f, 0.04171477f, -0.05346754f, 0.08889005f, 0.03182250f, 0.02813407f, 0.08594858f, 
    0.45110005f, -0.11950718f, 0.31345880f, 0.28229779f, 0.16863590f, 0.07761320f, 0.05935964f, 0.22043452f, 
    0.02631870f, 0.13902558f, -0.04932130f, 0.00165991f, -0.07381171f, -0.02301118f, -0.10643681f, -0.40567496f, 
    -0.19141859f, -0.12998460f, -0.15075409f, -0.13607100f, -0.15780704f, -0.05978984f, -0.06626343f, -0.08683836f, 
    -0.04412468f, 0.33173120f, 0.02472288f, 0.10361592f, 0.00936252f, 0.02029408f, 0.04070586f, 0.02118867f, 
    -0.01138704f, 0.15952431f, 0.22533360f, 0.05185242f, 0.27898493f, 0.13190430f, 0.36236599f, 0.15490271f, 
    -0.10468868f, 0.00635710f, 0.05720599f, 0.01826870f, 0.03961130f, 0.26458511f, 0.13617562f, 0.16513886f, 
    -0.00080723f, 0.01271387f, -0.14391553f, -0.17293791f, 0.06097726f, 0.01029828f, 0.06928621f, -0.08140451f, 
    0.00429022f, 0.11847388f, 0.04991879f, 0.07730592f, 0.17288314f, -0.13377999f, 0.02269928f, 0.01440508f, 
    0.09604101f, 0.12623987f, 0.04329277f, 0.17065543f, -0.06468655f, 0.16199823f, -0.09432126f, 0.06139557f, 
    -0.00367435f, -0.06069107f, 0.09044115f, 0.07427044f, -0.10679818f, 0.11036336f, -0.02466580f, 0.11243101f, 
    0.16563576f, 0.03581090f, 0.02771821f, -0.01238341f, 0.22485459f, 0.57252413f, 0.32541814f, 0.18070899f, 
    0.07622746f, 0.00962130f, 0.01667508f, -0.04922780f, 0.10167675f, 0.01804862f, 0.01877710f, 0.08623869f, 
    0.19045462f, 0.09952361f, -0.12920789f, 0.28911611f, 0.06171147f, 0.09441020f, -0.10566783f, -0.03957589f, 
    0.08170179f, 0.06325682f, 0.14288595f, -0.12076969f, -0.07555991f, 0.23587291f, 0.08578379f, -0.25350970f, 
    -0.00706255f, 0.23959485f, -0.03083200f, 0.20452699f, 0.08356473f, 0.02713511f, 0.04558723f, -0.00370830f, 
    -0.07899558f, -0.27038530f, 0.36755714f, -0.16989495f, -0.16182163f, -0.15736571f, -0.03145246f, 0.00309673f, 
    -0.41989726f, -0.19011500f, -0.29817989f, 0.00841394f, -0.12732990f, 0.24985406f, 0.08680455f, -0.32147458f, 
    0.05165432f, -0.02619431f, -0.18271399f, -0.02248694f, 0.19160710f, 0.04392882f, -0.14386147f, -0.08546012f, 
    0.24302767f, -0.15394020f, 0.51742047f, -0.12607370f, 0.14696506f, 0.09128545f, -0.14143939f, 0.28834528f, 
    0.00435010f, -0.07580607f, 0.12963983f, 0.00214024f, -0.05414912f, -0.16478807f, -0.12529488f, -0.10129934f, 
    0.06802989f, -0.11138643f, -0.05422222f, 0.14951108f, 0.13201363f, -0.13252248f, -0.14716081f, -0.08985899f, 
    -0.22582351f, 0.09041984f, 0.11278851f, -0.17616171f, 0.15610866f, -0.12559204f, 0.06839958f, 0.12408310f, 
    0.07683009f, 0.01639088f, 0.04896642f, 0.06052295f, 0.29860431f, 0.37523058f, 0.22164239f, 0.15607189f, 
    0.05402306f, 0.15125653f, -0.12443329f, 0.18574788f, 0.15388064f, 0.13946353f, -0.17602473f, 0.09296002f, 
    -0.31262904f, -0.04186272f, 0.03199591f, -0.16042979f, -0.06158471f, -0.06901526f, 0.21969822f, 0.21767585f, 
    -0.14085147f, -0.12252876f, 0.14185777f, 0.12458134f, -0.04270671f, 0.02405351f, 0.03141286f, -0.01907949f, 
    0.01085946f, 0.03532937f, -0.05938955f, 0.00862450f, -0.02884088f, 0.00230134f, -0.00666321f, 0.03307159f, 
    -0.00078058f, 0.00697761f, 0.27284452f, -0.12594524f, -0.08753880f, 0.19731252f, 0.12248877f, -0.06535798f, 
    0.24121597f, -0.02205979f, -0.19338739f, 0.44771430f, -0.10768519f, -0.22104409f, -0.00770845f, -0.07871380f, 
    0.09994103f, 0.03121314f, -0.00462695f, -0.10114403f, -0.19404893f, -0.05254997f, 0.17513256f, -0.13334079f, 
    0.07523352f, 0.07620642f, -0.04421344f, 0.03743071f, -0.17157735f, -0.06921332f, 0.02106743f, -0.23391648f, 
    0.00669861f, -0.03711117f, 0.04505866f, 0.04154461f, 0.09377839f, -0.33170390f, -0.11854374f, -0.18256034f, 
    -0.06047903f, -0.16446368f, 0.13320367f, -0.07321380f, -0.02024720f, -0.11643197f, -0.07988197f, -0.11116706f, 
    -0.07940292f, 0.06523553f, -0.03390142f, -0.18586454f, 0.09095662f, 0.17460053f, -0.11590070f, 0.09803598f, 
    -0.10256591f, -0.09418932f, -0.08317249f, -0.07916557f, 0.07971332f, 0.14538018f, 0.13368796f, 0.09992775f, 
    -0.10549918f, 0.20093568f, 0.18667370f, 0.27730447f, -0.02226528f, 0.19894604f, 0.03250040f, 0.04430912f, 
    -0.27386373f, -0.29512793f, -0.17441832f, 0.07286221f, 0.00779904f, 0.04184735f, 0.01875716f, 0.03684156f, 
    -0.01579643f, -0.00958920f, 0.00575672f, -0.17166039f, 0.12039739f, -0.03014825f, -0.36097604f, 0.00268831f, 
    -0.10357194f, -0.08328678f, 0.21462023f, 0.06181589f, 0.00746517f, -0.03579599f, 0.06172418f, 0.03215996f, 
    -0.06146951f, 0.15264390f, 0.18455508f, 0.11644225f, 0.04930577f, 0.12798755f, -0.27552211f, -0.06673507f, 
    0.14740610f, 0.07306503f, -0.12197942f, -0.16220964f, 0.40624455f, 0.07709036f, 0.26719084f, 0.20300415f, 
    -0.15312445f, 0.11614931f, 0.17935830f, 0.05934121f, -0.01034852f, 0.00162826f, 0.00607432f, -0.04730812f, 
    -0.36659846f, 0.01814242f, -0.16258290f, -0.00552184f, 0.09146858f, 0.14720134f, -0.07628992f, -0.14554535f, 
    -0.01167700f, -0.13130677f, 0.12220628f, -0.18829910f, -0.05669196f, -0.14713314f, 0.17699152f, 0.32670486f, 
    -0.00033364f, -0.01898500f, -0.11848038f, -0.21629794f, 0.07523413f, -0.05149316f, 0.07682763f, 0.27438602f, 
    0.07382735f, 0.34839883f, 0.13373993f, 0.33860886f, -0.11452944f, 0.03046368f, -0.10625586f, 0.11850438f, 
    0.10914280f, 0.00087635f, 0.01836076f, -0.07111784f, 0.02912812f, 0.24214464f, 0.07870403f, -0.08183672f, 
    0.19754407f, -0.01476643f, 0.23142938f, 0.12974377f, -0.10919426f, 0.08174039f, 0.09738877f, -0.07552186f, 
    0.33623526f, 0.34368286f, -0.13110842f, -0.08394200f, 0.08777419f, -0.02742420f, -0.10161076f, -0.08545954f, 
    0.02332010f, 0.09263742f, -0.15413541f, -0.01907114f, -0.10500361f, -0.10811332f, -0.04964709f, 0.11084931f, 
    0.00283870f, -0.02368492f, -0.00335852f, -0.08457911f, -0.09033217f, -0.00660118f, -0.01835009f, 0.11274699f, 
    -0.16226494f, -0.15705959f, -0.12111131f, 0.28825036f, -0.11993316f, -0.05127968f, 0.07432790f, -0.16194890f, 
    -0.21221471f, 0.08897752f, 0.19135655f, 0.01105996f, -0.00813642f, 0.17777744f, 0.08458191f, -0.07059366f, 
    -0.04244920f, -0.08588242f, 0.02207664f, 0.06824826f, 0.00775820f, -0.28347796f, -0.09050689f, 0.03638740f, 
    0.06098827f, -0.05857207f, -0.00847554f, -0.04823907f, 0.14430377f, 0.12647091f, -0.00372772f, 0.04590861f, 
    -0.13602732f, -0.04984424f, 0.02965516f, -0.04634770f, -0.08973626f, 0.31662005f, 0.04254235f, 0.03236442f, 
    -0.03467240f, -0.00692025f, 0.03104010f, -0.25932217f, 0.03888982f, 0.05527680f, 0.02170835f, 0.14820947f, 
    0.17183533f, -0.10324727f, -0.16710128f, -0.09872544f, 0.13480778f, 0.01666103f, -0.14985202f, -0.17951347f, 
    -0.06357269f, -0.12389944f, 0.00988942f, 0.04378107f, -0.05740380f, 0.15519592f, -0.00412251f, -0.02215653f, 
    0.01293701f, 0.12646350f, 0.09821407f, 0.06209244f, 0.05823199f, 0.02213637f, 0.10371301f, 0.05469014f, 
    0.29764169f, -0.13490763f, -0.10187332f, -0.11200822f, 0.30453807f, 0.05829333f, 0.01993210f, -0.07530466f, 
    0.01082878f, -0.08599617f, -0.10522315f, 0.04772737f, -0.07789002f, -0.13716172f, -0.18445489f, 0.09493441f, 
    -0.01267148f, -0.19443356f, 0.20632815f, -0.10022301f, 0.09862904f, -0.02048031f, 0.01034401f, 0.08446439f, 
    -0.39376652f, 0.07223349f, 0.01252538f, 0.15046524f, -0.06562641f, 0.05894239f, -0.02623249f, 0.07134140f, 
    0.09019942f, 0.01861028f, 0.05669906f, 0.07397588f, 0.08703642f, 0.16177537f, 0.14325173f, 0.10306603f, 
    0.04380418f, 0.09024856f, 0.18202634f, 0.16878611f, -0.02036856f, 0.14768723f, 0.09664833f, 0.13352515f, 
    -0.19991136f, -0.13106304f, -0.52224916f, 0.03327288f, 0.00708490f, -0.02659928f, -0.24723886f, -0.05255293f, 
    0.07154639f, -0.04991294f, -0.07165129f, 0.05913707f, -0.09145183f, 0.15699175f, 0.38852966f, -0.01257715f, 
    -0.08942269f, -0.02085452f, -0.08802864f, 0.07156215f, -0.00893314f, 0.08793797f, 0.01522313f, 0.10366818f, 
    -0.19583900f, 0.04445066f, 0.04486113f, 0.14747527f, -0.04214770f, 0.01551368f, -0.06681187f, -0.18170750f, 
    0.02838677f, 0.09478865f, 0.01566589f, 0.06781106f, -0.12738714f, 0.08677789f, 0.07023653f, -0.10032660f, 
    0.01603417f, -0.03652558f, 0.14925221f, -0.00646699f, -0.04497790f, 0.01917610f, 0.14734046f, 0.13936082f, 
    -0.04941077f, -0.03355670f, -0.18910228f, 0.00925342f, 0.01820612f, -0.11958446f, -0.12734215f, -0.14310953f, 
    0.01437333f, -0.03524681f, 0.13051823f, 0.02448377f, 0.07469443f, -0.09525465f, -0.07928674f, 0.05162325f, 
    0.02762118f, -0.16722889f, -0.12732394f, -0.06885415f, -0.07752576f, -0.05836726f, -0.12542082f, -0.04388250f, 
    0.19543937f, -0.09107035f, -0.21203709f, 0.22370528f, -0.01340643f, -0.01656487f, 0.03641724f, -0.01742354f, 
    -0.03840207f, -0.04770569f, -0.03589380f, -0.08382636f, -0.02186544f, 0.13521835f, -0.02536094f, -0.04911882f, 
    -0.22807230f, 0.02146808f, -0.06148753f, -0.03789945f, 0.02344154f, -0.08274048f, -0.20464170f, 0.22658220f, 
    -0.06491435f, -0.18824919f, -0.00450402f, 0.06878090f, 0.02638468f, -0.06269654f, -0.00630195f, 0.11124659f, 
    -0.03950412f, -0.09124387f, 0.16806123f, -0.15464664f, -0.48469761f, 0.24325278f, 0.03524356f, -0.05243837f, 
    -0.16044702f, -0.10578384f, -0.17855239f, -0.04791514f, 0.19260696f, 0.02901220f, 0.00889021f, 0.00047123f, 
    -0.04120606f, -0.01457305f, 0.04029388f, -0.03825011f, 0.04218100f, -0.05564173f, 0.05091678f, 0.00545371f, 
    -0.01850333f, 0.03331077f, -0.07643787f, -0.07532777f, -0.07723654f, -0.05546761f, -0.05277829f, 0.03460188f, 
    -0.00784502f, 0.03895401f, -0.08715368f, -0.04228080f, 0.02869390f, 0.02411061f, -0.06575114f, -0.05002991f, 
    0.00519221f, 0.03814654f, -0.04534166f, -0.02602598f, -0.07308744f, -0.06870888f, -0.07353036f, 0.00085442f, 
    0.01835214f, -0.00482055f, 0.00138512f, -0.01972192f, 0.01630844f, -0.07769657f, 0.03913860f, -0.05609636f, 
    0.00244861f, -0.03485027f, -0.06588234f, 0.01612275f, 0.05187488f, -0.05540467f, 0.04821964f, -0.00300511f, 
    0.00354761f, -0.00670943f, 0.05254835f, -0.01332759f, 0.04346712f, -0.05786276f, 0.04588895f, 0.01389122f, 
    -0.05984338f, 0.05990600f, 0.00532324f, -0.01844129f, 0.03191821f, -0.01218084f, 0.03849611f, -0.03527250f, 
    0.00975148f, -0.04794392f, -0.00949645f, 0.06481587f, -0.03950343f, -0.03909897f, 0.05730799f, -0.06292560f, 
    -0.01804446f, -0.02749641f, -0.03016826f, 0.02391965f, -0.04490906f, -0.03728048f, 0.03295153f, 0.04913813f, 
    0.06128307f, 0.00623771f, -0.04934450f, -0.05611097f, 0.01774185f, 0.04501789f, -0.04718441f, -0.04191541f, 
    0.02429863f, -0.03183733f, -0.01660626f, -0.05789089f, -0.07944181f, -0.06076624f, -0.00795417f, 0.04896273f, 
    0.02834897f, -0.03155297f, -0.01960785f, 0.05931400f, -0.02126649f, 0.02425106f, 0.00587449f, -0.03214625f, 
    0.03461570f, -0.03790259f, -0.00499607f, -0.05624332f, 0.01744789f, 0.05896867f, 0.00677974f, -0.02516794f, 
    0.04304069f, -0.00698732f, -0.01185890f, 0.06078063f, -0.02033439f, 0.00107700f, 0.04012123f, 0.01382376f, 
    -0.02416059f, -0.06289250f, 0.04454800f, -0.03984521f, -0.03280543f, -0.02602497f, 0.01781086f, 0.02009051f, 
    -0.05772662f, 0.04050087f, -0.06074237f, -0.08292147f, -0.02919982f, 0.01493636f, 0.05084348f, 0.01564923f, 
    0.00157636f, 0.04603142f, -0.01188578f, -0.03725100f, -0.01482337f, 0.00913973f, 0.00372602f, -0.06360518f, 
    0.01599112f, 0.01485204f, 0.02320512f, 0.01274194f, -0.04672291f, -0.06064632f, 0.00040504f, -0.01482475f, 
    0.01421708f, -0.02993133f, 0.02167640f, 0.05916466f, 0.04004626f, 0.04659707f, -0.08300474f, -0.04416440f, 
    -0.04433104f, 0.03722997f, -0.01088747f, 0.05262138f, -0.04154634f, 0.02324041f, -0.07320957f, -0.07576007f, 
    0.00311240f, 0.00536257f, 0.02234385f, -0.00289691f, -0.05452713f, 0.03423314f, -0.03625416f, -0.04624840f, 
    -0.02909851f, 0.01362297f, -0.00621554f, -0.06068750f, -0.02533787f, -0.02075216f, -0.03994621f, -0.02438387f, 
    -0.01240846f, 0.05473104f, 0.01360770f, 0.05655523f, 0.05155919f, -0.02189816f, 0.03389490f, 0.00457954f, 
    -0.29223099f, -0.10445008f, -0.46224931f, -0.15541652f, 0.00552983f, -0.16238587f, 0.13944374f, -0.18799359f, 
    0.06848320f, 0.12004293f, -0.17304267f, -0.25179541f, 0.26215371f, 0.57049608f, 0.00416792f, 0.24742061f, 
    0.34114277f, 0.22223356f, 0.20875499f, 0.04523824f, 0.01208705f, 0.00926052f, 0.09241784f, 0.09040297f, 
    -0.19190007f, 0.05294820f, -0.43708432f, 0.14368556f, 0.25902930f, 0.10301755f, -0.05319242f, 0.02942422f, 
    0.05867324f, -0.15445346f, 0.04182955f, -0.10446884f, 0.18227254f, 0.15319255f, 0.31916144f, 0.18529499f, 
    0.27386194f, -0.03697418f, 0.15453915f, 0.14554621f, 0.23634143f, 0.11565101f, 0.01672620f, -0.05855220f, 
    0.02901944f, 0.03634936f, 0.05156142f, -0.00300174f, 0.05637676f, 0.04769462f, -0.06838802f, 0.02629210f, 
    -0.05833778f, 0.02400734f, -0.12179780f, 0.04105013f, -0.14706409f, 0.09028505f, 0.02882598f, -0.06643371f, 
    0.11111284f, 0.11734139f, -0.05542365f, -0.06946026f, 0.15012060f, -0.06796368f, 0.01523563f, 0.02852045f, 
    -0.42147028f, -0.28029409f, 0.55289268f, -0.45945019f, 0.13231626f, -0.01680701f, -0.07343873f, -0.09713989f, 
    -0.05330589f, -0.02638669f, -0.05365882f, -0.09650829f, 0.21609260f, 0.30342585f, -0.06965537f, 0.10537279f, 
    0.02635037f, -0.09374863f, 0.00874717f, -0.00646121f, 0.07448085f, 0.11087131f, 0.05222916f, 0.08438576f, 
    -0.10339718f, -0.11984339f, 0.01184401f, -0.14400950f, 0.18802013f, 0.19370951f, 0.04806945f, 0.08779347f, 
    0.17191118f, -0.15442763f, -0.01936995f, 0.34045711f, 0.40412489f, 0.21154134f, 0.02846611f, 0.06860153f, 
    0.06562917f, 0.27442148f, -0.13641886f, 0.11421102f, 0.05364032f, 0.04011165f, -0.08235983f, -0.05682147f, 
    -0.26113856f, -0.09575052f, 0.09290385f, -0.00044793f, -0.13368072f, 0.17302787f, -0.03979883f, 0.12300766f, 
    -0.01868005f, 0.09221705f, 0.04024349f, 0.11221538f, -0.01291963f, -0.15922689f, 0.23928088f, 0.13688640f, 
    0.03043349f, 0.03690467f, -0.20150504f, 0.05612715f, 0.21009497f, 0.09098393f, 0.10139052f, 0.01690599f, 
    -0.04385023f, -0.33492595f, 0.04302691f, -0.43612540f, -0.07875952f, -0.07978052f, -0.28698578f, -0.09658470f, 
    0.29525733f, -0.07344816f, -0.03127625f, -0.01222491f, -0.00038260f, 0.04396668f, -0.33592567f, 0.08133492f, 
    0.23208311f, -0.00310831f, -0.04656996f, -0.21253750f, 0.05998605f, 0.05189573f, 0.10510289f, -0.04867945f, 
    0.10779712f, -0.11230669f, -0.27157226f, -0.09112232f, -0.00242266f, 0.09872143f, -0.08703627f, -0.09305619f, 
    -0.11248376f, -0.17239781f, -0.33892176f, -0.33713871f, 0.32136494f, -0.28002578f, -0.32689175f, -0.11167060f, 
    0.04380613f, -0.04684466f, 0.18464521f, -0.12995270f, 0.03949494f, -0.04356373f, 0.06230822f, 0.05287198f, 
    -0.11192887f, -0.20596161f, -0.14628722f, -0.18235970f, -0.09372122f, -0.00764992f, 0.07711623f, -0.05301956f, 
    0.08913685f, 0.08468587f, -0.00709186f, -0.12976585f, 0.35056618f, 0.44594327f, -0.01163372f, -0.11792644f, 
    0.21096019f, 0.04414210f, 0.24305134f, -0.06686103f, -0.05997752f, 0.07757105f, 0.02111039f, -0.03737304f, 
    -0.23555966f, -0.07092278f, -0.59650511f, 0.15495169f, -0.13214326f, 0.07899359f, -0.03665742f, 0.00869395f, 
    0.12181801f, -0.07615085f, 0.06683555f, 0.03170396f, 0.15699624f, 0.07115379f, 0.18341181f, -0.03277471f, 
    0.19955571f, 0.07661644f, 0.20926957f, 0.03068461f, 0.13468458f, -0.04384838f, -0.11520649f, -0.07373237f, 
    0.19411416f, 0.16875042f, 0.26777723f, 0.00281255f, 0.07770897f, -0.02612413f, 0.05031225f, 0.15286388f, 
    -0.06037061f, -0.10397250f, -0.01085533f, 0.14438087f, -0.01830510f, 0.10882779f, -0.11765159f, -0.06269648f, 
    0.18947679f, -0.10994866f, 0.04301018f, 0.03534893f, -0.10994941f, -0.07621042f, -0.00947209f, 0.10254042f, 
    0.06534074f, -0.13395318f, 0.18965237f, -0.21855830f, 0.06140629f, 0.03498163f, 0.12126701f, 0.02794666f, 
    -0.03935386f, 0.02425343f, 0.04585331f, 0.22927396f, -0.21042064f, 0.15645501f, 0.14199458f, -0.10069125f, 
    -0.03970089f, 0.02343539f, -0.15631409f, -0.08688365f, -0.00824849f, -0.03511597f, -0.06768615f, -0.00174327f, 
    0.17489569f, -0.07790081f, -0.00729627f, -0.16856948f, 0.15826373f, 0.02166027f, 0.19142194f, -0.03352914f, 
    -0.04167817f, -0.05672438f, 0.07596332f, 0.16701540f, 0.49952146f, 0.11433464f, -0.11309320f, 0.11329716f, 
    0.05462050f, 0.27288285f, -0.09704508f, 0.30016646f, 0.08440758f, 0.03243034f, -0.00091738f, -0.07910613f, 
    -0.29599956f, -0.02789873f, 0.12520514f, -0.09174109f, -0.03022642f, -0.00438726f, 0.09564839f, -0.06420214f, 
    0.04806473f, -0.00486582f, 0.03944616f, 0.04763816f, -0.44856066f, -0.37006754f, -0.15281889f, -0.07766766f, 
    -0.07366391f, -0.06921721f, -0.18472375f, -0.05095431f, 0.10333896f, 0.09788138f, 0.12283538f, 0.02375441f, 
    0.05167896f, -0.36335787f, -0.07980464f, -0.42455491f, -0.14107269f, 0.06882806f, -0.08068494f, -0.08789080f, 
    0.24992310f, -0.03433969f, 0.03810274f, 0.14931872f, -0.26011133f, -0.04881892f, 0.01965209f, 0.17334937f, 
    0.00229093f, -0.08420368f, -0.05181990f, -0.02088236f, 0.28423846f, 0.33993450f, 0.33346856f, 0.16110076f, 
    0.02927695f, -0.02919326f, -0.15304565f, -0.03872731f, -0.01922152f, -0.08744604f, -0.08472008f, 0.01146690f, 
    0.11597072f, 0.03241269f, -0.02011008f, 0.02247436f, -0.08547308f, -0.28699219f, -0.17714745f, 0.01470757f, 
    -0.03428898f, -0.06099128f, 0.12203016f, 0.14771162f, -0.08415206f, -0.14493203f, -0.05224922f, -0.04744336f, 
    0.11232982f, 0.03915089f, 0.12239661f, -0.03793962f, 0.07978082f, 0.27353862f, -0.00877736f, 0.15897568f, 
    -0.08339807f, -0.09620506f, 0.09257131f, 0.03368957f, 0.14556064f, -0.15488851f, 0.17864387f, -0.05824164f, 
    -0.24953000f, -0.15657379f, 0.01096751f, 0.11704012f, -0.21118896f, 0.06133673f, -0.09390581f, 0.03509700f, 
    0.14241999f, -0.03630932f, 0.20927463f, 0.12557195f, -0.07127766f, -0.00024189f, -0.01133542f, -0.03409563f, 
    -0.15870805f, -0.07002398f, -0.06681745f, 0.01950684f, -0.03073080f, -0.21207811f, 0.11526282f, -0.01346389f, 
    0.01925770f, 0.15011302f, -0.01330351f, 0.09064771f, -0.04325589f, -0.01632500f, -0.10285365f, 0.00226871f, 
    -0.22792640f, 0.28939727f, -0.11490005f, 0.07505234f, 0.06367477f, 0.18202312f, 0.25075567f, -0.08244920f, 
    0.37728465f, 0.06367447f, 0.34663254f, -0.01038076f, 0.03617636f, 0.02609136f, -0.12223427f, 0.03933319f, 
    -0.10032448f, -0.07443388f, 0.16525516f, 0.10628013f, 0.05254010f, 0.11193541f, -0.00647920f, 0.17588973f, 
    0.05587863f, 0.04850122f, -0.41738847f, 0.06896663f, 0.07043774f, 0.06353672f, 0.05104686f, 0.05964570f, 
    -0.09956259f, 0.03433777f, -0.06144195f, -0.05455519f, -0.18055221f, -0.00931438f, 0.13294928f, -0.13290340f, 
    -0.04475223f, -0.01782442f, -0.11889493f, 0.07050428f, -0.18322809f, -0.02617425f, 0.01395140f, -0.02965691f, 
    0.26715028f, -0.03274112f, -0.28978100f, 0.13861613f, -0.24142528f, -0.17582840f, 0.03000335f, -0.18031961f, 
    -0.16330442f, 0.07851953f, 0.00010135f, -0.11183966f, -0.31348103f, -0.21671627f, -0.42125562f, 0.23428313f, 
    -0.05494463f, -0.19889082f, -0.06499532f, 0.13959995f, 0.00833681f, 0.01728176f, 0.09412766f, 0.12559694f, 
    0.28953686f, -0.27926943f, -0.14653456f, -0.08180057f, 0.20408343f, -0.21052927f, 0.17269604f, -0.12226258f, 
    0.14950962f, 0.08375006f, 0.21779075f, -0.03166187f, -0.06353505f, 0.06580214f, -0.17051843f, 0.02259879f, 
    -0.06705038f, 0.04861524f, 0.02069387f, -0.07642039f, -0.03109597f, 0.13222010f, 0.29228896f, 0.20467545f, 
    0.11722030f, 0.19337127f, -0.03800606f, 0.29457170f, -0.00495066f, -0.05208524f, -0.00902920f, 0.03438105f, 
    -0.12886389f, 0.11790883f, -0.01849980f, 0.05569533f, 0.03560508f, 0.14961904f, 0.41046757f, -0.21000507f, 
    -0.17643490f, -0.00942679f, 0.04030918f, 0.09778374f, 0.10564108f, 0.16847673f, -0.17012794f, 0.09847818f, 
    -0.18355446f, 0.00206750f, -0.04692019f, -0.08061603f, 0.33731648f, 0.07069321f, 0.07556473f, -0.10955310f, 
    0.05273719f, 0.00623344f, 0.12342522f, -0.00795719f, -0.36268270f, 0.18380445f, 0.11999116f, -0.24600133f, 
    -0.00326115f, 0.05988501f, 0.01356155f, 0.31531084f, 0.09453779f, 0.02508481f, -0.15150514f, -0.04019096f, 
    -0.23977929f, 0.01478205f, -0.24587908f, -0.06888389f, 0.03261080f, -0.11028756f, 0.14487706f, -0.02710609f, 
    -0.00396906f, 0.09467381f, 0.12750915f, 0.04542588f, -0.17384277f, 0.26787546f, -0.15546343f, 0.05271942f, 
    0.06743665f, -0.09552116f, 0.11550044f, -0.04865483f, 0.03117791f, 0.04240210f, -0.00923413f, 0.02825512f, 
    -0.33688819f, 0.18112577f, -0.36340734f, 0.24650963f, 0.10609451f, 0.08025329f, 0.06265686f, 0.09061035f, 
    0.13978353f, -0.09823296f, 0.09144848f, 0.00372293f, -0.18450373f, 0.08707556f, -0.05461622f, -0.06989136f, 
    0.08176369f, -0.06291869f, 0.23491909f, -0.07362968f, 0.06878891f, 0.05966835f, -0.03308030f, -0.05422811f, 
    0.31742790f, -0.30212256f, 0.30412918f, -0.09404590f, 0.01702583f, -0.08548713f, -0.04481746f, 0.00704149f, 
    -0.09812126f, -0.13829795f, 0.03741952f, -0.05286352f, -0.30365112f, -0.13148752f, 0.13072458f, -0.27119359f, 
    0.09607676f, 0.18602076f, -0.08033434f, 0.07946549f, 0.06420362f, 0.02941194f, 0.04778947f, -0.07893399f, 
    0.09043469f, -0.36935061f, 0.34230107f, -0.12108310f, 0.25247219f, 0.17533305f, 0.01545040f, -0.16224886f, 
    0.02920743f, 0.02888740f, 0.08811426f, 0.07136898f, 0.40994442f, 0.07777359f, 0.10048307f, 0.14528739f, 
    0.00102174f, -0.16021930f, -0.13781177f, -0.22419277f, 0.25335959f, 0.12018970f, -0.00779910f, -0.13260368f, 
    -0.39729407f, -0.12771675f, -0.24577050f, -0.04873982f, 0.20132031f, 0.03772447f, 0.07090781f, 0.12906976f, 
    -0.04082032f, -0.01692726f, -0.09956516f, 0.00146563f, 0.14167014f, -0.04173722f, 0.02434129f, -0.07703162f, 
    0.10142067f, 0.16768704f, 0.02911128f, 0.27466106f, 0.07630990f, 0.08449563f, -0.01773612f, 0.02204279f, 
    -0.69630116f, -0.06719132f, -0.01086485f, 0.27086377f, -0.02848161f, 0.06684867f, -0.07946852f, 0.12730072f, 
    0.05646480f, 0.03533359f, -0.03313998f, 0.06244478f, -0.06974622f, -0.17878383f, 0.18673195f, -0.08534253f, 
    0.03119779f, -0.04854442f, -0.05351301f, -0.10219330f, 0.01963864f, 0.04021340f, 0.16766401f, 0.04381204f, 
    0.19785160f, -0.36830401f, 0.13452414f, -0.21988951f, 0.01874282f, -0.06468283f, -0.18948033f, -0.24560119f, 
    0.29402477f, 0.00051753f, -0.04151526f, 0.19835949f, -0.10161574f, 0.33773509f, -0.23721765f, 0.30760959f, 
    0.10209361f, -0.03153457f, 0.17571016f, -0.18519035f, 0.10967316f, 0.09843062f, 0.26535976f, 0.21472572f, 
    0.01988594f, -0.03398461f, -0.15049501f, -0.00453296f, 0.04041547f, 0.16850139f, -0.13522749f, 0.02827435f, 
    -0.02324514f, 0.04368534f, 0.13427323f, 0.05894937f, 0.29215926f, -0.02453128f, -0.27173999f, -0.14816827f, 
    -0.09525472f, -0.03866090f, 0.13415124f, 0.02253399f, 0.01354227f, 0.03536194f, -0.04099141f, -0.04107379f, 
    0.03755730f, -0.27032572f, -0.03086414f, -0.29857692f, 0.01118262f, 0.06876131f, 0.10140904f, 0.12797092f, 
    -0.01437800f, 0.00735907f, -0.49409235f, -0.09778722f, 0.29563451f, 0.31619442f, -0.01076774f, 0.00305946f, 
    0.13055225f, -0.01255327f, -0.01003434f, 0.13370724f, 0.07125115f, 0.10648061f, -0.04398449f, -0.00666825f, 
    -0.26232901f, -0.31345004f, -0.77560019f, 0.34407261f, 0.09328725f, 0.13069877f, 0.06208397f, 0.01147346f, 
    0.04522613f, -0.28727788f, -0.07627299f, -0.51974690f, 0.02592240f, 0.07426807f, 0.02667366f, -0.02341177f, 
    0.11265483f, 0.00539022f, 0.12476348f, 0.22509435f, 0.07551142f, 0.14180246f, 0.04688955f, -0.10925721f, 
    0.28405756f, 0.00540907f, 0.18892451f, -0.29081982f, 0.04948166f, 0.12629263f, -0.08989356f, -0.19664447f, 
    0.04154019f, 0.05461400f, 0.07285942f, 0.17001611f, 0.26008704f, 0.28587306f, 0.07883916f, -0.09039666f, 
    -0.17328024f, -0.06689882f, -0.00087027f, 0.09421558f, 0.01343315f, -0.08030681f, -0.17230916f, 0.09226603f, 
    0.22054830f, -0.32681149f, 0.19097936f, -0.84225720f, -0.03045201f, 0.28148699f, 0.04406843f, 0.08898006f, 
    -0.11647796f, -0.05969215f, -0.22401494f, -0.38367340f, 0.13807973f, 0.07128365f, 0.29282066f, 0.21183851f, 
    -0.30305010f, -0.23803137f, 0.00872690f, -0.11969639f, 0.30910635f, -0.01332861f, 0.20257676f, 0.05508729f, 
    0.04622428f, 0.06652555f, 0.05698709f, -0.06214071f, 0.19632959f, 0.16196200f, 0.02206851f, -0.04492878f, 
    0.05090095f, -0.01541575f, -0.06497800f, 0.12028276f, 0.42649338f, 0.19170997f, 0.08404615f, -0.15308763f, 
    0.08965703f, -0.02809841f, 0.10671987f, 0.27999327f, 0.05987830f, 0.09542801f, 0.00000116f, 0.17821461f, 
    -0.17970280f, 0.14094380f, -0.21748526f, -0.01872256f, -0.02815067f, 0.13258982f, 0.28081757f, 0.00125675f, 
    0.06577613f, 0.01513717f, 0.12633538f, 0.16178121f, -0.09151821f, -0.29242268f, -0.01553339f, 0.03837963f, 
    0.46221229f, 0.18888748f, 0.12502289f, -0.09122332f, 0.10780591f, -0.02654991f, 0.08108006f, 0.12661329f, 
    0.16818379f, -0.18776034f, -0.17662381f, 0.09154640f, -0.04431391f, 0.10119995f, -0.30516151f, -0.15279193f, 
    0.11933027f, 0.10371704f, 0.01126371f, 0.07019132f, -0.37551668f, -0.19281365f, 0.16434443f, -0.00077592f, 
    0.09911619f, -0.07391159f, -0.03948044f, 0.00198836f, 0.14079154f, -0.29503554f, -0.00404672f, -0.06926845f, 
    -0.20651874f, -0.13172945f, 0.13533257f, -0.13557796f, -0.00442491f, 0.22871073f, 0.16262268f, -0.12963155f, 
    -0.26842046f, -0.50148004f, -0.41640100f, -0.70833153f, 0.03464934f, 0.17763260f, 0.19718693f, -0.17617311f, 
    -0.19476056f, -0.13365042f, 0.08537552f, 0.02421263f, 0.05093003f, -0.07340724f, -0.00811180f, -0.08384095f, 
    -0.11316098f, 0.09919957f, 0.10576587f, 0.05918354f, 0.24864052f, 0.11037947f, 0.07164048f, 0.04505788f, 
    -0.12124379f, -0.10782915f, 0.11718808f, 0.04964396f, -0.26330659f, -0.39890257f, 0.25297642f, 0.32701966f, 
    -0.00798969f, 0.11877616f, -0.14802007f, 0.08664554f, 0.08274076f, -0.02743582f, -0.04278566f, -0.02876076f, 
    0.16294192f, -0.09346981f, 0.44344211f, -0.12833646f, -0.15763563f, -0.12850657f, -0.01760579f, 0.04019856f, 
    -0.14578480f, 0.07000071f, 0.00344741f, -0.15272321f, -0.03703159f, -0.02724670f, 0.35207400f, 0.12022579f, 
    -0.04914233f, 0.04402008f, -0.05700982f, -0.07704408f, -0.04007473f, -0.06235055f, 0.06644735f, 0.16669546f, 
    -0.12892562f, -0.05432572f, -0.27829194f, -0.01681954f, 0.01150053f, 0.01484684f, 0.18569843f, 0.10960888f, 
    0.02093472f, 0.11472967f, 0.16304886f, 0.20168026f, -0.16483717f, -0.16020101f, -0.01911630f, 0.34521165f, 
    -0.00119795f, -0.15166599f, 0.22520766f, 0.09481564f, 0.14730123f, 0.13441567f, 0.02958181f, 0.21798377f, 
    -0.05609337f, -0.03844036f, -0.25212947f, 0.13174668f, -0.21536052f, -0.10742772f, 0.08360559f, 0.15395032f, 
    -0.03756576f, -0.00920827f, -0.20963730f, -0.11121573f, 0.40815032f, -0.21894173f, -0.10911018f, -0.27088621f, 
    0.00896563f, -0.04975022f, 0.02904480f, 0.03988095f, 0.07223476f, 0.08491106f, 0.11724736f, 0.04879238f, 
    0.03515615f, -0.24547136f, 0.00458494f, 0.18465534f, -0.16246864f, -0.09667756f, -0.03060514f, -0.01522833f, 
    0.00679274f, 0.05388742f, -0.04017591f, -0.00515177f, -0.42033517f, -0.15256406f, -0.05438878f, 0.28845996f, 
    -0.12797332f, -0.05138511f, 0.10883912f, -0.15500169f, -0.04000149f, 0.05744714f, 0.06741836f, 0.11792414f, 
    0.61541629f, -0.31927109f, -0.11951131f, 0.27770013f, 0.20986870f, 0.06472891f, 0.09817232f, -0.03671147f, 
    -0.00760208f, -0.06102990f, 0.25686586f, 0.06210168f, -0.08975419f, -0.07250495f, -0.22460471f, -0.34159711f, 
    -0.13534582f, -0.14227417f, -0.05575408f, -0.09292841f, -0.07022233f, -0.00250923f, 0.00203712f, -0.02737363f, 
    -0.07740868f, 0.42090133f, 0.09596167f, 0.02920656f, 0.01599928f, -0.07568488f, -0.12513728f, 0.18317981f, 
    -0.19864288f, 0.02921645f, 0.10241275f, -0.03479268f, 0.37621734f, -0.04050722f, 0.25802919f, 0.03886089f, 
    -0.11294641f, 0.10074231f, 0.09877884f, 0.13006435f, -0.10104781f, 0.04446249f, -0.13102899f, -0.03897030f, 
    0.08221591f, 0.05205213f, 0.03926366f, -0.08653501f, 0.02950699f, -0.09831389f, 0.16020463f, 0.01404302f, 
    0.01377742f, 0.07987851f, 0.00398473f, 0.06702706f, 0.44160524f, 0.00425582f, 0.04945896f, 0.04662995f, 
    0.04527707f, 0.03739097f, 0.04087441f, 0.19726016f, 0.06945751f, 0.05250745f, 0.01984753f, -0.00157532f, 
    -0.09037410f, -0.01075518f, -0.01627748f, -0.09379670f, -0.06456797f, -0.03370321f, -0.06893916f, -0.05148497f, 
    -0.04552550f, 0.03156485f, -0.05833360f, -0.08322173f, 0.04358701f, -0.22399707f, -0.19438772f, -0.09067013f, 
    -0.02530066f, 0.06563248f, 0.31586874f, 0.12655675f, 0.01717278f, 0.08433947f, -0.02898229f, 0.02545454f, 
    -0.55712414f, -0.39960712f, -0.38601997f, -0.26559556f, -0.03106786f, -0.01596224f, -0.02524553f, 0.09441055f, 
    -0.08794411f, -0.04341086f, 0.05704492f, 0.03314932f, 0.04709649f, -0.29636022f, -0.23388858f, 0.02410911f, 
    0.08354058f, -0.06919231f, 0.28268752f, 0.14036286f, -0.01984491f, -0.02342342f, -0.07764720f, -0.21950477f, 
    -0.11038421f, 0.15880620f, 0.15119241f, 0.18624359f, -0.05049082f, 0.22445141f, -0.10182155f, 0.00770371f, 
    0.30016026f, 0.01747174f, 0.02861251f, -0.13255015f, 0.41819915f, 0.08808699f, 0.12024421f, 0.19092105f, 
    -0.25746673f, -0.01296469f, 0.21621922f, -0.01192389f, -0.08062265f, -0.08036613f, -0.05896138f, -0.17807949f, 
    -0.34189457f, 0.10803162f, -0.12650380f, 0.02979040f, 0.04922115f, -0.02985035f, 0.24840814f, 0.01982523f, 
    0.01961629f, -0.19227444f, 0.23853579f, 0.03269086f, 0.22867289f, -0.00438485f, 0.10218709f, 0.23972619f, 
    0.01269813f, 0.08071888f, 0.04428842f, 0.07456142f, -0.13508150f, 0.10895182f, 0.08723830f, 0.12759072f, 
    0.19254449f, 0.21889861f, -0.05604013f, 0.39528617f, -0.17622490f, 0.19920251f, -0.16339429f, 0.25126112f, 
    0.04847514f, 0.00995989f, -0.04542923f, 0.01765208f, -0.09199625f, 0.03219674f, -0.13137744f, -0.17570761f, 
    0.13782458f, -0.10521984f, -0.03393121f, 0.13978140f, -0.12195250f, -0.02968946f, -0.02828685f, -0.18343072f, 
    0.47819415f, 0.29448891f, 0.03029902f, -0.00856461f, -0.01953137f, 0.09862196f, -0.13781962f, -0.04260089f, 
    0.18608758f, 0.08031142f, -0.15355006f, -0.05228055f, -0.29526499f, -0.15620403f, -0.02805722f, 0.01169911f, 
    0.02805655f, 0.07832767f, 0.04263946f, 0.01670710f, 0.00933421f, 0.13007714f, 0.15703139f, 0.15678270f, 
    -0.23619959f, -0.09424502f, -0.56478548f, 0.29472846f, -0.11152257f, -0.02064746f, 0.05655683f, -0.04418992f, 
    -0.07300409f, 0.11505739f, 0.39300549f, -0.05559985f, -0.04134637f, 0.29921028f, 0.02637029f, 0.06832916f, 
    0.05929365f, -0.13958479f, -0.09872849f, 0.14849423f, 0.10511357f, -0.06088998f, -0.11508662f, -0.04659635f, 
    0.00079402f, 0.02597516f, 0.12052301f, 0.12049831f, -0.12531848f, 0.20749575f, -0.11143998f, 0.00063810f, 
    -0.04396261f, -0.05415092f, -0.01813058f, 0.09729519f, 0.02319738f, 0.49723837f, 0.22388780f, 0.24772549f, 
    0.10150211f, 0.05804238f, 0.23290882f, -0.00919443f, -0.08900840f, -0.01447595f, 0.08796331f, -0.01907008f, 
    0.01629492f, 0.02447895f, 0.15027079f, -0.05749033f, 0.07967652f, 0.14256097f, -0.01728970f, 0.17228355f, 
    0.24039850f, 0.04753341f, -0.09446540f, -0.05907384f, 0.13052048f, 0.32647380f, 0.37500036f, 0.33061513f, 
    -0.02175874f, -0.00580675f, 0.14927080f, 0.23253596f, -0.03201825f, 0.00991495f, 0.01550384f, -0.08247069f, 
    -0.18077260f, -0.13024692f, -0.28980562f, 0.28604108f, -0.17139812f, 0.07571467f, 0.15648957f, -0.00382843f, 
    0.08144255f, -0.03432818f, 0.05522990f, -0.12131160f, 0.14320475f, 0.02242720f, 0.42276451f, -0.03539193f, 
    0.08653121f, -0.07207211f, 0.16433418f, 0.22337061f, 0.01622897f, 0.00318253f, 0.00980386f, -0.04202336f, 
    -0.29512262f, -0.08352794f, 0.06883785f, 0.37016848f, 0.08577026f, 0.05416701f, -0.11370536f, -0.05080486f, 
    -0.00120003f, -0.06788567f, 0.06716312f, 0.00820121f, -0.14165817f, 0.02912812f, 0.11787448f, 0.12591153f, 
    -0.08630841f, -0.13334836f, 0.14884195f, 0.04681389f, 0.02625360f, 0.11182323f, 0.07226697f, 0.13752943f, 
    -0.43820488f, -0.17677145f, 0.21552293f, -0.01959465f, 0.04839736f, 0.15817213f, 0.37486035f, -0.03440615f, 
    -0.13033392f, -0.07305937f, -0.03529492f, 0.02778325f, -0.05819461f, 0.04173981f, 0.18246852f, 0.22513948f, 
    0.12112927f, -0.07428603f, -0.07353818f, -0.06712452f, 0.00221619f, -0.05434354f, -0.01669645f, -0.02035816f, 
    0.14609753f, -0.18488200f, 0.07547244f, 0.19383860f, -0.20203948f, -0.20218322f, -0.12257005f, -0.04127879f, 
    0.10161354f, 0.00981578f, 0.07748096f, 0.05691299f, -0.07466744f, 0.05480066f, -0.25719658f, 0.33359280f, 
    0.04116272f, -0.04658613f, -0.10139956f, 0.34645697f, -0.00999667f, 0.06381057f, 0.01110843f, -0.05181078f, 
    0.22785529f, -0.45135754f, -0.32573745f, 0.00171638f, 0.02086285f, -0.20648134f, 0.18511742f, -0.25353870f, 
    0.10901649f, -0.06151110f, 0.12390521f, 0.21221384f, -0.28890663f, -0.21734205f, -0.27086318f, -0.14279242f, 
    0.01325987f, 0.07883406f, -0.12848780f, -0.12224769f, 0.10543206f, 0.09581185f, 0.09740647f, 0.08450609f, 
    -0.06078089f, -0.34539661f, -0.13102324f, -0.07277264f, 0.06800520f, -0.03079825f, 0.01431503f, -0.20772494f, 
    -0.14018102f, 0.00606921f, -0.05835178f, -0.11044361f, 0.25324178f, 0.21999182f, 0.25404981f, -0.12173884f, 
    0.17630261f, -0.04342160f, -0.08611026f, 0.20905763f, 0.08767054f, 0.10013139f, -0.00386363f, 0.00794434f, 
    0.00536300f, 0.15383872f, -0.04437671f, -0.05305023f, -0.00618118f, -0.00936170f, 0.07176761f, -0.07830560f, 
    0.21007754f, -0.02885938f, 0.14367203f, 0.03574389f, 0.09686894f, 0.34995914f, 0.01743078f, -0.10260063f, 
    -0.00147443f, -0.22640812f, 0.02979582f, 0.04416381f, 0.03523437f, -0.05369891f, 0.03236786f, -0.05652547f, 
    0.00489110f, -0.13178864f, -0.14595151f, -0.01902855f, -0.08285702f, 0.00747172f, -0.17913824f, 0.22072722f, 
    -0.09945492f, 0.06435259f, 0.10601529f, -0.06835985f, 0.29557186f, 0.37527260f, 0.17446516f, 0.09721877f, 
    -0.14969245f, -0.11199659f, 0.14953947f, 0.27574462f, -0.12969901f, 0.15815924f, 0.04924232f, 0.06616386f, 
    -0.08967072f, 0.31253314f, -0.03713885f, 0.31464940f, 0.07027890f, -0.08949665f, -0.06961437f, -0.01945662f, 
    0.03755064f, -0.02813307f, 0.04240093f, 0.00935110f, 0.23366734f, 0.19505446f, -0.23480137f, -0.08721870f, 
    -0.08491091f, 0.14049901f, 0.00789284f, 0.19125362f, -0.07793268f, -0.14552882f, -0.24380581f, -0.05272667f, 
    0.28707808f, 0.16095217f, 0.01341229f, -0.07708273f, 0.05211306f, 0.07313832f, -0.15009113f, -0.06869084f, 
    -0.04942239f, -0.10853206f, -0.04164049f, -0.15098949f, 0.12147201f, -0.14006400f, -0.03202445f, -0.18381554f, 
    0.10782471f, 0.10274273f, 0.01010318f, -0.09378377f, -0.00023008f, -0.08525573f, -0.00887100f, 0.00729818f, 
    0.21958768f, 0.08332197f, 0.20812780f, -0.10023385f, 0.40040538f, -0.09199043f, 0.13223872f, -0.14243285f, 
    -0.03309882f, 0.06478789f, 0.04642686f, 0.18367033f, 0.12102095f, -0.00486910f, -0.10177536f, 0.15013514f, 
    0.00016753f, 0.02949571f, -0.17966986f, -0.14590676f, -0.04900137f, -0.17442198f, -0.14154693f, -0.09770989f, 
    0.32181355f, 0.44095924f, -0.14362562f, -0.08230983f, 0.09895348f, 0.02083892f, 0.01332010f, 0.19355379f, 
    -0.04025381f, -0.08712343f, -0.01245901f, 0.04347738f, 0.30174810f, 0.32184926f, 0.02582765f, 0.04889343f, 
    0.19415085f, -0.05325457f, 0.02142105f, 0.32431459f, 0.00735125f, 0.01600152f, -0.01142988f, -0.01133621f, 
    -0.36256474f, 0.36108306f, -0.02042145f, -0.44451988f, 0.01989614f, 0.09700931f, 0.18053554f, 0.22542611f, 
    0.07811268f, 0.07821769f, -0.10563240f, -0.05042380f, 0.15627484f, 0.27416322f, 0.22197941f, 0.11300068f, 
    -0.10656223f, -0.02697751f, -0.16558677f, -0.17826979f, -0.07730857f, 0.11721075f, -0.01013898f, 0.04114981f, 
    0.33404180f, 0.17233007f, 0.21784870f, 0.27533212f, -0.11580552f, -0.15435778f, 0.11790344f, -0.18411539f, 
    0.04890566f, 0.07237308f, 0.03253524f, 0.05866832f, -0.04059513f, -0.03989845f, 0.05160193f, -0.05979345f, 
    -0.16279532f, -0.06681643f, 0.06871801f, 0.08613412f, 0.14274442f, 0.11938500f, 0.13670577f, 0.05566500f, 
    -0.13297623f, -0.03555324f, -0.07947285f, -0.22547242f, 0.11034095f, 0.18592770f, -0.08254290f, 0.00924579f, 
    0.00036795f, 0.14156258f, 0.07276333f, 0.11378375f, -0.57332808f, -0.23130742f, -0.29434380f, -0.35763028f, 
    -0.08190058f, -0.02471918f, -0.15543486f, -0.29451469f, -0.06068967f, 0.09222120f, -0.03285709f, -0.05192680f, 
    -0.04995041f, -0.10512474f, -0.04446220f, -0.10483526f, 0.02455129f, -0.04723755f, -0.06123284f, 0.00424525f, 
    -0.06304505f, -0.09143142f, 0.01909822f, 0.03260739f, -0.06070700f, 0.01983205f, -0.04574374f, -0.01654435f, 
    -0.06583344f, 0.05608120f, -0.02925451f, -0.08962263f, 0.01971371f, -0.10718062f, -0.05830726f, -0.04529786f, 
    -0.10817183f, -0.00386700f, -0.00551390f, 0.02015869f, -0.04271469f, -0.08607820f, -0.00932263f, 0.00417433f, 
    0.01006867f, -0.10355876f, -0.00658623f, -0.09980380f, -0.08789818f, -0.05801668f, -0.08267654f, -0.00783484f, 
    -0.06245258f, 0.01450470f, 0.02753403f, -0.00007941f, -0.06463704f, -0.05940630f, -0.01173597f, -0.02916140f, 
    -0.11336808f, -0.01568346f, -0.03356170f, -0.02340216f, -0.06270559f, 0.02637591f, -0.04998640f, -0.06757472f, 
    -0.07016470f, -0.00740992f, -0.04431672f, -0.06570782f, 0.03233512f, -0.01485995f, -0.02243185f, -0.07599407f, 
    0.00464073f, -0.09966390f, 0.05252885f, -0.02866920f, 0.00111183f, -0.00302804f, -0.04212387f, -0.03778869f, 
    -0.04062170f, 0.01890464f, -0.01508009f, -0.07262406f, -0.10184907f, -0.10289789f, -0.09913979f, -0.07064063f, 
    -0.00046164f, -0.02345213f, 0.00528147f, -0.05457105f, 0.01586111f, 0.00453263f, 0.00516590f, 0.00076610f, 
    -0.07360387f, -0.00032829f, -0.07282363f, -0.07406851f, -0.00538157f, -0.06387084f, -0.01724845f, -0.07048293f, 
    -0.00475417f, -0.00003935f, -0.02766090f, 0.02290211f, -0.07317894f, 0.01654113f, -0.04425763f, -0.06823894f, 
    0.00614203f, -0.04358963f, -0.00369050f, -0.03054271f, -0.05156888f, 0.03942994f, 0.02740022f, -0.03012263f, 
    0.01008026f, -0.06628027f, -0.02415875f, -0.00251741f, -0.11286528f, 0.01983091f, -0.06041425f, -0.03052586f, 
    -0.08183563f, -0.03747725f, -0.06274082f, -0.03922950f, 0.00730512f, -0.01513388f, -0.06955680f, -0.08602311f, 
    0.01069747f, 0.00687435f, -0.03303187f, -0.00952987f, -0.11441572f, -0.07027054f, -0.00528126f, -0.05131099f, 
    -0.02293390f, -0.06202587f, 0.00719035f, 0.00771896f, -0.02452652f, -0.04129595f, -0.02928877f, -0.00782557f, 
    -0.02063970f, -0.01283917f, -0.01991422f, -0.00391456f, -0.00460155f, -0.04143383f, -0.08048505f, -0.06715804f, 
    -0.01073914f, -0.04991944f, -0.04360214f, -0.00693275f, -0.03002728f, 0.01402566f, -0.05861595f, -0.11339351f, 
    -0.02643846f, -0.01123803f, -0.00552009f, -0.01364452f, -0.05893817f, -0.10477811f, -0.02590055f, -0.01126626f, 
    -0.07463370f, -0.04839425f, 0.04985515f, -0.03732760f, -0.06527706f, -0.03167285f, -0.00957010f, -0.11157984f, 
    -0.01281735f, 0.03628363f, -0.06968638f, -0.04345725f, -0.03219450f, -0.06380901f, 0.01648045f, -0.00266279f, 
    -0.10523348f, 0.02721688f, 0.01199924f, -0.06195023f, -0.01627724f, 0.02480875f, -0.07350462f, -0.08262914f, 
    -0.36768523f, -0.05042436f, -0.15143895f, -0.10025779f, -0.01119030f, 0.03507446f, 0.06558658f, -0.07910303f, 
    -0.00442671f, 0.08380774f, -0.02080043f, -0.03204334f, -0.20128773f, 0.07626188f, 0.28099528f, 0.30563295f, 
    0.13459453f, 0.08622307f, 0.05942401f, 0.00777787f, 0.08081532f, 0.05224198f, 0.06735010f, 0.13810472f, 
    -0.30130440f, 0.03026174f, -0.18743148f, 0.04880089f, -0.02869699f, -0.09886808f, -0.03921512f, 0.11827752f, 
    0.08649612f, -0.00452155f, 0.18637443f, -0.21737319f, -0.02471844f, 0.09388789f, -0.15868264f, 0.01459319f, 
    0.08100258f, 0.01570332f, 0.29595453f, 0.00229581f, -0.12624077f, 0.02912522f, -0.10388666f, -0.14178488f, 
    -0.13343075f, -0.18114531f, 0.24738725f, -0.08115949f, 0.04349308f, 0.24459371f, -0.43539238f, -0.05840496f, 
    0.03195903f, -0.06554327f, -0.29062918f, -0.14297694f, 0.08322889f, 0.00895058f, 0.10999954f, -0.03056677f, 
    -0.05549437f, 0.02024179f, -0.05717252f, 0.04991708f, 0.12621494f, -0.12567878f, -0.02575413f, -0.21667439f, 
    -0.50504881f, -0.04990606f, 0.60181564f, -0.17087321f, 0.05523736f, 0.28896785f, -0.04759260f, 0.26409629f, 
    0.12869756f, -0.12515940f, 0.06615029f, -0.05192805f, 0.58816701f, 0.03053692f, 0.06360188f, -0.05226485f, 
    -0.03841029f, -0.24869213f, -0.07165908f, -0.17756143f, 0.15355088f, -0.19789615f, -0.13809825f, 0.04118515f, 
    -0.20463406f, 0.20058131f, -0.01273142f, -0.04403713f, -0.03003622f, -0.18469284f, -0.15919717f, 0.22301097f, 
    0.05880461f, 0.01559791f, -0.03054713f, -0.02517197f, -0.06079651f, 0.46586737f, 0.00258818f, -0.02243350f, 
    0.10757390f, 0.16817996f, 0.03816989f, 0.16321464f, -0.03550031f, 0.03959211f, -0.26383623f, -0.08536100f, 
    0.26446185f, -0.03792949f, 0.03416855f, 0.11057033f, 0.07870751f, 0.24164096f, 0.03861890f, 0.12571228f, 
    0.04903924f, -0.03215946f, -0.03874717f, 0.08236837f, -0.09668776f, -0.12574038f, 0.17920807f, 0.01299482f, 
    -0.01783483f, -0.17577505f, -0.07685747f, -0.20314701f, 0.00015072f, -0.02229959f, 0.16112690f, -0.01479210f, 
    0.07286505f, 0.17570180f, 0.07236091f, 0.13777903f, -0.14695832f, 0.10113646f, -0.04554129f, -0.12777159f, 
    0.19879800f, 0.10159576f, 0.01557444f, -0.05893638f, 0.00858983f, 0.08883052f, -0.03711127f, -0.00813544f, 
    0.06067825f, -0.17022790f, 0.16809580f, -0.03835235f, 0.08525330f, -0.12302983f, 0.15275504f, 0.05705277f, 
    0.00701615f, -0.09533148f, 0.11504545f, 0.17111012f, -0.15386194f, 0.12519623f, 0.03244068f, -0.04206659f, 
    -0.07391831f, 0.00007425f, 0.11267027f, 0.29385418f, 0.47113380f, 0.07634851f, -0.12717292f, -0.25935689f, 
    -0.13059489f, -0.15057264f, 0.34242085f, -0.11435869f, 0.00931416f, -0.05606502f, -0.08964920f, 0.04513065f, 
    -0.31470728f, -0.01992773f, -0.11145619f, -0.18980525f, 0.01157968f, -0.08043306f, 0.06006770f, -0.15624288f, 
    0.05802420f, 0.14623798f, -0.02538301f, -0.00309385f, -0.43886197f, -0.41670796f, -0.50146854f, -0.53093112f, 
    0.09887948f, -0.24883495f, -0.03982532f, -0.28728172f, -0.05037080f, -0.10012213f, 0.01622040f, -0.02374429f, 
    -0.45176435f, 0.03580915f, -0.26582429f, -0.14858316f, 0.03468730f, 0.08729763f, 0.10882018f, 0.00525694f, 
    -0.03841295f, -0.12970078f, -0.10045744f, 0.02747619f, -0.34523249f, -0.20627028f, -0.03340628f, 0.05485649f, 
    0.25729138f, 0.05207818f, 0.24375115f, -0.07485063f, 0.02724442f, -0.03931824f, 0.07592544f, -0.00849918f, 
    0.21297811f, -0.18234883f, 0.17192167f, 0.19309741f, 0.05324149f, 0.04805166f, 0.11673284f, 0.12657782f, 
    0.06602795f, 0.09664621f, 0.10444982f, 0.08975641f, -0.24866399f, -0.13158530f, 0.00809664f, -0.21340622f, 
    0.03531924f, 0.06523924f, -0.00935111f, 0.18835708f, -0.05923202f, -0.02680323f, 0.08832782f, -0.02966669f, 
    0.50369841f, -0.38427299f, -0.13806474f, 0.04375064f, 0.06887634f, 0.21615931f, 0.08197231f, -0.00696348f, 
    -0.00065947f, 0.03706576f, 0.09743042f, 0.02282294f, 0.02526751f, 0.24910216f, 0.35181764f, 0.14580908f, 
    -0.09043615f, 0.02488147f, -0.03001582f, -0.01592751f, 0.32094339f, 0.22787973f, 0.22380796f, -0.10030219f, 
    -0.33538920f, -0.38410497f, -0.08847115f, 0.14510635f, 0.05381829f, 0.08643557f, 0.14571138f, -0.10159551f, 
    0.01412565f, 0.02012719f, -0.04885827f, 0.10797939f, -0.09915462f, -0.26762089f, -0.17082796f, -0.26644006f, 
    0.10719105f, 0.08686490f, 0.01744739f, -0.03266218f, 0.07352863f, -0.02413016f, 0.09949379f, 0.04977908f, 
    -0.24863234f, 0.04640890f, -0.10315125f, 0.56111246f, -0.10404090f, 0.16506705f, -0.11297657f, 0.05475450f, 
    0.06190562f, 0.12547289f, 0.10120964f, 0.17568065f, -0.25926343f, -0.37913054f, -0.16992287f, -0.26153374f, 
    -0.06137186f, -0.09422863f, -0.12253408f, -0.05663942f, 0.00952606f, -0.13567346f, 0.08806979f, -0.07722246f, 
    0.23606163f, -0.55751419f, 0.26004642f, -0.10028955f, 0.05910812f, -0.02296282f, -0.16782229f, 0.03108260f, 
    0.17748648f, 0.05750694f, 0.13985705f, 0.06434236f, -0.05213754f, 0.53352374f, -0.04593290f, 0.40628546f, 
    0.18353371f, -0.04444672f, 0.22049567f, -0.05514791f, 0.25338560f, 0.35636389f, 0.26469430f, 0.30963299f, 
    -0.16643335f, -0.09390511f, -0.22182274f, -0.12753840f, 0.08367939f, 0.10788737f, -0.07224327f, 0.02997054f, 
    0.11427440f, 0.00423659f, -0.05020894f, 0.15525240f, 0.13294478f, 0.21009478f, -0.05442192f, 0.17571656f, 
    0.05824786f, 0.04687048f, 0.06796274f, 0.21566644f, 0.06888097f, -0.07191546f, -0.00173210f, 0.10779989f, 
    -0.06908214f, -0.01805098f, 0.04725140f, -0.07354322f, -0.02478620f, -0.05916698f, 0.01772168f, -0.01238339f, 
    0.06455520f, -0.00547904f, -0.01403254f, 0.04047921f, -0.00616950f, -0.06003933f, 0.04568177f, -0.00519373f, 
    0.03632918f, 0.01328757f, -0.00150676f, -0.03746506f, 0.01007550f, -0.06229008f, -0.05500375f, 0.00237244f, 
    0.00183437f, 0.03648120f, -0.01941273f, 0.05059173f, 0.03377869f, 0.00397566f, 0.06118687f, -0.02998008f, 
    0.05860651f, -0.04260030f, 0.05976893f, -0.02808588f, -0.03069753f, -0.05107037f, 0.04668519f, -0.04126963f, 
    -0.05846453f, -0.06321334f, 0.04057856f, -0.06201125f, -0.08507123f, -0.00221234f, -0.06131578f, -0.04194793f, 
    0.05332781f, -0.05807593f, -0.05173536f, -0.02590228f, 0.02622409f, -0.07090927f, 0.03919100f, 0.04994223f, 
    -0.02043100f, -0.02634554f, -0.01436633f, -0.04428377f, -0.00356017f, -0.03391363f, -0.05349326f, 0.02685249f, 
    0.00189339f, 0.04620684f, -0.01262958f, 0.00138584f, 0.00497339f, 0.00722127f, -0.04288546f, 0.05065452f, 
    -0.05285454f, 0.03281197f, 0.01175950f, -0.00586809f, 0.00324196f, -0.04183343f, -0.03803058f, 0.01480532f, 
    -0.00476590f, 0.02532684f, -0.01802726f, 0.04880522f, -0.00723620f, 0.06408090f, -0.01818886f, -0.05188476f, 
    0.01675008f, -0.00664413f, -0.02360035f, -0.03100880f, 0.05371737f, -0.06331679f, 0.02682687f, -0.06077620f, 
    -0.05832217f, -0.03703160f, -0.01990806f, -0.06244871f, 0.06407247f, -0.01540703f, -0.04354385f, 0.01003066f, 
    -0.07461227f, 0.04352012f, 0.05703073f, -0.04629693f, -0.07522496f, -0.02109426f, 0.05135733f, 0.04492315f, 
    -0.04574157f, -0.03037684f, 0.02412353f, 0.00334522f, 0.01869556f, -0.03438684f, -0.00002533f, -0.05038121f, 
    -0.02019744f, -0.06436449f, 0.02943983f, 0.03816072f, -0.05705040f, 0.05178112f, -0.03715864f, -0.02059792f, 
    -0.05166889f, 0.01573966f, -0.04024767f, -0.01064915f, -0.05852346f, 0.03507340f, -0.05192966f, 0.03774829f, 
    0.01310724f, 0.02473919f, 0.01339603f, 0.04095399f, -0.07865365f, 0.02099958f, -0.03797857f, -0.06298403f, 
    -0.07116710f, -0.07645671f, -0.01818171f, -0.05870870f, 0.03674230f, 0.01248382f, 0.03705307f, 0.05877809f, 
    -0.00174033f, -0.01256653f, -0.04130202f, -0.01542177f, -0.02349308f, -0.07833561f, 0.03712137f, -0.05054506f, 
    -0.02421136f, 0.06363944f, 0.05675525f, 0.02890302f, 0.01067917f, -0.07008491f, 0.00833757f, 0.01317419f, 
    0.06328402f, -0.03720937f, 0.00702194f, -0.00155908f, -0.05199854f, 0.02491436f, -0.05842668f, -0.06898738f, 
    -0.06803805f, -0.02338352f, 0.03528803f, -0.07123557f, -0.04139309f, -0.00609729f, -0.02303281f, -0.05444701f, 
    -0.03684736f, -0.03640190f, 0.00047832f, -0.00533062f, 0.03882526f, 0.05800287f, -0.00637169f, -0.06543719f, 
    0.07217464f, -0.11890297f, -0.05305142f, -0.05533332f, -0.03689965f, 0.14614666f, -0.16641352f, -0.25284544f, 
    -0.23582990f, -0.08805925f, 0.18543211f, 0.09585218f, 0.21308608f, -0.04450776f, 0.03344665f, 0.00131583f, 
    0.12420230f, 0.13276257f, -0.02015974f, -0.12778181f, -0.10515931f, 0.06998276f, 0.03334017f, 0.10050319f, 
    0.05602814f, -0.00451256f, 0.04792653f, -0.01538025f, 0.07423479f, -0.08956914f, -0.06188601f, -0.07617327f, 
    -0.02731613f, -0.00051209f, 0.03626693f, 0.13606980f, 0.25598937f, 0.07359792f, -0.29991695f, 0.35283205f, 
    -0.11108757f, 0.08866458f, 0.17874989f, -0.06036085f, -0.04713051f, -0.13741815f, -0.04614817f, -0.08602375f, 
    -0.07171569f, 0.59557444f, 0.09518969f, -0.31637359f, -0.07042824f, 0.06094068f, 0.17174880f, 0.01559861f, 
    0.17719567f, -0.15776570f, -0.04617150f, -0.01407081f, 0.05806567f, -0.06522055f, -0.16546470f, 0.02624087f, 
    0.32161731f, 0.30734095f, -0.02861143f, 0.04858422f, 0.09237777f, -0.14648947f, -0.04885442f, -0.00782345f, 
    0.31748924f, 0.18963943f, -0.39994797f, 0.03552679f, 0.03873242f, 0.05750732f, -0.29538259f, -0.12772976f, 
    0.03743767f, 0.10951691f, 0.00875090f, 0.23465787f, -0.03243997f, -0.04384179f, -0.13063483f, -0.38313019f, 
    -0.00859067f, -0.00596694f, -0.01850716f, 0.20240705f, 0.07032155f, 0.10502174f, -0.03490893f, -0.09322786f, 
    0.22357416f, 0.21599638f, -0.19560696f, -0.27711362f, 0.32347682f, 0.15499030f, 0.05547700f, -0.08210913f, 
    -0.19745366f, 0.08755871f, -0.09470506f, -0.00541015f, 0.27954957f, 0.07712838f, -0.10603029f, -0.20390719f, 
    0.12455251f, 0.06287629f, 0.20521742f, -0.14126477f, 0.13137996f, 0.03024789f, -0.01437486f, 0.18119800f, 
    -0.02814135f, 0.21368816f, 0.31787741f, -0.10786992f, 0.17997262f, -0.03099725f, -0.07853366f, 0.21159248f, 
    -0.02999433f, -0.01608752f, 0.19129017f, -0.26013526f, -0.00659218f, 0.05960806f, 0.03891975f, -0.04683216f, 
    0.00696147f, -0.06911050f, -0.05358508f, -0.08171803f, 0.00196646f, 0.03831207f, 0.10208574f, 0.01965013f, 
    -0.02988461f, 0.34353754f, -0.16717742f, 0.19672127f, -0.10213687f, -0.06541438f, 0.03825806f, 0.06098809f, 
    -0.04391799f, -0.04055252f, 0.01786963f, 0.21931984f, -0.12439760f, -0.09093553f, 0.11789329f, 0.02559802f, 
    -0.20471320f, -0.03779686f, -0.06688973f, 0.00037039f, 0.09470785f, 0.29709193f, -0.01210046f, 0.14149429f, 
    -0.10947036f, -0.03949570f, -0.02255466f, 0.00163136f, 0.22318508f, 0.05317508f, -0.06945862f, 0.02786098f, 
    -0.00059085f, 0.04393824f, 0.15520447f, 0.10448366f, -0.52842039f, -0.30493769f, 0.11649896f, -0.06564244f, 
    0.16665226f, 0.35821357f, 0.22987558f, 0.38351527f, -0.07495980f, -0.02338202f, -0.15090270f, -0.09261100f, 
    -0.06313881f, -0.03105894f, -0.04651490f, -0.07467027f, 0.02319442f, 0.00864409f, 0.01874954f, 0.00173670f, 
    0.01786246f, 0.00032815f, 0.01737793f, -0.00216819f, -0.07661089f, 0.01402934f, -0.06897713f, 0.01607331f, 
    0.02654519f, 0.04148247f, -0.07619773f, 0.00741793f, -0.00326375f, -0.05023735f, 0.03822264f, -0.05738982f, 
    -0.00716875f, 0.04282792f, -0.02648724f, 0.06249861f, 0.05022445f, 0.03953927f, -0.00278302f, -0.06513301f, 
    -0.01017937f, -0.02041732f, 0.04295449f, -0.05383039f, -0.07142595f, -0.01455403f, -0.00030643f, 0.00364446f, 
    0.00290798f, 0.05614855f, 0.04037369f, -0.04856633f, -0.05519581f, -0.02246536f, -0.04001728f, 0.00332557f, 
    0.03232655f, -0.03043359f, -0.02476628f, 0.04898756f, 0.02422513f, -0.04967440f, 0.02661987f, 0.00298078f, 
    -0.06973922f, -0.04268593f, -0.00486145f, 0.01844865f, -0.05986098f, -0.01793574f, 0.00924257f, 0.04189899f, 
    0.05686475f, 0.01781385f, 0.01645020f, -0.03593877f, -0.00647174f, -0.02021773f, -0.05807831f, -0.05443329f, 
    -0.05196458f, -0.00446826f, 0.02530302f, -0.05406604f, -0.01918581f, -0.06820496f, -0.00112533f, 0.05933496f, 
    0.03210234f, -0.05647494f, -0.07880614f, -0.05753683f, 0.02019986f, 0.01612162f, 0.03867097f, 0.03817279f, 
    0.03733482f, 0.05131252f, -0.05164944f, 0.02259305f, -0.06612665f, -0.00640085f, -0.07262981f, 0.04802163f, 
    0.04875436f, -0.01099326f, -0.01380760f, -0.02459456f, 0.05826725f, -0.04294957f, 0.00122112f, 0.00079846f, 
    0.00116051f, 0.03203741f, -0.05111207f, 0.02911912f, -0.07893976f, -0.00389997f, 0.01005984f, -0.05395776f, 
    -0.06197545f, -0.03860485f, -0.00088981f, 0.04533906f, 0.05683195f, -0.02044240f, 0.01058815f, 0.02439160f, 
    -0.00797189f, 0.05511456f, -0.06951642f, -0.03984082f, 0.05931458f, 0.01715740f, -0.01355997f, -0.03767125f, 
    -0.00139117f, 0.03036404f, -0.03435351f, -0.02385660f, -0.07580337f, -0.03049840f, -0.06627443f, -0.06964348f, 
    0.06482635f, -0.05841780f, 0.00555191f, 0.04624976f, -0.06216543f, -0.06784978f, 0.02900081f, 0.05616738f, 
    -0.00310615f, -0.02929447f, -0.04506882f, -0.04616895f, 0.04110722f, -0.02764561f, -0.01281396f, -0.04736094f, 
    -0.03653283f, 0.05765689f, -0.03268672f, 0.05968998f, 0.02645108f, -0.03996393f, -0.03494726f, -0.01133171f, 
    -0.03376019f, 0.03553328f, -0.07448850f, -0.05485278f, 0.00688529f, -0.06219172f, -0.05931259f, 0.06189631f, 
    -0.01005011f, -0.03450073f, 0.05723546f, 0.04835447f, -0.00458523f, -0.02351067f, 0.04421579f, 0.03948135f, 
    0.05757206f, -0.01976235f, -0.04853585f, -0.01558419f, -0.04235933f, -0.04443308f, 0.02220238f, -0.00308773f, 
    -0.00923077f, -0.01599868f, 0.04510242f, -0.03203134f, 0.06019495f, 0.01992794f, -0.01555225f, -0.00693768f, 
    0.00659401f, 0.06161637f, 0.03724295f, 0.01043542f, 0.00136995f, 0.05219526f, -0.02788720f, 0.01983782f, 
    -0.05773207f, -0.06419315f, 0.02265390f, -0.06796146f, -0.00779991f, 0.01566153f, 0.03773674f, -0.04018613f, 
    0.03203014f, 0.03095630f, -0.04558525f, 0.01489218f, -0.07182656f, 0.06266919f, 0.03053315f, -0.01728560f, 
    0.01730426f, -0.01077755f, 0.05983974f, -0.05531166f, 0.00541561f, -0.04748822f, 0.00639323f, -0.07511539f, 
    0.03000174f, -0.02319918f, -0.05538959f, -0.05071736f, 0.03154702f, -0.05988928f, 0.03593009f, -0.07175332f, 
    0.02762508f, -0.02974322f, 0.04015260f, -0.07544824f, -0.07508106f, -0.01830022f, 0.01218306f, 0.04045974f, 
    -0.03751728f, -0.06350126f, 0.01001657f, -0.06269175f, -0.01447223f, -0.05773354f, -0.06886784f, 0.02144699f, 
    0.06132165f, -0.05155331f, 0.02690133f, -0.01928987f, -0.02074723f, -0.05824130f, 0.03001084f, -0.00933025f, 
    -0.00349231f, -0.04938835f, 0.00772130f, 0.00838763f, 0.00181309f, -0.03495019f, 0.05385913f, 0.05898134f, 
    0.01039576f, 0.04225273f, -0.03978515f, -0.04746148f, 0.00310980f, -0.00644557f, -0.06994618f, -0.00559783f, 
    -0.04982808f, -0.04361749f, -0.00562898f, -0.06493643f, -0.01933062f, -0.02907545f, 0.02764715f, -0.02933225f, 
    0.02607103f, -0.04346074f, -0.03681533f, 0.02784571f, 0.02017364f, -0.05890011f, -0.07137594f, -0.02060899f, 
    0.01597460f, -0.02640379f, 0.06309538f, -0.03064817f, -0.06956419f, 0.04050991f, 0.05567743f, -0.07162699f, 
    0.05864650f, -0.00901387f, 0.02431601f, 0.02843645f, 0.05415276f, -0.00096976f, -0.07150077f, -0.00558992f, 
    -0.06038355f, 0.00283599f, -0.02063790f, 0.04684674f, -0.07526469f, 0.03152517f, -0.05414192f, -0.00025585f, 
    -0.02296542f, -0.03369015f, -0.01714433f, 0.05823425f, -0.02311670f, 0.00972238f, 0.05495529f, 0.05869348f, 
    0.01221488f, -0.03617739f, -0.05354357f, -0.06786206f, 0.03959733f, 0.03581858f, -0.03335910f, -0.07614877f, 
    0.03597022f, -0.03225829f, -0.05793946f, -0.02100696f, -0.00359160f, 0.06090017f, -0.05139490f, 0.01587810f, 
    -0.07961413f, -0.00899127f, -0.05952909f, -0.01273602f, -0.03590588f, -0.00926888f, -0.00692838f, -0.01285771f, 
    0.03736044f, 0.01349532f, 0.00010513f, -0.02228032f, -0.02607507f, -0.03757212f, -0.01527899f, -0.02692749f, 
    0.01927981f, -0.03822332f, -0.03017441f, -0.02840550f, -0.04879496f, -0.06344931f, 0.03438860f, 0.05732108f, 
    -0.04841767f, 0.03924923f, -0.03826573f, 0.04031641f, 0.00503987f, 0.00689590f, -0.06775963f, 0.04352531f, 
    0.02653923f, 0.01265804f, -0.04246213f, -0.04390449f, -0.04995975f, 0.05259628f, 0.06731907f, -0.04958149f, 
    -0.01590050f, -0.06400026f, -0.02567319f, -0.03041373f, -0.06419428f, -0.03277953f, -0.04226805f, 0.05058214f, 
    -0.24452293f, -0.06674399f, 0.11299384f, 0.18507020f, 0.02354684f, 0.08315779f, 0.13749738f, 0.04169443f, 
    -0.00595951f, 0.12744500f, 0.25703749f, -0.02071788f, -0.10816640f, -0.11135213f, 0.06964124f, 0.28462729f, 
    0.15623772f, 0.13502991f, 0.01908262f, 0.06258181f, 0.07993785f, 0.03992900f, -0.00329983f, -0.04780097f, 
    -0.31552497f, 0.04899934f, 0.23406871f, 0.15450110f, -0.10358256f, 0.03922319f, -0.00224089f, 0.02993900f, 
    0.01281644f, 0.05623842f, 0.10555543f, -0.06191828f, 0.05518311f, 0.09000858f, 0.44541791f, 0.17010699f, 
    0.11452521f, 0.24920304f, -0.12563431f, -0.04335538f, 0.22068426f, 0.01946242f, 0.03101415f, 0.06648985f, 
    0.29648077f, -0.00593371f, -0.22962919f, -0.27036700f, 0.02108441f, -0.16041178f, 0.18366790f, -0.01005911f, 
    -0.13252614f, -0.01646113f, -0.07981164f, -0.07457843f, -0.39772514f, -0.18526939f, -0.19985312f, 0.11676130f, 
    0.29133081f, -0.00785449f, 0.02243975f, 0.00714118f, 0.02575329f, 0.14825788f, -0.01634412f, 0.12061997f, 
    0.12052193f, -0.06280272f, 0.23863974f, -0.02994100f, 0.07007278f, 0.03965619f, 0.06280895f, -0.06713486f, 
    0.03868837f, 0.08623274f, 0.00383060f, -0.00965311f, 0.33236599f, 0.03946417f, -0.18513899f, -0.24743731f, 
    0.06840741f, -0.02758292f, -0.07759022f, -0.08784214f, 0.02031214f, 0.11918746f, -0.06283696f, -0.08220081f, 
    0.12456056f, -0.37542930f, -0.27149278f, -0.16671948f, 0.07756891f, 0.06052241f, 0.19703263f, 0.05003463f, 
    -0.05235483f, -0.04443344f, -0.03272824f, 0.10045837f, 0.10558990f, -0.13274170f, -0.23921858f, 0.30905718f, 
    -0.09815800f, 0.11949639f, -0.13858834f, -0.00298935f, 0.04944466f, 0.04788064f, -0.08972663f, 0.09473302f, 
    0.22413787f, -0.29277900f, 0.23487234f, 0.11774084f, 0.04675177f, -0.00761654f, 0.03248106f, 0.07861748f, 
    -0.10524777f, 0.02315565f, 0.08114756f, -0.03882360f, -0.04214222f, 0.03088838f, -0.03918371f, -0.29971918f, 
    0.01210107f, -0.03112590f, -0.00914392f, -0.06134873f, 0.06061575f, 0.04116514f, 0.07000087f, 0.11237171f, 
    -0.23114686f, 0.01514950f, 0.10658341f, -0.54329616f, -0.01698167f, 0.01877226f, -0.12726611f, -0.23297055f, 
    0.21618882f, -0.20744213f, -0.15132502f, 0.02378645f, 0.17938188f, -0.20786108f, 0.14813323f, 0.24872650f, 
    -0.06575036f, 0.05228701f, 0.07323245f, -0.09242783f, -0.11277335f, 0.16207261f, 0.23591940f, 0.02395791f, 
    0.08744918f, 0.03714814f, -0.08952379f, -0.08139922f, 0.05532778f, 0.00428597f, 0.08520417f, -0.05858876f, 
    0.00514265f, 0.11756690f, 0.13009676f, 0.09914611f, 0.72256011f, -0.42801389f, -0.21442823f, -0.14015698f, 
    0.00510261f, 0.09100144f, 0.01609221f, 0.26545018f, 0.03988827f, 0.06086217f, -0.05054658f, -0.12564600f, 
    -0.23866893f, -0.07524922f, -0.38803408f, -0.15589558f, -0.03471347f, 0.05549666f, -0.00181468f, -0.02143778f, 
    0.01695195f, 0.00265789f, -0.15024659f, -0.01980884f, -0.00562849f, 0.16923954f, 0.17192361f, 0.05606553f, 
    0.09630532f, 0.37361249f, 0.03563058f, 0.21069467f, 0.06602271f, 0.08985265f, 0.09703957f, -0.02584774f, 
    -0.32211038f, -0.06032284f, 0.19249463f, -0.01682255f, 0.11812932f, -0.06373107f, -0.08821039f, 0.06703130f, 
    0.07760377f, -0.04089800f, -0.14892307f, -0.18390346f, 0.14366584f, 0.25873959f, 0.20025189f, 0.10475535f, 
    0.13817245f, -0.06033523f, -0.08204144f, -0.07333300f, 0.05049152f, 0.04746493f, 0.08962118f, 0.19263636f, 
    -0.01571302f, 0.02576179f, -0.10318442f, 0.13198112f, 0.10471867f, 0.01560183f, -0.07401259f, -0.03105958f, 
    0.06735525f, 0.17572963f, -0.03615798f, 0.11493544f, 0.20100237f, -0.07683722f, 0.21358930f, 0.37206411f, 
    0.11325581f, 0.12177820f, 0.16513346f, -0.06717186f, -0.05956114f, -0.02616867f, 0.14580335f, 0.12997408f, 
    -0.01810469f, 0.04416335f, 0.02649358f, 0.05502497f, 0.03533653f, -0.13063599f, -0.03384033f, -0.18524079f, 
    -0.14828674f, 0.03796172f, -0.13784163f, -0.14127311f, 0.12500823f, -0.09519494f, -0.08176176f, 0.13314866f, 
    0.15504314f, 0.04404631f, 0.07625610f, -0.02197535f, 0.06629512f, 0.00488716f, 0.21376768f, 0.30995372f, 
    0.06398288f, 0.00428050f, 0.28558984f, 0.32078233f, -0.12745082f, -0.02655828f, -0.21750544f, 0.06061448f, 
    0.16522494f, -0.02093285f, 0.05857427f, 0.16273504f, 0.03167676f, 0.08376580f, 0.22684528f, -0.00688073f, 
    0.01331834f, -0.03237312f, 0.17071836f, -0.12121733f, -0.00873782f, -0.15897907f, 0.20939639f, -0.09089117f, 
    0.43889061f, 0.01913891f, -0.18181247f, 0.17292666f, -0.01438767f, -0.05838209f, -0.21741727f, -0.18629842f, 
    -0.12588249f, -0.01819661f, 0.02408287f, 0.13558434f, -0.35260665f, -0.41988033f, -0.06690933f, 0.10311083f, 
    -0.18608961f, 0.00628104f, -0.13719392f, 0.07804909f, -0.06368184f, 0.04506314f, -0.14477432f, 0.14961150f, 
    -0.39383963f, -0.40878269f, 0.08711146f, -0.28183931f, 0.03103114f, -0.26254371f, -0.29287699f, 0.08954474f, 
    -0.27260241f, -0.09263810f, 0.20414399f, -0.13043267f, 0.16151027f, -0.01681704f, -0.22111650f, 0.17070928f, 
    0.08845402f, 0.06608351f, -0.15570617f, -0.00105636f, -0.05952511f, -0.03246231f, -0.13696265f, -0.15247492f, 
    0.20598987f, 0.03810473f, -0.08104689f, -0.09723644f, 0.10588191f, -0.02995423f, -0.08159845f, 0.09413791f, 
    -0.06767654f, -0.17048964f, -0.26797655f, -0.15706837f, 0.47196740f, -0.01703761f, 0.03371461f, 0.34828535f, 
    -0.04408612f, 0.06949337f, -0.11842830f, -0.05674094f, -0.14535916f, -0.12489212f, 0.12524045f, 0.13561720f, 
    0.03966748f, 0.14781529f, 0.09967106f, 0.11025251f, 0.13301079f, -0.11209441f, 0.33612713f, -0.03067411f, 
    0.12569010f, -0.02755559f, -0.19807033f, -0.19701628f, 0.01683677f, -0.02954221f, -0.11786167f, -0.08324548f, 
    0.28230235f, 0.10876318f, -0.07179043f, -0.24478571f, 0.04139676f, -0.21934670f, -0.17463760f, -0.08765890f, 
    0.28965941f, -0.16763583f, 0.02080998f, -0.19300605f, -0.01657547f, 0.14318162f, 0.03738344f, -0.05417120f, 
    -0.22001047f, 0.02469565f, -0.04187677f, -0.17045632f, -0.17628677f, -0.17109963f, 0.51301318f, -0.06518783f, 
    0.18651719f, 0.13870831f, -0.11216415f, 0.16688420f, 0.29922527f, 0.26829898f, 0.09258001f, 0.08519761f, 
    -0.05067036f, -0.07110668f, -0.09431877f, 0.28188801f, 0.10782202f, -0.22141021f, 0.29866454f, 0.16692117f, 
    0.19136484f, 0.19050655f, 0.27082390f, 0.20657475f, -0.26366782f, 0.14248388f, 0.03312141f, -0.08232248f, 
    0.09101371f, -0.00476555f, 0.02499206f, 0.05533919f, 0.12766905f, -0.03412289f, -0.03380894f, 0.13735251f, 
    -0.30673903f, -0.07210877f, 0.11427344f, -0.02163714f, 0.08354352f, -0.00486371f, 0.13547319f, 0.08765426f, 
    -0.20496680f, -0.01270849f, -0.22172201f, -0.29252562f, -0.42549911f, 0.27058068f, 0.12002232f, -0.10601247f, 
    0.15624830f, -0.05644243f, -0.01647720f, 0.24606839f, 0.02317757f, 0.20856757f, 0.29757681f, 0.14007217f, 
    -0.22400646f, -0.29478568f, 0.12999977f, -0.17384945f, 0.20829664f, 0.14100045f, 0.14184701f, -0.01787249f, 
    0.03708845f, -0.14868397f, -0.04160924f, 0.09702665f, 0.00374562f, -0.26252404f, 0.08695260f, 0.25113401f, 
    -0.05631064f, 0.19426078f, -0.17709488f, -0.13214616f, 0.14101814f, -0.13640913f, 0.02529315f, 0.01057297f, 
    -0.07584361f, -0.21477427f, 0.23876011f, 0.13944599f, -0.13237184f, 0.04109020f, 0.03990717f, 0.03936392f, 
    -0.03277837f, 0.04755370f, 0.14489883f, 0.29100117f, -0.10907962f, -0.00515832f, -0.33492029f, 0.03745266f, 
    0.08001606f, 0.05018405f, -0.05790497f, 0.15223297f, 0.07162196f, 0.09878684f, 0.04828344f, -0.03064264f, 
    -0.10395704f, 0.02962323f, 0.21605347f, -0.39768183f, 0.02614521f, 0.01252060f, -0.06254471f, 0.16715178f, 
    0.25387159f, -0.06051278f, 0.05577089f, 0.01348544f, 0.19639023f, -0.02353205f, 0.14814264f, -0.03893530f, 
    0.14431849f, 0.12178638f, 0.01676525f, -0.12139327f, 0.02802142f, 0.26382625f, 0.22938114f, -0.10982670f, 
    0.08591826f, 0.01174278f, -0.18738581f, -0.07007929f, -0.03431110f, 0.13415159f, 0.08088177f, -0.17135242f, 
    0.02705303f, -0.17002861f, -0.44178203f, -0.38928664f, 0.40619209f, 0.18902634f, 0.12425528f, 0.28043070f, 
    0.07207628f, 0.02480228f, -0.05695117f, 0.23925206f, -0.01052554f, -0.12956777f, -0.03039185f, -0.04420458f, 
    -0.37324035f, -0.28300893f, 0.23446827f, 0.17269847f, -0.17127359f, 0.00394861f, -0.01189145f, 0.13055323f, 
    -0.00835244f, 0.04124726f, -0.18688414f, -0.41788098f, 0.47222346f, 0.25988576f, -0.02893270f, 0.24706070f, 
    0.10697213f, -0.05306109f, 0.15428275f, 0.24910474f, -0.06256162f, 0.14390020f, -0.03323086f, -0.09717288f, 
    -0.35208282f, -0.05113090f, -0.05723234f, 0.51896703f, 0.05474027f, 0.19647303f, 0.12564115f, 0.05802997f, 
    0.02671688f, -0.11794946f, 0.20024624f, -0.22842702f, 0.26244703f, 0.07314473f, 0.38408580f, 0.02200458f, 
    0.09002219f, 0.23608543f, 0.03583164f, 0.31046990f, 0.09082986f, 0.18341660f, -0.12338783f, -0.16722958f, 
    0.13145773f, 0.19208421f, -0.02718673f, -0.17232911f, -0.01603930f, -0.03217870f, 0.11053500f, 0.05626446f, 
    0.02003468f, -0.08896842f, 0.07594995f, 0.18368378f, 0.05711597f, 0.19905251f, -0.24477264f, -0.12835684f, 
    -0.03897822f, 0.01976036f, 0.08519371f, -0.13275735f, 0.02582962f, -0.03424693f, -0.15005481f, 0.24534917f, 
    -0.10276052f, 0.19970988f, 0.26827687f, -0.30162239f, 0.17643845f, -0.07033640f, 0.20699115f, 0.03116658f, 
    -0.30661470f, -0.02635798f, -0.12784298f, -0.14531754f, -0.01127516f, 0.14069320f, 0.03090636f, 0.10407581f, 
    -0.01217599f, 0.15708980f, -0.13904761f, -0.07309833f, -0.03409925f, -0.00412914f, 0.12359107f, 0.09938559f, 
    0.41630605f, -0.18706059f, -0.22193527f, -0.11972407f, 0.04148924f, 0.16335097f, 0.11262839f, -0.01945876f, 
    0.03066674f, 0.02688486f, 0.05416768f, 0.25889876f, 0.37578177f, 0.00216126f, -0.26222503f, 0.13489448f, 
    0.14701922f, 0.07106327f, -0.11165022f, 0.27931613f, -0.02228579f, 0.01815428f, 0.01749546f, 0.04957867f, 
    0.19803193f, -0.22236027f, -0.14093575f, -0.20722507f, -0.33111393f, 0.06395419f, 0.17255518f, -0.04850024f, 
    0.10108712f, 0.01167267f, 0.07283683f, 0.12679900f, 0.00897670f, 0.19675770f, -0.09164131f, -0.10160388f, 
    0.29380822f, 0.12902535f, -0.15102316f, -0.11631722f, -0.13349137f, -0.05690138f, 0.05688957f, -0.07316887f, 
    -0.18466215f, -0.06433421f, -0.19248852f, -0.08135024f, -0.00034514f, -0.06555974f, -0.17486833f, -0.28529370f, 
    -0.08123975f, -0.01790191f, 0.02105733f, -0.03100826f, -0.05121709f, -0.16123945f, 0.36459497f, -0.14066081f, 
    0.11304244f, -0.04145238f, -0.23340154f, 0.16734438f, 0.02670517f, 0.11705244f, -0.00434763f, -0.06783104f, 
    -0.12891388f, 0.09790066f, 0.16171484f, -0.19916078f, -0.03782240f, 0.10069571f, 0.04666600f, -0.26573756f, 
    -0.00226391f, -0.24304911f, -0.39991760f, -0.19476910f, 0.20972551f, -0.11323449f, -0.00929247f, -0.29097483f, 
    0.02606743f, -0.19739249f, -0.03099879f, 0.00167315f, -0.00883539f, -0.01057281f, -0.07517566f, -0.19573428f, 
    0.02426250f, -0.03976293f, 0.05361510f, -0.01128465f, 0.03774130f, -0.06835015f, -0.03374108f, 0.00725168f, 
    -0.05231356f, -0.07029788f, 0.03448714f, 0.01064971f, 0.02644442f, -0.01623767f, 0.05684481f, -0.07350001f, 
    -0.05181867f, 0.02503306f, -0.03928554f, 0.00091952f, -0.00339790f, 0.04672864f, -0.05050520f, -0.04881016f, 
    0.05315392f, -0.02569499f, -0.07638179f, 0.06195567f, 0.05072707f, -0.00871937f, 0.05229383f, -0.07469606f, 
    0.05006097f, 0.05646513f, 0.00918950f, -0.02978776f, -0.03798326f, 0.05009178f, -0.01127591f, -0.04848969f, 
    -0.00216067f, -0.06138504f, -0.03643712f, -0.02309761f, 0.04791388f, -0.00532796f, -0.04554558f, 0.03763173f, 
    -0.01003758f, 0.06522392f, -0.04587960f, -0.03749049f, 0.01321639f, -0.04804689f, 0.03645175f, 0.04524244f, 
    0.02035566f, 0.05906597f, 0.05194064f, -0.04028629f, -0.01653656f, -0.02242578f, -0.04873281f, 0.01633756f, 
    -0.03836340f, -0.03127196f, -0.05923113f, 0.04058865f, 0.05760503f, 0.05032062f, -0.05170236f, -0.03673281f, 
    -0.01540040f, 0.02113660f, 0.05591762f, -0.00398808f, 0.01725931f, 0.00673446f, -0.03098976f, -0.06683146f, 
    -0.06094238f, 0.02292111f, 0.02011079f, -0.01672335f, -0.07443312f, 0.03392952f, -0.02885193f, 0.05820106f, 
    -0.05897906f, -0.04837862f, -0.00303235f, -0.03361660f, -0.01184659f, 0.01511973f, -0.02609214f, 0.00532850f, 
    -0.02056945f, 0.02522129f, 0.01125995f, -0.02996883f, 0.06644922f, -0.02688426f, -0.03981233f, 0.00617070f, 
    0.04711033f, 0.03265007f, 0.00971722f, 0.00026437f, 0.02112889f, 0.05609938f, -0.06172144f, 0.00759122f, 
    -0.02440635f, -0.04957643f, 0.00089715f, -0.04573046f, -0.01072327f, -0.00804400f, 0.00689542f, -0.01948735f, 
    -0.06050253f, -0.02497846f, -0.01617267f, 0.04155915f, -0.05302945f, -0.01340923f, 0.02858964f, 0.05480844f, 
    -0.03742626f, -0.03969961f, -0.04505526f, -0.02558552f, -0.07829080f, -0.04210702f, 0.05972067f, -0.02763049f, 
    -0.06035314f, -0.02041584f, 0.01110120f, 0.04157198f, -0.00492439f, -0.04852879f, -0.05735195f, -0.02448081f, 
    0.03941315f, -0.00175636f, 0.02894470f, -0.07847691f, 0.00001848f, -0.07800732f, -0.00904556f, -0.05854639f, 
    0.03947212f, 0.02412265f, -0.00388725f, 0.05946543f, -0.07614806f, -0.04168154f, 0.01439588f, -0.07404402f, 
    -0.04608802f, -0.07861824f, -0.04673631f, 0.05302891f, -0.07294296f, -0.01861540f, 0.03388134f, -0.06465479f, 
    -0.05714907f, -0.02518843f, 0.04585456f, -0.01839838f, -0.03086860f, -0.05898990f, 0.01455126f, -0.03557494f, 
    0.03163645f, 0.01275155f, -0.01555979f, -0.07698880f, -0.03778625f, 0.06361585f, -0.02971439f, -0.06525705f, 
    -0.07332244f, 0.01311034f, -0.03895962f, 0.05130813f, 0.01938720f, 0.01204656f, 0.06188197f, -0.02807371f, 
    0.20708704f, -0.04591924f, -0.07049318f, -0.13914905f, 0.01842845f, 0.15596959f, -0.08306989f, 0.17650710f, 
    -0.02098601f, -0.24279483f, -0.03260682f, -0.00714933f, 0.26772901f, 0.08750754f, 0.12099737f, 0.03793876f, 
    -0.15913808f, 0.12831870f, 0.07505891f, 0.11458824f, 0.13333838f, 0.08851884f, 0.07264838f, -0.01146921f, 
    0.21485616f, -0.34816262f, -0.13321209f, -0.12465803f, -0.04085619f, 0.04293265f, -0.00783930f, -0.04100461f, 
    -0.03285643f, -0.01690771f, 0.00411553f, -0.04738636f, 0.18676311f, -0.27896333f, -0.46370772f, 0.16048996f, 
    0.12363929f, 0.00240831f, 0.30465701f, 0.14398618f, -0.07978089f, 0.08571450f, -0.03244065f, 0.09832802f, 
    -0.10507525f, 0.27725473f, 0.12935197f, -0.11512122f, -0.04416393f, 0.15166385f, 0.04728244f, -0.02228660f, 
    0.14822811f, 0.03923553f, 0.10112312f, 0.00627152f, 0.42913464f, 0.30286661f, 0.09245791f, 0.03126610f, 
    0.05382347f, 0.08326402f, -0.00945176f, -0.00380553f, 0.08912811f, -0.02371168f, -0.05254230f, -0.00310196f, 
    -0.63375735f, 0.23667113f, -0.30515859f, -0.09655587f, 0.06663074f, 0.21701844f, -0.01580216f, 0.04009335f, 
    -0.03347048f, -0.17509264f, -0.00145970f, -0.14066075f, -0.04384023f, 0.09480747f, 0.23490310f, 0.13581452f, 
    0.03599628f, 0.03777382f, -0.00326778f, -0.08356148f, 0.02080710f, 0.07417163f, -0.03834052f, 0.33187240f, 
    0.07728142f, 0.37850875f, 0.05340341f, 0.08023040f, -0.00796598f, 0.13995391f, -0.09496237f, 0.00001995f, 
    -0.13402198f, -0.01979446f, -0.07977550f, -0.10013267f, -0.00436380f, 0.21326260f, -0.04573291f, -0.19136958f, 
    0.14843623f, 0.05274140f, 0.26002020f, 0.05138944f, 0.00705892f, 0.12026205f, -0.03879675f, -0.02910068f, 
    0.25749791f, 0.23390464f, -0.00218264f, -0.24107060f, 0.14239980f, 0.07290478f, 0.01960979f, 0.12843755f, 
    0.04500517f, -0.02552677f, -0.04080489f, -0.02407094f, 0.11105815f, -0.07488158f, 0.00557787f, 0.16778420f, 
    0.00111736f, -0.07667753f, -0.03841049f, -0.05208063f, -0.08997235f, 0.05191086f, 0.09179495f, 0.02515966f, 
    -0.18633150f, 0.19866675f, -0.24654292f, 0.42190012f, -0.09105477f, -0.04073612f, 0.10770521f, -0.13421477f, 
    0.01728703f, 0.03541650f, 0.00947342f, 0.11276910f, 0.01708988f, -0.00893847f, 0.11843638f, -0.11901537f, 
    -0.14278711f, -0.11444902f, -0.04408125f, 0.09615888f, -0.03378769f, -0.22854613f, -0.04005451f, 0.05784136f, 
    -0.05457941f, -0.18706338f, 0.05678489f, -0.04262801f, -0.03073789f, 0.00199746f, 0.10511877f, -0.02961101f, 
    -0.22761351f, -0.05393141f, 0.01412162f, -0.12076780f, -0.27881095f, 0.24453537f, 0.12444000f, -0.18470457f, 
    -0.05927314f, 0.04756001f, 0.02762675f, -0.03827611f, 0.17076014f, 0.10790215f, -0.02177156f, 0.02125114f, 
    0.21383673f, 0.13103823f, -0.05467334f, -0.02842694f, 0.09018537f, -0.11089311f, -0.05088535f, -0.01010284f, 
    0.02866315f, 0.12953733f, 0.07467917f, 0.03765045f, 0.07202826f, -0.06197954f, -0.05857714f, 0.31352040f, 
    0.07455856f, 0.05589357f, 0.10886116f, -0.04006060f, 0.06369008f, -0.09544148f, 0.07326522f, 0.02102237f, 
    0.31244099f, 0.12844956f, -0.03263126f, 0.06551997f, -0.00383346f, -0.15448405f, 0.06644847f, -0.13240984f, 
    0.14126384f, 0.11587006f, -0.00072080f, 0.07793094f, -0.11075981f, -0.02113749f, -0.15044637f, 0.30311120f, 
    -0.14221703f, -0.37504154f, 0.32281390f, -0.13754551f, 0.05481343f, 0.11300242f, 0.12539044f, 0.07199539f, 
    0.04004699f, -0.08547051f, 0.10455427f, 0.05988022f, -0.16643484f, -0.05221673f, -0.26851809f, 0.14244220f, 
    -0.15850849f, -0.32961574f, -0.02861081f, 0.09163573f, 0.16504920f, -0.03352640f, -0.01437373f, 0.02837164f, 
    0.21236292f, 0.20101145f, 0.04457008f, 0.03389075f, -0.09537796f, -0.00248122f, 0.08659754f, -0.06201450f, 
    -0.16300203f, 0.05116344f, 0.00156197f, 0.04557844f, -0.24016392f, -0.15196595f, -0.00819030f, 0.06330407f, 
    0.05799136f, -0.13013554f, 0.06670990f, 0.20275293f, 0.30039036f, -0.00317186f, 0.04358101f, -0.11543059f, 
    -0.02350380f, 0.01063968f, 0.04695326f, -0.03989799f, 0.02072483f, -0.12117005f, -0.11198539f, 0.07386972f, 
    0.10923105f, 0.09823783f, 0.11911604f, 0.09745314f, 0.04310301f, 0.11694854f, -0.28710809f, -0.10445598f, 
    -0.12607169f, -0.10984614f, -0.14929011f, -0.09825435f, -0.16822277f, -0.05000162f, 0.00728429f, -0.47327825f, 
    -0.01009665f, -0.11793341f, 0.10192344f, -0.23610631f, -0.09425060f, -0.18657947f, 0.00013351f, -0.13704929f, 
    0.08661427f, 0.02077242f, -0.27563083f, 0.06943593f, -0.16826436f, 0.16690333f, -0.10581860f, 0.07104187f, 
    -0.13063569f, -0.13220416f, -0.20067084f, -0.00296210f, 0.23154318f, 0.02226337f, 0.29761627f, 0.20786381f, 
    0.09985866f, -0.02492199f, -0.02222138f, -0.06944279f, 0.11350237f, -0.08855674f, -0.10671866f, 0.03076726f, 
    0.04427715f, -0.00938307f, -0.04852016f, 0.08068991f, 0.01248361f, 0.03400147f, -0.06573869f, 0.04377831f, 
    0.04203457f, 0.12441642f, 0.28077346f, -0.08534231f, 0.22057392f, 0.30987948f, -0.32860833f, 0.20160682f, 
    -0.02338602f, -0.09422775f, 0.05120933f, 0.23399872f, 0.00787226f, 0.09588384f, -0.09557931f, 0.27311021f, 
    0.28620562f, 0.04857725f, 0.15624200f, 0.13393830f, -0.15457243f, -0.17136990f, 0.03937254f, 0.12327972f, 
    0.03866032f, -0.07794844f, -0.03481284f, -0.00930747f, -0.08361078f, -0.08359100f, -0.06043942f, 0.02775486f, 
    0.05877145f, -0.01252894f, 0.07618600f, -0.01369418f, -0.06910962f, -0.08947002f, 0.16374321f, 0.09948785f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15009479f, 0.00156667f, -0.17735496f, 0.10335265f, -0.02815045f, 0.04640478f, -0.06791504f, 0.22147065f, 
    -0.01974410f, 0.06234490f, 0.20815724f, 0.01172799f, 0.14461467f, -0.03408827f, 0.17502287f, 0.11897911f, 
    0.05334963f, 0.01934536f, 0.00316327f, 0.03255075f, 0.01040516f, -0.03525298f, -0.07801121f, 0.24613678f, 
    -0.03342795f, -0.06809420f, 0.08583929f, 0.00824849f, 0.08275671f, 0.24188200f, -0.07734172f, 0.00498335f, 
    -0.04718259f, 0.05110536f, 0.32351151f, -0.01893035f, 0.09936126f, -0.05693918f, 0.08579282f, 0.07863414f, 
    0.01310528f, -0.01996683f, 0.12587413f, 0.07522418f, 0.09998677f, -0.07033749f, -0.03818613f, -0.03578291f, 
    -0.01428390f, 0.03262602f, -0.01242788f, 0.11277917f, 0.20902829f, 0.04046748f, 0.09366501f, -0.00173865f, 
    0.00060285f, -0.12578909f, -0.15176944f, 0.04618341f, -0.23133525f, 0.02004392f, 0.04009334f, 0.07170778f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17733689f, 0.09067661f, 0.17835897f, -0.19741519f, 0.42241710f, 0.07642043f, -0.38540709f, -0.24498680f, 
    0.04456980f, 0.09805612f, -0.44010019f, 0.03692520f, 0.20447895f, 0.07766189f, -0.13233827f, -0.49826556f, 
    -0.05085660f, 0.22917591f, -0.00049719f, 0.11148214f, -0.12476788f, 0.29885954f, 0.10525527f, -0.44583055f, 
    -0.12392113f, 0.08379092f, -0.50469309f, -0.01571111f, -0.20698956f, -0.22717008f, 0.11080376f, 0.00473052f, 
    0.12616633f, 0.12969434f, -0.13138928f, -0.11073103f, -0.24457094f, -0.04112468f, 0.17124406f, -0.17745724f, 
    -0.04233175f, 0.13726762f, 0.12840419f, -0.14143358f, -0.16696465f, 0.44839379f, -0.53325891f, 0.27884161f, 
    -0.33314326f, 0.18910778f, -0.05926021f, -0.09158166f, -0.15850636f, 0.11690828f, 0.07306976f, -0.10663530f, 
    0.08387572f, -0.30637863f, 0.01764078f, -0.15561432f, 0.30778813f, 0.01713936f, 0.22660093f, 0.10550496f, 
    0.09209931f, 0.28480875f, -0.67062008f, -0.16071722f, 0.09964676f, 0.28294066f, -0.64937389f, -0.00730258f, 
    0.06396060f, -0.03115788f, 0.16481777f, 0.10934626f, 0.36171821f, 0.13506921f, -0.07314079f, -0.05303505f, 
    -0.02773101f, -0.12883621f, -0.11206332f, -0.07035054f, -0.03774635f, 0.23594403f, 0.10840145f, 0.10173609f, 
    0.02560281f, -0.11504512f, -0.69013363f, -0.06109087f, 0.15336838f, 0.12541123f, -0.06883335f, -0.05270065f, 
    -0.07751432f, 0.08269794f, 0.31654388f, 0.00219228f, -0.14168489f, -0.12377300f, 0.27809864f, 0.08523531f, 
    -0.07396134f, -0.23670428f, -0.18446562f, -0.00073777f, -0.12993345f, -0.85878229f, -0.11306749f, 0.17042522f, 
    -0.23012932f, 0.25640023f, 0.02697438f, 0.02823224f, -0.30723393f, -0.04821684f, 0.17872797f, 0.00069096f, 
    0.06266825f, -0.35296884f, 0.00069003f, -0.46253979f, -0.71338236f, -0.08582311f, 0.20293447f, 0.10369986f, 
    -0.31573248f, 0.33097085f, 0.16030832f, 0.18711314f, -0.52629334f, 0.14523654f, -0.04810752f, -0.24610943f, 
    -0.07583600f, -0.08684172f, 0.01238916f, 0.02558360f, -0.07407761f, 0.12326626f, 0.08682004f, 0.24054626f, 
    -0.02668040f, -0.51804823f, -0.00442872f, -0.01968499f, -0.06138680f, -0.03718103f, 0.09503377f, -0.13141453f, 
    -0.02056685f, -0.11454415f, 0.40843955f, -0.05978783f, 0.37636846f, -0.04638115f, 0.07177655f, 0.09562227f, 
    0.11554904f, 0.20923521f, -0.18199378f, 0.04184387f, 0.02134139f, -0.26945764f, 0.24100398f, -0.00490506f, 
    0.08754106f, -0.14361061f, -0.38561702f, -0.12682551f, 0.01161116f, -0.64300013f, -0.02118578f, 0.28786999f, 
    -0.26384026f, -0.47585729f, 0.11386747f, 0.18384509f, 0.23451179f, 0.10213435f, -0.24355148f, -0.09167635f, 
    0.09197387f, -0.37061357f, 0.20273653f, 0.13086511f, -0.78065568f, -0.01818799f, -0.11816917f, 0.09526524f, 
    0.07870872f, 0.29123536f, 0.25094438f, -0.01503044f, -0.31396201f, -0.00182912f, 0.04223553f, -0.91646218f, 
    0.02055943f, -0.09664490f, -0.25087339f, -0.12230711f, -0.32192993f, 0.28917572f, -0.45777202f, -0.21927835f, 
    -0.08403390f, 0.10855855f, -0.00335026f, -0.06664205f, -0.01122418f, 0.03005457f, -0.05988492f, -0.34764251f, 
    0.00869414f, 0.07399088f, 0.19764230f, 0.09999201f, 0.24566114f, -0.32783872f, -0.04382654f, -0.04350517f, 
    -0.10080107f, -0.51548254f, -0.19936626f, -0.05150368f, 0.05572536f, -0.26689547f, 0.03920964f, -0.04602399f, 
    0.10616164f, 0.18380305f, 0.14288491f, 0.03052660f, -0.10875159f, -0.27167735f, 0.25170046f, 0.06879759f, 
    0.25940156f, -0.14091356f, -0.12970556f, -0.10336158f, -0.12156069f, 0.03129910f, -0.01054994f, -0.10776904f, 
    -0.02936410f, 0.45262283f, 0.24083112f, 0.08435134f, 0.20261003f, -0.10878321f, -0.05617733f, 0.05930700f, 
    0.12894411f, -0.41623610f, 0.05566929f, 0.18816692f, -0.41275686f, -0.04281415f, 0.25132328f, 0.21820226f, 
    0.09788328f, -0.12395989f, -0.03084550f, -0.00476295f, -0.34031999f, -0.04903323f, -0.20572561f, 0.04592214f, 
    -0.09640508f, 0.01366701f, -0.09111862f, -0.05479206f, -0.13665761f, -0.08226003f, 0.02104254f, -0.01205229f, 
    0.03429686f, -0.06356117f, 0.20794956f, 0.01040219f, -0.23335613f, -0.05251514f, -0.12649165f, -0.00320790f, 
    -0.08346800f, 0.08096913f, -0.22093485f, 0.01745876f, -0.48659194f, 0.19136189f, 0.17455737f, 0.15162678f, 
    -0.04439927f, 0.08904473f, -0.01956774f, -0.03355616f, -0.37910095f, 0.46142292f, 0.14002746f, -0.17695837f, 
    0.33407095f, -0.14456907f, 0.01767876f, 0.03209596f, -0.72366798f, -0.02582399f, -0.13712169f, 0.02410809f, 
    -0.12417027f, -0.20554033f, 0.20991915f, -0.14506517f, 0.08493888f, 0.06312116f, 0.05145845f, 0.20935692f, 
    -0.08155829f, -0.17268923f, -0.48535651f, 0.12080751f, 0.04885652f, -0.72944200f, 0.04025294f, 0.33188185f, 
    0.04895258f, 0.04545939f, 0.20367685f, -0.04005625f, -0.02954396f, 0.00736898f, 0.14150245f, -0.02148512f, 
    0.00785097f, 0.33639082f, -0.10807999f, 0.06119288f, -0.06028496f, -0.20230120f, -0.00004539f, 0.05843085f, 
    -0.08244743f, -0.02503726f, -0.71318591f, -0.03379252f, 0.10499677f, 0.17252801f, 0.11890210f, 0.01949828f, 
    -0.01840230f, -0.13602178f, -0.07881718f, 0.11346957f, -0.21845053f, 0.31532538f, -0.07625519f, 0.03636034f, 
    0.00660068f, 0.28984496f, 0.29542494f, -0.17134978f, 0.26643208f, -0.05516559f, -0.40067521f, -0.16543140f, 
    -0.11814363f, 0.17112210f, 0.07988036f, 0.10831255f, 0.05175515f, 0.03723965f, 0.07446172f, -0.01328746f, 
    0.05351067f, -0.02342914f, -0.08207625f, 0.02909752f, -0.07042404f, 0.08393608f, -0.08990219f, -0.01227184f, 
    -0.39793643f, -0.60564697f, 0.38227499f, 0.07711034f, -0.28516567f, 0.22717591f, -0.12305984f, 0.33113775f, 
    0.07200491f, -0.06799597f, -0.00447307f, -0.10405178f, 0.17734610f, -0.87259644f, 0.37818855f, 0.20402186f, 
    0.10846557f, -0.87374407f, -0.04622665f, -0.06491626f, -0.07569472f, -0.71227193f, 0.09929584f, -0.03380691f, 
    0.09513346f, -0.10690649f, 0.24331401f, -0.02062023f, -0.30432692f, 0.07391029f, 0.09765390f, 0.04296724f, 
    0.09663822f, -0.00172339f, 0.12173679f, 0.06068274f, 0.03133080f, -0.33687118f, -0.47145510f, 0.20926315f, 
    -0.07293332f, -0.21804988f, -0.59397352f, 0.09458183f, -0.02599902f, -0.38631609f, 0.13144240f, -0.20094816f, 
    -0.22038116f, -0.65126818f, -0.05307564f, -0.56814879f, 0.21147613f, -0.01560769f, -0.05441921f, 0.07930862f, 
    -0.13306209f, -0.16787428f, -0.59593135f, 0.41041130f, -0.45718542f, -0.03200844f, 0.00887809f, 0.12753713f, 
    -0.23076048f, 0.25002763f, 0.31461617f, -0.73754275f, -0.07357909f, -0.01127876f, 0.37497690f, -0.25560278f, 
    -0.08063654f, -0.11317998f, 0.10143264f, -0.11259867f, 0.07822767f, -0.47204131f, 0.04875674f, -0.24859318f, 
    0.07869170f, -0.19576950f, -0.05338251f, 0.04131217f, 0.09441681f, 0.04889553f, -0.08275540f, 0.13850626f, 
    -0.12736298f, -0.11649126f, 0.15739413f, -0.04344040f, -0.11855792f, 0.10139566f, -0.00280265f, 0.08930594f, 
    0.00075267f, -0.11018497f, -0.28818938f, 0.05987994f, 0.09605142f, 0.19722576f, -0.63146061f, -0.45082819f, 
    -0.07434378f, 0.41144064f, -0.51061857f, -0.32776004f, 0.38790411f, -0.06907903f, 0.15187864f, -0.24017909f, 
    -0.27841514f, 0.05722714f, -0.04506659f, 0.52075481f, -0.08859466f, 0.06601450f, -0.31749791f, -0.09807952f, 
    0.02169864f, 0.34634665f, -0.19756091f, -0.02426709f, 0.09373438f, 0.06782001f, -0.50147456f, 0.16178997f, 
    0.00654665f, 0.19081347f, -0.31353617f, -0.32559943f, 0.25747189f, -0.26328617f, 0.41118202f, 0.15315023f, 
    -0.08265874f, 0.11228939f, -0.27930626f, -0.10852426f, -0.11919303f, -0.06774870f, -0.05554987f, -0.21777649f, 
    0.03780164f, 0.16805516f, 0.00485151f, 0.05692390f, -0.09773298f, -0.20505604f, -0.05100407f, 0.04767584f, 
    0.02415219f, 0.11452083f, -0.29924530f, 0.04651187f, 0.42310062f, -0.26656848f, 0.05984709f, 0.04590318f, 
    -0.01629119f, -0.22635271f, 0.17669293f, -0.11006068f, 0.33282381f, -0.25699556f, -0.49554914f, -0.02164411f, 
    0.09963792f, -0.62638766f, 0.07887206f, 0.17671475f, 0.24830797f, -0.27822125f, 0.13032280f, -0.23285867f, 
    -0.51838893f, 0.22533306f, 0.07879397f, -0.31796679f, 0.38464540f, -0.07825436f, 0.33198389f, 0.07141489f, 
    0.03467672f, 0.34236324f, -0.26684511f, -0.84373611f, -0.14273834f, -0.06325622f, -0.81579834f, -0.14165163f, 
    -0.39804471f, -0.68993485f, -0.07233894f, -0.09325675f, -0.55147803f, 0.14559007f, 0.20985207f, 0.41254252f, 
    -0.14592707f, -0.00393808f, -0.34315744f, -0.11013751f, -0.25101534f, -0.51908624f, 0.09954138f, -0.22060339f, 
    0.00551617f, -0.03533559f, -0.10303297f, 0.01845706f, -0.07742472f, 0.43113285f, -0.08772687f, -0.08697200f, 
    0.11180881f, -0.10544685f, 0.36890766f, 0.04643921f, -0.51762307f, 0.07181794f, -0.02660939f, 0.01971996f, 
    0.10596078f, 0.34558788f, -0.00846604f, -0.01445048f, -0.17099455f, -0.18984054f, 0.20116691f, 0.08966213f, 
    0.10341436f, 0.11767104f, 0.34174332f, 0.16570151f, 0.29868922f, 0.26424369f, -0.32770282f, 0.14050090f, 
    0.48210928f, 0.13997114f, 0.00296895f, -0.15210280f, 0.24074183f, -0.07674887f, -0.56463253f, -0.04765918f, 
    0.07892640f, -0.31502083f, -0.15723784f, 0.03546681f, 0.23722629f, -0.08355089f, -0.13660553f, -0.17774314f, 
    -0.00708613f, 0.08993678f, -0.07380201f, 0.13639702f, 0.02134189f, -0.09991637f, -0.41284844f, 0.00965519f, 
    -0.13746506f, -0.01627764f, 0.47701126f, 0.01209473f, -0.24160074f, 0.10540336f, -0.10988828f, 0.31350893f, 
    -0.05506861f, -0.66588533f, -0.10503950f, 0.11759333f, -0.05032375f, -0.87214446f, -0.03669963f, -0.23125781f, 
    -0.03027904f, -0.07291282f, -0.35840258f, -0.01387873f, -0.13305102f, -0.44114074f, 0.03317836f, 0.02411638f, 
    -0.07187033f, -0.58822006f, -0.24955243f, 0.03538740f, 0.30183136f, 0.10050341f, 0.17088290f, -0.05913251f, 
    0.02074503f, -0.52605939f, -0.03394660f, 0.30992365f, -0.23357825f, -0.17009397f, 0.25479180f, 0.17938775f, 
    0.30820271f, 0.00022934f, 0.00471323f, 0.52132100f, -0.26950827f, 0.10852016f, 0.07277568f, -0.11148056f, 
    -0.09116175f, 0.13401982f, -0.62443131f, -0.31501621f, 0.19436808f, -0.01795630f, 0.29956165f, -0.29477003f, 
    0.54893273f, -0.11739056f, -0.21070945f, 0.09963051f, 0.11960271f, 0.23285434f, 0.20935950f, -0.49630955f, 
    -0.08267485f, -0.08196180f, -0.37410155f, -0.08597409f, 0.04128861f, -0.24228866f, 0.05835856f, 0.34863687f, 
    -0.02010361f, -0.14053945f, -0.00083090f, 0.10201205f, 0.08458848f, -0.21247177f, -0.05768314f, 0.18885003f, 
    0.02834740f, 0.00148921f, -0.29941583f, 0.11246014f, -0.31627661f, 0.19476348f, -0.06091430f, 0.10984372f, 
    -0.00305068f, 0.26550072f, 0.24690659f, 0.09467710f, 0.17739056f, -0.01805150f, -0.36152387f, -0.24883367f, 
    0.01308747f, -0.41305840f, -0.35753471f, 0.27065733f, -0.50732946f, -0.72460961f, 0.24232896f, -0.44381067f, 
    -0.07449397f, 0.06906350f, 0.08948724f, -0.77241403f, -0.27802292f, -0.01589349f, -0.18722394f, 0.02418446f, 
    0.10684690f, 0.04172973f, -0.17248060f, 0.39172253f, 0.22155619f, -0.04254634f, -0.22077152f, -0.58243990f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26504910f, 0.04371190f, 0.08591220f, -0.05745157f, -0.03493648f, 0.10384683f, 0.17306854f, -0.13547683f, 
    -0.01889796f, -0.00159881f, -0.03628817f, -0.14427114f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
