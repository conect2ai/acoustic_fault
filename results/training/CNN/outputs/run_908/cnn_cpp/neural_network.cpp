#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.86252749f, 0.53456455f, 0.34950992f, -0.19231921f, -0.22285876f, 0.34600499f, -0.09673508f, 0.57674587f, 
    0.12819844f, -0.88418782f, 0.88372076f, 0.59129542f, -0.31461957f, -0.08879288f, -0.12682623f, 0.00613873f, 
    0.14199562f, 0.48674026f, -0.39175987f, -0.17569737f, -0.21076305f, -0.60372210f, 0.62692797f, -0.86381859f, 
    0.28824919f, -0.19806564f, 0.46118736f, -0.00500848f, -0.53738052f, -0.14821714f, 0.88146621f, 0.73635566f, 
    -0.41027671f, 0.11064073f, -0.30458248f, 0.09494545f, -0.62199020f, -0.84469783f, 0.29743323f, -0.81354892f, 
    -0.59796357f, 0.09675955f, -0.03144535f, 0.28862405f, -0.08278289f, -0.01931272f, 0.30416304f, 0.19784458f, 
    -0.17358242f, -0.42592591f, -0.62502670f, 0.65332103f, -0.59756196f, -0.55678082f, 0.38618714f, -0.79039955f, 
    0.67632139f, 0.37771836f, 0.13216344f, 0.52071631f, -0.14369527f, -0.43107140f, 0.45826772f, 0.09980308f, 
    0.11357931f, -0.63844723f, 0.36612266f, 0.40215394f, -0.52759230f, -0.55842763f, 0.43049815f, 0.26468599f, 
    -0.43043119f, 0.12602958f, 0.45716348f, 0.64683986f, -0.16846646f, -0.62150884f, -0.42863724f, -0.30411091f, 
    0.43796861f, 0.81843448f, -0.08059829f, 0.46370986f, 0.24200843f, -0.81999451f, 0.38732487f, -0.61797243f, 
    -0.47845563f, -0.00452085f, -0.39363548f, -0.47822639f, -0.87432986f, 0.20316795f, 0.45640373f, 0.50976229f, 
    0.11169036f, 0.10803887f, 0.58046651f, 0.36364096f, -0.81053048f, -0.68692136f, -0.50754857f, -0.26203609f, 
    0.09028555f, 0.08511683f, 0.24125005f, -0.08087908f, 0.62100852f, 0.75321162f, 0.67176783f, -0.43328005f, 
    -0.62714493f, 0.44283050f, 0.06659006f, -0.25028685f, -0.10039251f, -0.08891784f, 0.46305835f, 0.90184730f, 
    0.70711035f, 0.29696274f, -0.23096207f, 0.28285080f, -0.10441138f, 0.25167608f, 0.78227985f, 0.25409746f, 
    0.47210151f, 0.28595275f, 0.21474129f, -0.25050789f, 0.00662861f, 0.36082637f, -0.20022866f, -0.67877227f, 
    -0.49162072f, -0.47483131f, 0.29475269f, 0.64209509f, -0.05063544f, 0.20645548f, 0.26844218f, -0.31226060f, 
    0.44243538f, -0.14058478f, 0.59583426f, 0.83955407f, 0.46358770f, 0.60851264f, 0.23113208f, -0.17564990f, 
    -0.19758107f, -0.07153880f, 0.99544621f, -0.93088651f, 0.22898017f, 0.60966522f, -0.40529224f, 0.30260336f, 
    0.00138740f, -0.43272305f, -0.47776374f, -0.20299599f, -0.28493714f, 0.81975991f, 0.70469797f, 0.61621082f, 
    0.16562887f, -0.28415647f, -0.04709103f, -0.13158073f, -0.91088891f, -0.34362200f, 0.05946685f, 0.22961785f, 
    0.67352730f, -0.45689553f, -0.30210963f, -0.79683477f, 0.25506261f, -0.62446195f, 0.10700455f, -0.65283597f, 
    -0.15765125f, -0.18861823f, -0.21978706f, 0.50393647f, 0.53837973f, -0.92177182f, -0.45628506f, 0.72236085f, 
    0.49855974f, -0.55767494f, 0.37393361f, -0.01138987f, 0.22758318f, 0.14831671f, 0.50233179f, -0.71873099f, 
    -0.21490745f, -0.52214110f, -0.90498996f, 0.41429076f, 0.28418764f, -0.13315180f, -0.08179732f, -0.70034760f, 
    -0.65694088f, -0.75373858f, 0.00818999f, -0.51820463f, 0.34563896f, 0.03815852f, -0.12263750f, 0.15635982f, 
    0.81246793f, -0.61957669f, 0.56341338f, 0.22925383f, 0.54912698f, -0.53278780f, 0.21914443f, 0.42933640f, 
    -0.02237906f, -0.04220840f, 0.04527181f, 0.63483644f, -0.90157032f, 0.30590621f, -0.40101266f, 0.35988694f, 
    0.28888607f, -0.32985407f, -0.84712243f, 0.44332194f, 0.31723264f, 0.42448440f, -0.16127941f, -0.66833180f, 
    -0.17665067f, -0.32718009f, -0.66102117f, 0.72977656f, 0.48085842f, 0.37780491f, 0.55030996f, 0.69391745f, 
    0.18732442f, -0.39826089f, 0.01302281f, 0.07754089f, 0.08964376f, 0.35708591f, -0.16179170f, -0.65156746f, 
    -0.51018697f, -0.64975423f, -0.60453731f, -0.29721087f, 0.24970402f, 0.39050353f, 0.85757625f, -0.46287993f, 
    -0.78514451f, -0.71545678f, -0.78785187f, 0.25285316f, 0.31125426f, -0.02756335f, 0.59720808f, 0.51798666f, 
    0.49028102f, -0.03409255f, 0.00102848f, -0.45250824f, 0.53847069f, 0.35907170f, -0.46228173f, -0.64520651f, 
    -0.52260357f, -0.57414442f, -0.49026468f, 0.69619811f, 0.43911725f, -0.10076714f, 0.15618743f, 0.01481133f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03362375f, -0.06728093f, -0.31460246f, -0.17009777f, -0.20955999f, 0.18061845f, 0.14000446f, 0.04262342f, 
    -0.09043527f, 0.14608204f, -0.00102561f, 0.07726473f, 0.26632684f, 0.06989409f, 0.10806168f, 0.07425468f, 
    -0.36895785f, 0.24603499f, -0.21031603f, -0.13466442f, 0.21328664f, 0.03820879f, 0.06000303f, 0.19834000f, 
    -0.09346970f, -0.18251523f, 0.09464747f, -0.05282594f, -0.09340452f, 0.17310835f, -0.28305605f, -0.20469624f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.52419484f, 0.17154083f, -0.03544722f, -0.25993907f, -0.15538660f, -0.18886033f, -0.18388166f, -0.07788768f, 
    0.10833584f, 0.01433978f, 0.05149374f, -0.11418194f, 0.12989263f, -0.07130326f, -0.05107045f, 0.00526605f, 
    0.04133475f, 0.02600910f, -0.04080046f, -0.62782133f, -0.03957262f, -0.08028020f, -0.06236612f, -0.02588897f, 
    0.09694407f, 0.08907345f, 0.11447922f, -0.16325366f, -0.14106505f, -0.08229587f, -0.06597472f, 0.18192805f, 
    -0.03755301f, -0.02873039f, -0.05349323f, -0.13170214f, -0.50417715f, -0.23254441f, 0.08280557f, -0.04632306f, 
    0.06410843f, -0.02848088f, -0.03690746f, -0.04742556f, -0.04159348f, -0.01387152f, 0.06674991f, 0.06333128f, 
    -0.09295029f, 0.08535720f, 0.13074957f, 0.25271600f, 0.13187011f, -0.09549908f, -0.08497437f, 0.09998645f, 
    0.11993665f, 0.02174966f, -0.06163399f, 0.01245575f, 0.06880867f, -0.01323973f, 0.04887577f, -0.23842919f, 
    -0.21569008f, -0.28200212f, 0.01003472f, 0.02166765f, -0.08373804f, 0.05838282f, -0.00901395f, 0.08472601f, 
    -0.16858262f, -0.13021512f, 0.21201617f, -0.01483439f, -0.08493273f, -0.02992599f, -0.05563054f, 0.12912823f, 
    0.16693330f, 0.09210560f, 0.07081453f, 0.06130265f, -0.08533230f, 0.10487396f, -0.17157730f, 0.07123394f, 
    0.18032961f, -0.10998464f, 0.08744745f, 0.08347399f, -0.29108754f, 0.10747015f, 0.06655598f, 0.01685699f, 
    -0.06616418f, -0.07553750f, 0.01465839f, -0.20543498f, -0.18940280f, 0.04514416f, -0.03904972f, 0.05950281f, 
    -0.11583792f, -0.01094308f, -0.02326001f, 0.09342429f, 0.19113709f, 0.18517435f, 0.12837736f, -0.25742975f, 
    -0.15736941f, -0.16782787f, -0.02457157f, 0.05808203f, 0.06446148f, 0.09134048f, 0.16805233f, 0.37823263f, 
    -0.04763293f, -0.01678698f, -0.06515031f, -0.03660778f, 0.00978666f, -0.05379004f, 0.19442293f, 0.08803432f, 
    -0.05519533f, -0.11221690f, 0.01883001f, -0.04678207f, 0.06025249f, 0.02705212f, 0.01312809f, 0.19651170f, 
    -0.09871835f, 0.01666009f, 0.04753284f, 0.08499449f, 0.06725397f, 0.13274004f, -0.21542294f, -0.02231616f, 
    0.09423707f, -0.04873416f, -0.03982589f, 0.08452988f, -0.01304804f, -0.07484385f, -0.02398626f, -0.04059209f, 
    -0.11233934f, 0.26167244f, 0.00827879f, -0.12506497f, -0.04946006f, 0.05827904f, 0.05949301f, -0.05410074f, 
    -0.02039127f, 0.03248234f, 0.28299454f, 0.28527278f, -0.20051511f, 0.13816202f, 0.07095140f, 0.08220825f, 
    -0.16674872f, -0.12468077f, -0.13221137f, 0.17165698f, 0.04221484f, -0.22932044f, -0.08685499f, -0.08607972f, 
    0.02779792f, 0.20514959f, 0.05927847f, -0.00033629f, 0.11793256f, -0.03352048f, 0.07146095f, -0.00597177f, 
    0.21016750f, 0.01388604f, -0.18261625f, 0.00208749f, -0.04380294f, -0.69221246f, 0.09386661f, 0.16537291f, 
    0.05924254f, 0.06826992f, -0.05517869f, -0.07791229f, -0.01041399f, -0.03995422f, -0.03347648f, -0.24607156f, 
    -0.10635346f, 0.07106610f, 0.00685731f, -0.00173686f, 0.02706731f, 0.20268683f, 0.10308114f, 0.00581901f, 
    0.02646155f, -0.27158096f, 0.00475762f, 0.12342732f, 0.05149860f, -0.01021909f, -0.03331431f, 0.04022958f, 
    -0.07430646f, -0.14157785f, -0.05576986f, -0.25542063f, -0.02185467f, -0.02186741f, 0.00777875f, 0.09690750f, 
    0.08142061f, -0.11148319f, -0.17673986f, -0.19755886f, 0.11070106f, 0.00235462f, 0.18884189f, -0.12941717f, 
    -0.10550486f, 0.04704802f, -0.04448542f, 0.03687169f, 0.12162507f, -0.05020683f, -0.02778658f, -0.02877369f, 
    0.07893208f, 0.10875238f, 0.07414299f, 0.17865157f, 0.13639441f, 0.05625865f, -0.31664920f, 0.05860651f, 
    -0.11233428f, 0.06373321f, 0.04641024f, 0.14306131f, 0.11605590f, 0.01896673f, -0.03820963f, 0.15351419f, 
    0.02732054f, 0.06064542f, -0.00190921f, 0.19101399f, 0.13053845f, 0.01579244f, 0.12920210f, 0.09408712f, 
    0.09431347f, -0.09496337f, -0.02042594f, -0.03446570f, -0.03475096f, 0.14161547f, 0.11537354f, 0.30780804f, 
    -0.08097355f, -0.11782514f, -0.14300017f, 0.11684450f, 0.02359659f, -0.01202975f, 0.01321168f, 0.10822040f, 
    0.08237296f, -0.11932358f, 0.06382380f, 0.09741952f, 0.14605652f, 0.03103017f, 0.01690513f, -0.02203245f, 
    0.05458463f, 0.02201411f, 0.00646046f, -0.01675550f, -0.06556787f, 0.02778502f, -0.02229670f, -0.05514776f, 
    -0.01934918f, -0.01477369f, -0.05161536f, -0.05228632f, 0.03350658f, 0.01671981f, -0.00758450f, -0.05547929f, 
    -0.04183698f, -0.01325807f, 0.01036354f, -0.05663460f, -0.05675711f, -0.04661172f, -0.04294824f, 0.00413965f, 
    0.02867207f, -0.01346342f, 0.03121943f, 0.02600741f, -0.04503542f, -0.03104560f, -0.05476067f, -0.06651492f, 
    -0.06445434f, 0.05445940f, -0.06174842f, 0.00798714f, -0.04925269f, -0.06313155f, -0.10281762f, 0.05143717f, 
    -0.04083257f, -0.05746667f, -0.04708437f, 0.04685690f, -0.02013445f, 0.03174383f, -0.05304629f, -0.00495452f, 
    -0.04817370f, -0.06821787f, -0.03101652f, -0.03962290f, 0.02042578f, -0.02425217f, -0.01144197f, -0.01189639f, 
    -0.05217923f, 0.02330664f, -0.06356886f, -0.03659932f, 0.02495251f, -0.05144718f, 0.01622681f, 0.02515647f, 
    -0.05756915f, -0.01892999f, -0.01266518f, -0.03824206f, -0.06539699f, -0.06312595f, 0.03654758f, -0.01026500f, 
    -0.01258723f, -0.00683868f, 0.00711891f, -0.03122954f, -0.04299004f, -0.00331822f, 0.01941740f, -0.03669043f, 
    0.03058692f, 0.00133733f, -0.02867943f, 0.00641091f, -0.01799896f, -0.02006354f, -0.05746057f, -0.06006985f, 
    -0.01663673f, 0.01997593f, 0.05722727f, -0.04499293f, 0.00473891f, 0.04296565f, -0.05866306f, -0.07900997f, 
    0.00165608f, -0.04956108f, 0.01548421f, 0.00549496f, -0.03931654f, -0.01240556f, 0.01733062f, -0.02340928f, 
    0.04134498f, 0.00210517f, -0.00538971f, 0.06289022f, -0.04337623f, 0.02298175f, -0.03920743f, -0.00772402f, 
    0.02414156f, 0.02114634f, -0.07369099f, -0.01126240f, -0.06489597f, 0.01566009f, -0.00317967f, -0.01206168f, 
    -0.05411191f, -0.04444626f, -0.00014972f, -0.02527850f, -0.00014478f, -0.03241309f, 0.02342137f, 0.00634543f, 
    0.06650917f, -0.05358096f, -0.03826952f, -0.04903483f, -0.00751672f, 0.04087093f, 0.03560542f, -0.00768900f, 
    0.03908663f, -0.04342497f, -0.04840630f, -0.05040880f, -0.07527223f, 0.00428007f, -0.02586707f, -0.01155459f, 
    0.02522487f, -0.00693672f, 0.03938391f, -0.06768350f, -0.00629572f, -0.06416560f, 0.00010799f, -0.07330199f, 
    -0.00453092f, -0.00513010f, 0.01136878f, -0.01794803f, -0.06252401f, -0.02033756f, 0.00983986f, -0.01107844f, 
    0.02577635f, -0.06186057f, -0.04391856f, -0.00917124f, 0.01536561f, -0.04787233f, 0.02538824f, 0.01102193f, 
    -0.01472272f, -0.06804428f, 0.05331950f, -0.01222424f, 0.04609213f, -0.05867472f, -0.04451593f, -0.00780329f, 
    -0.05062807f, 0.04492129f, -0.03850893f, 0.03162150f, -0.04258523f, -0.02517097f, -0.05744029f, 0.00125994f, 
    -0.00105942f, -0.03250590f, -0.00827419f, 0.02698164f, -0.01858741f, 0.04681301f, 0.04793251f, 0.00544042f, 
    0.00498558f, 0.06080816f, -0.03036463f, 0.01304795f, 0.00070831f, 0.00888102f, -0.07254814f, 0.01959216f, 
    0.02294522f, -0.06196317f, 0.01850666f, 0.03767766f, 0.03922095f, 0.03932254f, 0.00432926f, 0.04556093f, 
    0.02195081f, -0.02841020f, 0.02780334f, -0.01690695f, -0.00161444f, 0.02648722f, -0.01515770f, -0.01555098f, 
    -0.05365232f, -0.00606069f, 0.01776966f, -0.03512308f, -0.07102897f, 0.01216608f, -0.02936759f, 0.02821967f, 
    -0.02401264f, -0.01579328f, -0.02779581f, -0.02917658f, 0.04687325f, -0.00347660f, 0.04042491f, -0.04322641f, 
    0.02893491f, 0.01444269f, -0.01742810f, -0.03428096f, 0.00298356f, -0.05379586f, 0.00021134f, -0.01491961f, 
    0.04859421f, -0.05111657f, -0.04536787f, -0.03730533f, 0.05611424f, 0.03742352f, 0.00640854f, 0.04600347f, 
    -0.02119321f, 0.04867106f, 0.03536624f, 0.01872038f, -0.01003363f, 0.03353526f, 0.01128213f, 0.00867869f, 
    -0.03800922f, 0.00926614f, -0.04109401f, -0.03633087f, -0.04111356f, 0.01721903f, -0.09886118f, -0.04866495f, 
    0.06049064f, 0.03304666f, -0.00276169f, -0.01188184f, -0.01811292f, 0.05647706f, 0.06542569f, 0.04087400f, 
    -0.01938787f, 0.01736813f, -0.08051585f, 0.04463006f, 0.03627925f, 0.02585694f, -0.04274991f, -0.00388101f, 
    0.04261772f, -0.06403615f, -0.01984636f, 0.04196854f, -0.05913417f, 0.03791483f, 0.04533799f, -0.05197426f, 
    0.02930013f, 0.39341497f, -0.01142522f, 0.07139508f, 0.12260804f, 0.05801491f, -0.20295939f, -0.00916884f, 
    -0.08430357f, 0.59082055f, -0.00099606f, 0.06266504f, -0.07092236f, -0.10548319f, -0.11861925f, -0.16205527f, 
    0.01370060f, 0.04979505f, 0.08874195f, 0.25961190f, -0.02302322f, -0.21834680f, -0.07490790f, 0.02638953f, 
    0.15136132f, 0.00384788f, 0.13641341f, 0.20961101f, -0.07386477f, -0.03340605f, -0.26914787f, 0.11299393f, 
    0.02045059f, -0.08517320f, 0.14422524f, 0.14097810f, 0.22011508f, -0.00664403f, 0.00371066f, 0.23521720f, 
    0.10452361f, 0.06662025f, -0.13097769f, -0.10792251f, -0.03643318f, 0.04286445f, 0.23866653f, -0.03398795f, 
    0.02654487f, 0.03606974f, 0.21129945f, 0.01730130f, -0.02048391f, 0.11198164f, -0.14093457f, -0.16895887f, 
    -0.12613225f, 0.03926693f, -0.02842922f, 0.04783527f, 0.02199489f, -0.06435472f, 0.00607369f, 0.00892750f, 
    -0.15283453f, 0.02566197f, -0.14767663f, -0.00973325f, 0.13755709f, -0.04748607f, 0.12343594f, -0.00325461f, 
    0.15630750f, 0.05170438f, 0.02096560f, -0.10924406f, 0.13051902f, -0.12210588f, 0.12071548f, 0.12233100f, 
    -0.00589027f, -0.31818029f, 0.19440226f, 0.09945077f, 0.14161645f, 0.04755310f, 0.02314811f, 0.04722404f, 
    -0.15418768f, 0.01461239f, 0.02429050f, -0.04650372f, 0.00135035f, -0.05955766f, -0.22052030f, 0.05628377f, 
    0.04223135f, -0.03384584f, -0.12296417f, 0.18582357f, -0.04199686f, -0.16820683f, 0.09159086f, 0.07957517f, 
    0.05798907f, -0.03061540f, 0.07471416f, -0.03431403f, 0.00316740f, 0.28730708f, 0.06766201f, 0.12388251f, 
    0.06077461f, -0.04646901f, 0.01440950f, -0.04753666f, -0.10964204f, 0.34931427f, 0.07770003f, -0.09446525f, 
    -0.06415118f, 0.03161114f, 0.20325199f, -0.05111138f, 0.00363786f, -0.02347257f, -0.21660095f, 0.23521268f, 
    -0.04573143f, 0.05335751f, 0.13014850f, 0.08378356f, -0.00076770f, -0.16490677f, -0.06451781f, 0.16423614f, 
    -0.01668895f, -0.04667036f, -0.21140638f, -0.07206625f, -0.02818654f, -0.15915449f, -0.03056610f, 0.07588074f, 
    -0.15790170f, 0.05264465f, -0.09200668f, 0.01245779f, 0.02133383f, 0.05652516f, -0.06853734f, -0.17395043f, 
    -0.11636164f, 0.15441208f, 0.03653509f, -0.16370885f, 0.07192204f, -0.03333420f, -0.07099301f, -0.26449013f, 
    0.00699157f, 0.03505031f, 0.21607037f, -0.16304642f, 0.02953790f, -0.17866094f, -0.28156227f, 0.02930103f, 
    -0.08174701f, 0.02757668f, 0.14341338f, -0.03045389f, -0.08000163f, -0.20788844f, -0.17766686f, -0.14538118f, 
    0.12409401f, 0.04795612f, 0.04993770f, -0.02943965f, 0.27540702f, 0.01073702f, -0.16445979f, 0.04884072f, 
    0.04438964f, 0.10601626f, 0.01762102f, -0.03914872f, -0.17285259f, 0.08329649f, -0.26197883f, -0.04031644f, 
    0.05897859f, 0.03640597f, 0.01290326f, -0.16828124f, 0.11302801f, -0.07109687f, 0.16639949f, -0.00309730f, 
    0.03649807f, -0.06111158f, 0.13072777f, -0.06081105f, -0.01190089f, 0.13122167f, 0.02473859f, -0.08014261f, 
    0.08328792f, 0.03038870f, -0.07958820f, -0.02496238f, -0.14108880f, -0.10497469f, -0.09945404f, -0.03599222f, 
    0.04530775f, -0.01756350f, -0.28885520f, -0.04877076f, 0.14981835f, -0.06098805f, -0.10360423f, -0.04498901f, 
    -0.10028410f, 0.48482782f, 0.18625414f, 0.01960041f, 0.16699170f, 0.16810116f, 0.07665109f, -0.28291118f, 
    -0.10177097f, 0.01962181f, 0.24146758f, -0.15638903f, 0.00257473f, -0.04234521f, 0.12358225f, -0.06179409f, 
    0.07799907f, -0.13174036f, 0.08446829f, -0.29615360f, -0.00006689f, 0.06116638f, 0.07611730f, -0.05460894f, 
    0.13625962f, -0.07280934f, -0.18315567f, -0.01910957f, -0.12176996f, 0.13899757f, 0.08650846f, -0.00187701f, 
    0.19465683f, -0.10284871f, 0.02231440f, 0.10206330f, 0.18479080f, 0.14523739f, 0.15940404f, -0.10310055f, 
    0.16041252f, -0.07007806f, -0.08489051f, -0.06699128f, 0.19675131f, -0.07597824f, -0.02876734f, 0.26462916f, 
    -0.04644896f, 0.09683578f, -0.00677953f, -0.00177371f, -0.06290195f, -0.15688118f, -0.11065362f, -0.00781460f, 
    -0.02959470f, -0.23944382f, -0.06209929f, 0.03003693f, 0.12881440f, -0.21106265f, -0.07535463f, 0.10442633f, 
    0.14752463f, 0.07577629f, 0.13041623f, 0.01001059f, 0.15630914f, -0.09476485f, 0.13027789f, -0.00417571f, 
    0.07592782f, 0.01824793f, -0.11047685f, -0.07526594f, -0.03689994f, 0.01408505f, 0.09749828f, -0.05557205f, 
    -0.07426219f, -0.01087669f, -0.13538100f, 0.06449236f, -0.14980684f, -0.20538811f, -0.09006192f, 0.21503188f, 
    0.12097748f, 0.04836558f, -0.13349758f, 0.21750747f, -0.17514807f, -0.11415839f, -0.03748620f, -0.04469483f, 
    -0.01542557f, -0.07534828f, -0.02585593f, -0.06950384f, 0.15714799f, 0.32469782f, -0.24309987f, -0.07746314f, 
    0.08205569f, 0.12000870f, -0.06484775f, 0.08699369f, 0.02276015f, 0.11919072f, -0.02631605f, -0.04636192f, 
    0.02115647f, 0.03840787f, 0.11656674f, -0.16908813f, 0.14976881f, -0.03650421f, -0.19407414f, 0.01791425f, 
    0.08099804f, -0.00345200f, -0.01392648f, -0.11682666f, 0.12730002f, -0.09544096f, 0.01147365f, 0.18744665f, 
    -0.05967402f, 0.01667755f, -0.09130242f, -0.05713921f, 0.08991159f, -0.05778559f, -0.01813416f, 0.08339231f, 
    -0.18995461f, 0.07824270f, 0.04283267f, -0.18202819f, 0.02357819f, 0.02219064f, 0.02265481f, 0.02905689f, 
    -0.06303824f, -0.02202605f, 0.01584918f, -0.07315546f, 0.02633202f, 0.16474165f, 0.10514115f, -0.00618589f, 
    -0.04589525f, -0.03832746f, 0.06327496f, 0.12002487f, -0.00617753f, 0.03013293f, -0.03168409f, -0.12685543f, 
    0.06430016f, 0.14790840f, -0.09546887f, 0.04328388f, 0.02769986f, -0.01658856f, 0.15201089f, -0.21633846f, 
    0.24615359f, 0.03652404f, 0.07388852f, -0.14901859f, 0.39635909f, 0.11086534f, -0.13833232f, 0.14902917f, 
    0.11461939f, 0.14411385f, 0.00856951f, -0.01019339f, -0.08232933f, 0.00478131f, -0.10388397f, -0.04603830f, 
    0.11023115f, -0.06517663f, -0.08140346f, 0.19304326f, -0.12877971f, 0.06755849f, 0.04748432f, -0.11385874f, 
    -0.01482209f, 0.09033341f, 0.06797379f, 0.07296064f, 0.20889001f, 0.02325057f, 0.13503556f, 0.01871134f, 
    0.06860747f, -0.09533350f, -0.14519839f, 0.02212559f, -0.03339038f, -0.09562553f, -0.01857670f, -0.06224961f, 
    -0.33798507f, -0.46783856f, -0.22512336f, 0.21688363f, 0.12857835f, 0.12121148f, -0.03901154f, 0.07807160f, 
    -0.11280244f, -0.15917586f, -0.13776745f, 0.02692405f, 0.12386414f, 0.08557975f, -0.13238791f, 0.03648996f, 
    0.11499608f, -0.06805480f, -0.02456662f, -0.21039605f, 0.00671673f, -0.01582889f, 0.06687713f, -0.13311152f, 
    -0.05145501f, -0.05141951f, -0.12046330f, 0.00255067f, -0.08067252f, 0.00751295f, -0.16691287f, -0.05272543f, 
    -0.11940329f, -0.05848305f, -0.04106671f, 0.00241175f, -0.06965876f, 0.00498593f, -0.10902619f, 0.07967843f, 
    -0.15264876f, 0.22658481f, 0.00590724f, 0.09676941f, -0.05934529f, -0.18490797f, 0.14947411f, -0.02373887f, 
    -0.05969800f, 0.00556273f, 0.05987493f, -0.10476677f, 0.08338460f, 0.10981077f, -0.10386716f, 0.17311610f, 
    -0.03071521f, 0.13115592f, 0.00254050f, 0.21318990f, 0.08207498f, -0.00325402f, -0.10374931f, 0.09260923f, 
    0.16669245f, -0.20084356f, -0.08329109f, 0.11928768f, 0.00296552f, 0.16479070f, 0.04219701f, 0.08602607f, 
    -0.11134024f, -0.01144565f, -0.14747196f, 0.13952795f, 0.21361722f, 0.07264263f, 0.05230209f, 0.07923407f, 
    0.05609578f, 0.36870903f, 0.07263021f, -0.02240515f, 0.10047350f, -0.07458738f, 0.09146404f, -0.03537172f, 
    0.14285813f, 0.00222712f, -0.25349212f, -0.06051970f, 0.08625296f, 0.10007471f, -0.05453030f, 0.06474011f, 
    -0.16465132f, -0.03017901f, -0.02512389f, -0.37209326f, -0.45627391f, -0.26324010f, 0.06754523f, 0.11562159f, 
    0.04934738f, -0.01173737f, -0.14656238f, 0.06849878f, -0.09219679f, 0.28793153f, -0.13351120f, 0.05319760f, 
    0.13637885f, 0.12523033f, -0.04169498f, 0.04149212f, -0.11914042f, 0.38974416f, 0.30043659f, 0.14711544f, 
    0.09426258f, 0.09676699f, 0.04292888f, 0.04170755f, 0.11785738f, -0.05378734f, 0.42644736f, -0.17206450f, 
    -0.25483260f, 0.06804705f, -0.04374791f, 0.10145873f, 0.14971669f, 0.04921878f, 0.18616216f, -0.12513831f, 
    -0.02916797f, 0.02157857f, -0.01869330f, -0.05206763f, -0.19335717f, -0.09929123f, 0.10789733f, 0.05930639f, 
    0.29438144f, 0.09557804f, -0.04945703f, 0.03026368f, -0.02558711f, 0.00094041f, 0.19350991f, 0.03802587f, 
    -0.07766080f, -0.04093044f, 0.00194694f, 0.07557752f, -0.12980402f, 0.01858086f, -0.06859353f, 0.04757376f, 
    -0.09621126f, 0.07758126f, -0.24607196f, -0.06432600f, -0.27428091f, 0.18223013f, 0.15581670f, 0.02403640f, 
    0.01984314f, 0.03102357f, -0.00953328f, -0.11706271f, -0.31299472f, -0.01609246f, -0.10075866f, -0.06662086f, 
    0.18215826f, -0.21896179f, -0.05655162f, -0.05965237f, -0.20194539f, 0.28885379f, 0.00598007f, 0.06326064f, 
    0.02548695f, -0.13488688f, 0.05249741f, -0.00971633f, 0.02894531f, 0.05750621f, -0.10001178f, -0.00908516f, 
    0.13272932f, -0.02832697f, -0.03397344f, -0.00964629f, 0.15641262f, 0.01859488f, -0.10516629f, 0.03850571f, 
    0.15547873f, 0.14323066f, -0.07246231f, -0.07724211f, 0.11845631f, 0.00673369f, 0.08271116f, 0.11646224f, 
    0.07764085f, -0.24551170f, -0.07812019f, -0.05100285f, -0.04413088f, -0.00801592f, -0.13900700f, 0.05219292f, 
    -0.15588942f, -0.13778210f, -0.24012385f, -0.14167328f, 0.10519829f, -0.01739690f, -0.01755934f, -0.07190057f, 
    0.13171010f, 0.05749848f, 0.17123951f, 0.09069514f, -0.00758927f, 0.06790884f, -0.08970916f, 0.16227487f, 
    0.04821920f, 0.12164170f, -0.17517088f, 0.04141616f, 0.28637186f, 0.02756328f, -0.00410133f, 0.06011420f, 
    -0.09404922f, -0.01170296f, -0.04301922f, 0.18300241f, 0.35505375f, -0.12683129f, 0.03808106f, 0.00116501f, 
    -0.00614853f, 0.04083130f, 0.00203263f, -0.08353586f, 0.24730869f, 0.12729864f, 0.22124045f, 0.10998577f, 
    0.17747572f, -0.07612901f, 0.03195135f, 0.09670522f, -0.07972514f, 0.24006762f, 0.12633121f, -0.14638229f, 
    -0.02994962f, 0.02775243f, -0.08025075f, -0.03355666f, -0.02810608f, 0.15486960f, 0.35260034f, 0.04685736f, 
    -0.02781720f, -0.10416322f, -0.06551521f, 0.03967024f, 0.10815526f, 0.11417970f, 0.00189199f, -0.15307222f, 
    -0.05694387f, 0.17958435f, 0.05817235f, 0.01875617f, 0.06291479f, 0.00369568f, -0.05357394f, -0.12493936f, 
    0.00139416f, -0.03484794f, 0.05299724f, 0.19383101f, 0.16441534f, -0.10757271f, -0.01101953f, 0.03570799f, 
    -0.06917872f, 0.01690806f, 0.14390625f, -0.04550825f, -0.03826923f, -0.09667826f, 0.00378980f, -0.01937866f, 
    -0.02462180f, 0.05647039f, -0.33629861f, -0.13320835f, 0.08322731f, 0.01683972f, 0.00022884f, -0.05240800f, 
    -0.13247609f, 0.05869362f, -0.07795292f, -0.08999830f, -0.01485312f, 0.01781952f, -0.09695148f, -0.03592166f, 
    0.01494932f, 0.00925054f, 0.05200721f, 0.11860412f, 0.03334238f, 0.16178732f, -0.11012371f, 0.07075986f, 
    -0.00525039f, 0.05481907f, 0.31442723f, -0.11932804f, -0.03045945f, -0.32800919f, -0.13061576f, 0.17524239f, 
    -0.07300117f, -0.01229262f, -0.00306738f, -0.04925509f, 0.05195832f, 0.04722361f, 0.02913789f, 0.04205714f, 
    0.06165182f, -0.07508084f, 0.03308485f, 0.03713946f, -0.05724504f, 0.12802510f, -0.01557760f, -0.11911548f, 
    0.12868735f, 0.21435712f, 0.09401073f, -0.08000383f, -0.03228430f, -0.11591297f, 0.05427153f, 0.00336397f, 
    0.12051697f, -0.18177778f, -0.18079254f, 0.01007161f, 0.01076116f, -0.08741485f, 0.04151574f, 0.00947610f, 
    0.02106402f, 0.18435274f, -0.02660124f, -0.26068485f, 0.12502466f, 0.05450119f, 0.14297500f, 0.22517814f, 
    0.05015819f, 0.23824579f, -0.23814622f, -0.18872823f, -0.11270452f, 0.04174539f, -0.09623767f, -0.04781121f, 
    0.10033201f, 0.02957782f, 0.00615682f, 0.13032728f, 0.03959839f, 0.05330173f, 0.05311258f, 0.03902083f, 
    -0.03994717f, -0.03343936f, 0.04118872f, 0.02364742f, -0.03054123f, 0.11793860f, -0.35423335f, 0.10270280f, 
    -0.09629192f, -0.00836412f, 0.21862981f, 0.05149919f, 0.17677920f, 0.19721410f, 0.25557142f, -0.56256568f, 
    0.11793552f, 0.03899246f, 0.00073910f, 0.13964945f, 0.00893473f, -0.07217420f, 0.37786308f, -0.02219077f, 
    -0.20925520f, 0.00631282f, 0.04334024f, 0.08214259f, 0.02546005f, -0.09243655f, -0.01798749f, -0.29219955f, 
    0.13361412f, 0.24320352f, 0.07475193f, -0.00419356f, -0.09138666f, 0.13619025f, 0.00581863f, 0.02928250f, 
    0.04355652f, -0.01384699f, -0.08605999f, 0.05676942f, -0.02403698f, -0.09261396f, 0.11680762f, -0.08700370f, 
    0.10083013f, -0.04360258f, -0.11414398f, -0.27028465f, 0.05093684f, 0.05073493f, -0.05520391f, -0.02448413f, 
    0.20049931f, -0.07215899f, 0.08538882f, -0.02517071f, -0.00677590f, 0.01004088f, 0.10747213f, 0.10372935f, 
    -0.12897393f, -0.14969370f, -0.12695564f, -0.02850070f, -0.35184649f, -0.05628882f, 0.13846794f, -0.02908306f, 
    -0.00208069f, 0.15776077f, -0.11155786f, 0.08128162f, -0.01755571f, -0.01122622f, 0.03045453f, 0.16717908f, 
    -0.01467552f, 0.20376089f, -0.21108449f, 0.18209082f, -0.09415049f, 0.03154329f, 0.03181065f, -0.21053369f, 
    0.10732082f, 0.14285122f, 0.13407440f, 0.19109841f, -0.06433079f, -0.01192973f, -0.06366797f, 0.02397027f, 
    0.23171946f, -0.02551611f, 0.09668407f, 0.01902406f, 0.09431219f, 0.10046931f, -0.02720845f, 0.11210325f, 
    -0.07986242f, -0.27676275f, -0.01632516f, 0.21519671f, 0.07134599f, 0.06350215f, 0.18157242f, -0.03864231f, 
    -0.05683245f, 0.06789111f, -0.03845209f, 0.13836758f, -0.00895632f, 0.16839199f, -0.12121801f, 0.09101041f, 
    0.06444319f, 0.07182138f, 0.03086166f, 0.04176104f, 0.06875570f, 0.11284699f, 0.03719356f, -0.21163788f, 
    0.12129439f, -0.16618636f, 0.31534666f, 0.06397200f, -0.11271168f, -0.06556635f, -0.08460015f, -0.13693497f, 
    0.04197883f, 0.18766129f, 0.00094381f, -0.17857939f, -0.13769464f, 0.02065725f, 0.12794971f, -0.06011593f, 
    0.09023520f, -0.00094070f, 0.09130759f, 0.04346375f, 0.21272312f, 0.02995544f, 0.13236706f, -0.07947814f, 
    0.02492520f, 0.15284587f, 0.00578626f, 0.06665514f, -0.03414281f, -0.12785716f, 0.26778272f, 0.08212326f, 
    -0.08748946f, 0.03547902f, -0.13708881f, -0.04933637f, -0.16972676f, 0.03775933f, -0.07974523f, -0.03400449f, 
    0.10960530f, -0.17212375f, 0.00687975f, -0.10413014f, 0.11236946f, -0.07097793f, 0.21797648f, 0.14229937f, 
    -0.04247151f, -0.00566867f, 0.03384673f, 0.02957591f, -0.05614242f, 0.14555584f, 0.11700652f, 0.10451808f, 
    -0.29881138f, -0.03613858f, 0.20409295f, -0.08798421f, -0.03331183f, -0.11810286f, 0.02056162f, -0.16263272f, 
    -0.03465320f, -0.04955147f, -0.11516681f, -0.13591479f, -0.03710988f, 0.25089896f, -0.03214852f, 0.01826734f, 
    0.06869392f, 0.01939810f, 0.10048974f, -0.07008744f, -0.06427711f, 0.07995340f, 0.04969225f, 0.15494876f, 
    0.09664992f, -0.00209864f, -0.10849755f, -0.18059643f, -0.17703728f, 0.05652934f, 0.22014290f, 0.00183843f, 
    0.00333268f, 0.16577081f, -0.05316101f, -0.24643031f, -0.17957449f, -0.02384925f, 0.03891102f, 0.02923327f, 
    0.21425140f, 0.04532095f, -0.03545405f, 0.02480352f, 0.04342153f, 0.11216957f, -0.04847778f, 0.32445982f, 
    0.19041497f, -0.04822987f, 0.02051368f, 0.02313390f, 0.01517544f, 0.16116309f, -0.07874400f, 0.06102222f, 
    -0.21756537f, 0.06474716f, -0.03369624f, 0.15644331f, 0.14053953f, 0.03080515f, -0.01058964f, 0.34970289f, 
    0.26219264f, -0.06097051f, 0.02833213f, -0.07155857f, 0.11210511f, 0.04204488f, 0.23776406f, -0.03860874f, 
    -0.18080461f, -0.11660454f, 0.00146494f, -0.06079104f, 0.09637753f, -0.10953454f, 0.11721631f, -0.05604018f, 
    0.11862753f, -0.10050990f, -0.26494151f, -0.11636221f, 0.06866850f, 0.08637434f, 0.11704214f, 0.08067699f, 
    -0.02835760f, -0.29176942f, -0.01990350f, -0.31461045f, -0.00999709f, 0.25063318f, 0.19686636f, -0.00154061f, 
    0.08304736f, -0.07408162f, 0.07515419f, 0.27133414f, 0.05239597f, 0.02187980f, -0.29822358f, 0.01396475f, 
    -0.13445497f, 0.00606695f, 0.03586232f, -0.07796741f, 0.10395494f, -0.14203377f, -0.05309173f, -0.08540511f, 
    0.05794335f, 0.10568729f, -0.17851278f, 0.01172341f, -0.03588728f, -0.15734433f, -0.26986355f, -0.13425191f, 
    0.01599483f, 0.11088753f, 0.08179444f, 0.11179771f, -0.12272864f, -0.06130019f, -0.25607902f, 0.01841835f, 
    -0.00577359f, -0.25530842f, 0.02039391f, -0.01541405f, 0.10711399f, 0.02973587f, 0.10809882f, 0.12050909f, 
    -0.10486731f, -0.08568641f, 0.20836040f, 0.00963389f, 0.05391249f, 0.12469079f, -0.01434654f, -0.04139720f, 
    -0.06803085f, 0.22167028f, 0.27412513f, -0.13244365f, 0.03911290f, -0.11677217f, 0.09050193f, 0.07976985f, 
    0.06549282f, 0.22509660f, -0.19660430f, 0.03646401f, -0.06993489f, -0.10147858f, -0.03621556f, 0.06237296f, 
    -0.00121816f, 0.00983426f, -0.12298062f, -0.08733252f, -0.00782059f, 0.01218663f, -0.09974475f, 0.17930087f, 
    0.03381704f, -0.12036078f, -0.08625531f, -0.05360287f, -0.39471817f, -0.48621249f, 0.07498161f, 0.02526156f, 
    -0.00491705f, 0.09034397f, 0.04705351f, 0.02983072f, -0.06734644f, -0.06782451f, -0.31166795f, -0.02632325f, 
    0.07968643f, -0.03507991f, 0.07986608f, -0.10001396f, 0.08107672f, 0.19472578f, -0.00689572f, -0.02392177f, 
    0.01255407f, 0.02693854f, 0.03866360f, 0.23365620f, 0.06088024f, 0.05709164f, 0.52071500f, 0.02480089f, 
    -0.06504441f, -0.03748012f, -0.01498708f, -0.03326048f, 0.01424994f, 0.00715435f, 0.07499198f, -0.03553485f, 
    0.12674896f, 0.24335766f, 0.01730283f, -0.05094691f, 0.04768933f, 0.14148821f, -0.07822424f, 0.18261722f, 
    0.04229933f, -0.11831515f, -0.12336010f, -0.09101538f, 0.08709320f, 0.06650628f, 0.10766383f, -0.06984745f, 
    0.06950916f, 0.05159525f, 0.21071336f, -0.08150816f, -0.09305977f, -0.02613228f, -0.02976021f, -0.04152453f, 
    0.00123952f, 0.11261450f, -0.13212989f, -0.34517521f, 0.21207111f, 0.05497556f, -0.14756845f, 0.05431892f, 
    0.14865296f, -0.12744531f, 0.01546915f, -0.16088758f, -0.00705216f, -0.24972822f, -0.00774641f, -0.02722957f, 
    -0.01545350f, 0.15830936f, 0.10435501f, -0.07005018f, -0.05056717f, 0.18307333f, 0.26285297f, 0.05155274f, 
    0.01803729f, 0.13760702f, -0.03045776f, 0.06926862f, 0.03580775f, 0.02755810f, -0.09485632f, -0.06204795f, 
    -0.05762285f, 0.17010173f, 0.02767994f, -0.03309259f, -0.15021202f, -0.10292295f, 0.03379415f, 0.25953445f, 
    0.11796588f, -0.04604238f, 0.03894205f, 0.02961203f, -0.10532289f, 0.16407436f, 0.01248240f, -0.30149752f, 
    -0.43810669f, -0.15608233f, 0.04555516f, -0.00715378f, -0.05202845f, 0.09547725f, 0.08915463f, -0.05234513f, 
    0.18005186f, -0.31606072f, 0.00672422f, -0.04807569f, 0.13398510f, 0.04328227f, 0.02823790f, -0.08868283f, 
    -0.13205278f, -0.27571434f, -0.12500364f, 0.44593766f, 0.08813105f, 0.02597714f, -0.02816673f, 0.02000873f, 
    -0.02797242f, 0.08537392f, 0.11946785f, -0.46578026f, -0.23500752f, 0.09028905f, -0.07258398f, 0.13116063f, 
    -0.05630028f, -0.10794724f, -0.04661756f, 0.42781875f, 0.02164932f, -0.21680872f, -0.16326106f, -0.03251391f, 
    -0.01855244f, 0.00177190f, -0.03445801f, 0.09471699f, 0.11609677f, -0.02057132f, -0.27757320f, -0.00518075f, 
    0.08272021f, 0.01036350f, 0.11355896f, -0.03285797f, 0.00185990f, 0.14896451f, -0.32878488f, -0.44557714f, 
    0.06414296f, 0.03407883f, -0.03255296f, 0.00395743f, 0.04352599f, -0.03114773f, 0.17081037f, -0.06917980f, 
    -0.19335112f, -0.15213184f, 0.04199821f, 0.16267264f, -0.02111058f, 0.08697806f, -0.10116476f, -0.34894869f, 
    -0.15641356f, -0.08194261f, 0.08764470f, 0.05453053f, 0.03284850f, -0.01463741f, -0.10653114f, 0.03350434f, 
    0.18181559f, -0.08940278f, -0.08057431f, -0.13250935f, 0.06766096f, 0.08719976f, -0.05533798f, 0.01605879f, 
    0.03022960f, 0.05363414f, 0.03851337f, 0.00242858f, 0.06811725f, 0.11032552f, -0.01072192f, 0.00861766f, 
    -0.00771543f, 0.00276590f, -0.24800050f, -0.25130787f, -0.07838711f, 0.04125490f, -0.01942944f, 0.06850721f, 
    0.00056440f, 0.11270431f, 0.16420583f, -0.38251576f, 0.19017740f, 0.12271044f, 0.07465464f, 0.09410734f, 
    -0.08219445f, -0.02379565f, 0.05764986f, -0.00662460f, 0.02989215f, 0.02590390f, -0.14603086f, -0.13184357f, 
    0.07389727f, 0.15591875f, -0.07276869f, 0.06978927f, 0.15972257f, -0.01751628f, 0.09374992f, 0.07980612f, 
    -0.04010076f, -0.00832812f, 0.04890794f, -0.07553399f, -0.02171724f, 0.02828976f, 0.19445555f, 0.16405948f, 
    0.02036059f, -0.06213658f, -0.06470498f, -0.17503807f, -0.03776179f, 0.03432406f, -0.09514635f, -0.23524269f, 
    -0.41784355f, -0.19024506f, -0.10466431f, 0.14632571f, -0.04730998f, 0.01347313f, -0.17882475f, -0.14842489f, 
    0.00019272f, 0.03973030f, -0.05550651f, -0.05241073f, -0.00870549f, 0.00209499f, -0.00369042f, 0.04759785f, 
    -0.00080221f, -0.03295200f, -0.04455393f, 0.03212663f, -0.06317133f, 0.03310582f, 0.04313047f, 0.02910409f, 
    0.00869323f, 0.01223334f, -0.01975781f, -0.03158400f, -0.01108259f, 0.01837223f, 0.00863913f, -0.01885743f, 
    -0.04675161f, -0.05558728f, 0.05355565f, -0.03989218f, -0.03788315f, -0.00038415f, -0.00792839f, -0.02804707f, 
    -0.05154870f, -0.01305152f, -0.01983898f, -0.03175731f, 0.01296535f, 0.00940644f, -0.04624080f, -0.01329904f, 
    -0.00697255f, -0.04274619f, 0.01056625f, -0.03324879f, 0.01206911f, 0.00942514f, -0.01968265f, 0.05284348f, 
    -0.00792048f, 0.05651551f, 0.00217408f, -0.05569758f, 0.03749223f, 0.00066076f, -0.03107694f, -0.03037310f, 
    0.03297845f, 0.05098927f, -0.01605756f, -0.01007871f, 0.00891796f, -0.03285988f, 0.00469050f, -0.02916053f, 
    -0.04847727f, 0.01950837f, -0.01947398f, 0.03992257f, 0.02677085f, 0.01629435f, -0.06017362f, 0.05729817f, 
    -0.00683089f, 0.01642673f, -0.06562636f, -0.00228501f, 0.01596174f, 0.01128368f, 0.00900173f, 0.05340678f, 
    0.00463048f, 0.05837904f, -0.02534959f, -0.00526040f, -0.03796490f, 0.03831493f, -0.02182458f, -0.06084659f, 
    -0.04764167f, 0.05056117f, 0.05446720f, -0.02119524f, 0.03919690f, 0.02321533f, 0.04821579f, 0.05254575f, 
    -0.05228751f, 0.00411083f, 0.04286673f, 0.02622545f, 0.03483902f, 0.02654986f, -0.03716530f, 0.03770367f, 
    0.00024978f, 0.00641113f, -0.04731902f, -0.00794970f, 0.04941316f, -0.01080771f, 0.04852433f, -0.04712223f, 
    -0.01750626f, 0.02875778f, -0.04223471f, -0.05139283f, 0.03496078f, -0.03656266f, -0.06881333f, -0.01908074f, 
    -0.05226462f, 0.04058888f, 0.00219485f, -0.00832478f, 0.03862947f, 0.05153851f, -0.00061348f, 0.05189069f, 
    -0.02709661f, 0.00815829f, -0.01271341f, -0.04189340f, 0.00889884f, -0.05644504f, 0.04603772f, 0.00679047f, 
    0.02203292f, -0.05651188f, -0.02738004f, 0.00535342f, -0.02034203f, -0.02680845f, 0.03727770f, 0.02036169f, 
    -0.03860234f, -0.01196731f, 0.01152335f, 0.03426835f, -0.06380967f, -0.03810547f, 0.04099825f, 0.05126180f, 
    -0.00804922f, -0.06494023f, -0.00207623f, 0.01740248f, 0.01110410f, 0.02222502f, -0.01261468f, -0.05545205f, 
    -0.05340381f, -0.01488357f, -0.03929010f, -0.02641233f, 0.05186498f, 0.01054858f, -0.04925284f, -0.00942860f, 
    -0.02976011f, -0.02943522f, 0.00086837f, -0.04742643f, 0.03290230f, 0.02665096f, -0.01481182f, -0.02325084f, 
    -0.05889483f, -0.04496449f, -0.02429037f, 0.01190528f, -0.04192691f, -0.04176042f, 0.02161383f, 0.00084061f, 
    -0.01971079f, -0.05266454f, -0.01918926f, -0.02213188f, -0.05064109f, 0.02967288f, -0.06086744f, 0.02731453f, 
    -0.01736083f, -0.04266256f, -0.01385686f, -0.01681755f, -0.02043195f, -0.01372755f, 0.03746650f, -0.01262279f, 
    -0.01920849f, -0.04470217f, 0.04595770f, 0.05039928f, -0.00071682f, 0.02306598f, -0.00872135f, -0.05405948f, 
    -0.03982954f, 0.01045417f, -0.02706844f, -0.02809460f, 0.02320813f, 0.01140926f, -0.02606915f, -0.00975890f, 
    -0.00567357f, 0.05673816f, 0.05064648f, -0.02073238f, -0.01270385f, 0.05586273f, 0.02423776f, -0.06122681f, 
    -0.03575831f, 0.03825269f, 0.00965784f, -0.03816595f, -0.03815556f, 0.00016734f, -0.01958513f, 0.02328310f, 
    -0.02631042f, -0.05957094f, -0.05427238f, 0.03493842f, 0.01255264f, 0.00320224f, -0.04600802f, -0.01602847f, 
    0.00228656f, -0.02912364f, 0.01808652f, -0.01518381f, -0.00512885f, 0.02501772f, -0.04108106f, 0.01036789f, 
    -0.02222958f, 0.03345817f, -0.00384956f, -0.01621108f, -0.06476478f, 0.04017030f, -0.01213020f, -0.02948521f, 
    0.02703317f, 0.02143876f, 0.00104451f, 0.00773716f, -0.04057770f, 0.01849220f, -0.02644564f, -0.04865060f, 
    -0.04898557f, -0.00674772f, -0.06429716f, -0.04664005f, -0.05503637f, -0.05391188f, -0.02285909f, 0.02189673f, 
    -0.05675516f, -0.05476360f, -0.00987957f, 0.05107188f, -0.06243742f, 0.01894022f, -0.05988593f, -0.04148307f, 
    -0.06054022f, -0.05385015f, -0.01389764f, 0.01822972f, -0.04385788f, -0.03974568f, -0.06650595f, -0.02439141f, 
    0.10007805f, 0.01432961f, -0.06351231f, 0.12239867f, 0.06192255f, 0.04400172f, 0.13785903f, -0.04073140f, 
    -0.14501803f, 0.08062612f, -0.21506508f, -0.09316920f, 0.04355855f, -0.06597954f, -0.03482840f, -0.05458662f, 
    -0.02867895f, 0.09401072f, -0.32620341f, -0.21356045f, -0.24588732f, 0.13085654f, -0.05900401f, 0.13725066f, 
    0.03447837f, -0.07938101f, -0.06131127f, 0.00451131f, 0.04371120f, 0.10282162f, -0.30272213f, -0.06386375f, 
    0.19426985f, 0.01341810f, -0.09959176f, 0.10206510f, 0.01389781f, -0.05213176f, 0.16370033f, 0.09857123f, 
    0.16135246f, -0.00249078f, 0.10667036f, -0.07281118f, 0.02850266f, -0.25042042f, 0.07136732f, -0.01268526f, 
    0.10268985f, -0.08888511f, 0.03905897f, 0.09128269f, -0.00344770f, 0.07270287f, 0.12426028f, 0.19685765f, 
    0.03485034f, -0.08324645f, 0.03390398f, -0.08472006f, 0.09680635f, -0.02076257f, -0.03098395f, -0.09331319f, 
    0.10120414f, -0.26767808f, -0.04797214f, 0.02079737f, 0.03137499f, 0.07067055f, 0.02253156f, 0.02073771f, 
    -0.13978893f, -0.11304260f, -0.30323532f, -0.02146794f, 0.01420910f, 0.02454263f, 0.10089669f, -0.12374572f, 
    0.02978789f, 0.00775277f, -0.01469328f, -0.20232759f, 0.07781146f, 0.16680011f, 0.10362525f, 0.05441876f, 
    -0.06877895f, -0.01503719f, -0.05259492f, 0.02169766f, 0.25119215f, -0.11088969f, -0.01809272f, 0.06548738f, 
    -0.11954936f, 0.09563953f, 0.20287564f, -0.03637668f, 0.34823370f, 0.16821267f, 0.21463393f, -0.04014592f, 
    -0.16256022f, 0.07031756f, 0.10674229f, -0.02474146f, -0.07815872f, 0.06319303f, 0.08488293f, 0.24111938f, 
    0.09468340f, -0.08021442f, -0.00548966f, 0.00946983f, -0.07702258f, -0.04270139f, 0.25620028f, -0.10309942f, 
    0.08127726f, 0.03332481f, -0.16058654f, 0.10732370f, 0.00414877f, 0.04024146f, 0.15515308f, 0.00444912f, 
    0.07143322f, 0.07407477f, 0.04399966f, -0.00434198f, -0.02440777f, 0.12239283f, 0.09607696f, -0.03221309f, 
    0.07391110f, 0.22701828f, -0.13957249f, -0.12434846f, -0.04071190f, -0.02924346f, 0.00021133f, 0.04751274f, 
    0.07554066f, 0.08729145f, -0.03726072f, 0.00780312f, 0.02151098f, 0.00971227f, 0.02970714f, 0.16819119f, 
    0.09331972f, -0.17643498f, 0.06553216f, -0.44325274f, -0.01730612f, -0.04660137f, -0.04384957f, 0.04619209f, 
    -0.02003990f, 0.13232857f, 0.13482542f, 0.04013654f, 0.24022008f, -0.12996835f, -0.18589564f, -0.04254575f, 
    -0.11741750f, 0.00480661f, 0.02308253f, 0.05792956f, 0.02125587f, 0.13512345f, 0.05304312f, 0.07036987f, 
    -0.04917214f, -0.05020477f, 0.15095595f, -0.03192387f, 0.05644098f, 0.14592126f, -0.02374550f, 0.02758956f, 
    -0.00898937f, -0.05159761f, 0.00648703f, -0.10387682f, 0.07017511f, 0.14169310f, -0.16991071f, 0.20879631f, 
    -0.15628429f, 0.05605648f, -0.08673687f, -0.11203194f, 0.08460905f, 0.00112259f, 0.13044693f, 0.19259189f, 
    0.02256607f, 0.02666319f, 0.06640859f, 0.00485135f, 0.04306956f, 0.13345808f, -0.06150815f, -0.15631649f, 
    -0.00607730f, 0.45824254f, -0.15294661f, 0.02762166f, -0.06409787f, 0.01246149f, 0.09701221f, 0.18009491f, 
    0.29849812f, -0.04792764f, -0.25820801f, 0.06421044f, 0.01848357f, -0.08685483f, 0.08207145f, 0.11493459f, 
    0.06174973f, 0.02782465f, -0.26931781f, -0.31480092f, 0.04393404f, 0.06825512f, 0.09744758f, 0.12358030f, 
    -0.08788812f, 0.01261129f, -0.35167673f, -0.20452644f, -0.11653865f, -0.07067459f, 0.04007289f, -0.02963222f, 
    0.08272982f, -0.11891311f, 0.01619136f, 0.05417712f, 0.03126211f, -0.12892435f, -0.02348617f, -0.02215190f, 
    -0.02317383f, -0.16526219f, 0.23303223f, 0.04087059f, -0.21016113f, -0.33872151f, -0.38117486f, 0.22870807f, 
    -0.11658524f, -0.02359884f, -0.10893629f, 0.05236102f, 0.13511243f, -0.14762570f, -0.03680768f, -0.44548258f, 
    -0.02314189f, 0.07367866f, -0.10619123f, -0.09342262f, 0.07230581f, -0.27628013f, 0.20749211f, 0.12065652f, 
    -0.02793524f, -0.00432663f, 0.00876799f, 0.00038807f, 0.01606874f, 0.05916440f, 0.01815131f, -0.14695667f, 
    0.02616491f, 0.17251065f, -0.10137809f, -0.04516198f, 0.02740726f, -0.01044482f, -0.01373556f, -0.04936289f, 
    -0.50432193f, -0.17765793f, -0.07033184f, 0.11652963f, 0.02857848f, 0.01490544f, -0.02729119f, 0.06696762f, 
    0.06624481f, 0.16617751f, -0.00742297f, -0.31103128f, -0.06446368f, 0.03885162f, 0.05206642f, -0.03617097f, 
    0.01468182f, 0.17345333f, -0.04613008f, -0.04473612f, -0.18212058f, -0.12916695f, -0.07627030f, 0.06009202f, 
    0.19804832f, -0.01771067f, -0.08476517f, -0.01905666f, 0.22999127f, -0.04316940f, -0.18746611f, -0.15273836f, 
    0.21696781f, 0.09500024f, 0.11474501f, -0.02379586f, 0.30651924f, 0.24748386f, 0.05708609f, -0.11971564f, 
    -0.06231355f, -0.05231250f, 0.06127868f, 0.14659441f, -0.09644028f, 0.01348486f, 0.05936994f, 0.20605698f, 
    0.10351762f, 0.00153474f, 0.08680770f, -0.07009446f, -0.04220926f, 0.02018800f, -0.18851244f, 0.02101737f, 
    0.31268203f, -0.08274238f, -0.06171717f, 0.01756186f, 0.01880661f, 0.03113650f, 0.16661021f, -0.05521044f, 
    0.15640810f, -0.13225737f, -0.20433049f, -0.23006277f, 0.08554764f, 0.05386322f, 0.02746694f, -0.01381923f, 
    0.01136769f, -0.07725442f, -0.17353567f, -0.06640775f, -0.04938212f, 0.05034941f, 0.05796815f, 0.07149868f, 
    0.11499635f, -0.70739853f, -0.03057430f, 0.10971545f, 0.11268928f, 0.05245280f, 0.02141582f, -0.10428174f, 
    0.00998871f, -0.00949653f, 0.18514112f, 0.26947597f, -0.03330896f, 0.01304587f, -0.13341489f, 0.11291755f, 
    0.01660105f, 0.07547633f, -0.02210798f, 0.17839870f, -0.15543976f, -0.14121152f, 0.08784878f, 0.01446760f, 
    -0.11571765f, 0.05238139f, -0.00466167f, -0.07501729f, -0.27225867f, -0.07838589f, -0.32124218f, 0.23106252f, 
    -0.02795050f, 0.15259232f, -0.08235298f, -0.05731821f, -0.11269747f, -0.14408417f, -0.02271190f, -0.14879803f, 
    0.15648489f, 0.03250799f, 0.04791857f, -0.06919647f, 0.01841472f, 0.21143053f, -0.38787118f, -0.26714244f, 
    -0.09973208f, 0.13274452f, 0.11662954f, 0.07686604f, 0.09285564f, 0.09309464f, -0.07196561f, 0.17184925f, 
    -0.02054829f, 0.03359469f, -0.25611046f, 0.06658732f, 0.00501169f, 0.07878199f, 0.08462877f, -0.14428926f, 
    0.03958483f, 0.07434171f, -0.12138492f, 0.06817914f, 0.11629338f, -0.05350900f, 0.06775749f, 0.05110097f, 
    0.09034015f, 0.08776847f, -0.07698543f, -0.04808506f, -0.01979693f, -0.04378123f, 0.02052241f, -0.03720772f, 
    -0.07082491f, 0.01746109f, 0.38446167f, 0.27851766f, 0.04183724f, -0.14891109f, 0.02972852f, -0.03661482f, 
    0.02319766f, -0.04730571f, 0.01494808f, 0.22250676f, 0.01363640f, -0.03043023f, -0.09564011f, -0.10698085f, 
    -0.28355148f, -0.19176756f, 0.07374977f, -0.07826249f, 0.14701810f, 0.02909965f, 0.01953451f, -0.02369033f, 
    -0.05646617f, 0.15390170f, 0.11277083f, 0.09195441f, 0.07024432f, -0.09961216f, 0.18695001f, -0.06004085f, 
    -0.12137289f, 0.00754563f, 0.08637583f, 0.17690374f, -0.05847929f, 0.05864555f, 0.02891861f, -0.06796535f, 
    -0.10763542f, -0.01117293f, -0.08401246f, -0.04521262f, 0.18315807f, -0.05226347f, -0.11065260f, 0.08672397f, 
    0.02258028f, 0.00308813f, 0.08386628f, 0.12014880f, 0.03803046f, -0.09401635f, 0.04263248f, -0.08601070f, 
    -0.40777725f, 0.03827780f, -0.12867157f, 0.21984582f, 0.03597363f, -0.03490745f, 0.18180045f, 0.05405175f, 
    0.09527165f, 0.42026445f, 0.19752550f, 0.05697700f, 0.02783030f, -0.10691201f, 0.04557084f, -0.00953995f, 
    0.01115875f, 0.02888763f, 0.07026999f, -0.13647236f, -0.05839754f, -0.02917473f, -0.00705476f, 0.19414769f, 
    -0.13893355f, -0.09451379f, -0.09865122f, -0.16547954f, -0.16502827f, 0.00112580f, 0.09462101f, 0.02558940f, 
    0.00609241f, -0.01740448f, -0.01633229f, -0.02953090f, -0.13815846f, 0.07595030f, 0.23613966f, 0.29775974f, 
    0.13592699f, -0.05624303f, -0.02270981f, -0.02592101f, -0.04320455f, 0.31326348f, 0.04965807f, 0.15645754f, 
    0.05576416f, -0.05322913f, 0.00004664f, -0.10206190f, -0.05620142f, 0.05262848f, -0.24368776f, -0.05136721f, 
    -0.06827477f, 0.12848227f, 0.05479556f, 0.13738215f, 0.06869306f, 0.17488490f, -0.02190026f, 0.18060075f, 
    0.03550815f, -0.10567746f, -0.08437092f, 0.05296693f, 0.02720847f, -0.05606522f, 0.11447715f, -0.04414839f, 
    -0.05315159f, -0.01391135f, -0.00480587f, -0.00950204f, 0.00301654f, -0.00633575f, -0.05240112f, 0.00419841f, 
    -0.03507962f, -0.04767855f, 0.01988826f, -0.03091404f, -0.05340613f, 0.02303998f, 0.05277688f, -0.06294914f, 
    -0.03956940f, -0.00119824f, 0.02823381f, -0.00507188f, 0.02324213f, -0.03823239f, -0.01270928f, 0.00142429f, 
    -0.05681995f, -0.04318959f, -0.01198382f, 0.01954691f, -0.03944939f, -0.01351766f, -0.04455674f, -0.01445310f, 
    -0.03145443f, 0.00375394f, -0.00965415f, -0.04852399f, 0.02842048f, 0.00740454f, 0.00497596f, -0.06997433f, 
    0.05325096f, -0.06304403f, -0.03682779f, 0.00902340f, 0.03434684f, -0.02266859f, -0.03897305f, -0.00768283f, 
    0.00886482f, -0.01886785f, -0.05414569f, -0.04683620f, -0.04812424f, -0.00017916f, -0.03768244f, 0.00235745f, 
    -0.01202083f, -0.03384159f, -0.06306128f, -0.06293563f, -0.00051432f, -0.00377335f, -0.07098024f, 0.03480703f, 
    -0.06131396f, 0.02674113f, -0.06926902f, -0.02763376f, -0.06936204f, 0.02840186f, 0.02942867f, -0.05376231f, 
    0.04675496f, -0.05737244f, -0.05622261f, -0.04533780f, -0.00573457f, -0.00581049f, -0.03096286f, -0.01929845f, 
    -0.04665729f, 0.05266288f, 0.04463891f, -0.08741162f, -0.06115488f, -0.01673203f, -0.01406219f, 0.02177378f, 
    0.02961453f, 0.01225371f, 0.00415252f, 0.05676062f, -0.03820980f, 0.05021096f, 0.03732226f, 0.01997711f, 
    -0.03672167f, -0.02490957f, -0.01424144f, 0.01071788f, 0.02317788f, 0.04408685f, -0.00453364f, -0.02929258f, 
    -0.04187737f, -0.01355822f, 0.01792992f, 0.01918850f, -0.00653739f, -0.07185142f, -0.08564164f, -0.00263521f, 
    -0.02133599f, 0.02923021f, -0.03692622f, -0.05271045f, -0.07062267f, 0.02236246f, -0.06268721f, -0.03073880f, 
    0.03378420f, -0.04403105f, -0.00751560f, 0.02356392f, -0.02796026f, -0.02723301f, -0.02467273f, -0.07091755f, 
    0.04330894f, 0.02728606f, -0.00952012f, -0.01030568f, -0.07277913f, -0.01824916f, 0.00283796f, -0.03880589f, 
    -0.03425345f, -0.05045339f, 0.02897341f, 0.00342312f, -0.06152104f, 0.04332549f, -0.04972294f, 0.03186262f, 
    -0.03615226f, 0.02833294f, -0.02428007f, 0.01795400f, -0.07149690f, -0.05997864f, 0.03949530f, -0.02288652f, 
    -0.05668801f, 0.03804485f, -0.04543874f, -0.04893183f, 0.00393964f, -0.06894362f, 0.03974916f, 0.02248243f, 
    0.02205701f, 0.04857057f, 0.03735269f, -0.01478877f, 0.03402212f, 0.00907530f, 0.01828940f, -0.05843541f, 
    -0.01887013f, 0.00211022f, 0.01478640f, 0.00435097f, 0.02623874f, 0.01021688f, -0.04783896f, 0.00443112f, 
    -0.01498508f, 0.04375954f, 0.04450446f, -0.04580965f, -0.06783025f, -0.04075708f, -0.01346020f, -0.04278174f, 
    0.04743075f, -0.05707503f, 0.03632665f, 0.00810713f, 0.01565338f, 0.02039254f, 0.04681521f, 0.02691749f, 
    -0.04963280f, 0.01313362f, -0.01393093f, -0.01848794f, -0.03253048f, 0.02249546f, -0.01719857f, 0.05927977f, 
    0.00636598f, -0.03126465f, -0.04228834f, -0.00439087f, -0.06201195f, -0.05424440f, -0.05629427f, 0.03401507f, 
    -0.01689224f, -0.00378847f, -0.02685579f, -0.02451023f, 0.03982791f, -0.04869895f, -0.08332863f, -0.05815654f, 
    -0.00944411f, -0.05932353f, -0.01944652f, -0.00442076f, -0.03445332f, -0.05464689f, -0.05618542f, -0.07030268f, 
    -0.00868479f, 0.02229426f, 0.02826436f, -0.05333359f, 0.03158163f, -0.01011335f, -0.04204868f, -0.03436754f, 
    0.00142745f, -0.04695925f, 0.06217472f, -0.02559299f, -0.03315178f, -0.02904064f, 0.04288742f, -0.06814933f, 
    -0.03561689f, -0.01236118f, 0.02208238f, -0.03119941f, -0.06594627f, -0.05085352f, -0.07108956f, -0.01882743f, 
    -0.01480452f, -0.03882211f, -0.03915205f, 0.01451516f, -0.00521653f, 0.02612663f, 0.00831327f, -0.00789532f, 
    -0.05302851f, -0.02808190f, -0.05473631f, -0.01238915f, 0.00728876f, -0.04742627f, -0.03432156f, 0.02163480f, 
    -0.01579983f, 0.04054985f, 0.02406711f, -0.04611146f, 0.02948321f, -0.00321171f, -0.04230987f, -0.03640100f, 
    -0.01499440f, -0.05282407f, 0.02761183f, 0.02019817f, -0.05413982f, -0.03038327f, 0.04657771f, 0.03792989f, 
    0.07099944f, -0.04235522f, 0.02483313f, -0.01999672f, -0.00837722f, -0.01246517f, -0.05918827f, 0.02087252f, 
    -0.47578129f, -0.26460093f, 0.00121680f, 0.12845519f, 0.01785992f, -0.03434739f, 0.05729366f, 0.03265243f, 
    -0.01304632f, 0.06307212f, 0.11846090f, 0.07229409f, 0.07902446f, -0.12127271f, -0.07330742f, 0.01279587f, 
    0.03015717f, -0.11691003f, -0.06942125f, 0.09214441f, 0.08484018f, 0.08732214f, -0.11614980f, -0.04340256f, 
    -0.02517713f, -0.06246575f, 0.17513813f, -0.05995145f, 0.01356335f, -0.13948414f, 0.15688530f, -0.09223840f, 
    -0.13368455f, -0.11007241f, 0.22186865f, 0.16499014f, 0.16493645f, -0.02999362f, -0.00371284f, -0.00364249f, 
    0.05392159f, -0.07487574f, 0.05195310f, 0.04258194f, 0.06809711f, 0.17552844f, 0.14375637f, -0.16364785f, 
    0.06597710f, 0.05718609f, -0.00447682f, -0.04083140f, 0.01208264f, 0.07969537f, 0.15460899f, -0.09446193f, 
    -0.08105946f, -0.02409539f, -0.01477245f, -0.01335596f, 0.07518835f, 0.14956634f, -0.17757979f, 0.04718858f, 
    -0.05471887f, 0.15021481f, -0.09874631f, -0.04287874f, -0.00675752f, 0.12333336f, 0.05587704f, 0.09816292f, 
    0.24834426f, -0.08812419f, -0.05456068f, 0.14691469f, -0.12673976f, -0.10420027f, -0.12229056f, 0.09211063f, 
    -0.08099296f, -0.08160032f, 0.11214128f, 0.05521634f, 0.13984689f, 0.02092985f, -0.00224018f, 0.04632661f, 
    0.01056247f, -0.17989451f, 0.18420351f, -0.19256417f, -0.01545233f, 0.04816801f, 0.12711971f, 0.01420259f, 
    -0.05625660f, 0.07152545f, -0.04024622f, 0.11130639f, -0.09095880f, 0.16377646f, -0.15951750f, 0.12607260f, 
    -0.13048333f, -0.14175749f, 0.06775977f, 0.14266194f, -0.17595123f, -0.23595572f, 0.13470390f, 0.05357433f, 
    0.19088112f, 0.01593411f, 0.06993388f, 0.06043593f, -0.16905202f, -0.11061707f, 0.02945773f, -0.01440437f, 
    0.05767132f, -0.09400532f, 0.10740768f, -0.01150795f, 0.11964346f, -0.13740624f, -0.34138441f, -0.04476079f, 
    -0.13174990f, 0.11647430f, -0.13256127f, 0.16744930f, 0.12365393f, -0.06894132f, 0.02686991f, 0.01965175f, 
    0.00401267f, -0.12302197f, 0.03225103f, -0.04749936f, 0.14305180f, 0.01233590f, 0.11828030f, 0.10550968f, 
    0.02547778f, -0.04861834f, -0.08890834f, -0.11731565f, 0.05936632f, 0.08876198f, 0.13090274f, 0.03170399f, 
    -0.17716472f, 0.10022536f, 0.21871835f, 0.06302679f, -0.03146965f, 0.00029516f, -0.00272007f, -0.07202702f, 
    0.12562712f, 0.15538551f, 0.20301847f, -0.03087255f, -0.11925527f, -0.16994442f, 0.04054482f, 0.12049692f, 
    0.07875152f, 0.14618331f, -0.20837174f, 0.05610743f, -0.22392818f, 0.08106907f, -0.15024833f, 0.02466439f, 
    0.12491604f, 0.00588648f, -0.00212038f, -0.11786416f, 0.17819718f, 0.02330960f, 0.00703549f, 0.01096023f, 
    -0.01404911f, -0.19827062f, 0.22111627f, 0.20785002f, -0.02995373f, 0.19027267f, -0.19936235f, -0.04569376f, 
    0.06967217f, 0.07717539f, -0.10841861f, 0.07167995f, 0.00937633f, -0.01390320f, 0.03313490f, -0.01356525f, 
    0.08449938f, -0.06352622f, 0.06991942f, -0.10129276f, -0.06856808f, -0.01934899f, -0.00094674f, 0.00160269f, 
    -0.19497350f, -0.04041272f, -0.04644056f, 0.17163613f, 0.04180502f, -0.12623519f, -0.02612884f, 0.09364314f, 
    -0.20798330f, -0.06404195f, -0.19150990f, 0.11981566f, 0.11754555f, -0.11747304f, 0.09438053f, -0.03582940f, 
    0.00638515f, 0.01052107f, 0.30404252f, -0.03315789f, 0.03094375f, 0.04352082f, -0.15840755f, 0.03641357f, 
    -0.07538038f, 0.06876735f, 0.28618571f, -0.02050104f, -0.05025064f, 0.06412054f, -0.05602844f, 0.10753317f, 
    -0.06204363f, 0.02924214f, 0.10849877f, -0.30056810f, 0.07599218f, -0.07551506f, 0.08183489f, -0.03178349f, 
    0.10330355f, -0.03114142f, 0.04385914f, -0.12059399f, 0.07555451f, 0.02604858f, 0.00761948f, 0.11619028f, 
    0.17543070f, -0.05099132f, 0.12461978f, -0.07735620f, -0.07908922f, -0.05503326f, 0.14578073f, 0.01071863f, 
    0.05087650f, 0.16231145f, -0.21066245f, -0.04776720f, 0.08408968f, 0.04093602f, -0.44110918f, -0.02828223f, 
    0.13189465f, 0.08101974f, 0.00054923f, 0.01384812f, 0.03735621f, -0.13165468f, -0.05860743f, 0.17141573f, 
    -0.02128874f, -0.04883271f, 0.00042250f, -0.01636648f, -0.07959004f, 0.08082928f, -0.15295725f, 0.03297970f, 
    -0.11873664f, -0.00940200f, 0.00209204f, -0.00351153f, -0.06423634f, 0.06369644f, -0.09149245f, 0.05067581f, 
    -0.02963078f, -0.04545046f, -0.10296904f, 0.33464485f, 0.08943094f, -0.11334947f, 0.02917084f, 0.00187386f, 
    -0.05419537f, 0.12074528f, 0.04858813f, 0.29148307f, 0.03445591f, 0.07794952f, 0.05553978f, -0.02715715f, 
    0.03047081f, -0.11641692f, 0.09440707f, 0.06549218f, 0.27779001f, -0.03270617f, -0.13242109f, 0.14024326f, 
    -0.18799050f, -0.06413157f, 0.21946263f, -0.00584950f, 0.13192585f, -0.30476591f, 0.10105739f, 0.04385086f, 
    -0.01715915f, -0.15007748f, 0.17862174f, 0.08766351f, -0.10347772f, -0.17228004f, -0.08728569f, -0.09334487f, 
    0.02464430f, -0.04036026f, 0.11090934f, 0.02610708f, -0.04753078f, 0.00830781f, -0.05548924f, -0.12720008f, 
    -0.18082573f, -0.22460710f, -0.10757094f, 0.07418750f, 0.12795438f, -0.09667563f, -0.09991664f, 0.06994884f, 
    0.01410478f, 0.12953204f, 0.09001575f, -0.01039547f, -0.06136018f, 0.17178614f, -0.12082528f, 0.10536452f, 
    0.01028624f, -0.02024521f, 0.17438011f, -0.00568432f, 0.14402358f, -0.02151640f, 0.04740337f, -0.06545934f, 
    -0.08790027f, 0.09344264f, -0.08142973f, -0.14126265f, -0.07880404f, 0.02177533f, -0.01503101f, 0.03724833f, 
    0.02901403f, -0.03944468f, -0.04533104f, -0.09696222f, 0.05400656f, 0.13024910f, -0.09502423f, -0.04999449f, 
    -0.14884128f, 0.03852513f, 0.08696289f, 0.31584138f, 0.09007342f, 0.10044998f, -0.21545899f, 0.08472903f, 
    -0.25699469f, -0.07766556f, -0.03657609f, -0.02955679f, -0.00741215f, -0.24759988f, -0.22245994f, -0.11979785f, 
    -0.06468827f, 0.08537560f, 0.01977972f, -0.00686800f, -0.11730892f, 0.06207386f, -0.04012471f, 0.19512507f, 
    0.14599043f, 0.02379214f, 0.09031955f, -0.04579418f, 0.09404834f, -0.00362671f, -0.14298618f, -0.21372059f, 
    -0.03116527f, -0.04019107f, -0.09973276f, 0.10195057f, 0.05179738f, -0.12517773f, -0.07986291f, 0.10223641f, 
    0.20270106f, 0.30632973f, 0.07221210f, -0.03248245f, -0.08512822f, -0.00375409f, 0.11374364f, 0.11412934f, 
    -0.14225952f, -0.08728567f, 0.04226173f, 0.06261892f, -0.09878244f, 0.10247429f, 0.10798527f, 0.12819037f, 
    -0.17458090f, -0.11156525f, 0.16321529f, 0.14896965f, 0.02222834f, -0.14086768f, -0.01194067f, 0.04603027f, 
    -0.11372811f, -0.02041967f, 0.02451792f, 0.05670603f, 0.20504758f, -0.10393433f, -0.05417031f, -0.06957339f, 
    -0.09781978f, 0.12489901f, 0.15736426f, 0.35005096f, -0.11167356f, 0.17385280f, -0.05775949f, 0.05868454f, 
    0.15033941f, -0.06982112f, -0.07425156f, 0.10492829f, 0.12515278f, -0.01791212f, -0.01517710f, -0.06041332f, 
    0.04487707f, -0.10861959f, -0.15639882f, -0.24851848f, -0.09592676f, 0.20028269f, -0.02719990f, -0.07293324f, 
    0.04411080f, 0.07925390f, -0.00805386f, -0.05992056f, 0.03272108f, -0.08093379f, 0.29251567f, -0.03082163f, 
    0.13708594f, -0.19417569f, 0.00469330f, -0.17051958f, 0.04110952f, -0.05091322f, -0.12809296f, 0.12490443f, 
    -0.00528795f, 0.08048446f, 0.18244313f, 0.11789863f, -0.04261830f, -0.10028576f, 0.03276332f, -0.00723986f, 
    0.03939041f, -0.10976047f, -0.03218938f, -0.01748103f, 0.09322352f, -0.03930143f, 0.10718745f, -0.08730248f, 
    -0.03861710f, 0.25275043f, -0.15686283f, 0.16342646f, 0.19797084f, -0.08176096f, 0.03742687f, 0.11824188f, 
    -0.17733109f, 0.06431584f, -0.08438535f, 0.09641323f, 0.25472939f, 0.05599703f, 0.09318648f, 0.07970536f, 
    -0.11695788f, -0.01169032f, 0.05368135f, -0.05045522f, 0.18863982f, 0.18737407f, -0.05061191f, 0.05387090f, 
    0.16252559f, 0.04467552f, -0.06451627f, -0.24393784f, 0.08798289f, -0.05141770f, 0.03687935f, 0.11328579f, 
    -0.03538981f, -0.08214535f, -0.09619163f, 0.02900827f, 0.07554892f, -0.01255110f, -0.13922161f, -0.10383384f, 
    -0.02450108f, -0.14777306f, -0.25740513f, 0.08540284f, 0.00184905f, 0.17735475f, -0.13650741f, -0.24480058f, 
    -0.05448863f, 0.04673352f, -0.21252634f, 0.07831073f, 0.00702297f, -0.00676453f, -0.02411471f, 0.31286576f, 
    0.14804021f, 0.23178789f, 0.08344136f, 0.07479331f, 0.07869872f, 0.04343329f, 0.16430594f, -0.10597376f, 
    -0.25734946f, 0.03741203f, 0.08874343f, -0.01433037f, -0.13918333f, -0.18858783f, -0.03720377f, -0.09416905f, 
    0.02051961f, 0.09058718f, -0.14778996f, -0.21358182f, -0.10451142f, -0.16281182f, -0.09885245f, -0.02145366f, 
    0.12439153f, -0.01157773f, -0.19921032f, 0.09284863f, 0.28092554f, -0.01410166f, 0.11265032f, 0.21970832f, 
    -0.37264636f, -0.08082914f, -0.24162059f, -0.13800813f, 0.34176248f, 0.28534654f, -0.05944576f, 0.11630422f, 
    -0.02899688f, 0.16626203f, 0.10657633f, 0.02537266f, 0.17563903f, 0.04811194f, 0.07668901f, 0.05674570f, 
    0.06087235f, 0.10343086f, -0.01163682f, 0.05643953f, 0.11126668f, -0.08762684f, 0.03163591f, -0.04455187f, 
    -0.12563759f, 0.02666482f, 0.00820543f, 0.13493219f, -0.14327009f, 0.07013683f, 0.05862851f, -0.10532433f, 
    -0.28714082f, 0.09761317f, -0.12812774f, -0.11982724f, -0.03030923f, -0.22489808f, -0.18631156f, -0.10983914f, 
    0.02173580f, 0.11473551f, -0.01491886f, 0.05910040f, 0.13879295f, 0.12439460f, 0.07345488f, -0.09087621f, 
    -0.02541505f, 0.17158175f, -0.27643904f, 0.07386942f, -0.06830367f, 0.12305894f, 0.01292079f, 0.12217787f, 
    -0.04357928f, 0.10455616f, 0.14180508f, -0.04572437f, -0.09469081f, -0.12051930f, -0.00589648f, -0.14314504f, 
    -0.01711271f, -0.08672652f, 0.18379328f, -0.03336778f, 0.00759174f, 0.05756744f, 0.05724115f, 0.09572060f, 
    -0.03362786f, -0.03613526f, 0.08302826f, 0.21940088f, 0.10508338f, 0.14083850f, -0.07204401f, 0.01660657f, 
    -0.05407290f, 0.05758588f, 0.07690723f, -0.08066725f, -0.22504243f, 0.09821127f, -0.08894198f, -0.18551333f, 
    -0.15891688f, -0.17687100f, -0.12049934f, -0.01232050f, -0.03197197f, -0.01641665f, 0.12010469f, -0.28963754f, 
    -0.02590992f, 0.10734725f, -0.13757792f, 0.08934224f, 0.18063863f, 0.07999641f, -0.17900197f, -0.00994578f, 
    -0.02800982f, -0.06467041f, -0.13147078f, 0.01171139f, 0.00761554f, 0.07641432f, -0.08758559f, 0.12398985f, 
    0.09183004f, 0.29046187f, 0.14857233f, -0.00505507f, 0.06615630f, -0.01833190f, 0.11451288f, 0.07382134f, 
    0.03478632f, -0.21553558f, -0.10633497f, 0.06529263f, -0.01574949f, 0.05008373f, 0.01995825f, 0.04914640f, 
    0.22744542f, -0.44592226f, 0.12064264f, 0.19670126f, 0.05045869f, 0.05775735f, -0.13495103f, 0.02866381f, 
    0.04744944f, -0.06599230f, 0.21554001f, 0.12237986f, 0.01920963f, 0.10808250f, 0.15059127f, -0.00519637f, 
    -0.02929138f, 0.01366863f, 0.08701318f, 0.29341462f, 0.18246259f, 0.12162674f, -0.01500507f, 0.01096493f, 
    -0.14278004f, 0.01506427f, 0.05047292f, 0.17658731f, -0.03337794f, -0.00871242f, -0.15046868f, -0.03290141f, 
    0.00099814f, -0.07107055f, -0.14934336f, -0.15385562f, -0.12291469f, 0.06179263f, -0.02534457f, 0.07256506f, 
    0.07973006f, -0.02933171f, 0.03433243f, -0.00921560f, -0.01416348f, -0.02423069f, 0.16254683f, 0.00757336f, 
    -0.03346746f, -0.12887444f, -0.00873415f, -0.07839211f, 0.04806260f, 0.04766978f, -0.01241978f, 0.04249578f, 
    0.17444512f, 0.22614719f, 0.16240644f, 0.03681899f, 0.17468005f, -0.04856054f, -0.01366483f, -0.03773072f, 
    0.08834959f, 0.05920348f, 0.14291513f, -0.14942639f, -0.12144766f, 0.08073459f, 0.12401695f, -0.04834557f, 
    -0.13153389f, 0.15333618f, -0.12143366f, 0.03611249f, 0.08224709f, -0.04511622f, -0.07062038f, -0.01788947f, 
    0.05363812f, -0.12670204f, -0.06487557f, 0.17385407f, 0.00948126f, 0.13014765f, 0.02128362f, 0.14199159f, 
    -0.00333591f, 0.03076844f, -0.03765766f, 0.04682459f, -0.12999411f, 0.06215417f, -0.06751154f, -0.04297798f, 
    -0.11019912f, 0.04875982f, 0.05139060f, 0.08058461f, -0.10253389f, 0.10995288f, 0.06658547f, -0.00422814f, 
    -0.07984684f, 0.03912618f, -0.04254047f, 0.00913126f, 0.01565958f, -0.30072743f, 0.02972384f, -0.05370065f, 
    -0.07201592f, -0.11351027f, -0.12568291f, -0.02189747f, -0.07111217f, -0.04763927f, -0.08199090f, -0.04958408f, 
    -0.07896156f, -0.10160318f, 0.04516849f, 0.05942340f, 0.09569292f, -0.00278363f, -0.09478714f, 0.25559735f, 
    -0.00307972f, 0.27498403f, 0.14499596f, 0.06511457f, -0.05175620f, -0.00135045f, -0.03926543f, 0.00367151f, 
    -0.07909211f, 0.20730589f, 0.10808134f, -0.20708965f, 0.01821892f, 0.14043738f, 0.05802306f, -0.08858642f, 
    0.03876834f, -0.09956138f, -0.18168220f, 0.05398696f, 0.01787443f, 0.08440541f, -0.02225817f, -0.03307404f, 
    0.08149496f, 0.09157345f, -0.25236586f, 0.08460528f, 0.01351211f, 0.16730607f, -0.04141327f, 0.01730575f, 
    -0.03827733f, -0.03670780f, -0.00130747f, -0.39006922f, -0.06744044f, -0.08777251f, -0.16046403f, -0.02114333f, 
    -0.26573935f, 0.07293466f, -0.02750783f, -0.08074579f, -0.23554540f, -0.19741671f, 0.35256273f, 0.18303703f, 
    -0.02448309f, 0.00311017f, -0.05050049f, 0.00380542f, 0.02058593f, 0.07814930f, 0.12174440f, 0.08597499f, 
    -0.07088701f, 0.14346200f, -0.16119191f, 0.14427049f, 0.19144849f, 0.17736888f, -0.39160755f, 0.07370317f, 
    -0.08026356f, 0.04053951f, 0.10478575f, -0.14790350f, 0.02154708f, -0.08392491f, -0.00928652f, -0.23773694f, 
    -0.29163438f, -0.15811598f, 0.02311325f, 0.11298879f, -0.16247578f, -0.01192271f, 0.07903889f, 0.05468972f, 
    0.11659722f, 0.07894234f, 0.07728414f, -0.00597539f, 0.03776623f, 0.06361045f, 0.04533952f, 0.17884375f, 
    0.03411564f, -0.07746197f, -0.03931139f, 0.09876998f, 0.03690294f, 0.08879158f, 0.07163329f, 0.16922955f, 
    0.06917311f, 0.01892660f, 0.01793372f, 0.09173113f, -0.12237983f, 0.00875067f, -0.02548867f, -0.06114528f, 
    0.00292661f, 0.12285306f, 0.06904470f, -0.10745695f, -0.15685509f, -0.06339852f, 0.11913425f, -0.07329191f, 
    -0.01993976f, 0.08733436f, 0.02542932f, 0.10704751f, -0.14286523f, 0.03234194f, 0.22590730f, -0.00904811f, 
    0.10829488f, -0.13549004f, 0.08072805f, 0.00632611f, -0.04679930f, 0.11040106f, 0.00491424f, 0.35895130f, 
    0.26799136f, -0.04059230f, -0.11736386f, -0.00545291f, -0.06478811f, -0.01096398f, -0.17913342f, -0.03643093f, 
    0.18915096f, 0.14952375f, 0.08780149f, 0.08794255f, -0.02719193f, -0.15534012f, 0.07860055f, -0.10015602f, 
    0.09542444f, -0.24865924f, 0.07509407f, -0.06443140f, 0.24550422f, 0.05324113f, -0.09358496f, -0.07016674f, 
    -0.40760133f, 0.09107766f, 0.23564596f, 0.04781644f, 0.04478167f, 0.02150317f, -0.07314927f, 0.07074551f, 
    0.05543181f, -0.25315696f, -0.01438093f, -0.10854156f, 0.03658863f, 0.04406590f, -0.02224866f, 0.04336520f, 
    0.07693007f, 0.00292487f, -0.08396936f, 0.23421299f, -0.14612119f, 0.05624785f, -0.01747527f, 0.10473742f, 
    0.06599206f, -0.03010766f, -0.01942751f, -0.12285548f, 0.27007371f, -0.19694421f, 0.09031272f, -0.14717813f, 
    0.02618465f, -0.01157682f, 0.03125927f, -0.10098951f, 0.01721915f, -0.04504943f, -0.09149498f, -0.13399085f, 
    0.03648373f, 0.03231495f, -0.07040192f, 0.02287652f, 0.17299950f, -0.34965274f, -0.45597404f, -0.07343168f, 
    0.01992611f, -0.06065598f, -0.01325537f, -0.17099065f, 0.08788788f, -0.15446031f, -0.19048589f, -0.18079492f, 
    -0.16009650f, 0.02762830f, 0.05914211f, 0.00315367f, -0.02202425f, 0.01068980f, -0.04077075f, -0.36969209f, 
    -0.04803944f, -0.14350528f, 0.10932021f, 0.23981531f, -0.01433840f, 0.12367222f, 0.10658249f, -0.09034421f, 
    -0.25459632f, -0.06177645f, 0.02391765f, -0.02962487f, 0.16062935f, 0.11307419f, -0.16271824f, -0.08680740f, 
    0.11354245f, -0.05789411f, 0.15686795f, -0.03921206f, -0.04108568f, -0.03273472f, 0.07212158f, 0.07480915f, 
    0.03637711f, -0.00484942f, 0.33228052f, 0.06552823f, 0.11934543f, 0.02420553f, 0.10707170f, -0.02959711f, 
    0.08820992f, 0.06774174f, 0.10899733f, 0.21028022f, 0.13884254f, 0.17870656f, 0.07351603f, 0.07240079f, 
    -0.11070359f, 0.09288193f, 0.15184222f, 0.03091354f, 0.10750855f, 0.08423785f, 0.05180085f, 0.02913136f, 
    -0.07844381f, 0.02810058f, 0.09936401f, 0.14760403f, 0.22171976f, 0.07170007f, 0.03672035f, 0.05910865f, 
    -0.10206731f, -0.05527074f, -0.00206047f, -0.15607227f, -0.07398809f, 0.19924614f, -0.22737591f, -0.00623275f, 
    0.02232525f, -0.02177991f, 0.10182990f, -0.09615844f, 0.00287855f, -0.02175364f, 0.11250838f, -0.44693393f, 
    0.00593007f, -0.41520861f, 0.12131844f, 0.05749124f, 0.15717725f, -0.03788302f, -0.07874343f, -0.01431954f, 
    0.04083683f, -0.04417470f, -0.01860471f, -0.04229935f, -0.00923175f, -0.03721752f, -0.04513963f, -0.02154379f, 
    -0.06902615f, -0.05203833f, -0.00156202f, 0.01470433f, 0.02197840f, -0.00827424f, -0.03023897f, 0.02958898f, 
    -0.00342211f, -0.04202303f, -0.07128232f, 0.03736219f, -0.06455003f, 0.03469017f, -0.02846047f, 0.04289057f, 
    0.00028737f, 0.00207126f, -0.03983764f, 0.03987898f, 0.04081425f, -0.02293610f, -0.06324869f, -0.02433027f, 
    0.04483828f, -0.05524541f, 0.01248702f, -0.03315937f, -0.06043321f, -0.00087832f, -0.02957032f, -0.05359719f, 
    0.03176044f, 0.02398204f, -0.05784595f, 0.00340751f, 0.00698895f, 0.03495059f, -0.02976354f, -0.06094856f, 
    0.03712343f, -0.03488909f, 0.01577529f, -0.00126458f, -0.06063193f, -0.03337946f, -0.02459282f, 0.04617415f, 
    0.01572861f, -0.05572425f, 0.02602052f, -0.02421148f, 0.03918068f, -0.04102127f, 0.00420680f, -0.00311783f, 
    -0.03600734f, 0.00266687f, 0.01130836f, -0.04580718f, -0.04533811f, 0.02298255f, 0.00124177f, 0.04250655f, 
    -0.02420187f, 0.02822410f, 0.02528190f, -0.03292912f, 0.02972149f, 0.04565106f, 0.00168310f, 0.01268170f, 
    -0.01944711f, -0.02593283f, -0.02012912f, -0.03825842f, -0.04405733f, 0.04431848f, 0.01431080f, 0.00679287f, 
    -0.03022089f, 0.00599969f, 0.03675681f, 0.03668243f, 0.03230956f, -0.01380142f, -0.04177547f, -0.05606197f, 
    -0.05170180f, 0.01300126f, 0.04841373f, 0.01426574f, 0.04843799f, -0.03123193f, 0.00044428f, -0.05876565f, 
    -0.05377560f, -0.02427880f, 0.01446167f, 0.02064218f, 0.04066290f, -0.00203594f, -0.03360667f, -0.03698263f, 
    -0.05383607f, -0.01789634f, -0.02759401f, 0.03070313f, -0.06704021f, 0.05198523f, 0.05343651f, -0.02044858f, 
    -0.06284645f, -0.00520304f, 0.05022174f, -0.01252945f, -0.07418110f, -0.03617181f, -0.04639312f, -0.00637879f, 
    -0.00019253f, 0.00827578f, -0.05876999f, 0.04203874f, 0.02336215f, 0.01028462f, 0.01585402f, -0.05606578f, 
    -0.00790062f, -0.05942490f, 0.01225574f, 0.03678158f, -0.06602392f, 0.03315010f, -0.02689647f, 0.04283237f, 
    0.01375242f, -0.00775200f, -0.01540132f, 0.01382669f, 0.03683865f, -0.02105859f, -0.04312860f, 0.00638005f, 
    -0.04299458f, 0.03743532f, 0.03999959f, 0.03642368f, 0.03632846f, -0.06418245f, 0.03302767f, -0.02778413f, 
    0.02988606f, 0.04068967f, 0.03506451f, -0.00701657f, -0.03704898f, -0.00173693f, -0.01389748f, -0.01713005f, 
    -0.03056845f, -0.04312414f, -0.06556624f, -0.04725974f, 0.04325148f, 0.01761847f, -0.00968260f, 0.01976871f, 
    -0.01879144f, 0.04796476f, 0.00570236f, -0.06754320f, -0.05184977f, 0.04034603f, -0.05124262f, -0.03459905f, 
    -0.06829538f, -0.06874165f, -0.06516092f, -0.06631370f, 0.04557867f, -0.05963030f, 0.02224657f, -0.02759208f, 
    -0.06157077f, -0.03555692f, 0.04198129f, 0.01809773f, -0.02614199f, 0.00478604f, -0.05844278f, 0.03717839f, 
    0.01050560f, -0.03344906f, 0.01141171f, 0.03419200f, -0.03140962f, -0.01481031f, 0.00347296f, 0.01426744f, 
    -0.06302700f, -0.02790183f, -0.03482382f, 0.04690429f, 0.03969102f, -0.00064222f, -0.02558284f, 0.02097416f, 
    -0.06618568f, 0.01960994f, -0.00583773f, -0.00575050f, -0.00258164f, -0.02226463f, -0.06259511f, -0.04930625f, 
    -0.01152633f, -0.00989005f, -0.04394140f, -0.07064090f, -0.04555721f, 0.00922220f, -0.04879909f, -0.05462271f, 
    -0.02561564f, -0.02404324f, -0.04094274f, 0.03185628f, 0.00701693f, -0.03815211f, -0.00448795f, -0.05068819f, 
    -0.05652955f, -0.01249439f, 0.01362030f, 0.02443800f, -0.06183571f, -0.00322415f, -0.04294857f, -0.05652037f, 
    -0.00150395f, -0.05249996f, 0.00280763f, 0.03916289f, -0.06168216f, -0.04891057f, 0.01008479f, -0.00543444f, 
    0.05162454f, 0.04071562f, 0.02833514f, -0.05459508f, 0.02238396f, -0.01812840f, -0.02183096f, -0.02588037f, 
    0.01205176f, 0.03655489f, 0.03804680f, -0.05768910f, -0.02209468f, -0.01128390f, -0.04677762f, 0.04042288f, 
    0.03202090f, -0.01873589f, 0.02959370f, -0.02438786f, -0.00462562f, -0.00058551f, -0.07303071f, -0.04663161f, 
    0.04530258f, -0.02679200f, 0.01599238f, -0.01064705f, 0.02570991f, -0.05418913f, -0.02245589f, 0.01928219f, 
    0.00010266f, -0.16105935f, -0.01032306f, -0.05763932f, 0.00092424f, -0.01668122f, -0.03827119f, 0.15439035f, 
    0.07617678f, 0.09673986f, 0.08918932f, 0.10888493f, 0.01964792f, -0.00046437f, 0.02037487f, -0.00890283f, 
    -0.13573779f, 0.02095454f, -0.08978742f, 0.15893276f, 0.05683243f, -0.08756392f, 0.01208799f, -0.06755817f, 
    -0.10120676f, -0.11868019f, -0.09104409f, -0.50291765f, -0.12141833f, 0.00582927f, 0.16636805f, -0.06658340f, 
    -0.12378659f, -0.05962386f, 0.18531001f, 0.03433200f, 0.09707542f, 0.01165532f, -0.17891505f, -0.04126058f, 
    -0.08986341f, -0.15020366f, 0.07821392f, -0.01767625f, 0.14781761f, -0.02352840f, -0.08627983f, 0.07164031f, 
    0.09402119f, -0.07757833f, 0.08171982f, 0.06327402f, 0.04911820f, -0.06498376f, -0.33197808f, -0.03824587f, 
    -0.21093169f, -0.08862864f, 0.02661821f, 0.11456884f, 0.00659734f, -0.09218314f, -0.03014599f, -0.11990017f, 
    -0.02069968f, 0.17158371f, 0.01233293f, 0.00052324f, -0.09899962f, 0.13892525f, -0.01314209f, -0.08758508f, 
    0.04435289f, -0.13115335f, 0.11791197f, 0.10576768f, 0.13135822f, -0.06445813f, -0.04676566f, 0.12285578f, 
    -0.04517024f, 0.13234018f, -0.03211690f, -0.30888054f, -0.01497607f, 0.03263525f, 0.16206682f, -0.04138050f, 
    -0.01611679f, 0.11437153f, -0.04310827f, -0.09981904f, 0.04862184f, 0.13079011f, 0.11750165f, -0.02614152f, 
    0.01441586f, -0.09718058f, 0.02236366f, 0.15071991f, -0.11598928f, -0.03013256f, 0.02254145f, 0.00330837f, 
    0.01453962f, 0.09717061f, 0.12715885f, 0.02196094f, 0.00216265f, -0.19687876f, -0.14548759f, -0.04206463f, 
    0.05501718f, 0.07276312f, 0.09726768f, -0.04497143f, 0.10524309f, -0.01413401f, 0.03504098f, -0.27897286f, 
    0.19024481f, -0.09860044f, 0.13174847f, -0.06078193f, 0.11131930f, -0.02494333f, -0.01249337f, -0.06956862f, 
    0.00817011f, 0.02610944f, 0.01861878f, -0.04850530f, 0.02279673f, 0.08116028f, 0.14495756f, -0.05885034f, 
    0.01792659f, 0.01837970f, -0.00387841f, 0.04530086f, -0.11492418f, 0.01933899f, 0.13206397f, 0.09894652f, 
    -0.34568363f, -0.12771162f, -0.01769567f, 0.12404489f, 0.07741207f, 0.06525158f, -0.01514101f, 0.01972464f, 
    -0.21745631f, 0.01315885f, 0.10029196f, 0.13411415f, -0.08826680f, -0.04507477f, 0.07693723f, -0.12720732f, 
    0.07870492f, -0.04267287f, -0.16059665f, -0.08621004f, 0.04132697f, 0.11419217f, -0.00714716f, 0.01998597f, 
    0.01265748f, 0.07664724f, 0.18013191f, -0.04012173f, -0.02541650f, 0.03904802f, -0.07242164f, 0.04484234f, 
    0.04321199f, 0.10859485f, -0.08679985f, 0.06078946f, 0.02874772f, 0.06809644f, 0.03451879f, -0.08094623f, 
    -0.17208558f, 0.09845555f, 0.06409911f, -0.16375171f, -0.02136154f, -0.04417463f, -0.04623001f, -0.07695522f, 
    0.04944683f, 0.21162011f, -0.00041112f, 0.08700312f, -0.12044363f, 0.05912448f, 0.21762776f, -0.04941490f, 
    -0.08149664f, -0.04513687f, -0.15285496f, -0.06918637f, 0.04739396f, 0.09962817f, 0.03970904f, 0.03931416f, 
    0.01776258f, -0.01614878f, 0.07837735f, 0.05380872f, -0.10675146f, 0.09530912f, -0.02038364f, 0.00901085f, 
    -0.14369951f, -0.11366710f, 0.03709557f, 0.04354232f, -0.04187897f, -0.01081476f, 0.05510541f, 0.12395025f, 
    -0.18250632f, -0.11252435f, 0.10626426f, 0.03596296f, -0.10686098f, 0.08260308f, 0.10872139f, 0.07485542f, 
    -0.05734813f, -0.07352389f, 0.17556615f, -0.07234287f, 0.08550931f, -0.03519870f, 0.00194648f, 0.10662735f, 
    -0.10851920f, 0.10323737f, -0.04457892f, -0.16025890f, -0.00864584f, -0.15487561f, 0.13454711f, 0.08971708f, 
    0.17636837f, 0.01216398f, 0.18283759f, -0.07099342f, 0.23301330f, -0.03035530f, 0.02274286f, 0.05947340f, 
    0.08779352f, -0.08488476f, 0.04450403f, 0.14810626f, -0.08853748f, 0.24216491f, -0.04219013f, 0.10208877f, 
    -0.19676775f, -0.00197692f, -0.12085048f, 0.14532109f, 0.08552825f, 0.02373704f, -0.15103373f, -0.02229095f, 
    -0.06325570f, 0.01963106f, 0.03367086f, 0.04139211f, 0.02692290f, -0.00502528f, 0.02206196f, -0.13965434f, 
    0.06031269f, -0.02379776f, -0.01051039f, -0.11122209f, -0.05462991f, 0.02860176f, -0.05647536f, 0.15186673f, 
    -0.24963512f, 0.11986527f, 0.21596326f, 0.03171028f, 0.04256814f, -0.01988032f, -0.03078582f, 0.00848184f, 
    -0.04460982f, 0.06022618f, 0.13214038f, -0.01383788f, 0.05718599f, -0.06326905f, 0.12325596f, 0.12546274f, 
    0.17099765f, -0.01902084f, -0.18107568f, 0.21156128f, 0.06414440f, 0.19315775f, -0.16508710f, 0.11513522f, 
    0.16339859f, -0.04597865f, -0.06444939f, 0.00257400f, -0.37799996f, -0.11275711f, 0.20655000f, -0.06035396f, 
    -0.06013327f, 0.02729753f, 0.11016113f, -0.14024588f, -0.03098706f, -0.19997236f, 0.16551974f, 0.20492674f, 
    -0.22399148f, 0.02343876f, 0.06077176f, -0.11433633f, 0.01795982f, 0.05353394f, -0.01042388f, 0.26772800f, 
    0.02123645f, -0.11729302f, -0.11366561f, 0.04925801f, 0.02627916f, 0.28059033f, 0.02821532f, -0.19877605f, 
    -0.20527191f, -0.00561245f, 0.13040717f, 0.07725316f, 0.07012482f, 0.16868851f, -0.00553408f, 0.08315047f, 
    -0.15751863f, 0.15774634f, 0.13158238f, -0.02092833f, -0.02990936f, 0.04403097f, 0.03355173f, 0.03154895f, 
    0.10109036f, 0.02790652f, -0.01911026f, -0.02665064f, -0.03799677f, 0.11794151f, 0.06885220f, -0.01569108f, 
    -0.11069293f, -0.10133943f, 0.21223889f, 0.13910961f, -0.12381519f, 0.17717469f, -0.15358557f, 0.18338482f, 
    0.04624709f, -0.10557050f, 0.24265650f, -0.06532992f, 0.02403665f, 0.08549529f, 0.05245068f, -0.05985454f, 
    0.07194456f, -0.06847806f, -0.17500839f, 0.03258997f, -0.07518639f, 0.12552911f, -0.09467225f, -0.08497837f, 
    0.02757617f, -0.02945511f, 0.04658240f, -0.04564403f, -0.27207831f, 0.17585711f, 0.36184591f, -0.04941853f, 
    0.09901779f, -0.02485600f, 0.10654373f, 0.07949551f, -0.04049287f, 0.10151269f, -0.11569351f, -0.07588230f, 
    0.01996115f, 0.07372823f, 0.18394622f, 0.03825615f, 0.00392809f, -0.07451958f, -0.14932173f, 0.14910917f, 
    0.05612456f, 0.06771718f, -0.02276427f, -0.02379300f, 0.03151841f, 0.05793969f, 0.08083217f, 0.02638442f, 
    -0.01102259f, -0.11230536f, 0.17159809f, 0.07307597f, -0.15002757f, -0.11056636f, -0.04585132f, 0.02060980f, 
    -0.11435758f, -0.23562364f, -0.01827390f, 0.03694869f, 0.16098733f, 0.23391855f, 0.01796634f, -0.12413175f, 
    -0.24808519f, 0.12736352f, 0.04126345f, -0.07193632f, -0.04601418f, 0.02253416f, 0.08752953f, 0.09574434f, 
    -0.00124284f, 0.25029427f, 0.02371635f, -0.29328537f, -0.11346817f, 0.08620700f, 0.15811524f, 0.00474403f, 
    0.02723802f, -0.10048336f, -0.01684954f, -0.04721828f, -0.25094762f, -0.03990699f, 0.00045134f, 0.03819314f, 
    0.03259585f, -0.00811784f, -0.11800135f, -0.05461173f, 0.09471561f, -0.00057899f, 0.16096476f, 0.12096143f, 
    -0.10330142f, -0.03521137f, 0.13075690f, -0.02354101f, -0.13698187f, 0.23708582f, -0.36727861f, -0.03871493f, 
    -0.04281452f, 0.02881005f, 0.08767206f, 0.04070756f, 0.06280132f, -0.10271164f, -0.04180974f, 0.01895173f, 
    0.14073864f, -0.13055614f, 0.01671648f, 0.02461574f, 0.00125439f, -0.14166932f, 0.09144222f, -0.02078526f, 
    -0.08223979f, 0.08844659f, -0.02307913f, -0.05467650f, -0.00983696f, -0.17500791f, -0.11349311f, -0.02246433f, 
    0.09375797f, 0.04605876f, -0.06506908f, 0.04532968f, -0.05985618f, -0.04626808f, -0.06941296f, 0.16627385f, 
    -0.02529305f, -0.09413648f, 0.11011751f, 0.13061681f, 0.13427240f, -0.25151733f, 0.02443569f, -0.09529751f, 
    0.06402665f, 0.03778184f, 0.37480187f, 0.06551228f, -0.01850724f, -0.17781626f, -0.07168355f, -0.08447245f, 
    0.14718507f, 0.07851693f, 0.09529261f, -0.45082250f, 0.02822527f, 0.10098615f, 0.13874140f, 0.05699280f, 
    0.21906930f, 0.11148245f, -0.03599224f, -0.15709484f, -0.02644210f, -0.04252557f, 0.24040288f, 0.10291671f, 
    0.25252119f, -0.29313692f, 0.26917344f, 0.01367126f, 0.16494627f, -0.12253409f, -0.00308442f, 0.17574762f, 
    0.05154884f, -0.01575431f, -0.20361213f, 0.06377260f, 0.07039052f, 0.11249511f, -0.25392982f, 0.10324508f, 
    0.14130530f, 0.05723983f, -0.06214358f, -0.18826975f, 0.00237335f, -0.07663256f, 0.07099876f, 0.13586096f, 
    0.01227808f, -0.01180124f, 0.10015744f, -0.17126024f, -0.00952502f, 0.00767414f, -0.03509374f, 0.08530766f, 
    0.05653176f, 0.10116278f, -0.13547391f, -0.10515180f, -0.05312577f, -0.10229035f, 0.10263678f, -0.13299352f, 
    0.01812801f, -0.07193173f, 0.07349393f, 0.03424589f, -0.04051002f, 0.16222085f, -0.06458557f, 0.07219622f, 
    -0.09143812f, 0.08854403f, -0.26632565f, -0.17030616f, 0.00880765f, -0.15216863f, -0.26116228f, 0.25625154f, 
    -0.01818285f, 0.09505507f, -0.15915120f, 0.13437690f, 0.00134127f, 0.26263231f, 0.01234959f, -0.06806337f, 
    -0.00308398f, 0.28552374f, 0.00141748f, -0.23769532f, 0.14073844f, -0.19765089f, -0.26003051f, -0.09602202f, 
    0.13868722f, -0.15439124f, 0.15278584f, 0.03115936f, 0.10528928f, -0.01421173f, 0.19660333f, 0.09725627f, 
    0.16831918f, 0.06867134f, -0.03036007f, 0.00385910f, 0.07960591f, 0.11687895f, 0.19954208f, 0.02995920f, 
    -0.26399174f, -0.01383522f, 0.16632436f, 0.05044626f, -0.07696424f, -0.28578749f, 0.09328467f, -0.14015806f, 
    -0.18259314f, 0.13746446f, 0.11723202f, -0.01671768f, 0.12416210f, 0.00736942f, -0.00558892f, 0.03070674f, 
    -0.14059806f, -0.02374760f, -0.20925699f, -0.03243174f, 0.13669477f, -0.03169214f, 0.16768058f, -0.05475720f, 
    -0.09684988f, 0.00860221f, -0.18608847f, -0.14249825f, -0.07555203f, 0.15016517f, 0.14499292f, -0.08639870f, 
    0.03611046f, -0.03171581f, 0.08544790f, -0.07295889f, 0.24371497f, -0.00231808f, -0.00179857f, -0.05672270f, 
    -0.06956118f, 0.09113832f, -0.05778909f, -0.11801225f, -0.20807494f, 0.12793161f, -0.22742207f, 0.00951267f, 
    0.09991830f, 0.20684431f, 0.04101197f, 0.02020393f, -0.00486512f, 0.03294598f, -0.47288117f, 0.09171280f, 
    0.03935114f, -0.01062413f, -0.03165774f, 0.10573243f, 0.08256167f, -0.20177929f, 0.13369709f, -0.25494993f, 
    0.12715727f, 0.14354323f, -0.05834961f, 0.03649540f, -0.21828909f, -0.15279275f, 0.05563502f, 0.05745905f, 
    -0.08890376f, 0.12020465f, 0.12579805f, 0.07464377f, 0.02083189f, -0.02433931f, 0.05581991f, -0.03359699f, 
    -0.03418802f, 0.14183171f, -0.13033560f, -0.01259705f, -0.03455045f, 0.01498347f, 0.03290831f, 0.05284599f, 
    0.08342564f, 0.05003285f, -0.39477482f, 0.00241207f, -0.06997298f, 0.09689851f, -0.09582467f, -0.18377706f, 
    0.08378841f, -0.09625535f, 0.19899648f, 0.13889708f, 0.11196216f, -0.05338399f, 0.01556560f, 0.06445014f, 
    0.18736079f, -0.16971885f, 0.20578827f, 0.07703499f, -0.12890577f, -0.12774362f, -0.05450173f, 0.04417780f, 
    -0.03126511f, -0.09786012f, -0.20678794f, 0.15336539f, 0.01600807f, -0.15282439f, 0.00721436f, 0.08690921f, 
    0.02354522f, 0.05060265f, 0.13855973f, -0.11786879f, 0.10195033f, -0.25527480f, -0.04823079f, -0.03944817f, 
    -0.13651714f, -0.05075563f, 0.07014724f, -0.04037774f, 0.08051845f, -0.16968404f, 0.03710230f, -0.23084179f, 
    -0.00062222f, -0.00413318f, 0.10415042f, 0.05511449f, -0.09948980f, 0.11612306f, 0.10922843f, -0.20254086f, 
    -0.15783378f, -0.11752721f, 0.15381910f, 0.05966815f, 0.21584718f, 0.10196967f, -0.05594563f, 0.04103762f, 
    -0.25087857f, 0.05403275f, 0.04099224f, 0.13553226f, 0.09921480f, 0.01946067f, 0.11695488f, 0.16934477f, 
    0.16304319f, 0.01085688f, 0.11661243f, 0.02920543f, 0.11951867f, 0.07499137f, -0.07111430f, -0.16060103f, 
    0.10426569f, 0.14626819f, 0.07501648f, -0.26077390f, -0.12331171f, -0.04169035f, -0.15362419f, -0.06614893f, 
    0.04139989f, 0.11019550f, -0.04303216f, 0.05038260f, 0.27727893f, -0.16725004f, -0.16422561f, -0.02754327f, 
    0.01325413f, 0.14721382f, 0.19750203f, -0.12361617f, 0.11164755f, -0.11489800f, 0.09708606f, 0.05342150f, 
    0.14160927f, 0.04141792f, -0.11739252f, -0.09341087f, 0.15410018f, -0.11724975f, -0.07280019f, 0.05076779f, 
    -0.13011158f, -0.08949218f, -0.04400784f, 0.08380789f, -0.05639698f, 0.13938133f, 0.07857221f, 0.20358065f, 
    0.00611902f, 0.14458787f, 0.09606861f, -0.10135476f, 0.09494518f, 0.08083344f, 0.01174974f, 0.15621170f, 
    -0.11225379f, -0.00548284f, -0.08247892f, 0.15530509f, -0.07900947f, 0.02938865f, 0.00052592f, -0.11750883f, 
    -0.21598896f, -0.10752888f, -0.14274359f, -0.05233485f, -0.18952332f, -0.07040428f, 0.07223621f, -0.03076762f, 
    -0.04017754f, 0.05254459f, 0.04095775f, -0.05414835f, -0.04769137f, -0.03501647f, -0.04281516f, -0.05289775f, 
    -0.05285236f, -0.06639214f, -0.04513566f, 0.04856538f, -0.00287885f, -0.06425609f, 0.05302468f, 0.01918193f, 
    0.00662318f, -0.05615734f, 0.01583240f, -0.02291642f, 0.02069658f, 0.01199237f, -0.05218067f, -0.00531401f, 
    -0.00461630f, -0.05442291f, -0.04546815f, -0.00552259f, -0.05130796f, -0.04155258f, -0.03484238f, -0.03999117f, 
    -0.00384132f, 0.03115361f, -0.00060105f, -0.04039416f, -0.00716288f, 0.01376239f, 0.01358862f, 0.03255552f, 
    0.02684148f, 0.00700001f, -0.00566206f, 0.02161859f, -0.05740163f, 0.02393777f, 0.00038708f, 0.02200117f, 
    -0.00535270f, 0.03559878f, -0.04029062f, 0.00551448f, 0.04365115f, 0.01826738f, 0.02729282f, 0.00628362f, 
    -0.01582170f, 0.03491437f, 0.03543402f, -0.02277548f, 0.02199300f, -0.04646913f, 0.03465649f, -0.02206475f, 
    -0.02381883f, 0.04777665f, 0.04002051f, 0.00155501f, -0.01950121f, 0.04311046f, -0.01860589f, -0.06323712f, 
    -0.02080962f, -0.05090436f, -0.03414859f, -0.00839277f, 0.04807715f, -0.01213191f, -0.04198974f, -0.03127376f, 
    -0.02263521f, 0.04376758f, -0.04538795f, 0.05490918f, 0.05096009f, 0.03246076f, -0.01851029f, -0.02534139f, 
    0.03469173f, 0.00352765f, -0.04183140f, -0.01640406f, 0.00284983f, -0.03639526f, -0.04988479f, -0.00894453f, 
    -0.01106553f, 0.00974071f, -0.03538050f, 0.03779335f, 0.00452431f, -0.00713798f, -0.05105026f, -0.00133123f, 
    -0.00190797f, -0.03937254f, -0.02602800f, -0.04298260f, 0.00738350f, -0.00385532f, -0.03617189f, -0.04947333f, 
    0.05104525f, -0.00588527f, -0.02676237f, -0.00629389f, -0.02512842f, 0.01062817f, 0.04365225f, -0.04481588f, 
    -0.01766252f, -0.03855446f, -0.00665897f, -0.01449615f, -0.02971158f, 0.03285806f, 0.02661344f, 0.04808885f, 
    -0.04067231f, -0.02894053f, 0.02074307f, -0.00990258f, -0.03806255f, -0.01300687f, 0.00477219f, -0.00707761f, 
    0.01469486f, 0.03700696f, 0.00942707f, -0.05531934f, 0.00066670f, -0.01138534f, -0.03539865f, 0.04888696f, 
    0.04600876f, 0.02687205f, 0.06121602f, -0.04187756f, 0.02801988f, -0.02980636f, 0.00666398f, -0.02215299f, 
    -0.05544694f, 0.00548518f, 0.05538939f, -0.00632544f, -0.06554341f, 0.02449827f, -0.05082571f, -0.01872770f, 
    -0.01880638f, 0.01097856f, 0.03338295f, 0.03008556f, 0.03387542f, -0.03784353f, 0.01558286f, 0.00068769f, 
    -0.04874893f, 0.02278256f, -0.04990887f, 0.00366794f, -0.01727691f, -0.04479862f, 0.02268067f, 0.00375526f, 
    0.03445553f, -0.00964048f, 0.00062181f, 0.02602471f, -0.00095688f, 0.01728153f, 0.00741885f, -0.06271876f, 
    0.03418244f, 0.03628413f, -0.03358840f, 0.03582025f, -0.00467513f, 0.04420466f, -0.02824242f, 0.03006749f, 
    -0.01692836f, 0.03171604f, 0.00059705f, -0.06483547f, -0.04497122f, 0.02800412f, 0.02231526f, 0.03686665f, 
    -0.02649886f, -0.05552306f, -0.05718389f, 0.04008572f, -0.02761443f, 0.02205603f, 0.03183211f, -0.02200814f, 
    -0.02832803f, -0.05758880f, -0.05864750f, -0.06728859f, -0.01092586f, 0.04796562f, -0.01376182f, -0.00628645f, 
    0.04193228f, 0.03649307f, -0.06258457f, 0.04628187f, 0.02155796f, 0.04403960f, -0.01440441f, -0.03562772f, 
    0.02877266f, -0.05558119f, -0.02108756f, 0.00320743f, 0.00091502f, -0.05535765f, -0.05155111f, 0.00467713f, 
    -0.01610426f, -0.00086880f, -0.03053880f, -0.02748177f, -0.00654155f, -0.04392349f, -0.03423528f, 0.00990082f, 
    -0.06212961f, -0.03128064f, -0.05004711f, -0.04406897f, -0.03000354f, 0.03266870f, 0.01026026f, -0.02668926f, 
    0.00291611f, -0.00967028f, 0.02090122f, -0.05814025f, -0.00044070f, 0.05455326f, -0.04573194f, 0.02739151f, 
    -0.02919420f, -0.05629973f, -0.03409693f, -0.02214794f, 0.02422685f, -0.05256083f, -0.01806569f, 0.03164396f, 
    0.04793218f, -0.01587928f, 0.01973120f, -0.00984222f, 0.00900334f, -0.06231248f, -0.03891340f, -0.04941321f, 
    -0.03328381f, -0.00797854f, 0.02479464f, 0.04020124f, 0.03918494f, 0.02166170f, 0.03283542f, -0.00203555f, 
    0.05154613f, -0.04073813f, -0.02049925f, -0.03697727f, 0.02882404f, -0.05893753f, -0.00442391f, -0.02868770f, 
    -0.02036044f, 0.04229204f, 0.00104704f, 0.00960212f, -0.00033129f, -0.05024876f, -0.04655245f, -0.03009605f, 
    -0.01671188f, -0.03801032f, 0.00745400f, -0.05950112f, 0.03645438f, -0.00191244f, 0.00905825f, -0.03187074f, 
    0.04935576f, -0.04039467f, 0.01098160f, 0.04394984f, -0.02934732f, -0.01528693f, 0.03922923f, -0.05839659f, 
    -0.03029297f, -0.01170368f, -0.04119365f, -0.06176491f, 0.00792632f, -0.04096356f, -0.06167353f, -0.05079379f, 
    0.04735043f, 0.02888948f, -0.00024771f, 0.01446703f, -0.01172918f, 0.04291036f, 0.00072758f, 0.01471813f, 
    -0.00514793f, 0.00842546f, 0.01878561f, -0.01641239f, 0.04672445f, 0.02801308f, -0.00869826f, -0.00302212f, 
    -0.00515465f, -0.03491324f, 0.02608046f, 0.01262162f, -0.02622522f, -0.03936242f, 0.04545819f, -0.04920106f, 
    -0.04181214f, -0.01161425f, 0.03002011f, -0.01801223f, -0.03178320f, 0.00007486f, -0.06233587f, -0.04162127f, 
    -0.02709706f, -0.05886195f, 0.02621694f, 0.02227895f, 0.03281047f, 0.04744298f, -0.04328221f, -0.00676375f, 
    0.02258006f, -0.02031970f, -0.06174345f, 0.00647864f, -0.02290392f, 0.03001734f, -0.04566667f, 0.01401728f, 
    0.05332843f, 0.02406116f, -0.04203271f, -0.04781656f, -0.04087919f, 0.04580155f, -0.00496945f, -0.03714056f, 
    -0.05371451f, -0.05688814f, 0.00822573f, -0.05408350f, 0.03714569f, 0.03111585f, 0.02266822f, 0.00687451f, 
    0.00009936f, -0.04480768f, -0.04930236f, 0.04759056f, -0.06187592f, 0.05203883f, 0.02957059f, -0.05918885f, 
    -0.00390250f, -0.03627995f, 0.04339802f, -0.04771633f, -0.05617159f, -0.05380025f, 0.00774885f, -0.03191305f, 
    0.05360282f, -0.05737595f, 0.01164577f, -0.03197781f, -0.04509464f, 0.04091960f, -0.01226028f, -0.00930437f, 
    -0.05115585f, 0.00960257f, 0.00659271f, 0.05266887f, -0.03668915f, 0.00536273f, 0.02144760f, 0.02989659f, 
    -0.00273602f, -0.02744486f, -0.00572583f, 0.01505567f, -0.02870090f, 0.02524281f, 0.00344897f, 0.03088659f, 
    -0.03252319f, 0.04960443f, -0.01964058f, -0.03476445f, 0.01929781f, 0.03605518f, -0.03635733f, -0.00893608f, 
    -0.01635172f, -0.00190403f, 0.00377880f, -0.05412385f, -0.00377760f, -0.02258626f, -0.01265393f, 0.04401345f, 
    0.02361118f, 0.02765857f, -0.02345102f, -0.06033738f, -0.03580265f, -0.05540304f, 0.03747572f, 0.05394812f, 
    -0.02658779f, 0.00573742f, -0.02066153f, 0.03540769f, -0.03556916f, 0.01580004f, 0.01994106f, -0.02527547f, 
    0.02953182f, -0.04423275f, -0.02075807f, -0.03321752f, 0.01085464f, 0.02546691f, 0.02111119f, 0.01246197f, 
    0.00431258f, 0.01840987f, -0.01043216f, -0.04284816f, -0.03550148f, -0.06108942f, 0.00649366f, -0.00539408f, 
    0.02850963f, -0.03837717f, -0.05392807f, 0.01509274f, -0.05145226f, -0.02782884f, -0.02585756f, 0.00964405f, 
    -0.04286443f, 0.01693977f, -0.00463961f, 0.05024099f, -0.05583685f, -0.00349502f, -0.06082559f, 0.01227568f, 
    -0.03379479f, -0.04246408f, 0.00486950f, 0.05456845f, -0.03345810f, -0.02569464f, 0.04077039f, 0.01740293f, 
    -0.04133566f, -0.01565374f, 0.05452125f, -0.00789460f, -0.03315024f, -0.01469887f, 0.04977343f, 0.04252327f, 
    0.04581695f, -0.04446750f, -0.00850980f, 0.01000171f, 0.02062130f, -0.01191279f, 0.04455513f, -0.00249771f, 
    -0.03763561f, -0.03928052f, -0.02964088f, -0.05299451f, -0.01116543f, -0.01862504f, 0.04922832f, 0.03284418f, 
    0.02899752f, -0.05847543f, -0.03806824f, -0.03768337f, 0.03431111f, -0.01321307f, -0.03935799f, -0.05595151f, 
    0.04950507f, 0.01007661f, 0.00741654f, 0.00396629f, -0.00041705f, 0.01641815f, 0.01944084f, -0.00145474f, 
    0.03338808f, -0.04568559f, -0.05818196f, 0.02305483f, -0.01206900f, 0.04604912f, -0.06365966f, -0.05100704f, 
    -0.03823221f, 0.03009974f, -0.03155596f, -0.03341238f, 0.00220786f, 0.05106729f, 0.03270301f, 0.00094928f, 
    -0.02284431f, 0.00352099f, -0.06204709f, -0.03964332f, 0.02500702f, 0.05847519f, -0.06117841f, -0.01244342f, 
    -0.05934626f, 0.04600993f, 0.04358976f, -0.01804208f, 0.04900272f, 0.04394803f, -0.04519947f, 0.02088371f, 
    0.01464184f, -0.03042265f, 0.03047104f, -0.03129321f, -0.04451038f, 0.05250347f, 0.02963674f, 0.03479787f, 
    -0.28326008f, -0.53650874f, 0.03139138f, 0.08294510f, -0.06617780f, 0.03257678f, 0.08561418f, -0.03574234f, 
    0.11159863f, 0.00681867f, 0.09852248f, 0.11160108f, 0.05044471f, -0.12760690f, 0.02693788f, 0.05062344f, 
    -0.02600915f, -0.03083345f, -0.30261150f, 0.15711986f, 0.22752485f, 0.15682387f, 0.10845341f, 0.03581177f, 
    -0.11984070f, 0.03410114f, 0.00694384f, -0.06173169f, 0.09290282f, -0.43429634f, -0.04502917f, -0.04940272f, 
    -0.08397323f, 0.05298891f, 0.00774804f, -0.02416404f, -0.12380293f, 0.27877289f, 0.17079596f, -0.19436802f, 
    -0.17224108f, 0.02129428f, -0.10613895f, 0.00673318f, 0.05994122f, 0.26194060f, 0.09489866f, 0.02720439f, 
    0.11431171f, -0.12146924f, 0.11433446f, 0.02550476f, 0.01937586f, -0.03606877f, -0.13774383f, -0.09661639f, 
    -0.06813962f, 0.07915237f, 0.00791509f, 0.00097753f, -0.01586964f, 0.21888977f, -0.11983743f, 0.19185759f, 
    0.08078616f, -0.10019334f, -0.01994727f, -0.02069475f, -0.04501653f, 0.10039341f, 0.18563509f, -0.00247589f, 
    0.18217148f, -0.17845540f, 0.03833520f, 0.00344337f, 0.00017798f, 0.00501136f, 0.09831078f, -0.08371972f, 
    -0.13041310f, -0.10209198f, -0.47706357f, 0.06669859f, 0.09710739f, 0.18808679f, 0.10019208f, -0.08876376f, 
    -0.08344758f, 0.01734276f, 0.25031647f, 0.07704581f, -0.13974519f, 0.02825525f, -0.18393221f, 0.03041558f, 
    -0.02914386f, 0.21689449f, 0.08037829f, 0.02673040f, 0.07649892f, -0.22336285f, -0.09405269f, -0.06983159f, 
    -0.05293970f, 0.02511418f, -0.02769038f, -0.04906612f, -0.34189004f, -0.73055196f, 0.05470241f, 0.02287722f, 
    0.02302637f, 0.10618195f, -0.13096593f, -0.04037855f, 0.02370025f, -0.12488189f, -0.04887197f, 0.04470355f, 
    0.03906904f, -0.22886823f, 0.06894547f, 0.07301770f, -0.02991281f, 0.03516859f, -0.10112611f, -0.56680441f, 
    -0.11536925f, 0.00458367f, -0.02312054f, 0.02825408f, -0.02488594f, -0.03223594f, -0.00959732f, 0.03159429f, 
    0.17556751f, 0.01636214f, 0.01448209f, -0.02170238f, -0.00984591f, -0.00588480f, 0.12693465f, 0.01434986f, 
    -0.22402097f, -0.10196427f, 0.15059973f, 0.10487588f, -0.02433006f, -0.14084660f, -0.06799504f, -0.04308818f, 
    0.08665542f, 0.24673489f, 0.08055647f, -0.10990006f, -0.00586029f, 0.11891856f, -0.04372239f, 0.02461110f, 
    0.07506629f, -0.10727596f, 0.18009712f, 0.13522184f, -0.00431503f, 0.07114492f, 0.04360663f, -0.01089377f, 
    -0.02109395f, 0.06454007f, 0.14170082f, 0.02600970f, 0.01715877f, 0.01268046f, 0.10429116f, 0.14855312f, 
    -0.02976334f, 0.00468538f, 0.11187322f, -0.06729256f, 0.14347762f, 0.13905460f, 0.04060901f, 0.08591784f, 
    -0.07304937f, -0.00322322f, 0.13345119f, 0.08476382f, 0.04471860f, -0.15577805f, 0.13399932f, 0.00597897f, 
    -0.07046613f, 0.02628168f, -0.03841827f, -0.08224378f, 0.02477608f, 0.10988211f, 0.15749031f, 0.04597580f, 
    -0.21794304f, -0.06992184f, -0.00892307f, -0.03711998f, 0.05169840f, -0.04141896f, -0.03662912f, 0.12668075f, 
    0.15280664f, -0.05189972f, 0.00711576f, -0.05675337f, 0.13690864f, -0.15827104f, -0.02230265f, 0.03663773f, 
    -0.12634303f, -0.15904365f, -0.06794941f, 0.07542893f, 0.04079883f, 0.02178494f, -0.03805693f, -0.00836971f, 
    0.06552211f, -0.00219380f, 0.16900888f, 0.05218331f, 0.13121553f, 0.14981529f, -0.04116738f, -0.05931599f, 
    -0.12998170f, -0.01426509f, 0.46447459f, -0.08572213f, 0.16376832f, 0.08026576f, -0.03086735f, 0.02429932f, 
    -0.08297823f, -0.15091234f, 0.08156466f, -0.37497488f, -0.19033882f, -0.11144808f, -0.04809136f, -0.09984675f, 
    0.07380169f, -0.09441195f, 0.03655889f, 0.01929020f, -0.00733961f, 0.00775727f, 0.05967449f, 0.18736860f, 
    -0.01766792f, 0.01586076f, -0.04821658f, -0.04910218f, -0.05475816f, 0.21489243f, -0.01939210f, -0.06223223f, 
    0.10244714f, 0.03941910f, 0.10167895f, -0.08744328f, -0.09627658f, -0.06051178f, -0.08358266f, -0.40132642f, 
    -0.05131181f, -0.11673978f, 0.09255334f, 0.17139930f, 0.04688786f, -0.01742441f, -0.16344710f, -0.02485467f, 
    0.17403200f, 0.15921283f, 0.02418125f, -0.03726300f, -0.16718981f, 0.02414157f, 0.08865694f, 0.04699512f, 
    -0.06256519f, 0.05136109f, -0.12699097f, 0.09695457f, 0.11094278f, -0.05987006f, 0.01846101f, -0.03981626f, 
    -0.15407658f, 0.20343964f, 0.21072131f, 0.05352265f, -0.16143510f, -0.05574576f, 0.07896706f, -0.00573958f, 
    -0.21365091f, 0.05234259f, -0.00815411f, 0.00385767f, 0.02104992f, 0.00992494f, 0.04436762f, -0.06395245f, 
    0.03750966f, -0.02271231f, 0.15114121f, -0.01186306f, -0.04212948f, 0.11554436f, -0.06068578f, -0.15500733f, 
    0.09814792f, -0.24252433f, 0.11458859f, -0.01433972f, -0.32556883f, 0.14659458f, -0.00181433f, 0.10736907f, 
    -0.01790868f, -0.14931461f, 0.09657978f, -0.05068711f, 0.12262680f, -0.07229598f, 0.14796418f, -0.05549426f, 
    0.10180764f, 0.14704414f, -0.06286406f, 0.01023546f, -0.00291181f, 0.18329929f, 0.21733046f, -0.27314511f, 
    -0.15694550f, -0.07882160f, 0.09199999f, 0.24057983f, -0.04078536f, -0.00922374f, -0.08701573f, 0.08020924f, 
    0.06711716f, 0.14489357f, -0.05151237f, -0.01745822f, -0.07629268f, -0.14619146f, -0.04076311f, -0.19483986f, 
    0.10337181f, -0.21402894f, 0.05303356f, -0.01302253f, -0.19670637f, 0.08560723f, -0.04366472f, 0.05083197f, 
    -0.16321003f, 0.14026113f, 0.13069057f, -0.16119657f, 0.00844688f, 0.10516910f, -0.08782683f, -0.12420993f, 
    -0.10754596f, -0.21361966f, 0.02620919f, -0.10232066f, 0.15388095f, -0.00696254f, -0.05027375f, 0.15497839f, 
    0.10292500f, -0.20473237f, -0.00712944f, 0.00532051f, 0.12223904f, 0.18268116f, -0.17989618f, 0.12126479f, 
    -0.02887780f, 0.01858494f, 0.12374698f, 0.01787303f, 0.04489599f, -0.00276143f, -0.14871897f, 0.09046584f, 
    0.02592920f, 0.00093396f, 0.04805071f, -0.01742298f, -0.08710112f, 0.03351650f, -0.24739474f, -0.00764586f, 
    0.04466877f, -0.06692864f, 0.15063025f, 0.05297928f, 0.02279922f, -0.01994788f, 0.26248375f, -0.07774035f, 
    -0.10335988f, 0.00772513f, 0.04349547f, -0.02775723f, -0.09746602f, 0.08240893f, -0.05115121f, -0.21080135f, 
    0.11018413f, 0.14826180f, 0.00611275f, -0.09041692f, 0.03422061f, -0.06723434f, 0.07906663f, 0.10357365f, 
    0.06182241f, -0.26054755f, -0.05003288f, 0.07911470f, 0.05560600f, 0.09301276f, 0.02054996f, -0.15779585f, 
    -0.23856686f, 0.16294533f, 0.05776157f, -0.08657750f, -0.15764996f, -0.05676104f, 0.09856153f, -0.05414612f, 
    -0.03031294f, 0.11415067f, -0.03001916f, -0.13946323f, 0.31782025f, -0.00693663f, 0.00222156f, 0.07439201f, 
    -0.14093687f, -0.12784734f, 0.04848706f, -0.18638274f, -0.22164454f, 0.25114128f, 0.02631650f, 0.08643240f, 
    0.11833742f, 0.06003232f, 0.15912138f, 0.10013265f, -0.02128457f, 0.06368933f, -0.08725370f, -0.01363783f, 
    -0.02198003f, 0.11388405f, 0.13151190f, -0.01744368f, 0.07344425f, 0.04402763f, 0.04191229f, -0.07848649f, 
    -0.14327914f, 0.02163231f, 0.23981369f, -0.02372865f, -0.06424184f, -0.03852360f, -0.09886084f, 0.18332893f, 
    0.13538522f, -0.14330558f, -0.03442066f, 0.10896976f, 0.00952239f, 0.08825751f, -0.10413647f, -0.03772182f, 
    -0.08979428f, 0.13402537f, 0.07678861f, -0.14437370f, 0.11427107f, -0.01326443f, 0.05127660f, 0.05856203f, 
    0.18711443f, -0.05709675f, -0.29186258f, 0.00800770f, 0.02189419f, 0.04117430f, -0.03403965f, 0.17824967f, 
    -0.12649809f, -0.09840696f, 0.29354325f, -0.09994876f, 0.08080224f, 0.03145562f, -0.13708931f, 0.08957785f, 
    -0.11660126f, 0.11564311f, 0.00501900f, -0.09795279f, -0.19364953f, -0.15009665f, 0.09595551f, 0.10104475f, 
    0.11549541f, -0.03273646f, 0.00496063f, -0.03949725f, -0.17156626f, 0.04767393f, 0.05905654f, 0.10396967f, 
    0.08988367f, -0.06037241f, 0.15503085f, -0.20364138f, 0.04813983f, 0.16855794f, -0.12313323f, 0.09392072f, 
    -0.07114494f, 0.08799902f, 0.00912270f, 0.15414219f, 0.11206499f, 0.11103108f, 0.20414135f, -0.32133207f, 
    0.15256555f, 0.07019659f, -0.11393386f, 0.03283921f, 0.06111783f, 0.15372467f, 0.18664759f, -0.02024605f, 
    0.15562528f, -0.03734239f, 0.01708488f, -0.11413918f, -0.03729400f, -0.10196204f, -0.04101250f, -0.27752686f, 
    0.12795559f, 0.24497214f, -0.24264929f, -0.14705725f, -0.02847040f, 0.02354082f, 0.05167788f, -0.10136624f, 
    -0.03235378f, 0.01110194f, 0.03899804f, 0.02845294f, 0.00071877f, -0.01195664f, -0.05062553f, 0.02783975f, 
    -0.01644182f, 0.00860157f, -0.00840264f, -0.02350357f, -0.03272628f, 0.01952647f, -0.05976431f, -0.06067009f, 
    -0.05487400f, 0.01584119f, 0.02442153f, -0.06473657f, 0.02424557f, -0.03535070f, 0.03712812f, -0.03498705f, 
    -0.03642522f, 0.01599127f, 0.03110613f, 0.01056796f, 0.03862650f, -0.04939898f, 0.04876487f, -0.01858358f, 
    -0.05141011f, 0.02747394f, 0.00110228f, -0.03288217f, 0.00183408f, -0.06201297f, -0.01310137f, 0.00828941f, 
    0.00267287f, 0.04328799f, -0.00029223f, -0.06308383f, 0.00263769f, -0.05769138f, -0.06514660f, -0.03923419f, 
    0.03048835f, -0.00244941f, -0.01323535f, -0.06524000f, -0.03362959f, -0.05101429f, 0.04907317f, 0.00856784f, 
    0.04574837f, 0.02112083f, 0.00432414f, -0.04144965f, 0.01571096f, 0.02583593f, 0.04192061f, -0.02944193f, 
    -0.01078296f, 0.00192187f, 0.01578898f, -0.03218078f, -0.06368619f, 0.02919813f, -0.02121254f, -0.01211839f, 
    0.00278773f, -0.00458196f, 0.00246536f, -0.03494366f, 0.03787737f, 0.04912895f, -0.00490373f, -0.03750204f, 
    0.00070154f, -0.03386885f, -0.05479229f, -0.06378687f, 0.03559079f, -0.06260353f, -0.00440040f, -0.02805023f, 
    0.03600244f, -0.03388511f, -0.05659162f, 0.03004340f, -0.05500581f, -0.01007547f, 0.04388052f, 0.02547512f, 
    -0.05342394f, 0.05621871f, -0.00157760f, 0.00770380f, -0.03122071f, 0.05166460f, 0.02758967f, -0.01206848f, 
    -0.03536288f, 0.02862922f, -0.02894982f, -0.04368976f, 0.03917542f, -0.03646009f, -0.00836490f, 0.03754575f, 
    0.01568089f, 0.04650196f, 0.02381246f, -0.01266405f, 0.01763494f, -0.04340836f, 0.00008655f, 0.02586901f, 
    0.00928857f, 0.00072877f, 0.01387923f, -0.01723920f, 0.04098539f, -0.01207906f, -0.03505344f, -0.02326304f, 
    0.02434144f, -0.02481262f, -0.04623120f, -0.04250730f, -0.00121208f, -0.00180585f, -0.05678051f, -0.05805913f, 
    0.00321398f, -0.04447258f, -0.04509801f, -0.06874823f, -0.01458503f, -0.01329216f, -0.00573704f, 0.02646834f, 
    -0.05581762f, 0.00381565f, -0.06622843f, 0.00537516f, 0.03725241f, -0.02572769f, -0.05486367f, -0.06014234f, 
    -0.01866184f, 0.02472493f, -0.00400225f, -0.00365755f, -0.06028650f, -0.04980084f, 0.00352280f, 0.03095588f, 
    -0.02644063f, -0.01065048f, 0.02548625f, 0.00100974f, -0.05070091f, 0.04199009f, -0.02194013f, 0.02612315f, 
    0.03386620f, -0.03344624f, 0.00306985f, 0.02678970f, 0.02917963f, 0.04690253f, 0.00712648f, 0.04344733f, 
    -0.01221856f, 0.02965313f, -0.00952180f, -0.01193732f, 0.03096467f, -0.03750007f, -0.01686504f, -0.06716938f, 
    -0.03471111f, 0.03383147f, -0.00718705f, -0.00566948f, -0.04008042f, -0.00696820f, -0.00468356f, -0.03492398f, 
    -0.04988603f, -0.06141387f, -0.06224762f, -0.01271134f, -0.03938284f, -0.02855847f, -0.03513668f, -0.04482638f, 
    -0.05615749f, 0.00588022f, -0.00558094f, -0.01899227f, -0.05178838f, 0.04066436f, 0.04683428f, 0.03773316f, 
    0.04277017f, 0.01475406f, -0.06783804f, 0.04899888f, 0.02241200f, 0.03086468f, -0.00005588f, -0.00242192f, 
    0.04839770f, -0.00758869f, -0.04165388f, -0.04521781f, -0.06280555f, 0.03611064f, -0.02769359f, -0.00664603f, 
    -0.03192789f, -0.05100999f, -0.04770402f, -0.04020780f, -0.03009816f, 0.01514721f, 0.00263957f, -0.01514628f, 
    -0.06277599f, 0.01884663f, -0.04742417f, 0.01177719f, -0.04286229f, 0.00586938f, -0.04271192f, -0.05238493f, 
    0.00307084f, 0.03446176f, -0.01929521f, 0.04108457f, 0.01546068f, 0.00769789f, 0.04461678f, 0.03985001f, 
    0.04047861f, -0.00561104f, 0.04540405f, 0.01307976f, -0.06081295f, -0.03066833f, 0.03191165f, -0.04469388f, 
    0.02857784f, 0.05184562f, -0.05677212f, -0.04320269f, 0.03330152f, -0.05572465f, -0.04030032f, -0.05026833f, 
    -0.01446569f, -0.03881215f, -0.00444331f, -0.02889999f, 0.01204454f, 0.03255671f, 0.03435909f, -0.06068353f, 
    -0.04568816f, 0.02198250f, 0.04677168f, -0.03498630f, -0.03571642f, -0.00964766f, 0.03090675f, -0.06500638f, 
    0.04397558f, 0.03572924f, 0.04802972f, -0.00845110f, 0.02529753f, -0.00507165f, -0.03373113f, -0.04434749f, 
    -0.04885520f, 0.03585801f, 0.02413682f, -0.02240457f, -0.04870533f, -0.00985052f, -0.02549585f, 0.01151818f, 
    0.01959541f, -0.03525763f, -0.05314593f, -0.05033838f, -0.01172223f, -0.04906274f, 0.03097951f, -0.05955277f, 
    0.03235669f, -0.01031982f, 0.01588417f, -0.06092644f, 0.05157339f, -0.04999167f, 0.00406801f, -0.04763342f, 
    0.00396582f, 0.03785340f, -0.01560806f, -0.05962360f, -0.03213078f, -0.01301851f, -0.04664544f, 0.03621907f, 
    -0.02932278f, 0.03614405f, -0.02018397f, 0.03473572f, 0.02748704f, -0.02683219f, 0.00497758f, 0.02167453f, 
    0.00329113f, -0.04664828f, -0.02880424f, -0.03727428f, 0.04949060f, -0.00733239f, -0.03768313f, 0.03234804f, 
    0.02202036f, 0.04102836f, 0.01902059f, 0.01452962f, 0.02072006f, -0.03722693f, 0.00543097f, 0.04869210f, 
    -0.03346001f, -0.03550241f, 0.03338894f, -0.01363859f, 0.03980833f, -0.05439087f, 0.02945901f, -0.02225437f, 
    0.04954287f, -0.02695894f, 0.01507358f, -0.01154048f, -0.05225084f, -0.06604013f, -0.03414377f, 0.01114928f, 
    -0.01520585f, 0.00955704f, -0.01417169f, -0.04480347f, 0.04664779f, -0.04679840f, 0.00328728f, -0.03964940f, 
    0.05042490f, 0.03529402f, 0.04964843f, -0.01067936f, -0.05541861f, -0.00026537f, -0.03678311f, 0.00812812f, 
    -0.05576707f, 0.02702325f, 0.03894814f, -0.02917599f, 0.03942066f, -0.03603487f, -0.03001302f, 0.05142044f, 
    0.04485398f, 0.05343844f, 0.00968724f, 0.05160959f, 0.03518770f, -0.02797557f, -0.03402011f, 0.03199048f, 
    0.00914286f, -0.01200252f, 0.05256168f, 0.03674259f, 0.02678994f, -0.04484633f, 0.03453010f, 0.02159230f, 
    0.03556684f, 0.03010571f, -0.05804112f, 0.03010822f, -0.03593282f, -0.04362293f, 0.01452023f, -0.01602728f, 
    0.03207659f, 0.00059865f, -0.00519076f, 0.00707739f, -0.01984802f, 0.02211531f, 0.03732815f, -0.00802446f, 
    -0.03239962f, -0.01981088f, -0.00326759f, 0.02506738f, -0.01029081f, -0.00922063f, 0.03036777f, -0.06030586f, 
    0.02731155f, 0.03686664f, -0.00024883f, 0.00819989f, -0.01450896f, -0.06182490f, -0.05129771f, -0.01894742f, 
    -0.01016363f, 0.00669395f, 0.00066445f, -0.00292358f, -0.01788241f, -0.00888214f, -0.06576288f, -0.03377384f, 
    0.03570489f, -0.01553847f, 0.02890776f, -0.00248462f, 0.01347478f, -0.01762437f, -0.05674380f, -0.03830664f, 
    -0.01205985f, -0.01228200f, 0.03967273f, -0.02036821f, 0.02488548f, 0.05186801f, -0.06411387f, -0.01199993f, 
    -0.02617426f, 0.02852273f, -0.02481705f, 0.02021365f, -0.01566951f, 0.03351878f, -0.01531469f, -0.00168217f, 
    0.00358233f, 0.03412211f, -0.06457678f, 0.03472371f, 0.02261662f, -0.04206755f, -0.01136294f, -0.03600850f, 
    0.04123788f, 0.02161541f, -0.02880392f, -0.01287695f, -0.03573959f, -0.05532070f, 0.01642511f, -0.04722032f, 
    0.00517719f, 0.03842197f, 0.02692572f, -0.01057555f, 0.02227325f, -0.00305671f, -0.06261611f, -0.04524685f, 
    0.02865029f, -0.04151889f, 0.04161280f, 0.02575627f, 0.05367591f, -0.01163428f, 0.02657924f, 0.01256192f, 
    -0.03313050f, -0.04478764f, 0.04099090f, 0.01194288f, 0.01632553f, -0.02286902f, -0.01729641f, 0.00060713f, 
    -0.02462207f, -0.06085024f, 0.04206666f, 0.00975084f, -0.06259098f, 0.04947456f, -0.03581262f, 0.00542784f, 
    -0.02419850f, -0.00719190f, -0.05836750f, -0.04910352f, -0.06374165f, -0.00806715f, 0.04874759f, 0.01962619f, 
    -0.01267328f, -0.00796179f, -0.04054226f, -0.00971926f, -0.04777719f, -0.04233346f, 0.02480119f, 0.01079508f, 
    -0.04007730f, -0.01262110f, -0.02872726f, -0.04638401f, -0.01321096f, 0.04211546f, 0.02700684f, 0.00276639f, 
    0.02886737f, -0.02605705f, -0.05163524f, -0.02775033f, -0.02840722f, -0.00618501f, -0.03030638f, -0.00319917f, 
    -0.00926733f, 0.00874532f, -0.00962370f, 0.00984137f, -0.01620091f, 0.02592999f, -0.05980649f, 0.03428065f, 
    -0.02426334f, -0.02299892f, -0.03173687f, 0.03712939f, -0.05372321f, -0.03428240f, -0.06083387f, 0.01787861f, 
    -0.03372427f, 0.00305559f, -0.04425671f, -0.06583025f, -0.02591879f, -0.00620268f, -0.04394506f, 0.00428216f, 
    -0.06004706f, -0.01652020f, -0.04791835f, -0.02068968f, -0.02774085f, 0.00763926f, 0.02505608f, 0.01835294f, 
    -0.14913593f, 0.18926747f, -0.00625386f, 0.00132213f, -0.03307515f, 0.13813566f, -0.22167742f, -0.00079322f, 
    -0.14996456f, 0.17130117f, 0.21130803f, -0.61408812f, 0.01516954f, 0.09508076f, 0.13415588f, -0.09671333f, 
    -0.13520887f, -0.06554431f, 0.02769693f, 0.00399271f, 0.02848964f, -0.00925125f, 0.06081807f, 0.29529247f, 
    0.02068971f, -0.02870148f, -0.13774946f, 0.01705073f, -0.30995291f, 0.29631105f, -0.14595690f, -0.19313261f, 
    -0.07834093f, 0.08844960f, 0.10429526f, -0.00354900f, -0.04293927f, -0.57412231f, -0.09243044f, 0.04623826f, 
    -0.11295390f, 0.02737306f, -0.16833504f, 0.11822864f, 0.07701215f, -0.04126214f, -0.11923135f, 0.05482550f, 
    -0.04921403f, -0.05584135f, -0.05175284f, 0.09376604f, 0.22392932f, 0.05529164f, -0.30526462f, 0.09880733f, 
    -0.03893093f, 0.14444350f, -0.00231412f, -0.03016712f, 0.15302105f, 0.09649732f, 0.07242907f, -0.00855917f, 
    -0.28022748f, 0.12751311f, 0.01847080f, -0.00830873f, 0.03341268f, -0.00246032f, 0.01284510f, 0.02156585f, 
    0.02919433f, 0.04151668f, -0.04416554f, -0.14157750f, 0.07662185f, -0.06545484f, 0.09816715f, -0.02296717f, 
    -0.00182691f, -0.32454243f, 0.16110180f, -0.11247720f, 0.03214441f, 0.05943648f, 0.08186547f, -0.08510807f, 
    0.04034213f, 0.10268438f, 0.40745938f, 0.03980853f, -0.00215034f, 0.05097031f, -0.13387923f, -0.10685918f, 
    0.09155583f, -0.08580307f, -0.04076033f, 0.01701060f, -0.46147054f, 0.25621596f, -0.09736879f, 0.20957446f, 
    0.03701080f, -0.00803791f, -0.17559285f, 0.06220521f, -0.18224953f, 0.00454839f, -0.11157132f, 0.07314123f, 
    0.08585790f, 0.11700743f, 0.04947099f, -0.18883796f, -0.03267939f, -0.04717534f, -0.02347419f, 0.04392236f, 
    -0.26569882f, 0.16759816f, 0.00978158f, -0.01269679f, -0.03767657f, -0.18949133f, -0.01577126f, -0.01826195f, 
    0.19005972f, -0.04935514f, 0.05645665f, -0.00615583f, -0.08767816f, -0.04652194f, 0.01636419f, 0.26543111f, 
    -0.24542141f, 0.11756522f, 0.02631429f, 0.00353183f, -0.17290503f, 0.12271240f, 0.07471775f, -0.04234859f, 
    -0.41341251f, 0.11170917f, 0.06568033f, 0.02791958f, 0.08280826f, 0.03008487f, -0.16902110f, 0.11256744f, 
    0.02912706f, 0.23299752f, -0.32117766f, -0.05889402f, -0.10035346f, 0.13934293f, 0.02711427f, 0.02345937f, 
    0.14497110f, 0.01211422f, 0.20452188f, 0.18344074f, 0.02509286f, -0.13160022f, -0.09201791f, -0.05004893f, 
    0.04936864f, 0.03459183f, 0.07873136f, -0.10462451f, 0.08979408f, 0.09788305f, 0.14075072f, 0.02240262f, 
    -0.00548734f, 0.06615549f, 0.01181865f, 0.29167885f, 0.13544078f, 0.08436751f, 0.05221274f, -0.04496386f, 
    -0.04261571f, -0.08459015f, -0.10277440f, 0.09671057f, -0.12008286f, 0.23038740f, 0.13173972f, -0.20019941f, 
    -0.02880543f, 0.00793198f, -0.08199541f, -0.03211902f, 0.10044676f, -0.09060874f, -0.18994533f, -0.07310230f, 
    0.17391694f, 0.00216627f, -0.10996152f, -0.01878065f, -0.05095374f, -0.08308066f, 0.15475368f, 0.18049626f, 
    -0.05928219f, 0.16081898f, -0.03220878f, 0.03845197f, -0.14379123f, 0.01969864f, 0.01172319f, 0.11145853f, 
    0.00256634f, -0.04122343f, 0.06888723f, -0.06272573f, 0.06844302f, -0.06753360f, -0.01524892f, -0.13647224f, 
    -0.17643249f, -0.07355495f, 0.15326817f, -0.21928412f, 0.17555483f, 0.00282874f, -0.01578184f, -0.13002288f, 
    0.00253477f, -0.09645500f, 0.20618334f, -0.56481349f, -0.25405157f, -0.16663036f, 0.08345679f, -0.01473730f, 
    0.16160074f, -0.00289487f, -0.18458109f, -0.04339435f, 0.04489806f, 0.10488323f, -0.13106927f, -0.00761613f, 
    -0.01015576f, 0.04164713f, 0.04416260f, 0.06608431f, -0.03172795f, -0.16216777f, 0.11855797f, 0.10976732f, 
    0.22665386f, 0.12305970f, -0.03281586f, -0.05201312f, -0.06588949f, -0.07509749f, -0.13602458f, -0.15296200f, 
    0.07134414f, 0.09252024f, -0.04706708f, -0.02369582f, -0.03495042f, -0.09011530f, -0.01754618f, 0.09546757f, 
    0.25293568f, 0.02109736f, 0.06004446f, -0.01163190f, 0.18492791f, -0.01252033f, 0.01165628f, 0.37252089f, 
    -0.13389696f, 0.10628419f, -0.06628177f, 0.11656832f, 0.12488803f, 0.00667032f, -0.06990562f, 0.09374925f, 
    -0.26470542f, 0.18848549f, 0.23361562f, 0.05874636f, -0.02902452f, 0.11081824f, -0.04363572f, -0.04215707f, 
    -0.07577894f, -0.02855707f, -0.02049438f, -0.21361963f, 0.11061600f, 0.05888892f, -0.08454380f, -0.10506768f, 
    0.06738406f, 0.08198220f, -0.05946144f, -0.15574083f, -0.01302411f, -0.02569646f, 0.22064303f, 0.21672794f, 
    0.05513891f, -0.18181086f, -0.06540389f, 0.14029756f, -0.17060055f, 0.20774269f, 0.02370300f, -0.06746697f, 
    0.03198752f, -0.06148984f, -0.02882925f, -0.01526318f, -0.20422041f, 0.00884252f, -0.20875621f, 0.13588025f, 
    0.04965887f, 0.04082244f, -0.18629400f, -0.06073505f, 0.14570871f, 0.05417682f, 0.10625652f, -0.08281715f, 
    -0.05594250f, 0.14778250f, -0.07099661f, -0.11315338f, 0.04994349f, 0.09705670f, 0.21531245f, 0.11954150f, 
    -0.25297630f, -0.13185237f, -0.08522403f, 0.08309935f, -0.00486846f, 0.12534881f, 0.15231688f, -0.10196038f, 
    0.02971210f, 0.18055230f, 0.03055195f, -0.03113006f, -0.16384324f, 0.14907894f, 0.00837993f, 0.06453626f, 
    -0.00066249f, -0.01643612f, -0.36842176f, 0.08268805f, 0.06884672f, -0.00888730f, 0.04663018f, -0.00244282f, 
    0.00248519f, 0.27045059f, 0.09385556f, 0.00910873f, 0.04553119f, 0.23921265f, 0.08603328f, -0.01888636f, 
    0.11650818f, 0.06857335f, 0.00374785f, 0.00624247f, 0.40140453f, 0.00938574f, 0.09909467f, -0.08041985f, 
    0.00488849f, 0.02623793f, -0.00600731f, 0.02974360f, -0.19758280f, 0.19768913f, 0.20090607f, -0.07882717f, 
    0.12893096f, 0.10479365f, 0.04804692f, -0.04071820f, -0.34474400f, 0.11386727f, 0.13463613f, 0.00302452f, 
    0.13844854f, 0.09974632f, 0.01843194f, 0.24278250f, -0.00225216f, 0.34005964f, -0.01978197f, -0.40658456f, 
    0.03775027f, 0.06878407f, 0.03134171f, 0.04246617f, -0.01924954f, 0.02112885f, 0.07631540f, 0.10625806f, 
    0.16390729f, 0.16054612f, -0.14235610f, 0.07342855f, -0.00894458f, -0.11718470f, -0.00150695f, -0.04798443f, 
    -0.13065867f, 0.28044850f, 0.05881135f, -0.14830376f, 0.04744969f, 0.02304463f, -0.07868920f, -0.05627877f, 
    0.10106161f, -0.04552105f, 0.13738783f, -0.19073421f, -0.14362398f, 0.10681101f, -0.07459746f, 0.00812789f, 
    0.09955135f, -0.11863472f, 0.05380105f, -0.12165631f, 0.04747373f, -0.03177942f, -0.16602293f, 0.17587075f, 
    -0.01434503f, 0.07330845f, -0.03939054f, -0.24411258f, 0.42230141f, 0.15309060f, -0.02102719f, -0.04756455f, 
    -0.08094147f, -0.03952629f, -0.06851721f, -0.08909974f, 0.04022401f, 0.43720582f, 0.02197714f, -0.12636966f, 
    0.04418208f, -0.10639241f, 0.03679711f, 0.02985227f, -0.09691770f, 0.02713407f, -0.14638793f, -0.10736682f, 
    -0.05691665f, -0.03607184f, -0.12773633f, -0.04252772f, 0.00837877f, 0.17567602f, -0.30896074f, -0.29950994f, 
    0.03807923f, 0.02667495f, -0.03128032f, -0.03306260f, 0.00512967f, -0.00987175f, -0.13362856f, -0.10621879f, 
    -0.07315044f, 0.04418186f, 0.04033609f, -0.00175389f, 0.05388247f, 0.05105545f, -0.06208146f, -0.03637883f, 
    -0.06358336f, 0.30594423f, 0.24024394f, 0.08679929f, 0.02691133f, 0.02883349f, -0.09432717f, -0.02288234f, 
    0.03883028f, 0.12848479f, -0.12139218f, 0.03416071f, -0.09889960f, -0.12142230f, 0.01715319f, -0.12749226f, 
    0.03237628f, -0.35139257f, 0.00354999f, -0.04742235f, -0.03599458f, 0.12968870f, -0.12791157f, -0.27228671f, 
    -0.05927064f, -0.16645344f, -0.01587706f, -0.03051615f, -0.34653416f, 0.18295375f, 0.05001482f, -0.01708137f, 
    0.10351416f, 0.20147832f, 0.05262262f, 0.31435472f, 0.05901712f, -0.03864839f, 0.02450970f, -0.13256253f, 
    0.07281378f, 0.02920992f, -0.04430505f, 0.21348107f, 0.00321843f, -0.00131720f, 0.11917881f, 0.02259022f, 
    -0.06415500f, -0.11822606f, 0.21219192f, -0.03662112f, 0.01865675f, -0.39035785f, 0.01860194f, -0.00117214f, 
    0.01003657f, -0.05713867f, -0.00790644f, -0.11018381f, -0.01020132f, -0.10578373f, -0.18873073f, 0.06108557f, 
    -0.00458390f, 0.01565708f, 0.07043115f, -0.05948359f, -0.01403184f, -0.04207473f, -0.11250682f, -0.03482286f, 
    -0.14908218f, 0.30353943f, 0.08108421f, -0.01075438f, -0.08179905f, -0.17594039f, -0.07154240f, 0.06377751f, 
    -0.15871130f, 0.12277446f, 0.00319859f, 0.01901545f, 0.02619558f, -0.05864860f, -0.24284658f, 0.04602709f, 
    -0.06215116f, 0.22044818f, -0.06631944f, -0.16515987f, -0.05897236f, -0.21577196f, 0.04879801f, -0.06932712f, 
    0.19045344f, -0.06073797f, -0.24959730f, 0.14782578f, 0.11887775f, -0.17440370f, 0.08679646f, 0.11283120f, 
    0.00787374f, 0.09049680f, 0.08023906f, 0.07857964f, 0.20624255f, -0.01503593f, -0.04748334f, -0.09276886f, 
    -0.10286900f, 0.00198417f, 0.10312418f, 0.02852143f, 0.13108891f, 0.12928228f, 0.04577436f, 0.03045049f, 
    0.00092645f, -0.06358706f, 0.04596576f, 0.05027746f, 0.02384594f, 0.08578797f, -0.09759702f, -0.00438869f, 
    -0.10433036f, -0.08126047f, -0.01854057f, -0.07410335f, -0.11155774f, 0.06848564f, 0.04641671f, -0.23695457f, 
    -0.28388706f, 0.04254235f, 0.06769909f, 0.04804624f, 0.02020787f, 0.09180182f, -0.02264254f, 0.04665080f, 
    0.02178367f, 0.18060076f, 0.03404646f, 0.09908455f, -0.04275601f, 0.06788673f, 0.13120224f, -0.06041788f, 
    0.07715832f, 0.10228692f, -0.09905765f, 0.09520632f, -0.11582863f, -0.02250464f, -0.02849620f, 0.05652719f, 
    -0.13228482f, 0.10928259f, 0.07736962f, -0.00353386f, 0.05514506f, -0.00728955f, -0.02621377f, -0.13773526f, 
    0.01951707f, -0.01221681f, 0.04507293f, -0.09475525f, 0.07744246f, -0.00417025f, -0.00493322f, -0.09926739f, 
    -0.02313385f, 0.12317248f, 0.07707743f, 0.03071647f, 0.12558450f, 0.21592630f, -0.11318055f, -0.17104492f, 
    -0.05984793f, -0.01508416f, 0.02840082f, -0.08842702f, -0.20022430f, -0.02213270f, -0.07764453f, -0.03850396f, 
    -0.07557144f, -0.09963859f, -0.22972560f, 0.01754880f, 0.04117588f, 0.03132637f, -0.05432209f, 0.14409512f, 
    0.11390971f, -0.03738185f, -0.07639646f, -0.15759625f, -0.02716050f, 0.11318135f, -0.28094327f, -0.04566800f, 
    -0.18136702f, -0.05609521f, 0.02880968f, 0.09886697f, -0.04810654f, -0.02999912f, -0.04242846f, -0.01675859f, 
    -0.02522813f, 0.24999058f, 0.14114228f, -0.08192806f, 0.10673743f, 0.03022264f, -0.01511910f, 0.07486360f, 
    -0.04719319f, -0.31312016f, 0.01340767f, -0.04908751f, 0.15294930f, -0.05612598f, 0.13789459f, -0.00399856f, 
    0.11180971f, -0.10731328f, 0.11169019f, 0.08613881f, -0.02290227f, -0.07814810f, -0.09290267f, -0.01287006f, 
    0.07443029f, 0.03026482f, 0.20845127f, -0.09577194f, 0.02950070f, -0.05384851f, 0.28979588f, -0.12553324f, 
    -0.03162622f, 0.00779987f, 0.14897268f, 0.21661967f, -0.17663512f, 0.14956535f, 0.12495405f, 0.15477152f, 
    0.10064389f, -0.02229709f, 0.07780675f, 0.11846060f, 0.12905870f, 0.12764473f, -0.08047858f, -0.12300122f, 
    -0.02688340f, -0.08795989f, 0.14021972f, 0.09963875f, -0.12386654f, 0.09855215f, -0.20634483f, 0.00704235f, 
    0.02285465f, -0.05380185f, 0.02087949f, 0.10528684f, 0.08132055f, 0.06283265f, 0.09877561f, 0.11950814f, 
    0.07929549f, -0.10090600f, -0.04916270f, -0.05350341f, -0.15955365f, 0.01773925f, 0.00408642f, -0.15221779f, 
    0.04165942f, 0.27897009f, -0.02237744f, 0.06338842f, 0.02063814f, -0.12852305f, 0.04436274f, -0.03955362f, 
    -0.01960607f, 0.05718519f, -0.12963086f, -0.21268308f, 0.08618175f, 0.06334742f, -0.06760055f, 0.04423844f, 
    -0.01583517f, -0.04031103f, 0.19697873f, -0.08084921f, -0.04779261f, -0.02073020f, 0.02631780f, -0.11963473f, 
    0.05238564f, 0.05341921f, 0.19346130f, 0.19180770f, -0.15540467f, 0.00319284f, -0.01176540f, 0.18756835f, 
    0.00839487f, 0.05753409f, 0.01622452f, 0.00215016f, -0.08663960f, -0.15225893f, -0.04729971f, -0.09128641f, 
    0.01962500f, 0.05343220f, 0.03924615f, 0.01575084f, 0.06790076f, -0.01940548f, -0.06729098f, 0.04772120f, 
    -0.08692423f, 0.07440987f, 0.00921027f, 0.10455266f, -0.09621951f, -0.17054297f, 0.00260660f, -0.26137176f, 
    0.02591673f, 0.01424670f, -0.11260217f, -0.16776417f, -0.00048824f, 0.07626802f, -0.19443730f, -0.22465359f, 
    -0.22962402f, -0.02538615f, 0.10851738f, -0.00282788f, -0.10874840f, 0.00600418f, 0.05135097f, 0.05748523f, 
    0.00691563f, 0.33940411f, 0.24915928f, -0.05074067f, 0.02286171f, -0.00942004f, 0.15847053f, 0.02956464f, 
    0.08885635f, 0.06530347f, -0.04034969f, 0.30333501f, -0.11227944f, 0.06685176f, 0.02635760f, -0.10850254f, 
    0.24563700f, -0.14352958f, 0.08331102f, -0.45292637f, 0.06169860f, 0.15270054f, 0.17147103f, 0.04042482f, 
    0.09071163f, 0.03350011f, 0.22136873f, -0.27973950f, -0.10098793f, -0.05909488f, -0.04965987f, 0.01167235f, 
    -0.02193340f, -0.04546921f, -0.17457181f, -0.09485447f, -0.04269181f, -0.00213249f, 0.00574189f, 0.05818738f, 
    -0.25540990f, 0.16014685f, -0.02775754f, 0.04345147f, -0.09044950f, -0.05838777f, 0.00215337f, 0.14118879f, 
    0.01042218f, 0.12046304f, -0.09059186f, -0.13193689f, 0.06808367f, 0.00055333f, -0.14869300f, -0.04048993f, 
    0.10094748f, 0.06798135f, 0.16576198f, -0.06880521f, -0.00493737f, 0.01694361f, 0.10177517f, 0.11503813f, 
    0.10558400f, 0.06822471f, -0.09474920f, -0.22656408f, 0.06609601f, 0.00242675f, 0.22317503f, 0.05205409f, 
    0.02152416f, -0.21656601f, 0.03938395f, 0.08973500f, 0.26853245f, 0.00146447f, -0.04411306f, 0.14611582f, 
    -0.14067367f, 0.16293453f, -0.11354760f, -0.04912929f, -0.06247611f, 0.13311060f, 0.01407260f, 0.17697184f, 
    -0.00903156f, -0.22109507f, -0.01303935f, 0.01273673f, -0.08964085f, 0.17751537f, 0.02550415f, -0.08011609f, 
    0.04055671f, 0.02156829f, 0.18323585f, 0.04485753f, -0.05150953f, -0.19236293f, -0.04109770f, -0.02491541f, 
    0.01147695f, -0.11417807f, 0.14560136f, -0.16871998f, -0.07360367f, 0.03280879f, 0.19324322f, 0.05793597f, 
    0.12309033f, 0.02330580f, -0.13775963f, -0.19616337f, 0.05126200f, 0.11912597f, 0.01924787f, 0.15243688f, 
    -0.08029717f, 0.14829117f, -0.05178839f, 0.00182193f, 0.23051760f, -0.24210362f, 0.24301566f, 0.13960180f, 
    -0.06652864f, -0.02439514f, -0.17741381f, -0.00682358f, 0.01867726f, 0.17072299f, 0.04714500f, -0.08145307f, 
    0.11791934f, -0.02338769f, -0.00682514f, 0.06110140f, 0.04057596f, -0.01182069f, 0.20377478f, -0.05369997f, 
    -0.17796616f, -0.10351465f, -0.06366523f, -0.12127704f, -0.04760631f, 0.10966673f, 0.01499973f, -0.07709948f, 
    0.09013055f, -0.02423935f, 0.03821937f, -0.09950661f, -0.02050632f, -0.35400793f, 0.05666104f, 0.00983492f, 
    0.03073883f, 0.13593094f, -0.31373912f, -0.25391784f, 0.01570488f, -0.07594276f, -0.05576107f, -0.02458178f, 
    0.06040910f, -0.00757982f, 0.17609715f, 0.09935766f, -0.09395045f, 0.01913393f, -0.02348572f, -0.30447134f, 
    0.08971129f, -0.11556607f, -0.05142003f, 0.16648333f, -0.15349190f, 0.11764885f, 0.09674512f, -0.02333429f, 
    -0.43835089f, 0.08134032f, -0.19907160f, -0.08664718f, -0.13826162f, -0.01197649f, -0.07627432f, 0.06241554f, 
    0.08562122f, 0.17489175f, -0.03281029f, -0.05728264f, 0.15164332f, -0.09015549f, 0.10605312f, 0.12236416f, 
    0.12688148f, 0.08533669f, 0.14880300f, 0.04043137f, -0.01715353f, -0.00153004f, -0.21673127f, 0.07490190f, 
    0.08247565f, 0.14446457f, -0.00191366f, 0.02694999f, 0.03416766f, -0.05915258f, -0.03595884f, 0.23615378f, 
    0.27880007f, -0.04618482f, 0.02402106f, -0.05719607f, 0.07875199f, 0.03508033f, -0.09460007f, 0.08886046f, 
    0.03839140f, -0.15287812f, 0.02934571f, 0.09948849f, -0.04874406f, 0.04671576f, 0.22520706f, 0.00066936f, 
    0.15124901f, -0.04013412f, -0.11679649f, -0.14860256f, -0.03590150f, -0.03752770f, 0.13397242f, -0.06164638f, 
    -0.10346803f, 0.05930862f, -0.21554035f, -0.15874228f, -0.18894574f, 0.20003378f, 0.11351909f, -0.02599233f, 
    -0.01100130f, -0.02203939f, -0.17997639f, 0.10853827f, 0.13076340f, 0.05882927f, -0.02751750f, -0.02414250f, 
    -0.16083151f, 0.02034109f, 0.18074997f, 0.03775390f, 0.09346854f, -0.14256524f, -0.18050325f, 0.02658923f, 
    -0.05725231f, 0.21428700f, -0.22222848f, -0.02270526f, -0.07126125f, 0.11203634f, 0.01326233f, -0.24150261f, 
    -0.03594741f, 0.00694166f, 0.25394243f, -0.10600064f, -0.19523767f, -0.07431959f, 0.06779464f, -0.12334728f, 
    0.11140347f, -0.12922244f, -0.00660473f, 0.00652837f, -0.02575108f, -0.05034244f, 0.21490948f, 0.00918550f, 
    -0.18778777f, -0.03313250f, 0.05775590f, 0.05835988f, -0.15619625f, 0.08572400f, -0.12996235f, -0.07235923f, 
    -0.03640417f, -0.01239400f, 0.01706911f, 0.03139695f, -0.01314333f, 0.04808893f, -0.04508591f, 0.02720560f, 
    0.04439415f, -0.01547699f, 0.00065813f, 0.04483593f, -0.04819835f, -0.01755787f, 0.03327470f, 0.03156219f, 
    -0.00880185f, -0.02393389f, -0.00259673f, -0.01247578f, -0.00456670f, 0.00400131f, 0.05043389f, -0.04460640f, 
    0.05169466f, -0.03947943f, -0.00993651f, 0.04012235f, -0.05371595f, -0.00554029f, 0.04176385f, 0.03354314f, 
    -0.04702578f, -0.04406181f, 0.00984002f, -0.04672879f, -0.02401825f, 0.04347924f, -0.01146578f, -0.04808311f, 
    -0.05589749f, -0.02442806f, 0.05409778f, 0.04776770f, 0.05521350f, -0.02729588f, 0.00047989f, 0.04189970f, 
    0.00857116f, -0.01736408f, -0.01910249f, -0.00776206f, -0.00563193f, -0.02611199f, 0.02191879f, 0.00331308f, 
    0.04858251f, -0.06479564f, 0.00272129f, -0.04528144f, 0.01009446f, -0.00061849f, 0.04947598f, 0.02232238f, 
    0.04249442f, -0.00866980f, 0.02043115f, -0.03045768f, 0.04656152f, -0.01143890f, 0.02777924f, 0.00379223f, 
    0.01698751f, -0.04763830f, -0.04306893f, -0.02928521f, -0.00664132f, 0.00224584f, -0.02862829f, 0.02975602f, 
    -0.04235398f, 0.04368650f, -0.00725937f, 0.00693962f, -0.03658494f, -0.01544793f, 0.03036937f, 0.01534088f, 
    -0.05150883f, -0.03126557f, -0.00599482f, -0.01385192f, 0.01570569f, 0.03893582f, -0.06543600f, 0.02323352f, 
    0.01504250f, -0.03839613f, -0.02800463f, 0.00634632f, 0.01122796f, -0.01455847f, -0.01320937f, 0.01083343f, 
    -0.04780402f, 0.02508617f, -0.04363729f, -0.00467343f, 0.04866324f, 0.04961065f, 0.01315997f, 0.03649858f, 
    -0.01090744f, 0.02943376f, -0.03879115f, -0.03399052f, -0.01951357f, -0.05987650f, -0.01768979f, -0.04232639f, 
    0.04690467f, -0.00063390f, -0.06512406f, -0.02450086f, 0.00405956f, -0.05393786f, -0.05600312f, -0.05842872f, 
    0.03386783f, -0.04175808f, 0.04579340f, 0.02299874f, -0.05077229f, -0.05375561f, -0.01297421f, 0.03638995f, 
    -0.01200091f, -0.03253587f, 0.01878625f, -0.02898930f, -0.05982716f, -0.02947388f, -0.02372488f, -0.00357975f, 
    -0.03629786f, 0.03791167f, 0.02956819f, -0.04211026f, -0.05673875f, -0.01179765f, -0.03842222f, -0.01709194f, 
    -0.01543825f, 0.00331247f, -0.01500809f, 0.01797361f, 0.02361757f, -0.03289463f, -0.06427961f, 0.02577222f, 
    -0.04683208f, -0.06174212f, 0.01245959f, -0.01442071f, 0.02004287f, -0.00958442f, -0.02021401f, -0.00829908f, 
    -0.04247748f, -0.03903373f, 0.04318684f, -0.06336081f, -0.03661846f, 0.00044655f, -0.04142516f, -0.00131267f, 
    -0.03833709f, -0.01485784f, 0.00809222f, 0.00240467f, -0.02587730f, 0.01402994f, -0.01397618f, 0.04190635f, 
    -0.00933343f, -0.03145400f, 0.02045017f, 0.03431757f, -0.03637491f, -0.06103183f, -0.06418554f, 0.01395586f, 
    -0.01575891f, 0.04378669f, 0.01068392f, 0.04907376f, 0.04753027f, -0.02022588f, -0.04345958f, 0.04889080f, 
    -0.00214544f, -0.02961049f, -0.03619546f, -0.03773433f, -0.06083767f, 0.01046475f, -0.04630380f, -0.03392591f, 
    -0.00507159f, 0.01056945f, -0.01245158f, 0.01950223f, -0.01241147f, 0.03343135f, -0.06412563f, 0.02752413f, 
    -0.00154429f, 0.00303692f, 0.03368509f, 0.05028300f, -0.02441715f, -0.06115782f, -0.01270719f, 0.03819606f, 
    0.04704654f, -0.05099170f, 0.01238183f, 0.00002589f, 0.03803113f, -0.00287931f, 0.02750362f, -0.03416177f, 
    -0.00788550f, -0.02006184f, -0.00030112f, 0.00803292f, -0.03870464f, 0.03754363f, -0.04518509f, -0.01224947f, 
    0.01448605f, -0.00034175f, -0.00194716f, -0.03496378f, 0.01084073f, 0.04244922f, 0.03188825f, -0.04928975f, 
    -0.00653254f, -0.06428409f, -0.00737917f, -0.02705217f, 0.00090668f, 0.00100872f, 0.01401388f, 0.04856386f, 
    0.04665598f, -0.00836915f, -0.01266985f, -0.00902123f, 0.03567252f, 0.04125866f, 0.01165946f, -0.00136528f, 
    -0.05326081f, -0.06286818f, -0.03597863f, 0.04655824f, 0.03415520f, -0.00469081f, 0.01871941f, -0.01311058f, 
    -0.04427444f, 0.01233537f, -0.04809897f, 0.00638016f, -0.05646221f, -0.00664061f, -0.00414794f, -0.02273097f, 
    -0.02449358f, -0.04143636f, -0.02596253f, 0.03825735f, -0.02152201f, 0.02299081f, -0.01310749f, -0.05211609f, 
    -0.00165712f, -0.05940707f, -0.01901673f, -0.01660638f, 0.01459697f, 0.02231270f, -0.04760380f, 0.02635991f, 
    -0.02452810f, 0.00466808f, -0.00074571f, -0.02415943f, -0.01795818f, 0.02458142f, 0.00108387f, -0.05357914f, 
    -0.02008704f, 0.04420155f, -0.04264900f, 0.00193441f, 0.03107739f, 0.04938141f, 0.01122610f, -0.05873705f, 
    -0.02239578f, -0.04829134f, -0.03677035f, 0.01099409f, -0.01044555f, 0.03699702f, 0.01615961f, 0.03292551f, 
    -0.00900344f, 0.03833057f, 0.01449165f, -0.02191138f, -0.04503154f, -0.02661774f, -0.02038046f, -0.04193936f, 
    -0.00030839f, -0.00428264f, -0.01411959f, -0.02628062f, 0.02699193f, 0.02844867f, -0.03194023f, 0.01954340f, 
    -0.04057218f, -0.01065102f, -0.05151657f, 0.00386369f, 0.03607262f, -0.05955558f, 0.01722299f, 0.01683509f, 
    0.02235609f, 0.04981044f, -0.01483989f, -0.03171512f, 0.03893726f, -0.04482264f, -0.06379934f, -0.03251107f, 
    -0.04649673f, -0.03221098f, 0.03703764f, -0.05588076f, 0.01176358f, -0.03690686f, 0.02728893f, -0.05107903f, 
    0.02144375f, 0.02178537f, 0.05219137f, 0.04666372f, -0.05985880f, -0.03066602f, 0.00935838f, -0.03294137f, 
    -0.04298618f, 0.02722499f, 0.04022603f, 0.03889440f, -0.04710054f, -0.02221625f, -0.05189406f, 0.04472816f, 
    -0.05613348f, -0.01028470f, -0.01726283f, 0.03006781f, -0.02111393f, -0.06383308f, -0.01786096f, 0.01847351f, 
    0.03087773f, 0.00520565f, -0.05563934f, -0.02826988f, 0.05037674f, 0.00960056f, -0.02361955f, -0.04609435f, 
    0.03763649f, -0.03066308f, -0.01075038f, -0.02828480f, -0.02678695f, -0.05434275f, -0.00413179f, -0.02309615f, 
    0.00154177f, -0.02418634f, -0.04742537f, 0.04420923f, -0.05609236f, -0.06473362f, -0.02405231f, 0.02698674f, 
    -0.01868466f, -0.06013306f, 0.01195997f, -0.02065922f, -0.00262282f, -0.04959454f, 0.01160549f, 0.02014244f, 
    -0.02042910f, 0.00790919f, 0.00428134f, 0.04237327f, 0.02183729f, 0.06430059f, 0.00317145f, -0.00707255f, 
    -0.03141595f, -0.06058726f, -0.01577064f, -0.06205097f, 0.00837154f, 0.04496401f, -0.00582898f, -0.01028875f, 
    0.00227272f, -0.03240622f, -0.03841819f, 0.03887887f, -0.00544482f, -0.03649871f, -0.04707475f, -0.02828565f, 
    0.03963581f, -0.00303947f, 0.04493210f, -0.05971608f, -0.04769185f, -0.00185891f, -0.02374478f, -0.00040620f, 
    -0.05342409f, -0.05104578f, 0.04270719f, 0.00878161f, 0.03086060f, 0.00436019f, -0.02923476f, 0.04369226f, 
    0.03575147f, -0.05916229f, -0.06399222f, -0.01258158f, -0.02044054f, 0.03005563f, -0.03892708f, 0.00209080f, 
    -0.03047892f, -0.00769074f, 0.03683215f, -0.02813140f, 0.03912405f, -0.02803366f, -0.00859867f, -0.01103804f, 
    -0.01413233f, 0.02461713f, -0.05197637f, 0.04791954f, 0.02817021f, 0.04741073f, 0.03332631f, -0.04268497f, 
    -0.06339902f, 0.05037355f, -0.03201842f, 0.04673376f, 0.04913613f, -0.02561027f, 0.00239239f, 0.04525151f, 
    0.00683650f, 0.04218682f, -0.02931601f, -0.03532895f, 0.04840209f, -0.04990787f, -0.03377111f, 0.00313297f, 
    0.02311867f, 0.00031773f, -0.00925298f, -0.03211147f, -0.06028085f, 0.04230652f, -0.02736963f, -0.06002413f, 
    -0.03001799f, -0.02515596f, 0.05197286f, -0.03657660f, 0.05263185f, -0.04392606f, -0.00226013f, -0.03148165f, 
    0.05045158f, -0.00148288f, 0.03002508f, 0.00299445f, 0.04765126f, 0.04161565f, 0.01581972f, -0.06257111f, 
    -0.01622915f, -0.03155055f, -0.02930073f, -0.02901104f, 0.03759280f, 0.02498020f, -0.04415723f, 0.03880622f, 
    0.04653738f, -0.00203551f, 0.05014015f, -0.01149029f, -0.05729387f, 0.05067854f, -0.01110587f, -0.02568373f, 
    -0.01865046f, -0.05867238f, 0.02268703f, 0.00558410f, -0.05819440f, -0.04838210f, 0.04555453f, 0.06357343f, 
    0.00813400f, -0.04427325f, 0.00919997f, 0.00255363f, 0.04558628f, 0.03528010f, -0.05251316f, -0.05767629f, 
    -0.04993481f, -0.05726508f, -0.03538585f, -0.00310059f, -0.05680592f, -0.06246588f, -0.05872738f, 0.02730708f, 
    0.03239987f, 0.04933620f, 0.03636289f, 0.00826976f, -0.01367612f, -0.00506100f, -0.02530150f, -0.05505156f, 
    -0.05139117f, -0.02271040f, -0.00542083f, -0.05123547f, 0.01097752f, -0.03876041f, -0.02364333f, 0.05416873f, 
    0.10347220f, 0.12346773f, 0.07944565f, 0.06565303f, 0.05518349f, -0.01329915f, -0.03130060f, 0.00165717f, 
    -0.08143066f, -0.07137288f, 0.06628171f, 0.18107739f, -0.10942356f, -0.09556343f, 0.01335021f, -0.08772527f, 
    -0.04989050f, -0.07837325f, -0.16465165f, 0.04232586f, 0.12253882f, 0.03143131f, -0.01502671f, 0.01400150f, 
    0.07328891f, -0.14267555f, -0.25167945f, 0.02594658f, 0.03244285f, -0.13197675f, 0.07083404f, -0.02877020f, 
    -0.09191049f, 0.08409004f, 0.00339575f, -0.06208983f, -0.00829786f, -0.02193535f, 0.04426016f, 0.13459961f, 
    -0.08509612f, 0.12151740f, -0.03451007f, 0.00680515f, 0.00298622f, -0.01497481f, 0.00571959f, -0.02358109f, 
    -0.01249261f, 0.03666285f, 0.02097890f, 0.03820103f, 0.00897609f, -0.03861864f, 0.09688050f, -0.15816076f, 
    -0.33188888f, 0.10570272f, -0.05791317f, -0.14873751f, 0.07375226f, -0.06011892f, 0.04772986f, -0.21086173f, 
    0.03390628f, 0.06816013f, 0.02641655f, -0.04506791f, 0.04233469f, 0.11608139f, 0.08108182f, -0.06019701f, 
    -0.20639913f, -0.02498101f, -0.08676897f, -0.07733368f, 0.03858134f, -0.07352483f, -0.06467597f, -0.01405373f, 
    -0.06566568f, 0.16091998f, 0.08198879f, 0.09396390f, -0.01851821f, -0.16808669f, 0.03630614f, 0.02673237f, 
    -0.02068000f, -0.00912804f, 0.04605349f, -0.07307222f, 0.03690439f, 0.22579819f, 0.14397807f, -0.01108145f, 
    0.07749229f, -0.14722276f, 0.09035624f, 0.21603015f, -0.07913169f, 0.09731863f, -0.07138231f, -0.04909593f, 
    -0.09012209f, 0.08118896f, 0.13514327f, -0.06878845f, -0.07974017f, 0.07378088f, 0.10919879f, 0.03096711f, 
    -0.16145265f, 0.02909065f, 0.05664402f, 0.06479643f, 0.00353080f, -0.00358061f, -0.10009392f, 0.04022751f, 
    0.01800584f, 0.03786179f, -0.08854915f, -0.11894106f, -0.01617046f, -0.01907095f, 0.06007730f, 0.06750915f, 
    0.11467464f, 0.05181744f, -0.06938646f, 0.08999930f, 0.04788078f, 0.09180463f, 0.00674329f, -0.14878522f, 
    -0.00751161f, 0.10518503f, 0.24202591f, 0.11269426f, -0.02338767f, -0.08465655f, -0.05014817f, -0.04234807f, 
    -0.19042754f, -0.10352756f, -0.11368833f, 0.03682795f, 0.16564588f, 0.14402615f, 0.18524566f, -0.07313364f, 
    0.05822008f, 0.11267819f, 0.11020988f, 0.09801850f, 0.15379328f, 0.02494431f, 0.09186171f, 0.06389213f, 
    0.01720512f, -0.04779311f, 0.03250197f, 0.11584718f, -0.04391836f, 0.35914025f, 0.17353156f, 0.05357774f, 
    -0.00394359f, -0.11482845f, 0.22262913f, 0.41955882f, 0.18042846f, -0.09326234f, 0.01620628f, -0.02879894f, 
    -0.08560085f, -0.12842718f, -0.09497857f, 0.24057749f, -0.03472889f, -0.09569313f, -0.03650047f, -0.05174398f, 
    -0.11344381f, 0.07942554f, 0.04576040f, 0.03140674f, -0.01399431f, -0.07277869f, -0.09150148f, -0.30631909f, 
    0.08425563f, 0.00862905f, -0.09782089f, -0.11743534f, -0.11805592f, -0.01412091f, 0.15806863f, -0.17774522f, 
    -0.05203768f, -0.06574844f, -0.18902759f, -0.03692429f, 0.05675134f, 0.12500654f, 0.05872924f, 0.09027489f, 
    -0.01954485f, 0.10674818f, 0.21758768f, 0.15616781f, 0.12980546f, 0.22559617f, -0.09637532f, -0.02014161f, 
    0.16111471f, -0.01111387f, -0.05174812f, -0.14341299f, -0.11842848f, 0.04952563f, 0.02231828f, 0.02819657f, 
    -0.04637660f, 0.08099756f, -0.18296026f, -0.00496642f, -0.12073657f, -0.11108127f, 0.06621724f, 0.13302450f, 
    0.30337578f, -0.04382502f, -0.01757410f, 0.30878890f, 0.10438337f, -0.05369226f, 0.04895835f, -0.09217661f, 
    0.03337229f, -0.17919892f, 0.06678870f, -0.11061624f, -0.02049720f, -0.01792505f, 0.17371978f, -0.00386694f, 
    0.07866569f, 0.01328942f, 0.04800766f, 0.04904091f, -0.05564864f, 0.08492653f, 0.09781624f, -0.15888627f, 
    -0.17990662f, -0.16604359f, 0.00572501f, 0.07017680f, -0.04071015f, 0.08086091f, 0.26447278f, 0.03958497f, 
    -0.28710601f, -0.20569430f, -0.06181037f, -0.00919648f, 0.04241913f, -0.03954232f, 0.05005528f, -0.07144337f, 
    -0.04509371f, -0.07135987f, -0.08035342f, 0.04180628f, -0.03377768f, -0.04528492f, 0.14244810f, -0.16641346f, 
    0.00576806f, 0.15943407f, 0.24274345f, 0.18714799f, -0.12346897f, -0.10656679f, -0.11614542f, -0.01551253f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07018345f, -0.04297658f, 0.06589063f, 0.12392023f, 0.07119600f, 0.21353936f, 0.12405042f, -0.03480961f, 
    0.06217482f, 0.05806526f, 0.00849847f, -0.03839111f, -0.07505247f, -0.09463399f, 0.15736389f, 0.01204943f, 
    -0.01191921f, 0.10993283f, 0.12996536f, 0.01396806f, 0.03048640f, -0.01902672f, -0.01407523f, -0.02950551f, 
    -0.00064027f, 0.03317965f, 0.08932696f, -0.06665993f, 0.19744469f, -0.04145267f, -0.03806743f, -0.01266777f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.31968659f, -0.02315054f, 0.26435426f, -0.25965500f, -0.04244136f, -0.30858454f, -0.10239188f, 0.13244270f, 
    0.46090871f, 0.07320864f, 0.14084759f, 0.25881907f, 0.17646024f, 0.09979341f, -0.15020928f, 0.17022170f, 
    -0.01976475f, 0.17826405f, -0.01609861f, 0.17969672f, -0.16350605f, -0.10809626f, 0.54117256f, 0.09987111f, 
    0.08981214f, 0.36976114f, 0.49280351f, 0.26512337f, -0.24483570f, -0.00439089f, -0.00815270f, 0.06980896f, 
    -0.14031848f, -0.00635399f, 0.07365415f, -0.02242660f, 0.04468407f, -0.02295886f, -0.00923283f, -0.00717706f, 
    -0.18634512f, -0.14392072f, -0.03801463f, -0.18242358f, -0.10419368f, 0.00901067f, 0.00668685f, -0.08716929f, 
    0.06699532f, 0.05884636f, -0.05304391f, -0.07217094f, 0.01741209f, -0.16552894f, 0.03135063f, -0.01526249f, 
    0.08036407f, -0.12160143f, -0.18219277f, -0.17225821f, -0.05191202f, -0.03482377f, -0.17509824f, -0.16885151f, 
    -0.00591813f, -0.01968093f, -0.18688644f, -0.04988801f, -0.00107087f, -0.15499398f, -0.04867185f, -0.07640271f, 
    -0.11569174f, -0.04180087f, -0.17532022f, -0.18902603f, -0.06663657f, 0.04936950f, 0.06882972f, 0.06626930f, 
    -0.12365776f, -0.09042507f, 0.11881155f, 0.10643371f, 0.17384492f, 0.05406100f, -0.01991198f, -0.03338033f, 
    0.00170334f, -0.07583756f, 0.07733155f, -0.15767817f, -0.13950352f, -0.07483554f, -0.07865942f, -0.20341542f, 
    -0.14093854f, -0.14294262f, -0.13562502f, 0.08131187f, 0.03736369f, -0.25604028f, -0.33168465f, -0.05559349f, 
    0.39368936f, -0.08679020f, -0.10580143f, -0.08814283f, 0.27599651f, 0.22113450f, -0.41966689f, 0.06251646f, 
    -0.00993146f, -0.17293444f, -0.11913398f, -0.11464294f, -0.00042667f, 0.35650015f, 0.31165844f, 0.16646278f, 
    -0.12442129f, 0.21575209f, -0.10589213f, 0.42057002f, -0.10181607f, -0.02021012f, -0.07838930f, 0.16736010f, 
    0.10489883f, -0.17643024f, -0.01381500f, -0.31697434f, 0.03354706f, 0.01370704f, -0.09004928f, 0.14908813f, 
    -0.41662797f, -0.17205599f, -0.08778393f, 0.31735671f, 0.12132301f, -0.10955862f, 0.56800979f, 0.10744639f, 
    0.28711775f, 0.45472646f, -0.07543462f, -0.02470802f, 0.07693279f, 0.18752325f, 0.31653705f, 0.01270603f, 
    0.16962332f, -0.37480247f, -0.05606145f, -0.18262890f, -0.22629310f, -0.15763550f, 0.15213008f, 0.34762734f, 
    -0.02363466f, 0.10708360f, 0.34300175f, -0.14450842f, -0.01950686f, -0.22260247f, -0.52518690f, -0.07655622f, 
    0.01538948f, 0.06316432f, -0.06546790f, 0.06079025f, 0.38213342f, 0.03797742f, -0.07921507f, -0.13702559f, 
    0.57563573f, 0.04792535f, 0.41684985f, -0.16641307f, 0.03678426f, 0.11380333f, 0.33295062f, 0.02346156f, 
    -0.13465421f, 0.27246535f, 0.08276770f, -0.25477380f, -0.27345198f, -0.02210581f, 0.09361699f, 0.08757274f, 
    0.15249929f, -0.10709365f, 0.03209364f, -0.07256162f, 0.20966002f, -0.25431186f, 0.31741822f, -0.08423997f, 
    -0.14592040f, -0.29975760f, -0.14520507f, 0.13792615f, 0.13294597f, -0.12303845f, 0.54052556f, -0.06125657f, 
    0.04184179f, 0.32090056f, -0.04329879f, 0.00167887f, -0.13773748f, -0.08929117f, 0.30248800f, -0.02839311f, 
    -0.15917629f, -0.56014425f, 0.21279445f, -0.24080788f, -0.18678540f, 0.07242732f, -0.00232018f, 0.32482460f, 
    0.10005202f, 0.14801131f, -0.10213473f, 0.09789745f, 0.12861139f, 0.09066304f, -0.29142520f, -0.16974181f, 
    -0.33904850f, -0.23361871f, 0.02733452f, 0.28777662f, 0.30593988f, -0.13334070f, -0.13526624f, -0.04698586f, 
    0.33743101f, 0.32378671f, -0.06702439f, -0.04550415f, 0.16388735f, 0.29696238f, 0.13746698f, -0.09467161f, 
    0.05560755f, 0.18177563f, -0.14466260f, -0.12459156f, -0.26715490f, 0.01645625f, -0.07144578f, 0.21086946f, 
    -0.03395498f, -0.17778350f, -0.08978835f, 0.25161600f, 0.25220472f, 0.07388480f, 0.30871561f, -0.00213478f, 
    0.24901469f, -0.40631813f, -0.01967004f, -0.13825752f, -0.76140851f, -0.36119449f, -0.11792064f, 0.04437994f, 
    -0.01769319f, -0.06165117f, 0.58903927f, -0.14796245f, 0.13654940f, -0.62179357f, 0.20571612f, -0.07350623f, 
    0.16005339f, -0.19121939f, 0.23757704f, 0.30726129f, 0.18689191f, -0.14214398f, -0.08071335f, -0.08819717f, 
    0.15432231f, 0.15509182f, 0.08259084f, 0.04742880f, 0.37734658f, 0.14080897f, 0.11351211f, -0.00158481f, 
    0.40060288f, -0.34581375f, 0.14628032f, 0.06156550f, 0.17445672f, -0.08935819f, -0.00201754f, 0.14432900f, 
    0.24481873f, 0.07398895f, -0.26819962f, 0.14075576f, -0.06704456f, -0.60333425f, 0.20255750f, 0.17697924f, 
    -0.15469521f, 0.03882455f, 0.19802058f, -0.23449750f, -0.21308662f, -0.00862603f, 0.10729903f, 0.20535858f, 
    0.22899567f, 0.08980860f, -0.18291235f, -0.20496090f, -0.01058577f, -0.05783680f, 0.13869318f, 0.02298987f, 
    -0.18047608f, -0.41367131f, 0.15224040f, 0.03153624f, 0.22223383f, 0.44682458f, 0.37994340f, 0.05345531f, 
    0.22654158f, 0.18996891f, 0.22210081f, -0.04432056f, -0.13536474f, -0.07144668f, 0.22117807f, 0.10883304f, 
    0.10908418f, -0.23099488f, 0.24299173f, 0.27103359f, -0.20084213f, -0.10074772f, -0.05451714f, 0.43913051f, 
    0.02648685f, 0.14758097f, 0.02822600f, -0.01713457f, -0.16945979f, -0.04584093f, -0.12558034f, -0.16479962f, 
    0.16809130f, -0.10044485f, -0.09061614f, -0.11751924f, -0.03277607f, 0.07857447f, 0.02334906f, -0.02296559f, 
    -0.01365052f, -0.05668133f, -0.00520657f, 0.12324086f, 0.05656832f, -0.10424118f, -0.09454259f, 0.16611938f, 
    -0.07924648f, 0.09649359f, -0.13008964f, 0.08001231f, -0.08129874f, 0.15969810f, -0.02813405f, -0.02740348f, 
    -0.20896013f, -0.11636913f, -0.16223639f, 0.08920156f, -0.12647101f, 0.19362310f, 0.05060541f, -0.08763105f, 
    0.36101913f, -0.18903722f, 0.08250868f, 0.13807368f, -0.31274161f, 0.01607729f, -0.27694553f, -0.14619273f, 
    -0.09880237f, 0.09872963f, -0.06601829f, 0.02939511f, 0.12308913f, 0.31961638f, 0.18771891f, 0.14992894f, 
    0.05125612f, 0.21286188f, 0.38703629f, 0.17881538f, 0.24450704f, -0.00828186f, 0.08284055f, 0.03063230f, 
    0.41729593f, 0.13837236f, 0.24853969f, -0.30599800f, -0.20952480f, 0.21144260f, -0.30997917f, -0.01727558f, 
    -0.43183583f, 0.17421368f, -0.05949346f, 0.40351552f, 0.00393550f, 0.05923898f, 0.35451972f, -0.08105048f, 
    0.22709742f, 0.35221261f, 0.19879536f, 0.10070153f, 0.07544097f, 0.08235538f, -0.05075230f, 0.03772471f, 
    -0.16186619f, 0.24288285f, -0.09393088f, 0.00439760f, -0.19088466f, 0.15398826f, 0.03626797f, 0.02977694f, 
    0.39732715f, 0.04087888f, -0.03453235f, -0.24306427f, -0.20453155f, 0.06765562f, -0.41680327f, 0.17475989f, 
    0.12680596f, -0.01215263f, 0.08519138f, 0.50342160f, 0.00662704f, 0.12040545f, -0.54713738f, -0.02844848f, 
    0.05089056f, 0.17174964f, 0.06467712f, -0.03162285f, 0.11403308f, 0.21970351f, 0.10159609f, 0.11066374f, 
    -0.13680896f, 0.29358602f, 0.03654435f, 0.44702742f, 0.18667550f, 0.03764438f, 0.13093540f, -0.32286185f, 
    -0.11060915f, -0.06643658f, 0.07528913f, 0.13828234f, -0.08590186f, -0.15643768f, 0.08052605f, 0.06822974f, 
    -0.06657866f, 0.07837401f, -0.14380033f, -0.13980129f, -0.10909258f, 0.05009272f, -0.07583883f, 0.13555056f, 
    0.07703386f, -0.02052138f, -0.06791255f, -0.08396179f, -0.11614844f, -0.09441879f, -0.12538289f, -0.03873473f, 
    0.14819258f, -0.07955772f, -0.05226349f, 0.11469377f, 0.09847649f, 0.11964734f, -0.06807461f, -0.07481560f, 
    0.39337713f, 0.14192243f, 0.31077406f, -0.15604961f, 0.38624683f, 0.24766611f, 0.69868922f, 0.14718318f, 
    0.38398570f, -0.07610055f, 0.02779018f, -0.34584171f, 0.05345652f, -0.16225161f, -0.13357621f, 0.07743963f, 
    -0.35366929f, -0.03520278f, -0.40601933f, 0.03754475f, -0.05911443f, -0.15338923f, 0.03694436f, 0.09169987f, 
    -0.04406391f, 0.20143887f, 0.13909031f, 0.18379548f, 0.37837079f, 0.04731017f, -0.10335397f, -0.18619500f, 
    -0.10445055f, -0.12590215f, 0.06404137f, 0.38177425f, 0.29748511f, -0.18464428f, 0.02238921f, -0.16390291f, 
    -0.01904849f, 0.48239884f, -0.00824482f, 0.12143870f, -0.07382936f, -0.34578395f, 0.13263883f, -0.07561338f, 
    -0.10912917f, 0.03942257f, 0.12672593f, -0.00015299f, 0.13751793f, 0.42294109f, -0.00986377f, 0.16769297f, 
    -0.12504868f, -0.27865952f, -0.15435523f, 0.11603244f, 0.07766327f, 0.07908881f, 0.13717324f, -0.24388221f, 
    -0.36281973f, -0.12921859f, -0.09945406f, -0.03476298f, -0.06049919f, -0.01722525f, 0.07390492f, -0.18377760f, 
    0.19180642f, 0.10457523f, 0.14630975f, 0.12276724f, 0.26125059f, 0.56314266f, -0.09366237f, 0.16374502f, 
    -0.12769999f, -0.13522165f, -0.01846827f, -0.17417818f, -0.01586165f, 0.41201675f, -0.19993486f, -0.03515153f, 
    -0.15066232f, 0.01195074f, -0.08890227f, 0.59710336f, 0.22449490f, -0.17552850f, -0.00076598f, 0.02255484f, 
    0.16257942f, 0.10816111f, -0.31825355f, -0.04353015f, -0.25886145f, 0.21776223f, -0.07300097f, 0.00721824f, 
    -0.08677681f, -0.08512309f, 0.10899526f, 0.10352319f, 0.12200166f, 0.60193777f, 0.03691729f, -0.05345975f, 
    -0.26650837f, -0.08328663f, 0.29026011f, 0.09382650f, -0.14185479f, 0.53627074f, -0.23762167f, -0.02658268f, 
    -0.04376116f, 0.19138326f, 0.03628797f, 0.53759414f, 0.27704185f, 0.15199341f, -0.16814767f, 0.12310738f, 
    -0.31548119f, -0.12806775f, 0.03200266f, 0.09808552f, -0.09060457f, -0.02208441f, 0.51017696f, -0.09658553f, 
    -0.17418867f, -0.18364456f, 0.13840975f, 0.09143371f, -0.02079592f, 0.03144021f, 0.16608913f, 0.07586560f, 
    -0.02754797f, 0.27088556f, 0.16739465f, -0.16253424f, -0.11012386f, 0.31955996f, 0.04925067f, -0.11166117f, 
    0.16165017f, -0.48639461f, 0.35755271f, 0.42479107f, -0.23445114f, 0.02936539f, -0.13125545f, 0.21293926f, 
    0.14269225f, 0.04892760f, -0.17474258f, 0.28042257f, 0.31805062f, 0.15644924f, -0.29363653f, 0.10118575f, 
    -0.02319863f, -0.15725164f, -0.08077696f, 0.01675472f, 0.18853079f, 0.10366423f, -0.40138575f, -0.08625357f, 
    0.27755636f, -0.24456199f, 0.59659374f, 0.16017705f, 0.13557623f, -0.38496453f, 0.01720123f, -0.14323731f, 
    0.08024146f, -0.11494534f, -0.28875241f, -0.42890120f, 0.14470030f, -0.12609172f, 0.04790388f, 0.39482370f, 
    0.28686208f, 0.05246395f, 0.19754814f, 0.04042637f, 0.23810107f, 0.37642449f, -0.09772976f, 0.07372125f, 
    0.02434422f, -0.15164454f, -0.12516811f, 0.02777667f, -0.02759261f, -0.06355586f, -0.22617878f, -0.02022775f, 
    -0.05485557f, 0.23683198f, -0.54547679f, -0.02529844f, 0.08511132f, -0.29366916f, 0.19774726f, -0.11833820f, 
    0.08355869f, 0.40645447f, -0.24827391f, -0.14008069f, 0.15563607f, -0.15329714f, -0.15547344f, -0.08380280f, 
    0.08097181f, -0.14084564f, -0.08747705f, 0.19763285f, 0.09347224f, 0.19543678f, 0.16907071f, -0.06751014f, 
    0.52310175f, 0.37503245f, -0.12661561f, -0.19142121f, -0.25018948f, 0.45451653f, 0.16243759f, 0.08689100f, 
    -0.32538456f, -0.19027811f, -0.09277675f, -0.17502898f, 0.14338563f, -0.16999981f, -0.18805005f, -0.16120501f, 
    0.08409100f, 0.02612792f, 0.12857498f, 0.02886635f, 0.53702366f, 0.08991838f, 0.15001379f, -0.13290240f, 
    -0.10614902f, 0.15922138f, -0.16594496f, -0.11594366f, 0.02729631f, 0.07315982f, -0.05020161f, 0.05342166f, 
    0.08457260f, -0.04128241f, 0.04422526f, -0.18819691f, 0.10551491f, -0.01212432f, 0.09944522f, 0.10889302f, 
    0.04292138f, -0.12646477f, -0.16513957f, -0.08131561f, 0.02516110f, 0.06313926f, -0.14068985f, 0.14875075f, 
    0.13710801f, 0.09141699f, -0.03966157f, -0.08829398f, -0.12691601f, -0.17426336f, 0.11844694f, -0.13652387f, 
    0.28287077f, -0.11721797f, 0.00950846f, -0.22458944f, -0.12653905f, 0.16580348f, -0.33641806f, 0.09310485f, 
    0.29161519f, 0.08453249f, -0.16276148f, 0.46996364f, -0.10564491f, 0.28319529f, -0.05118798f, -0.02541657f, 
    -0.08870272f, 0.31037948f, -0.18065566f, -0.06215547f, 0.15937290f, -0.35035282f, 0.15204081f, -0.02398933f, 
    0.13869843f, 0.37560722f, 0.16216438f, 0.00302147f, -0.17998472f, 0.05282353f, 0.04499760f, -0.15556993f, 
    0.09216648f, -0.10948411f, 0.21759005f, 0.33047578f, 0.15006340f, 0.10031274f, -0.63631618f, 0.04044452f, 
    0.16751753f, 0.57033229f, 0.04181844f, -0.03878419f, -0.18380834f, -0.35626355f, 0.04305102f, 0.05919071f, 
    0.06279159f, -0.20979257f, 0.23330301f, 0.16351096f, 0.09607144f, 0.11334462f, 0.16698156f, 0.01160103f, 
    0.05172308f, 0.13482426f, -0.15820591f, -0.18036689f, 0.31578183f, 0.16915147f, -0.16230425f, -0.05716278f, 
    -0.44379401f, -0.07599962f, 0.05696622f, 0.21180521f, -0.09992035f, -0.15370937f, 0.42195874f, 0.15047011f, 
    -0.42127886f, -0.10373570f, 0.05141587f, 0.28542918f, 0.19609581f, -0.39418888f, -0.14172332f, -0.09259267f, 
    0.29027799f, 0.37976810f, 0.16180347f, 0.00951729f, 0.10110039f, 0.33106607f, 0.15001181f, 0.05243852f, 
    -0.10911459f, -0.15863529f, 0.35070151f, 0.07543439f, -0.21397807f, -0.15574481f, -0.07393993f, 0.29910684f, 
    0.13369983f, -0.05179008f, -0.29960483f, 0.04114986f, 0.26641977f, 0.40158528f, -0.31822255f, 0.13357659f, 
    0.30629027f, 0.01344092f, 0.03086667f, -0.12341444f, 0.14485739f, 0.22160789f, 0.15138920f, -0.16447283f, 
    -0.20899975f, -0.15538108f, -0.21685757f, 0.06919584f, -0.09590480f, 0.29152983f, -0.14143340f, -0.15443228f, 
    -0.17930765f, 0.27509093f, 0.05499490f, -0.18088146f, 0.42220119f, 0.05941438f, -0.08591904f, -0.13978085f, 
    0.12751019f, 0.01053983f, -0.09953611f, -0.02313207f, -0.19182928f, 0.02778686f, -0.05526275f, -0.00388304f, 
    -0.20234948f, 0.22903568f, -0.04913175f, -0.09345295f, 0.30476907f, 0.58971065f, 0.41634339f, -0.08959392f, 
    -0.03639983f, -0.22886950f, -0.07729331f, 0.10256928f, -0.10030207f, -0.02107115f, -0.23339078f, -0.10256434f, 
    0.05628818f, -0.37999812f, -0.01901309f, 0.26062036f, -0.17994460f, 0.03645597f, -0.00053778f, 0.39404777f, 
    -0.09842233f, -0.12378377f, 0.11744011f, -0.16962847f, -0.12995411f, 0.05355851f, 0.72379607f, -0.15979783f, 
    -0.06845930f, 0.06240543f, -0.11534439f, 0.14489725f, -0.20908247f, 0.13470426f, 0.21251908f, -0.15162706f, 
    -0.33605999f, 0.19974847f, -0.09798293f, -0.13091433f, -0.07865082f, 0.30556592f, -0.21853335f, 0.01897862f, 
    -0.00895387f, -0.39193642f, 0.32475555f, 0.68903363f, -0.05611312f, 0.01410627f, -0.06576889f, 0.21116373f, 
    0.23374332f, -0.10169155f, -0.09965183f, 0.16644485f, 0.21383984f, 0.05287205f, -0.38376981f, 0.08154285f, 
    0.41939723f, -0.32617778f, 0.18383637f, 0.15244566f, 0.39236903f, 0.15361358f, -0.05353214f, -0.09238556f, 
    -0.12569596f, -0.25605321f, 0.13226216f, 0.09022990f, 0.12745525f, 0.19667420f, 0.07406352f, 0.11208870f, 
    -0.06120008f, -0.53599179f, -0.23058473f, -0.19909422f, 0.18659931f, -0.08269651f, -0.15113358f, 0.02195856f, 
    0.44365710f, 0.02258828f, -0.09536228f, 0.06650762f, 0.24835962f, 0.33348665f, 0.09476239f, -0.09339079f, 
    -0.02173143f, -0.12967388f, 0.05745490f, -0.31391898f, 0.01296666f, 0.06367245f, 0.43065250f, 0.00714070f, 
    0.04166393f, -0.09179007f, -0.14816380f, -0.02691830f, 0.07422393f, -0.26620647f, -0.05378817f, -0.11810417f, 
    0.09456997f, 0.14301816f, 0.12973148f, -0.19780809f, 0.31880361f, -0.11418664f, -0.02164924f, 0.29982269f, 
    -0.19140863f, -0.17349829f, -0.10255180f, 0.13127685f, 0.02806157f, -0.06277294f, 0.14742289f, -0.05114727f, 
    -0.17882629f, -0.13688195f, 0.09303906f, -0.07348523f, -0.00796599f, -0.00291636f, -0.07347985f, 0.02928258f, 
    -0.12129997f, -0.12709290f, 0.09903173f, 0.15261962f, -0.14230953f, -0.02534756f, -0.11506201f, -0.08979528f, 
    -0.01616485f, -0.04986710f, -0.15771599f, 0.14523020f, -0.03534058f, 0.01613685f, 0.11721685f, -0.04933604f, 
    0.47259599f, -0.10351150f, -0.06430446f, -0.03299902f, 0.30085346f, 0.24573310f, 0.53807575f, -0.12316938f, 
    0.32804233f, -0.02908091f, -0.06216881f, -0.03596788f, -0.01357649f, 0.47355542f, -0.37765253f, -0.02367477f, 
    -0.31109831f, 0.01965077f, -0.18333192f, -0.04732160f, 0.02435369f, -0.43688664f, -0.00709919f, -0.02876906f, 
    -0.08012818f, 0.26938263f, 0.02293836f, 0.15876423f, 0.31961042f, 0.00515576f, 0.09538483f, 0.11766652f, 
    -0.21337558f, 0.00448415f, -0.04199028f, 0.20885098f, 0.04775841f, 0.22842069f, -0.24406135f, -0.14310974f, 
    -0.09659848f, 0.16553605f, 0.02324518f, 0.23592372f, -0.13370728f, -0.17233808f, -0.34371486f, 0.15764785f, 
    0.24463186f, -0.08171288f, 0.15972261f, 0.03998719f, -0.08377399f, 0.36012778f, -0.15573485f, -0.00138035f, 
    -0.00127173f, 0.36483485f, -0.07869397f, -0.04779023f, 0.36664605f, -0.11849513f, -0.06289884f, -0.10568243f, 
    0.25719774f, -0.07163510f, -0.27946872f, 0.27546129f, -0.07267360f, 0.29222178f, -0.52234817f, -0.09840043f, 
    -0.12955070f, 0.22983103f, 0.08755923f, -0.09481257f, 0.25517246f, 0.40676072f, 0.20653109f, -0.08581349f, 
    0.12530333f, -0.23283109f, 0.40094349f, -0.02475736f, 0.04714860f, -0.00650533f, -0.40757716f, -0.08181042f, 
    -0.17220661f, 0.08675156f, -0.04428181f, -0.21003191f, 0.35116640f, -0.00984248f, -0.08147327f, 0.15863530f, 
    -0.06992414f, -0.14430198f, 0.00042915f, -0.14001912f, -0.35994548f, -0.12555504f, -0.32217768f, 0.12594518f, 
    -0.05371401f, 0.08971190f, 0.07350155f, 0.13199817f, 0.13125145f, 0.10330322f, 0.47557575f, -0.10208511f, 
    0.34252095f, 0.23045363f, 0.45122391f, 0.00647567f, -0.10259333f, 0.16619438f, -0.02928322f, -0.04493009f, 
    0.08225332f, -0.01500689f, 0.28229094f, -0.17743585f, -0.07484813f, 0.03177620f, 0.05223837f, 0.18857448f, 
    0.19826813f, -0.11882374f, 0.12110381f, 0.39511764f, 0.20995122f, 0.35247806f, 0.49731800f, -0.16914849f, 
    -0.13546334f, 0.17507182f, -0.15001412f, -0.04544802f, -0.36928606f, -0.20006903f, 0.01955183f, 0.17738907f, 
    -0.29653803f, 0.16326307f, -0.24769233f, -0.15539800f, 0.07226949f, -0.20630127f, -0.05641423f, -0.05855719f, 
    0.04643381f, 0.38476786f, 0.32620120f, -0.07373831f, 0.21646142f, 0.11275098f, 0.15460730f, 0.19684584f, 
    -0.00469922f, 0.09930000f, 0.06826797f, -0.02631786f, -0.21593387f, -0.04006661f, -0.20969999f, -0.08194850f, 
    0.12037797f, -0.05818366f, -0.15827426f, -0.13637063f, -0.14526510f, 0.11884562f, 0.11498751f, 0.03887366f, 
    -0.07666078f, -0.03759611f, 0.08556988f, -0.04272449f, 0.03887025f, 0.04147831f, -0.01847337f, 0.06281031f, 
    -0.07256071f, -0.05071285f, 0.03566783f, -0.12979600f, -0.12125486f, -0.06044381f, -0.05303150f, -0.09126583f, 
    -0.09577212f, 0.14964858f, -0.04810901f, 0.27323192f, 0.06673209f, -0.10565894f, -0.36516160f, 0.09053800f, 
    -0.04864236f, 0.37624085f, -0.13886416f, -0.12957199f, 0.04929207f, 0.31801453f, 0.16972171f, -0.08905482f, 
    -0.14362602f, -0.07762222f, -0.06670044f, -0.06082918f, 0.12526850f, -0.11361048f, -0.17269346f, -0.17556475f, 
    0.12345185f, -0.21360394f, -0.45692128f, 0.03434308f, 0.17385921f, -0.02667507f, 0.07059494f, 0.28355670f, 
    -0.01995760f, 0.08877824f, 0.59326434f, 0.16866945f, 0.40662268f, -0.15252754f, 0.40924957f, -0.06292246f, 
    -0.44456702f, -0.20205426f, -0.11559255f, -0.14211071f, 0.30423400f, -0.48438299f, -0.17355388f, -0.07289978f, 
    0.10396434f, 0.32844147f, -0.22660621f, -0.04263691f, -0.16117579f, 0.13619323f, 0.13687944f, -0.07992802f, 
    -0.12651844f, -0.24316375f, -0.18077120f, -0.04297814f, -0.15928674f, -0.07089001f, 0.01804144f, 0.06001600f, 
    0.07498610f, 0.03086643f, 0.09901322f, 0.19982597f, -0.18539505f, 0.29670236f, 0.28841874f, -0.12889801f, 
    -0.46670237f, 0.01701832f, -0.14118098f, 0.02376757f, -0.11925857f, 0.04262979f, 0.25260454f, -0.11674795f, 
    -0.02600430f, 0.21495348f, 0.00788481f, 0.15727791f, 0.02423045f, -0.03614934f, -0.51689529f, 0.07766879f, 
    0.14529617f, -0.19444473f, 0.07861440f, -0.16918577f, 0.25903577f, 0.16217209f, 0.05478536f, 0.10696431f, 
    -0.09590008f, 0.08245044f, -0.13222426f, -0.16989981f, -0.19751878f, 0.03519421f, 0.09267121f, -0.01569791f, 
    -0.17621958f, 0.05557976f, 0.03096830f, -0.11767971f, -0.00781719f, -0.07531027f, -0.03173273f, -0.14600460f, 
    -0.02148930f, -0.02630015f, 0.03972305f, 0.11514260f, 0.10985896f, 0.10619154f, 0.10830119f, -0.07068677f, 
    0.09239101f, -0.18189423f, -0.16548346f, -0.12657207f, -0.07941343f, 0.01710062f, -0.15360038f, -0.11209612f, 
    0.05182220f, -0.10061661f, 0.17612666f, 0.00716993f, -0.17508593f, 0.02415433f, 0.06324307f, -0.04494771f, 
    -0.52138162f, 0.13708082f, 0.12122285f, 0.43950212f, 0.09995688f, 0.10784025f, 0.15107928f, -0.01183654f, 
    0.07064059f, 0.39539936f, 0.51551670f, 0.00038719f, 0.04242522f, 0.29957497f, -0.21157245f, 0.15724097f, 
    -0.03238710f, 0.30843782f, -0.06460854f, 0.34255162f, 0.06898353f, 0.03099865f, 0.12846898f, -0.01690111f, 
    0.00636350f, 0.00213694f, -0.06149684f, -0.04393839f, -0.12158541f, -0.15167309f, 0.11635190f, 0.15854537f, 
    0.17281540f, -0.09786160f, 0.06769018f, -0.07343953f, 0.04470786f, 0.11214368f, -0.07999797f, 0.14943096f, 
    -0.04743211f, -0.17042406f, -0.08360974f, -0.12880704f, 0.15646489f, -0.01971024f, -0.00388241f, -0.15929487f, 
    -0.17246822f, -0.13783929f, -0.06303532f, 0.14990325f, -0.04728736f, 0.02356770f, -0.01559452f, 0.02032834f, 
    -0.64614975f, -0.01485866f, 0.01637546f, -0.10109314f, -0.19066811f, -0.21743649f, -0.22599916f, 0.00584417f, 
    0.21702433f, 0.06583798f, 0.02298430f, 0.38543078f, 0.12248766f, 0.28811514f, -0.05229993f, -0.07338556f, 
    0.39705700f, -0.04508893f, 0.47293538f, -0.16392943f, -0.06575947f, 0.29649961f, 0.28525546f, 0.15378502f, 
    -0.12467790f, 0.03502123f, 0.45086378f, 0.10263724f, -0.26830068f, 0.08713089f, 0.13258569f, 0.01199659f, 
    -0.15689819f, -0.01452916f, -0.04344269f, 0.06071441f, -0.03382932f, -0.17719953f, -0.14816459f, -0.09657910f, 
    -0.07659695f, -0.13274519f, 0.14568830f, 0.10734426f, -0.10515399f, 0.13827550f, -0.10996454f, 0.16890098f, 
    -0.01824420f, -0.05582267f, -0.08325426f, 0.15182108f, 0.16953309f, -0.06153568f, -0.15022434f, 0.17368370f, 
    -0.06368700f, -0.02918072f, -0.09785799f, -0.09074714f, -0.04046811f, 0.09881782f, -0.08829135f, 0.10298405f, 
    0.07880197f, 0.06263927f, 0.08419640f, 0.32227555f, 0.46255738f, 0.12199925f, 0.41796008f, 0.12079470f, 
    -0.07003157f, 0.22598627f, 0.11813147f, -0.07741764f, 0.18785885f, -0.36361337f, -0.28545064f, -0.02283235f, 
    -0.03234608f, 0.07783376f, -0.04858601f, 0.12736480f, 0.10867812f, -0.30456859f, 0.13372466f, -0.08311450f, 
    0.14150329f, -0.40539566f, -0.14189146f, -0.26770017f, 0.03593307f, -0.09637605f, -0.12393135f, 0.18388341f, 
    -0.05093404f, -0.04065245f, -0.06122424f, 0.08585908f, -0.10082315f, -0.16460057f, 0.01219851f, -0.11707012f, 
    -0.13204740f, -0.06086453f, -0.11366527f, -0.17088963f, -0.09201475f, -0.07481959f, -0.18638074f, 0.05959116f, 
    -0.00377282f, 0.09104364f, -0.11060469f, 0.00722159f, -0.13601620f, 0.10937694f, 0.03560363f, -0.06629217f, 
    0.07745761f, -0.17548193f, -0.14958401f, -0.05587074f, -0.05569538f, -0.02707992f, -0.09461050f, 0.10878504f, 
    0.01622898f, 0.10681905f, -0.12995774f, -0.09087720f, -0.12572950f, -0.16152461f, 0.16110654f, 0.17033793f, 
    0.04070639f, 0.03486469f, 0.08875056f, -0.02957506f, 0.10039790f, 0.05404522f, -0.02019648f, 0.05221482f, 
    -0.03413753f, -0.06479845f, -0.10638228f, -0.03746270f, 0.00650107f, -0.17539524f, -0.13427581f, 0.07436780f, 
    -0.14441057f, -0.17341027f, 0.03444128f, 0.10138306f, 0.04235644f, -0.10053974f, 0.04562266f, -0.16214022f, 
    -0.39865410f, -0.11392376f, 0.56919509f, 0.46278834f, 0.22025284f, -0.09880523f, 0.14345060f, -0.14170417f, 
    -0.16672650f, 0.33364674f, -0.01551209f, -0.25769296f, 0.30118400f, 0.01878983f, -0.09417252f, -0.06577239f, 
    0.34304410f, -0.02175660f, 0.36753803f, -0.01076861f, -0.14984526f, -0.44438532f, -0.14701892f, 0.07563819f, 
    0.10113011f, -0.23469803f, -0.04424846f, -0.09230101f, -0.10721339f, -0.14728040f, -0.10041828f, 0.05146264f, 
    -0.01738140f, 0.08538912f, -0.06714478f, 0.03049022f, -0.19634143f, 0.10668240f, -0.08159657f, -0.08428185f, 
    0.00108984f, -0.19275978f, -0.10495530f, 0.01133261f, -0.13800475f, 0.00384665f, -0.16943759f, 0.15002778f, 
    0.10329968f, -0.09491423f, -0.00077441f, -0.11873394f, 0.00429818f, -0.07423853f, -0.03072157f, -0.03799897f, 
    0.11317589f, -0.02532045f, 0.05919299f, 0.04838924f, -0.19028236f, 0.12213387f, 0.14979449f, -0.03686122f, 
    0.40369561f, 0.17552033f, 0.15355644f, 0.16262756f, 0.27967623f, 0.24171242f, -0.03192693f, 0.06717739f, 
    0.14396667f, 0.34168097f, 0.13638103f, 0.21977167f, 0.14589676f, -0.04656212f, -0.35170051f, 0.10425233f, 
    -0.11066435f, -0.01135267f, -0.26093483f, -0.17694627f, -0.13666315f, -0.01971632f, -0.33222985f, -0.15821746f, 
    -0.03431393f, 0.27757490f, -0.27128252f, -0.05061783f, 0.28691044f, 0.03185461f, 0.03729912f, -0.33567759f, 
    0.14912583f, -0.15091647f, 0.13214463f, -0.26926771f, -0.12114944f, -0.09924859f, -0.12940213f, -0.05811990f, 
    0.26140130f, 0.00603484f, 0.10783782f, 0.36326420f, -0.17124844f, 0.07578228f, -0.10099897f, -0.06844712f, 
    0.04892877f, 0.06681287f, -0.03786968f, 0.16197240f, 0.02349032f, 0.11672180f, 0.47064811f, 0.06213092f, 
    0.01001903f, 0.50850093f, 0.19513784f, 0.15457976f, -0.27733997f, 0.14441666f, -0.07527962f, -0.04773556f, 
    -0.16128774f, -0.15847294f, 0.15842998f, -0.17967311f, -0.15059134f, -0.13798274f, -0.17131665f, -0.16490209f, 
    -0.11766219f, -0.10630086f, -0.03269244f, -0.09221330f, 0.15678708f, -0.08546067f, -0.08259225f, 0.08475170f, 
    0.10859555f, -0.11690529f, -0.07025856f, 0.11155429f, 0.05629950f, -0.00293005f, -0.07128707f, -0.06021561f, 
    0.09592319f, 0.07267445f, -0.01636934f, 0.04661658f, 0.01456171f, -0.11568928f, 0.15514937f, 0.11639775f, 
    0.01423911f, 0.00691365f, 0.13092811f, 0.08244391f, 0.28269979f, -0.22112374f, -0.39659294f, -0.01374986f, 
    0.41946936f, 0.27095819f, 0.00076320f, 0.30967054f, 0.31330216f, -0.02606420f, -0.28622106f, -0.08204532f, 
    0.24344383f, -0.04391449f, 0.33759061f, -0.03555998f, -0.05045796f, 0.14211059f, 0.46078384f, -0.03431121f, 
    -0.05755872f, -0.12382652f, -0.10521560f, -0.17751475f, -0.23081702f, 0.08983954f, -0.01551231f, -0.10601987f, 
    -0.51782799f, -0.00087911f, 0.27261835f, 0.08109709f, 0.18585914f, -0.03348136f, -0.27012759f, 0.11138166f, 
    0.11306540f, 0.22650038f, -0.06456714f, 0.09440593f, 0.31007794f, -0.18446103f, 0.03193180f, 0.05851745f, 
    0.17948142f, -0.10412378f, -0.09685372f, 0.12206608f, -0.11944586f, 0.09152736f, 0.09194641f, -0.13121684f, 
    -0.08214343f, 0.21911559f, 0.32826129f, -0.01074043f, -0.02867533f, -0.14546734f, 0.10836798f, -0.09309266f, 
    -0.38409898f, 0.08779886f, 0.36173788f, 0.04499205f, -0.02680254f, 0.05419123f, -0.20413800f, 0.14759296f, 
    0.10475630f, 0.32562658f, -0.04879395f, 0.32512918f, -0.00417523f, -0.03570605f, -0.45944411f, -0.01307949f, 
    0.38589936f, 0.04992314f, 0.19509462f, -0.10809787f, -0.08745149f, 0.34181103f, 0.15407668f, 0.01916995f, 
    -0.03847739f, 0.34635833f, -0.00957889f, 0.22114941f, -0.13183193f, 0.12200275f, 0.10268255f, -0.26164985f, 
    -0.01512415f, 0.17355236f, -0.08515426f, 0.14961597f, -0.03867801f, 0.23562649f, 0.16510245f, -0.14900905f, 
    0.29211068f, 0.08240246f, 0.07507412f, -0.37013534f, -0.14048888f, -0.17687909f, 0.53221798f, -0.09915025f, 
    -0.15339409f, -0.05917304f, -0.09929380f, -0.17485830f, -0.00755753f, 0.09130513f, -0.15426850f, -0.03818648f, 
    -0.04332222f, -0.22607873f, 0.39325610f, -0.08938560f, 0.20001368f, -0.16781175f, -0.00896782f, -0.18348898f, 
    -0.21230049f, 0.03535701f, 0.17891558f, 0.38870800f, 0.06488884f, 0.15879464f, 0.27109399f, -0.13569611f, 
    -0.13914405f, 0.30963218f, -0.11531021f, 0.10896032f, -0.43968898f, -0.03888465f, 0.18315148f, 0.02315654f, 
    -0.05998387f, 0.09125857f, 0.39839205f, 0.04712388f, 0.08312448f, -0.36273992f, -0.28144914f, -0.10774864f, 
    -0.13142022f, -0.08690128f, 0.26598209f, -0.14572577f, 0.26267120f, 0.15878746f, -0.13463742f, 0.22988600f, 
    0.06211910f, 0.12037603f, -0.02102683f, 0.13809638f, 0.01409063f, -0.07076877f, 0.67475039f, 0.15162365f, 
    0.33071509f, -0.17459908f, 0.03165669f, -0.10351815f, 0.27274278f, 0.06090768f, -0.74648774f, 0.13793619f, 
    -0.03264372f, -0.01674760f, 0.30940211f, 0.06629638f, 0.11559930f, -0.21664535f, 0.16293328f, 0.06038412f, 
    0.16114420f, -0.51451772f, 0.03813165f, 0.09504987f, -0.04050155f, 0.02535161f, -0.15654184f, 0.29475486f, 
    0.63177556f, 0.09392776f, 0.28422976f, -0.33410308f, -0.11850584f, 0.18568450f, 0.36173424f, 0.09741317f, 
    -0.18425989f, -0.29387847f, 0.07928625f, -0.07622930f, 0.08251554f, 0.47784087f, 0.40982676f, -0.15823348f, 
    0.00739794f, 0.32579902f, -0.01781961f, -0.05356420f, 0.17557764f, -0.25440082f, -0.01943357f, 0.07543875f, 
    -0.08622354f, -0.24621542f, -0.16185930f, 0.21333447f, -0.10054629f, -0.05309999f, 0.01504742f, 0.24085256f, 
    -0.24513933f, -0.02007786f, -0.27630219f, 0.42150128f, 0.39314401f, 0.01957467f, 0.10810049f, 0.09781995f, 
    0.37830928f, -0.08380986f, -0.16723375f, -0.21629076f, -0.06329162f, -0.00972776f, 0.04412955f, -0.07604870f, 
    0.17535409f, -0.24943019f, 0.44630104f, -0.07065028f, -0.02635755f, 0.39111251f, 0.12296436f, 0.07635313f, 
    -0.07207192f, -0.70310432f, -0.10863616f, 0.15763679f, 0.28225330f, 0.07409783f, -0.01200467f, 0.25518703f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19498736f, -0.06135251f, -0.05466760f, -0.18922098f, -0.01975748f, 0.07133250f, 0.20384070f, -0.17780562f, 
    0.37406075f, 0.08324526f, -0.01243461f, -0.09063439f, -0.00944548f, 0.04348917f, 0.13479435f, -0.11301563f, 
    -0.00548397f, 0.04579308f, -0.05063827f, 0.19234258f, -0.05888563f, 0.02899724f, 0.25548029f, 0.04769835f, 
    0.00409257f, 0.02690351f, 0.18771937f, -0.07864852f, -0.06435516f, -0.25915989f, -0.08722188f, 0.00395727f, 
    -0.00383307f, 0.09389262f, 0.23816149f, 0.00328636f, 0.08918749f, -0.00397148f, 0.16605449f, -0.10786399f, 
    0.06991026f, 0.07426903f, 0.14715603f, 0.08192183f, 0.13067831f, -0.02784124f, -0.02272021f, -0.11881168f, 
    0.18544996f, -0.07642616f, 0.06160313f, 0.06838952f, -0.17868587f, 0.11338432f, -0.06820974f, 0.15342681f, 
    0.06121043f, 0.08775034f, -0.07166711f, -0.05610165f, 0.26125130f, -0.01248783f, 0.10703818f, 0.10766997f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.20606311f, 0.08505613f, -0.04178060f, -0.65705574f, 0.24030195f, 0.16100124f, 0.08323208f, 0.27139282f, 
    -0.67127848f, 0.03275100f, 0.18774155f, 0.03797705f, -0.40632388f, 0.33003965f, 0.40867904f, 0.04054854f, 
    -0.22004160f, -0.23964261f, -0.37886852f, 0.17712075f, -0.35842577f, 0.37095320f, 0.09851369f, -0.10925593f, 
    -0.03839496f, 0.18724459f, -0.04186244f, -0.30830511f, 0.04992235f, 0.13880283f, -0.27468008f, 0.44119361f, 
    0.04064311f, 0.10554526f, 0.10899400f, -0.27551079f, 0.28382975f, 0.11078835f, -0.20785229f, 0.01804032f, 
    -0.43891433f, -0.52524698f, -0.10274374f, 0.08733572f, 0.13386555f, 0.07230308f, -0.35518566f, 0.01050384f, 
    -0.08362689f, 0.01786578f, -0.01617670f, -0.61190361f, 0.02891504f, 0.11776629f, 0.10237620f, -0.07154267f, 
    0.12818480f, -0.45337659f, -0.28446189f, -0.52835584f, -0.24678086f, 0.22255771f, 0.30482006f, -0.35389912f, 
    -0.24866261f, -0.03655193f, -0.12363917f, 0.44645774f, -0.31939816f, -0.52819926f, -0.26793489f, -0.02929784f, 
    -0.11093597f, -0.01336324f, -0.10345428f, -0.00045197f, 0.33217946f, -0.07122907f, 0.16476393f, 0.06969152f, 
    0.26216081f, -0.27639297f, 0.09040108f, 0.26437962f, -0.14866298f, -0.13446875f, 0.26444882f, 0.28059962f, 
    -0.07109776f, -0.00198636f, -0.09821619f, -0.23925802f, 0.36479968f, -0.32746315f, 0.05023341f, -0.27084327f, 
    0.21589535f, 0.05953716f, 0.26053756f, 0.23425740f, 0.08785994f, -0.37685522f, 0.30140579f, 0.11702622f, 
    -0.18025063f, -0.40207696f, 0.09679510f, -0.05950669f, 0.05733724f, 0.03122023f, -0.27335107f, 0.04396966f, 
    -0.12264547f, 0.08396946f, -0.10981851f, -0.81496811f, 0.03938529f, 0.31178749f, 0.07317788f, 0.07465381f, 
    -0.47978687f, -0.24657160f, -0.16755110f, 0.05435677f, 0.12759028f, -0.57107282f, -0.05860607f, -0.26028022f, 
    0.44366777f, -0.00159993f, -0.07593179f, -0.64820081f, -0.74103111f, 0.30306628f, -0.42286843f, -0.34585300f, 
    -0.10057138f, 0.13091464f, -0.48377210f, 0.00403804f, -0.02388991f, -0.02137270f, 0.09240158f, 0.03158490f, 
    0.25083256f, -0.07367067f, -0.76621819f, -0.54751319f, -0.67585838f, -0.09270576f, 0.15747339f, 0.14230405f, 
    -0.10059649f, 0.13023934f, 0.20396334f, -0.32897535f, -0.19248496f, -0.18375793f, -0.39523605f, -0.86488396f, 
    -0.00544797f, 0.03692324f, 0.19358535f, -0.16812721f, -0.24308717f, -0.17021504f, 0.22246324f, 0.03446319f, 
    0.13098104f, 0.01754857f, -0.26436940f, -0.06512701f, -0.04327742f, 0.00688399f, -0.02779160f, 0.00763060f, 
    -0.00310263f, 0.06181838f, -0.06510512f, 0.40215668f, -0.09933121f, 0.24066785f, 0.33825672f, -0.12164684f, 
    0.19966127f, 0.21164270f, 0.20210308f, -0.27130732f, 0.03981094f, -0.29054931f, -0.11016246f, -0.83339351f, 
    0.09365587f, -0.09751067f, -0.01957920f, 0.16996314f, 0.22264269f, 0.23866494f, -0.12258005f, 0.21939488f, 
    -0.71453148f, -0.47451591f, -0.23117772f, -0.09269281f, 0.20416640f, 0.13597499f, 0.36955601f, 0.08957332f, 
    -0.40384576f, 0.38173589f, -0.13481078f, 0.01793966f, 0.07913449f, -0.59797013f, -0.23184243f, -0.55547088f, 
    0.00834559f, -0.37863639f, 0.06726385f, 0.28799435f, -0.10431541f, -0.64768034f, 0.03317182f, 0.06800354f, 
    -0.54692292f, 0.05835363f, -0.64424956f, 0.20884672f, -0.31991428f, 0.10136164f, -0.19725318f, 0.06152570f, 
    -0.46492454f, 0.35462400f, -0.25316188f, 0.09447747f, 0.23061006f, -0.08634696f, 0.18343873f, -0.03497608f, 
    -0.27243763f, 0.08005146f, 0.05647093f, -0.29398701f, 0.02592362f, -0.10794886f, 0.30043516f, -0.08458130f, 
    0.20599455f, 0.10152887f, 0.25490507f, -0.10792646f, -0.36850864f, -0.59638202f, -0.48753318f, 0.05668886f, 
    0.40321633f, 0.05325318f, -0.07365309f, -0.44623169f, 0.32404846f, 0.23981988f, 0.32776520f, 0.09590524f, 
    -0.04889583f, 0.13451941f, 0.24800645f, 0.02587357f, 0.17047232f, 0.09041601f, -0.22396548f, 0.06299643f, 
    -0.39216325f, -0.25466451f, -0.32115865f, -0.16600500f, 0.25217968f, -0.41571155f, -0.18892059f, -0.22824118f, 
    0.05551336f, 0.17586839f, -0.18052442f, 0.25978237f, -0.25688508f, 0.15833460f, 0.00010342f, -0.42918414f, 
    -0.07885270f, 0.05417093f, -0.24228826f, -0.36584926f, -0.21880236f, 0.24613807f, 0.00425085f, 0.00418011f, 
    -0.12296548f, -0.35446692f, -0.12361016f, -0.10275383f, 0.05427064f, -0.04939743f, 0.46161535f, 0.07028346f, 
    -0.22531711f, 0.06309132f, 0.05753048f, -0.12443309f, 0.07073094f, -0.76861072f, 0.29903418f, 0.02233290f, 
    0.04737997f, 0.16217341f, -0.08639563f, 0.06520205f, 0.09399653f, -0.66379291f, -0.05836664f, -0.21921989f, 
    -0.67786217f, -0.01848303f, 0.06990523f, 0.22353861f, 0.08739157f, -0.30494294f, 0.14979832f, -0.31228784f, 
    0.65040261f, -0.20571360f, 0.13264148f, -0.09968309f, -0.27084446f, 0.07511824f, -0.71622229f, -0.01050936f, 
    -0.08333772f, 0.06359899f, -0.00864566f, 0.14428958f, 0.08702010f, 0.09785451f, -0.36587155f, 0.25648504f, 
    -0.02720289f, -0.49163568f, 0.02465155f, -0.09786198f, -0.00865187f, 0.55276585f, 0.19444433f, -0.08606049f, 
    0.21868353f, -0.08116787f, -0.13866349f, -0.12933925f, 0.33346036f, 0.23892319f, 0.08058317f, 0.05401881f, 
    0.66720670f, -0.22251160f, 0.27211031f, -0.07782143f, 0.15113480f, 0.10021132f, -0.36890826f, -0.04043387f, 
    -0.14334857f, -0.11647929f, -0.05189423f, 0.22156075f, 0.02666989f, -0.40690398f, -0.70650482f, 0.01507313f, 
    -0.61011970f, -0.29174557f, -0.60352135f, 0.51531917f, 0.22453128f, -0.28926301f, 0.23134860f, 0.18523006f, 
    -0.15729786f, -0.05367308f, 0.07681617f, -0.53985929f, 0.29957753f, -0.19662377f, 0.24152894f, 0.13594542f, 
    -0.75877607f, 0.08249548f, 0.03451764f, -0.03395601f, -0.45444122f, 0.14777309f, -0.47981805f, -0.08077799f, 
    0.25921372f, 0.05907644f, -0.77122563f, -0.46509433f, 0.16603430f, -0.59383303f, 0.18507525f, -0.23724772f, 
    0.02816938f, -0.08919831f, -0.20850810f, 0.20629576f, -0.45862165f, -0.23303562f, 0.26370862f, -0.47727287f, 
    -0.04571520f, -0.00535137f, 0.05046109f, -0.47464707f, -0.56639695f, -0.19419630f, 0.07014990f, 0.02328059f, 
    -0.14472829f, 0.87928855f, 0.12951818f, -0.01916574f, 0.10818817f, 0.00834252f, -0.69257915f, -0.01207353f, 
    0.26517230f, -0.12683065f, 0.08243841f, 0.27421427f, 0.05943264f, 0.11402017f, -0.10343955f, 0.00816303f, 
    -0.26206347f, -0.03160826f, -0.19641049f, -0.12548558f, -0.04251378f, 0.00354760f, 0.26134589f, -0.38928825f, 
    0.27444175f, 0.09620319f, 0.07279390f, 0.26009020f, -0.15961115f, 0.10601890f, -0.33454436f, 0.03930132f, 
    0.03259144f, -0.14536104f, 0.27745980f, -0.02026032f, -0.01354360f, -0.02132325f, 0.23203050f, 0.01995687f, 
    0.13460355f, -0.61986518f, 0.40433845f, 0.24766760f, 0.14033313f, -0.33422297f, -0.43854174f, -0.14147274f, 
    -0.06839243f, -0.15463036f, -0.60999674f, 0.04272681f, 0.05109446f, 0.32602870f, 0.15497686f, 0.20083940f, 
    -0.19109738f, 0.10310360f, -0.09014915f, -0.04773872f, 0.10530606f, 0.07149882f, -0.55565065f, -0.10564363f, 
    -0.14220728f, -0.56900191f, -0.20795825f, -0.05397456f, 0.09080936f, 0.10673829f, 0.24587099f, -0.01689470f, 
    -0.59947217f, 0.09319469f, 0.04346031f, 0.00795731f, -0.10282798f, -0.31918254f, 0.03128291f, -0.06902967f, 
    -0.03806672f, 0.15946545f, 0.02600876f, 0.11602585f, -0.61214262f, 0.58127487f, 0.04779156f, -0.14586480f, 
    0.05921148f, -0.11923274f, -0.11969025f, -0.01514238f, -0.23030129f, -0.25913778f, 0.08277915f, -0.35627395f, 
    0.02268727f, 0.13578065f, -0.24213584f, 0.01389968f, 0.11991183f, -0.74617308f, -0.41599727f, -0.01219432f, 
    0.30518302f, 0.21282235f, 0.18036030f, -0.27920240f, -0.31505266f, -0.07305507f, 0.00675425f, 0.39375055f, 
    -0.02751120f, -0.37235180f, 0.13752708f, -0.62023723f, 0.43542346f, -0.03341796f, -0.17335333f, 0.63555557f, 
    0.08813444f, 0.00467962f, 0.18234305f, -0.30424351f, -0.09935904f, -0.37345570f, -0.07309421f, -0.10440844f, 
    -0.03231267f, -0.08930650f, -0.39680973f, 0.04364191f, -0.59395528f, 0.01398596f, -0.12312479f, -0.03620520f, 
    0.18759511f, 0.04144599f, 0.11334556f, -0.18361330f, 0.01029299f, 0.08956999f, -0.26281625f, 0.00018116f, 
    0.30544415f, 0.18650997f, -0.40369400f, 0.44334769f, -0.21407761f, 0.13203838f, -0.33586800f, 0.53745896f, 
    0.07712981f, -0.07507604f, 0.04163730f, -0.23514114f, -0.08032763f, -0.15827654f, 0.23807181f, -0.15235218f, 
    0.66193271f, 0.06472063f, 0.23160012f, -0.06500794f, 0.13168088f, -0.33820325f, -0.16992588f, 0.06833819f, 
    0.08849467f, 0.00125811f, 0.29752484f, -0.00484463f, 0.33363342f, 0.19459774f, -0.23511423f, -0.05251970f, 
    -0.02799486f, -0.37159848f, -0.36630052f, 0.26526389f, -0.50061631f, 0.21114415f, 0.23218179f, -0.21142584f, 
    -0.14142956f, -0.00270277f, 0.17016500f, -0.53797543f, -0.48089871f, -0.23564553f, 0.03000732f, -0.02755168f, 
    -0.27870879f, 0.10000854f, -0.15011911f, -0.05683970f, 0.00042410f, -0.07656239f, 0.09646709f, -0.07224421f, 
    0.14901343f, -0.07806665f, 0.01949652f, 0.02493172f, -0.12959979f, -0.42257032f, -0.06002158f, 0.11933574f, 
    0.00715508f, -0.31819943f, -0.21845748f, -0.29030040f, 0.05416310f, 0.75125790f, 0.01339941f, 0.29277086f, 
    -0.10923277f, -0.02100119f, -0.01427025f, -0.31307840f, -0.44107261f, -0.12228947f, -0.62859368f, -0.16396497f, 
    -0.68047994f, -0.42665562f, -0.63096762f, 0.00477508f, 0.00689096f, -0.06125795f, 0.09374998f, 0.10726500f, 
    -0.16487552f, 0.38203934f, 0.08113514f, 0.03211846f, -0.03794248f, -0.28697839f, -0.28229558f, 0.30331853f, 
    0.00235273f, -0.01256085f, 0.19044113f, -0.02399011f, 0.00929456f, -0.15394540f, 0.02985577f, -0.22730891f, 
    -0.43853551f, -0.04262209f, -0.14049836f, 0.27080655f, 0.23069058f, -0.02879327f, -0.02797147f, -0.01052378f, 
    0.14393078f, -0.62800318f, 0.08876935f, 0.02919978f, 0.14656015f, -0.05159365f, 0.13033497f, -0.10056249f, 
    0.05911639f, 0.04145826f, 0.02431331f, 0.31016147f, 0.02537863f, 0.36887866f, -0.22623958f, -0.07268756f, 
    0.15883297f, 0.17591867f, 0.19470935f, 0.00682977f, 0.26293737f, -0.29112160f, -0.75714624f, 0.15152420f, 
    -0.20323813f, 0.11104161f, 0.00937848f, -0.14687772f, -0.05228949f, 0.28216869f, -0.07697606f, 0.28496045f, 
    -0.32174072f, 0.14101477f, -0.11767888f, -0.12066716f, -0.22830753f, -0.22945029f, -0.49785578f, -0.11794300f, 
    -0.25550646f, -0.00128659f, -0.54372448f, -0.31451043f, -0.12608045f, 0.61834961f, 0.00161589f, -0.29727203f, 
    -0.05744720f, -0.65725780f, 0.03255634f, 0.11995503f, 0.03867358f, -0.34299573f, -0.82139915f, 0.30103105f, 
    0.02278581f, -0.00745322f, -0.18728609f, 0.15191066f, 0.21609084f, -0.16678926f, -0.10750713f, 0.10935016f, 
    -0.06738335f, 0.49058390f, -0.10704125f, 0.10864022f, -0.02054475f, -0.01295883f, 0.04290695f, 0.00429969f, 
    0.21743336f, 0.05644329f, -0.09701394f, 0.41377062f, -0.03132132f, -0.01033233f, -0.59499717f, 0.05442555f, 
    0.23712301f, 0.20426053f, 0.01583129f, -0.31439039f, 0.02357330f, 0.05951281f, -0.39202860f, 0.32550564f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.14867856f, 0.11800948f, -0.06993499f, -0.03562169f, -0.03229669f, 0.14470351f, -0.04182531f, -0.21571665f, 
    -0.01640407f, -0.06649703f, -0.02029044f, 0.00143808f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
