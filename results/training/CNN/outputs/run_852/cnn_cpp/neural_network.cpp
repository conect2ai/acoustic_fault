#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.00902121f, -0.03878748f, -0.36347899f, 0.25952467f, 0.54022360f, -0.82896590f, 0.06401426f, 0.31269464f, 
    -0.49338889f, 0.40031669f, 0.29909000f, -0.07575697f, 0.21177484f, -0.18605110f, 0.27193674f, 0.39406872f, 
    0.24107368f, -0.09135731f, 0.00958619f, -0.12212832f, 0.21677771f, -0.15845107f, -0.22692545f, 0.11126618f, 
    0.43135571f, -0.48754171f, -0.09377628f, 0.00385336f, -0.68585145f, -0.58431816f, 0.58552736f, 0.47189596f, 
    0.34112224f, 0.13426854f, 0.46716413f, 0.20434666f, 0.01687969f, -0.19218495f, -0.00691495f, 0.09181291f, 
    0.21915616f, 0.11220341f, -0.00379977f, -0.09004658f, 0.07546630f, -0.19662298f, -0.08167992f, 0.13774866f, 
    -0.29269645f, 0.33233556f, -0.69417787f, -0.14523050f, -0.04146199f, -0.13866101f, -0.39662847f, 0.33164042f, 
    0.70551127f, -0.02251993f, 0.29558158f, 0.12417088f, 0.15592192f, -0.29559812f, -0.13889368f, -0.21000442f, 
    0.22545932f, 0.08929546f, -0.23757559f, -0.13769178f, -0.12831847f, 0.01307235f, 0.27713653f, 0.15746152f, 
    0.09358613f, 0.44703287f, 0.13191716f, -0.49911901f, 0.08528158f, 0.39780882f, 0.07742514f, 0.49218929f, 
    -1.08436108f, 0.44803843f, -0.27425185f, -0.61200970f, -0.56477094f, 0.34007975f, 0.14339399f, 0.13242568f, 
    -0.12460339f, 0.09680562f, -0.19366679f, 0.19048470f, 0.07313096f, 0.03784542f, -0.09405357f, 0.01120880f, 
    -0.07703628f, -0.04405706f, 0.17375435f, 0.10316092f, 0.14036815f, 0.74812979f, 0.73138660f, 0.40747008f, 
    0.49489912f, -0.59956926f, 0.39593568f, -0.18174659f, -0.70789093f, -0.20221838f, 0.34403843f, 0.16335720f, 
    0.06510438f, -0.01212642f, -0.05579321f, 0.09551245f, -0.05103854f, -0.20208707f, 0.12526208f, 0.19333662f, 
    0.11020859f, 0.12620947f, 0.13165863f, 0.07943360f, 0.12708150f, 0.10730731f, 0.82305217f, -0.11774518f, 
    -0.63189167f, 0.22793783f, -0.56473184f, -0.03918875f, 0.59153080f, 0.23002927f, -0.13893476f, -0.10159205f, 
    0.07990794f, 0.10863025f, -0.27951264f, -0.01944266f, 0.22686766f, 0.04803141f, -0.32613346f, -0.35467291f, 
    -0.32202312f, -0.42737252f, -0.13363329f, -0.12530927f, 0.11365496f, -0.08594880f, -0.15847121f, -0.12902558f, 
    -0.27033189f, -0.37205878f, 0.33041096f, -0.25975427f, -0.30221030f, -0.33604774f, 0.26810914f, -0.33496225f, 
    -0.36214212f, -0.28004399f, -0.25752065f, -0.16361891f, -0.33747742f, -0.02039578f, 0.46869415f, 0.01528387f, 
    -0.21767028f, -0.18605348f, 0.23319264f, -0.08640289f, 0.02828207f, 0.11193884f, -0.23369196f, 0.52591151f, 
    1.00971401f, -0.35671782f, -0.36024138f, -0.46943054f, -0.28657514f, -0.17459746f, -0.08448876f, -0.54209363f, 
    -0.14564429f, 0.23100796f, -0.12251408f, 0.11998910f, 0.30301934f, -0.15332775f, -0.00897381f, -0.05011908f, 
    -0.21154088f, -0.00047660f, 0.18906268f, 0.00858002f, 0.19580795f, 0.28631905f, -0.30515593f, 0.16566494f, 
    -0.31786379f, 0.07621770f, -0.00212529f, -0.39307395f, 0.54636061f, -0.46371302f, -0.30651662f, -0.21570267f, 
    -0.15154119f, -0.19416152f, 0.26932555f, 0.27414286f, -0.19179668f, 0.17059277f, 0.10439695f, 0.00422408f, 
    0.13999718f, -0.58362854f, 0.10652321f, 0.18344417f, 0.16335768f, 0.41696948f, 0.07659054f, 0.49632549f, 
    -0.09311386f, 0.02761307f, -0.22489898f, -0.42208695f, -0.12527636f, -0.40233800f, -0.30227634f, -0.19744159f, 
    0.03173267f, 0.39339423f, -0.59213895f, -0.43889952f, -0.29736570f, -0.17768349f, -0.13830328f, -0.42897055f, 
    -0.25552320f, 0.02826396f, -0.41805717f, 0.30519274f, 0.21152288f, -0.12379076f, 0.18732761f, 0.35393640f, 
    -0.13101935f, -0.05074881f, -0.30050868f, -0.09814982f, -0.11892808f, -0.62842339f, 0.35773703f, -0.03543139f, 
    0.29954568f, 0.13107108f, -0.36162341f, -0.55872869f, 0.11359952f, -0.22855771f, -0.04546760f, 0.37914807f, 
    -0.35872284f, -0.05081613f, 0.01778558f, -0.38208643f, -0.22010061f, 0.12354422f, 0.26843840f, -0.32584697f, 
    -0.10650320f, 0.12236538f, 0.20438533f, 0.93000120f, -0.06211981f, -0.21477965f, 0.81500798f, 0.16765077f, 
    -0.35078174f, 0.03639595f, 0.07679194f, -0.00825916f, 0.19478366f, -0.34443521f, -0.00646103f, 0.04208457f, 
    -0.15783747f, 0.04553909f, -0.23280960f, -0.22468746f, 0.30545980f, 0.16918093f, -0.01951267f, 0.30609956f, 
    -0.17119220f, -0.00525210f, -0.30302736f, -0.02084839f, -0.06102362f, 0.36991450f, 0.39773339f, 0.42856139f, 
    0.04981375f, -0.17438966f, 0.39372918f, -0.20321184f, 0.24735788f, 0.54930228f, 0.07739137f, -0.24217634f, 
    -0.24805264f, -0.45944506f, -0.50669557f, -0.00273979f, -0.41582718f, 0.02231060f, -0.13035275f, -0.20383871f, 
    0.22243610f, 0.26798987f, 0.13208619f, 0.25148621f, -0.42023098f, 0.03382017f, -0.59530962f, 0.48416865f, 
    0.35536891f, 0.31281424f, 0.60785699f, -0.06420641f, 0.26298580f, 0.28068727f, -0.08824368f, 0.21493791f, 
    -0.00494693f, -0.04356061f, 0.22761101f, -0.00140730f, 0.21383046f, 0.26552573f, 0.21197078f, -0.22773503f, 
    -0.23198043f, 0.05076380f, -0.12411825f, -0.20657514f, 0.08282120f, 0.28608814f, -0.29117253f, -0.64711750f, 
    0.35666493f, 0.61013627f, -0.34207165f, -0.33945766f, 0.42915636f, 0.33089826f, -0.28394857f, -0.26566786f, 
    0.27238676f, -0.28057006f, -0.29813021f, -0.25135732f, -0.41496480f, -0.17424855f, 0.25960228f, -0.16235782f, 
    -0.15878761f, -0.11373485f, -0.26691300f, 0.23026356f, -0.17457300f, -0.01245749f, -0.12462173f, 0.82825702f, 
    0.21003008f, -0.24272810f, 0.51504314f, 0.27093121f, -0.55960476f, -0.22041175f, 0.52639389f, -0.05205439f, 
    0.26019204f, -0.17410547f, 0.03726460f, 0.47049111f, -0.02923079f, 0.00177775f, -0.12703095f, -0.02986045f, 
    0.13100144f, 0.02700144f, 0.16209167f, -0.15735324f, 0.07176625f, -0.12559776f, 0.07887377f, -0.01566847f, 
    0.72247398f, 0.68561709f, 0.37350681f, 0.68575048f, 0.58686638f, 0.04598143f, 0.15807582f, -0.29642466f, 
    0.04839908f, -0.25479308f, 0.12158348f, -0.05232205f, -0.32561943f, 0.30711189f, 0.02374122f, -0.10195586f, 
    -0.09774859f, 0.25318190f, -0.10212064f, -0.14172202f, 0.02781709f, -0.11361436f, -0.22353178f, 0.19398071f, 
    0.32611096f, -0.71721363f, -0.31934240f, 0.14043376f, -0.22612587f, 0.44558108f, 0.34097910f, 0.04838200f, 
    -0.04448380f, -0.52622032f, -0.10484165f, -0.02254524f, -0.22714101f, 0.26681358f, 0.24844824f, -0.12808830f, 
    0.18289280f, -0.23348305f, -0.10856347f, -0.11040594f, 0.22379786f, -0.13946262f, -0.12005772f, 0.07752389f, 
    -0.32545266f, 0.18731150f, -0.45953724f, 0.05401792f, 0.57365185f, -0.33646199f, -0.21130954f, -0.57656807f, 
    0.11601394f, -0.40128011f, -0.52419722f, 0.19564183f, -0.33768335f, 0.30355507f, -0.13585106f, 0.26108861f, 
    -0.12890682f, 0.32164323f, -0.03204615f, 0.35424188f, -0.20828423f, -0.10252547f, -0.24279879f, 0.02246227f, 
    -0.19107477f, -0.23839954f, 0.23942411f, -0.43364337f, 0.48184580f, -0.47652608f, -0.38705280f, 0.06328285f, 
    -0.13792136f, -0.53972912f, -0.66936934f, -0.34781757f, -0.20157135f, -0.25090373f, -0.10966269f, 0.33311212f, 
    -0.22420380f, -0.11013137f, -0.25294411f, 0.22068956f, 0.17894103f, -0.08210562f, -0.12975259f, 0.04072658f, 
    -0.15718417f, 0.38549238f, -0.17295422f, -0.08598071f, 0.66427070f, -0.42416322f, -0.52642715f, -0.06411549f, 
    -0.14659138f, -0.26393932f, -0.61644363f, -0.04412097f, 0.16084662f, 0.08883045f, -0.24964975f, -0.24109128f, 
    -0.32242891f, -0.36473250f, -0.20661028f, 0.25050426f, -0.04797708f, -0.20695989f, 0.09709571f, -0.16596507f, 
    0.22149491f, -0.05976327f, 0.22110201f, 0.16339964f, 0.36741075f, 0.58667135f, 0.57697284f, 0.68713760f, 
    0.42591572f, -0.00396749f, -0.31649935f, 0.11707604f, -0.20356151f, 0.19721720f, 0.33251640f, 0.46951321f, 
    0.11280354f, -0.20427136f, -0.22156571f, -0.48896539f, -0.18003576f, -0.27652550f, 0.14500146f, -0.21483818f, 
    -0.26553839f, -0.29190642f, 0.19426076f, 0.06346174f, 0.02061855f, -0.19987170f, 0.48967370f, 0.28969866f, 
    0.59601015f, 0.69916546f, -0.26060745f, -0.20158882f, -0.20713022f, -0.05905075f, 0.09060180f, 0.18319227f, 
    -0.14855845f, -0.13850382f, -0.19049849f, -0.20136383f, 0.23999339f, -0.24903356f, -0.25978735f, 0.13947996f, 
    -0.08929186f, 0.10660642f, 0.32991725f, 0.26602972f, 0.11176682f, 0.39179093f, 0.06397452f, -0.66353154f, 
    -0.20435469f, -0.31601074f, -0.34154373f, -0.14563604f, -0.25441292f, 0.51848340f, 0.58864397f, 0.39697272f, 
    0.35905817f, -0.11463664f, -0.12722042f, -0.06296915f, -0.28115034f, 0.21533096f, 0.26340279f, -0.14377698f, 
    0.01709667f, -0.01422864f, -0.13041975f, -0.26271328f, -0.02011917f, 0.06545758f, 0.04240171f, 0.35029715f, 
    0.34856179f, -0.32060170f, -0.58813673f, -0.76824993f, -0.49184349f, 0.38351530f, 0.15829457f, 0.37134153f, 
    0.45178437f, 0.27566853f, -0.03476438f, -0.11715832f, -0.42422104f, 0.02675900f, -0.06443684f, 0.11007518f, 
    0.13157038f, 0.02583113f, 0.17287210f, 0.28519076f, 0.06238596f, -0.08300333f, -0.17864469f, -0.16212553f, 
    -0.01112722f, 0.84438384f, 0.51493895f, 0.38147977f, -0.17334200f, 0.06050809f, 0.19760531f, 0.05582570f, 
    -0.02457131f, -0.14520323f, 0.29358310f, -0.43345243f, 0.26877353f, -0.04893146f, 0.10908911f, -0.04016252f, 
    -0.17124312f, 0.14979601f, -0.07192351f, 0.32325104f, 0.31689408f, -0.21380767f, -0.05786928f, -0.19622533f, 
    -0.30997223f, 0.03899025f, 0.29642969f, 0.58773351f, -0.84671706f, 0.57982260f, -0.85573328f, 0.36179528f, 
    -0.21792486f, -0.23484033f, 0.02254870f, -0.14869145f, 0.22027536f, 0.32786000f, 0.10445413f, 0.19094482f, 
    -0.03444879f, 0.15697898f, 0.01996173f, 0.22278416f, 0.21603145f, -0.01979817f, -0.22876652f, 0.23632953f, 
    0.05307988f, -0.13341475f, -0.13825488f, -1.19284999f, 0.52366585f, 0.10495321f, -0.56549251f, -0.10235085f, 
    0.54060173f, 0.53610408f, -0.14031716f, 0.13161275f, 0.29401639f, 0.00961917f, -0.08477909f, 0.33264259f, 
    -0.25049093f, -0.03979740f, -0.16473669f, -0.13417824f, -0.10335418f, -0.08832280f, -0.35346842f, -0.15844980f, 
    0.07138935f, 0.15190983f, 0.17705654f, -0.12044267f, -0.46604958f, -0.68979818f, -0.60274249f, -0.33652985f, 
    0.00569901f, -0.17470872f, -0.27784020f, -0.12652345f, 0.04360034f, 0.42849615f, 0.01143754f, 0.10332128f, 
    -0.26717654f, 0.09971101f, 0.11599784f, 0.17285793f, 0.19805461f, -0.34117129f, 0.29127252f, 0.11533073f, 
    0.08720351f, -0.24153848f, 0.57336807f, 0.17143258f, -0.07066172f, 0.03711962f, 0.27792740f, -0.14338371f, 
    -0.09760616f, 0.17793745f, -0.34851676f, 0.51058632f, 0.64056295f, 0.21620519f, 0.57313693f, -0.47707549f, 
    0.20286588f, 0.05010517f, -0.52591139f, 0.13918167f, -0.25089160f, -0.35022295f, -0.10909531f, -0.08256231f, 
    -0.11644743f, 0.01899615f, 0.22758614f, -0.06342769f, -0.05014159f, -0.06331044f, -0.09705733f, -0.97232711f, 
    -0.39841473f, 0.48353764f, -0.39275515f, -0.52537996f, 0.31883350f, 0.19679093f, -0.08563671f, 0.22674190f, 
    0.45481870f, 0.33513722f, -0.13671091f, 0.29051843f, -0.14338811f, 0.03054877f, -0.15972449f, 0.20446907f, 
    0.21879706f, -0.05186933f, 0.10393409f, -0.16918948f, 0.30357578f, -0.07823648f, -0.23306143f, -0.31872666f, 
    0.88277400f, 0.36649722f, 0.45588490f, 0.07461158f, 0.66792631f, -0.47399333f, -0.82187134f, -0.15449429f, 
    -0.51059014f, 0.10018411f, 0.04238930f, -0.18133415f, 0.15219140f, -0.24294630f, 0.12562668f, -0.00072653f, 
    0.15560542f, 0.03160315f, 0.06821986f, -0.05967827f, -0.33956972f, -0.05015304f, -0.13718237f, 0.06727133f, 
    0.47479922f, 0.42270494f, 0.68785989f, 0.83848381f, 0.11796063f, 0.03756301f, 0.06681206f, -0.30369166f, 
    0.47063649f, -0.01608279f, -0.32975501f, 0.10998221f, -0.01697200f, 0.32038847f, -0.25691324f, 0.27666110f, 
    0.25312275f, -0.31403866f, -0.21466814f, 0.18223223f, -0.24001940f, 0.14025696f, -0.14901692f, -0.11533419f, 
    -0.37332025f, 0.11972289f, -0.55307662f, -0.62447351f, -0.66896987f, 0.14055665f, 0.43704250f, -0.39843705f, 
    0.54750371f, 0.20706353f, 0.28688803f, -0.47110799f, -0.15428904f, -0.25727472f, -0.15032294f, -0.37479463f, 
    -0.12203027f, 0.02260892f, 0.15407354f, -0.01977173f, 0.05081100f, -0.37855789f, -0.02877812f, -0.37740889f, 
    0.14237216f, 0.07286509f, -0.52161026f, -0.54784906f, -0.40919036f, -0.41695660f, -0.06234043f, 0.29948136f, 
    -0.51759148f, -0.28385824f, -0.01842490f, -0.32389164f, -0.42612475f, 0.23489712f, 0.11906715f, 0.28019270f, 
    0.12994389f, 0.06274199f, -0.07001656f, -0.23075758f, 0.01187043f, 0.04769276f, 0.29018027f, 0.09934120f, 
    -0.26620555f, 0.00600221f, 0.17503588f, -0.34093490f, -0.97788423f, -0.58503008f, -0.21570513f, 0.06798809f, 
    -0.59537357f, 0.54146606f, 0.56535912f, -0.48806506f, 0.00970074f, 0.05285283f, 0.24111564f, 0.09591791f, 
    -0.09362007f, -0.12005926f, -0.10135207f, -0.18329117f, -0.21331896f, -0.04318945f, 0.11366824f, -0.06873414f, 
    -0.08864071f, 0.08309374f, 0.01949010f, -0.02424166f, -0.49885586f, 0.62140888f, 0.91052067f, 0.42492297f, 
    -0.14697412f, -0.15589379f, 0.44123033f, 0.28401127f, 0.40499827f, -0.00088387f, -0.47560072f, 0.03134802f, 
    0.05860620f, 0.03441019f, 0.15844131f, -0.23221630f, 0.00290099f, 0.19873950f, -0.03945396f, 0.06083304f, 
    -0.27179307f, 0.32340723f, -0.24199203f, -0.00549246f, 0.03353248f, 0.02294413f, -0.19112402f, -0.14111055f, 
    0.44724119f, -0.38821438f, 0.03056487f, 0.57339412f, 0.08060408f, 0.42048720f, 0.37107769f, 0.19140515f, 
    -0.09790366f, -0.35610434f, -0.44809973f, -0.22358781f, 0.20029423f, -0.59976274f, -0.25628996f, -0.00924725f, 
    0.09494884f, -0.02792930f, -0.14573917f, 0.39585251f, -0.05923172f, -0.33956003f, 0.77169651f, -0.65197432f, 
    0.09738412f, 0.31684396f, -0.23536660f, 0.63177103f, 0.49449432f, 0.37702140f, 0.52117419f, 0.14080100f, 
    -0.28785530f, 0.04145058f, -0.38498321f, 0.23151462f, 0.02422206f, 0.08915160f, -0.34284601f, 0.00398320f, 
    0.20485860f, 0.06259820f, -0.02612136f, -0.00323209f, -0.01609019f, 0.01857049f, -0.15143062f, -0.04729705f, 
    -0.27639663f, 0.12543286f, 0.12828314f, 0.46734896f, -0.08861692f, -0.09407113f, -0.79158401f, -0.58535588f, 
    0.04826050f, -0.19544089f, 0.57495892f, 0.15274923f, 0.16849315f, 0.29329073f, 0.21735407f, 0.21209323f, 
    0.36192045f, 0.21665910f, -0.34122732f, -0.05258143f, -0.24268188f, -0.15733077f, -0.24795361f, -0.22530150f, 
    0.30248296f, -0.05493797f, -0.50756812f, 0.36662579f, 0.07913750f, 0.14146392f, -0.33009216f, 0.53092450f, 
    -0.16828133f, 0.27207395f, 0.01768039f, -0.20268597f, -0.35021091f, 0.14942273f, 0.32247931f, -0.02543974f, 
    0.24069415f, -0.32998809f, -0.16084436f, 0.33857125f, 0.16524477f, 0.41304332f, 0.33562973f, -0.23355263f, 
    -0.18458819f, -0.67635655f, -0.33589378f, -0.27946475f, -0.07443930f, 0.11205100f, 0.05121975f, -0.22129537f, 
    0.02182441f, 0.55667454f, -0.21435946f, 0.01432515f, 0.04654472f, -0.11600820f, 0.30665183f, -0.24978819f, 
    0.24410403f, -0.06000488f, -0.24679402f, -0.33018896f, -0.32549250f, -0.09615923f, 0.00693735f, 0.05738370f, 
    0.06012125f, -0.06438051f, -0.80510902f, -0.40562963f, 0.21523510f, 0.30715722f, 0.41960868f, 0.29847538f, 
    0.48104531f, 0.43913487f, -0.06254768f, 0.38113078f, -0.03158778f, 0.21365003f, 0.19433919f, 0.27585912f, 
    0.24801992f, 0.11560402f, 0.21581674f, -0.11735656f, -0.06304774f, 0.10647472f, -0.23922347f, -0.31242707f, 
    0.15447162f, -0.33605540f, -0.24667923f, -0.13790523f, 0.27057496f, -0.20177047f, 0.51972920f, 0.43319511f, 
    0.26757112f, -0.22624420f, 0.01188706f, 0.07528406f, -0.37679753f, -0.30830592f, -0.40760243f, 0.10730880f, 
    -0.20068190f, 0.41515115f, 0.08171573f, 0.00673222f, -0.05956792f, 0.29908538f, 0.28359771f, 0.32691762f, 
    0.18524323f, 0.15259343f, 0.35245189f, 0.40381470f, 0.01257704f, -0.51858485f, -0.42337936f, -0.41903523f, 
    -0.18410298f, -0.14742683f, 0.01241748f, -0.40145776f, 0.09313592f, 0.00770839f, -0.43609574f, -0.03914196f, 
    0.41534436f, 0.03850327f, -0.13282125f, -0.08104064f, 0.38368046f, 0.39613670f, 0.21636516f, -0.16483825f, 
    -0.23214336f, -0.19340563f, -0.07427838f, 0.05919918f, 0.19632767f, -0.30697644f, -0.71268427f, -0.35164407f, 
    -0.01272453f, -0.66125250f, 0.12129965f, 0.60883898f, 0.34663409f, -0.25338903f, 0.39662141f, -0.35821807f, 
    -0.03685074f, -0.23404513f, -0.33296600f, -0.03712669f, -0.18173757f, 0.02121884f, 0.03665175f, -0.12202857f, 
    0.02927301f, 0.05397264f, -0.02487535f, 0.19862725f, 0.14951225f, -0.12411131f, 0.19266155f, 0.78009903f, 
    0.14996487f, 0.43309966f, -0.56700075f, -0.35317683f, 0.34543517f, -0.49016112f, 0.21372326f, -0.21726018f, 
    0.38176617f, 0.00352107f, -0.00691632f, -0.30311748f, -0.00951828f, -0.01612223f, 0.20017883f, 0.03206457f, 
    0.13937210f, 0.10041345f, -0.33545223f, -0.31910327f, -0.32788056f, -0.19845837f, -0.09861396f, -0.48849773f, 
    0.89785564f, -0.11942443f, -0.22969265f, 0.12656279f, -0.35434753f, 0.41322234f, 0.36590332f, 0.03177804f, 
    -0.57536918f, -0.14261037f, -0.43971139f, -0.00946318f, 0.10321943f, 0.47107071f, 0.18237300f, 0.16701527f, 
    0.11080655f, 0.18973549f, -0.11367889f, 0.25233272f, -0.19148120f, -0.17334673f, 0.24138571f, 0.20083268f, 
    -0.21242772f, -0.52819479f, 0.52823526f, 0.49684536f, -0.36831552f, -0.43449080f, -0.59996963f, 0.10938891f, 
    0.15470378f, -0.57699168f, 0.52061683f, -0.01814507f, -0.05253975f, 0.12228060f, 0.31411406f, 0.02830873f, 
    0.33527038f, 0.27790883f, -0.00080560f, 0.35584712f, -0.04186089f, -0.16257927f, 0.12994207f, -0.06893899f, 
    0.18053223f, 0.16456752f, -0.00064341f, -0.63764846f, -0.53073794f, -0.36811116f, 0.50215304f, 0.10676440f, 
    0.19360101f, -0.14634119f, -0.31822422f, 0.18092491f, -0.28251007f, 0.48417154f, 0.29218939f, 0.02825315f, 
    -0.15326641f, -0.20941153f, -0.25525865f, 0.12474933f, 0.15899970f, 0.04301558f, 0.19330861f, -0.26020595f, 
    0.02844959f, 0.04406476f, 0.75055504f, 0.54915994f, -0.23118959f, -0.56846833f, -0.78229392f, -0.17872396f, 
    0.13242273f, 0.22498903f, -0.00975401f, 0.31574491f, 0.43435127f, 0.25491127f, 0.01470192f, 0.04363534f, 
    -0.16929603f, 0.34030062f, 0.03012970f, 0.07059541f, -0.14071226f, 0.14157590f, -0.06852354f, 0.10669164f, 
    0.25528568f, 0.02839758f, 0.08043990f, 0.57557172f, 0.42717832f, 0.57334024f, -0.19181418f, 0.56429935f, 
    0.58708328f, 0.19305730f, -0.45688888f, -0.07613223f, 0.06321070f, 0.12228278f, 0.56711310f, 0.08304102f, 
    0.22409904f, -0.25682250f, -0.23159735f, -0.02025710f, -0.21656612f, -0.19492634f, -0.05947557f, 0.10581426f, 
    -0.24583621f, -0.05641145f, -0.28268641f, 0.03708985f, 0.54378271f, 0.01252470f, -0.37541720f, -0.52034527f, 
    -0.75775826f, -0.07843871f, 0.08216278f, 0.20834698f, 0.40646681f, 0.52508819f, 0.30534202f, -0.09945773f, 
    -0.17858313f, 0.07780355f, 0.41624680f, -0.08906991f, -0.14132679f, -0.13247678f, -0.13205983f, 0.30743653f, 
    0.00791654f, 0.24612434f, -0.13355571f, 0.21774761f, -0.22587593f, -0.30409324f, 0.67799658f, 0.28777963f, 
    0.08287980f, 0.23218846f, -0.43929741f, 0.78206819f, -0.21208104f, 0.07713047f, 0.50390542f, -0.07201122f, 
    0.08072387f, 0.17205799f, 0.10352214f, 0.04956717f, 0.10478240f, 0.05393616f, 0.02934978f, 0.22737245f, 
    0.11918155f, 0.06415801f, 0.12964158f, 0.38575166f, 0.14280668f, -0.12856582f, -0.64882952f, -0.92011732f, 
    0.62033516f, 0.63516176f, -0.60306835f, 0.41377524f, -0.18924987f, 0.34372380f, 0.14474277f, -0.04813606f, 
    -0.05181108f, -0.38333541f, -0.06713070f, 0.36753494f, -0.04959876f, 0.28776830f, 0.34958822f, -0.08134889f, 
    -0.15748002f, -0.32086581f, 0.16148613f, 0.11605439f, 0.09494080f, -0.19997059f, -0.02438535f, 0.64759880f, 
    0.37700823f, 0.03105575f, 0.55441749f, 0.21374871f, 0.26891696f, 0.25340325f, 0.31341881f, 0.55890679f, 
    0.15362695f, -0.00496092f, -0.29270995f, 0.14101416f, -0.37906992f, 0.11231487f, 0.11720326f, -0.04606161f, 
    -0.28668550f, -0.24001253f, -0.14869457f, -0.04259738f, -0.26837048f, 0.01088382f, -0.27087203f, -0.05317974f, 
    0.04409193f, -0.40794039f, -0.42789102f, -0.37122837f, 0.06034291f, 0.26983470f, -0.35765487f, -0.30380067f, 
    0.30767429f, -0.39516011f, -0.21094634f, -0.13328093f, -0.16240680f, -0.21986134f, -0.14257172f, -0.01013584f, 
    0.31471586f, -0.24386898f, 0.26688328f, -0.36028191f, 0.13052444f, -0.19094285f, 0.15639713f, 0.39573270f, 
    0.36626601f, -0.59941560f, -0.42584857f, -0.69281262f, -0.36872512f, 0.29638761f, -0.15333647f, -0.06830881f, 
    0.44900757f, -0.11672276f, 0.52031481f, 0.33938992f, -0.22296998f, 0.28157243f, -0.40287414f, -0.11551282f, 
    -0.17853855f, 0.21503876f, 0.22744316f, -0.14107737f, -0.43228179f, -0.00296910f, -0.17821674f, -0.17248732f, 
    0.02146110f, -0.08030608f, 0.45054168f, 0.23762353f, -0.81795728f, 0.23408249f, 0.04339934f, -0.48357391f, 
    -0.02211623f, 0.38766572f, 0.39546269f, -0.44704112f, -0.35594705f, -0.18422364f, 0.11762645f, -0.09973443f, 
    -0.02122525f, 0.00705944f, 0.09099345f, -0.29823205f, -0.06578679f, 0.26324517f, 0.07670433f, -0.02052216f, 
    0.29845664f, -0.15317301f, -0.34879532f, -0.40885624f, -0.07553462f, 0.10013811f, -0.27270564f, 0.18653497f, 
    0.19876900f, -0.34958050f, 0.61364806f, -0.44781446f, -0.45928600f, -0.04296855f, -0.27367988f, 0.02157497f, 
    0.11368679f, -0.12853074f, 0.17600623f, 0.39032876f, -0.32205445f, -0.27005640f, 0.50821716f, -0.12925094f, 
    -0.17524777f, 0.36393210f, 0.35422722f, -0.48445916f, 0.09330562f, -0.39604998f, -0.64530671f, -0.53888416f, 
    0.36229709f, 0.17033932f, -0.64423364f, 0.07185464f, 0.33902669f, -0.21318920f, -0.44811258f, 0.01225470f, 
    0.43433324f, -0.08783141f, -0.24589057f, 0.43013486f, -0.43042317f, 0.28493962f, 0.13200568f, -0.01016448f, 
    -0.17906579f, -0.16716421f, 0.17212167f, -0.07287654f, -0.11905190f, 0.03338068f, 0.26484105f, -0.11206520f, 
    0.51642215f, -0.34638479f, -0.17305245f, -0.24919721f, -0.34107837f, -0.37307465f, 0.36980450f, 0.46296206f, 
    0.39374653f, 0.16055678f, 0.28213763f, -0.09063254f, 0.12671274f, 0.21205144f, 0.26403913f, -0.12230818f, 
    0.49047148f, -0.04966735f, -0.26860577f, 0.23362127f, 0.45759434f, -0.04796693f, 0.47259775f, 0.33291176f, 
    0.47833288f, 0.77782148f, 0.75800121f, -0.02294534f, -0.32129309f, -0.20957491f, -0.09312431f, -0.41245905f, 
    0.04113598f, 0.28955880f, -0.00352456f, 0.02382535f, -0.08346030f, 0.20973229f, -0.03786129f, 0.37621164f, 
    0.02023390f, -0.00315326f, -0.17217791f, 0.30207229f, -0.15869875f, -0.16096216f, -0.04200630f, 0.70719701f, 
    0.33597001f, 0.09339120f, -0.04970407f, 0.62168050f, 0.27979439f, -0.79406393f, -0.55171543f, -0.61617988f, 
    -0.39401659f, 0.06655794f, 0.42186639f, 0.06026236f, 0.23995002f, -0.22020404f, 0.24751545f, -0.00069343f, 
    -0.26646256f, 0.01221347f, 0.07847573f, 0.08987503f, 0.30818951f, 0.24328201f, 0.06518798f, 0.30716863f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04329886f, -0.06861544f, 0.01026939f, 0.11963027f, -0.01322643f, 0.06593261f, 0.14058423f, 0.04967088f, 
    0.06293689f, -0.02466203f, 0.09679572f, 0.17397158f, -0.14652061f, 0.11899870f, 0.12891790f, 0.10720392f, 
    0.10933238f, 0.05908450f, 0.15880370f, 0.15086007f, -0.01994150f, 0.17023502f, 0.25492910f, 0.18706307f, 
    0.22897033f, 0.14554940f, -0.03616032f, -0.07071191f, 0.04946175f, -0.10403622f, 0.09529508f, 0.20802733f, 
    0.11157155f, 0.01531367f, 0.04500784f, 0.04989919f, 0.28438190f, 0.00723257f, 0.09777164f, 0.25871766f, 
    0.15935345f, 0.06391192f, 0.03813459f, 0.15214603f, 0.07496770f, 0.17280956f, 0.08635859f, -0.02282462f, 
    0.27476829f, 0.11773425f, 0.02248377f, 0.13377449f, 0.14632940f, 0.22476117f, 0.05093621f, -0.04166802f, 
    0.21178553f, 0.02330636f, -0.01353648f, -0.01165830f, 0.33297074f, 0.02745398f, -0.02096341f, 0.19843072f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18907753f, 0.19649206f, -0.05611077f, -0.17956929f, 0.14531761f, 0.07823625f, 0.02995301f, 0.10374178f, 
    -0.07123427f, -0.02460844f, -0.00631744f, 0.05853509f, -0.11388770f, 0.02307646f, -0.01774427f, 0.10608917f, 
    -0.05938352f, 0.04372442f, 0.00143807f, -0.04566635f, 0.04332499f, -0.05035203f, 0.00106477f, -0.15439278f, 
    -0.06521745f, -0.07949120f, 0.01220717f, 0.05835906f, 0.02725192f, 0.03313534f, 0.00018206f, -0.01906966f, 
    0.01280368f, 0.12961878f, 0.05854222f, -0.00080143f, 0.29556477f, -0.01548397f, -0.10508958f, 0.08143193f, 
    -0.03613808f, 0.06343389f, 0.07930759f, 0.09529076f, -0.01655766f, 0.04691958f, 0.06939480f, 0.03827901f, 
    0.32866624f, -0.18323851f, -0.21833369f, -0.07555391f, 0.14063562f, 0.05534015f, -0.04145909f, 0.00965730f, 
    -0.03718923f, -0.00376870f, 0.01297830f, 0.16074036f, -0.02753062f, 0.05426884f, 0.00988715f, 0.19181703f, 
    0.21186663f, 0.04896935f, -0.09316558f, 0.05180686f, 0.01285302f, 0.01846750f, 0.00287206f, 0.03210180f, 
    0.04055232f, -0.00738914f, -0.09390491f, 0.10474927f, -0.00987556f, -0.00787599f, -0.01074204f, 0.00577424f, 
    -0.03442992f, -0.03106673f, -0.04299410f, -0.06529189f, 0.10541280f, 0.16874386f, -0.00834919f, 0.26579300f, 
    0.13284066f, 0.09958395f, -0.13841987f, 0.04090030f, 0.13569841f, 0.06184623f, 0.02720852f, 0.05606746f, 
    0.06978157f, -0.09724168f, -0.01849989f, -0.00433814f, -0.08485194f, -0.08669562f, 0.03550719f, 0.12843744f, 
    0.02991472f, -0.05220899f, 0.02019931f, 0.12854341f, 0.02497893f, 0.10456644f, 0.14955007f, 0.07844806f, 
    0.11384223f, 0.13566975f, -0.15693107f, -0.00393895f, -0.04743504f, -0.00684758f, -0.03931760f, -0.08679920f, 
    0.12676075f, -0.04372087f, 0.11633373f, 0.25241336f, 0.00198979f, 0.12483609f, -0.05708946f, -0.10214403f, 
    0.01409377f, 0.04340381f, 0.03285574f, 0.11123772f, -0.33165902f, 0.13356890f, -0.03541499f, -0.17663534f, 
    0.06731734f, -0.02407280f, -0.00492535f, -0.02707308f, 0.04123982f, 0.01635141f, 0.03815541f, -0.03130411f, 
    0.09736907f, -0.20162368f, -0.07225490f, -0.24269772f, 0.14207335f, -0.15798458f, -0.00273376f, 0.02893806f, 
    0.00076266f, -0.01894157f, -0.09677346f, 0.00197215f, 0.06574971f, -0.07601218f, 0.05777187f, -0.06232599f, 
    0.01040694f, 0.03616136f, -0.07624605f, 0.06114459f, -0.06420916f, -0.01740467f, 0.00535643f, 0.11820406f, 
    0.07796863f, 0.08567641f, 0.09824695f, -0.02886326f, 0.15087532f, -0.11701231f, -0.00117767f, 0.00440930f, 
    0.11955306f, 0.05305609f, 0.04781099f, 0.03402828f, -0.45752856f, 0.26370773f, -0.14797294f, -0.09855647f, 
    0.11363944f, 0.09409438f, 0.02299408f, -0.02587948f, 0.00511057f, -0.03440638f, 0.00658828f, -0.00044891f, 
    -0.20899837f, -0.07914067f, -0.13584720f, -0.12264624f, 0.15838774f, 0.03886031f, -0.06142585f, -0.07955335f, 
    -0.01539402f, -0.00821200f, -0.01080806f, 0.05426750f, 0.06532507f, -0.03600103f, 0.01675179f, 0.13963170f, 
    -0.02977050f, 0.05450723f, 0.08573359f, -0.04424454f, 0.02780850f, -0.02508559f, 0.12602679f, -0.00618830f, 
    0.20781720f, -0.08807100f, -0.10758688f, 0.05124436f, -0.00504977f, -0.03344500f, -0.01558541f, 0.01077139f, 
    -0.00557994f, -0.04234786f, 0.08744172f, -0.05152514f, 0.00780216f, -0.06043689f, -0.10039455f, 0.11504391f, 
    -0.01431747f, 0.08266901f, -0.07318999f, -0.00299900f, -0.00839782f, -0.02033578f, 0.03744820f, -0.06085296f, 
    -0.11296062f, 0.19792007f, -0.06432578f, -0.00104855f, 0.10004810f, 0.00331780f, -0.05528864f, 0.02637775f, 
    0.08805333f, -0.02854704f, 0.06648716f, 0.11887679f, 0.15513682f, -0.05241360f, -0.11058383f, -0.22080265f, 
    0.19702791f, -0.01812695f, -0.08455396f, -0.10281191f, 0.02264163f, -0.01242946f, 0.15386382f, 0.04029408f, 
    0.10119988f, 0.00680717f, -0.05511426f, -0.23456949f, 0.12625970f, 0.06637734f, -0.00352604f, -0.00963126f, 
    -0.03745912f, 0.05991528f, 0.07089829f, -0.01278171f, -0.03581136f, 0.02101312f, 0.05314920f, 0.06244988f, 
    -0.05473244f, 0.01640888f, 0.04717439f, -0.00787851f, -0.01428902f, 0.07635492f, -0.02237078f, -0.05644763f, 
    0.01297879f, 0.14170663f, -0.06323101f, 0.08215060f, -0.00217219f, 0.00722335f, -0.05679525f, -0.05170371f, 
    0.00992362f, -0.07968084f, -0.12346654f, -0.02069863f, 0.00286839f, -0.03216957f, -0.17379522f, 0.16521153f, 
    0.05587132f, 0.07711008f, -0.04745323f, -0.13366087f, 0.02115780f, 0.07597847f, -0.01413469f, -0.02067118f, 
    -0.01965864f, 0.08168955f, 0.22104353f, -0.08045246f, 0.10319878f, -0.02675795f, 0.01352770f, 0.04627510f, 
    -0.10067518f, 0.09637009f, 0.05238710f, -0.02874035f, -0.27589455f, -0.24832721f, 0.03309260f, 0.13207436f, 
    0.00644455f, 0.07554081f, 0.05143166f, 0.03020542f, -0.02711728f, -0.04013339f, 0.07447844f, 0.03023176f, 
    -0.05972876f, -0.00220048f, 0.04616771f, -0.06904548f, -0.03715636f, -0.01796630f, -0.03272405f, -0.13251390f, 
    0.10545761f, 0.03161139f, -0.04236695f, -0.03815188f, 0.01207350f, -0.01637744f, -0.15599439f, 0.02035316f, 
    -0.01171559f, 0.00212528f, -0.05745657f, 0.07786137f, 0.03339378f, 0.05540143f, -0.04537944f, -0.09976986f, 
    0.08200802f, 0.08569986f, 0.22345813f, -0.05110184f, 0.11826327f, -0.06113277f, -0.08242345f, -0.01616852f, 
    0.07856912f, 0.00044743f, 0.04898514f, -0.01711436f, -0.08445731f, -0.20142588f, 0.00682070f, 0.12789223f, 
    0.06699780f, -0.07019430f, -0.03875603f, -0.05936637f, 0.00253224f, 0.01322076f, 0.09526873f, -0.00457826f, 
    -0.05297325f, -0.11768019f, 0.24870133f, -0.18451020f, 0.03605876f, 0.03343914f, -0.04233089f, -0.10076057f, 
    0.04446139f, 0.05516198f, -0.00258541f, 0.03864745f, 0.10840277f, 0.31183171f, 0.00294950f, -0.01390036f, 
    -0.13714510f, 0.02401052f, 0.04498967f, 0.00552852f, 0.08630931f, -0.02961219f, -0.02225694f, -0.05929775f, 
    0.05666863f, 0.06892709f, -0.15528642f, 0.09966516f, -0.03150601f, 0.09267963f, 0.02751919f, -0.02471063f, 
    -0.01611285f, 0.06076837f, -0.00417035f, 0.02873607f, -0.06081397f, 0.04863471f, -0.02475666f, -0.01815813f, 
    0.07610943f, 0.01539370f, 0.01534497f, 0.00020704f, 0.07429032f, 0.03854553f, 0.00763614f, -0.02399822f, 
    0.06849919f, -0.15461214f, 0.04811505f, 0.00227799f, 0.11463910f, -0.02600500f, -0.11026458f, 0.03320125f, 
    0.06346462f, 0.03160887f, 0.05491367f, 0.06032532f, 0.06355438f, -0.08713634f, -0.06560443f, 0.00057660f, 
    0.04045826f, -0.10347369f, -0.07194361f, 0.01285366f, 0.09242901f, -0.03110138f, -0.05926033f, 0.03423603f, 
    -0.13088155f, -0.06754233f, 0.01537836f, -0.12600362f, 0.05342717f, 0.00098924f, -0.01177730f, -0.02919060f, 
    -0.03835220f, -0.00351763f, -0.06759514f, 0.09591559f, 0.09006742f, 0.09503680f, -0.17229228f, -0.03996425f, 
    0.09030400f, -0.04300305f, 0.06761770f, 0.07449682f, -0.06077528f, 0.04775223f, 0.15877256f, -0.00222647f, 
    -0.11725700f, 0.19989884f, 0.05498295f, -0.01346549f, 0.11904721f, -0.10733750f, 0.07012243f, 0.03575334f, 
    0.00980454f, 0.12526006f, 0.00609407f, 0.05885445f, -0.06645374f, -0.07765925f, 0.04067072f, -0.04881458f, 
    0.01309208f, 0.00860178f, 0.13371752f, -0.11910837f, -0.12737888f, 0.03549682f, 0.05569972f, 0.07935685f, 
    0.12520963f, -0.08141869f, 0.09446680f, -0.03933827f, 0.01038325f, -0.00475609f, 0.14390624f, -0.15666723f, 
    0.02772823f, 0.03521860f, 0.07621995f, -0.02969612f, -0.09445146f, -0.07386591f, 0.10656310f, -0.08996476f, 
    -0.01246032f, -0.02719813f, 0.13486335f, 0.04183251f, -0.03092589f, 0.00358163f, 0.03481426f, -0.05386283f, 
    0.04424209f, 0.13854599f, -0.20640139f, -0.04843283f, 0.03848410f, 0.04491782f, -0.04439150f, -0.11097316f, 
    0.02845890f, 0.02111665f, -0.00707622f, -0.01354281f, 0.21509437f, 0.10014285f, -0.10227777f, 0.05877207f, 
    0.01388184f, 0.01224784f, 0.07937321f, 0.11308938f, 0.03545336f, -0.01302962f, -0.08492824f, -0.05151141f, 
    0.02819986f, 0.07678515f, 0.14207169f, 0.12379851f, 0.00154865f, -0.03304337f, 0.01412160f, 0.01597055f, 
    0.01896848f, -0.04593551f, 0.03633430f, 0.04672266f, -0.00559524f, -0.15100953f, 0.08171462f, 0.19232100f, 
    0.00309024f, 0.08465932f, -0.07126744f, 0.00419113f, 0.02629391f, -0.10987175f, 0.01692787f, 0.01021452f, 
    0.15448955f, 0.07611758f, 0.15759903f, -0.17759539f, -0.03404262f, -0.04096989f, 0.06981164f, 0.01667999f, 
    0.03295688f, 0.01368025f, 0.05609116f, 0.00690226f, -0.05376334f, 0.12340930f, 0.01925997f, 0.04424093f, 
    0.00369103f, -0.02091670f, 0.05129204f, 0.11450210f, 0.16790101f, -0.02682395f, 0.00624075f, -0.02613025f, 
    0.02703582f, 0.27084333f, 0.03769026f, 0.14811787f, 0.20404382f, -0.03215844f, -0.04869340f, -0.08490008f, 
    0.06743821f, 0.00449745f, 0.02159509f, 0.14373659f, 0.10326964f, -0.01630498f, -0.12373465f, 0.16876297f, 
    0.16388090f, 0.10488527f, 0.03154400f, -0.07249460f, 0.03721091f, -0.00142059f, 0.11697852f, 0.04906244f, 
    -0.10653378f, 0.36135074f, -0.00381005f, 0.14062977f, 0.10279043f, -0.01769637f, 0.02916319f, -0.03708086f, 
    0.03770186f, 0.04380120f, -0.02684953f, -0.09257329f, 0.13828620f, -0.06210364f, -0.00277172f, 0.01473665f, 
    0.12471917f, 0.03361174f, 0.05372529f, 0.14714675f, -0.05217908f, 0.05619580f, 0.03931436f, 0.05638553f, 
    0.18636465f, -0.08992630f, 0.16213734f, 0.01164068f, 0.01420126f, -0.08529723f, -0.01923687f, -0.08021414f, 
    -0.04604194f, 0.00020819f, 0.07240683f, -0.00512081f, -0.08382087f, -0.02718623f, 0.00191861f, -0.19513564f, 
    0.02609026f, -0.03765156f, -0.03450578f, -0.16582409f, 0.04091891f, -0.03339481f, -0.08637877f, -0.00667758f, 
    0.07357841f, 0.09620225f, -0.05052210f, 0.03165690f, -0.02174323f, 0.10177394f, 0.03364178f, 0.00642169f, 
    -0.01852318f, 0.01349212f, -0.04911613f, -0.07107987f, -0.15804100f, -0.12359388f, -0.00564222f, 0.02583114f, 
    -0.04802777f, 0.02685649f, 0.02615577f, 0.02914098f, -0.05263330f, 0.02297190f, 0.01002681f, -0.02816656f, 
    -0.30498573f, 0.12510380f, 0.08675358f, 0.02682102f, 0.07478231f, -0.07664213f, -0.04319640f, 0.00924901f, 
    -0.01372620f, -0.01246482f, 0.06566554f, 0.04120975f, -0.04628378f, -0.04810353f, 0.10396986f, 0.01151705f, 
    0.02191948f, -0.10557762f, -0.10309768f, 0.09717407f, 0.06127479f, 0.03135766f, 0.04802347f, 0.08151992f, 
    0.12574446f, 0.19363910f, -0.04764282f, 0.05397298f, 0.07361160f, -0.06017601f, -0.08278173f, 0.03041439f, 
    0.07189186f, 0.00174932f, 0.05686801f, -0.01353728f, 0.21651746f, 0.17514719f, 0.05581475f, -0.08708053f, 
    0.17835851f, -0.09962832f, -0.05079862f, 0.03584745f, -0.00466848f, -0.00201313f, 0.05459826f, 0.03253725f, 
    -0.03152383f, -0.00347368f, -0.09695142f, -0.25927490f, 0.06041969f, -0.00676401f, 0.01904902f, -0.05212127f, 
    -0.05913880f, 0.06452839f, 0.17205264f, -0.00988202f, 0.01101962f, 0.17155875f, -0.29152596f, 0.13112181f, 
    0.08431448f, 0.03242537f, 0.03330587f, -0.00718366f, -0.01636488f, 0.00122585f, 0.05819833f, 0.02420676f, 
    0.05124354f, -0.13872278f, 0.04261121f, 0.06317743f, -0.03244252f, -0.23630323f, 0.00311294f, -0.15726762f, 
    0.05184766f, -0.07175789f, -0.10741394f, -0.03713337f, 0.10196599f, 0.00867511f, 0.24532717f, -0.08196683f, 
    0.12199807f, -0.03633387f, -0.08603304f, 0.06471919f, 0.06169898f, -0.02827855f, 0.03186344f, 0.04668732f, 
    -0.17548060f, 0.04914642f, 0.06194206f, 0.00133774f, 0.06275647f, 0.00924394f, -0.00200781f, 0.12233800f, 
    0.04543514f, -0.06982834f, 0.06089786f, 0.01997814f, -0.26403803f, 0.01364848f, 0.16480055f, 0.11817479f, 
    -0.03040126f, -0.09332031f, 0.00285032f, 0.02591039f, -0.05396510f, 0.05506777f, -0.02838382f, -0.02170045f, 
    -0.11165036f, -0.06249602f, -0.05526904f, 0.13654116f, -0.00377846f, 0.05295286f, -0.03984228f, 0.02221172f, 
    -0.00109851f, -0.04472490f, -0.02082543f, -0.06618998f, 0.35966340f, -0.14463322f, -0.02401516f, -0.02269134f, 
    -0.17092600f, 0.02291606f, 0.10034370f, 0.08532866f, 0.03083782f, 0.08200485f, 0.18295127f, -0.04274678f, 
    0.06229580f, 0.03750148f, -0.00012048f, 0.18063581f, -0.04408753f, 0.06906673f, -0.00746293f, 0.05556507f, 
    0.00804246f, 0.06557909f, 0.10316148f, 0.09356045f, 0.17462341f, -0.19352749f, 0.25633672f, -0.06483480f, 
    -0.11341685f, 0.01832698f, 0.11317065f, -0.05584995f, -0.03760550f, -0.06387681f, -0.03505479f, -0.13457038f, 
    0.07960386f, -0.12886666f, 0.02435982f, 0.18893977f, -0.15436977f, 0.02438662f, -0.05379258f, -0.08341191f, 
    -0.10322254f, -0.11603028f, 0.04534185f, -0.16152287f, 0.10716718f, 0.20153032f, 0.01523528f, 0.15682331f, 
    0.00539147f, 0.00631979f, -0.02716280f, 0.05534474f, 0.03470711f, 0.00674602f, 0.07214473f, 0.06098448f, 
    -0.08175056f, -0.05374433f, 0.04829968f, 0.07137137f, 0.06901293f, -0.21492712f, 0.04877765f, 0.06058136f, 
    -0.00069753f, -0.00943710f, 0.01913774f, -0.03075273f, -0.07310469f, 0.03570624f, -0.08968911f, 0.03895832f, 
    0.12393665f, 0.05493184f, 0.07599530f, -0.10693713f, 0.11142182f, 0.00399499f, 0.09296775f, -0.00591136f, 
    -0.11594511f, 0.03619136f, 0.02196770f, -0.02460007f, 0.01503954f, 0.11875348f, 0.01139013f, 0.06315244f, 
    0.07269331f, 0.06910755f, -0.01343712f, -0.01582198f, 0.07056241f, 0.06314746f, -0.05795183f, -0.06814618f, 
    0.12908842f, -0.16913757f, 0.04358942f, -0.05479088f, -0.02361218f, -0.09370033f, -0.02771275f, -0.04893174f, 
    -0.16993102f, 0.22474623f, 0.03699138f, 0.00530819f, -0.06267311f, 0.14561005f, -0.05763404f, 0.08062620f, 
    -0.05311600f, 0.12178917f, 0.13117641f, 0.01619914f, -0.03522801f, -0.02304768f, -0.06377121f, 0.06576953f, 
    -0.05168349f, 0.02924318f, 0.12808381f, -0.03655513f, -0.01172938f, -0.02547114f, -0.03247233f, 0.01292491f, 
    0.08097260f, -0.02737270f, -0.08450352f, -0.09180316f, 0.08093663f, -0.04033117f, 0.00381110f, -0.03672178f, 
    -0.04050682f, -0.01853467f, -0.06583531f, -0.11290359f, -0.14422780f, -0.03409299f, 0.06237211f, -0.01223691f, 
    0.08895997f, -0.02167425f, -0.12987345f, 0.06449780f, 0.06405879f, -0.03361190f, 0.03400825f, 0.02851400f, 
    0.09283062f, -0.02971369f, 0.29070631f, 0.03601713f, -0.00878092f, 0.03821568f, -0.11566895f, 0.08399075f, 
    -0.12773804f, -0.04178308f, -0.03073587f, 0.20342493f, 0.01328896f, -0.04197811f, 0.12616421f, 0.01350005f, 
    -0.14606737f, 0.17734453f, 0.04498622f, 0.05071579f, 0.08362263f, 0.03289514f, -0.09371135f, 0.12855259f, 
    0.14991620f, 0.13090084f, 0.00871631f, 0.20613281f, 0.06378493f, -0.01554206f, 0.03890227f, -0.05100777f, 
    -0.00875652f, 0.18589374f, 0.06215871f, 0.06144643f, -0.03190288f, -0.08368381f, -0.02939267f, -0.05455647f, 
    -0.10116735f, 0.12935171f, -0.03846312f, 0.02067764f, 0.08760650f, 0.10563312f, -0.00905767f, 0.00507537f, 
    0.09770837f, -0.07246581f, -0.09303679f, -0.10350948f, -0.08786000f, 0.10649195f, -0.08786730f, -0.09863096f, 
    0.05218088f, -0.06113931f, -0.00485495f, -0.02001660f, -0.00149032f, 0.06201656f, 0.01561206f, 0.19467196f, 
    -0.01791644f, -0.06119306f, -0.04102694f, 0.16077392f, -0.04157629f, 0.02065709f, 0.06332638f, -0.00357722f, 
    0.00046734f, 0.07890547f, 0.19685945f, 0.17189179f, -0.00753884f, 0.02271025f, 0.02146877f, 0.08912105f, 
    0.03512621f, 0.01024582f, 0.01033266f, 0.03820216f, -0.06880523f, -0.11633571f, -0.01468366f, -0.04747563f, 
    0.02514157f, 0.09062301f, 0.12807953f, 0.11408118f, 0.00438561f, 0.07150486f, -0.05470786f, 0.10995683f, 
    -0.01189537f, 0.10090690f, -0.11794825f, -0.25036874f, -0.08179943f, 0.09337915f, 0.11798787f, -0.05518924f, 
    -0.08859362f, -0.16457902f, 0.01871667f, -0.10380688f, 0.20729133f, 0.01943860f, 0.11828014f, -0.04372865f, 
    0.15563309f, 0.05268133f, -0.02565768f, 0.07310066f, 0.02834121f, 0.03718669f, 0.08293732f, 0.02880376f, 
    0.09067140f, -0.14871697f, -0.10649411f, 0.15865472f, -0.03365725f, 0.03639761f, 0.09280501f, 0.04607571f, 
    0.04429331f, -0.00891667f, 0.03170115f, -0.03158485f, 0.02904212f, -0.08828364f, -0.01430981f, -0.04749110f, 
    -0.03620056f, -0.03457210f, -0.04395974f, 0.08273428f, -0.00349667f, 0.10136411f, 0.10467645f, -0.01355832f, 
    -0.26580170f, -0.02873960f, 0.10393319f, -0.02679626f, 0.07705671f, 0.05013262f, -0.04874543f, -0.05546277f, 
    0.02335086f, 0.09035178f, -0.09357794f, -0.11451048f, 0.10655419f, 0.12228090f, -0.03373515f, -0.04667366f, 
    0.04322601f, 0.07565764f, 0.01799545f, 0.05584563f, -0.13703619f, 0.00437349f, -0.04557009f, -0.01597249f, 
    0.01865527f, 0.05470031f, -0.19132662f, 0.06066209f, 0.00704014f, 0.11440076f, 0.02427127f, 0.08809796f, 
    0.04214924f, -0.01052085f, -0.08432350f, 0.08385730f, -0.02475520f, -0.02719319f, -0.06132924f, 0.29875553f, 
    0.08327577f, -0.11307853f, 0.01636694f, 0.07483701f, -0.00692940f, 0.07562386f, -0.04184912f, 0.09276843f, 
    -0.11666264f, 0.00550749f, -0.00814085f, 0.13648428f, 0.08114898f, -0.08202216f, -0.04347852f, 0.07678405f, 
    0.10324723f, -0.10298083f, -0.09647420f, 0.16721264f, -0.16954389f, 0.03886276f, -0.01518751f, 0.22741143f, 
    0.07056766f, -0.00779045f, -0.07503848f, 0.08800631f, -0.08752228f, 0.05334485f, -0.08526357f, -0.06675334f, 
    -0.19134678f, -0.04952635f, -0.04982746f, 0.00296802f, -0.02254877f, 0.04372326f, 0.05648603f, 0.04735610f, 
    -0.03046443f, -0.03650943f, -0.00088408f, 0.19116132f, -0.22636965f, 0.16119623f, 0.04711732f, -0.13715567f, 
    0.08411709f, 0.09991205f, -0.09670563f, 0.08452775f, -0.01622145f, 0.01141803f, 0.11777776f, -0.11402402f, 
    -0.22011912f, 0.22187497f, -0.11739888f, -0.07346731f, 0.04012902f, -0.01927509f, 0.01987275f, 0.09570742f, 
    0.09030074f, -0.00950350f, 0.07506874f, -0.02420120f, -0.07956097f, 0.03646745f, 0.16742642f, 0.13876125f, 
    -0.02169413f, 0.07470678f, -0.01038171f, -0.01959689f, 0.07109642f, 0.11534892f, -0.11148599f, 0.02974688f, 
    0.09962665f, 0.02893806f, -0.08786742f, -0.09486719f, -0.02032780f, 0.08612561f, 0.14579041f, 0.00406612f, 
    -0.08386727f, -0.06584538f, 0.05636955f, -0.02339306f, 0.18223573f, 0.08213515f, -0.14220658f, 0.27000734f, 
    -0.14127998f, -0.04329844f, -0.02181253f, 0.07376683f, 0.10493267f, 0.12444687f, 0.08415685f, 0.06131724f, 
    0.03785966f, 0.12888245f, 0.05168704f, -0.15866688f, 0.12368207f, 0.08009793f, -0.10276758f, 0.02551389f, 
    0.04272674f, -0.05100184f, 0.00544737f, -0.12815283f, 0.09929761f, -0.03056750f, 0.02349820f, -0.10000001f, 
    0.16055425f, -0.03381258f, -0.00244449f, -0.00894172f, -0.09338633f, -0.04670016f, 0.06175045f, 0.01606785f, 
    -0.06338941f, -0.02901793f, 0.13585913f, 0.15905081f, 0.04751280f, -0.07580891f, 0.01287281f, 0.13044575f, 
    -0.01313003f, 0.08635464f, -0.08548269f, 0.08630068f, -0.28789622f, 0.02195154f, 0.07699929f, 0.05226826f, 
    0.09958088f, 0.05481133f, -0.00017536f, 0.04760026f, -0.06518488f, -0.00108478f, 0.00451741f, -0.00284966f, 
    -0.11215797f, 0.10693435f, -0.14534666f, -0.08518866f, -0.07224468f, 0.03737497f, 0.05688500f, 0.10796911f, 
    0.00555313f, 0.08407552f, 0.06997394f, -0.01303123f, 0.28256413f, -0.08123768f, -0.04764691f, -0.12421259f, 
    -0.01337435f, -0.00866057f, 0.18999191f, 0.06303782f, -0.04242363f, 0.00287932f, 0.04878717f, 0.03160604f, 
    0.22869496f, -0.06876141f, -0.11720000f, 0.13124748f, -0.16373974f, -0.16293219f, -0.03731749f, -0.06336673f, 
    -0.03740519f, -0.11751051f, 0.02518749f, -0.13500780f, -0.11894103f, 0.05874016f, 0.10912368f, 0.05967803f, 
    0.11679824f, 0.00951557f, -0.01575156f, -0.01459356f, -0.09560405f, 0.07042980f, 0.02185374f, 0.01453882f, 
    0.00920487f, -0.13157409f, 0.24794953f, -0.15292174f, -0.09581352f, -0.03544250f, 0.03456899f, 0.15508489f, 
    -0.05751107f, 0.08455882f, -0.02254921f, -0.05439867f, 0.04510269f, 0.07395609f, -0.07124041f, -0.10201498f, 
    0.10118811f, 0.00603461f, 0.08060440f, 0.02447747f, -0.09980716f, 0.07808553f, -0.00242555f, 0.02316290f, 
    0.08412448f, 0.03412510f, 0.18222156f, -0.02858440f, -0.09215759f, 0.01221843f, 0.08250540f, 0.01700313f, 
    0.01034350f, -0.05635988f, 0.00249972f, 0.02724945f, 0.03910078f, 0.00862039f, 0.04944406f, -0.02745143f, 
    -0.08462755f, 0.03923211f, -0.06353323f, 0.01553884f, -0.03649511f, -0.15271443f, -0.07404742f, 0.02579408f, 
    0.28633022f, 0.04202108f, -0.06283782f, -0.13801484f, 0.02526874f, 0.09534959f, -0.03306507f, 0.05026281f, 
    0.05604078f, 0.01578668f, -0.03902575f, 0.03670482f, 0.03058394f, -0.07303786f, -0.08614403f, -0.13237496f, 
    0.11192920f, -0.08525974f, 0.03414675f, 0.11557773f, -0.02356265f, 0.07860231f, 0.07572561f, -0.01186222f, 
    -0.05692726f, 0.09583090f, 0.09555194f, 0.23742160f, 0.13321006f, -0.06055195f, 0.02899272f, 0.00709908f, 
    -0.12468261f, -0.02957739f, 0.11354808f, 0.06239264f, 0.09674841f, 0.02476583f, -0.10165085f, 0.09025033f, 
    -0.03123665f, -0.05710557f, 0.12253205f, 0.04314831f, -0.04748778f, 0.16798407f, 0.05545520f, -0.02290008f, 
    0.29825762f, 0.20697674f, -0.12099331f, 0.02512150f, 0.00815459f, 0.07060234f, -0.03447156f, -0.07459296f, 
    0.09248082f, 0.01699901f, 0.01353309f, 0.03269828f, 0.20082046f, 0.00583726f, -0.11564160f, 0.16294734f, 
    0.01066706f, -0.03360558f, -0.09812528f, 0.02864797f, 0.02437983f, -0.22668321f, 0.08545329f, -0.07144441f, 
    -0.02451385f, 0.05821037f, -0.14101470f, 0.26285139f, -0.03559697f, -0.00580606f, -0.08095519f, -0.03347525f, 
    0.11025807f, 0.06937116f, 0.05696725f, -0.01818382f, -0.09361543f, -0.01913016f, 0.08878023f, -0.05805586f, 
    -0.02670261f, 0.12291647f, 0.02701545f, 0.13459983f, 0.04859846f, -0.16889560f, -0.04404546f, -0.08787639f, 
    -0.10965075f, -0.05700799f, -0.08250713f, 0.21663100f, 0.03257234f, 0.02081894f, 0.06722517f, -0.05240896f, 
    -0.00605113f, -0.04016573f, -0.02634550f, -0.07456371f, -0.07240748f, 0.15258127f, -0.02446509f, 0.20845123f, 
    0.04468548f, -0.01904898f, -0.04043902f, 0.02318738f, -0.02554020f, -0.04378589f, -0.03201049f, 0.00960589f, 
    -0.11015712f, -0.12136323f, 0.00552564f, -0.01077019f, -0.11552890f, 0.03549916f, -0.00655436f, -0.09084643f, 
    -0.03898920f, -0.12120913f, 0.03327423f, -0.18972039f, -0.13434249f, -0.01026404f, -0.05778237f, 0.12018318f, 
    0.04341486f, 0.04815865f, 0.03727402f, 0.04614538f, 0.05244803f, 0.10278612f, 0.07312907f, -0.11832610f, 
    -0.09426995f, -0.01388419f, 0.08122408f, 0.12392999f, 0.03100001f, 0.15554073f, -0.17193833f, -0.04119632f, 
    -0.06749224f, 0.02365491f, 0.11234094f, 0.02050331f, 0.14540538f, -0.44895890f, -0.05854309f, 0.00788154f, 
    0.00827581f, -0.03063278f, -0.04519245f, -0.03564662f, -0.02605776f, 0.05654821f, 0.06036554f, -0.09516573f, 
    0.46563381f, -0.06830114f, -0.06999404f, -0.04944770f, -0.05645352f, 0.00722514f, 0.06947639f, -0.02658397f, 
    -0.01183007f, -0.11358957f, -0.01918295f, -0.14469011f, 0.04850321f, 0.12618090f, 0.00211848f, 0.03971335f, 
    -0.06599975f, -0.02919575f, 0.05558812f, 0.07968961f, 0.09520584f, 0.09000545f, 0.20999369f, -0.14415918f, 
    0.02785694f, 0.13374670f, -0.12261400f, 0.03688794f, -0.07453248f, 0.02930639f, 0.04912490f, -0.08898912f, 
    -0.06461225f, 0.03063272f, 0.16052289f, -0.00998594f, 0.34407571f, -0.21197036f, -0.06242622f, -0.00150000f, 
    -0.01487461f, 0.03099528f, 0.01901382f, -0.09894083f, -0.09315740f, -0.04904256f, 0.00821720f, -0.08704425f, 
    -0.34051806f, -0.25536683f, -0.04506400f, 0.14824942f, -0.19333990f, 0.00990621f, 0.00718872f, 0.05536707f, 
    -0.09283359f, -0.09012142f, -0.02002518f, -0.17902035f, -0.03403646f, 0.18899742f, 0.01578634f, -0.03457221f, 
    -0.02137587f, -0.13992755f, -0.18174383f, -0.06391104f, -0.06074687f, -0.03205493f, 0.00378641f, 0.17378865f, 
    -0.09746937f, -0.09172560f, 0.07297868f, 0.15985388f, 0.07861798f, 0.05678139f, -0.04867725f, -0.00948408f, 
    -0.08366706f, -0.17810746f, 0.05145951f, 0.04627381f, 0.01026047f, 0.38463470f, -0.11334321f, 0.02195493f, 
    0.02995724f, 0.09685098f, 0.07764252f, 0.01616491f, -0.03505875f, -0.05340424f, -0.07325882f, 0.05952700f, 
    0.23568754f, 0.08620793f, 0.19054168f, -0.11098810f, -0.09748740f, 0.08630317f, 0.05562264f, -0.02181643f, 
    -0.14285576f, -0.02372651f, 0.17158036f, -0.05467166f, 0.12781180f, -0.11284578f, 0.06837200f, -0.07326140f, 
    0.04045720f, -0.03115964f, -0.00875892f, 0.02968474f, -0.10650963f, 0.02981888f, -0.01038366f, -0.03662447f, 
    0.15482067f, -0.06459931f, -0.07046677f, 0.09165179f, -0.11178811f, 0.09889249f, -0.02491664f, -0.01901655f, 
    0.04653058f, 0.12226024f, 0.10276714f, -0.07415389f, -0.06922030f, 0.39123508f, 0.04320283f, 0.02244254f, 
    0.08327824f, -0.08452610f, 0.01864689f, 0.10170089f, 0.07594641f, 0.07957873f, -0.17468163f, 0.04561812f, 
    0.41402361f, 0.31401017f, 0.04194907f, -0.13096102f, -0.03892568f, -0.13076483f, 0.07756130f, 0.05931948f, 
    -0.01028847f, 0.06307168f, -0.17527467f, -0.05642723f, -0.03989161f, -0.02420135f, -0.11927271f, 0.16226517f, 
    0.00696132f, 0.12792248f, -0.03722105f, 0.00358660f, 0.04115211f, 0.05881156f, -0.01466196f, 0.11768113f, 
    0.06922237f, -0.14130479f, 0.03259837f, 0.03844349f, -0.05139863f, 0.04750975f, 0.07089361f, 0.01473612f, 
    0.00398448f, -0.01585285f, -0.15251178f, -0.12638268f, -0.16316712f, -0.07828414f, 0.05305660f, 0.07336288f, 
    -0.07469606f, 0.05949848f, -0.06590239f, -0.00940426f, -0.01220314f, -0.02848080f, -0.03460814f, 0.11020927f, 
    0.17736453f, 0.34454647f, -0.13713844f, -0.04099243f, -0.04346606f, -0.14710934f, 0.02167791f, 0.01642118f, 
    -0.15751405f, 0.00366577f, 0.14967276f, -0.12453412f, 0.44949719f, 0.20242439f, 0.04428866f, -0.14042915f, 
    -0.08051462f, 0.00757259f, 0.05860238f, 0.05316519f, 0.08207565f, 0.11198210f, 0.04581036f, 0.12861586f, 
    0.35656738f, 0.23794869f, 0.01816257f, -0.04403476f, -0.02610005f, 0.01180467f, -0.04127623f, -0.01046200f, 
    -0.00906832f, -0.16474730f, -0.03871176f, 0.03488164f, -0.12104202f, 0.02202842f, -0.00581437f, 0.03422251f, 
    0.07794282f, 0.01946359f, -0.04772064f, 0.10989087f, 0.01532565f, -0.00703057f, 0.17011638f, -0.07419204f, 
    0.02255665f, 0.02184741f, 0.05368050f, 0.05089983f, 0.19289817f, -0.13323061f, 0.09871504f, 0.10230736f, 
    -0.05081105f, 0.04960326f, 0.10252383f, 0.01224975f, 0.39176214f, 0.21091719f, 0.05722456f, -0.00054934f, 
    -0.07793476f, -0.00348588f, 0.10661517f, 0.01983150f, 0.15034817f, -0.00814323f, -0.09013597f, -0.04351173f, 
    -0.04536852f, 0.00394131f, 0.15825570f, 0.08730794f, 0.03116552f, 0.08448648f, -0.00811995f, -0.13345927f, 
    -0.04929599f, -0.01290560f, -0.02062797f, -0.05908849f, 0.09928335f, -0.24838449f, -0.01991324f, 0.00707039f, 
    0.07894260f, 0.22505458f, -0.03626822f, -0.03769481f, -0.01913130f, 0.23789647f, 0.00635831f, 0.17885049f, 
    0.09284567f, 0.03315089f, 0.02172255f, -0.02328750f, -0.05196897f, 0.08272564f, -0.07815844f, 0.21730019f, 
    -0.02235713f, 0.03602253f, 0.06968218f, -0.04026125f, -0.37147659f, 0.02480657f, 0.16897610f, 0.10221688f, 
    0.12601344f, -0.01215090f, -0.01456992f, 0.03105388f, -0.01799570f, -0.04922790f, 0.15246214f, 0.10489734f, 
    -0.02685294f, 0.25250828f, -0.13734302f, 0.09128796f, -0.01862152f, 0.10998789f, 0.12903383f, -0.05242221f, 
    -0.06360862f, 0.07204473f, -0.06730557f, -0.09631714f, -0.04668542f, 0.01054627f, 0.10998573f, -0.13642894f, 
    -0.08128579f, 0.02521462f, 0.06680020f, -0.03984418f, -0.00401440f, -0.01290157f, -0.06553005f, 0.05251878f, 
    0.38123897f, 0.42115775f, -0.01715887f, -0.25361001f, -0.06110161f, 0.13901109f, 0.03403473f, 0.07056043f, 
    0.07126144f, -0.04311399f, 0.05180314f, -0.08135607f, 0.14297538f, -0.14171398f, 0.04089069f, 0.08144134f, 
    0.22434691f, -0.07176803f, 0.02385212f, 0.06840731f, 0.01803087f, 0.10635183f, 0.03824185f, 0.15554389f, 
    0.02298062f, 0.13418514f, 0.10569019f, 0.13907768f, -0.06864741f, -0.00343905f, -0.01592814f, 0.10355227f, 
    0.16253805f, 0.01966125f, -0.03897829f, 0.04315928f, -0.03662020f, 0.14119200f, 0.10463459f, 0.12040247f, 
    0.14755580f, 0.07604467f, -0.02869050f, 0.03862556f, 0.00844600f, -0.00176246f, 0.08712273f, -0.16794962f, 
    0.27495486f, 0.10287396f, 0.09721901f, -0.04371152f, -0.02471646f, 0.07078775f, 0.14672244f, -0.01740170f, 
    0.00016025f, -0.03650018f, -0.01490099f, 0.01898589f, -0.16518942f, -0.01184979f, 0.10790803f, 0.04277844f, 
    -0.00467993f, 0.16079119f, 0.01343830f, 0.10432667f, -0.03884734f, -0.03623531f, 0.14740005f, -0.00681842f, 
    0.01790833f, -0.03965319f, 0.00760062f, 0.01006769f, 0.05799962f, -0.02154439f, 0.06888856f, 0.13241839f, 
    0.02025318f, 0.03390503f, -0.07432669f, 0.15565883f, -0.17444921f, 0.02338361f, 0.07737573f, -0.04213393f, 
    0.14976935f, -0.02385951f, -0.04499212f, -0.01341304f, 0.02968381f, -0.03816639f, -0.20428826f, -0.06717858f, 
    0.08229298f, -0.00186014f, 0.11130412f, -0.01214819f, 0.04296314f, -0.02840629f, -0.02051802f, 0.01156946f, 
    -0.02424628f, -0.02496304f, 0.10714459f, -0.09168125f, 0.04832536f, 0.02562720f, 0.00373410f, -0.01326100f, 
    0.05672636f, 0.10762524f, -0.00517130f, -0.01862812f, -0.00516179f, 0.17172228f, 0.06005817f, 0.01581113f, 
    -0.02211365f, -0.04399203f, -0.07966616f, -0.03309762f, 0.03698692f, 0.18557127f, 0.02108015f, 0.12238700f, 
    -0.10034546f, 0.00497123f, 0.03442251f, 0.02243401f, 0.00526139f, 0.01328187f, 0.00571651f, 0.07274235f, 
    -0.00647314f, 0.04107330f, -0.05588529f, -0.02473455f, -0.08282636f, -0.17011832f, -0.12481387f, -0.08920110f, 
    0.15570484f, 0.05808028f, 0.06048528f, 0.07194121f, 0.00676514f, -0.07331382f, 0.02199398f, 0.04418218f, 
    0.02133920f, -0.02558613f, -0.15689199f, -0.10489085f, -0.22680187f, 0.05741581f, 0.13059218f, 0.07003211f, 
    0.08727831f, 0.06984413f, -0.05801767f, -0.04011700f, -0.00390273f, 0.09036858f, 0.04039586f, -0.00509118f, 
    0.25504521f, -0.03082071f, -0.04804464f, -0.03172071f, -0.05176861f, -0.04138986f, 0.19907099f, 0.03125573f, 
    0.06305768f, 0.04609400f, 0.01948906f, -0.02047968f, 0.09406143f, -0.01269781f, 0.01880250f, 0.11619917f, 
    0.03837603f, -0.06045246f, 0.11655493f, -0.02874507f, -0.07854805f, -0.08387404f, -0.14958782f, -0.15441318f, 
    -0.11939359f, -0.01619148f, -0.03035149f, 0.03429632f, 0.00433453f, -0.07730794f, -0.03597087f, 0.05884796f, 
    0.01473687f, -0.13108391f, -0.11699854f, -0.10975341f, -0.05151074f, -0.15485273f, 0.08238332f, 0.07068210f, 
    0.01836157f, -0.00847128f, -0.05524135f, -0.13607711f, -0.09568643f, -0.04781510f, -0.02203663f, 0.00478877f, 
    0.18467166f, 0.00201774f, 0.10164451f, 0.00017377f, -0.01733484f, 0.08693862f, 0.14687452f, -0.02287296f, 
    -0.11762504f, 0.13164024f, 0.04078711f, -0.13158676f, 0.19708404f, 0.17227232f, -0.07977569f, 0.05866014f, 
    -0.09213865f, -0.05155722f, 0.02898523f, -0.00285731f, -0.03353806f, 0.01703148f, 0.02335569f, 0.05516927f, 
    0.03528840f, 0.18055558f, 0.03036634f, -0.00983338f, 0.07702204f, -0.03279918f, -0.04796849f, 0.01710289f, 
    -0.02743012f, -0.08476976f, 0.11629087f, 0.01010058f, 0.22029589f, -0.05256376f, 0.09385590f, 0.04866611f, 
    -0.00300012f, 0.00354088f, -0.02302361f, -0.03312024f, -0.15534872f, -0.06709909f, -0.05885749f, -0.09872741f, 
    0.03936518f, 0.16336602f, -0.02459043f, -0.09213958f, 0.06819616f, 0.15894628f, -0.07207204f, -0.04972298f, 
    -0.05659530f, -0.10788615f, -0.00892488f, 0.04500266f, -0.11876606f, 0.13960817f, 0.08793657f, 0.00921742f, 
    0.04503896f, 0.04947396f, 0.03590403f, 0.25595310f, 0.07699383f, 0.21016102f, 0.20628743f, -0.02714006f, 
    0.06756300f, 0.08893777f, -0.04990059f, -0.09540329f, -0.07878033f, -0.07701708f, -0.01676890f, 0.02216444f, 
    -0.06767886f, 0.01854159f, 0.07654121f, -0.01157422f, 0.02123739f, -0.01685669f, -0.03441654f, -0.04934289f, 
    0.07926845f, -0.07387974f, 0.06618959f, 0.06081455f, 0.01671718f, 0.11929037f, 0.12261615f, 0.05785861f, 
    -0.09902368f, 0.35489547f, -0.04409255f, -0.02132387f, -0.01232400f, -0.00974811f, 0.00182029f, -0.05568686f, 
    -0.01906815f, -0.02363115f, 0.20200281f, -0.04895525f, 0.08321200f, 0.05854817f, -0.17053074f, 0.02753480f, 
    -0.03526720f, 0.12735245f, -0.21416922f, 0.10086931f, -0.02398157f, -0.02651536f, -0.00296317f, -0.05437875f, 
    0.27642679f, -0.01933599f, 0.02189521f, 0.06115206f, 0.11044586f, -0.06755430f, 0.07139598f, 0.07502402f, 
    0.07985992f, -0.01316991f, -0.08437358f, 0.07335549f, -0.09490348f, -0.10274071f, 0.07437044f, 0.05395049f, 
    -0.01002059f, 0.14112197f, -0.11163108f, 0.01200055f, -0.01266306f, 0.04252776f, -0.15269710f, -0.15523528f, 
    0.20343094f, 0.22146170f, 0.03378587f, -0.12535612f, -0.03969276f, 0.05224415f, -0.00063955f, 0.03805888f, 
    0.03684793f, -0.01027625f, -0.12248857f, -0.08154138f, 0.01493837f, 0.05528321f, -0.06258062f, 0.00460378f, 
    0.04286306f, -0.12870382f, -0.06351957f, 0.04475409f, -0.08851300f, 0.06838537f, -0.00672340f, -0.05905962f, 
    -0.31821302f, 0.12646829f, -0.05424199f, 0.00009566f, 0.07247163f, 0.14296769f, -0.00890115f, 0.06224667f, 
    -0.09910201f, -0.00750721f, -0.01005865f, 0.08774082f, -0.25764886f, -0.19157353f, -0.14373894f, -0.22488418f, 
    -0.02815692f, 0.03724869f, 0.09845076f, -0.00348248f, 0.01758359f, 0.08397448f, -0.04660489f, -0.03132114f, 
    -0.14915083f, -0.12394726f, -0.05989517f, -0.02872145f, -0.04033645f, 0.03608051f, -0.05823720f, -0.05120901f, 
    -0.03904094f, 0.07852632f, -0.07901313f, 0.02800263f, -0.15027344f, 0.14808574f, -0.14800787f, -0.02550651f, 
    0.02079797f, 0.06937591f, 0.09896106f, 0.05689373f, 0.03825086f, 0.04396753f, 0.06142027f, 0.02255366f, 
    0.31364426f, -0.01489244f, 0.00168358f, 0.00302716f, -0.05740570f, 0.02790089f, 0.02355576f, 0.01713486f, 
    0.03775501f, 0.05926127f, 0.01435217f, 0.10091224f, -0.14906189f, 0.26768160f, 0.11634836f, -0.13462940f, 
    0.06499867f, -0.03877224f, -0.04461417f, 0.00483724f, 0.06043638f, 0.09694699f, -0.06123104f, 0.06501768f, 
    0.01039861f, -0.10763933f, 0.00641832f, -0.07996311f, -0.00514763f, -0.00948259f, 0.07202697f, -0.02036402f, 
    0.07402734f, -0.02324841f, -0.05892087f, -0.03544398f, 0.33109480f, 0.16686220f, -0.03739141f, -0.03784772f, 
    0.03371671f, 0.08087024f, -0.05950034f, 0.08150621f, 0.03445305f, 0.05489359f, 0.08581454f, 0.08610805f, 
    -0.16889989f, 0.10748123f, 0.04655905f, -0.06174513f, 0.03750989f, -0.06947413f, 0.07966855f, 0.06797711f, 
    0.03703684f, 0.10167219f, -0.08188578f, 0.04906136f, -0.13893767f, -0.08812311f, 0.02738209f, -0.10894264f, 
    0.04021915f, 0.01368607f, 0.04025374f, 0.08595785f, -0.03117102f, -0.02627595f, -0.08860812f, -0.04431108f, 
    -0.03544041f, 0.01011230f, 0.09652712f, 0.02705715f, 0.00791086f, 0.09357950f, 0.02100819f, -0.07538200f, 
    -0.03630519f, 0.05222466f, -0.00987264f, 0.12722106f, 0.06212506f, -0.06248011f, 0.06566330f, 0.05044841f, 
    -0.03371696f, -0.02166695f, -0.10469639f, 0.08366080f, 0.03050655f, 0.01309463f, 0.04811721f, 0.04581828f, 
    0.23214199f, -0.06157320f, 0.06180461f, 0.14965376f, 0.05928150f, -0.02197839f, 0.03680312f, 0.00042909f, 
    0.06875561f, 0.00942348f, -0.07810730f, 0.02855118f, 0.01108015f, 0.04221156f, 0.04798010f, 0.07722513f, 
    0.01740663f, 0.06600720f, 0.00291381f, 0.04833587f, 0.02629439f, 0.05663016f, 0.01114152f, 0.07807080f, 
    -0.23284848f, 0.05684683f, -0.14093778f, 0.11723001f, 0.02864037f, -0.07628828f, 0.01452757f, 0.00208234f, 
    0.04529505f, -0.00901051f, -0.07120075f, -0.04055742f, 0.06070327f, 0.03344925f, 0.03867303f, 0.06532965f, 
    0.02912565f, -0.04859985f, -0.10638432f, 0.08234914f, 0.10388704f, -0.02379293f, -0.02111628f, 0.07865334f, 
    0.23589014f, -0.02329500f, 0.06325834f, 0.16854830f, -0.09248181f, -0.00172352f, 0.01392923f, 0.04855032f, 
    0.03534358f, -0.06355600f, 0.03245115f, 0.08789798f, -0.10141192f, -0.05129240f, -0.03846889f, 0.05679617f, 
    0.04740931f, 0.10169309f, 0.12815048f, -0.04266734f, -0.03094459f, 0.06185477f, 0.03102995f, 0.03884818f, 
    -0.22237183f, 0.16083923f, -0.14199258f, -0.03414332f, -0.04956535f, 0.01556180f, 0.13186751f, 0.00264057f, 
    0.05291137f, -0.00358534f, -0.00493059f, -0.06882801f, -0.06208042f, -0.04813993f, -0.07570875f, -0.06972216f, 
    0.04672447f, -0.03491854f, 0.01014068f, 0.05504598f, 0.00422056f, -0.06540087f, 0.05987391f, -0.04721802f, 
    0.10844264f, 0.02009679f, 0.11328193f, -0.14232299f, 0.07529136f, 0.01426095f, -0.02919482f, -0.01779432f, 
    -0.01508623f, -0.11677667f, -0.00373383f, -0.02161722f, 0.33558220f, 0.09406713f, 0.00574528f, 0.09528045f, 
    0.06604690f, -0.13462980f, 0.01502064f, -0.03357198f, 0.07813725f, -0.04195211f, 0.08326171f, 0.03810884f, 
    0.20554142f, 0.06030716f, -0.02612893f, 0.22277495f, 0.04270230f, 0.02332451f, 0.01562242f, 0.03840793f, 
    -0.01012309f, -0.00571991f, -0.01900732f, 0.02161664f, -0.08883262f, 0.05426164f, -0.04377685f, -0.19903751f, 
    0.10533565f, 0.04349786f, 0.01944406f, 0.03329358f, 0.06083792f, 0.04413311f, -0.03353903f, -0.00456711f, 
    0.16813852f, -0.24455273f, -0.10133386f, -0.28393304f, 0.10164696f, 0.03027892f, 0.02849674f, 0.00082255f, 
    -0.00532408f, 0.07980220f, -0.03632771f, 0.03827740f, 0.37752026f, 0.12065622f, 0.02230644f, 0.11431858f, 
    -0.00945215f, -0.09687539f, -0.05001981f, -0.03410768f, 0.00879365f, 0.08892336f, 0.05891223f, 0.00825025f, 
    0.29733691f, -0.15471615f, -0.02272495f, 0.01719052f, 0.16753289f, -0.02977120f, -0.09385864f, 0.00378821f, 
    -0.01422245f, 0.11330107f, -0.03492163f, 0.10460126f, -0.34066662f, -0.20659681f, 0.05859094f, -0.03496093f, 
    0.00588887f, 0.11032729f, -0.01705789f, -0.00232229f, -0.01516521f, -0.06075131f, 0.08420587f, -0.00520064f, 
    -0.02581388f, 0.06539167f, -0.01820944f, -0.11948257f, 0.00048429f, -0.02378838f, 0.01514411f, -0.02188374f, 
    -0.04057696f, -0.00985664f, -0.04099073f, 0.02593805f, -0.07954512f, 0.11704952f, 0.04964003f, -0.12869933f, 
    0.15598269f, 0.03181843f, 0.08654915f, 0.04898060f, 0.04213771f, -0.10679516f, -0.09172835f, 0.04410664f, 
    -0.10010750f, -0.05109366f, -0.13594174f, 0.10183252f, 0.07125207f, -0.06936354f, -0.04126934f, 0.03455625f, 
    0.06150804f, -0.01299588f, 0.08969162f, 0.07485516f, 0.20851207f, -0.16710313f, -0.05886910f, 0.16446497f, 
    0.04041702f, -0.01211251f, -0.02299153f, 0.00629138f, 0.09198772f, 0.03438381f, 0.08558287f, 0.09775922f, 
    0.33728331f, -0.02489227f, 0.09509161f, 0.04564397f, -0.05811846f, -0.12374791f, -0.03530435f, -0.03750904f, 
    0.05429047f, 0.05511896f, 0.07703909f, 0.02335816f, 0.19520180f, 0.03761972f, 0.03753315f, -0.31992629f, 
    0.03274750f, 0.11185045f, 0.01021198f, -0.06614971f, 0.06890772f, -0.01770198f, 0.01985461f, 0.03266929f, 
    0.02608183f, -0.12823726f, 0.02437779f, -0.03449110f, -0.08760878f, 0.05753385f, 0.05975817f, -0.06038961f, 
    0.03714075f, 0.11172339f, 0.07987475f, 0.01212579f, -0.25424606f, -0.02933583f, -0.10245936f, -0.01560876f, 
    -0.02675151f, -0.06997207f, 0.07013337f, 0.04606027f, 0.04357694f, -0.05086688f, 0.08415500f, 0.05372642f, 
    0.04855229f, 0.02467673f, 0.14816190f, 0.19539250f, -0.03939237f, -0.04635333f, -0.05666675f, 0.01303594f, 
    0.00236756f, 0.05482923f, 0.09633840f, 0.02268799f, 0.18251011f, -0.06631885f, -0.01406405f, 0.16902143f, 
    0.01310805f, -0.05811915f, 0.03683107f, -0.11175868f, 0.05741864f, 0.04659935f, -0.09538323f, 0.05253470f, 
    0.36887705f, -0.18341534f, 0.05187716f, 0.06253418f, 0.14405821f, -0.05427976f, 0.00465828f, -0.05824126f, 
    -0.00385559f, 0.06735355f, -0.03408095f, 0.05449737f, 0.06374347f, 0.10565972f, -0.09157345f, -0.02558103f, 
    0.06204121f, 0.03534314f, 0.08789662f, 0.07334305f, -0.04077856f, -0.03164939f, 0.13427675f, 0.07574099f, 
    0.05272098f, 0.05240396f, 0.13757470f, 0.07425038f, 0.04677633f, -0.10046882f, -0.02758480f, 0.00383263f, 
    0.03194906f, 0.03519015f, -0.01196138f, 0.05630508f, -0.08077063f, -0.08756983f, 0.03662560f, -0.04466802f, 
    0.11826907f, 0.01875579f, 0.04804052f, -0.04977269f, -0.01205739f, -0.03594336f, -0.07017428f, -0.00385106f, 
    -0.11626945f, 0.05074103f, 0.00326007f, -0.00164523f, 0.09109526f, -0.00590379f, 0.01955167f, -0.08483949f, 
    0.00608646f, 0.13225934f, 0.05513411f, 0.00179117f, -0.03249344f, 0.06954134f, -0.01260698f, 0.19022229f, 
    -0.07192342f, 0.03101245f, 0.04146553f, -0.01534106f, -0.01148656f, 0.00120133f, -0.06749769f, -0.03247426f, 
    -0.02060392f, -0.10532549f, -0.05065269f, -0.13977115f, 0.06453684f, -0.00735054f, 0.02138717f, -0.00518998f, 
    0.03527555f, -0.04508435f, 0.10381531f, 0.05840129f, 0.05090993f, -0.03658400f, -0.18528901f, -0.08196460f, 
    0.07403646f, 0.03752351f, 0.03902907f, 0.00631292f, 0.04750102f, -0.04174156f, -0.02943584f, 0.02453521f, 
    0.30806139f, 0.08894435f, 0.01361983f, 0.07953177f, -0.02237973f, -0.01557312f, -0.05398037f, -0.01910496f, 
    0.01022827f, -0.02052826f, 0.05059825f, 0.10446881f, -0.16591041f, 0.14707619f, 0.08292608f, 0.08749859f, 
    -0.00626103f, 0.09286420f, -0.07700368f, -0.02532719f, 0.03872580f, -0.08075979f, 0.04134540f, -0.04140141f, 
    -0.30786824f, 0.07750302f, 0.00940086f, 0.00658974f, 0.12543349f, 0.07994699f, 0.07242009f, 0.11995897f, 
    0.07742152f, 0.04522547f, 0.01000108f, 0.13246769f, 0.03349813f, -0.22771792f, -0.01074056f, -0.08712712f, 
    -0.00457432f, 0.02693759f, 0.05620372f, 0.01588879f, 0.06096106f, 0.04208731f, 0.04960480f, 0.01400992f, 
    0.28917322f, 0.10998268f, -0.08008916f, -0.08172079f, 0.14065264f, 0.00854971f, -0.05322440f, -0.09479680f, 
    0.01590378f, 0.05391354f, 0.02182925f, 0.08913041f, 0.24081837f, 0.01361782f, 0.12111047f, 0.18960832f, 
    -0.06699023f, 0.06065793f, 0.03111972f, -0.00525690f, 0.05482463f, 0.04178783f, 0.02781301f, 0.05509375f, 
    0.11458664f, -0.11043116f, -0.13123165f, -0.08192743f, 0.10632683f, -0.03040397f, -0.02040169f, 0.07423328f, 
    -0.02178944f, 0.06375922f, -0.04148237f, 0.05016531f, 0.04752253f, 0.00263110f, -0.07851914f, -0.02293811f, 
    0.01853099f, -0.01830735f, 0.02608243f, -0.01016396f, 0.06815526f, 0.02478102f, 0.06821971f, 0.04038490f, 
    -0.22205290f, 0.19800626f, 0.06255304f, 0.08149002f, 0.04648044f, -0.03293214f, 0.05195473f, 0.02910662f, 
    0.03956322f, 0.03660455f, 0.08561970f, -0.01094008f, 0.04602716f, -0.05799272f, 0.08189908f, 0.16306928f, 
    -0.00273894f, 0.07904527f, 0.01108762f, -0.02393993f, 0.09819105f, 0.02285772f, -0.00455200f, -0.04346318f, 
    0.03396121f, -0.06569188f, 0.09696881f, -0.12712012f, -0.01558986f, 0.04601203f, 0.05509846f, -0.02043651f, 
    0.14109337f, -0.00431672f, -0.00548274f, -0.00945328f, 0.11932093f, 0.00714694f, -0.01266076f, -0.16306269f, 
    0.02134171f, 0.10978859f, -0.07251953f, -0.00983425f, 0.05248642f, -0.05303193f, -0.01576684f, 0.01152207f, 
    -0.18597984f, -0.00885444f, 0.09299922f, -0.06602101f, -0.04197033f, -0.03130404f, 0.05178691f, 0.04868339f, 
    -0.06651453f, -0.01762118f, 0.02932736f, 0.07607978f, -0.14686151f, -0.06430600f, 0.14163841f, -0.02849402f, 
    -0.00998288f, 0.03056604f, 0.04007553f, -0.07158890f, 0.05848892f, 0.10640261f, -0.12572916f, 0.10998633f, 
    -0.05368133f, -0.07692043f, 0.14311287f, -0.20521301f, 0.12678234f, -0.03894222f, 0.06921860f, 0.04659714f, 
    -0.01867910f, 0.04803843f, 0.08881656f, 0.08339962f, 0.13875215f, 0.03119642f, -0.00398690f, 0.06592785f, 
    0.20889784f, -0.09293722f, 0.08382013f, -0.00056568f, 0.03658848f, 0.09214431f, 0.11431465f, 0.06392939f, 
    0.29665980f, -0.09524927f, 0.03610935f, 0.03695925f, -0.04424028f, -0.04499444f, 0.02111230f, 0.09538436f, 
    0.08420768f, 0.05083088f, 0.01971620f, 0.10031711f, 0.34872624f, -0.02132531f, 0.06794001f, 0.05672297f, 
    -0.04027713f, 0.06142709f, 0.10386069f, 0.08271489f, -0.05197173f, 0.01744403f, -0.06120181f, 0.09906261f, 
    -0.19366124f, 0.01445272f, 0.11296484f, 0.15130223f, -0.05213466f, -0.01346953f, -0.05670332f, 0.08288083f, 
    0.05410775f, -0.11671738f, -0.03288170f, 0.09304681f, -0.00086425f, 0.02526718f, 0.00572721f, -0.04439560f, 
    0.03293007f, 0.04966769f, -0.04477224f, -0.05127488f, -0.06111243f, 0.03754206f, -0.06382245f, 0.16597180f, 
    -0.25132823f, 0.04925827f, -0.04657486f, -0.04750257f, 0.00192456f, 0.02731443f, 0.15042347f, 0.03045751f, 
    0.12016257f, -0.07849291f, -0.08898786f, -0.03303629f, -0.43708774f, 0.13050324f, 0.23899943f, 0.12186448f, 
    -0.02055253f, -0.06351505f, -0.03712275f, 0.04572023f, 0.03336110f, 0.04793344f, -0.03790037f, 0.10980048f, 
    -0.29991114f, 0.05637411f, 0.21571088f, 0.25440812f, -0.11404580f, -0.06948389f, -0.02209630f, 0.05380195f, 
    0.05265020f, 0.16775541f, 0.09210409f, 0.07869800f, 0.02145033f, 0.06960566f, 0.05845549f, -0.08386496f, 
    -0.00712571f, 0.01509388f, 0.06684862f, -0.13265173f, -0.10790796f, -0.02556327f, -0.10442919f, 0.01496938f, 
    0.14034374f, -0.06730976f, 0.12419089f, 0.04561756f, 0.08562120f, -0.02003344f, 0.03813086f, 0.06119669f, 
    0.03026140f, 0.01676817f, -0.07968690f, 0.07997910f, 0.04519920f, 0.11286948f, -0.03628903f, 0.06430048f, 
    -0.04947441f, -0.15239030f, 0.04950338f, -0.01531253f, -0.02617025f, 0.00946534f, 0.02700596f, -0.00832145f, 
    -0.05787011f, 0.13950042f, 0.19794382f, 0.07787108f, 0.08253393f, -0.12769198f, 0.00310472f, 0.03215866f, 
    -0.16744013f, 0.11567080f, -0.20508626f, 0.13282633f, 0.10871338f, 0.01581698f, -0.09057659f, -0.07362972f, 
    0.05335119f, -0.01122952f, 0.17970760f, 0.10024685f, 0.03373936f, -0.01567669f, -0.08913135f, -0.09737407f, 
    -0.09954112f, 0.09232024f, 0.07593043f, -0.12385883f, 0.03704943f, -0.05389772f, 0.13920808f, 0.04413576f, 
    -0.03707185f, -0.01244187f, 0.05173087f, 0.03440602f, 0.39504710f, -0.00758081f, 0.08636240f, 0.10055921f, 
    -0.04222643f, -0.00370429f, -0.06318039f, 0.08078771f, 0.09157266f, -0.03484436f, 0.08639735f, -0.11699761f, 
    -0.11664166f, 0.17280494f, -0.10459455f, 0.35060039f, -0.03794334f, 0.01252070f, 0.04965942f, 0.13018189f, 
    0.13197123f, 0.07101892f, -0.00690161f, -0.05723824f, -0.27963576f, 0.12388482f, 0.04277285f, 0.05402750f, 
    0.04916035f, 0.00897012f, 0.04708736f, 0.02238553f, 0.15486984f, -0.00778041f, -0.02874992f, -0.03732399f, 
    -0.38208947f, -0.04658753f, -0.01369852f, -0.07002383f, 0.07632065f, -0.00624099f, 0.00392707f, -0.00499421f, 
    -0.09333295f, -0.01877964f, -0.05921342f, -0.05585817f, 0.30535465f, -0.13042520f, 0.02148897f, 0.02078210f, 
    -0.16994268f, -0.03305434f, -0.09044905f, -0.07943331f, 0.02060193f, 0.01599931f, 0.11185653f, -0.09287245f, 
    0.34418747f, -0.09307024f, 0.11619691f, 0.33271644f, -0.13874508f, 0.09227598f, -0.01205165f, 0.05591667f, 
    0.03455329f, 0.02153037f, 0.08717629f, -0.00877023f, -0.33959588f, -0.01708902f, 0.22444506f, -0.02093211f, 
    0.11302639f, 0.04880044f, 0.00138464f, 0.03049801f, -0.09755118f, 0.03449397f, 0.09386986f, 0.04054618f, 
    -0.12312085f, 0.16787845f, 0.14475492f, 0.04414957f, -0.00276842f, 0.03887516f, -0.06960057f, 0.01574519f, 
    0.01943360f, -0.00943193f, 0.14042559f, 0.11124755f, 0.04403648f, 0.10168461f, 0.10413305f, 0.14228699f, 
    -0.01798951f, -0.08796970f, 0.21424368f, -0.00273537f, 0.01971802f, 0.05230315f, 0.09154239f, -0.03733445f, 
    0.09913907f, -0.10289860f, 0.09543499f, 0.09575698f, 0.06138755f, 0.10514546f, 0.08889775f, 0.03155948f, 
    0.06644471f, 0.05881470f, -0.11599100f, -0.05910712f, -0.05677547f, -0.08586399f, -0.03261469f, 0.25459883f, 
    -0.02509083f, -0.03247593f, -0.01783621f, 0.01448885f, 0.06212034f, -0.10106819f, -0.00094718f, -0.10377578f, 
    0.09819245f, -0.10210615f, 0.07366014f, 0.27299166f, -0.04994254f, -0.01791387f, 0.03418647f, 0.08382695f, 
    0.07275829f, 0.03915022f, 0.04841210f, -0.10371512f, -0.13223286f, 0.10908923f, 0.00382233f, -0.04008472f, 
    -0.00988218f, 0.10049863f, 0.02764157f, -0.06614182f, -0.00593192f, -0.02443434f, -0.08523638f, 0.14945523f, 
    0.01499986f, -0.13207109f, -0.03153498f, -0.07661189f, -0.03741981f, 0.04205957f, -0.10028285f, -0.15708387f, 
    0.13319542f, 0.15240070f, 0.00269297f, 0.05292836f, 0.18578613f, -0.07129733f, 0.08743897f, -0.01702942f, 
    0.04272487f, -0.09175842f, -0.03404254f, -0.00766367f, -0.00879091f, -0.02820755f, 0.10203928f, -0.01385488f, 
    0.22285509f, 0.02482404f, -0.23919787f, -0.03716853f, -0.08308805f, -0.04550232f, -0.04791493f, 0.03588894f, 
    0.12366631f, -0.02387511f, 0.06855948f, 0.06716169f, -0.28426102f, 0.34451869f, 0.08907942f, -0.06185601f, 
    0.05203299f, -0.11571880f, 0.09209935f, -0.08900198f, 0.04963456f, -0.15100978f, -0.07488530f, -0.13344742f, 
    -0.04623891f, 0.10472118f, 0.10064399f, 0.06656587f, 0.16355412f, -0.07715779f, 0.14273575f, 0.02272055f, 
    -0.00262469f, 0.13778135f, -0.12056689f, 0.02848228f, -0.03033751f, 0.08140890f, 0.03197869f, -0.12892443f, 
    -0.08329129f, 0.00066310f, -0.01015037f, -0.09888633f, -0.03600525f, -0.09848629f, 0.02241404f, -0.06269053f, 
    -0.30911803f, -0.00090050f, -0.04875508f, 0.11619775f, 0.04042317f, -0.07794669f, -0.02833384f, 0.01999458f, 
    -0.01557675f, -0.01935148f, -0.07849069f, 0.03298081f, 0.05363682f, 0.04694076f, 0.07921750f, 0.12274131f, 
    -0.06589609f, 0.08571266f, 0.02519629f, 0.03018522f, 0.05686134f, 0.07655952f, 0.11212124f, 0.13739908f, 
    0.10949947f, 0.01823306f, -0.10763597f, 0.35087812f, -0.11935586f, -0.10779165f, 0.03314314f, 0.03063536f, 
    -0.03063781f, 0.03752226f, 0.02307239f, 0.04702980f, -0.09094815f, -0.13789877f, -0.02131298f, 0.03010377f, 
    0.08242662f, -0.03276119f, -0.10214812f, -0.08982630f, -0.09241372f, -0.00315920f, 0.04715646f, -0.11242859f, 
    -0.05118924f, -0.08579636f, 0.05021344f, 0.02112773f, 0.08821132f, 0.13579273f, -0.09070393f, 0.07299918f, 
    -0.03211852f, -0.00183848f, 0.18064915f, 0.03638846f, -0.33081588f, 0.02359715f, 0.06172940f, -0.07355848f, 
    0.01927770f, -0.07165902f, 0.11299790f, 0.02858941f, 0.00428698f, 0.00335429f, -0.02304872f, 0.13337938f, 
    -0.18392645f, 0.16228101f, 0.02349560f, 0.04076802f, -0.01169631f, 0.03212951f, -0.04362607f, 0.06741995f, 
    0.09221769f, -0.03859387f, 0.03139316f, -0.00827104f, 0.03078192f, 0.09274241f, -0.05299167f, 0.09590305f, 
    -0.04046704f, 0.01495267f, 0.07982071f, -0.06049709f, -0.05748320f, 0.01648221f, -0.12987632f, 0.01914809f, 
    -0.03445343f, 0.13824196f, 0.05319194f, 0.04531586f, -0.00258782f, -0.04077504f, -0.08612503f, -0.15335643f, 
    0.02614785f, -0.00176774f, 0.02077571f, -0.07462812f, -0.07066108f, -0.03565693f, 0.13220528f, 0.14015806f, 
    0.08930355f, 0.01540845f, -0.02246081f, 0.02463908f, 0.07137630f, 0.01618125f, 0.13765541f, 0.11513960f, 
    0.15380089f, -0.05602069f, -0.01575092f, 0.00836390f, -0.01778342f, -0.03858517f, -0.01380764f, -0.00117142f, 
    0.08685516f, 0.06689183f, -0.15648456f, 0.00348981f, -0.05390947f, 0.02805708f, 0.06477202f, -0.10028076f, 
    0.07778776f, 0.01211281f, 0.04821935f, -0.05876949f, 0.06380413f, -0.10493629f, -0.01386028f, 0.01358006f, 
    -0.36904269f, 0.16945980f, 0.14369111f, -0.06409914f, 0.02590790f, 0.02165233f, 0.01641456f, 0.05216359f, 
    -0.04144391f, 0.05760933f, 0.00502489f, 0.01636219f, 0.17038171f, 0.06227177f, 0.14418361f, 0.08674603f, 
    -0.02169347f, 0.11427875f, -0.11380821f, 0.01053221f, 0.14059982f, 0.09501102f, 0.06386195f, 0.12326568f, 
    -0.05189994f, 0.06575218f, 0.06753287f, 0.10269593f, 0.02763642f, 0.07809753f, 0.07409006f, 0.07115982f, 
    0.07775641f, -0.02594991f, 0.12502003f, 0.02383190f, -0.22505185f, -0.01248180f, -0.01821827f, 0.08614218f, 
    0.02617434f, 0.00235265f, 0.03605362f, 0.09704451f, -0.07621199f, -0.01786317f, -0.05878617f, 0.00502484f, 
    0.05965191f, -0.02007734f, -0.09811534f, -0.15536447f, 0.03611988f, 0.04144725f, -0.01703890f, -0.02959034f, 
    -0.09128048f, 0.06377861f, 0.05722427f, 0.04129561f, -0.11394755f, 0.19952863f, 0.21263573f, -0.06980025f, 
    0.00074479f, 0.01289740f, -0.03831982f, -0.00537716f, 0.17451000f, 0.04881364f, 0.10606471f, 0.06702368f, 
    -0.20758809f, -0.10497080f, -0.00469810f, 0.07285421f, 0.05450955f, 0.10748144f, -0.14501002f, 0.08350454f, 
    0.00272740f, 0.08056414f, 0.02914002f, 0.16273543f, 0.09118710f, -0.08217890f, -0.22698247f, -0.05136412f, 
    0.05913790f, 0.07482716f, 0.04009644f, 0.08832159f, 0.00687357f, 0.02333976f, 0.07855000f, 0.05226221f, 
    0.16335796f, -0.00783560f, -0.20138550f, -0.20961638f, -0.07713148f, 0.01917835f, 0.02787757f, -0.00618011f, 
    0.04352263f, 0.06241001f, 0.02113249f, 0.04726765f, 0.11907281f, -0.14529040f, 0.13891123f, 0.13119467f, 
    0.01594666f, -0.01062608f, 0.04568960f, 0.04142582f, 0.03219553f, -0.03256463f, -0.11613616f, -0.06199260f, 
    0.21236195f, -0.24518360f, -0.11365838f, -0.12332810f, 0.01154897f, 0.06983823f, -0.09969890f, 0.02872239f, 
    -0.03266891f, 0.05239919f, -0.06035607f, -0.02510133f, -0.24935739f, 0.28070495f, -0.08234359f, 0.00683534f, 
    -0.10308941f, 0.00755106f, 0.02921849f, -0.08659796f, 0.15256456f, 0.05980186f, 0.01379786f, 0.08155390f, 
    -0.53949749f, 0.01030619f, 0.10315910f, -0.04900911f, 0.06928258f, 0.01541105f, 0.02598086f, 0.03838553f, 
    0.07129417f, -0.01954294f, -0.09108029f, 0.01424883f, 0.34531769f, 0.01255609f, 0.06624644f, 0.13467808f, 
    0.01250753f, -0.01929947f, 0.04485165f, 0.04160688f, -0.13870059f, -0.02070746f, -0.14878887f, -0.02354772f, 
    0.07714362f, -0.01163676f, 0.12126014f, -0.03018829f, 0.09848553f, 0.10381202f, 0.08491323f, 0.03176745f, 
    0.03539752f, -0.01311466f, -0.11740756f, -0.06498168f, -0.00810116f, 0.30623001f, 0.06025263f, 0.05437258f, 
    0.07573999f, 0.01391598f, -0.03420836f, -0.07500383f, 0.03027321f, -0.13794604f, 0.00292724f, -0.11848384f, 
    0.39817333f, -0.08949518f, 0.01280008f, -0.16666678f, 0.01040487f, -0.00587471f, -0.03705171f, -0.04591160f, 
    0.02748982f, -0.02286400f, -0.21081169f, 0.01075969f, -0.09501650f, -0.06159028f, 0.15986495f, 0.05996472f, 
    0.06036903f, -0.11473999f, 0.27432147f, -0.14512876f, -0.06812377f, -0.07128227f, 0.01942264f, -0.02035939f, 
    0.04669133f, -0.04428324f, -0.06192654f, -0.03990568f, 0.02755359f, -0.02461664f, 0.00171683f, -0.04828271f, 
    -0.01371595f, -0.11449335f, 0.14128846f, -0.07109848f, 0.13294564f, -0.26031977f, -0.13402356f, 0.10509048f, 
    -0.11623657f, -0.02089601f, 0.06921467f, -0.03574978f, 0.00011224f, -0.02488607f, 0.16422451f, 0.16024141f, 
    0.13014041f, -0.17769451f, 0.18329710f, 0.39576480f, 0.01439492f, 0.07094727f, 0.02070250f, 0.07058524f, 
    0.01483142f, 0.00201844f, 0.05274468f, 0.23357067f, 0.04832487f, -0.12890044f, 0.38694420f, 0.33741966f, 
    -0.13226850f, -0.00692683f, 0.01767223f, -0.01617130f, 0.09658656f, 0.03461543f, -0.01976499f, 0.18258049f, 
    0.01710468f, -0.03498289f, -0.03136513f, 0.01360618f, -0.01516181f, -0.01385423f, -0.01300501f, 0.01183472f, 
    -0.01388362f, 0.02675790f, -0.03118111f, 0.00423862f, -0.01924108f, -0.04040560f, -0.01184572f, 0.01935745f, 
    0.02908853f, -0.02642853f, -0.03947202f, 0.02961235f, -0.01270783f, -0.03057425f, -0.02276703f, -0.01809185f, 
    -0.01834510f, -0.00483384f, 0.01828353f, -0.02828111f, -0.03552935f, -0.00041199f, 0.00754249f, 0.00366380f, 
    0.03022690f, -0.00157564f, -0.00336254f, -0.04039917f, 0.01787602f, 0.02326713f, -0.03467005f, -0.02201145f, 
    -0.03196362f, -0.02551559f, 0.01179789f, -0.03407879f, -0.03366535f, 0.02391190f, 0.03198265f, 0.02203666f, 
    -0.02455509f, 0.00457468f, -0.03911827f, 0.02152868f, -0.00661823f, 0.03331622f, -0.01173607f, 0.02477152f, 
    -0.00429692f, -0.03967360f, -0.02930531f, -0.00316144f, 0.00087253f, -0.00615999f, -0.02241338f, 0.00070920f, 
    -0.02347794f, 0.01247584f, -0.03468777f, 0.00617914f, 0.00912651f, -0.00065903f, -0.01153793f, -0.02017071f, 
    -0.01156746f, -0.02204999f, -0.03809435f, 0.01056483f, 0.01357361f, 0.02031901f, 0.02194968f, -0.01573433f, 
    0.00117943f, 0.01284597f, -0.02118223f, -0.03281211f, 0.00044364f, 0.01630628f, 0.00123200f, -0.03004408f, 
    -0.03395875f, 0.02818017f, -0.01150235f, -0.04138360f, -0.01395774f, -0.03079468f, -0.01599759f, -0.01805005f, 
    0.02560661f, -0.00119044f, -0.02956846f, -0.01857447f, 0.00116623f, -0.01397651f, -0.04146510f, 0.02844746f, 
    0.01925573f, -0.01887356f, -0.03029260f, 0.01778999f, -0.02401187f, -0.01940025f, -0.01394710f, -0.03156028f, 
    0.00368574f, 0.01891831f, -0.03004463f, 0.02937302f, 0.02415027f, 0.02255960f, 0.01721203f, 0.01837092f, 
    0.01085315f, -0.01986902f, -0.02382041f, 0.02470445f, 0.02707125f, -0.03742047f, -0.00320782f, 0.01018896f, 
    0.00154319f, 0.02714365f, 0.01230792f, 0.00642260f, -0.02803660f, -0.03328961f, -0.03901181f, 0.02772084f, 
    -0.04025632f, -0.03510955f, -0.00037817f, -0.03963673f, 0.00012545f, -0.01698471f, -0.02335585f, -0.03057238f, 
    -0.03809897f, -0.03310171f, 0.01320828f, -0.02894185f, -0.03008818f, 0.00840215f, -0.02587471f, -0.00131558f, 
    -0.03625758f, 0.01040317f, -0.00797433f, 0.02964671f, 0.02793597f, -0.00866785f, -0.03248055f, 0.01275525f, 
    -0.00697821f, 0.01549166f, -0.01670470f, 0.01026839f, 0.00654391f, -0.04080572f, -0.03845652f, -0.01819224f, 
    -0.02316172f, -0.01989735f, -0.00821749f, -0.03875342f, 0.03025292f, -0.01472278f, -0.02805567f, -0.02970641f, 
    0.00555111f, -0.02406185f, 0.02606278f, -0.02273781f, 0.02104753f, 0.01999215f, -0.01804690f, -0.01844581f, 
    -0.01743574f, 0.02644305f, -0.00652170f, -0.01831339f, -0.02988318f, 0.01945149f, -0.00198549f, -0.02661983f, 
    -0.04142095f, -0.02837780f, -0.00439783f, 0.01876497f, -0.03104709f, 0.00086873f, -0.03555142f, -0.01317508f, 
    -0.03449712f, 0.00540479f, -0.03916530f, 0.00758396f, -0.01652936f, 0.02285811f, -0.00259752f, -0.03664385f, 
    -0.01370430f, -0.01711645f, 0.03045115f, 0.00576336f, -0.02434563f, -0.02362503f, 0.02008622f, 0.00193987f, 
    -0.00194077f, 0.01358413f, 0.02598821f, 0.00312506f, 0.00972637f, -0.03245359f, -0.03002086f, 0.00938369f, 
    0.00959240f, 0.02352062f, -0.01695576f, 0.03033373f, -0.02857661f, 0.03013701f, 0.00741768f, -0.01919946f, 
    0.01801573f, 0.02681136f, 0.00876270f, 0.02356675f, -0.00713647f, 0.01602262f, 0.00293192f, -0.03459372f, 
    0.00085920f, -0.02021057f, -0.00733929f, 0.00473759f, 0.02380923f, -0.00020053f, 0.02310193f, 0.02911724f, 
    0.00749932f, -0.01784591f, -0.01434264f, 0.02826986f, 0.02358877f, 0.00685441f, -0.01388312f, -0.01267096f, 
    0.01083378f, 0.01277370f, -0.02640160f, 0.01407447f, -0.02409111f, -0.03393213f, -0.03111186f, -0.00734677f, 
    -0.00534142f, -0.03612207f, -0.00580142f, -0.02043300f, 0.03463069f, -0.03666763f, -0.00785991f, 0.01071457f, 
    0.00042475f, -0.01695998f, 0.01666732f, -0.03571327f, -0.00929806f, 0.00444936f, -0.03100484f, -0.02706319f, 
    0.00122901f, 0.01673331f, -0.02482485f, 0.02124620f, -0.03772910f, -0.02057311f, 0.00941276f, -0.01921215f, 
    0.01122493f, 0.01916032f, -0.03485791f, -0.03593630f, -0.02662110f, -0.03103948f, 0.01142452f, -0.03304038f, 
    0.00693683f, -0.02505540f, -0.00235238f, -0.02769196f, 0.02919185f, -0.02215668f, -0.00933695f, -0.02349242f, 
    -0.00422145f, -0.03088177f, -0.03868810f, 0.02561631f, -0.00255353f, 0.02167898f, -0.00306155f, 0.01160687f, 
    -0.01354527f, -0.00546657f, -0.03717302f, 0.02067255f, -0.00908263f, 0.03051214f, 0.00774218f, -0.00868080f, 
    0.03027022f, 0.02042669f, -0.01281312f, -0.03018044f, -0.00571199f, -0.01782565f, -0.00629689f, 0.02565861f, 
    0.01101094f, -0.02657287f, -0.00193678f, -0.03704828f, -0.00185406f, -0.03175896f, -0.00389549f, 0.01346773f, 
    -0.02051701f, -0.03325567f, 0.00676437f, 0.02333704f, 0.01733914f, -0.03965029f, -0.01860124f, -0.00416093f, 
    -0.03061049f, 0.01745770f, -0.03823794f, 0.02536015f, -0.03079714f, 0.01107008f, 0.02538361f, -0.02400477f, 
    0.02003787f, 0.01851308f, -0.00283121f, -0.00769391f, -0.02668942f, -0.00979111f, -0.01992453f, 0.02610842f, 
    0.00298381f, 0.01736800f, -0.00109272f, 0.00106659f, -0.00280470f, -0.00990932f, 0.00820250f, -0.01911029f, 
    -0.01918573f, 0.00394587f, 0.02556495f, -0.04159946f, -0.00301793f, -0.00580477f, 0.02147663f, -0.03514946f, 
    0.01860473f, 0.00871344f, -0.03092074f, -0.00920465f, -0.02566876f, 0.00241822f, 0.00602302f, -0.03009874f, 
    0.00920194f, -0.03706784f, -0.00310458f, -0.01272004f, -0.03576048f, -0.01920421f, -0.02927133f, 0.00232268f, 
    -0.01660717f, -0.02323372f, 0.02483621f, -0.03257941f, 0.02590784f, 0.02311094f, -0.00353436f, 0.01452419f, 
    -0.04095947f, -0.03777089f, -0.00239655f, -0.03597970f, -0.00460829f, -0.02174327f, 0.01219561f, -0.03933076f, 
    -0.03477376f, 0.01140680f, -0.02907305f, -0.02260723f, -0.02150072f, -0.00752264f, -0.03835015f, -0.02505723f, 
    0.02186382f, 0.02219192f, -0.00175681f, 0.02852421f, -0.00645020f, 0.00520511f, 0.01347265f, -0.03347825f, 
    -0.03395519f, -0.04024807f, 0.02709457f, -0.00644269f, -0.00544241f, 0.01902352f, -0.02048025f, 0.00478100f, 
    0.01712422f, 0.02891321f, 0.02729461f, 0.03204861f, 0.00816804f, -0.03127859f, -0.01509933f, 0.02415905f, 
    -0.00640768f, -0.02498179f, -0.03040378f, -0.00796536f, -0.03543260f, -0.01102337f, -0.04028768f, -0.01582354f, 
    0.02095549f, -0.00644207f, 0.02550622f, -0.03127145f, 0.01044508f, 0.00568074f, -0.00592505f, -0.03880817f, 
    -0.03067881f, 0.02476160f, -0.00664178f, 0.00678092f, -0.02992074f, 0.01889824f, 0.02618166f, -0.02851403f, 
    -0.01600570f, -0.00586144f, -0.01404888f, -0.02879948f, -0.02387408f, -0.00003488f, -0.02089194f, -0.01581412f, 
    0.00944715f, -0.02300517f, -0.02788236f, 0.02500990f, 0.01450560f, 0.01568739f, -0.03502452f, 0.02030276f, 
    0.00259202f, 0.02850836f, 0.02808878f, -0.03933273f, -0.01271854f, -0.02739442f, -0.03747122f, -0.01915809f, 
    -0.03162860f, -0.04086727f, -0.00935486f, -0.01673939f, -0.02559674f, -0.01770721f, -0.01460383f, -0.03490097f, 
    0.01386426f, -0.03036249f, 0.02069127f, 0.01534075f, 0.00595607f, 0.00939921f, 0.01905738f, -0.00146959f, 
    0.00189349f, -0.03720373f, 0.03441232f, 0.02754663f, 0.00720019f, 0.02374830f, 0.01829115f, -0.03520229f, 
    -0.02048083f, -0.00019264f, -0.01792880f, -0.03196119f, 0.02024905f, 0.00637511f, -0.01586721f, -0.01677726f, 
    0.03038732f, -0.02760316f, -0.00795356f, -0.01322395f, 0.00354524f, 0.02650534f, 0.01860943f, 0.01173829f, 
    -0.00768595f, 0.01219880f, -0.02989458f, 0.00542230f, -0.03443790f, 0.02674142f, 0.00959645f, -0.03508432f, 
    0.02104814f, -0.01768167f, -0.02072689f, -0.02181274f, -0.01167698f, 0.00807887f, -0.01310793f, -0.01701453f, 
    0.02394307f, -0.01082398f, -0.00953415f, -0.00160615f, -0.00833515f, 0.01565701f, 0.02605552f, 0.01928975f, 
    0.03029908f, -0.01776171f, -0.03409969f, -0.04003052f, -0.01101191f, -0.00771496f, -0.01583853f, 0.00240288f, 
    -0.00260605f, -0.03285678f, -0.03357565f, 0.01933490f, 0.01809863f, 0.00389187f, 0.02116970f, -0.01435052f, 
    0.01896296f, -0.00156676f, -0.01904813f, -0.01879587f, -0.00636522f, -0.02773090f, -0.02517340f, -0.01256914f, 
    0.02598605f, 0.00852784f, -0.01561058f, -0.01771950f, 0.02790943f, -0.00954730f, 0.01395296f, 0.00556922f, 
    0.02311194f, -0.00248030f, 0.00451033f, -0.02730689f, 0.00069667f, -0.03638153f, -0.02452448f, -0.02293215f, 
    0.01543869f, 0.03425791f, 0.02059105f, 0.02002183f, 0.02344011f, -0.04026271f, -0.02764838f, 0.01276808f, 
    0.01248305f, 0.00460375f, 0.00849441f, -0.03944828f, -0.00281935f, -0.02414134f, -0.03100282f, -0.00924819f, 
    -0.02625377f, 0.00035175f, -0.01820628f, 0.02494349f, -0.00216932f, -0.01805206f, -0.02509334f, -0.00834439f, 
    0.01093599f, -0.02956794f, -0.03253221f, -0.03725701f, -0.01127757f, -0.02207058f, 0.00203726f, -0.02209760f, 
    -0.01305223f, -0.01148916f, 0.00295720f, -0.00931841f, 0.02814592f, 0.01379201f, -0.01860512f, 0.02251735f, 
    -0.02140661f, 0.02112094f, 0.01660813f, -0.03086470f, 0.00403214f, -0.03896363f, -0.01085822f, -0.00221118f, 
    0.02821221f, -0.01622662f, -0.03425815f, 0.02634119f, 0.01060029f, 0.02492991f, 0.00817828f, 0.02472919f, 
    -0.02831141f, -0.00610166f, -0.02613415f, 0.00170106f, 0.00506848f, 0.01834455f, -0.03214866f, -0.00078988f, 
    -0.00946782f, 0.02137563f, 0.02720612f, -0.00461496f, -0.00830960f, 0.01085850f, -0.03101790f, 0.02654018f, 
    0.00549414f, -0.02303465f, -0.00224493f, 0.01209473f, 0.00713994f, -0.01980742f, -0.02031863f, -0.03107258f, 
    -0.01542936f, -0.02350613f, -0.01602916f, -0.03317584f, -0.00998982f, -0.01557439f, -0.00153749f, -0.01081312f, 
    0.00704859f, -0.02182600f, -0.02178466f, -0.03197912f, 0.00434056f, -0.03123819f, -0.00347303f, -0.01176910f, 
    -0.03890960f, 0.02104620f, -0.01422119f, 0.02187158f, 0.02908168f, -0.03194403f, -0.01067114f, -0.00740480f, 
    0.02621571f, 0.01092932f, -0.01838005f, 0.01784282f, 0.00643410f, 0.00147604f, 0.02203192f, 0.01975581f, 
    0.01984207f, -0.03083259f, -0.00949282f, -0.01673361f, 0.01417095f, -0.01852764f, 0.02491772f, -0.03832379f, 
    -0.01246958f, 0.01645934f, 0.01689574f, -0.04032762f, 0.02360923f, -0.01954291f, 0.02720523f, -0.03881869f, 
    0.02004412f, -0.00148665f, 0.00998058f, 0.00251934f, -0.00099212f, 0.02184763f, -0.00792915f, -0.02641143f, 
    -0.02976849f, -0.03220481f, -0.03472775f, -0.01586387f, 0.01966561f, 0.01713915f, -0.02789575f, 0.00844361f, 
    0.02628177f, -0.02201891f, 0.02604223f, -0.02160003f, -0.00341018f, 0.00206108f, -0.00179686f, -0.04054128f, 
    -0.02357825f, -0.01174503f, 0.02684248f, -0.03530416f, -0.03715955f, 0.02803237f, -0.01646441f, -0.00025252f, 
    -0.01394326f, 0.03592098f, 0.01227220f, -0.03416987f, 0.00233676f, -0.03252429f, 0.00431621f, 0.01151696f, 
    -0.01073399f, 0.02147126f, -0.02644257f, 0.00703072f, -0.00980452f, -0.04112998f, -0.00822260f, 0.02880189f, 
    -0.03384342f, 0.13116772f, 0.01407030f, -0.19617483f, 0.12950930f, 0.07225002f, 0.08196475f, 0.09760220f, 
    -0.01714174f, -0.08807828f, -0.02778098f, 0.09609835f, 0.02503664f, -0.03093812f, -0.03814579f, 0.03969223f, 
    0.01548380f, 0.02075624f, -0.09524599f, -0.12240354f, -0.00698199f, -0.04721986f, -0.00087491f, 0.07728538f, 
    -0.00377250f, -0.14427340f, -0.06406070f, 0.03640500f, 0.02813973f, 0.01339759f, 0.16037223f, 0.02991637f, 
    0.04147941f, 0.05738519f, -0.06169147f, -0.11787468f, 0.18567586f, 0.06691947f, -0.09254221f, -0.02406065f, 
    0.02531214f, -0.04214395f, 0.09050271f, 0.00670097f, -0.01355405f, -0.03446281f, 0.08714385f, 0.15904994f, 
    0.18643478f, -0.07059023f, 0.02877715f, 0.12676494f, 0.08720575f, -0.05898374f, -0.04925867f, 0.01118272f, 
    -0.01580620f, 0.08354322f, 0.06521348f, 0.17696786f, 0.04524566f, -0.02165888f, -0.00393508f, 0.14324021f, 
    0.18285249f, 0.08323415f, 0.06235326f, -0.14650765f, -0.04324558f, 0.00819698f, -0.11493641f, 0.15969540f, 
    0.00774024f, -0.22304885f, -0.01338082f, 0.03338052f, 0.05445718f, -0.02734052f, 0.05062234f, 0.02232160f, 
    0.05603307f, 0.00078083f, -0.05270297f, -0.04289325f, -0.06828416f, 0.26144707f, 0.00346582f, 0.32642928f, 
    0.03963997f, -0.03955342f, 0.00858101f, -0.03573123f, 0.09353624f, 0.08245692f, 0.05794940f, 0.02068497f, 
    0.06455030f, 0.11220007f, 0.08891509f, -0.00697980f, -0.07081725f, -0.13074946f, 0.02593016f, 0.07136011f, 
    -0.12978120f, 0.00076021f, -0.16824880f, 0.16087781f, -0.03750771f, 0.00946812f, -0.04773793f, 0.11375841f, 
    0.13866636f, 0.16048448f, 0.02036597f, 0.04726842f, -0.04972043f, 0.03659672f, -0.06679042f, -0.16679887f, 
    0.03000816f, -0.00502126f, -0.06970995f, 0.09753412f, 0.00548748f, 0.07662806f, 0.04189479f, -0.08362089f, 
    0.06360678f, 0.15580262f, 0.08197008f, 0.05539956f, -0.02139331f, 0.04903879f, 0.06944851f, -0.12330627f, 
    -0.03012750f, -0.08562226f, -0.06867706f, 0.05245364f, 0.01610276f, 0.03733913f, 0.04653145f, -0.12568237f, 
    0.01067259f, -0.08949577f, -0.10673419f, 0.03947172f, 0.08211081f, -0.24174048f, 0.06446225f, 0.12219401f, 
    0.08965358f, 0.06453601f, -0.15491551f, -0.05045098f, -0.09675937f, -0.04512406f, 0.05858482f, 0.09257697f, 
    -0.05301799f, 0.00553624f, 0.02594952f, -0.00515081f, 0.08930738f, -0.08193571f, -0.05929752f, 0.08610108f, 
    -0.22882007f, 0.03336460f, 0.02601804f, -0.12851605f, 0.13374881f, -0.06626027f, -0.02983004f, 0.03477117f, 
    0.06577367f, 0.00477721f, 0.02142464f, 0.05989924f, -0.02341215f, 0.01823965f, -0.04596295f, -0.13457948f, 
    -0.08317856f, 0.02882904f, -0.01817419f, -0.05070042f, -0.01938071f, -0.00683489f, 0.11444809f, 0.01049636f, 
    -0.01106682f, -0.08389920f, 0.02555536f, 0.11830463f, 0.13164712f, 0.11641155f, 0.00141513f, -0.00867201f, 
    -0.02811884f, -0.02227868f, 0.08994831f, 0.04779701f, -0.23356187f, -0.09370936f, 0.05606313f, -0.07172026f, 
    0.06351684f, 0.03027355f, 0.09927862f, -0.10530350f, -0.06420190f, -0.04438638f, 0.22151718f, -0.07178936f, 
    0.15470077f, -0.07117274f, -0.10058725f, -0.06470741f, -0.03554029f, -0.02309524f, -0.11581257f, -0.05418498f, 
    0.03200735f, -0.00414923f, 0.20804092f, 0.06497191f, -0.19530992f, -0.08910476f, -0.01669201f, 0.10175109f, 
    0.01797023f, 0.00427178f, 0.10602059f, -0.03183110f, 0.02828125f, 0.06095865f, 0.08393460f, 0.00834333f, 
    -0.07356480f, -0.05842974f, 0.05447469f, 0.04135036f, 0.09903983f, 0.09565034f, 0.04098954f, 0.06665356f, 
    0.18553035f, -0.02465823f, -0.01526831f, 0.08963051f, 0.02669341f, -0.04287613f, -0.00780951f, 0.04345338f, 
    0.13319011f, -0.04353344f, -0.02237378f, -0.04557339f, 0.04041246f, -0.04739426f, 0.11149264f, -0.03985808f, 
    -0.01133723f, -0.04513734f, 0.05176438f, -0.02947742f, 0.09814169f, 0.06016143f, -0.01436201f, 0.08477002f, 
    0.05079013f, 0.13190342f, 0.09769226f, -0.12018069f, -0.04586654f, -0.03824874f, -0.03438841f, 0.04404027f, 
    -0.04865591f, 0.08004551f, 0.03260181f, -0.08133538f, -0.05468388f, -0.02623901f, -0.11142680f, 0.14005254f, 
    0.04978729f, 0.07976384f, -0.18118203f, 0.16398415f, 0.00837279f, 0.03641799f, -0.07627086f, -0.04151410f, 
    0.06309306f, -0.04343635f, -0.09548498f, 0.03127704f, 0.03474523f, -0.02176169f, -0.03215134f, 0.06309027f, 
    0.09483366f, 0.08397754f, -0.04250410f, -0.04559932f, -0.11450322f, 0.12422728f, 0.05525136f, 0.01774156f, 
    -0.02609782f, 0.14671461f, 0.09121000f, -0.21170293f, -0.02364864f, -0.03834283f, -0.06356733f, 0.00725541f, 
    0.02643180f, -0.01993851f, 0.01369986f, -0.09646378f, -0.23437062f, -0.21013606f, 0.09451898f, 0.05959047f, 
    0.02445097f, -0.02333139f, 0.11104056f, 0.01021408f, 0.06712501f, -0.17465669f, 0.02994160f, -0.04029761f, 
    -0.26492548f, -0.07953469f, 0.08836989f, -0.00006593f, 0.10752940f, -0.01833782f, 0.09479398f, -0.08572071f, 
    0.10555397f, 0.03907673f, -0.09840599f, 0.01144823f, 0.11016701f, 0.00645285f, -0.07472774f, 0.00910671f, 
    -0.14972694f, -0.08206912f, 0.01697915f, 0.09655597f, 0.00816559f, 0.02778428f, -0.00835296f, -0.07843839f, 
    -0.20837322f, -0.04305510f, 0.14642645f, 0.02419385f, 0.12866189f, -0.15986595f, -0.02383694f, 0.05937538f, 
    0.04402914f, 0.00303310f, -0.01218696f, -0.02589686f, -0.03511636f, -0.11935595f, 0.09171227f, 0.06637602f, 
    -0.00837107f, 0.05526291f, -0.07564052f, -0.08012453f, -0.00097669f, -0.02760476f, 0.04716138f, 0.06036104f, 
    0.06456488f, -0.06777766f, 0.19182877f, 0.16119561f, 0.05440224f, -0.00328081f, -0.04342475f, -0.01511867f, 
    0.00708492f, 0.04608735f, -0.06231508f, 0.05287974f, -0.06370732f, 0.23918481f, -0.06007497f, 0.02576124f, 
    -0.04166847f, 0.00691223f, -0.10129970f, -0.06586461f, 0.01140651f, -0.15945515f, 0.02866653f, -0.04772031f, 
    -0.26060525f, -0.10682387f, -0.07771444f, -0.03993395f, 0.09457446f, 0.13135839f, -0.09804222f, -0.00021883f, 
    0.02305617f, 0.12656009f, 0.08186853f, 0.10205448f, -0.44975019f, 0.07004261f, -0.12388641f, -0.05153329f, 
    0.04738911f, -0.02496041f, 0.07239764f, 0.05618072f, -0.00672607f, 0.02119893f, -0.01973792f, 0.05073545f, 
    0.07045047f, -0.09874150f, 0.09162251f, 0.10113873f, 0.06396978f, -0.01623123f, -0.16548125f, 0.04571753f, 
    0.10456292f, 0.01491616f, 0.07368108f, 0.02454600f, 0.12445949f, 0.03064254f, -0.05878191f, 0.04986182f, 
    0.01723022f, -0.09086227f, -0.01827613f, 0.06656174f, 0.00572145f, -0.08369529f, -0.11984607f, -0.03650167f, 
    -0.10492458f, 0.18796763f, 0.03087942f, 0.00484750f, 0.03919043f, -0.05970486f, -0.07106028f, -0.08917169f, 
    -0.02697773f, -0.06898115f, 0.03037445f, 0.01394076f, 0.09396356f, -0.01195135f, -0.11361656f, -0.10004906f, 
    0.09000499f, 0.03377764f, 0.00186314f, 0.07497870f, -0.12039910f, 0.02941491f, 0.25259823f, 0.01845983f, 
    -0.07518227f, 0.14402831f, -0.00686309f, -0.06243701f, 0.13646868f, -0.18472983f, 0.06869803f, 0.01147863f, 
    0.09284141f, 0.13648644f, -0.13691324f, 0.01636070f, -0.16441450f, -0.12605053f, -0.00027992f, -0.06502576f, 
    0.05425057f, 0.01200924f, 0.15962972f, -0.13400307f, -0.00594223f, 0.01398195f, -0.01258381f, 0.11209701f, 
    -0.07328926f, -0.01871163f, 0.11848737f, -0.05050210f, 0.00688994f, -0.03604331f, 0.15901019f, -0.11360588f, 
    0.10926776f, -0.05184292f, 0.06392577f, 0.00950841f, 0.03209584f, -0.06833307f, 0.11302723f, -0.04725846f, 
    0.03894363f, 0.09203617f, 0.04768762f, -0.04684477f, 0.04640920f, 0.08896703f, 0.06537566f, 0.02048027f, 
    -0.21554904f, 0.05483837f, -0.11375233f, 0.02446171f, 0.12150529f, 0.13285993f, -0.01763155f, 0.03129856f, 
    0.01841444f, -0.03900103f, 0.11313063f, 0.03446726f, 0.00979341f, 0.09515715f, -0.14448805f, -0.04666911f, 
    -0.02174682f, -0.07046542f, 0.06549827f, 0.15680587f, -0.00700672f, -0.10087878f, -0.04483997f, -0.09707849f, 
    0.05197990f, 0.18932925f, 0.08061974f, 0.04212209f, -0.00745971f, 0.00927486f, -0.03884643f, -0.03603514f, 
    -0.05442736f, 0.00230501f, 0.12421469f, 0.04351739f, -0.01422079f, -0.05884129f, 0.10942586f, 0.21292230f, 
    0.02409807f, -0.00008681f, -0.06877024f, 0.03181293f, 0.12145281f, 0.01245404f, 0.14879927f, 0.03383116f, 
    0.03792421f, -0.11007401f, 0.10848767f, -0.11074958f, 0.02233773f, 0.00766389f, -0.02195380f, 0.10423617f, 
    0.06482434f, 0.01950506f, 0.06970799f, 0.07930249f, -0.11783239f, 0.21984066f, -0.05876334f, -0.04947092f, 
    0.11021733f, 0.02695440f, -0.03021631f, 0.09689987f, 0.15400533f, 0.00281446f, 0.08522794f, -0.04039453f, 
    0.08313718f, 0.28221878f, -0.11937646f, 0.04671113f, 0.06066442f, 0.03951235f, 0.06783472f, -0.06557804f, 
    0.10680816f, -0.05181985f, -0.04743134f, 0.13929673f, 0.02463770f, 0.00368854f, 0.00491410f, 0.15666761f, 
    0.15228947f, 0.07983050f, 0.02608977f, 0.00067040f, 0.04494138f, 0.05231344f, 0.00149033f, -0.00976087f, 
    0.05957046f, 0.11305361f, -0.03594728f, 0.11413601f, 0.09583839f, -0.03858467f, 0.05181146f, -0.05542533f, 
    0.05094505f, 0.10594234f, -0.04069863f, -0.13420123f, 0.01816885f, -0.02267759f, -0.03896913f, -0.01106315f, 
    0.03871431f, 0.04386898f, 0.09556618f, -0.00639750f, 0.05105674f, 0.07131641f, 0.05795714f, 0.04278652f, 
    -0.25973132f, -0.15946697f, 0.10459467f, -0.15439613f, 0.03389221f, -0.12041986f, -0.00189871f, -0.01421331f, 
    0.04739145f, 0.01805697f, 0.00617202f, 0.00140302f, 0.23090264f, 0.07146082f, 0.03474838f, -0.01315454f, 
    0.00263049f, -0.07826736f, 0.05197852f, -0.09300290f, -0.03417306f, -0.08532852f, -0.15056333f, 0.05525407f, 
    -0.04849106f, -0.02949944f, 0.02649721f, 0.01879941f, 0.07956120f, 0.11874000f, 0.07165913f, -0.00456255f, 
    0.02615375f, -0.02949874f, -0.10618260f, -0.02691702f, -0.25024402f, -0.07240451f, -0.03479688f, 0.03997965f, 
    0.06736235f, 0.11570451f, 0.02720127f, -0.07027320f, -0.03023046f, -0.07390414f, 0.00791491f, -0.06745086f, 
    -0.03574090f, 0.03235635f, 0.00711774f, -0.01497665f, 0.11687849f, -0.00735238f, -0.03524062f, -0.08756342f, 
    0.07159454f, 0.01932278f, -0.07525446f, 0.00390857f, -0.19467247f, -0.14956114f, 0.15538442f, -0.02299090f, 
    0.04107808f, -0.16481011f, 0.15665537f, -0.05253614f, 0.00591865f, 0.01571111f, 0.07080222f, 0.07274807f, 
    -0.22984713f, 0.04518148f, -0.13281946f, -0.00377780f, 0.05671677f, 0.02407340f, -0.11274216f, -0.06464044f, 
    0.04108473f, -0.02874872f, 0.10952144f, -0.07248377f, 0.26574153f, 0.07649101f, -0.00332076f, -0.12735589f, 
    0.08196859f, -0.07108303f, 0.00014882f, 0.04810931f, -0.01948395f, -0.02835305f, 0.11128984f, 0.11230520f, 
    0.06187341f, 0.00722359f, 0.03312622f, -0.00895972f, 0.06839199f, 0.02335813f, 0.05418202f, 0.01406802f, 
    -0.05954966f, 0.03759690f, 0.12054963f, 0.16158244f, -0.03525852f, 0.09447802f, 0.01020874f, 0.17810705f, 
    -0.03859086f, 0.06272106f, 0.02765489f, -0.04503423f, 0.07744598f, -0.01130351f, 0.02554486f, 0.09260882f, 
    0.35425335f, -0.04410963f, -0.15862228f, -0.08928580f, -0.02764786f, 0.06161407f, -0.13098693f, 0.04496546f, 
    -0.04369074f, 0.13991165f, 0.07682977f, 0.11657474f, -0.10584940f, 0.04244550f, -0.00619598f, -0.10499214f, 
    -0.00311604f, -0.17904183f, 0.05221843f, 0.05564880f, 0.06233291f, 0.05179118f, -0.04187397f, -0.04112769f, 
    -0.00578238f, -0.00333129f, -0.04543877f, 0.00603173f, 0.01205242f, -0.12168787f, -0.07359067f, -0.04060643f, 
    0.09244788f, 0.09989664f, -0.08513536f, 0.14259699f, 0.12439745f, -0.13891159f, -0.29549760f, -0.18297178f, 
    -0.01390040f, 0.13891122f, -0.08061395f, -0.04763343f, 0.11949204f, 0.04605828f, 0.18531802f, -0.02196830f, 
    -0.00222476f, 0.03747739f, -0.10777047f, -0.09859443f, 0.05869640f, 0.05489022f, -0.00355240f, -0.04918127f, 
    0.05348928f, 0.13657476f, -0.02126038f, 0.08361057f, 0.20995671f, -0.02882799f, -0.02642074f, -0.10697157f, 
    0.03447184f, 0.03013586f, -0.04750466f, 0.05977921f, -0.03053778f, -0.09995335f, -0.01422452f, 0.05579280f, 
    -0.07587048f, -0.03376647f, -0.12195531f, -0.14253610f, -0.04145965f, 0.01896561f, 0.00881357f, 0.02684901f, 
    0.15326267f, -0.20439009f, -0.07671565f, -0.00836599f, -0.12586510f, 0.02008032f, 0.04978113f, -0.27492034f, 
    -0.05825632f, -0.03118612f, -0.00076077f, -0.02644141f, -0.06020345f, 0.05697366f, 0.01608615f, 0.13592339f, 
    0.00289060f, -0.02726459f, -0.10640351f, -0.21125321f, 0.14426486f, -0.03878486f, -0.02405808f, -0.00354824f, 
    0.12936454f, 0.05244377f, 0.05594429f, 0.07447200f, -0.02947600f, -0.26223764f, -0.00488609f, 0.00142078f, 
    -0.08293702f, 0.03314717f, -0.01170719f, 0.04570792f, -0.04840840f, 0.08601687f, -0.10844409f, -0.02562016f, 
    0.13162178f, -0.03846963f, -0.07961366f, -0.01272591f, 0.01079496f, 0.03226352f, 0.05069774f, 0.09054288f, 
    0.03508745f, 0.01301674f, -0.05430540f, -0.05851079f, -0.08336987f, -0.12845762f, -0.00331540f, 0.14899950f, 
    -0.05905449f, -0.06135691f, 0.02781973f, 0.05880343f, -0.06795154f, -0.03790985f, 0.03810306f, 0.01025738f, 
    0.14803693f, -0.06647135f, 0.08242896f, 0.12978171f, 0.08284420f, -0.00025850f, 0.09650452f, 0.00937756f, 
    0.04436695f, -0.09367836f, -0.08620297f, 0.12086014f, 0.13899438f, 0.16496976f, -0.00784369f, 0.14436372f, 
    -0.02320973f, 0.12789455f, -0.02441302f, -0.00441920f, 0.05726328f, -0.03836832f, 0.09415910f, 0.05915146f, 
    -0.01301117f, 0.04903968f, -0.20034967f, 0.21291089f, -0.04213105f, -0.11948648f, -0.07595824f, -0.00653141f, 
    0.08395255f, -0.01913772f, -0.13566510f, 0.00283921f, -0.00045404f, -0.15933071f, -0.02593018f, 0.05661363f, 
    0.05970481f, -0.02156640f, 0.03254481f, 0.02392993f, -0.01113034f, -0.04972334f, -0.02986235f, 0.08846360f, 
    -0.16548640f, -0.01965721f, -0.00212080f, 0.12350940f, 0.07312643f, 0.10063471f, 0.00321059f, 0.04868514f, 
    0.00125796f, 0.01018170f, 0.03264961f, 0.05900813f, 0.18630551f, 0.04506458f, -0.17161210f, -0.10836452f, 
    0.00480823f, -0.02911748f, 0.09679686f, -0.08951833f, -0.03268676f, 0.03484967f, -0.12171610f, 0.06834618f, 
    0.04616648f, -0.07221746f, -0.06777698f, -0.21249774f, 0.10369968f, 0.01354960f, -0.06061280f, -0.00430558f, 
    0.01185451f, 0.05036508f, -0.02029237f, -0.11494644f, -0.09703420f, 0.01032038f, -0.04459145f, -0.31406045f, 
    0.09740044f, -0.03628824f, 0.01194347f, 0.01573166f, -0.00183861f, -0.07790959f, 0.10105719f, -0.08132249f, 
    -0.00701438f, -0.03646663f, 0.03680088f, -0.00624339f, -0.02378342f, 0.06319148f, 0.00918458f, 0.05966139f, 
    -0.01973943f, -0.07815952f, -0.01394082f, 0.02097256f, 0.04041841f, 0.00324847f, 0.14470048f, 0.03715133f, 
    0.06985775f, -0.07201935f, 0.09875546f, -0.04581602f, 0.01733660f, -0.13837944f, -0.11850697f, 0.00994711f, 
    -0.13897987f, 0.08859005f, 0.02672402f, 0.11051874f, -0.07648695f, 0.03939137f, 0.13398351f, 0.05948233f, 
    0.01522487f, 0.05070326f, 0.00018692f, 0.03623326f, 0.19583304f, -0.12061825f, 0.00578446f, 0.01994450f, 
    0.09151329f, 0.00472169f, -0.01153129f, 0.10630550f, 0.08307507f, 0.00904726f, -0.05376119f, -0.06127007f, 
    0.13114993f, -0.12518039f, 0.12630457f, -0.09564780f, 0.00460259f, 0.01053973f, 0.08062109f, 0.17132817f, 
    0.00402719f, 0.02792140f, -0.01420635f, -0.05204129f, 0.18069750f, 0.04406204f, 0.11669956f, 0.07245331f, 
    0.12004346f, -0.01165213f, -0.02046220f, -0.04937416f, -0.10538202f, 0.04763297f, 0.01106144f, -0.05700289f, 
    -0.20885111f, -0.26801863f, -0.02618156f, -0.09795260f, 0.15367477f, -0.16418411f, 0.11286898f, 0.04891105f, 
    0.03222609f, 0.05223692f, -0.01273799f, 0.08669200f, -0.17867123f, -0.07599096f, 0.04609053f, 0.00928838f, 
    0.00373021f, -0.00742648f, 0.00813315f, 0.04471656f, 0.01675646f, 0.00634391f, 0.08062063f, -0.00820277f, 
    0.09946060f, -0.12342668f, 0.10985624f, 0.06330004f, -0.00413030f, 0.06250697f, 0.00846299f, -0.14613606f, 
    -0.02331541f, -0.04545267f, -0.04991907f, 0.14264281f, 0.49205527f, 0.09307707f, 0.12968116f, 0.10705324f, 
    0.07934903f, 0.13823424f, 0.16426983f, -0.00203557f, 0.09236261f, 0.02419749f, -0.15316384f, -0.09521434f, 
    0.22216052f, -0.18783349f, -0.03086980f, 0.11469101f, -0.12869360f, 0.04814563f, 0.02333990f, 0.02278366f, 
    -0.01860890f, -0.08579685f, 0.08610302f, 0.18571264f, -0.27834108f, -0.12065317f, -0.02531940f, -0.10448260f, 
    0.04999417f, 0.10743731f, 0.03936847f, -0.02662314f, -0.01802032f, 0.01120233f, 0.05083700f, -0.04259122f, 
    -0.03742823f, -0.08988253f, 0.08558381f, -0.00218802f, 0.10120552f, -0.00598569f, -0.00900746f, -0.11454208f, 
    0.00569117f, -0.04268161f, 0.13245404f, -0.05165245f, 0.03688012f, 0.01844995f, 0.15832877f, -0.06029799f, 
    -0.00337330f, 0.13044120f, -0.10021174f, 0.06419677f, 0.14696665f, -0.02904931f, 0.04154622f, -0.01079112f, 
    0.00308727f, 0.06920312f, 0.04813752f, 0.04263746f, -0.04196073f, -0.08781247f, 0.14966874f, 0.01453618f, 
    0.06938634f, 0.13350204f, -0.04002967f, 0.04066055f, 0.37111428f, -0.09664613f, 0.04397061f, 0.05808528f, 
    -0.10449111f, 0.02423694f, 0.04337791f, 0.05715717f, -0.06302548f, 0.00137659f, 0.01459342f, 0.01689852f, 
    0.17470275f, 0.00711270f, -0.01839105f, 0.02555494f, 0.10179942f, 0.01554024f, -0.03505740f, -0.10190322f, 
    -0.07325016f, 0.07749609f, 0.03849712f, -0.01704839f, 0.09316470f, -0.07370211f, 0.05910384f, 0.08463856f, 
    -0.05525126f, -0.05738036f, 0.03234951f, -0.05758230f, -0.02971792f, -0.01045149f, -0.19565116f, 0.12592743f, 
    0.44844991f, 0.00519825f, 0.07556978f, 0.05464225f, 0.02392098f, 0.02945446f, 0.05908261f, -0.04318390f, 
    0.04048639f, 0.04118662f, -0.00886210f, 0.04174478f, 0.11893240f, 0.04848436f, -0.15194254f, -0.11519642f, 
    -0.10679188f, -0.05565025f, -0.03247146f, 0.08129392f, -0.04321538f, -0.07251417f, 0.06415443f, -0.01658334f, 
    -0.08699813f, 0.02139589f, 0.02721900f, 0.11792132f, -0.06345031f, -0.08984021f, -0.08169819f, -0.01529794f, 
    0.10617037f, 0.07717576f, -0.02259643f, 0.06620747f, -0.04885553f, -0.02408417f, 0.01187138f, 0.14351490f, 
    -0.02293120f, 0.11607856f, -0.02969404f, 0.07881171f, -0.06086117f, -0.18236868f, -0.09448171f, -0.04975555f, 
    0.35180721f, 0.06722751f, -0.07395384f, 0.02042245f, -0.02061615f, -0.05692536f, -0.00852306f, -0.09927660f, 
    -0.04943169f, 0.03756569f, 0.03350338f, 0.01633812f, -0.07488577f, 0.00422571f, -0.11659406f, -0.11560793f, 
    -0.04746159f, 0.00244858f, 0.10789803f, -0.02677555f, 0.01636602f, 0.11301357f, 0.06273050f, 0.09220999f, 
    0.00280085f, -0.06930658f, 0.02315922f, -0.07467491f, 0.14255211f, -0.01332347f, 0.04946030f, 0.09252337f, 
    -0.14187151f, -0.04075111f, 0.15961722f, 0.01775946f, 0.22133210f, -0.01244985f, -0.09297577f, 0.03449137f, 
    0.01895079f, -0.06570861f, 0.01867079f, 0.01443037f, 0.09815573f, 0.05840415f, -0.04846278f, 0.07014699f, 
    -0.01861627f, -0.13917047f, 0.02715547f, 0.03662099f, 0.03224470f, -0.00264735f, -0.09228919f, 0.01198999f, 
    -0.00061115f, -0.01860078f, 0.02043486f, 0.03851769f, 0.12390823f, -0.20261525f, -0.24230064f, -0.07183696f, 
    0.04779000f, 0.16799065f, -0.06085270f, -0.02101888f, 0.05065373f, 0.01482719f, 0.01111173f, 0.04526960f, 
    -0.07110638f, 0.21660702f, -0.03425900f, -0.06021460f, 0.06656625f, 0.07035156f, 0.00498740f, 0.04897551f, 
    0.00102013f, 0.14267969f, 0.06074147f, 0.14135861f, 0.02447048f, 0.09345395f, 0.15880011f, 0.00015143f, 
    -0.08187591f, -0.09109268f, 0.03282473f, 0.08018056f, -0.01597300f, 0.09172049f, -0.00890651f, -0.16314308f, 
    0.26101014f, 0.15516929f, 0.12817723f, -0.11627533f, 0.05542022f, -0.08182501f, 0.00412300f, -0.02439778f, 
    -0.03011504f, -0.07414374f, 0.08261427f, 0.11581600f, -0.04016097f, 0.22496773f, 0.12355573f, -0.09147538f, 
    -0.04120923f, -0.01175190f, -0.00001115f, -0.03023688f, -0.01651405f, -0.03743006f, 0.00779474f, -0.00307129f, 
    0.26057738f, -0.04421000f, 0.07122705f, 0.02800390f, -0.03203950f, -0.03907315f, 0.05689899f, 0.08780088f, 
    -0.01458215f, 0.03147283f, -0.07067975f, 0.02447081f, 0.18355361f, -0.10465258f, 0.00902396f, -0.05145512f, 
    -0.04821951f, -0.01679313f, -0.01329028f, -0.08391473f, 0.17533220f, 0.01929502f, 0.11424550f, 0.05753841f, 
    0.18475951f, 0.28636125f, -0.15517847f, 0.21672544f, -0.00916392f, -0.15076388f, 0.01339315f, 0.01104183f, 
    0.04436781f, 0.06385586f, 0.13036196f, 0.03341808f, 0.11208203f, 0.05895853f, 0.09106158f, 0.12462142f, 
    0.07965172f, 0.01667004f, -0.07939058f, -0.08408295f, 0.03407532f, -0.12389511f, -0.10216374f, -0.05796294f, 
    -0.17044312f, -0.02555012f, 0.04677243f, -0.06022171f, 0.05276120f, 0.11343975f, -0.01338028f, 0.01649239f, 
    0.18107742f, -0.00180457f, 0.00360350f, 0.13732521f, 0.33774737f, -0.12371133f, -0.03927634f, 0.01172078f, 
    0.01785468f, 0.04927641f, -0.09971040f, 0.11544605f, -0.01279791f, -0.16799487f, 0.02465229f, 0.01239837f, 
    -0.08322167f, -0.35152766f, -0.00801100f, 0.02793129f, -0.10379028f, -0.04347049f, 0.05834831f, 0.15033536f, 
    -0.03162472f, 0.03671117f, -0.10476508f, 0.02416816f, 0.11047234f, 0.07843466f, -0.08388008f, -0.07032909f, 
    0.08044621f, -0.00663759f, 0.12295320f, -0.02247914f, 0.12549920f, 0.19446066f, -0.04664993f, 0.09032062f, 
    -0.16829398f, -0.05967060f, 0.15736616f, -0.08722040f, 0.05094090f, 0.03868039f, 0.01590624f, 0.05675489f, 
    -0.05692511f, 0.03311699f, 0.02258256f, 0.03010357f, -0.19930977f, 0.01231028f, 0.06488435f, -0.05595810f, 
    0.09977882f, -0.09198571f, 0.00616344f, 0.01499878f, 0.08995076f, 0.08905400f, 0.12840168f, 0.05673745f, 
    -0.06529804f, 0.00134883f, -0.04524399f, 0.02714898f, 0.09393738f, -0.06425698f, -0.00088768f, 0.02542977f, 
    -0.02635645f, 0.12777835f, 0.07345320f, 0.06778152f, -0.09380164f, 0.05890584f, -0.08108901f, -0.27398774f, 
    0.05093495f, 0.06243424f, 0.13992785f, -0.00238431f, -0.02938857f, 0.11395162f, 0.00956846f, 0.04645653f, 
    0.09150694f, -0.00615014f, -0.00499139f, 0.04810108f, -0.01576034f, -0.12051713f, 0.08658357f, -0.01233047f, 
    0.10129146f, 0.13837048f, 0.08149683f, -0.04587845f, 0.21533971f, 0.00695374f, 0.16663022f, 0.00955256f, 
    0.07836116f, 0.01852900f, 0.04230885f, 0.10755988f, -0.08438940f, -0.02368364f, 0.05412729f, 0.07016665f, 
    0.40716746f, -0.06028076f, 0.01082912f, -0.00687508f, 0.03297811f, 0.07709172f, -0.08418983f, 0.06882913f, 
    -0.16107193f, -0.01140327f, 0.07467096f, 0.00992014f, -0.00731335f, -0.08066519f, -0.12284089f, -0.08845071f, 
    0.01479233f, -0.02107615f, 0.01221732f, -0.04295044f, 0.10480461f, -0.07756919f, 0.07632367f, -0.00907160f, 
    -0.03532324f, 0.17356938f, -0.11644924f, -0.17799652f, 0.04626863f, -0.02913450f, -0.05006811f, 0.11045625f, 
    0.02897285f, -0.09058369f, 0.02981614f, -0.07175778f, 0.01543619f, -0.12407181f, -0.01443554f, -0.07128718f, 
    -0.12182663f, -0.01544209f, -0.03776612f, -0.01144365f, 0.15152127f, 0.03865130f, 0.19047086f, -0.02543352f, 
    -0.13466355f, 0.00195780f, 0.00847644f, -0.06628679f, -0.08988989f, -0.01445458f, -0.00636060f, 0.02993032f, 
    -0.04460149f, 0.13300163f, 0.15121667f, 0.10566767f, -0.14084761f, -0.03286640f, 0.00046472f, -0.13429224f, 
    0.07139874f, 0.13381889f, 0.01585150f, -0.04492199f, -0.02627737f, -0.02455022f, -0.03735317f, -0.01277920f, 
    0.01628751f, -0.04308048f, -0.12149217f, -0.06546082f, -0.04845008f, 0.13577712f, 0.02584480f, 0.05790156f, 
    0.14513777f, -0.08770290f, 0.09715185f, -0.09199469f, -0.10704477f, 0.00540196f, 0.05882259f, 0.03678537f, 
    -0.00520217f, -0.10233536f, -0.07341103f, -0.13162331f, 0.07258753f, -0.10358923f, 0.18795235f, 0.11897288f, 
    -0.04169109f, 0.08728381f, -0.15818855f, -0.30784154f, -0.06106136f, -0.02191027f, -0.06820045f, 0.04232568f, 
    -0.02675029f, -0.03495964f, 0.13433018f, -0.02258474f, -0.13983762f, 0.03221408f, -0.08885407f, 0.24189079f, 
    0.03917927f, 0.02784734f, 0.08365321f, -0.03484323f, -0.00583612f, 0.11523527f, -0.00387177f, 0.13087179f, 
    0.01068163f, 0.06523477f, 0.10075732f, -0.02317910f, -0.05779254f, 0.02525340f, -0.01844739f, -0.07045566f, 
    -0.08747625f, -0.01977354f, 0.10664382f, -0.03558521f, 0.29642969f, -0.06091475f, -0.07550593f, -0.00925793f, 
    0.07067555f, -0.02851596f, 0.07797595f, 0.07658103f, -0.04474850f, 0.07953083f, 0.06217063f, 0.06521209f, 
    0.11661591f, -0.05406344f, 0.02661985f, 0.01161638f, -0.08819865f, 0.07353747f, 0.10509970f, -0.02926756f, 
    0.03588432f, 0.02627401f, 0.07917995f, 0.18420857f, -0.18899661f, -0.09389494f, -0.08162779f, 0.25402206f, 
    0.12793095f, 0.01871989f, 0.05191934f, -0.01575999f, 0.05404432f, 0.10364043f, -0.01374852f, 0.01663290f, 
    -0.08523529f, 0.21254338f, 0.01112155f, -0.05127255f, 0.03598288f, -0.12764770f, 0.00721736f, 0.00735669f, 
    0.08758432f, 0.03408036f, -0.01931772f, -0.03146929f, 0.04335808f, 0.08633909f, -0.11685698f, -0.12730004f, 
    -0.07645770f, -0.08526050f, -0.07749777f, 0.11378410f, 0.11946243f, -0.12554891f, -0.05446930f, -0.02644637f, 
    -0.05980550f, -0.20532751f, 0.01594476f, -0.12877057f, -0.03454550f, 0.07513231f, 0.06805851f, 0.03025123f, 
    0.04213429f, 0.12076155f, -0.04651555f, 0.08322757f, -0.01574439f, -0.08414945f, -0.00435388f, -0.10669057f, 
    -0.01090553f, 0.09653020f, -0.01079044f, -0.00850552f, 0.04696327f, 0.08416567f, -0.09925633f, 0.09407534f, 
    -0.28016281f, -0.04102059f, -0.08356723f, 0.06534391f, 0.02079372f, -0.13315137f, 0.04733778f, 0.06040593f, 
    -0.06158606f, 0.05804018f, 0.14289609f, 0.10326996f, -0.01929342f, 0.11080516f, 0.08990488f, -0.04910033f, 
    0.02809966f, -0.02910524f, -0.02430057f, 0.03092911f, 0.04360973f, 0.20475011f, -0.05607403f, 0.03947999f, 
    -0.03677085f, 0.06123237f, 0.11374626f, 0.02284653f, 0.05973649f, -0.03060525f, -0.08540961f, -0.08669644f, 
    0.02829399f, 0.03975160f, -0.06726855f, 0.03156776f, 0.07241747f, -0.08579820f, 0.10513605f, 0.12644470f, 
    0.02439149f, -0.02704611f, -0.05752209f, 0.06877168f, -0.05868020f, -0.01766036f, 0.03810574f, 0.03898311f, 
    -0.02196019f, 0.17048192f, 0.18490207f, 0.08064765f, 0.00672244f, 0.05747443f, 0.13398862f, 0.10974895f, 
    -0.05291942f, -0.06898809f, 0.11927133f, 0.05337821f, -0.29151091f, 0.10485598f, -0.04851092f, -0.07041248f, 
    -0.03406315f, 0.15882711f, -0.00868811f, 0.05766755f, 0.19773822f, -0.03735967f, -0.03424853f, 0.05364513f, 
    -0.11935052f, 0.01878545f, 0.11594970f, -0.01765953f, -0.05496419f, 0.18412367f, -0.04701522f, -0.13825166f, 
    -0.01379375f, -0.08759571f, 0.00138868f, 0.06024055f, 0.55223721f, -0.05303491f, -0.04654096f, -0.00694329f, 
    0.00492074f, 0.05551792f, 0.03345155f, 0.04187866f, -0.04594010f, 0.09424598f, 0.06562824f, 0.05795332f, 
    -0.07631098f, -0.01281309f, -0.03057891f, 0.05894783f, 0.02523635f, 0.00003175f, -0.00504785f, 0.10364240f, 
    -0.02795883f, -0.06643277f, 0.03169646f, -0.01593220f, -0.00807039f, -0.05485296f, -0.02119521f, 0.19756837f, 
    -0.00515423f, 0.02208701f, -0.01803555f, 0.05920627f, 0.06540875f, 0.11886340f, 0.06027551f, 0.09352224f, 
    -0.11230305f, 0.18076357f, 0.04142927f, 0.00623046f, 0.05169020f, 0.15092322f, 0.11898080f, 0.00419161f, 
    0.02292746f, 0.03496103f, 0.02142272f, -0.02422590f, -0.14283578f, 0.28521252f, 0.05788041f, -0.37775022f, 
    -0.04779601f, -0.04536978f, -0.02899621f, 0.03116272f, 0.08187696f, -0.05560459f, -0.06650192f, -0.01455313f, 
    -0.11499133f, 0.09548938f, -0.04474319f, -0.08023284f, 0.12570228f, 0.01636869f, -0.10317789f, 0.13013129f, 
    0.00734745f, -0.06987289f, -0.02305647f, 0.05958279f, -0.11822977f, -0.05533151f, -0.09846744f, 0.11955074f, 
    0.03784695f, -0.03873882f, 0.07855188f, 0.08984760f, -0.00805269f, -0.02441650f, 0.04187890f, 0.14572106f, 
    -0.09800683f, -0.13004076f, 0.03559222f, -0.19473936f, 0.06336310f, -0.06283145f, 0.04799340f, 0.06571352f, 
    0.04998912f, -0.10294249f, -0.07961151f, 0.03430349f, -0.26127839f, 0.23115061f, -0.14864458f, 0.00799601f, 
    0.11804362f, 0.05885259f, 0.01965219f, -0.00018806f, 0.03224530f, 0.01859018f, 0.00477441f, -0.04699832f, 
    0.15245065f, -0.01170556f, -0.00614517f, 0.09723350f, 0.04695703f, -0.04069389f, 0.08891809f, -0.02060983f, 
    0.03863711f, 0.04163095f, -0.09636024f, -0.02297011f, -0.09136176f, 0.03389720f, 0.06873109f, 0.00249729f, 
    0.05693474f, 0.17273845f, -0.04263493f, 0.11341091f, -0.03150225f, 0.07454577f, 0.17879306f, 0.07303171f, 
    -0.04339638f, 0.03137711f, -0.04525159f, 0.07993866f, 0.06861063f, 0.12817192f, 0.07566312f, 0.12323336f, 
    0.03625041f, 0.02794330f, 0.07787777f, 0.02991769f, -0.06064845f, 0.00537117f, 0.01034380f, -0.05453035f, 
    -0.04525487f, -0.04658945f, 0.03609110f, -0.01217000f, 0.09151077f, 0.13611493f, -0.11577725f, -0.04465053f, 
    -0.04762868f, -0.15270503f, -0.00880205f, 0.05352766f, -0.01051517f, 0.18499856f, 0.06518873f, 0.02449327f, 
    0.02189338f, -0.06224695f, 0.10468867f, 0.04798221f, 0.08872443f, -0.02587361f, 0.04641834f, 0.06230999f, 
    -0.05854182f, 0.00244942f, -0.08742776f, 0.12254051f, 0.06129204f, 0.03960188f, 0.04973916f, 0.09192602f, 
    0.07275367f, -0.05859078f, -0.04171910f, 0.21128692f, 0.02507215f, -0.00662774f, -0.00725956f, 0.12859705f, 
    0.09212052f, -0.05349666f, -0.05709698f, 0.05778970f, 0.13319992f, -0.12998383f, -0.13196604f, 0.08688223f, 
    0.13026868f, -0.01568565f, 0.02082937f, 0.05676186f, 0.02171931f, -0.02021074f, -0.16728705f, -0.04889686f, 
    0.00731958f, -0.06648994f, 0.07662153f, -0.03120433f, 0.00082506f, -0.00362394f, 0.02492604f, 0.05569980f, 
    -0.02876130f, 0.05751814f, -0.11799091f, 0.03490904f, -0.26769355f, 0.11749025f, 0.19850880f, -0.11792386f, 
    -0.00310806f, 0.05266657f, -0.04441088f, -0.08347846f, -0.04239322f, 0.02394584f, 0.06021455f, 0.14080469f, 
    -0.04434855f, -0.08143256f, 0.04862989f, 0.07100606f, 0.05251924f, -0.02114058f, 0.03956611f, -0.03383455f, 
    0.11481445f, 0.09988146f, -0.04400436f, -0.00115793f, 0.30189139f, -0.13462721f, -0.12984709f, -0.10941663f, 
    -0.03576451f, -0.15669517f, 0.01948643f, 0.01018216f, -0.20154355f, 0.11062377f, -0.04624454f, -0.00749190f, 
    0.24016763f, -0.06522826f, 0.00645585f, 0.10101163f, 0.02655195f, -0.07953104f, 0.12360130f, -0.06538316f, 
    0.05477570f, 0.02456787f, -0.06791879f, -0.08420879f, -0.05607104f, 0.08762863f, 0.10402043f, -0.10006141f, 
    0.02715287f, 0.09376003f, 0.04111975f, -0.12821275f, 0.03490077f, -0.01657724f, 0.04936689f, 0.08409796f, 
    -0.26302910f, -0.01378367f, 0.13039288f, 0.09578475f, 0.04598260f, 0.08417873f, 0.01858796f, -0.02714449f, 
    -0.03090283f, 0.00907020f, 0.07285318f, -0.02078367f, -0.18939199f, 0.13219267f, -0.13454422f, -0.27262405f, 
    0.01337534f, 0.01399372f, -0.10636101f, -0.04222298f, 0.06525359f, 0.05020920f, 0.11291721f, 0.03607656f, 
    -0.14558737f, 0.06812185f, 0.17521100f, 0.08396712f, 0.01676073f, 0.06054422f, 0.09233165f, -0.02037341f, 
    0.05480967f, -0.09534518f, 0.09046445f, 0.09788702f, 0.04734379f, -0.14536384f, 0.04261620f, 0.20062663f, 
    0.13312623f, -0.03098421f, -0.02837191f, 0.06588181f, -0.01243166f, 0.03105783f, -0.05691737f, -0.06593484f, 
    0.35799915f, -0.16367684f, 0.07238549f, -0.03153847f, -0.02231660f, 0.11168588f, 0.03896901f, 0.05384823f, 
    -0.05054800f, 0.01708920f, 0.00307907f, 0.04038924f, -0.16750516f, -0.07783294f, -0.12141854f, 0.02992428f, 
    0.02714200f, 0.00432032f, 0.02152744f, 0.06438314f, 0.02264076f, 0.09161878f, 0.24369283f, 0.14200956f, 
    -0.16089340f, -0.07106223f, -0.08490624f, 0.02479581f, 0.03728140f, -0.10946862f, -0.00874217f, 0.04798115f, 
    -0.13118067f, 0.03547711f, 0.16203123f, 0.09169520f, -0.21497023f, 0.01373164f, 0.02462456f, 0.03452187f, 
    -0.06442736f, -0.02404760f, 0.08193199f, 0.14144267f, -0.02040783f, 0.11834450f, 0.06303172f, 0.08201676f, 
    -0.26177204f, 0.08861949f, -0.05195143f, 0.23964734f, 0.01058084f, 0.06172342f, -0.07922180f, 0.03215086f, 
    0.14461140f, 0.06464052f, 0.17541969f, 0.07604799f, 0.11087878f, 0.02036268f, -0.10986358f, -0.13141182f, 
    -0.11912090f, 0.13132583f, -0.10556146f, 0.14040016f, -0.01649697f, -0.06564012f, 0.05812088f, 0.00058119f, 
    -0.15518068f, 0.01744871f, -0.05545321f, 0.01738128f, -0.12038741f, 0.01813823f, 0.06055268f, 0.05069019f, 
    -0.04301580f, 0.02568365f, -0.02375136f, 0.02161402f, -0.01665175f, 0.08580724f, -0.00381014f, -0.02976837f, 
    -0.04707727f, 0.08952237f, 0.02029906f, -0.04905837f, -0.00797627f, 0.02611618f, -0.19394690f, -0.02720276f, 
    -0.05116631f, 0.19647059f, -0.10856991f, -0.20186844f, -0.05710814f, -0.12761804f, -0.03471536f, 0.05021197f, 
    0.06141453f, 0.01486951f, -0.06586642f, -0.12865241f, 0.01486379f, 0.14187014f, 0.03410090f, -0.35993612f, 
    -0.00722559f, 0.09992760f, -0.05323693f, 0.03803518f, 0.08465821f, -0.02680971f, 0.09644162f, -0.12078137f, 
    -0.02289177f, 0.00233825f, 0.01876347f, 0.01995911f, -0.01113754f, -0.00589696f, -0.02070924f, 0.03132948f, 
    0.02693522f, 0.03508268f, -0.01838861f, -0.01133669f, 0.03480407f, -0.02557553f, -0.02130129f, 0.02793690f, 
    0.01258879f, 0.00932780f, -0.01982595f, -0.00020090f, -0.00300476f, 0.01170588f, -0.02489098f, -0.02406763f, 
    0.00689038f, 0.02383140f, -0.03172749f, 0.01360579f, -0.00008271f, -0.00362497f, -0.00113938f, 0.02460562f, 
    0.02654107f, -0.02768258f, 0.01642430f, -0.00017805f, -0.01405757f, -0.02797604f, 0.00300062f, -0.03025416f, 
    0.01931199f, -0.02615744f, 0.00031824f, -0.03438861f, 0.02460923f, 0.03599008f, 0.02296920f, -0.00043337f, 
    0.02614953f, -0.01564482f, -0.00207293f, -0.04087025f, -0.02413096f, -0.02010976f, 0.03338594f, 0.01174345f, 
    0.01548133f, -0.03367347f, 0.01712259f, -0.04050413f, 0.00443245f, -0.02315762f, 0.03170170f, 0.00412449f, 
    -0.01165489f, 0.03038116f, -0.03900533f, 0.00603507f, -0.03205507f, -0.00156172f, -0.02621814f, -0.00919165f, 
    -0.02137643f, 0.01471728f, 0.00404867f, -0.04056409f, 0.03006066f, 0.02209363f, -0.03293993f, 0.00231410f, 
    -0.00423887f, -0.01450759f, -0.03716949f, -0.01463380f, -0.00144924f, 0.01012986f, -0.02620062f, 0.02197301f, 
    0.02514983f, -0.02512489f, -0.04094194f, -0.01429402f, -0.01809002f, -0.02836542f, -0.01410070f, -0.03867683f, 
    0.02809816f, -0.03843031f, 0.01566600f, -0.01639431f, 0.04312079f, -0.01194111f, -0.00660360f, -0.03174040f, 
    -0.00985285f, 0.02175859f, 0.01024489f, 0.00324219f, 0.02483698f, -0.03576742f, -0.00979612f, 0.00746246f, 
    -0.02957412f, -0.01821633f, 0.00852454f, -0.02743171f, -0.02139245f, 0.00214028f, 0.02466271f, -0.02972810f, 
    0.03157317f, -0.04284377f, 0.03190439f, 0.01860213f, -0.02223580f, -0.00403442f, -0.01549259f, -0.01131937f, 
    0.01172622f, -0.02445106f, 0.00844128f, -0.00724945f, -0.01912492f, 0.00668868f, -0.01823506f, -0.01909131f, 
    -0.01948643f, -0.00333005f, 0.00133840f, 0.00069586f, -0.01343758f, 0.02391174f, 0.00798665f, 0.00271330f, 
    -0.01404424f, -0.02366068f, -0.00889137f, 0.01709010f, 0.01791197f, -0.00057976f, 0.01234567f, 0.01011410f, 
    -0.01086352f, -0.03211349f, -0.02683364f, -0.00098119f, 0.00001933f, -0.00283757f, -0.00326138f, 0.01203058f, 
    0.00835288f, -0.00609029f, -0.01988329f, 0.02104890f, -0.03168210f, -0.02815263f, -0.02285396f, 0.02441509f, 
    0.00998316f, -0.03794210f, 0.02594289f, 0.02248664f, -0.01280409f, -0.02944104f, 0.02662519f, 0.02159384f, 
    -0.01518928f, 0.03062814f, -0.00389926f, 0.02393442f, -0.01363885f, 0.00948570f, -0.00257748f, 0.00898434f, 
    -0.03956978f, -0.02576561f, -0.00516502f, -0.00763639f, 0.01092393f, 0.00029507f, 0.01242016f, -0.02113641f, 
    0.02361098f, 0.00236832f, 0.01964217f, 0.01138962f, -0.00061007f, -0.02865842f, 0.01198674f, -0.02832770f, 
    0.00137881f, -0.02521635f, 0.00440790f, -0.00395539f, 0.02251689f, -0.00816078f, 0.01398390f, -0.02807598f, 
    -0.00531173f, 0.01931953f, -0.02575888f, 0.00527238f, -0.02886544f, 0.00325695f, 0.02028947f, -0.01397450f, 
    -0.04022274f, 0.01830424f, 0.00782577f, -0.02468094f, 0.00272457f, -0.03482024f, 0.00131888f, -0.01562660f, 
    -0.03092956f, -0.00632804f, -0.01270986f, -0.01052112f, 0.00991454f, 0.00708720f, -0.00284979f, 0.00141730f, 
    -0.00121601f, 0.02083420f, -0.01343433f, -0.02583561f, 0.00489812f, 0.01801723f, -0.00854850f, 0.00415698f, 
    0.01457237f, -0.00505428f, -0.00887667f, -0.02220675f, -0.01479788f, -0.01301021f, -0.03417594f, -0.02574081f, 
    0.00133445f, -0.03188357f, -0.00297195f, 0.00660731f, 0.02315977f, -0.01698855f, 0.02837614f, 0.02781888f, 
    -0.03550949f, 0.01864997f, -0.00279950f, 0.02799049f, -0.00927234f, 0.01940989f, -0.02447692f, 0.00480991f, 
    -0.01801278f, -0.02996965f, 0.01048423f, -0.00528236f, 0.02333034f, -0.00121582f, 0.01510653f, -0.02653788f, 
    0.00740641f, 0.00006576f, -0.02123579f, -0.03033716f, -0.02983523f, 0.02995978f, -0.01369193f, -0.03021985f, 
    -0.01787322f, -0.02302085f, -0.02597552f, 0.01730080f, 0.01263424f, 0.01084788f, -0.03139712f, 0.00001971f, 
    -0.01988275f, 0.02764715f, 0.02098701f, -0.00855032f, -0.00857006f, -0.01849955f, -0.03292794f, 0.02364300f, 
    -0.03497529f, -0.00107821f, -0.00663402f, -0.03449166f, 0.00316847f, -0.02484939f, -0.00553088f, 0.01237527f, 
    -0.01008540f, -0.03545325f, 0.02909945f, -0.02673380f, -0.00913648f, -0.03627294f, -0.00822702f, -0.01679547f, 
    -0.00504394f, -0.03873071f, 0.00659742f, 0.00574518f, -0.00363249f, 0.00232248f, 0.01814301f, 0.03697064f, 
    0.04149853f, -0.01372142f, -0.03401309f, 0.02862369f, -0.00932430f, 0.00904187f, 0.02188632f, 0.03000275f, 
    0.01691890f, -0.00054309f, -0.03264154f, 0.02663182f, -0.00268592f, 0.02252127f, -0.03107134f, 0.00259999f, 
    0.00917600f, 0.01390755f, -0.01235281f, 0.03127692f, -0.01001773f, -0.01923941f, 0.01508684f, -0.00307645f, 
    0.02171542f, -0.01047835f, -0.02296950f, -0.02302414f, -0.01680458f, -0.02770867f, -0.02106399f, 0.02732985f, 
    -0.01412949f, 0.00928553f, -0.00860255f, -0.01094180f, 0.02831125f, 0.03955911f, 0.00639239f, -0.00057690f, 
    -0.00176521f, -0.02885022f, -0.01790367f, -0.00025199f, -0.03228018f, -0.01762417f, 0.00608336f, -0.03399802f, 
    -0.00112244f, -0.01333975f, 0.02585718f, 0.00198207f, 0.02412946f, 0.02395457f, -0.02985039f, -0.00533410f, 
    -0.00683016f, 0.00725854f, -0.03010696f, 0.00850396f, 0.02563332f, 0.02437289f, 0.02743123f, -0.01765762f, 
    0.00288943f, -0.01842098f, -0.02030791f, -0.00321526f, -0.00891747f, -0.03075263f, -0.01373565f, 0.02369394f, 
    0.01941398f, 0.00495555f, 0.01228610f, -0.01484296f, -0.01737633f, 0.02960039f, 0.00377122f, -0.03613793f, 
    0.00608139f, 0.02134363f, 0.00494837f, -0.03212903f, 0.00478375f, -0.01344840f, 0.02302923f, 0.01418993f, 
    0.01242248f, 0.01575734f, 0.03365769f, -0.02748437f, 0.00083739f, 0.02021118f, -0.00095636f, 0.03798836f, 
    0.00949869f, 0.02843447f, 0.02733453f, 0.03244084f, -0.01535558f, 0.01612622f, -0.00029970f, 0.02935978f, 
    -0.01715499f, -0.00261604f, 0.01783225f, 0.02642424f, -0.02406322f, -0.00419057f, 0.02439135f, -0.00264009f, 
    -0.01508835f, 0.00707798f, -0.02159963f, -0.02305534f, 0.02306933f, 0.02189374f, -0.04538124f, 0.00425174f, 
    0.00450039f, 0.00179396f, -0.03250797f, 0.00938589f, -0.02626671f, -0.03093969f, -0.01826182f, 0.00257780f, 
    -0.01157739f, -0.02695645f, 0.00386611f, -0.03469514f, -0.02536043f, 0.01623422f, 0.01049533f, -0.02123885f, 
    0.00786439f, 0.00827398f, 0.00747725f, -0.02568085f, -0.02271958f, 0.01369352f, 0.00050780f, -0.02168395f, 
    0.01821624f, 0.01028535f, -0.02942104f, -0.02127997f, 0.01572020f, -0.03816019f, 0.02777310f, 0.02450361f, 
    0.02119719f, 0.02963421f, 0.02340672f, -0.03386134f, -0.03761915f, -0.02826290f, 0.01330889f, 0.03266403f, 
    0.02371762f, 0.01796661f, -0.00324567f, -0.00217542f, 0.01553240f, -0.00894724f, 0.01216903f, -0.02079041f, 
    -0.03500812f, 0.02521831f, -0.01400734f, 0.00775624f, 0.01299376f, -0.00705901f, 0.03255061f, -0.00818226f, 
    0.00635903f, -0.00045487f, 0.01382484f, 0.00103839f, -0.01467466f, 0.02484612f, -0.03943827f, -0.01704278f, 
    0.00899599f, 0.02542742f, 0.00181192f, 0.03561505f, 0.00638299f, 0.02709612f, -0.03352981f, 0.00815686f, 
    -0.03064432f, -0.02727862f, 0.00046725f, 0.01424248f, 0.00730312f, 0.01677483f, -0.02310794f, 0.02373118f, 
    0.01650336f, 0.01455116f, 0.00295889f, 0.00409027f, -0.00455506f, 0.02552742f, 0.00376189f, 0.00024583f, 
    -0.02534772f, -0.03120217f, -0.01754814f, -0.02605330f, -0.01971415f, -0.00966697f, 0.00548723f, -0.01486498f, 
    0.00961485f, -0.01676689f, 0.00584705f, -0.01898637f, -0.02838116f, -0.02153925f, -0.03968333f, 0.01953610f, 
    -0.01469683f, -0.02695985f, -0.01663966f, -0.00483549f, 0.00774371f, 0.00660326f, 0.02737813f, -0.00503956f, 
    -0.02221047f, -0.01185338f, -0.01559349f, -0.04020234f, 0.00822053f, -0.01076616f, -0.03190996f, -0.03085839f, 
    -0.03816094f, 0.02842841f, -0.03268059f, 0.03174803f, -0.00901120f, 0.00889342f, 0.02697770f, -0.00555986f, 
    -0.01827806f, -0.02496995f, -0.01860465f, 0.00994278f, 0.01115413f, -0.03461507f, -0.02066367f, 0.01819970f, 
    0.01758806f, 0.02031144f, -0.02644542f, 0.02827097f, -0.03389511f, 0.03524402f, -0.00367844f, 0.03086462f, 
    -0.00795940f, -0.03251226f, -0.00321677f, -0.02848145f, -0.01370668f, -0.03200549f, 0.03351616f, -0.02532852f, 
    0.00811849f, -0.03386493f, -0.00866567f, 0.03903870f, -0.01920558f, -0.01596421f, -0.00484614f, -0.03606596f, 
    0.02525952f, 0.03001207f, 0.00699725f, 0.01848122f, -0.01407120f, -0.03204587f, -0.01033245f, 0.00683977f, 
    0.00332513f, 0.00023120f, 0.00437899f, -0.02161080f, 0.02831320f, -0.01603655f, 0.01045460f, -0.01543062f, 
    -0.01033999f, 0.03965503f, -0.01922189f, -0.02991231f, 0.01419388f, 0.00399084f, 0.02991587f, 0.00595144f, 
    0.01562206f, 0.01048776f, 0.01924470f, 0.03259142f, 0.00689004f, 0.02859746f, 0.02138998f, 0.02183250f, 
    -0.02210532f, -0.03787412f, -0.00730940f, -0.00320388f, 0.00839446f, 0.00309425f, 0.02499953f, -0.00602595f, 
    0.02517705f, 0.00371142f, -0.01210855f, 0.02916652f, -0.02345297f, -0.01999017f, 0.02881108f, -0.03176325f, 
    -0.00548517f, -0.00588478f, -0.03288227f, -0.01724194f, -0.00477882f, -0.00963905f, 0.02004587f, 0.00420546f, 
    -0.00792786f, -0.00196564f, 0.01879050f, -0.03263335f, 0.03008876f, -0.01458970f, -0.01952189f, 0.00442195f, 
    0.02241109f, -0.01259268f, -0.03070677f, -0.01186079f, 0.03308778f, 0.00602425f, -0.00497342f, -0.02230141f, 
    -0.00967419f, -0.00857207f, -0.00957669f, -0.03541399f, -0.02020717f, 0.00595937f, -0.02682471f, -0.02588836f, 
    0.02993747f, -0.03434616f, 0.00562094f, 0.01445000f, 0.02948251f, -0.03093774f, -0.01242288f, 0.01995435f, 
    -0.00640564f, -0.04115311f, -0.00627943f, 0.00002092f, -0.02215369f, 0.03458926f, 0.01583814f, -0.00926517f, 
    -0.01465369f, 0.02114280f, -0.01219357f, -0.02975604f, -0.00472117f, -0.02442718f, 0.00471989f, -0.02037626f, 
    -0.03904694f, -0.03511883f, -0.03923339f, -0.01001974f, -0.03855257f, 0.02612869f, -0.01146953f, -0.02201173f, 
    -0.03166568f, 0.00103871f, -0.02691464f, -0.00137060f, -0.02755411f, -0.01055320f, -0.00814182f, -0.02123651f, 
    -0.03139541f, 0.01957482f, 0.03028498f, -0.03126788f, 0.02663322f, 0.02163144f, -0.03861715f, -0.01802540f, 
    -0.03171444f, -0.01760720f, 0.03700460f, -0.02944679f, -0.01639635f, 0.00938616f, 0.02038353f, 0.00599574f, 
    0.00687155f, -0.01523919f, 0.02687610f, 0.01544426f, 0.01272307f, 0.02871251f, 0.00028916f, 0.00336733f, 
    0.02369606f, -0.03573872f, -0.02086926f, -0.04163829f, 0.01713261f, -0.01307977f, -0.01637217f, 0.00655371f, 
    0.00891440f, -0.01212357f, 0.02099466f, 0.02321360f, -0.01256948f, 0.02742121f, -0.02230599f, -0.00597272f, 
    -0.01786856f, -0.02701578f, 0.02992580f, -0.02046077f, -0.00833302f, -0.03483199f, 0.00727102f, 0.02804209f, 
    -0.13622530f, -0.11827155f, 0.12434988f, -0.12146278f, -0.13333641f, -0.10821670f, -0.01919655f, -0.08140291f, 
    0.16276027f, 0.01204211f, -0.00225802f, 0.02256657f, 0.19900551f, 0.11296120f, 0.06954819f, -0.28746203f, 
    0.24543609f, 0.08836877f, 0.05039927f, -0.00355736f, 0.16401467f, 0.04153529f, 0.05265765f, 0.11183366f, 
    0.04426761f, 0.13881965f, 0.09919690f, -0.13394384f, 0.11936121f, 0.03056419f, 0.11906524f, -0.00288183f, 
    0.07706519f, -0.03485546f, 0.10971268f, 0.11307912f, -0.10217708f, -0.24688460f, 0.08304616f, -0.00318021f, 
    0.00685248f, -0.06686849f, 0.00514608f, -0.01276707f, 0.01740981f, -0.03113710f, -0.02591312f, -0.04033808f, 
    -0.09688435f, -0.16262648f, 0.11880466f, 0.00259056f, -0.09743011f, -0.06283087f, -0.12178841f, 0.03213935f, 
    -0.03495733f, -0.05381000f, -0.05009952f, -0.07156999f, 0.21664640f, -0.12509587f, 0.09850669f, -0.08278286f, 
    -0.04021857f, -0.07999167f, -0.09861146f, 0.03511515f, 0.01587504f, -0.03815399f, -0.01421592f, 0.00040701f, 
    -0.06301297f, 0.14864077f, 0.11577750f, 0.03813852f, 0.06726097f, 0.05876680f, -0.00756308f, 0.02094121f, 
    0.01131496f, 0.08303022f, 0.07894295f, 0.01022128f, -0.03656610f, -0.02335087f, 0.41457567f, 0.02409883f, 
    -0.17981265f, -0.11070220f, -0.01387139f, 0.09723391f, -0.03514148f, -0.16346188f, -0.02902106f, 0.00029100f, 
    0.06254617f, -0.11406086f, 0.08550739f, -0.02019410f, -0.03131230f, 0.04540844f, -0.13284066f, -0.15510865f, 
    0.01300251f, 0.06833740f, 0.11256649f, -0.04146425f, 0.09784890f, 0.15160425f, 0.07005744f, 0.17810827f, 
    0.04982012f, 0.12450587f, 0.08857134f, 0.06641741f, 0.00082456f, -0.07345664f, 0.14263292f, -0.05775154f, 
    -0.11956409f, -0.01601386f, -0.07284293f, 0.12650265f, -0.02033178f, 0.03742405f, -0.00467011f, 0.04591134f, 
    0.09336893f, 0.07778994f, -0.01851790f, -0.08057635f, 0.02151188f, -0.03837871f, -0.04725012f, 0.09215889f, 
    -0.04498689f, -0.00743868f, 0.01333798f, -0.15014660f, -0.01430575f, 0.08224477f, 0.00234023f, 0.05277811f, 
    -0.17431894f, 0.00729198f, -0.00353655f, 0.05528624f, 0.02175871f, -0.06328585f, -0.12469522f, -0.08604299f, 
    0.07471591f, 0.08352028f, -0.14535591f, 0.00835772f, 0.14925277f, 0.01260998f, -0.22097270f, 0.07368652f, 
    0.15135942f, -0.19480486f, 0.09515874f, -0.11681179f, 0.13989979f, -0.03549094f, -0.05843000f, 0.01755452f, 
    0.11668972f, 0.21833231f, 0.03901467f, 0.15340234f, -0.08311950f, 0.04193701f, 0.01662315f, 0.09502444f, 
    -0.03804845f, -0.02294609f, 0.05367164f, 0.07907691f, 0.04485282f, -0.07757402f, -0.02157265f, -0.08034863f, 
    -0.05560910f, 0.01710238f, -0.01988324f, -0.01961153f, -0.09544925f, -0.02171203f, 0.02944729f, -0.02699808f, 
    -0.32332832f, 0.10330229f, -0.08197848f, -0.01872777f, -0.04794376f, -0.08611316f, -0.03461733f, -0.07377777f, 
    -0.13017029f, -0.11707411f, 0.02322006f, -0.08892984f, -0.09383686f, -0.11218254f, 0.10544910f, 0.02249570f, 
    0.06169520f, 0.04315833f, -0.01584420f, 0.01409364f, 0.09372247f, -0.10561537f, 0.01852052f, -0.08887710f, 
    -0.09434743f, -0.12953301f, 0.28665209f, 0.00928434f, 0.05160579f, 0.04186895f, -0.06633765f, 0.10877639f, 
    0.02314266f, 0.04401097f, -0.01899947f, 0.10390353f, 0.10703463f, 0.05369425f, 0.11719425f, 0.12223686f, 
    0.02988029f, 0.02444812f, 0.01322868f, 0.02722874f, 0.04691545f, 0.02915087f, -0.08158251f, 0.06462456f, 
    0.20523159f, -0.13335647f, 0.03983003f, 0.12797481f, 0.00784012f, 0.03349484f, -0.00024472f, 0.00227578f, 
    0.03249245f, 0.13610327f, 0.17486332f, 0.02699037f, -0.06878038f, -0.12745880f, -0.05706146f, 0.10837613f, 
    -0.04294638f, 0.00223654f, -0.10807953f, -0.04147966f, -0.05816969f, 0.02593169f, 0.00969583f, -0.02084277f, 
    0.05914190f, -0.09746521f, -0.22463122f, 0.03641785f, -0.01574427f, -0.02168781f, -0.07538254f, -0.17593217f, 
    -0.01966326f, -0.08156309f, -0.09118458f, -0.09288738f, 0.23175123f, -0.04360306f, 0.03449152f, -0.10145169f, 
    0.13086721f, 0.05123476f, 0.02165561f, -0.00571681f, 0.00662085f, 0.04381221f, -0.04156688f, 0.07629171f, 
    0.20198719f, 0.16536435f, -0.15205295f, -0.16121919f, 0.06185336f, 0.13928342f, -0.05916338f, 0.04498357f, 
    0.01712418f, -0.01585032f, 0.01073874f, 0.03704923f, 0.03342088f, 0.09372232f, 0.03914166f, -0.04379926f, 
    -0.01488719f, 0.04309041f, 0.05376112f, -0.01430146f, -0.08908100f, -0.03427479f, -0.09869357f, 0.15660982f, 
    -0.21788372f, 0.33113500f, 0.07420059f, -0.17037894f, -0.10828153f, 0.06274219f, 0.05194215f, 0.02800402f, 
    -0.02892875f, 0.00153182f, -0.05955717f, 0.01567846f, 0.29722890f, -0.06682176f, 0.18325141f, -0.05444015f, 
    0.19175871f, 0.01097869f, 0.07275957f, 0.06774899f, 0.05747566f, -0.05997088f, 0.01207868f, 0.04105617f, 
    -0.12022744f, -0.07992245f, -0.07049703f, 0.05022117f, 0.11133321f, 0.10399084f, 0.10823604f, -0.07945491f, 
    0.06232164f, -0.02037981f, -0.01548571f, -0.03149531f, 0.14120217f, -0.17253827f, -0.09014037f, -0.29448041f, 
    0.01968679f, 0.00117231f, -0.03010768f, 0.01331382f, 0.08607642f, 0.13178375f, -0.01930194f, 0.02472139f, 
    -0.09794577f, -0.03338691f, 0.05534093f, -0.03206708f, -0.05357110f, -0.05903752f, -0.19848692f, -0.00779971f, 
    0.14791632f, 0.05616575f, -0.05290997f, -0.14741600f, -0.18706526f, 0.19586058f, 0.05751316f, 0.05180861f, 
    -0.01080807f, -0.08898502f, -0.06220249f, 0.09281962f, -0.10116111f, 0.00385031f, -0.03404589f, -0.00791866f, 
    -0.03190134f, -0.05835474f, 0.01497527f, 0.18031994f, 0.04507271f, -0.08303273f, -0.11011284f, 0.03977354f, 
    0.08466699f, -0.01854165f, -0.02598644f, 0.07853755f, 0.29762489f, 0.20310095f, -0.02556815f, -0.12963088f, 
    0.04105702f, 0.15792595f, 0.05201054f, 0.00724223f, -0.06028499f, -0.04972386f, 0.05993594f, 0.04000689f, 
    -0.10640502f, -0.03275004f, -0.00406507f, 0.19981013f, 0.09457645f, -0.02185515f, 0.07054504f, -0.07782841f, 
    0.11757806f, -0.08641566f, 0.01656718f, 0.09389474f, -0.18734154f, -0.02296112f, 0.07419237f, 0.00031725f, 
    0.00437698f, 0.15555488f, -0.04677916f, 0.04303848f, -0.04199136f, 0.12773409f, -0.00982498f, 0.02342120f, 
    -0.11134278f, -0.07619271f, 0.17295963f, 0.26708478f, 0.09628870f, 0.00602585f, -0.00410051f, -0.02114966f, 
    -0.01503140f, -0.05050717f, -0.02573386f, 0.05854631f, 0.00862407f, 0.32614863f, -0.09713038f, -0.07603512f, 
    0.07610018f, -0.02417395f, 0.02575434f, -0.09480010f, 0.08555664f, 0.05346574f, 0.13548319f, -0.09288123f, 
    0.20553888f, 0.18545477f, -0.23631556f, 0.05308988f, 0.00733684f, -0.05431562f, -0.05987528f, -0.08581881f, 
    0.08330303f, 0.03984696f, 0.11975839f, -0.00868250f, -0.18063304f, 0.01169826f, 0.00275663f, 0.02730600f, 
    -0.05843122f, 0.06491897f, 0.06589835f, -0.01086947f, 0.04560941f, 0.15759772f, -0.09572343f, 0.01678880f, 
    -0.00431462f, 0.02022115f, -0.06134970f, -0.14669260f, -0.05004267f, 0.10546602f, 0.00404613f, -0.07020694f, 
    -0.15243869f, -0.13305433f, 0.00808855f, 0.04493152f, -0.12351650f, 0.01735939f, 0.03813093f, 0.25292575f, 
    0.08562470f, -0.10631247f, 0.02263285f, 0.09201370f, 0.01540106f, -0.09140126f, 0.04382940f, -0.03238465f, 
    0.03726684f, -0.00836382f, 0.07894254f, -0.02909992f, 0.11287043f, 0.09061944f, -0.09744418f, -0.15898174f, 
    0.12972136f, -0.03389004f, -0.05673246f, -0.15262064f, -0.02234637f, 0.09606125f, -0.03613132f, -0.10374030f, 
    0.10193026f, -0.19691136f, -0.00392287f, -0.07680207f, -0.11477243f, 0.03372452f, 0.04683392f, 0.09761710f, 
    -0.05218692f, 0.04895870f, 0.10429125f, -0.02631034f, 0.12202732f, 0.11774720f, -0.02870421f, 0.10749029f, 
    0.05752260f, 0.02402885f, -0.06975903f, 0.10576057f, 0.10228740f, 0.14618038f, -0.01568836f, -0.11575753f, 
    0.09413984f, 0.06389551f, -0.04176454f, -0.00800752f, -0.01568187f, -0.01311028f, 0.05913180f, 0.08181237f, 
    -0.25867146f, 0.18237883f, 0.01667937f, 0.22228484f, -0.00865572f, 0.12076296f, -0.05601753f, -0.00536515f, 
    0.04217753f, 0.00736426f, -0.00618372f, -0.13768603f, 0.26437190f, -0.15650947f, 0.10638185f, 0.02417014f, 
    -0.03250065f, 0.01677043f, 0.15057753f, -0.01210622f, 0.00455702f, 0.01833952f, 0.07252409f, 0.00509515f, 
    0.43697211f, 0.03126933f, -0.10880627f, 0.13772187f, -0.11037047f, -0.13479087f, -0.04102949f, -0.12973784f, 
    0.05577160f, 0.04244225f, 0.03823968f, -0.08134545f, -0.11152588f, 0.16660367f, 0.03626856f, -0.00840700f, 
    0.04287698f, 0.10964574f, -0.05923051f, 0.00193780f, 0.11186276f, 0.01592666f, -0.02220399f, 0.05519507f, 
    -0.20661959f, 0.01077125f, 0.13414802f, -0.06713656f, 0.07720098f, 0.04219298f, -0.09212263f, 0.02939161f, 
    -0.05325202f, 0.00096633f, -0.02587783f, -0.08096119f, -0.16381459f, 0.16658160f, 0.08187854f, -0.28574580f, 
    0.05031215f, -0.01945150f, -0.00264162f, -0.01986220f, -0.11682374f, -0.04507565f, -0.01883948f, -0.05470663f, 
    -0.07560686f, -0.01575041f, -0.19656907f, -0.01911097f, -0.09928641f, 0.02234682f, 0.00581810f, -0.08225188f, 
    0.00748152f, -0.05252964f, 0.04566181f, 0.05360424f, 0.12791927f, -0.23098084f, 0.18639259f, -0.15006910f, 
    0.07697079f, 0.11621159f, -0.14302918f, -0.03261942f, 0.05152771f, -0.08311399f, -0.06950461f, 0.00309749f, 
    0.34896830f, 0.04311110f, 0.01961596f, 0.19982940f, 0.12051597f, -0.01601742f, 0.07625908f, 0.06688180f, 
    -0.04563703f, 0.03792687f, 0.00007242f, 0.06109152f, 0.00227284f, 0.04271610f, -0.08186159f, 0.00940887f, 
    -0.01381957f, -0.04346657f, 0.02740085f, -0.19823840f, -0.03064878f, -0.00082367f, 0.02517772f, -0.00156598f, 
    -0.02626420f, 0.17709991f, 0.05733424f, 0.10799104f, 0.18418048f, 0.00085191f, -0.02640687f, 0.04386823f, 
    -0.00197419f, -0.10045076f, 0.11483057f, 0.04717771f, -0.18007961f, -0.03469206f, 0.04109415f, 0.06876447f, 
    0.02789989f, 0.10588210f, -0.00453572f, 0.13062087f, -0.07281248f, 0.06034715f, -0.06000392f, 0.02482610f, 
    0.18056636f, 0.18694469f, 0.02598530f, 0.01679109f, -0.04152568f, 0.11197100f, 0.00205086f, 0.02759448f, 
    0.00807991f, -0.05932662f, 0.03571923f, -0.06769753f, 0.10550303f, 0.02510464f, -0.08647367f, 0.17004369f, 
    0.11496336f, 0.09267888f, -0.04499810f, -0.07911658f, 0.04954317f, -0.03839106f, 0.00960129f, -0.01437003f, 
    0.14100541f, 0.03807480f, 0.01235046f, 0.08693630f, -0.09254153f, 0.11324738f, -0.05363332f, -0.07448458f, 
    0.06190658f, -0.04793534f, 0.05158996f, -0.03330201f, -0.21887425f, 0.13246237f, 0.09203105f, -0.19541217f, 
    0.01215468f, -0.11223859f, 0.07595475f, -0.00356225f, 0.11634145f, -0.08383529f, -0.14152397f, -0.09172659f, 
    -0.12662217f, 0.06540546f, -0.08732629f, -0.00495125f, -0.07993034f, -0.06455292f, -0.01293332f, -0.03490709f, 
    -0.03337331f, 0.03830504f, -0.05706912f, -0.12831111f, -0.01330071f, 0.17256792f, -0.02783414f, -0.03664544f, 
    -0.12498374f, 0.04021555f, -0.10225181f, 0.01153273f, 0.00421061f, -0.12066323f, 0.00233502f, 0.05044945f, 
    -0.09705661f, 0.05900519f, -0.00568479f, 0.07819962f, -0.07544734f, -0.06233069f, -0.06678401f, 0.13976419f, 
    0.05496401f, 0.03926690f, -0.06183511f, 0.06162721f, -0.02154489f, 0.06449986f, 0.08140846f, 0.14249820f, 
    -0.03992499f, 0.00826003f, 0.11613222f, 0.01199946f, -0.04364352f, 0.03880318f, 0.07171553f, 0.12569094f, 
    -0.05504880f, 0.03211407f, -0.06075534f, 0.02172317f, 0.03933259f, -0.00292732f, 0.06981584f, -0.02257835f, 
    0.09268949f, -0.00556653f, 0.01791633f, 0.06150824f, -0.22583091f, 0.08807758f, 0.14553282f, -0.01449127f, 
    -0.16170630f, 0.03938005f, -0.09407093f, -0.06525785f, 0.08837825f, 0.03812868f, 0.06095690f, -0.01206683f, 
    -0.31122750f, 0.04263835f, -0.14369483f, -0.07206003f, -0.15060586f, -0.06301136f, -0.04365078f, -0.01168215f, 
    0.02784359f, 0.03923710f, -0.03482509f, 0.02830632f, 0.19780621f, -0.11742633f, 0.03685864f, 0.06539961f, 
    -0.07413169f, 0.10422043f, -0.03077362f, -0.11893778f, -0.07478385f, -0.13102531f, -0.07746886f, 0.07019694f, 
    0.17006819f, 0.14834009f, 0.11878290f, 0.05475844f, 0.03666057f, 0.07499257f, 0.04001921f, 0.14354365f, 
    0.04403722f, -0.05783312f, -0.05586465f, -0.03733290f, -0.17357221f, -0.10263810f, -0.00025654f, 0.18629068f, 
    0.07137150f, -0.04946388f, 0.01007673f, -0.13034442f, 0.01609509f, 0.04818784f, -0.07008965f, 0.04280816f, 
    0.14327420f, 0.04429139f, -0.08636851f, 0.04736965f, 0.14388168f, -0.07135981f, 0.00002713f, 0.04170038f, 
    -0.01442921f, -0.00011949f, -0.14639190f, 0.14578669f, 0.30059227f, 0.07014541f, 0.06843556f, 0.07086089f, 
    0.06893354f, -0.02502085f, 0.02217314f, -0.07892882f, 0.01960441f, 0.06337126f, -0.10601588f, -0.11654991f, 
    0.15725531f, 0.01434820f, 0.03314217f, 0.00000314f, 0.07893134f, -0.03933246f, 0.13366266f, 0.06611126f, 
    -0.04297396f, -0.09113163f, -0.01231827f, 0.03169235f, -0.06774806f, -0.01993367f, 0.04169090f, 0.04826717f, 
    0.05067177f, 0.02588033f, 0.00092802f, -0.04893786f, 0.08410278f, -0.13378242f, 0.04168562f, -0.06607710f, 
    -0.18826526f, 0.03171363f, -0.15542312f, -0.09840482f, -0.02248321f, 0.06709665f, -0.07859770f, 0.02443188f, 
    0.03489498f, -0.01213673f, 0.02410258f, 0.05466001f, -0.20409897f, 0.03139606f, -0.10300069f, -0.12065352f, 
    0.04844807f, -0.00131888f, -0.10250769f, 0.06799401f, -0.02169901f, 0.01604658f, 0.13653193f, 0.00510712f, 
    -0.01990851f, 0.08979026f, 0.09778716f, 0.01879372f, 0.05861261f, -0.04090030f, -0.03631157f, -0.05674632f, 
    -0.01071061f, 0.00097512f, -0.05469019f, 0.00216936f, -0.22543593f, -0.14499031f, -0.04258215f, -0.01557469f, 
    -0.02539258f, -0.03796642f, -0.02965930f, -0.03221245f, 0.01619329f, 0.04410744f, 0.01680773f, -0.09864072f, 
    -0.04154602f, -0.09703767f, 0.00550900f, 0.00233924f, -0.10211731f, 0.04359918f, -0.03268913f, -0.00416816f, 
    0.00980265f, 0.05553149f, -0.03178535f, 0.01028859f, 0.05778269f, 0.27159205f, -0.04845828f, -0.03740254f, 
    -0.00159058f, -0.06854761f, 0.00481825f, 0.11414465f, 0.00019677f, 0.05316621f, 0.06356490f, 0.10740948f, 
    0.26778761f, 0.05043614f, 0.18706708f, 0.03726893f, 0.00092314f, 0.05741050f, -0.06203734f, -0.00703289f, 
    0.09311970f, -0.00730415f, 0.01670853f, 0.02135333f, 0.16591449f, 0.18330432f, 0.10505714f, 0.10542417f, 
    0.09968618f, 0.10109594f, 0.09789392f, -0.01782639f, 0.01606001f, 0.05718388f, 0.02358486f, -0.08254720f, 
    -0.12622869f, 0.11023594f, -0.02622923f, 0.15693623f, 0.05085709f, -0.01925753f, 0.04404127f, -0.05859882f, 
    0.01748971f, 0.04219604f, 0.00777023f, 0.04683359f, -0.15437098f, -0.13155200f, -0.01484024f, -0.12373903f, 
    -0.03505278f, 0.05088300f, -0.01505083f, -0.03714283f, -0.04478529f, -0.12029167f, -0.04959213f, -0.04111092f, 
    -0.03140047f, 0.03768513f, 0.22440037f, -0.04986502f, -0.02655082f, -0.00681034f, -0.01528156f, -0.01417271f, 
    0.03327406f, 0.04613905f, 0.05354779f, 0.07758690f, -0.01743113f, -0.02431922f, 0.11510469f, 0.06538087f, 
    0.01274559f, 0.09796506f, 0.04284884f, 0.02680082f, 0.03154634f, 0.06696757f, -0.04779557f, 0.12739438f, 
    0.00573757f, -0.01469435f, 0.13385336f, 0.24882978f, 0.05506366f, 0.03968720f, 0.03484345f, -0.04665165f, 
    0.08147628f, 0.05754466f, 0.05726811f, 0.01693003f, -0.31249622f, -0.27961737f, -0.02798600f, -0.00773505f, 
    0.01250433f, 0.03648592f, -0.06867403f, -0.09971219f, 0.09295258f, -0.04816318f, 0.04806416f, -0.12395350f, 
    -0.27808902f, -0.07907939f, -0.20483617f, -0.02594507f, 0.03637344f, -0.10865247f, 0.12160542f, -0.02863156f, 
    0.11116144f, -0.01974143f, 0.07139330f, -0.01604703f, -0.32528859f, 0.15870434f, -0.15155303f, 0.08333769f, 
    0.06231489f, -0.06605136f, 0.06577396f, -0.04382148f, 0.02992847f, -0.00098317f, -0.02492050f, -0.12874632f, 
    0.14429806f, 0.04918693f, 0.10253970f, 0.23651275f, 0.14921847f, 0.01567956f, 0.10130984f, -0.02834054f, 
    -0.00649749f, 0.11334240f, -0.06106051f, 0.05857386f, 0.00042588f, -0.10311972f, -0.03086254f, -0.08420952f, 
    -0.02490332f, 0.10361140f, -0.03356462f, -0.09667834f, 0.11359026f, 0.07196189f, -0.01216563f, -0.12622654f, 
    -0.01040370f, 0.07747789f, 0.07950766f, -0.03348489f, 0.07732538f, 0.07139294f, 0.08741545f, -0.03171422f, 
    -0.12165511f, -0.00173760f, 0.00823816f, 0.11422763f, -0.20678462f, 0.08249287f, 0.04585839f, -0.14804839f, 
    -0.02130147f, 0.10851493f, -0.03565900f, 0.04252241f, -0.00791997f, -0.03035697f, 0.13294606f, -0.07006050f, 
    -0.28503656f, -0.10384197f, 0.07016774f, -0.19129412f, -0.04040009f, -0.13523300f, -0.04296027f, 0.06125237f, 
    -0.06943160f, -0.09006896f, 0.03053264f, 0.04475019f, -0.04874716f, -0.07757690f, 0.03897657f, 0.16691075f, 
    0.04618794f, 0.03413399f, -0.00824297f, 0.01561712f, 0.06830652f, 0.10492761f, 0.05334498f, -0.09263780f, 
    0.30019695f, 0.22762324f, 0.03263855f, 0.15501676f, 0.13682058f, 0.17081290f, 0.04825145f, -0.00565320f, 
    0.01455333f, -0.10556626f, 0.04873731f, 0.01865328f, 0.17824659f, -0.00824588f, 0.15961905f, 0.05361412f, 
    0.08925870f, 0.09313080f, 0.04552905f, 0.00832840f, -0.00659938f, -0.01590484f, -0.07236679f, -0.00719305f, 
    -0.11025836f, -0.00991607f, -0.14980909f, -0.27026010f, 0.13136621f, -0.02061287f, -0.07349316f, -0.06923222f, 
    0.04980726f, 0.10054401f, -0.00426262f, -0.00774226f, -0.14459686f, -0.03972559f, -0.00236369f, -0.16746160f, 
    0.04821057f, 0.06131688f, -0.04618017f, 0.04145858f, -0.03110270f, 0.06235334f, -0.07881263f, 0.13077594f, 
    -0.28988561f, 0.00377645f, 0.03708731f, -0.02371364f, 0.04979895f, 0.10265685f, 0.03191581f, -0.03954270f, 
    0.02750733f, 0.05275567f, -0.05228465f, 0.06041745f, 0.05148984f, 0.05558025f, -0.03538124f, 0.06466648f, 
    0.00278718f, -0.05039503f, -0.00604204f, 0.03135463f, 0.13240770f, -0.04635577f, -0.03193764f, -0.07095081f, 
    0.04584997f, -0.17891739f, -0.07591609f, 0.07211170f, 0.01702348f, -0.01506224f, 0.03597316f, 0.02648611f, 
    0.14299394f, 0.13127309f, -0.09179712f, 0.09982696f, 0.23597325f, 0.09499328f, 0.06556153f, -0.01822722f, 
    -0.02001560f, 0.05857293f, 0.07020553f, 0.05020662f, 0.00239980f, -0.16811189f, -0.01777827f, -0.03605911f, 
    -0.06137079f, 0.12962876f, -0.10347635f, -0.06809960f, -0.03121367f, -0.05204125f, -0.02901039f, 0.01071785f, 
    -0.05165270f, -0.03625063f, -0.02272961f, 0.09215049f, 0.11731233f, 0.01739803f, 0.05459990f, -0.07158577f, 
    0.16232343f, -0.01899365f, -0.01646101f, 0.08801650f, 0.07406485f, 0.10388937f, 0.02601319f, 0.06544035f, 
    0.11474628f, 0.18458234f, 0.05090378f, 0.15617727f, 0.08473070f, 0.09410495f, 0.05567789f, -0.06359984f, 
    -0.03573298f, 0.02827331f, 0.05021943f, -0.15984978f, -0.04847028f, 0.08528353f, 0.12151222f, 0.23780090f, 
    0.06195469f, -0.04680771f, 0.01325513f, 0.01615374f, 0.02583979f, 0.02751734f, -0.01860872f, 0.02337722f, 
    -0.23545589f, -0.18819770f, 0.09738701f, -0.10684869f, 0.03566757f, -0.05850299f, -0.10476416f, 0.01067645f, 
    0.01184153f, 0.03950791f, -0.00367201f, 0.00618258f, 0.07270105f, -0.28104490f, -0.02456443f, -0.01963409f, 
    -0.01359669f, 0.11057342f, -0.10339135f, -0.04217763f, -0.01511672f, 0.00547394f, -0.02077280f, 0.10263544f, 
    0.02106624f, 0.13078560f, 0.18345019f, -0.00938736f, 0.03990608f, -0.03739806f, -0.09847711f, 0.03185150f, 
    -0.04336418f, 0.17134227f, -0.05425235f, 0.06845504f, 0.20732005f, 0.04677797f, -0.03082303f, 0.12585443f, 
    -0.00655502f, 0.07052115f, 0.07820337f, 0.07493709f, -0.04524357f, 0.09237262f, -0.02474108f, -0.07165651f, 
    -0.11391497f, -0.08149172f, 0.00630426f, -0.09030410f, 0.03330873f, -0.06825499f, 0.00652540f, -0.02324061f, 
    0.00729761f, 0.02516451f, 0.02066799f, 0.04766952f, -0.28318894f, -0.02141654f, -0.21685730f, -0.13653477f, 
    0.01554663f, -0.02163693f, -0.11438579f, -0.04642462f, -0.02922511f, -0.10021055f, -0.03391529f, -0.06244158f, 
    0.13776430f, 0.03461005f, 0.03081396f, -0.03096661f, -0.00445590f, 0.03141680f, -0.00894713f, -0.03324611f, 
    0.09273322f, 0.05249421f, 0.02104202f, 0.09963116f, -0.34405783f, 0.06847318f, -0.15782654f, 0.00673652f, 
    -0.01812947f, -0.03510609f, -0.05700575f, -0.03920624f, 0.12079738f, 0.07985131f, 0.02534849f, 0.10160588f, 
    -0.01512366f, -0.01645480f, -0.05507623f, 0.08622283f, 0.06369343f, -0.07342824f, -0.00615646f, -0.04120170f, 
    -0.04716662f, -0.06864610f, 0.06055478f, 0.04632908f, 0.07993107f, -0.08748011f, -0.09126024f, -0.22208963f, 
    0.06558721f, -0.08000085f, -0.09726707f, -0.04108599f, -0.02350122f, -0.12187301f, -0.07065190f, 0.03773974f, 
    0.16080695f, 0.09478939f, 0.03468400f, 0.14080776f, 0.10387763f, 0.11429963f, 0.04009720f, 0.01951475f, 
    0.03807578f, 0.04187126f, -0.05348937f, 0.02877888f, 0.06750141f, 0.17449446f, -0.01131531f, 0.11539923f, 
    0.02503285f, -0.02222832f, 0.08097937f, 0.00283721f, 0.04174908f, -0.06598910f, 0.13650756f, -0.11920599f, 
    0.20511471f, -0.05802645f, 0.01359479f, -0.03472278f, 0.07426450f, -0.00546393f, -0.05640281f, 0.02011177f, 
    0.01606989f, 0.06348612f, -0.15838496f, 0.07270631f, 0.10233078f, 0.06416506f, -0.03243626f, 0.08290023f, 
    0.03932386f, -0.05921070f, 0.08062363f, 0.00046584f, -0.07742091f, 0.02478603f, 0.00793036f, -0.04715818f, 
    0.20215528f, 0.09304830f, 0.04577728f, 0.09313821f, -0.00620671f, -0.04396911f, 0.05330250f, -0.02657348f, 
    -0.05641001f, -0.12261320f, 0.06871612f, -0.03484472f, 0.10316909f, -0.18051505f, -0.09383155f, 0.07986794f, 
    -0.01303967f, -0.00107868f, -0.00117386f, -0.04755003f, 0.08369654f, 0.09819207f, 0.02575498f, 0.08642802f, 
    -0.12467993f, -0.08405465f, 0.00441167f, -0.05005942f, -0.01538921f, -0.11080154f, -0.05638194f, 0.06074516f, 
    -0.01331267f, -0.01102830f, 0.14828415f, -0.02415902f, -0.02545145f, 0.03776275f, 0.05727714f, 0.14202775f, 
    0.06262424f, 0.00273708f, -0.02192299f, -0.01402036f, -0.00156630f, 0.05026766f, -0.10643911f, 0.12431698f, 
    -0.03728655f, 0.01053752f, 0.00100865f, -0.02850576f, -0.03606666f, -0.00317628f, -0.00566183f, -0.03580077f, 
    0.01905570f, -0.03541697f, 0.01167474f, -0.01721605f, 0.00201237f, -0.02753188f, -0.04008839f, -0.00499986f, 
    0.01347355f, -0.01459090f, 0.01216015f, -0.00107576f, -0.04122277f, 0.01687000f, -0.02174743f, 0.00444323f, 
    0.00988283f, -0.02869275f, 0.02199228f, 0.00625115f, -0.00851782f, -0.00106958f, -0.02044859f, -0.01890189f, 
    0.00762842f, 0.02590833f, -0.00242475f, -0.03813101f, -0.02314033f, -0.02877928f, 0.01432535f, 0.00898619f, 
    0.02174024f, -0.01233791f, -0.04293253f, -0.02142215f, -0.04309460f, -0.02752857f, -0.02990023f, -0.01400045f, 
    0.01928030f, 0.02169965f, 0.02139863f, -0.02421850f, -0.01139018f, 0.00294327f, 0.01508867f, -0.00960692f, 
    -0.03518926f, 0.01614675f, -0.02565581f, -0.03461184f, 0.00290561f, -0.00322621f, 0.01822123f, -0.01398921f, 
    -0.02164408f, 0.02802720f, -0.03993575f, 0.01945481f, -0.02137167f, -0.01110264f, -0.04089602f, 0.02525107f, 
    -0.01781560f, 0.01303208f, 0.00437606f, -0.03414093f, 0.01389190f, -0.02546569f, -0.00435054f, 0.01580673f, 
    0.01262599f, -0.01041634f, 0.02381133f, 0.02562363f, 0.01158032f, -0.03234268f, -0.01257052f, 0.02545683f, 
    -0.01537756f, -0.02984838f, -0.00856681f, 0.01485301f, -0.02554417f, -0.01837998f, 0.00940555f, -0.03148093f, 
    -0.02460530f, -0.01689158f, -0.04235385f, 0.02736690f, 0.00517758f, -0.03760154f, 0.00981954f, -0.01922547f, 
    -0.01746012f, -0.02035379f, 0.02522239f, 0.00033701f, 0.00581232f, 0.01727480f, 0.02010928f, -0.00833921f, 
    -0.02084239f, -0.00953548f, 0.02372519f, 0.02410090f, -0.03970238f, -0.01936476f, -0.03645683f, 0.01886236f, 
    -0.03701245f, -0.00793255f, 0.00658096f, 0.02136443f, 0.01362754f, -0.03560138f, -0.01576365f, -0.00682078f, 
    -0.03011800f, 0.00893851f, 0.02525738f, -0.01109079f, 0.01499627f, 0.00906366f, -0.03923789f, 0.00604794f, 
    -0.01533438f, 0.01094525f, 0.02672752f, -0.01630902f, -0.03774141f, -0.03371241f, 0.02803097f, -0.01580944f, 
    0.00225675f, 0.02661970f, 0.01092790f, -0.00327227f, -0.00555960f, 0.02172139f, 0.01910096f, 0.02520744f, 
    -0.00802318f, -0.01159891f, 0.01870431f, 0.01910510f, 0.01507695f, -0.02490883f, 0.01570771f, -0.03009834f, 
    -0.03320607f, -0.01009523f, -0.01024069f, -0.00694203f, 0.00084973f, -0.01348243f, 0.01668989f, 0.01737887f, 
    0.02034978f, 0.01307817f, 0.00984177f, -0.03802101f, -0.01014113f, 0.01272765f, 0.02527243f, -0.02854681f, 
    -0.03277230f, -0.04173284f, 0.01865638f, -0.03666596f, -0.03710525f, 0.02636034f, -0.01014336f, -0.02361063f, 
    0.00755801f, -0.03548214f, -0.00677517f, -0.03293553f, -0.00941635f, 0.01867982f, -0.03902994f, -0.03493209f, 
    0.01638126f, -0.02209888f, -0.01710249f, -0.01089190f, -0.03144007f, 0.00746141f, -0.02504161f, -0.02839456f, 
    0.00737568f, -0.02111309f, 0.02298610f, -0.01968282f, -0.03247288f, -0.01318227f, 0.02236629f, -0.00752074f, 
    -0.02833964f, 0.01252941f, -0.01411537f, -0.01727044f, -0.00770090f, -0.03249833f, 0.00219481f, -0.02067130f, 
    0.01434865f, 0.02774877f, 0.02286588f, -0.00827758f, 0.01096389f, -0.01640586f, -0.03167593f, 0.00920403f, 
    -0.00178784f, -0.03422223f, 0.02531704f, 0.01476420f, 0.00518596f, -0.00168484f, -0.01790387f, 0.00850313f, 
    0.02463995f, -0.01744376f, -0.01773105f, -0.02626589f, 0.01056419f, -0.03020173f, 0.01523242f, -0.03070571f, 
    -0.00823242f, 0.00552754f, -0.01883010f, -0.02198876f, -0.03565555f, -0.01661521f, -0.02782734f, 0.00938230f, 
    0.01118899f, 0.02263169f, 0.00949251f, 0.00853194f, -0.03033922f, 0.00736476f, 0.02668970f, -0.04425915f, 
    -0.00403715f, -0.00757979f, 0.00128305f, -0.04050733f, 0.00223190f, -0.01184642f, 0.01335815f, 0.01630248f, 
    0.02020811f, -0.01060013f, 0.01058013f, -0.03630529f, -0.03362002f, -0.01242437f, 0.00508564f, -0.00362320f, 
    -0.03327242f, -0.04053304f, 0.01478501f, -0.01791931f, -0.00840512f, -0.02049132f, 0.00961359f, -0.01618902f, 
    0.02071710f, 0.01084030f, 0.01389441f, -0.03525390f, -0.02053053f, -0.04319201f, 0.02044152f, 0.02219556f, 
    0.01154593f, -0.01791529f, -0.02819297f, 0.01904745f, -0.01859060f, 0.02581576f, 0.00918006f, -0.03897055f, 
    -0.00337223f, 0.00754181f, -0.01884386f, -0.00072782f, 0.02640661f, -0.02494902f, -0.01454952f, -0.02265347f, 
    -0.00683537f, 0.01121604f, -0.02388777f, 0.01232650f, -0.02666394f, -0.03072648f, -0.03814833f, 0.01378011f, 
    0.00192947f, -0.01995326f, -0.02315713f, -0.03868709f, -0.03059195f, -0.00605226f, -0.00373297f, -0.03355809f, 
    -0.03695530f, -0.03807503f, -0.01983540f, 0.02696468f, -0.03887006f, 0.02009698f, -0.00277985f, -0.02230620f, 
    0.01926242f, 0.01691907f, -0.02995054f, 0.01392073f, -0.02817247f, -0.02588704f, -0.03537689f, 0.00332180f, 
    -0.00743855f, 0.01928784f, 0.02711567f, -0.01331960f, -0.00674068f, -0.03616751f, -0.01913463f, -0.03580421f, 
    -0.04234420f, -0.03289159f, -0.00142376f, -0.02144304f, -0.01329431f, 0.02213291f, -0.01527897f, -0.00584128f, 
    0.00500168f, 0.02397283f, 0.01125098f, -0.02906730f, 0.02199222f, -0.02962938f, -0.03768361f, 0.00731264f, 
    -0.04100123f, -0.01291068f, 0.00545247f, -0.03665163f, 0.00718605f, 0.02633356f, 0.00327040f, 0.00060469f, 
    0.00739044f, 0.02603369f, 0.01628781f, -0.01761951f, -0.01509328f, -0.00522646f, 0.00607668f, -0.00720702f, 
    0.00353083f, 0.02577028f, -0.03763637f, -0.00847676f, 0.02649329f, -0.03155623f, 0.00800046f, -0.01568371f, 
    -0.02652531f, 0.01052753f, -0.02649825f, 0.00560763f, -0.02009771f, 0.02408384f, 0.01709936f, -0.03093173f, 
    -0.00611514f, -0.02724957f, -0.03396424f, -0.02859849f, 0.02715624f, -0.03203297f, -0.03719686f, -0.00174595f, 
    0.02089054f, 0.00263159f, -0.02507932f, 0.00147030f, 0.02092409f, -0.00203677f, 0.01464363f, -0.00111189f, 
    -0.00769215f, -0.00732905f, 0.00076154f, -0.00359796f, 0.01216774f, -0.03240015f, -0.03769872f, -0.03678052f, 
    0.00813510f, -0.00682683f, 0.00281642f, 0.01158650f, -0.02133345f, 0.00746641f, -0.04140619f, 0.02428849f, 
    -0.00082511f, 0.01940470f, 0.02884924f, -0.02779036f, -0.00332458f, -0.04242544f, 0.00391160f, -0.04388352f, 
    -0.00998625f, -0.03154410f, -0.01041351f, -0.04151708f, -0.00689238f, 0.01668696f, -0.00097344f, -0.02493124f, 
    -0.04332579f, 0.01685011f, 0.01842169f, -0.03804798f, 0.01517052f, 0.00205404f, 0.00103866f, -0.00989609f, 
    0.02282356f, -0.02407308f, 0.01629318f, 0.01668841f, -0.02765173f, 0.02464557f, -0.03372653f, -0.02311528f, 
    0.02238368f, 0.00157248f, -0.03484275f, -0.04149310f, 0.02510074f, -0.02431329f, -0.03879750f, -0.00673776f, 
    0.01961946f, -0.01953242f, -0.02146400f, -0.04053686f, 0.02123244f, -0.00010753f, -0.03470537f, -0.01609159f, 
    -0.00056996f, -0.03251711f, 0.00701555f, 0.01587197f, 0.01111354f, 0.00857492f, 0.01407940f, 0.02718618f, 
    -0.00722984f, 0.01557851f, -0.02990284f, -0.02480409f, -0.01459606f, 0.01922887f, 0.01960510f, -0.01869094f, 
    -0.01734670f, -0.02768328f, -0.02031642f, 0.01692929f, 0.01396372f, 0.02155648f, -0.04251096f, 0.02760215f, 
    0.02801531f, -0.04300006f, 0.02545886f, 0.00769977f, 0.01700190f, -0.00744031f, -0.01744058f, 0.02220740f, 
    -0.04038342f, -0.04290776f, -0.00320398f, 0.02172911f, -0.01632617f, -0.00602680f, 0.02008439f, 0.00658049f, 
    0.01595008f, -0.01825990f, 0.00763052f, 0.01028109f, -0.00442454f, -0.01151580f, 0.02269340f, -0.01585871f, 
    -0.00398924f, 0.00151567f, 0.02300932f, 0.00194158f, -0.04111154f, -0.02719850f, 0.00658709f, 0.01481174f, 
    -0.03170952f, 0.02050848f, 0.01455672f, -0.00657177f, -0.03890076f, 0.00358081f, 0.01470820f, -0.00179657f, 
    -0.02305027f, 0.00548617f, -0.01841253f, -0.04347781f, 0.02530795f, 0.01580606f, -0.02822278f, 0.01570643f, 
    -0.00667222f, 0.01793361f, 0.01488664f, -0.03443087f, -0.01506925f, -0.04327969f, -0.02044356f, 0.01676658f, 
    -0.03345348f, -0.01464259f, -0.03839102f, -0.02950742f, 0.01864269f, -0.00025118f, -0.03687014f, -0.02587708f, 
    -0.00894294f, 0.00641716f, -0.04472072f, -0.02008863f, -0.01452486f, -0.01266122f, 0.00509186f, 0.01301559f, 
    -0.01962220f, -0.03921113f, -0.02649698f, 0.00573170f, -0.03237533f, -0.00701297f, 0.00845800f, -0.00985615f, 
    -0.02847877f, 0.00025272f, -0.03746062f, 0.02984357f, -0.03202714f, -0.03538447f, 0.01005726f, -0.02469801f, 
    -0.02370759f, -0.01600737f, -0.00704150f, 0.02497964f, -0.01289939f, 0.02364709f, 0.02203099f, -0.00430281f, 
    -0.01995593f, 0.01704684f, 0.02114420f, -0.02760449f, 0.01317197f, 0.02237712f, 0.02215832f, -0.00063286f, 
    0.03895994f, -0.00753792f, 0.00347150f, -0.00931584f, -0.00436799f, -0.01960221f, 0.00912911f, -0.03284327f, 
    0.00586424f, -0.04013054f, -0.01410479f, -0.03276049f, 0.01713231f, -0.03332901f, -0.01100471f, -0.04347868f, 
    -0.02754163f, -0.01404430f, 0.02642324f, 0.01564373f, -0.01496060f, 0.01039857f, -0.02461713f, -0.01974854f, 
    0.01152553f, -0.00060301f, -0.02972981f, 0.01964401f, 0.01349427f, -0.01580396f, -0.02896673f, 0.00655671f, 
    -0.02018613f, -0.00149013f, -0.01576502f, 0.01823849f, -0.03006133f, -0.01509297f, 0.01342630f, 0.00254177f, 
    0.01639782f, 0.01326241f, 0.02682046f, 0.00265779f, -0.04317754f, 0.01423007f, 0.00634160f, 0.02415463f, 
    -0.02069401f, -0.01161928f, -0.03690879f, -0.02941293f, 0.00602860f, -0.00006492f, 0.00704421f, 0.01920830f, 
    -0.02739854f, -0.03893947f, -0.01484099f, -0.01464100f, 0.01141672f, -0.04086199f, 0.01704129f, -0.00014755f, 
    0.00781531f, -0.01596147f, -0.00414261f, -0.00533119f, -0.02425300f, 0.02348503f, 0.02193669f, 0.00474234f, 
    -0.02372496f, -0.03836259f, -0.00217925f, 0.00679346f, -0.04086437f, -0.03490158f, 0.00573334f, 0.01890696f, 
    0.02375592f, -0.00207871f, -0.00756632f, 0.02119814f, -0.01134377f, -0.01850033f, 0.00267211f, -0.01543518f, 
    0.00725110f, 0.01457315f, -0.02154837f, -0.03723181f, -0.01590689f, -0.02714332f, -0.01168425f, 0.02356673f, 
    -0.02045495f, -0.01496271f, 0.00032412f, 0.01252450f, 0.02301503f, -0.01420086f, -0.00317398f, 0.00262207f, 
    0.01930879f, -0.03276138f, 0.02563732f, -0.04006064f, 0.02898687f, -0.00487566f, 0.02677188f, 0.00086778f, 
    -0.02069533f, 0.02292277f, -0.03736477f, -0.03982382f, 0.02579248f, 0.00433963f, 0.00271553f, 0.01016036f, 
    0.01385928f, 0.00487932f, -0.00200131f, -0.03105215f, -0.00877898f, -0.01042460f, -0.02827279f, -0.03032052f, 
    -0.02801018f, 0.02522293f, -0.02476719f, -0.03568247f, -0.01958995f, 0.01652559f, -0.02470400f, -0.01352376f, 
    -0.00892691f, 0.00860674f, -0.00911049f, -0.00248528f, -0.03658815f, -0.00380745f, -0.03241989f, 0.01868357f, 
    0.02197720f, 0.02772187f, -0.00922275f, -0.01067922f, -0.01990150f, 0.00391314f, 0.02418853f, 0.02248954f, 
    -0.04366680f, -0.01210155f, -0.02116509f, 0.01821534f, -0.02266375f, -0.01128300f, -0.01343270f, -0.03657161f, 
    0.02578080f, -0.04426501f, -0.01562750f, -0.00677971f, 0.00788660f, 0.01593467f, -0.03817838f, -0.01694901f, 
    0.02748856f, 0.01608364f, -0.02767775f, -0.03900243f, 0.00124996f, 0.00742396f, 0.01957262f, -0.03264210f, 
    0.02131383f, -0.03174394f, -0.02087082f, 0.00142393f, -0.03746750f, -0.01540579f, 0.02592122f, -0.01463910f, 
    -0.00619208f, -0.03052331f, 0.00660504f, 0.00371006f, 0.01043132f, 0.01835873f, 0.01976267f, -0.02867997f, 
    0.02299516f, 0.00483577f, 0.01117306f, 0.02006696f, -0.01994204f, 0.01151739f, -0.03399250f, -0.01436715f, 
    -0.00933538f, -0.03433578f, -0.01119874f, 0.01031219f, -0.00485868f, -0.00090949f, 0.03152810f, -0.03278943f, 
    0.00630604f, 0.00497824f, -0.03391633f, -0.00606917f, 0.00716363f, -0.02060319f, 0.00715310f, 0.03456900f, 
    -0.02308909f, -0.02472606f, 0.02436935f, -0.03619082f, 0.02735469f, -0.00878297f, -0.03192671f, 0.02693384f, 
    0.00541433f, -0.01085292f, 0.00934464f, 0.00967474f, 0.02710441f, -0.01673651f, -0.04171406f, -0.02763155f, 
    0.00883321f, 0.00227009f, 0.00701020f, 0.03347858f, -0.02462883f, -0.00457405f, -0.00113457f, 0.00571172f, 
    -0.00845374f, 0.01509453f, -0.02206831f, 0.03197857f, -0.01436214f, -0.01973137f, -0.01905516f, -0.00440744f, 
    -0.02574058f, 0.03119742f, 0.01856319f, 0.02112721f, -0.01038487f, 0.01283936f, -0.03183251f, -0.00137571f, 
    -0.04212230f, -0.01625986f, 0.01516880f, -0.00727732f, -0.00902050f, -0.03719461f, 0.01158091f, -0.02633068f, 
    0.02536257f, -0.00752523f, 0.02060271f, -0.03285111f, 0.03730482f, -0.00618925f, 0.01958735f, -0.04568164f, 
    -0.02037203f, -0.03150405f, -0.01701828f, -0.00049356f, -0.03194128f, -0.00382694f, 0.01617690f, 0.03142864f, 
    -0.00527657f, 0.00266684f, -0.03966186f, -0.01434433f, 0.00882133f, 0.01693214f, -0.01578552f, -0.02157456f, 
    -0.02079930f, -0.02729968f, 0.00266969f, -0.00334237f, -0.01988179f, -0.02682219f, -0.02040486f, -0.00396813f, 
    -0.02834945f, -0.01663601f, -0.00120795f, -0.01771432f, -0.00449717f, -0.01345004f, -0.00073688f, 0.02937983f, 
    -0.02371431f, 0.02237982f, 0.01633442f, -0.03563894f, 0.01170623f, -0.00765675f, 0.01761351f, 0.03428902f, 
    -0.02518921f, -0.02491805f, -0.02378645f, 0.02263821f, 0.02755923f, 0.02384461f, 0.00359908f, 0.01280079f, 
    0.02515199f, -0.01313697f, 0.03182343f, 0.01004627f, -0.03460840f, -0.03011390f, -0.01615160f, 0.01303010f, 
    0.01833252f, -0.01834661f, 0.01681675f, 0.02109394f, -0.02913044f, 0.03203738f, 0.02909503f, -0.00298702f, 
    0.02647591f, 0.01804369f, -0.02194872f, 0.02422868f, -0.01321085f, 0.00875859f, 0.00473909f, 0.01228360f, 
    -0.00136553f, 0.00655506f, -0.00007309f, 0.00166363f, -0.00092925f, 0.02331883f, -0.00613279f, -0.03923234f, 
    0.01505352f, 0.03115891f, 0.01226384f, 0.00169044f, 0.01549673f, -0.00133788f, -0.02896985f, -0.04283781f, 
    -0.00619258f, -0.01811458f, 0.00066949f, 0.02700479f, -0.00084403f, 0.00449538f, -0.00459147f, -0.03112532f, 
    0.01526202f, -0.04189623f, -0.02438835f, 0.01134038f, -0.01895057f, -0.03315082f, -0.02851625f, -0.00709546f, 
    0.00289440f, -0.01437655f, -0.00629428f, -0.01637254f, -0.00028868f, -0.01916490f, -0.01164116f, -0.03392268f, 
    0.02693202f, -0.01693026f, -0.00973109f, -0.03221085f, -0.02244625f, -0.00862195f, 0.00047439f, 0.00367809f, 
    -0.02868256f, 0.00486766f, -0.03530581f, 0.00894597f, 0.00628642f, -0.01581736f, -0.01472974f, 0.01413585f, 
    -0.04125309f, -0.02164811f, 0.00771410f, 0.00222214f, 0.02085019f, 0.00866545f, 0.00802014f, -0.00766205f, 
    -0.00442477f, 0.03170376f, 0.03477202f, 0.01039316f, -0.01501893f, -0.00525364f, -0.02154771f, -0.03399024f, 
    0.02769032f, 0.02711979f, 0.02002462f, -0.03234719f, 0.02479582f, -0.02517577f, -0.02659358f, -0.02831084f, 
    -0.00448941f, -0.00301527f, 0.01873185f, 0.01555058f, 0.00848198f, 0.02256981f, 0.00398950f, 0.01828854f, 
    -0.01668320f, 0.01802296f, 0.00317678f, 0.03875068f, -0.03705334f, -0.02675275f, 0.00057702f, 0.00823757f, 
    -0.03490777f, -0.00519397f, 0.00076543f, -0.00927328f, -0.03858185f, -0.03634913f, -0.02911890f, -0.00362067f, 
    0.02778194f, -0.03226164f, -0.03419876f, 0.00201511f, 0.00347806f, -0.01486700f, 0.00423042f, -0.03819935f, 
    -0.03045066f, -0.03237934f, -0.03160496f, -0.02814247f, -0.02951959f, 0.01751414f, -0.01604842f, -0.00896735f, 
    -0.02002715f, 0.03415520f, -0.01633310f, 0.00163128f, -0.01485501f, -0.00248418f, 0.00267794f, -0.01258738f, 
    0.00853924f, -0.03161518f, -0.00633926f, -0.02943319f, -0.01012992f, 0.01637681f, -0.00598662f, 0.00311094f, 
    0.01200653f, -0.01492990f, 0.00157108f, -0.00453973f, -0.00661107f, -0.02976524f, -0.03014108f, 0.00120896f, 
    0.01715339f, -0.00512271f, 0.02029132f, -0.01276438f, 0.01126504f, 0.00502215f, -0.00646089f, -0.01263136f, 
    0.01656698f, 0.01468521f, -0.03703653f, -0.04031795f, 0.02269375f, -0.00576242f, 0.01367239f, -0.01443346f, 
    0.00341751f, 0.00050340f, -0.02654560f, -0.03238356f, -0.01428431f, -0.02053750f, -0.01053907f, -0.02644085f, 
    0.01676453f, -0.00871214f, 0.01208580f, -0.02349230f, -0.00165752f, 0.01681908f, -0.00587070f, -0.02700708f, 
    -0.04430870f, -0.01225487f, -0.01624644f, -0.04032753f, 0.02177912f, 0.01583061f, 0.00311916f, 0.02807971f, 
    -0.01440706f, -0.02426971f, -0.01039540f, 0.02979093f, -0.02025385f, 0.01501223f, -0.03229699f, 0.03364490f, 
    0.00258491f, 0.02419897f, 0.02121411f, -0.00359222f, 0.01759478f, 0.00014668f, 0.00235512f, 0.00052616f, 
    -0.02798239f, -0.00022392f, -0.01675485f, -0.02002841f, -0.02804404f, 0.00813407f, -0.03316911f, 0.01215713f, 
    0.02239307f, -0.00640461f, 0.02444212f, -0.02127128f, -0.03390799f, 0.01096422f, -0.03127987f, 0.02505636f, 
    -0.04590023f, -0.01229655f, -0.03441795f, 0.01490661f, 0.02043144f, -0.01804208f, 0.00587267f, 0.03313233f, 
    0.01126801f, 0.02139513f, 0.00155361f, -0.03492101f, 0.01784845f, 0.02274018f, -0.03202920f, -0.02486951f, 
    -0.03223246f, -0.04007320f, -0.01882010f, 0.00212490f, -0.00920923f, 0.01994994f, 0.02039896f, -0.00104527f, 
    -0.00704518f, 0.00023100f, 0.01117092f, -0.01681638f, 0.03776404f, 0.00552258f, 0.00265298f, 0.03522247f, 
    -0.01464499f, 0.01472961f, -0.02174143f, -0.03970362f, -0.00291162f, -0.03672609f, -0.01122983f, -0.03056595f, 
    -0.03469614f, -0.02256531f, 0.01081623f, 0.03097050f, 0.00557196f, -0.01275427f, 0.00108642f, -0.00418455f, 
    0.00794675f, 0.02423782f, 0.00768920f, -0.02497142f, -0.02185039f, -0.01605072f, 0.02388716f, -0.00459422f, 
    -0.02010828f, -0.03773510f, 0.01094094f, -0.03433701f, 0.00451235f, -0.03873384f, -0.02297265f, 0.01988778f, 
    0.00480686f, 0.02939728f, -0.03351232f, 0.00510360f, -0.01154850f, 0.03103884f, 0.00648283f, -0.02334323f, 
    -0.00543114f, -0.01383153f, -0.01546351f, 0.02200687f, -0.00624957f, 0.02698259f, 0.01444996f, -0.00300300f, 
    -0.04008048f, 0.02619293f, -0.02577300f, 0.02206880f, 0.03895216f, 0.02577483f, 0.01824435f, 0.00559098f, 
    0.02732440f, -0.00821311f, 0.00500531f, -0.01131124f, 0.01649007f, 0.02768794f, -0.03586171f, -0.02226320f, 
    -0.02407685f, -0.02669646f, 0.02176290f, -0.04048777f, -0.01719733f, -0.00621980f, 0.01780287f, 0.02458572f, 
    0.00841519f, 0.03329588f, -0.01131500f, 0.00252668f, -0.04694059f, 0.02714821f, 0.02789513f, -0.00192050f, 
    -0.02328574f, 0.00311124f, -0.02267587f, -0.00033246f, 0.03102797f, 0.01608965f, 0.02726219f, 0.00852092f, 
    -0.00842197f, 0.03724236f, -0.00628454f, 0.00945460f, 0.00107807f, -0.00112657f, 0.02223339f, 0.02629056f, 
    0.02892177f, -0.02543299f, -0.02082566f, -0.03071407f, -0.02643006f, 0.02470582f, 0.00432880f, 0.00756752f, 
    -0.02053919f, -0.03233038f, 0.01959633f, -0.01960076f, -0.03501172f, -0.01055782f, -0.01926556f, 0.00391782f, 
    -0.02242875f, -0.01998702f, -0.02828274f, 0.02246328f, 0.02462244f, 0.02541793f, -0.01179369f, -0.02920289f, 
    0.00699888f, -0.00532193f, 0.01141192f, 0.00677927f, 0.01180671f, -0.02099390f, 0.02708095f, 0.03468627f, 
    0.00114068f, 0.01349055f, -0.01442501f, -0.00061692f, -0.04133016f, 0.03042210f, -0.01369147f, -0.03779737f, 
    -0.01169389f, -0.00108958f, 0.00255896f, -0.03444646f, -0.01179108f, -0.01374822f, 0.00360292f, -0.04040325f, 
    0.00106331f, -0.03905114f, 0.01584803f, -0.01275896f, -0.01081365f, -0.02592615f, 0.01345920f, 0.00024084f, 
    0.01653960f, -0.02047396f, 0.01459942f, -0.02454948f, -0.03400881f, 0.01458504f, -0.01223149f, 0.01080021f, 
    0.01086952f, 0.01504317f, 0.01120608f, 0.02887003f, -0.00243904f, 0.01193311f, 0.03106534f, -0.01734809f, 
    0.03337397f, -0.01725085f, -0.02192545f, 0.03241409f, 0.03315157f, 0.01451529f, 0.01682937f, -0.00722670f, 
    -0.02165888f, 0.02546157f, -0.03942961f, 0.00902331f, 0.02391218f, -0.01887997f, -0.01984787f, -0.02620155f, 
    -0.00622465f, 0.00168292f, -0.01268865f, 0.00611621f, -0.02607077f, -0.01966810f, 0.02994637f, -0.00524376f, 
    0.02362666f, -0.01365425f, 0.02243167f, -0.02700329f, -0.03569034f, 0.01049877f, -0.02899178f, 0.00780844f, 
    0.01727909f, -0.00752297f, -0.03183502f, -0.00995357f, -0.02253220f, -0.02653208f, -0.02929027f, -0.01035818f, 
    -0.00967232f, -0.01246437f, -0.03572538f, -0.01000357f, 0.02313458f, -0.00360488f, 0.00787183f, -0.00776169f, 
    -0.04811216f, 0.00550671f, 0.02152793f, -0.01046297f, -0.01022395f, 0.01544351f, 0.01200362f, -0.03427704f, 
    -0.03322578f, 0.02877902f, -0.02803613f, 0.00027154f, 0.01154561f, 0.01693721f, -0.03615790f, 0.01303856f, 
    -0.03382176f, -0.03850613f, -0.00529048f, -0.02469717f, 0.02025302f, 0.03941796f, -0.02995144f, 0.03151855f, 
    0.03047466f, 0.01814858f, -0.01676024f, -0.03566042f, 0.01978637f, 0.01779309f, 0.02498803f, -0.01664746f, 
    -0.03111589f, 0.02072283f, 0.01801974f, 0.02684835f, 0.02759073f, -0.02830021f, 0.02564901f, 0.00311242f, 
    -0.01308164f, 0.01383167f, 0.02208692f, -0.03433933f, 0.01840224f, -0.01677307f, -0.00944090f, 0.00376907f, 
    -0.03237901f, 0.00906951f, -0.01282602f, -0.00746705f, 0.03601849f, 0.00616643f, 0.01948247f, 0.01600078f, 
    -0.02279190f, 0.00213575f, 0.02482220f, -0.01205274f, -0.02323713f, -0.02159898f, -0.01708855f, 0.00172725f, 
    -0.03184256f, -0.03515899f, -0.02996705f, 0.03139639f, -0.00969825f, 0.00785177f, 0.01044063f, 0.04063057f, 
    -0.03437897f, 0.03210586f, -0.04190241f, -0.01340038f, 0.02795550f, 0.02453824f, 0.01447745f, -0.01746933f, 
    -0.02324525f, -0.01869378f, -0.00545328f, -0.00156819f, -0.01246854f, -0.03818471f, -0.01579884f, 0.00884189f, 
    0.02621305f, 0.02490965f, -0.03055683f, 0.00256804f, -0.02089491f, 0.02718418f, 0.00282419f, -0.01912010f, 
    0.02246771f, 0.01213399f, 0.02102242f, 0.01379861f, -0.00629635f, -0.00583366f, -0.03429532f, -0.00076445f, 
    -0.02059393f, 0.03280830f, -0.01570114f, 0.01803149f, 0.00110504f, -0.01346730f, -0.00673828f, -0.01041412f, 
    0.02519601f, -0.03427370f, 0.03382222f, -0.01893789f, -0.00843654f, -0.03585985f, -0.01192840f, 0.01419799f, 
    -0.04078672f, -0.01772446f, 0.00771087f, 0.02935859f, -0.02434441f, 0.02533000f, 0.02188393f, 0.01242567f, 
    0.22253151f, 0.07806289f, -0.05587066f, 0.02815347f, 0.07269169f, -0.07965838f, -0.01452905f, -0.01815150f, 
    -0.02002935f, 0.13829829f, 0.04347991f, 0.11311934f, 0.22552213f, 0.22784607f, 0.35165933f, 0.01783621f, 
    0.03773090f, -0.06850578f, 0.03032866f, 0.11655349f, -0.02336168f, -0.03456474f, 0.00283872f, -0.03373429f, 
    0.12454946f, 0.17158210f, 0.23512167f, 0.05945306f, -0.03716067f, -0.03947904f, -0.02591506f, 0.13967925f, 
    -0.00192959f, 0.04855645f, 0.07063292f, 0.05549741f, -0.07152734f, 0.00782515f, -0.00805099f, 0.06474163f, 
    -0.04943671f, -0.02500047f, -0.03209218f, -0.10141113f, 0.00896026f, 0.03670961f, -0.03106007f, -0.09140211f, 
    -0.08663931f, -0.09269671f, -0.16353703f, 0.11218688f, 0.01976259f, 0.06946142f, -0.02858547f, -0.03959786f, 
    0.00756937f, -0.03404130f, -0.01186426f, -0.02810727f, 0.22851342f, -0.01174401f, -0.02260303f, -0.09266192f, 
    -0.02154873f, 0.02750566f, -0.07270962f, 0.01729495f, -0.01910560f, -0.08624049f, 0.05069883f, -0.07861055f, 
    -0.08697703f, 0.04785861f, 0.02270641f, 0.07555024f, 0.04234340f, 0.03806432f, -0.04413200f, 0.10419240f, 
    -0.01537822f, -0.01552533f, -0.03111091f, 0.00719176f, -0.02561093f, 0.01996001f, 0.09580800f, -0.17234467f, 
    -0.01212168f, -0.00343726f, 0.02096905f, 0.01554922f, 0.03524448f, 0.00743118f, -0.05781592f, -0.03813875f, 
    0.19455467f, -0.10257932f, -0.02090346f, 0.03287917f, 0.03926630f, 0.06927855f, -0.01106056f, -0.03861013f, 
    0.06083450f, -0.06209092f, 0.10830537f, -0.01778978f, 0.07056165f, 0.03773579f, 0.08998889f, 0.09721844f, 
    0.00825723f, -0.00099708f, 0.01529881f, -0.03665513f, 0.03208857f, 0.01207428f, 0.05653417f, -0.03565987f, 
    -0.03820865f, 0.08926480f, 0.11481036f, -0.04930938f, 0.02953400f, -0.09534404f, -0.00824536f, 0.05166804f, 
    0.04676677f, -0.03406030f, -0.01266158f, 0.03933849f, -0.18404688f, 0.01684044f, -0.05928534f, 0.20928946f, 
    0.10476404f, 0.01546641f, 0.00623450f, -0.06460597f, 0.02944882f, -0.00053387f, 0.11851733f, -0.03593482f, 
    -0.02853971f, -0.01948525f, -0.07743113f, -0.02733578f, 0.01423706f, 0.07770716f, -0.02795815f, -0.07461271f, 
    0.11051160f, 0.01211423f, 0.06048001f, 0.02968075f, 0.01381837f, 0.03741946f, 0.02205249f, 0.08359369f, 
    0.09670796f, -0.02027755f, -0.05870439f, -0.04124492f, -0.04050092f, -0.00421539f, 0.02702781f, 0.08011579f, 
    -0.05257366f, 0.21780153f, 0.08702161f, 0.03214690f, -0.04538782f, -0.04776013f, -0.04967584f, -0.06371593f, 
    0.02558671f, 0.05636073f, -0.07367513f, -0.04324602f, -0.11853057f, 0.01477053f, -0.14425720f, 0.11148799f, 
    0.05089848f, 0.07106353f, 0.05446924f, 0.02535693f, -0.00407157f, -0.01724337f, 0.03331113f, 0.00080255f, 
    -0.17056327f, -0.14532916f, -0.10749964f, 0.12941450f, 0.09919799f, 0.01097211f, -0.01020924f, -0.04451430f, 
    -0.02115037f, 0.04138676f, 0.03212753f, -0.02647183f, 0.00070070f, 0.06927221f, 0.19792430f, -0.05925184f, 
    0.02597750f, -0.04620413f, -0.09590727f, -0.03790785f, 0.00251459f, -0.03224174f, -0.08361427f, -0.04961272f, 
    0.04501360f, -0.01191321f, 0.08477850f, -0.03865148f, 0.06902722f, 0.08349467f, 0.00479433f, 0.06146082f, 
    -0.06265187f, -0.01516926f, -0.04466341f, 0.11804385f, -0.00004080f, 0.02649012f, -0.06117268f, -0.07710004f, 
    0.06608094f, 0.02695086f, 0.05022179f, -0.01348814f, 0.09346247f, 0.00520473f, -0.09015355f, -0.07976360f, 
    -0.06070282f, 0.02707876f, 0.05129430f, 0.15184318f, 0.08178752f, -0.02666752f, -0.05879177f, 0.02371641f, 
    0.05571008f, 0.10765862f, 0.03497173f, 0.12780167f, 0.02182266f, -0.16062739f, -0.05246994f, -0.07501622f, 
    0.01416675f, 0.06618736f, -0.03871974f, -0.03681157f, -0.02357803f, 0.01083362f, -0.05242715f, -0.04921525f, 
    0.00841422f, -0.04931846f, -0.13994110f, 0.00939498f, -0.03742538f, 0.02765255f, -0.04329955f, -0.04632169f, 
    0.06938804f, 0.02309083f, 0.02560773f, 0.00673833f, 0.21327478f, 0.12779525f, 0.17173281f, 0.17046307f, 
    -0.05102388f, -0.03787006f, -0.00110296f, 0.07184919f, -0.00127087f, 0.01256758f, -0.05389925f, -0.12971909f, 
    0.12391140f, 0.17502658f, 0.23798428f, 0.07779121f, -0.08837540f, 0.06421869f, -0.01092835f, 0.02744686f, 
    0.00684203f, -0.03348484f, -0.07232784f, 0.04530875f, -0.20065616f, -0.17195097f, -0.13978270f, -0.07957732f, 
    0.09458211f, 0.06001109f, 0.05578367f, -0.02484435f, 0.00231537f, 0.06090161f, -0.06107148f, 0.08963389f, 
    -0.07524960f, -0.05452512f, -0.18133199f, -0.22393742f, -0.02888591f, -0.07626076f, 0.11092271f, -0.03687023f, 
    -0.10039490f, -0.00396780f, 0.03257837f, 0.01123620f, 0.28953099f, 0.17860320f, 0.12702064f, 0.03697039f, 
    0.10274462f, -0.00247649f, -0.01686074f, 0.06818023f, 0.05040797f, -0.05276397f, 0.04883678f, -0.06727782f, 
    0.13071355f, -0.01253668f, 0.12439171f, 0.18491089f, -0.08510659f, 0.04720677f, 0.11856654f, -0.00201896f, 
    -0.03162196f, -0.12239458f, 0.03888048f, -0.02775159f, 0.32029918f, -0.01204772f, -0.13447903f, 0.00835314f, 
    0.01588714f, 0.04783643f, -0.04703053f, -0.04636818f, 0.05911162f, 0.16204111f, 0.00334137f, -0.09038483f, 
    0.19900174f, -0.04361226f, 0.21627681f, -0.03547342f, -0.02700252f, 0.08204489f, -0.09565548f, -0.01248030f, 
    0.02084562f, 0.04694331f, -0.01063647f, 0.06016995f, -0.12239363f, 0.09277380f, -0.12230232f, 0.04945188f, 
    -0.01084373f, -0.05161166f, 0.02935540f, 0.03126980f, -0.09453651f, 0.04646030f, -0.02348814f, -0.04378585f, 
    -0.17110135f, -0.22286652f, -0.19376428f, 0.11047149f, 0.07404412f, -0.05115584f, -0.04839866f, 0.04636377f, 
    -0.00058808f, -0.04536728f, -0.07303655f, 0.05807399f, 0.14414427f, 0.16369992f, 0.04718711f, 0.18808894f, 
    -0.01066505f, 0.02112646f, -0.03410557f, 0.02548355f, -0.00787518f, 0.05186373f, -0.13378130f, -0.03660940f, 
    0.06617590f, 0.07804043f, 0.08486705f, 0.05877225f, 0.01719866f, 0.01350294f, 0.03670003f, 0.08619582f, 
    0.07808797f, -0.05887640f, -0.11858277f, 0.03275727f, 0.13366096f, 0.04555370f, 0.17643324f, 0.05512553f, 
    -0.05389022f, 0.02172631f, 0.03805958f, 0.02180415f, -0.03479191f, 0.01454500f, -0.05521433f, -0.00237411f, 
    -0.17438494f, -0.08924449f, -0.11972084f, 0.02006954f, 0.02070848f, 0.04710034f, -0.00131215f, -0.04309135f, 
    0.02082084f, 0.01732860f, -0.02280432f, 0.07846867f, -0.04286901f, 0.13178314f, 0.04708776f, -0.03453602f, 
    0.05870420f, 0.04116717f, -0.02673812f, 0.10439493f, 0.04700394f, 0.08386638f, 0.04952409f, -0.00276925f, 
    0.01368873f, 0.09910268f, -0.06262918f, 0.03578094f, -0.04025778f, 0.06299908f, 0.06686639f, 0.13421062f, 
    0.04272980f, 0.00724165f, 0.06022538f, -0.08675230f, 0.01908483f, -0.03355020f, 0.01040570f, 0.13757630f, 
    -0.08098709f, -0.01011768f, 0.04731313f, 0.00795807f, 0.00547358f, 0.06076863f, -0.07920355f, -0.04906541f, 
    0.06708173f, -0.02067053f, 0.00545809f, 0.00399929f, -0.09992184f, 0.11460973f, 0.12008478f, 0.07511520f, 
    -0.01450247f, -0.07755192f, 0.03328959f, 0.03288832f, 0.05185342f, 0.08662661f, 0.05343032f, 0.13700603f, 
    -0.01072716f, 0.02813752f, -0.06371662f, 0.06169388f, 0.00971929f, -0.07371819f, 0.02131520f, -0.05409055f, 
    0.22322147f, 0.10360156f, 0.13579492f, -0.00626766f, 0.06638890f, -0.00458644f, -0.08466142f, -0.08176921f, 
    0.03629459f, -0.04617548f, -0.03626838f, -0.02671397f, -0.05397134f, -0.04655642f, -0.04791330f, -0.05999622f, 
    0.10497519f, -0.06785531f, 0.05281673f, 0.04079491f, 0.04212518f, 0.05769252f, 0.07018507f, 0.09873881f, 
    -0.02906593f, 0.12201697f, 0.06207731f, 0.02063047f, -0.02228916f, -0.01936194f, 0.01756516f, -0.00955220f, 
    -0.03558148f, 0.04056737f, -0.00289240f, -0.00302234f, 0.13092965f, 0.12808681f, 0.14252457f, 0.11799665f, 
    -0.00465733f, -0.05850537f, 0.04194793f, 0.01029395f, 0.01612771f, 0.03262556f, -0.04024811f, 0.00528743f, 
    -0.16105101f, -0.10468695f, -0.07140833f, -0.04484716f, -0.10022590f, 0.04912077f, -0.02013251f, 0.04099683f, 
    -0.03472422f, 0.07861029f, 0.01794692f, -0.00672242f, 0.05505525f, -0.06049784f, -0.12302290f, -0.22569595f, 
    -0.00953840f, 0.06807162f, -0.03191319f, 0.05555638f, -0.09365609f, 0.04067334f, 0.06423461f, 0.09088105f, 
    0.28265443f, 0.03512435f, -0.12384630f, 0.03617017f, -0.05610796f, -0.05542715f, -0.04093804f, -0.07660501f, 
    -0.03951002f, 0.05395174f, -0.01216756f, 0.02407725f, -0.02481029f, 0.15521927f, 0.11836404f, -0.02549755f, 
    -0.03384782f, -0.02632846f, 0.10778338f, 0.08368371f, 0.00014770f, 0.06776704f, 0.02541282f, -0.03087826f, 
    -0.19954965f, 0.06574252f, 0.26303852f, -0.12577271f, -0.00016223f, -0.13442449f, -0.09849926f, 0.04235312f, 
    -0.00670671f, -0.05347522f, 0.04566427f, 0.09617937f, 0.06102191f, -0.05963288f, -0.14195797f, -0.14761430f, 
    0.16929793f, 0.03283330f, -0.00100523f, -0.01198745f, -0.02916764f, 0.08160884f, 0.06015225f, -0.01436522f, 
    0.01956743f, 0.08189075f, 0.18714303f, -0.01194732f, -0.15355256f, -0.02655576f, 0.08572634f, 0.05614541f, 
    0.08495742f, 0.02800344f, -0.01520125f, 0.10255505f, 0.16292822f, -0.01345501f, -0.05110609f, 0.05150559f, 
    0.04430439f, 0.03689340f, -0.04815307f, 0.04117885f, 0.03100815f, -0.07312704f, 0.09841388f, 0.03025726f, 
    0.25984037f, 0.04763564f, 0.11741619f, 0.10878977f, -0.11371970f, 0.00400945f, 0.02782352f, 0.02184945f, 
    0.03087974f, 0.01256059f, -0.01249511f, -0.00741569f, -0.00194618f, -0.13187194f, -0.12641035f, -0.05487113f, 
    0.00663465f, 0.00399688f, -0.04636053f, -0.08684235f, -0.07497399f, -0.01534927f, 0.08464834f, -0.03999938f, 
    -0.02277860f, 0.05174349f, 0.13788016f, 0.18608260f, 0.11450732f, 0.03699854f, -0.03234100f, 0.09048172f, 
    0.01174724f, -0.00339782f, 0.05619671f, 0.06159965f, 0.11946296f, 0.12720144f, 0.07003221f, 0.25958055f, 
    -0.04197346f, -0.05248854f, 0.00030969f, 0.10715283f, 0.01904972f, 0.02635211f, 0.01028744f, -0.10385469f, 
    0.06536435f, 0.02983632f, -0.04536020f, -0.02674128f, -0.00063355f, 0.02157695f, -0.02192568f, 0.12474123f, 
    0.05565197f, -0.00509673f, 0.05862245f, -0.04810760f, 0.03234885f, 0.21760985f, 0.04800911f, 0.12523726f, 
    0.03112200f, 0.01654032f, -0.07258651f, 0.04206192f, -0.02476732f, -0.17305450f, 0.02320410f, -0.11597391f, 
    -0.01534824f, 0.20639279f, 0.00192764f, 0.18357319f, -0.01415963f, 0.04710793f, -0.08233891f, -0.02895282f, 
    -0.00692332f, 0.02305458f, 0.04893091f, -0.00737044f, -0.00035878f, 0.06226876f, 0.04975680f, 0.02465887f, 
    0.00304044f, 0.00587410f, 0.08188850f, -0.02080690f, -0.00297805f, 0.04933566f, 0.04749678f, 0.06249489f, 
    -0.20067723f, -0.18796827f, -0.16433130f, 0.20896876f, 0.08253124f, -0.05872269f, -0.04148984f, 0.00612771f, 
    -0.02740139f, 0.03750583f, 0.06469699f, -0.09506817f, -0.06864604f, 0.00460599f, -0.02360841f, 0.00103804f, 
    0.05222921f, -0.03477972f, 0.04268391f, 0.00263800f, 0.06593297f, -0.02467187f, 0.00432508f, 0.01370147f, 
    0.20288546f, -0.11565438f, 0.17566371f, -0.19955610f, -0.03497948f, 0.10789818f, 0.00687093f, -0.00502502f, 
    0.09602907f, -0.00314382f, 0.10243869f, 0.03678069f, -0.03344992f, -0.13326247f, -0.10339233f, -0.09487663f, 
    0.03543318f, -0.02098047f, 0.01033651f, 0.01992363f, 0.12357106f, 0.05022765f, -0.03853616f, 0.06602912f, 
    0.13845484f, -0.07193872f, 0.01242899f, -0.01293888f, 0.19413777f, 0.07922190f, 0.08259003f, -0.00129955f, 
    0.14362223f, 0.03393732f, -0.01159822f, -0.02246185f, 0.52467930f, -0.17437664f, -0.18309602f, -0.02122154f, 
    -0.01220325f, -0.04065372f, 0.02182717f, -0.06204274f, 0.02452464f, -0.02384512f, 0.11562390f, 0.13904551f, 
    0.22800697f, 0.14971353f, 0.17964076f, -0.05805241f, -0.10904615f, -0.03496706f, 0.02021419f, -0.03071276f, 
    -0.01913596f, 0.04647665f, 0.05885283f, 0.10189635f, 0.09288917f, -0.04371306f, 0.01364477f, 0.06555443f, 
    -0.01540899f, 0.01154974f, -0.00251267f, -0.11944761f, -0.00229075f, -0.05631191f, 0.02126471f, 0.06765085f, 
    -0.19627731f, -0.20906289f, -0.05905790f, 0.06360834f, 0.06538748f, 0.09905165f, 0.12548140f, -0.03833757f, 
    0.13179575f, -0.12586685f, 0.01742810f, -0.05114544f, -0.27310994f, 0.00843275f, 0.26589602f, 0.16527641f, 
    -0.14029068f, -0.14470679f, 0.23001198f, -0.03333982f, -0.05028941f, -0.10076809f, 0.03431043f, 0.08495972f, 
    0.01845712f, -0.03221614f, 0.11542974f, -0.05172145f, -0.05560283f, 0.13189432f, 0.05578807f, -0.07496879f, 
    -0.08907562f, -0.03432692f, 0.00017458f, 0.02555754f, -0.10594893f, -0.06810518f, -0.17217503f, 0.15700507f, 
    0.06452031f, 0.15182985f, 0.00220832f, -0.09545869f, -0.07084360f, -0.05427959f, -0.15354897f, -0.08939038f, 
    -0.03554093f, -0.02820783f, -0.18219130f, 0.03460777f, -0.01226471f, 0.11592313f, -0.01238195f, 0.09582762f, 
    0.06650718f, 0.06172948f, -0.02845396f, -0.13131443f, 0.10440486f, -0.07400053f, 0.03436457f, 0.01422384f, 
    -0.12647693f, 0.03553302f, 0.01048775f, 0.04378890f, -0.09855827f, 0.09456010f, -0.04330474f, 0.05656781f, 
    0.06691562f, 0.00006911f, 0.11013137f, -0.00085665f, -0.01964909f, -0.14499283f, 0.04740172f, -0.02880621f, 
    0.02743250f, -0.00041911f, -0.01636032f, -0.04679865f, 0.07534747f, 0.05143980f, -0.19165802f, 0.07854199f, 
    -0.01425529f, 0.06815815f, 0.09261774f, -0.00340244f, 0.15326568f, -0.05406153f, -0.04333840f, 0.07679824f, 
    -0.05225904f, 0.00634635f, -0.14247520f, 0.14623198f, -0.04347078f, 0.11173762f, -0.01126049f, -0.02632681f, 
    -0.00461878f, -0.02986425f, 0.05749136f, 0.00658569f, 0.02751792f, -0.00535959f, 0.05949733f, -0.10061831f, 
    -0.06240625f, 0.03108993f, -0.03142533f, 0.07328992f, -0.08346920f, -0.02372926f, 0.10424491f, 0.05321191f, 
    -0.00612473f, 0.17693667f, 0.22404236f, -0.02962756f, -0.01933096f, -0.01040692f, 0.04689470f, 0.01832451f, 
    -0.06905067f, 0.00064634f, -0.02232547f, 0.06960313f, -0.05160535f, -0.20395072f, -0.13184957f, -0.09888223f, 
    0.03657110f, 0.06421694f, 0.04081205f, 0.01338727f, 0.06734037f, -0.04048417f, 0.02642035f, 0.03203663f, 
    0.07829795f, -0.14566495f, -0.04475319f, 0.03653735f, 0.05365792f, -0.01497532f, -0.10063492f, 0.01437955f, 
    -0.05304553f, 0.11015564f, 0.04912329f, -0.02171200f, -0.19271304f, -0.17031601f, 0.05725044f, 0.06836332f, 
    -0.03402784f, -0.04316007f, 0.12579325f, -0.06653653f, -0.05675464f, -0.08311588f, -0.00641355f, 0.10538330f, 
    -0.00267113f, -0.14373040f, 0.03291162f, 0.04046803f, 0.03157990f, 0.05109446f, 0.07296771f, 0.02668879f, 
    -0.00692041f, -0.04286726f, 0.08537389f, -0.07850984f, 0.07029162f, 0.25303227f, 0.16492786f, 0.14020337f, 
    -0.11852431f, -0.14174861f, 0.03555620f, 0.03820592f, 0.04103581f, -0.03553747f, 0.00187510f, 0.06362233f, 
    -0.00300391f, 0.17414019f, 0.02487196f, 0.20107181f, -0.07385997f, -0.01281198f, -0.06800805f, -0.01189123f, 
    -0.03785482f, 0.06460238f, 0.04384350f, 0.03793280f, 0.09955972f, -0.08543850f, -0.14951073f, -0.08144111f, 
    0.16049318f, 0.00567940f, 0.04498148f, 0.08780530f, 0.00837214f, -0.03839710f, 0.01721172f, 0.11387920f, 
    0.12687939f, -0.14580831f, -0.15572086f, -0.01796077f, 0.10087673f, -0.08226585f, 0.05716342f, 0.12378634f, 
    0.01965046f, -0.04432012f, 0.00702886f, -0.00809473f, 0.05367317f, 0.25758994f, 0.36858523f, -0.10053593f, 
    -0.06471878f, 0.00796068f, 0.05272676f, 0.06743482f, -0.05467218f, 0.05167072f, 0.00077037f, 0.05911959f, 
    -0.33946154f, 0.19988574f, 0.25400597f, -0.09690356f, -0.01510107f, 0.03931114f, -0.06004958f, 0.01702769f, 
    0.05723361f, -0.04534828f, -0.00871931f, -0.00936362f, 0.08269759f, -0.36945838f, -0.00550177f, -0.15441626f, 
    0.08692501f, 0.04202162f, 0.13186903f, -0.10250963f, -0.03705310f, 0.06926209f, 0.06509428f, 0.00267777f, 
    -0.17571527f, -0.30584219f, -0.04335444f, -0.10039536f, 0.22892284f, 0.07949679f, 0.06057631f, -0.01929421f, 
    0.06299898f, 0.05792690f, -0.07884646f, -0.00308942f, 0.17296243f, -0.06163607f, 0.01142976f, -0.15277115f, 
    -0.06363026f, -0.03424648f, 0.10918126f, 0.06477603f, 0.06565309f, 0.01128721f, 0.00578194f, 0.07719767f, 
    -0.17368904f, -0.12091275f, -0.10714812f, 0.13363104f, 0.04519307f, -0.03069860f, 0.13831623f, 0.06093247f, 
    0.14866708f, 0.00586970f, -0.07584461f, -0.05321628f, -0.24826588f, 0.15388563f, 0.39185250f, -0.01471662f, 
    -0.11042190f, -0.00568327f, 0.05536378f, -0.01831536f, -0.00406451f, 0.00667732f, 0.00722238f, 0.12128085f, 
    0.14984883f, 0.22455223f, 0.15231401f, 0.04245459f, 0.00850124f, 0.05523238f, 0.01249031f, -0.04513007f, 
    0.02169073f, 0.07838637f, 0.01870890f, 0.00404571f, 0.19272767f, -0.03042937f, 0.02510329f, -0.16356087f, 
    0.18667622f, 0.04617634f, -0.04447901f, 0.06513880f, -0.03290095f, -0.12354641f, 0.05924377f, 0.04275995f, 
    -0.40772983f, -0.17419642f, -0.05058354f, 0.05759041f, 0.19146459f, 0.06968457f, 0.00140344f, -0.02777492f, 
    0.14479087f, 0.04667333f, 0.02737270f, 0.07359695f, -0.20733419f, -0.04191822f, -0.23296092f, -0.06724276f, 
    0.08364122f, 0.09413473f, -0.08337599f, 0.06450486f, -0.08395870f, 0.02030707f, -0.03365766f, -0.10388602f, 
    0.19782268f, 0.13829757f, 0.08127067f, 0.23455691f, 0.02287789f, 0.07798928f, 0.04839968f, 0.01307543f, 
    -0.02748542f, 0.05688566f, 0.12378914f, 0.06251429f, 0.07472768f, 0.08919097f, -0.02229567f, -0.03033462f, 
    -0.00255317f, -0.05835871f, -0.01854827f, -0.00090363f, -0.00270808f, -0.05627881f, -0.01928907f, -0.00150356f, 
    0.14092800f, 0.14325641f, -0.07796200f, 0.05601409f, 0.04527055f, -0.08316226f, 0.04576971f, -0.00985267f, 
    0.01605062f, -0.05903075f, 0.00664578f, 0.15063369f, 0.02168425f, 0.06534044f, 0.09603415f, -0.19568561f, 
    0.00037208f, 0.01185996f, -0.05505124f, 0.03499655f, -0.15136968f, 0.10849582f, 0.10422437f, 0.02095689f, 
    -0.06106436f, 0.11333431f, 0.10975651f, -0.07800747f, 0.06141810f, -0.06963746f, 0.03280968f, -0.01065290f, 
    0.07816618f, 0.01202135f, 0.02621439f, 0.00593109f, -0.34343916f, -0.16965446f, -0.22325030f, 0.06556107f, 
    0.10910573f, 0.08441763f, 0.04168615f, 0.04586602f, -0.00035086f, -0.09312032f, -0.11399750f, -0.04819883f, 
    0.00688550f, -0.05875575f, -0.22207345f, -0.15010823f, 0.03414997f, 0.09988143f, 0.04491418f, 0.06641302f, 
    0.15824609f, -0.06941435f, 0.04888252f, -0.04561140f, 0.17052555f, 0.13650671f, -0.00191818f, -0.02395659f, 
    -0.04750204f, -0.00134754f, 0.00338642f, -0.06024832f, -0.02692721f, 0.10033041f, 0.06751899f, -0.02578207f, 
    -0.16160725f, -0.16366658f, 0.01922669f, 0.03281464f, 0.27030963f, 0.08827946f, -0.04471086f, 0.09363991f, 
    -0.02358507f, -0.04306929f, 0.06836138f, 0.03634882f, -0.06238968f, 0.07261866f, -0.11082614f, -0.11781230f, 
    0.11290044f, -0.04046249f, -0.05302041f, 0.02547887f, -0.02932408f, -0.08608692f, 0.05143465f, -0.00353045f, 
    -0.10636254f, 0.22851810f, 0.16666108f, 0.20956112f, -0.12100064f, -0.02251270f, -0.02088802f, 0.03783366f, 
    0.07356442f, -0.03568675f, 0.03225529f, 0.00209013f, 0.23684360f, -0.13133137f, -0.01475739f, 0.22449252f, 
    0.00026793f, -0.03724136f, 0.10830457f, 0.00435260f, 0.20333570f, 0.09116647f, 0.04655764f, -0.04491733f, 
    0.01053868f, 0.10010006f, -0.07649282f, 0.15721649f, 0.03938195f, 0.05899540f, 0.00160570f, 0.06414562f, 
    0.04388910f, 0.02368214f, 0.00646182f, 0.07506427f, -0.29833883f, 0.03552706f, 0.06761524f, -0.02642233f, 
    0.07008932f, 0.00110140f, -0.02934090f, 0.01871841f, 0.06829578f, -0.00903736f, 0.02614083f, -0.05320877f, 
    -0.13905227f, 0.08362766f, 0.10710460f, 0.05164744f, 0.00878527f, -0.03210727f, 0.18634942f, 0.03652994f, 
    0.01020565f, -0.06986470f, 0.04281736f, 0.01713525f, -0.32155940f, 0.20165905f, 0.35029903f, -0.13637464f, 
    -0.07546280f, 0.00367426f, 0.06978644f, 0.11800625f, -0.00664046f, 0.00870250f, -0.00969197f, 0.06889034f, 
    -0.00191702f, -0.21159048f, -0.04444338f, 0.01783504f, 0.03961599f, -0.12711605f, 0.18012460f, -0.07215001f, 
    -0.03415956f, -0.06167884f, -0.02515901f, -0.01208344f, 0.07767907f, -0.20369393f, 0.15265369f, -0.23478757f, 
    -0.04340495f, 0.13657771f, 0.10253697f, -0.08529838f, 0.04407367f, 0.08664647f, 0.03015382f, -0.02096763f, 
    -0.08603448f, 0.13455226f, -0.37597302f, 0.12573788f, 0.11972973f, 0.00867966f, 0.01494178f, -0.03653517f, 
    0.07820427f, -0.02350158f, 0.01162730f, 0.00869527f, 0.10351664f, 0.19485027f, 0.03947026f, 0.06002323f, 
    -0.10175743f, 0.05071894f, -0.02199788f, -0.04347877f, 0.01387630f, -0.06719051f, -0.03143531f, 0.10807338f, 
    -0.18808027f, -0.04251598f, -0.02526290f, 0.02958387f, 0.25648561f, 0.00273564f, -0.02884155f, 0.02412705f, 
    0.01910123f, 0.01263607f, 0.05425444f, 0.05397629f, -0.20641112f, -0.19826221f, -0.21082789f, -0.20875295f, 
    0.24500842f, 0.18365829f, -0.04884512f, 0.14656447f, -0.11638980f, -0.06650451f, -0.05734737f, -0.02775991f, 
    -0.04145622f, 0.03396881f, -0.06700149f, 0.19164687f, 0.02761273f, 0.13859965f, -0.05839324f, -0.12406435f, 
    -0.02917507f, -0.00942747f, -0.05754268f, -0.02823012f, -0.10584549f, -0.14256291f, -0.12189841f, 0.06909439f, 
    0.03171033f, 0.11209383f, 0.02917874f, -0.04945913f, -0.01585563f, 0.19339710f, 0.05388503f, -0.00564225f, 
    -0.15519780f, -0.28864691f, 0.03694244f, -0.20344260f, 0.09529038f, 0.15243982f, 0.00857790f, -0.04523073f, 
    -0.00885556f, -0.08008592f, 0.01110295f, 0.03382975f, -0.01811446f, 0.16716108f, 0.17241688f, 0.01826659f, 
    0.04232263f, -0.04331106f, 0.06042979f, 0.06246505f, 0.15088159f, 0.00451003f, -0.06851178f, 0.04855156f, 
    0.21511459f, 0.29386592f, 0.10156928f, -0.17001681f, -0.08226112f, -0.03548247f, 0.05873101f, -0.01081518f, 
    -0.06952395f, 0.07878409f, 0.01842250f, 0.17374995f, 0.00633497f, 0.16940530f, 0.28069815f, -0.09303915f, 
    -0.10708921f, -0.05678385f, 0.07827129f, -0.01286409f, -0.02244234f, -0.04390925f, 0.04793278f, 0.09662958f, 
    0.01278216f, -0.01916847f, -0.02043497f, 0.02851652f, 0.02927755f, -0.00492246f, 0.02835762f, -0.03993604f, 
    0.00785765f, -0.02706352f, -0.03917382f, 0.02473459f, -0.02045789f, -0.00880134f, -0.02410862f, 0.02379405f, 
    -0.01973317f, -0.01115335f, -0.00574278f, -0.04047228f, -0.03962530f, -0.00398177f, 0.00813668f, 0.00222516f, 
    0.00677442f, 0.01291047f, -0.02181212f, -0.00820310f, -0.00074487f, -0.01847639f, -0.00154260f, 0.02190408f, 
    0.01726584f, -0.01072689f, -0.04249145f, 0.02506970f, 0.01341965f, -0.04297951f, 0.01308838f, 0.02377117f, 
    -0.04038961f, 0.02127223f, -0.02294724f, 0.01727687f, -0.03902961f, 0.01846678f, -0.00713792f, 0.02232446f, 
    0.00098089f, -0.04020680f, 0.00711745f, -0.00146144f, 0.01428674f, -0.01609545f, 0.02634236f, -0.01900753f, 
    0.01938367f, 0.01201450f, -0.01037183f, -0.03465952f, -0.02710594f, -0.00220853f, 0.02935968f, 0.00829871f, 
    0.00455951f, 0.00995381f, 0.02676739f, 0.01896891f, -0.01674256f, -0.03327249f, -0.00773493f, 0.01392857f, 
    -0.01050996f, 0.02085645f, -0.01009602f, -0.03227032f, 0.01301481f, 0.01945126f, -0.03679927f, 0.01520495f, 
    -0.01339022f, 0.01296503f, 0.01480323f, -0.00324748f, 0.00663373f, -0.00833254f, 0.03102845f, 0.00549564f, 
    0.01122998f, -0.01453017f, 0.02543496f, 0.00461059f, -0.00999806f, -0.02165492f, 0.00928907f, 0.00470960f, 
    0.01506025f, 0.02793799f, 0.00275172f, -0.03239764f, 0.00941843f, 0.00857461f, -0.03224043f, -0.01080277f, 
    0.02709130f, -0.00114173f, 0.01275764f, -0.01780406f, -0.01501585f, 0.02195016f, 0.02747466f, -0.04174810f, 
    0.01538866f, -0.01998707f, -0.00703140f, 0.01960493f, -0.02521424f, -0.03125800f, -0.01780719f, -0.02019338f, 
    0.02549281f, 0.00309888f, 0.01257919f, -0.02034155f, 0.01332395f, 0.00952962f, 0.01962017f, -0.00492825f, 
    -0.00160818f, -0.02261606f, -0.04210270f, 0.01684038f, 0.01509328f, 0.01551712f, -0.01751180f, -0.03656027f, 
    -0.03089234f, -0.02142962f, -0.02918070f, -0.03262853f, -0.03815005f, -0.01301742f, 0.02706679f, 0.02832878f, 
    0.00430654f, -0.04289183f, 0.02272049f, 0.00278789f, -0.00280018f, 0.01284578f, 0.00867847f, -0.01270788f, 
    -0.03993396f, -0.03691267f, -0.03154996f, -0.00616177f, -0.02057593f, 0.00236553f, -0.01339602f, 0.01935432f, 
    0.02196315f, 0.01449418f, -0.01969686f, -0.00126741f, 0.01726259f, 0.01701894f, -0.02433568f, -0.01557192f, 
    -0.03505016f, -0.03796501f, 0.00715009f, 0.02808407f, -0.03437124f, -0.00603072f, 0.01129007f, -0.03824588f, 
    -0.00057635f, -0.02392090f, 0.00493141f, -0.01120043f, -0.00046113f, -0.00216213f, -0.01606563f, 0.00748982f, 
    -0.00090549f, -0.00542044f, -0.02110403f, -0.01107409f, -0.02611102f, -0.03085539f, -0.02409987f, -0.03990157f, 
    -0.01677464f, -0.01087841f, 0.01793426f, -0.01566339f, -0.01102976f, -0.01466168f, -0.03613495f, -0.03360872f, 
    0.00187309f, -0.01748967f, -0.03654332f, 0.02456727f, -0.01979385f, 0.02823758f, -0.00959619f, -0.03894114f, 
    0.01799712f, 0.02727545f, -0.00649309f, 0.00490818f, 0.00099970f, -0.00342194f, -0.01353546f, -0.01449109f, 
    -0.01711623f, -0.03143490f, 0.02433300f, 0.00163269f, -0.03722914f, -0.00268006f, -0.02806504f, 0.02588949f, 
    -0.03119096f, -0.02731250f, -0.03328114f, -0.00881603f, 0.02655303f, -0.00431343f, -0.03318769f, -0.02206871f, 
    -0.02087061f, -0.00419041f, 0.02854324f, -0.03824250f, 0.01303515f, -0.01093251f, -0.02658001f, 0.01802897f, 
    -0.02377481f, -0.01526638f, -0.03219946f, 0.01500786f, 0.02059148f, -0.03151813f, -0.02587324f, 0.00303328f, 
    -0.01687890f, 0.02755872f, -0.04314199f, -0.01761509f, 0.01826257f, -0.03817828f, -0.02033633f, -0.01591626f, 
    -0.03632698f, 0.01588684f, 0.01429866f, -0.01842573f, -0.00122980f, -0.02642361f, 0.01555494f, 0.02524284f, 
    0.00548171f, 0.01287881f, 0.02090690f, 0.00902554f, -0.02840654f, -0.01305951f, 0.00093070f, -0.00981256f, 
    0.01888156f, -0.02351758f, -0.01917603f, -0.03688180f, 0.01695066f, -0.02513220f, 0.00306467f, 0.02008424f, 
    -0.03963053f, 0.01496914f, 0.02486865f, -0.01655697f, -0.02357696f, -0.00982335f, -0.02438508f, -0.01077913f, 
    -0.04032946f, -0.01601602f, -0.02044427f, -0.00296321f, 0.02706986f, 0.00297575f, 0.00694579f, -0.04369987f, 
    -0.02752574f, -0.02648364f, -0.03978710f, 0.01407196f, 0.01079360f, -0.00485628f, 0.01501824f, -0.03061884f, 
    0.02941171f, -0.03205874f, -0.00937567f, -0.03785414f, -0.02355448f, -0.03063140f, -0.00832015f, 0.00726995f, 
    -0.02717509f, 0.02020870f, -0.00633454f, -0.04425371f, 0.00632186f, -0.00959502f, 0.01612151f, -0.03644317f, 
    -0.00874346f, -0.00364760f, -0.01672838f, -0.03581329f, -0.03686064f, 0.01982971f, -0.01902509f, 0.02897840f, 
    0.00371233f, -0.00396935f, 0.02170659f, 0.02537142f, -0.01602791f, -0.03134793f, 0.01253969f, 0.00545994f, 
    -0.00146780f, -0.03522303f, 0.02374730f, 0.00667341f, 0.01707502f, -0.04047615f, 0.02802541f, 0.00208768f, 
    0.00046325f, 0.00231709f, 0.01404550f, -0.04204449f, 0.01541097f, -0.01165370f, 0.02145782f, 0.01509889f, 
    -0.00028435f, 0.02835884f, 0.02434606f, 0.02696226f, -0.01561492f, -0.00961057f, -0.03018358f, -0.01854506f, 
    0.00944129f, -0.01735468f, 0.00267028f, -0.03641243f, 0.02369081f, -0.03476024f, 0.02011318f, -0.01551837f, 
    -0.02452652f, -0.00604297f, -0.02165666f, 0.02160205f, -0.00983159f, -0.00227222f, -0.01608325f, 0.00142003f, 
    0.01937049f, -0.03291398f, -0.01915684f, 0.01802303f, 0.01375193f, -0.01112107f, -0.00211595f, -0.00875735f, 
    -0.03539207f, -0.03902485f, 0.01818949f, -0.01098523f, -0.02209773f, -0.00499805f, -0.01060867f, 0.00545790f, 
    0.02828977f, -0.02981084f, 0.02473875f, -0.03071037f, -0.03135972f, -0.03726712f, -0.04053680f, 0.00163444f, 
    -0.02185681f, 0.02784835f, -0.01743430f, -0.04086392f, -0.02947793f, 0.02749303f, -0.01516600f, -0.02650338f, 
    0.02793044f, -0.00374167f, -0.01498839f, -0.02725531f, -0.01634349f, 0.03010871f, -0.03154595f, -0.03345501f, 
    0.01140142f, 0.00138625f, 0.00263071f, -0.01303439f, -0.01489673f, -0.02653867f, 0.01267870f, -0.04293914f, 
    -0.02992537f, -0.01833314f, -0.01462277f, 0.01852346f, -0.00887440f, -0.03373703f, 0.00846372f, 0.01731626f, 
    0.01774726f, 0.01472698f, -0.02172816f, 0.01150641f, 0.01120563f, 0.03150611f, 0.00874233f, -0.02635224f, 
    0.01912427f, 0.01062328f, -0.00522822f, -0.02307959f, -0.02490822f, 0.02724437f, -0.02354289f, 0.02664332f, 
    -0.01032757f, -0.03356182f, -0.01803639f, 0.01231877f, -0.01019766f, -0.00745460f, -0.01998909f, -0.03944299f, 
    -0.01660169f, -0.00600536f, 0.02054801f, -0.03349987f, -0.03408451f, -0.01264315f, -0.02759154f, -0.02324129f, 
    0.01743887f, 0.00219296f, 0.02557252f, -0.02063023f, -0.00505681f, 0.01612785f, 0.01869261f, -0.01345460f, 
    0.00596925f, -0.02420802f, -0.04031523f, 0.00273400f, -0.00109138f, -0.01698248f, 0.01341348f, -0.02521178f, 
    0.02465298f, -0.03708103f, -0.00807367f, -0.01459149f, -0.00882919f, 0.02949054f, 0.02094548f, 0.02281152f, 
    -0.03595023f, -0.02058737f, -0.03331532f, -0.00750944f, -0.03370908f, -0.00090914f, -0.01609870f, -0.04260484f, 
    0.00121710f, -0.04132100f, 0.01198626f, 0.00667280f, 0.03191625f, -0.00765107f, 0.01542312f, -0.02886628f, 
    -0.03288012f, 0.01105429f, -0.00103884f, 0.02322200f, 0.01475757f, -0.00871408f, -0.04184334f, 0.02720793f, 
    -0.03761800f, -0.00371071f, -0.01450152f, 0.01182136f, 0.02186747f, -0.01749906f, 0.00083786f, 0.01617143f, 
    -0.01930225f, -0.00471766f, 0.01127197f, -0.04047753f, -0.04196261f, 0.02097446f, -0.03132525f, -0.00036472f, 
    -0.04015932f, 0.02280959f, -0.04376747f, -0.00489549f, -0.01681238f, 0.00520267f, 0.01466318f, -0.00346791f, 
    -0.00671305f, 0.01674957f, 0.00148631f, -0.01758461f, 0.02731597f, -0.02882794f, 0.00029530f, 0.01449296f, 
    0.02505098f, -0.01840553f, 0.02909153f, 0.01936176f, -0.01494944f, 0.02344342f, -0.02464103f, -0.01012834f, 
    -0.00826526f, -0.00816770f, -0.01783495f, -0.02302047f, -0.01032881f, -0.00311028f, -0.03262265f, -0.01436735f, 
    0.00435620f, -0.00334627f, -0.01367950f, 0.02671153f, -0.03290212f, 0.01209680f, 0.03128856f, -0.00971591f, 
    -0.00927533f, -0.03382358f, -0.02283463f, -0.02914239f, -0.02730408f, 0.01178111f, -0.01011256f, 0.00037446f, 
    -0.00270749f, 0.01727764f, 0.01200539f, -0.04124115f, 0.01702681f, -0.00759986f, 0.02032460f, -0.03850447f, 
    0.00935225f, 0.00100708f, -0.00586610f, -0.02466292f, 0.02913968f, 0.01596461f, -0.01276252f, 0.00654788f, 
    0.00429694f, 0.01912877f, -0.03058260f, 0.01406747f, -0.00783348f, -0.03723111f, 0.01373968f, 0.02747648f, 
    -0.03098070f, -0.03796496f, 0.02314141f, 0.02017560f, -0.03493275f, -0.03813739f, -0.02673458f, 0.00761176f, 
    0.01286775f, 0.00553373f, -0.02620977f, -0.00883477f, -0.03576220f, 0.00357753f, -0.00996527f, 0.02638662f, 
    -0.02094710f, 0.01984608f, -0.00895819f, -0.02423602f, -0.01581225f, -0.02037042f, 0.02949503f, -0.02529904f, 
    -0.01779116f, 0.01698286f, 0.01157113f, 0.02770911f, -0.03356886f, -0.01328455f, 0.02001988f, 0.00229239f, 
    -0.01023644f, -0.01196844f, -0.01669027f, -0.03164920f, -0.02068994f, -0.02264210f, -0.02343211f, -0.03049792f, 
    -0.01870787f, -0.01011873f, 0.02383814f, 0.02766518f, -0.02676504f, -0.02721456f, -0.00158718f, -0.02853156f, 
    0.01909658f, 0.02442779f, 0.01074001f, -0.01406193f, -0.03804312f, -0.00979486f, -0.00050459f, -0.04057011f, 
    -0.00879999f, -0.03592210f, -0.01983127f, -0.00422246f, -0.03672592f, -0.02110505f, -0.00700986f, 0.00523596f, 
    -0.00628038f, -0.01041129f, 0.01008565f, -0.00222643f, 0.00696438f, 0.01084363f, -0.00906911f, 0.01801393f, 
    -0.00206728f, -0.02549505f, -0.01104320f, -0.02326426f, -0.01645061f, -0.00261643f, 0.02582652f, 0.01462160f, 
    0.00312093f, -0.01625752f, 0.02397336f, 0.00557691f, 0.01231453f, -0.02132976f, 0.01229912f, -0.03830093f, 
    0.02974337f, 0.01827921f, -0.00443323f, 0.01156733f, 0.01797509f, -0.02511648f, 0.01232163f, 0.01196164f, 
    -0.04152136f, -0.02863388f, -0.00956971f, 0.00838444f, 0.01532833f, -0.03944873f, 0.02460399f, -0.03640018f, 
    -0.02605498f, -0.00469306f, 0.02668805f, 0.02022433f, -0.03627387f, 0.01942185f, -0.00814420f, -0.03750849f, 
    -0.03496863f, -0.00171027f, 0.00298843f, -0.04264533f, -0.00159743f, 0.02397600f, 0.01041524f, -0.03328476f, 
    -0.00278756f, -0.04119856f, -0.01268208f, 0.02224395f, -0.03658577f, 0.02076364f, 0.02130132f, -0.01233059f, 
    0.02395040f, 0.02017517f, 0.00140172f, -0.03900583f, -0.00011565f, -0.00893850f, -0.01671151f, 0.02065542f, 
    0.01987419f, -0.02373788f, -0.00965454f, -0.03084776f, -0.01465256f, -0.03302941f, -0.00114005f, 0.00313737f, 
    -0.01421263f, 0.02404948f, -0.01854932f, -0.03676419f, 0.02706527f, -0.01290961f, 0.00747292f, -0.03213044f, 
    -0.00833939f, 0.01261590f, -0.00912295f, 0.01066729f, -0.03398272f, 0.02125189f, 0.00661524f, 0.02809021f, 
    -0.03508260f, 0.01195582f, 0.02595482f, -0.04373566f, 0.02785433f, -0.03809565f, -0.01220524f, -0.04111475f, 
    -0.15599819f, -0.11437970f, 0.18348972f, 0.07449830f, -0.11405940f, 0.03470311f, 0.02070215f, -0.00203779f, 
    0.14962398f, -0.00762057f, 0.03968817f, -0.03434218f, 0.11509202f, 0.01562100f, -0.05921280f, -0.02928944f, 
    0.11240511f, 0.09135960f, -0.02459766f, -0.01725671f, 0.12306333f, 0.00470638f, 0.03837534f, 0.13993426f, 
    0.08612896f, 0.16190441f, 0.03876581f, -0.00065241f, 0.04387638f, 0.01542129f, 0.11295454f, 0.01730331f, 
    -0.03431706f, -0.07032387f, 0.06124663f, 0.05228557f, -0.14567482f, 0.03578098f, 0.31178683f, 0.02309523f, 
    0.02974046f, -0.01869822f, 0.11498071f, 0.02882698f, 0.05737194f, -0.09832357f, -0.14803506f, 0.01316681f, 
    -0.32430786f, -0.02345873f, 0.23398706f, -0.13172597f, 0.00674225f, 0.01955876f, 0.06401581f, 0.10207175f, 
    -0.06989060f, -0.04938056f, -0.08883438f, -0.02025530f, -0.04449960f, -0.13306470f, 0.15943447f, 0.01721973f, 
    -0.00011283f, -0.08112750f, -0.02634111f, 0.04726909f, 0.04490946f, 0.01412748f, -0.00025516f, 0.04041849f, 
    0.10648430f, 0.10779912f, 0.16335726f, 0.08245158f, -0.01674735f, 0.09123116f, -0.02324871f, 0.03163036f, 
    -0.06068065f, 0.13973677f, 0.07660001f, 0.03154146f, -0.17518757f, -0.15060011f, 0.18377711f, 0.08865952f, 
    -0.06841611f, 0.04292345f, -0.03698687f, 0.23598136f, -0.01030513f, -0.08781870f, -0.01956182f, -0.04722124f, 
    -0.00354087f, 0.11717379f, 0.08250321f, 0.04739533f, 0.06569402f, 0.13126551f, 0.04379265f, 0.02093178f, 
    -0.02026947f, 0.10728317f, 0.07745425f, 0.04716391f, 0.13572380f, 0.09133938f, 0.06356029f, 0.08238170f, 
    -0.01170433f, 0.05528512f, 0.19868888f, 0.04173820f, 0.13109222f, -0.03136050f, 0.07652651f, 0.05429056f, 
    -0.04634504f, -0.02723167f, -0.11039754f, 0.09760232f, 0.00876435f, 0.06488515f, -0.00324427f, 0.10236107f, 
    0.00806889f, 0.07771448f, 0.01061132f, -0.05379507f, 0.20982920f, -0.11398669f, 0.02058741f, -0.08516673f, 
    -0.10726276f, 0.05502336f, 0.04148201f, -0.05432686f, -0.07529437f, 0.03654693f, -0.00376510f, 0.03286780f, 
    -0.26312655f, 0.12925409f, 0.07534614f, 0.04508504f, -0.08357145f, -0.04974786f, -0.04179433f, -0.03125367f, 
    -0.00936707f, 0.00987089f, -0.00516115f, -0.01501987f, 0.03426581f, -0.02541709f, -0.10021711f, -0.05445851f, 
    -0.03053956f, -0.09025652f, 0.09036953f, -0.06324288f, 0.07477739f, 0.05502263f, 0.00144225f, -0.04323113f, 
    0.28473821f, -0.02418947f, 0.18792924f, 0.05550348f, 0.03238355f, 0.10353988f, 0.10646227f, 0.10556988f, 
    -0.10096534f, -0.07037504f, 0.05422317f, 0.07832103f, 0.18871686f, -0.18048540f, 0.21096328f, -0.11185639f, 
    -0.12032449f, 0.09738644f, -0.00367125f, -0.02879037f, -0.12510280f, -0.00835667f, 0.05478106f, -0.05634972f, 
    -0.27757663f, 0.09524585f, 0.04347106f, -0.16200574f, -0.11181806f, -0.07565515f, 0.00188976f, 0.08300804f, 
    -0.02096248f, -0.04964174f, 0.02250476f, -0.06613856f, -0.00444272f, -0.02373437f, 0.00223636f, 0.07552169f, 
    0.01340101f, 0.02243742f, -0.02548401f, 0.10733858f, 0.09430287f, -0.05488619f, -0.04642046f, -0.08227545f, 
    -0.13686918f, 0.02058737f, 0.21515585f, 0.08248942f, 0.06971325f, -0.02216623f, 0.06685575f, 0.07251875f, 
    -0.00351082f, 0.08785373f, -0.01635726f, 0.10896734f, 0.30142981f, 0.10831438f, 0.14555635f, 0.19121346f, 
    -0.00151483f, 0.00458561f, 0.00804986f, 0.07514144f, 0.02020247f, -0.00999792f, -0.03594796f, 0.13526706f, 
    0.14272927f, -0.20106107f, 0.02338783f, -0.00573673f, -0.09089138f, 0.09354792f, 0.04638427f, -0.00249785f, 
    -0.02148050f, 0.03614201f, 0.02844242f, -0.09755305f, -0.29847780f, 0.05743352f, 0.04266063f, 0.13079390f, 
    -0.09946287f, 0.05688911f, -0.03244789f, 0.06395848f, -0.09443530f, 0.09935530f, -0.01723342f, 0.03386248f, 
    -0.10172243f, -0.11220655f, 0.01601848f, -0.05038319f, 0.01539883f, -0.07564455f, 0.02104959f, -0.05999812f, 
    -0.02856931f, -0.01939369f, -0.05679910f, -0.03901200f, 0.03158580f, -0.09438451f, 0.05822290f, -0.10294002f, 
    0.05180825f, -0.00811099f, 0.04982235f, -0.09701683f, 0.02058616f, 0.01240415f, -0.00240447f, 0.13280900f, 
    -0.04208852f, 0.06492701f, -0.13072400f, -0.06003152f, -0.04014600f, 0.09374929f, 0.05039239f, -0.03460387f, 
    0.00585973f, 0.02196476f, 0.09033522f, 0.05916515f, -0.23981084f, 0.04349229f, 0.03435901f, -0.03641430f, 
    -0.08042385f, -0.05786759f, 0.01299412f, 0.14303993f, 0.02843273f, -0.11125138f, 0.01796304f, 0.09225512f, 
    -0.03763034f, 0.28113061f, 0.07469420f, 0.30287123f, -0.13155644f, 0.12711458f, 0.00461179f, 0.12381275f, 
    0.02710934f, -0.01492525f, 0.02825074f, 0.06269599f, 0.16214058f, 0.17654562f, -0.00702077f, 0.02513151f, 
    -0.05806508f, -0.10393083f, 0.02956667f, 0.02689188f, 0.01525856f, 0.01116014f, -0.07438132f, 0.12311926f, 
    -0.13034908f, 0.02917308f, -0.16418946f, -0.07229723f, 0.05758351f, 0.00018141f, 0.03508118f, 0.07908975f, 
    0.02547411f, 0.06195128f, 0.10843118f, -0.00381270f, -0.19639257f, -0.13520449f, 0.10128801f, -0.15051737f, 
    -0.06073737f, -0.06649438f, -0.06325714f, -0.05655481f, 0.01075998f, 0.09594816f, 0.01606938f, 0.08727548f, 
    -0.05510696f, 0.08255669f, -0.08787892f, -0.07717742f, -0.10592709f, -0.04452247f, -0.06004575f, 0.01207216f, 
    0.03838208f, 0.06473230f, -0.03405199f, -0.03832340f, 0.00530854f, 0.18581980f, 0.07497200f, 0.05770654f, 
    -0.02022169f, -0.04082894f, 0.07350602f, 0.14454994f, -0.02253845f, 0.05936800f, -0.02983672f, -0.02707182f, 
    -0.14623258f, 0.04995529f, 0.01822005f, 0.05091925f, -0.01437324f, -0.01516243f, 0.06500841f, 0.10831486f, 
    0.03206654f, 0.03221262f, 0.01454670f, 0.04401273f, 0.00657341f, -0.03346195f, -0.00550497f, -0.06366945f, 
    -0.03742113f, 0.10556547f, 0.08698861f, 0.02148368f, -0.00532918f, 0.04678193f, 0.04748662f, 0.03175539f, 
    -0.02812643f, -0.01027631f, 0.03528560f, -0.00652003f, 0.06517561f, -0.04687613f, 0.04741916f, -0.06563368f, 
    -0.08326203f, -0.05251672f, 0.09508298f, -0.09124215f, 0.05785821f, -0.09941100f, 0.07410357f, -0.04371149f, 
    0.01660479f, 0.02925022f, -0.00457328f, 0.03949964f, 0.02840641f, 0.05349333f, -0.05434924f, 0.06440509f, 
    -0.09735333f, 0.03579650f, 0.12943831f, 0.08416666f, 0.02545987f, -0.12714446f, 0.08074840f, 0.06011084f, 
    -0.00409334f, -0.00587568f, -0.00126388f, 0.00511314f, -0.07376757f, 0.12396915f, -0.02421384f, -0.01883737f, 
    0.01592622f, 0.00813474f, 0.05611993f, -0.15657780f, 0.13162573f, 0.04411270f, 0.10941751f, -0.04240320f, 
    -0.03184128f, 0.03295064f, -0.08597019f, 0.09223128f, -0.09428795f, 0.02581920f, -0.01237844f, -0.04789808f, 
    0.03357581f, 0.01872182f, 0.05530765f, 0.00848914f, -0.17477322f, 0.01839936f, 0.15022448f, 0.01146570f, 
    0.02957378f, 0.13910338f, -0.01442361f, -0.08057468f, 0.08087181f, 0.09238302f, -0.08358434f, 0.07708009f, 
    0.00005536f, -0.09436774f, -0.03001427f, -0.05349089f, -0.01373931f, 0.16198139f, -0.02682639f, -0.00682348f, 
    -0.06122452f, -0.02577203f, 0.07968125f, -0.01625179f, 0.00118004f, 0.03081082f, 0.09333362f, 0.04271945f, 
    0.00912667f, -0.10539395f, -0.04105124f, 0.06504717f, 0.01004673f, 0.00994868f, 0.09256777f, -0.03765557f, 
    -0.14392929f, -0.12234819f, 0.00524800f, 0.04293876f, 0.04268822f, -0.03467910f, -0.02223096f, -0.00807294f, 
    0.09267522f, -0.01160433f, -0.00743683f, 0.00210531f, -0.00887565f, 0.13283092f, -0.07615908f, -0.04928576f, 
    -0.02975042f, -0.02558721f, 0.04855003f, 0.02952103f, -0.01956339f, 0.01917147f, -0.00738048f, -0.02084211f, 
    0.05166902f, -0.05681365f, 0.10286934f, -0.04172341f, -0.05325701f, 0.08365028f, 0.00851256f, 0.03000409f, 
    0.07650772f, 0.05895699f, -0.02552931f, 0.13857535f, 0.10217414f, -0.02111998f, 0.03252658f, -0.10892803f, 
    0.01779959f, 0.07836877f, -0.00926005f, -0.03561479f, -0.04026444f, -0.01638725f, 0.13243745f, 0.06698480f, 
    -0.26049468f, 0.18645978f, 0.03612288f, 0.18638538f, 0.06821029f, 0.04790356f, 0.05097829f, 0.10606102f, 
    0.12236862f, -0.00378079f, -0.07838568f, -0.08519898f, 0.01784920f, 0.09061900f, 0.16249177f, 0.01021678f, 
    -0.03694870f, -0.13835388f, 0.12720871f, -0.02873848f, 0.04335791f, 0.14472944f, -0.02420021f, -0.00074031f, 
    0.17959815f, -0.02820355f, -0.05413808f, 0.14503284f, -0.07454524f, -0.01174053f, 0.12172792f, -0.17287822f, 
    0.04239961f, 0.01461701f, 0.03346456f, -0.11615548f, 0.12304805f, -0.02191290f, -0.08267584f, 0.00095311f, 
    -0.08523906f, 0.10634170f, 0.03778239f, -0.06587575f, 0.05359764f, 0.02752224f, -0.06846537f, 0.17445216f, 
    -0.32087129f, -0.19878328f, -0.16587323f, 0.20145889f, -0.00459810f, 0.12544532f, -0.03703324f, 0.10800450f, 
    -0.01052748f, 0.00838846f, -0.04982479f, -0.10662759f, -0.27634242f, 0.02497030f, 0.14287993f, -0.07752376f, 
    -0.09376333f, -0.02573791f, -0.03545802f, 0.08780243f, -0.03769878f, -0.09919808f, 0.01179327f, 0.03254045f, 
    -0.17468394f, -0.06604527f, -0.20414183f, 0.02420367f, -0.12404963f, 0.13553864f, -0.03042598f, -0.06645156f, 
    0.01886059f, -0.05396723f, 0.04678371f, -0.00102326f, -0.17191723f, 0.00518841f, 0.17311938f, -0.05139426f, 
    0.06612893f, -0.00621660f, 0.02034500f, 0.03606280f, -0.02162674f, 0.07997522f, -0.07085190f, 0.02272956f, 
    0.16004793f, -0.11639555f, -0.00867485f, 0.11988339f, 0.10567430f, -0.00342424f, 0.08996103f, 0.06134553f, 
    -0.05473373f, 0.07031621f, -0.03433802f, -0.03335397f, -0.23828276f, 0.10271598f, -0.00253867f, 0.08329807f, 
    -0.16683944f, 0.04803615f, 0.04819012f, 0.00262996f, 0.00426976f, -0.02936402f, 0.05751414f, 0.10064963f, 
    0.09812011f, 0.04202173f, -0.05308436f, 0.01840508f, -0.04677335f, -0.05764002f, 0.01224191f, -0.01366985f, 
    -0.09736273f, 0.01106586f, 0.05415777f, 0.02086817f, -0.24336927f, 0.09270804f, 0.09459027f, -0.08248851f, 
    -0.05555333f, -0.00121864f, -0.00955501f, 0.02359826f, -0.04051840f, 0.02485855f, -0.01321427f, 0.09247199f, 
    0.22222713f, 0.00068750f, 0.14756691f, 0.09865646f, 0.01740864f, 0.08588559f, 0.00426620f, -0.09882831f, 
    0.03282271f, -0.00637555f, -0.02677852f, -0.02787831f, 0.08592958f, -0.08417431f, -0.08866608f, 0.05159502f, 
    0.02842279f, 0.09225968f, 0.00244444f, 0.00021132f, 0.00747558f, 0.05884234f, -0.03393219f, -0.01552951f, 
    0.16893288f, -0.05692984f, 0.04868360f, -0.03580834f, -0.08896122f, 0.09070028f, 0.00476697f, 0.01690333f, 
    0.03255890f, 0.03343299f, -0.07275175f, 0.04733803f, -0.17917402f, 0.02480252f, 0.01152783f, 0.07256382f, 
    -0.08934661f, 0.08649928f, 0.03662976f, 0.04729491f, 0.06909306f, -0.05427112f, -0.07663538f, -0.02711346f, 
    -0.10184460f, 0.07024181f, 0.01159068f, -0.12494221f, -0.10582548f, 0.04186540f, 0.06694382f, 0.04549857f, 
    0.04720790f, -0.03611093f, -0.08939847f, -0.01557284f, 0.00720553f, -0.05253208f, 0.05656302f, -0.03469642f, 
    -0.13403034f, 0.07355127f, -0.06890788f, 0.11149693f, -0.02136014f, -0.12277827f, 0.03739928f, -0.03173947f, 
    0.02071776f, 0.02300886f, -0.02325148f, -0.01971339f, -0.03407327f, -0.00865386f, -0.00943693f, 0.00079426f, 
    -0.04448836f, -0.02000928f, -0.03815147f, -0.00312415f, -0.02401170f, -0.04130783f, -0.02621886f, 0.01009883f, 
    0.00883611f, -0.01263776f, 0.00812095f, -0.03018216f, 0.00810204f, -0.03054782f, 0.02329629f, -0.01820868f, 
    -0.03506902f, -0.01463626f, -0.03835532f, -0.01433863f, -0.00392211f, -0.00335551f, -0.03475265f, 0.01082670f, 
    -0.00171783f, -0.00660541f, -0.01810559f, -0.01045611f, 0.02050368f, -0.03526849f, -0.00629753f, 0.01510627f, 
    0.02421270f, -0.03804997f, 0.00696798f, 0.02424434f, 0.00193241f, -0.01188595f, -0.01058567f, 0.02063954f, 
    -0.01549364f, 0.00135545f, -0.01342489f, 0.00497415f, 0.02221735f, 0.02582851f, -0.01462897f, -0.00075629f, 
    0.00659128f, 0.02055916f, -0.02704631f, -0.00439057f, -0.00852991f, 0.01714269f, -0.03312042f, -0.00738369f, 
    -0.00924327f, -0.01940177f, 0.01313678f, -0.00956195f, 0.00649422f, -0.03854893f, 0.01714734f, 0.01760381f, 
    0.01927977f, 0.00856430f, -0.02632381f, -0.00470744f, -0.00039252f, 0.01457211f, 0.01461412f, -0.02565718f, 
    -0.03585140f, 0.00904156f, -0.03154757f, 0.01421460f, 0.02272111f, 0.00784814f, -0.03363788f, -0.03191924f, 
    0.02178711f, -0.01885064f, 0.00742390f, -0.03920322f, -0.03515949f, -0.00710557f, 0.00262468f, 0.02182723f, 
    0.00645424f, -0.03920886f, -0.03498621f, -0.00878608f, -0.01564349f, -0.01244513f, -0.01976982f, 0.00212591f, 
    -0.03070163f, 0.02339681f, -0.03917534f, -0.00538107f, 0.00470102f, -0.00322459f, 0.02043213f, 0.02730550f, 
    -0.01243723f, -0.00876630f, -0.04293274f, -0.02973250f, -0.03600787f, 0.01383231f, -0.03456982f, 0.01567532f, 
    -0.01378636f, -0.02128237f, -0.01864542f, 0.01657252f, 0.01946262f, 0.00191643f, 0.02759974f, 0.00995442f, 
    0.01587243f, -0.00041026f, 0.02691008f, 0.00532651f, -0.03852923f, 0.00786028f, -0.04278680f, 0.01998283f, 
    -0.01829706f, 0.01346134f, -0.01325001f, -0.01475976f, 0.01780020f, 0.01726810f, -0.03406277f, 0.01073266f, 
    0.00854931f, 0.02288322f, 0.01476812f, 0.00918592f, 0.01853167f, -0.03922176f, 0.02637353f, 0.02290286f, 
    -0.02693308f, -0.01562751f, -0.00602596f, -0.01491808f, 0.01154734f, 0.01526749f, 0.00915049f, -0.00733666f, 
    -0.02365521f, -0.01713488f, -0.00109722f, -0.00811643f, 0.00364533f, 0.02493216f, 0.00116645f, -0.03766093f, 
    0.00185037f, 0.00187145f, 0.02838929f, -0.04105042f, 0.01868716f, 0.00931581f, 0.00920139f, -0.02843567f, 
    -0.02891351f, 0.01163118f, 0.02204398f, 0.01062099f, -0.04073964f, 0.00886596f, 0.02689726f, 0.02012966f, 
    -0.01861373f, 0.02463290f, -0.02978300f, -0.02037702f, 0.01724378f, -0.00099441f, -0.00627589f, -0.02523290f, 
    -0.02594253f, 0.01453567f, 0.02473024f, -0.00648981f, 0.00161966f, -0.01660700f, 0.01344175f, -0.03235407f, 
    0.01941551f, 0.01617598f, -0.01548155f, 0.00107509f, -0.01179891f, -0.02882180f, -0.01685444f, -0.03398973f, 
    -0.00184979f, -0.01535946f, 0.00255966f, 0.00378629f, -0.01601356f, -0.02959375f, -0.03666668f, -0.03781196f, 
    -0.02282886f, 0.00182942f, -0.00936124f, -0.01548501f, -0.00887275f, -0.01755289f, 0.01036783f, 0.00464327f, 
    0.01516895f, -0.01408131f, -0.01044523f, -0.02438129f, -0.00427233f, 0.02310606f, -0.01708309f, -0.02232946f, 
    0.02085951f, -0.01680841f, -0.00890070f, 0.01214140f, 0.01889720f, -0.02468258f, -0.03229599f, -0.02195326f, 
    -0.01753371f, 0.00612958f, -0.00623607f, -0.00606301f, -0.03560600f, -0.00995266f, 0.02120273f, -0.04005777f, 
    -0.01613548f, -0.02669607f, -0.01786178f, -0.00992682f, -0.01814903f, -0.02963400f, -0.00823879f, 0.00090907f, 
    0.00585560f, 0.02169755f, -0.01326632f, -0.02871629f, -0.04144477f, -0.01173389f, 0.00143061f, 0.01545550f, 
    0.02555187f, -0.02736302f, -0.02469387f, -0.01581312f, -0.00747496f, -0.01435789f, 0.02215903f, 0.02308472f, 
    -0.01872652f, 0.02425731f, 0.01717824f, -0.00490079f, -0.01141079f, -0.03652588f, -0.03013654f, -0.02667926f, 
    -0.04357979f, 0.00917032f, -0.00462213f, 0.02245655f, -0.03174208f, 0.01929438f, -0.01392346f, 0.02218778f, 
    -0.03847232f, -0.03402241f, 0.01028823f, -0.00821294f, -0.02598694f, -0.00716785f, -0.03415165f, -0.01830084f, 
    -0.00468233f, 0.02737402f, -0.03951566f, 0.00248279f, 0.02350234f, -0.02717534f, -0.02719904f, 0.01988249f, 
    -0.04362582f, 0.02451007f, 0.01859286f, 0.01338993f, 0.01338584f, 0.00706600f, 0.01532547f, -0.00587873f, 
    -0.00743513f, 0.01394541f, -0.01260762f, 0.01610618f, 0.00343669f, -0.00607639f, 0.00793208f, -0.03508467f, 
    0.01542007f, -0.00444316f, 0.02713998f, -0.00403893f, -0.02437582f, 0.02149931f, 0.01667925f, -0.03537456f, 
    0.02044543f, -0.02934648f, 0.00107515f, -0.02773405f, 0.00455885f, -0.01549220f, 0.01307683f, 0.02392665f, 
    0.02713843f, -0.04205211f, -0.03459981f, -0.00948509f, 0.02686218f, -0.01109412f, -0.01807876f, -0.03575588f, 
    0.01043625f, 0.02181749f, 0.00617067f, 0.01333964f, -0.02992714f, -0.00186120f, 0.01227874f, 0.01619269f, 
    0.01128386f, -0.02272324f, -0.00420576f, -0.01243875f, -0.03239531f, -0.02791557f, 0.00512826f, -0.00898418f, 
    0.02760139f, -0.00889121f, -0.00333436f, 0.01302635f, -0.00122682f, -0.01002269f, 0.01076958f, 0.00997672f, 
    0.00956868f, 0.00413379f, -0.01302161f, -0.00680406f, 0.00011413f, -0.00656375f, 0.01767131f, 0.00692775f, 
    -0.01654242f, 0.02568018f, -0.04309618f, -0.00323409f, -0.02500310f, -0.02040513f, -0.00920975f, -0.04135073f, 
    -0.01120087f, 0.01297835f, 0.01073257f, 0.02247334f, 0.01328580f, 0.01122395f, 0.01907532f, 0.01855564f, 
    -0.04297512f, 0.00380902f, -0.00619924f, -0.00059683f, -0.01531509f, -0.02565582f, -0.00885790f, -0.03008010f, 
    -0.03734457f, -0.01345033f, 0.03255254f, 0.02067153f, -0.02552889f, 0.00375015f, -0.02175030f, 0.00587219f, 
    -0.00140877f, -0.02474714f, 0.01850686f, -0.02206306f, 0.00429112f, -0.01198364f, -0.00524078f, -0.01279253f, 
    -0.01168239f, 0.00497132f, 0.00208813f, 0.00046211f, 0.02733464f, -0.00194297f, 0.00502510f, 0.01874031f, 
    -0.03499561f, -0.00526957f, -0.01119473f, -0.02585903f, -0.03621923f, 0.01420870f, -0.02019258f, -0.03387759f, 
    -0.02183696f, -0.03760914f, 0.01486169f, -0.03775289f, -0.02231504f, -0.01271401f, -0.03543694f, -0.01970838f, 
    -0.02448735f, -0.01506791f, -0.02847635f, -0.02154233f, -0.03101459f, -0.01613419f, 0.00434503f, -0.03651536f, 
    0.00565429f, 0.01426221f, 0.02141413f, -0.01503951f, 0.00137548f, -0.02108145f, 0.00036379f, -0.04141824f, 
    -0.02236385f, -0.02738656f, 0.02395163f, -0.02032435f, 0.01087439f, 0.01875404f, -0.02282016f, -0.02167736f, 
    -0.03676265f, 0.02624690f, 0.02553318f, -0.01556842f, -0.01497450f, -0.03521257f, -0.01504148f, 0.02214533f, 
    0.00952862f, -0.00245065f, 0.01346444f, 0.01599642f, -0.03465951f, -0.01924637f, 0.00546512f, -0.00744135f, 
    0.01938674f, -0.00210358f, 0.00102672f, 0.00195882f, 0.00653817f, 0.02188008f, 0.00257489f, -0.01382958f, 
    -0.02643904f, -0.03940875f, -0.00856898f, 0.00762706f, 0.01259559f, 0.00412869f, 0.02257294f, -0.01604370f, 
    0.02295125f, 0.02320166f, -0.00857003f, 0.00067969f, 0.01694768f, 0.01355825f, -0.01608439f, 0.01376008f, 
    0.01310838f, 0.01386129f, 0.01144100f, -0.01902887f, -0.03522123f, 0.00997726f, -0.03533342f, 0.01886164f, 
    -0.00279537f, -0.01731873f, -0.04128333f, 0.02220895f, 0.01686085f, -0.03608760f, -0.03586527f, 0.01695878f, 
    0.02264925f, 0.00243465f, -0.04218672f, -0.00231917f, 0.00800521f, 0.02714235f, -0.02362780f, 0.02298439f, 
    -0.03255264f, -0.01533536f, -0.03642053f, 0.01125101f, -0.01549392f, -0.04279373f, -0.01676949f, -0.04197302f, 
    -0.01075377f, 0.02302409f, -0.03403975f, 0.00410985f, -0.04389571f, -0.03476385f, -0.00403329f, -0.03753077f, 
    -0.02321547f, 0.01111498f, -0.03116989f, -0.01667026f, -0.00937546f, -0.03693369f, -0.02127818f, 0.01490619f, 
    -0.00084552f, 0.00574227f, -0.02899181f, -0.04243420f, -0.01724060f, -0.03945410f, -0.00723559f, -0.00718009f, 
    -0.00424819f, -0.01924282f, 0.01125391f, -0.00549007f, -0.00222273f, -0.00149808f, -0.00335998f, 0.02300257f, 
    -0.02194041f, -0.02847006f, -0.03668657f, -0.00911586f, 0.01886912f, -0.03474813f, -0.04351984f, -0.03209962f, 
    -0.00211169f, -0.00362279f, 0.02047681f, -0.02584496f, -0.03146044f, 0.00033001f, 0.01136651f, -0.02751914f, 
    0.02557703f, 0.02373941f, 0.01694953f, -0.02791494f, 0.02102558f, 0.02333469f, 0.00723731f, -0.00953627f, 
    0.00363834f, 0.00288840f, -0.02160260f, 0.02446134f, -0.00780307f, -0.00713498f, -0.01622890f, 0.00934627f, 
    0.02392604f, 0.01111034f, 0.02166830f, -0.01607387f, -0.04293702f, -0.01460051f, -0.01105454f, 0.02381159f, 
    -0.00420834f, 0.02406265f, -0.04377579f, -0.01332433f, -0.00645767f, -0.03180127f, -0.04144636f, -0.03465620f, 
    -0.00380133f, 0.02217733f, 0.02614005f, 0.00965372f, -0.04253684f, -0.04344679f, -0.00208612f, -0.02335824f, 
    -0.02243443f, -0.01937407f, -0.02162082f, -0.01061814f, -0.02223632f, 0.00757102f, -0.01743014f, -0.00931317f, 
    0.00681257f, -0.04012042f, 0.00595558f, 0.01848424f, -0.02823378f, -0.00450453f, -0.01464852f, 0.00134253f, 
    0.01212864f, -0.02582851f, 0.00832141f, -0.03766261f, -0.01653512f, -0.00633456f, -0.00273771f, 0.02348541f, 
    0.01667440f, -0.01957787f, 0.02650470f, 0.01236475f, -0.01793189f, 0.02358407f, -0.03948775f, 0.00304837f, 
    -0.00328412f, -0.00672740f, 0.01501763f, -0.01184551f, -0.02984299f, -0.02160551f, -0.02723654f, 0.00362394f, 
    -0.01548530f, -0.04271860f, 0.01978413f, -0.02282492f, 0.02371202f, 0.02356078f, 0.00927145f, 0.01037235f, 
    -0.02341538f, -0.01382481f, 0.01244704f, -0.02941782f, -0.04256496f, -0.04358632f, -0.02584176f, -0.03341570f, 
    -0.01452416f, -0.01972399f, -0.00646507f, -0.03997649f, -0.04197796f, -0.00831881f, -0.03275643f, -0.02129546f, 
    -0.02973278f, -0.03238695f, -0.00738574f, -0.02283024f, -0.03854826f, -0.00350023f, -0.02680317f, 0.02363132f, 
    0.00267312f, -0.00541485f, -0.01791948f, -0.02343306f, -0.00500405f, 0.00910993f, -0.00520897f, 0.02155575f, 
    0.00309846f, 0.00793033f, -0.04334035f, 0.00218280f, 0.01491969f, -0.00376278f, -0.01006947f, -0.02735864f, 
    -0.01106003f, 0.02766359f, -0.02817423f, -0.00348345f, -0.01754015f, 0.02154949f, -0.02046991f, -0.01380248f, 
    -0.01106398f, -0.03648696f, 0.02158140f, 0.02431571f, -0.03788321f, -0.02767499f, -0.02332733f, 0.00323688f, 
    -0.02587260f, -0.01108522f, -0.01816841f, -0.00969214f, 0.01984971f, 0.02377858f, -0.04306878f, -0.01760788f, 
    0.00333996f, -0.00987150f, -0.02012651f, -0.04114734f, 0.02258231f, 0.00359547f, 0.01731019f, -0.01633057f, 
    -0.00789212f, 0.00015070f, -0.00822612f, -0.02955197f, -0.00102400f, -0.01676043f, -0.01368124f, 0.00610630f, 
    0.01070127f, -0.03247592f, -0.04300863f, 0.01876008f, 0.00368559f, -0.02779603f, 0.00937045f, -0.01521484f, 
    -0.01610363f, -0.03656643f, 0.00253966f, -0.03583423f, -0.01578175f, -0.01969013f, 0.01094928f, -0.02286765f, 
    -0.02846894f, -0.00185368f, -0.03735219f, -0.04128253f, -0.02481818f, 0.01258194f, 0.00503327f, 0.00612930f, 
    -0.01406331f, -0.03122788f, -0.00832744f, 0.03565579f, -0.00834308f, 0.03196516f, 0.00641699f, 0.00763447f, 
    0.02450792f, -0.00887938f, -0.01932273f, -0.03717065f, 0.00125081f, -0.03541176f, -0.01055968f, -0.04063760f, 
    -0.00899536f, -0.03787652f, -0.02106920f, 0.02735157f, -0.02072705f, 0.01168169f, 0.01053695f, 0.00317634f, 
    -0.03525219f, -0.04023991f, -0.03199410f, -0.01352659f, -0.03737412f, -0.01178526f, 0.00091989f, -0.03338309f, 
    -0.03201122f, 0.02354230f, -0.02728329f, -0.03415172f, -0.02748396f, 0.03553536f, -0.01133758f, -0.02294505f, 
    0.00517039f, 0.01348949f, -0.03741872f, 0.01881928f, -0.00234154f, 0.00507328f, -0.01886392f, -0.03542478f, 
    0.01878701f, 0.02421102f, -0.03992794f, 0.02943550f, -0.00602951f, -0.02295231f, -0.02265262f, 0.00306114f, 
    0.01426081f, -0.02163528f, 0.01223901f, 0.00786066f, 0.00240695f, 0.00593454f, -0.00238283f, -0.04130133f, 
    -0.00525962f, 0.02766125f, -0.00069642f, -0.03536559f, -0.00881036f, -0.01055914f, -0.00409874f, 0.02259587f, 
    -0.04407355f, -0.02061648f, -0.03087978f, 0.00609848f, -0.03393968f, -0.03070442f, -0.04272749f, 0.02756607f, 
    -0.00876303f, -0.02913139f, 0.02983073f, -0.00333468f, -0.02826878f, -0.02711168f, -0.03460532f, 0.02931409f, 
    -0.01992793f, -0.01492047f, -0.01697282f, -0.03605688f, -0.01953103f, -0.00629725f, -0.01068656f, -0.02386680f, 
    -0.03496752f, 0.01356395f, -0.03925057f, 0.00906116f, -0.01384760f, -0.03568015f, 0.02348406f, -0.02691503f, 
    -0.02246248f, 0.00586466f, 0.02701697f, -0.03602989f, -0.01278362f, -0.02673076f, 0.00596058f, -0.03613340f, 
    -0.02082542f, -0.00156021f, 0.01887098f, -0.03468074f, -0.01043184f, -0.01798896f, -0.03921980f, 0.00934223f, 
    0.00200280f, -0.00186687f, -0.01787380f, -0.00248717f, -0.03661708f, -0.01162771f, -0.03283667f, -0.01983373f, 
    -0.00607760f, 0.02634418f, 0.01105026f, -0.01503926f, -0.04067969f, 0.00089209f, -0.04046691f, -0.00403908f, 
    0.00731157f, 0.01102363f, -0.02955794f, 0.04105700f, -0.02325838f, -0.03936936f, 0.01304877f, 0.00241879f, 
    0.00033516f, 0.01495959f, 0.01826018f, -0.03645058f, 0.01377657f, -0.00073259f, -0.03383020f, -0.03511198f, 
    0.02301925f, 0.01641504f, 0.00310749f, 0.03361733f, 0.02340199f, -0.03781377f, 0.01041023f, -0.01500429f, 
    0.01496746f, 0.01795347f, 0.02236126f, -0.00078838f, -0.03011266f, 0.02778071f, 0.01959959f, 0.02235388f, 
    0.01455086f, 0.00310562f, 0.01599956f, 0.00753550f, -0.03012420f, -0.04118263f, 0.02132308f, -0.01049707f, 
    -0.03254286f, 0.02543182f, 0.02696739f, 0.02621549f, -0.03107913f, 0.00574586f, 0.02002810f, -0.01236507f, 
    -0.02297839f, -0.01656847f, 0.01599251f, -0.01514939f, -0.04272546f, 0.02637951f, -0.00996190f, 0.00074560f, 
    0.00848263f, -0.01620912f, 0.01015076f, -0.02442171f, 0.01852293f, -0.01064249f, 0.00568124f, -0.01502463f, 
    -0.00669875f, 0.01869196f, 0.01044967f, -0.01090877f, 0.01541729f, 0.00901897f, -0.03799305f, -0.02480539f, 
    0.02166156f, -0.00543744f, -0.03547795f, 0.00758241f, 0.00313219f, -0.00687012f, 0.03175826f, -0.00638410f, 
    -0.01398934f, -0.01704601f, -0.02273375f, -0.00248271f, -0.02280699f, -0.00283957f, 0.02829656f, 0.01341162f, 
    -0.00307502f, -0.03101420f, 0.02105596f, -0.03741799f, -0.03934727f, 0.01808600f, 0.00602409f, 0.02284570f, 
    0.02190134f, -0.02767955f, 0.00262963f, -0.00342749f, 0.02596915f, -0.03907623f, 0.01085360f, -0.03727306f, 
    -0.03362879f, 0.02095401f, -0.02524679f, -0.01696564f, 0.01831377f, -0.02829583f, -0.02340934f, -0.03331457f, 
    0.01680957f, -0.03710031f, 0.00998435f, 0.00861042f, 0.00330561f, -0.02783213f, 0.01583735f, 0.01443367f, 
    0.02314416f, -0.00843113f, -0.01208359f, 0.01197616f, 0.02141894f, -0.03198386f, -0.03287619f, -0.00042106f, 
    -0.00447302f, -0.01086645f, -0.04205651f, 0.01192064f, -0.02888117f, 0.01229807f, -0.00978818f, -0.02363520f, 
    -0.03401475f, 0.02413950f, -0.02961322f, -0.02830265f, 0.02584149f, 0.00541199f, -0.02555565f, -0.02195606f, 
    0.02574370f, -0.02246907f, 0.02558940f, -0.03735703f, 0.02566707f, 0.01339837f, -0.03879661f, -0.03476617f, 
    -0.00219753f, 0.00224924f, 0.02902012f, -0.02319682f, -0.00745561f, -0.01281071f, 0.01891563f, 0.01853806f, 
    0.03303115f, -0.00795753f, 0.01022788f, 0.00181290f, -0.01296874f, -0.03714000f, 0.01433061f, 0.00251384f, 
    -0.01916899f, 0.01109668f, -0.02038063f, -0.03551579f, -0.02135529f, -0.02833240f, -0.02931718f, 0.01574074f, 
    -0.00971803f, 0.00980141f, 0.02040972f, 0.02852612f, -0.00176366f, 0.00922360f, 0.03446995f, -0.02594546f, 
    0.01744727f, 0.02150127f, -0.03938067f, -0.02535553f, 0.01752651f, -0.01204053f, 0.00388608f, -0.00458817f, 
    0.02896369f, -0.00741772f, 0.01406944f, 0.02065009f, -0.01008690f, 0.01582423f, 0.00498040f, -0.00208682f, 
    -0.01387359f, -0.00038438f, -0.01685945f, -0.02350148f, -0.02293312f, 0.02899773f, -0.01219478f, 0.02207394f, 
    -0.02493422f, -0.04341980f, 0.00203128f, -0.02441214f, -0.02354313f, -0.01155908f, -0.01420785f, -0.03642529f, 
    -0.02782776f, 0.01953257f, -0.00154077f, 0.00627520f, -0.03224997f, -0.02283374f, 0.00452076f, 0.00112748f, 
    -0.03337140f, -0.01845585f, -0.00037230f, -0.01117685f, -0.03467092f, -0.00251875f, -0.03159305f, 0.00884730f, 
    -0.00436551f, 0.02135470f, 0.02649690f, -0.00308742f, 0.00915219f, 0.01032714f, -0.00793297f, 0.01429869f, 
    -0.03391948f, -0.01863383f, -0.03377678f, 0.00550042f, -0.01151924f, -0.01004343f, 0.02155358f, -0.00744084f, 
    -0.02181309f, -0.03999763f, -0.00769837f, 0.01598703f, -0.02471316f, -0.01960758f, -0.00191954f, 0.02495199f, 
    -0.04106032f, -0.01942561f, -0.01140221f, 0.02589749f, 0.01195218f, -0.02827539f, 0.04128216f, 0.01027191f, 
    -0.03342314f, 0.02819236f, 0.01706398f, -0.02892337f, 0.01607640f, -0.03340701f, -0.02222997f, 0.00931053f, 
    0.01432363f, 0.01286780f, -0.02417281f, -0.02233353f, -0.04188976f, 0.02728826f, 0.00096719f, 0.02209366f, 
    0.02181649f, -0.03218177f, 0.02576106f, -0.03258792f, 0.02566055f, -0.00983251f, -0.02088493f, 0.00952435f, 
    0.00956976f, -0.03157439f, -0.00354804f, -0.00269165f, -0.00284611f, 0.00155506f, 0.02249203f, -0.04087673f, 
    0.02723946f, -0.01763849f, 0.03408401f, -0.01225445f, -0.03254405f, 0.01840947f, -0.01753147f, -0.04065594f, 
    -0.02941272f, 0.01389465f, -0.02448731f, -0.03970462f, -0.00437617f, 0.01399251f, 0.02054289f, 0.01363441f, 
    0.01634836f, 0.00664421f, 0.01008508f, -0.02510357f, -0.03115279f, -0.03955937f, -0.03948642f, 0.01531430f, 
    -0.00762794f, -0.00757036f, -0.02831659f, -0.00787620f, 0.02391735f, -0.03996538f, 0.01573236f, -0.01299600f, 
    -0.04242627f, 0.00652806f, -0.01454339f, -0.03967175f, -0.00021213f, -0.03059547f, -0.03784585f, 0.02665717f, 
    0.01764026f, -0.01535170f, 0.03036206f, 0.01196038f, -0.01184648f, -0.01831646f, -0.03610970f, -0.00440517f, 
    0.01369844f, -0.03385648f, 0.01664033f, -0.04160029f, -0.01773585f, -0.03781517f, -0.02814173f, 0.01617612f, 
    -0.02349345f, -0.01783608f, 0.00422425f, -0.01567355f, -0.01641743f, 0.01896553f, -0.00456524f, -0.00759461f, 
    0.01837275f, -0.02098171f, -0.03547695f, -0.02247927f, 0.01061096f, -0.01567280f, -0.04343405f, -0.03982703f, 
    0.00332437f, -0.01393953f, 0.00442887f, -0.01654131f, -0.04208105f, -0.02794662f, 0.02619955f, -0.02220797f, 
    0.01815730f, -0.00067580f, -0.00871072f, -0.00490905f, 0.02287309f, -0.02867074f, -0.02812710f, 0.00555005f, 
    -0.02025032f, -0.01185980f, -0.00334204f, -0.00747881f, -0.03048729f, 0.01378184f, 0.03703707f, -0.03666241f, 
    -0.02784100f, -0.03810586f, -0.03190920f, -0.01614765f, 0.00552498f, -0.00072888f, -0.00228122f, -0.03574410f, 
    -0.03160361f, -0.01899637f, -0.01459268f, -0.00158773f, 0.00776881f, 0.02998656f, -0.04138146f, -0.04072847f, 
    0.01813077f, -0.03844923f, -0.01772563f, -0.03029226f, 0.01886951f, 0.02889473f, -0.00704645f, -0.03192352f, 
    0.02835207f, -0.01281347f, -0.02391976f, -0.00078807f, -0.04105674f, -0.02555436f, -0.01138873f, -0.00197761f, 
    -0.03285109f, -0.01519011f, -0.00555423f, 0.00694814f, 0.00376473f, -0.01640216f, -0.01568742f, -0.01461809f, 
    -0.02327849f, 0.00766505f, -0.03086689f, -0.01090178f, 0.01035934f, -0.02339519f, -0.03078334f, -0.02534475f, 
    -0.00597154f, -0.00365710f, 0.00949271f, 0.00438931f, 0.01003897f, 0.03286121f, -0.03848292f, 0.01899860f, 
    0.01641350f, 0.01105262f, -0.01443849f, -0.01474158f, 0.02356632f, 0.01980340f, -0.01902064f, -0.02559846f, 
    0.00147745f, -0.00170798f, -0.00000087f, 0.01134497f, -0.02217485f, -0.03293792f, 0.02709552f, 0.01944220f, 
    0.02014652f, -0.01352857f, -0.01074585f, 0.02199294f, 0.01148483f, 0.03157112f, 0.03865525f, -0.00215819f, 
    -0.03051866f, 0.00778032f, -0.03930034f, 0.01309683f, -0.01984382f, 0.00064142f, 0.01771069f, -0.02888075f, 
    0.01645509f, 0.02508606f, 0.02344545f, 0.01778744f, 0.01558616f, -0.02134954f, -0.01734185f, 0.00606777f, 
    -0.04015546f, -0.01531774f, -0.00058712f, 0.01183061f, 0.01807263f, 0.01625679f, 0.00615185f, -0.02379966f, 
    -0.03997004f, -0.02278234f, 0.01400287f, 0.00458934f, -0.00814492f, -0.00247524f, 0.02695599f, -0.00900644f, 
    0.02598147f, 0.01309503f, -0.02335994f, 0.02797286f, 0.00087977f, 0.00486485f, -0.01238427f, -0.03718054f, 
    -0.02632379f, -0.01246490f, -0.02789924f, -0.02173591f, 0.00490903f, -0.01019635f, -0.01091832f, 0.00507718f, 
    0.03395644f, -0.02208952f, -0.02215308f, 0.00925748f, 0.02744244f, -0.03512500f, -0.00245875f, 0.00947384f, 
    -0.00105689f, 0.01690776f, -0.02071621f, -0.01391361f, 0.01817754f, -0.03586174f, -0.03612344f, -0.01422218f, 
    0.01979469f, -0.03803946f, 0.01997328f, 0.02746397f, 0.01235841f, -0.01855872f, 0.01071461f, 0.02227593f, 
    -0.01338409f, 0.01195115f, 0.02214367f, -0.00763530f, -0.01034438f, 0.01265915f, 0.00929650f, 0.02381614f, 
    -0.00875593f, -0.00406782f, 0.01305727f, 0.01303893f, -0.04220846f, -0.03589235f, -0.01016841f, -0.01202894f, 
    -0.04083624f, -0.01503958f, 0.03308425f, -0.02923930f, -0.00335938f, -0.04115701f, -0.02480588f, -0.02392042f, 
    0.01780367f, -0.02971294f, 0.02160630f, 0.02468511f, 0.02307781f, -0.01381871f, -0.03799255f, -0.02548418f, 
    -0.00061817f, 0.02027948f, -0.02804846f, 0.01809311f, 0.00560651f, -0.02713942f, -0.01487374f, 0.02745989f, 
    0.02767226f, -0.00159132f, 0.01127083f, -0.01698963f, -0.03846964f, -0.01030594f, 0.00826990f, -0.03614885f, 
    -0.02773797f, -0.00180973f, -0.04111955f, 0.01226921f, -0.04199759f, -0.04229170f, 0.00383051f, 0.01678051f, 
    -0.00167136f, 0.02139261f, -0.00298796f, -0.01706703f, 0.00481586f, 0.00223690f, -0.01508171f, -0.00736420f, 
    0.02406912f, 0.00248897f, 0.02011784f, 0.00966090f, -0.02935682f, 0.02611047f, -0.01112845f, -0.02321370f, 
    -0.00977293f, -0.02658659f, -0.00830547f, -0.01123695f, 0.00902761f, -0.02519260f, 0.02084995f, -0.01568903f, 
    -0.03214957f, -0.01916250f, -0.03267238f, -0.01991631f, -0.01084955f, -0.00992804f, 0.00308428f, -0.01293569f, 
    -0.01873780f, 0.00350300f, 0.01091663f, -0.01403461f, 0.03150977f, 0.01459464f, 0.01340054f, -0.00341230f, 
    -0.02329148f, -0.03139579f, -0.04146432f, -0.01626306f, -0.01931523f, 0.00282373f, -0.03109644f, -0.01052528f, 
    0.00560234f, 0.02676048f, -0.01784858f, 0.01262349f, -0.01674034f, -0.00497501f, 0.02328198f, -0.02391659f, 
    -0.03534446f, 0.02630210f, -0.00681057f, -0.03025301f, 0.01373969f, -0.02391478f, 0.01181411f, 0.01917841f, 
    0.00720654f, 0.02360662f, -0.01801123f, -0.03975745f, 0.02460157f, -0.01361160f, -0.00900159f, -0.01203256f, 
    -0.00612818f, 0.01576464f, -0.03200208f, 0.01711733f, 0.01240615f, -0.00746829f, -0.02872282f, 0.00724318f, 
    0.00262217f, -0.00810991f, -0.04004635f, -0.02925371f, -0.02120127f, -0.00380299f, 0.00028456f, -0.02522046f, 
    -0.02109653f, 0.02581818f, -0.02445844f, -0.00545760f, 0.00636252f, -0.01725088f, 0.01235128f, 0.00142179f, 
    -0.03219306f, 0.00669404f, 0.01323236f, -0.04202120f, -0.00660830f, -0.02383041f, -0.02764479f, 0.03824704f, 
    -0.00743357f, -0.01182889f, -0.03393997f, 0.02267068f, 0.03524373f, -0.00333095f, 0.01425390f, -0.00910415f, 
    0.00437133f, -0.00304179f, -0.03830733f, 0.00074922f, 0.01573975f, 0.02667628f, -0.02281588f, -0.02689732f, 
    -0.00895572f, -0.03791071f, 0.00808355f, 0.01433749f, -0.02599563f, -0.02696412f, -0.00656258f, 0.01545826f, 
    0.02418435f, -0.00561746f, -0.00452589f, -0.01545152f, -0.01482017f, 0.03334011f, 0.01449261f, 0.03541481f, 
    0.02958008f, -0.03760762f, -0.01844320f, -0.01518528f, -0.01265520f, 0.02545116f, 0.01534984f, 0.01874445f, 
    -0.04098934f, -0.01434312f, -0.03969145f, -0.00780985f, -0.01816922f, -0.00935872f, 0.01351817f, -0.00488299f, 
    0.02436513f, -0.01706024f, 0.02275499f, 0.01438355f, 0.01117683f, -0.01602892f, 0.00463559f, 0.00535425f, 
    -0.01417909f, -0.03584300f, -0.02728636f, -0.00374824f, -0.02864451f, 0.02497009f, 0.02724898f, -0.02370329f, 
    -0.01794644f, 0.01655456f, -0.02176332f, 0.02273369f, -0.02945011f, -0.01424418f, -0.00280210f, -0.01547093f, 
    -0.03610367f, 0.02562163f, -0.00330928f, 0.02375283f, 0.00035582f, 0.01586534f, -0.01193062f, -0.01596387f, 
    0.00696874f, 0.00633247f, 0.00477320f, -0.00971866f, -0.03661851f, -0.02128016f, -0.01756920f, 0.00855962f, 
    -0.00977932f, -0.01004910f, -0.01676265f, 0.02801925f, -0.01795228f, -0.02806623f, 0.01348372f, 0.04098982f, 
    -0.01985958f, 0.00870421f, -0.00651756f, 0.01960365f, -0.01373405f, 0.01340905f, 0.00651658f, 0.01291291f, 
    0.01769895f, 0.03313530f, 0.02708509f, -0.01816738f, 0.00437472f, 0.00596876f, -0.00015786f, 0.00109356f, 
    -0.02074007f, 0.01181293f, -0.03812827f, -0.02218035f, -0.03867752f, 0.02391701f, 0.02299715f, -0.03570428f, 
    -0.00357245f, -0.03806933f, 0.00989201f, -0.00171415f, -0.00066947f, -0.01816014f, 0.03971658f, 0.02534028f, 
    0.01059974f, 0.03487124f, -0.02035857f, 0.02953664f, -0.03928246f, -0.00736370f, -0.00607428f, 0.01595546f, 
    0.02853816f, 0.02618764f, 0.03023345f, -0.01473359f, -0.00299217f, 0.01439595f, -0.01613961f, -0.01905928f, 
    0.01415602f, -0.00020903f, 0.02531292f, 0.02641726f, -0.03545887f, -0.01482604f, 0.02824341f, -0.01017784f, 
    -0.00037374f, -0.01625452f, -0.03762951f, 0.00461310f, -0.03592035f, 0.00442385f, 0.02139040f, 0.02684307f, 
    -0.00615422f, 0.02063977f, -0.01077810f, -0.02772919f, 0.01271215f, 0.02747066f, -0.01997317f, -0.00866738f, 
    -0.02445940f, 0.02725081f, -0.02159106f, 0.03002007f, -0.03850222f, 0.03094052f, 0.01295193f, 0.00135539f, 
    -0.01760596f, -0.03761860f, 0.00232365f, 0.01558232f, 0.02112970f, 0.02124399f, 0.01158815f, 0.00220052f, 
    0.00902150f, -0.00415045f, -0.00573863f, -0.01687206f, -0.02630655f, -0.03088878f, -0.01332427f, 0.00279333f, 
    -0.02358253f, -0.00447245f, 0.01192283f, -0.00080552f, -0.00020572f, -0.03693708f, 0.00479809f, -0.04129235f, 
    0.01535807f, -0.01615940f, -0.03624795f, -0.01409601f, -0.00684964f, -0.04076712f, -0.02258774f, 0.02479963f, 
    0.01168009f, 0.03580984f, -0.01907631f, 0.00571906f, 0.02163430f, 0.00895220f, -0.03959905f, -0.00489790f, 
    0.01940341f, 0.01000546f, 0.02367886f, -0.00622303f, 0.00977837f, -0.03665351f, -0.00169657f, -0.02656428f, 
    -0.03248413f, -0.00203752f, -0.02262669f, -0.03237195f, 0.00741722f, 0.02941779f, -0.01198791f, 0.01345929f, 
    0.02283589f, 0.00880135f, 0.01986502f, 0.00920992f, -0.01179826f, -0.01238526f, 0.02678825f, 0.01190299f, 
    -0.01770288f, 0.00229832f, -0.01976631f, -0.03482072f, 0.01007797f, -0.01371690f, -0.03417658f, -0.02040526f, 
    -0.00719222f, 0.02658026f, -0.00183495f, -0.00780820f, -0.00422974f, 0.00730763f, 0.02301895f, 0.00709294f, 
    -0.00249204f, 0.02556934f, -0.02165359f, -0.02715281f, 0.00945491f, -0.02409883f, -0.02134422f, 0.01299784f, 
    -0.01681297f, 0.00662826f, 0.00075623f, 0.01987603f, 0.02156585f, -0.04173884f, 0.00636726f, -0.02782013f, 
    0.00340691f, -0.01314862f, -0.03816210f, -0.01605475f, 0.00479912f, -0.03556750f, -0.02893421f, -0.04027390f, 
    0.02933224f, -0.03166907f, 0.01255711f, 0.01340718f, 0.00877236f, -0.01350403f, 0.00205268f, -0.00267148f, 
    -0.03570007f, -0.03408168f, 0.01866079f, -0.02856995f, -0.03810795f, -0.01427797f, -0.02319185f, -0.01036565f, 
    -0.03733938f, 0.01291668f, 0.01771851f, 0.01245547f, -0.03686890f, 0.02888064f, -0.02195787f, 0.01992772f, 
    -0.04208706f, -0.02854120f, 0.01380049f, -0.01840715f, -0.02446453f, 0.01063652f, -0.00119812f, -0.01767611f, 
    -0.02893158f, -0.00601280f, -0.00876919f, -0.00880345f, 0.00259016f, 0.01018265f, 0.01515388f, -0.01847162f, 
    0.00344764f, 0.02712035f, -0.01002483f, -0.00610408f, 0.00238303f, 0.00250570f, 0.00261209f, -0.01082844f, 
    -0.02637244f, 0.00232304f, 0.04148472f, -0.02011636f, 0.00466473f, -0.04107761f, -0.03844082f, -0.03009138f, 
    0.02375654f, -0.02058823f, 0.00175841f, -0.02387861f, 0.03207796f, -0.00096159f, 0.01346759f, -0.01018247f, 
    0.00334663f, 0.03665383f, 0.01451474f, 0.03083139f, 0.03850278f, -0.01094775f, -0.02582325f, -0.01797827f, 
    0.00663388f, -0.03672051f, 0.00373022f, 0.01932691f, -0.01019673f, 0.02700677f, 0.02477844f, -0.03413206f, 
    -0.02413848f, 0.00425004f, -0.02800076f, 0.01340695f, 0.00664099f, 0.01737736f, -0.02902823f, 0.01916562f, 
    -0.01886478f, 0.00057980f, -0.01725693f, -0.01438073f, -0.02222335f, -0.03226666f, -0.01535621f, -0.01105198f, 
    -0.02620729f, -0.01397899f, -0.02121092f, 0.00626305f, -0.02159575f, -0.03838078f, -0.00786053f, -0.02759219f, 
    -0.02283789f, -0.00076633f, 0.01494356f, -0.01848746f, -0.03340062f, -0.03693685f, -0.02799348f, -0.00437807f, 
    -0.00702337f, 0.01620589f, 0.01516604f, -0.02660366f, 0.01346963f, 0.01791092f, -0.00626761f, 0.01728376f, 
    -0.01387733f, -0.03055302f, -0.00449507f, -0.03302880f, -0.01444541f, 0.02535170f, 0.01458705f, -0.01486844f, 
    -0.03169481f, 0.01904250f, 0.01410962f, -0.00990513f, -0.00291780f, 0.01919277f, -0.00736377f, -0.03798846f, 
    0.01672049f, -0.01572211f, 0.00867718f, 0.00058800f, -0.04006151f, -0.00765013f, -0.04067163f, -0.02023912f, 
    0.01418878f, -0.02040032f, -0.03050792f, -0.03472154f, -0.03603283f, -0.01825930f, 0.00647513f, -0.02029329f, 
    0.00430998f, 0.00140194f, 0.01268097f, 0.02347773f, 0.02744700f, -0.02097087f, 0.01498833f, 0.02629115f, 
    0.00518737f, 0.02022619f, 0.02244947f, -0.02171784f, 0.00412202f, 0.00047656f, -0.00569667f, -0.01594724f, 
    -0.02628366f, -0.00542832f, 0.00779776f, 0.02017787f, -0.02232397f, -0.00921995f, -0.02260364f, -0.01393181f, 
    0.01440007f, 0.01388572f, 0.02044251f, 0.00598645f, 0.00678499f, 0.02919071f, -0.01809150f, 0.03887003f, 
    0.01288043f, -0.01951906f, -0.03021251f, 0.02706878f, 0.02319032f, -0.02892758f, 0.02514838f, -0.00441330f, 
    -0.01735924f, 0.00589250f, -0.03316732f, -0.03361982f, -0.01560905f, 0.01598419f, -0.00459030f, 0.02768172f, 
    -0.02718340f, 0.00810570f, 0.02662828f, -0.00083667f, 0.01705464f, -0.03194093f, -0.03720354f, 0.01592258f, 
    -0.01216580f, 0.01893350f, 0.01349522f, -0.03520728f, -0.01455972f, -0.04173320f, 0.02610163f, -0.03465354f, 
    0.00010173f, -0.02798101f, 0.01232357f, -0.04053536f, 0.01217627f, -0.03062477f, 0.00667925f, -0.01681089f, 
    -0.01323442f, 0.00752348f, 0.00206994f, -0.00129541f, -0.04066030f, -0.01358531f, 0.01756280f, -0.02565302f, 
    0.02745331f, -0.00888366f, -0.03134950f, -0.01244479f, 0.01306365f, 0.01790558f, -0.01839263f, -0.02337451f, 
    -0.01249648f, -0.00502702f, -0.01471401f, 0.01231974f, -0.00164840f, -0.03046685f, 0.00793125f, -0.03150442f, 
    -0.01449350f, -0.02227154f, -0.01112061f, -0.02350859f, -0.02127053f, -0.00692926f, -0.01323111f, -0.02225819f, 
    -0.02070799f, 0.02437722f, -0.02956461f, 0.02442659f, -0.03634750f, 0.02359467f, -0.02807451f, 0.01149384f, 
    0.03222748f, 0.02751769f, 0.01099950f, 0.02094040f, -0.00252146f, -0.03371118f, -0.03908307f, -0.01151865f, 
    -0.02456319f, 0.01480606f, -0.03612269f, -0.01996273f, -0.03720512f, 0.01549374f, -0.03092351f, -0.04155676f, 
    -0.00894216f, 0.00387698f, 0.00237219f, -0.00722446f, 0.02347842f, -0.03721677f, -0.00524387f, -0.00840424f, 
    -0.02688975f, -0.03198117f, -0.01652563f, 0.01520521f, 0.01715826f, -0.00693934f, -0.03291164f, -0.00170628f, 
    -0.03242282f, 0.00237526f, -0.01294459f, 0.03669483f, -0.01473635f, -0.00316699f, -0.02645320f, -0.01393831f, 
    0.02825397f, 0.02867078f, -0.01566296f, -0.01884065f, 0.01741085f, -0.02746985f, 0.01523773f, 0.02395855f, 
    0.01717325f, 0.01495230f, -0.03324537f, 0.02390637f, -0.01160183f, 0.01169494f, 0.00671361f, 0.04185681f, 
    -0.02565715f, -0.00533620f, 0.00246829f, -0.00363850f, -0.01877648f, 0.01954081f, -0.03962822f, -0.03805948f, 
    0.01980721f, 0.01550513f, 0.03692967f, 0.01895139f, -0.01502465f, -0.01627334f, -0.00263124f, -0.02488117f, 
    -0.00161741f, -0.03544540f, 0.02163556f, 0.00567753f, 0.01620557f, 0.01494446f, -0.00667538f, -0.00673349f, 
    -0.02725536f, -0.03598603f, -0.02820268f, -0.00222169f, 0.00966872f, 0.04144859f, 0.01743584f, 0.02437779f, 
    0.00272787f, 0.01634327f, 0.00806639f, -0.00231223f, -0.02425302f, -0.03224088f, -0.01819704f, -0.01272846f, 
    -0.01691354f, -0.01388809f, -0.02599879f, -0.03401645f, -0.01126001f, 0.01570637f, -0.03576569f, -0.03438433f, 
    -0.04170610f, 0.01204069f, 0.01993499f, 0.01478712f, 0.00251211f, 0.00866795f, 0.01219370f, 0.01002226f, 
    -0.01548947f, 0.00087593f, 0.01444267f, 0.00871922f, 0.02403690f, 0.00702317f, -0.00865642f, -0.01923656f, 
    -0.01485144f, -0.02641103f, -0.01630842f, -0.03543974f, -0.03369825f, -0.02042220f, -0.00617075f, 0.00661027f, 
    -0.02784479f, -0.00823452f, -0.03629201f, -0.01032052f, -0.02540227f, 0.03276125f, -0.00625333f, 0.01712942f, 
    -0.00715881f, -0.01453942f, 0.02766468f, 0.01692563f, -0.00393513f, -0.02273021f, -0.01203655f, 0.02138157f, 
    0.29884371f, -0.13952066f, -0.00951670f, -0.08711345f, -0.12018347f, -0.00666948f, 0.01524449f, -0.00105385f, 
    0.12848131f, 0.02600669f, 0.02044773f, -0.10327539f, -0.07540313f, 0.08109634f, -0.16898581f, 0.25607818f, 
    0.00777027f, -0.03936294f, 0.01458973f, 0.01160706f, -0.05439923f, 0.03509457f, 0.04516776f, -0.00632775f, 
    0.07178675f, -0.05315372f, -0.01896364f, 0.10538057f, 0.04442529f, 0.00118141f, -0.00571075f, -0.13651082f, 
    -0.05596881f, -0.07475665f, -0.00310093f, 0.01891849f, 0.29782736f, -0.28527549f, 0.06902779f, -0.17589730f, 
    0.06682440f, 0.08993039f, -0.08260784f, -0.03427170f, 0.06734538f, 0.03013479f, 0.01182295f, 0.08039947f, 
    0.03042054f, 0.10877942f, 0.13377388f, 0.04975431f, 0.07538208f, -0.00299757f, 0.00461280f, -0.08612771f, 
    -0.01773450f, 0.04358088f, 0.01403234f, -0.02806833f, 0.00184069f, 0.02516577f, -0.15815656f, 0.08013234f, 
    0.12218928f, 0.02466989f, 0.01940300f, 0.05851863f, 0.03526331f, 0.05527833f, 0.07180079f, 0.12966609f, 
    -0.04444037f, 0.03428921f, -0.05112386f, -0.13335145f, -0.02482897f, -0.00424270f, -0.05021319f, -0.09859195f, 
    0.01796446f, 0.03736477f, 0.01625940f, 0.03812764f, -0.07988318f, -0.01019825f, -0.25203910f, -0.02556979f, 
    0.03821934f, 0.01799557f, -0.02517578f, -0.05252308f, -0.00904668f, 0.03334576f, 0.01981081f, 0.06373944f, 
    -0.24145287f, -0.01006347f, -0.09504429f, -0.13907425f, 0.01570925f, 0.05261667f, 0.00690952f, -0.01717235f, 
    0.02245687f, 0.04315206f, 0.08361526f, 0.01279549f, -0.02074702f, -0.03217416f, 0.02917296f, -0.02073038f, 
    -0.08072853f, -0.04256606f, -0.02794501f, -0.04392283f, -0.04568599f, -0.04702493f, 0.06694489f, 0.17333531f, 
    0.13529651f, 0.00539557f, -0.04910028f, 0.03312246f, 0.07592914f, 0.01517762f, -0.02428717f, -0.01618824f, 
    -0.04260364f, -0.00868245f, 0.06240566f, -0.09687728f, 0.15375181f, 0.08737240f, 0.08749463f, -0.10981532f, 
    -0.01836972f, 0.04184964f, 0.13192208f, 0.04748432f, -0.02491403f, 0.00410119f, -0.00080487f, -0.00744593f, 
    0.10005786f, 0.06650355f, 0.12236325f, 0.06770030f, 0.03478456f, -0.01806387f, 0.05518240f, -0.02628329f, 
    -0.04610413f, -0.15691836f, 0.05189330f, 0.06113933f, 0.19161628f, -0.06707694f, 0.01188277f, -0.00938870f, 
    -0.17101271f, 0.02609633f, 0.03234763f, -0.02095588f, -0.03003332f, 0.04042503f, 0.05136232f, -0.04646485f, 
    0.37087014f, -0.35373858f, 0.05258143f, -0.05487852f, 0.03438640f, 0.01080831f, 0.01586412f, 0.10452783f, 
    0.05242720f, 0.01036497f, -0.00049416f, 0.08265010f, 0.21928436f, 0.04625408f, 0.18111555f, -0.05084352f, 
    0.00172666f, 0.01730911f, 0.03058328f, -0.02343287f, -0.06567841f, 0.04188627f, -0.06237117f, -0.06398809f, 
    0.01267184f, 0.13055673f, 0.13291436f, 0.03275720f, 0.10222620f, 0.00295625f, -0.03847655f, -0.02121154f, 
    0.04543699f, 0.04111965f, 0.08720455f, 0.05942848f, 0.23465621f, -0.06178040f, -0.13629706f, -0.04691460f, 
    -0.04968179f, -0.04287262f, 0.05298808f, -0.09076947f, -0.03366734f, 0.09211350f, 0.00388614f, -0.09486894f, 
    0.11696310f, -0.09780734f, -0.16103669f, -0.09043817f, 0.08620095f, -0.02212338f, 0.04065818f, -0.06319356f, 
    0.00450548f, 0.03514175f, 0.01839294f, -0.05699360f, -0.03887954f, 0.01228112f, 0.03355173f, -0.07424922f, 
    0.02475176f, -0.01124243f, -0.06775457f, 0.08399567f, 0.03464218f, 0.04372822f, 0.06049936f, 0.11593285f, 
    0.01829426f, 0.13186321f, -0.04004622f, -0.18013301f, -0.17221016f, 0.11902782f, 0.02579747f, 0.05486824f, 
    -0.03312434f, -0.08364227f, 0.00513469f, -0.04922131f, -0.10678962f, 0.12235936f, 0.17251295f, 0.09823728f, 
    0.08106578f, 0.03191313f, 0.06397052f, 0.03882105f, -0.04555904f, 0.05200869f, -0.01847800f, 0.06238545f, 
    -0.16943227f, -0.02030987f, 0.13162138f, -0.04056713f, 0.01547184f, -0.06593793f, 0.09149163f, 0.04012610f, 
    -0.02686899f, -0.03187736f, 0.04738325f, -0.02691077f, -0.06065677f, -0.27224559f, -0.01997740f, 0.18065782f, 
    0.00017370f, 0.05818915f, -0.01260696f, -0.03252265f, -0.01811819f, -0.05524464f, 0.06842219f, 0.02719125f, 
    -0.22940609f, 0.25363055f, 0.06996864f, 0.27512962f, -0.03715895f, 0.00477405f, 0.05034198f, 0.13431336f, 
    -0.00693897f, -0.09049602f, 0.08003777f, -0.08654079f, 0.09158009f, 0.22608425f, 0.01159473f, 0.11348856f, 
    -0.03790081f, 0.01774636f, -0.00999495f, 0.02157350f, -0.07447742f, -0.05944431f, 0.00230794f, -0.03325700f, 
    -0.00916706f, 0.05164096f, 0.15329108f, 0.29962206f, 0.00835278f, 0.04174346f, 0.02901971f, 0.06708401f, 
    0.16638656f, 0.00658673f, 0.04493151f, -0.08468391f, 0.05044828f, 0.07824197f, -0.09984745f, 0.05479444f, 
    -0.00982232f, 0.03156878f, 0.00946544f, 0.02094360f, -0.03487058f, 0.15002567f, -0.00649940f, 0.12083417f, 
    -0.16114967f, 0.03926172f, 0.09719097f, 0.05886491f, -0.05046535f, 0.05852873f, -0.04509964f, 0.00198218f, 
    0.03655242f, -0.01726525f, 0.11551607f, 0.11419245f, 0.11080420f, 0.01032429f, 0.12807721f, 0.26991227f, 
    -0.04193910f, 0.04183439f, 0.03672059f, -0.03328201f, -0.10254065f, -0.02350723f, 0.03808008f, 0.12281276f, 
    0.20815495f, -0.01997736f, 0.05829380f, -0.03506424f, -0.11563017f, 0.03710325f, 0.17085055f, 0.05746485f, 
    -0.13986485f, -0.00350851f, 0.09349247f, 0.04169025f, 0.09259161f, -0.03778109f, 0.01161715f, -0.13790649f, 
    0.01616187f, 0.08220958f, 0.01513647f, -0.03935756f, 0.11720936f, -0.01067455f, 0.02622114f, 0.01845139f, 
    0.06330491f, 0.10213511f, 0.10670085f, -0.01724211f, 0.03793781f, 0.04375007f, 0.11497642f, -0.03711814f, 
    0.01988328f, 0.04632676f, 0.16124892f, -0.17051467f, -0.37244681f, -0.03158681f, 0.03927307f, 0.13718036f, 
    0.00685987f, 0.04683437f, 0.01662660f, 0.06729979f, 0.05866474f, 0.01720666f, 0.04571917f, 0.05897652f, 
    -0.13741411f, 0.12656434f, 0.15314506f, -0.09384040f, -0.01732182f, -0.09891054f, -0.03142693f, -0.08120295f, 
    -0.04711626f, 0.02654867f, -0.06471685f, -0.02586675f, 0.38165072f, -0.00198623f, 0.18895520f, 0.00758029f, 
    0.01033870f, 0.15518774f, -0.01353292f, -0.03524248f, 0.01532152f, -0.01692458f, 0.06928290f, 0.10187701f, 
    0.40566525f, 0.05472790f, 0.06736786f, -0.10954204f, 0.05042122f, 0.04216162f, 0.06014366f, -0.05929362f, 
    -0.01382281f, 0.03640073f, -0.00886134f, -0.04459953f, 0.06680348f, -0.16794063f, 0.04558561f, 0.04861915f, 
    -0.06935317f, -0.00120417f, 0.05702516f, 0.02118993f, -0.05491868f, -0.00620918f, 0.05615913f, 0.05971413f, 
    0.16468656f, 0.02943788f, 0.10289157f, -0.02025635f, -0.08512945f, -0.03880317f, 0.05337423f, 0.04880037f, 
    0.02077139f, -0.03711495f, 0.05603916f, 0.03057093f, -0.06163255f, -0.07647018f, 0.01913887f, -0.18203063f, 
    -0.03387911f, 0.05953202f, -0.08040913f, -0.06930633f, 0.09438621f, -0.03127822f, -0.09665592f, -0.02815288f, 
    -0.05291678f, 0.04115624f, -0.06480698f, 0.01717708f, -0.00777903f, -0.00500422f, -0.07182928f, 0.07523347f, 
    0.06274795f, 0.03450773f, 0.00331579f, -0.04996104f, -0.08754180f, -0.08141167f, 0.14303769f, 0.05464468f, 
    -0.03927962f, -0.00441144f, -0.00865096f, -0.09078859f, -0.01997935f, 0.11300624f, 0.02197227f, 0.06171624f, 
    0.26928437f, -0.24842338f, 0.06855765f, 0.15263546f, -0.07607835f, 0.01371535f, 0.10650909f, 0.03928168f, 
    -0.05197798f, 0.05539596f, -0.05130325f, 0.03201422f, -0.14189674f, 0.03515230f, -0.08475056f, -0.07109863f, 
    0.02969654f, 0.10138901f, 0.01235037f, -0.08134794f, 0.03216904f, -0.10863025f, -0.04479887f, -0.06911541f, 
    0.04078720f, 0.00566234f, 0.03076480f, -0.00004906f, -0.01483651f, -0.00580336f, -0.00531545f, 0.04627742f, 
    -0.05232248f, 0.01375916f, -0.00339075f, 0.01365653f, 0.02265185f, -0.12595013f, 0.15190759f, 0.02242115f, 
    0.00223179f, 0.00956163f, -0.03294131f, -0.07185847f, -0.05806522f, 0.04980660f, -0.00482686f, 0.08238389f, 
    0.17803156f, -0.05171598f, -0.04259668f, 0.05255435f, 0.12375049f, 0.02162081f, 0.05602276f, 0.00948287f, 
    0.06131527f, -0.01627180f, -0.01715167f, -0.06500300f, 0.08023588f, -0.08172575f, -0.10997087f, 0.02918345f, 
    0.12705596f, -0.04390197f, 0.00474397f, -0.04157280f, -0.01060385f, 0.03563225f, -0.07447820f, -0.01276748f, 
    -0.06611676f, -0.20375536f, 0.10628114f, -0.14239311f, -0.02251236f, 0.02687398f, 0.09801909f, -0.05807810f, 
    0.01601033f, -0.00017727f, -0.10098246f, -0.07662998f, 0.03339939f, 0.28401679f, 0.03463070f, 0.04101688f, 
    0.04264229f, -0.00714986f, -0.09289382f, -0.03176291f, -0.10123673f, -0.04281139f, -0.01458006f, -0.01040731f, 
    0.16587603f, 0.15373974f, -0.23746251f, 0.14593741f, 0.01875213f, 0.10455774f, 0.06415401f, 0.07382525f, 
    0.04086633f, -0.04440571f, -0.00515767f, 0.00881144f, 0.07851543f, 0.23848434f, -0.05178076f, 0.15137216f, 
    -0.08968507f, -0.04083947f, -0.11781266f, 0.01434201f, -0.03170544f, -0.03212764f, -0.00989065f, 0.08671229f, 
    -0.06557261f, 0.27064699f, -0.00403894f, 0.11294030f, 0.02182460f, 0.04117658f, -0.00380333f, 0.18094079f, 
    -0.02452614f, -0.04546868f, 0.05369589f, -0.11762173f, 0.02898883f, 0.07997368f, 0.14890049f, 0.10180598f, 
    0.00413424f, -0.04707479f, 0.04890072f, -0.05682298f, 0.00007109f, -0.04410116f, -0.04460679f, -0.07386937f, 
    0.11329576f, -0.16666880f, 0.14105491f, -0.22199252f, 0.00843356f, -0.01994584f, -0.03022184f, -0.06103130f, 
    -0.03711364f, 0.05751874f, 0.05048289f, 0.03936793f, 0.03493585f, 0.19991933f, 0.10349841f, 0.13262519f, 
    0.03918751f, 0.01294801f, 0.02044295f, 0.03083210f, 0.06992878f, 0.07302532f, 0.08770643f, 0.01834863f, 
    -0.06444159f, 0.11853081f, -0.07667874f, -0.13676448f, -0.11804413f, 0.01316163f, 0.04922082f, -0.05442918f, 
    -0.07499089f, 0.01505386f, -0.01161100f, 0.06180399f, 0.02444006f, -0.10218906f, 0.12736169f, 0.06459665f, 
    -0.02268212f, 0.01371784f, 0.03166992f, -0.07611971f, 0.03170531f, -0.01393272f, 0.04310562f, 0.16978151f, 
    0.06917609f, -0.16913059f, 0.04831196f, 0.02592472f, 0.07276820f, -0.02581626f, 0.07422793f, 0.03963116f, 
    0.01932342f, 0.04412664f, 0.07483902f, 0.02548685f, 0.16990343f, 0.05702121f, -0.09270332f, -0.15148750f, 
    0.01266350f, 0.05725177f, 0.12569262f, 0.07489549f, 0.00287339f, 0.03024583f, 0.04543353f, 0.03662138f, 
    -0.17153412f, -0.05555814f, 0.04437260f, -0.00970939f, -0.01573322f, 0.08569998f, 0.04332262f, 0.12633097f, 
    0.07369901f, 0.07003126f, -0.07737060f, 0.00653912f, -0.26113564f, 0.01533367f, 0.00663356f, -0.09216161f, 
    -0.10553084f, 0.04792545f, -0.05876458f, -0.00710581f, -0.07541247f, -0.00414208f, -0.02028203f, -0.13637531f, 
    -0.10658503f, 0.18514229f, 0.20235893f, -0.03045828f, 0.04904030f, -0.03600427f, 0.00244599f, -0.07825445f, 
    0.08918412f, 0.01108688f, -0.03953028f, -0.04699463f, -0.29274252f, 0.03837438f, -0.15442652f, -0.12460909f, 
    0.02517956f, 0.04014337f, -0.07118095f, -0.05895551f, -0.00635085f, 0.07358492f, -0.01761726f, -0.13281961f, 
    0.33700740f, 0.13814516f, -0.03757679f, -0.01819834f, 0.10400977f, 0.03854860f, -0.02318121f, 0.05411427f, 
    -0.11211680f, 0.07711382f, 0.03293788f, 0.17642397f, 0.30869704f, 0.08922543f, 0.11076546f, -0.06419694f, 
    -0.08326828f, -0.05267058f, 0.07591223f, 0.09089488f, -0.04435697f, 0.04404119f, -0.04590626f, 0.01709007f, 
    0.35934934f, 0.04642509f, 0.12611687f, -0.06832364f, -0.09517684f, 0.01583226f, 0.01370576f, 0.11020769f, 
    0.03372402f, 0.07364088f, 0.01970696f, 0.05504971f, 0.32659471f, 0.15344940f, -0.34723568f, 0.05121577f, 
    0.05398592f, 0.01348035f, -0.06423401f, -0.08685026f, -0.00817756f, -0.01537321f, 0.05162445f, 0.03292574f, 
    0.12370656f, 0.19022156f, -0.14701648f, 0.06303044f, 0.06741428f, 0.00071164f, 0.00015801f, -0.04413418f, 
    -0.01805926f, 0.06262890f, 0.00023119f, -0.01197220f, -0.10443099f, 0.08956508f, -0.03398204f, -0.05725991f, 
    0.05041592f, -0.03823173f, -0.00293753f, -0.11742353f, 0.01720279f, -0.08924598f, -0.05237249f, -0.05950674f, 
    -0.16172156f, -0.08120616f, -0.00130270f, -0.07104139f, 0.12579182f, 0.03506257f, 0.10688721f, 0.05524632f, 
    0.07714594f, -0.10607177f, -0.02210946f, -0.01887742f, -0.22923376f, 0.20414703f, -0.09184361f, -0.20174843f, 
    0.00881660f, 0.00737554f, 0.04578726f, 0.00065397f, 0.01126395f, 0.00740254f, -0.04689046f, 0.00535349f, 
    0.21257694f, 0.01330509f, -0.04091840f, -0.17717604f, 0.13859402f, 0.08467665f, 0.09022628f, -0.02604407f, 
    0.13989121f, 0.00453104f, -0.02482864f, 0.05588816f, -0.09807491f, -0.13146396f, -0.10743257f, 0.01644812f, 
    0.03303148f, 0.04371255f, 0.05020678f, -0.08877703f, 0.02826009f, 0.00995030f, 0.00235343f, -0.04811111f, 
    -0.00304978f, 0.08901452f, 0.04293467f, -0.16051789f, -0.01236122f, -0.02276240f, -0.00902089f, 0.07273836f, 
    0.08558662f, 0.07578144f, -0.06616976f, 0.02698581f, -0.04464150f, -0.08936288f, 0.01649202f, 0.16603489f, 
    0.00400012f, -0.00772403f, -0.06242345f, 0.07054731f, -0.03847410f, 0.02387024f, -0.00150422f, -0.00689751f, 
    0.08832420f, -0.03690000f, -0.08076718f, 0.01677990f, 0.00424717f, 0.03095043f, 0.01728340f, -0.08970508f, 
    0.01772323f, -0.01502014f, 0.11088787f, 0.02638041f, -0.17387748f, 0.04472150f, 0.07800325f, 0.16326974f, 
    0.04178479f, 0.05327909f, -0.01529292f, 0.01878538f, 0.10242435f, -0.00671779f, 0.00734790f, 0.07680524f, 
    -0.01766078f, 0.08068315f, -0.08592180f, 0.04105762f, -0.07663800f, 0.00182897f, 0.03524170f, -0.15643306f, 
    0.10658097f, -0.10288500f, -0.10983854f, -0.04029205f, 0.06897408f, -0.04302962f, -0.09737332f, 0.14216521f, 
    0.05440592f, 0.03038715f, 0.03265310f, 0.09856221f, 0.07136278f, -0.00885712f, 0.06613231f, 0.03091659f, 
    0.04387806f, -0.15809767f, -0.03929178f, 0.09500679f, 0.03068124f, 0.00990579f, -0.00619013f, 0.00936741f, 
    0.00051166f, 0.01885285f, 0.01596675f, 0.09935880f, 0.10545655f, 0.07465210f, 0.10962804f, -0.07503451f, 
    -0.00346783f, -0.05332308f, -0.00816869f, -0.02120548f, -0.01098601f, -0.04577175f, -0.05309934f, 0.06116087f, 
    0.05926534f, 0.00208962f, -0.17667873f, -0.04810969f, 0.08637094f, 0.02071231f, 0.03271521f, 0.01324670f, 
    0.02531036f, 0.03957878f, -0.00897802f, -0.01417333f, -0.12947552f, -0.03270894f, -0.13680914f, -0.16762018f, 
    0.17931733f, -0.06074860f, 0.01910843f, -0.06182022f, 0.01306701f, -0.00421905f, -0.01618866f, -0.11382975f, 
    -0.16397935f, -0.21832815f, 0.06849939f, 0.10729663f, 0.14208125f, -0.02907371f, -0.02748420f, 0.02615136f, 
    0.17094201f, -0.04376687f, 0.00691360f, 0.03257353f, 0.04753781f, 0.03863273f, -0.05405036f, 0.02947051f, 
    0.03282890f, -0.00873384f, -0.02303666f, -0.02853251f, 0.02846929f, -0.05861100f, -0.09864677f, -0.04282094f, 
    -0.10792278f, 0.10062769f, -0.03161462f, 0.16384660f, -0.07367596f, 0.02368288f, -0.00854882f, 0.05229871f, 
    0.00618359f, 0.14600663f, 0.02744267f, 0.04764643f, 0.23024860f, 0.19689550f, 0.00959216f, 0.01633914f, 
    -0.00074395f, -0.02401065f, -0.04486274f, 0.06711317f, 0.05580146f, 0.01096111f, -0.05256937f, -0.01789813f, 
    0.17938828f, -0.05240102f, 0.09671067f, -0.07170586f, 0.00360700f, -0.04073149f, 0.02966060f, -0.01245513f, 
    -0.07183708f, 0.00866113f, 0.01140363f, 0.01487390f, -0.14106297f, -0.08576847f, 0.08422186f, -0.19404706f, 
    0.04292757f, -0.02076557f, -0.04246334f, -0.07035278f, -0.04492722f, -0.03699364f, 0.02704280f, 0.01476291f, 
    -0.07314504f, -0.20500863f, -0.07046644f, -0.17335583f, -0.00012576f, -0.11164169f, -0.03846287f, -0.06054028f, 
    -0.03259663f, 0.05613089f, -0.03594659f, 0.08470526f, 0.36751086f, 0.09802666f, 0.02716479f, -0.02457254f, 
    -0.02951242f, -0.02188013f, -0.03444247f, -0.04895741f, 0.04153552f, -0.04314495f, 0.07268961f, -0.13055535f, 
    0.16381176f, -0.08767612f, 0.11301455f, -0.00156462f, -0.00024574f, 0.07816751f, 0.06233930f, 0.01373086f, 
    -0.00577571f, -0.07500865f, 0.00060328f, 0.03253947f, 0.25769567f, 0.15532199f, -0.13138604f, 0.08245936f, 
    0.01945469f, 0.02030646f, 0.08379090f, 0.00565070f, 0.06213492f, 0.03004178f, -0.00535567f, 0.08345747f, 
    0.31555131f, -0.11676241f, 0.08238675f, 0.06481986f, -0.00518771f, 0.04458256f, 0.06020624f, 0.07353617f, 
    0.02114766f, -0.10190696f, 0.08537707f, 0.09693680f, -0.17748058f, -0.01968219f, -0.05119095f, 0.01103165f, 
    0.03133613f, 0.01047998f, 0.02293266f, -0.02275456f, 0.05767210f, 0.02110974f, -0.02453867f, -0.05301094f, 
    -0.06972980f, -0.09897283f, -0.13422190f, 0.11890867f, 0.04279253f, -0.06234646f, -0.03380134f, -0.04452648f, 
    -0.06451137f, 0.00277904f, -0.11227031f, -0.01378514f, 0.11865667f, 0.10832243f, 0.09901197f, -0.06443608f, 
    0.07128181f, 0.07830569f, -0.00585448f, 0.02671377f, -0.01247063f, -0.01956396f, -0.08672158f, 0.00938367f, 
    0.03730555f, -0.02752895f, 0.04864272f, -0.14120364f, 0.04177930f, 0.01389710f, 0.05135137f, 0.07958039f, 
    0.06160633f, 0.08391406f, 0.01573543f, 0.02961242f, 0.27821994f, 0.11876290f, -0.02914546f, -0.11987057f, 
    -0.06884709f, 0.02500298f, 0.05326744f, -0.03724109f, 0.05204845f, -0.02672168f, 0.07713853f, 0.04927747f, 
    -0.14504573f, 0.05838105f, -0.18310367f, 0.03805728f, -0.05039889f, -0.02293784f, -0.02410141f, -0.01199733f, 
    0.02291058f, 0.02597024f, -0.07177749f, -0.00321335f, 0.20719039f, 0.01531545f, 0.02111560f, -0.00677263f, 
    -0.01472627f, 0.01198491f, 0.09094485f, 0.04076082f, 0.00667708f, -0.00035675f, -0.02624290f, -0.01806456f, 
    0.08645744f, -0.04877761f, -0.07149899f, 0.07758518f, -0.04500367f, 0.00662418f, 0.04185915f, 0.06496913f, 
    0.02671797f, -0.02245462f, 0.03576318f, -0.07733537f, 0.24159914f, -0.12600173f, 0.01236722f, 0.00003740f, 
    -0.08718895f, -0.08199214f, 0.02973190f, 0.06234274f, -0.08109656f, -0.06073530f, 0.08938570f, -0.00855511f, 
    0.01326356f, -0.03161154f, 0.00045751f, 0.08310939f, -0.03577731f, -0.01734980f, 0.07060201f, 0.04052523f, 
    -0.00122309f, -0.02945847f, -0.00257816f, -0.00099484f, 0.00350262f, 0.04421141f, -0.06756034f, -0.07353505f, 
    0.09482390f, 0.06875535f, -0.01596528f, 0.08769353f, 0.02555303f, -0.10600928f, -0.11693031f, -0.10989153f, 
    0.10397402f, 0.11670486f, -0.07711710f, 0.03493302f, -0.11319398f, -0.00874398f, -0.07708764f, 0.08842769f, 
    -0.02793183f, -0.03178823f, 0.02558635f, 0.08375004f, -0.02224683f, -0.04806066f, -0.05942684f, 0.06112575f, 
    -0.01340635f, -0.07471388f, -0.05562373f, 0.04030556f, 0.09256326f, 0.10978194f, 0.03820987f, 0.10183847f, 
    -0.03043764f, 0.00665727f, -0.08470073f, -0.03655958f, 0.06924260f, 0.05540369f, 0.03419516f, -0.04029908f, 
    -0.02548343f, -0.00253852f, 0.08011611f, -0.00210635f, 0.23198532f, 0.10533145f, 0.00358425f, 0.00956643f, 
    -0.10693994f, -0.03889535f, -0.03528583f, 0.04741133f, 0.12459736f, -0.05367684f, 0.03854200f, 0.00011964f, 
    -0.06368838f, -0.12865807f, 0.06557458f, -0.08488351f, -0.05607762f, -0.05692657f, -0.05052537f, -0.06025944f, 
    -0.04313850f, -0.03560090f, -0.02820193f, 0.03527106f, -0.15213175f, 0.07600674f, -0.19595732f, -0.07675063f, 
    -0.03156812f, 0.04317641f, -0.18641977f, 0.02274577f, -0.06720714f, 0.13778371f, 0.02728263f, 0.09203427f, 
    0.00385099f, 0.08216212f, -0.11168537f, 0.12635896f, 0.03652893f, 0.03555679f, -0.03960624f, 0.06730524f, 
    0.01622871f, 0.09362039f, 0.05708445f, 0.15517315f, -0.04681659f, 0.03209488f, 0.04502242f, -0.05193040f, 
    -0.08993241f, -0.08673575f, 0.11083649f, 0.02403787f, 0.03827714f, 0.04557550f, 0.02568969f, 0.05062334f, 
    -0.27948889f, 0.07178798f, 0.17486046f, -0.10596114f, -0.03453596f, -0.10583275f, 0.00083670f, -0.05709824f, 
    0.03307048f, -0.09692568f, 0.07141720f, 0.07146358f, -0.00340867f, -0.12924528f, 0.08760823f, -0.21023895f, 
    0.02951355f, -0.05725610f, 0.02120164f, -0.07791477f, 0.03145268f, 0.06868788f, 0.01060641f, -0.03636305f, 
    0.01216147f, -0.21657678f, 0.09735553f, -0.02123305f, -0.06365866f, -0.06662455f, 0.06872467f, -0.04756482f, 
    0.02855629f, 0.00353335f, -0.00295609f, 0.04757178f, 0.09685043f, -0.08959813f, -0.11726568f, 0.00086539f, 
    -0.02626492f, 0.03575765f, -0.04736617f, -0.01664403f, 0.07480963f, 0.06629455f, 0.08714290f, 0.00448355f, 
    -0.12474918f, 0.07178650f, -0.10993870f, 0.25696349f, -0.08393685f, 0.07520434f, 0.01004103f, 0.06808131f, 
    0.08797450f, -0.00843532f, 0.02999029f, -0.09073905f, 0.03324660f, -0.09666779f, -0.10821553f, 0.03483161f, 
    -0.02318682f, 0.00718908f, -0.00719294f, -0.10283665f, -0.04269652f, -0.01663633f, -0.00676525f, -0.06005800f, 
    -0.11770546f, -0.15153329f, 0.02380375f, 0.01284346f, 0.12363963f, 0.06003798f, -0.12355187f, 0.05390096f, 
    0.13934456f, 0.00904219f, 0.02475479f, -0.06270684f, 0.16280134f, 0.10183559f, -0.02596020f, 0.10735623f, 
    0.04404149f, 0.11897229f, -0.06389762f, 0.05244595f, 0.04431670f, -0.04377793f, -0.10912845f, 0.04691753f, 
    -0.17568046f, -0.08259354f, -0.08775526f, -0.00716929f, -0.04292950f, 0.01108354f, 0.03991571f, 0.09069796f, 
    0.02090575f, 0.00076937f, -0.02463221f, -0.09326193f, -0.23984218f, 0.09375104f, 0.06868259f, 0.07560372f, 
    0.01410346f, 0.11804723f, 0.03511809f, -0.02220792f, 0.02236517f, 0.09538890f, -0.03760777f, -0.08953807f, 
    -0.11417198f, -0.01469372f, 0.08871475f, -0.16260940f, 0.04352257f, 0.07393848f, 0.03685175f, -0.06600661f, 
    -0.14065818f, -0.01950836f, 0.00159072f, 0.04037757f, 0.13900559f, 0.03594604f, -0.00873852f, 0.08692384f, 
    -0.01241172f, 0.00840389f, 0.03263627f, -0.06329352f, 0.02193242f, 0.08443015f, 0.07541756f, 0.12470347f, 
    0.05677018f, 0.01077850f, -0.09671923f, 0.03612004f, 0.02682089f, -0.06116827f, -0.02353563f, -0.04431161f, 
    -0.02700494f, -0.00057317f, -0.01802896f, 0.03131329f, 0.11354822f, -0.11644391f, 0.14757688f, -0.23042205f, 
    0.07902896f, 0.02556981f, 0.11447605f, -0.05748135f, 0.07174622f, 0.05521894f, 0.05372223f, 0.02151153f, 
    -0.24827935f, 0.00945711f, -0.03686553f, -0.03109658f, 0.03704409f, 0.01328650f, -0.02026931f, 0.10402696f, 
    0.00538262f, -0.00364055f, -0.00764132f, 0.00981574f, -0.29805207f, -0.17959724f, -0.14633167f, -0.07690219f, 
    -0.03171284f, -0.00357915f, -0.04352030f, -0.05693156f, 0.07629072f, 0.04508706f, 0.07270478f, -0.03523223f, 
    -0.33989304f, -0.14751706f, -0.22366172f, -0.00372028f, 0.08580473f, -0.04357791f, 0.01664955f, -0.06701183f, 
    0.02788498f, 0.04284070f, 0.04207224f, -0.00954230f, -0.10913227f, 0.15786894f, 0.04898053f, -0.02574293f, 
    -0.07557604f, 0.00383510f, 0.06501423f, 0.18977910f, -0.02536821f, 0.00309420f, 0.10564347f, -0.01960567f, 
    -0.03497065f, -0.08936051f, -0.02308641f, -0.17685646f, -0.04230748f, -0.03054643f, -0.03060052f, 0.07756359f, 
    0.03418081f, -0.01542187f, 0.01649468f, 0.10372955f, 0.18654580f, -0.09849778f, 0.11626992f, 0.23078065f, 
    -0.02902390f, 0.07059109f, 0.02773275f, 0.03318252f, -0.00119846f, 0.04650084f, -0.03596536f, 0.09047461f, 
    0.24838430f, -0.02841752f, -0.05192645f, 0.16777383f, -0.09057564f, 0.01208821f, 0.03688235f, 0.03699806f, 
    0.01802311f, 0.00357005f, 0.04326213f, -0.04088797f, 0.05881909f, -0.19545105f, 0.17138734f, 0.34306514f, 
    0.02731289f, -0.02866971f, -0.00894425f, -0.06402601f, 0.04893870f, 0.09835607f, 0.07164675f, 0.01999584f, 
    0.13610484f, -0.02408664f, 0.02279885f, 0.15292494f, -0.05599261f, -0.09888589f, -0.04304256f, 0.05718467f, 
    -0.08829322f, 0.02183906f, -0.03798817f, 0.06696732f, 0.04960359f, 0.14313634f, 0.04731436f, 0.10058036f, 
    0.06948345f, 0.04344113f, -0.09412707f, 0.06761046f, 0.00682409f, 0.04394832f, -0.06446373f, 0.01345376f, 
    0.16331090f, -0.11227444f, -0.01186028f, 0.23217459f, -0.03905730f, 0.03933433f, 0.05110403f, -0.02279740f, 
    -0.03713612f, 0.04207665f, 0.05912831f, 0.05167578f, -0.20536840f, 0.02106683f, 0.04374959f, -0.08758589f, 
    0.00532408f, -0.03504559f, 0.08308051f, -0.01031278f, 0.03465453f, -0.01401765f, 0.03134202f, 0.03389750f, 
    -0.06118910f, -0.07229319f, -0.01523716f, -0.06178975f, 0.04782895f, -0.10214510f, -0.01917811f, 0.13200431f, 
    0.01781277f, 0.05664418f, -0.08945139f, 0.01631608f, 0.05700343f, 0.05649692f, -0.09794935f, -0.11555379f, 
    0.04560894f, 0.00017351f, 0.00609741f, 0.04100213f, -0.04698027f, -0.00290312f, 0.06810059f, 0.05145430f, 
    -0.12162918f, 0.13416520f, -0.03886198f, 0.06647912f, 0.08153765f, 0.06296904f, -0.05875210f, 0.05155996f, 
    -0.01290995f, 0.04441285f, 0.08004840f, 0.01572409f, -0.28525102f, 0.06419241f, -0.05972306f, -0.05794338f, 
    -0.02007120f, 0.06528237f, 0.02827642f, -0.08494446f, -0.01363894f, 0.01088552f, -0.03617743f, 0.06590913f, 
    -0.06069087f, 0.01561565f, 0.02563692f, -0.18208121f, 0.01312830f, 0.05109133f, -0.02456146f, -0.05119315f, 
    0.05877320f, 0.01829046f, -0.05598462f, -0.01710956f, -0.03242944f, 0.15310328f, -0.19961594f, 0.06239117f, 
    -0.00746942f, 0.05491663f, 0.07943930f, 0.13038981f, 0.05748346f, 0.02280357f, 0.10234579f, 0.11859037f, 
    0.10334025f, -0.00458442f, 0.12429035f, 0.10385013f, -0.08651412f, 0.04450407f, -0.06642233f, 0.03626459f, 
    0.04754345f, 0.02345783f, 0.03964066f, -0.00113072f, 0.18629634f, -0.07623205f, 0.04752397f, 0.25516486f, 
    -0.10041435f, 0.08406410f, 0.05398910f, 0.05473862f, -0.05744325f, 0.04663505f, 0.05950335f, 0.07602528f, 
    -0.04226534f, 0.14463629f, -0.09538180f, -0.01890607f, 0.05112685f, -0.01401369f, 0.09469425f, -0.03744172f, 
    0.00612373f, 0.04241212f, 0.00987549f, 0.01658829f, 0.00072634f, 0.01468718f, 0.04013640f, -0.10280327f, 
    0.01927402f, 0.01422463f, -0.04247060f, 0.00494786f, 0.00212397f, -0.05552371f, 0.04107755f, 0.05058424f, 
    0.08801509f, 0.04204289f, 0.12453969f, -0.10014483f, 0.08610111f, 0.05771654f, 0.01679371f, -0.00962261f, 
    0.03532574f, 0.01109272f, 0.00674832f, 0.02161847f, -0.13466573f, -0.06489387f, -0.15038100f, -0.07862115f, 
    0.07486746f, 0.04914822f, 0.05836980f, 0.02597292f, -0.02631048f, 0.04327707f, 0.00931157f, 0.01154717f, 
    -0.02562752f, -0.14961194f, -0.07104872f, 0.04008649f, 0.04492031f, 0.00940673f, -0.01441325f, -0.00988385f, 
    0.08911557f, -0.00062097f, -0.05263219f, 0.01857951f, -0.12240084f, -0.10389961f, 0.00513204f, 0.13737741f, 
    0.03820547f, 0.08285487f, -0.02303110f, 0.01402827f, 0.11747158f, 0.06029235f, -0.01384273f, -0.01840271f, 
    -0.20114754f, 0.08419564f, 0.12683181f, -0.03576489f, 0.06715325f, 0.10338186f, 0.08011223f, -0.00412852f, 
    0.00166495f, -0.03046575f, 0.04945884f, -0.00589543f, -0.45523492f, -0.18953776f, -0.14158963f, -0.03367260f, 
    -0.04133717f, 0.01565898f, -0.00416534f, -0.02071765f, -0.02427625f, 0.01467374f, 0.00962447f, 0.04518435f, 
    0.03204468f, -0.12165105f, -0.13755542f, 0.00771319f, 0.06606359f, -0.07191405f, -0.05751722f, -0.04469314f, 
    0.08624475f, 0.14096126f, -0.01019737f, 0.00805877f, -0.16671145f, -0.16072081f, 0.03168955f, -0.12450174f, 
    -0.01055428f, 0.04217962f, 0.00091456f, 0.08835991f, 0.07886057f, -0.01395186f, 0.02661715f, -0.13716651f, 
    -0.28292492f, 0.21137929f, -0.09114828f, -0.00528493f, 0.13143675f, -0.05144180f, -0.04194760f, -0.07316422f, 
    0.02169627f, -0.01795126f, -0.05702254f, -0.02601726f, -0.07538278f, -0.04247786f, 0.18257666f, -0.05382451f, 
    0.08038503f, 0.05514862f, -0.01822828f, 0.03676818f, -0.00608990f, 0.00167774f, 0.11684017f, -0.00895657f, 
    -0.07132740f, 0.11089078f, 0.24176763f, -0.24472046f, 0.04545198f, 0.07627362f, -0.00925617f, -0.00274997f, 
    0.05386686f, -0.02205881f, 0.04635758f, 0.06876956f, 0.06034126f, -0.10455450f, -0.10980362f, 0.04839605f, 
    -0.02590485f, -0.06773582f, -0.01626041f, 0.02073127f, 0.05960724f, 0.04764328f, 0.07013676f, -0.03778907f, 
    0.18221994f, 0.01012667f, -0.22063941f, 0.20362857f, 0.00465858f, 0.07171181f, 0.02535753f, -0.00546258f, 
    0.01553430f, 0.09199557f, 0.06186455f, 0.08569340f, -0.22536771f, -0.11197998f, -0.22466646f, 0.10594828f, 
    0.07963279f, -0.05829707f, -0.06653714f, 0.12851416f, -0.03298559f, 0.04119976f, -0.02107529f, -0.10761396f, 
    -0.05524645f, 0.00254670f, 0.10227493f, -0.07455905f, 0.12958778f, 0.02531154f, -0.02061215f, 0.07780664f, 
    0.00163564f, -0.01629733f, 0.08189745f, 0.07808486f, -0.16998833f, -0.05232660f, -0.00700271f, -0.04434374f, 
    0.05954602f, 0.01402683f, -0.08278029f, 0.04272361f, 0.08546694f, -0.08677454f, -0.12001103f, 0.06117141f, 
    -0.28885400f, -0.01690819f, 0.06582729f, -0.11352383f, 0.10831874f, 0.04051082f, 0.02376678f, -0.04909748f, 
    -0.01843220f, 0.00227363f, -0.06975868f, 0.17249168f, 0.04625984f, 0.21040861f, -0.02583468f, 0.01751623f, 
    0.09973643f, 0.00129656f, -0.06501871f, 0.02967041f, 0.06111654f, 0.06687826f, 0.07652224f, 0.09314730f, 
    -0.04598081f, 0.03075160f, 0.03398544f, -0.01093908f, 0.15335755f, -0.02183878f, 0.01562070f, -0.09996356f, 
    0.11295197f, 0.19665559f, -0.05852151f, 0.05699845f, 0.21519122f, -0.02030346f, -0.13234243f, -0.00694367f, 
    -0.09382618f, -0.05894284f, 0.10157561f, 0.03473016f, -0.01802314f, 0.02227115f, 0.06547687f, 0.07887129f, 
    -0.09291456f, 0.16658635f, -0.09006395f, -0.12587740f, 0.05587345f, 0.02297053f, 0.07677764f, -0.07138386f, 
    0.06066779f, 0.00520853f, 0.04864254f, -0.05643072f, 0.10626957f, 0.03325471f, 0.12922616f, -0.02369593f, 
    0.03617517f, 0.01859712f, 0.10787379f, 0.05420451f, -0.07416489f, 0.03131298f, 0.02769483f, -0.01296518f, 
    0.02851902f, -0.00285944f, -0.10050084f, 0.05334904f, 0.10498863f, 0.02782843f, -0.04754497f, 0.01715163f, 
    0.06299441f, 0.05660643f, 0.01638545f, -0.05522921f, -0.18992382f, 0.00183139f, -0.15871200f, 0.07041517f, 
    0.00469638f, 0.05811914f, 0.03357836f, 0.08138079f, -0.00650724f, 0.01756963f, -0.01918964f, -0.03146800f, 
    -0.11628909f, 0.11962422f, 0.21252245f, 0.03815382f, 0.07408049f, 0.00998361f, 0.02371710f, 0.01128366f, 
    0.09188896f, -0.02937735f, 0.04621610f, 0.07249542f, 0.11038400f, -0.22599849f, 0.18915214f, 0.21269566f, 
    -0.00963528f, 0.05535424f, 0.11546823f, -0.02240422f, 0.14381424f, -0.10380850f, 0.02623371f, -0.02968187f, 
    0.02738892f, 0.15824166f, 0.12683183f, -0.08686665f, 0.03011187f, 0.00159863f, -0.00671611f, 0.02958887f, 
    0.00472498f, -0.05813381f, 0.08447320f, 0.02435893f, 0.09389675f, -0.12831220f, 0.01114092f, 0.10485549f, 
    0.12859385f, 0.02902804f, -0.01006436f, 0.03904350f, 0.05140626f, 0.08854131f, 0.02373418f, -0.01321023f, 
    0.13557217f, -0.08971836f, 0.03645626f, 0.03939364f, 0.11166582f, 0.06679437f, 0.07152706f, -0.02951116f, 
    0.04584654f, 0.10058073f, -0.00822590f, -0.04591359f, -0.14663735f, 0.08403043f, 0.02207675f, 0.01922623f, 
    0.11855341f, 0.08649394f, 0.00496442f, 0.03817957f, 0.01994226f, -0.03453203f, -0.00467944f, 0.01566995f, 
    0.04201047f, 0.01564312f, 0.00969917f, -0.03092983f, 0.06372880f, 0.03174251f, -0.01743601f, -0.04249403f, 
    0.08847772f, 0.07569981f, 0.00845502f, -0.01949083f, -0.13399449f, -0.02388074f, -0.01836785f, -0.07730904f, 
    0.05946016f, 0.05049446f, 0.03093595f, 0.05475331f, -0.01790739f, 0.05613155f, -0.05527587f, 0.05658727f, 
    0.13316230f, 0.08087573f, -0.15082231f, -0.03812036f, 0.11043936f, -0.08866788f, -0.00326418f, -0.05052449f, 
    -0.06203689f, 0.00144260f, 0.05902918f, 0.09861963f, -0.06089034f, 0.03758761f, 0.02668006f, -0.16383247f, 
    0.07392831f, 0.01163726f, -0.01845468f, -0.00798716f, 0.02291665f, -0.08562548f, -0.08705693f, 0.05832883f, 
    0.16614020f, 0.00833053f, -0.06885846f, 0.13567491f, 0.05944246f, -0.01231938f, 0.12824813f, 0.02565330f, 
    -0.00119704f, 0.01294074f, -0.02481873f, -0.00256037f, -0.08451574f, -0.11715259f, -0.19789369f, -0.13094082f, 
    0.00374868f, -0.06067105f, 0.14084305f, 0.02945643f, -0.03588188f, -0.01893481f, 0.13025612f, -0.00918414f, 
    0.01366211f, 0.00332571f, 0.04453425f, 0.08666652f, 0.04553258f, 0.00038285f, -0.06973630f, -0.09709676f, 
    0.02082301f, 0.02008217f, -0.05600381f, 0.10334122f, 0.14364126f, -0.19908963f, -0.07614176f, 0.00784007f, 
    -0.01501167f, -0.17881101f, 0.00527500f, 0.06390791f, 0.10518200f, 0.11344240f, 0.09463979f, 0.12208904f, 
    0.23620062f, 0.00550106f, -0.08586149f, 0.11857565f, 0.04469327f, -0.08444236f, -0.00274486f, 0.04903263f, 
    0.08484045f, -0.02011413f, 0.08848546f, -0.00283872f, 0.15560973f, 0.02027854f, 0.04692809f, -0.01704539f, 
    0.16982405f, -0.01579821f, -0.02623219f, 0.07031786f, 0.11848883f, -0.00148867f, -0.01042230f, 0.03417406f, 
    -0.04245472f, 0.06992041f, 0.05153414f, -0.23259117f, 0.00100881f, 0.02381579f, 0.05356716f, -0.00203274f, 
    -0.03367690f, 0.01841839f, 0.12032769f, 0.10258464f, 0.09801544f, 0.09252360f, -0.00179400f, 0.23783162f, 
    0.03101335f, -0.01472204f, -0.01473527f, 0.02462637f, -0.03358115f, 0.01388882f, -0.03341478f, 0.09416026f, 
    0.11996005f, 0.05934959f, 0.10225667f, -0.01055811f, 0.03322510f, 0.05762632f, 0.12314048f, 0.00294752f, 
    0.07834186f, -0.04614105f, 0.03241286f, -0.11515421f, 0.18981053f, 0.13965473f, -0.06979711f, 0.28268555f, 
    -0.03222273f, 0.05465556f, -0.03196041f, 0.01620092f, -0.01210350f, -0.02371662f, 0.04681302f, 0.06923397f, 
    0.18898460f, 0.01380498f, 0.00149205f, 0.07109770f, 0.02044941f, 0.11913747f, 0.09983924f, 0.02420398f, 
    -0.01330019f, -0.03104043f, 0.11868850f, -0.07225651f, 0.34400025f, -0.07517553f, 0.17350957f, 0.07428853f, 
    0.01405637f, -0.01256916f, 0.05030541f, 0.02755917f, 0.01984832f, 0.03499655f, -0.05641355f, 0.09223893f, 
    -0.00508355f, 0.02559195f, 0.01030942f, -0.05635339f, 0.02557385f, 0.00050406f, -0.00916349f, -0.02528914f, 
    -0.06343585f, -0.09891854f, 0.01637003f, -0.02706081f, -0.09437206f, -0.07709413f, -0.05529378f, 0.33124352f, 
    0.07623248f, 0.06468540f, 0.12099986f, -0.06767476f, -0.00944387f, -0.03974073f, 0.01203794f, -0.00835210f, 
    0.08024359f, 0.03151283f, -0.01015068f, 0.10025439f, 0.03055965f, 0.04755634f, 0.00195463f, 0.02209756f, 
    -0.10240158f, 0.11502051f, 0.14269939f, 0.03180096f, -0.29803780f, -0.06502326f, -0.13243999f, 0.30140215f, 
    0.08468486f, 0.00475723f, 0.06710543f, -0.01249376f, 0.04837556f, -0.00754305f, -0.02866356f, -0.07882323f, 
    0.15877770f, -0.05848203f, -0.03445258f, 0.08022428f, -0.02157873f, 0.03736823f, 0.01715747f, 0.07139076f, 
    -0.05907074f, -0.01971390f, -0.02823289f, -0.01056607f, 0.07657562f, 0.22083941f, -0.03455373f, 0.05862630f, 
    0.01681602f, 0.01009991f, -0.03963613f, -0.10942844f, -0.00228282f, 0.05943368f, 0.08709630f, 0.09268884f, 
    0.06137764f, 0.02496887f, -0.07447281f, 0.08796048f, 0.00658204f, 0.04239165f, -0.00017913f, -0.01992841f, 
    0.02913718f, -0.04014925f, 0.06698214f, -0.02499668f, 0.03601814f, 0.20805889f, 0.06616436f, -0.25199944f, 
    0.03043933f, 0.04360667f, 0.07664735f, -0.01037444f, 0.00883481f, 0.02227374f, -0.02140795f, -0.06105005f, 
    -0.06023529f, 0.04490113f, -0.03085238f, -0.19548883f, -0.02874348f, -0.08774494f, -0.07532839f, 0.07402485f, 
    -0.10434105f, -0.03033137f, 0.16931105f, -0.04062669f, -0.06410987f, -0.15143333f, 0.04725390f, -0.15484436f, 
    -0.06570268f, -0.03347950f, 0.02166273f, 0.06233099f, -0.04993103f, 0.02371840f, 0.02106698f, -0.04787378f, 
    0.32939684f, -0.14000736f, 0.20941241f, -0.22954510f, 0.11002612f, 0.08335499f, 0.04991273f, 0.00192231f, 
    -0.00844826f, -0.01522739f, 0.08331646f, 0.11065692f, -0.12902756f, 0.11660898f, 0.06474771f, -0.13351783f, 
    -0.03879858f, 0.08183763f, 0.04336503f, -0.04426348f, -0.04342161f, 0.06029948f, 0.06415779f, -0.15688145f, 
    -0.08299532f, 0.09324156f, 0.06385108f, -0.20484908f, 0.08518690f, 0.02070925f, -0.00802574f, -0.01358815f, 
    0.02762995f, 0.08766314f, -0.05586021f, 0.04696754f, 0.06017276f, 0.05932634f, 0.04508489f, 0.10243083f, 
    -0.05657236f, -0.05827972f, -0.03098681f, 0.12271802f, 0.03961660f, -0.05802636f, 0.10122439f, 0.02319565f, 
    0.20654429f, -0.15679839f, -0.03650053f, 0.15455391f, 0.01643271f, 0.02777898f, 0.00957357f, 0.02010014f, 
    0.00162443f, 0.01329624f, 0.03327760f, 0.02756592f, 0.09678270f, 0.08200140f, 0.05106392f, 0.27960336f, 
    -0.01638172f, 0.02752225f, -0.03430661f, 0.02350127f, -0.02695889f, 0.09211572f, -0.05476706f, 0.11994555f, 
    -0.14757606f, 0.00956327f, -0.14770186f, 0.09684956f, 0.01166437f, 0.00254762f, 0.04760809f, 0.00509853f, 
    0.12435102f, -0.01012517f, 0.04210400f, 0.02861249f, -0.15090296f, 0.11655446f, 0.04771965f, -0.12768586f, 
    0.04998914f, 0.11888480f, -0.01948636f, 0.04618937f, -0.01053777f, 0.08306286f, 0.09871821f, 0.06629055f, 
    -0.04704562f, 0.08922272f, 0.14421073f, -0.25943443f, 0.10432538f, -0.06570105f, -0.07200737f, -0.00621496f, 
    0.00091927f, 0.07279184f, 0.01861653f, 0.02441923f, -0.04107067f, -0.07022688f, -0.01107191f, 0.09774260f, 
    -0.03456792f, 0.04130803f, -0.01617311f, -0.07892325f, -0.09562609f, -0.03096564f, 0.06339923f, 0.10346340f, 
    -0.20275827f, 0.20862408f, -0.06746245f, 0.34699482f, -0.01725651f, -0.03510836f, 0.05023593f, -0.03974076f, 
    0.08012678f, 0.00388350f, 0.09357989f, 0.01255177f, -0.35733786f, -0.03120131f, -0.00892588f, -0.03154682f, 
    -0.09401614f, 0.07585707f, 0.02153208f, 0.02398007f, 0.04984299f, -0.03186103f, -0.01852674f, -0.06993144f, 
    -0.18882145f, 0.28899461f, 0.22431822f, 0.14551178f, -0.12903960f, 0.06660080f, -0.03088148f, -0.06591577f, 
    0.08458155f, -0.06087367f, 0.02280832f, -0.06237952f, 0.27213734f, 0.09229194f, -0.11272711f, 0.12672749f, 
    -0.02639052f, 0.00257525f, 0.09908751f, -0.03890695f, -0.06627927f, 0.08924835f, -0.07802491f, 0.08512092f, 
    -0.05322462f, 0.01616340f, 0.00227466f, -0.04472635f, 0.11287427f, 0.02608058f, -0.04163027f, 0.09583285f, 
    0.06143841f, 0.10864616f, 0.10822141f, -0.00452788f, -0.22215709f, -0.06354240f, -0.06350867f, 0.14148596f, 
    -0.15955649f, -0.06168404f, -0.13792516f, 0.01232293f, -0.05669742f, 0.02814193f, 0.12689707f, 0.01047569f, 
    0.08970632f, 0.25206244f, 0.16398558f, -0.14491269f, 0.05273984f, 0.01860606f, 0.04732835f, 0.06959720f, 
    -0.04818400f, 0.04285956f, 0.00489960f, -0.10343335f, -0.10752420f, 0.12743518f, 0.20122172f, -0.10530154f, 
    -0.05041949f, -0.02043076f, -0.00391627f, -0.00974424f, 0.04805418f, -0.04320693f, 0.00283072f, 0.05777096f, 
    -0.20771709f, 0.17250364f, 0.07889552f, -0.17209533f, -0.00265764f, 0.11170312f, 0.05532038f, 0.09035273f, 
    -0.04958447f, 0.02591930f, -0.00721497f, 0.01847010f, -0.18524905f, 0.01254296f, -0.09536596f, 0.18985850f, 
    0.00503857f, -0.08029146f, 0.07879157f, 0.03715797f, -0.04453786f, 0.00475245f, 0.00364017f, 0.00619151f, 
    0.04420098f, 0.05939336f, -0.02818282f, -0.04392342f, 0.07812198f, 0.09097330f, -0.11877827f, 0.01877036f, 
    -0.08436361f, -0.05736975f, 0.03069400f, -0.00134709f, 0.09723756f, 0.06806692f, 0.03175334f, -0.10413427f, 
    0.07453831f, 0.11927593f, -0.06225000f, -0.02036092f, 0.06631327f, 0.00990698f, -0.01768646f, 0.00665292f, 
    0.10493340f, 0.07762370f, 0.01287229f, -0.13079488f, 0.03652696f, -0.00064012f, 0.01712942f, 0.00553750f, 
    0.07186958f, 0.03441628f, -0.10280729f, -0.04025644f, -0.02330996f, -0.05508183f, 0.05169395f, -0.14746492f, 
    -0.03346778f, 0.05631651f, -0.01304372f, 0.12992784f, -0.07126802f, -0.07504730f, 0.16786458f, -0.00650581f, 
    -0.47711843f, 0.04614338f, 0.01888281f, -0.02626587f, -0.10267838f, 0.08759291f, -0.00605485f, 0.06458896f, 
    -0.00909321f, -0.09481756f, -0.00728360f, 0.05922299f, 0.06602993f, -0.05065192f, 0.06665383f, -0.06121681f, 
    0.14675777f, 0.02353047f, -0.05569376f, -0.02137665f, -0.01425841f, 0.07139923f, 0.00307562f, -0.05425623f, 
    -0.02576813f, -0.01588779f, -0.07174397f, -0.00028821f, 0.09683023f, 0.04148163f, 0.02725890f, 0.04281850f, 
    0.04783358f, 0.02689550f, 0.00294821f, -0.03322902f, 0.08375850f, 0.04650403f, -0.01938690f, -0.16015470f, 
    0.02423884f, -0.03275009f, 0.02920542f, -0.04091997f, 0.04834378f, 0.06171727f, 0.08626428f, 0.08045304f, 
    -0.01524595f, -0.11936332f, 0.01285459f, 0.06584797f, -0.10823436f, 0.03654234f, 0.08343899f, 0.18386835f, 
    0.02808414f, -0.08554806f, -0.00836045f, -0.00298747f, 0.08903412f, -0.01723170f, 0.13628538f, -0.03207693f, 
    0.10639948f, 0.06261406f, -0.04035599f, 0.04013850f, 0.06165852f, 0.01584877f, -0.02611312f, -0.07362123f, 
    0.09280989f, 0.14433169f, -0.05144579f, 0.11339290f, -0.04491373f, 0.03381805f, -0.00010409f, -0.03775544f, 
    0.03149487f, 0.09311765f, -0.10492147f, -0.01014274f, -0.01242267f, 0.04929963f, 0.09180027f, 0.03891300f, 
    -0.07627162f, -0.01602241f, -0.01327130f, 0.02299382f, -0.03891930f, 0.04843973f, 0.07962994f, 0.00831039f, 
    -0.20347603f, 0.03629463f, 0.21731327f, 0.07311082f, 0.07389634f, -0.02676217f, 0.10351916f, 0.01846799f, 
    0.03325142f, -0.03932707f, -0.01985379f, -0.03587228f, -0.06936833f, -0.04243863f, 0.04709004f, 0.20425835f, 
    0.02695123f, -0.12520573f, 0.05391724f, -0.03017146f, 0.02372047f, 0.05492393f, -0.14267527f, -0.01140555f, 
    0.11892880f, -0.10398305f, 0.13603126f, 0.00867676f, -0.00735155f, -0.02151169f, 0.03405057f, -0.03197185f, 
    0.06964892f, -0.03591498f, -0.01780123f, -0.10361064f, 0.04645756f, 0.19731699f, -0.04981558f, 0.10264909f, 
    -0.00349190f, 0.03549399f, -0.00654908f, -0.02661717f, 0.04819868f, -0.05252317f, 0.01616500f, 0.08364619f, 
    -0.36231911f, -0.04717947f, -0.11677000f, 0.24394041f, -0.04560558f, 0.08475293f, 0.11236919f, -0.02287885f, 
    0.01006390f, -0.00901693f, -0.00103351f, -0.09247702f, -0.21928585f, -0.07347895f, -0.03888804f, 0.05915101f, 
    0.08975460f, -0.03982535f, -0.01447072f, -0.01457497f, 0.03257552f, 0.00123770f, 0.05124166f, 0.03826285f, 
    -0.27736297f, 0.16976123f, -0.05900212f, 0.11937249f, 0.03567302f, 0.01683346f, 0.01176532f, -0.08339702f, 
    0.06758076f, 0.01324423f, 0.06799966f, -0.10312962f, -0.16355145f, 0.05331174f, 0.09697157f, -0.00414553f, 
    0.07797267f, 0.01363065f, 0.06139543f, 0.04606902f, -0.10630594f, 0.11697453f, -0.06342229f, -0.07403895f, 
    -0.03982298f, -0.31793639f, 0.00119121f, -0.13572444f, 0.02989103f, 0.13883841f, -0.06742807f, -0.02535239f, 
    -0.06671597f, -0.01988509f, -0.03815699f, 0.03418893f, -0.14330195f, 0.12986328f, -0.02226930f, -0.12008981f, 
    -0.08747303f, -0.00552455f, 0.06912561f, 0.04391808f, -0.00167059f, 0.04920812f, 0.03229836f, 0.10128874f, 
    0.04987099f, 0.08132088f, -0.18212385f, 0.06910713f, -0.03614305f, -0.05463101f, 0.01462047f, 0.04153440f, 
    -0.06095822f, 0.06601314f, 0.03913214f, -0.05910327f, -0.32689667f, 0.05151783f, -0.04536511f, 0.04010511f, 
    -0.03328010f, -0.01850744f, 0.09199252f, 0.01011469f, -0.01457569f, 0.10448812f, 0.01076329f, 0.12701979f, 
    0.02738030f, 0.14906779f, -0.00626142f, 0.09963542f, 0.17748760f, 0.06357183f, -0.02506501f, -0.13113521f, 
    0.08374915f, 0.01178854f, 0.06933070f, -0.01261335f, -0.03433168f, -0.00485170f, -0.04159640f, 0.03459812f, 
    0.00437514f, -0.00950561f, -0.01456768f, 0.12267657f, -0.04237563f, 0.00061536f, 0.19796526f, -0.05171198f, 
    0.18980248f, 0.11920149f, -0.13355541f, 0.09866680f, -0.00145093f, -0.00959877f, -0.03462556f, 0.01203235f, 
    0.05777041f, -0.00282074f, -0.06644179f, -0.03153096f, 0.11541034f, 0.06296263f, -0.02085261f, -0.02583878f, 
    -0.16383189f, 0.15180509f, -0.11321303f, 0.04386802f, -0.10385640f, -0.03900878f, -0.11159759f, 0.00656406f, 
    -0.11912166f, 0.24859260f, 0.10061807f, -0.27753061f, -0.05504147f, 0.02709876f, 0.03499180f, -0.02945238f, 
    -0.03230386f, -0.06983089f, 0.03945284f, -0.02756163f, -0.15980545f, -0.03275932f, -0.03580391f, 0.07278873f, 
    0.00594774f, -0.04076524f, -0.08826045f, -0.07206780f, 0.00149028f, 0.01654006f, 0.10372385f, -0.06325414f, 
    -0.04086512f, -0.02608966f, -0.00368626f, 0.02939007f, 0.00297077f, -0.01417213f, 0.03091606f, -0.00977932f, 
    -0.03343845f, 0.00470305f, -0.01354816f, -0.01313026f, -0.00173245f, -0.02926902f, 0.03333805f, -0.02410279f, 
    0.02368541f, 0.01838415f, 0.00609642f, -0.04114497f, -0.00858779f, -0.01561569f, -0.01417457f, -0.00471145f, 
    0.00098034f, -0.01557910f, -0.01262921f, 0.00190972f, -0.01567089f, 0.02674795f, -0.02751678f, -0.02004228f, 
    -0.00624197f, 0.02982730f, -0.03985443f, -0.03794796f, 0.00824951f, 0.02430542f, 0.01198073f, 0.00413241f, 
    -0.03395376f, -0.00929881f, 0.02750113f, 0.01967701f, -0.03912155f, -0.03526230f, 0.01323373f, -0.01231558f, 
    -0.01001998f, 0.00406624f, 0.00412650f, -0.00207970f, 0.02241631f, -0.00394046f, -0.00187584f, -0.02378464f, 
    -0.03948000f, -0.03437136f, 0.02796353f, -0.02943707f, -0.03247527f, 0.01058865f, -0.02470378f, -0.01728348f, 
    -0.02825939f, -0.01066588f, -0.01832956f, -0.02994848f, 0.01249743f, -0.01587131f, -0.01200754f, 0.00877719f, 
    -0.01911202f, -0.02085063f, 0.02739024f, -0.01659887f, -0.01217028f, -0.03334199f, -0.02158636f, -0.01512085f, 
    -0.02158227f, -0.02523737f, -0.00831495f, 0.02011181f, -0.01243360f, 0.02910795f, 0.00036011f, -0.00693211f, 
    0.02456501f, 0.01320013f, -0.02063464f, -0.03213355f, 0.02286291f, 0.00913620f, -0.03336417f, 0.00099092f, 
    -0.03654313f, 0.01564646f, -0.01140264f, -0.02873867f, -0.01555241f, -0.01440147f, -0.00426054f, -0.01731768f, 
    0.00290012f, -0.01692200f, 0.02291753f, 0.01423127f, -0.01567416f, 0.01346836f, -0.02767167f, -0.03268399f, 
    0.00129460f, -0.00496745f, 0.01443039f, 0.00216896f, -0.02618526f, 0.00911989f, -0.03268364f, -0.03541278f, 
    -0.02976023f, -0.02916276f, -0.03242230f, -0.00403797f, 0.01416429f, 0.02492814f, -0.00131674f, -0.03644184f, 
    -0.00750196f, 0.02053902f, 0.02868693f, 0.02702503f, 0.00888979f, -0.03187863f, 0.02062978f, -0.03791279f, 
    -0.03201204f, -0.02272236f, 0.01024931f, -0.01019059f, -0.03227688f, -0.02562913f, -0.02465617f, 0.02403294f, 
    -0.01100546f, 0.02728203f, -0.01720795f, -0.02237183f, -0.03408734f, -0.00105335f, 0.00038568f, -0.02856159f, 
    0.01805258f, 0.02875855f, 0.02690849f, -0.00333236f, -0.02135406f, 0.00043205f, -0.02662180f, -0.03736647f, 
    0.01572073f, -0.01412912f, -0.03828687f, 0.01299835f, -0.00559871f, 0.00131665f, -0.02797578f, 0.01413537f, 
    0.01964478f, 0.01152532f, 0.01138387f, 0.01626072f, -0.03273977f, -0.02977931f, -0.02351659f, -0.00155336f, 
    -0.03412343f, 0.02340184f, 0.01564301f, -0.00536549f, -0.03087414f, -0.00615195f, -0.03404626f, 0.02991644f, 
    -0.03242344f, 0.02931557f, 0.02980895f, 0.00358316f, 0.02725004f, 0.01403210f, -0.04022881f, -0.00416233f, 
    -0.02798889f, 0.02624322f, -0.01211228f, 0.01191323f, 0.01693480f, -0.03848607f, 0.02318602f, -0.03583805f, 
    -0.03444397f, -0.01852092f, -0.03315338f, 0.02537045f, -0.01802454f, -0.03727359f, -0.02456568f, -0.02950938f, 
    -0.01327059f, 0.00401234f, 0.00458643f, 0.00108552f, -0.01442334f, -0.02651166f, 0.01973394f, 0.01780964f, 
    -0.03642289f, -0.00184946f, -0.02095655f, -0.01355280f, -0.02364388f, -0.00250375f, -0.00328271f, 0.01430001f, 
    -0.03488255f, -0.03631603f, -0.02787077f, 0.00319775f, -0.00262924f, -0.00218969f, -0.03353836f, 0.01972740f, 
    0.01507288f, 0.01023430f, -0.01008894f, 0.01612701f, -0.00793450f, -0.03248395f, 0.02563684f, 0.00077313f, 
    0.02598845f, -0.01451729f, -0.01955762f, 0.01339803f, 0.01051433f, -0.00357316f, 0.02362092f, -0.01532314f, 
    -0.03956984f, -0.03461636f, -0.02834143f, -0.03055930f, -0.04098979f, -0.00738675f, -0.01372145f, -0.00571676f, 
    -0.02446532f, -0.02901380f, 0.02220885f, -0.00946426f, -0.01925522f, -0.03833452f, -0.00798520f, -0.00421804f, 
    0.01143119f, -0.04021353f, -0.00703837f, -0.02643878f, -0.03754180f, -0.00903441f, 0.02267118f, -0.02076408f, 
    -0.02856864f, -0.02106893f, -0.02922392f, -0.03651244f, -0.01921970f, -0.00866027f, 0.02269108f, -0.02735927f, 
    -0.00054828f, -0.02593816f, 0.02095942f, -0.00932084f, -0.01245618f, 0.02613220f, -0.03040881f, -0.01240651f, 
    0.02940813f, -0.04192137f, 0.00738828f, -0.02438940f, 0.02682234f, -0.01955077f, -0.03401772f, -0.01039061f, 
    -0.01622624f, 0.00675474f, -0.01425399f, -0.00056274f, -0.00482143f, -0.03602281f, -0.01448893f, -0.01206633f, 
    0.00194523f, 0.00012296f, -0.02493092f, 0.02332863f, -0.03564353f, 0.02085504f, 0.00101763f, -0.00002119f, 
    0.02820952f, -0.00140108f, -0.01150894f, 0.03119759f, 0.01968844f, -0.02039244f, -0.03503541f, -0.00028937f, 
    -0.01150147f, -0.03481937f, -0.01916881f, 0.01581218f, -0.01089538f, 0.01398136f, 0.00454439f, -0.00648062f, 
    -0.02246467f, -0.02484284f, 0.00437888f, -0.00141849f, -0.02829398f, -0.02858306f, 0.01632339f, -0.03898280f, 
    -0.02394479f, -0.02772219f, 0.01018885f, 0.02886125f, 0.02412210f, -0.01117503f, 0.00510821f, -0.03918577f, 
    -0.00542692f, 0.01765424f, -0.00284362f, 0.02693784f, 0.01968150f, -0.04142754f, 0.01506535f, 0.01057393f, 
    -0.01733522f, -0.00524776f, 0.00945769f, -0.03696829f, -0.02688514f, 0.01262779f, -0.03635715f, -0.02992299f, 
    -0.00638897f, -0.02133695f, -0.04166629f, -0.00578672f, 0.02407056f, -0.00539056f, -0.02080241f, 0.00668058f, 
    0.00831716f, -0.01049071f, -0.02933918f, 0.00470990f, -0.01717699f, 0.01995741f, 0.01932010f, 0.01293476f, 
    0.01432925f, 0.01074997f, 0.01725027f, -0.01383123f, -0.02800457f, -0.04177271f, 0.01039263f, 0.01554048f, 
    0.02301137f, -0.01935550f, 0.00555184f, 0.00114104f, 0.01141459f, -0.02992744f, -0.01104118f, -0.02998754f, 
    0.02029472f, 0.02137670f, -0.00873456f, 0.00925713f, -0.01162796f, -0.03201051f, -0.01070951f, -0.01016409f, 
    -0.02547043f, 0.00104625f, -0.02295468f, -0.00756879f, 0.00704570f, -0.02320408f, 0.01179659f, -0.00653062f, 
    -0.00922397f, -0.02858503f, 0.00341608f, -0.00783191f, -0.00122742f, 0.01249523f, -0.04101467f, -0.00666103f, 
    0.03203890f, 0.02702181f, 0.02320617f, -0.02211261f, 0.01751577f, -0.01931873f, 0.02413539f, -0.03485511f, 
    -0.00650126f, 0.01958246f, 0.00549173f, -0.02661336f, -0.00887922f, 0.02497776f, 0.00899358f, -0.02233899f, 
    0.00666217f, 0.01477429f, -0.00763984f, -0.01722080f, 0.00416315f, -0.01227417f, 0.00926227f, -0.02195653f, 
    -0.03427706f, -0.00878752f, 0.00098532f, -0.00726198f, -0.00659691f, 0.01652060f, 0.01433390f, -0.00743559f, 
    0.02378074f, 0.02214857f, 0.02828859f, 0.00304604f, -0.03889095f, 0.00810475f, 0.02473708f, -0.00242843f, 
    -0.02171138f, -0.01695235f, 0.02396510f, 0.00179357f, 0.00710460f, -0.01118271f, -0.03834927f, 0.00671454f, 
    0.00935903f, -0.00535012f, 0.01639705f, 0.01668535f, -0.01420620f, -0.01051871f, -0.04131289f, -0.01641472f, 
    0.00564026f, -0.00128636f, 0.00128121f, -0.03520981f, -0.01695655f, 0.01898306f, 0.00871450f, 0.02445033f, 
    0.01523845f, -0.03643950f, -0.03344506f, -0.00649760f, 0.02036560f, -0.03290618f, -0.03769784f, -0.00808615f, 
    -0.03623579f, 0.01385289f, -0.02316198f, 0.01773084f, 0.00095128f, -0.02984417f, 0.00395478f, -0.03246697f, 
    0.00592442f, -0.03873620f, 0.00592029f, 0.00853348f, 0.02651324f, -0.01885159f, -0.02238682f, -0.01385878f, 
    0.01694631f, -0.02567626f, -0.01837907f, -0.00875466f, 0.02378361f, 0.02083292f, 0.01014097f, 0.01291304f, 
    -0.03368171f, 0.00497062f, -0.01036897f, 0.02957899f, 0.02424161f, 0.02956117f, 0.02006250f, -0.02782273f, 
    0.00156849f, 0.01979771f, 0.00097031f, -0.03406127f, 0.01903169f, -0.03440525f, -0.00473973f, -0.01686602f, 
    0.00531196f, 0.00304766f, -0.02409738f, -0.00762475f, 0.02750851f, 0.00824061f, -0.03782201f, -0.00642346f, 
    0.02812286f, -0.00173096f, -0.01804404f, 0.00099263f, -0.00255675f, -0.00493214f, -0.01344069f, -0.02847804f, 
    -0.00728530f, -0.01850490f, -0.00134454f, 0.02752564f, -0.03213131f, -0.00428422f, 0.02407038f, 0.02329494f, 
    0.00905659f, -0.02846916f, -0.02084103f, -0.02657678f, 0.02471450f, -0.00398354f, -0.00470795f, -0.02580366f, 
    -0.01202625f, -0.04163760f, 0.01986062f, 0.00647284f, -0.00029929f, -0.00718120f, -0.03218028f, 0.00455856f, 
    -0.02769469f, 0.00372668f, 0.00537936f, -0.04039853f, -0.02031575f, -0.01248252f, 0.01337655f, 0.00539725f, 
    0.01304216f, -0.00767848f, -0.03517991f, -0.01700085f, 0.00677318f, 0.01824465f, 0.01524820f, 0.00865001f, 
    0.00161559f, -0.02117781f, 0.01707730f, -0.01224296f, 0.02503669f, 0.00777742f, -0.03366307f, -0.02702129f, 
    -0.01308523f, 0.01577397f, 0.01461850f, 0.00854300f, 0.01854106f, -0.00660325f, -0.03137568f, 0.02726200f, 
    0.00428598f, -0.00091374f, -0.02566992f, 0.01140591f, 0.02315216f, -0.02487257f, 0.01086223f, -0.01994414f, 
    -0.01237810f, -0.00123610f, -0.01295563f, -0.01675127f, 0.01608904f, -0.02312494f, 0.01849276f, -0.02578999f, 
    0.00134500f, 0.00241920f, -0.02145847f, 0.02914422f, -0.02334383f, -0.04070166f, 0.01685605f, -0.02074256f, 
    -0.02501385f, 0.00291669f, -0.02875128f, -0.03999691f, 0.00260239f, -0.00993326f, 0.00919933f, -0.03193309f, 
    -0.01551312f, -0.03794319f, -0.02197120f, -0.03505044f, -0.02837115f, 0.01302693f, 0.02299723f, 0.00902537f, 
    -0.03223379f, -0.00261311f, -0.03515872f, -0.03165745f, -0.02203038f, -0.00902191f, -0.01300655f, -0.04077332f, 
    -0.02257326f, -0.04037284f, 0.01037186f, -0.02430372f, 0.01416329f, -0.00149100f, 0.00318360f, -0.01077956f, 
    -0.01578801f, 0.00271497f, 0.01487264f, 0.01526456f, -0.00762999f, -0.01464986f, -0.03700773f, -0.02695278f, 
    0.01822788f, -0.00630308f, -0.01302977f, -0.02635374f, 0.01828448f, -0.02331512f, -0.03574572f, 0.02657546f, 
    -0.00257828f, -0.01868151f, 0.01742451f, 0.02632481f, 0.03395487f, -0.00505444f, -0.03185458f, 0.00753720f, 
    -0.02171869f, 0.02166148f, 0.02453854f, -0.02614225f, -0.01797813f, 0.00948304f, -0.00803452f, -0.02079142f, 
    -0.03381956f, 0.00985981f, -0.03304013f, -0.03988446f, 0.01512007f, -0.03964721f, -0.02333514f, -0.03809597f, 
    0.03417959f, -0.02156140f, -0.00689489f, 0.00054591f, -0.03074931f, -0.03458657f, -0.00674851f, 0.01144221f, 
    -0.03898023f, -0.03985834f, -0.03195580f, -0.01953776f, -0.00920929f, 0.02044052f, -0.01740756f, 0.01420450f, 
    -0.02904305f, 0.02941239f, 0.02136411f, -0.00725935f, -0.02503202f, -0.00503356f, -0.03048192f, -0.03238583f, 
    0.01802968f, -0.00042194f, -0.02008707f, 0.01125212f, 0.01810221f, 0.01329103f, -0.04030740f, -0.04019521f, 
    -0.03497259f, -0.02977950f, 0.01814625f, 0.01927292f, -0.01318366f, 0.00933607f, 0.02782914f, -0.03514082f, 
    -0.00156817f, -0.00678947f, 0.00730492f, -0.01798251f, 0.00834078f, -0.03028279f, -0.00087108f, -0.01009313f, 
    0.00640369f, -0.03631921f, 0.02242174f, -0.04204295f, -0.03776907f, -0.02480948f, 0.02880506f, -0.03097360f, 
    -0.01959876f, -0.04009211f, -0.00631717f, 0.02712044f, 0.01391964f, -0.02326601f, -0.01150357f, -0.00854829f, 
    0.02007269f, -0.03554023f, -0.02564362f, -0.01255258f, 0.02239370f, 0.01259530f, -0.00923584f, 0.02059431f, 
    0.01528740f, -0.02390989f, 0.03454634f, -0.02403357f, 0.01958149f, -0.02739020f, -0.02652616f, -0.01960886f, 
    0.00357097f, -0.01267581f, 0.00242042f, -0.02028626f, -0.01120003f, 0.02561430f, 0.00805891f, 0.00311604f, 
    -0.00771620f, 0.03149975f, -0.03277525f, -0.03200683f, 0.02087981f, -0.00764345f, -0.02614896f, -0.04543824f, 
    -0.00978216f, -0.03792987f, -0.01865717f, -0.01580367f, 0.00672108f, 0.01434711f, 0.00461013f, -0.04319264f, 
    -0.03169828f, -0.04634505f, 0.00682123f, -0.03786372f, -0.01799578f, -0.03762455f, -0.01486750f, 0.00947277f, 
    -0.03065725f, -0.03713507f, -0.00682687f, 0.01428816f, -0.01527248f, 0.01332276f, -0.04439610f, 0.01991351f, 
    -0.01922221f, -0.00517074f, -0.04125981f, -0.01771046f, 0.00656623f, 0.02341010f, 0.00387086f, -0.04250899f, 
    -0.04509034f, -0.00022299f, 0.01160000f, 0.00059895f, -0.01821346f, 0.00753876f, -0.01277943f, -0.02476255f, 
    0.02012287f, -0.03861537f, 0.00809451f, -0.01009956f, -0.02120566f, -0.03818013f, -0.02735781f, 0.02100722f, 
    0.01571543f, -0.04588329f, -0.02024886f, 0.02145699f, 0.01954415f, -0.03916992f, 0.01861272f, -0.02163071f, 
    0.02005638f, 0.02352743f, -0.00986295f, 0.00212687f, -0.00599558f, -0.00543190f, -0.04577931f, -0.04492326f, 
    0.01892221f, -0.00771403f, -0.02000483f, 0.01833512f, 0.01381011f, 0.02387531f, -0.04130969f, 0.01777855f, 
    -0.03246319f, -0.00308118f, 0.02412677f, 0.00898511f, -0.01504164f, -0.03130452f, -0.01403648f, -0.02478951f, 
    0.00537697f, -0.01260521f, -0.03622422f, -0.04760785f, 0.00256508f, -0.00476473f, -0.03955918f, -0.01617614f, 
    -0.00635031f, 0.02197521f, -0.04301018f, -0.02015374f, -0.01999979f, -0.00847085f, -0.01533829f, -0.02585473f, 
    0.00149332f, 0.01472951f, -0.02175813f, 0.00795107f, 0.02478857f, -0.04018858f, -0.02460280f, -0.01155338f, 
    -0.01866050f, -0.02204172f, -0.04071409f, -0.02968602f, -0.02453987f, -0.04188761f, -0.01456050f, 0.00793567f, 
    -0.01443309f, -0.03359642f, 0.00668585f, -0.02730031f, -0.00048511f, -0.00506674f, -0.00364630f, -0.03294295f, 
    0.01240500f, 0.01673045f, -0.04651044f, 0.01924572f, -0.01463829f, -0.03304508f, 0.01738993f, -0.03853637f, 
    0.01702723f, -0.02883011f, -0.02854698f, -0.02189512f, 0.00839415f, 0.01189809f, 0.01020082f, -0.03031920f, 
    0.00411359f, -0.01428598f, 0.00183982f, 0.01689984f, -0.02352055f, -0.04543714f, 0.00954380f, -0.04062794f, 
    -0.01227800f, 0.01422136f, -0.03858708f, -0.04795623f, 0.02155552f, -0.01813968f, -0.00921290f, -0.01297340f, 
    0.00742867f, -0.03760490f, 0.00335861f, -0.04627002f, -0.01755752f, 0.01514974f, -0.00801150f, -0.01571512f, 
    -0.01514357f, 0.02846371f, -0.02717106f, -0.02425027f, -0.03841863f, 0.00225210f, -0.04543723f, 0.00292511f, 
    -0.02852198f, 0.02436825f, -0.02287195f, -0.04087755f, -0.01151198f, -0.00741899f, -0.00877804f, -0.02509777f, 
    0.02169854f, -0.03560887f, -0.04677059f, 0.00992196f, 0.02082920f, -0.02886462f, -0.03452947f, -0.03932055f, 
    -0.02825050f, 0.01154661f, -0.02418444f, -0.02667859f, -0.02398689f, -0.04337297f, -0.01375826f, -0.02799952f, 
    -0.01514830f, 0.00138748f, -0.00036644f, -0.03669174f, 0.00875816f, -0.03601591f, -0.04759914f, -0.01648332f, 
    0.00829365f, -0.00552153f, -0.02236953f, -0.01327819f, -0.00305351f, -0.00715849f, 0.02190407f, -0.04851798f, 
    -0.00113853f, -0.01600356f, -0.00470330f, -0.00061932f, -0.01089741f, -0.01996214f, -0.04851309f, 0.00074676f, 
    -0.04234206f, 0.00707136f, -0.01163412f, -0.03660768f, -0.04106615f, -0.01328803f, -0.01044126f, -0.04317350f, 
    -0.02217453f, 0.02002105f, -0.01180647f, -0.03403714f, -0.01452425f, 0.00917400f, -0.01508047f, 0.02714142f, 
    0.00310032f, -0.01713128f, -0.02471173f, -0.03942617f, -0.03226097f, 0.00973621f, 0.01375213f, -0.02438081f, 
    -0.02260276f, -0.03260132f, -0.00080396f, -0.01212018f, 0.01191461f, -0.04188246f, 0.00528370f, 0.02057285f, 
    -0.01026436f, -0.04113577f, 0.01447902f, -0.04221322f, 0.01323178f, 0.00715938f, -0.00444643f, 0.00983207f, 
    0.03161799f, -0.03222322f, -0.03132711f, -0.00104372f, -0.01016571f, -0.04286285f, 0.00223295f, -0.02441297f, 
    0.02833094f, -0.02025281f, -0.02572660f, -0.02135284f, -0.04224337f, 0.01042975f, 0.00117129f, -0.03427849f, 
    -0.04188061f, -0.01273113f, 0.01961119f, 0.01449350f, -0.01799235f, 0.00879638f, -0.01714945f, 0.02533505f, 
    0.02298154f, 0.00057281f, 0.01430829f, -0.01827087f, -0.02309574f, -0.04392773f, -0.02472450f, 0.00304432f, 
    -0.01833007f, -0.02878605f, 0.00329082f, 0.01578058f, 0.02057978f, -0.00000086f, -0.01437126f, 0.01447636f, 
    -0.01850303f, -0.02012083f, -0.00346506f, 0.01048526f, -0.02829073f, 0.02413821f, -0.01248646f, 0.01149466f, 
    -0.02747848f, -0.00986564f, -0.00782877f, 0.01739174f, -0.00734273f, 0.01350644f, -0.01887871f, -0.00303743f, 
    -0.02108221f, -0.00365972f, -0.04267790f, -0.02146369f, -0.01081797f, 0.02012354f, 0.00011406f, 0.01522877f, 
    -0.03206703f, -0.00911673f, -0.02073736f, 0.01658990f, -0.01199153f, -0.00261018f, 0.01961857f, -0.03434256f, 
    -0.03212117f, -0.02037963f, -0.01118685f, 0.01661154f, -0.03476320f, 0.00263265f, -0.03281358f, -0.04529652f, 
    -0.03820556f, 0.00590355f, -0.02656139f, 0.00215226f, -0.04230842f, -0.00834684f, 0.00392170f, -0.05028513f, 
    0.02153795f, 0.02300050f, -0.03970384f, -0.02601198f, -0.01840911f, -0.02015267f, -0.02876816f, -0.02066420f, 
    -0.03399339f, -0.02451649f, -0.02706765f, 0.01946727f, -0.04006119f, 0.01428872f, -0.00144388f, -0.03482871f, 
    -0.02712065f, 0.00031271f, -0.03061600f, 0.01126059f, 0.00441971f, 0.00937503f, -0.04179433f, -0.02098133f, 
    0.01418857f, 0.02760400f, -0.02608377f, -0.00765970f, -0.02959802f, -0.00359890f, -0.03374433f, 0.01011540f, 
    -0.00979810f, -0.01070479f, -0.01209285f, -0.04320092f, -0.02617384f, -0.03617281f, -0.04615759f, 0.01990450f, 
    0.01867320f, -0.01409491f, -0.00308029f, -0.02464758f, -0.02321901f, 0.01660090f, -0.03080921f, -0.04812641f, 
    -0.01098726f, -0.03711454f, 0.00594486f, -0.03196620f, -0.01062363f, 0.02572360f, -0.00879413f, -0.00095838f, 
    -0.03535897f, 0.00278974f, -0.02909018f, -0.02831747f, -0.00912061f, -0.01740896f, -0.02981062f, -0.02104110f, 
    -0.00686254f, -0.04564190f, -0.04378598f, -0.02867950f, -0.02720468f, -0.03799048f, 0.02666947f, -0.03052785f, 
    -0.00266708f, -0.04588449f, -0.02849725f, -0.00263195f, -0.04940128f, -0.00612151f, -0.03314913f, -0.03010591f, 
    0.00079023f, -0.01607203f, 0.00051294f, 0.03134142f, -0.02472378f, 0.01267733f, -0.03356651f, -0.02194142f, 
    0.01953118f, -0.04017118f, -0.03685826f, 0.00809866f, -0.01202703f, -0.03786739f, 0.00054909f, -0.03787657f, 
    -0.02719498f, -0.03096756f, -0.04317489f, 0.00184217f, 0.00694035f, -0.03314453f, -0.03408174f, -0.00308519f, 
    -0.01351811f, -0.03845900f, 0.00897777f, 0.01514641f, -0.04788704f, -0.00845701f, -0.04198208f, 0.01840384f, 
    -0.00843165f, 0.00936580f, -0.00873240f, -0.02668575f, -0.01437909f, -0.03119903f, -0.00384852f, 0.00738121f, 
    -0.01582563f, -0.00299086f, -0.02402717f, -0.04109015f, -0.01106507f, -0.01310178f, 0.00197400f, 0.02073867f, 
    0.00125326f, 0.00160666f, -0.01023543f, 0.00051069f, 0.00631705f, -0.03870476f, -0.04098002f, -0.04593943f, 
    0.00534963f, -0.02977316f, 0.01346776f, -0.03531598f, 0.02912450f, -0.02451043f, -0.02875954f, -0.03301900f, 
    0.01240391f, -0.01633276f, -0.04389971f, -0.02208661f, 0.02078702f, 0.00163576f, -0.02883745f, -0.02723104f, 
    -0.03145741f, -0.00251360f, 0.00102435f, -0.02900071f, -0.03821156f, 0.02355064f, -0.04677583f, -0.04822502f, 
    -0.01315806f, -0.01473804f, -0.03677871f, -0.03251955f, -0.02728505f, -0.03553142f, -0.00072174f, -0.03420465f, 
    -0.01444840f, -0.02404806f, -0.02280726f, -0.03812589f, 0.01059484f, -0.02108090f, -0.00784731f, -0.00297386f, 
    -0.01669902f, -0.01673762f, -0.01559149f, -0.03508167f, -0.04734020f, -0.01885986f, -0.04650009f, -0.00888153f, 
    -0.01180437f, 0.01480555f, -0.04836143f, 0.01837456f, 0.02628052f, 0.02339572f, -0.02577947f, -0.02621880f, 
    -0.02898893f, -0.02051855f, -0.03648866f, 0.00612374f, 0.02262826f, -0.01810389f, -0.00910181f, 0.00471153f, 
    0.02653995f, -0.00018077f, -0.00086740f, -0.02886850f, -0.01566288f, 0.01008156f, -0.04600085f, -0.01172783f, 
    -0.00504138f, 0.00978442f, -0.00517955f, -0.04493774f, 0.01774786f, 0.01642405f, -0.03903892f, -0.02283679f, 
    0.01884971f, -0.02703524f, -0.02601275f, -0.01633916f, -0.02902743f, -0.02856173f, -0.03965447f, -0.00074364f, 
    -0.00036672f, 0.00625105f, -0.04309949f, -0.01857451f, -0.01127207f, -0.03530411f, -0.01306055f, -0.03860934f, 
    -0.04682916f, -0.01567360f, -0.03483324f, 0.01962182f, 0.00670874f, 0.00135495f, 0.01179021f, -0.00035566f, 
    -0.02224098f, -0.00061116f, 0.00029402f, -0.01099737f, 0.02078426f, -0.02033274f, -0.02795449f, -0.01907818f, 
    -0.03926083f, -0.00694795f, 0.01592930f, -0.00646365f, -0.00431452f, -0.04018911f, -0.03955149f, -0.00466681f, 
    -0.01628272f, -0.04535849f, -0.03436421f, -0.00660099f, -0.00477482f, -0.02159124f, -0.03393500f, -0.03403197f, 
    0.00262408f, -0.00949347f, -0.03500301f, 0.02290488f, -0.01417594f, 0.02913620f, 0.01522071f, 0.01800569f, 
    -0.00094674f, 0.03268521f, -0.02650073f, 0.01197733f, 0.01220766f, -0.02741568f, 0.00175915f, -0.00295122f, 
    -0.04478542f, -0.00619653f, 0.02078738f, 0.00168500f, -0.02652750f, 0.03146927f, -0.00870483f, -0.03575854f, 
    -0.02421656f, -0.01860836f, 0.00624635f, -0.02405995f, -0.02565795f, -0.04865519f, -0.04828929f, -0.01575288f, 
    0.00939431f, -0.03055047f, 0.03381744f, 0.00672707f, 0.00404938f, 0.00341426f, -0.04581798f, -0.02820524f, 
    -0.00364748f, -0.01820637f, -0.02844801f, -0.03105927f, 0.00841336f, -0.00973589f, 0.00113057f, -0.00208749f, 
    -0.02460530f, 0.00582299f, -0.04537593f, -0.01992794f, -0.00454827f, 0.01805431f, 0.00522223f, 0.00504148f, 
    0.00016360f, -0.02398560f, -0.00218050f, -0.01806448f, 0.00379086f, 0.01106863f, 0.01900260f, -0.04139920f, 
    0.01278294f, -0.04359750f, -0.02323129f, -0.01602420f, 0.00425888f, -0.00248611f, -0.02523498f, -0.00685401f, 
    -0.02837350f, 0.02057746f, -0.04121910f, -0.02916062f, -0.00488734f, 0.02019598f, 0.01698863f, 0.00854635f, 
    -0.03624820f, -0.01102529f, -0.01596267f, -0.02204824f, -0.01295744f, -0.01688859f, -0.04183438f, 0.01644579f, 
    -0.04135131f, -0.01176356f, -0.00279951f, -0.03593180f, 0.00130663f, 0.00876163f, 0.01592106f, 0.00277546f, 
    -0.04502961f, -0.04767003f, -0.03694328f, -0.04195777f, -0.03334424f, 0.01585376f, -0.00017970f, 0.02122350f, 
    0.00907946f, 0.03368230f, -0.04186012f, -0.00463024f, -0.03844875f, -0.01409363f, 0.00765174f, -0.00136722f, 
    0.01165458f, -0.02881015f, -0.00890726f, 0.02760994f, 0.00078885f, 0.03109726f, -0.01797524f, -0.02911449f, 
    -0.00032710f, -0.01147374f, -0.00952442f, -0.03539281f, -0.02261883f, 0.01916390f, -0.03459195f, 0.00020783f, 
    -0.03097922f, -0.03869912f, 0.01152068f, 0.02055053f, -0.01205738f, 0.01524982f, -0.03749944f, 0.00040418f, 
    -0.04637786f, 0.07352020f, 0.05237767f, 0.14859463f, 0.13313384f, 0.11221800f, 0.07006603f, 0.00697537f, 
    -0.06241877f, -0.01505166f, -0.00989227f, -0.05074434f, 0.10395227f, 0.03966615f, -0.06570546f, -0.17942140f, 
    -0.06541288f, 0.02719172f, 0.09333348f, 0.06717507f, 0.02885136f, 0.05543312f, -0.00476387f, -0.11674365f, 
    0.28996742f, 0.17500535f, 0.07487172f, -0.05408544f, -0.14450076f, 0.05217379f, 0.00402779f, 0.05459830f, 
    -0.03627933f, 0.03998290f, 0.08555982f, 0.05829459f, 0.08862701f, 0.38649184f, 0.16698641f, 0.25533861f, 
    0.09353571f, 0.09752861f, 0.04755159f, 0.04509287f, -0.06797349f, 0.06919157f, -0.13523398f, -0.05339007f, 
    0.04840255f, 0.01052795f, 0.02403503f, -0.02187248f, 0.06319049f, 0.10585216f, 0.02557279f, -0.00089635f, 
    -0.02936327f, 0.00286438f, -0.00326864f, -0.07973299f, -0.37962928f, 0.19976689f, 0.06569003f, -0.04116618f, 
    0.01882851f, 0.00939490f, 0.00789423f, 0.11019958f, 0.09837680f, 0.08539698f, -0.05866563f, -0.09620146f, 
    0.07295381f, 0.16731325f, 0.13876346f, 0.09824089f, 0.07482322f, -0.00272330f, -0.00259406f, -0.00961346f, 
    -0.02108741f, 0.07090567f, 0.02475130f, -0.00739018f, 0.09773082f, 0.00617861f, -0.10616636f, -0.06196969f, 
    0.08932016f, 0.13918166f, -0.03494010f, 0.15610677f, 0.04607657f, 0.00930653f, 0.01043215f, -0.02213246f, 
    0.11347025f, 0.14492694f, 0.05099102f, 0.06592073f, 0.07624843f, 0.15461156f, 0.02157240f, 0.00870471f, 
    0.11755811f, 0.04805648f, 0.13169225f, -0.06540120f, 0.03412744f, 0.01258623f, 0.10672929f, -0.04171276f, 
    -0.01791280f, -0.03150585f, 0.08012249f, 0.00400185f, 0.08602557f, 0.03047477f, 0.09091286f, 0.11114537f, 
    -0.00126122f, 0.11901074f, 0.16529536f, 0.01730127f, -0.00714357f, 0.02901754f, -0.03305131f, 0.07106297f, 
    0.08052409f, 0.01085486f, -0.03169651f, 0.11383639f, 0.02079704f, -0.09073254f, -0.04187134f, -0.04441835f, 
    0.04138266f, 0.11308430f, -0.01967119f, -0.02074355f, 0.01952559f, 0.02212114f, -0.06379294f, 0.08563504f, 
    0.03022290f, -0.03032129f, -0.07077912f, -0.10383532f, -0.03292802f, 0.13010466f, -0.06061495f, -0.14078914f, 
    -0.09153637f, -0.00704290f, 0.16335262f, 0.06588738f, -0.13930745f, -0.08807660f, 0.03954212f, -0.05207217f, 
    0.04176762f, 0.04882932f, -0.04566264f, 0.02735787f, -0.00311176f, 0.08582047f, 0.02905699f, -0.08460704f, 
    0.25257343f, 0.05497273f, 0.20175655f, 0.05168024f, 0.02181026f, 0.02527060f, 0.06646026f, 0.00779193f, 
    0.02766273f, 0.00055823f, -0.02706205f, -0.01069297f, 0.08323457f, 0.12177421f, 0.04554068f, 0.00922477f, 
    0.12531826f, 0.07872806f, 0.04016006f, 0.12889950f, 0.01507827f, -0.01333740f, -0.01796099f, 0.01918215f, 
    -0.00201193f, -0.12040315f, -0.06788845f, -0.15052839f, -0.11990108f, -0.08444207f, 0.02512552f, 0.01670522f, 
    0.05311271f, -0.01687757f, 0.03301666f, 0.04712158f, 0.19343275f, 0.08015289f, 0.11537512f, 0.21134759f, 
    -0.02842507f, 0.04737382f, 0.04972378f, 0.10550105f, 0.10847771f, 0.02455033f, -0.10739099f, 0.00742113f, 
    -0.11337356f, 0.28179538f, -0.06876108f, 0.19859198f, 0.03942997f, 0.04593662f, 0.15602718f, 0.05762874f, 
    0.00976008f, 0.00419921f, -0.14861554f, -0.04553096f, 0.22277272f, 0.08787959f, -0.05642952f, 0.10239429f, 
    0.10519882f, -0.01986219f, -0.06568082f, -0.04147030f, 0.00721281f, 0.00627858f, -0.05298012f, -0.02926792f, 
    0.09155969f, -0.15352821f, 0.11364584f, 0.00081637f, 0.07089619f, -0.03939554f, -0.03108219f, -0.08521435f, 
    0.01100053f, 0.02499528f, -0.02418105f, -0.04258027f, -0.04451501f, 0.02660879f, -0.16877739f, -0.03590927f, 
    -0.02113052f, 0.10261994f, -0.03547065f, -0.00828783f, -0.02940863f, 0.11669739f, 0.06113878f, 0.08020061f, 
    -0.04695506f, -0.03823147f, -0.12084761f, -0.03491239f, 0.06111492f, -0.06513122f, -0.01207942f, -0.00243438f, 
    -0.03747293f, -0.02463452f, -0.00413638f, 0.11728694f, 0.10130753f, 0.22918615f, -0.00431275f, -0.14035684f, 
    -0.03908067f, 0.02726545f, -0.01285449f, 0.01481330f, 0.03155169f, 0.05560498f, 0.05514144f, -0.09187676f, 
    0.03763588f, -0.10392053f, -0.12032365f, -0.26872835f, 0.00350736f, -0.00008744f, 0.09012505f, -0.05214768f, 
    -0.02729767f, 0.02079532f, -0.03177786f, 0.01248896f, -0.11310941f, -0.00607176f, -0.05208237f, -0.03962069f, 
    -0.06429377f, -0.09896576f, -0.01120892f, -0.02808264f, 0.04924129f, -0.03484407f, 0.03274060f, 0.07408126f, 
    0.33915564f, -0.08895775f, -0.03135313f, 0.22638124f, 0.01242408f, 0.03790830f, -0.01476872f, 0.13100079f, 
    -0.07197588f, 0.09233756f, -0.04326015f, 0.13718791f, 0.18379121f, 0.27953222f, -0.04133175f, -0.05055507f, 
    -0.15016365f, 0.03174368f, -0.10100030f, 0.08532588f, 0.01450778f, 0.08547059f, -0.01544129f, 0.06704537f, 
    0.23696724f, 0.13272463f, -0.07090593f, -0.23086388f, -0.12960801f, 0.00980952f, -0.09456624f, 0.13732164f, 
    -0.05205555f, -0.06130437f, 0.08027932f, -0.03996121f, -0.28336486f, 0.10760660f, -0.10586473f, -0.16084599f, 
    0.13548315f, 0.04766893f, -0.03739605f, 0.01568326f, -0.04769580f, -0.06288110f, 0.02838715f, 0.15568723f, 
    0.33831862f, 0.03879397f, -0.05757121f, -0.07587296f, -0.02358396f, 0.04505166f, -0.02829931f, 0.05273993f, 
    0.07578297f, -0.01620514f, 0.02065438f, -0.00877988f, 0.38786489f, -0.01639102f, -0.10005879f, 0.28139541f, 
    0.09487920f, -0.09788120f, 0.08898262f, 0.08567002f, 0.01087121f, 0.04216558f, -0.08454350f, 0.01280591f, 
    -0.06402795f, -0.11944184f, -0.15608376f, -0.08793125f, -0.06378923f, -0.04695098f, 0.07192585f, -0.01734349f, 
    0.04733853f, 0.08104676f, -0.01283342f, -0.01173356f, 0.17021438f, 0.04130051f, 0.02794130f, -0.19525948f, 
    -0.00406649f, -0.02147003f, 0.17614384f, -0.02641354f, 0.00176928f, 0.09891453f, -0.02434548f, 0.04292716f, 
    0.34413478f, 0.02946373f, 0.03829085f, -0.10060049f, -0.06209027f, 0.01464846f, 0.03519616f, 0.01049450f, 
    -0.04416655f, 0.02512897f, -0.00784217f, -0.10640837f, 0.39987975f, -0.01722929f, 0.08041381f, -0.05667417f, 
    -0.03019838f, -0.04979721f, -0.00258686f, -0.02922837f, 0.16325079f, -0.01231649f, 0.06198296f, 0.00371909f, 
    -0.20467548f, 0.04655330f, -0.06978992f, -0.02107946f, -0.10959995f, -0.03134444f, 0.02824041f, 0.11548462f, 
    0.01610332f, 0.03679525f, -0.03192827f, 0.02837950f, 0.12421014f, -0.10120348f, 0.01258627f, -0.05494177f, 
    0.02035062f, 0.05571598f, 0.12008578f, -0.04816632f, 0.15576600f, -0.00140707f, 0.19041878f, -0.00444846f, 
    -0.06395344f, -0.40869167f, -0.15686955f, -0.02250739f, -0.04050833f, 0.07351331f, 0.01695030f, 0.02740823f, 
    0.05121550f, 0.01439748f, -0.02069343f, -0.03739335f, 0.22414817f, -0.03288350f, 0.05448354f, 0.13775638f, 
    0.01989713f, 0.07555431f, 0.09844358f, 0.02970012f, -0.00532806f, -0.08174357f, -0.08251809f, 0.01709816f, 
    0.11340832f, -0.05868719f, 0.05488552f, 0.11006584f, -0.02616004f, 0.11257304f, 0.02327227f, 0.00987998f, 
    -0.09003530f, -0.10787785f, 0.18759482f, 0.01512705f, 0.15403225f, 0.14804013f, 0.04128629f, -0.14422359f, 
    0.07553793f, -0.00706866f, -0.05942188f, 0.01876007f, 0.03412340f, 0.10170667f, 0.03149229f, -0.02347121f, 
    -0.07635961f, 0.03702822f, -0.04560346f, 0.02903393f, -0.05785943f, 0.01380016f, -0.07989995f, 0.13324535f, 
    0.00230847f, 0.04429519f, 0.07534209f, 0.05362373f, -0.07295786f, 0.07823569f, -0.04112024f, 0.15442531f, 
    -0.07965869f, -0.06619500f, -0.00351021f, 0.04338126f, -0.02405516f, -0.02240678f, 0.02408321f, 0.05361464f, 
    0.19891535f, 0.02040461f, -0.12115404f, -0.07769220f, -0.11431993f, -0.05329511f, 0.05432941f, -0.11164659f, 
    0.05127304f, 0.06533937f, -0.04864958f, 0.03184522f, 0.36491036f, -0.01359291f, 0.06041439f, -0.06025964f, 
    0.00549353f, 0.06173334f, -0.00132221f, 0.01822284f, 0.07840231f, 0.03704973f, 0.05029321f, 0.00279640f, 
    0.09732375f, 0.04169159f, 0.00045306f, 0.03743653f, 0.00313829f, 0.03593455f, 0.06478865f, 0.02360944f, 
    0.02608123f, -0.02951997f, -0.02069939f, -0.03646917f, -0.35219851f, 0.30057502f, 0.01394999f, 0.02245106f, 
    -0.00327396f, -0.02602672f, 0.01618766f, 0.07396603f, -0.08973888f, 0.04568766f, -0.07486963f, -0.03160683f, 
    -0.08913087f, 0.18677664f, -0.00757100f, 0.09391321f, -0.00688284f, 0.04915630f, 0.06360705f, -0.04348127f, 
    0.02764529f, -0.02440130f, -0.01824401f, -0.06818847f, 0.19098839f, -0.24085714f, -0.10609744f, -0.03547479f, 
    -0.11645120f, 0.01045131f, 0.05745978f, 0.00331327f, 0.01552833f, -0.03540797f, 0.00336463f, 0.14889178f, 
    -0.32017130f, -0.19100128f, -0.03808710f, 0.09859449f, -0.02334599f, 0.05169610f, -0.06595550f, 0.04242754f, 
    0.01892064f, 0.05454121f, -0.03130509f, -0.10021952f, 0.14334093f, -0.19977416f, 0.01372219f, 0.00944138f, 
    -0.10163958f, -0.04202003f, 0.06731945f, -0.01458773f, 0.06551070f, 0.05917805f, 0.04553714f, 0.06991408f, 
    -0.18294702f, -0.18941912f, -0.10577086f, -0.06966152f, 0.01203251f, 0.03740118f, 0.01684000f, 0.04443188f, 
    0.02626006f, 0.00300447f, 0.05970088f, 0.07169980f, -0.07414776f, 0.07412624f, -0.08386751f, -0.01193918f, 
    0.10188945f, 0.03004109f, -0.06715284f, 0.09180789f, -0.07548811f, 0.01403511f, -0.02755589f, -0.00448645f, 
    -0.00825787f, 0.04684784f, -0.02395965f, 0.17786723f, -0.02969989f, 0.12094784f, 0.12094814f, 0.08502566f, 
    0.05370286f, 0.04294889f, 0.09241299f, -0.04779346f, -0.33961603f, -0.15060046f, -0.11757936f, -0.07996078f, 
    -0.14171179f, 0.07988315f, 0.00842522f, 0.04628919f, 0.07682007f, 0.08979300f, 0.07449377f, -0.02888780f, 
    0.18282294f, -0.08991919f, 0.08396401f, -0.04943005f, -0.09206348f, -0.00868836f, -0.09739619f, -0.00433127f, 
    0.05768734f, 0.09074911f, 0.03287983f, -0.04670592f, 0.05684863f, 0.14779301f, 0.03870725f, -0.09575243f, 
    -0.04385429f, -0.03203335f, -0.02604919f, -0.04652624f, 0.01824404f, 0.09412926f, -0.01444138f, 0.09238830f, 
    -0.03038650f, 0.05433154f, 0.12092246f, 0.00470923f, 0.01553986f, 0.02197715f, 0.15314418f, 0.06656764f, 
    -0.05168346f, 0.03816308f, 0.17028747f, -0.01954574f, -0.13143967f, 0.10732146f, 0.14917652f, 0.09337433f, 
    0.03510421f, 0.10292294f, -0.08781447f, -0.01719757f, 0.01348999f, 0.05251396f, -0.07226309f, -0.04568094f, 
    0.18915319f, 0.02190580f, 0.18973809f, -0.07029865f, 0.04425855f, -0.01025683f, 0.12018877f, 0.04300097f, 
    -0.00996198f, 0.12952048f, -0.05398834f, 0.05763040f, 0.06716212f, 0.06055427f, -0.04854632f, 0.16706283f, 
    0.02770418f, 0.07667618f, 0.00057582f, 0.00619100f, -0.00703933f, 0.02952312f, 0.05293614f, -0.10335869f, 
    0.13533071f, -0.04243897f, -0.01639351f, -0.04677520f, -0.09004617f, 0.08455079f, -0.02428244f, -0.05731405f, 
    0.05574583f, -0.07559904f, -0.08712430f, -0.12440831f, 0.25973681f, -0.22046642f, 0.03958730f, -0.00857951f, 
    0.12437025f, -0.01356672f, -0.02132196f, 0.08006008f, -0.04361502f, 0.02854316f, 0.02257717f, -0.08928506f, 
    0.02382302f, -0.02754042f, -0.02394975f, -0.04097271f, -0.04273472f, -0.01578174f, -0.01248510f, -0.02275864f, 
    -0.00784609f, 0.00090672f, -0.02675389f, 0.02290064f, 0.00808366f, -0.02321463f, -0.03337360f, -0.03691928f, 
    0.00673373f, -0.00359946f, 0.01045068f, 0.02219629f, 0.00833609f, 0.01120855f, -0.00291766f, -0.01058204f, 
    -0.01801416f, 0.02779836f, -0.02612710f, 0.00572593f, 0.02060034f, 0.01997609f, -0.03040968f, -0.03875912f, 
    0.01332226f, -0.01474266f, 0.02064526f, 0.02811784f, -0.03418546f, -0.03420511f, 0.00701172f, -0.01565349f, 
    0.02518065f, 0.01022081f, -0.01505128f, -0.04106224f, -0.02409378f, -0.00815380f, -0.01207893f, -0.00526020f, 
    -0.01032118f, 0.00923967f, -0.01649147f, 0.02734819f, 0.00687591f, 0.00581438f, -0.00992270f, 0.02605365f, 
    0.01511124f, 0.00823694f, 0.01309719f, -0.03172033f, -0.01575761f, -0.01787856f, -0.00823413f, -0.03255688f, 
    0.01912702f, 0.02528791f, -0.04025755f, 0.02638979f, -0.03047664f, -0.02217894f, 0.00433244f, -0.01796742f, 
    -0.01698645f, 0.01844203f, 0.01606812f, -0.01163829f, -0.00617316f, 0.01260948f, -0.03038459f, -0.01956120f, 
    -0.01052355f, -0.01713657f, -0.01403622f, 0.02766229f, 0.00119667f, -0.01790745f, -0.02978285f, 0.02742651f, 
    -0.03060809f, 0.01971428f, 0.01234287f, 0.02911423f, 0.01283215f, 0.02507812f, -0.00992021f, -0.01710429f, 
    0.02090798f, 0.01988197f, -0.00685656f, 0.03050930f, 0.00280291f, -0.03932796f, -0.00861626f, -0.03690072f, 
    -0.00021815f, 0.00370593f, -0.03935344f, 0.03147618f, -0.00487158f, 0.03476015f, 0.03112464f, -0.01610502f, 
    -0.03221666f, -0.02420739f, 0.02424187f, -0.01598509f, 0.02650381f, 0.01991268f, 0.00423472f, -0.03081957f, 
    0.00111950f, 0.02481916f, -0.02218175f, -0.00572098f, -0.02394050f, -0.03047278f, -0.03118984f, 0.01611248f, 
    -0.02243618f, 0.00883081f, 0.00208072f, -0.02328177f, -0.03032732f, -0.03280425f, -0.03734688f, 0.02498213f, 
    -0.02623940f, -0.01695172f, -0.01653619f, -0.00826598f, 0.02888566f, 0.01530327f, -0.03510296f, 0.01910737f, 
    -0.02185508f, -0.00665706f, 0.02190154f, 0.00819043f, 0.02771592f, 0.00192658f, -0.04055120f, -0.00692478f, 
    -0.00777241f, 0.00330375f, 0.01366381f, 0.02442207f, -0.01801935f, 0.01704659f, -0.02387254f, -0.03075366f, 
    0.00311715f, 0.01307067f, -0.00251879f, -0.01934792f, -0.01841074f, 0.02773367f, -0.00147329f, 0.00497644f, 
    0.01644051f, 0.01827035f, -0.02733113f, -0.02239245f, -0.02582880f, 0.02012505f, -0.01382384f, -0.00418659f, 
    -0.04066638f, 0.01906654f, -0.02322219f, -0.01475703f, 0.02785789f, -0.01224639f, 0.02642274f, -0.04068126f, 
    -0.00702207f, -0.03362889f, 0.02300107f, -0.01600828f, 0.01047968f, -0.02120882f, -0.01006279f, -0.02300866f, 
    0.02635037f, 0.02698434f, 0.01323379f, 0.00956920f, 0.01393312f, -0.01496173f, -0.00925688f, -0.02016160f, 
    -0.04214063f, -0.00675197f, -0.03482988f, -0.03479418f, -0.03132870f, 0.02825552f, -0.01329739f, -0.03529415f, 
    -0.00150392f, 0.01633414f, 0.01479155f, 0.00267536f, 0.01856192f, -0.00462318f, 0.01325826f, -0.02250518f, 
    -0.04041550f, 0.00405320f, -0.01041609f, 0.02720953f, -0.01328722f, -0.00980369f, -0.02468527f, 0.01983216f, 
    0.00453877f, -0.04084678f, -0.02412316f, -0.02340247f, 0.00322525f, -0.01257659f, 0.02503239f, -0.02282729f, 
    0.02156531f, -0.01456897f, -0.01451174f, -0.04076279f, 0.00503987f, 0.02126076f, 0.00079663f, 0.00092686f, 
    -0.01382396f, -0.03548829f, 0.01287306f, 0.02828179f, 0.01054199f, 0.03024020f, -0.02781665f, -0.03176315f, 
    -0.02138022f, -0.03991998f, 0.01914881f, 0.01191857f, -0.00828935f, 0.00313806f, 0.01091214f, -0.01672313f, 
    0.02489524f, -0.03386752f, -0.02599952f, -0.00179327f, 0.00947829f, 0.01509271f, -0.02409052f, -0.02802653f, 
    0.02830812f, -0.03068531f, -0.02426344f, -0.00561378f, -0.04126250f, 0.01130053f, 0.00636425f, 0.00699480f, 
    -0.03291768f, -0.03928232f, 0.02809864f, -0.02559154f, -0.00088809f, -0.02210664f, -0.03579566f, 0.01988333f, 
    0.02620227f, -0.02317304f, 0.02493345f, -0.00064210f, -0.02696274f, 0.01698540f, -0.04167007f, 0.01663171f, 
    -0.00123995f, -0.01711322f, -0.01156814f, -0.01273025f, -0.01388513f, 0.00615720f, 0.01754242f, -0.02689989f, 
    0.00004860f, -0.00771726f, -0.03886252f, -0.01188846f, -0.00206073f, -0.02164488f, -0.00547271f, 0.02417347f, 
    0.00111533f, -0.00228528f, -0.01783004f, 0.00223193f, 0.01958770f, 0.00673279f, -0.02619841f, -0.02958597f, 
    -0.03360417f, -0.02359341f, -0.02715537f, 0.01875523f, -0.01618695f, -0.03609848f, 0.01074583f, -0.04042047f, 
    -0.01199517f, -0.04147752f, 0.00355755f, 0.01102704f, -0.04204738f, -0.03043609f, -0.00057396f, 0.02174554f, 
    -0.02404354f, -0.04218576f, -0.02358139f, -0.02098482f, -0.00856229f, 0.02390973f, -0.00563896f, -0.03581494f, 
    -0.02471326f, -0.01700013f, 0.02500890f, 0.00238387f, -0.01186649f, -0.00894087f, 0.00358621f, -0.03345451f, 
    -0.02146481f, -0.04023385f, -0.02698850f, 0.00295862f, 0.02010235f, -0.03641589f, -0.02940427f, -0.00499720f, 
    -0.01815113f, 0.00937460f, 0.00577837f, -0.01357455f, -0.03592170f, -0.00329605f, -0.00237827f, 0.02355546f, 
    -0.00394453f, -0.00149266f, -0.03086623f, 0.00800779f, 0.02668339f, 0.00264137f, -0.03871895f, -0.02642681f, 
    0.00983202f, -0.02555721f, -0.00997756f, -0.04070817f, -0.01150542f, -0.04046732f, -0.01799834f, -0.02298738f, 
    -0.02390357f, 0.00926366f, -0.01656420f, 0.02349997f, 0.02111460f, -0.00452103f, -0.02101909f, -0.02068756f, 
    -0.03942312f, 0.00865190f, -0.00691255f, -0.03451293f, -0.01683746f, -0.00415561f, 0.01917993f, -0.00573930f, 
    -0.03650359f, -0.02388465f, -0.00108796f, 0.02219849f, 0.00974971f, -0.02946725f, -0.01454237f, -0.03229271f, 
    -0.00343448f, 0.00386009f, 0.02527589f, -0.02834697f, -0.02560909f, 0.00086772f, 0.02092373f, 0.00297310f, 
    -0.01857939f, -0.04257210f, 0.02238840f, -0.01465252f, -0.01080371f, -0.02036062f, 0.00769658f, 0.01684896f, 
    0.00923003f, -0.03046394f, -0.00636929f, -0.01092362f, -0.00246772f, -0.04188981f, 0.04013951f, 0.02480451f, 
    0.01010778f, -0.02785718f, -0.02796161f, -0.04097315f, 0.00897982f, -0.01644352f, -0.01476104f, -0.00919458f, 
    -0.00924540f, -0.03689065f, -0.01514130f, 0.02793293f, 0.00752317f, 0.02469895f, 0.02526079f, -0.00106895f, 
    -0.02095892f, -0.03607847f, -0.00500620f, -0.03211051f, 0.01297775f, 0.00969320f, -0.01088315f, -0.02016565f, 
    0.02142878f, -0.02973269f, 0.01300565f, -0.00887070f, 0.02685069f, 0.00393930f, -0.03408073f, 0.00756402f, 
    -0.00411108f, -0.02990217f, -0.01270112f, 0.00079536f, -0.04077531f, -0.02192145f, -0.03492430f, -0.01922801f, 
    -0.00253811f, -0.01687783f, -0.02770558f, -0.04101013f, -0.01504284f, -0.01110565f, 0.02813915f, 0.02618086f, 
    0.01994197f, -0.00071160f, -0.01908924f, -0.01270507f, 0.00623779f, 0.02490890f, 0.00523805f, -0.00659669f, 
    0.01640952f, 0.02530112f, -0.01276461f, -0.01050693f, -0.03949983f, -0.01810464f, 0.01950133f, -0.01519156f, 
    -0.01073554f, -0.03907768f, 0.01918326f, -0.00189527f, -0.01943003f, -0.03115264f, 0.01643543f, -0.01526062f, 
    -0.02097191f, 0.01163802f, -0.01082084f, -0.03985485f, -0.02998962f, 0.02270480f, -0.02247055f, -0.04259483f, 
    0.00737824f, 0.00111565f, 0.00720649f, -0.01413064f, -0.00631486f, 0.02604896f, -0.03133527f, -0.01330035f, 
    -0.03844547f, -0.03965868f, 0.00453955f, -0.01687429f, -0.00419049f, -0.03984088f, 0.02847564f, 0.02674443f, 
    -0.02792761f, 0.00619143f, -0.00997936f, -0.00037514f, -0.02766480f, -0.00052895f, -0.03040464f, -0.02196049f, 
    -0.01690462f, -0.01935897f, -0.02261003f, -0.02746871f, 0.01509533f, 0.00488935f, -0.03149272f, 0.02327498f, 
    -0.00187419f, -0.03317310f, 0.02632669f, 0.00456807f, 0.02068244f, -0.04129132f, -0.00812790f, -0.01633253f, 
    -0.00582012f, -0.00948562f, 0.01314083f, 0.00639770f, -0.04445657f, 0.01574645f, -0.03674809f, 0.01928423f, 
    -0.01671225f, 0.00722866f, -0.03827629f, 0.00372886f, -0.03607879f, -0.04111618f, -0.03418998f, -0.01644132f, 
    0.01533951f, -0.00965944f, 0.00467845f, 0.00120826f, 0.01955066f, -0.03178435f, 0.01656402f, -0.01525199f, 
    0.00646243f, 0.01628475f, -0.04134151f, -0.00273237f, -0.02406848f, 0.00462187f, 0.01335356f, -0.00094759f, 
    -0.02817351f, -0.02947669f, -0.00138520f, 0.02837447f, -0.00689247f, 0.01014178f, 0.00044306f, -0.00036099f, 
    0.01267525f, -0.02559459f, -0.00226540f, -0.03090879f, 0.02619856f, -0.00109476f, -0.02439202f, -0.01359186f, 
    -0.03471917f, -0.01576867f, -0.04061728f, -0.03214726f, 0.02897579f, 0.00820857f, 0.01639498f, -0.04106591f, 
    0.01630457f, 0.00453162f, 0.02155720f, -0.01702533f, 0.02751716f, 0.01795659f, 0.02317143f, -0.00654021f, 
    -0.00121687f, -0.02261789f, 0.01976711f, -0.00095486f, 0.02000308f, 0.02065892f, -0.00416760f, -0.00825968f, 
    0.02451568f, 0.01872339f, -0.00991388f, 0.01711016f, -0.00363018f, -0.00827953f, -0.00061717f, 0.00979371f, 
    -0.00640005f, 0.01428547f, -0.01520500f, -0.01927885f, 0.00972594f, -0.02044715f, -0.03943683f, -0.02725908f, 
    -0.03848023f, 0.00821770f, 0.00130711f, -0.01833487f, 0.00430587f, 0.01184955f, -0.00675433f, 0.00633107f, 
    0.02633662f, 0.00880278f, 0.01235809f, -0.04245846f, -0.00849139f, -0.04031007f, 0.01219646f, -0.00603063f, 
    -0.02747274f, -0.04326672f, 0.02955768f, -0.02226849f, -0.03535295f, 0.01923875f, -0.02993846f, 0.01910254f, 
    0.00052115f, 0.01641619f, -0.03716595f, -0.02350176f, -0.01266457f, 0.01384886f, -0.02670072f, -0.04340399f, 
    0.02919432f, 0.00743980f, 0.00509474f, 0.01689871f, 0.02544612f, -0.00865599f, 0.00479732f, -0.00874041f, 
    -0.03271601f, -0.01792428f, -0.02680539f, -0.03752811f, -0.02498853f, -0.01938165f, -0.00852835f, 0.01936065f, 
    -0.02792939f, -0.02548180f, 0.00565002f, 0.02207632f, 0.00046836f, -0.04086332f, -0.02453574f, 0.01466621f, 
    -0.01020704f, 0.02512841f, 0.02736013f, -0.00991594f, -0.00558955f, -0.00488105f, -0.02344669f, -0.02024507f, 
    0.01575200f, -0.01908174f, -0.03489789f, 0.02658455f, 0.02318030f, -0.00668426f, 0.01253795f, -0.01452084f, 
    -0.01144125f, 0.01389306f, 0.02541690f, 0.00924521f, -0.03150301f, -0.00378796f, -0.02462484f, -0.00175361f, 
    -0.03317691f, -0.00043203f, -0.00726357f, -0.02344395f, -0.00245053f, 0.01349910f, 0.00163539f, -0.01785505f, 
    -0.00321270f, -0.03393519f, -0.00819278f, 0.01942489f, -0.01882687f, 0.02316693f, -0.02550489f, 0.00617035f, 
    -0.02760723f, 0.01996198f, 0.00329487f, -0.03618916f, -0.00043077f, -0.03394038f, -0.01294335f, -0.02531061f, 
    -0.00311220f, 0.00630168f, 0.02224571f, 0.02340329f, 0.00521915f, -0.01726039f, 0.00799077f, -0.02816950f, 
    -0.04020047f, 0.02542687f, 0.01114864f, 0.01998435f, 0.00386049f, 0.02224061f, -0.03686178f, -0.01722627f, 
    -0.01629318f, 0.01427871f, -0.04218130f, -0.02512133f, 0.02005056f, -0.02566464f, -0.02838620f, -0.00051029f, 
    -0.02013580f, 0.01958844f, 0.02699605f, 0.02104850f, 0.00745347f, -0.02221181f, 0.00129956f, 0.00790768f, 
    0.20838401f, -0.09508926f, -0.11150485f, 0.23007752f, -0.03133582f, -0.07376188f, -0.05501674f, -0.04906576f, 
    0.03358977f, 0.04899406f, -0.06802897f, -0.09573035f, -0.13360815f, -0.12933184f, -0.02977066f, -0.06261110f, 
    -0.00929194f, -0.02111860f, -0.01990443f, 0.10095064f, -0.09690969f, 0.05295803f, 0.07915518f, -0.02670334f, 
    -0.13086523f, -0.00584535f, -0.14289474f, -0.03113007f, -0.06052350f, -0.03665065f, -0.07886381f, -0.04125181f, 
    0.00665946f, -0.08216515f, -0.00832180f, 0.05049304f, -0.30886254f, 0.27605823f, 0.16783781f, -0.02406722f, 
    0.09126050f, -0.01002183f, -0.14129339f, 0.01415826f, -0.01094548f, 0.07502665f, 0.00457966f, -0.04181410f, 
    -0.18549088f, 0.26443827f, 0.10713731f, 0.20676488f, 0.04072301f, -0.03534762f, -0.02495073f, -0.02425558f, 
    0.03127879f, 0.12607595f, 0.06381503f, -0.10047191f, 0.02456420f, 0.12682761f, -0.11478680f, -0.13269198f, 
    -0.07147706f, 0.06207282f, 0.11997551f, 0.05040298f, -0.04679559f, 0.15984468f, 0.10079546f, 0.07068325f, 
    0.06239057f, -0.00547287f, 0.10108402f, -0.03587291f, -0.04174272f, -0.06342684f, -0.02035695f, 0.01843720f, 
    0.07952245f, 0.02115393f, 0.01471579f, 0.14182346f, 0.22175552f, -0.05396712f, -0.22871642f, -0.30030149f, 
    0.07147110f, 0.05014726f, 0.04352538f, -0.10530501f, -0.00649144f, 0.12952398f, 0.01741351f, -0.01474660f, 
    0.01930308f, 0.13849461f, -0.06487809f, 0.00866076f, 0.09157546f, -0.01374739f, -0.01264920f, -0.08402731f, 
    0.10581335f, 0.07185106f, -0.00550482f, -0.13724542f, -0.00983823f, -0.04769040f, -0.01121375f, -0.17275862f, 
    -0.10765947f, -0.17110384f, 0.06708202f, 0.09131671f, 0.03725715f, -0.00775548f, 0.07103586f, 0.16077700f, 
    -0.02909609f, 0.10831998f, 0.07188797f, -0.16704753f, 0.03088842f, -0.14665297f, 0.06601680f, 0.06038297f, 
    -0.03480894f, -0.05173543f, 0.05848330f, 0.01274143f, 0.19989434f, -0.04403054f, 0.03545545f, 0.12639941f, 
    0.06184984f, 0.05999400f, 0.04812768f, -0.00981986f, 0.07711446f, -0.06691363f, 0.09170853f, 0.02654584f, 
    0.01490937f, 0.13190100f, 0.02957379f, 0.21324340f, 0.00223906f, 0.15545529f, 0.00133067f, -0.01610062f, 
    0.04112990f, -0.01025001f, 0.10507465f, 0.05377290f, 0.00526261f, 0.08092844f, 0.05479281f, -0.06215912f, 
    0.03163205f, -0.00776252f, 0.00233782f, 0.03450023f, 0.03987857f, 0.06371593f, 0.10322210f, -0.07405426f, 
    -0.17032483f, -0.09110869f, -0.12305170f, -0.01748861f, -0.00745868f, 0.07020074f, -0.01167304f, 0.07432853f, 
    -0.01777131f, 0.08232074f, -0.01178605f, -0.03683852f, 0.30599770f, -0.16333388f, 0.04526044f, 0.21605118f, 
    -0.03882319f, -0.03320610f, 0.01924295f, -0.05358565f, 0.08738803f, -0.01093298f, -0.09153622f, 0.01897454f, 
    0.41617385f, -0.11916667f, 0.11229708f, 0.18827072f, -0.00781497f, 0.00350235f, 0.01368250f, 0.03063587f, 
    0.05816706f, 0.00521598f, 0.10690086f, 0.02376523f, 0.06783582f, 0.09297272f, -0.02183593f, -0.08778495f, 
    0.05166172f, -0.08039518f, -0.02294949f, 0.01946712f, -0.01607846f, 0.09886804f, -0.03781963f, 0.05607623f, 
    -0.12632224f, 0.22296467f, -0.02467479f, -0.03430429f, 0.00917948f, 0.04393027f, 0.02026227f, -0.02648698f, 
    0.02835167f, -0.01492163f, -0.01927571f, 0.00905078f, 0.05319433f, 0.00122138f, 0.06825399f, -0.17008713f, 
    -0.03834016f, 0.07539492f, 0.04221852f, 0.04858630f, 0.12396652f, 0.01490778f, 0.06557231f, 0.01561019f, 
    0.07050097f, 0.04463209f, 0.10494863f, -0.01145169f, -0.03316111f, -0.03641935f, 0.07281723f, -0.01406588f, 
    -0.04802489f, -0.01898423f, -0.03776714f, -0.01345060f, 0.01549314f, -0.01184594f, 0.03764027f, 0.21116391f, 
    0.00527878f, 0.04505469f, 0.07075544f, -0.01897470f, 0.08395008f, 0.04382597f, -0.05051652f, 0.02470765f, 
    -0.05054728f, 0.00387661f, 0.07586640f, 0.19551578f, -0.02040505f, -0.00015350f, 0.06029653f, -0.04223723f, 
    0.07890372f, -0.05035056f, 0.05076218f, 0.10904875f, -0.08617624f, -0.05220826f, -0.09287035f, 0.07888595f, 
    -0.05882891f, 0.02009761f, -0.01904179f, 0.09676424f, 0.00339860f, -0.02105234f, 0.08593084f, -0.00336228f, 
    -0.14047927f, -0.17251813f, 0.18264972f, -0.04234444f, 0.01462640f, 0.03102764f, 0.06663720f, 0.07169280f, 
    0.00283107f, 0.07926786f, 0.07825683f, -0.03154238f, 0.16496906f, 0.00030103f, 0.11550632f, 0.01897005f, 
    0.11492798f, 0.00209406f, 0.00575215f, -0.00168156f, 0.07271589f, -0.02698131f, 0.02040318f, -0.03623933f, 
    0.32615408f, -0.25086620f, -0.24814518f, 0.06314528f, 0.09483825f, -0.00992591f, 0.01349531f, -0.05110400f, 
    0.13093702f, -0.07016905f, -0.00321754f, 0.02096573f, -0.08433840f, 0.20689009f, -0.02874563f, -0.15590857f, 
    0.01558835f, 0.05483723f, -0.07797767f, 0.04986710f, -0.03489099f, 0.12574711f, -0.04364533f, 0.07829999f, 
    0.18084535f, 0.05091343f, 0.01461686f, 0.08435082f, -0.09194734f, 0.01840923f, 0.01450854f, 0.08168400f, 
    -0.06670565f, -0.04268163f, 0.05390119f, 0.05117859f, -0.00235734f, 0.11720496f, 0.05081145f, 0.10222139f, 
    0.11134733f, 0.16375113f, 0.10116709f, -0.00775227f, -0.07459226f, -0.08451755f, 0.03507728f, 0.03444832f, 
    -0.06064654f, -0.04727658f, -0.09694382f, 0.01765008f, 0.04960993f, 0.11366642f, 0.10420610f, 0.00460470f, 
    -0.08831246f, -0.00204382f, 0.04023512f, 0.04898238f, 0.39175981f, 0.00964084f, -0.08196262f, 0.01667753f, 
    0.09950160f, 0.16965042f, 0.00565883f, 0.04943895f, 0.06019057f, 0.02933564f, 0.05140203f, 0.01203720f, 
    0.13600087f, 0.03107676f, -0.16981675f, 0.16251379f, -0.04997284f, 0.01973190f, 0.05025442f, 0.00866305f, 
    0.00409130f, 0.00239705f, 0.08363716f, 0.03191280f, -0.27571219f, -0.24340990f, -0.03234405f, 0.14097211f, 
    0.09066251f, -0.09463024f, 0.01860323f, 0.06428093f, 0.01886530f, 0.14681199f, 0.00837227f, 0.10323620f, 
    0.05586283f, -0.01384603f, 0.06306048f, -0.12884218f, -0.09395140f, -0.06744896f, -0.00930462f, 0.02049528f, 
    -0.02900835f, -0.05607097f, -0.01972436f, -0.02570234f, 0.13341817f, 0.04477219f, -0.02190358f, 0.05778639f, 
    -0.03589891f, -0.06465342f, 0.03115669f, 0.03292803f, 0.00747901f, -0.05830294f, 0.04473966f, 0.06408409f, 
    -0.01500690f, 0.15602346f, -0.11734195f, -0.14923529f, -0.06904245f, 0.06733710f, 0.08215716f, 0.01996366f, 
    -0.00302816f, -0.04877348f, 0.00693883f, 0.04730709f, 0.00594713f, -0.12597318f, -0.01032642f, 0.05202796f, 
    0.05407975f, 0.13451046f, 0.07555003f, 0.08244203f, -0.10573760f, 0.06188905f, 0.00581341f, 0.09668778f, 
    0.06056385f, -0.03557062f, 0.04854142f, -0.05337201f, 0.07664342f, 0.07105789f, 0.03030743f, 0.03502424f, 
    0.05329921f, 0.06521406f, 0.05876593f, -0.00965460f, 0.07294589f, -0.03945446f, 0.11990418f, 0.11001815f, 
    0.01402429f, 0.06812814f, -0.08292888f, 0.08182243f, 0.16522957f, -0.06632084f, -0.13155806f, 0.05573245f, 
    0.16350403f, -0.05808148f, 0.01202111f, 0.11662405f, -0.00992082f, 0.03378851f, -0.04317958f, 0.03199308f, 
    0.04781623f, -0.03559361f, 0.00146032f, 0.03191738f, 0.22177531f, 0.10228845f, -0.04087974f, 0.03007047f, 
    -0.06009047f, 0.05821577f, 0.01080601f, 0.05728960f, 0.14443193f, 0.07340989f, 0.02074169f, 0.05589889f, 
    0.04841375f, 0.16134413f, -0.07223349f, 0.07948791f, -0.03302034f, -0.02231014f, -0.09957653f, 0.17003985f, 
    -0.10766578f, 0.09232184f, 0.01425086f, 0.05773386f, 0.04121668f, 0.02459092f, 0.00595878f, 0.14507003f, 
    0.03373710f, 0.04439861f, -0.08664780f, -0.01420598f, 0.10353567f, -0.08497497f, 0.03788633f, 0.07491527f, 
    -0.00683069f, -0.10579500f, 0.10334414f, 0.07220370f, -0.06285187f, -0.10895839f, 0.06512068f, 0.08203951f, 
    -0.00844796f, -0.01328027f, 0.02910452f, -0.03962474f, -0.22918549f, -0.19265869f, 0.07922608f, 0.02545148f, 
    0.00116133f, 0.07457023f, -0.02420733f, -0.01090826f, -0.03489155f, 0.04109826f, -0.02298352f, 0.13477807f, 
    0.26399133f, -0.15713617f, -0.18938057f, -0.21392319f, 0.03920068f, 0.03421688f, 0.00618777f, -0.04324480f, 
    -0.06509841f, 0.02452076f, 0.01616329f, 0.05813656f, -0.05107624f, 0.16897109f, -0.13440694f, -0.20058297f, 
    0.09459680f, 0.04600649f, 0.04786389f, 0.02416683f, 0.03010181f, 0.00245787f, -0.06694711f, 0.07690427f, 
    -0.33781883f, -0.01036847f, -0.02326060f, 0.02575126f, 0.11173863f, 0.06328695f, -0.09192899f, 0.02479640f, 
    -0.05340963f, -0.03113941f, -0.03189517f, -0.00128904f, 0.13827857f, -0.06335425f, -0.06346021f, -0.04288519f, 
    0.02077640f, 0.04629738f, 0.01612228f, -0.01603112f, -0.17134979f, 0.04675578f, 0.00171176f, 0.02646244f, 
    0.24941272f, -0.15784307f, -0.00485392f, -0.15435117f, -0.13299583f, -0.01581722f, 0.07486540f, 0.07587804f, 
    -0.05177936f, 0.10581613f, -0.00462348f, -0.04025658f, 0.27366772f, -0.04926633f, 0.03360694f, 0.06450753f, 
    -0.10677174f, -0.02435050f, -0.03170032f, -0.01522994f, 0.03281041f, 0.05336340f, -0.09431022f, -0.01129076f, 
    0.17856218f, -0.15197471f, 0.07874656f, -0.05540213f, -0.00337652f, 0.10112761f, 0.02570014f, 0.25388485f, 
    -0.02816153f, -0.04848799f, 0.01662530f, 0.01510385f, -0.12516128f, 0.19385254f, -0.11895104f, 0.11941751f, 
    -0.10109837f, -0.06963485f, -0.01015019f, -0.07031940f, 0.04835219f, -0.08046979f, -0.01007451f, 0.01778986f, 
    -0.15523891f, 0.06441053f, -0.01533484f, -0.22036089f, -0.06878293f, 0.10575379f, -0.05232511f, 0.08108839f, 
    0.06217425f, -0.00394672f, 0.02385182f, 0.03368397f, 0.19537033f, -0.04901240f, 0.00247099f, 0.09905945f, 
    0.15539363f, -0.01739239f, -0.03111673f, 0.13563190f, 0.04050706f, 0.11681628f, 0.11304893f, 0.01650795f, 
    -0.00792415f, -0.07842918f, 0.05781835f, -0.10355018f, -0.03890092f, -0.03731310f, 0.00456171f, 0.02772726f, 
    0.07847716f, 0.03732582f, -0.03863619f, 0.09526073f, 0.31818384f, 0.07767455f, -0.01752197f, 0.02856376f, 
    -0.01726201f, -0.09494971f, 0.00282601f, -0.01492927f, 0.12377740f, 0.04384158f, 0.11092194f, 0.01533056f, 
    0.20008072f, -0.13105185f, -0.05951336f, -0.07516453f, -0.03082574f, -0.02023276f, 0.07322982f, 0.04832930f, 
    0.05830348f, 0.07183041f, 0.00600595f, 0.13206241f, 0.09244582f, 0.09925541f, -0.02907398f, -0.07432663f, 
    -0.00601435f, -0.02308695f, 0.09262305f, -0.02216236f, 0.01691515f, -0.13344331f, -0.06116871f, 0.04265844f, 
    -0.18894130f, -0.10621750f, 0.06053416f, 0.02077343f, -0.01212964f, -0.06525643f, 0.07968693f, 0.10234938f, 
    0.06670553f, 0.10873041f, 0.03376124f, 0.02418576f, -0.06999266f, -0.21096155f, -0.07751239f, 0.05576397f, 
    -0.09016680f, 0.09428780f, 0.02400460f, 0.02016380f, -0.01079761f, -0.00883084f, 0.00073126f, -0.07765854f, 
    0.14332731f, -0.16570978f, 0.17099589f, 0.41974899f, 0.12883744f, -0.03612778f, -0.05709826f, -0.03990518f, 
    0.06776190f, -0.00281914f, -0.03215231f, -0.01968810f, 0.00624848f, -0.10846817f, 0.17175800f, 0.05717693f, 
    0.05236803f, 0.00597430f, -0.05574553f, 0.00810192f, 0.05030163f, 0.04360221f, -0.07511705f, -0.06382211f, 
    -0.01441000f, 0.01992426f, -0.01118908f, -0.03551796f, -0.03430300f, 0.02321124f, -0.01926950f, 0.01660031f, 
    -0.04139986f, -0.00506951f, -0.01009694f, -0.00028779f, -0.00926928f, -0.00041002f, -0.00504464f, 0.01473686f, 
    -0.02881566f, 0.00673770f, -0.00256048f, -0.01732647f, -0.03593146f, -0.01300614f, -0.00110955f, -0.02365787f, 
    -0.00300340f, -0.01532764f, 0.02285013f, -0.00961371f, -0.02483024f, -0.03185401f, 0.01651443f, -0.01475161f, 
    0.00613329f, -0.03762734f, 0.00212469f, 0.02940462f, -0.00010311f, -0.00768882f, 0.00358813f, 0.02629609f, 
    0.02865582f, -0.02992418f, 0.03145790f, -0.01875247f, -0.01903719f, 0.00612263f, -0.01495004f, 0.02597077f, 
    0.01485454f, -0.04386564f, 0.00471368f, 0.01759421f, -0.03384871f, 0.02812578f, -0.00050968f, -0.02282577f, 
    -0.02292436f, 0.02976928f, -0.00057935f, -0.01084975f, 0.00819511f, 0.03035960f, 0.00280647f, 0.00411848f, 
    -0.03653682f, -0.03081603f, -0.04419930f, 0.02108766f, -0.01176898f, -0.03228232f, -0.02571742f, 0.03003341f, 
    -0.04239945f, -0.01144912f, -0.02816884f, -0.02450608f, 0.03186184f, 0.01478481f, -0.02914250f, 0.02014254f, 
    0.00911244f, 0.01653269f, -0.03507521f, 0.00923447f, 0.03438078f, 0.02142384f, 0.01506725f, 0.02417484f, 
    0.02998175f, -0.03693242f, -0.03096455f, -0.01688645f, 0.00859206f, -0.01545575f, 0.02433385f, -0.03682376f, 
    -0.01835576f, -0.00764692f, 0.01445785f, -0.01377637f, 0.01965448f, 0.01932531f, 0.02789749f, 0.01777056f, 
    0.03062468f, -0.01023533f, 0.02697750f, 0.02313421f, 0.02216716f, 0.00850617f, 0.00279573f, 0.01677951f, 
    0.03817402f, -0.00585081f, -0.00886869f, 0.02215705f, 0.01212218f, -0.01108563f, -0.04318307f, -0.01224541f, 
    0.03040576f, 0.00912614f, -0.02714729f, -0.00052076f, 0.02721073f, -0.03158322f, 0.02562162f, -0.01544343f, 
    -0.04352211f, -0.02973256f, -0.02010820f, -0.03090357f, -0.03508678f, 0.00319857f, 0.00644897f, 0.00491956f, 
    -0.02522598f, 0.00687173f, -0.03016570f, 0.01428471f, -0.00786136f, -0.02580103f, 0.03113842f, -0.00592828f, 
    0.02771210f, -0.03163521f, 0.02577814f, 0.00462837f, -0.01205312f, 0.00101614f, -0.01727941f, 0.02150018f, 
    -0.03708915f, 0.00280702f, -0.01408665f, 0.01070912f, 0.02326618f, 0.00381982f, 0.00664421f, 0.00851676f, 
    0.00368747f, 0.01083610f, -0.00216677f, -0.02248756f, 0.02483281f, 0.01501490f, 0.02543875f, 0.00558773f, 
    -0.02323149f, -0.01913332f, -0.01311459f, -0.03077932f, -0.00664291f, 0.01878710f, 0.01774615f, -0.00803534f, 
    0.01829468f, -0.04119869f, 0.00265053f, -0.04146879f, -0.03175572f, 0.00026509f, 0.00199251f, -0.02931208f, 
    0.00637836f, 0.02639777f, -0.00074341f, -0.03144694f, 0.02874773f, -0.00044793f, 0.00312856f, -0.00605021f, 
    0.01339052f, 0.02282949f, 0.01083381f, 0.01512711f, 0.00451602f, -0.03369878f, 0.02495055f, -0.00776478f, 
    -0.02860120f, -0.02492225f, 0.00218029f, 0.01872834f, 0.01599412f, -0.01747722f, 0.04386567f, 0.01127287f, 
    0.01697093f, 0.02781686f, 0.02200138f, -0.02700861f, -0.03323223f, 0.02539975f, -0.00725059f, 0.02514874f, 
    -0.03777319f, 0.02141888f, 0.02239195f, 0.02414305f, 0.00830813f, -0.03428387f, 0.00705968f, 0.02137002f, 
    -0.02041075f, -0.01837659f, 0.02762835f, 0.02103692f, 0.00755018f, -0.01243300f, 0.00026698f, -0.01365165f, 
    -0.01033780f, 0.02494024f, -0.02815346f, -0.01161365f, -0.00271524f, -0.01081671f, -0.00702277f, 0.02583276f, 
    -0.02931758f, 0.01778417f, -0.01090867f, -0.02609755f, -0.00223783f, 0.02169041f, 0.00231317f, -0.00759506f, 
    -0.01526538f, 0.01446756f, -0.03297220f, -0.02446537f, -0.02072538f, 0.00513762f, -0.00702306f, 0.03019204f, 
    -0.00740004f, 0.00869456f, -0.03346067f, 0.01214323f, -0.02311729f, -0.01972166f, -0.02287336f, 0.01766683f, 
    -0.00016255f, 0.02169322f, 0.02502791f, -0.00596434f, -0.00477125f, -0.02711361f, -0.01980636f, -0.01171582f, 
    -0.02222785f, 0.03328037f, 0.00288353f, -0.04116293f, -0.04127677f, -0.02790594f, -0.03049988f, 0.00052245f, 
    0.01740764f, 0.00438845f, 0.02298692f, -0.01978755f, 0.01728011f, -0.00616015f, 0.02453139f, -0.02116576f, 
    -0.03239583f, -0.00566533f, -0.02747749f, -0.02815098f, -0.01962157f, -0.03473559f, 0.02376939f, -0.01927583f, 
    -0.01522635f, -0.00483286f, 0.01078221f, -0.03672011f, 0.00951910f, -0.00842713f, -0.03095839f, -0.02490906f, 
    0.00407515f, -0.02387593f, -0.04304940f, 0.01017307f, -0.01199896f, -0.01407988f, 0.00450137f, 0.00988326f, 
    -0.00580060f, 0.01063842f, 0.01920080f, -0.01368668f, 0.01333318f, -0.02817930f, -0.02318791f, -0.01917702f, 
    0.02235969f, 0.01203144f, 0.01044070f, 0.01916630f, -0.03125741f, 0.02319961f, 0.02412960f, -0.01145835f, 
    -0.01258397f, -0.01053104f, -0.02352208f, 0.02207031f, -0.03708603f, 0.00491946f, 0.02100490f, -0.00358266f, 
    0.02385826f, -0.03103076f, 0.03544101f, 0.00280308f, -0.02645083f, 0.00970322f, -0.00263574f, -0.00214001f, 
    0.02884343f, -0.02371961f, 0.03733556f, 0.01025810f, -0.00495012f, -0.03689827f, 0.03228886f, 0.03508447f, 
    -0.00781071f, -0.01898392f, 0.01714760f, -0.02145230f, 0.00021980f, 0.00047282f, -0.02379245f, 0.00675551f, 
    -0.02730728f, 0.02202031f, 0.00220026f, 0.02875854f, -0.01439756f, 0.01845006f, 0.02154164f, 0.00360983f, 
    0.01345893f, 0.02090718f, 0.01430030f, 0.01789379f, 0.01519135f, 0.02315394f, 0.00141741f, 0.02349039f, 
    -0.02981613f, -0.02600969f, -0.02363242f, 0.00583726f, -0.03823071f, -0.01921811f, -0.02617705f, 0.02361555f, 
    -0.02272322f, -0.01309000f, -0.02820002f, 0.01663057f, 0.01107676f, -0.00348609f, -0.03097436f, 0.01434010f, 
    0.00883861f, -0.03132936f, -0.01889439f, -0.01562940f, 0.01536795f, 0.02526681f, 0.00003277f, -0.00200882f, 
    0.02278204f, 0.01703530f, 0.00140240f, -0.01368441f, -0.03898939f, -0.02825793f, 0.01544037f, 0.00529670f, 
    -0.02869197f, 0.00763819f, -0.01605041f, 0.00616792f, -0.02894093f, 0.01835357f, 0.02173775f, 0.00225893f, 
    -0.01282626f, 0.01032380f, 0.01131670f, 0.01953101f, -0.03402153f, -0.02233607f, -0.03508394f, -0.00437474f, 
    -0.01239305f, -0.03489850f, -0.00234633f, 0.00068773f, -0.01259483f, 0.00371766f, 0.02138028f, -0.00055580f, 
    -0.02280848f, -0.01807330f, -0.03659199f, 0.01055421f, -0.02272768f, -0.03441356f, -0.01220264f, 0.01368667f, 
    0.01142541f, -0.00631470f, -0.01623794f, -0.00869728f, -0.03956147f, -0.01892648f, 0.01088246f, -0.01710866f, 
    -0.02311288f, 0.01605583f, 0.00040840f, 0.00168972f, 0.02226906f, -0.03747300f, -0.03513918f, -0.00089419f, 
    -0.03314608f, -0.01877584f, 0.00747684f, 0.00225075f, 0.00844614f, 0.00308501f, -0.00631880f, 0.00342328f, 
    -0.02975805f, 0.01554522f, -0.00444161f, -0.03984244f, -0.00458826f, -0.03790851f, -0.04285114f, -0.03120937f, 
    0.01085497f, -0.03696507f, 0.01935666f, -0.02426528f, 0.01172491f, -0.01611418f, 0.01228387f, -0.01977238f, 
    -0.04117849f, 0.02062942f, -0.02431240f, 0.01476339f, -0.03399508f, -0.01945532f, 0.00982097f, 0.00626726f, 
    0.01925779f, 0.02374624f, 0.00534271f, 0.01630946f, -0.01694546f, -0.02746129f, 0.01783358f, -0.03366002f, 
    -0.01854963f, -0.01750606f, -0.00611702f, 0.02658732f, -0.02896706f, -0.01029083f, 0.00016499f, -0.03107352f, 
    0.02455077f, 0.02123539f, -0.00990713f, -0.03124579f, -0.01346014f, -0.00041189f, -0.01078621f, 0.01543994f, 
    -0.02051870f, -0.00876539f, 0.01387409f, -0.00189232f, 0.00257240f, -0.03560365f, -0.01431315f, 0.01078941f, 
    0.01872313f, -0.01121336f, 0.00099881f, -0.00061077f, 0.02668991f, 0.00985549f, -0.03558606f, 0.01222778f, 
    -0.02995961f, 0.00246510f, 0.02917997f, -0.00589018f, -0.00652717f, 0.01076638f, -0.01423809f, -0.00177132f, 
    0.03240337f, -0.02473549f, -0.00120667f, -0.04065523f, 0.01214699f, 0.01087659f, -0.01306917f, -0.02483379f, 
    -0.00914292f, 0.01711277f, 0.00814319f, 0.01095536f, 0.01691388f, 0.02121387f, -0.01500340f, -0.00093922f, 
    0.00856578f, -0.03869721f, -0.04202959f, -0.00088560f, 0.02680173f, -0.04425658f, -0.02596719f, 0.02418184f, 
    0.01139462f, 0.02167661f, 0.00327597f, -0.01130704f, -0.01978228f, -0.04122997f, -0.02604112f, -0.01321818f, 
    -0.02490693f, 0.02062961f, -0.01995467f, 0.00872103f, -0.00325941f, -0.00648030f, -0.01859250f, 0.00727173f, 
    0.01702630f, -0.02803577f, -0.02168304f, -0.02254667f, -0.01143097f, -0.03351825f, -0.03979706f, -0.01749715f, 
    -0.01939677f, 0.00575370f, -0.01341578f, -0.03478955f, 0.00549937f, -0.02042452f, 0.01204796f, -0.03279848f, 
    -0.01913525f, -0.00517991f, 0.01311896f, 0.01893518f, -0.03065230f, -0.00597794f, 0.00657145f, -0.03882498f, 
    0.01704269f, -0.01659562f, -0.03725633f, 0.02498933f, -0.03960782f, -0.03998273f, -0.00274189f, 0.00814002f, 
    -0.03426098f, -0.01766051f, 0.02350836f, 0.00245920f, 0.01660651f, 0.01868993f, -0.03601134f, 0.02158394f, 
    0.02301366f, -0.00820646f, -0.01228768f, 0.00348643f, 0.01945690f, 0.03074317f, 0.01106033f, -0.03067650f, 
    -0.02154703f, 0.02783694f, -0.04050355f, 0.01678648f, -0.02176436f, -0.00262897f, 0.03929947f, -0.02846436f, 
    -0.03214455f, 0.02831584f, -0.02973924f, -0.03755967f, -0.02403007f, 0.01271253f, 0.00928865f, -0.02482994f, 
    0.00062572f, 0.00143436f, 0.00201192f, 0.00396506f, 0.00275916f, -0.03917655f, -0.03207141f, 0.01333407f, 
    -0.00915189f, -0.02599669f, 0.01336408f, -0.01301725f, 0.02103173f, -0.00990509f, -0.02919656f, 0.00297980f, 
    -0.01771102f, -0.02888661f, 0.02870029f, 0.02459717f, -0.00021240f, -0.03670435f, -0.02215165f, 0.00374689f, 
    -0.01484046f, 0.00716518f, -0.04549110f, 0.00192331f, -0.02320715f, -0.02309333f, -0.03654845f, 0.01547887f, 
    -0.02582516f, 0.02967130f, -0.01818880f, -0.03070555f, -0.02271983f, -0.00581585f, 0.03259293f, -0.02177907f, 
    0.02160654f, 0.02318853f, -0.01831062f, -0.03372137f, 0.02500060f, -0.00215985f, 0.00399253f, 0.00359617f, 
    0.01238864f, 0.02879187f, -0.00016787f, 0.02565024f, -0.00374345f, 0.01122985f, -0.00384095f, 0.01575595f, 
    0.01752964f, -0.04178257f, -0.02083220f, -0.02320978f, 0.02395589f, 0.02365543f, 0.01588920f, 0.01758950f, 
    -0.03094208f, -0.02952630f, 0.02742745f, -0.01973508f, 0.00687380f, -0.03645805f, 0.03988811f, 0.01176271f, 
    0.01636193f, 0.00359332f, 0.02967834f, 0.00971567f, 0.01375164f, -0.03115148f, -0.00817610f, -0.00375173f, 
    0.00423007f, -0.01605377f, -0.02166802f, -0.03042641f, -0.00224400f, -0.03180142f, 0.01518356f, 0.00296806f, 
    -0.02716004f, -0.00904315f, -0.03007583f, -0.01902160f, -0.03234944f, 0.01959891f, -0.02609393f, -0.03284842f, 
    -0.02707270f, 0.00605266f, 0.00884649f, -0.03353354f, -0.03498784f, -0.02169612f, 0.01180953f, -0.02183956f, 
    -0.01071453f, -0.03146437f, 0.01544327f, -0.01299560f, -0.01615374f, -0.00037789f, -0.01158542f, 0.01593846f, 
    -0.01698847f, 0.00604515f, 0.02796732f, -0.00844915f, -0.03047302f, 0.01200442f, 0.00989691f, 0.02786923f, 
    -0.02268164f, -0.00685579f, -0.00538888f, 0.02983885f, -0.02859882f, 0.00457810f, -0.01945821f, 0.02158108f, 
    -0.03598022f, -0.00928253f, -0.04308627f, 0.01973874f, 0.02404218f, 0.02865228f, 0.00996411f, 0.01776638f, 
    0.00347621f, -0.02239429f, -0.01340133f, 0.03465588f, -0.02419068f, 0.01609783f, -0.00053486f, 0.01208446f, 
    -0.04016998f, -0.00521109f, 0.01466775f, 0.01299686f, -0.03589200f, -0.01982886f, 0.00842934f, 0.01189212f, 
    -0.01592962f, -0.03990142f, -0.02571916f, 0.02734154f, 0.00117526f, -0.00088685f, 0.00673368f, -0.01432509f, 
    -0.03099719f, 0.01077945f, 0.02131311f, -0.01304699f, 0.01506771f, -0.02507349f, 0.00119855f, 0.01782788f, 
    -0.00242497f, -0.02299069f, 0.01898826f, -0.01731696f, -0.01044164f, 0.02070065f, -0.03410849f, -0.03625554f, 
    -0.03044870f, -0.04087421f, -0.01867558f, 0.01906990f, -0.03188211f, -0.01200581f, 0.00415705f, -0.02456960f, 
    -0.01925802f, -0.02336884f, 0.01793366f, 0.01082677f, -0.02801935f, 0.01897627f, -0.00953442f, -0.01831222f, 
    -0.01867933f, 0.00379938f, 0.00270769f, -0.03977615f, -0.01962817f, -0.00523470f, 0.00628476f, 0.02203393f, 
    0.00206322f, -0.03036025f, -0.00768874f, -0.02413051f, 0.04254606f, 0.03135868f, -0.04186330f, -0.01080189f, 
    -0.01058797f, 0.02376984f, 0.00543621f, 0.02462552f, -0.03969203f, -0.01620207f, 0.01152071f, 0.01759118f, 
    -0.01756486f, -0.01417457f, -0.03137630f, 0.03293570f, -0.01092267f, 0.01457879f, -0.00438368f, -0.02408512f, 
    -0.04579164f, 0.02038904f, -0.00877561f, 0.01732734f, -0.02914826f, -0.00169868f, -0.00739555f, -0.02657404f, 
    0.02568978f, 0.02545684f, 0.03306892f, 0.00956211f, 0.03053015f, -0.02519831f, -0.02907256f, 0.02308446f, 
    -0.01416311f, -0.03223341f, -0.00609941f, -0.00858263f, 0.00978654f, 0.01982680f, 0.01219158f, 0.02127478f, 
    0.02535665f, 0.01250738f, -0.02995228f, 0.00647308f, -0.01027567f, 0.01669794f, 0.00507461f, 0.02231469f, 
    0.02597000f, -0.03753599f, -0.00184417f, 0.00612579f, -0.02297288f, -0.03595714f, 0.02981205f, -0.03438402f, 
    -0.01457493f, 0.02480246f, -0.03108714f, 0.00870351f, 0.01583800f, -0.01003666f, -0.03529270f, -0.03056262f, 
    0.02441346f, 0.02289758f, -0.01194026f, 0.01165020f, 0.01599211f, 0.01176214f, -0.01154184f, 0.02284210f, 
    0.03239493f, -0.04543058f, -0.00618388f, 0.02930114f, -0.02413618f, 0.01872560f, 0.01482217f, 0.02931392f, 
    -0.01145173f, 0.00717304f, 0.02570181f, -0.03282420f, -0.00266842f, -0.04486042f, -0.03702654f, 0.01927152f, 
    0.01252982f, -0.02020258f, -0.03088542f, -0.00981381f, -0.01003226f, -0.00967814f, -0.02924547f, -0.03829279f, 
    -0.03846517f, -0.02337341f, 0.02184225f, 0.01898174f, 0.00443526f, 0.02873630f, -0.04054589f, 0.00619420f, 
    0.01026203f, -0.03442532f, -0.01688932f, -0.00644086f, 0.01122913f, 0.01934903f, 0.03157518f, 0.00493738f, 
    -0.00161219f, 0.00698871f, -0.00332318f, -0.00399483f, -0.00608623f, 0.00657002f, 0.00904828f, -0.02481058f, 
    0.00006768f, -0.03368206f, 0.01953570f, 0.02119364f, 0.01678503f, -0.04075222f, 0.00036965f, -0.02344965f, 
    -0.03308343f, 0.00890033f, -0.03356203f, -0.00097569f, 0.00712375f, -0.03336350f, -0.00452503f, -0.01990547f, 
    -0.00695350f, 0.00168880f, 0.00489550f, -0.02546263f, -0.02906294f, -0.03206450f, -0.02527119f, 0.02937621f, 
    0.02929235f, 0.00355026f, 0.02755018f, 0.02638332f, 0.02473239f, 0.01105930f, -0.00278096f, -0.03109571f, 
    -0.01255198f, 0.01382487f, 0.02455466f, -0.03495653f, 0.02068396f, -0.01915725f, -0.02543095f, 0.02412117f, 
    0.01481197f, -0.03765570f, 0.00466726f, 0.00566771f, -0.03565264f, 0.02129273f, -0.01191107f, -0.01248095f, 
    0.02767237f, -0.03267252f, 0.02567441f, -0.02363434f, -0.03161414f, -0.03441778f, -0.02307447f, 0.02979767f, 
    -0.00133973f, -0.01204421f, -0.02715694f, -0.03488334f, -0.00702432f, -0.04174625f, -0.00066968f, 0.01028001f, 
    -0.02244623f, -0.01847883f, -0.03918543f, 0.00004822f, -0.00239474f, -0.00930872f, -0.02549702f, 0.00601046f, 
    -0.01879729f, -0.00726847f, -0.03368931f, 0.01785341f, -0.02119915f, -0.04494454f, -0.01538852f, -0.01836889f, 
    0.00404569f, 0.01488238f, -0.00463471f, -0.01340725f, 0.02533701f, -0.00761663f, -0.01459821f, 0.00455621f, 
    -0.04475748f, 0.00552177f, -0.02053635f, -0.02974527f, -0.02104717f, 0.01880630f, 0.00177718f, -0.03785694f, 
    0.02739768f, 0.01913672f, -0.03820864f, -0.01215691f, 0.01514659f, 0.00787499f, -0.03400227f, 0.02807678f, 
    -0.01783268f, 0.02890883f, -0.01246826f, 0.02098732f, 0.02024126f, 0.00510727f, 0.01536176f, 0.02816699f, 
    0.02748301f, -0.00876561f, -0.00085402f, 0.01334224f, 0.00688276f, 0.00632111f, 0.00263355f, 0.02208650f, 
    -0.01268892f, 0.00046143f, 0.00291484f, 0.02477532f, -0.00929214f, 0.03186033f, -0.02531781f, -0.02427075f, 
    -0.01595656f, -0.01615595f, 0.00762655f, 0.01157697f, -0.03410724f, -0.02197969f, -0.04078733f, 0.02933629f, 
    -0.01707458f, 0.01926202f, 0.00133703f, -0.01327518f, -0.00151300f, -0.01163486f, -0.00892874f, 0.01206478f, 
    -0.01454302f, -0.01820218f, 0.01570219f, 0.02940405f, 0.03919994f, 0.00857017f, -0.03286942f, 0.03118414f, 
    -0.00577948f, -0.01280097f, 0.02405864f, 0.00504391f, 0.00304081f, 0.00088025f, 0.03001256f, 0.00130138f, 
    -0.02778979f, 0.01931810f, 0.02435159f, 0.02170245f, 0.00612065f, 0.01328822f, 0.01823553f, -0.03917689f, 
    -0.01531717f, -0.00326370f, -0.00706898f, 0.00206596f, 0.00611019f, -0.00260935f, -0.02887712f, 0.00947273f, 
    -0.01427018f, -0.02405997f, -0.01381439f, -0.02458850f, -0.02026317f, 0.01403458f, 0.02436566f, -0.00133256f, 
    0.01280249f, 0.00050001f, -0.01777953f, 0.00536855f, -0.02367786f, 0.02087076f, -0.01319698f, 0.01323193f, 
    -0.00420563f, 0.00667344f, 0.01783350f, -0.01618160f, -0.03529170f, -0.02208980f, -0.02598898f, -0.02473534f, 
    -0.01778208f, -0.00076173f, -0.01502254f, 0.02352780f, 0.01200876f, -0.01393523f, 0.00236940f, 0.00480660f, 
    0.02132816f, 0.02649347f, 0.00120370f, 0.00027514f, -0.03110263f, -0.04387952f, -0.01898542f, -0.03411764f, 
    0.00786390f, -0.02764869f, 0.03292745f, -0.02036890f, -0.00732060f, 0.00427469f, 0.01543717f, -0.03759877f, 
    -0.03451330f, 0.02556507f, -0.03078210f, 0.01826475f, -0.02937955f, -0.01058628f, 0.03172972f, 0.00133895f, 
    -0.01106620f, -0.01684792f, 0.00697925f, 0.02644960f, -0.00587176f, 0.02043242f, -0.02010672f, 0.02485918f, 
    0.02933551f, -0.03469855f, -0.00540551f, 0.01725614f, -0.03038568f, 0.00711191f, 0.02166314f, -0.00376169f, 
    0.02079663f, -0.02806288f, 0.03476205f, -0.00909103f, -0.01518071f, -0.01641282f, -0.01574065f, 0.00386414f, 
    0.01696048f, 0.02683910f, -0.01731626f, 0.00015996f, 0.00119218f, -0.03156610f, 0.00826292f, 0.00778619f, 
    -0.02924029f, -0.00353333f, -0.01410632f, -0.00205565f, 0.00043496f, -0.01082590f, -0.04462128f, -0.03474992f, 
    -0.00353214f, -0.01971445f, -0.00362573f, 0.00022639f, -0.01828389f, -0.02565704f, -0.00385588f, -0.02686680f, 
    -0.02861031f, 0.00712782f, -0.04039921f, -0.00076585f, -0.02298545f, -0.00029378f, -0.03733389f, 0.02556913f, 
    -0.01654761f, -0.02675566f, 0.01028089f, -0.00238330f, 0.00878721f, -0.02914315f, 0.00034790f, 0.00069660f, 
    -0.01604062f, -0.03949028f, 0.02032920f, 0.02664343f, -0.00997266f, -0.00358567f, -0.01107361f, 0.00613010f, 
    -0.01803409f, -0.01590876f, -0.02145611f, -0.00858993f, -0.01762611f, -0.00730476f, 0.02120671f, -0.02502375f, 
    0.01444402f, -0.01740642f, -0.00699525f, 0.03292198f, -0.04488122f, -0.01621630f, -0.01521172f, 0.01667907f, 
    0.00065000f, 0.01952038f, 0.00156743f, -0.03177098f, -0.01301113f, -0.03544484f, -0.01973848f, -0.02259959f, 
    -0.01235693f, 0.02169701f, -0.03491515f, -0.00880747f, -0.04110904f, -0.02314837f, -0.00345420f, -0.02510592f, 
    0.02976794f, -0.00723881f, 0.03129490f, 0.01964403f, 0.02790789f, -0.00623948f, -0.03101932f, 0.00648206f, 
    0.01228088f, 0.01680868f, 0.03269946f, -0.01159099f, -0.02333698f, 0.01832478f, -0.01176448f, 0.02418853f, 
    -0.03207825f, 0.01802180f, 0.01261117f, -0.02061611f, -0.00257510f, -0.04368626f, 0.00971203f, -0.00292204f, 
    -0.03341124f, -0.00598964f, 0.01010716f, 0.02349312f, 0.00408431f, -0.00238380f, -0.02193861f, -0.04250779f, 
    0.00643683f, -0.04223466f, -0.01958230f, 0.00476199f, -0.04155203f, -0.01914904f, -0.01311563f, -0.02226904f, 
    -0.00292454f, -0.01286188f, 0.02746378f, 0.00390026f, -0.02581976f, 0.00166910f, -0.00532186f, -0.02261970f, 
    -0.03901227f, -0.02949935f, -0.01564886f, -0.01824413f, 0.01441142f, 0.00603545f, 0.01084315f, -0.04271007f, 
    -0.03306979f, 0.01244161f, -0.01038240f, 0.02791151f, 0.02321919f, 0.02743046f, -0.02308895f, -0.01432490f, 
    0.00223918f, -0.02336427f, -0.00273816f, -0.02981799f, 0.01664248f, -0.00367457f, 0.02328129f, -0.03530057f, 
    -0.02643400f, -0.02066951f, -0.01886719f, -0.01189273f, -0.02776084f, -0.01179217f, 0.01632836f, 0.01303155f, 
    -0.00050257f, 0.00846063f, 0.00656423f, -0.01691377f, 0.02356132f, -0.00029845f, 0.01502018f, -0.04103974f, 
    -0.03488439f, 0.00918264f, 0.02515930f, -0.01195605f, -0.04250677f, -0.01676334f, -0.02169824f, -0.00208677f, 
    -0.01052107f, -0.03242778f, 0.00428865f, 0.00476639f, 0.00111552f, -0.02131169f, -0.02287850f, -0.01049692f, 
    -0.03790546f, 0.00842106f, 0.00125802f, 0.01493157f, -0.01830065f, -0.03224774f, -0.02538409f, -0.01614089f, 
    -0.04145226f, -0.01226531f, 0.02551400f, 0.01922134f, -0.03367937f, -0.01838803f, 0.02459653f, -0.02358545f, 
    0.00686842f, 0.00442932f, -0.03272115f, -0.01591249f, 0.03983078f, -0.03208716f, 0.01738008f, -0.00397426f, 
    0.00515587f, 0.02715543f, 0.00545970f, -0.02223361f, -0.01153414f, 0.00578272f, -0.01381339f, -0.00265763f, 
    0.00304732f, -0.03918306f, -0.02901586f, 0.02229155f, -0.02343240f, -0.03357615f, 0.02999618f, 0.02563906f, 
    -0.01056958f, -0.03064626f, 0.02560332f, -0.01851659f, -0.03371787f, -0.02401998f, -0.00243492f, -0.00806748f, 
    -0.03743574f, -0.01088845f, -0.04883245f, -0.00913652f, 0.02518327f, -0.01083445f, -0.00107998f, -0.02806312f, 
    -0.01254045f, -0.04218030f, 0.02457735f, -0.02181838f, 0.00512472f, 0.01466561f, -0.00752097f, 0.00922940f, 
    0.01884291f, 0.00126931f, -0.04043677f, -0.00306578f, 0.02128297f, -0.02776399f, -0.03084006f, -0.03771269f, 
    -0.02727637f, 0.00416885f, 0.01337237f, 0.01927926f, -0.00848232f, 0.01637737f, 0.02062779f, -0.03491470f, 
    -0.04044705f, -0.00234267f, 0.00782033f, -0.03321964f, -0.01199759f, -0.03848795f, 0.00183922f, 0.01922605f, 
    0.02234503f, -0.00027909f, -0.03277126f, 0.01230178f, 0.00049602f, 0.00528523f, -0.00555088f, -0.03868090f, 
    -0.00734495f, 0.00554229f, 0.03011014f, -0.04150961f, 0.02756703f, -0.02596490f, 0.00839660f, 0.00264209f, 
    -0.01019293f, 0.02377908f, -0.04075627f, 0.03013199f, -0.02226790f, -0.00042956f, -0.03974450f, -0.00037324f, 
    0.00865427f, -0.01375648f, 0.02640942f, 0.00972981f, 0.00487352f, 0.01485453f, -0.04028244f, 0.02044294f, 
    0.00938663f, 0.02887120f, -0.03028231f, -0.01695841f, -0.02637120f, -0.01036581f, -0.02538385f, -0.02522309f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04040298f, -0.03741847f, -0.03152211f, 0.08292407f, 0.02858571f, 0.00726837f, 0.06438284f, 0.02859413f, 
    0.03580616f, 0.01050092f, -0.00059514f, 0.04381487f, -0.02412297f, 0.01595822f, -0.04068060f, -0.04079216f, 
    0.00543141f, 0.01459475f, -0.02679276f, -0.01937427f, -0.00343874f, -0.05320881f, 0.00504021f, 0.09494421f, 
    -0.00132989f, 0.00790086f, -0.03256184f, 0.00851369f, 0.00178639f, 0.04601004f, -0.01220321f, 0.02200845f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.52516091f, -0.03595356f, 0.03624615f, 0.15437795f, 0.12532058f, -0.02545840f, -0.23358814f, -0.17610274f, 
    0.22337468f, -0.13104954f, 0.42790252f, -0.59979445f, 0.15121323f, 0.07178205f, 0.10866582f, 0.22076356f, 
    0.06066031f, 0.12950009f, 0.11366515f, 0.04486503f, 0.01137185f, -0.35915634f, 0.23268522f, -0.36027262f, 
    -0.27542269f, 0.12820868f, 0.07189821f, 0.23972106f, 0.03222946f, -0.11804966f, 0.03110633f, -0.00695955f, 
    -0.35833716f, -0.24213405f, 0.07206776f, 0.27014020f, 0.15605013f, -0.03697890f, -0.24938133f, 0.41521478f, 
    -0.34001556f, 0.07900632f, -0.43483448f, 0.01427961f, 0.00075425f, 0.15470229f, -0.11495185f, 0.10110319f, 
    0.05213223f, -0.21179400f, -0.16548309f, 0.09402199f, 0.01579001f, 0.07191365f, -0.04451888f, -0.01401595f, 
    -0.55018973f, -0.11092491f, -0.12527499f, 0.00838426f, 0.08185300f, 0.31965885f, -0.11328787f, -0.17082365f, 
    -0.17699265f, 0.20400321f, -0.00236072f, -0.32097602f, -0.48837328f, 0.15413302f, -0.04977358f, 0.16813578f, 
    0.11622305f, -0.01319504f, -0.31500059f, -0.47927999f, -0.14863232f, 0.02797088f, 0.26064166f, 0.18204582f, 
    -0.06865893f, -0.38088974f, -0.13377263f, 0.04466652f, -0.05518603f, 0.20760530f, 0.41402406f, -0.49496961f, 
    0.15384127f, 0.15592222f, -0.16464052f, 0.03787263f, -0.12815142f, 0.12148076f, -0.16153695f, 0.10276936f, 
    -0.15569727f, 0.29235870f, -0.31000522f, -0.08440829f, 0.18813112f, -0.09290662f, -0.26945409f, -0.49371621f, 
    -0.27292955f, -0.13227630f, 0.13745229f, -0.08680478f, -0.04710015f, -0.06241676f, 0.12018273f, -0.69926518f, 
    0.07377105f, 0.25810164f, 0.08397923f, -0.01995910f, -0.17894299f, -0.16363727f, -0.30816466f, 0.04449875f, 
    -0.07085726f, 0.01818554f, 0.08332771f, 0.39896113f, -0.02262452f, 0.20804532f, 0.15964435f, 0.11621995f, 
    -0.43435371f, 0.29629490f, 0.10030678f, -0.26039183f, 0.31595159f, -0.06097893f, -0.08730108f, -0.36554271f, 
    0.22436216f, -0.15446414f, -0.10249494f, 0.31210688f, 0.00089293f, -0.03799022f, -0.04843280f, 0.00940780f, 
    -0.07206792f, 0.01478174f, -0.07412177f, -0.06672835f, 0.10357367f, 0.02943319f, -0.33416128f, 0.15049343f, 
    0.18662833f, 0.02014114f, -0.05641337f, -0.35772511f, -0.15629995f, 0.21524562f, -0.02306430f, -0.00286430f, 
    0.22458601f, -0.07716288f, -0.09732199f, 0.13355397f, 0.25876647f, 0.14630076f, 0.41558009f, -0.09726080f, 
    -0.42975605f, -0.08025113f, 0.13230453f, -0.19979039f, -0.14494891f, 0.13343650f, -0.21360703f, 0.33748814f, 
    -0.06866794f, -0.03861237f, -0.11481942f, -0.02208156f, 0.00105476f, -0.17485905f, -0.19568072f, 0.28255823f, 
    -0.01547399f, 0.02787876f, -0.07241921f, -0.26669171f, 0.01515021f, -0.28807718f, -0.09922493f, 0.09389810f, 
    0.06983958f, -0.44698781f, 0.20823522f, 0.00254787f, -0.39342114f, 0.00214701f, -0.13343492f, -0.32857701f, 
    0.19150782f, -0.08259351f, -0.30565923f, -0.49274313f, 0.02171019f, -0.12443904f, -0.46832323f, 0.14788079f, 
    -0.10397091f, 0.23637582f, -0.11713227f, 0.05318398f, 0.16661155f, 0.41009849f, -0.32642046f, 0.05051174f, 
    0.37232512f, 0.16683537f, -0.04967248f, 0.26173452f, 0.14066166f, -0.11863748f, -0.15831909f, 0.02623532f, 
    0.21928151f, 0.10720415f, 0.16899729f, -0.43642488f, -0.16877241f, 0.07145555f, -0.35246751f, -0.05538997f, 
    -0.29587018f, -0.13303462f, 0.37752470f, 0.21378592f, -0.03291376f, 0.10009190f, 0.26457903f, -0.26000795f, 
    -0.14490777f, 0.11239864f, -0.04578161f, -0.00074089f, 0.09633643f, 0.08159180f, -0.21988288f, -0.03859655f, 
    0.21601897f, 0.01805916f, 0.12691416f, 0.02153430f, 0.10008799f, -0.45507529f, 0.05666187f, -0.05910218f, 
    0.27105856f, -0.37882972f, -0.37231177f, 0.16018882f, 0.23120940f, -0.15034474f, 0.40699086f, 0.20307259f, 
    0.06996271f, -0.00984183f, -0.07622329f, -0.17307003f, 0.13627943f, -0.09801687f, 0.18578435f, -0.34935349f, 
    0.02092193f, -0.40943280f, -0.13872860f, -0.02478663f, 0.12782858f, 0.22532499f, 0.03429057f, -0.45278013f, 
    -0.23275998f, 0.15817468f, -0.12597255f, -0.42719913f, 0.08354943f, 0.05177378f, 0.11066811f, 0.16796450f, 
    0.20123282f, 0.31283209f, 0.11723026f, -0.08007513f, -0.73689604f, -0.01665804f, -0.13766874f, 0.20134827f, 
    0.33122510f, 0.12921427f, 0.34989309f, -0.15694910f, 0.12761952f, 0.01048924f, 0.09677584f, 0.18855914f, 
    0.10743999f, -0.01982340f, -0.10558426f, 0.01156073f, 0.08200947f, 0.00841431f, -0.35222492f, 0.23926909f, 
    -0.13743237f, -0.14024466f, -0.16209318f, -0.34400055f, -0.10302667f, -0.24134520f, -0.17359306f, -0.07719879f, 
    0.22714967f, -0.27491754f, -0.46311274f, -0.12680615f, -0.16569321f, -0.17506620f, -0.08170217f, 0.20815828f, 
    0.14850818f, 0.03150917f, -0.21670248f, 0.45696992f, 0.07306433f, -0.09944040f, 0.17589997f, -0.14533344f, 
    0.08388317f, -0.05970059f, -0.13439095f, 0.03800293f, 0.00194411f, -0.38240346f, 0.29861566f, 0.22968552f, 
    0.12023789f, -0.06731092f, -0.15365790f, 0.16676642f, -0.10374723f, -0.23548815f, -0.08604582f, 0.07049758f, 
    0.39738917f, 0.10882509f, 0.31791416f, 0.20348251f, -0.08380958f, 0.17094550f, -0.04275309f, -0.49059349f, 
    -0.09861016f, 0.02108297f, -0.56494343f, -0.10760536f, 0.07895947f, 0.10713690f, 0.02144216f, -0.38497427f, 
    -0.12728983f, -0.42480719f, -0.09007730f, 0.10856130f, 0.13671154f, -0.32327273f, -0.17331091f, 0.24185178f, 
    -0.02047326f, -0.18010336f, -0.08037007f, 0.23157966f, 0.01834834f, 0.04302668f, -0.04581014f, -0.14062314f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18996446f, 0.00687833f, 0.13806115f, 0.14018069f, 0.17714405f, 0.08352683f, 0.08337434f, -0.05470204f, 
    0.03129286f, -0.00430425f, 0.07883611f, -0.04168977f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
