#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.11626720f, 0.25893342f, 0.13065574f, 0.28494555f, 1.00867057f, 0.33913481f, 0.18060622f, 0.32514045f, 
    0.16702768f, 0.36823663f, -0.32183221f, -0.02333887f, -0.24703337f, -0.03322779f, 0.15020144f, -0.06728344f, 
    -0.28794104f, -0.06611604f, 0.05912307f, -0.04859092f, 0.04558544f, -0.01136538f, -0.22434546f, 0.02008688f, 
    -0.13872367f, 0.10747530f, 0.99637079f, 0.03385371f, -0.40550366f, -0.77410740f, -0.21029416f, 0.34968704f, 
    -0.47127375f, -0.49998072f, -0.03965729f, 0.23753728f, 0.41235855f, -0.03026090f, -0.02122401f, -0.11819865f, 
    0.13849765f, 0.04169533f, 0.24177906f, 0.09799763f, -0.16801171f, -0.01612655f, 0.15359417f, 0.16634315f, 
    -0.28130281f, 0.10183235f, 0.06705848f, 0.17386407f, -0.48361149f, -0.29256943f, -0.22161447f, 0.32766977f, 
    -0.55760205f, 0.16123129f, 0.53705531f, -0.48160750f, -0.10435589f, -0.67535424f, -0.00688047f, 0.13765703f, 
    0.36013409f, 0.26496023f, -0.24448454f, -0.13345557f, 0.01823553f, 0.12993494f, -0.18214270f, 0.17610101f, 
    -0.30512267f, 0.11026809f, 0.20466337f, -0.43628559f, -0.66801155f, 0.05452453f, -0.47663057f, -0.76971960f, 
    0.15975590f, 0.07430597f, 0.40734431f, -0.56266797f, 0.01432389f, 0.28818762f, -0.01935981f, -0.05585707f, 
    -0.02530470f, 0.09061923f, 0.04788034f, 0.16100606f, -0.00095017f, -0.18696755f, 0.10090492f, -0.19362339f, 
    0.09910738f, -0.01704283f, -0.05784380f, -0.05257472f, 0.10330860f, -0.65827221f, -0.75753051f, -0.62441498f, 
    0.04243547f, 0.32153702f, 0.56493235f, -0.07529663f, 0.16984089f, 0.14985153f, -0.09409721f, -0.02900097f, 
    -0.33226699f, 0.30354297f, -0.29394066f, -0.02435668f, 0.25974181f, 0.12754388f, -0.10530309f, 0.19250526f, 
    0.36524069f, 0.19113432f, -0.38568184f, -0.02125789f, 0.24816458f, 1.00035179f, 0.69879270f, -0.08131243f, 
    -0.48463011f, -0.51676315f, -0.02947168f, 0.40120867f, 0.26298106f, 0.25546408f, 0.60949671f, 0.01572473f, 
    0.04498774f, -0.04337537f, -0.27522406f, 0.07046730f, 0.02757537f, -0.10623199f, -0.04357564f, -0.03754098f, 
    0.15688032f, 0.24761574f, -0.09619281f, -0.19962256f, 0.07330242f, -0.11621497f, -0.90247357f, 0.91733700f, 
    -0.10266161f, -0.63751698f, 0.32507336f, -0.59432530f, 0.17918710f, 0.52882624f, -0.31629786f, -0.49755833f, 
    -0.09300228f, 0.13874836f, -0.13392933f, 0.02061872f, -0.01452616f, 0.05836556f, -0.05671464f, 0.00205323f, 
    -0.15206213f, -0.20510195f, -0.05697595f, 0.06711960f, 0.09760352f, 0.17064641f, 0.15275516f, 0.75785112f, 
    0.40181300f, -1.15357029f, -0.69353056f, -0.33589157f, 0.29163945f, -0.23934688f, 0.09429246f, 0.08660083f, 
    -0.29290041f, -0.25960276f, 0.25319317f, 0.34775570f, 0.27142733f, -0.05910922f, -0.00714761f, -0.03646857f, 
    -0.20490322f, -0.06324225f, 0.03880284f, 0.00017710f, 0.06584847f, 0.07420026f, -0.05934282f, 0.21301922f, 
    0.51770890f, 0.86242801f, 0.82099968f, 0.11625291f, 0.36170051f, -0.43727410f, 0.13742782f, -0.07034734f, 
    -0.62905890f, 0.41379288f, 0.11930037f, 0.44963586f, 0.24972109f, 0.28291813f, -0.06684636f, -0.15363075f, 
    -0.29734921f, -0.04874886f, 0.07047985f, -0.12755081f, 0.00879518f, 0.13361146f, -0.02541133f, -0.04295294f, 
    0.07564131f, -0.71868491f, -0.54432291f, -0.47728127f, -0.26900434f, -0.55043811f, 0.59240484f, 0.93192232f, 
    0.08283463f, 0.37534609f, 0.51751828f, -0.10946145f, -0.24174391f, 0.18073158f, -0.33090287f, -0.16088460f, 
    -0.00118479f, -0.04991269f, 0.12880993f, -0.13457397f, -0.18323433f, -0.14879410f, -0.28587699f, 0.01588966f, 
    -0.19021523f, 0.04641636f, -0.62784898f, 0.08803607f, -0.18215050f, 0.20681022f, 0.20772389f, 0.05310068f, 
    0.83659667f, 0.25388163f, -0.08968445f, -0.07565718f, 0.19454786f, -0.26130813f, 0.19612263f, -0.03724676f, 
    0.28327891f, -0.32887122f, -0.40788132f, -0.35747162f, -0.15089133f, -0.08324780f, 0.21490483f, 0.27706876f, 
    0.23424377f, 0.43825144f, -0.25540188f, 0.64230019f, -0.13793503f, 0.59859663f, 0.93073756f, 0.55638707f, 
    0.57177216f, 0.26550722f, -0.05238790f, 0.20512705f, 0.00864603f, 0.06206651f, 0.14088579f, -0.07200745f, 
    0.15428013f, -0.24180450f, 0.15559152f, 0.02866050f, 0.19068128f, 0.26503721f, -0.03799803f, 0.22405384f, 
    0.14036968f, 0.15602130f, -0.03989481f, 0.19958879f, -0.14068478f, 0.33478057f, -0.49118623f, 0.24843921f, 
    0.22281760f, -0.45557910f, -0.11569303f, 0.85521019f, 0.42936435f, 0.23111187f, -0.05785706f, 0.11437782f, 
    -0.38425305f, -0.24482016f, -0.68181145f, -0.34503791f, -0.09212336f, -0.18607178f, 0.09033981f, -0.18077204f, 
    0.08816364f, 0.03570802f, -0.11096654f, -0.31330797f, 0.05308533f, 0.03993321f, 0.51842463f, 0.71681100f, 
    0.33282652f, 0.13289487f, 0.50198293f, -0.13729720f, -0.89707857f, -0.39279070f, -0.54877996f, -0.08353001f, 
    -0.15978056f, -0.24379919f, -0.18237168f, -0.31429517f, 0.07934904f, 0.04790397f, -0.23419663f, -0.32043678f, 
    -0.17041339f, -0.05694739f, 0.05994829f, 0.03101846f, -0.09835106f, -0.03271826f, 0.66215271f, -0.37487739f, 
    -0.11837073f, -0.34961879f, -0.08929890f, -0.05138781f, -0.44170773f, 0.08182479f, -0.23546159f, 0.22231591f, 
    -0.41793346f, 0.07003745f, -0.20740932f, -0.35545978f, -0.30026147f, -0.46183497f, -0.28973153f, -0.45245251f, 
    -0.33073702f, -0.17837596f, 0.00461887f, -0.03312736f, 0.09575622f, -0.22403847f, -0.41680452f, -0.42691165f, 
    -0.85060978f, -0.49363497f, -0.02352369f, -0.30853474f, -0.63796735f, 0.42060497f, 0.23135403f, -0.60189217f, 
    0.14647023f, 0.44967017f, 0.56763631f, 0.28049970f, 0.36029983f, 0.37569669f, -0.22376597f, 0.19143520f, 
    0.02581058f, 0.10829969f, -0.00287516f, 0.09602439f, -0.18694390f, -0.10708952f, 0.02260438f, 0.09867384f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17902368f, -0.03045333f, 0.09739196f, 0.17291494f, 0.32465586f, 0.29611883f, 0.25157011f, 0.13276601f, 
    -0.07201627f, -0.05292459f, 0.18062326f, 0.19016294f, -0.02065535f, -0.03732552f, -0.02846322f, 0.12345842f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29619932f, -0.20716310f, 0.21519776f, 0.17192763f, -0.00454564f, 0.08051450f, 0.11105153f, 0.03236884f, 
    0.05860084f, 0.04457009f, -0.04808301f, 0.04694418f, -0.12499655f, -0.08344775f, -0.09422110f, -0.19046584f, 
    -0.02168267f, 0.08490694f, 0.12138788f, 0.05430750f, 0.02897830f, 0.11604244f, 0.02562019f, 0.02059880f, 
    -0.03641538f, -0.07068542f, 0.02882856f, -0.06065959f, -0.08186328f, 0.00507307f, 0.03778218f, -0.03028722f, 
    0.11171828f, 0.12935281f, -0.06623136f, 0.02378994f, -0.06912148f, 0.02130085f, 0.08384173f, -0.00621496f, 
    0.03508027f, 0.04008674f, 0.08546147f, 0.09459897f, -0.02977719f, -0.05677833f, -0.02848158f, 0.04417300f, 
    -0.06561102f, -0.07199656f, -0.04104577f, -0.13706052f, 0.05626813f, 0.01940417f, -0.01130872f, 0.06857613f, 
    0.08920147f, 0.08472463f, 0.10818084f, -0.06249630f, 0.06937869f, 0.03268155f, 0.05382230f, 0.06737792f, 
    0.05162252f, -0.05660948f, -0.05938490f, 0.04707281f, 0.01858473f, 0.04564507f, 0.00845078f, 0.09965998f, 
    -0.05460729f, 0.20403251f, -0.16274652f, -0.39636704f, -0.03688165f, -0.02154759f, 0.10263438f, 0.05068313f, 
    0.02356882f, 0.03502193f, -0.01051983f, 0.05940121f, 0.21994874f, -0.33106413f, -0.01362642f, -0.16568542f, 
    -0.10880900f, -0.05984847f, 0.13786094f, -0.01224714f, -0.05955849f, -0.01174705f, 0.00822469f, -0.04534769f, 
    -0.17780569f, 0.07203887f, 0.07236397f, 0.03823778f, -0.07258539f, -0.10659661f, 0.05469076f, -0.00424729f, 
    0.05126696f, -0.03729551f, -0.07944643f, -0.03216182f, -0.07263273f, -0.13195145f, 0.02094093f, -0.05485547f, 
    -0.01813293f, 0.06751651f, 0.00022138f, -0.00315131f, 0.02916634f, 0.01757555f, 0.07327842f, 0.21311958f, 
    0.15922374f, 0.06208292f, -0.05478210f, 0.10863282f, 0.04707734f, 0.14945273f, -0.02940868f, -0.13655907f, 
    -0.05514835f, -0.04515093f, -0.06907840f, 0.03494794f, 0.31029290f, 0.11351004f, 0.09950737f, 0.22428752f, 
    -0.13309617f, 0.05641294f, -0.01663772f, 0.10346580f, 0.04959433f, 0.00806180f, 0.11866737f, -0.04090704f, 
    0.01939007f, -0.03557413f, 0.19245198f, 0.08352102f, -0.05036852f, 0.09092669f, 0.14193910f, 0.09511086f, 
    -0.06189134f, -0.13186665f, -0.03568460f, 0.04027277f, 0.02802161f, 0.13595751f, 0.23182756f, -0.04213318f, 
    0.07584083f, 0.09721822f, 0.08257207f, 0.06146633f, -0.03903258f, -0.02633457f, 0.03636884f, 0.00724742f, 
    0.00002366f, -0.01445665f, 0.17465357f, -0.10471264f, -0.05430567f, 0.00184863f, 0.08902115f, -0.01886973f, 
    -0.03631715f, -0.00300173f, -0.08246884f, 0.00279076f, -0.22596310f, -0.04551065f, -0.01303174f, 0.02864126f, 
    -0.09754004f, 0.02233469f, 0.02371984f, 0.03652080f, 0.11605569f, 0.03717570f, -0.00122959f, 0.06722715f, 
    0.05028266f, 0.02864780f, 0.02067003f, -0.05725070f, -0.04053343f, 0.03078321f, 0.04817747f, -0.01302530f, 
    -0.03958495f, 0.00064490f, -0.01558038f, 0.02036685f, 0.02771944f, 0.01597806f, 0.00104808f, -0.03744291f, 
    0.04388221f, 0.04104190f, -0.02398880f, 0.00649248f, -0.03403318f, -0.00647640f, -0.04275146f, -0.00260558f, 
    0.00983732f, -0.07646897f, -0.00862728f, -0.03477863f, -0.04993361f, -0.04034281f, -0.07541099f, 0.03296186f, 
    -0.04371563f, 0.03724570f, -0.09052008f, 0.03268436f, -0.02928429f, 0.05630776f, -0.04492997f, -0.01079190f, 
    0.03815762f, -0.07512414f, -0.05902452f, 0.05416006f, 0.03193177f, 0.04656064f, 0.02837948f, -0.02781381f, 
    -0.01119737f, 0.06509519f, -0.05294752f, 0.01947400f, -0.01964497f, 0.01520789f, -0.00706205f, -0.04976335f, 
    0.04110983f, -0.01706794f, -0.00817046f, -0.02676343f, 0.05556241f, 0.00552955f, -0.04690501f, -0.08138303f, 
    0.05352085f, -0.05333476f, 0.01077058f, -0.08056596f, 0.04716080f, 0.04540249f, -0.01034068f, -0.01866181f, 
    -0.02317922f, 0.03120971f, -0.03104720f, 0.04877233f, -0.08667619f, -0.06805430f, -0.01043059f, -0.01463597f, 
    0.04764478f, 0.00893366f, 0.06075564f, 0.04578518f, -0.01110441f, -0.03836989f, 0.02192429f, -0.02440817f, 
    -0.03613092f, -0.08265183f, 0.04140617f, 0.03386814f, -0.04140576f, 0.00570792f, -0.04019322f, -0.04738273f, 
    0.00487486f, 0.02945120f, -0.00398618f, -0.07605468f, 0.05173680f, -0.06948651f, -0.08196067f, 0.05792847f, 
    -0.06910946f, 0.04498720f, -0.00642894f, -0.06131849f, -0.04095128f, 0.04025104f, -0.03581108f, -0.03046615f, 
    0.03265058f, 0.03001032f, -0.08817305f, -0.04153952f, -0.05831719f, -0.02683751f, 0.03168456f, 0.03702349f, 
    0.06024456f, -0.07915469f, 0.05078094f, 0.05050578f, 0.00983426f, -0.00152728f, 0.04871587f, -0.04381150f, 
    0.05262771f, 0.03453607f, -0.05645094f, 0.05116961f, -0.04532740f, -0.01936407f, -0.01499581f, -0.00124308f, 
    0.01341500f, 0.03198960f, -0.03563114f, 0.06748050f, -0.07630523f, -0.02082253f, 0.01882236f, -0.01473896f, 
    -0.04903298f, -0.03480471f, -0.00324660f, -0.03604113f, 0.07495120f, -0.04046652f, -0.04933710f, -0.05467806f, 
    -0.02016746f, -0.04398249f, 0.01065451f, 0.03706515f, 0.05689070f, 0.00254095f, -0.05770549f, 0.04243559f, 
    0.04634336f, -0.06847040f, -0.03194461f, -0.01839134f, -0.02268161f, 0.05249251f, -0.01530162f, -0.05714538f, 
    -0.01539754f, -0.07773101f, -0.04458812f, 0.03471460f, -0.09031125f, 0.02384444f, -0.04139408f, -0.02852767f, 
    -0.06115048f, 0.00483243f, -0.09107751f, 0.01120498f, -0.00828860f, -0.00834538f, 0.00811312f, -0.04017464f, 
    0.03829780f, 0.03000127f, -0.00095827f, -0.07139236f, -0.02500007f, -0.02390359f, -0.04542171f, -0.00944830f, 
    -0.13674219f, -0.08489737f, -0.02638524f, -0.00209086f, -0.12946342f, 0.05533586f, -0.05257641f, -0.14317563f, 
    0.05073455f, -0.03141263f, -0.19407715f, -0.14399101f, 0.08418538f, 0.06656458f, -0.25795147f, 0.14166386f, 
    -0.10165333f, -0.10193436f, -0.18278934f, -0.26728475f, 0.05502295f, 0.00304170f, 0.12836899f, -0.05236270f, 
    0.09952957f, 0.18434516f, 0.08940478f, 0.05553216f, 0.09549166f, 0.07728305f, -0.09086262f, -0.07964603f, 
    -0.07782550f, 0.16967934f, 0.08088335f, 0.02935643f, 0.25943297f, 0.05658260f, 0.08641130f, -0.00777256f, 
    0.18586026f, 0.04904668f, 0.23967543f, -0.08394934f, 0.12692183f, 0.17081258f, -0.05523259f, 0.05875376f, 
    0.36554497f, 0.07462353f, -0.04561896f, 0.20818880f, 0.06062724f, 0.23255713f, 0.07388206f, 0.09217675f, 
    0.10880543f, 0.03416816f, 0.02034869f, 0.11795158f, 0.14049435f, -0.16359736f, -0.19591975f, 0.04452927f, 
    0.05774417f, 0.13164935f, -0.13996650f, -0.15713713f, -0.04378834f, -0.11938637f, -0.09571970f, 0.01635879f, 
    0.08578198f, -0.13739344f, 0.40518761f, 0.02968450f, 0.03088320f, 0.12903588f, -0.05693495f, 0.00493233f, 
    -0.00651330f, 0.02741486f, -0.13839914f, 0.00738878f, 0.06426914f, 0.16473953f, -0.22714521f, 0.15018743f, 
    -0.10250710f, 0.16881816f, -0.02833621f, -0.06212830f, 0.05125243f, -0.09957728f, 0.08451564f, -0.07390426f, 
    -0.06011756f, -0.16832130f, -0.17192173f, 0.12829003f, 0.10206642f, -0.00732583f, -0.01240606f, 0.02246791f, 
    -0.00361977f, -0.04729577f, 0.05492871f, 0.03985614f, 0.05462786f, 0.25648016f, 0.05891950f, 0.06425346f, 
    -0.02706725f, 0.13624620f, 0.12063967f, -0.22750758f, -0.01082203f, -0.07413881f, 0.09804431f, -0.10907317f, 
    -0.18470804f, -0.13727865f, -0.07992420f, 0.00615999f, 0.02158804f, 0.07042809f, 0.19052812f, 0.16329330f, 
    -0.00101211f, 0.06872955f, -0.04419913f, -0.16064285f, -0.33139628f, -0.11647405f, -0.09010942f, -0.04387298f, 
    -0.01533124f, -0.03100448f, -0.01672829f, 0.01309608f, 0.14903317f, -0.09774730f, 0.09414685f, 0.00281060f, 
    0.13837622f, -0.19483827f, -0.04607626f, -0.04534630f, 0.03072627f, -0.08150152f, -0.12396648f, 0.00067357f, 
    0.01072600f, -0.02000742f, -0.12771647f, -0.02531465f, -0.21812564f, -0.05396004f, 0.06485007f, 0.17430051f, 
    -0.07547594f, -0.12247188f, 0.08603815f, -0.04852168f, 0.06009487f, 0.04986104f, 0.00943986f, -0.16776344f, 
    0.19373241f, -0.03595052f, 0.15281877f, 0.21010169f, -0.09822893f, -0.02384185f, 0.15711497f, -0.08405580f, 
    0.11456483f, -0.13676091f, -0.16484556f, -0.32551405f, 0.12186483f, 0.16185308f, 0.13295646f, -0.04765531f, 
    0.08079239f, 0.10773554f, -0.03224818f, -0.01712393f, 0.00366420f, 0.13338168f, 0.00006499f, 0.16354173f, 
    0.01603317f, -0.07351809f, 0.21920303f, 0.09723547f, -0.10288071f, -0.02862734f, 0.02103978f, 0.14696932f, 
    0.03934761f, 0.01272775f, 0.00635826f, 0.09454629f, 0.13316146f, 0.07179063f, -0.14024329f, 0.07524782f, 
    0.06548928f, 0.08266618f, 0.07808445f, 0.03939094f, -0.01863849f, 0.05074720f, -0.17658794f, 0.03240627f, 
    0.02850012f, -0.12219610f, 0.14056116f, 0.01715393f, -0.00635857f, 0.02040670f, 0.05555900f, -0.00815989f, 
    0.06288127f, 0.02957992f, 0.03557289f, 0.04116837f, -0.08401754f, -0.07045893f, -0.05520963f, -0.28095251f, 
    -0.03668315f, 0.13866463f, 0.06922770f, -0.02358396f, -0.01762444f, -0.02039114f, 0.05783876f, 0.00286947f, 
    -0.20799719f, 0.05281981f, 0.00112932f, -0.23513830f, 0.06327359f, -0.00410407f, 0.10178923f, 0.01578035f, 
    0.00232191f, -0.07875617f, 0.06823445f, -0.04254298f, -0.27047729f, 0.14427334f, -0.12206020f, 0.20550542f, 
    0.05216894f, 0.04773900f, -0.01137229f, 0.01188166f, 0.01250339f, -0.02015560f, 0.02239346f, -0.04191692f, 
    -0.36486042f, 0.30270016f, 0.05052599f, -0.15187268f, -0.01958747f, -0.07131405f, -0.00132550f, 0.02736035f, 
    -0.00963207f, 0.03736074f, 0.15212069f, 0.01211892f, 0.15965661f, -0.03122361f, -0.11145516f, -0.05793419f, 
    0.04881808f, 0.07351774f, -0.01875817f, 0.02653685f, 0.09496172f, 0.02766839f, -0.04082184f, -0.00968336f, 
    0.09945730f, 0.15819283f, -0.01663606f, -0.00732527f, 0.07325147f, -0.03874360f, -0.09100557f, 0.02901090f, 
    0.10152191f, 0.03050145f, 0.08606383f, -0.02358356f, -0.02505881f, -0.30998114f, 0.04024252f, -0.25419995f, 
    -0.07381212f, 0.05410796f, 0.03289503f, 0.03446688f, -0.05326791f, 0.08847855f, -0.01785840f, 0.21315621f, 
    -0.00943736f, -0.00121974f, 0.02636655f, 0.12381098f, 0.06457833f, -0.05300273f, 0.01224748f, -0.12053421f, 
    -0.03260460f, -0.11164209f, -0.00188224f, 0.13798222f, 0.30184579f, -0.07714003f, 0.11590277f, 0.11234069f, 
    -0.13084319f, -0.01473359f, -0.04503725f, -0.06537287f, 0.06519907f, -0.03771579f, -0.02071021f, 0.02008948f, 
    -0.27161890f, 0.09098739f, 0.05839467f, 0.01136521f, 0.14502095f, 0.05243957f, 0.08645561f, 0.08180305f, 
    -0.07948141f, 0.01622961f, 0.15970267f, 0.05380202f, 0.30251542f, 0.10122588f, 0.05229129f, -0.18514697f, 
    0.09105912f, -0.05263574f, -0.01019252f, 0.08169069f, 0.03817765f, -0.06762476f, 0.00633832f, 0.03197080f, 
    -0.13314649f, 0.10200886f, 0.06717498f, -0.19673219f, -0.02130519f, -0.04077043f, 0.03714728f, 0.02811133f, 
    0.07454223f, 0.15495706f, 0.19857125f, 0.12597938f, -0.38726413f, -0.00603890f, 0.09358832f, -0.05781074f, 
    0.07821035f, 0.03613435f, 0.12447166f, -0.04776809f, 0.05517686f, 0.05016525f, 0.08877288f, 0.01054322f, 
    -0.28294611f, 0.21248697f, 0.07692496f, 0.00378907f, -0.00237972f, -0.00010619f, 0.01606772f, 0.06656021f, 
    0.00094931f, 0.04516158f, 0.03324417f, 0.13857311f, 0.19786972f, 0.06844374f, -0.12344115f, 0.25791392f, 
    -0.10046148f, 0.04845138f, -0.00826809f, 0.10185196f, 0.00001391f, -0.01649375f, 0.10957456f, 0.03599642f, 
    -0.21718587f, -0.08645571f, 0.03325696f, 0.06998438f, -0.04299346f, 0.12616749f, -0.09018220f, 0.08965718f, 
    -0.00898016f, 0.02030921f, -0.03269889f, 0.05078067f, -0.06046717f, -0.11635770f, -0.08730983f, -0.11306544f, 
    -0.18966955f, -0.03229358f, 0.06066546f, -0.05257201f, 0.04161578f, 0.09423241f, 0.03487701f, -0.04571993f, 
    0.04195832f, 0.01559241f, -0.08479560f, -0.17074302f, 0.06938154f, 0.15521403f, -0.00515390f, -0.10387096f, 
    -0.05900231f, 0.07014717f, -0.01643403f, -0.00821846f, -0.00960113f, 0.39324668f, 0.06304625f, 0.11997104f, 
    0.10675315f, 0.05958585f, -0.05406124f, 0.11732358f, 0.11077893f, 0.06065388f, 0.02884521f, 0.02840225f, 
    -0.22611521f, 0.05220244f, -0.05360182f, -0.08414931f, 0.03983084f, 0.07584529f, -0.02882218f, 0.08100905f, 
    -0.03336162f, 0.09142629f, 0.00680173f, 0.04773817f, -0.08703490f, 0.00907417f, 0.19288623f, 0.12736510f, 
    0.10403427f, -0.05150003f, -0.03167412f, 0.05057739f, 0.17325127f, -0.01745986f, -0.01518140f, 0.10833628f, 
    0.37556332f, 0.14626163f, -0.00868251f, -0.01115536f, 0.03044713f, 0.15999003f, -0.04338153f, -0.01260488f, 
    0.09482520f, 0.12567854f, 0.01163211f, -0.10327694f, 0.00627145f, -0.25403509f, -0.22000737f, -0.18802601f, 
    -0.01155099f, 0.09684893f, 0.03708136f, -0.01493570f, -0.01240304f, -0.04887259f, -0.11634967f, 0.10110875f, 
    0.11999077f, -0.18382642f, 0.08745173f, 0.22049923f, 0.02437406f, -0.03408456f, -0.06473775f, 0.02064774f, 
    0.02919914f, 0.00041356f, 0.10586969f, 0.02248792f, 0.17958605f, -0.15938538f, 0.11090888f, -0.06530136f, 
    0.01087330f, -0.04109383f, -0.06829177f, -0.02250609f, 0.03072738f, 0.07239351f, 0.10035773f, 0.09065448f, 
    -0.36431149f, 0.15391849f, 0.01125063f, -0.05629575f, 0.12770917f, -0.01219529f, -0.11278381f, 0.03968561f, 
    0.00613008f, 0.06358972f, -0.06239923f, 0.12934585f, 0.35228410f, -0.11459488f, -0.19837150f, 0.00140404f, 
    0.05797772f, -0.05856402f, -0.01365691f, -0.01877351f, 0.02824245f, 0.04509155f, 0.07248478f, -0.14382789f, 
    -0.00692233f, 0.24705103f, -0.06178981f, -0.04198293f, -0.02399245f, -0.10596997f, -0.02583890f, 0.01847520f, 
    0.18000896f, 0.08379915f, 0.18458197f, 0.08796048f, -0.06471973f, -0.00893662f, -0.07227715f, -0.05230173f, 
    0.09814488f, 0.02694433f, 0.14182681f, -0.06643007f, -0.02025848f, -0.06336400f, 0.03861735f, 0.00889455f, 
    0.06751160f, 0.17334193f, 0.24089223f, 0.09940479f, 0.06270849f, 0.00634907f, 0.06510156f, -0.03212890f, 
    0.03170941f, -0.02595892f, 0.01235501f, 0.12108265f, 0.13760573f, 0.00172286f, -0.12589714f, -0.01384351f, 
    0.00992903f, -0.02491916f, -0.04910192f, 0.05856998f, 0.02382302f, -0.10816145f, 0.07710213f, 0.08329008f, 
    -0.30819142f, 0.05164276f, -0.01840173f, 0.14865939f, -0.12814462f, 0.00706523f, -0.09963237f, 0.11640435f, 
    -0.10097790f, 0.01029286f, 0.05178329f, 0.09889429f, -0.19407700f, 0.08927457f, -0.21012896f, 0.07577944f, 
    -0.10560096f, -0.05360460f, 0.08820131f, 0.02087595f, -0.00431468f, 0.01576561f, -0.04174482f, -0.08021088f, 
    -0.03264188f, -0.06029642f, 0.16172870f, -0.16560104f, 0.07550461f, 0.03806766f, -0.10648584f, -0.02029361f, 
    0.09665563f, -0.02522801f, 0.06248916f, 0.05626092f, 0.02692855f, 0.40771663f, -0.06489869f, 0.20392664f, 
    0.01110492f, -0.07329564f, 0.03168957f, 0.00583503f, 0.01913113f, -0.03376331f, 0.05881817f, -0.03276272f, 
    -0.13469659f, -0.09375019f, -0.05710001f, -0.30096343f, 0.09607919f, 0.14207707f, -0.11056468f, -0.12706259f, 
    0.06089357f, 0.02584139f, 0.02215918f, 0.10267311f, 0.05957162f, 0.06530489f, -0.07886108f, -0.01374416f, 
    0.10737413f, -0.17712703f, 0.06892373f, -0.05770055f, 0.12057891f, -0.03209301f, 0.09043830f, 0.14598578f, 
    0.49965265f, 0.27001357f, -0.11624027f, -0.14399585f, 0.02728810f, 0.17348894f, 0.03917179f, 0.00734427f, 
    0.13847490f, 0.06449266f, -0.01322573f, 0.00965720f, 0.27029985f, -0.19955270f, -0.10957088f, -0.03520197f, 
    -0.12451552f, -0.07097384f, -0.08893809f, 0.07355922f, -0.01179995f, 0.10436824f, -0.04051794f, 0.05267369f, 
    0.33525780f, -0.09472319f, 0.06792484f, 0.22367536f, 0.05972617f, 0.07642670f, -0.00930774f, -0.09653860f, 
    -0.03575503f, -0.03278958f, 0.10174124f, -0.05369217f, 0.15015395f, -0.03589089f, 0.12349659f, 0.01358349f, 
    -0.08277439f, 0.02107199f, 0.00101936f, -0.06178237f, -0.04741204f, 0.00997829f, 0.05973652f, -0.00150294f, 
    -0.21572161f, -0.02685093f, 0.02847593f, 0.05758468f, 0.13220657f, -0.03354802f, 0.06001121f, 0.01342305f, 
    0.07264520f, -0.11435949f, 0.01937138f, 0.12144584f, 0.05999664f, -0.15901379f, -0.18321720f, -0.12829827f, 
    0.10964081f, -0.01252640f, 0.06735776f, 0.00569745f, 0.04910288f, 0.00655493f, 0.06083212f, -0.05402118f, 
    -0.09882231f, -0.03988851f, -0.14882430f, -0.08234071f, -0.01720358f, -0.00222163f, 0.02108133f, -0.06832142f, 
    0.14219309f, 0.03433433f, -0.01872546f, -0.01141478f, 0.35926977f, -0.02901636f, -0.04456795f, -0.03952948f, 
    -0.16436082f, 0.08624843f, -0.01145764f, -0.03313853f, 0.05460746f, -0.09124076f, 0.07566669f, -0.04637786f, 
    0.03510043f, 0.01659485f, 0.03683219f, -0.03579619f, 0.02891031f, 0.08522213f, 0.06564495f, 0.07173849f, 
    0.05763602f, -0.04691072f, 0.11291060f, -0.00707052f, 0.01796777f, -0.15441994f, 0.34737661f, 0.07439741f, 
    0.03194173f, 0.12818767f, 0.03364116f, 0.03922829f, 0.00941219f, -0.02204236f, -0.22186202f, -0.05983706f, 
    0.32066023f, 0.06729566f, -0.05046110f, 0.20122309f, 0.03614657f, -0.05600770f, 0.00899450f, -0.04008841f, 
    0.14547038f, -0.16501644f, 0.08209124f, -0.01272260f, -0.10821071f, -0.04737483f, -0.02581700f, -0.01550739f, 
    0.04584226f, 0.13591270f, -0.09175888f, 0.09500986f, 0.06712868f, -0.08898692f, 0.18843868f, -0.06063395f, 
    -0.19657618f, 0.03425571f, 0.02106393f, 0.01254496f, 0.00395411f, -0.10104218f, 0.26775759f, -0.07915384f, 
    -0.01429593f, -0.09103897f, -0.02387018f, 0.08911883f, -0.18231460f, -0.07538766f, 0.04241501f, -0.03779191f, 
    -0.04156833f, 0.03985079f, 0.07939736f, 0.09177905f, 0.09625174f, -0.03150238f, 0.05141422f, -0.00502693f, 
    -0.00558999f, 0.13392994f, 0.07829620f, 0.28941128f, -0.12901326f, -0.20574895f, 0.02471231f, -0.01549154f, 
    -0.07217476f, -0.08545714f, 0.13285783f, -0.16363803f, 0.00850612f, -0.03448272f, -0.17125037f, 0.11290070f, 
    0.03871409f, -0.03176658f, 0.02528886f, -0.15460618f, 0.02637179f, 0.03565601f, -0.12698250f, 0.03611436f, 
    0.01962541f, -0.01097715f, 0.11777034f, -0.01943239f, -0.08485540f, -0.06111312f, -0.06715066f, -0.00881396f, 
    0.01005026f, 0.03628143f, -0.04679308f, 0.04942803f, -0.13297834f, 0.05245556f, -0.05025598f, 0.07107703f, 
    0.15738881f, 0.17400324f, -0.03150228f, 0.09872945f, -0.01455339f, 0.09821004f, 0.00467143f, 0.05247943f, 
    -0.29650646f, -0.01763465f, 0.08081087f, -0.20810145f, 0.11314575f, -0.02690574f, -0.00591031f, 0.03034969f, 
    0.00080018f, -0.07699513f, 0.11017342f, 0.18814170f, 0.06218763f, 0.00429251f, -0.03193269f, -0.03865939f, 
    0.02954272f, 0.13342211f, 0.12499920f, 0.11348237f, 0.00003871f, 0.10207318f, -0.22104076f, -0.06381981f, 
    0.05871470f, 0.17588648f, 0.12877101f, -0.14776318f, 0.00109275f, 0.17151786f, 0.08273914f, -0.00455391f, 
    -0.08155847f, 0.05118862f, 0.16324675f, -0.03181703f, 0.20457497f, 0.04459861f, 0.11491269f, 0.15112942f, 
    -0.13592099f, 0.06184625f, 0.06508315f, 0.07252558f, -0.03513652f, 0.10004638f, -0.03890842f, 0.07420812f, 
    0.04827302f, -0.03721349f, 0.03517905f, -0.07538377f, 0.12038070f, 0.00519378f, -0.05030291f, 0.02526311f, 
    -0.08593595f, 0.06927384f, 0.16866416f, 0.32763046f, -0.30012000f, 0.00340035f, 0.11801154f, 0.09498668f, 
    0.11675478f, 0.04828826f, 0.00407482f, 0.00215595f, -0.02963390f, 0.02044188f, -0.10195569f, -0.07410526f, 
    -0.06543379f, -0.01563630f, 0.03462244f, 0.02877209f, -0.06720956f, -0.07891513f, 0.04775478f, 0.04448689f, 
    0.01781521f, -0.00648499f, -0.02894068f, -0.05238746f, -0.06885543f, -0.02955668f, -0.07650718f, -0.03826064f, 
    0.05597131f, -0.03744968f, 0.00647811f, -0.03213296f, 0.00728500f, -0.02016761f, 0.02346454f, -0.02909379f, 
    -0.04813461f, 0.04089690f, -0.00303541f, -0.05242473f, 0.00730062f, -0.02392901f, 0.01073941f, -0.04266617f, 
    0.00869296f, -0.01468204f, -0.03708455f, 0.00030431f, -0.06711005f, 0.03237780f, 0.05265397f, -0.06703752f, 
    -0.04476561f, -0.06663290f, -0.06137004f, 0.04103870f, -0.00043954f, -0.04403271f, -0.03193988f, 0.03591899f, 
    -0.05160623f, -0.06519805f, 0.03784769f, -0.07393486f, -0.02448827f, 0.01040189f, -0.07548691f, -0.06480253f, 
    -0.01036634f, -0.02006431f, 0.00952327f, 0.01650036f, -0.04713543f, -0.02588299f, -0.02996057f, 0.02017948f, 
    -0.03759389f, -0.02856668f, 0.00032283f, 0.02220301f, 0.05196242f, -0.04107478f, -0.00568350f, 0.03378762f, 
    -0.02148337f, -0.06617520f, 0.00602779f, 0.02114457f, 0.04878124f, -0.02902778f, -0.05519575f, -0.07050069f, 
    -0.07695886f, 0.05771840f, 0.05075870f, 0.02023949f, -0.03942577f, -0.03284452f, -0.06426127f, 0.01665118f, 
    0.04535988f, 0.00072477f, 0.05934458f, 0.04563878f, -0.05389574f, -0.03620038f, -0.01303041f, 0.00020909f, 
    -0.01531615f, -0.05565765f, 0.05173307f, 0.00237831f, -0.03373069f, 0.01633077f, -0.03258322f, -0.04816939f, 
    -0.02071891f, 0.01379802f, 0.01223312f, 0.01663156f, 0.03741036f, 0.02731864f, -0.02034631f, -0.01072348f, 
    -0.01673480f, -0.00164484f, 0.00608394f, -0.04544065f, -0.01001239f, 0.04857158f, -0.02523733f, -0.06709844f, 
    -0.00130541f, 0.05011638f, 0.05076541f, -0.05213052f, -0.01059295f, 0.04521196f, 0.03620148f, 0.03993924f, 
    0.06059993f, -0.00252491f, 0.03737300f, -0.04267679f, -0.01761838f, 0.04881273f, 0.05212512f, 0.02052606f, 
    -0.07115750f, 0.04258920f, -0.02364013f, 0.00610999f, -0.07205013f, -0.03999144f, -0.02829989f, 0.03818997f, 
    -0.03169167f, -0.05123622f, 0.02155744f, 0.03602231f, -0.04797494f, -0.03929644f, -0.05446213f, -0.04881472f, 
    -0.02915886f, 0.05305365f, 0.02199080f, -0.01226589f, -0.00980562f, -0.05296162f, -0.06750255f, -0.01017228f, 
    0.03309150f, -0.01594257f, -0.01735255f, 0.03017016f, 0.05310182f, -0.00725417f, -0.06790101f, -0.00314666f, 
    -0.06268429f, 0.00854056f, -0.01979944f, -0.00989760f, -0.02190612f, 0.04217190f, -0.04526413f, 0.05762815f, 
    0.04010800f, 0.02544736f, 0.03842253f, 0.05619702f, -0.03428718f, -0.06168314f, 0.00732719f, 0.02028172f, 
    -0.01697408f, 0.04392838f, 0.02049491f, -0.04627316f, 0.03681455f, -0.02090527f, 0.00060503f, -0.01600341f, 
    -0.05439531f, 0.16372477f, 0.11941894f, 0.06175024f, -0.03944359f, -0.06215728f, 0.01759913f, 0.01031665f, 
    0.03533807f, -0.02866853f, 0.11519931f, -0.01538821f, 0.09349368f, 0.17882746f, -0.06478533f, -0.00041538f, 
    0.00417836f, 0.01082462f, 0.10667174f, 0.06989567f, -0.13864809f, -0.11843757f, 0.02641082f, 0.00372255f, 
    -0.03326795f, 0.15758312f, -0.14916167f, -0.10809539f, -0.05647228f, -0.02355094f, -0.03357185f, 0.08406045f, 
    0.04972777f, -0.12198235f, 0.09407999f, -0.04320114f, -0.01766844f, -0.02274103f, -0.00758235f, -0.29764214f, 
    0.03434383f, -0.11149800f, -0.03116788f, 0.01461492f, -0.07844777f, -0.05832897f, -0.02010248f, 0.02800081f, 
    -0.14777569f, 0.19147000f, 0.23848762f, 0.08001336f, -0.18281998f, 0.05150332f, 0.01901939f, 0.06885471f, 
    0.00082047f, -0.22748624f, 0.06846064f, 0.00613186f, -0.06965490f, 0.09281532f, -0.11118914f, -0.02934411f, 
    -0.03216135f, -0.08995946f, 0.13917826f, 0.05506920f, -0.00946272f, -0.08069479f, 0.02748195f, -0.11673436f, 
    0.28267464f, 0.06074922f, -0.10789693f, 0.01818947f, 0.01081635f, -0.03224842f, -0.09157050f, -0.09670555f, 
    -0.05322143f, -0.02557168f, 0.01075888f, 0.05419317f, -0.07004017f, 0.22109284f, -0.17687753f, -0.13092297f, 
    0.00305912f, 0.08732790f, -0.00210210f, -0.01270716f, 0.15942332f, 0.10008049f, 0.02391161f, -0.09668043f, 
    -0.04383907f, 0.08951360f, -0.11040974f, 0.07929946f, 0.22055510f, 0.03272428f, 0.04281415f, -0.09479346f, 
    0.05587080f, 0.14732632f, 0.17420535f, -0.03672092f, 0.35250062f, 0.17493702f, 0.17210250f, 0.21522081f, 
    -0.17181738f, -0.15959109f, 0.09956760f, -0.00885788f, 0.01661382f, 0.00645817f, -0.01266143f, -0.12709785f, 
    0.19761486f, 0.03014196f, 0.06366459f, 0.00671674f, -0.00194947f, -0.09644096f, -0.05006577f, -0.03810673f, 
    0.06072465f, -0.09777526f, 0.11451907f, -0.05968226f, -0.04181942f, -0.08195998f, 0.06527018f, 0.18991342f, 
    0.01352439f, -0.05711953f, 0.07633930f, -0.08915044f, 0.02291245f, -0.05621792f, -0.05107908f, -0.04689470f, 
    0.08745337f, 0.09698841f, -0.06133842f, 0.12195201f, 0.09799708f, -0.01592135f, -0.00412709f, 0.01796403f, 
    -0.06476337f, 0.09300598f, 0.07459826f, 0.03803905f, -0.20147008f, -0.13723603f, -0.13824123f, -0.01095584f, 
    0.11971387f, -0.16572218f, -0.03106730f, -0.08133809f, 0.13623892f, 0.10974880f, -0.12118585f, -0.03439524f, 
    -0.23192063f, -0.18352175f, -0.13707380f, -0.18959852f, -0.07473713f, 0.08977678f, -0.08387326f, 0.04735050f, 
    -0.09879632f, 0.02608822f, -0.08318808f, -0.00612412f, 0.37810922f, 0.03013049f, 0.05810434f, -0.05041407f, 
    -0.04810971f, -0.03603769f, -0.02117144f, 0.00238170f, -0.00281933f, 0.05444693f, 0.09174346f, 0.06882243f, 
    -0.05666156f, -0.05781895f, -0.05728281f, -0.04657221f, -0.07565585f, -0.01164580f, -0.01856453f, 0.04910336f, 
    0.02664381f, -0.05197451f, -0.07076968f, -0.03981612f, 0.04922056f, 0.00948220f, -0.08005785f, -0.03211607f, 
    -0.02341585f, -0.05188476f, -0.01904115f, 0.07763936f, -0.05730240f, -0.07819209f, -0.06358435f, -0.06537303f, 
    0.00242773f, -0.01085045f, -0.05059694f, -0.07709170f, 0.02968656f, 0.00438545f, 0.06031825f, 0.03844507f, 
    -0.05918264f, 0.03825191f, 0.02934859f, -0.06338657f, -0.02404948f, 0.04756241f, -0.03996455f, 0.03413621f, 
    -0.05047880f, 0.04428308f, -0.06470557f, 0.04778567f, -0.00455206f, 0.06684119f, 0.02066196f, -0.07763781f, 
    0.04420786f, 0.04432413f, 0.01696793f, 0.01656657f, 0.04991172f, 0.06298142f, 0.04184287f, 0.01294628f, 
    -0.05249784f, 0.06111632f, 0.05265040f, -0.01236242f, 0.04315271f, -0.06779266f, -0.00302532f, -0.07137773f, 
    -0.01408353f, 0.01666594f, 0.02449800f, -0.02956070f, 0.04355239f, 0.05637769f, -0.03525172f, 0.05003057f, 
    -0.06412522f, -0.07227380f, 0.04331281f, 0.04734118f, 0.02883322f, 0.00911723f, -0.04346852f, -0.03535079f, 
    0.01159476f, -0.03180399f, -0.06176051f, 0.02860693f, 0.00540590f, -0.03211556f, -0.01776000f, -0.06726530f, 
    -0.04101581f, 0.06187012f, 0.03924354f, 0.00011012f, -0.03860902f, -0.06627007f, -0.03399723f, -0.06589556f, 
    0.05346379f, 0.05190792f, 0.03497178f, 0.00720449f, -0.06509855f, -0.06948421f, 0.00277780f, 0.00362444f, 
    0.01864710f, -0.02839570f, -0.05236546f, -0.03091098f, 0.03470849f, 0.05008626f, -0.06042211f, 0.04144022f, 
    0.02273875f, 0.00538113f, -0.05291566f, -0.06313722f, -0.00865909f, 0.04817073f, 0.02909167f, 0.04716358f, 
    0.04310367f, 0.01466488f, -0.06701990f, 0.04742861f, -0.00340302f, -0.05718905f, -0.02064462f, -0.04898547f, 
    0.03492919f, 0.04002307f, 0.02266584f, -0.05293498f, 0.01519687f, -0.06402030f, -0.00784686f, -0.04296486f, 
    0.02505765f, -0.00151569f, 0.00022295f, -0.05282034f, -0.01811095f, 0.03507331f, 0.06974555f, -0.06210685f, 
    0.00797936f, -0.04380104f, -0.03589487f, 0.00253039f, 0.02996249f, 0.05816694f, 0.01881870f, 0.01368801f, 
    0.06360696f, 0.06172330f, -0.05574176f, 0.00540070f, -0.01331026f, -0.01148739f, -0.02306925f, 0.00647326f, 
    -0.00793285f, -0.05425131f, -0.05286453f, -0.02742795f, -0.02255149f, -0.01402232f, 0.05522128f, -0.02240955f, 
    0.05337657f, -0.06566475f, 0.03547049f, 0.04231403f, -0.00430979f, -0.02830328f, -0.07703575f, -0.02877296f, 
    0.03467448f, 0.00037942f, 0.01817455f, 0.04173849f, -0.01424818f, -0.02509337f, 0.03061768f, 0.01990308f, 
    -0.05527218f, 0.02986909f, -0.00878061f, -0.05404265f, -0.00792406f, -0.06874916f, -0.03307772f, -0.00309920f, 
    0.13249284f, -0.23423921f, -0.14999045f, 0.10310831f, -0.03435545f, 0.01078296f, 0.09234742f, 0.02418183f, 
    -0.02439654f, -0.02669671f, 0.06604511f, -0.11553546f, -0.00721320f, 0.09159614f, 0.14270353f, -0.10841841f, 
    0.03495746f, 0.07835268f, 0.16124371f, -0.04860647f, -0.08421009f, -0.02603875f, -0.01789268f, 0.03330747f, 
    0.23838592f, 0.04583256f, 0.02580141f, -0.01134621f, 0.03147933f, -0.10793623f, 0.08893788f, -0.00811855f, 
    -0.00179749f, -0.07977386f, 0.12451555f, 0.10320130f, 0.10461415f, 0.03846293f, 0.30510509f, -0.11428795f, 
    0.03483607f, 0.03621055f, -0.03636561f, 0.04608891f, 0.04325350f, -0.08190390f, -0.00549858f, 0.03994502f, 
    -0.06346007f, 0.06063689f, 0.18463261f, 0.15620588f, -0.17128053f, -0.07286514f, 0.05566913f, 0.06850267f, 
    -0.07966570f, -0.08295171f, 0.06279856f, 0.02081915f, -0.22392735f, -0.20382288f, -0.01203291f, -0.22510597f, 
    0.01418107f, 0.00617479f, -0.01836309f, 0.00799647f, -0.07811967f, -0.10924011f, -0.05620694f, 0.01611114f, 
    0.09802447f, 0.36277321f, 0.07159921f, 0.02622044f, -0.03570182f, -0.01319240f, -0.08296829f, -0.03766352f, 
    -0.10070360f, -0.14155979f, 0.02781777f, 0.05637540f, 0.00244461f, -0.04064826f, -0.19621384f, -0.19368805f, 
    0.00191898f, 0.03439634f, 0.05668242f, -0.03212576f, -0.05033085f, 0.20099698f, 0.05199942f, 0.00244391f, 
    -0.21597254f, -0.05250581f, -0.14570513f, 0.13982613f, 0.01925558f, -0.08450695f, -0.05029555f, -0.00098726f, 
    0.09239741f, -0.02133298f, 0.03450098f, -0.04773578f, 0.21201655f, 0.25094712f, 0.23855315f, 0.17881401f, 
    0.05140351f, 0.02013673f, 0.03352925f, 0.18019429f, 0.03742447f, 0.08823080f, 0.08079717f, 0.01156630f, 
    -0.01096079f, 0.12516512f, -0.08831403f, -0.12626740f, -0.00551243f, -0.01446986f, -0.05036872f, -0.11003543f, 
    0.04550466f, -0.04009962f, 0.09041044f, 0.12243693f, -0.10037301f, -0.11127310f, -0.07196643f, 0.09240834f, 
    -0.08914812f, 0.08277638f, 0.04148444f, 0.05773327f, -0.06128329f, 0.02939127f, -0.03416019f, -0.02844086f, 
    0.12641679f, 0.09544091f, -0.08521458f, 0.01932092f, -0.09159302f, 0.08366015f, 0.15670136f, 0.03518871f, 
    -0.06769817f, -0.04074669f, 0.11582805f, -0.04805909f, -0.05745512f, 0.09968040f, 0.19886290f, 0.13689865f, 
    0.03695821f, 0.00654067f, -0.01915694f, -0.03137499f, -0.01635930f, 0.06762397f, -0.08039432f, -0.01521668f, 
    -0.01866035f, -0.03460745f, 0.04667863f, -0.02328504f, 0.11317471f, 0.03439002f, -0.05003044f, 0.05496131f, 
    -0.05862383f, 0.02340187f, -0.01579458f, 0.11809900f, 0.06298718f, 0.14737646f, 0.06430622f, 0.02128414f, 
    0.04937957f, 0.09505343f, 0.00740928f, -0.01742603f, 0.03682261f, 0.04238457f, -0.10292032f, 0.07936883f, 
    -0.06750910f, -0.05832757f, 0.04353637f, -0.01632773f, -0.04926419f, 0.05151274f, -0.01122565f, 0.02997493f, 
    0.06249926f, 0.04050074f, -0.05016333f, 0.03596294f, -0.00634346f, -0.07591023f, -0.02973216f, 0.00706444f, 
    0.03345581f, 0.03647498f, -0.04578426f, -0.05222751f, 0.03991897f, -0.04837984f, 0.05176987f, 0.05242649f, 
    0.04104346f, -0.07182268f, -0.01162982f, 0.00498693f, -0.01830118f, -0.04800504f, -0.05103849f, 0.01847624f, 
    -0.00077020f, 0.02778400f, -0.04079026f, -0.01086600f, -0.06547656f, -0.04572222f, -0.02332517f, -0.06046805f, 
    -0.05037077f, 0.00507925f, -0.00856127f, 0.05425162f, 0.00869363f, -0.04479011f, -0.03886770f, -0.03987876f, 
    -0.03465200f, -0.05406296f, -0.01366860f, -0.03517439f, -0.01420962f, 0.00209424f, -0.01501297f, 0.01314644f, 
    0.01041961f, -0.00438171f, -0.02656738f, -0.05921908f, 0.05300814f, -0.02632130f, 0.03367773f, -0.00600202f, 
    -0.04847432f, -0.01864364f, 0.03855175f, -0.01907717f, -0.05409125f, 0.01524875f, -0.06712551f, -0.01715069f, 
    -0.00602778f, 0.05896977f, 0.05207930f, 0.01212555f, -0.01542763f, 0.01577576f, -0.06516118f, 0.05288280f, 
    -0.08118959f, -0.01749968f, 0.03690217f, -0.01442215f, -0.00706499f, -0.06068318f, 0.01118741f, 0.05747145f, 
    -0.03845098f, 0.00735175f, 0.02527395f, -0.01188278f, -0.06146540f, 0.05159221f, -0.05631709f, -0.01483094f, 
    -0.05985039f, -0.02396152f, -0.04580844f, -0.08185114f, 0.03600335f, 0.01956253f, 0.00023185f, 0.03634847f, 
    0.05642752f, 0.00999127f, 0.03670250f, -0.00899652f, -0.05626076f, -0.05461243f, 0.03321985f, 0.02023948f, 
    0.02402599f, -0.01980479f, -0.05192300f, -0.01430457f, 0.05626215f, 0.02252718f, -0.07379656f, -0.06571765f, 
    -0.05056337f, -0.04154906f, -0.01862264f, 0.02112374f, -0.05255490f, 0.03426304f, -0.03863658f, -0.02367733f, 
    -0.02499853f, -0.00064767f, -0.00359377f, 0.05398463f, -0.03505213f, 0.05441844f, 0.03243012f, 0.04330744f, 
    0.05503608f, -0.00777597f, -0.07713147f, -0.02724067f, 0.01385301f, 0.00999210f, 0.01803201f, 0.01005946f, 
    -0.00253886f, -0.06048266f, -0.03682969f, -0.08251993f, 0.00304746f, 0.03693143f, -0.05993835f, 0.04515425f, 
    -0.05993079f, 0.04296310f, 0.03902022f, -0.03632976f, 0.03970402f, 0.00915378f, 0.01416750f, 0.02536996f, 
    -0.03302870f, -0.02610776f, 0.05504881f, -0.07494019f, -0.04681990f, -0.03789595f, -0.05801575f, -0.07759493f, 
    -0.01675428f, 0.02108812f, -0.00469871f, 0.06139712f, -0.04943680f, 0.00466584f, 0.04105482f, 0.00322163f, 
    -0.03527526f, 0.06015188f, 0.01778303f, 0.05681929f, 0.02201317f, -0.08044995f, 0.03399402f, -0.00771974f, 
    -0.02563886f, 0.03553637f, -0.04413200f, -0.02271459f, 0.05571967f, -0.03038303f, -0.03269939f, -0.02604090f, 
    0.11135273f, -0.18446198f, -0.03516972f, -0.03676722f, -0.00420222f, 0.03757059f, 0.00708778f, -0.07118123f, 
    0.06646074f, 0.01711728f, 0.10466206f, 0.02438318f, -0.33067429f, 0.17017856f, 0.18666805f, 0.17321017f, 
    0.16760489f, -0.01827480f, -0.04962772f, 0.06233151f, 0.00265433f, 0.20487763f, -0.11951377f, -0.07094856f, 
    0.45553884f, -0.19525708f, 0.03976407f, -0.03490344f, -0.05404355f, 0.04663213f, 0.04307684f, -0.06269953f, 
    0.18101078f, -0.02563716f, -0.03184820f, 0.15612924f, 0.09182881f, 0.09472276f, 0.14839929f, 0.21708964f, 
    0.17235425f, 0.14474298f, -0.08295419f, 0.01368993f, -0.06334881f, -0.03237916f, 0.12654196f, 0.21463530f, 
    -0.01826802f, 0.20566349f, 0.17746915f, -0.05953894f, -0.01455871f, -0.00315913f, 0.18934771f, 0.10279816f, 
    -0.01480498f, 0.09363003f, -0.12530509f, -0.07121339f, -0.52573037f, -0.22191350f, -0.11994696f, -0.05254358f, 
    0.14788291f, 0.13861693f, 0.07174831f, -0.11967365f, 0.06243116f, 0.03767880f, 0.06890213f, 0.01914223f, 
    -0.02984362f, -0.02447185f, 0.20480964f, 0.22681643f, 0.01494350f, -0.16942912f, -0.08241367f, 0.02173947f, 
    0.08097192f, 0.05825227f, 0.05166453f, 0.11929514f, -0.00736433f, -0.06259773f, -0.03024167f, 0.05467359f, 
    -0.00348324f, 0.08160853f, 0.07502242f, 0.01221139f, 0.11265491f, -0.02651566f, -0.11362652f, -0.00024258f, 
    -0.28248268f, -0.17114757f, -0.05692490f, -0.15943828f, 0.04498425f, -0.03681666f, -0.13441034f, -0.01536512f, 
    0.09784131f, -0.11249525f, -0.22269572f, 0.01289207f, 0.20687510f, 0.26372066f, 0.10245573f, -0.31673107f, 
    0.12691222f, 0.14468522f, 0.10032374f, 0.10046288f, 0.02183458f, 0.05314647f, -0.02041464f, 0.11206950f, 
    0.09770265f, 0.00189872f, -0.02570979f, -0.05967461f, 0.10034063f, 0.12033609f, 0.04458496f, -0.04315512f, 
    -0.02169073f, 0.10508424f, 0.07193660f, 0.26749003f, -0.17784630f, -0.09352501f, -0.18311092f, -0.08853856f, 
    0.11717885f, -0.05054101f, -0.05722364f, -0.11796552f, 0.06870892f, -0.00930882f, -0.03716588f, 0.00815765f, 
    0.02866949f, 0.03775696f, 0.01980717f, -0.23753452f, 0.01895913f, -0.07377703f, -0.03300787f, -0.00149532f, 
    -0.14151450f, 0.13442914f, 0.09537997f, 0.06683245f, -0.18114786f, 0.23389192f, 0.18155520f, -0.11448798f, 
    0.09651590f, -0.12055107f, -0.05689835f, -0.02733012f, -0.07289748f, 0.06328763f, 0.00088504f, 0.03839674f, 
    0.01310721f, -0.19552481f, 0.05320387f, 0.14781477f, 0.02581263f, 0.13879454f, 0.05796557f, 0.10318289f, 
    0.06641011f, 0.09566955f, 0.12893645f, 0.25418392f, -0.13087343f, -0.03153028f, 0.03419459f, -0.06483177f, 
    -0.05184934f, -0.04724065f, -0.02862244f, -0.04980216f, 0.04353248f, 0.06971366f, -0.12376215f, -0.04094148f, 
    0.00444087f, 0.40494299f, 0.03978218f, -0.02636999f, 0.12257537f, 0.05149859f, -0.06197350f, -0.10626268f, 
    0.03662649f, 0.08035510f, 0.02254832f, 0.02887489f, -0.19876276f, -0.01094748f, -0.00561958f, -0.22873804f, 
    -0.05469059f, -0.07375893f, 0.05871660f, -0.06068417f, 0.03116142f, -0.03047088f, 0.10825126f, -0.01564389f, 
    -0.53503406f, 0.07226806f, -0.00475001f, -0.00657635f, -0.08451613f, 0.00764904f, -0.05876929f, 0.07792567f, 
    -0.10725450f, 0.01253937f, -0.03668619f, -0.13703848f, -0.29426664f, -0.13713075f, -0.25656018f, 0.07104368f, 
    0.01608261f, 0.02089040f, 0.05233149f, 0.03216022f, 0.15003082f, 0.02549679f, -0.07808837f, -0.09140597f, 
    -0.03584487f, -0.17932917f, -0.01369394f, 0.05177924f, 0.09076931f, -0.00863009f, -0.23750731f, 0.06913899f, 
    0.08233157f, 0.08429160f, 0.06289661f, -0.01516287f, 0.36391854f, 0.11774898f, 0.07089209f, -0.06679143f, 
    0.01506102f, -0.07657892f, 0.12156221f, 0.09001137f, -0.10299768f, 0.02225488f, 0.11417381f, 0.05284464f, 
    0.23535854f, -0.28037721f, -0.14316963f, -0.12107318f, -0.01108648f, 0.17816783f, -0.03853432f, 0.12249358f, 
    0.01484379f, 0.01890038f, 0.12197914f, 0.02879487f, -0.35775018f, -0.04199604f, 0.13607970f, -0.14536971f, 
    0.05361922f, 0.01507209f, -0.02022298f, 0.15690938f, 0.03542322f, -0.10032181f, 0.07406582f, 0.02561485f, 
    0.27197921f, 0.19248241f, 0.29499704f, -0.02321639f, -0.04867760f, 0.03991886f, 0.11206550f, 0.08414768f, 
    -0.18419912f, 0.03035745f, -0.01380586f, 0.04852707f, -0.09347345f, -0.13538562f, -0.05819793f, 0.00789628f, 
    -0.06075687f, -0.11763363f, -0.01094999f, 0.02120536f, 0.08786924f, -0.01322985f, -0.01758899f, -0.07261845f, 
    -0.02544820f, 0.12161049f, -0.11084554f, -0.08155459f, 0.14226273f, -0.07566410f, -0.03757802f, 0.05206183f, 
    0.04448568f, -0.08144650f, -0.03094341f, -0.04836494f, 0.17191063f, 0.09750846f, 0.19279096f, -0.01570784f, 
    -0.00019492f, 0.06002518f, -0.08423404f, -0.11781059f, 0.12386087f, 0.03833698f, 0.04610843f, 0.12692717f, 
    0.16252479f, -0.14470957f, -0.10374230f, 0.10487442f, -0.00661341f, 0.07948343f, -0.02796935f, 0.02669981f, 
    0.06148550f, -0.03364960f, 0.05900970f, 0.05946530f, 0.03017861f, -0.07987085f, 0.02453386f, 0.02792145f, 
    0.10635056f, 0.11119472f, 0.06481779f, -0.16257668f, 0.12334690f, 0.05085003f, 0.03970080f, 0.08231900f, 
    -0.33268493f, -0.06319119f, 0.03366921f, -0.02447197f, 0.26460311f, 0.07039793f, 0.03991018f, -0.05525605f, 
    0.15953077f, -0.02156992f, -0.13350733f, -0.21177287f, 0.35510692f, -0.32866797f, -0.07629886f, -0.10301879f, 
    -0.08844314f, -0.04269876f, 0.07192533f, 0.19181180f, 0.01905398f, 0.03742887f, 0.18413720f, -0.06769305f, 
    0.01403320f, -0.03311365f, -0.01483233f, 0.05327945f, 0.03146949f, -0.05746918f, 0.03781592f, -0.06967341f, 
    0.06094874f, 0.01083676f, -0.03573980f, -0.06151322f, -0.00158738f, -0.02192838f, 0.05374663f, -0.05315883f, 
    -0.00927473f, 0.04323015f, -0.01404696f, -0.04314733f, -0.00347470f, -0.03013464f, -0.01395631f, 0.03046274f, 
    0.00845431f, 0.02214443f, 0.01809985f, -0.03941153f, -0.06004237f, -0.07607624f, -0.05765124f, -0.06483454f, 
    0.03888719f, 0.02280462f, -0.03081797f, -0.06192717f, 0.01131591f, -0.05562430f, 0.04358556f, 0.03570018f, 
    0.00710541f, -0.02539727f, 0.04485537f, -0.05128566f, -0.01374031f, -0.05947221f, 0.02570345f, 0.06520969f, 
    0.06561231f, -0.03148996f, -0.04692436f, 0.02868376f, -0.07236139f, 0.00107608f, -0.00617334f, 0.03987934f, 
    -0.02861582f, 0.00315943f, 0.01498502f, 0.03396921f, 0.00038148f, 0.00469594f, 0.02940582f, -0.03118009f, 
    -0.07149389f, -0.06175452f, 0.01953235f, -0.06518902f, -0.06386417f, -0.00711519f, -0.02739389f, -0.01642538f, 
    -0.01980937f, -0.01535153f, 0.01311634f, -0.02648896f, -0.03832200f, -0.01294796f, 0.00134862f, -0.01233646f, 
    -0.04322556f, -0.02553471f, 0.05647295f, 0.01722391f, -0.04279571f, 0.00763229f, 0.01920704f, 0.06208953f, 
    0.04223700f, 0.05918652f, 0.06587910f, 0.02631053f, -0.03252338f, 0.06304681f, 0.06089913f, 0.01415684f, 
    -0.04015915f, 0.01431966f, 0.02936053f, 0.04016435f, -0.07865614f, -0.02374152f, 0.03694751f, 0.01234653f, 
    -0.06146540f, -0.03085649f, 0.00990453f, -0.01908808f, 0.05986061f, 0.05444205f, -0.06283068f, -0.07050145f, 
    0.01430934f, -0.04413498f, -0.06802217f, -0.03323734f, -0.02669101f, 0.04837862f, -0.00910108f, -0.03163067f, 
    0.06301163f, -0.02870871f, 0.06598482f, -0.05291577f, 0.04832663f, -0.04916544f, -0.00367991f, -0.00548807f, 
    -0.00492967f, -0.03250317f, -0.02589362f, -0.05306622f, -0.05240013f, -0.00647941f, -0.07343965f, 0.01412389f, 
    0.02252106f, -0.05337061f, 0.05229401f, 0.01596900f, 0.03389290f, -0.00766364f, 0.00932240f, -0.00880453f, 
    0.03539581f, 0.04208435f, 0.00019501f, 0.04474408f, 0.02208777f, 0.00542693f, -0.03043474f, 0.05391354f, 
    -0.02545897f, -0.02862458f, 0.03372212f, -0.01524950f, -0.04604756f, -0.04309814f, -0.01012730f, -0.01163369f, 
    0.01301960f, -0.01775730f, -0.06500988f, -0.06410935f, -0.07087170f, 0.03101945f, -0.03973745f, -0.01685334f, 
    0.01288621f, -0.01330930f, 0.00355983f, -0.00335131f, 0.00160322f, -0.05667064f, -0.03244575f, -0.06718127f, 
    -0.02622167f, 0.02241417f, -0.06663083f, 0.00495883f, -0.01893783f, 0.06025590f, -0.04061460f, -0.04444569f, 
    -0.03327795f, 0.05340878f, 0.00328842f, 0.00491922f, -0.02612912f, -0.03387972f, -0.06263867f, 0.03270278f, 
    0.02751781f, -0.01417886f, 0.01771906f, 0.00344672f, -0.06738664f, -0.04768417f, -0.06252316f, 0.01542413f, 
    -0.05604383f, -0.03895772f, -0.05112600f, -0.05315362f, -0.04433574f, -0.05260441f, -0.00554469f, -0.04114965f, 
    0.04552884f, 0.01531429f, -0.00338560f, -0.04283228f, 0.02432636f, 0.02090692f, 0.06220244f, -0.06007333f, 
    -0.06426749f, 0.04807217f, -0.05712098f, 0.01221923f, -0.06594793f, -0.00495722f, -0.06577030f, 0.06307055f, 
    0.03362550f, 0.01303041f, -0.03582596f, -0.02645398f, 0.03406978f, 0.00213062f, -0.05602751f, -0.07562993f, 
    -0.02865226f, -0.01472427f, 0.03847999f, -0.02009958f, 0.05519717f, -0.07875162f, -0.01287724f, 0.01453261f, 
    -0.08112394f, -0.02598730f, -0.06069603f, 0.01722948f, -0.07650036f, -0.01814478f, -0.08226755f, -0.06392717f, 
    -0.02936667f, 0.04050268f, 0.05132325f, 0.03842372f, 0.04157914f, 0.04014691f, -0.04834965f, -0.04475276f, 
    -0.06265267f, -0.02569206f, -0.06924760f, 0.01129880f, 0.03893208f, 0.01797897f, 0.06134662f, 0.02892339f, 
    -0.08176199f, -0.00427209f, 0.03213778f, -0.06208251f, -0.06016225f, 0.05414844f, -0.01275343f, -0.03316326f, 
    0.01490070f, -0.04865998f, 0.01405466f, 0.03919192f, -0.00569579f, 0.01156211f, 0.02652804f, -0.05547862f, 
    -0.07827906f, -0.02264587f, -0.03951781f, -0.03470076f, 0.02942375f, -0.04158457f, 0.02048341f, -0.04316020f, 
    0.05578829f, -0.02123830f, -0.05233095f, 0.04864199f, -0.04240335f, -0.04624582f, -0.00442248f, -0.03884719f, 
    -0.05823850f, 0.06415989f, 0.06057257f, -0.00552531f, 0.01635698f, -0.03675203f, -0.01110856f, -0.05996737f, 
    -0.01993681f, 0.00134143f, 0.07050056f, -0.06833076f, -0.06762061f, 0.05943685f, 0.05440949f, -0.07442062f, 
    -0.01307739f, 0.03624361f, 0.04536952f, -0.02377850f, 0.03213821f, 0.06367900f, 0.02201496f, -0.01065836f, 
    -0.00331527f, 0.04217204f, -0.03796311f, 0.06189262f, 0.01604925f, 0.04871632f, -0.04518697f, -0.04672230f, 
    -0.00208631f, 0.03733676f, -0.06386852f, -0.05446608f, -0.03201497f, -0.05583518f, 0.03907764f, 0.00254711f, 
    0.03393785f, 0.02341712f, -0.05791376f, -0.02255171f, -0.01363305f, 0.04279089f, 0.02593799f, -0.03741777f, 
    -0.07326909f, -0.06884813f, 0.05978249f, 0.00551650f, 0.03090828f, 0.02619246f, -0.02231907f, 0.03411466f, 
    0.03115052f, 0.04711105f, -0.05405226f, 0.05052788f, 0.00792727f, 0.04823738f, 0.03011736f, 0.02960552f, 
    -0.04408934f, -0.06223011f, 0.03597051f, 0.01496956f, -0.06261443f, -0.05907230f, -0.05888297f, -0.06265433f, 
    0.00548739f, -0.00902288f, 0.04379980f, 0.04150901f, -0.03309168f, -0.07519080f, -0.05026843f, 0.02475600f, 
    0.05135499f, -0.00579498f, -0.01658764f, -0.04178917f, 0.02799398f, -0.00122993f, 0.06118953f, -0.06957088f, 
    0.16112036f, -0.30773497f, -0.53740585f, 0.01177586f, 0.02263889f, 0.05832056f, 0.00022287f, -0.04495483f, 
    -0.01676419f, -0.05767087f, 0.04017527f, -0.04820528f, 0.14392640f, -0.20172556f, 0.27457005f, 0.04554402f, 
    0.06085534f, 0.04555876f, 0.12716711f, -0.12465440f, 0.02132471f, 0.14927630f, -0.00829341f, -0.03397203f, 
    0.30258152f, 0.06511478f, -0.01503719f, 0.02321911f, 0.06740639f, -0.03280546f, 0.05357764f, 0.12458695f, 
    0.00271653f, 0.03617089f, 0.07539099f, 0.02606254f, 0.14244746f, 0.04826020f, 0.23729329f, 0.05828867f, 
    0.04252324f, 0.11581288f, -0.16179752f, 0.11232936f, 0.06358624f, -0.08371116f, 0.10073338f, 0.05391420f, 
    0.03743751f, 0.07864339f, 0.10318299f, 0.19366249f, 0.06961382f, -0.11883424f, 0.27970389f, -0.06440116f, 
    0.03571137f, -0.00010603f, 0.04705275f, -0.07554663f, -0.21919052f, -0.23601893f, -0.00376660f, -0.20639883f, 
    0.00178255f, 0.20226051f, -0.01623041f, -0.05241286f, 0.21957676f, 0.07809735f, -0.00295071f, 0.17604440f, 
    -0.04467338f, 0.10724091f, 0.10481079f, 0.25022495f, -0.02825511f, -0.08949360f, 0.03596460f, 0.14067687f, 
    -0.12672172f, -0.10345013f, 0.04316848f, -0.03530498f, 0.09522270f, 0.05700605f, 0.03267209f, 0.08874117f, 
    0.10734725f, 0.04755924f, 0.08533826f, -0.00039239f, -0.03197235f, 0.18130228f, 0.02857313f, -0.03344371f, 
    -0.12207612f, -0.33203012f, -0.06442053f, 0.00210832f, 0.02425318f, -0.06497164f, -0.01025755f, -0.07643218f, 
    -0.05235489f, -0.02365248f, -0.02292475f, -0.04802715f, -0.34259462f, 0.07328051f, 0.14812922f, 0.00759224f, 
    0.18684039f, 0.12363596f, 0.09544332f, 0.19880696f, -0.11220217f, 0.02979681f, 0.02273948f, -0.03852889f, 
    -0.11309994f, -0.03469686f, -0.04496089f, -0.21432717f, -0.00923211f, 0.17178041f, 0.02465743f, -0.02105622f, 
    -0.03424232f, 0.06596877f, 0.07729586f, 0.17130080f, -0.13348775f, -0.10236355f, -0.16773459f, -0.21032590f, 
    0.07026914f, -0.06329585f, -0.07277916f, -0.03859707f, -0.19648133f, 0.00544152f, 0.03602264f, 0.04324576f, 
    0.13542017f, 0.04420948f, -0.16756758f, -0.17878979f, -0.17089511f, 0.10794394f, 0.01873367f, 0.03762799f, 
    -0.06686831f, 0.06441648f, 0.19411086f, 0.03579600f, -0.06114710f, 0.05346527f, 0.17599146f, 0.03899603f, 
    0.09323224f, 0.07458483f, -0.24231590f, -0.09361663f, 0.02033295f, 0.06944042f, 0.07892369f, 0.12055112f, 
    0.02712269f, 0.03032132f, -0.12979947f, 0.12265091f, 0.01706198f, 0.13542438f, -0.03628828f, -0.00612957f, 
    -0.10708249f, 0.16413803f, 0.10236808f, 0.10715047f, -0.26626047f, 0.06456815f, -0.04876137f, 0.04386923f, 
    0.16280253f, -0.02001058f, -0.03947565f, -0.05113185f, -0.09493262f, 0.06466517f, -0.16187723f, -0.10216830f, 
    0.14714877f, -0.04339480f, -0.12303912f, 0.16553512f, 0.10600949f, -0.07755703f, 0.00191352f, -0.03533895f, 
    0.08547234f, 0.00051494f, -0.04709766f, -0.03109848f, 0.20244090f, 0.31980529f, -0.16477728f, -0.23803212f, 
    -0.00359409f, 0.07524497f, 0.02839643f, -0.03351307f, 0.02211905f, -0.12575008f, 0.20734355f, 0.06239293f, 
    0.04541165f, -0.00219107f, -0.00590682f, -0.08110636f, -0.00895526f, 0.07261531f, 0.01318054f, 0.06585629f, 
    -0.02540883f, 0.05256277f, 0.05018606f, 0.00758203f, 0.03395779f, -0.06220553f, 0.33868527f, -0.10489521f, 
    -0.12491353f, -0.04603166f, 0.01873426f, 0.09384816f, 0.10808236f, -0.01931652f, 0.04456634f, -0.00869816f, 
    0.07238683f, -0.07939313f, 0.14780234f, 0.01588532f, -0.27144077f, -0.00332000f, 0.00326119f, 0.04079845f, 
    -0.00765040f, -0.03729858f, -0.04514189f, 0.06375299f, 0.19696793f, 0.00826089f, -0.10795087f, -0.23268016f, 
    -0.05975432f, -0.09527238f, -0.00247128f, -0.00675924f, 0.04532565f, -0.00628502f, -0.08266468f, 0.07713045f, 
    -0.22861901f, 0.36904171f, -0.00405928f, -0.28982565f, 0.11129833f, 0.16279645f, -0.08207922f, 0.02273785f, 
    0.02851418f, -0.12929207f, 0.03451078f, -0.01096134f, 0.04050669f, 0.04379421f, -0.00380087f, -0.29570135f, 
    0.12160372f, -0.07597543f, 0.03214708f, 0.01131472f, -0.05737529f, 0.10531078f, 0.06868679f, -0.00457030f, 
    0.18703479f, -0.05012541f, -0.12057352f, 0.20266885f, 0.06564422f, 0.08872476f, 0.06430503f, 0.02206022f, 
    0.06134657f, 0.00098875f, 0.12495310f, -0.01080780f, 0.28608459f, 0.18432926f, 0.15604731f, 0.18339144f, 
    -0.06423537f, -0.10592820f, -0.09549975f, 0.06291205f, -0.10936146f, 0.01052427f, 0.02879924f, -0.19109654f, 
    0.01592042f, 0.23568717f, 0.14135271f, 0.12053999f, 0.09561838f, 0.10919613f, 0.06042007f, -0.00288606f, 
    0.06588842f, 0.05308611f, 0.03053272f, 0.03574822f, -0.00247461f, -0.26152954f, 0.04996417f, 0.46291471f, 
    0.05074203f, 0.02695441f, 0.04229101f, -0.02393195f, -0.00314043f, 0.03389387f, -0.01203695f, 0.00722223f, 
    -0.05608141f, 0.08204672f, -0.19338587f, 0.14563935f, -0.07785331f, -0.00045561f, 0.13046268f, -0.06930086f, 
    -0.08958160f, -0.01446852f, 0.02612864f, -0.05938795f, 0.11047099f, -0.30361196f, -0.11306165f, 0.30056506f, 
    0.07079292f, 0.10641204f, -0.01023361f, -0.04923873f, 0.04250745f, -0.06488099f, -0.04688937f, -0.07500892f, 
    -0.06368067f, -0.03121709f, -0.02733752f, -0.10093180f, 0.13100345f, -0.01937108f, -0.03574928f, 0.11939147f, 
    0.03396175f, 0.09287110f, -0.01214271f, -0.13533208f, 0.31343231f, 0.06532726f, 0.02537030f, -0.10531621f, 
    0.10794199f, -0.05221232f, -0.01797126f, -0.08433159f, -0.01459371f, 0.08569141f, 0.04138790f, 0.06857382f, 
    0.06831866f, 0.01253965f, -0.13896352f, 0.03034638f, 0.17224951f, -0.08105747f, -0.11412465f, 0.00249068f, 
    0.06707025f, 0.14480150f, -0.01302008f, 0.04911120f, 0.25233167f, 0.07432331f, -0.16675133f, -0.21737213f, 
    -0.04515808f, -0.03532514f, 0.17114760f, -0.04110387f, 0.16065784f, -0.03355993f, 0.08277072f, 0.01239382f, 
    -0.18154870f, 0.08049262f, -0.18349180f, 0.11252642f, -0.08180199f, 0.07958137f, 0.01806665f, 0.09246392f, 
    -0.18239461f, 0.09149905f, 0.00708210f, 0.01316165f, -0.21236125f, 0.06754738f, 0.19113210f, -0.01548286f, 
    -0.14506976f, -0.22189887f, 0.09630568f, 0.06434046f, 0.20286587f, 0.07838298f, -0.16003966f, -0.01157732f, 
    0.03747836f, -0.07434218f, 0.10478958f, 0.19235983f, -0.17591171f, -0.01649088f, -0.13559896f, -0.05513449f, 
    0.00833553f, 0.00950901f, -0.14642598f, 0.05206895f, 0.41225392f, 0.12692016f, 0.01748316f, -0.19664562f, 
    0.02505536f, -0.02494080f, 0.01852642f, 0.01888816f, -0.02531660f, 0.05740154f, -0.08027685f, 0.07532062f, 
    0.00735642f, -0.01099857f, -0.14406297f, 0.06981413f, -0.04270337f, 0.03591075f, -0.04932141f, 0.00871876f, 
    0.13991930f, -0.05339661f, 0.02401034f, 0.03600886f, -0.12537572f, 0.30532822f, -0.03135234f, -0.21093747f, 
    0.07283325f, -0.13695201f, 0.06800556f, 0.07963420f, -0.06903817f, 0.09331930f, 0.04515600f, -0.11202204f, 
    0.46496978f, 0.07390475f, -0.01776429f, 0.14369088f, 0.08094458f, 0.06994835f, 0.13907576f, 0.10493374f, 
    0.00913977f, 0.02780076f, 0.03837617f, 0.08624908f, -0.04988408f, 0.07578925f, 0.17994928f, 0.26167318f, 
    0.02225624f, -0.19960494f, -0.25822806f, 0.16099872f, -0.12681714f, 0.03045849f, -0.08207120f, -0.25729370f, 
    -0.11429456f, 0.07467680f, 0.05605583f, 0.04021666f, 0.12763765f, 0.06701401f, 0.08818134f, -0.01358545f, 
    0.05367584f, -0.00586503f, -0.13025038f, -0.04874211f, 0.14136542f, -0.04668180f, 0.17513196f, 0.25628027f, 
    0.15244839f, 0.03920693f, 0.06104169f, 0.14858638f, 0.03169178f, 0.00798560f, 0.03810287f, 0.17668451f, 
    -0.15878405f, -0.00816582f, -0.20828781f, 0.13831389f, -0.02027066f, -0.09093351f, -0.01668025f, -0.07149256f, 
    0.11660449f, -0.12807490f, 0.10484217f, 0.00004704f, -0.16456141f, -0.41757122f, -0.18272223f, 0.18513235f, 
    0.03206086f, 0.10574478f, 0.04012745f, -0.15393278f, 0.06967931f, -0.01331796f, 0.00151374f, 0.02066566f, 
    -0.36310795f, -0.04080366f, -0.06101356f, -0.17166720f, 0.18362784f, -0.05163892f, -0.10427614f, 0.09445135f, 
    -0.05479557f, 0.00878823f, -0.07698361f, -0.16414848f, 0.28398272f, 0.06638469f, 0.02683354f, -0.09143411f, 
    0.00404577f, -0.11150953f, -0.07661531f, 0.05295015f, -0.03841493f, 0.05016909f, 0.03568190f, -0.02350033f, 
    -0.29795989f, 0.15942563f, -0.28287336f, 0.14172643f, -0.07871193f, 0.05249518f, 0.05704037f, -0.05307187f, 
    -0.05011329f, 0.03174568f, 0.01090704f, 0.03112837f, 0.27621132f, -0.23562208f, 0.07259948f, 0.33772907f, 
    0.07525992f, -0.13160920f, -0.06268644f, 0.02523031f, -0.03011052f, 0.01014615f, -0.04924684f, -0.02768758f, 
    0.02544803f, -0.02945993f, 0.10873573f, -0.00395831f, 0.05819966f, -0.01191219f, -0.04924893f, 0.10425705f, 
    0.00162495f, 0.01406451f, 0.06318175f, 0.01920873f, 0.19396490f, 0.12553315f, -0.10356577f, 0.07201765f, 
    0.03465898f, -0.10429296f, 0.11292747f, -0.03321322f, -0.17588823f, 0.02697628f, 0.08630095f, -0.00037708f, 
    -0.04031724f, 0.15761258f, 0.04468476f, 0.20532916f, 0.03208087f, 0.01221482f, -0.02513530f, -0.08583178f, 
    -0.02224386f, -0.04324586f, 0.11286237f, -0.02117795f, -0.30883360f, 0.14504045f, 0.04590297f, 0.25100005f, 
    0.12143347f, 0.16896072f, -0.05735695f, 0.08549657f, 0.11504026f, 0.02202315f, 0.03233084f, -0.05668901f, 
    0.17399600f, -0.37137747f, 0.14988986f, 0.07364593f, 0.07687391f, 0.03087156f, 0.07220820f, -0.01555423f, 
    -0.09216416f, 0.08773759f, 0.00547833f, 0.00517139f, 0.08806113f, 0.15109095f, 0.01343930f, 0.32425949f, 
    0.02677185f, 0.20867643f, -0.01786609f, 0.08500388f, 0.21523619f, -0.03519005f, 0.02942477f, 0.10126033f, 
    0.06436445f, -0.08568247f, -0.22522317f, -0.16393821f, 0.12812534f, 0.01410687f, -0.10813714f, -0.19399387f, 
    0.03217319f, 0.02476955f, -0.03117263f, 0.04995665f, -0.15428358f, -0.13296203f, 0.12384539f, 0.01634270f, 
    -0.02859493f, -0.05765069f, 0.07934801f, 0.01055680f, 0.06552944f, 0.08206673f, -0.01216498f, 0.12163589f, 
    0.17857794f, -0.35100478f, 0.03333536f, 0.14724255f, -0.12970202f, 0.06493354f, -0.10541288f, -0.02941634f, 
    -0.07800013f, 0.06729665f, 0.00180412f, -0.00125098f, -0.08961498f, 0.11633615f, -0.15546584f, -0.27859879f, 
    0.09564386f, -0.03241521f, 0.03762029f, -0.10514349f, -0.20884933f, -0.10373028f, 0.08545247f, -0.00565283f, 
    -0.02915776f, -0.12201481f, 0.07729883f, -0.08771777f, 0.16092697f, 0.08791541f, -0.04069189f, -0.03120518f, 
    0.05362912f, 0.10906039f, 0.11672156f, 0.00036410f, -0.04324976f, 0.19884503f, -0.10176025f, -0.28660497f, 
    0.08258321f, -0.12615407f, -0.18490969f, -0.04794252f, 0.09033515f, -0.11907371f, 0.03702043f, -0.03197137f, 
    0.13031262f, 0.15745062f, -0.14770590f, 0.07031823f, -0.17020018f, 0.03156233f, 0.01918367f, -0.20679158f, 
    0.11546046f, 0.10876784f, 0.21121001f, 0.23407705f, -0.03511997f, 0.00361353f, -0.00706388f, -0.06784046f, 
    -0.05026063f, 0.07576921f, 0.15879059f, -0.11737101f, 0.07963267f, 0.11900653f, -0.00744853f, -0.08401933f, 
    0.03337342f, -0.05190389f, 0.01139680f, -0.05065985f, -0.00378855f, -0.06842083f, -0.02772574f, -0.03185190f, 
    -0.02695057f, -0.06733797f, 0.06045003f, 0.05119716f, -0.02397339f, -0.05677529f, 0.01042651f, -0.01520278f, 
    -0.01357628f, -0.02339752f, 0.04534815f, -0.07613235f, -0.01544916f, 0.05234108f, 0.01629107f, -0.05793561f, 
    -0.01741833f, -0.07408103f, -0.03361351f, 0.01475416f, -0.03558804f, -0.02936590f, 0.04446996f, 0.04817007f, 
    -0.06919011f, 0.04970392f, -0.05404948f, 0.02783719f, -0.03720370f, 0.05900933f, 0.02707799f, -0.04463718f, 
    -0.00829237f, -0.00550777f, -0.05521594f, -0.00259242f, -0.02657064f, 0.03476376f, -0.02223269f, -0.00483113f, 
    -0.00679312f, -0.06761841f, 0.05549172f, 0.05957664f, 0.01152520f, -0.02186533f, 0.01662987f, -0.03466354f, 
    0.05974375f, -0.01910865f, -0.03631274f, -0.02828426f, 0.04267942f, -0.08434633f, 0.00897824f, -0.03535825f, 
    -0.04715528f, 0.03564090f, -0.03977450f, -0.01668046f, 0.03578007f, -0.04601715f, -0.02568845f, 0.05846042f, 
    -0.01559591f, 0.00397186f, -0.07407369f, -0.05025565f, 0.04448123f, -0.03554614f, -0.08192009f, 0.00869024f, 
    0.05284465f, -0.05338083f, 0.02637098f, 0.02328678f, 0.02517563f, -0.03900778f, 0.04590973f, 0.01252817f, 
    -0.05190241f, 0.03935759f, 0.01145496f, -0.06189161f, 0.04907352f, 0.01644132f, 0.00457218f, -0.03923278f, 
    -0.07064495f, -0.05651260f, 0.06305316f, -0.05086722f, 0.01896521f, -0.03815812f, -0.05901454f, -0.03834238f, 
    0.05020779f, 0.05402883f, -0.04711815f, 0.06936005f, -0.02214509f, -0.07592707f, 0.02048118f, -0.02872610f, 
    0.01506397f, 0.03950082f, 0.00222665f, -0.02650137f, 0.00266665f, -0.07681406f, -0.03135195f, 0.00229585f, 
    -0.05085469f, -0.01098345f, -0.00078159f, -0.04754435f, 0.04896621f, 0.03883152f, -0.03057376f, -0.03215718f, 
    -0.04569072f, -0.01910634f, 0.03415490f, -0.04031010f, -0.03599748f, 0.00762657f, 0.06270287f, -0.07389548f, 
    -0.04622188f, 0.04243525f, -0.00457315f, -0.00559447f, -0.01987675f, 0.00696779f, -0.04227327f, 0.02662478f, 
    0.03183603f, 0.03997071f, -0.04770067f, 0.02267325f, -0.03697856f, -0.02272789f, -0.00960748f, 0.00344441f, 
    0.02697695f, 0.05937545f, -0.02725424f, 0.02378956f, -0.03171203f, -0.00492675f, 0.00283772f, 0.00041442f, 
    0.04384828f, -0.03735193f, -0.04909725f, -0.04210771f, 0.06620079f, -0.06578153f, -0.00618948f, -0.04900262f, 
    0.00886614f, -0.02602772f, -0.01191850f, -0.05614866f, 0.04595936f, -0.04064604f, -0.03837954f, 0.02858593f, 
    -0.05480389f, -0.06129184f, -0.04042985f, 0.00681265f, 0.00050435f, -0.00148289f, 0.03566250f, -0.04498558f, 
    -0.07290839f, -0.04078767f, -0.05339942f, -0.03412951f, 0.00353409f, 0.02392746f, 0.01767508f, 0.02336922f, 
    -0.04294403f, -0.03927133f, -0.04506011f, -0.01446673f, 0.03773314f, -0.05746100f, -0.06849479f, 0.04543051f, 
    0.02366445f, -0.05919354f, -0.07618771f, -0.06328619f, -0.07630453f, -0.00652925f, -0.06472076f, 0.06364061f, 
    0.00520894f, 0.02693652f, 0.01472235f, 0.00270193f, -0.02026769f, 0.02533047f, 0.01367638f, -0.07609779f, 
    -0.00979799f, -0.03853828f, -0.05619512f, 0.01904726f, 0.04957722f, 0.03746650f, 0.05091980f, 0.04806569f, 
    0.03798928f, 0.00333379f, 0.04437816f, 0.03649366f, -0.05298628f, 0.03429763f, -0.00038407f, -0.03174883f, 
    -0.01749707f, 0.00306261f, 0.04299075f, -0.05163639f, -0.06436908f, -0.06265471f, 0.05148386f, -0.05817178f, 
    -0.01675847f, 0.00528023f, -0.05050974f, 0.00465743f, -0.07050770f, 0.03416419f, -0.05682815f, -0.06349217f, 
    0.00158094f, 0.05046586f, -0.01389237f, -0.01676136f, -0.07574885f, -0.02971858f, 0.00858525f, 0.04650250f, 
    0.06380291f, -0.02401060f, -0.00214306f, -0.06234261f, -0.02292464f, -0.03337901f, -0.02806345f, 0.00130555f, 
    0.02967505f, -0.05005191f, -0.00668342f, 0.06297400f, 0.02694506f, -0.02877389f, -0.04222004f, 0.03545689f, 
    0.01879168f, -0.06212299f, -0.00957983f, -0.06400883f, -0.06605890f, -0.05856258f, -0.06461013f, 0.05753671f, 
    0.05415241f, -0.05078483f, -0.05095551f, 0.00868027f, 0.01201942f, 0.00834206f, 0.05946915f, 0.01694853f, 
    -0.04727054f, 0.04228314f, -0.04891251f, 0.02119768f, -0.04170701f, 0.03304364f, 0.00063143f, 0.01458851f, 
    0.05519444f, 0.06293858f, -0.04125950f, 0.05706436f, -0.03858374f, -0.04437152f, -0.03751003f, -0.06686191f, 
    -0.00144782f, 0.03090408f, -0.07506019f, -0.03845782f, -0.04381672f, -0.01976122f, -0.03979741f, 0.03942816f, 
    -0.00164438f, 0.06140931f, -0.03989988f, -0.07316250f, -0.02277121f, 0.03161817f, 0.01607215f, 0.00423644f, 
    0.01383788f, -0.05404231f, -0.04781489f, -0.04159767f, -0.00735970f, -0.07649398f, 0.03735156f, -0.05198689f, 
    -0.01829993f, -0.06781448f, 0.05511261f, -0.01334930f, -0.05987128f, 0.00914504f, -0.01685685f, -0.05932346f, 
    0.01093323f, -0.04388383f, 0.01105883f, -0.02697356f, 0.00331315f, 0.02777994f, -0.07374331f, -0.05530978f, 
    0.02605798f, -0.07842695f, -0.00377677f, -0.07352680f, -0.01184120f, -0.01732720f, 0.03503695f, -0.05580072f, 
    -0.04757354f, 0.05086718f, -0.03813093f, 0.00194299f, 0.05199398f, 0.00984899f, -0.06498018f, -0.01447958f, 
    -0.00512583f, 0.03705721f, 0.00496874f, 0.04595170f, 0.03200932f, -0.05824635f, -0.01207488f, -0.00711973f, 
    -0.07742828f, 0.03508148f, -0.03286318f, 0.01066591f, 0.05734664f, -0.04877753f, -0.02982465f, -0.06738515f, 
    -0.00868423f, -0.04471103f, -0.00582502f, -0.00436165f, -0.03030995f, 0.01457200f, -0.06367738f, -0.03609631f, 
    -0.20751408f, -0.16409017f, 0.04156236f, -0.02762765f, -0.01373974f, -0.03777020f, 0.13768961f, 0.08333449f, 
    -0.06103629f, 0.01780995f, 0.02217361f, 0.08677239f, 0.03696773f, -0.13882436f, 0.15184473f, 0.09727050f, 
    0.01151367f, -0.00939294f, 0.08301247f, -0.00105194f, -0.01863463f, -0.04191103f, -0.19060737f, 0.04991461f, 
    0.12910058f, 0.06564498f, -0.00968796f, 0.16403326f, 0.02889750f, -0.03074467f, 0.06328469f, 0.02707019f, 
    0.09164923f, -0.03504758f, 0.03924847f, 0.11832274f, 0.19341335f, -0.06687897f, 0.00875090f, -0.17763044f, 
    -0.14573911f, 0.07221385f, 0.03751045f, 0.11914660f, -0.04699162f, -0.06205685f, 0.06321587f, -0.07834379f, 
    -0.16732028f, -0.08147235f, -0.02171087f, 0.03779147f, -0.05298968f, 0.00345000f, 0.13539743f, -0.03372060f, 
    -0.04328271f, -0.09484242f, -0.01011782f, -0.00591077f, -0.39071500f, 0.04509085f, 0.04882332f, 0.22260237f, 
    0.02093692f, 0.00376857f, -0.03862782f, 0.11322495f, -0.01601263f, -0.07050972f, -0.02314147f, -0.10269319f, 
    -0.24227306f, 0.32682109f, -0.07178610f, -0.03242590f, 0.01140400f, -0.00774694f, 0.10902055f, -0.02628739f, 
    0.00743927f, 0.03785435f, 0.07586487f, -0.02019263f, 0.22655536f, -0.09066180f, -0.32709152f, 0.24256381f, 
    -0.00617687f, 0.02885973f, 0.18356161f, -0.03284093f, 0.13196619f, 0.02556627f, -0.15267555f, -0.06249402f, 
    -0.16094020f, 0.09702467f, -0.01696815f, 0.08786744f, 0.07096258f, -0.01449044f, 0.00650448f, -0.04696944f, 
    0.16246411f, 0.10851662f, 0.06084369f, -0.12489895f, -0.15468992f, -0.31373999f, -0.16298766f, -0.01598964f, 
    -0.16724932f, -0.00565877f, 0.02986590f, 0.03822240f, 0.03630652f, 0.16531421f, -0.01635370f, 0.02195146f, 
    0.06527973f, -0.01921884f, 0.04195458f, -0.05330459f, -0.01191637f, -0.03059134f, -0.01729523f, -0.13351732f, 
    0.04561721f, -0.01459949f, 0.13145536f, 0.06823506f, 0.13455336f, -0.21050295f, 0.07064065f, -0.21065228f, 
    -0.18079646f, -0.02661370f, 0.01287536f, 0.03418698f, 0.02092131f, -0.03993097f, -0.04809361f, -0.06875795f, 
    -0.21775712f, 0.09610827f, -0.06688525f, -0.07224450f, 0.05935984f, 0.12590683f, 0.27611071f, 0.02049601f, 
    -0.13592859f, 0.10211663f, 0.16217068f, -0.00032537f, 0.47746730f, -0.01028016f, -0.01680386f, 0.13737321f, 
    0.02296403f, 0.10544607f, -0.03314447f, 0.18168005f, 0.03802629f, 0.08222162f, 0.01182058f, 0.02938390f, 
    -0.08877927f, 0.05170307f, 0.04807242f, -0.04970343f, -0.02089159f, 0.01747192f, 0.02121738f, 0.11575691f, 
    0.00456804f, 0.17665611f, 0.23874524f, 0.31997770f, 0.02390705f, 0.18805952f, 0.15184951f, 0.03230654f, 
    -0.13115370f, -0.09008329f, 0.02815982f, 0.05482027f, 0.00341072f, -0.01124109f, -0.00355531f, -0.14395410f, 
    -0.06703063f, -0.02796731f, -0.07596976f, -0.09250141f, 0.03596592f, -0.05387997f, 0.06468964f, -0.00681598f, 
    0.00048637f, -0.06600448f, -0.03812570f, 0.01006436f, -0.00711471f, -0.00353102f, 0.02749625f, -0.01752192f, 
    0.04025142f, -0.01092379f, -0.03517823f, 0.04093194f, -0.04908475f, -0.00081869f, 0.02826303f, -0.06897100f, 
    0.01437700f, -0.04278392f, -0.07453694f, 0.01292088f, -0.06156448f, -0.08241950f, -0.06774183f, -0.02495688f, 
    -0.05324132f, 0.02850033f, -0.01965327f, -0.04227090f, -0.04374998f, -0.01387877f, -0.00595549f, -0.07405186f, 
    -0.04181504f, -0.06942832f, -0.05008234f, -0.05710564f, 0.06755880f, -0.08776518f, -0.06066541f, -0.08879793f, 
    -0.00155647f, -0.06641711f, 0.05343574f, -0.01288346f, 0.01100500f, -0.02598739f, 0.02397873f, 0.04904020f, 
    -0.06986586f, 0.03876748f, -0.06845693f, 0.03669617f, -0.08244087f, 0.02485950f, -0.06730588f, -0.08486799f, 
    0.00454859f, 0.05999371f, -0.04439347f, -0.01967939f, 0.00204101f, -0.01441385f, -0.07245968f, 0.00449927f, 
    0.02235970f, 0.00563764f, 0.01720370f, -0.04647220f, -0.04392877f, -0.08716061f, -0.02955632f, 0.02352527f, 
    -0.07012224f, -0.00699583f, 0.03494756f, -0.06229280f, 0.05678161f, 0.01433037f, -0.08380062f, -0.00024365f, 
    0.04246781f, -0.01931902f, -0.07180867f, -0.07191388f, -0.08702485f, -0.03548800f, -0.01541616f, 0.00636431f, 
    0.02202511f, 0.01110327f, -0.01519032f, 0.04666812f, 0.03639022f, -0.07622348f, -0.02736116f, -0.02511930f, 
    -0.08782123f, 0.04836947f, -0.00229895f, -0.06728669f, -0.08132022f, -0.05028970f, -0.05840149f, -0.04403227f, 
    -0.02886164f, 0.04514291f, -0.07224146f, -0.09761275f, -0.04479030f, -0.06521163f, -0.02711652f, -0.06364180f, 
    -0.05016990f, -0.08299945f, 0.03968243f, -0.02123483f, -0.00669471f, -0.08544047f, 0.02271451f, -0.01591284f, 
    -0.01392187f, -0.05553481f, -0.00320165f, 0.04877892f, -0.07569695f, 0.02553355f, 0.02247402f, -0.07525779f, 
    -0.05268295f, -0.01126509f, 0.05262360f, -0.03842860f, 0.02306020f, -0.05110867f, 0.01014642f, -0.05401617f, 
    -0.03700646f, -0.03785381f, -0.03862337f, -0.07444103f, 0.02091383f, -0.04832299f, -0.07835665f, 0.03423327f, 
    0.01960843f, -0.03122026f, -0.06032341f, 0.01295517f, 0.00756468f, -0.05961809f, -0.06396922f, -0.05633308f, 
    -0.03465364f, -0.07477394f, -0.01905616f, -0.05064315f, -0.05012237f, -0.07471673f, 0.02761399f, -0.01428848f, 
    0.01101685f, -0.03451440f, -0.03478773f, -0.02288781f, -0.01667416f, -0.05381912f, -0.02987031f, -0.07851888f, 
    -0.01213217f, -0.05615599f, -0.10724416f, 0.01969106f, -0.00333027f, -0.01267201f, 0.00438328f, -0.01763272f, 
    -0.06027827f, -0.04905627f, -0.00933540f, 0.03669120f, -0.09097870f, 0.03564977f, -0.02820903f, -0.00116956f, 
    0.02136083f, 0.01047457f, 0.39105478f, 0.06789786f, -0.09148970f, 0.02781637f, 0.00631695f, 0.00748526f, 
    -0.03074475f, -0.01082003f, -0.06004737f, 0.12051606f, 0.04113653f, 0.30806160f, -0.20113823f, 0.03510629f, 
    -0.06721047f, -0.06293742f, -0.11461825f, 0.14023517f, 0.07733124f, -0.00245706f, 0.04822211f, 0.12465709f, 
    -0.00613350f, -0.05060834f, 0.07250434f, -0.10271852f, -0.10896758f, 0.11466610f, -0.05707412f, -0.03766806f, 
    0.08462628f, 0.15736514f, -0.02030231f, 0.11409599f, -0.17530820f, -0.14162415f, -0.10270295f, -0.07422588f, 
    0.01097043f, 0.05238315f, 0.09824777f, -0.06347224f, 0.06646481f, 0.05450125f, 0.00956293f, 0.00462513f, 
    0.02899556f, -0.09880567f, 0.00329117f, -0.31941393f, 0.07053930f, 0.14916071f, -0.03477165f, 0.01007804f, 
    0.09933586f, 0.09352385f, 0.02909319f, 0.08613060f, 0.11573357f, 0.08487731f, -0.19136706f, -0.04504305f, 
    0.08698700f, -0.05335645f, -0.11120204f, 0.09616438f, 0.00456153f, 0.06527998f, 0.07815678f, 0.09246033f, 
    -0.35941559f, 0.21789409f, 0.14636518f, 0.00072465f, 0.01730029f, 0.11561293f, -0.05585150f, -0.07407389f, 
    0.11308376f, 0.17089088f, -0.11415086f, 0.12840158f, 0.14565374f, -0.04786656f, 0.01373502f, -0.12274908f, 
    0.02251749f, -0.07478745f, -0.03659626f, -0.03279812f, 0.04366747f, -0.06049676f, -0.02175277f, 0.05215498f, 
    0.04577713f, 0.23173170f, 0.09674051f, 0.15053691f, 0.02365553f, 0.09738220f, 0.02348974f, 0.13827801f, 
    -0.00821129f, -0.00950100f, 0.01084847f, -0.00766888f, 0.24145056f, -0.03708505f, -0.15056369f, -0.31522346f, 
    -0.01752273f, 0.14992571f, 0.00153100f, -0.16751271f, 0.03268180f, -0.12707791f, 0.04690363f, 0.02693937f, 
    -0.07203602f, 0.08890701f, 0.05305778f, 0.17538288f, -0.00196960f, -0.01417772f, 0.13204733f, 0.07892167f, 
    0.14606646f, 0.01749178f, -0.05650644f, -0.01988678f, 0.09634147f, -0.04679698f, 0.15746100f, 0.24694893f, 
    -0.06707212f, 0.01474426f, -0.00161274f, 0.01573889f, 0.16176291f, -0.01007919f, 0.19246121f, 0.11472005f, 
    -0.26830927f, 0.14639522f, 0.06495342f, -0.13312583f, 0.10750750f, -0.10133059f, 0.00583535f, 0.03042272f, 
    0.06990124f, -0.03447353f, -0.05230368f, 0.02756002f, 0.17197518f, -0.07344259f, 0.00553897f, 0.15090407f, 
    0.06943686f, -0.02816276f, 0.13354334f, 0.03994467f, 0.08851436f, 0.03374992f, -0.03132052f, -0.05964677f, 
    0.03868992f, 0.00957691f, 0.08731464f, -0.09056483f, -0.03458097f, 0.00706181f, 0.13497454f, 0.03394485f, 
    0.20132780f, -0.03629742f, 0.01047149f, -0.15610681f, -0.21835729f, -0.06084242f, -0.09935643f, -0.01811213f, 
    -0.01552841f, 0.06108331f, 0.06652741f, -0.03508619f, 0.05159333f, 0.04398932f, 0.18647088f, 0.06083499f, 
    -0.01522383f, 0.22070347f, 0.01897241f, 0.02248061f, 0.09560338f, -0.01445141f, -0.21946616f, -0.19372432f, 
    0.03237481f, -0.11510545f, 0.04531277f, -0.06623598f, 0.20666812f, 0.27899727f, 0.03050290f, 0.00181947f, 
    -0.01518746f, 0.16097040f, -0.13974495f, -0.17550267f, 0.03282749f, -0.00432275f, 0.11235179f, -0.10528397f, 
    -0.08290369f, 0.05210499f, 0.01064653f, -0.12573707f, 0.02530033f, 0.09003535f, -0.07591002f, 0.24509181f, 
    0.07981041f, -0.00514058f, -0.02579466f, 0.04413166f, 0.19316208f, -0.01410327f, -0.04990124f, -0.04057802f, 
    0.12023605f, 0.03976837f, 0.01704784f, 0.16810475f, 0.09961703f, 0.13690816f, 0.14904819f, 0.14758922f, 
    -0.08230206f, 0.14746206f, -0.19069985f, 0.11061473f, -0.03788280f, -0.02365218f, 0.02704477f, -0.09520353f, 
    -0.01606122f, 0.08407336f, -0.03730768f, 0.18068121f, 0.27902493f, -0.15282100f, -0.16516455f, -0.10953187f, 
    -0.05887606f, 0.06978209f, 0.09640539f, -0.09239816f, 0.00107232f, -0.04775045f, 0.07618906f, -0.01714453f, 
    0.32137594f, -0.33475396f, 0.00623405f, 0.22852810f, -0.01467244f, 0.06864084f, -0.00345533f, 0.15173012f, 
    -0.00750926f, -0.08553670f, 0.16106412f, 0.08368718f, -0.26562253f, 0.34446883f, 0.23431689f, 0.07459034f, 
    -0.00505286f, 0.02845228f, -0.21187000f, 0.00207910f, 0.15218450f, 0.08598938f, 0.03161949f, -0.04139047f, 
    -0.02428919f, -0.36173135f, 0.10652098f, -0.01177499f, -0.06615646f, 0.08833087f, -0.03437978f, -0.07824018f, 
    -0.22390623f, -0.15864955f, 0.02569830f, -0.07770667f, -0.15317117f, 0.11213547f, -0.10606701f, -0.17405044f, 
    0.25223708f, 0.08583952f, 0.08586914f, 0.05096161f, 0.01902394f, 0.05552376f, 0.02273575f, -0.21619725f, 
    -0.20769714f, -0.00182921f, 0.03512634f, -0.17048469f, 0.02564339f, 0.11311602f, -0.09622660f, 0.04220098f, 
    0.07754168f, 0.08063431f, -0.04037731f, 0.02102901f, -0.12434278f, 0.14427026f, -0.16130012f, 0.09549067f, 
    0.30715138f, -0.11509047f, -0.03631506f, -0.22175218f, -0.04717824f, -0.00092492f, -0.11379050f, -0.04098142f, 
    0.17941122f, -0.04602701f, -0.02665024f, 0.16049831f, -0.15315366f, -0.07771657f, -0.23720191f, 0.06134757f, 
    -0.10294922f, 0.13515089f, 0.03699894f, 0.06520543f, -0.13907994f, 0.04142680f, -0.05462131f, 0.16811608f, 
    0.06039881f, 0.14576142f, -0.02954822f, 0.05157602f, -0.08511583f, 0.13999464f, 0.06239156f, 0.11227199f, 
    0.15822379f, 0.11113377f, 0.05442847f, 0.10403074f, -0.01112615f, 0.03001203f, 0.02657123f, 0.14898847f, 
    -0.00101100f, 0.05443064f, -0.04209739f, 0.00099397f, -0.06701435f, -0.10891709f, -0.07821584f, -0.08985165f, 
    0.19364354f, -0.11693338f, -0.03625891f, 0.03133982f, -0.06379154f, 0.08602076f, -0.03875714f, -0.03628973f, 
    -0.03611731f, -0.19127220f, 0.18625900f, 0.08430098f, -0.02345863f, 0.15726145f, 0.08380304f, 0.11576394f, 
    0.03745012f, -0.00261144f, 0.03237533f, -0.01064321f, -0.26726115f, -0.26637921f, 0.05964792f, 0.15566826f, 
    0.09230710f, 0.07680844f, 0.02011216f, 0.12742560f, -0.11703368f, 0.04298561f, -0.13181977f, -0.04217241f, 
    0.16382964f, -0.12760907f, 0.16952167f, 0.04603309f, 0.00842597f, 0.07953058f, 0.11358681f, -0.08872332f, 
    0.14378549f, -0.04837864f, 0.04406538f, 0.00176064f, 0.14702165f, -0.14148144f, -0.04745042f, -0.12010475f, 
    -0.06505851f, 0.01312790f, -0.09387581f, -0.00609517f, -0.05719929f, -0.05214826f, 0.04162270f, -0.01154757f, 
    -0.10611556f, 0.01747098f, 0.10676374f, -0.01509465f, 0.01980956f, -0.13047007f, 0.10316686f, -0.05819789f, 
    -0.01768676f, 0.03433003f, 0.05130437f, -0.03101397f, -0.53628874f, -0.21103162f, 0.03708929f, 0.27075157f, 
    -0.02764623f, 0.07451564f, 0.02741727f, -0.00618577f, -0.04547410f, 0.02684433f, 0.04312571f, -0.05738987f, 
    -0.07097860f, 0.21602197f, 0.05879422f, -0.02175875f, -0.12645867f, -0.11018784f, 0.17541692f, -0.10576629f, 
    0.01524682f, 0.04909557f, 0.07948924f, 0.08132004f, 0.06182735f, -0.31798309f, -0.22350667f, 0.03068500f, 
    -0.12559126f, 0.12232171f, 0.02025383f, 0.01564577f, 0.08979255f, -0.04360093f, -0.08188726f, -0.02644966f, 
    -0.56469738f, 0.02414617f, 0.10347516f, 0.14750901f, 0.03461073f, -0.01129261f, -0.04613464f, -0.09513330f, 
    0.20009556f, -0.02048302f, -0.00624610f, -0.02071824f, 0.06915132f, -0.17083474f, 0.02318299f, -0.06937473f, 
    -0.08695745f, 0.02613839f, 0.15653776f, 0.03328221f, -0.05138426f, 0.11912411f, 0.11792786f, 0.21436141f, 
    0.15332811f, 0.04364628f, -0.10046845f, -0.02482074f, -0.08098233f, 0.02116441f, -0.04124199f, -0.04155258f, 
    -0.01002873f, -0.00410588f, 0.06022142f, 0.02396796f, 0.05981176f, 0.12832795f, 0.08527564f, -0.06155782f, 
    -0.14480476f, 0.02544629f, 0.10200097f, 0.10927724f, 0.08324616f, -0.01873450f, 0.00881858f, -0.05011532f, 
    -0.06575308f, -0.05800663f, 0.14684953f, -0.03511230f, 0.14768261f, 0.09099617f, 0.25545809f, 0.10738952f, 
    -0.12358648f, 0.04473928f, 0.18510514f, 0.12248711f, 0.07085249f, 0.18213528f, 0.13404848f, -0.19508414f, 
    0.17529269f, -0.01462424f, -0.03905129f, 0.10957641f, 0.07576203f, 0.00416399f, 0.00507390f, 0.10521258f, 
    -0.06637809f, -0.09910153f, 0.07018087f, -0.09913351f, 0.00759191f, 0.10166883f, -0.02730411f, 0.13608848f, 
    0.02931191f, -0.05479621f, 0.02726758f, 0.20803577f, -0.18148743f, 0.12451658f, 0.06686449f, 0.06800859f, 
    0.03109915f, -0.00006938f, 0.05787931f, 0.00871471f, 0.11922031f, 0.00759219f, -0.06965593f, 0.06513939f, 
    -0.15920521f, -0.05649865f, -0.21230526f, -0.19200861f, 0.13656066f, 0.04017927f, 0.03042196f, -0.03824870f, 
    -0.01395635f, -0.06887894f, 0.09874833f, -0.09642740f, 0.18502712f, -0.00587078f, -0.13490202f, -0.03477079f, 
    -0.07809304f, -0.03842402f, -0.04557526f, -0.01342204f, 0.04925138f, -0.02708045f, 0.00516974f, -0.03054151f, 
    0.10906245f, 0.28623497f, -0.17373563f, 0.25284070f, 0.13938838f, 0.10314105f, 0.08272724f, -0.03946361f, 
    -0.16012394f, 0.01086237f, 0.06902387f, 0.05824175f, 0.26595291f, 0.05231204f, 0.10480105f, 0.18043523f, 
    -0.03107814f, -0.04995091f, 0.03369254f, 0.13443233f, 0.02255618f, -0.00588385f, -0.11798742f, 0.02850356f, 
    0.28692490f, -0.10460015f, -0.03200277f, 0.22023377f, -0.13566346f, 0.02050380f, 0.03697949f, -0.06708770f, 
    -0.07164881f, -0.03777653f, 0.07082938f, 0.07491223f, 0.13924412f, -0.05791669f, -0.03292151f, -0.16699708f, 
    -0.09085147f, 0.05915610f, 0.05784848f, -0.01214602f, -0.02699881f, 0.01637448f, 0.03816623f, 0.02482743f, 
    0.01962770f, 0.16848829f, 0.13862006f, 0.06153737f, -0.04326781f, 0.07062453f, -0.07740708f, -0.11709634f, 
    0.01320449f, -0.01881769f, 0.00913391f, 0.16498370f, 0.17519316f, 0.06320179f, -0.19420175f, 0.25895700f, 
    0.00116256f, 0.00329469f, 0.06033364f, -0.12514295f, -0.00045043f, 0.20453097f, 0.06964482f, -0.14415695f, 
    0.14307214f, -0.07174756f, -0.04822290f, -0.01470320f, 0.12289970f, -0.02754063f, 0.07321467f, 0.03675496f, 
    0.08905166f, -0.08288111f, 0.03595892f, -0.07848535f, -0.02343307f, 0.16079091f, 0.08877609f, 0.22690551f, 
    -0.04941439f, 0.05973652f, 0.10639481f, 0.09001071f, -0.13340123f, -0.10235121f, -0.05084447f, -0.20714526f, 
    0.00488013f, -0.03053632f, -0.04639078f, 0.07930607f, 0.06287378f, -0.05364299f, 0.11168907f, 0.06775340f, 
    0.06491261f, 0.06447406f, -0.06689463f, -0.09881397f, -0.12942155f, -0.30202428f, -0.00666788f, -0.14223038f, 
    0.07499591f, 0.05523535f, -0.03300217f, -0.00713208f, 0.12166376f, -0.08251727f, 0.02750452f, 0.07488375f, 
    0.09256589f, 0.01739774f, -0.18128830f, -0.07202335f, -0.11257546f, 0.02995516f, -0.01215770f, 0.01234584f, 
    0.01495598f, -0.01325666f, 0.03388255f, 0.01005001f, 0.13772789f, -0.35361585f, -0.18821338f, 0.28758648f, 
    -0.09802761f, 0.07475969f, 0.03187715f, -0.08989432f, -0.05210909f, 0.21668860f, -0.02532261f, -0.03962022f, 
    0.07049838f, 0.05442269f, 0.03426707f, 0.10490849f, -0.05509403f, 0.00548928f, 0.14763248f, 0.04704376f, 
    -0.16994074f, -0.05914901f, 0.05903102f, 0.00186760f, 0.59106976f, 0.27244407f, 0.08870526f, -0.00340998f, 
    -0.07401079f, -0.02804780f, 0.00143691f, -0.00514842f, -0.17867522f, -0.12720564f, -0.13875148f, 0.03999511f, 
    -0.19711971f, 0.18858750f, -0.29043028f, 0.10021511f, 0.02341348f, -0.03023787f, 0.15393223f, -0.01261157f, 
    -0.00829049f, 0.01604360f, 0.04779826f, -0.08527653f, 0.36933336f, -0.26368886f, 0.18929328f, 0.15963052f, 
    0.10688853f, -0.02651561f, -0.02601114f, -0.03971756f, -0.07427185f, 0.05255736f, 0.06214457f, 0.02640118f, 
    0.01969557f, -0.18869808f, 0.04437274f, 0.07182971f, 0.02507686f, 0.04308021f, -0.01797123f, 0.25103498f, 
    -0.03424925f, -0.04276306f, 0.03325565f, 0.04102961f, -0.08502975f, 0.24630748f, -0.12832676f, 0.10737147f, 
    -0.02269663f, 0.03961592f, 0.02080519f, -0.05042697f, -0.08554203f, 0.09548645f, 0.05253914f, -0.00108468f, 
    -0.01507170f, 0.11485200f, 0.09585039f, 0.11435766f, 0.09600921f, 0.06378300f, 0.03128922f, -0.09763787f, 
    -0.00959691f, -0.05978207f, -0.02205723f, -0.03203184f, -0.11117510f, 0.13006036f, 0.18104631f, 0.13788687f, 
    0.06915484f, 0.05919946f, 0.06529514f, -0.04178025f, 0.20048009f, 0.09873080f, 0.02431016f, -0.02968910f, 
    0.10933907f, -0.21275611f, -0.06514122f, -0.00661844f, 0.04449954f, 0.05542000f, -0.00047798f, 0.13551052f, 
    -0.08269873f, -0.04193880f, 0.13710693f, -0.09779700f, -0.06272209f, 0.14340545f, 0.17168409f, 0.13014679f, 
    0.14050849f, 0.10790314f, -0.08552738f, -0.07186680f, 0.21283527f, -0.04312244f, 0.05449909f, 0.19601572f, 
    0.39947525f, -0.03560999f, -0.24434547f, -0.23314352f, 0.08053552f, -0.04090075f, -0.07028086f, -0.09958889f, 
    -0.03241839f, -0.03942946f, -0.00663325f, -0.07338906f, -0.12523618f, -0.07239206f, 0.14688987f, 0.01890433f, 
    0.21803378f, 0.07029679f, -0.12614362f, 0.13583726f, 0.07632063f, 0.06126183f, 0.03868744f, 0.09881331f, 
    0.08350982f, -0.30907020f, -0.01995106f, 0.07100306f, 0.02035566f, 0.05910832f, -0.13146001f, 0.00852437f, 
    -0.18999526f, -0.01278836f, 0.15502158f, 0.08573252f, 0.00398208f, 0.13782401f, -0.17218968f, -0.34148011f, 
    0.19910210f, -0.01097372f, 0.10163730f, -0.10569592f, -0.22608849f, -0.01005025f, -0.11417469f, -0.13324013f, 
    -0.13159303f, -0.00597002f, -0.06178529f, -0.03512136f, 0.07025318f, -0.00217142f, -0.13956226f, 0.02970164f, 
    0.04370455f, -0.02675077f, 0.13723928f, 0.07489529f, -0.03752086f, 0.09909476f, -0.03870996f, -0.29325783f, 
    -0.04769769f, -0.11241196f, -0.07059729f, -0.03163506f, -0.11083140f, -0.01507210f, 0.05554308f, -0.06953958f, 
    0.06654371f, 0.14072314f, -0.16463284f, 0.01294072f, -0.00661901f, -0.12594657f, 0.00787803f, -0.09930781f, 
    -0.10409620f, 0.03763383f, 0.10112581f, 0.17873234f, -0.03796157f, 0.13858125f, 0.03947613f, 0.06500358f, 
    0.02173241f, 0.10582695f, 0.12280916f, -0.14068921f, 0.07927427f, -0.10308720f, 0.01869542f, -0.15338348f, 
    -0.08120087f, 0.00905439f, -0.06407533f, -0.05940051f, 0.04712410f, -0.07788091f, -0.01746946f, -0.03871638f, 
    -0.00158612f, -0.06857230f, 0.02651091f, 0.05226558f, 0.06572914f, -0.06652239f, -0.02480364f, 0.00460151f, 
    -0.00658422f, -0.05842103f, 0.05038043f, -0.04849078f, 0.03655426f, 0.03943671f, 0.00066416f, 0.00861281f, 
    -0.01097152f, -0.07215133f, 0.03139070f, 0.06011552f, 0.03999875f, -0.03293229f, -0.03904041f, 0.06237139f, 
    -0.07732005f, 0.00240277f, 0.04336742f, 0.05450029f, -0.04902637f, 0.05877492f, -0.00392575f, 0.05504987f, 
    -0.01344237f, 0.04040832f, -0.04392086f, 0.00725025f, 0.01392388f, 0.02127612f, -0.00766943f, -0.02691209f, 
    0.01268847f, -0.03747329f, -0.00477166f, -0.04119184f, -0.02690126f, -0.07764976f, 0.01912694f, 0.03459736f, 
    0.04008729f, 0.00572748f, -0.05019056f, 0.01142093f, -0.03944443f, 0.04763012f, 0.04120869f, -0.02808074f, 
    0.02236987f, 0.01562253f, -0.06547990f, -0.01088985f, 0.01891986f, 0.00591147f, -0.07575445f, -0.03765920f, 
    0.01149310f, -0.04925109f, -0.01598061f, -0.03959504f, -0.02183186f, -0.03428730f, -0.06625862f, 0.01018153f, 
    0.00759975f, -0.02287118f, -0.02815110f, -0.02128013f, 0.03618138f, 0.02838807f, 0.06445169f, -0.06203388f, 
    0.03246865f, -0.03169362f, -0.00370059f, -0.02938931f, -0.04421984f, 0.04273191f, 0.03785177f, 0.04541210f, 
    0.00666577f, 0.00089349f, -0.06767444f, -0.03679150f, -0.03407840f, 0.05149253f, -0.07462671f, 0.01394109f, 
    0.03822432f, 0.01373047f, 0.00382119f, -0.01312181f, -0.07666823f, 0.00482152f, -0.03810374f, -0.02094086f, 
    -0.07834087f, -0.02811520f, -0.04358347f, -0.04869978f, -0.06098038f, -0.02262609f, 0.05061839f, 0.01111714f, 
    0.00728433f, -0.00683723f, -0.06441737f, -0.05252758f, 0.01324569f, -0.01016352f, 0.03541651f, 0.03466482f, 
    0.00805039f, -0.06761006f, -0.05829340f, -0.08366901f, -0.06386050f, 0.02844007f, -0.04242134f, 0.04912645f, 
    -0.06609236f, 0.02988006f, -0.01187323f, 0.05443387f, 0.06041858f, -0.01762466f, 0.04360139f, 0.02544165f, 
    0.04737302f, 0.00598375f, -0.05611364f, -0.07753011f, 0.01445803f, -0.07654579f, 0.00263394f, 0.01375997f, 
    0.00431148f, -0.04403909f, -0.01439868f, -0.00494459f, 0.04254032f, -0.04626802f, 0.06219411f, -0.03152033f, 
    -0.03047754f, 0.05441291f, -0.01847075f, -0.06601434f, 0.03259118f, 0.03706878f, 0.06396504f, -0.04345109f, 
    0.01326936f, -0.00181065f, 0.00313922f, 0.02993313f, -0.02863484f, -0.00638232f, -0.03704232f, 0.01657921f, 
    0.01762335f, 0.00441424f, 0.00865787f, -0.03054267f, -0.00392828f, -0.04166208f, 0.04715070f, -0.04185158f, 
    -0.04111833f, 0.05368737f, 0.03272102f, -0.05794105f, -0.05527357f, -0.06009740f, 0.03192000f, 0.00494257f, 
    -0.33091643f, 0.03351906f, -0.00473962f, -0.21399513f, 0.02512129f, 0.10122403f, 0.00600901f, -0.00072300f, 
    -0.04613982f, 0.05663539f, 0.04329208f, -0.03157539f, -0.17341267f, -0.19350687f, 0.21739519f, 0.34248143f, 
    0.02026622f, -0.05267141f, -0.03988579f, 0.00683627f, -0.00606614f, 0.05834412f, -0.00681429f, -0.04165767f, 
    0.19426189f, 0.09886058f, -0.00360931f, 0.10346503f, 0.07883877f, 0.15639594f, 0.05197117f, 0.02697301f, 
    0.07314714f, -0.00000482f, 0.02015159f, 0.00924606f, 0.14593524f, -0.08582389f, -0.14618470f, -0.11435635f, 
    0.05369856f, -0.00796165f, -0.00167921f, -0.05568413f, 0.02227343f, -0.00607892f, 0.06464542f, 0.03439213f, 
    -0.02130765f, 0.17677303f, -0.08384712f, 0.26055321f, 0.03762873f, -0.06716187f, 0.06686603f, 0.03806050f, 
    0.05687407f, -0.04853581f, 0.07608628f, 0.04787770f, -0.24193257f, -0.13962036f, 0.00592779f, 0.10124210f, 
    -0.10909693f, 0.09208569f, 0.11352279f, 0.10319842f, 0.03664042f, 0.06315967f, 0.06614130f, -0.05054593f, 
    0.15115294f, -0.21122220f, 0.21379369f, 0.52287060f, -0.03936443f, -0.04735397f, 0.04521938f, 0.00617337f, 
    0.09625456f, 0.05201304f, -0.05177012f, 0.01601307f, -0.19496627f, 0.14771980f, 0.01029680f, 0.26673138f, 
    -0.06338492f, 0.23125087f, -0.09493502f, 0.01299747f, 0.05305515f, -0.05942979f, -0.10554662f, 0.15291178f, 
    -0.28099567f, -0.15244634f, 0.06462315f, -0.06809770f, 0.13373619f, 0.08382669f, -0.02732344f, -0.03255015f, 
    -0.07784107f, -0.04873294f, -0.02006002f, 0.00255778f, -0.18771076f, 0.00550854f, -0.04802667f, -0.00836471f, 
    0.04596440f, -0.00613053f, 0.12238193f, -0.06661768f, 0.02450386f, -0.07276939f, 0.01945301f, -0.02853611f, 
    -0.11122276f, 0.02221962f, 0.03417928f, -0.11519381f, 0.00721585f, -0.06525832f, 0.11684146f, 0.21028188f, 
    0.01040167f, 0.04876285f, -0.06529056f, -0.03186018f, -0.26136670f, 0.18184760f, -0.10018149f, -0.29046005f, 
    0.14821026f, 0.01353256f, 0.09789858f, 0.09601207f, 0.07732937f, 0.05049260f, -0.01600616f, 0.04781794f, 
    0.16787370f, 0.02145704f, 0.08744951f, -0.08351769f, 0.05038347f, 0.03385331f, -0.11863144f, 0.08530361f, 
    -0.06023503f, 0.11554658f, 0.00494272f, 0.11872303f, -0.14043316f, 0.12684940f, 0.08276584f, 0.04337838f, 
    0.07586670f, -0.05353028f, -0.01612534f, -0.00319086f, -0.03286055f, -0.01446898f, -0.00461650f, 0.09288027f, 
    0.04379258f, 0.01135062f, -0.04311623f, 0.23370351f, 0.03629118f, 0.06393300f, -0.03075142f, 0.05627009f, 
    0.03189626f, -0.16701037f, -0.03447457f, 0.08734778f, -0.21186668f, 0.09874046f, 0.10386976f, -0.01215951f, 
    0.03041305f, -0.01864407f, -0.03841873f, 0.15015489f, -0.00697248f, 0.08924253f, -0.03932062f, -0.01045760f, 
    0.21783115f, -0.11365931f, 0.03205103f, 0.12812811f, -0.03048490f, 0.05320561f, -0.02856958f, 0.01715165f, 
    -0.00653728f, -0.01250859f, 0.01469056f, 0.00785193f, 0.02520458f, 0.19005015f, -0.08501379f, -0.14039579f, 
    -0.13027820f, 0.14934282f, -0.04299139f, -0.07316563f, 0.05146826f, 0.00971620f, -0.14000158f, -0.00204450f, 
    -0.05757749f, 0.25451672f, 0.00081746f, -0.17092206f, -0.02840193f, 0.01229491f, 0.08315895f, -0.08572292f, 
    0.02112373f, 0.08650842f, -0.08848403f, -0.03797621f, 0.21568993f, -0.04090669f, 0.18193372f, -0.12983106f, 
    0.08944496f, 0.02780846f, 0.02675596f, 0.17783043f, 0.03810154f, 0.02292733f, -0.00865556f, 0.10103921f, 
    -0.09284444f, 0.01449244f, 0.07293014f, 0.01480580f, -0.06431372f, -0.05696811f, 0.00645629f, -0.10541166f, 
    -0.08632431f, -0.00538622f, -0.02921159f, -0.00531585f, 0.26037726f, -0.10775705f, -0.16437516f, -0.17594013f, 
    -0.04859907f, -0.03281855f, -0.08934306f, 0.00560789f, -0.06944858f, -0.02303766f, 0.04665019f, 0.05670516f, 
    0.02549759f, 0.22994868f, 0.05556824f, -0.09289644f, -0.06629656f, -0.11577733f, 0.19691633f, 0.09146509f, 
    -0.04986118f, 0.08364579f, -0.01269454f, -0.00855016f, 0.23850571f, -0.04714845f, 0.03284327f, -0.02677602f, 
    -0.13144000f, -0.02102529f, 0.01105311f, 0.00824403f, 0.03876405f, 0.06206062f, 0.03753760f, 0.01940251f, 
    -0.31351858f, -0.22480872f, 0.20216376f, 0.31751278f, -0.00749872f, -0.02938157f, -0.01319299f, -0.07802128f, 
    -0.07874586f, -0.02313694f, -0.03337033f, -0.06977824f, -0.27791891f, -0.14306256f, 0.04251534f, -0.00239934f, 
    -0.07673182f, -0.01704882f, 0.08764826f, -0.10605191f, -0.02115415f, -0.00461154f, 0.04947811f, 0.07862338f, 
    -0.11651580f, 0.27389389f, 0.00481895f, -0.13555472f, 0.07613843f, 0.00083853f, -0.03922071f, -0.10349839f, 
    0.04069199f, -0.08488658f, -0.05287422f, -0.02000923f, 0.12654379f, 0.06880590f, 0.15007533f, 0.31709144f, 
    -0.08426952f, 0.04241442f, -0.04164412f, -0.06862105f, -0.00395640f, -0.05038368f, -0.07618449f, -0.05463779f, 
    0.15471072f, -0.13117255f, 0.16618222f, 0.12162901f, -0.12732120f, 0.12532417f, 0.14435828f, -0.00992799f, 
    -0.22442716f, 0.03510783f, 0.01527502f, -0.00517955f, 0.24663380f, -0.25691554f, -0.02161923f, 0.40948170f, 
    0.07107610f, 0.15983425f, 0.06776251f, 0.26989883f, 0.01071467f, -0.00904727f, -0.02661713f, 0.13445957f, 
    -0.01110801f, 0.03718917f, -0.01865223f, 0.02699797f, -0.05814795f, 0.01017543f, -0.00298243f, 0.05513786f, 
    0.03860754f, 0.15968965f, 0.03573615f, 0.02755853f, -0.02390190f, 0.03268189f, 0.19870465f, 0.06531437f, 
    -0.03576465f, -0.12712643f, 0.03140793f, 0.01820507f, -0.03281396f, 0.02703426f, 0.01007720f, 0.12930228f, 
    -0.00288228f, -0.06435639f, 0.02835410f, 0.03312457f, -0.04989368f, -0.07796177f, 0.00226317f, -0.03097085f, 
    0.02747931f, 0.02367870f, 0.02447786f, 0.03450099f, 0.00597313f, -0.04834185f, -0.03234323f, -0.04271178f, 
    0.00993267f, 0.00273655f, -0.02718796f, -0.01587240f, 0.00217760f, -0.03099192f, 0.01533101f, -0.04218150f, 
    -0.04341894f, 0.04272807f, -0.03264948f, -0.03062745f, -0.07288522f, -0.04982310f, -0.05303965f, 0.02984758f, 
    0.03214866f, -0.01892775f, 0.05973656f, -0.04343538f, 0.04417760f, -0.04256063f, -0.05382291f, 0.03343747f, 
    0.02127974f, 0.03036236f, 0.01644362f, 0.07194102f, 0.03284375f, -0.07999178f, 0.00084282f, 0.02225307f, 
    -0.02087182f, -0.01243629f, -0.00622042f, 0.01457576f, 0.04046126f, -0.02961528f, -0.01212811f, -0.05663959f, 
    -0.07607862f, 0.01735155f, 0.00724820f, 0.04990764f, -0.00299214f, 0.03679920f, -0.01330277f, -0.01979752f, 
    0.00662705f, 0.00734829f, -0.05735406f, -0.00864804f, 0.03442268f, -0.00276066f, -0.08101354f, -0.00212644f, 
    -0.00844583f, -0.02498773f, -0.06910235f, -0.07409048f, -0.03822704f, -0.05522650f, -0.02070716f, -0.01096370f, 
    -0.06468257f, 0.04423960f, 0.01233761f, 0.01352300f, 0.01758339f, -0.00386464f, -0.01850623f, 0.04692149f, 
    0.05332527f, 0.03337514f, -0.02875114f, 0.04125780f, -0.00493656f, -0.03873024f, 0.03180701f, -0.02640841f, 
    -0.03890602f, -0.04528131f, -0.03606671f, -0.01268329f, -0.05903939f, -0.06455538f, -0.07653570f, 0.04468136f, 
    -0.07835859f, -0.04206181f, 0.02712109f, -0.00980219f, -0.01111555f, 0.03187284f, 0.00012243f, -0.03121662f, 
    -0.01459622f, 0.02051954f, 0.01581282f, -0.05822057f, 0.03847856f, 0.05228202f, 0.05580044f, -0.00405407f, 
    0.01892049f, -0.07819875f, 0.05775453f, 0.02110537f, -0.04024192f, -0.01633603f, 0.04746335f, 0.05459166f, 
    -0.01940623f, -0.01310178f, 0.00480921f, -0.01006886f, -0.03134118f, -0.05268325f, 0.02191586f, -0.07874499f, 
    0.04042162f, -0.04881928f, -0.04489332f, 0.02804460f, -0.00783755f, -0.05381566f, 0.01523870f, -0.01095728f, 
    -0.04775839f, 0.00395161f, -0.06949619f, -0.00295884f, 0.03708648f, -0.04368601f, -0.07102815f, 0.03626771f, 
    0.01608207f, 0.05784596f, 0.06456254f, -0.00480310f, -0.02726945f, 0.00824004f, 0.06258947f, 0.03162082f, 
    0.01216470f, 0.00471046f, -0.02176347f, 0.02406268f, 0.01142401f, -0.06766530f, 0.02718426f, -0.06507802f, 
    0.00288097f, 0.03966122f, 0.00605449f, -0.00544835f, 0.02560143f, 0.04831715f, -0.05864092f, -0.06487110f, 
    -0.08160764f, -0.06235272f, -0.01464548f, 0.04653300f, 0.05213578f, 0.04597674f, 0.05406051f, -0.06986927f, 
    0.02240607f, -0.08593590f, -0.02850526f, -0.04587176f, -0.02457719f, 0.00796173f, 0.03943661f, -0.06130404f, 
    -0.21369918f, 0.09612141f, 0.06189057f, -0.08969638f, 0.02039860f, 0.11083422f, 0.05412280f, 0.06858250f, 
    0.04022877f, 0.01705421f, 0.16970490f, -0.05506922f, -0.20002457f, -0.07583777f, 0.09523124f, 0.13664852f, 
    0.00108254f, 0.13526073f, 0.12134916f, 0.06393119f, -0.05471629f, 0.02140682f, -0.09017974f, 0.00688001f, 
    -0.02795464f, -0.01420200f, 0.09162684f, -0.02257033f, 0.16666938f, 0.07900729f, 0.12188161f, 0.05885383f, 
    0.04812340f, -0.07129168f, 0.01006079f, 0.11864530f, 0.05286827f, -0.18531390f, 0.00619816f, -0.30648518f, 
    -0.03053994f, 0.00991300f, 0.00643779f, 0.08774854f, 0.02279164f, -0.03306005f, 0.02011967f, 0.03511281f, 
    -0.25251916f, 0.18486586f, 0.10521849f, 0.18458025f, -0.06670808f, -0.10586087f, 0.05277175f, 0.01589685f, 
    -0.02103642f, -0.06395834f, -0.02277324f, 0.12311807f, -0.08293641f, -0.09222434f, 0.00012180f, 0.19641905f, 
    -0.07908000f, 0.19119249f, 0.06933278f, -0.02036808f, -0.02813414f, -0.04015272f, -0.02998822f, 0.02958163f, 
    0.15982521f, -0.07099447f, -0.05386759f, 0.34441683f, -0.07516310f, -0.08410192f, 0.14840539f, 0.03400096f, 
    -0.09546021f, -0.01001816f, -0.03815347f, 0.10791291f, -0.17065564f, 0.05778933f, -0.01558224f, 0.24701616f, 
    -0.02806826f, 0.23139597f, -0.04888999f, -0.02695196f, 0.03160067f, 0.04536662f, -0.08549725f, 0.09947567f, 
    -0.38897663f, -0.06770321f, -0.05885830f, -0.04601633f, 0.09167239f, -0.03222669f, -0.12192020f, -0.09102508f, 
    0.08578651f, 0.03631451f, 0.02379700f, -0.06043157f, -0.14541669f, -0.16449708f, 0.04819367f, 0.10341580f, 
    -0.09536336f, -0.03163151f, -0.03181779f, 0.02604810f, -0.01499229f, -0.05573972f, -0.04339487f, 0.05277798f, 
    0.06455702f, 0.02993324f, -0.00607936f, -0.03038705f, 0.04215270f, -0.11253565f, -0.05867472f, 0.04341790f, 
    0.03956934f, -0.03445093f, -0.00384155f, -0.01108367f, -0.05272011f, 0.12275951f, -0.05604077f, -0.08768290f, 
    0.16517757f, -0.02686766f, 0.04198781f, -0.06533906f, 0.00077365f, -0.04492580f, -0.01252787f, 0.00399114f, 
    -0.06983821f, -0.11189716f, 0.02381803f, 0.10866843f, 0.03792183f, 0.04353880f, 0.08019963f, 0.12348948f, 
    -0.16441022f, 0.19682753f, 0.13031822f, 0.08811481f, 0.04839531f, 0.19913064f, 0.07868412f, -0.09759641f, 
    0.12570105f, -0.01531792f, -0.03852126f, 0.15264000f, 0.04029150f, -0.03361180f, -0.08593987f, 0.07441007f, 
    -0.17482843f, 0.10516334f, 0.00918051f, 0.04251960f, -0.02161006f, 0.09815452f, -0.15833518f, 0.07261579f, 
    0.04782018f, -0.09360034f, 0.01552205f, 0.07127826f, -0.20186774f, 0.01032837f, 0.05078180f, -0.05599632f, 
    0.09188047f, -0.07711893f, 0.04329391f, 0.10431866f, -0.10000727f, 0.10841625f, 0.06251574f, 0.07265780f, 
    0.07997990f, -0.14079016f, -0.06405469f, 0.11299489f, -0.03470047f, 0.08002496f, -0.06047051f, 0.06798600f, 
    0.04965203f, -0.05460607f, -0.03264269f, 0.04632352f, -0.16479205f, 0.16404191f, 0.14632037f, -0.05159405f, 
    0.09484278f, -0.09414329f, -0.07977948f, -0.10046382f, 0.06770462f, 0.05344304f, 0.05038730f, -0.02757579f, 
    0.11425597f, -0.23534839f, 0.13889685f, -0.07511609f, -0.03182585f, -0.01708014f, 0.03036186f, 0.10581221f, 
    -0.00680051f, 0.05338965f, -0.08657512f, 0.05991032f, 0.06454267f, 0.03832820f, 0.01505948f, 0.17952138f, 
    -0.01794046f, 0.03729397f, -0.02275465f, -0.06683183f, 0.03166489f, -0.02048287f, 0.18432683f, 0.09551093f, 
    0.22262858f, 0.07884817f, -0.14440137f, -0.17657210f, 0.00604761f, 0.00953782f, 0.08252236f, 0.08884572f, 
    -0.08592827f, 0.20767564f, -0.06057060f, 0.07512264f, 0.01156005f, -0.11701522f, 0.14170051f, -0.10038632f, 
    0.07119673f, 0.10900717f, 0.05402341f, 0.03896220f, -0.01712781f, 0.10268395f, -0.00585600f, 0.09805053f, 
    -0.08054618f, -0.02565335f, 0.18263011f, -0.04391241f, 0.11796344f, 0.05825262f, 0.05323552f, 0.07928514f, 
    -0.04405849f, 0.01502252f, 0.09748270f, -0.12688789f, 0.00669401f, -0.24449752f, 0.30796510f, -0.23117340f, 
    -0.03990372f, 0.02500792f, 0.09567394f, 0.01806045f, -0.03142417f, 0.04828550f, -0.00099744f, 0.09533464f, 
    -0.15037997f, 0.01458445f, -0.01538292f, -0.10761432f, -0.01736713f, 0.07734327f, -0.00064483f, 0.03628995f, 
    -0.00048587f, 0.02278250f, -0.18504174f, 0.07789423f, 0.31550172f, 0.26662296f, -0.05212253f, -0.29803795f, 
    0.13846034f, 0.03552539f, -0.00305064f, 0.01843067f, 0.09820571f, -0.10558593f, -0.02760861f, -0.05652747f, 
    0.15031374f, 0.06309704f, 0.08704836f, -0.03813562f, -0.05057272f, 0.12866239f, -0.11446623f, 0.00352054f, 
    0.01094890f, 0.03896154f, -0.00526792f, 0.13511191f, -0.15909427f, 0.03018244f, -0.10451598f, 0.07441254f, 
    0.11757319f, 0.11758062f, 0.00155780f, 0.04429024f, -0.04489920f, 0.03258301f, 0.00179783f, 0.01100539f, 
    -0.06249922f, -0.05534761f, 0.06181497f, 0.00008044f, -0.01947582f, -0.09660087f, -0.10737055f, 0.05937492f, 
    0.02465083f, -0.11701892f, -0.12839361f, -0.04388849f, -0.22407052f, 0.09900019f, -0.00712199f, -0.06236078f, 
    -0.10462044f, 0.00554143f, 0.01744462f, -0.04612402f, -0.12499625f, -0.09218034f, -0.03486522f, -0.05786965f, 
    0.15625766f, -0.04587269f, 0.16967012f, 0.08693461f, -0.03150263f, -0.03211184f, 0.07952677f, 0.01152754f, 
    -0.07419971f, -0.01642997f, 0.03313218f, -0.19858627f, -0.27803683f, -0.09475735f, -0.01084357f, 0.01519288f, 
    0.01632255f, -0.07080693f, -0.10992797f, -0.00686042f, 0.12094077f, -0.01052844f, -0.03071098f, 0.03231969f, 
    0.33447957f, 0.00362721f, 0.05595286f, 0.10867035f, 0.23373005f, 0.05389917f, 0.05515338f, 0.04599829f, 
    0.11479278f, 0.00465818f, 0.17456782f, 0.18034753f, 0.02934077f, -0.13421722f, 0.25956124f, -0.15311769f, 
    -0.02737164f, 0.21361473f, 0.11937764f, 0.04797991f, 0.08185605f, 0.08613617f, -0.00846552f, 0.08996084f, 
    -0.14271913f, -0.11678369f, -0.00443815f, 0.13393794f, -0.03244593f, -0.07672235f, 0.09322086f, 0.06511988f, 
    0.03909833f, -0.04469179f, 0.11815268f, -0.04080322f, -0.16687743f, -0.09070408f, -0.19650489f, -0.09812120f, 
    0.01516219f, 0.10875534f, -0.05593255f, 0.07854677f, 0.06844201f, -0.05486434f, -0.13264056f, -0.09017743f, 
    -0.05646461f, -0.15769237f, -0.03550627f, -0.25686762f, 0.18984967f, -0.15607207f, 0.12039571f, 0.02062894f, 
    -0.07158043f, -0.06397900f, -0.04789028f, -0.14026017f, 0.26269135f, 0.02942421f, 0.19210675f, -0.12941927f, 
    -0.06744932f, 0.08804908f, 0.08360126f, -0.02962981f, 0.11937466f, 0.04632731f, 0.15796883f, 0.01312227f, 
    0.02132796f, 0.08864246f, -0.22248618f, -0.11210367f, -0.01111600f, -0.11103919f, 0.05066279f, 0.09869507f, 
    -0.14551926f, 0.06501844f, 0.08311202f, -0.07348852f, -0.08883309f, -0.18510750f, -0.03263595f, -0.18337095f, 
    0.04504227f, 0.03223804f, 0.19847511f, 0.02907435f, 0.03420388f, -0.04140036f, 0.02291269f, 0.05056464f, 
    0.05192661f, 0.04661802f, 0.18369000f, 0.10547323f, -0.26918194f, -0.00251331f, -0.05192722f, 0.01907192f, 
    -0.02272800f, -0.00328724f, -0.02899440f, 0.07295562f, -0.34259751f, -0.16749693f, -0.13610834f, -0.27071252f, 
    0.18249175f, 0.04961804f, 0.02307307f, 0.33413306f, 0.04940204f, 0.18914214f, -0.04824752f, 0.09015464f, 
    0.02097192f, 0.16886741f, -0.12524720f, -0.19349173f, 0.23891674f, 0.21838139f, -0.08516961f, 0.08899006f, 
    -0.14228728f, -0.05449052f, 0.07507429f, 0.10543536f, 0.38646653f, 0.26070774f, 0.12877508f, 0.04773819f, 
    0.05169930f, -0.00195790f, -0.00040439f, -0.06230524f, -0.03839403f, 0.02568907f, -0.03401650f, 0.08725554f, 
    0.13430062f, -0.19421957f, 0.07856725f, 0.19743897f, -0.01855664f, 0.05768315f, 0.06893254f, -0.01685089f, 
    0.04281145f, 0.15655741f, 0.14405060f, 0.08700628f, 0.12746128f, 0.15747164f, 0.19216871f, -0.03220734f, 
    -0.09197957f, 0.11696132f, -0.08037300f, -0.06550705f, 0.03302119f, 0.04041424f, 0.06360830f, 0.11895940f, 
    -0.13445286f, 0.02171880f, 0.00435407f, -0.10249343f, 0.10970042f, 0.11156821f, -0.02486188f, -0.05947403f, 
    0.09680086f, 0.19364081f, 0.04233683f, -0.04678630f, -0.26316816f, -0.22509775f, -0.15114161f, -0.01804469f, 
    0.12498454f, 0.07263173f, 0.12771216f, 0.01730093f, 0.14618690f, 0.07617735f, -0.01595369f, -0.25811705f, 
    0.05072282f, -0.04543302f, 0.03154190f, 0.02818410f, -0.03976440f, 0.03386899f, -0.01181168f, -0.03867346f, 
    0.04280736f, 0.03866460f, 0.01528030f, 0.01308961f, 0.02236804f, 0.05965489f, -0.05609350f, -0.00495010f, 
    -0.02851140f, 0.04224517f, 0.03656528f, -0.06365605f, 0.00716053f, -0.04665139f, -0.00714633f, -0.05269535f, 
    -0.02021136f, 0.03408717f, 0.01256920f, -0.01267844f, 0.00175396f, -0.06737003f, 0.05673382f, 0.06200698f, 
    -0.01995699f, 0.00813946f, 0.06688280f, -0.00455970f, -0.07947397f, -0.04325655f, -0.04704424f, 0.02530709f, 
    0.00662422f, -0.06537610f, 0.05369838f, 0.03789275f, -0.00481672f, 0.02711886f, 0.01344306f, 0.06291965f, 
    -0.03667854f, 0.02140992f, -0.03430080f, 0.05588923f, -0.07449855f, 0.02880152f, 0.04352784f, 0.03859367f, 
    0.01209071f, -0.07062517f, -0.07070285f, -0.02218860f, 0.04140735f, 0.00142211f, -0.06723701f, -0.05793711f, 
    -0.07644098f, -0.06937681f, 0.05704574f, 0.02503059f, 0.01052570f, -0.04191770f, -0.04060198f, -0.02523993f, 
    -0.02098123f, 0.00796746f, 0.04294259f, -0.05291018f, -0.03868612f, -0.01441425f, 0.01303126f, 0.04837937f, 
    0.04582465f, 0.05178226f, -0.01323066f, 0.02078072f, -0.06410899f, -0.04995226f, -0.04935527f, -0.06781178f, 
    -0.06059147f, -0.04514504f, 0.03343857f, -0.07916130f, 0.03056339f, -0.02584885f, -0.04266750f, -0.01602431f, 
    -0.03990656f, 0.06016346f, -0.04061847f, 0.03384924f, 0.01429491f, -0.00410654f, -0.01707218f, -0.04801166f, 
    -0.02882203f, -0.03960028f, 0.02896844f, 0.05480981f, -0.07711747f, -0.05790331f, -0.01533397f, -0.06428950f, 
    0.03252465f, 0.05954234f, -0.04625171f, -0.06230495f, -0.00935758f, -0.05058617f, -0.03952369f, 0.03628254f, 
    -0.07178283f, -0.04095517f, 0.01063443f, -0.05193903f, -0.02299231f, 0.01088010f, -0.06982780f, -0.01388476f, 
    0.01498648f, 0.03395950f, 0.04801736f, -0.00788435f, 0.02910302f, -0.07166401f, -0.07015523f, -0.05019544f, 
    -0.04603557f, -0.07212611f, 0.00005516f, 0.03107946f, 0.00181886f, -0.04160732f, 0.05200263f, -0.02752327f, 
    -0.04797143f, 0.01012200f, 0.00799075f, 0.03781854f, -0.03775449f, -0.05469014f, -0.04641679f, -0.00714648f, 
    -0.05662782f, -0.04626661f, -0.01575087f, -0.06546819f, 0.00335464f, -0.05557758f, 0.00023649f, 0.05860718f, 
    -0.05159191f, 0.02072761f, 0.03810415f, 0.05185631f, 0.02470814f, 0.01800320f, 0.05196954f, 0.01866068f, 
    -0.02399482f, -0.01216389f, -0.01842076f, -0.01148714f, 0.05102792f, 0.04749726f, 0.02828441f, 0.03097276f, 
    -0.04467267f, 0.01299383f, 0.05822693f, -0.02099450f, -0.04287760f, 0.05156476f, -0.00999245f, 0.00636504f, 
    -0.01075431f, -0.00712321f, -0.07711238f, 0.05623239f, -0.06898864f, -0.07769142f, -0.05639780f, -0.03303927f, 
    -0.21077122f, 0.38946208f, 0.05278822f, 0.01227203f, 0.11673725f, 0.00050196f, -0.08160450f, -0.07845417f, 
    -0.00200040f, -0.00971783f, -0.06042997f, 0.04781936f, -0.06654100f, -0.02500392f, -0.01037438f, -0.05338005f, 
    0.01196528f, -0.00916958f, 0.07034434f, 0.04779792f, -0.04372393f, -0.03782904f, 0.11925764f, 0.05023364f, 
    -0.28389174f, -0.02927168f, -0.10070249f, 0.03970050f, 0.00172006f, 0.03192892f, 0.02804215f, 0.07007322f, 
    0.00907730f, -0.01552455f, -0.09565757f, 0.06861525f, -0.22827484f, 0.00909968f, -0.28534648f, 0.11458920f, 
    0.00538567f, -0.01631450f, 0.03145818f, -0.01498480f, 0.02915192f, 0.02472066f, 0.03909860f, -0.07093921f, 
    0.12341977f, 0.03214375f, 0.01946379f, 0.00773128f, 0.15481664f, 0.15121274f, -0.13132115f, 0.13816024f, 
    0.12046083f, 0.02121020f, -0.03386734f, 0.04574854f, 0.14519668f, 0.25318405f, 0.02454019f, 0.12823026f, 
    -0.03660462f, 0.05161928f, 0.09710736f, -0.00148675f, -0.01206982f, 0.02403529f, -0.08578825f, -0.10934742f, 
    0.18220103f, -0.44801101f, -0.18970563f, 0.08266959f, 0.10817067f, 0.25430527f, -0.12347643f, -0.12204319f, 
    0.11742734f, 0.13318141f, 0.02529822f, 0.06280260f, -0.31573617f, 0.17122029f, 0.11821757f, 0.05059842f, 
    0.04213604f, -0.03349357f, 0.04548992f, 0.01519293f, 0.14630389f, -0.11317966f, 0.06544479f, 0.09845733f, 
    0.29511431f, 0.14758383f, -0.09542096f, -0.15603942f, 0.13659275f, 0.25673488f, 0.05357152f, -0.00445335f, 
    -0.05137912f, 0.05788619f, 0.04146825f, 0.09841742f, 0.33168930f, -0.03951047f, 0.04120045f, -0.00794133f, 
    -0.11720729f, -0.03129512f, -0.05568814f, -0.05618618f, 0.04619548f, -0.00115303f, -0.05758315f, -0.02229801f, 
    0.29543921f, -0.12187221f, -0.03153940f, 0.07691690f, -0.01849359f, -0.10996914f, -0.04920316f, 0.08364387f, 
    0.09696495f, 0.01841532f, 0.02032667f, -0.06206699f, -0.15836360f, 0.06012703f, 0.07944628f, -0.19053216f, 
    0.14044939f, 0.04540513f, -0.00427676f, -0.07151826f, -0.00496712f, 0.02869196f, 0.11852580f, -0.06148796f, 
    0.01158625f, 0.01900971f, 0.05663189f, 0.02565350f, 0.13390751f, -0.01729974f, -0.09266420f, 0.04723540f, 
    0.16850090f, 0.07778776f, -0.01740090f, 0.09400546f, -0.34776959f, 0.03918587f, -0.16433966f, -0.28955254f, 
    0.11555286f, -0.07032694f, 0.03473212f, -0.14769946f, 0.03963065f, -0.00030170f, 0.08259770f, -0.06507809f, 
    -0.01090212f, -0.05130595f, 0.00321337f, 0.10531379f, -0.08708657f, 0.09385620f, 0.17251189f, -0.06191129f, 
    0.15183085f, -0.09001735f, -0.11853420f, -0.02533359f, 0.36388081f, -0.10441026f, -0.17844383f, -0.12144021f, 
    -0.05885781f, -0.07684765f, -0.00958895f, 0.05881858f, -0.07856575f, 0.04477057f, 0.13249822f, -0.03362395f, 
    -0.13191031f, 0.13873082f, 0.29066157f, -0.28343439f, -0.12125647f, -0.09561407f, 0.04895575f, -0.07694793f, 
    0.07231679f, -0.14190470f, -0.07246990f, 0.04572168f, -0.00080649f, 0.07299334f, -0.03112533f, 0.27137959f, 
    -0.05430319f, 0.04947291f, -0.04908536f, -0.02621070f, 0.01649620f, 0.06547085f, 0.00227410f, -0.04936319f, 
    0.25525916f, 0.07121384f, -0.08489922f, 0.05115977f, 0.17037791f, 0.08169080f, 0.06997591f, -0.02810499f, 
    -0.01589509f, 0.02925094f, 0.00447521f, 0.08027427f, -0.02641028f, -0.06634615f, -0.18782327f, 0.07950790f, 
    0.11596562f, 0.07298681f, 0.06412681f, 0.05855626f, 0.13248453f, 0.17869973f, 0.15086856f, 0.04799654f, 
    0.08075253f, -0.19015284f, -0.36762202f, 0.00952154f, 0.04374359f, 0.08975030f, 0.02761139f, -0.04190526f, 
    0.01140890f, 0.08258890f, 0.01320151f, -0.04841316f, -0.00204863f, 0.08314872f, -0.12361977f, -0.06760605f, 
    -0.09236281f, -0.05078529f, 0.03695797f, 0.02927205f, 0.10132899f, 0.02618680f, 0.03040238f, -0.09668970f, 
    -0.13583250f, -0.10864545f, 0.16629526f, 0.40234411f, 0.03746739f, 0.17824800f, 0.05603380f, -0.01598877f, 
    0.01979976f, 0.03832054f, 0.00371400f, 0.10219401f, -0.10576206f, 0.21040516f, -0.15837038f, 0.25597116f, 
    -0.04326823f, -0.01978020f, -0.16324274f, 0.00754579f, 0.11166426f, 0.11838144f, -0.08212578f, -0.06655562f, 
    0.18838312f, 0.06390245f, 0.10586044f, 0.07861845f, -0.00675503f, 0.00920722f, -0.03247274f, -0.09194610f, 
    -0.17743824f, -0.08969832f, -0.03955872f, -0.14992517f, -0.05134514f, 0.03698557f, -0.33975136f, -0.11828238f, 
    -0.03620940f, 0.07050648f, 0.01063488f, -0.02325897f, -0.06622458f, -0.02022899f, 0.03373305f, -0.10821334f, 
    -0.23567341f, 0.00147955f, 0.07269513f, -0.15608087f, 0.02716494f, -0.20648359f, 0.00729146f, 0.13041976f, 
    0.00728284f, 0.02717055f, -0.03617292f, 0.08681981f, -0.05880146f, 0.01459469f, 0.06376007f, -0.14860851f, 
    0.13375157f, 0.01020160f, -0.12934248f, -0.18313791f, -0.01011645f, -0.20066175f, -0.12902519f, -0.01841889f, 
    0.09801949f, 0.19895692f, -0.01725266f, -0.34338242f, -0.10858370f, 0.08128730f, -0.04533458f, 0.07276862f, 
    0.01706953f, -0.08521591f, -0.04574295f, 0.14194430f, 0.14373721f, -0.12054750f, 0.03445230f, 0.43968347f, 
    -0.10595172f, 0.01994754f, 0.20802854f, 0.08245813f, -0.07504897f, 0.23164532f, 0.13265462f, 0.12502559f, 
    0.04152021f, 0.03522390f, 0.12588023f, 0.12099972f, 0.03512357f, -0.12555453f, 0.13063312f, 0.04844091f, 
    0.14139134f, -0.09897683f, 0.13905220f, 0.09875357f, 0.01270758f, 0.05614109f, -0.01477612f, -0.17263575f, 
    0.04737252f, -0.07639202f, -0.05252315f, 0.12647210f, -0.09651445f, -0.01266197f, 0.07075905f, 0.14460489f, 
    0.22170880f, -0.09360987f, -0.04632213f, 0.07190887f, 0.09812463f, -0.06709310f, 0.10470814f, -0.01106231f, 
    0.14761850f, 0.01432949f, -0.17118099f, 0.05329767f, -0.31726515f, -0.39246693f, -0.10020266f, -0.08807554f, 
    0.03988466f, 0.00654204f, 0.11223461f, -0.02985050f, 0.00555327f, 0.03140602f, -0.00545176f, -0.13767917f, 
    -0.10157602f, 0.00183415f, -0.03900480f, 0.00586244f, -0.00495994f, 0.07136001f, -0.04098907f, 0.04599993f, 
    -0.00137381f, 0.04854120f, 0.04706334f, -0.00160901f, 0.03974728f, 0.12511285f, -0.05121817f, 0.08721240f, 
    0.01335938f, 0.03958971f, 0.15888652f, 0.03487276f, 0.04095736f, 0.00826459f, -0.04523588f, 0.05957355f, 
    0.04416120f, -0.11440682f, 0.01582289f, 0.18467960f, 0.10121079f, -0.03904754f, -0.08624939f, 0.11843988f, 
    0.09903849f, -0.13115643f, 0.19813251f, -0.12267695f, 0.02399012f, -0.24563973f, 0.06860573f, 0.10424894f, 
    0.02843086f, 0.02963642f, 0.01230063f, -0.00596725f, 0.06731123f, -0.00714073f, -0.11074290f, 0.02404579f, 
    0.31848443f, 0.20080096f, -0.12149509f, -0.25294405f, -0.10773042f, 0.08352900f, -0.02254558f, -0.04279080f, 
    0.05108698f, 0.05744544f, 0.08895126f, 0.05760067f, -0.00952989f, -0.23834293f, -0.31362808f, -0.01176130f, 
    -0.08083855f, 0.13998677f, 0.07096507f, 0.09689610f, -0.04402086f, 0.02342066f, -0.03373379f, -0.13646917f, 
    -0.39051598f, 0.12380264f, -0.05819826f, -0.05895820f, 0.03721629f, -0.08007921f, -0.03547163f, 0.02215709f, 
    0.05436767f, -0.13161786f, -0.06192647f, -0.02847639f, -0.12370593f, -0.04947519f, 0.03399893f, 0.23381573f, 
    -0.11448990f, -0.14883755f, 0.02692120f, 0.05437712f, -0.01372123f, 0.08746692f, 0.02227959f, -0.01361603f, 
    0.17579383f, -0.13525397f, -0.17313875f, 0.14316389f, 0.04019302f, 0.03668576f, 0.06498142f, -0.03464823f, 
    -0.06991662f, -0.14095417f, 0.05936673f, -0.03860259f, 0.13150483f, 0.05973593f, 0.08605738f, -0.11508483f, 
    -0.12815449f, 0.07083698f, 0.00620367f, 0.04339080f, 0.06888481f, -0.05442040f, 0.17512704f, -0.04281501f, 
    0.15560314f, -0.20070764f, -0.08101869f, -0.00305889f, 0.01178288f, 0.02555791f, 0.09504243f, 0.09813082f, 
    0.03701433f, -0.11662398f, 0.18301781f, -0.05865870f, -0.12805755f, 0.19494537f, 0.26717576f, -0.25371143f, 
    0.18483697f, 0.21538879f, -0.04663171f, -0.01673695f, 0.13404283f, 0.00168231f, 0.12828180f, 0.01205597f, 
    -0.15568703f, -0.12064410f, -0.01587179f, -0.01418819f, 0.14658175f, 0.17761257f, 0.24492306f, -0.02921897f, 
    0.07577232f, 0.05094720f, -0.09992514f, -0.08645778f, 0.24028140f, 0.05342682f, -0.06557453f, -0.07078794f, 
    -0.06094909f, 0.18685666f, 0.06701403f, 0.20787330f, 0.03466892f, 0.09985731f, 0.04788946f, -0.07043732f, 
    -0.08919125f, 0.00584540f, 0.15841047f, 0.07971640f, -0.15005434f, 0.05190528f, 0.01041024f, 0.01973110f, 
    0.03289287f, 0.05108275f, 0.07015663f, 0.03591732f, 0.09906770f, 0.30322650f, -0.15429357f, 0.12266771f, 
    -0.08514177f, 0.10914987f, 0.01157790f, 0.00178195f, 0.01746973f, -0.07621852f, 0.05674990f, 0.12477165f, 
    -0.14346144f, -0.00318445f, 0.13488659f, -0.11897018f, -0.03136795f, 0.03590423f, 0.01509786f, -0.02691108f, 
    0.00780593f, 0.02856720f, -0.03580057f, 0.04332320f, 0.18082502f, -0.15424132f, 0.02288698f, -0.22092313f, 
    -0.13464709f, -0.05522209f, 0.04717483f, 0.03387200f, -0.00016968f, -0.11726595f, -0.09650467f, 0.02349531f, 
    -0.15648893f, 0.01601026f, 0.15457273f, -0.23435460f, -0.17728180f, 0.03619752f, -0.02879007f, 0.00626529f, 
    -0.04402477f, 0.05057688f, 0.03255221f, -0.02258167f, -0.10626836f, 0.18038256f, -0.16522965f, 0.13682953f, 
    0.06777764f, 0.07522751f, -0.11514003f, 0.10631384f, -0.02477217f, 0.03857822f, 0.09650166f, -0.01024585f, 
    -0.29414433f, 0.21658817f, 0.11690508f, -0.19915740f, 0.16491419f, 0.02886183f, 0.08219112f, -0.05673665f, 
    0.04216804f, 0.23344265f, -0.01466004f, 0.14570121f, 0.17165256f, -0.08529064f, 0.07955686f, -0.03359197f, 
    0.03895353f, 0.01154668f, -0.01600099f, 0.05240444f, 0.01956196f, -0.05495627f, -0.04457311f, 0.11306589f, 
    -0.09419263f, 0.16423242f, 0.05006161f, 0.21701407f, 0.14327057f, 0.08337625f, -0.02754248f, -0.07318046f, 
    0.05236199f, 0.13493893f, 0.08075674f, -0.05089236f, 0.09576077f, -0.18268658f, -0.00601125f, -0.15956835f, 
    -0.15954903f, -0.05147041f, 0.02871374f, -0.05210768f, -0.07230439f, 0.03507013f, -0.06258354f, 0.10060084f, 
    0.22172731f, 0.15299881f, 0.07824097f, 0.13747528f, 0.00201072f, -0.02471891f, 0.07163473f, -0.08301483f, 
    0.06963064f, -0.07006029f, 0.00077528f, -0.02481110f, 0.11556309f, -0.17000692f, 0.03453829f, 0.19794244f, 
    -0.06285649f, -0.03147802f, -0.02465562f, -0.08784717f, 0.03527010f, 0.02749471f, 0.08240872f, -0.03388563f, 
    -0.14496121f, 0.00097351f, 0.02689028f, 0.03889192f, 0.15289778f, 0.04937276f, 0.02612033f, -0.00082096f, 
    -0.05474897f, 0.07797600f, -0.14326742f, 0.03943417f, 0.28804499f, -0.21701196f, -0.04683029f, 0.15074651f, 
    0.09718596f, -0.06555168f, 0.05626334f, 0.11422262f, 0.13235277f, -0.02178223f, -0.07592995f, -0.09350344f, 
    0.11739484f, 0.11411682f, 0.06198271f, -0.02206950f, -0.05120826f, -0.06008080f, 0.05316733f, -0.01978754f, 
    0.20802391f, 0.08888844f, 0.11968715f, 0.00291702f, 0.15679422f, -0.00556726f, 0.11950962f, 0.01403805f, 
    -0.09940936f, 0.01660961f, 0.13565780f, -0.06465025f, 0.10599554f, -0.01953093f, 0.13066167f, 0.15061918f, 
    0.26886410f, 0.32557479f, 0.10889354f, 0.08396648f, -0.01115559f, 0.06463647f, 0.00928012f, 0.08042645f, 
    -0.06605223f, 0.04954158f, 0.09787378f, -0.01296554f, -0.05768862f, 0.02807035f, 0.09089078f, -0.02879409f, 
    -0.04295903f, 0.11720364f, 0.00260084f, 0.01822609f, -0.03494795f, -0.05630426f, -0.05376620f, 0.05352440f, 
    -0.18340050f, 0.16870646f, 0.02760785f, -0.00349096f, -0.11458682f, -0.09968705f, -0.03521743f, -0.05877542f, 
    -0.01152847f, -0.01766901f, -0.03816851f, -0.06388365f, 0.05964356f, 0.18532275f, -0.10734470f, 0.23845138f, 
    0.14223592f, 0.08810183f, 0.04754005f, 0.01758517f, -0.05738125f, -0.03437705f, -0.03640711f, 0.01710057f, 
    -0.18711160f, 0.01037859f, 0.05155447f, -0.12577680f, 0.20936051f, 0.08838835f, 0.02557211f, 0.05503584f, 
    0.04748954f, 0.10876309f, -0.02380469f, -0.08840911f, 0.23248611f, 0.09622904f, -0.10643125f, -0.02215726f, 
    0.05955894f, -0.09198970f, 0.03732106f, -0.00353277f, -0.02524730f, 0.03075865f, 0.12151558f, -0.05088495f, 
    0.30513835f, -0.41863582f, -0.04082432f, 0.05697969f, -0.08684766f, -0.19406195f, 0.10175300f, 0.09854926f, 
    0.04910263f, -0.10301259f, 0.06875218f, 0.02620384f, 0.20797764f, 0.15547305f, 0.10371525f, 0.15202123f, 
    -0.04842645f, -0.02798291f, -0.07425047f, 0.04637061f, -0.08335839f, -0.07183278f, 0.00332594f, 0.07970766f, 
    0.06577571f, 0.02681046f, 0.15073025f, -0.12899472f, -0.09537140f, 0.07460988f, 0.03615202f, -0.07777680f, 
    -0.10208022f, -0.13211538f, -0.11348755f, 0.11853934f, -0.21543157f, 0.10914769f, 0.02658296f, 0.01937230f, 
    0.14221454f, 0.07733502f, -0.03416973f, -0.00677707f, 0.14942856f, 0.01914313f, -0.07562173f, 0.10360657f, 
    -0.08329903f, -0.07455306f, 0.08904389f, -0.16562425f, 0.00174064f, -0.01350733f, -0.03197264f, 0.08638403f, 
    -0.03846161f, -0.07934268f, 0.00411528f, 0.00190205f, 0.19272016f, 0.38814405f, -0.02061445f, 0.03647712f, 
    0.03384954f, 0.08570480f, 0.08380701f, 0.02078590f, -0.05371388f, 0.06970614f, -0.10061809f, -0.06507443f, 
    0.18799342f, -0.28582269f, 0.29680800f, 0.07515436f, -0.05538341f, 0.03634156f, -0.14810643f, -0.16340342f, 
    0.00941793f, 0.10510050f, 0.07505617f, -0.01832336f, -0.20705482f, -0.00515451f, 0.01507561f, -0.09494276f, 
    -0.10058608f, -0.02047122f, -0.00869825f, 0.13324854f, -0.10667453f, -0.09111662f, 0.04395524f, 0.08330703f, 
    0.09360396f, -0.05361266f, -0.12078059f, 0.03612679f, -0.04142389f, 0.07029985f, -0.01238165f, -0.06729172f, 
    -0.05359305f, 0.01541230f, 0.01138894f, 0.00705247f, -0.02282028f, -0.10482144f, 0.08685161f, 0.11785752f, 
    0.01161866f, -0.09954320f, -0.04963016f, -0.06767686f, 0.13026196f, -0.03145613f, 0.08252475f, 0.07488666f, 
    -0.40197986f, 0.04926341f, -0.11646739f, -0.11682016f, -0.02460998f, -0.02597882f, 0.00756050f, 0.00583179f, 
    -0.01692723f, 0.03782276f, 0.01033299f, -0.00913694f, 0.27513275f, 0.02950787f, -0.08195993f, 0.16996138f, 
    -0.03908846f, -0.03055126f, 0.08406313f, 0.04048757f, -0.04325946f, -0.02165572f, 0.09471467f, -0.01311572f, 
    -0.02688212f, -0.04025959f, -0.10416348f, 0.08690467f, 0.14140803f, 0.18662007f, 0.04310487f, 0.00051732f, 
    -0.08495757f, 0.07279930f, 0.12042193f, 0.02436021f, -0.01744330f, -0.04935845f, -0.02038136f, -0.24676313f, 
    -0.06626914f, -0.05786602f, 0.02732049f, -0.00372833f, 0.10372426f, 0.09753522f, 0.10166261f, 0.00321548f, 
    0.07854377f, 0.08651663f, 0.03604561f, 0.20717125f, -0.05533453f, 0.05835028f, 0.06181518f, -0.08954106f, 
    0.07628562f, -0.08499778f, -0.06837635f, 0.03113344f, -0.08653849f, 0.06309675f, -0.11348525f, 0.20090260f, 
    -0.00836708f, 0.16220795f, 0.03400297f, -0.04726515f, 0.03699926f, -0.01440329f, 0.00175634f, 0.04022651f, 
    -0.06686523f, 0.10784075f, 0.07385938f, 0.27997300f, 0.04445268f, 0.03169803f, 0.03228731f, -0.02550951f, 
    0.06009926f, -0.03960091f, -0.01931817f, 0.06835280f, -0.14937772f, 0.32773346f, -0.06565083f, 0.28191909f, 
    0.17722201f, 0.05757206f, -0.05449893f, -0.06892084f, 0.10991054f, 0.06560543f, 0.05940785f, 0.10672949f, 
    0.08495918f, -0.07606065f, -0.02254290f, 0.02172456f, 0.05009062f, 0.06766052f, -0.00322700f, -0.06530107f, 
    -0.03860890f, 0.07177856f, 0.10338584f, 0.00361525f, -0.07880244f, -0.17713328f, 0.05053793f, 0.09343239f, 
    -0.15571758f, -0.07357496f, -0.06556544f, -0.02477066f, -0.06872372f, -0.07221370f, -0.08417752f, -0.06284431f, 
    -0.11514763f, -0.05914491f, 0.11025885f, 0.08710480f, 0.03689706f, -0.07733764f, 0.03528949f, 0.11646699f, 
    0.07634406f, 0.09210843f, 0.06959613f, 0.06226213f, -0.20898144f, -0.14096984f, -0.08534916f, -0.16546312f, 
    0.13603702f, -0.00047389f, -0.00801938f, 0.02562829f, -0.08778102f, -0.03949344f, 0.08987679f, 0.17185526f, 
    -0.07314240f, 0.12343937f, -0.23329303f, 0.04165905f, 0.06882736f, 0.06494957f, -0.03910049f, -0.00351552f, 
    -0.07265623f, 0.05944667f, -0.02272017f, 0.05736481f, 0.21905050f, -0.15082163f, -0.05881637f, 0.11053313f, 
    0.01050971f, -0.02195013f, 0.04750760f, -0.06630664f, 0.09893008f, 0.07211214f, -0.08502311f, -0.13982588f, 
    -0.03406009f, 0.06283601f, 0.01134898f, 0.07579456f, 0.05984454f, -0.12506613f, -0.07308760f, -0.03900866f, 
    0.09804751f, -0.13311736f, -0.01091445f, 0.01207580f, 0.09412150f, 0.10964666f, -0.01674102f, -0.04332496f, 
    0.10748696f, -0.14098161f, 0.05498841f, 0.03448452f, -0.06308050f, 0.04283944f, 0.12493394f, 0.06732526f, 
    -0.19436809f, 0.14586605f, 0.04078650f, -0.21464871f, 0.12583153f, 0.01077830f, 0.00796767f, 0.04208903f, 
    -0.02065728f, -0.00640217f, 0.07508416f, 0.05282729f, 0.10678404f, -0.11203083f, 0.16661963f, 0.08101444f, 
    -0.06938573f, 0.04723281f, -0.06045689f, 0.02819519f, 0.05744489f, -0.02379383f, -0.12573780f, -0.02763954f, 
    0.06313347f, 0.18446578f, -0.08685415f, 0.13265328f, 0.04353357f, 0.07668928f, -0.04305087f, -0.03147352f, 
    -0.02271578f, -0.04151887f, 0.04425157f, 0.01663670f, 0.03436945f, -0.04476482f, -0.02886569f, 0.09506852f, 
    -0.01377005f, 0.10547069f, -0.09820919f, 0.01410138f, 0.13021939f, -0.03543838f, 0.12931947f, -0.14117165f, 
    0.03990244f, -0.01385147f, -0.12974750f, 0.04821910f, 0.09113133f, -0.00665283f, 0.13437884f, -0.09833267f, 
    -0.06880322f, 0.01934182f, 0.01845425f, -0.01347038f, -0.13916852f, 0.18292950f, 0.09161696f, 0.07252429f, 
    -0.07221576f, 0.00339236f, 0.10377219f, 0.03498045f, 0.04972906f, -0.03096893f, 0.07277361f, -0.09767959f, 
    -0.01892132f, 0.05950781f, 0.08299122f, 0.35716254f, 0.00362142f, -0.07804472f, 0.01268810f, -0.05607781f, 
    -0.00420055f, -0.09357863f, -0.00168366f, -0.14087115f, -0.04628487f, 0.13654104f, -0.07823293f, 0.26852286f, 
    0.15657718f, -0.03195091f, 0.01312147f, -0.10351048f, 0.07519599f, 0.01168915f, -0.09627261f, -0.03302760f, 
    0.11238876f, 0.08512145f, 0.24165589f, 0.10198417f, -0.06098535f, 0.09557750f, 0.04125020f, 0.05325550f, 
    -0.00970812f, 0.05319205f, -0.02987152f, -0.01963367f, -0.14486209f, -0.00114487f, -0.07991571f, 0.04787254f, 
    0.01928152f, 0.15637864f, -0.01441640f, 0.09193633f, -0.01392432f, -0.01729218f, -0.08779082f, 0.02456003f, 
    -0.33800772f, 0.00807790f, 0.16948138f, -0.13672808f, 0.04539625f, 0.02944730f, 0.08992670f, 0.05275161f, 
    -0.01503550f, 0.05676489f, 0.05077793f, 0.03908056f, -0.05456474f, -0.09104633f, 0.11227868f, -0.21018927f, 
    0.03240777f, 0.03427518f, 0.08681527f, 0.07773154f, -0.06212990f, -0.00354176f, -0.14850351f, 0.04850081f, 
    0.08498848f, 0.13778608f, 0.04626858f, -0.13930076f, -0.01210652f, 0.08249440f, 0.00576675f, -0.07449315f, 
    -0.08693232f, 0.07112564f, 0.09935571f, -0.03106567f, 0.40935162f, -0.13255596f, -0.10935370f, 0.28448671f, 
    -0.08054810f, 0.03671065f, 0.07220735f, 0.10930767f, -0.04956946f, 0.18869120f, -0.06491067f, 0.02193451f, 
    0.09995145f, 0.09878691f, -0.06528086f, 0.00002249f, 0.12314723f, -0.07391385f, -0.10091215f, 0.09976787f, 
    -0.03484555f, 0.03821306f, 0.17891014f, 0.24017704f, -0.04113865f, 0.03968211f, -0.01696620f, 0.12367956f, 
    0.07362966f, -0.07164119f, 0.02533980f, -0.05106809f, -0.04218837f, -0.12301947f, -0.12124003f, 0.01963929f, 
    -0.02800279f, 0.05435725f, -0.00798492f, 0.04016393f, -0.01420882f, -0.01685786f, -0.03355215f, 0.07005307f, 
    -0.07241603f, 0.00585943f, 0.01722251f, -0.04774128f, -0.07716631f, 0.05645997f, 0.01277649f, -0.04628137f, 
    0.05270660f, -0.01919791f, -0.07141827f, 0.01069331f, 0.05298534f, 0.02616569f, -0.04452085f, 0.02542311f, 
    -0.04371841f, -0.06299510f, -0.02374681f, -0.04675250f, -0.07432438f, -0.06676871f, 0.02955871f, 0.04322008f, 
    -0.06278378f, -0.02812547f, -0.03800800f, -0.06531699f, -0.03508710f, -0.00210892f, -0.02839709f, 0.03232152f, 
    -0.07081848f, -0.02334333f, 0.06333403f, -0.03178855f, -0.02111296f, -0.00060360f, 0.00399442f, -0.06001596f, 
    0.01499609f, -0.07256551f, 0.05143008f, -0.03395501f, 0.00734999f, 0.02892788f, 0.06458777f, -0.06321830f, 
    0.03403438f, 0.00607219f, -0.05533322f, 0.06548044f, -0.02995237f, 0.03380837f, -0.03336412f, -0.05615136f, 
    0.04552526f, 0.00666874f, 0.01246535f, -0.04092396f, 0.01358032f, 0.06329717f, -0.04186555f, -0.07004560f, 
    0.05231012f, -0.04272064f, 0.03344834f, -0.01481442f, 0.06580962f, -0.05847288f, 0.06426986f, -0.01793865f, 
    -0.00004653f, 0.00107222f, -0.01745374f, 0.06971072f, -0.07052299f, 0.00386603f, 0.05359218f, 0.04641035f, 
    -0.03606183f, 0.01360354f, 0.04307894f, -0.05892605f, 0.02002429f, -0.07047639f, 0.02846337f, -0.03694183f, 
    -0.06242298f, -0.01721676f, -0.03543432f, 0.04573977f, 0.05544990f, 0.05191807f, -0.01621490f, 0.05415697f, 
    -0.00352775f, -0.00413491f, 0.03558468f, 0.02474025f, -0.02839409f, -0.05937292f, -0.05431567f, 0.05583942f, 
    0.03242077f, 0.01968114f, -0.03067243f, -0.05620351f, -0.05039310f, -0.05263987f, -0.06932699f, 0.00872708f, 
    0.01880610f, -0.04498911f, -0.00478607f, 0.03041167f, -0.07759938f, -0.00185739f, -0.06140897f, -0.07013377f, 
    0.04103198f, 0.00763475f, -0.04389696f, 0.02557060f, 0.04976566f, -0.02020254f, 0.05782845f, -0.01032507f, 
    -0.07308165f, -0.02984548f, 0.00091850f, 0.02401340f, 0.01480785f, -0.05741459f, -0.03437905f, 0.02390284f, 
    -0.05446017f, 0.00345778f, -0.07326312f, 0.05183383f, 0.04818900f, -0.00155928f, -0.06558242f, -0.05131266f, 
    -0.01730506f, -0.03360226f, -0.00754423f, -0.00615446f, -0.06977651f, 0.01519874f, -0.01961292f, -0.03311478f, 
    -0.01301932f, 0.05874768f, 0.06499551f, -0.04238865f, -0.04283091f, -0.01518125f, 0.03978489f, 0.03590211f, 
    -0.01311022f, -0.02446284f, -0.03610520f, -0.04153637f, -0.02480443f, 0.04912905f, -0.03103099f, 0.00541079f, 
    -0.01536418f, 0.01118559f, -0.05612161f, -0.04600304f, 0.05001650f, 0.02366719f, 0.05079427f, -0.01559315f, 
    0.03465290f, -0.07238174f, -0.07461498f, 0.05136217f, -0.04962888f, 0.05532851f, -0.05063510f, -0.06691205f, 
    -0.08684636f, -0.07773987f, 0.33351183f, -0.29973122f, -0.03950097f, -0.01412247f, 0.07261991f, 0.13630773f, 
    0.11322152f, 0.04162775f, 0.16014569f, 0.12277288f, -0.26033619f, 0.05880601f, 0.11450659f, -0.02196070f, 
    0.11842967f, 0.01359304f, 0.00198170f, 0.14698957f, -0.06035363f, -0.11762904f, -0.05541680f, -0.01528067f, 
    0.16380806f, -0.01799093f, -0.06222993f, 0.12784834f, -0.00224483f, -0.02515530f, 0.02974455f, -0.17225713f, 
    0.01853504f, 0.04200487f, 0.01201139f, 0.07472207f, -0.22260951f, -0.05764688f, -0.03101779f, -0.08113507f, 
    0.06507469f, -0.03795195f, -0.00460917f, 0.00755432f, -0.02375286f, -0.13162930f, 0.09094139f, -0.06707034f, 
    -0.10234891f, -0.06230458f, 0.10622756f, -0.08656557f, 0.03760831f, 0.06085894f, 0.03805673f, -0.00885005f, 
    -0.00969985f, -0.17065445f, -0.00328037f, 0.13574468f, -0.29787484f, -0.08121648f, -0.10132463f, 0.07411867f, 
    -0.00498289f, -0.11076301f, 0.15105459f, 0.08462908f, -0.04272940f, -0.12973662f, 0.09692419f, -0.10780463f, 
    -0.02246168f, 0.22714330f, -0.05637934f, 0.07107601f, -0.00691758f, 0.00215764f, -0.06390246f, -0.20739670f, 
    0.09733689f, 0.01235413f, -0.06160641f, 0.02052484f, -0.11214104f, -0.13465618f, -0.16567877f, 0.03699765f, 
    0.07649897f, -0.03825115f, 0.10131481f, -0.13478731f, -0.09060755f, -0.02232327f, -0.12720479f, -0.03836951f, 
    -0.09317951f, 0.25850981f, 0.07497928f, -0.05035019f, 0.05202615f, 0.09214726f, 0.04619028f, 0.05495434f, 
    0.10188477f, 0.07524905f, 0.04504425f, 0.00881858f, 0.46591499f, 0.04128295f, 0.00842123f, 0.02841826f, 
    -0.09009685f, -0.03334408f, 0.02305130f, 0.06323935f, -0.03515122f, -0.04081930f, -0.07442982f, 0.05995129f, 
    -0.05374500f, 0.03198013f, 0.00098789f, -0.07009856f, -0.04609239f, -0.05635058f, 0.06784323f, -0.10162205f, 
    0.05127556f, -0.05657012f, 0.13762520f, -0.01493178f, -0.08837126f, -0.17616379f, 0.05002903f, -0.03225059f, 
    -0.06897996f, 0.07684848f, 0.00438177f, 0.09088722f, 0.18373767f, 0.03008085f, 0.01683508f, 0.05844437f, 
    -0.06388849f, 0.23037890f, 0.01998747f, -0.12092714f, -0.03628982f, 0.06946886f, 0.20173073f, 0.06987060f, 
    0.02951590f, -0.02558260f, 0.04302904f, 0.10643326f, 0.12433798f, 0.13689053f, 0.05352503f, 0.10512727f, 
    -0.00148256f, -0.06724924f, 0.14679007f, 0.11849789f, 0.12310299f, 0.19958679f, -0.09865675f, 0.03291209f, 
    -0.14080764f, -0.10250144f, 0.11882978f, -0.06426074f, -0.03725759f, 0.06469782f, 0.07235859f, 0.10901575f, 
    0.01005210f, -0.08985554f, -0.04908209f, 0.15388934f, 0.22086650f, -0.00841012f, -0.00311360f, 0.10789979f, 
    -0.00425303f, 0.01423775f, 0.08342904f, 0.02481299f, -0.02033531f, -0.11146984f, 0.02286884f, -0.05282338f, 
    -0.09201305f, 0.11198825f, -0.07945982f, 0.04591722f, 0.08084274f, 0.05807086f, 0.01847040f, -0.01670228f, 
    0.07987902f, 0.05267022f, 0.06108697f, 0.03656058f, -0.07742561f, -0.05645883f, 0.23419617f, -0.07441240f, 
    0.03330389f, -0.01570676f, 0.09064287f, -0.03613555f, -0.11329572f, 0.02520264f, -0.08230720f, 0.04725920f, 
    -0.20412804f, 0.03970465f, 0.16853593f, -0.02822526f, 0.00207654f, -0.10525047f, -0.02874058f, 0.05218454f, 
    0.11830994f, -0.08444351f, -0.04345555f, -0.00178846f, 0.19908394f, 0.00083696f, -0.01530541f, -0.15333706f, 
    -0.10819755f, -0.09076619f, -0.10752299f, 0.00610546f, -0.13030943f, -0.09012388f, 0.06990103f, -0.00016981f, 
    -0.11840083f, 0.02252741f, 0.07494188f, -0.02210515f, 0.14847594f, -0.09713352f, 0.10085055f, -0.01087532f, 
    -0.08628596f, 0.06282315f, 0.06324180f, -0.05124735f, -0.10449983f, -0.02161708f, 0.26640534f, 0.26422307f, 
    -0.00860560f, 0.06555025f, 0.12257678f, -0.00167681f, 0.03033076f, 0.09916074f, 0.09686868f, -0.04639674f, 
    0.27463406f, -0.16026588f, -0.21618560f, -0.17164479f, 0.00097549f, 0.05924545f, 0.12511328f, 0.09771056f, 
    -0.03301852f, 0.05239275f, 0.03724817f, -0.09033921f, -0.11341741f, -0.04567064f, 0.28368974f, 0.16370557f, 
    -0.07837174f, 0.00973209f, 0.13562983f, 0.07077380f, 0.03036206f, -0.01895282f, -0.04654359f, 0.09687546f, 
    -0.14470775f, 0.06447870f, 0.05630869f, -0.07842674f, -0.06523256f, 0.03309628f, -0.09446139f, -0.20067917f, 
    0.01594018f, 0.14619119f, -0.17043215f, 0.01006039f, 0.16041787f, -0.21826456f, 0.04926956f, -0.03954514f, 
    -0.01951698f, -0.11412439f, -0.09711061f, 0.11367862f, 0.04036068f, 0.20861103f, 0.01406238f, 0.23424762f, 
    0.33354795f, -0.00028647f, -0.11076482f, -0.00256420f, -0.03544312f, 0.06665231f, -0.19691388f, -0.13046433f, 
    -0.00857821f, -0.09133375f, 0.12868808f, 0.07046078f, 0.10233015f, 0.17550722f, -0.17931384f, -0.15316565f, 
    0.13632232f, -0.00495716f, 0.13152437f, -0.02625811f, -0.06021840f, 0.00522242f, 0.02475100f, -0.15959257f, 
    0.00092403f, -0.18546841f, 0.15033902f, 0.31437203f, -0.00278496f, 0.01663221f, 0.16767031f, 0.09098575f, 
    -0.10330469f, 0.10044408f, 0.09678014f, 0.13552055f, 0.15138543f, 0.19458982f, -0.12174638f, -0.46480125f, 
    0.10839749f, 0.00584992f, -0.11090145f, 0.08900077f, -0.16766627f, -0.05142049f, 0.00438219f, -0.07387830f, 
    0.12554869f, 0.20577870f, -0.14219561f, 0.01666167f, -0.16384289f, 0.10053539f, -0.03383784f, 0.04605273f, 
    0.06276614f, 0.08958230f, 0.04595008f, 0.19114886f, 0.17087257f, -0.16250478f, 0.03540315f, 0.11569960f, 
    -0.12921076f, -0.10907744f, 0.13347977f, -0.09000548f, 0.14817426f, -0.02562737f, -0.02887150f, -0.18267944f, 
    -0.28257298f, 0.18611887f, 0.09015126f, -0.02643715f, -0.04548633f, 0.06563524f, 0.08719813f, -0.03107193f, 
    0.00206909f, 0.07232195f, -0.08591751f, -0.01694033f, -0.21260108f, -0.11737827f, 0.03091847f, 0.32279006f, 
    0.06945918f, -0.13608950f, -0.00227948f, 0.11409596f, 0.04431706f, 0.16632573f, -0.01478422f, 0.08978005f, 
    0.02828418f, -0.20225792f, 0.09573662f, -0.01207402f, -0.03583013f, 0.17775454f, -0.01721054f, 0.01952361f, 
    0.00904859f, 0.11937414f, -0.09341371f, 0.09703310f, 0.03600792f, -0.01573399f, -0.29475641f, -0.00634882f, 
    0.05259124f, -0.01228369f, 0.13861020f, -0.10067736f, -0.01025296f, 0.03503043f, -0.01663223f, 0.03628512f, 
    0.11722390f, 0.13279186f, -0.13823994f, 0.09959789f, 0.10052461f, 0.02541496f, 0.02180510f, 0.11824616f, 
    0.12098095f, 0.06876923f, 0.14053497f, -0.03893746f, -0.10213181f, -0.05753842f, 0.00932285f, 0.26968130f, 
    0.04241938f, 0.20814694f, 0.12590311f, -0.04776631f, 0.04522150f, 0.01126766f, -0.01740665f, -0.07819317f, 
    0.19730507f, -0.46599004f, 0.02358140f, 0.27360094f, 0.00436171f, 0.08442432f, 0.11311700f, 0.04075934f, 
    0.05173666f, 0.10786201f, -0.04340323f, 0.05924425f, -0.19438140f, 0.05087367f, 0.19527175f, 0.27529368f, 
    -0.04854357f, 0.19335252f, -0.09033871f, 0.04819394f, 0.10181777f, -0.17967364f, -0.01476853f, 0.07125433f, 
    -0.25522032f, -0.05660559f, -0.03631736f, -0.08139800f, 0.01457467f, 0.05395152f, -0.03017326f, -0.00676213f, 
    -0.03509657f, -0.06971997f, -0.00851197f, 0.07123331f, 0.00554826f, -0.01397891f, -0.09109530f, -0.13071033f, 
    0.00996284f, -0.08473758f, 0.05590075f, -0.14040297f, 0.07335696f, -0.14123075f, 0.04068345f, 0.10372487f, 
    0.02235505f, -0.27160946f, -0.09461926f, 0.12669709f, -0.05826532f, -0.11919659f, -0.03234744f, 0.20140333f, 
    -0.06153731f, -0.06409200f, 0.00529474f, -0.00508807f, -0.08185919f, 0.22989671f, -0.06033793f, -0.35041979f, 
    0.13549915f, -0.04837179f, 0.02827411f, -0.02342756f, 0.00064666f, -0.08788061f, 0.07419689f, 0.04828528f, 
    -0.02231988f, -0.14527020f, 0.13219966f, -0.01490436f, 0.13801856f, -0.12561944f, -0.17262898f, 0.06553832f, 
    0.05222369f, 0.13336778f, 0.05058466f, 0.20058466f, -0.36411983f, 0.31800202f, 0.04843666f, -0.34327117f, 
    0.15735605f, 0.01104712f, 0.00624797f, 0.05438373f, -0.02798867f, 0.00677533f, 0.09048980f, 0.06856306f, 
    -0.04721833f, 0.05450305f, 0.12769841f, 0.22155511f, -0.00499894f, 0.13169979f, 0.08435571f, -0.07830435f, 
    0.17648627f, -0.24875902f, -0.09134300f, 0.00023699f, -0.25595763f, -0.01471497f, -0.13887553f, -0.06880540f, 
    0.01141330f, 0.08916890f, 0.06230129f, 0.16917814f, 0.02537202f, 0.04954256f, 0.08697829f, -0.06224436f, 
    0.20342664f, -0.19834721f, 0.22997497f, -0.10813632f, 0.04935743f, -0.06893294f, 0.04619109f, 0.16555817f, 
    0.01612955f, 0.04526389f, -0.01446400f, 0.08214259f, -0.12033813f, -0.06200555f, 0.06162619f, -0.06592734f, 
    0.09480853f, -0.02125022f, 0.07786425f, 0.06780498f, 0.13319513f, 0.00468271f, 0.10508039f, 0.00289610f, 
    0.26721239f, -0.19520746f, -0.08574648f, 0.19580401f, 0.06252178f, 0.00406996f, 0.08351704f, -0.03924383f, 
    0.01625890f, 0.06824192f, 0.02363086f, 0.09532496f, -0.35772178f, -0.02289204f, -0.09058004f, 0.00217263f, 
    -0.04874854f, 0.09495656f, 0.01183746f, -0.00976579f, 0.04837345f, 0.09166961f, -0.00960668f, -0.04715349f, 
    0.14430663f, -0.09566066f, -0.08250765f, -0.10986252f, 0.08290391f, 0.03917154f, 0.12325685f, 0.06508857f, 
    0.14817996f, -0.03462427f, 0.02064347f, 0.07331593f, -0.14685047f, -0.10611781f, -0.01608169f, -0.05213754f, 
    0.02532678f, -0.04983780f, 0.10962925f, -0.01246945f, -0.00242820f, -0.02103571f, 0.03594600f, 0.04073393f, 
    -0.20799488f, 0.37571183f, -0.00220833f, 0.02055252f, -0.04594460f, 0.06747180f, -0.15470275f, -0.10961467f, 
    0.02542009f, -0.04384402f, 0.02145888f, 0.02528120f, -0.12658730f, -0.20496792f, -0.27496210f, -0.05563558f, 
    0.11308882f, -0.08862375f, 0.10627375f, -0.22725599f, -0.05771692f, -0.02593852f, -0.06002377f, -0.00653562f, 
    0.06400046f, 0.31200978f, 0.00313819f, 0.00579404f, 0.05863729f, -0.01809003f, 0.01797931f, 0.08125441f, 
    0.05590963f, -0.06631368f, 0.02126800f, 0.00332980f, 0.32869697f, 0.11365177f, -0.17499731f, 0.07081568f, 
    -0.05250260f, 0.07140792f, 0.00917752f, 0.02165938f, -0.10637036f, -0.01442724f, 0.01687356f, -0.03196964f, 
    -0.14783594f, -0.08614934f, 0.00239525f, -0.01071990f, 0.09005219f, -0.01380510f, 0.10803990f, 0.00396054f, 
    0.10719330f, -0.02526089f, 0.08611163f, 0.08349788f, -0.01636729f, -0.12246464f, 0.12242882f, -0.03605881f, 
    -0.14890860f, 0.08481494f, 0.04495467f, 0.05631657f, 0.12626129f, 0.09273826f, 0.05657755f, 0.12519954f, 
    -0.16184077f, 0.29018849f, -0.06797805f, -0.21542659f, -0.03485493f, 0.08485154f, 0.08694851f, 0.11433748f, 
    0.12487820f, -0.10904635f, 0.01491837f, 0.02045934f, 0.14338923f, 0.22104706f, 0.19887586f, -0.01934243f, 
    0.02644922f, 0.03467928f, 0.12986214f, -0.16036811f, 0.08578688f, 0.11884676f, -0.08621502f, 0.03869364f, 
    -0.21473855f, -0.19201310f, 0.12907618f, -0.09603266f, 0.05454639f, 0.00997109f, 0.07438361f, 0.09707697f, 
    -0.00272776f, -0.11859675f, -0.03618141f, 0.03772519f, -0.01922094f, 0.17955093f, -0.06181394f, -0.04258258f, 
    0.09944922f, 0.06870444f, 0.04302147f, 0.04756607f, -0.02253392f, -0.06952723f, 0.12263503f, -0.00629089f, 
    0.09613808f, -0.10126310f, -0.06798363f, 0.12626423f, 0.11057644f, 0.03557749f, 0.04673747f, -0.12402184f, 
    0.13989127f, 0.08547495f, 0.00865659f, 0.00306673f, 0.06783211f, 0.08169493f, -0.27705652f, 0.03697487f, 
    -0.05746748f, -0.04084833f, -0.04857799f, -0.05987578f, 0.14614451f, 0.07704641f, 0.01280055f, 0.06011574f, 
    -0.09934465f, 0.15078516f, 0.05342633f, -0.10421576f, 0.06327972f, 0.06780037f, -0.07001161f, 0.02760261f, 
    0.03802092f, 0.10182570f, -0.01033125f, 0.12117454f, 0.33348221f, -0.00134665f, 0.17872500f, 0.13781209f, 
    -0.01495645f, -0.04894355f, 0.10097684f, 0.03822379f, 0.00097682f, 0.03902157f, -0.12888113f, 0.13634844f, 
    0.01730101f, 0.03688001f, 0.06925581f, 0.22574034f, -0.04289949f, -0.09121828f, -0.05870784f, 0.07014493f, 
    -0.08162584f, 0.04964228f, 0.01949023f, -0.03718240f, 0.26125309f, -0.05093045f, -0.22646102f, 0.00041983f, 
    -0.06410942f, 0.14279833f, -0.13917308f, 0.01555102f, -0.10274815f, 0.01923769f, -0.05199075f, 0.06523865f, 
    0.16311873f, -0.05828489f, 0.08358476f, -0.06454249f, 0.02133050f, 0.01480282f, 0.00207902f, -0.00623041f, 
    -0.01792827f, -0.09253631f, -0.11526319f, 0.15184550f, 0.21119018f, 0.09760187f, -0.12747481f, 0.04033182f, 
    -0.14920847f, -0.02184466f, -0.10816816f, 0.19517812f, -0.02687051f, 0.07812849f, 0.04270974f, 0.02711412f, 
    -0.13728949f, -0.27267236f, 0.03180197f, 0.18331636f, -0.03078136f, 0.00099859f, -0.03403129f, -0.07162921f, 
    0.06852387f, -0.06052444f, 0.09603004f, -0.03834420f, -0.36674055f, 0.05356242f, 0.28003240f, 0.23850666f, 
    -0.06867453f, -0.09595297f, -0.07591480f, 0.00230207f, -0.07271928f, -0.07329007f, 0.01938113f, -0.07138394f, 
    -0.10718446f, 0.02487165f, -0.03270192f, 0.06204046f, 0.00371772f, 0.06138385f, -0.06339802f, 0.01662160f, 
    0.11698916f, -0.02012690f, -0.17151475f, -0.03035349f, -0.05280294f, 0.06871534f, 0.09323500f, 0.21941370f, 
    0.06054892f, -0.05939643f, -0.02597984f, 0.05530723f, -0.01947889f, -0.16919766f, 0.08170830f, 0.07082436f, 
    0.22713789f, -0.21292123f, -0.02833962f, 0.24260752f, -0.02010978f, 0.02075369f, 0.04372813f, 0.00816609f, 
    -0.18568347f, 0.05551407f, -0.02262404f, -0.12496307f, -0.15127406f, -0.19904546f, -0.01255866f, 0.27636135f, 
    -0.04798775f, -0.00790647f, -0.12930350f, 0.01590404f, 0.02901391f, -0.04908419f, -0.01974143f, -0.00895409f, 
    -0.00221817f, -0.03562780f, -0.10127201f, 0.04759115f, 0.03237943f, 0.02091016f, -0.13067634f, 0.02267517f, 
    0.14432530f, 0.03971960f, -0.09856796f, -0.13186164f, 0.17312439f, -0.00073386f, 0.08891526f, -0.06739076f, 
    -0.03047029f, 0.03735406f, -0.09587368f, -0.05854335f, 0.00768814f, 0.20662999f, 0.04214960f, 0.18930268f, 
    -0.19329141f, 0.24401638f, 0.08159767f, -0.18751283f, 0.18262029f, -0.01119783f, 0.10569700f, -0.02546120f, 
    -0.01597212f, -0.11703876f, 0.12821853f, 0.10462326f, 0.20599742f, -0.21240239f, 0.12692873f, 0.09173191f, 
    0.01010499f, 0.08462805f, 0.04172857f, 0.08818201f, -0.01300462f, 0.12019404f, -0.03270405f, 0.04218721f, 
    -0.06750667f, 0.14611974f, -0.17663284f, 0.20526917f, 0.12819247f, -0.01861393f, 0.04102125f, 0.05739905f, 
    0.03027723f, -0.01306785f, 0.14048088f, 0.07123517f, -0.13598463f, 0.02249210f, -0.19723824f, -0.02726464f, 
    -0.06574194f, 0.04470699f, -0.13792524f, 0.06631041f, 0.03342552f, 0.02304411f, 0.06697715f, -0.09186307f, 
    -0.10606410f, -0.03033198f, -0.09004089f, 0.10062252f, 0.05478339f, -0.03059753f, -0.01834930f, -0.14142834f, 
    -0.08821805f, -0.17440662f, 0.07671409f, 0.00453430f, -0.06659212f, 0.19059391f, 0.10305819f, 0.09014279f, 
    -0.01759057f, -0.00462557f, 0.07929785f, 0.06904785f, 0.04217288f, -0.07942661f, 0.13759860f, -0.05488380f, 
    0.08526672f, -0.00030403f, -0.19057468f, 0.32863516f, -0.01681555f, 0.05420958f, 0.07102041f, -0.02012453f, 
    -0.02172322f, 0.04448311f, 0.03122595f, 0.01590521f, -0.07623523f, 0.16091220f, -0.09585485f, 0.35557282f, 
    0.10044663f, 0.02788107f, -0.06503212f, -0.01848350f, 0.07785016f, -0.02142935f, -0.04567132f, 0.06281371f, 
    0.16359538f, 0.05349173f, 0.14589076f, 0.06717882f, 0.00080530f, -0.00993757f, -0.07056701f, -0.04855435f, 
    -0.08405659f, 0.04672793f, -0.06374288f, -0.11755592f, -0.22227453f, -0.23519409f, -0.21182279f, 0.07445092f, 
    0.09750602f, -0.00651978f, -0.06421287f, 0.00936786f, 0.00605426f, 0.02569298f, -0.11209288f, 0.01956715f, 
    -0.27956790f, -0.02974705f, -0.01777979f, -0.11776892f, 0.08973843f, -0.09738802f, -0.00770754f, 0.11494536f, 
    -0.00911585f, -0.07410774f, 0.15261278f, -0.03269325f, 0.07850665f, 0.04134351f, 0.09495647f, -0.32785693f, 
    -0.00255583f, 0.05784575f, -0.03517953f, 0.00748724f, 0.08310145f, -0.03540947f, -0.12739804f, 0.05510256f, 
    0.05001207f, 0.01640756f, -0.01463990f, -0.10341354f, -0.01798105f, 0.14615768f, 0.04193929f, 0.07431041f, 
    -0.06450374f, 0.10813265f, 0.06030708f, 0.07854480f, 0.33576733f, -0.02808310f, 0.09461690f, 0.12130063f, 
    -0.04207477f, 0.09125877f, 0.03338793f, -0.01361169f, -0.04061289f, 0.11955861f, 0.03897607f, 0.08307564f, 
    -0.06645088f, 0.16223890f, -0.04232525f, -0.04413440f, 0.07174318f, -0.06241087f, -0.06567528f, 0.04037165f, 
    0.05372528f, 0.03205951f, 0.12790193f, 0.24642393f, -0.06415546f, 0.08020527f, -0.03191327f, 0.06113320f, 
    0.06228464f, -0.04496816f, 0.05957300f, 0.01455671f, -0.05021407f, -0.03339018f, 0.04262898f, -0.06897318f, 
    0.09644552f, 0.15466794f, 0.14222142f, -0.15966786f, 0.04044653f, 0.00624219f, 0.01340805f, 0.00762066f, 
    0.02362978f, -0.03677921f, 0.01020284f, -0.07942063f, 0.05161900f, -0.04395384f, 0.04880087f, 0.19489929f, 
    0.10733515f, -0.03588936f, -0.01916241f, -0.00155139f, -0.00578382f, -0.02314036f, 0.03142500f, 0.03842131f, 
    0.22674665f, 0.04654482f, -0.07416864f, 0.15047158f, 0.10024783f, -0.01178409f, 0.04005983f, -0.04790679f, 
    0.06880572f, 0.02595090f, 0.13842294f, -0.00435927f, -0.19538580f, 0.01642034f, 0.02516767f, 0.06761333f, 
    0.03407703f, 0.00644780f, 0.02418170f, -0.08349446f, 0.03643378f, 0.01474291f, 0.02389681f, -0.05901385f, 
    -0.19536829f, 0.20444047f, 0.11538007f, 0.04369848f, 0.02953120f, 0.04860333f, 0.11883762f, 0.01278238f, 
    0.16377518f, -0.11661846f, -0.03740895f, 0.09878532f, -0.10076822f, 0.05845919f, -0.22279848f, 0.10041957f, 
    0.02666920f, -0.05199216f, 0.05385376f, 0.03271956f, 0.05774032f, -0.04168614f, 0.05189119f, -0.19699964f, 
    0.03945023f, -0.09336571f, 0.00006007f, 0.39314938f, -0.02724344f, -0.03374209f, -0.07695272f, -0.13363589f, 
    0.05815996f, -0.06078808f, 0.09363348f, 0.01656953f, -0.11929896f, 0.34565243f, -0.34143475f, 0.21490966f, 
    0.02634316f, 0.10911148f, -0.07059413f, -0.15990345f, 0.14238526f, -0.07731642f, -0.00554283f, -0.02998591f, 
    0.12337229f, 0.15526593f, -0.12266838f, -0.02379748f, 0.00739889f, 0.02867949f, -0.06905643f, 0.07191116f, 
    -0.02470195f, -0.02725902f, 0.07470599f, 0.02654469f, 0.03169815f, 0.11641941f, 0.06525186f, 0.13588995f, 
    0.01914302f, 0.03758619f, 0.01680432f, 0.00044519f, -0.08342946f, -0.12445280f, -0.08747750f, -0.01540222f, 
    -0.18183850f, -0.07820971f, -0.04120529f, -0.01545989f, 0.05127269f, -0.16604541f, 0.15867336f, -0.01558599f, 
    0.00451985f, 0.08289362f, -0.00656737f, -0.05500323f, 0.02007117f, 0.07492463f, 0.06393816f, -0.02181490f, 
    0.05780829f, -0.01588539f, 0.04322092f, 0.04025736f, 0.13862811f, -0.05549478f, -0.00052307f, -0.03939234f, 
    0.03065554f, 0.10160539f, 0.05225594f, -0.21956518f, 0.12540169f, 0.00313532f, -0.05982456f, -0.15716057f, 
    0.06312201f, 0.02117899f, 0.10807125f, 0.07363126f, -0.06210050f, 0.18249318f, -0.00539284f, -0.04294967f, 
    -0.09200491f, -0.03360870f, 0.04012595f, 0.00147995f, 0.11525401f, 0.14671309f, 0.01704037f, 0.08945508f, 
    -0.16745418f, -0.02493431f, -0.09418085f, -0.04839002f, -0.03043181f, 0.05779576f, -0.02554995f, -0.05077028f, 
    -0.01238295f, -0.14572810f, -0.08930060f, 0.04581351f, 0.07855281f, 0.06495450f, 0.03639283f, -0.02186664f, 
    0.14130308f, 0.01945370f, 0.06071049f, 0.00846577f, -0.03246106f, -0.00385123f, 0.06772020f, 0.11494053f, 
    -0.05028480f, 0.02751355f, -0.02096669f, 0.05059887f, -0.04900962f, -0.07915221f, 0.04650170f, -0.01680707f, 
    0.00651487f, -0.04303319f, 0.04558222f, 0.06225693f, 0.06425118f, -0.00389679f, -0.01151980f, -0.01284516f, 
    -0.05028020f, -0.01478535f, -0.03275476f, 0.00156613f, 0.00648921f, -0.05858551f, -0.01967006f, -0.07188801f, 
    -0.04661929f, 0.01678846f, -0.01073984f, 0.00014854f, -0.07970936f, -0.02066164f, -0.08089610f, 0.00054152f, 
    -0.03708201f, 0.04890927f, -0.07734679f, -0.05913165f, 0.03282183f, 0.03035728f, -0.07078177f, 0.05071355f, 
    0.02023473f, 0.03420110f, -0.02442921f, -0.00493352f, 0.05634684f, 0.01315312f, -0.04131535f, -0.02442967f, 
    0.00539977f, 0.01501312f, 0.02536000f, 0.03099195f, -0.03124105f, -0.01331801f, -0.04643898f, 0.06155709f, 
    -0.00451726f, -0.03143565f, 0.00228541f, -0.06020680f, 0.00734914f, 0.00966882f, 0.01056406f, -0.02300381f, 
    -0.01279737f, -0.05767472f, 0.03443220f, 0.05824062f, 0.03750391f, -0.02684177f, -0.06019921f, -0.05764511f, 
    -0.07929457f, -0.05468395f, -0.03011312f, -0.06484774f, 0.00425704f, 0.02472305f, -0.06832282f, -0.05467873f, 
    -0.06753875f, -0.06529075f, 0.00868783f, -0.06194072f, -0.01030984f, 0.01332876f, -0.03429169f, -0.05203802f, 
    0.00487434f, 0.05000588f, -0.04961567f, -0.07641784f, 0.00827743f, -0.04832119f, -0.05678227f, 0.03340141f, 
    -0.06675066f, -0.06466576f, 0.01072013f, 0.03394040f, 0.04525059f, 0.06296733f, -0.03624455f, -0.05992794f, 
    0.05473762f, -0.07192745f, 0.06282385f, -0.00947484f, -0.04299084f, 0.02901399f, -0.06741108f, -0.03028862f, 
    0.01072867f, -0.01558674f, -0.02374078f, -0.02570060f, -0.03176751f, 0.06557121f, 0.00864565f, 0.03428203f, 
    0.04579191f, -0.07159261f, -0.06081088f, 0.05528988f, -0.02369219f, 0.00660647f, -0.06504799f, -0.03678406f, 
    -0.01339904f, -0.03331728f, 0.01067454f, 0.00832913f, 0.03550322f, 0.01321483f, -0.03968944f, 0.03763993f, 
    0.00895861f, -0.04133179f, -0.02088770f, -0.04282219f, -0.03368377f, 0.04027859f, -0.06086635f, -0.03734995f, 
    0.04406493f, 0.01368610f, -0.04491526f, 0.00012354f, -0.03690079f, -0.03374457f, 0.00407845f, -0.02913874f, 
    0.00542852f, -0.00795193f, 0.05750543f, -0.03330898f, 0.01735799f, 0.00896907f, 0.06274486f, -0.00694792f, 
    -0.07321963f, 0.05287147f, -0.03516820f, 0.00290278f, 0.04772705f, -0.01952136f, -0.00460970f, -0.06677005f, 
    -0.01902733f, 0.00360500f, 0.01333640f, 0.01170465f, 0.04670933f, -0.02568805f, 0.06300864f, 0.05784793f, 
    0.05214678f, 0.00656153f, 0.00813376f, -0.01304572f, -0.01139305f, -0.07651734f, -0.07237685f, -0.04262061f, 
    -0.05838893f, 0.05101788f, 0.05178024f, 0.03067677f, 0.04282120f, -0.05703660f, 0.00140791f, 0.04188207f, 
    -0.04721951f, -0.04220302f, -0.01539536f, -0.05399774f, -0.00419321f, 0.06208451f, 0.01319109f, 0.03688452f, 
    0.06338859f, -0.04646390f, -0.01029646f, 0.00502668f, -0.01140541f, -0.00837778f, -0.00644017f, -0.01162349f, 
    -0.05344040f, -0.01728995f, -0.03596599f, -0.03187210f, -0.02302120f, -0.03153296f, 0.00308642f, -0.06602132f, 
    0.03918952f, -0.06226153f, -0.02802425f, -0.03910425f, -0.03802041f, -0.05222427f, 0.03258707f, 0.03981144f, 
    0.04528373f, -0.06894145f, -0.02198990f, 0.01935381f, -0.00580152f, -0.05912255f, 0.01406712f, -0.04745810f, 
    -0.04744897f, -0.02520605f, 0.01388606f, -0.04630965f, -0.02467031f, 0.00997323f, -0.06361496f, -0.05052692f, 
    -0.02981175f, 0.00622574f, -0.07603790f, -0.01138308f, -0.06745769f, 0.01184999f, 0.06549845f, -0.00564073f, 
    -0.06786390f, 0.01692916f, -0.03458733f, 0.01113121f, -0.07563505f, 0.02769810f, 0.06638654f, 0.00740635f, 
    -0.07667134f, 0.01482206f, 0.06131827f, -0.07215120f, 0.00001150f, -0.01295612f, -0.02990933f, -0.03861895f, 
    0.04597066f, 0.02051931f, 0.02691482f, 0.03334553f, 0.03599168f, -0.04798859f, -0.07097537f, -0.05289282f, 
    -0.02402915f, 0.01044210f, -0.05739756f, 0.03469898f, -0.06218909f, 0.04678750f, 0.00460754f, -0.04874095f, 
    0.02175423f, -0.01563953f, -0.00675607f, -0.03050625f, -0.06428112f, 0.00304560f, -0.01027837f, 0.01930343f, 
    0.06637597f, 0.04608065f, 0.00269380f, -0.03564896f, -0.05293750f, 0.05160880f, -0.01776945f, 0.00932499f, 
    -0.00254708f, 0.03770910f, -0.05913541f, -0.06099820f, -0.06389008f, 0.00624552f, 0.05179451f, -0.02268855f, 
    -0.02759620f, 0.00157812f, -0.07437035f, -0.02296560f, 0.00689805f, -0.01638303f, -0.03756081f, -0.05081150f, 
    0.01902860f, -0.04669966f, -0.05180386f, -0.03617978f, -0.01699362f, -0.05585966f, -0.04339034f, -0.05916612f, 
    0.05632066f, -0.06181516f, 0.01435571f, 0.03582144f, -0.03752230f, 0.01889082f, -0.03726879f, -0.00887724f, 
    0.04360573f, 0.00964547f, -0.07113630f, -0.06352164f, 0.02927359f, -0.07436714f, -0.01238787f, -0.07155848f, 
    0.04637322f, -0.05135586f, 0.03253300f, 0.04647908f, 0.05820279f, -0.02824062f, 0.03233993f, 0.04083270f, 
    -0.00234655f, -0.02739706f, -0.04239893f, -0.02815465f, 0.05853841f, 0.06646078f, -0.04164389f, -0.02871214f, 
    0.03604311f, 0.05601649f, -0.02194053f, 0.01725641f, -0.05398463f, -0.06089620f, -0.00087550f, -0.07239581f, 
    0.03342876f, 0.04143066f, -0.00560983f, -0.02568102f, -0.05367106f, -0.05631262f, -0.07338609f, 0.04274232f, 
    0.04906896f, -0.00231779f, 0.00018235f, 0.02187300f, -0.02300660f, -0.01582268f, 0.03604788f, -0.01337014f, 
    -0.01484383f, 0.02798295f, 0.02437676f, 0.03551353f, -0.01830737f, 0.06504592f, 0.03867568f, -0.00110247f, 
    0.05654107f, -0.39404929f, -0.05109815f, 0.11659961f, 0.05309252f, 0.05389130f, 0.07616182f, 0.03716280f, 
    0.10363968f, -0.00893452f, -0.07682231f, -0.03666509f, 0.16026203f, -0.05948652f, -0.08122452f, -0.07114742f, 
    -0.00917547f, 0.07252271f, -0.07527839f, 0.09318572f, 0.17604199f, -0.01816763f, -0.02773920f, 0.01720502f, 
    0.14740843f, -0.05334076f, 0.12514848f, -0.00280162f, 0.04477551f, 0.05245064f, -0.00255367f, -0.06192517f, 
    0.03152417f, -0.05110462f, 0.15970822f, 0.03733429f, 0.09850944f, 0.07065158f, 0.13137572f, 0.15796337f, 
    -0.09296435f, 0.05508087f, 0.07686457f, 0.01128938f, 0.10331658f, 0.10571028f, 0.00298999f, 0.08365550f, 
    0.34410006f, -0.22351402f, -0.15492146f, 0.00463911f, -0.21153194f, 0.05527179f, 0.08263310f, 0.00354035f, 
    -0.06539123f, 0.04534392f, 0.01985340f, -0.00682001f, -0.04774298f, -0.12306780f, 0.07574182f, -0.08228043f, 
    0.04658895f, -0.08152436f, -0.18832710f, -0.02872567f, 0.11077295f, 0.08630523f, -0.02570491f, 0.17819414f, 
    -0.20140880f, 0.47371712f, 0.16138773f, -0.32067367f, 0.07725469f, 0.17135398f, -0.08943332f, 0.11453851f, 
    0.00321706f, 0.02567920f, -0.00397503f, 0.01008808f, 0.25646484f, -0.37193412f, 0.05438386f, -0.09005147f, 
    0.09783094f, -0.06005271f, 0.01516343f, 0.02485520f, -0.05879856f, 0.15616290f, -0.04118117f, -0.01601175f, 
    0.00582771f, -0.10524268f, -0.13208787f, 0.10086186f, 0.04538169f, -0.09492883f, -0.01678207f, 0.11509514f, 
    0.13068677f, -0.09283650f, 0.03908847f, -0.06859555f, 0.16446076f, 0.05926791f, -0.09626745f, -0.06488448f, 
    0.06497807f, -0.00586634f, 0.00263900f, 0.01112538f, -0.13885836f, -0.03256187f, 0.04907145f, -0.03561897f, 
    0.12732382f, 0.11299317f, 0.05335746f, 0.13786507f, 0.02467877f, 0.13224086f, -0.04587567f, -0.09337222f, 
    -0.02759328f, 0.00621706f, -0.00003064f, 0.09921017f, -0.02277112f, -0.25063586f, -0.06491081f, 0.18964370f, 
    -0.04935579f, 0.08305048f, -0.04776554f, 0.15483665f, 0.01599439f, -0.02129765f, 0.01174045f, 0.03216808f, 
    -0.02489917f, 0.08377451f, -0.11027213f, -0.05618333f, -0.02132751f, -0.01227938f, 0.15825306f, 0.12476071f, 
    0.01911248f, -0.16417761f, -0.05363884f, -0.09448319f, 0.18944384f, -0.25520760f, 0.02520900f, 0.25714886f, 
    -0.02177159f, 0.09882435f, 0.07433836f, 0.01583886f, -0.01867723f, 0.00261216f, 0.05679876f, -0.07358319f, 
    0.07295586f, -0.00582738f, 0.15320168f, -0.05315751f, 0.09815979f, -0.05167573f, 0.04661718f, 0.04038569f, 
    -0.03378270f, 0.19781582f, 0.00219780f, -0.03729559f, 0.11047315f, 0.21722807f, -0.05084934f, -0.00552288f, 
    -0.11846354f, 0.03274735f, -0.11548792f, 0.01270230f, -0.07494697f, 0.03002118f, 0.01358674f, -0.04733978f, 
    -0.04134479f, -0.02793662f, -0.03204752f, 0.03121709f, -0.00962447f, -0.06119801f, -0.05880781f, 0.03528670f, 
    0.00307241f, -0.05030784f, -0.02799753f, 0.02431697f, 0.03387244f, 0.00423741f, -0.01137958f, 0.06069410f, 
    -0.02780223f, 0.01792438f, 0.00974931f, 0.04001443f, -0.07502104f, -0.06608845f, -0.01634712f, 0.03745744f, 
    -0.03497335f, -0.02727257f, -0.02721412f, -0.04315408f, -0.07160009f, 0.03535428f, 0.03027953f, -0.02898040f, 
    0.05535894f, -0.07503153f, -0.04366097f, -0.03793506f, 0.01770836f, -0.05956291f, 0.02823859f, 0.03084184f, 
    -0.01794156f, -0.06653595f, -0.03768259f, 0.03132448f, 0.00667258f, -0.01171607f, -0.03041482f, -0.02828997f, 
    -0.02633983f, -0.03813254f, -0.02102344f, -0.03694096f, 0.05872134f, -0.07620665f, -0.05664422f, 0.01982399f, 
    0.03019490f, 0.06051424f, -0.01244896f, 0.02278411f, -0.03066839f, -0.01621039f, -0.06752422f, -0.04127512f, 
    0.01956283f, -0.02091753f, -0.01116715f, 0.05251765f, 0.02617644f, 0.03746770f, -0.01602405f, -0.06296639f, 
    -0.03805693f, 0.05323417f, 0.00292598f, -0.04100907f, -0.06378769f, -0.05192003f, -0.07687830f, 0.01229995f, 
    0.03291582f, -0.02302993f, 0.01259167f, 0.01031609f, -0.03568456f, -0.03816032f, -0.01460500f, 0.03353529f, 
    0.05909004f, -0.03338945f, 0.06607651f, -0.04869713f, 0.02363765f, 0.06048263f, 0.05484426f, -0.02169214f, 
    -0.01315344f, -0.04394360f, -0.03696771f, -0.00354802f, -0.07194264f, 0.04781101f, -0.05316769f, 0.01399220f, 
    -0.04223222f, -0.06749909f, 0.00936363f, 0.02830235f, -0.01703937f, 0.00430306f, 0.04045457f, -0.06971679f, 
    -0.02793984f, 0.01681398f, -0.06075080f, -0.07308495f, -0.00946988f, 0.05688986f, 0.01720214f, -0.03922642f, 
    0.02356514f, -0.04136895f, 0.00135020f, 0.05966983f, 0.04594888f, 0.01545895f, 0.01897284f, -0.03711657f, 
    -0.05746055f, 0.03640178f, -0.03270381f, -0.05749105f, -0.01780512f, 0.03404962f, 0.04105177f, -0.05982775f, 
    -0.02838349f, 0.01496330f, -0.01971597f, -0.03975971f, 0.05500219f, -0.00639755f, -0.06963601f, -0.06825527f, 
    0.02667817f, -0.02694227f, -0.06010751f, -0.02353805f, -0.07126903f, -0.05922486f, -0.07267973f, -0.06323401f, 
    0.06296400f, -0.03560945f, -0.06705558f, -0.01062672f, -0.01760677f, -0.01005429f, -0.06621914f, 0.03539307f, 
    -0.01623871f, 0.01457684f, 0.00080396f, 0.03111025f, -0.07033704f, -0.03995442f, 0.00635201f, 0.02087445f, 
    0.01770644f, -0.03903072f, 0.03427704f, 0.01945787f, -0.05742797f, 0.04055796f, 0.02740907f, 0.06090083f, 
    0.06149342f, 0.06191088f, 0.04149195f, -0.00943216f, 0.05547343f, 0.02621260f, -0.07271024f, 0.02271557f, 
    0.04586787f, 0.01997903f, 0.06417376f, 0.02181961f, -0.05135830f, -0.00716202f, 0.04397067f, -0.07013530f, 
    -0.03719578f, -0.32549071f, -0.01893262f, 0.00785182f, 0.04381592f, -0.04638321f, 0.15956248f, 0.04153563f, 
    0.12201982f, 0.08731059f, -0.16966791f, 0.17749596f, -0.12764992f, -0.23094229f, -0.15308048f, -0.04684007f, 
    0.01995961f, 0.00106028f, 0.02102843f, 0.05975031f, 0.09104182f, 0.05860698f, 0.10466906f, 0.03530075f, 
    0.06628525f, -0.13220187f, 0.09740638f, 0.03616016f, 0.07916588f, 0.10521235f, 0.05084733f, -0.03239138f, 
    -0.08600105f, 0.08171698f, 0.08953429f, -0.06056755f, 0.21188465f, -0.09339445f, -0.00358214f, 0.01121231f, 
    -0.08322904f, 0.07231332f, 0.05928442f, 0.07519497f, -0.03703140f, 0.08929224f, -0.13448161f, 0.05579773f, 
    0.19044764f, -0.16935337f, -0.03445158f, 0.05820563f, -0.02801204f, -0.05544279f, 0.00322243f, -0.02365508f, 
    -0.00056333f, -0.01342137f, 0.23890680f, -0.05681463f, -0.13064785f, -0.07914139f, 0.10792655f, 0.06616591f, 
    0.09764664f, 0.12249856f, -0.12039695f, -0.00550891f, 0.02067654f, -0.03983520f, -0.03362092f, 0.12965713f, 
    -0.16177826f, 0.43323517f, -0.04254449f, -0.32450524f, 0.10875836f, 0.10602471f, 0.12162581f, 0.00530388f, 
    0.05164997f, 0.15188149f, -0.01232725f, -0.03997893f, 0.20659429f, -0.38100013f, -0.12715265f, 0.01099434f, 
    -0.08290763f, -0.00078808f, 0.11212331f, 0.00870625f, -0.07874869f, 0.00457544f, 0.00418841f, -0.07449809f, 
    -0.22803296f, -0.05116624f, 0.01321669f, 0.16308655f, 0.00728513f, -0.06433813f, -0.02301274f, -0.02239581f, 
    0.24055251f, 0.05723110f, 0.01831593f, -0.08175490f, -0.08173919f, -0.11191643f, -0.09754107f, -0.01400708f, 
    -0.14315018f, 0.01421314f, -0.02548443f, -0.07999337f, -0.10248917f, 0.04307567f, 0.08530900f, 0.02126172f, 
    0.10184819f, -0.02632363f, -0.10088912f, 0.18717359f, 0.06360324f, 0.12828839f, 0.02594677f, -0.09305573f, 
    -0.05567732f, -0.03039003f, -0.06085163f, -0.05498019f, 0.00201418f, -0.14081125f, 0.15225111f, -0.06035952f, 
    -0.13400018f, -0.03179576f, -0.02496109f, 0.09627756f, 0.07603329f, -0.02533112f, 0.14200643f, 0.05229041f, 
    -0.11665735f, 0.08557903f, -0.08639120f, 0.03710096f, 0.09817047f, -0.00506532f, 0.12792815f, 0.19591039f, 
    0.04289542f, -0.05848834f, -0.05002168f, -0.08304312f, 0.13980335f, -0.06028604f, 0.11964833f, 0.02512691f, 
    0.15231194f, 0.22596020f, -0.02945715f, -0.02656197f, 0.13698214f, -0.03743508f, -0.02937418f, -0.02425085f, 
    -0.03313488f, 0.06664250f, 0.21105888f, 0.04119100f, 0.06641847f, 0.03791355f, 0.13644396f, 0.13472445f, 
    0.07457096f, 0.08096699f, 0.07142931f, 0.02274008f, 0.01227336f, 0.18566440f, -0.03796893f, 0.04222513f, 
    -0.11029985f, 0.03144745f, 0.07526428f, 0.00482261f, -0.08489413f, -0.01728394f, 0.05204196f, -0.06375207f, 
    0.31364372f, -0.06867751f, 0.21848255f, -0.01641361f, -0.01582724f, 0.10048796f, -0.06657254f, 0.05482161f, 
    0.07126687f, 0.00140397f, 0.05427378f, 0.12097876f, -0.34684756f, 0.02963188f, 0.08159955f, -0.11047212f, 
    -0.04792377f, 0.05667301f, -0.07161456f, 0.11311258f, 0.04488379f, -0.11592442f, -0.04997132f, -0.00629638f, 
    0.02761651f, 0.01002207f, 0.05467434f, -0.13213634f, -0.11211683f, 0.01475971f, -0.08876456f, -0.19278951f, 
    0.18621199f, 0.07343738f, 0.00478515f, -0.03804242f, -0.11814752f, -0.04071402f, -0.10318323f, 0.04005152f, 
    0.01108066f, 0.15735000f, 0.00992716f, 0.06918117f, 0.01273554f, -0.04579191f, 0.10199609f, -0.06254165f, 
    0.05838976f, -0.11987059f, -0.13390976f, -0.22056772f, 0.05243367f, -0.13697264f, 0.06023166f, 0.07906139f, 
    0.01146092f, 0.11635541f, -0.06618685f, 0.03102608f, 0.09669130f, -0.11175019f, 0.04064127f, -0.12067027f, 
    0.03182641f, 0.02456135f, -0.05396276f, -0.05712775f, -0.03995855f, 0.00716495f, 0.13904579f, 0.06899015f, 
    -0.21045411f, 0.13397907f, 0.02463837f, -0.10608432f, -0.00000252f, -0.10614219f, -0.00627130f, 0.04593938f, 
    -0.00685242f, -0.01763125f, -0.00896666f, -0.04968683f, 0.23794654f, -0.36912304f, 0.13095872f, -0.21309109f, 
    -0.11083184f, -0.04140397f, 0.16932973f, 0.03696219f, -0.06068699f, -0.00819165f, -0.05595790f, 0.06537201f, 
    -0.28004029f, 0.07046340f, 0.26075488f, 0.10789313f, -0.15688454f, -0.03855499f, -0.01446269f, 0.03021027f, 
    -0.00084873f, -0.03560825f, -0.07566094f, 0.06763677f, 0.02406801f, 0.15972558f, -0.19178225f, -0.26037410f, 
    -0.00742667f, 0.07089842f, 0.02258882f, -0.00063966f, 0.05225335f, -0.05795573f, 0.13430335f, 0.29104039f, 
    0.05943044f, 0.26155904f, 0.03294228f, -0.05986912f, 0.06341719f, 0.02084167f, 0.11315480f, 0.02532314f, 
    -0.04362058f, 0.07069049f, 0.08525459f, 0.03700983f, 0.12902126f, 0.00544741f, 0.16689086f, 0.23304579f, 
    -0.17207225f, 0.08786243f, -0.06587712f, 0.06828713f, 0.08124124f, 0.15225971f, 0.06218440f, 0.00087572f, 
    0.09120131f, -0.03539833f, 0.11455471f, 0.01515125f, -0.01263949f, -0.09294509f, 0.11465127f, -0.09605630f, 
    0.07168076f, -0.06971183f, -0.00729779f, -0.02327650f, 0.05369710f, 0.03655349f, 0.19633745f, 0.19655046f, 
    0.04964236f, -0.03572010f, 0.04659517f, 0.14053510f, -0.12322313f, -0.07320016f, 0.02059548f, -0.00113577f, 
    0.18020692f, -0.05607876f, 0.12664042f, 0.04746758f, 0.00517953f, 0.13070606f, -0.06210699f, -0.03711649f, 
    0.07117644f, -0.02959007f, -0.07784411f, -0.05181218f, -0.27044448f, -0.05337584f, -0.05896572f, 0.00633188f, 
    0.05472886f, 0.09235223f, -0.04001003f, 0.05400347f, 0.12834936f, -0.04678867f, -0.05472196f, -0.06486980f, 
    0.01157611f, 0.17566282f, 0.00965047f, 0.01522684f, -0.05048520f, 0.00048098f, 0.00648364f, -0.09086824f, 
    0.04886589f, -0.03123935f, -0.01357532f, 0.00241012f, -0.23454049f, -0.15417162f, -0.06261399f, -0.05073528f, 
    0.15968299f, -0.07156692f, 0.11964047f, 0.08084258f, -0.05057788f, 0.03662994f, -0.02486982f, 0.00259207f, 
    -0.12746541f, 0.26718581f, 0.02677840f, -0.00771377f, -0.00650716f, -0.02327999f, 0.06808101f, 0.04284509f, 
    0.02925079f, 0.17447956f, -0.08776519f, 0.06714223f, 0.16659854f, 0.10872260f, 0.00775957f, 0.09918428f, 
    0.09345234f, 0.09069142f, 0.09337834f, 0.07416625f, -0.12956044f, 0.01298966f, -0.08445071f, 0.01063869f, 
    -0.19076669f, -0.04076681f, 0.12352298f, 0.16739662f, 0.08979826f, 0.00888372f, -0.06267921f, 0.07758699f, 
    0.09278599f, -0.06074502f, 0.18466541f, 0.00607334f, -0.23349307f, 0.00091825f, -0.14327960f, 0.22823825f, 
    0.03590023f, 0.07935628f, 0.07182664f, -0.06077009f, -0.02487110f, -0.09949996f, -0.07724290f, -0.11247378f, 
    0.51681608f, -0.14921717f, -0.13216045f, -0.16656341f, -0.01546466f, 0.05280653f, 0.07759824f, -0.13349403f, 
    0.06694041f, 0.04951954f, -0.03139960f, 0.16951135f, 0.06301974f, 0.03759298f, -0.27616540f, 0.09480893f, 
    -0.14113387f, 0.17632043f, 0.03217113f, 0.06569639f, 0.00516850f, -0.10937478f, 0.01362208f, -0.14715444f, 
    -0.29457027f, 0.00796364f, -0.06686332f, 0.00612495f, 0.11081369f, 0.06418115f, -0.03782618f, -0.09640275f, 
    0.00828873f, -0.00392346f, 0.01655413f, 0.01518363f, 0.00939158f, -0.06191752f, 0.11373584f, 0.23147708f, 
    -0.09185074f, -0.04660855f, 0.08193780f, -0.07606103f, 0.10295071f, 0.11666888f, 0.12226098f, 0.04058123f, 
    0.32456315f, -0.03923415f, -0.17205246f, 0.00031185f, -0.05279530f, -0.14655106f, -0.01361014f, -0.04290935f, 
    0.02758549f, -0.03429293f, -0.00837229f, -0.06122244f, 0.03705410f, 0.19141488f, -0.00326406f, -0.06959837f, 
    -0.05948187f, -0.02559055f, -0.01228619f, -0.05639679f, 0.03852639f, -0.02389704f, 0.17632312f, -0.06918228f, 
    0.34819043f, -0.30147615f, 0.05992556f, 0.08756854f, 0.03732095f, -0.05443594f, 0.04586997f, 0.07472192f, 
    0.04253493f, -0.00419960f, 0.04865240f, 0.05112331f, -0.20706673f, 0.18602422f, 0.00151754f, -0.21523705f, 
    0.21278507f, -0.06451877f, -0.05815865f, 0.08700079f, 0.00835634f, 0.06177234f, 0.09642495f, -0.00041331f, 
    -0.22785300f, -0.00823221f, -0.06023496f, 0.08136266f, -0.02663017f, 0.27988920f, 0.12373651f, -0.01907109f, 
    0.03399485f, -0.08763778f, -0.14901941f, 0.00163364f, 0.50462842f, -0.05285880f, 0.07886299f, -0.05675643f, 
    -0.25588351f, 0.05384932f, 0.02146516f, 0.10212827f, 0.11020850f, 0.06090665f, 0.03194813f, 0.01642444f, 
    -0.00262099f, 0.06512553f, 0.04334918f, 0.01544294f, -0.02344104f, -0.03051006f, -0.01368269f, 0.03491885f, 
    -0.00698640f, -0.07400566f, -0.00778397f, -0.05399659f, -0.06045894f, 0.04498441f, 0.05280643f, 0.04094532f, 
    0.04572856f, 0.02173351f, 0.06513686f, 0.03512523f, 0.05593573f, 0.02801575f, 0.04452595f, 0.04397118f, 
    -0.03918117f, -0.04771991f, 0.02037182f, -0.04428905f, -0.06098944f, -0.05318141f, -0.00186766f, -0.02488072f, 
    0.02086650f, -0.04082702f, -0.02460437f, -0.06238587f, 0.01473764f, -0.04141936f, -0.02495573f, 0.03735780f, 
    -0.03797962f, 0.00591383f, -0.03994339f, 0.03311983f, -0.02118384f, 0.00723159f, -0.03573404f, -0.07295777f, 
    -0.01651217f, 0.01090065f, -0.01161431f, 0.00446874f, -0.07535245f, 0.05889411f, -0.07288928f, 0.02729924f, 
    0.04386226f, -0.02407317f, 0.00408355f, -0.03260067f, 0.03995013f, -0.01742710f, 0.02121264f, 0.01958400f, 
    -0.06112202f, -0.03536791f, 0.03107805f, -0.01288118f, -0.05152166f, 0.00072766f, -0.02211650f, -0.03229210f, 
    -0.01342973f, 0.04616934f, -0.04048855f, -0.03931969f, 0.03621000f, -0.04738240f, -0.05634536f, 0.00135095f, 
    -0.02593264f, -0.05555878f, -0.05623604f, 0.01895676f, -0.03822636f, 0.00098798f, 0.00675009f, -0.07552567f, 
    -0.02012943f, -0.03579381f, -0.05662496f, 0.06035837f, 0.01169149f, -0.01442285f, -0.07319209f, -0.06802005f, 
    0.01870374f, -0.02500335f, 0.04331529f, 0.04707147f, -0.00965170f, -0.03192871f, -0.02801571f, -0.02742627f, 
    0.02306677f, -0.02688736f, 0.05062697f, -0.06474340f, -0.02465838f, -0.04668687f, -0.05754453f, 0.05961930f, 
    -0.06239922f, -0.07133216f, 0.01784181f, -0.01986266f, 0.00168732f, -0.03780382f, -0.05754254f, -0.06833469f, 
    0.06544884f, 0.06684544f, -0.06942508f, 0.06008236f, -0.06160968f, 0.01636393f, -0.01726044f, -0.06353745f, 
    -0.01028164f, -0.05872336f, -0.00539526f, 0.04398677f, -0.00788132f, 0.05053103f, -0.03603489f, -0.04335831f, 
    0.02587260f, -0.07500319f, 0.06258660f, -0.02726801f, 0.01296112f, 0.01542881f, -0.04914833f, -0.06356047f, 
    -0.05623094f, 0.05805263f, -0.03900649f, 0.00667017f, -0.03553514f, 0.06181356f, 0.05487258f, 0.06505845f, 
    0.02530061f, 0.00929605f, -0.02563904f, 0.00056650f, -0.01312177f, 0.04550209f, 0.01877915f, 0.06419211f, 
    0.03118548f, 0.05208264f, 0.00140945f, -0.03227106f, 0.02070376f, -0.06517812f, -0.04451043f, 0.04566379f, 
    -0.06415042f, 0.03374380f, 0.01560546f, -0.06032588f, 0.03011367f, -0.06284533f, -0.06634198f, 0.04138201f, 
    -0.05604826f, -0.03517642f, -0.04743879f, -0.05192087f, 0.00527839f, -0.06672230f, 0.05054265f, 0.01456897f, 
    0.04107073f, 0.04885526f, -0.05995869f, -0.06851491f, 0.00230710f, -0.07238749f, -0.01416396f, -0.05491871f, 
    0.27589190f, 0.21615094f, -0.08203106f, -0.00647317f, 0.07109615f, 0.10883882f, 0.00956622f, 0.03908237f, 
    -0.04539489f, 0.08276951f, 0.09551018f, -0.05790855f, -0.05378310f, -0.07691570f, 0.23944199f, -0.09763546f, 
    -0.04197849f, 0.04380381f, -0.00445756f, -0.02777085f, -0.04404595f, 0.03519709f, -0.08348396f, 0.00577597f, 
    -0.05516504f, 0.21036246f, -0.01828430f, -0.01412023f, 0.00691285f, -0.06653090f, -0.03804196f, 0.06022435f, 
    -0.04248994f, 0.08700246f, -0.12219484f, -0.01077920f, 0.13105302f, 0.03851924f, -0.07967826f, 0.12165696f, 
    0.17772819f, 0.05321846f, -0.01644535f, 0.01564971f, -0.06742851f, 0.01687271f, -0.05737829f, 0.02953090f, 
    -0.15216888f, -0.01287911f, -0.10293324f, 0.05774424f, 0.26574937f, -0.01839450f, -0.10295708f, -0.00971964f, 
    0.06956370f, -0.02603404f, 0.02727337f, -0.07364773f, 0.17830850f, 0.04607091f, 0.07032065f, -0.05058783f, 
    0.04558108f, -0.09045909f, 0.15183374f, 0.05830933f, 0.05430364f, 0.07488107f, -0.01238155f, -0.09125727f, 
    0.44958442f, -0.34444013f, -0.06777970f, 0.20953378f, -0.07280056f, -0.13441467f, 0.01200990f, 0.03410530f, 
    -0.05273453f, -0.09860936f, -0.03238741f, -0.00859451f, 0.09516201f, 0.04952648f, -0.00864165f, 0.06279451f, 
    -0.13309237f, 0.15683043f, -0.04815681f, 0.12153674f, -0.09478499f, 0.09500999f, 0.01309112f, 0.02670670f, 
    -0.04785128f, -0.16585219f, 0.22847220f, -0.03275776f, -0.10056628f, 0.07290851f, -0.05943671f, 0.00190768f, 
    -0.12788700f, -0.11374874f, -0.02533515f, 0.09682044f, -0.40402356f, -0.03384322f, 0.06546258f, 0.12741260f, 
    0.15262948f, 0.00301534f, -0.09340528f, 0.04874280f, 0.08754484f, 0.00103850f, -0.01275466f, -0.01078814f, 
    -0.15296240f, -0.00220475f, -0.04544484f, -0.14878939f, -0.01970145f, 0.00646863f, -0.07949699f, 0.09415113f, 
    -0.02962003f, -0.08596060f, 0.00779016f, 0.05515417f, 0.11518127f, 0.38513690f, -0.03210910f, -0.08869383f, 
    0.04880027f, 0.02345606f, 0.15591501f, -0.03172027f, 0.01907592f, -0.08171632f, -0.04745288f, -0.07829235f, 
    0.35441127f, -0.21584223f, 0.16610144f, 0.12305032f, -0.10124402f, -0.06591950f, -0.09018654f, -0.04144474f, 
    0.01913085f, 0.16776951f, 0.02242784f, -0.00663255f, -0.29898563f, 0.16326295f, 0.06633271f, -0.19169404f, 
    -0.07474814f, 0.09557501f, 0.00654076f, 0.00799683f, -0.00882267f, 0.03490972f, 0.15595397f, 0.21660717f, 
    0.02184545f, -0.02822156f, -0.04119567f, 0.06485285f, -0.04317864f, 0.12999429f, 0.02165504f, -0.02945203f, 
    -0.07433103f, 0.00364871f, -0.02207078f, -0.05921948f, -0.16705802f, -0.15625593f, 0.07003994f, 0.14240991f, 
    0.06797688f, -0.00932745f, 0.00983973f, 0.09761801f, 0.03500485f, 0.08001069f, -0.07726721f, 0.06244137f, 
    -0.03079779f, 0.03880518f, -0.00390520f, -0.00452422f, -0.01781125f, -0.08999684f, -0.01305801f, 0.01439398f, 
    -0.00099085f, -0.00341899f, 0.03568840f, 0.06074881f, -0.01922481f, 0.04329313f, 0.05150381f, -0.03891244f, 
    -0.05915844f, 0.01775378f, -0.07984897f, -0.05360142f, 0.03691963f, 0.10155636f, -0.09105162f, 0.03190272f, 
    0.00255205f, -0.06661171f, 0.04101802f, 0.01652570f, 0.04430571f, 0.00199395f, 0.04102247f, -0.03398679f, 
    -0.08327791f, 0.01130300f, 0.06030422f, 0.02567387f, -0.00180725f, -0.06026664f, 0.06018368f, -0.06127844f, 
    -0.07093102f, 0.08102022f, -0.10797796f, -0.02824804f, 0.03977099f, 0.00082773f, -0.06235572f, -0.00611272f, 
    -0.11857986f, -0.02262126f, 0.04810993f, 0.05943474f, -0.08968417f, -0.04967830f, -0.03468355f, -0.02580289f, 
    0.04536012f, -0.02933826f, -0.03136788f, -0.11433208f, -0.13524112f, -0.07882186f, 0.03590275f, -0.06499103f, 
    0.04233881f, 0.00066950f, 0.07518166f, -0.06605851f, 0.00651957f, -0.03343268f, -0.06054952f, -0.05319208f, 
    0.03013848f, 0.08892458f, -0.04888390f, -0.03434257f, -0.03522983f, -0.11819532f, -0.01106803f, -0.02580282f, 
    -0.03567160f, -0.06042697f, -0.00609522f, -0.02082998f, 0.02195683f, 0.03610723f, -0.02236101f, 0.04743017f, 
    -0.00883416f, -0.05999889f, 0.03244154f, -0.11205034f, 0.04929624f, 0.04952035f, 0.02707282f, 0.02582623f, 
    -0.06601872f, 0.00995480f, -0.00748515f, 0.02169629f, 0.02169280f, -0.00925223f, -0.05357025f, -0.02146031f, 
    -0.03439961f, -0.04122944f, -0.08773032f, -0.08367801f, -0.03618035f, -0.01969763f, -0.02755344f, 0.07941774f, 
    -0.04527607f, 0.07076822f, 0.05192401f, 0.06841195f, 0.00647512f, -0.08422218f, -0.02931417f, 0.06852787f, 
    -0.03370691f, -0.02153583f, -0.07765586f, 0.04753214f, 0.00276874f, 0.03235016f, 0.02518540f, 0.01181180f, 
    -0.04298769f, -0.03300536f, -0.00569476f, -0.04994750f, 0.00705308f, -0.01133384f, -0.01164492f, -0.02243034f, 
    -0.03621028f, -0.03519068f, 0.04487031f, 0.00244980f, -0.07668068f, 0.01282799f, -0.00994979f, -0.09848501f, 
    0.07789983f, -0.09438161f, -0.07386110f, -0.10828489f, -0.02938514f, 0.06806432f, 0.03059581f, -0.01367061f, 
    -0.01580033f, -0.00633701f, 0.04605304f, -0.09495871f, -0.04434812f, 0.06720808f, 0.04514861f, -0.06602664f, 
    -0.04075747f, 0.01928707f, -0.00596047f, 0.00958145f, -0.02463158f, 0.00756900f, -0.09302337f, -0.06054459f, 
    0.00130619f, -0.11778242f, 0.00195050f, -0.03664137f, 0.00602279f, 0.06875946f, 0.00230707f, -0.02910152f, 
    -0.08803812f, 0.03397595f, -0.04756292f, 0.01706251f, -0.10274585f, 0.00725034f, 0.06897680f, 0.01841753f, 
    -0.02131820f, -0.05457086f, 0.01892522f, -0.08798037f, 0.09878086f, 0.03982426f, -0.15064615f, 0.06413192f, 
    -0.21090059f, -0.03888533f, -0.19012770f, -0.03783346f, -0.10018042f, 0.09957387f, 0.07298611f, 0.03665332f, 
    -0.06644312f, 0.03109312f, 0.02606435f, -0.06701072f, -0.09811830f, 0.08722163f, 0.18517284f, 0.34802675f, 
    0.02135344f, 0.01553246f, -0.09885947f, -0.05634231f, -0.05455901f, 0.03705370f, -0.02955813f, -0.05470470f, 
    0.31980973f, -0.07669947f, 0.16186734f, -0.00455291f, 0.07182061f, 0.02609698f, 0.01596774f, -0.02076456f, 
    0.16731805f, -0.04439011f, -0.04233229f, 0.02807130f, 0.28985682f, 0.06512295f, -0.04097286f, 0.02989852f, 
    0.10724685f, -0.02454516f, 0.05960470f, -0.03023701f, 0.00570089f, 0.04991987f, 0.19384991f, 0.08281137f, 
    0.12127033f, 0.22109683f, -0.13202946f, 0.02389550f, -0.00973122f, -0.02995924f, 0.14212792f, 0.07904695f, 
    -0.08335681f, 0.10112265f, -0.06775800f, -0.03537550f, -0.20491762f, -0.18313953f, 0.12427641f, 0.02057140f, 
    0.06348135f, 0.09607619f, 0.08572544f, 0.07486804f, 0.13966353f, 0.07671450f, 0.01139613f, -0.02792856f, 
    -0.06731873f, -0.20533970f, 0.27118549f, 0.27703708f, 0.01164973f, -0.11648541f, 0.03177784f, 0.17081502f, 
    0.03512917f, 0.02829089f, -0.01471521f, -0.02665398f, 0.05050581f, 0.13238682f, 0.20535570f, 0.00701197f, 
    -0.05418830f, 0.19994996f, -0.04364653f, 0.05125367f, -0.02536250f, -0.03487092f, -0.04220078f, 0.10636065f, 
    -0.15996611f, -0.13590372f, 0.01498404f, -0.07836385f, 0.00177521f, -0.02500718f, 0.02505647f, -0.03177794f, 
    -0.09328836f, 0.00273488f, 0.03182818f, 0.04882412f, 0.03329629f, 0.24010359f, 0.01637703f, -0.17451717f, 
    0.15025118f, 0.09052236f, 0.01029593f, -0.01335128f, 0.08882526f, -0.09603459f, -0.02938554f, -0.05876977f, 
    -0.08703886f, -0.01429795f, 0.07081329f, -0.00689883f, -0.07963675f, 0.07744142f, 0.03842756f, 0.20775978f, 
    -0.02828791f, 0.17178164f, -0.07115123f, 0.23580097f, -0.15927412f, 0.10424210f, -0.15119231f, -0.12692586f, 
    0.13755529f, 0.05380953f, 0.02343443f, 0.04641832f, -0.08486793f, 0.09489751f, -0.10833371f, 0.04655545f, 
    0.12960498f, 0.10772433f, 0.07255741f, -0.04975830f, -0.01380233f, -0.05076747f, -0.14016216f, -0.08048935f, 
    -0.04440514f, 0.21064983f, -0.00335446f, 0.08672684f, -0.12865910f, 0.15473667f, 0.05164842f, -0.09080494f, 
    -0.03873716f, -0.03415419f, -0.04768782f, -0.01451593f, -0.04705746f, -0.02614694f, 0.00782156f, 0.06836306f, 
    0.22966658f, 0.06408329f, -0.01295458f, 0.18432875f, -0.00001599f, 0.01143590f, -0.13050796f, -0.08134440f, 
    -0.03567469f, 0.00979676f, 0.11208845f, 0.08133411f, -0.29606968f, -0.07082351f, 0.02030126f, 0.03494631f, 
    0.03540913f, 0.00907884f, 0.05209287f, -0.01734385f, -0.01203816f, 0.05794015f, -0.15149158f, 0.02016493f, 
    0.08161491f, -0.11985446f, 0.14563788f, 0.04484918f, -0.05781705f, -0.03809714f, -0.04352199f, -0.03147663f, 
    -0.01296924f, -0.02301623f, -0.10822717f, 0.09481656f, -0.14119320f, 0.10677378f, 0.00837875f, -0.00021905f, 
    0.07167682f, 0.00157582f, -0.14684439f, 0.06964269f, 0.05408467f, -0.08992533f, 0.10314313f, -0.03798462f, 
    0.10417323f, -0.11637235f, 0.06505041f, 0.01599880f, -0.11023485f, -0.08690009f, 0.00323105f, -0.10210054f, 
    0.12592353f, 0.09744392f, -0.01901123f, -0.01390246f, -0.05935656f, 0.13660170f, 0.00113686f, 0.21819103f, 
    0.04891283f, 0.03430837f, 0.06783963f, 0.00285837f, -0.04078367f, 0.03663231f, 0.05817323f, -0.10883355f, 
    0.29954940f, -0.02665271f, -0.04935567f, -0.23741268f, 0.01236359f, 0.12394822f, 0.07733471f, 0.04248312f, 
    -0.01158894f, 0.07059237f, 0.00158686f, -0.02046491f, -0.02122096f, 0.05648381f, 0.15094520f, -0.16915002f, 
    0.05073308f, -0.18394120f, -0.02397427f, 0.03669928f, -0.02506198f, 0.02866873f, 0.02791318f, 0.06437829f, 
    -0.25758231f, 0.09085116f, 0.01118962f, -0.12696813f, 0.19836248f, 0.05811256f, -0.18440688f, 0.04371154f, 
    0.04783510f, 0.16655490f, 0.06034220f, -0.08437489f, 0.06947244f, -0.30208012f, 0.15533909f, -0.17921759f, 
    0.05628452f, -0.12592924f, 0.02380198f, 0.08361114f, -0.08388090f, 0.01807557f, -0.02644960f, 0.03901887f, 
    0.16400997f, 0.17253637f, 0.03436149f, 0.00135331f, -0.02871206f, 0.01167073f, -0.00013464f, 0.20802921f, 
    0.10954218f, -0.04745291f, -0.13380143f, 0.00394293f, 0.50875729f, 0.24394561f, -0.02973983f, -0.23040541f, 
    0.01155038f, 0.15376031f, 0.04588119f, -0.03155334f, -0.09455545f, -0.00230409f, -0.03603646f, 0.18412919f, 
    0.14193927f, -0.00571124f, 0.03550103f, 0.08606484f, 0.01122030f, 0.06209347f, -0.00828250f, -0.06562155f, 
    0.05073648f, 0.11795555f, -0.00294285f, 0.01684944f, -0.01241534f, -0.21719547f, 0.11062994f, 0.13732702f, 
    -0.10632798f, -0.06589822f, -0.12394398f, 0.00434345f, 0.00622843f, 0.06598102f, 0.04595314f, 0.01938261f, 
    -0.08739947f, 0.16446194f, 0.05519340f, -0.12763907f, 0.03551186f, -0.03875582f, 0.07063752f, 0.07351232f, 
    0.11150897f, -0.20839031f, -0.13319801f, 0.06816246f, 0.11548469f, -0.07972597f, 0.02712411f, 0.03426919f, 
    -0.01862553f, -0.07365321f, 0.15297596f, -0.01349019f, -0.06340300f, -0.02618981f, 0.03773361f, -0.08117744f, 
    0.19916283f, -0.14622250f, 0.13318057f, -0.01616167f, 0.06235181f, -0.07311038f, 0.01374354f, -0.02476691f, 
    -0.10263406f, -0.00445139f, 0.01471166f, -0.07780875f, 0.07615695f, 0.00675691f, -0.06921946f, 0.11121434f, 
    -0.04957867f, 0.04921972f, -0.00773992f, 0.04626972f, 0.03057642f, -0.14391266f, 0.04860774f, -0.00825178f, 
    -0.01577209f, -0.01603195f, 0.04031885f, -0.07003196f, -0.02541136f, 0.04012379f, 0.06152460f, 0.00121928f, 
    0.03449221f, -0.02694196f, -0.02552596f, 0.02191841f, -0.07573064f, -0.03669547f, 0.04574851f, 0.02794349f, 
    0.00690661f, 0.04790311f, -0.01011115f, -0.04775657f, 0.04710221f, 0.03392614f, -0.02713823f, 0.04583371f, 
    -0.06345065f, 0.06497539f, 0.03500795f, -0.00973393f, -0.02303403f, 0.01115326f, -0.05869622f, -0.03380828f, 
    0.02840124f, 0.02626495f, 0.05743609f, 0.03751629f, -0.04609164f, -0.02245329f, -0.06554504f, -0.06365222f, 
    0.02147903f, 0.01956324f, 0.05378658f, -0.04485071f, -0.02328584f, -0.07547515f, 0.04421937f, -0.06845792f, 
    0.01036309f, 0.05444296f, -0.04779188f, -0.05627896f, -0.04149134f, -0.03161152f, -0.02706841f, -0.01439705f, 
    -0.03048361f, 0.04739263f, -0.00542487f, -0.01773625f, -0.06052291f, -0.07713886f, 0.05969399f, 0.06649438f, 
    -0.05477330f, 0.03932973f, 0.05465955f, -0.06715238f, -0.06797947f, -0.06537277f, -0.03709354f, -0.00342532f, 
    -0.05472860f, -0.06376856f, 0.04318881f, -0.02019911f, 0.05577737f, -0.06244417f, 0.04385203f, 0.02965994f, 
    0.01382252f, -0.06897666f, 0.06055824f, -0.07079349f, 0.05452942f, -0.04190793f, -0.05803519f, -0.06000484f, 
    -0.02854171f, 0.04916282f, -0.01124055f, -0.07545675f, -0.05883605f, -0.07522928f, -0.07149041f, -0.08419998f, 
    -0.06914452f, -0.06801266f, -0.05010690f, -0.03441120f, 0.01687567f, -0.01057838f, -0.06007259f, -0.07427695f, 
    -0.00131350f, -0.03514621f, 0.02394616f, -0.00617132f, 0.02254406f, -0.01506395f, -0.00897156f, -0.02827846f, 
    0.03095211f, 0.02915784f, 0.02227380f, -0.07377364f, 0.06627309f, 0.03820824f, 0.03483260f, 0.04039175f, 
    0.05135671f, -0.07906127f, 0.05530295f, -0.07363286f, -0.06426007f, 0.05659420f, -0.04277200f, 0.00741687f, 
    0.05154750f, -0.02987501f, 0.05932938f, -0.05689469f, -0.00979029f, 0.01799801f, 0.02285483f, 0.04230120f, 
    -0.03208702f, 0.01183608f, -0.01200156f, -0.06907414f, 0.00659330f, -0.06058209f, -0.05541002f, 0.05297832f, 
    -0.00684694f, -0.01388205f, 0.03802555f, -0.03700312f, -0.05149374f, 0.04033006f, 0.01309492f, 0.02777836f, 
    0.01389766f, -0.06012620f, -0.05746565f, -0.04676021f, 0.05179360f, 0.07464495f, -0.01181353f, -0.00082658f, 
    -0.07184137f, -0.07758491f, -0.07208364f, 0.02275568f, -0.00731132f, 0.05529469f, 0.03760957f, -0.06051656f, 
    0.03841240f, -0.05308988f, -0.06744989f, 0.01903072f, 0.05146560f, -0.01880313f, 0.02552762f, 0.04450535f, 
    0.05406416f, 0.03943283f, -0.01585515f, 0.01738508f, -0.00098412f, -0.05727900f, 0.04480791f, -0.05033650f, 
    -0.01388846f, 0.03383804f, -0.03871167f, -0.04481632f, 0.02488723f, 0.04729484f, 0.04271387f, -0.07876559f, 
    -0.18714632f, 0.11127231f, -0.33705470f, 0.01952018f, 0.12450925f, 0.09991987f, 0.02082665f, -0.01804273f, 
    -0.04919289f, -0.00184339f, 0.07807285f, 0.00848136f, 0.16680700f, -0.24676596f, 0.01805818f, 0.08712934f, 
    -0.04178648f, 0.08495346f, -0.12593703f, -0.03573203f, -0.10633457f, 0.03110546f, -0.07805593f, 0.00187395f, 
    -0.09380180f, 0.03704623f, 0.07482561f, 0.05859391f, 0.07090627f, 0.02662631f, 0.05603824f, 0.00668894f, 
    -0.01095124f, -0.16023961f, 0.14790009f, -0.07349146f, 0.45781544f, 0.20861073f, 0.14387694f, 0.12523323f, 
    -0.13767923f, -0.01417458f, -0.04545638f, 0.09225698f, -0.11958895f, 0.00825731f, -0.03895840f, 0.01300062f, 
    0.11051911f, 0.20443393f, -0.00930278f, 0.19044037f, 0.08131466f, 0.00094638f, 0.01713736f, -0.09451475f, 
    -0.14429213f, -0.04754801f, 0.04181971f, -0.02084259f, 0.06628263f, 0.04669471f, 0.08492679f, 0.19474715f, 
    -0.10578699f, 0.17371248f, -0.04713510f, -0.02226376f, 0.03598467f, 0.04003540f, 0.02057036f, 0.00112625f, 
    0.09475711f, -0.19753505f, -0.04307108f, 0.03380400f, 0.03868112f, 0.00590687f, 0.12375059f, 0.12402534f, 
    -0.06791482f, -0.04143117f, 0.01685832f, -0.05407188f, 0.39198825f, 0.06781714f, 0.03924001f, 0.36480916f, 
    -0.01057577f, 0.17614684f, -0.12084904f, 0.11513972f, 0.11008513f, 0.08269764f, -0.02836562f, 0.06652261f, 
    0.03181148f, -0.27170870f, -0.10182984f, 0.00707399f, 0.05289077f, 0.05722306f, 0.03395679f, -0.11764973f, 
    -0.08344056f, -0.07046266f, -0.01068044f, -0.05049098f, -0.33006921f, -0.12334473f, 0.12842415f, 0.09114525f, 
    0.01769501f, 0.02141343f, 0.04286606f, 0.03925755f, 0.04370379f, 0.19560218f, 0.01854814f, 0.08463806f, 
    0.02119084f, -0.04818012f, -0.11362410f, -0.04179954f, -0.04193429f, 0.01665216f, -0.23845559f, -0.02980013f, 
    -0.09808365f, -0.05768933f, -0.02966474f, 0.00643489f, 0.09882408f, 0.14262651f, -0.09226236f, -0.28164279f, 
    0.16060407f, -0.01004425f, 0.07040381f, 0.00779111f, -0.16825338f, -0.04691289f, 0.05560558f, -0.11104429f, 
    -0.00782845f, -0.19659665f, -0.03261919f, 0.17530672f, -0.06006712f, 0.15673758f, 0.10980908f, 0.03134508f, 
    0.00643111f, 0.15190160f, -0.00604164f, 0.04546771f, 0.14688540f, 0.01168986f, -0.14166707f, -0.14115049f, 
    0.08059330f, 0.08623084f, -0.18361999f, -0.01875886f, -0.14776854f, -0.06194942f, -0.02776660f, 0.09521867f, 
    0.19702460f, 0.16179961f, -0.15227811f, 0.02763163f, -0.08844008f, 0.06008462f, -0.09989751f, -0.05073279f, 
    0.04058167f, 0.16069327f, 0.10731845f, 0.19921155f, -0.05143156f, -0.01692337f, 0.15690491f, 0.10428196f, 
    -0.05232527f, 0.01352328f, 0.02039983f, -0.10450095f, -0.01855762f, 0.04204687f, -0.03087189f, -0.02467529f, 
    0.27914324f, 0.03177170f, 0.07665814f, 0.09852453f, 0.08863471f, -0.08877868f, 0.02768273f, 0.00070442f, 
    0.06632460f, -0.01428576f, -0.20251487f, 0.04175056f, 0.07621406f, -0.18242131f, -0.12645270f, -0.04170252f, 
    0.07801189f, -0.06638471f, 0.16020523f, -0.00036824f, 0.04452158f, 0.02668943f, 0.11420015f, 0.03745900f, 
    0.00573530f, -0.17826183f, -0.04426882f, 0.21564800f, 0.02146964f, 0.06953935f, -0.02624181f, 0.01757933f, 
    -0.10650266f, 0.10895429f, -0.01688694f, 0.06119017f, -0.29614487f, 0.09052192f, -0.12604941f, 0.21051352f, 
    -0.02210149f, 0.00876692f, 0.08375934f, -0.06786132f, -0.00726123f, 0.14449619f, -0.00102486f, 0.00255264f, 
    0.07117260f, -0.01985922f, -0.06617757f, 0.02904464f, 0.21496296f, 0.09375221f, -0.07457048f, 0.06292825f, 
    0.18167827f, -0.01469106f, 0.19210224f, -0.04886085f, 0.23146661f, 0.17297089f, 0.06601956f, 0.16207333f, 
    0.12177198f, -0.04237663f, 0.10812780f, -0.01458098f, 0.07726301f, -0.04116030f, -0.13053556f, -0.00462182f, 
    0.11352324f, -0.00891988f, -0.13969970f, -0.02719972f, -0.03884448f, 0.19971314f, -0.04787026f, -0.01686485f, 
    0.00403880f, 0.06196983f, 0.15529738f, 0.06675259f, -0.09222926f, -0.02784541f, -0.11437134f, -0.01984831f, 
    0.05937710f, 0.05209994f, -0.02585806f, -0.13769776f, -0.01816584f, -0.06651609f, 0.02358173f, -0.06364238f, 
    0.30332825f, 0.21445626f, -0.07337194f, -0.08002358f, 0.04145997f, -0.16287102f, -0.01994377f, 0.12713833f, 
    0.07812141f, -0.11406771f, -0.07496658f, 0.08620194f, -0.01799890f, -0.09774461f, -0.10330185f, 0.18553175f, 
    0.02015627f, -0.10857214f, -0.08507028f, -0.06903927f, -0.00570087f, 0.06253420f, 0.05990479f, 0.00777829f, 
    0.08335263f, -0.23513114f, -0.14838859f, 0.10867035f, 0.01371741f, -0.02045051f, 0.07859169f, 0.05759445f, 
    -0.07231163f, 0.02612327f, 0.02343431f, -0.02834288f, 0.25124303f, 0.16425489f, 0.23016974f, -0.11245008f, 
    -0.10234337f, 0.07346488f, 0.01924968f, 0.07621143f, 0.07709192f, -0.04312218f, 0.06794310f, 0.03078300f, 
    -0.02646070f, 0.04501621f, 0.02743104f, 0.06518763f, 0.00306093f, -0.04749556f, 0.05810189f, 0.01426158f, 
    0.21881562f, -0.18265173f, 0.05391325f, -0.06616829f, -0.12265886f, 0.20752493f, 0.11659264f, -0.28255701f, 
    -0.02958651f, 0.11782867f, 0.03348815f, -0.12763208f, 0.09014901f, 0.01970272f, 0.03152514f, 0.04710539f, 
    -0.20708613f, -0.06087391f, 0.10657668f, -0.05079280f, 0.09910460f, 0.05496010f, 0.12760745f, -0.00039527f, 
    -0.02043321f, -0.10072649f, -0.14335454f, -0.10516781f, 0.03644495f, 0.18774560f, -0.13844256f, -0.02519022f, 
    0.04907194f, 0.17483619f, -0.02943587f, 0.10195187f, -0.04067579f, -0.02554699f, 0.04945598f, -0.12553173f, 
    0.01769264f, -0.21076806f, -0.02611017f, -0.01918427f, -0.09974362f, 0.08976974f, 0.04509699f, -0.04810137f, 
    0.00894822f, 0.01015035f, 0.07852335f, -0.02525459f, -0.31462514f, 0.18167269f, 0.18429589f, 0.07235640f, 
    0.05935522f, 0.03636290f, -0.06762265f, -0.00138954f, -0.07274885f, 0.01491466f, -0.07954875f, -0.07171758f, 
    0.11521737f, 0.05129766f, 0.15031867f, 0.00045390f, 0.01922076f, -0.02549998f, 0.04618332f, -0.08379389f, 
    0.21625705f, 0.04422164f, -0.08059750f, 0.05181333f, 0.32212147f, 0.14558914f, 0.01840005f, 0.03533565f, 
    0.06003128f, 0.12353551f, -0.00453246f, 0.01707955f, -0.11904313f, -0.08706932f, 0.05163501f, 0.06649386f, 
    0.03243852f, 0.19983022f, 0.10136844f, 0.01800884f, -0.01822369f, -0.12164028f, 0.17533784f, 0.04834101f, 
    -0.02852524f, 0.04745863f, -0.06744308f, -0.03272308f, -0.24605528f, -0.25307426f, 0.01431493f, -0.11778469f, 
    0.01048290f, 0.00892518f, 0.12024409f, 0.04690261f, -0.01277691f, 0.02855917f, 0.11293586f, -0.06974960f, 
    0.17345589f, 0.06031401f, 0.08423098f, 0.08945911f, 0.09152683f, -0.15062548f, 0.08561930f, -0.02899896f, 
    -0.02791846f, 0.06674257f, 0.04523079f, 0.00993694f, 0.11301031f, -0.11331228f, 0.07137223f, -0.09326468f, 
    -0.12505051f, 0.14728601f, 0.07027149f, 0.14118664f, -0.09314586f, -0.00742731f, -0.00253019f, 0.00276788f, 
    -0.44736037f, -0.14447646f, 0.13629441f, -0.10097536f, 0.01073489f, 0.03702963f, 0.01981125f, -0.03842973f, 
    -0.07375078f, -0.05658839f, -0.09040700f, 0.03093545f, 0.33606637f, 0.33754385f, 0.03899865f, -0.16216183f, 
    0.01341059f, 0.02251578f, 0.11624417f, -0.00342976f, 0.06492350f, 0.08482416f, 0.08465295f, 0.06048882f, 
    0.19466604f, 0.18955319f, 0.00167132f, -0.05059350f, -0.07394689f, 0.01424618f, -0.06196880f, 0.05836997f, 
    0.05814550f, 0.01717183f, -0.04668142f, -0.00300480f, -0.23832870f, -0.07982317f, -0.26680788f, -0.00717722f, 
    -0.11762997f, 0.07284333f, -0.01398894f, -0.00057210f, -0.01472420f, 0.01944552f, -0.02718055f, 0.01422402f, 
    0.20294178f, -0.14149684f, 0.16338196f, -0.04621860f, 0.00627224f, -0.03120709f, 0.02718749f, -0.02812543f, 
    -0.02012776f, 0.12193771f, -0.02366816f, 0.07721850f, -0.11560908f, 0.12494502f, 0.04977595f, -0.08258311f, 
    0.12278014f, -0.08777037f, -0.03949083f, 0.03399702f, -0.05122608f, 0.07277171f, -0.08109901f, 0.00420866f, 
    0.11934432f, -0.06131966f, 0.13116725f, 0.16157351f, -0.10855135f, 0.25580603f, 0.00830789f, -0.03279963f, 
    0.02004031f, 0.07095237f, 0.07104663f, 0.02001441f, -0.00466989f, -0.01991657f, 0.12085677f, -0.03176946f, 
    -0.08998106f, 0.01935163f, -0.08150947f, -0.02370488f, 0.01042274f, 0.04789400f, -0.11646664f, 0.08678360f, 
    0.00981632f, -0.10329719f, 0.04121557f, -0.09010467f, -0.03374897f, 0.14001128f, 0.01962877f, 0.02416735f, 
    0.06592522f, 0.04109187f, -0.07000384f, 0.02806027f, -0.36035606f, 0.00403752f, 0.05016860f, 0.02822956f, 
    0.03990375f, -0.03588527f, -0.11677641f, 0.01370122f, 0.17550598f, 0.10037181f, 0.02251005f, -0.03799483f, 
    0.18257856f, 0.08815264f, -0.01185958f, -0.03234265f, 0.01701416f, 0.05810108f, 0.10701188f, -0.07494693f, 
    0.04365384f, 0.08714660f, -0.12356552f, 0.10701406f, 0.03065048f, -0.07911366f, -0.10415496f, 0.10221621f, 
    0.22477296f, 0.04875548f, 0.10863908f, -0.05365023f, 0.08852950f, -0.04032573f, 0.00319635f, 0.02796635f, 
    0.30464023f, -0.03317499f, -0.23682256f, 0.17104605f, 0.04443152f, 0.05656037f, -0.01028772f, 0.05357568f, 
    0.10396937f, 0.14979054f, 0.07716698f, 0.08570008f, 0.11530709f, -0.30083019f, 0.03185370f, -0.01861276f, 
    -0.06297763f, -0.01762215f, 0.10412626f, 0.00860475f, -0.06949620f, -0.05118043f, -0.00673492f, 0.02186464f, 
    0.23297864f, -0.00808649f, 0.05006465f, 0.24091257f, -0.08688216f, 0.00664066f, 0.03064474f, -0.06899570f, 
    0.17029035f, 0.00749714f, -0.13217048f, 0.12423889f, -0.15730190f, -0.11516655f, 0.14988044f, -0.03866930f, 
    -0.12074952f, 0.05418197f, -0.02778911f, 0.00348538f, -0.20717214f, 0.05229874f, 0.03368955f, -0.03209393f, 
    -0.44321293f, -0.04612156f, 0.26431814f, 0.01319339f, -0.09390011f, -0.02836594f, 0.03949413f, 0.02754449f, 
    -0.06258096f, -0.05324658f, -0.00645002f, 0.08331501f, 0.00446448f, 0.15406887f, -0.15760791f, -0.01808084f, 
    0.02935447f, 0.04872690f, 0.12681435f, -0.08783530f, 0.04331041f, -0.15883896f, 0.00187040f, -0.12662616f, 
    -0.20382541f, 0.10501769f, -0.02270338f, -0.04179546f, 0.05844197f, 0.00436565f, 0.15103708f, 0.19318283f, 
    0.17661870f, 0.12258673f, -0.06526566f, -0.03021986f, -0.21022902f, 0.05533925f, 0.07351184f, -0.08495884f, 
    -0.04738994f, -0.00014087f, 0.00786417f, 0.09715389f, 0.16904692f, -0.00653929f, 0.10253688f, 0.07258959f, 
    0.22904621f, -0.08003565f, 0.05716467f, -0.05924632f, 0.00158904f, -0.01124052f, -0.07628898f, 0.10472288f, 
    0.11474889f, -0.01245714f, -0.17817627f, -0.02016001f, -0.21576692f, 0.18345422f, 0.19625936f, 0.07482904f, 
    0.03738716f, 0.04646029f, 0.02952371f, 0.04960667f, -0.02842249f, -0.08096962f, 0.10114785f, -0.00731843f, 
    0.02713048f, -0.18810315f, 0.21892923f, 0.23532467f, -0.01626319f, 0.13178620f, 0.14763252f, -0.05539970f, 
    0.05032271f, -0.24265514f, -0.16651922f, -0.34860143f, -0.10918287f, 0.01381138f, -0.03499261f, 0.06257007f, 
    0.05207013f, -0.06095343f, -0.10662868f, 0.16149509f, -0.02546422f, -0.03963569f, -0.05372851f, 0.05134829f, 
    -0.12007852f, -0.14417189f, -0.54117620f, 0.02267947f, 0.09044784f, -0.08011955f, 0.00002323f, -0.08610488f, 
    0.10113074f, 0.04016134f, -0.00100662f, -0.00130384f, 0.11992038f, -0.25998044f, 0.00806767f, 0.15431368f, 
    -0.00075861f, 0.04440515f, -0.07030052f, -0.04019094f, -0.02771343f, -0.01299125f, 0.07318331f, -0.03957002f, 
    0.13229166f, -0.03711954f, 0.04125439f, 0.10617068f, 0.12885128f, -0.10328204f, 0.09881808f, 0.01615749f, 
    0.08590130f, -0.17614970f, 0.06755824f, -0.02023845f, 0.34202734f, 0.21137412f, 0.19639659f, 0.16155098f, 
    0.13806774f, -0.04811348f, 0.04357981f, -0.00108720f, -0.13677175f, 0.10435700f, -0.09937757f, 0.04578814f, 
    0.18111561f, 0.17745821f, 0.16955265f, 0.25951830f, 0.02379717f, -0.12106250f, 0.00626063f, 0.14318605f, 
    -0.15479806f, -0.00753126f, 0.02682262f, -0.02650521f, 0.11102841f, -0.21203975f, 0.14853179f, 0.08918165f, 
    -0.00713166f, 0.10227601f, -0.00826137f, -0.02037029f, 0.11544785f, 0.08573352f, 0.09628295f, 0.04614026f, 
    0.19044870f, -0.22818938f, 0.08726722f, -0.02066534f, -0.03069612f, 0.06787498f, 0.09167699f, 0.11677091f, 
    -0.17510231f, -0.08864856f, -0.07086432f, 0.03970290f, 0.32070947f, 0.07727782f, 0.03301493f, 0.14874782f, 
    -0.09199507f, 0.08796552f, 0.00811956f, 0.18086462f, -0.05935463f, 0.14572977f, 0.04244346f, 0.00018881f, 
    -0.37245414f, -0.41036367f, -0.11764412f, 0.02124407f, -0.13490817f, -0.05045941f, -0.06849860f, -0.10775757f, 
    0.09341855f, -0.04056343f, -0.07855215f, -0.10789725f, -0.39892986f, 0.18490708f, 0.28800428f, 0.17931841f, 
    0.15054011f, -0.07055730f, 0.12285466f, 0.09108047f, 0.03901418f, 0.07380757f, -0.04797746f, -0.01934389f, 
    0.13477673f, -0.07826753f, -0.06949966f, -0.05429699f, -0.07836050f, 0.13908193f, -0.19681990f, -0.00827288f, 
    0.00592043f, -0.01341512f, -0.05338115f, 0.07596088f, -0.13173287f, 0.15492438f, -0.12014706f, -0.20063920f, 
    0.11319966f, -0.03655595f, -0.02495340f, 0.01635431f, -0.10408124f, -0.04961119f, 0.01496908f, 0.00811192f, 
    0.10483214f, -0.17794220f, 0.03684165f, 0.08171371f, -0.01016428f, 0.03385103f, 0.05006670f, 0.07404502f, 
    0.02991260f, 0.17791982f, 0.10852196f, -0.00561765f, -0.00255914f, 0.24224995f, 0.02006055f, -0.20789123f, 
    -0.00035577f, 0.02624374f, -0.21032324f, -0.12880869f, -0.03881937f, -0.03128241f, 0.07672308f, 0.02910768f, 
    0.17834784f, -0.00660314f, -0.08435404f, 0.08578227f, -0.07543353f, 0.03178029f, -0.03799844f, -0.10063392f, 
    -0.00113093f, 0.12186188f, 0.11522995f, 0.08326184f, 0.00467757f, 0.03833513f, 0.11955468f, -0.00583952f, 
    -0.01501765f, 0.08390949f, 0.06750695f, 0.09700137f, -0.10081314f, 0.06338143f, -0.02366322f, -0.15901041f, 
    0.03768739f, -0.01830049f, -0.04397048f, -0.07282997f, 0.01787038f, -0.07439610f, -0.06792927f, 0.04362233f, 
    0.02936972f, -0.05874495f, 0.03877946f, -0.00626928f, -0.04679102f, -0.05622296f, -0.05598564f, -0.00250677f, 
    -0.07852061f, -0.06838509f, 0.04712278f, 0.03528528f, -0.04431962f, 0.00016577f, 0.02461394f, 0.01086428f, 
    0.02803862f, 0.01663153f, 0.03764477f, 0.00791406f, 0.03827232f, -0.05116670f, -0.03838910f, -0.02717144f, 
    -0.07761033f, 0.03585148f, -0.07233131f, -0.02727222f, -0.00523333f, -0.00421539f, 0.02281025f, 0.02784038f, 
    0.01182507f, 0.02458949f, 0.00985221f, -0.01892529f, -0.03404386f, 0.03965783f, -0.03173446f, 0.02489875f, 
    -0.00657048f, -0.07045006f, 0.04865177f, -0.04627074f, 0.01419820f, 0.02456041f, -0.03770583f, -0.03265550f, 
    -0.04752406f, -0.00492531f, 0.00075137f, 0.05036666f, 0.04852332f, 0.01786995f, 0.02021302f, 0.01694474f, 
    -0.00966876f, -0.07496969f, -0.05521124f, -0.06734519f, -0.05996950f, -0.01580179f, 0.04873579f, -0.03119362f, 
    -0.07109868f, 0.04257862f, 0.05322999f, -0.03879804f, 0.04576471f, 0.00688292f, 0.00346461f, 0.01142821f, 
    0.00412854f, -0.00653176f, 0.01989017f, 0.02633670f, -0.06970734f, -0.04012842f, -0.01355213f, 0.00537382f, 
    0.01781287f, 0.03246532f, 0.01608868f, -0.07380676f, -0.04903330f, 0.03243908f, -0.00224185f, -0.00199177f, 
    -0.05720197f, -0.05034481f, 0.00758388f, 0.00551943f, -0.04403640f, 0.01155951f, -0.07516670f, 0.02385916f, 
    -0.05399485f, -0.00316866f, -0.01758484f, -0.02438330f, -0.02075638f, 0.01664015f, -0.01707515f, 0.03297207f, 
    0.05309056f, -0.05319339f, 0.01538933f, -0.00247828f, -0.04506117f, 0.01710393f, -0.02921105f, -0.07224956f, 
    0.01354676f, -0.00312845f, -0.03551989f, -0.02059281f, -0.00392505f, 0.04779250f, -0.04467388f, -0.00127200f, 
    0.04193526f, -0.00359500f, -0.02255999f, -0.04071768f, -0.02972239f, -0.02552960f, -0.04707452f, 0.00656560f, 
    -0.03086421f, -0.02899978f, -0.07449070f, -0.06209546f, -0.07397956f, -0.03540383f, 0.02238418f, -0.02159611f, 
    0.01407099f, -0.05309524f, 0.05816399f, 0.00671949f, 0.01317676f, -0.05193992f, 0.02967226f, -0.06095966f, 
    0.03430032f, -0.06390385f, -0.00195862f, 0.00955073f, 0.04712351f, 0.05360023f, 0.03957668f, 0.02464130f, 
    0.03704945f, -0.01691397f, -0.00584190f, -0.00006988f, 0.05097116f, -0.06039489f, -0.07329692f, -0.06481229f, 
    -0.02151833f, -0.06505770f, -0.04029747f, -0.03006545f, 0.04272629f, -0.02188908f, -0.05048586f, 0.05366281f, 
    -0.00506956f, -0.04339272f, 0.02729615f, 0.05813994f, 0.00332186f, -0.06746691f, -0.00326101f, -0.06245339f, 
    0.00217375f, -0.02766322f, 0.00742635f, 0.03690473f, -0.06252038f, -0.00435407f, -0.04762213f, -0.03015351f, 
    -0.00400643f, -0.04283883f, -0.00449449f, -0.02999224f, 0.03238500f, 0.01009743f, -0.06683148f, -0.07499018f, 
    0.00755008f, 0.00609809f, 0.03812065f, 0.03389284f, -0.00813881f, 0.04321463f, -0.02912293f, 0.02073967f, 
    0.03605282f, 0.05616741f, -0.00950734f, -0.07937993f, -0.03108844f, -0.02842060f, -0.06298213f, -0.02161254f, 
    -0.05376370f, 0.00858188f, 0.01522917f, -0.04709095f, 0.00209305f, 0.01914608f, -0.04901236f, -0.02813612f, 
    0.01491790f, 0.05059975f, -0.01970631f, -0.05587725f, 0.00946457f, -0.07051814f, -0.06772543f, -0.02673340f, 
    0.05996665f, 0.06038481f, -0.01159315f, 0.01336821f, -0.01808993f, 0.05008025f, -0.01703175f, -0.06515940f, 
    0.01896708f, -0.05462579f, 0.05723481f, 0.04167300f, 0.04645788f, 0.00895508f, -0.02650873f, 0.03033310f, 
    0.01486583f, -0.07035575f, 0.03595982f, -0.04758504f, -0.05325305f, -0.08158286f, -0.04695233f, 0.05824029f, 
    0.03182118f, 0.03659265f, 0.04496678f, -0.03854800f, -0.05174810f, 0.03715964f, -0.02780323f, 0.04658320f, 
    -0.00566049f, 0.02031088f, 0.00741122f, -0.07782971f, -0.02782515f, -0.04901742f, -0.01775526f, 0.02473749f, 
    -0.00579694f, -0.02326205f, 0.05432034f, 0.01056795f, 0.05588788f, -0.05954850f, 0.01033243f, 0.05719704f, 
    -0.07368127f, -0.01717265f, 0.01954235f, 0.01400247f, -0.03925354f, -0.05630637f, 0.02999958f, 0.00606856f, 
    -0.05857319f, 0.05811909f, 0.00170317f, 0.01321814f, -0.03054386f, 0.01062556f, -0.07484931f, -0.06173846f, 
    -0.00699551f, 0.04736206f, 0.05012027f, -0.05494946f, 0.01236784f, -0.06901757f, -0.00036613f, 0.01220428f, 
    0.01546367f, -0.06943811f, 0.06349851f, 0.05622178f, 0.01729545f, -0.04665399f, -0.05003529f, -0.00134688f, 
    0.02365711f, -0.00395282f, -0.04334209f, -0.07051586f, -0.04186704f, 0.05038666f, 0.03335719f, -0.01472392f, 
    -0.01237422f, -0.00824991f, -0.03010421f, -0.01910854f, 0.00995336f, -0.02345994f, 0.02770982f, -0.03473488f, 
    -0.01130888f, 0.03140163f, -0.06148819f, -0.06452261f, 0.05716673f, -0.06519128f, -0.02404989f, -0.08085127f, 
    -0.05492434f, 0.03430540f, 0.04520831f, -0.05581865f, 0.01955652f, -0.01266542f, 0.00487720f, 0.03705207f, 
    -0.02325740f, 0.00488934f, 0.02304112f, -0.05647012f, -0.01701578f, -0.03207944f, -0.08254217f, 0.01304495f, 
    0.05275165f, -0.04234907f, 0.00150831f, 0.03424201f, -0.03724464f, -0.04760910f, -0.00881909f, -0.01131914f, 
    0.02418390f, 0.02754073f, -0.01031885f, 0.05055524f, -0.03026207f, -0.04059212f, 0.01102638f, -0.04923210f, 
    -0.04743441f, 0.00995916f, -0.04007027f, -0.00984342f, 0.03896261f, -0.03134006f, 0.03787679f, 0.00195968f, 
    -0.02478593f, 0.00425231f, -0.05526451f, -0.00723903f, 0.04465820f, 0.00314291f, -0.03452699f, -0.06730711f, 
    0.02585274f, -0.03758464f, -0.05970464f, 0.01779273f, 0.04903020f, 0.01370591f, -0.01624527f, -0.00857595f, 
    0.01514950f, -0.00744618f, 0.01073423f, -0.05506322f, -0.02006165f, 0.04302477f, -0.06319341f, -0.03637690f, 
    -0.06799321f, -0.05327418f, -0.04297425f, 0.04542734f, -0.05644707f, -0.01459548f, 0.00200182f, 0.00615009f, 
    0.06255742f, -0.03544488f, -0.06827278f, 0.01131397f, 0.02436919f, 0.04620332f, -0.07968473f, -0.05062361f, 
    -0.02035622f, 0.06251998f, -0.03170505f, -0.01424673f, -0.02544834f, 0.04517613f, -0.00827343f, 0.03741074f, 
    -0.01656725f, -0.07480481f, -0.05770582f, 0.02263303f, -0.00970590f, 0.03145185f, -0.06281534f, 0.03113869f, 
    0.03930450f, -0.05285703f, -0.03836594f, 0.01485267f, -0.03458650f, -0.07023434f, 0.00985017f, -0.04844189f, 
    -0.00794276f, -0.05448509f, -0.01925453f, -0.04500410f, -0.00786282f, -0.02811293f, -0.06396575f, -0.07474986f, 
    0.00289693f, 0.01026196f, 0.03274529f, -0.05552116f, 0.00324909f, -0.02310276f, -0.07173189f, -0.03929254f, 
    0.03284765f, -0.02698641f, -0.06057668f, 0.05440847f, 0.03348836f, -0.06418277f, 0.05059095f, 0.05622954f, 
    -0.01816890f, -0.01296589f, -0.04761802f, -0.00988295f, -0.05310955f, 0.04159057f, -0.07565806f, 0.04415737f, 
    0.05012505f, 0.00637671f, 0.00565205f, -0.01370307f, 0.05690112f, 0.00099086f, -0.05856226f, -0.04278475f, 
    -0.02822892f, 0.01149961f, -0.04764315f, -0.07495350f, 0.03874553f, -0.05029010f, -0.02844569f, 0.05786317f, 
    -0.00680684f, 0.04475029f, 0.05859502f, -0.02232427f, 0.02606814f, 0.06031528f, -0.05945393f, -0.02430560f, 
    -0.02298958f, -0.01395558f, 0.03797559f, -0.07373779f, -0.06716116f, -0.05968524f, -0.05930002f, 0.00225801f, 
    0.03457283f, 0.02126579f, 0.01783402f, 0.02754484f, -0.03013013f, 0.01290714f, -0.04952699f, -0.07888763f, 
    -0.02251075f, 0.01533782f, -0.02725151f, -0.04435431f, -0.06597590f, 0.01777017f, 0.02679054f, -0.02007513f, 
    -0.01216547f, 0.04563440f, -0.07659728f, 0.02702622f, 0.03248272f, 0.06328586f, 0.00006656f, 0.04281555f, 
    -0.01858611f, -0.02993318f, -0.05405961f, -0.04086453f, -0.04702173f, -0.03118465f, 0.04929317f, -0.02634622f, 
    0.05191918f, -0.07554788f, -0.00125582f, 0.01233842f, -0.01048843f, -0.06478820f, 0.00954987f, -0.06499960f, 
    -0.01036266f, -0.05469347f, 0.00886726f, 0.03414600f, -0.07158301f, 0.05903149f, 0.01363866f, -0.02000540f, 
    0.02407995f, -0.07038471f, -0.02437373f, -0.07755599f, -0.05972891f, 0.01465461f, 0.03318140f, 0.04359148f, 
    -0.02607262f, 0.01574066f, -0.00027896f, -0.02647339f, -0.04891535f, -0.06682891f, 0.00866407f, -0.05452757f, 
    -0.04523335f, -0.02793648f, -0.04773485f, 0.02256260f, -0.03344616f, -0.06809510f, -0.06956087f, -0.07236103f, 
    -0.37006140f, 0.16858657f, -0.19908682f, -0.08074459f, 0.01549873f, -0.00375251f, 0.03066500f, -0.04242237f, 
    -0.08174555f, -0.07834821f, 0.06795887f, -0.09032594f, -0.07433308f, -0.00553194f, 0.26054204f, 0.09417652f, 
    0.09501906f, -0.04017472f, -0.05490527f, 0.00393043f, -0.02718041f, -0.03658107f, -0.02122158f, -0.04129360f, 
    0.03826562f, 0.06358586f, 0.02930736f, 0.09104225f, 0.04371028f, -0.10591110f, -0.00372818f, 0.10695605f, 
    -0.01088984f, -0.05980653f, 0.00440196f, 0.06352763f, 0.09547886f, 0.17092012f, -0.05529842f, 0.04674627f, 
    0.02331360f, -0.06139096f, -0.14350863f, -0.12011223f, -0.07271547f, -0.09067678f, 0.08942962f, -0.10700770f, 
    0.15197368f, 0.15073051f, 0.10920986f, 0.15078221f, 0.11095668f, 0.02109594f, 0.11127630f, -0.01058817f, 
    -0.09377555f, 0.04130027f, 0.00129406f, 0.04383379f, -0.19068563f, 0.01156374f, 0.23681000f, -0.02726653f, 
    0.06707369f, -0.03678834f, 0.09638194f, 0.03960550f, 0.06998394f, 0.01297489f, 0.03607978f, 0.04741548f, 
    0.20724909f, -0.28553665f, -0.02429220f, 0.25867763f, 0.03112844f, 0.11477531f, -0.01615527f, 0.10091172f, 
    -0.05829676f, 0.02254143f, 0.09467171f, -0.09830605f, -0.32052162f, 0.09885178f, 0.31647223f, 0.06386421f, 
    0.10706059f, 0.05361503f, 0.12334143f, -0.00685782f, 0.01183412f, 0.00500484f, -0.01390561f, 0.01052473f, 
    0.07727532f, -0.05051736f, 0.03675641f, -0.11195407f, -0.00934877f, 0.13028711f, 0.02668812f, -0.02318490f, 
    -0.07914899f, 0.08238678f, -0.03147324f, 0.05314622f, 0.35207021f, 0.16171418f, 0.08332182f, 0.00054998f, 
    0.15316720f, -0.02359486f, -0.00570539f, 0.24162666f, 0.04559858f, 0.03168646f, -0.00577353f, 0.02434103f, 
    0.08765714f, -0.01938842f, 0.12296311f, -0.02569331f, -0.07675231f, 0.02069733f, -0.08137912f, -0.00057085f, 
    0.07758933f, -0.00747463f, 0.09207143f, 0.11311490f, -0.21728224f, -0.03086640f, -0.21852951f, -0.26176682f, 
    0.16456860f, 0.04751531f, 0.12431096f, -0.02205734f, -0.12350845f, 0.10321201f, -0.02662863f, -0.06906485f, 
    -0.02017304f, 0.08395880f, 0.02316306f, -0.06475081f, 0.05773938f, -0.00194875f, 0.02933161f, 0.01200591f, 
    -0.04608113f, 0.14225940f, 0.08366723f, 0.01612852f, 0.00433087f, 0.04264797f, -0.20643348f, -0.22422230f, 
    0.05550299f, -0.05211902f, -0.13291924f, -0.02488710f, -0.16532369f, 0.07376400f, -0.09062216f, -0.05383221f, 
    0.04513682f, 0.12708586f, -0.02970717f, 0.20648429f, 0.02209454f, -0.03457524f, -0.05013160f, 0.05811656f, 
    -0.07384256f, 0.04493426f, 0.05998502f, 0.13401486f, 0.19329892f, 0.01640186f, -0.08136144f, -0.00503691f, 
    0.03265328f, -0.09431006f, 0.00704792f, -0.00248895f, -0.01711863f, -0.06029183f, -0.14517456f, -0.12169021f, 
    -0.06821695f, 0.02002855f, 0.06626543f, 0.06298970f, -0.07640737f, 0.05063817f, -0.04298246f, -0.04622605f, 
    -0.05164636f, -0.03674845f, 0.01318479f, 0.06435114f, 0.03652196f, -0.01425451f, -0.06297073f, -0.06906930f, 
    -0.03368782f, -0.06455994f, 0.04305517f, -0.04840257f, -0.06608590f, -0.01244745f, 0.01608055f, 0.06341928f, 
    0.03361959f, -0.06379499f, -0.02222156f, -0.07007330f, -0.00966740f, 0.03976736f, -0.00011304f, -0.05424019f, 
    -0.01080998f, 0.05618075f, -0.00692216f, -0.01810540f, -0.00333106f, -0.04634947f, -0.02833595f, 0.05606662f, 
    -0.06166373f, -0.04385483f, -0.07011339f, 0.05711733f, -0.02871113f, -0.01551973f, -0.01192516f, -0.05273845f, 
    -0.06911980f, -0.05746539f, 0.01317532f, -0.02380150f, -0.03944225f, 0.01905318f, -0.04193545f, -0.06364906f, 
    -0.03698509f, 0.05837551f, -0.03682585f, -0.07711662f, -0.03779811f, 0.04044614f, -0.05527085f, 0.04689161f, 
    0.00845769f, -0.05428945f, -0.03309280f, 0.06451142f, -0.00793191f, 0.04245826f, 0.03519677f, 0.04536544f, 
    -0.05560489f, -0.03706845f, 0.00159844f, 0.03778709f, 0.05099747f, 0.04207075f, -0.03008184f, -0.00437053f, 
    0.01607468f, -0.03657028f, -0.07443520f, 0.01903724f, -0.05272442f, -0.02558991f, 0.03730463f, 0.05177948f, 
    -0.00824824f, -0.00175007f, 0.01563709f, 0.03670251f, 0.02654077f, 0.02552475f, -0.03719142f, -0.05000112f, 
    0.02449154f, -0.03850045f, -0.06524034f, -0.04538818f, -0.05630478f, 0.02770856f, -0.06773367f, -0.07534835f, 
    0.02219032f, 0.06181192f, 0.00406871f, 0.04032854f, -0.03299228f, 0.01941862f, 0.03716886f, -0.07023659f, 
    -0.05287897f, -0.06209967f, -0.01425824f, 0.03327410f, 0.04076414f, -0.06994941f, -0.06917967f, -0.07537229f, 
    -0.07452332f, -0.00822464f, 0.02552933f, -0.02642948f, 0.00100378f, -0.06156074f, 0.06519927f, -0.02626341f, 
    -0.05030182f, -0.07506349f, 0.00265993f, 0.01322050f, -0.00369019f, -0.05508230f, 0.03455799f, -0.03938106f, 
    0.00478845f, 0.06152371f, -0.01252894f, 0.06367369f, -0.00394443f, -0.04845081f, -0.01485736f, -0.02205262f, 
    0.01559343f, -0.00573900f, 0.06176305f, -0.00935535f, -0.05349174f, 0.00786709f, -0.02458036f, 0.03012337f, 
    -0.03986209f, 0.01126984f, -0.07534201f, -0.02493666f, -0.05346503f, -0.03448318f, -0.02839066f, -0.01556418f, 
    -0.02967199f, 0.01012508f, 0.04652619f, 0.05203146f, -0.03286972f, -0.00797765f, -0.07659052f, 0.05386038f, 
    0.02571080f, -0.01784185f, -0.04852614f, 0.05706260f, -0.06044078f, 0.05407000f, 0.02486795f, -0.01962044f, 
    0.03933053f, -0.02215837f, 0.00956891f, 0.05582315f, 0.03688836f, 0.05576901f, -0.02370667f, -0.03638871f, 
    0.00369664f, 0.05865223f, 0.04923673f, -0.01604559f, -0.05146892f, 0.03151345f, -0.02247151f, 0.04029070f, 
    -0.12567721f, 0.00674279f, 0.16425274f, -0.08227638f, -0.02265539f, 0.12044937f, 0.02631713f, 0.07806622f, 
    0.03621144f, -0.02496770f, 0.12590063f, 0.05816948f, -0.14836475f, -0.06390235f, 0.31487268f, 0.08468339f, 
    -0.01256310f, 0.11818458f, -0.00243285f, 0.08024883f, -0.04522118f, -0.03226113f, -0.28274626f, -0.05363980f, 
    -0.03297872f, 0.14313199f, -0.00578293f, 0.02998593f, -0.06919998f, -0.04173959f, 0.08344013f, -0.06531746f, 
    0.11090074f, -0.05522211f, -0.00520895f, 0.02319754f, 0.21601585f, 0.04319423f, -0.04142100f, 0.07372165f, 
    0.05410776f, 0.01041497f, -0.08217750f, 0.00375317f, -0.10243987f, -0.08351156f, 0.11655954f, -0.09725823f, 
    -0.07480090f, -0.02323652f, 0.10877300f, -0.02789219f, 0.13478246f, -0.03153568f, 0.10717947f, -0.00468807f, 
    -0.09510228f, 0.08299862f, -0.02732940f, 0.05387883f, -0.30220097f, 0.02866878f, 0.12757756f, 0.04783624f, 
    -0.09306093f, 0.00161505f, 0.09183356f, 0.07238730f, 0.00113794f, -0.01612454f, 0.14189506f, -0.05035839f, 
    0.09868143f, -0.01028193f, 0.00530060f, 0.06770328f, -0.01377307f, -0.12824482f, 0.16430633f, 0.03408067f, 
    -0.05908415f, 0.02271370f, 0.07092394f, -0.05760835f, 0.26223496f, -0.16344503f, -0.01029689f, 0.10488759f, 
    -0.07511026f, 0.03246468f, 0.08936986f, 0.13109152f, -0.03630881f, 0.00336442f, -0.13744508f, 0.04776342f, 
    -0.26190302f, 0.02702236f, 0.27376613f, -0.09150071f, -0.03859187f, 0.16114540f, 0.05533996f, -0.13160574f, 
    -0.07549405f, -0.01890085f, -0.12277801f, 0.04943153f, 0.14139067f, 0.05401499f, -0.02719042f, -0.11230578f, 
    0.01181926f, 0.11387940f, 0.03478738f, 0.06147234f, 0.05068018f, 0.13197772f, 0.05306263f, 0.23274103f, 
    0.12716024f, 0.15863788f, 0.07686637f, -0.17316568f, -0.01412882f, -0.04176074f, -0.06610046f, -0.04458297f, 
    0.03563438f, -0.08724380f, 0.10166883f, 0.01460650f, 0.04672049f, 0.06307101f, -0.04451641f, -0.08738119f, 
    -0.12382805f, -0.03056807f, 0.07194749f, -0.04344674f, -0.07381177f, 0.00484053f, -0.12982169f, -0.06077753f, 
    0.14914899f, -0.14202863f, 0.28312218f, 0.00421438f, 0.02838827f, 0.11522929f, 0.14846548f, 0.03186719f, 
    -0.15548128f, 0.10446780f, 0.01337512f, -0.00368321f, 0.20858356f, -0.00329676f, -0.12094346f, 0.01456081f, 
    0.00748189f, -0.13682339f, -0.03027670f, 0.10937699f, -0.15339357f, 0.11918911f, 0.02049026f, 0.05816006f, 
    0.15795077f, 0.10860348f, -0.14331767f, 0.05581344f, -0.15854768f, 0.15261503f, -0.02568684f, 0.04474807f, 
    -0.04701746f, 0.09323952f, 0.06881879f, 0.14220607f, 0.07755668f, -0.07330570f, 0.14738417f, 0.14517137f, 
    -0.21808355f, -0.09090415f, 0.04173147f, -0.05171553f, 0.08853451f, -0.08201901f, -0.10356680f, -0.01773420f, 
    -0.04644223f, -0.03152945f, -0.03648386f, 0.00682878f, -0.05541779f, 0.01799109f, -0.04447393f, -0.06178866f, 
    -0.03684935f, 0.02161665f, 0.00264426f, 0.00565746f, -0.01150216f, 0.05950011f, 0.04600628f, 0.00251217f, 
    -0.06721816f, -0.02080325f, -0.04163410f, 0.01161590f, -0.03222582f, 0.02027206f, -0.06808705f, -0.04912348f, 
    0.01101775f, 0.02251997f, -0.04209926f, 0.03734145f, 0.01511569f, 0.03897389f, -0.05519214f, -0.00983022f, 
    -0.05723396f, -0.02246122f, -0.05189604f, 0.03641140f, -0.07213399f, -0.05544478f, -0.02675098f, -0.04538317f, 
    -0.07167616f, -0.01148256f, 0.06802799f, -0.06030128f, -0.04424118f, 0.01725962f, -0.04814920f, -0.07112602f, 
    0.02455892f, -0.07162567f, -0.01857041f, 0.04949237f, -0.01313355f, 0.01513741f, 0.03949512f, 0.00049869f, 
    -0.01628285f, 0.00081351f, -0.03897516f, -0.07172743f, -0.00243262f, 0.06600647f, 0.06521873f, 0.00940298f, 
    0.05550526f, -0.05284642f, -0.04963760f, -0.07121154f, -0.00563193f, 0.04365162f, 0.02281027f, 0.01877712f, 
    -0.00552389f, -0.00930630f, 0.02681338f, 0.00208390f, 0.00165031f, -0.04551320f, -0.01706067f, -0.05257741f, 
    -0.02625903f, 0.02379306f, -0.00023748f, 0.01279269f, 0.05556153f, -0.04632587f, -0.04622404f, 0.03898736f, 
    -0.05793934f, -0.06822018f, 0.02395339f, -0.02530055f, 0.00721857f, 0.00416364f, 0.00737243f, 0.03251943f, 
    0.00355836f, 0.06074221f, -0.02484154f, -0.04608237f, 0.03034599f, 0.03132807f, -0.02451450f, -0.06038845f, 
    0.01740360f, -0.05390329f, -0.02318266f, 0.01999533f, -0.07179792f, -0.03632777f, 0.04125076f, 0.00643356f, 
    -0.04913649f, -0.03828127f, 0.02027762f, -0.01974029f, 0.03731882f, 0.00146191f, 0.04208801f, -0.00128689f, 
    -0.05873205f, -0.07195667f, 0.00547089f, -0.06890986f, -0.04909492f, -0.04495734f, 0.03274490f, 0.02773898f, 
    -0.06243813f, 0.00721416f, -0.03192540f, -0.05606933f, -0.00192139f, 0.04783532f, -0.06096669f, 0.02107287f, 
    -0.03030359f, 0.06214327f, -0.05395154f, -0.00199300f, 0.04663532f, 0.01977387f, 0.05461751f, 0.02028428f, 
    0.04389441f, -0.04747014f, 0.02295032f, 0.04390738f, 0.06328139f, 0.02293157f, 0.00277718f, 0.05556977f, 
    -0.02752923f, 0.02518717f, 0.03834860f, -0.03854638f, -0.03206411f, -0.03918894f, -0.03049635f, -0.00158977f, 
    -0.05075408f, -0.06005952f, -0.03246445f, -0.04971691f, -0.03053490f, 0.02717235f, -0.02207212f, 0.07154449f, 
    -0.02177479f, -0.05153845f, -0.00260286f, -0.05459915f, -0.00069139f, -0.04031862f, 0.06191821f, -0.05927622f, 
    -0.00009207f, 0.00703003f, 0.05423076f, 0.03523839f, 0.02509763f, -0.04230353f, -0.01972877f, -0.07113343f, 
    0.04527279f, 0.00583120f, 0.02796915f, 0.01665048f, 0.07175246f, -0.06148689f, -0.04562668f, -0.05518289f, 
    -0.00746487f, -0.00170281f, -0.02632806f, -0.04421552f, 0.04573425f, 0.02290378f, 0.04854225f, 0.03158973f, 
    -0.06045660f, -0.03960351f, -0.05075363f, -0.07687299f, -0.07234848f, 0.03627285f, 0.02911856f, 0.02239782f, 
    -0.01211370f, 0.01213098f, -0.07745623f, -0.07273032f, 0.01988437f, -0.01955995f, 0.03555867f, 0.04235129f, 
    -0.06449831f, -0.02906151f, -0.04921083f, 0.01201379f, 0.02533942f, 0.03454839f, -0.07354734f, -0.02483655f, 
    0.00338942f, 0.00199108f, 0.01759907f, 0.00084607f, -0.01320008f, -0.05440560f, -0.00114451f, 0.03622411f, 
    0.02565114f, -0.00282008f, -0.06752764f, -0.02787313f, 0.00565218f, 0.06069106f, -0.07147183f, 0.04299602f, 
    -0.01892666f, 0.06000515f, -0.06481033f, 0.02039780f, 0.03202400f, -0.07946947f, 0.00125275f, 0.03423794f, 
    -0.04700172f, -0.00280054f, 0.02784605f, -0.00027632f, 0.02331090f, -0.06375213f, 0.03402976f, -0.07366997f, 
    -0.00601332f, -0.00844696f, 0.03308357f, 0.03594512f, 0.05386598f, -0.01525058f, -0.06791359f, -0.00582228f, 
    -0.03295078f, 0.05463975f, -0.07933285f, -0.03400380f, -0.00826623f, 0.01493847f, 0.04527062f, 0.02747497f, 
    -0.00794119f, -0.02060913f, 0.01606880f, -0.08059260f, -0.05654238f, 0.02767681f, -0.05772120f, -0.03762142f, 
    -0.05268696f, -0.06418835f, -0.06290277f, 0.00976978f, -0.03102186f, -0.00930676f, 0.02300267f, 0.03305632f, 
    0.03817663f, -0.06015564f, 0.04595257f, 0.01854992f, -0.07750768f, 0.04554947f, 0.01816186f, 0.02961548f, 
    0.00516657f, 0.01685704f, -0.00319976f, -0.02456002f, 0.00694682f, -0.03416672f, -0.00507207f, -0.02191342f, 
    -0.04301309f, -0.05663141f, -0.07414109f, 0.05309280f, -0.03062291f, -0.00507111f, -0.02058057f, 0.01811357f, 
    -0.07358928f, 0.03809963f, -0.01025797f, -0.01041564f, -0.00754216f, 0.03667132f, -0.01885627f, 0.04999024f, 
    -0.01855142f, 0.04992969f, 0.00272549f, -0.01962318f, 0.03564400f, -0.01054406f, -0.00064265f, -0.05963673f, 
    0.01040881f, 0.00393186f, -0.06321441f, 0.04806907f, 0.05391588f, 0.05995056f, -0.01092707f, -0.04164556f, 
    -0.06549550f, 0.05970311f, -0.02671381f, 0.03793283f, -0.03033276f, -0.07679274f, -0.04386852f, 0.02589740f, 
    -0.07332003f, -0.00896605f, 0.06173474f, -0.07206201f, -0.00985201f, 0.03735855f, 0.05276480f, -0.01268837f, 
    0.00291794f, 0.02855833f, 0.05066405f, -0.07741608f, -0.06304009f, -0.05159922f, 0.01003118f, -0.03973378f, 
    0.04637073f, 0.05795239f, 0.02571782f, -0.01655667f, -0.00232912f, -0.04945946f, -0.00153851f, 0.01325683f, 
    -0.03194278f, 0.00643536f, -0.04113404f, -0.06597408f, -0.00301032f, 0.06155657f, -0.03919934f, -0.02596213f, 
    -0.02003116f, 0.00663140f, 0.00005346f, -0.06667706f, 0.01879617f, -0.01531150f, 0.01269538f, 0.02906305f, 
    -0.27314243f, 0.05304854f, -0.03915953f, -0.08017344f, 0.05524845f, -0.02226058f, -0.04177990f, -0.05159890f, 
    0.04917474f, -0.03754718f, -0.10591574f, -0.00472105f, -0.20452510f, 0.08721207f, -0.17500982f, -0.07492410f, 
    -0.10882903f, -0.04555952f, -0.06549653f, -0.04695656f, 0.11891021f, -0.02570780f, 0.18404108f, -0.06082040f, 
    -0.14562944f, 0.07648740f, -0.00514911f, -0.05304388f, 0.12938516f, -0.02101605f, -0.10361480f, 0.08077241f, 
    -0.10359444f, 0.01863840f, -0.00955707f, 0.02019580f, 0.23361354f, -0.00818440f, -0.04345420f, 0.26332822f, 
    0.10897776f, -0.11792206f, -0.01333740f, 0.05545159f, 0.12523273f, -0.04680365f, -0.00238025f, 0.03525431f, 
    0.37590858f, -0.07864283f, -0.10238537f, 0.13182297f, 0.09639899f, 0.04048194f, -0.08207658f, 0.03669636f, 
    -0.09759046f, 0.07726921f, 0.08981574f, 0.08755133f, 0.26756144f, -0.08884203f, 0.16934358f, -0.03121360f, 
    -0.03150539f, -0.02994096f, 0.03869604f, -0.03932518f, -0.06438974f, 0.17485374f, -0.01786290f, 0.18596075f, 
    0.21455349f, -0.04455293f, -0.14125982f, 0.04280910f, 0.22701429f, 0.20646091f, -0.02408170f, 0.08850128f, 
    0.00022105f, 0.14123046f, -0.10237797f, -0.02129313f, -0.07599742f, -0.23412193f, 0.33985636f, -0.06194698f, 
    -0.07574701f, -0.04280550f, 0.11616939f, 0.09952181f, -0.11193559f, 0.01879912f, -0.07363736f, 0.05403389f, 
    -0.18074992f, -0.02832583f, 0.00530116f, -0.06241959f, 0.03229897f, 0.11733456f, 0.01709620f, -0.04461523f, 
    -0.05223397f, -0.01845891f, 0.02664478f, 0.01207740f, 0.12017774f, 0.12245357f, -0.09591556f, -0.08046457f, 
    0.03849928f, -0.08129305f, 0.08215054f, 0.06475933f, 0.01525704f, -0.13274017f, 0.05115334f, -0.16422026f, 
    0.12829052f, 0.06354664f, 0.04488562f, 0.00423757f, 0.02445046f, 0.02008762f, -0.02626234f, 0.18433468f, 
    0.11017504f, 0.07150647f, -0.06005595f, -0.12821458f, -0.19525200f, -0.20156050f, -0.02481563f, -0.10163665f, 
    0.07596117f, -0.06758162f, -0.15769799f, 0.02255284f, -0.01971820f, 0.03383088f, 0.03585747f, 0.04692554f, 
    0.11323310f, -0.10682590f, -0.07727173f, 0.14050806f, -0.08108348f, 0.06193995f, -0.09310355f, 0.15396750f, 
    0.03439634f, -0.02438142f, -0.17062847f, -0.03330938f, -0.06600822f, -0.10214017f, -0.08844883f, 0.01935188f, 
    -0.03976644f, 0.01959995f, 0.09900805f, -0.14267170f, -0.07030419f, -0.01713932f, 0.01969690f, 0.00620859f, 
    0.16333421f, 0.03817820f, 0.18142389f, 0.23217168f, 0.03101585f, 0.07589760f, 0.18812563f, 0.08236175f, 
    0.04844029f, 0.05388317f, -0.05495520f, -0.12888321f, 0.39973786f, -0.07784294f, -0.11903299f, 0.01860400f, 
    -0.02403442f, -0.14738333f, -0.08518974f, 0.07882583f, -0.02044865f, 0.02512016f, 0.04170401f, -0.04087008f, 
    0.15864420f, -0.09090527f, -0.19270033f, -0.00036290f, -0.05160639f, 0.04141987f, 0.05878643f, -0.04701605f, 
    -0.01710840f, 0.07246762f, -0.03941401f, -0.03508822f, 0.21073329f, 0.06086803f, -0.08670053f, 0.07198135f, 
    0.02319444f, 0.02308233f, 0.04028101f, -0.06217532f, 0.09316235f, 0.00779398f, 0.08320693f, 0.05130993f, 
    0.33775830f, -0.01625196f, -0.07816418f, 0.01802491f, 0.08074510f, 0.05291094f, 0.09097724f, 0.07579297f, 
    -0.06856848f, -0.00731509f, 0.11935235f, -0.00662449f, 0.02206657f, -0.00894641f, 0.13406537f, -0.00320162f, 
    0.05059113f, 0.05102954f, -0.01368563f, 0.10719416f, 0.09810890f, 0.12647936f, 0.03566127f, -0.00822255f, 
    -0.04345531f, 0.10743135f, -0.09161026f, 0.15533438f, -0.18580504f, -0.02456679f, 0.01683835f, 0.06177660f, 
    0.06063404f, -0.00127502f, 0.04587841f, 0.03505971f, -0.09438418f, -0.07593682f, -0.06342273f, -0.03367617f, 
    0.02616396f, -0.03122578f, -0.09249698f, -0.04946125f, -0.00161110f, -0.07247118f, -0.01465328f, 0.04037891f, 
    -0.05182432f, 0.20496757f, 0.21840918f, 0.24502438f, -0.08468066f, 0.02194787f, -0.03827372f, 0.08500324f, 
    -0.04022205f, -0.11815955f, -0.05688661f, -0.02163712f, -0.00414713f, 0.29525828f, -0.28538129f, -0.01750071f, 
    0.13218093f, 0.15165310f, -0.10829698f, -0.07867905f, 0.09525729f, 0.11025880f, 0.01175271f, -0.10149926f, 
    0.06206713f, -0.19510543f, -0.15922104f, 0.16633813f, -0.01246453f, -0.13305505f, -0.05768466f, 0.09650955f, 
    0.07655985f, -0.03926686f, 0.13187195f, 0.03108800f, -0.14022675f, 0.16398305f, 0.09515861f, 0.16780694f, 
    0.06262436f, 0.13637970f, -0.04696425f, 0.01052647f, -0.03578109f, -0.00623151f, 0.03501752f, -0.17769526f, 
    -0.28060496f, -0.12437635f, -0.04195790f, -0.03530825f, 0.11614509f, -0.05387991f, 0.17235450f, 0.05017503f, 
    -0.05390020f, 0.10004938f, -0.02100993f, 0.11395898f, -0.13471009f, -0.05507855f, -0.05029495f, 0.03496400f, 
    0.04986419f, 0.05297337f, 0.05200600f, 0.09264044f, -0.02341914f, -0.03041149f, -0.00199390f, 0.10923597f, 
    0.19233076f, 0.13617723f, -0.21750450f, -0.11914235f, 0.03387991f, -0.00907897f, -0.11415144f, -0.07032602f, 
    0.01336141f, 0.05237260f, 0.13418630f, -0.02390008f, -0.07677722f, 0.00510278f, 0.14662999f, 0.26271021f, 
    -0.10837956f, -0.03277336f, -0.05840839f, -0.04109260f, 0.05103145f, 0.08175501f, -0.07687866f, 0.04253544f, 
    0.01377749f, -0.09447409f, -0.00012567f, 0.02975242f, 0.06641162f, -0.04671191f, -0.06531918f, 0.09118143f, 
    -0.11874005f, -0.10366096f, 0.05282673f, -0.01584858f, -0.18456982f, 0.21265666f, 0.08012529f, 0.02211965f, 
    0.18297042f, 0.09810242f, -0.07858335f, 0.05750619f, -0.05059073f, 0.07786003f, 0.07022388f, 0.09054904f, 
    0.15576856f, -0.11178409f, 0.24143748f, 0.02129779f, 0.00171406f, 0.04874815f, -0.00003886f, 0.11471052f, 
    -0.05692486f, -0.06465210f, -0.10242201f, 0.11619979f, 0.11336006f, 0.07085592f, -0.08324777f, 0.05172335f, 
    -0.05239125f, 0.02756446f, -0.00445065f, 0.00392209f, 0.04785775f, 0.11642070f, 0.07418361f, 0.03675172f, 
    0.23617572f, -0.11695737f, -0.08045608f, 0.07980093f, -0.11251543f, 0.02731728f, -0.07558256f, -0.05742715f, 
    0.02212203f, 0.03065125f, 0.01251992f, -0.02892470f, -0.24552301f, -0.06781012f, -0.03395300f, 0.20039997f, 
    -0.02876312f, 0.02880900f, 0.12982406f, -0.07329800f, 0.06310518f, 0.14538731f, 0.04702472f, -0.09342375f, 
    0.21938056f, -0.05077253f, -0.28530180f, -0.28010795f, 0.05736600f, 0.10538108f, -0.01695585f, -0.03820239f, 
    0.03059794f, 0.06133863f, -0.01703293f, 0.04000949f, 0.20425071f, 0.11951213f, -0.02952925f, -0.15887128f, 
    0.13596122f, -0.03774209f, -0.03839777f, -0.08830103f, -0.01327523f, 0.10533875f, -0.03412057f, 0.13996220f, 
    -0.57534117f, 0.21736112f, 0.13788112f, 0.08838613f, -0.04427943f, 0.03883217f, -0.01320435f, -0.01451564f, 
    0.10461742f, 0.08972570f, 0.01807866f, 0.03109488f, 0.27300736f, -0.04656852f, -0.03263704f, 0.00134275f, 
    0.01623402f, -0.06600864f, -0.03674865f, -0.00393042f, -0.01740770f, -0.01324986f, -0.02319774f, -0.05650370f, 
    0.38669726f, 0.20741402f, 0.13362889f, 0.05370977f, -0.10129648f, 0.00182758f, -0.02865761f, 0.24068323f, 
    0.05591533f, -0.09234789f, 0.01896537f, 0.03765821f, -0.01487694f, -0.04337548f, -0.27497017f, -0.19833942f, 
    0.06640814f, 0.21571095f, 0.02781477f, -0.12625283f, -0.02667729f, -0.07292504f, -0.01551850f, 0.03096466f, 
    -0.32996273f, 0.00147942f, -0.00423273f, -0.00781550f, 0.04780776f, 0.05858226f, 0.07560436f, 0.06422346f, 
    0.01587770f, 0.14651194f, 0.00908370f, 0.07773311f, 0.16200411f, -0.06311732f, 0.10226209f, 0.12229073f, 
    -0.15106186f, -0.03382874f, -0.06708264f, 0.05552307f, 0.03197486f, 0.00640259f, 0.09145228f, 0.04398339f, 
    -0.30410269f, 0.22233929f, 0.11882377f, -0.12206092f, 0.03736183f, -0.04302350f, -0.03460064f, -0.07789709f, 
    0.08451959f, -0.05927961f, -0.11077055f, 0.02104495f, 0.15283461f, -0.07129984f, 0.07478914f, 0.25417778f, 
    -0.08329233f, 0.07143202f, 0.10569628f, -0.05124862f, -0.00370482f, -0.00039535f, 0.09754180f, -0.02562410f, 
    0.10683297f, -0.05928979f, 0.15630318f, 0.00091858f, 0.05163775f, -0.18690640f, 0.08670542f, 0.04764698f, 
    0.02309360f, 0.03862383f, 0.16405840f, -0.02697791f, -0.41567165f, 0.13197052f, -0.09549510f, 0.04658361f, 
    0.07385350f, -0.04015196f, -0.02333103f, 0.06629431f, 0.03997341f, -0.13691081f, 0.10006279f, -0.03069089f, 
    0.30175018f, -0.00116854f, 0.13936605f, 0.12802553f, -0.18788758f, 0.05305054f, -0.02792713f, -0.00284826f, 
    -0.07026686f, -0.00506801f, 0.03217989f, -0.17718643f, 0.14443226f, 0.25679496f, -0.19424722f, -0.03113478f, 
    0.05109587f, 0.07436328f, -0.07258606f, -0.08215135f, 0.04557344f, 0.00527706f, -0.07549822f, 0.06268784f, 
    0.04932424f, 0.21458411f, -0.01080605f, -0.17090647f, -0.11554398f, 0.10568847f, -0.15448278f, -0.16245835f, 
    -0.00425809f, 0.03892208f, 0.00872114f, -0.06936028f, 0.19732593f, 0.12975726f, 0.17284958f, 0.04695123f, 
    0.07289393f, 0.13241981f, 0.12151545f, 0.03910660f, -0.00482353f, 0.09081710f, -0.10641690f, 0.09392606f, 
    -0.11785313f, 0.09123381f, -0.10806455f, -0.09706593f, -0.06544861f, 0.17371452f, -0.05292724f, 0.15725078f, 
    -0.05756278f, 0.20449074f, -0.02532703f, 0.00618544f, 0.12611912f, 0.00636413f, -0.40559137f, -0.18063098f, 
    -0.00697080f, -0.02593104f, -0.06685783f, -0.13229346f, -0.08658651f, 0.08642366f, -0.00007878f, 0.06257837f, 
    0.04045879f, -0.04695973f, 0.35543442f, -0.11767118f, -0.01746856f, -0.04281840f, -0.15626711f, -0.01501865f, 
    0.11189941f, 0.01957197f, -0.13658951f, 0.07839816f, 0.26995280f, 0.19793223f, -0.06270407f, -0.11004955f, 
    -0.19590370f, -0.01493750f, -0.01267842f, 0.11239538f, 0.04168676f, -0.05149347f, 0.07502420f, 0.02465869f, 
    -0.02003920f, -0.12900786f, -0.03410400f, 0.03305954f, 0.06987509f, 0.13940966f, 0.00064577f, -0.01503568f, 
    -0.02761156f, -0.12784760f, -0.00982096f, 0.06652845f, -0.05681898f, 0.09633002f, -0.00823639f, -0.07727448f, 
    0.04366723f, 0.07777890f, 0.10194244f, -0.14780506f, 0.01341223f, 0.00060724f, 0.02629407f, 0.00409055f, 
    -0.10485606f, 0.09078038f, 0.08395885f, -0.13901569f, -0.03056480f, 0.08119991f, -0.05595460f, -0.01377621f, 
    -0.10684923f, 0.07185066f, -0.04090782f, -0.04881216f, 0.00592841f, 0.08428653f, -0.11509804f, 0.28015962f, 
    -0.03170630f, -0.04693156f, -0.04039791f, -0.02519026f, 0.04902336f, 0.01438178f, 0.07889564f, -0.03198243f, 
    0.17873242f, -0.12648785f, 0.24409467f, -0.08039713f, -0.09383220f, -0.08493981f, -0.12468562f, -0.10482637f, 
    -0.00674443f, 0.07034590f, -0.04517346f, -0.07709709f, -0.07708230f, -0.21123770f, -0.02241557f, 0.32209724f, 
    -0.14577770f, -0.05586414f, 0.15557005f, 0.22465798f, -0.05469484f, 0.01104543f, 0.04099846f, 0.11915308f, 
    0.19430345f, 0.00702245f, 0.03922146f, 0.07707971f, -0.04969275f, 0.02956488f, -0.02491749f, 0.06002651f, 
    -0.03070414f, -0.00875486f, -0.01394003f, -0.06104236f, -0.01887763f, 0.03367220f, 0.13646220f, 0.05283277f, 
    0.03835345f, -0.07286996f, -0.10447983f, -0.06515012f, 0.09255558f, 0.05788598f, -0.08581211f, 0.21137032f, 
    0.07417803f, -0.09687486f, -0.06061896f, 0.15112914f, 0.00250580f, 0.08282994f, -0.09132365f, 0.03752406f, 
    0.04856552f, 0.09217316f, 0.09786790f, -0.01617819f, -0.09132203f, 0.21450210f, -0.04988932f, -0.07953436f, 
    0.05241392f, 0.02842930f, -0.02704647f, -0.03120822f, 0.08652443f, 0.08272184f, 0.09812576f, 0.10449894f, 
    0.11057565f, -0.32494920f, 0.11792276f, -0.08812143f, -0.00333481f, 0.05857940f, 0.06127219f, 0.06561011f, 
    0.09375589f, 0.11890557f, -0.10802059f, 0.03789143f, -0.19671966f, -0.15209821f, 0.00475090f, -0.19665632f, 
    0.02586685f, 0.01335374f, 0.13608779f, -0.04987852f, 0.03530887f, 0.02337516f, 0.03530258f, 0.15734966f, 
    0.04938957f, 0.09777338f, -0.00602491f, 0.03103024f, 0.07788062f, -0.03650299f, -0.01332874f, 0.16724190f, 
    0.12646586f, 0.08168783f, 0.00625934f, 0.14362514f, 0.20857191f, -0.16561839f, -0.09715524f, -0.05253094f, 
    0.09572044f, 0.05518816f, 0.04763949f, -0.00174254f, 0.04694709f, 0.05405832f, -0.06889361f, 0.05993863f, 
    -0.04446733f, -0.00118392f, -0.03922567f, 0.02261382f, -0.09897953f, 0.00006737f, -0.04498051f, 0.00527508f, 
    0.10848842f, -0.00705376f, 0.07184857f, 0.11387157f, -0.27716476f, 0.04553564f, 0.28483376f, -0.22675735f, 
    0.02349886f, 0.03127243f, -0.02529972f, -0.06587868f, 0.01896055f, -0.10850767f, 0.07510781f, 0.09559499f, 
    -0.10151859f, -0.09731006f, -0.12802380f, -0.05300157f, 0.05551996f, 0.04734020f, -0.07844479f, 0.02434181f, 
    -0.03388218f, -0.02827062f, 0.07486936f, 0.00895267f, 0.18129387f, 0.19358915f, 0.01917521f, -0.13687040f, 
    0.01694311f, -0.02841398f, 0.07044684f, 0.01036325f, -0.04845761f, -0.15964282f, -0.00357701f, -0.07711045f, 
    0.00374457f, -0.00134090f, -0.04793854f, -0.00176693f, 0.03908767f, -0.02437318f, 0.03946028f, 0.03145947f, 
    0.13248423f, 0.02833834f, -0.03447714f, 0.04102768f, 0.03285025f, 0.06907112f, -0.13999744f, 0.24061196f, 
    0.13604856f, -0.02860885f, 0.13910523f, -0.00981567f, -0.01638472f, 0.05685619f, -0.01224736f, 0.05261426f, 
    -0.11106317f, 0.08766244f, 0.06110449f, 0.08738079f, -0.02585245f, -0.05531077f, -0.17346315f, 0.07701293f, 
    0.04969690f, -0.00247008f, -0.04125657f, 0.05017962f, -0.16255426f, 0.30856219f, -0.01726061f, -0.14477511f, 
    0.06349202f, -0.04815065f, -0.00276796f, 0.00727557f, -0.05160730f, -0.06435273f, -0.09222556f, 0.05094396f, 
    -0.09371442f, -0.10024349f, 0.11535036f, -0.00874732f, 0.14583345f, 0.03307615f, 0.05892292f, 0.06095728f, 
    0.04301336f, -0.05297828f, -0.11169960f, -0.23680124f, -0.36381617f, -0.08065708f, -0.08844300f, -0.00992182f, 
    0.20842911f, -0.02368573f, 0.02611991f, 0.02861600f, -0.05895105f, 0.06771237f, 0.08512096f, 0.10274378f, 
    0.03693563f, 0.13126341f, 0.04538126f, 0.01011735f, -0.15028211f, -0.03650096f, 0.12187212f, 0.00808763f, 
    -0.06846692f, -0.06006443f, 0.05490075f, -0.04010334f, 0.06643528f, -0.23311669f, 0.07339691f, 0.05985188f, 
    0.09146973f, -0.05213132f, 0.04702558f, 0.02071120f, -0.07253443f, -0.08942806f, -0.08213985f, -0.02951757f, 
    -0.02169285f, 0.11402968f, -0.05861053f, 0.06211542f, 0.05290195f, 0.00318579f, 0.00100462f, 0.00624319f, 
    0.10289172f, -0.10022884f, 0.02070764f, 0.04728968f, 0.06050322f, 0.21945623f, -0.01508948f, 0.11526214f, 
    0.09384354f, 0.02996161f, 0.05147441f, 0.02871936f, -0.10437497f, -0.02593438f, -0.04540677f, 0.02553210f, 
    -0.33111936f, 0.07790029f, 0.20927671f, 0.10806590f, -0.03936395f, 0.02459864f, 0.08653551f, 0.03065391f, 
    0.06776001f, -0.05802736f, -0.00188769f, -0.09525057f, -0.34086829f, 0.23215586f, -0.09508423f, 0.12520280f, 
    -0.09441714f, -0.04793069f, -0.00448796f, 0.10944408f, -0.02169167f, -0.07448220f, -0.00887807f, -0.18083690f, 
    0.29308435f, -0.12886991f, 0.06237306f, 0.02575698f, 0.06156266f, -0.08671077f, 0.00260488f, -0.15404682f, 
    -0.00515418f, -0.06959110f, 0.11815441f, -0.00201535f, 0.19391571f, 0.17890780f, -0.33192897f, 0.19675705f, 
    0.04636884f, 0.06773411f, 0.02609464f, 0.01011549f, 0.11882479f, -0.03870570f, -0.00986457f, -0.03397313f, 
    0.07686646f, 0.05874756f, -0.11302411f, -0.08996569f, 0.03053503f, 0.02563908f, -0.00658799f, -0.05039035f, 
    0.10557502f, -0.03470171f, -0.07599907f, -0.01726422f, 0.01232113f, -0.02107937f, 0.22466125f, 0.25584918f, 
    0.05940324f, -0.03081943f, 0.08437201f, 0.06297640f, -0.01481272f, 0.10415287f, 0.10179270f, 0.09600446f, 
    0.20704767f, -0.23623925f, -0.09299393f, 0.02768685f, -0.04180568f, 0.02044342f, -0.06672195f, -0.11925590f, 
    -0.08058764f, -0.02404344f, 0.05274135f, -0.08550541f, 0.06499108f, 0.22033960f, -0.01342671f, -0.11585305f, 
    -0.06311315f, -0.05131853f, 0.06877721f, -0.08601176f, -0.12252589f, -0.11029376f, 0.04519612f, -0.11344747f, 
    0.19995618f, -0.09441876f, 0.05244560f, -0.01910998f, 0.10391609f, -0.02354275f, 0.09952207f, -0.10901460f, 
    -0.02822499f, 0.03134551f, 0.25254220f, -0.01076287f, -0.08875196f, 0.03355799f, -0.02126949f, -0.07580201f, 
    -0.05755263f, -0.13320255f, -0.12909360f, 0.01331761f, 0.05856005f, 0.01366861f, 0.04352391f, -0.00550096f, 
    -0.02101766f, 0.00291124f, -0.21222325f, 0.01235177f, -0.05655727f, 0.02850970f, 0.03242345f, -0.06951327f, 
    0.03580811f, 0.11717036f, 0.13506530f, 0.31010142f, 0.24783497f, 0.06414000f, 0.13459487f, -0.06287713f, 
    -0.13620640f, 0.09687375f, 0.13092425f, -0.08388190f, 0.09790980f, 0.03590451f, 0.05561234f, -0.06606508f, 
    0.19496594f, -0.07455447f, 0.01825363f, 0.02747007f, -0.04103632f, -0.02469619f, -0.05600322f, -0.10788205f, 
    -0.04365054f, 0.01849512f, -0.01288021f, -0.15526535f, 0.12060351f, 0.38347933f, -0.01372825f, 0.03260700f, 
    0.05408629f, 0.10472954f, 0.00179012f, -0.05106518f, 0.09884851f, 0.06671894f, 0.04771654f, 0.05132448f, 
    0.17507197f, 0.10082906f, -0.07632923f, -0.10848603f, -0.00456348f, -0.00901390f, -0.01953435f, -0.05546579f, 
    0.01947900f, -0.05177590f, 0.11231239f, 0.01721176f, -0.08815835f, -0.01340524f, 0.10666925f, -0.05463378f, 
    0.15337883f, 0.02589856f, -0.00621212f, 0.12597930f, 0.06250821f, 0.12430083f, -0.00163762f, 0.08747294f, 
    -0.14015327f, 0.19484566f, -0.01316583f, 0.02783401f, 0.00512570f, 0.05132987f, 0.01860903f, 0.03877744f, 
    0.06070344f, 0.00436698f, -0.06242472f, 0.12967795f, 0.13949728f, -0.01955082f, -0.25116447f, -0.11981966f, 
    -0.03583107f, -0.10535098f, -0.11266202f, -0.01795477f, -0.05429461f, 0.01668983f, -0.01653020f, 0.03346081f, 
    -0.04452479f, -0.06725870f, 0.26918578f, 0.17041196f, -0.04043514f, -0.03998676f, -0.02873379f, 0.09102545f, 
    -0.03280843f, -0.10186344f, -0.07092245f, 0.12396249f, 0.02700273f, 0.30467385f, -0.05104966f, -0.06472278f, 
    -0.09996761f, 0.11398709f, -0.11153140f, -0.02902413f, -0.02938062f, 0.04110426f, 0.01500498f, -0.04086732f, 
    0.18633151f, -0.16710123f, 0.01121755f, 0.09638103f, -0.06752078f, -0.01553618f, -0.00806367f, 0.17618823f, 
    -0.08369589f, -0.04254480f, 0.08108525f, 0.10530847f, -0.07802650f, 0.27647442f, 0.10962674f, 0.13699615f, 
    0.10432298f, 0.16175036f, -0.05790779f, -0.04900007f, -0.03961550f, -0.13035142f, -0.05494833f, -0.03090529f, 
    -0.32450700f, 0.11653348f, 0.05022911f, -0.14477800f, 0.05898277f, -0.04537274f, 0.14321454f, 0.05317355f, 
    0.07366148f, 0.15545501f, -0.00421728f, 0.08929764f, -0.08108180f, 0.01866742f, -0.03339206f, 0.16616575f, 
    0.03104700f, -0.01230741f, 0.12748502f, -0.06513416f, 0.09964448f, -0.07292116f, -0.11634886f, -0.02779551f, 
    0.18171613f, -0.00342716f, 0.05365456f, -0.10280066f, -0.04389012f, 0.01122407f, -0.18785869f, -0.12373267f, 
    -0.03541224f, 0.01502085f, -0.02161964f, -0.07910419f, -0.20228782f, -0.10084174f, 0.07263852f, 0.25851610f, 
    -0.15884730f, -0.06696042f, 0.03755336f, -0.01943291f, 0.06308065f, 0.11940295f, -0.00372174f, -0.01794126f, 
    0.12314601f, -0.18490730f, 0.07529329f, -0.00915748f, 0.08158644f, -0.04183630f, -0.04920294f, -0.04679482f, 
    -0.02070421f, -0.05700528f, 0.02054835f, -0.16898841f, -0.24468727f, -0.06760506f, 0.09175544f, -0.00880740f, 
    0.15867899f, 0.02274030f, -0.08186368f, -0.03584957f, 0.02408816f, 0.04312672f, 0.00807122f, 0.20290275f, 
    -0.26739278f, 0.37248886f, 0.10160825f, -0.25502077f, 0.07251844f, -0.00560282f, 0.02830219f, -0.08647646f, 
    -0.02590864f, -0.09364202f, 0.09514581f, -0.02115070f, -0.10393217f, -0.22923107f, 0.24582319f, 0.16286948f, 
    -0.00813625f, -0.01681215f, -0.01537506f, 0.05860916f, -0.02942748f, 0.00623155f, -0.07596619f, 0.02599831f, 
    -0.14581399f, 0.13112418f, -0.03525919f, 0.08849262f, 0.11784115f, -0.03062256f, 0.09402070f, 0.04895096f, 
    0.08639475f, -0.02341698f, 0.04136105f, 0.08051289f, 0.00966950f, 0.04941184f, -0.27594656f, -0.07821224f, 
    0.10644436f, 0.01205644f, -0.05669344f, -0.01367450f, 0.02331833f, 0.00592462f, 0.12632857f, 0.02006804f, 
    -0.09260717f, 0.05513367f, -0.01052311f, 0.15274829f, 0.17514117f, -0.07120816f, -0.00168999f, -0.08822799f, 
    -0.07063088f, -0.06725150f, -0.01947661f, 0.05112332f, -0.00197507f, 0.06085650f, 0.06526455f, 0.16367620f, 
    -0.14901459f, 0.07110959f, 0.10147144f, 0.09413712f, 0.01928515f, -0.06034558f, 0.14647987f, -0.12819219f, 
    0.30195066f, -0.43007267f, -0.21190876f, 0.42116973f, 0.02183833f, 0.00078222f, 0.03346803f, -0.00711968f, 
    0.02702839f, -0.07342099f, 0.04209611f, 0.06237732f, -0.10093866f, 0.28587469f, 0.06128248f, 0.23635003f, 
    -0.04668759f, 0.04683631f, -0.02533740f, -0.01819350f, 0.05193596f, 0.01366775f, -0.07989565f, 0.14321809f, 
    -0.03519518f, -0.01100109f, 0.16126646f, -0.04780756f, -0.00314921f, -0.00795350f, 0.01581629f, -0.04951717f, 
    -0.10353552f, -0.08120664f, -0.01512767f, 0.04792150f, -0.15305676f, 0.04172917f, 0.01698767f, 0.04934405f, 
    0.08379339f, -0.06320258f, 0.00208759f, 0.11303045f, 0.08331943f, 0.06211292f, -0.06015494f, 0.03797690f, 
    -0.15136649f, -0.01119559f, -0.06060990f, -0.18883319f, 0.13132381f, -0.09689645f, -0.00478825f, 0.11535361f, 
    0.06964085f, -0.11964313f, 0.01087795f, -0.12111534f, -0.05113027f, 0.13859059f, 0.06583261f, -0.33844712f, 
    0.14295636f, -0.04485159f, -0.01051856f, -0.12871799f, 0.04463379f, -0.01371588f, -0.09730473f, 0.03005283f, 
    0.11070807f, -0.06597420f, 0.16888849f, 0.05320576f, -0.01336483f, 0.13335614f, -0.04275183f, 0.04831101f, 
    -0.09579389f, 0.08721992f, 0.05486949f, 0.09171381f, 0.01396030f, 0.02625018f, -0.03121615f, 0.00053288f, 
    0.04647007f, -0.03541165f, 0.02074329f, 0.00794310f, -0.05174527f, 0.14020476f, -0.00797897f, 0.09150900f, 
    0.03189463f, 0.17828596f, -0.04411549f, 0.04147105f, 0.02664762f, 0.09433662f, -0.01517980f, -0.02216073f, 
    0.05358088f, -0.12467706f, 0.01259780f, 0.07261250f, 0.15715681f, -0.09308336f, -0.04663684f, -0.04893621f, 
    0.06028026f, -0.14551453f, 0.08582374f, 0.04507145f, -0.13613410f, -0.00582776f, 0.04231024f, -0.02028217f, 
    -0.00299490f, -0.01934045f, -0.01662000f, -0.09098542f, -0.08301931f, 0.00030379f, 0.02940349f, -0.02515860f, 
    -0.00147553f, -0.04131318f, 0.03137103f, 0.03341545f, -0.01554339f, -0.07078892f, 0.01256707f, -0.07815742f, 
    0.00258657f, -0.00773156f, -0.04393919f, 0.02443035f, 0.00391512f, 0.03887124f, -0.02930170f, -0.03068338f, 
    -0.06037079f, 0.01717142f, -0.05744030f, -0.04658177f, -0.07560293f, 0.00187746f, -0.02620812f, 0.04753321f, 
    -0.07570516f, -0.00100271f, 0.01338255f, 0.02310048f, -0.01671383f, 0.06225680f, -0.04360070f, -0.00138717f, 
    -0.01622904f, -0.05767385f, -0.01204265f, -0.02623345f, -0.08579961f, 0.02945155f, -0.02363490f, -0.00516734f, 
    -0.03489085f, 0.02329603f, -0.07882727f, 0.03061268f, -0.06904095f, 0.03441062f, -0.07902670f, 0.00138394f, 
    0.01307082f, -0.05042019f, 0.01099187f, 0.05152712f, -0.05507334f, -0.01433290f, -0.01297341f, 0.01444593f, 
    0.04315346f, 0.01734288f, 0.04311649f, -0.07945779f, -0.03992324f, 0.04762765f, -0.00354663f, -0.06089035f, 
    -0.05116138f, -0.05302804f, -0.00369667f, -0.07285165f, -0.07397860f, 0.00680078f, -0.05437922f, -0.04924675f, 
    -0.02051596f, -0.00464287f, 0.00823834f, -0.04332169f, -0.03431762f, -0.03935103f, 0.00509038f, -0.05790660f, 
    -0.05766546f, -0.06425073f, 0.06403191f, 0.05947222f, -0.02625364f, -0.01187302f, 0.01587478f, -0.06322333f, 
    -0.02458358f, -0.06873262f, 0.02094608f, -0.04054184f, -0.05780250f, 0.01477947f, 0.05038890f, -0.03272869f, 
    -0.05432528f, 0.05781426f, 0.02722514f, 0.00759926f, -0.01807549f, 0.05525227f, -0.05380870f, 0.01652935f, 
    -0.03052497f, 0.03066192f, -0.02921718f, 0.05839279f, -0.06372239f, -0.02475763f, -0.06828876f, -0.04271627f, 
    -0.00353399f, -0.08803159f, 0.03957726f, -0.02285801f, 0.01399571f, 0.01336516f, 0.03468239f, 0.00419000f, 
    -0.05901327f, -0.06764170f, -0.03713256f, 0.00679630f, 0.03298693f, -0.05007744f, 0.03398170f, 0.04722938f, 
    -0.08406365f, -0.04110943f, 0.04227253f, -0.01305437f, -0.00960175f, -0.08440068f, -0.00183429f, 0.02877634f, 
    -0.06843279f, 0.00508640f, -0.05384455f, -0.01479585f, 0.04742460f, 0.01354583f, -0.01643934f, 0.04843977f, 
    -0.06635642f, 0.02403508f, 0.02256806f, 0.04694233f, -0.05938010f, 0.00252292f, 0.03346721f, -0.06739645f, 
    -0.03753701f, -0.05754008f, 0.01340120f, -0.06691101f, -0.03572463f, 0.01050012f, 0.05280429f, 0.02378251f, 
    0.02513056f, 0.01508918f, -0.08262057f, 0.02813170f, -0.04227529f, 0.02662113f, -0.01780718f, -0.00405074f, 
    0.02669689f, -0.07493625f, 0.01458311f, 0.02518259f, -0.05796369f, -0.06523880f, -0.02413257f, 0.01201619f, 
    -0.00374008f, -0.01652573f, -0.00948056f, -0.02588159f, -0.04290449f, 0.03712546f, 0.04756084f, 0.05520036f, 
    -0.15770085f, -0.17408016f, -0.12029082f, -0.05308476f, 0.00834219f, 0.02805577f, 0.06661481f, 0.07229684f, 
    0.00646865f, 0.05278214f, 0.09774654f, 0.00278526f, -0.12075308f, -0.06755086f, 0.11416580f, 0.08163794f, 
    0.07535287f, 0.07953744f, 0.12145919f, 0.05620399f, -0.01464973f, 0.01871907f, -0.22730245f, -0.04616033f, 
    0.22664109f, 0.11862534f, -0.02231313f, 0.00753904f, 0.09174669f, -0.02452904f, 0.09439021f, 0.01915778f, 
    0.13811773f, -0.05869060f, 0.07800747f, 0.09042221f, 0.19828209f, -0.02194558f, 0.09145562f, -0.09951030f, 
    0.07056066f, -0.00237812f, -0.08146257f, 0.05435316f, -0.01059751f, -0.12704092f, 0.11094102f, 0.01546673f, 
    -0.09037302f, 0.17033550f, 0.17930940f, 0.19564976f, -0.07069238f, -0.12870264f, 0.21540284f, -0.05464119f, 
    -0.08535593f, -0.09933747f, 0.01391603f, 0.05300588f, -0.39587492f, -0.22537467f, -0.02241334f, 0.05138396f, 
    -0.00932355f, 0.05118201f, 0.01847539f, -0.00822783f, 0.00427152f, 0.00319325f, 0.04648973f, 0.00235242f, 
    0.12833525f, 0.12101525f, 0.14268270f, 0.24809088f, 0.08262482f, -0.17415006f, 0.08308206f, -0.03711867f, 
    -0.11985929f, -0.07651582f, -0.05692379f, 0.02177464f, 0.06645546f, -0.07166221f, -0.12811641f, 0.02995404f, 
    -0.06662703f, 0.13356358f, -0.01574650f, -0.01142144f, 0.01763617f, 0.09777851f, -0.09546562f, 0.05076321f, 
    -0.56658280f, -0.10717753f, -0.02160842f, 0.12975167f, 0.12549661f, -0.05452985f, -0.04553756f, -0.06770125f, 
    0.06187234f, 0.09479938f, 0.05444132f, -0.05497490f, 0.04596431f, 0.13111749f, 0.11318285f, 0.08178362f, 
    -0.05407490f, 0.03902837f, 0.09579848f, 0.12378775f, 0.03320273f, 0.13192667f, 0.00758929f, 0.00184621f, 
    0.05361076f, 0.11437883f, 0.00095519f, -0.08603480f, -0.02274413f, 0.03596104f, 0.06187737f, -0.00514426f, 
    0.01813121f, -0.03638828f, 0.13626944f, 0.17269289f, -0.19606893f, -0.02602379f, -0.18033169f, -0.08586561f, 
    0.05878974f, -0.02838808f, 0.05484680f, -0.10220421f, -0.05857143f, -0.02999821f, -0.02700211f, -0.02460388f, 
    0.16456552f, 0.00587927f, 0.04660780f, -0.10141581f, 0.04362619f, 0.04437510f, 0.15624860f, 0.03229123f, 
    -0.15616746f, 0.07228486f, 0.20291759f, 0.05538552f, -0.05261375f, 0.16379991f, 0.05846769f, 0.12463710f, 
    0.17750704f, -0.05891412f, -0.08487824f, 0.02913557f, 0.12733890f, -0.00486884f, -0.14879191f, 0.07297146f, 
    0.06639051f, 0.05571729f, -0.01185509f, 0.04842152f, -0.07321187f, 0.08794454f, -0.05333929f, 0.09152955f, 
    0.04347115f, 0.11013970f, 0.06290683f, 0.20152418f, -0.01553486f, 0.04759685f, 0.15059349f, 0.03161915f, 
    -0.01702908f, -0.04960540f, 0.04701794f, 0.00407740f, 0.07680140f, 0.14830856f, -0.04377142f, 0.10868075f, 
    0.11969539f, -0.16343829f, -0.19204895f, -0.04270731f, 0.08635384f, -0.02965461f, 0.07617807f, 0.13152282f, 
    -0.01368259f, 0.10394252f, -0.03417467f, 0.00710957f, -0.06822067f, -0.28439102f, 0.19112012f, -0.06976325f, 
    0.10637921f, -0.05260389f, 0.18611784f, 0.05482329f, 0.02465884f, 0.03302009f, 0.02457885f, -0.04299497f, 
    0.31018269f, -0.14729051f, 0.01299547f, 0.10474493f, 0.10816991f, -0.01593330f, 0.08712684f, 0.05717229f, 
    -0.14333583f, 0.02381340f, 0.02701669f, 0.10285153f, -0.15411001f, -0.02760644f, 0.11987673f, 0.07799233f, 
    -0.07961176f, -0.08305817f, -0.06661621f, 0.00436453f, 0.17257702f, 0.03672449f, 0.14380993f, -0.01641944f, 
    -0.02406327f, 0.10737109f, -0.11861161f, 0.25331071f, 0.02444657f, -0.14000966f, 0.09709781f, -0.00096462f, 
    0.03023820f, -0.03001196f, 0.03119926f, 0.06878095f, -0.02388307f, -0.17546561f, 0.13781202f, 0.06495721f, 
    0.02747684f, -0.01719205f, 0.07571868f, 0.03875929f, 0.18115813f, -0.04333843f, 0.02986076f, 0.03183313f, 
    0.01966802f, -0.05720099f, -0.06697961f, 0.15447520f, -0.08990829f, -0.04919829f, 0.03670284f, -0.01805085f, 
    0.00416424f, -0.08793476f, 0.13894124f, 0.03991653f, -0.30606863f, 0.09110288f, -0.07358002f, 0.03449443f, 
    0.08611257f, 0.09968139f, -0.00761950f, -0.15361971f, 0.01519225f, 0.05254575f, 0.09801199f, 0.08089687f, 
    0.00202024f, -0.07160684f, -0.16414151f, -0.20204206f, -0.10786885f, -0.18631503f, 0.05428313f, 0.10688192f, 
    0.08169688f, -0.05922520f, -0.01812927f, 0.02442091f, -0.10326377f, 0.09523821f, 0.09567598f, 0.05130801f, 
    0.17373644f, 0.00913326f, -0.03423228f, 0.13057514f, 0.00261389f, 0.01275929f, 0.02493083f, -0.08629883f, 
    -0.22352158f, -0.19838692f, -0.02347132f, -0.08312009f, 0.01476095f, -0.01828115f, 0.00259135f, 0.00578257f, 
    -0.00887968f, 0.15837130f, 0.14898787f, 0.14920722f, -0.11855666f, 0.08383109f, -0.10503456f, -0.24633572f, 
    0.06281941f, 0.04891737f, 0.03368217f, 0.16393988f, 0.05146924f, -0.02439084f, -0.08738953f, 0.01938727f, 
    -0.07788629f, 0.11665988f, -0.15184519f, 0.00029150f, 0.10579755f, -0.01220214f, -0.03076245f, 0.00693358f, 
    0.00825537f, -0.08048066f, 0.14710104f, 0.05631328f, -0.20289509f, 0.20220272f, 0.21114877f, -0.25865787f, 
    0.00999082f, 0.10158045f, -0.00606310f, -0.02331346f, -0.01797230f, -0.07994127f, -0.05257805f, 0.06855261f, 
    -0.09625083f, -0.10024865f, 0.14686432f, -0.00040665f, 0.09413850f, -0.04878229f, 0.03046141f, 0.12700166f, 
    -0.08223065f, -0.09761541f, -0.05634350f, 0.01450788f, -0.44573826f, 0.16543670f, 0.07489350f, 0.06709162f, 
    0.16793735f, 0.03239776f, 0.00149024f, 0.13668233f, -0.08565375f, -0.04707527f, -0.03449761f, -0.08202375f, 
    0.05706428f, -0.00860195f, -0.16591810f, 0.19381323f, 0.06826205f, -0.03388384f, 0.05552736f, 0.02533889f, 
    0.10743620f, 0.03979234f, 0.06567824f, -0.06956421f, 0.12756059f, 0.22001605f, 0.00049265f, -0.21534036f, 
    0.05114927f, 0.10401318f, 0.08039836f, -0.06985470f, -0.03396984f, -0.09006650f, -0.01324984f, 0.03812731f, 
    -0.10619654f, -0.09100492f, 0.17814177f, -0.05566222f, 0.04037063f, -0.09443826f, 0.02215993f, 0.02864164f, 
    0.09724176f, -0.01644127f, 0.06345350f, 0.06098418f, 0.18699731f, -0.01404840f, 0.30676958f, -0.26798329f, 
    -0.01507486f, -0.06006235f, -0.05886657f, 0.02224600f, 0.03252104f, -0.13524133f, -0.04266368f, 0.02774476f, 
    -0.03751875f, 0.03528736f, 0.18303430f, -0.09993418f, -0.11506610f, -0.04393109f, -0.01728266f, 0.03271766f, 
    -0.07097115f, -0.04727720f, -0.00397590f, 0.01115215f, 0.03751244f, 0.01159813f, -0.02542442f, -0.01495032f, 
    -0.08714224f, -0.02032335f, 0.01397600f, 0.01452997f, -0.07505064f, 0.04219856f, 0.07296503f, 0.05982798f, 
    -0.10586152f, 0.32409769f, -0.06820892f, -0.22705820f, 0.11591870f, 0.02988501f, -0.01072885f, 0.07050578f, 
    -0.09723280f, 0.06418879f, 0.06322082f, -0.05247688f, -0.08608647f, -0.05288417f, 0.06382738f, -0.09800985f, 
    0.00714819f, -0.03701930f, 0.13536458f, 0.13357435f, -0.01684576f, 0.07407931f, 0.03704857f, -0.08252091f, 
    -0.11497512f, -0.00193378f, -0.15059075f, 0.17259392f, 0.03401878f, -0.01955169f, 0.01825118f, -0.09675750f, 
    0.10665924f, 0.10779916f, 0.02441630f, -0.04197082f, 0.37817585f, 0.07872913f, 0.25217265f, 0.00770631f, 
    -0.14442109f, -0.08180223f, -0.03760619f, 0.13887879f, -0.04622602f, 0.08212693f, 0.05602473f, 0.05118728f, 
    0.39189386f, 0.20161323f, 0.01895974f, 0.18677133f, -0.00590905f, 0.11579593f, -0.09694359f, -0.15846878f, 
    0.11124694f, 0.00186094f, 0.00969066f, 0.09198704f, -0.05005483f, -0.07041376f, -0.11613601f, 0.30424428f, 
    0.03997790f, -0.04113540f, 0.03028837f, -0.05412924f, -0.13442250f, -0.02478799f, -0.05521389f, -0.11760549f, 
    -0.11280601f, -0.01998122f, -0.10248701f, 0.25437519f, -0.02762107f, 0.03070813f, 0.21329685f, 0.09083665f, 
    -0.12377560f, 0.00126348f, 0.01273306f, 0.09462439f, 0.06201035f, -0.05834245f, -0.02369359f, -0.04484998f, 
    0.13880776f, 0.02748823f, -0.20038804f, -0.00209933f, 0.08469998f, 0.08333141f, -0.11175958f, 0.02778267f, 
    0.07550798f, 0.12443878f, -0.05677581f, -0.05364449f, -0.05337941f, 0.11056791f, -0.10066118f, 0.05318946f, 
    -0.04982582f, 0.26061302f, 0.11155134f, 0.10950585f, 0.22235622f, -0.04246695f, 0.10899907f, -0.05775306f, 
    -0.02306126f, -0.07010330f, 0.03193264f, -0.07186685f, -0.02358758f, 0.05499257f, -0.03248065f, -0.02837129f, 
    -0.06981850f, -0.03302288f, -0.00568206f, -0.04979346f, -0.04948008f, 0.06067225f, 0.01505527f, -0.04274996f, 
    -0.04958282f, -0.04977183f, -0.04276352f, -0.00048598f, 0.02794446f, 0.06185374f, -0.03819004f, 0.06184428f, 
    -0.03365447f, -0.07506173f, -0.03106138f, 0.04080681f, 0.02838986f, 0.05329734f, 0.05274658f, -0.03912388f, 
    -0.04881534f, -0.02310461f, -0.07017696f, -0.01747258f, 0.04797744f, 0.05548959f, -0.06208511f, 0.02833061f, 
    -0.06620742f, 0.02873692f, -0.04357437f, -0.05627196f, -0.06334504f, -0.06673260f, 0.04163273f, -0.06323728f, 
    0.06148734f, -0.06151593f, 0.05803019f, 0.04239567f, 0.03038864f, 0.04131327f, -0.03699192f, -0.06971461f, 
    0.04518519f, 0.04488630f, 0.01517346f, 0.04194875f, 0.01058764f, 0.02126404f, -0.06753016f, 0.02207617f, 
    -0.03879018f, 0.00277664f, 0.01626521f, -0.07317246f, 0.05716354f, -0.02681694f, 0.03104702f, 0.06175511f, 
    -0.02385133f, 0.03898388f, -0.07596666f, -0.04912428f, -0.05587127f, -0.01701274f, -0.01585684f, 0.01276345f, 
    -0.04363862f, 0.01173274f, 0.05124879f, 0.00153359f, -0.03212989f, 0.01483546f, 0.04008845f, -0.07527224f, 
    -0.01729195f, 0.05107970f, -0.04861316f, 0.03722517f, -0.01686961f, -0.04580485f, -0.00575064f, 0.06395087f, 
    -0.04334940f, 0.03356784f, -0.01005157f, -0.07373594f, 0.02650209f, -0.04047836f, 0.02171355f, -0.02126502f, 
    -0.06212266f, -0.04614677f, 0.04219358f, -0.05591961f, -0.04719348f, 0.06221399f, -0.07022506f, -0.04209949f, 
    -0.05422061f, -0.07030705f, -0.01583526f, -0.01613766f, 0.02822606f, 0.06001186f, -0.04812352f, 0.06371311f, 
    -0.03980042f, -0.01086457f, 0.05371461f, 0.04969522f, -0.03873594f, -0.03681340f, -0.02961083f, -0.05632738f, 
    0.04949530f, 0.02510071f, -0.05556184f, 0.03313795f, 0.05384387f, 0.03252364f, -0.01982529f, -0.07400420f, 
    -0.06169583f, 0.02383348f, -0.03699457f, 0.01243039f, -0.03207826f, -0.06909503f, -0.01125497f, -0.02404710f, 
    -0.01418933f, -0.00425628f, -0.07059912f, 0.02367261f, 0.04956076f, -0.03548152f, -0.03621490f, -0.04348436f, 
    0.02152017f, -0.03495311f, 0.05238571f, 0.00686025f, 0.06099348f, 0.04271150f, -0.05269834f, 0.00754866f, 
    0.03766316f, -0.04975549f, 0.04583996f, -0.02385684f, -0.03497446f, -0.00966935f, -0.05141194f, -0.01366076f, 
    -0.01110427f, 0.01386070f, -0.05834153f, 0.02136729f, -0.00750760f, -0.01665410f, -0.02709134f, -0.03803700f, 
    0.00523398f, -0.01158885f, -0.02862919f, 0.05969402f, 0.00365529f, -0.06870509f, -0.07532056f, -0.02359040f, 
    -0.03577620f, 0.00472197f, -0.05705884f, -0.07336915f, 0.01693941f, 0.01667511f, 0.04422421f, 0.02324571f, 
    -0.03615237f, -0.04471772f, -0.03876651f, -0.00248828f, -0.05292670f, -0.05339685f, -0.02646328f, 0.04467526f, 
    0.19060180f, -0.14997539f, 0.04191110f, 0.08793557f, -0.12148175f, -0.06751664f, 0.10561502f, 0.08602025f, 
    0.00232502f, 0.04182990f, -0.00942367f, 0.04379086f, 0.00315701f, 0.06063263f, -0.14578564f, 0.16736203f, 
    0.13264944f, -0.04165903f, 0.03519648f, 0.02194097f, 0.08299854f, 0.04687676f, 0.00340913f, 0.01555982f, 
    0.30537298f, -0.17322741f, 0.06734795f, 0.01138340f, 0.05418506f, 0.04908825f, 0.06426500f, -0.03350777f, 
    0.09801456f, 0.03465287f, 0.12120221f, 0.01507350f, -0.17835708f, -0.01156475f, 0.12504822f, -0.00758357f, 
    -0.01851103f, 0.07418400f, 0.08075469f, -0.01096340f, -0.02514840f, 0.05822513f, 0.00713258f, -0.02201694f, 
    -0.07756567f, 0.03881784f, 0.05264271f, -0.09521665f, -0.11585637f, 0.05238359f, 0.13372028f, 0.06592801f, 
    0.07247187f, -0.10758983f, 0.03239995f, 0.05303515f, -0.27249840f, 0.02236197f, -0.13820542f, 0.03438002f, 
    0.07217910f, 0.07548541f, -0.06483398f, -0.06199633f, -0.03850443f, 0.01406563f, -0.00411850f, -0.08418683f, 
    -0.27779639f, 0.35362676f, 0.19807126f, 0.03249174f, -0.01515680f, -0.07604117f, -0.11271237f, -0.01769116f, 
    -0.00553730f, 0.02428666f, -0.00703323f, 0.03005710f, 0.04175983f, 0.02571419f, -0.30447367f, -0.12198810f, 
    0.04086097f, 0.00490679f, -0.08116414f, -0.02965166f, 0.05105922f, -0.01827726f, -0.05061965f, 0.03001932f, 
    0.03479921f, 0.20726521f, -0.16930278f, 0.11526713f, 0.18363346f, -0.04662066f, -0.06966674f, 0.14304383f, 
    0.19465865f, 0.05576380f, 0.17435309f, 0.02985443f, 0.32683170f, 0.15116209f, 0.04809809f, 0.02840567f, 
    -0.13410540f, 0.08761947f, 0.05865989f, -0.03141011f, -0.13124168f, -0.03045720f, 0.06055343f, 0.03310321f, 
    0.04454342f, -0.07320748f, 0.05405652f, 0.15855876f, 0.05600146f, -0.07332521f, 0.13942075f, -0.10027771f, 
    0.05286092f, 0.04172672f, 0.01226154f, 0.10204844f, -0.01192540f, -0.16627449f, -0.00019171f, 0.10522372f, 
    -0.11055168f, 0.06239164f, 0.00625592f, 0.03360355f, 0.00296803f, 0.00722031f, 0.02078790f, 0.04972794f, 
    -0.19831926f, 0.24107084f, -0.09837895f, -0.19619922f, 0.07176648f, -0.05169978f, 0.12492285f, -0.08182182f, 
    0.03319061f, -0.02391828f, 0.09034070f, 0.09717841f, 0.09237558f, 0.14676075f, 0.07445064f, 0.03133869f, 
    0.10097701f, -0.09587261f, 0.08360949f, 0.02717428f, 0.10762066f, 0.02414708f, -0.11442346f, 0.01687604f, 
    -0.17523620f, -0.17081635f, 0.07120988f, -0.07952606f, 0.00230231f, -0.08157697f, 0.07698690f, 0.11701391f, 
    0.00773921f, -0.05001846f, -0.00115643f, 0.03333126f, -0.02991417f, 0.23537230f, 0.02841916f, -0.01088494f, 
    0.08102763f, 0.10258479f, 0.03442899f, -0.02095873f, -0.01944248f, 0.08712818f, 0.09988154f, 0.04503383f, 
    0.16417418f, 0.07007098f, -0.16892368f, 0.04762843f, 0.21729845f, -0.12239392f, 0.09007619f, 0.12952237f, 
    0.10814908f, -0.03084772f, 0.11522273f, -0.00208016f, 0.01860881f, -0.28498799f, 0.09761537f, -0.27751872f, 
    0.06359447f, 0.01330796f, 0.20891795f, 0.08034303f, 0.00164980f, -0.00713602f, -0.03187016f, 0.01413515f, 
    -0.10373821f, -0.14981787f, -0.05268725f, 0.07917231f, 0.06335557f, -0.17217787f, 0.03027694f, 0.05288626f, 
    -0.06863108f, -0.08853833f, 0.03891142f, -0.04915121f, -0.20632368f, 0.08689251f, 0.08243233f, 0.03653220f, 
    -0.07773300f, 0.04654795f, -0.09399047f, 0.11667600f, -0.04220395f, -0.04621037f, 0.01455213f, 0.02611049f, 
    -0.06571802f, -0.01487399f, 0.08432088f, 0.13688783f, 0.07443642f, -0.02789370f, -0.03977013f, 0.00216818f, 
    0.06097763f, -0.14257929f, 0.10382688f, 0.04904454f, 0.12534039f, 0.10775632f, 0.23330301f, 0.13469689f, 
    -0.06243154f, 0.05686694f, 0.12722291f, 0.00429467f, -0.03235130f, -0.02675803f, 0.04494562f, -0.03284575f, 
    0.24754772f, 0.02615323f, -0.39710689f, -0.20335001f, -0.10290434f, 0.07302023f, 0.05245028f, -0.04447637f, 
    -0.07813869f, -0.04303896f, 0.20549524f, -0.08623229f, -0.18470201f, -0.03106306f, -0.01951456f, -0.03107334f, 
    0.10752480f, -0.03249137f, 0.17125878f, -0.07248510f, 0.01771501f, 0.06477676f, 0.03576072f, -0.02658155f, 
    0.09176471f, 0.15351248f, -0.04986712f, -0.11073507f, -0.01458255f, -0.04653836f, -0.04420755f, -0.10726815f, 
    0.14214490f, 0.08032271f, -0.11255120f, -0.09017392f, 0.19818096f, -0.11692356f, 0.12154850f, 0.26343283f, 
    0.01962856f, -0.05854061f, -0.01781712f, 0.14732076f, 0.01456938f, 0.14593199f, 0.06761514f, 0.04100915f, 
    0.26388326f, -0.07985119f, -0.09684700f, 0.11151956f, 0.06217126f, 0.14411260f, -0.21573238f, -0.19521722f, 
    -0.02827533f, -0.10721245f, 0.13382249f, 0.06806134f, 0.26326394f, 0.11112268f, 0.08942540f, -0.06212575f, 
    0.08995988f, 0.07033814f, 0.04092597f, 0.01403168f, -0.01095285f, 0.00599838f, -0.09589092f, -0.03459509f, 
    -0.03718231f, -0.12789679f, 0.02591689f, 0.19437076f, -0.07718351f, 0.05303212f, 0.21015579f, 0.07019129f, 
    -0.00063026f, -0.12459294f, 0.13809820f, 0.01486875f, 0.05527624f, 0.22438005f, 0.11316837f, -0.35000506f, 
    0.11310598f, 0.21608166f, -0.12356986f, -0.02415873f, -0.02741477f, -0.03132029f, 0.02454478f, 0.10792447f, 
    -0.20276764f, 0.08936702f, -0.02721824f, -0.04704954f, -0.00618934f, 0.18909177f, 0.07797407f, 0.03741511f, 
    -0.12412780f, 0.13950776f, 0.00477228f, 0.17142935f, 0.10482309f, 0.13906194f, -0.07936045f, 0.10493872f, 
    -0.02869800f, 0.09265733f, 0.06388506f, -0.00298736f, 0.05327662f, -0.02137562f, -0.02268581f, -0.24347529f, 
    -0.06181684f, 0.02921973f, 0.04869773f, 0.00519334f, 0.02527150f, -0.02717352f, 0.03352994f, -0.04492861f, 
    0.04128743f, 0.02190619f, -0.04451047f, 0.01072387f, -0.04204836f, 0.03434318f, -0.01794506f, 0.00892466f, 
    -0.00674084f, -0.07061163f, 0.00647631f, 0.01677612f, 0.03517659f, 0.05243602f, 0.04146166f, 0.04801995f, 
    -0.04197697f, -0.06844358f, 0.05522313f, 0.00150864f, -0.03961287f, -0.03157668f, 0.03267622f, -0.03568031f, 
    0.02066352f, 0.06569567f, -0.00603976f, -0.04613868f, 0.02082288f, 0.04242287f, 0.05803570f, -0.00728822f, 
    -0.02231543f, -0.03236294f, 0.00124840f, -0.07379793f, -0.07468108f, -0.07339995f, 0.03053609f, -0.01175915f, 
    0.00313019f, 0.01924615f, -0.03331047f, -0.03685899f, -0.08164218f, -0.00145797f, 0.00084438f, 0.01277185f, 
    -0.05523186f, 0.06859482f, 0.01162579f, -0.01735211f, 0.04184210f, -0.03227438f, -0.01796594f, -0.03124119f, 
    0.02151984f, -0.00509686f, -0.01005974f, 0.00557320f, -0.03684026f, 0.06171658f, -0.01854592f, 0.00939154f, 
    0.00436453f, -0.04145871f, 0.02587345f, -0.05459238f, -0.01052270f, 0.01128085f, 0.05160679f, -0.05284443f, 
    -0.00402406f, 0.06096109f, -0.07889113f, -0.06093826f, 0.04665995f, 0.00685408f, -0.01448356f, -0.07102456f, 
    0.02089637f, 0.05746363f, -0.00140256f, -0.03173913f, -0.00235117f, -0.03328735f, -0.05360900f, -0.07088415f, 
    -0.08164724f, 0.01928864f, 0.03894433f, -0.00920768f, 0.07311387f, -0.00520386f, -0.02035078f, -0.01110257f, 
    -0.02462065f, -0.05551453f, -0.04817341f, -0.06451875f, 0.05476669f, 0.06516318f, 0.03431090f, -0.05568481f, 
    -0.06370210f, 0.02860308f, 0.03068651f, -0.05035118f, -0.05564458f, 0.03130262f, 0.01856592f, 0.03734639f, 
    -0.02073311f, -0.06308218f, 0.03065643f, 0.02558576f, -0.02437541f, 0.04623335f, -0.06799986f, -0.05296000f, 
    0.06704807f, 0.06770852f, -0.06930242f, -0.05792836f, -0.00136276f, -0.01799892f, -0.06017014f, -0.01232766f, 
    -0.04738362f, -0.03744582f, 0.01269597f, -0.00432388f, -0.00313502f, 0.00217147f, -0.06844516f, -0.02288732f, 
    0.06337830f, 0.03984301f, 0.00862669f, 0.08287296f, 0.00601754f, -0.07856443f, -0.02898670f, -0.06576288f, 
    -0.03389734f, -0.05056758f, -0.07803851f, 0.01244443f, -0.02395408f, 0.02614825f, -0.00302236f, -0.06955248f, 
    -0.03812262f, -0.03364117f, -0.06326360f, 0.06040629f, -0.04408517f, -0.01680125f, -0.06707565f, -0.06127512f, 
    -0.00178410f, 0.04052086f, 0.03492239f, -0.03590350f, 0.00485280f, -0.00462130f, 0.03862633f, -0.08390593f, 
    0.00915704f, 0.00014064f, -0.03296451f, -0.00803495f, -0.05349509f, -0.01665532f, -0.08041254f, -0.09091587f, 
    -0.04238683f, -0.04882126f, 0.01391550f, 0.05355318f, -0.07562379f, -0.04681308f, 0.00767421f, 0.03670180f, 
    0.06640123f, -0.04410623f, -0.04067313f, -0.03612990f, 0.01792493f, 0.05652648f, -0.06144025f, 0.03363987f, 
    -0.03382997f, -0.00753838f, 0.02550813f, -0.08083723f, -0.05113709f, -0.01916297f, 0.03414658f, -0.02926607f, 
    -0.07294515f, -0.06578902f, -0.03521608f, 0.04724894f, -0.06471314f, -0.01163764f, -0.03092150f, 0.00968796f, 
    0.05814103f, -0.00375188f, 0.03037817f, -0.07576835f, 0.02955312f, -0.05633824f, -0.03653028f, 0.05740793f, 
    -0.00357713f, -0.02359954f, 0.00131872f, 0.03732032f, 0.03089471f, 0.01737764f, -0.06268559f, 0.05046921f, 
    0.03242657f, 0.06166261f, -0.03490908f, 0.05397956f, -0.07977408f, 0.00164890f, 0.02266383f, 0.05631800f, 
    0.01385800f, -0.05936355f, 0.02475566f, 0.03137531f, 0.02609742f, -0.05311577f, -0.03845881f, -0.07293984f, 
    -0.07247138f, -0.01490815f, -0.00217299f, -0.04241655f, 0.04970218f, 0.05566549f, -0.04247202f, -0.03088977f, 
    -0.05171864f, -0.07613467f, -0.00404119f, -0.07895160f, -0.05830700f, 0.05934814f, 0.04889076f, 0.03144308f, 
    -0.07751305f, -0.02816207f, 0.00372752f, 0.01133254f, 0.00432104f, 0.03428843f, -0.01222092f, 0.03759050f, 
    0.02552781f, -0.06667276f, -0.06287599f, 0.05572011f, -0.05604652f, 0.00503575f, -0.02579276f, 0.04851490f, 
    0.05983832f, 0.01483881f, 0.03470495f, -0.05003847f, -0.06032580f, 0.05872458f, -0.07135226f, -0.04585421f, 
    -0.00244517f, 0.01419023f, 0.00494683f, 0.04779933f, -0.00923723f, -0.02517215f, 0.05995500f, -0.04914736f, 
    0.05012021f, -0.01356204f, -0.06024558f, 0.00847948f, 0.05816440f, 0.02357828f, -0.00087046f, 0.00546538f, 
    0.04149851f, -0.01458242f, 0.00834588f, -0.02461504f, -0.05998486f, -0.01715006f, 0.01371573f, -0.02916823f, 
    -0.01974625f, -0.03141068f, 0.02187317f, -0.06653044f, 0.00274032f, 0.00883773f, -0.07750376f, 0.05538806f, 
    -0.01010734f, 0.06016841f, -0.02724982f, 0.04476205f, -0.00429413f, -0.01283281f, 0.00335987f, -0.01343374f, 
    -0.01307870f, -0.07638659f, -0.02096587f, -0.03473850f, -0.02619090f, -0.04399972f, 0.06741133f, 0.02762021f, 
    -0.07562369f, 0.04619466f, 0.02579520f, 0.03550845f, -0.03339284f, -0.01868071f, 0.02020821f, 0.04915447f, 
    -0.03917580f, 0.02119458f, -0.01714711f, 0.02840012f, -0.01642315f, -0.08814081f, -0.02646954f, 0.02225243f, 
    0.03315991f, -0.00844686f, -0.02705177f, -0.01501419f, 0.02229957f, 0.00168543f, -0.05822017f, -0.01163612f, 
    -0.00380142f, -0.00946561f, -0.07079594f, 0.02499398f, -0.01458965f, -0.03040448f, 0.03504489f, 0.01648021f, 
    0.03070382f, 0.03602900f, -0.02888066f, 0.06853817f, 0.02000192f, -0.03509037f, 0.02252224f, 0.03742018f, 
    0.00757504f, -0.07568927f, -0.05157872f, -0.06422704f, -0.07675504f, 0.03292240f, -0.06068359f, -0.07907912f, 
    -0.17219788f, 0.19409686f, -0.25407675f, 0.02033452f, 0.17510955f, 0.02449153f, 0.09696040f, 0.07028445f, 
    0.06155864f, -0.01220894f, 0.16904132f, -0.01055866f, 0.22585374f, -0.06095097f, 0.18802185f, 0.00858688f, 
    -0.03577184f, 0.13642658f, 0.06100366f, -0.00084396f, -0.15753470f, -0.03955717f, -0.05164428f, -0.06338663f, 
    -0.01786026f, -0.02110481f, 0.03733709f, 0.10355601f, 0.05339782f, -0.07183565f, 0.05917973f, 0.11961859f, 
    -0.04428562f, -0.10756832f, 0.10365622f, -0.02846087f, 0.05612373f, 0.09511805f, 0.13654521f, -0.18271691f, 
    -0.03852246f, -0.04877222f, -0.10498708f, 0.01199376f, 0.05133909f, 0.00264204f, 0.13005915f, 0.02184802f, 
    -0.05748194f, 0.06628795f, 0.10779490f, 0.09678369f, -0.06915122f, -0.05035714f, 0.09798834f, -0.05087728f, 
    -0.16177122f, -0.14322020f, 0.03087042f, 0.08975022f, -0.18114820f, 0.05004746f, 0.12646417f, 0.08090128f, 
    -0.01997540f, 0.09726311f, 0.07279078f, 0.03366818f, 0.13923475f, 0.06547749f, 0.02610660f, -0.00880971f, 
    0.16183358f, -0.06221331f, -0.23664339f, -0.02058671f, -0.01028029f, 0.02431482f, 0.12528214f, 0.16376700f, 
    -0.11745466f, -0.05653000f, 0.07350260f, -0.05342643f, -0.29179916f, 0.15774840f, 0.22179520f, 0.06339557f, 
    0.10294800f, -0.00961045f, 0.09741069f, -0.03502060f, 0.06661212f, -0.01059563f, 0.04217268f, 0.01420581f, 
    -0.00407231f, -0.03382089f, -0.12970351f, 0.02294918f, 0.09491095f, 0.07754357f, 0.01881733f, -0.17931913f, 
    0.07598481f, 0.07192963f, -0.08468319f, -0.06992614f, 0.20084555f, -0.03371366f, 0.20143037f, 0.13965932f, 
    -0.02471805f, -0.01446130f, -0.10394531f, 0.18911271f, -0.02511280f, 0.13127187f, -0.07141842f, -0.01413376f, 
    0.20456457f, 0.01442601f, 0.06538769f, 0.10262199f, -0.03698572f, 0.13244213f, -0.20868044f, -0.06143640f, 
    0.01107759f, -0.10451937f, 0.07893734f, 0.13895553f, -0.00033541f, -0.06684035f, -0.14283906f, -0.16663760f, 
    0.15901470f, 0.04234426f, 0.11473639f, 0.00408469f, -0.14028306f, 0.00248582f, -0.10564437f, -0.09675056f, 
    -0.03052196f, 0.00200934f, -0.10512406f, 0.20595005f, -0.03424896f, 0.11050528f, 0.10462546f, 0.01586984f, 
    -0.03515906f, 0.16148010f, 0.11355184f, 0.11068359f, 0.21764949f, 0.00945538f, -0.09844933f, -0.20356719f, 
    0.12855747f, 0.03104916f, -0.17583635f, -0.08298659f, -0.03559249f, 0.00666170f, -0.04054870f, -0.07742987f, 
    -0.03029756f, 0.27032813f, -0.16367471f, -0.00373457f, -0.03757904f, 0.11434957f, -0.12893169f, 0.09669799f, 
    -0.09592921f, 0.14743903f, 0.09736144f, 0.25346413f, 0.11105272f, -0.00349754f, -0.01024036f, -0.06472324f, 
    0.05776603f, -0.02002749f, 0.05813629f, 0.00699334f, -0.04582476f, 0.06545348f, -0.09918755f, -0.15768255f, 
    0.05921372f, -0.15665695f, -0.07449919f, -0.02570274f, 0.16778147f, -0.03539215f, -0.06870005f, -0.03123346f, 
    0.09586064f, 0.03560753f, -0.03110087f, 0.02731100f, -0.15843539f, -0.10012719f, -0.12082335f, -0.16815558f, 
    -0.14837067f, -0.07807311f, -0.01436324f, -0.08347936f, 0.19099203f, 0.04265274f, 0.23625077f, 0.02619069f, 
    0.06151172f, 0.04873887f, -0.08334196f, -0.00169215f, 0.09020747f, 0.04711011f, 0.04642988f, 0.10333327f, 
    -0.00804678f, 0.15837456f, -0.06358816f, 0.05211685f, 0.00861969f, -0.02340906f, 0.08487782f, 0.23265362f, 
    0.09017610f, -0.11750823f, 0.07495926f, 0.04497978f, 0.11669600f, 0.05379881f, -0.10923625f, 0.04762475f, 
    0.25869399f, -0.20528528f, -0.10395983f, 0.08317714f, 0.08750892f, -0.05435211f, -0.14048934f, 0.11792444f, 
    0.07184587f, -0.06585442f, 0.12661292f, 0.08617963f, 0.30227762f, -0.19324508f, 0.15765248f, -0.16048789f, 
    0.11339635f, 0.01207444f, -0.02773600f, -0.02879572f, -0.04543021f, 0.08834024f, 0.04382891f, 0.25075147f, 
    0.03452272f, 0.30064538f, -0.07998779f, -0.10395050f, 0.00685380f, 0.13147610f, -0.09634782f, -0.03832656f, 
    0.13414764f, 0.15780060f, 0.02256278f, 0.00476987f, -0.09914656f, -0.23042704f, 0.21611802f, -0.17530584f, 
    -0.13644682f, -0.12041974f, 0.02114272f, 0.05190929f, -0.05829304f, -0.05105358f, -0.05982547f, -0.04490506f, 
    -0.16714756f, -0.02558487f, 0.22786796f, 0.15703119f, 0.04206891f, 0.01404762f, 0.13627736f, 0.12929501f, 
    -0.06297517f, -0.01525865f, 0.10456874f, 0.11242038f, -0.14883061f, 0.11094902f, -0.11893203f, -0.03808691f, 
    -0.01180463f, -0.01469543f, -0.08964720f, 0.01671813f, -0.04763040f, -0.04080489f, -0.02515975f, -0.09656850f, 
    -0.12417259f, 0.06937224f, -0.01757891f, -0.02962845f, 0.06443357f, 0.00972622f, 0.09282015f, 0.12139619f, 
    -0.11863697f, 0.14724049f, -0.14336854f, -0.04984812f, -0.14304593f, -0.06026288f, 0.06761242f, 0.11840064f, 
    0.02291145f, 0.09645043f, -0.08004352f, 0.07328301f, 0.09976467f, 0.03262118f, 0.15825322f, 0.12632810f, 
    0.04096445f, -0.03667681f, -0.10634204f, -0.00970521f, 0.05989976f, 0.00134003f, -0.05100534f, 0.05021717f, 
    0.03306878f, -0.05254631f, -0.05271512f, -0.13053049f, -0.24394809f, -0.15256359f, 0.11461424f, 0.16548853f, 
    0.02676548f, 0.22799323f, 0.09217916f, -0.08996072f, -0.01633103f, -0.02076505f, 0.01759177f, -0.12243407f, 
    -0.11491100f, -0.17818327f, 0.19554666f, -0.03569916f, 0.16838680f, -0.01173313f, 0.03487848f, 0.03102439f, 
    0.09639547f, -0.21947837f, -0.17907721f, -0.39445055f, 0.08568857f, -0.00441203f, -0.08082219f, 0.01515739f, 
    -0.03338257f, 0.00742334f, -0.11530849f, 0.08277521f, -0.14030248f, 0.08479435f, 0.09290203f, -0.00160667f, 
    0.15255877f, 0.01441181f, 0.03703650f, -0.01012903f, 0.13358946f, 0.06323269f, -0.19723347f, -0.00968705f, 
    0.08880839f, 0.06351651f, 0.11444171f, 0.06025894f, -0.24727628f, 0.24934457f, 0.18070497f, -0.30685055f, 
    -0.15491074f, 0.15808123f, -0.03545856f, -0.12890801f, 0.04021160f, -0.03828969f, 0.04711907f, -0.01426317f, 
    -0.01203030f, -0.01377428f, -0.04238154f, -0.04457061f, -0.00423131f, -0.03387937f, -0.04108066f, -0.04498259f, 
    0.11828355f, 0.05471681f, 0.04075911f, 0.06620482f, -0.02883464f, -0.18172802f, 0.08014631f, -0.10258815f, 
    0.05196429f, 0.05671357f, 0.04726784f, 0.11043939f, 0.12040152f, -0.00421253f, 0.10550030f, -0.01380180f, 
    0.06694528f, 0.01711710f, -0.09852732f, -0.12687618f, -0.02601697f, -0.08230098f, 0.01384929f, -0.00107014f, 
    -0.01674530f, 0.12932631f, -0.04555207f, 0.04860331f, 0.46041983f, -0.24776648f, 0.02206045f, -0.31108186f, 
    -0.10469102f, 0.04291330f, 0.05364426f, -0.13413122f, -0.05793421f, 0.04368806f, 0.14580475f, 0.02565223f, 
    0.06558833f, 0.13253322f, -0.03307081f, 0.02008866f, 0.00898192f, -0.11947246f, 0.04656638f, 0.12435196f, 
    0.01025230f, 0.03745617f, 0.00726107f, 0.00081683f, -0.03679517f, -0.19793013f, 0.23626687f, -0.28516153f, 
    -0.10487200f, -0.07686234f, 0.12843706f, 0.04731607f, -0.02834110f, 0.01403624f, -0.05018273f, 0.02881929f, 
    -0.21721025f, -0.15053098f, 0.32838738f, 0.03743814f, -0.18071140f, 0.01603622f, 0.03003452f, -0.00216097f, 
    -0.07829126f, 0.06232011f, -0.09010491f, -0.01410962f, -0.05686392f, 0.18419883f, -0.24565098f, -0.22351789f, 
    0.03246744f, 0.11672763f, 0.03483349f, 0.18763810f, 0.14919448f, 0.05533690f, 0.04444732f, -0.03418190f, 
    -0.29325250f, 0.41743314f, -0.09911839f, -0.38739243f, 0.15687768f, 0.11939947f, 0.03702198f, 0.07550168f, 
    0.02942494f, 0.02357308f, -0.05726137f, -0.03700113f, -0.06426970f, -0.03863793f, -0.03309405f, 0.21258661f, 
    -0.00391083f, -0.08381013f, -0.11884502f, 0.01627905f, 0.07331607f, -0.02117838f, -0.10437686f, 0.09856577f, 
    0.10864883f, -0.13042410f, 0.05079374f, 0.22286041f, -0.00809962f, -0.01321755f, 0.04683065f, -0.16957727f, 
    0.03207570f, 0.16594321f, -0.11582574f, 0.05879276f, 0.14425611f, -0.06807350f, 0.03362655f, 0.26036415f, 
    0.05106725f, 0.09748626f, 0.04655664f, 0.06683671f, 0.13078134f, 0.09831969f, 0.07301237f, 0.10184346f, 
    0.07733064f, -0.00090893f, 0.13589509f, 0.05627566f, 0.25267074f, 0.14824353f, -0.01438631f, 0.12883335f, 
    0.11903596f, 0.09158900f, -0.00963533f, -0.16218586f, -0.18651561f, -0.22696023f, -0.16037107f, 0.02954223f, 
    0.12139329f, -0.07228819f, 0.01434548f, 0.00060060f, 0.07899838f, 0.14364138f, 0.02679785f, -0.07914595f, 
    0.36872748f, -0.10036810f, 0.06299295f, 0.15908226f, 0.02586795f, 0.00447262f, -0.02835999f, 0.00383958f, 
    0.04626736f, 0.05111119f, 0.08101594f, 0.03806295f, -0.08529914f, 0.10685083f, 0.20256847f, -0.17881198f, 
    0.07934915f, 0.13926049f, 0.02069347f, -0.02447413f, 0.10958895f, 0.02649123f, 0.00217334f, 0.12905225f, 
    0.17509259f, -0.01610852f, 0.03162480f, -0.05063500f, -0.03815340f, -0.07807970f, 0.03759683f, -0.03764536f, 
    0.04856561f, 0.12438598f, -0.03780550f, 0.03471280f, -0.14489169f, -0.05285843f, 0.05176548f, -0.16511123f, 
    0.04535206f, 0.03599188f, -0.02980091f, 0.09254365f, -0.01655708f, 0.03621060f, 0.02780914f, 0.13845791f, 
    -0.16082115f, 0.04703438f, -0.04547771f, -0.00492471f, 0.14436431f, -0.02515955f, -0.02742859f, 0.12719746f, 
    0.09343120f, -0.04111961f, -0.05805736f, -0.03800613f, 0.16188973f, -0.26594397f, -0.04510452f, -0.12750857f, 
    -0.05237690f, 0.12817603f, 0.02777647f, -0.07828186f, -0.09195013f, -0.08150502f, 0.02594602f, -0.03222253f, 
    0.08816555f, -0.03934594f, -0.06175665f, 0.12291462f, -0.20797397f, -0.09919452f, 0.04418097f, -0.02091079f, 
    -0.02266328f, -0.07940390f, 0.06345966f, 0.10521895f, 0.05378957f, -0.03418364f, -0.11600839f, -0.09734750f, 
    -0.20335208f, 0.05669755f, -0.04494938f, -0.08088137f, -0.08771127f, 0.04281824f, -0.04375256f, 0.07427717f, 
    -0.27740911f, -0.00948227f, 0.17349906f, 0.08676828f, -0.05707150f, -0.15818554f, 0.00430738f, 0.08844822f, 
    -0.04769169f, 0.00404262f, 0.07698122f, 0.07557188f, -0.21754241f, 0.05633903f, 0.03208570f, 0.03093076f, 
    0.12560014f, 0.08849214f, 0.07832815f, -0.04360841f, -0.02049961f, 0.01637212f, 0.08890148f, 0.10048256f, 
    -0.23646100f, 0.10544953f, -0.07649236f, -0.20029053f, 0.12045239f, 0.00454747f, 0.13077664f, -0.04838429f, 
    -0.01912384f, -0.00045121f, 0.06557170f, 0.02902929f, 0.17468722f, 0.28555086f, 0.11652055f, 0.36227238f, 
    -0.04315359f, 0.06760301f, 0.04193978f, 0.05262971f, 0.06862990f, 0.07552978f, 0.03666969f, -0.00398420f, 
    0.05918002f, -0.02006016f, 0.19346139f, 0.02079817f, -0.03929673f, 0.04846050f, -0.02336738f, -0.04436124f, 
    -0.09990383f, -0.04758584f, 0.05060514f, -0.05130931f, -0.09566985f, 0.22630598f, 0.27486297f, -0.05349585f, 
    0.05971150f, 0.13984254f, -0.06988037f, 0.12252546f, -0.02049149f, -0.05159476f, 0.08125432f, 0.16405642f, 
    -0.14417407f, -0.13624124f, 0.06233029f, -0.02624145f, 0.02936140f, 0.10640117f, -0.06187337f, -0.01106679f, 
    0.01555693f, -0.09192376f, -0.21711017f, -0.14461063f, -0.56400943f, 0.02978232f, 0.02433232f, 0.03655231f, 
    0.14523773f, -0.05780696f, -0.06256891f, 0.09138101f, 0.06230430f, 0.09729647f, -0.02067490f, 0.08321118f, 
    -0.03136457f, -0.12806560f, -0.18292579f, -0.02452047f, -0.04849624f, -0.02115145f, -0.21854292f, -0.14370401f, 
    0.12612839f, 0.06960463f, -0.06844449f, -0.06189340f, -0.28681439f, 0.03801075f, -0.03574770f, -0.03192519f, 
    -0.04194565f, -0.14244983f, 0.03167031f, -0.08445314f, 0.14298739f, -0.05662349f, 0.09668890f, 0.03184672f, 
    0.02154571f, 0.12709434f, 0.04019861f, -0.06038388f, 0.12321319f, 0.09627523f, 0.05983966f, -0.02130195f, 
    0.02903886f, 0.21575890f, -0.04810337f, 0.04183906f, 0.13595973f, -0.09755001f, 0.16969760f, -0.01552803f, 
    0.26832551f, 0.01656868f, 0.09814040f, 0.12291991f, 0.08243025f, 0.00502933f, -0.12151508f, 0.08522380f, 
    0.18116711f, -0.01271832f, -0.00061987f, 0.21021956f, 0.04105593f, 0.07298479f, 0.00213015f, 0.07683412f, 
    0.10892800f, -0.06782361f, 0.01748889f, 0.00904737f, 0.24718212f, -0.43246639f, -0.12134887f, -0.14080234f, 
    0.03155672f, 0.10348930f, 0.02962906f, -0.08804600f, -0.08495136f, 0.06907409f, -0.00457220f, 0.19145243f, 
    0.21029392f, 0.05603430f, 0.18411891f, 0.07206399f, -0.06565210f, 0.02904448f, 0.08853423f, 0.03864887f, 
    0.07479309f, -0.04812669f, 0.00205808f, 0.11832157f, -0.15696710f, -0.08209281f, 0.10891318f, -0.05423474f, 
    -0.10098053f, -0.00302381f, 0.00407272f, 0.17332102f, 0.01426001f, -0.05326615f, 0.09945723f, -0.09150296f, 
    -0.52340341f, -0.37391949f, 0.07025956f, 0.07605070f, -0.03610364f, -0.00580574f, 0.09256033f, 0.03518118f, 
    -0.09883943f, -0.01534056f, 0.13672844f, 0.15659840f, -0.17667316f, 0.17947116f, 0.02719838f, 0.04082973f, 
    0.09599423f, 0.09462631f, 0.10556179f, -0.03479675f, 0.01425578f, -0.04064377f, 0.01452046f, -0.08612513f, 
    -0.13242881f, 0.10633726f, -0.06758459f, -0.12291074f, -0.02900290f, -0.01684950f, 0.26523405f, 0.13201238f, 
    0.02362522f, 0.11514878f, -0.03360883f, -0.09093376f, -0.33965412f, 0.06196543f, -0.02847061f, 0.12955067f, 
    -0.03330271f, -0.11073328f, -0.00002171f, -0.00539174f, 0.11291018f, -0.04305205f, 0.18841347f, 0.21013142f, 
    0.23448727f, -0.17543750f, -0.16911837f, 0.12251562f, -0.05749205f, -0.04129023f, -0.14474690f, 0.04016054f, 
    0.09793971f, 0.07012761f, -0.05784087f, 0.05379742f, -0.17736979f, 0.07553952f, 0.15774184f, 0.17261547f, 
    0.15821087f, 0.00721107f, -0.07967048f, -0.04276143f, 0.03873734f, 0.06689928f, 0.04999131f, 0.02584136f, 
    0.13924633f, -0.07683080f, 0.09480800f, 0.16798656f, 0.21094388f, 0.10098852f, -0.09600551f, -0.05050482f, 
    -0.00426307f, -0.14163035f, -0.11048573f, -0.30063507f, -0.04620995f, -0.06517924f, -0.02690242f, -0.07025427f, 
    0.09368622f, -0.02845454f, -0.03383647f, 0.10129101f, -0.02496744f, 0.02206977f, 0.03889221f, 0.06434134f, 
    0.07663094f, -0.13656314f, 0.14308986f, -0.11664949f, -0.08794514f, 0.02018056f, -0.06666803f, -0.03963527f, 
    0.01041336f, 0.05695417f, -0.01985763f, -0.02271724f, -0.10793933f, 0.26069829f, -0.05814312f, 0.15873230f, 
    0.08292792f, -0.02329325f, -0.11366672f, 0.01157366f, 0.14027104f, 0.07183715f, 0.10959139f, 0.01300303f, 
    0.31140292f, -0.03918885f, -0.00414000f, 0.00467970f, -0.02329081f, 0.12279417f, -0.00232039f, -0.14166142f, 
    -0.00664071f, 0.11886308f, -0.07430848f, 0.11186220f, -0.02819192f, 0.01951171f, 0.00217704f, 0.28033584f, 
    0.03507525f, 0.03139204f, 0.15739620f, -0.06892417f, 0.01471760f, -0.01413320f, 0.06340924f, -0.08907418f, 
    0.13786337f, 0.07172377f, -0.11516420f, -0.12992193f, -0.03278477f, 0.10641681f, 0.00198422f, 0.05806869f, 
    0.05685934f, 0.18418014f, -0.09504831f, 0.08898146f, -0.10958943f, -0.03197507f, -0.06726611f, -0.22636519f, 
    0.08695953f, -0.15276361f, 0.02992560f, -0.04625160f, -0.00845772f, 0.04435763f, -0.02538825f, 0.07358356f, 
    -0.27130276f, 0.16595948f, 0.38108808f, 0.23102185f, 0.14170638f, -0.01511438f, -0.07864688f, -0.01776457f, 
    0.13190491f, 0.11902091f, -0.04904862f, 0.08012276f, 0.00092950f, -0.03576439f, 0.02226058f, -0.10937449f, 
    0.03908152f, -0.07840395f, 0.00714385f, -0.02656797f, -0.03349746f, -0.02332672f, 0.06388996f, -0.01597284f, 
    0.03591910f, 0.09044424f, 0.05513138f, 0.05052634f, 0.06402325f, -0.00666643f, 0.08051354f, 0.16678262f, 
    -0.08875385f, -0.01847902f, 0.06327721f, 0.11631154f, 0.26043946f, 0.38241833f, -0.13141042f, -0.18115909f, 
    0.11922816f, 0.12064554f, 0.03158420f, -0.03731109f, -0.04050111f, -0.12907316f, 0.08937635f, -0.02658230f, 
    -0.21553907f, 0.01697017f, 0.04980235f, 0.06318505f, 0.05341503f, -0.02850738f, 0.17766589f, 0.07840145f, 
    0.05073119f, 0.23191154f, -0.01624438f, -0.00628343f, -0.22690564f, -0.17297424f, -0.01998444f, 0.00633920f, 
    -0.06242548f, 0.04764104f, -0.02630362f, 0.05206281f, 0.06914558f, -0.02184287f, 0.12007739f, 0.04870516f, 
    0.04126416f, 0.25242797f, 0.02381604f, -0.32488391f, -0.01163696f, -0.08654164f, -0.20031638f, -0.11192663f, 
    0.13622043f, -0.11297733f, -0.08488231f, -0.03063659f, -0.10775188f, 0.01629238f, 0.09261739f, 0.22538061f, 
    -0.20533194f, -0.11330736f, 0.18437672f, -0.16072839f, 0.07013784f, -0.01315186f, 0.03637703f, -0.02166388f, 
    0.10648137f, -0.19889237f, 0.22694340f, 0.03317384f, 0.03860396f, -0.20485854f, 0.01003323f, -0.03042804f, 
    0.08089906f, -0.13166872f, -0.05876554f, -0.06341477f, -0.06534922f, 0.05070278f, -0.01638317f, 0.03666845f, 
    0.01005967f, 0.06240306f, -0.04154477f, -0.03873855f, 0.04932532f, 0.01019230f, 0.06898303f, 0.11251219f, 
    -0.00926194f, 0.17187962f, 0.08154143f, 0.06235016f, 0.18913808f, -0.12136073f, 0.04303253f, 0.02156224f, 
    0.11871994f, 0.06143744f, 0.08313353f, 0.11505944f, 0.28040290f, 0.07887284f, -0.18239488f, -0.16135970f, 
    -0.13665403f, -0.03490264f, 0.08758651f, -0.02902065f, 0.07486417f, 0.12184170f, 0.19495578f, 0.08780357f, 
    -0.18107331f, -0.10214502f, -0.02358214f, 0.03882652f, 0.02531380f, 0.08189646f, -0.04478539f, 0.04147682f, 
    -0.19401844f, 0.04274832f, 0.05917820f, 0.07902304f, -0.19445392f, -0.15069631f, 0.01416444f, -0.02055760f, 
    -0.08502936f, -0.08158208f, 0.00204269f, 0.03181854f, 0.09576109f, 0.18008342f, -0.09586950f, -0.02567546f, 
    0.12746948f, -0.11478905f, -0.03325408f, -0.08938032f, 0.09346140f, 0.01873737f, -0.19930513f, -0.05362100f, 
    0.02156445f, 0.01696498f, -0.01163779f, -0.00882969f, 0.49267980f, 0.26618570f, 0.01759173f, 0.01450481f, 
    -0.04195873f, 0.00037751f, 0.03733703f, 0.01832218f, 0.00472133f, 0.11035748f, 0.03741696f, 0.16572295f, 
    -0.09483150f, 0.11296122f, -0.23031859f, -0.05375950f, -0.01453539f, 0.17169845f, -0.05295061f, 0.04519472f, 
    0.13777187f, 0.14043428f, -0.02928248f, 0.01084495f, -0.13111590f, 0.11090635f, 0.14026159f, 0.03000274f, 
    0.06638918f, -0.11792620f, 0.00063133f, 0.04113386f, -0.03087418f, -0.00346167f, 0.04261619f, 0.09020561f, 
    0.35841104f, 0.05983371f, 0.01400145f, 0.05470838f, 0.01283580f, 0.00448782f, 0.00493841f, 0.08700889f, 
    0.04990259f, -0.00404876f, 0.09338184f, -0.04636224f, -0.04043267f, -0.19071443f, -0.14058103f, 0.04398668f, 
    -0.06630328f, 0.01657498f, -0.01709998f, -0.01095659f, -0.06598932f, 0.01813506f, -0.03035432f, -0.03047654f, 
    0.03502924f, -0.03402315f, 0.08303341f, 0.17300786f, 0.13733461f, 0.01453017f, 0.07253870f, 0.07038785f, 
    0.09479190f, -0.02527711f, -0.06798337f, -0.13637246f, 0.13968828f, -0.12989292f, 0.21259449f, 0.09015719f, 
    0.12371004f, 0.05416808f, -0.01112884f, 0.06353041f, 0.09385633f, 0.05156591f, 0.13036826f, 0.15839252f, 
    -0.08188770f, -0.02781669f, 0.01041909f, 0.13610984f, -0.07518128f, -0.04756286f, -0.03119976f, 0.17573190f, 
    0.02082708f, 0.04641763f, -0.07778922f, 0.07047371f, 0.22587588f, -0.06627793f, -0.08506925f, 0.09819341f, 
    0.03425211f, 0.21387139f, 0.06987374f, -0.05417736f, 0.02303723f, 0.06504121f, 0.05117308f, 0.00957412f, 
    -0.06224535f, 0.17520751f, 0.07249294f, -0.03583301f, 0.04771525f, -0.07365228f, 0.10728811f, 0.00133518f, 
    0.14330980f, -0.00951407f, -0.10830024f, -0.22012401f, 0.07261080f, 0.05102257f, -0.12612583f, -0.03718873f, 
    0.08439438f, -0.00164473f, -0.03684744f, -0.01394441f, -0.01842720f, 0.01204403f, 0.06181461f, -0.04458261f, 
    -0.27642950f, -0.00648962f, -0.03732934f, -0.08268677f, 0.01335012f, 0.02081295f, -0.03430026f, 0.03820862f, 
    0.02424466f, 0.03563840f, 0.03121657f, 0.12646751f, 0.00001023f, 0.12766635f, -0.03802312f, 0.13035338f, 
    0.08245455f, -0.20837449f, -0.00043132f, -0.02606262f, 0.02408506f, 0.01168518f, 0.11634160f, -0.00369938f, 
    -0.03270389f, -0.34539083f, 0.15380716f, 0.13983153f, -0.02821727f, -0.01183614f, -0.01462062f, 0.06950618f, 
    0.01950952f, 0.11137997f, -0.04004898f, 0.07221349f, -0.03144535f, 0.17732821f, -0.10086308f, -0.04065464f, 
    -0.19134387f, -0.12955180f, 0.10781305f, -0.09480228f, 0.07602911f, 0.04297524f, 0.09443858f, -0.00574883f, 
    0.29200476f, 0.06784833f, 0.06872530f, -0.13610850f, -0.11627934f, 0.07481863f, -0.02979369f, 0.17188662f, 
    0.05939547f, 0.03184634f, 0.02323191f, 0.09026787f, -0.07702870f, 0.11240027f, -0.01483952f, 0.09194044f, 
    0.15860237f, 0.04797236f, 0.06008936f, 0.06110170f, 0.07079691f, 0.12997954f, -0.00750704f, 0.13196564f, 
    -0.21046719f, -0.02462740f, 0.05345771f, -0.14887193f, 0.22635975f, 0.21163790f, -0.13447121f, 0.06415670f, 
    0.01907954f, 0.12997374f, -0.00339359f, 0.02816235f, -0.14383262f, 0.05345537f, 0.21248451f, -0.04067819f, 
    0.17292422f, -0.02279668f, 0.03023603f, 0.06534820f, 0.20754147f, -0.15628448f, 0.00146521f, 0.09913041f, 
    0.17312008f, 0.26770821f, -0.22290722f, -0.18481654f, 0.09832685f, 0.23365353f, -0.02552196f, -0.00077737f, 
    0.01354794f, 0.08262756f, -0.08956941f, 0.02456641f, 0.52558970f, -0.05710179f, -0.07168528f, -0.17599171f, 
    -0.04313488f, -0.04816012f, -0.02272836f, 0.03267511f, -0.00420251f, -0.01639642f, -0.09096172f, 0.10929624f, 
    0.39263204f, -0.14779510f, -0.06425519f, 0.15864202f, -0.03623861f, 0.09462637f, -0.05453222f, 0.07475229f, 
    0.14533418f, 0.08067262f, 0.04232312f, 0.06256627f, -0.07767683f, -0.15146175f, -0.14253512f, -0.16312440f, 
    0.17522684f, -0.02142421f, 0.04626026f, 0.01841075f, -0.03717900f, 0.07279962f, 0.05880007f, 0.01777546f, 
    -0.37530264f, 0.02905697f, -0.04230629f, -0.02494706f, 0.14208835f, -0.07413830f, -0.06777176f, 0.18989521f, 
    0.12764694f, -0.19298503f, -0.05075827f, 0.13701506f, -0.02420212f, 0.05709907f, -0.11772607f, -0.33704454f, 
    0.21617490f, -0.01457899f, -0.02909487f, -0.12564796f, 0.04064503f, -0.09023222f, 0.00631004f, -0.12320701f, 
    -0.04661736f, -0.11531711f, 0.00568394f, -0.00217501f, -0.09855759f, 0.00893753f, 0.01614319f, -0.06806275f, 
    0.11068583f, -0.07718549f, 0.03192002f, -0.09088472f, 0.20065117f, -0.02053375f, -0.10524601f, 0.00767701f, 
    -0.14236049f, -0.08512864f, -0.00038988f, 0.06707505f, 0.09119496f, -0.07427277f, 0.02110266f, -0.07769857f, 
    -0.15342286f, 0.02336466f, -0.18882512f, -0.13623546f, -0.00298586f, 0.03646704f, 0.04351445f, -0.09744043f, 
    -0.04729740f, 0.02525355f, 0.03750174f, -0.12059283f, 0.15751125f, -0.12322892f, 0.11912690f, 0.30897969f, 
    0.03931422f, -0.03666689f, 0.02300389f, -0.11677656f, 0.05907910f, 0.06772475f, 0.03277180f, 0.03433461f, 
    0.25385079f, 0.01386967f, -0.00444390f, 0.00971481f, 0.08220985f, 0.20276064f, 0.03212531f, 0.10313611f, 
    -0.01156796f, 0.04734027f, 0.06982392f, -0.02825012f, 0.01058070f, 0.13194983f, -0.09472620f, 0.02928677f, 
    0.03313916f, 0.02631410f, 0.09236932f, -0.14599244f, 0.16033497f, 0.14395429f, 0.12942488f, 0.07504293f, 
    0.15182328f, 0.10867036f, -0.19636756f, 0.12417477f, 0.06925482f, 0.03065609f, 0.02440661f, -0.05247633f, 
    0.05452969f, 0.05707446f, 0.00650400f, -0.05858676f, -0.05166474f, -0.01016444f, 0.04450518f, 0.06493509f, 
    -0.00564331f, 0.05286305f, -0.00146874f, -0.07783633f, 0.13422032f, 0.06451266f, -0.07580315f, 0.07497472f, 
    0.03535672f, -0.18716782f, 0.16603822f, 0.39226916f, 0.03509968f, 0.05693999f, 0.03643382f, 0.02996305f, 
    0.03862707f, 0.06142430f, 0.00605735f, -0.04762181f, -0.03793341f, 0.26879218f, 0.04376654f, 0.17874649f, 
    0.10580789f, 0.15269366f, -0.17967315f, -0.01794498f, 0.10184318f, 0.02138770f, 0.08220865f, 0.05655844f, 
    0.13471256f, -0.09903720f, 0.05135472f, -0.06064629f, 0.02109154f, 0.04809561f, -0.04021554f, 0.00338621f, 
    -0.05719650f, -0.03113448f, 0.07392541f, 0.05700177f, -0.28668845f, 0.05522754f, -0.00939653f, -0.07465892f, 
    0.10888623f, 0.09895759f, -0.03757633f, 0.01716058f, 0.02966080f, -0.08415613f, -0.07828955f, -0.19778502f, 
    -0.33887231f, -0.09483631f, 0.13034293f, -0.09545681f, 0.00774147f, -0.03103686f, 0.07035077f, 0.21186197f, 
    -0.08706734f, 0.20014296f, -0.07287133f, 0.15521584f, -0.22090110f, 0.01886054f, -0.04258807f, -0.35630938f, 
    0.15063873f, -0.01547134f, 0.05855949f, 0.06808676f, -0.03621412f, 0.00781954f, 0.00103956f, 0.06280672f, 
    0.07483108f, 0.13953598f, -0.12065743f, -0.11947400f, 0.02095129f, -0.01934900f, -0.23139468f, -0.05907976f, 
    0.06493717f, 0.11239868f, 0.01180702f, -0.08059165f, -0.16583115f, -0.00373902f, -0.05933174f, 0.07562211f, 
    -0.14473739f, -0.08365744f, 0.06034536f, -0.09904727f, -0.01156391f, 0.01520451f, 0.00697086f, 0.06295671f, 
    0.07747551f, 0.02956215f, 0.10289774f, 0.09672844f, 0.00184854f, -0.11237475f, -0.01157140f, -0.08098505f, 
    -0.04649001f, -0.17062828f, 0.06253483f, 0.03910647f, -0.26755282f, 0.08872321f, -0.05751095f, 0.03976693f, 
    0.14960986f, 0.05850103f, 0.01476412f, -0.01679262f, -0.01099320f, -0.03595707f, -0.08581139f, 0.05838218f, 
    0.06009751f, 0.07194434f, 0.13677850f, -0.00980552f, 0.01794212f, 0.02278252f, -0.01893113f, -0.00766277f, 
    0.06424028f, -0.01059031f, -0.07748318f, 0.05560859f, 0.25644392f, -0.16407445f, -0.11894640f, 0.10773570f, 
    -0.00703360f, -0.04102162f, 0.00819203f, -0.03723608f, 0.17757562f, 0.04420196f, 0.12387235f, 0.07667644f, 
    -0.15665898f, 0.02566378f, -0.05979211f, -0.00326738f, 0.13697287f, 0.05071655f, 0.04047596f, 0.05365948f, 
    -0.03185998f, 0.05117450f, 0.02704882f, 0.03781034f, -0.08912955f, -0.11625974f, -0.12183586f, -0.01250549f, 
    -0.03092953f, 0.04675123f, 0.05470072f, 0.06848335f, 0.11190908f, 0.08379474f, -0.05113328f, 0.02224419f, 
    -0.03222103f, -0.20427860f, -0.12593703f, 0.03241994f, -0.01342810f, 0.10620222f, -0.07742376f, -0.09433269f, 
    0.08127958f, 0.01672935f, 0.05255168f, -0.02276498f, 0.21414401f, 0.16562988f, -0.09314726f, 0.03049595f, 
    0.03926199f, 0.05154728f, -0.08525678f, 0.05249214f, 0.05319206f, 0.02765524f, 0.04597625f, -0.01105262f, 
    -0.09502240f, 0.26855257f, -0.07671252f, -0.01774862f, -0.01457595f, 0.01859189f, 0.05772559f, -0.02208701f, 
    0.10349753f, 0.12910809f, -0.01439715f, 0.13533731f, 0.03092230f, 0.08746932f, -0.21187049f, 0.08904829f, 
    0.05576275f, -0.00044350f, -0.01342575f, 0.00611272f, -0.03299832f, 0.09892931f, -0.00694466f, -0.05799112f, 
    0.19096051f, 0.05237394f, 0.04089260f, 0.24643849f, -0.02399330f, -0.11429662f, 0.08628400f, -0.04169971f, 
    0.01210739f, -0.03267292f, 0.15782712f, 0.03167558f, -0.43148735f, -0.25240642f, -0.13710052f, 0.09946247f, 
    -0.06682970f, 0.03994146f, -0.03396457f, -0.11679149f, -0.06841334f, -0.10506712f, 0.00268974f, -0.08295464f, 
    -0.22079559f, -0.05657485f, -0.04298730f, 0.01390438f, 0.05280611f, -0.08322497f, 0.11001150f, 0.09409415f, 
    0.04531113f, -0.02942354f, -0.05739352f, -0.10370492f, 0.20329843f, 0.02907197f, 0.22743072f, 0.01924662f, 
    -0.04931544f, -0.00945548f, -0.04975944f, 0.01897399f, 0.17366220f, -0.05787006f, 0.16984893f, 0.03716625f, 
    -0.00672318f, 0.07308665f, -0.01260129f, 0.04971199f, -0.04153920f, 0.09775568f, -0.00383623f, 0.01957038f, 
    0.09472076f, -0.00114211f, -0.05128457f, 0.06983120f, 0.19094673f, -0.14227527f, 0.04642247f, 0.26980552f, 
    -0.07203101f, 0.18063855f, 0.10464266f, -0.07489600f, 0.15293483f, 0.10410482f, 0.00953677f, 0.07636450f, 
    -0.17282952f, 0.07053252f, 0.02451795f, -0.13074441f, 0.03445773f, -0.12436271f, 0.06948106f, -0.00336211f, 
    0.14925388f, -0.02352057f, 0.03004451f, -0.12734795f, -0.11308957f, 0.07884162f, -0.13561051f, -0.09132440f, 
    0.04071049f, 0.01289125f, 0.01096312f, 0.04200886f, 0.02219642f, -0.00078519f, 0.07994608f, -0.00042758f, 
    0.24581541f, 0.08575939f, 0.17011856f, 0.03137530f, 0.15057936f, 0.03484491f, 0.00388188f, 0.07908238f, 
    0.14020805f, 0.08107787f, 0.03672715f, 0.09560687f, -0.02486484f, 0.16128418f, 0.19983283f, -0.22014576f, 
    -0.01070079f, 0.15827221f, 0.02847355f, -0.01839859f, -0.03540954f, -0.03756684f, 0.03747208f, 0.02484442f, 
    -0.24191169f, -0.06348123f, 0.06982851f, 0.10101327f, -0.11450092f, -0.11982342f, -0.00740063f, 0.01086652f, 
    0.10339290f, 0.01229392f, -0.03195046f, 0.00169999f, -0.11217067f, -0.00654038f, 0.08261794f, -0.03712906f, 
    -0.05996978f, 0.09507404f, 0.01121751f, 0.02241909f, -0.02351541f, -0.09415282f, 0.09276420f, -0.04045179f, 
    -0.13333441f, -0.04669422f, 0.13408838f, -0.31574830f, 0.10942413f, 0.04120945f, 0.02476610f, -0.03102885f, 
    0.04404238f, -0.00587667f, -0.02450680f, -0.01026632f, 0.26191419f, 0.21247350f, 0.11885539f, -0.08557790f, 
    0.06855083f, -0.00363289f, 0.15136103f, 0.05637047f, -0.07023043f, 0.04129651f, 0.02892750f, -0.01087528f, 
    0.12361843f, -0.07171441f, -0.20230187f, -0.31242451f, 0.07024392f, -0.04346295f, 0.06597179f, 0.08944714f, 
    0.02433265f, 0.04412101f, 0.15315816f, -0.00718485f, -0.04011591f, -0.14589286f, 0.17098457f, -0.10374197f, 
    0.01733984f, -0.08805325f, 0.18562675f, -0.01602752f, -0.01099274f, -0.01780670f, 0.01138133f, 0.03928358f, 
    0.19272134f, 0.19366698f, 0.06441326f, -0.10924850f, -0.03861434f, 0.07838560f, -0.02965632f, -0.02263150f, 
    0.00130574f, -0.00956615f, -0.09856112f, 0.04947916f, 0.30093828f, -0.01645929f, -0.00376085f, -0.00345714f, 
    -0.04073073f, 0.08228314f, -0.01151899f, 0.10615327f, 0.01882207f, 0.07515985f, 0.04671961f, 0.26139742f, 
    0.24411252f, 0.07109220f, -0.03896394f, 0.05623380f, -0.02645300f, 0.10387100f, -0.19736712f, -0.14394845f, 
    0.01216995f, -0.05897355f, 0.06410389f, -0.04645469f, 0.23262171f, 0.02381482f, 0.02747136f, 0.15723167f, 
    -0.05860149f, 0.00070885f, -0.02030647f, -0.05491617f, 0.00581473f, 0.05131804f, -0.09023128f, -0.02873619f, 
    -0.11697692f, -0.05335195f, 0.08530436f, 0.12811323f, -0.00399831f, -0.03247578f, 0.08457442f, -0.02038668f, 
    0.07682276f, -0.04061780f, -0.04567817f, 0.08780324f, 0.16567189f, 0.09744031f, -0.07852325f, -0.16181251f, 
    0.12329890f, 0.08315112f, 0.01127096f, 0.11208230f, -0.11325215f, 0.04814053f, 0.03930138f, -0.06971189f, 
    0.01997894f, 0.02650799f, -0.00710522f, -0.04868038f, 0.06863073f, 0.12830326f, 0.05047782f, -0.02315708f, 
    -0.03297550f, 0.19215579f, 0.05612069f, -0.08408460f, -0.05493872f, -0.16696642f, -0.00064153f, 0.06652483f, 
    0.03278374f, -0.02322934f, 0.01802445f, -0.02810106f, 0.12681031f, -0.04053371f, -0.02459709f, -0.00249691f, 
    0.15213199f, -0.19719350f, -0.19691923f, -0.04616133f, -0.03412212f, -0.04936675f, -0.10269184f, -0.06058991f, 
    -0.04359523f, -0.06108849f, 0.24607192f, 0.10499454f, -0.01525965f, 0.23154473f, 0.32412547f, -0.05324474f, 
    0.17089930f, 0.14161782f, 0.15862404f, -0.07050510f, -0.11404391f, 0.10351615f, -0.10979738f, -0.22495459f, 
    0.27689889f, -0.25583136f, -0.03757026f, 0.03957038f, 0.10040036f, -0.11998663f, -0.05466070f, -0.02374032f, 
    0.16388896f, -0.17388326f, -0.00878299f, 0.15313473f, -0.01519217f, 0.01530384f, 0.30402407f, -0.03445945f, 
    0.07594474f, 0.11545979f, -0.01091977f, 0.10602628f, 0.02639714f, -0.08347634f, 0.06839164f, 0.06261329f, 
    -0.15620129f, 0.11188658f, 0.14753912f, -0.02533966f, -0.01867685f, -0.10022502f, 0.22829330f, 0.10374638f, 
    0.12481475f, -0.10137089f, -0.21025851f, 0.06855512f, -0.11000531f, 0.06245216f, -0.10918552f, -0.15567437f, 
    0.03269874f, 0.06576844f, -0.00346726f, -0.21046805f, -0.13243616f, -0.16048591f, 0.12409683f, 0.04835383f, 
    -0.02002444f, 0.16796646f, 0.13287069f, 0.05871405f, 0.06538340f, -0.14543879f, -0.00725951f, 0.10499004f, 
    -0.07584979f, -0.06322415f, 0.13897556f, -0.11686092f, 0.13538346f, 0.12806411f, -0.02654896f, -0.16808666f, 
    -0.00068333f, -0.03205136f, 0.14613780f, -0.00422975f, 0.01120226f, -0.03040528f, 0.06810495f, -0.03780494f, 
    0.11217944f, -0.06469671f, -0.01443914f, -0.10086136f, -0.05625540f, 0.00898999f, -0.11426542f, -0.04078032f, 
    -0.13336146f, -0.02653318f, -0.18174964f, 0.04326708f, 0.28238228f, 0.32704809f, 0.17379604f, -0.11469659f, 
    0.10273181f, -0.01792960f, -0.04207795f, 0.19052352f, -0.04025395f, 0.08270664f, -0.07260973f, -0.06137547f, 
    0.01905228f, 0.19913395f, 0.06944126f, -0.20810769f, 0.09450465f, 0.12592444f, -0.09704015f, -0.17133796f, 
    -0.01178022f, -0.02426870f, 0.02234247f, 0.10332936f, 0.01710408f, -0.07547303f, -0.24613102f, 0.11869423f, 
    -0.05569891f, -0.07476278f, -0.13918400f, -0.11745375f, -0.16494684f, 0.06225956f, -0.06546187f, -0.17565265f, 
    0.05566730f, 0.09704157f, -0.26961401f, -0.04758517f, -0.14714156f, -0.02860043f, 0.23020348f, -0.12326462f, 
    -0.12194450f, 0.06848516f, 0.23358437f, 0.08621769f, 0.03468691f, 0.13412218f, 0.09006966f, -0.02136056f, 
    0.07526677f, -0.05492776f, -0.21150130f, -0.11228336f, -0.10260141f, 0.10029965f, 0.07661603f, 0.15450318f, 
    0.09160121f, -0.02353986f, -0.09590042f, 0.10484806f, -0.07030496f, 0.14140743f, 0.04806529f, 0.04287136f, 
    -0.11090633f, 0.19986285f, 0.09104335f, 0.28117019f, 0.05425948f, -0.05438013f, -0.04851309f, -0.01992059f, 
    -0.03118491f, -0.08130824f, -0.03292508f, 0.00554530f, 0.08024536f, 0.09857046f, -0.11248864f, -0.11717445f, 
    0.08158322f, 0.10930928f, -0.08615369f, 0.11176500f, 0.18064012f, -0.07013266f, 0.01890235f, 0.02297894f, 
    0.05260714f, -0.04908949f, -0.08738016f, 0.06231209f, 0.25733516f, -0.10870139f, -0.13361867f, -0.15837269f, 
    -0.09784357f, -0.02540541f, 0.08119156f, -0.08282559f, 0.08485728f, 0.11750013f, 0.13970892f, 0.05688846f, 
    -0.21860752f, -0.00498094f, -0.10957934f, 0.05648265f, -0.03304344f, 0.02275455f, -0.07557654f, 0.08590351f, 
    -0.15525676f, -0.04890972f, -0.01864152f, -0.06065429f, -0.15306732f, -0.00176231f, -0.11538634f, 0.04918431f, 
    -0.03820342f, -0.04056779f, 0.04066505f, 0.05723923f, 0.11940765f, 0.17995818f, -0.03606339f, 0.03163753f, 
    0.10144923f, -0.10315706f, -0.09919006f, 0.03879346f, 0.15637670f, 0.13402076f, -0.21017061f, -0.07312968f, 
    0.06863572f, -0.07134449f, 0.05210293f, -0.02817962f, 0.46231234f, 0.27212200f, 0.10541555f, 0.07933202f, 
    0.02718096f, -0.06483297f, -0.07941078f, 0.00862603f, 0.09202896f, 0.03705243f, 0.04792843f, 0.10479929f, 
    0.06567433f, -0.08074431f, -0.29389739f, -0.09807508f, 0.01877388f, 0.14212024f, 0.00897154f, 0.10553304f, 
    0.02660802f, 0.01272667f, 0.05176926f, 0.07245455f, -0.10371996f, 0.15485398f, 0.01927081f, 0.02766339f, 
    0.02927374f, -0.00967293f, -0.02491527f, -0.01955344f, 0.03878372f, -0.03805910f, 0.15151301f, -0.04361105f, 
    0.48530951f, 0.04753518f, -0.00087837f, 0.03063036f, -0.07526336f, -0.03595170f, 0.08078945f, -0.02995714f, 
    0.03114620f, -0.03929892f, 0.01048247f, -0.02694519f, -0.18195854f, -0.32802400f, -0.05567890f, 0.18901835f, 
    0.09225924f, -0.00301783f, -0.02219851f, 0.03220494f, 0.03384661f, 0.02845949f, -0.11083513f, -0.05225106f, 
    -0.03961610f, -0.17919528f, -0.07019903f, 0.10131781f, 0.06955155f, 0.06503811f, -0.04618696f, -0.05072612f, 
    -0.03082941f, -0.01011478f, -0.06567181f, -0.10733559f, 0.16328451f, 0.11150175f, 0.15616854f, 0.06385287f, 
    0.00042240f, 0.04349225f, -0.03699846f, -0.00572636f, 0.04196186f, -0.07190354f, 0.06359747f, -0.02566920f, 
    0.05885189f, -0.09133273f, -0.07539117f, 0.26180613f, -0.01632550f, 0.06044884f, -0.05806593f, 0.04153839f, 
    0.05465003f, -0.16670710f, -0.03893058f, 0.03555945f, 0.13493609f, 0.02743724f, 0.07707714f, -0.00320592f, 
    -0.00013237f, 0.21217398f, 0.02396541f, -0.11327358f, -0.07600874f, 0.01195997f, 0.13984044f, -0.00259762f, 
    -0.10471169f, 0.10059077f, -0.08602839f, -0.05298385f, 0.01788601f, -0.13604179f, 0.16184002f, -0.04339331f, 
    0.04025047f, -0.06140314f, -0.07940209f, -0.01229804f, 0.05996547f, -0.01812280f, -0.12214892f, 0.03707935f, 
    0.02838157f, -0.01286466f, 0.03155920f, -0.00382123f, -0.04736229f, 0.00529780f, 0.07714932f, -0.11390886f, 
    0.17123799f, 0.08557866f, -0.08642845f, 0.07198600f, 0.10778712f, -0.00198159f, -0.11780048f, -0.04814072f, 
    0.01214682f, 0.03023420f, -0.08284803f, 0.11124557f, -0.15842250f, 0.08556342f, 0.10734455f, -0.25183821f, 
    -0.04920091f, -0.02111334f, -0.08215843f, -0.06829647f, 0.10966855f, -0.05273707f, 0.21698397f, 0.03942570f, 
    -0.19098170f, -0.06535538f, -0.12436888f, -0.17456795f, -0.01328611f, -0.02150599f, -0.01352499f, 0.09114756f, 
    0.02604595f, 0.00298726f, -0.01694855f, 0.01899932f, -0.38798121f, -0.09835717f, -0.20199557f, 0.08211032f, 
    0.02621001f, 0.10003699f, -0.04926426f, 0.11270844f, 0.23333806f, 0.03334602f, 0.02138079f, -0.08592618f, 
    -0.01557954f, -0.16022271f, -0.03350999f, -0.12811984f, 0.01818476f, 0.07767636f, -0.10251152f, 0.02399849f, 
    0.02636367f, 0.11918809f, 0.01299182f, 0.00602513f, 0.50366175f, -0.02384401f, 0.16052443f, -0.30577269f, 
    0.04338540f, -0.01211086f, 0.07534862f, 0.03027444f, 0.00027865f, 0.03206035f, 0.12180758f, 0.13003913f, 
    0.12267122f, -0.25469244f, -0.01137253f, -0.08270103f, 0.09717180f, 0.01850707f, -0.02481220f, 0.11174876f, 
    0.13757420f, -0.06665996f, 0.12883507f, -0.00230229f, -0.25169313f, 0.01342191f, 0.25745699f, -0.41447514f, 
    -0.08157486f, 0.02892371f, 0.02227682f, 0.01432569f, -0.06676584f, -0.05350078f, 0.00825208f, 0.03270505f, 
    0.10171208f, -0.07633241f, 0.28716388f, -0.04260436f, -0.19595093f, 0.06040197f, 0.10448048f, 0.17933509f, 
    -0.17010960f, -0.06768954f, 0.08585614f, 0.01839086f, -0.15390709f, -0.00088301f, -0.08123011f, -0.22218621f, 
    0.15335663f, 0.05899961f, 0.08449016f, 0.11776208f, 0.11384906f, 0.04812159f, 0.00535647f, -0.06479096f, 
    -0.09486843f, 0.15767105f, -0.01762610f, -0.10953692f, 0.16936360f, 0.06093533f, 0.07681663f, 0.15638453f, 
    -0.01873614f, -0.02992230f, 0.02563928f, 0.03856488f, 0.17240649f, 0.10060561f, 0.04929122f, 0.09258482f, 
    -0.00172551f, -0.06808736f, -0.06343826f, -0.07236252f, 0.03137626f, 0.04883287f, 0.02687284f, 0.09334043f, 
    0.14140268f, -0.06357256f, -0.00610241f, 0.20578924f, -0.02508954f, -0.11364783f, -0.00902743f, -0.04936399f, 
    0.14443511f, 0.01509150f, -0.00339653f, 0.03986060f, -0.12388311f, 0.02363315f, 0.15204270f, -0.01029444f, 
    -0.05534871f, 0.04806451f, 0.01948663f, -0.07201467f, 0.02669131f, 0.02362521f, 0.10411208f, 0.07283106f, 
    0.02043127f, -0.22292933f, 0.22899126f, 0.07453268f, 0.15787163f, 0.04845968f, 0.07150635f, 0.03347855f, 
    0.01084118f, -0.03020759f, -0.01463746f, -0.19168429f, -0.21898480f, -0.35785213f, -0.21244718f, -0.00044260f, 
    0.00494731f, -0.06478142f, -0.00135195f, 0.06091851f, 0.03212567f, 0.06539584f, 0.12655134f, 0.00962016f, 
    -0.03237490f, 0.03580750f, 0.00159866f, 0.02474589f, 0.00779875f, -0.01566194f, -0.04438179f, -0.03494792f, 
    0.01601952f, -0.05944308f, 0.02859467f, 0.06103614f, 0.04544735f, -0.04757789f, -0.04464349f, -0.06898499f, 
    -0.07313924f, 0.04309641f, -0.03895251f, -0.03808128f, -0.03702813f, -0.03607840f, 0.00008659f, 0.03492837f, 
    -0.02400435f, -0.03329112f, 0.04258067f, -0.07631531f, 0.04535777f, 0.03771578f, 0.04859635f, 0.04659047f, 
    0.02160773f, -0.03109224f, 0.05142950f, -0.07182371f, 0.01485444f, 0.04691118f, 0.05083821f, -0.06589586f, 
    -0.07668261f, -0.05229879f, 0.03919824f, 0.03237204f, -0.01931544f, 0.05209525f, -0.01454358f, -0.05601970f, 
    0.06734070f, 0.01968060f, 0.00871614f, 0.01785279f, -0.05820962f, -0.02712867f, -0.01966125f, -0.07839318f, 
    -0.05767590f, 0.01568874f, 0.04968640f, 0.01060221f, 0.00406852f, -0.04873504f, 0.05351899f, -0.06324784f, 
    0.00983995f, -0.01860175f, -0.07263403f, -0.00442985f, -0.01711878f, -0.07444807f, 0.03932032f, 0.06673298f, 
    -0.03868956f, 0.06026858f, -0.02466898f, -0.04338653f, -0.02162176f, -0.05966164f, -0.02507124f, -0.04820035f, 
    0.04987696f, 0.05569355f, 0.03959373f, 0.01882038f, 0.02650990f, -0.01113082f, 0.01265645f, 0.05714048f, 
    0.01995940f, -0.01038265f, 0.01813127f, -0.02362255f, -0.04482486f, -0.06780129f, -0.01052409f, -0.02002007f, 
    -0.00086181f, -0.03785203f, -0.04817068f, -0.02478349f, -0.07810755f, -0.07398412f, 0.03800973f, 0.02989277f, 
    -0.06899104f, -0.06189255f, 0.04744271f, 0.02794053f, -0.02261049f, -0.04787142f, -0.05952730f, 0.05163525f, 
    0.01575861f, -0.07296438f, 0.02028796f, -0.00154243f, -0.06744723f, -0.02401556f, 0.00668271f, -0.06525916f, 
    0.02744358f, 0.01807787f, -0.07406234f, -0.02375615f, 0.05044807f, 0.05094546f, -0.04183348f, -0.04849875f, 
    0.03447060f, -0.01402227f, 0.01328178f, -0.03279020f, -0.00214635f, 0.01577522f, -0.06059894f, 0.02176338f, 
    -0.00855823f, -0.00878919f, 0.01977802f, -0.04316782f, -0.07265800f, -0.05758104f, -0.07342596f, 0.01237379f, 
    0.06139775f, -0.00611819f, -0.02522719f, -0.07653347f, -0.00212497f, -0.03397008f, -0.01451131f, -0.04621167f, 
    -0.01188116f, 0.04671881f, -0.06100616f, -0.04567458f, -0.06911901f, 0.06012295f, -0.00864227f, -0.05850367f, 
    0.01210327f, -0.06172008f, -0.05447987f, -0.01274365f, -0.05215485f, -0.01888442f, -0.01046770f, 0.01588827f, 
    0.05797476f, -0.03676192f, -0.06539237f, 0.00381032f, -0.02127920f, 0.04293115f, -0.05485070f, -0.01131335f, 
    0.00999309f, -0.06089595f, 0.05437862f, 0.01842425f, 0.04604261f, -0.04796788f, 0.04434950f, -0.05414029f, 
    -0.00537645f, -0.02069890f, 0.06027547f, 0.04053935f, -0.04662586f, 0.03239923f, -0.05884556f, -0.06191860f, 
    0.00669054f, 0.13554114f, 0.27802604f, -0.01535085f, -0.09298111f, -0.02222762f, 0.04172083f, 0.00825372f, 
    -0.02621427f, -0.04285934f, -0.12143748f, 0.04589157f, -0.19143872f, 0.07448459f, -0.07940662f, -0.01424256f, 
    -0.03147398f, -0.09533996f, 0.01115988f, 0.05499896f, 0.02425940f, 0.00645196f, -0.00244501f, 0.07796116f, 
    -0.16538015f, 0.09957828f, -0.07512403f, 0.06459306f, 0.02495557f, -0.09250897f, -0.06419874f, 0.00947943f, 
    0.13340035f, 0.06946363f, -0.07726340f, 0.03465976f, -0.11642805f, 0.14050151f, -0.17661946f, 0.22998969f, 
    -0.03676520f, -0.06344886f, 0.04112662f, 0.03038287f, -0.06318048f, 0.04148792f, -0.01905117f, -0.03483893f, 
    0.07913090f, -0.11458946f, -0.02548047f, -0.33996660f, 0.26245412f, 0.04575329f, 0.00208863f, 0.07345913f, 
    0.05832763f, 0.14317329f, 0.01791648f, 0.02920427f, 0.09791045f, 0.14026389f, 0.03162667f, 0.03409418f, 
    -0.04341228f, -0.00971124f, 0.11689898f, 0.05362111f, 0.01100116f, 0.02426201f, 0.08959661f, 0.06622339f, 
    -0.01415216f, -0.03201839f, -0.14148588f, -0.09123097f, 0.18403170f, 0.18651770f, -0.09664229f, -0.02790964f, 
    0.12196460f, 0.06539961f, -0.09656262f, -0.01364461f, 0.09319055f, -0.15652232f, 0.07939576f, -0.00542663f, 
    -0.03073695f, -0.20046997f, 0.11715844f, 0.02597872f, -0.08923053f, 0.01560080f, 0.00519775f, 0.08652560f, 
    0.11141185f, 0.25410858f, 0.16041209f, -0.09544018f, -0.06492135f, 0.14749458f, 0.13536322f, -0.00931024f, 
    0.00337786f, -0.04989370f, -0.01971728f, 0.00925869f, 0.15348889f, -0.11649219f, -0.12884837f, -0.20907529f, 
    0.03329578f, 0.08429544f, 0.06596799f, 0.01487023f, 0.04954945f, 0.02176409f, 0.06123068f, 0.15139559f, 
    0.19075306f, -0.06051281f, -0.03013556f, 0.13770829f, 0.04747776f, 0.11669970f, 0.00725174f, -0.07792147f, 
    0.10360241f, 0.03184785f, 0.02400769f, -0.04685134f, 0.03581898f, -0.09571505f, 0.22178973f, 0.06011692f, 
    -0.18352391f, -0.04995101f, -0.14515626f, -0.07895227f, 0.03664370f, 0.03750466f, 0.16344988f, -0.05153780f, 
    -0.05082491f, -0.02446320f, 0.09739994f, -0.10061666f, 0.13366134f, -0.06960595f, 0.02289791f, 0.05558355f, 
    -0.00526718f, -0.18752776f, -0.17928529f, -0.00870282f, 0.11281703f, -0.10010356f, -0.00847708f, -0.01239426f, 
    0.04005156f, 0.01066650f, 0.01482166f, 0.02678443f, -0.09915119f, -0.13198048f, -0.04396732f, 0.03718369f, 
    0.01729064f, 0.01350327f, 0.07711698f, -0.09703044f, 0.01650609f, -0.09772784f, 0.02943686f, -0.03501993f, 
    -0.00477158f, -0.00635978f, -0.23131140f, -0.12452457f, 0.30267850f, -0.13003679f, -0.05685386f, 0.05775125f, 
    -0.15285662f, -0.05887089f, -0.04001165f, -0.02563078f, 0.04212824f, -0.07497128f, 0.03682708f, -0.10354280f, 
    -0.05542051f, -0.04974031f, 0.12657718f, 0.00622190f, -0.07323089f, 0.04458223f, 0.02537542f, 0.05363914f, 
    -0.09832665f, -0.07121175f, -0.09922098f, 0.04802999f, 0.16598926f, -0.11871737f, 0.02076312f, 0.32320362f, 
    -0.01040618f, 0.10448514f, -0.08866800f, 0.05237316f, -0.00539669f, 0.15032783f, -0.05265631f, -0.01104018f, 
    0.16438279f, 0.03808714f, -0.01929643f, -0.00011576f, 0.09608039f, 0.10749521f, -0.02471652f, 0.08501297f, 
    -0.01148888f, -0.01309121f, 0.00797982f, 0.03659451f, 0.09188967f, -0.15345280f, -0.01013847f, 0.12904413f, 
    0.04171467f, 0.05979934f, 0.09659087f, -0.06506511f, 0.03902932f, 0.09657694f, -0.00627537f, 0.04892802f, 
    0.06790715f, -0.01744295f, -0.28776702f, 0.01349885f, -0.02781002f, 0.02198558f, -0.00362773f, -0.14125259f, 
    -0.02297709f, 0.03710106f, 0.10247837f, -0.02888252f, -0.13647036f, -0.01115425f, 0.02992873f, 0.07373834f, 
    0.03763815f, 0.01553599f, -0.13189368f, 0.07279459f, 0.09312875f, 0.00318369f, -0.01093567f, 0.01019568f, 
    -0.23160006f, 0.15077816f, 0.23381661f, 0.17765035f, 0.02091933f, -0.08579781f, 0.04313904f, -0.00634502f, 
    -0.04362392f, -0.00660264f, 0.02925968f, -0.00403627f, 0.27938294f, -0.09111916f, -0.10111103f, 0.16179806f, 
    0.04501109f, 0.01217903f, -0.09148372f, 0.06808992f, 0.00714055f, 0.05197689f, 0.04111255f, 0.00287394f, 
    -0.00803294f, -0.01650448f, 0.11190353f, 0.16281152f, -0.03567277f, -0.03400257f, 0.03999014f, 0.06951254f, 
    -0.00398369f, -0.00465874f, 0.13137452f, -0.02741604f, -0.41004837f, -0.09968701f, -0.24947123f, -0.10296182f, 
    0.03908893f, 0.09246942f, -0.03787896f, -0.07795561f, -0.06533179f, -0.06863301f, 0.03890643f, 0.00582342f, 
    -0.25592870f, -0.02779760f, 0.10233717f, -0.05693043f, -0.00986014f, 0.01559435f, 0.15393078f, 0.16689061f, 
    -0.05720085f, 0.03380662f, 0.05207904f, 0.03781126f, 0.07987556f, 0.09380885f, 0.03579245f, -0.02846109f, 
    0.02488693f, 0.03926446f, -0.09797031f, -0.00907142f, 0.09710523f, -0.02694963f, -0.02876677f, 0.05493333f, 
    0.05540935f, 0.18524940f, 0.06789292f, -0.13995025f, -0.02345741f, 0.00353930f, -0.09614176f, -0.09280556f, 
    0.05613137f, -0.02575384f, 0.03269160f, -0.07418690f, 0.24150839f, -0.17008410f, 0.12619862f, 0.33080101f, 
    -0.12775734f, 0.12319647f, 0.05300206f, 0.09137461f, 0.09618032f, -0.02294736f, 0.11660805f, -0.03224828f, 
    0.14896691f, 0.10447953f, 0.08828668f, 0.06582160f, -0.02876260f, -0.09154286f, 0.05227476f, -0.07852293f, 
    0.14368737f, -0.03708822f, 0.15289308f, 0.12287880f, -0.24687065f, 0.01797973f, 0.05315027f, -0.00737333f, 
    0.14732261f, 0.00007060f, 0.05085804f, 0.01364358f, -0.08276269f, -0.01945556f, 0.00399257f, 0.06068451f, 
    -0.02742935f, -0.04697305f, 0.03112561f, -0.03276678f, 0.01861054f, 0.00054749f, -0.06226147f, 0.04022761f, 
    0.02443370f, -0.06525425f, -0.03970411f, 0.02173793f, -0.03585356f, 0.02090230f, 0.05640566f, 0.00734893f, 
    -0.02122287f, -0.01103543f, 0.06249511f, 0.04460267f, 0.01042720f, 0.02145103f, 0.00474558f, -0.06156557f, 
    -0.05532704f, -0.05472873f, -0.01897367f, -0.03312851f, 0.03513404f, 0.00262237f, -0.02010324f, -0.05648892f, 
    -0.02142366f, -0.05493069f, 0.02895892f, 0.01408319f, -0.05301034f, -0.01782069f, 0.04123529f, 0.05638994f, 
    0.02132889f, -0.01114425f, -0.03119210f, -0.00613381f, 0.03165415f, -0.04454893f, -0.03867793f, 0.01396282f, 
    -0.01438508f, 0.04751070f, -0.03156266f, -0.05827526f, -0.05532996f, -0.06098503f, -0.05767949f, 0.04573314f, 
    -0.04670831f, -0.03575381f, -0.05808628f, -0.03429919f, 0.01026314f, -0.01269293f, -0.03713601f, 0.00825486f, 
    -0.02223870f, -0.03711183f, -0.01006663f, -0.04347661f, -0.06196588f, -0.07758705f, 0.04016164f, -0.01607887f, 
    -0.07411767f, -0.01546618f, 0.01353689f, -0.04590161f, 0.02259331f, 0.06104489f, -0.07698401f, -0.03856272f, 
    -0.00282083f, 0.05219010f, 0.01915980f, -0.08109545f, 0.00617151f, -0.00517880f, 0.02594768f, -0.04973273f, 
    0.05407704f, -0.05519682f, -0.01288205f, -0.01054216f, -0.05780673f, 0.06451733f, -0.00005081f, -0.07303280f, 
    -0.00480517f, -0.05869963f, 0.05608208f, 0.04093975f, -0.06135092f, 0.04241090f, 0.04785357f, 0.00821080f, 
    0.06334122f, 0.00506731f, 0.03338417f, -0.01367175f, -0.00970776f, -0.06426073f, 0.04796743f, -0.05401907f, 
    0.05688120f, 0.01208806f, 0.05698299f, -0.07166705f, -0.03001326f, -0.00657631f, 0.01854228f, 0.02196007f, 
    -0.01448583f, -0.01071642f, -0.03435873f, -0.05239140f, -0.01513515f, -0.07466398f, 0.04730495f, -0.05248105f, 
    0.01449137f, 0.01769273f, 0.00397657f, -0.01864413f, -0.02051778f, -0.05689399f, -0.00363059f, -0.04656895f, 
    0.01324207f, 0.06140967f, -0.02981954f, -0.07514921f, 0.04601369f, 0.04961360f, -0.00489280f, -0.04685640f, 
    0.01595102f, 0.00203220f, 0.00821658f, -0.01734019f, -0.01947344f, 0.05220863f, -0.00171602f, -0.02369785f, 
    0.00640648f, -0.06512757f, 0.05796106f, -0.04419667f, -0.02705912f, 0.04845218f, 0.05549853f, 0.04600674f, 
    -0.06335521f, 0.03423968f, -0.06269797f, -0.00015995f, -0.04770447f, 0.05847000f, 0.01123686f, 0.06511530f, 
    -0.01586116f, -0.05662989f, 0.00460524f, -0.05534883f, -0.00254620f, 0.05973683f, 0.06440864f, 0.00354853f, 
    -0.07031845f, -0.05245250f, 0.00641702f, -0.02010867f, 0.02096228f, -0.04702254f, 0.03112036f, 0.05045133f, 
    -0.02883684f, -0.06912785f, -0.07198349f, -0.07055133f, -0.00614806f, 0.05048881f, -0.01776674f, -0.00148556f, 
    0.01171234f, -0.05719433f, 0.03199242f, -0.07149427f, -0.05901578f, -0.05414854f, -0.02093027f, -0.02772624f, 
    0.03065457f, -0.01107676f, -0.02663928f, -0.01807512f, -0.02446947f, -0.00994198f, -0.07092475f, -0.05383436f, 
    0.06582025f, -0.00457803f, -0.04006445f, -0.06620691f, -0.06254119f, -0.06637333f, 0.02188903f, -0.04418270f, 
    -0.04261213f, 0.00222993f, 0.04237512f, -0.06415075f, -0.06548961f, -0.04855565f, -0.02558896f, -0.04604184f, 
    -0.05211464f, -0.02706379f, -0.05238423f, -0.01893949f, 0.02825972f, -0.04696528f, -0.03630126f, -0.00739080f, 
    -0.01308681f, 0.03326284f, -0.04073106f, -0.04507225f, 0.05925988f, -0.01380664f, 0.01245138f, 0.06766799f, 
    -0.04180794f, -0.02780404f, 0.06712935f, 0.06123507f, 0.06101559f, -0.04653034f, -0.00161222f, -0.07125849f, 
    -0.04908393f, 0.00685799f, 0.01419820f, 0.03333738f, 0.01703167f, 0.07211881f, -0.02789337f, 0.01726898f, 
    0.06546171f, -0.07076097f, 0.05354593f, -0.02792284f, -0.06360259f, 0.00139811f, 0.04686012f, -0.06577057f, 
    0.03727181f, -0.01169862f, 0.04813835f, -0.03581642f, 0.06853639f, 0.02081540f, 0.00036944f, 0.05082634f, 
    -0.06883437f, 0.06245581f, -0.03850982f, -0.05026829f, -0.06094313f, 0.04058481f, -0.01169921f, 0.05413669f, 
    0.01500698f, -0.05871695f, 0.02675768f, 0.01838707f, 0.01133477f, -0.05888695f, 0.02802768f, -0.06806040f, 
    0.03258491f, -0.02767075f, 0.01529191f, -0.04245757f, 0.00142346f, -0.00779452f, -0.01017521f, 0.06325160f, 
    0.01645388f, 0.03733399f, 0.02909791f, -0.02832872f, -0.06811379f, -0.05016643f, -0.03391292f, -0.06397621f, 
    0.01896467f, -0.04421718f, 0.02221279f, -0.02708859f, 0.00960670f, -0.04084100f, -0.03093466f, -0.06632888f, 
    -0.00695899f, -0.04272326f, -0.05837014f, 0.00492053f, -0.03811452f, -0.01621411f, -0.02140572f, -0.03837850f, 
    -0.01604048f, 0.01787885f, -0.00495316f, 0.02394420f, 0.05004388f, -0.01227408f, -0.01348581f, -0.03266677f, 
    -0.00247440f, 0.05075232f, -0.00755960f, 0.02105557f, -0.07019417f, -0.01400345f, -0.00217400f, -0.02524786f, 
    -0.00836916f, -0.06512937f, 0.01549585f, 0.05826349f, -0.07158674f, 0.05242692f, -0.03354544f, -0.03400290f, 
    0.02408023f, -0.06414508f, 0.01068696f, -0.00233673f, 0.04086057f, -0.03225094f, -0.06556419f, 0.04875563f, 
    -0.01290607f, 0.03892422f, 0.06395537f, 0.06581619f, -0.05445855f, 0.03735752f, -0.03332444f, 0.05326984f, 
    0.02229769f, -0.05823725f, -0.06846629f, 0.01148406f, 0.01555076f, -0.00879486f, -0.00613131f, 0.02919952f, 
    -0.06280011f, 0.01012346f, -0.01236558f, 0.04319313f, 0.01451855f, 0.01408007f, 0.03198894f, -0.05038422f, 
    -0.00223472f, -0.06404985f, -0.03830484f, -0.06620722f, 0.00118123f, -0.01086007f, 0.05884954f, -0.06078070f, 
    -0.40561366f, -0.25457215f, -0.42796895f, -0.05094795f, 0.14287432f, 0.07356305f, 0.12814714f, 0.01448988f, 
    0.08606702f, 0.00664277f, -0.02881949f, 0.02485874f, 0.00237920f, -0.12917441f, 0.00949601f, 0.02753751f, 
    -0.01851127f, 0.07648213f, -0.02538585f, -0.07712074f, 0.14002031f, 0.00976857f, -0.01630750f, -0.01317674f, 
    -0.06982025f, -0.02626652f, 0.11302201f, -0.07278708f, 0.18479465f, 0.08518495f, 0.05100049f, 0.07835454f, 
    -0.04735593f, -0.03424853f, 0.10477643f, 0.07387241f, 0.24742408f, -0.07788276f, 0.12356114f, -0.13973466f, 
    -0.11610515f, -0.03336218f, -0.06572254f, 0.09384298f, -0.04814691f, 0.00645358f, -0.06527242f, 0.08353525f, 
    0.39303792f, -0.05293997f, -0.10523877f, 0.13306360f, -0.02644481f, -0.10782193f, 0.06850892f, -0.04540901f, 
    -0.05087758f, -0.00316135f, 0.11404885f, 0.01593371f, -0.07744037f, -0.24628961f, 0.33705759f, 0.04608113f, 
    -0.03371851f, 0.16125897f, -0.09601616f, 0.00298702f, 0.09023824f, 0.16922875f, 0.04818500f, 0.23838817f, 
    -0.10428386f, 0.30827865f, -0.02749969f, -0.09605804f, 0.20494388f, 0.21777785f, 0.14648548f, 0.09289090f, 
    -0.04157089f, 0.06608342f, 0.01294679f, -0.10383552f, -0.12582079f, -0.11258858f, 0.25991625f, -0.01229561f, 
    -0.01033372f, 0.08060744f, 0.07828663f, 0.17625894f, 0.03164605f, 0.11967199f, -0.07469920f, -0.01769131f, 
    -0.32925096f, -0.35721287f, -0.09485433f, 0.03295789f, 0.06756844f, 0.08029252f, 0.03129727f, -0.09775823f, 
    0.06221589f, 0.05178365f, -0.02624154f, -0.03075553f, -0.11202405f, -0.10730914f, -0.06842924f, -0.01839649f, 
    -0.06539660f, -0.00485429f, 0.11098228f, 0.16559157f, -0.01960883f, 0.13463995f, 0.01242519f, -0.14310481f, 
    0.10468233f, 0.08151408f, -0.01829788f, 0.04686152f, 0.00595117f, 0.09056658f, -0.11438374f, 0.00600586f, 
    0.00145469f, -0.05028570f, 0.05656959f, 0.05312921f, -0.22747940f, -0.22257590f, -0.09596332f, -0.22117014f, 
    0.10241839f, 0.05911892f, -0.05037365f, 0.15317476f, -0.07828965f, -0.08243079f, 0.04233732f, 0.07276656f, 
    0.01143563f, -0.04754355f, -0.06250911f, 0.20220758f, 0.00088486f, 0.15259841f, 0.16965929f, 0.09643458f, 
    0.01078071f, 0.08281689f, 0.03064490f, 0.07141978f, 0.27733153f, 0.00143230f, 0.01994995f, -0.09514283f, 
    0.12754208f, 0.17707509f, -0.09020185f, -0.02389316f, -0.08531602f, -0.13233218f, -0.03897778f, -0.08585287f, 
    0.03818478f, 0.28439924f, 0.07827525f, 0.05059065f, 0.13241804f, 0.04309499f, 0.07369328f, -0.00088145f, 
    -0.02773898f, 0.04668647f, 0.11111114f, -0.06163253f, 0.10216934f, 0.16141990f, 0.00982238f, -0.00693304f, 
    -0.05043152f, -0.01281481f, 0.01047987f, 0.00190825f, -0.12832375f, -0.03786997f, -0.05745278f, -0.09307551f, 
    0.54244709f, 0.15145169f, -0.00658193f, 0.28388098f, -0.01569420f, -0.01785182f, -0.03994430f, 0.05006259f, 
    0.01174770f, -0.03580304f, -0.01426563f, -0.12059271f, 0.38385397f, 0.04390116f, 0.06736305f, -0.17704515f, 
    0.11524110f, 0.04350536f, 0.03289903f, 0.07897954f, 0.01876501f, 0.00405989f, 0.06511077f, 0.03383582f, 
    0.00370613f, 0.00795362f, -0.05400402f, 0.08394606f, -0.09903647f, -0.18652843f, -0.02642890f, 0.12670548f, 
    -0.03694036f, -0.08088188f, -0.01330175f, -0.03864347f, -0.21071599f, 0.16243179f, 0.12222936f, 0.25604934f, 
    0.03734158f, 0.14120430f, -0.02229208f, 0.06450142f, 0.05874294f, 0.09106640f, 0.05955344f, 0.02152843f, 
    -0.09973819f, 0.06496663f, 0.01096101f, -0.16448091f, 0.07672868f, 0.09545219f, -0.09226100f, 0.08650671f, 
    0.03930941f, 0.01945424f, -0.04759106f, 0.02396131f, 0.32772672f, 0.20681493f, -0.03395815f, -0.11901701f, 
    0.11868469f, -0.19309489f, 0.05290523f, -0.00634175f, -0.06353831f, 0.01811920f, -0.04054358f, 0.01551282f, 
    0.01169294f, -0.14840952f, 0.01798767f, -0.16060975f, -0.01964782f, 0.02925459f, -0.12340570f, -0.00948033f, 
    0.01634756f, -0.17102055f, 0.10710010f, -0.03171747f, 0.16053818f, 0.25524598f, -0.02462907f, -0.22872177f, 
    0.11929692f, -0.02591114f, 0.04659736f, -0.09066485f, -0.04385906f, 0.04955882f, 0.12200797f, 0.05194566f, 
    0.68346691f, 0.17862014f, -0.13978428f, -0.15200758f, -0.10870354f, -0.05827025f, 0.06023314f, 0.04608779f, 
    -0.06282479f, -0.11730327f, -0.03331202f, 0.04897939f, 0.02728230f, 0.05881130f, 0.15551227f, 0.17098644f, 
    0.17877775f, 0.07801217f, -0.07043084f, 0.15780728f, -0.00136764f, 0.11555852f, -0.01145594f, 0.14768584f, 
    0.02020751f, -0.12296569f, 0.02138023f, -0.04687397f, 0.05535561f, 0.10065190f, -0.05187785f, -0.06481848f, 
    -0.13273412f, 0.02714500f, -0.00165690f, 0.04551717f, 0.32869473f, 0.19972835f, 0.07679767f, 0.19095065f, 
    -0.09670577f, -0.07488586f, -0.04574131f, -0.11182840f, -0.09380227f, 0.04249296f, -0.15401530f, -0.11700422f, 
    0.05631971f, 0.06661070f, 0.05534369f, 0.13604584f, -0.10557330f, -0.06036522f, 0.01976355f, -0.18549615f, 
    0.02996277f, -0.12292466f, 0.01735781f, -0.14943326f, -0.08583233f, -0.04926302f, 0.04002372f, -0.07941026f, 
    -0.17481825f, 0.04987762f, -0.01284867f, 0.01556227f, -0.10149365f, -0.00404663f, 0.06666049f, -0.03688336f, 
    -0.03426944f, 0.02308234f, -0.04155365f, -0.15799384f, 0.06438282f, -0.15603925f, 0.02373047f, -0.04655977f, 
    -0.04160741f, 0.10196913f, 0.06631918f, 0.04555243f, 0.06056729f, 0.05057633f, 0.06402551f, 0.13314180f, 
    0.03200340f, 0.11690846f, -0.00231948f, -0.14593418f, 0.07335490f, -0.02907267f, -0.01031295f, -0.05200674f, 
    -0.12345015f, 0.27819350f, 0.15591894f, 0.08682116f, -0.10769589f, -0.02807570f, -0.04428291f, -0.11315098f, 
    -0.03469162f, 0.05007651f, -0.00602513f, 0.04591019f, -0.03956987f, -0.03317015f, -0.17241855f, 0.17006798f, 
    -0.08440379f, -0.08934030f, -0.07132015f, 0.07495498f, -0.00944447f, -0.03859650f, 0.15315042f, 0.02506404f, 
    -0.37499416f, 0.03575178f, 0.03706761f, -0.09751051f, -0.04192338f, 0.02358049f, 0.01724096f, 0.11147142f, 
    -0.02333613f, 0.14403360f, -0.04016839f, -0.06421716f, -0.06745078f, 0.02807710f, -0.13304211f, -0.01055324f, 
    -0.03736058f, -0.10696578f, 0.10506194f, -0.06239110f, -0.03010156f, 0.02714506f, 0.00911354f, 0.03528947f, 
    0.11984304f, -0.01389294f, -0.04088231f, -0.14226732f, 0.16155499f, 0.14008425f, -0.08692044f, 0.11773205f, 
    0.05935735f, 0.07588739f, -0.02327088f, -0.05758712f, 0.15744764f, 0.25316638f, -0.02446192f, 0.22974433f, 
    0.08943486f, 0.05325842f, 0.04062577f, 0.10924240f, -0.01940115f, 0.14384013f, -0.09442181f, 0.00099447f, 
    0.07600863f, -0.36503556f, -0.12797311f, -0.06468797f, 0.12558772f, 0.19526380f, -0.05475630f, 0.04286962f, 
    0.07908153f, 0.18746786f, -0.04423121f, 0.21101139f, -0.19048516f, 0.15660538f, 0.28147769f, 0.05027431f, 
    0.06971340f, -0.05935512f, -0.08222126f, 0.10674419f, 0.11379692f, -0.05822538f, 0.02806218f, 0.04357645f, 
    0.26378652f, 0.17998984f, -0.00212358f, -0.15271008f, 0.12723480f, 0.25728020f, -0.05672470f, -0.05418456f, 
    -0.05619607f, -0.00249219f, -0.00748777f, -0.02084853f, 0.19515164f, -0.12853995f, -0.14415750f, -0.15334617f, 
    -0.12089578f, -0.11681731f, 0.03300464f, -0.10670388f, -0.02019863f, -0.06012278f, -0.05830518f, 0.00723474f, 
    0.30266240f, -0.07859731f, 0.04714872f, 0.20456672f, 0.00416270f, -0.00029231f, -0.04732591f, 0.06644154f, 
    0.15898836f, -0.00785828f, -0.10182320f, -0.10178950f, -0.00520565f, 0.13428023f, 0.10695029f, -0.08083392f, 
    0.10877381f, 0.02041838f, -0.03193878f, -0.12546170f, 0.03179310f, -0.00851796f, 0.06650253f, 0.04335386f, 
    -0.07683587f, -0.10525452f, 0.12018533f, 0.10233682f, 0.07398653f, -0.04309626f, -0.16595331f, 0.04728121f, 
    0.11176857f, -0.04249267f, -0.17203937f, 0.10527521f, -0.20310676f, 0.02797202f, -0.15051849f, -0.22437464f, 
    0.09723569f, 0.04274732f, 0.03891971f, 0.02490373f, -0.06618259f, 0.01656609f, 0.12963861f, -0.01800342f, 
    0.02002059f, 0.05621553f, 0.01523758f, -0.01678503f, -0.16940553f, 0.01146528f, 0.13569477f, -0.07815265f, 
    0.17366657f, -0.07600027f, -0.11734005f, -0.03201662f, 0.23039556f, -0.14959320f, -0.03449338f, -0.05462037f, 
    -0.14918821f, -0.09612204f, -0.03496841f, 0.00048586f, 0.02314058f, 0.01822924f, 0.13396876f, 0.02057208f, 
    0.02742710f, 0.02672392f, 0.04996554f, 0.04863791f, -0.01211768f, -0.00475622f, 0.04944881f, -0.01240715f, 
    0.01640525f, 0.03879389f, -0.07171197f, 0.00462521f, 0.00385183f, 0.02690807f, 0.01452843f, 0.00171969f, 
    -0.06561884f, -0.05047351f, -0.00506825f, 0.04126343f, -0.05949194f, -0.07794857f, -0.08056863f, 0.00645592f, 
    -0.01752068f, -0.07902294f, 0.00174988f, 0.01347373f, 0.06049824f, 0.01574864f, -0.07098833f, 0.04905729f, 
    -0.03509677f, -0.07026219f, -0.07502888f, -0.05624791f, -0.07220925f, -0.06834503f, -0.01189158f, -0.03584035f, 
    -0.07217579f, 0.05851403f, -0.02618055f, 0.05905598f, 0.03989000f, 0.05877803f, 0.05228867f, -0.07080014f, 
    0.04215706f, -0.02569106f, 0.05315663f, -0.01936205f, 0.03191676f, 0.05343390f, -0.03945730f, -0.01325843f, 
    -0.06919438f, -0.02532089f, -0.01215542f, -0.00255080f, 0.01045494f, 0.05776450f, -0.01747016f, -0.07791080f, 
    0.04733505f, -0.02338051f, -0.04952464f, 0.06340290f, 0.02318299f, 0.05145359f, -0.05069445f, 0.02315731f, 
    -0.02112680f, 0.03822908f, -0.07255680f, 0.04853820f, 0.02504317f, 0.01342804f, -0.04961557f, -0.06006435f, 
    -0.04199658f, -0.06122324f, 0.04815203f, -0.07766363f, -0.08033489f, -0.03717264f, 0.04602212f, -0.08024092f, 
    0.04828898f, 0.02254449f, -0.01532975f, -0.04765894f, -0.05098202f, -0.00558020f, -0.05194723f, -0.04499562f, 
    -0.04701155f, 0.00977330f, 0.05411449f, -0.05011064f, -0.00900035f, -0.06648716f, -0.03329096f, -0.05872398f, 
    0.02266813f, -0.00839203f, 0.00364265f, 0.00080522f, 0.04105761f, 0.01886985f, -0.06764997f, -0.01228789f, 
    -0.02103177f, -0.03773691f, -0.01101505f, 0.01670375f, 0.03232630f, -0.00349332f, 0.00426008f, -0.05421575f, 
    0.02706183f, 0.05402084f, -0.02650663f, 0.03086881f, -0.04770515f, -0.00770244f, -0.06810568f, 0.01687453f, 
    -0.00598574f, 0.00995613f, -0.04178199f, 0.03025261f, -0.06266642f, -0.03717232f, 0.01168445f, 0.03370728f, 
    -0.01818605f, -0.02176556f, -0.07409406f, -0.07115453f, 0.00034941f, -0.02765456f, -0.00126483f, -0.02849826f, 
    -0.05142137f, 0.02114975f, -0.06971244f, 0.03305702f, -0.01041206f, 0.03247951f, 0.02735462f, -0.04369866f, 
    0.02616770f, 0.02045128f, -0.02141554f, -0.06151513f, -0.04180115f, 0.00037249f, -0.06540699f, 0.00433168f, 
    -0.03730120f, 0.02595401f, 0.06087049f, -0.06886832f, -0.07477878f, 0.02156750f, -0.00732296f, -0.06139672f, 
    0.06062402f, -0.07187754f, -0.03982627f, 0.02634588f, 0.02821942f, 0.03671869f, 0.04300551f, 0.02136461f, 
    -0.02048235f, 0.00070882f, -0.00375100f, -0.00762224f, -0.06747620f, 0.02572787f, -0.03377398f, 0.00249306f, 
    0.03625662f, 0.04832332f, 0.00286503f, -0.07571090f, -0.04452717f, -0.00755852f, -0.07817482f, -0.01970436f, 
    0.62772524f, -0.13227473f, 0.10353588f, 0.19897556f, -0.05390993f, 0.00653934f, -0.00066218f, 0.02504741f, 
    0.03116958f, 0.13673934f, -0.19439124f, -0.05170925f, -0.21903780f, -0.02646848f, 0.14367393f, -0.19603539f, 
    0.04632827f, 0.00523793f, 0.08322711f, 0.01498406f, 0.08842697f, 0.06235568f, 0.07264230f, 0.00155665f, 
    0.07281474f, -0.00683030f, 0.01228195f, -0.01125368f, 0.00587758f, -0.04442847f, -0.03762969f, -0.14037611f, 
    0.06620724f, 0.06765195f, 0.01481092f, 0.01150557f, -0.16843198f, 0.12852812f, 0.09149978f, 0.16953467f, 
    0.08982995f, 0.06635810f, 0.01886459f, 0.02450763f, 0.02874398f, 0.09203456f, -0.00537190f, 0.10043041f, 
    -0.10235624f, 0.02618697f, 0.00284980f, 0.03370801f, 0.07791476f, -0.02866678f, -0.03442091f, 0.15679461f, 
    0.18307929f, 0.07471903f, 0.06746048f, 0.02832180f, 0.25235975f, -0.18867533f, 0.05440884f, -0.17458814f, 
    0.04539338f, -0.06941128f, 0.06938498f, -0.13964900f, -0.05012638f, -0.04389308f, 0.01523447f, -0.00798478f, 
    0.21407554f, 0.01193788f, -0.02684845f, -0.16441095f, -0.17784277f, -0.13279973f, -0.07409652f, -0.11487556f, 
    0.10005431f, -0.05580847f, 0.07040340f, 0.00456599f, 0.24166371f, -0.07017895f, -0.17339914f, -0.18305901f, 
    -0.17419854f, 0.01922492f, 0.03251435f, -0.03304148f, -0.25711775f, -0.00755406f, 0.08442626f, -0.03727092f, 
    -0.09645123f, 0.03176560f, 0.13106270f, 0.01621928f, -0.10937018f, -0.19897370f, 0.06613021f, 0.05415675f, 
    -0.08536609f, -0.13773294f, 0.04784814f, 0.14229581f, -0.17767382f, 0.23770151f, 0.05967290f, 0.02979534f, 
    0.15773462f, 0.04745281f, -0.02662289f, -0.02845575f, 0.07700130f, 0.05804373f, 0.01913885f, -0.04205087f, 
    -0.11430626f, 0.03341513f, -0.17823739f, -0.17186321f, -0.00943751f, 0.10959675f, 0.03397569f, -0.02786712f, 
    -0.07189021f, -0.02595055f, -0.05083197f, -0.08054336f, 0.12774034f, 0.23575364f, 0.03193707f, 0.19689465f, 
    -0.09766775f, 0.02947387f, -0.02425911f, 0.03934444f, 0.13549733f, 0.04680365f, -0.03293584f, -0.08477654f, 
    0.21761836f, -0.15911259f, 0.12038206f, 0.00005743f, -0.08847749f, 0.01467540f, 0.06810582f, -0.02602634f, 
    0.04147908f, -0.12652990f, -0.01474181f, -0.09504104f, -0.23786508f, 0.22742060f, 0.32864982f, -0.04790998f, 
    -0.14319289f, 0.16036695f, 0.05523968f, 0.07060598f, 0.02210627f, -0.08203885f, 0.05714360f, 0.09764082f, 
    0.00222554f, -0.14466065f, 0.08212908f, -0.05946357f, 0.16740870f, 0.05422157f, 0.09775062f, 0.01525143f, 
    -0.09643739f, -0.00211741f, -0.17962162f, -0.05685046f, -0.24641778f, 0.02595559f, -0.00745838f, 0.07484621f, 
    0.06157809f, 0.11274783f, -0.05810145f, 0.01677160f, 0.03866653f, 0.05881277f, -0.01771477f, 0.05344099f, 
    0.00336407f, 0.00786618f, -0.05623389f, -0.06830102f, -0.02567304f, -0.01638519f, 0.04367675f, -0.02575598f, 
    -0.01963623f, 0.04251662f, -0.03410654f, 0.06264013f, 0.05825433f, -0.05605822f, -0.01549755f, -0.03342960f, 
    -0.03697923f, 0.02766598f, 0.04685944f, 0.01286441f, -0.05787137f, -0.00412514f, 0.01250518f, 0.00526689f, 
    0.06422945f, 0.04812497f, 0.00213073f, -0.00731724f, 0.01411126f, 0.00645295f, 0.05953957f, 0.01520837f, 
    -0.02604677f, 0.05540662f, 0.00567956f, 0.02929166f, -0.04782709f, 0.03851493f, 0.01089280f, -0.07813301f, 
    -0.01063773f, 0.02137253f, -0.05727119f, -0.01332762f, 0.02643354f, 0.02028122f, -0.04819366f, -0.03023483f, 
    -0.07927252f, -0.05301475f, -0.07219391f, 0.04701881f, -0.07243747f, -0.05639289f, 0.00997249f, 0.05866784f, 
    -0.00005404f, -0.01572327f, -0.03191273f, -0.00148587f, 0.02399319f, 0.02534260f, 0.01700312f, -0.01518645f, 
    0.04499863f, 0.05927590f, -0.05583406f, -0.05400689f, 0.04255491f, 0.04088699f, -0.06894666f, -0.03365777f, 
    -0.01697925f, 0.06428125f, -0.00311136f, 0.06251407f, -0.04605785f, 0.01972258f, -0.02395240f, -0.01870818f, 
    -0.04263298f, -0.03805475f, 0.05692898f, 0.01791186f, 0.01779396f, -0.03368077f, 0.05505146f, 0.00272712f, 
    -0.00403821f, 0.04564160f, -0.02153410f, -0.04139687f, -0.07351582f, -0.01743662f, 0.00761758f, 0.02596123f, 
    -0.05498447f, 0.01868828f, -0.06284402f, 0.04955336f, -0.01035448f, 0.01641317f, -0.04025392f, -0.07055070f, 
    -0.02945884f, 0.00560081f, 0.01161784f, -0.00180191f, 0.05279654f, -0.02345590f, -0.01900957f, -0.06274565f, 
    0.05083060f, -0.04013183f, -0.01276780f, -0.07389602f, 0.04792652f, -0.02479095f, 0.04498373f, 0.06319014f, 
    -0.04822943f, 0.02843538f, 0.02250970f, 0.01035538f, 0.05454955f, -0.07631998f, -0.03450659f, -0.05539826f, 
    0.02445599f, -0.01260277f, -0.06800684f, -0.00601197f, 0.04629915f, 0.05113450f, 0.06723980f, 0.01525044f, 
    0.03046087f, -0.03827563f, 0.02046833f, -0.07552115f, -0.05501742f, -0.02149539f, 0.01193112f, -0.00142657f, 
    -0.06101339f, -0.04921863f, 0.01060517f, 0.00584000f, 0.04623120f, -0.01898418f, -0.06311630f, 0.03526837f, 
    -0.03864735f, 0.02413902f, -0.05774076f, -0.03736610f, -0.01561272f, 0.04423150f, -0.02342368f, -0.05781878f, 
    -0.06733774f, -0.02736664f, -0.00034925f, -0.03823023f, 0.00001334f, -0.04029398f, -0.01825597f, 0.00810914f, 
    0.00092749f, 0.01536748f, -0.02256476f, -0.06482908f, -0.05219338f, -0.02289532f, -0.05090664f, -0.03750833f, 
    0.06301901f, 0.04397114f, -0.06331820f, -0.00496881f, -0.01660903f, 0.04395411f, -0.03638215f, -0.01745925f, 
    0.00529908f, -0.05590368f, -0.00762928f, 0.02116274f, 0.02706418f, 0.01357484f, -0.01845797f, -0.04537010f, 
    -0.16236439f, 0.34693262f, -0.02377077f, 0.14180629f, -0.00721361f, -0.00047591f, -0.00706699f, -0.04997935f, 
    0.06907102f, 0.02441491f, 0.19822052f, 0.00508352f, -0.03816971f, 0.30193755f, -0.06843969f, -0.09146412f, 
    0.14427201f, 0.11776681f, -0.05750284f, 0.04870542f, -0.06179952f, 0.00567772f, -0.11684752f, -0.02368997f, 
    -0.20627044f, 0.01115385f, 0.08123850f, -0.08779819f, -0.15535887f, -0.23186459f, -0.04023420f, 0.05170387f, 
    0.18088071f, -0.19175935f, -0.07583922f, -0.00999020f, 0.11233789f, 0.09827860f, 0.13563332f, -0.19174907f, 
    0.03887078f, -0.06081777f, -0.07704413f, -0.00654044f, -0.01666269f, 0.06125801f, -0.05654439f, 0.02624390f, 
    -0.15727137f, 0.26992863f, 0.27917063f, -0.06613702f, 0.14784233f, -0.02501464f, -0.05862945f, 0.04132283f, 
    0.13005325f, 0.01833278f, -0.10690700f, 0.03833858f, 0.08008786f, 0.11971566f, -0.10627896f, 0.15790360f, 
    -0.03852138f, 0.08281261f, 0.08535069f, -0.05237344f, 0.03552822f, -0.00151364f, -0.08743700f, -0.03124664f, 
    0.20975371f, -0.34185773f, -0.15908141f, -0.01691490f, 0.10689373f, 0.06267272f, -0.09120441f, 0.12119219f, 
    -0.13539420f, 0.13764746f, 0.03067457f, 0.07908318f, -0.23653591f, 0.24540070f, 0.23282908f, -0.14540689f, 
    -0.01241651f, 0.02411027f, -0.09842894f, 0.12776534f, 0.18794109f, -0.05040162f, -0.08380294f, 0.03668875f, 
    0.04857429f, -0.00890691f, -0.13379715f, -0.13682783f, 0.14755712f, 0.13570510f, -0.04050878f, -0.16587248f, 
    -0.02505055f, 0.10234762f, -0.10746104f, 0.00704491f, 0.46227786f, 0.11845332f, 0.22726302f, -0.03688433f, 
    0.07191596f, -0.04142467f, 0.07156485f, 0.12059534f, -0.09231213f, 0.09723396f, 0.02210992f, 0.08392332f, 
    0.28996637f, -0.01216488f, -0.05477173f, 0.06483374f, -0.11254001f, -0.13129616f, -0.18827310f, -0.03010879f, 
    -0.04947836f, -0.08806985f, 0.01575860f, -0.04756699f, 0.06708187f, 0.14706628f, -0.09481327f, 0.03751673f, 
    0.21500063f, -0.17406593f, 0.02053799f, -0.16575588f, -0.09884464f, 0.00805988f, 0.07489908f, -0.06693029f, 
    0.02789291f, -0.16836944f, -0.02433291f, 0.15101740f, -0.01542450f, -0.00377723f, -0.05659036f, 0.04345653f, 
    -0.11883770f, 0.15746213f, 0.10221549f, 0.13472001f, -0.15885006f, 0.17543429f, -0.13228275f, -0.38360795f, 
    0.11091129f, -0.11231939f, -0.24345002f, 0.04547936f, -0.11701569f, 0.08180866f, 0.08670628f, -0.05300205f, 
    0.02271607f, 0.06126711f, -0.17491141f, 0.09518374f, -0.07358003f, 0.20616512f, 0.03036678f, -0.10573069f, 
    0.07713009f, 0.06966636f, -0.01795156f, 0.13765010f, 0.43696302f, -0.38621053f, -0.07024258f, -0.21260479f, 
    -0.11931307f, -0.19038168f, -0.00058010f, 0.05174480f, 0.07250640f, 0.04880865f, -0.03735919f, -0.06313452f, 
    -0.01047991f, -0.06785561f, 0.00343434f, -0.01116805f, -0.05017917f, -0.07036246f, -0.00585164f, -0.01736141f, 
    -0.03835569f, -0.06077214f, -0.07700343f, -0.06543384f, -0.02008069f, -0.00305406f, 0.03831362f, -0.05753682f, 
    0.04063291f, -0.01654465f, -0.00542074f, -0.04894642f, 0.03465556f, -0.05282104f, 0.00281060f, -0.04172336f, 
    -0.05737139f, -0.06614383f, 0.05302816f, -0.00405060f, -0.02630435f, 0.00531610f, 0.02419906f, -0.02349318f, 
    -0.00554158f, -0.01166447f, -0.00797044f, 0.02567994f, 0.02596675f, 0.04675130f, 0.04465726f, -0.03681408f, 
    0.06121222f, -0.06384039f, 0.02216136f, 0.05245260f, -0.07575933f, -0.01580558f, -0.02308528f, 0.03974361f, 
    -0.01793218f, 0.00516026f, -0.04617729f, -0.03252187f, 0.05975435f, 0.00301446f, -0.00748055f, 0.03485155f, 
    -0.06834951f, 0.02956230f, 0.06628338f, 0.06345224f, -0.06849334f, -0.05687059f, 0.04712423f, 0.01402645f, 
    -0.07706332f, -0.00367772f, -0.04677194f, -0.05982860f, 0.05639496f, 0.02411874f, 0.04829190f, -0.07696339f, 
    -0.02266869f, -0.01997397f, -0.01666777f, -0.00037899f, -0.00046232f, 0.04521049f, -0.07501925f, -0.04093010f, 
    -0.04183666f, -0.05135083f, 0.00705345f, 0.04040914f, -0.01420033f, 0.02737001f, 0.01291155f, -0.02905404f, 
    -0.03351629f, 0.05866979f, -0.07395503f, 0.06349555f, 0.03296192f, -0.00715740f, -0.04865056f, -0.04792268f, 
    0.03820831f, -0.04387107f, 0.05900248f, -0.01136669f, 0.00896960f, -0.04264164f, 0.02158459f, -0.05101190f, 
    0.04348087f, -0.02702715f, 0.04402579f, 0.01363652f, 0.01059045f, -0.05975219f, -0.06592152f, 0.01323908f, 
    0.01391869f, -0.01155510f, 0.00052280f, 0.03872706f, 0.02889323f, 0.00659449f, -0.03393196f, 0.00461452f, 
    -0.00045073f, -0.07137475f, 0.00730946f, 0.03990358f, 0.04822541f, 0.03685278f, -0.01532947f, -0.06235321f, 
    -0.03899617f, -0.01196523f, -0.01202554f, 0.01135795f, 0.06682558f, 0.04907481f, -0.07396428f, -0.02146227f, 
    0.00221304f, -0.01356383f, 0.02638575f, -0.01741798f, -0.05750114f, -0.00418956f, 0.04084802f, 0.05240921f, 
    -0.05706112f, -0.05026581f, 0.04562439f, -0.04027044f, -0.01046759f, 0.01213770f, 0.01330384f, -0.06498113f, 
    -0.05725424f, 0.06012414f, -0.04925784f, 0.00201927f, 0.05704968f, 0.01593105f, -0.07217038f, -0.05349375f, 
    -0.00302656f, 0.03084048f, 0.06391491f, -0.07203809f, 0.04927679f, 0.00792353f, -0.01939056f, 0.02130380f, 
    -0.06605739f, -0.06280719f, -0.06364497f, -0.06160824f, -0.05775629f, -0.06896463f, -0.04555995f, -0.03268565f, 
    -0.03665942f, -0.06052329f, -0.01825755f, -0.03671271f, -0.04197318f, -0.06448892f, 0.06698151f, -0.00448517f, 
    -0.02099597f, -0.00570694f, 0.05235939f, 0.03464565f, -0.06440035f, 0.03358226f, -0.05902382f, 0.04920908f, 
    -0.05767558f, -0.05693231f, -0.05457151f, -0.01622052f, 0.05178076f, -0.00504585f, 0.03082997f, 0.02339113f, 
    0.04617887f, -0.02021506f, -0.04474571f, 0.04745119f, -0.00388195f, 0.00637950f, -0.04808658f, -0.02368033f, 
    -0.04057627f, 0.01072434f, 0.05579372f, 0.05333701f, 0.02876258f, -0.07003856f, -0.00916514f, 0.05424722f, 
    -0.01282239f, -0.02496572f, 0.03041907f, 0.04459630f, -0.06078385f, -0.07423147f, 0.04399043f, 0.00819944f, 
    -0.07347301f, 0.00960459f, 0.00989905f, -0.00143926f, 0.01376626f, 0.00861348f, -0.02285629f, -0.07065769f, 
    -0.04283761f, -0.05924965f, 0.05489296f, -0.06706401f, -0.04643788f, 0.04313811f, -0.00054916f, -0.03496860f, 
    0.00102727f, -0.01960913f, -0.03994875f, -0.02321376f, -0.06679691f, -0.00706513f, -0.00126195f, -0.03575117f, 
    0.04031751f, -0.05159469f, -0.04557159f, -0.04970151f, -0.02004724f, 0.04098673f, -0.06786609f, -0.04367446f, 
    0.00597836f, 0.05725550f, 0.05775695f, -0.04241338f, 0.05036311f, 0.05094484f, -0.00705977f, -0.07417006f, 
    0.02606736f, -0.01897225f, -0.05886135f, -0.06356825f, 0.05864394f, -0.00489818f, 0.03418731f, -0.06496910f, 
    0.00385451f, -0.05022875f, -0.01450249f, 0.03475950f, 0.04419813f, 0.04682309f, -0.07021894f, -0.06159307f, 
    -0.03078440f, 0.02829495f, -0.03336705f, -0.01517793f, -0.01139544f, 0.04976038f, -0.04081189f, -0.01739885f, 
    -0.00221806f, -0.07020901f, 0.00153716f, -0.02689076f, -0.01129419f, 0.00720131f, 0.03656471f, -0.06424522f, 
    0.05259357f, 0.03919842f, 0.04000400f, 0.01696241f, 0.04961000f, -0.05081223f, -0.03550267f, -0.02250341f, 
    0.05490371f, -0.02005977f, -0.04578227f, -0.03070782f, -0.01048374f, 0.02170035f, 0.01449730f, 0.04251711f, 
    0.05584525f, -0.06630503f, -0.00056590f, -0.05940534f, -0.06900283f, -0.07762752f, -0.02087647f, -0.07507025f, 
    -0.01151311f, 0.00480191f, -0.04821726f, 0.02513406f, -0.00468337f, 0.05549615f, 0.02569085f, 0.03196496f, 
    0.00347682f, -0.02231739f, -0.00717468f, -0.03772796f, 0.01564174f, -0.02836232f, 0.06294160f, -0.06919558f, 
    -0.06484842f, -0.03231971f, -0.04029422f, 0.00499771f, -0.02678823f, -0.03687574f, -0.05728554f, -0.07794574f, 
    0.05483524f, -0.04802020f, -0.06041222f, 0.00646011f, -0.01937761f, 0.04196146f, 0.06228377f, -0.01632719f, 
    0.01612601f, -0.04104281f, -0.06771694f, -0.05685901f, -0.01366828f, -0.02108287f, -0.03384345f, -0.03743433f, 
    -0.03035527f, -0.00776658f, 0.00056832f, 0.05623989f, -0.00562154f, 0.04249392f, 0.01816732f, 0.03690371f, 
    -0.01385298f, 0.01537060f, -0.02121168f, -0.03987295f, 0.03032008f, -0.06919967f, -0.02085117f, -0.02029942f, 
    -0.00514491f, 0.05165290f, -0.01443150f, -0.07323909f, 0.06083144f, 0.05466163f, -0.08302199f, 0.00184153f, 
    0.08165383f, 0.15183184f, 0.06646221f, 0.10952997f, 0.01276707f, 0.12920891f, 0.09299439f, -0.00281788f, 
    -0.00132128f, 0.00797213f, 0.05545822f, 0.05044287f, 0.29664144f, -0.20311864f, 0.07393420f, 0.12514566f, 
    0.03480207f, 0.07873105f, 0.02041356f, 0.00863537f, -0.03821637f, 0.09833966f, -0.08314928f, 0.14670572f, 
    -0.06617283f, 0.14019303f, -0.03016464f, 0.03849120f, 0.01326153f, 0.10592984f, 0.01917746f, -0.01698519f, 
    -0.01476788f, -0.00758354f, 0.07786824f, -0.07647752f, -0.04373788f, -0.03255617f, -0.10167265f, 0.05980770f, 
    -0.01317349f, 0.00658192f, 0.05001902f, 0.04167749f, 0.00333188f, 0.05095011f, 0.00779916f, 0.04006740f, 
    -0.25480160f, -0.03480158f, -0.06276850f, -0.03440282f, 0.03597387f, -0.03749480f, -0.03563331f, -0.01833676f, 
    0.02015097f, -0.11197860f, 0.00091617f, -0.01891350f, 0.02421381f, 0.18591860f, -0.13617669f, 0.17935076f, 
    -0.00180923f, 0.17986649f, -0.00339040f, 0.00678912f, 0.13715757f, 0.00732383f, 0.00344512f, -0.09605768f, 
    0.00735423f, -0.14553076f, -0.04763274f, 0.09088954f, -0.17019489f, -0.07728729f, 0.05606114f, 0.05520969f, 
    0.02901289f, 0.00801743f, 0.08179460f, -0.02791879f, 0.24972415f, 0.18402866f, -0.25491866f, 0.25904724f, 
    -0.09016719f, 0.11440659f, -0.02699307f, 0.03727405f, 0.11555027f, 0.05801534f, 0.06035037f, 0.02302256f, 
    0.13920240f, -0.02849766f, 0.10782994f, 0.11703996f, 0.05889597f, -0.06334238f, -0.04314237f, 0.03139478f, 
    -0.07515880f, -0.10593719f, 0.04994723f, -0.02309508f, -0.46400592f, -0.20541799f, -0.00386448f, -0.00318786f, 
    0.08225688f, 0.06654732f, -0.07444620f, -0.06208988f, 0.08801766f, 0.04790041f, -0.00937690f, 0.01205521f, 
    -0.24926658f, -0.02759786f, -0.00457723f, 0.00357371f, 0.06043253f, -0.01276796f, -0.05255322f, -0.01382587f, 
    -0.17561769f, -0.09136856f, 0.08968624f, 0.04226900f, 0.33323619f, 0.26914755f, 0.20056774f, -0.07927439f, 
    0.00314910f, -0.00565453f, -0.00866729f, 0.00335830f, -0.00066448f, -0.08558767f, 0.07369970f, 0.00162640f, 
    0.13123588f, -0.13643609f, 0.14652300f, 0.01382643f, 0.05716420f, 0.08843321f, 0.00637424f, -0.05602838f, 
    -0.04255898f, 0.05105384f, 0.14384988f, 0.00867239f, 0.09024417f, -0.00514605f, 0.05772265f, -0.01426951f, 
    -0.11217871f, 0.02922480f, -0.04254691f, 0.11544215f, 0.05670605f, -0.00851024f, 0.04318628f, 0.05432278f, 
    -0.04637777f, 0.10819402f, -0.12048485f, -0.12326531f, 0.01666360f, -0.01257245f, 0.02751835f, -0.05037260f, 
    0.04830990f, 0.01967759f, 0.11580238f, 0.18252252f, -0.25164574f, 0.04669213f, -0.00545306f, 0.04585753f, 
    0.07564533f, 0.06593630f, 0.12869109f, -0.00803324f, 0.01204314f, -0.00149634f, 0.07872701f, 0.00993354f, 
    -0.03965279f, -0.04332947f, 0.03715532f, -0.05342401f, -0.06376228f, 0.05479542f, -0.06753252f, -0.06809564f, 
    -0.02707163f, 0.03891823f, -0.07877470f, -0.06555925f, -0.07533907f, -0.01140839f, 0.00556799f, 0.02648096f, 
    -0.01676066f, -0.05117561f, 0.07057233f, -0.07067650f, -0.04903064f, -0.02491905f, -0.00364334f, -0.06700628f, 
    0.02654948f, 0.02797950f, -0.07510759f, 0.03062625f, -0.05019601f, 0.05313641f, -0.06064370f, -0.04799289f, 
    0.06678721f, -0.03549894f, 0.02653091f, -0.01596877f, 0.03443542f, 0.05394933f, -0.05517717f, -0.03774693f, 
    -0.02837275f, 0.00587072f, 0.04028478f, 0.02490726f, -0.04683819f, 0.00300929f, 0.02691707f, -0.05452727f, 
    0.06684479f, 0.04604240f, 0.03412756f, -0.06640849f, -0.04146301f, 0.06700835f, 0.05628498f, -0.05726477f, 
    -0.06193453f, -0.00896024f, 0.06203127f, -0.06360491f, -0.02483210f, 0.03080337f, -0.06040379f, 0.02150293f, 
    -0.04365160f, 0.01326198f, 0.01694895f, 0.05831397f, 0.00989299f, -0.04958116f, 0.04202077f, 0.04125643f, 
    -0.08715148f, -0.05398432f, -0.08545594f, 0.04723361f, -0.01099025f, -0.06363162f, -0.00080389f, 0.04655998f, 
    0.03499464f, -0.04052806f, -0.07673041f, 0.03966465f, -0.00057405f, -0.00350555f, 0.02615814f, -0.00227212f, 
    0.00888986f, 0.02064841f, 0.01514536f, 0.02015906f, 0.05952987f, 0.02566136f, -0.01622746f, -0.01702349f, 
    -0.04308822f, -0.00474784f, -0.02812048f, -0.04284376f, -0.00714309f, -0.04394345f, -0.02310363f, -0.02803974f, 
    -0.03647648f, -0.01133009f, 0.07155977f, -0.06722441f, 0.04212610f, -0.04299914f, 0.05704502f, 0.05484180f, 
    0.02685198f, -0.03580641f, -0.06508823f, 0.04329498f, -0.06673440f, -0.01223033f, -0.04657535f, 0.00797005f, 
    -0.05777172f, -0.00799954f, 0.04385949f, -0.00077949f, 0.00305056f, -0.01623436f, -0.06086588f, 0.04508099f, 
    -0.06800576f, -0.01211725f, 0.04657536f, 0.06792022f, -0.05604712f, -0.05250861f, -0.08544806f, -0.01182848f, 
    -0.04480503f, 0.02930168f, -0.04053786f, -0.03895041f, 0.05254266f, -0.04841414f, 0.01604487f, -0.04344706f, 
    -0.03959525f, -0.02896392f, 0.04117615f, -0.03263135f, -0.05470585f, -0.04171535f, -0.08035109f, -0.02629506f, 
    0.01146509f, 0.01841561f, 0.06565953f, 0.00617472f, -0.05654811f, 0.01942254f, -0.03875768f, -0.07188889f, 
    0.06219323f, -0.01318873f, 0.01876749f, -0.00905846f, 0.05888682f, 0.01764381f, -0.07686754f, -0.00397871f, 
    -0.00474210f, 0.01381925f, 0.00449696f, -0.00937483f, 0.03877518f, -0.07213890f, 0.00455016f, 0.01745026f, 
    0.04240794f, -0.06892756f, 0.00916670f, -0.07946396f, -0.03825517f, -0.01445007f, -0.02006743f, 0.06448124f, 
    0.03386513f, -0.01403333f, -0.08492786f, 0.01225381f, -0.04472542f, 0.00263073f, 0.02312968f, -0.02553331f, 
    0.10040264f, 0.01614857f, -0.01956597f, -0.01966793f, 0.07869013f, -0.09205506f, 0.04602254f, -0.04947459f, 
    0.12818336f, 0.08782494f, 0.03483146f, 0.05795840f, -0.26177007f, -0.05579246f, -0.03430720f, -0.20777786f, 
    -0.07038861f, 0.02705027f, 0.01523067f, -0.06437013f, 0.14953667f, 0.12490816f, 0.08322534f, -0.04450504f, 
    -0.16722746f, 0.04890849f, -0.01497311f, -0.01609323f, 0.10967842f, 0.04950647f, 0.01973530f, 0.05349687f, 
    -0.11966371f, 0.17715268f, 0.01049631f, 0.06314669f, -0.03518291f, -0.12097194f, 0.03246127f, -0.07901940f, 
    0.15413806f, -0.00218589f, 0.04060392f, 0.08745435f, 0.01739239f, -0.05974116f, -0.04970120f, 0.10319313f, 
    0.05432582f, -0.03458599f, 0.07380676f, 0.26771212f, 0.09271508f, -0.08304936f, -0.12841377f, 0.13123757f, 
    0.04460609f, -0.05069664f, 0.14728610f, 0.04003595f, 0.19534668f, -0.19254947f, 0.03121505f, -0.04377288f, 
    -0.04791547f, 0.06152618f, 0.11816756f, -0.05486283f, -0.04541975f, -0.03208933f, -0.09450804f, 0.03138269f, 
    0.26029849f, 0.13811414f, -0.26941693f, 0.02751141f, -0.12632497f, 0.14129126f, -0.04529964f, -0.10840002f, 
    0.00991684f, 0.04599978f, 0.02492180f, 0.11379150f, -0.31229046f, -0.00314083f, -0.21251456f, 0.02080042f, 
    -0.06298804f, 0.05020042f, -0.01916762f, -0.07169263f, -0.20047782f, -0.00738804f, 0.09049635f, -0.13170163f, 
    -0.31795782f, 0.00075432f, 0.13817121f, 0.06843014f, 0.08175830f, 0.01168404f, -0.07567853f, -0.09002966f, 
    0.12276046f, 0.04458778f, 0.04135064f, 0.03424155f, -0.02835348f, -0.04764257f, -0.01240511f, 0.34209269f, 
    -0.04824521f, -0.13765718f, 0.01599074f, 0.02914353f, 0.00995376f, -0.01462426f, 0.03614051f, -0.19390163f, 
    0.04647470f, 0.08158498f, -0.21898292f, -0.03883955f, -0.00904526f, -0.02485802f, 0.06440601f, 0.03171713f, 
    0.04584180f, 0.00834844f, -0.00805677f, -0.12534608f, -0.12945914f, 0.04929727f, 0.01073813f, 0.02471558f, 
    0.04376859f, -0.02029906f, 0.04827272f, 0.07962824f, 0.16105630f, -0.00823806f, 0.15621287f, 0.03036193f, 
    0.16983946f, -0.10419889f, -0.03748327f, 0.12999377f, -0.03897867f, 0.07799779f, -0.00888839f, 0.14855644f, 
    0.08376152f, -0.01540237f, 0.02418869f, -0.00924748f, -0.24177691f, 0.20425381f, 0.08813218f, -0.13210253f, 
    0.18956558f, 0.18136948f, -0.10806147f, -0.01784998f, 0.11535990f, -0.03107053f, -0.02358267f, 0.08601020f, 
    -0.26751277f, -0.13118200f, 0.00825814f, 0.03566676f, 0.04151281f, 0.16090585f, 0.14823492f, 0.04065013f, 
    -0.07069302f, -0.05538675f, -0.17954829f, -0.09855241f, 0.22735623f, 0.02379653f, -0.12715621f, -0.00899853f, 
    0.00356410f, -0.04647180f, 0.00654267f, 0.15820415f, -0.12572247f, 0.09661330f, 0.08070294f, 0.02055802f, 
    -0.08101911f, 0.04446000f, 0.01677575f, -0.02763863f, -0.02798265f, 0.20376201f, 0.10081181f, 0.11654292f, 
    -0.07269882f, -0.05803375f, 0.14397885f, -0.05475386f, 0.12419418f, -0.10215708f, 0.19246538f, 0.20232700f, 
    -0.04010035f, 0.06498875f, 0.00515246f, -0.05164489f, -0.10975242f, 0.08166277f, -0.10404833f, 0.03600777f, 
    0.10536374f, 0.04440347f, 0.11701358f, 0.03471264f, 0.00597601f, 0.05615971f, -0.00548014f, -0.03529122f, 
    0.13541144f, 0.00507643f, 0.04167007f, -0.01801284f, 0.10758802f, -0.03327282f, -0.06508677f, -0.11293829f, 
    -0.06026294f, 0.11112320f, -0.00415471f, -0.07324382f, 0.06264155f, 0.03883512f, 0.14950033f, -0.03820748f, 
    -0.14171900f, 0.10085937f, -0.10198870f, 0.04940462f, 0.11522534f, -0.01894611f, 0.22821987f, -0.02655861f, 
    -0.11098421f, 0.02568343f, -0.05282894f, -0.01493021f, -0.14407828f, -0.03635837f, 0.09150178f, 0.13788673f, 
    -0.05938581f, 0.11589166f, 0.11504980f, 0.11660654f, 0.10551976f, 0.09621681f, 0.04147366f, -0.05127346f, 
    -0.16582163f, -0.14680251f, 0.09871039f, 0.21870859f, -0.09468189f, -0.20190133f, 0.08911024f, 0.13325183f, 
    -0.04301248f, -0.01783555f, -0.07146320f, -0.07141297f, 0.02751895f, 0.06791729f, 0.05968840f, 0.18046635f, 
    -0.03250667f, 0.14774852f, -0.07826246f, -0.03903652f, 0.05554178f, -0.04197320f, -0.06008325f, 0.08683763f, 
    -0.02560263f, -0.12446134f, 0.21164553f, -0.00411620f, -0.05259132f, 0.04318131f, 0.03278222f, -0.00567269f, 
    -0.01512689f, 0.06058713f, -0.01103758f, 0.03648212f, -0.30889922f, -0.14738306f, -0.09830353f, -0.19777501f, 
    0.08066860f, 0.08832554f, -0.03048029f, -0.01489846f, 0.03728963f, 0.01172355f, -0.08324195f, 0.04683711f, 
    -0.18192351f, 0.07378748f, 0.11724622f, -0.08174712f, 0.07325639f, 0.04034697f, -0.05213994f, 0.10405373f, 
    -0.06659541f, 0.05925365f, 0.02286969f, 0.06468207f, 0.06656422f, 0.18730943f, -0.01361074f, -0.10321809f, 
    0.11852503f, 0.06243081f, 0.06109600f, -0.00240349f, -0.08144925f, 0.03103888f, -0.05427411f, 0.00105592f, 
    0.05067996f, 0.11955722f, 0.18542695f, -0.08983488f, -0.06866053f, 0.04072816f, -0.04732598f, -0.09214985f, 
    -0.11745116f, 0.16380347f, 0.05737064f, 0.05138622f, 0.25205094f, 0.08301070f, 0.02780709f, 0.08227259f, 
    -0.11181515f, -0.00566514f, -0.03863832f, 0.19149299f, -0.09909095f, 0.02632097f, 0.07034318f, 0.03899486f, 
    0.20496750f, 0.18095437f, -0.00101301f, 0.01225642f, 0.07861126f, -0.04270218f, -0.10557112f, -0.02673395f, 
    -0.01122048f, 0.10363819f, 0.26708546f, 0.23625422f, -0.49760449f, -0.03093920f, 0.07111392f, 0.09958535f, 
    0.11562317f, -0.09475011f, 0.08595730f, -0.04106953f, 0.07070170f, -0.01425148f, -0.13084285f, -0.00105928f, 
    -0.20469987f, -0.21784867f, -0.09824294f, -0.09849583f, 0.02288590f, -0.01195229f, -0.00097477f, -0.01328339f, 
    -0.06518278f, -0.03568190f, -0.00374819f, 0.04507541f, 0.16242541f, 0.08122180f, -0.21132760f, -0.11354636f, 
    0.01595971f, -0.14546248f, -0.08459318f, 0.07359631f, 0.08860789f, -0.01492556f, 0.13527821f, 0.06582603f, 
    0.06869987f, -0.00107260f, -0.04660692f, 0.03665621f, -0.07401104f, 0.05727096f, -0.04073462f, 0.08332221f, 
    -0.09187837f, -0.02918298f, 0.02738043f, -0.04217200f, 0.15218651f, 0.09293918f, 0.01094818f, 0.13864653f, 
    -0.12999532f, 0.00287093f, -0.01505157f, 0.02450579f, 0.05184166f, 0.04453754f, -0.06115006f, 0.04156746f, 
    0.39485815f, -0.09594510f, -0.07096632f, -0.03014860f, -0.19249915f, 0.12518273f, 0.10637093f, 0.00687045f, 
    -0.08439770f, 0.05600634f, 0.05332572f, 0.05255988f, 0.03962541f, 0.08220785f, -0.01122766f, -0.11640398f, 
    0.12685277f, 0.01300668f, -0.06107790f, 0.02338927f, -0.00351307f, 0.03092106f, 0.05905456f, 0.22801903f, 
    -0.30145681f, 0.33529532f, 0.11324768f, -0.15714811f, 0.24972709f, 0.19505069f, -0.08716132f, 0.05176978f, 
    0.04487488f, 0.04768723f, -0.00267788f, -0.07829287f, 0.14454108f, -0.04485532f, -0.00933860f, -0.12210962f, 
    0.16032021f, -0.13705333f, 0.15462033f, 0.03671699f, 0.05815112f, -0.00939290f, 0.06663394f, 0.05179548f, 
    0.26911306f, 0.00470101f, -0.04753399f, -0.03550323f, 0.01993918f, 0.06499588f, 0.03727316f, 0.09894273f, 
    0.08022843f, 0.00514071f, -0.01065483f, 0.00338136f, 0.36783952f, 0.08287718f, -0.06247242f, -0.09056130f, 
    0.02798672f, -0.04939613f, 0.06780537f, 0.10590575f, -0.00064148f, -0.02021486f, -0.06169042f, -0.05365719f, 
    0.08740604f, 0.07159969f, 0.02971363f, 0.22116071f, -0.01713034f, 0.08481231f, -0.03449403f, 0.01268517f, 
    0.08289851f, 0.09721267f, 0.03794990f, -0.03926529f, -0.05704591f, -0.42314002f, 0.00698556f, -0.00078760f, 
    0.00309628f, 0.07347490f, -0.13915676f, -0.02738322f, -0.06375131f, 0.07144833f, 0.03791788f, 0.07543370f, 
    -0.15189430f, 0.18631680f, -0.13153048f, 0.01294352f, 0.04520736f, 0.03074370f, 0.04341567f, 0.07453915f, 
    0.04509338f, -0.08112971f, -0.07749139f, -0.03441269f, 0.22004721f, -0.32786044f, -0.09630424f, 0.15769348f, 
    -0.03139854f, 0.01647799f, 0.10319787f, -0.17095083f, 0.07132276f, 0.04416087f, -0.08430141f, -0.10513715f, 
    0.10916314f, 0.12770832f, 0.01640502f, 0.05140782f, 0.09003910f, -0.19814093f, 0.01341695f, -0.01771036f, 
    -0.06098030f, 0.07408958f, 0.15866812f, 0.04633009f, 0.44602749f, 0.15971947f, -0.08455914f, -0.00319839f, 
    -0.14875938f, -0.06016301f, -0.00764727f, -0.03834007f, 0.03641916f, -0.11883442f, 0.02786909f, -0.07810031f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02838468f, -0.07845442f, -0.00941869f, 0.09314481f, 0.05449877f, 0.04230314f, -0.03995952f, -0.03648797f, 
    -0.08881284f, -0.07147989f, 0.02220047f, 0.03987304f, 0.11568842f, -0.00038480f, -0.03021470f, -0.03553321f, 
    0.09222027f, -0.02673707f, -0.05459150f, -0.01152903f, 0.05787450f, 0.01563115f, 0.05180081f, -0.02264303f, 
    0.06553043f, 0.01233137f, 0.06441999f, 0.03924618f, 0.04888029f, -0.04581620f, 0.11562260f, -0.07704199f, 
    0.04737796f, 0.08156513f, 0.10130123f, 0.03607860f, 0.02224857f, 0.08186946f, 0.01484132f, 0.10782380f, 
    0.08474158f, -0.08245009f, 0.06414171f, -0.06417886f, -0.04789526f, 0.05726337f, 0.03954051f, 0.07409759f, 
    0.10591408f, -0.00899748f, -0.02896817f, -0.09374790f, -0.05587907f, -0.04460198f, 0.03846064f, 0.01257639f, 
    0.18059337f, 0.06641220f, 0.00354555f, -0.01642974f, -0.06289900f, -0.00171620f, 0.05034440f, 0.04961692f, 
    0.00472375f, -0.02825381f, 0.05522999f, -0.03068727f, 0.06447722f, 0.08415049f, 0.03294683f, -0.07530453f, 
    -0.02648783f, -0.02837344f, 0.04098500f, -0.06138096f, 0.02412671f, -0.02472993f, 0.03166884f, -0.00730842f, 
    0.04254224f, -0.15110449f, 0.09610128f, -0.08947519f, -0.10147065f, -0.02919880f, -0.02738258f, -0.01887847f, 
    0.10943142f, 0.06899969f, -0.00623851f, 0.02342762f, 0.01235980f, -0.00909249f, 0.01809071f, 0.06585717f, 
    0.11583054f, -0.03893362f, 0.03898019f, 0.07752123f, 0.00917135f, 0.11911178f, 0.04048381f, 0.04976305f, 
    0.06974526f, -0.01986057f, 0.06442256f, 0.00614613f, 0.04880079f, 0.03245157f, 0.04836395f, 0.00903247f, 
    0.05135671f, 0.00382820f, 0.11734518f, -0.14012207f, 0.05576750f, -0.03661081f, -0.09362657f, -0.07713572f, 
    0.04211122f, 0.03012986f, -0.00538143f, 0.03202193f, 0.04646403f, 0.03903363f, 0.03377250f, 0.00092842f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10973644f, 0.02661652f, -0.42315802f, 0.10485350f, -0.04586312f, -0.09265766f, 0.14253443f, -0.03101229f, 
    0.04303272f, -0.02292726f, 0.19889179f, -0.00277221f, 0.34025392f, -0.23459825f, 0.00651393f, -0.01511681f, 
    0.10086325f, 0.11467201f, -0.07503717f, -0.52180785f, 0.04283683f, -0.07019941f, -0.23641729f, -0.04138840f, 
    0.16839057f, 0.02922789f, 0.04864657f, -0.67187667f, -0.16985336f, -0.00568237f, -0.24138360f, 0.04505018f, 
    -0.01933916f, -0.06389288f, 0.29824063f, 0.09375631f, 0.00289707f, -0.22067724f, -0.26496220f, -0.44744954f, 
    0.02277830f, 0.03682410f, -0.37607267f, -0.06496611f, -0.03399242f, 0.15812106f, -0.04632268f, -0.29031646f, 
    0.15928614f, -0.42700526f, -0.26691988f, -0.02170898f, 0.01448762f, -0.05689202f, 0.09820620f, 0.03439286f, 
    -0.21712098f, 0.24172828f, -0.40576211f, 0.03114350f, -0.14477921f, 0.02072129f, 0.10045139f, 0.34033367f, 
    -0.00356853f, -0.60346222f, -0.07794105f, 0.22990182f, -0.07374503f, -0.46803421f, -0.03949320f, 0.03896287f, 
    -0.08796324f, 0.03880599f, -0.03172948f, 0.07233656f, -0.05000095f, -0.06935753f, -0.27870828f, -0.01346328f, 
    0.20488675f, 0.22532555f, 0.19334063f, -0.17499496f, 0.17118129f, -0.36348349f, -0.02602668f, 0.00215284f, 
    0.09723902f, 0.13807079f, -0.03623750f, 0.18120523f, -0.05132384f, 0.05355290f, 0.00114940f, -0.09450300f, 
    -0.11911619f, 0.17755820f, 0.17528465f, -0.13051191f, 0.21502510f, -0.09865482f, 0.04921523f, -0.21798460f, 
    -0.25727585f, 0.19419460f, 0.52296633f, -0.24111927f, 0.10363450f, 0.03078962f, -0.01068747f, -0.07927592f, 
    0.05388676f, 0.07183986f, -0.36175433f, 0.19565256f, -0.17721747f, 0.03717944f, 0.19900517f, 0.08367944f, 
    0.24625781f, 0.00323201f, 0.00892208f, -0.17910631f, 0.02763444f, -0.30612564f, 0.04317601f, -0.02459133f, 
    0.22021785f, 0.02531406f, 0.02650888f, 0.00917037f, 0.05927924f, 0.16028586f, -0.22260228f, 0.06479510f, 
    -0.31696507f, 0.06607543f, -0.17418417f, -0.03547225f, -0.49039158f, 0.25930572f, -0.05816753f, 0.02951982f, 
    -0.21573493f, 0.03987771f, 0.06554344f, -0.18086891f, -0.03126324f, 0.04553872f, -0.19043559f, -0.04129368f, 
    0.12041236f, -0.42896324f, -0.18084948f, 0.07543915f, -0.16752018f, 0.01707772f, -0.43098295f, 0.12597677f, 
    -0.01249280f, -0.32928589f, 0.02323998f, 0.24612083f, -0.01187610f, -0.02011241f, -0.26993284f, 0.20048101f, 
    0.02679436f, 0.04677001f, -0.31956887f, -0.13229275f, -0.03520804f, -0.11794212f, -0.03104864f, -0.22678670f, 
    0.01912825f, 0.12350390f, -0.09333619f, -0.26404151f, -0.04770044f, -0.02400369f, 0.18356487f, 0.01678904f, 
    0.15717247f, 0.21961597f, 0.00930372f, 0.02098910f, -0.03130623f, -0.08623689f, -0.22583669f, 0.22221996f, 
    -0.02336624f, 0.12403098f, 0.15186276f, -0.14195742f, -0.02914941f, 0.27991608f, 0.05983418f, 0.07903746f, 
    0.05695007f, -0.25817138f, 0.06833242f, -0.07360917f, 0.02206520f, -0.00820464f, 0.17408262f, -0.20424366f, 
    0.20358691f, 0.11140924f, -0.06921999f, -0.12835778f, -0.15151501f, -0.32382146f, 0.06620245f, -0.34886906f, 
    -0.34867567f, -0.05068780f, 0.06156146f, -0.12011644f, 0.01574137f, 0.04837443f, 0.05071289f, -0.26819560f, 
    0.24828835f, 0.12269937f, -0.04286661f, -0.02114091f, -0.00252621f, 0.14824626f, -0.03373751f, -0.29586372f, 
    0.13648367f, 0.13038649f, -0.39283299f, 0.20965661f, 0.33853406f, -0.06019464f, 0.32301036f, 0.03529677f, 
    -0.02526165f, 0.04347645f, 0.00517794f, 0.15202656f, 0.12092090f, -0.04306497f, 0.18340820f, 0.06352284f, 
    -0.25805262f, -0.02774430f, -0.07529034f, -0.00757733f, -0.01635929f, -0.03065247f, -0.15008681f, 0.12840661f, 
    -0.14578649f, -0.02031139f, -0.35780385f, -0.31788978f, -0.04154737f, 0.18582502f, -0.02178720f, -0.06651942f, 
    0.29187575f, -0.05055899f, 0.12300704f, -0.06413835f, -0.35554194f, 0.25139230f, -0.01395541f, -0.00584327f, 
    -0.25605795f, 0.15108517f, 0.20828749f, -0.28417230f, -0.05066940f, -0.03453433f, 0.05100079f, 0.01899743f, 
    -0.19185612f, 0.01180900f, -0.16614617f, 0.26640761f, -0.15034780f, 0.01567942f, -0.16761656f, -0.08047853f, 
    0.02332264f, 0.04380731f, -0.26784998f, -0.06392199f, -0.01760081f, 0.23498678f, -0.15924020f, 0.14107649f, 
    -0.09050874f, -0.07476470f, 0.03848934f, 0.09436686f, 0.07447618f, 0.35990375f, 0.19449688f, -0.34288129f, 
    0.12632576f, -0.09367877f, 0.13602313f, 0.09944640f, 0.00044214f, -0.04579590f, -0.08089399f, -0.03418867f, 
    -0.13989131f, -0.21335693f, 0.24085298f, -0.00800372f, -0.10087711f, -0.04361073f, -0.40681365f, 0.04015031f, 
    -0.00811528f, -0.13531826f, 0.07264817f, -0.04296885f, -0.10057525f, -0.19145513f, -0.05517756f, 0.06822410f, 
    -0.06536435f, 0.25796309f, 0.00760728f, 0.09765123f, -0.01913111f, 0.04761229f, 0.25662616f, -0.23120758f, 
    -0.48424655f, -0.44133204f, -0.13251470f, 0.11593316f, -0.24725878f, 0.26114783f, -0.02085214f, -0.02477285f, 
    -0.16424543f, 0.16828303f, 0.06409600f, -0.11092665f, 0.26727316f, -0.00144506f, -0.03835990f, 0.21978046f, 
    0.01068203f, 0.03791548f, -0.28022686f, -0.08543146f, -0.23663634f, 0.11292541f, 0.06508608f, -0.50843370f, 
    -0.11186241f, 0.16046615f, 0.09962349f, 0.10552815f, -0.02429084f, -0.03636158f, 0.16376139f, -0.55136764f, 
    -0.00997095f, -0.07567874f, 0.02693199f, 0.02852193f, 0.01143194f, 0.03514388f, -0.16434206f, 0.03317779f, 
    0.29181537f, 0.08301047f, 0.02840279f, -0.28282818f, -0.02140195f, 0.22409745f, -0.35462570f, 0.11163726f, 
    -0.07056208f, 0.02582847f, 0.04771886f, 0.00303242f, 0.03823526f, -0.48329797f, -0.00509064f, 0.03559380f, 
    -0.02552480f, -0.00562543f, 0.08988719f, 0.04986833f, 0.01845498f, -0.33234224f, 0.06796146f, -0.02205510f, 
    0.12999870f, 0.11824200f, -0.08112194f, -0.08989068f, 0.03209014f, -0.06425340f, 0.24560972f, -0.07075968f, 
    0.02184606f, 0.17116390f, 0.15484516f, 0.16724010f, -0.38747993f, 0.03437022f, 0.13069424f, 0.39261901f, 
    0.03824914f, 0.15345724f, 0.03789006f, -0.21950334f, 0.04790496f, -0.56131095f, 0.12813668f, -0.34227878f, 
    0.26153344f, -0.20494634f, 0.12038647f, 0.13326660f, 0.03639025f, -0.03693760f, 0.06645599f, -0.28461200f, 
    -0.26320100f, 0.20031729f, -0.03806811f, -0.32233679f, 0.07813241f, 0.01207355f, 0.13754804f, -0.03043318f, 
    0.10988370f, 0.07541753f, -0.06224350f, 0.05989667f, -0.20447811f, -0.01313844f, 0.12952094f, -0.09375151f, 
    -0.08157183f, 0.12111161f, -0.51909274f, 0.17516470f, 0.04836092f, 0.05331016f, 0.02914678f, 0.05345261f, 
    -0.04591275f, 0.02163422f, 0.07552426f, 0.18495847f, 0.05237734f, 0.02232580f, 0.19838090f, -0.00268730f, 
    -0.14398567f, 0.10468886f, -0.09942067f, -0.23337695f, -0.03521417f, -0.06708129f, 0.05931865f, 0.19965126f, 
    -0.43841872f, 0.18811311f, 0.02294612f, -0.10156221f, -0.38220459f, 0.04602696f, 0.03174420f, 0.03820778f, 
    0.10809207f, 0.30572689f, -0.20322135f, 0.20023367f, -0.00732613f, -0.05186939f, -0.18276966f, -0.05902060f, 
    -0.05054358f, -0.18911207f, 0.05547303f, -0.43090844f, -0.51158410f, 0.07608998f, -0.14711200f, 0.15041234f, 
    -0.07760578f, -0.02119472f, 0.29450086f, -0.51596308f, -0.21394655f, 0.03413922f, -0.38937941f, -0.04507754f, 
    -0.06701932f, 0.04723068f, -0.08602320f, -0.12926263f, 0.04674824f, -0.11652030f, 0.14947961f, 0.12347368f, 
    0.14325912f, -0.07518018f, -0.09512348f, 0.01189433f, -0.23618163f, -0.36743030f, 0.17139034f, 0.01047080f, 
    0.07201069f, -0.06039308f, 0.19834487f, -0.01752277f, 0.06809871f, -0.16390209f, -0.05626377f, 0.03065344f, 
    0.28284839f, -0.09968814f, -0.04918673f, -0.06527380f, 0.00176933f, 0.03276554f, 0.10974997f, 0.09726229f, 
    -0.25311512f, -0.04054128f, 0.26579037f, -0.11453932f, -0.07292118f, 0.03890900f, 0.06585838f, 0.16595019f, 
    0.00498104f, 0.20565726f, -0.14216323f, 0.19668746f, -0.07262622f, -0.34910706f, -0.16126594f, 0.34751239f, 
    -0.22579776f, 0.04235953f, -0.12484414f, -0.02692322f, -0.03754073f, -0.03835851f, 0.03711459f, -0.04265834f, 
    0.04476652f, 0.20161477f, 0.05944616f, 0.03378931f, 0.04394006f, -0.08642968f, -0.07482501f, 0.02334735f, 
    0.07144480f, 0.01781373f, 0.16093153f, -0.00819146f, 0.20735781f, 0.03566393f, -0.03541141f, -0.38791296f, 
    0.05912638f, 0.14001341f, 0.09987058f, 0.00294372f, 0.05525102f, 0.18807036f, 0.00030097f, 0.05469928f, 
    0.03539620f, -0.16554686f, 0.07859499f, -0.00400236f, -0.08224069f, -0.01325190f, -0.29469007f, 0.12837106f, 
    -0.13011949f, -0.06374070f, 0.01245268f, 0.05979491f, -0.02189322f, 0.01493522f, 0.05028896f, 0.12936331f, 
    0.22865745f, -0.05368207f, 0.05103349f, -0.04010117f, 0.16502821f, 0.01406737f, -0.09056300f, -0.02498775f, 
    -0.02148994f, 0.04490324f, 0.29634666f, 0.08863624f, -0.25216377f, -0.09357152f, -0.57445192f, -0.07301401f, 
    0.03006785f, -0.07303061f, 0.08528689f, 0.02091049f, -0.05852355f, 0.04702840f, -0.53818589f, 0.04038545f, 
    -0.01143513f, 0.07466768f, 0.03515974f, -0.00526374f, -0.41121411f, -0.03874667f, 0.34633330f, 0.07449728f, 
    -0.34016392f, -0.02819026f, -0.01310042f, 0.16651055f, 0.01068310f, 0.20626128f, 0.08289902f, -0.51684827f, 
    -0.10951354f, -0.06023568f, 0.34346130f, -0.15829495f, 0.01413433f, -0.17574087f, 0.06508093f, 0.01395643f, 
    -0.21442336f, 0.05814967f, -0.22507016f, -0.05747455f, -0.13019963f, 0.15126267f, 0.02859987f, 0.01284623f, 
    -0.16493469f, -0.14482524f, 0.14657590f, -0.35077786f, -0.03841719f, -0.03758721f, -0.30465275f, 0.01717972f, 
    0.13029037f, 0.46491918f, -0.23308432f, 0.06991426f, -0.26057026f, -0.03556393f, 0.19300885f, 0.02308687f, 
    0.00981487f, 0.05990359f, -0.01508020f, -0.02695024f, 0.00714329f, 0.05407209f, 0.40036798f, -0.23494282f, 
    -0.17238584f, 0.08833190f, 0.10484368f, 0.16939430f, 0.00666588f, 0.08381808f, -0.39166364f, 0.11334082f, 
    0.09751609f, 0.02126480f, 0.14263150f, 0.19130148f, 0.01743736f, -0.01390258f, -0.24133335f, -0.00370138f, 
    -0.25201827f, 0.05017846f, -0.17614171f, -0.04545610f, 0.12082300f, -0.02427791f, 0.05404181f, -0.04338146f, 
    -0.00158462f, -0.32736519f, 0.06261371f, -0.13470846f, 0.26984137f, -0.59256405f, -0.02302711f, -0.03529336f, 
    0.07066618f, -0.07495058f, 0.06051120f, -0.11875667f, 0.04010209f, -0.00443125f, 0.08124119f, 0.10719041f, 
    0.22925229f, 0.18297091f, 0.08830117f, -0.29519716f, 0.23673306f, 0.22604561f, -0.04962710f, -0.18711224f, 
    0.10268631f, -0.43916526f, -0.04927327f, -0.10151444f, -0.23571196f, 0.01671347f, -0.07982238f, -0.33330998f, 
    0.22422567f, 0.17322153f, 0.11684005f, 0.18768662f, 0.19916604f, 0.10548663f, -0.15305714f, 0.17422672f, 
    0.14161123f, -0.12243913f, -0.42098987f, 0.04718290f, 0.20154755f, 0.03886728f, -0.04470401f, 0.14977477f, 
    0.03924631f, 0.02082288f, -0.36446685f, -0.06490574f, 0.02595970f, -0.02465459f, 0.09318559f, -0.04425682f, 
    -0.27732611f, 0.05356157f, 0.05977266f, 0.05751975f, -0.07065266f, 0.05309152f, 0.10426866f, -0.14006606f, 
    0.07332756f, -0.07156423f, -0.31915992f, 0.24019183f, 0.19363618f, 0.21998180f, 0.11440837f, -0.09277604f, 
    0.01011415f, -0.06160305f, -0.22327590f, -0.05786581f, 0.04954796f, -0.10648576f, 0.04962646f, 0.04203124f, 
    -0.25334319f, -0.43729606f, -0.64163208f, 0.18377961f, 0.06729992f, -0.06474438f, 0.33775002f, 0.06848834f, 
    0.14921823f, -0.54089487f, 0.32643843f, -0.20781437f, 0.05840874f, 0.01761190f, 0.10627844f, -0.06640157f, 
    0.05291533f, 0.16346760f, -0.24932475f, -0.01198057f, 0.01722137f, 0.06669986f, 0.11311822f, -0.01152024f, 
    0.16256629f, 0.06192669f, 0.01012426f, 0.14001046f, 0.06374618f, 0.26273048f, 0.14316891f, 0.14182842f, 
    0.08599623f, -0.36006537f, 0.17846906f, 0.18436535f, -0.05648005f, 0.02291473f, -0.24566735f, 0.05343881f, 
    0.00545660f, 0.04536580f, 0.18618174f, 0.07791959f, -0.07449409f, 0.00121255f, -0.01970217f, 0.00533728f, 
    -0.01157759f, 0.08762457f, 0.04756503f, 0.06264862f, -0.18443564f, -0.31168315f, -0.01122038f, -0.04648058f, 
    -0.06476662f, -0.02915068f, -0.03117221f, 0.22187634f, 0.03671367f, -0.01768236f, -0.42346618f, -0.23228508f, 
    0.06361932f, -0.01660949f, -0.15435755f, 0.23667742f, -0.32110989f, 0.15192834f, -0.06032560f, 0.03335051f, 
    -0.23838928f, -0.14777726f, -0.06878921f, 0.09928217f, -0.01617387f, -0.08652599f, 0.07817183f, -0.06857575f, 
    -0.62792474f, -0.35027304f, -0.10545112f, -0.74108016f, -0.06679074f, -0.04428679f, 0.05455995f, -0.12290042f, 
    0.02604959f, 0.04680327f, -0.36935252f, -0.09964184f, -0.45552814f, 0.06196633f, 0.22410266f, 0.12022553f, 
    0.04146448f, 0.04315893f, -0.21589762f, -0.11235610f, 0.13537434f, -0.02964474f, -0.20918751f, -0.02788296f, 
    0.02972961f, -0.00926538f, -0.08733318f, 0.18367492f, 0.03373066f, -0.23928115f, 0.15990113f, -0.20591132f, 
    -0.28808773f, -0.04274311f, 0.21321280f, -0.61183149f, -0.35740075f, 0.02977350f, 0.00592894f, 0.03484000f, 
    0.15214692f, 0.02060563f, 0.15021409f, 0.01087836f, 0.23348990f, 0.02686147f, -0.00270399f, 0.03645442f, 
    0.23998733f, -0.02968724f, 0.04925798f, 0.20811504f, 0.00288074f, -0.00040851f, -0.17907567f, -0.09852121f, 
    -0.36242276f, 0.20732065f, -0.30402312f, 0.22182095f, 0.12095700f, -0.00586097f, 0.09821604f, -0.05487629f, 
    0.00768677f, -0.24270341f, -0.08208534f, -0.35725033f, 0.01310697f, 0.09383789f, 0.21144331f, -0.02649188f, 
    -0.22203924f, 0.19397905f, -0.13414806f, 0.03346981f, -0.05450070f, -0.19262573f, -0.27913976f, -0.11154151f, 
    -0.28902897f, 0.14835495f, -0.10209116f, 0.15638763f, -0.05059345f, 0.02205699f, -0.02665769f, -0.03474983f, 
    -0.28323945f, -0.26860729f, 0.24872836f, -0.07159124f, 0.21081181f, 0.04181496f, 0.14422756f, -0.03184676f, 
    -0.01898394f, 0.10995410f, -0.09340189f, 0.15364687f, -0.07374938f, 0.16942117f, -0.03792479f, -0.03765728f, 
    0.06133566f, 0.11645631f, -0.01531286f, 0.08579459f, -0.08486158f, -0.05752147f, -0.01647322f, 0.20621799f, 
    -0.29320571f, 0.19866759f, -0.34886277f, 0.34378949f, 0.18832569f, 0.09513615f, 0.05356935f, 0.12410191f, 
    -0.08234461f, -0.14760159f, 0.00237842f, -0.05803490f, -0.26686820f, -0.04670814f, -0.05603387f, -0.13166739f, 
    -0.17284320f, -0.32828003f, -0.23866621f, 0.03838364f, 0.13855767f, -0.37044013f, -0.23462783f, 0.13108572f, 
    -0.21570215f, -0.34700012f, 0.25209704f, -0.15690179f, 0.01855007f, -0.03710102f, -0.08337945f, 0.06118376f, 
    -0.01470396f, -0.02543001f, -0.23643591f, 0.15165402f, -0.03430885f, 0.07185553f, 0.08149878f, 0.00361719f, 
    0.15683581f, -0.03296966f, -0.06033399f, 0.02271025f, -0.00376139f, -0.21403348f, -0.05651455f, 0.00880531f, 
    0.00411407f, 0.03310172f, 0.14820983f, 0.14634041f, 0.11848018f, 0.21697098f, -0.38807461f, -0.03789613f, 
    0.33801582f, -0.09542040f, 0.03396256f, -0.07244456f, -0.37405372f, 0.04154449f, 0.05893007f, 0.07082205f, 
    -0.29817972f, 0.23749138f, 0.21033505f, 0.04620947f, -0.02446364f, -0.07684950f, -0.19343290f, 0.03008817f, 
    0.16614100f, 0.23168439f, -0.19423968f, -0.03263357f, -0.09495346f, 0.02954079f, -0.30370614f, 0.16012037f, 
    -0.05825292f, 0.18076061f, -0.33520281f, -0.20733753f, 0.03226057f, 0.12797214f, -0.21081805f, -0.03943160f, 
    0.25303459f, -0.07274242f, 0.18810828f, -0.30131999f, 0.03885686f, -0.12469595f, -0.25645086f, -0.11262199f, 
    -0.11440564f, 0.29300150f, -0.17562313f, 0.19449160f, -0.00676429f, -0.02196342f, -0.13312609f, -0.03316052f, 
    -0.12563321f, -0.39421806f, 0.15580221f, -0.02127420f, -0.18988810f, -0.04269206f, -0.29663816f, -0.27924630f, 
    -0.01236740f, -0.05164278f, 0.07190273f, -0.37313494f, -0.38268274f, -0.17071633f, -0.04569416f, -0.04604070f, 
    -0.02137604f, -0.38535982f, -0.02443156f, -0.48140648f, -0.07244786f, -0.05641196f, -0.27137873f, 0.16012567f, 
    -0.08868469f, 0.20659579f, 0.16024813f, 0.11512797f, 0.19963969f, -0.29481313f, -0.02996300f, -0.14695184f, 
    -0.32164493f, 0.18818651f, 0.06780037f, 0.21325855f, -0.04526917f, 0.06586593f, -0.07463694f, -0.05042485f, 
    -0.13359441f, -0.27591711f, 0.02177203f, 0.05700643f, -0.08720806f, 0.17877854f, 0.04651922f, -0.18051371f, 
    0.16514394f, -0.01368720f, -0.15425582f, 0.14218606f, -0.23258173f, -0.05709198f, -0.22341131f, -0.07495651f, 
    -0.00810672f, 0.00057495f, -0.43761757f, 0.16276230f, 0.21348082f, 0.07964014f, -0.05904376f, 0.04139729f, 
    0.30313393f, 0.06906091f, -0.01162559f, 0.10781489f, -0.03500407f, 0.08349004f, -0.24966851f, -0.05257519f, 
    -0.10616354f, 0.06404803f, -0.25496465f, -0.13959338f, 0.10379586f, -0.01906648f, -0.07657184f, 0.07908350f, 
    -0.28838938f, -0.05018374f, -0.30494770f, -0.01110708f, -0.05872488f, 0.07422597f, -0.07442683f, 0.03912039f, 
    0.05091012f, -0.23699117f, -0.08012902f, 0.28752196f, 0.02087097f, -0.05416742f, -0.31676924f, -0.07343294f, 
    -0.20636950f, 0.33127418f, -0.14948852f, -0.45051232f, 0.31592584f, 0.06740107f, 0.11639681f, -0.17818847f, 
    0.07526269f, 0.15714984f, 0.22555891f, 0.11374055f, -0.08323839f, 0.22637814f, -0.26359376f, -0.16181867f, 
    -0.14285870f, 0.18022598f, -0.02054599f, -0.04869317f, -0.00864574f, -0.31709319f, 0.33699572f, 0.25307223f, 
    -0.35552463f, -0.12401789f, 0.03342353f, -0.12506561f, -0.08167002f, 0.02288255f, -0.51271909f, 0.02387280f, 
    -0.35961339f, -0.16542552f, 0.01434019f, 0.00744906f, 0.18446618f, -0.03580130f, 0.16222531f, -0.21818838f, 
    0.07401357f, 0.30588943f, -0.00160003f, 0.03157936f, -0.07578744f, 0.25522861f, 0.00799807f, -0.07567856f, 
    0.06433336f, 0.28760758f, 0.01961661f, 0.02916248f, -0.02100720f, -0.01379796f, 0.11226335f, -0.23109584f, 
    -0.29033488f, -0.27530751f, 0.11261249f, -0.02311364f, -0.15779664f, 0.23227863f, -0.06693983f, -0.09314636f, 
    0.00754473f, -0.01054146f, -0.06314618f, -0.41167194f, 0.08444893f, 0.01476182f, -0.01785293f, 0.21547745f, 
    -0.21821053f, -0.06195759f, -0.08375426f, -0.04193187f, -0.32233551f, 0.03914008f, 0.19890773f, 0.05810261f, 
    -0.16939220f, 0.07284904f, -0.08607578f, 0.10297024f, 0.11102201f, -0.04265421f, -0.04171090f, -0.11260311f, 
    0.00943756f, 0.07916248f, 0.08207252f, 0.00861685f, 0.26061407f, -0.05150941f, -0.15252748f, -0.00685465f, 
    0.45334390f, -0.03458238f, -0.00624963f, 0.04850517f, -0.08904002f, -0.09378685f, 0.14057828f, -0.22625905f, 
    -0.08139172f, 0.02466211f, 0.24848224f, -0.17770670f, -0.05795850f, -0.10048854f, -0.27037263f, 0.04735125f, 
    0.05532880f, 0.03969435f, 0.10166486f, 0.01409989f, 0.24801615f, -0.29540625f, -0.02830485f, -0.02793790f, 
    0.03911231f, -0.02949962f, -0.21329348f, 0.11789504f, -0.05873191f, -0.07224628f, -0.14654188f, 0.11999219f, 
    0.03016877f, -0.43532270f, 0.21562210f, 0.00203999f, -0.08869462f, -0.00168526f, 0.18238197f, -0.42672455f, 
    -0.06856345f, 0.09357478f, 0.21881704f, -0.74327922f, 0.05221817f, 0.24147545f, -0.26490304f, 0.35494095f, 
    -0.07210535f, -0.51627463f, 0.05529476f, -0.26793966f, -0.06979002f, 0.18134406f, -0.06724643f, 0.38714793f, 
    0.23567404f, -0.12752607f, -0.29748499f, -0.02638302f, 0.05101527f, 0.07750080f, 0.15359791f, 0.03988940f, 
    0.20949046f, -0.08628208f, 0.16397561f, -0.07952583f, -0.49178138f, 0.00244718f, 0.11263839f, 0.20534681f, 
    -0.03474667f, -0.18940660f, 0.12541802f, 0.19292104f, 0.27952436f, 0.08774569f, 0.05151284f, 0.05915458f, 
    -0.06464051f, 0.13349555f, 0.01543147f, -0.18693411f, 0.08782402f, 0.06906033f, 0.24396555f, 0.03782385f, 
    -0.12807675f, -0.29933500f, 0.18620741f, -0.11972768f, -0.23314233f, -0.23700094f, 0.06234803f, 0.08105805f, 
    0.22199756f, -0.00948503f, -0.06000299f, 0.18712448f, -0.07494590f, 0.08114293f, -0.04662877f, -0.07491045f, 
    0.22367471f, -0.36917591f, -0.16831701f, 0.24473432f, 0.20704387f, -0.07549761f, 0.31285954f, 0.01568874f, 
    -0.22281317f, -0.26397970f, -0.09904674f, -0.17893524f, -0.45280528f, 0.03282475f, 0.00589786f, -0.08811220f, 
    -0.00355341f, 0.02707972f, 0.20722307f, -0.46110317f, 0.16660456f, 0.01342071f, -0.06333516f, 0.02822898f, 
    0.04711151f, -0.01965896f, 0.05808320f, -0.40635279f, 0.03744893f, 0.20843764f, -0.24622431f, 0.10022025f, 
    -0.17392692f, 0.01972281f, -0.10987216f, 0.12733825f, 0.23060018f, 0.05979398f, 0.15246177f, 0.01717387f, 
    -0.17175816f, 0.06144685f, 0.02687813f, 0.02178645f, -0.22445872f, -0.45191994f, -0.03663291f, 0.01099273f, 
    0.18008362f, 0.08914600f, 0.11845133f, 0.09285352f, 0.05152301f, -0.06716444f, 0.21350758f, -0.00972146f, 
    -0.03705839f, -0.22201186f, -0.18152675f, 0.16915672f, 0.31177440f, 0.01560888f, -0.08613691f, -0.22663496f, 
    -0.01113594f, -0.04948484f, -0.07541163f, -0.08538613f, -0.02202238f, -0.16219440f, 0.12337768f, -0.21917440f, 
    -0.07413290f, -0.30724135f, 0.26882204f, 0.22881591f, -0.06699945f, -0.04062465f, -0.17559105f, -0.22943854f, 
    0.18698975f, -0.23975216f, 0.22272116f, 0.06053499f, -0.05490178f, -0.06818575f, 0.18188012f, 0.02601627f, 
    0.07548624f, -0.40972057f, -0.50189811f, 0.03487245f, -0.42969018f, -0.03950539f, -0.00807492f, 0.04760704f, 
    -0.06395675f, 0.06981618f, 0.12220107f, -0.42165107f, -0.37631387f, -0.08638623f, -0.01566184f, -0.00236428f, 
    -0.01816507f, 0.09340359f, -0.04893465f, -0.23250629f, -0.03128206f, -0.02252388f, -0.18164332f, 0.21736798f, 
    0.26954177f, -0.35090178f, -0.08678037f, -0.05876634f, -0.05892455f, -0.11660880f, 0.00731345f, -0.10317782f, 
    0.25139117f, -0.02673238f, -0.01067742f, 0.12357206f, 0.06752422f, -0.11039420f, -0.01629235f, 0.17195836f, 
    -0.00580830f, -0.40072003f, -0.37456241f, -0.31416595f, 0.02223541f, 0.14409074f, 0.09270906f, 0.17242669f, 
    0.12990762f, -0.14045863f, 0.14787994f, 0.18084365f, -0.41730610f, 0.07695600f, -0.22401193f, 0.17865855f, 
    0.00155130f, -0.00487558f, 0.14210232f, 0.10008150f, -0.20180492f, 0.04115178f, -0.33528331f, -0.06677161f, 
    -0.53681117f, 0.07795926f, 0.00377854f, 0.06779709f, -0.09649589f, -0.24947099f, 0.09023532f, 0.27752441f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03012650f, -0.05047661f, -0.08944228f, 0.00005315f, 0.04608877f, -0.08784845f, 0.08051106f, -0.14315584f, 
    -0.07208533f, 0.07147445f, 0.15051979f, -0.04468847f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
