#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.31771171f, -0.18213400f, -0.50991470f, 0.02435515f, -0.44796607f, -1.48641145f, 0.74089080f, 0.30923796f, 
    1.38055646f, 0.00388686f, 0.44275251f, -0.28422698f, -1.33295727f, -0.78807729f, -1.15876639f, -0.66057855f, 
    -0.58493567f, -0.53872931f, 0.12219752f, 0.83687377f, 0.20423545f, 0.63854671f, 0.75501668f, 1.06139302f, 
    -0.36098769f, -0.35243216f, 0.01958242f, 1.11571586f, 1.27152193f, -0.53804785f, -0.12851505f, -1.04827893f, 
    -0.17930420f, 0.09394108f, 0.58829403f, 0.45801938f, -1.44730210f, -0.84921819f, -0.36472756f, 0.56985229f, 
    1.41686082f, -0.57128888f, -0.86594361f, -0.86008239f, -0.45577696f, 0.44583273f, 0.26863855f, 0.57551831f, 
    0.66957927f, 0.37791488f, 0.84697181f, 0.40950716f, 0.55402243f, -0.23178931f, 0.62655187f, 0.24271174f, 
    0.86158228f, 0.58613032f, -0.62241602f, -0.55447495f, -0.48958328f, 0.88641781f, -1.08965862f, -1.25133657f, 
    0.22443382f, 0.98751360f, -0.79028445f, -0.42250440f, -0.09528831f, 0.82720917f, -0.74347031f, -1.02202892f, 
    -0.66677397f, 0.47652450f, -0.11933169f, -0.30699584f, 0.06714962f, 0.23689343f, -0.70666158f, 1.40102673f, 
    -0.90109283f, -0.89453214f, 0.90557057f, 0.10325041f, -0.04394205f, 0.25768250f, -0.08061930f, 0.88795966f, 
    0.80933487f, 0.03900072f, -1.56342089f, -1.33895969f, -1.13885403f, -0.52382141f, 0.08622696f, 0.21854702f, 
    0.42755502f, 0.08506428f, -0.29916632f, 1.23855543f, 1.29644465f, -0.33744699f, 0.01400151f, -0.09054355f, 
    -0.75641549f, 0.13350661f, 0.07598504f, 0.16107650f, 1.02451909f, 0.66467226f, 0.19241026f, -0.73955870f, 
    0.00961927f, 0.39772373f, 0.08484373f, -0.78796411f, -0.74638700f, -0.46810469f, -0.74055344f, 1.47073233f, 
    0.12360537f, -0.58415872f, -0.22789137f, -0.27179638f, -0.73448050f, 0.82416898f, 0.56999195f, -1.12579787f, 
    0.22085130f, 0.37004742f, -1.36067259f, -1.70713019f, 0.63065106f, -0.30053765f, 0.10392471f, -0.15163532f, 
    0.30320635f, -0.21287075f, -0.99870503f, -0.79686379f, 0.31316838f, 0.58505243f, 0.73689640f, 0.98288780f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.19841172f, -0.05791130f, 0.44332647f, 0.53981644f, -0.15558523f, 0.91465586f, 0.22288726f, 0.40189153f, 
    0.50238568f, 0.05455000f, 1.03185081f, 1.04145443f, 0.24263829f, -0.13979883f, 0.50628877f, 0.54399556f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.24108715f, 0.90272260f, 0.01301515f, -0.08319137f, -0.02300452f, 0.02573171f, -0.10863528f, -0.06173091f, 
    0.00276396f, -0.03461507f, 0.41678143f, 0.38939551f, -0.34907481f, 0.05099346f, -0.14693645f, -0.13851413f, 
    0.00478720f, 0.04792117f, -0.41255137f, -0.39305979f, -0.53023362f, 0.36899814f, -0.53254741f, -0.39028680f, 
    0.13107559f, 0.00082693f, -0.01634458f, -0.37475660f, -0.57075852f, -0.25200358f, -0.17602183f, -0.22302218f, 
    0.06377579f, 0.27163428f, 0.14257240f, -0.13512830f, 1.01001310f, -0.08025354f, -0.39607289f, 0.24369285f, 
    0.02027017f, 0.30665782f, -0.05968495f, 0.20940234f, 0.29727721f, 0.19066852f, -0.16186042f, -0.02765753f, 
    0.18568169f, -0.09196191f, -0.41186786f, 0.12928641f, 0.46512905f, 0.12575942f, -0.59534132f, -0.01305593f, 
    0.38754332f, 0.01738416f, 0.01780706f, -0.10208793f, -0.08814222f, 0.08831231f, 0.03596943f, 0.24556848f, 
    0.44791681f, 0.50771546f, 0.01328234f, -0.13847156f, -0.45052797f, 0.09433238f, -0.07488205f, 0.04321203f, 
    -0.45447683f, -0.31182083f, -0.18431199f, -0.18994763f, -0.17878129f, 0.06405488f, -0.06497381f, 0.01211833f, 
    0.21710713f, 0.24976403f, -0.15505743f, 0.00420116f, 0.02776648f, 0.10026242f, 0.21098746f, -0.10877945f, 
    0.32681409f, 0.52020276f, 0.60671461f, -0.11952236f, -0.14371875f, 0.36143523f, 0.30475593f, 0.12368976f, 
    -0.07987517f, 0.12399700f, 0.18412645f, -0.33266094f, -0.73624343f, -0.32282120f, -0.15106328f, -0.19661017f, 
    -0.46130711f, 0.02453922f, 0.24315830f, 0.04376449f, -0.42173043f, -0.30235916f, 0.17514202f, 0.24264884f, 
    -0.39675081f, -0.22457339f, 0.10641486f, -0.17312157f, 0.25427377f, 0.11034528f, 0.41358668f, -0.19062637f, 
    0.16248366f, -0.14217991f, -0.06100874f, 0.23214170f, -0.07752916f, -0.21115117f, -0.17245859f, 0.46433860f, 
    0.05122039f, 0.04827988f, -0.01358471f, -0.34101287f, 0.02404794f, -0.13309729f, -0.00013669f, 0.15651463f, 
    0.15389669f, 0.34296578f, -0.18579230f, -0.05178426f, -0.05247461f, -0.08618002f, -0.07029399f, 0.10710876f, 
    -0.39700666f, -0.77474689f, 0.80604845f, -0.20857540f, -0.00829236f, -0.04239585f, 0.16654412f, 0.16120356f, 
    0.16467178f, 0.03566551f, 0.17926851f, 0.11824766f, 0.13672486f, -0.18328364f, -0.08971782f, 0.34954405f, 
    0.22379763f, 0.13914745f, 0.14649124f, 0.01913897f, 0.00521532f, -0.17534657f, -0.18843496f, 0.04784003f, 
    -0.14927433f, -0.18589102f, 0.06343509f, 0.26332951f, 0.43404341f, 0.23522492f, -0.15791710f, -0.08731475f, 
    0.06345257f, -0.10482459f, 0.24972008f, 0.08186759f, -0.15128830f, -0.82758021f, -0.33684865f, -0.01289398f, 
    -0.01330221f, -0.18580759f, -0.28286472f, -0.40525743f, -0.23563519f, 0.14805377f, 0.13767596f, 0.02308122f, 
    -0.14879985f, -0.14531824f, -0.11146867f, 0.05303551f, 0.05448466f, 0.09935303f, 0.03413204f, 0.03733615f, 
    0.09428569f, -0.11020476f, -0.18283848f, -0.20255452f, -0.16842708f, -0.03736128f, 0.12400295f, -0.27326784f, 
    -0.30639389f, 0.84764671f, 0.05772929f, -0.29996902f, -0.07922115f, 0.09914559f, 0.05512122f, -0.00492898f, 
    0.56360143f, -0.36336249f, 0.18150267f, -0.05602965f, -0.18096384f, -0.03519052f, -0.36628208f, -0.12686735f, 
    0.43641180f, 0.38915595f, -0.00792502f, -0.19023596f, 0.40127507f, 0.15465510f, 0.11773045f, 0.31326094f, 
    0.14116172f, 0.37409177f, 0.45424029f, -1.21751678f, -1.27067018f, -0.07067417f, -0.16785194f, 0.18584061f, 
    -0.02278373f, 0.00936167f, 0.02552844f, 0.24978419f, 0.30739981f, -0.05767313f, 0.04608645f, -0.03490486f, 
    -0.08898447f, 0.04088185f, 0.13242488f, -0.02864843f, 0.08998076f, 0.22209103f, 0.07910791f, 0.21821441f, 
    -0.05510264f, 0.01103971f, -0.01056719f, -0.15942350f, 0.08020488f, -0.24431860f, -0.61029935f, 0.36671266f, 
    -0.23443580f, 0.09128167f, 0.20628823f, 0.18602012f, 0.04192933f, 0.03115722f, 0.04667043f, 0.09367485f, 
    0.61642164f, -0.22314380f, 0.27232668f, 0.04407583f, 0.10772017f, 0.03597581f, -0.15522690f, 0.17320468f, 
    -0.21856740f, 0.11345854f, 0.19410098f, 0.13781165f, -0.12189671f, 0.13474216f, 0.18099596f, 0.15072353f, 
    -0.06829852f, 0.04421454f, 0.06149707f, 0.04359796f, -0.01973995f, -0.04156640f, -0.04416262f, 0.06562509f, 
    -0.02656586f, 0.02798840f, -0.00999592f, 0.02994345f, -0.04790140f, -0.05590802f, 0.05971748f, -0.05127537f, 
    -0.05449219f, 0.00976567f, 0.04244018f, -0.02281748f, -0.03698307f, -0.00428443f, 0.04814431f, 0.07039300f, 
    -0.05746790f, -0.00949788f, 0.03134500f, 0.00235817f, 0.05642713f, -0.07750577f, -0.02341574f, -0.03413066f, 
    0.06381001f, 0.01390257f, 0.04339606f, 0.00991329f, 0.05909643f, 0.02003764f, -0.01225062f, -0.02312287f, 
    0.05824967f, 0.03675341f, -0.03010936f, -0.07815247f, -0.07709593f, -0.07129850f, -0.00849346f, -0.04279833f, 
    -0.05442067f, -0.05234565f, 0.06970185f, -0.01906401f, -0.04008182f, -0.02071203f, -0.08335626f, 0.08693490f, 
    -0.08116481f, 0.05933009f, -0.06571745f, -0.05396378f, -0.04444561f, -0.07588110f, -0.06998413f, 0.05807324f, 
    0.02780738f, -0.08529615f, 0.00880627f, 0.01290395f, 0.01478051f, -0.09098080f, 0.06920337f, 0.06377494f, 
    0.06766640f, -0.03091206f, -0.02492387f, -0.05370448f, -0.00268332f, 0.04168450f, -0.08044177f, -0.04093321f, 
    -0.03433729f, 0.00117275f, -0.06169733f, 0.00264427f, -0.01419689f, 0.03287761f, 0.05525900f, -0.07060263f, 
    -0.01485399f, 0.07897673f, -0.08697499f, 0.04259063f, -0.03464331f, -0.03061950f, -0.07319160f, -0.02781335f, 
    0.06911514f, -0.03343942f, -0.01547852f, -0.02327795f, 0.03877540f, -0.05531308f, -0.04890848f, -0.06737879f, 
    -0.00726976f, -0.08218329f, -0.09212703f, 0.04747145f, -0.06974560f, 0.06148414f, -0.07533880f, 0.01720539f, 
    0.03652667f, 0.01505022f, 0.01133009f, 0.03651139f, 0.03514936f, 0.01871737f, -0.06829020f, -0.09315252f, 
    0.03246277f, 0.04148321f, -0.06107560f, -0.01339888f, 0.03412005f, 0.03660425f, -0.00430042f, 0.03663965f, 
    -0.06529059f, -0.08357152f, 0.04160100f, 0.03299717f, -0.08169439f, -0.09252225f, -0.04946137f, 0.01588707f, 
    -0.00874920f, 0.06103862f, 0.03230116f, -0.06119135f, -0.05521800f, 0.03265722f, 0.03092248f, -0.09372146f, 
    -0.70700705f, -0.12593479f, -0.30037746f, -0.14118145f, -0.13365678f, 0.13761035f, 0.07375473f, 0.26627609f, 
    0.02210665f, -0.23678835f, -0.00335428f, -0.01377173f, 0.03967851f, 0.19286293f, -0.09638635f, 0.00980859f, 
    0.14556798f, -0.13013786f, 0.02397416f, -0.01208340f, 0.01762597f, 0.05374530f, -0.07550567f, -0.12725087f, 
    -0.10348243f, -0.39567754f, -0.20159844f, -0.62383658f, -0.24088076f, -0.04106247f, 0.02175527f, -0.15713409f, 
    0.07088740f, 0.08421151f, -0.05426836f, 0.07618681f, -0.37125000f, 0.26280844f, 0.10347608f, -0.03464532f, 
    -0.18521160f, -0.18159688f, 0.11651331f, -0.42102408f, -0.59320831f, 0.15451230f, 0.04799984f, 0.36333796f, 
    0.14823075f, -0.00604212f, -0.07108343f, -0.02613093f, 0.03540440f, 0.32342157f, -0.11851613f, 0.04966552f, 
    0.20028479f, 0.07036744f, -0.16130242f, 0.09067462f, 0.08651096f, 0.20455229f, 0.01071341f, 0.24622399f, 
    0.15989073f, -0.39838639f, 0.23521456f, -0.19725515f, 0.24440226f, -0.04325193f, -0.14809477f, 0.15942465f, 
    -0.30589685f, 0.14670892f, 0.46000341f, -0.07067089f, 0.02239965f, -0.00790588f, 0.43274242f, 0.01494342f, 
    0.35120410f, 0.19568029f, -0.01414936f, 0.22565264f, -0.05556798f, 0.23119470f, 0.36444813f, 0.15588266f, 
    -0.13958016f, 0.38989362f, 0.56081516f, 0.48193663f, 0.04764561f, -0.15417318f, -0.04737880f, -0.02006265f, 
    0.02754182f, -0.02252932f, -0.19296382f, -0.63793761f, -0.13525118f, -0.11366340f, -0.02063646f, -0.07663278f, 
    0.09809124f, 0.17732698f, 0.28619936f, 0.01318902f, -0.11063349f, 0.23877613f, 0.13916393f, 0.09083234f, 
    -0.05634627f, 0.05430320f, -0.10424694f, 0.09323530f, 0.24251209f, 0.68475795f, -0.13224964f, -0.42351905f, 
    0.02761823f, -0.12088268f, -0.22180626f, 0.07791258f, 0.27640295f, -0.04354186f, 0.02852029f, -0.00043889f, 
    -0.54179585f, 0.15412019f, -0.17633922f, 0.00319694f, 0.07245896f, 0.19434112f, 0.10202688f, -0.68203092f, 
    -0.48950595f, 0.01288246f, 0.14873526f, 0.27557880f, -0.09400603f, 0.23855987f, 0.07549574f, 0.39643201f, 
    0.60779154f, 0.62372452f, 0.23221950f, -0.02243264f, 0.15102737f, 0.13864799f, 0.23874699f, 0.24433413f, 
    0.24287899f, 0.38700098f, 0.28519824f, 0.36387905f, 0.25219294f, 0.15682380f, 0.15051168f, -0.09904253f, 
    0.03010547f, -0.16804850f, 0.05185779f, -0.13774675f, -0.05744447f, 0.01002995f, -0.01008794f, -0.04363161f, 
    0.05547381f, -0.31578773f, -0.54243493f, -0.35610449f, -0.51913470f, -0.35161316f, -0.03822310f, -0.13222802f, 
    -0.13627717f, 0.10260189f, 0.19382994f, 0.03440347f, -0.18806735f, 0.06141937f, -0.35734510f, -0.13872316f, 
    -0.04709503f, -0.02217462f, 0.00813400f, -0.25444087f, -0.28013158f, -0.26096988f, -0.22647472f, -0.15930073f, 
    -0.25149855f, -0.06984238f, -0.16924345f, -0.07459372f, -0.07568259f, -0.18595454f, -0.31741238f, -0.20757766f, 
    0.12432260f, 0.13331048f, -0.00838069f, -0.09938314f, 0.18965611f, 0.09474418f, -0.28305593f, -0.14409958f, 
    0.20131978f, 0.51678139f, -0.00427971f, -0.01880118f, -0.07369255f, -0.20552352f, 0.13804421f, -0.06941681f, 
    -0.18587317f, -0.12143385f, 0.27706304f, -0.19092561f, 0.17254449f, -0.39094985f, -0.45242149f, 0.45593002f, 
    -0.17459397f, 0.05828833f, 0.00806087f, -0.07388406f, 0.02772161f, 0.10538422f, 0.01821382f, 0.08684733f, 
    0.56513405f, 0.32537258f, 0.12632760f, 0.22110884f, -0.35085019f, -0.00283055f, -0.18183638f, -0.23803923f, 
    0.03196071f, -0.12323064f, 0.14893739f, -0.50557637f, -0.83525860f, -0.17390352f, 0.09651133f, -0.10620457f, 
    0.05970543f, 0.07560927f, 0.21365985f, -0.04385740f, -0.02574015f, -0.52607912f, -0.04351790f, 0.14109030f, 
    -0.07771289f, 0.04814180f, -0.14069170f, -0.02808069f, -0.06526629f, 0.29808781f, 0.34734717f, -0.59105736f, 
    0.17946565f, 0.15364857f, 0.01901849f, -0.17380053f, 0.15403029f, -0.21301904f, 0.56357247f, 0.55170131f, 
    0.10217144f, -0.03735993f, 0.23026815f, 0.15490155f, 0.10536280f, 0.14826290f, -0.00107499f, 0.11298782f, 
    0.24893080f, 0.18538149f, -0.14012143f, 0.02147345f, -0.04545125f, 0.25608772f, 0.06955081f, 0.19974282f, 
    -0.51737177f, 0.13245341f, 0.05699853f, -0.24628659f, -0.29393163f, -0.41323888f, 0.00032872f, -0.16283792f, 
    0.15859143f, -0.26391712f, -0.32477567f, -0.24352208f, 0.03910993f, 0.00965248f, 0.34936279f, 0.33227095f, 
    0.17418963f, -0.09353657f, -0.09955673f, 0.00316670f, -0.33734941f, -0.22518843f, -0.20528683f, -0.17855987f, 
    -0.07380822f, -0.01529296f, -0.02680572f, 0.43948931f, -0.16236120f, 0.05563550f, -0.17502913f, 0.15861601f, 
    -0.01382887f, 0.05822685f, 0.21937536f, 0.11657311f, -0.65383142f, -0.00647883f, 0.05926263f, -0.13385454f, 
    0.33021712f, -0.08802452f, 0.03255829f, -0.22412090f, -0.09324487f, 0.11706166f, -0.07878596f, -0.10780445f, 
    -0.11825520f, 0.03133995f, -0.02413996f, -0.01513546f, 0.20686370f, 0.07483085f, -0.65008938f, 0.01788845f, 
    0.48807311f, 0.08718592f, 0.25848228f, -0.20116156f, 0.19878036f, 0.20226407f, 0.27273205f, -0.38291433f, 
    -0.02772733f, 0.16574235f, -0.10062860f, 0.27019197f, 0.07697345f, -0.02420416f, 0.06100420f, -0.28130245f, 
    -0.17335798f, -0.12476394f, 0.85529709f, -0.05304114f, 0.11757806f, -0.32607603f, -0.10796718f, -0.13440016f, 
    0.54909199f, -0.50615925f, -0.07803353f, -0.11911763f, -0.07497308f, 0.14591324f, 0.09674389f, 0.08496522f, 
    0.39514294f, 0.06300044f, -0.22248946f, -0.08868003f, -0.31308907f, -0.08030758f, 0.25854746f, 0.08982757f, 
    0.21589047f, 0.04901604f, -0.01060859f, 0.44965723f, -0.11020725f, -0.04344945f, -0.13483636f, -0.07230649f, 
    -0.15477669f, 0.05879556f, 0.28954658f, 0.09101620f, 0.00206128f, -0.11210282f, -0.24877064f, -0.00598135f, 
    -0.09980889f, -0.10202345f, -0.00050474f, 0.22829348f, 0.02507671f, -0.76891291f, 0.45143026f, 0.57698786f, 
    -0.11010206f, -0.07247267f, 0.17228867f, 0.29904211f, 0.11700350f, 0.37193716f, -0.16761275f, -0.18209651f, 
    0.39087534f, -0.10441705f, -0.16237636f, -0.04358907f, -0.02896217f, 0.20538726f, 0.19828600f, -0.14858656f, 
    -0.08307468f, -0.10667625f, 0.09092649f, 0.25881687f, 0.12391147f, 0.18039456f, 0.31560549f, 0.15827334f, 
    0.28529218f, 0.28972253f, 0.46365377f, 0.03941235f, 0.21415435f, -0.07496762f, -0.05173329f, -0.22319356f, 
    0.33479181f, 0.21391769f, -0.01058387f, -0.06882051f, -0.11240504f, -0.04231165f, -0.21441968f, 0.02616135f, 
    0.17162292f, 0.00639633f, 0.61479419f, -0.64164281f, -0.10903869f, -0.06904227f, -0.14240123f, -0.16491240f, 
    -0.01133415f, -0.04052190f, 0.11543803f, -0.32248917f, -0.70267671f, -0.87482733f, -0.13436535f, -0.22827297f, 
    0.10347210f, -0.17649364f, -0.02584006f, -0.01152633f, 0.00377626f, 0.04848374f, 0.84807450f, -0.05766754f, 
    0.00318517f, -0.12644081f, 0.26976314f, 0.26022071f, -0.19945799f, -0.05952945f, -0.42034656f, -0.35228273f, 
    -0.33460334f, -0.12762327f, -0.03086201f, 0.10269486f, -0.04758987f, 0.14005995f, -0.04978848f, -0.66267765f, 
    0.57437938f, 0.11664075f, -0.33687043f, 0.11645993f, 0.04725236f, -0.06058829f, 0.07000731f, -0.18420617f, 
    -0.31851161f, -0.20202209f, 0.02951774f, -0.26230326f, -0.14526109f, 0.04221288f, -0.02398576f, 0.11368173f, 
    -0.21030237f, -0.01644946f, 0.64096737f, -0.08789008f, 0.44486344f, 0.25155377f, 0.00616997f, 0.00371040f, 
    -0.04437700f, 0.24977830f, -0.21949081f, 0.09665360f, -0.03334478f, 0.13823409f, 0.22089998f, 0.23623301f, 
    -0.01060425f, 0.15465809f, 0.22905390f, 0.25332871f, 0.32203647f, -0.23611093f, -0.04230867f, -0.25639504f, 
    -0.03770969f, 0.15961236f, 0.03854368f, -0.33427399f, -0.39432409f, -0.25089931f, 0.06335965f, -0.23852791f, 
    0.27355117f, -0.03073894f, 0.03083039f, 0.07939300f, 0.07853916f, 0.26474357f, 0.05068097f, 0.14334248f, 
    0.10409343f, 0.00177491f, -0.00447909f, 0.12207723f, -0.00086781f, -0.38818750f, -0.36646351f, -0.07732733f, 
    -0.20615768f, 0.35547891f, 0.20993505f, 0.12560280f, -0.20858929f, 0.01516495f, 0.04038236f, 0.26607317f, 
    -0.12139475f, -0.03579151f, -0.00795959f, 0.08967815f, -0.06724059f, -0.01271197f, 0.01734382f, -0.43713450f, 
    -0.15172005f, 0.13087232f, -0.01641495f, -0.02206554f, -0.12537195f, 0.02271864f, 0.03127589f, 0.24169920f, 
    -0.05453977f, -0.08762002f, 0.05067243f, -0.07996252f, -0.05217434f, -0.02849264f, 0.01369653f, 0.03315039f, 
    -0.06241231f, 0.04976860f, -0.06773853f, -0.06059851f, -0.00821758f, 0.03486587f, -0.03059779f, 0.02554953f, 
    -0.00800567f, 0.07630315f, 0.05480424f, -0.08438068f, -0.01057686f, -0.01112198f, 0.06883256f, 0.06237720f, 
    0.00301029f, 0.05418136f, 0.05149502f, 0.00173893f, 0.00488321f, -0.09722774f, -0.02965524f, -0.05052539f, 
    0.03940607f, 0.05270876f, -0.08251070f, 0.06145358f, -0.07295466f, -0.00057632f, 0.02664043f, -0.07738294f, 
    0.00156266f, 0.05332713f, 0.05014937f, -0.08086958f, 0.04316875f, -0.08133610f, -0.04401723f, -0.05342090f, 
    -0.05832678f, 0.06829749f, 0.01653894f, -0.04427217f, 0.04858163f, -0.05831457f, -0.08306880f, 0.03947159f, 
    -0.05124490f, -0.05641658f, 0.01158227f, -0.00265477f, 0.00490216f, -0.09307285f, -0.07081022f, -0.03983692f, 
    0.00999896f, -0.01120432f, 0.05560576f, -0.00155617f, 0.04866966f, -0.06473371f, 0.02113333f, 0.05882416f, 
    0.01014817f, -0.07275327f, 0.03491971f, -0.02685902f, 0.02639243f, 0.02076006f, -0.09666423f, -0.02856453f, 
    -0.03432520f, -0.02865857f, 0.02228379f, 0.00825950f, -0.05179063f, -0.08895643f, -0.06828683f, -0.05570174f, 
    -0.07631869f, -0.02546686f, 0.02988738f, 0.01305338f, -0.03776731f, 0.05667114f, -0.10746369f, 0.01755448f, 
    -0.06476997f, -0.06290809f, -0.04640096f, -0.08080719f, 0.01409019f, -0.01350049f, 0.05372152f, -0.07249875f, 
    -0.05170565f, -0.02948246f, -0.04946307f, -0.05456503f, 0.03297700f, -0.07967244f, -0.04467841f, 0.00020452f, 
    0.06269434f, -0.03815459f, 0.00727463f, 0.05729524f, 0.01932546f, -0.07408356f, 0.00267942f, -0.00606354f, 
    -0.07452408f, -0.01402912f, -0.01796895f, 0.05905670f, -0.02526694f, 0.00440261f, -0.08255710f, -0.08635743f, 
    0.05038135f, -0.00490339f, -0.09629457f, -0.01209360f, 0.05774739f, -0.00276608f, -0.02409106f, -0.02280927f, 
    -0.07158680f, 0.05702446f, -0.05880406f, -0.01262561f, 0.03216924f, -0.08148343f, -0.01353574f, -0.00311814f, 
    -0.23466250f, -0.13486892f, 0.37819934f, -0.02045195f, -0.10046958f, -0.39010334f, -0.04838908f, -0.07269550f, 
    -0.05657754f, 0.25319898f, -0.04916633f, 0.55418539f, -0.10981604f, 0.09944178f, 0.17527881f, 0.22627637f, 
    0.12968998f, -0.10230368f, -0.74522293f, -0.38967639f, -0.22076061f, 0.17833623f, -0.33206868f, -0.09567597f, 
    0.01650736f, 0.07969542f, 0.06047152f, 0.10984645f, 0.40880534f, 0.01470631f, -0.09691519f, 0.00089127f, 
    -0.02260504f, 0.07967843f, 0.09433398f, -0.03299401f, -0.43858230f, -0.06131677f, 0.32341668f, -0.05978639f, 
    -0.06509475f, -0.43606550f, -0.03382085f, -0.07797474f, 0.15393242f, -0.07590537f, -0.06319390f, 0.43611670f, 
    0.14163014f, 0.03209950f, -0.03333053f, 0.10842544f, 0.25479615f, 0.23178887f, -0.26075315f, 0.65056926f, 
    0.79264832f, 0.07042470f, -0.02228786f, -0.26912156f, 0.01965192f, 0.25516775f, 0.31067398f, 0.09628271f, 
    -0.28767687f, 0.13791242f, -0.28896269f, 0.05660801f, -0.08567810f, -0.16316101f, 0.26170880f, 0.07022253f, 
    0.26554394f, 0.59278637f, 0.36355427f, -0.12029155f, -0.02349677f, -0.25157294f, -0.42211807f, 0.25816607f, 
    0.15483928f, -0.32460707f, -0.30925000f, -0.43381274f, -0.15019365f, -0.14851297f, -0.03310666f, 0.36207443f, 
    0.25085121f, 0.11669548f, -0.43144354f, 0.00527769f, 0.00367912f, 0.04210982f, -0.23808099f, -0.21379176f, 
    0.07247207f, 0.12141131f, 0.08517382f, 0.07163328f, 0.69197363f, -0.22602484f, -0.01267152f, 0.09007338f, 
    0.02686195f, -0.01143509f, 0.10698332f, 0.03791090f, -0.70388281f, 0.03558790f, -0.49871725f, -0.17763627f, 
    -0.30478308f, -0.13818197f, -0.03270258f, 0.03590612f, -0.16997959f, -0.72968370f, 0.52284402f, 0.17842481f, 
    -0.47545663f, -0.01959996f, -0.06849531f, -0.05103773f, -0.07278630f, 0.00377997f, -0.11005031f, -0.05954725f, 
    0.73547930f, 0.08686451f, -0.21178506f, -0.02997862f, -0.03283032f, -0.10745347f, 0.03368437f, -0.30892015f, 
    0.50381601f, -0.10721821f, -0.11662504f, -0.02653171f, -0.03828577f, 0.35205576f, 0.06224289f, 0.16500261f, 
    -0.46179166f, -0.01626807f, 0.20454495f, 0.33735514f, 0.22289667f, -0.19576696f, -0.06543494f, -0.11235648f, 
    0.08292883f, -0.13168915f, -0.59528798f, 0.10180745f, -0.18993112f, 0.06006314f, -0.24193044f, -0.00841914f, 
    0.08400240f, 0.49389374f, -0.26690191f, 0.11508777f, 0.13742414f, -0.32434344f, 0.39010301f, -0.26026034f, 
    -0.00299948f, 0.07409721f, 0.03995649f, -0.56440651f, 0.16502489f, -0.10659792f, -0.07083048f, -0.13778982f, 
    -0.24258566f, 0.07205000f, 0.04804546f, -0.26062006f, 0.12626508f, -0.17671493f, -0.17900324f, -0.11444110f, 
    0.25671259f, 0.23638026f, 0.31741241f, -0.01337094f, 0.05518407f, -0.07096426f, 0.35778281f, 0.01559677f, 
    0.08247508f, -0.14002602f, -0.23390014f, 0.26790127f, 0.07829012f, 0.05033066f, -0.23163594f, 0.21957856f, 
    -0.21498193f, 0.14283809f, -0.14851399f, -0.23114467f, 0.04456122f, 0.26790938f, -0.00920806f, 0.24805604f, 
    0.00615826f, -0.14808041f, 0.18415214f, -0.01460080f, 0.24037138f, 0.08795502f, 0.34275234f, 0.07989699f, 
    0.47820657f, 0.17228423f, -0.24090579f, 0.16704519f, 0.12638833f, -0.07272237f, 0.27413636f, -0.07200585f, 
    0.13517331f, -0.05681048f, -0.11785387f, -0.29091710f, 0.01399045f, -0.22206618f, -0.21508212f, -0.16557351f, 
    0.04573270f, -0.14662287f, 0.25728247f, -0.00494069f, 0.13856828f, 0.14596270f, 0.19494487f, 0.41241601f, 
    0.04774097f, 0.09475835f, -0.00998339f, -0.46165559f, 0.32342803f, 0.16355388f, -0.01095338f, 0.03413266f, 
    0.05816502f, 0.11929078f, 0.15385509f, -0.00700949f, -0.17022181f, 0.31856069f, 0.07670327f, -0.04624137f, 
    0.15503332f, -0.15180922f, -0.08314566f, 0.00515648f, -0.16654700f, 0.07405111f, -0.46047190f, -0.51023924f, 
    0.57347697f, -0.24846213f, 0.22561628f, -0.02486082f, 0.11437546f, 0.13591658f, -0.02996343f, 0.19214527f, 
    0.09433712f, -0.01446557f, 0.11423425f, -0.12615353f, -0.20399070f, -0.07495946f, 0.00284811f, -0.07323924f, 
    -0.41481560f, -0.29376942f, 0.15470642f, 0.19793500f, 0.10707121f, -0.14755110f, 0.05709163f, 0.10993902f, 
    -0.42850664f, 0.02709907f, -0.34234262f, -0.23627259f, -0.14685996f, -0.17894949f, 0.15809381f, -0.14277288f, 
    0.04119978f, -0.16758916f, -0.04529931f, -0.61820978f, 0.13446966f, 0.05869995f, 0.25857955f, 0.07257738f, 
    -0.11507501f, 0.09240334f, -0.01586175f, 0.14836834f, -0.01860114f, -0.08438494f, -0.12490627f, 0.02987087f, 
    0.12959458f, 0.15360749f, 0.22340973f, 0.25577593f, -0.33010632f, -0.49679324f, 0.13114999f, 0.05384479f, 
    0.31874147f, 0.12530205f, 0.07677041f, -0.30436289f, -0.47539952f, -0.14920178f, -0.62872916f, -0.18840313f, 
    -0.16351177f, 0.10914810f, 0.02924685f, -0.05380828f, 0.05697669f, -0.10684636f, 0.05485330f, 0.06430949f, 
    0.22278450f, 0.18525150f, 0.02686203f, 0.15719104f, 0.13100350f, 0.31509191f, -0.27619120f, -0.61011797f, 
    0.26640013f, 0.09223634f, 0.02017841f, -0.22033368f, 0.44716233f, 0.17947173f, 0.22774696f, -0.72585022f, 
    -0.09550048f, -0.55424666f, 0.33048424f, 0.11656112f, 0.07711551f, 0.01034995f, 0.16352648f, 0.33701220f, 
    -0.46513051f, 0.33900908f, 0.35085046f, 0.22779964f, 0.03275380f, -0.09600477f, 0.38941923f, 0.12823139f, 
    0.11259919f, -0.62888265f, -0.26743725f, -0.12720317f, -0.00821418f, -0.15425710f, -0.28222641f, 0.23122059f, 
    0.09558772f, -0.08515953f, -0.41371232f, -0.21651803f, 1.01884985f, 0.22278263f, 0.01588818f, 0.08540700f, 
    -0.00299253f, -0.10175087f, 0.06480456f, 0.52570575f, -0.26754975f, -0.08473773f, 0.28754979f, 0.20159960f, 
    0.34700590f, -0.01249104f, 0.04882299f, 0.02522353f, -0.22873738f, -0.39897895f, -0.30133700f, -0.15572859f, 
    0.01077818f, 0.02569328f, 0.03695740f, -0.11137621f, 0.16335148f, -0.46413741f, -0.73621720f, 0.06509040f, 
    -0.10611688f, -0.22133656f, 0.26748347f, 0.17165941f, -0.32003424f, -0.41719413f, 0.94243890f, -0.81428903f, 
    -0.23668966f, -0.08107591f, 0.07336035f, -0.13339578f, 0.21231718f, 0.06604276f, 0.00242334f, -0.19904625f, 
    0.19628748f, -0.19563401f, 0.10021140f, -0.04285586f, 0.10882331f, 0.22850016f, 0.36570188f, 0.05343018f, 
    0.61110133f, 0.34931701f, -0.05111569f, 0.03750614f, -0.29924223f, 0.21892773f, -0.05069080f, -0.08206960f, 
    0.12639013f, -0.45815605f, -0.38851646f, -0.49328461f, 0.29393756f, -0.15732896f, 0.08373761f, 0.17920166f, 
    0.13017383f, 0.26033551f, 0.09652182f, 0.07017405f, 0.39365095f, -0.16227244f, -0.08456577f, -0.01980561f, 
    0.14067011f, -0.20635431f, -0.06668980f, -0.05532145f, 0.38155189f, -0.10292980f, 0.12022369f, 0.00191498f, 
    0.09963204f, -0.05642499f, 0.02025324f, 0.01075833f, 0.07851403f, 0.51986629f, -0.07656492f, -0.41970766f, 
    0.33058846f, -0.53214604f, 0.16333108f, 0.03782711f, -0.20213442f, 0.06014721f, 0.06727438f, 0.33610964f, 
    0.04094950f, 0.04499191f, 0.14335997f, 0.19274101f, 0.13689640f, 0.00115559f, 0.12403231f, 0.07738928f, 
    0.20874403f, -0.05353435f, -0.01253990f, 0.04415813f, -0.02251567f, -0.04396120f, -0.08039953f, -0.07317265f, 
    -0.40335971f, -0.40214399f, -0.10243160f, -0.33622077f, 0.13376375f, 0.15243387f, 0.23396960f, 0.13218415f, 
    -0.90900385f, 0.10611898f, 0.00910063f, 0.17648432f, 0.04299597f, 0.01711722f, 0.32222950f, 0.07298925f, 
    0.07720598f, -0.10360866f, 0.10814486f, -0.05934007f, -0.14441434f, 0.01929615f, -0.12081418f, 0.26789710f, 
    -0.10890420f, -0.21930622f, -0.44617021f, -0.22052857f, 0.21400486f, 0.15255058f, -0.06629195f, -0.32272857f, 
    0.12425073f, -0.00291783f, -0.21010128f, 0.08752187f, 0.23341779f, 0.07855033f, 0.09851746f, -0.04885140f, 
    0.11227688f, 0.01459699f, 0.08637928f, 0.01518600f, 0.17758128f, -0.05847716f, 0.07648075f, 0.02956354f, 
    -0.06754006f, -0.12036483f, 0.05934348f, -0.11443830f, 0.04235931f, -0.85806322f, -0.10827252f, 0.06190009f, 
    -0.54890513f, -0.02895933f, -0.37395078f, 0.06960174f, 0.07225786f, 0.16179651f, 0.54364318f, -0.17844793f, 
    -0.22046490f, -0.35127753f, -0.15033841f, 0.15201283f, -0.14267865f, 0.01588184f, 0.04625651f, -0.19979143f, 
    0.27209198f, 0.24270537f, 0.16481563f, -0.11940235f, 0.11514371f, 0.16746965f, -0.12028180f, 0.10397550f, 
    -0.32515171f, 0.02724394f, 0.07923787f, 0.01903703f, -0.19460788f, -0.00257943f, -0.07556777f, -0.11964488f, 
    -0.12042934f, -0.65987808f, -0.47650090f, -0.83843601f, 0.16032392f, 0.11261592f, -0.14219351f, -0.08830746f, 
    -0.01961084f, -0.02291479f, 0.04678682f, 0.09650300f, 0.06024848f, -0.13608018f, -0.15825509f, -0.14899798f, 
    -0.16316499f, -0.21177642f, 0.05247741f, 0.72796971f, 0.10184772f, 0.18500654f, -0.11968723f, 0.04489862f, 
    0.10289215f, 0.04351662f, -0.07146122f, -0.02584916f, 0.05292062f, -0.38189477f, -1.09344721f, -0.27280691f, 
    0.19443165f, -0.12158877f, -0.19302323f, -0.16338487f, 0.40537405f, 0.26218268f, 0.20553276f, 0.10889949f, 
    -0.01788205f, -0.01121498f, 0.06597800f, -0.04226023f, -0.02035822f, -0.05403962f, 0.10886601f, -0.09418704f, 
    -0.07754666f, 0.00800954f, 0.07733325f, -0.00553633f, 0.20486380f, 0.10257314f, 0.08921120f, -0.40048105f, 
    -0.10344011f, 0.13871750f, -0.03887531f, -0.20924321f, 0.07913566f, 0.20566538f, -0.03168007f, 0.14997500f, 
    0.09523043f, 0.11771056f, -0.14442691f, 0.34879872f, -0.09589710f, -0.29761180f, 0.45488220f, 0.35348183f, 
    -0.14541732f, -0.21115540f, 0.03824343f, 0.09090075f, -0.08123588f, 0.06393898f, -0.15379179f, -0.01514712f, 
    0.09182797f, -0.22995803f, 0.38585314f, 0.16183661f, -0.49243265f, 0.19211905f, 0.03485259f, -0.13311052f, 
    0.20838819f, -0.10774084f, 0.00242490f, 0.61844450f, -0.09145241f, 0.08218387f, 0.03364782f, 0.14443395f, 
    -0.00814219f, 0.14115798f, 0.10627982f, 0.09165423f, 0.23846133f, -0.11731753f, 0.17462714f, -0.06528927f, 
    -0.01543527f, -0.00327489f, 0.01276687f, 0.04679965f, 0.29781961f, -0.26220134f, -0.09423198f, 0.12864266f, 
    0.53016371f, 0.00578508f, -0.18912564f, 0.06382452f, -0.01915232f, -0.06869501f, -0.95733255f, -0.76896864f, 
    -0.33289737f, 0.19063441f, 0.18871593f, 0.20228130f, 0.04465356f, 0.03704679f, -0.09726769f, 0.15086478f, 
    0.08047896f, -0.10817183f, 0.26438606f, 0.10884676f, 0.04451204f, 0.00501785f, 0.00349409f, -0.06672677f, 
    0.08047564f, -0.04944502f, -0.02726969f, -0.01814387f, 0.13730882f, -0.01150576f, 0.17626713f, 0.11386159f, 
    0.05696647f, -0.00141670f, -0.16601321f, -0.14879021f, 0.08443606f, 0.25913611f, 0.14092448f, 0.06422780f, 
    0.12751091f, -0.00406382f, -0.57566351f, 0.00174911f, 0.06654304f, 0.01551853f, -0.09572601f, -0.29664373f, 
    0.03635202f, -0.09769350f, -0.08716465f, -0.50811493f, -0.40936357f, 0.01711168f, -0.01558827f, 0.06064221f, 
    0.21177052f, 0.05574629f, 0.16815737f, 0.02975427f, 0.36319670f, 0.23518156f, -0.37439024f, -0.02407553f, 
    0.02933805f, -0.07948812f, -0.02930175f, -0.15278395f, -0.14974014f, -0.32186639f, -0.01926510f, 0.18904905f, 
    0.05085909f, 0.12761803f, -0.15484527f, -0.19363286f, -0.05906144f, 0.00486205f, -0.48453632f, -0.17102373f, 
    0.33915564f, -0.17393589f, 0.12033191f, 0.15124696f, -0.12343932f, 0.23265198f, 0.15188412f, 0.26635054f, 
    0.18501517f, -0.11960805f, 0.18388337f, 0.23941387f, 0.13303740f, -0.00004373f, 0.24220997f, -0.21478944f, 
    0.38744649f, 0.61244321f, -0.31062341f, -0.15224381f, 0.05780707f, -0.10631141f, 0.39698088f, 0.07527679f, 
    0.30050680f, 0.14478800f, 0.13241795f, -0.02737855f, 0.07811348f, -0.22124153f, -0.10133006f, 0.01101732f, 
    0.06595712f, -0.12116343f, 0.08844553f, -0.25349325f, -0.12607653f, -0.05475121f, 0.00836974f, 0.13344307f, 
    0.07069410f, -0.22856815f, -0.03322605f, -0.59255683f, -0.00762285f, 0.04754485f, -0.03038579f, 0.11796410f, 
    0.03975052f, -0.03413346f, 0.13202725f, 0.00473221f, -0.88577938f, -0.47876799f, -0.15650156f, 0.04293576f, 
    -0.01256374f, 0.02678879f, 0.03841027f, -0.01541372f, 0.01331833f, -0.44346246f, 0.11694215f, -0.11857357f, 
    -0.09826664f, 0.20924865f, 0.11438577f, 0.15305819f, -0.07656229f, -0.05494123f, 0.43993929f, -0.28892705f, 
    0.20150132f, -0.16558792f, 0.21223740f, 0.23971066f, -0.00872107f, 0.12559907f, -0.04846378f, 0.22265831f, 
    0.14218496f, 0.10297200f, -0.00270248f, 0.11315691f, -0.04556372f, 0.23981521f, 0.11796400f, 0.09512410f, 
    0.13036670f, -0.06790865f, -0.20732222f, 0.31577387f, 0.20497416f, -0.15049887f, 0.14832383f, -0.11953448f, 
    -0.32147795f, 0.35878885f, 0.20167364f, 0.12005366f, 0.36019790f, 0.04993444f, -0.05310727f, -0.16177435f, 
    -0.04568497f, 0.06993594f, -0.04606009f, 0.01929650f, -0.00835107f, 0.32238647f, 0.26133654f, 0.14919966f, 
    -0.13489996f, -0.02742252f, -0.15964592f, 0.12691532f, 0.16569455f, -0.04438697f, -0.00436135f, 0.04403682f, 
    0.23317705f, 0.06145731f, 0.10645732f, -0.08718364f, -0.17503059f, -0.01663688f, 0.10842013f, 0.01890133f, 
    0.23888803f, 0.09921759f, -0.12286659f, 0.18616261f, 0.31545040f, -0.11169468f, -0.11112787f, 0.05145883f, 
    0.02852554f, -0.01154808f, 0.12905587f, -0.32262078f, -0.09011264f, -0.08641262f, 0.22617623f, -0.26376718f, 
    0.03503019f, -0.07760762f, 0.11174739f, 0.13377453f, 0.16646668f, 0.12957315f, 0.00586113f, 0.06190975f, 
    0.20867090f, 0.02982528f, -0.04610258f, -0.02397933f, 0.12709367f, 0.09394502f, 0.00152113f, 0.14039391f, 
    -0.02635415f, -0.02909706f, -0.23450446f, -0.03588330f, 0.23662932f, 0.59775937f, 0.04173700f, -0.08447859f, 
    0.51512510f, -0.07546628f, -0.08617721f, 0.12523629f, 0.11298360f, 0.16193447f, 0.27442622f, -0.21624407f, 
    -0.68087989f, -0.50131989f, -0.14284281f, -0.15712218f, -0.13843390f, 0.20465519f, -0.05696948f, 0.00198621f, 
    0.06876688f, 0.18699554f, 0.11683449f, 0.09384398f, 0.09659296f, 0.06293337f, -0.07794565f, 0.08285464f, 
    0.21815918f, 0.05764953f, -0.07552903f, -0.07494592f, -0.30772892f, 0.05565993f, -0.49312121f, 0.10626502f, 
    0.04399202f, 0.09023628f, 0.27897146f, 0.14973927f, 0.15469965f, 0.50237513f, 0.30328667f, -0.50574332f, 
    -0.09777164f, -0.15701512f, 0.08910789f, 0.29819116f, -0.07592501f, -0.11006817f, 0.01307239f, -0.34840044f, 
    -0.04059105f, 0.38801816f, 0.02790751f, 0.44396484f, -0.09017143f, 0.10125706f, -0.00651134f, 0.01793874f, 
    0.14630412f, 0.02180467f, 0.21406502f, 0.03130782f, -0.14281254f, -0.41554266f, -0.88351387f, -0.45476359f, 
    -0.02290500f, -0.13101593f, 0.39655319f, -0.10017305f, -0.17690560f, -0.06875999f, -0.08389413f, 0.08996436f, 
    -0.16900253f, 0.07809273f, -0.27595177f, 0.18554631f, 0.09994093f, -0.16882095f, 0.12474114f, -0.02427785f, 
    0.04903020f, -0.19049594f, -0.22049525f, -0.19613390f, -0.28595817f, -0.17280240f, 0.13015169f, -0.06115550f, 
    -0.07355603f, 0.13173109f, 0.09088849f, 0.62149382f, -0.17595598f, -0.45567983f, -0.27766451f, -0.06729251f, 
    0.02313978f, 0.15177575f, -0.08168460f, -0.01427620f, -0.77945489f, -0.06494242f, 0.29520994f, 0.02827158f, 
    0.23712598f, 0.00065868f, 0.17522478f, 0.19996034f, 0.16132998f, -0.15106575f, -0.26797739f, -0.61939722f, 
    0.14288162f, -0.07219207f, -0.15296061f, 0.14924082f, 0.14956884f, 0.33595249f, -0.34211329f, -0.88371104f, 
    0.06417808f, 0.08295029f, 0.05957213f, -0.05375871f, 0.01602860f, -0.04438096f, 0.03457327f, 0.12142699f, 
    -0.14917625f, 0.41722023f, 0.02381426f, -0.11789607f, 0.00411849f, 0.05897124f, -0.05026213f, -0.12621450f, 
    -0.22285786f, -0.23490550f, -0.48435640f, 0.02782600f, -0.12634131f, -0.14887558f, 0.00768617f, -0.06646533f, 
    -0.13248773f, 0.26846257f, -0.10030768f, -0.21477911f, -0.00492471f, -0.01065375f, -0.05131762f, 0.04597896f, 
    -0.08573802f, -0.44179448f, -0.04936780f, -0.02396095f, 0.42096651f, 0.11329532f, 0.48437309f, 0.21465652f, 
    0.21538885f, 0.07776240f, 0.21644348f, 0.66263884f, -0.32319611f, -0.31901702f, 0.11435777f, -0.07864565f, 
    0.10182580f, 0.01978667f, -0.05904720f, 0.14215198f, 0.56362480f, -0.10880217f, 0.12773372f, 0.09184507f, 
    -0.15086955f, -0.13447063f, 0.14342143f, -0.07252329f, 0.20378566f, 0.32467946f, 0.01645284f, -0.42880312f, 
    0.12743559f, -0.02540888f, -0.08586258f, 0.03513146f, 0.42086375f, 0.01981634f, 0.13322024f, 0.35994729f, 
    0.22784968f, -0.06098132f, 0.11850458f, -0.20389469f, -0.00617324f, -0.19117853f, 0.05598490f, 0.29197696f, 
    0.15005758f, 0.00877985f, -0.06071023f, -0.10400479f, -0.03900413f, -0.10530726f, -0.14306074f, -0.39738771f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.22925434f, -0.34246013f, 0.04047122f, 0.32435071f, -0.09359705f, 0.12538303f, 0.13929458f, 0.06119518f, 
    0.18080640f, 0.63997972f, 0.77948397f, 0.52099067f, 0.18114825f, 0.17702897f, -0.17109834f, 0.30087358f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.81534016f, -0.12728405f, -0.02959022f, 0.13767391f, 0.28894693f, -0.42877460f, 0.06695473f, -0.06634884f, 
    -1.22895980f, -0.66981035f, -0.16704100f, 0.10921848f, 0.07342799f, 0.00830204f, 0.28181264f, -0.49090740f, 
    0.06559954f, -0.21885918f, -0.23363583f, 0.40322998f, -0.05826860f, 0.31361806f, 0.45766214f, 0.24611410f, 
    -0.52873337f, -0.11722054f, -0.00475352f, 0.24591853f, 0.47197625f, -0.12570350f, -0.49088818f, 0.22798629f, 
    -0.79711640f, -0.37678701f, -0.10469636f, 0.77781755f, -1.17282748f, -0.26976657f, -0.12736782f, -0.08311016f, 
    0.04139670f, 0.18665986f, -0.06545308f, 0.18189186f, -0.68830472f, -0.37340912f, 0.36347005f, 0.55779159f, 
    0.27484587f, -0.01889463f, -0.10740253f, 0.08938338f, -0.09114090f, -0.73081964f, -0.62712038f, -0.02915478f, 
    0.18334082f, 0.03322499f, -0.57063341f, 0.39748576f, -0.27233356f, 0.35952467f, 0.25975862f, -0.08366521f, 
    -0.11401788f, 0.08488967f, -0.01060529f, -0.42406064f, 0.51132149f, -0.26127490f, 0.55394435f, -0.04231188f, 
    0.03560968f, -0.38209018f, -0.09028216f, 0.27455711f, 0.05160872f, -0.49568164f, 0.18126911f, 0.35323355f, 
    0.14873789f, 0.15205486f, -0.09043266f, 0.00270475f, 0.18199916f, 0.42804489f, -0.26206300f, 0.12052146f, 
    -0.25671831f, -0.55073702f, 0.15900390f, -0.03048581f, -0.09366957f, 0.05415739f, -0.20126744f, 0.62850356f, 
    -0.96337503f, -0.72428358f, -0.15259053f, -0.40250954f, -1.38006234f, 0.39495084f, -0.93302560f, -0.04943568f, 
    -0.18490689f, 0.34072155f, 0.74274570f, -0.20231208f, 0.40644181f, -1.18396902f, 0.21708637f, -0.59604836f, 
    -0.44133317f, 0.67424268f, 0.11355473f, 0.25378776f, -0.42322850f, 0.07903091f, -0.02699201f, 0.17447522f, 
    -0.42763731f, 0.36129245f, -0.53479284f, -0.60087711f, 0.25144672f, -0.37678045f, 0.01709580f, 0.11208551f, 
    -0.69821894f, 0.44053999f, 0.10381126f, 0.31047633f, 0.23817657f, -0.06551974f, -1.03022528f, -0.18203956f, 
    -0.18207325f, 0.48940387f, 0.16184381f, -0.23714179f, -0.00794342f, 0.66642368f, -0.58962643f, -0.56454879f, 
    -0.50478590f, -0.27639237f, 0.08670060f, -0.79581857f, -0.80833322f, -0.41848880f, 0.32651544f, 0.13490570f, 
    -0.31335333f, 0.33530468f, 0.92912865f, 0.50540698f, -0.28747898f, -0.05873258f, 0.05323139f, 0.13682990f, 
    -0.43166390f, -0.35771596f, 0.12267744f, -0.03260130f, -0.63764846f, 0.42529801f, 0.80258673f, -0.08195956f, 
    0.52897698f, -0.18879445f, -0.11608066f, 0.36635199f, -0.29429191f, 0.73359382f, -0.27186915f, -1.38516772f, 
    -0.45438641f, 0.00101273f, 0.22393250f, -0.74016184f, -0.28123817f, 0.51707351f, -1.76484108f, 0.09171597f, 
    0.87291908f, -0.17655551f, -0.25827056f, -0.07260987f, 0.40907818f, 0.30793089f, -0.05302154f, -0.25648484f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.36096227f, 0.49300951f, 0.76403743f, 0.28752747f, -0.38170692f, -0.09837328f, 0.54756331f, -0.84177220f, 
    -0.02285682f, 0.17734219f, -0.14453818f, -0.10264067f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
