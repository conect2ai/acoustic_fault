#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.05445569f, -0.28040153f, -0.35169318f, -0.28340617f, -0.68174058f, -0.46742499f, 0.32365912f, -0.03142902f, 
    0.66739172f, 0.16000836f, 0.33054385f, -0.08044580f, 0.13034162f, 0.29696280f, -0.27118501f, 0.62575150f, 
    -0.04159587f, -0.67620057f, -0.63301206f, -0.39840496f, 0.05963896f, 0.64681321f, -0.17049824f, -0.83051902f, 
    -0.08448669f, -0.27539605f, -0.18545039f, -0.56833178f, -0.45898110f, -0.13129613f, 0.55958259f, -0.58716589f, 
    0.95333797f, 0.03880648f, -0.15900783f, -0.15212621f, 0.05907698f, 0.27802688f, -0.14437328f, -0.50131041f, 
    -0.15139866f, 0.05020336f, 0.48013198f, -0.70187068f, -0.08697336f, -0.53210402f, -0.05035553f, -0.50322270f, 
    -0.41694921f, 0.26718241f, -0.60659546f, -0.29213503f, -0.24856541f, -0.02749400f, -0.26838019f, 0.23654598f, 
    -0.10498975f, 0.50084341f, 0.09244072f, -0.16604826f, 0.41817042f, 0.16849235f, 0.40506053f, -0.33586136f, 
    0.11259697f, 0.75589389f, -0.24174722f, 0.00467522f, 0.74033552f, -0.08162692f, -0.51497841f, -0.15460670f, 
    -0.11512448f, -0.11921325f, 0.16825753f, 0.62008166f, 0.08731014f, -0.26216134f, 0.25927350f, 0.38281137f, 
    -0.78781778f, -0.63370889f, -0.23361489f, -0.30696386f, 0.65469664f, -0.17431660f, -0.39207867f, -0.16935249f, 
    -0.22585237f, -0.16251054f, 0.23627333f, 0.66009563f, -0.45279124f, 0.00763738f, 0.15391147f, -0.40757221f, 
    0.19040740f, 0.39299992f, 0.43475342f, 0.69361746f, 0.08755447f, -0.03878214f, -0.10128286f, 0.29250920f, 
    0.18471244f, 0.43008396f, -0.02316238f, 0.24916357f, 0.72683328f, 0.17315046f, 0.76450789f, -0.70466018f, 
    0.72343928f, -0.25405535f, 0.12968051f, -0.03662432f, -0.19681071f, 0.26861155f, -0.38898432f, 0.50720781f, 
    0.88336557f, -0.74921167f, -0.19354315f, -0.09324944f, -0.07759148f, 0.07197637f, -0.19112213f, -0.30922118f, 
    -0.24672799f, 0.51265001f, 0.38788125f, 0.22537813f, -0.48174039f, -0.52169389f, -0.19596153f, -0.40542331f, 
    0.90248120f, -0.48902097f, -0.61472923f, -0.25705805f, 0.84458351f, -0.31783077f, 0.14045185f, 0.24314566f, 
    0.41404378f, 0.50865078f, -0.49041614f, 0.07282647f, 0.38603055f, 0.54068816f, -0.27940044f, 0.70995957f, 
    -0.42584306f, -0.67423248f, -0.32261068f, -0.78026175f, 0.54211575f, 0.76844752f, 0.15218374f, -0.29798612f, 
    0.26911467f, 0.16487862f, 0.02419961f, 0.61489111f, 0.21972072f, -0.36587626f, -0.53506029f, -0.76321095f, 
    -0.35257685f, -0.27400550f, -0.47092962f, -0.38649827f, -0.09534571f, 0.63720673f, 0.27196959f, -0.53926712f, 
    0.16100189f, 0.15653610f, 0.68437546f, -0.39660877f, 0.54603571f, 0.55272818f, 0.55656940f, -0.61137545f, 
    -0.55949551f, -0.19203743f, 0.23688164f, 0.19462265f, 0.04795041f, 0.38441789f, 0.12630849f, -0.25486636f, 
    -0.69126320f, -0.26300487f, -0.27415225f, -0.14712225f, 0.49017271f, 0.51309276f, 0.46591467f, 0.20717157f, 
    0.26117727f, -0.36550751f, -0.31332317f, -0.01956099f, -0.00523272f, -0.31806219f, 0.64916176f, -0.68366373f, 
    0.00945689f, 0.06369694f, 0.18818648f, -0.37379867f, -0.65947586f, 0.48415086f, 0.71914399f, 0.10231319f, 
    -0.54313546f, -0.44357350f, -0.35038489f, -0.17533791f, 0.26267332f, -0.12339187f, -0.06806976f, -0.14353351f, 
    -0.26981357f, 0.01786959f, 0.37079427f, 0.29808277f, 0.28326693f, -0.20530254f, -0.30365348f, 0.29317182f, 
    -0.44222042f, 0.10543068f, -0.38752234f, 0.10892267f, 0.59096014f, -0.68786746f, -0.41539642f, -0.46070820f, 
    0.15761676f, -0.04211373f, 0.52130741f, -0.81492442f, -0.34016716f, 0.04188246f, -0.21416819f, -0.21963684f, 
    0.43708307f, -0.31022820f, -0.01035847f, 0.63926136f, -0.67498893f, 0.83739907f, -0.45879450f, 0.01712072f, 
    -0.36454678f, -0.68457288f, -0.16427319f, 0.04702935f, -0.03301316f, -0.88363230f, 0.28990847f, 0.56835109f, 
    0.21468347f, 0.51703835f, -0.33032531f, -0.54142863f, -0.08532521f, -0.65784144f, 0.09086223f, 0.26070845f, 
    0.02128510f, 0.88814765f, 0.33685422f, 0.35149971f, -0.07894266f, 0.14834751f, -0.04716813f, 0.08118645f, 
    0.50276262f, -0.50069731f, 0.62066418f, -0.51298088f, -0.17367995f, 0.15594637f, 0.22370103f, -0.33068368f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09004713f, 0.04889722f, -0.03196802f, -0.26797524f, 0.24533512f, -0.14851634f, -0.30597314f, 0.27194372f, 
    0.16357087f, 0.10014208f, 0.18861827f, 0.34727943f, -0.14525568f, 0.26844338f, -0.10008004f, 0.18765686f, 
    -0.10633933f, 0.35799810f, -0.08990733f, -0.14627764f, -0.09177867f, 0.38958013f, 0.16965224f, 0.02307998f, 
    0.20196521f, 0.11186147f, 0.26204211f, 0.15992892f, 0.24757880f, -0.35503715f, -0.32066178f, 0.19486262f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00964494f, -0.06139860f, 0.00316545f, 0.02145197f, 0.00870880f, -0.07788172f, -0.08087395f, -0.01443482f, 
    -0.01457136f, -0.05019080f, 0.02302112f, -0.05659828f, -0.04245120f, 0.04098208f, 0.01777621f, 0.00023516f, 
    0.04276850f, -0.00742098f, 0.01485107f, -0.00614325f, -0.06640973f, -0.00808873f, 0.01704912f, -0.01036095f, 
    -0.01683687f, -0.08399906f, 0.03172472f, -0.08211051f, -0.04289875f, -0.08996185f, -0.01382796f, -0.05819391f, 
    -0.06942178f, -0.08442242f, -0.00771980f, 0.01063509f, -0.00482653f, -0.08317835f, -0.04404205f, 0.02872187f, 
    -0.04473396f, -0.04455652f, -0.06705111f, -0.04125930f, -0.00416745f, -0.01306677f, -0.08163464f, -0.06275734f, 
    0.00437342f, -0.05900033f, -0.05139703f, -0.03835012f, -0.04939042f, -0.05818044f, -0.02084272f, -0.06625310f, 
    -0.05344038f, -0.03345835f, -0.04011250f, -0.00571231f, -0.05541254f, -0.02182271f, -0.09742888f, -0.07222309f, 
    -0.05103375f, 0.02224767f, -0.05058490f, -0.03633106f, -0.01342121f, -0.01614571f, 0.00095520f, -0.06321079f, 
    -0.08452002f, -0.04904912f, -0.04391322f, -0.04810078f, -0.04828845f, -0.07601583f, -0.00631950f, -0.03538646f, 
    -0.06663483f, -0.00521435f, -0.00108743f, -0.06475329f, -0.04130773f, -0.08241848f, 0.02432437f, -0.01575214f, 
    -0.01021334f, -0.03428574f, -0.04172529f, 0.02002037f, -0.00041534f, -0.00901301f, 0.00990783f, 0.00285585f, 
    -0.02399504f, -0.07743860f, -0.00755876f, -0.05046698f, -0.04190332f, -0.09045167f, -0.04031052f, -0.00231061f, 
    -0.01962902f, -0.05723373f, -0.01237109f, -0.01146898f, -0.06070453f, 0.01691501f, -0.01715185f, 0.01028056f, 
    0.01332704f, -0.09365293f, 0.04726566f, -0.03270586f, -0.00827372f, 0.01612399f, 0.01708094f, -0.05103800f, 
    -0.01618993f, -0.04151269f, -0.07012765f, -0.02021298f, -0.04852761f, 0.01880953f, -0.03909867f, -0.03007182f, 
    0.06266092f, -0.06326725f, -0.02405419f, -0.00632455f, 0.02186820f, -0.03100159f, 0.00735929f, 0.01709330f, 
    0.01913219f, -0.05577335f, -0.01999662f, -0.07787994f, -0.00074903f, -0.06896771f, -0.00953828f, -0.05370064f, 
    -0.02485033f, 0.00789982f, -0.01910194f, 0.04230056f, -0.08716334f, 0.00617063f, -0.07085156f, -0.03371343f, 
    -0.00672002f, -0.03809595f, -0.06268177f, -0.07699840f, -0.08396556f, -0.08015756f, -0.08296788f, 0.02232111f, 
    0.02037893f, -0.03516574f, 0.02580315f, -0.02921072f, -0.07158660f, 0.01937752f, -0.09036369f, 0.01803052f, 
    -0.02113538f, -0.00758979f, -0.00549599f, -0.02706582f, -0.01436165f, -0.04908267f, 0.01837655f, -0.02361744f, 
    0.01555173f, -0.04550144f, -0.07799635f, -0.05003868f, -0.03009063f, -0.05897371f, 0.01128722f, -0.06982371f, 
    -0.01724229f, -0.01354999f, -0.03296573f, -0.01181107f, -0.07111100f, -0.01067312f, -0.00376632f, -0.06335879f, 
    -0.07361291f, -0.06990623f, -0.01926301f, -0.01045601f, -0.00354676f, -0.00012171f, -0.08054942f, -0.08970165f, 
    -0.06335746f, -0.04461416f, 0.00988048f, -0.05158634f, -0.01838274f, -0.07631567f, 0.02572598f, -0.05152983f, 
    -0.02163498f, -0.05085331f, -0.07654069f, -0.05625570f, -0.02666566f, -0.00871859f, -0.03889989f, -0.08120917f, 
    -0.07595401f, -0.02872545f, -0.07177156f, -0.00003107f, -0.04610765f, -0.03300708f, -0.03572273f, -0.04354019f, 
    -0.02897095f, -0.08653913f, -0.02987843f, -0.09410971f, -0.08184758f, -0.04125458f, 0.01079301f, -0.07355835f, 
    -0.00892000f, -0.04880935f, -0.02541310f, -0.01138934f, -0.00142803f, -0.03325671f, 0.02410853f, -0.06998587f, 
    -0.05371009f, -0.00573562f, -0.06035382f, -0.09238954f, 0.02416825f, -0.06890814f, -0.07983407f, -0.02001399f, 
    -0.03196067f, -0.00595373f, -0.07230113f, -0.09182034f, 0.02329776f, 0.00082121f, -0.08005669f, -0.07121521f, 
    -0.05063760f, -0.07782568f, -0.06272696f, -0.02486027f, -0.03529626f, -0.01206885f, -0.07621251f, -0.05440185f, 
    -0.05384463f, -0.04130683f, -0.04961290f, -0.05873371f, -0.08501993f, -0.07680391f, -0.00029743f, 0.03387661f, 
    -0.04417823f, 0.03365875f, -0.08200648f, -0.04347582f, -0.05813849f, -0.01030372f, -0.07978832f, -0.05775769f, 
    -0.08549964f, -0.07122257f, -0.03680829f, 0.00947844f, 0.01158910f, -0.03502984f, -0.04890110f, -0.01399956f, 
    -0.03645153f, 0.19071181f, 0.23024610f, 0.04799864f, 0.02646571f, 0.06290108f, -0.12923194f, -0.03471715f, 
    -0.02475766f, -0.08081498f, 0.16571020f, 0.02089211f, -0.09666726f, 0.07400775f, 0.23977169f, 0.25031808f, 
    0.02451502f, 0.21224006f, -0.34981993f, 0.14652768f, 0.28804213f, 0.14736560f, 0.03901061f, 0.02581323f, 
    0.06545197f, -0.17154856f, 0.19105838f, -0.42743674f, -0.10800645f, 0.01678433f, 0.19014363f, 0.03150506f, 
    -0.09233519f, -0.17533500f, -0.16074683f, 0.11228082f, 0.28893214f, 0.09588394f, 0.13522582f, -0.04465553f, 
    -0.00236302f, 0.07635443f, 0.25398135f, 0.02965684f, 0.24018228f, -0.16152310f, 0.13782911f, 0.26847446f, 
    -0.04597246f, -0.09807166f, 0.01885302f, -0.03651292f, -0.06104276f, 0.13098735f, -0.07712073f, -0.08929089f, 
    -0.11248728f, -0.18408334f, -0.06319449f, 0.01802378f, -0.01047993f, 0.09731542f, -0.04919499f, -0.09211020f, 
    -0.15214495f, -0.39178231f, -0.05716326f, 0.11505902f, -0.08490875f, 0.00070119f, 0.08009180f, -0.16742536f, 
    -0.44043389f, -0.02283745f, 0.31854936f, 0.20060433f, 0.11765172f, 0.11830902f, 0.14407048f, -0.02803839f, 
    0.01284727f, -0.26080614f, -0.00174702f, 0.28867406f, 0.07262587f, -0.02125099f, -0.00090478f, -0.04985130f, 
    -0.10820121f, 0.16225640f, -0.16214278f, -0.21696229f, -0.27364308f, -0.07271133f, 0.14382567f, -0.02767728f, 
    0.05536061f, 0.24400435f, 0.08060807f, -0.14144398f, -0.06364390f, -0.25580680f, -0.06160934f, 0.02395938f, 
    -0.06928545f, 0.07550207f, 0.01095843f, 0.07376195f, 0.02592348f, 0.00877559f, -0.07011796f, -0.12510443f, 
    -0.12722163f, 0.02038265f, -0.10105518f, -0.08237790f, -0.16583632f, 0.04799943f, 0.10531874f, 0.14416474f, 
    -0.07087836f, 0.17946640f, 0.03392972f, 0.22623758f, -0.08723183f, 0.19130561f, -0.13566329f, 0.04499286f, 
    0.01180787f, 0.01988601f, 0.09371147f, -0.11827040f, -0.03838506f, -0.01320095f, -0.01118424f, 0.60668904f, 
    0.07786837f, -0.08692782f, 0.00853207f, -0.05714724f, 0.08435853f, 0.03941708f, -0.09760108f, 0.04697528f, 
    -0.04711369f, -0.23847733f, -0.04964695f, -0.25251690f, -0.11738153f, 0.10041956f, 0.13863064f, -0.01745559f, 
    0.08885735f, -0.19607691f, 0.42289954f, 0.33546710f, 0.20430684f, 0.00920121f, 0.10045781f, 0.10965658f, 
    0.06217582f, 0.10640806f, 0.23080127f, -0.12269846f, 0.29604062f, -0.03054753f, -0.02612328f, -0.00142021f, 
    0.05692818f, -0.00276942f, -0.16366404f, 0.09001797f, -0.28471926f, -0.29988208f, -0.04883019f, 0.04283993f, 
    -0.11428242f, -0.01713103f, 0.13785578f, -0.12163494f, -0.01860029f, -0.27573738f, -0.22723331f, -0.01502358f, 
    0.09629763f, -0.08528454f, -0.08097009f, 0.05129449f, 0.03276273f, 0.21612965f, 0.22684143f, 0.15670316f, 
    -0.01767637f, 0.11701389f, -0.02803826f, -0.03056685f, 0.18374200f, 0.04010865f, 0.32820871f, -0.10726295f, 
    -0.29848638f, 0.02765796f, 0.09166168f, -0.04796655f, 0.00223528f, 0.05991193f, -0.00878916f, 0.11843357f, 
    0.12747125f, 0.19572110f, -0.02078690f, 0.02941594f, -0.19103768f, -0.14257032f, 0.09502816f, 0.02987797f, 
    -0.05471793f, 0.17548391f, 0.20116198f, 0.10508769f, 0.01784305f, 0.08221364f, -0.10363375f, -0.03526716f, 
    0.01360661f, 0.19504657f, -0.15982638f, 0.18047778f, -0.00911602f, 0.00408581f, 0.14112586f, -0.02857261f, 
    0.04832433f, 0.04068787f, 0.09135017f, 0.09617247f, 0.18819600f, 0.04536073f, 0.10316071f, -0.12846828f, 
    -0.04624045f, 0.04552380f, -0.01868034f, 0.14862032f, 0.13766423f, 0.16272725f, 0.05542276f, -0.05407840f, 
    -0.02393718f, 0.11617360f, -0.08929186f, 0.02872237f, 0.12667944f, 0.11318433f, 0.34104985f, 0.15141758f, 
    0.02763212f, 0.12247588f, -0.17135394f, 0.03514242f, 0.12518772f, -0.50767082f, -0.18533753f, 0.21746063f, 
    0.03328595f, -0.10214645f, -0.08148092f, -0.20028931f, 0.03903965f, -0.02056272f, 0.01907583f, -0.15740719f, 
    -0.06494658f, -0.10139737f, -0.09327195f, -0.15947108f, -0.02821653f, -0.08914424f, -0.01389829f, 0.33062905f, 
    -0.04504510f, 0.27582729f, 0.29821518f, 0.12077028f, 0.13075987f, 0.02613810f, -0.00161377f, 0.30535066f, 
    -0.03548425f, -0.01964312f, 0.03444160f, -0.01188105f, -0.04996420f, -0.04224192f, -0.06585247f, 0.01583161f, 
    -0.05309212f, 0.02653045f, 0.02427561f, 0.02663443f, -0.00985828f, -0.04826937f, 0.04520122f, 0.01015380f, 
    -0.05965928f, 0.00532049f, 0.04527458f, 0.00922404f, -0.03524934f, 0.02144963f, -0.04912107f, 0.02105848f, 
    0.05010005f, -0.01358920f, 0.04082724f, -0.04766385f, -0.05506394f, 0.04367867f, -0.02278544f, 0.02912619f, 
    0.04551503f, 0.02804494f, -0.01296865f, -0.01899133f, 0.00593491f, -0.02879628f, -0.02885263f, 0.03312968f, 
    -0.00358977f, 0.03630224f, 0.04237420f, 0.00201415f, -0.01455033f, 0.03601137f, -0.04698721f, -0.03001058f, 
    -0.03353309f, -0.02905544f, -0.04278849f, -0.02072154f, -0.02009604f, 0.02870302f, 0.02671489f, -0.01498492f, 
    -0.01905267f, -0.02029000f, -0.00188141f, -0.05410707f, -0.00777104f, -0.06122755f, 0.04103614f, 0.00739708f, 
    -0.01103298f, 0.01780079f, -0.04925257f, -0.04888253f, 0.01605647f, 0.01278289f, -0.06537271f, -0.01208765f, 
    -0.01232438f, -0.05780909f, -0.05136739f, 0.02788525f, 0.04245076f, 0.01149057f, -0.02018955f, 0.04109618f, 
    -0.05746668f, -0.00212266f, -0.01277561f, 0.05692891f, -0.03557703f, 0.01943177f, -0.05478087f, 0.03511375f, 
    0.00589990f, 0.01291354f, -0.06190543f, 0.03492716f, 0.04203231f, -0.03061535f, -0.01704636f, -0.02425073f, 
    -0.02574737f, -0.04378491f, -0.03521848f, 0.05116244f, 0.04500532f, -0.01362685f, 0.00907655f, 0.02381494f, 
    -0.04685037f, -0.04764149f, -0.00354568f, -0.06491248f, -0.04323799f, -0.01974702f, -0.02599308f, 0.03675543f, 
    0.02787271f, -0.04826645f, 0.00547146f, -0.02922891f, 0.04948866f, -0.01926279f, 0.04087367f, -0.02337924f, 
    -0.05973862f, -0.06243862f, -0.02704507f, -0.01589336f, -0.03467580f, -0.06341707f, 0.05158438f, 0.00974871f, 
    -0.04356854f, -0.02342538f, 0.02125612f, -0.05233455f, -0.06177598f, -0.02011421f, -0.02157167f, -0.04517020f, 
    -0.03516843f, 0.01922859f, 0.04613275f, 0.02132098f, 0.04136512f, -0.02448104f, -0.02131646f, -0.02952787f, 
    -0.04467238f, -0.04688095f, -0.01918227f, 0.00624058f, 0.02206537f, -0.00678891f, -0.03608969f, 0.00564216f, 
    0.04138152f, -0.04296273f, 0.05008902f, 0.04528778f, 0.00600530f, -0.02814997f, -0.02611333f, 0.04988561f, 
    0.02170106f, -0.02570024f, -0.01808603f, -0.01928625f, 0.04264360f, -0.06126558f, -0.01014119f, -0.06196331f, 
    -0.04377306f, -0.03973431f, -0.06492114f, -0.01089913f, -0.04471187f, 0.00782142f, 0.03049833f, 0.00713253f, 
    0.00342047f, 0.02635963f, -0.02125100f, -0.04410538f, -0.00210419f, 0.04935354f, 0.01448158f, -0.00806467f, 
    0.03975036f, -0.02148842f, -0.03375512f, 0.00301169f, -0.02251054f, -0.00939789f, -0.00100212f, -0.05249913f, 
    -0.03244614f, -0.03129108f, -0.03931655f, 0.03769131f, -0.04010326f, -0.04657583f, 0.03252165f, -0.04820238f, 
    -0.04999344f, 0.03119571f, -0.05504177f, 0.03680372f, -0.02271992f, -0.06255110f, 0.01573964f, 0.02479070f, 
    -0.02618740f, 0.00998982f, 0.00852147f, -0.05166381f, 0.04824548f, -0.02931079f, -0.01721400f, -0.00186208f, 
    -0.04984350f, -0.06107409f, 0.00956504f, 0.00209472f, -0.04343527f, -0.04987474f, -0.04748603f, -0.01022090f, 
    -0.05148530f, 0.00198987f, 0.02256269f, 0.01856773f, 0.05040039f, 0.02385602f, -0.00567924f, 0.00050140f, 
    -0.00609342f, -0.01402448f, -0.03341835f, -0.04232804f, 0.01097385f, 0.02118659f, 0.02527194f, -0.04130683f, 
    -0.06205187f, -0.02166209f, 0.02328912f, -0.04853372f, 0.02426980f, 0.00117385f, -0.05149515f, -0.05903186f, 
    -0.00628324f, 0.03594013f, -0.05423906f, -0.05881725f, 0.02446359f, -0.05200638f, -0.02914822f, 0.04845454f, 
    -0.01022306f, -0.00089925f, -0.00875376f, -0.04251216f, -0.04112071f, -0.05522959f, -0.02313997f, 0.01437480f, 
    -0.05092170f, -0.04268381f, 0.05024854f, 0.02766765f, 0.02709081f, -0.01577028f, -0.04381942f, 0.00415749f, 
    0.01254235f, -0.03409933f, 0.00521743f, 0.00971528f, 0.05235181f, -0.03183419f, -0.05540204f, 0.00428578f, 
    0.04914009f, 0.03396237f, 0.04512359f, -0.01009423f, 0.01299022f, 0.00044986f, 0.01307020f, -0.04156042f, 
    0.00518550f, -0.13924418f, -0.18283775f, -0.19287516f, -0.08731184f, -0.00193615f, 0.02317906f, 0.24964426f, 
    0.07934383f, -0.04054581f, 0.13834649f, 0.08915144f, 0.18260562f, 0.03083897f, -0.09746886f, 0.07156258f, 
    0.08524389f, 0.04825945f, 0.24964681f, -0.03360235f, -0.05749199f, 0.00794556f, 0.03023164f, 0.02783943f, 
    -0.15736391f, -0.14013408f, -0.06915581f, -0.17343691f, 0.07629646f, -0.28705919f, 0.12775445f, 0.00021199f, 
    -0.04286360f, -0.06958319f, 0.14812851f, -0.02753754f, 0.13595060f, 0.15765992f, 0.01895667f, 0.01633649f, 
    -0.01749820f, 0.05280484f, -0.00064480f, 0.15326354f, -0.01302875f, 0.09302564f, 0.10562406f, 0.14575522f, 
    -0.02211832f, -0.06479467f, -0.20467298f, -0.13081321f, 0.01450938f, -0.09819669f, -0.05565541f, 0.08439846f, 
    -0.00006354f, 0.13412465f, 0.01993106f, -0.05515720f, -0.17395401f, 0.11146467f, 0.00695179f, 0.03641929f, 
    -0.04288717f, -0.07533015f, -0.03588389f, -0.08337263f, -0.12888965f, -0.12103276f, 0.06857987f, -0.07381863f, 
    0.00472246f, 0.02028847f, 0.14736806f, 0.07594247f, 0.13323984f, -0.00026205f, 0.01395303f, 0.13748503f, 
    -0.02711781f, 0.11204261f, 0.07684176f, 0.09279967f, -0.05468936f, 0.11694075f, 0.00324147f, -0.11759351f, 
    -0.27224234f, -0.16359822f, -0.06928372f, -0.00821657f, -0.07614949f, 0.08101600f, -0.05772208f, 0.01071919f, 
    0.25127298f, 0.20919864f, 0.05170070f, -0.20831858f, 0.03681592f, -0.01795806f, 0.04094015f, 0.00053270f, 
    0.04252418f, -0.03926675f, -0.00512136f, 0.09111039f, -0.02836283f, -0.05145968f, -0.06618121f, -0.03904411f, 
    0.02557239f, -0.05865922f, -0.08466953f, 0.16919661f, 0.18418601f, 0.16315673f, 0.12364523f, 0.13314649f, 
    -0.00061564f, 0.12618360f, 0.03651058f, 0.17078133f, 0.18089621f, 0.01932615f, -0.09900871f, -0.03159044f, 
    0.00899883f, -0.08685236f, 0.01598027f, -0.05810440f, -0.04522613f, -0.46915239f, -0.28187248f, 0.29376671f, 
    0.36930713f, 0.34823105f, 0.17129786f, 0.01352371f, 0.27459943f, 0.08602771f, 0.13902435f, 0.18178302f, 
    -0.17015846f, 0.02177055f, -0.10193748f, 0.17196064f, 0.20733514f, -0.05014981f, -0.09801079f, -0.15616831f, 
    -0.19436157f, -0.09254429f, 0.13588731f, 0.05304359f, 0.13771349f, -0.00203278f, 0.08898449f, 0.10836241f, 
    -0.21910764f, -0.08740893f, -0.06699385f, -0.31726131f, -0.45863286f, 0.02151160f, 0.12635970f, 0.03736936f, 
    -0.21697707f, -0.38301322f, -0.39661899f, 0.08278715f, 0.11855236f, 0.18775433f, 0.02428307f, 0.30617118f, 
    -0.18437244f, -0.10840911f, 0.05521240f, 0.21693288f, -0.19819944f, 0.03821112f, -0.13681395f, 0.16108455f, 
    0.04814072f, 0.19208951f, 0.02579503f, -0.01180312f, 0.15906863f, 0.17311540f, -0.24557112f, -0.14155643f, 
    0.04548683f, 0.04409093f, 0.14196026f, 0.20270458f, 0.12605178f, 0.40066019f, -0.10147351f, -0.08639857f, 
    0.10053191f, 0.08811481f, 0.06089386f, 0.08731032f, 0.14389205f, -0.02861896f, 0.17601645f, 0.06486454f, 
    -0.03353728f, 0.25179768f, 0.05972435f, 0.00751678f, -0.16416851f, 0.08925092f, 0.11301330f, 0.15086646f, 
    0.00348125f, 0.06721908f, 0.07809906f, 0.05901080f, -0.08793315f, -0.21692602f, -0.26857162f, -0.14873889f, 
    -0.22112530f, -0.36481890f, -0.08453153f, 0.13193697f, 0.10083096f, 0.09860048f, -0.01293190f, -0.04938689f, 
    0.07111487f, 0.20213643f, -0.09572592f, 0.02963129f, -0.12387308f, 0.04927892f, 0.15151474f, -0.01855082f, 
    0.19786268f, 0.19206925f, 0.24972238f, 0.09989677f, 0.09347150f, 0.19182390f, 0.03422999f, -0.03181825f, 
    -0.07039735f, -0.09833649f, -0.00028408f, 0.04725204f, 0.03289803f, 0.12520863f, 0.16411996f, 0.02034382f, 
    -0.06765036f, 0.09218361f, 0.07989879f, 0.13026951f, -0.08328972f, -0.05246077f, -0.11202276f, 0.11537477f, 
    0.13130967f, -0.00143489f, -0.01632761f, -0.09810147f, 0.04410364f, -0.10959169f, -0.29096922f, -0.29658926f, 
    -0.20313568f, 0.08832534f, 0.17043769f, -0.03170781f, 0.12023763f, -0.13837224f, -0.21015650f, -0.03969510f, 
    0.35820556f, 0.01124851f, 0.12930885f, -0.12019739f, 0.10911876f, 0.08871602f, 0.19229493f, 0.14114799f, 
    -0.03280131f, -0.04730709f, 0.04018598f, -0.03037218f, 0.02919767f, -0.03063644f, -0.06371244f, 0.03309781f, 
    0.02681674f, 0.01579309f, 0.00992499f, 0.01781810f, 0.05120578f, 0.00986070f, 0.03663857f, -0.02594921f, 
    -0.00758363f, -0.00240247f, 0.02002054f, -0.03457517f, 0.01257429f, -0.04643850f, -0.03406990f, -0.03645188f, 
    0.00883632f, -0.05998817f, 0.01728905f, -0.05074624f, -0.01806103f, -0.02328456f, -0.00721465f, -0.03471943f, 
    0.01201437f, 0.03663711f, -0.02125034f, -0.03459732f, -0.05860709f, 0.01600001f, -0.01306334f, -0.04061209f, 
    -0.03696494f, -0.05751371f, 0.03314988f, 0.00691770f, -0.00532180f, 0.04388215f, -0.02301239f, -0.02185941f, 
    -0.03084012f, 0.01589080f, 0.01000924f, 0.02962414f, -0.03054642f, 0.05616464f, 0.01084236f, -0.04372022f, 
    -0.02679095f, -0.05246447f, 0.05363820f, -0.01705359f, 0.02141356f, -0.03937694f, 0.03838808f, -0.00209357f, 
    -0.05556452f, 0.05178419f, -0.01048365f, -0.02203260f, -0.01956743f, 0.02341102f, -0.04063241f, -0.05928033f, 
    0.00799510f, -0.02825382f, -0.05633168f, 0.02947231f, 0.00081326f, 0.02111779f, 0.03801982f, 0.04519125f, 
    -0.02826237f, 0.00656025f, -0.00775574f, 0.02327300f, 0.05355404f, -0.03486582f, 0.04549717f, 0.00285539f, 
    -0.05149369f, 0.02863725f, -0.04884065f, 0.01451039f, 0.00651514f, -0.05481271f, 0.03399218f, 0.03430601f, 
    0.00931026f, 0.02222222f, -0.03608770f, 0.03002373f, 0.01483228f, -0.03412066f, -0.06162407f, -0.05554107f, 
    -0.01959036f, -0.04230557f, 0.03864696f, 0.01461489f, -0.01558574f, 0.01102624f, 0.00044236f, 0.02404911f, 
    -0.01732703f, -0.05827749f, 0.04884022f, 0.02785957f, -0.02984507f, -0.02284136f, -0.02736986f, -0.03800056f, 
    0.04176334f, -0.05208338f, -0.02373774f, 0.03761956f, -0.00684552f, -0.05086784f, -0.03660320f, -0.03721309f, 
    0.01730256f, -0.03478262f, -0.04617296f, 0.04139215f, -0.05451002f, -0.03053451f, 0.05049665f, -0.01943438f, 
    0.01858692f, -0.04204487f, -0.01760263f, -0.03410962f, 0.01532467f, -0.00951282f, 0.02399188f, -0.01474715f, 
    0.03248709f, -0.03562507f, -0.01659231f, -0.01682252f, -0.02304790f, -0.04506722f, -0.05660247f, -0.00430101f, 
    -0.01372053f, -0.03719165f, -0.06148454f, 0.04991597f, -0.05075745f, 0.00215278f, -0.04127015f, -0.05185558f, 
    0.00544629f, 0.02700975f, 0.04899751f, -0.05565322f, 0.02919656f, 0.00084967f, 0.00715832f, -0.05070971f, 
    -0.01768378f, 0.02048095f, -0.05831321f, -0.02930643f, 0.03640058f, -0.04577982f, -0.03682529f, -0.01470086f, 
    0.04590313f, -0.00919241f, 0.02777675f, -0.01765520f, 0.01512218f, 0.00542308f, 0.01425969f, 0.03618457f, 
    0.00573948f, -0.02244571f, 0.01536243f, -0.02587709f, 0.00951463f, 0.01908172f, -0.03744936f, -0.05303155f, 
    -0.01226051f, -0.01326901f, 0.04106124f, 0.05153656f, -0.05556681f, -0.00698007f, 0.03154108f, 0.05225987f, 
    -0.05925812f, -0.04685041f, -0.00908729f, 0.04839868f, -0.05801699f, -0.03186147f, -0.03306509f, 0.04503662f, 
    0.03067836f, 0.03042041f, 0.00318351f, 0.03252765f, 0.03025714f, -0.06217795f, -0.05802284f, 0.00422438f, 
    -0.05170111f, 0.01315636f, 0.01593658f, -0.00626603f, -0.01313000f, -0.02732052f, -0.02016112f, 0.04230631f, 
    -0.01322333f, -0.05934232f, -0.00748316f, -0.00436671f, -0.04268214f, -0.01471337f, -0.02335070f, -0.02455349f, 
    0.01472962f, 0.04262716f, 0.04622706f, -0.02100739f, 0.03797033f, -0.04907542f, 0.02564183f, -0.00110407f, 
    0.00100591f, -0.04021966f, 0.03748100f, 0.02821263f, -0.04717065f, 0.01180895f, -0.04005211f, -0.04460407f, 
    -0.03000423f, -0.00670286f, 0.00758031f, -0.05851783f, -0.00550348f, 0.04907107f, 0.02016932f, -0.00667829f, 
    -0.02842579f, 0.01515733f, -0.02356915f, -0.02113899f, -0.00273521f, -0.02894863f, -0.02748513f, 0.02764693f, 
    -0.01349596f, 0.03773138f, -0.04225043f, -0.01914741f, -0.01247172f, -0.03724953f, -0.03213204f, -0.00231549f, 
    -0.03177532f, 0.00903421f, -0.01467276f, 0.04842744f, -0.04592672f, -0.02263849f, -0.05650822f, -0.01095491f, 
    0.03654425f, 0.01778477f, -0.01005916f, 0.00482885f, 0.02627355f, -0.00673636f, -0.03760786f, -0.01039580f, 
    0.01153145f, 0.01083441f, 0.00795138f, -0.12434518f, -0.03375186f, 0.03551352f, -0.01924866f, -0.19510449f, 
    -0.12262151f, 0.10305367f, 0.08624594f, 0.11993546f, 0.03218126f, 0.05332962f, 0.00114852f, 0.14890650f, 
    0.07464662f, 0.07900035f, -0.10224254f, -0.25181299f, 0.11986820f, -0.14574143f, -0.03088115f, -0.04307242f, 
    -0.07621839f, -0.03551024f, 0.06895625f, 0.36694193f, -0.01408321f, -0.23378143f, -0.13602319f, -0.08319347f, 
    -0.27624997f, 0.12274028f, -0.06448704f, 0.02095170f, -0.09102785f, 0.18622789f, 0.23326784f, 0.08755763f, 
    0.00945987f, 0.03103209f, -0.09835977f, 0.18239324f, -0.09123783f, 0.11676405f, -0.18836361f, -0.35312575f, 
    -0.02318859f, 0.07325176f, -0.14796779f, 0.04182590f, 0.08971445f, 0.07731827f, 0.11417159f, 0.19033845f, 
    -0.01372513f, -0.12270366f, 0.12079854f, 0.19677046f, 0.05738177f, -0.02305941f, -0.17575008f, -0.12789115f, 
    0.19259015f, 0.24006473f, -0.07898148f, -0.04873728f, 0.05120581f, 0.06277626f, -0.05209073f, -0.05405205f, 
    -0.00116652f, -0.08063895f, 0.32605597f, -0.12543818f, 0.05823840f, 0.05339654f, 0.10308564f, -0.00706731f, 
    0.00858179f, 0.12296312f, -0.23129781f, -0.20374879f, -0.15143466f, 0.04244404f, -0.09796553f, 0.03000451f, 
    -0.09387515f, 0.07014599f, 0.21471217f, 0.24676448f, 0.04038404f, 0.12645945f, 0.03491655f, 0.14366764f, 
    0.01928776f, -0.00695233f, 0.10563744f, 0.16782366f, 0.13086405f, 0.08241370f, 0.09186705f, 0.03543392f, 
    -0.12487288f, -0.11272273f, 0.02614445f, 0.01617637f, 0.17447157f, 0.02744618f, -0.06632371f, 0.10905614f, 
    0.12259667f, 0.05220729f, 0.00940537f, 0.09959040f, 0.12821999f, 0.20261081f, -0.16852783f, 0.34880248f, 
    0.03003784f, 0.04247517f, 0.00511696f, 0.06930152f, 0.14967979f, -0.03336617f, -0.00012933f, -0.09169868f, 
    0.01226191f, -0.08002064f, -0.03615353f, -0.11882286f, -0.07321319f, -0.01131543f, -0.00261490f, -0.02982456f, 
    0.00462276f, -0.12425895f, 0.08596765f, -0.06945840f, 0.11189453f, 0.03445541f, 0.04863408f, -0.07046869f, 
    0.07411662f, 0.16546631f, 0.00318202f, -0.07404543f, -0.17280902f, -0.20785619f, 0.09839124f, 0.09011418f, 
    -0.07114358f, 0.30753896f, 0.02793231f, -0.26408324f, -0.00114668f, 0.02096770f, -0.06193664f, 0.08864864f, 
    -0.03025671f, -0.08174862f, -0.25346637f, -0.07535759f, -0.28438106f, 0.16198801f, 0.01740893f, 0.05869826f, 
    0.09722865f, -0.08113301f, 0.06836557f, -0.08306976f, 0.05982045f, 0.52080780f, 0.10391109f, 0.19970363f, 
    0.08496194f, 0.02012603f, -0.07862245f, 0.00203155f, 0.08338366f, 0.22622828f, -0.13003160f, 0.13197123f, 
    0.04951397f, 0.03486407f, 0.05028534f, -0.00012428f, 0.00486817f, -0.07416487f, -0.15854891f, 0.01421646f, 
    -0.00838493f, 0.01101039f, -0.00837522f, 0.15815626f, -0.20127574f, 0.12016557f, 0.06952450f, -0.14789243f, 
    -0.12038153f, 0.14421247f, 0.03829845f, 0.06700245f, 0.03122277f, -0.17466004f, -0.01497273f, 0.29396209f, 
    -0.08559397f, 0.25360978f, -0.05608793f, -0.02157146f, 0.02298241f, 0.12014280f, -0.10890456f, -0.05281666f, 
    0.11318214f, -0.28805432f, -0.42629436f, -0.06993933f, -0.06050812f, 0.07262953f, 0.08721124f, 0.05134217f, 
    0.04941010f, -0.02791047f, -0.19137856f, -0.06030858f, 0.04496640f, 0.08992109f, 0.10143325f, -0.02920117f, 
    0.07338470f, -0.00700836f, -0.41808927f, 0.01442285f, 0.07405797f, 0.06305658f, 0.00403185f, 0.05554006f, 
    0.05733312f, 0.10322890f, 0.09161463f, 0.21103172f, -0.03764999f, -0.18275881f, 0.11190339f, 0.08575889f, 
    -0.00158999f, 0.12792659f, -0.02127768f, -0.22948551f, -0.31412476f, -0.14226247f, 0.00266882f, 0.11817166f, 
    -0.01371596f, -0.07104263f, 0.02259146f, -0.18142703f, 0.03281287f, -0.03524742f, 0.07525666f, -0.06715111f, 
    0.04768748f, -0.05386837f, -0.29398724f, -0.02478223f, -0.22544634f, -0.07532045f, 0.04176854f, 0.01399314f, 
    0.09372519f, -0.28011999f, -0.11749200f, -0.13083598f, 0.07736683f, -0.11421057f, -0.07831233f, 0.16606611f, 
    0.03600152f, -0.03348357f, -0.04141444f, 0.06932743f, 0.05053599f, 0.10576103f, 0.18346345f, 0.09015413f, 
    -0.04736638f, 0.19728075f, 0.10533030f, 0.15834562f, -0.10861284f, -0.13579923f, -0.01593166f, 0.06282524f, 
    -0.02925343f, -0.03081652f, -0.04414335f, -0.04776815f, -0.00921240f, -0.09552072f, -0.02177620f, 0.12664844f, 
    -0.01668973f, 0.11744772f, -0.46021312f, 0.17108959f, -0.09772797f, 0.21357526f, 0.06073371f, -0.20645991f, 
    0.14695291f, -0.05716060f, 0.03926262f, -0.17298627f, -0.10687756f, -0.30629167f, 0.21705262f, -0.26456422f, 
    0.27520201f, 0.09828612f, 0.10250352f, -0.28887165f, 0.11882808f, -0.06827180f, -0.03374342f, -0.02739889f, 
    0.08841738f, -0.06851020f, 0.16367975f, 0.09190101f, 0.15390347f, -0.25534528f, 0.39067227f, 0.01086607f, 
    0.13508244f, -0.08806355f, -0.02557400f, 0.11012707f, -0.08689186f, 0.19549082f, 0.09460985f, 0.09060749f, 
    0.04532655f, 0.09268340f, 0.07797000f, -0.08643056f, 0.11381614f, -0.17718741f, -0.18249474f, -0.14437060f, 
    0.11240700f, 0.15356112f, -0.11482726f, -0.17871238f, -0.10885061f, 0.00792777f, 0.18666466f, -0.02276156f, 
    -0.19023027f, -0.18847781f, 0.18419805f, 0.23096052f, -0.05116826f, 0.00890269f, 0.20277572f, -0.16197635f, 
    0.24563669f, -0.31641728f, 0.20148209f, -0.14626861f, 0.09988877f, -0.07018587f, -0.14485216f, 0.13635024f, 
    -0.10699943f, 0.06100861f, -0.03345706f, -0.01690707f, -0.03125300f, 0.00699687f, -0.02774313f, -0.03647950f, 
    -0.00614750f, -0.05957523f, -0.06104482f, -0.07446675f, 0.00180857f, 0.04847950f, 0.00107145f, 0.10185434f, 
    0.10827255f, 0.15723251f, 0.00931984f, 0.01218323f, -0.21362936f, -0.16294719f, 0.31509346f, 0.04612830f, 
    0.17107312f, -0.13227189f, 0.11068876f, -0.10002010f, -0.13082704f, 0.07753427f, -0.40863985f, -0.00711359f, 
    0.05204165f, -0.02822224f, 0.08159279f, 0.09102947f, -0.05458549f, -0.05647816f, -0.08826922f, 0.22358318f, 
    -0.33671108f, 0.07011524f, -0.20325990f, -0.15582438f, 0.02152511f, 0.09308675f, 0.09978849f, -0.12085798f, 
    -0.03952194f, -0.12521282f, 0.02951371f, -0.11992833f, -0.08260134f, 0.06261638f, 0.11928698f, -0.05866450f, 
    -0.13968366f, -0.12680341f, -0.04422641f, 0.11933243f, 0.11780101f, 0.06039689f, -0.06508286f, -0.09705279f, 
    0.17914739f, -0.18016763f, -0.03704218f, -0.21977001f, 0.26455346f, 0.23238286f, -0.03088954f, 0.00436935f, 
    -0.14337397f, 0.09095038f, 0.07150546f, -0.13626860f, -0.09600645f, 0.04392733f, -0.01919626f, 0.02898014f, 
    -0.04363075f, 0.00674421f, -0.21655382f, 0.20019290f, -0.00641658f, 0.00586786f, -0.27370346f, 0.00796730f, 
    -0.10149292f, 0.27327237f, 0.47248000f, -0.19234659f, -0.05277235f, 0.02887653f, -0.17496614f, 0.12068721f, 
    -0.06145474f, 0.21264353f, -0.06740221f, 0.05787878f, -0.04626510f, 0.12081216f, 0.19581966f, 0.08978197f, 
    0.10777180f, -0.02994612f, 0.02609731f, 0.02484897f, 0.14541027f, 0.05416503f, -0.04818667f, -0.19613750f, 
    0.03580987f, 0.07709450f, -0.10092064f, 0.00942235f, 0.00814542f, 0.09854311f, 0.12995477f, 0.07918406f, 
    0.09597629f, 0.07758732f, -0.35367888f, 0.08535801f, -0.13653050f, 0.10068697f, 0.09077068f, -0.03663739f, 
    -0.03083989f, 0.25216177f, -0.22865072f, -0.07300115f, -0.12083344f, -0.02550437f, 0.03008175f, 0.03823122f, 
    0.01732269f, 0.07633513f, -0.20160796f, -0.07559644f, -0.00788476f, 0.03199778f, -0.02650980f, 0.01365526f, 
    -0.13279530f, 0.00630743f, 0.12657237f, 0.03945935f, 0.02015122f, -0.02648681f, -0.04539306f, -0.00524265f, 
    -0.07164628f, 0.10900962f, -0.10901006f, -0.37297300f, 0.07770374f, 0.14180638f, -0.11572319f, -0.04015419f, 
    -0.10304657f, 0.04847132f, 0.04457415f, -0.09590959f, 0.14676091f, -0.02649912f, -0.03072781f, 0.11649287f, 
    0.06232877f, 0.08256882f, -0.04990047f, 0.01160942f, 0.07532852f, -0.40565211f, -0.05840264f, 0.13415085f, 
    -0.10801113f, -0.35373667f, -0.01805498f, 0.18216363f, 0.00092563f, 0.00868107f, -0.15440185f, -0.10616540f, 
    0.10445115f, 0.35108116f, -0.01056615f, -0.03383335f, 0.01829174f, -0.28593746f, -0.13949993f, 0.04426764f, 
    -0.11750026f, -0.06518651f, 0.04489213f, 0.16721444f, 0.02991404f, 0.07321782f, -0.03215366f, 0.12367351f, 
    -0.04527247f, -0.00262176f, -0.03187851f, -0.04437906f, -0.20450383f, -0.08193938f, 0.06066991f, -0.19705047f, 
    0.05254170f, 0.06357532f, 0.33785048f, 0.18548463f, 0.01407454f, 0.04246924f, -0.01354068f, 0.04491597f, 
    0.08122326f, 0.14559618f, 0.11482765f, -0.26491162f, -0.23212998f, -0.09990738f, 0.02133743f, 0.06660591f, 
    0.05253492f, -0.03850551f, 0.03529140f, -0.49310124f, -0.48165837f, -0.13001797f, -0.14254174f, -0.03566319f, 
    -0.25106773f, -0.36662284f, -0.29118094f, -0.02208488f, 0.14683211f, 0.00323973f, 0.05371356f, -0.03884414f, 
    0.06173498f, 0.03552096f, -0.16271856f, 0.10446321f, -0.00825602f, -0.06009606f, -0.05068039f, -0.20924999f, 
    -0.04886014f, 0.02583859f, -0.15992485f, 0.08887877f, -0.04137472f, 0.02903003f, -0.24273494f, -0.10714029f, 
    -0.08029951f, -0.15259464f, 0.12657228f, 0.03283540f, 0.07385577f, 0.18773308f, 0.11925419f, 0.14864364f, 
    0.10109168f, 0.05933073f, 0.06636166f, 0.04214008f, -0.09030703f, 0.06547630f, 0.11007465f, 0.09520900f, 
    0.11238631f, 0.01961525f, -0.00032836f, 0.13668546f, 0.20115151f, -0.00361225f, -0.11098210f, 0.07870089f, 
    0.08485796f, 0.07908501f, -0.07403905f, -0.10987551f, -0.02349077f, -0.06306483f, -0.01428926f, -0.01439236f, 
    -0.07582291f, -0.00768603f, 0.18825401f, 0.09402752f, -0.10602337f, -0.03300089f, 0.12823980f, 0.01300615f, 
    0.24194238f, 0.21503372f, 0.10840056f, 0.24904720f, 0.22841573f, 0.14827730f, -0.11910643f, -0.00430816f, 
    0.08115780f, 0.12310274f, 0.08617442f, 0.23840481f, 0.40090802f, 0.05149059f, 0.19322430f, -0.35933292f, 
    -0.08291974f, -0.05724824f, 0.00279389f, 0.07312496f, 0.10389090f, 0.03440322f, 0.01656697f, -0.02806845f, 
    -0.10342173f, 0.16866657f, 0.01861541f, 0.09204242f, 0.20366518f, 0.07834917f, -0.00077947f, -0.10477471f, 
    -0.32943428f, -0.11921781f, 0.15372342f, -0.10528132f, -0.15104415f, -0.29745454f, -0.05273857f, -0.05544576f, 
    -0.05524266f, 0.07778565f, 0.21098420f, 0.29309863f, 0.01996117f, 0.21079755f, 0.09075021f, 0.00262432f, 
    0.18014368f, 0.00668870f, 0.05718350f, 0.03034762f, -0.05996935f, -0.16840464f, -0.15536214f, -0.08572324f, 
    0.18060091f, -0.30975085f, -0.24672572f, -0.26234004f, -0.06032152f, 0.10410099f, -0.01298680f, -0.02892961f, 
    -0.15021089f, 0.12192076f, -0.15446535f, -0.09997457f, -0.17824894f, -0.13987887f, -0.13969694f, 0.05391880f, 
    -0.03923734f, -0.03461543f, -0.06257485f, -0.17238735f, -0.14640982f, -0.15103066f, -0.12602840f, -0.03380561f, 
    0.01302626f, -0.07244483f, -0.00384012f, 0.07702327f, 0.61505973f, 0.09374579f, 0.12035721f, -0.09727997f, 
    -0.22240646f, -0.21421432f, -0.07946552f, 0.08434929f, 0.01444486f, 0.20643902f, -0.08334263f, 0.07999392f, 
    0.14311466f, 0.02917457f, 0.08870627f, 0.16904852f, 0.12345586f, 0.15006100f, 0.51912600f, 0.23400573f, 
    0.28575110f, 0.08908873f, -0.12049754f, -0.06380972f, -0.01995783f, 0.04179854f, -0.00914174f, -0.35831723f, 
    -0.10233115f, -0.22011961f, 0.01516687f, -0.13304450f, 0.05716908f, 0.13064824f, -0.07390346f, 0.09602125f, 
    0.07770676f, -0.02369431f, -0.28743643f, -0.06417833f, 0.10909272f, -0.03685007f, 0.01602375f, 0.03181564f, 
    0.03647024f, 0.25904396f, 0.13130942f, 0.11618491f, -0.14489163f, -0.01927380f, 0.06251201f, 0.04217752f, 
    0.09635970f, 0.29704028f, 0.05322507f, -0.07126024f, 0.05013847f, 0.18964581f, -0.24927802f, 0.08894562f, 
    0.03559133f, 0.07227940f, 0.11496436f, 0.12069175f, -0.21499790f, -0.01010309f, -0.03778447f, 0.04544946f, 
    0.20371065f, 0.05727953f, 0.19555216f, 0.12370019f, -0.41916084f, -0.15248750f, -0.25931647f, -0.09783775f, 
    -0.06180851f, 0.00979836f, 0.21658258f, 0.00864323f, -0.14908178f, -0.14325753f, -0.26026589f, -0.32001445f, 
    -0.08937898f, 0.06977801f, -0.23711969f, -0.00002840f, 0.04242829f, -0.16001530f, -0.26185566f, -0.34026259f, 
    -0.31528828f, -0.26986516f, -0.11728173f, -0.16764411f, -0.13397101f, -0.15819570f, -0.08610234f, 0.06476989f, 
    -0.02819196f, -0.13522749f, 0.00844250f, 0.06856982f, 0.08222243f, 0.03941778f, 0.10379152f, 0.12320911f, 
    -0.04041595f, 0.00410479f, 0.03591169f, 0.04225468f, 0.03480559f, 0.03229327f, 0.02074698f, 0.00246644f, 
    0.04544945f, -0.06235670f, -0.00620498f, -0.06745768f, -0.00434192f, -0.00226909f, -0.03236219f, -0.03672647f, 
    -0.03366102f, 0.01082364f, 0.05437443f, -0.02220675f, 0.04857354f, -0.03276057f, 0.00468004f, 0.01384781f, 
    -0.01597292f, -0.00645290f, 0.02602306f, -0.02039852f, -0.01504055f, -0.05716403f, 0.00765704f, -0.04234100f, 
    0.02061096f, 0.05436283f, 0.05210511f, -0.02670156f, -0.01350311f, 0.00174472f, 0.02831633f, 0.00768204f, 
    -0.04371532f, -0.00295730f, -0.00068218f, 0.01452573f, -0.03812441f, -0.01419681f, 0.03335772f, -0.00921140f, 
    0.03498004f, -0.06095612f, -0.04097657f, 0.04868607f, 0.00387366f, 0.03783746f, 0.02593061f, -0.04268660f, 
    0.00638020f, -0.04659199f, -0.03202914f, 0.04196306f, 0.02965962f, 0.04656950f, 0.00732551f, -0.05080774f, 
    -0.01076469f, 0.00229910f, -0.05887879f, -0.05936522f, 0.00840993f, 0.01358435f, -0.05986782f, -0.03902646f, 
    -0.00985404f, 0.05532585f, -0.03964932f, 0.02964508f, 0.03202639f, 0.05042078f, -0.06421358f, 0.04449799f, 
    -0.05861965f, -0.00126470f, -0.01580098f, -0.01675389f, -0.02042886f, 0.04622469f, 0.03891769f, -0.04973819f, 
    -0.02696222f, 0.01707210f, 0.01739767f, -0.03040496f, -0.00844491f, 0.02904306f, 0.04079326f, -0.04551983f, 
    -0.02724149f, -0.02438941f, -0.05772503f, 0.04042549f, -0.04583663f, 0.02587494f, -0.00524068f, -0.01259611f, 
    -0.05254031f, -0.00453455f, 0.01652474f, -0.02317428f, 0.04271012f, -0.05112544f, -0.00023879f, 0.01822853f, 
    -0.01600557f, -0.01302376f, 0.03556510f, -0.02364277f, 0.02222145f, 0.01043719f, -0.03478296f, 0.00599065f, 
    -0.00987308f, 0.03675079f, -0.01725394f, 0.01113713f, -0.03822668f, 0.02003420f, 0.05524400f, -0.04760699f, 
    0.00649159f, -0.04027239f, -0.02586528f, -0.05651288f, 0.01504777f, 0.05393123f, -0.03048152f, 0.00688072f, 
    -0.01061918f, -0.05353440f, -0.02917461f, -0.01704642f, 0.04444846f, -0.04095459f, 0.02960427f, -0.00324648f, 
    0.03001367f, 0.02747216f, 0.01967454f, 0.04011257f, 0.01452767f, -0.05254912f, -0.03018494f, 0.02331950f, 
    -0.06275530f, -0.01764228f, 0.01902101f, -0.02203310f, -0.04274440f, 0.00937523f, 0.05129388f, -0.06156639f, 
    -0.05705277f, -0.00451935f, -0.05470984f, -0.00255682f, -0.02542523f, 0.02168806f, 0.00962370f, -0.04851544f, 
    0.04043690f, 0.01333238f, 0.00172406f, -0.05671421f, 0.03274816f, 0.00744694f, 0.05268184f, -0.01547525f, 
    0.01330352f, -0.06135951f, -0.07143702f, 0.02323525f, -0.00527785f, -0.03968864f, 0.00640009f, -0.05250873f, 
    0.04101548f, 0.00283887f, -0.03913924f, -0.02928299f, 0.04582591f, 0.03654473f, 0.03364812f, 0.05052954f, 
    0.01180774f, -0.01618150f, -0.03784239f, 0.04006583f, -0.01943188f, -0.00861641f, -0.04520462f, -0.00050839f, 
    -0.04054570f, -0.01902980f, 0.01761860f, -0.01930663f, -0.03978380f, -0.03343695f, -0.01199016f, -0.03407607f, 
    -0.00129003f, -0.02797232f, -0.03704273f, -0.01694237f, -0.05671652f, -0.03241925f, -0.00837471f, -0.02842928f, 
    -0.03952310f, 0.05625378f, -0.00846773f, 0.02091215f, 0.00090579f, -0.02972632f, -0.00376849f, -0.03299053f, 
    0.03972037f, -0.01720985f, -0.04709735f, -0.03097778f, 0.00730850f, -0.03217015f, -0.01116792f, 0.04246886f, 
    0.01036192f, 0.05318058f, -0.04884241f, 0.04148528f, -0.02530338f, -0.01772218f, 0.03475745f, 0.01085662f, 
    -0.00078933f, -0.00447866f, -0.05818456f, 0.02191163f, -0.01285005f, 0.04797465f, -0.00356069f, 0.00427930f, 
    0.00595894f, 0.03595266f, -0.01920540f, -0.01554349f, 0.01340650f, 0.01638620f, 0.01055575f, -0.01492625f, 
    -0.00707832f, -0.02517143f, -0.01279566f, -0.02504014f, 0.01790516f, 0.05015578f, 0.02770596f, -0.00732981f, 
    0.03448584f, -0.02875782f, 0.03165576f, 0.00738639f, -0.02810196f, -0.01030563f, -0.01607683f, -0.03039327f, 
    0.01275547f, -0.04648407f, -0.00774709f, 0.04736752f, 0.02709649f, 0.01576043f, -0.04841053f, 0.00362300f, 
    0.02600639f, -0.05450336f, 0.00966287f, -0.03429310f, -0.05981014f, -0.04285835f, -0.02965998f, 0.00016149f, 
    -0.03618505f, 0.15120408f, 0.23352559f, -0.19332404f, -0.06373887f, 0.12488326f, 0.07020412f, -0.06175580f, 
    0.06226210f, -0.07062721f, 0.01173201f, 0.14032602f, 0.08597077f, -0.00902606f, -0.00157755f, -0.13990425f, 
    0.12586649f, -0.06627273f, 0.13922337f, 0.09630795f, -0.24069159f, -0.00898490f, 0.03642065f, -0.07205214f, 
    0.05549525f, -0.14832258f, -0.05720197f, -0.08699192f, 0.12442430f, -0.08099842f, 0.11449226f, -0.01754016f, 
    -0.00212236f, -0.21157612f, 0.07125275f, 0.00639776f, 0.01024157f, 0.07371537f, -0.02682158f, 0.10293673f, 
    -0.01403761f, -0.00038189f, -0.03753957f, 0.12280704f, 0.00864600f, 0.04517609f, 0.14671047f, 0.18965656f, 
    -0.08123589f, 0.09191541f, 0.01210991f, 0.08463884f, 0.04743401f, 0.05433434f, -0.02325489f, -0.04333698f, 
    -0.16350493f, -0.12270872f, -0.24123268f, -0.22552684f, -0.07979975f, 0.08709367f, 0.00801962f, -0.25661227f, 
    -0.16788767f, 0.21779411f, -0.04935854f, -0.02137226f, -0.02517781f, -0.04066056f, -0.08897555f, -0.00927720f, 
    -0.18612358f, -0.16773677f, 0.24784051f, 0.12162302f, 0.09367038f, -0.07669120f, -0.10198194f, -0.01932397f, 
    -0.02865522f, 0.15517692f, 0.16818845f, -0.22508937f, -0.00137125f, 0.12212095f, -0.05357919f, 0.02041115f, 
    -0.12767874f, 0.00451249f, -0.17954709f, 0.09134676f, -0.15357649f, -0.21193500f, -0.17901538f, 0.09749833f, 
    -0.05241841f, 0.12923342f, 0.16338526f, -0.15965165f, -0.08232334f, -0.01486921f, -0.19519983f, -0.05436531f, 
    0.07594312f, -0.07986188f, 0.11536603f, 0.12495846f, -0.07342739f, -0.07441571f, 0.27281514f, 0.06386901f, 
    0.13201107f, 0.02358179f, -0.42801952f, 0.12196389f, -0.14865208f, 0.00705739f, -0.18823513f, -0.19591181f, 
    -0.01610451f, -0.01353897f, 0.10151768f, 0.03475893f, -0.04943369f, 0.03790045f, 0.00114283f, -0.04756402f, 
    -0.05848713f, -0.04213205f, 0.09176456f, -0.09633058f, -0.04407026f, -0.23983589f, -0.23974641f, -0.10561159f, 
    0.05640773f, 0.24110739f, -0.02588340f, 0.13335711f, -0.01786779f, -0.02191664f, -0.07277155f, 0.18142860f, 
    0.07619949f, 0.02721911f, 0.15596168f, 0.14167416f, 0.03685069f, 0.11889898f, -0.06038364f, -0.07247438f, 
    0.06344543f, 0.22481899f, -0.07104330f, -0.11061190f, 0.00916861f, -0.03760379f, 0.03879534f, 0.02300329f, 
    -0.02702708f, 0.00326351f, -0.11317382f, -0.18388347f, -0.12837285f, 0.14732631f, 0.08030336f, -0.01829793f, 
    0.07238075f, -0.09748021f, -0.14964616f, -0.06363473f, 0.10254957f, 0.10267658f, -0.20004316f, -0.04017343f, 
    0.03679378f, 0.13026300f, 0.27153203f, 0.07122600f, -0.21902357f, -0.17461067f, -0.13069981f, -0.05563466f, 
    0.01206434f, 0.03884448f, -0.16684639f, -0.02707936f, 0.05935446f, 0.10653263f, 0.02846139f, 0.03756225f, 
    -0.10247096f, 0.23273931f, 0.09942313f, 0.08546217f, -0.03809702f, -0.01365380f, 0.13947956f, -0.16018768f, 
    0.07171978f, -0.01157936f, 0.14586903f, -0.00224651f, -0.19208176f, -0.15797031f, 0.06946669f, 0.09661689f, 
    0.39975885f, 0.17142156f, -0.05204823f, 0.05981274f, -0.07105271f, 0.11152998f, 0.14695126f, 0.05173125f, 
    0.07577065f, -0.02545379f, -0.13646244f, 0.06207213f, -0.01602224f, -0.13229313f, -0.07462983f, 0.03722778f, 
    -0.08787172f, -0.05145042f, -0.27372292f, -0.15342847f, 0.09032322f, -0.00050079f, -0.02755178f, -0.03623435f, 
    -0.10535490f, -0.16132684f, 0.09494772f, 0.11150121f, 0.11406617f, 0.08478241f, 0.04845507f, 0.07081874f, 
    0.04839528f, 0.07495125f, -0.03733136f, -0.03375991f, 0.05882303f, 0.17954250f, -0.02924887f, 0.06453154f, 
    -0.11710481f, 0.05571880f, 0.14987727f, 0.11375000f, 0.09068488f, 0.24086528f, -0.13511771f, 0.04180028f, 
    0.07866130f, 0.14244339f, 0.08443552f, 0.05229915f, -0.05597290f, -0.38749102f, -0.12874012f, 0.07777785f, 
    0.25903785f, -0.01480877f, 0.33999538f, -0.29101124f, -0.30080301f, -0.13836628f, -0.06825969f, -0.13108969f, 
    -0.02480009f, 0.22137755f, 0.10350120f, -0.10552721f, -0.25066432f, -0.10614395f, -0.07129791f, 0.18388362f, 
    0.15797570f, -0.21281841f, -0.10181562f, 0.06617502f, 0.12789115f, 0.17993769f, 0.12414268f, -0.00559084f, 
    -0.14916272f, 0.23269932f, 0.15448789f, -0.16284114f, 0.20801538f, -0.14387131f, -0.09019804f, 0.08053270f, 
    0.11931649f, -0.01802254f, 0.16379921f, 0.26518261f, 0.04661037f, -0.01315639f, 0.01476168f, -0.10484217f, 
    0.02186550f, 0.11321389f, 0.31098413f, -0.04631676f, -0.11133778f, -0.11886086f, 0.00001671f, -0.06522209f, 
    -0.10949221f, 0.06263090f, -0.02268943f, 0.18225563f, 0.44953877f, -0.05729123f, -0.03847757f, -0.17343009f, 
    -0.12259901f, 0.08829525f, -0.00878869f, -0.15314887f, -0.20323195f, 0.13693430f, 0.23901990f, 0.16261993f, 
    -0.10262033f, -0.13301922f, -0.15784802f, -0.03697377f, -0.06862186f, 0.14082552f, 0.30010843f, 0.22289605f, 
    -0.05891991f, -0.03185520f, 0.06532668f, 0.09679656f, -0.09848705f, -0.09249954f, 0.07874533f, 0.07974043f, 
    0.12722416f, 0.02327439f, -0.03237322f, -0.11917188f, 0.07665787f, -0.00618994f, 0.07193892f, -0.42726541f, 
    0.12809749f, 0.09473821f, -0.11794607f, -0.09633169f, -0.00429375f, -0.15771592f, 0.04665026f, 0.01960700f, 
    -0.03582083f, -0.02863036f, 0.25355339f, -0.09065083f, -0.01626529f, -0.05481341f, -0.03913035f, 0.03294002f, 
    -0.02260604f, 0.26003537f, -0.10960849f, -0.14939095f, -0.00810484f, 0.09651256f, 0.03311364f, 0.00638355f, 
    0.00734890f, -0.09692203f, -0.09314298f, 0.08209833f, 0.07120870f, 0.07331954f, 0.05529963f, -0.02830118f, 
    0.04487226f, 0.14294061f, 0.13458939f, -0.02414529f, 0.00274852f, 0.10898846f, 0.13951373f, -0.02423155f, 
    0.02389988f, -0.01536250f, -0.00311909f, 0.02873548f, -0.01962635f, 0.18839170f, -0.15405972f, 0.05337891f, 
    -0.13081323f, 0.10601588f, 0.00777421f, 0.16881932f, -0.19169490f, -0.02536134f, -0.41704205f, 0.17382596f, 
    -0.27924860f, 0.18080725f, -0.06943952f, 0.12420505f, 0.03416414f, -0.03740143f, 0.05557209f, -0.11782820f, 
    0.00216242f, -0.16266359f, -0.05895045f, 0.06555696f, 0.04598901f, -0.14261860f, 0.11240763f, -0.44001743f, 
    0.08494421f, -0.23828913f, -0.08025978f, 0.06995446f, 0.02410663f, 0.21247321f, -0.05232841f, 0.10410602f, 
    0.12794250f, 0.22289678f, -0.07284900f, -0.00612813f, -0.14037035f, 0.00964734f, 0.00921195f, -0.10688090f, 
    -0.04492300f, 0.20954277f, -0.12774660f, -0.39474687f, -0.02964655f, -0.02332511f, 0.03660739f, 0.06378084f, 
    -0.11092208f, -0.09829080f, -0.04830251f, 0.00657101f, -0.06919169f, -0.10877740f, -0.06452254f, -0.20907770f, 
    -0.04790739f, -0.01083633f, 0.18010432f, -0.18046856f, 0.12184949f, 0.30704468f, -0.24796900f, 0.21907045f, 
    -0.14036450f, 0.11405180f, 0.07847465f, -0.05359558f, -0.16101679f, -0.10334311f, -0.08617493f, -0.00138233f, 
    -0.01170944f, 0.03215525f, 0.08474170f, -0.00879830f, 0.08712132f, -0.19231372f, -0.02735720f, 0.07775106f, 
    -0.05450597f, -0.01957278f, 0.05146800f, 0.04822697f, 0.14917201f, 0.06695054f, -0.15740655f, 0.21623755f, 
    -0.04170121f, 0.03848927f, -0.14898401f, -0.11197692f, -0.01927501f, 0.12280268f, -0.01812973f, 0.49605292f, 
    -0.11524435f, 0.07028012f, -0.14024545f, 0.07663105f, 0.03295940f, 0.06255531f, 0.11863225f, 0.05734092f, 
    0.15431246f, -0.13182741f, -0.06788471f, -0.02025540f, -0.00159274f, 0.05470932f, 0.07797470f, -0.05203668f, 
    0.01487587f, 0.03522416f, -0.22777516f, 0.17721820f, -0.03642871f, -0.10720934f, -0.14691685f, 0.12092236f, 
    -0.12844002f, 0.07709504f, -0.10181683f, 0.26847658f, 0.21862742f, -0.02679721f, 0.07961238f, -0.08682089f, 
    0.00828533f, 0.17714141f, 0.05868346f, 0.17610477f, 0.14159295f, -0.19234249f, -0.07657097f, -0.04686566f, 
    0.03948849f, -0.02727678f, 0.08820467f, -0.06498665f, -0.06211622f, -0.09407789f, 0.08566527f, -0.13369302f, 
    0.11138262f, 0.00790381f, -0.01771486f, 0.13945220f, -0.03891634f, -0.24152346f, 0.16367470f, -0.20703933f, 
    -0.15752119f, 0.12608878f, -0.00633350f, -0.05452220f, -0.07258459f, 0.01892349f, 0.16413015f, 0.08624006f, 
    0.26383772f, -0.23346888f, -0.22282904f, -0.36267138f, 0.05909641f, -0.10997026f, -0.07663839f, 0.04753253f, 
    0.01457954f, 0.26665699f, -0.00752217f, 0.20478368f, -0.21464399f, 0.00156796f, 0.22483522f, 0.02366568f, 
    -0.15576404f, -0.21198425f, 0.01260960f, -0.07601559f, 0.10956436f, -0.16801518f, -0.10494351f, -0.02708595f, 
    -0.15160990f, -0.04952445f, 0.17557102f, -0.14394379f, -0.17008327f, 0.00221928f, 0.02594852f, 0.10794043f, 
    -0.06943946f, 0.11397074f, -0.13839926f, 0.03249191f, 0.09378088f, -0.06233934f, -0.15559892f, -0.12495010f, 
    0.04963669f, 0.04316964f, 0.07170451f, -0.36819679f, 0.02814146f, 0.10440177f, 0.07142172f, -0.06691444f, 
    -0.03963296f, -0.15743139f, -0.09356410f, 0.00581065f, 0.05835867f, -0.09574009f, -0.02004868f, 0.02075507f, 
    0.01984469f, -0.06215565f, -0.01132413f, -0.19393437f, 0.21606907f, -0.30935347f, 0.01077475f, 0.02224346f, 
    -0.11475857f, 0.01379472f, 0.00746847f, -0.04759980f, -0.02207495f, -0.11004072f, -0.14592913f, -0.06560482f, 
    0.06653644f, -0.07761061f, 0.05534667f, -0.04858820f, 0.04950858f, 0.05648601f, 0.09620677f, 0.20659493f, 
    -0.07295238f, 0.05872721f, -0.27130282f, -0.06622862f, 0.09931912f, 0.11439601f, -0.04147422f, 0.06781163f, 
    -0.12973255f, 0.05889801f, -0.15128866f, -0.12113748f, 0.14933915f, -0.02777325f, 0.13935542f, 0.12575477f, 
    0.02398022f, -0.21887359f, 0.02575179f, 0.12968805f, 0.04604175f, -0.09622334f, 0.05301789f, -0.09175842f, 
    0.05555485f, 0.10668726f, -0.04025709f, -0.18345675f, -0.13330260f, -0.02423655f, 0.06208635f, 0.06238145f, 
    0.12415593f, 0.14110875f, 0.00994711f, 0.16903797f, 0.00262062f, 0.16824870f, 0.00240402f, 0.04448689f, 
    0.12342785f, 0.00743748f, 0.15635447f, 0.10403646f, 0.13936973f, 0.09683031f, 0.35019666f, -0.10247000f, 
    -0.24826182f, 0.10412297f, -0.11919536f, 0.10980821f, 0.10051140f, 0.03785783f, -0.03504711f, 0.00297778f, 
    -0.05579507f, -0.01056673f, 0.01019093f, 0.02226732f, 0.02820183f, 0.08133773f, -0.09409823f, -0.01851843f, 
    -0.08970760f, -0.07697423f, 0.10965936f, 0.01530992f, -0.13779899f, 0.04916574f, -0.17756943f, 0.34321788f, 
    0.01623757f, 0.24967816f, -0.06028327f, 0.04049120f, -0.21525608f, 0.09870251f, 0.02779912f, 0.05471583f, 
    0.14737500f, -0.17382099f, -0.03565022f, -0.18375026f, 0.02331647f, 0.06687143f, 0.05572141f, 0.01144421f, 
    0.21540149f, -0.08190615f, 0.10504635f, 0.20234750f, 0.06433100f, 0.05726929f, 0.05451275f, 0.01529967f, 
    0.07603844f, 0.08158234f, -0.09742247f, -0.04280616f, -0.18630406f, -0.04905640f, -0.03474464f, -0.15846211f, 
    -0.15596841f, -0.18064019f, -0.04871270f, -0.15669717f, -0.19495881f, -0.06655671f, -0.07593447f, -0.06328469f, 
    -0.03483425f, 0.06311938f, 0.06846645f, 0.19189377f, 0.23045233f, -0.06891505f, -0.11952796f, -0.04268675f, 
    -0.04293215f, -0.10829996f, -0.03056743f, 0.22133946f, 0.24668269f, 0.05319953f, -0.18778174f, -0.00949134f, 
    0.05730982f, 0.02764928f, 0.04617734f, 0.05525803f, 0.10057496f, -0.08464696f, 0.23248300f, 0.12168186f, 
    0.19634193f, -0.01137662f, -0.07065393f, 0.04651852f, -0.17831475f, 0.23406306f, 0.08267854f, -0.32215264f, 
    -0.15376677f, -0.05031418f, -0.11471498f, -0.08694150f, -0.23740150f, 0.16957702f, 0.01869691f, 0.08321371f, 
    -0.10729117f, 0.10515217f, 0.01416280f, 0.02142586f, -0.08600618f, 0.04375433f, -0.00906818f, 0.09016418f, 
    0.08675357f, 0.18927069f, 0.15135577f, -0.09116039f, -0.13316818f, -0.14697288f, -0.06570215f, 0.02756288f, 
    0.13668631f, 0.17592859f, -0.08133703f, -0.16780932f, -0.10350306f, 0.01021904f, -0.05901181f, -0.13319549f, 
    -0.07480880f, 0.10056364f, 0.03866616f, 0.17961182f, 0.05537245f, 0.31819096f, -0.04470747f, -0.11670364f, 
    -0.02078489f, 0.05477512f, -0.21797781f, 0.05304755f, -0.16072191f, 0.06750504f, -0.09677550f, -0.09477474f, 
    0.00497914f, 0.21193509f, 0.09189425f, -0.03816016f, 0.10102007f, -0.02482666f, -0.16393046f, -0.04720435f, 
    -0.16464730f, 0.06942875f, 0.20087348f, 0.14803836f, -0.10563326f, -0.23831467f, -0.04517233f, -0.21501181f, 
    -0.24378915f, -0.01071753f, -0.02864586f, 0.03311755f, 0.10259229f, 0.10155899f, 0.01231677f, 0.06958678f, 
    0.04916433f, -0.05112087f, -0.03957660f, -0.02538423f, -0.13663349f, 0.03517057f, -0.03886766f, 0.14882106f, 
    0.26550457f, 0.33075371f, 0.17444439f, -0.02235166f, -0.02109405f, -0.07070743f, 0.08680921f, -0.07372305f, 
    -0.02873026f, -0.09012920f, -0.18734781f, -0.03180361f, 0.07473502f, 0.06812414f, -0.14133674f, -0.00144617f, 
    -0.04780496f, 0.09205566f, 0.32442182f, 0.10831729f, 0.03464231f, -0.06482409f, -0.03103800f, -0.21139854f, 
    -0.07717942f, -0.06790061f, -0.06248841f, 0.18797052f, -0.04353766f, 0.16888107f, 0.18018115f, 0.08962737f, 
    0.10706017f, 0.01032843f, 0.06390889f, 0.12758583f, -0.13261835f, 0.19862285f, 0.07370754f, 0.06660032f, 
    -0.04929300f, 0.12530349f, -0.08486260f, -0.06156614f, 0.04921656f, 0.15490940f, 0.10687467f, 0.13656284f, 
    -0.04949678f, -0.06136955f, 0.04504312f, -0.03806294f, 0.03452089f, -0.05307207f, 0.10420126f, 0.01723231f, 
    -0.22151320f, 0.03297533f, -0.05540181f, 0.03957726f, 0.05415571f, -0.04124157f, 0.05519149f, -0.00107212f, 
    -0.27378201f, -0.05096814f, 0.05876108f, -0.10426196f, -0.16956909f, 0.05033270f, 0.04598430f, 0.13503391f, 
    0.11163807f, -0.27939883f, -0.11235029f, 0.09745783f, -0.01588869f, -0.03950138f, 0.04341244f, 0.05175684f, 
    0.15605919f, 0.21238518f, 0.08135134f, 0.05664199f, -0.07140296f, -0.03138500f, -0.05509736f, -0.10473941f, 
    -0.01626814f, 0.06632520f, -0.02527230f, -0.04563186f, -0.29032135f, 0.08765393f, 0.09316504f, -0.09220012f, 
    -0.00179985f, 0.01071292f, -0.11944371f, -0.12600201f, -0.13853934f, -0.22208005f, 0.01940669f, -0.07027103f, 
    -0.00934832f, 0.01151633f, 0.09959935f, 0.07460175f, -0.52700919f, -0.52620476f, -0.03593116f, 0.11304117f, 
    0.00481542f, -0.02198469f, 0.05828027f, 0.03005397f, 0.15196259f, -0.27271807f, 0.02350219f, -0.13973369f, 
    -0.20997530f, -0.00658257f, -0.05036054f, -0.07857717f, -0.06933085f, 0.09043330f, 0.28576484f, -0.01913046f, 
    0.01604907f, -0.05021740f, -0.09607407f, 0.06062854f, -0.07985083f, 0.17547770f, -0.10416806f, -0.09883290f, 
    -0.01104043f, -0.10876192f, -0.13252841f, 0.05877908f, 0.00248446f, 0.03198638f, 0.08819163f, 0.01652006f, 
    -0.00103440f, 0.13055719f, -0.39581913f, 0.03343096f, 0.00835254f, 0.15949070f, 0.03406929f, 0.04132860f, 
    0.02712761f, 0.02635046f, -0.13057308f, -0.12864852f, 0.08867048f, 0.04139888f, 0.18431085f, -0.08326665f, 
    0.17690982f, 0.08731597f, -0.05123705f, 0.13959102f, 0.25092456f, -0.17937724f, 0.02685666f, 0.05246853f, 
    0.04513816f, -0.03398494f, 0.07854440f, -0.04712471f, 0.19817910f, 0.03100631f, 0.15179428f, -0.01988307f, 
    -0.01120724f, 0.10510148f, -0.03128748f, 0.32200858f, -0.27886823f, -0.10173206f, -0.07374065f, 0.02668478f, 
    0.03403576f, -0.04463055f, 0.07952709f, -0.01570538f, 0.05987037f, 0.09627253f, 0.10792377f, 0.00480739f, 
    0.01995296f, -0.18956085f, -0.03945027f, -0.08430195f, 0.07137825f, -0.09494854f, -0.15389934f, -0.25565729f, 
    -0.04972845f, -0.04481172f, -0.00393939f, -0.09088736f, -0.05248637f, 0.10478766f, -0.08762712f, 0.25626960f, 
    0.24274036f, 0.15964223f, 0.12352684f, -0.07164738f, 0.14576754f, 0.01878639f, 0.08290376f, 0.12903725f, 
    0.22867374f, 0.00076263f, 0.04001452f, 0.00020899f, -0.00556866f, -0.04322734f, 0.00222114f, -0.00418601f, 
    0.12681326f, 0.01203765f, 0.00107316f, -0.06342659f, 0.02514190f, 0.00757306f, -0.02704659f, 0.07547791f, 
    0.06243324f, -0.04584240f, 0.17795797f, 0.19047844f, 0.16457178f, -0.02906195f, -0.07619935f, -0.01044430f, 
    -0.12164585f, 0.11568789f, -0.09934942f, 0.09830350f, -0.01740431f, -0.02924585f, 0.05026819f, 0.11453053f, 
    -0.01530988f, 0.01830372f, 0.02039177f, 0.01363150f, 0.12215110f, 0.13416652f, -0.02716430f, -0.03464511f, 
    -0.05540701f, -0.05972037f, -0.00669031f, -0.07043753f, -0.11679754f, 0.25413859f, 0.11882021f, 0.08902381f, 
    -0.13380954f, 0.10952900f, 0.00712109f, 0.11419480f, -0.14943740f, -0.12279321f, -0.01461459f, 0.19013464f, 
    -0.18225393f, 0.10072482f, 0.06948850f, 0.07013325f, -0.12951830f, 0.07687093f, 0.08074677f, -0.06556676f, 
    0.03867954f, -0.16942370f, -0.06071514f, 0.17688152f, 0.04445494f, -0.00523184f, -0.04065524f, 0.18017003f, 
    -0.25812328f, -0.20164442f, -0.02279907f, -0.10130921f, 0.00596949f, 0.17121574f, -0.09301493f, -0.06640244f, 
    -0.34306774f, -0.12815778f, -0.01551922f, 0.01302265f, 0.00653073f, 0.08261250f, 0.02539760f, 0.09739526f, 
    0.02871716f, 0.15107675f, -0.21095100f, 0.17239980f, 0.10288662f, -0.04257477f, 0.03724967f, 0.01039601f, 
    -0.02557209f, 0.06905904f, -0.02738335f, -0.33349299f, -0.26787701f, -0.15206239f, -0.01447320f, 0.12084026f, 
    -0.29385343f, 0.05042993f, -0.03333938f, 0.04172318f, -0.09940028f, 0.11860476f, -0.12875502f, 0.05131171f, 
    0.10877617f, 0.07895298f, 0.08099612f, 0.12996016f, -0.06930976f, -0.33825400f, -0.23195916f, -0.12227771f, 
    -0.08848596f, -0.15411133f, 0.07810559f, 0.05128637f, -0.01183742f, -0.04035490f, -0.18859541f, -0.20002629f, 
    -0.20356598f, 0.15035391f, -0.24863316f, -0.21458182f, 0.01407387f, 0.13468659f, -0.09992358f, 0.04265354f, 
    0.00984457f, -0.21085280f, 0.13418569f, 0.08048303f, -0.17040838f, 0.06581997f, -0.03697588f, 0.08773696f, 
    -0.07511562f, -0.00903982f, 0.09843479f, 0.04277221f, 0.13397151f, 0.21168752f, 0.13417199f, -0.07427333f, 
    0.16221409f, -0.10117205f, 0.13993463f, 0.10886785f, -0.05689407f, -0.03718271f, 0.05087213f, 0.03331072f, 
    0.01900715f, 0.07573518f, -0.21485731f, 0.01196198f, -0.35677847f, 0.06867952f, -0.22634993f, 0.06372020f, 
    0.10114736f, -0.07502999f, 0.05381519f, -0.14432918f, 0.17130202f, -0.05183813f, 0.13658230f, 0.04708554f, 
    0.06930419f, 0.13414274f, 0.23025510f, 0.17782320f, -0.34413937f, -0.01966265f, -0.16293755f, 0.02515948f, 
    -0.27790573f, -0.04852473f, -0.19218266f, -0.09583834f, 0.09028788f, -0.10026885f, 0.11559482f, -0.23892131f, 
    -0.21425167f, 0.21639238f, -0.02614629f, 0.08721780f, 0.10298982f, 0.12250160f, 0.01868860f, 0.00211450f, 
    0.07912752f, 0.11274309f, -0.04005639f, -0.12330675f, 0.00749011f, -0.10828493f, -0.10440958f, 0.50810540f, 
    -0.00898024f, -0.17845561f, 0.00081474f, -0.01452076f, -0.20559038f, 0.05114780f, 0.22628370f, 0.32860693f, 
    -0.03402190f, 0.15816043f, -0.21306901f, -0.08478317f, -0.22255498f, 0.06737383f, -0.07513948f, -0.11085916f, 
    0.19210261f, -0.11696552f, 0.15577097f, 0.17143796f, -0.01359614f, -0.09298620f, -0.00365265f, 0.18232572f, 
    0.04971838f, 0.31489834f, -0.13605654f, -0.00274499f, 0.37032664f, 0.03615746f, -0.13382424f, 0.04900051f, 
    -0.14551465f, -0.21230613f, -0.23981060f, 0.29471004f, -0.59607249f, -0.27223670f, 0.14425208f, -0.01905587f, 
    -0.06616160f, 0.02510513f, -0.01643971f, 0.06250372f, -0.23359182f, 0.01402120f, 0.09806878f, -0.15867691f, 
    -0.09864323f, -0.17860556f, -0.01193954f, -0.08111020f, 0.13994110f, 0.11177825f, 0.03736382f, 0.16983388f, 
    0.05522195f, 0.12168408f, 0.18872334f, 0.05737377f, 0.02917833f, -0.10093295f, -0.10557114f, 0.13349597f, 
    -0.12707415f, -0.05223031f, 0.17184016f, 0.12765370f, 0.19746333f, 0.04192453f, 0.01340606f, 0.12276632f, 
    -0.48678854f, 0.17751437f, -0.01510330f, -0.17658955f, 0.16841690f, 0.00388616f, -0.12943633f, -0.05800126f, 
    -0.05480371f, -0.04879079f, 0.23029751f, -0.01195963f, -0.05152369f, -0.02302804f, -0.01812385f, -0.02909343f, 
    0.06354746f, -0.19019495f, 0.37484160f, 0.11308560f, -0.03431605f, 0.06529372f, 0.05120230f, 0.28569862f, 
    0.08225104f, 0.07447019f, 0.35095930f, -0.05046294f, -0.05965290f, 0.03153857f, 0.03947679f, 0.14927362f, 
    -0.10709487f, -0.03621531f, -0.06892425f, 0.07583407f, -0.08820008f, 0.01230230f, 0.11995987f, -0.03649347f, 
    -0.15027907f, 0.09701540f, 0.20878366f, 0.07189817f, 0.20525613f, 0.07284606f, 0.21088739f, 0.00202419f, 
    -0.03172991f, 0.01271384f, -0.09454656f, -0.07628622f, 0.07170708f, -0.01083848f, -0.01967565f, 0.05710391f, 
    0.04128480f, -0.05327855f, 0.16487101f, -0.12003241f, -0.37973294f, -0.12356614f, -0.19862872f, -0.11294748f, 
    -0.05003740f, -0.22413357f, -0.07921400f, -0.10438997f, -0.00402251f, -0.28790227f, -0.10836766f, 0.06437030f, 
    0.06288335f, -0.07981353f, 0.10523234f, 0.18875730f, 0.13177614f, -0.01111669f, 0.14043663f, 0.05990350f, 
    -0.00653386f, -0.00078654f, -0.02110298f, -0.04881393f, -0.03961268f, -0.00260859f, -0.06308386f, -0.01297915f, 
    -0.06724285f, -0.02642901f, 0.00592981f, 0.00223492f, -0.01961107f, -0.02975278f, -0.05272011f, 0.01854887f, 
    0.02896110f, 0.03870561f, -0.01710423f, 0.00835015f, 0.00162991f, 0.04079526f, -0.04707228f, 0.01915733f, 
    0.02932624f, -0.01476822f, -0.03261030f, 0.03871245f, -0.00357310f, 0.01640890f, -0.01383918f, -0.03986318f, 
    -0.05580543f, 0.01766835f, -0.03427635f, 0.04705473f, -0.02479719f, 0.01540925f, 0.01605400f, -0.03049656f, 
    0.00848825f, 0.04299053f, -0.00753115f, 0.01112299f, 0.00949305f, 0.04418269f, -0.00184588f, -0.06599600f, 
    -0.03240830f, -0.00143076f, -0.00406390f, 0.01134571f, 0.01225488f, -0.04728478f, 0.01699862f, -0.01057981f, 
    -0.01278769f, 0.02653153f, -0.04174902f, -0.04112881f, -0.04751604f, -0.03997683f, 0.00604132f, -0.02376492f, 
    -0.07203230f, 0.04256053f, 0.00110773f, -0.04185833f, -0.02203089f, 0.03176137f, 0.00623808f, -0.01979275f, 
    -0.00317141f, 0.02231227f, 0.01459983f, 0.04462292f, -0.02924389f, 0.04390755f, -0.00380475f, -0.05028921f, 
    -0.07176660f, -0.04556495f, -0.05570117f, 0.01361514f, 0.03899511f, -0.03446031f, -0.02115399f, 0.02683836f, 
    -0.05747106f, 0.00788700f, 0.02056526f, -0.00472665f, 0.03304823f, 0.05726605f, 0.01058753f, -0.05737041f, 
    0.04939245f, -0.02234310f, -0.02498036f, 0.00247810f, 0.01590091f, -0.06127379f, 0.03345310f, -0.04582345f, 
    -0.02848007f, -0.04785197f, -0.02603557f, -0.03161311f, -0.00832372f, -0.02158466f, -0.01077699f, -0.02704162f, 
    0.02621921f, -0.04450441f, 0.03965971f, 0.04670416f, -0.04758494f, -0.00047288f, -0.00410197f, -0.06503192f, 
    -0.05937662f, 0.02619428f, 0.01149820f, 0.02423675f, 0.03824044f, 0.01235376f, -0.02383434f, -0.01593744f, 
    0.03127056f, -0.02978331f, 0.02140530f, -0.00872239f, -0.01948634f, 0.04967581f, 0.02449553f, -0.04848664f, 
    -0.01307778f, -0.00899363f, 0.00785549f, -0.02574502f, 0.01497248f, -0.02572742f, 0.01345433f, -0.04042618f, 
    -0.02583786f, 0.03192939f, -0.02201080f, 0.03040723f, -0.02101883f, -0.01680914f, -0.00353708f, -0.01021942f, 
    -0.02033294f, -0.02695790f, 0.01588137f, -0.04444584f, 0.01374740f, 0.02033649f, -0.06093134f, -0.00992754f, 
    -0.04729291f, -0.02344725f, 0.01579664f, 0.03355446f, -0.04414887f, 0.01914117f, -0.03551280f, -0.02232975f, 
    0.05471864f, -0.05006250f, -0.05843899f, 0.02157064f, 0.01057542f, 0.02437563f, -0.00678797f, -0.03680950f, 
    0.02420965f, -0.00872847f, 0.01596108f, -0.02079199f, -0.05367856f, -0.00098419f, -0.01418093f, -0.00280638f, 
    0.00144900f, -0.05571973f, -0.04409628f, 0.01507839f, 0.01407802f, 0.05047139f, -0.03904104f, -0.06150695f, 
    0.05229447f, 0.03341166f, -0.00877383f, -0.05576701f, 0.03486738f, -0.00735455f, -0.06258178f, -0.05058028f, 
    -0.07159556f, -0.06174137f, -0.03228827f, -0.03333114f, -0.00545035f, -0.00452404f, -0.06359761f, 0.02045328f, 
    -0.00132738f, -0.01668234f, 0.03603355f, 0.05559485f, -0.01205579f, -0.05873923f, 0.01111639f, 0.05722573f, 
    -0.02203924f, -0.01030825f, 0.04018232f, -0.04328934f, 0.03451593f, -0.01921102f, -0.01547256f, -0.01923475f, 
    -0.05469034f, -0.00965363f, 0.06475093f, -0.00159351f, -0.00128679f, 0.00966565f, 0.02570052f, -0.02763497f, 
    0.02294873f, 0.00218787f, -0.02701080f, 0.03098749f, -0.02953153f, 0.03312087f, -0.04589596f, 0.01766674f, 
    -0.06405094f, -0.05418033f, 0.01915712f, -0.03790523f, 0.03435842f, -0.04704777f, 0.02335491f, 0.00384810f, 
    -0.01072817f, -0.03057792f, -0.01937053f, 0.00713265f, -0.01362429f, -0.04828373f, -0.02274917f, -0.05583839f, 
    -0.00237530f, -0.02246008f, -0.05580382f, 0.01170636f, 0.05368949f, -0.04538188f, 0.03183652f, 0.00453744f, 
    -0.04808504f, -0.02912677f, -0.03075930f, 0.00413426f, -0.04654641f, 0.01485876f, -0.03921126f, -0.00478747f, 
    -0.04240716f, 0.02416714f, -0.00194703f, -0.04146190f, -0.01307051f, 0.03674338f, 0.03034113f, -0.04809862f, 
    -0.00938802f, -0.00243358f, -0.03141567f, -0.03813934f, -0.06030194f, -0.05467581f, 0.02430258f, -0.03977228f, 
    -0.02553613f, 0.04997217f, -0.03511204f, -0.02538897f, 0.03816234f, 0.02741872f, 0.02015434f, 0.01718757f, 
    -0.00695597f, 0.01485734f, 0.02140227f, -0.04580856f, 0.00805915f, -0.00560321f, -0.03806445f, 0.02333358f, 
    0.01115356f, -0.00965448f, 0.05392806f, -0.04144482f, -0.00781682f, -0.03959465f, 0.01031795f, 0.00667756f, 
    -0.03085833f, -0.06159487f, -0.01252749f, 0.00585612f, 0.00046825f, -0.03423934f, 0.00177887f, -0.04020587f, 
    -0.00723618f, -0.01492240f, 0.02970001f, -0.02218715f, -0.02832366f, 0.00616581f, 0.00622526f, -0.03392420f, 
    0.03187155f, 0.00521794f, 0.02618222f, -0.00746621f, 0.02884394f, -0.00266104f, 0.05991215f, -0.00536269f, 
    -0.04020366f, 0.03559707f, -0.05357948f, -0.05005287f, -0.04762696f, -0.03531267f, 0.02631626f, -0.03069142f, 
    0.01448110f, 0.00451623f, 0.02818131f, 0.04414449f, -0.03892842f, -0.00717032f, -0.02834688f, -0.02379153f, 
    -0.00422490f, 0.04015216f, 0.03894117f, -0.05496518f, 0.03581293f, -0.05875702f, -0.05029005f, -0.04968837f, 
    0.02363602f, -0.03604855f, -0.06223040f, -0.01815641f, -0.01880428f, 0.03336394f, 0.02469829f, -0.01197537f, 
    0.01671980f, -0.02637505f, 0.01459795f, -0.01371896f, -0.04676501f, -0.03362723f, -0.00071370f, -0.03276190f, 
    -0.01617645f, 0.02074223f, -0.04727460f, -0.03169094f, -0.01641738f, -0.02751763f, 0.00240775f, 0.03799219f, 
    -0.06968939f, -0.06761473f, -0.02911204f, -0.03064192f, -0.02758585f, -0.04584502f, 0.04781137f, -0.05847896f, 
    -0.05908272f, 0.02237943f, -0.02041430f, 0.03072438f, 0.01879844f, 0.01391096f, -0.02278387f, 0.03437255f, 
    0.02011184f, 0.04935582f, 0.03560775f, 0.00044344f, 0.04209722f, 0.00661567f, -0.00812061f, -0.02667444f, 
    0.03827545f, -0.04218215f, 0.04146307f, -0.02982776f, 0.02059203f, 0.00425261f, -0.03996070f, -0.00991077f, 
    -0.04990320f, 0.00379694f, -0.05893348f, -0.06450252f, -0.03852014f, -0.06008802f, 0.04867546f, 0.03362849f, 
    -0.03142718f, -0.00599432f, 0.00467687f, 0.00730639f, 0.04539235f, -0.04298224f, 0.04087906f, 0.03775792f, 
    0.02923039f, 0.03613746f, 0.03925514f, -0.04008727f, 0.03238706f, -0.01545175f, -0.03998319f, -0.01479847f, 
    -0.06068124f, -0.05950729f, -0.02103877f, 0.02040848f, 0.00090125f, 0.03375124f, 0.02536712f, 0.02767538f, 
    -0.01543583f, 0.03975724f, -0.04243276f, -0.04450367f, -0.01230550f, -0.04188995f, 0.00017186f, 0.03539035f, 
    0.05235821f, 0.04704663f, 0.02824357f, -0.04565793f, 0.02698134f, -0.03968282f, -0.02673693f, -0.02585297f, 
    -0.01153185f, 0.02579671f, 0.04210871f, 0.04256953f, 0.01786994f, -0.05888515f, -0.02522824f, 0.04608604f, 
    0.02288159f, -0.06537507f, -0.00950710f, -0.06461603f, -0.00060419f, 0.03214314f, -0.03132506f, 0.02814285f, 
    -0.02721240f, 0.01585632f, 0.04496541f, -0.01480500f, -0.00206882f, -0.02311712f, -0.01331986f, 0.02385422f, 
    -0.02682130f, -0.00782488f, -0.02153798f, 0.01934834f, 0.03887046f, 0.04584060f, -0.04541487f, -0.02159631f, 
    0.03256308f, 0.03825259f, -0.04307141f, -0.05956679f, -0.04758669f, -0.01135664f, -0.05320882f, -0.01376829f, 
    -0.05691331f, 0.02499580f, 0.01498980f, 0.03160916f, 0.01918912f, -0.05691280f, -0.05017390f, -0.02817579f, 
    0.02935916f, -0.05643196f, 0.01453296f, -0.04433684f, -0.02793538f, 0.04254124f, 0.02821184f, 0.00620198f, 
    -0.00143655f, 0.03919050f, -0.03846252f, 0.05056639f, 0.03401492f, -0.05879065f, 0.01390764f, -0.04222130f, 
    -0.05932366f, -0.06354336f, 0.02393925f, -0.00996441f, 0.03117551f, -0.06144186f, -0.02043861f, 0.01467546f, 
    -0.06793196f, -0.00072372f, -0.05339365f, 0.04259125f, -0.04909732f, -0.04620751f, -0.04998095f, -0.04490009f, 
    0.01105395f, 0.02497725f, -0.00072708f, 0.01021289f, -0.00248524f, 0.04116425f, -0.00889313f, 0.00612848f, 
    -0.03639029f, -0.04503236f, -0.05463292f, 0.03327353f, -0.03619650f, 0.03222346f, -0.00247212f, 0.03501316f, 
    -0.04260214f, -0.01645889f, -0.03167634f, -0.02192717f, -0.00036828f, -0.02846018f, -0.06137045f, -0.03463634f, 
    -0.05209422f, 0.04688654f, -0.04958144f, 0.01103173f, -0.02015159f, -0.03615119f, -0.04637541f, -0.02232041f, 
    0.32648966f, 0.41851252f, 0.23411608f, -0.18312508f, 0.04009970f, -0.06420156f, 0.09994727f, 0.13742387f, 
    0.10169958f, -0.00423490f, -0.10965592f, 0.02514040f, 0.07108714f, -0.00567157f, 0.00715598f, -0.00623046f, 
    -0.03078814f, 0.05426534f, 0.21688221f, 0.06953914f, -0.12243766f, -0.16439646f, -0.03907726f, -0.07715382f, 
    0.15176427f, -0.00594836f, 0.10336647f, 0.25657022f, -0.23170634f, 0.20789446f, -0.27626592f, 0.18091874f, 
    0.16593815f, -0.00414842f, 0.01269730f, 0.11218280f, -0.12897961f, 0.24796100f, 0.17503977f, -0.06056532f, 
    -0.12447194f, -0.01748494f, -0.14353245f, -0.06072516f, -0.07379536f, 0.09305194f, 0.08018427f, 0.17194697f, 
    -0.08598968f, 0.01027835f, 0.09533342f, -0.00027630f, -0.09150510f, 0.06326269f, 0.02286854f, -0.16311896f, 
    -0.33672792f, -0.09365051f, -0.33985502f, 0.06668332f, 0.14177951f, 0.12031811f, 0.00600438f, -0.49328241f, 
    -0.38562098f, -0.13428159f, -0.17447802f, -0.21992658f, -0.08645953f, 0.09890219f, -0.02908373f, 0.13594167f, 
    -0.05578348f, -0.65968078f, -0.18852699f, 0.05816638f, -0.06363737f, -0.08650401f, 0.02637152f, 0.14384399f, 
    -0.02669732f, 0.12370464f, 0.09139908f, 0.08074946f, -0.14756691f, -0.00231406f, -0.01891182f, 0.12064952f, 
    0.01203566f, 0.06916004f, 0.15360533f, -0.33687833f, -0.53447360f, 0.05027556f, 0.18835993f, -0.20379308f, 
    0.15308461f, 0.29834184f, -0.04589531f, -0.14863816f, -0.01075251f, -0.38233393f, -0.07064833f, 0.06779165f, 
    -0.03128862f, 0.07475889f, 0.07020456f, 0.00937676f, -0.38428208f, -0.32353929f, -0.22783008f, 0.01497030f, 
    -0.04379085f, -0.23301102f, 0.08707259f, -0.06660138f, 0.06604771f, 0.03627454f, -0.29210842f, -0.42589706f, 
    -0.24741918f, 0.03091773f, -0.14856067f, -0.01583482f, 0.02268267f, -0.02753266f, 0.05840671f, -0.09051760f, 
    0.25729531f, -0.11774806f, 0.03401717f, 0.10244584f, 0.03757856f, -0.00730291f, 0.08546497f, -0.50764591f, 
    -0.23737529f, -0.15800886f, -0.15447551f, -0.05949432f, -0.01762195f, 0.17340407f, 0.15451486f, -0.09602711f, 
    0.13181807f, -0.20896468f, -0.74880439f, -0.22382586f, -0.00813638f, 0.10871964f, 0.10823344f, -0.01249616f, 
    0.00418605f, 0.12739126f, -0.14489590f, -0.14998668f, -0.07192699f, -0.03575933f, 0.10889195f, 0.11194705f, 
    0.00448906f, 0.00466461f, 0.09861386f, 0.18841699f, 0.09304925f, -0.04916417f, 0.03602716f, -0.00648043f, 
    0.01009799f, -0.05674965f, 0.02194704f, -0.20034915f, 0.01692187f, 0.08185695f, -0.11912096f, 0.07962956f, 
    -0.24777475f, 0.00899938f, 0.04777861f, 0.16968542f, 0.04857495f, -0.38752362f, -0.05089020f, 0.01077166f, 
    0.00039964f, -0.07339616f, -0.00231604f, -0.01200825f, 0.04030727f, 0.10773405f, -0.00259841f, -0.00279472f, 
    -0.05239961f, 0.12195502f, -0.04870322f, 0.00893322f, 0.05945566f, -0.07777906f, -0.10567662f, -0.35796660f, 
    0.25540724f, -0.03812594f, 0.09061031f, -0.16471834f, -0.16729596f, -0.03449160f, -0.14412619f, 0.27987626f, 
    0.40948308f, 0.46595123f, -0.08731280f, -0.12401958f, -0.11844762f, 0.02814085f, 0.13714576f, -0.03028740f, 
    0.15344793f, -0.04700550f, 0.14770703f, 0.04602299f, 0.06930482f, 0.02680559f, 0.03630679f, 0.10650429f, 
    0.05484642f, 0.10197417f, -0.07508720f, 0.05939183f, 0.12285211f, -0.05790317f, -0.07398534f, -0.15609771f, 
    0.02588373f, -0.15578312f, 0.04563152f, 0.15642077f, 0.07406856f, -0.01097256f, 0.12769012f, -0.13516378f, 
    -0.02183199f, 0.04751275f, -0.02282932f, 0.00959561f, 0.10654595f, -0.01618855f, -0.10604744f, 0.14841798f, 
    0.15587988f, 0.12542889f, 0.03137589f, 0.06255464f, 0.06246844f, 0.11797980f, 0.00374371f, -0.09253069f, 
    -0.00600807f, -0.09125642f, 0.17828131f, 0.12903012f, -0.02554393f, -0.28717181f, -0.17709161f, -0.02979109f, 
    -0.27622288f, 0.05433946f, 0.03620164f, 0.24416205f, 0.00640639f, -0.10345371f, 0.46692827f, 0.26333284f, 
    0.13378641f, -0.42819163f, -0.41622046f, 0.15847751f, 0.21886431f, 0.09651698f, 0.01146847f, -0.00944222f, 
    -0.16535425f, -0.40968326f, -0.03476150f, -0.03534955f, -0.02872000f, 0.01567065f, 0.06756465f, -0.06395097f, 
    -0.23560905f, 0.30412093f, 0.29047644f, 0.00433045f, 0.00045496f, -0.12784941f, 0.08562450f, 0.08098489f, 
    -0.00943457f, -0.06641243f, 0.16124173f, 0.15234311f, -0.08425748f, -0.08081993f, 0.18268645f, -0.00723999f, 
    0.07762850f, -0.03222135f, -0.16113545f, -0.06940599f, 0.16336085f, -0.00700588f, -0.03604478f, -0.11909793f, 
    -0.06255262f, 0.03917117f, 0.03861096f, -0.66804248f, 0.43368229f, 0.38472483f, -0.03452627f, -0.16048835f, 
    -0.19672285f, 0.14608237f, -0.02920891f, -0.12001410f, 0.02041327f, -0.09193225f, 0.37508941f, -0.02822076f, 
    0.03424467f, 0.01833283f, 0.00081911f, 0.00653292f, 0.14606854f, 0.00622635f, 0.29652685f, 0.32711709f, 
    0.04705191f, 0.00783729f, 0.13099739f, 0.05902286f, -0.00010233f, 0.07910816f, 0.01682986f, -0.10909602f, 
    0.09499356f, 0.10903935f, 0.18696004f, 0.10135013f, 0.02066749f, -0.13429867f, 0.07600365f, -0.31656414f, 
    0.06224944f, 0.17224248f, 0.00793223f, -0.03998612f, -0.00829003f, -0.04622228f, -0.04108117f, 0.04242087f, 
    -0.02524293f, -0.04000902f, 0.02721293f, -0.05451151f, -0.04742683f, 0.03742113f, 0.03937253f, -0.05377138f, 
    -0.17520818f, -0.04869173f, -0.07014209f, 0.11509948f, 0.06302777f, -0.02015268f, -0.01454625f, -0.00656692f, 
    0.02401212f, -0.00309741f, -0.03437507f, -0.05581781f, -0.01405220f, 0.04716456f, 0.08347981f, -0.00832694f, 
    0.09163390f, 0.03008291f, 0.01359095f, 0.05292234f, 0.07838835f, 0.09501051f, 0.02018812f, 0.00847623f, 
    0.03533451f, -0.10111874f, 0.01310870f, 0.07146253f, 0.13060996f, 0.47587773f, 0.18642904f, -0.03580739f, 
    -0.23035890f, -0.00247328f, 0.05736771f, 0.09418570f, -0.19303983f, -0.19886607f, -0.31765801f, 0.40506214f, 
    -0.09589309f, 0.15887567f, -0.05852955f, 0.05252954f, -0.01668049f, 0.00561701f, -0.20956375f, -0.08924627f, 
    -0.11263370f, 0.00650320f, -0.02183459f, -0.02582166f, -0.11704520f, -0.12865654f, 0.04424342f, -0.64842939f, 
    0.13420542f, -0.38530442f, 0.10289511f, 0.09421217f, 0.02586669f, -0.06192368f, -0.03744818f, 0.05208598f, 
    0.11821866f, -0.05707305f, 0.20206855f, -0.03557017f, -0.20585360f, -0.08420220f, -0.03250979f, 0.05932226f, 
    -0.08691632f, -0.36719736f, -0.04429809f, -0.13682014f, -0.10129578f, -0.04402553f, -0.05508186f, 0.10259687f, 
    -0.00999190f, 0.04108088f, 0.08892028f, -0.10902628f, -0.09906340f, 0.07352155f, 0.05114507f, -0.18929416f, 
    0.04153141f, 0.11519312f, -0.01787644f, 0.05531045f, -0.09220459f, -0.01787097f, 0.08227159f, 0.06344245f, 
    -0.07068349f, 0.06566303f, -0.02380614f, 0.02046281f, -0.08993902f, 0.01025225f, 0.10352127f, -0.04581112f, 
    -0.00714199f, -0.24386038f, 0.00741839f, -0.02322167f, 0.04476077f, -0.05101434f, 0.08446979f, 0.03515444f, 
    0.01301928f, -0.11249275f, 0.01332397f, 0.09795499f, 0.01671111f, -0.07848340f, -0.04558246f, 0.29976180f, 
    0.00942271f, -0.07924049f, -0.04543285f, 0.14221437f, -0.06762239f, 0.03820704f, 0.01689098f, -0.01107205f, 
    0.10000038f, -0.05307136f, -0.11120269f, -0.00630400f, 0.06630747f, 0.00373313f, -0.03563143f, -0.13923232f, 
    -0.05453942f, -0.01998595f, 0.06158060f, 0.06079957f, -0.04766473f, -0.04579939f, 0.08680033f, -0.06107111f, 
    0.07316139f, 0.04395635f, -0.28779861f, 0.28634316f, -0.07491782f, -0.24909666f, -0.01834591f, 0.17427653f, 
    -0.02438976f, 0.05942092f, -0.20679986f, 0.24401419f, 0.23698772f, 0.03433404f, 0.03253584f, -0.08677715f, 
    -0.06492607f, 0.01501443f, 0.07845002f, -0.12210691f, 0.23645149f, 0.03741859f, 0.12551083f, -0.03225091f, 
    0.08142272f, 0.07057993f, 0.03745821f, 0.04340287f, -0.13463244f, 0.02755436f, -0.02489055f, 0.07446550f, 
    0.17955333f, 0.06148817f, 0.00014847f, 0.06480619f, 0.00364464f, -0.83887547f, -0.19774240f, -0.32551220f, 
    -0.01949356f, 0.13222107f, 0.03584025f, -0.22576983f, -0.11112378f, 0.14668964f, 0.29765168f, -0.20907031f, 
    0.00664493f, 0.01733985f, -0.14314072f, -0.40172315f, 0.14763233f, 0.03546567f, 0.11999580f, -0.05703427f, 
    -0.05942505f, 0.26020038f, 0.00768736f, -0.00978710f, -0.17222330f, 0.04256733f, 0.10581068f, 0.07330647f, 
    0.09144036f, -0.15513185f, 0.14667688f, -0.05625474f, 0.02415209f, 0.06138709f, 0.01646172f, -0.10108089f, 
    -0.01462734f, -0.04954116f, 0.21705642f, -0.14138944f, 0.20961811f, -0.03440254f, -0.17113735f, 0.15809682f, 
    -0.17539503f, 0.04625274f, -0.50401348f, 0.00404687f, 0.25870591f, 0.03169419f, -0.00685334f, -0.09259174f, 
    0.12476013f, -0.02656393f, -0.07643618f, -0.47391245f, -0.18924573f, -0.16239576f, 0.23538958f, -0.07397428f, 
    -0.01655007f, -0.01885897f, 0.00521833f, 0.08803414f, 0.13619894f, 0.07546140f, 0.05743675f, 0.04115659f, 
    0.11411757f, 0.00404283f, 0.04472105f, -0.17760155f, -0.12002842f, -0.28418151f, 0.03254567f, 0.03947227f, 
    -0.06743485f, 0.04340001f, 0.01959567f, 0.07327434f, -0.11883236f, -0.12984045f, -0.16042963f, -0.05467758f, 
    -0.38300574f, -0.12897366f, -0.18802734f, -0.11777373f, 0.10317411f, 0.05149584f, -0.03879089f, -0.06155277f, 
    -0.07597636f, -0.12721434f, 0.07973832f, 0.00415934f, -0.09712666f, -0.08075414f, -0.13073292f, 0.03143120f, 
    -0.18844406f, -0.02582811f, 0.24497998f, 0.12882245f, 0.02105076f, -0.16452818f, -0.00064223f, -0.03581131f, 
    0.06732629f, -0.44997361f, -0.00222390f, 0.08717972f, -0.08151548f, -0.00905823f, -0.00939505f, 0.09575160f, 
    -0.05779276f, -0.01238173f, -0.07040772f, -0.17676686f, -0.34289730f, -0.04231884f, -0.10532250f, -0.00051140f, 
    -0.12249321f, 0.19775993f, 0.09499722f, -0.10370859f, -0.14814927f, -0.10977709f, 0.11439223f, -0.06601977f, 
    0.03568238f, 0.05755682f, 0.08792386f, 0.03290224f, -0.47043154f, -0.21589698f, -0.11985282f, -0.00329655f, 
    -0.23349001f, -0.17196441f, 0.01127580f, -0.15963727f, 0.10199542f, 0.03832021f, -0.06289413f, -0.09339429f, 
    -0.14518872f, 0.04709183f, 0.02463697f, 0.18967301f, -0.00733653f, -0.05082674f, -0.36573651f, -0.08091607f, 
    -0.24847943f, 0.12900275f, 0.04856837f, 0.10508233f, -0.28535375f, -0.06911841f, -0.37210369f, 0.36591256f, 
    0.10266003f, -0.28350011f, 0.07678475f, -0.05312138f, -0.09436773f, 0.08118973f, 0.14951867f, 0.07598030f, 
    -0.09640192f, -0.28999025f, -0.28694451f, -0.07033513f, -0.13207971f, 0.07752691f, 0.09514354f, -0.02912904f, 
    0.14948229f, -0.23005693f, 0.14650451f, -0.03565484f, 0.01867093f, 0.03584398f, 0.14295883f, 0.03290939f, 
    0.12863174f, 0.16783205f, 0.21969026f, -0.05974452f, 0.27008352f, 0.14717257f, -0.08925853f, -0.03988045f, 
    0.08402450f, -0.13623746f, -0.31278393f, 0.18744433f, -0.00202650f, 0.11616769f, 0.08635772f, -0.11899502f, 
    -0.11612664f, -0.10414992f, -0.06720439f, 0.02467720f, -0.33940282f, -0.23059157f, -0.34818688f, 0.00447873f, 
    -0.09823567f, -0.03089062f, -0.07329401f, 0.04122970f, 0.21940276f, 0.16855021f, 0.01600058f, 0.07006254f, 
    -0.01332679f, 0.01026799f, 0.17581072f, 0.04069468f, 0.18288112f, -0.16064073f, 0.04155420f, -0.13045311f, 
    -0.26115897f, 0.00091426f, 0.17410333f, 0.12828581f, 0.02113779f, -0.09024552f, -0.07960714f, 0.22952139f, 
    0.09721179f, 0.08551611f, 0.05744888f, -0.00377529f, -0.04665090f, 0.06472810f, 0.02448656f, -0.04616887f, 
    -0.28610313f, -0.04490777f, -0.04170866f, 0.06453988f, 0.00068167f, 0.04254922f, 0.05958559f, 0.04427351f, 
    -0.05928186f, 0.09954854f, 0.09887207f, -0.06630236f, 0.06982367f, -0.00337046f, 0.10255273f, 0.14991960f, 
    -0.09477813f, -0.09023025f, 0.00155275f, -0.08220256f, 0.06812160f, 0.03131219f, 0.02572676f, 0.01882014f, 
    0.05571296f, 0.10222518f, -0.00641174f, 0.04996640f, -0.12077653f, 0.02515999f, 0.32919726f, -0.19778314f, 
    -0.11022609f, 0.17745376f, -0.02765619f, 0.10641650f, 0.12154704f, -0.00327639f, 0.10612020f, 0.04556132f, 
    0.10280915f, 0.02939800f, 0.03508434f, 0.04467366f, 0.07903410f, -0.50454915f, -0.14827600f, 0.23026983f, 
    0.11519856f, 0.14052382f, -0.08461762f, -0.10970820f, -0.22529167f, -0.22474669f, 0.06499655f, -0.22652546f, 
    -0.30421647f, -0.33429167f, -0.05687589f, -0.08228962f, 0.01357591f, -0.14727023f, -0.06641781f, 0.30821386f, 
    0.03918580f, -0.15258463f, 0.20737644f, 0.15311913f, -0.03343885f, 0.00438278f, 0.05180530f, 0.11297775f, 
    -0.33172002f, -0.16461638f, -0.18330093f, -0.01296177f, -0.02965306f, -0.06684826f, 0.08783296f, 0.11961240f, 
    0.03469474f, 0.15865545f, 0.04452220f, 0.19638135f, 0.00953726f, 0.10518787f, -0.15070307f, 0.03674237f, 
    0.04245185f, -0.06992469f, -0.07036953f, 0.16253826f, 0.14195679f, 0.01214918f, 0.00577990f, -0.03946506f, 
    0.09146877f, -0.00863623f, -0.15719330f, -0.49458542f, 0.10193066f, 0.02824320f, -0.05288259f, -0.01505419f, 
    0.28363824f, -0.06328024f, -0.07866062f, -0.26317948f, 0.00418657f, -0.11991177f, -0.01450384f, 0.12403720f, 
    -0.03685264f, -0.07823911f, -0.02849221f, 0.20402966f, -0.02155665f, -0.27873921f, 0.11777892f, 0.16183005f, 
    0.11425688f, -0.03018049f, 0.04866545f, 0.00556344f, -0.11233579f, 0.05071647f, -0.02888500f, 0.05852501f, 
    0.13677646f, 0.10389192f, -0.04508154f, 0.10231810f, 0.05765298f, 0.12487618f, 0.23931499f, -0.04549826f, 
    -0.05559091f, 0.21642978f, -0.10658536f, 0.00902170f, 0.23775640f, -0.12790416f, -0.27080566f, -0.29111981f, 
    0.07710029f, -0.06732634f, 0.22790663f, -0.03534667f, 0.14923748f, -0.00919887f, -0.02740876f, -0.02493334f, 
    0.05083982f, -0.09711584f, 0.21367644f, 0.18568206f, 0.07754330f, -0.10585813f, -0.04112471f, 0.02000096f, 
    -0.08213043f, -0.10157631f, 0.03730951f, -0.07603284f, 0.00111965f, 0.04913525f, -0.17390144f, -0.13472989f, 
    0.13622956f, 0.21046221f, -0.01030362f, 0.03287937f, 0.09174863f, 0.19928499f, -0.07283402f, 0.00242502f, 
    -0.06448154f, 0.00346349f, 0.08293606f, 0.02285812f, 0.03856520f, 0.24894845f, 0.38191348f, -0.05171897f, 
    0.17137237f, -0.01103900f, -0.17180660f, 0.04141375f, 0.00616326f, 0.17070465f, -0.21852225f, -0.08854435f, 
    0.26928541f, -0.30549750f, 0.04325239f, 0.10682731f, 0.02319071f, -0.33509582f, -0.07849567f, 0.18400101f, 
    0.00744481f, 0.06456355f, -0.01733562f, -0.10697299f, -0.10797791f, -0.23398873f, -0.50893760f, -0.01900430f, 
    0.00923627f, 0.04646790f, -0.11854707f, 0.14505067f, -0.13664664f, -0.11167862f, -0.02323183f, 0.02253209f, 
    0.15431465f, 0.05109280f, 0.22036824f, -0.02529956f, 0.18528071f, 0.19006041f, -0.02775894f, -0.15699856f, 
    0.03815603f, 0.10129129f, 0.24796215f, 0.29881683f, 0.17709558f, 0.11613184f, -0.07116038f, 0.07112642f, 
    0.07698774f, 0.09898721f, -0.32305557f, -0.27700076f, -0.32414776f, 0.18980852f, 0.09914891f, 0.09919783f, 
    0.01387907f, 0.02655926f, 0.01486779f, 0.19973451f, -0.04003505f, 0.10399085f, -0.16451176f, -0.01906658f, 
    0.11925483f, -0.01634130f, -0.36890724f, 0.06588162f, -0.13934247f, 0.11381414f, -0.10245457f, 0.10008401f, 
    -0.06182263f, -0.01918456f, 0.15020643f, 0.13419722f, 0.16269806f, 0.16170822f, -0.22828947f, -0.26463681f, 
    0.02456295f, 0.02218968f, -0.11871288f, 0.15033880f, 0.18629308f, 0.14175728f, 0.06132224f, -0.00799071f, 
    0.21758980f, 0.07773689f, -0.10193027f, -0.04678772f, 0.03722804f, 0.09484193f, 0.08886338f, -0.23817110f, 
    -0.27467433f, -0.28281331f, -0.11459550f, 0.10166553f, -0.02207061f, 0.10845704f, 0.18718377f, 0.06266505f, 
    -0.10264388f, 0.17017899f, 0.13616280f, 0.01419478f, -0.07902725f, -0.07682857f, -0.14692847f, -0.22468287f, 
    -0.06913673f, 0.01060738f, -0.21946138f, 0.15996045f, 0.11201159f, -0.13817817f, 0.04067074f, -0.09511854f, 
    0.04010301f, -0.04201366f, -0.00124371f, -0.04179232f, -0.20162827f, 0.12489166f, -0.18320972f, 0.13650419f, 
    0.14515002f, 0.10450433f, 0.07587737f, -0.22779226f, 0.15980804f, 0.13582984f, -0.03515652f, 0.06466731f, 
    0.02655248f, -0.00255047f, -0.02032049f, 0.06459997f, -0.06960373f, -0.00668751f, -0.25496137f, 0.13693304f, 
    -0.02588677f, 0.05984561f, 0.12988281f, 0.15487048f, -0.02404753f, -0.44425520f, 0.03332601f, 0.14499341f, 
    0.13173828f, -0.01662983f, -0.05446718f, -0.41037828f, 0.00559914f, -0.36347553f, -0.13215089f, 0.01460984f, 
    0.12056012f, 0.23967904f, 0.09973989f, 0.20214812f, 0.04553619f, 0.20650508f, -0.06947424f, 0.09456520f, 
    -0.12087635f, -0.02830825f, 0.24754149f, -0.01048277f, 0.10432780f, -0.03113093f, -0.14157544f, -0.06744424f, 
    -0.07974391f, 0.04293198f, -0.10060415f, 0.09170416f, 0.11673028f, -0.30985957f, -0.00380507f, 0.11510497f, 
    -0.29929763f, 0.18798977f, 0.26908702f, 0.16008203f, 0.09001538f, 0.17566457f, 0.03475945f, 0.09484159f, 
    0.07356239f, 0.04187961f, -0.10512458f, -0.04953139f, 0.02228881f, 0.04890543f, 0.06289107f, -0.13374588f, 
    0.00818172f, 0.04007749f, 0.13428678f, 0.00116413f, 0.29921699f, 0.03331477f, -0.18827455f, -0.12915573f, 
    -0.00966783f, -0.08483005f, 0.12729153f, 0.12163804f, 0.04574401f, 0.05734240f, 0.29423642f, -0.04079948f, 
    0.03483633f, -0.04445748f, 0.04163212f, 0.07097907f, 0.17415099f, 0.05495409f, -0.21195458f, -0.02112000f, 
    -0.18889855f, 0.02263783f, -0.14282264f, 0.12724057f, -0.14960191f, 0.16927886f, 0.14430811f, -0.05163741f, 
    -0.00276874f, -0.00146297f, -0.03602040f, 0.00694427f, 0.00030328f, -0.02343217f, -0.25583771f, 0.08928224f, 
    0.41852742f, 0.02704244f, -0.11487203f, 0.19249025f, 0.01729086f, 0.19573873f, -0.07918983f, -0.04425072f, 
    0.03345435f, 0.24704979f, 0.07078009f, 0.12406708f, 0.21727830f, 0.06777176f, 0.08022227f, 0.01453985f, 
    0.12015000f, -0.04157047f, -0.17877683f, -0.01903746f, 0.06958029f, -0.00226352f, -0.07975663f, -0.06955229f, 
    0.05660670f, 0.19525622f, 0.25990552f, 0.19359939f, 0.09132750f, 0.04052715f, 0.12402637f, 0.01297853f, 
    -0.01213988f, -0.07623865f, -0.24837042f, 0.13853025f, 0.07339086f, -0.04676123f, 0.04649422f, 0.08027641f, 
    0.06611200f, 0.01782089f, 0.00950483f, -0.18318120f, 0.18981239f, 0.13815533f, 0.16888247f, 0.03117558f, 
    -0.00742284f, 0.03969323f, 0.07927151f, -0.03266267f, 0.02035000f, 0.08097642f, 0.31513792f, 0.47236031f, 
    0.08020240f, -0.08755521f, 0.04339996f, -0.05498076f, 0.18120757f, -0.00801918f, 0.12999499f, -0.11169611f, 
    -0.11253557f, -0.10913644f, -0.03148124f, -0.09115066f, -0.03533743f, 0.11047887f, 0.18208206f, -0.14464581f, 
    0.22189870f, -0.08334066f, 0.19068091f, -0.03600179f, 0.03234050f, 0.05798429f, 0.07104934f, -0.14836109f, 
    0.24724197f, -0.25541016f, 0.25438848f, -0.01750299f, 0.17638792f, 0.12617302f, 0.05224756f, 0.02310708f, 
    -0.16626336f, 0.11557940f, 0.00164792f, 0.07099350f, -0.00306366f, -0.15930226f, -0.02331895f, -0.12601189f, 
    0.05857950f, -0.02714997f, 0.13442656f, 0.25831574f, 0.22115356f, -0.09758218f, -0.02777259f, -0.07819790f, 
    0.16087209f, 0.23116167f, 0.01742087f, 0.05954200f, 0.18938635f, -0.10392527f, 0.10213798f, 0.21852840f, 
    -0.08606142f, 0.12877639f, 0.13758303f, 0.09437479f, 0.01965172f, 0.28515789f, -0.03528961f, 0.14285061f, 
    -0.01422777f, -0.06815787f, -0.00666141f, -0.10273951f, -0.19140047f, -0.09257124f, 0.16329637f, 0.17826907f, 
    0.10798351f, 0.06662716f, -0.06266173f, -0.05764415f, -0.17378624f, -0.20127170f, -0.10917579f, 0.43773869f, 
    0.05492929f, -0.00043049f, 0.02109789f, -0.19695294f, 0.05823205f, 0.05703568f, -0.03299368f, -0.26600206f, 
    -0.16652513f, 0.00142555f, 0.16538492f, -0.00676212f, -0.34043410f, -0.07265949f, -0.06704067f, -0.10782512f, 
    -0.10208917f, -0.07008088f, -0.13308331f, 0.08403223f, -0.00934744f, -0.05517700f, -0.06534578f, -0.05259461f, 
    0.27840492f, 0.27530739f, 0.20780954f, 0.18419980f, -0.03124482f, -0.09526591f, 0.05589706f, 0.06823025f, 
    0.09054875f, 0.22066317f, -0.18575370f, 0.09015533f, -0.08261725f, -0.12083924f, -0.03134226f, -0.07550509f, 
    -0.03295166f, -0.15368983f, -0.13962004f, 0.02499548f, 0.07285348f, -0.05998181f, 0.03717435f, -0.07967485f, 
    -0.04063604f, -0.10775503f, 0.05990162f, -0.06231727f, -0.04426131f, 0.08785076f, 0.11098057f, 0.09588943f, 
    -0.07802787f, -0.13313594f, 0.07374647f, -0.00614015f, 0.03555725f, 0.05228661f, 0.25132835f, -0.55465293f, 
    -0.21445972f, -0.00622067f, -0.14563349f, 0.04753767f, 0.04820042f, 0.08470742f, 0.24413982f, -0.04755622f, 
    0.17555629f, -0.04067727f, -0.12195736f, -0.12733783f, -0.03719518f, -0.06640437f, 0.00908880f, 0.22136267f, 
    0.01595745f, 0.28056630f, 0.18995278f, -0.08761749f, 0.02666664f, 0.06815934f, 0.10082895f, 0.23972519f, 
    0.07327369f, -0.10377564f, -0.18627846f, 0.23818395f, -0.01021316f, 0.02670766f, 0.04716640f, -0.00271295f, 
    -0.19300720f, -0.21778589f, 0.09732594f, -0.23568322f, -0.08186260f, 0.21755005f, -0.22270432f, 0.00510696f, 
    0.07761535f, 0.10555749f, -0.01588180f, 0.08163437f, 0.26335108f, 0.04640840f, -0.00996349f, 0.22546084f, 
    -0.00387622f, -0.08240322f, 0.03245779f, -0.21336439f, -0.51203907f, 0.09281436f, 0.13306329f, 0.08804380f, 
    0.13356805f, -0.04207820f, 0.20050523f, 0.05899991f, 0.17448451f, 0.16060075f, -0.02189664f, -0.04787872f, 
    0.28706783f, -0.22990827f, 0.07434811f, 0.11658680f, 0.06320693f, 0.22455257f, 0.06390677f, 0.09957849f, 
    0.20071483f, -0.08493824f, 0.12356833f, -0.09480030f, 0.03354436f, 0.14165004f, -0.02743625f, 0.06807814f, 
    -0.09052245f, 0.10642245f, 0.03234456f, 0.12397891f, -0.02241196f, -0.02286753f, -0.26773283f, 0.48475200f, 
    0.09032695f, -0.16051614f, -0.10251877f, 0.09960584f, 0.09151092f, 0.18860430f, -0.07601133f, -0.20822293f, 
    -0.24792334f, 0.02090936f, -0.34155306f, -0.12341936f, 0.27761373f, 0.09058928f, 0.10618527f, -0.05521912f, 
    0.03577021f, 0.08228202f, -0.03986893f, 0.07523374f, 0.03708245f, 0.03223991f, 0.09393063f, -0.05166108f, 
    0.00450044f, 0.11225552f, -0.18033600f, 0.08440750f, 0.04391481f, -0.00521801f, -0.14323404f, -0.01854898f, 
    -0.02094981f, 0.09953194f, -0.13435936f, -0.09718246f, 0.01147639f, 0.00220086f, 0.10324169f, 0.09419987f, 
    -0.11883096f, 0.02789317f, 0.01710179f, -0.03960946f, 0.03825078f, 0.07328610f, -0.53660297f, 0.05377358f, 
    0.06178600f, -0.19937447f, 0.01889073f, -0.12825979f, 0.15241621f, -0.32774827f, 0.26396546f, 0.07745980f, 
    0.11542783f, -0.25929633f, 0.11178023f, 0.12508467f, 0.09129167f, -0.23014583f, 0.04777899f, 0.09073254f, 
    0.03845099f, -0.06257080f, 0.01162137f, 0.16776666f, 0.06482133f, 0.26478785f, -0.04241925f, 0.19914728f, 
    0.21380889f, 0.03082176f, -0.06298109f, -0.06412128f, -0.08999434f, 0.08989947f, 0.08196094f, -0.10417681f, 
    -0.22065575f, 0.21466394f, 0.07522558f, -0.02504709f, 0.16184874f, 0.14367260f, -0.01689111f, -0.08695580f, 
    -0.10275262f, -0.25772962f, -0.31960601f, -0.14703903f, 0.03725498f, 0.12985896f, 0.11533727f, -0.07278363f, 
    0.02834291f, 0.04410087f, 0.24110861f, 0.19055788f, 0.29063740f, -0.25705501f, -0.21949302f, 0.19708118f, 
    0.14721365f, 0.05447156f, 0.04538755f, 0.15790750f, 0.06533163f, -0.28700063f, -0.10324736f, 0.35803941f, 
    -0.12387056f, 0.05026026f, -0.18159604f, -0.21724844f, -0.08998796f, 0.13687888f, -0.20586987f, -0.12191052f, 
    -0.00140823f, -0.05789433f, 0.13947052f, 0.09038647f, -0.02983301f, 0.03214118f, 0.04297330f, 0.05215776f, 
    -0.07686405f, -0.16962923f, -0.00215877f, -0.00472724f, -0.07655583f, -0.09826180f, -0.09571499f, 0.12569444f, 
    0.07128734f, 0.02060545f, 0.04055022f, -0.10566121f, 0.10456280f, 0.16517042f, 0.13665408f, 0.10860194f, 
    -0.15426068f, -0.26553810f, 0.22487122f, 0.08238928f, 0.14454012f, 0.05528842f, -0.02143128f, -0.18310653f, 
    0.03856305f, -0.03833317f, 0.25211439f, 0.04274695f, 0.10085069f, 0.15458766f, -0.06598239f, 0.02949958f, 
    0.12054273f, -0.27242988f, 0.11915398f, 0.02969136f, -0.06101509f, 0.07984366f, -0.07793790f, 0.04474310f, 
    0.12695806f, -0.20372254f, 0.31491229f, 0.05803142f, -0.08606021f, 0.15859222f, -0.21689492f, 0.09236442f, 
    -0.12390930f, 0.02373672f, 0.06460687f, 0.12234092f, -0.06509788f, 0.01992651f, 0.18108171f, 0.00064777f, 
    0.00408327f, -0.10753742f, -0.04536842f, 0.02266702f, 0.26341394f, 0.15384871f, 0.06822546f, 0.17723274f, 
    -0.02219678f, 0.07195024f, -0.05521621f, -0.00230124f, -0.00882855f, 0.58997160f, 0.49409959f, -0.15390036f, 
    -0.22385947f, 0.03197139f, 0.21479163f, 0.14065807f, -0.10331427f, -0.07985514f, -0.13790631f, 0.11932097f, 
    0.03149541f, 0.13944808f, 0.08493549f, 0.05230122f, -0.06841227f, -0.03982288f, -0.31777850f, -0.31513420f, 
    0.03624120f, 0.13451351f, -0.04934704f, 0.02430763f, 0.11753448f, 0.05497446f, 0.19846961f, -0.05439359f, 
    0.20480393f, 0.19844861f, -0.00835459f, 0.02350613f, -0.05793204f, -0.04877551f, -0.02980326f, 0.06237646f, 
    -0.22564828f, -0.00771109f, -0.20162818f, 0.07242214f, 0.15973990f, 0.14771833f, -0.12173304f, 0.00233258f, 
    0.08939750f, 0.20870039f, 0.15880679f, -0.34206265f, -0.13190375f, -0.15019692f, -0.01931051f, -0.03738590f, 
    0.03031366f, -0.00680724f, 0.00912968f, 0.31232688f, -0.45252961f, 0.29519743f, -0.28709492f, -0.12055596f, 
    -0.13817136f, -0.05276998f, -0.05908423f, 0.06849569f, -0.08355987f, 0.07003287f, -0.11668152f, 0.00265690f, 
    0.12126667f, -0.01245117f, 0.06617786f, 0.18592647f, 0.19021913f, 0.07217109f, -0.22017908f, -0.29515174f, 
    -0.08196891f, 0.05650042f, -0.16936316f, 0.03457589f, -0.05080184f, 0.04460645f, -0.02512193f, -0.12276193f, 
    -0.03349252f, -0.18465632f, -0.10043903f, 0.11497848f, 0.19093549f, 0.05842594f, 0.04269549f, -0.00926684f, 
    0.00667208f, -0.10734802f, 0.08532425f, 0.01484762f, 0.09322263f, -0.11482786f, 0.11057754f, 0.24721770f, 
    0.03174639f, 0.13749529f, 0.13150556f, -0.04638501f, 0.00468667f, -0.19065253f, 0.07561270f, -0.00603755f, 
    0.19978778f, 0.21693060f, -0.14279374f, -0.07748634f, -0.18301107f, -0.06279611f, 0.04006049f, 0.08161775f, 
    -0.06179934f, 0.03813486f, 0.09661166f, 0.00277829f, -0.12427658f, 0.01562614f, 0.08121042f, 0.18631312f, 
    0.04098272f, 0.12859651f, 0.04320896f, 0.27861482f, 0.07002731f, 0.00751790f, 0.17608021f, -0.08378182f, 
    0.07852557f, 0.00462783f, 0.04719497f, 0.11860274f, -0.09286719f, -0.37100458f, -0.20964794f, 0.16864289f, 
    0.13652688f, -0.04494235f, 0.00270987f, -0.07675921f, 0.07464869f, 0.04043388f, -0.28005880f, 0.19119044f, 
    0.05194164f, 0.12477067f, -0.05870778f, 0.07820338f, 0.24935572f, -0.09590659f, 0.17884876f, 0.02340137f, 
    0.05945861f, -0.01703842f, -0.16668811f, 0.09151844f, 0.16257423f, 0.06432132f, 0.17997149f, -0.45957702f, 
    -0.21597166f, -0.31401050f, 0.02832867f, 0.01421521f, 0.05807121f, 0.00909028f, 0.01927152f, 0.10348617f, 
    -0.19578387f, -0.02463026f, -0.11044160f, -0.15958357f, -0.02937390f, 0.15919282f, 0.06556582f, 0.04018282f, 
    -0.00694421f, 0.07249874f, 0.08049891f, 0.28114134f, 0.10481523f, 0.02760587f, -0.03561004f, 0.07481705f, 
    0.11645455f, 0.07229988f, -0.17994151f, 0.00600193f, -0.24998075f, -0.05054304f, -0.08406095f, 0.00956697f, 
    0.08011495f, 0.02961903f, 0.05503744f, -0.34857401f, -0.18881617f, -0.02624227f, -0.03741491f, 0.13361111f, 
    -0.10209121f, 0.26288471f, 0.22534561f, -0.10386850f, 0.34205651f, -0.30303898f, -0.31231675f, 0.05781433f, 
    0.09116630f, -0.02996325f, 0.20442466f, -0.10882957f, 0.04434095f, 0.04953445f, 0.02962468f, -0.39373541f, 
    0.10018814f, 0.06501023f, 0.05398852f, 0.05705193f, -0.09888723f, -0.07271881f, 0.08212384f, -0.12203796f, 
    0.01219330f, 0.13301271f, 0.12891723f, -0.00858163f, 0.04370114f, -0.07012413f, 0.10203427f, -0.52344102f, 
    -0.28915933f, 0.10916755f, -0.14800732f, 0.15461400f, -0.05213019f, 0.09294303f, 0.08214269f, -0.21675037f, 
    0.16488780f, -0.02244194f, 0.21893881f, -0.05388591f, -0.00651799f, 0.12730238f, 0.14894041f, -0.09295509f, 
    0.06948382f, 0.03702970f, -0.23750630f, -0.02830230f, 0.07611808f, 0.05554288f, -0.03311443f, 0.01835919f, 
    0.04922300f, 0.01508347f, 0.04506011f, -0.31325918f, -0.42839336f, -0.08566174f, 0.02544656f, -0.02731986f, 
    0.06033450f, -0.13872795f, -0.00295316f, -0.02471945f, 0.01280393f, 0.18509014f, 0.02991023f, 0.12942152f, 
    -0.07339815f, 0.02798876f, -0.02299569f, -0.15480871f, -0.30280784f, -0.22748451f, -0.36439738f, 0.02549106f, 
    -0.03328106f, -0.06228496f, 0.02886098f, 0.00939960f, 0.08572336f, -0.10342835f, -0.04430075f, -0.04100996f, 
    -0.16894449f, -0.37766674f, 0.06648541f, -0.02470819f, -0.10152677f, 0.12252712f, -0.13009231f, 0.05244827f, 
    -0.12065003f, -0.17170921f, -0.26290062f, 0.20883141f, 0.05237006f, 0.02317952f, 0.05887619f, 0.23119561f, 
    -0.26280087f, -0.00385159f, 0.03051622f, 0.09105423f, 0.00041906f, 0.11836153f, -0.07308747f, -0.01666274f, 
    -0.49387756f, -0.03797171f, -0.04441987f, 0.11938566f, 0.06316133f, 0.09568793f, -0.19343467f, -0.02642026f, 
    -0.08368075f, 0.26590124f, 0.17781888f, 0.05879975f, 0.11031110f, 0.01507236f, -0.09137511f, 0.13034013f, 
    -0.11069217f, 0.12791969f, 0.21078953f, -0.27048659f, -0.35123608f, -0.04013651f, -0.03550913f, 0.08758005f, 
    0.00951525f, -0.08691360f, -0.02410753f, -0.57260054f, -1.02468669f, -0.44073606f, -0.24456692f, 0.00288637f, 
    -0.09503099f, -0.08869871f, -0.09970321f, -0.20038354f, 0.07796234f, 0.20798941f, 0.19913039f, 0.03579436f, 
    0.15395583f, -0.04102870f, 0.02066458f, 0.26743338f, 0.24279369f, 0.05256499f, -0.50892258f, -0.62602133f, 
    0.02683836f, -0.10343953f, -0.02264381f, 0.00395756f, 0.01609886f, 0.02185458f, 0.12636599f, 0.01604104f, 
    -0.09172549f, -0.09815446f, -0.11162386f, 0.09241466f, 0.08861936f, 0.04871184f, 0.00064528f, 0.12537155f, 
    0.23529884f, 0.02233959f, 0.06873859f, -0.01135884f, 0.19189043f, 0.24805366f, 0.07105450f, 0.28915927f, 
    0.19397721f, 0.17088917f, 0.02386756f, 0.08782410f, -0.02669599f, -0.04478084f, 0.18015228f, 0.09374464f, 
    0.06771906f, 0.21804497f, -0.75925940f, -0.36835143f, -0.10361451f, -0.03071389f, 0.08736175f, 0.04714619f, 
    -0.01425171f, 0.01865990f, 0.03885621f, 0.13231075f, -0.13649052f, -0.07020401f, -0.15051143f, 0.11394294f, 
    -0.05359653f, -0.02720484f, 0.10996408f, 0.25951916f, 0.23928455f, -0.01725323f, 0.00436563f, -0.17862420f, 
    -0.10082301f, 0.03771140f, -0.02370038f, -0.06556489f, 0.34582999f, -0.00512016f, 0.13068706f, -0.08619784f, 
    0.09412463f, -0.13022518f, 0.13750395f, 0.03292421f, -0.00726109f, 0.03223405f, -0.18566728f, 0.05545583f, 
    0.04013303f, 0.03155575f, 0.04052985f, 0.32073534f, 0.12149917f, -0.03826471f, -0.46051532f, -0.23535688f, 
    -0.07186162f, -0.00445835f, -0.16346960f, -0.08887207f, 0.05826030f, -0.11421820f, -0.01290616f, -0.22678444f, 
    -0.20895553f, 0.00707322f, 0.10209662f, 0.16525549f, 0.15190065f, -0.01427898f, -0.02670318f, -0.05937213f, 
    0.15011166f, 0.52156270f, 0.08147684f, -0.10304596f, -0.23839337f, -0.15516998f, 0.15091200f, 0.04832103f, 
    -0.00806215f, -0.10687011f, -0.31459039f, -0.14226067f, 0.10998742f, 0.22645167f, 0.10101916f, -0.01532941f, 
    0.10984176f, -0.00871182f, -0.09371796f, 0.35277200f, -0.01506873f, -0.06846790f, -0.09583414f, -0.07414285f, 
    0.06889595f, -0.04883526f, 0.16220839f, -0.18190581f, -0.01529969f, -0.04361710f, -0.15295409f, -0.22102579f, 
    -0.25693461f, 0.08791783f, 0.05033115f, -0.05765935f, 0.16076283f, -0.42659771f, -0.04323146f, -0.16546613f, 
    -0.01122822f, -0.09407280f, 0.05532658f, 0.01156526f, -0.01977643f, -0.44472453f, 0.01979269f, 0.12128036f, 
    0.13516401f, 0.00225510f, 0.05785585f, -0.00132304f, -0.02526218f, -0.00380042f, 0.18520659f, -0.07698891f, 
    0.14671527f, -0.10400614f, 0.00897817f, -0.13339649f, 0.00709326f, 0.00334079f, -0.19544896f, -0.72338283f, 
    0.05913251f, -0.00621215f, 0.01406914f, 0.02268464f, 0.01611281f, -0.09138438f, -0.03414997f, 0.16911972f, 
    -0.20485865f, -0.72386223f, -0.44439185f, -0.07095151f, 0.00596541f, 0.08970036f, 0.13195691f, -0.00916231f, 
    -0.01882405f, 0.17281185f, 0.05025572f, 0.04461929f, 0.01967919f, 0.21349220f, -0.05288488f, 0.10529935f, 
    0.03555274f, 0.09942681f, -0.33446687f, -0.00208682f, 0.24047118f, 0.02103361f, 0.01036364f, -0.06332386f, 
    0.04636646f, 0.11404028f, -0.02220296f, -0.31437644f, -0.39101994f, -0.39403060f, 0.07758348f, 0.16043538f, 
    0.08135822f, -0.01963668f, -0.08339912f, -0.06222587f, -0.70248669f, 0.10593212f, -0.38116014f, 0.23083684f, 
    0.17663254f, 0.16275144f, 0.01207467f, 0.00584518f, -0.03788486f, 0.03540235f, -0.05748406f, -0.01467124f, 
    -0.00324098f, 0.10325948f, 0.13957779f, 0.05403200f, -0.25033250f, 0.07704430f, 0.06294698f, 0.15571579f, 
    0.10493103f, -0.28256822f, -0.15139383f, -0.08344037f, -0.01293775f, -0.04711411f, -0.03289681f, 0.09224475f, 
    0.12985232f, 0.10496002f, 0.03473678f, 0.20455033f, -0.02400186f, 0.00944638f, 0.12731029f, -0.04517939f, 
    0.01799821f, -0.01633973f, -0.04915026f, 0.01414233f, 0.01365558f, -0.02198821f, 0.02095614f, 0.01487432f, 
    0.02493994f, 0.03216271f, 0.01906984f, -0.00452977f, -0.04067952f, 0.04349579f, -0.03798349f, 0.02545145f, 
    -0.03838430f, 0.00340477f, -0.03080111f, -0.04918030f, -0.00978783f, -0.01084367f, -0.01090929f, -0.02492555f, 
    -0.00805011f, -0.05124567f, 0.01769569f, -0.05813568f, 0.03862505f, 0.04976724f, -0.06088256f, 0.00985305f, 
    0.03236302f, -0.03814489f, -0.01343350f, -0.02712323f, 0.03216462f, -0.00484570f, -0.02980041f, -0.03033449f, 
    -0.05508206f, -0.05058391f, -0.01925452f, 0.00304777f, -0.01326883f, 0.04786460f, -0.05867229f, 0.01191254f, 
    0.01228881f, -0.00578005f, 0.04650951f, 0.02468764f, -0.04887032f, -0.04827598f, -0.02158890f, 0.03492308f, 
    0.04643115f, 0.01418087f, 0.04292000f, 0.00664053f, 0.00314078f, -0.02773400f, -0.00656425f, -0.06010579f, 
    0.01480625f, -0.02298939f, 0.00350826f, -0.05758162f, 0.01316845f, -0.04739789f, -0.03741405f, -0.01550817f, 
    0.04048798f, -0.03874891f, -0.06004618f, 0.01886828f, -0.03021976f, -0.00111337f, -0.03966642f, 0.01679120f, 
    0.00293524f, -0.03326487f, 0.05283164f, -0.00228442f, -0.00915568f, -0.02554184f, 0.05281546f, 0.02482870f, 
    0.04329813f, -0.00651018f, -0.00638439f, 0.05440022f, 0.00738317f, -0.01018644f, -0.03192923f, -0.05084642f, 
    0.03744611f, 0.00177616f, 0.00830963f, 0.03021530f, -0.01617355f, -0.02849157f, -0.05029253f, -0.04592499f, 
    0.03417686f, -0.01373324f, -0.01769250f, -0.05927900f, 0.01172140f, -0.03173835f, -0.05216076f, 0.05716488f, 
    0.01231267f, -0.02042171f, -0.06353198f, -0.03272986f, -0.02513082f, -0.02944287f, 0.00044360f, -0.01710677f, 
    -0.03058080f, -0.01333386f, 0.03908500f, 0.00565128f, -0.04937939f, 0.05141537f, 0.03754060f, -0.02260924f, 
    0.01755921f, -0.05033391f, 0.00152507f, 0.03871180f, 0.03113089f, 0.03760159f, 0.03068620f, -0.00102077f, 
    -0.06174823f, -0.02479779f, -0.04738130f, 0.02616183f, -0.00944332f, 0.02544641f, 0.01323046f, -0.03473008f, 
    0.03217398f, -0.00585134f, 0.00848524f, 0.03255620f, 0.02426931f, -0.03024821f, 0.03821291f, 0.03270533f, 
    0.05055990f, -0.06034234f, -0.04914193f, 0.01540378f, -0.02068014f, 0.00272036f, -0.05609133f, 0.02125368f, 
    -0.03175588f, -0.05014505f, -0.04819565f, 0.00446582f, 0.03209564f, -0.03404576f, -0.01223821f, -0.04262665f, 
    -0.01966598f, -0.05739680f, -0.01609918f, -0.04419739f, -0.04102707f, -0.03072897f, -0.00375202f, 0.02535488f, 
    -0.04850112f, -0.04136466f, -0.00130511f, -0.05981247f, 0.01021475f, 0.01553608f, 0.05530878f, -0.01607137f, 
    0.01567603f, -0.04781536f, 0.02779814f, 0.01901653f, -0.05971283f, -0.01293145f, 0.00615909f, 0.04977685f, 
    -0.05735320f, -0.02221559f, -0.01513514f, -0.04387887f, 0.02115718f, -0.03516430f, -0.05627595f, -0.02930942f, 
    0.03960326f, 0.03403588f, -0.02083031f, -0.04704043f, 0.01303875f, 0.00549314f, -0.04755137f, 0.05289335f, 
    0.03833068f, -0.04083166f, 0.04690109f, 0.04049549f, 0.02025999f, 0.00029741f, 0.01154663f, 0.01864580f, 
    -0.05208584f, -0.03277501f, 0.03718815f, 0.00534689f, 0.00331813f, -0.04734632f, 0.00443939f, 0.03652617f, 
    0.02564897f, -0.05766385f, 0.02287315f, -0.03387863f, -0.03493552f, 0.03817929f, -0.05752821f, 0.03853200f, 
    -0.05323688f, -0.05372668f, -0.00530432f, 0.01209409f, -0.00353935f, -0.02972005f, 0.02941419f, 0.04611727f, 
    0.01872976f, -0.02592568f, -0.05069165f, 0.04240935f, 0.04401163f, -0.03393216f, -0.01257598f, -0.04041358f, 
    0.00948225f, -0.03988165f, -0.03747058f, -0.04047987f, 0.04164585f, 0.03606367f, -0.05188697f, -0.04554002f, 
    -0.05613146f, -0.05385157f, -0.05327873f, 0.03890032f, -0.00455291f, 0.02382597f, 0.04971915f, -0.06345671f, 
    -0.04161502f, -0.04849651f, 0.00223607f, 0.05111086f, -0.02436895f, -0.05710374f, 0.04426917f, 0.00135093f, 
    0.02733214f, 0.02399868f, -0.02202463f, -0.02812938f, 0.05228364f, 0.03086580f, -0.01535592f, -0.05536243f, 
    0.01080576f, 0.03065338f, 0.03052742f, 0.04642536f, -0.01297226f, 0.01592783f, 0.00371256f, -0.02751249f, 
    -0.08696675f, 0.12989815f, 0.25509200f, 0.07945670f, 0.03947598f, -0.09298549f, 0.01176492f, -0.06538662f, 
    0.11181756f, 0.07819853f, -0.17415535f, 0.08688606f, 0.09280965f, -0.02620955f, -0.00044587f, 0.00374780f, 
    0.08879306f, -0.03914263f, 0.26487079f, 0.10365593f, 0.11544650f, -0.03302731f, 0.12492237f, 0.08161809f, 
    0.03427706f, 0.03142327f, -0.06696787f, 0.21538113f, 0.17375915f, 0.08700167f, -0.01290100f, 0.03715964f, 
    -0.11336727f, 0.09295113f, 0.09112410f, -0.24698374f, 0.05493697f, 0.08606245f, 0.07289366f, -0.09069358f, 
    0.00413832f, 0.05581551f, -0.00349175f, 0.04498230f, -0.06114593f, -0.01905028f, 0.15852600f, 0.30068749f, 
    0.05611790f, 0.10261008f, 0.13749535f, 0.06811935f, 0.05227597f, -0.19260629f, -0.03124585f, -0.06704199f, 
    -0.02452957f, -0.05847869f, -0.04510669f, -0.05983828f, -0.05146984f, 0.02704807f, -0.03441177f, -0.39924192f, 
    -0.13660392f, 0.22913069f, -0.00766202f, -0.20656316f, -0.16981022f, 0.10341497f, 0.00727192f, 0.09560911f, 
    -0.05088887f, -0.22373009f, 0.17365173f, 0.06689048f, 0.00810720f, -0.12949675f, -0.00809815f, -0.13181253f, 
    0.04013067f, 0.24618195f, 0.28211299f, 0.12029471f, -0.02570920f, 0.19193207f, -0.00380769f, 0.06016949f, 
    -0.03670848f, -0.13706005f, -0.15065241f, -0.20881081f, 0.00505430f, 0.09742911f, -0.05341897f, -0.00831685f, 
    0.15891433f, 0.18434295f, 0.11952094f, -0.11494417f, -0.26003620f, -0.02391836f, -0.11513850f, -0.01735751f, 
    0.14198498f, -0.01159800f, 0.15873165f, 0.05430184f, -0.01940940f, -0.18292683f, 0.28671482f, -0.17521328f, 
    -0.02379980f, -0.03491132f, -0.03542639f, 0.21489203f, -0.10506850f, -0.11892304f, -0.37073776f, -0.09430052f, 
    -0.01021660f, 0.01689854f, -0.06715006f, 0.05168442f, 0.08229508f, -0.09677102f, 0.06965480f, 0.18106040f, 
    0.28873593f, 0.11139389f, 0.04941424f, -0.10222551f, 0.06069130f, -0.04037534f, -0.05914924f, -0.26492283f, 
    0.19477658f, 0.16948168f, 0.04888697f, 0.02564475f, -0.03907944f, -0.00538566f, 0.11591908f, 0.14790104f, 
    0.06692249f, -0.13938196f, -0.07989363f, 0.04073064f, 0.01888103f, 0.03291901f, -0.17087506f, 0.05748144f, 
    -0.16056752f, 0.22346994f, -0.00384635f, 0.07615303f, 0.08252473f, 0.06878874f, 0.14935490f, 0.02820653f, 
    0.06342828f, 0.07252283f, -0.03793345f, -0.10822429f, -0.03130491f, 0.04500046f, 0.01373215f, -0.11110312f, 
    -0.06562889f, -0.11760180f, -0.00783454f, -0.24483660f, -0.10079652f, 0.13002214f, -0.24689713f, 0.07669280f, 
    0.06648009f, 0.11586914f, 0.03769516f, 0.02920195f, -0.14051881f, -0.42776242f, 0.19829100f, -0.13580795f, 
    -0.21301353f, -0.00766590f, -0.00975368f, 0.12805596f, 0.23987363f, 0.01761557f, -0.09864772f, 0.00532626f, 
    0.05989891f, 0.10648718f, -0.04314279f, 0.03126300f, -0.00731525f, 0.13995475f, 0.00049762f, -0.22776267f, 
    -0.12708090f, -0.04108986f, -0.02757894f, -0.12190078f, -0.07139374f, -0.01224787f, 0.00677912f, 0.06450454f, 
    0.39090851f, 0.35229862f, 0.02895207f, 0.14923018f, 0.13128018f, -0.04264860f, 0.00044502f, 0.07017557f, 
    0.09722236f, 0.04801349f, 0.10738033f, 0.09392364f, 0.11523339f, 0.08040470f, 0.08135143f, 0.04724161f, 
    -0.10468090f, 0.11422008f, -0.19331980f, -0.24152856f, -0.06033780f, -0.21618254f, -0.09353393f, 0.06685227f, 
    0.01712716f, 0.12223789f, -0.13748048f, 0.19429345f, 0.22846963f, 0.18863875f, 0.02145049f, -0.02515026f, 
    -0.07258071f, 0.08659289f, 0.00832518f, -0.06783049f, 0.16710623f, 0.12665837f, 0.02749271f, 0.09109620f, 
    0.11074340f, 0.06714801f, 0.17617755f, -0.04043112f, 0.04247728f, 0.22069740f, 0.15313366f, -0.06057571f, 
    -0.01485354f, 0.13571720f, -0.01824789f, 0.11506815f, 0.04992402f, -0.34218788f, -0.12459647f, 0.27650774f, 
    0.15192749f, -0.03108511f, -0.06386273f, 0.06092145f, 0.11076362f, 0.03435651f, -0.01864495f, -0.14973888f, 
    -0.02183383f, 0.13444875f, -0.07546736f, -0.20448413f, -0.19768082f, -0.23685181f, -0.05354904f, 0.13570160f, 
    0.22065841f, 0.01118139f, 0.08902302f, -0.06849471f, 0.06490610f, -0.04009742f, 0.05321786f, -0.05002298f, 
    -0.50434434f, -0.09959680f, -0.04549083f, -0.00261810f, 0.01473254f, -0.10615472f, 0.09958209f, -0.12542793f, 
    0.05734414f, 0.05108288f, 0.13302998f, 0.01613311f, -0.07184186f, 0.03007927f, -0.13602199f, -0.00199202f, 
    0.08587966f, 0.31220236f, -0.06234293f, -0.23646639f, -0.17002723f, -0.03079883f, 0.02364501f, -0.01788947f, 
    -0.01872754f, 0.12700659f, -0.04078249f, -0.45628086f, -0.27747831f, 0.05535419f, -0.28911987f, -0.18346407f, 
    0.17787552f, -0.17268965f, -0.07220504f, 0.19926226f, 0.09350698f, -0.03410368f, -0.24515417f, 0.14016862f, 
    0.02593595f, 0.05490598f, 0.07568230f, 0.06598167f, 0.22557168f, -0.10070278f, -0.26599613f, -0.24691269f, 
    -0.01321595f, 0.12860347f, -0.02757281f, -0.03131297f, -0.04841772f, 0.00334540f, -0.28571996f, -0.11930822f, 
    0.05140626f, -0.15422741f, -0.20085712f, -0.15293789f, 0.09847774f, -0.04285090f, -0.08652482f, 0.11543708f, 
    0.24301551f, -0.19178839f, 0.12781928f, -0.02807610f, -0.00047240f, -0.01893185f, 0.11401739f, 0.26690927f, 
    -0.04391142f, 0.04302028f, 0.07813377f, 0.00865778f, -0.01247851f, 0.08846579f, 0.13562265f, 0.14347775f, 
    0.08321629f, -0.02214158f, -0.22652186f, 0.15950988f, -0.08050817f, -0.06157845f, 0.04951216f, -0.02854605f, 
    0.00177845f, 0.00886231f, 0.10263647f, -0.26371819f, -0.06639246f, -0.00275451f, 0.06948284f, 0.04023131f, 
    -0.11286714f, -0.06976689f, -0.14053485f, 0.16156231f, 0.26105356f, 0.01740342f, 0.03342238f, -0.07862840f, 
    0.11023538f, -0.06509485f, 0.01908896f, -0.05398289f, 0.13628602f, -0.23233670f, 0.13278735f, 0.09181883f, 
    -0.11876913f, -0.02969263f, -0.00693741f, 0.10016470f, -0.06650450f, -0.16327302f, 0.00004051f, 0.02287365f, 
    0.07159137f, 0.17339499f, 0.10231239f, 0.11340251f, 0.01823779f, 0.02800225f, -0.03928598f, 0.19695182f, 
    0.19806816f, 0.00949167f, 0.07242291f, -0.01885551f, 0.06199618f, 0.08189137f, 0.12210866f, 0.26373312f, 
    -0.03781219f, 0.08372963f, -0.00326192f, -0.01144948f, 0.07752021f, 0.25410536f, 0.07016049f, 0.04669265f, 
    0.08569642f, 0.02270118f, 0.01169833f, 0.05112264f, 0.00869622f, -0.08056863f, 0.05988349f, -0.08710657f, 
    0.10695880f, -0.26545817f, 0.14733529f, 0.40354559f, 0.20232727f, 0.07493470f, -0.03558281f, 0.00367356f, 
    -0.04159341f, 0.10720401f, -0.45078892f, -0.01309082f, -0.28801706f, -0.08116847f, -0.00452987f, -0.06524109f, 
    0.03396893f, -0.05427781f, -0.03638806f, -0.09119985f, -0.25143892f, -0.33144131f, -0.18233110f, -0.23333263f, 
    -0.04238953f, 0.10998273f, -0.07915982f, -0.01725285f, 0.29454339f, -0.23626408f, -0.45588404f, 0.04698126f, 
    0.05426625f, -0.00336965f, -0.09337838f, 0.05645540f, -0.16214029f, 0.03540366f, -0.26843575f, -0.27903336f, 
    0.15412654f, 0.07109468f, -0.00120767f, -0.03605497f, 0.00476425f, 0.02947070f, 0.19975820f, -0.04821455f, 
    0.22154479f, -0.09728377f, -0.01879987f, 0.07581981f, -0.01955952f, 0.12802964f, -0.04477342f, -0.50740564f, 
    -0.35359496f, -0.00227820f, -0.10463861f, 0.09001838f, -0.07233205f, 0.05338997f, -0.04564520f, -0.02555703f, 
    0.02153385f, 0.00551440f, 0.06515528f, -0.07401348f, 0.15247251f, 0.08853498f, 0.04677081f, -0.00079235f, 
    0.08772421f, 0.01628319f, -0.17446004f, -0.12446743f, -0.12869453f, 0.03469949f, 0.03027153f, -0.02406023f, 
    0.10574176f, 0.06057736f, 0.00551593f, -0.42563003f, -0.22795317f, -0.01037661f, -0.00568059f, 0.01088007f, 
    0.10168765f, 0.02469789f, -0.02840397f, 0.24918631f, 0.29813460f, 0.19500615f, -0.13527499f, 0.22879218f, 
    0.08337291f, -0.06236520f, -0.05086627f, 0.03818385f, 0.05454294f, -0.21970020f, -0.43767539f, 0.09793692f, 
    -0.08947612f, 0.10865837f, 0.06142615f, 0.08182977f, 0.12235547f, 0.17221138f, 0.00929022f, 0.15510175f, 
    -0.21571849f, 0.07034256f, -0.06744872f, -0.01561250f, -0.02446147f, 0.12972328f, -0.40000454f, -0.10809134f, 
    -0.26930630f, 0.09224886f, -0.03266323f, -0.19590008f, -0.04554921f, -0.06283475f, -0.11063343f, 0.09532203f, 
    0.05191145f, 0.06274043f, 0.07086144f, -0.16125602f, -0.20015016f, 0.05369524f, -0.04912192f, 0.13670039f, 
    -0.13190374f, 0.13143498f, -0.20501551f, -0.10066392f, -0.07604066f, 0.06599032f, 0.10748252f, 0.17695947f, 
    0.20092577f, -0.17974102f, 0.18167226f, -0.15546370f, -0.34647232f, 0.20207520f, 0.00909498f, 0.19133838f, 
    0.21205395f, 0.30222669f, -0.37378597f, 0.09301104f, 0.07407705f, 0.00435279f, 0.02610889f, -0.16178212f, 
    -0.09711340f, -0.06031941f, 0.10184041f, 0.28154531f, 0.04932672f, -0.03963824f, -0.30110696f, -0.15810822f, 
    -0.11017464f, -0.05304675f, -0.27903298f, -0.01062507f, 0.01506762f, -0.14668126f, -0.34762928f, 0.09695183f, 
    0.05719599f, 0.17971644f, 0.20699058f, 0.06820571f, 0.15459222f, -0.17754637f, -0.10787770f, -0.15027578f, 
    -0.20993751f, -0.29777473f, -0.06966306f, 0.01586804f, -0.00883099f, 0.06314499f, -0.09691983f, -0.03607336f, 
    -0.14044675f, -0.08161034f, -0.06571426f, -0.28113529f, 0.13655858f, 0.15252842f, -0.07055330f, -0.01408792f, 
    -0.24538819f, 0.15867957f, 0.06313930f, -0.13640593f, 0.12520261f, -0.40486160f, -0.02983627f, 0.09119244f, 
    -0.14315552f, 0.14841783f, 0.09235860f, 0.01867451f, 0.01541308f, 0.02442202f, 0.05165664f, 0.19888069f, 
    -0.04048792f, -0.25435019f, 0.10186093f, 0.03417585f, -0.11117412f, -0.00952999f, -0.01093333f, -0.13049534f, 
    -0.07148899f, 0.00886904f, 0.12397723f, 0.06200274f, -0.24879038f, 0.03328212f, -0.01268211f, 0.16397201f, 
    0.31818581f, 0.04553846f, 0.09783330f, 0.03071773f, 0.09366019f, -0.00444749f, 0.23731393f, 0.07357045f, 
    0.05782612f, 0.33033496f, -0.09663796f, 0.18081057f, -0.28828144f, -0.55622691f, -0.15308033f, 0.05975622f, 
    0.09785848f, -0.02355506f, 0.07694163f, -0.04873506f, 0.05652257f, -0.10831500f, 0.06384688f, -0.08205008f, 
    -0.00752718f, 0.16492258f, -0.03621222f, 0.21475290f, -0.04113499f, 0.17028809f, 0.20145717f, -0.09287122f, 
    0.09780578f, -0.23294288f, 0.07474980f, 0.12178810f, -0.26162440f, -0.15409550f, -0.22764391f, -0.17736855f, 
    -0.22695835f, 0.11408285f, 0.14067462f, -0.11077494f, -0.00523422f, 0.11485164f, -0.16898254f, 0.26248458f, 
    -0.17390920f, 0.01693030f, -0.18293411f, -0.09358626f, 0.11499013f, 0.10499939f, 0.13179319f, -0.12293221f, 
    -0.00899661f, 0.12100581f, 0.29617125f, 0.13352397f, -0.10826398f, -0.09814440f, 0.07447967f, 0.05128175f, 
    -0.07585794f, 0.03103103f, -0.25844753f, -0.35150537f, 0.06193943f, 0.07208926f, 0.00820759f, -0.01493699f, 
    -0.08346210f, -0.05539712f, -0.18989363f, -0.03608023f, -0.25133735f, -0.12493332f, 0.16085520f, -0.32429665f, 
    0.14656624f, 0.10522647f, 0.06021477f, -0.09213268f, 0.06010276f, -0.26285866f, -0.08970410f, 0.17310408f, 
    0.26107934f, 0.15136372f, 0.24811789f, 0.08195670f, -0.08596198f, 0.04882065f, 0.08814070f, -0.12556686f, 
    0.13242400f, 0.19623439f, 0.20495780f, 0.16122678f, 0.21875992f, 0.06923717f, -0.09467232f, -0.24738215f, 
    -0.08902599f, 0.08194681f, 0.19762312f, 0.09682650f, 0.21494980f, 0.15496057f, 0.00615814f, -0.07535136f, 
    -0.08314000f, -0.04574033f, -0.12194463f, -0.13131788f, 0.09374709f, 0.13864525f, 0.16524422f, 0.16821434f, 
    0.03819951f, 0.19273129f, 0.28355923f, -0.11296310f, -0.14479610f, -0.04576834f, -0.23171465f, -0.01203450f, 
    0.03329365f, -0.29607818f, -0.02251906f, 0.01240348f, 0.00643429f, 0.19186793f, 0.00027480f, -0.03475329f, 
    -0.00896675f, 0.10481373f, 0.12336662f, -0.36095175f, 0.02411157f, 0.02101601f, 0.09606080f, 0.20204450f, 
    0.06514755f, 0.11044288f, -0.03461204f, -0.02045305f, -0.23621669f, 0.30907896f, 0.01903804f, -0.27753595f, 
    0.05350705f, 0.04517641f, -0.12322909f, 0.33876970f, -0.07361969f, -0.13480839f, 0.01978138f, -0.05246906f, 
    -0.01074187f, -0.09511473f, 0.06189820f, -0.07081998f, -0.00913357f, -0.18931788f, -0.19535415f, 0.00826360f, 
    -0.13342313f, -0.24997832f, 0.08906554f, -0.22802506f, -0.27492172f, -0.08046663f, -0.10584398f, -0.05048658f, 
    -0.15637627f, -0.37981689f, -0.12297709f, -0.05010684f, 0.08845840f, -0.16779537f, -0.20889387f, -0.04317842f, 
    -0.02332938f, -0.16893679f, 0.09558538f, 0.13845973f, 0.03298758f, 0.11103885f, 0.00630458f, 0.02458892f, 
    0.09522619f, -0.02301823f, -0.10959767f, -0.00766607f, -0.04844525f, 0.00618653f, -0.01211917f, 0.04629223f, 
    0.10323633f, -0.25011709f, 0.15028548f, -0.00658908f, 0.00697453f, -0.09927905f, -0.02929789f, 0.25116849f, 
    0.13283475f, 0.02537768f, 0.39847517f, 0.07567427f, -0.26193953f, 0.11441509f, 0.02377103f, 0.11250397f, 
    -0.07269919f, 0.13319322f, 0.02136306f, 0.06298080f, 0.13484816f, -0.27930170f, 0.07156959f, -0.12936111f, 
    -0.22664979f, 0.16881193f, 0.03705092f, -0.05890235f, -0.02576689f, 0.11940654f, -0.07834158f, 0.02477818f, 
    -0.04704054f, -0.06726157f, 0.04537619f, 0.14159258f, 0.00324085f, 0.20344687f, 0.03650730f, -0.04702551f, 
    0.01752793f, -0.03035599f, 0.03059653f, 0.01381268f, 0.07122440f, -0.12397914f, -0.05427397f, -0.07387501f, 
    0.02827306f, -0.09315874f, -0.00476299f, 0.08387678f, -0.08352985f, -0.00706063f, 0.19683260f, -0.34523407f, 
    0.11464528f, 0.23744020f, 0.05450166f, 0.04096493f, -0.19370914f, -0.06968281f, -0.14957786f, 0.06547093f, 
    -0.04416188f, -0.00879848f, -0.00513415f, -0.03817990f, 0.03712864f, -0.03243926f, 0.09821339f, 0.10244589f, 
    0.10795053f, 0.38892996f, 0.02386124f, -0.17608707f, 0.08715724f, 0.15806928f, 0.02687507f, -0.00730548f, 
    0.04480953f, -0.12717852f, -0.36017361f, -0.18659878f, 0.04708814f, -0.08999041f, -0.16348132f, 0.00531198f, 
    -0.00602953f, -0.14169805f, -0.00319775f, -0.07274830f, -0.18748192f, -0.08550982f, 0.03419196f, -0.12092880f, 
    0.05085941f, -0.03931918f, 0.12612922f, 0.05716271f, -0.63560128f, -0.13809137f, 0.02536085f, 0.02445779f, 
    -0.09372020f, -0.04036176f, -0.11460242f, 0.01119852f, 0.03688699f, -0.02959580f, -0.19482534f, -0.09521633f, 
    0.08998267f, 0.01547630f, 0.04946666f, 0.13649841f, -0.09360959f, -0.00429066f, 0.21317284f, 0.06222561f, 
    -0.06691065f, 0.09008682f, 0.13869177f, -0.10676911f, 0.02364581f, -0.07735275f, -0.06979533f, 0.04692281f, 
    0.15654278f, -0.01551618f, 0.04521710f, -0.10556231f, 0.09187791f, 0.14093290f, 0.01801521f, 0.04652015f, 
    -0.05835466f, -0.20268609f, 0.20627406f, 0.09608369f, -0.06909872f, -0.09065059f, -0.08898479f, -0.06184647f, 
    -0.07044965f, -0.05408323f, -0.25807580f, -0.22827230f, 0.06382764f, 0.10421950f, -0.01416791f, -0.00976283f, 
    0.08156165f, 0.03320745f, 0.03890562f, -0.05843174f, -0.19695938f, -0.04728946f, -0.09039494f, 0.00259223f, 
    -0.23534378f, -0.15199181f, -0.13543679f, -0.22112322f, 0.05034402f, -0.02916835f, 0.03389303f, 0.04774112f, 
    -0.14689451f, 0.08670745f, 0.02689810f, 0.05326273f, -0.53933340f, -0.05052161f, -0.01415234f, -0.12464508f, 
    -0.17559999f, 0.02854857f, -0.02593787f, -0.06102379f, 0.10736499f, -0.01571041f, -0.00822882f, -0.10044290f, 
    -0.06139556f, -0.02495672f, 0.13153046f, 0.04530675f, 0.00606116f, 0.09215059f, -0.10310075f, 0.00147833f, 
    -0.08598316f, -0.14375247f, -0.09419832f, -0.03340996f, 0.08800463f, 0.09390161f, 0.07854825f, 0.13182922f, 
    0.35768917f, -0.14311361f, -0.03242120f, -0.00854156f, 0.06718411f, 0.04358412f, -0.07720612f, 0.12816928f, 
    0.13868152f, -0.00688948f, -0.11962194f, 0.11215395f, 0.10353823f, 0.00424239f, 0.01416122f, 0.01427796f, 
    -0.04009786f, -0.00347630f, -0.11631655f, 0.04974022f, -0.09792438f, -0.06858134f, -0.06924700f, 0.21140699f, 
    0.00604058f, 0.09173816f, 0.21786366f, 0.10582221f, -0.04726483f, -0.05379823f, 0.08212427f, 0.08621114f, 
    -0.01671011f, 0.01252514f, 0.10814722f, 0.15455452f, 0.02860871f, -0.12838921f, 0.05962443f, 0.06249276f, 
    -0.09095088f, 0.21099472f, 0.09744234f, -0.02326624f, 0.20420845f, -0.05753230f, 0.00688244f, 0.05592618f, 
    0.00026991f, 0.05569543f, -0.09740598f, -0.09497210f, -0.09459735f, 0.31226557f, -0.08236979f, -0.32054186f, 
    0.10644564f, 0.02031263f, 0.27263126f, -0.03237751f, -0.12752336f, -0.34119743f, -0.23380885f, -0.22528973f, 
    0.19124420f, 0.16851592f, 0.14251430f, -0.03956224f, -0.17412928f, -0.13962501f, -0.02782981f, -0.08546493f, 
    -0.01570041f, 0.07838296f, -0.06087315f, 0.10528209f, -0.15334323f, 0.03002973f, 0.00098876f, 0.10986000f, 
    -0.19074140f, -0.16737798f, 0.04344891f, 0.13579117f, 0.16503792f, -0.00306474f, -0.17224343f, 0.02953066f, 
    -0.10147281f, 0.10969800f, -0.24318747f, -0.14508224f, -0.04807619f, 0.19397980f, -0.06410415f, 0.15987934f, 
    0.17606367f, 0.19516064f, 0.14367442f, -0.08575598f, 0.09403376f, -0.02446641f, 0.03122583f, -0.14336807f, 
    0.00023072f, 0.03773905f, 0.00206892f, -0.16414692f, 0.16301021f, 0.07674907f, -0.20439525f, -0.08711858f, 
    -0.10523743f, 0.12733735f, 0.29788530f, 0.15062474f, -0.06789321f, 0.12358605f, 0.06409824f, 0.09705590f, 
    0.22665225f, -0.03512641f, -0.10284787f, 0.09371915f, 0.06441876f, -0.05548536f, 0.04985532f, -0.04007106f, 
    -0.06882436f, 0.00158522f, -0.37366605f, 0.04319436f, -0.13837539f, 0.09134637f, -0.02000457f, -0.18992199f, 
    -0.06343649f, 0.00547737f, -0.05239453f, 0.07038062f, -0.01357244f, -0.05046054f, -0.22887531f, 0.03356493f, 
    -0.14787428f, -0.12338080f, -0.05475212f, 0.20406550f, 0.11688331f, 0.13566686f, 0.08670749f, -0.07931288f, 
    0.14747576f, -0.25846615f, 0.05250516f, -0.16161363f, 0.15222125f, 0.07418001f, 0.10873137f, 0.20347452f, 
    0.14251898f, 0.02836667f, -0.16077326f, 0.03063544f, 0.08428185f, -0.02340388f, -0.07960714f, 0.03733642f, 
    0.01380891f, 0.09593403f, -0.00246596f, 0.09519247f, 0.02196628f, 0.09048832f, -0.06895643f, -0.11449152f, 
    -0.21830812f, -0.10324035f, 0.05089737f, -0.03824981f, -0.01068877f, 0.07059257f, 0.10469499f, -0.02572968f, 
    0.11348747f, 0.00506639f, 0.04807113f, -0.02494140f, -0.11711807f, -0.07866944f, -0.01504469f, -0.09683593f, 
    -0.22916625f, -0.02404977f, -0.07628727f, 0.03113446f, 0.17758161f, 0.40937254f, 0.27995670f, 0.11083831f, 
    -0.11963853f, 0.12117708f, 0.11383262f, 0.16005859f, 0.21197271f, 0.15159377f, 0.02807246f, -0.15013236f, 
    0.05494728f, 0.18393564f, 0.12768042f, -0.01603117f, 0.03777780f, 0.07720987f, 0.12696815f, -0.01950443f, 
    0.09810335f, 0.10244150f, -0.12630329f, 0.14279148f, -0.01747427f, 0.06721383f, 0.11823943f, 0.02844471f, 
    -0.11283157f, 0.05762699f, -0.00437510f, -0.01480444f, 0.08781269f, 0.03748032f, 0.04005830f, -0.10621297f, 
    0.17981140f, -0.14994708f, 0.13471319f, 0.29652047f, 0.06705594f, -0.02062643f, -0.00804673f, -0.04289922f, 
    -0.22301984f, 0.10597075f, -0.03381135f, 0.11575659f, 0.12595820f, -0.05512775f, -0.00044031f, -0.02869773f, 
    0.01367912f, 0.01906871f, 0.04043699f, 0.04110346f, -0.26088145f, -0.04979395f, -0.20924358f, 0.06516957f, 
    0.04780805f, -0.03605007f, 0.11526029f, -0.03553706f, -0.13308863f, 0.31380168f, -0.15715776f, -0.00658498f, 
    -0.06862053f, -0.02577669f, -0.17070575f, -0.07463687f, 0.05267479f, 0.04699260f, 0.19515237f, 0.09211402f, 
    0.12212051f, 0.09816014f, 0.04003733f, -0.22431171f, -0.09877104f, 0.07025665f, -0.11599443f, 0.24003053f, 
    -0.07341737f, 0.02616910f, -0.04040769f, -0.08589415f, -0.23163135f, 0.24047369f, 0.12560262f, -0.16953738f, 
    -0.51872492f, 0.07516097f, 0.08805603f, -0.01739903f, -0.09519576f, -0.14850806f, -0.17193964f, -0.00620235f, 
    0.07924642f, 0.08037943f, 0.01746922f, -0.00578710f, -0.01985328f, -0.10734788f, 0.15644951f, 0.05363458f, 
    0.22319190f, 0.07311255f, 0.23576042f, -0.00833322f, 0.01253639f, -0.00985311f, 0.10274428f, -0.05585771f, 
    0.05639582f, -0.02598877f, -0.02445647f, 0.01483563f, -0.09441871f, 0.06864599f, 0.16958839f, -0.02666944f, 
    -0.16113555f, 0.07647968f, 0.02753604f, -0.12295370f, 0.05996283f, 0.05149807f, -0.08563399f, 0.10237177f, 
    -0.00840675f, 0.11784333f, 0.18710041f, -0.00984416f, 0.07101791f, -0.00275969f, 0.08911161f, 0.21918559f, 
    0.04894399f, -0.12403030f, -0.12624674f, 0.01632561f, 0.00540169f, 0.04255219f, -0.19526385f, -0.02609425f, 
    0.09041239f, 0.05440719f, -0.03047488f, 0.07552394f, -0.15977591f, 0.05334711f, -0.23951949f, -0.25887412f, 
    0.31610823f, 0.18382499f, -0.02109354f, 0.04596834f, -0.12891825f, -0.07790890f, -0.08563332f, -0.09538911f, 
    0.09463130f, 0.00901134f, 0.05094167f, 0.01698566f, 0.09682756f, 0.10967082f, 0.21488968f, 0.14571495f, 
    0.09374832f, -0.16395174f, 0.20232247f, 0.28005174f, 0.26042578f, -0.11669118f, 0.06721640f, 0.02555052f, 
    -0.36909783f, -0.23527905f, 0.37948593f, -0.07459839f, 0.24927682f, -0.08889945f, -0.01323918f, -0.04105038f, 
    0.03165726f, 0.10000822f, -0.34790629f, 0.01787435f, 0.05884342f, 0.03561278f, -0.06771038f, 0.01487096f, 
    -0.00291943f, -0.16192439f, 0.08448827f, -0.28741741f, -0.28494576f, -0.08342285f, 0.30455521f, 0.09675393f, 
    0.24673873f, 0.00298880f, 0.12949213f, -0.03383769f, 0.25374624f, 0.25621125f, 0.15778267f, 0.02977510f, 
    0.11368281f, 0.06711920f, 0.14943944f, 0.12162083f, 0.17568618f, 0.06856389f, -0.04839117f, 0.01650006f, 
    -0.04529723f, 0.00944855f, -0.07613495f, -0.02851169f, 0.00127600f, 0.14313747f, -0.11551912f, 0.00991450f, 
    -0.02694219f, -0.22212939f, -0.18815248f, 0.09350926f, -0.10050260f, -0.06652608f, -0.19575943f, 0.11595540f, 
    0.18273538f, -0.02446493f, 0.12290085f, 0.06719489f, 0.08365928f, 0.06270765f, 0.06273818f, 0.01330034f, 
    -0.32141203f, 0.19079557f, -0.26814705f, 0.08206842f, 0.05668937f, 0.03762913f, 0.19572969f, -0.01674711f, 
    0.12646264f, -0.24413455f, -0.19073856f, -0.09921048f, 0.05292960f, -0.00961695f, -0.00218544f, 0.04056277f, 
    -0.02636879f, 0.13054922f, -0.16681369f, -0.06606321f, 0.10413796f, -0.12979104f, -0.02316581f, -0.13919802f, 
    -0.26388413f, 0.03685359f, -0.19692010f, 0.00644205f, 0.07112592f, 0.06182144f, -0.08614595f, -0.13463248f, 
    -0.07007350f, -0.23135951f, -0.02628915f, -0.03159348f, 0.25056073f, 0.30505037f, 0.01722906f, -0.12333899f, 
    -0.21197106f, -0.05814018f, -0.13755018f, -0.08885346f, -0.04524388f, 0.10536305f, 0.22841194f, 0.25878695f, 
    -0.00558165f, 0.03494926f, 0.02325690f, 0.06078240f, -0.12145875f, 0.12771013f, -0.16912922f, -0.29770276f, 
    -0.21323003f, -0.00107991f, 0.06142151f, 0.10235893f, 0.11578268f, 0.12125687f, 0.09378023f, 0.44080275f, 
    -0.04482828f, 0.07006405f, 0.23924479f, 0.03668486f, -0.12877797f, 0.11048356f, 0.01765233f, -0.02481767f, 
    -0.28879812f, -0.03299446f, 0.05450712f, -0.02049719f, 0.03217880f, -0.05160104f, -0.17537801f, 0.09156099f, 
    0.14553562f, -0.15487450f, -0.26291648f, -0.16383731f, 0.15249464f, 0.21744488f, 0.17958695f, -0.11003523f, 
    0.09939562f, -0.03390484f, 0.56373775f, 0.18097833f, 0.44370928f, 0.01829109f, -0.03724825f, 0.01546627f, 
    0.10305432f, 0.07806168f, 0.16467530f, 0.14899766f, 0.09526121f, -0.11260599f, -0.00991732f, -0.04016909f, 
    -0.00865902f, 0.10726495f, -0.16831763f, 0.12299435f, 0.20618409f, 0.02473498f, -0.03436064f, 0.03622771f, 
    -0.03702784f, 0.09545925f, -0.02105102f, 0.00444710f, -0.24973422f, 0.02623495f, -0.02863304f, 0.30580080f, 
    0.15843913f, -0.02291756f, -0.01033468f, -0.04155653f, 0.01140027f, -0.19582844f, 0.02525171f, 0.09487084f, 
    0.16713955f, -0.04029519f, 0.04495065f, -0.04421479f, 0.00247681f, -0.04500049f, 0.01380268f, -0.20482098f, 
    -0.12522104f, -0.24004225f, 0.16256329f, 0.11393354f, -0.02539194f, 0.14350265f, -0.04803689f, -0.25623509f, 
    -0.07955547f, -0.05416678f, -0.04640152f, 0.08480154f, 0.03501881f, 0.00994929f, -0.09195635f, 0.00373019f, 
    0.21411976f, 0.13765427f, 0.21692193f, 0.13589141f, 0.06310114f, -0.17342113f, 0.08977283f, -0.13365832f, 
    -0.07593068f, -0.08428843f, 0.03187582f, 0.08653793f, 0.09773851f, 0.15059058f, 0.01197974f, 0.01785417f, 
    0.06758057f, 0.06914801f, -0.11229166f, 0.17650953f, -0.03386152f, 0.17765035f, 0.20669581f, -0.12815019f, 
    0.08185707f, -0.05978794f, 0.03236150f, -0.09795479f, 0.03618095f, 0.04449660f, 0.17935456f, 0.24413542f, 
    -0.05121464f, 0.08259258f, 0.12169008f, -0.06939498f, 0.08073328f, 0.07769161f, 0.19071387f, -0.13382690f, 
    0.00175971f, -0.00926928f, -0.00708497f, 0.08282343f, 0.08310048f, -0.05640931f, -0.23376346f, -0.02853426f, 
    0.00570583f, 0.00575766f, 0.15885110f, 0.02614177f, 0.13087739f, -0.05934910f, 0.10337862f, 0.07170923f, 
    0.13220383f, -0.13148749f, 0.17912929f, 0.05905238f, 0.16282761f, 0.20280275f, 0.04503486f, 0.04807910f, 
    0.04290678f, -0.06162284f, -0.02438524f, 0.01856316f, -0.02696323f, 0.03757780f, 0.02243495f, -0.04163603f, 
    -0.06109524f, -0.02896615f, -0.06052775f, 0.01363785f, 0.00947768f, 0.01934197f, -0.01375044f, -0.04791841f, 
    0.01170390f, -0.04440287f, -0.03866036f, 0.02176747f, -0.04530102f, 0.00261644f, 0.04715889f, -0.03564150f, 
    0.02221710f, -0.03156893f, -0.01890988f, 0.01890272f, 0.04180895f, -0.03229586f, 0.00173895f, -0.02832712f, 
    0.04733041f, -0.05564395f, -0.05037761f, -0.04900796f, -0.04116522f, 0.01169152f, 0.00097399f, -0.00947791f, 
    0.03967695f, -0.02752481f, -0.05965554f, 0.00897690f, 0.03845266f, -0.04868823f, -0.05853506f, -0.01601707f, 
    0.04867043f, -0.02336819f, -0.03670313f, -0.05102346f, 0.03882988f, -0.03730864f, -0.00000695f, -0.01185243f, 
    -0.00843525f, -0.04803610f, 0.01598725f, -0.00498149f, -0.03717773f, -0.02640913f, -0.04841579f, -0.06374466f, 
    -0.01056222f, 0.03530042f, 0.04873428f, 0.04285133f, -0.03073389f, -0.00282071f, -0.04322996f, 0.00108884f, 
    -0.06248941f, 0.04912641f, -0.03870884f, 0.04223686f, -0.05881805f, 0.04352407f, 0.02828168f, 0.04505904f, 
    0.01234468f, -0.01380996f, 0.00997421f, -0.03297803f, 0.03735160f, 0.01033397f, -0.00437081f, 0.03324249f, 
    -0.01810318f, 0.03624383f, 0.03941860f, 0.00487962f, 0.00995843f, -0.02550987f, -0.05841960f, -0.03094905f, 
    0.04756606f, 0.03379522f, -0.02207212f, 0.03663743f, 0.00477989f, -0.03758223f, 0.04194704f, 0.05251437f, 
    -0.00130579f, -0.02590203f, 0.00319769f, 0.01141642f, -0.02196562f, 0.04557424f, 0.03451843f, -0.04510095f, 
    -0.05719122f, 0.04343151f, -0.04438295f, 0.04688837f, -0.03727725f, 0.02428084f, -0.06343338f, 0.02020743f, 
    0.01264717f, -0.02519809f, -0.04032708f, 0.02186676f, -0.03702230f, -0.06035384f, -0.02164226f, 0.00262096f, 
    0.01405952f, 0.03018409f, 0.03139280f, -0.05170690f, -0.01840482f, -0.03588816f, -0.02969276f, -0.06487492f, 
    -0.03096140f, 0.04660926f, 0.03123455f, -0.05096762f, 0.03853660f, 0.00763022f, -0.03422335f, -0.00028547f, 
    0.00104743f, -0.04895111f, -0.01250697f, -0.04665029f, -0.01082265f, 0.03398466f, -0.00212248f, 0.00891929f, 
    -0.00290924f, -0.04722348f, 0.02558088f, 0.01232474f, -0.04831873f, -0.03621598f, -0.00337540f, 0.04612791f, 
    -0.00313028f, -0.04890062f, -0.05483376f, -0.00996105f, 0.00388631f, 0.02231639f, -0.03717031f, -0.04123925f, 
    0.05174489f, -0.05444848f, -0.06252462f, -0.04442715f, -0.02796322f, -0.01590672f, -0.02781496f, -0.03972748f, 
    0.03390598f, -0.00381596f, -0.06302492f, -0.00519514f, -0.05136727f, -0.03369441f, -0.06077981f, -0.00399050f, 
    -0.06028943f, -0.03512025f, -0.03889182f, -0.05117096f, 0.01812760f, 0.02540808f, 0.02272282f, 0.05242461f, 
    0.04381329f, 0.05205717f, -0.05555249f, -0.06276488f, -0.04385532f, -0.02068778f, -0.03843143f, -0.02696288f, 
    0.02104347f, -0.05203558f, 0.04606375f, 0.03826354f, -0.01022236f, 0.03871088f, 0.01955686f, -0.03037673f, 
    -0.04934011f, -0.05534068f, -0.00216803f, 0.01567052f, -0.00072772f, 0.00032641f, 0.02315905f, 0.04196397f, 
    -0.05191182f, 0.00232253f, -0.04476864f, 0.04300022f, -0.02766913f, 0.04524505f, -0.06436217f, -0.05404001f, 
    -0.05157328f, -0.05818410f, 0.04145071f, -0.02722898f, -0.05476484f, -0.04892546f, -0.00794855f, -0.04343960f, 
    -0.02130063f, -0.05851305f, 0.03547673f, -0.02780327f, -0.01883696f, -0.03324363f, 0.03639096f, -0.02299464f, 
    0.01369034f, 0.02454674f, 0.03395482f, -0.00024459f, 0.01787917f, 0.00504884f, 0.02970852f, -0.01294697f, 
    0.03051515f, -0.02959731f, -0.04593376f, 0.02333286f, -0.05134549f, -0.04573146f, 0.00487909f, 0.02686411f, 
    0.02590576f, -0.05674275f, -0.04758568f, 0.02363354f, -0.00091474f, -0.04377652f, 0.01922851f, 0.00870614f, 
    0.03824617f, -0.05650054f, -0.04732672f, 0.03260963f, 0.02919755f, -0.05659987f, -0.03001043f, 0.03325530f, 
    -0.04643085f, -0.00519300f, -0.00716526f, -0.00128176f, 0.03680496f, 0.00216586f, -0.02556652f, -0.01387770f, 
    -0.03813160f, -0.03912318f, 0.01242344f, 0.00418695f, -0.03954470f, -0.03856119f, -0.03448427f, 0.04335937f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.06418234f, 0.22600861f, 0.02123118f, -0.04771866f, -0.02376683f, 0.05652844f, 0.05721701f, 0.22221825f, 
    -0.06372072f, -0.02329554f, 0.02530815f, 0.11968040f, -0.06784390f, 0.22694340f, -0.03111112f, -0.03785751f, 
    -0.04250465f, 0.08491783f, 0.10902419f, 0.00498401f, 0.07669306f, 0.03404822f, 0.16509648f, 0.14984266f, 
    -0.05452570f, 0.01027628f, 0.09250068f, 0.19373450f, -0.02567383f, 0.16232766f, 0.15323514f, 0.03941002f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05195826f, 0.34474355f, 0.01263273f, 0.02785035f, 0.09659286f, -0.29104593f, 0.50496274f, 0.41446915f, 
    0.09605050f, -0.21398947f, -0.52016085f, 0.19874357f, -0.23295194f, 0.26482075f, 0.15772685f, -0.06294326f, 
    -0.27368024f, 0.21990933f, 0.57127666f, 0.13613416f, 0.10880604f, -0.14132549f, -0.31386721f, -0.31614166f, 
    -0.06381726f, 0.15574627f, -0.01234617f, 0.26670811f, -0.09892880f, 0.00590442f, 0.22820459f, -0.16057001f, 
    0.14759186f, -0.05183057f, -0.17055437f, 0.03525044f, -0.10649714f, -0.04987534f, -0.00745153f, 0.01497459f, 
    0.13424166f, -0.17443112f, -0.15669098f, -0.17451648f, 0.16533235f, 0.02738961f, 0.11786248f, -0.16418639f, 
    -0.15554602f, 0.13560250f, 0.04760434f, -0.10785842f, -0.09173036f, -0.04422078f, 0.03441402f, 0.03124336f, 
    0.02963438f, -0.03659960f, -0.02462459f, -0.01729400f, -0.04576222f, -0.04412823f, -0.09041953f, 0.15739639f, 
    -0.06281213f, -0.09157932f, -0.10999998f, -0.03661845f, -0.13403280f, 0.16529734f, -0.07141210f, 0.04548226f, 
    -0.05379387f, -0.60321665f, 0.18303402f, 0.33472854f, -0.26161674f, -0.04482587f, 0.06012399f, -0.10251962f, 
    -0.10689691f, -0.03453240f, 0.05583916f, 0.19273065f, 0.00435223f, -0.28467980f, -0.25501266f, 0.07831115f, 
    -0.04232005f, -0.48363620f, -0.29632235f, -0.19996567f, -0.20419680f, -0.18792379f, 0.28135595f, -0.10201573f, 
    -0.16180615f, 0.00017939f, 0.10738939f, 0.01590014f, -0.16627258f, 0.12448069f, 0.10037826f, 0.28936929f, 
    -0.10595877f, -0.03215810f, -0.03667243f, -0.26768070f, 0.10184196f, 0.26965770f, 0.12881678f, 0.08139620f, 
    0.38764295f, -0.54054213f, 0.05298957f, -0.11764687f, -0.07246636f, 0.09356430f, 0.03659965f, 0.30591425f, 
    -0.00470250f, 0.24261583f, -0.51371944f, -0.01532600f, 0.29027262f, -0.04754460f, 0.02116275f, -0.01418623f, 
    0.13083729f, 0.26979983f, -0.04531544f, 0.16107108f, 0.14891244f, -0.51078516f, 0.12460059f, -0.06818592f, 
    -0.00360065f, 0.08035970f, 0.11879329f, 0.07327835f, 0.13435736f, 0.32581109f, 0.15336232f, -0.02041593f, 
    -0.39817828f, -0.54060322f, 0.45735359f, 0.11528919f, -0.28143728f, 0.22950947f, -0.33101323f, -0.24353205f, 
    0.00167601f, -0.03332824f, -0.14088377f, 0.36508995f, 0.24091546f, 0.06494723f, 0.07593589f, 0.04094888f, 
    -0.00020676f, 0.05561445f, 0.06614415f, 0.00073430f, 0.05267555f, -0.10421767f, 0.10166176f, -0.20524588f, 
    -0.17617659f, 0.06937888f, -0.19518797f, -0.14988162f, 0.35758588f, 0.40523323f, 0.04815311f, 0.03198856f, 
    0.10768536f, -0.40860793f, 0.42954266f, -0.21956027f, 0.19145054f, 0.15208779f, 0.01030955f, -0.64199656f, 
    -0.12205579f, -0.14808175f, -0.28923294f, 0.21183963f, 0.36086577f, 0.25552577f, -0.04833598f, -0.04856411f, 
    0.03999257f, -0.15740108f, -0.06347461f, 0.05475263f, 0.03249910f, -0.18525384f, 0.01048474f, -0.01419300f, 
    -0.14299840f, 0.05481735f, 0.03732292f, 0.04341453f, -0.09050140f, -0.17551379f, 0.17401674f, -0.04628763f, 
    -0.12468335f, -0.13139309f, -0.14945705f, -0.09649096f, -0.00750143f, 0.07133285f, -0.14844178f, 0.13450505f, 
    -0.15187952f, 0.02250300f, 0.02575091f, -0.17342521f, -0.02727571f, -0.17392316f, 0.12886259f, 0.05180168f, 
    -0.10499101f, 0.14598118f, -0.08195600f, -0.03607384f, -0.00705233f, -0.16433342f, 0.26137036f, -0.28083321f, 
    -0.06053040f, 0.00328302f, -0.41154179f, -0.29532266f, -0.22857031f, 0.41543987f, 0.12259420f, -0.02508003f, 
    0.47441736f, -0.37662745f, -0.04219866f, 0.06830627f, -0.20328051f, -0.00916449f, 0.54490852f, 0.29970360f, 
    0.03302353f, 0.22465901f, 0.31789285f, 0.24773663f, 0.06901147f, 0.08042239f, 0.11887474f, -0.03691265f, 
    -0.00051719f, 0.34014225f, 0.03243538f, 0.33651975f, -0.08831884f, -0.11003709f, 0.09333400f, 0.09647034f, 
    -0.10227365f, 0.14636420f, 0.13166755f, 0.15172172f, -0.13057341f, 0.05726570f, 0.09692327f, -0.05616645f, 
    -0.25228623f, 0.43123594f, 0.18460752f, -0.00960960f, -0.08410409f, -0.16650926f, -0.31606126f, 0.11181232f, 
    0.07489960f, 0.15597366f, 0.09108134f, -0.01045533f, -0.22969723f, -0.29286930f, -0.07730941f, 0.12236793f, 
    0.10299617f, 0.14114146f, -0.01347167f, -0.04066911f, -0.12476449f, -0.09921331f, -0.30666959f, 0.14411502f, 
    0.16982909f, -0.28800687f, -0.23531771f, 0.05206151f, -0.22026975f, 0.03802431f, 0.14508943f, 0.00075123f, 
    -0.26987955f, -0.19469331f, -0.36462352f, -0.38046449f, 0.33835185f, 0.20068410f, 0.33863235f, -0.20188072f, 
    -0.14971493f, 0.03552575f, 0.52746803f, -0.14754659f, -0.18813634f, 0.12280343f, 0.15307297f, 0.15785652f, 
    0.08293042f, 0.26703471f, -0.01324117f, -0.38396707f, -0.14076756f, -0.05520038f, 0.28106564f, -0.21076076f, 
    -0.06489522f, -0.16784896f, -0.16385844f, 0.32658681f, 0.07262216f, -0.05975862f, 0.13597324f, 0.02152589f, 
    0.13671269f, 0.26380423f, 0.46257445f, -0.01000165f, 0.31603512f, -0.04779796f, 0.20956999f, -0.65209424f, 
    0.08194043f, -0.12474657f, -0.07447230f, 0.07293135f, -0.38963360f, 0.07729585f, 0.29560715f, 0.05617543f, 
    0.15569480f, -0.15110286f, -0.12786889f, -0.27621719f, 0.16720811f, 0.21005741f, -0.16041888f, -0.00312391f, 
    -0.11454988f, -0.09651098f, 0.32340053f, -0.12180102f, 0.25290361f, -0.10469081f, 0.19714394f, -0.13429654f, 
    0.29457206f, 0.22618757f, -0.12393050f, -0.42004496f, 0.24865822f, 0.06263340f, 0.27043229f, 0.11124725f, 
    0.13255252f, -0.14302990f, -0.43616968f, 0.18889752f, -0.08866289f, 0.21487062f, 0.14147320f, 0.01067895f, 
    0.12278009f, 0.09157275f, 0.02081207f, 0.07589492f, 0.08201530f, -0.01422479f, 0.12179390f, 0.00127520f, 
    -0.09345867f, -0.09244429f, -0.20768258f, -0.00948409f, -0.10868636f, 0.11476216f, 0.16621412f, 0.14924559f, 
    -0.14449571f, -0.06577419f, -0.05319862f, 0.02371846f, -0.09801501f, -0.13649696f, -0.03522060f, -0.06341375f, 
    -0.13589767f, -0.15600643f, -0.08284079f, -0.04376328f, -0.14544043f, -0.05401694f, 0.02974732f, -0.07176171f, 
    0.03258903f, -0.15188059f, 0.16987503f, 0.10468518f, 0.14515653f, 0.13423438f, 0.03812641f, 0.20852742f, 
    0.15435423f, 0.26143801f, 0.48043075f, -0.08698456f, 0.19672555f, -0.27782407f, 0.12981403f, 0.12150204f, 
    -0.03613298f, 0.11121096f, -0.14575320f, 0.08254000f, -0.04113966f, 0.08575785f, -0.27265477f, 0.05246991f, 
    0.07429876f, 0.12086901f, -0.23625338f, -0.12405205f, 0.07400395f, -0.14975835f, 0.05274460f, 0.14792235f, 
    -0.04403641f, -0.05958080f, -0.06498393f, 0.18487176f, -0.06882296f, 0.27480274f, -0.00910600f, 0.36416358f, 
    0.09674276f, 0.16348074f, 0.21425542f, -0.20259468f, 0.20554845f, 0.01006954f, 0.08131614f, 0.02826358f, 
    0.31414366f, 0.13383202f, -0.15879445f, 0.16885890f, -0.15885608f, 0.03453261f, -0.14461856f, 0.30131397f, 
    0.12158564f, 0.16197409f, -0.21103632f, 0.07043493f, 0.29372966f, -0.15324748f, -0.17722704f, 0.11710739f, 
    -0.17266193f, -0.03635532f, 0.06545368f, -0.00363958f, -0.07932247f, -0.14145713f, -0.02368118f, -0.11006308f, 
    0.08945466f, 0.01670117f, 0.06798540f, -0.08538052f, -0.00021872f, -0.15728141f, -0.00310801f, -0.13975969f, 
    -0.18911280f, -0.00931612f, -0.10900165f, -0.06761479f, -0.04641134f, 0.04655091f, -0.13998918f, 0.01915721f, 
    0.00098980f, 0.03116850f, -0.18624197f, -0.20014277f, 0.09494710f, -0.20786558f, 0.04513266f, -0.03436331f, 
    -0.07856648f, 0.15645745f, -0.17218608f, 0.35753334f, 0.06941748f, -0.32629442f, 0.10304876f, 0.17304917f, 
    -0.11522583f, 0.20992868f, -0.09277743f, 0.00008432f, -0.14308338f, -0.21457104f, -0.14660311f, -0.01804161f, 
    -0.28247863f, -0.29474288f, 0.09773840f, 0.11649130f, -0.19758096f, -0.11968467f, -0.10735983f, -0.10203417f, 
    -0.05740200f, 0.05405015f, -0.31317654f, 0.19456851f, -0.16687417f, -0.04136443f, 0.23877217f, -0.04354370f, 
    -0.04693235f, 0.28353956f, -0.01315561f, -0.25857323f, 0.08092912f, -0.14899686f, 0.04129684f, 0.35286355f, 
    0.05781806f, -0.27935046f, -0.34924722f, 0.16133977f, -0.29133767f, -0.22540757f, -0.05636670f, -0.03017682f, 
    -0.09603724f, -0.05388935f, 0.18044947f, -0.00733832f, 0.26317164f, 0.12307030f, 0.34693334f, 0.23042087f, 
    0.08766728f, -0.07455418f, 0.17859127f, 0.08971170f, -0.40371126f, 0.14527842f, 0.32869288f, 0.09159092f, 
    0.15537459f, 0.13299254f, -0.05816019f, 0.07579775f, -0.03265522f, 0.10521849f, 0.16254994f, -0.26551357f, 
    -0.05654231f, 0.05728440f, 0.13657694f, -0.15392488f, -0.36171263f, -0.02017970f, 0.16511503f, -0.06904452f, 
    -0.19395486f, -0.14979395f, 0.23941939f, 0.25579014f, -0.17555530f, 0.16207552f, 0.38958830f, 0.27630323f, 
    -0.01540503f, 0.00097474f, 0.29470333f, 0.27680400f, -0.18379702f, -0.24856183f, 0.25333866f, -0.13983132f, 
    -0.02530774f, 0.16427067f, -0.03709463f, 0.36221832f, 0.06650959f, -0.26644745f, 0.23226775f, 0.08753666f, 
    -0.03126500f, 0.27504957f, -0.15091988f, 0.17440946f, 0.21263915f, 0.52651113f, 0.09901848f, 0.04309550f, 
    0.29150209f, 0.11982480f, 0.28546375f, 0.06666109f, -0.31823334f, -0.23653509f, -0.21677138f, 0.15581875f, 
    -0.14822020f, 0.37465483f, -0.07859047f, 0.06956549f, 0.09026463f, 0.06968930f, -0.23475756f, -0.15007348f, 
    0.15149269f, 0.18055609f, 0.04210118f, -0.19214016f, 0.10307587f, 0.32516795f, -0.07970880f, 0.24072944f, 
    0.16621742f, 0.06881962f, 0.36757162f, 0.06801561f, 0.18328317f, 0.10426674f, 0.03436266f, 0.07874178f, 
    0.46702439f, 0.40270802f, 0.09860956f, -0.27594939f, 0.10957206f, -0.23401283f, -0.19072400f, -0.04681667f, 
    -0.07961009f, 0.34149250f, -0.26138589f, -0.28488863f, -0.21843553f, -0.03611629f, -0.08903629f, -0.10439160f, 
    -0.09285761f, 0.30523410f, -0.02234807f, 0.04774876f, 0.04413496f, -0.33793035f, 0.00607731f, 0.14080237f, 
    -0.03157844f, -0.18864825f, -0.28639105f, 0.46212870f, -0.10805485f, 0.11660889f, -0.17154136f, 0.02336001f, 
    -0.27543536f, 0.31204432f, 0.10623657f, -0.31238410f, 0.13243563f, 0.13578117f, -0.07919714f, -0.60918260f, 
    -0.02643228f, -0.10982381f, 0.38962010f, -0.09100927f, -0.25573626f, 0.15595137f, 0.09498492f, -0.05480172f, 
    0.15111360f, -0.13218139f, 0.10148358f, 0.26219484f, 0.16072261f, 0.12318400f, -0.11923455f, -0.20573792f, 
    0.12731117f, -0.23636152f, 0.15509646f, -0.20095539f, -0.01003319f, 0.20501162f, -0.00530009f, -0.00510518f, 
    -0.33925277f, -0.37723893f, -0.46666247f, -0.15931375f, -0.02467261f, 0.36706299f, 0.48306170f, 0.10836370f, 
    -0.15977636f, -0.00856164f, 0.36734989f, 0.30496201f, 0.23250507f, 0.36211064f, -0.07691576f, 0.01626927f, 
    -0.02373763f, 0.14832641f, 0.12460661f, -0.02010996f, 0.03606771f, 0.16739933f, -0.40165681f, 0.26923242f, 
    0.00091081f, -0.17331620f, 0.06456937f, -0.25286004f, -0.03288732f, -0.22198927f, -0.17496762f, 0.01156895f, 
    0.33805910f, 0.18366365f, -0.25503051f, -0.19741632f, 0.03112084f, -0.08439993f, 0.57080537f, 0.03064331f, 
    -0.14454539f, -0.01667259f, -0.11949305f, 0.15708232f, -0.27643806f, 0.01624738f, 0.07999609f, 0.03064721f, 
    0.11797375f, 0.16372050f, -0.03430907f, 0.11132275f, 0.04271564f, 0.18585931f, -0.45555902f, 0.09206339f, 
    -0.10993749f, -0.19102696f, 0.15252420f, -0.03752527f, 0.20219967f, -0.08495456f, 0.14833283f, -0.02669683f, 
    -0.42488819f, -0.44148013f, -0.24649736f, -0.52973187f, -0.04059439f, 0.21926516f, 0.14764196f, 0.24746674f, 
    -0.07391310f, -0.00078844f, -0.06178018f, -0.42478916f, 0.13323365f, 0.23950773f, 0.19922510f, -0.05565234f, 
    -0.11678592f, -0.15795469f, 0.00986226f, 0.00758909f, 0.16502914f, -0.07020398f, -0.07061936f, 0.04461402f, 
    -0.12949027f, 0.09596843f, 0.05047237f, 0.13070956f, -0.08684587f, -0.07663724f, 0.03721350f, -0.13532846f, 
    -0.07537203f, -0.12790072f, -0.10517697f, 0.01684413f, -0.14961566f, -0.17172538f, -0.10053892f, -0.15613928f, 
    0.04438539f, -0.12310462f, -0.09728091f, -0.04732113f, 0.00876711f, 0.12005138f, -0.16777591f, -0.13168296f, 
    0.00185754f, -0.08892366f, 0.17094903f, -0.12432586f, 0.17327890f, 0.07020538f, -0.11204704f, 0.01046388f, 
    0.09872052f, -0.11754407f, -0.08558255f, -0.14196324f, -0.05674679f, -0.01048030f, 0.15545858f, 0.06646442f, 
    0.06822959f, -0.00048982f, -0.05724707f, 0.00710104f, -0.04397103f, -0.07889840f, -0.04483965f, -0.15352318f, 
    -0.15345921f, -0.04548237f, -0.02278053f, 0.13198434f, -0.13372679f, -0.14689068f, -0.10947530f, 0.04451021f, 
    0.03529660f, 0.22473066f, 0.10161629f, 0.21869764f, 0.03825429f, 0.06559628f, -0.18768708f, 0.33812609f, 
    -0.10645369f, 0.37826297f, 0.18473715f, 0.18611221f, -0.25227991f, 0.13594721f, 0.11605764f, 0.02662809f, 
    -0.19027235f, 0.28057176f, -0.29943085f, 0.06987476f, -0.04061197f, -0.20129439f, -0.16959845f, 0.02991753f, 
    0.11466438f, 0.26479182f, 0.41139224f, -0.14586511f, 0.13706975f, -0.13776049f, -0.23838329f, -0.16565754f, 
    0.01571228f, 0.00027647f, -0.13890687f, -0.00431775f, 0.03700895f, 0.22961672f, 0.13645758f, -0.33809629f, 
    0.14117275f, 0.29666987f, 0.70457250f, -0.30815884f, 0.24761677f, 0.06043446f, -0.08171642f, 0.13565767f, 
    0.40348798f, 0.13328961f, 0.04716687f, -0.46868593f, 0.08313575f, 0.16328484f, -0.12298293f, -0.44325343f, 
    0.16450706f, 0.23591544f, -0.50906026f, -0.11289340f, 0.33200163f, 0.01027181f, 0.29868752f, -0.09957979f, 
    -0.09407791f, 0.16636597f, 0.02796612f, 0.28587136f, -0.09666587f, -0.05880763f, 0.13186730f, 0.37720343f, 
    -0.09205332f, 0.01780950f, 0.01789771f, 0.45736068f, -0.25532109f, 0.04841494f, 0.02082616f, -0.16197298f, 
    -0.51569766f, 0.47823432f, 0.16155516f, 0.17070255f, 0.20874068f, -0.17914884f, -0.35112354f, -0.04007525f, 
    0.17114800f, 0.04400146f, 0.55528444f, -0.16406117f, -0.18040583f, 0.09990156f, 0.28681755f, -0.10725092f, 
    -0.03963974f, -0.14545907f, -0.00723722f, 0.15686455f, -0.09991033f, -0.12835461f, 0.04122942f, 0.09092898f, 
    0.15374106f, -0.06661456f, -0.14342594f, 0.13015409f, 0.00404188f, -0.09185796f, 0.10638977f, -0.09545237f, 
    0.03043972f, -0.17325108f, -0.02657478f, -0.07440485f, -0.11328128f, -0.15067545f, -0.17002235f, -0.14114754f, 
    -0.01047107f, 0.10237090f, -0.17693177f, -0.04290634f, 0.10921083f, -0.03636641f, -0.02028679f, 0.05214100f, 
    -0.00907662f, 0.31364551f, 0.07701764f, -0.33247280f, 0.04515922f, -0.11979034f, 0.20656830f, 0.09867945f, 
    0.01347729f, -0.05777511f, 0.17449893f, -0.07872558f, 0.25271708f, 0.14361705f, -0.08629471f, 0.05693090f, 
    0.51461893f, -0.28248513f, 0.65473747f, -0.29413038f, 0.18584304f, 0.17235446f, -0.28149331f, 0.13067712f, 
    0.17512737f, -0.01591097f, -0.67832768f, 0.33561406f, -0.00248002f, -0.11075496f, 0.35409209f, -0.13427588f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08029824f, 0.04404809f, 0.23321751f, 0.02921609f, 0.17824301f, -0.06026227f, 0.12877850f, 0.32590458f, 
    0.16869009f, 0.18344752f, 0.16448103f, 0.10089701f, 0.11557757f, -0.07859544f, 0.14170882f, 0.01870224f, 
    0.02064134f, 0.20050336f, -0.13866904f, 0.24206801f, 0.07916117f, 0.29036719f, 0.10011596f, 0.01943082f, 
    -0.12182494f, 0.03097842f, 0.08019967f, -0.02385123f, 0.20420733f, 0.14797007f, -0.12798452f, 0.00793813f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.18968385f, 0.04146289f, -0.04893667f, 0.23275873f, 0.12365676f, 0.21458411f, 0.12145595f, -0.13636446f, 
    -0.56588095f, 0.08142581f, -0.25387028f, -0.12704585f, -0.01387603f, 0.24576429f, 0.12081109f, -0.06087650f, 
    0.08187897f, -0.22521764f, -0.10538724f, 0.10664923f, -0.26650944f, -0.22889291f, 0.50250727f, -0.13753028f, 
    0.19983342f, -0.05681024f, 0.07572583f, 0.00336043f, 0.23676808f, -0.23793167f, 0.15191291f, 0.07262905f, 
    0.18513075f, -0.05210180f, -0.19858627f, 0.18812908f, 0.40190065f, 0.33626509f, 0.01596815f, 0.48405102f, 
    -0.20410158f, 0.05132998f, 0.20888878f, -0.11674356f, -0.06247471f, -0.32192189f, -0.23783924f, 0.08266323f, 
    0.10892240f, 0.20262332f, 0.05086152f, 0.26331466f, -0.45712996f, 0.09471583f, 0.26397601f, -0.03826062f, 
    -0.14162497f, -0.07722166f, -0.13932975f, -0.19669282f, -0.19635338f, 0.17386054f, -0.13921799f, 0.23380695f, 
    -0.14189823f, -0.06152186f, -0.34748766f, 0.15327047f, -0.00665113f, 0.18867841f, 0.11865941f, 0.03461564f, 
    -0.24376987f, -0.19883135f, 0.67309529f, 0.50981456f, -0.10734776f, -0.01561667f, -0.24760772f, 0.17515309f, 
    -0.31612989f, -0.05241807f, -0.39220199f, 0.02318104f, 0.41264820f, -0.07805565f, -0.58218783f, 0.52506113f, 
    -0.02419559f, -0.13874762f, 0.08123451f, -0.43280339f, 0.32968500f, -0.26564121f, 0.04271042f, 0.17561665f, 
    0.32917657f, -0.08479729f, 0.06812554f, 0.19595833f, 0.13103352f, 0.66121191f, -0.11129781f, 0.25158292f, 
    -0.17944182f, 0.04651595f, 0.57618237f, -0.23310214f, -0.12128276f, -0.59110463f, -0.49156564f, -0.10676143f, 
    -0.09857343f, 0.03166719f, -0.35734484f, 0.29884207f, 0.23776919f, 0.43060255f, -0.12314767f, -0.40930361f, 
    -0.33372676f, 0.16409989f, 0.17586227f, -0.28031009f, 0.28863001f, -0.20126529f, -0.05736466f, 0.15496610f, 
    0.16428295f, 0.00264573f, -0.30355194f, 0.11525457f, 0.39262766f, 0.07944348f, -0.05739810f, -0.01709468f, 
    0.07077511f, 0.40572628f, -0.31297335f, -0.05701374f, 0.03330358f, -0.20202982f, -0.19018997f, 0.13222586f, 
    0.28558731f, 0.25493607f, -0.20724863f, -0.15457064f, -0.42765480f, -0.05469018f, 0.27883440f, 0.17876317f, 
    0.45094156f, -0.14368223f, 0.02116401f, 0.07639418f, 0.03589630f, 0.16419576f, 0.03158182f, 0.13267303f, 
    -0.11604690f, -0.15386698f, 0.00785402f, 0.18978213f, 0.00400577f, 0.10739449f, -0.11875527f, 0.11704963f, 
    -0.40981922f, -0.24076852f, -0.38407078f, 0.04922597f, 0.12334280f, 0.33545899f, 0.16934924f, 0.15053783f, 
    -0.04214700f, -0.19214748f, -0.53924060f, -0.06581122f, 0.14809269f, -0.35835999f, -0.02147191f, -0.18539801f, 
    -0.17188266f, -0.09190310f, -0.13863747f, -0.18534335f, 0.21507409f, -0.27823684f, -0.03426992f, 0.02983350f, 
    0.32739165f, -0.10512079f, 0.06781570f, -0.19481200f, 0.01905863f, 0.10708141f, -0.08983929f, 0.15988053f, 
    -0.12300699f, 0.35289252f, 0.88282245f, 0.08345327f, 0.13590950f, -0.42127356f, -0.44061285f, 0.14369395f, 
    0.11954939f, 0.17064218f, -0.06536216f, -0.13135530f, -0.03746991f, 0.48511472f, 0.07880221f, 0.17507814f, 
    -0.31016341f, -0.07924366f, 0.10890130f, -0.24172693f, 0.07459517f, 0.02778936f, 0.02807706f, 0.24354753f, 
    0.33372110f, 0.01988037f, -0.20777389f, 0.50307703f, 0.16417412f, 0.37812680f, -0.19884990f, 0.34097463f, 
    -0.04882493f, -0.28779522f, -0.02387104f, -0.03425713f, 0.02132129f, -0.15006582f, 0.09111510f, -0.06997601f, 
    -0.18416837f, 0.02072554f, 0.08972918f, 0.29105279f, 0.10159937f, -0.40623701f, -0.13824917f, -0.15998854f, 
    -0.13629282f, -0.09553774f, -0.08036249f, -0.20081751f, -0.05261007f, 0.00018229f, -0.06408138f, 0.49630323f, 
    -0.17677200f, 0.02295785f, -0.02043148f, 0.09651278f, -0.02748499f, -0.05187565f, -0.07370365f, 0.02210006f, 
    0.11292876f, 0.09992907f, 0.03956260f, -0.02201894f, -0.17212649f, -0.14196803f, -0.00067861f, 0.15748216f, 
    -0.13273549f, -0.17318647f, 0.11954451f, 0.03226743f, -0.19714053f, -0.10512526f, -0.06209696f, -0.04075498f, 
    0.13892598f, -0.07920853f, -0.12773643f, -0.10830636f, -0.13260181f, -0.02480297f, 0.10466609f, -0.12351807f, 
    0.29828224f, -0.17256927f, -0.09036515f, -0.05967256f, 0.50509953f, 0.19476140f, 0.11841863f, 0.24341352f, 
    0.46051425f, -0.12448580f, 0.04548374f, -0.59972811f, -0.08056755f, -0.25097445f, -0.03592434f, 0.04345538f, 
    0.25529495f, -0.13814509f, 0.20319854f, 0.24558963f, -0.35267010f, 0.08731963f, -0.09845721f, -0.56198162f, 
    -0.37720603f, 0.12242201f, 0.05821595f, -0.03642687f, -0.02202936f, 0.08380867f, 0.08418688f, -0.07488580f, 
    -0.19463864f, 0.09952515f, -0.04839072f, -0.10551558f, -0.14907855f, -0.08652499f, 0.14151785f, -0.19570495f, 
    -0.18957916f, -0.03273240f, -0.13967204f, -0.19375050f, 0.07149655f, 0.00840640f, -0.04518380f, 0.08621521f, 
    -0.10759256f, -0.16529265f, -0.00071312f, 0.05525669f, -0.13788866f, -0.04204630f, 0.01793408f, -0.18372343f, 
    -0.01725996f, 0.17100315f, -0.01320680f, -0.11153845f, 0.05036144f, -0.08291575f, -0.00121739f, -0.07118914f, 
    0.23582311f, -0.01336521f, 0.13016848f, 0.01262471f, -0.08940949f, -0.28799412f, 0.08768924f, 0.56468326f, 
    -0.13100366f, 0.59001189f, 0.10644715f, 0.14128684f, -0.05007324f, -0.26385218f, -0.21370819f, 0.00532368f, 
    -0.01977998f, 0.33610514f, 0.11660597f, -0.26117003f, -0.55952734f, 0.19860156f, 0.35729390f, 0.13738753f, 
    0.12589549f, -0.14995374f, 0.04160428f, -0.17289373f, -0.53120166f, 0.25170064f, 0.15446095f, -0.04482589f, 
    0.01127962f, -0.00758406f, -0.31118262f, -0.13257897f, 0.18685822f, 0.14555168f, 0.10145922f, -0.35358530f, 
    0.09002276f, 0.19969094f, 0.66557115f, 0.05403508f, -0.06562651f, 0.01492652f, -0.35826519f, -0.02529039f, 
    0.25166658f, 0.10352556f, -0.27399632f, -0.05560952f, 0.27985707f, 0.61554259f, -0.48062626f, -0.16145606f, 
    0.07282367f, -0.05430548f, -0.09862994f, -0.19462202f, 0.22564191f, 0.17904264f, 0.12794262f, 0.33466947f, 
    -0.04122496f, 0.07698916f, 0.35791153f, 0.19474353f, 0.07083835f, 0.30576712f, 0.07996443f, 0.04725577f, 
    0.16812664f, -0.41652912f, -0.52965778f, 0.06787908f, 0.03105653f, 0.28787428f, 0.39103553f, 0.15033907f, 
    -0.19487174f, -0.04933263f, 0.17052871f, -0.05755229f, -0.05675101f, -0.75404733f, 0.29277319f, 0.00559874f, 
    -0.53286266f, 0.07392443f, 0.01574944f, 0.08003037f, -0.14348333f, 0.02823450f, 0.08793000f, -0.29553396f, 
    0.08396813f, 0.12346302f, -0.20780201f, -0.04451357f, -0.02195486f, 0.29935738f, -0.02972725f, -0.21457393f, 
    -0.06047991f, -0.17855996f, 0.11330585f, 0.26485616f, -0.09190590f, 0.19700815f, 0.08102039f, 0.10887638f, 
    0.22828232f, 0.01405207f, 0.18313731f, -0.27931041f, -0.43101886f, -0.12348375f, 0.22844647f, -0.09113865f, 
    -0.00814830f, 0.02194709f, -0.04908795f, -0.23907956f, 0.26445851f, 0.06422390f, -0.17240332f, 0.22097801f, 
    -0.03256856f, -0.04367967f, -0.49891365f, 0.10828031f, -0.27962524f, 0.19327606f, 0.05124239f, -0.37465906f, 
    0.02883988f, -0.09718781f, 0.07822170f, 0.28452784f, 0.06431028f, 0.16117947f, 0.25947481f, -0.06397393f, 
    -0.34911299f, -0.14484514f, -0.23440142f, 0.14985247f, 0.69687426f, 0.06633462f, 0.14272630f, 0.43637171f, 
    0.26714489f, -0.09773407f, -0.19181775f, 0.16645053f, 0.57155633f, 0.06877140f, -0.12948522f, 0.17393966f, 
    0.00490398f, 0.05584854f, 0.16822584f, -0.09846141f, 0.39433590f, 0.23649409f, 0.05958455f, 0.08158745f, 
    -0.12134117f, 0.47529361f, -0.11504949f, 0.05137941f, -0.15827356f, -0.16544086f, -0.43390289f, -0.05194878f, 
    -0.15776321f, 0.07787126f, 0.01562610f, -0.06109495f, -0.32419610f, 0.49647456f, 0.43379635f, -0.02216459f, 
    0.54004556f, 0.11230148f, -0.14507866f, -0.16991650f, 0.01384539f, 0.00633816f, 0.15255189f, -0.00343944f, 
    0.06781717f, -0.13276853f, -0.13700780f, -0.24972379f, 0.17604314f, -0.19379985f, 0.13581762f, 0.48039800f, 
    0.23247826f, 0.16210561f, -0.43460283f, -0.27088758f, 0.11027866f, -0.07911703f, -0.03370025f, 0.10313963f, 
    0.30406487f, 0.04685292f, 0.18808453f, 0.34354243f, -0.02202361f, 0.00530738f, 0.09288202f, -0.17358352f, 
    -0.18284170f, -0.14369409f, 0.10446734f, 0.30784225f, 0.00296298f, 0.24950971f, 0.00133750f, -0.27365398f, 
    0.29983094f, -0.00318048f, 0.02079532f, -0.21822070f, 0.34181646f, 0.10832705f, -0.05440962f, -0.47122473f, 
    0.16707581f, 0.10104907f, -0.18276834f, 0.12648138f, 0.18299223f, 0.17619453f, -0.08061109f, -0.01797042f, 
    0.11321006f, -0.16941389f, -0.27316773f, 0.26002532f, 0.33815435f, 0.38458696f, -0.06989577f, -0.16550373f, 
    -0.03918476f, -0.04852794f, -0.02853607f, 0.13048732f, -0.00364556f, 0.27009118f, 0.14647040f, 0.03688755f, 
    0.01925258f, -0.10874013f, -0.03040694f, 0.19598396f, -0.09781990f, -0.04361901f, -0.12556434f, 0.19051179f, 
    -0.12005144f, 0.18917468f, 0.41824400f, 0.15348233f, -0.01668098f, -0.13552232f, -0.04361732f, 0.05395788f, 
    0.19013645f, 0.26554510f, 0.14986792f, -0.34892669f, -0.00150991f, 0.27487072f, 0.06195613f, 0.14333348f, 
    0.12832548f, -0.16675825f, 0.18596052f, -0.00939062f, -0.06200052f, 0.02944280f, 0.04562472f, 0.26767671f, 
    0.29431343f, -0.15107928f, 0.20419215f, -0.02358397f, 0.11219287f, -0.04749075f, 0.17280215f, -0.08209983f, 
    0.56260109f, 0.10117480f, -0.03814266f, -0.44015896f, -0.03152810f, 0.06486072f, 0.02577019f, -0.09252898f, 
    0.45525002f, 0.14374995f, -0.17547593f, 0.20386891f, -0.08678193f, 0.35137239f, -0.34009889f, -0.34800377f, 
    -0.07798374f, -0.02201652f, -0.07846662f, 0.40059364f, -0.16774336f, 0.28526732f, -0.04254698f, -0.00367264f, 
    0.22639728f, -0.12174963f, -0.02168525f, -0.19709074f, 0.20155574f, -0.16959201f, 0.09531828f, 0.15871319f, 
    0.42149889f, -0.40284911f, 0.46828610f, -0.09825765f, 0.14805101f, 0.13418844f, -0.05834826f, 0.15358859f, 
    0.29821476f, 0.26895219f, 0.34992772f, 0.20043635f, -0.02086579f, -0.04385002f, -0.29981357f, -0.01700068f, 
    -0.79183000f, -0.16814548f, 0.05113918f, 0.15649943f, -0.04580798f, 0.11818265f, 0.04311147f, 0.23165210f, 
    0.00986486f, 0.08242477f, 0.03357504f, 0.01888077f, -0.30419415f, -0.36981314f, 0.06558162f, -0.07892379f, 
    0.02278598f, 0.32338959f, 0.01146925f, 0.17514968f, 0.13077416f, -0.11006653f, 0.05165556f, -0.17094339f, 
    0.12453227f, 0.30074340f, 0.13021503f, -0.41824353f, 0.18088023f, -0.05658270f, 0.12573373f, 0.42737699f, 
    0.57278633f, 0.07821861f, 0.03602235f, 0.22482786f, -0.14974101f, -0.07798608f, -0.13753477f, 0.27735153f, 
    -0.20656127f, 0.10111840f, 0.06341450f, -0.02636705f, -0.00288418f, -0.02585527f, 0.01220415f, -0.30940723f, 
    0.20565070f, 0.27882698f, 0.12883073f, 0.24232768f, 0.09411030f, 0.05075921f, -0.17571102f, 0.11268320f, 
    -0.01627557f, 0.04364721f, 0.14670475f, -0.28254709f, 0.12375887f, 0.55970705f, 0.22140074f, -0.00953686f, 
    0.59237522f, -0.04354669f, 0.17800924f, -0.01565880f, 0.29324558f, 0.13742959f, 0.05920335f, 0.04790287f, 
    0.28752425f, 0.17308173f, -0.32743919f, -0.07378841f, 0.12204850f, 0.01336948f, -0.14526509f, -0.51349169f, 
    0.14577028f, -0.03765524f, 0.05503444f, -0.14285721f, 0.03342419f, 0.20495290f, 0.00723242f, -0.09185456f, 
    0.54273456f, 0.26507008f, 0.03444545f, 0.03802073f, -0.10536211f, 0.24417573f, -0.30344251f, -0.31809568f, 
    -0.07061374f, -0.14207815f, 0.09702792f, 0.07414745f, -0.37915027f, 0.27550051f, -0.17803442f, 0.14684114f, 
    0.11831319f, -0.09982329f, 0.20923623f, 0.13542043f, 0.11168921f, 0.37351152f, 0.00189969f, 0.11210040f, 
    -0.18262522f, -0.13789220f, 0.39414850f, 0.49657187f, 0.03236075f, -0.20208427f, -0.05502611f, 0.11707887f, 
    -0.16448182f, -0.04971121f, -0.27237695f, 0.15692422f, 0.21492484f, -0.08888975f, -0.15184017f, 0.44759065f, 
    -0.39312398f, -0.04544018f, -0.12909412f, -0.03617558f, 0.47089246f, -0.24256010f, 0.15595287f, 0.33357611f, 
    0.05978768f, 0.01225925f, 0.01964059f, 0.16284947f, 0.25441307f, -0.04146851f, -0.15262087f, 0.00768119f, 
    0.57438618f, -0.21411438f, -0.68709910f, -0.34027964f, 0.10766984f, 0.07480556f, 0.10140857f, -0.00271385f, 
    0.39262533f, 0.03576927f, -0.00080718f, 0.53332490f, 0.13823467f, -0.06058369f, -0.14830083f, -0.22936715f, 
    0.14040396f, -0.04247688f, 0.04921404f, 0.41445065f, -0.06747486f, 0.32070935f, 0.05066787f, -0.02698692f, 
    0.09615631f, -0.10499580f, -0.29792428f, 0.31288135f, 0.02019879f, -0.03963444f, 0.16071491f, 0.26094082f, 
    0.23265125f, -0.00707115f, -0.60309869f, 0.11596282f, -0.07222558f, 0.03372661f, 0.16932641f, 0.19674622f, 
    0.07909084f, -0.15628521f, -0.03526799f, 0.26699185f, 0.48743415f, -0.60744262f, -0.04943440f, 0.18783425f, 
    0.50898373f, 0.09439377f, 0.08916806f, 0.05858891f, 0.41012001f, -0.19131401f, 0.15565544f, 0.41267923f, 
    0.10045522f, -0.10104860f, -0.15561694f, 0.04763708f, -0.69489157f, -0.15734886f, 0.07518204f, -0.09333444f, 
    -0.08907312f, -0.01825551f, 0.05544297f, 0.19794127f, -0.04302075f, 0.06618780f, 0.33340120f, -0.04033609f, 
    -0.44760805f, 0.31435677f, -0.12609883f, -0.07227508f, 0.28578424f, -0.03366924f, 0.21228202f, -0.07987344f, 
    0.26029283f, 0.02593578f, -0.15312734f, -0.09388680f, -0.68467456f, 0.28657678f, -0.06509368f, -0.02871008f, 
    0.08600998f, 0.09096464f, -0.13125962f, 0.03970677f, -0.17819622f, -0.13139650f, 0.09270547f, -0.13701262f, 
    -0.14336468f, -0.15877676f, 0.13188383f, 0.15021703f, 0.09777500f, -0.15342279f, -0.17502506f, 0.16593765f, 
    -0.00878239f, -0.17737290f, -0.02879270f, -0.04109716f, 0.00062747f, 0.09152365f, -0.16500467f, 0.11873486f, 
    0.15465544f, -0.15810424f, -0.02392232f, -0.07565890f, -0.01762491f, -0.08960736f, -0.10259051f, -0.12935439f, 
    0.23615283f, 0.01459059f, -0.01332208f, 0.01392068f, -0.17177109f, -0.05529690f, 0.15597439f, 0.06890920f, 
    0.37930194f, 0.21761021f, -0.16536972f, -0.01298286f, -0.14875053f, -0.14199199f, -0.08841573f, 0.04787718f, 
    0.07129040f, 0.15031055f, -0.15474890f, 0.09091913f, 0.40174937f, 0.09557220f, 0.11802439f, 0.39969987f, 
    0.05584743f, 0.13354911f, 0.11666206f, 0.35260597f, 0.01792677f, 0.19711223f, 0.18858846f, -0.18219073f, 
    0.02881221f, 0.15595247f, -0.03138316f, 0.54266942f, -0.01217851f, 0.20338029f, -0.07639138f, 0.31633699f, 
    0.00813635f, -0.17970243f, -0.55135053f, 0.12905291f, 0.09019546f, 0.01429855f, 0.28987634f, -0.07901934f, 
    0.12856998f, 0.14242907f, -0.00140265f, 0.32396257f, 0.11504353f, -0.73875409f, -0.02615204f, 0.41075814f, 
    -0.00491125f, -0.11860763f, -0.10684247f, 0.06255857f, 0.21850501f, -0.17332965f, 0.17254151f, 0.46723816f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.27933738f, 0.19949140f, -0.03716386f, 0.25288090f, 0.03672111f, 0.04191952f, 0.08718956f, 0.37129912f, 
    -0.03148578f, 0.20034532f, -0.18946491f, 0.44430104f, 0.03405204f, 0.11087943f, -0.19533935f, 0.19147664f, 
    0.20071544f, 0.40326422f, 0.10486394f, -0.01641868f, 0.08389598f, 0.00039635f, -0.07965586f, -0.14452203f, 
    -0.21774745f, 0.20296334f, 0.15297069f, 0.06079912f, 0.11488599f, 0.07190546f, 0.17933953f, 0.26216552f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.34071654f, -0.11898407f, 0.21924178f, -0.14130422f, -0.41751763f, 0.56384391f, -0.55487365f, 0.05992921f, 
    0.05620000f, -0.52176458f, -0.16956435f, -0.17746887f, -0.01503896f, -0.09485141f, 0.17018124f, 0.18452415f, 
    -0.56913173f, -0.12889455f, -0.01606720f, -0.21687838f, -0.30058441f, -0.29675296f, 0.01407116f, -0.18320915f, 
    -0.10286932f, 0.23621966f, -0.05914497f, 0.22309320f, 0.04502775f, 0.15362962f, -0.48685989f, 0.18890564f, 
    -0.06327859f, 0.02106936f, -1.00169075f, 0.02383477f, -0.06298769f, -0.39259031f, -0.55039132f, 0.22783913f, 
    -0.07965583f, 0.07869682f, -0.07446447f, -0.00996927f, -0.64657432f, -0.04556869f, -0.38189492f, 0.17593250f, 
    -0.40329599f, 0.19886993f, 0.13686982f, -0.25512350f, 0.02366913f, -0.13975279f, -0.02267112f, -0.23571825f, 
    -0.19627739f, 0.15425703f, 0.23520701f, 0.24044889f, 0.24061646f, -0.07900121f, 0.19267137f, 0.22672854f, 
    -0.06204111f, 0.26591602f, -0.24494234f, 0.49151847f, -0.08729838f, -0.34436154f, 0.24293430f, 0.11163280f, 
    -0.09501541f, 0.39346540f, -0.02617878f, 0.19348992f, 0.29242358f, 0.48861864f, -0.01228277f, -0.42034724f, 
    0.11979053f, 0.10680038f, 0.02339469f, -0.09744749f, 0.22046112f, -0.09553160f, -0.49799588f, -0.00253024f, 
    -0.13550608f, -0.42230135f, -0.12902863f, -0.74409091f, -0.09799309f, 0.09033090f, -0.06983389f, -0.37385288f, 
    0.35772848f, 0.14990966f, -0.03104921f, 0.07966650f, 0.39066038f, -0.05066539f, -0.11161327f, 0.13189122f, 
    -0.08532003f, -0.13518475f, -0.16199705f, -0.79523617f, 0.20094417f, 0.18696120f, 0.31434485f, 0.14915481f, 
    0.53809118f, -0.41725349f, 0.15506247f, -0.16998036f, -0.31997007f, -0.36923671f, -0.57039809f, 0.23434316f, 
    -0.06762038f, 0.16115484f, -0.22666341f, -0.06437869f, -0.60083741f, 0.10496744f, -0.25781858f, -0.01679167f, 
    -0.80598176f, -0.16967016f, 0.40007621f, 0.15485604f, -0.65739465f, -0.46904302f, 0.12409730f, 0.24036372f, 
    -0.22946650f, -0.26242536f, 0.05951327f, -0.16992508f, 0.36037371f, 0.15224336f, 0.06658063f, 0.16034007f, 
    -0.64992392f, -0.43200538f, -0.08630101f, -0.06755076f, -0.15409814f, 0.16023524f, -0.16914825f, -0.09830023f, 
    -0.22746158f, 0.27701992f, -0.17409126f, -0.04891075f, 0.20070262f, 0.12451982f, 0.10526109f, 0.01539953f, 
    -0.22731407f, 0.17861630f, -0.03660238f, 0.01020259f, -0.08458421f, 0.12571877f, 0.00348920f, 0.24750228f, 
    -0.09713696f, 0.34142122f, 0.05490686f, -0.53057247f, 0.12267600f, -0.24381842f, 0.17127188f, -0.13742663f, 
    -0.29065266f, -0.10609996f, 0.14335300f, -0.07950591f, 0.15681961f, 0.24330783f, 0.03665826f, -0.20204228f, 
    0.38962224f, 0.08005986f, 0.11747594f, -0.01744161f, 0.17126416f, 0.16263202f, -0.34834579f, 0.08412112f, 
    -0.37318236f, 0.08582964f, -0.61593497f, -0.72919518f, 0.02558362f, -0.03366065f, 0.37763542f, -0.91113973f, 
    -0.14991891f, -0.19968863f, 0.12224918f, 0.38673711f, -0.24362434f, 0.25536621f, -0.18364413f, -0.61087573f, 
    0.48646438f, 0.16488321f, -0.77137256f, 0.27077842f, -0.08420822f, -0.13909486f, 0.14482096f, 0.17434593f, 
    -0.24314295f, -0.83407587f, -0.24423066f, -0.91678828f, 0.06491525f, 0.07741099f, 0.02726029f, -0.59308785f, 
    -0.46406639f, -0.64089298f, -0.07139508f, -0.49518299f, 0.10905681f, -0.56455135f, -0.46880776f, -0.09893539f, 
    -0.18557115f, -0.22317283f, -0.03619983f, -0.22359197f, 0.41132936f, -0.05252997f, -0.18473363f, 0.25684869f, 
    0.02191927f, -0.27767038f, -0.32319134f, 0.14786294f, -0.36424288f, -0.37921149f, 0.22742793f, 0.25562865f, 
    -0.41276005f, -0.30329055f, -0.01382531f, 0.48115045f, -0.05824617f, 0.15439664f, 0.02669326f, 0.25294974f, 
    -0.25860059f, 0.12929776f, -0.09702143f, -0.75741059f, 0.34035164f, -0.06768921f, -0.46936432f, 0.19212110f, 
    -0.06623036f, 0.23524247f, 0.02147420f, 0.12794617f, -0.98714137f, -0.14826009f, -0.07731037f, -0.56607187f, 
    0.07505328f, 0.23871948f, -0.12539057f, -0.24052463f, 0.24193861f, 0.25993553f, -0.14804193f, -0.28849319f, 
    0.16468847f, -0.90072066f, 0.38081250f, 0.06108731f, -0.34229600f, 0.10689836f, 0.15717161f, 0.16064256f, 
    -0.64449793f, 0.27290037f, 0.00925382f, 0.05677326f, 0.08204190f, -0.09790447f, 0.38357487f, 0.03529687f, 
    -0.08579537f, -0.31027600f, 0.12186670f, 0.14697695f, -0.07615983f, -0.19519089f, 0.29112437f, -0.14534990f, 
    0.07705721f, 0.09608240f, -0.38101655f, 0.16096193f, -0.56550288f, 0.18147841f, -0.03753993f, 0.03603300f, 
    -0.48353857f, 0.16666867f, -0.58285439f, -0.30234143f, -0.10317725f, -0.01915032f, -0.00430509f, 0.13015561f, 
    -0.37763873f, -0.50489134f, -0.61572713f, -0.53406715f, -0.25874096f, -0.44772372f, -0.25816551f, -0.20429736f, 
    -0.18904378f, 0.20183565f, -0.02943197f, -0.70506448f, 0.00028709f, -0.14009099f, 0.21706040f, 0.44229963f, 
    -0.11441712f, 0.38903967f, 0.41263402f, -0.40558782f, 0.22783767f, 0.20596334f, -0.55158508f, 0.36029103f, 
    -0.10485534f, -0.13395807f, 0.34221193f, 0.01324185f, -0.81146157f, -0.14921324f, 0.24844846f, -0.24109261f, 
    -0.49987301f, -0.26006547f, -0.05125388f, -0.22215992f, 0.19681947f, -0.09467933f, 0.17154258f, -0.42067835f, 
    0.00217273f, -0.27940562f, -0.15998626f, -0.07719905f, 0.34294701f, -0.32125407f, -0.33166441f, 0.08886266f, 
    -0.10554252f, 0.00491278f, 0.41412157f, 0.04984605f, 0.41793212f, -0.12791631f, 0.01133990f, 0.02151773f, 
    0.48192540f, -0.11109798f, -0.08709150f, -0.56881344f, 0.07598117f, -0.05176548f, 0.14016993f, -0.48574847f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09338747f, 0.19499780f, 0.07676792f, 0.10674225f, 0.12972391f, -0.11606368f, 0.07590118f, 0.03759172f, 
    -0.15277392f, 0.13357046f, 0.24577692f, -0.00014918f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
