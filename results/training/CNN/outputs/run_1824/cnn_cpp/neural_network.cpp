#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.67838198f, -0.00687223f, -0.19257922f, -0.23996721f, 0.09591950f, -0.11787327f, 0.40733230f, -0.44850776f, 
    -0.44339132f, 0.20912528f, -0.02100488f, 0.27042544f, -0.32086611f, -0.19571862f, 0.10988620f, 0.25137201f, 
    0.29973319f, 0.07656488f, -0.08097903f, -0.25226167f, -0.38172740f, 0.08337501f, 0.18518336f, 0.00586236f, 
    0.00144694f, 0.47957411f, 0.14080194f, -0.27602839f, -0.10142383f, 0.19453138f, 0.10826474f, 0.22487383f, 
    -0.05450706f, -0.29826793f, 0.32927763f, 0.00854408f, 0.16255733f, -0.20997217f, -0.07801334f, 0.30426237f, 
    -0.02378383f, -0.24476993f, 0.26591247f, -0.23259300f, -0.08138065f, -0.26587087f, 0.03777692f, 0.27748340f, 
    -0.21727623f, 0.12100800f, -0.43769827f, 0.68981934f, 0.48288089f, -0.52613348f, -0.12247437f, -0.54267895f, 
    -0.43190590f, 0.05263393f, 0.27026898f, 0.29150590f, -0.45024988f, -0.10299499f, -0.40718618f, 0.16832332f, 
    -0.03530692f, 0.52159232f, 0.32273194f, -0.03577431f, -0.38721201f, -0.08724165f, 0.04618836f, -0.14049287f, 
    -0.28897053f, -0.12143008f, -0.26299632f, -0.41403574f, -0.62081844f, -1.06733334f, 0.19334200f, 0.88029569f, 
    0.06611242f, 0.62373334f, 0.40498134f, 0.17516881f, -0.47563526f, -0.21036153f, 0.23993522f, -0.27607501f, 
    -0.31099352f, -0.12083915f, -0.06138460f, 0.19368774f, 0.06877704f, 0.00980559f, 0.24575976f, 0.13613799f, 
    -0.22989021f, -0.02874174f, 0.25520444f, 0.02532074f, 0.25497931f, -0.46352068f, -0.19238818f, 0.27364904f, 
    0.35988048f, -0.38511127f, 0.06321424f, -0.32371399f, -0.00273191f, -0.04737584f, -0.05591513f, 0.03050247f, 
    0.07638478f, -0.03665983f, -0.22716823f, -0.09699192f, 0.03675446f, -0.00727115f, 0.28778434f, -0.09483680f, 
    0.12488826f, -0.22873436f, -0.10056843f, 0.22863580f, 0.37908348f, 0.49713096f, 0.57604700f, -0.66529429f, 
    -0.74344766f, -0.09437648f, 0.11391795f, 0.52135032f, 0.33764121f, -0.69955945f, 0.24867550f, -0.28532743f, 
    -0.15833965f, -0.13029651f, 0.18179297f, -0.04103423f, -0.07482550f, -0.30844662f, 0.28956428f, 0.17346513f, 
    -0.08475088f, 0.25646389f, -0.19430593f, -0.17461483f, 0.10303754f, -0.12453368f, -0.08427799f, -0.72522354f, 
    -0.21339336f, -0.20558210f, -0.71405452f, 0.45235670f, -0.01930566f, -0.18878497f, -0.28253990f, 0.07305821f, 
    -0.12423341f, -0.09332690f, -0.19905841f, 0.28344065f, 0.03175369f, 0.14933622f, -0.04959067f, 0.04819774f, 
    -0.11540142f, -0.28030762f, -0.40621239f, -0.11711512f, 0.12641607f, -0.22752357f, -0.16275597f, 0.36660275f, 
    -0.56969839f, -0.22735152f, -0.08877856f, 0.39284351f, -0.14162634f, 0.13122557f, -0.20007806f, -0.04018844f, 
    0.31124198f, 0.02006126f, -0.11247256f, -0.07021829f, 0.05208120f, 0.06875572f, -0.22547008f, -0.05497234f, 
    -0.17819011f, 0.06678731f, -0.37045333f, 0.37729770f, -0.06146888f, 0.00736634f, 0.38562670f, 0.40227899f, 
    -0.18666486f, 0.44413647f, 0.20305824f, 0.22853640f, 0.17253807f, -0.08918241f, 0.17264123f, -0.04435217f, 
    -0.07426988f, 0.22108318f, 0.16209477f, -0.01579298f, 0.08566875f, -0.38628432f, -0.13055515f, 0.26856977f, 
    0.07612894f, -0.04173740f, -0.02554187f, -0.29909196f, 0.23262325f, -0.19341180f, -0.16366710f, -0.17336397f, 
    -0.24507053f, -0.65449125f, 0.03797236f, -0.31339055f, -0.55769342f, -0.22753491f, 0.42352822f, -0.02652322f, 
    -0.13419324f, -0.13072702f, -0.17196254f, -0.20437856f, -0.09639285f, -0.25743738f, -0.21966678f, 0.04846390f, 
    -0.04759968f, -0.42839161f, -0.19629496f, 0.02200876f, -0.14294662f, -0.06983817f, 0.19389418f, -0.04809400f, 
    0.06498633f, 0.11965141f, 0.22645710f, -0.09477220f, -0.16762166f, -0.17956118f, 0.18631126f, 0.34929624f, 
    -0.03778825f, 0.06521814f, -0.18031359f, -0.00152594f, -0.20271820f, 0.34916836f, -0.19846304f, -0.08948737f, 
    0.24289037f, 0.30441707f, -0.08288928f, -0.19809645f, -0.21000166f, -0.30949134f, -0.14834808f, 0.27122793f, 
    0.14796023f, 0.02566577f, 0.33687830f, 0.45251375f, 0.04720298f, 0.17491406f, 0.12217289f, 0.18985978f, 
    0.15423001f, 0.23106007f, -0.21019752f, 0.04897200f, 0.03336949f, -0.01310670f, 0.46042839f, 0.03777705f, 
    -0.20820665f, -0.23226486f, -0.16022684f, 0.07326006f, 0.12144992f, 0.05038891f, -0.07372311f, 0.04800818f, 
    0.21055774f, 0.18421303f, -0.02336791f, -0.21941236f, -0.64258921f, -0.16729029f, -0.28160384f, 0.20388071f, 
    -0.24015890f, 0.34188706f, -0.23095503f, 0.16907109f, 0.22673248f, 0.06044744f, 0.27405754f, 0.05402036f, 
    0.25707603f, -0.21814358f, -0.21909533f, -0.12806134f, -0.11857983f, -0.23675416f, -0.32009530f, 0.14011574f, 
    0.00230005f, 0.22190759f, 0.53246647f, 0.07583442f, -0.37030682f, -0.91243166f, -0.18256259f, -0.28576884f, 
    -0.43244773f, -0.45227689f, 0.16625649f, 0.00396482f, 0.18771720f, 0.47958404f, 0.72929823f, -0.13545655f, 
    0.17830405f, 0.19908990f, 0.12758283f, -0.25378299f, -0.18773028f, 0.15750098f, -0.18939373f, 0.18163297f, 
    0.16117892f, -0.20449102f, -0.07410880f, 0.08830502f, -0.26120159f, -0.30530363f, 0.60460490f, -0.56034285f, 
    -0.50188822f, 0.20986190f, 0.24870975f, -0.16076013f, 0.33915424f, -0.45738280f, -0.24815091f, -0.07404263f, 
    0.33440742f, 0.13094260f, 0.13028772f, -0.22805139f, 0.33804440f, -0.12528211f, 0.01698304f, 0.27382439f, 
    -0.04802005f, -0.26484516f, -0.26314312f, 0.21877971f, 0.02195286f, -0.09204736f, 0.14577372f, 0.10394806f, 
    -0.49134195f, -0.61278623f, -0.37511548f, -0.33610880f, 0.40918934f, 0.49977633f, 0.44672456f, 0.10876560f, 
    -0.23300619f, -0.06574485f, 0.19851184f, -0.09426802f, -0.04588039f, 0.30740115f, 0.14719896f, -0.26898825f, 
    -0.30970776f, -0.41773319f, -0.45228037f, 0.16396555f, -0.10196888f, 0.27092075f, 0.12338421f, 0.16012593f, 
    0.85275018f, -0.33302307f, 0.16931176f, -0.77388030f, -0.71491957f, 0.36410603f, 0.07246689f, 0.02531981f, 
    -0.06475380f, 0.46883312f, 0.09916455f, 0.22420357f, -0.30315179f, -0.06244824f, 0.25295234f, -0.01553444f, 
    -0.02351268f, -0.02469748f, -0.32883981f, 0.15881541f, 0.25361174f, -0.14042369f, -0.20106043f, 0.14072363f, 
    0.05718154f, -0.11231298f, -0.23348683f, -0.37984109f, -0.13161020f, 0.10822691f, 0.15526879f, 0.25695744f, 
    -0.19818754f, 0.27984720f, 0.06495887f, -0.09164246f, 0.36183992f, -0.30338648f, 0.26740566f, -0.24014449f, 
    -0.14713068f, 0.06446876f, -0.38894168f, 0.13660580f, 0.39891902f, 0.22655621f, 0.07121818f, 0.06019381f, 
    0.35084423f, -0.01815249f, -0.06313224f, 0.49294597f, -0.45236298f, 0.51554787f, -0.25567448f, -0.42348489f, 
    -0.57390326f, -0.26190138f, 0.43615201f, 0.61122406f, 0.12018517f, -0.16653571f, -0.07442594f, -0.21684399f, 
    0.41609836f, -0.20188783f, 0.12239197f, -0.04368503f, 0.28667876f, 0.11927927f, -0.20703189f, -0.23749724f, 
    -0.25473586f, -0.05155414f, -0.35450676f, 0.09485166f, -0.18378000f, -0.29335865f, -0.36939937f, -0.35079640f, 
    -0.41875586f, -0.32141134f, -0.50054979f, 0.06010271f, -0.38211647f, 0.26092198f, 0.07685354f, 0.45857540f, 
    -0.24860701f, 0.07989050f, 0.06234933f, 0.17242362f, 0.16956082f, 0.07989044f, 0.06565075f, 0.01996613f, 
    0.07243671f, 0.27235538f, -0.07133677f, -0.09104281f, -0.12716629f, -0.10420281f, -0.26058131f, -0.24551691f, 
    -0.46083465f, -0.22796901f, -0.31040424f, -0.38837525f, -0.00155961f, -0.44868165f, -0.19733648f, -0.08203614f, 
    0.09139600f, 0.24020918f, -0.18221042f, 0.18106742f, -0.10988665f, 0.20290044f, -0.10463070f, -0.10595403f, 
    0.10223624f, 0.42036074f, 0.08032190f, 0.07018381f, 0.21570089f, 0.48619270f, 0.48976460f, 0.06333210f, 
    0.06574386f, -0.47682896f, -0.32546195f, -0.34824839f, -0.07182522f, 0.44072270f, -0.18523118f, 0.10028253f, 
    -0.48666051f, -0.09668657f, 0.40159652f, -0.28004131f, 0.01736325f, 0.30143356f, 0.28425485f, 0.03254667f, 
    -0.35872415f, -0.09456828f, 0.08725269f, -0.20837495f, 0.08091288f, -0.20950539f, 0.04688174f, 0.48474824f, 
    -0.43473428f, 0.13803087f, -0.25664487f, -0.46426502f, -0.18080868f, 0.59401172f, -0.00165592f, -0.11777779f, 
    -0.41997898f, -0.18690220f, 0.84198731f, -0.29130089f, -0.32490149f, 0.20181218f, 0.15899788f, 0.13811733f, 
    -0.04885167f, -0.26466456f, -0.03389347f, -0.17611583f, -0.08251068f, 0.09498774f, -0.19645643f, 0.21319216f, 
    0.42941099f, 0.48139644f, 0.63581645f, 0.15421021f, -0.37652412f, -0.21159810f, -0.40624338f, -0.60652053f, 
    -0.52220696f, -0.16268882f, 0.21218596f, 0.04238238f, -0.19583094f, -0.04694985f, 0.06167240f, -0.10351415f, 
    0.07969107f, -0.16652602f, 0.34430909f, -0.13876536f, -0.21770640f, 0.11201183f, 0.04276221f, 0.19755374f, 
    0.72254950f, 0.51311624f, -0.16764042f, 0.22061361f, -0.56548816f, 0.29213807f, -0.31444886f, -0.10319348f, 
    -0.32897791f, -0.27914423f, 0.19671787f, 0.05207074f, 0.00243784f, 0.11358438f, -0.11408614f, -0.21335936f, 
    0.21108298f, -0.22110768f, 0.25793186f, -0.03643110f, 0.39351931f, -0.22143848f, -0.16821259f, -0.24517410f, 
    -0.22243555f, -0.16633125f, 0.22677386f, 0.20724194f, -0.19326623f, 0.27154753f, 0.08773725f, -0.23328048f, 
    -0.09641056f, -0.12283370f, -0.26375833f, 0.05179206f, -0.01928730f, 0.04013747f, 0.13217682f, 0.29734170f, 
    0.18653584f, -0.30405188f, -0.14994562f, 0.00318570f, -0.04205332f, -0.12582123f, 0.29416984f, 0.19280575f, 
    0.04331483f, 0.32418078f, -1.09003794f, -0.75401473f, 0.01629951f, 0.81169289f, 0.19649979f, 0.02916974f, 
    0.34565049f, 0.07433676f, -0.11970422f, 0.01108035f, -0.23291869f, -0.45332333f, 0.04999343f, 0.44851539f, 
    -0.21502888f, 0.05637267f, 0.22991079f, -0.20138873f, -0.04584173f, -0.11856131f, -0.06189547f, -0.15950295f, 
    0.06559394f, 0.01431486f, -0.35693836f, -0.86984015f, -0.67826980f, -0.29750672f, 0.19467039f, 0.49769044f, 
    0.39252374f, 0.21566810f, -0.17836782f, 0.38695347f, 0.56469923f, 0.41652340f, 0.04131176f, 0.05209540f, 
    -0.19385608f, -0.20696670f, -0.18551904f, -0.14575242f, 0.20417145f, -0.04020549f, -0.22424634f, -0.15019611f, 
    0.06345358f, 0.28172261f, -0.11434013f, 0.22706482f, 0.31684014f, 0.42133853f, 0.01801239f, 0.49722090f, 
    -0.07199709f, -0.59492445f, -0.71512228f, -0.32241532f, 0.26016024f, 0.35727710f, 0.34582016f, -0.21547258f, 
    -0.34729502f, -0.16599745f, 0.19371834f, -0.08570622f, 0.24261703f, -0.00970649f, 0.05309910f, -0.19248867f, 
    0.04566339f, -0.00338808f, -0.27185914f, 0.28985310f, -0.12482736f, -0.00091371f, 0.40800548f, 0.06727275f, 
    0.10732378f, 0.28768414f, 0.28959370f, 0.22221169f, -0.22582187f, -0.12223882f, -0.08622652f, 0.20589556f, 
    0.07404290f, 0.10887929f, -0.34678105f, -0.18599518f, 0.03418015f, 0.02770648f, -0.05397481f, -0.15373334f, 
    0.12063338f, 0.31612879f, -0.10349598f, 0.00617698f, 0.04322443f, -0.18761638f, -0.27437890f, -0.15327553f, 
    0.09737730f, 0.22501157f, 0.26341027f, -0.15606521f, 0.36084417f, 0.01667010f, 0.26435918f, -0.11661105f, 
    -0.44729674f, -0.10096218f, -0.07873843f, 0.17909272f, 0.17469786f, -0.22571163f, -0.32674330f, 0.09149990f, 
    0.41527233f, 0.08254687f, -0.37232873f, -0.28376672f, 0.33044305f, 0.04208932f, 0.01337998f, -1.09357798f, 
    0.46105200f, -0.19387434f, -0.71024871f, 0.44589931f, 0.28237543f, -0.10398243f, 0.01462193f, 0.47308266f, 
    0.25198564f, -0.17922536f, -0.02488750f, -0.05317264f, -0.14100596f, 0.13031782f, 0.45091775f, 0.11541139f, 
    -0.26006454f, -0.04266331f, -0.11429571f, -0.01146626f, 0.28045940f, -0.08612146f, -0.15886429f, -0.48090211f, 
    0.31315830f, 0.26218125f, 0.16225734f, -0.06326435f, 0.34575632f, -0.00445965f, -0.46503621f, -0.20098692f, 
    0.08276408f, -0.34525734f, -0.26795542f, -0.23064150f, -0.13298267f, 0.34358773f, 0.38259280f, 0.33972016f, 
    -0.02708348f, -0.30574739f, 0.04517446f, -0.15628034f, 0.04176342f, -0.01549310f, -0.13207659f, 0.01961438f, 
    -0.34396580f, -0.44547781f, 0.07159761f, -0.18258618f, -0.50044185f, -0.38010201f, -0.36484873f, -0.03409194f, 
    -0.06909040f, 0.03228636f, 0.17978483f, -0.17403536f, -0.08859402f, -0.37381297f, -0.40763760f, 0.21956339f, 
    0.03497120f, 0.12667415f, 0.27518722f, -0.06472649f, 0.05816122f, -0.09802193f, -0.12391099f, -0.30037004f, 
    -0.27045777f, -0.16474763f, -0.57900310f, -0.27449027f, -0.24453203f, 0.50925738f, 0.47584566f, -0.42067122f, 
    0.21613367f, -0.38083744f, 0.00396267f, 0.15886903f, 0.03429207f, -0.22791533f, -0.08121481f, 0.48246661f, 
    -0.23335281f, -0.02980623f, 0.12855248f, -0.00519506f, -0.28232649f, -0.27459127f, -0.21778132f, 0.22410600f, 
    0.29139259f, 0.32945967f, 0.11067341f, -0.87612468f, -0.27220201f, -0.36604056f, 0.21322682f, 0.31499121f, 
    0.35641736f, 0.18121551f, 0.26845586f, 0.28355989f, 0.41372061f, 0.28752539f, -0.03168867f, 0.21765237f, 
    -0.20003504f, -0.13661759f, -0.12781060f, 0.02888815f, 0.18581201f, -0.16511345f, 0.03026525f, 0.09257261f, 
    -0.18391928f, -0.03836441f, -0.13203730f, 0.31834447f, 0.63913488f, 0.36793602f, 0.03942582f, -0.53148729f, 
    -0.86028516f, -0.01593310f, -0.22546817f, 0.14863802f, 0.39490125f, 0.00994605f, -0.07012077f, 0.08016009f, 
    0.10107560f, 0.45602992f, -0.57798409f, -0.27983302f, 0.09146276f, -0.30615759f, 0.11397127f, 0.24897189f, 
    0.08572429f, 0.03637885f, 0.03522885f, 0.09455468f, 0.12412877f, 0.44139493f, 0.10670392f, 0.27880383f, 
    -0.37521482f, 0.14084144f, -0.40106177f, -0.05405926f, 0.11910628f, -0.04150639f, 0.11823558f, -0.22219373f, 
    0.69012481f, -0.22581103f, -0.42121807f, 0.02640245f, 0.14714198f, -0.00396651f, -0.12631589f, -0.17316855f, 
    0.12675211f, -0.12381079f, 0.01708053f, 0.07373863f, -0.02117900f, -0.01736864f, 0.22645533f, 0.04814086f, 
    -0.12674089f, -0.18864463f, -0.37512454f, -0.52518719f, -0.40114757f, -0.43322942f, -0.31675589f, -0.35279673f, 
    0.04381021f, -0.12933192f, -0.08467301f, 0.16090474f, 0.02670785f, -0.08842548f, 0.25562453f, -0.23875649f, 
    -0.16095659f, -0.15914528f, -0.12892283f, -0.08353293f, -0.20811349f, -0.19711962f, -0.36270973f, 0.68001211f, 
    0.52831388f, 0.66341287f, -0.53970873f, -0.57219076f, 0.11403583f, -0.08524638f, -0.17112538f, -0.06214913f, 
    -0.57084852f, 0.02955665f, -0.10066924f, 0.40544796f, -0.20432959f, 0.33238766f, -0.00225619f, -0.20239425f, 
    -0.02500719f, 0.30536544f, -0.30798045f, -0.11639433f, -0.15577500f, -0.06601111f, 0.08509359f, 0.21291727f, 
    -0.24350649f, -0.13852669f, 0.01163547f, 0.27690509f, -0.17883791f, -0.18350115f, 0.04513576f, -0.55608517f, 
    -0.48159948f, -0.27597246f, 0.04451254f, -0.20660286f, -0.12875877f, -0.05478904f, -0.06265894f, 0.26504245f, 
    -0.18626359f, -0.25240049f, 0.02196655f, -0.30778015f, -0.08739562f, -0.18889546f, -0.18951833f, -0.26597115f, 
    -0.03091395f, 0.17086951f, -0.43750405f, -0.64118701f, -0.36538282f, -0.72300678f, 0.81448627f, -0.17291510f, 
    0.16565597f, 0.30340198f, 0.01901598f, -0.09542884f, 0.37116671f, -0.02129005f, -0.11913517f, 0.20059219f, 
    -0.22173730f, -0.04266801f, 0.01421726f, -0.08268047f, 0.01867841f, 0.24231236f, -0.27967942f, -0.22005615f, 
    0.02768461f, 0.20807074f, 0.48184064f, 0.40353605f, 0.22791825f, 0.17806995f, 0.23928556f, -0.03157169f, 
    0.11264277f, 0.14416933f, 0.00035913f, -0.05637188f, 0.26515877f, -0.20579277f, 0.00078806f, 0.22945066f, 
    0.06698705f, 0.16528425f, -0.14958756f, -0.00077610f, 0.05987661f, 0.04138585f, 0.05937575f, 0.06731663f, 
    -0.13655065f, 0.23108508f, -0.11106315f, 0.66116196f, -0.04074283f, -0.39556247f, -0.38873231f, -0.46333441f, 
    0.21580164f, 0.37476674f, 0.56901610f, -0.44331634f, -0.03375424f, -0.26664054f, 0.46959740f, -0.23885775f, 
    -0.20416243f, -0.20713700f, 0.17452383f, 0.12017105f, -0.14892395f, 0.03328011f, -0.12489676f, 0.27819932f, 
    -0.23930290f, -0.30699635f, -0.02641932f, 0.16047904f, -0.58356893f, -0.40404475f, -0.41291654f, -0.45449901f, 
    0.07688981f, -0.13462985f, -0.25046059f, -0.28522217f, -0.31849277f, -0.06001278f, 0.38997677f, 0.13664983f, 
    0.11288421f, -0.02435241f, -0.23734605f, -0.24969590f, 0.17968565f, -0.24744423f, -0.19147214f, -0.32559589f, 
    -0.36563715f, -0.26323968f, -0.02769107f, -0.22618806f, -0.27400807f, 0.53890449f, 0.74845117f, 0.41581047f, 
    -0.56790715f, -0.65404272f, 0.14350291f, -0.17890824f, -0.08256967f, -0.13285522f, -0.07023595f, 0.32891029f, 
    -0.35268405f, 0.16295390f, -0.10668591f, -0.11101262f, 0.25286528f, 0.08200435f, -0.39014935f, 0.32364595f, 
    -0.09741515f, -0.42729121f, 0.11160374f, 0.03935942f, 0.02744983f, 0.20569701f, -0.48189497f, -0.62790167f, 
    -0.23883817f, -0.40033498f, 0.27608156f, 0.65566468f, -0.46847278f, -0.45306903f, 0.49349570f, 0.05508867f, 
    -0.30553237f, -0.02730466f, 0.01832532f, -0.10728121f, -0.30522045f, 0.03901851f, 0.20308450f, 0.12989937f, 
    0.01983588f, 0.31481099f, 0.04585417f, 0.10477867f, -0.05316126f, -0.06669623f, 0.07728726f, -0.45978931f, 
    0.05112537f, 0.69433230f, 0.49247885f, -0.35936952f, -0.50266206f, -0.58124340f, -0.04659958f, 0.13810025f, 
    -0.22732016f, 0.57717460f, -0.20427524f, -0.07783345f, -0.07404034f, -0.17476760f, -0.15911399f, 0.01631919f, 
    -0.07837951f, -0.32640278f, -0.43634531f, -0.08430323f, -0.22660868f, 0.18427080f, -0.09084465f, -0.02512612f, 
    -0.90334815f, -0.29384384f, 0.50532228f, 0.54672408f, -0.00977520f, -0.09713983f, -0.68109298f, 0.33684185f, 
    -0.12521222f, -0.04064123f, 0.14017823f, 0.04693983f, -0.33767089f, -0.18635133f, 0.61792743f, -0.23152083f, 
    0.02873580f, -0.32485226f, 0.03152842f, 0.44604176f, -0.04448608f, 0.03355532f, 0.06257180f, -0.00013811f, 
    0.08736138f, 0.46682587f, -1.30720055f, -0.15539986f, 0.17239740f, 0.29625914f, 0.24524815f, 0.55482918f, 
    0.20323628f, 0.01839898f, 0.09248235f, -0.21123186f, -0.46736875f, -0.18413779f, -0.43829641f, -0.03605203f, 
    0.32247892f, 0.02371967f, -0.05485988f, 0.01978973f, 0.00979576f, -0.21991652f, -0.03340116f, -0.05085729f, 
    0.00996081f, -0.30894840f, -0.99378031f, 0.41006520f, -0.41063434f, -0.31842268f, 0.46125591f, 0.04027806f, 
    0.07954194f, 0.80768973f, -0.59966856f, -0.21717243f, -0.03570792f, -0.10262631f, -0.06744941f, -0.21594979f, 
    -0.08447669f, 0.45221516f, 0.07887392f, 0.07087839f, 0.10663201f, -0.04019623f, 0.13442054f, -0.00200354f, 
    -0.02416365f, -0.13199666f, -0.08491545f, -0.73350900f, -0.24921940f, -0.33727580f, -0.36157215f, -0.56727850f, 
    0.11931594f, 0.41801348f, -0.00486423f, -0.32746750f, 0.06980620f, -0.01188473f, -0.11026587f, -0.31527385f, 
    -0.38245216f, -0.07734254f, 0.00298015f, 0.34337306f, -0.36173481f, -0.16136937f, 0.07036136f, 0.02890777f, 
    -0.01894260f, -0.23917353f, 0.17824903f, -0.17498961f, -0.34817007f, -0.35271975f, -0.31040972f, -0.33377373f, 
    -0.07472812f, -0.27739832f, -0.39839518f, -0.35613459f, -0.22306387f, -0.21863234f, 0.17138310f, 0.47393563f, 
    0.50338703f, 0.37401110f, 0.50923324f, -0.23128328f, -0.17817219f, -0.28731120f, -0.09055478f, -0.02857124f, 
    0.28985414f, 0.03931707f, 0.09745274f, 0.04227579f, 0.04880645f, 0.48723277f, 0.23470622f, -0.40423840f, 
    0.25817096f, -0.34821209f, -0.47903427f, -0.28687268f, -0.10827564f, -0.29170412f, -0.56434584f, 0.57763088f, 
    0.13054340f, 0.24259217f, 0.12978253f, 0.00001865f, -0.07040615f, -0.04244786f, -0.30218449f, 0.09025839f, 
    -0.22378811f, -0.22763291f, 0.03942669f, 0.06230565f, 0.11876950f, -0.20841506f, 0.23902880f, -0.00787799f, 
    -0.23076794f, -0.00484684f, 0.10975972f, -0.19667326f, -0.24168816f, 0.26268074f, -0.27793232f, -0.41708758f, 
    0.06981469f, 0.33280629f, -0.30774897f, 0.11146034f, 0.16048317f, 0.03156141f, 0.15981732f, 0.22054198f, 
    -0.06386237f, -0.15604812f, -0.26020336f, -0.25786000f, -0.05820039f, 0.34095612f, 0.01706371f, 0.02914755f, 
    0.25941357f, 0.02412481f, 0.02188787f, 0.28254360f, 0.25734785f, 0.19226012f, -0.02890212f, 0.18195537f, 
    0.20153205f, -0.25169137f, 0.19928543f, 0.21386364f, 0.02500356f, 0.10949135f, -0.08195689f, -0.12374583f, 
    -0.20597757f, 0.16459578f, -0.27995425f, -0.01547344f, 0.03522381f, 0.17930491f, -0.28062668f, -0.16460457f, 
    0.72869629f, 0.24875332f, -0.49482882f, -0.57600236f, -0.83083141f, 0.56844705f, 0.02830479f, 0.08418049f, 
    0.16427341f, 0.38731083f, -0.10853356f, -0.17699006f, -0.25621745f, 0.05106064f, 0.04233633f, 0.21160027f, 
    -0.24886371f, 0.34220722f, 0.06574500f, -0.29307196f, -0.05441727f, 0.26258355f, 0.07403804f, -0.19561620f, 
    0.18731289f, 0.26005080f, 0.16585149f, -0.21656497f, -0.25480995f, 0.13408582f, 0.23912278f, 0.21080281f, 
    -0.09920771f, 0.22412370f, -0.54102850f, -0.44793373f, 0.64313716f, 0.00312505f, -0.39049926f, 0.16934577f, 
    -0.53066170f, 0.36200282f, 0.26859200f, -0.15038505f, 0.08619489f, 0.12751974f, -0.03912441f, -0.03774024f, 
    -0.19613276f, 0.19975120f, -0.39976385f, -0.49414185f, -0.27111194f, -0.21001875f, 0.20214361f, -0.28082564f, 
    -0.43157676f, 0.05618000f, -0.17291410f, -0.19697995f, -0.12124546f, -0.08175438f, -0.09231282f, -0.03768180f, 
    -0.09648900f, -0.08961999f, -0.13923782f, -0.21089326f, 0.09737269f, -0.10143864f, -0.17787896f, 0.22622840f, 
    -0.20160732f, -0.35914555f, 0.36175823f, 0.56125420f, 0.05679908f, 0.07361443f, -0.06740721f, -0.27990678f, 
    0.00163184f, -0.19310069f, 0.02391561f, 0.24310574f, -0.17108268f, 0.13686961f, -0.27422160f, -0.06743357f, 
    0.10122629f, -0.24528295f, 0.12660037f, -0.06350316f, -0.25980189f, 0.09891288f, -0.32366848f, -0.29947400f, 
    0.05451311f, -0.32633621f, -0.30605638f, -0.53592765f, 0.74874353f, 0.27363753f, -0.08832577f, -0.46703073f, 
    -0.65273160f, 0.05000663f, 0.19330320f, 0.25004587f, 0.05080114f, -0.38698971f, -0.33177045f, 0.03273553f, 
    -0.26517779f, 0.02246010f, 0.13017376f, 0.27574044f, 0.04491004f, 0.32830459f, 0.13410944f, -0.42078838f, 
    -0.19551949f, -0.05419454f, -0.32191968f, -0.10234222f, 0.45703793f, 0.18595421f, 0.83212447f, 0.81824571f, 
    -0.76578838f, -0.49557146f, -1.00177431f, 0.24928106f, -0.18048851f, -0.00893124f, 0.18597877f, 0.15551931f, 
    0.02570303f, 0.31249937f, -0.08131503f, 0.06556509f, -0.03354223f, -0.26076141f, 0.00716273f, -0.16024087f, 
    -0.08887639f, -0.04061291f, 0.05381135f, 0.06343774f, -0.17328122f, -0.06484385f, -0.40018597f, -0.07579260f, 
    0.30272606f, -0.08002301f, -0.29956278f, -0.19686820f, -0.00630751f, 0.26250094f, -0.06246521f, 0.29768652f, 
    -0.49042761f, -0.12356707f, 0.43244237f, -0.06983453f, 0.12940507f, 0.05726289f, 0.09890848f, -0.27450225f, 
    -0.35921168f, -0.38603362f, -0.17186739f, 0.36028463f, 0.30853280f, -0.12805645f, 0.16482827f, 0.38460684f, 
    -0.56839114f, -0.35405093f, -0.56651360f, -0.63950884f, 0.35404301f, 0.59867549f, 0.14637515f, -0.33526471f, 
    0.04894072f, 0.04620228f, -0.14327228f, -0.09447012f, 0.09482358f, 0.12918760f, -0.01363580f, 0.30198312f, 
    0.10402373f, -0.33606687f, -0.04091718f, -0.40207732f, -0.22726190f, 0.12918665f, -0.15000640f, -0.38493699f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07877646f, 0.04937382f, 0.04872979f, -0.03949255f, 0.12960394f, -0.02485015f, -0.02527904f, -0.15089791f, 
    -0.00713274f, 0.06662550f, -0.12771703f, -0.20877706f, -0.13131422f, -0.00750746f, -0.27071136f, -0.13015452f, 
    0.17026255f, -0.35026094f, -0.08653312f, 0.11221611f, -0.10020655f, 0.19131106f, 0.15205920f, -0.03736612f, 
    0.02867531f, -0.17707185f, -0.19186929f, 0.03922056f, 0.10168125f, 0.00316681f, -0.01467477f, -0.08366136f, 
    -0.23464856f, -0.26524907f, 0.26070753f, -0.22414473f, 0.14225726f, -0.07140940f, -0.05878351f, 0.06174295f, 
    -0.14203078f, 0.16022894f, -0.27282450f, 0.12017935f, 0.05790032f, 0.16848253f, -0.19629198f, -0.24188398f, 
    0.09765507f, -0.22363871f, -0.09647498f, -0.10624619f, -0.18006355f, -0.12387078f, -0.26818594f, 0.05382412f, 
    0.02420559f, 0.15566455f, -0.01271330f, -0.14080593f, 0.19602661f, -0.01429046f, 0.23696601f, -0.17077303f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01488464f, -0.00775701f, -0.01510138f, -0.01809298f, 0.01003912f, -0.05105768f, -0.04582775f, 0.01470821f, 
    -0.04832255f, -0.00529127f, -0.03165564f, -0.00346308f, 0.00898781f, -0.04270744f, -0.04302115f, -0.00961777f, 
    0.00958094f, -0.05033622f, -0.01512979f, 0.01808749f, -0.00099003f, -0.03221625f, 0.00538922f, -0.04148689f, 
    -0.01397705f, -0.02724022f, -0.01976684f, -0.00062063f, -0.01655624f, -0.02845742f, -0.02146439f, -0.00826023f, 
    -0.00428392f, -0.01564231f, -0.00427013f, 0.00755879f, -0.04902650f, 0.00936452f, 0.00614512f, -0.02302216f, 
    -0.00086108f, -0.03314915f, -0.04473559f, -0.00778243f, 0.00917322f, 0.00871966f, -0.02634886f, -0.00387882f, 
    -0.04656681f, -0.00353887f, -0.03849735f, -0.05050167f, 0.01430809f, -0.00658408f, 0.01911729f, 0.00587204f, 
    -0.04328092f, -0.01371289f, -0.04977044f, -0.04040490f, -0.01932221f, -0.01106158f, -0.02753128f, -0.03667760f, 
    -0.01407562f, -0.03438541f, 0.00639497f, 0.01144250f, 0.01939453f, -0.00343962f, 0.00584140f, -0.02279330f, 
    -0.01391447f, -0.00107414f, 0.03457945f, -0.04482615f, -0.02941440f, -0.02275387f, -0.04490768f, 0.01177235f, 
    0.00726618f, -0.00732332f, -0.03869167f, -0.02714830f, -0.00543052f, -0.05066104f, -0.00952598f, -0.01480801f, 
    -0.00134300f, -0.00218043f, 0.01675101f, -0.04206647f, -0.03350288f, -0.00005802f, -0.00330817f, -0.03349649f, 
    -0.02550336f, -0.02252806f, -0.00529702f, -0.00146325f, -0.00704513f, -0.04137352f, 0.01087100f, 0.01806414f, 
    -0.02541342f, -0.04714962f, -0.04266485f, -0.00107095f, -0.03476533f, 0.00316890f, -0.04918369f, -0.01553166f, 
    -0.00598972f, -0.03265188f, -0.00116037f, -0.02450364f, -0.01091537f, 0.00990576f, -0.00618630f, -0.01478571f, 
    -0.04964432f, -0.01260106f, 0.00809645f, 0.01064141f, -0.01554761f, -0.04594336f, -0.02190494f, -0.01317827f, 
    -0.01164581f, -0.02083914f, 0.00398022f, -0.03357235f, -0.01623191f, -0.05042796f, -0.05185839f, -0.02576990f, 
    -0.01269170f, -0.04380165f, -0.00625274f, -0.04901227f, 0.01765536f, -0.03122284f, -0.04068979f, 0.01409501f, 
    -0.00355822f, -0.02828712f, -0.04076087f, -0.01263801f, 0.01547644f, -0.04650772f, -0.04648697f, 0.01717056f, 
    -0.03292166f, -0.03644202f, -0.03925602f, -0.03779215f, -0.01564096f, -0.02434011f, 0.00725368f, -0.01880044f, 
    -0.04700993f, 0.00640582f, 0.00221427f, -0.01322271f, 0.00366673f, -0.02450419f, 0.00309078f, -0.00228953f, 
    -0.00609314f, 0.00700575f, 0.01221161f, 0.01278554f, 0.01016442f, -0.01915999f, -0.04090057f, 0.01301537f, 
    -0.01298818f, -0.04806115f, -0.02765721f, 0.00611506f, 0.01262371f, -0.05050849f, -0.04134049f, -0.02394823f, 
    -0.01483988f, -0.03148656f, -0.03577484f, -0.03327625f, -0.00708335f, -0.03787747f, -0.04750739f, -0.00050652f, 
    -0.02329600f, -0.03137131f, 0.00426022f, 0.00641238f, -0.00157059f, -0.00635496f, -0.04126582f, -0.00431814f, 
    -0.04009583f, -0.00317078f, -0.00604152f, -0.04318758f, -0.02305113f, 0.00518501f, -0.02293561f, -0.05155417f, 
    0.00593191f, -0.03516809f, -0.03681055f, -0.02917551f, -0.04215182f, 0.00526537f, -0.04500494f, -0.03594606f, 
    -0.01734015f, -0.05064926f, -0.04268408f, -0.04129390f, 0.00666823f, -0.03444654f, -0.04772041f, -0.03181969f, 
    -0.03040375f, -0.04808578f, -0.05174452f, -0.01030441f, -0.01992053f, 0.00195865f, 0.00887774f, 0.00659369f, 
    -0.01822664f, -0.04759758f, -0.02796612f, -0.00289492f, -0.02487176f, -0.00502196f, -0.02322162f, -0.02230129f, 
    -0.02933115f, 0.02142086f, -0.03043432f, -0.01564304f, -0.00009006f, -0.04503715f, -0.01004867f, -0.04767160f, 
    -0.01377694f, 0.03254050f, -0.00178757f, -0.01655229f, -0.04579987f, -0.04707791f, -0.01714111f, -0.02179193f, 
    0.00962687f, -0.02308090f, 0.01838719f, 0.01710671f, -0.00798338f, -0.02900437f, -0.03696506f, -0.00916814f, 
    -0.00440635f, -0.03812414f, -0.01493802f, 0.02784722f, 0.00803791f, -0.02179010f, -0.02833137f, -0.00857117f, 
    0.01806991f, -0.03662647f, -0.03838258f, 0.00696947f, -0.02629502f, 0.01290773f, -0.04543336f, -0.03826756f, 
    -0.04458583f, 0.01195623f, 0.01726604f, -0.04926362f, -0.04811786f, -0.01630516f, -0.04293969f, -0.00551180f, 
    0.00600817f, 0.00829045f, -0.04363710f, -0.01124507f, 0.01067311f, -0.04907773f, -0.00455375f, -0.02202923f, 
    -0.03413704f, -0.01895406f, 0.00351484f, -0.01998225f, -0.03281295f, -0.02954389f, -0.02048774f, 0.01754385f, 
    -0.02100922f, 0.01911987f, 0.01592858f, -0.04382879f, -0.03348634f, -0.04549907f, -0.04319023f, 0.00159767f, 
    0.01864617f, -0.00031550f, -0.03871704f, 0.00641214f, -0.03900782f, -0.02591445f, -0.04281143f, 0.00515253f, 
    -0.05006699f, -0.02124334f, 0.01364012f, -0.03638402f, -0.00740222f, 0.01218602f, 0.00214623f, -0.01534952f, 
    -0.01983982f, -0.03791809f, -0.00922732f, -0.02810438f, -0.05171959f, 0.00830834f, -0.03011116f, 0.01841841f, 
    -0.04191706f, 0.00039080f, -0.04921447f, -0.00925645f, -0.01166969f, -0.02125852f, -0.02061725f, -0.03460348f, 
    -0.03321994f, -0.04601288f, 0.00514474f, -0.00754636f, -0.00333093f, -0.02817136f, -0.00497637f, -0.02338120f, 
    0.01393883f, 0.01070943f, 0.00682678f, -0.03276998f, -0.03918777f, -0.01817813f, -0.00533415f, -0.01991992f, 
    -0.04496660f, 0.00855127f, -0.04955048f, 0.00956848f, -0.03955499f, -0.00796101f, -0.01686543f, -0.01330713f, 
    -0.03808760f, -0.00674486f, 0.00483626f, 0.00471990f, 0.01911392f, -0.01467522f, 0.01025842f, -0.00321234f, 
    0.00331385f, -0.01575886f, 0.00324027f, -0.00097528f, 0.01706711f, 0.01591020f, 0.00010842f, -0.02140229f, 
    0.00770776f, -0.04412115f, -0.00959320f, 0.01177919f, -0.01969662f, -0.00449148f, 0.01011744f, -0.02049094f, 
    0.00627671f, -0.04215453f, -0.03901249f, -0.01760910f, 0.00918495f, -0.00101634f, -0.01419176f, -0.02110326f, 
    0.01711954f, -0.00524388f, 0.00052323f, -0.00328370f, -0.05083181f, 0.00745025f, -0.03126736f, -0.04329328f, 
    -0.00620691f, 0.01859217f, -0.03132710f, 0.01632230f, -0.00616542f, -0.03068346f, -0.05081237f, 0.01755923f, 
    -0.03861568f, -0.03263128f, -0.01454151f, -0.02421284f, -0.00517299f, -0.01792326f, -0.02517875f, 0.00810624f, 
    0.00057207f, 0.00022732f, 0.01722986f, 0.00230859f, -0.04451398f, -0.03538343f, 0.01593955f, -0.03592310f, 
    -0.01981847f, -0.02273372f, -0.02166386f, -0.03091748f, -0.01659830f, -0.02065332f, -0.04480727f, -0.01075411f, 
    -0.00967226f, -0.04061113f, -0.01578095f, -0.00150818f, -0.02639470f, -0.00043859f, -0.01369850f, -0.01336086f, 
    -0.00836511f, -0.03362177f, -0.03378452f, 0.01643348f, -0.03917348f, 0.00867722f, -0.01653201f, -0.00867830f, 
    -0.00493172f, 0.01380253f, 0.00752082f, -0.01203990f, 0.02966741f, -0.04911274f, -0.04027075f, 0.01682645f, 
    -0.02886760f, -0.01100533f, -0.00382543f, -0.01631356f, -0.01433444f, -0.00637224f, -0.00499902f, 0.00296820f, 
    -0.01740720f, -0.01897250f, 0.01653398f, -0.03703599f, 0.00440680f, -0.00705390f, -0.01681249f, 0.00329880f, 
    -0.01607804f, 0.00215448f, -0.02309068f, -0.00373787f, -0.00213805f, -0.01257584f, -0.02153314f, 0.00857886f, 
    -0.03361830f, -0.01175543f, -0.02321764f, -0.02608352f, -0.00827355f, 0.00583837f, -0.01947945f, -0.00991713f, 
    -0.01672142f, -0.01872096f, 0.01069763f, 0.00044524f, -0.02821679f, -0.05001019f, -0.00656718f, -0.03396710f, 
    -0.00234504f, 0.00427692f, -0.00369746f, -0.02480922f, -0.03001026f, -0.01955149f, -0.02480858f, 0.01682908f, 
    -0.03813639f, -0.04578930f, -0.04738612f, -0.00766131f, 0.01343049f, -0.02280500f, 0.01051395f, -0.01714389f, 
    -0.04223785f, -0.01268109f, -0.04043301f, -0.04168981f, -0.04960314f, -0.03277379f, -0.04050384f, -0.01831530f, 
    0.00658586f, 0.00725306f, -0.00642901f, -0.01239386f, 0.00023179f, -0.01880832f, -0.02996136f, 0.01309227f, 
    -0.02744312f, -0.02634310f, 0.01385338f, 0.01283087f, -0.01329474f, -0.01744731f, -0.00611868f, -0.01697668f, 
    0.00668788f, -0.00897733f, -0.01142245f, -0.04406286f, -0.03027739f, 0.01804519f, -0.02845436f, 0.00296930f, 
    0.02019020f, 0.02035685f, -0.03873179f, 0.00642767f, 0.01565477f, 0.01694437f, -0.03629417f, -0.00914108f, 
    0.01392159f, 0.00339157f, -0.00187541f, -0.01880941f, -0.04840708f, 0.00630064f, -0.04537532f, -0.03060818f, 
    0.00267868f, -0.02160822f, -0.00281855f, 0.00837154f, 0.01196263f, -0.02073889f, -0.01126913f, 0.00345931f, 
    -0.00253150f, -0.03967596f, -0.03560249f, 0.01306868f, -0.00711481f, -0.05209094f, -0.01194242f, -0.01197582f, 
    -0.02523435f, -0.00985325f, -0.04429971f, -0.02978346f, -0.02602418f, -0.04145804f, -0.05184007f, 0.00027255f, 
    0.00684421f, 0.00700965f, -0.03777348f, -0.01243996f, -0.01412459f, -0.04534170f, -0.00724856f, -0.00535415f, 
    0.03162503f, -0.02456527f, 0.01235113f, -0.02292793f, -0.02473535f, -0.00348289f, 0.01132173f, -0.05133136f, 
    0.00674525f, -0.00579605f, 0.01543216f, 0.01792309f, -0.02884735f, -0.02041881f, -0.00024247f, 0.00875919f, 
    -0.04826182f, -0.02562482f, -0.05142472f, -0.01990994f, -0.02606072f, -0.01977513f, -0.04013921f, -0.03010025f, 
    -0.00488456f, 0.02291179f, 0.00515284f, 0.00396633f, 0.00525978f, -0.03273918f, 0.00064487f, -0.03038330f, 
    -0.03259714f, 0.01251136f, 0.02842280f, 0.01270362f, -0.02916132f, -0.01075400f, -0.02759645f, -0.01157205f, 
    -0.04428132f, 0.01486798f, -0.00024879f, -0.02094355f, -0.04663996f, 0.00215324f, -0.02483584f, -0.04439377f, 
    -0.04103335f, -0.00464682f, -0.03450660f, -0.02179587f, -0.02182934f, -0.02932976f, -0.02151299f, -0.01369859f, 
    -0.04289482f, 0.01069178f, -0.03354973f, -0.01850187f, -0.03895427f, -0.02213383f, -0.01941301f, 0.00047114f, 
    -0.00657206f, -0.01964334f, 0.02101318f, -0.03643354f, -0.04216963f, 0.00243038f, -0.03075095f, -0.02789761f, 
    -0.00724854f, -0.01850107f, -0.02774636f, -0.04841802f, -0.01414271f, 0.00742411f, -0.00616684f, 0.01593097f, 
    0.01195825f, -0.00018652f, -0.01386412f, -0.00756667f, -0.03477971f, -0.03474011f, 0.00333548f, -0.00401708f, 
    -0.03099858f, -0.03578383f, -0.00284102f, 0.00219427f, -0.03822049f, 0.01565431f, -0.02084968f, -0.05199654f, 
    -0.00633250f, -0.02998850f, 0.01049865f, -0.01124151f, -0.02139797f, -0.03433254f, -0.04629929f, 0.01311562f, 
    -0.04965606f, 0.01985636f, -0.03146920f, -0.03045056f, -0.04487317f, -0.01587681f, 0.00676468f, -0.03483488f, 
    -0.04336154f, 0.01387362f, -0.00012242f, 0.01224091f, -0.04307232f, -0.03658851f, -0.05119257f, -0.02001055f, 
    -0.03905763f, -0.04993069f, -0.04264625f, -0.00266504f, -0.03136588f, -0.01797066f, 0.00633389f, -0.03692475f, 
    0.00580888f, 0.00020220f, -0.00305073f, -0.02229899f, -0.03749010f, -0.03018854f, 0.00314382f, -0.04505652f, 
    0.00159426f, -0.02958430f, -0.02807543f, -0.01904815f, -0.01261189f, -0.03443000f, -0.00201095f, -0.00200494f, 
    -0.05131982f, 0.01959470f, -0.04024618f, 0.00294348f, 0.00258432f, -0.02295459f, -0.04502447f, -0.03512473f, 
    -0.04498177f, -0.01688815f, -0.02900132f, -0.02670205f, -0.02769060f, -0.04699350f, -0.02893839f, -0.03537776f, 
    -0.02967420f, 0.01604645f, -0.00375064f, -0.03243652f, -0.01111019f, -0.01685116f, -0.02379626f, 0.01901787f, 
    0.24109423f, 0.13077331f, -0.07017542f, 0.02493895f, 0.03874275f, 0.04488778f, -0.07001393f, 0.06253288f, 
    0.02863578f, -0.08364295f, 0.03351558f, -0.01896163f, 0.28436056f, 0.21754886f, 0.05245218f, 0.19769922f, 
    -0.06609263f, -0.04990656f, -0.04953273f, -0.00991148f, -0.03190862f, 0.07203655f, -0.11071195f, -0.00424150f, 
    -0.16200477f, -0.15629421f, 0.09377474f, 0.05537474f, 0.32621846f, -0.06230056f, -0.03745587f, 0.10990486f, 
    0.03962187f, 0.05295977f, -0.00855975f, 0.02359249f, -0.42979166f, -0.26633757f, 0.01947994f, 0.23931415f, 
    -0.18304004f, 0.22243729f, 0.08163958f, 0.03517033f, 0.16493782f, -0.06442156f, 0.01186092f, 0.12569983f, 
    0.00021726f, -0.02101352f, 0.13047703f, -0.00480704f, -0.02644822f, 0.15763272f, -0.09082968f, 0.11972088f, 
    -0.01553030f, -0.06261147f, -0.08203671f, 0.01743930f, 0.11947098f, 0.28567484f, 0.11452304f, -0.36670107f, 
    0.09483419f, -0.06530470f, -0.05310053f, 0.18827985f, -0.07631435f, 0.04618084f, 0.07925581f, 0.05463320f, 
    0.06916178f, 0.14284742f, 0.15068769f, -0.04598032f, 0.01384388f, -0.10325326f, 0.04605307f, -0.00699077f, 
    0.10290903f, -0.06807471f, -0.08640920f, -0.05036869f, 0.05431857f, -0.11607308f, -0.00098585f, -0.04054078f, 
    -0.06356664f, 0.01281570f, -0.06956822f, 0.08613682f, -0.06784872f, -0.14168891f, -0.01738966f, -0.09743688f, 
    0.06445034f, 0.10273594f, 0.04777702f, 0.09824628f, -0.01836945f, -0.03076591f, -0.04662430f, -0.00006707f, 
    0.03403487f, -0.01434419f, 0.14389190f, 0.15893088f, -0.07193970f, 0.17389753f, 0.10644446f, -0.03319129f, 
    0.05420754f, 0.08033977f, 0.10474843f, 0.04780070f, 0.04203212f, -0.01516832f, -0.03544910f, -0.01041725f, 
    0.10457233f, -0.01922184f, -0.04028967f, 0.03057624f, -0.05493827f, 0.11189257f, -0.04517704f, 0.02992775f, 
    -0.04447570f, -0.09851392f, -0.07680210f, 0.14993601f, 0.17879064f, 0.09443361f, 0.05190612f, 0.12598717f, 
    -0.11136770f, -0.06676376f, -0.04950882f, -0.03772445f, -0.07479110f, -0.09357909f, -0.05227338f, -0.06674660f, 
    -0.19971642f, -0.03955338f, -0.29533747f, 0.03911375f, -0.14752035f, -0.14727654f, 0.14976625f, 0.13847937f, 
    -0.00862081f, 0.00190263f, 0.12216215f, -0.10997407f, -0.28592241f, -0.20236634f, -0.30000576f, -0.31652445f, 
    -0.03990829f, -0.14208427f, -0.04269960f, 0.09823138f, 0.00807416f, -0.03770518f, -0.05817335f, -0.16251391f, 
    -0.00805078f, -0.06880856f, -0.07854661f, -0.03810743f, -0.00229012f, 0.03362342f, 0.00019617f, 0.00170741f, 
    -0.00170128f, -0.12200479f, 0.15204874f, 0.04183900f, 0.07683041f, -0.26631522f, -0.20062619f, -0.17443497f, 
    -0.15249299f, -0.11520401f, -0.04469940f, -0.01859541f, 0.18132576f, -0.13328758f, -0.12347276f, -0.10135194f, 
    0.27384388f, -0.12744464f, -0.18531762f, -0.25105521f, -0.04619389f, 0.05558156f, 0.06441227f, 0.15858865f, 
    0.12125342f, 0.07497980f, -0.07711425f, 0.02670689f, -0.07717606f, -0.01862155f, -0.07847691f, -0.03388743f, 
    0.06976741f, 0.08363812f, 0.05892182f, -0.05636532f, -0.11341266f, -0.13644783f, -0.17843008f, -0.09307977f, 
    -0.02194965f, -0.08813507f, 0.00866926f, 0.07516812f, 0.08820094f, -0.01901335f, -0.01273921f, 0.08484141f, 
    -0.01608182f, 0.02379330f, 0.04243405f, 0.02807636f, -0.03552779f, 0.05307200f, 0.27879331f, 0.03003013f, 
    -0.04571915f, 0.03322497f, -0.02573922f, -0.00712857f, -0.07446358f, -0.01511760f, 0.00524014f, -0.07467046f, 
    -0.04497592f, 0.13405609f, 0.14021491f, -0.00574407f, 0.06794219f, 0.01742142f, 0.04493761f, 0.09182870f, 
    -0.02164928f, -0.07656252f, 0.00236939f, -0.02129308f, 0.34734952f, -0.05008558f, 0.11840448f, 0.24457687f, 
    0.21191832f, 0.00010108f, -0.00207082f, 0.07596357f, 0.08905152f, 0.11295410f, 0.07919890f, -0.00007704f, 
    0.30592230f, -0.12305622f, 0.27247229f, -0.02700222f, 0.26751927f, -0.03051355f, 0.11882776f, 0.00890801f, 
    0.10778091f, -0.08153072f, 0.10288315f, 0.01446181f, 0.34840503f, 0.19665870f, 0.03441127f, -0.10632845f, 
    -0.08775603f, -0.11453919f, -0.15742247f, -0.08147382f, -0.10896043f, 0.02569510f, -0.03162744f, 0.01268789f, 
    0.32440975f, 0.04172306f, 0.12237581f, -0.07409218f, 0.10143271f, -0.11717451f, 0.05681630f, 0.01191467f, 
    -0.11530101f, -0.07376196f, 0.07343701f, -0.04457371f, 0.05731905f, 0.00701800f, -0.07144903f, -0.01865898f, 
    0.04457564f, 0.04371654f, 0.04815062f, -0.00686598f, -0.07714658f, -0.03841923f, -0.05494940f, -0.02213880f, 
    -0.11442035f, -0.39502877f, 0.16461079f, 0.10911742f, 0.07532153f, 0.00544920f, 0.08329140f, 0.05859512f, 
    0.12434954f, 0.01794932f, -0.00884295f, 0.00094286f, -0.20107563f, 0.02389723f, -0.22269212f, 0.05266651f, 
    -0.19056933f, 0.02227917f, 0.03117858f, 0.05154981f, -0.01843627f, -0.11401147f, 0.05351461f, 0.18602237f, 
    0.13003698f, 0.36407608f, 0.22155131f, 0.21944669f, 0.22434629f, -0.14817227f, 0.00235237f, 0.02586415f, 
    -0.03231844f, -0.12057719f, 0.02335542f, 0.01333997f, 0.26167491f, 0.16071203f, 0.02486519f, 0.24125475f, 
    -0.08422150f, -0.08743235f, -0.11286148f, -0.02385672f, -0.00681459f, -0.04955246f, -0.02089581f, -0.00149214f, 
    0.06931841f, -0.03150155f, 0.13970417f, 0.12343864f, -0.07862487f, -0.06520640f, 0.00298589f, -0.00407371f, 
    0.28437477f, 0.34596285f, -0.06013895f, 0.02552464f, -0.74325979f, -0.05771218f, 0.00192467f, -0.15386678f, 
    0.10881684f, 0.02962960f, -0.04368643f, 0.12744747f, -0.01590447f, -0.12152178f, 0.11097696f, -0.07489673f, 
    0.14315936f, 0.20394161f, 0.03057333f, -0.09248925f, 0.12499754f, 0.06370521f, -0.11943865f, 0.05679616f, 
    -0.02468600f, 0.00567859f, 0.08163489f, -0.04968870f, -0.14073066f, 0.16033301f, 0.01419189f, 0.02835752f, 
    -0.05194262f, -0.09077724f, -0.11217760f, -0.06866688f, -0.01018992f, -0.00716751f, 0.06615559f, -0.08691468f, 
    -0.16478327f, -0.10588441f, 0.19277366f, 0.17902158f, 0.04014695f, 0.00658490f, 0.14683728f, 0.05848401f, 
    0.00251886f, -0.00716566f, 0.07527083f, 0.09669591f, -0.15726708f, -0.05533767f, -0.17538211f, -0.00503355f, 
    -0.15564395f, -0.03526991f, -0.09340627f, 0.02780734f, 0.02391652f, -0.05081819f, 0.00228995f, 0.11545257f, 
    0.27949855f, -0.11007193f, 0.12949868f, -0.07408877f, 0.10947304f, 0.12852113f, -0.08782990f, 0.08742008f, 
    -0.02448915f, -0.05158594f, 0.06358020f, 0.00275895f, 0.38400421f, 0.04566692f, 0.04172467f, 0.33067590f, 
    -0.03556463f, 0.02881582f, -0.09678620f, 0.00579127f, -0.01773911f, -0.02651511f, 0.00251414f, 0.03727548f, 
    0.06599673f, 0.11985227f, 0.04411575f, -0.01889941f, 0.02267197f, -0.14538896f, -0.22599775f, -0.07453386f, 
    -0.00447751f, -0.05086282f, 0.07879003f, 0.02059849f, 0.18899037f, 0.09700643f, 0.05992094f, 0.00856341f, 
    0.01016907f, 0.08130964f, 0.04787148f, -0.07459850f, -0.06460053f, 0.11007331f, 0.08156431f, 0.06191309f, 
    0.06086886f, 0.07024650f, 0.11955982f, -0.00862541f, -0.02169807f, -0.10955966f, -0.08898907f, -0.02034991f, 
    0.14265807f, -0.01905923f, -0.01428714f, 0.06196502f, 0.05942574f, -0.08237737f, -0.13777232f, -0.08604447f, 
    -0.07492847f, 0.05341762f, 0.02516594f, 0.11348660f, 0.15013558f, -0.02392091f, -0.09501123f, -0.05875670f, 
    0.20853035f, 0.07656821f, 0.07278016f, 0.08141682f, -0.04039627f, -0.02588776f, -0.07757495f, -0.07729919f, 
    -0.08620283f, -0.04109263f, -0.03616176f, -0.01358925f, 0.28422043f, 0.00549555f, -0.00084418f, -0.16853805f, 
    -0.02030295f, 0.01624734f, 0.07096386f, 0.09188817f, 0.08518481f, -0.09190603f, 0.06442950f, 0.10694231f, 
    -0.03033275f, 0.10781233f, 0.08245222f, 0.01606614f, -0.10493751f, -0.03824042f, 0.01902783f, -0.07616583f, 
    0.05657236f, -0.05523629f, -0.01241671f, -0.09442675f, 0.34503284f, -0.12567987f, 0.15137984f, 0.10434587f, 
    0.23805395f, -0.03080521f, 0.04343875f, -0.02016988f, 0.03911430f, 0.03121537f, 0.05669803f, 0.11685031f, 
    -0.17067045f, 0.04008942f, 0.20335010f, 0.19600850f, -0.00552482f, -0.00114965f, -0.01350864f, -0.02608716f, 
    -0.08435837f, -0.10649412f, -0.00570161f, -0.07060000f, -0.41394567f, -0.12317233f, -0.18314648f, 0.15465309f, 
    0.07191623f, -0.06123785f, 0.13853328f, 0.01592681f, 0.05868725f, -0.07679634f, 0.04183654f, -0.03231075f, 
    -0.23370126f, 0.10957013f, 0.09928488f, 0.26054010f, 0.02413887f, 0.00937716f, 0.10864822f, 0.22025073f, 
    0.05172793f, 0.07560581f, -0.12399058f, 0.04121708f, 0.25867686f, -0.54911214f, 0.04901039f, 0.10966214f, 
    -0.11642412f, -0.07637277f, -0.08594768f, 0.02205065f, -0.08323984f, -0.12415768f, -0.08269905f, -0.02729002f, 
    -0.45344356f, 0.11279198f, 0.29213399f, -0.01180776f, -0.00846986f, 0.05479668f, 0.02305917f, 0.15440966f, 
    -0.03954784f, -0.10741379f, -0.06272034f, -0.07311093f, -0.03603370f, 0.16719088f, 0.16524671f, -0.06567141f, 
    -0.01294815f, 0.00662574f, 0.11732642f, -0.05443815f, -0.02501064f, -0.03319673f, -0.09610324f, -0.06316590f, 
    -0.04554774f, 0.00008581f, 0.14018606f, 0.08644313f, 0.02907143f, 0.04315994f, -0.02955715f, -0.07270312f, 
    0.05502170f, -0.02890240f, -0.08246515f, -0.05714318f, 0.07972039f, 0.02642903f, 0.16918236f, 0.08322587f, 
    -0.03543350f, 0.01996066f, 0.13363007f, -0.06019733f, -0.12689736f, -0.08289613f, -0.01114778f, 0.14632496f, 
    -0.10079090f, 0.02171039f, -0.00237114f, 0.02237343f, -0.00178345f, 0.12725633f, -0.02398354f, -0.11839725f, 
    -0.14951378f, -0.03163470f, -0.08559717f, 0.01926330f, 0.08216854f, 0.01663372f, 0.02562175f, 0.04205853f, 
    -0.08939184f, -0.04368749f, -0.06226220f, 0.02153975f, 0.06318784f, 0.06018864f, 0.15237300f, -0.03879366f, 
    0.12585507f, -0.05830070f, -0.01032650f, -0.35082343f, 0.03042663f, 0.06710288f, -0.05905594f, 0.00422484f, 
    -0.09892652f, -0.08905283f, -0.00890468f, -0.01006225f, 0.22499529f, 0.04900127f, -0.02444012f, 0.20642272f, 
    -0.00141639f, 0.03760079f, -0.08729807f, 0.03325482f, 0.13052720f, 0.12048030f, 0.12077821f, 0.07651637f, 
    -0.06220241f, 0.09483712f, 0.22423241f, 0.10105719f, -0.05980367f, 0.11050777f, 0.03930440f, -0.04673440f, 
    0.02116775f, 0.04299619f, -0.00230126f, 0.11172054f, 0.12809993f, 0.02137909f, -0.01240949f, 0.01581687f, 
    0.03588261f, 0.02218186f, -0.03392132f, 0.03588955f, -0.07996249f, -0.16972221f, -0.10518312f, -0.03440290f, 
    0.33314541f, 0.11587142f, -0.14955828f, -0.16515492f, 0.04600700f, -0.08637938f, 0.05264211f, -0.04437631f, 
    0.04535851f, -0.05495906f, -0.04345388f, 0.06090681f, -0.01483484f, -0.16275452f, 0.06105995f, 0.26503050f, 
    0.11310622f, 0.11256029f, -0.11632543f, -0.07281245f, -0.01890732f, 0.01137896f, 0.04388315f, 0.10060494f, 
    -0.26639575f, -0.06667469f, 0.10290698f, -0.04666470f, 0.24092571f, 0.02689107f, 0.06735516f, 0.05169745f, 
    0.03535365f, -0.01320149f, 0.07617998f, 0.08115960f, -0.03281936f, 0.08104712f, -0.12406251f, -0.29210550f, 
    -0.03527312f, -0.15638570f, 0.02378707f, -0.04650361f, -0.09669524f, -0.09560576f, 0.01967419f, -0.16353284f, 
    0.11344256f, 0.02264886f, -0.14644481f, 0.20829599f, -0.01967033f, 0.03969317f, -0.09314288f, 0.11587305f, 
    -0.06909186f, 0.06090468f, -0.06682993f, -0.16092545f, 0.07495949f, -0.00711971f, 0.00841175f, 0.00205536f, 
    -0.00043025f, -0.11461350f, -0.10006021f, 0.06920724f, -0.09609960f, -0.03859815f, 0.06670825f, -0.02639971f, 
    0.15621775f, 0.00808829f, -0.08970553f, -0.12848566f, -0.19686159f, -0.05153609f, 0.07552423f, 0.00884467f, 
    0.09509438f, 0.10832671f, 0.23719180f, 0.00441249f, -0.16797225f, -0.01791524f, -0.01764608f, 0.25264296f, 
    0.24625231f, 0.08873542f, -0.23110542f, 0.11845143f, -0.06490532f, -0.04396189f, 0.11054979f, -0.08487615f, 
    0.06000296f, -0.30027324f, -0.18454546f, -0.01680418f, 0.09791063f, -0.14252307f, -0.03812856f, 0.04506227f, 
    -0.12920639f, -0.14109573f, -0.20152617f, -0.21586013f, -0.13408704f, 0.05823122f, -0.10200635f, 0.06812469f, 
    0.02736911f, -0.04491466f, -0.04225264f, 0.05176168f, 0.03854388f, 0.06932162f, 0.01494890f, 0.24209160f, 
    -0.08236015f, 0.01730195f, -0.10640267f, 0.08984529f, -0.09340736f, 0.05724081f, 0.03904187f, 0.00232058f, 
    0.08651569f, 0.04861267f, 0.07009728f, 0.17799108f, 0.11475157f, -0.06814531f, -0.14400005f, 0.10437953f, 
    0.14615585f, -0.26606387f, -0.03700747f, -0.04820263f, -0.23099507f, 0.02976115f, -0.09780562f, -0.16729885f, 
    -0.03924443f, -0.03931383f, -0.12263621f, -0.12276337f, -0.12391381f, 0.04827972f, 0.06627287f, -0.07765071f, 
    0.15557128f, 0.28416690f, 0.10573110f, 0.07018627f, -0.08604750f, -0.27432075f, -0.06377138f, -0.12058239f, 
    -0.05244903f, -0.12428175f, -0.10124218f, -0.03836726f, -0.09860097f, -0.01081724f, 0.03936190f, -0.02708478f, 
    0.07576358f, 0.04548538f, 0.02257879f, -0.01135897f, 0.05717691f, -0.06535015f, -0.19192326f, -0.02389759f, 
    -0.16648228f, 0.02226642f, -0.05012650f, -0.37626624f, -0.03489207f, -0.05056578f, -0.07038935f, -0.05823485f, 
    0.08992890f, 0.17720936f, -0.03107955f, -0.11364303f, -0.19914706f, -0.09138346f, -0.15946524f, -0.00200704f, 
    0.06181493f, 0.13553399f, 0.29901916f, 0.19449532f, -0.18989888f, 0.05407081f, -0.22498615f, -0.09430457f, 
    -0.01854076f, 0.06711986f, 0.06321084f, 0.00786814f, 0.18081613f, 0.25194815f, 0.20454642f, -0.03524671f, 
    0.04508593f, -0.00739237f, 0.04457274f, -0.12093918f, 0.00571807f, 0.12194816f, 0.00067301f, 0.16581659f, 
    0.04907603f, 0.11816969f, 0.03318615f, 0.19510253f, 0.01882206f, -0.02020775f, 0.07244137f, 0.05574342f, 
    0.09594174f, 0.04619789f, -0.02429005f, -0.18237495f, -0.08434875f, 0.03527764f, 0.00141541f, 0.08613374f, 
    -0.06796551f, -0.10529379f, -0.18049227f, -0.14176242f, -0.09826028f, 0.05341509f, 0.18472782f, 0.07867651f, 
    0.00178029f, 0.10247597f, 0.11937397f, 0.16708215f, 0.15495934f, -0.06571265f, 0.11872211f, -0.09915685f, 
    -0.18092769f, -0.07870937f, 0.04606589f, 0.05042561f, -0.09925888f, 0.07744507f, 0.07663582f, -0.00235848f, 
    0.15819168f, 0.05396967f, -0.15463620f, 0.09025503f, -0.15232173f, -0.29530105f, 0.01477593f, -0.29938936f, 
    0.30045509f, -0.09506432f, -0.20155820f, 0.04360782f, -0.09657895f, 0.07062596f, 0.15079020f, -0.04062020f, 
    -0.03304190f, 0.17059958f, 0.14986183f, 0.19673760f, 0.12405934f, -0.05810685f, 0.08076853f, -0.05368200f, 
    -0.03300056f, 0.06522627f, -0.06762567f, -0.05773529f, 0.01378321f, -0.00766397f, -0.22936559f, -0.16975985f, 
    -0.02087404f, -0.10876494f, -0.06883179f, -0.10629862f, -0.03516439f, -0.09300227f, -0.04554702f, -0.04521770f, 
    -0.08958118f, -0.07541342f, -0.18678775f, -0.22677502f, 0.24090658f, 0.03303407f, 0.01966010f, 0.06898697f, 
    0.01304846f, -0.08593237f, 0.06654098f, 0.03107998f, 0.00106482f, 0.12309635f, 0.03946510f, 0.02725658f, 
    -0.17527664f, 0.15982458f, -0.03085380f, -0.17953065f, -0.06310456f, -0.05587427f, 0.06077875f, 0.29494461f, 
    -0.05652377f, 0.28297490f, -0.11768308f, 0.02419851f, 0.11259712f, -0.11705626f, -0.00287155f, 0.05540206f, 
    0.06559551f, 0.07634749f, 0.03818152f, 0.04379057f, -0.15537751f, -0.09132393f, -0.16612971f, -0.07639893f, 
    0.22475518f, -0.04922480f, 0.17078179f, 0.03461377f, 0.06185815f, 0.08201229f, 0.23189579f, -0.06511321f, 
    -0.03147277f, 0.00535444f, 0.04246021f, 0.15616748f, -0.04034201f, 0.02340982f, 0.01684095f, -0.08152752f, 
    -0.00535810f, 0.01478092f, -0.14084731f, -0.13314739f, -0.22219065f, -0.27444831f, -0.11382142f, -0.41534019f, 
    0.09906743f, 0.18490671f, -0.27800408f, 0.10752948f, 0.03363425f, 0.18116920f, 0.01405795f, -0.02966150f, 
    0.06000296f, 0.06666989f, 0.12335429f, 0.24577577f, 0.02240820f, 0.12329222f, 0.19741599f, 0.13480264f, 
    0.04186269f, -0.14217936f, -0.12494842f, -0.01801760f, -0.08749703f, 0.11395379f, 0.04164242f, -0.03157552f, 
    0.35696205f, -0.07622444f, -0.33445960f, 0.01355654f, -0.08761036f, 0.06229660f, 0.16212791f, -0.11594236f, 
    -0.12633093f, -0.10518283f, -0.06271831f, -0.14507566f, -0.01627998f, -0.12470771f, -0.04576776f, -0.02419103f, 
    0.00962556f, 0.23507769f, -0.01510513f, -0.13273910f, -0.05193159f, 0.14706072f, 0.09450853f, 0.10823922f, 
    -0.11541047f, -0.04167536f, 0.00499587f, 0.00320971f, 0.05518577f, 0.02163401f, -0.03320915f, 0.10433556f, 
    0.02183114f, -0.01976599f, -0.01069397f, 0.32768664f, 0.25286824f, -0.07674468f, 0.14019401f, -0.05144142f, 
    -0.00231337f, 0.03837276f, -0.01494394f, -0.02744508f, 0.17941137f, 0.07073630f, 0.08664492f, -0.06140103f, 
    0.21073641f, -0.00106199f, -0.08731212f, -0.01879953f, 0.02664304f, 0.19443306f, 0.20887202f, 0.12461036f, 
    -0.02052438f, -0.01151921f, 0.17649621f, 0.09804745f, 0.01724850f, -0.05086253f, -0.11681394f, -0.13591433f, 
    -0.05921342f, 0.01045335f, 0.13884430f, 0.04159085f, 0.11097823f, 0.07648487f, 0.07705488f, 0.16793719f, 
    -0.05404797f, 0.07588492f, -0.22276641f, 0.08983590f, 0.05242606f, -0.10039003f, -0.21630737f, -0.03639193f, 
    -0.06898015f, -0.12056457f, -0.09739731f, -0.22455755f, -0.02933121f, 0.12512180f, 0.17933193f, -0.06655128f, 
    0.09698571f, -0.09917644f, 0.08044474f, -0.05932339f, 0.00847056f, 0.00339940f, 0.02463997f, -0.05070822f, 
    0.17870884f, -0.06706095f, 0.35471576f, -0.07855223f, 0.14800432f, -0.06097974f, 0.14122014f, 0.01885203f, 
    -0.03104321f, 0.02959580f, 0.11855080f, -0.01147411f, 0.02687654f, -0.08154410f, -0.14231905f, -0.05961522f, 
    -0.02551123f, 0.05825458f, 0.14719723f, -0.08865940f, -0.13254760f, -0.08680867f, 0.12803742f, -0.08130121f, 
    -0.00430852f, -0.01096327f, -0.11817100f, -0.00068241f, -0.02283122f, 0.06694033f, 0.10890561f, 0.05383417f, 
    0.03063042f, 0.08188137f, 0.07121544f, 0.01909163f, 0.26570308f, 0.02064857f, 0.14279413f, -0.13372688f, 
    -0.04117209f, 0.00178208f, 0.17412576f, 0.04439061f, -0.05970081f, 0.02152726f, -0.01363604f, 0.00274435f, 
    -0.11434510f, -0.12701279f, -0.04082879f, 0.02229755f, -0.07224019f, 0.00242378f, 0.16380239f, -0.01489472f, 
    0.00961833f, 0.19239944f, 0.06857286f, 0.02756060f, 0.09931794f, 0.17517124f, 0.18051620f, 0.05365761f, 
    -0.08916368f, -0.12794781f, -0.04599964f, -0.11405051f, 0.01586835f, -0.06138141f, -0.11144563f, 0.10161468f, 
    0.21364485f, 0.01239220f, -0.05212812f, -0.26694992f, 0.04037155f, 0.04702865f, 0.05375562f, 0.02055314f, 
    -0.10561373f, -0.08141907f, -0.06837449f, -0.14018627f, -0.14179318f, 0.09905495f, 0.14163381f, 0.03431340f, 
    0.06022194f, -0.03723196f, 0.07187273f, -0.06208681f, -0.03322645f, 0.21394029f, 0.06410908f, -0.08867163f, 
    -0.10102104f, -0.11334255f, 0.01897777f, 0.10337925f, -0.12940714f, -0.01624376f, -0.00002031f, -0.00362361f, 
    0.07335155f, 0.17705846f, 0.08212406f, 0.06652203f, 0.15116128f, 0.08521481f, 0.04290038f, -0.08411095f, 
    0.00488296f, -0.06043414f, -0.07523561f, 0.14577353f, -0.18195191f, -0.00710354f, 0.13846187f, -0.26215136f, 
    0.04410552f, -0.08597159f, 0.01562460f, -0.06221335f, -0.11873589f, 0.03446104f, 0.00652863f, 0.07203011f, 
    -0.03542624f, -0.09332190f, -0.04362930f, -0.03701912f, 0.03087239f, -0.06178444f, -0.15208708f, 0.06379679f, 
    -0.06802540f, 0.04306146f, 0.03179755f, -0.01968130f, -0.05823326f, 0.17382018f, 0.18783784f, 0.04619028f, 
    -0.16896322f, 0.05975565f, 0.04533868f, 0.09355990f, -0.05262785f, 0.02917477f, 0.06927434f, -0.13319860f, 
    -0.03236503f, -0.17853500f, 0.13188301f, -0.13193358f, -0.36103711f, 0.16653416f, -0.12593992f, 0.13526800f, 
    0.05253108f, 0.15632571f, 0.08233568f, 0.16622265f, 0.08155062f, 0.09163599f, 0.23662856f, 0.23153326f, 
    0.07237751f, -0.25297326f, 0.13364142f, 0.01410834f, -0.01382743f, 0.06536134f, -0.01413017f, 0.04481602f, 
    -0.10429499f, -0.03728982f, -0.13263574f, -0.11607492f, -0.14036828f, -0.19004181f, -0.17689343f, -0.02894591f, 
    -0.09638093f, 0.02933357f, 0.13546434f, -0.06906094f, -0.07537901f, -0.01664896f, 0.00161158f, -0.07007101f, 
    -0.12481822f, 0.17245047f, 0.07225376f, -0.18329374f, -0.12266520f, -0.18962543f, -0.09499009f, -0.09974973f, 
    0.04892361f, -0.09824550f, -0.13096705f, -0.08580925f, 0.37182930f, 0.22365077f, 0.18906218f, -0.04429328f, 
    -0.01753787f, 0.01982913f, 0.11726236f, 0.16209655f, 0.11496488f, 0.02818992f, 0.11947165f, -0.06457255f, 
    0.10569345f, 0.05406970f, -0.09818047f, 0.04140595f, 0.16491924f, 0.09223720f, -0.11411518f, 0.17540942f, 
    0.08450881f, -0.08235171f, -0.17173393f, -0.25589949f, -0.04644695f, -0.04608339f, -0.12438536f, -0.13641489f, 
    0.05409221f, -0.05190100f, -0.12732194f, 0.05257608f, 0.07520780f, 0.00108054f, -0.01789230f, 0.12392432f, 
    -0.00432829f, 0.00937279f, -0.12268618f, 0.10953943f, -0.01186322f, -0.00529406f, -0.03545871f, -0.00282856f, 
    0.02523473f, 0.02341809f, 0.04515848f, 0.08837907f, -0.04095718f, -0.11949114f, 0.14279515f, -0.01786696f, 
    -0.01642940f, 0.12117656f, -0.08090362f, 0.02753869f, 0.02383702f, -0.00096066f, -0.13429393f, -0.01053992f, 
    -0.02912567f, -0.22399357f, 0.00525744f, -0.09288107f, -0.11218008f, -0.16806565f, -0.06068794f, 0.01888197f, 
    -0.10501121f, -0.05643310f, 0.06043588f, -0.07546057f, 0.10804036f, 0.07846352f, 0.14919333f, 0.01318196f, 
    -0.05136703f, -0.02286773f, -0.02696269f, -0.06367898f, 0.06478800f, 0.27784619f, 0.39780921f, 0.33212179f, 
    0.14959522f, 0.08845728f, 0.12646829f, -0.07961901f, 0.07753916f, -0.19268207f, 0.11692105f, 0.00074215f, 
    -0.01978652f, 0.13487555f, 0.12699151f, -0.07387678f, 0.44854400f, 0.02738714f, -0.07304302f, -0.04043489f, 
    -0.07642180f, 0.08741967f, 0.11787429f, -0.06516083f, 0.05044680f, -0.07886104f, -0.00046568f, -0.03147757f, 
    0.09036107f, 0.18662633f, -0.11357091f, -0.11786677f, -0.03818825f, -0.02389911f, -0.16140527f, -0.07963292f, 
    -0.11141743f, -0.03099415f, 0.05764269f, 0.02158348f, -0.18900280f, 0.34228945f, 0.00040540f, 0.11477257f, 
    -0.06790259f, 0.02376638f, 0.02735268f, 0.09617455f, 0.09600142f, 0.04142175f, 0.08287867f, 0.37907967f, 
    0.06693584f, 0.03938232f, 0.01619894f, -0.17879294f, 0.15705732f, -0.04110433f, 0.03654499f, 0.08533773f, 
    -0.04056305f, -0.09127749f, 0.15938883f, -0.03051963f, 0.25743219f, 0.14884003f, -0.13402133f, -0.00978037f, 
    0.02718442f, -0.07995559f, -0.00927445f, 0.03670513f, -0.08761966f, 0.04858866f, 0.08892412f, 0.07561823f, 
    0.26964167f, 0.19296581f, -0.16870254f, -0.04015714f, -0.04000191f, -0.02690249f, 0.13219675f, -0.11683390f, 
    0.14846589f, 0.05095588f, 0.07869493f, 0.08527155f, -0.40607482f, 0.39886644f, 0.28964603f, 0.02933544f, 
    0.12132465f, 0.07541545f, -0.09580507f, 0.21198715f, -0.13879177f, 0.06206823f, 0.06290131f, 0.20584357f, 
    -0.16602087f, -0.16539571f, 0.02501175f, 0.08298575f, -0.02541981f, 0.12636642f, 0.11507455f, 0.19782035f, 
    -0.03927470f, 0.00517502f, -0.00613746f, -0.03662163f, 0.19783801f, 0.36671677f, -0.08188978f, -0.35264888f, 
    0.06961745f, -0.00628290f, 0.12811476f, -0.12506314f, -0.01542655f, 0.13102750f, -0.16375341f, -0.05451556f, 
    -0.09208367f, 0.09411236f, -0.12360676f, 0.02466634f, -0.11864948f, -0.07554424f, -0.01789272f, 0.14726655f, 
    0.08908946f, 0.07072435f, 0.07954530f, 0.04834205f, -0.06571311f, 0.04889305f, -0.02063926f, -0.07972577f, 
    -0.13850337f, 0.00416263f, -0.01980915f, 0.02876457f, -0.00662081f, -0.04760075f, -0.02071609f, 0.00209592f, 
    -0.08428182f, -0.01615477f, -0.08174034f, -0.05261778f, -0.00111772f, -0.03001229f, -0.01596411f, 0.03335497f, 
    0.08859630f, -0.00785880f, -0.00460215f, -0.01323892f, -0.00719019f, -0.05207635f, 0.02219410f, -0.14058650f, 
    -0.04840866f, -0.01965648f, 0.05348910f, -0.05178566f, 0.08050008f, 0.00461037f, -0.01421601f, -0.05567801f, 
    -0.06486493f, 0.09122615f, -0.12406310f, -0.12240975f, -0.05672193f, -0.00568265f, 0.06912762f, -0.00098746f, 
    0.05617521f, -0.16794109f, 0.01819205f, 0.04389115f, -0.11760981f, -0.25527155f, -0.15880893f, -0.03946536f, 
    -0.06624883f, 0.01190860f, -0.05243537f, -0.00754501f, -0.01641930f, -0.12373078f, 0.02827143f, -0.06202804f, 
    -0.02572215f, 0.04615530f, 0.24408911f, 0.28129837f, 0.03254192f, -0.04084586f, -0.04387323f, -0.03166126f, 
    -0.10243678f, -0.10417527f, 0.09982949f, 0.00870709f, 0.02926839f, 0.10974230f, 0.12760705f, 0.04831068f, 
    -0.06519920f, -0.18867917f, -0.12406600f, 0.02398377f, -0.01302212f, 0.09789057f, 0.20680273f, 0.15854380f, 
    -0.16293003f, 0.04371839f, 0.00789468f, 0.22873323f, 0.12361103f, -0.16270553f, -0.08662114f, 0.03180298f, 
    -0.04979110f, -0.08832857f, 0.05738587f, 0.03631781f, 0.09960424f, 0.37919158f, 0.15027942f, -0.08178648f, 
    -0.01432704f, -0.26094186f, -0.06142312f, -0.08721659f, 0.01913269f, -0.00964326f, -0.04404279f, -0.03298365f, 
    -0.11343515f, 0.35719734f, 0.13700996f, -0.08769170f, -0.06396876f, -0.12989123f, 0.16269505f, 0.01223967f, 
    -0.08579849f, 0.08581792f, -0.04599332f, 0.07515275f, -0.14370365f, -0.02531351f, 0.11776211f, 0.00594686f, 
    -0.01464645f, -0.01351587f, -0.06294662f, 0.15598221f, -0.00357428f, 0.04270530f, 0.11669611f, -0.08130036f, 
    0.08605438f, -0.04075965f, -0.10856511f, 0.01690795f, -0.03219508f, 0.01815626f, 0.18567201f, 0.14835565f, 
    0.12847510f, 0.14297056f, 0.04331641f, 0.02409208f, -0.14488013f, 0.08393634f, 0.14257541f, -0.03203793f, 
    0.12663130f, 0.06123549f, 0.05733399f, 0.02452769f, -0.02432488f, -0.01343711f, 0.03779342f, -0.00640780f, 
    -0.11450475f, 0.02545206f, -0.21554558f, -0.20525704f, 0.00065027f, 0.04025613f, 0.16334146f, -0.07648052f, 
    0.01614280f, 0.00749364f, 0.00331747f, 0.02171548f, 0.31871796f, 0.09280902f, -0.39296994f, 0.11903916f, 
    0.02053277f, 0.02706870f, 0.07029929f, 0.01886001f, 0.07673653f, 0.07314832f, 0.07631627f, -0.05311777f, 
    0.17074238f, 0.22493716f, -0.00825779f, 0.07657231f, 0.14757825f, 0.02863635f, -0.00699076f, 0.08957893f, 
    -0.01716514f, 0.00053068f, 0.17018422f, -0.02873494f, -0.09128987f, -0.49315020f, -0.10310362f, -0.09055955f, 
    0.13521993f, 0.18615125f, 0.13854526f, 0.12149449f, -0.00786647f, -0.05984907f, -0.01893540f, -0.05335740f, 
    0.09158140f, 0.01219926f, -0.07599897f, -0.09700695f, 0.07450804f, 0.17212427f, 0.25172344f, 0.05937728f, 
    -0.00265555f, 0.03910878f, -0.11586673f, -0.15357281f, -0.03870645f, -0.06145737f, -0.09939215f, -0.08532931f, 
    -0.01935662f, 0.10827118f, 0.24668491f, 0.05946624f, 0.09163877f, -0.05034260f, -0.04857135f, -0.02278284f, 
    -0.55980271f, 0.41336858f, -0.05665364f, 0.37081352f, 0.10404967f, 0.01940135f, -0.15244882f, -0.00891785f, 
    0.08429135f, 0.15217142f, -0.02340432f, 0.04484182f, -0.17298208f, 0.03388432f, 0.44854552f, 0.30363685f, 
    0.05221224f, -0.12407134f, -0.06377070f, -0.05407169f, -0.01666689f, -0.01674985f, -0.05459489f, 0.14551176f, 
    0.17012203f, -0.19638854f, -0.51474488f, 0.15058808f, 0.00635309f, 0.10488975f, 0.17894258f, 0.06319091f, 
    0.04974414f, 0.02604394f, -0.10219134f, 0.03970904f, -0.10222520f, -0.15237398f, -0.03050441f, -0.20118716f, 
    0.01670177f, 0.00404041f, -0.07447691f, 0.05056677f, 0.00042741f, -0.09743024f, -0.04641898f, -0.09202759f, 
    -0.18802570f, 0.12508096f, 0.18222354f, 0.12763365f, -0.09171449f, -0.04743867f, 0.07244355f, -0.01763046f, 
    0.06556120f, 0.10472361f, -0.02951450f, 0.03482381f, 0.17049430f, 0.25727764f, 0.03360886f, 0.08734128f, 
    -0.08511031f, -0.02198706f, -0.02460087f, -0.09505953f, 0.28118467f, -0.00140272f, 0.07762075f, 0.09397138f, 
    -0.12112713f, -0.04034126f, -0.08300196f, -0.06791583f, -0.08192925f, 0.11088323f, 0.13142213f, 0.03699699f, 
    0.02938962f, -0.09050176f, -0.06339061f, 0.07332478f, -0.00712368f, -0.15972841f, -0.04010793f, -0.06944219f, 
    -0.09101660f, -0.21914190f, 0.15711136f, 0.17231570f, 0.05860531f, 0.09622439f, 0.11293296f, -0.01346170f, 
    -0.20663370f, 0.06991482f, -0.04355073f, 0.27115336f, 0.05630971f, 0.20651647f, 0.00109625f, 0.09251171f, 
    -0.06480598f, -0.00033542f, -0.00041564f, 0.06910809f, -0.17351836f, 0.05957948f, 0.22591840f, 0.14589675f, 
    0.07520604f, -0.08154739f, -0.10851768f, -0.00464083f, -0.07305815f, 0.05017238f, -0.01184471f, 0.01323318f, 
    0.18981107f, 0.32382154f, 0.03362457f, -0.00129105f, -0.10978146f, -0.14469574f, -0.00144790f, -0.12561113f, 
    0.11118399f, 0.18283097f, 0.05117132f, -0.05719162f, -0.06729722f, -0.08220901f, -0.02282519f, 0.09817892f, 
    -0.05660579f, -0.03789325f, 0.08241644f, 0.00903284f, -0.01167009f, -0.05252416f, 0.08860534f, 0.03092592f, 
    -0.07561002f, -0.10627361f, -0.09446554f, 0.00496618f, -0.04605570f, 0.00983431f, 0.11829806f, -0.10469592f, 
    0.03459065f, 0.06850947f, -0.01487415f, -0.04886450f, -0.11320225f, 0.09716953f, 0.14412163f, -0.22796831f, 
    -0.01925094f, -0.06127045f, 0.02811231f, 0.10810838f, -0.05055301f, 0.10340016f, 0.02003852f, -0.04322115f, 
    -0.22558947f, -0.04203534f, -0.06746804f, 0.00661908f, -0.08937344f, 0.24169105f, -0.05604265f, -0.02710369f, 
    0.18349327f, 0.02242566f, 0.01696887f, 0.00218909f, -0.12487051f, 0.25520721f, 0.25120565f, 0.00380372f, 
    -0.02255806f, -0.10382297f, -0.20659821f, 0.05561582f, 0.03332566f, 0.00915737f, 0.01415235f, -0.03485459f, 
    -0.03501867f, -0.29295304f, -0.19292395f, -0.21959981f, -0.12020307f, -0.05346593f, -0.02351239f, 0.05990309f, 
    0.01322695f, -0.00174470f, -0.15792795f, 0.00552802f, -0.11224979f, 0.14568675f, 0.23199658f, -0.17837960f, 
    0.18648092f, 0.01543725f, 0.00263974f, 0.03430876f, 0.00603501f, 0.17415647f, -0.00068050f, 0.04061578f, 
    -0.17078380f, -0.01434808f, 0.08865591f, 0.03539110f, 0.01863225f, -0.07044347f, -0.08336797f, -0.03800479f, 
    0.08577670f, 0.07647368f, 0.09998012f, -0.00847884f, 0.23212753f, -0.06563968f, -0.09349951f, -0.04149856f, 
    -0.10036496f, -0.11208136f, 0.02865114f, -0.03647189f, -0.03208892f, 0.10161244f, -0.10152538f, 0.12548959f, 
    -0.39345777f, -0.18290460f, 0.06490598f, 0.06844752f, 0.06052172f, 0.02205168f, 0.02214140f, -0.03566500f, 
    -0.03914807f, 0.05257184f, 0.08869353f, 0.02796064f, 0.06212848f, -0.05503140f, -0.16047542f, 0.44443810f, 
    -0.09035620f, 0.20380536f, 0.09812581f, -0.10703557f, 0.06036812f, -0.06981877f, -0.11326901f, 0.01819794f, 
    0.01683410f, -0.08404680f, 0.19027308f, 0.24495037f, -0.01350076f, 0.26551202f, -0.02041135f, 0.04638489f, 
    0.02510004f, 0.01148300f, -0.08408495f, 0.03309981f, -0.36540365f, 0.43576938f, 0.01315507f, -0.06698397f, 
    0.01003766f, -0.02060326f, -0.06106693f, 0.00193689f, -0.05134227f, 0.16315095f, 0.08981895f, -0.02375680f, 
    -0.03636822f, -0.06192686f, 0.12512405f, -0.09593972f, 0.02627535f, 0.00907753f, 0.02486897f, 0.08069996f, 
    0.06156618f, -0.10255209f, 0.03928059f, 0.08404068f, -0.29173669f, -0.12975673f, -0.03169690f, -0.02208788f, 
    -0.07048286f, -0.05376969f, -0.03706355f, 0.07823426f, 0.00556770f, 0.03961672f, 0.07321374f, -0.02149364f, 
    -0.08013564f, -0.01015023f, 0.11357004f, -0.16191626f, 0.04107565f, -0.14928626f, -0.00631857f, -0.10091817f, 
    -0.04244923f, -0.02263092f, -0.02782907f, -0.01398818f, 0.04143734f, -0.26168081f, -0.06739172f, 0.16569728f, 
    0.21514142f, 0.15396480f, 0.18443009f, -0.22409694f, -0.01088492f, -0.03239954f, -0.00505249f, -0.08904123f, 
    -0.12836143f, -0.18443683f, 0.07404952f, -0.09530921f, 0.30044943f, 0.07736632f, -0.22643116f, 0.03805844f, 
    -0.16921306f, 0.04988870f, 0.11442714f, -0.01643870f, 0.02325153f, -0.01573341f, 0.02770458f, 0.00840201f, 
    -0.00103203f, -0.06768422f, -0.00081776f, -0.06424467f, 0.09263524f, 0.08230212f, 0.11674897f, 0.12544008f, 
    0.23716480f, 0.11132583f, -0.17451221f, -0.16817187f, -0.03470532f, -0.20709942f, 0.08607966f, -0.09741192f, 
    0.06276473f, -0.04792528f, 0.04292468f, -0.03274880f, -0.05403491f, 0.02984032f, 0.19673304f, -0.04433646f, 
    0.01884590f, 0.07393273f, -0.08371256f, 0.01171681f, -0.01554644f, 0.08587727f, 0.11099578f, 0.09723696f, 
    -0.23471051f, -0.19301312f, 0.08774345f, 0.06255968f, -0.00365251f, 0.07075539f, -0.01054533f, 0.12915972f, 
    0.02118660f, -0.01499399f, 0.09996095f, 0.04004632f, 0.18722829f, 0.14307615f, -0.07514614f, -0.03639049f, 
    0.00866446f, -0.00992829f, 0.14182705f, -0.00598114f, 0.16745581f, 0.05861401f, 0.11367972f, 0.01729640f, 
    0.11550887f, 0.09304217f, 0.01357210f, -0.09848139f, 0.12396280f, -0.00114997f, -0.04358720f, 0.19993274f, 
    0.01553678f, -0.00237082f, 0.13878046f, -0.06073967f, -0.14300567f, 0.26274058f, 0.11995929f, -0.05273651f, 
    -0.06370176f, -0.06060923f, 0.29043385f, -0.09265286f, 0.03986682f, 0.04358796f, -0.23334703f, 0.06518615f, 
    0.23767890f, 0.14022043f, 0.07235025f, -0.04302116f, -0.05350956f, 0.04543525f, 0.01611172f, -0.02717335f, 
    0.07021235f, 0.02546332f, 0.02586605f, 0.05079542f, -0.07353273f, 0.14290096f, -0.05912016f, -0.14945129f, 
    -0.07910512f, -0.08361573f, -0.08999533f, 0.17940076f, 0.07950675f, 0.14740425f, 0.06910715f, 0.00186704f, 
    -0.02872303f, -0.04007112f, -0.00632146f, -0.01768361f, -0.02437851f, 0.00055928f, 0.01058818f, -0.02496875f, 
    0.02370531f, 0.03317126f, -0.01653662f, -0.03199502f, -0.02504588f, 0.02282869f, -0.04157082f, 0.02129737f, 
    -0.01633825f, 0.02348346f, 0.04084019f, 0.01629567f, 0.02340485f, 0.00986178f, -0.03970258f, -0.02269663f, 
    0.02644380f, -0.00801345f, -0.00813232f, 0.00238020f, -0.03007973f, -0.01022622f, 0.00675284f, 0.01458558f, 
    0.00837773f, 0.02660832f, -0.00818913f, 0.01034898f, -0.02480324f, 0.02404535f, -0.01460424f, 0.01934545f, 
    0.00641182f, -0.03233770f, -0.00108183f, 0.02282396f, -0.03351295f, 0.00637351f, -0.03238291f, -0.01762128f, 
    -0.01962671f, -0.00051774f, 0.01057019f, -0.01015816f, 0.00250945f, -0.00520649f, -0.00428405f, 0.01823810f, 
    -0.02806096f, 0.04190877f, 0.02214372f, -0.02203955f, -0.01153731f, -0.00480663f, -0.01866060f, -0.01475807f, 
    -0.03872302f, -0.00729502f, 0.03690506f, 0.01407237f, 0.00869637f, -0.00360880f, -0.02601421f, -0.00558399f, 
    -0.00173188f, 0.02613516f, 0.02448872f, 0.02630469f, 0.02476519f, -0.01885070f, -0.02736813f, -0.01671645f, 
    0.02344032f, -0.00542868f, 0.02569806f, -0.04004018f, 0.00662812f, -0.03723530f, -0.00777972f, 0.02542020f, 
    -0.03086887f, 0.01067987f, -0.00013827f, -0.00930267f, 0.01945588f, 0.02916432f, 0.02936461f, -0.02318529f, 
    -0.02684204f, -0.02412740f, -0.01724890f, -0.03732711f, 0.00855957f, 0.02648553f, -0.04124089f, -0.03320435f, 
    -0.00721537f, 0.01353089f, 0.03392377f, -0.03828106f, -0.00880354f, -0.03091100f, -0.00661062f, 0.02788485f, 
    -0.00030466f, 0.01466200f, 0.02931122f, -0.01147114f, -0.01119574f, -0.02145581f, -0.03664165f, 0.01340790f, 
    0.02493843f, -0.02414962f, 0.00517174f, -0.03417067f, -0.01181961f, 0.01808219f, 0.00891236f, 0.01470423f, 
    0.03514431f, 0.02048294f, -0.03547248f, 0.02259297f, 0.02666885f, -0.03718907f, -0.02671106f, 0.02427221f, 
    -0.01085992f, -0.00196061f, -0.02263128f, 0.00384894f, 0.00710371f, 0.02499219f, 0.02234657f, -0.00900212f, 
    -0.00906637f, -0.02754467f, 0.04334053f, 0.02738677f, -0.01348076f, 0.02511132f, 0.00932126f, 0.00954036f, 
    -0.02364188f, -0.03250019f, 0.02535464f, 0.03662027f, -0.00659652f, -0.03079402f, -0.04133585f, -0.00932551f, 
    0.00982133f, -0.02024840f, 0.01495790f, 0.03035458f, -0.00002510f, 0.00930970f, -0.00490142f, -0.01764016f, 
    -0.02404835f, -0.01759079f, 0.03478346f, -0.00577762f, -0.03591426f, 0.02459490f, -0.02823072f, -0.02449454f, 
    -0.00700370f, 0.02336180f, -0.01490942f, -0.00618221f, -0.03296090f, -0.02733785f, -0.00988417f, 0.01294155f, 
    -0.01580592f, 0.02426415f, 0.00825146f, 0.00387308f, 0.01982410f, 0.02219037f, 0.03068436f, -0.04251674f, 
    0.02695253f, 0.03131387f, -0.02308944f, -0.00592319f, -0.02747114f, 0.00412152f, 0.02318577f, -0.01926732f, 
    -0.00094245f, 0.01805515f, -0.04244388f, -0.00074133f, -0.01251998f, -0.03994732f, -0.03244698f, -0.00853327f, 
    -0.02235370f, -0.01492780f, 0.00707405f, 0.00587452f, 0.01160902f, 0.01286849f, 0.01198268f, -0.00928547f, 
    -0.02777650f, 0.00841543f, -0.04057863f, -0.00615167f, -0.01003638f, 0.02279728f, 0.01436971f, -0.03966149f, 
    0.00990973f, 0.02647033f, 0.02256019f, 0.01662482f, 0.01968230f, -0.00173155f, -0.00231766f, -0.02162432f, 
    0.00961087f, 0.00319723f, 0.01986213f, -0.01154419f, -0.00418261f, 0.02902103f, 0.02903414f, -0.03036211f, 
    -0.02045557f, 0.01975706f, -0.00297634f, 0.01491781f, 0.00802885f, 0.00890572f, -0.03263524f, -0.02235901f, 
    0.02481169f, 0.02010608f, 0.00220353f, -0.00143195f, -0.03103646f, -0.02931393f, -0.00666809f, -0.02129120f, 
    -0.00113136f, -0.03154776f, -0.03853423f, -0.00637571f, 0.00052229f, -0.03075901f, -0.03455983f, -0.00351375f, 
    0.00248440f, -0.01454019f, 0.01053406f, -0.01399323f, -0.00112912f, -0.03559170f, -0.00072796f, -0.00432804f, 
    -0.00170674f, -0.02325497f, -0.00282979f, 0.00499704f, -0.02394626f, -0.01708344f, 0.03554911f, -0.03783371f, 
    -0.02553749f, 0.02873536f, 0.00058538f, 0.00703176f, -0.01880584f, -0.02780435f, -0.01583801f, -0.03453018f, 
    -0.00149025f, 0.00406548f, -0.02474683f, 0.02643215f, 0.01705724f, 0.02458167f, 0.01887383f, 0.01653753f, 
    -0.00044271f, 0.01906013f, -0.00445744f, -0.03296231f, -0.02509844f, -0.01756721f, 0.00006069f, 0.01416147f, 
    0.00141876f, 0.00602651f, 0.01473936f, 0.00742479f, -0.03247279f, 0.02292956f, -0.02289606f, -0.02932569f, 
    -0.01042785f, -0.02097582f, -0.00180425f, -0.02827558f, 0.00317190f, 0.03799352f, 0.03535030f, 0.02970065f, 
    -0.02691682f, -0.00155307f, 0.02826774f, -0.02557464f, -0.02290934f, 0.02845818f, 0.01702431f, 0.00613493f, 
    0.02179087f, 0.02684708f, -0.03032899f, -0.03699483f, -0.00087011f, -0.03224757f, -0.02764100f, 0.01633490f, 
    0.02451431f, 0.02613516f, 0.02169861f, 0.02533439f, -0.02751066f, 0.00357328f, 0.00302550f, -0.01164437f, 
    -0.04034797f, -0.00250601f, 0.01641533f, -0.04219060f, -0.00285088f, -0.01116933f, 0.02050949f, -0.04310886f, 
    0.01436509f, 0.03159137f, 0.02310130f, -0.02896802f, -0.01187988f, -0.04056844f, -0.00192204f, -0.00009229f, 
    0.02604241f, -0.01549362f, -0.01218639f, 0.01390547f, -0.00215319f, -0.02091949f, -0.02224271f, -0.00474649f, 
    -0.02940480f, 0.02935894f, -0.02175191f, 0.00806167f, -0.03076958f, -0.03707983f, -0.00037951f, -0.01659346f, 
    0.01641035f, -0.01726876f, -0.00416659f, -0.01156093f, -0.03284288f, 0.02432015f, -0.01124133f, -0.03159568f, 
    0.01439726f, 0.01020265f, 0.02710645f, -0.00442581f, -0.00838665f, 0.02013576f, 0.00552015f, 0.04001439f, 
    0.02954012f, -0.03087716f, -0.01501583f, -0.00465691f, -0.01900209f, 0.01989221f, -0.01909665f, -0.02123417f, 
    -0.02590780f, -0.00517837f, -0.03766542f, -0.00648477f, -0.02539638f, -0.03158586f, -0.02427353f, 0.02956385f, 
    -0.02818073f, -0.02795921f, 0.04128273f, 0.00249246f, -0.01053323f, -0.04109640f, -0.02776511f, -0.01308562f, 
    -0.02133556f, -0.01729685f, 0.03022958f, 0.01246467f, 0.00929491f, 0.01543440f, 0.02416283f, 0.01497716f, 
    0.00947021f, -0.02605165f, -0.04092627f, 0.01984295f, -0.01525413f, -0.01378033f, -0.01750132f, 0.03050397f, 
    0.00889325f, 0.00223161f, -0.01002722f, -0.02931503f, 0.02165786f, 0.00544609f, -0.02625480f, 0.03256427f, 
    0.02122387f, -0.01881303f, -0.01546854f, -0.00614678f, 0.00609266f, 0.01530158f, -0.00871608f, 0.02033749f, 
    0.01243482f, 0.00551074f, -0.00747271f, -0.02534269f, 0.01136493f, 0.01004665f, 0.02630376f, -0.02229296f, 
    -0.03540511f, -0.01801864f, -0.01062981f, 0.02250319f, 0.00401682f, -0.02324504f, 0.00027595f, -0.01296221f, 
    0.01804230f, -0.03015093f, 0.01497112f, -0.02772447f, 0.02927154f, 0.01229643f, -0.01912707f, -0.01437719f, 
    0.01044712f, 0.00571019f, 0.04301665f, 0.02956793f, 0.02229753f, -0.01868592f, -0.03463685f, -0.00105078f, 
    -0.00888598f, 0.00982363f, -0.03681756f, 0.02961640f, -0.01601024f, -0.01527122f, 0.02430604f, -0.00660307f, 
    -0.01784270f, 0.00288324f, -0.01404660f, 0.02317754f, 0.02841234f, -0.00168410f, -0.00790541f, -0.00176740f, 
    -0.00683231f, 0.01227027f, -0.01211507f, 0.02408896f, -0.01038451f, -0.02337651f, -0.01038288f, -0.00158032f, 
    0.01896705f, -0.02325772f, 0.01370879f, 0.00737745f, 0.01653268f, -0.02767755f, 0.00034461f, -0.02898816f, 
    -0.03029501f, 0.03484181f, -0.01015027f, 0.00933740f, -0.01747051f, -0.01462639f, -0.02882016f, 0.01518015f, 
    -0.00404382f, -0.01017295f, -0.02918260f, -0.01795535f, -0.01318988f, -0.00278729f, 0.00272885f, 0.02240374f, 
    0.01518077f, 0.01373301f, -0.00585428f, -0.00787238f, 0.02257387f, 0.02298415f, -0.02576506f, -0.01338914f, 
    -0.00195179f, 0.00855544f, -0.00529305f, -0.03946833f, 0.01655779f, -0.03565783f, -0.03375285f, -0.02446785f, 
    0.02189464f, 0.03553064f, -0.01381519f, -0.01989179f, 0.00476879f, 0.02538290f, 0.01201081f, 0.01722924f, 
    -0.03321869f, -0.03929134f, 0.00482523f, -0.01401239f, -0.03342849f, -0.03651435f, -0.00388242f, 0.03348044f, 
    -0.02765355f, 0.02745269f, -0.02689142f, -0.01027485f, -0.03038320f, -0.01247115f, -0.04067028f, 0.00430857f, 
    -0.00780416f, 0.02961530f, -0.00084045f, 0.01181007f, 0.00148269f, -0.03947631f, 0.00199537f, 0.02036602f, 
    0.00687459f, -0.03341417f, -0.01358458f, 0.01701762f, -0.00450238f, 0.01418754f, 0.03655009f, -0.00072795f, 
    0.00557790f, 0.03894682f, 0.00584898f, -0.02288951f, 0.00653722f, -0.01057979f, -0.02052106f, -0.01762666f, 
    -0.01954181f, -0.02405554f, -0.03770321f, 0.00717707f, 0.01590699f, 0.01276484f, 0.01385192f, 0.02083925f, 
    0.01549007f, -0.02071990f, 0.01776852f, 0.01181234f, 0.01731618f, -0.03016099f, 0.01663702f, 0.01977727f, 
    -0.03126241f, 0.03813858f, 0.02554915f, -0.01202190f, -0.03595266f, 0.02770540f, -0.00593385f, 0.01466792f, 
    -0.01395963f, 0.02136878f, 0.00407607f, 0.01403256f, 0.00434692f, 0.03345958f, -0.00103486f, 0.02907784f, 
    0.02416177f, -0.02022761f, 0.02199750f, -0.02509781f, 0.01627780f, 0.01449894f, -0.01164819f, -0.01606035f, 
    -0.03032166f, 0.04020131f, -0.01440657f, -0.01349414f, -0.00310964f, 0.01503572f, -0.02834320f, -0.02632227f, 
    -0.00577667f, -0.01653690f, 0.02847763f, 0.00108221f, -0.03635123f, -0.02806189f, 0.00146435f, 0.00613238f, 
    -0.03027336f, 0.02853309f, 0.01111066f, -0.02019851f, 0.01224362f, -0.03962690f, -0.02542561f, 0.02199671f, 
    0.00331734f, -0.03238165f, 0.02983527f, -0.00207773f, -0.02458970f, -0.04046312f, 0.00073087f, -0.01213279f, 
    0.01630540f, 0.00919132f, 0.02130519f, -0.01665505f, 0.01300239f, 0.01008937f, -0.01694308f, -0.03954037f, 
    -0.02976360f, -0.00921403f, -0.01565531f, -0.03210444f, 0.02562711f, -0.01792796f, 0.00012830f, 0.02695337f, 
    -0.02526919f, -0.00675616f, 0.01113191f, 0.02383755f, -0.03969027f, -0.03193863f, -0.01869539f, -0.04074349f, 
    0.01168656f, 0.02742002f, 0.04020761f, -0.03698421f, -0.03607597f, -0.00689954f, -0.04060316f, 0.01113158f, 
    -0.03788300f, 0.02881138f, -0.00049031f, -0.00371874f, -0.02621448f, -0.02556813f, -0.00586702f, -0.02557873f, 
    -0.02383371f, -0.00014507f, -0.03498385f, -0.01151472f, -0.02268815f, -0.02590678f, -0.00566560f, -0.04050905f, 
    0.00381189f, 0.01938917f, 0.00886990f, -0.00362149f, 0.00109514f, 0.02564150f, -0.00639584f, -0.02626942f, 
    0.00871355f, -0.01224617f, -0.01733989f, -0.01529482f, -0.00033601f, -0.00677982f, 0.00849328f, 0.00874569f, 
    0.02356501f, 0.00083800f, -0.03307546f, -0.01301551f, -0.03274081f, 0.00300526f, 0.01343398f, -0.00234370f, 
    -0.01091563f, 0.03068277f, 0.02260451f, -0.01457085f, -0.01113635f, -0.01407082f, 0.01040396f, -0.02239616f, 
    0.01609088f, 0.02741557f, 0.00935692f, -0.02359809f, -0.02139846f, -0.01848535f, -0.00455522f, 0.00888297f, 
    -0.03209034f, 0.02502043f, -0.00682133f, -0.01087807f, -0.00192466f, -0.02182189f, -0.01720127f, 0.01845844f, 
    -0.03582589f, 0.00375314f, -0.01753610f, -0.02698367f, 0.03521185f, -0.01626464f, -0.00897877f, 0.02318645f, 
    -0.38180867f, 0.12171906f, -0.05809056f, -0.12013716f, 0.14861251f, 0.05156156f, 0.02882068f, -0.07985730f, 
    -0.03290576f, -0.07026681f, 0.07859430f, -0.07231247f, -0.11526778f, -0.08799037f, -0.17223978f, -0.01556913f, 
    0.05467012f, -0.05409586f, -0.04029181f, -0.01975688f, -0.04725621f, -0.05911687f, 0.03052920f, 0.00695630f, 
    -0.00951765f, 0.13566068f, 0.00077893f, 0.05080896f, -0.01826989f, 0.14448598f, 0.01909919f, -0.06471167f, 
    -0.03671926f, -0.09190006f, 0.01736381f, 0.06100686f, 0.20765181f, -0.00652501f, -0.10463362f, -0.18388537f, 
    -0.09280825f, -0.03347670f, 0.16815576f, -0.05962049f, -0.16944058f, -0.06001761f, -0.01154988f, -0.01173570f, 
    0.11063512f, 0.05492451f, 0.27942875f, -0.01704059f, 0.01128264f, 0.04051726f, 0.01521689f, 0.06551448f, 
    -0.12902282f, -0.06530917f, -0.19064969f, -0.08736251f, -0.37038362f, 0.23973298f, -0.26501969f, 0.17721806f, 
    0.08963389f, 0.07430688f, -0.06168868f, -0.08197222f, -0.05207535f, 0.07517981f, 0.08105589f, -0.08521406f, 
    0.07157838f, -0.01180836f, 0.00254233f, -0.09398714f, 0.00185717f, 0.02909275f, -0.01747152f, 0.03824436f, 
    0.04282540f, -0.06061012f, 0.06936116f, 0.19102372f, -0.04665681f, -0.02176612f, 0.02988515f, 0.02704653f, 
    0.13889280f, -0.03158451f, -0.07127044f, -0.10027970f, -0.25538823f, -0.09351710f, -0.19952610f, -0.10311177f, 
    -0.13554609f, -0.12595271f, 0.03045120f, -0.07839149f, -0.02855622f, -0.23413081f, -0.00873417f, -0.01562015f, 
    0.09880923f, -0.01519036f, 0.11846757f, 0.14890535f, 0.01410353f, 0.01273435f, -0.08209638f, -0.02155304f, 
    0.04511613f, -0.03714525f, -0.00774199f, -0.05768209f, -0.00414911f, -0.04126967f, -0.06728686f, 0.08339810f, 
    -0.29616928f, 0.00649774f, -0.17211038f, -0.03851686f, 0.11064526f, -0.00307068f, -0.06498846f, -0.00609420f, 
    0.10536086f, -0.28981236f, -0.13766123f, -0.19268912f, -0.23751943f, 0.04600230f, -0.03077661f, -0.00339137f, 
    0.09997823f, -0.06025514f, -0.13659674f, -0.04448109f, 0.00715256f, -0.25021607f, 0.01826517f, -0.05625283f, 
    0.32181570f, -0.15445139f, 0.02615361f, 0.07064238f, 0.12239519f, -0.08413826f, 0.08827753f, -0.07355162f, 
    0.26059246f, 0.02782205f, 0.21653162f, -0.05388141f, 0.14319956f, -0.09328843f, 0.04113990f, 0.28435722f, 
    -0.01635065f, 0.05039001f, 0.09249729f, 0.24715054f, 0.03622798f, 0.16822617f, 0.18249907f, 0.13600239f, 
    0.06046258f, -0.15932840f, 0.13946012f, -0.10433173f, 0.05871440f, -0.03871846f, -0.01407922f, -0.05439818f, 
    0.02008257f, 0.01009989f, -0.12279574f, -0.02816358f, -0.02506797f, -0.15572198f, 0.03716950f, 0.18954812f, 
    0.04797980f, 0.08580738f, 0.04596967f, -0.05092481f, 0.15354839f, -0.08810320f, -0.08391137f, -0.00624160f, 
    -0.36696908f, 0.02456586f, -0.06064691f, 0.04225277f, -0.03467856f, 0.03439172f, -0.04974684f, -0.07947549f, 
    -0.00105416f, 0.08369706f, -0.17515682f, 0.11554098f, 0.14303473f, -0.02126959f, -0.04563723f, -0.06300545f, 
    -0.02644086f, 0.04302784f, 0.09741192f, -0.05746892f, 0.05718246f, -0.01495333f, -0.21595289f, -0.12381213f, 
    0.16911794f, 0.00692548f, 0.10328422f, 0.01343575f, 0.06432847f, 0.04519571f, -0.14684114f, 0.07926399f, 
    0.06383454f, 0.06925762f, -0.01848873f, 0.15368785f, 0.01842842f, 0.08853806f, -0.05354789f, -0.10607366f, 
    0.14010361f, 0.02600878f, 0.15735853f, 0.18086389f, -0.07128704f, -0.05226302f, 0.09266882f, -0.08663794f, 
    0.06087477f, -0.09399615f, 0.00145206f, -0.18319911f, 0.14191641f, 0.09210141f, 0.18729635f, 0.04667746f, 
    -0.06520080f, -0.11317617f, 0.10065074f, -0.10194772f, -0.30160436f, -0.11946052f, 0.08417499f, 0.13402069f, 
    0.10105944f, 0.13744748f, -0.22814067f, 0.08643826f, 0.08987606f, -0.02182302f, 0.17825173f, -0.03862032f, 
    0.02943598f, -0.01020351f, 0.06627620f, 0.22891526f, 0.00602875f, 0.14436419f, -0.11076160f, 0.05615354f, 
    -0.05842839f, -0.16357586f, 0.16565603f, -0.10745084f, -0.24480790f, 0.37405676f, 0.33614048f, 0.23658584f, 
    0.20097238f, -0.10196033f, -0.10502420f, 0.13454409f, -0.16821593f, 0.01971461f, -0.04032364f, -0.15370654f, 
    -0.28144968f, -0.01551314f, 0.04069126f, 0.12703620f, 0.06212213f, 0.05312284f, -0.17998171f, 0.12662788f, 
    0.22854762f, 0.13235989f, -0.00908265f, 0.02803139f, -0.14307047f, 0.17726052f, 0.10795466f, 0.07103152f, 
    0.04486851f, 0.07519612f, 0.00083222f, -0.05642555f, -0.02374466f, -0.13806164f, -0.32623121f, -0.12482157f, 
    0.24945524f, -0.06252078f, 0.06282512f, 0.04009286f, -0.02151403f, -0.14937654f, -0.02868439f, -0.02453092f, 
    0.12078425f, 0.12912579f, 0.01935131f, 0.17273013f, -0.03342409f, 0.02462118f, 0.03580419f, -0.05695377f, 
    -0.00477783f, 0.05163687f, 0.03336319f, -0.03609533f, 0.02960400f, -0.01615655f, 0.07647854f, -0.08543155f, 
    -0.09791022f, -0.05856958f, 0.31834820f, 0.06205332f, 0.04772666f, -0.03337494f, -0.20095257f, 0.06318446f, 
    -0.00702601f, 0.01841668f, -0.04542615f, 0.00917935f, -0.09321127f, 0.19840044f, 0.03375809f, -0.16175732f, 
    0.01301680f, -0.14339197f, 0.00101370f, 0.18517655f, -0.01465407f, -0.02022338f, 0.10941543f, -0.03888174f, 
    0.06880414f, 0.00424073f, -0.18860434f, 0.05510711f, -0.06564842f, -0.03893535f, 0.07885722f, -0.01408238f, 
    -0.17006654f, -0.02335891f, -0.10113442f, 0.11518271f, 0.20011419f, -0.13000065f, 0.01092810f, 0.24144991f, 
    -0.14758812f, 0.11002345f, 0.22109844f, 0.05797808f, 0.25024804f, -0.01503209f, -0.10944214f, 0.30798888f, 
    -0.25757831f, 0.20533058f, 0.32720912f, 0.20643708f, -0.04361031f, -0.16221637f, -0.11289602f, 0.10593654f, 
    0.07405276f, 0.09699687f, 0.03148162f, 0.18948430f, 0.06018624f, 0.03897061f, 0.04909349f, 0.12624012f, 
    0.07234941f, -0.04285803f, 0.14268082f, 0.09646089f, -0.06284938f, -0.03229501f, 0.12122894f, 0.05063600f, 
    0.16710235f, -0.08453613f, 0.21062405f, -0.06646477f, 0.03824934f, 0.06695198f, -0.06835709f, -0.12440772f, 
    -0.11894920f, -0.15265927f, -0.06966033f, -0.19425568f, 0.12308975f, -0.02075340f, -0.21339048f, -0.10390314f, 
    -0.05642417f, 0.07103934f, -0.02701599f, 0.16083866f, -0.04457974f, 0.10216999f, 0.01412739f, -0.01885438f, 
    -0.33437264f, -0.01531885f, -0.24531415f, 0.11710494f, -0.05222471f, 0.21286318f, -0.16773289f, -0.09343394f, 
    0.06562147f, -0.01988498f, 0.00103165f, 0.06805584f, -0.36356288f, 0.01459142f, -0.12246536f, 0.12610079f, 
    -0.01886402f, 0.14702342f, -0.32504842f, -0.05833973f, 0.00727515f, -0.06228868f, -0.05198329f, 0.04703887f, 
    0.03356175f, 0.14370605f, 0.18015681f, 0.09151912f, 0.07216945f, -0.00014052f, -0.04983501f, 0.08403154f, 
    0.09648822f, 0.02097582f, 0.05355815f, 0.00419437f, -0.32423738f, 0.34213954f, -0.11092811f, 0.17355631f, 
    0.18623312f, 0.01714555f, -0.16852415f, -0.01259510f, -0.00114155f, 0.00259708f, 0.06295536f, -0.02759711f, 
    0.08820204f, 0.20209336f, 0.06608221f, 0.06337650f, -0.00705130f, 0.02897924f, -0.05883676f, 0.04479634f, 
    0.02126530f, -0.09390894f, 0.00831614f, 0.09922633f, -0.13111317f, -0.03918517f, 0.14163828f, 0.09588498f, 
    -0.10624570f, 0.00931740f, 0.04304517f, -0.02935849f, -0.01827657f, -0.03580419f, -0.11829308f, 0.10083237f, 
    -0.42294058f, -0.23941600f, -0.06331185f, 0.10209475f, 0.26128453f, -0.15887834f, 0.00789890f, -0.08035100f, 
    -0.13488330f, -0.06801889f, -0.04171477f, 0.06211778f, -0.44165963f, 0.21570665f, -0.10910163f, 0.01538355f, 
    0.00603891f, -0.02612089f, -0.08198272f, 0.08210571f, -0.02450982f, 0.06125608f, 0.08956711f, 0.08232930f, 
    0.18336767f, 0.15148896f, 0.00422577f, 0.03183259f, 0.05465965f, -0.03059906f, 0.01798233f, -0.10674179f, 
    0.12394149f, 0.03238189f, 0.09472827f, 0.14633900f, -0.40852767f, 0.13470957f, -0.20522910f, 0.15920301f, 
    0.31952983f, 0.19884942f, -0.08847248f, -0.11536918f, -0.02963666f, -0.10791124f, 0.11974440f, -0.08089688f, 
    0.12302873f, -0.11197059f, 0.22476633f, -0.03452280f, -0.06165711f, 0.14423031f, 0.00186918f, -0.01677379f, 
    0.09297694f, -0.05742803f, -0.00698150f, 0.10125733f, 0.33669215f, 0.16996354f, 0.52396584f, 0.43489036f, 
    0.04956077f, -0.05200917f, 0.00928573f, -0.08263527f, 0.00017000f, 0.00666829f, 0.02231493f, 0.19561803f, 
    0.36766738f, 0.04059886f, 0.14329848f, -0.08101826f, 0.08138366f, 0.00957485f, -0.03994141f, -0.10700434f, 
    0.12295949f, -0.12079009f, -0.18553384f, 0.07914323f, 0.02992478f, -0.21690483f, -0.01161264f, -0.25228637f, 
    0.03330333f, -0.00201061f, 0.04121634f, 0.00331283f, -0.01362557f, 0.16501452f, 0.03997156f, 0.06031582f, 
    0.16712025f, 0.35139415f, -0.09737166f, -0.11561482f, 0.04424303f, -0.04612820f, 0.08314557f, 0.05263706f, 
    0.01508147f, -0.10668769f, 0.16369188f, 0.13803312f, -0.07700670f, 0.04074680f, -0.04469251f, 0.04213316f, 
    -0.00530358f, -0.04340864f, 0.07263745f, 0.11796070f, -0.01035271f, 0.03641742f, 0.03542978f, 0.14153488f, 
    0.36649409f, -0.00570075f, -0.16219805f, -0.10293514f, 0.06858912f, 0.01106845f, 0.11344033f, 0.08702470f, 
    0.10548398f, -0.00605501f, -0.09488408f, -0.13064604f, -0.07407372f, 0.07812585f, 0.02426411f, 0.08491245f, 
    -0.00516540f, -0.08590669f, -0.09769325f, -0.14456309f, 0.07394184f, 0.06606179f, 0.01442023f, -0.10626546f, 
    0.12532422f, 0.04721265f, -0.02002556f, 0.00391927f, 0.06146882f, 0.00040823f, 0.03094206f, -0.11442363f, 
    0.01777093f, 0.02429554f, 0.01398672f, -0.01696400f, -0.01632394f, -0.22777173f, -0.18298481f, 0.13461226f, 
    -0.00213157f, -0.11917555f, -0.04616914f, -0.04293417f, 0.12397775f, 0.03225988f, 0.20586614f, 0.10484997f, 
    -0.35677406f, -0.07332300f, 0.01500714f, 0.09155068f, 0.04624959f, 0.04272136f, -0.01637652f, 0.08976782f, 
    0.11964463f, -0.12086251f, 0.09506141f, 0.08552140f, -0.20759985f, -0.14001967f, -0.14620966f, -0.09442416f, 
    -0.05536054f, -0.05357565f, -0.07553070f, -0.02013249f, 0.02409984f, -0.22089039f, 0.18692854f, -0.22732517f, 
    0.20939833f, -0.03179953f, 0.08418366f, -0.10331590f, 0.05459561f, 0.08385929f, -0.06551959f, 0.10092103f, 
    0.06689397f, -0.12401428f, 0.04568559f, 0.03324791f, -0.13681445f, -0.04972955f, -0.04485175f, 0.10287610f, 
    -0.01680497f, 0.00446144f, -0.00688345f, -0.01733746f, 0.27160427f, 0.03405612f, 0.04943669f, 0.28684935f, 
    -0.44709113f, 0.12643111f, 0.04665774f, 0.03111886f, -0.02248514f, 0.00693309f, -0.07356288f, 0.19987950f, 
    -0.03520304f, 0.08587903f, 0.15044436f, 0.01392189f, -0.69378805f, 0.27548376f, -0.10787272f, 0.48798689f, 
    0.08240580f, -0.06732140f, -0.12520218f, -0.27155742f, -0.04102327f, 0.03317779f, 0.02529345f, -0.01554778f, 
    0.09295072f, -0.10946923f, -0.10639439f, 0.09254512f, -0.07552887f, -0.03107761f, -0.10014010f, -0.07552481f, 
    0.10236867f, -0.11202931f, -0.18933992f, 0.01869909f, -0.16984285f, 0.07673597f, -0.06854440f, 0.06712080f, 
    0.09647784f, 0.09190499f, 0.13837561f, 0.01919342f, -0.00724701f, 0.09603569f, 0.11952032f, 0.24854836f, 
    -0.11145641f, 0.05948324f, -0.20330119f, 0.27756214f, -0.06874559f, -0.06607729f, -0.00885080f, -0.06860635f, 
    -0.08506937f, -0.05429446f, -0.01245536f, -0.14314625f, 0.08777588f, -0.01931022f, -0.19193886f, -0.00657580f, 
    0.03297716f, -0.12237439f, -0.22780417f, -0.06661377f, -0.09220389f, -0.02146362f, 0.12229012f, -0.03423729f, 
    0.46844780f, -0.29298738f, -0.01809323f, -0.16229695f, -0.09072426f, 0.08282909f, 0.12998021f, -0.05513819f, 
    -0.03459587f, 0.01065822f, 0.06751066f, 0.04421076f, -0.15429533f, 0.09164036f, 0.14291228f, 0.15833504f, 
    0.03447191f, 0.00957278f, -0.10190631f, 0.05124018f, -0.00529960f, 0.10947664f, -0.10963856f, -0.14826803f, 
    -0.10748797f, -0.04336993f, -0.02030169f, 0.15925570f, 0.02240676f, 0.05899775f, -0.04443493f, 0.07293697f, 
    -0.19891083f, -0.03077308f, -0.14294228f, -0.17718343f, 0.17808215f, 0.23561130f, -0.02509595f, 0.30132681f, 
    -0.04703235f, 0.03822666f, -0.03243949f, 0.06036671f, -0.00847616f, 0.04314795f, 0.20687470f, 0.06042653f, 
    -0.23603058f, 0.03760331f, 0.17826335f, 0.20020843f, -0.06971021f, -0.06150147f, 0.00489015f, 0.01147821f, 
    0.09795772f, 0.09978770f, 0.03156431f, 0.12362205f, -0.03206268f, 0.03454129f, -0.21888068f, 0.19089539f, 
    0.05582159f, -0.09175331f, 0.08255810f, -0.08083177f, -0.21086183f, 0.02206380f, -0.03754145f, -0.18664227f, 
    0.14814295f, -0.02964327f, -0.05285706f, -0.20801271f, 0.01454215f, -0.01905588f, 0.01165284f, -0.08180652f, 
    0.13476124f, 0.10393137f, 0.01632018f, 0.02866086f, -0.05716380f, -0.18996365f, 0.05982465f, 0.19747892f, 
    0.00607859f, -0.14475569f, -0.12484997f, -0.05255533f, -0.06488762f, -0.00579869f, -0.01977597f, -0.07665966f, 
    0.09667438f, 0.00765526f, -0.19072533f, -0.04945042f, -0.02876268f, -0.00042204f, -0.08868586f, 0.08564737f, 
    -0.12694243f, -0.05680307f, 0.04061299f, -0.15273917f, -0.00962351f, 0.10563408f, -0.12119712f, -0.15836060f, 
    -0.04713816f, -0.09458300f, 0.01197715f, -0.01834798f, -0.10437036f, -0.21642180f, -0.17365566f, -0.13223705f, 
    0.20767225f, 0.10113470f, 0.05823641f, 0.04801126f, 0.02574018f, -0.07994415f, 0.11399057f, -0.04082570f, 
    0.12198920f, 0.08153905f, -0.09527960f, -0.01424550f, 0.50755185f, 0.13141617f, 0.01832065f, 0.20621510f, 
    0.03125452f, 0.03643608f, 0.08617359f, -0.02940427f, 0.08638258f, 0.07644501f, 0.00080559f, 0.11303840f, 
    -0.22288546f, 0.13498183f, -0.02456263f, 0.26301715f, -0.02173581f, -0.08730675f, -0.12555222f, 0.11127210f, 
    0.02005229f, 0.00890757f, 0.17127103f, -0.19861740f, -0.06113907f, 0.07557935f, 0.23168187f, 0.08354414f, 
    -0.06712510f, 0.08998573f, 0.09523116f, 0.02603449f, -0.05885203f, 0.02352372f, 0.03158557f, 0.15675442f, 
    -0.26811188f, 0.22346714f, 0.02403680f, 0.34598202f, 0.07945301f, -0.10912529f, 0.07441621f, -0.10217081f, 
    -0.12717724f, 0.13644542f, -0.16174951f, 0.11967570f, 0.05651887f, -0.04248584f, -0.07989087f, 0.03487879f, 
    0.10317826f, -0.04945049f, -0.04357619f, 0.04906137f, -0.05467770f, -0.09611136f, -0.12636952f, -0.16025081f, 
    0.21361004f, -0.02194007f, -0.04415228f, -0.03346521f, -0.04875479f, 0.09991588f, -0.01075994f, -0.08114415f, 
    0.07443351f, 0.21749873f, -0.00476315f, 0.18340658f, -0.18003394f, -0.05671342f, 0.09826686f, 0.04377318f, 
    0.08688359f, 0.04092159f, 0.03366240f, -0.17135899f, 0.04903989f, -0.03443391f, -0.09141645f, -0.10824206f, 
    -0.06128206f, -0.20488185f, 0.07614447f, 0.10994761f, -0.04096451f, 0.00662399f, -0.08865830f, -0.04850582f, 
    0.05878721f, -0.05982848f, -0.12368647f, -0.14754547f, 0.08195164f, -0.20387037f, 0.27966574f, 0.06345922f, 
    -0.05466631f, -0.03013071f, -0.02695693f, 0.03462040f, -0.04865596f, 0.00913977f, 0.01967565f, -0.06553211f, 
    0.14696015f, -0.03352273f, -0.06837716f, -0.20532504f, -0.15415354f, 0.01126413f, -0.01714368f, 0.04615947f, 
    0.10031149f, 0.18659876f, 0.11907110f, -0.09927845f, -0.08210913f, 0.34672204f, 0.35427871f, 0.24803582f, 
    0.04415939f, 0.04246967f, 0.15544844f, 0.04532024f, -0.14684393f, 0.08920781f, -0.14492062f, -0.04101475f, 
    -0.15661319f, 0.14202948f, 0.19432390f, 0.12510063f, 0.09689079f, 0.00610336f, 0.01045056f, 0.01653256f, 
    0.17428057f, 0.06618191f, 0.04827874f, 0.15365379f, 0.06394855f, -0.00750613f, -0.03663327f, -0.10778214f, 
    0.11881422f, 0.12086001f, -0.17718634f, 0.10330967f, -0.13201310f, -0.18294166f, -0.03563912f, -0.20037687f, 
    -0.19340205f, 0.15896860f, -0.00058635f, -0.13452610f, -0.00698475f, 0.06129990f, 0.10453995f, 0.01241966f, 
    -0.21222222f, 0.08747587f, 0.14544414f, 0.18884839f, -0.16834962f, 0.04913134f, -0.24504089f, -0.15863606f, 
    0.03351216f, -0.02276184f, -0.03258589f, -0.00318457f, -0.03152275f, 0.00663114f, 0.05954143f, -0.09743361f, 
    -0.01351804f, -0.14153941f, 0.08538472f, 0.16324617f, -0.03512734f, 0.06940109f, 0.12912947f, 0.06221321f, 
    -0.10566314f, -0.02514771f, -0.14211440f, -0.07026999f, 0.15333885f, 0.10514460f, -0.04017087f, -0.20073766f, 
    -0.05239110f, -0.00839020f, -0.02628022f, 0.07364691f, -0.02425747f, 0.10078269f, -0.06443558f, 0.01617797f, 
    -0.06239362f, 0.05276630f, -0.25357503f, -0.11956073f, -0.02345225f, 0.08618122f, 0.06401796f, 0.01292646f, 
    -0.10034288f, 0.06857508f, -0.02564749f, 0.02732421f, 0.77259463f, -0.26502731f, -0.11502456f, 0.14631934f, 
    0.04843688f, -0.06840125f, 0.05986439f, -0.05561785f, 0.10324001f, -0.04267687f, -0.05320933f, 0.15656233f, 
    0.13012162f, 0.12003804f, 0.10269660f, 0.15091017f, -0.05725482f, 0.16468242f, -0.10793144f, -0.00404692f, 
    -0.09496040f, 0.07176164f, 0.05859703f, 0.14893039f, 0.03439632f, -0.18959957f, -0.04664760f, -0.06136366f, 
    -0.00659048f, -0.00259013f, 0.07305779f, -0.04686728f, 0.08464005f, 0.04412763f, 0.04207575f, 0.09048913f, 
    -0.05327347f, 0.05690598f, -0.23940770f, 0.20141889f, -0.12662885f, 0.04988758f, -0.13520737f, 0.02274891f, 
    -0.12645085f, -0.09021004f, -0.03457851f, -0.19667880f, -0.06599285f, 0.00563490f, -0.20045973f, -0.27894518f, 
    0.04313585f, 0.12592705f, 0.10328157f, 0.07733753f, -0.03234664f, 0.06926918f, -0.04585167f, -0.10459752f, 
    0.03052836f, -0.06213032f, 0.19147547f, 0.09226229f, 0.05684393f, 0.08939681f, -0.17028666f, 0.07323015f, 
    -0.09115601f, 0.05549362f, 0.08572167f, 0.08303557f, 0.23012590f, -0.09354401f, -0.09744878f, 0.00027554f, 
    -0.13424684f, 0.00484102f, 0.05950438f, -0.00307727f, -0.10255560f, 0.19024962f, -0.07059877f, -0.02650125f, 
    -0.12780410f, -0.09395303f, -0.01909098f, 0.10529529f, -0.03238047f, 0.06709273f, -0.05716030f, -0.06815189f, 
    0.09481551f, 0.07057133f, -0.02128245f, 0.06561907f, -0.09733247f, 0.03140223f, 0.35406569f, -0.01979673f, 
    -0.05816819f, 0.06279574f, -0.06466986f, 0.00273976f, -0.05753072f, 0.09923412f, -0.01484765f, -0.08799822f, 
    -0.19409832f, -0.05776042f, 0.02879925f, 0.14305390f, -0.06604271f, 0.06564755f, 0.02369807f, -0.11016178f, 
    0.08574499f, 0.12023073f, 0.06710421f, 0.01315295f, -0.09838256f, 0.26336303f, 0.19354631f, 0.36256978f, 
    -0.04211598f, 0.00907245f, 0.02253034f, -0.00597242f, 0.00283032f, -0.04313258f, -0.18578969f, 0.01344799f, 
    0.13358225f, -0.09749635f, -0.11867388f, -0.18147278f, -0.20807695f, -0.05787700f, 0.00234216f, 0.10969926f, 
    0.03692732f, -0.05119853f, -0.05249460f, -0.17275465f, -0.02999961f, 0.22983751f, -0.00732162f, 0.14310324f, 
    0.07127889f, 0.02388147f, 0.06135485f, -0.01533868f, 0.08258454f, 0.11183769f, -0.01423318f, 0.03912976f, 
    -0.14161089f, -0.09100839f, 0.00111018f, 0.17458688f, 0.00223764f, -0.10390273f, -0.00073086f, -0.07182685f, 
    0.03869322f, 0.13884091f, 0.01789009f, 0.12576753f, 0.03844462f, 0.15776165f, 0.45935458f, -0.08511546f, 
    0.04058920f, 0.09676205f, -0.28726879f, -0.05223809f, -0.10184851f, 0.01063167f, 0.04436621f, -0.13167082f, 
    -0.13283277f, -0.12476362f, 0.11676105f, 0.29531184f, -0.01227117f, -0.00830609f, 0.01557803f, 0.02740390f, 
    -0.13440605f, 0.03786192f, -0.08501557f, -0.10818017f, 0.02691975f, 0.17296331f, -0.02901832f, 0.25347087f, 
    0.04766698f, -0.00878651f, 0.06660982f, -0.18916756f, -0.10258350f, 0.02241978f, 0.05044118f, 0.07266855f, 
    0.04325498f, 0.21542138f, -0.18336077f, 0.13951388f, 0.12334205f, -0.13085230f, 0.03387541f, -0.05989718f, 
    -0.08589141f, -0.02264779f, -0.14339079f, 0.00929743f, -0.66831982f, 0.35078791f, -0.14181687f, -0.10882992f, 
    -0.00319247f, 0.17676906f, 0.10005869f, 0.05509307f, 0.01919174f, 0.02915949f, 0.11807918f, 0.05756046f, 
    0.13904293f, -0.29638749f, 0.16018319f, 0.01868902f, 0.06902032f, 0.00901302f, -0.04571278f, -0.09988615f, 
    0.01629419f, -0.09191046f, -0.00334100f, 0.04105181f, -0.05749314f, -0.12215538f, 0.13207509f, 0.21799424f, 
    -0.01437857f, -0.12683450f, 0.09364321f, -0.08796293f, -0.03999041f, 0.05516559f, -0.07959925f, -0.02898441f, 
    -0.07000091f, -0.10641763f, 0.03460027f, 0.15052246f, 0.00135341f, -0.06916499f, -0.03135780f, 0.04359759f, 
    0.01580029f, -0.00906868f, -0.11400156f, -0.07002068f, -0.13047712f, -0.00659746f, 0.19526403f, 0.24493818f, 
    -0.09082430f, 0.12795725f, 0.01744824f, -0.02611937f, 0.00027890f, -0.06729390f, 0.17966552f, 0.07200935f, 
    0.07413337f, 0.02641233f, 0.11517396f, 0.24978606f, 0.00005464f, 0.02172053f, 0.04655088f, 0.02184035f, 
    0.00782698f, -0.01240870f, 0.00889600f, -0.04744604f, 0.12140197f, 0.00103210f, -0.17786746f, -0.13732901f, 
    -0.09631785f, -0.04615245f, -0.09678794f, 0.02069601f, 0.13138656f, -0.10031360f, 0.00279447f, -0.00446829f, 
    -0.19287731f, 0.31251600f, 0.09259596f, 0.29875329f, 0.02468584f, 0.14656688f, -0.15939079f, 0.07419587f, 
    -0.02095036f, -0.03134386f, 0.02216078f, 0.11008812f, 0.22077525f, 0.06237485f, -0.00828051f, -0.04402362f, 
    -0.01941087f, 0.05002149f, -0.06195597f, 0.01076342f, 0.04805396f, 0.05344398f, -0.06932521f, -0.03779303f, 
    -0.20475167f, -0.13084774f, -0.02482655f, 0.04766340f, -0.10940694f, -0.00501339f, -0.16939355f, -0.00681045f, 
    0.01601877f, -0.08508223f, 0.09136843f, -0.11082163f, -0.01168632f, 0.13075228f, 0.09668399f, 0.07376187f, 
    0.01996517f, 0.07382471f, -0.10607155f, -0.09914636f, 0.13145874f, 0.17974655f, 0.16615404f, 0.17965713f, 
    0.01809889f, 0.22993171f, 0.09298401f, -0.02106840f, 0.05423538f, -0.02076103f, 0.03203214f, -0.01872269f, 
    -0.02952043f, 0.06939869f, 0.17904675f, 0.01106817f, 0.25993377f, -0.14558375f, 0.12091655f, 0.01279093f, 
    0.11278363f, 0.10523118f, -0.22157720f, -0.24208044f, 0.08207168f, -0.08365277f, -0.00700694f, 0.09019724f, 
    0.21938047f, 0.03071502f, -0.04954010f, 0.06552362f, -0.08443128f, 0.00060013f, -0.06204222f, -0.02937280f, 
    -0.07253817f, -0.15764509f, 0.04873500f, 0.02513129f, -0.34974033f, 0.23956323f, 0.26498580f, 0.23247063f, 
    -0.06949876f, -0.07723999f, 0.19930294f, 0.03782121f, -0.03996603f, 0.10197254f, -0.07404547f, 0.19084074f, 
    -0.08138805f, -0.07527421f, 0.06456149f, 0.29125121f, -0.06621150f, -0.04505048f, 0.00697487f, 0.01030020f, 
    -0.12974823f, 0.11042526f, -0.08532151f, -0.11806216f, 0.14335716f, -0.04159667f, 0.28840682f, 0.03074384f, 
    -0.09853176f, 0.08096520f, -0.08060814f, -0.03803227f, 0.02179192f, 0.10742564f, -0.00862064f, -0.01379749f, 
    0.04851337f, 0.01077088f, 0.15781561f, -0.10822855f, 0.12422759f, 0.02554723f, 0.15958723f, -0.01594139f, 
    0.15366711f, 0.15576859f, 0.23691322f, 0.11015420f, 0.32469663f, -0.13531473f, -0.06865679f, 0.12052057f, 
    0.30809677f, -0.09450699f, 0.14254922f, 0.09134772f, 0.05519483f, -0.12241118f, -0.00251566f, 0.04667459f, 
    0.06273650f, 0.12183499f, -0.09275244f, 0.09536418f, 0.01372978f, -0.11185181f, 0.04832895f, 0.00536532f, 
    -0.06365652f, -0.04256027f, -0.02044578f, -0.13904658f, 0.06990951f, -0.21079044f, 0.23185806f, 0.19929995f, 
    -0.09835722f, -0.16895500f, -0.00798301f, 0.04073476f, -0.18961066f, 0.05567873f, 0.22974382f, 0.13913633f, 
    -0.02136165f, -0.07029510f, 0.18107101f, 0.08147783f, -0.03510795f, 0.04883272f, 0.00697008f, 0.06929041f, 
    0.05077905f, 0.02989228f, 0.07518936f, 0.06458518f, 0.09570845f, 0.06045692f, -0.03236658f, 0.01518206f, 
    0.26348504f, -0.07641884f, 0.03265760f, -0.14245385f, -0.13083938f, 0.00431701f, -0.01029067f, -0.12005732f, 
    -0.02815526f, 0.04680263f, 0.01856109f, 0.01887834f, -0.01539561f, 0.23188128f, -0.04855301f, -0.05825734f, 
    0.04701553f, 0.12873505f, 0.15099257f, 0.07913256f, -0.02802758f, -0.03787800f, 0.07720727f, 0.02817498f, 
    -0.04285464f, 0.06138825f, -0.00157674f, 0.09335508f, -0.09170280f, -0.05455322f, 0.00360876f, 0.00891762f, 
    -0.00080609f, -0.06231673f, -0.05571640f, 0.06572339f, -0.02226328f, -0.07969482f, -0.17190111f, 0.01042554f, 
    -0.18147500f, 0.02713867f, -0.09397886f, -0.04233196f, 0.21635237f, 0.17655776f, 0.12340014f, 0.02734906f, 
    0.00568566f, 0.04145873f, 0.05748684f, 0.11003236f, -0.13443409f, -0.07517952f, -0.03803390f, 0.01953571f, 
    -0.09941347f, 0.03014824f, -0.03719636f, -0.17795524f, -0.01106085f, -0.09329377f, 0.06434251f, 0.09442537f, 
    0.02992975f, 0.04812552f, -0.10420589f, 0.01625151f, 0.40005580f, 0.05446936f, -0.20448866f, 0.05092601f, 
    -0.14960581f, 0.09722518f, -0.01622927f, -0.20244361f, 0.11160973f, -0.06165430f, 0.17163613f, 0.14061104f, 
    -0.11331520f, -0.06195169f, -0.02452013f, 0.04394322f, -0.08303847f, -0.02425564f, -0.06750286f, 0.09129295f, 
    0.04762241f, 0.17002597f, 0.01537999f, -0.14241745f, -0.27855176f, -0.16647008f, 0.20227852f, 0.06198166f, 
    -0.20685034f, 0.06903659f, 0.00459441f, -0.07458169f, -0.25419745f, -0.02966476f, 0.10709967f, 0.05920799f, 
    -0.12847111f, 0.02395217f, 0.21552974f, -0.36941820f, -0.02824642f, 0.05608004f, -0.01256665f, -0.08642422f, 
    0.10745977f, 0.09689404f, -0.07836064f, 0.11519109f, 0.05482386f, -0.05550166f, -0.20794709f, -0.03658261f, 
    0.18635292f, 0.05503060f, 0.17332621f, 0.11927816f, -0.01808493f, -0.16369916f, -0.09489498f, 0.02052907f, 
    0.00417669f, -0.03790468f, 0.15416081f, -0.13201821f, 0.18633807f, 0.14176494f, -0.12436893f, -0.16100161f, 
    0.04037249f, 0.09972955f, 0.04196152f, 0.09902620f, -0.00107637f, -0.10299905f, -0.06375572f, -0.08997059f, 
    -0.08034659f, -0.04162364f, 0.04823272f, -0.12401631f, -0.07391202f, -0.03547958f, -0.09367540f, -0.11116559f, 
    -0.06513332f, -0.20736358f, -0.01022244f, -0.02198616f, -0.16802742f, -0.02439408f, -0.24098296f, 0.02432757f, 
    -0.11652952f, -0.09042972f, -0.10708377f, -0.14336091f, -0.23053262f, -0.16590962f, 0.32645646f, 0.13410303f, 
    -0.02458598f, -0.11069858f, -0.03283865f, 0.10261143f, -0.05352720f, 0.00374151f, 0.04985658f, 0.05133823f, 
    -0.09145191f, 0.04530787f, -0.05242455f, 0.03078535f, 0.06612804f, -0.02664768f, 0.05937880f, -0.09190659f, 
    0.11150750f, 0.26789698f, 0.09042890f, 0.08393198f, 0.35322428f, 0.48407048f, 0.17102443f, -0.08515943f, 
    -0.16097984f, -0.07478446f, 0.00468260f, 0.03198992f, -0.12233752f, 0.00000748f, -0.04775208f, 0.00888157f, 
    -0.37439051f, 0.29659402f, 0.28441471f, -0.04822210f, -0.10446696f, -0.10356828f, -0.08105064f, -0.02679452f, 
    -0.04111458f, -0.07621694f, 0.04297155f, 0.31132853f, 0.16600090f, 0.07225136f, 0.04741526f, -0.15626702f, 
    0.05937811f, -0.05871494f, -0.23337358f, 0.01556530f, -0.12269986f, -0.03435967f, 0.06169958f, -0.00612606f, 
    0.18614282f, 0.06713744f, -0.14560995f, 0.31388643f, 0.14762926f, 0.06403578f, -0.03156937f, 0.10070471f, 
    0.01344206f, -0.10347845f, 0.25918993f, 0.08082129f, 0.11706778f, 0.13651487f, -0.05643878f, -0.00084297f, 
    0.09057434f, -0.00623091f, -0.09194576f, 0.01080706f, -0.08807764f, 0.03338939f, 0.09554106f, -0.01023598f, 
    0.02177946f, 0.15389027f, 0.36984172f, 0.13691631f, -0.09365331f, -0.00475990f, -0.07704525f, -0.01959979f, 
    -0.07360033f, -0.11985284f, -0.04630478f, -0.00719303f, 0.06891901f, 0.14086027f, 0.21377330f, 0.00607020f, 
    -0.03101486f, 0.11205801f, 0.11115903f, 0.08111929f, -0.06135185f, 0.12176035f, 0.04951816f, 0.05685757f, 
    0.13148364f, 0.04624196f, -0.19396053f, -0.01616945f, 0.01422189f, 0.05090658f, 0.07558119f, 0.01657081f, 
    0.08517432f, 0.16076553f, 0.39052212f, -0.04059647f, 0.20435557f, -0.05824380f, -0.01233714f, 0.22708236f, 
    -0.04255981f, 0.06715073f, -0.10563041f, -0.07247232f, -0.01318057f, 0.02023001f, -0.04520668f, 0.15841660f, 
    0.11922489f, 0.03951051f, 0.11073006f, 0.07176012f, 0.17149575f, -0.01784289f, 0.05977092f, -0.05248756f, 
    -0.03312061f, 0.13627259f, 0.19249313f, 0.01622248f, 0.09092933f, -0.00664882f, 0.10598614f, -0.14344716f, 
    -0.03133476f, 0.12115813f, 0.04489760f, -0.05950442f, -0.00232805f, 0.03458985f, -0.06550416f, 0.09639581f, 
    0.05593370f, -0.07712289f, -0.25661698f, -0.06481740f, 0.10070885f, -0.09074423f, 0.06483229f, 0.01690292f, 
    -0.08693899f, -0.12618771f, 0.02705639f, -0.16278750f, 0.17583895f, 0.01762461f, -0.19703348f, -0.05469155f, 
    0.01100413f, 0.03371751f, 0.02422189f, 0.02325824f, -0.01174395f, 0.09392552f, 0.02302590f, -0.01622050f, 
    -0.18942487f, -0.11744081f, 0.29979962f, -0.12592877f, 0.09161305f, 0.07505144f, 0.10608548f, 0.13843329f, 
    -0.00178780f, 0.03317150f, 0.08182096f, 0.04152625f, 0.11742385f, -0.01705690f, 0.09234752f, 0.08975593f, 
    0.02427220f, 0.08160409f, -0.14573091f, -0.06269965f, -0.01683003f, 0.01723297f, -0.18702388f, 0.07040117f, 
    -0.16579811f, -0.11687663f, 0.01603537f, -0.15926671f, -0.02392444f, -0.04203259f, -0.01877892f, 0.07697473f, 
    0.00437670f, 0.07999294f, -0.01518032f, 0.01554967f, -0.07421558f, 0.00872652f, 0.17533498f, -0.08130455f, 
    -0.00568335f, 0.24444714f, 0.05042418f, -0.14735134f, 0.01618436f, -0.04331431f, -0.03174114f, -0.05370073f, 
    -0.02259343f, -0.03757681f, 0.05054504f, -0.06219264f, 0.07992956f, 0.02962040f, 0.08355452f, 0.00876466f, 
    0.03520626f, 0.14257143f, 0.11282258f, -0.02679040f, 0.00081050f, -0.10730010f, 0.14809164f, -0.14983748f, 
    -0.21746513f, -0.01173137f, 0.14005631f, 0.13676399f, -0.06331279f, 0.05157917f, -0.11458493f, -0.06562945f, 
    0.27202219f, 0.23156334f, 0.13032539f, 0.00757812f, -0.22503822f, -0.01245675f, 0.09481186f, 0.16372444f, 
    -0.03274841f, -0.05205386f, 0.06809474f, 0.10551156f, 0.03486512f, 0.13119097f, -0.02224647f, -0.02369859f, 
    -0.04001912f, -0.03489138f, 0.18857789f, 0.09023040f, -0.00147523f, 0.15374497f, 0.05326002f, 0.04385728f, 
    0.02253170f, -0.14914872f, -0.08861553f, 0.04846596f, 0.00247323f, 0.00184877f, 0.00737854f, -0.00122710f, 
    0.01733833f, 0.09069559f, 0.05298154f, 0.04336028f, -0.22641359f, 0.23206253f, 0.54741913f, -0.21383242f, 
    -0.17790721f, -0.01621664f, -0.06512442f, 0.15042700f, -0.02974679f, -0.00612797f, 0.09421285f, -0.06150717f, 
    0.14796571f, 0.17978887f, 0.02813513f, 0.07199958f, -0.06384497f, -0.03405289f, 0.06136146f, 0.08184712f, 
    -0.04350879f, -0.13805415f, -0.13093001f, -0.08179353f, 0.02478152f, -0.03223873f, 0.03515757f, -0.03694049f, 
    0.04254214f, -0.01876058f, -0.00267258f, 0.13617551f, -0.07816479f, -0.00764278f, 0.04277178f, -0.03116777f, 
    0.28042206f, 0.40538159f, -0.19528542f, -0.39773631f, 0.23682824f, -0.10751268f, 0.06472367f, 0.19379270f, 
    -0.05397195f, 0.02316424f, 0.04574500f, -0.06235989f, -0.14231040f, 0.12956646f, 0.00443626f, 0.22310279f, 
    0.05632031f, -0.04942577f, 0.11645636f, -0.10716416f, 0.08160455f, 0.12677856f, 0.20084244f, 0.16396387f, 
    0.02091495f, -0.11082839f, -0.08437380f, 0.08945652f, 0.12516040f, -0.01894458f, 0.01636838f, -0.11862588f, 
    -0.00049334f, -0.03019514f, -0.11092429f, -0.02007498f, 0.13840863f, 0.05975265f, 0.06631082f, -0.06436576f, 
    -0.02559942f, -0.01249888f, 0.09047332f, 0.10716248f, -0.04855936f, -0.04153344f, -0.12548035f, 0.07897616f, 
    -0.05953422f, -0.12996049f, -0.14755271f, 0.05013880f, -0.07217729f, -0.04277070f, 0.04540971f, 0.01386631f, 
    -0.07911876f, -0.05430139f, -0.11125172f, -0.06413497f, -0.14364603f, -0.06139568f, 0.02451549f, -0.00102347f, 
    0.02843361f, -0.05313742f, 0.03006574f, 0.13440648f, -0.00538885f, -0.05056936f, 0.04055511f, 0.17303173f, 
    -0.02750029f, -0.03893619f, 0.03423891f, 0.27984509f, -0.05980401f, -0.02957483f, 0.24779701f, 0.10479981f, 
    0.15368575f, -0.12617138f, -0.19914703f, 0.02056218f, 0.12237109f, 0.16176060f, 0.06700296f, 0.06597169f, 
    -0.05570416f, 0.05230585f, -0.06255494f, -0.00511651f, -0.00249333f, -0.03379011f, 0.06390640f, 0.02647214f, 
    -0.22881578f, -0.00250361f, 0.48985389f, -0.06937072f, -0.10358234f, 0.22338448f, -0.12181548f, -0.04791135f, 
    -0.23094797f, 0.03004478f, 0.09861054f, -0.07893222f, 0.19643708f, -0.00268475f, -0.05829969f, 0.06542972f, 
    -0.07575449f, 0.02379743f, -0.00755254f, 0.21389729f, 0.10303054f, 0.20014518f, -0.29714504f, 0.08085699f, 
    -0.00697781f, 0.07746922f, -0.07175390f, -0.01835685f, 0.01437886f, -0.12006919f, 0.02221691f, 0.04142911f, 
    -0.07791539f, 0.00836938f, -0.01547013f, -0.10131137f, -0.13348463f, -0.04345268f, 0.22485997f, 0.16934870f, 
    0.00331966f, -0.02086396f, -0.09576055f, -0.04393079f, 0.08709329f, 0.18129113f, 0.24552742f, 0.19160539f, 
    -0.01869231f, -0.05115153f, 0.12501849f, -0.01240568f, -0.04036314f, -0.11951149f, 0.06496926f, 0.03656262f, 
    -0.01796066f, 0.07218965f, 0.02195113f, 0.09679476f, 0.15020157f, 0.07895858f, 0.16804996f, -0.34958830f, 
    0.10058240f, 0.16224056f, -0.21559055f, 0.00347900f, 0.03915558f, -0.12407865f, 0.11324605f, 0.14247434f, 
    -0.08944180f, 0.11125510f, -0.10148970f, 0.03874403f, -0.05713620f, 0.16360435f, -0.02649537f, 0.01897148f, 
    0.01087782f, -0.02475965f, -0.01306409f, 0.04413406f, -0.09810706f, -0.09114812f, 0.20806280f, 0.14537805f, 
    -0.18417990f, -0.00546749f, 0.08723840f, -0.12190887f, 0.07513691f, 0.10996696f, -0.02517694f, 0.09280084f, 
    0.02943275f, 0.01270122f, -0.01862641f, -0.00237168f, -0.03187994f, 0.01726146f, -0.03603003f, 0.02781055f, 
    -0.02527958f, -0.01600926f, -0.01627287f, 0.00781312f, -0.02226178f, 0.01580904f, -0.02500857f, -0.00053837f, 
    0.00836767f, -0.00494311f, 0.02443346f, 0.00106135f, 0.01155370f, -0.02475978f, -0.01655067f, 0.00466740f, 
    0.01347064f, -0.00778925f, -0.02759345f, 0.00557133f, -0.01351122f, -0.02729475f, -0.00218399f, -0.00385800f, 
    -0.02053722f, 0.00412416f, -0.00612241f, -0.03924452f, -0.01322180f, 0.02111192f, 0.00247976f, -0.01356992f, 
    0.01054387f, -0.03965374f, -0.01824252f, 0.01712180f, -0.01477377f, 0.00345326f, -0.00002486f, 0.02997396f, 
    -0.02870625f, 0.00079139f, 0.00016774f, -0.02566497f, 0.01238106f, -0.03371116f, -0.02248463f, 0.01042444f, 
    0.01880005f, 0.02387021f, -0.03479161f, 0.01132185f, 0.00948386f, 0.02037222f, -0.03114955f, 0.00566185f, 
    -0.01493042f, 0.01888474f, 0.01782872f, -0.01984515f, -0.03827625f, -0.02458578f, 0.00395672f, 0.01038889f, 
    -0.01403407f, 0.01683268f, -0.03051287f, 0.01292567f, -0.01595063f, -0.02346217f, 0.00245369f, 0.01202520f, 
    -0.01049552f, 0.02477126f, 0.00344426f, 0.00656764f, 0.01514412f, 0.02628671f, 0.02976242f, 0.02996251f, 
    0.03005877f, 0.02924669f, -0.03694376f, 0.01033145f, 0.01430794f, -0.03346471f, -0.01074601f, 0.02216308f, 
    -0.02394103f, 0.02662181f, -0.03612785f, -0.01348252f, 0.02091477f, -0.00053913f, -0.03052239f, -0.03841127f, 
    -0.02610711f, -0.01939240f, -0.00970535f, -0.02662035f, 0.01817940f, 0.01927122f, 0.01953752f, -0.00363907f, 
    0.01333817f, 0.02271150f, 0.01376896f, 0.01203067f, 0.01079794f, -0.02518451f, -0.01092291f, -0.01919609f, 
    -0.01933656f, -0.00753783f, 0.01469483f, 0.02717790f, -0.02000086f, 0.01654131f, -0.00992220f, -0.04075361f, 
    -0.02119550f, -0.02998530f, -0.00320369f, -0.03292583f, 0.00646608f, -0.02128787f, 0.00744615f, -0.00010057f, 
    0.01994939f, 0.02172773f, 0.01900057f, -0.00614037f, -0.01489629f, 0.01074210f, -0.00267393f, 0.02350296f, 
    -0.01676395f, -0.00741403f, 0.01549056f, 0.02484261f, -0.01709842f, 0.02002781f, 0.01520968f, -0.00967045f, 
    -0.02678542f, -0.04206368f, 0.00354407f, -0.00773197f, -0.02724980f, -0.03207648f, -0.04021158f, 0.01241583f, 
    0.00322076f, -0.00834646f, -0.04075900f, -0.03464248f, -0.02311228f, 0.01165267f, -0.04150483f, -0.01160219f, 
    -0.00041238f, -0.03670780f, 0.02825826f, 0.00147653f, -0.01048402f, -0.02660398f, -0.02165041f, -0.01962531f, 
    -0.01355644f, -0.00844923f, -0.02797569f, 0.00512881f, -0.01247028f, -0.03552775f, -0.02639151f, -0.01176718f, 
    -0.02769018f, -0.03320393f, 0.02382364f, 0.02855814f, -0.00965027f, 0.03966445f, 0.00857521f, 0.00541903f, 
    -0.01980033f, -0.01956945f, 0.01095836f, -0.01923345f, 0.00079007f, 0.00345105f, 0.00697326f, -0.02412815f, 
    -0.03276851f, 0.02010535f, -0.01472789f, -0.01604339f, -0.01946487f, -0.03672079f, 0.02058952f, 0.01008525f, 
    -0.03047537f, -0.01170272f, 0.02389032f, -0.03711198f, -0.03643404f, 0.02149219f, 0.02122328f, -0.00935981f, 
    -0.00697921f, -0.01707860f, 0.00817392f, 0.02854259f, -0.03878651f, -0.03570382f, -0.01666423f, 0.00708191f, 
    0.01073546f, 0.01125947f, -0.01223943f, -0.02336102f, -0.02384131f, -0.03055460f, 0.01544700f, -0.01629109f, 
    0.02790260f, 0.01573957f, -0.03241907f, -0.00642109f, -0.02629399f, -0.03215321f, -0.03059212f, -0.02753716f, 
    -0.01289843f, 0.00074029f, -0.00793562f, 0.00887501f, 0.00329548f, 0.02922037f, 0.01252562f, -0.00415347f, 
    -0.03038161f, 0.00019808f, 0.02876832f, 0.01820046f, -0.01773388f, -0.02148024f, -0.03454335f, -0.02446592f, 
    -0.00702333f, -0.01646370f, -0.00233114f, -0.00453323f, -0.02209763f, -0.00139566f, 0.01906570f, -0.00159338f, 
    0.01975725f, 0.00432992f, -0.01811313f, -0.01992929f, 0.02583247f, -0.01934534f, -0.00023442f, 0.01313146f, 
    -0.00581521f, 0.02796366f, -0.04121199f, -0.03706986f, -0.02484951f, 0.02507368f, -0.03039081f, 0.00735177f, 
    -0.00430513f, 0.02561590f, -0.03098766f, -0.02598716f, -0.02801883f, -0.01341635f, -0.04076278f, -0.02472063f, 
    0.00913002f, 0.02299703f, -0.03774666f, 0.02555163f, 0.02645491f, -0.01701551f, -0.02893031f, -0.03607268f, 
    0.01755627f, -0.03414912f, -0.01607221f, -0.00633914f, 0.01119213f, -0.03510875f, 0.00715623f, -0.04100341f, 
    0.02293209f, 0.00427336f, 0.00718387f, -0.00082088f, -0.02379479f, 0.01734886f, -0.03812246f, 0.00704083f, 
    -0.03753156f, 0.01118354f, 0.02524133f, 0.01609677f, 0.00913461f, -0.00654417f, -0.01790227f, 0.00894837f, 
    -0.04090818f, -0.04024480f, -0.02269293f, 0.01478147f, -0.03288166f, -0.02116683f, -0.01828833f, 0.00289100f, 
    0.01655354f, 0.00137276f, 0.02550920f, -0.01287129f, -0.04206785f, -0.01749783f, -0.00888958f, -0.01531125f, 
    0.02644057f, 0.02467536f, 0.01396849f, -0.01078659f, -0.01611833f, -0.03462491f, -0.00932292f, -0.02074014f, 
    0.00971923f, 0.00017133f, -0.01175416f, 0.01273732f, -0.02510477f, -0.04011002f, -0.04031637f, -0.03598453f, 
    0.02661691f, 0.00273473f, -0.00913730f, -0.01898863f, 0.00032359f, 0.00095380f, -0.01841547f, 0.00271828f, 
    -0.00742273f, -0.01283187f, -0.04038613f, -0.02356012f, -0.00523173f, -0.01333103f, 0.00477494f, 0.01501837f, 
    -0.00027527f, -0.01575011f, -0.03850772f, -0.00861607f, 0.00451594f, -0.01563930f, -0.03274377f, -0.02487554f, 
    0.00003377f, -0.02980020f, -0.00531980f, -0.03994700f, 0.01621570f, 0.03419210f, -0.00906760f, -0.03999404f, 
    0.01650888f, -0.00997584f, 0.01135084f, -0.00762091f, -0.03594530f, 0.02803672f, -0.01479556f, -0.02484360f, 
    -0.02801481f, -0.02482127f, 0.01734645f, -0.01427473f, -0.02443554f, 0.00550929f, 0.01677237f, -0.03212567f, 
    0.01792995f, 0.00874462f, -0.01954687f, 0.02585933f, -0.01434180f, 0.02732374f, 0.00615093f, 0.02358425f, 
    0.00478497f, -0.03444301f, 0.01053264f, -0.01677788f, -0.02798340f, 0.01233497f, 0.00643235f, -0.00201960f, 
    -0.00238090f, -0.04171829f, -0.00875544f, -0.02397362f, -0.00950725f, -0.01583619f, 0.00950794f, -0.00344302f, 
    -0.02634230f, 0.02549576f, 0.02580287f, -0.03872762f, 0.01134855f, -0.04098561f, -0.00036447f, -0.02988303f, 
    0.00284734f, -0.02832087f, 0.02128934f, -0.00647265f, 0.01281533f, 0.01861053f, -0.01819978f, -0.02380277f, 
    -0.03681566f, -0.00464865f, -0.03411817f, 0.00906280f, -0.03036571f, -0.01716173f, -0.02050033f, -0.00631736f, 
    -0.01484919f, -0.02418433f, -0.03614495f, 0.02556867f, 0.01635076f, 0.03567729f, 0.00101621f, -0.00026942f, 
    -0.00977152f, -0.01621943f, -0.03056640f, -0.01731883f, 0.01621803f, 0.02344600f, -0.00584111f, 0.02403517f, 
    -0.03927314f, 0.01665333f, 0.01383216f, -0.04159651f, -0.00449034f, 0.01443647f, -0.03046332f, -0.04181715f, 
    -0.01374901f, -0.00248286f, -0.00339678f, -0.03948951f, -0.03891996f, -0.02584679f, 0.00537616f, 0.00502635f, 
    0.01996357f, -0.02527443f, 0.02774727f, 0.00098413f, 0.01762080f, -0.00937569f, -0.02175019f, -0.03937141f, 
    -0.00750515f, 0.01385288f, -0.03637904f, -0.03893376f, 0.00516702f, 0.02647432f, -0.00076354f, -0.02013941f, 
    -0.00683163f, -0.01426734f, -0.01708147f, 0.02500781f, -0.02861037f, -0.03755478f, -0.00598488f, 0.00392180f, 
    0.02313720f, -0.00056333f, 0.01057884f, -0.03654363f, -0.02540127f, 0.01082761f, 0.01591843f, -0.00040179f, 
    -0.02527085f, -0.01924742f, -0.03112743f, -0.01956102f, 0.01552492f, -0.01256605f, 0.02866260f, 0.00410697f, 
    0.02668497f, -0.03250111f, -0.04185530f, 0.00489242f, 0.02353580f, 0.02434411f, 0.02018359f, 0.01742814f, 
    -0.02850408f, -0.01943553f, 0.02121756f, 0.00307164f, -0.02758860f, 0.00037889f, 0.02795820f, -0.04144755f, 
    0.01097683f, -0.03357663f, -0.03330019f, 0.00635322f, -0.01263548f, -0.00532570f, -0.01673542f, 0.01632288f, 
    -0.04000032f, -0.00326645f, -0.01688964f, 0.01276652f, -0.00474945f, 0.02387501f, 0.00134965f, -0.00120622f, 
    -0.03038055f, 0.01255615f, -0.01354966f, -0.03954037f, -0.02419541f, -0.02578825f, 0.02091642f, -0.00112519f, 
    -0.01537719f, 0.00234291f, -0.00249085f, 0.02564836f, -0.01044560f, -0.01423728f, -0.01281382f, 0.01807553f, 
    -0.00216608f, 0.00658738f, 0.02390463f, 0.01213600f, -0.01706186f, -0.01726389f, -0.04183480f, 0.01643025f, 
    -0.02799860f, -0.00919056f, -0.04070720f, -0.01477483f, -0.04132050f, 0.00216094f, 0.01905539f, -0.01384705f, 
    0.01754958f, -0.00758707f, 0.00757827f, -0.03245303f, -0.02110754f, -0.03598376f, -0.01688673f, -0.01561777f, 
    -0.03289304f, 0.01938561f, -0.01918509f, -0.00603591f, -0.02781445f, 0.02950521f, 0.01467990f, 0.00072548f, 
    -0.02235901f, -0.02337992f, -0.02257962f, -0.00272638f, -0.00259742f, -0.02895595f, -0.04087839f, -0.01903504f, 
    0.01281990f, 0.01643397f, -0.00505526f, 0.00115811f, -0.00464485f, -0.00894504f, 0.02285861f, 0.02641371f, 
    -0.01710351f, -0.02633986f, 0.02732720f, -0.00104943f, -0.02929639f, -0.03598771f, -0.01495946f, 0.01338845f, 
    0.00541431f, -0.00767081f, -0.00030690f, -0.02698620f, -0.01511090f, -0.04009191f, -0.03705138f, -0.00785470f, 
    0.01328605f, 0.00966209f, 0.02750219f, 0.01678273f, -0.01860615f, -0.02386493f, -0.03990594f, 0.00165354f, 
    0.01072291f, 0.02332909f, -0.02167227f, -0.04057912f, -0.02827609f, -0.01911685f, 0.02938997f, -0.00695318f, 
    -0.03393514f, 0.02861104f, -0.00729887f, 0.00452401f, -0.02995967f, -0.01153261f, -0.00489205f, -0.00316612f, 
    -0.03925436f, -0.01343640f, -0.01945195f, -0.03232092f, -0.00301649f, 0.01831614f, -0.01378491f, -0.03811409f, 
    0.00641322f, 0.00013016f, -0.01857201f, 0.00334886f, -0.02011206f, -0.01220920f, 0.00356050f, -0.02845018f, 
    -0.01447326f, -0.00918780f, -0.02417098f, -0.02918371f, -0.03817178f, -0.03584830f, -0.04181268f, 0.02768773f, 
    0.01350658f, 0.01144986f, 0.02202397f, 0.00998423f, -0.03294177f, 0.02625598f, -0.00346646f, 0.00261097f, 
    -0.02963770f, 0.00325700f, 0.02925694f, -0.01922404f, 0.02303782f, 0.02051968f, -0.01677686f, -0.01834192f, 
    -0.00939377f, 0.01512712f, 0.02307456f, 0.00595458f, 0.00988460f, -0.02436429f, -0.02183509f, -0.01347371f, 
    0.02113395f, 0.01674983f, -0.03606114f, -0.00067714f, 0.02096067f, -0.01014764f, -0.04059234f, -0.01091044f, 
    0.02778375f, -0.02007478f, 0.00889760f, 0.01752420f, -0.00447660f, 0.00386706f, -0.03889849f, 0.02049907f, 
    -0.01880253f, -0.02087234f, -0.00848959f, -0.03889189f, 0.02851785f, 0.00237022f, -0.03813409f, -0.03633595f, 
    0.00953617f, -0.01363009f, -0.01906810f, -0.02703003f, 0.00166597f, 0.01029777f, 0.01971207f, -0.01127684f, 
    -0.03445436f, 0.00869533f, -0.03641079f, 0.01564017f, 0.00952302f, 0.00980462f, -0.00336438f, -0.01371718f, 
    -0.02236184f, -0.03830523f, -0.04019602f, -0.01965725f, -0.01577926f, -0.01485195f, 0.02470056f, -0.01354409f, 
    -0.00893426f, 0.00820804f, 0.00623984f, 0.00605032f, -0.01592522f, -0.03548950f, -0.00880676f, -0.03444178f, 
    -0.03323782f, -0.02099624f, 0.02357798f, 0.00315347f, -0.01320328f, -0.02141003f, 0.02739290f, -0.00607320f, 
    0.02073076f, -0.02040333f, 0.02584021f, -0.00047685f, -0.02515410f, 0.02795507f, -0.02546127f, 0.01677755f, 
    -0.03246195f, -0.01562130f, 0.00844296f, 0.01356868f, 0.00450126f, 0.00618050f, -0.00603579f, -0.03450702f, 
    -0.02331320f, -0.01092620f, -0.00489804f, 0.01618244f, -0.00990459f, 0.01014533f, -0.01672768f, -0.00423892f, 
    -0.00033433f, -0.03752374f, 0.02362240f, -0.00274427f, 0.02069579f, -0.00394383f, 0.02307612f, 0.00265911f, 
    -0.00648614f, -0.03049500f, -0.00471435f, -0.00475751f, 0.01839288f, -0.02480507f, 0.02393591f, -0.00349801f, 
    -0.00535830f, -0.03982170f, -0.02882737f, -0.03386689f, -0.02551959f, -0.03765764f, -0.01006476f, -0.02948049f, 
    0.01476421f, -0.04280110f, -0.02382522f, 0.00122212f, 0.01920821f, -0.02876983f, 0.00682443f, 0.01914715f, 
    0.02181242f, -0.03368928f, -0.02147960f, -0.00485891f, -0.03010131f, 0.02109203f, -0.01068521f, -0.02604526f, 
    0.00619510f, -0.02321912f, 0.01980658f, -0.00295269f, -0.02851182f, -0.03394128f, -0.00047504f, -0.00299325f, 
    -0.01814713f, -0.01356299f, 0.01303005f, -0.02684607f, -0.03152123f, 0.02950178f, -0.04276357f, -0.01238521f, 
    -0.02290993f, -0.01600041f, -0.02979436f, -0.03164401f, -0.03321941f, 0.01003051f, 0.00486910f, -0.00314346f, 
    -0.01678904f, -0.00042149f, -0.00193577f, 0.00396786f, -0.03620709f, -0.03146779f, 0.01923556f, -0.03230399f, 
    0.01441252f, -0.00889968f, -0.00795630f, 0.00676173f, 0.02077728f, 0.01810839f, 0.00845690f, 0.00547789f, 
    -0.01767995f, -0.02808791f, 0.01087372f, -0.01798830f, 0.01765718f, 0.02533706f, -0.00900196f, -0.01159787f, 
    -0.01353473f, -0.00623106f, -0.03621426f, 0.01870853f, -0.01645135f, 0.00044570f, -0.03755527f, 0.01324372f, 
    0.02061165f, 0.03153772f, -0.02833420f, 0.03169832f, 0.01728659f, -0.03588801f, 0.02091980f, 0.01461840f, 
    0.03128681f, -0.00242773f, -0.04027539f, -0.02650460f, 0.01651184f, -0.03281389f, -0.01975500f, -0.01924172f, 
    -0.03215701f, 0.01376471f, 0.00356262f, 0.00018485f, -0.02987297f, -0.02195059f, -0.01517772f, 0.01875612f, 
    -0.00164766f, -0.00936788f, -0.00717811f, 0.00111320f, 0.02002840f, 0.00673718f, 0.00161961f, 0.00955777f, 
    -0.03822797f, 0.02740999f, 0.01122502f, 0.02034463f, -0.02072511f, -0.04049276f, -0.03153428f, -0.02046894f, 
    0.01634995f, -0.03292513f, 0.02424174f, -0.02438941f, 0.02381177f, 0.00479677f, -0.03123004f, 0.00267301f, 
    0.00328343f, -0.01759828f, 0.00785328f, 0.02351571f, 0.00767391f, 0.01098865f, -0.01545998f, -0.00737368f, 
    0.00592619f, -0.01474674f, -0.03208624f, -0.03837492f, 0.02450706f, -0.02212252f, -0.00079523f, 0.00312638f, 
    0.01898270f, -0.00838262f, 0.01953703f, -0.00491296f, -0.01828529f, 0.01470123f, 0.00020604f, -0.03096600f, 
    -0.00998627f, 0.00570795f, -0.00011052f, -0.00725855f, -0.01284373f, -0.02419459f, 0.01173609f, 0.03069601f, 
    0.00894251f, -0.00521987f, 0.00339722f, -0.02556100f, -0.01231151f, -0.00045969f, -0.01900350f, 0.02371063f, 
    0.02336638f, -0.01691592f, -0.00133520f, -0.01322898f, -0.01431868f, 0.01900177f, -0.00653462f, 0.00819098f, 
    0.02646058f, -0.02345917f, -0.00440142f, 0.02602597f, -0.00207985f, 0.01202493f, 0.01794946f, 0.00927951f, 
    0.01924057f, -0.01284373f, 0.02922009f, -0.01905563f, -0.02086785f, -0.01464994f, 0.02026065f, -0.02817836f, 
    -0.01997180f, -0.03501556f, -0.03601358f, -0.02686609f, 0.01465735f, 0.02441413f, -0.03066338f, 0.01957717f, 
    0.01656435f, -0.03798920f, 0.00168970f, 0.00522022f, 0.01705229f, -0.03983957f, 0.01879214f, 0.01831295f, 
    -0.02995433f, -0.03707542f, -0.00956417f, 0.01195631f, -0.03601172f, 0.00967117f, -0.00971974f, -0.01967822f, 
    0.02124430f, -0.03034787f, 0.02620421f, -0.03397528f, 0.00132995f, -0.01753423f, -0.03056719f, -0.00951379f, 
    -0.02139127f, -0.03968896f, -0.03993231f, -0.04294678f, -0.03035979f, -0.01892347f, -0.02759050f, 0.02365897f, 
    -0.02049820f, -0.01917628f, 0.00218444f, -0.03194238f, 0.01329769f, 0.01736898f, -0.04309712f, 0.00464157f, 
    0.01327906f, 0.01376484f, -0.04151782f, -0.02777737f, 0.00698593f, -0.02375119f, -0.02482405f, -0.01799752f, 
    0.02595780f, 0.00974115f, 0.02842896f, -0.00682885f, -0.02266727f, -0.00667547f, -0.02637536f, 0.00285936f, 
    -0.00874455f, 0.01364036f, -0.03246270f, -0.03719501f, 0.00612183f, -0.00883983f, -0.02346119f, 0.01173530f, 
    0.01932976f, 0.01345014f, 0.00632033f, -0.02840501f, -0.01757895f, -0.00046447f, -0.02930470f, -0.01730119f, 
    0.01625323f, -0.01104103f, 0.01062839f, 0.01993196f, -0.04061993f, 0.01688862f, -0.01979109f, -0.02445702f, 
    -0.03643923f, -0.00014367f, -0.02058845f, -0.00808252f, -0.00857295f, -0.00097791f, -0.00534763f, 0.00201766f, 
    -0.02421973f, -0.02459184f, -0.03402901f, -0.00381967f, -0.02032289f, -0.03918469f, -0.04297156f, -0.01810456f, 
    -0.01218030f, -0.01110560f, -0.01938574f, -0.04326215f, -0.00534214f, -0.03092032f, -0.01473371f, -0.01362476f, 
    0.01457390f, 0.00200667f, -0.03836586f, -0.03214286f, -0.02449860f, 0.00212886f, 0.02818118f, 0.01587741f, 
    0.00614164f, 0.00197083f, 0.01869928f, 0.00960850f, 0.00525047f, 0.02403347f, 0.00300146f, 0.00813783f, 
    0.00517656f, 0.01026874f, 0.02036101f, -0.00052030f, 0.02367911f, -0.02457651f, -0.00632569f, -0.01602076f, 
    -0.00800815f, -0.03082066f, -0.00753541f, -0.00039020f, 0.00444405f, 0.01441604f, -0.03055642f, 0.02317649f, 
    0.00229675f, -0.00574414f, 0.03077136f, -0.01839839f, -0.03780539f, -0.03653158f, -0.00782641f, -0.01749049f, 
    0.00058464f, -0.03419752f, -0.00618385f, -0.00800741f, -0.03889158f, 0.01928446f, 0.01735992f, 0.00095774f, 
    -0.00223164f, -0.01954725f, 0.01762186f, -0.01954697f, -0.03572067f, -0.01712046f, -0.03415552f, 0.00205009f, 
    -0.01677100f, -0.00845656f, 0.02471502f, -0.00976415f, 0.02013972f, 0.00350966f, 0.01952390f, -0.03633400f, 
    -0.03669742f, -0.01462130f, -0.04116914f, -0.03478102f, 0.01852533f, -0.01097961f, 0.02210601f, -0.01801520f, 
    -0.00707143f, 0.02272571f, -0.00285001f, -0.00717328f, 0.00065297f, -0.02460811f, -0.02608243f, -0.00275245f, 
    -0.03348492f, -0.03403414f, 0.02471066f, -0.00100806f, 0.00620583f, 0.00271988f, 0.02598022f, -0.01730558f, 
    0.00316257f, -0.01454692f, -0.01882623f, -0.03969766f, -0.04097970f, -0.01885141f, 0.01174537f, 0.01663280f, 
    -0.00116174f, -0.00765156f, 0.02986950f, -0.00737579f, -0.03688192f, -0.03033206f, -0.03990085f, -0.03031923f, 
    0.01407308f, -0.02091986f, -0.03332731f, -0.01371991f, -0.01718912f, -0.00066534f, -0.03563860f, -0.00696037f, 
    0.01518649f, -0.01711891f, -0.01751826f, -0.01955760f, 0.00476823f, -0.02469500f, 0.02542648f, 0.00800303f, 
    -0.02595616f, 0.00206201f, 0.02716083f, -0.03673312f, -0.02356908f, 0.01475004f, -0.04483474f, -0.02380881f, 
    -0.02961937f, -0.01956679f, 0.01960895f, -0.03841597f, 0.00729816f, 0.01971787f, -0.01065980f, 0.02397077f, 
    0.01998603f, -0.03062204f, -0.02252670f, -0.02689644f, -0.00925157f, -0.02729698f, -0.03299038f, -0.03097300f, 
    0.01382107f, -0.02480308f, -0.01407285f, 0.01063302f, -0.03737127f, 0.01945241f, 0.01308445f, -0.04011359f, 
    -0.04545678f, -0.04136537f, 0.02533933f, 0.01453707f, -0.00878972f, 0.00691307f, 0.01050279f, 0.02025443f, 
    0.02344411f, 0.01444557f, -0.02567391f, 0.01246989f, 0.02743223f, 0.01278235f, 0.03640389f, -0.02866788f, 
    0.00371838f, -0.00110459f, 0.01502771f, -0.02686520f, -0.01977687f, -0.03440996f, 0.01885990f, -0.00230741f, 
    -0.02495549f, 0.02265059f, -0.02629688f, -0.01360696f, 0.01404366f, 0.02643703f, -0.02201630f, 0.01080859f, 
    -0.00187435f, 0.02148259f, -0.00189201f, -0.00417993f, -0.04447838f, -0.03545515f, -0.03615697f, -0.03041903f, 
    0.00573859f, 0.00317621f, -0.03597420f, -0.01868568f, -0.01629855f, -0.00768469f, 0.01287866f, 0.01860676f, 
    -0.03047913f, -0.01088098f, -0.02045110f, 0.01146300f, 0.02837252f, -0.00720648f, -0.00623393f, -0.00176662f, 
    -0.00263486f, -0.00282021f, 0.02549556f, 0.00256255f, 0.00690654f, -0.01926539f, -0.03478922f, -0.02935644f, 
    -0.02472025f, -0.03354389f, -0.03284212f, -0.01290564f, -0.01650590f, -0.01004393f, -0.01523021f, 0.00211272f, 
    -0.01497796f, 0.00375065f, -0.03160517f, -0.02884945f, -0.03849981f, 0.01312625f, 0.02043045f, -0.00973416f, 
    -0.00444941f, 0.01929962f, -0.00528091f, 0.01417289f, 0.00655601f, -0.00405165f, 0.00794900f, 0.00910184f, 
    -0.02150645f, -0.02526282f, 0.02936333f, -0.01856703f, -0.02361769f, 0.02192513f, 0.00889267f, 0.01373152f, 
    -0.01599389f, 0.01208771f, -0.03451450f, 0.02416095f, -0.03122026f, -0.02504342f, 0.00241810f, 0.02314815f, 
    -0.01257402f, 0.02293784f, 0.01173402f, 0.01773787f, 0.01505383f, -0.03324271f, -0.00512031f, 0.01170855f, 
    -0.00908153f, -0.01054806f, 0.00645416f, -0.01817051f, 0.02242899f, 0.03167807f, 0.01216776f, -0.03368985f, 
    -0.01354786f, -0.02128089f, 0.01877770f, -0.00821619f, -0.02751043f, -0.03859355f, -0.01913067f, 0.01227241f, 
    -0.03799569f, -0.01261338f, 0.02121704f, 0.00425949f, -0.03694857f, -0.04855775f, -0.03609275f, -0.01263432f, 
    -0.02748060f, -0.00194635f, -0.02415862f, -0.03950441f, -0.02799330f, -0.02820544f, 0.00664788f, -0.02029085f, 
    -0.02979103f, -0.00470332f, -0.03136243f, -0.02792987f, -0.02129458f, 0.01045338f, -0.01618441f, 0.01653997f, 
    0.01767939f, -0.01424237f, 0.01111090f, -0.01316257f, 0.02006656f, 0.00635059f, 0.02401769f, 0.01979791f, 
    -0.03882269f, -0.01730729f, -0.01186772f, -0.00518968f, -0.01305478f, -0.00725051f, 0.03011093f, 0.03394878f, 
    0.02636010f, -0.03131674f, 0.00727595f, -0.00006946f, -0.03082589f, -0.03421289f, -0.01198561f, -0.03257946f, 
    -0.00388346f, 0.00596217f, -0.03660424f, -0.03852301f, -0.01504576f, -0.02922677f, 0.02281755f, 0.00898732f, 
    0.02161123f, 0.02251985f, -0.04173207f, -0.04671050f, 0.00274236f, 0.02779506f, -0.00734594f, 0.01969999f, 
    -0.00852199f, -0.02608719f, 0.03074550f, -0.01951406f, 0.01091739f, -0.01722724f, -0.00857592f, 0.01859918f, 
    -0.04277413f, 0.00012606f, -0.02451597f, 0.00936967f, 0.00231536f, 0.01573701f, -0.00949973f, -0.00474989f, 
    -0.00853505f, -0.03207848f, 0.00865750f, -0.02049916f, 0.00123768f, 0.00646312f, -0.00427376f, -0.01812695f, 
    0.01205075f, 0.02399298f, -0.01178198f, 0.02231189f, -0.04100723f, -0.03434685f, -0.03291764f, -0.01836671f, 
    0.00795388f, 0.00585801f, -0.02333684f, -0.00758691f, -0.01280741f, 0.00276606f, 0.01975206f, -0.00694024f, 
    -0.03034242f, -0.02566927f, -0.02913900f, -0.03654533f, -0.02929428f, 0.00018107f, -0.03483528f, -0.03124999f, 
    0.00007954f, -0.02678424f, 0.02388385f, -0.02879049f, -0.04241285f, 0.02906134f, -0.03569260f, 0.02671264f, 
    -0.02721009f, -0.00324947f, -0.03185857f, -0.01021511f, -0.03671800f, -0.01020504f, -0.02295630f, -0.03502179f, 
    0.02587715f, -0.01971994f, -0.01954972f, 0.02056898f, 0.00179386f, -0.00833987f, 0.02538273f, -0.00156687f, 
    -0.03759306f, -0.01571761f, -0.04247131f, -0.02863742f, 0.02379286f, -0.02672717f, 0.02457602f, -0.01456230f, 
    0.19127114f, -0.18102238f, -0.22723062f, -0.19915754f, 0.01777244f, 0.16458452f, 0.02161672f, -0.04481720f, 
    0.16506079f, -0.16518076f, -0.10870076f, -0.02589751f, -0.10265111f, -0.24693578f, -0.13247323f, -0.27835113f, 
    0.00732640f, -0.01322601f, -0.04173379f, -0.00758490f, 0.03170614f, -0.10775454f, -0.10842246f, 0.01812845f, 
    0.04660624f, -0.18372214f, -0.09385604f, 0.04872740f, 0.14051127f, 0.08058225f, 0.05054794f, 0.13168752f, 
    -0.04831926f, 0.05385398f, -0.10271993f, 0.00195586f, -0.10449671f, 0.09337664f, 0.26557028f, 0.14346960f, 
    -0.13084383f, -0.01386909f, -0.05186453f, 0.01556659f, 0.10649455f, 0.03089964f, -0.05183591f, -0.07401229f, 
    0.07842950f, -0.00343852f, 0.13005501f, 0.04094154f, -0.01492387f, 0.03523774f, 0.00912939f, -0.01589286f, 
    0.04379432f, -0.05621495f, -0.02274158f, 0.03682008f, 0.25124934f, -0.21278946f, 0.14666492f, -0.33055064f, 
    0.02649204f, -0.06424661f, -0.18247046f, 0.08780970f, 0.05977039f, 0.00897304f, 0.04648542f, 0.02318195f, 
    0.07187443f, 0.11189009f, 0.28317466f, 0.03827922f, 0.13630243f, 0.13944720f, 0.08806600f, -0.04755954f, 
    0.06790599f, 0.02601749f, 0.02792669f, -0.01765299f, 0.03824195f, -0.27343360f, 0.07725159f, 0.10124362f, 
    -0.02661353f, 0.01710155f, -0.01017291f, 0.08065110f, -0.02407262f, -0.12417755f, -0.09606227f, -0.03778546f, 
    0.00841400f, -0.17864318f, -0.02132904f, -0.15471263f, -0.02083092f, -0.06170322f, -0.01695722f, -0.02780435f, 
    0.00075037f, -0.05536876f, -0.01321482f, -0.06725389f, -0.08458615f, 0.11128338f, 0.18276370f, 0.19736585f, 
    0.16417839f, -0.02413304f, 0.06708924f, 0.01993999f, -0.02046536f, -0.02812986f, -0.05078201f, 0.01798143f, 
    0.02003574f, -0.26653230f, -0.04482452f, -0.10587215f, 0.07369494f, 0.06982113f, -0.05601157f, 0.06823912f, 
    0.01539350f, -0.04115646f, -0.10727742f, 0.06125749f, -0.13097546f, -0.16089223f, -0.16815512f, -0.25673205f, 
    0.03138517f, -0.04537970f, -0.04393203f, -0.07772690f, -0.01509830f, -0.04886144f, -0.13889287f, -0.10277309f, 
    -0.15998369f, 0.14293808f, -0.02482496f, 0.05194378f, -0.05142719f, -0.03597260f, 0.11294074f, 0.05958841f, 
    0.13095821f, 0.03296614f, 0.07021801f, -0.00785106f, -0.09263820f, 0.03144190f, 0.04239097f, 0.23774226f, 
    -0.03248943f, 0.08593567f, 0.04504589f, 0.10726375f, 0.05463364f, 0.00785873f, -0.01977610f, 0.06948827f, 
    0.02122329f, -0.19982819f, -0.06622560f, -0.24517225f, -0.04114227f, 0.01101146f, -0.12258238f, -0.04267776f, 
    0.11169534f, -0.09180400f, 0.06274801f, -0.00610325f, 0.14673959f, 0.14942807f, 0.17434615f, -0.07280803f, 
    -0.01972644f, 0.09829988f, -0.00824261f, 0.13808055f, 0.12896961f, 0.00649883f, 0.03154615f, -0.06104475f, 
    0.39063635f, 0.12025481f, -0.12854058f, 0.11492493f, -0.00776863f, 0.01172357f, -0.09185037f, 0.10403504f, 
    0.17135099f, 0.10701378f, 0.07301382f, 0.05911530f, -0.02602174f, -0.14706382f, -0.08433096f, 0.02481244f, 
    -0.11129217f, -0.03458052f, -0.00673396f, -0.07543302f, 0.02529298f, -0.10754177f, -0.25338307f, -0.08317804f, 
    0.05157924f, -0.18707347f, -0.17148815f, 0.05146329f, 0.00663387f, -0.19147260f, -0.13896841f, 0.01748328f, 
    0.06535962f, 0.00356040f, -0.01924212f, 0.12549017f, -0.04256469f, 0.06781831f, -0.02348988f, 0.03957601f, 
    -0.01018947f, 0.03870519f, -0.01049090f, -0.07656138f, 0.04617136f, 0.00635112f, 0.00927722f, -0.04013967f, 
    -0.09335302f, 0.00329974f, 0.08166458f, 0.14683190f, 0.11088751f, -0.11734818f, 0.00015007f, -0.01652370f, 
    -0.03161997f, -0.00891226f, 0.00882225f, 0.01078726f, 0.03168811f, -0.04425376f, 0.04826230f, -0.27152410f, 
    0.03875830f, 0.09424300f, 0.03641305f, -0.03802005f, 0.01794549f, 0.00037000f, -0.00628218f, -0.08568708f, 
    0.17132378f, 0.01398876f, -0.07428100f, -0.19120423f, -0.02012042f, 0.07592342f, 0.06274110f, -0.01557549f, 
    0.08172236f, 0.03777096f, 0.05288132f, -0.10054820f, -0.24020413f, 0.02819167f, -0.02376094f, 0.10053440f, 
    0.04021494f, 0.00528797f, -0.02789664f, -0.03050305f, -0.04876642f, -0.01512772f, -0.04862111f, 0.03695592f, 
    0.21361823f, 0.07009301f, 0.02325727f, -0.19216006f, -0.03977938f, -0.14575987f, -0.13010307f, -0.01083095f, 
    0.08259295f, 0.02233190f, 0.07343248f, 0.05656734f, -0.23179872f, -0.16882387f, -0.13308550f, 0.03436649f, 
    0.11248766f, -0.03909189f, 0.01004361f, 0.00998448f, -0.05442592f, -0.01630411f, -0.15223552f, -0.02413849f, 
    -0.09489684f, -0.15230873f, 0.27693027f, -0.21056078f, -0.04526830f, -0.08211404f, 0.05546849f, 0.05444650f, 
    -0.08364300f, 0.01395493f, 0.02624580f, 0.02995333f, -0.07404750f, -0.09032671f, 0.00790480f, -0.06149048f, 
    -0.09570053f, -0.01546763f, -0.00045389f, 0.15830626f, 0.08289748f, -0.01314348f, -0.00047293f, 0.09096900f, 
    -0.04329547f, -0.07302910f, 0.00919005f, -0.00202556f, 0.19532025f, -0.03878525f, -0.07714074f, 0.09904774f, 
    0.02733708f, 0.01314032f, 0.03040414f, -0.01492138f, 0.10520421f, -0.12293389f, -0.11453302f, -0.11484186f, 
    0.01947941f, -0.13581058f, -0.08153353f, -0.01161349f, 0.03519478f, -0.00789537f, -0.01851635f, -0.04220106f, 
    0.12436304f, 0.00858018f, -0.09797959f, -0.06683882f, -0.00740652f, -0.07484390f, -0.06855617f, 0.02476978f, 
    -0.11511701f, -0.02207847f, -0.07677506f, -0.06085161f, -0.25539407f, -0.05354936f, -0.07153308f, 0.12907353f, 
    0.13509591f, -0.15686692f, 0.00188413f, 0.09340413f, 0.13543335f, -0.05395273f, 0.10212151f, 0.15007907f, 
    -0.09095475f, -0.02258866f, 0.00604192f, 0.06300946f, -0.02929298f, -0.10239279f, -0.06756517f, 0.10699023f, 
    -0.05245052f, 0.11008033f, 0.13058229f, 0.03744810f, -0.11818071f, 0.03772955f, 0.01808011f, 0.14158954f, 
    0.01390607f, -0.00238460f, -0.05822368f, -0.02062630f, -0.04830192f, -0.06313692f, 0.01144520f, 0.03656335f, 
    0.08352787f, -0.23225027f, 0.08715324f, 0.02874933f, -0.07658397f, 0.00077201f, -0.01104377f, 0.07074293f, 
    0.04072219f, -0.08014119f, 0.07108411f, 0.04458258f, -0.24824804f, -0.12699485f, -0.06229853f, 0.05166027f, 
    -0.11928204f, -0.02978870f, -0.00036983f, -0.04699270f, 0.09880532f, 0.07079069f, -0.00740933f, 0.18484829f, 
    0.23471406f, 0.25852111f, -0.15948823f, 0.11958832f, 0.15654656f, 0.11174913f, -0.09788463f, 0.06795289f, 
    -0.01002683f, -0.06666315f, -0.05211082f, 0.10779869f, 0.16079707f, -0.10858861f, -0.33716479f, -0.30233333f, 
    -0.00759535f, 0.01119102f, -0.17270112f, -0.01856849f, 0.04560091f, -0.03034822f, -0.14063071f, -0.04291083f, 
    -0.04000859f, 0.09842881f, 0.10137996f, 0.12181085f, 0.00111877f, 0.06851222f, -0.04406257f, -0.01960640f, 
    0.00162391f, -0.01303782f, 0.04272328f, 0.12666444f, 0.05775559f, 0.04151467f, -0.05891224f, -0.03691914f, 
    -0.05856022f, -0.01731178f, -0.06826150f, -0.02418333f, -0.03210390f, -0.00001169f, 0.01867005f, 0.01819563f, 
    -0.08497422f, 0.00985829f, -0.01553063f, 0.04653727f, 0.06517559f, -0.02990634f, 0.11062326f, 0.02126868f, 
    0.04304644f, -0.05141123f, 0.11602780f, 0.10122386f, 0.09124155f, 0.17318130f, -0.01439320f, 0.09014881f, 
    0.10994198f, 0.10108382f, 0.17822932f, -0.00225396f, 0.11089167f, 0.01248823f, 0.02473921f, 0.06235952f, 
    -0.34091568f, -0.18997514f, -0.23165473f, -0.02702105f, 0.07684943f, -0.10627711f, -0.05017385f, -0.09587910f, 
    -0.08607908f, -0.06680515f, -0.00099723f, -0.02052401f, 0.34469363f, -0.03038653f, 0.07764031f, 0.04254623f, 
    -0.03689579f, 0.05097400f, 0.06178225f, -0.01214065f, 0.14253923f, 0.02910820f, 0.11986803f, 0.05443307f, 
    0.00082782f, 0.17058520f, 0.22862776f, 0.09218699f, 0.03024262f, 0.08951499f, 0.11867104f, 0.06916663f, 
    0.04550874f, 0.03708266f, 0.06577326f, 0.06713385f, 0.16285166f, 0.04011832f, 0.08376079f, -0.22725452f, 
    0.18572102f, -0.05900666f, -0.03282356f, -0.10227234f, 0.09090052f, -0.03919231f, 0.04144491f, -0.03513990f, 
    -0.20975156f, -0.07315942f, 0.10610697f, 0.14032951f, 0.18898475f, -0.02639193f, -0.05827792f, 0.06801424f, 
    0.04400552f, -0.01702869f, -0.02991382f, 0.07727433f, -0.22742184f, -0.01666627f, -0.27113080f, -0.25705421f, 
    0.07032336f, -0.12012476f, -0.02631777f, 0.02949573f, -0.05379005f, 0.04658875f, 0.16796081f, 0.00727411f, 
    -0.14855671f, -0.08945184f, -0.35068306f, 0.45444551f, 0.17411549f, -0.04406298f, -0.16646785f, -0.00251718f, 
    -0.06245640f, 0.00734449f, -0.11061602f, 0.06743571f, 0.24143024f, -0.10769629f, 0.02898938f, 0.03800789f, 
    -0.15706149f, -0.00510743f, -0.16599797f, -0.03733936f, 0.04032475f, -0.07541280f, 0.01354028f, -0.04861898f, 
    -0.26542962f, 0.10006335f, -0.03490555f, 0.07273293f, 0.10249496f, -0.09367532f, 0.08268561f, -0.04822232f, 
    0.05570254f, 0.00691912f, 0.03421588f, -0.09336834f, -0.07233118f, 0.10652469f, 0.20814183f, 0.17677894f, 
    0.05046131f, -0.05170923f, 0.03690865f, -0.07597879f, 0.01705602f, -0.05244803f, 0.05511327f, 0.05061580f, 
    -0.00635205f, -0.06173004f, 0.08757458f, 0.17611307f, 0.00661432f, 0.02420742f, -0.04674460f, 0.14078641f, 
    0.01764084f, 0.02246814f, 0.00701320f, 0.05391850f, -0.09594939f, 0.15237272f, 0.18576752f, -0.19460289f, 
    -0.05433356f, -0.06649169f, -0.04673189f, -0.06936182f, -0.00532401f, -0.03635960f, 0.06975418f, 0.05747413f, 
    -0.08168872f, 0.04427445f, -0.17083475f, 0.08874284f, -0.17634298f, 0.04811765f, 0.11162751f, -0.23681931f, 
    0.06808700f, -0.09551600f, 0.02286329f, 0.02467783f, -0.11512525f, -0.14332704f, -0.12007457f, -0.12409555f, 
    -0.08092064f, -0.10357188f, -0.10277744f, 0.04892793f, 0.07394698f, -0.01832997f, -0.02599859f, 0.03806568f, 
    0.30859023f, 0.30015108f, 0.17240673f, -0.18392093f, 0.06608430f, 0.00905378f, -0.02529679f, 0.12281837f, 
    0.06627400f, 0.02596173f, -0.05010188f, 0.01126820f, 0.20129953f, -0.10826063f, -0.13114296f, -0.10314208f, 
    0.11933827f, -0.02255492f, -0.00676584f, -0.17480119f, 0.10420243f, -0.05205384f, 0.06396474f, 0.07032019f, 
    -0.15851504f, 0.12258747f, 0.05301237f, 0.16091569f, -0.01059744f, 0.04562278f, 0.00884055f, -0.08645759f, 
    0.01636670f, 0.00070638f, -0.05978477f, 0.08027516f, 0.03368329f, 0.12813643f, -0.01540905f, -0.04832967f, 
    -0.01842404f, 0.01776607f, 0.03127960f, -0.04399870f, 0.09581774f, 0.05857766f, -0.02404152f, 0.01910536f, 
    0.22694881f, 0.21701860f, -0.00814670f, -0.11533634f, 0.07658804f, 0.06716908f, 0.04182231f, -0.10558476f, 
    0.02606787f, -0.11760384f, -0.09304547f, 0.05435029f, 0.23345967f, -0.01028868f, -0.18728013f, -0.14159662f, 
    0.04030504f, -0.00363621f, -0.15328771f, 0.04414022f, 0.07329472f, 0.07613380f, 0.11755829f, -0.01171849f, 
    0.06670043f, -0.00340421f, -0.07565576f, 0.12019923f, 0.17095631f, 0.04324719f, 0.11162273f, 0.07588585f, 
    0.05627974f, 0.01237427f, -0.04421608f, 0.02197010f, 0.11158875f, 0.12527493f, 0.22288907f, -0.16789681f, 
    0.05963575f, 0.06382632f, -0.02680730f, -0.13682170f, 0.04534025f, -0.00667654f, 0.14536099f, 0.00724352f, 
    0.18801141f, -0.07675570f, -0.02981680f, -0.08765042f, -0.00704652f, -0.01704252f, 0.07628793f, 0.04148223f, 
    -0.02242187f, -0.10599694f, -0.02788778f, -0.06160443f, 0.27201772f, 0.04251793f, 0.16141953f, 0.01051424f, 
    -0.03538382f, -0.07976172f, -0.04723571f, -0.04811683f, -0.05375529f, -0.02120985f, -0.06630351f, -0.00722560f, 
    -0.00410393f, -0.09154420f, -0.18361565f, -0.00328620f, 0.17851950f, 0.01035864f, 0.07459090f, -0.00602065f, 
    0.06748283f, 0.09733715f, 0.00070738f, 0.03504503f, -0.42282709f, -0.34351805f, 0.44437349f, 0.31899786f, 
    -0.10950937f, 0.02722337f, -0.17205282f, 0.17448226f, 0.13100366f, 0.05475178f, -0.10731634f, -0.02605930f, 
    -0.06315743f, -0.24730328f, -0.01672430f, -0.05669123f, -0.01631716f, 0.16975932f, -0.04008232f, 0.12358931f, 
    -0.09048599f, -0.10765219f, -0.09068117f, -0.04033520f, 0.04007781f, 0.07897606f, 0.27225953f, -0.33797753f, 
    0.06031916f, 0.07115791f, -0.12455533f, 0.05314958f, -0.00942945f, 0.14684312f, 0.03974361f, 0.18828042f, 
    -0.00080064f, 0.10563429f, 0.09432264f, 0.04747332f, -0.00708156f, -0.04393592f, 0.02658685f, 0.00583509f, 
    0.10546431f, 0.02666091f, 0.03461926f, 0.06049026f, 0.10327875f, -0.14417821f, -0.05271727f, 0.03614044f, 
    0.00942583f, 0.03762502f, 0.00475500f, 0.07330057f, -0.08806906f, -0.20002088f, -0.16374360f, -0.26910609f, 
    0.22038208f, -0.05797670f, 0.00492176f, 0.02661962f, 0.02762271f, 0.02207933f, 0.03795447f, 0.00458027f, 
    0.09116106f, 0.05006038f, 0.07777648f, 0.08028655f, -0.12729366f, 0.02037697f, 0.08303369f, 0.06897758f, 
    -0.01064439f, -0.00488849f, -0.03408346f, 0.07574698f, 0.00286478f, -0.01500631f, -0.03320220f, -0.05403848f, 
    0.21021050f, -0.03112905f, -0.00058079f, 0.01793400f, -0.03336190f, 0.03273716f, 0.02486066f, 0.04748179f, 
    -0.07665139f, -0.08515479f, -0.05165680f, -0.01137748f, 0.16727535f, -0.01666315f, 0.00844901f, 0.03653326f, 
    -0.02748041f, -0.03877514f, 0.05562883f, 0.00206714f, -0.10502272f, -0.06403987f, -0.04260161f, -0.04014748f, 
    -0.03742766f, 0.28304395f, -0.05763334f, 0.06776027f, -0.08833923f, -0.04629182f, -0.03269291f, 0.06533515f, 
    0.02636223f, -0.03811333f, 0.07530114f, 0.02835848f, 0.05381163f, 0.25063282f, -0.01763591f, 0.00190675f, 
    -0.12728959f, -0.13299371f, -0.00460475f, -0.06668013f, 0.08681558f, 0.00241198f, 0.00070053f, 0.05029767f, 
    -0.04908679f, -0.17869727f, 0.15871400f, -0.09519520f, 0.05280509f, -0.09633919f, -0.08445447f, 0.02551924f, 
    0.05170178f, -0.10942325f, 0.12629345f, -0.07600906f, 0.22633314f, 0.02246605f, 0.24839047f, -0.09595440f, 
    -0.12443204f, -0.08478196f, 0.00777325f, -0.02381345f, -0.00503439f, 0.02493368f, 0.02615665f, -0.01058965f, 
    0.23728196f, 0.12915033f, 0.03517241f, -0.10571137f, -0.02843410f, -0.03991402f, 0.01296904f, 0.01918705f, 
    -0.02663518f, 0.15044236f, 0.01231020f, 0.01509198f, 0.06028650f, 0.06709301f, 0.05301968f, 0.03233965f, 
    0.08589332f, -0.00607056f, -0.04598368f, 0.04968041f, -0.02870945f, -0.12430302f, -0.13115051f, -0.15524374f, 
    0.03640297f, 0.00058056f, -0.12864445f, 0.03468255f, -0.01294331f, 0.06244218f, 0.04043595f, -0.13116249f, 
    0.13562444f, 0.16797513f, 0.17482753f, 0.16849005f, -0.11111764f, 0.07104819f, 0.19771896f, 0.01269918f, 
    -0.04369988f, -0.00894515f, -0.05052534f, -0.07016634f, 0.07037476f, 0.00242996f, -0.02389597f, -0.09281885f, 
    -0.13734718f, 0.07779039f, -0.03297580f, -0.06825830f, -0.05083855f, -0.09335633f, -0.00228098f, 0.00650458f, 
    0.06041729f, -0.07813468f, -0.06440910f, -0.05336297f, 0.15919879f, 0.19541278f, -0.04416529f, 0.04540378f, 
    0.16281444f, 0.02456657f, 0.12501611f, -0.06048201f, 0.13273293f, 0.07587053f, -0.00767321f, 0.04932566f, 
    -0.05699924f, 0.04904805f, 0.11724741f, -0.14020897f, 0.05779385f, -0.07130708f, 0.15796575f, 0.01665202f, 
    0.03660870f, 0.05094832f, 0.08477407f, -0.04540909f, 0.02935621f, 0.05644409f, -0.02527962f, -0.06188807f, 
    -0.02520113f, 0.10012349f, -0.05427677f, 0.04853154f, -0.08127210f, 0.02511482f, -0.10561529f, -0.03746984f, 
    0.26402089f, 0.19173454f, 0.04896821f, -0.16961971f, 0.14038311f, -0.12196613f, 0.06332613f, 0.01795751f, 
    0.00304545f, 0.02745228f, 0.12996297f, 0.08466247f, 0.04046231f, -0.03483717f, -0.05073380f, 0.02310036f, 
    0.00474896f, 0.02874871f, 0.04116536f, 0.01986921f, -0.05983969f, -0.11117358f, -0.04396480f, -0.06266809f, 
    -0.04681770f, -0.33381820f, 0.10798762f, 0.11498043f, -0.05088066f, 0.01302798f, 0.02553230f, 0.03607126f, 
    -0.02655401f, 0.08229265f, 0.07227819f, 0.14112838f, 0.01632092f, 0.16520518f, 0.11007764f, 0.20453632f, 
    -0.05979884f, -0.05712453f, -0.08053818f, 0.00039167f, -0.03262506f, -0.04779905f, -0.06192750f, 0.07988000f, 
    -0.03253248f, 0.04598683f, -0.18175955f, 0.20541333f, 0.06268670f, 0.00860995f, 0.11030712f, -0.00493938f, 
    -0.02126610f, -0.06454241f, 0.01109174f, 0.01728661f, 0.43281522f, -0.02624463f, -0.00959054f, 0.08634575f, 
    0.01699716f, -0.02090847f, 0.01735139f, -0.04318949f, -0.01905081f, 0.09000053f, -0.04504973f, 0.06928232f, 
    -0.15716675f, -0.06859852f, 0.12651169f, 0.15710394f, -0.02641831f, 0.00150806f, 0.00565164f, -0.01541247f, 
    0.01959129f, 0.14311603f, -0.08510634f, -0.01777848f, -0.31817818f, 0.00002512f, 0.04047772f, 0.09580970f, 
    0.01473657f, -0.10987837f, -0.06183371f, -0.00768218f, 0.12409046f, 0.00251150f, 0.08986539f, -0.06387492f, 
    0.16341506f, 0.19909945f, -0.11315047f, 0.00562675f, 0.02658224f, 0.08143840f, -0.06995048f, -0.03875021f, 
    -0.03044293f, -0.04222734f, -0.02414361f, 0.10922976f, -0.19000831f, 0.07073846f, 0.04022180f, -0.04472866f, 
    -0.05315765f, -0.04279536f, -0.07882261f, -0.02008556f, 0.04352767f, 0.04103404f, 0.07313041f, 0.04136097f, 
    -0.11516426f, -0.13663830f, 0.03442898f, 0.16872950f, 0.06855604f, 0.01681734f, 0.03111218f, 0.05846033f, 
    -0.12304476f, -0.11214004f, -0.00020147f, -0.03593524f, -0.08203983f, 0.08416221f, 0.07669265f, 0.10461075f, 
    -0.10167933f, -0.02363162f, -0.02927314f, 0.01118914f, 0.04412363f, -0.00575703f, -0.07896549f, 0.03465722f, 
    0.10291717f, 0.21833210f, 0.09050940f, -0.12343789f, 0.15446728f, 0.05042399f, -0.00437087f, 0.12839204f, 
    0.00402233f, -0.05821883f, 0.12295945f, -0.01183466f, 0.30133837f, -0.14860012f, -0.00219160f, 0.10227783f, 
    -0.02013737f, -0.01103742f, 0.06530545f, 0.03511372f, -0.00817476f, 0.04253310f, -0.01624692f, -0.04830116f, 
    -0.08961120f, 0.03108493f, -0.10114092f, -0.04618225f, 0.02993407f, 0.00594166f, -0.12207946f, -0.10116190f, 
    -0.01829203f, 0.02466155f, 0.06086564f, 0.09068215f, 0.11682943f, 0.13002832f, 0.06496153f, -0.12309109f, 
    -0.05651283f, 0.05243000f, 0.12306768f, -0.11121633f, -0.08142141f, 0.08693863f, 0.00347489f, -0.00521632f, 
    -0.06953303f, -0.06611507f, 0.00967798f, -0.05373610f, 0.05847129f, 0.01894814f, 0.03456677f, 0.01763873f, 
    0.08178361f, 0.09140732f, 0.06537338f, 0.05965662f, 0.29852447f, 0.29696640f, 0.06762926f, -0.01842912f, 
    -0.18363315f, -0.11636318f, -0.00817353f, 0.06030505f, 0.06164527f, 0.05078543f, -0.05179365f, 0.03768743f, 
    0.23062167f, 0.04855015f, 0.02033348f, -0.01248608f, -0.07171289f, 0.01058573f, 0.03111750f, 0.02855512f, 
    0.02294473f, 0.02614754f, -0.02149343f, -0.01646964f, 0.20692663f, 0.08138636f, 0.22686265f, -0.25985381f, 
    0.04900058f, 0.05145749f, 0.11260763f, -0.01882554f, 0.15129894f, 0.12130506f, 0.05494846f, -0.02883919f, 
    -0.03083898f, 0.02686996f, 0.15488334f, 0.11581592f, -0.15952972f, -0.11458608f, -0.06042756f, 0.00834096f, 
    0.09653734f, 0.07183884f, 0.10761133f, 0.04244033f, 0.27171627f, -0.05092379f, 0.00467983f, -0.07867745f, 
    0.05026436f, -0.03409737f, 0.08468075f, 0.02132023f, -0.07810722f, 0.01419077f, -0.02735397f, 0.08352219f, 
    -0.24324794f, -0.01468565f, 0.05001003f, 0.27450258f, -0.08762705f, -0.04938814f, -0.05215623f, 0.00952660f, 
    -0.01991152f, -0.02183976f, -0.01360506f, -0.14893654f, -0.43451467f, -0.06677435f, -0.38830572f, 0.05222320f, 
    -0.04428654f, 0.00006485f, 0.08608717f, -0.00349444f, -0.04254988f, -0.05225847f, 0.06986648f, -0.04105663f, 
    -0.17712896f, 0.00050198f, -0.06988632f, 0.29330006f, 0.04299541f, -0.05112178f, -0.01802160f, 0.02396283f, 
    -0.05019562f, 0.04223954f, 0.01657933f, -0.07592775f, -0.16630729f, -0.44697112f, 0.18951592f, 0.19680634f, 
    -0.04651692f, 0.03032393f, -0.02582107f, 0.06301992f, 0.08778707f, 0.01454522f, 0.17226879f, 0.14462073f, 
    -0.37892431f, -0.28043371f, 0.22200540f, 0.03293642f, 0.00762014f, -0.01622873f, -0.03550380f, 0.07391877f, 
    0.05439715f, -0.02781986f, -0.06362849f, -0.09476959f, -0.12912792f, 0.00013248f, 0.19908631f, -0.00136198f, 
    -0.05826482f, -0.05104276f, 0.07012340f, -0.08441269f, 0.02524331f, -0.01341849f, -0.04834406f, -0.07999603f, 
    -0.04829485f, 0.05481323f, 0.10225700f, 0.07567365f, -0.08539947f, -0.05542336f, -0.13890709f, -0.12027526f, 
    0.06110960f, -0.03680849f, -0.08625425f, -0.00777254f, -0.16422848f, -0.00433231f, 0.12316057f, 0.08356370f, 
    0.02704121f, 0.07505542f, 0.13191617f, 0.00786968f, 0.10781827f, -0.02573755f, 0.07090257f, 0.00392060f, 
    -0.06229678f, 0.04978675f, 0.01188039f, 0.03480847f, -0.03679410f, 0.04762494f, 0.02189471f, -0.03454310f, 
    -0.09464421f, -0.01665118f, -0.05050838f, -0.09532949f, 0.15261993f, 0.08536050f, -0.07249973f, 0.01589991f, 
    -0.04121162f, -0.05512414f, -0.02024731f, 0.02425915f, 0.07271954f, -0.00465842f, 0.01401189f, -0.00280300f, 
    0.07049955f, 0.33779073f, 0.15246868f, -0.21624963f, -0.05230746f, 0.00078880f, -0.01542563f, -0.02519783f, 
    0.02099041f, 0.06668334f, -0.13255242f, 0.03998621f, 0.26276639f, -0.02381345f, -0.02290053f, 0.02545874f, 
    0.05595885f, 0.03473183f, 0.01032188f, -0.02363504f, 0.02815004f, 0.08449780f, 0.01987869f, 0.01671832f, 
    -0.15785885f, -0.03777321f, 0.08562993f, 0.01259040f, -0.08630319f, -0.02018774f, -0.00052572f, 0.00525690f, 
    0.01396390f, -0.01227301f, 0.02853051f, 0.05084223f, 0.13633087f, 0.21831781f, 0.04559549f, -0.02752186f, 
    -0.00768615f, 0.01758891f, -0.01169118f, -0.06927935f, -0.02971461f, 0.04411849f, 0.17282438f, 0.21779421f, 
    0.18361753f, 0.32595992f, -0.06555749f, -0.23040612f, 0.08797683f, -0.04227886f, 0.15153748f, -0.08991913f, 
    0.03738017f, 0.15939260f, -0.01646607f, -0.00201873f, 0.16989370f, -0.21822868f, -0.00033694f, 0.03994697f, 
    0.00597522f, 0.19667467f, 0.02671728f, -0.11748556f, 0.13415803f, 0.04346611f, 0.04291789f, 0.14509277f, 
    -0.02901529f, 0.02050306f, 0.04934085f, -0.01571487f, 0.00952681f, 0.06530426f, 0.06261981f, -0.06824168f, 
    -0.11422511f, -0.16802682f, 0.12862177f, -0.02246011f, -0.05708076f, 0.17098455f, 0.15216832f, -0.22240718f, 
    -0.09307777f, -0.22327422f, 0.03583119f, -0.03528281f, 0.01093933f, 0.08804251f, 0.15164733f, 0.09207539f, 
    0.18356851f, -0.29306561f, 0.15005042f, -0.18778102f, 0.09467233f, 0.04631483f, -0.00524072f, -0.00973144f, 
    -0.02129785f, -0.03949041f, 0.15544960f, -0.03546597f, 0.12217656f, -0.17376789f, 0.15127972f, -0.12835450f, 
    -0.01501738f, -0.14977363f, -0.16455857f, -0.09691805f, 0.08771273f, -0.11753380f, 0.06344301f, -0.06087183f, 
    -0.00394871f, -0.11003837f, -0.20099592f, 0.19032194f, 0.10455944f, 0.10816319f, 0.00664361f, -0.10277116f, 
    0.04210518f, -0.03086662f, -0.02673291f, 0.07600815f, -0.08643190f, -0.30866918f, 0.26124996f, 0.06530302f, 
    -0.17467292f, -0.16093160f, -0.04365649f, 0.10315911f, 0.08204564f, 0.06324690f, -0.05827715f, -0.11147565f, 
    0.00425386f, -0.17071477f, 0.12268986f, -0.06171361f, 0.00415820f, 0.07431871f, 0.01667150f, -0.03514607f, 
    -0.15023877f, -0.05376121f, -0.11415645f, -0.11527904f, 0.02688594f, 0.03352169f, 0.18970101f, 0.02082175f, 
    0.07725085f, -0.24525233f, 0.09356017f, 0.01329335f, 0.02997576f, 0.08301454f, 0.12408513f, 0.15921915f, 
    -0.06183735f, -0.04064653f, 0.11603028f, 0.08859637f, -0.01828606f, 0.04686518f, 0.04281488f, 0.01052324f, 
    0.14496638f, 0.02220912f, -0.02599905f, 0.06236289f, 0.15090580f, -0.23634915f, 0.22392406f, 0.04619261f, 
    0.14366230f, -0.01084187f, 0.00441520f, -0.18570629f, -0.30136850f, -0.10190614f, -0.15167697f, -0.33860952f, 
    0.14395341f, -0.04031884f, -0.05817524f, -0.10615802f, -0.01260381f, -0.03547511f, 0.01746367f, -0.11921787f, 
    0.13556796f, 0.04403293f, 0.00910994f, 0.06577455f, -0.17595416f, -0.15895461f, 0.02552270f, 0.13196106f, 
    -0.02384974f, -0.06559681f, 0.01702222f, 0.01722790f, 0.00670779f, -0.04790474f, 0.00413875f, -0.04214302f, 
    0.19561267f, -0.20791690f, 0.19249523f, -0.12780395f, -0.01511930f, 0.02420325f, -0.05784359f, -0.06654023f, 
    0.01214794f, -0.01333427f, -0.10030916f, -0.16996907f, 0.08415505f, -0.10496625f, 0.10573376f, -0.13236673f, 
    0.15949205f, -0.09442986f, 0.04843173f, -0.01268014f, -0.18751879f, -0.27372006f, -0.23051912f, 0.06867903f, 
    0.20565477f, 0.25017506f, 0.04819489f, 0.03633595f, -0.10328608f, -0.00825881f, -0.06227121f, -0.03729334f, 
    0.16668329f, -0.01737526f, 0.03210640f, 0.10771409f, 0.35782996f, 0.26316866f, 0.04233680f, 0.07738181f, 
    -0.10117216f, 0.00178869f, -0.02408719f, -0.07314906f, 0.14003731f, -0.09466294f, -0.04274442f, 0.26995787f, 
    0.04535414f, -0.37126076f, 0.48956901f, -0.19595841f, -0.00635609f, -0.07038254f, -0.09345908f, 0.06368461f, 
    0.05467160f, -0.04829947f, -0.02468407f, -0.09533496f, 0.10713592f, 0.02855285f, 0.14228454f, -0.03083818f, 
    0.00240905f, -0.04107014f, 0.08426679f, 0.02273205f, 0.16923700f, 0.08617786f, 0.09750998f, 0.14584883f, 
    0.09931628f, 0.07205649f, 0.02336716f, 0.07922783f, -0.00997325f, 0.05925383f, -0.05118550f, -0.12452761f, 
    -0.14281887f, 0.07795074f, 0.06721132f, 0.00158091f, 0.06100592f, -0.06426559f, 0.02964184f, 0.01563180f, 
    -0.10979300f, -0.18806171f, 0.11032796f, -0.11487938f, -0.07423530f, -0.22100180f, -0.18381958f, -0.08999806f, 
    0.17527881f, -0.18610333f, -0.12958170f, -0.03559692f, -0.06958264f, 0.20071468f, -0.00878053f, -0.22323160f, 
    0.05296836f, 0.14860716f, 0.19377270f, 0.11995196f, -0.19490704f, -0.00747196f, 0.05830359f, 0.15038121f, 
    -0.05281986f, 0.01742604f, 0.00719037f, -0.00135888f, 0.07132949f, -0.05384589f, -0.05197482f, -0.11853059f, 
    -0.14033028f, -0.07642277f, 0.01956876f, 0.18373041f, 0.05061541f, -0.03349838f, 0.02682657f, 0.10787985f, 
    -0.08715784f, -0.10110202f, -0.07809188f, -0.03301355f, -0.13053361f, 0.12935898f, 0.09833709f, -0.15422150f, 
    0.10691093f, 0.03834814f, 0.01806692f, -0.03380670f, 0.09506544f, 0.02730211f, 0.02898322f, -0.05324524f, 
    -0.25996563f, 0.06259594f, -0.24895312f, -0.03412042f, 0.01311683f, 0.02055751f, 0.11697394f, 0.06996409f, 
    0.02264506f, 0.04765951f, -0.04623971f, -0.07942740f, -0.16446202f, 0.11894651f, 0.03148292f, 0.06365015f, 
    0.09697386f, 0.05847266f, 0.06999137f, 0.05827127f, -0.13867737f, -0.07228950f, -0.16134134f, -0.04955596f, 
    0.07832211f, 0.23516569f, 0.08974183f, -0.07852427f, 0.24474962f, -0.03639229f, -0.15563178f, 0.06642561f, 
    0.13100983f, 0.06217987f, 0.09251023f, 0.07547673f, -0.16592887f, -0.02228640f, -0.03903231f, 0.08184721f, 
    -0.07479972f, -0.10110465f, 0.14716868f, -0.01917042f, -0.21208745f, -0.19289850f, -0.10821724f, -0.28397238f, 
    0.13781087f, -0.12145349f, 0.00679194f, -0.16686231f, -0.04742188f, 0.01071255f, 0.10547812f, 0.01488200f, 
    0.08122049f, 0.17051959f, -0.00278350f, 0.17989326f, 0.26757798f, 0.01906068f, 0.17684683f, -0.13192813f, 
    -0.15814720f, 0.00232642f, -0.16443413f, 0.14270619f, 0.10368858f, -0.06667998f, -0.00689406f, 0.00604808f, 
    -0.11137991f, -0.24801670f, 0.01057362f, 0.07001843f, -0.00170388f, 0.10264976f, 0.08916888f, -0.03715286f, 
    -0.02364831f, -0.08773439f, -0.04782605f, -0.03760498f, 0.29782137f, 0.07173508f, -0.07044155f, -0.05843729f, 
    0.01164992f, -0.05462583f, -0.00111185f, -0.11448340f, -0.02215010f, 0.08203357f, -0.00809457f, 0.06222356f, 
    -0.03502502f, -0.00648293f, -0.04346072f, -0.12649056f, -0.07793891f, -0.12284660f, -0.07182620f, 0.13443363f, 
    -0.09042317f, 0.04765997f, 0.02256636f, -0.03486886f, 0.41695648f, -0.02082820f, -0.07113148f, 0.06851628f, 
    -0.07036514f, 0.00370698f, -0.10348892f, -0.09368020f, 0.28126872f, -0.15379965f, -0.02942907f, 0.08132853f, 
    -0.13091470f, 0.17783959f, -0.04293275f, 0.09020330f, 0.01344283f, 0.05096084f, -0.01423177f, -0.07081779f, 
    -0.08434646f, -0.04574721f, 0.02728548f, 0.15260586f, -0.16960135f, -0.03788123f, -0.02532287f, 0.11023705f, 
    0.07622424f, 0.00006400f, 0.02752982f, -0.01842614f, 0.02711150f, -0.05070322f, 0.06472306f, 0.17548226f, 
    0.00063628f, -0.13497798f, -0.01530006f, -0.00674727f, -0.03165765f, 0.06362865f, -0.07226970f, -0.05411339f, 
    -0.15933502f, -0.18359032f, -0.02344861f, -0.07313029f, 0.32971302f, 0.16844380f, 0.10999358f, -0.18901946f, 
    -0.21496862f, 0.02254499f, -0.04869579f, -0.06519772f, 0.12801252f, 0.04081993f, -0.06098552f, -0.00599360f, 
    -0.14137052f, 0.38540632f, -0.22662717f, 0.01003374f, 0.11333745f, 0.02740904f, -0.06180354f, 0.08232037f, 
    -0.04344498f, -0.04231875f, 0.13627890f, -0.00979566f, -0.08132724f, -0.13088836f, 0.02906905f, -0.23417327f, 
    0.11302173f, -0.07327022f, 0.10240479f, -0.14020994f, 0.04074320f, 0.20389628f, -0.22850050f, -0.14338478f, 
    -0.13891758f, -0.00699396f, -0.05655156f, 0.16096385f, -0.00136132f, 0.08123056f, 0.04357297f, -0.00360462f, 
    0.08716655f, 0.04580017f, 0.00946719f, 0.08115699f, -0.04828041f, 0.30826247f, -0.06067195f, 0.06245061f, 
    0.02226425f, -0.02976369f, 0.04493819f, 0.03592465f, -0.07912874f, -0.06346398f, -0.10163031f, -0.02476423f, 
    -0.16821916f, -0.07828068f, 0.01892305f, 0.09053494f, 0.09510181f, 0.03331313f, 0.10970218f, -0.00306509f, 
    0.06412399f, 0.09295844f, -0.00309379f, 0.01843676f, 0.17205615f, 0.26663190f, 0.03293827f, -0.03259078f, 
    -0.12458538f, -0.13204847f, 0.01932279f, 0.00478054f, 0.07488201f, -0.06086597f, -0.05812578f, 0.14139140f, 
    -0.21189776f, -0.02440736f, -0.02355587f, -0.13824974f, -0.02627897f, -0.15636052f, 0.11429325f, 0.03017183f, 
    0.00036701f, -0.18547650f, 0.05163258f, -0.14701113f, 0.05064441f, 0.08559655f, 0.19220701f, -0.01759793f, 
    0.07454388f, -0.07030254f, 0.15098180f, -0.08990125f, 0.07913941f, 0.06810842f, -0.04326285f, 0.02784974f, 
    -0.05262591f, -0.07612295f, 0.17971650f, 0.18015353f, -0.09196204f, -0.11044885f, -0.02682826f, 0.04385062f, 
    0.15233390f, 0.09597538f, 0.02247864f, 0.07829972f, -0.04782289f, 0.24255233f, -0.11976358f, -0.03195287f, 
    0.13567844f, 0.03428667f, -0.04368074f, -0.06840634f, -0.09699155f, -0.00829622f, -0.01820603f, -0.11174763f, 
    -0.22337645f, -0.20101048f, -0.03289048f, 0.01680688f, -0.08999661f, 0.01885401f, -0.16036913f, 0.15759906f, 
    -0.00380207f, -0.11148036f, -0.05368546f, -0.07776324f, -0.12688179f, 0.04415678f, -0.22360930f, 0.17649299f, 
    -0.08160906f, 0.07281299f, 0.02484891f, 0.00101645f, 0.04188409f, 0.05200848f, 0.04819455f, 0.08619307f, 
    0.02900504f, -0.06641966f, -0.31121898f, 0.28250498f, 0.03757646f, -0.09669443f, 0.10932316f, -0.06844651f, 
    -0.08594262f, 0.03467432f, 0.03779975f, -0.05136495f, -0.21336633f, -0.08353171f, 0.05400252f, 0.00123543f, 
    -0.08422580f, -0.04507105f, 0.07406398f, 0.03544628f, 0.24973044f, 0.01211108f, 0.12597038f, -0.01917160f, 
    -0.17226028f, -0.23065597f, -0.09654944f, 0.08417974f, 0.11154363f, -0.18374002f, 0.01710190f, -0.03236792f, 
    0.11834134f, -0.07622723f, -0.20121810f, -0.00358457f, -0.19705203f, -0.17411852f, 0.07772943f, 0.10997939f, 
    -0.02854584f, -0.12766972f, 0.05981738f, 0.01033223f, -0.01440896f, -0.01588317f, -0.02725015f, 0.03778680f, 
    -0.07790825f, -0.03805448f, 0.06900722f, 0.11521979f, -0.06659663f, -0.05517852f, 0.04174675f, 0.06383153f, 
    0.05175572f, -0.06046404f, 0.01046707f, -0.03156389f, -0.14076303f, 0.16587079f, -0.01091191f, 0.16512536f, 
    0.09353136f, -0.00487446f, -0.06620699f, 0.04339802f, 0.15635864f, -0.02031399f, 0.11236705f, -0.10046731f, 
    -0.13558541f, 0.13053240f, -0.09375098f, 0.12366334f, 0.09245536f, -0.03316319f, 0.07416055f, -0.05969008f, 
    0.03625029f, -0.08046564f, 0.02284149f, -0.12723005f, 0.06690688f, -0.02080782f, -0.02529665f, -0.08860813f, 
    -0.16020294f, -0.21772732f, -0.04243309f, -0.04394819f, 0.11219643f, -0.15923117f, -0.01421301f, 0.10694632f, 
    -0.05465822f, 0.18633670f, 0.07618987f, 0.10392582f, -0.00189575f, 0.00422898f, 0.03329663f, 0.05730256f, 
    0.00812706f, -0.04419184f, 0.07791681f, 0.14794715f, 0.19798014f, -0.10927907f, 0.06590080f, -0.20127700f, 
    0.03991204f, -0.13925509f, -0.01190325f, 0.01966674f, -0.02954474f, -0.10215857f, 0.01680417f, -0.01532880f, 
    -0.25793836f, -0.10761126f, -0.04341708f, 0.12308610f, -0.13441937f, -0.11247322f, -0.04259422f, -0.04073536f, 
    0.04090052f, -0.05255044f, 0.07936535f, 0.07025985f, 0.01833562f, 0.20536019f, 0.10813175f, 0.06582041f, 
    0.02090742f, 0.04498076f, 0.03284637f, -0.15494581f, 0.12469788f, 0.13459794f, 0.09693474f, 0.09450522f, 
    0.02157415f, 0.37101072f, -0.04787060f, 0.04621064f, 0.15966965f, -0.02246146f, 0.19351617f, -0.04180006f, 
    0.00495080f, 0.08821563f, 0.02026617f, 0.08913048f, 0.10523291f, -0.03862740f, -0.29387566f, 0.15480375f, 
    0.10478591f, 0.03405387f, -0.07027277f, -0.02785804f, 0.25693643f, -0.06089884f, 0.03950249f, -0.02187549f, 
    0.06753036f, 0.05772913f, -0.14396305f, 0.17751519f, -0.06942035f, 0.07005820f, -0.02207916f, -0.15074541f, 
    0.00115116f, -0.12329965f, 0.10623398f, 0.07889041f, -0.03637052f, 0.06645704f, 0.28082961f, -0.03365815f, 
    -0.03051133f, -0.07628138f, 0.16006714f, -0.00315661f, 0.12653545f, -0.05071420f, 0.11744045f, 0.32030255f, 
    0.37494585f, -0.18175510f, -0.26237345f, -0.10897003f, 0.17532100f, 0.04553407f, 0.06887129f, 0.03222957f, 
    0.10150561f, -0.16757818f, -0.12835069f, 0.00632021f, 0.17822024f, -0.08708030f, 0.04292690f, -0.02070986f, 
    0.02805887f, -0.06416932f, 0.07696847f, 0.09980420f, -0.09890118f, 0.16641784f, -0.11079167f, 0.01237184f, 
    -0.17940228f, 0.09617799f, -0.26788694f, 0.13304690f, 0.00625867f, -0.06692017f, 0.05744160f, 0.06193553f, 
    0.08197229f, 0.08689974f, -0.01752794f, -0.03504404f, -0.31078818f, -0.18811496f, 0.33424339f, 0.17744631f, 
    0.01178253f, 0.00057620f, 0.03879937f, 0.00921164f, 0.03345012f, -0.01701276f, 0.10569201f, -0.11188680f, 
    -0.11753077f, 0.05711517f, 0.09266675f, -0.13497671f, 0.01315624f, 0.09424981f, 0.14395247f, 0.04641178f, 
    0.05502157f, 0.04044234f, -0.01875027f, 0.00193160f, -0.02860718f, -0.08618761f, -0.09571180f, -0.72541279f, 
    0.27446464f, -0.25807706f, -0.20172688f, -0.00203406f, 0.07881586f, 0.16073847f, -0.07607266f, -0.02331417f, 
    0.25792724f, 0.15030152f, 0.12699248f, -0.08878907f, 0.01476726f, -0.04277623f, 0.02241229f, -0.06778424f, 
    -0.01263084f, -0.10048835f, -0.01952010f, 0.03140252f, -0.01164427f, -0.03416745f, 0.05775779f, 0.04330657f, 
    0.01642665f, -0.01194146f, -0.00940265f, 0.05425369f, -0.06664325f, -0.03258931f, -0.03251352f, -0.10061756f, 
    -0.03289450f, -0.21530861f, -0.07970992f, 0.13251442f, 0.06781381f, 0.06232971f, 0.07207035f, 0.05837370f, 
    0.20620154f, -0.07707020f, 0.03520131f, 0.11675651f, -0.10440857f, 0.18718779f, 0.06937758f, -0.00559715f, 
    0.02814170f, 0.01193886f, -0.02084211f, -0.06779783f, -0.01292924f, 0.00927589f, -0.09503731f, -0.06578285f, 
    0.13911268f, -0.15973487f, -0.00216160f, 0.08885729f, 0.06516051f, -0.03006350f, 0.03045008f, 0.05762078f, 
    0.07257933f, -0.02509717f, -0.08372894f, 0.03862609f, 0.02047662f, -0.22201952f, -0.11784733f, 0.06729186f, 
    0.09904313f, 0.05234054f, 0.06421618f, 0.07288088f, -0.02549893f, -0.06060942f, 0.01040489f, -0.03272550f, 
    -0.24855565f, 0.15158482f, 0.03739202f, 0.07213350f, -0.01615114f, -0.05172693f, 0.00582580f, -0.00174715f, 
    0.08969037f, -0.01147236f, 0.04936513f, -0.10446883f, -0.30716479f, 0.27851632f, 0.14548969f, 0.23530634f, 
    -0.05065221f, -0.05252887f, 0.01743124f, -0.00323695f, 0.08933262f, 0.06265538f, 0.02622022f, 0.15943542f, 
    0.31727436f, -0.17998070f, 0.04779973f, -0.18355982f, 0.10670502f, -0.04720531f, -0.03558858f, -0.06703772f, 
    -0.03404195f, -0.18159647f, 0.06037020f, -0.02651118f, 0.33723763f, 0.08048657f, 0.08965378f, -0.02699146f, 
    -0.08395220f, -0.12063545f, -0.06466045f, 0.02256171f, 0.11866601f, -0.07546324f, -0.01884932f, -0.18403079f, 
    0.51853299f, 0.11520550f, -0.07201181f, -0.20564292f, 0.02234795f, -0.02072717f, -0.14476763f, 0.19588995f, 
    0.01425126f, 0.07198101f, 0.03001220f, 0.00122889f, -0.00445283f, 0.02994428f, 0.11188908f, 0.08430801f, 
    0.06380840f, -0.08974469f, -0.06288217f, -0.10380097f, 0.07711130f, -0.04941170f, -0.13602960f, -0.07122673f, 
    -0.07582454f, -0.06627859f, -0.10402244f, 0.20009629f, -0.02093100f, 0.12823661f, -0.00031262f, 0.02568552f, 
    0.10335029f, 0.03729991f, 0.17225882f, 0.18912371f, 0.09475992f, 0.22138938f, 0.12322215f, -0.03538471f, 
    -0.03524900f, 0.02590993f, -0.04534850f, 0.07675137f, 0.04282892f, 0.00995474f, 0.03575807f, -0.03025327f, 
    0.00430846f, 0.22316618f, -0.00827752f, -0.17745158f, 0.08533878f, -0.05286841f, 0.10653961f, 0.05167826f, 
    -0.01206342f, -0.08168318f, 0.04861313f, -0.04193634f, 0.18276125f, 0.09899088f, -0.23387285f, -0.13378268f, 
    0.09935740f, 0.04410792f, 0.11687963f, -0.09779593f, 0.21627301f, 0.15362723f, 0.02136976f, 0.05481270f, 
    -0.15223899f, 0.12077688f, 0.03535356f, -0.12485899f, 0.16795748f, -0.08915865f, 0.01970426f, 0.04425361f, 
    -0.10078952f, -0.05073917f, -0.01755037f, 0.05392356f, -0.11518764f, -0.20306695f, -0.15172282f, -0.04142184f, 
    0.19140829f, 0.31388208f, 0.14960924f, 0.26842836f, -0.05532786f, -0.07322369f, -0.02168543f, 0.02531848f, 
    0.29200786f, -0.02414130f, -0.09243472f, -0.24614851f, 0.10753147f, 0.01318185f, 0.07083327f, -0.03821952f, 
    0.13990609f, -0.03422475f, -0.00386544f, -0.02317106f, -0.05455951f, -0.09480622f, 0.01499975f, 0.21150172f, 
    0.02253651f, -0.07167438f, 0.13310462f, 0.07593860f, -0.06110685f, -0.07300184f, -0.05678582f, -0.03173080f, 
    0.05424958f, -0.38353774f, 0.27968261f, 0.02971947f, 0.01207559f, 0.03959741f, 0.03606274f, -0.03641553f, 
    0.18974082f, -0.08697481f, -0.01441118f, 0.08593072f, -0.17735888f, 0.10730966f, 0.28121206f, 0.51706988f, 
    -0.11630574f, -0.03006732f, -0.06658909f, 0.05447750f, 0.03501472f, -0.02035039f, -0.08329340f, 0.09096213f, 
    0.01133229f, -0.00220594f, -0.16108252f, -0.02075919f, -0.03984552f, 0.12535845f, 0.29246506f, -0.02158723f, 
    0.05387045f, -0.07118799f, 0.06830352f, 0.06147243f, 0.06180071f, -0.26509076f, -0.08352493f, 0.08723395f, 
    0.12071066f, -0.01031276f, 0.03983169f, 0.02009671f, 0.04070882f, -0.03642727f, 0.04046061f, 0.06893789f, 
    -0.09021680f, 0.00650993f, 0.21191807f, 0.14211592f, 0.08346540f, -0.02389760f, -0.03825169f, 0.11709566f, 
    -0.00800149f, 0.17810579f, 0.07816687f, -0.04400256f, -0.65098852f, 0.17799965f, 0.04127952f, 0.24926782f, 
    0.02304622f, 0.05828267f, 0.01846943f, 0.12263136f, 0.21489255f, -0.02618394f, 0.16755150f, 0.04061202f, 
    -0.04684277f, 0.26292768f, -0.17048205f, -0.08950937f, 0.08680389f, -0.03588489f, 0.11731457f, 0.09878056f, 
    -0.03749001f, -0.01053375f, -0.02178492f, 0.01632117f, -0.18101998f, 0.21259992f, 0.03755384f, 0.02452031f, 
    -0.06675431f, 0.05222335f, -0.04347498f, -0.02153513f, -0.05832767f, -0.03803034f, 0.07534095f, 0.02342667f, 
    -0.09165839f, -0.23880465f, 0.31536478f, 0.09433110f, 0.06850806f, -0.03836405f, 0.06513651f, 0.12617558f, 
    -0.04447021f, -0.14456141f, 0.04486382f, -0.01589011f, -0.20514128f, -0.00336038f, 0.31339499f, 0.38423294f, 
    -0.13507654f, -0.03362747f, -0.03453944f, 0.01123616f, 0.01976237f, 0.01534868f, -0.03089408f, 0.23325042f, 
    0.23341969f, 0.42945006f, -0.16785042f, -0.12794808f, 0.16495700f, -0.03637265f, -0.11260962f, 0.14729172f, 
    0.11686160f, -0.02335735f, -0.05125161f, -0.07713285f, 0.19180107f, -0.14665616f, -0.23873252f, 0.01235525f, 
    0.05141902f, 0.02474668f, 0.05771697f, 0.03774028f, 0.08714870f, -0.04760166f, -0.05337055f, 0.03393152f, 
    0.03069861f, 0.17482994f, -0.00576892f, 0.00316882f, 0.09454270f, 0.09923175f, 0.00335548f, 0.04044502f, 
    -0.01988425f, -0.03150542f, 0.03900390f, 0.01215319f, 0.23353708f, 0.05370700f, -0.19892579f, -0.13598594f, 
    0.02759030f, -0.12531035f, 0.21632630f, -0.10785559f, -0.02514815f, -0.02386856f, 0.04402068f, 0.07418770f, 
    0.12568915f, 0.00165568f, -0.09896123f, -0.04512159f, -0.02290388f, -0.07366617f, 0.00551898f, 0.07027336f, 
    -0.00211694f, -0.08237847f, -0.07457570f, -0.06487022f, 0.28925163f, 0.21456110f, 0.11182638f, -0.19461013f, 
    0.01154297f, -0.07877361f, -0.00084344f, -0.18003158f, 0.05405943f, 0.07859841f, -0.08690306f, 0.04541266f, 
    -0.09267291f, -0.10054950f, -0.06024624f, 0.09889232f, 0.15897596f, 0.02068763f, 0.05417649f, 0.02158689f, 
    -0.04134199f, -0.05476134f, -0.03120210f, 0.03177684f, 0.19252545f, -0.04737625f, 0.09340762f, -0.44444558f, 
    0.11191592f, -0.12807553f, -0.08471719f, -0.02848964f, 0.05191969f, 0.04345793f, -0.08149281f, 0.05207737f, 
    0.07393909f, 0.24026169f, 0.20391940f, 0.03253003f, -0.09256461f, -0.04435104f, -0.07629962f, -0.03177187f, 
    -0.03595347f, -0.04408606f, -0.03131631f, -0.00740172f, 0.34972516f, -0.20287843f, -0.26012930f, -0.14904980f, 
    0.04229647f, -0.07233044f, 0.19647452f, 0.14365984f, 0.05681331f, -0.01387662f, -0.09443729f, 0.01058467f, 
    -0.14523348f, 0.06782088f, 0.18210049f, -0.00779304f, 0.03084541f, 0.03661784f, -0.01633049f, 0.00101874f, 
    0.07251126f, 0.00792598f, 0.08082546f, 0.04848439f, -0.21376760f, -0.09332103f, -0.14798795f, -0.22673933f, 
    -0.03868481f, 0.05872552f, 0.01840911f, -0.02483026f, 0.02297416f, -0.04883748f, 0.02887794f, -0.17847697f, 
    -0.30081347f, -0.03315364f, 0.07308152f, 0.43732643f, -0.06218718f, 0.03591030f, -0.04532056f, -0.09615856f, 
    0.16334145f, -0.03382394f, 0.01862312f, 0.09802596f, 0.39739844f, -0.44763315f, 0.18338276f, 0.10726719f, 
    0.00286622f, 0.04938991f, -0.12046504f, 0.10418964f, 0.15691167f, -0.06972691f, 0.09039138f, 0.08603618f, 
    -0.35511890f, 0.03120480f, 0.15399732f, 0.02357283f, 0.01918170f, -0.02788812f, 0.09845221f, 0.10166043f, 
    0.07074913f, -0.05655990f, 0.07181125f, 0.00731729f, -0.07170306f, 0.19175901f, 0.09786624f, 0.02047323f, 
    0.01112162f, 0.02264642f, 0.02085060f, -0.07072830f, -0.01825161f, -0.07000920f, 0.01005956f, -0.04248741f, 
    0.10190053f, 0.19312888f, 0.13573936f, 0.04860195f, -0.10120396f, -0.04711911f, -0.06181620f, -0.06273255f, 
    0.02476727f, -0.09731398f, -0.07676982f, -0.05084198f, 0.13057527f, 0.16749831f, 0.08126665f, -0.29473838f, 
    -0.05896239f, 0.00303815f, 0.05472773f, -0.12419581f, 0.04885086f, 0.08402605f, -0.21848123f, -0.11940823f, 
    0.03700019f, -0.07842173f, 0.03807453f, -0.00081786f, 0.00434617f, 0.07864437f, 0.12038266f, -0.03749666f, 
    -0.05432827f, 0.01810095f, 0.01973194f, -0.01072872f, -0.07774201f, -0.07951988f, 0.00604433f, 0.20061220f, 
    0.04798785f, -0.01766300f, 0.01742355f, 0.04099923f, 0.08875493f, 0.08086298f, 0.14397982f, 0.09707499f, 
    0.42699033f, 0.13221358f, -0.18219435f, -0.41236573f, 0.08649269f, -0.17469698f, -0.11408867f, 0.17952543f, 
    0.06477588f, -0.02321043f, 0.00567204f, 0.03079164f, 0.17242150f, -0.27368876f, -0.00752047f, -0.03908711f, 
    0.25294828f, -0.13530751f, 0.05593551f, 0.09743965f, 0.08898197f, 0.01013742f, 0.03930356f, 0.18504485f, 
    -0.02424338f, 0.08950521f, 0.14295867f, -0.01378983f, 0.00843534f, 0.09779788f, 0.11409286f, -0.04023165f, 
    -0.02579014f, -0.02746242f, 0.00250743f, -0.01762642f, 0.05961493f, 0.10936871f, -0.10401285f, -0.08053727f, 
    -0.00700642f, -0.02420427f, 0.04350135f, 0.00168136f, 0.03555024f, 0.00393151f, 0.15285097f, 0.16134369f, 
    0.28898007f, 0.08080493f, -0.13710110f, -0.37327269f, 0.11548328f, -0.17877865f, 0.07615357f, 0.01001819f, 
    0.00218063f, 0.02503285f, 0.03710580f, -0.01504417f, 0.07023229f, 0.00931401f, -0.03602669f, -0.04053962f, 
    0.04206118f, -0.02240177f, -0.06168397f, -0.11134730f, 0.17101131f, -0.01376815f, -0.08020978f, 0.08052821f, 
    -0.04429986f, 0.00572071f, -0.01941646f, 0.00150649f, 0.13101810f, -0.12619594f, 0.06249704f, 0.08842108f, 
    0.05796284f, -0.08258933f, -0.07773610f, 0.09338755f, 0.29484713f, 0.11672341f, 0.02923900f, -0.27235085f, 
    0.09685612f, -0.12770368f, -0.09189334f, -0.19815290f, 0.05969323f, -0.07807250f, 0.18514431f, 0.16530763f, 
    -0.29151320f, -0.01503533f, 0.36884901f, -0.21769008f, 0.08569609f, 0.22170255f, -0.02121946f, -0.04314743f, 
    0.06085281f, -0.06149603f, 0.06117438f, 0.05940708f, -0.10129152f, 0.11419681f, -0.04102365f, -0.12718798f, 
    -0.06650747f, 0.03277030f, 0.03619068f, 0.03328018f, 0.03203220f, 0.04682720f, 0.06639216f, 0.09865627f, 
    0.03553144f, -0.02114107f, 0.08260079f, 0.18415129f, -0.02903147f, 0.16643064f, -0.06169353f, 0.12768707f, 
    -0.13729501f, 0.04614453f, 0.02835914f, -0.04968994f, 0.11514781f, 0.15785849f, 0.06049000f, 0.00262860f, 
    -0.10348074f, -0.00760394f, 0.27118465f, 0.01814562f, -0.07564481f, -0.10513309f, 0.13906738f, 0.01995320f, 
    0.24714082f, 0.06692662f, 0.28641695f, 0.15375662f, 0.10008997f, 0.05492049f, 0.10755159f, 0.04319496f, 
    0.15989909f, 0.06016880f, 0.10232117f, 0.08202359f, -0.15572375f, 0.08595030f, 0.25898740f, -0.08791325f, 
    -0.01535785f, -0.06288259f, 0.01352481f, 0.06071659f, -0.13717067f, 0.24945459f, 0.02243053f, -0.06122827f, 
    0.01346319f, -0.05268719f, 0.04982931f, -0.12313446f, 0.02873411f, 0.06650186f, 0.08974408f, -0.00203292f, 
    -0.13750862f, -0.19138257f, -0.10583526f, -0.10397089f, 0.15164796f, -0.20405510f, 0.04881676f, -0.24096517f, 
    -0.05450431f, 0.00778813f, -0.06598544f, 0.03875333f, -0.02988411f, 0.04617023f, 0.20048560f, 0.22246817f, 
    -0.06893414f, 0.06470866f, -0.09367548f, -0.25163570f, -0.08798550f, -0.23321483f, -0.05979982f, 0.04158298f, 
    -0.07668225f, -0.02796657f, -0.01858969f, -0.13604918f, -0.17289259f, -0.06416693f, -0.03009957f, -0.11741945f, 
    0.08123263f, 0.06180630f, 0.11445038f, 0.00936693f, 0.04422695f, 0.03027134f, -0.07684740f, -0.01986918f, 
    -0.28893068f, -0.00016341f, -0.04251301f, -0.27518755f, -0.13995588f, 0.04678297f, -0.04625974f, -0.04114797f, 
    0.13112102f, -0.09350765f, -0.01006802f, 0.17544721f, -0.23013462f, 0.05476104f, 0.05339369f, -0.10802879f, 
    -0.19577508f, -0.09412602f, -0.17737781f, -0.07051159f, -0.01337755f, -0.02602755f, 0.01707994f, -0.04360568f, 
    0.21757573f, -0.21053889f, -0.02798282f, 0.14951812f, -0.08790760f, -0.04003263f, 0.02342097f, -0.15769140f, 
    0.25302196f, 0.12850773f, 0.21108012f, -0.12858061f, -0.01425231f, -0.18317840f, -0.10712732f, 0.18865091f, 
    0.04161981f, 0.05889314f, 0.06968076f, 0.31872931f, 0.03013576f, 0.00745637f, 0.10792413f, 0.02394446f, 
    -0.11429235f, -0.12844943f, -0.01248821f, 0.09655909f, 0.08221327f, 0.05463092f, -0.11428165f, 0.00472014f, 
    -0.05279470f, -0.03966257f, -0.00020454f, 0.05965133f, -0.37485060f, -0.04783237f, -0.05093006f, -0.26318589f, 
    -0.09174328f, -0.04439200f, -0.06559730f, 0.02822904f, 0.12404399f, -0.01301093f, -0.09106454f, 0.01144222f, 
    -0.07629226f, 0.24181628f, -0.02439799f, 0.16813979f, -0.05906855f, 0.08320520f, 0.15797377f, 0.14497478f, 
    0.04984179f, 0.02559701f, -0.02727919f, 0.07282308f, -0.12841508f, -0.24706869f, 0.02072827f, -0.01127336f, 
    -0.20095786f, 0.00074795f, 0.10355293f, -0.09913173f, 0.01337619f, 0.07325143f, 0.03844889f, -0.02732036f, 
    0.23431225f, -0.14396617f, -0.07890972f, -0.03701772f, 0.04863370f, 0.00181831f, 0.21419159f, 0.32997820f, 
    -0.03755894f, 0.02431700f, -0.15193185f, -0.12345563f, -0.12673800f, -0.09794460f, -0.15378176f, 0.02119757f, 
    0.16768716f, 0.08334746f, 0.08933105f, 0.13014437f, -0.04971066f, -0.04428941f, 0.03605103f, -0.06359278f, 
    -0.11584277f, -0.17037985f, -0.13936548f, -0.16884671f, 0.21747762f, 0.16201204f, 0.16824670f, -0.12078919f, 
    -0.05896083f, -0.07231465f, 0.02909745f, 0.08842530f, 0.02395845f, 0.12027642f, 0.02824589f, 0.05498504f, 
    0.09522894f, 0.18802759f, -0.03718082f, 0.00817756f, 0.08745292f, -0.04061158f, 0.18615533f, -0.04462514f, 
    0.38699660f, 0.11371963f, -0.15468079f, 0.27659023f, 0.14841674f, 0.15144835f, -0.04230572f, 0.16083023f, 
    0.03292454f, -0.06942887f, 0.05891576f, -0.10451494f, -0.21687520f, -0.01103015f, 0.00677418f, -0.05083052f, 
    0.05445033f, -0.10026807f, -0.01635873f, -0.05705864f, 0.03574757f, -0.10024049f, 0.04744871f, -0.02806358f, 
    -0.09616359f, -0.05926646f, 0.11358071f, -0.04563598f, -0.12587976f, 0.07612241f, -0.17686246f, 0.13786648f, 
    0.00203507f, 0.02417677f, -0.06891809f, -0.22510365f, -0.18755324f, -0.07098202f, -0.01864213f, -0.17742462f, 
    -0.11651839f, -0.08562212f, 0.11404136f, -0.05761759f, 0.02131126f, -0.02500480f, -0.15490671f, 0.08188126f, 
    0.04802331f, 0.02262123f, -0.12210146f, 0.05752065f, 0.01770921f, -0.00162712f, -0.08258270f, -0.00677966f, 
    0.11616226f, 0.04553105f, -0.00580120f, 0.00784797f, -0.21760912f, -0.27359954f, 0.06737122f, -0.05696578f, 
    -0.15436052f, 0.03765774f, 0.00410985f, 0.05428509f, 0.16104867f, 0.00092895f, 0.18958618f, 0.00739163f, 
    0.22904915f, 0.05528507f, 0.14960487f, 0.01402967f, 0.02199622f, -0.03768327f, 0.04239750f, 0.05110512f, 
    -0.09643479f, 0.05053516f, 0.11097305f, 0.07052756f, -0.08778571f, 0.12492110f, -0.02745892f, -0.25277373f, 
    -0.11629346f, -0.10985106f, -0.10124426f, 0.05297072f, -0.00344412f, 0.02692154f, 0.02837827f, -0.22638260f, 
    0.20674399f, 0.08326975f, 0.02530846f, -0.03497178f, -0.07234831f, -0.17917746f, 0.07425737f, -0.02317435f, 
    0.11090034f, 0.00447745f, 0.05840168f, 0.20067461f, 0.01945250f, -0.05055931f, -0.04957107f, -0.14924105f, 
    -0.04716286f, -0.00091190f, 0.19594961f, 0.02036472f, 0.13555899f, -0.02161247f, 0.06698634f, 0.09526820f, 
    -0.47889265f, -0.12071972f, 0.28627214f, -0.09523890f, -0.00164099f, -0.13801652f, -0.00219956f, -0.03704666f, 
    0.03935299f, -0.09048662f, -0.06457692f, -0.00117594f, -0.11529229f, -0.02487029f, -0.05954392f, 0.07873486f, 
    -0.01840378f, -0.03885664f, 0.12994497f, 0.10031526f, -0.14974028f, -0.14864501f, -0.05190231f, -0.23901089f, 
    0.26751384f, -0.03086569f, 0.11847576f, 0.14130428f, 0.07717676f, 0.05786912f, 0.06669304f, 0.06337239f, 
    0.21625923f, 0.11748865f, 0.11740307f, 0.24185221f, -0.15177347f, -0.09367423f, -0.04922818f, -0.11546907f, 
    -0.03257708f, -0.04277399f, -0.03056184f, 0.01049405f, 0.03633270f, 0.02186307f, 0.11793352f, 0.09505181f, 
    0.06618848f, 0.36096475f, -0.00345223f, 0.31135443f, -0.02181769f, 0.00806939f, -0.07149950f, -0.07493569f, 
    0.11075251f, 0.17083488f, -0.02494509f, 0.11210524f, -0.07422207f, 0.04982539f, -0.04619328f, 0.14008194f, 
    -0.05467327f, 0.03783942f, -0.21979940f, 0.02576785f, -0.08837054f, 0.05147423f, 0.09385647f, -0.00473514f, 
    -0.09870861f, -0.06727468f, 0.02960237f, 0.00361665f, 0.02136917f, 0.07406693f, 0.04641871f, -0.13720252f, 
    0.06041581f, -0.08246957f, 0.04762501f, -0.16236590f, -0.34074077f, 0.09011784f, 0.04374170f, 0.21285407f, 
    0.17761052f, -0.07001013f, -0.24728177f, 0.07721368f, 0.05454778f, -0.04353324f, 0.05367962f, 0.02841929f, 
    -0.12426738f, 0.04204952f, 0.01903496f, -0.02090091f, 0.00641442f, 0.06273866f, -0.05563285f, -0.09437543f, 
    0.06105072f, -0.09655748f, -0.00902187f, -0.03426055f, -0.36781788f, -0.02555958f, 0.12255285f, 0.19830298f, 
    0.03349200f, 0.04709976f, 0.15609103f, 0.15963607f, -0.00698081f, -0.06514974f, 0.08126582f, 0.01930884f, 
    -0.41230533f, -0.13204230f, -0.10560624f, -0.24148588f, -0.06784143f, -0.22101094f, -0.08135965f, -0.09144253f, 
    -0.17296687f, -0.10975809f, -0.12789111f, -0.06211456f, -0.28763402f, 0.17416611f, 0.05065287f, 0.13471614f, 
    -0.07871959f, 0.04744155f, -0.02176778f, 0.05973383f, -0.02525801f, 0.03287752f, 0.09914998f, 0.16547287f, 
    -0.04406936f, 0.02097240f, 0.00527602f, -0.19799489f, 0.01612057f, 0.02574443f, 0.07635752f, -0.11108506f, 
    -0.04352034f, -0.20855157f, -0.06133660f, -0.18332833f, -0.13395081f, 0.07081281f, 0.03460886f, 0.08515378f, 
    0.14501067f, -0.04883647f, -0.15254797f, -0.05332015f, 0.19141158f, 0.04767135f, 0.09015597f, 0.06028052f, 
    -0.17848624f, -0.14828807f, 0.11800984f, 0.14599800f, 0.30579272f, 0.07489789f, 0.18159533f, 0.14058185f, 
    -0.10707705f, 0.01324554f, 0.09186855f, 0.12108568f, 0.37900731f, 0.13586274f, 0.03879017f, 0.22416569f, 
    0.12548792f, 0.05060435f, 0.00956853f, -0.01806973f, 0.16533226f, -0.08515598f, -0.05320168f, 0.01679143f, 
    0.44071221f, 0.14494075f, -0.02138860f, 0.36551499f, -0.01940723f, 0.28504461f, 0.07033809f, 0.06486287f, 
    0.12925625f, -0.01463796f, 0.04695615f, 0.11875514f, 0.09481821f, -0.09008224f, 0.12428222f, -0.09248310f, 
    -0.13755798f, -0.05829353f, -0.08133940f, -0.12232637f, -0.04943298f, -0.00433350f, 0.00870656f, -0.15604526f, 
    -0.10324594f, 0.33876756f, -0.08356511f, -0.09914084f, 0.11924018f, -0.01077759f, 0.15282999f, 0.19888748f, 
    0.03647359f, -0.06407464f, 0.05936661f, 0.01976308f, -0.21849839f, 0.00505607f, 0.01311309f, 0.00897812f, 
    -0.04761358f, 0.10635156f, 0.07038497f, 0.17529947f, -0.03884894f, -0.07607135f, -0.00498970f, -0.05842809f, 
    -0.13125072f, -0.35799968f, -0.20448261f, -0.12682161f, 0.08576712f, -0.02040223f, 0.07109849f, -0.10137913f, 
    -0.14658546f, -0.03200954f, -0.07580980f, -0.09923823f, -0.03341881f, -0.04558440f, -0.16227049f, 0.07854151f, 
    0.18348674f, 0.05919118f, -0.08666278f, -0.33286431f, -0.02162151f, -0.06633306f, -0.05933537f, -0.07837278f, 
    -0.21373306f, -0.14699078f, -0.09510451f, -0.07747902f, 0.14743870f, 0.05438029f, -0.19267787f, -0.09019582f, 
    0.06469160f, -0.12306771f, 0.14976318f, 0.04299108f, -0.02695998f, -0.10132932f, 0.01613828f, -0.12176278f, 
    -0.12978014f, -0.07275730f, 0.03731270f, 0.03146333f, 0.14610988f, 0.11396616f, 0.06792809f, 0.12437793f, 
    -0.12134956f, 0.02451875f, 0.06057850f, 0.14567432f, -0.00362738f, 0.01004864f, 0.06102596f, -0.06837331f, 
    0.06382043f, 0.04055829f, -0.00453417f, 0.00417761f, -0.34767488f, 0.13376592f, 0.06900066f, -0.10640061f, 
    -0.07436458f, 0.01923748f, -0.00043537f, -0.15823455f, 0.05700338f, -0.04204914f, 0.21798505f, 0.17951556f, 
    -0.00937321f, -0.06075108f, 0.00258099f, -0.02488439f, 0.09712849f, 0.05391371f, 0.09373482f, 0.03234732f, 
    0.06133160f, -0.01871616f, -0.02153569f, 0.03114684f, 0.00302518f, 0.00627094f, -0.16097052f, -0.06665045f, 
    0.04318912f, 0.01987405f, 0.03536936f, -0.01230101f, 0.17726794f, -0.07439946f, -0.15847430f, -0.37099931f, 
    -0.15667804f, 0.20289384f, 0.00814397f, 0.09404612f, 0.02982543f, 0.18596470f, 0.00008008f, 0.21555290f, 
    0.02043568f, -0.07638498f, 0.08484601f, 0.11673616f, -0.46543407f, 0.06793080f, -0.17142102f, 0.18742731f, 
    0.06280445f, -0.02926056f, 0.00434001f, 0.03047955f, -0.11038562f, 0.09601945f, -0.01004684f, -0.03131516f, 
    0.16725750f, 0.00014026f, -0.00039907f, 0.16237314f, 0.13440354f, 0.03273371f, 0.05976847f, -0.00198411f, 
    0.19964121f, 0.13189103f, 0.01856283f, 0.17302817f, -0.06359830f, -0.04802169f, 0.00028934f, -0.16061164f, 
    -0.12640819f, 0.21845743f, 0.10358924f, 0.18484648f, -0.07737307f, -0.07803927f, 0.00145600f, -0.14869915f, 
    0.14018378f, -0.12713103f, 0.10698118f, 0.11648663f, 0.04176833f, -0.22852764f, 0.02170226f, 0.00852617f, 
    -0.09216888f, 0.03814879f, -0.01712948f, 0.04762096f, -0.06698176f, -0.17223948f, 0.12496881f, -0.05177808f, 
    -0.09474205f, -0.11751740f, -0.04299708f, -0.23052388f, 0.08286663f, 0.09068678f, -0.06733779f, -0.01711773f, 
    0.02817451f, 0.09780187f, 0.02494538f, -0.04776759f, 0.16186118f, -0.07587580f, 0.06386203f, 0.06115912f, 
    0.03868460f, -0.05746735f, -0.12657659f, 0.11121958f, 0.40588632f, -0.04575962f, 0.24233812f, -0.03037840f, 
    0.04591524f, -0.10791753f, -0.03219511f, 0.00413566f, 0.04378906f, 0.09628844f, -0.05420138f, 0.01564978f, 
    -0.12220114f, 0.22684109f, 0.07212770f, 0.03403055f, 0.03378921f, -0.00708135f, 0.00003031f, -0.01907515f, 
    -0.05789266f, -0.01176253f, -0.00152664f, -0.07017289f, 0.19165954f, -0.09624336f, 0.03759315f, 0.53009784f, 
    -0.01101288f, -0.10583469f, 0.17943658f, -0.22158875f, 0.20393246f, -0.12431778f, 0.04088423f, 0.04494151f, 
    0.04202689f, 0.10258583f, 0.13140154f, 0.21897623f, 0.11539286f, -0.03963589f, 0.07456877f, 0.13933392f, 
    0.11223663f, 0.04035603f, -0.03092705f, 0.02014877f, 0.05563693f, 0.36648467f, 0.19418937f, 0.25950611f, 
    -0.02866403f, 0.13697267f, 0.07191122f, -0.17467032f, 0.04867441f, -0.02189150f, 0.04871016f, -0.05049500f, 
    -0.00190910f, -0.11023609f, 0.14372173f, 0.13559867f, -0.09464592f, 0.05640129f, -0.05481303f, -0.13692695f, 
    0.08183981f, -0.07303480f, 0.04666255f, 0.11227550f, 0.37504598f, 0.20380703f, 0.18189964f, 0.36012924f, 
    -0.00806451f, 0.11084343f, 0.07223180f, 0.13818632f, -0.05952077f, -0.01519614f, 0.01985000f, -0.08634195f, 
    0.25637016f, -0.11166997f, 0.01576683f, 0.19477277f, -0.00530223f, -0.09516428f, -0.00847953f, -0.12009777f, 
    -0.09552076f, 0.13477944f, -0.03419064f, 0.04468550f, 0.06946984f, -0.16264629f, 0.04896368f, -0.03362945f, 
    -0.02207384f, -0.19529720f, 0.07482709f, -0.02399084f, -0.01827128f, 0.01683797f, -0.07774439f, 0.02007468f, 
    0.26585707f, 0.34589246f, 0.03165103f, -0.10299860f, 0.12851420f, 0.06958437f, 0.09017721f, 0.17927444f, 
    -0.12543021f, 0.02248267f, -0.24878198f, 0.23358552f, 0.28225172f, 0.21641549f, -0.01474641f, -0.10914356f, 
    -0.03245313f, 0.03391523f, -0.08143521f, -0.11279676f, 0.01812242f, -0.01535490f, -0.04705027f, -0.00556652f, 
    -0.09465439f, -0.09467505f, 0.07029183f, -0.15359429f, -0.08790585f, 0.02527216f, -0.08046919f, 0.00915300f, 
    -0.02835601f, 0.11714155f, 0.02677658f, 0.03024822f, 0.56736684f, 0.11684472f, 0.21674836f, 0.24360731f, 
    -0.02106252f, 0.02584970f, 0.14172965f, -0.07908577f, 0.07198568f, 0.04514326f, -0.00330628f, 0.05137394f, 
    -0.06692521f, -0.19016901f, 0.07611113f, -0.23336172f, -0.07014173f, 0.04377253f, -0.14764167f, -0.12612879f, 
    0.06215259f, 0.00617449f, 0.13075399f, 0.01165454f, 0.22889505f, 0.16610728f, -0.14440610f, -0.10088632f, 
    0.09914960f, -0.04297182f, -0.05277802f, -0.05164369f, -0.01247884f, -0.01645390f, 0.03337712f, 0.09514406f, 
    -0.47433987f, 0.17616716f, 0.13841879f, -0.21104920f, 0.04309813f, 0.22204719f, -0.14481720f, -0.30676085f, 
    0.13675022f, 0.05874249f, 0.05175809f, 0.07791646f, 0.00935651f, 0.05474125f, 0.15315789f, 0.11874786f, 
    -0.02085509f, 0.02709024f, 0.09414569f, 0.11445899f, -0.00615056f, -0.00298105f, 0.01265972f, 0.14595641f, 
    0.09626693f, 0.23662686f, 0.15413541f, 0.30304161f, -0.15022321f, 0.09976756f, -0.07578001f, 0.20039077f, 
    0.00265518f, 0.00911703f, 0.00291333f, 0.06698281f, -0.45177245f, 0.02588202f, 0.04103161f, -0.16749805f, 
    -0.16092585f, -0.13055028f, 0.05542757f, 0.00461443f, 0.04639613f, 0.06166609f, -0.19799365f, 0.09213107f, 
    -0.34578213f, -0.10399240f, 0.17496486f, 0.14664769f, -0.14667007f, -0.02480520f, 0.12905860f, -0.17153858f, 
    0.00612525f, 0.03092823f, 0.03537289f, 0.11053644f, 0.02602209f, 0.28869918f, 0.16009864f, 0.05550547f, 
    -0.08678332f, 0.03929819f, -0.04487335f, 0.18066712f, -0.01643971f, 0.02263411f, -0.06822713f, -0.07263078f, 
    -0.32850558f, 0.02869158f, -0.15885776f, 0.02019381f, 0.01424742f, -0.07274896f, -0.12643147f, -0.03909858f, 
    0.00519488f, 0.05095312f, -0.02723168f, 0.11085579f, 0.07645372f, -0.12221497f, -0.12770008f, -0.00645609f, 
    0.00784726f, -0.03132472f, -0.12070067f, -0.05144391f, -0.01121531f, 0.04688602f, 0.06737573f, 0.01536666f, 
    0.27603257f, 0.25992739f, 0.37525731f, 0.10014074f, 0.02301192f, 0.03630256f, 0.01458493f, 0.03344707f, 
    -0.07182590f, -0.05492711f, -0.04695560f, -0.16756053f, 0.39780822f, 0.30862918f, -0.11736163f, -0.02382723f, 
    0.09632186f, 0.03969604f, -0.01647411f, -0.02854569f, -0.05669001f, -0.03102695f, -0.08718923f, 0.04972320f, 
    -0.56122464f, -0.01047662f, 0.27072507f, 0.06838090f, -0.05437924f, 0.04121491f, -0.04906245f, 0.02311530f, 
    0.01210572f, -0.08515618f, -0.07886466f, 0.02812562f, 0.01738407f, -0.05037684f, 0.09039575f, 0.11592393f, 
    -0.11682750f, -0.12491965f, -0.03688898f, -0.06699490f, 0.02404239f, -0.10034978f, 0.03052953f, 0.13590476f, 
    -0.09594496f, -0.06075734f, -0.14608416f, -0.14006212f, 0.00298567f, 0.05327839f, -0.16803564f, -0.10390864f, 
    0.06110216f, 0.06632831f, 0.05995119f, -0.31910083f, 0.34652448f, 0.05702615f, -0.12959664f, 0.20702215f, 
    -0.06539462f, 0.06926407f, -0.13752519f, -0.00924395f, -0.21985394f, 0.07878260f, -0.11514369f, 0.05006336f, 
    -0.00612443f, 0.21442439f, -0.19148996f, 0.17148022f, -0.06318667f, -0.02351594f, -0.14465146f, -0.14105402f, 
    -0.03713933f, -0.03655269f, -0.07145248f, -0.15793306f, 0.21487518f, 0.07214252f, 0.14116925f, 0.08407703f, 
    0.16508262f, 0.08484113f, -0.16058360f, -0.00805777f, 0.02789704f, 0.05195957f, -0.13798383f, 0.13048849f, 
    0.03823568f, 0.26446855f, 0.02889788f, -0.05679335f, 0.05394327f, 0.10868491f, 0.11345597f, -0.00019524f, 
    -0.11772855f, -0.02831965f, 0.01271813f, -0.04521928f, 0.30662119f, 0.00613105f, -0.19694892f, -0.05330707f, 
    -0.04321925f, 0.04761863f, -0.07246003f, -0.08979060f, 0.05731851f, 0.01151786f, 0.01436779f, 0.06028448f, 
    -0.27654317f, 0.02388597f, -0.16951643f, -0.05270273f, -0.00154050f, 0.01283376f, 0.00525380f, 0.02929677f, 
    0.03744238f, -0.02771400f, -0.00222959f, 0.06612196f, -0.16201146f, -0.14086097f, 0.37992373f, -0.30816340f, 
    -0.03165478f, -0.29612222f, 0.07199406f, -0.06494398f, 0.03791300f, 0.04272385f, -0.13384578f, -0.11790323f, 
    0.07506439f, 0.07241309f, -0.00014209f, 0.12085629f, 0.10253879f, 0.07353169f, 0.08017579f, 0.25620222f, 
    0.00748405f, -0.00092013f, -0.09582150f, 0.05004039f, 0.05365570f, 0.07268107f, 0.11798596f, 0.09399817f, 
    0.02523826f, 0.06877212f, 0.12922324f, 0.02375914f, -0.03387900f, -0.03169490f, -0.07494929f, -0.13390015f, 
    0.21819888f, 0.09778813f, 0.14895490f, 0.09141545f, 0.14589220f, 0.02262982f, 0.04275717f, 0.17659931f, 
    -0.01480102f, 0.02255321f, -0.01496462f, -0.03233944f, 0.45700482f, 0.16545540f, 0.00295779f, -0.00325156f, 
    -0.04012465f, 0.11324199f, -0.00051991f, -0.00942035f, -0.00578103f, 0.05936839f, -0.00663376f, -0.05775308f, 
    -0.16077791f, -0.09331403f, -0.03357024f, 0.16867797f, -0.26031470f, -0.10492787f, -0.10480455f, -0.08609336f, 
    0.13747288f, 0.04219236f, 0.07064973f, 0.03306706f, 0.41181180f, -0.10771288f, 0.11464105f, -0.00699466f, 
    0.02550467f, -0.03312292f, 0.00601886f, -0.05966391f, 0.13004331f, -0.07058477f, -0.12733996f, -0.00180640f, 
    0.24599561f, 0.06717622f, -0.06431621f, 0.26801437f, 0.14213406f, 0.02891605f, 0.02033963f, 0.20423265f, 
    -0.02042448f, 0.05032323f, -0.01226645f, 0.14445883f, -0.19013017f, -0.11184715f, 0.06033304f, 0.02463270f, 
    -0.16280472f, -0.05031315f, 0.07764889f, -0.05121389f, -0.09925736f, -0.01216692f, -0.18875802f, 0.05613149f, 
    0.19748414f, 0.26035815f, -0.25917783f, 0.11072324f, -0.15994675f, 0.01865346f, -0.02579479f, 0.13410619f, 
    -0.01070746f, 0.05433452f, -0.14255457f, -0.10207594f, -0.17125386f, 0.18079552f, 0.18745892f, -0.15010816f, 
    -0.09774146f, -0.10176064f, -0.01957243f, 0.13725990f, -0.17758979f, -0.06907248f, -0.18019763f, -0.02533320f, 
    -0.02725052f, 0.02257965f, 0.02119123f, -0.37235805f, 0.11455350f, -0.09182113f, 0.11329287f, 0.15642935f, 
    -0.00464666f, 0.21110106f, -0.00840035f, -0.01181057f, 0.01191162f, 0.17189328f, 0.05550909f, -0.07768863f, 
    0.06568117f, -0.01305991f, -0.01028804f, -0.09852251f, 0.09017888f, 0.08582374f, -0.06391028f, 0.07309438f, 
    0.28246799f, -0.32455650f, 0.08365967f, 0.28474188f, 0.04895901f, 0.11772330f, -0.00435592f, -0.06157700f, 
    -0.02474865f, 0.03035207f, -0.09809835f, 0.04431275f, 0.38902783f, 0.11059736f, 0.26788494f, 0.13964464f, 
    0.13540067f, -0.12990485f, -0.03062525f, -0.02120511f, -0.02964304f, 0.04609640f, -0.11879871f, -0.00718502f, 
    0.18011998f, 0.28866351f, 0.10095277f, 0.24649017f, 0.03362356f, 0.23126750f, 0.15711245f, 0.26508391f, 
    0.10617647f, 0.05855250f, 0.07539281f, 0.01666774f, -0.42837012f, -0.15351468f, 0.01436297f, 0.29539165f, 
    0.07718214f, 0.10426509f, -0.03837170f, 0.19749796f, -0.11545208f, -0.05069015f, -0.05284185f, 0.03797790f, 
    0.01927513f, -0.02876223f, 0.16825873f, 0.10002427f, 0.05387571f, -0.09372808f, 0.23118734f, 0.13191856f, 
    -0.04557845f, 0.11948866f, -0.01298844f, 0.06159433f, -0.07411631f, -0.01231845f, -0.02301748f, -0.02888852f, 
    -0.04062781f, -0.09485609f, -0.07463144f, -0.14679724f, -0.08087610f, 0.01654771f, 0.02617000f, -0.06890876f, 
    0.07079089f, 0.10685240f, 0.16591437f, 0.24966517f, -0.00640390f, 0.04154690f, -0.06953301f, -0.18190551f, 
    -0.01359233f, 0.03706549f, -0.02587270f, 0.11929310f, 0.32618251f, 0.02296105f, -0.09558688f, -0.05030825f, 
    -0.00048306f, -0.11826067f, -0.02599200f, 0.14693484f, 0.09308736f, 0.11856099f, -0.08389342f, -0.06451923f, 
    0.04134583f, 0.21377282f, -0.00252277f, 0.18663993f, 0.05476086f, 0.08781935f, 0.02347622f, 0.16102804f, 
    -0.01892312f, -0.03525384f, -0.09376704f, -0.08107432f, -0.07721888f, 0.04830619f, 0.06711271f, 0.14209133f, 
    -0.07998195f, -0.07964054f, -0.09688549f, -0.03278409f, 0.00501354f, -0.02495072f, -0.06563962f, 0.07700615f, 
    0.09530207f, -0.04327395f, 0.08290194f, 0.10961021f, 0.06149358f, -0.05630860f, 0.07921335f, -0.10147019f, 
    0.06737801f, 0.09349716f, -0.02754607f, 0.01668929f, 0.05424291f, -0.13959461f, 0.39681482f, -0.08716870f, 
    -0.00526708f, -0.02174152f, -0.14342505f, -0.04529618f, 0.13025391f, -0.08323358f, -0.05050097f, 0.12938246f, 
    0.04823015f, 0.09708208f, 0.22247706f, 0.12939586f, -0.06736122f, 0.10160121f, 0.01938916f, -0.10372385f, 
    -0.11138018f, 0.00275698f, -0.01838038f, -0.04065925f, 0.08162168f, -0.21765827f, 0.19323733f, 0.08690688f, 
    0.08748537f, -0.13428742f, 0.09766389f, -0.04125117f, 0.18172109f, 0.12383993f, -0.03565773f, -0.00282214f, 
    -0.08630859f, 0.07260796f, 0.01183363f, -0.23820008f, 0.10219960f, 0.07038628f, -0.05094394f, 0.03593937f, 
    0.07281849f, -0.08000664f, 0.04273029f, -0.01998390f, 0.01243177f, -0.08968427f, -0.18075192f, -0.24648246f, 
    0.02695673f, -0.10877442f, -0.01817385f, 0.02074370f, -0.00619392f, -0.06851535f, 0.10575944f, 0.00682391f, 
    0.08396679f, 0.08173431f, -0.24675329f, 0.14386758f, -0.16128127f, 0.10704975f, 0.11760776f, -0.21476616f, 
    -0.09784466f, -0.10044828f, 0.08221883f, -0.08621898f, -0.18860388f, 0.14164831f, -0.07786696f, -0.00332516f, 
    -0.03745373f, 0.08989679f, -0.08677682f, 0.09283966f, -0.22004403f, -0.00198117f, 0.05071044f, -0.04298324f, 
    0.07795793f, -0.08733339f, 0.22494993f, -0.04064594f, 0.00227319f, -0.10001197f, 0.01811592f, -0.00956545f, 
    0.00089685f, 0.00285763f, -0.16929272f, 0.02093802f, -0.16727793f, 0.41498545f, -0.27768341f, -0.07447353f, 
    -0.04293085f, -0.01724818f, 0.07654350f, -0.07225511f, 0.01967703f, 0.02013120f, -0.10931595f, 0.09098973f, 
    -0.02329499f, 0.09942625f, -0.07252761f, -0.00520883f, -0.04958512f, 0.06714053f, 0.00736340f, 0.02531725f, 
    -0.00989859f, -0.14342269f, -0.03978378f, 0.05683893f, 0.20780571f, -0.16440062f, 0.19870834f, 0.04868606f, 
    -0.03139527f, -0.13338287f, -0.07299316f, -0.04709272f, -0.11509416f, 0.13686480f, -0.02323762f, 0.10516124f, 
    -0.16768649f, -0.12167822f, -0.23259766f, -0.15659842f, 0.02664144f, -0.04326464f, 0.03787646f, 0.02152763f, 
    0.09644530f, 0.00358015f, -0.03971898f, -0.00580891f, -0.13536641f, -0.15773010f, -0.14895931f, -0.06558818f, 
    -0.02180979f, -0.12023286f, -0.07387711f, -0.04400733f, 0.01567601f, 0.00011506f, 0.03414753f, 0.02217742f, 
    -0.17069209f, 0.04784465f, -0.00311905f, -0.16204110f, -0.00212131f, -0.02762586f, -0.09883711f, -0.01469726f, 
    0.10873586f, 0.02200170f, 0.01018351f, -0.07847659f, -0.14153180f, -0.26916423f, -0.13889585f, -0.14495045f, 
    0.13231410f, 0.14434972f, -0.07331095f, -0.03881863f, 0.07686801f, -0.07091568f, -0.07044648f, 0.01124828f, 
    0.30826414f, -0.00490523f, 0.16025415f, 0.16968219f, -0.05200206f, -0.08297767f, -0.09129133f, -0.02154932f, 
    0.19632548f, 0.01506492f, 0.20202391f, -0.10382780f, -0.05197670f, -0.06313369f, 0.04828477f, -0.00990761f, 
    0.11798438f, -0.03216255f, 0.10431145f, 0.20131558f, -0.03453138f, 0.01385833f, -0.02535763f, 0.07317398f, 
    0.26669952f, -0.08616248f, 0.36605972f, -0.18165615f, 0.11163206f, -0.13019513f, 0.06690464f, -0.04400479f, 
    0.05004811f, -0.07197986f, -0.15037802f, -0.05154056f, 0.12397452f, 0.15919217f, -0.17409419f, 0.12041977f, 
    0.07652316f, -0.14365013f, -0.00779973f, 0.09624592f, 0.12869297f, 0.03998656f, 0.09262646f, -0.01087609f, 
    -0.20302851f, -0.01115081f, 0.06638853f, 0.12374080f, -0.02443535f, 0.00108539f, 0.01932107f, -0.04325050f, 
    -0.08515849f, 0.01766958f, -0.00672881f, -0.04568332f, -0.00704563f, 0.00782805f, 0.09155023f, -0.05487255f, 
    -0.11242853f, -0.03387935f, -0.02986676f, -0.16094455f, 0.00179035f, 0.08511436f, -0.08676204f, -0.03220099f, 
    0.27248871f, -0.20698255f, -0.08588798f, 0.04303925f, -0.04400232f, 0.04881278f, 0.02131316f, 0.02580608f, 
    -0.07533975f, 0.02067979f, 0.08567706f, 0.00682480f, 0.10998856f, 0.28281292f, 0.19639388f, 0.14227895f, 
    0.06760413f, 0.03116089f, 0.02474094f, 0.06358262f, 0.03739849f, -0.03253258f, -0.04888332f, -0.05501225f, 
    0.13738358f, 0.13319212f, 0.13948815f, 0.21919896f, 0.07485490f, 0.01115970f, 0.17922223f, 0.08552564f, 
    0.02995536f, 0.01557658f, 0.00312261f, 0.01519671f, 0.20921992f, 0.04835746f, -0.30623621f, 0.12812355f, 
    -0.03021676f, 0.09532853f, 0.01741509f, 0.06966684f, 0.07075047f, -0.03353219f, 0.02610770f, -0.07243055f, 
    0.03859091f, 0.19825597f, -0.23853666f, 0.08696985f, 0.02299156f, 0.03901348f, -0.03052920f, 0.11904757f, 
    -0.09462485f, -0.13351265f, -0.09088597f, -0.09779095f, 0.00315629f, -0.13920705f, 0.24502090f, 0.31058115f, 
    0.29778776f, 0.11363837f, 0.16040444f, 0.27354395f, -0.03853805f, -0.07037139f, -0.02500203f, -0.04402165f, 
    0.24292052f, 0.00541228f, -0.03753993f, 0.24171329f, -0.02479345f, 0.38521329f, 0.10420620f, 0.00674357f, 
    0.11702634f, -0.02014619f, -0.06528476f, -0.04234729f, -0.19186296f, -0.07911931f, 0.01418980f, 0.02476902f, 
    0.05484368f, 0.10692111f, 0.16273074f, 0.08498659f, -0.00095861f, -0.14762728f, -0.05742684f, -0.09065991f, 
    -0.21243602f, -0.05789551f, -0.14761144f, -0.03427645f, 0.03069703f, -0.00136404f, 0.01274713f, 0.04400460f, 
    -0.02888251f, 0.10312454f, -0.06965405f, 0.07485332f, 0.23047955f, -0.10691255f, 0.26353315f, 0.01226600f, 
    -0.07383008f, 0.00180787f, 0.04008213f, 0.03480461f, 0.01025184f, 0.10276516f, 0.03967898f, -0.02493621f, 
    0.26066253f, -0.30804840f, -0.30000427f, 0.12895904f, -0.04707611f, 0.07030489f, 0.07974675f, 0.00448175f, 
    0.03675001f, 0.02638511f, -0.04001495f, -0.04809742f, -0.13057135f, -0.06149145f, -0.11527741f, -0.11909488f, 
    0.08461528f, 0.13747494f, -0.05807941f, 0.01916438f, 0.04329248f, -0.02369654f, 0.00019421f, -0.07167885f, 
    0.07952200f, 0.02294863f, 0.04892419f, -0.10374388f, 0.02820971f, -0.01441385f, -0.02443499f, 0.07428514f, 
    -0.07497940f, -0.12746643f, -0.16505466f, 0.13471289f, 0.23912263f, -0.05486071f, -0.07241395f, -0.02128760f, 
    -0.03344643f, -0.00343528f, 0.14518747f, 0.05151321f, 0.18479800f, -0.11164103f, 0.01657642f, 0.06730268f, 
    0.03253711f, 0.02122549f, 0.03097047f, 0.10418746f, -0.04038433f, 0.17505719f, 0.10029109f, 0.10575590f, 
    -0.00537748f, -0.03070586f, 0.07804883f, 0.09974525f, -0.01902922f, -0.05744258f, -0.08618301f, 0.21230796f, 
    -0.01142660f, -0.19319323f, 0.17328738f, 0.07023747f, 0.05561556f, -0.05844297f, 0.18251804f, 0.14721289f, 
    0.05064529f, -0.06603608f, 0.19294508f, 0.15090580f, -0.01980708f, 0.00218677f, -0.16986604f, 0.05001174f, 
    -0.09346951f, -0.07459571f, -0.06435212f, -0.01398269f, 0.16764738f, 0.09936846f, 0.04594611f, -0.07338846f, 
    -0.00910876f, 0.07403164f, 0.01163321f, 0.03548013f, -0.11610900f, 0.01868144f, -0.03989558f, -0.06699036f, 
    -0.09528249f, 0.07647280f, -0.19626610f, 0.16479935f, -0.00874427f, 0.03148007f, -0.00342744f, -0.07798094f, 
    0.11159461f, -0.02653723f, -0.00546877f, -0.08556477f, -0.44696340f, -0.03752536f, -0.24338804f, -0.07661648f, 
    0.01507741f, 0.07915378f, 0.08825874f, -0.02217679f, 0.05939070f, -0.09793322f, 0.05843372f, -0.05495593f, 
    0.11319768f, 0.19013718f, 0.11978117f, 0.24746864f, -0.00982956f, 0.04973130f, 0.05230533f, 0.01472484f, 
    0.03633378f, -0.03171587f, 0.07523820f, -0.02006576f, -0.06148053f, 0.42839912f, -0.15964532f, 0.30230072f, 
    -0.07210555f, 0.06647868f, 0.04396555f, 0.27987599f, -0.02097205f, -0.00258687f, -0.02327745f, -0.02061548f, 
    -0.15821512f, 0.10172025f, 0.02838847f, 0.14481442f, 0.01703612f, 0.08162129f, -0.00121971f, -0.02055985f, 
    0.06931587f, 0.04095881f, -0.03060217f, 0.05214740f, -0.04878709f, 0.06604800f, 0.04684756f, 0.06470199f, 
    0.03738860f, -0.03694046f, 0.05356680f, 0.07713005f, 0.06805445f, -0.11090971f, -0.10100801f, 0.07689922f, 
    -0.27230725f, -0.30752870f, -0.20957224f, -0.24367921f, 0.17508636f, 0.00794845f, 0.04746271f, -0.02737307f, 
    0.06382930f, -0.02635388f, 0.02267803f, -0.03769923f, -0.31012449f, 0.20473406f, 0.03210996f, 0.10492060f, 
    0.08541932f, -0.14658967f, 0.14666021f, 0.00159229f, -0.08860002f, 0.11991537f, 0.01095246f, 0.05518997f, 
    -0.02517407f, 0.04843255f, 0.15468442f, 0.11198280f, 0.07658822f, -0.06545556f, 0.05665645f, -0.02092505f, 
    0.10940650f, 0.01062264f, 0.05567683f, 0.00065584f, -0.13696598f, 0.24414571f, -0.41090056f, 0.25185779f, 
    0.04801477f, 0.12422969f, -0.04349215f, 0.07051471f, 0.00512451f, -0.05594017f, 0.04384379f, -0.15322767f, 
    -0.08001562f, -0.26759425f, 0.33476615f, -0.11601815f, -0.09614064f, 0.08064413f, -0.04096664f, -0.06895365f, 
    0.04696390f, 0.02713626f, -0.04985328f, 0.14047350f, 0.06786500f, 0.03049577f, 0.02664438f, 0.59365433f, 
    -0.02029591f, 0.04802832f, 0.07914136f, -0.03751981f, 0.03056102f, -0.01967576f, 0.15548055f, -0.01630425f, 
    0.04968278f, -0.21638909f, 0.13280672f, 0.26263678f, 0.01299311f, -0.00407639f, -0.03687620f, -0.16135484f, 
    0.10955770f, -0.14876288f, -0.00637193f, -0.01838910f, -0.16936085f, 0.16794942f, -0.03914807f, -0.25983635f, 
    -0.03921272f, 0.02260098f, -0.04043123f, 0.16724168f, -0.11390930f, 0.01300104f, 0.05657097f, -0.05448079f, 
    -0.02269071f, 0.29891765f, -0.05694627f, 0.09560716f, -0.10210631f, -0.04559581f, -0.08514517f, 0.08220825f, 
    0.02318968f, -0.11735779f, 0.01172779f, 0.03259557f, -0.31218424f, -0.06697526f, -0.17141132f, 0.08198651f, 
    -0.08832026f, -0.08899035f, -0.00648109f, -0.01122668f, -0.02207499f, -0.00119875f, 0.12067243f, 0.04125674f, 
    0.16306095f, 0.13668171f, 0.22542156f, 0.16743807f, 0.11845864f, -0.12692840f, 0.17130619f, 0.20432608f, 
    0.12629323f, -0.07124493f, -0.09044123f, -0.07104675f, 0.33409578f, 0.21955906f, 0.39114654f, 0.16757967f, 
    0.12243881f, 0.10074219f, 0.04286480f, 0.01198539f, -0.01205903f, -0.02721632f, 0.08215750f, -0.13667877f, 
    0.12957920f, 0.06629650f, 0.08994526f, 0.02647240f, 0.17941257f, 0.10809276f, -0.02118300f, 0.00167708f, 
    -0.14189668f, -0.06270523f, 0.07896870f, -0.13020805f, -0.10009660f, -0.18286838f, -0.10894400f, -0.09507041f, 
    0.01037710f, -0.02362577f, -0.05700758f, -0.06174369f, 0.06766930f, -0.04069611f, -0.01747065f, 0.06210135f, 
    0.05114018f, -0.25422937f, -0.25880077f, -0.04098121f, 0.02796299f, -0.15824175f, 0.03630866f, 0.13370873f, 
    0.10527654f, -0.13594088f, 0.04121224f, 0.18165290f, -0.02778167f, -0.10939579f, 0.07232397f, -0.19796307f, 
    0.00481140f, -0.03611317f, 0.03026242f, -0.05871375f, 0.05719412f, -0.16798195f, -0.01718083f, -0.03464881f, 
    -0.09267820f, -0.18183507f, 0.05760442f, 0.02060581f, -0.01795554f, -0.04603825f, -0.07612585f, 0.00397532f, 
    0.02463925f, -0.06054268f, 0.02095911f, 0.07415967f, 0.08819623f, -0.04658140f, -0.06624754f, 0.05237210f, 
    -0.00398207f, 0.02041041f, 0.12245999f, -0.01665304f, 0.30315295f, -0.07128338f, -0.04912129f, 0.02866985f, 
    -0.12989330f, 0.20641717f, -0.13215163f, 0.19041736f, -0.03819235f, -0.12158405f, 0.06023071f, 0.22301081f, 
    -0.10601740f, -0.11621622f, 0.05698799f, 0.03177198f, -0.36710000f, 0.67075449f, -0.38327309f, 0.38187444f, 
    -0.04700580f, 0.08527489f, 0.17112510f, -0.08478121f, 0.11870948f, -0.16336982f, 0.02842397f, -0.02944138f, 
    0.08279459f, -0.01086382f, -0.18480183f, 0.05066000f, 0.05586652f, -0.09519343f, -0.07671388f, -0.03822804f, 
    0.05750250f, -0.01631016f, -0.04617800f, 0.03962753f, -0.15391335f, 0.12517773f, -0.10646986f, -0.02625835f, 
    0.00960160f, 0.16785397f, 0.00760242f, 0.24812375f, 0.00137359f, -0.14624685f, 0.00584495f, 0.22480744f, 
    -0.00700539f, -0.10828353f, 0.05846529f, -0.12765557f, 0.13149542f, 0.25194919f, -0.15652226f, 0.09013482f, 
    0.06152357f, -0.10797316f, -0.06755207f, 0.02492589f, -0.00050180f, 0.05042784f, 0.19510454f, 0.05784669f, 
    -0.00730800f, 0.02727471f, -0.01170539f, -0.01377688f, 0.13069148f, -0.04637985f, -0.07725065f, 0.01703469f, 
    -0.01531095f, -0.14056537f, 0.28086117f, 0.17958808f, 0.08421124f, 0.27817145f, -0.03061875f, 0.27406910f, 
    0.07367416f, 0.08147427f, -0.02294419f, -0.12361366f, 0.22013301f, 0.26086631f, -0.25634199f, -0.02532217f, 
    0.22422870f, -0.13620391f, 0.52071947f, -0.04259781f, 0.12236354f, -0.00255928f, -0.03226876f, 0.08438705f, 
    0.14556454f, 0.16247411f, -0.22458261f, -0.00537747f, 0.10953164f, -0.22103719f, 0.12775551f, -0.12550959f, 
    0.11202531f, 0.07303748f, 0.04678666f, 0.04430151f, 0.35666564f, -0.34757257f, 0.18005696f, -0.00667437f, 
    -0.04107452f, -0.07404885f, 0.11203127f, 0.03828925f, 0.31961551f, 0.00373948f, -0.15318742f, -0.09910548f, 
    -0.08893231f, -0.15489221f, 0.00961192f, -0.08969224f, 0.07270244f, 0.22044916f, -0.04340606f, -0.03647836f, 
    0.02112665f, -0.01041551f, -0.01272796f, -0.08263124f, 0.02466756f, 0.01431734f, 0.10926904f, -0.08856419f, 
    0.00337200f, -0.18053550f, 0.08494015f, -0.06697049f, 0.07761694f, 0.14139023f, 0.09430271f, 0.12803699f, 
    0.02618615f, 0.06424471f, 0.10683930f, 0.05908852f, -0.00941881f, 0.01639406f, -0.09191289f, 0.08379485f, 
    -0.08471934f, 0.13142587f, 0.05280105f, -0.21922810f, 0.04065978f, 0.08705146f, 0.07119226f, -0.04647090f, 
    0.12877420f, 0.14277564f, 0.16805157f, 0.02501131f, 0.00537951f, 0.01171176f, 0.03722791f, 0.00494441f, 
    -0.05511519f, -0.01922523f, 0.07139402f, -0.05481556f, 0.14362006f, -0.06396832f, -0.04837429f, -0.05272606f, 
    0.06019290f, -0.00398983f, -0.00137719f, 0.04533179f, -0.01469315f, 0.02248424f, 0.04455711f, 0.02748212f, 
    -0.04185479f, 0.03732064f, -0.12995103f, -0.05492998f, -0.06928359f, 0.04132680f, -0.06546685f, 0.05800394f, 
    -0.32940981f, -0.08002754f, -0.02929742f, -0.00012983f, -0.04675914f, 0.00390813f, -0.05561149f, 0.05800311f, 
    0.03021574f, 0.28278092f, 0.11277321f, -0.02168395f, -0.25965646f, -0.27321026f, -0.02398286f, 0.04828614f, 
    0.00879600f, 0.12184066f, 0.01478005f, 0.00993061f, 0.01719342f, 0.06701203f, 0.01536217f, 0.13914356f, 
    0.01035447f, 0.08812746f, -0.02343517f, -0.10547756f, -0.11774787f, 0.03960997f, 0.08230326f, 0.01044335f, 
    -0.03355965f, -0.01572428f, 0.01703724f, 0.02705563f, -0.19881238f, 0.04898616f, 0.02120649f, -0.05047076f, 
    -0.00315083f, 0.04968575f, -0.14874026f, 0.06978558f, 0.17787364f, 0.16660407f, 0.22660263f, 0.03060228f, 
    0.37090608f, -0.04883362f, -0.11417425f, -0.03268040f, 0.04926981f, 0.05319810f, -0.03066390f, -0.01957480f, 
    0.41817760f, -0.11463274f, 0.16254868f, -0.01015550f, -0.17100507f, -0.19706653f, -0.11860059f, 0.03150121f, 
    0.00619615f, 0.01487029f, 0.13481289f, -0.12696989f, 0.00717883f, 0.02876757f, 0.02246193f, -0.00924708f, 
    -0.08002621f, -0.19269848f, 0.01086839f, 0.05231718f, 0.08801646f, -0.14418434f, 0.11568474f, 0.26790026f, 
    0.07152127f, -0.08412638f, 0.06789968f, -0.07080747f, 0.08081541f, -0.04940868f, -0.33190221f, -0.09474798f, 
    0.13083933f, 0.16246329f, 0.04796955f, 0.04517705f, -0.06620448f, -0.02039476f, -0.01476459f, 0.03205991f, 
    -0.12725183f, -0.15778542f, -0.13717823f, -0.10759622f, 0.14355113f, 0.10424437f, 0.06563279f, -0.06071407f, 
    -0.05298703f, -0.02382872f, -0.01900749f, 0.02538817f, 0.10434990f, -0.06561925f, 0.22449374f, -0.05378044f, 
    -0.08360308f, 0.28826398f, -0.08250596f, 0.15860496f, -0.11886521f, 0.03384217f, 0.02700713f, 0.05222734f, 
    0.15367769f, 0.14883046f, -0.27438471f, 0.19754921f, -0.06478498f, 0.34701222f, 0.04143560f, 0.12746683f, 
    0.12554438f, 0.27495742f, -0.18927003f, 0.15099272f, -0.02493800f, -0.11547424f, -0.18654580f, -0.12022648f, 
    0.12047134f, 0.03975293f, -0.05846266f, -0.20192954f, 0.01731100f, -0.05453569f, 0.03983761f, 0.04390022f, 
    0.09287646f, -0.02160073f, -0.01709490f, -0.02549425f, 0.06838608f, 0.11909080f, 0.03334789f, -0.03833002f, 
    -0.00379108f, -0.13563089f, 0.04370563f, 0.04809772f, -0.12168974f, -0.11660507f, -0.00918809f, -0.02816109f, 
    0.04694964f, -0.18088832f, -0.09130252f, -0.05353124f, -0.05677149f, -0.07658939f, 0.01826632f, 0.01551079f, 
    0.05157350f, 0.17748958f, -0.07091581f, -0.06426470f, -0.07472993f, -0.03814485f, -0.00058358f, 0.17489718f, 
    0.04225523f, 0.22827645f, -0.06577179f, 0.05677629f, -0.24825594f, -0.04500785f, 0.30919909f, -0.08765350f, 
    -0.08509286f, -0.06262969f, -0.03533527f, 0.09573714f, 0.04930482f, 0.17354535f, 0.10899966f, 0.09436749f, 
    0.17224215f, 0.02117319f, 0.26761040f, -0.06192733f, 0.22995035f, 0.00833968f, -0.09193812f, -0.07870099f, 
    -0.01189940f, 0.08558051f, 0.03895113f, -0.01379314f, -0.05106272f, 0.18257147f, 0.17243427f, 0.14347622f, 
    -0.05001341f, -0.07800473f, -0.05562837f, -0.04114935f, -0.03920926f, -0.02916968f, 0.04123101f, -0.07609810f, 
    0.13005415f, 0.25690007f, -0.01147461f, 0.12130059f, -0.02104612f, -0.06359553f, -0.11912562f, 0.06430916f, 
    0.18901363f, -0.01731773f, 0.04985297f, 0.22687384f, -0.15117152f, -0.17250659f, 0.05359036f, -0.09935341f, 
    0.15785991f, -0.04536257f, 0.05945891f, 0.02563082f, -0.13326553f, -0.08676711f, 0.08790737f, 0.10291012f, 
    -0.06710204f, -0.19479473f, 0.24786158f, 0.11655411f, 0.13926491f, 0.03549914f, 0.36192471f, 0.01569586f, 
    -0.01158062f, -0.02640138f, 0.16149914f, -0.12557809f, -0.02265441f, -0.10429920f, 0.03881657f, -0.01394155f, 
    0.03272693f, 0.10615602f, 0.02157719f, 0.10598174f, -0.01919540f, -0.11148930f, -0.02189287f, -0.04586797f, 
    -0.11717211f, 0.00020805f, 0.05086981f, -0.16632089f, 0.05242870f, -0.04486916f, 0.05648153f, 0.24231061f, 
    0.12302447f, 0.08341894f, 0.06645283f, 0.16626513f, -0.09201062f, -0.03357983f, 0.08229846f, -0.01657459f, 
    -0.03117043f, -0.07310203f, -0.03556020f, -0.06792221f, 0.03401452f, 0.09730720f, 0.15239078f, 0.23458523f, 
    0.25043419f, 0.07982540f, 0.01431162f, 0.14592446f, -0.00033828f, -0.03906248f, -0.01148370f, 0.03370261f, 
    0.17825823f, 0.06192687f, -0.03863660f, 0.23864749f, 0.07907414f, 0.21665405f, -0.09154246f, -0.04814496f, 
    0.18201239f, -0.04506042f, -0.09284278f, -0.06221831f, -0.03983493f, -0.10529651f, 0.01280389f, 0.04556291f, 
    -0.03925890f, -0.11686758f, 0.06919278f, -0.00045287f, 0.04842830f, 0.06097375f, 0.08416250f, 0.04496371f, 
    0.04739732f, -0.08722747f, -0.04229392f, -0.01028343f, 0.21381503f, -0.18109404f, -0.09380833f, -0.02482138f, 
    0.10385281f, 0.05809478f, -0.03585209f, 0.02848580f, 0.03003457f, -0.10009661f, -0.05032023f, 0.18247634f, 
    -0.03559386f, -0.00318670f, 0.02400734f, -0.01566073f, 0.15642171f, 0.04316695f, 0.06458517f, 0.09255581f, 
    0.08138914f, 0.05739084f, 0.02711741f, 0.04798396f, -0.17872894f, -0.14549042f, -0.08073650f, -0.22391936f, 
    0.19490333f, 0.07239893f, 0.18257201f, -0.09424660f, 0.17194575f, 0.11529742f, -0.01712681f, 0.05629920f, 
    -0.08727313f, 0.11118966f, 0.10158163f, 0.04044815f, 0.00828070f, -0.16100919f, 0.01608486f, -0.08102720f, 
    -0.16874269f, -0.15902837f, -0.02404673f, -0.11171546f, 0.22251168f, -0.12428457f, -0.11162036f, 0.10187750f, 
    0.00605083f, -0.05240488f, 0.30081323f, -0.09498502f, 0.02422287f, 0.03421055f, 0.10447481f, 0.23007569f, 
    -0.12296961f, -0.04347751f, -0.03840289f, -0.18702288f, 0.01646475f, 0.05100143f, 0.13018358f, -0.01996626f, 
    0.01411504f, -0.00742265f, -0.10657079f, -0.15735282f, 0.17309333f, 0.06190610f, 0.13653956f, -0.17251456f, 
    0.10649392f, -0.01420598f, -0.05234024f, -0.01214028f, 0.11292902f, -0.09386071f, 0.18769459f, -0.08537781f, 
    0.01851592f, 0.06022073f, -0.18890400f, -0.22618847f, 0.33733663f, 0.02397433f, 0.10937645f, 0.12995230f, 
    -0.00011253f, -0.02062635f, -0.00991506f, 0.07321135f, 0.28248250f, 0.02599672f, 0.12243986f, -0.35491508f, 
    0.14115921f, -0.01307181f, -0.22425494f, 0.16071281f, -0.06456854f, 0.08747012f, 0.05453389f, -0.03766634f, 
    -0.13616695f, -0.02179827f, -0.06978029f, 0.02195175f, 0.07467277f, 0.25052509f, 0.01695094f, 0.28991032f, 
    0.08010092f, 0.03177778f, 0.19460231f, 0.07621355f, 0.43215132f, 0.22158377f, 0.00588369f, 0.29213402f, 
    -0.13392203f, -0.01006990f, 0.01392508f, -0.08032350f, 0.20224576f, -0.00368782f, 0.02187541f, -0.05069105f, 
    0.02075612f, 0.29219711f, -0.32313228f, -0.04586893f, 0.14515755f, 0.01883151f, 0.17373589f, -0.00961484f, 
    -0.08482046f, 0.06022198f, 0.00374801f, -0.02383452f, 0.10052827f, 0.10256103f, -0.03668530f, -0.00234384f, 
    0.12380110f, 0.11821803f, -0.02303860f, 0.10435219f, -0.02235021f, -0.07970311f, 0.09107037f, 0.01541676f, 
    -0.09395172f, -0.14702918f, -0.18627875f, -0.07431767f, 0.08168548f, 0.11635896f, 0.05509978f, 0.02093879f, 
    -0.11872493f, -0.03200030f, 0.03314719f, 0.00835081f, 0.07132868f, 0.24120747f, -0.25759321f, -0.28690359f, 
    0.07613589f, -0.00470423f, 0.05041261f, 0.09765909f, -0.08787662f, -0.00391255f, -0.11225072f, 0.03904455f, 
    -0.13025276f, 0.03133819f, -0.12059747f, -0.17092913f, 0.02269926f, 0.05177092f, 0.10642270f, -0.01860880f, 
    0.07290404f, -0.10159045f, -0.00359847f, 0.06512360f, 0.03299683f, 0.01987886f, 0.12250149f, 0.11653722f, 
    0.00572333f, 0.00023887f, 0.01584298f, 0.03187750f, 0.05481248f, 0.12730770f, 0.12488174f, 0.11901818f, 
    0.37504396f, -0.02141706f, 0.05261048f, -0.13909391f, 0.00675911f, 0.18058458f, -0.06972680f, -0.05804899f, 
    0.18876159f, 0.00354425f, 0.06871714f, -0.10920335f, -0.06175428f, 0.03240072f, -0.02637081f, 0.07874252f, 
    0.11486338f, -0.16102117f, 0.15670329f, -0.07713914f, 0.12757534f, 0.07339570f, -0.19119491f, 0.50967985f, 
    0.15581943f, 0.15201139f, -0.07608128f, 0.01676853f, 0.20827772f, 0.04474081f, 0.18594867f, 0.03506092f, 
    0.03252694f, 0.05883821f, -0.03607414f, 0.05136004f, 0.04260281f, -0.00063537f, 0.05402520f, -0.09298316f, 
    -0.00565276f, 0.07519953f, -0.01677289f, 0.06017166f, -0.00190926f, 0.04394509f, -0.00854739f, -0.34092817f, 
    0.18056072f, -0.12048237f, -0.02571549f, -0.02140886f, 0.07510176f, 0.08080389f, 0.24597096f, 0.07787891f, 
    0.21724772f, -0.12443865f, 0.02307565f, 0.21008170f, 0.35336748f, -0.04862500f, -0.14267233f, -0.27067825f, 
    -0.03220073f, 0.00648882f, -0.06343455f, 0.29480898f, -0.11348789f, 0.04238532f, 0.05244914f, -0.03910265f, 
    0.02444726f, 0.06049822f, 0.00386134f, 0.15371221f, 0.23766559f, 0.09366313f, -0.07379784f, 0.16858998f, 
    0.17259704f, 0.39560547f, -0.05984590f, 0.18139477f, 0.07507249f, -0.25395298f, -0.21585052f, -0.01034195f, 
    0.11640222f, 0.32938191f, -0.04788730f, -0.15421100f, 0.02744170f, -0.03935402f, 0.05882960f, -0.16054325f, 
    -0.02902224f, 0.00006314f, -0.03657414f, -0.03754243f, -0.00746439f, -0.02367285f, 0.02904661f, -0.03873581f, 
    -0.00082212f, -0.01876987f, 0.01805757f, 0.01229111f, -0.02031433f, 0.00633792f, -0.01997296f, -0.00160106f, 
    -0.01937238f, -0.01769341f, -0.01005960f, -0.02145756f, -0.03637003f, 0.00066726f, -0.04007003f, 0.01731765f, 
    -0.03917237f, -0.02224016f, -0.02749717f, -0.03889951f, -0.00687021f, 0.02368206f, -0.01827371f, -0.00840467f, 
    -0.00873693f, 0.01770189f, 0.00055832f, 0.01013862f, -0.00415717f, -0.00434210f, 0.02218771f, 0.02092840f, 
    -0.02065378f, -0.01737623f, 0.00023016f, -0.03329601f, 0.00699762f, -0.04142156f, 0.00214940f, 0.02767310f, 
    -0.01499274f, -0.03232127f, -0.01569888f, 0.00470436f, -0.02133270f, 0.00077637f, -0.00320030f, 0.00671085f, 
    -0.02236453f, 0.01904863f, -0.03953279f, -0.00024814f, 0.00066668f, -0.03402299f, 0.02265402f, -0.00364886f, 
    -0.02505301f, 0.02538654f, -0.01833658f, -0.03500552f, -0.02122109f, -0.01057586f, -0.02348213f, -0.02085339f, 
    -0.00435838f, -0.03320314f, 0.02288040f, -0.04097137f, 0.01853156f, 0.02948928f, 0.01971540f, -0.01736076f, 
    0.00121585f, -0.02762173f, -0.01280369f, -0.03715310f, 0.02507396f, -0.02777039f, -0.00072936f, -0.01604076f, 
    -0.02324277f, -0.02057772f, -0.01024137f, 0.02821001f, 0.00866499f, -0.04015686f, -0.01933582f, -0.02851081f, 
    -0.00489032f, -0.01632499f, -0.01002633f, 0.00402291f, -0.00873160f, -0.02947140f, -0.02479505f, -0.02444207f, 
    -0.02093487f, 0.00775336f, 0.01592628f, -0.02224749f, 0.01243825f, -0.00465132f, 0.02960858f, 0.01899081f, 
    -0.01281005f, -0.01453914f, 0.00206801f, -0.03179791f, 0.02003940f, -0.00737449f, -0.04132013f, -0.02352484f, 
    -0.01598736f, 0.02841429f, -0.00922862f, 0.00664556f, 0.01438027f, 0.00929035f, 0.02842423f, -0.00623093f, 
    -0.02913479f, -0.02710994f, -0.01829851f, -0.00675894f, -0.02496955f, 0.02289337f, 0.03588599f, 0.03371483f, 
    -0.00980779f, 0.03599272f, -0.03712915f, -0.00965005f, 0.01358789f, 0.02882779f, 0.01205375f, 0.00732337f, 
    0.00776510f, -0.01631084f, 0.00482537f, 0.00232088f, -0.01747543f, -0.02305444f, 0.00391273f, -0.01424535f, 
    -0.00668324f, -0.01327461f, 0.00296706f, -0.02517668f, -0.02915942f, -0.02430315f, -0.02810020f, -0.02638232f, 
    -0.00700918f, -0.03939577f, -0.04202318f, 0.00013071f, 0.02632503f, -0.01756801f, -0.01882786f, 0.00938728f, 
    0.01631610f, -0.00239594f, -0.01158688f, 0.00098376f, -0.00725990f, 0.02102994f, -0.02297179f, -0.00028933f, 
    0.00386396f, 0.01505303f, 0.02846240f, -0.02607821f, -0.01453873f, -0.04084212f, 0.00704898f, 0.01370382f, 
    -0.00686425f, 0.01303172f, 0.03452467f, 0.00463968f, -0.02585952f, -0.01350371f, -0.00235445f, -0.02936749f, 
    0.02007030f, -0.03639945f, -0.02974042f, 0.00036650f, 0.01286219f, -0.01089432f, -0.03054055f, -0.04031638f, 
    -0.01583323f, 0.02314699f, -0.02597502f, -0.03554289f, -0.03254840f, 0.01260933f, -0.03058737f, -0.00743113f, 
    -0.02739482f, 0.00627961f, 0.01507592f, 0.01240275f, 0.01762471f, -0.02863833f, 0.01046016f, -0.01200558f, 
    -0.01348081f, -0.04127560f, 0.01490157f, 0.00571637f, -0.00456712f, 0.01440491f, 0.01466754f, 0.00044723f, 
    0.01946963f, -0.00307114f, -0.01818659f, -0.02589582f, -0.02919374f, 0.00100958f, -0.00168540f, -0.00817588f, 
    0.01754309f, 0.00834687f, -0.01428808f, -0.00532997f, -0.03607940f, -0.01113547f, 0.01610725f, 0.00091028f, 
    -0.00939964f, -0.02509546f, -0.02568356f, -0.01935178f, 0.00263445f, -0.04052655f, -0.02466118f, 0.00239074f, 
    0.02163301f, -0.02434048f, 0.00348400f, -0.04136235f, 0.01359575f, -0.01742244f, -0.03025816f, 0.00555436f, 
    -0.02261226f, 0.00573426f, 0.01634214f, 0.01948311f, -0.01037525f, -0.02344173f, -0.01366622f, 0.02123220f, 
    0.00096779f, -0.02416117f, -0.03683089f, 0.01132701f, 0.02198452f, 0.02996930f, 0.02768143f, 0.02258867f, 
    -0.02367477f, -0.03286334f, -0.03520467f, 0.00518333f, 0.03004127f, -0.00706337f, 0.01851282f, -0.03345064f, 
    -0.02062004f, 0.00861081f, -0.02716377f, -0.01591956f, 0.00978042f, -0.02350720f, -0.01047920f, -0.00812536f, 
    0.01594734f, 0.02372123f, -0.00649638f, 0.00757416f, -0.03447300f, -0.02880454f, -0.02776093f, -0.03366374f, 
    0.01274548f, 0.01939771f, 0.01783735f, 0.02787460f, -0.00184201f, -0.02108956f, 0.03084661f, 0.00064193f, 
    -0.00450136f, -0.02060667f, -0.00562759f, 0.00978140f, 0.02490060f, 0.02365448f, -0.03758552f, 0.02039467f, 
    -0.02940002f, -0.02485522f, -0.02357856f, -0.01049373f, -0.03632296f, 0.01073308f, -0.01364778f, -0.00494338f, 
    -0.00098366f, -0.01723079f, 0.00298067f, -0.00982711f, 0.00160338f, 0.03001362f, -0.00338639f, -0.00776548f, 
    -0.03885038f, -0.03840553f, 0.00631009f, 0.00658900f, -0.00935651f, -0.03437405f, 0.01855695f, -0.00477073f, 
    -0.03840183f, 0.02687255f, 0.00239861f, -0.00759845f, -0.03545286f, -0.02021808f, -0.00333516f, -0.01995855f, 
    -0.01664053f, -0.02624197f, -0.00352003f, -0.02680327f, -0.03352202f, -0.01036216f, -0.01643528f, 0.02812730f, 
    -0.03853315f, 0.02740788f, 0.00596540f, -0.01047690f, -0.00452748f, -0.03619409f, -0.03446457f, 0.02153209f, 
    -0.02295926f, -0.04013348f, -0.03846830f, -0.02504374f, 0.02408376f, -0.00165056f, -0.01758388f, 0.01987132f, 
    -0.02664475f, -0.04023950f, -0.00147543f, -0.03573764f, -0.00633047f, 0.00240562f, -0.01989304f, -0.01291184f, 
    -0.01408072f, -0.02133328f, -0.00847841f, -0.01391494f, 0.03348468f, -0.04152368f, 0.00792332f, -0.02945250f, 
    -0.03945441f, 0.01061335f, 0.03275554f, -0.03767057f, -0.00915161f, 0.02788337f, 0.00796581f, 0.02679797f, 
    -0.03961587f, -0.00638182f, -0.01947290f, 0.01158321f, -0.00385050f, -0.02994160f, 0.01500776f, -0.02775921f, 
    0.02537451f, -0.02264265f, -0.03258521f, 0.01077856f, -0.02034019f, -0.04154915f, 0.01409205f, -0.00548634f, 
    -0.00385090f, -0.02294626f, 0.02321469f, -0.03290794f, 0.02582842f, 0.00992215f, 0.00189360f, -0.01107132f, 
    -0.02044115f, 0.02169522f, -0.00927827f, -0.03064177f, -0.02356167f, 0.00687746f, 0.00232774f, 0.02968124f, 
    -0.03102652f, 0.01257052f, 0.00703895f, 0.01022673f, 0.00279192f, -0.02359210f, 0.00111461f, 0.02380112f, 
    0.02423824f, 0.02873964f, -0.04207885f, 0.01317121f, -0.02252672f, 0.03786570f, -0.01222355f, 0.01519172f, 
    0.02869813f, 0.02654921f, -0.01060709f, -0.00097913f, -0.01382830f, -0.02025809f, 0.01925356f, -0.02668743f, 
    -0.02043797f, 0.00869035f, -0.01731208f, 0.00368036f, -0.00502587f, -0.03078061f, 0.02735072f, -0.00261656f, 
    -0.03604747f, 0.00600400f, -0.02010461f, -0.02567841f, -0.01689715f, 0.02509375f, -0.00907171f, -0.03743340f, 
    -0.03345400f, 0.01938977f, -0.03927270f, -0.03207543f, -0.01338515f, -0.00558043f, -0.03846727f, 0.00489267f, 
    -0.00277364f, 0.02298432f, -0.03212719f, 0.00587061f, 0.02744283f, 0.02527523f, 0.00691056f, 0.00341491f, 
    -0.00235586f, 0.02038563f, 0.00159663f, 0.00655459f, 0.02144039f, -0.01216249f, 0.01270322f, -0.02227580f, 
    -0.01131067f, -0.02187194f, -0.00863602f, -0.00903548f, -0.01047196f, -0.03775743f, -0.00574934f, -0.01500496f, 
    -0.00887642f, -0.01747728f, 0.01452254f, 0.01862174f, -0.03560488f, 0.00940150f, -0.00231967f, 0.02309676f, 
    0.02155502f, 0.00787815f, -0.00860048f, -0.03980236f, -0.01954884f, -0.01343135f, 0.01168920f, -0.02318608f, 
    -0.02583130f, -0.00136461f, -0.03460071f, -0.00071902f, 0.02617721f, -0.00204801f, -0.00690333f, 0.02316929f, 
    -0.02037419f, 0.02734512f, -0.02272120f, -0.04166859f, 0.00844577f, -0.01466786f, -0.02575944f, 0.02349395f, 
    -0.02366984f, 0.00280115f, -0.01317439f, 0.00103455f, -0.03313347f, 0.00729244f, 0.01282328f, -0.01294971f, 
    0.00565721f, -0.02913607f, -0.01285033f, -0.02066478f, 0.02305266f, -0.01567188f, -0.01501153f, 0.00339520f, 
    -0.00922430f, 0.01428175f, -0.00921397f, -0.02752930f, 0.00452506f, 0.00685191f, 0.00529694f, -0.01789539f, 
    0.00773638f, -0.02021710f, 0.01591402f, 0.00382183f, -0.03917103f, -0.03783463f, -0.00663346f, -0.00247316f, 
    0.02461004f, -0.02174541f, 0.00805838f, 0.00365287f, -0.02053696f, 0.00740389f, -0.00454256f, -0.01990761f, 
    0.01901726f, 0.01096507f, -0.02192091f, -0.00958138f, 0.01823553f, -0.00010908f, 0.01048664f, -0.02824396f, 
    -0.02601422f, -0.03324142f, 0.00443219f, 0.02110734f, 0.00980976f, -0.04119414f, -0.00427278f, 0.01731060f, 
    -0.00396646f, -0.01074046f, 0.02074889f, 0.01980042f, -0.02345647f, 0.01263639f, -0.01931324f, 0.02849610f, 
    0.01064885f, 0.00178341f, -0.03708071f, 0.00352336f, 0.00382257f, 0.01679184f, -0.00649241f, 0.01019019f, 
    0.01230411f, 0.02726254f, -0.03752308f, -0.02464036f, 0.02177253f, -0.00848371f, 0.02672874f, -0.03248111f, 
    0.00281227f, -0.02780826f, 0.01560162f, -0.01228665f, -0.00309098f, 0.01111352f, -0.02959945f, 0.02331273f, 
    -0.01495977f, -0.03364201f, 0.02313327f, 0.01000329f, 0.01633636f, -0.03145609f, 0.00231183f, -0.03001988f, 
    0.01072273f, 0.02425931f, -0.02855629f, -0.03051418f, 0.00426870f, -0.03535435f, 0.01129008f, 0.01727655f, 
    0.00951605f, -0.01179599f, -0.01446792f, -0.04182947f, -0.01741604f, 0.00823483f, -0.01767605f, -0.01445419f, 
    -0.01169059f, -0.02796626f, -0.01730935f, 0.01919147f, -0.02909819f, -0.01446386f, 0.02798317f, -0.02129008f, 
    -0.00542534f, -0.00320704f, 0.02818865f, 0.01017145f, -0.03307745f, 0.01010279f, 0.02174654f, 0.02574326f, 
    0.00821268f, -0.01528866f, 0.01723095f, 0.01236640f, -0.03499950f, -0.00050379f, -0.02905821f, -0.01553619f, 
    0.01374588f, 0.01311333f, 0.00702409f, -0.00876915f, 0.01450655f, 0.00012253f, 0.00322135f, 0.01932898f, 
    0.00202751f, 0.01738512f, -0.00672068f, 0.02263213f, 0.02126407f, -0.01692350f, 0.00497840f, 0.02499152f, 
    -0.00134066f, 0.01251855f, 0.00404150f, 0.01363413f, 0.01123385f, 0.00624042f, 0.00988943f, 0.01491490f, 
    -0.03228935f, -0.01530160f, -0.02011704f, -0.03363515f, -0.01604952f, -0.00888148f, -0.02630044f, -0.04200080f, 
    -0.01188294f, 0.02993855f, 0.02917706f, -0.03790799f, -0.00033872f, 0.00271225f, 0.01000261f, -0.02185377f, 
    0.02779638f, 0.02825754f, -0.00030346f, -0.00629925f, -0.01130483f, 0.01192638f, 0.00491624f, -0.03447450f, 
    0.02713650f, -0.03158831f, -0.00031408f, 0.00276644f, 0.01741494f, -0.00126867f, -0.00777090f, -0.02648043f, 
    0.02923268f, 0.01554813f, 0.01802315f, -0.00293374f, -0.02311509f, -0.01870012f, 0.00381832f, 0.01239085f, 
    -0.01938223f, 0.01187095f, -0.00853550f, 0.02710989f, 0.02633232f, -0.01170807f, -0.02526197f, -0.03532325f, 
    -0.01815353f, 0.00926092f, 0.00430797f, -0.03936434f, -0.01988093f, 0.01873695f, 0.01113343f, -0.01608212f, 
    -0.01999504f, -0.03891454f, 0.01817725f, -0.03557288f, 0.01131825f, -0.03807387f, -0.02461759f, -0.01797842f, 
    0.00697107f, -0.01188360f, 0.01965771f, -0.01868895f, 0.00550180f, -0.00153522f, 0.02672753f, -0.02903379f, 
    0.01214814f, 0.01191910f, -0.01033911f, -0.00679656f, 0.01207119f, -0.00212930f, -0.00917027f, 0.03007387f, 
    0.07983652f, 0.07853220f, 0.08909813f, -0.12481903f, -0.05995291f, 0.07271010f, 0.08006315f, 0.05340728f, 
    -0.03586694f, 0.21144238f, -0.03424865f, 0.07861896f, 0.19212964f, 0.18137212f, 0.21473466f, 0.14839786f, 
    0.03669397f, -0.01232598f, 0.06146988f, 0.03278464f, 0.13921061f, 0.09627286f, 0.02822119f, -0.01680797f, 
    -0.16801262f, 0.03175738f, -0.00863576f, -0.02121137f, -0.08300466f, -0.01947728f, -0.10886564f, 0.26564524f, 
    -0.11545836f, -0.07461186f, -0.05779283f, 0.16095176f, 0.10565872f, -0.38095137f, -0.22203590f, -0.33243650f, 
    0.01800467f, -0.06728470f, -0.01104421f, -0.04788052f, -0.09631357f, -0.05530967f, -0.05003989f, 0.05545688f, 
    0.01081686f, -0.06708619f, 0.08365564f, -0.05650210f, 0.11013801f, 0.08184605f, -0.07523835f, -0.15896067f, 
    -0.02167618f, -0.04108822f, -0.04959626f, 0.07868794f, 0.00676368f, 0.34847316f, -0.01650381f, 0.45181099f, 
    -0.05132606f, -0.05040624f, 0.11646493f, -0.02585092f, 0.02377416f, 0.15002806f, 0.13929352f, 0.08822557f, 
    -0.23286436f, -0.29429242f, -0.31631109f, -0.39054164f, 0.17096317f, 0.05592504f, 0.08061336f, -0.07691652f, 
    -0.12793438f, -0.02025363f, -0.06592527f, -0.19844860f, 0.27252647f, 0.00043114f, 0.26959899f, 0.00818305f, 
    0.06227008f, 0.10005108f, 0.02127585f, 0.06936099f, -0.02187297f, -0.08125632f, -0.09128789f, -0.00208082f, 
    0.21484068f, 0.25582340f, 0.17897001f, 0.04278821f, 0.00464739f, -0.00775774f, 0.03206190f, 0.00158866f, 
    0.20819484f, 0.20838587f, 0.01590996f, 0.25875095f, -0.63334692f, -0.56474894f, -0.49989858f, -0.41252765f, 
    0.19315490f, 0.02024510f, 0.15083914f, 0.02048703f, -0.03935079f, 0.00520846f, -0.10115965f, -0.12824799f, 
    0.16739149f, 0.07780074f, 0.15126172f, -0.01444967f, -0.00029292f, 0.11297504f, 0.07229950f, 0.00116241f, 
    0.02499688f, -0.04172444f, 0.05766838f, -0.07763629f, 0.18376625f, 0.17096730f, 0.24671598f, 0.13914414f, 
    0.01621809f, 0.00897973f, 0.01475095f, -0.00168835f, -0.01385923f, 0.02218369f, 0.00846794f, -0.00428827f, 
    0.28194708f, -0.30555320f, -0.28046516f, -0.25218493f, -0.13097030f, -0.07970928f, -0.09721825f, 0.12147122f, 
    0.10958403f, 0.34053493f, 0.12376990f, 0.17838404f, -0.12266997f, -0.24480885f, -0.10773489f, -0.24890396f, 
    -0.04314888f, -0.00327975f, -0.10975927f, 0.09630290f, -0.02933193f, 0.02754315f, 0.05568676f, -0.13674052f, 
    -0.06376757f, -0.09628546f, 0.09647322f, -0.12088494f, 0.09392253f, 0.04670402f, 0.09907518f, -0.09211209f, 
    -0.03326170f, 0.24356861f, 0.06079628f, 0.11154401f, 0.10541857f, -0.21309090f, -0.32665631f, -0.15731142f, 
    -0.09175075f, -0.07266799f, -0.02329688f, 0.16617833f, 0.30059761f, 0.24197650f, 0.17497070f, 0.05028415f, 
    0.17707483f, -0.00884873f, -0.22875817f, 0.05891506f, -0.07296749f, 0.07634193f, 0.20316935f, 0.22246110f, 
    0.20502228f, 0.19019122f, 0.19323212f, -0.27697590f, 0.01975395f, -0.02371922f, -0.06864687f, 0.04488922f, 
    -0.21295126f, -0.06739978f, 0.04492601f, -0.05689375f, 0.00542307f, 0.06432237f, -0.06079916f, 0.04579931f, 
    -0.04773913f, -0.07387076f, -0.00698043f, -0.03199350f, -0.08605550f, 0.21334077f, 0.05975433f, 0.16709511f, 
    -0.01943603f, 0.13621721f, 0.12952903f, 0.11571103f, -0.03239658f, -0.11499424f, -0.48908356f, -0.30734357f, 
    0.09609778f, 0.02647535f, -0.08831047f, 0.01453996f, -0.04130019f, -0.00550909f, 0.01929783f, 0.06172488f, 
    -0.20544858f, -0.46324310f, -0.43719709f, -0.26600844f, 0.14589188f, 0.04062891f, 0.02706859f, 0.02728115f, 
    -0.02401491f, 0.00172304f, -0.02788162f, -0.02043982f, 0.19317764f, 0.20195393f, 0.19800101f, 0.00910797f, 
    -0.02060740f, -0.06966311f, 0.06491915f, 0.01933991f, 0.09623595f, 0.15599658f, 0.21037035f, 0.08633537f, 
    -0.17711884f, 0.06025625f, 0.07767081f, -0.11338706f, -0.07858019f, -0.21323416f, -0.03711696f, 0.12142465f, 
    -0.04505824f, -0.02204426f, -0.00582858f, 0.18482684f, 0.20240134f, 0.14246465f, 0.03314027f, 0.36084485f, 
    -0.03269299f, -0.23596232f, -0.01283011f, -0.13030306f, -0.02249399f, -0.00032185f, -0.00627780f, -0.02861411f, 
    0.13581911f, 0.00988755f, -0.04343567f, 0.05814650f, 0.02451978f, -0.00502783f, 0.03816064f, 0.22092299f, 
    0.17322424f, 0.15255791f, 0.04490414f, -0.01206937f, 0.04420597f, 0.04783526f, 0.04858645f, 0.10128209f, 
    -0.04917488f, -0.00381452f, 0.15058334f, -0.02039069f, -0.05316609f, -0.00076176f, -0.01929834f, -0.02387684f, 
    0.52792925f, -0.14163882f, -0.26154867f, -0.51257962f, 0.04945159f, 0.07643736f, -0.01760874f, -0.13532317f, 
    -0.08431416f, -0.00991592f, 0.03230984f, 0.06495009f, 0.44192463f, -0.06610621f, -0.01696770f, -0.41714773f, 
    -0.04034200f, 0.00629775f, -0.06104822f, 0.01432553f, -0.04493545f, 0.03188195f, 0.03024509f, 0.04073071f, 
    0.27646637f, 0.16265215f, 0.20798616f, 0.00759480f, -0.17350569f, -0.08270012f, -0.12051027f, 0.19443229f, 
    -0.03463576f, 0.00078116f, 0.03843552f, -0.00181564f, 0.38687718f, 0.31483641f, 0.10272541f, 0.25233784f, 
    -0.01206904f, -0.00991847f, -0.01699363f, -0.04027600f, 0.11126729f, 0.06445282f, 0.04077156f, 0.09495874f, 
    0.11036655f, 0.03006220f, 0.14877139f, 0.06231251f, -0.02803162f, -0.03493359f, 0.03642755f, -0.05202237f, 
    -0.00407335f, 0.07743359f, 0.16386631f, -0.10558853f, 0.12442157f, -0.05297304f, 0.01205642f, -0.33619413f, 
    -0.05405154f, 0.03523542f, -0.03019071f, 0.10912344f, -0.20325252f, -0.16118759f, -0.02400465f, -0.04465595f, 
    0.04896525f, 0.09881850f, -0.00341737f, 0.12310080f, -0.10611729f, -0.17185171f, 0.03265155f, 0.17061819f, 
    0.11790267f, 0.04803044f, 0.19277905f, -0.07070096f, -0.44419640f, -0.32794216f, -0.40263927f, -0.21839580f, 
    0.10112559f, 0.05368411f, 0.01076589f, 0.08597723f, -0.09344765f, -0.04054898f, -0.24472277f, -0.13271658f, 
    0.17378287f, -0.06668752f, 0.14694056f, -0.09123044f, -0.04375443f, 0.14934699f, 0.09913190f, 0.10665093f, 
    -0.05747818f, 0.05608711f, 0.07246232f, -0.00462184f, 0.35280332f, 0.18304858f, 0.04376841f, -0.11459138f, 
    -0.04145265f, -0.03887577f, -0.00918018f, -0.10586388f, -0.14381367f, -0.15004867f, 0.02304697f, -0.03064160f, 
    0.23353173f, 0.17374285f, -0.28236046f, 0.02045391f, 0.00545155f, -0.02562736f, 0.21238428f, -0.07087743f, 
    0.16567980f, 0.23395619f, -0.02483195f, 0.00592809f, 0.13576227f, 0.20890768f, 0.18811345f, 0.11602170f, 
    -0.01680922f, -0.06030814f, -0.01677042f, -0.05444613f, 0.06560642f, 0.08512180f, 0.06819342f, -0.01802464f, 
    -0.12193392f, -0.22186050f, -0.12923473f, 0.09288638f, 0.19717467f, 0.14853844f, 0.13829352f, 0.05166861f, 
    -0.09921376f, -0.11060350f, -0.05614088f, -0.01070963f, 0.35394019f, 0.09018509f, -0.23031235f, 0.23501149f, 
    0.03954674f, 0.05442145f, 0.04689222f, 0.12134392f, 0.04596285f, 0.11387262f, -0.04452650f, -0.04359958f, 
    -0.13749774f, -0.15368192f, -0.24800757f, -0.04442178f, 0.18028770f, -0.05900621f, 0.11760444f, 0.03042647f, 
    -0.18877308f, -0.10050231f, -0.13595805f, 0.06494858f, -0.21292619f, -0.27868426f, -0.52999657f, -0.11484540f, 
    -0.02810834f, -0.11440457f, 0.02706119f, 0.10871927f, 0.11003745f, 0.02414384f, 0.19093408f, -0.15077044f, 
    0.17305028f, 0.26414976f, 0.11316337f, 0.12944023f, 0.03485380f, -0.02965759f, 0.02769656f, -0.03949800f, 
    0.06744148f, 0.04341568f, 0.02276264f, -0.05075052f, 0.06787379f, -0.03148098f, -0.20315929f, 0.29622903f, 
    0.15239874f, 0.08610263f, 0.01512017f, -0.12695871f, 0.11582802f, -0.13355000f, 0.08586279f, 0.05843601f, 
    -0.14969251f, -0.30409533f, -0.09055591f, -0.27075645f, 0.06986627f, 0.10940517f, 0.03691022f, 0.08429824f, 
    0.03226861f, 0.03148960f, 0.09316619f, 0.07700360f, 0.40446955f, 0.32634249f, -0.04969487f, 0.15834202f, 
    0.11007337f, 0.04444300f, 0.14982225f, -0.17658433f, 0.05223675f, 0.21060602f, 0.07982515f, -0.09119358f, 
    -0.10081851f, -0.29649168f, -0.05640464f, -0.34579250f, -0.12417112f, -0.02800656f, -0.09569284f, 0.09921423f, 
    -0.08171864f, -0.10132673f, 0.02022131f, -0.08804303f, -0.04756261f, 0.14035901f, 0.21987259f, 0.03588630f, 
    -0.27343047f, -0.06314705f, -0.06920364f, -0.08909588f, -0.01805445f, -0.06979012f, -0.21417908f, 0.00788688f, 
    0.05710708f, -0.06940300f, -0.09453323f, 0.15273920f, -0.16884188f, 0.10269091f, 0.14607313f, -0.02916906f, 
    -0.04635321f, 0.10615731f, 0.01453214f, -0.06421823f, 0.18492073f, -0.17654105f, 0.09028091f, 0.00494974f, 
    -0.01012884f, -0.04334281f, 0.03157082f, -0.00369520f, -0.06838416f, -0.18542042f, 0.00704149f, -0.01022798f, 
    -0.05576726f, -0.12047905f, -0.55135614f, -0.09505071f, 0.06866540f, -0.05326114f, 0.06056499f, 0.03055290f, 
    -0.02510430f, -0.02335976f, -0.04695161f, 0.05353584f, -0.36046764f, -0.50332963f, -0.55794442f, -0.28839266f, 
    0.05933640f, -0.10467441f, -0.05424839f, 0.08214607f, -0.06530243f, -0.05068967f, -0.19025956f, -0.04403540f, 
    -0.53384596f, -0.34673706f, -0.22677079f, -0.22305219f, 0.10345434f, 0.07695573f, 0.06435448f, -0.05252492f, 
    -0.07362708f, 0.04143133f, 0.10579740f, 0.03269612f, -0.05238222f, -0.06156966f, -0.05890881f, 0.26105410f, 
    0.21844707f, -0.09667037f, -0.04729646f, 0.01182836f, -0.03906475f, -0.04041516f, 0.00908416f, 0.17347156f, 
    -0.10249250f, -0.02146108f, -0.14232799f, -0.10372841f, 0.10908140f, 0.02404476f, 0.07489409f, -0.11335809f, 
    -0.05359549f, 0.07053313f, 0.00116548f, -0.00504777f, 0.14334802f, 0.18480562f, 0.09139250f, 0.05469084f, 
    0.03581606f, 0.03211693f, -0.03449189f, -0.02150508f, 0.23489927f, 0.01996045f, -0.05530570f, -0.06259865f, 
    0.06350859f, -0.07002445f, -0.06738340f, 0.10542043f, 0.04442002f, -0.07145699f, 0.22196043f, 0.07453936f, 
    0.13281326f, 0.13504811f, -0.01778965f, -0.07068922f, -0.05892606f, 0.18859565f, 0.14158997f, 0.08264467f, 
    0.05894835f, 0.05855583f, 0.01629608f, -0.02185914f, 0.02897142f, 0.17186391f, 0.17325768f, -0.01658576f, 
    -0.27976456f, -0.43806928f, -0.48490089f, -0.35984907f, 0.14589339f, 0.00952054f, 0.12149586f, -0.04566384f, 
    -0.06902801f, -0.02898676f, -0.09969969f, -0.07162236f, 0.06370131f, -0.09780804f, -0.12389508f, -0.21179803f, 
    -0.01354498f, -0.05254784f, -0.01527318f, 0.08446405f, -0.04442034f, -0.01549199f, 0.00807879f, 0.01025157f, 
    0.09162088f, 0.06131833f, -0.15775888f, 0.22860146f, 0.03620237f, 0.06838387f, 0.07000732f, -0.03870578f, 
    0.17302705f, 0.16330072f, -0.14014897f, 0.08362345f, 0.18171126f, -0.15627225f, -0.29188472f, 0.21242030f, 
    -0.01900758f, 0.07234057f, 0.10278445f, 0.26815486f, 0.03599700f, 0.01527082f, 0.02462813f, -0.07740662f, 
    -0.01942352f, -0.24351242f, -0.05048899f, 0.08575492f, -0.13258426f, 0.06642992f, 0.12803103f, 0.02473750f, 
    -0.03046143f, 0.12396584f, 0.25041541f, -0.09168902f, 0.01769817f, -0.13910379f, -0.23325224f, -0.10649981f, 
    -0.12180647f, 0.01377239f, 0.04923524f, 0.03084587f, 0.10340264f, -0.04254960f, -0.14615384f, 0.05089583f, 
    -0.01536093f, -0.02850104f, -0.00764147f, 0.00806530f, -0.00770962f, -0.00757012f, -0.03547460f, 0.02295453f, 
    -0.03405790f, 0.00111042f, 0.02219030f, -0.03555552f, -0.00178070f, -0.02338708f, -0.00156783f, -0.01221319f, 
    -0.02954991f, -0.01242187f, 0.01621299f, 0.00299790f, 0.01553915f, 0.00849268f, -0.03983602f, -0.01744985f, 
    -0.00778284f, -0.02061570f, -0.03962757f, 0.00992862f, -0.02402176f, -0.02393418f, -0.01208160f, -0.04001884f, 
    0.01532276f, 0.02312779f, -0.04132625f, 0.02741613f, 0.00330016f, 0.00639537f, -0.00149918f, -0.04139852f, 
    0.00863093f, 0.02357775f, 0.01501396f, 0.00590777f, -0.02216924f, 0.00288793f, 0.00770297f, -0.02979554f, 
    -0.03153795f, -0.04110235f, -0.01212263f, 0.02660444f, 0.02229162f, -0.03469202f, -0.00565425f, -0.02234936f, 
    0.02472509f, 0.00189125f, 0.00998013f, -0.00094309f, -0.02728017f, 0.00543041f, 0.01110854f, 0.03544059f, 
    -0.01144377f, -0.02189369f, 0.01015441f, -0.01870582f, -0.00800231f, -0.03939698f, 0.02449379f, 0.00196137f, 
    -0.00951888f, -0.02747222f, 0.00942596f, 0.00936495f, -0.03657516f, 0.00352817f, -0.01703114f, 0.02871129f, 
    0.02026209f, 0.02942492f, -0.02300134f, 0.02228529f, -0.00778193f, -0.01944298f, -0.00337785f, -0.00790122f, 
    -0.01186058f, 0.01666576f, -0.00095826f, -0.00072613f, -0.00712982f, 0.00968856f, -0.03805625f, 0.00363137f, 
    0.01590772f, -0.03869656f, 0.01651272f, -0.01293063f, -0.01206728f, -0.01512623f, -0.02543530f, 0.02204591f, 
    0.00320487f, 0.02752690f, -0.04083882f, 0.01925636f, -0.02967014f, 0.01078215f, -0.02160382f, 0.01869647f, 
    -0.01580171f, -0.02897471f, -0.03991219f, 0.01337257f, -0.01801468f, -0.01915080f, 0.00730392f, -0.03815223f, 
    -0.01463678f, -0.02331786f, 0.00317093f, -0.00950503f, -0.02777348f, -0.02822831f, 0.02712783f, -0.02708181f, 
    -0.04162747f, -0.01647797f, 0.01354769f, -0.00060059f, -0.02584086f, 0.02244994f, 0.01034976f, 0.00310177f, 
    0.02129489f, -0.01697979f, -0.03861517f, -0.02193221f, -0.01774264f, -0.03599770f, 0.02913951f, 0.02646030f, 
    -0.01947488f, -0.01366844f, 0.00150094f, -0.04088114f, 0.02030629f, -0.02725991f, -0.03433914f, -0.03203702f, 
    0.00249927f, 0.00358168f, 0.00488016f, -0.00572333f, -0.01013421f, -0.02853425f, 0.00239282f, -0.00470402f, 
    0.01286193f, 0.01887268f, -0.03586384f, -0.03193449f, -0.00853760f, -0.02285369f, 0.00255285f, -0.03970240f, 
    0.01599536f, -0.03196638f, -0.03349406f, 0.01065545f, 0.00352359f, -0.01895018f, -0.00398231f, -0.00343227f, 
    -0.03676628f, -0.02126116f, -0.04152660f, 0.02936117f, 0.02683856f, -0.00768476f, 0.00706390f, 0.02665275f, 
    -0.02048070f, 0.02845676f, 0.03164572f, -0.02167257f, -0.00453539f, -0.00872511f, -0.01124664f, -0.01038740f, 
    0.01719393f, -0.03188082f, 0.01658631f, -0.01113043f, -0.00086870f, -0.01045200f, -0.00570237f, -0.00708712f, 
    0.00650860f, -0.01361963f, -0.01990137f, 0.02349675f, -0.03522792f, 0.00898093f, 0.00371291f, -0.01422560f, 
    -0.01344066f, -0.01265450f, -0.00076786f, 0.01879225f, -0.00788505f, -0.03376135f, 0.01476781f, -0.01389791f, 
    -0.03803387f, -0.00681517f, -0.01989706f, 0.01355794f, 0.00697362f, -0.04165736f, -0.02191111f, 0.01698368f, 
    0.02149854f, 0.00793613f, -0.01091155f, 0.03042276f, 0.01250289f, -0.00622889f, 0.01673665f, -0.01826497f, 
    0.02867965f, -0.00234985f, 0.02048231f, 0.02612852f, -0.03691295f, -0.01766828f, -0.00503023f, 0.02531432f, 
    0.02052863f, -0.00086262f, 0.02122125f, -0.03466868f, -0.01376031f, 0.01835332f, -0.02240511f, -0.00078254f, 
    0.00113553f, -0.02935543f, 0.01138394f, -0.01437166f, 0.02055318f, -0.01022063f, 0.02135414f, -0.03749516f, 
    -0.02645667f, -0.01402396f, 0.01605051f, 0.01266006f, -0.02861745f, 0.00437920f, -0.02025433f, -0.02188396f, 
    -0.00992570f, -0.03604059f, -0.03018872f, -0.02376814f, -0.03125370f, -0.01375043f, 0.02208964f, -0.00786352f, 
    -0.00004580f, -0.03711487f, -0.03463779f, -0.01049735f, -0.02050820f, -0.02043650f, -0.03527464f, -0.01905865f, 
    -0.03235069f, 0.03358860f, 0.02422877f, 0.02143073f, -0.00960028f, -0.04189916f, -0.01915992f, -0.01267663f, 
    -0.02035586f, 0.02050972f, 0.00447327f, -0.01872095f, -0.02253439f, 0.02843230f, -0.01246415f, -0.00665283f, 
    -0.02935126f, -0.02113079f, -0.01440701f, -0.01994404f, 0.02284999f, -0.03930118f, -0.03897117f, 0.01902034f, 
    0.01686399f, -0.02500999f, 0.02134118f, -0.02462889f, 0.02530215f, 0.02013626f, 0.02638442f, 0.01289079f, 
    0.01165832f, -0.03892027f, 0.00560936f, 0.03183578f, 0.00209190f, 0.02738346f, -0.00527663f, -0.02403556f, 
    -0.03617724f, -0.01299784f, 0.02332913f, -0.01367710f, -0.01301292f, -0.01415050f, 0.00145436f, 0.00786267f, 
    -0.02747850f, -0.02282028f, 0.02150941f, 0.02477271f, -0.01073263f, -0.03133754f, -0.03137349f, -0.02249479f, 
    0.02599044f, -0.02319506f, 0.01761642f, -0.00887847f, 0.02649259f, 0.00402814f, 0.01647367f, 0.03319797f, 
    0.00460894f, 0.00416170f, -0.00753910f, -0.03699180f, -0.01652578f, -0.04080926f, 0.01853043f, 0.01940682f, 
    -0.00465541f, 0.02766480f, -0.03489439f, -0.03417023f, 0.01906038f, -0.00448762f, -0.00964577f, 0.02545966f, 
    -0.02610741f, -0.03655447f, 0.00885832f, -0.02464162f, 0.01319429f, 0.01862955f, 0.01384405f, -0.03442964f, 
    0.01830773f, -0.02312322f, -0.02397799f, -0.02979604f, 0.02454275f, -0.01254537f, 0.02272956f, -0.02604199f, 
    -0.02081302f, 0.01294745f, -0.01869901f, 0.01627591f, 0.00518880f, 0.02547047f, 0.01302053f, -0.02280908f, 
    -0.03158471f, -0.03327899f, 0.00877132f, 0.02936561f, -0.00723336f, -0.01778181f, -0.01890414f, -0.01546998f, 
    -0.03964719f, 0.00875498f, 0.00828404f, 0.02305494f, -0.02818253f, 0.01317020f, 0.02959586f, -0.01591533f, 
    -0.01705148f, -0.03188851f, 0.02892432f, -0.03541912f, -0.00895656f, 0.01850846f, 0.00306322f, 0.03554920f, 
    -0.01721994f, 0.01537695f, 0.00619711f, 0.00427272f, 0.00543048f, 0.02270993f, -0.02149483f, -0.03619118f, 
    -0.01520704f, 0.01117596f, 0.00535774f, 0.00677448f, -0.02770983f, -0.02905846f, -0.02954371f, 0.00853247f, 
    -0.00409524f, -0.03906451f, -0.01804656f, -0.02708100f, -0.03571483f, -0.04023552f, 0.02232012f, -0.00695820f, 
    -0.00460043f, 0.00137463f, -0.02264734f, 0.00269370f, 0.00021434f, -0.00897998f, -0.01237201f, -0.02810759f, 
    -0.02594254f, 0.02067987f, 0.00302817f, 0.02436048f, 0.01529668f, -0.03481376f, 0.02783231f, -0.00543997f, 
    0.00220760f, 0.02306481f, 0.02075641f, 0.02655699f, 0.01150890f, 0.02008443f, -0.03889252f, -0.02518104f, 
    -0.02670028f, 0.00971495f, -0.01073956f, -0.00536443f, 0.02468861f, 0.01845676f, -0.03143874f, -0.03863699f, 
    0.01618272f, -0.03176228f, 0.01017149f, 0.01738011f, 0.02030290f, 0.00428365f, 0.01622506f, -0.01951839f, 
    -0.03729352f, -0.01733272f, 0.00240455f, -0.01823826f, -0.00092132f, 0.02555719f, -0.01731657f, 0.02912765f, 
    0.00750252f, -0.02429462f, 0.01782599f, -0.01101260f, -0.04105807f, -0.01760869f, -0.01278550f, -0.02220483f, 
    -0.02892586f, -0.00235729f, -0.01397091f, 0.01287652f, 0.00224271f, 0.02869735f, -0.02571886f, -0.00491699f, 
    0.00810118f, 0.02894937f, -0.03381277f, -0.04187812f, -0.02054389f, 0.00085752f, -0.04142626f, -0.03419897f, 
    -0.00408665f, -0.03509019f, -0.00481632f, -0.01654824f, -0.00639862f, -0.00412174f, -0.01209926f, 0.01699748f, 
    -0.00898130f, -0.01228426f, -0.02517109f, 0.02721451f, 0.02352348f, -0.02349386f, -0.02168164f, 0.02157186f, 
    -0.00985240f, -0.00105735f, 0.02315183f, -0.01669699f, -0.01146436f, -0.03430296f, -0.00040218f, -0.03028935f, 
    -0.03664036f, -0.02369772f, 0.01911366f, -0.03481932f, 0.01722549f, 0.01698766f, -0.02987075f, -0.04125572f, 
    -0.03076162f, 0.00107836f, -0.02885473f, 0.02214380f, -0.01155712f, 0.00961668f, -0.02020838f, 0.00830301f, 
    -0.01823498f, -0.02479019f, 0.00957709f, 0.02974306f, -0.00264498f, -0.02378619f, -0.01080976f, -0.02552641f, 
    0.03554869f, -0.00987433f, -0.03020442f, -0.01565448f, 0.01769748f, -0.01052157f, -0.00292613f, 0.02229108f, 
    0.02947191f, -0.02403015f, 0.02731732f, -0.04160882f, -0.01082159f, -0.00051813f, 0.01471908f, -0.03060002f, 
    -0.02427137f, -0.00248557f, -0.00698180f, -0.03397436f, -0.03890944f, -0.02264084f, -0.00016049f, -0.00320582f, 
    -0.03347048f, 0.01467442f, -0.00500846f, 0.01199017f, -0.01035878f, 0.01150802f, 0.01757723f, -0.00372665f, 
    -0.03699530f, 0.01861728f, 0.02423622f, -0.03543884f, -0.03514397f, -0.01702190f, 0.01679293f, -0.03892019f, 
    0.01074150f, -0.02753612f, 0.01774289f, 0.00386883f, 0.00250209f, -0.00697512f, 0.02886212f, 0.01497191f, 
    0.02540351f, -0.02392004f, -0.00847537f, -0.01137868f, 0.01879707f, -0.03357238f, -0.02557115f, -0.00362214f, 
    -0.02485370f, 0.01105508f, -0.00414997f, -0.03542197f, -0.02260781f, 0.01730869f, -0.02069454f, 0.00940678f, 
    -0.03158756f, -0.02567826f, -0.00982834f, -0.03112845f, -0.01440590f, -0.00393046f, -0.02383838f, 0.01313851f, 
    0.02505806f, 0.00615502f, -0.00141291f, 0.00914802f, 0.02312961f, 0.00527138f, 0.02495891f, -0.00294318f, 
    -0.02077441f, -0.02638778f, 0.03175689f, -0.03894899f, 0.01351594f, -0.00284274f, -0.03139285f, 0.02722158f, 
    -0.00997804f, -0.00712736f, 0.02498364f, 0.02973040f, 0.01727034f, 0.02091789f, -0.02429558f, -0.03892637f, 
    0.00778066f, -0.00505072f, 0.00231291f, -0.03139458f, 0.01324925f, -0.03986996f, 0.00235919f, -0.03843353f, 
    -0.03291786f, -0.01864141f, -0.03166712f, -0.03390259f, -0.01141797f, -0.02378619f, -0.00178815f, 0.02563901f, 
    -0.00358651f, -0.02406818f, -0.02574578f, -0.02920528f, 0.01916808f, -0.03764936f, 0.01133211f, 0.01212981f, 
    -0.01149801f, -0.00343656f, 0.02292865f, -0.02204124f, -0.03641320f, -0.01784849f, -0.01216706f, 0.01921773f, 
    0.01375538f, 0.01926231f, -0.01367585f, -0.03322383f, 0.00392031f, 0.01253782f, 0.02076939f, 0.01751655f, 
    -0.01176975f, 0.01829243f, -0.02026322f, 0.01741138f, -0.03008957f, -0.01967240f, 0.00389394f, -0.02809053f, 
    0.02792731f, 0.02614051f, 0.01606474f, -0.01500415f, -0.02598972f, 0.00763139f, 0.00939614f, -0.02478039f, 
    -0.03279206f, -0.01247184f, -0.01391818f, -0.02307742f, -0.00803586f, -0.02395333f, -0.00672727f, 0.02157780f, 
    0.01849735f, -0.02454223f, 0.02243855f, 0.00782766f, 0.01276438f, -0.02795246f, 0.00786878f, -0.01775490f, 
    0.01559615f, 0.00375137f, 0.00396188f, 0.02000854f, 0.00383603f, -0.03425952f, -0.00061547f, 0.02091947f, 
    -0.04190570f, -0.02238842f, 0.01692100f, -0.00454792f, -0.03447130f, 0.00085391f, -0.03905585f, 0.02876337f, 
    -0.01987510f, 0.00172425f, -0.02764847f, -0.01779687f, -0.00115527f, -0.00846903f, -0.02568450f, -0.00718860f, 
    0.02044016f, -0.01457833f, 0.02575757f, -0.02074544f, -0.02119146f, 0.02995070f, 0.02929653f, 0.01308681f, 
    0.02283093f, -0.03177610f, -0.03114013f, -0.04095947f, -0.00750687f, -0.03510677f, -0.03300242f, -0.04116634f, 
    -0.02557997f, -0.00909304f, -0.02353949f, 0.01960453f, 0.00323494f, -0.03643651f, 0.00096967f, -0.02406963f, 
    0.02809065f, -0.03500985f, -0.00022082f, 0.03216454f, 0.00858426f, 0.00245253f, -0.00394748f, -0.03504093f, 
    -0.01934580f, -0.01851940f, 0.01374701f, -0.03381521f, -0.01927156f, 0.01229887f, -0.04311597f, -0.03162225f, 
    -0.01093771f, 0.00615323f, -0.01220911f, -0.01549307f, 0.00324855f, 0.01006988f, -0.02732209f, -0.00011574f, 
    -0.02309229f, 0.02355842f, -0.01178320f, -0.01754288f, 0.01710849f, 0.02688244f, -0.03092829f, 0.03492046f, 
    0.00807069f, -0.03234125f, -0.00512903f, -0.02329047f, -0.00486015f, -0.00656952f, -0.00025734f, 0.01431754f, 
    -0.03122639f, -0.02346073f, -0.03911867f, 0.00268679f, 0.01653272f, -0.00134928f, -0.01008698f, -0.00220940f, 
    0.02377736f, 0.01157734f, -0.01984239f, 0.03290686f, -0.02100778f, -0.04306754f, 0.00446041f, 0.02093416f, 
    0.00042906f, 0.02136123f, 0.00755064f, -0.02036212f, -0.00609944f, -0.03176123f, -0.00923220f, 0.02130718f, 
    -0.02051337f, -0.02236616f, -0.01792642f, -0.04537061f, 0.01969776f, -0.02687453f, 0.01061509f, 0.01074758f, 
    0.02604050f, 0.00923463f, 0.03143282f, 0.00698948f, -0.00090697f, -0.01611249f, 0.00939215f, -0.01293451f, 
    -0.02140101f, -0.03055355f, 0.00888899f, 0.02466477f, -0.00464050f, -0.03094161f, 0.00910140f, -0.02159289f, 
    0.01170775f, 0.01848983f, 0.01388646f, -0.03636386f, -0.01039584f, -0.01194444f, -0.00393508f, 0.01204590f, 
    -0.00282337f, 0.00823152f, -0.04586526f, 0.01814124f, 0.01338894f, -0.00780112f, -0.02127028f, -0.02102356f, 
    -0.03472538f, 0.00306483f, -0.00341482f, -0.00524313f, 0.01728484f, -0.00159458f, -0.02900594f, 0.00437210f, 
    -0.01840987f, -0.00369559f, -0.02358740f, 0.00331740f, -0.04435192f, 0.00172129f, 0.00252328f, -0.02810007f, 
    -0.01522186f, 0.02499967f, 0.02227635f, -0.01451533f, -0.02680084f, 0.01224612f, -0.00082398f, -0.03155921f, 
    0.01056628f, -0.02347707f, -0.00416890f, -0.00068434f, 0.02215578f, 0.01390116f, 0.02496533f, -0.03070665f, 
    0.03135304f, 0.00477101f, -0.03606131f, -0.02472625f, 0.00680282f, -0.03994203f, -0.00749216f, 0.01007306f, 
    0.00110770f, -0.00831852f, -0.02478539f, -0.03844974f, -0.04066173f, 0.00802331f, -0.00555544f, -0.01291292f, 
    -0.03982397f, 0.04440259f, 0.02803568f, -0.01666667f, -0.01092517f, 0.00825796f, -0.02158083f, -0.00674088f, 
    -0.04515374f, -0.00246165f, -0.03498708f, -0.02738623f, -0.00929395f, 0.02101856f, -0.03306245f, -0.03681113f, 
    0.00369673f, 0.01710221f, 0.00712186f, -0.03830714f, -0.00769303f, 0.01946958f, -0.00410512f, 0.02588643f, 
    -0.02193538f, -0.01702575f, -0.03281361f, -0.01511569f, -0.03674912f, -0.03770763f, -0.00329759f, 0.00514117f, 
    0.03067207f, -0.00676116f, -0.00506556f, -0.03503721f, 0.01012810f, 0.02017938f, -0.02193913f, 0.00242234f, 
    -0.04238567f, -0.00902035f, 0.01911160f, 0.01168163f, 0.01655519f, 0.01843480f, -0.00906004f, 0.00425322f, 
    -0.02145671f, -0.03731707f, -0.00658551f, -0.00093681f, -0.00568414f, -0.00522260f, -0.01114879f, -0.00213255f, 
    0.03042455f, 0.03409461f, 0.02752219f, -0.03099201f, -0.02252440f, 0.00923225f, -0.00955487f, -0.00965262f, 
    -0.02091001f, -0.00308701f, 0.01173455f, -0.00327159f, 0.01258509f, -0.01849140f, -0.01788072f, 0.01344204f, 
    -0.02236421f, -0.00163928f, -0.03081455f, -0.02750157f, 0.01032793f, 0.01173744f, 0.03082591f, 0.02876649f, 
    -0.03190481f, -0.02314522f, 0.01242477f, -0.01308371f, 0.01721392f, -0.02622734f, 0.02346051f, -0.03871487f, 
    0.00837814f, 0.02091033f, 0.01434365f, -0.01401739f, -0.03412072f, 0.02917431f, -0.03280501f, -0.00765131f, 
    -0.03129982f, 0.01474820f, -0.01403845f, -0.03417469f, 0.01640658f, 0.01741348f, 0.02185688f, 0.01273270f, 
    -0.04064751f, -0.00917981f, 0.01707513f, 0.01685500f, -0.01961130f, -0.01192521f, 0.01961201f, 0.01882401f, 
    -0.00612249f, -0.00451095f, -0.02937740f, -0.01566079f, -0.02480870f, -0.01722145f, 0.01999121f, 0.02355114f, 
    0.02051942f, -0.01474784f, -0.02260789f, -0.03398676f, 0.00102168f, 0.01642358f, 0.00548569f, -0.02531425f, 
    0.01952679f, 0.02702378f, 0.01762654f, -0.00585594f, -0.03282654f, -0.02771286f, -0.02868363f, -0.02929949f, 
    -0.00905218f, -0.01048460f, -0.03267995f, 0.02303884f, -0.04123329f, 0.02335151f, -0.00396297f, -0.03573532f, 
    -0.02274498f, -0.03760369f, 0.02841764f, -0.02485609f, 0.00928500f, -0.00653736f, -0.02670875f, 0.00213659f, 
    -0.01835747f, 0.00040009f, 0.00970765f, 0.00020062f, 0.01837218f, -0.01946093f, -0.01982669f, 0.02423962f, 
    -0.01575773f, 0.00130948f, -0.00137310f, -0.03247013f, 0.00700185f, -0.04068379f, -0.01030291f, -0.02513613f, 
    -0.04232550f, -0.02766860f, 0.00979944f, -0.00711469f, -0.04189740f, 0.02445436f, -0.03046303f, -0.00837869f, 
    -0.03071701f, -0.00516090f, -0.00097255f, -0.01885422f, -0.00796614f, -0.02437495f, 0.00200989f, -0.02938295f, 
    0.02374305f, -0.01090005f, -0.00297795f, 0.02936079f, 0.02398418f, 0.01754119f, 0.00593779f, -0.02554276f, 
    -0.00475834f, 0.00636513f, 0.01376773f, 0.00940197f, 0.00920453f, 0.00291499f, 0.01591934f, 0.00050770f, 
    0.02474342f, -0.02794365f, -0.03306313f, -0.00347984f, 0.01085566f, -0.03774643f, 0.01049257f, 0.02341818f, 
    -0.01842911f, 0.02526548f, -0.04241984f, -0.00306599f, 0.01878744f, 0.01910637f, -0.03950495f, -0.04438903f, 
    0.01010255f, -0.00109124f, 0.00449905f, -0.02170472f, -0.03210443f, 0.01784783f, -0.00471718f, -0.00928651f, 
    0.02312927f, 0.02420283f, -0.03244120f, -0.01852007f, 0.03416718f, -0.02367944f, -0.00504883f, -0.00505995f, 
    0.00209558f, -0.01832806f, -0.01222030f, 0.02965218f, 0.02221207f, -0.04084807f, -0.00290157f, -0.02244199f, 
    -0.03848071f, -0.03340061f, -0.02727685f, 0.01824572f, -0.01652925f, -0.00599687f, -0.02893970f, -0.02276822f, 
    -0.01013093f, 0.00001676f, -0.02873298f, 0.01563465f, -0.00423851f, -0.02605775f, 0.01581399f, -0.03032262f, 
    -0.01508977f, 0.02854738f, 0.02268348f, 0.02638017f, -0.01932237f, 0.02320644f, 0.02321454f, 0.00151273f, 
    -0.01595455f, -0.02253267f, -0.02919489f, -0.00590799f, 0.00277693f, -0.02893192f, -0.03400330f, 0.01137196f, 
    -0.03633225f, 0.02533953f, -0.03669311f, 0.03130019f, -0.01972868f, 0.00666037f, 0.00442516f, -0.00706026f, 
    0.03794274f, -0.03397011f, -0.01378414f, -0.01199344f, 0.02151956f, -0.03271174f, 0.01688760f, -0.03266299f, 
    0.00920597f, 0.00568227f, -0.00650216f, -0.02164170f, -0.00381114f, -0.02400133f, -0.03913550f, 0.01985561f, 
    0.02872957f, 0.01629999f, -0.00489270f, -0.03854707f, -0.02776885f, 0.01529773f, 0.02477013f, -0.03050193f, 
    0.03791481f, 0.02832657f, 0.02519798f, -0.02238138f, -0.03574887f, -0.03606759f, 0.00807018f, -0.03806107f, 
    -0.01138839f, 0.00605098f, -0.03140428f, -0.02114661f, 0.02017766f, -0.00034707f, 0.02001686f, 0.00226482f, 
    0.01497544f, 0.02135048f, -0.01180643f, -0.03910206f, -0.00358552f, 0.00087295f, -0.02073278f, -0.02906230f, 
    -0.03111566f, 0.01574982f, -0.00312084f, -0.00295338f, -0.02876889f, 0.00813297f, -0.00186918f, 0.00091583f, 
    -0.02354383f, 0.00672043f, -0.03589640f, 0.01400637f, -0.03257894f, 0.00672011f, -0.00980325f, 0.04226043f, 
    -0.00062628f, -0.00197997f, 0.01811457f, -0.02171052f, 0.00890074f, -0.03748980f, -0.03547224f, -0.00580055f, 
    -0.01258067f, 0.02179616f, 0.01693076f, -0.03590994f, -0.02677055f, -0.00988376f, 0.00974809f, -0.01138822f, 
    0.00352465f, 0.00118228f, 0.01940511f, 0.00149743f, -0.00536414f, -0.03307334f, 0.01870183f, 0.01861569f, 
    -0.01758765f, -0.03280711f, 0.00475804f, 0.01930435f, -0.02194979f, -0.04008748f, -0.00436345f, 0.02189897f, 
    0.02519228f, 0.03600116f, 0.01913400f, 0.02993356f, -0.01248052f, 0.02018609f, -0.03673522f, -0.01957000f, 
    0.02209178f, 0.01668603f, 0.00467511f, -0.01078543f, -0.00194613f, -0.04126254f, -0.03090899f, -0.01705380f, 
    -0.00103598f, 0.00951991f, 0.01893569f, -0.00502107f, 0.00916860f, -0.03059174f, 0.00611820f, 0.01767856f, 
    0.02439645f, -0.01758635f, -0.00785367f, 0.03059238f, 0.00703385f, 0.01558671f, 0.03516439f, -0.00712067f, 
    0.02107191f, -0.00052122f, 0.02501637f, -0.02020326f, -0.00563065f, 0.03446262f, -0.00813961f, 0.02248071f, 
    -0.02790182f, -0.03577576f, 0.00012073f, 0.00368343f, -0.01487187f, -0.01104719f, -0.00166848f, 0.03046160f, 
    -0.01497685f, -0.04454440f, 0.00251901f, -0.00225788f, 0.02704974f, -0.00365348f, 0.02641533f, -0.03352687f, 
    -0.01768541f, 0.01843669f, 0.01516030f, -0.02623876f, 0.02691320f, -0.02707836f, -0.01043432f, 0.00275006f, 
    -0.01309078f, -0.00037283f, -0.01847576f, -0.00169332f, -0.01251247f, -0.00571078f, 0.02210066f, 0.02012598f, 
    0.01657853f, -0.00174968f, -0.01114427f, -0.00945418f, 0.00506168f, -0.02596742f, 0.02269765f, 0.03026245f, 
    -0.00766974f, -0.04400804f, 0.02578853f, 0.01799275f, 0.03464761f, -0.02691899f, 0.00808654f, -0.00837086f, 
    -0.03046755f, 0.02962889f, -0.03261848f, 0.00946446f, -0.02109848f, 0.01716862f, -0.02935657f, 0.01657679f, 
    -0.01703801f, 0.03286554f, -0.00979300f, 0.01221580f, -0.03066496f, 0.01121099f, -0.00676693f, 0.00118103f, 
    0.01617758f, -0.00537226f, -0.03607434f, -0.01016859f, -0.01889595f, -0.02239968f, 0.00546541f, -0.01127133f, 
    -0.04007792f, -0.04027947f, -0.00585308f, -0.04265933f, 0.01346758f, -0.00917071f, 0.02652387f, -0.02775711f, 
    -0.02355625f, 0.00554915f, -0.04181688f, -0.03981782f, 0.01195682f, -0.01401212f, -0.02354030f, -0.02762640f, 
    0.01449925f, -0.00762949f, 0.01858452f, -0.01864465f, 0.01559843f, 0.02325737f, -0.02887021f, -0.01477705f, 
    -0.00139316f, 0.00880648f, -0.04444516f, 0.00589195f, 0.01210638f, -0.00008708f, 0.01648763f, -0.00068478f, 
    -0.00029985f, 0.01687466f, -0.04203622f, -0.03494116f, -0.00400107f, 0.01879746f, 0.02542255f, -0.01591125f, 
    0.01511061f, 0.00303827f, -0.00530891f, -0.00893595f, -0.01136981f, -0.03942192f, -0.03652927f, 0.00846397f, 
    0.01850982f, -0.00258546f, 0.00908073f, -0.02860249f, -0.00302449f, 0.01806972f, -0.02544850f, -0.02966010f, 
    -0.00634642f, 0.00240722f, 0.01948305f, -0.01734317f, 0.02099290f, -0.01945125f, 0.00296897f, -0.03311300f, 
    -0.01825785f, 0.02257816f, -0.02829526f, -0.02523043f, 0.02196355f, -0.03408703f, -0.02795067f, -0.02148994f, 
    0.00752191f, 0.01199081f, -0.04127712f, -0.04153069f, -0.01067167f, 0.01013307f, 0.01913656f, -0.01889067f, 
    0.01442251f, 0.02104194f, -0.01776177f, 0.01213564f, -0.03439954f, -0.04160720f, -0.02496756f, 0.00605374f, 
    0.01799708f, -0.04545841f, -0.02705087f, -0.00213306f, 0.02204134f, -0.03333518f, -0.04113471f, 0.01795434f, 
    0.00257963f, 0.00218545f, -0.00916640f, 0.01021158f, -0.03588547f, -0.00276513f, -0.02131618f, -0.01463087f, 
    0.00490709f, 0.02350840f, 0.02901148f, -0.00393351f, -0.03842890f, -0.03207896f, 0.01366058f, 0.02403464f, 
    -0.02775255f, -0.03459665f, -0.02844615f, -0.02140467f, -0.01542513f, -0.00743137f, -0.02293003f, -0.03420127f, 
    0.02299677f, 0.01237892f, 0.01538856f, -0.04432339f, -0.02730681f, -0.01431906f, 0.02602498f, -0.03951180f, 
    -0.01378414f, -0.02905071f, -0.01095868f, -0.02307948f, -0.03267085f, -0.02981351f, -0.03024752f, 0.00438392f, 
    -0.02750181f, -0.00173146f, -0.03634747f, 0.01391295f, -0.00345425f, 0.01307426f, -0.01177463f, -0.02207772f, 
    0.00464710f, 0.01339408f, -0.03444183f, -0.03872629f, -0.02781167f, -0.01031062f, -0.02750385f, 0.03595030f, 
    -0.03358736f, 0.02041795f, 0.01254995f, -0.02232136f, -0.00106846f, -0.03319827f, -0.03094420f, 0.01957883f, 
    0.00801422f, -0.00381240f, -0.04087394f, -0.02253764f, 0.00052294f, -0.00497785f, -0.02077781f, 0.00750035f, 
    0.00522113f, -0.01658896f, -0.01863786f, -0.01423933f, -0.04380200f, -0.03946463f, -0.01628571f, -0.03459432f, 
    0.01606744f, -0.00508535f, -0.03926967f, -0.02895091f, -0.03126096f, -0.01120197f, 0.02677880f, 0.01030260f, 
    -0.00502957f, -0.03605319f, -0.01439838f, 0.02593820f, -0.01559898f, 0.02697874f, 0.01495200f, 0.03389240f, 
    -0.00110788f, -0.00816451f, -0.01318367f, -0.02893877f, -0.00760125f, -0.03344949f, -0.03120927f, -0.03311374f, 
    -0.01170614f, -0.00957390f, -0.02384464f, -0.01909922f, -0.01841092f, -0.03666926f, -0.03465511f, 0.02105901f, 
    -0.02327076f, -0.02872701f, -0.02941669f, 0.02284268f, 0.00545941f, 0.03740477f, -0.00628669f, -0.00048206f, 
    -0.00777800f, -0.02311444f, 0.00193019f, 0.00417756f, -0.02335766f, -0.03621649f, -0.01643254f, -0.03268034f, 
    0.01080294f, -0.02591014f, 0.00595385f, -0.00894293f, -0.04043474f, -0.01583214f, -0.01709790f, 0.02091791f, 
    -0.00221864f, 0.03557204f, 0.01643003f, -0.02025012f, 0.02564541f, 0.00493182f, -0.02934356f, 0.00054524f, 
    0.02964353f, 0.01571880f, -0.03421360f, 0.00189358f, -0.03247955f, -0.02044061f, 0.01153820f, 0.00780632f, 
    0.00055940f, -0.03846567f, -0.02059342f, 0.00830237f, -0.01873898f, -0.03896783f, -0.02641387f, -0.03461152f, 
    0.02577920f, -0.00370645f, -0.01298848f, -0.02082645f, 0.01481702f, 0.00661119f, 0.01387215f, 0.00704775f, 
    -0.03832060f, -0.00984233f, 0.01474144f, 0.02591572f, 0.00572729f, 0.01204416f, -0.03095876f, 0.01316923f, 
    0.02584085f, 0.02163698f, 0.01644683f, -0.01063358f, -0.02307525f, -0.01194812f, -0.00580809f, -0.01688331f, 
    0.00462297f, 0.00700272f, 0.02183393f, -0.02419621f, 0.01586674f, -0.00322963f, 0.00176954f, 0.01330561f, 
    0.01899851f, -0.03289314f, -0.02944669f, -0.01424596f, -0.01692859f, 0.00118907f, -0.02376262f, -0.01164156f, 
    0.00062227f, -0.03461305f, -0.00439899f, -0.02921709f, -0.02292982f, -0.00689603f, 0.01126516f, 0.00101708f, 
    -0.00070565f, -0.02693976f, 0.01012284f, -0.01700887f, -0.02256978f, -0.03620670f, -0.03144091f, -0.02515470f, 
    -0.03793572f, -0.02879530f, -0.02383856f, -0.01882450f, -0.02492628f, 0.00588363f, -0.01254485f, -0.01634649f, 
    -0.00344428f, -0.02419945f, -0.01804102f, 0.01228416f, 0.02097100f, 0.02408472f, -0.03644606f, -0.02580121f, 
    0.03688356f, -0.01723793f, -0.03922705f, 0.01386793f, -0.03948629f, 0.00055271f, -0.02669121f, 0.01785466f, 
    -0.02440295f, -0.01426385f, -0.02186568f, 0.02047208f, -0.00136245f, -0.04069472f, -0.03732164f, 0.00587026f, 
    -0.00685350f, 0.00248318f, -0.01406755f, -0.00866519f, -0.04187878f, 0.02501103f, 0.02446491f, -0.01909052f, 
    0.00467391f, -0.03114445f, 0.03583249f, -0.00611537f, 0.01973059f, 0.01918757f, 0.00016737f, 0.01823993f, 
    -0.03167124f, 0.03568924f, -0.01630652f, 0.02031298f, 0.02329282f, 0.00127283f, -0.01791306f, 0.02821577f, 
    0.00913080f, 0.00351977f, -0.01757001f, 0.00586255f, -0.02475173f, -0.01558978f, -0.01531368f, -0.02993544f, 
    -0.00010977f, 0.00474782f, -0.00472152f, -0.01207342f, -0.03556893f, -0.02239457f, 0.01265605f, -0.01819492f, 
    0.01407803f, -0.03400912f, 0.00765075f, -0.01378495f, 0.00915963f, 0.00714891f, -0.03586133f, -0.00334005f, 
    0.01653573f, -0.01960561f, -0.03016734f, 0.02443668f, -0.02506246f, -0.00483391f, -0.00445317f, 0.00408732f, 
    -0.01296230f, 0.01689982f, 0.01412257f, -0.01721443f, -0.02295045f, -0.03019164f, 0.02174830f, 0.02088196f, 
    -0.02657809f, 0.00031441f, -0.04096559f, -0.02020036f, -0.03097016f, -0.00367801f, -0.00877108f, 0.01311196f, 
    0.01632840f, 0.02361830f, 0.02157207f, -0.02946879f, -0.02069427f, -0.03386062f, 0.02762721f, 0.01045189f, 
    0.00765183f, -0.00141916f, -0.00127030f, -0.03963026f, 0.00339527f, -0.04265499f, 0.02491168f, 0.02365799f, 
    -0.03027257f, 0.02612398f, -0.01145223f, 0.02082435f, 0.01795401f, -0.03182835f, -0.01038422f, -0.00912074f, 
    -0.02376414f, -0.00538842f, 0.03177903f, 0.02909144f, -0.02100606f, -0.01655189f, 0.01023144f, 0.02082093f, 
    -0.01006082f, -0.00314984f, 0.01847034f, 0.00658864f, 0.01451533f, -0.02747407f, -0.02794703f, -0.01477920f, 
    0.00099470f, -0.02155189f, -0.02339915f, -0.03502594f, 0.00379987f, 0.01451125f, -0.02356582f, -0.00093820f, 
    -0.02940346f, 0.03087765f, 0.02268897f, 0.00378126f, 0.00653317f, 0.00124386f, 0.02199379f, -0.00675226f, 
    -0.03008707f, 0.02406068f, -0.02850528f, -0.04508137f, -0.01521844f, 0.02387904f, -0.03079335f, 0.01531926f, 
    -0.02984358f, 0.02498782f, -0.00666344f, 0.01066831f, 0.00587174f, -0.03831488f, -0.01244855f, 0.01959880f, 
    0.00334584f, -0.01173859f, -0.02089584f, 0.01089749f, -0.00337975f, -0.03955071f, 0.02485860f, -0.00706213f, 
    0.00071547f, -0.01682236f, -0.02090364f, -0.01288876f, -0.00210130f, -0.00604574f, 0.00780332f, 0.02321094f, 
    -0.01159493f, -0.00646507f, -0.04191655f, -0.04400542f, -0.02516369f, 0.01239489f, -0.03224902f, -0.01566421f, 
    0.01302145f, -0.03302976f, -0.01811990f, -0.03199233f, 0.00700596f, -0.00028068f, -0.01829051f, -0.04637463f, 
    -0.00623705f, -0.00544415f, 0.00813398f, -0.00345612f, -0.03456914f, -0.01606598f, -0.03813329f, -0.03049855f, 
    0.02912335f, -0.00183468f, 0.00764765f, -0.00495462f, -0.00287931f, 0.02157461f, -0.00789187f, 0.00743417f, 
    -0.02989477f, -0.02349876f, -0.02195440f, -0.02908211f, 0.02584216f, 0.01769766f, -0.03831972f, -0.01593815f, 
    -0.00720765f, -0.03409376f, -0.04601800f, 0.01464515f, -0.00796126f, 0.00286324f, 0.00875509f, -0.03771273f, 
    0.02417760f, 0.01696547f, 0.01195878f, -0.04051131f, 0.02964628f, -0.02340730f, -0.00114067f, 0.02091308f, 
    -0.01169232f, 0.00901905f, -0.03482268f, 0.00972232f, -0.04165230f, -0.03100212f, -0.01967780f, 0.02179687f, 
    0.00311326f, -0.02170834f, 0.01014781f, -0.03728705f, -0.02783808f, -0.00130381f, 0.02252736f, 0.01262728f, 
    0.00093129f, -0.04189102f, 0.01231600f, -0.02776418f, -0.00108769f, 0.02193888f, -0.03619236f, 0.01764234f, 
    -0.03097061f, -0.03372273f, 0.02093711f, -0.00275137f, -0.00218260f, 0.01733730f, -0.01538700f, 0.00001158f, 
    0.00833199f, -0.01721233f, 0.02068083f, 0.02237178f, -0.01183558f, 0.02785553f, -0.01140521f, 0.02893513f, 
    -0.01719684f, -0.00478041f, -0.03947784f, 0.00591464f, -0.04362025f, -0.00361549f, -0.04315485f, 0.01681765f, 
    0.00960303f, 0.02278435f, 0.01645490f, 0.02747924f, -0.02190236f, -0.03501076f, -0.01605863f, 0.02037530f, 
    -0.04308133f, -0.02705510f, -0.01106923f, 0.01968392f, 0.00647706f, 0.01153110f, 0.01766471f, 0.01910461f, 
    0.03491172f, 0.01462220f, -0.03941865f, -0.00132475f, 0.01713904f, 0.02088317f, 0.01157179f, -0.02527940f, 
    -0.02467657f, -0.04300674f, 0.02536057f, 0.02293420f, 0.02757618f, 0.01933279f, -0.01846272f, -0.00310640f, 
    0.00426207f, -0.03211245f, -0.02611996f, 0.01412568f, 0.01014305f, 0.02423901f, -0.03201077f, -0.02414761f, 
    -0.01963219f, -0.02009901f, -0.00689124f, 0.03321809f, -0.01603028f, 0.00072219f, -0.00497718f, -0.03033309f, 
    -0.04587649f, 0.00452310f, 0.00018469f, -0.00892601f, -0.03074313f, -0.00038578f, 0.01842424f, 0.02269785f, 
    -0.02079443f, 0.00775556f, -0.02145876f, -0.01745019f, 0.02732069f, 0.02675136f, -0.00947927f, 0.02464759f, 
    -0.02382044f, 0.00212517f, -0.01629713f, -0.03983804f, 0.00280166f, 0.02400185f, 0.02760343f, -0.03784541f, 
    -0.02163208f, -0.03046726f, -0.03154388f, 0.02051057f, -0.02862364f, 0.04587720f, -0.01405228f, -0.00655504f, 
    -0.00815422f, 0.02359859f, 0.01479859f, -0.04282865f, -0.00444969f, 0.01883206f, 0.03050106f, 0.00351735f, 
    -0.00699823f, 0.01618091f, 0.02092390f, 0.00108886f, -0.01077592f, 0.01662662f, 0.02636977f, 0.02243165f, 
    -0.00832854f, -0.04621078f, 0.02556548f, -0.00609066f, 0.00283685f, -0.01310293f, -0.00561896f, 0.00648322f, 
    0.00602557f, -0.00729926f, -0.00342812f, -0.01221101f, -0.01652852f, -0.00353984f, -0.00688665f, 0.01359690f, 
    -0.03950809f, 0.01021178f, 0.01633334f, 0.02692158f, -0.02782639f, -0.03853617f, -0.00285360f, -0.02705201f, 
    0.02163930f, -0.01082404f, -0.02492260f, 0.02384008f, -0.01590071f, -0.00194005f, 0.00175944f, 0.02200837f, 
    0.01508681f, -0.02511918f, -0.01966605f, 0.00423542f, -0.00793383f, 0.01773100f, -0.01981247f, -0.02205192f, 
    -0.01876710f, -0.01811749f, -0.03977023f, 0.03013497f, -0.02580304f, 0.01078897f, 0.00889215f, -0.01193044f, 
    -0.00868330f, -0.02121101f, 0.02211384f, 0.02019233f, -0.02756849f, -0.01113854f, -0.02198974f, -0.02061632f, 
    -0.00777296f, -0.02564232f, 0.02872431f, -0.01191841f, -0.03772413f, -0.03357596f, 0.03348778f, -0.03209292f, 
    0.01016363f, -0.03339559f, -0.04372332f, 0.00950074f, -0.03363633f, 0.01796284f, 0.00752786f, -0.01334518f, 
    -0.04277838f, 0.01755666f, 0.00445599f, -0.01856789f, 0.01009813f, -0.03221381f, -0.02543501f, 0.00457524f, 
    0.03737492f, 0.02066447f, -0.02516887f, -0.02827867f, -0.01966692f, 0.00470259f, -0.02573119f, -0.00900261f, 
    0.02305811f, 0.01638774f, -0.03396267f, 0.02325694f, -0.02347278f, -0.03064499f, -0.03351106f, 0.01555747f, 
    0.01636045f, 0.02107487f, -0.00627661f, 0.02923814f, -0.02205944f, 0.00374404f, -0.01442298f, 0.02670100f, 
    0.02178220f, -0.01489472f, 0.02576309f, 0.00674236f, 0.00454395f, -0.01980243f, 0.00820693f, -0.02234108f, 
    0.01316319f, -0.02290675f, 0.01229187f, -0.04138801f, -0.02929690f, -0.01644907f, -0.02607933f, -0.00282143f, 
    0.00492781f, -0.02533217f, -0.03354272f, 0.02329551f, 0.02125769f, -0.03962861f, 0.02098988f, -0.00671963f, 
    0.02235333f, 0.01372254f, -0.02482790f, -0.01642316f, -0.02398218f, 0.02830521f, 0.00526605f, 0.01009957f, 
    0.01080267f, -0.02140737f, -0.00227395f, 0.02412297f, -0.00959901f, 0.01501974f, 0.03030801f, -0.03447433f, 
    0.02116571f, -0.04231126f, 0.02343407f, -0.03585095f, -0.00747727f, -0.01758734f, -0.00315537f, -0.00263372f, 
    -0.00831190f, -0.00816627f, 0.00687904f, -0.01340960f, 0.02674271f, 0.02368548f, 0.01582807f, 0.04251047f, 
    0.01626009f, 0.01419089f, 0.02000373f, -0.04068619f, 0.02047839f, -0.04188460f, -0.02487676f, 0.02198167f, 
    0.01332212f, 0.01956897f, -0.00854890f, 0.00986557f, 0.01390499f, -0.00259906f, 0.00873316f, -0.00147764f, 
    0.01463803f, 0.01082393f, 0.00678173f, 0.00707500f, 0.01921966f, 0.01278557f, 0.00540555f, 0.01616227f, 
    0.00239088f, -0.01333774f, -0.02303270f, 0.00282370f, -0.01069317f, -0.01789747f, 0.00207599f, -0.02782794f, 
    0.07764794f, 0.13200206f, -0.08091601f, -0.25897029f, 0.25346249f, 0.00429675f, -0.06193705f, 0.10478697f, 
    0.01606549f, -0.05619923f, 0.04128305f, -0.00040501f, 0.06796673f, -0.13915989f, -0.03123432f, -0.15827706f, 
    -0.06638801f, -0.03102481f, -0.05577312f, -0.12340821f, 0.06180577f, -0.03504601f, -0.01919576f, -0.04420737f, 
    -0.46274215f, 0.37494883f, -0.02642076f, 0.11954480f, 0.14423659f, -0.03113415f, 0.06736202f, -0.24729854f, 
    0.06739274f, 0.03568606f, 0.13165765f, 0.13016529f, 0.03516920f, -0.27313191f, -0.20233560f, -0.09806685f, 
    0.10922149f, -0.07393231f, 0.21198738f, 0.09893065f, -0.06656313f, -0.11360019f, 0.09359206f, 0.15226619f, 
    0.11347484f, -0.07065680f, 0.21083151f, -0.17473690f, 0.04760727f, -0.05467070f, 0.09090465f, 0.02628575f, 
    -0.03384402f, -0.03359718f, -0.14604419f, -0.03570051f, -0.14160065f, 0.21090111f, -0.31370541f, -0.23823544f, 
    0.10059625f, -0.01643313f, -0.00022015f, -0.10033023f, -0.05379939f, 0.04188366f, -0.09142666f, 0.01677490f, 
    0.33160725f, 0.08440115f, -0.05315476f, -0.11586196f, -0.02227143f, 0.02469809f, -0.06545990f, 0.07522156f, 
    0.09265979f, -0.01161843f, 0.01573765f, 0.02304732f, 0.11874108f, -0.15234606f, 0.29104811f, -0.09987709f, 
    0.12720484f, -0.04409488f, -0.03284418f, -0.23219150f, -0.10706371f, -0.06217487f, -0.08381946f, -0.04015229f, 
    -0.24675883f, -0.07992696f, -0.02110054f, 0.25802192f, 0.01969496f, 0.17008136f, -0.06489840f, -0.02314056f, 
    0.07956554f, -0.01464077f, -0.02934735f, 0.11971805f, 0.06370611f, 0.21643621f, 0.02067285f, -0.21299601f, 
    -0.00855679f, 0.08534968f, 0.09707517f, 0.03334411f, 0.06942106f, -0.06140650f, -0.01283310f, 0.13562004f, 
    -0.02337511f, 0.08765786f, -0.16711451f, -0.10644971f, 0.07124158f, 0.08433424f, -0.13140950f, -0.21124637f, 
    0.18476105f, -0.10802235f, -0.02746989f, -0.13609122f, 0.15618594f, -0.20799668f, -0.09873848f, 0.04196056f, 
    0.11373664f, 0.14624892f, 0.03154721f, 0.14602259f, 0.13883704f, -0.09314609f, 0.05003582f, -0.01817727f, 
    0.09468044f, 0.02848887f, -0.09316520f, -0.07466286f, 0.04576105f, -0.11467201f, -0.05583103f, -0.03327836f, 
    0.04440071f, -0.12958243f, 0.16006941f, -0.05057581f, -0.05460379f, -0.12091407f, -0.06252115f, -0.09132060f, 
    -0.00431035f, -0.12113089f, -0.14992785f, -0.24168946f, 0.02230819f, -0.07989080f, 0.09223484f, 0.09067878f, 
    0.28304705f, -0.29824266f, 0.17557667f, -0.35254881f, 0.04730249f, -0.19900034f, 0.05795529f, -0.09521689f, 
    0.04057364f, -0.00796219f, -0.18423009f, 0.00005399f, 0.08887283f, -0.04189701f, -0.28307614f, 0.00537906f, 
    0.01362122f, -0.18951425f, -0.03547275f, -0.18263744f, 0.01484873f, -0.05111624f, 0.05743803f, -0.13104737f, 
    -0.24665934f, -0.28576103f, 0.09813230f, -0.72791260f, -0.05986166f, 0.02409805f, -0.10449655f, -0.14398758f, 
    0.00292235f, 0.06466753f, -0.00933863f, -0.01143008f, 0.09212399f, -0.08594310f, -0.27185947f, -0.26829425f, 
    0.07364380f, 0.19670369f, 0.13003136f, -0.04184777f, 0.03138006f, 0.00161580f, -0.10150671f, 0.02386508f, 
    0.08999445f, -0.07983743f, 0.27838421f, -0.07624151f, 0.07205199f, -0.09463567f, -0.22204781f, -0.04571583f, 
    -0.02965505f, -0.01468636f, 0.14995936f, 0.01929475f, 0.39044169f, 0.38189071f, 0.16387103f, -0.06062803f, 
    0.01200105f, 0.04881762f, 0.06381989f, 0.05052944f, -0.07725622f, 0.13070321f, 0.08353963f, -0.13173844f, 
    0.29658383f, 0.35989559f, 0.19951479f, 0.01294077f, -0.00955039f, 0.17133968f, 0.14598623f, 0.10281708f, 
    -0.00854566f, -0.00018074f, 0.03644996f, -0.05124198f, 0.00096108f, -0.09198504f, -0.21734372f, 0.21946704f, 
    0.10018880f, 0.00041436f, -0.07993843f, 0.08081437f, 0.05305633f, -0.00114656f, 0.07758807f, -0.04824673f, 
    -0.15317425f, 0.22695515f, -0.03136487f, 0.25259507f, 0.17438672f, -0.04291398f, -0.11220109f, -0.00120307f, 
    -0.09298026f, -0.02226897f, 0.05816434f, -0.00425504f, 0.42632073f, -0.05332199f, -0.05794149f, -0.04401245f, 
    0.06878384f, -0.09149805f, -0.09987359f, 0.31179607f, -0.05165033f, -0.14257351f, -0.10969613f, -0.27575764f, 
    0.13283435f, 0.14927943f, -0.20815215f, -0.05221067f, -0.03321729f, -0.02584577f, 0.12994136f, 0.14877497f, 
    -0.03030117f, -0.06077244f, 0.02009334f, -0.09472998f, -0.05188914f, 0.19698912f, -0.09329074f, -0.06513102f, 
    0.02189681f, 0.05835395f, 0.07238954f, 0.01206265f, 0.07439536f, -0.11169503f, -0.11258312f, -0.13663469f, 
    0.07657588f, -0.15095492f, -0.03362877f, 0.53516394f, 0.14808527f, -0.10787600f, -0.04248251f, -0.01546056f, 
    0.17720896f, 0.10884871f, -0.03369932f, -0.02335192f, 0.28697953f, -0.02258223f, 0.10869042f, 0.12263998f, 
    -0.01030229f, -0.02289122f, -0.08065018f, -0.19825327f, 0.06613106f, -0.00716026f, -0.03100821f, 0.04932293f, 
    0.09897413f, 0.07631534f, 0.00251607f, 0.16781312f, 0.05623084f, 0.07144333f, -0.12289687f, 0.01920111f, 
    0.05406721f, -0.02549728f, -0.03694510f, -0.09878981f, -0.12136205f, -0.03732213f, 0.04961236f, 0.04231670f, 
    0.08099435f, 0.14554733f, -0.01585170f, 0.13401124f, 0.02189113f, -0.04078947f, -0.01720194f, -0.10374451f, 
    0.04160644f, -0.15981755f, -0.08699193f, 0.02209562f, 0.09696644f, -0.08791944f, -0.03891382f, -0.12479949f, 
    -0.00548213f, 0.02192509f, 0.09078455f, 0.09188192f, -0.39559510f, 0.23592788f, 0.13027041f, 0.27074125f, 
    -0.12574571f, 0.10783942f, -0.14270853f, -0.26693842f, 0.16359487f, -0.02945425f, 0.02964558f, 0.15195911f, 
    0.07337966f, 0.07345753f, -0.05790994f, -0.00958274f, 0.04328270f, -0.02647706f, 0.02663301f, -0.01146581f, 
    -0.02728219f, -0.02867029f, 0.10829827f, -0.00523378f, 0.07369690f, 0.31535512f, 0.19161725f, 0.03526595f, 
    0.05121861f, -0.04917612f, 0.08729251f, 0.00377519f, 0.06290611f, 0.00238665f, 0.10258143f, 0.16971490f, 
    -0.05597501f, -0.10090777f, 0.24787973f, 0.03199920f, 0.23508960f, -0.06301972f, -0.01643132f, -0.08787194f, 
    -0.01437725f, -0.08439973f, -0.07677646f, -0.21841653f, 0.18962608f, 0.01176846f, -0.06985247f, 0.13013513f, 
    -0.08550877f, -0.02695684f, -0.24134426f, -0.16664602f, 0.02571720f, 0.06221422f, 0.01989173f, 0.08768627f, 
    -0.16419487f, -0.10446268f, -0.25158268f, -0.24766214f, -0.01591910f, 0.08650250f, 0.12101088f, -0.04520832f, 
    0.04700200f, 0.01923559f, 0.01522815f, 0.08428451f, -0.35533276f, -0.01699609f, -0.06419370f, 0.07594970f, 
    0.14114214f, 0.05793897f, -0.12255774f, -0.06244022f, 0.11148771f, -0.19559661f, -0.03110243f, -0.06177050f, 
    0.25017443f, 0.39652881f, 0.20735930f, 0.12732644f, 0.11518456f, -0.05201930f, -0.00828595f, 0.14644760f, 
    -0.03734527f, 0.10404408f, 0.12481943f, 0.01999884f, -0.05223711f, 0.44810715f, -0.33716252f, 0.18322219f, 
    -0.03051437f, 0.03074283f, 0.00759453f, 0.15061146f, -0.06240975f, -0.03821733f, -0.05687054f, -0.03559557f, 
    0.14209408f, 0.26188532f, 0.19563287f, -0.00308163f, 0.08709933f, 0.04402801f, -0.02311637f, 0.15105584f, 
    0.06694535f, 0.04505395f, -0.03876174f, 0.00000655f, 0.19938648f, -0.19790773f, 0.00328669f, -0.51983118f, 
    -0.13104692f, -0.01076127f, -0.02600861f, -0.03091679f, -0.01346097f, -0.01713036f, -0.03841218f, -0.01165048f, 
    0.00882099f, -0.11320814f, -0.04768092f, -0.07585753f, 0.17240563f, -0.02300672f, 0.00601997f, 0.04961464f, 
    0.15335409f, -0.01513053f, 0.04736755f, 0.00081660f, -0.21162485f, 0.11049639f, -0.06266825f, -0.14997904f, 
    0.09166953f, -0.11000486f, 0.06131498f, 0.02384478f, -0.06146117f, 0.10510309f, -0.04212400f, 0.04476948f, 
    0.21368288f, 0.07727516f, 0.12229147f, 0.10391489f, 0.10962722f, 0.00534967f, 0.00571291f, -0.01519245f, 
    0.06608682f, -0.01216712f, 0.08745073f, 0.02498207f, -0.21711256f, 0.17211436f, -0.50904649f, -0.06715539f, 
    -0.02489795f, 0.05657278f, 0.17201845f, 0.29256544f, -0.13910604f, -0.01573141f, 0.00164343f, -0.07254972f, 
    0.25552088f, -0.03857582f, 0.36125433f, -0.41752842f, -0.14151724f, 0.17390577f, -0.00529797f, -0.04120034f, 
    0.22197302f, -0.13185635f, -0.03086590f, 0.08458858f, -0.07335217f, -0.11218497f, 0.13069050f, 0.55832160f, 
    -0.00541136f, 0.06756835f, 0.08104967f, 0.13849908f, 0.11095265f, -0.03024110f, 0.05259709f, -0.08956622f, 
    0.23776248f, -0.10122950f, 0.28563470f, -0.08635437f, 0.23693289f, -0.03778772f, 0.01922171f, 0.02574835f, 
    0.09620546f, -0.00492666f, -0.19107194f, -0.03348480f, 0.17515704f, -0.19929144f, -0.03223410f, 0.07050902f, 
    0.09479740f, -0.18931313f, 0.03023692f, -0.06223352f, -0.06548624f, 0.11093821f, 0.13890697f, 0.12962477f, 
    -0.15963310f, 0.62109911f, -0.13373011f, 0.11225377f, 0.00716778f, 0.05211481f, -0.00580884f, 0.01595078f, 
    0.07561291f, -0.05236732f, 0.02822369f, 0.03993084f, 0.01268455f, 0.33423990f, -0.13392748f, -0.14074819f, 
    0.05100600f, 0.03858984f, 0.03637945f, 0.19578898f, 0.09355692f, -0.01435520f, 0.03286966f, 0.11819118f, 
    0.33782992f, 0.33200741f, 0.22475682f, 0.04454615f, 0.03699965f, -0.01203016f, 0.16461523f, -0.00471376f, 
    0.14786497f, -0.04319416f, -0.01244056f, -0.05361438f, 0.24991232f, 0.19132215f, 0.12406268f, 0.03060040f, 
    0.07475074f, -0.17894980f, -0.00155478f, 0.04439867f, -0.05090321f, 0.03134423f, -0.03179244f, -0.02867180f, 
    0.16529614f, 0.03933446f, -0.03214064f, -0.04776857f, 0.25188687f, 0.08859926f, -0.04869200f, 0.05414270f, 
    -0.10896030f, 0.05838555f, -0.08328186f, -0.12488469f, -0.01058848f, -0.08595773f, 0.05785381f, 0.20761763f, 
    0.03493371f, -0.00946115f, -0.14669487f, -0.23713668f, 0.08469011f, 0.01419054f, 0.04755900f, -0.01086724f, 
    0.06815886f, -0.36054274f, -0.03441959f, -0.64424700f, -0.07534723f, -0.05306399f, 0.04013065f, -0.12362823f, 
    0.03158199f, -0.00400802f, 0.09798361f, 0.06028173f, 0.13985680f, -0.21949799f, -0.23501822f, -0.05229523f, 
    -0.10512896f, 0.03352699f, -0.01273528f, 0.11801474f, 0.09877200f, -0.13252293f, 0.01838734f, -0.21828289f, 
    0.28787011f, 0.19945174f, 0.28376028f, 0.11728150f, 0.11312465f, 0.05919171f, 0.14440849f, 0.09577558f, 
    0.07268799f, -0.05260975f, 0.04345379f, 0.04985411f, 0.05031570f, -0.16134731f, 0.00485694f, 0.11292498f, 
    0.07896350f, -0.01884901f, 0.10461759f, 0.11937191f, 0.09129070f, -0.03399513f, 0.05029686f, 0.11153246f, 
    -0.12440934f, -0.02315036f, -0.09318876f, -0.04959571f, -0.06126732f, -0.12676725f, 0.01341076f, 0.18977086f, 
    -0.11545017f, 0.03424139f, -0.05485875f, -0.00511998f, -0.57859325f, 0.65746218f, -0.26354313f, -0.03698893f, 
    -0.06065729f, 0.01755094f, 0.05278202f, -0.02872406f, 0.00586760f, -0.02924727f, 0.02914962f, -0.03227264f, 
    -0.13342743f, 0.03672382f, -0.19426848f, 0.01784234f, -0.00044845f, -0.00273259f, -0.07501555f, -0.07431283f, 
    0.07243630f, 0.01681905f, -0.03366236f, -0.06658411f, 0.09581328f, -0.08591702f, -0.21109302f, -0.16444702f, 
    -0.03583775f, 0.08167899f, -0.02784401f, -0.01074578f, 0.09958558f, 0.00311817f, 0.07984402f, 0.10009263f, 
    0.01813300f, -0.01903358f, -0.00015455f, 0.02657419f, -0.02778188f, -0.03300839f, -0.02802226f, -0.02198856f, 
    0.01137467f, -0.04169498f, -0.02367296f, -0.00585806f, 0.00953918f, 0.00588988f, -0.03129332f, 0.00944070f, 
    -0.00582535f, -0.01938284f, -0.02475176f, 0.01534176f, -0.00631175f, 0.01405657f, 0.00425310f, -0.02186010f, 
    -0.01889192f, 0.01598905f, 0.00423893f, -0.03262080f, 0.02412701f, -0.04111896f, 0.02513879f, -0.01164556f, 
    0.02464724f, -0.00704262f, -0.01614905f, -0.01001836f, 0.01096041f, 0.02729210f, -0.02796855f, -0.01548654f, 
    0.01776849f, 0.02698704f, -0.00409925f, -0.04041638f, 0.02611195f, 0.01664786f, 0.02454387f, -0.01018183f, 
    0.00213239f, -0.00793088f, -0.04112449f, 0.01928365f, 0.02571334f, -0.00841615f, -0.01933944f, -0.00137139f, 
    -0.02149601f, 0.02942185f, -0.02059212f, 0.02427665f, -0.02283217f, 0.01733772f, -0.04014656f, -0.02389605f, 
    -0.03822235f, -0.00087327f, -0.04047336f, 0.01233562f, 0.02183070f, 0.02795425f, -0.04051986f, 0.02673493f, 
    -0.02111087f, -0.03413492f, 0.02907990f, 0.00463799f, 0.00776177f, -0.02442193f, -0.02165489f, 0.01881702f, 
    0.01136454f, 0.00136107f, -0.00820979f, 0.02100221f, -0.03016041f, -0.03656433f, -0.00085326f, -0.01464745f, 
    0.02793509f, -0.00305955f, -0.03494479f, -0.02891940f, 0.02178481f, -0.02431149f, -0.02742185f, -0.03093177f, 
    -0.02427780f, -0.01720269f, 0.01904206f, -0.00204445f, -0.00229056f, 0.02763739f, -0.03344969f, -0.00485774f, 
    -0.01891313f, -0.00284378f, -0.04134177f, -0.00756886f, 0.00108097f, -0.02848274f, -0.01851878f, 0.00423351f, 
    -0.01231126f, -0.00039702f, 0.00540336f, -0.01459209f, -0.01224807f, 0.01203124f, -0.01184773f, -0.02255540f, 
    0.00007333f, 0.00883910f, -0.01298136f, 0.00096779f, 0.02446174f, 0.00358102f, 0.00580956f, -0.02635517f, 
    -0.02217282f, -0.02718018f, -0.03558482f, -0.00914757f, -0.03735258f, -0.04131049f, -0.03149955f, -0.04199644f, 
    -0.00033098f, 0.00241117f, 0.00123331f, 0.00942918f, -0.00347343f, 0.01084887f, -0.02182715f, -0.03773361f, 
    0.00292321f, 0.02694492f, -0.01115994f, 0.02697180f, 0.02845947f, -0.02628870f, 0.00893106f, -0.02225563f, 
    0.02917630f, 0.01018616f, 0.01975353f, -0.00555552f, 0.01026816f, 0.01771292f, -0.03912779f, -0.01093359f, 
    0.02459693f, -0.02709818f, -0.00691455f, -0.01304127f, -0.01237839f, -0.02121698f, -0.00280332f, -0.00433358f, 
    0.00948731f, 0.02465130f, -0.03382246f, 0.01523355f, -0.01635252f, -0.01737155f, -0.03648685f, -0.01979269f, 
    -0.03242395f, -0.03077254f, 0.01952690f, -0.00345720f, -0.02557767f, 0.02789816f, -0.01917030f, -0.01969128f, 
    0.01929742f, -0.02430751f, -0.02737839f, -0.01936232f, -0.03704152f, -0.01719157f, -0.01190049f, -0.01479327f, 
    -0.01995396f, 0.00797178f, -0.00828102f, -0.00914608f, -0.03445292f, -0.01582752f, -0.02738998f, -0.02307907f, 
    -0.04185107f, 0.00747295f, -0.00858262f, 0.01863365f, 0.02998734f, -0.01460019f, -0.03356709f, -0.00521610f, 
    -0.02452941f, -0.02419800f, 0.02903173f, -0.03128026f, -0.02761167f, 0.02310674f, 0.02095854f, -0.01399879f, 
    -0.00955376f, 0.01588777f, -0.01800019f, 0.00956748f, -0.00693620f, 0.01811006f, -0.02537029f, 0.01665006f, 
    -0.03517564f, -0.00615233f, -0.02802029f, 0.01294313f, -0.00477550f, -0.02068695f, 0.02710713f, -0.00525427f, 
    0.02632754f, -0.02818413f, -0.01184409f, -0.03411166f, -0.03980084f, -0.01229915f, -0.00898692f, -0.00803983f, 
    -0.03771406f, -0.02848509f, -0.03808721f, -0.04166996f, 0.01997451f, -0.01102457f, 0.00503545f, -0.01530094f, 
    -0.03979125f, -0.03273537f, -0.00018248f, -0.01012207f, -0.00706598f, -0.04207424f, -0.00523235f, 0.00495435f, 
    0.02131445f, 0.00365419f, 0.00878790f, 0.00690434f, 0.02009629f, 0.00001007f, -0.03008525f, -0.03445435f, 
    0.02340772f, 0.00294760f, -0.00048286f, -0.00644781f, -0.01759328f, 0.01835230f, -0.03296361f, 0.00182038f, 
    -0.03349157f, -0.01140559f, -0.02215425f, -0.01086096f, 0.02446324f, -0.01533459f, -0.03797079f, 0.02865560f, 
    0.01513005f, -0.02645199f, -0.03313341f, 0.00099636f, -0.00709590f, -0.00458433f, 0.00687902f, 0.01472237f, 
    -0.00330046f, 0.02559170f, -0.00528905f, -0.03401062f, 0.00793026f, -0.03137403f, -0.00675647f, -0.02439932f, 
    0.00345693f, 0.01334329f, -0.01009546f, 0.00965647f, 0.01652755f, -0.02885955f, 0.00548638f, 0.02417149f, 
    -0.02756339f, 0.02793038f, -0.01073542f, 0.02032913f, -0.02701398f, 0.04205128f, -0.02088811f, -0.00364968f, 
    -0.02912694f, -0.00168897f, -0.01428950f, -0.04199130f, 0.00283198f, -0.02595700f, -0.03277077f, -0.03165918f, 
    0.02566934f, -0.00108392f, 0.01295434f, 0.00447785f, 0.01141907f, -0.03781337f, -0.00466684f, -0.01630921f, 
    -0.03018439f, -0.02409499f, -0.00128438f, -0.00799659f, -0.02941649f, -0.00638555f, 0.02185834f, 0.00912948f, 
    -0.01648986f, -0.00584701f, -0.03133691f, 0.01778649f, 0.01416313f, -0.01533366f, -0.02504096f, -0.01915864f, 
    -0.03328073f, -0.01402614f, 0.00421449f, -0.00740686f, 0.01951690f, 0.00431115f, 0.01370712f, 0.02555985f, 
    -0.02379403f, 0.02354612f, -0.01245766f, 0.00966681f, -0.03499549f, 0.01329110f, 0.01441412f, 0.00786181f, 
    0.01884464f, -0.01744774f, 0.00698103f, 0.02809493f, -0.03662353f, -0.01748129f, 0.01244266f, 0.00752085f, 
    0.00802648f, -0.01321452f, 0.02924507f, -0.01980564f, -0.01977308f, -0.01032971f, 0.00101045f, -0.02310371f, 
    0.00358502f, 0.00296255f, 0.02559345f, -0.00715197f, -0.00748662f, -0.01364291f, -0.01404712f, -0.02319314f, 
    0.02327359f, 0.02715905f, -0.02684029f, 0.00119800f, 0.00619382f, -0.02374865f, -0.01174092f, -0.02277960f, 
    0.02565108f, -0.02045441f, -0.02111426f, -0.03828615f, -0.03902152f, -0.03585372f, -0.02842817f, 0.02612151f, 
    0.02298324f, -0.03893403f, -0.01655675f, -0.03694131f, -0.02296900f, -0.02248207f, 0.01959919f, -0.03696254f, 
    0.01300395f, 0.02600564f, 0.02633114f, -0.02453521f, -0.03082387f, 0.01599815f, -0.03217623f, 0.02092742f, 
    0.02663786f, -0.03792099f, -0.03349452f, -0.00922777f, -0.01914137f, -0.00165847f, -0.02702145f, 0.02876252f, 
    -0.01704024f, 0.01208507f, 0.01516175f, 0.01039253f, -0.00124323f, 0.00349294f, -0.03582501f, -0.02206535f, 
    0.01905975f, -0.01891216f, -0.01649481f, -0.04033142f, -0.02025558f, -0.02934485f, -0.00569502f, -0.02236714f, 
    0.00128251f, 0.01971877f, -0.00936582f, -0.02444222f, -0.03660054f, -0.00096825f, 0.02654078f, 0.02385177f, 
    0.00454067f, -0.03034405f, -0.00748095f, -0.03188533f, -0.01769747f, 0.00827387f, 0.03396647f, -0.00156965f, 
    -0.03866306f, 0.01735856f, 0.01041101f, 0.00703673f, -0.00320629f, 0.01985434f, -0.00408111f, 0.02189549f, 
    -0.04181958f, -0.02819586f, -0.02519910f, 0.01221028f, -0.03753254f, -0.01000509f, -0.01397940f, -0.00474946f, 
    -0.02952697f, 0.01168229f, 0.00630419f, -0.00433896f, 0.00914206f, -0.02048118f, 0.00474402f, 0.01406533f, 
    0.01892705f, 0.02346284f, 0.01671696f, -0.02593799f, -0.02174927f, -0.03870255f, -0.03590771f, -0.03631802f, 
    -0.04207174f, 0.00117970f, -0.00312051f, 0.02282385f, -0.01848179f, 0.01621383f, -0.00072828f, 0.00826648f, 
    -0.02970533f, 0.02288614f, 0.01515637f, 0.02411604f, -0.02696689f, -0.03707588f, -0.01780353f, 0.02622542f, 
    -0.00590823f, -0.03294111f, -0.02267859f, -0.00924487f, 0.01890505f, -0.02697194f, -0.00887507f, 0.01294113f, 
    -0.03680860f, 0.02033918f, -0.00891127f, 0.00469771f, -0.01326279f, -0.00191047f, -0.03071082f, 0.00762132f, 
    -0.03103412f, 0.02597935f, 0.01695701f, -0.00924545f, -0.00416203f, -0.01925014f, -0.02738788f, 0.01842915f, 
    0.01808791f, -0.01980177f, 0.01137269f, -0.01836022f, 0.00974590f, -0.03002533f, -0.01170226f, 0.02199352f, 
    0.01658599f, -0.02175686f, 0.01046979f, 0.02367550f, 0.00869147f, -0.04099465f, -0.03164094f, -0.02236938f, 
    0.02288709f, 0.02796023f, -0.03365109f, 0.00574781f, -0.02908619f, -0.01965096f, -0.01429224f, 0.02989257f, 
    -0.00422746f, 0.01556322f, -0.03778708f, -0.01597209f, 0.00204047f, -0.03619269f, -0.00785144f, -0.03331311f, 
    0.02493691f, 0.02318754f, 0.01132422f, -0.02653939f, 0.02757445f, -0.02042095f, 0.00575976f, -0.03255675f, 
    -0.00752169f, -0.03655643f, 0.02107976f, -0.02226658f, 0.02138532f, -0.00472813f, -0.00522054f, -0.01912129f, 
    0.01754297f, 0.01155561f, -0.01116025f, 0.02715260f, -0.03411626f, -0.00420304f, 0.00260792f, 0.00403401f, 
    -0.00996687f, -0.00425269f, -0.02883799f, -0.00388497f, 0.00213104f, -0.03824079f, 0.02689187f, -0.02505944f, 
    0.02067627f, 0.01165118f, 0.02107551f, 0.01105606f, -0.00100276f, -0.00558691f, 0.02993322f, 0.02247369f, 
    0.02778410f, 0.00891359f, 0.00076670f, 0.01350683f, 0.02393867f, 0.01361239f, -0.00787341f, -0.02020010f, 
    0.00050774f, 0.00527742f, 0.02131936f, 0.02915568f, -0.02376056f, -0.01326752f, -0.01869758f, -0.03278582f, 
    -0.00584951f, -0.00756003f, -0.00525425f, -0.01592039f, 0.02058421f, -0.04073193f, 0.00573169f, 0.01174412f, 
    -0.00277091f, -0.01999733f, 0.02261011f, -0.01931700f, -0.02655714f, -0.00231562f, 0.01309475f, 0.01386698f, 
    -0.02407193f, -0.00091543f, 0.01501834f, 0.02687834f, -0.04155659f, -0.03712070f, -0.01436701f, -0.03272472f, 
    0.01936382f, 0.00092473f, 0.02031595f, 0.01776003f, 0.00701638f, -0.00029342f, -0.02837876f, 0.00178612f, 
    0.01166612f, -0.03224299f, -0.00128549f, 0.01203320f, -0.00869989f, -0.02670823f, -0.02677643f, -0.04192965f, 
    -0.00859612f, -0.03504252f, -0.03632322f, -0.01036010f, -0.02483723f, 0.00008086f, -0.00843915f, -0.00867497f, 
    -0.03710925f, 0.00558759f, -0.01629561f, 0.01970695f, -0.02721114f, -0.01827983f, -0.02179410f, 0.01243723f, 
    0.01018139f, 0.02737802f, -0.02850307f, -0.00982528f, -0.02301134f, -0.03085782f, -0.04114959f, 0.01406024f, 
    -0.00749847f, -0.03876135f, -0.00262108f, 0.03395651f, -0.00116555f, 0.02254648f, -0.00410931f, -0.02348793f, 
    0.00200511f, 0.02228998f, -0.03180836f, 0.02508557f, -0.01000836f, -0.03028208f, 0.02869522f, -0.00467627f, 
    -0.02732439f, 0.02446484f, -0.01242351f, -0.00389748f, -0.02351800f, 0.01311366f, 0.00911751f, -0.01484543f, 
    0.01728565f, 0.01777940f, 0.00366337f, 0.01731107f, 0.00963362f, -0.02750614f, -0.03172783f, 0.02665640f, 
    0.01490429f, 0.00013970f, -0.03498627f, 0.00095436f, 0.02019068f, 0.00758690f, 0.02408844f, -0.04103126f, 
    0.01653988f, -0.01510035f, -0.03328941f, -0.02855872f, -0.00054550f, -0.01600395f, 0.02631038f, -0.02223442f, 
    -0.00541900f, 0.02727417f, 0.00686115f, -0.01511240f, 0.02691254f, 0.02999230f, -0.01477927f, 0.02454766f, 
    -0.02680978f, -0.01194085f, -0.00408144f, 0.02557429f, -0.03124337f, -0.03048089f, 0.02812500f, -0.02390524f, 
    0.02799982f, -0.02205863f, -0.02161187f, -0.02283423f, -0.01473013f, -0.01419573f, -0.04063800f, -0.02672719f, 
    0.01897169f, -0.02556744f, 0.00787784f, -0.03766204f, 0.00820133f, 0.00371025f, -0.02605717f, -0.01354326f, 
    0.01173972f, -0.00314178f, 0.02183103f, -0.02695522f, 0.02660195f, -0.00730106f, -0.03417097f, -0.03540830f, 
    0.01513361f, 0.30532604f, -0.55505002f, 0.23988853f, -0.16466950f, -0.07953172f, -0.13310456f, -0.15323459f, 
    -0.13701709f, -0.00264869f, 0.07957326f, -0.14191230f, -0.02276726f, 0.06833758f, -0.42825013f, 0.20167756f, 
    -0.01626714f, -0.01006668f, -0.09377110f, 0.04550061f, -0.01718955f, 0.03774798f, 0.12731378f, -0.15463655f, 
    0.14979440f, 0.05343161f, 0.32669771f, -0.24192509f, 0.07670871f, -0.01524787f, 0.06325595f, -0.04637770f, 
    0.09860425f, 0.07160231f, 0.17504217f, 0.00475217f, 0.07040745f, 0.23085527f, -0.42304513f, -0.17847925f, 
    0.20793107f, 0.15483922f, 0.10834347f, 0.08286642f, -0.16982171f, 0.02339624f, 0.03059415f, 0.13795362f, 
    0.04169409f, 0.26612934f, 0.03832190f, 0.11984312f, 0.09982147f, 0.00984115f, -0.08670454f, -0.04632865f, 
    -0.12114477f, 0.00380598f, -0.08995418f, -0.04769152f, 0.18151484f, 0.34892809f, -0.44291437f, 0.22592880f, 
    0.06761245f, 0.15678480f, -0.11216821f, -0.02112808f, -0.05305104f, -0.04298641f, 0.09197865f, -0.12981711f, 
    0.02155057f, 0.04184162f, 0.04957070f, 0.04599475f, 0.04304900f, -0.00195776f, -0.01335637f, 0.09674095f, 
    -0.05535759f, -0.01429506f, 0.08500793f, 0.05790873f, -0.06952003f, 0.44984284f, 0.04844937f, 0.08197487f, 
    0.07159404f, 0.01202885f, 0.05048527f, -0.09269430f, -0.08790048f, -0.10232538f, -0.10674722f, 0.01309518f, 
    -0.22048171f, 0.02168049f, -0.03023782f, -0.04380372f, 0.02201829f, 0.05551104f, -0.02348603f, 0.04222371f, 
    0.14202322f, 0.04740020f, 0.12001801f, 0.15701002f, 0.28860429f, 0.18857476f, 0.04261803f, 0.06456161f, 
    0.14462185f, 0.06666347f, 0.00276461f, -0.04953886f, -0.09219714f, -0.02289767f, 0.01843696f, -0.03360130f, 
    0.11146325f, 0.17249204f, -0.26419598f, 0.06408373f, 0.01123423f, 0.00783886f, -0.04286132f, -0.02703002f, 
    -0.13932770f, -0.01271230f, 0.03535601f, -0.24791370f, 0.11522397f, 0.08438668f, -0.12907323f, 0.10828118f, 
    -0.06430468f, 0.06592669f, -0.00997886f, 0.05319884f, -0.05614311f, 0.01145669f, 0.00852752f, -0.05823447f, 
    0.04258224f, -0.20990933f, -0.05925170f, -0.04146624f, 0.04428137f, 0.02126043f, 0.05536105f, 0.11332279f, 
    0.01802011f, 0.06910974f, 0.02280912f, -0.05634401f, 0.17334768f, -0.15284300f, 0.02257240f, -0.10527568f, 
    0.09113868f, 0.07104973f, 0.05207406f, 0.08897434f, -0.00072878f, 0.06133670f, 0.06327764f, 0.04830550f, 
    -0.07237978f, 0.22516786f, -0.40951708f, 0.12593204f, -0.02677872f, 0.15949842f, 0.13166530f, 0.06158857f, 
    -0.13361882f, -0.02989296f, 0.11907452f, -0.07570425f, -0.03823730f, -0.11031175f, -0.16267851f, 0.17679317f, 
    0.04223134f, 0.02445934f, -0.04248108f, -0.15083511f, -0.00641361f, -0.12041858f, -0.10671674f, -0.06047700f, 
    -0.20008580f, -0.11454926f, -0.19203089f, -0.05804773f, 0.03033688f, -0.11562749f, -0.01817029f, -0.30895698f, 
    0.02367222f, 0.02821427f, -0.18250525f, 0.05863864f, -0.14793178f, 0.05132946f, -0.12325687f, 0.04796161f, 
    0.11622769f, 0.06040234f, -0.06585476f, 0.03070729f, -0.03251455f, -0.05234055f, -0.04592096f, 0.01131382f, 
    -0.06787838f, 0.12194633f, 0.21925285f, 0.00089830f, 0.00706983f, -0.11765576f, -0.04143080f, 0.11914538f, 
    0.04204218f, 0.02306321f, 0.11201725f, 0.13270333f, 0.36292872f, 0.22437571f, 0.09648590f, 0.03311497f, 
    0.14321536f, 0.11609776f, 0.07456080f, -0.04539067f, -0.00748216f, 0.01453181f, -0.01996988f, -0.01408157f, 
    0.43990365f, 0.22921576f, 0.24123803f, 0.09048077f, -0.00417988f, 0.05989345f, -0.08582221f, -0.00188285f, 
    0.00105881f, -0.06989243f, -0.01844837f, -0.10140845f, 0.14657328f, -0.45648578f, 0.29501653f, 0.10877437f, 
    -0.18279567f, -0.07780673f, -0.25405550f, 0.01887239f, 0.02917425f, 0.08128582f, 0.06782024f, -0.04208255f, 
    0.20661663f, -0.14649296f, 0.26629147f, -0.17841929f, -0.05908113f, 0.17094888f, -0.15271732f, 0.05305644f, 
    0.09432753f, 0.19534986f, -0.01326093f, 0.05454315f, 0.20297168f, 0.31272316f, 0.19693214f, 0.19642898f, 
    -0.04392396f, -0.39837816f, -0.17767386f, -0.08815488f, -0.07847565f, 0.07142949f, 0.01233667f, 0.06173988f, 
    -0.13324027f, -0.04630037f, 0.13518363f, 0.06859172f, -0.04284211f, 0.00012901f, 0.16652453f, -0.16765057f, 
    0.03638503f, 0.05604503f, 0.09824082f, 0.07516955f, 0.19320437f, 0.15328288f, 0.06879571f, -0.02532290f, 
    0.13344564f, 0.02695182f, -0.10390809f, 0.03139825f, -0.03447391f, -0.15221851f, -0.09927642f, -0.09176973f, 
    0.00035759f, 0.28810766f, 0.07204933f, 0.07766526f, -0.01675050f, 0.03198529f, 0.02087886f, -0.08408919f, 
    -0.11669755f, 0.10534142f, 0.05037030f, 0.11504457f, -0.25899336f, 0.21714579f, -0.34259331f, -0.10316912f, 
    0.13190244f, 0.10548028f, 0.09802855f, -0.04316773f, -0.06902938f, -0.03218062f, 0.05052767f, -0.07941844f, 
    0.08937921f, 0.20188093f, 0.29615948f, 0.04705510f, -0.03207947f, -0.12509941f, -0.24607132f, 0.07211602f, 
    -0.03642972f, 0.00125572f, -0.05782426f, 0.01761821f, -0.14495753f, 0.02664503f, 0.02641134f, -0.03920613f, 
    -0.06757691f, 0.05046194f, -0.05530126f, 0.03251945f, -0.00301807f, 0.01908675f, 0.06755408f, 0.08085006f, 
    -0.00645215f, -0.02027871f, -0.22172114f, 0.00744028f, -0.04418671f, 0.03969190f, 0.10275844f, -0.02589145f, 
    0.00003256f, 0.13259351f, -0.00152235f, -0.01013911f, -0.06433123f, 0.11795966f, 0.03457474f, -0.03123193f, 
    0.02384509f, 0.12161780f, 0.09506395f, 0.08276724f, -0.09138329f, -0.03373947f, 0.02810546f, 0.14070193f, 
    0.05554151f, -0.02847721f, 0.10718590f, 0.05899470f, -0.09464220f, -0.02711978f, 0.01388185f, -0.06275190f, 
    0.11715609f, 0.16985048f, 0.18840954f, 0.05169116f, 0.29866177f, 0.01966855f, 0.16554935f, 0.03393305f, 
    0.13796495f, 0.09591132f, 0.13183910f, 0.16477041f, 0.01485636f, 0.07885577f, -0.00442982f, 0.14536317f, 
    0.03886854f, 0.24509901f, 0.01768251f, -0.03335774f, 0.08786249f, 0.07842335f, -0.00155109f, 0.01643419f, 
    -0.05689749f, -0.10216748f, -0.07666291f, -0.15822019f, -0.27204525f, 0.00652195f, -0.21515407f, -0.08752852f, 
    0.13556969f, 0.02965566f, 0.06071729f, 0.05056028f, -0.17810611f, -0.04205329f, -0.07903877f, -0.08768498f, 
    0.15516460f, -0.57035291f, 0.20887847f, -0.00354876f, -0.15561086f, -0.03159049f, -0.16708706f, -0.23440731f, 
    0.02105288f, 0.08467609f, 0.04732731f, 0.12355959f, 0.18488766f, -0.01270339f, -0.15208864f, 0.21115433f, 
    -0.08161020f, -0.02552621f, -0.13322128f, -0.03444872f, -0.15624849f, 0.05484420f, -0.02471422f, 0.18807346f, 
    0.12130999f, -0.00541016f, 0.13563815f, 0.07628080f, 0.03366819f, 0.00784032f, 0.03302479f, 0.18403192f, 
    -0.00265815f, 0.00139157f, -0.04719393f, -0.03570254f, 0.13967468f, -0.09840749f, 0.16448157f, -0.09598324f, 
    -0.00709173f, 0.03518284f, -0.19220868f, -0.16889514f, -0.01590469f, 0.16914223f, 0.01358824f, 0.01132076f, 
    0.14739902f, 0.10629838f, 0.07503501f, 0.16241677f, -0.06053663f, 0.00219135f, 0.03968151f, 0.00434945f, 
    -0.04954178f, -0.00531554f, 0.08726936f, 0.08052316f, -0.10765253f, -0.15244871f, 0.00389168f, 0.05732298f, 
    0.08853655f, 0.05905435f, -0.02790954f, -0.05352435f, -0.04841551f, -0.04641849f, -0.03340043f, -0.03310778f, 
    0.20746282f, -0.07288823f, -0.01629648f, 0.06203736f, -0.07794665f, 0.00650328f, -0.01061025f, 0.09341559f, 
    0.05642549f, -0.01702113f, 0.06882150f, 0.08851479f, -0.02975106f, 0.12479397f, -0.23010324f, 0.06774846f, 
    0.07281522f, 0.08278716f, -0.04736847f, -0.04924351f, -0.09723499f, -0.00462592f, -0.02631867f, 0.06727766f, 
    0.01175722f, -0.03216014f, -0.07946330f, 0.12740816f, 0.04942463f, 0.03743609f, -0.07821222f, -0.00422619f, 
    0.03818619f, 0.15396105f, 0.00941702f, -0.00773997f, 0.11849818f, -0.22015323f, 0.27029783f, 0.01476858f, 
    -0.02328500f, -0.04269880f, -0.19783087f, -0.13917406f, -0.06849404f, -0.00387054f, 0.05704994f, -0.03304363f, 
    0.21639180f, 0.19878049f, 0.18562096f, -0.06462425f, 0.03047580f, 0.08585194f, -0.07167394f, -0.05313965f, 
    0.01251710f, -0.01495355f, 0.03725957f, -0.03510495f, 0.11856855f, 0.08989801f, 0.53802514f, 0.34749958f, 
    0.00371900f, -0.10204714f, -0.00798318f, -0.20992368f, -0.01539140f, -0.01940603f, -0.05199704f, 0.11406881f, 
    -0.16247065f, 0.31684226f, 0.28166738f, -0.09881042f, 0.17637859f, 0.04215832f, 0.17317681f, 0.03255417f, 
    0.14716943f, -0.09274217f, -0.22557075f, -0.02409018f, -0.12832394f, 0.36063433f, -0.31341591f, -0.16450104f, 
    0.05898063f, 0.09185135f, 0.17992409f, 0.04998372f, -0.06179255f, 0.12730026f, 0.08815107f, 0.08730309f, 
    0.21351524f, 0.24578074f, 0.06576746f, -0.00935413f, 0.04650707f, 0.08420802f, -0.03616492f, -0.11126234f, 
    -0.07394021f, 0.02567104f, 0.06759249f, 0.08994841f, 0.24659550f, 0.21653838f, 0.05427488f, 0.03324324f, 
    0.16318356f, 0.02142011f, 0.06716142f, 0.00534501f, -0.03399176f, 0.07995453f, -0.05582479f, 0.05986517f, 
    0.34644300f, 0.16755898f, 0.14996096f, 0.09715937f, 0.18038322f, 0.06570993f, 0.09558789f, 0.19489942f, 
    -0.01957775f, -0.04602801f, -0.12242031f, -0.05071484f, 0.17923661f, -0.01020360f, 0.16030221f, 0.05023671f, 
    -0.13804176f, -0.01143021f, 0.06859688f, 0.01160920f, -0.17390962f, 0.05624963f, 0.12751196f, 0.06630453f, 
    0.16130380f, 0.01004868f, -0.02921297f, 0.07293459f, 0.14904790f, -0.00232261f, 0.13044485f, 0.01449690f, 
    -0.04081386f, 0.09494758f, -0.00803185f, -0.09479506f, -0.13531101f, -0.14610417f, -0.16438764f, 0.09896968f, 
    0.01666275f, 0.03572927f, -0.10264329f, 0.00733535f, 0.07009023f, 0.03638349f, 0.14526053f, -0.08113156f, 
    0.06867258f, -0.17608310f, -0.10119593f, -0.01616050f, 0.05263441f, 0.06884868f, -0.10878737f, -0.05520076f, 
    -0.06618760f, -0.16554010f, 0.30145639f, -0.03763105f, 0.11234141f, -0.09740593f, -0.21197563f, 0.13821597f, 
    -0.16146088f, 0.12265261f, -0.13273451f, 0.09071450f, -0.14169364f, 0.18283691f, -0.03710768f, -0.16748615f, 
    0.19264032f, 0.17593680f, 0.17594090f, -0.00821372f, 0.25642592f, 0.18810055f, 0.08895034f, 0.06501789f, 
    -0.01041062f, -0.06223377f, -0.02375241f, -0.14110018f, -0.13615078f, -0.25279444f, 0.04884896f, 0.07180260f, 
    -0.02846392f, 0.05449843f, -0.17348546f, 0.00584519f, 0.15746512f, 0.04202716f, 0.20360486f, 0.24513166f, 
    0.09418952f, -0.31754661f, 0.01385266f, 0.11175350f, -0.15446299f, -0.01451548f, -0.23927002f, 0.08492475f, 
    -0.00304529f, -0.00916956f, 0.05030702f, -0.14976352f, 0.00712569f, -0.21945356f, 0.15454204f, 0.01992367f, 
    -0.03875686f, -0.00524784f, -0.07793352f, -0.06199218f, -0.14642873f, 0.04373702f, 0.04183604f, 0.04160984f, 
    0.05391812f, -0.03747617f, 0.03021127f, -0.14207874f, -0.12586260f, -0.02753285f, -0.02145863f, 0.03151427f, 
    0.00179244f, -0.04321031f, -0.01247946f, 0.00480642f, -0.05259009f, 0.06542470f, -0.20480013f, 0.23452903f, 
    0.04754977f, 0.04751280f, -0.00832072f, -0.03503027f, -0.00768561f, 0.12562346f, -0.10372233f, 0.18017460f, 
    0.01418195f, -0.02704004f, 0.01899212f, 0.00506660f, 0.00502737f, -0.03690794f, -0.02527039f, -0.03708609f, 
    0.00677855f, -0.02529591f, -0.00842711f, -0.00642879f, 0.00258778f, -0.00322103f, 0.01213759f, -0.02473806f, 
    0.01270713f, 0.01935262f, -0.03873895f, 0.00247910f, 0.00379469f, 0.02283980f, -0.02803592f, 0.00411989f, 
    0.02484225f, 0.01544847f, -0.00216077f, -0.02284252f, -0.03180327f, 0.02635112f, -0.03079881f, -0.04035553f, 
    0.00253874f, -0.02785524f, -0.02496986f, 0.00422210f, 0.02802848f, -0.04371559f, -0.01690475f, -0.02725202f, 
    0.01502034f, -0.00935502f, -0.03996500f, 0.01111192f, -0.01343412f, 0.02508783f, 0.01424169f, 0.02771591f, 
    0.01496391f, -0.03755021f, 0.01790841f, -0.00391343f, 0.02577057f, -0.00690278f, 0.02690627f, -0.03569106f, 
    -0.03631814f, 0.01195229f, -0.00501956f, -0.00751680f, -0.02431010f, -0.03937939f, 0.00487236f, -0.01014143f, 
    0.00167286f, -0.03422795f, -0.02353360f, 0.02070439f, -0.02017648f, -0.02741938f, -0.03616991f, 0.01973309f, 
    -0.01351895f, -0.04115497f, -0.01434049f, 0.00277597f, 0.00301004f, 0.00540194f, -0.02112683f, -0.02496897f, 
    0.01286271f, -0.01084075f, -0.01328069f, 0.00383211f, 0.01599720f, -0.04362157f, -0.03528373f, 0.02574847f, 
    -0.02452295f, -0.02679750f, -0.03986774f, -0.02032571f, -0.02047505f, -0.00158721f, -0.03883284f, 0.00813604f, 
    -0.02853720f, -0.02172736f, 0.01286611f, -0.02585338f, 0.00783429f, -0.01514652f, -0.04244095f, -0.01861110f, 
    -0.03048420f, -0.01205785f, 0.01778184f, -0.01059156f, -0.02685585f, -0.03311674f, -0.03343770f, -0.01546875f, 
    -0.00543591f, 0.01024386f, -0.01539930f, 0.02014736f, -0.02814004f, -0.02238056f, -0.02522747f, -0.02219381f, 
    0.00709127f, 0.01201001f, 0.01146535f, -0.01624296f, 0.02101674f, 0.01877687f, 0.00661127f, -0.01559812f, 
    -0.00908964f, -0.02152370f, -0.02859046f, 0.01936718f, -0.00753016f, 0.02717923f, -0.01143366f, -0.03625067f, 
    0.00534711f, -0.00678849f, 0.00902726f, 0.01598367f, 0.01130354f, 0.01719334f, 0.01662409f, 0.00661594f, 
    0.00815194f, -0.01328944f, -0.02608241f, -0.02905119f, -0.00381171f, 0.00907197f, 0.00783882f, -0.00216272f, 
    0.01194059f, -0.00050593f, -0.01737597f, 0.00743460f, -0.03251913f, 0.00677014f, -0.03177703f, -0.00972079f, 
    0.02801566f, -0.03388391f, -0.01111712f, -0.02439534f, 0.01110674f, -0.00917035f, -0.01545317f, 0.01509063f, 
    0.00057088f, 0.01196161f, 0.01112477f, 0.02180293f, 0.01469144f, -0.04340016f, -0.00803266f, -0.04134965f, 
    0.00088062f, -0.02324812f, 0.02749738f, 0.01479560f, 0.00184610f, 0.02109725f, -0.00495782f, -0.00073323f, 
    0.00948099f, -0.00438307f, -0.00701907f, -0.03131301f, -0.01509414f, 0.00619281f, 0.00905196f, -0.02195412f, 
    -0.01888690f, -0.01580617f, -0.02346512f, -0.04311055f, 0.01883891f, 0.02462260f, -0.00051693f, 0.00470838f, 
    -0.00728087f, -0.01600517f, -0.03666878f, -0.03747208f, -0.03435230f, -0.02220667f, -0.02322047f, -0.03911411f, 
    0.01539239f, -0.02243291f, -0.00174337f, -0.00011515f, -0.04057018f, -0.03723555f, -0.00519476f, -0.04025485f, 
    -0.00105312f, 0.00457293f, -0.03479996f, 0.00307873f, -0.02428513f, -0.02924341f, -0.01990558f, 0.01013002f, 
    0.01917323f, 0.02837190f, 0.02084871f, -0.03620527f, -0.00992401f, 0.00213173f, -0.03751381f, 0.00444001f, 
    0.02440908f, 0.00432816f, -0.00964735f, -0.03653523f, 0.00603642f, -0.03072871f, -0.02492133f, 0.00878360f, 
    -0.03174010f, -0.02590198f, -0.03222129f, -0.02583291f, -0.02639294f, 0.00102581f, -0.01549602f, -0.01834013f, 
    0.00487719f, -0.01780995f, -0.01567889f, 0.01611861f, -0.00103311f, 0.00288225f, 0.00449264f, 0.02622673f, 
    -0.01874799f, 0.02749638f, -0.02853682f, -0.03047531f, -0.03028010f, 0.01252043f, -0.00538859f, -0.03443133f, 
    0.01508113f, 0.00788149f, -0.02122411f, 0.02921057f, -0.04048902f, 0.01695153f, 0.01940034f, 0.00384368f, 
    -0.01166007f, -0.00494615f, 0.02432714f, -0.02416372f, -0.01383070f, 0.00171705f, -0.02566926f, -0.03871178f, 
    -0.03993163f, -0.00120364f, -0.00778031f, 0.02184886f, -0.03242225f, 0.02825285f, -0.04386550f, -0.00788634f, 
    0.00350127f, -0.01066561f, -0.00590458f, -0.00950668f, -0.02349073f, 0.01192485f, -0.00934777f, 0.01570303f, 
    -0.02368953f, -0.01334105f, 0.01888117f, -0.02935169f, -0.02068228f, 0.01326752f, 0.03044994f, 0.00719970f, 
    -0.03715533f, 0.02762136f, -0.00844625f, -0.03654996f, 0.01462000f, -0.02878891f, 0.02427430f, -0.03979558f, 
    0.01763863f, -0.00061463f, -0.03314970f, -0.00419735f, -0.00409585f, -0.03981496f, -0.01567294f, -0.00955438f, 
    -0.00363941f, -0.02780845f, 0.02742003f, -0.02230503f, 0.00836363f, -0.04035950f, -0.01537012f, 0.00159877f, 
    -0.01542740f, 0.00149448f, -0.02029632f, 0.01771507f, -0.03090577f, -0.01176097f, -0.00516565f, -0.00188954f, 
    -0.03739437f, 0.01930135f, -0.03570667f, 0.01846331f, 0.00306566f, -0.00873912f, -0.04048142f, 0.01567251f, 
    -0.03080939f, -0.03975704f, 0.00605337f, 0.02226299f, -0.01432418f, -0.02877385f, 0.00905086f, -0.00195298f, 
    0.01457458f, 0.00155266f, 0.01079364f, -0.02169502f, 0.00144750f, 0.01220606f, 0.01922310f, -0.03848816f, 
    0.02223016f, 0.01390651f, 0.00448358f, -0.01111743f, -0.00281458f, -0.00712229f, -0.00839875f, 0.01719218f, 
    -0.00185342f, -0.00803678f, -0.02933117f, 0.01966859f, -0.02534884f, -0.02484252f, 0.02649222f, 0.02310006f, 
    -0.03097018f, -0.02074626f, -0.02800880f, -0.00159054f, 0.00356665f, -0.03790960f, -0.03147100f, -0.01531279f, 
    -0.02583482f, -0.00733575f, -0.02511946f, 0.02287414f, -0.00180615f, -0.03784284f, 0.01300908f, 0.00154601f, 
    -0.01174952f, -0.00719020f, 0.02065793f, -0.01107308f, -0.03411518f, -0.03840756f, 0.01277687f, 0.01480223f, 
    -0.01752763f, 0.00256628f, -0.00378005f, -0.01070405f, -0.00695892f, -0.01680386f, -0.00084958f, 0.01632672f, 
    -0.03239456f, -0.00677773f, -0.02171578f, -0.03063062f, -0.04153801f, -0.04149441f, -0.00541954f, 0.01317392f, 
    0.02546017f, -0.01975398f, -0.02154567f, -0.02632845f, 0.01486165f, -0.00218229f, 0.02129511f, -0.02710868f, 
    -0.01082731f, -0.00921156f, -0.03546020f, 0.01718967f, -0.03371589f, 0.02227241f, -0.01280750f, -0.04179214f, 
    0.00987150f, -0.00289531f, 0.02719428f, -0.00931030f, -0.01902764f, 0.02170081f, -0.01426212f, -0.01257493f, 
    -0.01990697f, -0.01719864f, -0.04021284f, 0.00134507f, 0.02085995f, -0.01716663f, 0.00861925f, -0.04405639f, 
    0.00377398f, -0.02217820f, -0.04200588f, -0.00862951f, -0.00398534f, 0.02619857f, -0.00798600f, 0.00341894f, 
    -0.01253334f, -0.03242889f, -0.00462831f, -0.02916907f, 0.02254976f, 0.01032266f, 0.01043752f, 0.00685017f, 
    0.01347061f, -0.00200884f, -0.00975059f, -0.01057885f, -0.01159765f, -0.03284898f, 0.01831898f, -0.03989113f, 
    -0.01789361f, -0.04158456f, 0.02264037f, -0.03523816f, -0.02932617f, -0.02949794f, -0.03058098f, -0.00028184f, 
    0.02599744f, 0.02784138f, 0.00809240f, -0.04086884f, -0.01524077f, 0.00029614f, 0.00800976f, 0.01808779f, 
    -0.02113000f, -0.02912427f, -0.04030874f, 0.00524870f, -0.01990838f, 0.00370190f, -0.01997514f, -0.02061311f, 
    -0.02853605f, -0.01688588f, -0.03157384f, -0.01210701f, -0.03779987f, 0.01893893f, -0.00893913f, -0.03316386f, 
    -0.00048426f, 0.00929960f, 0.00132536f, 0.02125561f, -0.02168743f, -0.00759722f, 0.00168402f, 0.02950712f, 
    0.01574281f, 0.01173521f, -0.02333563f, 0.02589155f, -0.03609607f, 0.02722709f, -0.03051981f, 0.01863283f, 
    -0.00953293f, 0.01260697f, -0.02460007f, -0.01220761f, -0.03571739f, -0.02424152f, 0.02558740f, -0.01919640f, 
    -0.01779618f, 0.01664087f, 0.00333065f, 0.01951116f, 0.02446146f, -0.01243622f, 0.02583401f, 0.01445409f, 
    -0.01014710f, 0.00540720f, 0.00963723f, -0.00967201f, 0.00941522f, -0.03806578f, -0.00510199f, -0.03031040f, 
    0.01841515f, -0.01012812f, -0.00547889f, -0.00664360f, 0.00259831f, -0.00100228f, -0.02547042f, 0.01605141f, 
    -0.00738176f, 0.01451960f, -0.02285292f, -0.01179948f, -0.02510408f, -0.02290899f, -0.00391865f, 0.00676287f, 
    0.01738765f, -0.01485333f, -0.02779989f, 0.02806083f, -0.03941791f, -0.00247302f, 0.01253776f, -0.00996549f, 
    -0.01429919f, -0.03753961f, -0.03314310f, -0.01643834f, 0.00880684f, 0.01033264f, -0.00948221f, -0.02974727f, 
    -0.01548679f, -0.03353889f, -0.01117973f, -0.02532096f, -0.03202035f, -0.02674655f, 0.00407335f, -0.00470984f, 
    -0.00157493f, 0.01224993f, 0.02548711f, 0.00300912f, 0.00348409f, -0.02665180f, 0.01860369f, -0.00699632f, 
    -0.01470736f, -0.01892707f, 0.01907297f, -0.02653086f, -0.02960390f, 0.00378874f, -0.03076060f, 0.00064439f, 
    -0.00694673f, 0.02710212f, 0.01804054f, 0.01015873f, -0.01185419f, -0.03990593f, 0.01421460f, -0.03846016f, 
    0.00179132f, -0.01878165f, -0.01006239f, -0.03694901f, -0.00173185f, 0.01605483f, 0.02449649f, 0.00683179f, 
    0.02846080f, -0.02995097f, -0.00523521f, 0.01661658f, 0.02757818f, 0.02460785f, -0.01768325f, -0.00906856f, 
    -0.00604361f, -0.00512257f, 0.00882650f, 0.02331999f, -0.02038425f, -0.03725154f, 0.02492840f, 0.00263959f, 
    -0.00211146f, 0.02953568f, -0.00871056f, 0.00149679f, 0.01570372f, -0.04140131f, 0.01765050f, -0.01825197f, 
    -0.03217066f, -0.02539906f, -0.01643717f, -0.02043413f, -0.03767348f, -0.00890647f, -0.03233084f, -0.00611663f, 
    0.03155905f, -0.01402998f, -0.02732770f, -0.02890993f, -0.00238584f, -0.00436890f, -0.01798559f, 0.00865859f, 
    0.00698212f, 0.00435317f, -0.01388140f, 0.01652003f, 0.00787691f, -0.00564024f, -0.03702963f, -0.02567564f, 
    0.01365873f, 0.00386277f, 0.01554172f, 0.02476393f, 0.02516521f, -0.02554942f, -0.01517377f, 0.00100669f, 
    0.02229974f, -0.00258515f, 0.01633016f, -0.01679889f, -0.00013075f, -0.03683940f, 0.02742501f, -0.04338750f, 
    -0.04253381f, -0.01547023f, -0.03180145f, 0.00600589f, 0.01914835f, 0.01276902f, -0.02007512f, -0.00807512f, 
    -0.02330824f, 0.02293102f, 0.00174898f, -0.02115186f, -0.01478938f, 0.01171029f, -0.01465131f, 0.00856595f, 
    -0.04187118f, 0.01405823f, 0.01858575f, -0.03798221f, -0.01558871f, -0.02533920f, -0.00512792f, -0.01887138f, 
    0.01701264f, 0.02555526f, -0.00192792f, 0.02753576f, -0.01341154f, 0.00053590f, -0.02181460f, 0.00130414f, 
    0.01523064f, 0.00935304f, -0.01434753f, -0.03077848f, -0.04305790f, 0.00932328f, 0.00029726f, -0.00227802f, 
    -0.01185367f, -0.03129259f, 0.02808969f, -0.01880452f, -0.01646085f, 0.01720868f, 0.01191182f, -0.00066234f, 
    0.02356778f, -0.01632958f, 0.02557837f, -0.00725516f, -0.02579303f, -0.02045218f, 0.02260525f, 0.00385403f, 
    0.01031981f, 0.00603903f, 0.00100209f, -0.02579585f, -0.03609261f, -0.02780923f, 0.02857448f, 0.02805912f, 
    -0.02475344f, 0.02302589f, 0.01166138f, -0.03731371f, -0.02939795f, 0.00301490f, -0.02560802f, 0.00452639f, 
    0.00066784f, 0.01872742f, 0.01018134f, 0.01026999f, -0.02359595f, -0.02977457f, -0.00741941f, 0.02383836f, 
    0.00724030f, 0.00076908f, -0.03743235f, -0.00389156f, 0.02025406f, -0.04255611f, 0.01991001f, 0.02221985f, 
    -0.02738444f, -0.00350792f, 0.00117200f, -0.02500376f, 0.00840460f, 0.03634695f, 0.03154232f, -0.04114245f, 
    0.01657878f, 0.00406761f, -0.00407000f, 0.01479860f, -0.00647689f, -0.03027632f, 0.03291236f, -0.00116930f, 
    0.02103957f, -0.02728662f, -0.01065965f, 0.00468192f, 0.00016386f, 0.00265072f, 0.00275673f, 0.00695803f, 
    -0.01722208f, -0.02015875f, 0.01410311f, 0.03011142f, -0.02941225f, -0.00322885f, 0.01968679f, -0.03657183f, 
    -0.00881900f, -0.02959467f, -0.00939238f, 0.01738653f, 0.00883466f, -0.00254586f, -0.00424293f, -0.00043053f, 
    -0.01966288f, -0.02092230f, -0.00766843f, -0.03260287f, 0.02480719f, -0.02563290f, -0.00279780f, -0.02940268f, 
    0.01180116f, -0.01637359f, 0.01366247f, -0.02644350f, -0.03283697f, 0.02530231f, -0.00666711f, -0.03892843f, 
    0.01780058f, 0.02064140f, -0.03607349f, -0.03692621f, 0.01153701f, -0.00222158f, 0.02132418f, 0.00265580f, 
    -0.02536834f, -0.03619122f, 0.00069613f, -0.01282181f, 0.01194913f, -0.00594167f, -0.00479744f, 0.02442054f, 
    0.02605765f, -0.02155779f, -0.03379659f, -0.03280213f, -0.02069722f, -0.02787233f, 0.03263165f, -0.02283850f, 
    0.02344643f, -0.00167308f, -0.04418654f, 0.00416405f, 0.02930831f, -0.02530754f, -0.03603915f, -0.00956409f, 
    -0.01091315f, 0.00996338f, 0.01399420f, -0.03076387f, 0.01657582f, -0.02888389f, 0.00819783f, 0.00836760f, 
    0.01340968f, 0.00790393f, -0.01437783f, 0.02975674f, -0.03225297f, 0.01260471f, -0.00532379f, -0.00682495f, 
    0.01426189f, -0.03599223f, -0.02792764f, -0.01113045f, -0.03255720f, 0.00459752f, 0.01530535f, -0.01198496f, 
    0.00634445f, -0.00730272f, 0.00999514f, 0.02244843f, 0.01006042f, -0.00919785f, 0.01347704f, 0.02147235f, 
    -0.01350604f, 0.01896038f, 0.01449714f, -0.03580466f, -0.03486395f, -0.02807877f, -0.03393127f, -0.02014483f, 
    -0.00413389f, -0.01162713f, -0.02217912f, -0.04252558f, 0.01657831f, 0.03677193f, -0.03629258f, -0.03084891f, 
    -0.03427536f, -0.00670931f, -0.00919428f, -0.00104865f, 0.01182193f, 0.01519070f, 0.00625943f, -0.03124555f, 
    -0.02931471f, 0.01103617f, 0.01193976f, -0.01935023f, -0.03490750f, -0.00820391f, 0.01876985f, -0.02853252f, 
    -0.02642822f, -0.01319633f, -0.02291104f, 0.01929058f, 0.00550694f, -0.01211092f, -0.02318313f, 0.01001211f, 
    0.02792758f, -0.01140056f, -0.03347893f, -0.03399584f, 0.01206164f, 0.00481727f, -0.00504531f, -0.00212911f, 
    -0.02960581f, -0.01454982f, -0.03804288f, -0.01706171f, -0.01497167f, 0.02215731f, 0.01369599f, -0.00967827f, 
    -0.00560373f, -0.01344011f, 0.03333185f, 0.02725172f, 0.00964621f, -0.02432279f, -0.01979733f, 0.00322922f, 
    -0.00551181f, 0.01928597f, -0.03911731f, 0.01932656f, 0.01266124f, -0.00596533f, -0.01649869f, 0.00636200f, 
    -0.01104062f, -0.01816604f, -0.04149212f, -0.00697182f, 0.02707695f, -0.03242777f, -0.00770902f, -0.02936091f, 
    -0.00558494f, 0.01542640f, 0.00487513f, 0.01342490f, -0.02011100f, 0.00824610f, -0.00942898f, 0.00774743f, 
    -0.02733972f, 0.00828686f, 0.00905840f, 0.02039402f, 0.00570839f, -0.02151359f, 0.01673860f, -0.02129608f, 
    0.02087384f, -0.02254615f, -0.00750645f, -0.01465775f, -0.03498474f, 0.03007687f, 0.02300311f, 0.00971735f, 
    0.02375312f, -0.01337845f, 0.00342735f, 0.02199952f, -0.01686779f, 0.01395034f, -0.01512361f, 0.02605009f, 
    -0.02994532f, 0.02382602f, 0.00110654f, 0.00412211f, 0.02801999f, -0.01751725f, 0.00632472f, 0.02279120f, 
    -0.02886841f, -0.00283271f, 0.01026351f, -0.03182498f, -0.04089862f, -0.01808227f, -0.00247997f, 0.02757704f, 
    -0.01021149f, 0.00090835f, -0.00883403f, -0.02118930f, 0.01856429f, -0.00494400f, -0.01347511f, 0.03914781f, 
    0.01369872f, -0.04009307f, -0.00558676f, 0.00412023f, -0.03909576f, 0.00182820f, -0.02408774f, 0.02729175f, 
    0.01954305f, 0.00875979f, -0.02128581f, -0.02797362f, -0.00741524f, 0.02281279f, 0.01064798f, -0.02784450f, 
    -0.02021246f, -0.02780169f, -0.00015167f, 0.00364216f, -0.02751123f, 0.00000485f, 0.00151883f, -0.02011132f, 
    -0.01106611f, -0.00798958f, 0.02324988f, 0.02906135f, 0.02359563f, 0.00343827f, -0.00186578f, 0.01544533f, 
    -0.02069916f, 0.02514591f, -0.02630853f, -0.00031859f, 0.02671277f, -0.00900189f, -0.01464667f, -0.01196844f, 
    -0.00077170f, -0.00240832f, -0.01341083f, 0.02636782f, -0.00632759f, -0.01205692f, -0.03254564f, -0.00115168f, 
    -0.02731478f, 0.00196256f, 0.00347490f, -0.00894440f, -0.03402775f, -0.02766598f, 0.00597741f, -0.03473630f, 
    -0.02233094f, 0.02234704f, -0.02057812f, 0.01522974f, -0.02896851f, 0.00407151f, 0.00573510f, 0.02701860f, 
    0.02771533f, -0.01560439f, -0.00840484f, 0.00445272f, 0.01460795f, -0.03041497f, -0.02866410f, -0.03134992f, 
    0.02489613f, 0.01815502f, 0.02717754f, 0.01706521f, -0.03454547f, 0.00858502f, -0.01959504f, -0.02340525f, 
    0.01522978f, -0.03360958f, 0.00743081f, -0.02943274f, 0.00380840f, -0.03911509f, 0.00950026f, 0.02612367f, 
    -0.02230246f, -0.02946942f, -0.00347414f, -0.00943006f, -0.01081570f, 0.03792701f, -0.02502168f, 0.02470799f, 
    0.01503938f, -0.02584761f, 0.00978192f, -0.03614797f, 0.00171979f, -0.02784418f, -0.03099450f, 0.02254853f, 
    -0.02257783f, 0.02121962f, 0.00867087f, 0.00600678f, -0.03743647f, 0.01174055f, 0.01680100f, 0.00420197f, 
    -0.02759110f, -0.01286723f, 0.03135952f, -0.02351564f, 0.00553335f, -0.02277892f, -0.02361558f, 0.02221901f, 
    -0.00108664f, -0.03374138f, 0.00330159f, -0.01262964f, -0.02599395f, -0.00429868f, -0.03844838f, -0.02378230f, 
    -0.01194068f, 0.01596386f, 0.03158051f, 0.00577932f, -0.00509378f, 0.01647282f, 0.00893082f, -0.00048864f, 
    -0.00080540f, 0.01786753f, 0.01405575f, -0.00964099f, -0.01344211f, -0.00643578f, 0.02571855f, -0.03039744f, 
    -0.03791671f, -0.00876719f, -0.03557394f, -0.02556541f, -0.03769214f, 0.01966804f, -0.01603922f, -0.01610651f, 
    -0.02754644f, -0.02323858f, 0.02712710f, -0.02764489f, -0.02917999f, -0.00837120f, -0.03664812f, -0.02307281f, 
    -0.00248319f, 0.01587716f, -0.03397489f, 0.01500893f, -0.00145092f, -0.00066494f, 0.01213203f, 0.01626125f, 
    0.02790221f, 0.02072647f, -0.02852019f, -0.00116048f, -0.02884010f, 0.00651801f, -0.02577702f, -0.01826323f, 
    -0.01578388f, 0.02167755f, -0.02047631f, -0.02492425f, -0.02147667f, -0.01018365f, -0.03312587f, -0.03568959f, 
    -0.04319743f, 0.00280857f, -0.00811369f, -0.01960068f, -0.02742518f, 0.01983150f, 0.01439694f, -0.01736883f, 
    -0.00793595f, -0.03016777f, -0.01411504f, -0.02334046f, 0.03157502f, -0.02391197f, -0.04030141f, 0.01478307f, 
    -0.03996790f, -0.03338977f, -0.01381836f, 0.02682789f, -0.03521492f, 0.00300192f, 0.03197302f, -0.01581902f, 
    -0.02965217f, -0.02045339f, 0.00464944f, -0.01255436f, -0.01940114f, 0.01025461f, -0.02241423f, -0.02990607f, 
    0.01593996f, -0.02911627f, 0.00552533f, 0.01908815f, 0.02327652f, -0.02347072f, -0.01305450f, 0.02211924f, 
    0.01533816f, -0.01657718f, -0.02803498f, -0.03327638f, -0.00071490f, -0.00330409f, 0.02610050f, -0.01337019f, 
    -0.01922656f, -0.03320345f, -0.03152725f, -0.01493466f, -0.00973543f, -0.02334262f, 0.02437437f, 0.00513490f, 
    -0.03219838f, 0.01622886f, 0.02480552f, 0.01913993f, 0.00950311f, -0.02891541f, -0.02194365f, -0.02871558f, 
    0.00879809f, -0.00797478f, 0.01127168f, 0.00839987f, -0.02591651f, 0.00601944f, 0.00490125f, -0.02357814f, 
    0.02079179f, 0.03044480f, -0.03279294f, -0.01560661f, 0.00641688f, -0.00444602f, 0.00732416f, -0.03047881f, 
    0.02393273f, -0.00457008f, -0.00817418f, -0.00181841f, 0.01754417f, 0.02459489f, -0.03175933f, 0.02733932f, 
    -0.01759270f, -0.03851151f, -0.02294088f, -0.03299714f, -0.03058163f, -0.02763609f, -0.03085306f, -0.00415477f, 
    -0.00016577f, 0.02303944f, -0.02130869f, -0.03012902f, 0.02229998f, -0.02099825f, -0.00426701f, -0.00546591f, 
    -0.01296280f, 0.02177931f, -0.02748777f, 0.01216081f, -0.00747088f, -0.01094128f, 0.00678576f, 0.00967322f, 
    -0.03607284f, -0.02487061f, 0.00748810f, 0.02887138f, 0.00404326f, -0.00971588f, 0.01164796f, 0.00955093f, 
    0.00222201f, 0.02183076f, 0.00936956f, -0.02820072f, 0.00175697f, -0.03212659f, 0.00788381f, 0.02049925f, 
    -0.01739789f, 0.00600788f, -0.02815236f, -0.01290179f, 0.03089911f, -0.02036855f, 0.02470976f, -0.04090817f, 
    -0.04327504f, -0.02162834f, 0.00067703f, 0.00764701f, -0.03631947f, 0.02476785f, 0.01655196f, 0.02372106f, 
    -0.01102874f, -0.00652869f, -0.01634459f, -0.00274457f, 0.01533073f, -0.01126527f, -0.00359562f, 0.01300202f, 
    -0.02526482f, 0.00424053f, 0.00218546f, -0.01685925f, -0.00299527f, -0.03088822f, 0.03355097f, -0.02657394f, 
    0.02321236f, -0.02510663f, -0.00215268f, -0.03079427f, 0.02843715f, -0.01923570f, 0.02457905f, 0.00493811f, 
    -0.01912049f, -0.00485331f, -0.01775113f, -0.00681950f, 0.00642213f, 0.02634002f, -0.00603712f, 0.01950386f, 
    0.01809569f, -0.00594292f, 0.02804290f, 0.00396507f, -0.00589950f, -0.02595544f, 0.02388488f, -0.00492309f, 
    0.02336586f, 0.00021769f, 0.00469369f, -0.02874123f, -0.02445069f, 0.01055725f, 0.01930297f, 0.01153253f, 
    -0.03562054f, 0.00554281f, 0.03153773f, -0.03423074f, -0.02720436f, -0.03610526f, 0.02278316f, 0.00990552f, 
    -0.02553497f, 0.01236838f, 0.00249033f, 0.02246415f, 0.01883159f, 0.01139818f, -0.02813446f, -0.00173887f, 
    -0.03593647f, 0.00838105f, 0.00751308f, 0.02678887f, 0.00644810f, -0.01901152f, -0.01597308f, -0.00345357f, 
    -0.03079069f, 0.00474958f, 0.00096146f, 0.02059476f, 0.02947276f, 0.01274202f, -0.01120050f, -0.03750151f, 
    -0.02684357f, -0.00593548f, -0.00866403f, -0.01842828f, 0.02078225f, -0.01524763f, 0.00949339f, -0.00986608f, 
    0.02372171f, -0.03417280f, -0.00653250f, -0.02575914f, -0.01663760f, -0.00238163f, -0.02563168f, -0.02274965f, 
    -0.02522282f, 0.01089889f, 0.03546951f, 0.01422056f, 0.00044593f, -0.01730512f, -0.00543290f, 0.02307151f, 
    -0.02671054f, -0.02370526f, 0.00744082f, 0.00832528f, 0.00780004f, -0.01763276f, 0.01741083f, 0.02356305f, 
    -0.03304651f, -0.02033442f, -0.00512334f, -0.00947025f, -0.01688958f, -0.00035660f, 0.01641665f, -0.00014513f, 
    0.02859985f, -0.04060595f, 0.00953082f, -0.04339492f, -0.01320947f, 0.00142749f, 0.02856556f, 0.01237099f, 
    0.02968298f, -0.00649640f, 0.00396181f, -0.00017726f, 0.00320245f, -0.00676236f, 0.00782019f, -0.03325768f, 
    -0.01040988f, -0.02517195f, 0.00377847f, 0.02543529f, -0.01971202f, -0.00768192f, 0.03304453f, -0.02255872f, 
    0.00800955f, -0.02035370f, -0.00445020f, 0.01865213f, -0.00387592f, 0.03331616f, 0.03046393f, -0.00146026f, 
    -0.01215016f, -0.04146037f, -0.04077341f, -0.01258104f, -0.01607951f, 0.02934640f, 0.01521846f, -0.01033333f, 
    -0.01014747f, 0.01302083f, 0.01683674f, -0.00228741f, -0.00301173f, -0.03766691f, -0.03565351f, -0.02741937f, 
    -0.01141934f, -0.03511857f, -0.01866108f, -0.01284000f, -0.04057476f, -0.00048215f, 0.00805966f, -0.02293285f, 
    -0.02497423f, 0.01380744f, 0.02178088f, 0.00879825f, -0.00124734f, 0.00641136f, -0.01086677f, 0.02120011f, 
    -0.13291365f, -0.08582145f, 0.01544166f, 0.07967275f, 0.04091317f, 0.11166033f, -0.06629305f, -0.01569811f, 
    0.05818728f, 0.01117324f, 0.01962519f, -0.03117015f, -0.05263583f, 0.09451936f, -0.08277406f, -0.00831244f, 
    -0.01837999f, 0.01086880f, -0.03140962f, 0.00511165f, -0.05575882f, 0.14076693f, 0.10205416f, 0.24438053f, 
    0.42044029f, 0.00674790f, -0.02960342f, -0.11608861f, -0.04807410f, -0.18276212f, 0.11683566f, 0.00794200f, 
    -0.00291616f, 0.02130350f, 0.18361591f, -0.02884786f, -0.29002401f, 0.49258402f, 0.14193824f, 0.02120962f, 
    0.03302924f, 0.08025185f, -0.19932039f, -0.01831098f, -0.21297589f, -0.15565039f, 0.03128913f, 0.17077023f, 
    0.02009981f, 0.09333061f, -0.02667332f, 0.29859668f, -0.10601454f, -0.08473106f, -0.08927120f, -0.05702850f, 
    0.10769566f, 0.05628885f, -0.00391873f, 0.04341037f, 0.22237231f, -0.24910174f, 0.01142681f, -0.22510388f, 
    -0.01146441f, -0.11870538f, 0.04138206f, -0.02907388f, -0.01936993f, -0.00905954f, 0.02936398f, 0.06099213f, 
    -0.14751561f, 0.06520411f, -0.04157143f, 0.22251786f, 0.00380014f, -0.00798374f, 0.06522175f, 0.15940383f, 
    -0.00750072f, -0.07916107f, -0.00863921f, -0.06533584f, 0.05630501f, 0.18746981f, -0.04196183f, 0.11273757f, 
    -0.12723401f, -0.18501201f, -0.11124121f, -0.07516737f, -0.03211806f, 0.05416685f, 0.12864543f, 0.26540217f, 
    -0.11961705f, -0.08951461f, -0.08981725f, -0.10362699f, -0.06546894f, 0.04057482f, -0.03501888f, -0.06419009f, 
    0.07957281f, 0.14284128f, 0.05234018f, 0.05491361f, 0.06192395f, -0.12872432f, 0.04919794f, 0.13466871f, 
    -0.01383566f, -0.04975175f, 0.06214335f, 0.03254008f, 0.01846134f, 0.01803590f, 0.05202013f, 0.07289217f, 
    -0.09132008f, -0.03416273f, -0.05012817f, -0.03236209f, 0.09905732f, 0.10354347f, -0.04795917f, 0.00331171f, 
    -0.02138625f, 0.08524912f, 0.05030761f, 0.24857551f, -0.06734069f, -0.03259766f, -0.03623688f, 0.16340497f, 
    0.00599345f, 0.08840637f, -0.06988093f, -0.06458513f, 0.03067400f, 0.05941278f, -0.09620784f, 0.05054071f, 
    -0.21330537f, -0.02257073f, 0.13922693f, 0.12203432f, 0.01217304f, -0.07976885f, 0.09063093f, -0.01924514f, 
    0.07442872f, -0.01348897f, -0.04398954f, 0.07179613f, -0.31089902f, -0.15728858f, -0.10752203f, -0.08304091f, 
    0.07123034f, -0.11363074f, -0.00106424f, 0.15305632f, -0.06825770f, -0.01476039f, 0.08189460f, -0.08450279f, 
    0.02222281f, 0.08407616f, -0.20207162f, 0.12293612f, 0.06018080f, -0.05770811f, -0.06126593f, 0.01970208f, 
    -0.04273630f, 0.00906256f, 0.04712478f, 0.03207957f, -0.11176747f, 0.28093854f, 0.21657564f, 0.05876859f, 
    -0.01823458f, -0.00781121f, -0.04293164f, 0.07760651f, 0.04935246f, 0.13767536f, 0.00776834f, -0.02020061f, 
    -0.37470031f, 0.15921263f, 0.08764951f, 0.11190568f, -0.00963804f, -0.01091574f, 0.06303378f, 0.03100603f, 
    0.05450067f, 0.05614719f, 0.05340182f, 0.06120843f, -0.00086176f, 0.02890347f, 0.11071552f, -0.03917916f, 
    0.07481736f, 0.10015360f, 0.05457744f, -0.00838352f, -0.01718129f, 0.04622555f, 0.09228881f, -0.03134853f, 
    -0.06452743f, -0.11833161f, -0.20869075f, -0.03530151f, 0.01672250f, -0.06197745f, 0.09291457f, 0.03504797f, 
    0.01067666f, 0.01597297f, -0.03906405f, -0.13410467f, -0.09446344f, 0.06590158f, 0.06116464f, 0.07025111f, 
    0.07406527f, -0.03266149f, 0.05269567f, 0.04696956f, -0.16216199f, -0.06206754f, -0.01597036f, -0.07637866f, 
    0.04884965f, -0.00796768f, 0.08251023f, 0.16811030f, -0.04360234f, -0.14097251f, -0.04743675f, 0.00211399f, 
    -0.03079897f, -0.01014692f, -0.00882658f, 0.04063594f, 0.11795517f, -0.01094868f, -0.32106942f, 0.10417679f, 
    -0.13720207f, 0.00711745f, 0.04628367f, 0.11744136f, -0.02429701f, 0.09075963f, 0.02633597f, -0.03985883f, 
    0.41817623f, -0.09671838f, 0.05885702f, 0.06810238f, 0.14772676f, 0.01670470f, -0.00374057f, 0.05064693f, 
    0.16495967f, -0.00367610f, 0.04457788f, -0.01715031f, 0.23784971f, -0.05926232f, 0.32554924f, 0.26546204f, 
    0.04398387f, 0.15164931f, -0.02879982f, -0.06434266f, 0.04641099f, -0.09372242f, -0.05328604f, -0.01052641f, 
    -0.10646217f, -0.00265305f, 0.17111397f, 0.34343657f, 0.05312696f, 0.27605557f, 0.04081304f, -0.08911660f, 
    -0.01603764f, -0.05419438f, -0.18065162f, -0.14478257f, 0.01392753f, -0.08173318f, -0.03236480f, -0.08645993f, 
    0.23385848f, 0.19212188f, 0.00444226f, 0.11000927f, 0.12492654f, 0.01911534f, 0.08674074f, 0.08453143f, 
    -0.68333149f, 0.31457019f, -0.06600790f, 0.06884513f, -0.03532697f, 0.13711062f, -0.02039458f, 0.06047149f, 
    -0.02662079f, -0.23756337f, 0.05445382f, -0.05102669f, -0.21044229f, -0.08128329f, -0.00850233f, 0.24653001f, 
    0.00027975f, 0.01243578f, 0.05971665f, -0.01950308f, -0.04670106f, 0.05816542f, 0.04123490f, 0.13501409f, 
    0.23489797f, 0.00006273f, -0.20306198f, 0.17633964f, -0.06007984f, -0.07009897f, 0.17138900f, -0.02141213f, 
    -0.01466564f, 0.10186199f, -0.04220295f, 0.07409521f, -0.08044148f, -0.06726244f, 0.14651214f, 0.03924233f, 
    -0.10802411f, 0.02171599f, -0.05750090f, 0.03813625f, 0.02211876f, -0.05756436f, -0.05199117f, -0.00948871f, 
    0.11522027f, 0.12633486f, 0.00322373f, -0.04498768f, 0.05065241f, 0.02901752f, -0.05295519f, 0.01374935f, 
    0.07903054f, -0.04608742f, -0.12395433f, 0.05662379f, -0.08419439f, -0.06816921f, -0.25382477f, -0.06526697f, 
    0.10527729f, -0.10099634f, -0.04154199f, -0.06132739f, -0.14978427f, 0.00084785f, 0.07403304f, 0.16989429f, 
    0.01739265f, -0.03223747f, 0.12327431f, 0.00948558f, -0.03483200f, 0.10680816f, -0.08243603f, 0.06462085f, 
    -0.00430843f, -0.03441949f, 0.13574049f, 0.04567169f, 0.08869132f, -0.16434959f, -0.00578241f, 0.11324330f, 
    -0.07541122f, -0.23206376f, 0.00139366f, 0.02582736f, 0.02700108f, -0.01156491f, 0.00719472f, -0.00048070f, 
    0.04434190f, 0.16835983f, -0.23607627f, 0.12724775f, -0.00647863f, 0.05195599f, -0.06049116f, 0.09905110f, 
    0.01311891f, 0.05810473f, 0.08640242f, 0.22162977f, -0.18666604f, -0.13482237f, -0.07392875f, 0.03790704f, 
    0.05038650f, -0.03839266f, -0.06625457f, 0.04524679f, 0.06352539f, 0.05124806f, 0.12928048f, 0.04269410f, 
    -0.08018420f, 0.24927588f, 0.20721497f, 0.12793081f, 0.09479862f, 0.02359936f, -0.07255263f, -0.01153481f, 
    0.00215586f, 0.14675041f, 0.04403643f, -0.02467556f, -0.02428634f, 0.08740945f, 0.07034995f, 0.03878196f, 
    0.00732919f, 0.00990574f, -0.10820286f, -0.00200983f, 0.07993183f, -0.06291135f, 0.06437324f, -0.00784095f, 
    -0.02024973f, -0.05896867f, 0.04154797f, 0.06275331f, -0.09923381f, 0.00229538f, 0.02125611f, 0.02542465f, 
    0.02483326f, 0.11344215f, 0.01725269f, -0.00003839f, -0.17791522f, -0.09842758f, 0.32753235f, 0.24165946f, 
    0.05062467f, -0.00573092f, 0.18777215f, 0.17690976f, -0.00790452f, -0.02864351f, 0.06446341f, -0.02306651f, 
    -0.13761216f, 0.02004211f, 0.00908124f, 0.09469891f, -0.00368343f, 0.15444492f, 0.01099285f, 0.06389414f, 
    0.13166341f, 0.11315631f, 0.13444518f, 0.03775090f, -0.16584666f, 0.05369712f, 0.22094634f, 0.19826637f, 
    0.20620517f, 0.11096412f, 0.03423223f, 0.13074146f, 0.03085305f, -0.02381592f, 0.01048321f, -0.01182759f, 
    -0.05665619f, -0.05450943f, 0.05185409f, 0.08108550f, 0.01313261f, 0.03751327f, 0.02682706f, -0.01162518f, 
    0.06726299f, 0.06306341f, 0.01795261f, -0.00485839f, 0.02571609f, -0.01097561f, 0.27577034f, 0.00551672f, 
    0.08124871f, 0.04908993f, -0.04632556f, 0.16381799f, 0.03832112f, 0.07438126f, 0.03179166f, 0.11290924f, 
    -0.16065426f, -0.05711532f, 0.03598135f, 0.04034707f, 0.14856036f, 0.03747373f, 0.08915127f, 0.00834835f, 
    0.03794784f, 0.11708880f, 0.09501055f, 0.11029963f, -0.07227066f, 0.02767030f, 0.14761889f, 0.19022028f, 
    -0.00541028f, -0.09469957f, -0.09174797f, -0.03054112f, 0.19572292f, -0.02170877f, 0.11186779f, -0.00749672f, 
    -0.15984301f, -0.15035547f, -0.09039877f, 0.05573790f, 0.22696202f, -0.09461087f, 0.08605784f, -0.18225953f, 
    -0.22924227f, 0.00522756f, -0.02473014f, 0.06556173f, 0.27277157f, 0.07035089f, -0.21311297f, 0.17032227f, 
    0.14673957f, -0.05669461f, 0.07599216f, -0.04688298f, 0.00459621f, -0.05123982f, 0.06042920f, 0.07228182f, 
    0.07340816f, -0.04424219f, -0.08264330f, -0.09437095f, 0.06009917f, 0.01897931f, -0.10830999f, 0.14686871f, 
    0.00393082f, -0.13105986f, -0.01988539f, 0.07923447f, -0.18177643f, 0.63010997f, 0.02776689f, -0.25845745f, 
    -0.07183036f, 0.07588208f, -0.20107512f, -0.00454049f, -0.11879197f, -0.14439185f, -0.22740524f, -0.03314356f, 
    0.11092197f, -0.07490986f, 0.05606698f, 0.10091893f, -0.01066913f, 0.06169512f, -0.11583243f, 0.05471639f, 
    -0.06715408f, -0.13943657f, 0.01036888f, 0.03263383f, -0.13603863f, -0.05822580f, 0.04273793f, 0.16528858f, 
    -0.07985656f, -0.04708998f, -0.01930664f, -0.05741535f, -0.02949100f, -0.08453148f, 0.03212664f, 0.06544265f, 
    -0.01998071f, -0.07175917f, 0.09914608f, 0.02789067f, 0.03231918f, -0.01861548f, 0.04203133f, 0.20203736f, 
    -0.09506204f, -0.01663781f, -0.07762624f, -0.03464738f, 0.03481326f, -0.14951201f, 0.22070768f, 0.12398780f, 
    0.14203456f, 0.16102113f, 0.10625485f, -0.01107057f, -0.14684689f, -0.10387114f, 0.02837646f, 0.06047875f, 
    -0.03817740f, -0.16767266f, 0.09638110f, 0.03594996f, 0.00186254f, 0.04005597f, 0.06580269f, 0.11110200f, 
    0.05212419f, -0.12346287f, 0.06288698f, -0.05296463f, -0.15984677f, -0.03250376f, 0.04248505f, -0.04724945f, 
    -0.00617205f, -0.00751934f, -0.00043617f, -0.05545739f, 0.05614164f, 0.21225096f, 0.09693305f, 0.16165605f, 
    0.09635956f, 0.00136947f, -0.00003016f, 0.04337034f, 0.00294226f, -0.07999721f, -0.05502534f, -0.04545090f, 
    -0.04380317f, 0.04499969f, 0.01477039f, 0.06771341f, 0.08443551f, 0.04865929f, 0.15589437f, -0.02441365f, 
    -0.00836156f, 0.04731648f, 0.00099653f, -0.00685303f, 0.07917764f, 0.18192592f, -0.08549054f, 0.31880307f, 
    -0.11625076f, -0.14608091f, 0.02246218f, 0.07116914f, -0.01489734f, 0.02027986f, -0.04761558f, 0.05574078f, 
    0.02842169f, 0.01740215f, 0.10616469f, 0.08635618f, 0.04341425f, 0.10705503f, -0.08550298f, 0.00314755f, 
    0.00037795f, 0.04581095f, 0.01704535f, 0.08650077f, 0.13064097f, -0.01064797f, -0.22824855f, -0.23768148f, 
    -0.02979737f, -0.16236906f, 0.07799305f, 0.08626048f, 0.17005059f, 0.01694037f, -0.09427202f, 0.19270411f, 
    0.02373045f, -0.08982929f, 0.17699413f, -0.02751313f, 0.04038487f, 0.44948551f, 0.21767084f, -0.04211602f, 
    0.08447454f, -0.09962618f, -0.02111433f, -0.05972563f, -0.08265133f, -0.18708645f, -0.05195179f, 0.10584580f, 
    0.14017949f, 0.21747883f, 0.03990243f, 0.04810166f, 0.04962577f, -0.04887956f, -0.08165854f, 0.14197378f, 
    0.20009530f, 0.09346718f, -0.09159820f, 0.07334007f, -0.32252532f, -0.07237819f, -0.12909636f, -0.00305151f, 
    0.00305121f, -0.01108479f, -0.07460946f, 0.10873291f, -0.05107111f, -0.00825204f, -0.11055341f, -0.05942616f, 
    -0.01767091f, 0.01316858f, 0.02689757f, 0.02838267f, 0.02384824f, -0.00101340f, 0.01615964f, -0.03912324f, 
    0.00248907f, -0.03580339f, -0.00986726f, 0.01928061f, 0.00769339f, -0.02049631f, 0.01132686f, 0.00726177f, 
    -0.00781162f, -0.01750013f, 0.01608937f, -0.00336295f, -0.01248989f, -0.01176785f, 0.01232787f, 0.00200999f, 
    0.02753071f, -0.04138411f, -0.03297509f, 0.02348742f, 0.00279456f, 0.01674396f, -0.01026999f, -0.04169715f, 
    -0.02062794f, -0.02960414f, 0.01096373f, -0.03749852f, 0.02680064f, -0.01663354f, -0.00764918f, 0.01402246f, 
    -0.03523448f, 0.01050245f, -0.02597377f, -0.02763960f, -0.03003888f, 0.01643096f, -0.01992133f, 0.02887483f, 
    -0.02948233f, -0.02005259f, -0.01166605f, 0.01495013f, -0.02215355f, 0.01381519f, -0.03718477f, -0.02109643f, 
    -0.00617061f, -0.00227097f, -0.02792790f, 0.01624838f, -0.01555859f, -0.04228567f, 0.02420076f, -0.00543412f, 
    0.00275083f, 0.01303371f, -0.01127604f, 0.02637834f, -0.04150366f, -0.03320456f, 0.02695959f, -0.01393324f, 
    -0.04149974f, 0.00213451f, 0.02416329f, -0.00869634f, -0.03092607f, -0.03329531f, 0.00613957f, 0.02399465f, 
    0.01707465f, 0.00541146f, 0.00297392f, -0.03291360f, -0.01732103f, -0.02678907f, 0.01848603f, -0.01207554f, 
    0.02248423f, 0.01839643f, -0.01736971f, -0.02380784f, 0.02592683f, 0.01729506f, -0.03296593f, 0.03294688f, 
    -0.00264478f, -0.02678613f, 0.00510872f, -0.00497521f, -0.01476451f, 0.00644081f, -0.01011022f, 0.02130954f, 
    -0.03645239f, -0.02989336f, 0.02455986f, 0.02146737f, -0.00413914f, -0.03138100f, -0.00235619f, -0.02677207f, 
    0.02895280f, -0.02413051f, 0.02922561f, -0.03425856f, -0.01498021f, 0.01494335f, 0.01538379f, -0.03383807f, 
    -0.00884552f, -0.03690718f, -0.04285863f, -0.03027191f, 0.02778408f, -0.02709090f, 0.02117225f, -0.03420419f, 
    -0.03798858f, -0.02050665f, -0.00977188f, 0.00590617f, -0.03078947f, -0.00146732f, -0.03213182f, -0.03002481f, 
    -0.03009627f, -0.00099242f, 0.00603333f, 0.00027524f, -0.04165573f, 0.01580884f, -0.03342627f, -0.01968692f, 
    0.02652488f, -0.03744809f, 0.00414613f, -0.02542196f, -0.04177397f, 0.02446097f, 0.00128663f, -0.00315996f, 
    -0.01107303f, 0.01766334f, -0.02847326f, -0.00706234f, -0.02289532f, 0.02417110f, -0.01916362f, -0.03442575f, 
    -0.01106020f, -0.01975137f, -0.00464556f, 0.02499056f, -0.03902994f, 0.00769407f, 0.00626038f, -0.03809553f, 
    0.00250393f, -0.00909626f, 0.00356038f, 0.02604613f, -0.04186866f, 0.01275839f, -0.04363440f, -0.00586118f, 
    0.00999455f, 0.02622639f, -0.00195519f, -0.01344961f, -0.00054849f, -0.04630502f, 0.01239416f, -0.02258532f, 
    -0.03659288f, 0.00791748f, -0.04214934f, -0.01633251f, 0.02784050f, -0.00699981f, -0.01523883f, -0.02729122f, 
    -0.01288478f, 0.00488360f, 0.00901938f, 0.01448977f, 0.01404156f, 0.01816216f, 0.00636692f, 0.03050003f, 
    -0.00925184f, 0.02938354f, 0.00215103f, 0.02973243f, 0.01703084f, -0.02769595f, -0.03149921f, -0.02631404f, 
    -0.02726781f, -0.00243435f, 0.01252676f, 0.00940247f, 0.01870305f, 0.00099897f, -0.03815841f, 0.02220182f, 
    0.02508982f, 0.02282880f, 0.01696993f, 0.01489863f, 0.00264419f, -0.01999549f, -0.00142985f, -0.02088654f, 
    -0.03449249f, 0.00988875f, -0.02108414f, -0.00241334f, 0.01145550f, -0.03026690f, -0.01248033f, 0.01556208f, 
    0.01282453f, -0.00724216f, 0.00747801f, 0.02285695f, -0.00561463f, 0.02922452f, -0.01642505f, 0.01722075f, 
    -0.04090285f, 0.01277089f, -0.02368176f, 0.01964748f, -0.01863747f, 0.01748629f, 0.01081443f, -0.00207310f, 
    -0.03707388f, 0.02305981f, -0.04108380f, -0.00470437f, -0.01575761f, -0.02397904f, -0.02857509f, -0.02665354f, 
    -0.01582170f, 0.00773150f, 0.02058509f, -0.01579016f, 0.01695039f, -0.03591064f, -0.02047536f, 0.01269979f, 
    0.00658591f, -0.00430040f, 0.01059176f, -0.02593558f, -0.01160871f, -0.02546000f, -0.02732096f, -0.01363310f, 
    -0.01908276f, -0.02516464f, 0.00305243f, -0.00796843f, 0.01205394f, 0.03267402f, -0.00168016f, 0.02104370f, 
    -0.01461710f, 0.00204268f, -0.02501424f, -0.03686624f, 0.00145174f, 0.01703479f, -0.01362970f, 0.01817161f, 
    -0.04207379f, 0.01076533f, -0.00669804f, -0.03677247f, -0.01622838f, -0.03068482f, 0.02353761f, 0.00511070f, 
    0.01500006f, 0.00192573f, 0.01782884f, 0.02265332f, -0.03594561f, 0.00406107f, 0.03079000f, -0.02546279f, 
    0.01894458f, -0.00420202f, 0.00621833f, 0.00211005f, -0.00880658f, -0.03151242f, 0.02414931f, 0.01283116f, 
    -0.00379188f, 0.01539550f, -0.01327696f, 0.02669907f, 0.00259361f, 0.01282312f, 0.00645005f, -0.02407954f, 
    0.02545250f, 0.00353194f, 0.01926946f, -0.02914013f, -0.03533634f, 0.02455628f, 0.01743692f, -0.02307586f, 
    0.02595791f, 0.01654775f, -0.01470659f, 0.00338781f, -0.01830063f, 0.01399148f, 0.00446392f, -0.00568025f, 
    0.01994907f, 0.01665299f, -0.01783570f, 0.01532862f, -0.03328850f, -0.00089512f, -0.02621307f, -0.01940890f, 
    -0.00117206f, 0.01192545f, -0.04088302f, -0.02264367f, 0.00539374f, 0.02885417f, -0.01183329f, 0.00429312f, 
    -0.00413667f, -0.00427580f, -0.03614060f, 0.00682257f, -0.01567131f, -0.03278069f, -0.01479072f, -0.02957563f, 
    -0.01518916f, 0.03180396f, 0.01126750f, 0.00869793f, -0.02580791f, -0.03278938f, 0.02564277f, 0.03057510f, 
    -0.00432815f, 0.02775193f, -0.02290152f, 0.00944503f, 0.00155394f, 0.02358395f, 0.00249373f, 0.01785853f, 
    -0.00478405f, -0.00517960f, 0.02039962f, 0.00288321f, -0.00118706f, -0.03013078f, -0.00465619f, -0.02140636f, 
    0.00989723f, 0.02594232f, 0.01845467f, -0.01468405f, -0.01134573f, 0.01628544f, -0.03389733f, 0.01140906f, 
    -0.02264385f, 0.02124741f, -0.01431591f, 0.02293418f, -0.02810682f, -0.04178591f, -0.01606845f, -0.00005008f, 
    0.00734682f, 0.02206899f, -0.01576982f, -0.04343706f, -0.03246738f, -0.00125310f, -0.00468839f, 0.00616137f, 
    0.00052804f, 0.01922468f, 0.02502181f, -0.00625832f, 0.01061809f, -0.03908885f, -0.03828177f, 0.01234915f, 
    0.02531077f, -0.00113155f, -0.01223372f, 0.01402385f, -0.01022561f, -0.00265588f, 0.02196518f, -0.00298935f, 
    -0.04057022f, -0.00153215f, -0.00607686f, -0.00111023f, -0.02813816f, 0.02030353f, -0.00101854f, 0.02172430f, 
    0.02109945f, -0.01965458f, 0.02248797f, -0.02911300f, 0.01044900f, -0.01479797f, 0.01071553f, 0.01018576f, 
    -0.00848190f, -0.03764566f, -0.01726622f, 0.01311120f, 0.00749058f, -0.00953521f, 0.01002142f, -0.00965266f, 
    0.02180709f, 0.00295087f, 0.00827080f, 0.00998335f, 0.01488115f, -0.01301670f, 0.01852412f, -0.00814098f, 
    0.01271012f, 0.02642618f, -0.00480894f, -0.02196354f, 0.00965593f, 0.00134550f, -0.04097272f, -0.03063362f, 
    -0.01468615f, -0.02835078f, 0.01706310f, -0.02631272f, 0.01928806f, -0.03791338f, -0.03201334f, 0.00551487f, 
    -0.03456554f, -0.00054986f, 0.02602211f, -0.03001911f, 0.00852619f, -0.03045681f, -0.00223369f, -0.01178726f, 
    -0.04163699f, 0.01907663f, -0.01952243f, -0.00235149f, -0.01955438f, -0.02154528f, 0.02698134f, -0.01989176f, 
    -0.00136885f, 0.00921090f, 0.02778026f, -0.02849182f, -0.02577443f, 0.00599747f, -0.01824955f, -0.03200974f, 
    -0.03800743f, -0.00052954f, -0.03577567f, 0.02313328f, 0.02613320f, -0.02902953f, 0.01899900f, 0.00342192f, 
    -0.02638814f, -0.01666686f, -0.01031654f, 0.01011889f, 0.02779225f, -0.00525343f, 0.02119466f, 0.01166049f, 
    0.01892358f, -0.02394024f, -0.03984726f, -0.00856743f, -0.01462606f, -0.00555054f, -0.03472268f, -0.03977905f, 
    -0.02465617f, -0.00854024f, 0.00604500f, -0.01780995f, -0.03628466f, -0.01404367f, 0.01562955f, -0.00198254f, 
    0.00677235f, 0.02445070f, -0.02543619f, 0.02356889f, -0.02570551f, -0.02700999f, 0.00852371f, 0.00599747f, 
    -0.03574304f, 0.00990595f, -0.03506812f, -0.03081749f, -0.02201457f, 0.01730970f, 0.01473900f, -0.03924707f, 
    0.00908758f, 0.02084192f, 0.03157220f, -0.03697721f, -0.03634753f, -0.00662546f, 0.01496842f, -0.01771943f, 
    -0.03637487f, -0.01957041f, -0.00290436f, -0.03104092f, -0.03065051f, 0.01522521f, -0.02607250f, -0.02947791f, 
    0.02917083f, -0.03327450f, 0.01633303f, -0.02180644f, -0.02032353f, -0.00038572f, -0.04121320f, -0.02543228f, 
    0.03296901f, -0.02324968f, 0.00164851f, 0.00598549f, -0.01478637f, -0.00573440f, -0.02816080f, 0.00498288f, 
    -0.01946894f, -0.01607007f, 0.02122218f, -0.02571980f, -0.02771052f, 0.00355757f, -0.03474272f, 0.02621385f, 
    -0.01526487f, -0.00208177f, 0.02110664f, 0.01420800f, -0.01660405f, -0.02484675f, -0.00697197f, -0.01338366f, 
    -0.00186865f, -0.01933086f, -0.00978828f, -0.00385987f, -0.02506431f, 0.01069223f, -0.02406418f, 0.02385743f, 
    -0.00359610f, -0.03409040f, 0.02124012f, -0.02020840f, -0.02690279f, -0.01282167f, -0.02409367f, -0.00796681f, 
    -0.00739131f, 0.02633005f, -0.01958610f, -0.04099859f, -0.01395958f, 0.01264909f, -0.00204354f, -0.00847272f, 
    0.00061350f, -0.03318509f, -0.01631485f, 0.00554168f, -0.02955852f, 0.00262901f, -0.03116778f, 0.00091135f, 
    -0.04199583f, -0.01890536f, -0.00574922f, 0.01776301f, -0.00601243f, 0.00079737f, -0.01131953f, 0.03210219f, 
    0.01634938f, -0.02525309f, -0.03928652f, 0.00658705f, 0.02509488f, -0.01284411f, -0.01949773f, -0.03030489f, 
    -0.01371946f, -0.02804871f, 0.01126265f, 0.01295875f, 0.02684459f, -0.00910010f, 0.01833313f, 0.01352580f, 
    0.01230111f, -0.04094774f, 0.01765193f, -0.03857243f, 0.00106881f, -0.01991461f, 0.00185914f, 0.00042565f, 
    -0.00464937f, -0.00273905f, -0.01916265f, 0.01696511f, 0.01194620f, -0.02064233f, -0.02323441f, 0.00607900f, 
    -0.03785724f, -0.01363287f, -0.01862689f, 0.00329286f, -0.02111406f, -0.01694406f, -0.00781202f, 0.01423033f, 
    -0.02685412f, -0.04374469f, -0.03401332f, -0.03220040f, 0.02319618f, -0.00655554f, 0.00436474f, -0.02122285f, 
    -0.03175160f, -0.01143556f, -0.01953224f, 0.02289776f, 0.00148009f, 0.00822831f, -0.01550907f, -0.01091546f, 
    -0.03186528f, 0.01106509f, -0.02110297f, -0.03687358f, 0.00497450f, -0.03746879f, 0.00170425f, 0.01511640f, 
    0.01037585f, -0.02893761f, -0.02456644f, -0.04033516f, -0.01010793f, 0.02763661f, 0.01560288f, -0.02777084f, 
    0.02446761f, -0.00685068f, -0.04365567f, -0.00330802f, 0.00756855f, 0.00678753f, 0.03719897f, -0.02377463f, 
    -0.04085294f, 0.00193516f, 0.01263715f, -0.02762314f, 0.00002614f, 0.03359219f, -0.00471298f, -0.04061992f, 
    0.02263060f, -0.01797933f, 0.01460327f, -0.00180806f, 0.01056694f, -0.01973488f, 0.00000235f, 0.00290650f, 
    -0.01619492f, 0.00566575f, 0.01358536f, -0.01005844f, -0.01899119f, 0.03014225f, -0.00590086f, -0.02869321f, 
    -0.03713953f, 0.01885829f, -0.02378872f, -0.03433101f, -0.00816476f, -0.03747996f, 0.01692399f, -0.02693412f, 
    -0.01680517f, -0.00423612f, 0.01907227f, 0.01196193f, -0.02142084f, 0.02188096f, -0.00253566f, -0.00371891f, 
    -0.00392735f, -0.00141199f, 0.02918488f, 0.01887379f, 0.01228184f, 0.02135687f, -0.03360784f, 0.02053597f, 
    -0.00838947f, -0.02920236f, 0.02429227f, -0.03276215f, 0.00873777f, 0.02157745f, 0.03930956f, 0.02007229f, 
    -0.22628318f, -0.00644663f, 0.20690307f, 0.20207098f, 0.01245266f, 0.04490940f, 0.04733845f, 0.10030147f, 
    -0.04417095f, 0.06456964f, 0.03095411f, 0.04595595f, -0.02165931f, 0.19930892f, 0.05393910f, -0.00119496f, 
    -0.03424948f, 0.03424139f, 0.00264071f, -0.03691712f, 0.11150230f, 0.02390592f, 0.18410413f, 0.08915064f, 
    0.36653215f, -0.01393718f, 0.18629594f, -0.11942671f, -0.06860349f, 0.06861147f, 0.10431620f, 0.19178662f, 
    0.10340787f, 0.05642818f, 0.18608169f, 0.09593294f, 0.17613567f, 0.32652992f, -0.13582747f, -0.05518760f, 
    0.29668871f, 0.09814715f, 0.07874253f, 0.04649384f, -0.02982975f, 0.01657697f, 0.02309226f, 0.01747854f, 
    0.02343113f, 0.13116638f, -0.09933924f, 0.15815152f, 0.07642089f, -0.02772123f, -0.01136847f, -0.03127828f, 
    0.05511748f, 0.00178059f, 0.04212543f, -0.06323314f, 0.35966504f, 0.09790345f, 0.36647916f, 0.46891445f, 
    -0.15591720f, -0.10437199f, 0.11198579f, 0.08230657f, 0.08198897f, 0.06283219f, 0.15981762f, 0.02646441f, 
    -0.24602219f, -0.13510138f, -0.11200120f, 0.09964723f, 0.09080327f, 0.14612629f, 0.06084711f, 0.08009291f, 
    0.07157148f, 0.13869381f, 0.01666547f, 0.03170737f, -0.02721612f, 0.08236542f, -0.18401554f, -0.14003691f, 
    0.05494145f, -0.03076427f, 0.01496736f, -0.08567435f, 0.06558727f, 0.01054811f, 0.06960406f, 0.08910332f, 
    0.01596926f, 0.08837628f, 0.00212173f, -0.17073940f, -0.07577345f, -0.06253132f, 0.03103355f, -0.03385310f, 
    -0.17757551f, 0.12175603f, -0.00910829f, -0.02896587f, 0.07670095f, -0.15574010f, -0.03997305f, -0.05626056f, 
    0.03170844f, 0.05624950f, 0.06882516f, 0.14613019f, 0.02239328f, 0.00485361f, 0.05333378f, 0.01946509f, 
    -0.11352221f, -0.02535517f, 0.01370002f, -0.08146361f, 0.00446568f, -0.02157267f, 0.06416124f, -0.06538839f, 
    -0.08458044f, 0.13155247f, 0.23349877f, 0.09050380f, -0.07081597f, 0.10184838f, 0.11422987f, -0.10573678f, 
    -0.11329918f, -0.02996302f, -0.02449517f, -0.03493919f, -0.01382562f, 0.07935224f, -0.01692992f, 0.00987840f, 
    0.02651790f, -0.08231007f, 0.02494675f, -0.01353513f, -0.00857158f, 0.05447253f, 0.01064705f, 0.07861058f, 
    -0.02477033f, 0.13781235f, -0.03363255f, 0.10437315f, -0.01454188f, -0.19487347f, -0.14896744f, -0.16471259f, 
    -0.01999793f, 0.06888308f, -0.00851517f, -0.07386359f, 0.02784543f, 0.06184943f, 0.00695193f, -0.05977529f, 
    -0.20849931f, 0.19403651f, -0.02029077f, 0.26303354f, -0.09082350f, -0.03183518f, -0.07001977f, 0.03425779f, 
    0.05570940f, 0.24916375f, 0.12832525f, 0.04321459f, -0.36706400f, 0.10100672f, -0.02484472f, -0.05700425f, 
    -0.05384327f, 0.00920065f, 0.03126172f, 0.04289044f, -0.10107271f, 0.17091179f, 0.07221813f, 0.14751393f, 
    -0.13065362f, -0.02535571f, 0.09878724f, 0.04669009f, 0.03543661f, -0.03375966f, 0.23236732f, 0.02642109f, 
    0.13459890f, 0.00375248f, 0.04962018f, 0.07372656f, -0.07132797f, -0.03952822f, -0.10083239f, -0.03818244f, 
    0.13525514f, 0.15854451f, 0.22098963f, 0.16364342f, -0.05089301f, 0.01595992f, 0.10816219f, -0.00384073f, 
    0.03595670f, -0.04247674f, -0.11741167f, -0.13105331f, 0.01947459f, 0.07749083f, 0.10480935f, 0.05431476f, 
    -0.00836787f, 0.16501833f, -0.12765171f, -0.11608463f, -0.11396216f, -0.23524940f, -0.08460157f, 0.07867385f, 
    0.04090511f, 0.08133977f, 0.03698384f, -0.06532146f, -0.08896597f, -0.08509862f, -0.06801211f, -0.00924296f, 
    -0.04924970f, -0.16299064f, -0.05708172f, 0.09287531f, -0.01202643f, 0.04464766f, -0.08029854f, -0.05163817f, 
    -0.07719596f, -0.01076626f, -0.11438242f, -0.00859875f, 0.07341892f, 0.02925064f, 0.18961361f, 0.00634656f, 
    -0.26485637f, -0.04556293f, 0.11438002f, 0.18454824f, -0.18090817f, -0.00409255f, 0.02233756f, 0.04605012f, 
    0.20330393f, 0.01751392f, 0.04214184f, 0.07199537f, -0.00792272f, 0.13843046f, 0.09356033f, 0.12613428f, 
    0.10428375f, 0.28438056f, 0.03748521f, 0.23823093f, 0.16527446f, -0.00314154f, 0.03394039f, -0.10914636f, 
    -0.18201151f, -0.02858448f, 0.07251808f, -0.23113848f, -0.02319744f, -0.00738356f, -0.07048068f, -0.08249087f, 
    -0.17994291f, -0.08181178f, 0.09524802f, 0.15091066f, -0.18984343f, -0.06196163f, 0.03164324f, 0.07446598f, 
    -0.17324017f, -0.00498519f, -0.00938956f, 0.02062155f, 0.00256913f, 0.00569036f, -0.02726492f, -0.15917291f, 
    0.06656372f, 0.14525896f, 0.01142962f, -0.01397822f, 0.01435519f, 0.04108845f, 0.09686135f, 0.03338454f, 
    -0.07763499f, 0.34895054f, -0.21968305f, -0.00920352f, 0.15153389f, 0.19869809f, 0.05198958f, 0.08889851f, 
    0.03924208f, 0.10799894f, 0.07753523f, -0.02130058f, -0.00088236f, -0.03226882f, -0.15132987f, -0.16180997f, 
    0.05795353f, -0.02641344f, -0.00220940f, 0.02507534f, 0.14875330f, 0.13525397f, 0.10761937f, -0.09204248f, 
    0.30420116f, 0.09754667f, -0.05915626f, -0.05738040f, -0.09825960f, -0.03973116f, 0.06367180f, -0.01953986f, 
    -0.06131741f, 0.01973121f, -0.05718340f, -0.09856541f, -0.04540605f, 0.22287545f, 0.02102214f, -0.05880915f, 
    -0.13265564f, 0.01522753f, -0.00035630f, -0.01372640f, -0.04356430f, -0.01429475f, -0.05909259f, -0.07659481f, 
    0.13487040f, 0.22131245f, -0.17732027f, -0.09990295f, 0.00517390f, 0.02460715f, -0.05357495f, -0.11282952f, 
    0.14121765f, -0.00660955f, 0.06974281f, 0.07609164f, 0.47100896f, -0.12900095f, -0.13344485f, -0.26398653f, 
    0.07972545f, -0.05682247f, -0.07111526f, -0.15023795f, -0.21106420f, -0.03265942f, 0.03002074f, -0.03780099f, 
    0.10793758f, -0.16752601f, 0.04557430f, -0.04732485f, 0.00308509f, 0.09050754f, 0.05077161f, -0.06490260f, 
    -0.04598130f, -0.03881042f, -0.02993315f, -0.02720869f, 0.11515288f, -0.22159252f, -0.05943200f, -0.14722326f, 
    0.04075925f, 0.02020760f, 0.08793651f, 0.09516946f, 0.04027274f, 0.03758348f, -0.09544723f, 0.01421602f, 
    0.06898194f, 0.19403127f, -0.34372744f, -0.03069218f, 0.00166088f, 0.13364062f, 0.06748378f, -0.01184325f, 
    0.05298298f, 0.15125002f, -0.03516609f, 0.01296518f, -0.01731003f, -0.06629188f, -0.12823361f, -0.18933162f, 
    0.00933205f, -0.03194443f, -0.01378070f, -0.07159150f, 0.22813742f, 0.11993563f, 0.18797138f, 0.04711720f, 
    0.26231608f, -0.06496680f, 0.34741035f, 0.17909504f, -0.01581594f, 0.01928412f, 0.23987783f, 0.05176121f, 
    0.00457510f, 0.22068518f, 0.05052790f, 0.09570491f, 0.04431993f, 0.07791298f, 0.24732903f, 0.04737591f, 
    -0.05785748f, -0.13468483f, 0.02281788f, 0.05395551f, -0.14251918f, 0.02519534f, 0.03664393f, -0.00037879f, 
    -0.07595968f, -0.21979149f, -0.08480940f, -0.02818047f, -0.00220670f, 0.00877272f, 0.11263312f, -0.00814885f, 
    0.03274215f, 0.09393467f, -0.00027873f, 0.07304638f, 0.07244552f, -0.20094301f, 0.27034575f, 0.09412137f, 
    0.05232342f, 0.12560926f, 0.10106769f, 0.15227906f, 0.02809279f, -0.04076658f, -0.01107693f, 0.00691844f, 
    -0.08268446f, -0.10490140f, 0.01791684f, 0.05916058f, 0.20128904f, 0.21384934f, 0.04703864f, 0.00555023f, 
    0.08001428f, 0.13557726f, 0.13676634f, 0.15753455f, -0.24317320f, -0.08723941f, 0.00385874f, 0.12428840f, 
    0.07608256f, 0.00242964f, 0.13091055f, 0.27860057f, 0.02878411f, 0.04971180f, 0.02769763f, -0.13217302f, 
    0.14166322f, 0.14363123f, -0.03419057f, -0.13549832f, -0.12762636f, 0.01191653f, 0.04459159f, 0.03634639f, 
    -0.03467329f, 0.03196993f, -0.01800359f, -0.06388994f, 0.07575219f, 0.09020263f, 0.10048451f, 0.34352130f, 
    -0.01237868f, -0.10816371f, 0.07991590f, 0.15211229f, 0.04990811f, 0.03747339f, 0.10074358f, 0.02544692f, 
    -0.17368519f, -0.23922490f, -0.16542368f, -0.13082807f, 0.18217912f, 0.13294879f, 0.21835531f, 0.09744509f, 
    0.08180805f, 0.13576022f, 0.08509718f, 0.13010930f, 0.05070215f, 0.07760372f, 0.40005994f, 0.07624207f, 
    -0.34947795f, -0.05515603f, -0.03148093f, 0.09539236f, 0.07595789f, 0.00914941f, 0.04252263f, -0.01403576f, 
    0.00279240f, 0.12661798f, -0.15110663f, 0.03249877f, 0.14605941f, -0.02748286f, 0.09566402f, 0.12327623f, 
    -0.13297820f, -0.03504930f, -0.04884497f, -0.10266755f, 0.25266793f, 0.06182750f, 0.00592622f, -0.01221634f, 
    0.11302336f, 0.10596629f, 0.00432660f, 0.09295765f, 0.00205840f, 0.02303165f, -0.08200139f, 0.15432882f, 
    0.20124610f, 0.23634341f, -0.08027697f, -0.17796651f, 0.10009533f, 0.22365957f, 0.05364265f, 0.08813442f, 
    0.03028158f, 0.13197644f, 0.10618089f, -0.02394180f, -0.23357411f, 0.43572655f, -0.09131487f, 0.15694337f, 
    0.02154175f, -0.03100763f, -0.02977244f, -0.16529644f, 0.05459853f, 0.07730994f, 0.05644021f, -0.03030632f, 
    0.22812033f, -0.16092485f, 0.10115462f, 0.09379418f, 0.04326346f, 0.09406720f, 0.03365593f, -0.01984991f, 
    -0.06516285f, -0.01415725f, -0.05979037f, 0.01837607f, 0.10390703f, -0.15340395f, -0.09994315f, -0.03015243f, 
    0.00465633f, 0.08803727f, -0.03302557f, 0.08689758f, -0.01311037f, 0.01179192f, -0.01804589f, -0.03163839f, 
    -0.26595128f, -0.15402128f, -0.14061084f, -0.01490994f, 0.04965895f, 0.09764402f, -0.01880359f, -0.00294405f, 
    -0.19522347f, 0.04471224f, -0.00553982f, 0.02857423f, -0.02349775f, -0.12319234f, -0.14923814f, 0.16018951f, 
    0.16992061f, 0.13944194f, 0.00115683f, 0.15892141f, -0.02640685f, 0.00258042f, 0.07629064f, 0.20640351f, 
    -0.10696867f, -0.00088544f, 0.06326988f, 0.00191203f, -0.00289769f, 0.01084547f, -0.04537759f, 0.13866089f, 
    0.09947661f, 0.02077753f, -0.02240632f, 0.00918450f, 0.02390221f, 0.15185340f, -0.01522286f, -0.10762560f, 
    -0.07915989f, -0.03686093f, 0.00040987f, -0.03118988f, 0.04338510f, 0.14711346f, 0.09600166f, 0.11649155f, 
    -0.02014741f, 0.09429181f, 0.21147783f, 0.36083624f, -0.06609812f, 0.03735950f, 0.10799749f, -0.15345235f, 
    -0.02020697f, 0.08571912f, 0.00334933f, -0.05268591f, -0.13109221f, 0.21827485f, 0.18455477f, 0.01569751f, 
    -0.10135376f, -0.01770003f, -0.00642053f, 0.02641025f, -0.03601412f, 0.23313823f, -0.02284339f, 0.15040697f, 
    0.00268709f, -0.08176496f, -0.13010840f, -0.02296499f, 0.05187386f, -0.06404319f, 0.00506889f, 0.06381797f, 
    0.00788629f, 0.05325685f, 0.01550945f, -0.02420634f, 0.15077473f, 0.06514147f, 0.14715081f, 0.19032259f, 
    -0.00280441f, -0.03373433f, -0.00313419f, 0.06906471f, -0.06713226f, 0.05034711f, -0.05792771f, -0.25120386f, 
    0.06878889f, -0.01512717f, 0.24869524f, 0.19665681f, 0.04697238f, 0.04702134f, 0.04421853f, 0.13592713f, 
    0.09097310f, 0.04625881f, 0.04111411f, 0.11745460f, 0.27959916f, -0.06739609f, 0.31528541f, -0.10475461f, 
    -0.00838325f, -0.00941805f, 0.07759535f, 0.10324161f, -0.18065500f, -0.07294808f, 0.02929706f, 0.11374759f, 
    0.12874855f, 0.09723359f, 0.10598041f, -0.03977697f, 0.01987482f, 0.14330080f, 0.00653219f, 0.00440813f, 
    0.10249145f, 0.30699587f, 0.12897803f, 0.09708072f, -0.16310008f, -0.14592293f, -0.09136272f, 0.13658705f, 
    -0.07197978f, -0.02736397f, 0.06817479f, 0.26675248f, -0.01115142f, 0.10375483f, -0.04023618f, -0.18441662f, 
    -0.05847381f, 0.26779807f, 0.10992575f, 0.10121959f, 0.07033892f, 0.03987394f, 0.05446459f, 0.10110344f, 
    -0.03950911f, 0.05759110f, 0.08758102f, -0.07217665f, -0.22800496f, 0.19973502f, -0.26613691f, 0.16758719f, 
    -0.05716078f, -0.01069657f, 0.03995177f, 0.04126030f, 0.02206301f, -0.07443248f, 0.00621997f, 0.06836671f, 
    -0.20318653f, 0.08796853f, 0.06543671f, 0.04888060f, 0.05695955f, 0.00810569f, -0.05638825f, 0.04057974f, 
    0.00462442f, -0.07942697f, 0.07099798f, 0.00029070f, 0.06540191f, -0.31829041f, -0.10401459f, 0.01811955f, 
    -0.16969787f, 0.25971630f, -0.07735091f, -0.09122209f, 0.02138442f, 0.05994246f, 0.12474193f, -0.10524736f, 
    0.06646122f, -0.00497952f, 0.09470759f, -0.07304722f, 0.07221246f, 0.11300822f, -0.16266394f, 0.16060425f, 
    0.00455343f, -0.00501363f, -0.05485997f, -0.01080919f, -0.44841462f, 0.39272603f, 0.07241900f, 0.18761837f, 
    0.04005466f, 0.14104198f, -0.11596746f, 0.04948165f, 0.03567713f, 0.00299190f, -0.04469750f, 0.13460276f, 
    0.21095397f, 0.14595202f, -0.13938695f, -0.06209584f, 0.10740037f, 0.02116881f, 0.09888743f, 0.11756757f, 
    -0.06637165f, -0.09463739f, -0.05442497f, 0.01641212f, -0.05511438f, -0.03498607f, -0.08238889f, -0.02600847f, 
    -0.00956493f, 0.08802128f, -0.14619951f, 0.09625610f, -0.02739413f, -0.06641530f, 0.03917740f, 0.04275897f, 
    -0.11798571f, -0.02328404f, -0.11463185f, -0.02584083f, -0.06916197f, -0.13293865f, -0.00516682f, -0.11527824f, 
    -0.13048673f, -0.10325730f, -0.00307401f, 0.07548017f, 0.15273154f, 0.08274067f, -0.04727167f, -0.07328779f, 
    0.06166085f, 0.10767736f, 0.15502083f, 0.13435614f, 0.02982601f, -0.00338372f, -0.05452980f, -0.03519695f, 
    -0.13719247f, 0.05717781f, -0.05060906f, 0.02485948f, -0.04442704f, 0.05003086f, 0.02656459f, -0.04739270f, 
    0.03076212f, -0.00270550f, 0.11896533f, 0.06366771f, -0.11604426f, 0.07977466f, -0.02411664f, 0.01436656f, 
    -0.01921321f, -0.04802178f, -0.04906760f, -0.06878506f, -0.02452966f, 0.00032525f, 0.02771374f, -0.05020748f, 
    0.23355484f, -0.09869087f, -0.09017675f, 0.05055982f, -0.05027447f, 0.08707946f, 0.03297250f, -0.02499760f, 
    -0.03748139f, -0.05786536f, 0.04728009f, -0.01667250f, -0.15573002f, 0.01413332f, -0.04780809f, -0.28192508f, 
    0.08424570f, -0.07292833f, 0.03533789f, 0.11140154f, 0.02707767f, 0.07991826f, -0.09412014f, -0.13247749f, 
    0.09750340f, 0.16969022f, 0.07332288f, -0.03711619f, -0.00601129f, -0.00306911f, -0.00193358f, -0.02032776f, 
    -0.07659469f, 0.02892306f, 0.07184672f, -0.00256702f, 0.07555363f, -0.31062660f, -0.28578106f, 0.06656957f, 
    -0.03465986f, -0.01728153f, -0.04479373f, -0.00851323f, 0.19077878f, -0.07919153f, -0.07694877f, 0.02704533f, 
    0.04047479f, -0.24285935f, -0.06979677f, 0.01093091f, 0.04327589f, -0.00075495f, 0.08669374f, 0.12491027f, 
    -0.01418024f, -0.15856841f, 0.10798941f, -0.08590057f, 0.02221054f, 0.08480704f, 0.07171982f, -0.06049906f, 
    -0.03631930f, -0.00464020f, -0.04502596f, -0.01833530f, -0.12987098f, -0.02221402f, -0.02586664f, -0.12070540f, 
    -0.23831969f, 0.18837544f, -0.07165942f, -0.01443665f, 0.07200170f, 0.01671015f, 0.16124301f, 0.05324531f, 
    -0.08580306f, -0.01446130f, 0.07051875f, 0.06926943f, 0.14640372f, 0.09375520f, 0.27326453f, 0.08278303f, 
    -0.06071765f, -0.03557031f, -0.06842320f, 0.17624046f, -0.04698031f, -0.00549401f, -0.01893928f, 0.01566799f, 
    0.13927752f, 0.24124973f, 0.13111803f, 0.01955448f, 0.07418717f, 0.03720403f, 0.07632092f, 0.07524242f, 
    -0.06625726f, -0.03995282f, -0.04293365f, 0.05128297f, -0.04928111f, 0.13338645f, -0.11415015f, 0.14646266f, 
    0.12371245f, 0.04566896f, -0.07268320f, 0.03347046f, -0.03271354f, 0.01809478f, -0.11488473f, -0.02117059f, 
    -0.02602035f, -0.18918185f, 0.39853415f, 0.00268202f, 0.02185135f, 0.12292682f, 0.02695815f, 0.12818909f, 
    -0.02418555f, -0.21212068f, -0.04301939f, 0.13320050f, 0.23066527f, 0.13171741f, 0.12271033f, -0.06128647f, 
    0.07539041f, 0.00443717f, -0.13862602f, 0.14983459f, -0.00015876f, -0.01526087f, -0.01163897f, -0.11581641f, 
    0.01762445f, -0.26613262f, -0.23757826f, 0.12723406f, 0.08107550f, 0.03573507f, 0.12309314f, 0.00387856f, 
    -0.14722073f, 0.00435845f, -0.07995939f, -0.20497876f, 0.05781699f, 0.02787672f, -0.07629813f, -0.06859777f, 
    -0.05230648f, 0.06582872f, 0.11356674f, 0.03684498f, -0.03161321f, 0.10091850f, -0.00227821f, 0.02428265f, 
    0.37016681f, -0.25787392f, 0.09574749f, -0.02313791f, -0.02633147f, 0.06127053f, 0.10955621f, -0.03664740f, 
    0.11747675f, 0.10513891f, -0.10978632f, 0.09483580f, 0.08710184f, 0.13771506f, -0.20364888f, 0.08899023f, 
    -0.12440632f, 0.00641009f, 0.11682525f, -0.02946844f, 0.10762152f, 0.01222623f, 0.01138037f, -0.01969267f, 
    0.05214477f, 0.44720495f, 0.05885726f, 0.02308761f, 0.08407432f, -0.03975822f, -0.04513272f, -0.05761926f, 
    -0.11596708f, -0.07047597f, 0.07643189f, -0.06069886f, -0.07502545f, -0.05820290f, -0.05792009f, 0.13602175f, 
    -0.07466662f, -0.05736157f, 0.01816047f, -0.11932911f, -0.08524279f, -0.10860008f, -0.06355660f, -0.02639785f, 
    0.03464860f, -0.16099566f, 0.18878250f, 0.00735576f, -0.06483432f, -0.09359515f, -0.08256515f, 0.00156626f, 
    0.22245644f, 0.11751042f, -0.17109793f, 0.23107468f, -0.38975489f, -0.00451599f, -0.04087425f, -0.22764564f, 
    -0.08227172f, 0.09608290f, 0.02229460f, 0.01422315f, 0.07050037f, 0.18078274f, 0.14817132f, -0.15205736f, 
    0.10661699f, 0.09940193f, -0.04226497f, -0.12163685f, -0.05869161f, 0.07563496f, -0.15942107f, -0.00642525f, 
    -0.00126608f, -0.16849883f, -0.23898499f, -0.05855139f, 0.00091563f, 0.23910916f, 0.08512759f, 0.04667972f, 
    0.12167986f, 0.08467209f, 0.06964688f, 0.02024543f, -0.02045042f, -0.05460320f, 0.02871439f, -0.00616641f, 
    0.02744694f, 0.21603155f, 0.25660965f, 0.03425530f, 0.14875123f, 0.07465572f, 0.05458225f, -0.01514230f, 
    -0.03390048f, 0.17007816f, -0.05730842f, 0.07002397f, -0.08311684f, -0.11266024f, -0.11659463f, -0.02874710f, 
    -0.12055966f, -0.03030489f, -0.01739744f, 0.01168330f, 0.11198310f, -0.01767529f, 0.04567614f, -0.05619745f, 
    -0.05459447f, -0.34691644f, 0.11282398f, 0.08421262f, 0.06088727f, 0.09358746f, 0.00008289f, 0.04411027f, 
    -0.03937114f, -0.12574665f, -0.00593486f, -0.06820323f, -0.10403328f, 0.06186000f, 0.13367979f, 0.24327053f, 
    -0.02067299f, -0.01344748f, -0.01697381f, 0.05595614f, -0.05576323f, -0.08630816f, 0.20816168f, -0.13378812f, 
    0.18543358f, 0.24015315f, 0.05848207f, -0.05297358f, 0.10531064f, 0.00667410f, -0.01309811f, 0.00394475f, 
    -0.05940357f, -0.05651179f, 0.05574854f, 0.00836192f, 0.18688627f, 0.16741712f, 0.08049792f, 0.24980980f, 
    0.18340243f, -0.00146500f, 0.07189514f, 0.11806176f, -0.00883193f, 0.06951459f, -0.00153003f, 0.02757101f, 
    0.31439963f, 0.16049288f, 0.07223880f, -0.08913951f, 0.07820922f, 0.00198055f, 0.00977327f, 0.09913308f, 
    -0.05906822f, -0.02874395f, 0.00573568f, 0.15549912f, 0.15169793f, -0.05812295f, -0.11662800f, 0.12593447f, 
    -0.03069287f, 0.08203197f, -0.05428218f, 0.07074001f, 0.02750510f, -0.04511493f, 0.04041603f, -0.14030135f, 
    -0.00674814f, -0.06578966f, 0.03547310f, 0.03506184f, 0.08338583f, 0.09018636f, -0.02298525f, -0.05693499f, 
    -0.02719533f, 0.05138722f, -0.10882850f, 0.00495683f, -0.08364765f, -0.11492300f, 0.04362856f, 0.03980630f, 
    0.01787295f, 0.05313063f, -0.09602284f, 0.03346917f, 0.00985524f, -0.03187350f, 0.05507158f, -0.04013235f, 
    0.24071223f, 0.14629695f, -0.02144360f, -0.03233865f, 0.06982310f, 0.10256005f, 0.03445346f, 0.13937509f, 
    -0.00593855f, -0.00261824f, 0.06493137f, -0.12681375f, -0.03858295f, -0.32234520f, -0.25787404f, 0.48462585f, 
    0.18419327f, 0.06503671f, 0.06574421f, -0.03104469f, -0.08693894f, -0.00254579f, -0.03199220f, 0.01239647f, 
    0.26791179f, 0.21613339f, 0.07002032f, 0.12199862f, -0.04276178f, 0.12006550f, 0.04948275f, -0.09334007f, 
    -0.10131848f, -0.04147766f, 0.08459515f, -0.14624111f, -0.08461303f, 0.05400205f, 0.17898296f, 0.06854063f, 
    -0.04041775f, 0.00978096f, 0.10680816f, 0.12325184f, -0.06228853f, -0.09493072f, 0.02797569f, 0.05444366f, 
    -0.01977761f, 0.01682081f, 0.38708404f, -0.06509256f, -0.16820106f, 0.02473274f, 0.14520454f, 0.00684622f, 
    0.06069283f, -0.02491431f, 0.06052952f, 0.01262688f, 0.33253041f, -0.48666611f, 0.13718861f, 0.01773134f, 
    -0.05659687f, -0.05100276f, -0.10050522f, 0.00505684f, 0.02658353f, 0.09013753f, 0.03517175f, 0.11105154f, 
    0.04568416f, 0.14528058f, 0.31814584f, 0.00626149f, -0.11340611f, 0.18257430f, 0.01281570f, 0.19396091f, 
    -0.07307998f, -0.06349275f, 0.00024892f, -0.04380935f, 0.18057036f, 0.10194629f, -0.07956082f, -0.08868645f, 
    0.06971204f, 0.19842269f, 0.06991366f, 0.06682190f, -0.04037293f, -0.05306139f, -0.01138939f, -0.09692652f, 
    0.25292701f, 0.21635762f, 0.16318223f, -0.02792341f, -0.00816246f, 0.04366814f, -0.04384267f, -0.05111770f, 
    0.09706599f, -0.01126259f, -0.02821549f, -0.04929484f, 0.23034979f, 0.03252282f, 0.11924158f, 0.15121037f, 
    -0.11509731f, 0.11699031f, 0.01222441f, 0.13247311f, -0.02660087f, 0.08359810f, 0.05857302f, 0.02152716f, 
    0.03475834f, 0.08438033f, 0.13100418f, -0.13858405f, -0.05927971f, 0.05487316f, -0.13384080f, 0.12769924f, 
    -0.09516174f, 0.09751018f, -0.00871990f, -0.04482354f, -0.19299363f, -0.10418749f, -0.12824509f, -0.05305532f, 
    -0.05188583f, -0.03852021f, -0.02172781f, -0.04506336f, -0.04675146f, -0.00295353f, 0.03591183f, 0.08439597f, 
    -0.29474875f, -0.20195764f, -0.27623484f, 0.15915456f, -0.00750385f, -0.03478190f, 0.01021394f, -0.09579551f, 
    0.00576872f, -0.08599170f, -0.12158981f, 0.09178583f, -0.22095764f, 0.09550627f, 0.08668422f, 0.17767224f, 
    0.07587414f, -0.04360758f, 0.06235101f, -0.01291399f, -0.02886853f, 0.02406317f, 0.18015833f, -0.15101317f, 
    0.19598179f, 0.07626113f, 0.10982869f, -0.01894652f, -0.01583854f, 0.15930572f, 0.11071588f, 0.01043178f, 
    -0.03750441f, 0.02619985f, -0.01908506f, 0.02481517f, 0.05429646f, -0.02024169f, -0.09052313f, 0.10047794f, 
    -0.00493418f, -0.03327959f, -0.03817936f, -0.01603471f, -0.05286301f, -0.08745728f, -0.11079132f, 0.03767772f, 
    -0.10247117f, -0.03894960f, 0.06199898f, 0.02064033f, 0.04870307f, 0.02832915f, -0.04055343f, 0.03302180f, 
    -0.05578585f, 0.08997045f, -0.09700656f, 0.11248021f, -0.28353032f, -0.08883732f, 0.14622125f, 0.49071136f, 
    -0.02950302f, -0.01217346f, 0.23592652f, -0.10225499f, -0.03088287f, -0.01673940f, 0.04999382f, 0.11647172f, 
    -0.12162709f, -0.07830091f, 0.23103601f, -0.05240429f, 0.12414732f, 0.03523175f, 0.07360148f, -0.11027936f, 
    -0.07848869f, 0.00455134f, 0.04888978f, 0.10106765f, 0.03071124f, -0.01416983f, -0.08507058f, -0.10772695f, 
    0.11528410f, -0.10108160f, -0.09294160f, 0.13414657f, 0.00690943f, 0.04000716f, 0.02460942f, -0.09475812f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02458920f, 0.18450885f, -0.04197223f, 0.01926952f, -0.00818686f, -0.02650756f, -0.02870024f, 0.02526938f, 
    0.00008768f, 0.01846370f, 0.07289174f, 0.10943187f, 0.02706374f, 0.13601519f, 0.08350853f, -0.00433851f, 
    -0.02599153f, 0.15613522f, 0.01210572f, 0.09306455f, 0.02140984f, 0.01934072f, -0.02130089f, 0.02779252f, 
    -0.03210604f, -0.05364630f, 0.02046226f, -0.00696835f, 0.09642249f, -0.01474323f, 0.06592076f, 0.04439059f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05723450f, -0.21666406f, -0.09700726f, -0.17874047f, -0.12540007f, 0.37010926f, -0.51746619f, 0.02004249f, 
    -0.06063455f, 0.01972942f, -0.21920370f, -0.30225003f, -0.58929390f, 0.08175164f, -0.36221200f, 0.21311411f, 
    -0.19980027f, -0.05285992f, -0.06860755f, -0.29956061f, -0.08983982f, 0.07810581f, 0.12247390f, 0.36572817f, 
    0.02144381f, 0.24240483f, 0.15300284f, 0.01354271f, -0.28452441f, -0.12046675f, -0.16723830f, 0.31891525f, 
    0.05628874f, 0.36963257f, -0.32879594f, -0.32076362f, -0.07164377f, -0.56598186f, -0.36799362f, 0.15884288f, 
    0.11272763f, 0.08148845f, 0.26098588f, 0.14254749f, -0.05670574f, 0.21950820f, -0.30825686f, 0.30803192f, 
    -0.66973442f, 0.11051556f, 0.16894946f, 0.13608171f, 0.12089530f, -0.01065291f, -0.09881382f, -0.04200485f, 
    0.02648016f, 0.00102521f, -0.12994578f, -0.10862558f, -0.04813964f, -0.08397391f, 0.00508060f, 0.05346410f, 
    -0.10323242f, -0.09556310f, -0.21451759f, 0.05670147f, 0.10513869f, 0.24306494f, 0.37917006f, 0.18232077f, 
    0.12050591f, 0.07274410f, 0.20498574f, 0.27021006f, 0.27805588f, 0.27932736f, 0.34693351f, 0.16514805f, 
    -0.47545722f, -0.02615759f, -0.15946257f, -0.65359628f, -0.03180243f, -0.04689769f, -0.12794270f, -0.49694154f, 
    -0.16929984f, -0.27279386f, -0.12827495f, 0.14742258f, -0.06631505f, 0.11736272f, -0.19151980f, -0.39388427f, 
    0.03135952f, -0.55646861f, -0.06874263f, 0.01263198f, -0.12147485f, 0.17296584f, 0.40474844f, 0.03720837f, 
    0.09486247f, 0.00669194f, -0.01501211f, -0.43213877f, -0.06503533f, -0.35216153f, -0.20639008f, 0.18305653f, 
    0.15594028f, -0.00040411f, -0.07657599f, -0.32295236f, 0.03159114f, -0.05748260f, 0.03985475f, -0.03609280f, 
    -0.17014454f, 0.21201327f, 0.01734814f, -0.13524477f, 0.18417364f, 0.05266111f, 0.10290852f, -0.23571473f, 
    0.08399275f, 0.06162214f, -0.07323620f, -0.06759932f, 0.16592555f, 0.23697291f, 0.26976553f, -0.28239873f, 
    -0.04706933f, 0.13602458f, 0.22662757f, 0.17877740f, 0.22166686f, 0.12792362f, -0.30981511f, 0.07525066f, 
    0.42196873f, -0.37139252f, -0.16402355f, 0.21721222f, 0.17048852f, 0.14813812f, -0.16706938f, 0.07829676f, 
    0.08901712f, -0.01534698f, -0.09913242f, -0.13345654f, 0.03457265f, 0.02227519f, -0.37595689f, 0.15678836f, 
    -0.18261306f, 0.26701993f, -0.66364992f, 0.14508860f, 0.10068826f, 0.15654953f, -0.67782623f, -0.50795668f, 
    -0.05086471f, 0.01164031f, 0.21112420f, -0.14435773f, -0.29988560f, 0.09055964f, 0.33619273f, -0.23471199f, 
    0.17785007f, 0.27392742f, 0.00134533f, -0.02831549f, 0.03664688f, 0.15514965f, -0.02917634f, 0.27957854f, 
    0.03665632f, -0.05850792f, -0.08838182f, 0.08088556f, 0.10151866f, -0.11275227f, -0.15275241f, 0.09414009f, 
    0.10638515f, -0.12657416f, 0.47827813f, 0.22414471f, -0.11562566f, -0.47582269f, 0.07685870f, -0.22472498f, 
    0.08258639f, 0.11991357f, 0.18419363f, 0.23977746f, 0.20367785f, 0.20468879f, 0.05993762f, -0.60776371f, 
    0.08726399f, 0.22335447f, 0.00997937f, -0.09188373f, -0.01159325f, 0.12306217f, 0.03123286f, -0.77393597f, 
    -0.02980728f, -0.58794701f, 0.06385875f, -0.06941629f, -0.08341862f, 0.04850033f, 0.01821839f, -0.41999224f, 
    0.12010367f, -0.09446260f, -0.04998851f, -0.12468363f, 0.11363035f, 0.17117661f, 0.08445738f, 0.00617836f, 
    -0.17860712f, -0.13671872f, -0.34758887f, -0.08217462f, 0.38980320f, -0.44469425f, 0.19495477f, -0.06411891f, 
    0.32708973f, -0.08153076f, -0.03270752f, 0.30217519f, -0.02786734f, -0.11533318f, 0.13954224f, 0.37339917f, 
    -0.12393237f, -0.19449095f, -0.03304747f, 0.11055143f, -0.45516029f, -0.08475266f, 0.17146514f, -0.11408962f, 
    -0.02399347f, -0.15751779f, -0.29296410f, -0.38757890f, -0.07335788f, 0.11660260f, -0.33336970f, 0.18767641f, 
    -0.04908575f, -0.04992534f, -0.09271210f, -0.40131819f, -0.34089616f, -0.46370190f, 0.49580881f, -0.18398027f, 
    -0.20069528f, 0.21512246f, 0.04469433f, -0.10095967f, 0.16680698f, 0.11772566f, 0.10139924f, -0.50287455f, 
    0.08552734f, -0.50629067f, -0.11122461f, 0.07240252f, 0.17959207f, 0.10726904f, 0.37111464f, 0.20233841f, 
    0.12746514f, -0.26128137f, 0.18281980f, 0.38363454f, 0.05942578f, -0.18420294f, -0.35568821f, 0.17755984f, 
    -0.10258729f, 0.13264450f, -0.12900756f, 0.19563647f, 0.13549031f, 0.18976161f, -0.23739317f, -0.10126983f, 
    0.24584232f, -0.06101696f, 0.11536539f, -0.26603347f, 0.12755397f, -0.13585263f, -0.10953351f, 0.70479268f, 
    -0.14656475f, -0.47769183f, -0.00253683f, -0.09146374f, 0.01500375f, -0.06463337f, -0.10876089f, -0.45980287f, 
    0.09106801f, 0.06422381f, -0.19060491f, 0.39980826f, -0.00237782f, -0.57702291f, -0.05966980f, -0.54791582f, 
    -0.13567568f, -0.08303832f, -0.27582255f, 0.04114951f, -0.26862958f, -0.20654456f, 0.02027155f, 0.29854712f, 
    -0.15579359f, -0.12314050f, -0.10630604f, -0.47572792f, -0.16652745f, -0.11347428f, 0.03059949f, -0.80863297f, 
    -0.07636115f, -0.21153508f, 0.05549949f, -0.06323475f, 0.24646564f, -0.11876654f, 0.27306193f, 0.32672143f, 
    0.05592721f, 0.33166796f, 0.21176630f, 0.16072012f, -0.17803839f, -0.17754816f, 0.42781195f, 0.35980052f, 
    0.09769899f, -0.08598810f, -0.41204569f, 0.19364735f, -0.47994548f, -0.19811328f, -0.01216491f, -0.60048759f, 
    -0.30174160f, -0.14750810f, 0.15135790f, -0.28541088f, 0.11145362f, 0.11426676f, 0.02546146f, 0.04274844f, 
    0.10204625f, 0.21679956f, -0.14026712f, 0.12145741f, 0.05424577f, 0.03850114f, 0.23220423f, 0.08704161f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.18958113f, 0.28621075f, 0.35109252f, -0.09180868f, -0.16156265f, 0.11074268f, -0.32046849f, -0.22262497f, 
    0.19452086f, 0.03337299f, 0.04995622f, -0.17696522f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
