#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.02755892f, -0.85031432f, -1.27464664f, -0.83773381f, -1.09314716f, 1.18761349f, 0.33531588f, 0.27988350f, 
    -0.04563264f, 0.63982749f, -0.04648243f, 0.34579828f, 0.26012841f, 0.05334789f, 0.10919029f, -0.04809280f, 
    -0.08776891f, 0.20349851f, -0.09799495f, -0.09916546f, -0.08646570f, -0.02003747f, -0.00920916f, -0.27045757f, 
    0.36591822f, 0.39249134f, 0.36688873f, 0.04123630f, 0.09735844f, 0.23598669f, 0.70958626f, 0.79597527f, 
    0.13658974f, 0.12770830f, 0.00967428f, 0.28258151f, -0.12861471f, -0.10854020f, -0.12942860f, 0.11534363f, 
    0.16167784f, 0.30908164f, 0.12763044f, 0.10669919f, 0.12718776f, -0.10275044f, -0.19066514f, -0.21108232f, 
    -0.20132346f, -0.03949919f, -0.16883928f, -0.59415323f, -0.72802728f, -0.76171422f, -0.76486522f, -0.52852625f, 
    -1.33600080f, -0.97334325f, -0.92582303f, -1.43737137f, 0.54472101f, 0.26240119f, 0.50090814f, 0.29172415f, 
    0.35783678f, 0.05560461f, 0.23856424f, -0.07492717f, -0.11564600f, 0.02291645f, -0.06124786f, 0.22171572f, 
    0.30572671f, 0.07869275f, -0.06875560f, 0.66883409f, 0.46173394f, 0.31318483f, -0.48398691f, 0.09974172f, 
    -0.02771624f, 0.14018334f, 0.22752358f, 0.30703461f, -0.43379837f, -0.13075066f, 0.58052397f, -0.22088082f, 
    -0.85638601f, 0.25392014f, -0.15096173f, -0.15256463f, -0.42797041f, -0.33003509f, 0.19674195f, -0.12953277f, 
    0.53013313f, -0.03611476f, -0.51237231f, 0.33200988f, -1.16965425f, -1.12123728f, 0.34712747f, 0.63259441f, 
    0.54489839f, 0.97894686f, 0.53456742f, -0.27071911f, -0.57840073f, -0.23326887f, 0.33393094f, -0.48061231f, 
    -0.34357411f, 0.17680351f, -0.38914034f, -0.16336377f, -0.14275905f, -0.14061692f, 0.16982926f, 0.25546333f, 
    -0.09007110f, -0.04814135f, 0.17768554f, -0.08723721f, 0.20254205f, 0.50726664f, 0.55325675f, 0.60639501f, 
    0.02536589f, -0.07070486f, -0.12749949f, 0.06200754f, 0.88730401f, -0.48427913f, -0.31993777f, -0.51688951f, 
    0.19196784f, 0.68048948f, -0.51752847f, -0.02763493f, 0.24765082f, -0.01347593f, -0.11060613f, -0.28121051f, 
    0.20848197f, -0.21437372f, -0.49466458f, -0.41874591f, 0.14123392f, 0.55876672f, 0.61349881f, -0.53525537f, 
    -0.52573419f, -0.11473249f, 0.06412467f, 0.29651910f, -0.09517691f, 0.15877385f, 0.71018010f, 0.35594133f, 
    -0.33371517f, 0.49952823f, -0.60770667f, -0.33143607f, 0.26738179f, -0.39378756f, -0.10806465f, -0.26378450f, 
    -0.03900125f, -0.15428497f, 0.22782061f, -0.31440356f, 0.10091908f, 0.47836167f, 0.55469871f, 0.24362957f, 
    -0.50803852f, -0.23612860f, 0.13673496f, -0.56607878f, -0.39253870f, -0.13996468f, 0.57339686f, 0.68094432f, 
    0.47630808f, 0.28132012f, 0.04495490f, -0.64475530f, -0.61215162f, 0.27959484f, -0.28763577f, 0.18545525f, 
    0.11962888f, -0.13727736f, -0.66815543f, -0.60812509f, -0.31392875f, -0.84512740f, -0.84561479f, -0.50437754f, 
    1.42480087f, 0.82721055f, 0.71296775f, -0.50217783f, -0.38001150f, 0.09355681f, 0.25487188f, -0.19645733f, 
    -0.70107633f, -0.88809639f, 0.04074884f, -0.13237382f, -0.27380589f, -0.02720385f, 0.14048739f, 0.12097047f, 
    0.04127881f, 0.06518584f, -0.09138156f, -0.08171554f, -0.34615576f, 0.04934807f, -0.23977517f, -0.03741181f, 
    -0.11665232f, -1.84243858f, -0.74035448f, -0.25980774f, 0.65089786f, 0.48404890f, -0.80843014f, 0.07163770f, 
    0.65622675f, 0.36403266f, -0.20860286f, -0.38345593f, -0.17203799f, -0.19081154f, 0.46482813f, -0.14724071f, 
    0.13742992f, 0.06275073f, 0.15038656f, 0.26571426f, 0.03712239f, 0.37610513f, -0.18029346f, 0.02591420f, 
    0.13460764f, 0.04210271f, 0.00506043f, -0.13156970f, 0.26873034f, 0.33975875f, -0.37654197f, 0.10370632f, 
    -0.40862817f, -0.11042135f, 0.40355247f, -0.35576248f, 0.34122691f, -0.33578101f, 0.01445127f, -0.24514893f, 
    0.79871076f, 0.16930537f, 0.00729259f, -0.54164118f, -0.38912627f, -0.32473177f, 0.29646569f, -0.08637310f, 
    0.44220689f, 0.30290180f, 0.26892859f, -1.66446054f, 0.95349222f, 0.82384795f, -1.64558232f, -1.02700984f, 
    -0.27309832f, 0.63384444f, 0.90949613f, 0.84124786f, -0.41966030f, -0.02716302f, 0.09907487f, -0.02681510f, 
    0.27743363f, -0.17590210f, -0.14832644f, -0.33094373f, -0.10814868f, -0.58179498f, -0.46594232f, 0.05337990f, 
    0.05940379f, 0.44238585f, -0.18202449f, -0.58509785f, -0.51767874f, -0.06301516f, 0.19960222f, 0.36582521f, 
    0.56525797f, 0.78788519f, -0.27299914f, 0.28563863f, 0.46202755f, 0.68326449f, 0.37504011f, 0.44490644f, 
    -0.19727500f, -0.58627522f, 0.24699688f, -0.27462420f, 0.07422733f, 0.13190554f, 0.00427353f, -0.24888040f, 
    -0.14874034f, -0.07635897f, 0.06483606f, 0.14399806f, 0.04928568f, -1.75160098f, -0.36186489f, -0.54510623f, 
    -1.37141216f, -1.16524243f, 0.26904398f, -0.36413953f, -0.54988509f, 0.23333807f, 0.67470014f, -0.22697672f, 
    -0.15475801f, -0.12524962f, -0.37735322f, -0.23313390f, 0.30430597f, -0.30243874f, -0.21837136f, -0.13262485f, 
    -0.19170374f, 0.08267620f, 0.23243389f, -0.04915685f, -0.18559638f, 0.50635153f, 0.27209154f, -0.22161555f, 
    0.41054320f, 0.40552640f, 0.45642784f, -0.39450568f, 1.15740693f, -0.90178150f, -0.97643012f, -0.65477806f, 
    0.27183801f, 0.15226103f, 0.20831558f, -0.50920361f, -0.21545359f, -0.25313675f, 0.24151671f, 0.31609687f, 
    0.25046369f, 0.13300958f, -0.10741840f, -0.04925303f, 0.40020591f, -0.02687521f, 0.30842504f, -0.53329760f, 
    -0.66918224f, -1.07669103f, -0.15188898f, -0.85131097f, -0.41824892f, -0.37693778f, -0.81624520f, -1.00262606f, 
    -0.47636837f, -0.23238026f, -0.57810867f, -0.59358895f, -0.40081418f, 0.78581721f, -0.13517982f, -0.10350873f, 
    -0.14712688f, -0.42533854f, 0.18719487f, -0.20512573f, -0.80234635f, 0.25294530f, 0.11234143f, -0.31427485f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.59512007f, -0.01611511f, -0.07721035f, 0.61376947f, 0.72007537f, 0.25007796f, 0.37340900f, 0.22982441f, 
    0.33044425f, 0.22704859f, 0.38665918f, 0.15811846f, 0.21364674f, -0.03524997f, 0.57683206f, -0.20188847f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22394353f, -0.14205623f, -0.37611556f, 0.16312069f, 0.20656346f, 0.10283213f, -0.02289483f, -0.30964532f, 
    -0.02032056f, 0.11632908f, 0.02482762f, -0.02059870f, -0.08800455f, -0.02320229f, 0.04087796f, 0.11083880f, 
    0.09156284f, 0.09798077f, -0.02064921f, -0.00590670f, -0.35580254f, -0.13918377f, -0.05847635f, 0.14562018f, 
    0.77466851f, 0.38548678f, -0.41269061f, -0.32289788f, 0.00594407f, 0.20412534f, 0.05900703f, 0.18224600f, 
    0.05655641f, 0.16344802f, 0.03063541f, -0.01411391f, -0.28290415f, -0.64866310f, -0.74673933f, 0.12961015f, 
    -0.08458187f, -0.05097392f, -0.06336153f, -0.03955036f, -0.12852415f, -0.11327455f, 0.03162983f, -0.25440922f, 
    0.77003509f, -0.37811440f, -0.46577126f, -0.62913269f, -0.49442536f, -0.33440369f, 0.05517198f, -0.05825427f, 
    -0.19570930f, -0.03285794f, -0.30555999f, -0.14714123f, -0.17436828f, -0.27368209f, -0.13532519f, 0.03086482f, 
    0.06809837f, 0.01787217f, 0.06813252f, 0.06386124f, 0.04085805f, 0.04878896f, 0.03997877f, -0.16195902f, 
    -0.27390352f, -0.08694070f, -0.11178713f, 0.13256595f, 0.00699337f, 0.10341258f, -0.01812059f, -0.00072208f, 
    -0.08756665f, -0.06956594f, -0.10279428f, -0.15593353f, -0.46334931f, 0.03487334f, 0.06624711f, 0.04442094f, 
    -0.00656058f, 0.01417710f, 0.07981728f, 0.05993245f, -0.05044948f, 0.22910513f, 0.12060026f, 0.32823372f, 
    -0.31721151f, -0.89121449f, -0.56787771f, 0.00271481f, 0.07701898f, 0.06937703f, -0.18724483f, -0.06499394f, 
    -0.07561473f, 0.09035073f, 0.08022980f, 0.04473501f, 0.66803592f, 0.20412374f, 0.41389790f, -0.50499481f, 
    0.02563273f, 0.06106421f, 0.25677815f, -0.03702858f, 0.08424826f, 0.09330788f, -0.01113001f, -0.02586187f, 
    -0.11127754f, -0.15309007f, 0.02351948f, -0.25618216f, -0.04113399f, 0.20186868f, -0.19183700f, -0.17766912f, 
    -0.06879777f, -0.08444210f, -0.25411734f, -0.44179469f, -0.08547980f, -0.96101993f, 0.08099691f, -0.04449563f, 
    -0.01859973f, 0.14933166f, -0.20465326f, 0.09423126f, -0.03576846f, -0.19161944f, -0.26384386f, 0.17169812f, 
    -0.07528251f, 0.03765436f, 0.04325808f, 0.06624383f, -0.05965870f, 0.02567771f, 0.01194852f, 0.02496447f, 
    -0.03811269f, -0.05313380f, -0.12573871f, -0.06852467f, 0.30544052f, 0.20933332f, 0.06541147f, -0.40092948f, 
    0.15750158f, 0.34294313f, -0.05995818f, -0.09493083f, 0.00570752f, -0.01551864f, 0.01088360f, -0.11089556f, 
    0.14710328f, -0.06335457f, -0.12122641f, 0.00431982f, 0.17286262f, -0.43009761f, -0.25652784f, -0.33390436f, 
    -0.16403796f, 0.01379339f, 0.05083809f, 0.03351246f, 0.54568118f, 0.34269375f, 0.04294236f, -0.21754068f, 
    0.32271042f, 0.23683596f, -0.00940883f, -0.04951591f, -0.19291322f, -0.15411679f, -0.04695950f, -0.14356709f, 
    0.81897438f, -0.34503347f, -0.27979234f, -0.25698456f, 0.12431165f, 0.06260154f, -0.04949196f, -0.25074184f, 
    0.09285662f, -0.08246040f, -0.04466775f, -0.19265628f, -0.01171226f, -0.00423286f, 0.12516819f, 0.17219941f, 
    -0.09387961f, 0.00588516f, -0.06654558f, -0.03955608f, 0.24567606f, 0.09023542f, -0.02041034f, -0.10142656f, 
    -0.35768813f, -0.12624083f, 0.07998726f, 0.18707803f, -0.16543446f, 0.01814125f, 0.14951512f, -0.00490932f, 
    -0.15003130f, 0.05523271f, 0.07143134f, 0.06746524f, 0.56486773f, 0.38637489f, 0.17904706f, 0.29748276f, 
    -0.04569595f, -0.00148526f, -0.05054720f, 0.04330188f, -0.03481588f, 0.05785428f, -0.29824409f, -0.03416771f, 
    0.37803432f, -0.38233790f, 0.14218506f, -0.13263339f, -0.06080708f, -0.03038652f, 0.20780656f, 0.05093222f, 
    0.21979240f, 0.05662606f, 0.23221232f, -0.11106438f, 0.44060543f, -0.06231778f, 0.10109505f, -0.06117460f, 
    -0.11129633f, -0.03868188f, 0.06594096f, -0.27593282f, 0.24654274f, -0.05500187f, -0.01158747f, 0.16214041f, 
    0.50411195f, 0.42729986f, -0.06897328f, 0.11588730f, -0.15221962f, 0.18943813f, 0.11420459f, -0.01269059f, 
    0.18118082f, 0.08983096f, 0.10834163f, -0.15744805f, -0.24473737f, 0.14464363f, 0.13726626f, -0.16785105f, 
    -0.02070651f, 0.10415495f, -0.20539989f, -0.16770844f, -0.23623498f, -0.35684815f, -0.39764699f, -0.23095015f, 
    0.62073058f, -0.21548210f, 0.09627593f, -0.14455928f, -0.11460249f, -0.25762817f, -0.11295200f, -0.08757088f, 
    -0.02540788f, 0.09208409f, -0.15775311f, 0.09828620f, -0.95131761f, -0.01785567f, 0.29978696f, 0.21022178f, 
    -0.09142868f, -0.16060387f, 0.16011800f, -0.23202281f, -0.01049078f, -0.13983841f, -0.14807239f, -0.17108886f, 
    -0.40250018f, -0.01238532f, 0.00478958f, -0.03046189f, -0.17699514f, -0.06102015f, 0.33892453f, 0.05932767f, 
    -0.07791863f, 0.10721270f, 0.04466469f, -0.11405614f, -0.79999846f, -0.63250923f, 0.15158962f, -0.59079880f, 
    0.06214955f, -0.02405360f, -0.08455462f, 0.04622475f, -0.11827701f, 0.00703345f, 0.19764154f, -0.11433541f, 
    0.11012758f, 0.16351511f, 0.04716527f, 0.07793852f, -0.08656044f, -0.01023082f, -0.03788317f, -0.07174549f, 
    -0.12323304f, -0.07821467f, -0.03940649f, 0.08652000f, 0.28917757f, 0.47004834f, 0.09495110f, 0.21907280f, 
    0.05652953f, 0.21715884f, -0.23947926f, 0.05158759f, -0.05885942f, 0.03964447f, 0.01007836f, -0.17399251f, 
    0.13048862f, 0.04652205f, -0.17879149f, -0.10450367f, -0.34838426f, 0.18996224f, 0.02089542f, -0.25015137f, 
    0.01414357f, -0.03338528f, -0.02538525f, 0.10509694f, 0.16381377f, -0.13493358f, 0.55922431f, -0.26640376f, 
    0.22303000f, -0.07139880f, -0.25502363f, -0.19451797f, 0.15800634f, 0.06920254f, 0.02227906f, -0.04142701f, 
    -0.14438611f, 0.63237810f, 0.48302108f, 0.34626165f, -0.10356326f, 0.04806931f, 0.05713652f, -0.05941837f, 
    0.04163659f, 0.09088998f, 0.13296816f, 0.16534723f, -0.00618879f, -0.19955340f, -0.04473180f, -0.10366379f, 
    0.08811375f, -0.04754268f, 0.11986192f, 0.04074851f, 0.00307519f, -0.08912439f, -0.04424015f, 0.30522436f, 
    -1.29627872f, -1.01413786f, -0.21810454f, -0.29237011f, -0.12351342f, -0.05105852f, 0.06920003f, -0.38670456f, 
    0.06286006f, 0.07901385f, -0.05778760f, 0.00523848f, 0.22076574f, -0.29881960f, -0.08292852f, -0.04186185f, 
    -0.06880049f, 0.09980918f, -0.02811849f, 0.07572275f, 0.12272512f, -0.00248599f, -0.23365811f, 0.12771016f, 
    -0.10183068f, 0.20183007f, 0.26837227f, 0.25752619f, 0.24965386f, 0.04523069f, 0.06679447f, 0.24442708f, 
    0.04161632f, 0.07686534f, 0.03446291f, -0.21918431f, -0.08817363f, 0.07760869f, -0.38836184f, -0.03237558f, 
    0.00239880f, 0.01753934f, 0.01091142f, 0.00890596f, -0.01685135f, 0.00749871f, -0.03253863f, -0.20096111f, 
    -0.37191445f, 0.19155854f, -0.18671244f, -0.01143719f, -0.00933538f, 0.03780820f, 0.01319565f, -0.04036241f, 
    -0.01532815f, -0.09576999f, -0.69412321f, -0.17230454f, 0.02209224f, 0.09120637f, 0.09749405f, 0.07033478f, 
    0.04068527f, 0.01990530f, 0.01382143f, -0.11029059f, 0.26753083f, 0.20480989f, -0.21353860f, 0.35274509f, 
    -0.63203692f, -0.12089288f, 0.07213398f, -0.87237173f, 0.04921142f, -0.12751481f, -0.13147317f, -0.11184444f, 
    0.02051051f, 0.12736507f, -0.11991169f, -0.00596257f, -0.16924638f, -0.03188844f, -0.09464476f, 0.39609396f, 
    0.00791194f, -0.03883386f, -0.21972005f, 0.09627158f, -0.07398412f, -0.07236306f, 0.00790911f, -0.05537973f, 
    -0.67354399f, -0.30888507f, -0.21223769f, 0.17311139f, -0.32345760f, 0.03378171f, 0.15189017f, -0.08192448f, 
    -0.08692380f, 0.04338980f, -0.33468151f, 0.17870384f, 0.44102216f, 0.55626494f, -0.09818902f, 0.21222426f, 
    -0.05431519f, -0.00671798f, 0.19868344f, -0.28293261f, -0.22373301f, -0.00397713f, 0.00114677f, 0.04928437f, 
    -0.12111179f, -0.14516954f, -0.07507470f, -0.01616314f, -0.02212238f, -0.00407154f, 0.06681850f, 0.17835659f, 
    -0.21856008f, 0.01253034f, 0.08587670f, 0.17520905f, 0.21537891f, 0.69523329f, 0.36218154f, 0.97789216f, 
    0.00188005f, 0.15347910f, -0.19422299f, 0.07223784f, 0.03676306f, -0.08640249f, -0.08996050f, 0.07896297f, 
    -0.06807900f, 0.19918726f, -0.04420611f, -0.23376526f, -0.08946501f, -0.28559229f, 0.13388534f, 0.11901851f, 
    -0.06295019f, 0.00991356f, 0.03755578f, -0.03373624f, -0.97070724f, -0.74443209f, 0.47751150f, -0.18210810f, 
    -0.14766431f, -0.10369898f, 0.12312900f, -0.32909745f, -0.07930630f, 0.07812330f, -0.05209977f, -0.07298315f, 
    -0.89001197f, -0.37121364f, -0.10506514f, 0.35387802f, 0.24881673f, 0.07063377f, -0.01177071f, 0.01709053f, 
    0.01687551f, -0.05655158f, 0.13992593f, -0.04477051f, 0.02586559f, 0.20865472f, -0.35795254f, -0.11235805f, 
    0.18196651f, 0.15108179f, 0.07238392f, 0.15982470f, -0.25449142f, 0.21887778f, 0.03817173f, -0.36242518f, 
    0.00108206f, -0.32442716f, 0.01623268f, 0.37692967f, 0.18070884f, 0.06939383f, 0.26126093f, 0.11957157f, 
    -0.01848471f, -0.04893213f, -0.01693494f, -0.03193405f, -0.39103118f, -0.22181477f, 0.45379278f, -0.32793275f, 
    -0.18557715f, 0.10437289f, -0.58328938f, -0.13963935f, -0.33445317f, 0.01728937f, -0.30887595f, -0.25290063f, 
    -0.95916611f, 0.74603641f, -0.45124641f, -0.69863951f, 0.07246587f, 0.31735706f, -0.12073983f, -0.08006995f, 
    -0.52702105f, -0.10188699f, 0.09711874f, -0.13966902f, 0.01639228f, 0.10784511f, -0.24082823f, -0.32880569f, 
    0.12697092f, -0.13951264f, -0.16399108f, -0.04334056f, -0.03465571f, 0.01163343f, -0.08423635f, 0.08259430f, 
    -0.52883482f, 0.27394259f, 0.14501792f, -0.03554256f, 0.14697179f, -0.28107160f, 0.31983644f, -0.20924623f, 
    -0.03257305f, 0.02279033f, 0.22450317f, 0.21004122f, -0.11922310f, -0.26113743f, -0.11365314f, -0.07443886f, 
    0.08512435f, -0.01793012f, 0.02937692f, 0.00126806f, -0.20469621f, 0.27348480f, -0.03033988f, 0.03613104f, 
    -0.35945955f, -0.13424645f, 0.73759681f, 0.44977927f, -0.17589641f, -0.01939205f, 0.21691215f, 0.09783385f, 
    -0.03288389f, 0.09007109f, 0.06174955f, 0.01655279f, 0.15917911f, 0.56472003f, -0.51105529f, -0.83039004f, 
    0.01976404f, 0.17048617f, -0.17728528f, -0.17216240f, -0.18994774f, 0.08711267f, -0.04037494f, -0.04656271f, 
    0.26839477f, -0.19441955f, 0.07398496f, -0.21644831f, -0.16921085f, -0.12948221f, 0.00128073f, 0.14025314f, 
    0.03587741f, -0.04587679f, -0.08308907f, -0.13433935f, 1.28948689f, -0.05995880f, 0.27809724f, 0.34079134f, 
    0.03366793f, 0.00739572f, -0.18768975f, -0.00055691f, -0.08756538f, 0.08031371f, 0.06525178f, -0.04529395f, 
    -0.31285965f, -0.18134469f, -0.12405710f, -0.81898338f, 0.28286910f, 0.08273973f, 0.15772012f, 0.12533230f, 
    -0.05939874f, 0.01851762f, -0.29548389f, 0.11244033f, 0.44346705f, -0.07891904f, 0.00182813f, 0.37936914f, 
    0.07752706f, -0.06530172f, -0.10969122f, -0.20423691f, 0.03271933f, 0.17064549f, 0.00778706f, 0.31494188f, 
    -0.25799936f, 0.65394789f, -0.49163094f, 0.73532522f, -0.09194566f, -0.50601995f, -0.10755822f, -0.20466332f, 
    0.02060026f, 0.05545009f, -0.00392981f, 0.15372162f, -0.20486495f, -0.32292241f, -0.10992443f, 0.35811213f, 
    -0.02545236f, 0.06475431f, 0.00597118f, 0.04441116f, 0.00387836f, 0.03703125f, -0.03321166f, 0.00357098f, 
    -0.02049588f, 0.02281393f, 0.06880582f, 0.12137953f, 0.01510584f, -0.16708279f, -0.05564617f, -0.03590421f, 
    -0.03201469f, -0.09069445f, 0.12361491f, -0.00518544f, 0.10081283f, -0.00972938f, -0.03088815f, 0.06013335f, 
    0.29301441f, 0.19830635f, 0.04281073f, 0.09180799f, -0.00339383f, -0.04700315f, 0.21823058f, 0.36429483f, 
    0.34524074f, 0.40397871f, 0.52095318f, 0.20278393f, -0.10616850f, -0.13375384f, -0.16552082f, 0.26246110f, 
    0.17397112f, 0.02156636f, 0.00525396f, -0.01266178f, -0.24724850f, -0.22749491f, -0.30633998f, -0.54733008f, 
    -0.02523879f, -0.05382422f, 0.24079402f, -0.02840870f, 0.04110390f, -0.00239172f, -0.03315025f, -0.18230566f, 
    0.13487241f, -0.64312935f, 0.34796736f, 0.04319749f, -0.09673858f, 0.02096588f, -0.21979488f, -0.43337345f, 
    -0.23524372f, 0.14602040f, -0.35353750f, -0.17891839f, -0.16127396f, -0.03129704f, -0.07628594f, -0.11870256f, 
    0.06002079f, 0.07051738f, -0.09090981f, 0.07608169f, 0.09023583f, 0.06149298f, -0.10216541f, -0.27993092f, 
    0.16817565f, -0.07922476f, -0.03197063f, 0.05115067f, -0.20049509f, 0.00156613f, -0.03025621f, 0.20020108f, 
    -0.41139814f, -0.39919960f, -0.48167539f, -0.10378025f, 0.08832914f, -0.03041895f, -0.38757765f, -0.21535538f, 
    -0.07857568f, 0.02358487f, 0.14339447f, 0.00297191f, 0.22113301f, 0.17471392f, 0.24590261f, 0.29864231f, 
    0.13997056f, 0.90177327f, -0.73420733f, 0.40097737f, 0.22804977f, 0.15790138f, 0.00278429f, -0.11760975f, 
    0.08511715f, 0.03329171f, -0.03505345f, -0.09153834f, -0.34464994f, -0.87967378f, -0.05515277f, -0.13239151f, 
    -0.35215205f, 0.04932376f, -0.11874721f, 0.00893301f, -0.01898115f, 0.05689180f, -0.13693663f, 0.03659527f, 
    0.20644565f, -0.09091175f, 0.06301013f, 0.19943883f, 0.17116635f, 0.03961413f, -0.06240884f, 0.13496044f, 
    -0.10922334f, -0.15313992f, -0.35693747f, -0.11059753f, -0.11649389f, 0.12812205f, -0.00917525f, 0.17243195f, 
    -0.04445745f, -0.18611011f, 0.04267555f, -0.18489456f, 0.16393182f, -0.23315713f, 0.11653144f, -0.00736098f, 
    0.23424590f, -0.05519300f, -0.16950446f, -0.09414882f, 0.10428173f, -0.01475391f, 0.06174210f, 0.10495083f, 
    -0.30049744f, -0.23259534f, -0.15873589f, -0.10057694f, 0.04563779f, 0.06083367f, 0.00321172f, 0.16416526f, 
    -0.14984936f, -0.22415094f, -0.05032233f, -0.24342068f, 0.05609032f, -0.04610317f, 0.16279864f, 0.06425114f, 
    -0.05120329f, 0.12911436f, 0.23577471f, 0.05385929f, 0.15330942f, 0.12470374f, -0.04840465f, 0.13564181f, 
    -0.20726807f, -0.15784606f, -0.10763187f, -0.18857844f, 0.05299174f, 0.17285225f, -0.06063691f, 0.24294522f, 
    -0.16970775f, -0.09529472f, 0.24489728f, 0.12777647f, -0.16236125f, -0.12089606f, -0.08850909f, 0.26762974f, 
    -0.36261758f, -0.49444911f, -0.36037469f, -0.42818132f, -0.14279748f, -0.03996456f, -0.04185892f, 0.04938465f, 
    0.05490464f, -0.00541048f, 0.02657225f, -0.04312313f, 0.07933020f, 0.00566301f, -0.01869402f, 0.09943663f, 
    -0.00794979f, -0.08095540f, -0.10641474f, -0.04435675f, 0.10318180f, -0.19724688f, -0.40318382f, -0.02950895f, 
    0.13049096f, 0.28380862f, 0.06886716f, -0.23585598f, 0.28379449f, 0.08988078f, 0.05786177f, -0.28457972f, 
    0.02581531f, -0.01020386f, 0.05877723f, -0.09637559f, -0.08405187f, -0.38646615f, -0.43971202f, 0.15610641f, 
    0.12715650f, 0.05914942f, -0.00612103f, 0.05108794f, 0.16041589f, -0.06720670f, 0.29068631f, 0.26727179f, 
    -0.33492237f, 0.34171128f, 0.04780954f, 0.30143043f, 0.03320809f, -0.03668910f, 0.12239129f, 0.13235494f, 
    0.15934867f, -0.07152808f, -0.18299142f, 0.18500631f, -0.06088860f, -0.20980161f, -0.36735708f, 0.62342733f, 
    0.06396959f, 0.06902145f, -0.17017820f, -0.00490976f, -0.15901893f, 0.04471416f, 0.16285318f, 0.27716273f, 
    -0.55683100f, -0.42933357f, 0.25064933f, -0.06633583f, -0.06405266f, -0.09289777f, -0.19259407f, -0.06506886f, 
    0.13181788f, -0.00322425f, -0.00153279f, 0.20757359f, 0.07754485f, -0.30464223f, -0.22053577f, 0.04363237f, 
    0.06480716f, -0.14181092f, 0.08648799f, 0.18569779f, 0.00368119f, -0.51584715f, -0.10304141f, -0.45676836f, 
    -0.01743220f, -0.01226400f, -0.84681535f, 0.24955682f, 0.08337642f, 0.26133692f, -0.00169308f, 0.03032461f, 
    0.08202937f, -0.23316693f, 0.04551997f, -0.24591325f, -0.09659474f, -0.06712230f, -0.00660222f, 0.25439575f, 
    0.22388168f, -0.19690047f, 0.02280903f, 0.13972017f, 0.01540287f, 0.00451456f, 0.02078265f, 0.03025119f, 
    0.14108625f, -0.16978225f, -0.15191926f, 0.14893658f, -0.13755059f, 0.00628266f, -0.27362114f, 0.11693676f, 
    0.05486344f, 0.14782260f, 0.05361405f, 0.31654119f, -0.67021263f, 0.19711092f, -0.72309947f, 0.21958859f, 
    0.04869390f, -0.03528295f, -0.06934083f, -0.02146207f, 0.17410743f, 0.15079980f, -0.26779470f, -0.27581200f, 
    -0.16434988f, 0.02091963f, 0.10994606f, 0.11723506f, -0.05896260f, -0.04210033f, -0.16062823f, -0.09138603f, 
    0.22124888f, -0.03528085f, 0.29943380f, 0.15055887f, -0.48868713f, -0.13670212f, 0.00307488f, -0.24767336f, 
    0.29756624f, 0.05449861f, 0.18567158f, 0.18475012f, 0.06054737f, -0.01623849f, -0.09712239f, 0.13649732f, 
    0.19141902f, -0.16628525f, -0.16968784f, -0.13624442f, 0.27711114f, -0.06225580f, 0.31910416f, 0.27738461f, 
    0.17082918f, 0.09483885f, 0.04202317f, 0.18093529f, 0.09060572f, 0.36404890f, 0.04494193f, 0.22578202f, 
    0.15082976f, 0.06183127f, -0.08390658f, 0.03311437f, 0.04425474f, -0.01084847f, 0.06430538f, -0.04593021f, 
    0.38373095f, 1.05608547f, 0.45518515f, 0.15523854f, -0.01802941f, -0.19024611f, 0.19620788f, 0.26172504f, 
    0.02167987f, 0.06658573f, -0.09957501f, 0.12090079f, -0.06605341f, 0.05859654f, 0.02317087f, -0.08669788f, 
    0.11063867f, -0.08568390f, 0.04793645f, 0.01490321f, -0.05209424f, 0.04689788f, 0.02420732f, -0.16713160f, 
    -1.55210316f, -0.36461237f, -0.84074402f, -0.40708262f, -0.10529247f, -0.11634662f, -0.51396638f, -0.56652689f, 
    0.02426999f, -0.14292823f, 0.01748283f, -0.10677117f, 0.15548849f, 0.01503878f, 0.00798422f, -0.43310878f, 
    0.10752752f, -0.08183569f, 0.16574664f, -0.17050317f, 0.02358203f, -0.12767071f, 0.19805145f, -0.02073348f, 
    -0.30848360f, -0.35271358f, 0.57129377f, -0.00572793f, 0.12575977f, -0.02745031f, -0.16455962f, 0.09570580f, 
    -0.12443876f, 0.05999929f, 0.09131201f, -0.13417313f, -0.13368899f, 0.00005116f, -0.04574322f, -0.24933796f, 
    -0.10193992f, -0.01809836f, 0.08274522f, -0.05281872f, -0.13687286f, -0.06900548f, -0.32961220f, 0.01428463f, 
    -0.17338623f, 0.01811698f, -0.23609070f, 0.33484426f, 0.13705818f, -0.23122199f, 0.03221279f, 0.12488274f, 
    -0.03958113f, 0.06311949f, 0.21694478f, 0.13354430f, 0.19067948f, 0.31089270f, -0.00623567f, 0.00255504f, 
    -0.00750794f, 0.06480284f, 0.08900986f, 0.12340163f, 0.12216087f, 0.27744797f, 0.45794231f, 0.19185865f, 
    0.29645669f, -0.43968850f, -0.01365518f, -0.35537484f, 0.09971034f, 0.15175588f, 0.31906196f, -0.26158202f, 
    -0.03325569f, 0.09901638f, 0.14260074f, 0.13539079f, -0.32778075f, -0.28442499f, -0.01176239f, -0.54780674f, 
    -0.49652940f, 0.01633184f, 0.24492522f, -0.19424346f, -0.09393268f, -0.03826564f, 0.02610764f, -0.00566689f, 
    0.05956680f, -0.05022558f, -0.10841396f, -0.15879123f, 0.15571845f, 0.00447897f, -0.10073929f, -0.00103301f, 
    0.15675455f, 0.05486515f, 0.18544625f, -0.33422074f, -0.13571599f, 0.02614510f, 0.63666886f, -0.11386387f, 
    0.01624667f, 0.06370491f, -0.15990673f, 0.05032030f, -0.09700050f, 0.25276208f, 0.20672540f, 0.09370169f, 
    -0.00255358f, -0.13465887f, 0.05746569f, 0.04745661f, 0.10089283f, -0.07048965f, 0.06352739f, 0.15306258f, 
    0.30643815f, -0.05661149f, 0.04438178f, -0.10217883f, -1.38471234f, -0.66096359f, 0.46515107f, 0.11401507f, 
    -0.11770497f, -0.53545266f, 0.15569660f, -0.08133002f, -0.10657518f, -0.03703676f, -0.00721917f, -0.21579748f, 
    -0.31339952f, -0.72246623f, -0.07110103f, 0.17781433f, 0.08107947f, 0.31322789f, -0.29595503f, -0.15624106f, 
    0.04670079f, -0.00691241f, -0.15280581f, 0.05471358f, -1.35219121f, -1.06863654f, -0.99766105f, 0.11029820f, 
    -0.27577400f, -0.00103203f, -0.22759397f, -0.23278742f, 0.06498500f, -0.09649775f, 0.22990014f, 0.04526717f, 
    -0.55162865f, -0.66734624f, -0.21797232f, -0.35071689f, -0.17897595f, -0.01187633f, 0.00347000f, -0.01294656f, 
    0.04015802f, 0.04166115f, -0.03337640f, 0.15829869f, 0.13575542f, 0.16167447f, 0.15521069f, -0.02879320f, 
    -0.08493067f, -0.02004569f, -0.03110374f, 0.01746644f, -0.13399442f, -0.35368779f, 0.06744467f, -0.03445798f, 
    -0.84868354f, -1.03392434f, 0.08754306f, 0.43062779f, 0.26114622f, 0.11533198f, 0.18884780f, 0.07126083f, 
    0.05769028f, 0.06322924f, -0.02580550f, -0.00184804f, -0.18245211f, 0.16023976f, -0.03768322f, -0.23556612f, 
    -0.06424929f, -0.09981410f, -0.00923264f, -0.07238640f, 0.13266818f, -0.04887647f, -0.09495850f, -0.31501400f, 
    0.45515850f, -0.13302834f, -0.13119799f, -0.59486151f, -0.12533882f, -0.10966287f, 0.01287774f, 0.18340822f, 
    -0.05348914f, 0.04295619f, -0.00618305f, -0.07047059f, 0.03779167f, 0.27951106f, -0.20895866f, 0.10903050f, 
    -0.00220317f, -0.04702459f, 0.04919706f, 0.03154981f, -0.06456073f, 0.05531258f, -0.02890820f, -0.12531190f, 
    0.12979142f, -0.42391190f, -0.09005970f, -0.60890836f, 0.09747072f, 0.14552663f, 0.14070706f, -0.08979338f, 
    -0.06429202f, 0.05569534f, -0.07970437f, -0.06258025f, 0.10126811f, -0.70590580f, 0.22512120f, -0.01565221f, 
    -0.05928676f, -0.08230035f, 0.06828179f, -0.00243507f, 0.05921831f, -0.06134460f, -0.02999599f, 0.07164271f, 
    -0.13358033f, 0.47536737f, 0.11951600f, 0.01773542f, -0.16713597f, -0.10582824f, -0.04024763f, 0.14681211f, 
    0.11394669f, -0.06458898f, 0.11417112f, -0.06734311f, 1.19497907f, -0.33774829f, -0.55064577f, -0.34911633f, 
    0.09811945f, 0.04215366f, -0.09665527f, -0.11460782f, -0.03503526f, 0.12271075f, 0.03257287f, -0.09335085f, 
    -0.00745524f, 0.60545868f, 0.27708164f, 0.12499692f, -0.14144595f, 0.04801551f, 0.12088924f, -0.18586339f, 
    0.00677626f, -0.06695237f, -0.20692627f, 0.17813027f, 0.15121338f, 0.69229919f, -0.76526010f, 0.22246468f, 
    -0.11105379f, 0.17427792f, -0.01309357f, -0.02474561f, 0.03199057f, -0.02677323f, 0.05510102f, 0.03530465f, 
    0.26728851f, -0.01835783f, 0.14014578f, -0.38451737f, -0.03199574f, 0.08002327f, 0.03856724f, -0.10727483f, 
    -0.04549078f, -0.00871142f, -0.14711079f, -0.44387665f, 0.00510845f, -0.70337009f, -0.67140663f, -0.74589437f, 
    0.03613623f, 0.17010690f, -0.13719110f, 0.28258708f, 0.09126260f, -0.06968124f, -0.00624481f, 0.00623784f, 
    -0.16692640f, 0.24985033f, 0.19154964f, -0.16478291f, -0.01934410f, -0.60781544f, 0.20478214f, -0.06558766f, 
    -0.17930062f, -0.00923591f, 0.07554775f, 0.02625678f, -0.55601621f, -0.89943552f, -0.16541210f, -0.28076187f, 
    0.03034841f, 0.17518921f, 0.06290437f, 0.12099082f, -0.10548853f, -0.01834051f, -0.04267361f, -0.21483183f, 
    -0.53836298f, -0.92807448f, -0.09880996f, 0.41913176f, 0.19360533f, 0.23047198f, 0.19160460f, 0.22658111f, 
    -0.04141055f, 0.03885598f, -0.13768980f, 0.07299403f, -0.42407361f, -0.10208392f, -0.03547939f, -0.26144972f, 
    -0.14841762f, -0.11946463f, -0.06840457f, -0.05588130f, -0.08701061f, -0.06709709f, 0.04957725f, -0.00816075f, 
    -0.45764598f, -0.43989843f, -0.29708529f, -0.03681991f, -0.07546455f, 0.11280812f, -0.20381299f, 0.09428845f, 
    -0.08342667f, -0.10696419f, 0.02406897f, 0.00146375f, -0.30937082f, 0.26494765f, 0.32392281f, 0.07045918f, 
    -0.08550564f, -0.00482697f, -0.11891586f, -0.06290912f, -0.16233587f, 0.18439750f, 0.12965360f, 0.40801930f, 
    0.35651657f, 0.24618499f, -0.18902309f, -0.39159855f, -0.21051513f, -0.36995545f, -0.09450629f, 0.13318884f, 
    0.17462583f, 0.15935889f, 0.13760717f, 0.23854373f, -0.37557480f, -0.04616277f, 0.11158039f, 0.22862260f, 
    -0.00762475f, -0.11877329f, -0.06499795f, 0.04816064f, -0.06943586f, -0.18188371f, -0.05035681f, 0.01410304f, 
    0.12189487f, -0.12456945f, 0.09230024f, -0.17415109f, -0.01147073f, -0.07740077f, -0.04519687f, -0.08553489f, 
    0.23323192f, 0.15114453f, 0.41711634f, 0.41671088f, -0.11435053f, -0.01520155f, -0.01830844f, -0.06270227f, 
    0.16264135f, 0.09090774f, 0.08012001f, 0.04635942f, -0.33480284f, -0.28840443f, -0.53490174f, -0.52239490f, 
    -1.23670185f, 0.07163544f, 0.19248743f, 0.44610012f, -0.02962328f, -0.11676420f, -0.36684051f, 0.03781557f, 
    -0.25823602f, -0.32009628f, -0.13336667f, -0.13418782f, 0.63340312f, 0.10224344f, -0.43444222f, -0.76757574f, 
    0.02754906f, -0.04333600f, -0.02256927f, 0.10412817f, 0.30921197f, -0.06072506f, 0.11086195f, 0.21091010f, 
    0.02590201f, -0.38535136f, 0.02453648f, -0.31684628f, 0.27073342f, 0.01981295f, -0.36357254f, 0.17225167f, 
    0.20682161f, 0.17518148f, 0.27309144f, 0.20764323f, -0.58104038f, -0.21861327f, -0.18542601f, 0.05654966f, 
    0.08784900f, 0.32841271f, 0.11620709f, 0.26403183f, 0.14585859f, 0.17799856f, -0.05750078f, -0.27339080f, 
    0.16791463f, 0.05502190f, -0.12191233f, -0.26347360f, -0.26108080f, -0.06087290f, 0.06017837f, -0.00774791f, 
    0.12562935f, 0.06598692f, 0.10773748f, 0.21942198f, -0.46940657f, -0.83378279f, -0.97831190f, 0.40997994f, 
    0.27312762f, 0.08991820f, 0.11706574f, -0.09609621f, 0.00094341f, 0.07168898f, 0.04156109f, -0.04108820f, 
    0.09798832f, 0.14200854f, 0.07353617f, 0.25059426f, -0.23611857f, -0.02880903f, -0.06873407f, -0.09162550f, 
    0.06767799f, 0.20724550f, 0.08679580f, 0.18188427f, 0.08828757f, -0.51098710f, -0.68026632f, -0.64144045f, 
    0.22110511f, -0.19976357f, 0.21031912f, -0.25420102f, 0.11311716f, -0.15347227f, -0.01718885f, -0.07023375f, 
    0.47698128f, 0.23660819f, 0.89629900f, -0.80762321f, -0.15609738f, -0.48589092f, -0.42345047f, -0.00697763f, 
    -0.15243497f, -0.02000087f, 0.09640983f, 0.13594268f, 0.14753607f, -0.24673241f, 0.00917610f, -0.04305521f, 
    -0.11290271f, 0.21443617f, 0.28953364f, 0.11326634f, 0.27805710f, 0.14703254f, 0.06126237f, 0.01913053f, 
    0.11180034f, 0.37953678f, 0.09490921f, -0.50489682f, -0.07843784f, -0.14861783f, 0.14149004f, 0.27425644f, 
    -0.07829870f, -0.01658192f, 0.02095613f, -0.15630829f, -0.50723565f, -0.28201926f, -0.35945299f, -0.03180814f, 
    0.07403336f, 0.12692520f, 0.13126092f, 0.12887718f, 0.04693784f, -0.05265792f, -0.03758879f, -0.03360109f, 
    -0.43514770f, -0.27116573f, 0.19507934f, 0.47726879f, -0.03383477f, 0.28094345f, -0.50899410f, 0.07116108f, 
    0.06493980f, -0.45655215f, 0.15549681f, -0.12917495f, -0.76839322f, 0.02651207f, -0.22564970f, -0.09529699f, 
    0.36107230f, 0.08929017f, 0.25000137f, 0.19624510f, -0.05571288f, -0.19808939f, -0.02049643f, 0.07430535f, 
    0.34978896f, -0.12616752f, 0.36591265f, -0.57854766f, 0.00063184f, -0.23923285f, -0.03394092f, -0.14047267f, 
    -0.23541549f, 0.02894179f, -0.08451124f, -0.21129267f, 0.34478784f, -0.06253000f, 0.47695950f, 0.30878231f, 
    0.02377940f, -0.00527205f, 0.10486633f, -0.00179601f, 0.27747130f, 0.21945269f, 0.28211179f, 0.00880141f, 
    -0.06348698f, -0.21127306f, -0.18086800f, -0.13312992f, -0.00050509f, 0.27840194f, 0.26413012f, 0.27080837f, 
    0.00296608f, -0.02172417f, 0.02718687f, 0.10030188f, -0.58765906f, 0.23315176f, -0.07371866f, 0.81068301f, 
    0.45740330f, -0.24310863f, -0.32389781f, -0.00767084f, 0.16587628f, -0.16644675f, 0.00646091f, 0.08265312f, 
    0.32457832f, -0.31160524f, -0.46090713f, -0.04611412f, -0.02039962f, -0.18752524f, -0.17397346f, -0.13395022f, 
    -0.03341668f, -0.41562492f, 0.03480072f, -0.48441467f, -0.81546795f, 0.74729431f, -0.71883875f, 0.02916215f, 
    -0.10243864f, -0.29336819f, -0.05534094f, -0.12939578f, 0.06743547f, -0.19981322f, 0.00702982f, 0.18250598f, 
    -0.05711514f, -0.26157761f, 0.24407238f, 0.20933282f, 0.16625237f, 0.25216010f, -0.14370111f, -0.26006588f, 
    0.05068696f, 0.18532741f, 0.07453626f, -0.32310101f, -0.37239331f, -0.09223925f, 0.05141386f, -0.56513596f, 
    -0.19610251f, -0.13567005f, 0.13250421f, -0.26209846f, 0.12183870f, 0.07602932f, 0.09561979f, -0.09843542f, 
    0.09744883f, -0.89282882f, 0.18564947f, -0.44125050f, 0.18786611f, 0.12810785f, -0.09321769f, 0.31203648f, 
    0.06668181f, -0.10256673f, -0.04788235f, -0.13893986f, -0.34604111f, -0.22840191f, 0.37428057f, -0.06422606f, 
    -0.18866180f, -0.01083233f, 0.03322345f, 0.43733945f, 0.01953474f, -0.00350631f, 0.13823217f, -0.01237855f, 
    -0.37100708f, 0.31733954f, -0.38746959f, 0.55658835f, 0.07108670f, -0.28511995f, 0.19745323f, -0.14033316f, 
    -0.07126348f, 0.15309866f, 0.08931676f, -0.10617125f, 0.10563252f, -0.08394312f, 0.20305893f, -0.29446626f, 
    0.05471149f, -0.18762042f, -0.37164518f, -0.30334419f, -0.21170115f, 0.01002283f, -0.05455843f, -0.32259080f, 
    -0.43799210f, -0.14696883f, -0.17355132f, 0.31896827f, -0.15094189f, -0.12791249f, -0.20252383f, 0.16553673f, 
    -0.11760551f, 0.28843501f, 0.13471106f, 0.05975775f, -0.27871305f, 0.11805099f, 0.50913841f, -0.01047728f, 
    -0.24865180f, -0.22412071f, 0.55835009f, 0.19891186f, 0.11525205f, 0.16060551f, 0.51946813f, 0.14545470f, 
    -0.40125626f, 0.32147804f, -0.38477525f, 0.13787030f, -0.01944296f, 0.15155385f, -0.02678853f, -0.08316996f, 
    0.01588376f, 0.13247652f, -0.12245129f, 0.14891037f, -0.31471616f, -0.73192585f, 0.34306785f, -0.29328606f, 
    -0.02832637f, 0.09974387f, -0.16233301f, 0.07125927f, 0.05459821f, -0.23384258f, 0.40886486f, 0.15574707f, 
    -0.21013781f, 0.62161601f, 0.14396797f, -0.00933479f, 0.04730935f, -0.06221605f, -0.19434144f, -0.09448444f, 
    0.51837993f, 0.00001145f, 0.50991005f, 0.02015462f, -0.60528064f, 0.45113376f, -0.24134953f, -0.41661826f, 
    0.03845705f, -0.07315926f, -0.35871834f, 0.09847503f, -0.23963910f, -0.57210499f, -0.38916716f, -0.66732752f, 
    -0.06078856f, -0.22460762f, 0.01397907f, -0.39534628f, -0.28264880f, -0.14462100f, 0.00349395f, 0.21153484f, 
    -0.29488459f, 0.00229754f, -0.23321006f, -0.25497222f, -0.55660093f, 0.30624583f, 0.10190012f, 0.10412275f, 
    -0.35673401f, 0.22000657f, -0.53211707f, 0.23353511f, -0.05575863f, 0.11519288f, 0.02633136f, -0.22993517f, 
    -0.06942005f, 0.48689058f, 0.24142687f, 0.07716266f, 0.13755628f, 0.06557073f, 0.05749188f, -0.06649428f, 
    0.08847288f, 0.03488640f, 0.44355038f, 0.31203356f, 1.11110950f, 0.01241316f, 0.34529269f, -0.43700695f, 
    -0.04846890f, -0.18710461f, -0.14186749f, 0.15584715f, -0.22761071f, -0.38099417f, -0.35419783f, -0.05394556f, 
    -0.36847299f, -0.26215842f, -0.44293186f, 0.04426900f, -0.09659635f, 0.00431437f, 0.10917116f, -0.21940522f, 
    -0.06339405f, 0.15004487f, -0.28640586f, 0.00369930f, 0.04449361f, -0.35201159f, -0.01304475f, -0.11663807f, 
    -0.42061228f, 0.14938056f, 0.04466388f, 0.33059090f, 0.21115865f, 0.01904336f, 0.11372633f, -0.10420518f, 
    -0.29505593f, -0.32503933f, 0.70143455f, 0.30355951f, -0.30789667f, 0.16560647f, 0.07993369f, 0.06280796f, 
    -0.13817255f, -0.09726280f, 0.27257740f, 0.20132042f, -0.47295564f, 0.38774377f, -0.37754470f, 0.13369420f, 
    0.06537802f, -0.03424123f, -0.10826264f, -0.04533599f, 0.06284796f, 0.10480674f, -0.16734549f, -0.13434887f, 
    -0.76375079f, 0.08766575f, -0.09755903f, 0.22429119f, -0.19170387f, -0.04974351f, -0.01047955f, 0.23367397f, 
    -0.33551386f, -0.02081068f, -0.15044871f, -0.15312725f, -0.34510151f, -0.06130299f, -0.32263216f, -0.13732730f, 
    -0.21748573f, 0.06687912f, 0.10332368f, 0.08550196f, 0.04450295f, 0.24159719f, 0.10353240f, -0.01706833f, 
    -0.27263516f, -0.37690905f, 0.40995073f, -0.18858577f, -0.22185878f, -0.24435399f, -0.31700397f, -0.43745846f, 
    -0.07724559f, -0.13633108f, -0.23062013f, 0.01388870f, 0.28099751f, 0.22009704f, 0.26316717f, 0.28478757f, 
    -0.10967688f, 0.32112131f, -0.27663717f, 0.03532510f, -0.16138366f, -0.05414758f, 0.04986189f, -0.02597635f, 
    -1.02654207f, -0.05973703f, -0.60591167f, 0.45782766f, 0.38204455f, 0.10747976f, 0.17585777f, -0.40365887f, 
    0.01271464f, -0.04702276f, 0.21705225f, 0.13875817f, 0.59698480f, 0.06472989f, 0.63845181f, -0.50642025f, 
    0.10564392f, 0.01141012f, -0.12496657f, 0.20964637f, -0.17489228f, 0.30780515f, -0.01315066f, 0.00827291f, 
    -0.28985789f, -0.54519004f, -0.27803349f, 0.80029261f, 0.22741155f, -0.00094508f, -0.11573596f, 0.13176656f, 
    -0.39423838f, -0.22974025f, -0.31169063f, -0.08901998f, 0.05274832f, -0.02156942f, -0.42956388f, 0.07039423f, 
    0.05189429f, -0.15029873f, -0.00493777f, 0.05893653f, -0.15423897f, 0.16733952f, 0.17644845f, 0.12013014f, 
    0.50596011f, 0.36752903f, 0.67086905f, -0.08943848f, -0.03066100f, 0.07858005f, 0.04508700f, 0.10050780f, 
    0.05016491f, 0.08714856f, 0.25155538f, 0.18810490f, -0.11079600f, -0.17312637f, 0.05171112f, 0.25727808f, 
    0.30284622f, 0.34614778f, 0.14246528f, 0.06330619f, -0.10626355f, -0.03858056f, 0.27998668f, 0.32810438f, 
    0.29799560f, 0.41538420f, 0.10234427f, -0.11538801f, 0.12671784f, 0.06432350f, 0.12229966f, 0.01596526f, 
    -0.02584717f, -0.23033188f, 0.01462642f, -0.06895549f, 0.13473205f, -0.83782595f, 0.24193864f, -0.68730158f, 
    0.05492991f, 0.13395549f, 0.25866354f, -0.07927138f, -0.03371055f, 0.05909424f, 0.07394496f, 0.11431307f, 
    -0.35514194f, 0.37002990f, -0.51046163f, 0.22260627f, -0.01393565f, 0.06243227f, 0.09270620f, -0.08400384f, 
    -0.03491959f, 0.14794835f, -0.07867263f, -0.17033431f, 0.15619893f, 0.23603816f, 0.34183013f, -1.09058857f, 
    -0.07278183f, -0.29924169f, 0.08678175f, 0.02871219f, 0.05492506f, 0.00167633f, 0.03037906f, -0.13481985f, 
    -0.03886918f, 0.84654468f, -0.52661932f, 0.20461695f, -0.26758400f, 0.16634409f, -0.11594301f, -0.16219524f, 
    -0.03909500f, 0.03463035f, -0.21415684f, -0.31880507f, 0.02212362f, -0.54401243f, -0.20056462f, 0.18380754f, 
    -0.45301667f, -0.08666597f, 0.18709317f, 0.02276452f, 0.12363356f, 0.09040609f, -0.10675288f, -0.02676930f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33631587f, 0.07232112f, 0.15004264f, -0.14880085f, -0.11007975f, 0.18506785f, 0.12007858f, -0.28871980f, 
    0.19312324f, 0.06656416f, -0.00271313f, -0.05376205f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
