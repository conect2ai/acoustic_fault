#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.16358161f, 0.01517393f, -0.91240019f, 0.70976132f, 0.85785091f, 1.05460143f, 0.34133819f, 0.37761620f, 
    0.84819210f, 0.93291360f, -0.22705558f, -0.19455273f, -0.66279119f, 0.06029321f, 0.30878374f, -0.00790994f, 
    -0.40408766f, -0.04958009f, -0.03977637f, 0.30579135f, 0.28328407f, 0.00832251f, -0.10537163f, -0.15563799f, 
    -0.32132879f, 0.46108460f, 0.28545740f, -0.73522538f, -1.59834886f, -0.71857065f, 0.58787370f, -0.36304137f, 
    0.12945114f, 0.86813867f, 0.09861705f, -0.96970409f, -0.46651271f, -0.36838150f, 0.03899523f, 0.04755914f, 
    -0.24948414f, 0.33537421f, 0.37644720f, 0.21269172f, -0.15067822f, 0.12710433f, -0.07981966f, -0.40799743f, 
    0.06906352f, 0.30952883f, 1.62038302f, 0.89672548f, 0.45701194f, 1.43812919f, 1.44750249f, 0.79378223f, 
    0.16770834f, -0.91930336f, 0.68412012f, -0.60913771f, 0.08907839f, 0.22159141f, -0.46146041f, 0.28646842f, 
    -0.26359397f, 0.13928013f, 0.02554214f, 0.16974096f, -0.17900586f, -0.20523660f, 0.38999715f, 0.35369223f, 
    0.23902583f, -0.01690625f, 0.53882760f, -0.79564333f, -0.25420362f, -0.92536098f, -0.63672853f, -0.38910231f, 
    0.01907156f, -0.68697661f, -0.62790835f, -0.55567259f, -0.42173767f, -0.13350351f, -0.06103380f, 0.29266009f, 
    -0.10161775f, -0.92199445f, -0.27890831f, 0.42441276f, 0.01761116f, -0.80011040f, -0.64177263f, 0.09959756f, 
    0.11082133f, 0.27421153f, 0.28932634f, 0.34404677f, -1.92831087f, 0.60662353f, -0.45012522f, -0.47479242f, 
    -0.33277193f, 0.53442734f, 1.10388112f, -0.15515925f, 0.72630531f, 0.93220323f, 0.17540158f, -0.09508622f, 
    -0.10766634f, -0.29253909f, 0.29515266f, 0.36170438f, 0.34852159f, 0.25727436f, 0.32970548f, -0.16914739f, 
    0.09359857f, -0.02194245f, 0.16612005f, 0.12955835f, 0.47006729f, 0.70962685f, 1.20060349f, 1.21219516f, 
    0.03364102f, 1.00035143f, 0.46713120f, -0.53280562f, -0.92661679f, -0.97581935f, -0.23189361f, 0.11111916f, 
    0.50688827f, 0.36257169f, 0.34733680f, -0.31949210f, 0.05089902f, 0.22273596f, 0.30630302f, 0.02251506f, 
    0.35461748f, 0.08864526f, 0.11225659f, 0.04211066f, -0.14689493f, 0.07952419f, 1.40571487f, 1.16037285f, 
    0.79309589f, 0.39968246f, -0.81437588f, -0.41368139f, -0.96949589f, 0.06524224f, -0.15261647f, 0.91085923f, 
    0.19291100f, -0.09436389f, -0.14050420f, -0.19707985f, 0.35920024f, -0.29034436f, -0.45477697f, 0.14452873f, 
    -0.23299383f, -0.16257741f, 0.23314627f, 0.33547387f, -0.39953384f, -0.18033862f, -0.09987634f, 0.34127265f, 
    1.32124782f, -0.88559556f, -1.20325899f, -0.62507379f, 0.58059973f, -0.97712451f, -0.71036679f, -0.54157078f, 
    0.37824264f, 0.16400409f, -0.29686502f, 0.50723279f, 0.56158084f, 0.04438968f, 0.31641611f, 0.23975681f, 
    -0.17833149f, 0.16048460f, 0.59420550f, 0.21801054f, 0.30042902f, 0.73171341f, 0.32188982f, 0.09483691f, 
    0.43992481f, 0.37018391f, 0.82623047f, -0.59499872f, -0.37088981f, 0.76940769f, -1.05099273f, 0.75449461f, 
    0.70422190f, 0.64273596f, 0.44566220f, 0.63134778f, -0.29002872f, -0.01559771f, -0.11638330f, 0.57930481f, 
    0.36698991f, -0.34634492f, -0.00927629f, 0.45914692f, 0.20200036f, 0.13455883f, 0.05265380f, 0.01434452f, 
    0.14666320f, -0.26908603f, -0.45789436f, -0.60722017f, -0.23727266f, -0.64237553f, 0.52250159f, 1.44258261f, 
    -1.33617401f, -0.42944181f, 0.33927488f, 0.04270044f, 0.03083051f, -0.56198257f, 0.08632621f, 0.43060169f, 
    -0.22195555f, -0.12146661f, -0.41634431f, -0.42075405f, -0.16196384f, -0.04986010f, 0.17594226f, 0.06407442f, 
    0.01387137f, -0.26930994f, 1.77455628f, 1.15557408f, -0.24676752f, 0.61312538f, -0.23965839f, -0.39215699f, 
    0.22345631f, 0.59737831f, 0.79717284f, 0.42144945f, -0.45558196f, 0.06847357f, 0.39664990f, -0.17561795f, 
    -0.45582238f, 0.27985299f, 0.07780930f, -0.24550931f, -0.08708262f, 0.20097624f, 0.38256392f, -0.36309436f, 
    0.13415149f, -0.22559339f, 0.09724837f, -0.14853442f, -0.96632159f, -0.55950290f, 0.24680500f, 1.20705926f, 
    1.31871068f, 0.00662979f, -0.30479169f, 0.39832363f, 0.03611138f, -0.50278312f, 0.88368529f, 0.20935644f, 
    0.48029208f, 0.06618646f, -0.16047269f, 0.18353677f, 0.44566110f, 0.17023295f, -0.23400328f, 0.03125480f, 
    -0.35861415f, -0.13738997f, 0.01434287f, -0.07659496f, -0.93720609f, -1.59816253f, -0.86409128f, -0.43682271f, 
    -0.11162688f, -0.51805991f, 1.14545953f, 0.81927407f, -0.27588573f, 0.43634674f, -0.50070220f, -0.12443892f, 
    -0.27102137f, -0.58745450f, -0.25691485f, -0.13959971f, -0.12999792f, 0.16867930f, 0.17980985f, -0.14742005f, 
    -0.24322349f, -0.22694968f, -0.12838492f, -0.11514235f, 0.04840405f, 0.87238657f, -0.66039890f, -0.67040068f, 
    -0.81408447f, -0.67352051f, 0.10820537f, 1.13101614f, 0.67260462f, 0.81798118f, 0.50097811f, -0.06821736f, 
    0.25488544f, -0.66418886f, -0.17295189f, -0.23239084f, 0.03350234f, 0.31966659f, 0.04718136f, -0.01886734f, 
    -0.46539980f, 0.08749905f, 0.48505154f, 0.29362634f, -0.11482106f, -0.16920862f, -0.32240537f, -0.52825272f, 
    -0.92837065f, -0.11389655f, -0.59009767f, -0.69424057f, 0.40295824f, -0.36691019f, -0.79897976f, 0.16863532f, 
    0.22492178f, 0.06256133f, 0.27355376f, 0.77416134f, 0.56658959f, 0.21997714f, 0.43614188f, 0.95440590f, 
    0.40966052f, 0.26092938f, 0.31006828f, -0.35613650f, -0.35569826f, -0.29172352f, 0.20089030f, -1.32136297f, 
    -1.81111455f, -0.07553365f, 0.53645349f, -0.08803950f, 0.73688942f, 0.04318840f, 0.63758934f, 0.24883157f, 
    -0.53334349f, 0.19118744f, -0.06323873f, 0.15797037f, 0.89656174f, 0.27959594f, -0.13518116f, 0.24656256f, 
    -0.14636315f, -0.02054085f, -0.07304893f, -0.00713165f, 0.14510694f, 0.05467488f, -0.19373050f, -0.24282224f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32934272f, 0.24513125f, 0.44415811f, 0.32412267f, -0.02574385f, -0.04619126f, 0.34716922f, 0.43590096f, 
    0.12247042f, 0.59474576f, 0.70070237f, 0.36129215f, 0.20485413f, 0.26152590f, 0.13916828f, 0.57066053f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26598752f, -0.13001037f, 0.05754324f, 0.40451837f, -0.21034940f, -0.00607934f, -0.02914979f, 0.09345180f, 
    -0.01753177f, -0.01292489f, 0.00405441f, -0.05374343f, 0.41562176f, -0.08222593f, 0.02465417f, -0.61834979f, 
    0.10246734f, 0.09306382f, -0.14956045f, -0.02056490f, -0.08408047f, 0.18289483f, 0.02208188f, 0.11220826f, 
    0.15584041f, -0.09030652f, 0.00050377f, 0.39727026f, -0.22969852f, -0.21869260f, -0.04242980f, 0.14965351f, 
    -0.07544171f, -0.04041573f, -0.01036353f, -0.17642719f, -0.14673661f, -0.42713347f, -0.01198839f, 0.27923509f, 
    -0.05782658f, -0.00425956f, 0.02536428f, 0.10659942f, -0.13476510f, 0.20993015f, -0.15377043f, -0.30538914f, 
    1.10546160f, 0.30871764f, 0.13494802f, -0.29449993f, 0.16128471f, 0.04106060f, -0.12466349f, 0.18814741f, 
    0.19213298f, -0.10485443f, -0.11013483f, 0.05452262f, -0.17528611f, 0.03246927f, 0.46515915f, -0.36707410f, 
    -0.26812887f, -0.18201540f, 0.07908875f, 0.11343721f, 0.07987050f, 0.09209226f, -0.14794406f, 0.06969368f, 
    -0.01241651f, 0.24680881f, -0.20225795f, -0.11014070f, -0.38957497f, -0.19760941f, -0.11425634f, -0.00686190f, 
    -0.11327512f, -0.00215722f, -0.13340940f, 0.06503648f, -0.19426270f, 0.06782921f, 0.25976360f, -0.72382218f, 
    -0.25074437f, 0.09307922f, 0.10145566f, -0.08540143f, -0.14225054f, -0.12051938f, 0.00452967f, -0.04994128f, 
    0.42853442f, -0.19438621f, -0.06454840f, 0.03656585f, -0.01655779f, -0.04894292f, 0.00161840f, -0.14886840f, 
    0.03985748f, -0.01555903f, 0.15222853f, 0.08745778f, 0.10817204f, -0.27409083f, 0.41646826f, -0.21325670f, 
    -0.17188986f, -0.13887326f, -0.00610912f, -0.03431597f, 0.15288818f, 0.18047179f, 0.07127684f, -0.01110384f, 
    -0.10149070f, 0.07973595f, -0.30932909f, -0.00398640f, -0.20657289f, -0.12685439f, -0.05546879f, 0.12433929f, 
    -0.16877921f, -0.03472502f, 0.05166971f, -0.18005289f, -0.06817921f, -0.02620447f, 0.27589253f, 0.03437884f, 
    0.02862400f, -0.04305749f, 0.06958112f, -0.23957345f, -0.12523042f, 0.13869746f, 0.05592658f, 0.12739234f, 
    -0.26890674f, 0.16374120f, -0.01523092f, -0.48266003f, 0.11508530f, 0.09343549f, 0.08169199f, 0.29577771f, 
    0.07673895f, 0.04842765f, 0.01466872f, 0.11525188f, 0.01282771f, -0.02088112f, -0.05173811f, -0.45472383f, 
    0.11329500f, 0.03017622f, 0.06691065f, -0.25111756f, -0.22343257f, 0.08782092f, -0.00551108f, -0.08523864f, 
    -0.51700407f, -0.05218674f, -0.05769740f, -0.00319464f, 0.06334249f, -0.05012664f, 0.04323560f, 0.10343765f, 
    0.09014558f, -0.04400628f, -0.04754085f, 0.09390476f, -0.47904336f, -0.10276777f, -0.07272891f, 0.11241066f, 
    0.27005288f, 0.15870212f, -0.16600740f, 0.12403392f, 0.14285320f, -0.19293755f, -0.11329725f, -0.09374329f, 
    0.55226839f, -0.21983704f, 0.23060861f, 0.01219470f, 0.20027219f, 0.04822763f, -0.15470552f, -0.10263600f, 
    0.17685767f, 0.30711904f, -0.10835049f, 0.08632131f, -0.17011379f, -0.27476439f, 0.10260464f, -0.45967185f, 
    0.15028033f, -0.21499166f, 0.16598728f, 0.15729144f, 0.12718162f, 0.14353672f, -0.07802912f, -0.24114643f, 
    0.35771784f, -0.18574497f, 0.41173059f, 0.39260730f, -0.17989694f, -0.03145873f, 0.01824441f, 0.01854854f, 
    -0.11822306f, -0.03709093f, 0.06035376f, -0.00267068f, -0.10000306f, 0.10877189f, -0.10761561f, -0.31361946f, 
    0.17859711f, -0.03765731f, 0.17191395f, 0.06818461f, 0.08145303f, -0.55771667f, -0.03480006f, -0.13292976f, 
    -0.59870881f, -0.17068960f, -0.26108506f, -0.29765564f, -0.05632079f, -0.09218797f, -0.09913642f, 0.16717815f, 
    0.22386098f, 0.09647456f, -0.03066657f, 0.00930421f, 0.18294509f, -0.08763673f, -0.02188995f, -0.07866851f, 
    -0.12007450f, 0.08603809f, 0.02004400f, 0.02395696f, 0.06791607f, 0.11137272f, 0.22505176f, -0.07825974f, 
    -0.01747175f, 0.05040769f, -0.12840982f, 0.18892926f, -0.01953897f, -0.05289820f, 0.10499433f, 0.06765371f, 
    -0.02558656f, -0.08339596f, -0.14080806f, 0.14263585f, -0.18429083f, -0.46819067f, 0.01751168f, -0.56001031f, 
    -0.08417942f, -0.30498248f, 0.09502644f, -0.06637706f, -0.19999424f, 0.22822019f, 0.16608538f, -0.01569328f, 
    -0.35351712f, 0.01752549f, 0.20620109f, -0.14727464f, -0.04284516f, -0.15826204f, 0.07684407f, -0.13617063f, 
    -0.00312768f, 0.05470590f, 0.22819847f, 0.02612961f, -0.08419599f, -0.00046745f, -0.42917556f, -0.11475445f, 
    -0.04094249f, -0.16204794f, 0.11688477f, -0.04882785f, -0.28081551f, -0.09082282f, -0.19497558f, -0.13359441f, 
    0.63584280f, -0.00810291f, 0.20269585f, 0.26250097f, -0.10097469f, -0.34559605f, -0.06935758f, 0.09733798f, 
    -0.11606176f, -0.07305285f, -0.15429379f, 0.07727084f, 0.56019795f, -0.33905351f, -0.09230823f, -0.05038615f, 
    -0.12523131f, -0.14907211f, -0.28422904f, 0.02535651f, -0.15184997f, -0.15159793f, -0.00916941f, -0.04811287f, 
    0.31873015f, -0.20852390f, -0.12617196f, -0.11804785f, 0.04445005f, -0.04886407f, -0.09023600f, -0.10723938f, 
    0.07326039f, -0.04946075f, -0.21589999f, -0.06500294f, 0.49125817f, -0.33947551f, 0.02725016f, -0.15249698f, 
    0.20591484f, -0.00178665f, -0.09791905f, -0.15623011f, 0.17097718f, 0.00972851f, -0.15317686f, -0.08719184f, 
    0.18802780f, 0.05471415f, -0.13174768f, 0.26350874f, -0.06300034f, 0.06822456f, -0.21960559f, 0.03670675f, 
    0.03219094f, 0.02838023f, 0.16156429f, 0.17627999f, 0.12040313f, 0.33963832f, -0.29211372f, 0.33116153f, 
    -0.17070065f, 0.07690734f, 0.22286507f, 0.04508674f, -0.13270687f, -0.03435446f, -0.04391899f, 0.10309269f, 
    0.21413045f, -0.27500221f, -0.15360981f, -0.15201619f, -0.05664991f, -0.11090511f, 0.09157975f, 0.15217972f, 
    0.01143048f, -0.01972994f, -0.07392617f, 0.00975076f, -0.75477821f, 0.41219857f, -0.09497306f, 0.22011900f, 
    0.10670494f, -0.23113891f, 0.10955779f, -0.17150654f, -0.23439337f, -0.14037989f, -0.14930528f, 0.03307302f, 
    0.13119479f, -0.24886551f, -0.15426280f, -0.15223435f, 0.32167050f, -0.11879215f, -0.00623516f, -0.17370370f, 
    -0.05244882f, 0.05969982f, 0.06207189f, -0.01725657f, -0.88905060f, -0.52528751f, -0.19168121f, -0.46924561f, 
    0.09665417f, -0.11427575f, -0.38698202f, -0.34842148f, 0.04493844f, 0.26995656f, -0.13189182f, 0.13403380f, 
    0.67152816f, -0.11600278f, -0.11250131f, 0.25695518f, -0.11296740f, 0.00165165f, -0.13396132f, 0.11998662f, 
    -0.11609551f, 0.08900821f, 0.09575655f, -0.15280873f, 0.07359947f, 0.11067858f, -0.04290241f, 0.01424577f, 
    0.10413793f, 0.14181949f, 0.10433584f, -0.23619336f, 0.01139270f, 0.17049596f, -0.14536574f, -0.34624544f, 
    -0.47997800f, 0.18931323f, 0.01306096f, -0.51383770f, -0.11219952f, -0.03151939f, 0.23695891f, -0.14799772f, 
    -0.04479023f, 0.19688340f, -0.01271249f, 0.02365676f, -0.68022537f, 0.23352158f, 0.15473391f, -0.46672288f, 
    0.02651994f, 0.29741991f, 0.02813500f, 0.03893278f, -0.08973789f, -0.09513236f, -0.10424943f, 0.02158814f, 
    0.05517754f, 0.27733356f, 0.07257410f, 0.15713876f, -0.20046470f, -0.03727740f, 0.05421969f, -0.09110321f, 
    -0.18375982f, -0.05431577f, 0.09666134f, -0.16879772f, 0.59353936f, -0.43012455f, 0.23560883f, -0.54948324f, 
    0.18913159f, -0.07015698f, -0.01892980f, 0.12075394f, 0.17214039f, -0.17724454f, 0.14094940f, 0.01697886f, 
    0.24957721f, 0.17205076f, -0.22997272f, -0.05355322f, -0.01637145f, -0.02320674f, 0.18293662f, 0.04318977f, 
    -0.18430093f, 0.10048296f, 0.02210728f, -0.19860883f, -0.03599905f, -0.16883053f, 0.50532693f, 0.08756544f, 
    0.04792549f, 0.13391598f, -0.08071270f, 0.13760512f, -0.24605410f, -0.10814361f, -0.02097343f, 0.01812904f, 
    0.61479026f, 0.01707692f, -0.21770695f, 0.51173109f, -0.18461011f, -0.00824596f, 0.04346696f, 0.13416901f, 
    0.01759581f, 0.18557067f, 0.07482582f, 0.02807831f, 0.00750591f, 0.10938876f, 0.17475395f, 0.30320045f, 
    -0.09769075f, -0.41158286f, 0.11043506f, -0.02301187f, -0.01039328f, -0.18679743f, -0.01352069f, 0.01129605f, 
    0.72072810f, -0.08133798f, -0.34790978f, -0.05720844f, -0.08989488f, 0.01858276f, 0.27957422f, -0.15361600f, 
    -0.38204885f, -0.05733046f, -0.08886094f, -0.17199919f, 0.15134466f, -0.17343846f, -0.06604958f, -0.01091481f, 
    -0.35317066f, -0.01625733f, -0.27425608f, -0.10473087f, 0.23220785f, -0.10439683f, -0.03177628f, -0.06687973f, 
    -0.53229058f, 0.37976274f, -0.50516206f, -0.16683125f, 0.01772965f, -0.11059731f, 0.09504973f, -0.24608228f, 
    0.04586534f, -0.08771844f, 0.17015947f, -0.31551695f, -0.05767638f, 0.00117635f, 0.34111989f, -0.31269619f, 
    -0.08998305f, -0.00559280f, 0.03487552f, -0.10273197f, -0.09639360f, 0.12698723f, -0.21666574f, 0.10284496f, 
    0.25873575f, -0.76321363f, -0.49700356f, 0.14161691f, -0.11847343f, -0.00184772f, -0.02661099f, -0.04673447f, 
    0.03559719f, -0.22807004f, -0.05193457f, 0.09846561f, 0.54055661f, 0.31640568f, -0.02163536f, -0.12802669f, 
    -0.11947835f, -0.19851959f, -0.02482883f, 0.09510902f, -0.02513107f, 0.25146127f, -0.15174653f, 0.02577248f, 
    -0.59710848f, 0.68205470f, 0.01386913f, -0.39649507f, -0.17838462f, 0.07833165f, -0.01552628f, -0.05387414f, 
    0.06514643f, -0.18982926f, 0.00034886f, 0.03886927f, 0.30271459f, -0.60882705f, 0.01577559f, 0.56084985f, 
    0.10855391f, 0.05454520f, 0.19791482f, -0.14306507f, -0.11816953f, -0.25208354f, -0.33649230f, 0.02172712f, 
    0.16799119f, -0.78927428f, -0.37694803f, 0.40776578f, -0.12793727f, 0.20411272f, -0.02826700f, 0.05862874f, 
    -0.05989885f, 0.03328612f, -0.02716931f, 0.13242131f, 0.54311222f, 0.32077461f, 0.16981322f, 0.03581719f, 
    0.02686089f, -0.12275338f, -0.09934374f, 0.18199489f, 0.03296802f, -0.04081268f, -0.02334883f, 0.11713037f, 
    -0.70433676f, -0.19283025f, -0.06993580f, 0.00774953f, -0.01259581f, 0.00879439f, 0.07850026f, 0.17238760f, 
    -0.05582219f, 0.21454062f, -0.19601950f, 0.00955570f, 0.23405668f, -0.00085828f, 0.11025905f, 0.27364627f, 
    0.08408981f, -0.05445731f, 0.04586218f, -0.02178897f, -0.12502697f, 0.00063530f, 0.14944242f, 0.21686433f, 
    -0.06905799f, -1.20266771f, -0.47861987f, 0.04254795f, -0.24479304f, -0.21339272f, -0.14623924f, 0.08899617f, 
    0.12155668f, 0.08983500f, -0.06060917f, 0.08809786f, 0.11292976f, 0.21858516f, -0.37218329f, 0.12803762f, 
    -0.03915748f, -0.01299614f, -0.08253096f, -0.13567916f, -0.09028222f, -0.07036106f, 0.09713122f, 0.13895229f, 
    -0.06572442f, 0.03875469f, 0.10570137f, 0.01998538f, -0.13468659f, -0.21430591f, 0.11937457f, 0.06923353f, 
    -0.04276171f, 0.10611939f, -0.04583952f, -0.04902272f, -0.12040395f, -0.13737512f, -0.09964018f, 0.05603402f, 
    -0.22981271f, 0.22153276f, 0.06447455f, -0.07277026f, -0.17889039f, 0.11988568f, -0.12006538f, 0.09366705f, 
    -0.30104342f, -0.17791095f, 0.21095654f, -0.30054355f, 0.10160873f, -0.17088462f, 0.09973013f, -0.07514349f, 
    0.25342724f, 0.08690146f, -0.12375303f, 0.19123185f, 0.54937810f, 0.12744004f, -0.03189597f, 0.02577699f, 
    0.00910828f, 0.10460223f, -0.09052144f, 0.23737705f, -0.07977425f, 0.02625340f, 0.08363590f, 0.05398375f, 
    -0.10866716f, -0.12780030f, -0.32452717f, 0.28156373f, 0.09201252f, 0.15242495f, 0.23273630f, -0.09930801f, 
    -0.17953606f, -0.17879169f, 0.15450259f, 0.03937631f, -0.10876947f, -0.38016850f, 0.10621289f, 0.18102688f, 
    -0.10276388f, -0.18174483f, 0.25674245f, -0.00879155f, 0.02629886f, -0.07002085f, 0.08487834f, 0.25440234f, 
    0.54960120f, 0.21665753f, -0.01182228f, 0.14818558f, -0.35491014f, -0.09948222f, 0.07003981f, 0.06815625f, 
    0.00158088f, 0.06832943f, -0.06345776f, 0.10849068f, 0.16050594f, -0.16842510f, 0.17118861f, -0.21555765f, 
    0.16561362f, 0.11616928f, -0.02017976f, 0.20915791f, -0.02212470f, 0.17224298f, 0.09135704f, 0.12634844f, 
    -0.08627344f, -0.12003964f, 0.01074742f, 0.14094393f, 0.03361188f, 0.07166652f, 0.13901201f, -0.06038664f, 
    -0.15568636f, 0.03575293f, -0.01382158f, -0.21577963f, -0.67091841f, 0.11679611f, 0.20558245f, 0.10982653f, 
    0.04496589f, 0.13413717f, -0.19192685f, 0.20205243f, 0.03205960f, -0.29633510f, -0.10771173f, -0.09506662f, 
    -0.30310673f, -0.61692566f, 0.33360326f, -0.12843505f, -0.22816975f, 0.06173193f, 0.08608198f, -0.14395995f, 
    0.21954711f, 0.03460941f, -0.11771378f, -0.09427580f, 0.20712362f, -0.40520513f, -0.10995378f, 0.36827055f, 
    -0.05698785f, -0.01047046f, 0.00491922f, -0.04789880f, 0.04275480f, -0.06363223f, -0.19425222f, -0.08887249f, 
    0.39059576f, -0.27693614f, -0.27704504f, -0.28248847f, -0.14512770f, -0.02117985f, -0.27966103f, -0.07268884f, 
    0.10869835f, 0.04673320f, -0.03583953f, -0.08209241f, -0.91142160f, 0.15708137f, 0.31094304f, -0.04536127f, 
    0.04553187f, -0.06920671f, -0.12307299f, 0.07929371f, -0.07811933f, -0.08576877f, -0.15436588f, 0.13916130f, 
    0.29010978f, -0.33109549f, 0.22587049f, -0.06520080f, -0.18003790f, -0.03598937f, 0.23570089f, -0.12258370f, 
    -0.11141277f, 0.21615751f, -0.08942642f, -0.21869482f, -0.50704020f, 0.04594189f, -0.15739144f, -0.05787114f, 
    -0.05509304f, 0.00260024f, 0.32118338f, -0.00313453f, 0.22565810f, -0.07388993f, -0.15826675f, -0.12810250f, 
    -0.94566244f, 0.02841394f, 0.21746305f, 0.26341081f, 0.02847778f, 0.02383666f, 0.04399311f, -0.05686945f, 
    -0.03351567f, 0.09234526f, 0.10409880f, 0.17419900f, -0.63381255f, 0.05688158f, 0.25124466f, 0.05598978f, 
    -0.09921291f, 0.14986101f, -0.14694454f, 0.00596318f, -0.06025462f, 0.25208300f, 0.18469268f, -0.03648715f, 
    -0.09302854f, -0.07702527f, 0.58723074f, 0.25513086f, 0.13711263f, 0.12924850f, 0.01058095f, 0.21113545f, 
    0.25389728f, 0.08363803f, -0.08365250f, 0.05530595f, -0.45929441f, 0.33773944f, -0.27383444f, -0.33429196f, 
    -0.03787088f, 0.09502854f, -0.10215179f, 0.04513723f, -0.00989407f, -0.08998565f, -0.07482012f, 0.02778917f, 
    0.04866773f, 0.32280743f, 0.26604301f, -0.50033921f, -0.10806451f, -0.26818046f, -0.41748410f, -0.01577681f, 
    -0.03540028f, 0.15627728f, -0.12903272f, -0.12102089f, 0.51975936f, -0.55281270f, -0.14829966f, 0.04622169f, 
    0.12917387f, 0.10570462f, -0.20717700f, -0.14372154f, -0.01259734f, -0.07840139f, 0.19306186f, -0.08173149f, 
    -0.11613443f, -0.11973438f, 0.00343011f, -0.04976455f, 0.02173213f, -0.01070577f, 0.14923528f, 0.03641095f, 
    0.15465669f, 0.01523805f, -0.21233959f, 0.24428484f, -0.15857163f, -0.01644471f, 0.07150134f, 0.36246839f, 
    -0.13989162f, 0.36007932f, 0.03831901f, -0.05392425f, 0.14484607f, -0.29161462f, 0.16625129f, -0.02960731f, 
    -0.63693947f, -0.15998198f, 0.01486038f, 0.00007142f, 0.18148105f, 0.12830693f, 0.00631542f, -0.44202915f, 
    0.01460763f, -0.22458857f, 0.14879137f, 0.22083148f, 0.01591913f, -0.01158708f, 0.37555638f, 0.32857490f, 
    -0.04199651f, -0.00158899f, 0.15761913f, 0.01306826f, -0.22112133f, 0.12938285f, 0.22537479f, 0.38035861f, 
    0.50007290f, -0.08579733f, 0.16001438f, 0.05018254f, -0.05031748f, 0.12142690f, -0.26641744f, 0.20294616f, 
    -0.16286141f, -0.05036588f, 0.01399717f, -0.27899230f, -0.30712113f, -0.00326687f, 0.23135203f, 0.19129786f, 
    0.00948724f, -0.07546196f, 0.11202405f, 0.06163982f, 0.31495032f, 0.06757249f, -0.03358757f, -0.09371419f, 
    0.10713530f, 0.29674411f, 0.07226554f, 0.32000831f, 0.01941414f, -0.15318963f, -0.13472667f, -0.10514209f, 
    0.12607437f, 0.01581169f, -0.36851159f, 0.24015243f, -0.58443928f, -0.49809030f, -0.26760167f, -0.00661067f, 
    -0.01550289f, 0.13783105f, -0.10449734f, 0.18096423f, -0.09941087f, 0.01061954f, -0.12296531f, -0.19443701f, 
    0.24899206f, 0.12089602f, 0.20567687f, -0.04763997f, -0.07318335f, 0.21476413f, -0.27153298f, -0.15537994f, 
    -0.05692881f, -0.16160521f, -0.11761822f, 0.09962336f, -0.43568811f, 0.21827859f, 0.20072921f, -0.39229655f, 
    0.14010164f, 0.08205819f, 0.03513331f, -0.09686747f, 0.14125715f, 0.04978279f, 0.34182572f, -0.12751247f, 
    -0.11352600f, 0.27745673f, -0.59328085f, -0.32064444f, -0.02635362f, 0.06149863f, 0.02309225f, -0.01118072f, 
    -0.08412213f, -0.18607132f, -0.06948157f, -0.16922468f, 0.05515827f, -0.11891779f, -0.28795406f, -0.13790441f, 
    0.07767007f, 0.07617997f, 0.09129840f, 0.10358839f, 0.15734051f, -0.07098172f, -0.18840583f, 0.20230491f, 
    -0.29516590f, 0.08886735f, -0.20899262f, -0.06833322f, -0.03285036f, -0.06410112f, -0.27184361f, 0.08813708f, 
    0.06634396f, 0.11089937f, 0.30067441f, 0.19382931f, -1.23181224f, -0.44742993f, -0.06718317f, 0.00639456f, 
    0.18605947f, 0.11442383f, 0.08941415f, -0.06437042f, 0.09082801f, 0.16579381f, 0.05593344f, 0.06459688f, 
    -0.31510124f, -0.11488811f, 0.21199986f, -0.37272024f, -0.18444000f, 0.01188215f, 0.05470289f, 0.01223146f, 
    0.11768205f, -0.29523343f, 0.11118996f, 0.04505390f, -0.23905081f, 0.29577765f, -0.32728839f, 0.26456428f, 
    -0.14607099f, -0.03941149f, 0.22591695f, -0.26027563f, 0.09800039f, -0.04505987f, -0.06035159f, -0.18734787f, 
    -0.36785510f, 0.42318082f, -0.01840926f, -0.38722169f, 0.04939990f, 0.05299377f, -0.05572056f, 0.19415024f, 
    0.01613433f, 0.03858147f, 0.10732428f, -0.18346873f, 0.11730765f, -0.10575388f, -0.45414898f, -0.12022225f, 
    -0.13425848f, -0.25606003f, -0.11518782f, -0.06933814f, -0.02207622f, 0.35346100f, -0.12016872f, 0.11298364f, 
    0.03738255f, -0.21595736f, -0.23230998f, -0.06246703f, -0.06098559f, 0.09503162f, 0.11840843f, -0.03519377f, 
    -0.23195802f, 0.10547306f, -0.17261931f, -0.11763396f, 0.21031205f, 0.29995954f, -0.00460666f, -0.32032993f, 
    -0.07103337f, -0.02026754f, 0.10849456f, 0.06720582f, 0.08278321f, -0.17385386f, -0.07714987f, -0.27304494f, 
    -0.27396309f, 0.55393094f, 0.05169550f, 0.33163318f, 0.17367935f, -0.04818640f, 0.00775592f, 0.13987041f, 
    0.14617565f, 0.03819171f, -0.07158122f, 0.07133652f, 0.20980252f, -0.22229788f, -0.40078914f, 0.36300015f, 
    0.05070483f, 0.36491567f, -0.16424264f, 0.08655430f, -0.24396199f, -0.12402427f, 0.00603130f, -0.23397888f, 
    -0.84424150f, 0.24130194f, -0.21673273f, 0.46028578f, 0.00990887f, 0.11117531f, 0.18652256f, 0.04946446f, 
    -0.00136128f, -0.11501648f, 0.05203545f, -0.23360866f, 0.57243705f, 0.25985777f, -0.09830108f, 0.16177343f, 
    0.20623046f, 0.01451723f, -0.05740506f, -0.00730307f, -0.06529772f, 0.09299162f, 0.23074067f, 0.13407628f, 
    -0.63223684f, 0.59422541f, 0.33926183f, 0.22211753f, 0.17734611f, -0.02350755f, 0.15879495f, 0.09081896f, 
    0.14769478f, 0.02004756f, 0.25819331f, -0.03018640f, -0.27128267f, -0.55807173f, 0.07859648f, -0.35640666f, 
    -0.04065796f, 0.21334638f, 0.05138688f, -0.04547114f, 0.09060690f, 0.12326341f, -0.28516072f, 0.03217281f, 
    0.01699379f, -0.60247910f, -0.19910866f, -0.47633159f, 0.05488984f, 0.02307569f, 0.01328584f, 0.04425882f, 
    -0.04099250f, -0.10784636f, 0.19998372f, 0.36519000f, -0.23050296f, -0.00237275f, 0.03925344f, 0.12671271f, 
    0.17039670f, -0.17804609f, -0.19076388f, -0.08030755f, -0.03804831f, -0.07743647f, 0.34669742f, 0.15715005f, 
    -0.36703950f, -0.02590207f, 0.04184613f, 0.13474765f, -0.01781843f, -0.39526692f, 0.26802117f, 0.15327278f, 
    -0.10727502f, -0.08162437f, 0.02499361f, -0.16206177f, -0.08365618f, -0.59377372f, 0.29989094f, -0.24043442f, 
    -0.02659565f, -0.35239199f, 0.11627287f, -0.16450515f, -0.03642057f, 0.16511382f, -0.14513509f, -0.12506320f, 
    -0.41409817f, 0.13403349f, -0.10143452f, -0.24060863f, -0.11375824f, 0.01417235f, -0.16843461f, -0.17111970f, 
    0.09502672f, -0.04956284f, -0.14755830f, -0.17169085f, 0.36124417f, 0.41352558f, -0.60589737f, 0.49764374f, 
    0.14033855f, 0.16164067f, 0.16053787f, 0.18265207f, -0.02809100f, -0.07643303f, 0.01720660f, 0.07571816f, 
    -0.83241224f, 0.65692884f, -0.21801482f, -0.01781002f, -0.01640240f, -0.02694159f, 0.03296452f, -0.19954947f, 
    -0.23629616f, 0.12203592f, -0.10799335f, 0.04115456f, 0.02622386f, 0.17838666f, 0.14522831f, 0.35931781f, 
    0.10242449f, 0.06282926f, -0.13959983f, 0.01314506f, -0.15663509f, 0.20173600f, -0.03312267f, -0.26351306f, 
    -0.13833255f, 0.27062953f, 0.30141723f, -0.02216848f, 0.31596094f, -0.01077511f, 0.26525146f, -0.02062436f, 
    -0.08630247f, 0.08028452f, 0.16664575f, 0.09317598f, -0.33900774f, -0.07197616f, -0.15689608f, 0.21112847f, 
    0.02079736f, -0.21168841f, -0.04559515f, -0.15678474f, -0.08082655f, -0.05112371f, 0.01089525f, -0.07781292f, 
    -0.42971161f, 0.04643247f, -0.57522100f, -0.48705068f, -0.04633074f, 0.00854002f, -0.10442428f, -0.15351494f, 
    -0.20694122f, -0.21028061f, 0.07450616f, -0.18883069f, -0.31301481f, 0.38802314f, -0.03846754f, 0.41882730f, 
    -0.03073091f, -0.13820159f, -0.26605409f, -0.12700410f, 0.00364175f, -0.03588140f, 0.02224203f, -0.06997032f, 
    -0.18720306f, 0.01797191f, -0.08195816f, -0.21565129f, 0.07517866f, 0.02083169f, -0.07058831f, -0.02147525f, 
    0.02866923f, 0.11983740f, -0.20068941f, -0.20934585f, -0.11101891f, 0.41276121f, 0.04894326f, 0.21430656f, 
    -0.10952140f, -0.13067047f, -0.14573894f, 0.11036171f, -0.06063299f, -0.01919869f, -0.13911898f, 0.28272039f, 
    -0.21135212f, 0.20629857f, -0.09483594f, -0.50732207f, -0.10315926f, 0.06491519f, -0.04742630f, -0.17939311f, 
    -0.18906960f, -0.11441834f, -0.16565657f, -0.20061451f, -0.36209789f, 0.12955989f, -0.13529171f, -0.34408498f, 
    -0.20544347f, 0.05432026f, -0.04212622f, -0.04856251f, -0.11788709f, -0.02690478f, -0.19595121f, -0.10924081f, 
    0.35124016f, 0.12018921f, 0.28985688f, 0.16668008f, 0.04594313f, 0.24476746f, 0.16432054f, -0.17755695f, 
    -0.12976065f, 0.03279871f, -0.17903696f, -0.14580561f, -0.19353022f, 0.25584641f, 0.14565502f, 0.06995866f, 
    -0.02799212f, 0.22081718f, 0.04198055f, -0.02313380f, 0.00492524f, 0.13080037f, 0.03178006f, -0.16393760f, 
    0.31766930f, 0.26863161f, 0.22724573f, -0.06475276f, 0.07582471f, 0.12093755f, -0.07397821f, -0.21022519f, 
    0.00125121f, -0.04776421f, -0.01344025f, -0.03563150f, -0.11096951f, -0.08607922f, 0.09969775f, 0.18779521f, 
    0.12626453f, -0.02960370f, -0.06120813f, -0.10756879f, -0.19205585f, 0.12741995f, -0.03900248f, -0.18916304f, 
    0.39490560f, 0.17544568f, 0.10296808f, 0.24810278f, -0.14714192f, -0.13482094f, -0.20859277f, 0.04179775f, 
    -0.14604920f, 0.12093744f, -0.08927280f, -0.17259207f, -0.14020333f, 0.16745411f, -0.12690656f, -0.26767302f, 
    -0.21052150f, 0.25578699f, -0.26585549f, 0.08960705f, -0.07847362f, 0.04459446f, 0.08809090f, -0.19643936f, 
    0.01975006f, -0.25063303f, 0.41158137f, 0.31027278f, 0.16428417f, 0.17470556f, -0.06825218f, -0.09651755f, 
    0.11225842f, -0.25857347f, 0.06570296f, 0.12274346f, -0.62507343f, 0.01074369f, 0.07082094f, -0.36296538f, 
    0.09506459f, 0.03064745f, 0.05180620f, -0.06537517f, 0.06583814f, -0.34002972f, -0.00500024f, 0.12019494f, 
    -0.02571066f, -0.03077077f, 0.02904012f, 0.26936209f, -0.22799045f, 0.03363367f, -0.07390241f, -0.08337193f, 
    0.20916291f, -0.10515676f, -0.24793047f, 0.09688261f, -0.02387653f, -0.04679606f, -0.41599533f, 0.03462989f, 
    0.04148689f, -0.04214089f, -0.21657310f, -0.10461189f, -0.00189675f, -0.08176403f, 0.15036084f, -0.10266423f, 
    0.27577105f, -0.20712693f, -0.25574833f, -0.01791932f, 0.40020537f, -0.00949813f, -0.15620193f, 0.04145188f, 
    0.13422222f, 0.04640699f, 0.16289772f, -0.37002158f, -0.13439199f, 0.57733572f, -0.33968648f, -0.08361357f, 
    0.07800536f, -0.41645598f, -0.05521572f, -0.08182077f, 0.14718655f, 0.04115301f, 0.04039269f, 0.12030332f, 
    0.42673045f, 0.33904359f, -0.15103149f, 0.02934767f, -0.09926540f, -0.18644333f, -0.16553444f, -0.15085463f, 
    -0.05508350f, -0.17098601f, 0.02420817f, 0.45910752f, 0.20852081f, 0.19835722f, -0.21496919f, -0.14885914f, 
    -0.17672198f, -0.00980135f, -0.04239859f, -0.20558944f, -0.31295216f, 0.00340090f, 0.01138926f, -0.05369608f, 
    0.26476285f, -0.11731760f, -0.17052545f, 0.14654596f, 0.18722425f, -0.04482100f, -0.29600236f, -0.03861032f, 
    0.06251003f, 0.16708270f, -0.06293266f, 0.19177112f, -0.10498422f, -0.17913014f, -0.00844258f, 0.08260686f, 
    -0.41925320f, -0.14642613f, 0.08134305f, -0.08386973f, 0.13291062f, 0.11790155f, -0.00452837f, -0.02734222f, 
    -0.35308769f, -0.27978328f, 0.28676340f, -0.00353083f, -0.08192619f, 0.03300274f, -0.16881864f, -0.52949613f, 
    0.17431946f, 0.02700254f, -0.20358020f, -0.26960793f, 0.23889886f, 0.38877007f, -0.10790039f, 0.22938305f, 
    -0.40031576f, 0.09139799f, 0.02386598f, 0.35144123f, 0.22394083f, -0.18879475f, -0.26964346f, 0.06508996f, 
    -0.08983658f, -0.21718833f, -0.05710889f, -0.32088625f, -0.08232354f, -0.15717846f, -0.05674118f, -0.14610447f, 
    0.06765398f, 0.14448409f, 0.22560160f, 0.04450288f, -0.52493876f, -0.34541401f, 0.51762646f, -0.22768867f, 
    -0.02945103f, -0.20795359f, -0.01325264f, 0.14886056f, -0.08431783f, 0.07059344f, 0.06660880f, 0.03636219f, 
    -0.66064537f, 0.69164342f, 0.08531305f, -0.06690688f, 0.28616950f, 0.15190327f, 0.01833630f, 0.12474203f, 
    -0.13392088f, -0.00867953f, 0.08873768f, -0.02093307f, -0.29585430f, 0.41959271f, 0.34706825f, -0.05774644f, 
    -0.17423829f, -0.11800826f, -0.15436162f, 0.26282483f, 0.14987446f, -0.19139060f, -0.10817503f, 0.16409202f, 
    -0.66477138f, 0.64490616f, -0.30485332f, -0.72890347f, 0.05731973f, -0.02565162f, 0.00824939f, -0.25404623f, 
    -0.19356751f, -0.10783273f, -0.11712544f, -0.15984564f, -0.15294434f, -0.14436996f, 0.09022639f, 0.07873068f, 
    0.15279341f, 0.00335282f, -0.04248826f, 0.00538920f, -0.07189149f, -0.07197370f, 0.11193474f, 0.08152640f, 
    -0.00769125f, -0.93326700f, 0.21754327f, -0.02361909f, 0.10665414f, 0.05450239f, 0.04254182f, -0.00056354f, 
    -0.10678115f, -0.15472604f, 0.23199230f, 0.05618711f, -0.12067238f, 0.13437170f, -0.06813676f, -0.90995240f, 
    0.05151286f, -0.08397651f, -0.32070830f, 0.07401109f, -0.05170206f, -0.08301380f, -0.16621307f, -0.16551182f, 
    0.22884941f, 0.18137133f, 0.32021695f, -0.08998445f, 0.07384785f, -0.05143328f, 0.17366834f, -0.11523109f, 
    -0.01871966f, -0.02426705f, -0.01451998f, 0.03558362f, -0.13189438f, -0.02659007f, 0.42553174f, -0.12687069f, 
    -0.02518328f, 0.09424736f, -0.03986311f, 0.13423294f, -0.01188331f, -0.35268044f, -0.04420229f, 0.18598559f, 
    0.42084137f, -0.31049606f, 0.17420077f, -0.28384879f, 0.07910340f, 0.07467704f, 0.19597909f, 0.11559861f, 
    -0.02539302f, -0.16419427f, 0.13145334f, -0.14671996f, -0.91107452f, 0.09144536f, -0.04115276f, -0.01973618f, 
    -0.00764123f, 0.17522101f, -0.25407401f, -0.11439835f, 0.29913047f, 0.19814812f, 0.16721228f, -0.11867816f, 
    -0.43133765f, -0.01336324f, 0.09018585f, -0.00567356f, 0.09918066f, 0.08727419f, 0.11829769f, -0.14779928f, 
    0.17161727f, -0.05029540f, 0.14340752f, 0.03266365f, -0.15382111f, 0.53155339f, -0.35377559f, 0.26587328f, 
    0.16978402f, -0.08389118f, -0.18088308f, -0.16560787f, 0.10560129f, 0.15952526f, 0.01951965f, 0.14013177f, 
    0.28124392f, -0.55643791f, -0.02778588f, 0.07479693f, 0.04431087f, -0.02657633f, 0.04632349f, 0.00235643f, 
    -0.19454670f, -0.01655784f, 0.06714287f, -0.08051726f, -0.12574995f, 0.15442695f, -0.03625011f, 0.23676065f, 
    0.14679655f, 0.09586474f, -0.04420234f, 0.19813775f, -0.18967620f, 0.21149001f, 0.03566862f, -0.05910804f, 
    -0.65412056f, -0.10121602f, -0.08879153f, -0.19053446f, 0.09442854f, 0.01517232f, 0.25350660f, -0.14080155f, 
    -0.11549748f, -0.04805354f, -0.34662533f, -0.43353358f, 0.92080736f, 0.04016195f, -0.19735663f, 0.07280582f, 
    0.17429775f, -0.05497530f, -0.07941397f, 0.00374198f, -0.03982228f, -0.09129386f, -0.08180896f, 0.03523325f, 
    -0.00309136f, -0.52481842f, -0.26255259f, -0.00267134f, 0.02281532f, -0.05491390f, 0.17059608f, -0.06899176f, 
    0.19147411f, -0.02393978f, -0.13999963f, 0.14422059f, -0.26667544f, -0.20496267f, 0.19189903f, 0.07970461f, 
    -0.07463320f, 0.02816601f, -0.11493400f, 0.12139392f, 0.09686179f, 0.16610071f, -0.15242092f, -0.35047400f, 
    -1.01039040f, -0.60479629f, -0.17717972f, -0.40898284f, 0.05270584f, 0.03177032f, 0.15177087f, 0.07392857f, 
    0.23552348f, 0.09141525f, 0.16002104f, 0.20229235f, 0.18225937f, 0.00828702f, 0.02751339f, 0.07867267f, 
    0.10973202f, 0.23017243f, 0.01489741f, 0.03197988f, -0.01143396f, -0.15918353f, 0.44199497f, -0.03889463f, 
    -0.01066661f, 0.24410108f, -0.12424706f, 0.08249504f, -0.28656390f, -0.13335831f, 0.01852623f, -0.09432945f, 
    -0.07378604f, 0.13177589f, 0.14441974f, -0.00511733f, -0.32439241f, -0.28863055f, -0.04747776f, -0.65364814f, 
    0.17295781f, -0.10754748f, -0.11117693f, 0.02747619f, 0.20806637f, 0.05618482f, 0.11946367f, 0.02167706f, 
    -1.25963855f, 0.04972648f, 0.16543050f, 0.40403658f, 0.24610500f, 0.19313322f, -0.17686215f, -0.03434709f, 
    -0.10763570f, -0.04389187f, -0.12414679f, 0.05383956f, -0.22867772f, 0.10801775f, -0.25616392f, 0.01695155f, 
    0.37855616f, 0.20161888f, 0.01281572f, -0.20168871f, 0.06797478f, 0.32203710f, 0.15736626f, 0.08228878f, 
    -0.57270640f, -0.14421649f, -0.06452776f, -0.01395785f, 0.23489647f, -0.02237181f, 0.04964191f, 0.00867631f, 
    -0.03111106f, 0.16403222f, -0.09513069f, 0.33597860f, 0.17934379f, 0.08183883f, -0.32329088f, 0.14275083f, 
    0.14570257f, -0.09576038f, 0.21730620f, 0.10714445f, 0.06884434f, -0.15004475f, -0.04742883f, -0.12181547f, 
    -1.38301170f, -0.67580342f, -0.15957233f, -0.31140485f, 0.20030607f, -0.03352391f, -0.17201678f, -0.13588482f, 
    0.10596558f, -0.06037572f, 0.17011158f, 0.44589373f, 0.43119588f, 0.33398017f, -0.21938038f, 0.21099368f, 
    0.09099842f, -0.28811231f, 0.08550552f, 0.19886635f, -0.20185202f, -0.00683560f, 0.13688929f, -0.07643325f, 
    0.49765143f, -0.11594523f, -0.07573261f, 0.00634490f, -0.06332572f, -0.03236493f, -0.09663351f, 0.04752796f, 
    -0.07480161f, -0.01423166f, -0.20156243f, -0.26217651f, 0.19972308f, -0.06104878f, 0.02428086f, -0.15177245f, 
    -0.34453011f, -0.15227149f, 0.39031896f, 0.00858980f, 0.28013763f, -0.21731049f, 0.03144035f, -0.30222893f, 
    0.24841574f, -0.11955807f, -0.17179550f, -0.19468251f, -0.15414488f, 0.26687318f, -0.31162798f, -0.03625437f, 
    -0.22652471f, 0.22058070f, 0.29994440f, 0.04534496f, 0.43624654f, -0.00448787f, -0.04236221f, 0.19823807f, 
    -0.00650866f, -0.19212393f, 0.21807013f, 0.02684353f, -0.06267458f, 0.07504264f, 0.03044290f, -0.16193677f, 
    -0.37144342f, -0.50301230f, -0.23720004f, -0.16078205f, 0.15523240f, 0.18006346f, 0.21535528f, 0.08344723f, 
    -0.23869999f, -0.06938745f, 0.04278151f, -0.00618619f, 0.07959781f, -0.06065348f, -0.11959176f, 0.25470498f, 
    0.04202752f, 0.01715340f, -0.15172371f, -0.16768080f, -0.05204548f, 0.03597630f, -0.00185090f, 0.07212500f, 
    0.30753887f, -0.42669964f, -0.12508811f, -0.17752485f, 0.11949108f, 0.05599541f, -0.09920179f, -0.19632605f, 
    0.06694366f, -0.04540931f, -0.13506486f, -0.14422053f, 0.07282660f, -0.27585182f, -0.19394799f, 0.13225342f, 
    -0.44946140f, 0.02557753f, 0.08931102f, -0.14362428f, -0.10566416f, -0.00462048f, -0.27653363f, -0.10924587f, 
    -0.26131323f, -0.18069340f, 0.02922599f, -0.01774706f, -0.20451230f, -0.04396549f, -0.16554387f, 0.18776388f, 
    -0.29462671f, 0.08356872f, -0.11634973f, -0.14267197f, 0.57198417f, -0.24882504f, -0.77902228f, 0.54792106f, 
    -0.08052507f, -0.05123505f, 0.18572299f, 0.03226360f, -0.02748437f, 0.09620840f, 0.02955185f, 0.06380267f, 
    0.78814149f, 0.41198316f, -0.04678383f, -0.17770512f, -0.04303780f, -0.32823071f, -0.13043422f, 0.20868497f, 
    0.26334357f, 0.06971890f, 0.08382957f, 0.18039373f, 0.46365467f, -0.46758926f, -0.47452638f, 0.35886681f, 
    0.20252672f, -0.10243642f, -0.44572470f, -0.12354310f, 0.03211008f, 0.18444079f, -0.12462850f, 0.08507410f, 
    -0.18384790f, -0.65646613f, 0.04665799f, -0.21059741f, 0.01333479f, 0.32752404f, -0.05827597f, 0.19269940f, 
    -0.07593615f, -0.01731524f, -0.08473785f, -0.16269217f, 0.56731218f, -0.33446926f, -0.11168530f, 0.27410400f, 
    0.19508441f, 0.14236701f, 0.09695975f, -0.20243467f, 0.07355759f, -0.15322916f, 0.05018428f, -0.17604698f, 
    -0.32809758f, 0.45193720f, -0.42874226f, -0.13721791f, 0.14052537f, 0.27095598f, -0.07439926f, 0.07563470f, 
    0.05145888f, -0.04550320f, 0.03382842f, -0.10218304f, 0.32184041f, -0.18342611f, 0.19429252f, 0.31267956f, 
    0.09807401f, 0.01436162f, 0.02749073f, 0.40334883f, -0.03348288f, 0.22831935f, -0.05055407f, 0.10612243f, 
    -0.43828395f, 0.40777072f, -0.03174250f, 0.16115981f, 0.01404522f, -0.11355252f, -0.00929325f, 0.04101246f, 
    0.09982972f, -0.02854766f, 0.11268299f, -0.03455113f, -0.51600558f, 0.22606128f, 0.09450726f, -0.17033914f, 
    0.10324772f, -0.09326038f, 0.05828683f, 0.03887624f, -0.23754165f, -0.12868713f, -0.04393887f, -0.15926562f, 
    0.35434088f, 0.16251668f, -0.25641701f, 0.10818941f, -0.03846199f, 0.20971699f, -0.05944556f, -0.04125690f, 
    -0.07900299f, -0.42723671f, -0.36240011f, -0.31355038f, 0.04800019f, 0.01867847f, 0.29576951f, -0.14846466f, 
    0.00575981f, 0.00042174f, -0.07249558f, -0.19025372f, 0.05017278f, -0.07553319f, 0.30154037f, 0.11815910f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20184734f, 0.06869520f, 0.00099124f, 0.11506305f, 0.07355206f, 0.01418539f, 0.06510196f, -0.17427650f, 
    -0.11679275f, -0.05593290f, 0.25217557f, 0.04245105f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
