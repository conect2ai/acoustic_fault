#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.35935447f, 0.56364113f, 0.52572894f, -0.34484941f, 0.00214863f, 0.22906590f, 0.39299783f, 0.01724088f, 
    -0.30482322f, -0.43198216f, 0.97891557f, -0.49380767f, -0.53004974f, -0.12542370f, 0.61776459f, 0.10074156f, 
    -0.35663912f, 0.03430765f, -0.55949503f, -0.61163819f, -0.29237482f, 0.39650196f, 0.19123532f, 0.31458256f, 
    0.12964764f, 0.22378375f, 0.28953159f, 0.58487785f, -0.56787264f, -0.81964034f, 0.11561687f, 0.06168021f, 
    0.35816714f, 0.41536206f, -0.19224589f, 0.29473251f, 0.98713028f, -0.21604441f, 0.08137202f, -0.34693208f, 
    -0.22449160f, -0.25429481f, 0.24169049f, 0.32101944f, 0.20848897f, 0.18013239f, 0.32759580f, 0.31134370f, 
    0.29916731f, 0.25495487f, 0.53276724f, 0.07260849f, -0.03086450f, 0.28520405f, 0.24333337f, -0.63420278f, 
    0.82597679f, 0.24911369f, -0.35407296f, -0.26276496f, 0.25713000f, -0.19495590f, -0.10716524f, 0.26411578f, 
    -0.54987955f, 0.49863046f, -0.27321759f, 0.15077055f, 0.16664167f, 0.33521608f, -0.13306823f, -0.39500749f, 
    -0.22996998f, -0.15833654f, 0.20215863f, 0.29500824f, 0.11166319f, -0.32424110f, 0.14886826f, 0.37029302f, 
    0.43501198f, 0.37215209f, 0.43176714f, 0.13994041f, -0.72752398f, 0.20671704f, 0.34390929f, 0.05886853f, 
    -0.00716147f, -0.11626634f, -0.00134385f, -0.08002077f, 0.00008667f, 0.43080088f, 0.78139639f, -0.44308642f, 
    -0.56766570f, 0.07854751f, 0.52927649f, 0.60914266f, 0.56727147f, 0.34036651f, -0.49746636f, 0.14191192f, 
    0.09521043f, -0.34974658f, -0.03529710f, 0.12484277f, 0.40422848f, 0.45023903f, -0.77135080f, -0.17999870f, 
    -0.39178139f, -0.13692890f, -0.25908867f, -0.51969332f, -0.46967313f, 0.60362297f, -0.58928126f, -0.65693784f, 
    0.14033934f, 0.47429296f, 0.57414001f, -0.08860186f, -0.24680203f, -0.39393035f, 0.03728396f, 0.22446387f, 
    -0.15899715f, -0.31564426f, 0.79016131f, -0.67445570f, -0.09659732f, -0.20961437f, -0.08065526f, -0.74647236f, 
    -0.49425277f, -0.33423272f, 0.73210728f, -0.17927521f, -0.03092560f, -0.08288442f, -0.40288505f, -0.52886438f, 
    -0.65214634f, -0.01556320f, -0.45794663f, -0.15909868f, -0.13779432f, 0.23401849f, 0.27013120f, 0.09442057f, 
    0.57458711f, 0.16559038f, 0.49784425f, -0.15805273f, 0.52307916f, -0.28847286f, -0.15559386f, 0.19176623f, 
    0.52365661f, -0.51528609f, 0.26398748f, 0.17440099f, -0.00537007f, -0.12346224f, 0.01025840f, 0.44523504f, 
    -0.30006951f, 0.42774856f, -0.49375194f, 0.69543827f, 0.76738071f, -0.62578899f, -0.02124760f, -0.31495208f, 
    -0.00659068f, -0.01738643f, 0.11536735f, 0.09993610f, -0.75126743f, -0.30585504f, 0.19398166f, -0.40939170f, 
    0.56454557f, -0.53510404f, -0.23156275f, 0.23189303f, -0.12235612f, -0.01137106f, -0.34903261f, 0.54486543f, 
    -0.01354935f, 0.20727852f, -0.09119217f, 0.24932860f, 0.14498354f, 0.33703980f, -0.05465471f, 0.03403870f, 
    0.05853436f, -0.01243622f, 0.59594494f, 0.54507309f, 0.22751573f, -0.48343134f, -0.04672305f, -0.24812704f, 
    0.09244795f, -0.09794674f, -0.65252972f, -0.59277201f, 0.10631040f, 0.29138306f, 0.38390291f, -0.31935239f, 
    0.81520653f, -0.39096811f, -0.19393677f, 0.05045466f, -0.00854040f, 0.20196119f, -0.39011613f, 0.51042318f, 
    -0.00144354f, -0.34890527f, 0.28822660f, 0.55355644f, 0.05900495f, 0.22319666f, -0.20122668f, -0.20970088f, 
    -0.32341155f, -0.32511184f, -0.16920407f, -0.37697384f, -0.19142193f, -0.56269413f, -0.59937549f, -0.54636371f, 
    0.48117194f, 0.18361732f, 0.09465236f, 0.40800232f, 0.11662365f, -0.09760763f, -0.29872832f, -0.40122744f, 
    -0.65773350f, -0.12980014f, -0.51268739f, 0.04610154f, -0.50129509f, -0.51477402f, -0.25173929f, 0.47485653f, 
    0.44043711f, -0.77962017f, 0.22902186f, -0.42133379f, -0.33087125f, -0.46678710f, 0.57112962f, -0.56565922f, 
    0.50640833f, -0.48458752f, -0.29734215f, -0.09701100f, 0.34009862f, 0.32069165f, -0.81707400f, 0.70754522f, 
    -0.53306955f, 0.13281652f, 0.64926100f, 0.24973923f, 0.22080725f, 0.04497677f, -0.20048292f, 0.05938349f, 
    0.31058818f, 0.31574643f, -0.33841112f, -0.51141405f, -0.25916848f, -0.05837706f, 0.45890284f, 0.63216275f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.25753269f, -0.14231083f, 0.15300319f, -0.13399655f, -0.02175282f, 0.16257407f, 0.01224828f, -0.03173391f, 
    0.29972726f, 0.37416381f, -0.17922373f, -0.12696537f, -0.01532633f, 0.03854281f, 0.25258356f, 0.04430183f, 
    0.12544346f, -0.17994452f, 0.06000301f, 0.35754550f, -0.22822133f, 0.08527632f, 0.19047150f, -0.02211374f, 
    0.29117522f, 0.17979626f, -0.26152298f, -0.33923778f, 0.20791927f, 0.20169324f, 0.07375876f, -0.07919668f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.11091762f, 0.15796761f, -0.09068877f, -0.03462968f, 0.21493153f, 0.05917387f, 0.07726982f, -0.10519428f, 
    0.13024157f, 0.12115359f, 0.14388868f, -0.22848696f, -0.30905625f, 0.12360901f, 0.09114432f, 0.19023477f, 
    0.02062455f, -0.02926613f, 0.28203189f, 0.13329771f, 0.02923966f, -0.00514548f, -0.10320039f, 0.01705992f, 
    0.03545144f, 0.03941076f, 0.02700689f, 0.05534829f, 0.00489169f, 0.10685562f, 0.05081854f, 0.01376615f, 
    -0.08242430f, 0.06631448f, 0.04312950f, 0.01022945f, -0.27412978f, 0.02423533f, 0.13860168f, 0.02343904f, 
    0.05157820f, 0.12735313f, 0.00610347f, -0.07677853f, -0.08351339f, 0.06687021f, 0.03420519f, -0.00981225f, 
    -0.14599793f, -0.12168927f, -0.32503974f, 0.00961006f, 0.11523067f, 0.12017343f, -0.05905533f, -0.11211133f, 
    0.02361636f, 0.18181255f, 0.00613290f, -0.03056713f, 0.05332753f, -0.07251524f, -0.02294331f, -0.22634821f, 
    -0.00087687f, -0.09885003f, -0.05755628f, 0.04214194f, -0.10866281f, 0.04069632f, -0.19181015f, 0.13656545f, 
    0.03686730f, 0.04336051f, -0.12688212f, -0.03125346f, -0.11306543f, 0.00889011f, 0.09361865f, 0.04456025f, 
    0.00751695f, -0.13974826f, 0.13594450f, -0.11613573f, -0.10995295f, -0.01301866f, 0.01294333f, -0.05723527f, 
    0.00295637f, -0.08497677f, 0.16826016f, 0.19055386f, 0.05728485f, -0.20411915f, -0.27692345f, -0.10763782f, 
    -0.06913236f, -0.05745170f, 0.01876740f, -0.02475894f, 0.09728747f, -0.06988806f, -0.00641411f, 0.06840736f, 
    0.02983355f, -0.00393829f, 0.10933679f, -0.07280690f, -0.09964770f, -0.12695223f, -0.03076241f, -0.01659251f, 
    0.02364515f, -0.00187882f, -0.10990777f, 0.02280063f, 0.16632472f, 0.11450543f, -0.00665993f, 0.02689176f, 
    0.02694825f, 0.01557690f, 0.08117537f, -0.01415262f, 0.08245994f, 0.06720132f, -0.17631978f, -0.04187229f, 
    -0.11667659f, -0.09076034f, -0.16829114f, 0.00524975f, -0.02448962f, -0.09096637f, -0.02270217f, 0.22775044f, 
    -0.06931666f, -0.29481259f, -0.06402979f, -0.06742740f, -0.03415686f, -0.06398988f, 0.08079801f, 0.04386431f, 
    0.46179584f, 0.00450196f, -0.10378364f, 0.04770523f, -0.10757426f, -0.07993603f, 0.06456596f, 0.03885950f, 
    0.01934457f, -0.08745932f, 0.11245667f, 0.13683495f, -0.14256646f, 0.04904241f, -0.01302140f, 0.01097837f, 
    -0.09313302f, 0.11168358f, 0.03602401f, 0.16305301f, 0.05441235f, 0.01303728f, -0.00610557f, -0.01725074f, 
    0.09179820f, -0.07834899f, 0.14143921f, -0.14541373f, 0.13635980f, 0.05202971f, -0.02992114f, -0.01042445f, 
    0.03727358f, -0.00071299f, 0.05062606f, -0.23268172f, 0.57151061f, 0.00258479f, -0.17960618f, 0.15116639f, 
    -0.00575679f, 0.01059233f, 0.03546415f, -0.00995742f, 0.01237697f, 0.00034881f, 0.02715264f, -0.07294304f, 
    -0.02625225f, -0.05218733f, -0.00833738f, 0.14397874f, 0.00818195f, 0.03448198f, 0.02205938f, 0.19744171f, 
    0.13430485f, -0.35040414f, -0.39286041f, -0.26625058f, 0.01302686f, 0.21056466f, 0.14448602f, 0.21745302f, 
    0.12609290f, 0.03024032f, 0.06127203f, -0.18590429f, -0.05000325f, -0.03838697f, -0.00383688f, 0.09558525f, 
    -0.24779254f, -0.02285694f, 0.07570117f, 0.02269018f, 0.02827352f, -0.03656475f, -0.01356562f, -0.06771029f, 
    -0.07095753f, 0.13711014f, 0.12118725f, 0.01639245f, 0.06224211f, 0.03263539f, -0.10264871f, 0.07327557f, 
    0.11563135f, 0.18178004f, 0.41219628f, 0.19833216f, 0.20888771f, -0.03661838f, -0.11496804f, -0.20092882f, 
    -0.09156787f, -0.02215508f, 0.11388075f, 0.04415759f, 0.42589280f, 0.21091864f, -0.09375305f, -0.02880361f, 
    -0.04503463f, 0.02784435f, 0.00021508f, 0.19731720f, 0.14008245f, -0.17142519f, -0.41202313f, -0.06422704f, 
    -0.09014394f, -0.09391908f, -0.08157713f, -0.06357836f, -0.05253154f, 0.08656213f, 0.06866748f, -0.20537017f, 
    -0.07211811f, 0.00583655f, 0.01148428f, 0.05250249f, -0.04551597f, 0.09535369f, 0.06083879f, 0.03148673f, 
    -0.03080284f, -0.28313515f, -0.12327839f, -0.08715082f, -0.04217163f, 0.05142489f, 0.07669698f, -0.00469336f, 
    0.27528492f, 0.10166144f, 0.15287679f, 0.01183971f, 0.07877641f, 0.05255167f, 0.04074202f, -0.02183744f, 
    0.04802803f, 0.02320919f, 0.00190579f, -0.01512564f, -0.06051582f, -0.01736106f, -0.01956844f, -0.06217325f, 
    -0.06216928f, -0.00468138f, 0.01099971f, -0.06862954f, -0.04361949f, -0.02758657f, 0.01794578f, 0.04717132f, 
    -0.02670032f, 0.02632165f, 0.01817583f, 0.01223936f, -0.03386185f, -0.01062018f, 0.00720928f, 0.01004806f, 
    -0.01033352f, 0.03982601f, -0.02053518f, 0.02601629f, -0.05973252f, -0.06546228f, -0.02058707f, 0.01877786f, 
    0.02891032f, -0.05227716f, -0.01277511f, 0.00118945f, -0.03939497f, -0.03170167f, -0.04431441f, -0.01623186f, 
    0.04743743f, -0.06542610f, -0.05899005f, 0.04556327f, 0.00720723f, 0.04817349f, -0.06747835f, -0.01527259f, 
    0.01426207f, 0.00662251f, -0.04415414f, 0.00225052f, 0.04679812f, 0.04056338f, -0.01097955f, -0.02739244f, 
    -0.05863193f, 0.04352694f, 0.04404038f, -0.03785833f, -0.02830698f, 0.00750291f, 0.01360291f, -0.03716322f, 
    0.02089817f, -0.06194327f, 0.00085847f, -0.04962346f, -0.01130251f, -0.06770451f, -0.02441994f, -0.04167303f, 
    0.01327412f, 0.00420823f, -0.06731933f, 0.04697679f, 0.02647062f, -0.00152233f, 0.03623625f, -0.01461036f, 
    -0.02365935f, -0.05492240f, 0.04340687f, -0.01089215f, -0.03895335f, 0.02194241f, 0.02993351f, -0.05766562f, 
    -0.00988785f, 0.04653002f, -0.02917850f, -0.00556740f, -0.05254947f, 0.05052437f, 0.01931202f, -0.00341668f, 
    -0.06269811f, 0.03146194f, -0.00498071f, -0.03765245f, -0.01082883f, 0.03624194f, 0.04724984f, 0.04392219f, 
    -0.04414169f, -0.02477694f, 0.01358397f, -0.01940610f, -0.00324484f, -0.06481713f, 0.02222338f, 0.05145875f, 
    -0.03743717f, 0.00991184f, -0.02920930f, 0.01831984f, 0.05086379f, -0.00852359f, -0.04322487f, -0.03380460f, 
    0.04886339f, -0.03733619f, -0.05182248f, -0.01281856f, -0.00684718f, 0.01045520f, -0.02793468f, -0.06437611f, 
    0.01261666f, -0.01542737f, -0.02171536f, 0.02832272f, 0.00435350f, -0.04719616f, -0.06202629f, -0.05481176f, 
    -0.04187272f, 0.00325463f, -0.02004705f, 0.00406742f, -0.01529847f, 0.04766629f, -0.01396445f, -0.03259411f, 
    -0.04278405f, -0.03886521f, -0.01136862f, -0.05378745f, 0.00776061f, 0.04580946f, 0.01974160f, 0.03590046f, 
    0.01840283f, -0.05098316f, 0.00483363f, -0.03530842f, 0.00297745f, -0.01257788f, 0.02095280f, 0.01648535f, 
    0.04521140f, 0.04355302f, -0.06335357f, 0.04709655f, 0.00160780f, -0.05850577f, -0.03466251f, -0.03033595f, 
    0.02461605f, 0.04217101f, -0.05585846f, -0.01300457f, -0.01353436f, 0.04791120f, 0.04581481f, 0.01162905f, 
    0.03392843f, 0.04429678f, 0.03348476f, -0.05549718f, -0.01878309f, -0.04653805f, 0.02625778f, -0.01976036f, 
    -0.00831843f, 0.04381653f, -0.04688674f, -0.04072095f, -0.00964808f, -0.01995985f, -0.00512332f, -0.04300032f, 
    0.01611553f, 0.00749278f, -0.05959261f, -0.00041303f, 0.00223047f, -0.06471098f, -0.00396351f, -0.00088503f, 
    -0.01892873f, -0.05372341f, -0.02553220f, 0.04503663f, -0.00322943f, -0.05177401f, 0.02335713f, -0.03424163f, 
    -0.05945031f, 0.02316077f, 0.04981939f, -0.00063438f, 0.04599250f, 0.00605989f, -0.02750673f, -0.06065046f, 
    -0.01699911f, -0.05816869f, -0.06195605f, 0.04506369f, -0.03591188f, -0.02719624f, 0.04621882f, 0.04712809f, 
    0.02509879f, 0.01496155f, -0.05585095f, -0.05890648f, 0.00843166f, -0.03310604f, -0.03973626f, -0.03519464f, 
    -0.05455095f, -0.04342226f, -0.05258109f, 0.03414134f, 0.03303443f, -0.01088017f, 0.04468802f, -0.00722557f, 
    0.04791345f, 0.03311131f, 0.04575758f, 0.04202214f, -0.04381751f, 0.00579314f, -0.04473434f, -0.06013216f, 
    -0.00985770f, 0.03952304f, 0.02164806f, -0.01369864f, -0.00858994f, 0.00117145f, 0.00592885f, 0.00237825f, 
    0.03463932f, -0.06608151f, -0.02929602f, 0.01163285f, -0.00473144f, -0.01264178f, 0.00005272f, 0.03130140f, 
    0.05231861f, -0.06310673f, -0.00902653f, 0.02951140f, 0.02310116f, -0.05351904f, 0.04447731f, -0.01464852f, 
    0.00878757f, -0.01400164f, -0.06038933f, -0.04167783f, 0.01565542f, -0.06107587f, -0.02699045f, -0.05382592f, 
    -0.05761248f, -0.06729557f, 0.02423624f, 0.02085379f, -0.00866555f, 0.01648371f, 0.03858316f, -0.02244855f, 
    -0.09323263f, -0.30367669f, 0.13279313f, 0.09713969f, 0.13413456f, -0.06859769f, -0.00742609f, 0.05513922f, 
    0.10901041f, -0.42312169f, -0.07928073f, -0.08731870f, -0.06949050f, -0.17858289f, 0.05589515f, -0.04511672f, 
    0.06425025f, -0.14016843f, -0.14387125f, -0.21393010f, -0.16626984f, 0.01587677f, 0.14954008f, 0.18960498f, 
    0.08678966f, 0.03746277f, 0.11843598f, 0.17823212f, -0.20066006f, -0.42280084f, -0.00007621f, 0.05955288f, 
    0.03790841f, 0.10049559f, 0.23298658f, -0.09844853f, 0.05174317f, 0.06282932f, -0.16006920f, -0.15271908f, 
    -0.02752287f, -0.05900037f, 0.08892283f, -0.02678828f, 0.10094450f, -0.06972156f, -0.22388522f, -0.25383809f, 
    -0.05734621f, 0.12707429f, 0.04956654f, -0.10195622f, 0.02458043f, -0.01474962f, 0.02158592f, 0.00289492f, 
    -0.39311671f, 0.10218342f, -0.01416419f, -0.05664048f, -0.02815498f, 0.02400854f, 0.00662230f, -0.04636324f, 
    -0.13316295f, 0.01217289f, -0.00754021f, 0.05911866f, -0.12995452f, -0.14231950f, 0.10474103f, 0.00981316f, 
    -0.10653470f, 0.03036836f, 0.00555708f, -0.02060254f, 0.09093975f, 0.15249757f, 0.00134056f, 0.06471758f, 
    0.02090032f, 0.02189555f, -0.27297050f, 0.09441983f, -0.14767003f, 0.00525233f, -0.06904837f, -0.01837301f, 
    0.03244062f, 0.04557265f, -0.26476663f, -0.43697447f, -0.09017232f, 0.00558420f, 0.11286868f, 0.03638015f, 
    0.10427873f, -0.08049411f, 0.05782333f, 0.17445302f, -0.22688262f, -0.08233075f, 0.10357639f, 0.12092754f, 
    -0.07621122f, 0.11351069f, 0.13286842f, 0.10716224f, 0.13663284f, 0.24496013f, 0.11436278f, 0.12313049f, 
    -0.09717846f, -0.05202207f, 0.06057048f, -0.08145437f, -0.12941681f, 0.38755757f, -0.11604655f, 0.00249517f, 
    0.04539361f, -0.05091682f, 0.00599281f, 0.10700801f, 0.03533797f, -0.03860993f, 0.08696073f, -0.06366444f, 
    -0.00336912f, -0.10240814f, -0.12857956f, 0.00372972f, 0.05141276f, 0.16632664f, -0.00097406f, 0.18552621f, 
    0.13746598f, 0.09285555f, 0.10732824f, 0.06935704f, 0.09098888f, 0.09586212f, 0.02058135f, 0.10657264f, 
    -0.02790129f, 0.05908301f, -0.02300540f, 0.10240786f, 0.07047088f, 0.16361344f, 0.05296121f, -0.01850858f, 
    -0.06110094f, -0.14514652f, 0.01872914f, -0.19053188f, 0.02899939f, -0.02235374f, -0.13098916f, -0.01761211f, 
    0.14079176f, 0.10298903f, 0.09435908f, -0.04187197f, -0.02431564f, -0.07010742f, -0.00761589f, -0.12211574f, 
    0.02750410f, 0.17110503f, 0.00337462f, 0.08619537f, -0.29023045f, -0.35299709f, -0.11285320f, -0.05918758f, 
    0.01412456f, 0.04035637f, -0.02393189f, 0.09129364f, 0.27398169f, 0.00261104f, 0.12710845f, -0.05175929f, 
    0.09526373f, 0.16742954f, 0.15750375f, 0.08056516f, -0.09386702f, -0.11817878f, 0.04304794f, -0.18989973f, 
    0.04340394f, 0.02107781f, 0.17147699f, 0.02959773f, 0.03587338f, -0.06625879f, -0.31441694f, -0.26253936f, 
    -0.20449328f, -0.00841856f, -0.03686677f, 0.04751540f, 0.18119900f, 0.09996279f, 0.04436299f, -0.01436394f, 
    0.08296934f, 0.19661440f, 0.02681783f, 0.03637901f, -0.17327476f, 0.01325354f, 0.06760475f, -0.06807301f, 
    0.16391902f, -0.08223062f, -0.19232766f, -0.04876309f, 0.20021984f, 0.03481041f, 0.10480654f, 0.02591760f, 
    0.07866980f, -0.23866254f, -0.06206979f, -0.00254101f, 0.02913561f, -0.04682596f, -0.07900648f, 0.07338420f, 
    0.05435365f, -0.05438046f, 0.15677099f, 0.37474918f, 0.28943488f, -0.07299454f, -0.05898426f, -0.10462556f, 
    0.11246695f, -0.05253614f, 0.06627480f, -0.02752716f, 0.14687096f, 0.04637166f, 0.15019821f, -0.03265635f, 
    -0.07344816f, 0.05016515f, -0.01789270f, 0.03594323f, 0.25318035f, 0.06008273f, 0.00917356f, 0.04197035f, 
    0.03246887f, 0.15103774f, 0.08570418f, 0.02230117f, 0.04634192f, 0.11204411f, 0.14283094f, -0.06559228f, 
    -0.09119771f, 0.05288197f, -0.05410091f, -0.09137610f, -0.11328556f, -0.02558430f, -0.54863572f, -0.14589001f, 
    -0.28095672f, 0.02661366f, -0.03437170f, -0.10802952f, -0.03046666f, 0.08757274f, 0.07873218f, 0.23263039f, 
    -0.07363613f, -0.09236693f, -0.13778272f, 0.07641307f, -0.00551139f, 0.04018288f, 0.01731807f, 0.11547776f, 
    0.11977625f, 0.05894059f, 0.22173820f, 0.22093727f, 0.02517339f, 0.03378302f, -0.10591157f, -0.06990203f, 
    0.03174647f, -0.72966516f, -0.33447227f, 0.27637434f, -0.08219923f, -0.04985606f, 0.03879506f, 0.06439655f, 
    -0.10014617f, 0.09637838f, 0.25832337f, 0.10494740f, -0.00862075f, -0.02182204f, 0.03354655f, 0.13706285f, 
    -0.10796256f, -0.02414958f, -0.05733274f, 0.41682115f, -0.19783315f, -0.34644803f, -0.05908079f, -0.11788932f, 
    0.02827725f, 0.00445507f, -0.00232239f, -0.06609346f, -0.14594017f, -0.00567442f, -0.03599427f, -0.22520858f, 
    -0.00662223f, -0.07212181f, 0.02535190f, 0.05568005f, 0.18083863f, 0.14192922f, -0.20916295f, -0.61268145f, 
    -0.31012112f, -0.06959705f, 0.11465798f, 0.02338473f, 0.06944872f, -0.02265228f, 0.05060740f, -0.70391935f, 
    -0.46383774f, -0.20763503f, -0.00253176f, 0.01288934f, -0.00801847f, -0.02148370f, -0.03443768f, -0.06092047f, 
    -0.52610338f, -0.04033759f, -0.13900547f, 0.03938628f, 0.05569408f, -0.13302328f, 0.03091844f, -0.09793398f, 
    0.02882331f, 0.15052202f, 0.09015567f, -0.04535707f, -0.02385580f, 0.07795285f, 0.02086477f, 0.05132360f, 
    0.10570463f, -0.05412931f, -0.08938517f, 0.09013018f, -0.02156485f, -0.10564884f, -0.04979417f, -0.07600567f, 
    0.04382445f, -0.03465148f, -0.13783377f, -0.01804126f, 0.42650208f, 0.04002892f, 0.06017223f, 0.03453504f, 
    0.03840966f, 0.07902645f, 0.11744471f, 0.13033026f, -0.25222817f, -0.09403872f, 0.03207719f, -0.34592104f, 
    -0.00574559f, -0.22338411f, 0.14744762f, -0.11252545f, 0.04634166f, 0.28685993f, 0.17650567f, 0.04403858f, 
    0.04215609f, 0.00643437f, 0.01096189f, -0.01172120f, 0.05992082f, 0.37653720f, 0.05251801f, 0.07648712f, 
    0.05543488f, -0.11796457f, 0.02913842f, 0.06525685f, -0.07495239f, 0.04151287f, -0.12201412f, -0.17060825f, 
    -0.02718495f, 0.01470563f, -0.02459220f, -0.09805555f, 0.18982099f, 0.03741391f, -0.11933221f, 0.22591327f, 
    0.16122656f, 0.21868071f, -0.01634462f, 0.08321495f, 0.13440292f, 0.03532878f, 0.12640046f, -0.02718525f, 
    0.10595042f, 0.17277236f, 0.04958321f, -0.02574071f, 0.07704137f, -0.11985859f, -0.01616614f, 0.08138556f, 
    0.10392435f, 0.14655161f, -0.50413984f, -0.02562952f, -0.30168641f, 0.01817577f, 0.17864114f, -0.22763595f, 
    0.01167964f, 0.01833032f, 0.21227731f, -0.01431133f, -0.09692221f, 0.02665485f, -0.08631404f, -0.01152920f, 
    0.03732089f, -0.00273803f, -0.01745261f, -0.32356790f, -0.40939575f, -0.50260806f, -0.00433608f, -0.18391170f, 
    -0.04812331f, -0.06861441f, 0.07000496f, -0.06514175f, 0.35151169f, 0.04454663f, 0.20852917f, 0.02577153f, 
    -0.01386191f, 0.22073665f, -0.04309814f, 0.04961244f, -0.04316663f, -0.06632223f, -0.08199277f, -0.42164138f, 
    -0.10572383f, 0.01218509f, 0.25977710f, 0.10305730f, -0.00966176f, 0.11940112f, -0.31559595f, 0.08125346f, 
    0.22790900f, -0.17781164f, -0.03719684f, 0.02755636f, 0.00792778f, 0.06592425f, -0.02805317f, 0.00855182f, 
    0.11580589f, 0.14560992f, -0.04921480f, 0.04701062f, -0.14130734f, -0.02460291f, 0.10924450f, 0.09964909f, 
    0.37353680f, -0.19082338f, -0.12967722f, -0.01629640f, -0.16597277f, -0.06811847f, -0.08424772f, -0.03140717f, 
    -0.14189300f, -0.39454278f, -0.31649864f, -0.15410532f, -0.05443429f, -0.12683536f, -0.21743695f, 0.14201663f, 
    -0.02075477f, -0.12820950f, 0.16662152f, 0.29909337f, 0.26673424f, -0.08123216f, 0.03235728f, -0.09523528f, 
    -0.03624443f, 0.02173719f, 0.08233063f, 0.16624112f, 0.21406385f, 0.08848836f, -0.06458481f, -0.04511283f, 
    -0.13595416f, 0.00331154f, -0.06190406f, 0.07904313f, 0.25134242f, 0.11085440f, 0.10252439f, 0.09520235f, 
    -0.00090106f, 0.05573625f, -0.02039300f, 0.04960167f, -0.08709551f, 0.04052221f, 0.12224589f, -0.09953068f, 
    -0.00038985f, -0.10768780f, -0.02811084f, -0.01744513f, 0.03474573f, -0.03103227f, -0.72682315f, -0.31996712f, 
    0.16224973f, -0.02954923f, -0.10265472f, 0.00483167f, -0.03153975f, -0.10619248f, 0.06241017f, -0.09042736f, 
    -0.00006271f, 0.01969895f, -0.04255515f, 0.13050006f, -0.17479098f, 0.07101298f, -0.00739131f, 0.05238831f, 
    -0.14316502f, 0.09150903f, -0.20585921f, 0.02229705f, 0.07079812f, -0.16145040f, -0.11781099f, -0.00115730f, 
    -0.27913684f, 0.26857439f, 0.46332350f, 0.26707175f, 0.22263591f, -0.02544579f, 0.14136328f, -0.17412615f, 
    0.11185712f, -0.17167476f, 0.05623060f, -0.09918509f, -0.07336938f, 0.15352450f, 0.05742061f, 0.03205686f, 
    -0.02009173f, -0.20047979f, 0.07566855f, -0.09099801f, -0.17920509f, -0.01237940f, 0.09739111f, 0.15733008f, 
    0.00065938f, -0.13244115f, -0.19414112f, 0.07206294f, -0.09094831f, 0.12697971f, 0.25397429f, -0.02644755f, 
    -0.00052736f, -0.07846138f, 0.10169091f, 0.03140075f, 0.07247132f, -0.20615019f, -0.11404860f, -0.11968253f, 
    0.03687722f, 0.00746391f, -0.00411496f, -0.13886254f, -0.02444808f, -0.04024708f, -0.00146162f, 0.36792216f, 
    0.09677640f, 0.24718167f, -0.07526551f, -0.04947218f, 0.00495091f, 0.01644060f, 0.04526126f, 0.16061370f, 
    0.25849187f, 0.11026867f, 0.03905556f, 0.04575702f, -0.03780962f, -0.01500502f, 0.00065077f, -0.31059766f, 
    -0.02561365f, 0.06952187f, -0.10212103f, 0.08058221f, -0.14132912f, -0.14603166f, 0.07496522f, 0.07128868f, 
    0.09124024f, -0.24385399f, -0.02518377f, -0.02422021f, 0.00218619f, 0.11211975f, 0.01015590f, -0.12994981f, 
    0.08150280f, -0.17689916f, -0.26776516f, -0.14515193f, -0.08526862f, 0.13932088f, 0.04709885f, 0.09044904f, 
    0.13074037f, -0.00427005f, 0.03990000f, -0.06233981f, 0.08180568f, 0.04207509f, -0.07014246f, 0.12592959f, 
    -0.01868425f, -0.06994236f, -0.00145399f, -0.04777931f, -0.05292039f, 0.20819926f, -0.03657062f, 0.08219762f, 
    -0.03341199f, -0.02202519f, -0.13443127f, 0.08196359f, -0.28399009f, -0.04143360f, -0.10460170f, -0.12191524f, 
    0.12285581f, 0.21069169f, 0.00013974f, -0.22219735f, -0.12982394f, -0.21838360f, -0.02882448f, 0.18352278f, 
    -0.12210682f, -0.10879540f, -0.07753655f, 0.10783225f, -0.06660213f, 0.15284288f, 0.01046554f, -0.04012200f, 
    -0.01308113f, -0.19049515f, 0.11099423f, -0.07311706f, -0.01665054f, -0.11181003f, -0.09208584f, -0.09447830f, 
    0.13927706f, 0.05561055f, 0.19806311f, -0.10444814f, -0.11360449f, -0.20992610f, -0.03844986f, -0.03626273f, 
    0.21839121f, -0.03396163f, 0.06415004f, -0.15092205f, 0.15581834f, 0.11863905f, -0.13836934f, 0.17256574f, 
    0.18651822f, -0.11685035f, -0.24768549f, -0.20781776f, -0.03353944f, -0.02969407f, 0.15208828f, 0.08863125f, 
    -0.11843666f, 0.00388244f, -0.03201119f, -0.24361032f, 0.13722351f, 0.12543586f, 0.13299818f, 0.09321979f, 
    -0.07391739f, -0.03930115f, 0.20102961f, -0.06327777f, -0.08262964f, 0.07562044f, 0.20780687f, 0.11746947f, 
    0.09816531f, -0.13248637f, 0.16920562f, 0.19274414f, 0.27605894f, 0.02978530f, 0.12708639f, 0.01500053f, 
    0.07438119f, -0.15168388f, -0.05502099f, 0.02945706f, 0.03341716f, 0.12722258f, -0.03097583f, -0.13395646f, 
    -0.16341551f, 0.04089425f, -0.03155283f, 0.11399952f, -0.08258367f, -0.09305172f, -0.22570416f, -0.03880864f, 
    -0.01230062f, -0.00133264f, 0.12084604f, 0.10312277f, 0.11324036f, 0.03873794f, 0.11175603f, 0.00411941f, 
    -0.06920431f, -0.15328120f, 0.14535281f, 0.20586973f, 0.11370774f, -0.01476468f, -0.00633459f, -0.14085580f, 
    0.05514756f, -0.04026951f, 0.04251910f, -0.11779632f, -0.06135378f, -0.01626091f, 0.05187079f, -0.20772123f, 
    -0.10307731f, -0.08778577f, -0.00831810f, 0.11289478f, -0.15695079f, -0.00515212f, 0.04993768f, 0.12729985f, 
    0.04696776f, 0.00241370f, 0.00122713f, -0.14373893f, -0.22436313f, 0.23109223f, 0.10307318f, 0.09275216f, 
    -0.09031015f, -0.13662364f, -0.04735685f, 0.08653398f, -0.01167175f, -0.02278826f, -0.21728945f, 0.04420858f, 
    -0.11977529f, 0.16065744f, -0.09495132f, 0.08318698f, -0.13905381f, 0.02873780f, 0.36153170f, 0.08912962f, 
    0.05791910f, 0.13174720f, 0.02423372f, 0.07479161f, 0.18740565f, 0.15676449f, -0.07890829f, 0.25946128f, 
    0.13848579f, 0.04976675f, 0.08484438f, -0.01978628f, -0.08047735f, 0.16387379f, -0.06659015f, -0.10985398f, 
    0.07534968f, -0.01774569f, -0.01998368f, 0.17137088f, 0.09819628f, 0.22422758f, 0.03841706f, 0.13445188f, 
    -0.22710112f, -0.10359583f, 0.14106360f, 0.06054100f, 0.08036533f, 0.02390292f, -0.00562299f, 0.04406752f, 
    -0.12704034f, -0.01413899f, 0.07412886f, 0.04670159f, 0.03110274f, -0.01756971f, 0.09723945f, 0.15002026f, 
    0.09282292f, 0.17285864f, -0.02737174f, 0.02588314f, -0.03826521f, -0.03897971f, 0.05728686f, -0.01971402f, 
    0.05416482f, 0.12789463f, 0.05380052f, -0.16347709f, 0.09091683f, 0.30720437f, -0.08057997f, -0.05891458f, 
    -0.05115709f, -0.02015596f, 0.18561266f, 0.03385685f, -0.16374949f, -0.09524529f, 0.27323616f, -0.20166709f, 
    0.10725319f, 0.21551616f, -0.00877992f, -0.02271624f, 0.04882532f, -0.03129633f, 0.05518218f, 0.11983547f, 
    0.05145085f, -0.02692617f, 0.00434962f, -0.10599942f, 0.06574003f, 0.03530473f, -0.32084414f, -0.02344006f, 
    0.32674915f, 0.01705999f, 0.03238741f, -0.14210981f, 0.08601964f, 0.01708270f, -0.05204010f, 0.11304663f, 
    0.00830298f, 0.01524009f, -0.04886732f, 0.03569975f, -0.04546499f, 0.02333874f, 0.01558277f, 0.03374186f, 
    0.09299687f, -0.04803351f, 0.07231165f, -0.02850346f, 0.13582556f, -0.01370488f, -0.03461555f, 0.00688045f, 
    0.08770125f, -0.38880041f, -0.00026681f, -0.03511815f, 0.10463253f, -0.05737600f, 0.00203254f, -0.01888375f, 
    0.13332018f, 0.13057569f, 0.08179622f, 0.00574215f, -0.15622871f, -0.06078640f, -0.16899039f, 0.02365977f, 
    0.09662801f, -0.00606232f, 0.03637043f, -0.37001014f, -0.22818306f, 0.04632276f, 0.12430178f, -0.03490661f, 
    -0.01073653f, -0.03224984f, 0.14238249f, 0.05940033f, -0.08583588f, -0.13192357f, 0.20453559f, 0.17333572f, 
    -0.08736825f, -0.02647323f, -0.03818705f, -0.05244452f, -0.13215557f, 0.27164793f, -0.12300218f, 0.08842384f, 
    0.06305701f, -0.15657882f, -0.00143339f, 0.08214169f, 0.03311744f, -0.10875389f, -0.01054905f, 0.09798386f, 
    0.00873984f, -0.00575412f, -0.10768248f, -0.11157440f, -0.00084356f, 0.03629000f, 0.15130241f, 0.27790597f, 
    -0.07155661f, 0.08759636f, 0.00707202f, 0.08873545f, -0.05337218f, 0.07683796f, -0.03986426f, 0.12142101f, 
    0.19176121f, 0.08631366f, 0.11671752f, 0.00394451f, 0.10652273f, -0.01329702f, -0.05453860f, 0.07260830f, 
    -0.05152148f, -0.12953231f, 0.05910888f, 0.29155686f, -0.09439260f, 0.07998022f, -0.08240162f, -0.03525838f, 
    0.01662303f, 0.08361574f, -0.15331221f, -0.00922962f, -0.01100110f, 0.11299949f, -0.23472477f, 0.05553420f, 
    -0.05337937f, 0.19236645f, 0.15961690f, -0.28379282f, -0.07082948f, 0.19117358f, 0.06336365f, 0.01629006f, 
    0.08923484f, -0.06180124f, 0.12493471f, 0.04553607f, 0.42570511f, 0.20870741f, -0.00496114f, 0.07455400f, 
    0.06474328f, 0.03051173f, 0.05044694f, -0.03238981f, -0.03568735f, 0.05507846f, 0.03891969f, 0.09496620f, 
    0.00149537f, 0.02322176f, -0.03440252f, 0.01280425f, -0.08789939f, -0.00848726f, -0.00695056f, 0.08911517f, 
    0.03593225f, -0.11102464f, -0.14911816f, -0.02456244f, -0.05833757f, 0.01521165f, -0.05902362f, 0.29294056f, 
    -0.07864411f, -0.06357739f, 0.04487718f, -0.13423128f, 0.05041645f, -0.02238310f, -0.03413684f, -0.06270987f, 
    -0.05443914f, -0.11020184f, 0.06091692f, -0.04052442f, -0.00909261f, -0.00524386f, 0.10555313f, 0.22264847f, 
    0.05070783f, -0.05912403f, 0.19447713f, -0.03634664f, 0.08880302f, 0.11815646f, 0.00599083f, 0.12898634f, 
    0.02236702f, -0.01271121f, 0.15107869f, -0.13135996f, 0.22577143f, 0.09847443f, -0.10613176f, 0.04712509f, 
    -0.15689512f, -0.10062736f, -0.11979911f, -0.07898970f, 0.11779720f, 0.23834106f, -0.01986158f, 0.02438692f, 
    0.00183129f, -0.16469665f, 0.07209641f, -0.11241610f, 0.27407092f, 0.00652951f, 0.00541606f, 0.02089739f, 
    -0.07158712f, -0.03120124f, -0.04499502f, 0.00382361f, 0.12507020f, 0.22350484f, -0.07050256f, 0.16734004f, 
    0.03425945f, 0.12337495f, 0.08993442f, -0.13249484f, 0.09100315f, -0.09515833f, -0.03312110f, 0.06080092f, 
    0.12641279f, -0.21501713f, 0.03213449f, -0.00260033f, -0.15720424f, -0.15711373f, 0.06278349f, 0.11205996f, 
    0.21432157f, -0.04028158f, -0.09970191f, 0.08612841f, 0.03755990f, -0.11158171f, 0.01520681f, -0.18787540f, 
    0.09233431f, -0.06477547f, -0.30093402f, -0.01929741f, 0.06673478f, -0.13048068f, -0.06820443f, -0.13344926f, 
    -0.07639914f, -0.41941497f, -0.13885799f, -0.47628707f, -0.02017874f, -0.10340892f, -0.05354513f, 0.06003417f, 
    0.12505403f, 0.11133384f, -0.08730843f, 0.32903278f, 0.37479484f, -0.03175074f, 0.01998176f, -0.09595128f, 
    -0.07781260f, -0.19450521f, 0.08452012f, 0.11635116f, 0.27115288f, 0.12760685f, 0.09540689f, -0.09733263f, 
    -0.14569205f, 0.02303082f, -0.00106642f, -0.04625522f, 0.30848622f, 0.03258871f, -0.33915254f, -0.04260616f, 
    -0.00055905f, -0.05271807f, -0.01537480f, -0.02613132f, -0.09855608f, 0.01220093f, 0.05864235f, 0.09941708f, 
    -0.03616491f, 0.07825322f, 0.07228452f, 0.02388780f, 0.01504894f, 0.06062935f, 0.09113950f, -0.22878508f, 
    -0.09189907f, -0.03706467f, -0.08717325f, -0.03347156f, 0.15177800f, 0.01694928f, -0.03001216f, 0.00844398f, 
    0.05633106f, -0.30821714f, -0.01754353f, 0.01124263f, -0.02795357f, 0.17258902f, -0.12078266f, 0.23508629f, 
    0.00776881f, -0.04812558f, 0.07737074f, -0.08718166f, -0.04042934f, -0.07020567f, 0.00730385f, -0.00462978f, 
    -0.04172262f, 0.03124368f, 0.05882027f, -0.19220783f, 0.07023976f, 0.15532549f, 0.06028842f, 0.09159316f, 
    0.12410949f, -0.00314763f, -0.13366231f, -0.09523713f, 0.12310728f, -0.02254229f, 0.01884679f, 0.01798524f, 
    0.00664671f, 0.13328204f, 0.14014032f, -0.17795983f, -0.06912892f, -0.18918683f, -0.08126217f, 0.07312594f, 
    -0.04127201f, -0.13246122f, -0.01668101f, -0.13352048f, -0.09293226f, -0.23667608f, -0.10889249f, 0.03966685f, 
    0.02215485f, 0.05623578f, 0.04622442f, 0.11788524f, 0.00689579f, -0.02176645f, 0.07070846f, 0.14739455f, 
    0.07331306f, -0.01567136f, 0.04105733f, 0.24445283f, 0.06697327f, 0.15945458f, -0.06122223f, -0.28572327f, 
    -0.02726316f, 0.20437150f, 0.17236972f, 0.20066407f, 0.02743704f, 0.03550792f, -0.02983980f, 0.15451054f, 
    -0.08435155f, 0.24629427f, -0.00900806f, -0.02171907f, -0.00948479f, 0.07896409f, 0.18349797f, 0.21598427f, 
    -0.22142676f, 0.34571031f, 0.12382226f, -0.17464019f, 0.17539315f, -0.16043004f, -0.04188009f, -0.12349226f, 
    -0.03240352f, 0.01558115f, -0.30540475f, -0.13365804f, -0.10759058f, -0.05569383f, -0.11293349f, 0.19285031f, 
    -0.18198116f, 0.04607605f, 0.01744673f, 0.09889181f, -0.14393815f, 0.03549992f, 0.06460088f, -0.03868163f, 
    -0.03633787f, -0.11082064f, -0.04626602f, 0.19625229f, 0.05951538f, -0.08380310f, 0.12645371f, 0.02044510f, 
    0.10925702f, 0.16713692f, 0.04427334f, -0.01410987f, -0.38806313f, -0.24444549f, -0.60833108f, 0.08181416f, 
    -0.09208119f, -0.15852118f, -0.02880748f, -0.18191767f, 0.03903022f, 0.01293321f, -0.08510928f, -0.03403790f, 
    -0.00385501f, -0.05913886f, 0.05812439f, -0.00675045f, 0.05815791f, -0.03929090f, 0.01341875f, 0.16173041f, 
    0.20113522f, 0.00328186f, -0.06849425f, -0.03444793f, 0.11378694f, 0.03947741f, 0.14874180f, -0.21644065f, 
    0.04080361f, -0.14700472f, -0.00502012f, -0.02803257f, -0.04279718f, 0.05401197f, -0.04615081f, -0.05333804f, 
    0.07582698f, 0.07005941f, -0.14370677f, 0.13118662f, 0.01830843f, 0.13527864f, -0.00710653f, 0.08452658f, 
    0.15157609f, -0.09085501f, 0.05783269f, -0.02585916f, -0.01888879f, 0.07897556f, -0.02475249f, 0.00945900f, 
    -0.04616838f, -0.01600400f, -0.20556729f, -0.12782463f, -0.30142364f, -0.08702004f, -0.20227969f, -0.22690468f, 
    -0.00390305f, -0.07671395f, -0.10542928f, -0.12840436f, -0.26246399f, -0.48646784f, -0.03536700f, -0.09226473f, 
    -0.13782644f, 0.09665580f, 0.00168859f, -0.06746209f, 0.02434510f, -0.33548793f, 0.14113449f, 0.03882540f, 
    0.17408900f, -0.12090279f, 0.06542245f, -0.02248244f, 0.19060645f, -0.05722219f, -0.02599982f, -0.06555706f, 
    0.01084487f, -0.09667967f, -0.07400138f, 0.07734360f, -0.04306044f, -0.02145895f, -0.16369544f, -0.01708787f, 
    0.11179860f, -0.03852870f, -0.01570147f, -0.02375950f, 0.02498490f, -0.03163832f, 0.02076495f, 0.18819481f, 
    -0.08001062f, -0.28373519f, -0.11581896f, -0.14750247f, -0.12056032f, 0.00763472f, -0.02707820f, -0.05403902f, 
    0.00113596f, -0.32154036f, 0.20859510f, 0.17259371f, 0.09279744f, -0.03933967f, -0.00444013f, -0.01706891f, 
    0.00260501f, 0.00697925f, -0.19728337f, -0.10461464f, -0.10365707f, -0.09455550f, -0.13107651f, -0.07720517f, 
    0.08369257f, 0.16093232f, -0.16896993f, -0.00516246f, -0.17228371f, 0.02807964f, -0.22113340f, 0.06518208f, 
    -0.03786950f, 0.08412229f, 0.06822728f, -0.15624255f, 0.17432128f, -0.84460169f, -0.09997248f, -0.07887536f, 
    -0.07737873f, -0.00686463f, 0.05545408f, 0.11468265f, -0.28749382f, -0.22711639f, -0.21971829f, -0.12589706f, 
    0.08347433f, -0.06887884f, -0.03871147f, 0.04162604f, -0.10537878f, 0.07254454f, 0.07769919f, 0.22959314f, 
    -0.02635708f, -0.03395183f, -0.30790326f, 0.04885431f, 0.01858627f, 0.10550728f, -0.26758707f, 0.00312869f, 
    -0.00018933f, 0.04679590f, 0.20030655f, 0.12904638f, 0.04583343f, -0.00648828f, 0.15843897f, -0.25175592f, 
    -0.17696087f, 0.29373035f, 0.06505831f, -0.07578508f, 0.15039359f, -0.14398657f, 0.10408474f, -0.00257188f, 
    -0.21798453f, 0.36420462f, -0.05357584f, 0.09035779f, -0.09339898f, 0.08874153f, 0.04625273f, 0.10740858f, 
    0.02198000f, -0.31143960f, -0.50302470f, 0.21941133f, 0.07490775f, -0.05125614f, -0.00809339f, -0.01819246f, 
    0.03057532f, 0.04282363f, -0.09070680f, 0.15996295f, -0.11886310f, -0.09025488f, -0.15510955f, -0.15493664f, 
    0.09733419f, -0.03553772f, -0.01214251f, -0.06542087f, -0.73034269f, 0.08821559f, 0.08414309f, -0.05279732f, 
    -0.14758001f, 0.00975953f, 0.08976013f, 0.04816554f, -0.01801189f, 0.14085825f, 0.12998769f, -0.05012894f, 
    0.06749592f, 0.11340131f, 0.09781014f, -0.01617729f, 0.06387775f, 0.16146451f, -0.38062260f, -0.24404185f, 
    0.06543539f, -0.01875805f, 0.08544601f, 0.08798300f, 0.05612242f, 0.02866121f, -0.14356758f, 0.11013091f, 
    -0.04309041f, -0.06074655f, -0.10423811f, 0.20647973f, 0.02791608f, 0.10824039f, -0.02126493f, 0.30372834f, 
    0.10690725f, -0.05990519f, -0.06804421f, 0.00971174f, 0.07827264f, -0.07341304f, 0.04813334f, 0.05685878f, 
    0.01764903f, 0.28687549f, 0.03366451f, 0.00987583f, -0.15915781f, 0.04830362f, -0.10005686f, -0.12284723f, 
    0.00580701f, -0.26207459f, -0.06706043f, -0.35911816f, 0.06254092f, -0.11222726f, -0.14140081f, 0.05560982f, 
    0.21135899f, -0.07506531f, -0.10977754f, -0.01504869f, 0.10947802f, -0.00464626f, -0.25989702f, -0.05381196f, 
    -0.09826362f, 0.01252226f, 0.09367024f, 0.06922110f, -0.47703630f, -0.34533960f, -0.09134014f, 0.18703240f, 
    -0.01827387f, 0.09686065f, 0.02373763f, -0.13751109f, 0.23626263f, 0.22587246f, 0.20810045f, -0.04163205f, 
    -0.13346490f, 0.28778100f, -0.06239491f, -0.00258232f, -0.13325444f, -0.12318730f, -0.07983718f, -0.00199803f, 
    0.06150632f, 0.10176733f, 0.17956470f, 0.09679599f, 0.02775871f, 0.10513273f, 0.12908524f, -0.02008371f, 
    0.20938531f, -0.03260091f, -0.21936423f, -0.17935693f, 0.04435418f, 0.11788490f, 0.05689618f, 0.10522409f, 
    0.21662872f, 0.17224769f, -0.14109050f, 0.05461985f, -0.18489482f, 0.03415167f, 0.02578764f, 0.05939327f, 
    -0.36109060f, 0.11419280f, -0.08983848f, 0.06700028f, 0.05357267f, -0.00988655f, 0.07532990f, 0.20686966f, 
    -0.04852472f, -0.20879145f, 0.15888847f, 0.08810454f, -0.07260842f, 0.00345584f, -0.00313586f, -0.02654543f, 
    -0.05591861f, 0.09507015f, 0.23717652f, 0.23742953f, 0.07534450f, -0.19565657f, -0.01352863f, -0.24671105f, 
    0.07659966f, 0.03387444f, -0.01470161f, -0.29970518f, -0.01289413f, 0.13648400f, 0.01378433f, -0.03626176f, 
    -0.19230819f, 0.17783806f, -0.07020232f, 0.18282169f, 0.32801467f, 0.16763531f, -0.27973726f, 0.06343368f, 
    0.02954063f, 0.07016786f, 0.02511578f, 0.07181509f, 0.01241642f, 0.01925109f, 0.16352384f, -0.26252583f, 
    0.01495316f, 0.07515442f, 0.18720037f, 0.00851944f, -0.02916603f, 0.10201584f, 0.17726266f, -0.17576677f, 
    -0.03048106f, -0.01366076f, -0.02361859f, -0.06546645f, 0.04672473f, 0.02887661f, 0.04239041f, 0.06203635f, 
    -0.23976757f, 0.23591369f, -0.22827446f, 0.03610962f, -0.17101452f, 0.02653198f, -0.08414253f, -0.00356719f, 
    0.00521764f, 0.03895263f, 0.01631244f, 0.01287539f, -0.04063518f, 0.05260973f, -0.00820520f, -0.02334385f, 
    -0.05585280f, -0.05147737f, 0.03797523f, -0.01131007f, -0.04087820f, -0.04890620f, -0.05776265f, -0.01751712f, 
    0.01602012f, 0.01480084f, -0.04703730f, 0.00725147f, -0.05997641f, 0.00277354f, -0.01335815f, -0.00847136f, 
    0.04181845f, -0.05581769f, -0.06320608f, -0.01614022f, 0.01007374f, 0.02215205f, 0.00337678f, -0.00923234f, 
    0.02826863f, -0.00064641f, 0.02523172f, -0.03103452f, -0.03638592f, 0.01953865f, 0.00674585f, 0.00646396f, 
    -0.03437839f, -0.01628937f, 0.03199822f, -0.01180487f, -0.04117153f, -0.03416593f, 0.05006646f, 0.01298575f, 
    0.02090328f, -0.01562421f, -0.05426061f, 0.04120610f, -0.00798625f, 0.05379574f, 0.06097791f, 0.02878292f, 
    -0.04556111f, -0.00818405f, -0.02816069f, 0.03678899f, -0.01555773f, -0.03412211f, -0.03967656f, 0.03817628f, 
    -0.03574100f, -0.02042645f, 0.02840251f, -0.02346404f, 0.01919063f, -0.04545867f, -0.03977520f, 0.02675521f, 
    0.03564353f, 0.03172332f, 0.00909005f, -0.06234913f, 0.05170075f, -0.03242916f, -0.03565085f, 0.01366275f, 
    0.02593437f, -0.03450647f, -0.06011042f, 0.04652119f, -0.04269064f, 0.03460712f, -0.04595156f, -0.04547444f, 
    -0.05642278f, -0.02973770f, 0.04590210f, 0.05444219f, -0.05120138f, 0.03463356f, -0.03654454f, -0.06107752f, 
    0.01187991f, 0.03910319f, -0.02405866f, 0.03294443f, -0.03904633f, 0.01174135f, 0.04103348f, -0.03577406f, 
    0.02086713f, -0.02784264f, 0.05312512f, -0.02593150f, -0.04235490f, -0.05708772f, -0.04195739f, 0.04818389f, 
    -0.01898887f, -0.02966279f, 0.03642264f, -0.02291851f, -0.03432424f, -0.04650722f, 0.02805061f, 0.03799596f, 
    -0.01803831f, 0.04518385f, -0.02167782f, -0.00062625f, 0.00662023f, 0.00642378f, 0.00937525f, -0.03112109f, 
    -0.05728604f, -0.05193280f, -0.05657759f, 0.00614852f, -0.00224798f, 0.02348328f, 0.03493666f, 0.04999585f, 
    -0.00180599f, -0.05139833f, 0.02441903f, 0.00765646f, 0.01008603f, -0.05016221f, -0.01286006f, 0.03791636f, 
    0.01941075f, 0.03345364f, -0.02213357f, 0.01413398f, 0.01834734f, -0.01584843f, -0.01016522f, 0.01476904f, 
    -0.02885308f, -0.04985763f, 0.03788666f, 0.01309509f, 0.05427576f, -0.03177207f, 0.00361670f, -0.04378365f, 
    -0.03363131f, 0.05003409f, -0.05895673f, -0.02485175f, 0.02994777f, 0.00849643f, 0.05477358f, 0.02368079f, 
    0.00249780f, 0.00751908f, -0.05904733f, 0.02759628f, -0.01877805f, -0.04199893f, 0.02459630f, -0.05748022f, 
    0.00120468f, -0.02557076f, 0.00843316f, -0.01068815f, -0.04117768f, 0.02828756f, 0.04057033f, 0.00752891f, 
    0.01538252f, 0.04824397f, 0.02772217f, 0.03202622f, 0.00744506f, -0.01754854f, 0.02244858f, -0.00692351f, 
    0.01060925f, 0.01068036f, -0.03726165f, -0.00423674f, -0.02758840f, 0.02889552f, 0.00635818f, -0.00720567f, 
    0.02325391f, 0.04565264f, -0.02371920f, -0.01910687f, 0.03994929f, -0.06633919f, 0.03262830f, 0.03633567f, 
    0.03209320f, -0.03269783f, 0.01923069f, 0.02718252f, 0.04877897f, 0.01518756f, -0.05707962f, 0.04357432f, 
    -0.04828345f, -0.04783887f, 0.00974785f, -0.01195212f, 0.00199091f, 0.05211230f, -0.03038781f, -0.06198938f, 
    -0.05845806f, 0.00267911f, -0.05481319f, -0.03727877f, -0.04714778f, 0.00486665f, -0.00221689f, -0.01419256f, 
    -0.02696095f, 0.04441620f, -0.00627860f, -0.00878949f, -0.03273381f, -0.05210321f, -0.02571602f, -0.01377780f, 
    -0.03662606f, 0.03765182f, 0.00080269f, -0.04077026f, -0.03746324f, -0.03206906f, 0.00192394f, 0.02391275f, 
    -0.03170026f, 0.04692182f, -0.03207137f, -0.00400963f, 0.01872767f, -0.02836945f, 0.03442528f, -0.02781117f, 
    -0.02554922f, -0.05790589f, 0.04011815f, 0.01501302f, -0.03372807f, -0.05213483f, -0.02733043f, 0.02724415f, 
    -0.02798262f, -0.00829600f, -0.01344770f, -0.01406338f, -0.02159335f, -0.04622123f, -0.04530426f, 0.00989793f, 
    0.05081200f, 0.02567790f, 0.05185871f, -0.04677934f, 0.02071405f, -0.05696603f, -0.06263612f, 0.01115918f, 
    0.03704038f, 0.04188069f, -0.00959448f, -0.04966397f, -0.04285252f, 0.01743611f, 0.01535678f, -0.00039373f, 
    -0.04272757f, 0.02241729f, -0.06044929f, -0.01541392f, -0.01577598f, 0.07049797f, -0.00105350f, 0.10845478f, 
    0.03531778f, 0.56256133f, -0.36611211f, -0.40053147f, 0.10145107f, 0.06911722f, 0.01269102f, 0.01222156f, 
    -0.12936224f, -0.05423736f, 0.00913056f, 0.15096736f, 0.27015877f, 0.01398850f, -0.12795424f, -0.12536751f, 
    0.14642373f, 0.07998968f, 0.08522391f, -0.36478549f, 0.19938792f, 0.07741805f, -0.13021050f, 0.01937751f, 
    0.01646700f, 0.01071055f, -0.13723353f, 0.12204099f, -0.16880341f, 0.06478883f, 0.12994714f, 0.15446322f, 
    0.13848826f, -0.05668539f, 0.16811097f, 0.10737438f, 0.00107305f, -0.06281776f, -0.03391776f, -0.03827694f, 
    0.03404084f, -0.01135934f, 0.06965766f, 0.19870010f, 0.17085008f, 0.07874463f, -0.22809181f, -0.16661823f, 
    0.13110466f, 0.05100835f, -0.10365217f, 0.03374960f, 0.24621230f, -0.08215297f, -0.10023591f, -0.06806619f, 
    0.15684997f, -0.16369143f, -0.00276803f, -0.19407503f, 0.15774059f, 0.13918832f, -0.08138750f, 0.07715803f, 
    0.04660592f, -0.05974868f, -0.12330206f, -0.05768021f, -0.01943896f, -0.10409427f, 0.13206908f, 0.16503529f, 
    0.03003948f, 0.05263459f, -0.24486661f, -0.28760049f, 0.05137249f, 0.00324152f, -0.05705393f, -0.03167114f, 
    -0.02219242f, -0.06473632f, -0.01967590f, -0.08997706f, -0.07543367f, -0.18435386f, -0.12656702f, -0.10450916f, 
    0.06262294f, -0.07780214f, -0.02361698f, -0.07913075f, -0.07167076f, -0.14555475f, -0.08580606f, 0.01199889f, 
    -0.02448461f, -0.11462260f, -0.02609598f, -0.04983323f, 0.02573231f, -0.35542798f, 0.02521201f, 0.09668785f, 
    -0.06022013f, -0.04667317f, 0.07498495f, 0.08040529f, 0.15758336f, -0.18640634f, 0.36436629f, -0.11800557f, 
    0.13312782f, -0.11750642f, 0.16438636f, -0.21940574f, 0.00883530f, 0.03203121f, 0.09470816f, 0.06800389f, 
    0.01478048f, 0.05671366f, -0.00561001f, 0.02910906f, -0.04203024f, 0.04582071f, 0.04297201f, -0.14189756f, 
    -0.12605760f, 0.45661896f, -0.00392795f, -0.06577139f, 0.00213069f, -0.07302731f, -0.08106409f, 0.11804365f, 
    0.04758133f, -0.06958824f, 0.19124608f, 0.12970527f, -0.08078787f, -0.00733611f, 0.02719427f, -0.08732501f, 
    0.06268079f, -0.04820760f, 0.11775832f, -0.01780823f, 0.01182295f, -0.01105877f, -0.10087601f, 0.19491060f, 
    0.26786742f, -0.06478990f, -0.12399254f, 0.05288475f, -0.28734195f, -0.12649064f, -0.02943189f, -0.01969397f, 
    -0.08837443f, -0.03691185f, -0.11738283f, -0.10708304f, -0.06403521f, -0.06610814f, 0.02113889f, 0.16131957f, 
    -0.07331579f, 0.03481509f, 0.06290576f, 0.13242428f, -0.06894622f, 0.24331957f, 0.15313129f, -0.09123481f, 
    -0.08947864f, -0.23899944f, -0.18644653f, 0.04098188f, 0.08554483f, -0.06292493f, -0.15494654f, -0.02594370f, 
    -0.05668390f, -0.06617334f, -0.15290709f, 0.19181837f, 0.09261605f, 0.02080541f, 0.00515429f, 0.18732004f, 
    -0.20631924f, 0.01175862f, 0.02224973f, 0.01712608f, -0.10931369f, 0.13396557f, 0.02188298f, 0.22422670f, 
    0.13510509f, 0.21911806f, 0.06623913f, -0.15637830f, 0.05895900f, 0.11557983f, 0.03534314f, 0.12915011f, 
    -0.02669606f, -0.00460190f, -0.14481597f, -0.10775699f, 0.08549859f, 0.04493228f, 0.00682093f, 0.01809232f, 
    0.02158076f, 0.07884610f, -0.16561483f, 0.01631472f, -0.13628878f, 0.02347402f, 0.03291445f, -0.04918448f, 
    -0.11358937f, 0.04088461f, 0.12550506f, 0.07521363f, 0.53169751f, -0.05659105f, -0.15431780f, -0.03903026f, 
    -0.00856816f, -0.04108325f, 0.06265246f, 0.20443341f, 0.03335659f, 0.33413276f, 0.08388599f, -0.04650241f, 
    -0.10742166f, 0.05293765f, 0.00383815f, 0.22129990f, -0.06823569f, 0.20525950f, 0.26018462f, -0.02825514f, 
    -0.12640348f, 0.01518998f, -0.04012170f, -0.02937291f, 0.01844493f, 0.05714322f, 0.07644165f, 0.06272011f, 
    0.03947757f, -0.12734137f, -0.08322540f, 0.17120859f, 0.06689205f, 0.11614237f, -0.06465790f, 0.10820422f, 
    0.03129331f, 0.05405031f, 0.19066310f, 0.10884402f, -0.12076952f, 0.30917960f, -0.10884048f, -0.12546243f, 
    0.20199697f, 0.05687170f, 0.20012403f, 0.09429485f, -0.00042911f, 0.05486261f, 0.15124670f, -0.06673032f, 
    -0.03331466f, -0.06273387f, 0.15897284f, -0.05915886f, 0.00634926f, 0.02774203f, 0.05612729f, -0.23708577f, 
    0.02519909f, 0.35079703f, -0.00354138f, 0.32394889f, 0.03320903f, -0.11986928f, -0.03012827f, -0.18804233f, 
    0.10885341f, -0.07580860f, 0.03876373f, 0.20187441f, 0.06571987f, -0.15437113f, -0.02727861f, -0.01187315f, 
    -0.06507613f, 0.05096389f, 0.09989046f, 0.07028981f, 0.07808035f, 0.07370185f, 0.02315035f, 0.00924139f, 
    0.00297201f, -0.11507190f, 0.00616506f, 0.05225871f, 0.02235605f, -0.25046438f, -0.12637913f, 0.16489956f, 
    -0.04844525f, 0.20573932f, 0.06350359f, 0.03631750f, 0.27685112f, -0.12022644f, -0.07611498f, 0.02232100f, 
    0.08695044f, 0.01236982f, 0.08815550f, -0.00933049f, -0.18336309f, -0.02229551f, -0.12947628f, 0.06738598f, 
    0.00191357f, -0.01835394f, -0.01674016f, 0.13756460f, 0.09631334f, 0.06945764f, -0.20721637f, 0.06418763f, 
    0.01210518f, 0.02461232f, -0.13960789f, -0.06153973f, 0.04785339f, 0.09976482f, 0.05658687f, -0.17748486f, 
    -0.00814358f, 0.04033515f, 0.10986543f, 0.03021948f, -0.05352192f, 0.04944202f, 0.06528679f, 0.02690478f, 
    0.05410760f, 0.12316325f, -0.03149299f, 0.17117161f, -0.02450602f, 0.06066815f, 0.07748217f, -0.11095395f, 
    -0.08762050f, 0.08154350f, 0.04069322f, -0.01177548f, 0.11520975f, -0.03932213f, -0.00660088f, 0.10193168f, 
    0.13420905f, -0.03046096f, 0.07153120f, -0.02882675f, -0.09469828f, 0.13134795f, -0.03055479f, 0.04236910f, 
    0.07134913f, -0.06546087f, -0.05897853f, -0.07917395f, 0.07668623f, 0.23596336f, -0.07643364f, -0.01811772f, 
    -0.03930197f, -0.03111854f, -0.10386736f, -0.00281828f, -0.21738507f, 0.00775011f, -0.03386889f, -0.13059130f, 
    -0.10433284f, -0.02886069f, -0.13904439f, 0.01221009f, -0.04377028f, -0.08622150f, 0.12762643f, 0.03571736f, 
    -0.09190848f, 0.06750866f, 0.09922561f, -0.08298969f, 0.11519942f, -0.14147754f, -0.02641455f, -0.23458691f, 
    0.23885648f, 0.32384264f, 0.07693646f, -0.08306377f, -0.16263239f, -0.01109514f, -0.03333140f, -0.16910003f, 
    0.11084221f, 0.20894782f, 0.06086166f, -0.14146164f, -0.06763925f, 0.01163566f, 0.08499651f, 0.05500574f, 
    -0.02815429f, 0.00513674f, 0.16044541f, 0.10151702f, -0.02518919f, -0.02029835f, 0.18583477f, -0.16954872f, 
    -0.20538254f, -0.08043791f, 0.06459811f, -0.01010470f, -0.11599430f, -0.04966556f, 0.04220004f, 0.06782773f, 
    0.04746209f, -0.12945926f, -0.06341749f, -0.01075877f, -0.12020270f, 0.15355992f, 0.06699969f, 0.01080274f, 
    -0.04145760f, -0.06997728f, -0.01713890f, 0.21324448f, 0.00538082f, 0.03220684f, 0.28847000f, 0.02334407f, 
    -0.01402755f, 0.11902425f, -0.05174433f, -0.21364404f, 0.06326892f, 0.09478087f, 0.11901515f, 0.05193606f, 
    -0.04683359f, 0.03266630f, -0.03712517f, -0.10239594f, 0.14458077f, 0.02212910f, -0.05138164f, -0.18242002f, 
    0.00177191f, 0.12931083f, 0.11245334f, 0.01317526f, -0.04540995f, -0.15975079f, -0.03685175f, 0.17348039f, 
    0.07272617f, -0.09867162f, 0.01073655f, -0.00260032f, 0.09974961f, -0.11038975f, 0.07921759f, -0.15621647f, 
    0.26542515f, 0.05734115f, -0.07119514f, 0.05001184f, 0.03031544f, 0.00210109f, -0.05951964f, -0.07077052f, 
    0.06083750f, -0.17221193f, -0.26197502f, 0.04449964f, 0.06665222f, -0.06434865f, 0.07007650f, 0.01448432f, 
    -0.04695422f, -0.23723175f, -0.07319228f, -0.03461593f, -0.28293839f, 0.09769074f, -0.05214555f, 0.08635959f, 
    0.03359045f, 0.13638148f, -0.26625553f, 0.13422363f, 0.10651983f, -0.42292047f, 0.01971020f, 0.00436181f, 
    -0.12187889f, -0.02437430f, -0.12012387f, -0.40611303f, 0.06019552f, 0.27390960f, 0.20140915f, -0.07604276f, 
    0.07328193f, -0.04983694f, -0.01148908f, 0.01809328f, -0.08427639f, 0.02943486f, 0.03419865f, 0.13489805f, 
    0.11652815f, -0.15889926f, 0.06017295f, 0.20150487f, 0.02833275f, -0.08066610f, -0.01852217f, -0.04038471f, 
    0.10735775f, 0.12954535f, -0.03878389f, -0.08368398f, 0.02868251f, -0.22612472f, 0.13900113f, 0.02586738f, 
    -0.17160007f, -0.06217335f, 0.05077571f, 0.23075770f, 0.03563612f, 0.05410519f, 0.07246999f, 0.17900057f, 
    0.01100720f, -0.01811555f, 0.14306661f, -0.03176912f, -0.20263511f, -0.15887396f, 0.05585636f, 0.10016780f, 
    -0.06969271f, -0.24133533f, 0.24467807f, 0.05620697f, -0.20941728f, -0.17155746f, 0.14257963f, -0.08639681f, 
    0.16288425f, -0.03036906f, -0.11018615f, 0.10172712f, -0.22451459f, -0.05613910f, 0.04558143f, -0.07535193f, 
    -0.02517336f, -0.06903867f, -0.07649764f, 0.16202095f, -0.13345858f, 0.04527668f, -0.01006449f, -0.00617993f, 
    0.05175418f, -0.07910772f, -0.04672426f, -0.06630616f, 0.14968783f, -0.06857064f, 0.06055005f, -0.12712519f, 
    0.15139776f, 0.14825501f, -0.10260799f, -0.08650003f, -0.06166405f, 0.07138787f, 0.08944180f, 0.05098316f, 
    0.07517624f, -0.07231362f, -0.08354741f, -0.04615739f, -0.07629719f, -0.20665590f, -0.10757871f, 0.22928786f, 
    0.20898220f, -0.02550144f, 0.30490512f, -0.10123812f, -0.10184693f, 0.03853492f, -0.02554340f, -0.08763919f, 
    0.18438047f, 0.31040254f, -0.16713244f, -0.01324152f, 0.04250168f, -0.16359697f, 0.07436315f, 0.04364086f, 
    0.10585022f, 0.11171515f, -0.02736030f, 0.08570213f, 0.11185417f, 0.03090666f, 0.01951041f, -0.02988993f, 
    -0.03558262f, 0.09418248f, -0.04077137f, -0.06484209f, 0.00223085f, -0.01708444f, -0.02762035f, 0.04286787f, 
    0.15050305f, 0.00437473f, 0.10491085f, 0.16604912f, 0.00980375f, 0.04390123f, -0.16429611f, -0.07056767f, 
    0.05750294f, 0.11666469f, -0.26229161f, -0.02991808f, 0.05454463f, -0.02210583f, 0.05038993f, 0.11964075f, 
    -0.19017874f, 0.19059674f, 0.03383844f, 0.00304052f, 0.08123722f, -0.11911017f, -0.14074303f, 0.11908051f, 
    0.11902910f, 0.28294811f, 0.00465758f, -0.01834915f, 0.02976336f, 0.30533698f, -0.15881340f, -0.08814780f, 
    0.00336784f, -0.02077437f, 0.06332138f, -0.10229973f, 0.03452653f, 0.25860712f, 0.19615775f, -0.01267943f, 
    0.22913191f, 0.02668595f, -0.08678284f, 0.03057045f, -0.10318428f, 0.04046071f, -0.17249608f, -0.31163195f, 
    -0.01592528f, 0.00852313f, -0.00038785f, -0.12481728f, -0.12225604f, -0.05004933f, 0.06241944f, 0.05509331f, 
    0.03158617f, 0.09301312f, -0.17770603f, 0.11730567f, 0.07725882f, -0.04461164f, -0.00957104f, -0.02745396f, 
    -0.13216035f, 0.25549498f, -0.08922929f, 0.23440884f, 0.06753830f, -0.12627080f, -0.09808700f, 0.01668504f, 
    0.13101891f, -0.06464174f, 0.11855184f, -0.07950287f, 0.01366222f, 0.03505806f, -0.05536740f, -0.02111352f, 
    0.09275359f, -0.00754231f, 0.02432219f, 0.23708679f, -0.08773571f, 0.05567282f, 0.12744576f, 0.04213776f, 
    0.13559279f, 0.06628520f, -0.00875429f, 0.09078487f, -0.22671334f, 0.10713609f, 0.48734325f, -0.02948032f, 
    0.00241807f, -0.04491010f, 0.19552368f, 0.05331502f, -0.04527240f, 0.11550912f, 0.11466249f, -0.04865171f, 
    0.05728914f, 0.08980706f, 0.11731950f, -0.09441038f, -0.00800583f, -0.07393815f, 0.02692249f, -0.00962534f, 
    0.02561708f, -0.04204927f, -0.12086778f, -0.08926015f, -0.03309989f, 0.04091355f, -0.02253132f, -0.21770863f, 
    -0.09288957f, -0.07041803f, -0.12671079f, -0.17149639f, 0.04994725f, -0.00567284f, 0.09354933f, 0.05310021f, 
    0.36938822f, -0.14482495f, 0.11252628f, -0.15978506f, 0.02138142f, 0.17747605f, 0.03390639f, 0.04015604f, 
    -0.12829159f, -0.09339464f, 0.01183439f, 0.04889630f, 0.13589343f, 0.03012754f, 0.00266252f, 0.06302457f, 
    0.14996274f, 0.11278693f, -0.12674364f, 0.14568304f, -0.06497688f, -0.05534535f, 0.04878959f, -0.08131954f, 
    0.04695195f, 0.03964391f, 0.00111476f, -0.10239943f, 0.05219107f, -0.05298460f, -0.00962864f, 0.04766358f, 
    -0.02450994f, 0.09081158f, -0.23741406f, 0.07400354f, -0.19140773f, -0.18330884f, 0.17501079f, 0.05830865f, 
    -0.04039674f, 0.03834490f, -0.00149739f, 0.14520720f, -0.03998088f, -0.18367557f, 0.08845507f, 0.05918133f, 
    0.01199152f, 0.01688795f, 0.05246846f, 0.05480525f, -0.14075045f, 0.06494424f, -0.10555718f, 0.18034990f, 
    0.00699627f, -0.15755162f, -0.22409664f, 0.03672287f, -0.04944220f, 0.07560038f, -0.13362193f, 0.00590930f, 
    -0.07243168f, -0.00352711f, 0.01850544f, 0.10411331f, -0.08307368f, -0.09641619f, -0.01103540f, 0.04977620f, 
    0.06508062f, -0.06162914f, -0.10218562f, -0.09530090f, -0.12112307f, -0.06949537f, 0.06138929f, 0.20211247f, 
    -0.02315072f, -0.61121112f, -0.48223025f, -0.55985880f, -0.10690450f, -0.23966567f, -0.08226064f, -0.09797870f, 
    0.06726544f, -0.04453011f, -0.04490629f, 0.20155115f, 0.06057501f, 0.01772852f, 0.08920348f, 0.06308725f, 
    -0.02610360f, 0.10904188f, 0.22572994f, 0.40595347f, 0.11102062f, -0.15491617f, 0.02791845f, 0.00946224f, 
    -0.13461480f, 0.10457426f, -0.01600832f, -0.11646041f, 0.25679830f, -0.08425682f, -0.30162263f, 0.05931734f, 
    0.20053339f, -0.04149145f, 0.06291641f, 0.08213279f, 0.06358013f, 0.01359113f, 0.03517994f, 0.17316185f, 
    0.03304030f, -0.02565325f, 0.02789150f, 0.01844804f, -0.07693169f, -0.00764504f, 0.00163481f, 0.06833752f, 
    -0.23066302f, 0.12776758f, -0.00751595f, 0.06445524f, 0.06091856f, 0.05392234f, 0.01809279f, 0.02815643f, 
    -0.02618736f, -0.31325039f, -0.12673154f, -0.00622480f, -0.17371915f, -0.08752926f, -0.03553391f, 0.22090542f, 
    0.00087501f, -0.05111415f, 0.16114005f, 0.05947311f, -0.11009380f, 0.06450973f, 0.16163580f, 0.18619372f, 
    0.24191584f, 0.13332279f, -0.15439826f, -0.11453363f, 0.03181619f, 0.02334701f, 0.07738745f, 0.11722771f, 
    0.19787723f, 0.14867406f, -0.13575442f, -0.20024851f, 0.20247670f, 0.00334596f, -0.09193873f, -0.09239480f, 
    0.06776715f, 0.07679737f, 0.05379334f, -0.09347364f, -0.11140587f, -0.00515250f, -0.00906723f, 0.02607919f, 
    0.09354370f, 0.01034979f, 0.02635718f, 0.07406991f, -0.02445836f, 0.01211073f, -0.14654604f, 0.03956904f, 
    0.09992281f, 0.02667938f, -0.02934869f, 0.02146637f, 0.05340663f, 0.15388203f, -0.09293395f, 0.03750513f, 
    -0.15553729f, -0.02186285f, 0.03643622f, -0.11231447f, -0.12329686f, -0.06136707f, -0.23601621f, -0.23457021f, 
    0.03331383f, 0.09845784f, 0.22520199f, 0.08147249f, -0.02497885f, 0.04515406f, 0.06113812f, -0.06523416f, 
    0.21285528f, 0.02672778f, -0.03417190f, -0.11818684f, -0.18104462f, -0.01157053f, -0.06566438f, -0.05125933f, 
    -0.52461523f, 0.25812408f, 0.11310112f, 0.09439333f, 0.08835766f, -0.03467622f, 0.08464772f, 0.06901152f, 
    0.12320054f, -0.01474999f, -0.21970432f, -0.17307740f, 0.02583310f, -0.08039232f, -0.02601240f, 0.07886357f, 
    0.10241982f, 0.01546170f, 0.03779279f, -0.03411723f, -0.10219699f, -0.01063883f, -0.06167554f, -0.02775821f, 
    -0.00068094f, 0.00313488f, 0.04292392f, 0.29233408f, -0.15235837f, -0.05374470f, 0.06459194f, 0.08368962f, 
    0.09734222f, 0.00014744f, -0.03846117f, -0.11505246f, -0.28038126f, -0.30978861f, -0.08100428f, -0.00876008f, 
    -0.15850765f, 0.03720634f, 0.08422498f, -0.18101454f, -0.11759843f, 0.04163909f, 0.00120177f, 0.01769454f, 
    -0.03753543f, -0.04026710f, 0.06305924f, 0.13428807f, -0.00425146f, 0.20131834f, -0.01974935f, -0.00949479f, 
    0.25028351f, -0.04354029f, -0.01311957f, -0.05232795f, 0.16580899f, -0.12419727f, 0.15631662f, -0.16813561f, 
    0.09412733f, -0.09070813f, -0.18983816f, 0.04839131f, -0.03829752f, 0.04254737f, 0.00108144f, -0.04833709f, 
    0.37122163f, 0.10594968f, -0.14502934f, 0.06750821f, 0.05955882f, -0.14141007f, 0.01657686f, 0.03973566f, 
    0.17071931f, -0.20735615f, -0.15183264f, 0.09908330f, 0.03566335f, -0.01029873f, 0.06332164f, -0.13457286f, 
    -0.01066265f, 0.19819640f, 0.01718532f, 0.13705109f, -0.13996793f, 0.09146582f, 0.06296423f, -0.09089525f, 
    -0.03236495f, 0.07173613f, 0.04273157f, -0.13201670f, -0.38511294f, -0.57299757f, -0.06166261f, 0.05114629f, 
    -0.02728483f, 0.08580344f, -0.00385872f, 0.02168574f, -0.04116359f, 0.00884132f, 0.01346030f, -0.00774720f, 
    0.00394286f, -0.03685069f, -0.03737755f, 0.03833152f, 0.00881159f, -0.34473866f, -0.09031390f, -0.13981891f, 
    0.10811797f, -0.08640898f, -0.02060969f, 0.21184023f, 0.02559705f, 0.13198835f, -0.19369997f, 0.06553271f, 
    0.11510365f, 0.04848185f, 0.08964151f, -0.05163468f, 0.06060902f, -0.08079860f, 0.06210086f, -0.11517186f, 
    -0.34959093f, -0.11066083f, 0.02636903f, 0.18650134f, 0.21119051f, 0.09957393f, -0.00865425f, 0.12746625f, 
    0.35886410f, 0.32000500f, 0.06898007f, -0.08854344f, -0.07664236f, -0.19750831f, -0.03906675f, 0.01433905f, 
    -0.03058301f, -0.13412786f, -0.13436976f, -0.20592993f, -0.05311099f, -0.13385196f, -0.11519566f, 0.16835250f, 
    0.05906658f, 0.10822453f, -0.07877899f, -0.03111818f, -0.20462121f, 0.07627580f, 0.00366315f, -0.13385727f, 
    -0.17533013f, -0.00847675f, -0.06193199f, -0.20342644f, -0.06515808f, -0.12050235f, 0.02389144f, 0.15703791f, 
    -0.00788687f, -0.05058776f, 0.13846388f, -0.01789304f, 0.35559776f, 0.11647325f, 0.09816577f, 0.15507884f, 
    0.01252965f, 0.03912631f, -0.05769655f, 0.04324088f, -0.18268281f, 0.15076642f, 0.17697322f, -0.07943836f, 
    -0.11141159f, 0.01519474f, -0.07591553f, -0.03002816f, -0.02650345f, -0.05272731f, -0.02962061f, 0.10825557f, 
    0.15701811f, -0.09395991f, 0.17414565f, -0.17926277f, -0.03181161f, -0.12284921f, -0.01824001f, -0.09981801f, 
    0.06569700f, 0.26647121f, -0.03650306f, -0.05505921f, -0.06873771f, -0.12727575f, 0.03742992f, -0.04654405f, 
    -0.10770110f, 0.00741197f, -0.09173819f, 0.01751454f, 0.07701986f, -0.09679475f, 0.11857196f, -0.05563910f, 
    -0.04386091f, 0.21388848f, 0.13074201f, 0.03960211f, -0.05884649f, -0.03859512f, -0.06172354f, 0.01348724f, 
    0.02014107f, 0.02189415f, 0.16378100f, 0.12863447f, 0.05181580f, -0.11699427f, -0.23469181f, -0.13069952f, 
    0.05210727f, -0.01057689f, -0.22977559f, 0.37867725f, 0.23727298f, 0.09678010f, 0.00882350f, 0.03221412f, 
    -0.05410066f, 0.16297273f, 0.10477716f, 0.05272891f, 0.04250672f, -0.09406930f, -0.14993641f, 0.00379689f, 
    -0.05829833f, 0.07247338f, -0.04530365f, 0.04282214f, 0.01281770f, -0.10314515f, -0.38439390f, 0.01348656f, 
    -0.03860713f, 0.03315933f, 0.13021946f, -0.19854514f, -0.01308610f, 0.23427525f, -0.15978782f, -0.31321833f, 
    0.11648250f, -0.05057086f, 0.10210002f, -0.07742146f, 0.07720939f, 0.10795217f, -0.00257705f, 0.06282490f, 
    -0.12233443f, -0.08131638f, -0.05234202f, 0.07889161f, 0.00401524f, -0.00877339f, 0.09065530f, 0.19846767f, 
    -0.00748614f, -0.02694819f, -0.18965021f, 0.04611850f, -0.03543313f, -0.12987866f, -0.01530484f, 0.05319874f, 
    -0.03107082f, 0.04285045f, 0.09441765f, 0.06836486f, 0.04058313f, -0.10514465f, -0.15711673f, 0.06287254f, 
    0.12772019f, 0.06638762f, 0.03106446f, 0.00367144f, 0.22492987f, -0.01504578f, 0.07963084f, -0.08715566f, 
    -0.07964123f, 0.22466756f, 0.08168441f, 0.26334822f, 0.05168818f, 0.09211638f, -0.03913018f, -0.01087183f, 
    0.12651575f, -0.02370184f, 0.04239620f, -0.09803110f, 0.03324070f, 0.20742060f, 0.22683990f, 0.13945672f, 
    0.00140745f, -0.19809811f, 0.10222910f, -0.00832571f, -0.02555010f, -0.11687129f, -0.05781914f, -0.12805931f, 
    0.10016628f, 0.09461781f, -0.04238595f, 0.03546037f, 0.06677642f, -0.05740247f, -0.02321879f, -0.02088717f, 
    0.07757466f, -0.06433801f, -0.01755376f, -0.01944449f, -0.04298279f, -0.05611826f, 0.08657678f, -0.06861988f, 
    -0.02560975f, -0.11137250f, -0.03379351f, -0.08805913f, -0.25509816f, 0.01745722f, -0.00065401f, 0.13455765f, 
    0.08224089f, -0.06182699f, 0.20134185f, -0.00719130f, 0.02804887f, 0.22355472f, -0.10813069f, 0.00400906f, 
    -0.03094200f, -0.03849878f, 0.04633116f, -0.01866700f, -0.06135299f, 0.08445895f, -0.00507383f, 0.01596861f, 
    -0.00173867f, 0.20300555f, 0.16498241f, 0.05692851f, 0.12641570f, -0.13085447f, -0.15587854f, -0.26053625f, 
    0.04786751f, 0.04866771f, 0.09173205f, 0.07481076f, 0.38923216f, 0.07910214f, -0.17538285f, -0.23638070f, 
    -0.10385229f, 0.01443271f, 0.14162365f, -0.07723179f, 0.11802717f, -0.12194656f, -0.06985868f, -0.09624560f, 
    0.17518193f, -0.18670312f, -0.02566081f, 0.09067997f, 0.14930795f, -0.50261277f, -0.11511315f, 0.10882301f, 
    0.08901381f, -0.26117975f, 0.04977054f, 0.09188640f, 0.00294404f, -0.32302985f, -0.20118888f, -0.09400947f, 
    -0.20610179f, 0.05524882f, -0.01638856f, 0.05983903f, -0.14650361f, -0.04591113f, 0.14582780f, 0.06166019f, 
    0.02764550f, 0.09329274f, 0.14112151f, 0.06333476f, -0.07087933f, 0.10016198f, 0.07703543f, -0.12942323f, 
    0.08318415f, 0.08844880f, 0.12037993f, 0.08298522f, -0.16928349f, -0.13679774f, -0.02210157f, 0.06049686f, 
    -0.01252874f, 0.21440759f, 0.10707553f, 0.11453056f, -0.08523893f, 0.17906205f, -0.27802518f, 0.12787591f, 
    -0.04006416f, 0.05198054f, -0.01063535f, -0.36169109f, -0.18232842f, -0.03416120f, -0.09528677f, 0.01381798f, 
    0.08852758f, 0.01323520f, 0.04192917f, -0.16484252f, -0.04721024f, -0.24407171f, -0.04244047f, 0.06928200f, 
    -0.07116789f, 0.03784653f, 0.03236363f, -0.01387259f, -0.12407099f, 0.13305442f, -0.03593007f, -0.09645173f, 
    0.01303227f, 0.04255132f, -0.00218261f, -0.00357694f, -0.02179600f, 0.07679205f, 0.03200850f, 0.12596340f, 
    0.04316150f, -0.03182918f, -0.10707192f, -0.11064186f, -0.03021864f, 0.03206140f, -0.14470653f, 0.06261647f, 
    -0.05909316f, -0.01612898f, -0.17333509f, -0.05520856f, 0.11994769f, -0.06816332f, -0.08851766f, -0.12655945f, 
    0.08623639f, 0.09017649f, -0.03755637f, 0.06117425f, -0.10350306f, 0.15602343f, -0.12522337f, -0.01020775f, 
    0.12156119f, -0.07238590f, -0.05300837f, -0.01525205f, 0.04078098f, 0.09023508f, 0.03743553f, 0.02156773f, 
    -0.01653189f, 0.18724817f, 0.01383722f, 0.22885785f, 0.05633860f, -0.01918454f, -0.10902199f, 0.09707302f, 
    0.03822745f, 0.03753730f, 0.16018616f, 0.08724812f, 0.04231459f, 0.10539322f, -0.23483823f, -0.09915172f, 
    -0.00811542f, -0.10352822f, -0.02493653f, 0.17292286f, -0.04906988f, 0.14301531f, -0.05239582f, -0.07964383f, 
    -0.05827607f, 0.00801629f, -0.02146612f, 0.02974580f, -0.06838144f, -0.06506322f, -0.05122351f, -0.04352121f, 
    0.06157772f, 0.04040788f, 0.06385194f, -0.02585149f, -0.08470012f, 0.05369403f, -0.16784184f, -0.04467219f, 
    -0.04002387f, 0.09434988f, 0.06119769f, 0.06085415f, -0.03682958f, 0.03329572f, 0.04972085f, 0.27265516f, 
    -0.16777709f, -0.00163107f, 0.03170725f, 0.10533886f, 0.04359857f, -0.02391344f, 0.15196292f, -0.00080098f, 
    -0.00689180f, -0.39505899f, 0.03167045f, -0.23329034f, 0.13782676f, 0.10512212f, -0.04528898f, -0.03029047f, 
    -0.41371599f, -0.42385286f, -0.16082259f, -0.12495343f, -0.09252857f, -0.00410090f, -0.04516049f, -0.05067508f, 
    -0.04196506f, -0.02357589f, 0.28599352f, -0.15026802f, -0.04308077f, 0.07047747f, -0.03545767f, 0.02232596f, 
    0.14535305f, -0.14609256f, 0.07214618f, 0.10566664f, 0.06784517f, -0.01545685f, 0.07050530f, -0.05465220f, 
    0.04756131f, 0.00119192f, -0.02658544f, 0.19904020f, -0.01167155f, 0.06375575f, -0.06574000f, 0.19843903f, 
    -0.12648335f, 0.11236335f, 0.11183013f, 0.00537845f, 0.01443645f, -0.22845535f, -0.17986555f, -0.03060207f, 
    -0.06188565f, -0.02388989f, 0.27199388f, 0.02840677f, 0.07633843f, 0.11179382f, 0.01602930f, -0.10513470f, 
    -0.08947435f, 0.00578410f, 0.00996647f, 0.01212619f, 0.01887210f, -0.08374672f, 0.08962885f, -0.04132432f, 
    -0.02759014f, 0.00555167f, -0.00383254f, -0.14977008f, -0.03264222f, -0.03661990f, 0.04823393f, -0.11360071f, 
    -0.28163493f, 0.27857202f, 0.02177628f, -0.06294150f, -0.04072172f, -0.01789992f, -0.01643997f, 0.09874017f, 
    0.02822114f, 0.15635769f, 0.15080522f, -0.02932229f, 0.09226651f, -0.09944102f, 0.16953793f, -0.01916381f, 
    -0.00156119f, 0.09484250f, 0.01884925f, 0.07193726f, 0.08491475f, 0.02226084f, -0.01917921f, -0.11430129f, 
    0.03297867f, 0.08944442f, 0.17731349f, -0.23674011f, 0.44422927f, -0.07640242f, 0.06246875f, -0.06181398f, 
    0.01594113f, -0.00551734f, 0.07360816f, 0.07191356f, 0.30876723f, 0.10474467f, -0.08125728f, -0.16405919f, 
    -0.04803956f, 0.05567994f, -0.20124702f, 0.02826372f, -0.19876556f, 0.16372743f, -0.28322390f, 0.06362206f, 
    -0.14414164f, 0.09443194f, 0.01402720f, -0.16303693f, 0.06383860f, -0.11653472f, 0.42930761f, -0.25390238f, 
    0.19304605f, 0.07361438f, -0.03589533f, 0.14984192f, 0.08162813f, -0.05214451f, 0.32605416f, -0.06714761f, 
    -0.13592008f, 0.02645205f, -0.06924276f, -0.33905640f, 0.03729709f, -0.09027882f, 0.00162039f, -0.02108869f, 
    0.09083472f, 0.19108282f, 0.07386580f, 0.04858822f, -0.02367968f, -0.03807173f, -0.00438334f, -0.06817317f, 
    0.00048806f, -0.01560269f, -0.01693769f, -0.05228262f, -0.01210780f, -0.02838057f, 0.00726213f, -0.03397197f, 
    0.03867830f, -0.06023208f, -0.03940953f, 0.01574941f, 0.03305409f, -0.01322398f, 0.02862407f, -0.01274341f, 
    -0.03024675f, -0.05393657f, 0.04159461f, -0.00031246f, -0.06595708f, -0.03427306f, 0.00573929f, -0.01494400f, 
    0.02396910f, 0.01678827f, -0.04368581f, -0.03030355f, -0.04403149f, -0.03892776f, -0.00557042f, 0.05485575f, 
    0.01455253f, 0.00748502f, -0.02315631f, -0.06550963f, 0.01138051f, 0.00765073f, 0.05861528f, 0.01798850f, 
    -0.00541264f, -0.01302562f, -0.02506220f, 0.00855474f, 0.03724852f, -0.02501510f, 0.03965885f, -0.05357512f, 
    0.01390254f, 0.05724004f, -0.01140038f, -0.04954967f, 0.03422451f, -0.03602725f, 0.02007383f, -0.00194381f, 
    0.01679495f, -0.00901069f, 0.04590827f, 0.02064213f, -0.04104060f, 0.02699903f, -0.04382394f, 0.05003823f, 
    -0.05395846f, 0.00908354f, 0.04699481f, 0.02382652f, 0.02680705f, 0.01004039f, -0.04630385f, -0.04187692f, 
    0.02054237f, -0.03639122f, 0.02339317f, 0.00627648f, -0.06086381f, 0.01879144f, -0.01509270f, -0.02618940f, 
    -0.01208419f, 0.05223020f, -0.06001950f, 0.02157341f, -0.01217784f, -0.05468868f, -0.05166584f, -0.00481253f, 
    -0.02790886f, -0.01244060f, -0.05337075f, -0.02169764f, 0.03141895f, -0.05260198f, -0.03425607f, -0.04200792f, 
    -0.03968684f, -0.00097811f, 0.00490537f, -0.02020332f, -0.02039978f, -0.01903451f, 0.05564559f, 0.04153069f, 
    0.03409306f, -0.05867148f, 0.02076313f, 0.01451669f, -0.00150331f, -0.05272488f, -0.04498456f, 0.02813906f, 
    -0.03766084f, -0.06333889f, -0.04007288f, -0.05223392f, -0.06413990f, -0.00846722f, -0.05576459f, -0.00799948f, 
    -0.03890395f, -0.01846177f, 0.03384606f, -0.06057706f, 0.05120548f, 0.00505348f, 0.01578078f, -0.03824866f, 
    -0.03894224f, -0.02649118f, 0.00657955f, -0.03856037f, 0.02564805f, 0.02001097f, -0.01705775f, 0.03593252f, 
    0.04695336f, -0.05190182f, -0.01215394f, -0.03744677f, 0.00704224f, -0.06024305f, 0.01050407f, 0.04305641f, 
    -0.00127766f, 0.01892543f, -0.00891894f, 0.02696818f, 0.01762839f, 0.03072698f, -0.05611260f, -0.04740142f, 
    0.02186073f, -0.06186032f, 0.00002448f, 0.01036470f, -0.04107256f, -0.03244917f, -0.05933565f, -0.01944954f, 
    -0.01986582f, -0.02309757f, -0.06322615f, -0.05175482f, 0.03332164f, -0.00645360f, -0.02463373f, 0.02936765f, 
    0.00772442f, -0.01337746f, 0.01958942f, 0.04691554f, -0.05140948f, -0.04500375f, 0.05038159f, 0.02076505f, 
    -0.00075633f, -0.05357652f, 0.02315933f, -0.00416265f, 0.04288597f, 0.01351443f, 0.02736659f, 0.03614510f, 
    0.03833139f, 0.04061110f, -0.00880278f, -0.06152969f, -0.02355834f, -0.05229218f, -0.05157047f, 0.01890016f, 
    -0.05117325f, -0.02317601f, -0.04102965f, 0.05015405f, -0.04098348f, -0.05727008f, 0.00244075f, 0.02821855f, 
    0.00113200f, -0.04442096f, 0.01697710f, 0.04869786f, -0.00155432f, -0.01470614f, -0.02887180f, -0.01632148f, 
    0.01421004f, -0.04083985f, -0.03749685f, 0.01650714f, 0.02182461f, -0.05768659f, 0.01328894f, 0.02378186f, 
    -0.01512336f, -0.00784808f, -0.03934214f, 0.03637104f, 0.00842802f, 0.02284028f, -0.01053187f, 0.04329524f, 
    0.02260513f, -0.06392459f, -0.00695192f, -0.02964095f, -0.05112104f, -0.03480983f, 0.00196073f, 0.03838642f, 
    -0.02137270f, 0.01857498f, 0.03555642f, -0.04278181f, -0.02225828f, -0.04379980f, -0.03843818f, 0.00328179f, 
    0.00370208f, -0.03347612f, 0.01161584f, -0.00174853f, 0.04589151f, 0.03048329f, 0.03784464f, -0.06319918f, 
    -0.02667027f, 0.02961419f, -0.00341283f, -0.03541248f, 0.03892601f, 0.00106626f, 0.02415247f, 0.02904571f, 
    0.03817389f, 0.01284669f, -0.06372134f, -0.04978563f, -0.00389791f, -0.01245602f, 0.04411478f, -0.03333202f, 
    -0.01420618f, -0.00646577f, -0.01116277f, 0.00972124f, 0.00914852f, -0.03085908f, 0.00057137f, -0.02014631f, 
    -0.05901284f, -0.04694498f, -0.01873999f, 0.05231632f, -0.04259089f, -0.00170996f, -0.02284200f, -0.03480938f, 
    -0.02507774f, -0.04943184f, 0.03510161f, 0.01706118f, 0.03180378f, 0.00279304f, 0.02238602f, -0.00375467f, 
    -0.03876493f, -0.00051538f, -0.02649561f, 0.00741042f, 0.05359784f, -0.04333904f, -0.01779608f, -0.00077382f, 
    0.02685513f, -0.01247510f, 0.01826361f, -0.02622848f, 0.04468579f, -0.01217306f, -0.05422631f, 0.02525837f, 
    0.03941581f, 0.03013693f, -0.04297785f, -0.03681710f, 0.04240311f, -0.01816664f, 0.00993476f, -0.00911046f, 
    -0.04340713f, 0.01155042f, 0.02613735f, -0.03030604f, -0.02153421f, -0.04671159f, 0.01650349f, -0.05844264f, 
    0.05666621f, 0.04974692f, -0.04955396f, 0.01366722f, -0.01155627f, 0.01807103f, 0.01319879f, -0.07117038f, 
    0.00307285f, 0.01072582f, -0.06318097f, -0.01682979f, -0.02990597f, -0.04534715f, 0.01810364f, -0.05635044f, 
    0.01797697f, -0.01272526f, 0.03808734f, 0.00934269f, 0.03484805f, -0.04007362f, -0.04814851f, -0.05405379f, 
    0.06016262f, 0.03881113f, -0.03674624f, -0.02032630f, -0.04950134f, -0.02257441f, 0.02415196f, -0.03468084f, 
    -0.04950886f, 0.01268726f, 0.03970888f, -0.05396588f, -0.00155215f, -0.02561478f, 0.02002583f, 0.03360597f, 
    -0.01435637f, -0.05916149f, -0.00929414f, -0.02611645f, -0.01098342f, -0.01197701f, -0.00200954f, -0.04529773f, 
    0.00972886f, 0.00561753f, -0.02812092f, -0.02234192f, -0.00717459f, 0.03044369f, 0.00256492f, 0.01598666f, 
    -0.00282711f, 0.03252364f, 0.02282491f, -0.04441942f, -0.03747191f, 0.02892497f, -0.04093646f, 0.02193639f, 
    0.04025434f, -0.03952046f, 0.04471721f, 0.04063444f, -0.01939688f, -0.05611334f, 0.04932924f, 0.01880878f, 
    -0.04160825f, -0.03297943f, 0.03189056f, -0.01433000f, 0.01834011f, 0.03021971f, 0.00969856f, 0.00926197f, 
    0.02136533f, 0.03949178f, -0.04018475f, -0.04114085f, -0.00637422f, -0.00866822f, -0.03211959f, 0.00805021f, 
    0.00709180f, -0.06410201f, -0.05577455f, 0.02241316f, -0.06953449f, 0.00175809f, -0.02429187f, 0.03695789f, 
    -0.03291104f, 0.05225550f, -0.01908330f, -0.04327808f, -0.06580667f, 0.02421369f, -0.03475296f, 0.00008544f, 
    -0.04151687f, 0.01577089f, -0.00850678f, -0.05072244f, 0.01896018f, 0.00705345f, 0.00594410f, 0.01216896f, 
    0.05494290f, -0.04401782f, -0.03605191f, -0.04830396f, 0.00774113f, -0.04232807f, 0.03297672f, 0.03017532f, 
    -0.05037181f, 0.00407820f, 0.06410982f, 0.03423315f, -0.02926607f, 0.00548516f, -0.04017827f, -0.00129120f, 
    0.04365082f, 0.02461708f, 0.03066673f, 0.04193673f, 0.04002795f, 0.00568977f, -0.02642773f, 0.05741281f, 
    -0.01654831f, -0.05420961f, 0.02562162f, -0.03662307f, 0.02779224f, -0.05977631f, -0.04903002f, 0.00242036f, 
    -0.03973925f, -0.04135083f, 0.01565661f, 0.04139777f, -0.05480849f, 0.00574832f, -0.05095563f, 0.03177934f, 
    -0.02097914f, -0.01109577f, -0.06179295f, -0.03378287f, 0.00638436f, 0.05434101f, -0.01395491f, 0.00536900f, 
    -0.04210668f, 0.00612432f, -0.04537423f, 0.03598456f, -0.05988566f, 0.03555183f, 0.02014733f, -0.01670953f, 
    -0.02001601f, 0.03585931f, -0.06300014f, -0.06067143f, -0.01468820f, 0.03153603f, -0.06081427f, -0.00883273f, 
    -0.06448480f, 0.02293637f, -0.06610330f, -0.02202904f, 0.04008954f, -0.01750649f, 0.00634422f, 0.04895160f, 
    -0.00211223f, 0.00704437f, -0.00026710f, -0.01319335f, -0.05411232f, -0.04710303f, -0.05446702f, 0.04303147f, 
    -0.00601244f, -0.02054585f, 0.02361802f, -0.00002951f, 0.00711224f, 0.03836077f, -0.02330458f, 0.00910476f, 
    -0.03204953f, 0.02864147f, 0.00310375f, -0.02553968f, -0.06211614f, 0.00061585f, -0.03331538f, -0.05289441f, 
    0.03134984f, -0.02483884f, 0.02520416f, 0.04841425f, 0.03238555f, -0.02491820f, -0.03279854f, -0.04152006f, 
    -0.05317189f, 0.01900358f, -0.05663787f, -0.04744506f, 0.02978765f, 0.03521004f, -0.03592242f, 0.05127563f, 
    -0.03852240f, 0.04927443f, -0.02309054f, 0.04314379f, -0.04387296f, -0.03124007f, 0.03839197f, 0.02462279f, 
    -0.02564395f, 0.04383976f, 0.01513689f, -0.04549202f, -0.04556761f, 0.02121808f, -0.05367345f, -0.03846074f, 
    -0.05622110f, -0.04623102f, 0.00517560f, 0.00276932f, 0.01728080f, -0.05134393f, -0.02542067f, 0.02737877f, 
    -0.02805056f, -0.02602979f, 0.01673338f, -0.03412192f, -0.06154910f, -0.03006870f, -0.02376104f, 0.06050274f, 
    -0.01168358f, -0.10159537f, -0.07563527f, -0.19652036f, -0.18089896f, -0.16570812f, -0.05431293f, 0.00538876f, 
    0.05506944f, 0.31500947f, -0.59294266f, -0.11650146f, 0.00989165f, -0.23725352f, -0.06279048f, -0.11487503f, 
    0.11167756f, 0.22065295f, -0.28362966f, 0.06957419f, 0.13625595f, 0.08426696f, 0.13946280f, -0.01731196f, 
    -0.04543791f, 0.01288337f, -0.08886147f, 0.06425086f, 0.09250545f, 0.35387510f, -0.30449143f, 0.10841825f, 
    0.00452027f, 0.16014612f, 0.10243859f, -0.05838669f, 0.01605276f, 0.05936722f, -0.23954262f, 0.06361800f, 
    -0.05116578f, -0.10076999f, -0.04736159f, -0.12902403f, -0.04067142f, 0.11489111f, 0.03279299f, -0.00055393f, 
    -0.08348404f, -0.07112727f, -0.09450448f, 0.16557696f, 0.19592088f, 0.07169364f, -0.09863786f, 0.00111098f, 
    -0.10761217f, -0.10189665f, -0.01162235f, 0.06000727f, -0.07719821f, 0.15097369f, 0.07161064f, -0.09042387f, 
    0.20637329f, -0.06585322f, -0.11525491f, 0.07758208f, -0.08650549f, 0.08746619f, 0.02928791f, 0.24321261f, 
    -0.09278774f, -0.15491296f, -0.18727206f, -0.09874380f, 0.02404938f, 0.09112725f, 0.04117395f, 0.11990291f, 
    -0.02721155f, 0.08520665f, -0.02809044f, -0.13336815f, -0.05781915f, 0.00702883f, -0.12619668f, 0.03387419f, 
    0.08863045f, 0.06466740f, 0.06125903f, -0.30296779f, -0.16115052f, -0.12851617f, -0.09410971f, -0.22355066f, 
    0.31168962f, 0.00418047f, -0.03036879f, -0.08185901f, 0.01496306f, -0.06145343f, 0.01759909f, -0.16497155f, 
    -0.26937908f, -0.15260184f, 0.01659620f, 0.02761029f, 0.19531344f, -0.09636377f, 0.07463318f, -0.07634605f, 
    0.06117447f, -0.00601841f, 0.02779084f, -0.01780395f, 0.12407820f, 0.17794104f, 0.30160668f, 0.20219776f, 
    -0.03376822f, 0.08931775f, 0.04191979f, -0.08176353f, 0.15792942f, 0.24702218f, 0.16989119f, -0.08520048f, 
    0.30136690f, 0.04460332f, 0.06902361f, -0.02171745f, 0.11878996f, 0.11348826f, 0.31259844f, -0.20591348f, 
    0.34429365f, 0.12130747f, 0.10251433f, -0.03524961f, 0.17503655f, 0.00403191f, 0.04430689f, 0.18951255f, 
    -0.02271814f, -0.13729450f, 0.22197543f, 0.02469548f, 0.13238154f, -0.01924722f, 0.06183910f, -0.01923480f, 
    -0.03169456f, 0.06050150f, -0.25195986f, -0.32380703f, -0.02268383f, -0.13744810f, -0.26959512f, 0.14859283f, 
    0.19413212f, 0.10175429f, 0.05704351f, -0.22581886f, -0.03896970f, -0.14413600f, -0.10580916f, 0.01005946f, 
    0.04224163f, 0.09700618f, 0.14542238f, 0.27082980f, 0.16376053f, 0.19486275f, -0.02349323f, -0.12061049f, 
    0.01247681f, 0.18552302f, 0.02542589f, 0.08551855f, -0.10799016f, 0.14810003f, 0.09170450f, 0.02811019f, 
    -0.14358352f, -0.09880532f, -0.17112358f, -0.11218051f, 0.01832870f, -0.14229678f, -0.17907543f, -0.23985362f, 
    -0.03073902f, 0.01167972f, 0.12426660f, 0.09486064f, 0.11344996f, 0.01467067f, -0.03872710f, -0.12760843f, 
    -0.04281689f, 0.02237870f, 0.04512358f, -0.23333554f, 0.05594297f, 0.13106695f, 0.08426269f, 0.19941182f, 
    -0.19210269f, 0.02939310f, 0.02943195f, -0.04690727f, -0.02686855f, 0.05362670f, 0.02317998f, 0.02010049f, 
    0.13743414f, 0.09330068f, 0.18571389f, 0.02933322f, 0.12224117f, 0.16752946f, 0.12080077f, 0.17676520f, 
    0.25049400f, 0.07435344f, 0.13749769f, 0.06817986f, 0.04313837f, -0.06351492f, -0.03902175f, 0.10579965f, 
    0.10728168f, 0.21698430f, -0.17590675f, -0.22101244f, 0.03733983f, -0.07732426f, -0.04689886f, -0.25369370f, 
    -0.08861516f, 0.00461025f, -0.02186413f, -0.03570930f, -0.00350292f, 0.10890092f, -0.23648126f, -0.09676080f, 
    -0.16829522f, -0.03724074f, -0.04145818f, 0.09486740f, -0.07201148f, 0.37181792f, 0.18242687f, 0.06421870f, 
    0.06314708f, 0.05040127f, 0.16120343f, 0.18120168f, 0.13842037f, -0.19142812f, -0.03078761f, 0.24247369f, 
    0.08850311f, -0.03095744f, -0.03124363f, 0.04243119f, 0.05860407f, -0.02126122f, -0.13384478f, -0.23966897f, 
    -0.12546133f, 0.10928534f, -0.02775106f, 0.19521965f, -0.08697474f, 0.03999136f, 0.18097338f, 0.00103607f, 
    -0.24311852f, -0.16925696f, -0.08837659f, -0.06499350f, -0.01603919f, -0.05203230f, -0.04980505f, -0.12138277f, 
    -0.00036600f, -0.21687979f, -0.21189828f, -0.08601303f, 0.00959918f, 0.02358146f, 0.00436885f, 0.10355290f, 
    -0.02795694f, 0.06655541f, -0.02196288f, -0.01019999f, -0.05863582f, -0.02704288f, 0.00663368f, -0.05311623f, 
    0.17266478f, 0.07591329f, 0.10672843f, -0.10623504f, 0.15642436f, -0.09245063f, 0.09558488f, 0.04099882f, 
    0.07255784f, 0.03135249f, -0.15671954f, -0.13073382f, 0.05175350f, 0.10670815f, 0.04311696f, 0.07915474f, 
    -0.01510880f, -0.05795405f, 0.00721086f, 0.03856430f, -0.02588110f, 0.11234262f, 0.01512632f, 0.01771666f, 
    0.10872792f, -0.04782547f, 0.16308957f, -0.09308288f, -0.09275907f, 0.03926677f, -0.04136086f, -0.10634422f, 
    0.01113189f, 0.08273599f, 0.06733622f, 0.13925010f, 0.10910951f, 0.03688162f, 0.04741973f, -0.01071415f, 
    -0.09178044f, 0.01776653f, -0.01795529f, 0.11213201f, -0.06410926f, 0.17565493f, -0.06972408f, 0.11383054f, 
    -0.01202543f, -0.24221547f, 0.04079976f, 0.08437974f, -0.00536974f, 0.13041253f, 0.22997244f, 0.19779529f, 
    -0.03500141f, -0.08073290f, 0.03636511f, 0.01427043f, 0.04670617f, 0.00229764f, -0.16971213f, -0.15829916f, 
    -0.10317212f, -0.01025574f, 0.04723755f, -0.12114377f, -0.07349218f, 0.11613383f, 0.00861702f, -0.02119162f, 
    0.02431290f, 0.03235980f, 0.09722062f, -0.08120628f, 0.06268274f, 0.05963347f, 0.05085181f, 0.08500083f, 
    -0.26583904f, 0.00907016f, 0.17860729f, -0.11950934f, -0.20263825f, -0.24733503f, -0.08906920f, 0.05175636f, 
    0.00082370f, -0.04696598f, 0.09229175f, 0.03423627f, -0.05804189f, -0.10048161f, 0.01387716f, 0.03881310f, 
    0.01243009f, -0.08151649f, -0.13929373f, 0.08029684f, 0.15764655f, -0.19084682f, 0.02180418f, -0.01097189f, 
    0.11102561f, 0.12751073f, 0.08472906f, 0.08027598f, -0.04371640f, 0.16346467f, 0.09694062f, 0.07231798f, 
    0.01865987f, 0.24877781f, 0.08728358f, -0.18870272f, 0.10232402f, 0.00769253f, 0.23663664f, 0.03025774f, 
    -0.06782321f, -0.08713371f, -0.06135863f, 0.08932880f, 0.11362200f, 0.03057948f, 0.15175854f, 0.17806058f, 
    0.01941428f, -0.08409703f, 0.02416369f, 0.02579011f, 0.05850895f, -0.07794438f, 0.17969318f, 0.17277473f, 
    -0.16019849f, 0.10085161f, -0.18296303f, -0.15718231f, -0.11693418f, -0.06447582f, 0.14345396f, 0.04859305f, 
    -0.14316520f, 0.07134937f, -0.06031887f, -0.02411629f, -0.17182100f, 0.04423397f, 0.11628906f, 0.05994620f, 
    0.04250653f, 0.02903589f, 0.24592929f, -0.00010091f, 0.10500033f, -0.11347717f, -0.01437540f, -0.12305725f, 
    0.10051678f, -0.01519140f, 0.08420927f, -0.00047929f, 0.17954113f, 0.05422896f, -0.38670844f, -0.11900372f, 
    -0.06880111f, -0.06233975f, -0.08976824f, -0.08937486f, 0.02983011f, -0.06692068f, -0.13965844f, 0.01132536f, 
    0.01510393f, 0.12254299f, -0.06749932f, -0.04610062f, -0.04561413f, -0.23389380f, 0.09842154f, 0.09721558f, 
    -0.02612811f, 0.07501340f, 0.16532302f, 0.08216843f, 0.01747262f, -0.04321935f, 0.14227456f, -0.06478959f, 
    -0.10894369f, -0.16547865f, 0.05483535f, 0.12626353f, 0.04247120f, 0.00248325f, -0.04593135f, -0.04136929f, 
    -0.16621198f, 0.12708189f, 0.07354265f, 0.04245987f, -0.14281957f, -0.00277020f, 0.06737977f, -0.03110242f, 
    0.16147886f, 0.13175169f, 0.08538794f, -0.02480679f, 0.08976588f, 0.10073908f, -0.00419394f, 0.01002495f, 
    0.10677768f, 0.02067958f, -0.17763075f, -0.30095217f, -0.18436211f, 0.04070302f, 0.20716332f, 0.04780066f, 
    -0.06899945f, -0.00995507f, -0.20869079f, -0.15852202f, -0.00771236f, 0.15976566f, 0.00450127f, 0.13043407f, 
    0.00699067f, -0.03327249f, 0.01842441f, 0.01801689f, 0.08334608f, 0.04340013f, -0.12723528f, -0.03963219f, 
    0.00374766f, -0.02199023f, 0.07205371f, 0.20886587f, 0.12488338f, -0.02258673f, -0.22777699f, 0.06426363f, 
    0.15908003f, 0.06845819f, -0.16173309f, -0.10300647f, 0.12420129f, -0.17632642f, 0.16745822f, -0.07665414f, 
    0.06201733f, -0.01251213f, 0.11566985f, 0.10862378f, 0.02212922f, -0.17516942f, 0.09676334f, -0.08286785f, 
    -0.04816682f, -0.08602171f, -0.06292724f, 0.04623251f, 0.07575453f, -0.07067631f, -0.11600349f, -0.35947713f, 
    -0.15881497f, -0.00400203f, 0.06984735f, -0.00618224f, -0.18771768f, 0.01998410f, -0.31557199f, 0.03723020f, 
    -0.05160180f, 0.18317924f, -0.21151479f, -0.16887575f, 0.11060958f, -0.01713761f, -0.09517074f, -0.02629895f, 
    -0.01333231f, -0.06805228f, 0.18316998f, 0.11562005f, -0.11280558f, -0.00252580f, 0.06286272f, -0.07733924f, 
    -0.04163824f, 0.14555214f, 0.06051828f, 0.10926814f, -0.05193282f, -0.14333287f, 0.02144435f, 0.22864535f, 
    -0.05450913f, 0.08105616f, -0.04897818f, 0.04526604f, -0.12680584f, -0.18542057f, -0.01870244f, 0.02397401f, 
    -0.02535154f, -0.11625338f, -0.01739461f, 0.02559405f, 0.28228581f, -0.11324932f, -0.06200304f, -0.01841980f, 
    -0.08233806f, -0.02278701f, -0.06406430f, -0.17697747f, -0.09084293f, -0.10752734f, 0.34909904f, -0.01182716f, 
    -0.06973375f, 0.04413786f, 0.08495002f, 0.04183249f, 0.03567301f, 0.10205335f, 0.07967178f, 0.25059238f, 
    -0.01054526f, 0.10618519f, 0.14625825f, 0.00989283f, -0.05136583f, -0.16543625f, 0.03671583f, 0.15263799f, 
    -0.03147634f, 0.07933554f, 0.09708548f, -0.09516948f, 0.01208157f, -0.04778942f, 0.00758030f, 0.16778883f, 
    0.18372010f, -0.10642786f, -0.04682744f, 0.14127111f, 0.02196939f, 0.01852917f, -0.02403570f, -0.12606341f, 
    0.08721211f, -0.00587748f, -0.07214417f, -0.13379112f, -0.06260809f, -0.20631281f, -0.06819086f, -0.10147586f, 
    0.08491293f, 0.16657613f, 0.05583818f, -0.07679109f, -0.00828208f, -0.09708061f, -0.13750347f, 0.01170232f, 
    -0.01770213f, 0.01222026f, -0.05747435f, -0.19554886f, 0.07582284f, 0.01885311f, -0.04044649f, -0.02072271f, 
    0.08944207f, 0.03145860f, 0.12602741f, -0.02663230f, -0.18833944f, 0.16486053f, 0.01011829f, 0.10276697f, 
    0.11647125f, 0.03788409f, -0.10832704f, -0.02147730f, -0.19321014f, -0.06549609f, -0.16249578f, -0.07579675f, 
    -0.04585535f, 0.01985458f, -0.01637233f, 0.11323516f, 0.13553791f, -0.01691436f, 0.06156841f, 0.07557780f, 
    0.22794312f, 0.00952933f, 0.07012831f, -0.01725636f, 0.09984410f, -0.01622479f, -0.12439273f, -0.21888633f, 
    0.18184707f, 0.11545805f, -0.00743346f, -0.08977208f, 0.02911419f, -0.11947431f, 0.05226614f, 0.15492815f, 
    0.05263587f, -0.27265361f, 0.06987424f, 0.09413282f, -0.04799621f, -0.16442187f, -0.10757913f, -0.00219294f, 
    0.06243579f, 0.15132022f, -0.15373348f, 0.00396085f, 0.13506132f, -0.06324808f, 0.04512354f, 0.04954073f, 
    -0.30886164f, -0.22488752f, 0.08411378f, -0.13419901f, 0.06029502f, 0.03750228f, -0.03481349f, -0.03357407f, 
    0.09008319f, 0.08280129f, 0.02925912f, 0.09673379f, 0.17894563f, -0.08398313f, 0.05586924f, 0.05329021f, 
    -0.09092465f, -0.09029916f, 0.15568858f, -0.15047061f, 0.10853359f, 0.05094605f, -0.04419415f, -0.01993748f, 
    -0.04728091f, 0.01583675f, -0.01501586f, 0.05374796f, 0.22482991f, 0.10781308f, -0.12155960f, -0.04371884f, 
    0.03207484f, 0.20730671f, 0.13255711f, -0.03806192f, -0.07954221f, -0.14124842f, -0.12639824f, 0.07299950f, 
    -0.25816429f, -0.04322950f, 0.09512029f, -0.09400451f, -0.04211314f, 0.05539500f, 0.02413365f, 0.04431453f, 
    0.07441400f, 0.01411315f, -0.08597538f, 0.15231341f, 0.20546518f, 0.14150143f, 0.09101397f, 0.06583390f, 
    0.23890951f, -0.09091334f, -0.03440038f, 0.08252669f, 0.07186072f, -0.04191829f, -0.01742740f, -0.09874170f, 
    -0.18114309f, -0.14619823f, -0.10040635f, -0.18515876f, -0.28568485f, 0.01153507f, -0.04674382f, 0.07620040f, 
    -0.01518596f, 0.08531228f, 0.08459396f, -0.15582891f, -0.15758099f, -0.21540411f, 0.05113621f, 0.02102879f, 
    -0.05304409f, 0.11619826f, 0.02133974f, -0.37136427f, 0.11406860f, 0.18604280f, 0.10961691f, 0.08224691f, 
    0.02119615f, 0.04235641f, 0.07037924f, -0.07868570f, 0.04530483f, 0.00824419f, -0.15455765f, 0.19590542f, 
    -0.03898826f, -0.01656698f, 0.13072658f, 0.05148586f, 0.06875192f, 0.16305785f, 0.06597658f, 0.09250235f, 
    -0.08651842f, -0.04203675f, 0.08561575f, 0.04545625f, -0.04368845f, -0.02772452f, 0.10692259f, -0.17813578f, 
    -0.17235918f, 0.10463887f, -0.05705183f, -0.02472360f, -0.00915673f, 0.05759963f, 0.21154122f, 0.13700359f, 
    0.08009379f, 0.00958165f, -0.32215428f, 0.04558535f, 0.07109934f, -0.00768090f, -0.06969529f, 0.03982275f, 
    -0.12596235f, 0.00359908f, 0.02913245f, -0.28663865f, -0.03695355f, 0.05415729f, 0.22417922f, 0.10598030f, 
    0.02970842f, -0.13581155f, -0.21715067f, 0.23107931f, 0.21314612f, 0.11119113f, 0.18476757f, 0.00995551f, 
    -0.16252260f, -0.05922585f, -0.03249936f, 0.08804048f, 0.23290943f, 0.17217468f, 0.01181874f, -0.06487449f, 
    -0.14401452f, 0.02476108f, -0.12236626f, 0.10860173f, 0.24581127f, 0.07849343f, 0.09262928f, 0.00646378f, 
    -0.02515351f, -0.10342927f, -0.19980808f, -0.01126723f, -0.00762307f, 0.01361171f, -0.00946736f, -0.05022585f, 
    0.00740225f, 0.07436445f, 0.07261503f, -0.04517768f, 0.00235405f, 0.02974979f, -0.05764337f, 0.17494886f, 
    0.12026729f, -0.11629406f, 0.02019572f, -0.02025064f, 0.08868223f, -0.08922654f, 0.00104416f, -0.14328638f, 
    0.19380456f, 0.01144954f, -0.07203697f, 0.24549906f, -0.01830749f, -0.07529541f, -0.19689135f, -0.03876256f, 
    -0.08727200f, 0.16416401f, -0.07178542f, -0.03717751f, 0.10960995f, -0.01978111f, 0.06289792f, 0.08615980f, 
    0.02758840f, 0.14029969f, 0.10624460f, -0.18275559f, 0.07597016f, 0.08314434f, 0.07435500f, -0.01883272f, 
    0.09661156f, -0.10767937f, -0.10342407f, -0.05437618f, 0.00321427f, -0.07188551f, -0.01909371f, 0.24022792f, 
    -0.09436055f, 0.05775461f, -0.21480383f, 0.02916975f, 0.03126676f, 0.06980518f, -0.02036238f, 0.02399722f, 
    0.04865631f, -0.08328711f, 0.06007482f, -0.08424111f, 0.03899349f, -0.03674204f, -0.05676148f, -0.02090386f, 
    0.09256337f, 0.17516112f, 0.05542197f, 0.10384189f, 0.01083898f, -0.10647956f, -0.09025227f, 0.08429334f, 
    0.10175066f, 0.00533734f, 0.02937011f, 0.19072218f, 0.10078724f, 0.13155136f, 0.17159820f, -0.03260678f, 
    0.09044235f, -0.07509552f, 0.05492483f, 0.12228875f, 0.22199255f, 0.02087752f, -0.28097203f, -0.17456479f, 
    -0.03775132f, -0.09467842f, 0.01598530f, -0.02987241f, 0.06229085f, -0.01452549f, 0.11099169f, 0.18686096f, 
    -0.21936566f, 0.13225254f, 0.22802626f, 0.15073393f, 0.19541979f, -0.04729807f, -0.03882191f, -0.06407782f, 
    -0.07209579f, 0.01088889f, -0.01901179f, 0.13166642f, 0.07874332f, -0.06529096f, -0.11251006f, 0.20940499f, 
    -0.08388652f, 0.20267370f, -0.00819636f, -0.01957822f, -0.05327042f, 0.06473393f, 0.10096277f, -0.00325152f, 
    0.13229625f, -0.08333384f, 0.02952444f, 0.25865945f, 0.06126444f, 0.14898393f, -0.02228263f, 0.00799189f, 
    0.05628158f, -0.05929414f, 0.11743908f, -0.08256747f, -0.35302699f, -0.30528823f, -0.14800136f, -0.00328118f, 
    0.15401463f, 0.05358841f, -0.01127421f, -0.07595929f, 0.02317246f, 0.04684880f, 0.04985385f, 0.00328615f, 
    -0.04059814f, 0.04862315f, 0.00125525f, -0.03416057f, 0.11285492f, -0.03416392f, -0.09750716f, 0.10969882f, 
    0.03790728f, 0.03295161f, -0.04970225f, 0.14405535f, 0.04468207f, 0.04380006f, -0.04928306f, -0.40381533f, 
    -0.31730941f, -0.25197080f, 0.06077023f, 0.18150476f, 0.09452032f, 0.10655378f, -0.01557312f, -0.05378718f, 
    -0.04719966f, -0.08372956f, 0.10238980f, 0.01584144f, 0.06476963f, -0.02466377f, -0.06178695f, -0.01100355f, 
    0.00071191f, -0.09610002f, 0.15830930f, 0.06352826f, -0.02501957f, -0.00261810f, 0.01163684f, 0.04436742f, 
    0.04176788f, 0.01060237f, -0.28709412f, -0.30006978f, -0.32515815f, 0.10459967f, 0.11313950f, -0.05317851f, 
    -0.10549705f, -0.18921359f, -0.04535106f, 0.23732021f, -0.04242803f, 0.01380288f, -0.06184610f, -0.09513587f, 
    -0.10789572f, 0.06990499f, -0.07332674f, 0.05123030f, -0.15531124f, -0.19370531f, -0.14625925f, -0.01826611f, 
    -0.10247856f, 0.22302620f, 0.06169873f, 0.12338127f, 0.04905901f, -0.12724417f, 0.14983189f, -0.08838889f, 
    -0.04882189f, 0.13312429f, -0.00892546f, 0.13026382f, -0.00648331f, -0.03500322f, -0.18033363f, 0.10817077f, 
    0.18885501f, 0.11166442f, 0.06344928f, 0.07668718f, -0.01881049f, 0.16713768f, -0.19981837f, -0.00267307f, 
    -0.02652587f, -0.13100930f, -0.02312859f, -0.07906665f, -0.25183490f, -0.05659422f, -0.09565278f, -0.14029418f, 
    0.06983738f, 0.03223788f, -0.03262439f, 0.05038472f, 0.03308532f, -0.04180026f, 0.02448398f, 0.03572294f, 
    0.04390178f, -0.02294619f, -0.05486792f, -0.06461611f, -0.01345284f, -0.00591683f, 0.03265753f, -0.01638747f, 
    0.01899136f, -0.01985877f, 0.01551365f, -0.06169291f, -0.08251353f, 0.03770583f, -0.00904367f, -0.03663269f, 
    -0.03549025f, -0.05011739f, -0.01066034f, 0.06109360f, -0.01630910f, -0.00966406f, 0.04988085f, 0.00908330f, 
    -0.02247658f, -0.06197070f, 0.06825206f, -0.05454071f, -0.00509383f, -0.01667316f, -0.03389079f, 0.00933226f, 
    0.02386549f, -0.01989663f, -0.02998339f, -0.00239914f, -0.04725954f, 0.01118934f, 0.04177640f, -0.02691452f, 
    -0.04843982f, 0.01596442f, 0.02369521f, 0.06473602f, -0.03033600f, 0.01269721f, 0.02312404f, -0.05687417f, 
    -0.01591160f, -0.00453291f, -0.04232011f, -0.07901423f, 0.02311579f, -0.03631793f, -0.03633547f, 0.01837590f, 
    0.00007624f, 0.05508482f, -0.00009122f, 0.03012780f, -0.06046121f, -0.05815706f, -0.01710620f, 0.01824178f, 
    -0.04558097f, -0.00728036f, 0.03815305f, 0.01934793f, -0.01471916f, -0.06613286f, -0.04460371f, 0.02353968f, 
    0.02212048f, -0.03307385f, 0.04986641f, -0.00072804f, 0.02384931f, -0.01553154f, -0.03326530f, -0.03842136f, 
    0.03233149f, -0.05976348f, 0.05567116f, 0.00486896f, -0.01436335f, -0.02742874f, -0.04717193f, 0.02776662f, 
    0.02301830f, -0.03231689f, -0.04214763f, 0.01813639f, 0.02057201f, 0.00382157f, 0.01146772f, -0.05048771f, 
    -0.04985707f, -0.03054305f, -0.03429872f, -0.01728196f, -0.03452244f, 0.04370951f, -0.08275740f, -0.01704892f, 
    -0.06500190f, -0.00292022f, -0.05166849f, 0.03240369f, -0.06633659f, 0.05963775f, -0.04845579f, -0.05160659f, 
    -0.05606775f, 0.00966456f, -0.08133688f, -0.01700232f, 0.02772387f, 0.02207742f, 0.00281043f, -0.06753883f, 
    -0.07429685f, -0.07763910f, -0.07190330f, -0.06347539f, -0.05304784f, -0.04364704f, 0.01013959f, 0.02325783f, 
    -0.06167790f, -0.03360685f, -0.03983041f, 0.03792380f, -0.01360711f, -0.05440397f, -0.00167991f, -0.03832813f, 
    0.02700811f, -0.00770280f, -0.01683278f, 0.03013671f, 0.00811330f, -0.05285548f, -0.04339524f, 0.00524690f, 
    0.03872317f, 0.02850696f, -0.05092737f, -0.03797052f, -0.02269006f, 0.02817771f, 0.00170947f, 0.07418574f, 
    -0.03708713f, -0.04271189f, 0.02525170f, 0.00756639f, 0.05871916f, -0.07252655f, -0.04456839f, -0.04087738f, 
    0.00626720f, -0.07235484f, -0.03521001f, 0.03254744f, -0.06490918f, -0.04077336f, -0.02332274f, 0.00202625f, 
    0.01101160f, -0.06497291f, -0.02717576f, -0.04913783f, 0.03992393f, 0.02064320f, -0.04201043f, 0.03112435f, 
    -0.03780401f, 0.02021967f, -0.03968050f, -0.05390652f, -0.03820095f, 0.01630096f, -0.06185226f, -0.03641017f, 
    -0.07226199f, 0.02682766f, -0.03194470f, -0.00858358f, 0.03738697f, -0.03802174f, 0.06828030f, -0.02333785f, 
    -0.03846236f, -0.08148676f, -0.02105605f, 0.02740955f, -0.01523030f, -0.01185087f, 0.01858513f, -0.03398801f, 
    0.01793787f, -0.01173450f, -0.05986962f, 0.02002940f, -0.04956122f, -0.00123824f, -0.03914709f, -0.00067052f, 
    -0.02033729f, 0.01342652f, 0.02977656f, -0.01474048f, -0.06745651f, 0.03252577f, -0.03688955f, 0.03371775f, 
    -0.05391096f, 0.05438666f, -0.03796598f, -0.01940094f, -0.06382312f, -0.05181922f, -0.01100140f, -0.03444310f, 
    0.02321369f, 0.03329751f, -0.00491682f, -0.02529585f, -0.00754877f, 0.02114667f, -0.00424411f, 0.01838467f, 
    -0.04786898f, -0.01269293f, -0.06339244f, -0.01336243f, 0.00581539f, -0.01191013f, -0.02848070f, 0.04221705f, 
    -0.05031414f, -0.07369077f, -0.03139970f, -0.04958972f, 0.02997183f, 0.02781899f, 0.00817455f, -0.04536523f, 
    0.00144941f, -0.05892744f, 0.01133062f, 0.01693146f, -0.07589673f, -0.00257956f, 0.00839141f, -0.07161047f, 
    -0.01624337f, -0.06531883f, -0.00115443f, 0.00769091f, -0.06666962f, -0.07784401f, 0.04720491f, -0.01843916f, 
    0.00863616f, -0.04469474f, 0.03929426f, 0.01353342f, -0.01263370f, -0.02756806f, 0.02815409f, -0.02770009f, 
    0.01443380f, -0.07284967f, -0.02568971f, 0.01486954f, -0.05907774f, 0.03329710f, -0.01579970f, -0.05185068f, 
    -0.14952925f, -0.02860745f, 0.04196046f, 0.13812141f, -0.10266639f, -0.01013723f, -0.20622140f, 0.07752365f, 
    0.02114902f, 0.21875408f, 0.30381301f, -0.35600877f, -0.07836781f, 0.00526757f, -0.07265428f, 0.04538202f, 
    -0.02577305f, 0.18622634f, -0.04935644f, 0.03822563f, 0.12566824f, 0.04355133f, -0.07972970f, 0.06544116f, 
    -0.00221623f, -0.04060097f, 0.17653668f, -0.12651728f, 0.02985600f, -0.08523762f, -0.08853122f, 0.05389524f, 
    0.00797707f, -0.08541705f, 0.21930660f, -0.12837376f, -0.03551617f, -0.12220284f, -0.23371322f, -0.00039260f, 
    0.18420213f, -0.06934531f, -0.05762115f, -0.17133835f, -0.03312442f, 0.04610921f, -0.11770363f, -0.17642625f, 
    0.04268666f, 0.01104502f, 0.09104842f, 0.03212202f, 0.07432054f, 0.03990578f, 0.27424073f, -0.23158856f, 
    -0.27150980f, -0.07617940f, 0.09664974f, 0.13523981f, -0.03630400f, 0.05698980f, -0.03833496f, 0.25628155f, 
    -0.23334178f, -0.06728761f, 0.01595875f, -0.14029612f, 0.13241822f, 0.15424764f, -0.05870554f, 0.05601013f, 
    -0.00767521f, -0.17003982f, 0.08746251f, -0.06835622f, 0.01622236f, -0.06112699f, -0.00713601f, -0.08704675f, 
    -0.06472126f, 0.10227450f, -0.16294046f, -0.33260301f, 0.18658310f, -0.19969270f, 0.00277852f, 0.03346067f, 
    0.21347862f, 0.07310548f, 0.03745379f, -0.27249071f, -0.06145332f, 0.12316975f, 0.11385135f, 0.03633150f, 
    -0.28316471f, -0.00826328f, -0.06795361f, 0.14579871f, -0.01793137f, -0.10553734f, 0.33872402f, -0.15511785f, 
    0.02047677f, -0.04306941f, -0.04623774f, -0.01134535f, 0.42308709f, 0.02393135f, 0.17329513f, 0.23216814f, 
    -0.01706599f, 0.14280745f, 0.10260204f, 0.07220246f, -0.01053883f, -0.11017308f, -0.04607064f, -0.32237738f, 
    -0.07916844f, 0.04040933f, 0.03085771f, 0.17309716f, 0.14830098f, 0.17879921f, -0.10794239f, 0.05349979f, 
    0.07638962f, 0.05994722f, -0.04560668f, -0.00631297f, 0.06280605f, -0.20249899f, -0.00481198f, -0.38914946f, 
    -0.06234002f, 0.04483670f, -0.00731900f, 0.05030448f, 0.00838634f, 0.00685401f, -0.05663801f, 0.06444231f, 
    0.01646993f, 0.04159344f, 0.09150266f, 0.13402717f, -0.09427217f, 0.01159208f, 0.01911454f, -0.12494896f, 
    -0.14298145f, -0.07266070f, -0.13833363f, -0.29784608f, 0.12440091f, 0.08284765f, 0.13707198f, 0.15598238f, 
    -0.06793692f, 0.13828690f, -0.14281639f, -0.09275231f, -0.27880105f, 0.13345514f, -0.27964112f, 0.03623451f, 
    0.01199637f, 0.06399240f, -0.02300478f, 0.66008711f, 0.02752014f, -0.46254271f, -0.01219023f, 0.01482980f, 
    0.06582123f, 0.04384664f, 0.09461203f, -0.06039052f, -0.31709170f, -0.08999769f, 0.17537715f, 0.07910683f, 
    -0.04292316f, 0.07222593f, -0.14088015f, 0.07609139f, -0.00855845f, 0.05264498f, -0.15877590f, -0.10872185f, 
    -0.04595035f, -0.03587175f, -0.04437061f, -0.07825363f, -0.13967469f, -0.11524688f, -0.05081366f, -0.12132467f, 
    -0.20832869f, 0.09920201f, 0.05021518f, -0.00758628f, 0.05425811f, 0.09693427f, 0.05786389f, 0.24035931f, 
    0.03635669f, 0.15176676f, -0.03495124f, -0.05468367f, -0.02785677f, 0.16169539f, -0.11643725f, -0.09778503f, 
    -0.18833584f, 0.07829870f, -0.25738922f, -0.03916295f, -0.11332145f, 0.01307844f, 0.21915771f, -0.18907617f, 
    0.02960680f, 0.02644669f, 0.00487597f, 0.13624611f, 0.03232389f, -0.11896170f, 0.08348535f, 0.01117880f, 
    -0.12674071f, -0.02735451f, 0.36498559f, 0.07291819f, 0.31467319f, 0.21677096f, -0.01505634f, 0.01132801f, 
    0.02570331f, -0.07530411f, -0.21232572f, 0.38352540f, 0.14848317f, 0.28709731f, 0.20537858f, 0.06852724f, 
    -0.05231205f, -0.08410697f, -0.02551589f, -0.00241890f, -0.31171417f, -0.03731076f, 0.01049544f, 0.04295224f, 
    -0.01550078f, 0.12666219f, 0.05375941f, -0.01619021f, -0.06085690f, 0.15873811f, 0.09612810f, 0.03340039f, 
    -0.09630860f, -0.18750443f, -0.06624264f, 0.16424111f, 0.02502898f, -0.03206531f, -0.03754065f, 0.42383415f, 
    -0.29172695f, -0.11586767f, -0.04332085f, 0.03598962f, 0.13726693f, -0.16472523f, 0.15457395f, -0.04098244f, 
    -0.10017552f, 0.02777350f, -0.04637874f, -0.03773114f, -0.11707378f, -0.15304530f, -0.05420008f, -0.17628969f, 
    -0.55051708f, -0.40739578f, 0.04769042f, 0.11348555f, 0.09433860f, -0.07200946f, -0.06198194f, 0.00249060f, 
    0.03913854f, -0.53415293f, -0.22088806f, -0.22579373f, -0.00697748f, -0.17988253f, 0.12873064f, 0.04107885f, 
    -0.07740057f, 0.00183255f, 0.21427025f, 0.13861357f, 0.25530276f, -0.15969916f, 0.03010143f, -0.01690987f, 
    0.05789901f, 0.06386360f, 0.10406087f, -0.35935992f, -0.12852369f, 0.04654849f, -0.19048800f, -0.15423870f, 
    -0.06973746f, 0.03329033f, -0.04949064f, -0.04076011f, -0.20710698f, -0.22139665f, -0.10606290f, 0.00955495f, 
    -0.06593194f, -0.00729453f, -0.05868318f, -0.15959255f, 0.06709363f, -0.14292619f, -0.05154048f, -0.04974118f, 
    -0.08413750f, -0.03055877f, 0.10639194f, 0.11659935f, 0.05226501f, 0.08311640f, -0.22879854f, -0.41688010f, 
    -0.50027388f, 0.07479421f, -0.07604631f, 0.09404372f, 0.07309487f, 0.00213692f, 0.07667939f, -0.41131148f, 
    -0.28933814f, -0.13178678f, -0.03276363f, -0.00738333f, -0.03560312f, -0.05073651f, 0.05367250f, -0.02820358f, 
    0.11138830f, -0.06104481f, 0.06159067f, 0.05285551f, 0.06523207f, -0.02601041f, 0.00811870f, 0.11023165f, 
    0.06937346f, -0.10116571f, -0.23074062f, -0.05036223f, 0.12589452f, -0.01112910f, 0.03011879f, 0.07307404f, 
    0.11263242f, 0.11282203f, -0.17665885f, -0.13561003f, 0.17753288f, -0.21278976f, -0.04432818f, -0.00025493f, 
    0.06110807f, 0.07612617f, -0.03691924f, -0.09781148f, -0.52597535f, 0.00658100f, -0.04054461f, -0.03455779f, 
    -0.01320604f, -0.10645504f, 0.04924202f, 0.06488582f, 0.10058948f, 0.20089193f, -0.12655757f, 0.07854024f, 
    0.00427614f, 0.16085288f, 0.17374074f, 0.03791185f, -0.06682164f, -0.28420722f, 0.05384896f, 0.03880031f, 
    0.05872665f, -0.10335547f, -0.02645177f, 0.19050567f, 0.02325038f, -0.00415391f, 0.10601668f, -0.02612385f, 
    0.09520779f, 0.18788831f, 0.00326608f, -0.04328422f, 0.12677309f, 0.09966747f, -0.09248529f, -0.03489777f, 
    0.06710193f, 0.15960538f, -0.10163552f, 0.11156570f, -0.01744396f, 0.28435570f, -0.02375963f, 0.03677062f, 
    0.10199668f, 0.10398705f, 0.19563386f, -0.04037120f, 0.10241111f, -0.02101853f, -0.06305493f, 0.02789611f, 
    0.10539406f, -0.13115196f, -0.22894619f, 0.02068173f, 0.06732814f, -0.00571042f, 0.10486688f, -0.00532835f, 
    -0.19325966f, 0.12366650f, 0.00285892f, -0.24096379f, -0.07946785f, 0.01238687f, 0.04529136f, -0.12521189f, 
    0.16494466f, 0.05254405f, 0.00800946f, -0.09220586f, -0.48252118f, -0.28815097f, 0.12594996f, -0.04205104f, 
    0.10254244f, 0.00585267f, -0.02606694f, 0.04153564f, -0.39675039f, -0.16898260f, 0.35734680f, -0.27926773f, 
    -0.08593756f, 0.11785127f, -0.08436146f, 0.21095553f, 0.08273401f, 0.04174216f, -0.04387104f, -0.11920860f, 
    -0.02345130f, 0.03282872f, -0.02330036f, 0.00610515f, 0.15213305f, -0.02675766f, -0.08487817f, -0.10977767f, 
    0.10038541f, -0.00171243f, -0.24975958f, -0.02385920f, 0.17152202f, 0.06783774f, -0.03319026f, 0.01851147f, 
    0.10028579f, 0.25290835f, -0.03167361f, 0.02587807f, 0.06280866f, 0.01446646f, 0.01864020f, 0.00712069f, 
    0.15253861f, -0.13982238f, -0.11885032f, 0.09352607f, -0.12262870f, -0.10910679f, 0.12984650f, 0.04961728f, 
    0.04493878f, -0.22456971f, -0.37215135f, 0.10783634f, -0.01041186f, -0.09035520f, 0.01703953f, 0.16828947f, 
    -0.04954719f, -0.08683322f, -0.09172796f, 0.09802024f, 0.20965974f, -0.17276134f, -0.10471024f, 0.05092585f, 
    -0.02501480f, -0.10471939f, -0.02886310f, 0.20405702f, 0.15816784f, 0.04517205f, 0.07020488f, 0.08432795f, 
    -0.04284473f, -0.04984179f, -0.06619120f, -0.00940472f, -0.04108826f, -0.01353893f, 0.23612143f, 0.03141519f, 
    -0.02208977f, 0.02607727f, 0.14068298f, 0.07435244f, 0.00612323f, 0.13106173f, -0.00943038f, 0.06220821f, 
    0.14241134f, 0.11021180f, 0.11007868f, -0.03104697f, 0.06385802f, 0.06463212f, -0.13300310f, -0.12898061f, 
    0.17936493f, -0.04928949f, -0.05677301f, 0.12403214f, 0.14186092f, 0.06263913f, 0.03755964f, -0.17575127f, 
    -0.12361962f, -0.03495045f, -0.00536595f, 0.06062462f, -0.02425167f, -0.14096950f, -0.06904544f, 0.01998488f, 
    -0.12808870f, -0.13038182f, -0.08852278f, 0.06731058f, 0.09443468f, 0.14472534f, -0.06841453f, 0.14753719f, 
    -0.06620650f, -0.34109476f, -0.20555446f, -0.09948687f, 0.16576894f, -0.13657202f, 0.18921830f, 0.04014291f, 
    0.03729073f, -0.02937312f, 0.15324913f, -0.15562807f, -0.00609592f, 0.00664901f, -0.09883292f, -0.21389323f, 
    0.05492542f, -0.01598207f, 0.08134329f, -0.15876894f, -0.19137979f, 0.21341334f, 0.16385341f, -0.16024776f, 
    -0.12899850f, -0.04960677f, -0.01744309f, -0.07814185f, -0.05619338f, 0.10396753f, 0.23805054f, -0.07473788f, 
    -0.01027518f, 0.17072283f, 0.00419698f, 0.08116508f, -0.02036702f, -0.02129070f, -0.01399807f, 0.04867577f, 
    -0.06629124f, -0.07599777f, -0.05267914f, 0.10575231f, 0.03634248f, 0.01846184f, -0.02294938f, -0.26608780f, 
    -0.25214851f, -0.09097648f, 0.02175816f, 0.08441281f, -0.06226359f, 0.14379467f, -0.20566183f, -0.11324190f, 
    -0.16588363f, 0.11750313f, -0.08388303f, 0.03289564f, -0.01753992f, -0.24602140f, 0.09851005f, -0.15687484f, 
    0.15801713f, -0.00988886f, 0.05876459f, -0.01790563f, -0.05518325f, -0.06589359f, 0.13697672f, 0.10247480f, 
    -0.02120428f, -0.19946659f, -0.19993234f, -0.10751072f, -0.00807309f, 0.03561855f, 0.11812626f, -0.05684442f, 
    0.02127928f, 0.00637614f, 0.01912139f, -0.04098945f, 0.07347488f, -0.24075118f, -0.11324764f, -0.24906918f, 
    0.26938942f, -0.10188358f, -0.05929700f, -0.09662913f, -0.24915662f, -0.09481069f, 0.11100545f, 0.12361562f, 
    0.12316462f, 0.04062467f, -0.00527948f, -0.00287886f, 0.10136262f, -0.16253734f, -0.22620714f, 0.08209680f, 
    -0.05579263f, 0.11915420f, 0.05733429f, 0.04284401f, -0.09182656f, 0.19984151f, -0.07729022f, 0.05515842f, 
    0.10466163f, -0.10589449f, -0.01913911f, -0.04254563f, -0.06622364f, -0.13778904f, -0.04970898f, -0.22380665f, 
    0.16004829f, 0.00832268f, -0.07707807f, -0.00722041f, 0.06449571f, 0.16639714f, -0.09212687f, 0.24261060f, 
    -0.09586640f, -0.09151437f, -0.11690589f, -0.02185952f, -0.14162244f, 0.10780241f, -0.07081593f, 0.00051486f, 
    0.08657803f, -0.16497116f, 0.15915088f, -0.05259638f, 0.01065299f, -0.08668695f, 0.01050389f, 0.03273859f, 
    0.09611628f, -0.02255676f, -0.06359666f, 0.19707596f, -0.09416950f, 0.04552251f, 0.13488944f, 0.12924477f, 
    0.20616351f, 0.03983241f, -0.09120663f, -0.07567000f, 0.11037666f, 0.08076426f, 0.03363046f, 0.04182175f, 
    -0.08571321f, -0.09409700f, -0.00139442f, -0.19995524f, -0.09837496f, -0.29325300f, 0.06910630f, -0.03326473f, 
    0.11159731f, 0.00079303f, 0.09895657f, 0.09868709f, -0.04373572f, 0.16221802f, 0.15065089f, 0.00458190f, 
    -0.02134289f, -0.03369967f, 0.01090727f, 0.17113268f, 0.05246194f, 0.01459246f, 0.00466313f, -0.03318384f, 
    -0.13015634f, -0.09607101f, -0.02939981f, 0.08653396f, 0.10171295f, 0.00805295f, 0.14333513f, 0.08091025f, 
    0.08412728f, -0.13818969f, -0.06473631f, -0.21614170f, -0.02697118f, -0.04074182f, -0.10116463f, 0.03709626f, 
    0.09517788f, 0.24660009f, 0.01120786f, -0.04120332f, 0.06150508f, -0.03446734f, 0.04804350f, -0.04923593f, 
    -0.06846793f, -0.08239100f, 0.25191295f, 0.22701780f, -0.01156674f, -0.14758135f, 0.14696766f, -0.09406079f, 
    -0.00450081f, -0.11684839f, -0.11750440f, -0.03528768f, 0.03945134f, 0.15183413f, 0.10648440f, 0.05498683f, 
    -0.10329943f, -0.16135330f, 0.25541782f, 0.19903341f, 0.23493248f, -0.02535501f, -0.00487162f, 0.10274404f, 
    0.02691697f, -0.01732166f, -0.05480357f, 0.20630111f, 0.02264741f, 0.14735241f, 0.01893525f, 0.06967834f, 
    0.13435908f, 0.04709428f, 0.06237664f, -0.04337416f, 0.25654611f, -0.06412917f, 0.07656192f, -0.08161068f, 
    -0.06617904f, -0.08707348f, 0.08278614f, -0.06693037f, 0.06601641f, 0.16365387f, 0.06813357f, -0.17276651f, 
    -0.11779211f, 0.19320211f, 0.17507125f, -0.01544354f, 0.00792795f, 0.03726758f, 0.18040644f, 0.08055000f, 
    0.06171659f, -0.08361234f, 0.02189258f, 0.04243842f, -0.05931079f, 0.04265198f, 0.02795667f, 0.05449869f, 
    0.17242613f, 0.08182972f, 0.07330986f, 0.10262327f, 0.04951733f, 0.11042184f, -0.10092214f, -0.10333234f, 
    -0.17875420f, 0.10082833f, 0.03283879f, -0.04416331f, 0.06574080f, -0.02438067f, 0.09546173f, 0.07413793f, 
    -0.09457407f, -0.36666098f, 0.04850419f, 0.14587016f, -0.01886702f, 0.12820154f, -0.05836521f, -0.09354685f, 
    0.01506292f, 0.12345695f, -0.03219599f, -0.13691732f, -0.03588603f, 0.13443805f, -0.07634965f, -0.09390453f, 
    -0.06541647f, -0.08565834f, 0.13526957f, 0.04055768f, -0.14281745f, 0.31416708f, -0.08304901f, 0.05502151f, 
    0.00919697f, -0.06748668f, 0.01073431f, 0.05021746f, -0.03957532f, 0.10287587f, 0.04050181f, 0.15130393f, 
    0.14021687f, -0.04425709f, 0.01334537f, 0.10394734f, 0.12695310f, -0.17066427f, 0.06773755f, 0.01286320f, 
    -0.02763844f, 0.01927424f, -0.03832681f, 0.01878922f, 0.06132821f, 0.01033324f, 0.06573451f, -0.02942577f, 
    0.18211427f, -0.04879734f, 0.17508364f, -0.12152378f, -0.12973210f, -0.04894472f, 0.01003345f, -0.13843401f, 
    0.08229974f, 0.04815447f, -0.00074112f, 0.16584554f, -0.06276282f, -0.22132136f, 0.03211420f, -0.08496181f, 
    -0.11874465f, 0.06121324f, -0.09245553f, 0.09389790f, 0.01972969f, -0.00007428f, 0.09507937f, 0.14275771f, 
    0.13147457f, -0.28575662f, 0.01401963f, 0.07671612f, 0.02424772f, -0.00684712f, 0.10982098f, -0.03948721f, 
    0.06629197f, 0.00558073f, -0.25809339f, 0.02179559f, 0.06732309f, -0.02948831f, -0.02688959f, -0.14460523f, 
    -0.06735157f, -0.00180344f, 0.13398683f, -0.11481617f, 0.00907348f, 0.03598401f, 0.00327924f, -0.00648914f, 
    0.11548483f, 0.05986596f, -0.07188400f, -0.04232932f, -0.01202569f, -0.12827134f, -0.26971862f, -0.00442710f, 
    -0.01729021f, 0.13660252f, -0.01413092f, 0.09543683f, -0.05683338f, -0.04267166f, -0.19610615f, -0.03580556f, 
    0.02669834f, -0.11720166f, 0.08961994f, -0.18795416f, -0.09787754f, -0.22997175f, -0.11699414f, 0.21868415f, 
    -0.33462963f, 0.01860051f, -0.01111843f, 0.05055486f, -0.10595151f, 0.09200830f, -0.01019928f, 0.05559878f, 
    0.10157304f, -0.02843125f, -0.01513634f, -0.05700058f, -0.05548336f, -0.13429487f, -0.18445551f, -0.23245896f, 
    -0.06537841f, 0.08783742f, -0.01445543f, 0.00573594f, -0.07678160f, -0.13606524f, 0.09340498f, 0.04723606f, 
    0.07451063f, -0.04343947f, -0.04721743f, 0.09812077f, 0.02483646f, 0.16583864f, 0.00069839f, 0.03218073f, 
    0.13489696f, 0.00347073f, -0.25821862f, 0.01482176f, -0.06951194f, -0.04359322f, -0.07947427f, 0.02998845f, 
    -0.14126323f, 0.07332848f, 0.04771353f, -0.16760136f, 0.05793548f, 0.00668908f, 0.05447910f, 0.05567923f, 
    0.08012947f, -0.00458123f, 0.08549871f, 0.03413410f, -0.12161592f, 0.01455697f, 0.01142277f, 0.01077219f, 
    -0.11765531f, 0.07794315f, 0.15511794f, 0.04428465f, 0.14313653f, -0.09862927f, -0.03383789f, -0.01864973f, 
    -0.01000948f, -0.04459108f, -0.09317596f, 0.09718655f, 0.22875050f, 0.23151307f, -0.04497264f, 0.04550470f, 
    0.00795159f, 0.03029819f, -0.04022371f, -0.01387705f, -0.07613908f, -0.02985580f, -0.04336659f, 0.01649065f, 
    0.21636620f, 0.10369714f, -0.04117428f, -0.00384763f, 0.07191318f, -0.02110492f, 0.15959673f, 0.04068058f, 
    -0.12790519f, 0.06670082f, 0.08507919f, 0.13725817f, 0.18236920f, -0.06986276f, -0.04752807f, -0.19179428f, 
    0.17484844f, -0.28631294f, 0.01193812f, 0.01439257f, -0.09262232f, -0.00426566f, -0.00430663f, -0.12646708f, 
    -0.06164867f, -0.16373959f, 0.02400470f, 0.08364694f, -0.08273155f, -0.12431473f, -0.01260180f, 0.10560511f, 
    0.11190055f, 0.10827819f, 0.08511683f, 0.03225879f, -0.43231785f, -0.20186110f, -0.01793987f, 0.00790066f, 
    0.01172789f, 0.02453180f, 0.02637352f, -0.03160307f, 0.12360946f, -0.01602861f, -0.03356906f, -0.02135622f, 
    -0.05348433f, -0.04004532f, -0.04121823f, -0.16449200f, -0.03065124f, 0.00089771f, 0.07136168f, -0.00862717f, 
    0.08728456f, 0.13154379f, 0.07109258f, 0.03749739f, 0.17010289f, 0.05800620f, -0.02500177f, 0.15521529f, 
    -0.02932131f, 0.12907524f, 0.13508497f, -0.16643129f, 0.08438914f, -0.00683584f, 0.02069979f, 0.02316952f, 
    0.09835590f, -0.16456088f, 0.09496783f, 0.20757718f, 0.02702697f, 0.23002568f, 0.12314144f, -0.04585198f, 
    0.09115172f, 0.10226847f, -0.02586438f, -0.03355428f, 0.04231042f, 0.00027425f, 0.06744356f, 0.04487346f, 
    -0.00196496f, -0.11586966f, 0.13558023f, -0.21086600f, 0.01052715f, 0.19506557f, 0.05539552f, 0.13955469f, 
    0.06192929f, 0.14380546f, -0.01476190f, -0.07240615f, 0.23722278f, 0.04252435f, 0.06000305f, -0.06186258f, 
    0.00501305f, -0.18452917f, 0.02305645f, -0.09020065f, 0.12267520f, 0.13021404f, -0.05992666f, 0.08792458f, 
    -0.05563456f, -0.08657810f, -0.00522107f, -0.08393385f, 0.02245986f, 0.24156579f, 0.00346794f, 0.10712817f, 
    -0.03272891f, -0.04683473f, 0.00376834f, 0.00961896f, 0.01521842f, 0.00459130f, -0.00335867f, -0.16402441f, 
    0.07540638f, 0.02333401f, 0.06489430f, -0.00548096f, -0.00486793f, -0.21119234f, 0.20756948f, -0.08130559f, 
    -0.08691920f, 0.01660378f, 0.08455537f, -0.04112140f, 0.02422762f, 0.07405604f, -0.06986687f, -0.15743129f, 
    -0.02014347f, -0.05294782f, 0.08158835f, 0.06532268f, 0.12670310f, -0.02056790f, -0.05401634f, 0.13281752f, 
    0.04380177f, -0.11366797f, -0.11080659f, 0.05423218f, 0.02891891f, 0.11746947f, -0.10938086f, -0.24353640f, 
    -0.19669470f, 0.00323480f, 0.11360341f, -0.13052951f, 0.10291147f, 0.00422828f, -0.05469976f, 0.04470484f, 
    -0.06869414f, -0.04554955f, 0.08972476f, 0.07564887f, -0.07681766f, 0.10447487f, -0.07732687f, -0.07687323f, 
    -0.12534668f, -0.10013420f, 0.01294210f, -0.07928126f, 0.10758450f, -0.16628371f, 0.03863465f, 0.01212740f, 
    0.05822185f, 0.17618732f, -0.00654693f, -0.06769744f, -0.02165567f, 0.15352522f, 0.16061720f, -0.12599672f, 
    -0.01451288f, -0.00327630f, 0.04695232f, 0.06014732f, 0.13930702f, -0.06483714f, 0.13171092f, -0.01848115f, 
    -0.07303651f, 0.00925496f, 0.11505692f, 0.13149691f, 0.07832178f, 0.03887402f, 0.04717698f, 0.07133351f, 
    -0.09463596f, 0.16614118f, -0.05010286f, 0.07549153f, 0.09652787f, 0.04447542f, -0.01188531f, 0.02396401f, 
    0.09338675f, 0.03678903f, 0.12240884f, 0.01108834f, 0.06936946f, 0.04953337f, 0.13210683f, 0.25805992f, 
    -0.07546815f, 0.10835069f, -0.00495356f, 0.16823684f, 0.17751029f, -0.04875198f, 0.08850282f, -0.25417781f, 
    -0.23853575f, 0.08759606f, 0.07669380f, -0.07778448f, 0.01878145f, 0.05252140f, 0.04385490f, 0.11911226f, 
    -0.10087217f, -0.10987475f, -0.00316378f, 0.18970998f, -0.11884062f, -0.03278469f, -0.03096183f, 0.05657435f, 
    0.08554867f, 0.02441898f, -0.08948872f, -0.14724819f, 0.12702346f, 0.00126783f, 0.01856739f, -0.06185332f, 
    -0.05278373f, 0.09438727f, 0.07190521f, -0.02360962f, 0.12280174f, 0.06930973f, -0.08988243f, -0.13727793f, 
    0.24078350f, 0.14112431f, -0.06196654f, -0.04916596f, -0.07962515f, 0.09375458f, -0.12996292f, -0.05653908f, 
    0.06207573f, -0.00728837f, -0.05233254f, -0.01618155f, -0.05502874f, -0.26860404f, 0.18109590f, -0.07241805f, 
    0.04000987f, 0.01615951f, 0.08703040f, -0.06562413f, 0.02273792f, -0.04930402f, -0.07266496f, 0.06057278f, 
    0.23039089f, -0.08135805f, 0.08967238f, 0.01402452f, -0.03864154f, -0.12048895f, -0.09838612f, -0.06728040f, 
    -0.15715206f, -0.01888615f, -0.04093711f, -0.03298047f, 0.01689525f, 0.06459534f, 0.12203149f, -0.05310568f, 
    -0.04780411f, 0.16774787f, 0.18316872f, -0.23254313f, 0.03827322f, 0.07186291f, -0.02693985f, 0.10975553f, 
    0.01133651f, -0.08778150f, 0.21003743f, 0.14444853f, 0.00410650f, 0.24674149f, 0.08605170f, 0.08551241f, 
    -0.09249127f, -0.03288100f, -0.18163042f, 0.04612583f, 0.42177293f, 0.44450295f, 0.23384875f, 0.04588204f, 
    -0.04746490f, -0.00661855f, -0.02421997f, -0.05186439f, -0.01721658f, 0.01031633f, -0.08834481f, -0.11413956f, 
    0.02398234f, 0.07493796f, 0.02346352f, 0.03254503f, 0.19079371f, 0.05034655f, -0.02916709f, -0.13436024f, 
    0.00705208f, -0.09253994f, 0.11433088f, 0.00762370f, -0.06386255f, -0.14151849f, -0.02355133f, -0.11484776f, 
    0.00650237f, -0.05739286f, 0.04332707f, 0.02533571f, -0.09483874f, 0.08697746f, -0.16787477f, 0.19235753f, 
    0.18227279f, -0.06484561f, 0.04682031f, -0.11369179f, -0.07171426f, -0.07101859f, -0.10669216f, -0.19935909f, 
    0.04002401f, -0.06893934f, 0.01446366f, -0.00029188f, -0.05436194f, 0.01987642f, -0.00516338f, 0.03055286f, 
    0.00175802f, 0.06054287f, 0.02696170f, 0.03420880f, -0.05311224f, -0.01768381f, -0.00101205f, -0.01972214f, 
    -0.04352181f, -0.04694964f, -0.05501920f, -0.01953547f, -0.01432254f, 0.01850319f, -0.01145229f, 0.03857158f, 
    -0.05145980f, -0.05023044f, 0.03942819f, -0.05161696f, 0.00718011f, -0.02070979f, 0.04829988f, -0.05185987f, 
    -0.01673519f, -0.03368497f, -0.03706426f, -0.01081079f, -0.02474659f, 0.02985399f, -0.04489728f, -0.06054496f, 
    -0.05767584f, -0.03863434f, 0.04644521f, 0.04019279f, -0.03712558f, -0.02799781f, 0.02684535f, -0.02103191f, 
    -0.04256271f, 0.05042680f, -0.05224640f, 0.04341877f, 0.03800092f, 0.04770652f, -0.04772875f, -0.00141625f, 
    -0.06320635f, 0.00471522f, 0.03820586f, 0.01192896f, -0.00280809f, -0.05509498f, -0.06901716f, 0.01503795f, 
    -0.01289731f, -0.01497401f, 0.01921491f, 0.00839024f, 0.01763893f, 0.05038627f, -0.04133036f, 0.03022673f, 
    -0.06235468f, 0.01968522f, -0.05965933f, 0.02288455f, -0.04846568f, -0.03357311f, 0.01329805f, 0.03132070f, 
    0.04531524f, -0.02725171f, -0.06018331f, 0.01980880f, -0.02792530f, -0.05699580f, 0.01104605f, 0.05201016f, 
    0.01639825f, -0.00059597f, -0.04818715f, 0.03096174f, 0.03627662f, -0.02482966f, -0.02549699f, 0.04657881f, 
    -0.04220840f, 0.02445837f, 0.04698643f, 0.01355555f, 0.03601487f, 0.01078960f, -0.02710105f, 0.01445950f, 
    -0.05541574f, -0.05170579f, 0.04991158f, -0.05068577f, 0.00066846f, -0.05350358f, -0.04115656f, -0.02785324f, 
    0.00510658f, -0.02371037f, -0.04640765f, -0.02364414f, -0.02921876f, -0.06369643f, 0.04842372f, -0.01948733f, 
    0.03692817f, 0.04238990f, -0.00800302f, 0.03458774f, -0.03016311f, 0.03061523f, 0.02963355f, -0.02943393f, 
    0.00777156f, 0.03267784f, -0.03483433f, -0.06812941f, 0.04867481f, -0.00147490f, -0.01059450f, -0.01245329f, 
    0.04162442f, -0.02696515f, 0.00204048f, 0.02173307f, -0.02860156f, -0.05295558f, 0.01222354f, -0.01499173f, 
    0.01460710f, 0.00710634f, 0.00972518f, -0.03731527f, -0.03094378f, -0.03606596f, 0.01334459f, -0.04518574f, 
    -0.03166573f, -0.02690656f, 0.01193731f, 0.04496702f, 0.00162279f, -0.05123021f, -0.04605126f, 0.00209051f, 
    -0.01734175f, -0.00073467f, -0.04748790f, -0.01288654f, 0.00980644f, -0.01585613f, -0.00564881f, -0.02150654f, 
    0.00869965f, -0.03284876f, -0.05125325f, -0.05798446f, 0.03122444f, -0.00492519f, 0.03274792f, 0.04380881f, 
    0.03749555f, 0.03612453f, -0.01226925f, 0.01411988f, -0.03940645f, -0.00412549f, 0.04691499f, 0.03779304f, 
    -0.02271417f, 0.03650717f, -0.01601277f, -0.04438201f, -0.03205493f, 0.01661881f, 0.04022887f, -0.00105951f, 
    -0.00383986f, -0.05302338f, -0.06146324f, -0.06543336f, -0.02857057f, -0.01694212f, -0.02685571f, 0.04092128f, 
    0.01966875f, 0.03076776f, 0.01627585f, 0.04714905f, -0.04626288f, 0.05001494f, -0.02852061f, -0.04655324f, 
    -0.04983640f, 0.01752051f, -0.02496644f, 0.05011909f, -0.04116639f, 0.03928925f, -0.03002705f, -0.00059357f, 
    -0.05693460f, -0.06869432f, -0.02363396f, 0.01639824f, -0.03618485f, 0.02088238f, -0.05858770f, 0.00437207f, 
    0.00617870f, 0.02710758f, -0.02123985f, -0.02947312f, 0.02969031f, -0.03241107f, 0.03772895f, -0.02946886f, 
    -0.04640718f, 0.01003883f, 0.05389942f, 0.01983434f, -0.05020091f, -0.02947468f, -0.02803439f, 0.01552200f, 
    -0.03912798f, -0.02238905f, -0.01667973f, -0.00972773f, -0.01326136f, 0.02395367f, 0.03991346f, -0.01605253f, 
    -0.01049081f, -0.04966611f, 0.06545027f, -0.05826325f, -0.03839457f, -0.02749600f, -0.05828585f, -0.04947248f, 
    -0.05127430f, -0.04331038f, 0.00631228f, -0.03303662f, -0.05230648f, -0.03272413f, -0.05689848f, 0.02325814f, 
    0.02632450f, 0.01382833f, 0.00554475f, -0.01238680f, -0.01359656f, 0.02012715f, -0.05793091f, 0.02933215f, 
    0.03685753f, 0.03225803f, 0.02461901f, 0.02953601f, 0.00951630f, 0.01440716f, 0.02617324f, 0.04089722f, 
    -0.03600093f, 0.03721778f, 0.03452171f, -0.01989615f, -0.06798145f, -0.04435302f, 0.03276190f, -0.03734061f, 
    -0.08042003f, -0.01107201f, 0.03941862f, 0.01269575f, -0.08779422f, -0.02156407f, -0.00685861f, 0.02515769f, 
    -0.06924815f, -0.02781501f, 0.01869669f, 0.00245318f, 0.01127147f, -0.01930343f, -0.08184439f, -0.01164695f, 
    -0.06071115f, -0.00968768f, 0.01416694f, -0.09602629f, -0.06207244f, -0.03253526f, -0.00867819f, -0.04894545f, 
    -0.08233932f, -0.05037266f, -0.03329419f, 0.01071768f, -0.04660637f, -0.00199324f, -0.07339846f, -0.06751257f, 
    0.01882502f, -0.01508936f, -0.03506975f, -0.06151954f, -0.06398435f, -0.02018131f, -0.00251174f, 0.02298306f, 
    -0.01030680f, -0.05437379f, -0.08894911f, -0.06512188f, -0.08705973f, -0.02189367f, 0.00128713f, -0.03560048f, 
    -0.03507951f, 0.01002011f, -0.04068490f, -0.05492856f, 0.03543825f, 0.01291549f, -0.04893997f, -0.07225377f, 
    0.00460031f, -0.07351641f, -0.05855384f, -0.08187694f, 0.01453368f, -0.07224811f, -0.08803505f, -0.01890968f, 
    0.00453678f, -0.08956845f, -0.07140122f, -0.07803966f, -0.05335028f, -0.03191838f, -0.09710307f, -0.08185858f, 
    -0.03469459f, -0.04511683f, -0.08498224f, 0.01030694f, -0.09290612f, 0.00248701f, -0.05374359f, -0.05153004f, 
    -0.01179642f, -0.05928461f, -0.04474672f, -0.00479348f, -0.01764888f, 0.01038857f, -0.07478563f, -0.01210211f, 
    0.00878624f, -0.01693908f, -0.04956564f, 0.02467364f, 0.01380877f, -0.10147411f, -0.06790376f, -0.01100189f, 
    -0.00016928f, 0.00522036f, -0.05390763f, -0.01327906f, -0.02944678f, 0.00089280f, 0.01955059f, -0.01115640f, 
    -0.05660683f, 0.01365734f, 0.00663683f, -0.00278993f, -0.07214368f, -0.06838637f, -0.09642215f, -0.01084624f, 
    -0.02320404f, -0.00854686f, -0.04117892f, -0.03299823f, 0.00497635f, -0.00267984f, -0.05512551f, -0.01976145f, 
    -0.02704860f, 0.01812769f, -0.00528071f, -0.05449859f, 0.01346492f, -0.01383682f, -0.07863362f, 0.00061419f, 
    -0.01687075f, -0.00779756f, -0.09967374f, -0.08055834f, -0.02575347f, -0.05867455f, -0.05329866f, -0.08572052f, 
    -0.03995198f, -0.08286599f, 0.00633934f, 0.00686534f, -0.04326753f, -0.02020898f, -0.07243966f, -0.07334314f, 
    -0.03608936f, 0.01067686f, -0.02514420f, -0.03195255f, -0.09612424f, -0.07454986f, -0.04907145f, -0.00432361f, 
    -0.04480177f, -0.01122633f, -0.03751434f, -0.05179525f, -0.05087763f, -0.01049354f, -0.07277576f, -0.08316109f, 
    0.00216695f, -0.03773952f, 0.00545320f, -0.08211385f, 0.00820470f, -0.02158399f, -0.05316367f, -0.03898453f, 
    -0.02267336f, -0.08878916f, -0.08305160f, -0.09242874f, -0.02160282f, -0.07886338f, -0.09043218f, 0.00719179f, 
    -0.07823775f, -0.06756747f, -0.07417733f, -0.06904247f, -0.00357070f, -0.02253742f, -0.08848520f, -0.01061225f, 
    0.00317590f, -0.00462608f, -0.07718619f, -0.00448917f, -0.05867860f, -0.07522499f, -0.05046199f, -0.04974886f, 
    -0.05682596f, -0.03214331f, -0.06809612f, -0.07953314f, -0.04400050f, -0.08884163f, -0.02964248f, -0.08276385f, 
    -0.06388249f, -0.02368337f, -0.04469498f, -0.03510144f, -0.04565833f, -0.03040119f, -0.01396726f, -0.08072734f, 
    0.01370955f, -0.01180582f, -0.08504706f, -0.03881758f, 0.00633779f, -0.09425616f, -0.07688954f, -0.02153122f, 
    -0.02510174f, -0.01234277f, -0.02799805f, -0.07151826f, -0.00089194f, -0.08108200f, -0.09078606f, -0.04442877f, 
    -0.02951820f, -0.04144131f, -0.06978669f, 0.02720377f, -0.04648185f, -0.02646266f, 0.00509873f, -0.01418190f, 
    -0.07613438f, -0.02322518f, 0.01322962f, -0.01152765f, -0.04334627f, -0.07800220f, -0.00042576f, -0.08905981f, 
    0.00875044f, 0.01127548f, 0.00317635f, -0.04003696f, -0.03694307f, 0.01185032f, -0.02465892f, -0.01721795f, 
    -0.01667899f, -0.06311267f, 0.03529178f, -0.01007103f, -0.01243560f, -0.03537097f, -0.08537636f, -0.00610929f, 
    -0.06062217f, -0.03756366f, -0.07814395f, -0.02946854f, -0.04736878f, -0.07735177f, -0.00427761f, -0.04944738f, 
    -0.09355699f, -0.09971415f, -0.03777552f, 0.00398560f, -0.08921379f, -0.00495255f, -0.05478240f, -0.00918833f, 
    -0.00714642f, -0.09898932f, -0.08393130f, -0.09544058f, -0.06155413f, -0.07639713f, -0.09305422f, -0.00818137f, 
    0.00834868f, -0.04757636f, -0.00961091f, -0.00493093f, -0.03342276f, 0.00587613f, -0.01815703f, -0.01448023f, 
    0.13166833f, 0.19436617f, -0.12255289f, -0.02319740f, -0.10274696f, -0.13649330f, -0.10432380f, -0.12419397f, 
    -0.03739109f, -0.11901941f, 0.29288048f, -0.30157039f, 0.08531311f, -0.01684305f, 0.09597887f, 0.23308106f, 
    0.18010528f, 0.01383469f, -0.02691291f, -0.24767089f, 0.01774061f, -0.00317311f, 0.07661935f, 0.01453284f, 
    -0.08051959f, 0.00211285f, -0.12862541f, -0.15520166f, -0.02036194f, 0.14962977f, 0.05994648f, 0.08894841f, 
    0.06683046f, -0.02054731f, -0.10504129f, -0.07844061f, 0.05590101f, -0.04472016f, 0.10602941f, -0.06594387f, 
    -0.10090657f, -0.08810149f, -0.14480881f, -0.11214880f, 0.19103698f, -0.03713799f, 0.20524423f, -0.05502413f, 
    0.03078556f, 0.08669278f, -0.00438189f, -0.01442862f, 0.11068127f, 0.09470106f, 0.10597031f, -0.28946665f, 
    -0.06775381f, 0.05782248f, -0.04152982f, 0.00290772f, -0.04683067f, 0.02767286f, -0.06251910f, 0.21578112f, 
    0.02328719f, -0.06742793f, 0.13796221f, 0.01574075f, -0.10898236f, 0.22798346f, -0.18575405f, -0.04104580f, 
    0.04260153f, -0.12266307f, -0.07357594f, -0.03042198f, -0.01148826f, 0.06753676f, -0.10804939f, 0.10058357f, 
    -0.13441315f, 0.14353704f, 0.23948903f, -0.28254569f, 0.04838204f, -0.00712429f, -0.04088619f, 0.05308608f, 
    0.00872043f, 0.04122540f, -0.19628821f, -0.15473200f, -0.03852643f, -0.05088508f, -0.00553928f, 0.03595465f, 
    -0.13993041f, 0.08236989f, -0.45900890f, -0.08346058f, 0.26210347f, -0.16807799f, -0.09729572f, 0.00401861f, 
    -0.02104161f, -0.11206710f, -0.05369692f, -0.04804486f, -0.02277156f, 0.12940794f, 0.15190908f, 0.20294710f, 
    0.13511778f, 0.09376423f, 0.16239050f, 0.19929130f, 0.00817393f, -0.31031200f, 0.24022765f, 0.25560927f, 
    0.17603450f, 0.08381137f, -0.02949629f, 0.14620343f, 0.03070166f, 0.09687869f, 0.13302831f, 0.14724278f, 
    0.18334094f, 0.14452940f, 0.12302306f, 0.22696479f, 0.15307210f, 0.14220057f, 0.05716674f, 0.09257744f, 
    -0.25425857f, 0.27036536f, -0.02364358f, 0.02640227f, 0.06577177f, 0.18441157f, 0.08571691f, 0.20385516f, 
    -0.10649126f, -0.06610555f, 0.10895885f, 0.05549114f, 0.03054581f, -0.00534022f, -0.09246538f, -0.05236952f, 
    -0.07527359f, -0.05293800f, 0.02049568f, -0.01283668f, 0.06699599f, -0.06182110f, -0.08547317f, -0.18674394f, 
    -0.05799968f, 0.05998620f, -0.03002390f, 0.15374163f, 0.00170719f, 0.06692863f, 0.02501403f, -0.07752952f, 
    0.10304003f, -0.10649347f, -0.10796033f, -0.11566293f, 0.31170201f, -0.03982802f, 0.09229866f, 0.00099177f, 
    0.01892079f, 0.01147595f, -0.02664723f, 0.04105287f, -0.10013876f, -0.16106349f, 0.00812150f, -0.23140940f, 
    0.04589935f, -0.01718409f, 0.07185494f, 0.08200178f, -0.01659428f, 0.10226261f, -0.17534836f, 0.01357341f, 
    -0.05342587f, -0.08890586f, -0.05155289f, -0.01245044f, 0.14996409f, -0.01107122f, -0.13923867f, 0.07821893f, 
    -0.01784107f, -0.05576120f, 0.07070173f, -0.04541659f, 0.02767901f, 0.06117848f, -0.06777100f, -0.05179993f, 
    0.06320617f, 0.14548008f, 0.18502775f, 0.10268435f, 0.11074585f, 0.00421683f, -0.12812951f, 0.04137686f, 
    -0.11301547f, 0.00384638f, 0.02312519f, 0.16339457f, 0.05204480f, 0.21817118f, -0.11688481f, -0.01303408f, 
    0.04765202f, 0.17496547f, 0.10381079f, -0.05712750f, -0.04499231f, 0.00010958f, -0.08293576f, 0.04243332f, 
    0.03576883f, 0.02025912f, -0.17448142f, 0.02185373f, 0.28570157f, 0.02916001f, 0.04679567f, -0.03876213f, 
    -0.04647184f, -0.11484073f, 0.04294224f, 0.12458643f, 0.16132894f, 0.25533149f, 0.12304007f, 0.02395965f, 
    -0.11001988f, 0.12769344f, -0.01237434f, -0.05081042f, 0.19581488f, -0.22657578f, 0.26023766f, -0.06958374f, 
    0.15618053f, 0.03774294f, 0.06986770f, 0.02989213f, 0.16355380f, 0.06706820f, 0.09623704f, 0.12104861f, 
    0.04040061f, 0.04881989f, 0.04025174f, 0.07016674f, 0.03419510f, -0.09818900f, 0.06281937f, -0.01382649f, 
    -0.10847123f, -0.03370105f, 0.07197707f, -0.01505277f, 0.02187791f, 0.06774461f, -0.07777710f, -0.02197987f, 
    0.17365105f, -0.01215984f, -0.10481016f, -0.20118123f, -0.22201818f, -0.02972342f, -0.08962452f, -0.03126693f, 
    0.10262863f, 0.17424780f, -0.04885785f, -0.10084492f, -0.11799975f, -0.07599928f, -0.01723949f, 0.03546198f, 
    0.02142810f, -0.06842326f, 0.00798515f, -0.30967113f, 0.01626024f, 0.21080001f, 0.11936823f, 0.05283324f, 
    0.04465760f, -0.00069617f, -0.13193703f, -0.51856416f, -0.44646215f, 0.01232190f, 0.13440627f, 0.17022356f, 
    0.17011495f, -0.00234421f, -0.01065987f, -0.50637531f, -0.19693501f, -0.45952663f, 0.17519048f, 0.13073695f, 
    -0.18226667f, 0.02331535f, -0.06646590f, -0.07870878f, 0.17135417f, -0.11585674f, -0.11457612f, -0.02215528f, 
    -0.07571347f, -0.08663557f, -0.00147194f, -0.08518939f, -0.00151743f, 0.16143213f, 0.18082906f, 0.13017000f, 
    -0.05613901f, -0.09332320f, -0.01391476f, -0.03260567f, -0.10575324f, 0.03802162f, 0.02469029f, -0.13148615f, 
    -0.21838641f, -0.10310768f, 0.11897812f, -0.18815243f, -0.09373273f, 0.12458581f, -0.05952510f, 0.04332643f, 
    0.02361060f, -0.30994189f, 0.01577357f, 0.13308217f, -0.01679193f, -0.02082920f, 0.09667270f, 0.08471030f, 
    0.00036149f, -0.08100998f, -0.05561579f, 0.03858999f, 0.01910321f, 0.12327699f, 0.17541949f, -0.03327514f, 
    0.04360624f, 0.19611773f, 0.17785560f, 0.13422385f, 0.05311187f, 0.19470406f, 0.04713548f, 0.13625686f, 
    0.07547892f, 0.03588478f, -0.15164024f, 0.14833929f, 0.09167548f, -0.00767718f, 0.04971429f, -0.06032705f, 
    0.08885318f, -0.10553721f, -0.09179067f, -0.02342017f, 0.12224024f, -0.00067173f, -0.01456840f, -0.10329169f, 
    0.02935162f, -0.06437152f, 0.01590372f, 0.11165975f, -0.39048827f, -0.21567822f, 0.03655344f, -0.09792751f, 
    0.05734111f, -0.00233164f, 0.06147044f, 0.08507188f, 0.05082462f, -0.44191065f, 0.04792850f, -0.20472601f, 
    -0.07676501f, 0.12269338f, -0.08290738f, -0.05994302f, -0.03514303f, 0.03966923f, -0.17696282f, 0.27059531f, 
    0.16984066f, 0.11974906f, 0.08587406f, 0.08739270f, 0.16358496f, 0.15420753f, 0.03744929f, 0.13341402f, 
    -0.72063541f, -0.32265455f, -0.23985974f, 0.07019460f, 0.21701282f, 0.02377832f, -0.07621791f, 0.00349728f, 
    -0.10504165f, -0.36198601f, -0.52723479f, -0.00897239f, 0.04663283f, -0.02291466f, 0.12012086f, -0.12008462f, 
    -0.11989675f, -0.21132135f, 0.10750886f, -0.07972437f, -0.13575372f, -0.02624506f, -0.06175543f, 0.02146836f, 
    -0.04270500f, -0.06676638f, 0.00358723f, 0.33023494f, 0.07610452f, -0.03934723f, 0.06116461f, -0.10554247f, 
    -0.08234823f, 0.03024395f, 0.16742004f, -0.16496302f, 0.12469968f, -0.03603377f, -0.03785535f, 0.13738795f, 
    0.07649253f, 0.09180503f, 0.05452509f, 0.02105979f, 0.11197203f, -0.33714914f, -0.72766572f, -0.13997380f, 
    -0.12251642f, 0.01116858f, 0.10712794f, -0.04269329f, -0.07994440f, -0.05202703f, -0.09974347f, -0.06025756f, 
    -0.06518237f, -0.05437382f, -0.00154628f, 0.07374032f, -0.03153345f, 0.03507292f, -0.02250088f, 0.28891110f, 
    0.02710981f, 0.01807067f, -0.10001691f, 0.00704114f, -0.05716315f, 0.05751511f, 0.07602842f, -0.24760833f, 
    -0.57654554f, -0.08604670f, -0.00282341f, 0.11682126f, -0.04900858f, 0.10940893f, 0.12259159f, 0.01780471f, 
    -0.02521687f, 0.12458129f, 0.05673132f, 0.03105145f, 0.18936518f, 0.01366140f, 0.22980127f, 0.12721299f, 
    0.09599308f, 0.16315477f, 0.16221407f, -0.06302554f, -0.01330007f, -0.04911724f, -0.09305368f, 0.02033141f, 
    0.08732633f, 0.19829476f, 0.20729406f, -0.35122269f, 0.13211067f, -0.10374947f, 0.03696256f, -0.02179707f, 
    -0.04636727f, -0.13516949f, -0.02904100f, -0.34988153f, -0.19962291f, -0.10078809f, -0.26011550f, -0.16720092f, 
    -0.13161606f, -0.01743028f, -0.01483447f, 0.07495350f, 0.12398078f, -0.29100758f, -0.25142160f, -0.05624319f, 
    0.08890703f, 0.13981988f, 0.02730981f, 0.01742359f, 0.06955777f, -0.20486178f, 0.05038980f, -0.28414729f, 
    -0.05400421f, 0.13099734f, -0.09606867f, 0.20951140f, -0.08373186f, -0.08236277f, 0.03216872f, 0.01636554f, 
    -0.39276639f, -0.04255874f, 0.06969241f, 0.11157133f, 0.10017319f, -0.02445418f, 0.05634363f, -0.09355021f, 
    0.00809701f, 0.02012449f, -0.07416027f, -0.22383733f, 0.03299361f, 0.03927037f, -0.05317483f, 0.18213114f, 
    0.09576567f, 0.11360856f, 0.17310248f, -0.09449030f, -0.19167078f, -0.04607453f, -0.03668034f, 0.04778262f, 
    0.00025992f, -0.34821603f, 0.18973155f, -0.16052513f, -0.13978913f, -0.27253702f, 0.10562586f, -0.14385766f, 
    0.16839306f, -0.01922990f, -0.27375674f, -0.05296964f, -0.05262654f, -0.09081052f, 0.07057087f, -0.04219082f, 
    -0.06466384f, 0.05961561f, -0.03085414f, -0.35556114f, 0.02897752f, -0.11246565f, -0.06868480f, -0.00144340f, 
    0.05309369f, -0.03302625f, 0.05584333f, 0.01442296f, 0.11176936f, -0.13563813f, 0.07166534f, 0.12906568f, 
    0.04015270f, 0.10826413f, 0.03389663f, -0.02951503f, 0.06119461f, 0.02300406f, 0.04972166f, -0.02046080f, 
    -0.00043358f, -0.06378545f, 0.00985238f, 0.00749081f, 0.01507890f, 0.01686606f, -0.15738392f, 0.17423590f, 
    0.15524866f, -0.19348679f, 0.36426690f, -0.15393618f, -0.00887131f, 0.05080915f, 0.04153344f, 0.03212511f, 
    0.20331523f, 0.39383456f, -0.16631401f, -0.01762761f, 0.09760609f, -0.18384297f, -0.03351539f, 0.07098552f, 
    -0.02991871f, 0.01590834f, 0.07871747f, 0.10426161f, 0.08945336f, -0.05545754f, 0.07624270f, 0.04596104f, 
    0.16101766f, 0.12146197f, -0.04115936f, 0.11336123f, -0.00579117f, -0.03937368f, -0.03747880f, 0.04681478f, 
    0.18812095f, 0.00483885f, -0.03049927f, 0.02241436f, 0.04965517f, -0.06454004f, 0.00764674f, -0.20491430f, 
    0.22253181f, -0.19269289f, 0.09291989f, 0.07352384f, 0.07164863f, 0.05295614f, -0.15921386f, -0.15840645f, 
    -0.11008807f, 0.10625468f, 0.09189726f, -0.06529558f, 0.08955471f, -0.01934024f, -0.17614251f, -0.05671248f, 
    0.05419605f, 0.02066081f, 0.01215104f, 0.01186478f, 0.16967101f, -0.18718982f, -0.03956645f, -0.01348555f, 
    0.09358580f, 0.06077395f, -0.08057583f, -0.30433765f, 0.02724843f, -0.01331132f, 0.05749439f, -0.04457952f, 
    0.32860988f, 0.15952568f, -0.01668713f, -0.04155567f, 0.04846027f, -0.06586743f, -0.16829696f, -0.25165704f, 
    -0.03485681f, 0.16055177f, -0.00311441f, 0.01383065f, -0.05923616f, -0.15447335f, 0.00204880f, 0.00614855f, 
    -0.18214370f, 0.13799009f, 0.02924728f, 0.04662699f, -0.02333955f, -0.03064914f, 0.17937911f, 0.14328705f, 
    -0.11123525f, 0.04966341f, 0.04960315f, 0.12290365f, 0.04777123f, 0.02498852f, -0.10063999f, 0.08421145f, 
    -0.05232528f, 0.08555111f, 0.01035951f, -0.05054844f, 0.20946980f, -0.02453516f, -0.29901689f, -0.11572988f, 
    -0.09359583f, 0.08806843f, 0.09658393f, 0.13791792f, -0.00579902f, 0.09773459f, 0.10955798f, 0.02258061f, 
    0.01289146f, -0.00469936f, 0.07321796f, 0.09353418f, -0.40639725f, -0.10485315f, 0.51479757f, -0.03233786f, 
    -0.09950311f, -0.21320097f, 0.13300055f, 0.03423052f, -0.07504746f, -0.02362533f, 0.06662124f, -0.00281596f, 
    0.01994533f, 0.18050955f, 0.03392803f, 0.07546046f, 0.10636387f, 0.06155755f, -0.13620225f, -0.10285512f, 
    0.19118869f, 0.05948631f, -0.08236182f, -0.18581392f, -0.09808589f, -0.00410387f, 0.01291665f, -0.24687159f, 
    0.04623055f, -0.13321047f, -0.07509527f, -0.03987768f, -0.12352133f, 0.07891444f, 0.13992958f, 0.11577015f, 
    0.23666310f, -0.13057423f, 0.22460759f, 0.00473283f, 0.03706771f, 0.32245344f, -0.11789004f, -0.02087798f, 
    -0.01592926f, -0.19082604f, -0.13888840f, 0.08055589f, 0.01766279f, 0.04828447f, -0.17465162f, 0.10378431f, 
    0.05785480f, 0.01366062f, -0.41609377f, 0.00386358f, 0.12439857f, -0.19588421f, -0.08197057f, -0.16167639f, 
    0.04401802f, 0.12201829f, 0.02094751f, -0.01637788f, 0.04556047f, 0.05389851f, -0.13067719f, -0.19168314f, 
    -0.15302327f, 0.03530720f, 0.10767874f, -0.02252839f, -0.12441160f, 0.13383879f, 0.18444408f, 0.09269847f, 
    -0.02495443f, -0.01721095f, -0.03850272f, 0.21113566f, 0.01032182f, -0.18637560f, 0.08061598f, 0.14806375f, 
    0.07347715f, 0.01215060f, 0.06406158f, 0.13314500f, -0.04553830f, 0.01523672f, -0.17521937f, -0.11297126f, 
    -0.04309398f, 0.09142705f, -0.04904687f, 0.11956585f, 0.02034605f, 0.06484602f, 0.07470340f, -0.10862385f, 
    0.07849308f, -0.12385117f, 0.11267370f, -0.01320469f, -0.05027448f, 0.15610261f, 0.15466039f, -0.04952220f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07643357f, 0.00165241f, 0.00948605f, -0.03316937f, 0.01437060f, -0.05554203f, 0.13894095f, 0.09250765f, 
    0.03745248f, 0.07557514f, 0.07442552f, 0.03626541f, 0.21602187f, 0.03225312f, 0.14731482f, -0.05261725f, 
    -0.05985128f, 0.21385390f, 0.02633621f, 0.11971326f, 0.03910091f, -0.03906058f, 0.03986637f, 0.13802047f, 
    0.05875964f, 0.06956191f, -0.08922508f, 0.02212359f, -0.08120394f, 0.20118403f, 0.27432895f, 0.09314407f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16030166f, 0.01353298f, -0.04229210f, -0.36703014f, -0.06916849f, -0.00204583f, 0.25199991f, 0.04193791f, 
    -0.11109008f, 0.09641313f, -0.40822440f, -0.22714520f, 0.34600034f, -0.11173776f, -0.33100298f, -0.14875019f, 
    0.01358406f, 0.29089734f, -0.04430917f, -0.09561522f, 0.00111917f, -0.11431780f, 0.12334458f, 0.09649687f, 
    -0.19610733f, -0.00636235f, 0.12153482f, 0.00599335f, -0.18226239f, 0.36449859f, 0.03874650f, -0.22222234f, 
    0.27844459f, -0.16566165f, 0.18844777f, 0.20679009f, 0.10147396f, 0.25710726f, -0.15662277f, 0.29101592f, 
    -0.11429179f, 0.19501735f, -0.02602370f, 0.12141115f, -0.25117731f, 0.21373028f, 0.21002434f, -0.05017494f, 
    0.10443845f, 0.09081464f, -0.01598856f, -0.14221513f, -0.18374874f, -0.03587401f, -0.10357106f, -0.15037879f, 
    0.36853164f, -0.05844792f, 0.20641071f, -0.17982779f, -0.10014556f, -0.16302924f, -0.07846092f, -0.07735180f, 
    -0.17839219f, -0.08139239f, 0.00234407f, 0.06239649f, 0.21741642f, -0.36631322f, 0.26299962f, 0.17041759f, 
    -0.10285192f, -0.02984852f, 0.22256309f, -0.15643726f, 0.27838817f, -0.10998008f, -0.18615039f, -0.09483458f, 
    -0.15543312f, 0.17449774f, -0.16730995f, 0.24283087f, 0.14637218f, 0.11480233f, 0.12045693f, 0.30768821f, 
    0.25709149f, 0.05592168f, -0.11957552f, 0.13145758f, -0.03713664f, 0.22863707f, -0.14022423f, -0.11647411f, 
    0.04700851f, 0.03350919f, -0.05136300f, -0.04347765f, -0.14333928f, -0.20013699f, -0.13013421f, 0.05397772f, 
    0.09060740f, 0.08648664f, -0.04491626f, -0.00609087f, -0.14770408f, -0.16914730f, -0.17014818f, 0.09689339f, 
    -0.00297177f, -0.09424351f, -0.17265411f, 0.11930088f, -0.11460190f, 0.08119906f, -0.06380173f, 0.03830787f, 
    -0.10977668f, -0.07812814f, -0.11427256f, -0.09116486f, -0.12453323f, 0.05198288f, -0.07942597f, 0.10352834f, 
    -0.63593960f, -0.13939290f, 0.15398902f, -0.06168945f, -0.15827663f, -0.12414876f, 0.25840855f, -0.19261125f, 
    -0.15377647f, 0.01671248f, -0.15656297f, 0.09335970f, 0.35719582f, -0.22302492f, -0.18927428f, 0.13542964f, 
    -0.14010437f, 0.31164044f, -0.06923600f, 0.12887056f, 0.10058499f, 0.03792276f, 0.29960650f, 0.19222021f, 
    -0.21243131f, -0.09898136f, -0.25333127f, 0.08416806f, -0.06029370f, 0.27534360f, -0.14593986f, 0.10177996f, 
    0.16321716f, -0.12780379f, -0.16701677f, -0.15681048f, -0.05108107f, 0.32685560f, -0.28253573f, -0.13570394f, 
    0.05716080f, 0.02721956f, -0.23116444f, -0.14737304f, -0.08075552f, 0.15717152f, 0.42685151f, 0.11360963f, 
    0.16068655f, 0.10070492f, 0.10021789f, -0.05468902f, -0.23092966f, -0.01776566f, 0.17768312f, -0.27985507f, 
    0.18645598f, 0.14024387f, -0.03887866f, -0.16544431f, -0.11599669f, 0.15907559f, 0.44540218f, -0.23354080f, 
    0.26557687f, 0.15836401f, -0.18344404f, -0.25386268f, 0.10265931f, 0.20795768f, -0.27224487f, 0.21252273f, 
    0.04854091f, 0.20497373f, -0.31326336f, -0.13214706f, -0.57446527f, 0.13196591f, 0.31817454f, -0.00981778f, 
    -0.02447013f, 0.18074852f, 0.05499279f, 0.11903178f, -0.26233849f, 0.06069835f, 0.31244931f, -0.07333484f, 
    0.09876670f, -0.22514853f, 0.25431681f, 0.10382632f, -0.04873719f, 0.21652985f, -0.08434977f, -0.05803037f, 
    -0.09936800f, 0.06787711f, 0.27658656f, -0.18487039f, 0.09713633f, -0.13317855f, -0.20639652f, 0.27229434f, 
    -0.17425084f, 0.25853375f, 0.18379387f, -0.18659669f, -0.08574906f, -0.09018834f, 0.11425254f, -0.06359895f, 
    0.15631489f, -0.02319725f, 0.11404482f, 0.10360248f, 0.13385747f, 0.09600542f, 0.12198322f, 0.17152721f, 
    0.28584132f, 0.13909794f, -0.15500624f, 0.12314729f, -0.13435033f, -0.10982592f, 0.50863302f, 0.00236517f, 
    -0.45538467f, 0.06548364f, 0.06805262f, 0.23156662f, -0.13486831f, -0.12310690f, -0.04616234f, -0.42059791f, 
    0.01290698f, 0.29820696f, 0.36398479f, -0.10699179f, -0.00585320f, 0.06325846f, -0.20874053f, 0.14064547f, 
    0.08951662f, 0.19522525f, 0.02765388f, 0.01968043f, -0.06955205f, 0.04511673f, -0.03968247f, 0.35109371f, 
    -0.25451902f, 0.08385859f, -0.23759140f, 0.10456315f, 0.18877859f, 0.10172679f, 0.35986468f, 0.22243054f, 
    0.09332142f, 0.00693079f, 0.00471511f, 0.44246504f, 0.05212429f, 0.26462424f, 0.10597033f, -0.41600403f, 
    0.14370172f, -0.04618539f, 0.27001771f, 0.10407299f, -0.14090776f, -0.20618145f, -0.04136023f, 0.09234831f, 
    -0.12328330f, 0.27053323f, 0.09592624f, 0.18420717f, -0.02558305f, 0.07980663f, -0.38753554f, 0.05375771f, 
    -0.13708302f, -0.18055137f, 0.09559690f, 0.11059946f, 0.07558927f, -0.14117347f, 0.30212831f, -0.08039358f, 
    -0.07551833f, -0.10200526f, 0.13743311f, -0.56591916f, -0.11091797f, 0.29182097f, -0.08114206f, -0.45415273f, 
    0.14570768f, -0.26486859f, -0.21989550f, 0.21196985f, -0.09955175f, 0.18773785f, 0.26384836f, 0.12968501f, 
    0.04241925f, 0.19746764f, 0.02998924f, -0.11322294f, -0.08221738f, 0.07611331f, -0.08460395f, 0.08335346f, 
    -0.03347462f, -0.25671524f, -0.16282851f, -0.08473959f, 0.20363259f, -0.04526024f, 0.36386159f, 0.21841124f, 
    0.17623256f, -0.15595166f, 0.06223640f, -0.32273993f, -0.02942732f, 0.18471117f, -0.21559033f, -0.30482805f, 
    0.11120376f, -0.20614959f, 0.00995296f, 0.19332977f, -0.17872041f, 0.02180240f, 0.45918486f, 0.16282421f, 
    -0.12196685f, 0.15279821f, -0.08431113f, -0.04368681f, -0.15161152f, -0.00854919f, 0.23395191f, -0.11057776f, 
    -0.06872523f, -0.16960904f, -0.15418491f, -0.14681247f, 0.18292050f, 0.16684395f, -0.00423206f, 0.11529611f, 
    0.14300473f, 0.15770163f, -0.19310047f, 0.22666399f, -0.16574568f, -0.19977236f, 0.36636531f, -0.27488357f, 
    -0.09260608f, 0.03530223f, -0.05342048f, 0.05999259f, 0.14860947f, -0.04648256f, 0.04064158f, 0.07078393f, 
    -0.07895271f, 0.21249729f, 0.09482821f, -0.00723138f, 0.17008653f, 0.09019985f, 0.16942409f, 0.05655149f, 
    -0.36456254f, -0.09035219f, 0.07193829f, 0.14220399f, 0.03538210f, 0.27176288f, 0.06494461f, -0.00646257f, 
    -0.10780255f, 0.04157223f, -0.33369783f, -0.32857415f, 0.15562603f, 0.00211547f, 0.36341226f, -0.19261043f, 
    -0.00790401f, 0.18440743f, 0.03120177f, -0.21767767f, 0.05320101f, -0.00449583f, -0.14855619f, -0.05461593f, 
    0.03036557f, 0.34595144f, 0.21766859f, -0.09720550f, -0.04177421f, 0.18660238f, 0.13466354f, -0.19876000f, 
    -0.25214484f, -0.13871770f, 0.19185627f, 0.12267035f, -0.05683564f, 0.38141128f, 0.17001851f, 0.02746143f, 
    0.04936141f, 0.16137898f, -0.08766872f, 0.00054414f, -0.30211633f, -0.05005100f, 0.19619127f, -0.16642115f, 
    0.07269988f, 0.26493818f, -0.19521400f, 0.19639839f, 0.05852516f, 0.06479553f, -0.08086991f, 0.08102657f, 
    -0.04597164f, 0.28390214f, 0.23393816f, -0.09941313f, -0.07420033f, 0.01925841f, 0.29127422f, -0.14675246f, 
    -0.10832762f, -0.12619835f, 0.28790566f, 0.13503237f, 0.14867035f, -0.01152029f, -0.31245849f, 0.06589183f, 
    0.02242898f, 0.00149981f, 0.06900602f, -0.22862414f, 0.33333287f, 0.17772169f, -0.24208447f, 0.40833002f, 
    -0.12188442f, 0.12987663f, -0.05729533f, -0.14354751f, -0.17395541f, -0.00296348f, 0.34303585f, 0.10165867f, 
    0.03924606f, 0.04251896f, 0.01552544f, 0.30904204f, -0.31978932f, 0.09681039f, 0.37978902f, -0.33901805f, 
    0.22675903f, -0.00941993f, 0.00050503f, -0.16224192f, -0.03209521f, -0.23840740f, 0.35667363f, -0.09630054f, 
    -0.11738966f, 0.11730551f, -0.02418829f, -0.16190037f, 0.03376934f, -0.05576205f, 0.11736824f, -0.09371860f, 
    0.11822623f, -0.02009781f, -0.11111264f, -0.07811752f, 0.03803471f, -0.02213942f, 0.03562498f, 0.08077639f, 
    -0.02874929f, -0.09121322f, 0.02210649f, -0.06686760f, -0.12752773f, 0.11080731f, 0.06490857f, -0.12120611f, 
    -0.13784912f, -0.10800473f, 0.03645325f, 0.01456574f, -0.02039402f, -0.01954992f, -0.12904435f, -0.09775226f, 
    0.14689209f, -0.00131247f, -0.12228227f, -0.42669153f, 0.31381014f, 0.12304894f, -0.33315009f, 0.07199317f, 
    0.12933592f, 0.21271481f, -0.27410579f, -0.07380071f, -0.27634630f, 0.12196928f, 0.11468303f, -0.15462482f, 
    0.10906264f, 0.19408894f, 0.25130674f, 0.23113668f, -0.20760827f, 0.16103518f, 0.24640568f, -0.11354565f, 
    0.12867182f, 0.10733825f, 0.03989005f, 0.15336001f, 0.00133189f, -0.03675754f, -0.07895858f, -0.12511672f, 
    -0.09649688f, -0.10109133f, -0.01849675f, -0.24391505f, 0.32205865f, 0.06656705f, -0.09272330f, 0.03507755f, 
    -0.11497807f, 0.22462277f, -0.23870221f, 0.29154256f, -0.26381120f, 0.22677779f, 0.19663775f, 0.07402775f, 
    -0.01201443f, -0.10188759f, -0.20534267f, -0.15865313f, 0.18832292f, -0.12520657f, 0.35558066f, 0.16389553f, 
    0.15821369f, 0.22584058f, 0.05361365f, 0.15953897f, -0.03998434f, -0.12579468f, -0.32187659f, 0.37479100f, 
    0.02161717f, -0.15489626f, 0.20826989f, 0.33030936f, 0.13114846f, -0.11961087f, 0.04042587f, 0.54303432f, 
    0.00475340f, -0.16166425f, -0.00808759f, 0.07220025f, 0.06468462f, -0.13922387f, 0.11149535f, -0.04590904f, 
    -0.10731117f, -0.00684528f, -0.15594572f, 0.17488721f, -0.14131680f, -0.14896202f, 0.27302554f, 0.07990602f, 
    0.22371916f, 0.09459613f, 0.21225046f, -0.08361796f, -0.12685871f, 0.14570101f, -0.27352309f, -0.18511634f, 
    -0.04575582f, -0.00501914f, 0.28936777f, 0.41128623f, -0.00480500f, 0.19473009f, 0.05908538f, 0.29833403f, 
    0.08540618f, 0.10961641f, -0.18025853f, 0.17091435f, -0.07498524f, 0.27957475f, -0.13724166f, -0.15889478f, 
    -0.16563924f, 0.08072245f, -0.15969250f, -0.19267346f, 0.02905639f, -0.06308373f, -0.20482405f, 0.01922594f, 
    0.03592785f, -0.15357545f, 0.21217200f, 0.06544008f, 0.12562419f, -0.18968663f, -0.12816560f, 0.19251928f, 
    -0.18732077f, 0.03970495f, 0.17114520f, 0.29416782f, -0.08915953f, 0.17285933f, 0.22579737f, 0.01628256f, 
    -0.11950360f, -0.14938816f, -0.03975385f, 0.30500507f, 0.11950331f, 0.24791840f, -0.01049236f, -0.11969283f, 
    -0.17341445f, 0.20676936f, 0.02161500f, -0.47060516f, 0.12167891f, -0.05550291f, -0.07815312f, -0.24983978f, 
    -0.44258538f, 0.07873118f, -0.27935985f, -0.04386539f, 0.19367321f, 0.05759048f, 0.06969561f, 0.11095229f, 
    -0.03913238f, -0.14451909f, 0.06487052f, 0.01382325f, -0.18286715f, 0.08297686f, 0.11158324f, -0.17572059f, 
    -0.06495927f, 0.06486434f, -0.01670562f, 0.20046285f, -0.13327797f, 0.17364258f, 0.20803802f, 0.05553677f, 
    0.05588594f, 0.05142970f, -0.17573066f, 0.17339759f, -0.19519155f, -0.06661918f, -0.24793077f, 0.30751911f, 
    0.14764163f, -0.10571653f, -0.09244354f, 0.04987165f, 0.09640875f, 0.07960145f, -0.09137999f, -0.16401549f, 
    0.01440172f, 0.12076842f, -0.15156592f, -0.09202779f, -0.16430923f, 0.03982042f, -0.04579488f, -0.09519525f, 
    0.04130014f, -0.16813293f, -0.01610017f, -0.05325003f, -0.05548318f, -0.18226959f, 0.13130648f, -0.02450407f, 
    -0.03909735f, 0.14412478f, -0.13128422f, 0.11985432f, -0.07201707f, 0.13095839f, -0.12230271f, -0.06177850f, 
    -0.12178387f, -0.16107272f, -0.10679486f, -0.17439829f, 0.16162695f, -0.03679238f, -0.08513968f, -0.06334881f, 
    0.03950968f, 0.09377159f, -0.06940288f, -0.27528444f, -0.07120230f, -0.11226837f, 0.38777456f, 0.09241720f, 
    -0.07474551f, 0.12335464f, -0.04460084f, -0.03124040f, 0.15355720f, 0.03435393f, -0.29511890f, -0.14597642f, 
    -0.17601275f, 0.11405079f, 0.14175208f, -0.13950518f, 0.08767890f, -0.12505966f, 0.37036309f, 0.13043989f, 
    0.04968893f, -0.18900865f, 0.16730136f, 0.16696200f, -0.00190937f, 0.03296398f, -0.08725154f, -0.08630155f, 
    -0.21217889f, 0.14377317f, 0.15919535f, 0.29695576f, 0.11496086f, 0.22768378f, 0.00708251f, 0.26910451f, 
    0.17310265f, -0.08735140f, -0.09964879f, 0.21721980f, 0.01664915f, 0.17876534f, -0.08066519f, -0.05447131f, 
    0.14130421f, 0.02504977f, -0.16300943f, -0.27775943f, 0.18520744f, 0.15727930f, -0.53846580f, 0.29751211f, 
    0.01078019f, -0.02623995f, -0.12751663f, -0.15804251f, 0.07679740f, 0.23885278f, -0.20072573f, 0.19409460f, 
    0.08001997f, 0.16766258f, -0.15290640f, -0.17768450f, 0.46911058f, 0.19529961f, -0.26553759f, 0.23706955f, 
    -0.15053612f, 0.14829771f, -0.02857967f, -0.00917273f, -0.32012850f, -0.17072482f, 0.22766545f, 0.09461382f, 
    0.03742152f, 0.11977542f, -0.22632976f, 0.35050213f, -0.03112231f, -0.19028024f, 0.20224014f, 0.05560795f, 
    -0.07187622f, 0.26626059f, -0.27886730f, 0.00054211f, 0.10169300f, -0.06671152f, 0.07951323f, 0.26605800f, 
    -0.01789356f, -0.17675464f, -0.01856942f, 0.35368454f, 0.28239885f, 0.34911102f, 0.03239705f, 0.08721707f, 
    0.02365597f, -0.09302743f, 0.21260861f, 0.23518844f, -0.11687955f, -0.14956991f, -0.26661640f, -0.02772526f, 
    0.12926847f, 0.10588388f, 0.03924433f, -0.10506145f, -0.06875389f, 0.04500804f, -0.67602986f, -0.02108143f, 
    -0.07437363f, 0.08442533f, -0.10953849f, -0.15190843f, 0.11299843f, -0.06221968f, -0.22027276f, 0.20459397f, 
    0.12323994f, 0.15694544f, -0.69453454f, 0.47128719f, -0.25212765f, 0.40501207f, 0.00593446f, 0.02139306f, 
    0.05161126f, -0.04690848f, 0.03270751f, -0.06172773f, 0.16989771f, -0.10902788f, -0.08896098f, 0.14215672f, 
    0.05728942f, -0.36543372f, -0.10471625f, -0.22913782f, -0.04033862f, 0.07128616f, -0.37924734f, -0.18776228f, 
    0.19545124f, 0.15777031f, -0.08747023f, -0.12579024f, -0.04675340f, -0.23243317f, -0.08485669f, 0.09131519f, 
    -0.04727715f, 0.14199658f, -0.02767299f, -0.09660884f, 0.14311361f, 0.29546991f, 0.19644123f, -0.25715289f, 
    -0.01182613f, -0.13533419f, -0.03981111f, -0.10191256f, 0.04623307f, -0.36388016f, -0.04897493f, -0.02571156f, 
    0.05315363f, 0.07345757f, 0.26584464f, -0.15479754f, 0.13116422f, -0.08854661f, -0.11203870f, 0.29777485f, 
    -0.05113320f, -0.00019493f, 0.07855331f, 0.02996291f, 0.11145179f, 0.02272918f, -0.17063136f, -0.11211977f, 
    -0.10274748f, 0.00877459f, 0.21551090f, -0.32746702f, -0.20783089f, -0.12919614f, -0.03333655f, 0.10018089f, 
    0.17460662f, 0.05064473f, 0.04215992f, 0.15894215f, 0.12483098f, 0.31060657f, 0.10216209f, 0.10309793f, 
    -0.07149136f, 0.00747502f, 0.16019079f, 0.03597802f, -0.12779737f, -0.01896343f, 0.58651441f, 0.29284668f, 
    -0.10963353f, 0.04439881f, -0.16634171f, -0.01879707f, -0.14262241f, -0.07100583f, -0.19915622f, -0.08362988f, 
    -0.30303329f, 0.11487410f, 0.42642990f, 0.18923742f, -0.11926578f, 0.21433230f, -0.10007429f, 0.04963176f, 
    -0.12808694f, -0.06244294f, 0.31025723f, -0.03471244f, -0.14200634f, 0.24295701f, 0.16245429f, 0.03598861f, 
    0.16761319f, 0.29807171f, -0.20181185f, 0.27278611f, -0.27752748f, -0.12035548f, -0.23666377f, 0.00685097f, 
    -0.03697606f, -0.04724865f, -0.17138794f, -0.09841730f, -0.04769446f, -0.16702837f, 0.46731699f, 0.07405619f, 
    -0.13261287f, -0.07129475f, 0.36166626f, 0.44179177f, -0.23642717f, 0.24018350f, 0.07546559f, -0.09250990f, 
    -0.14929916f, -0.26874560f, 0.20215206f, 0.05978948f, -0.01762843f, 0.18914570f, 0.06348063f, -0.11975697f, 
    -0.04735193f, 0.18099631f, 0.01907085f, -0.01359812f, -0.12066936f, 0.12235252f, -0.42115015f, -0.16141827f, 
    0.12197296f, 0.01007130f, -0.06537626f, -0.17313983f, -0.00490017f, -0.16677973f, 0.04890612f, -0.00834555f, 
    -0.18555446f, -0.03885424f, 0.01581217f, 0.13208987f, -0.10215920f, 0.10566843f, 0.06774735f, -0.01164036f, 
    -0.16954030f, 0.22675470f, 0.17814237f, 0.01250856f, 0.03710734f, -0.04470745f, 0.20900926f, -0.16170448f, 
    0.05088293f, -0.15157871f, -0.25664589f, 0.01872674f, 0.24714327f, -0.00463176f, -0.29958433f, 0.22340657f, 
    0.04860559f, 0.22975139f, -0.04395835f, -0.01847744f, 0.17801085f, 0.08326473f, 0.33811861f, -0.04543778f, 
    0.27651736f, -0.04066391f, 0.10837860f, -0.41819933f, 0.10167502f, 0.19530687f, -0.11449593f, 0.17972830f, 
    -0.11149757f, 0.11967056f, -0.37113073f, -0.16707139f, -0.39597696f, -0.07829884f, 0.28580779f, 0.08241728f, 
    -0.12989639f, 0.22836003f, 0.26022378f, -0.00629448f, -0.31127366f, -0.11008635f, 0.38323855f, -0.23501788f, 
    -0.08923959f, -0.17713428f, 0.15759787f, -0.08826827f, 0.02016260f, 0.17553343f, -0.16503520f, -0.10586277f, 
    0.16181947f, 0.06440637f, 0.05331277f, -0.19199415f, 0.14634320f, 0.04216523f, -0.02143834f, 0.05556160f, 
    0.01952293f, -0.22496316f, 0.08448043f, -0.03055507f, 0.06762881f, -0.06332763f, 0.20453441f, -0.08361674f, 
    0.00661565f, -0.28679866f, 0.03460846f, -0.21741298f, 0.10186969f, -0.03298535f, -0.16516697f, -0.46238822f, 
    -0.06059725f, 0.11639012f, -0.11317255f, -0.17268097f, -0.07690622f, -0.18288893f, -0.41983730f, -0.22614366f, 
    0.07396338f, 0.14984515f, 0.24553525f, 0.15282550f, -0.06369314f, 0.37054974f, -0.13763829f, 0.32031554f, 
    -0.14594354f, -0.10976961f, 0.00585895f, -0.09224584f, -0.10843654f, 0.01402669f, 0.40227145f, 0.05707280f, 
    -0.10112375f, 0.07429049f, 0.10312775f, -0.06073361f, -0.14396726f, 0.04860020f, 0.18307930f, 0.32327506f, 
    0.24612871f, 0.16585627f, -0.12334952f, -0.08291728f, -0.02296440f, 0.02638755f, -0.14872433f, 0.06790267f, 
    -0.10585164f, 0.01890491f, 0.04825212f, 0.27237222f, -0.13044067f, -0.24859048f, 0.26467377f, 0.03045867f, 
    0.11625547f, -0.11229047f, 0.03598663f, 0.25798237f, 0.25480792f, 0.26258263f, 0.13873962f, -0.13252257f, 
    -0.01613366f, 0.13747682f, -0.20802020f, -0.20144126f, 0.26698276f, 0.01225850f, 0.15221712f, 0.14527838f, 
    0.00923274f, 0.04804043f, -0.08465695f, -0.15034643f, 0.05092205f, 0.26681194f, -0.16237587f, 0.18462045f, 
    0.21425901f, 0.10198855f, 0.15277545f, 0.13573907f, -0.06445823f, -0.04951018f, -0.29282683f, 0.35540348f, 
    0.11920492f, 0.26315030f, -0.02850292f, -0.27430844f, -0.35633650f, 0.34146088f, 0.19089916f, 0.06952418f, 
    0.10011471f, 0.01095415f, 0.05303921f, -0.16165400f, 0.06495054f, -0.07409974f, 0.28369221f, 0.16164368f, 
    0.17239279f, 0.05221829f, 0.10145207f, 0.13669334f, -0.01307914f, 0.19380699f, 0.26010779f, 0.03960760f, 
    -0.28515959f, -0.11628550f, -0.24390586f, -0.37420952f, 0.21280634f, 0.38961160f, -0.10804275f, -0.09594645f, 
    -0.14956668f, 0.37846613f, -0.22521131f, -0.05589190f, -0.33616829f, -0.45967570f, -0.32348034f, -0.04347572f, 
    0.06505120f, 0.28115061f, 0.07405609f, 0.10454427f, 0.10374127f, -0.18288518f, 0.20316026f, 0.04095624f, 
    0.18556331f, -0.02010932f, -0.27915385f, -0.15102029f, 0.16953775f, -0.07440156f, -0.37275329f, -0.05453381f, 
    -0.28107587f, 0.17142726f, -0.24980076f, -0.11775517f, -0.00786173f, 0.30770046f, 0.34367371f, -0.13241833f, 
    -0.11390979f, -0.00307604f, -0.12428717f, 0.18447834f, -0.27750015f, 0.09031446f, -0.36381832f, -0.16273217f, 
    0.07003228f, 0.40088356f, 0.31939086f, 0.16188639f, 0.11083609f, -0.10780072f, -0.20603047f, -0.24974832f, 
    -0.32772127f, -0.42280111f, 0.07375725f, 0.01705908f, -0.04038677f, 0.06768030f, -0.15522021f, 0.18252593f, 
    -0.19149843f, 0.06666571f, 0.10205153f, 0.11587717f, -0.29098693f, -0.08469583f, -0.04987751f, -0.31361967f, 
    -0.16227871f, 0.29334095f, 0.08195746f, -0.11729910f, -0.04848513f, -0.14366557f, 0.36916009f, -0.02417407f, 
    0.12475231f, 0.16914921f, 0.20740992f, -0.18383607f, -0.11880317f, -0.05080877f, 0.20772204f, 0.37225440f, 
    0.23925374f, 0.12999345f, -0.07561105f, -0.09120245f, -0.12975383f, -0.05974231f, -0.43420917f, 0.16832110f, 
    -0.39686233f, 0.03005678f, 0.33709541f, 0.01669822f, -0.05731348f, -0.10618602f, 0.03659599f, -0.08567356f, 
    0.10694200f, 0.27452448f, 0.10468018f, 0.12005395f, 0.06059956f, 0.27495012f, -0.36160415f, -0.00602341f, 
    0.07186136f, 0.36651796f, -0.07883003f, 0.30502102f, -0.14175077f, 0.08535456f, -0.28090489f, -0.36480507f, 
    -0.33363068f, -0.12101573f, 0.01801974f, -0.12040649f, 0.18002862f, -0.08194287f, 0.49301696f, 0.16611603f, 
    0.07486463f, -0.11824550f, -0.15225901f, 0.07166519f, -0.00752131f, -0.03697914f, -0.11472154f, 0.16482811f, 
    0.08310613f, -0.09284074f, 0.02644072f, -0.05532304f, -0.11375780f, -0.00523078f, -0.05626951f, -0.11608499f, 
    0.15767902f, -0.01217661f, -0.16338630f, 0.11297549f, -0.16671456f, -0.12810667f, 0.01402340f, 0.04483546f, 
    -0.18501861f, -0.05697152f, -0.12467960f, -0.16011627f, -0.03658981f, 0.09154777f, -0.08542985f, -0.02159601f, 
    -0.31135714f, -0.04610264f, 0.26175794f, 0.41714686f, -0.18869436f, -0.00654506f, -0.06394155f, 0.10406257f, 
    0.11678746f, -0.06976236f, 0.09584928f, 0.18799376f, 0.19040106f, -0.16162644f, 0.16902804f, 0.09140187f, 
    -0.10893509f, 0.05983555f, -0.12595417f, 0.16443792f, 0.05099443f, -0.09423476f, -0.08419791f, 0.13551630f, 
    -0.21467394f, -0.01543936f, 0.01160717f, 0.02371539f, 0.00080595f, -0.08172410f, 0.03753490f, 0.04861107f, 
    -0.23292713f, -0.16934441f, 0.12168312f, -0.04832137f, 0.14493603f, 0.10235088f, 0.22795513f, -0.42717591f, 
    0.14478059f, 0.16464792f, -0.10066446f, 0.10377835f, -0.14813346f, -0.00477522f, -0.09970816f, 0.00862513f, 
    0.09120288f, 0.13506067f, 0.13777173f, -0.14204362f, 0.23947673f, 0.11256998f, -0.26227280f, -0.21761559f, 
    -0.31998903f, -0.30909425f, -0.05858965f, -0.10308731f, 0.09787450f, -0.13074334f, 0.11908870f, 0.32545918f, 
    -0.35464886f, -0.16630423f, -0.01452582f, 0.18164280f, 0.15367939f, 0.32700637f, 0.14109635f, -0.08171981f, 
    0.05875813f, 0.10028812f, 0.15792079f, 0.08809735f, 0.05134146f, -0.49467671f, -0.20312624f, -0.06035705f, 
    0.02936336f, 0.16994384f, -0.25672543f, 0.14828499f, -0.16255504f, 0.14574312f, -0.63819379f, 0.35346004f, 
    0.01201059f, 0.13181837f, -0.20176810f, 0.16000354f, 0.08544500f, -0.05430634f, -0.50732625f, 0.13316618f, 
    -0.16687168f, 0.06296331f, 0.24177195f, 0.05340717f, 0.19723569f, -0.00302720f, -0.09084538f, -0.21309553f, 
    0.07801967f, -0.22959371f, 0.09853411f, 0.09948804f, 0.24491072f, -0.37479562f, -0.22469814f, -0.00630799f, 
    -0.06290336f, 0.36777353f, -0.07677189f, 0.36766478f, 0.02387916f, -0.12344913f, 0.27339181f, -0.03802049f, 
    -0.38978651f, -0.06977008f, -0.21492516f, 0.12270594f, 0.12988007f, 0.16411564f, -0.02716115f, -0.11927961f, 
    0.18732770f, 0.01138062f, 0.33004761f, 0.18279146f, -0.05308156f, 0.02018496f, 0.01760545f, -0.11240218f, 
    0.13835144f, -0.09880283f, 0.20088217f, 0.03950859f, 0.17772557f, -0.23444505f, -0.09860203f, -0.03357198f, 
    0.15275699f, -0.11281184f, -0.19596218f, 0.12713538f, -0.21395871f, -0.12686862f, -0.49647945f, 0.07293634f, 
    0.02696082f, 0.18420056f, 0.05476028f, -0.12918001f, -0.02661423f, -0.22020358f, 0.31997842f, 0.17078607f, 
    -0.69410205f, -0.15183337f, 0.11255080f, -0.13968371f, 0.15182588f, 0.01582154f, 0.09784556f, -0.00498406f, 
    -0.04934383f, -0.06565554f, -0.03449722f, 0.06130011f, 0.34289125f, -0.01600933f, -0.23044741f, 0.07779796f, 
    0.09276660f, 0.07350943f, -0.02924668f, 0.16362546f, -0.00408171f, 0.02661415f, 0.34256744f, 0.09311750f, 
    -0.35975644f, 0.15881687f, -0.19559051f, 0.08726001f, -0.12087962f, 0.01749516f, 0.18661186f, 0.26671872f, 
    -0.04751638f, 0.04313429f, 0.19294606f, -0.02825871f, -0.19563708f, 0.05614724f, -0.07697009f, 0.02659321f, 
    0.10691556f, -0.32055303f, 0.07708428f, 0.09660835f, 0.00191192f, 0.23025200f, -0.32795438f, 0.16235973f, 
    0.14006124f, 0.02625019f, -0.14659721f, 0.06165310f, -0.24618001f, 0.17522864f, -0.36321497f, -0.06791502f, 
    0.10948598f, -0.14484352f, 0.15989006f, 0.14775926f, -0.02546563f, 0.02223231f, -0.01783952f, -0.11350922f, 
    -0.05925486f, -0.03697557f, -0.18565013f, -0.09145426f, -0.07006224f, -0.15767106f, -0.16793294f, -0.16825391f, 
    0.09345087f, -0.14146526f, 0.12510827f, 0.04053215f, -0.12522587f, 0.02806167f, -0.03621496f, 0.03665598f, 
    -0.00112024f, -0.13669826f, 0.04201974f, 0.15186366f, -0.12102928f, -0.14240107f, -0.04400069f, -0.13667652f, 
    -0.00219910f, 0.08736872f, -0.01313872f, 0.07099047f, 0.15578687f, -0.19703186f, -0.10271468f, 0.03208637f, 
    0.02441084f, -0.09552084f, 0.29021910f, -0.13929656f, 0.09350277f, 0.01579455f, 0.03166941f, -0.10665325f, 
    0.04924598f, 0.35920668f, 0.01515551f, 0.16668835f, -0.07482751f, 0.31167993f, -0.10699338f, 0.08042408f, 
    0.05928769f, -0.16307814f, 0.14203317f, 0.00397120f, -0.09904374f, -0.07245824f, -0.14920248f, 0.03565169f, 
    -0.15136115f, -0.15322752f, -0.11840601f, 0.11155254f, 0.06268579f, -0.06388865f, 0.29226035f, 0.26576686f, 
    0.02935695f, -0.01409504f, 0.09093475f, -0.03500026f, -0.13041349f, 0.01502143f, -0.18380602f, -0.07661790f, 
    -0.06127406f, -0.08736568f, -0.22308782f, 0.03098363f, 0.04604316f, -0.00298178f, -0.05139970f, 0.13074228f, 
    -0.01062350f, 0.04315526f, -0.08110097f, -0.20563413f, -0.06003694f, -0.10333381f, 0.12569743f, 0.02111389f, 
    -0.17711876f, -0.02721520f, -0.03658560f, -0.00870691f, -0.13843182f, -0.12191928f, -0.13140690f, 0.10370273f, 
    -0.02619785f, 0.15185218f, -0.21008347f, -0.41861898f, 0.10536807f, 0.25054896f, 0.02422816f, -0.22575268f, 
    -0.13330860f, 0.11565279f, 0.18286543f, -0.20080709f, -0.07126460f, -0.11130784f, -0.28805694f, 0.15030260f, 
    -0.10414839f, 0.34053937f, 0.15349519f, 0.25918466f, 0.05299355f, -0.17930757f, -0.15594019f, -0.12680808f, 
    -0.17635824f, 0.24448980f, -0.02381862f, -0.15183899f, 0.08116820f, 0.17948854f, -0.17434894f, 0.07896736f, 
    0.08954509f, 0.01855908f, -0.20705362f, -0.26251763f, 0.14429073f, -0.03170171f, 0.12852772f, 0.21747391f, 
    0.00788459f, -0.03453878f, -0.35567391f, -0.13719745f, 0.29916352f, -0.22822751f, 0.31635645f, 0.09527437f, 
    0.03599417f, 0.15115435f, -0.07528202f, -0.08672805f, -0.11814857f, 0.07836999f, 0.03689210f, -0.19940643f, 
    -0.05134209f, -0.14890490f, 0.17281786f, 0.14882073f, 0.13262951f, 0.32262865f, 0.49437985f, -0.17535889f, 
    0.18918473f, -0.10355300f, -0.03677924f, -0.06429205f, -0.25535518f, 0.16474137f, -0.05487906f, -0.30215868f, 
    0.16898443f, 0.06603355f, -0.00091301f, -0.11112574f, -0.32465142f, -0.20922989f, 0.15655474f, -0.12711398f, 
    0.07005696f, 0.02094027f, 0.09412551f, -0.15828471f, -0.14762367f, 0.10665150f, 0.02081341f, 0.26877022f, 
    0.00219301f, -0.24228454f, 0.25337416f, -0.14440966f, 0.10176765f, 0.38215685f, 0.10065702f, -0.02760975f, 
    0.01911285f, 0.05131899f, -0.11208846f, 0.01760202f, -0.13151217f, -0.03197476f, -0.12979557f, 0.01118827f, 
    -0.09127368f, 0.07136796f, -0.01468089f, -0.15177505f, 0.04643465f, -0.02961907f, -0.01590902f, 0.10478138f, 
    0.08337166f, -0.09745391f, -0.12604569f, 0.05800362f, -0.21976778f, -0.16687246f, -0.12610689f, -0.01554430f, 
    -0.16248882f, 0.06251758f, 0.03050505f, 0.17512357f, 0.13601930f, -0.03280135f, -0.05467485f, -0.09847900f, 
    -0.06150720f, 0.01212289f, -0.06496987f, 0.01814286f, 0.24346381f, 0.05492788f, -0.10675221f, 0.08360456f, 
    -0.12240016f, -0.06403594f, 0.08993551f, 0.10138743f, -0.09496161f, -0.29328558f, 0.35160446f, 0.01910659f, 
    0.09024359f, -0.19672814f, 0.06432913f, -0.19288422f, 0.21076141f, -0.21086009f, 0.17018139f, 0.34048569f, 
    0.06630631f, 0.13507508f, -0.07621010f, 0.05762097f, -0.11815193f, 0.17136826f, -0.20030956f, -0.10428972f, 
    -0.13807578f, -0.16736099f, -0.21347953f, -0.76172513f, 0.06721751f, -0.30949742f, 0.04239441f, -0.01625398f, 
    -0.11918157f, 0.15524206f, 0.25746366f, -0.45275077f, -0.03289619f, -0.26463687f, 0.14424017f, 0.03969888f, 
    0.16316384f, 0.25663605f, -0.04994256f, 0.20584998f, -0.02846643f, -0.14973280f, 0.27421471f, 0.02409255f, 
    0.03577301f, 0.21053793f, -0.04596022f, -0.10145395f, -0.08790650f, 0.20644535f, 0.10228491f, 0.16242447f, 
    0.10360724f, 0.05405778f, 0.22013438f, -0.21853347f, -0.15243103f, 0.07509398f, -0.06811710f, 0.38475412f, 
    -0.06242422f, 0.06415024f, -0.26115084f, -0.13767168f, 0.04323945f, 0.04876824f, 0.32090425f, -0.07346577f, 
    0.05710718f, 0.17499429f, 0.02572591f, -0.02149846f, -0.14530993f, -0.15140830f, 0.02439917f, -0.25618485f, 
    0.12540221f, 0.20176725f, -0.10876829f, 0.11177575f, -0.09674949f, 0.13357198f, 0.04429490f, -0.03818968f, 
    -0.26606670f, -0.08099212f, -0.03419712f, 0.34129950f, -0.00819085f, -0.16257270f, 0.08451264f, -0.04301655f, 
    0.04626643f, 0.10672584f, 0.01389431f, 0.29438746f, 0.17348519f, -0.06568532f, 0.10330483f, 0.07554456f, 
    -0.00043823f, 0.07503108f, -0.13451238f, -0.13869517f, 0.22540861f, 0.04188066f, -0.04608314f, 0.06594718f, 
    -0.22271699f, 0.08742311f, 0.03009317f, -0.10853378f, -0.07074255f, 0.22477019f, 0.33904195f, 0.26237783f, 
    -0.00401984f, -0.10704593f, -0.37748745f, 0.02262205f, -0.18538740f, -0.22535531f, 0.11861899f, -0.02603050f, 
    -0.05926528f, -0.21300286f, -0.08421095f, 0.14131950f, -0.26468617f, 0.22934350f, 0.22895087f, 0.15999360f, 
    -0.12344430f, -0.29463744f, -0.15182783f, -0.06268317f, 0.07058691f, 0.21265309f, 0.27873394f, 0.22869891f, 
    -0.24314426f, -0.05163298f, -0.04506892f, 0.14625835f, 0.10226215f, -0.11045884f, 0.29975876f, 0.09490398f, 
    0.23018503f, 0.15089448f, -0.23319855f, 0.06651169f, -0.23690465f, -0.01023029f, -0.06594431f, 0.00727076f, 
    -0.05773388f, 0.38211823f, -0.01707893f, 0.05513256f, -0.06834131f, 0.04577290f, 0.06170737f, -0.05669106f, 
    0.11032151f, 0.03939351f, 0.13047238f, -0.09745020f, 0.14365135f, -0.06861376f, 0.34284031f, 0.03020874f, 
    -0.15026048f, -0.19877775f, 0.05133139f, -0.07713945f, 0.04978054f, 0.17755063f, 0.14669262f, -0.07969215f, 
    -0.07072090f, 0.01341301f, 0.39562884f, 0.48853168f, -0.08007651f, -0.26744297f, 0.06859310f, -0.05843268f, 
    0.18205833f, 0.01125521f, 0.03623284f, 0.22792305f, 0.10922495f, -0.03102599f, -0.05871039f, -0.08313733f, 
    0.13770519f, 0.05373194f, 0.03463588f, 0.20031151f, 0.02766166f, 0.14444137f, 0.21154545f, -0.13857691f, 
    -0.25225112f, -0.03605982f, 0.26658359f, 0.11809659f, 0.02465147f, -0.18757342f, 0.21098675f, -0.12714022f, 
    -0.06223480f, -0.14547513f, -0.06017384f, -0.10528228f, 0.42287239f, 0.00053213f, -0.14208545f, -0.05783845f, 
    -0.08139218f, 0.22247545f, 0.02444377f, 0.08069348f, -0.28281027f, 0.21428363f, -0.28795758f, -0.07515454f, 
    0.06011142f, -0.06137381f, -0.00385207f, 0.13504325f, 0.12574023f, 0.00132053f, -0.18157448f, -0.10361228f, 
    -0.04572615f, 0.05467687f, -0.02900717f, 0.17358613f, 0.00179877f, -0.00238334f, -0.15440179f, 0.38426533f, 
    -0.14132814f, -0.16117968f, 0.31462190f, 0.28631365f, 0.22186837f, 0.21731250f, -0.02411092f, 0.44653356f, 
    0.03467811f, 0.02659387f, 0.23869610f, -0.17813933f, -0.17879748f, -0.12729028f, -0.10995440f, 0.00825444f, 
    -0.00081984f, -0.01724007f, -0.08547688f, 0.26853922f, -0.40258470f, -0.12133138f, -0.14918599f, 0.10726722f, 
    0.03395614f, 0.15603213f, -0.17165455f, -0.01770208f, 0.14465867f, -0.00036272f, 0.45522603f, -0.05722397f, 
    -0.31365740f, 0.03593773f, -0.17878069f, -0.16495652f, 0.25984666f, -0.14262992f, 0.25632682f, 0.36344168f, 
    -0.02488136f, -0.04359493f, 0.06555723f, -0.05615865f, 0.00069922f, -0.04276071f, 0.22655945f, -0.04003932f, 
    0.10825397f, 0.22745284f, -0.15380886f, -0.00825212f, 0.19443512f, 0.03398297f, 0.01581030f, 0.03247589f, 
    -0.05491605f, 0.33438712f, -0.28258747f, 0.01121232f, 0.12678576f, 0.26252055f, -0.04656582f, 0.24091688f, 
    -0.02251364f, 0.06743494f, -0.02736767f, -0.18675552f, -0.12501071f, -0.01402475f, 0.07771745f, 0.36957255f, 
    -0.02362021f, -0.12860337f, -0.14911792f, 0.00679534f, 0.01824395f, 0.18986350f, 0.17020780f, 0.08280757f, 
    0.10820212f, 0.02888652f, -0.08052433f, -0.18991683f, 0.08603770f, -0.06821587f, 0.12892339f, 0.09382561f, 
    0.38907489f, 0.21078722f, -0.18446729f, 0.04007609f, -0.13061638f, 0.24100821f, 0.15357652f, -0.20133607f, 
    -0.16828722f, 0.05270573f, -0.06299035f, -0.01977237f, -0.00173710f, -0.12150824f, -0.09414788f, -0.14092210f, 
    -0.08153330f, 0.01730587f, -0.15452017f, -0.06606312f, -0.02854432f, 0.02922388f, 0.08650485f, 0.14452592f, 
    0.09197749f, -0.09272714f, -0.13031307f, 0.14160566f, 0.04109899f, 0.07621403f, 0.11035898f, 0.04631833f, 
    -0.05227934f, -0.02090922f, -0.06935314f, 0.15108067f, -0.15300646f, -0.02133205f, -0.06553882f, 0.11611728f, 
    0.25389230f, -0.14866708f, 0.19856745f, -0.13826638f, -0.04064483f, 0.07950997f, 0.05563909f, 0.21808819f, 
    -0.07696464f, -0.11306114f, 0.13393566f, -0.08087029f, -0.01777647f, -0.19927448f, 0.14572081f, -0.01437529f, 
    -0.02510430f, 0.12743899f, 0.08405332f, 0.36831650f, -0.39643401f, 0.05689400f, 0.13948686f, -0.42492381f, 
    -0.15987098f, 0.06061295f, 0.07057793f, 0.00904872f, -0.13140480f, -0.05411519f, 0.33513838f, -0.15972330f, 
    -0.25065982f, -0.03632421f, 0.15896198f, 0.34701237f, 0.05563422f, -0.22594035f, -0.08525841f, -0.22465669f, 
    -0.14728613f, -0.00285027f, 0.30096182f, 0.24882190f, 0.01483184f, -0.17587149f, 0.33397341f, -0.13127482f, 
    0.13099484f, 0.04422047f, -0.27253947f, 0.03234800f, -0.08202821f, -0.08752839f, 0.11981900f, 0.33103582f, 
    0.09530574f, -0.15704712f, -0.08551310f, -0.09548700f, 0.19096079f, 0.02246238f, 0.50341165f, 0.07592503f, 
    0.16383758f, 0.13147190f, -0.09874675f, -0.30873182f, 0.05866362f, 0.01497435f, 0.05262796f, -0.46157318f, 
    0.02629495f, -0.19266541f, -0.07340395f, 0.28989315f, -0.01196086f, 0.02842030f, 0.20302343f, 0.12036023f, 
    0.01471271f, 0.10508506f, 0.01046503f, 0.00915194f, 0.21591958f, -0.16653085f, 0.34924328f, -0.56230098f, 
    -0.18862680f, -0.19085371f, -0.00281679f, 0.15759519f, 0.12145399f, 0.15131836f, 0.21710256f, 0.03494928f, 
    0.06323566f, -0.12538791f, -0.00350359f, 0.10062252f, -0.10714916f, -0.03627341f, 0.10857560f, -0.13876666f, 
    0.14908636f, -0.11473686f, -0.12174503f, -0.17887668f, -0.02183355f, -0.07473148f, 0.00878616f, -0.03852038f, 
    -0.08527251f, -0.09955300f, 0.01996269f, -0.09093744f, 0.02604534f, -0.12448192f, -0.08760260f, 0.14669174f, 
    -0.13392614f, 0.12182190f, 0.02277329f, 0.15706763f, 0.07762029f, -0.11123881f, -0.15693526f, -0.16115284f, 
    -0.24612369f, -0.00117351f, -0.00784027f, 0.07033030f, -0.11894866f, -0.13035791f, -0.01085960f, -0.33121589f, 
    0.14043382f, 0.10784210f, 0.19952835f, -0.13958885f, -0.18900585f, -0.56497705f, -0.35318819f, -0.03266728f, 
    0.11908678f, 0.22774979f, 0.25301546f, 0.25369471f, -0.01210741f, -0.13116939f, 0.47234040f, 0.39234850f, 
    -0.36723620f, -0.30241096f, 0.10346414f, -0.05787347f, 0.10153618f, -0.03404098f, -0.43127820f, 0.02619590f, 
    -0.02443034f, 0.16318929f, -0.24510998f, 0.18859702f, 0.01570223f, -0.08344924f, 0.22709936f, 0.01742755f, 
    -0.17109522f, 0.28259996f, -0.30632779f, 0.00728242f, -0.01116651f, -0.12943156f, 0.11187986f, 0.08902329f, 
    -0.07617416f, -0.07539137f, 0.09904920f, -0.50599360f, 0.00523288f, -0.03957759f, 0.21482317f, 0.24112074f, 
    0.03441090f, -0.23450111f, 0.25824583f, 0.10659561f, 0.15807578f, 0.30142313f, -0.14870848f, 0.07812494f, 
    -0.17503329f, 0.16211109f, 0.09249458f, 0.21629670f, 0.23229936f, -0.26325443f, -0.06409099f, 0.08008173f, 
    0.11237542f, 0.06766728f, 0.28992310f, -0.01081156f, 0.12257329f, 0.17708844f, 0.02875495f, -0.02206654f, 
    0.15698481f, -0.04326853f, 0.08387721f, 0.31221375f, -0.04343068f, -0.02587039f, 0.10796178f, 0.05563074f, 
    -0.20041932f, 0.02594705f, -0.29222035f, 0.04248539f, 0.02040110f, -0.11439151f, 0.13787492f, 0.21262804f, 
    -0.44362018f, -0.02739687f, -0.28356382f, 0.01394721f, 0.24704708f, 0.28286713f, -0.20675929f, -0.27282983f, 
    0.18286175f, 0.10376336f, -0.07955313f, 0.22508012f, -0.27740836f, 0.03250007f, -0.00241174f, -0.15651162f, 
    -0.14092447f, 0.24711815f, 0.19972543f, -0.10858705f, 0.13405801f, -0.11129469f, 0.15310818f, 0.36486065f, 
    0.01943547f, -0.13334768f, -0.19143762f, 0.14561483f, -0.01867264f, -0.15925154f, -0.46785796f, 0.38678148f, 
    0.28589621f, 0.07118736f, 0.21307354f, 0.03580146f, -0.24545217f, 0.28735846f, -0.04580102f, 0.29781628f, 
    -0.12669639f, 0.22479512f, -0.01641623f, 0.11468510f, -0.06680267f, 0.05887246f, 0.33877963f, -0.10114225f, 
    -0.15799746f, -0.14232683f, 0.07678243f, -0.17863475f, -0.18807010f, 0.14734666f, 0.17800532f, 0.15634789f, 
    0.41549373f, -0.15077707f, 0.17685197f, 0.08540001f, -0.02615772f, 0.00403529f, -0.12352883f, -0.21232493f, 
    -0.18022822f, -0.17507228f, -0.09661757f, -0.34578612f, 0.33893505f, 0.29000050f, -0.39610055f, 0.07732025f, 
    -0.10064816f, 0.18379901f, 0.14685825f, 0.04789205f, -0.43465021f, -0.09109676f, 0.19502929f, -0.01723956f, 
    0.10058104f, 0.04011054f, -0.14707825f, 0.29909641f, -0.09707352f, 0.02343375f, 0.19956377f, 0.08988167f, 
    0.08896454f, 0.26042300f, -0.27316990f, 0.07392519f, 0.10619970f, 0.09409209f, 0.20175985f, 0.34447715f, 
    -0.02893401f, 0.10545759f, 0.10130972f, -0.03329647f, -0.08371232f, 0.04881226f, -0.03299911f, -0.05281735f, 
    0.16358437f, -0.19498235f, -0.13869850f, 0.09489042f, -0.10972681f, -0.12239767f, -0.05351838f, 0.11599658f, 
    -0.11237842f, -0.18298846f, -0.21183887f, 0.06152752f, -0.12759539f, -0.11497066f, 0.09108821f, -0.14188595f, 
    0.13179003f, -0.00914467f, -0.12466336f, -0.14207216f, 0.02426440f, -0.04566146f, -0.08806244f, 0.06016056f, 
    -0.03110340f, -0.03057391f, -0.08326402f, -0.06419984f, -0.11159903f, 0.15791471f, 0.04900377f, -0.30855575f, 
    0.12788093f, 0.14794445f, 0.23214343f, -0.02454698f, -0.30474979f, -0.00001163f, -0.28984895f, -0.03736548f, 
    -0.10630018f, 0.03774775f, 0.28214496f, 0.14654194f, -0.14312501f, -0.02664202f, -0.00192095f, 0.02186656f, 
    -0.05255415f, -0.31063411f, 0.02105414f, 0.10127024f, 0.18350334f, 0.16541186f, 0.42500460f, 0.15993650f, 
    -0.00032759f, -0.12808223f, -0.14077470f, 0.01154971f, -0.27414566f, 0.13582927f, 0.22268501f, 0.24232841f, 
    0.06118970f, 0.31427446f, -0.28312057f, 0.10670496f, -0.16012427f, 0.16307165f, 0.11433747f, -0.06624492f, 
    -0.09060820f, 0.02638927f, 0.06863345f, -0.26945570f, 0.00896705f, 0.03289118f, 0.28899351f, 0.36204344f, 
    0.21163338f, -0.03506033f, 0.28440350f, 0.02143171f, -0.13756238f, -0.02795879f, -0.35769442f, 0.06166320f, 
    -0.39631674f, 0.00275587f, 0.10067720f, 0.17644869f, -0.34429765f, 0.10744642f, 0.00766719f, -0.40561911f, 
    -0.13998380f, 0.15871827f, -0.03839855f, 0.23759873f, -0.03837580f, 0.16317178f, -0.38445526f, -0.07769912f, 
    0.04541804f, 0.28743494f, 0.17279173f, -0.20684302f, 0.13492267f, 0.09616566f, 0.26659703f, 0.26512697f, 
    -0.26831195f, -0.54944098f, 0.26069990f, -0.17511255f, -0.05113424f, 0.13612914f, -0.31791165f, 0.15534066f, 
    -0.16572089f, -0.14850256f, 0.06170238f, -0.12464481f, -0.02946142f, 0.08262203f, -0.16866158f, -0.21380171f, 
    0.15104741f, -0.08828044f, 0.02056509f, -0.08962893f, -0.08464828f, -0.11745858f, 0.20062377f, 0.05882414f, 
    0.16321397f, 0.02917614f, 0.09300467f, 0.07393400f, -0.03107413f, 0.10603262f, 0.00538210f, -0.02477945f, 
    0.09506197f, -0.38555434f, -0.01247330f, -0.00602722f, 0.14718416f, 0.14147869f, 0.10618015f, 0.03631413f, 
    -0.00092958f, -0.18159196f, 0.32013664f, 0.47359914f, -0.19668064f, 0.08277519f, -0.03204812f, 0.34470230f, 
    -0.09352842f, 0.03447286f, -0.15892318f, 0.28654158f, 0.16429944f, 0.13906828f, 0.22315411f, 0.14223883f, 
    -0.14843582f, -0.02134760f, 0.04332131f, -0.18737362f, 0.00107406f, 0.07849697f, 0.36669540f, -0.10021843f, 
    0.09472069f, -0.14144312f, 0.02550605f, 0.03476039f, -0.04668063f, -0.04428825f, -0.13774808f, -0.04943208f, 
    -0.32443231f, -0.17434800f, 0.04538612f, -0.13692202f, -0.08659829f, 0.14616103f, -0.11630625f, -0.53939301f, 
    -0.01711707f, 0.26852560f, 0.24495444f, -0.19010822f, -0.09907053f, -0.32413602f, -0.07704622f, -0.01498163f, 
    -0.00944419f, 0.24436785f, -0.08547162f, 0.41780952f, -0.27354106f, -0.14875089f, 0.28676739f, 0.39606515f, 
    -0.21322504f, -0.13554092f, -0.17551896f, 0.08439533f, -0.19846267f, -0.01721853f, 0.38867939f, 0.05382327f, 
    0.20156755f, 0.12704852f, 0.09369430f, -0.19752407f, 0.18264279f, 0.24092837f, -0.13312359f, 0.43377942f, 
    0.07023400f, 0.21204853f, -0.24371293f, 0.10950252f, -0.20327798f, 0.12092404f, 0.22314362f, -0.14001058f, 
    -0.02415004f, -0.15866750f, -0.03545046f, -0.24914622f, 0.05984696f, -0.08533459f, 0.11867964f, 0.29376987f, 
    0.32631400f, 0.03165591f, 0.18992648f, 0.14910355f, 0.12969609f, -0.08891827f, -0.22603741f, 0.09814352f, 
    0.00493749f, -0.08842278f, -0.03575356f, 0.23798455f, -0.14240593f, 0.34644797f, -0.05028420f, 0.34872934f, 
    -0.17363262f, -0.00398965f, -0.07937263f, -0.07641815f, -0.36595139f, -0.37514764f, 0.00089928f, 0.10738475f, 
    -0.03250421f, 0.11002768f, 0.10046295f, 0.05961857f, -0.11013234f, -0.14362356f, 0.19413860f, 0.15436211f, 
    0.41950026f, -0.06113355f, 0.16871314f, -0.13690200f, -0.06676616f, 0.15384392f, -0.69389045f, 0.07310736f, 
    -0.21072796f, 0.10108405f, -0.15387645f, 0.10278785f, -0.14401278f, -0.19132794f, -0.13684250f, -0.11563728f, 
    0.08085179f, 0.03145014f, -0.08929669f, -0.11774026f, -0.14087631f, 0.10967619f, 0.01619402f, 0.14810872f, 
    0.14865512f, -0.06674152f, 0.09816200f, -0.07988594f, -0.19699422f, -0.14387612f, 0.03120454f, 0.11184572f, 
    0.12469545f, 0.01935290f, 0.01063634f, 0.16589527f, 0.17459279f, -0.04860283f, -0.12587565f, -0.14660089f, 
    0.09944930f, -0.06496401f, 0.11951239f, 0.15763560f, -0.15917283f, -0.01552016f, -0.11670546f, -0.32773790f, 
    -0.15593237f, -0.14730963f, 0.11834823f, 0.01176925f, -0.09964757f, -0.01245674f, 0.11289319f, 0.10394112f, 
    0.07541222f, -0.15815029f, 0.15950547f, 0.19920929f, 0.24884099f, -0.08590132f, 0.34611031f, 0.34619954f, 
    -0.11208834f, -0.16891223f, 0.18246160f, -0.05250511f, -0.01188313f, -0.15789849f, 0.16241103f, 0.16576403f, 
    -0.24210609f, 0.13160668f, -0.03642903f, 0.22642213f, 0.22049868f, 0.35952485f, -0.04718410f, 0.29384002f, 
    0.04478472f, 0.17514475f, 0.15130444f, -0.12994924f, -0.10100799f, -0.27707636f, -0.06335793f, 0.12126368f, 
    0.12659222f, -0.18483713f, -0.06806976f, -0.12054246f, 0.07928704f, -0.12844761f, -0.55399120f, 0.30411166f, 
    0.37422863f, 0.21896166f, 0.05498041f, -0.04187897f, 0.12943563f, 0.15355332f, -0.07793750f, -0.11448745f, 
    -0.20245926f, 0.16012156f, 0.07026064f, 0.00139310f, -0.22454166f, -0.23611479f, -0.03815456f, -0.08156250f, 
    0.11262724f, -0.00371489f, 0.15747726f, 0.21228810f, 0.18012334f, 0.30942279f, 0.10725930f, -0.09965268f, 
    -0.05892084f, 0.14521930f, 0.07432192f, -0.14258245f, -0.04431555f, 0.00547817f, 0.03619760f, 0.20629959f, 
    0.13304089f, -0.07868253f, -0.12016218f, -0.05870780f, -0.01939994f, 0.09897654f, 0.19125223f, 0.35280856f, 
    -0.02497850f, -0.04400575f, -0.05799806f, -0.44163740f, 0.24247724f, -0.09107305f, 0.23201920f, -0.01031774f, 
    -0.16190875f, 0.36984754f, -0.15675104f, -0.05886504f, 0.12006038f, 0.33245954f, -0.30127144f, 0.04002753f, 
    0.08893802f, 0.21603024f, -0.01228561f, 0.19098914f, -0.02764685f, 0.05798936f, 0.05064304f, 0.07427548f, 
    -0.20890908f, 0.02062115f, -0.18047610f, 0.06369326f, 0.13762334f, 0.22349508f, 0.02823137f, -0.04055972f, 
    0.00558464f, -0.17200352f, -0.00012832f, -0.11868430f, 0.07347996f, 0.00426985f, -0.04894911f, 0.01431526f, 
    0.05449608f, -0.14260246f, -0.14610040f, -0.11585283f, -0.12791307f, 0.02881716f, -0.08335669f, -0.02298474f, 
    0.16947287f, -0.16244999f, -0.14763163f, 0.07185903f, -0.09309772f, -0.16800809f, -0.17080124f, 0.02246839f, 
    0.10844395f, -0.00752753f, -0.11251270f, 0.02941174f, 0.02626157f, -0.17024417f, 0.09701935f, 0.00039865f, 
    -0.06155927f, 0.01790465f, 0.04453363f, -0.18395913f, -0.03561679f, -0.11916658f, -0.23854081f, -0.16600515f, 
    -0.10669589f, 0.29352400f, -0.03185032f, -0.08882752f, 0.01001710f, 0.07512474f, 0.05814734f, -0.04457639f, 
    -0.03366765f, 0.16890109f, 0.15680990f, 0.17073320f, -0.18341859f, -0.15227665f, 0.39333594f, 0.10632418f, 
    0.05561284f, 0.09092115f, -0.27624139f, 0.17547715f, 0.02201278f, -0.01611519f, -0.25372499f, 0.01282717f, 
    -0.11915700f, 0.16420315f, 0.04335850f, -0.05255231f, -0.15242253f, -0.16845040f, 0.03126181f, 0.13420424f, 
    0.14510433f, 0.09036752f, -0.17311479f, 0.10854590f, -0.13838239f, -0.00992590f, -0.09350790f, 0.07527655f, 
    0.02908879f, -0.04603837f, -0.12005530f, -0.15806754f, -0.16816777f, 0.14577360f, -0.10369707f, -0.17439868f, 
    -0.00215623f, -0.14606266f, 0.02703790f, 0.06410828f, 0.13413005f, -0.06005108f, 0.09954011f, -0.05772803f, 
    -0.34450945f, -0.08440223f, 0.25535449f, -0.15225856f, -0.11230422f, -0.20108074f, 0.06078201f, 0.23353678f, 
    0.15923072f, -0.01920709f, -0.13373323f, 0.15081708f, 0.17890918f, 0.33854225f, 0.15085776f, 0.15944961f, 
    -0.15632232f, 0.08093496f, -0.18067247f, -0.06675594f, -0.01968971f, -0.17690191f, 0.18712552f, -0.05182010f, 
    0.03914756f, 0.20825581f, -0.14423211f, -0.00787865f, -0.03888153f, 0.11813495f, 0.29080179f, 0.17060764f, 
    -0.12830968f, 0.08304247f, 0.21438453f, 0.16847478f, 0.06917838f, 0.04062172f, -0.33718073f, 0.38816276f, 
    0.16596390f, -0.12404670f, 0.07993554f, -0.01817353f, 0.04663709f, 0.16104065f, -0.07800290f, 0.00255832f, 
    0.12697464f, -0.06296252f, -0.00281646f, 0.06573402f, 0.00065825f, 0.11112412f, 0.17102438f, -0.21294118f, 
    0.11702522f, 0.08932555f, -0.16208537f, -0.11244503f, -0.18421835f, -0.00919402f, 0.40472278f, 0.20008910f, 
    0.13571100f, -0.17031482f, -0.08126252f, 0.14222512f, -0.06022402f, 0.15200679f, 0.11695612f, 0.30463758f, 
    -0.14714803f, 0.13678037f, 0.19425838f, -0.25653344f, -0.13730259f, -0.35439110f, 0.07881985f, -0.14118163f, 
    -0.08220046f, -0.00116221f, 0.10983211f, -0.05413844f, -0.21556796f, 0.03139826f, 0.12206189f, 0.25378478f, 
    0.34061149f, 0.14066793f, 0.24837156f, 0.09986567f, -0.14375418f, 0.24188846f, -0.41488913f, -0.33341104f, 
    -0.09023506f, 0.00220078f, -0.02556224f, -0.17788024f, 0.37289605f, 0.04957318f, 0.04835661f, -0.08900504f, 
    0.10998961f, -0.04895759f, 0.15491891f, -0.32145551f, -0.00712512f, -0.24147722f, -0.19702280f, -0.13742012f, 
    -0.02065085f, 0.03841088f, 0.11448613f, 0.35614827f, -0.10057715f, -0.15958618f, 0.20242934f, -0.11451615f, 
    0.10607608f, 0.13774392f, 0.00763475f, 0.18129471f, -0.20509088f, -0.04413635f, -0.03258845f, -0.10624218f, 
    -0.10527086f, -0.16995010f, -0.16299906f, -0.12253125f, 0.05658455f, 0.12055840f, 0.24555881f, -0.20440491f, 
    0.11839534f, 0.16935046f, -0.06515785f, -0.01309945f, 0.04135824f, -0.06504527f, 0.02209016f, 0.14273858f, 
    0.12385271f, 0.14488544f, 0.13519152f, 0.25322288f, -0.09969198f, -0.13904530f, -0.35732779f, 0.19469580f, 
    0.05750972f, 0.27105448f, -0.21515308f, -0.16695306f, -0.05056259f, 0.26800886f, 0.12356839f, -0.21502891f, 
    0.17128465f, 0.06173370f, 0.34024009f, 0.11912897f, -0.16340517f, 0.12877131f, -0.09783401f, 0.29596123f, 
    0.17691571f, -0.11711904f, -0.10691238f, -0.01855915f, 0.19709954f, -0.62403542f, 0.00170262f, -0.00743964f, 
    0.11262010f, 0.29263920f, 0.06845496f, 0.13796064f, -0.34746069f, 0.02202305f, 0.21010666f, -0.05303544f, 
    0.12514032f, 0.14598568f, 0.07963855f, 0.10551260f, 0.08600762f, -0.04020410f, -0.39504948f, -0.07414239f, 
    0.14275073f, -0.12047354f, -0.21982817f, -0.29896995f, 0.08135724f, 0.10746973f, 0.02841802f, 0.17045730f, 
    -0.13217291f, 0.00544698f, -0.18635260f, 0.16864410f, -0.04833356f, -0.04783819f, 0.04967624f, -0.06407423f, 
    -0.02721424f, -0.09700640f, -0.10861771f, -0.03053002f, 0.09463561f, 0.07756227f, 0.21076903f, -0.16234006f, 
    -0.21915777f, 0.03722313f, -0.02935827f, -0.13627994f, -0.17581230f, 0.17881763f, 0.09063290f, -0.10687952f, 
    0.30219838f, -0.00696230f, 0.02344226f, 0.14798518f, 0.24980803f, -0.12099946f, -0.26958889f, 0.18640859f, 
    0.03750817f, -0.03311406f, -0.00441717f, 0.12020966f, 0.01044112f, -0.19966558f, 0.14731346f, 0.14613515f, 
    0.06005087f, -0.16122307f, -0.11470775f, -0.01996351f, -0.07633246f, -0.15589584f, 0.51571739f, 0.35737267f, 
    0.13051781f, 0.17501351f, 0.04092564f, 0.06843379f, 0.13055353f, 0.10424077f, 0.26424062f, 0.03583485f, 
    -0.19112365f, -0.05264902f, -0.18753223f, -0.18447550f, -0.15875080f, 0.02035312f, 0.11810564f, -0.31685466f, 
    -0.03304683f, 0.25642091f, 0.08098526f, 0.09602859f, 0.27024016f, 0.10716417f, -0.30303136f, -0.15988283f, 
    0.04843141f, 0.11032737f, 0.13738920f, -0.15294369f, -0.08122536f, -0.14502166f, 0.17306638f, 0.28387582f, 
    -0.11321283f, -0.15962666f, 0.21692769f, -0.03462901f, 0.00285608f, 0.17113395f, -0.20017624f, -0.15549023f, 
    0.32880354f, 0.16132836f, 0.04231542f, 0.23986526f, -0.13339880f, 0.39930373f, -0.43410933f, 0.33523262f, 
    -0.16333851f, 0.00753082f, -0.12011633f, 0.07711667f, -0.59190816f, 0.04618428f, -0.02643804f, 0.00563409f, 
    0.03863531f, 0.11355065f, 0.21815199f, -0.10862499f, -0.22916137f, 0.03523699f, 0.13453165f, -0.03972261f, 
    0.09829404f, -0.39096886f, 0.22280242f, 0.00485477f, -0.20644329f, 0.13912982f, -0.03758784f, -0.34056172f, 
    -0.24372119f, -0.15773588f, 0.18120801f, 0.40624878f, 0.04786613f, 0.08929414f, -0.18194056f, -0.11206049f, 
    -0.05231587f, -0.19513474f, 0.23726936f, 0.06655969f, 0.02018100f, -0.14047083f, 0.01822629f, -0.11080975f, 
    0.03499065f, -0.14095393f, -0.18979014f, 0.29820952f, -0.09116520f, -0.11114125f, 0.04737991f, 0.14542539f, 
    0.07196383f, 0.12861218f, 0.03417058f, -0.14653824f, -0.07035500f, 0.09392422f, 0.28076306f, -0.08508980f, 
    -0.25562668f, 0.07772342f, -0.19103487f, -0.04227665f, 0.04325957f, -0.16438271f, 0.34400594f, -0.03180798f, 
    0.00828959f, 0.12679213f, -0.00594482f, 0.09988498f, 0.31848413f, 0.08990972f, -0.28666568f, -0.05735415f, 
    -0.07148077f, 0.02852597f, 0.07159682f, -0.06777285f, 0.12432536f, -0.09441212f, 0.01879661f, 0.30287209f, 
    -0.12860674f, 0.21016851f, -0.12147722f, 0.08649808f, 0.16210884f, 0.36752337f, -0.12554032f, 0.12481488f, 
    0.09472167f, 0.08510933f, -0.14190240f, -0.23449212f, -0.40880370f, 0.34317380f, 0.16785613f, -0.28491160f, 
    0.09984080f, 0.12902312f, -0.11487060f, -0.29321796f, -0.46050519f, 0.09957114f, -0.38723907f, 0.07215466f, 
    -0.07005609f, 0.28252593f, 0.36093393f, -0.28748429f, 0.02754861f, -0.03562737f, 0.09019534f, 0.12749928f, 
    -0.00348883f, -0.46318278f, 0.36033446f, -0.06720828f, 0.06173620f, 0.15276615f, -0.01250392f, -0.07221010f, 
    -0.09660844f, -0.12537228f, -0.03545596f, -0.03508097f, -0.06634540f, -0.16449338f, -0.00463174f, -0.11103286f, 
    0.13802744f, 0.12282360f, -0.12699488f, -0.11299017f, 0.01929216f, -0.15379280f, -0.12632997f, 0.13164115f, 
    -0.12641089f, -0.20365524f, 0.04197351f, -0.04075978f, 0.04657868f, -0.16200536f, -0.09272791f, -0.12331234f, 
    0.08686535f, -0.14896503f, -0.10448449f, 0.03983351f, 0.03795962f, -0.10908831f, 0.11934441f, -0.19313172f, 
    0.00603620f, 0.01724639f, 0.33551246f, 0.43478125f, -0.22234167f, -0.13560936f, 0.04859510f, 0.13534473f, 
    -0.05139603f, 0.03394670f, -0.10907698f, 0.21157467f, 0.21698314f, 0.17955677f, 0.27892396f, 0.10157669f, 
    0.04969847f, -0.21041612f, 0.04003803f, -0.01618646f, 0.01850219f, -0.09024546f, 0.04526446f, 0.15642111f, 
    0.12504373f, -0.12301347f, -0.17788336f, 0.13521411f, 0.21255036f, 0.14063683f, 0.14667165f, 0.12935761f, 
    -0.10000979f, -0.10573924f, -0.10157089f, 0.11331338f, -0.16093722f, -0.07726200f, 0.02709300f, -0.13748956f, 
    0.13180412f, -0.18064795f, 0.06688251f, -0.01498688f, -0.13527785f, 0.03133621f, -0.14837354f, 0.08048510f, 
    -0.00760676f, -0.15313421f, 0.11069258f, -0.00705313f, -0.00440450f, 0.01947814f, 0.04726937f, -0.17634988f, 
    0.12344454f, -0.07033340f, 0.05843183f, -0.06630135f, -0.06251486f, -0.07391562f, -0.13349789f, -0.22007190f, 
    -0.08161870f, 0.17248951f, -0.16849340f, -0.47900113f, 0.33703715f, -0.22352713f, 0.32004687f, -0.05749504f, 
    0.06518666f, -0.04543750f, -0.09064858f, 0.07623398f, 0.10734280f, -0.09127399f, -0.15430355f, 0.07730345f, 
    0.00658633f, 0.28436008f, 0.19858132f, 0.07723843f, 0.17681904f, -0.02278506f, -0.00300791f, -0.04650598f, 
    -0.13075872f, -0.13423403f, 0.15541147f, -0.07545906f, 0.08198239f, 0.15434466f, -0.26950628f, 0.04613160f, 
    0.32709938f, 0.14544323f, 0.20380247f, 0.18923587f, 0.30255008f, 0.04508429f, -0.10061302f, 0.41913125f, 
    -0.11115082f, -0.04568546f, -0.15404290f, -0.01598890f, -0.13968579f, -0.10171042f, 0.23909055f, -0.16226238f, 
    -0.15308478f, -0.13368703f, 0.12345964f, 0.07296076f, -0.14822705f, -0.14738671f, 0.36614251f, 0.03912236f, 
    0.11052888f, -0.04089090f, 0.02402217f, -0.02752937f, -0.18999776f, -0.04109938f, 0.27833226f, -0.08369850f, 
    -0.11496981f, -0.03702485f, -0.02353918f, -0.00937625f, -0.08878324f, -0.11730368f, 0.08409700f, -0.34802663f, 
    0.05242880f, 0.38161024f, 0.18105464f, -0.14732032f, -0.15718237f, -0.21537437f, -0.00985991f, 0.11370003f, 
    -0.08523094f, -0.20529574f, 0.11361451f, 0.01281921f, 0.22055896f, -0.11681627f, 0.14754209f, 0.26518211f, 
    -0.02608378f, -0.08039723f, 0.11469875f, -0.13740613f, 0.11880779f, 0.19350114f, 0.21342613f, -0.03197612f, 
    -0.24023797f, 0.07223306f, 0.30579171f, 0.32369968f, -0.05693524f, 0.00619008f, 0.16736017f, 0.33122349f, 
    0.14458236f, -0.35879886f, 0.13237464f, -0.01042502f, -0.02721315f, -0.27765471f, 0.03050642f, 0.02490015f, 
    0.17654277f, 0.21053778f, -0.21916923f, 0.27052742f, -0.13255030f, -0.03036731f, 0.25412580f, 0.19312349f, 
    -0.21205573f, 0.04822773f, 0.02094839f, -0.17464046f, -0.11093973f, 0.20249552f, -0.11130054f, -0.12906380f, 
    -0.05083556f, -0.03671563f, -0.35609785f, -0.41806802f, 0.16640367f, -0.19531983f, 0.38603312f, 0.18158931f, 
    0.04476130f, 0.09701417f, -0.09276243f, -0.14131644f, 0.04827534f, -0.01777771f, -0.09160396f, 0.04854186f, 
    0.03055940f, 0.07897413f, 0.10987761f, 0.12152383f, 0.18859012f, 0.15278651f, -0.16948017f, -0.16640340f, 
    -0.11282255f, 0.12028978f, 0.16842984f, -0.11702380f, -0.14399144f, 0.39231580f, -0.02830995f, -0.13437836f, 
    -0.11908472f, -0.04426110f, -0.23390310f, -0.18972781f, 0.04717353f, 0.24752487f, 0.30425099f, -0.22422495f, 
    0.08541339f, 0.28811026f, 0.00589155f, -0.27280989f, -0.07978540f, 0.16215548f, -0.26188573f, -0.02654156f, 
    -0.08464223f, 0.28385404f, 0.17116606f, -0.14606470f, -0.11570136f, 0.03885458f, -0.20634331f, -0.07602844f, 
    0.04451152f, -0.17154740f, 0.18549699f, -0.08850671f, 0.10375347f, 0.29719070f, 0.12793535f, -0.27181217f, 
    -0.38534030f, 0.12663630f, 0.21529758f, -0.16665407f, 0.33440322f, -0.09376311f, 0.00558034f, 0.28016087f, 
    -0.09850831f, 0.01211329f, 0.21784596f, -0.29460540f, 0.04029512f, -0.16939154f, 0.05128214f, -0.16154771f, 
    -0.13583075f, -0.02749262f, -0.16118127f, 0.43110153f, -0.22933225f, 0.06913355f, 0.13819411f, -0.07123423f, 
    -0.13371439f, 0.17432255f, -0.21943727f, -0.12424195f, -0.17167325f, -0.04382209f, 0.32434452f, 0.10718283f, 
    0.26561287f, 0.05191518f, -0.03284331f, 0.33484137f, 0.07336903f, 0.23395371f, 0.15946074f, 0.28216779f, 
    -0.13458848f, -0.22485200f, -0.30542892f, -0.06680874f, -0.34606162f, 0.07046036f, -0.05070564f, -0.00780176f, 
    0.08280205f, -0.02682134f, 0.03904695f, 0.21049008f, -0.10940067f, -0.01431692f, 0.14804339f, -0.01173385f, 
    0.22470203f, -0.02166286f, 0.19535644f, 0.17265585f, 0.11899327f, -0.24746001f, 0.12001575f, -0.26758754f, 
    -0.10134733f, -0.10442976f, -0.11285773f, -0.08922674f, 0.13239887f, -0.21735688f, -0.00745948f, 0.03454791f, 
    0.03050448f, 0.11434667f, 0.03217259f, 0.04811665f, -0.09107787f, 0.33916745f, -0.11172102f, 0.11728697f, 
    0.01554155f, 0.17840464f, -0.11955260f, 0.25922716f, 0.17776637f, 0.04561646f, 0.01865153f, -0.09663699f, 
    0.00554638f, 0.18094070f, -0.12803978f, -0.01556570f, -0.20218238f, 0.21452610f, 0.11111203f, 0.26746845f, 
    -0.11781066f, 0.10359889f, -0.26183105f, -0.35211557f, -0.12790978f, 0.35498750f, 0.22830948f, 0.16510850f, 
    0.05322487f, -0.08663190f, -0.23051064f, -0.06161358f, 0.13162199f, -0.07430452f, 0.24915020f, 0.10119401f, 
    0.16939202f, 0.15848866f, -0.00714071f, -0.04553267f, 0.07929415f, 0.10826147f, 0.22607546f, 0.14298615f, 
    0.00309730f, 0.15114187f, 0.05952108f, 0.05292999f, -0.13359034f, 0.23734811f, -0.44195223f, -0.18300469f, 
    -0.30716148f, -0.06292478f, 0.23567802f, 0.12854882f, 0.15172262f, 0.05674094f, -0.28561556f, 0.09996606f, 
    -0.11876375f, 0.09427504f, 0.23260394f, -0.31319252f, -0.05771335f, -0.35087129f, -0.11050565f, -0.13380317f, 
    0.16406032f, 0.16393080f, 0.04385811f, 0.39781958f, -0.17094551f, 0.02586505f, 0.03012223f, -0.04047322f, 
    0.22468734f, -0.05133897f, -0.19784801f, 0.09110203f, 0.19239959f, 0.19688261f, 0.16539966f, -0.00905453f, 
    0.01126919f, 0.01295678f, -0.13934787f, -0.23367783f, -0.12745599f, 0.07796580f, -0.00881960f, -0.12568510f, 
    0.12163807f, 0.19890727f, -0.25156575f, 0.04880604f, -0.12935428f, -0.03376895f, 0.13344097f, -0.09956430f, 
    -0.13267340f, 0.23497011f, 0.10627963f, -0.14900015f, 0.15263091f, 0.16075486f, 0.29266909f, 0.05372945f, 
    -0.16108936f, 0.15743954f, 0.10972074f, -0.10435822f, 0.03888375f, 0.03308772f, -0.42397740f, 0.08483338f, 
    -0.15716672f, 0.08380640f, 0.31762582f, 0.41866845f, -0.10948186f, -0.03319802f, 0.11253178f, 0.17641063f, 
    -0.08188994f, -0.01732173f, -0.01658296f, -0.00339992f, 0.12851989f, 0.06459581f, 0.19089662f, -0.04111428f, 
    -0.04540382f, -0.17590588f, -0.21678433f, -0.02550459f, -0.05349817f, 0.00733860f, -0.08902237f, 0.35799292f, 
    -0.03171017f, 0.08665957f, 0.08039306f, 0.11587428f, -0.06859384f, -0.10759119f, 0.27849993f, 0.00795048f, 
    -0.08906867f, 0.15167008f, -0.08095274f, -0.17769301f, 0.08559758f, 0.17529573f, 0.15225074f, -0.03388282f, 
    0.01221914f, -0.18505722f, -0.13229060f, -0.06609224f, -0.06683567f, 0.02812140f, 0.04526700f, 0.14725992f, 
    0.09962389f, -0.16601303f, -0.11471877f, 0.01715736f, -0.16606005f, -0.13241972f, -0.17808074f, 0.12647067f, 
    -0.13622443f, -0.14590298f, 0.16334654f, 0.13651958f, 0.13861744f, -0.00407661f, -0.09671813f, 0.03206635f, 
    0.00204344f, 0.15006250f, 0.21673860f, 0.12816048f, 0.00612106f, -0.10040171f, -0.17251927f, 0.36096480f, 
    0.07262293f, -0.24730392f, 0.18867752f, 0.03078912f, 0.05938350f, 0.13465667f, 0.12010370f, 0.00401547f, 
    -0.00144531f, -0.24547076f, 0.06210247f, -0.04552106f, 0.00295981f, -0.07899191f, 0.62000030f, 0.06502418f, 
    -0.06234902f, 0.02476587f, 0.11053851f, 0.06657416f, 0.09802175f, -0.04784325f, 0.20137325f, -0.14205532f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.28674287f, -0.05823534f, 0.18414828f, -0.16863051f, 0.31133321f, 0.14239037f, 0.12358029f, 0.04498195f, 
    0.22485539f, -0.01415736f, 0.12362368f, -0.02873304f, 0.23835839f, 0.00339430f, 0.20405215f, -0.10235783f, 
    -0.02740253f, -0.15048712f, -0.07560255f, 0.09246180f, -0.02660088f, 0.09460406f, 0.08636139f, 0.07053940f, 
    0.13777126f, 0.27262050f, -0.03583776f, 0.10568777f, 0.12365730f, 0.24595433f, -0.10185720f, 0.27752793f, 
    0.05402330f, 0.09353669f, -0.04944745f, -0.30551288f, -0.05910400f, -0.10597666f, 0.05126496f, 0.12040515f, 
    0.08226575f, 0.15565147f, 0.17181781f, 0.05596249f, -0.02614496f, -0.08102810f, 0.16649236f, 0.06218107f, 
    -0.17646195f, 0.24127708f, 0.07962130f, -0.02010639f, -0.03879621f, -0.08135065f, 0.07238211f, 0.26183462f, 
    0.05680472f, -0.09685261f, 0.17837206f, 0.23866762f, -0.14330113f, 0.06062921f, -0.07924629f, -0.02199843f, 
    0.00088349f, -0.06303513f, -0.03740336f, -0.06783727f, -0.09959123f, -0.03540380f, 0.13223644f, 0.07036621f, 
    -0.02322375f, -0.09295356f, 0.18490651f, 0.10001828f, 0.23883016f, 0.15530881f, 0.07514065f, 0.22013153f, 
    -0.15351933f, 0.14811346f, 0.01957181f, -0.02802552f, -0.05325831f, -0.08914126f, 0.39293751f, -0.09928218f, 
    -0.06835237f, 0.02792530f, -0.06372414f, -0.03007327f, 0.07532401f, -0.11048233f, -0.14409472f, 0.26241556f, 
    -0.17082623f, 0.05045548f, -0.10440131f, 0.19075999f, 0.16734108f, 0.00767216f, 0.18674859f, -0.10841958f, 
    0.04870426f, 0.07700647f, 0.05620472f, 0.17234492f, 0.30504274f, 0.28711799f, -0.16734985f, -0.10488254f, 
    -0.04429426f, 0.06937937f, 0.01215644f, 0.03879250f, -0.00449264f, 0.27323401f, -0.02305406f, 0.14981909f, 
    0.08727956f, 0.05045436f, -0.03455140f, 0.06916505f, -0.03040095f, 0.24798051f, 0.13419093f, -0.16855560f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.40130222f, 0.18677455f, -0.05280105f, -0.06372001f, -0.57338649f, -0.53166604f, 0.04086841f, 0.00868325f, 
    -0.57409400f, 0.08711131f, -0.13725145f, -0.00793272f, -0.12388761f, -0.32234332f, -0.17305367f, 0.11317330f, 
    -0.03751319f, -0.20591360f, -0.06044494f, 0.20444706f, 0.21132928f, -0.15569749f, -0.18633743f, 0.08342078f, 
    -0.02090632f, 0.14378001f, -0.02055502f, 0.13516368f, -0.17693508f, 0.00988822f, -0.20878439f, 0.04464997f, 
    0.15658465f, -0.03556845f, -0.12753680f, 0.06579471f, 0.10358060f, -0.07463582f, 0.05691697f, -0.45086974f, 
    0.10895762f, -0.20421869f, -0.32145792f, -0.05314810f, 0.10709652f, -0.06136677f, -0.23539291f, -0.14516002f, 
    0.04408068f, -0.45391837f, 0.34143218f, 0.00861869f, -0.18365622f, -0.01656196f, -0.36334801f, -0.01044699f, 
    -0.13368182f, -0.07945456f, 0.08623470f, -0.35829198f, -0.05591556f, -0.07268588f, -0.01006534f, -0.02606065f, 
    0.15690283f, -0.09784132f, 0.19668147f, -0.10684624f, -0.04567037f, 0.06205912f, 0.05166211f, -0.03567118f, 
    0.04602609f, -0.06910512f, -0.02762696f, -0.04207943f, -0.01878611f, -0.17730184f, 0.13677016f, -0.15998025f, 
    -0.03867514f, -0.23303412f, 0.10115212f, -0.00698659f, -0.03200705f, 0.17154372f, -0.30195624f, 0.09086926f, 
    0.18548310f, -0.05448523f, -0.01194737f, 0.00633046f, -0.28034264f, -0.55067027f, 0.06476089f, -0.36969215f, 
    0.03446266f, -0.15349317f, 0.08410691f, 0.03970649f, -0.09564270f, -0.33995950f, 0.15887779f, -0.19040735f, 
    0.05642702f, -0.42150623f, 0.25478426f, 0.08972540f, -0.33266956f, -0.18986219f, 0.01245443f, 0.02099399f, 
    0.09300609f, -0.10799333f, 0.18738036f, -0.35234824f, 0.16453631f, -0.08906631f, -0.69627929f, -0.12932567f, 
    0.34702536f, -0.26666519f, -0.12057627f, 0.02611146f, -0.09399825f, 0.16166106f, -0.05868287f, 0.12507896f, 
    -0.07160594f, -0.03423062f, 0.06587722f, -0.01625328f, 0.18605980f, 0.18348341f, -0.49604717f, -0.00714655f, 
    0.20183282f, 0.08723266f, 0.33141714f, 0.19871633f, -0.09747300f, -0.17411593f, -0.06820839f, -0.06695204f, 
    -0.07985345f, -0.63664895f, -0.20373212f, 0.03114077f, 0.05225883f, 0.25057214f, 0.17239174f, -0.05409355f, 
    -0.07959341f, 0.13727090f, -0.14613602f, 0.10965750f, 0.05331712f, -0.03092766f, -0.04465472f, 0.37806648f, 
    0.26050696f, 0.08036952f, -0.53841954f, -0.02260838f, 0.03498810f, 0.07254982f, -0.26507986f, -0.44138703f, 
    -0.15840411f, 0.01675231f, 0.24374625f, 0.01753456f, 0.30967489f, -0.08214393f, 0.40697879f, 0.25103056f, 
    0.02487375f, 0.16425762f, -0.29913723f, -0.09218483f, 0.01007369f, -0.01974459f, -0.10759605f, 0.29304969f, 
    0.00162501f, 0.02277563f, -0.03191995f, -0.60975784f, -0.00813958f, 0.05330252f, 0.18214256f, -0.11277545f, 
    0.08786009f, -0.20728467f, 0.19220065f, -0.12077728f, 0.03764381f, -0.00273566f, 0.02212848f, 0.44321012f, 
    0.12011261f, -0.00284527f, 0.02779933f, -0.39688587f, 0.10935801f, -0.36532173f, -0.03679116f, -0.04821258f, 
    -0.02688399f, -0.10126327f, -0.24184725f, -0.02528646f, 0.01534649f, 0.04442845f, 0.13778874f, -0.14537406f, 
    -0.11021316f, 0.07183530f, 0.04761982f, 0.08577411f, 0.04160932f, -0.12855640f, -0.07256895f, -0.04805094f, 
    0.00936130f, 0.15056917f, 0.10090340f, 0.03972182f, -0.03237641f, -0.05154157f, 0.08648223f, -0.07931501f, 
    0.03887691f, -0.06035309f, -0.28191611f, 0.15204135f, 0.03652420f, -0.50593352f, 0.03210385f, 0.11901703f, 
    -0.04799696f, -0.21843188f, -0.05324289f, -0.15590899f, 0.20362532f, -0.12565513f, -0.32073694f, 0.04537997f, 
    -0.69791692f, -0.06237967f, -0.26147327f, 0.07228686f, -0.27524480f, 0.13110697f, 0.05825946f, 0.00503554f, 
    0.11541674f, -0.27415457f, 0.03515280f, 0.03714813f, 0.18550903f, -0.34362972f, -0.12064476f, -0.18291111f, 
    0.17513518f, 0.22639802f, -0.22942686f, -0.07961634f, 0.10581169f, 0.09994663f, 0.12674947f, -0.36423150f, 
    0.04878425f, -0.07375444f, -0.32785004f, -0.22555390f, -0.26576716f, -0.52502322f, -0.17044893f, -0.08259796f, 
    0.06626470f, -0.33569464f, -0.23995048f, 0.02379911f, 0.08237341f, 0.24485075f, 0.05126626f, -0.15690580f, 
    0.08397783f, -0.08557275f, 0.02200813f, 0.14993896f, -0.02104210f, -0.05411337f, -0.50003517f, 0.19739936f, 
    0.19639225f, 0.17781931f, -0.05321235f, 0.06024935f, 0.11952635f, 0.06477090f, 0.02201814f, 0.38305444f, 
    0.15775664f, 0.07534949f, -0.09153441f, -0.00741354f, -0.23670234f, -0.02222037f, 0.15035386f, -0.36827472f, 
    0.16595241f, -0.01047079f, 0.05694340f, 0.34772101f, -0.28600276f, -0.07039978f, 0.09614111f, 0.07172507f, 
    0.08684104f, -0.17925936f, -0.94078404f, -0.15517047f, -0.15957673f, -0.01897117f, 0.09833109f, -0.15974329f, 
    -0.12513904f, 0.06205695f, 0.52411360f, -0.06316111f, 0.00193371f, 0.17267708f, -0.13798143f, -0.26433143f, 
    -0.02995252f, 0.17376095f, -0.05086952f, 0.21926522f, 0.13784009f, -0.09397416f, 0.37673515f, -0.18568981f, 
    -0.01504299f, 0.03233022f, 0.17004336f, -0.30814970f, -0.09375935f, -0.02640567f, -0.07251892f, 0.12841822f, 
    0.07046317f, -0.33842710f, -0.26262814f, -0.01344526f, 0.06924989f, 0.02673623f, 0.06793634f, -0.11064259f, 
    -0.12726694f, 0.11202322f, -0.55936009f, -0.04668363f, 0.04964285f, 0.39044991f, -0.00380143f, -0.14070401f, 
    0.01602490f, 0.12018328f, -0.16694450f, 0.13322474f, 0.14018531f, 0.01480296f, 0.04799156f, -0.25554860f, 
    -0.22406635f, -0.14061229f, 0.09224253f, -0.04883877f, 0.15904863f, -0.05735876f, -0.06867038f, 0.09950141f, 
    0.17730254f, 0.14454193f, -0.15653895f, -0.10362124f, -0.28192559f, 0.41567442f, 0.30115551f, -0.00744776f, 
    -0.34802759f, 0.00336052f, -0.75252008f, -0.16097471f, -0.20450953f, 0.11860061f, 0.08567996f, 0.23805153f, 
    0.00689344f, 0.33949801f, -0.26313144f, -0.06285614f, 0.01072225f, -0.41542053f, -0.05528178f, -0.02660566f, 
    0.07147609f, -0.16180806f, -0.05783787f, -0.10078895f, -0.08025922f, 0.09759737f, -0.11938023f, 0.07347687f, 
    0.13433900f, -0.40830791f, 0.29904455f, -0.25766167f, 0.08055517f, -0.59297341f, -0.01574221f, 0.19640985f, 
    0.21450086f, -0.12858646f, -0.00442691f, 0.00865952f, -0.31222531f, -0.15541512f, -0.26191810f, -0.04868092f, 
    0.33142731f, -0.42796358f, -0.16485506f, -0.10322153f, 0.02528230f, 0.04139413f, 0.11074663f, -0.08000120f, 
    0.15120175f, 0.06539012f, -0.21181335f, 0.01313435f, 0.18397562f, -0.53490376f, 0.02721676f, -0.01491114f, 
    -0.11038552f, -0.21228814f, 0.03224637f, -0.30434245f, -0.02222705f, -0.05081173f, 0.31237364f, -0.49670333f, 
    -0.50690621f, 0.07112992f, -0.00532372f, -0.07340223f, -0.22582863f, -0.19400468f, 0.13720699f, -0.00265965f, 
    -0.03678614f, 0.08625508f, 0.01278139f, 0.00129706f, 0.07910415f, -0.06090956f, 0.04499156f, 0.03504214f, 
    0.05971991f, 0.03752248f, -0.45115566f, 0.00110735f, -0.35339627f, 0.02669493f, 0.02648861f, 0.05602046f, 
    0.03282338f, -0.30799392f, -0.05692798f, 0.13337202f, 0.13902597f, -0.00616612f, 0.16432926f, -0.22463237f, 
    -0.07437080f, -0.04719755f, 0.22825335f, -0.08774688f, -0.27817780f, 0.26847482f, 0.02502112f, -0.28119156f, 
    -0.03856857f, 0.02290477f, 0.05744894f, -0.13143960f, -0.01022823f, 0.12434847f, 0.19745536f, -0.18760790f, 
    0.09444888f, -0.21421371f, 0.05386984f, 0.03072124f, 0.00215876f, -0.19641206f, 0.00647401f, -0.17403302f, 
    -0.02818160f, 0.08215945f, -0.01824517f, -0.06463321f, -0.06257153f, -0.30770838f, 0.11822992f, 0.06268404f, 
    0.13540275f, -0.11561395f, -0.35567203f, -0.21503273f, -0.06403353f, -0.13007480f, 0.06163139f, -0.18011826f, 
    0.06097115f, -0.09294234f, 0.18044168f, -0.02525666f, 0.10078613f, -0.24312824f, -0.01844385f, -0.00359544f, 
    0.08680414f, -0.00435280f, -0.14411612f, -0.20728184f, -0.13196445f, 0.02560354f, 0.05814204f, -0.13699721f, 
    -0.17724931f, 0.11464520f, -0.13117060f, -0.15202105f, 0.04161315f, 0.02578737f, 0.11540169f, 0.05367597f, 
    -0.46031776f, 0.23836599f, -0.35349992f, -0.02616804f, -0.07821685f, 0.17693636f, -0.20713116f, -0.31746954f, 
    0.04536865f, -0.28279641f, -0.21739770f, 0.03725856f, 0.19438298f, 0.04509272f, -0.26980931f, -1.00259876f, 
    0.22382878f, -0.03558559f, 0.06035994f, -0.88354850f, -0.17064674f, -0.01608972f, -0.14867586f, 0.11204705f, 
    -0.00075761f, 0.02150978f, -0.20718960f, -0.36340016f, 0.01795111f, 0.05408096f, -0.35839888f, 0.19124165f, 
    -0.07049448f, -0.08839104f, 0.17732194f, 0.28009909f, -0.01927311f, 0.18047939f, 0.16147746f, -0.02395758f, 
    -0.00945082f, -0.00287334f, 0.18404219f, 0.18794399f, -0.51098442f, 0.07010768f, 0.09477267f, 0.14286841f, 
    0.04793731f, -0.03824711f, 0.04545582f, 0.02346971f, 0.05984276f, -0.02253986f, -0.05708208f, 0.07459094f, 
    -0.02523419f, -0.05512658f, -0.03507107f, 0.03847006f, -0.17930053f, -0.15121259f, -0.08705790f, -0.13218893f, 
    0.14087796f, 0.15177275f, 0.07222953f, 0.00224728f, 0.02893643f, 0.09935432f, -0.08663455f, 0.07195880f, 
    0.05454985f, -0.33356726f, -0.01357293f, 0.41760078f, -0.09197109f, -0.24793702f, -0.12425840f, -0.46554291f, 
    -0.13754909f, -0.08064365f, -0.10671887f, -0.03947745f, 0.04813537f, 0.12000667f, 0.04335825f, 0.01739796f, 
    0.01647440f, -0.02355636f, 0.06464422f, 0.05982969f, 0.13785814f, -0.06966013f, -0.01083349f, 0.07584304f, 
    -0.10223098f, -0.31652746f, -0.17488016f, 0.23648374f, -0.09835070f, -0.08624151f, -0.02255064f, 0.22167730f, 
    -0.06031635f, 0.10709698f, 0.29466474f, 0.13427217f, -0.07125477f, -0.37383869f, -0.15032642f, -0.08944208f, 
    0.02559761f, -0.18697025f, 0.24232678f, -0.42369503f, -0.44502115f, -0.20392945f, 0.19786550f, -0.02508839f, 
    -0.28247470f, -0.10410096f, -0.00667450f, -0.07715969f, 0.02219889f, 0.01775121f, 0.00252564f, 0.14758845f, 
    -0.32571325f, 0.02210313f, -0.12674461f, -0.10851568f, 0.02293439f, -0.27868548f, -0.13676186f, 0.21901537f, 
    -0.23518784f, 0.26495692f, -0.33702144f, 0.02317101f, 0.03164813f, 0.02703832f, -0.06115250f, -0.33153898f, 
    -0.45175526f, -0.08277161f, 0.03429625f, 0.41643393f, 0.08898612f, -0.04287722f, 0.02977324f, 0.00985642f, 
    0.09080672f, -0.04110818f, 0.01334623f, 0.09534023f, 0.05809054f, 0.09013268f, 0.07844349f, -0.07258366f, 
    0.10300338f, -0.04528342f, 0.08070845f, -0.27057534f, 0.12198921f, -0.00840331f, -0.00742079f, 0.17732066f, 
    -0.06844065f, -0.35466915f, -0.02055461f, -0.19116028f, -0.14208110f, 0.07772753f, 0.09519465f, 0.05314407f, 
    -0.09153104f, -0.05611735f, 0.07325411f, -0.16759333f, -0.00851321f, 0.07515945f, 0.03418154f, 0.18109031f, 
    -0.04814222f, 0.16979532f, 0.13450363f, -0.04132725f, 0.04621002f, -0.17632793f, 0.10687513f, -0.04089613f, 
    0.17952229f, -0.10574270f, -0.28499943f, 0.01416056f, 0.01174773f, -0.69915968f, -0.00073784f, 0.01785981f, 
    0.01742752f, -0.00506858f, 0.14060532f, -0.10905843f, 0.10433451f, -0.04181787f, -0.52482885f, 0.28790146f, 
    -0.03390130f, 0.03245922f, -0.01525541f, 0.05934369f, 0.05181066f, -0.03219590f, 0.00636594f, 0.18458033f, 
    0.36889386f, -0.37287119f, 0.05238822f, 0.01033979f, 0.33240312f, -0.48868421f, -0.59996849f, -0.48891103f, 
    -0.19026226f, 0.01447512f, -0.37667635f, -0.29636365f, 0.20640522f, 0.25408182f, 0.20375954f, -0.39781576f, 
    0.06261299f, -0.48876661f, 0.00607118f, -0.25968599f, 0.02243291f, 0.24343529f, -0.19874701f, -0.05484502f, 
    0.31337276f, 0.03284374f, -0.44233477f, -0.04415382f, -0.28403330f, 0.02425216f, -0.10910798f, -0.86460215f, 
    -0.29079568f, -0.10083427f, -0.18888897f, 0.07743034f, -0.63942361f, 0.16812676f, -0.62131095f, -0.43120617f, 
    0.33319220f, -0.92140573f, 0.21237977f, 0.00459548f, -0.04180095f, 0.33134323f, -0.25883386f, 0.18806347f, 
    -0.12390909f, 0.22604975f, -0.04533957f, -0.03351771f, -0.00358102f, 0.03839416f, 0.03909617f, 0.06963308f, 
    -0.24945544f, 0.07403569f, -0.10535710f, -0.31636217f, -0.20300379f, 0.16221671f, 0.18337324f, 0.06513714f, 
    0.16801298f, 0.03175742f, -0.35674414f, 0.07468053f, -0.02135360f, 0.05828884f, 0.00893384f, -0.25046149f, 
    0.13141224f, -0.11296222f, -0.19468620f, 0.15912746f, -0.04207143f, -0.23932171f, -0.40379804f, -0.69672728f, 
    0.02318513f, 0.01316131f, -0.02531778f, 0.18973400f, -0.23193344f, 0.00925178f, -0.82338381f, -0.18960650f, 
    -0.76867890f, 0.03468430f, -0.16052049f, -0.40110344f, 0.00829692f, 0.20915683f, -0.05991604f, -0.24494284f, 
    -0.08742006f, 0.02826466f, -0.09042852f, -0.87209123f, 0.04562085f, 0.01261105f, -0.58180296f, 0.02828269f, 
    -0.22954135f, 0.19758596f, -0.80424356f, -0.16954960f, 0.22233325f, 0.00552911f, 0.04113400f, -0.02750961f, 
    -0.09817419f, 0.32331046f, -0.26395649f, -0.05084007f, -0.15665841f, 0.22456674f, 0.17668854f, -0.06248397f, 
    -0.11801962f, 0.03438477f, 0.05114621f, -0.74574792f, 0.06895666f, -0.18487942f, 0.04795502f, -0.08815701f, 
    -0.73108834f, 0.12771448f, -0.57895654f, -0.00419177f, -0.39481193f, 0.22770992f, 0.45788959f, 0.08735262f, 
    -0.32806480f, 0.09126594f, -0.17398489f, 0.15266311f, -0.05205548f, -0.01515950f, -0.00756172f, 0.31132898f, 
    0.01832769f, 0.47076350f, 0.05058924f, -0.15876868f, -0.08756701f, -0.45914948f, -0.16056447f, -0.03732844f, 
    -0.35100529f, -0.34224886f, 0.33587500f, -0.09108395f, 0.11386304f, -0.48628983f, -0.16289724f, -0.12492303f, 
    -0.10813547f, 0.08385994f, 0.46594015f, -0.00443716f, 0.04846547f, -0.03281582f, -0.05636816f, -0.61736214f, 
    -0.05779755f, -0.33485684f, -0.14324443f, 0.05710116f, -0.10823448f, 0.01452381f, -0.58720767f, -0.50037408f, 
    0.03310067f, -0.45839125f, -0.20138316f, 0.03451174f, -0.00168171f, -0.00009507f, -0.20025288f, 0.15833727f, 
    0.28049403f, -0.04378885f, 0.07537644f, -0.08517620f, 0.09515054f, 0.05321008f, -0.41090176f, 0.11765884f, 
    -0.00395561f, -0.06578285f, -0.54761815f, -0.05102587f, 0.04892799f, -0.00088149f, 0.13212882f, 0.12213625f, 
    0.06285107f, 0.06063537f, -0.28063458f, 0.22005224f, -0.01221242f, -0.12076398f, 0.05635208f, 0.24725126f, 
    -0.04803813f, 0.02887411f, -0.07762239f, -0.30576116f, 0.13212319f, 0.05409052f, -0.36151010f, 0.11525489f, 
    -0.34022942f, -0.08644308f, -0.02027956f, -0.03172258f, 0.01097591f, -0.09773408f, -0.03399803f, -0.00039653f, 
    0.07868414f, -0.00224750f, 0.10005244f, -0.36706620f, -0.13725971f, 0.02367554f, -0.24101980f, 0.11256873f, 
    0.22682703f, -0.36742508f, 0.09573919f, 0.05012597f, -0.17385444f, -0.02521948f, 0.02737132f, 0.07726957f, 
    0.01217106f, -0.39274675f, 0.21190022f, 0.05384434f, -0.24077182f, -0.11766538f, -0.12392211f, -0.21123557f, 
    0.03375345f, -0.06552510f, -0.23897201f, -0.56342125f, 0.07287523f, -0.00960270f, 0.05688476f, -0.01181227f, 
    -0.08595178f, -0.27338138f, 0.10629952f, 0.01727481f, -0.26152188f, 0.05175335f, -0.03303915f, 0.22272211f, 
    0.30966052f, 0.12564890f, -0.18087274f, -0.24093030f, 0.02809898f, 0.20050119f, -0.25838950f, 0.26197302f, 
    -0.02242367f, -0.08461426f, -0.32046172f, -0.09616226f, -0.33667925f, 0.02351175f, -0.26727858f, -0.06316967f, 
    -0.14799051f, -0.14635591f, 0.06989021f, -0.07115278f, -0.10901976f, -0.14145702f, -0.17117181f, 0.16686116f, 
    -0.13202345f, 0.22755779f, -0.28346238f, 0.03055564f, -0.22977865f, -0.11304209f, 0.15811589f, -0.32030642f, 
    -0.04545450f, -0.64832646f, 0.23587152f, 0.00841691f, -0.21353370f, 0.01372873f, -0.58678663f, -0.19383755f, 
    -0.05047764f, 0.02404435f, -0.18003006f, -0.03924128f, 0.12732126f, -0.08467023f, 0.11562633f, 0.01998191f, 
    -0.08863413f, 0.05634592f, -0.01040232f, 0.44688687f, -0.10970750f, 0.08389733f, 0.27114284f, 0.03051547f, 
    0.04396649f, 0.07961620f, 0.35721865f, 0.12305395f, -0.00298875f, -0.01815660f, 0.10386427f, 0.07846401f, 
    -0.14854744f, 0.04554877f, -0.35899597f, -0.19452690f, 0.22489232f, -0.51490074f, -0.46774468f, 0.15778974f, 
    0.08066069f, 0.26916924f, -0.72821462f, -0.76562285f, -0.05063821f, -0.43169001f, 0.29120219f, -0.31994998f, 
    -0.78040409f, -0.01204310f, -0.10297686f, 0.03127385f, 0.00873350f, 0.20233148f, -0.01029687f, 0.07492046f, 
    0.07150508f, 0.06774910f, 0.09605214f, -0.12088345f, 0.17219228f, 0.15215226f, -0.29292461f, -0.03712317f, 
    -0.06397741f, -0.04224963f, 0.13535531f, 0.17747268f, 0.07777449f, -0.05444316f, 0.05595680f, -0.09719028f, 
    -0.00862764f, -0.07856876f, -0.06159456f, 0.19222780f, -0.30470023f, 0.17903222f, 0.12936343f, 0.34872243f, 
    -0.20001155f, 0.15034392f, -0.63277125f, 0.35871416f, -0.39836767f, 0.05475809f, -0.04573871f, -0.15089931f, 
    0.32429048f, -0.09229382f, 0.14797179f, -0.08485068f, 0.07766937f, 0.25750530f, 0.00940518f, -0.17465922f, 
    -0.23202327f, -0.31900212f, -0.26089051f, -0.03923120f, 0.02611201f, 0.11962286f, 0.03797616f, -0.36552227f, 
    -0.05377202f, -0.29931530f, -0.03532972f, 0.05233148f, -0.00414283f, -0.19866370f, 0.14807835f, 0.05247561f, 
    0.13834009f, 0.19340335f, -0.42332119f, -0.32638842f, -0.05626173f, 0.06614315f, 0.02885056f, -0.38696176f, 
    -0.18146926f, 0.21452412f, -0.04838131f, -0.35455832f, 0.07222223f, 0.13501547f, -0.01195213f, -0.49834090f, 
    -0.09822193f, 0.01164267f, -0.32677609f, 0.00122888f, -0.02894171f, -0.39978048f, -0.03467518f, -0.37388310f, 
    -0.25915560f, -0.12001598f, -0.06635245f, -0.03990430f, -0.26606506f, -0.04767894f, -0.05851869f, 0.19830891f, 
    0.11744868f, -0.02143091f, 0.10879389f, 0.06109222f, 0.18493335f, 0.03352100f, -0.38194090f, 0.08503118f, 
    -0.24720784f, -0.34075984f, -0.36334381f, 0.16863492f, 0.27503434f, 0.00541495f, -0.18540335f, -0.19094175f, 
    -0.21661198f, -0.04934357f, -0.27291811f, 0.24364060f, -0.18819894f, -0.32211965f, 0.12708806f, -0.39773768f, 
    0.07849757f, -0.21346948f, 0.28911540f, -0.14106032f, -0.19929273f, 0.08133368f, -0.47433153f, 0.12670407f, 
    0.00995239f, 0.00587911f, -0.41761631f, 0.10179240f, 0.00977451f, 0.08480711f, 0.01190411f, -0.08036192f, 
    0.04344300f, 0.12522332f, -0.20508656f, 0.11576404f, -0.16078326f, 0.11336996f, -0.07137159f, 0.05723264f, 
    -0.11080257f, 0.08822660f, -0.55276352f, -0.17879090f, 0.20621674f, 0.08362812f, -0.04778465f, 0.08899076f, 
    -0.07699634f, 0.04123470f, -0.18285543f, -0.08606765f, 0.11574746f, 0.19451103f, 0.12816769f, -0.02675731f, 
    -0.37494746f, -0.02111487f, 0.37302688f, -0.26088437f, 0.10028817f, 0.12992261f, -0.00045737f, -0.30387443f, 
    -0.16198146f, -0.01462991f, 0.15781353f, -0.07467718f, -0.01145953f, -0.32662395f, -0.23257062f, 0.07491553f, 
    0.00793743f, 0.02158896f, 0.00974554f, -0.18162541f, -0.33686882f, -0.12200028f, -0.54591340f, -0.04989364f, 
    -0.06217248f, 0.02562705f, 0.34599817f, -0.06735531f, -0.08789553f, -0.42647552f, -0.06607373f, 0.06187664f, 
    -0.34513363f, 0.34948269f, 0.35446247f, 0.28472888f, 0.16115302f, 0.19891798f, -0.53566045f, -0.08892732f, 
    -0.41568485f, 0.14247234f, -0.35971493f, -0.09324203f, 0.09430671f, -0.15849397f, -0.40651801f, 0.41235110f, 
    0.07232276f, -0.28531259f, -0.30635273f, -0.02162892f, -0.12211053f, 0.11586939f, 0.44402537f, 0.08570490f, 
    -0.26811025f, 0.09070679f, -0.02555842f, -0.08017892f, -0.14799199f, -0.01087147f, 0.15497525f, -0.38487595f, 
    -0.28578016f, -0.01856318f, 0.37155542f, -0.09494842f, -0.30141962f, -0.06208356f, -0.02026171f, -0.39395469f, 
    -0.64266080f, 0.18083224f, -0.04057878f, 0.19206537f, 0.05947975f, -0.03273318f, -0.32685694f, 0.02516227f, 
    -0.52589959f, -0.06451543f, -0.13006787f, -0.15128367f, 0.03817466f, 0.42253765f, -0.17057100f, 0.33121812f, 
    0.01370343f, -0.17041776f, -0.21144268f, -0.37505022f, -0.08502574f, -0.47437921f, 0.06313732f, 0.18335576f, 
    -0.08437829f, -0.02719240f, -0.07947103f, 0.33552441f, -0.26230517f, 0.02676093f, -0.06374997f, -0.03936334f, 
    -0.04536764f, -0.23730382f, 0.01470733f, -0.12551102f, 0.22599679f, 0.09559964f, -0.16284882f, -0.03581643f, 
    0.19990793f, -0.30958158f, -0.51350552f, 0.12709628f, 0.08202104f, -0.43463543f, -0.06405008f, -0.32265624f, 
    -0.06967326f, 0.12573294f, 0.03051700f, -0.16718312f, -0.10503951f, 0.02421863f, -0.09720318f, 0.13742268f, 
    -0.05878991f, 0.01868317f, 0.08733744f, 0.06355990f, -0.07249114f, -0.13169771f, 0.03512120f, -0.37033758f, 
    -0.30754155f, 0.05207103f, -0.27226755f, -0.05024693f, -0.00755720f, -0.20547681f, 0.06347914f, -0.13858248f, 
    0.22173965f, 0.00663285f, 0.19961084f, 0.08657173f, -0.11131998f, 0.03493896f, 0.11566222f, -0.23838092f, 
    -0.03797384f, -0.07130444f, 0.26974466f, -0.77926636f, 0.31380042f, 0.21554838f, -0.00842041f, -0.06120388f, 
    -0.13384552f, 0.22174241f, -0.02060819f, 0.25078622f, -0.47085807f, -0.30948755f, -0.04663647f, 0.14783324f, 
    0.22341239f, -0.06081053f, -0.05086374f, -0.02055518f, -0.13760895f, -0.00610881f, -0.08559152f, 0.06329729f, 
    0.32100254f, 0.03097455f, 0.30251303f, -0.00002459f, -0.08991281f, 0.27922273f, -0.28346023f, -0.53407347f, 
    -0.17403436f, 0.06028238f, -0.23703107f, -0.11439785f, 0.22372115f, 0.06451663f, 0.12429105f, -0.55967510f, 
    -0.00576466f, 0.06257407f, -0.20305602f, -0.22341344f, -0.06495380f, 0.05068980f, -0.12912513f, 0.01009851f, 
    -0.08417460f, 0.34874555f, -0.66571659f, 0.00664596f, -0.09454487f, 0.00503895f, -0.20292948f, -0.08738081f, 
    -0.09384293f, 0.05062674f, -0.29433730f, -0.10576302f, 0.09668246f, 0.45133072f, -0.21342629f, 0.15939790f, 
    0.00037800f, 0.14341789f, 0.07430320f, 0.23489101f, 0.05803895f, -0.01801946f, -0.12765585f, 0.04487272f, 
    -0.04548480f, -0.05848512f, -0.10175367f, -0.08210044f, 0.11228279f, 0.09194560f, -0.07196848f, 0.08793539f, 
    0.01003041f, 0.06885277f, 0.06217798f, -0.46439794f, -0.15622464f, -0.09410357f, -0.53444320f, -0.30627203f, 
    -0.54024851f, -0.08662694f, -0.06673286f, -0.36428294f, 0.02263801f, 0.18326931f, 0.03920751f, -0.10162633f, 
    0.05965593f, -0.02776688f, -0.42853618f, -0.16499588f, -0.53229350f, 0.00366030f, 0.03493197f, -0.43383342f, 
    0.02530074f, 0.16806281f, -0.36789346f, -0.32572773f, 0.11622875f, -0.21131071f, -0.03009140f, -0.33113661f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04795773f, 0.08312468f, 0.06924980f, -0.02986527f, -0.06137151f, -0.10947986f, 0.02924857f, -0.08145238f, 
    0.04503951f, 0.12273715f, -0.04832246f, -0.05681506f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
