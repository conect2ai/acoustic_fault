#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.44600371f, -0.36701566f, -0.29609165f, -0.26703566f, 0.55781585f, -0.07461385f, -0.14126715f, -0.30886632f, 
    0.14035648f, -0.34302485f, 0.30481157f, 0.11127372f, 0.18038225f, -0.10810212f, -0.31277508f, 0.32302946f, 
    0.01165279f, -0.15606160f, -0.26920667f, -0.12828282f, 0.04310147f, -0.21637501f, 0.02657710f, -0.32694086f, 
    -0.26558599f, 0.33927107f, 0.05879471f, 0.31852442f, 0.04337161f, -0.63237476f, 0.22445406f, -0.26183727f, 
    -0.36717695f, 0.04343574f, -0.09810431f, -0.03043153f, -0.31991956f, -0.14538901f, -0.11735447f, 0.27870443f, 
    -0.25900394f, 0.01193830f, 0.32784361f, 0.01453751f, -0.02287568f, -0.10795986f, -0.26963961f, -0.19546448f, 
    -0.30153811f, -0.33237708f, -0.54294777f, -0.35059702f, 0.09866320f, -0.48022565f, -0.35461882f, 0.14597522f, 
    0.28500858f, -0.34679720f, 0.24151331f, 0.34511471f, 0.00502348f, -0.02567885f, 0.02998070f, -0.00903694f, 
    -0.04951474f, -0.11016694f, -0.01746223f, -0.37943840f, -0.28178093f, -0.01693963f, -0.10839457f, 0.06011683f, 
    0.10621860f, 0.25177902f, 0.21839821f, -0.25283483f, 0.16359015f, 0.46823150f, -0.23479272f, 0.15980464f, 
    -0.00494344f, -0.28465012f, 0.20310667f, -0.26972443f, 0.00403593f, -0.27583602f, -0.13522501f, 0.14884342f, 
    -0.32529545f, -0.03646541f, 0.20665134f, 0.25257894f, 0.06875375f, 0.16337880f, -0.20533147f, -0.07673492f, 
    0.06693802f, -0.19075596f, 0.05689719f, -0.05708079f, -0.63523453f, -0.76020712f, 0.19536705f, 0.39528367f, 
    0.61472666f, 0.47729856f, 0.32647291f, 0.00473783f, -0.37411824f, 0.04703274f, -0.18855846f, -0.17255625f, 
    0.29625714f, -0.34780008f, -0.25756976f, -0.20817909f, 0.02379716f, -0.10542525f, 0.06944953f, 0.18737586f, 
    -0.11997710f, -0.11419953f, -0.01572183f, 0.14773974f, 0.07140895f, -0.09071504f, 0.10571758f, 0.33282930f, 
    0.67156869f, 0.21599141f, -0.29849786f, -0.38861519f, -0.43871716f, -0.33742845f, -0.08605769f, -0.03121920f, 
    -0.06082043f, -0.02216066f, 0.17963706f, -0.11701713f, -0.13317955f, -0.02468748f, 0.03576437f, 0.00780556f, 
    -0.11746775f, 0.06632094f, -0.00633909f, 0.03830568f, 0.09255322f, -0.08045078f, 1.09633088f, -0.87901491f, 
    -0.77248758f, -0.23286824f, -0.74008197f, 0.85965437f, 0.35894483f, 0.40323392f, -0.06411897f, 0.29820141f, 
    -0.19367160f, 0.42287418f, -0.22845004f, -0.20324701f, -0.30777863f, -0.09770733f, 0.22627184f, 0.29593727f, 
    -0.22045381f, -0.10722252f, -0.00043338f, -0.13386980f, -0.02036510f, -0.01191072f, 0.01978966f, 0.05853584f, 
    -0.93825251f, -0.20097229f, 0.25174725f, 0.81603301f, 0.04594989f, -0.09982912f, 0.47206977f, -0.19109750f, 
    -0.29461899f, -0.18477352f, -0.37015760f, 0.19381188f, -0.26092401f, 0.17735311f, -0.10827612f, 0.01865061f, 
    0.00566353f, 0.21558256f, 0.23694184f, -0.19044214f, -0.22459982f, -0.16483442f, 0.11460137f, 0.07088973f, 
    -0.31311849f, 0.18997502f, 0.24810264f, 0.16533883f, 0.08202045f, -0.38898617f, 0.05512890f, 0.19999102f, 
    -0.28881124f, -0.01344621f, 0.02905626f, 0.24511975f, -0.16093065f, 0.16907227f, -0.13602819f, 0.06180849f, 
    0.09693779f, -0.21169631f, -0.27657279f, -0.18142793f, -0.00948063f, 0.11923894f, 0.13234471f, 0.09138720f, 
    0.16775972f, 0.22013059f, 0.78753698f, 0.53307080f, -0.28171185f, -0.57198352f, -0.23669168f, -0.14112215f, 
    -0.07146128f, -0.15722494f, -0.24138813f, -0.00970241f, 0.30818120f, -0.16898756f, 0.30513352f, 0.17629418f, 
    -0.13863921f, 0.03947122f, 0.06142884f, 0.03862016f, -0.27678010f, 0.04588830f, -0.00102401f, -0.04501884f, 
    0.12010814f, -0.32865608f, -0.10710645f, -0.53233951f, -0.07554916f, -0.04132944f, -0.06741715f, -0.27856827f, 
    -0.36577886f, 0.27049598f, 0.43955502f, -0.43119273f, 0.41708550f, -0.02544647f, -0.06855451f, -0.23510061f, 
    -0.16372398f, 0.02323046f, 0.12810884f, -0.03820347f, -0.37698978f, -0.20991792f, -0.23801202f, 0.02300499f, 
    0.16064981f, 0.02233344f, 0.35034636f, 0.40747964f, 0.07215239f, 0.01253042f, -0.01476810f, 0.13054743f, 
    -0.33081833f, 0.21891657f, 0.06714085f, 0.11441722f, -0.36341164f, -0.32067874f, -0.13341132f, -0.12163909f, 
    0.40733331f, -0.10832957f, 0.42557767f, -0.12775402f, 0.07066496f, -0.00437624f, -0.22654095f, 0.05601084f, 
    -0.12224098f, -0.09052601f, -0.25166050f, -0.11694842f, -0.27959421f, 0.00192161f, -0.13440479f, -0.48668522f, 
    0.32188615f, -0.07099112f, -0.21580428f, 0.16216265f, -0.25124660f, -0.24067426f, -0.09778470f, -0.27724117f, 
    0.22575456f, -0.37212268f, 0.46785596f, -0.02258065f, -0.00674273f, -0.43298030f, -0.28390783f, -0.04253348f, 
    -0.14766245f, -0.21671867f, -0.17722890f, -0.19986489f, -0.23328345f, -0.10997568f, 0.04577582f, 0.13134979f, 
    -0.04445025f, 0.27570516f, 0.17363216f, 0.45402929f, -0.17784478f, -0.20958975f, -0.33801383f, -0.18779454f, 
    -0.04277471f, 0.13423309f, -0.36824527f, 0.15161382f, -0.04033123f, -0.17846890f, 0.30566549f, 0.16585524f, 
    0.07082278f, 0.00509203f, -0.06411557f, 0.10324185f, -0.14336370f, -0.28878742f, 0.32800376f, 0.42677310f, 
    0.30597931f, 0.16221085f, -0.46289265f, -0.02236210f, -0.67005193f, -0.40453154f, 0.06858385f, 0.11084186f, 
    0.07595760f, -0.16465184f, -0.10879091f, 0.01665369f, -0.18389583f, 0.11415651f, 0.32509962f, 0.15045865f, 
    -0.06448992f, -0.00219583f, -0.01830218f, -0.44068781f, -0.22598979f, 0.07222805f, 0.09946372f, -0.40943682f, 
    -0.17360781f, -0.44677758f, -0.00611425f, 0.13580434f, 0.31362414f, 0.31660116f, 0.27801117f, 0.22925131f, 
    -0.12090228f, 0.13882008f, 0.06720021f, -0.11002848f, -0.00719248f, -0.12999821f, -0.19102192f, -0.28580898f, 
    -0.24641922f, 0.34343582f, 0.35126585f, 0.25633073f, -0.17778577f, 0.13621709f, -0.17662808f, -0.02485550f, 
    -0.27619511f, -0.26605529f, -0.40119374f, -0.32880387f, -0.56620276f, -0.12704726f, 0.16877177f, 0.22963585f, 
    0.24210501f, -0.02098349f, -0.16725394f, -0.15184323f, 0.05953899f, 0.17022766f, -0.15898100f, 0.23686695f, 
    0.35855320f, -0.13599117f, 0.16840194f, 0.22141863f, 0.08117804f, 0.05873434f, -0.01209863f, -0.20432176f, 
    -0.36946428f, -0.15519245f, 0.06651380f, 0.21106558f, -0.04134409f, -0.33734739f, -0.55228490f, -0.14400028f, 
    -0.46316037f, -0.13004510f, -0.03212357f, 0.54368573f, -0.14467552f, 0.13109703f, 0.02893042f, -0.23223208f, 
    0.02228490f, -0.30882013f, 0.25987446f, -0.00004205f, -0.37523678f, 0.11545046f, -0.24428861f, -0.06267723f, 
    0.25813189f, 0.21661125f, -0.47948232f, 0.11766499f, 0.37930253f, -0.52826625f, -0.25585696f, -0.20500770f, 
    -0.40057918f, -0.05066694f, 0.22170122f, 0.53954375f, 0.01399141f, -0.04906406f, -0.12416542f, 0.24778345f, 
    -0.01691172f, 0.32032850f, 0.02844887f, 0.16880037f, -0.11392922f, -0.26872307f, -0.01784595f, -0.11622833f, 
    -0.03043777f, -0.24766663f, -0.26064518f, 0.04932014f, 0.32490382f, -0.05644821f, -0.00747052f, -0.23168392f, 
    -0.29678524f, 0.10338657f, 0.08606865f, 0.21122511f, 0.01129543f, 0.09416964f, -0.43862277f, 0.60512733f, 
    -0.58117610f, 0.28531483f, -0.04218226f, 0.23552385f, 0.03008092f, -0.18016544f, -0.11017196f, 0.14595841f, 
    0.17331608f, -0.37298626f, -0.04692408f, 0.13180082f, 0.38218874f, 0.64440286f, 0.64486146f, -0.66603988f, 
    -0.10734276f, -0.44491211f, 0.05090886f, -0.08232877f, -0.33930892f, 0.16113128f, 0.16490108f, -0.16459616f, 
    0.33751920f, 0.09220755f, -0.14909287f, 0.16095449f, -0.19559243f, -0.17501096f, 0.05420564f, 0.16054563f, 
    -0.13547270f, 0.17831495f, 0.00409464f, -0.13668919f, 0.12107032f, -0.57747352f, -0.28030625f, 0.32316932f, 
    -0.62825114f, -0.44354728f, 0.24488424f, 0.24738061f, -0.12899406f, -0.14607371f, 0.36309972f, -0.19765450f, 
    -0.25739497f, -0.19507135f, -0.26648000f, -0.09039950f, 0.07693284f, 0.09333529f, -0.19439894f, -0.22889666f, 
    0.04923512f, -0.06044731f, -0.16027908f, 0.03320104f, -0.05415606f, -0.09128328f, 0.19395584f, 0.11735305f, 
    0.31905401f, -0.22346279f, -0.32768574f, 0.36505145f, -0.08461619f, -0.24069116f, -0.21002634f, 0.14201775f, 
    0.24306589f, -0.10807429f, 0.18085991f, 0.09690847f, -0.32223922f, 0.18666425f, 0.00784422f, 0.22494954f, 
    -0.36558348f, 0.03950572f, -0.02280746f, -0.19508670f, 0.21724986f, 0.00190831f, 0.10035963f, -0.66578412f, 
    -0.26933175f, -0.36082596f, -0.71921825f, -0.52412891f, 0.74014521f, -0.03952942f, 0.08699300f, 0.09344883f, 
    0.27231607f, 0.17691062f, 0.33576402f, -0.08816791f, 0.45894921f, -0.33383268f, -0.21288909f, 0.03693061f, 
    0.07763471f, 0.12796068f, -0.14171781f, -0.03702780f, -0.05818407f, 0.30674520f, 0.04543497f, 0.13938467f, 
    0.06001781f, -0.06689769f, -0.11278755f, -0.16820621f, 0.17238483f, 0.15698531f, 0.02667535f, -0.19635303f, 
    -0.35903093f, 0.21181113f, 0.16126738f, 0.07602574f, -0.13645165f, 0.17749284f, -0.14741427f, 0.12075017f, 
    -0.00995968f, -0.21420519f, -0.00697584f, 0.02973306f, -0.10315149f, 0.14837362f, -0.05703007f, 0.11548080f, 
    0.12030952f, -0.62170345f, -0.42784312f, -0.00545638f, 0.14397381f, 0.17047657f, -0.27412540f, 0.17548311f, 
    -0.17478213f, -0.10143443f, 0.10434729f, -0.24171540f, -0.12001771f, -0.09257192f, -0.20019540f, -0.07599344f, 
    -0.13109496f, -0.07997114f, -0.31983581f, -0.04509355f, -0.08332229f, 0.20672143f, 0.24924742f, -0.15965226f, 
    -0.17281386f, 0.22787824f, -0.00341608f, 0.36105880f, 0.08460083f, 0.03176804f, -0.01328664f, 0.14472815f, 
    0.14933941f, 0.11149837f, 0.08510023f, -0.25711790f, -0.22894685f, -0.08477747f, -0.00292486f, -0.25995308f, 
    -0.00225267f, -0.00187376f, -0.07654732f, 0.14353102f, 0.00837931f, -0.10071583f, -0.12885709f, -0.11204471f, 
    -0.29074854f, -0.22503644f, -0.38752079f, 0.57591951f, -0.52059913f, -0.25290173f, 0.01730063f, -0.18156262f, 
    0.11367971f, 0.20610157f, -0.06367154f, -0.07913126f, 0.23851533f, -0.13218020f, -0.04684210f, 0.12137866f, 
    -0.24135603f, 0.28001112f, -0.34959722f, 0.25366870f, -0.28955939f, -0.09673262f, -0.08926876f, 0.15421081f, 
    -0.06819613f, -0.29768375f, 0.20550470f, 0.42591286f, -1.18374753f, 0.17929150f, -0.07739530f, 0.43620569f, 
    0.42071468f, -0.54698712f, -0.15445206f, 0.10271087f, 0.37351269f, 0.07654257f, 0.09028903f, 0.08742967f, 
    0.04132593f, 0.05410442f, 0.24345088f, 0.15742564f, -0.20163386f, 0.23727688f, -0.10044900f, -0.27484229f, 
    -0.12264860f, -0.28106689f, 0.34357119f, -0.10458396f, -0.09033973f, -0.26391289f, 0.05200845f, 0.28514782f, 
    -0.17831574f, -0.47048694f, -0.06002453f, 0.27763155f, 0.03598159f, 0.03025900f, 0.13222726f, -0.06236224f, 
    -0.08515416f, -0.32038018f, 0.54170513f, -0.26129088f, -0.38138729f, -0.20178862f, 0.23723036f, 0.25990662f, 
    -0.16628550f, 0.16057190f, 0.02425190f, 0.20442256f, -0.38394490f, 0.01151237f, 0.16299842f, -0.16714662f, 
    -0.07763065f, 0.17476888f, -0.20800090f, 0.38485953f, -0.12918201f, 0.03971229f, 0.02333169f, 0.12665252f, 
    0.04156490f, 0.06102502f, -0.22582239f, -0.35687172f, 0.19353770f, -0.39407948f, 0.13907000f, -0.08241601f, 
    0.16522978f, -0.00833860f, 0.40503529f, 0.13939506f, -0.01336314f, -0.09163038f, -0.05348420f, -0.10479620f, 
    0.09801231f, -0.29580507f, -0.16108407f, -0.09790104f, -0.08809661f, 0.04380745f, 0.17282893f, -0.33721042f, 
    -0.06095568f, -0.18027052f, 0.00304870f, -0.10852082f, 0.10588745f, -0.10299204f, 0.05324096f, -0.32185483f, 
    0.21256784f, -0.06236988f, -0.39085519f, 0.09865267f, -0.05934493f, -0.14312679f, 0.19435889f, 0.29743996f, 
    0.14639984f, 0.32097834f, 0.01083032f, -0.06281443f, -0.35960811f, 0.38076591f, -0.29724151f, 0.29986200f, 
    -0.34761351f, 0.03659945f, -0.06562006f, -0.35091394f, 0.05437590f, 0.22140783f, -0.00479602f, -0.02217964f, 
    -0.29765353f, 0.08825134f, 0.34540701f, 0.07624426f, -0.03665943f, 0.32990614f, -0.19986017f, -0.15333647f, 
    -0.27644852f, 0.26244316f, 0.12906046f, 0.43449619f, -0.25482503f, -0.18609820f, 0.08016752f, -0.39511707f, 
    -0.17693721f, 0.18012331f, -0.03884904f, -0.00665456f, 0.05263767f, -0.15915571f, 0.25163215f, -0.19980650f, 
    0.15085046f, 0.08693600f, -0.23051986f, -0.23372288f, -0.09000120f, -0.01374626f, -0.16440314f, -0.09021218f, 
    -0.38416642f, -0.42648077f, -0.42246762f, -0.43272117f, -0.23588370f, -0.20192294f, -0.00979393f, 0.00146077f, 
    -0.19322355f, -0.47110665f, -0.55851793f, -0.14934361f, 0.09557635f, -0.10298343f, -0.08651101f, -0.35004801f, 
    -0.34284526f, 0.08942960f, -0.10992994f, -0.13419378f, 0.15132210f, -0.10213788f, -0.24458936f, 0.09151445f, 
    0.07020315f, -0.16335763f, -0.24808858f, -0.52656776f, -0.27430573f, -0.00449858f, -0.03641756f, -0.14767827f, 
    0.40884569f, -0.26293677f, -0.24352086f, -0.28152812f, -0.34378460f, -0.18021145f, 0.36974731f, -0.24703468f, 
    -0.23810634f, -0.28326586f, 0.02496106f, -0.27260953f, 0.00678117f, 0.10529799f, -0.23074268f, -0.17022598f, 
    0.17037907f, 0.11102473f, -0.23455691f, 0.09498338f, -0.53091508f, -0.47232535f, -0.44794390f, 0.51136923f, 
    0.35412082f, 0.46633825f, 0.10247866f, -0.10239801f, 0.02558139f, 0.35464153f, 0.10207743f, 0.00861357f, 
    -0.00706130f, -0.26798549f, 0.13880475f, -0.19173850f, -0.10279983f, 0.35484314f, -0.15010828f, 0.06445263f, 
    -0.20958962f, -0.10232563f, 0.12330494f, -0.08674841f, 0.17135943f, -0.17525469f, -0.54182738f, 0.13972092f, 
    0.00142585f, 0.32280886f, -0.22561401f, -0.07988808f, -0.21555702f, -0.08996218f, -0.18801051f, 0.12056567f, 
    -0.14973822f, -0.22913769f, 0.12920591f, 0.10544191f, -0.13489789f, 0.02350769f, -0.07247384f, 0.05138598f, 
    0.17733090f, 0.15500446f, -0.21410628f, 0.09267689f, -0.03045957f, 0.05340981f, -0.35297596f, 0.17035849f, 
    0.36861032f, -0.32685399f, -0.51836854f, 0.10212970f, -0.03317996f, -0.20362194f, -0.18738058f, -0.07635844f, 
    0.16279350f, 0.11229990f, -0.02878841f, 0.31207731f, 0.09582429f, -0.09420863f, -0.05255593f, 0.02352824f, 
    -0.19172132f, 0.00125369f, -0.19498166f, 0.47695792f, 0.14996392f, -0.13916358f, 0.02178794f, 0.59293675f, 
    -0.20551819f, -0.16676368f, -0.10816300f, -0.09527179f, -0.40821111f, -0.32511356f, -0.59279794f, -0.42043641f, 
    -0.58023661f, -0.00747680f, -0.19566827f, -0.00895525f, 0.51792532f, 0.10417277f, -0.12776814f, -0.06706655f, 
    0.03345635f, 0.06069797f, 0.02523407f, -0.37804729f, 0.07917546f, 0.03074809f, 0.09558764f, 0.05783843f, 
    0.82872099f, -0.29051340f, -0.19525202f, 0.34259850f, -0.59781879f, 0.12188020f, 0.10512136f, 0.02159429f, 
    -0.21421622f, -0.14043882f, 0.55828267f, 0.07726151f, -0.30748180f, -0.32156450f, 0.35234058f, 0.15137689f, 
    -0.18010822f, 0.36194676f, -0.15254147f, -0.36001134f, -0.01423273f, 0.11381130f, 0.06602622f, 0.08687043f, 
    -0.17427292f, 0.05168453f, 0.96400648f, 0.03816371f, -0.41715652f, -0.28099808f, -0.07199394f, -0.22210337f, 
    0.09101983f, 0.09355552f, -0.39847785f, -0.12009172f, 0.18155871f, -0.06239179f, 0.12201361f, -0.01902644f, 
    0.15862159f, -0.14541647f, -0.21178667f, 0.30679038f, -0.23156837f, 0.11724634f, 0.00863503f, -0.01565378f, 
    -0.08428689f, 0.26767254f, -0.30289400f, -0.20310184f, 0.20992185f, 0.51926380f, 0.03100111f, 0.65431368f, 
    0.01054450f, -0.37941262f, -0.41964173f, 0.12113698f, 0.16887979f, -0.17302783f, 0.04845402f, 0.34060043f, 
    -0.26078069f, -0.12203703f, 0.24456003f, 0.09423207f, -0.07460442f, -0.28870773f, -0.14233401f, 0.27447200f, 
    -0.12313008f, 0.09403485f, 0.02006534f, -0.29079485f, -0.51774234f, -0.04918772f, 0.19553487f, 0.57792550f, 
    0.07722199f, -0.53344673f, -0.18077655f, 0.51739502f, 0.53023118f, -0.18578841f, 0.23798202f, -0.25965899f, 
    -0.23318084f, 0.44792056f, -0.25713688f, -0.15063156f, 0.24639677f, -0.04897923f, -0.18068042f, -0.13939306f, 
    0.00879797f, 0.09363528f, 0.13013154f, 0.17445390f, -0.37124947f, 0.53518540f, -0.44394439f, -0.47963771f, 
    0.08192216f, 0.05903150f, 0.00107291f, 0.47765410f, -0.38201275f, -0.38898245f, 0.10809597f, 0.22682437f, 
    0.37846690f, -0.26823917f, -0.30128002f, -0.18551463f, -0.08896213f, -0.23234171f, -0.14650883f, -0.17221269f, 
    0.21084121f, 0.17670806f, -0.12522259f, 0.05940467f, 0.33013430f, 0.49218342f, -0.37366486f, -0.17079461f, 
    0.59456122f, -0.13695642f, 0.03818435f, 0.23697053f, 0.36724338f, -0.27653134f, -0.12337936f, -0.51798981f, 
    -0.20353484f, 0.24976429f, -0.35524634f, 0.06769770f, 0.06569334f, 0.34494647f, -0.02096144f, 0.14603265f, 
    0.22751814f, -0.09205446f, -0.27787861f, 0.14142336f, -0.27912787f, -0.20238236f, -0.48195854f, -0.28337336f, 
    -0.27219078f, -0.03491487f, 0.14576873f, 0.27143246f, -0.03549448f, 0.32623282f, -0.40467021f, 0.38990188f, 
    0.33963364f, 0.04827551f, -0.23111913f, -0.02528718f, 0.19874915f, -0.04204188f, -0.07091749f, -0.01864882f, 
    -0.05095593f, -0.12136333f, 0.11573768f, 0.41487801f, 0.09857466f, 0.17623045f, -0.01799589f, 0.43684882f, 
    -0.27133426f, -0.20871630f, 0.29443717f, 0.05654416f, 0.18161614f, -0.29327142f, -0.13744003f, 0.13769867f, 
    0.26094222f, 0.42609707f, -0.37905139f, -0.08155672f, 0.04464871f, 0.33213168f, -0.14359830f, 0.17574081f, 
    -0.06618239f, -0.05850957f, -0.06856959f, -0.05638091f, 0.03095631f, 0.34682074f, -0.09287786f, -0.13476934f, 
    -0.37912530f, -0.18322740f, 0.41954175f, 0.29194945f, -0.18906432f, -0.10858798f, 0.02047023f, -0.20127343f, 
    0.34335557f, 0.04105902f, -0.38641647f, 0.35282388f, -0.23763174f, 0.02161459f, 0.25193053f, -0.16413186f, 
    0.37309873f, -0.19804853f, -0.15545124f, 0.16427252f, 0.19757162f, -0.16052586f, -0.18500945f, 0.26285398f, 
    -0.01717867f, -0.31939423f, -0.03336704f, -0.11679839f, -0.13233304f, -0.55895495f, 0.33884475f, 0.04647468f, 
    -0.37647673f, -0.34796253f, -0.02571627f, 0.07195366f, 0.00618103f, 0.04581875f, -0.09217366f, -0.08670360f, 
    0.05336975f, -0.02377509f, 0.00288920f, 0.02895767f, -0.23039770f, -0.20319347f, -0.29844669f, 0.21032162f, 
    -0.25504041f, 0.02800892f, -0.26585957f, 0.04166654f, -0.04533568f, 0.07510707f, 0.32629094f, 0.03467829f, 
    -0.30201858f, 0.21231394f, 0.14053978f, -0.01626528f, 0.39644226f, -0.36358976f, 0.10559470f, -0.19393653f, 
    -0.01236146f, 0.17688078f, -0.03792831f, -0.00516999f, -0.26813316f, -0.29569867f, 0.13472858f, -0.06420221f, 
    -0.03843209f, 0.19098938f, 0.01120581f, 0.28651929f, 0.46756634f, 0.04165508f, -0.02428039f, 0.02883926f, 
    -0.13741757f, -0.33816555f, 0.12993532f, 0.25464529f, -0.10260723f, -0.06124682f, -0.18929516f, -0.00958322f, 
    0.10276455f, -0.13093287f, -0.02981015f, 0.06851359f, 0.07564751f, -0.18464719f, -0.32592148f, 0.03911247f, 
    0.02299947f, 0.05830820f, 0.13579535f, 0.17653625f, 0.89036208f, -0.81103277f, -0.48410714f, 0.07644930f, 
    -0.31803033f, -0.01610957f, 0.20174466f, 0.56543255f, 0.00591965f, -0.29406437f, -0.16791485f, -0.08781552f, 
    -0.00659399f, -0.08115953f, 0.04630276f, 0.22132152f, -0.42985663f, -0.14828449f, 0.17790067f, -0.06404616f, 
    0.17024460f, -0.03981992f, -0.04654307f, 0.06818591f, -0.18371533f, 0.18986949f, 0.46053785f, 0.14243701f, 
    -0.06484438f, 0.30922514f, -0.20035006f, -0.21325631f, 0.04133365f, -0.34342322f, -0.22489834f, -0.04814546f, 
    0.15742798f, -0.08199897f, 0.12724701f, -0.15916900f, -0.08571376f, 0.04629566f, -0.02882874f, 0.19859155f, 
    0.12257718f, -0.04819807f, -0.04041213f, -0.14236063f, 0.01349912f, 0.19624725f, -0.58263481f, -0.55858773f, 
    0.23530442f, 0.25351107f, -0.06048614f, -0.06300223f, -0.41202241f, -0.25083569f, -0.23515832f, 0.00641879f, 
    0.04345351f, 0.25219810f, 0.50817984f, 0.37638050f, -0.26046672f, 0.02921013f, 0.02171577f, 0.08223949f, 
    -0.08179277f, 0.11818492f, 0.31843057f, -0.09602778f, -0.13284561f, -0.04554120f, 0.16609731f, -0.79819340f, 
    0.23465441f, 0.19863051f, -0.77273679f, -0.36462578f, 0.39568746f, 0.20221885f, 0.19520144f, -0.23299511f, 
    -0.00333039f, -0.23775420f, -0.01604767f, -0.19943038f, -0.38413262f, -0.04925796f, 0.28050670f, 0.21343075f, 
    0.06033358f, -0.10851521f, -0.06200187f, 0.06685460f, 0.19080698f, -0.04990514f, 0.12718813f, 0.15705600f, 
    -0.45849416f, -0.08679483f, -0.34580445f, -0.43482012f, -0.30663499f, -0.08839601f, -0.30303779f, -0.26863158f, 
    -0.35480747f, 0.22043988f, 0.08666207f, 0.23836090f, 0.30435100f, 0.20627831f, 0.31899956f, -0.37521586f, 
    -0.15927289f, -0.18016157f, -0.14035194f, -0.07216288f, 0.19673383f, 0.04187519f, -0.06344718f, -0.19130281f, 
    -0.09707250f, 0.26516289f, 0.25088927f, 0.01543008f, 0.27945673f, 0.19568776f, 0.15523170f, 0.16998675f, 
    0.30227783f, 0.18305582f, -0.00648500f, 0.03156154f, 0.02148556f, 0.24282543f, 0.05805083f, -0.25599965f, 
    -0.18494882f, 0.17593436f, -0.00553524f, 0.01446716f, -0.13872659f, 0.00910863f, 0.14209245f, 0.00209304f, 
    0.05447333f, -0.06028630f, 0.12977703f, 0.30323681f, -0.06959858f, 0.21006903f, 0.18433163f, -0.05451332f, 
    0.05757053f, 0.03146299f, -0.01659673f, 0.12008715f, 0.07609104f, -0.18741256f, -0.01137000f, -0.11929540f, 
    0.09726777f, 0.05610321f, 0.06415787f, -0.11653349f, 0.16585770f, -0.03576315f, -0.16678500f, 0.10012671f, 
    -0.27807808f, -0.25753969f, -0.09430499f, -0.63517427f, 0.14686273f, -0.06278384f, -0.31828061f, -0.00889402f, 
    -0.09852467f, 0.07709594f, -0.20156837f, 0.24084538f, 0.15929298f, 0.07036784f, -0.05920638f, -0.04177620f, 
    -0.40965089f, -0.26645687f, 0.29467037f, -0.11916991f, -0.07588734f, 0.43151850f, 0.18555117f, -0.24498560f, 
    -0.18243855f, -0.08616780f, -0.06510909f, -0.30083728f, -0.69049138f, -0.35061395f, -0.65077305f, -0.42969608f, 
    -0.14053972f, 0.18941827f, 0.35861483f, 0.45852834f, 0.27824792f, 0.24091297f, 0.07293095f, 0.01198425f, 
    -0.14139536f, 0.10118125f, 0.23985015f, -0.05200682f, 0.03338560f, 0.06129847f, 0.04859535f, -0.40219018f, 
    -0.21839795f, 0.04208018f, -0.11056489f, -0.02590276f, 0.02824002f, 0.06453463f, -0.69199723f, -0.66985935f, 
    0.32756227f, 0.16595891f, 0.20516042f, 0.16260636f, 0.21892092f, -0.39202285f, 0.40787941f, -0.12383755f, 
    -0.21430202f, -0.40303916f, -0.17964944f, 0.35492730f, 0.04683503f, -0.02554579f, -0.18754648f, 0.15558004f, 
    0.20236170f, 0.13927950f, 0.05031458f, -0.14473101f, -0.31656304f, -0.30903345f, 0.08639224f, -0.19638045f, 
    0.15353565f, -0.12652676f, 0.22142379f, 0.15635836f, -0.49583304f, -0.07353692f, 0.47569305f, -0.03789188f, 
    -0.19326320f, 0.12101694f, -0.07739695f, 0.06718033f, -0.18433732f, 0.03858382f, -0.09082000f, 0.05397428f, 
    -0.09631515f, 0.10221058f, 0.03255218f, 0.12611306f, -0.22683163f, -0.14230673f, 0.19381040f, 0.35317498f, 
    -0.19378485f, -0.17799796f, 0.40676850f, -0.20724393f, -0.11173113f, -0.02615345f, 0.15062776f, -0.19936508f, 
    -0.29700580f, 0.00871376f, 0.27954692f, 0.04515552f, -0.02320737f, 0.03393756f, 0.30256832f, -0.06346066f, 
    -0.05444485f, -0.15722577f, -0.08253623f, -0.09517720f, 0.18756495f, 0.18294577f, -0.00680816f, 0.18335886f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.19191156f, -0.21170208f, -0.07151484f, 0.02655200f, 0.15483673f, 0.00795035f, 0.13523102f, -0.02678984f, 
    -0.10403364f, -0.14725360f, -0.22655962f, -0.02904382f, -0.12380314f, -0.04817102f, -0.01369260f, 0.05408245f, 
    -0.26560551f, -0.03126943f, -0.06106468f, 0.04809495f, 0.04122727f, -0.35393015f, 0.01655615f, 0.00951283f, 
    0.08625197f, -0.40543351f, -0.07767160f, 0.16825898f, -0.10334817f, 0.12397888f, -0.30117753f, -0.20948435f, 
    0.12798792f, -0.19437128f, -0.36137775f, -0.34619778f, -0.07723629f, -0.07030287f, -0.08701671f, -0.31609178f, 
    0.09440702f, 0.07578923f, 0.14858787f, 0.06604545f, 0.00394227f, -0.15000618f, -0.44386819f, 0.03592461f, 
    0.11353675f, -0.08586874f, 0.05787768f, 0.08797639f, 0.03933861f, 0.05986623f, -0.04613101f, -0.23503774f, 
    -0.16000059f, -0.34701201f, -0.17173667f, -0.18203294f, 0.00344355f, -0.28964853f, 0.06838623f, -0.20848845f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03869935f, 0.11380836f, 0.16664600f, -0.01338910f, 0.15782610f, 0.08421681f, 0.00170155f, 0.15597428f, 
    0.02697252f, 0.02346990f, 0.00358621f, -0.13090459f, 0.06557472f, 0.01164791f, 0.00349964f, 0.05506273f, 
    0.02209458f, 0.08463994f, 0.05327310f, -0.04625629f, 0.06486698f, -0.02035651f, 0.04364321f, -0.12062155f, 
    -0.14992592f, -0.06159120f, 0.04007562f, 0.03317970f, 0.03950833f, -0.09843379f, 0.02993184f, 0.07218295f, 
    0.03342593f, 0.03196546f, 0.05153560f, 0.02357647f, -0.09618592f, -0.14277381f, 0.06059063f, -0.09480302f, 
    0.05360478f, 0.14632314f, -0.00469426f, 0.01422838f, -0.00076371f, 0.00332607f, -0.02512268f, 0.06482388f, 
    -0.27068663f, -0.03834033f, 0.10276510f, 0.15921278f, 0.07537306f, 0.00951913f, -0.18211550f, 0.00783538f, 
    -0.01892759f, 0.13704200f, -0.01445516f, 0.04529254f, -0.09114584f, -0.18877004f, -0.14026333f, 0.09631176f, 
    0.01604280f, 0.04485212f, 0.04628264f, 0.04396451f, -0.03897821f, -0.02361646f, -0.03343125f, 0.00225305f, 
    -0.09772693f, 0.44678998f, 0.28147355f, 0.05354880f, 0.06253332f, -0.00178178f, 0.00906225f, 0.11770175f, 
    0.03376928f, 0.01085886f, 0.12140366f, 0.05552011f, -0.26530629f, -0.00342407f, 0.04380558f, 0.12533720f, 
    0.10070578f, -0.03261618f, -0.03549142f, 0.05377560f, 0.00395051f, 0.04715905f, 0.05632498f, 0.08624565f, 
    0.06533331f, -0.19483833f, -0.13117753f, -0.10936427f, -0.01776397f, 0.01871380f, 0.00702354f, 0.01937845f, 
    -0.04468400f, -0.07161077f, 0.01401105f, -0.13124906f, 0.32406011f, -0.10346333f, -0.05306043f, -0.23315473f, 
    -0.06421077f, -0.09331872f, -0.04454039f, 0.04391493f, -0.00313135f, -0.00084382f, -0.03287430f, 0.06707226f, 
    -0.22688948f, 0.00997553f, -0.10015415f, 0.18921876f, -0.09992498f, -0.13016178f, -0.08995587f, 0.02013846f, 
    0.05393135f, -0.10672371f, 0.07333449f, -0.06047949f, 0.18961295f, 0.21589649f, -0.18389475f, 0.05793316f, 
    0.05451189f, 0.02210599f, 0.02559164f, 0.04121464f, -0.02436979f, -0.09036610f, 0.05083272f, 0.06673118f, 
    -0.21831951f, -0.02175941f, 0.11451828f, 0.01004522f, 0.08514542f, 0.06589571f, 0.17851606f, -0.01163531f, 
    0.08973706f, -0.00062378f, 0.04954230f, 0.03480950f, 0.01768532f, -0.16273764f, 0.02917642f, 0.07948100f, 
    0.10132502f, 0.16608025f, 0.03162896f, -0.03397680f, 0.02564484f, 0.03941171f, 0.02106659f, 0.03242589f, 
    0.16152538f, -0.07852717f, -0.04650562f, -0.15985829f, 0.01111657f, 0.06890866f, 0.30507657f, 0.06098006f, 
    0.07999704f, 0.01436871f, -0.12205563f, 0.02410505f, -0.21328425f, 0.15689586f, 0.23771252f, 0.05662366f, 
    -0.04425225f, -0.01484794f, -0.02346347f, -0.07406476f, 0.15496062f, 0.13994271f, 0.07456692f, 0.14987519f, 
    -0.22528064f, 0.04679026f, -0.07920256f, -0.05052080f, -0.09458420f, -0.10578608f, 0.08704661f, -0.01842757f, 
    0.15624267f, 0.00827507f, -0.00618571f, 0.03923592f, -0.18141329f, -0.21149814f, -0.14214580f, -0.03167230f, 
    0.06407429f, -0.14085391f, 0.07199337f, -0.09632417f, 0.03646959f, 0.01438840f, -0.11566351f, 0.00754506f, 
    0.18166004f, -0.04787166f, -0.05643899f, 0.05658361f, 0.02816022f, 0.02206981f, 0.01155048f, 0.10166971f, 
    0.06037996f, 0.08095088f, 0.10697329f, 0.07755461f, 0.15290917f, 0.07762107f, -0.01923909f, -0.03147064f, 
    -0.02191395f, 0.01185212f, 0.17986429f, -0.05914408f, 0.10621213f, 0.08867018f, 0.13574494f, 0.05399042f, 
    0.27865896f, -0.12805006f, 0.00892882f, -0.15728135f, -0.08501904f, 0.03764348f, 0.22942850f, 0.07567331f, 
    -0.05116720f, -0.02609638f, -0.07018661f, -0.00504021f, -0.10190316f, -0.07960410f, -0.06013344f, 0.11257958f, 
    -0.01691920f, 0.03180134f, 0.02707287f, -0.11329678f, 0.05835315f, 0.00846226f, 0.10295185f, -0.04025463f, 
    0.01012016f, -0.08217823f, 0.16704537f, -0.08962801f, 0.13912629f, 0.00089508f, 0.04715289f, -0.03717381f, 
    0.11170503f, 0.06474853f, -0.07033809f, 0.02628655f, -0.22527435f, 0.27583569f, 0.30841500f, 0.07191873f, 
    -0.01231004f, -0.17875667f, 0.08444434f, -0.01555716f, 0.00156616f, 0.11349453f, -0.07113749f, -0.03469831f, 
    0.04350274f, -0.11949252f, 0.12982096f, -0.16539766f, 0.08915151f, 0.03535353f, 0.09869144f, 0.17594855f, 
    -0.02143642f, 0.03961616f, 0.03484197f, -0.01845271f, -0.30078438f, -0.15331855f, 0.00677358f, 0.17770939f, 
    -0.08586759f, 0.06321249f, -0.04794430f, 0.12526551f, 0.04932964f, 0.00961449f, 0.11569685f, 0.06705803f, 
    0.15393507f, 0.11768033f, 0.07573337f, -0.02273321f, 0.03512286f, -0.00798826f, -0.00629489f, 0.00773645f, 
    0.02711106f, 0.09636571f, 0.01881011f, 0.00405107f, 0.10954679f, 0.11528545f, 0.16906999f, 0.05640183f, 
    0.09054922f, -0.12854864f, 0.08200543f, 0.11787984f, 0.10850875f, 0.08769266f, 0.07744823f, 0.07533315f, 
    -0.06171175f, -0.14471719f, -0.09883543f, 0.13229778f, -0.04825604f, 0.01417224f, -0.03051038f, 0.03338172f, 
    0.12529384f, 0.00662825f, 0.00077517f, 0.01196904f, 0.02799280f, 0.10519027f, 0.24036533f, -0.02940161f, 
    0.05368539f, 0.10652905f, 0.22642788f, 0.02193327f, 0.14877377f, 0.13280365f, 0.00068877f, 0.11269178f, 
    -0.03615493f, 0.04127101f, -0.22466893f, -0.05408559f, -0.02870422f, -0.03728803f, -0.04024569f, -0.09635352f, 
    0.00298955f, -0.09961800f, 0.05872328f, 0.08812442f, -0.10972037f, -0.12999415f, 0.03228618f, -0.17317848f, 
    -0.00894485f, 0.02174905f, 0.15797067f, 0.11022560f, 0.07476544f, 0.04685891f, -0.06463637f, 0.04165995f, 
    0.11354245f, 0.11482785f, -0.04482235f, -0.00065593f, -0.01350288f, -0.08991954f, 0.09599262f, 0.08080174f, 
    0.07337093f, 0.09498554f, 0.11394602f, 0.12080406f, 0.29773495f, 0.13263650f, -0.02067456f, 0.00395626f, 
    -0.05100839f, 0.05520613f, -0.04919434f, 0.03528388f, -0.01924561f, 0.07993336f, 0.16654265f, -0.09238172f, 
    -0.32516247f, -0.19449344f, 0.10995341f, 0.04275976f, -0.12228792f, -0.09958437f, -0.08256292f, -0.09157641f, 
    0.01874678f, 0.07895761f, 0.07501517f, -0.09570880f, -0.28276464f, -0.28235745f, 0.04035572f, 0.07449871f, 
    -0.01393728f, -0.13793002f, -0.06985157f, -0.17082897f, 0.01084063f, 0.05156465f, -0.04952644f, -0.01007972f, 
    -0.23902828f, -0.06640267f, 0.11643803f, 0.10271701f, -0.00598364f, -0.04972091f, -0.03699251f, 0.08943827f, 
    0.08641917f, 0.05293482f, 0.02950020f, 0.04769323f, -0.27941909f, -0.09490768f, 0.00970357f, 0.17967539f, 
    -0.02068213f, -0.01339855f, 0.03114099f, -0.02639107f, 0.03299850f, 0.00811464f, 0.04242029f, -0.00142572f, 
    -0.10942154f, -0.10861488f, 0.13100456f, 0.02005671f, 0.02752718f, -0.02322074f, 0.12999509f, -0.01753436f, 
    0.06075571f, -0.03513378f, 0.00975632f, -0.00605694f, -0.26659277f, -0.08427393f, -0.00735456f, 0.00051870f, 
    0.00779831f, -0.01072122f, -0.10020515f, -0.22194056f, 0.03647744f, -0.10519830f, -0.01295772f, 0.08227552f, 
    0.43278152f, 0.29173520f, 0.05549543f, 0.02079086f, -0.00939766f, 0.02433448f, 0.14029680f, -0.06317595f, 
    0.19703825f, -0.05457223f, 0.14326765f, 0.06167496f, 0.20598523f, -0.03295572f, -0.04834347f, -0.26591504f, 
    0.17724763f, 0.09577602f, 0.19868714f, 0.17899927f, 0.06068905f, -0.05948962f, 0.02235298f, 0.02406156f, 
    -0.07432915f, -0.08560337f, 0.06401183f, 0.05752865f, 0.07980876f, -0.00113986f, 0.12220091f, 0.11301425f, 
    0.01613702f, 0.03421377f, -0.03035944f, -0.08109609f, -0.00973643f, -0.10721271f, -0.09357580f, 0.38553920f, 
    0.04625810f, -0.10431767f, -0.03249857f, 0.12444866f, 0.01187383f, 0.06216355f, 0.09497947f, 0.02430492f, 
    -0.12971111f, -0.09011816f, 0.23910736f, -0.16076620f, -0.06091177f, -0.01992158f, -0.10412969f, 0.33591774f, 
    0.13866074f, 0.03202357f, -0.21700002f, -0.06301365f, -0.03679754f, 0.07054421f, -0.17617621f, 0.05440393f, 
    -0.05526568f, -0.04672325f, -0.04616035f, 0.04868057f, 0.07889838f, 0.01312986f, -0.03055000f, 0.10183109f, 
    -0.15431099f, -0.14398733f, 0.02938163f, -0.00811579f, -0.12093361f, -0.14023119f, 0.05625381f, 0.13802435f, 
    -0.03171183f, -0.00754670f, 0.10783906f, -0.02214024f, 0.14890848f, 0.00448594f, -0.15801793f, 0.13989277f, 
    0.04906892f, -0.00678524f, -0.02011904f, -0.04555796f, -0.12448714f, -0.03308348f, 0.00626111f, -0.05240761f, 
    -0.11546674f, -0.06172080f, -0.00333280f, 0.20319577f, 0.10487145f, 0.16609399f, 0.02536363f, -0.04161872f, 
    0.02225434f, -0.05649609f, 0.03062904f, 0.10026035f, -0.17908162f, -0.08735899f, 0.13328640f, 0.00844243f, 
    0.07092228f, 0.00410782f, 0.07022973f, -0.07542638f, 0.08174611f, 0.16667165f, 0.01985502f, 0.04474169f, 
    0.12895152f, -0.00053798f, -0.18711899f, -0.00037440f, 0.07739341f, -0.02874923f, -0.00634041f, -0.00035584f, 
    -0.02460566f, 0.02598664f, -0.02226965f, -0.15623356f, 0.02484295f, -0.06472145f, -0.09963187f, -0.31721222f, 
    0.00111314f, 0.06462214f, 0.03337898f, -0.05272546f, -0.05502696f, 0.01052159f, -0.07625431f, -0.09830192f, 
    -0.11484653f, 0.19721419f, -0.00215532f, -0.09182650f, -0.05137717f, 0.14188445f, 0.05975931f, 0.11398605f, 
    0.11885458f, 0.15228479f, 0.16267936f, 0.12096838f, 0.07345489f, -0.03996610f, -0.11351319f, -0.13164902f, 
    0.19031951f, 0.15896955f, 0.18623681f, -0.00550485f, -0.04399710f, -0.06380948f, 0.00104227f, 0.00859455f, 
    -0.35631493f, -0.20057023f, 0.07751588f, 0.17746717f, 0.11666165f, 0.05641645f, -0.05874996f, -0.14894383f, 
    -0.04638837f, 0.04072069f, -0.00395058f, 0.00095339f, -0.23239645f, -0.20529601f, 0.14093578f, 0.05087724f, 
    0.07196017f, -0.08637112f, 0.10745139f, 0.00893297f, 0.06275588f, 0.01323023f, -0.00600561f, -0.05024534f, 
    -0.25560400f, -0.14922918f, 0.12839569f, 0.07639669f, -0.03952224f, -0.07233853f, -0.00139807f, -0.00868733f, 
    0.06046293f, 0.14045103f, 0.02363546f, 0.09408127f, -0.03610102f, -0.05126545f, -0.06933142f, -0.02926723f, 
    -0.04723652f, -0.12105174f, -0.09448961f, -0.06092330f, -0.09206161f, -0.14070001f, -0.15976667f, -0.18009545f, 
    0.07757181f, 0.04976160f, -0.04514487f, 0.00658393f, 0.00357404f, -0.03421734f, 0.04632284f, 0.00911124f, 
    0.06860456f, -0.09180254f, 0.02929159f, -0.11497305f, -0.09795032f, -0.15807292f, 0.09744557f, 0.10836658f, 
    -0.04353845f, -0.04711822f, 0.00363415f, 0.01003852f, 0.01624707f, 0.14448652f, 0.07598516f, 0.00756274f, 
    -0.26186395f, 0.14784327f, 0.23505349f, 0.03282087f, -0.06205862f, -0.07785104f, -0.03125479f, -0.01836213f, 
    -0.00026567f, 0.15347937f, 0.17668058f, 0.03713070f, -0.21165508f, -0.15279859f, 0.09299450f, 0.12998147f, 
    -0.05572830f, 0.19166934f, 0.04122334f, 0.05263001f, 0.23239931f, 0.05028453f, 0.15250871f, 0.00410427f, 
    -0.02555300f, -0.01717447f, -0.12662025f, 0.09319491f, -0.07330307f, 0.08392912f, 0.08461104f, -0.00016742f, 
    0.06321720f, -0.04127669f, 0.00281594f, 0.01063114f, -0.03901222f, -0.10823971f, -0.00171718f, -0.09222282f, 
    0.05912799f, -0.04506689f, 0.07921233f, 0.11822890f, -0.05050480f, -0.01017797f, -0.00789358f, -0.00620860f, 
    0.00688729f, -0.03549829f, 0.17215121f, 0.04690694f, -0.01656291f, -0.05652579f, -0.14270470f, -0.00699775f, 
    0.29881698f, -0.01350963f, 0.12249766f, 0.11174185f, 0.08376534f, 0.03925932f, -0.01852515f, 0.10468468f, 
    0.10793759f, -0.06391595f, 0.03272006f, -0.03302145f, 0.00951893f, 0.05739461f, 0.07897761f, 0.17839424f, 
    0.05341043f, 0.08148097f, 0.10082607f, 0.14833733f, -0.01601478f, -0.08528560f, -0.00975511f, -0.09107107f, 
    -0.10250210f, -0.05947043f, 0.05296516f, -0.00071307f, 0.07025661f, -0.19253203f, -0.05716016f, 0.14946555f, 
    0.03336344f, -0.00532898f, 0.06223648f, -0.08417302f, -0.01471823f, -0.09104069f, -0.07466581f, -0.05701808f, 
    -0.09657677f, -0.09393407f, 0.28148648f, 0.19386621f, 0.00029155f, -0.00283731f, -0.14151937f, -0.01499621f, 
    -0.15812719f, 0.06498711f, -0.04258043f, -0.05101575f, -0.15000905f, -0.24001993f, 0.08555345f, 0.35266265f, 
    0.15750898f, 0.20760003f, 0.12240046f, 0.05635538f, -0.04126282f, -0.02495950f, -0.06193049f, -0.07162738f, 
    -0.21899296f, 0.35671899f, 0.55199963f, 0.00920632f, 0.02966455f, -0.04411567f, -0.02797657f, 0.06883489f, 
    -0.04805406f, -0.01346572f, -0.06336829f, 0.15198594f, -0.14126197f, -0.11617112f, 0.18090750f, 0.06628115f, 
    -0.09106754f, -0.06139171f, 0.00466060f, 0.07198770f, -0.09278362f, 0.00674755f, -0.02017100f, 0.07003962f, 
    -0.14654665f, -0.13133565f, -0.03686335f, 0.04819955f, 0.09517323f, 0.05741344f, -0.01674946f, 0.01038202f, 
    -0.06754301f, -0.13718644f, -0.09818419f, -0.20735177f, 0.05733999f, 0.10643233f, -0.20828047f, 0.08563882f, 
    -0.06097328f, -0.05494070f, 0.04155052f, -0.05227683f, 0.10044549f, 0.12390770f, -0.02589442f, -0.04265477f, 
    -0.08327837f, 0.07800382f, 0.12388494f, 0.02698254f, -0.09289222f, -0.15567295f, 0.01080933f, 0.04878496f, 
    0.04125927f, -0.05695495f, 0.00540126f, -0.11755664f, -0.18428543f, 0.01556738f, -0.13128416f, -0.03894439f, 
    0.02787717f, 0.03588615f, 0.03991824f, 0.00440963f, 0.09693002f, -0.04719963f, 0.02185881f, 0.07651769f, 
    -0.08076368f, -0.00864009f, -0.00411236f, 0.07355108f, 0.09490702f, 0.02960258f, 0.12274113f, 0.00622129f, 
    0.18563148f, 0.02449454f, 0.07825937f, 0.28966901f, -0.01770115f, -0.24602818f, 0.21935418f, 0.11388870f, 
    0.01519668f, 0.13420276f, 0.09879803f, -0.04991340f, 0.03887208f, -0.04052187f, 0.05819414f, 0.09147247f, 
    0.07419542f, -0.06095603f, -0.35364884f, 0.17523289f, 0.02126839f, 0.10891269f, -0.02067161f, 0.06442253f, 
    0.07740929f, 0.12403640f, -0.12707491f, -0.03859661f, -0.00241347f, 0.27850938f, 0.45738688f, 0.09359600f, 
    -0.05999122f, -0.04317752f, -0.10344592f, 0.08182203f, 0.05699559f, 0.00005392f, -0.03225487f, 0.01622659f, 
    -0.19609234f, 0.13960890f, 0.06792419f, 0.04955298f, -0.09918568f, -0.25883207f, -0.02319600f, 0.07114303f, 
    0.03579825f, 0.00670273f, -0.00720891f, 0.07611106f, -0.06362607f, 0.01229130f, -0.06401919f, 0.19273749f, 
    -0.12990960f, -0.07168602f, 0.05566369f, -0.12785408f, 0.06614748f, -0.00011890f, -0.07163592f, -0.10001540f, 
    0.17733859f, 0.11581059f, -0.11206648f, 0.03092059f, -0.06148301f, -0.11008293f, 0.11809646f, -0.10106618f, 
    -0.01811651f, -0.05676776f, 0.08854903f, 0.13540055f, 0.08526453f, 0.24982142f, -0.10729548f, -0.17632508f, 
    -0.07588091f, -0.08066244f, 0.09602369f, 0.03947642f, 0.25205535f, 0.10881623f, -0.05999429f, -0.08383030f, 
    0.04780687f, -0.06285529f, -0.36756068f, 0.09880499f, 0.05579504f, 0.18263140f, -0.00259563f, -0.03019997f, 
    0.12225193f, -0.13634337f, -0.03928633f, -0.15022832f, -0.32491982f, -0.11655381f, -0.10848687f, 0.15369411f, 
    0.01726678f, -0.03831411f, 0.10056961f, 0.03531350f, -0.00170152f, -0.02389443f, 0.07872311f, 0.10229466f, 
    0.01457076f, 0.08479977f, -0.21043371f, 0.19166698f, -0.02565965f, 0.04013285f, 0.12072375f, -0.03750883f, 
    -0.05662476f, 0.08816512f, -0.10348973f, 0.03770012f, 0.18877853f, 0.27261797f, 0.24820060f, 0.22488806f, 
    0.05827738f, -0.23226982f, 0.11572079f, -0.03200062f, 0.01374628f, -0.07824030f, -0.01815192f, 0.04020689f, 
    -0.00942233f, -0.04177913f, 0.10030223f, 0.06574403f, 0.02164497f, 0.06393241f, -0.01904633f, 0.11503576f, 
    -0.12359654f, -0.01894589f, 0.07026896f, -0.00499073f, -0.19359648f, -0.14816038f, -0.01354127f, 0.16624323f, 
    -0.07445877f, 0.06230231f, 0.04271059f, -0.02631841f, -0.00294182f, 0.02348102f, 0.03670012f, 0.05404060f, 
    0.04695265f, -0.01613245f, -0.03403692f, -0.01041498f, 0.05407833f, -0.00793721f, 0.10672244f, -0.08001949f, 
    0.17813058f, 0.16585459f, 0.09047232f, 0.16895296f, 0.12462538f, 0.20436622f, 0.10587412f, 0.09349532f, 
    0.00410494f, 0.00381429f, -0.20478757f, 0.00580777f, -0.16013704f, 0.07697924f, 0.04241467f, 0.01234648f, 
    -0.33554026f, -0.15574701f, -0.07252844f, 0.19990112f, 0.08801822f, -0.06004499f, -0.07000117f, -0.04014222f, 
    0.05420583f, -0.01036241f, 0.00019152f, 0.01376903f, 0.01297803f, 0.18882225f, -0.06545718f, -0.04313973f, 
    0.02785439f, -0.03843809f, 0.06724995f, -0.04570114f, 0.14224818f, -0.09932224f, -0.02887218f, 0.11178979f, 
    0.09164914f, -0.08036111f, 0.06503195f, -0.07325968f, 0.10115028f, 0.03178241f, -0.00667790f, 0.00947620f, 
    -0.00804695f, -0.08591547f, 0.02717782f, 0.10828651f, -0.04204675f, -0.16120315f, -0.04958005f, 0.05197431f, 
    -0.07933481f, -0.06127070f, 0.15966885f, -0.01167239f, -0.00157914f, -0.01044885f, 0.03419149f, -0.02414630f, 
    0.06652763f, 0.10328303f, 0.05405182f, 0.10095624f, 0.03699740f, 0.07954315f, -0.04637429f, -0.11801161f, 
    0.18167269f, -0.02290067f, 0.02381161f, 0.16240923f, 0.11108451f, 0.12714753f, -0.32229751f, -0.06208188f, 
    -0.05285422f, -0.06012548f, 0.05757808f, -0.14122544f, 0.07901713f, -0.00200000f, 0.08251473f, 0.29447675f, 
    -0.27249926f, -0.25792867f, 0.01902146f, 0.09030470f, 0.02787018f, -0.00619047f, -0.13095164f, 0.01497080f, 
    0.08950155f, 0.04386348f, 0.16736530f, 0.09510139f, -0.14259546f, -0.32569778f, 0.13855197f, 0.15648256f, 
    0.05021725f, -0.18981840f, -0.02301030f, -0.06447787f, 0.01811850f, -0.06159790f, 0.03570587f, -0.02270698f, 
    0.12009880f, -0.09435745f, 0.23361154f, -0.00655789f, 0.09024914f, -0.03017397f, -0.12905455f, 0.02780165f, 
    -0.08480073f, 0.19437447f, -0.01470905f, 0.00225536f, -0.21470559f, -0.09683993f, 0.01025332f, 0.19888881f, 
    -0.08778434f, 0.02511603f, -0.15866962f, -0.06262463f, -0.10250466f, -0.01822225f, -0.05311150f, 0.02488088f, 
    0.11408425f, 0.14806333f, 0.01486729f, 0.02601189f, -0.00233867f, -0.04600549f, 0.02992152f, 0.01349646f, 
    0.09603103f, -0.12403247f, -0.05968034f, -0.16053088f, -0.14333463f, 0.10262652f, 0.00191675f, 0.14369272f, 
    -0.05646906f, 0.06714953f, -0.04920623f, -0.00821077f, 0.00457702f, -0.12483084f, -0.02497202f, -0.07848547f, 
    0.07600415f, -0.02646539f, 0.12726964f, -0.28474104f, 0.07436184f, 0.07243688f, -0.00721889f, -0.13220331f, 
    0.06954052f, 0.06544790f, -0.02035469f, 0.09968112f, 0.08401036f, 0.19518606f, -0.18620762f, -0.05089923f, 
    0.09471548f, -0.05477307f, 0.09384890f, -0.02353872f, 0.00202846f, -0.02919173f, 0.03612744f, -0.14029521f, 
    0.25214681f, -0.19328998f, 0.03530964f, 0.10902984f, 0.21399213f, 0.11352922f, -0.09725568f, -0.03728582f, 
    -0.03427766f, 0.15585448f, -0.04593966f, -0.01802639f, 0.09266479f, -0.06430173f, -0.06184810f, 0.07719202f, 
    0.00592117f, -0.12661546f, -0.01026256f, -0.10050921f, -0.06881158f, 0.00388538f, -0.05952790f, 0.07924601f, 
    0.12397385f, 0.06737432f, 0.13582252f, -0.07303354f, 0.00572620f, -0.14834756f, -0.04254366f, -0.04185934f, 
    0.00171104f, -0.10362180f, -0.13107769f, -0.12428018f, -0.21486665f, -0.03495088f, 0.11645800f, -0.21275765f, 
    -0.03042132f, -0.05553151f, -0.03075378f, 0.09670918f, 0.02012401f, -0.06796666f, -0.03145530f, 0.11713250f, 
    0.08949524f, 0.05860101f, 0.30669826f, 0.05753514f, -0.01689762f, 0.04057609f, 0.02442160f, -0.08154150f, 
    0.08595064f, 0.09713360f, 0.04485499f, -0.10732029f, -0.02573504f, -0.20932689f, -0.04244329f, -0.05738791f, 
    0.07328580f, -0.07082267f, -0.11243311f, -0.03976724f, -0.04475158f, -0.09141146f, -0.05692507f, 0.03231033f, 
    0.08369537f, -0.04311463f, -0.09619840f, 0.16725416f, 0.07251573f, 0.04677477f, -0.02403287f, -0.11640643f, 
    -0.05245888f, 0.00235356f, 0.00494976f, -0.03620724f, -0.01187057f, -0.09802519f, 0.05409576f, 0.15801945f, 
    -0.03274355f, -0.11058094f, 0.06627150f, 0.04785305f, 0.08556171f, 0.06045870f, -0.06363261f, 0.06546465f, 
    0.12114418f, -0.01784653f, -0.05960161f, 0.07348220f, 0.09348881f, -0.05106347f, -0.00729124f, -0.00837623f, 
    -0.06864555f, -0.17433918f, -0.02960766f, -0.11499039f, -0.11935758f, -0.09277698f, -0.19026208f, -0.02543070f, 
    -0.01791559f, 0.00049954f, -0.02629586f, 0.00032142f, -0.09506257f, -0.09948827f, -0.00978668f, -0.19404753f, 
    -0.34817648f, -0.02280158f, 0.07809676f, -0.22795230f, 0.01073268f, -0.03997035f, -0.05517017f, 0.08666367f, 
    0.05965567f, -0.07433701f, -0.05608663f, 0.10798796f, -0.12590539f, -0.20695727f, -0.01587762f, 0.11754180f, 
    0.16825472f, 0.15595563f, 0.14908962f, 0.04456199f, -0.00163100f, -0.05721520f, -0.06494710f, -0.15364166f, 
    -0.06240446f, -0.05484192f, -0.05092305f, 0.13101952f, -0.11131059f, -0.00858430f, -0.01158848f, -0.12551099f, 
    -0.07900023f, 0.07439574f, -0.11645326f, -0.09699824f, -0.00016997f, -0.18054561f, -0.04256029f, 0.13868925f, 
    0.02755244f, -0.09704655f, 0.06233406f, -0.09333821f, 0.00435189f, -0.07130875f, 0.01776660f, -0.01938411f, 
    0.09224256f, 0.12964544f, 0.09419399f, 0.13916479f, -0.07478812f, -0.04808658f, 0.08609527f, 0.06009102f, 
    0.15913996f, 0.03111665f, -0.03160474f, 0.05260597f, -0.21643743f, -0.22805767f, -0.27617925f, -0.15817516f, 
    0.03695105f, 0.00563370f, 0.04006337f, 0.05803627f, 0.13898684f, 0.02461508f, -0.05502749f, 0.05895103f, 
    -0.05545316f, -0.21321249f, -0.12418617f, -0.14308712f, -0.04736040f, -0.00004543f, 0.10000616f, -0.00837961f, 
    0.22881308f, 0.15071674f, 0.11292437f, 0.17161728f, -0.09663666f, -0.15425932f, 0.02191627f, 0.12669998f, 
    0.01924174f, -0.02974747f, -0.03334415f, 0.10097503f, 0.00771866f, 0.02975016f, 0.13639243f, 0.02427948f, 
    0.18221149f, 0.21330544f, 0.30517435f, 0.15467066f, -0.02731120f, -0.09832123f, 0.05182031f, 0.12989207f, 
    0.04002258f, 0.05728013f, 0.08246935f, 0.06882852f, -0.25770921f, -0.11509049f, 0.14929634f, 0.06252957f, 
    -0.11807814f, 0.08992614f, -0.13404405f, 0.09722771f, 0.09464915f, -0.01896439f, -0.04917675f, 0.31385827f, 
    -0.00328056f, -0.14310080f, -0.14998817f, 0.03627597f, -0.00333462f, 0.05106212f, 0.07447353f, -0.06928732f, 
    0.06515300f, -0.08216936f, -0.00484053f, 0.00832557f, 0.03571309f, -0.03349397f, 0.23991989f, -0.09764931f, 
    0.11459049f, -0.06484537f, -0.00024125f, 0.00978290f, 0.04956244f, -0.09078670f, -0.03017296f, -0.09772398f, 
    -0.00941597f, 0.19021611f, 0.05188119f, -0.03934722f, 0.04241719f, 0.03487087f, 0.07007038f, -0.00100858f, 
    -0.00257382f, 0.08082585f, -0.05069659f, 0.12691139f, -0.22030644f, 0.00872296f, 0.01718909f, 0.22427590f, 
    0.02367492f, 0.07160442f, -0.01800941f, -0.00171675f, 0.07997726f, 0.10359208f, -0.06191494f, -0.18661791f, 
    0.04049107f, -0.04213694f, 0.03821208f, 0.23818319f, 0.03117212f, 0.00751931f, 0.02490622f, -0.00548537f, 
    0.07838094f, 0.05795699f, -0.10540671f, 0.02252625f, 0.12758212f, 0.03817571f, 0.29527512f, -0.01299081f, 
    0.03527838f, 0.00413727f, -0.03751768f, 0.07977439f, -0.06071421f, -0.03272148f, -0.00714300f, -0.11840916f, 
    -0.30240473f, 0.19689853f, -0.17291696f, -0.20846015f, 0.02591378f, -0.00767783f, 0.00673083f, -0.01787386f, 
    -0.06844530f, -0.00267576f, 0.12062272f, 0.09027483f, 0.22772999f, 0.34646413f, 0.28556094f, 0.08106695f, 
    -0.06066643f, -0.17828362f, -0.05286480f, -0.04806073f, -0.03743629f, -0.11512139f, -0.02437692f, -0.04095693f, 
    -0.50466657f, 0.23898748f, 0.01645416f, 0.08610876f, -0.09875385f, 0.14784802f, 0.03629292f, 0.00910570f, 
    -0.04221470f, 0.01624354f, 0.07195193f, 0.12978995f, 0.13289313f, 0.37774703f, -0.02190935f, 0.04507758f, 
    0.08991575f, 0.06666427f, 0.00422899f, 0.01238962f, 0.00359285f, -0.00792119f, 0.00035424f, 0.00496786f, 
    0.13023907f, 0.05472920f, -0.03344060f, -0.09304040f, 0.08632666f, -0.08596382f, -0.03621140f, 0.00408248f, 
    -0.02234589f, -0.00090576f, 0.05055619f, 0.03467461f, -0.11273581f, 0.07364232f, 0.33928955f, 0.06958683f, 
    0.00975682f, -0.11758240f, -0.14590314f, -0.08024926f, -0.04859718f, -0.09503347f, 0.01436948f, 0.14960819f, 
    0.11190964f, -0.06420062f, -0.01424678f, 0.02066148f, 0.09278650f, 0.04691553f, -0.02089177f, -0.03595706f, 
    0.03702725f, 0.08485029f, -0.05548803f, 0.12009733f, 0.25443399f, -0.01953813f, 0.09450043f, 0.04445111f, 
    -0.03609527f, 0.01200574f, -0.11009350f, 0.11656536f, -0.12225281f, -0.04479631f, 0.18100928f, -0.02558528f, 
    -0.02290038f, -0.05727427f, -0.03406023f, -0.11446618f, 0.00457605f, 0.00010477f, 0.00189125f, 0.07336228f, 
    0.09557652f, 0.21190087f, -0.06715807f, -0.05615279f, 0.09940632f, 0.22776589f, 0.07164256f, -0.09808886f, 
    0.01510737f, 0.00221265f, 0.08011365f, 0.05817487f, -0.02982113f, 0.13482256f, -0.09058695f, -0.09232113f, 
    -0.17082994f, -0.01466915f, 0.26119798f, 0.13717271f, -0.09628169f, -0.09467368f, 0.11093722f, 0.04010231f, 
    0.00846675f, 0.03850559f, -0.04999594f, -0.12511726f, 0.04980575f, -0.16088825f, -0.11507788f, -0.15334339f, 
    0.03075711f, 0.07453185f, 0.06995858f, 0.09166116f, 0.13130158f, 0.08678606f, 0.08436805f, 0.01530638f, 
    0.27212134f, -0.22513315f, 0.01997233f, 0.16257225f, 0.02212474f, -0.02574861f, 0.16920467f, 0.06343979f, 
    -0.06607827f, -0.08697709f, -0.06728177f, -0.04793219f, 0.13792455f, -0.10589622f, 0.11148757f, 0.09756923f, 
    0.09633724f, 0.12558235f, 0.03020039f, 0.04689121f, 0.03783177f, 0.02390411f, 0.10573025f, -0.05092571f, 
    0.12185610f, -0.09267044f, -0.03584737f, -0.02955011f, 0.09309153f, -0.05035908f, 0.13663746f, -0.01544347f, 
    -0.05985501f, -0.03700345f, 0.01486462f, 0.05537151f, -0.05052511f, -0.12571952f, 0.00010731f, -0.00732164f, 
    0.12816554f, 0.03299569f, -0.06393697f, 0.06577035f, -0.10229365f, 0.08057655f, 0.15036842f, 0.00077476f, 
    -0.14654636f, 0.11375234f, 0.35589895f, 0.03359522f, 0.07358443f, -0.04234054f, -0.06150974f, -0.06745634f, 
    -0.00060572f, -0.04463517f, 0.03744362f, 0.01724478f, 0.06500001f, 0.01263841f, 0.17196195f, 0.14131148f, 
    0.04717638f, -0.11445259f, 0.06873628f, -0.11109990f, 0.05029424f, 0.06398716f, 0.05471440f, 0.11238673f, 
    -0.21154486f, 0.09637215f, 0.20732217f, 0.02344081f, 0.01039925f, -0.00072995f, 0.01033685f, -0.00461684f, 
    0.04602600f, 0.07869260f, 0.10454092f, -0.03995070f, -0.20364724f, -0.14656502f, -0.12345760f, 0.25951108f, 
    0.06758482f, 0.05727825f, -0.00372717f, 0.03254508f, -0.05050538f, -0.12641156f, -0.06702181f, -0.03405556f, 
    -0.08468286f, 0.02683576f, -0.08598673f, -0.01004995f, 0.07578225f, -0.00314977f, -0.02167008f, 0.06726532f, 
    -0.01299659f, 0.01169236f, 0.03662753f, -0.09300448f, -0.07479338f, 0.04795219f, 0.03938510f, 0.00455047f, 
    0.06753295f, 0.08027714f, -0.08328760f, 0.09794296f, -0.01370965f, 0.03529544f, 0.16862096f, 0.02351579f, 
    0.03678142f, -0.05820712f, -0.11466382f, -0.14284636f, -0.03464972f, -0.05953741f, -0.10171425f, -0.01269893f, 
    0.02714645f, 0.20402123f, 0.03320978f, -0.05912092f, -0.31912658f, 0.10373422f, 0.02297387f, 0.16233952f, 
    0.02620336f, 0.03018288f, 0.04243662f, -0.04640147f, -0.04683686f, 0.02216315f, -0.05778781f, 0.16919348f, 
    0.26056841f, -0.01648409f, -0.29093844f, -0.28435773f, -0.02656188f, -0.07826402f, -0.09191884f, -0.08716372f, 
    0.06989282f, 0.14145818f, 0.10801414f, 0.05760664f, 0.30387524f, -0.16614249f, 0.21414277f, 0.20295215f, 
    0.17967898f, 0.07466697f, 0.01697916f, -0.06388441f, -0.02097086f, -0.00190439f, 0.10989957f, -0.03892526f, 
    -0.18949656f, 0.10619319f, 0.02144766f, 0.04101617f, -0.00241715f, 0.05800137f, 0.00488034f, -0.07045794f, 
    -0.01236972f, 0.04881545f, 0.02332900f, 0.13553697f, 0.11653261f, -0.07444273f, 0.07691608f, 0.08339931f, 
    -0.02665968f, 0.00168516f, -0.02992145f, 0.09323335f, 0.03120728f, 0.00428254f, 0.06680399f, -0.00389826f, 
    -0.05747154f, -0.16391467f, 0.04289768f, -0.02186062f, 0.01985131f, 0.01913377f, -0.02146110f, 0.00719153f, 
    0.05126779f, -0.03980701f, 0.12780353f, -0.12310208f, -0.11263164f, -0.01849629f, 0.05669684f, 0.05291983f, 
    -0.03305326f, -0.05080286f, -0.16743217f, -0.15476997f, 0.17407149f, 0.09402625f, -0.04050571f, 0.06731974f, 
    -0.11318062f, -0.00690481f, -0.02964998f, 0.02837970f, -0.03722676f, -0.03091158f, -0.02088113f, -0.01902587f, 
    -0.01821706f, -0.00188628f, -0.02653721f, 0.05256644f, -0.13003860f, -0.09140868f, -0.10755289f, 0.03835252f, 
    0.03202371f, -0.00255066f, -0.01200239f, -0.02959988f, -0.07329544f, 0.00676596f, 0.03997115f, 0.08837239f, 
    -0.18497112f, 0.05418576f, -0.26783374f, -0.16938339f, 0.04874009f, 0.06268888f, 0.05507567f, 0.07117316f, 
    0.09255356f, 0.10236014f, 0.13268918f, 0.06107258f, -0.03744184f, 0.07106843f, -0.05033417f, 0.09834037f, 
    -0.05404644f, 0.11161151f, 0.03162043f, -0.02636694f, 0.05268028f, -0.04266460f, -0.01326175f, -0.03752237f, 
    -0.06486002f, -0.10998487f, 0.14041840f, 0.20821455f, 0.13034736f, 0.01973779f, 0.05264375f, 0.12781791f, 
    0.04573661f, 0.03236007f, -0.15902317f, -0.04556352f, -0.24561749f, -0.19885021f, 0.01475436f, 0.17913486f, 
    0.01787778f, 0.11962327f, -0.01662078f, 0.07797649f, 0.04059180f, -0.08502878f, -0.03515450f, -0.04704743f, 
    -0.54859716f, 0.16745389f, 0.09287073f, 0.23968790f, -0.08389209f, -0.00201634f, 0.08169772f, 0.12067501f, 
    0.02107513f, 0.11038505f, 0.01532383f, -0.01715759f, -0.01638410f, -0.21409982f, 0.29914334f, 0.06407420f, 
    0.20188800f, 0.16650744f, -0.17983222f, 0.12483736f, -0.02896509f, -0.08864819f, 0.01453612f, -0.01513682f, 
    -0.24184753f, 0.37084723f, 0.00490280f, -0.00755075f, 0.07770912f, -0.10565922f, -0.00107113f, 0.00367549f, 
    -0.00584433f, -0.01710307f, 0.17614077f, 0.24838786f, -0.00213298f, 0.00306037f, -0.18716335f, -0.01196557f, 
    0.02185669f, -0.05002756f, -0.05829610f, -0.11220632f, -0.03947145f, 0.15928614f, 0.01375078f, 0.19629951f, 
    0.17659546f, -0.06445824f, 0.02567481f, 0.17935362f, 0.05922289f, 0.00172412f, 0.00601066f, 0.07035016f, 
    0.00456467f, 0.09563766f, -0.04780163f, -0.09847321f, -0.05435795f, 0.08636205f, -0.29557663f, -0.05130689f, 
    0.00863786f, -0.04411887f, 0.10102250f, 0.04990661f, -0.11248109f, 0.06850856f, -0.20084569f, -0.03555351f, 
    -0.11318915f, -0.10923155f, -0.14635730f, -0.06365747f, 0.09366369f, 0.16906033f, 0.17706576f, 0.11622149f, 
    0.15489842f, -0.01715481f, 0.04098631f, -0.03091832f, -0.08786225f, 0.19454880f, -0.03833045f, 0.00197422f, 
    0.01195865f, -0.01283139f, -0.02887495f, -0.03157291f, 0.03008229f, 0.05848936f, 0.06159440f, 0.29169348f, 
    0.07469223f, 0.05347931f, -0.02253478f, 0.00589050f, 0.12286882f, 0.01729736f, 0.05091339f, 0.16218394f, 
    -0.03857119f, 0.04547910f, -0.12301072f, 0.13670917f, -0.00014406f, -0.00247126f, 0.09170607f, 0.17922965f, 
    -0.01457609f, -0.00262956f, 0.00444225f, -0.15039256f, 0.04188626f, 0.01166994f, -0.00360465f, 0.06623075f, 
    0.09352134f, -0.02124448f, -0.05616876f, -0.10680937f, -0.01373139f, -0.05504690f, -0.03586562f, -0.09580015f, 
    -0.07167725f, 0.05894577f, 0.16047212f, 0.10060584f, -0.00809504f, -0.06319577f, 0.24411707f, 0.12958330f, 
    0.04802014f, -0.04590534f, -0.10033772f, -0.04845981f, -0.04221258f, -0.00773565f, 0.07666709f, 0.02784746f, 
    -0.00560656f, 0.11861508f, 0.24943049f, 0.09522450f, 0.00509929f, 0.11488122f, -0.00363673f, 0.08750077f, 
    -0.00055642f, 0.05645616f, 0.15067963f, -0.02889056f, 0.02958256f, 0.11816496f, 0.34536511f, 0.00658903f, 
    0.00461527f, 0.05820026f, -0.03061631f, 0.11179835f, 0.01947528f, -0.07871252f, -0.05334568f, -0.08010432f, 
    0.21111470f, -0.08771899f, -0.11453488f, 0.01862974f, 0.14082620f, 0.04702007f, 0.02282097f, 0.05628881f, 
    0.00177159f, -0.02523957f, -0.11092974f, -0.16238123f, 0.24680667f, -0.05266423f, 0.03001211f, 0.19064887f, 
    0.02024943f, -0.08648105f, 0.03873473f, -0.10913908f, -0.13904041f, -0.03351298f, -0.16027957f, 0.01215356f, 
    -0.10710592f, -0.18270144f, -0.11662374f, 0.09788998f, 0.07676125f, 0.01240895f, 0.07416021f, 0.03088983f, 
    -0.02946124f, 0.00171282f, -0.05040690f, -0.01089062f, -0.08029880f, 0.06308252f, 0.03101750f, 0.01752755f, 
    -0.05739870f, 0.01070034f, -0.00314881f, 0.03588904f, 0.02517961f, 0.05894273f, 0.05446910f, 0.05837584f, 
    -0.05407598f, -0.04662352f, -0.06413436f, -0.13969941f, -0.07533200f, 0.02623084f, -0.05523755f, 0.02184715f, 
    0.06620949f, 0.11190336f, -0.00724440f, -0.00144560f, 0.20160371f, -0.10625347f, -0.09625775f, 0.03378705f, 
    0.08203579f, -0.09389157f, 0.17364776f, -0.01916908f, 0.04942121f, 0.06096410f, 0.11046130f, 0.05279976f, 
    -0.06765162f, -0.10199382f, -0.05690149f, -0.05803037f, 0.00037252f, 0.04701738f, 0.02603867f, 0.03670118f, 
    -0.06884614f, 0.02093237f, -0.05095401f, 0.03846101f, -0.02647858f, 0.11851311f, 0.03186029f, 0.07172502f, 
    0.03910689f, -0.01014472f, 0.08437859f, 0.06735180f, 0.01577522f, 0.12891075f, 0.00071497f, 0.01169508f, 
    -0.05903398f, -0.02708168f, 0.17426616f, 0.02058144f, 0.12101934f, -0.03921724f, 0.03012032f, 0.05200133f, 
    -0.07870204f, 0.05576624f, -0.02366151f, -0.13212770f, -0.08484144f, -0.02215438f, -0.07403953f, 0.10416614f, 
    0.07729717f, 0.18174648f, 0.02423482f, 0.13838315f, 0.09396501f, 0.03310914f, -0.06686532f, -0.09328213f, 
    0.02805502f, -0.00552480f, -0.02714626f, -0.00776613f, 0.01681414f, -0.02358221f, -0.01039063f, -0.02101482f, 
    0.02096377f, -0.01622748f, 0.00066155f, 0.01781399f, -0.02172216f, 0.03639691f, -0.00932401f, -0.00499979f, 
    -0.00314875f, 0.02459294f, -0.03585517f, -0.02946847f, 0.01884863f, -0.00273517f, -0.03130273f, -0.01840357f, 
    -0.01709523f, 0.02019012f, -0.00413717f, -0.01177406f, 0.01326395f, 0.02299499f, -0.00739740f, -0.00414140f, 
    -0.03811542f, -0.02208767f, -0.01671010f, 0.02437824f, -0.00042345f, 0.02462821f, 0.03321363f, -0.01391085f, 
    -0.00435434f, -0.00408162f, -0.00368433f, -0.00781303f, -0.00524636f, -0.00927789f, -0.02186361f, -0.01501251f, 
    -0.00434383f, 0.02250366f, -0.01228149f, -0.02773837f, -0.01555282f, 0.01780639f, 0.01584099f, 0.01727472f, 
    0.01809283f, 0.01198372f, -0.02596070f, 0.01333254f, -0.02516652f, -0.02837814f, -0.00567208f, -0.01779272f, 
    0.01357252f, 0.00443784f, 0.01028992f, -0.01570138f, 0.02342401f, -0.00871035f, -0.02765532f, 0.00573801f, 
    0.00354716f, 0.02640152f, 0.01042037f, 0.02189408f, -0.01793091f, -0.01884961f, -0.02786576f, -0.00335156f, 
    -0.00233910f, -0.01710339f, -0.03493832f, 0.00172419f, -0.02625053f, 0.03510250f, 0.02630594f, -0.02292514f, 
    -0.01392225f, -0.03067074f, -0.00282680f, 0.00955613f, 0.02469506f, -0.02242850f, 0.00818742f, 0.02054892f, 
    0.02905711f, 0.00081746f, -0.00892153f, -0.03438883f, 0.00863353f, -0.04532378f, 0.00783117f, 0.01208400f, 
    -0.04298261f, 0.02302999f, 0.01233606f, 0.01297684f, 0.00119306f, -0.03384162f, -0.03229586f, 0.02831234f, 
    0.00520654f, -0.03286316f, 0.01835666f, 0.01694003f, -0.00143267f, 0.00128959f, -0.01756062f, -0.03758067f, 
    0.02784493f, 0.02349799f, -0.01167492f, 0.00788122f, -0.02465319f, 0.02264168f, -0.00350343f, -0.00359542f, 
    -0.01113285f, -0.03115708f, 0.03660185f, -0.03300978f, -0.02877936f, -0.00346767f, -0.00082779f, -0.02344632f, 
    0.02163351f, -0.03307366f, -0.00527289f, 0.00198316f, 0.02725516f, 0.00300544f, 0.01318004f, 0.00366312f, 
    0.00066855f, 0.00016687f, 0.02045664f, 0.01872578f, -0.00325453f, -0.00037750f, -0.03500440f, -0.02082349f, 
    0.03003830f, 0.03754365f, -0.01181044f, 0.03233071f, -0.00373239f, 0.01055442f, 0.02050906f, -0.01274424f, 
    -0.02312486f, -0.03528798f, -0.01599951f, -0.03414572f, 0.00236175f, -0.03588061f, -0.01165830f, -0.02676113f, 
    -0.01894409f, -0.02357642f, 0.00527651f, 0.01167296f, -0.01528450f, 0.02412102f, -0.01165531f, -0.01624842f, 
    -0.02357418f, -0.01036600f, 0.01536396f, -0.00851955f, 0.02375907f, -0.01254537f, 0.02284411f, -0.03991839f, 
    -0.00824642f, 0.00972851f, -0.03702855f, 0.02137655f, 0.01846259f, -0.01333228f, 0.01400254f, -0.01198127f, 
    0.02357397f, 0.01575980f, 0.01767972f, 0.02278215f, -0.01162505f, 0.02313363f, -0.00384104f, 0.03055356f, 
    -0.03367919f, 0.00323242f, 0.03044452f, 0.00614508f, -0.00208655f, -0.00157780f, -0.03337753f, -0.03148511f, 
    0.01284790f, 0.02944690f, -0.02604086f, -0.01286232f, 0.02801200f, -0.02271612f, 0.01445219f, 0.00815742f, 
    0.00777797f, 0.00821391f, -0.00586948f, -0.03109282f, 0.00641452f, -0.00455390f, -0.03795689f, 0.00984855f, 
    0.03075044f, 0.00511238f, 0.02283100f, 0.02879637f, 0.02549278f, -0.00472095f, 0.03024999f, 0.00527916f, 
    -0.01718600f, -0.00834626f, 0.01050401f, -0.00464036f, -0.02477746f, -0.00446168f, 0.00674713f, 0.02919290f, 
    -0.03384998f, 0.02640429f, -0.03683919f, -0.02330499f, 0.02973246f, 0.02238944f, -0.01122348f, 0.02089544f, 
    0.00865148f, -0.00875983f, -0.01964183f, -0.03742408f, -0.02880826f, -0.03653080f, -0.03414973f, 0.01073821f, 
    0.03123288f, -0.03583780f, -0.01467597f, -0.01054783f, -0.02341129f, -0.01670155f, 0.00457362f, 0.02488329f, 
    -0.01498514f, -0.00797087f, 0.02855079f, -0.00621329f, 0.02828890f, -0.00572498f, 0.00400416f, -0.02336798f, 
    0.01379630f, -0.02266580f, -0.01097212f, -0.00730595f, -0.01427111f, -0.00324309f, 0.02423299f, 0.01279449f, 
    0.01153794f, 0.02739299f, 0.01447694f, 0.00200936f, -0.00874771f, 0.00444191f, -0.03870491f, 0.02220008f, 
    0.01198546f, 0.01531828f, -0.01874070f, 0.00044022f, 0.00734020f, 0.02571739f, -0.00641673f, 0.00125661f, 
    0.01352801f, -0.01535554f, -0.03731944f, 0.00433856f, 0.02862835f, -0.03430812f, 0.01872574f, 0.02018545f, 
    0.01201453f, 0.02879653f, 0.02011505f, -0.03068493f, -0.02146445f, 0.01964348f, 0.00848341f, -0.00356471f, 
    -0.03858525f, -0.00072039f, 0.00433669f, 0.00466219f, -0.01801070f, 0.03481852f, -0.03482942f, -0.00791296f, 
    0.02736029f, -0.02577136f, -0.03253562f, 0.01791549f, -0.02648490f, 0.02643117f, -0.01357765f, -0.03118164f, 
    -0.03104813f, -0.00457215f, 0.00006361f, 0.02341527f, -0.00553415f, -0.04090852f, -0.01674079f, -0.00807179f, 
    -0.03579836f, 0.03082485f, -0.00677472f, -0.02074879f, -0.03315996f, -0.00172275f, -0.00432655f, -0.00443841f, 
    0.02226532f, -0.02202999f, -0.02839238f, -0.01390921f, -0.01347113f, -0.02781953f, -0.02053628f, -0.00583554f, 
    -0.01532224f, -0.03126773f, 0.02369226f, 0.01049703f, 0.02877392f, 0.02661080f, 0.00534268f, -0.02541562f, 
    -0.04357919f, -0.03200034f, 0.00429428f, 0.02531207f, -0.02856473f, -0.02980828f, -0.02432997f, 0.00856488f, 
    -0.01518294f, -0.03309538f, -0.01655941f, -0.03167558f, -0.01191569f, -0.01681735f, -0.01400379f, 0.02048386f, 
    -0.01820766f, -0.01388603f, -0.03687355f, -0.00537255f, -0.03815309f, 0.00214370f, -0.00489477f, 0.00938013f, 
    0.00415868f, -0.02912297f, -0.01788796f, -0.03002548f, -0.03734524f, 0.02748472f, 0.01188703f, 0.02720653f, 
    -0.01699120f, 0.01432195f, -0.00707240f, 0.01973044f, -0.01530214f, -0.02726533f, 0.00585313f, -0.02023499f, 
    -0.01549847f, 0.03491338f, 0.03196499f, -0.01363117f, 0.02323502f, 0.01978453f, -0.02806232f, 0.03176780f, 
    -0.00528349f, -0.00142860f, 0.03616619f, -0.00108278f, -0.01455190f, -0.02078524f, 0.02156117f, 0.00882268f, 
    -0.02277049f, -0.03551927f, -0.01793596f, 0.02240528f, 0.03402255f, -0.00277196f, -0.01144344f, 0.02625193f, 
    0.03506117f, -0.01394393f, -0.01467288f, -0.00998918f, 0.01127022f, -0.01215284f, -0.01208142f, 0.02239589f, 
    -0.02038188f, -0.03635225f, -0.03517159f, 0.02072694f, -0.00600406f, -0.02480013f, 0.00976067f, -0.01368795f, 
    0.01510359f, -0.00968194f, -0.01382852f, 0.01908838f, -0.02399684f, 0.02336191f, -0.03792313f, 0.01742582f, 
    -0.03079594f, 0.00445990f, -0.00179456f, -0.03916502f, -0.04183415f, -0.02389870f, 0.00618530f, 0.02738914f, 
    -0.01528147f, -0.02411315f, 0.00031768f, 0.02485092f, -0.03587797f, -0.00503367f, -0.01863593f, 0.00390053f, 
    0.01329067f, 0.00961377f, -0.00897466f, -0.01827042f, 0.01865490f, 0.00132000f, -0.01574855f, 0.02698267f, 
    -0.01120561f, -0.00084936f, -0.02578030f, 0.02498496f, 0.00701215f, -0.04053331f, 0.01807070f, -0.00213350f, 
    0.00258124f, 0.00589562f, -0.02997230f, 0.02962929f, -0.02651277f, -0.00718559f, 0.00301730f, -0.02850319f, 
    0.02120580f, 0.02213036f, -0.00437591f, -0.03395761f, 0.01505832f, 0.02998158f, 0.00213176f, 0.01656222f, 
    -0.03088916f, -0.03134569f, 0.00127038f, 0.00052307f, -0.03397620f, 0.01972513f, 0.00172538f, 0.01451216f, 
    -0.03682118f, 0.01717811f, -0.04118497f, 0.01710696f, 0.00344986f, 0.02803136f, -0.02024728f, 0.02060205f, 
    -0.00802343f, -0.04088658f, -0.01514610f, 0.01213549f, -0.01303945f, -0.01845970f, 0.02969378f, 0.01442507f, 
    -0.02337843f, -0.00404564f, -0.01583593f, 0.01490901f, 0.01603141f, 0.03036423f, 0.02180298f, -0.00664943f, 
    -0.02699074f, -0.00149264f, 0.01159026f, -0.00719903f, -0.00623610f, 0.01853919f, -0.03246091f, 0.01937996f, 
    0.02533091f, 0.00504907f, -0.00646454f, -0.01949641f, -0.01391016f, -0.00814352f, -0.00802551f, -0.03957037f, 
    -0.01307458f, 0.00381747f, -0.00733484f, 0.01053584f, 0.01754410f, -0.01214241f, -0.02345795f, 0.00396694f, 
    -0.03480604f, 0.00570034f, 0.02542944f, 0.02952261f, 0.01883428f, -0.03523661f, 0.01525000f, -0.03065296f, 
    0.02429680f, 0.01828123f, 0.01810607f, -0.03527332f, -0.02096263f, -0.03210668f, 0.01698606f, -0.03444832f, 
    -0.03523603f, 0.00331645f, -0.01940552f, 0.02992871f, -0.00391279f, 0.01589273f, 0.00863876f, -0.00543036f, 
    0.01759008f, -0.03875101f, -0.01914052f, 0.01404220f, 0.00278754f, -0.01502244f, -0.03030381f, -0.00727686f, 
    0.00385505f, 0.01834861f, 0.02567695f, -0.00107613f, -0.01814699f, -0.02315156f, 0.00764275f, -0.01288287f, 
    -0.00371656f, -0.03185198f, 0.00225886f, 0.00348805f, -0.00379415f, -0.02542502f, 0.00544886f, -0.02638909f, 
    -0.03980580f, -0.01035132f, -0.02243214f, 0.00680105f, -0.02158944f, -0.02940188f, -0.02932323f, -0.02652495f, 
    -0.01026467f, -0.04124942f, -0.01744361f, -0.03556438f, 0.02652848f, -0.03591963f, -0.03863715f, -0.01136146f, 
    -0.04598099f, 0.00717101f, -0.00093485f, 0.00590540f, -0.01854861f, -0.03559207f, -0.00246209f, -0.00261850f, 
    0.01404808f, -0.01587805f, -0.01062102f, -0.04278217f, 0.02341811f, 0.01337343f, 0.00429196f, 0.01469906f, 
    0.02062676f, -0.03450042f, 0.02477463f, -0.02406998f, 0.00095149f, -0.03446311f, -0.00038978f, -0.03136663f, 
    -0.02657982f, 0.02000277f, -0.03312924f, 0.02886173f, -0.02864612f, -0.03397846f, 0.01047197f, -0.00545235f, 
    -0.03281166f, 0.00688513f, -0.01936672f, -0.03861053f, 0.01036403f, 0.02880323f, -0.01083606f, -0.03309421f, 
    0.00359615f, 0.01887123f, -0.02330484f, 0.00130482f, -0.00999253f, -0.01716430f, -0.03984011f, -0.03068751f, 
    -0.01370848f, -0.01221090f, 0.00130568f, -0.01727024f, -0.01175631f, -0.03564457f, -0.01109971f, -0.01036814f, 
    0.00613566f, 0.02490181f, -0.02282415f, 0.00608981f, -0.00904682f, -0.01362956f, -0.02380428f, 0.01427452f, 
    -0.03173568f, -0.00362917f, -0.03067297f, 0.00359178f, -0.04160286f, -0.00174673f, -0.04177322f, 0.02753900f, 
    -0.00380838f, 0.01487948f, -0.01004999f, -0.00466340f, -0.03824852f, -0.02799905f, -0.03561279f, 0.01806670f, 
    0.00992327f, 0.00967935f, 0.03087002f, 0.02917695f, -0.00755842f, 0.01558182f, 0.00337240f, -0.00045054f, 
    0.01743138f, 0.02992697f, 0.00750564f, -0.01688428f, -0.00386041f, 0.01987110f, 0.00622867f, -0.00337973f, 
    -0.02032786f, 0.00562959f, 0.02310612f, -0.02975993f, 0.02581068f, -0.00662513f, -0.02189884f, -0.00369222f, 
    -0.02599002f, -0.01031112f, 0.00534192f, -0.04023183f, -0.03583929f, 0.03083659f, -0.01712971f, -0.01119730f, 
    -0.00966316f, -0.01739993f, 0.01947981f, -0.02394810f, -0.00527107f, -0.02185562f, 0.00146874f, -0.01499609f, 
    -0.02732914f, 0.02964302f, -0.01353490f, -0.01290445f, -0.03106546f, -0.02997010f, -0.02613132f, 0.00359524f, 
    0.02106214f, -0.01938803f, 0.01840836f, 0.01189596f, 0.01046849f, -0.03338132f, 0.02364784f, -0.01329590f, 
    0.02067065f, -0.04177683f, -0.04037173f, 0.02784134f, -0.01032141f, 0.02585906f, -0.02877246f, 0.01370351f, 
    0.02258199f, 0.00392601f, 0.00545870f, -0.00049442f, 0.01859046f, -0.02454526f, 0.01964531f, -0.02621506f, 
    -0.02647649f, 0.01043897f, 0.13367404f, -0.08928481f, -0.03604539f, 0.13409495f, 0.24728084f, -0.12308718f, 
    -0.11768123f, 0.06248900f, 0.00896445f, 0.02836803f, -0.08647965f, -0.13260418f, 0.10235944f, 0.06160582f, 
    0.07164100f, 0.18740673f, 0.07970028f, 0.15486471f, 0.14568655f, 0.07016721f, 0.03279211f, -0.14975418f, 
    -0.14759316f, -0.23921125f, -0.07243421f, -0.03934839f, 0.08205243f, 0.13916413f, -0.01968162f, -0.01065529f, 
    0.16043124f, 0.03881399f, -0.08951052f, -0.01009113f, 0.03970678f, 0.23303829f, 0.12749699f, -0.13577747f, 
    0.19427578f, -0.02491484f, -0.00920550f, 0.12771463f, -0.09505057f, 0.02986254f, 0.13385366f, -0.03499502f, 
    0.08432101f, 0.24875309f, -0.19238633f, -0.16688310f, -0.04475844f, -0.05185363f, 0.01984849f, 0.03923693f, 
    0.08435640f, 0.02049395f, 0.05570206f, 0.06753297f, 0.34847775f, 0.21417838f, 0.31639856f, -0.06016041f, 
    -0.10194943f, -0.15413985f, 0.03728501f, -0.02662385f, -0.05065196f, -0.01997914f, -0.07377680f, -0.03550148f, 
    -0.19944088f, -0.31827608f, -0.29693410f, -0.10948928f, -0.06680154f, 0.16296953f, 0.15335678f, -0.00975582f, 
    0.01319359f, 0.03629922f, 0.12358777f, -0.03790107f, 0.30458111f, 0.18108141f, -0.09071933f, -0.07097516f, 
    0.00817756f, -0.06392752f, 0.08105002f, 0.05973763f, 0.12889557f, 0.01382125f, -0.02695895f, 0.09617961f, 
    0.09177922f, 0.12871206f, 0.07451469f, 0.02188540f, 0.02033798f, -0.10224377f, -0.09137902f, -0.11313397f, 
    -0.04214335f, -0.04412115f, 0.02131689f, 0.05763867f, -0.16534027f, 0.24143682f, 0.13686474f, 0.12525292f, 
    0.06185023f, -0.03396678f, 0.01399515f, 0.08126752f, -0.10087617f, -0.16476914f, 0.03633494f, 0.02810307f, 
    0.16438721f, -0.26079217f, -0.03691738f, 0.08824085f, 0.19038783f, 0.04050174f, -0.00084363f, -0.06131678f, 
    0.09797034f, 0.17373723f, 0.00503432f, 0.13824914f, 0.19842139f, -0.01763260f, 0.21143815f, 0.20639865f, 
    -0.04511727f, 0.03240599f, 0.16608241f, 0.00879436f, -0.07014227f, 0.06429520f, 0.12767927f, -0.08949953f, 
    -0.03917756f, -0.04787724f, -0.07881026f, -0.01424747f, 0.03354911f, -0.05350060f, 0.03190779f, 0.10047511f, 
    0.09659278f, 0.13230442f, 0.00345244f, -0.12270037f, 0.06358495f, 0.39438158f, 0.01299439f, 0.04286116f, 
    -0.15459147f, -0.09368908f, -0.00577025f, 0.21859291f, 0.09800699f, 0.04309709f, -0.07568121f, -0.06644258f, 
    -0.04527078f, 0.03041598f, 0.20543577f, 0.01013230f, 0.13827643f, -0.14643763f, -0.05877870f, 0.10493974f, 
    -0.07860488f, 0.00899058f, 0.01720033f, -0.07620346f, 0.13841149f, -0.08827083f, -0.43557110f, -0.16319340f, 
    0.06041338f, 0.10062174f, 0.02412732f, 0.00608138f, 0.06118856f, 0.10412899f, 0.18323636f, 0.08137375f, 
    0.22364728f, -0.23741393f, -0.02473887f, -0.04767530f, 0.10353491f, 0.13757007f, 0.12686099f, 0.08461100f, 
    -0.09317917f, -0.12052032f, -0.01696368f, 0.01480398f, 0.14764518f, 0.11214032f, 0.08151861f, 0.09926213f, 
    0.09747385f, 0.05432832f, 0.03107238f, 0.09274103f, -0.00687409f, -0.00636539f, 0.05401949f, 0.02838175f, 
    -0.11670871f, -0.30075616f, 0.09502933f, 0.03042589f, 0.08178734f, 0.06393363f, 0.09208212f, 0.16556653f, 
    -0.04912811f, -0.04283008f, 0.00681077f, -0.15545489f, 0.00326911f, -0.14772752f, -0.14162925f, 0.09402635f, 
    0.19739361f, 0.00753602f, -0.03072701f, -0.01453392f, -0.26442325f, 0.02938063f, 0.17727327f, 0.18477926f, 
    -0.26259711f, 0.21160011f, 0.10803380f, -0.03680665f, 0.13326228f, -0.09635364f, -0.20707382f, 0.00817333f, 
    -0.04210828f, -0.02049234f, 0.00000731f, 0.04892168f, 0.09322264f, 0.10222369f, -0.03127966f, -0.06060942f, 
    -0.05593595f, -0.06222277f, -0.03740617f, 0.05230521f, 0.04190908f, 0.04282486f, 0.02138225f, 0.00935240f, 
    -0.11310872f, 0.08532975f, 0.10868350f, -0.05175854f, -0.04669167f, 0.05776547f, -0.05627361f, 0.03416247f, 
    0.00330438f, -0.10213926f, 0.19709541f, -0.10863033f, -0.40770051f, -0.45512092f, -0.28445598f, -0.14068228f, 
    0.06764396f, 0.20670950f, 0.04575478f, 0.04916771f, 0.00020101f, -0.09126821f, -0.01773364f, -0.04784153f, 
    -0.16005893f, 0.09025230f, 0.00010709f, -0.01773605f, 0.07763205f, 0.05383161f, 0.00928513f, -0.06498414f, 
    0.09149761f, -0.00723121f, -0.02356068f, -0.06775735f, 0.13578200f, 0.03254423f, 0.08640228f, -0.17274733f, 
    0.19230793f, -0.10148146f, -0.08715320f, 0.05426084f, 0.04021299f, 0.08915269f, 0.06496844f, 0.06472158f, 
    0.09540046f, 0.03382626f, -0.06043581f, 0.04428360f, -0.00023861f, -0.00735517f, 0.02864845f, 0.06865142f, 
    0.03861289f, -0.04153540f, 0.00998499f, -0.12285610f, -0.16243051f, -0.26229370f, -0.01660049f, -0.08392458f, 
    0.02456464f, -0.03313174f, -0.00069276f, -0.00329307f, 0.20641829f, 0.02428104f, -0.10374624f, 0.11697488f, 
    0.37199032f, -0.02208858f, 0.04839413f, -0.09927253f, -0.02403691f, -0.11120968f, 0.10068189f, -0.12523799f, 
    0.13492054f, 0.03873092f, 0.06200355f, -0.07881327f, 0.06775521f, -0.16324113f, 0.05968177f, 0.06995733f, 
    0.12342703f, 0.16875251f, 0.00798636f, 0.11478817f, -0.05422048f, 0.00802516f, 0.22890259f, -0.03463357f, 
    -0.05918454f, -0.05293523f, -0.00735573f, 0.00348015f, -0.08828931f, -0.03432625f, 0.01163601f, -0.08288734f, 
    0.01711950f, 0.06352160f, 0.01321379f, -0.04417610f, 0.02086220f, 0.15206967f, -0.05933352f, -0.02132149f, 
    0.14380196f, -0.08700921f, -0.13451022f, 0.09018760f, 0.04647981f, 0.06113417f, 0.04124815f, 0.13022089f, 
    0.07009527f, -0.04502716f, -0.05458632f, -0.09562081f, 0.06636859f, 0.03300214f, 0.01262478f, 0.19782682f, 
    0.05811409f, -0.13080037f, 0.07706746f, -0.09892156f, -0.09755582f, -0.10556435f, 0.23652504f, 0.05607843f, 
    0.07015785f, 0.11808512f, -0.03820663f, -0.03074704f, 0.16552946f, 0.03810291f, -0.06553314f, -0.18392083f, 
    0.16491732f, 0.28329322f, 0.14562052f, -0.09177829f, -0.07813116f, -0.03653834f, 0.17907593f, 0.02549462f, 
    -0.03699062f, 0.02742834f, 0.01177020f, 0.04522870f, -0.00643262f, 0.22107239f, -0.05429082f, -0.24220000f, 
    0.03997726f, 0.11551300f, -0.00084248f, 0.05138243f, 0.00133647f, 0.03741704f, 0.06444690f, 0.11294701f, 
    0.09118246f, -0.00759123f, -0.18095833f, -0.25986019f, -0.10052663f, 0.09527375f, 0.06558899f, -0.03896419f, 
    0.11649220f, -0.07911071f, 0.12280802f, -0.00421521f, 0.32726410f, 0.07106972f, 0.01031555f, -0.08361764f, 
    0.14514834f, 0.04762387f, 0.13301581f, 0.02098650f, 0.13519889f, -0.00597327f, -0.02358674f, 0.04890365f, 
    -0.16018438f, -0.06182731f, 0.04923453f, 0.13549331f, 0.09698015f, 0.06193426f, 0.06435440f, 0.11438571f, 
    0.03192561f, 0.02916352f, -0.01431809f, -0.02424800f, 0.11188019f, -0.07022470f, 0.14747760f, 0.03843329f, 
    0.08064122f, 0.05119075f, 0.07663786f, 0.02139301f, 0.02863576f, 0.04359454f, 0.01160005f, 0.04078036f, 
    -0.22456563f, 0.12717980f, 0.01048444f, 0.15297247f, 0.04470520f, 0.07529192f, 0.03898361f, 0.14468063f, 
    -0.00551157f, -0.00514507f, 0.04349303f, -0.11888607f, -0.19906875f, 0.04120156f, 0.06587116f, 0.19036731f, 
    0.03184036f, 0.04684987f, -0.06072923f, 0.03222997f, -0.05577699f, -0.01330480f, 0.05022073f, 0.08127328f, 
    -0.05094863f, 0.25538695f, 0.14221929f, -0.19993074f, -0.12659669f, -0.07358527f, -0.03202473f, 0.03419134f, 
    0.06296327f, -0.11188473f, -0.01433742f, 0.12381352f, 0.22154169f, -0.22470821f, 0.23774290f, -0.14976853f, 
    -0.06934960f, -0.00465010f, -0.04681782f, -0.05732661f, 0.19114621f, 0.13583940f, 0.04736265f, 0.10673795f, 
    -0.15128033f, 0.08238789f, -0.13551752f, 0.17032154f, 0.04125187f, 0.14145373f, 0.12744090f, -0.05122059f, 
    0.06553639f, 0.08575656f, 0.13652052f, 0.11207605f, 0.07428677f, -0.01164377f, -0.17337063f, 0.12103400f, 
    -0.02457166f, -0.08973794f, 0.09095018f, -0.08547097f, -0.16012511f, 0.11201822f, 0.00833698f, -0.09685947f, 
    0.00013901f, -0.16803366f, -0.22685602f, -0.09287310f, 0.02804734f, -0.01478069f, 0.01318213f, 0.09557891f, 
    0.08358780f, -0.04808512f, -0.07194215f, -0.01718703f, -0.02710165f, 0.01669942f, 0.17628136f, -0.13995369f, 
    -0.03342949f, -0.00622265f, -0.03555386f, -0.06373785f, 0.11425543f, 0.05275751f, 0.04433129f, 0.09595478f, 
    0.09095409f, -0.01148106f, -0.07325611f, -0.11462443f, 0.05648690f, 0.00208487f, 0.05900208f, 0.06434896f, 
    0.09354154f, 0.05321094f, -0.10704064f, 0.15286355f, -0.11260235f, 0.06511865f, -0.03900944f, -0.12580039f, 
    -0.12296558f, 0.09026610f, -0.01412187f, -0.05089989f, -0.00618054f, -0.09141555f, 0.08093628f, 0.00955705f, 
    0.04418328f, 0.05720143f, 0.04546360f, -0.13105400f, -0.07122278f, -0.01822196f, -0.03324431f, -0.07203131f, 
    0.01557586f, 0.13621873f, 0.18565464f, 0.14474960f, 0.25056154f, 0.19845547f, 0.24511634f, 0.16082694f, 
    0.05370197f, -0.07347891f, -0.11443362f, -0.04028402f, -0.00933251f, 0.01826912f, 0.03282392f, 0.07558654f, 
    0.23542836f, -0.03924921f, 0.03196770f, 0.06552279f, 0.11439257f, 0.05162333f, 0.22003791f, 0.00227552f, 
    -0.01972353f, 0.08665476f, 0.10085397f, -0.12349562f, 0.07890671f, 0.18174469f, 0.07907475f, 0.02352092f, 
    -0.05499660f, -0.19580087f, -0.15852454f, -0.04355902f, -0.01658293f, -0.00406574f, 0.00241418f, 0.02746264f, 
    0.28075278f, -0.12097608f, 0.01206725f, -0.12087934f, 0.26976183f, 0.07427159f, 0.02459712f, 0.16049682f, 
    0.00804624f, -0.00274829f, -0.00951241f, -0.07967286f, -0.10759844f, 0.29920059f, -0.18054995f, -0.03958648f, 
    0.03345722f, 0.04574111f, -0.02841646f, 0.12565702f, -0.08272674f, 0.00539552f, -0.02987335f, 0.11173873f, 
    -0.09586898f, -0.15888579f, -0.03482739f, -0.05436162f, 0.08987330f, 0.09183334f, 0.09416825f, 0.02160807f, 
    -0.07164647f, -0.02845067f, -0.00606656f, -0.08078410f, 0.11969199f, 0.12214392f, 0.17192158f, 0.05338075f, 
    -0.03123721f, 0.00082663f, -0.06022348f, -0.05482672f, -0.06736439f, 0.01017960f, 0.08590695f, 0.02716350f, 
    0.01461543f, 0.02512521f, 0.00606671f, -0.01596043f, 0.00773715f, 0.02073835f, -0.06732468f, 0.04262615f, 
    -0.08739784f, 0.09404948f, -0.05227742f, -0.08528310f, 0.05068862f, 0.05491294f, -0.06495015f, -0.09695041f, 
    0.06557786f, -0.13760327f, 0.09353800f, 0.07815309f, 0.01447303f, -0.01966258f, -0.07105517f, 0.13584672f, 
    -0.18506557f, -0.29207161f, -0.45433900f, -0.16591586f, 0.01455899f, 0.03142298f, 0.06182904f, 0.03960713f, 
    0.06805786f, -0.08267001f, -0.11799841f, -0.00589405f, 0.08581231f, 0.00826523f, -0.14726454f, -0.07623832f, 
    0.11451177f, -0.11241783f, 0.15003404f, 0.09747919f, -0.05982807f, 0.04415940f, 0.01109798f, -0.14236964f, 
    0.08841535f, -0.04012593f, 0.24303380f, -0.10707778f, 0.21313044f, -0.04027725f, -0.06709558f, -0.01252184f, 
    -0.07503247f, 0.09086637f, -0.05167788f, 0.04375298f, -0.11420927f, 0.03408704f, -0.10985066f, 0.09708180f, 
    0.11769138f, 0.06485848f, 0.00277269f, -0.00521825f, -0.00710758f, -0.03110129f, -0.06776614f, 0.01236084f, 
    0.12574440f, -0.00655173f, 0.01050252f, -0.09043474f, 0.01863661f, -0.07121117f, -0.12154697f, -0.03973130f, 
    0.08516578f, -0.20188341f, -0.03584009f, 0.03518501f, 0.12103578f, 0.07897587f, -0.14090215f, -0.08486857f, 
    0.11031219f, -0.02446721f, -0.06136584f, 0.09832866f, -0.07315811f, -0.10657524f, 0.00073487f, 0.02612586f, 
    0.01723251f, 0.11015508f, 0.05472191f, -0.05535477f, 0.03525897f, 0.00912899f, 0.15760782f, 0.05641691f, 
    -0.00934249f, -0.03455665f, 0.03319597f, 0.00036092f, -0.03321870f, -0.02161025f, 0.01304638f, 0.19964884f, 
    0.09211739f, 0.08597104f, 0.12290439f, -0.02524051f, 0.01417016f, 0.01454471f, 0.04009714f, -0.01669062f, 
    0.15022227f, -0.39848197f, 0.25560775f, 0.19480582f, -0.06475849f, -0.07289060f, -0.04641561f, -0.00363334f, 
    0.07229663f, 0.09339671f, -0.11022955f, 0.01640540f, -0.17486192f, -0.30858421f, 0.01565391f, -0.01715563f, 
    0.12632857f, 0.22500515f, 0.03681557f, 0.09201053f, 0.00513148f, 0.05424782f, -0.05018209f, 0.05295923f, 
    0.25461084f, -0.14355369f, -0.06031783f, -0.02890169f, -0.01621148f, -0.07233440f, -0.11332151f, 0.10648770f, 
    -0.01859647f, -0.13037083f, -0.05355341f, -0.09823849f, -0.00966751f, -0.24953237f, 0.30430904f, 0.02445960f, 
    0.00680740f, 0.06664813f, -0.03300584f, 0.07359139f, -0.03111952f, -0.02838049f, -0.03606190f, -0.00520754f, 
    -0.32796243f, -0.25763178f, 0.06076130f, 0.10420282f, 0.13562332f, 0.04034669f, -0.01240793f, -0.00871970f, 
    0.02175174f, 0.00984881f, 0.02126610f, -0.02450948f, -0.08749580f, -0.12131798f, -0.37104076f, 0.24631220f, 
    -0.00715275f, 0.10770028f, 0.02551362f, -0.06708121f, -0.03745084f, 0.11836115f, -0.02748726f, -0.18329252f, 
    0.13528013f, 0.14934653f, 0.15585202f, 0.09002172f, 0.02765773f, 0.01525934f, 0.13184653f, -0.02824112f, 
    0.12398549f, -0.05081114f, -0.02207420f, -0.06668997f, -0.22633280f, -0.01560098f, -0.08837514f, -0.15687476f, 
    -0.01409330f, 0.04773726f, 0.02782378f, -0.04095517f, 0.06523063f, 0.02270113f, -0.10571293f, -0.04397459f, 
    0.12317586f, 0.13086249f, 0.08395816f, 0.07031974f, 0.04994855f, 0.03726622f, 0.02373441f, -0.03738265f, 
    0.06030032f, -0.08929814f, 0.03870517f, 0.03889831f, -0.13710915f, -0.20537189f, 0.12622979f, -0.00507216f, 
    0.06547606f, -0.05282855f, -0.01616658f, -0.00373604f, 0.10234798f, -0.07982672f, -0.01595683f, -0.02717056f, 
    0.05087464f, -0.14260173f, -0.41907892f, 0.00194455f, 0.13508376f, 0.05638663f, -0.09165534f, 0.10801239f, 
    -0.01816549f, 0.10421900f, 0.03954396f, 0.01014165f, -0.20663515f, 0.06229835f, 0.05180638f, 0.06125482f, 
    -0.02339943f, -0.04805484f, 0.00934295f, 0.04391659f, -0.01234485f, 0.05483237f, -0.07614331f, 0.05828591f, 
    -0.15722461f, 0.17580639f, 0.04658473f, 0.01885769f, 0.09298148f, 0.00617764f, -0.03844967f, 0.09478427f, 
    0.01868159f, 0.07460067f, -0.05215872f, -0.04272859f, -0.03969533f, 0.21090712f, 0.18565798f, 0.21796653f, 
    -0.07175799f, 0.03335180f, 0.04651885f, -0.07515924f, -0.01189599f, 0.07201670f, -0.11180988f, 0.08468030f, 
    -0.20415889f, 0.08074611f, 0.03038201f, 0.00583633f, -0.04180435f, -0.09200321f, 0.09761769f, 0.08757016f, 
    0.02394785f, -0.00124058f, -0.06171650f, -0.02368474f, 0.12917560f, 0.06793295f, 0.14221337f, 0.10141821f, 
    -0.02396769f, -0.15256521f, 0.05793300f, -0.07294483f, 0.18632038f, -0.10096429f, 0.08808287f, 0.14803211f, 
    -0.16478905f, -0.19111104f, -0.44602424f, 0.22065829f, -0.09127762f, 0.09336082f, 0.13701430f, -0.03199867f, 
    0.10459258f, 0.02178001f, -0.10694037f, 0.05581235f, -0.16321823f, -0.00814830f, -0.11300856f, -0.08771200f, 
    0.02394973f, -0.02439580f, 0.11729191f, 0.16029620f, -0.08192784f, -0.10520433f, 0.01278470f, -0.05562973f, 
    -0.04270011f, -0.07151680f, -0.43460068f, 0.19699036f, -0.06015025f, -0.03061209f, -0.06829268f, 0.09412757f, 
    -0.09756741f, -0.10926081f, -0.08356925f, 0.12404954f, 0.05974834f, 0.16742931f, 0.04446670f, -0.08651584f, 
    -0.00562393f, 0.09393339f, 0.24649177f, 0.04706319f, 0.02285010f, 0.06341588f, -0.00715699f, -0.05620339f, 
    0.02917619f, 0.01378245f, 0.06676462f, 0.02764570f, -0.05991549f, 0.04063501f, -0.06113452f, -0.02956537f, 
    0.06105931f, -0.01359305f, 0.06857499f, 0.07102711f, 0.01183946f, -0.00048087f, 0.03677078f, 0.08509497f, 
    -0.05962558f, -0.09100494f, 0.03133088f, -0.03571485f, -0.01075066f, 0.01704686f, 0.06534494f, 0.06649853f, 
    -0.14470610f, -0.13722470f, -0.14230444f, -0.05063215f, 0.00478306f, 0.00790462f, -0.00430212f, -0.03570307f, 
    -0.01038886f, -0.17394145f, -0.04850075f, -0.01577873f, 0.23877791f, 0.03684267f, -0.00467674f, -0.00251792f, 
    -0.00394156f, 0.04281742f, -0.05722721f, 0.13738051f, 0.08443844f, 0.04318432f, 0.15735364f, -0.05174867f, 
    -0.49153334f, -0.04328814f, 0.17909259f, 0.05085829f, 0.03557369f, -0.09568463f, 0.05189553f, 0.11942864f, 
    -0.06362449f, -0.09659806f, -0.14324352f, 0.07692571f, -0.06769162f, 0.19844323f, -0.05503482f, -0.09647401f, 
    -0.03032074f, -0.04792837f, 0.05406677f, 0.13579072f, 0.13029370f, 0.06768738f, -0.08052865f, 0.08207212f, 
    0.04720649f, -0.10503410f, -0.04583897f, -0.04607653f, 0.00744230f, -0.05501691f, -0.04221073f, -0.03876102f, 
    -0.03602138f, -0.02452041f, 0.06888707f, -0.03321547f, 0.00888159f, 0.11338317f, 0.07404945f, 0.13346823f, 
    0.07200968f, 0.07619316f, 0.02637047f, 0.06254636f, 0.00899833f, 0.01649700f, 0.01221391f, 0.01294308f, 
    -0.01984598f, 0.01742655f, -0.11661451f, 0.15674318f, 0.00226302f, 0.07300652f, 0.02602136f, -0.11011294f, 
    0.05343426f, 0.10322382f, -0.20275311f, 0.06885938f, -0.00407776f, -0.08647443f, -0.25367060f, -0.05709377f, 
    0.04380543f, -0.05767400f, 0.09116915f, 0.04974531f, -0.12198035f, -0.08674755f, -0.15939529f, -0.18206519f, 
    0.04916755f, 0.01050590f, 0.14088438f, 0.04611076f, 0.10391700f, 0.06463035f, 0.02734097f, -0.02771062f, 
    0.02187387f, 0.00623795f, 0.02475913f, 0.04093478f, 0.07290769f, 0.07055421f, 0.23714964f, 0.07124446f, 
    -0.00102554f, 0.03173043f, 0.09331055f, -0.04661647f, 0.03880886f, 0.04966835f, 0.02923741f, -0.07670210f, 
    0.04919967f, -0.11482559f, -0.07727217f, 0.02878147f, -0.12694201f, 0.00512889f, 0.00277216f, -0.04212119f, 
    -0.01252814f, 0.01477092f, -0.01586115f, 0.11422480f, 0.07294008f, 0.04082944f, 0.16408652f, 0.18971249f, 
    0.02333621f, 0.01259363f, 0.00790869f, 0.10607691f, 0.02249511f, 0.04244313f, -0.05552054f, 0.05028157f, 
    0.19924258f, 0.29170537f, 0.10093763f, -0.03152508f, 0.02071368f, -0.02983363f, 0.12695988f, 0.03978849f, 
    0.02235019f, 0.08022271f, -0.01537805f, 0.02277342f, 0.22178078f, 0.39708424f, 0.11065237f, -0.02170477f, 
    0.04093473f, 0.02358816f, -0.09662452f, 0.02396192f, 0.01868418f, 0.00824856f, -0.02352412f, 0.04701187f, 
    0.21688129f, 0.02517519f, -0.08421174f, -0.29623759f, 0.19259499f, 0.01388285f, 0.02352412f, -0.03629765f, 
    -0.09552634f, -0.07484943f, -0.12241610f, -0.05032649f, -0.03315772f, 0.11303306f, -0.27217156f, 0.15353072f, 
    -0.02541045f, 0.05785768f, 0.18170458f, 0.04745699f, 0.01838383f, 0.14249249f, -0.01175362f, -0.00324006f, 
    0.17410058f, -0.27306306f, -0.04606880f, -0.00087418f, 0.04275540f, 0.00442858f, -0.06741004f, -0.10184240f, 
    -0.01145461f, 0.02231993f, -0.10232390f, 0.01105726f, -0.14427894f, 0.11751616f, -0.00173191f, -0.04761657f, 
    -0.18494251f, -0.06092697f, 0.06048515f, -0.01992987f, 0.06802722f, -0.09238592f, 0.01700579f, 0.13792796f, 
    0.15060419f, 0.08299492f, 0.09018925f, 0.08302212f, -0.06612702f, 0.15574042f, 0.04628321f, -0.03499429f, 
    0.01278688f, -0.12136754f, 0.01373815f, 0.03163549f, -0.04488689f, -0.32670030f, 0.18861438f, -0.19534314f, 
    -0.03871217f, 0.00678349f, -0.16409625f, -0.00587569f, -0.15030341f, 0.01691986f, 0.27194679f, -0.11086612f, 
    -0.00503470f, 0.09655143f, 0.09614445f, 0.00675752f, -0.05001390f, 0.04703388f, -0.01360280f, -0.03353834f, 
    0.06488441f, 0.05609662f, 0.08457261f, -0.03501200f, -0.18923506f, -0.21238546f, -0.19067174f, -0.13939303f, 
    0.02035990f, -0.09143861f, -0.05057259f, 0.05487891f, -0.12297080f, -0.06234424f, 0.00402537f, -0.07970456f, 
    -0.11999594f, -0.17332326f, 0.09055964f, 0.10979695f, -0.00771350f, 0.10694336f, -0.10328121f, 0.02012383f, 
    0.02402359f, -0.03249974f, 0.25477704f, -0.17569983f, 0.12001547f, 0.11821195f, -0.05376106f, -0.01340770f, 
    0.04793115f, 0.02044989f, 0.03641081f, 0.16892831f, -0.05799272f, -0.05376565f, -0.03299494f, 0.02630688f, 
    -0.21920516f, -0.02613673f, -0.00896846f, 0.25615105f, 0.02601707f, 0.00553983f, 0.03562401f, 0.00336927f, 
    0.02177551f, -0.18182878f, -0.00019093f, 0.11536795f, -0.16999406f, -0.13292523f, -0.38133448f, 0.02159996f, 
    0.03125458f, 0.05612831f, 0.01781737f, 0.05801968f, 0.08926923f, -0.00482053f, 0.02749264f, 0.03236057f, 
    0.15050340f, -0.12187988f, -0.09962452f, -0.16456045f, 0.03438818f, -0.00713888f, -0.07076124f, 0.05528670f, 
    0.06973673f, -0.00511606f, -0.08629462f, 0.05662929f, -0.18047528f, -0.22128469f, -0.28838491f, 0.02085643f, 
    0.15241097f, 0.09007463f, 0.07660986f, 0.00501179f, 0.02596153f, 0.01431254f, -0.02815799f, 0.02242502f, 
    0.09662322f, 0.26689246f, 0.08405328f, 0.06073661f, -0.16883588f, 0.08344316f, -0.03390036f, 0.05575892f, 
    0.03758105f, 0.05684647f, -0.00127881f, 0.08572754f, -0.03274848f, 0.20078030f, 0.09806314f, -0.01628940f, 
    0.05822847f, 0.01246064f, 0.08536697f, 0.05696456f, 0.04003739f, -0.02324963f, 0.09996955f, -0.05862410f, 
    0.19418775f, 0.24879074f, 0.23555562f, 0.00920161f, 0.01292824f, 0.10529804f, 0.05318028f, 0.09134991f, 
    0.07566159f, -0.03511517f, 0.03938760f, -0.04513446f, -0.10702243f, -0.20964128f, -0.27170134f, -0.10388747f, 
    -0.03863148f, -0.02485266f, -0.00849690f, -0.03372857f, 0.00554138f, -0.03413175f, 0.02279527f, 0.08425695f, 
    -0.10870965f, -0.16420060f, -0.08645605f, -0.04549593f, 0.01028366f, -0.00929179f, 0.02798844f, -0.08975407f, 
    -0.08083086f, -0.05316358f, -0.08088810f, -0.07818297f, -0.22670093f, 0.10893252f, 0.09394661f, 0.05746370f, 
    -0.02880320f, -0.01191912f, 0.01179255f, 0.09980255f, -0.03578888f, 0.02314326f, -0.04705804f, -0.11032875f, 
    0.04560445f, 0.05805947f, -0.03014435f, -0.04865288f, 0.03617431f, -0.01509699f, 0.00420789f, 0.09926697f, 
    0.15685834f, -0.02214181f, 0.01701508f, -0.05462633f, -0.08249996f, 0.00499351f, 0.19443136f, 0.01386254f, 
    -0.06777155f, 0.01628459f, -0.10457711f, 0.11367313f, -0.01117951f, -0.04767199f, -0.15672638f, 0.12081192f, 
    0.00814013f, -0.04155821f, -0.15280437f, 0.12143450f, -0.08889803f, 0.02256201f, 0.09998227f, -0.02851261f, 
    0.08887023f, 0.06112600f, 0.00415403f, 0.04755327f, 0.09418059f, -0.07719610f, 0.17595811f, -0.09711958f, 
    -0.01023697f, 0.06744348f, 0.05724466f, 0.11224031f, 0.05286125f, -0.02534357f, 0.03594795f, 0.04919718f, 
    0.04738497f, 0.04343672f, -0.01288310f, -0.05655516f, -0.02431819f, -0.04976222f, 0.08827911f, -0.08794194f, 
    -0.08201864f, 0.01278570f, 0.09000115f, 0.03598270f, -0.14914611f, -0.08955812f, 0.15468386f, -0.03132996f, 
    0.04862432f, 0.02538810f, -0.03817321f, 0.01211255f, -0.00713467f, 0.04284301f, -0.05707579f, -0.11459617f, 
    0.18947951f, -0.03148157f, 0.03189461f, 0.21038114f, -0.01942036f, 0.16342971f, -0.07127117f, 0.08527154f, 
    0.03333027f, 0.01583893f, 0.01570155f, 0.04205626f, 0.01591188f, 0.16780175f, -0.07022537f, 0.08214886f, 
    0.05370173f, -0.06217726f, -0.09481656f, -0.02275703f, 0.06644282f, 0.05346039f, -0.02281955f, -0.00665174f, 
    0.17892586f, 0.35063219f, -0.06255763f, -0.22002089f, -0.08413037f, -0.08024626f, -0.03014253f, 0.09804241f, 
    0.10952792f, -0.00630999f, 0.13066089f, -0.02123700f, -0.09758669f, 0.09582509f, 0.06093218f, 0.16860399f, 
    0.02235423f, 0.00085639f, 0.00919435f, 0.02372956f, -0.05758470f, -0.04379793f, 0.04820351f, -0.00768597f, 
    0.05914813f, 0.04822045f, 0.24377190f, -0.08989058f, 0.00545775f, 0.11165118f, 0.06140057f, -0.17761986f, 
    0.22759435f, 0.01922234f, -0.00019351f, 0.08490292f, 0.23916292f, 0.16665563f, -0.30704230f, 0.06979314f, 
    0.00546171f, -0.11521403f, 0.12905608f, 0.06350419f, 0.22950378f, -0.02981981f, -0.01331873f, 0.05640041f, 
    -0.06316676f, -0.11582552f, -0.16757588f, -0.00330683f, 0.09774362f, -0.03366963f, 0.03463192f, -0.00500603f, 
    -0.01167109f, -0.03318219f, -0.03880924f, 0.14156879f, -0.21540053f, 0.14721425f, -0.12343558f, 0.11229121f, 
    0.09735826f, -0.13691150f, -0.23017815f, 0.03198940f, 0.08370128f, -0.09949943f, -0.05419798f, 0.11996535f, 
    0.00051413f, 0.04108755f, -0.09051103f, -0.19211699f, 0.03879813f, 0.14530383f, 0.05913515f, -0.08912645f, 
    -0.03007255f, 0.11936385f, 0.00596588f, 0.05435370f, -0.23683204f, -0.11681525f, 0.01996969f, 0.07563981f, 
    -0.01065428f, 0.05272374f, -0.08751622f, 0.00702266f, -0.16542682f, -0.03514345f, 0.11557294f, 0.02681778f, 
    0.09441186f, -0.06075126f, -0.24582838f, 0.04269932f, 0.06204908f, -0.04302159f, 0.07520687f, -0.01481099f, 
    -0.03291658f, 0.00348533f, -0.13440609f, -0.08206956f, -0.01243071f, 0.15251309f, -0.05787353f, -0.05528207f, 
    -0.04097162f, -0.04225878f, -0.08600613f, 0.18612392f, 0.03588790f, 0.04787315f, 0.07649463f, -0.09786185f, 
    -0.34684053f, 0.09961527f, 0.14944108f, -0.10397789f, 0.10357633f, -0.00958268f, -0.00067256f, 0.02036264f, 
    0.01181246f, -0.02220663f, 0.00779391f, 0.03920112f, 0.22918223f, 0.01046818f, -0.13277940f, -0.08674069f, 
    0.04058996f, -0.06590263f, 0.06170558f, 0.12453254f, -0.07417761f, -0.05243705f, 0.09614884f, -0.06005641f, 
    0.03813624f, -0.15075718f, 0.09617250f, 0.12414044f, 0.10378600f, 0.25311476f, 0.18734844f, -0.08475207f, 
    0.02790514f, -0.03815800f, 0.08223737f, 0.04337392f, 0.08003354f, 0.07317867f, 0.05234976f, -0.03365046f, 
    0.09355929f, 0.22480412f, -0.00595015f, 0.07863712f, -0.04626648f, -0.06689978f, 0.15251313f, 0.03525304f, 
    0.15294284f, -0.07174664f, 0.04577052f, 0.20677845f, 0.06174725f, 0.16152065f, 0.03308795f, -0.04366159f, 
    -0.06150828f, 0.02055338f, -0.03735543f, 0.10572407f, -0.10593402f, -0.13727856f, -0.30423182f, -0.08411518f, 
    0.11061633f, -0.01964884f, -0.11999922f, 0.02696420f, -0.07507962f, 0.21291912f, -0.13831449f, -0.01861210f, 
    -0.41517985f, -0.07290860f, -0.19295140f, -0.05537969f, 0.12404951f, -0.14133978f, -0.24487673f, -0.17178565f, 
    -0.05813487f, -0.02402205f, 0.06445957f, -0.05733601f, 0.36441252f, 0.05821179f, 0.32781255f, 0.16997518f, 
    0.01272458f, -0.03393336f, -0.11638853f, -0.00285777f, 0.02131781f, 0.07712693f, -0.07173463f, 0.08422498f, 
    -0.04669551f, 0.05079328f, -0.12440552f, -0.15185349f, -0.02196736f, 0.00038072f, -0.10229842f, 0.13496915f, 
    0.06474094f, -0.03444625f, 0.07500939f, -0.09749083f, 0.01048034f, -0.24499007f, -0.02430689f, 0.00555793f, 
    0.06939329f, 0.23347393f, -0.05569263f, 0.10230813f, 0.05481744f, -0.10377178f, -0.02485184f, 0.13859241f, 
    -0.06091388f, -0.12260454f, -0.07364191f, -0.05015377f, 0.10178009f, -0.00197193f, -0.03500339f, 0.00688475f, 
    0.05248015f, 0.05334607f, 0.07818957f, -0.02856897f, 0.17794016f, 0.21085548f, 0.10903466f, -0.14949983f, 
    0.04931889f, 0.02819443f, -0.10341192f, 0.12978733f, 0.03283753f, 0.05401656f, -0.07828430f, -0.04752921f, 
    -0.03296847f, 0.04030210f, 0.00225466f, 0.03202773f, -0.00374935f, -0.00768055f, -0.03977393f, 0.09356131f, 
    -0.13564134f, 0.08713187f, 0.00813793f, -0.12606855f, 0.05751963f, -0.01211710f, 0.00304396f, 0.06135355f, 
    -0.06550013f, 0.05341728f, 0.03086671f, -0.07511128f, 0.04423956f, 0.18015765f, -0.04695221f, -0.02003513f, 
    0.45745224f, 0.09224740f, -0.07508191f, -0.17218123f, -0.07523471f, -0.02997105f, 0.05279110f, -0.06430719f, 
    0.01715926f, 0.10318501f, 0.02718190f, -0.01353331f, -0.01496208f, -0.01666395f, -0.13149381f, 0.17436184f, 
    0.15473126f, 0.18050215f, -0.18455099f, 0.00123978f, -0.05973826f, -0.17358297f, 0.16843678f, -0.11660627f, 
    -0.04312987f, -0.14138936f, 0.01540900f, -0.16197251f, -0.11994610f, -0.05475378f, -0.18491152f, 0.12909642f, 
    -0.02152800f, 0.02349461f, 0.06444675f, 0.00667374f, 0.07439779f, 0.08654257f, 0.05912883f, 0.05722525f, 
    0.06165412f, 0.00301956f, 0.08672402f, -0.08823703f, -0.03701289f, -0.03424536f, 0.12941605f, 0.03317013f, 
    -0.21006376f, -0.06878800f, -0.06941684f, -0.08477521f, 0.05900026f, 0.12564398f, -0.09861532f, 0.01218395f, 
    -0.03216618f, -0.07776681f, 0.11094593f, -0.06568976f, -0.16470610f, 0.04027793f, -0.02745195f, 0.02884714f, 
    0.01845763f, -0.00633055f, -0.03610144f, -0.03065131f, 0.13729288f, 0.01149872f, 0.00061892f, 0.00747796f, 
    0.06850346f, 0.18805912f, 0.06391385f, -0.07055391f, 0.06396919f, 0.02003292f, 0.06982183f, 0.13844141f, 
    -0.02976793f, -0.02114841f, -0.04079779f, 0.03135531f, 0.02165195f, 0.28759864f, -0.06140868f, -0.18710741f, 
    0.04996606f, -0.06334248f, 0.04499878f, 0.10748996f, -0.02713829f, 0.00850102f, -0.02018110f, 0.12023892f, 
    0.24981818f, -0.00769833f, 0.03999305f, -0.33701679f, -0.04862634f, -0.05521184f, -0.06389669f, 0.07862028f, 
    -0.01116060f, 0.06147566f, 0.03019463f, -0.04670200f, 0.08291428f, 0.04746915f, -0.00079109f, -0.02752135f, 
    0.12329978f, 0.14871772f, -0.02702053f, 0.00178711f, 0.07675242f, -0.07262225f, 0.04581538f, 0.02789963f, 
    0.09519199f, -0.17221075f, -0.01816649f, 0.14200826f, 0.17607363f, 0.06284899f, -0.05925691f, 0.15667170f, 
    -0.00257679f, 0.03297834f, 0.09300067f, 0.03105739f, -0.07812155f, -0.14242619f, 0.10011762f, 0.13056938f, 
    0.11062705f, 0.10867003f, 0.16527860f, -0.15299441f, -0.03414582f, -0.05407167f, 0.01005960f, -0.00778417f, 
    -0.20787221f, -0.22560503f, 0.21173188f, -0.15398009f, -0.15178704f, 0.03717889f, -0.09641313f, 0.00635903f, 
    0.14401837f, -0.00583183f, -0.01081764f, -0.04209010f, -0.22799940f, 0.04127003f, 0.01872718f, 0.24437003f, 
    0.01180835f, 0.02809515f, -0.04412481f, -0.03383297f, -0.02347879f, -0.09731366f, 0.09205750f, -0.07135323f, 
    0.10428906f, 0.09020396f, 0.09821142f, -0.23401770f, -0.10683530f, -0.07879723f, -0.15445632f, 0.08485828f, 
    0.03434906f, 0.01199815f, -0.02564084f, 0.12170569f, 0.07541505f, -0.20529239f, 0.14033519f, -0.29910800f, 
    0.12319148f, -0.02119091f, -0.06832423f, 0.04753724f, 0.09030721f, 0.07141255f, 0.01560772f, 0.11822820f, 
    0.02907739f, 0.21795191f, -0.20989621f, 0.17616524f, 0.15408398f, -0.01048470f, 0.11750862f, -0.17473197f, 
    -0.04163215f, 0.18569525f, 0.01778529f, 0.03034680f, -0.10710631f, 0.14616717f, -0.14664727f, 0.21641013f, 
    0.14653704f, 0.05555611f, -0.01632172f, -0.11540415f, 0.24432120f, -0.05172776f, -0.08611178f, 0.05970566f, 
    0.11191808f, -0.22201943f, -0.18496582f, -0.06504518f, 0.08587915f, -0.01350197f, -0.09377828f, -0.01626691f, 
    0.03504052f, -0.09803126f, -0.12315845f, 0.05754139f, -0.03419780f, -0.17016296f, 0.10950412f, -0.29548600f, 
    -0.14384803f, -0.02101402f, -0.05375424f, -0.10263378f, 0.13153957f, -0.03349813f, -0.01234481f, 0.09892276f, 
    0.17298670f, -0.01463738f, -0.07307700f, -0.17146945f, -0.08938793f, -0.14060266f, -0.01709992f, 0.16505620f, 
    -0.05612499f, 0.00595728f, -0.19901662f, 0.14409311f, 0.01182837f, -0.06279778f, 0.09636413f, -0.09338254f, 
    0.03785321f, 0.01870314f, -0.04185573f, -0.15372114f, 0.01114443f, 0.02253990f, -0.03648859f, 0.03818263f, 
    -0.00699759f, 0.09126531f, 0.02831155f, -0.22488406f, 0.04285969f, -0.05044899f, 0.12143157f, 0.05744423f, 
    0.02030822f, 0.12929296f, 0.03775234f, 0.12403020f, -0.29340500f, 0.01140105f, 0.07564940f, 0.13021907f, 
    0.12683599f, -0.05066808f, -0.01732275f, 0.01535149f, -0.01035312f, -0.06092062f, 0.03148993f, 0.04913766f, 
    0.07840707f, 0.41109532f, 0.05533849f, 0.06414866f, 0.02615110f, 0.04327593f, 0.13860464f, -0.19472884f, 
    0.05046892f, -0.05009921f, 0.03660027f, 0.01193059f, -0.34327039f, 0.04323602f, -0.01898292f, 0.10522833f, 
    0.05095268f, 0.02094701f, -0.02383033f, -0.05995215f, -0.02668454f, -0.05620543f, -0.01875270f, -0.00329924f, 
    0.23957397f, -0.05171337f, -0.18465146f, -0.00309747f, 0.09826364f, 0.08404607f, 0.06772663f, 0.17909884f, 
    0.10094991f, -0.01028107f, -0.04273171f, -0.03409916f, 0.22546735f, 0.13425049f, -0.03198058f, 0.09634622f, 
    0.14087532f, -0.02248762f, -0.14413396f, -0.03057579f, -0.01913389f, 0.09254889f, -0.08203092f, 0.13847384f, 
    0.15342969f, -0.12560351f, -0.09572826f, 0.12697639f, 0.16056219f, 0.17128922f, 0.04129062f, 0.03136710f, 
    -0.11994593f, -0.07089213f, 0.00156590f, 0.00782956f, -0.22952799f, -0.10858012f, 0.02900592f, -0.02227780f, 
    0.01765167f, -0.10758127f, -0.05528049f, -0.09380207f, -0.06085048f, -0.12990016f, -0.06092760f, 0.02269684f, 
    -0.09492292f, -0.07184811f, -0.00616238f, 0.03067685f, 0.00776235f, 0.01350384f, -0.08188126f, -0.00103398f, 
    -0.10714385f, -0.03513606f, -0.03264641f, 0.05428153f, 0.19563207f, 0.08514006f, -0.07130235f, 0.05677577f, 
    -0.05153558f, 0.03634756f, 0.09109443f, 0.14862414f, 0.03837512f, 0.08195690f, -0.03088181f, 0.00230081f, 
    0.09178537f, 0.02899112f, 0.04070377f, 0.16837992f, 0.09042384f, 0.06393870f, 0.15987112f, 0.02971087f, 
    0.04790968f, -0.01081660f, -0.10433193f, 0.09809130f, 0.05817490f, 0.02279392f, -0.07467075f, 0.05326146f, 
    0.04789430f, -0.06067652f, 0.11677931f, 0.05779762f, 0.02038981f, -0.04674322f, 0.00267500f, 0.01158614f, 
    -0.12558001f, 0.01751581f, 0.06700662f, -0.35068780f, -0.07258808f, -0.02591519f, -0.10509660f, 0.10248440f, 
    -0.03052283f, 0.04662900f, 0.01548470f, -0.05830619f, -0.06506977f, -0.07429573f, -0.17245923f, -0.03345188f, 
    0.09557245f, 0.01665722f, -0.09940848f, -0.07321446f, 0.03648733f, 0.03790106f, -0.00072142f, 0.05975177f, 
    0.02752310f, 0.00478904f, -0.02332760f, 0.00158925f, 0.00684101f, -0.03293649f, 0.01612199f, -0.00526051f, 
    -0.03744372f, 0.01541004f, -0.00161132f, -0.01870067f, -0.03011141f, -0.01622685f, -0.02374677f, -0.02985281f, 
    -0.02279584f, -0.03614227f, -0.01567117f, 0.01336604f, 0.01348229f, -0.01878077f, -0.03381693f, 0.00205233f, 
    -0.02159401f, 0.02922871f, 0.00586569f, -0.00381022f, -0.01312853f, 0.00832842f, 0.00400641f, -0.03744178f, 
    -0.02172277f, -0.01168164f, -0.03491204f, -0.01534975f, 0.01239076f, 0.02548680f, -0.01929577f, 0.01512540f, 
    -0.01515980f, -0.02841897f, -0.01137628f, -0.02192559f, 0.00380441f, 0.01520428f, -0.02298774f, 0.01351289f, 
    0.01427467f, -0.02564904f, 0.02668420f, 0.00063595f, -0.01243167f, 0.02665342f, 0.02619311f, 0.02140507f, 
    0.01064854f, -0.02750455f, 0.02704038f, -0.04137493f, -0.03707043f, -0.03750481f, -0.02120268f, -0.01559287f, 
    -0.00149925f, -0.02074669f, 0.01744070f, -0.03229788f, 0.00360886f, -0.03849467f, -0.03995666f, 0.02386327f, 
    0.00671848f, 0.01563259f, 0.00404315f, 0.01754519f, -0.02708909f, 0.01665466f, -0.02361666f, -0.01388589f, 
    -0.00927801f, 0.01951866f, -0.03118826f, -0.00826488f, -0.01454480f, -0.01855867f, 0.01722138f, -0.00221715f, 
    -0.01404131f, 0.01684870f, 0.01910202f, -0.03044982f, 0.01422005f, 0.01192173f, -0.00513099f, -0.03628651f, 
    -0.03099617f, 0.01530795f, -0.01042469f, -0.02104641f, -0.00045913f, -0.03658861f, -0.03223727f, 0.01718778f, 
    0.00634219f, -0.00035073f, 0.02122237f, -0.00581325f, -0.00825211f, -0.03772094f, -0.02381634f, -0.03156158f, 
    0.02107892f, 0.02761098f, 0.00505719f, 0.00943209f, -0.03456554f, -0.00377341f, 0.02030559f, 0.00909976f, 
    -0.03859971f, -0.01356566f, 0.01313600f, -0.00811290f, -0.03055680f, -0.02973601f, -0.03737905f, 0.01962451f, 
    0.01229040f, 0.02250606f, 0.02066660f, -0.03400298f, -0.03944031f, 0.00911744f, 0.02163239f, 0.02842375f, 
    0.01330468f, 0.01584866f, -0.01340474f, 0.00221210f, -0.02714910f, 0.01725087f, 0.01616466f, 0.00913886f, 
    -0.01949587f, -0.02426976f, -0.02514609f, 0.01653779f, 0.00344532f, 0.00558547f, -0.01417377f, 0.01842146f, 
    0.01705101f, -0.03707259f, -0.00192681f, -0.00511290f, -0.01023075f, -0.04012277f, 0.02087651f, -0.02957893f, 
    0.02117554f, -0.01919177f, -0.02216427f, 0.00909110f, 0.01190901f, -0.02792763f, 0.02583100f, 0.01417026f, 
    -0.02152118f, -0.03002190f, 0.02672220f, -0.01033928f, 0.01248902f, -0.01088766f, 0.00438916f, -0.01826742f, 
    0.00756577f, -0.02459103f, 0.00257566f, -0.01142628f, 0.00579882f, 0.01058597f, -0.02092909f, 0.00817338f, 
    0.02380455f, 0.01190923f, -0.02955976f, -0.02398400f, 0.00890304f, -0.03945892f, -0.01869654f, -0.01108791f, 
    -0.00459084f, -0.02889886f, 0.01085342f, 0.02991633f, 0.01070244f, -0.02776433f, 0.00410175f, 0.02831006f, 
    0.01516794f, -0.02796345f, -0.00611963f, -0.02856182f, 0.01796090f, -0.03275983f, 0.01009980f, -0.02397632f, 
    0.00144822f, -0.00800333f, 0.02573466f, 0.02636662f, 0.02317961f, -0.00076227f, 0.02374743f, -0.02906014f, 
    -0.00563357f, -0.03680860f, 0.02620199f, -0.01564436f, -0.02038441f, 0.00775733f, -0.02658763f, -0.02627517f, 
    -0.00301416f, -0.04035753f, -0.02808166f, -0.02822391f, -0.00744898f, -0.02078748f, -0.00249555f, -0.00675315f, 
    0.01465330f, 0.02379256f, -0.01560873f, 0.02344667f, 0.00031818f, -0.02895138f, 0.00985844f, 0.00076540f, 
    0.02969103f, 0.00208000f, -0.03747377f, 0.00177142f, -0.00767019f, -0.03811070f, 0.00823639f, 0.01289723f, 
    -0.04023159f, -0.03860379f, 0.00344459f, 0.00223743f, -0.01769730f, -0.00707962f, 0.02077645f, 0.01352574f, 
    -0.03020211f, -0.02045046f, -0.03210933f, -0.01198075f, 0.02288232f, 0.01591102f, 0.02610140f, -0.02728543f, 
    0.02082013f, -0.01183981f, 0.00158349f, -0.01618962f, 0.00238091f, -0.02442398f, -0.01189712f, 0.01560474f, 
    -0.00455108f, -0.04104911f, -0.04180585f, 0.02322806f, 0.01926406f, -0.00614844f, -0.01307493f, -0.00219364f, 
    0.01305600f, 0.01739440f, -0.01263027f, 0.02472345f, -0.01005625f, 0.02644220f, -0.00270296f, 0.00969538f, 
    -0.01327610f, -0.01483478f, 0.00158165f, 0.00667698f, -0.00546065f, 0.01250576f, 0.00978662f, -0.01470577f, 
    -0.03042760f, 0.02082531f, 0.00395082f, 0.01288735f, -0.01845074f, 0.03092086f, -0.01253149f, 0.02815402f, 
    -0.03669258f, -0.03432498f, 0.00561680f, -0.00517506f, 0.00934204f, 0.01043183f, -0.01458902f, 0.03052248f, 
    -0.01067584f, -0.00687160f, 0.00826615f, -0.03082358f, -0.03489875f, -0.03375369f, 0.01981268f, -0.02413832f, 
    0.00479889f, -0.00444266f, 0.02156851f, -0.01841728f, 0.00975351f, -0.02859609f, -0.00076297f, 0.00284042f, 
    -0.01440646f, 0.02423526f, -0.00763120f, -0.00063589f, 0.00602709f, -0.04208702f, -0.02592356f, -0.01705659f, 
    0.01854798f, -0.00217688f, -0.01254226f, -0.02748270f, 0.00401567f, -0.04128880f, 0.00422422f, 0.02616251f, 
    0.01709348f, -0.03959798f, -0.00937472f, -0.03071884f, -0.03261577f, 0.00733537f, -0.03236784f, -0.00140027f, 
    -0.03186887f, 0.02229787f, 0.00194929f, -0.00944592f, 0.00733645f, 0.01526572f, 0.02351893f, 0.00954969f, 
    -0.01505526f, -0.02183421f, 0.01913702f, -0.01412491f, 0.00203511f, 0.01496943f, 0.01246681f, 0.01970946f, 
    0.00785952f, -0.03395615f, 0.02757032f, -0.00136096f, 0.02338416f, -0.00686771f, -0.01879296f, 0.02928056f, 
    0.00023635f, -0.00156111f, -0.02682856f, -0.02723169f, -0.01167132f, 0.01893648f, -0.01593423f, -0.03565038f, 
    -0.00639940f, -0.02488193f, 0.02619968f, -0.03381153f, -0.04122772f, -0.03197576f, -0.00571338f, -0.02512335f, 
    -0.01633789f, 0.01834851f, -0.01641788f, 0.02368718f, 0.02694821f, -0.00443429f, -0.03505916f, -0.01100258f, 
    0.00751403f, 0.02109243f, -0.02551004f, -0.03011477f, -0.02560769f, 0.00493520f, 0.01252997f, -0.01683461f, 
    -0.02672665f, -0.00332636f, -0.00637506f, 0.02689897f, -0.03747618f, -0.01807335f, -0.03271028f, -0.00003781f, 
    -0.02752236f, -0.01393359f, -0.01274299f, -0.02333303f, 0.02890097f, 0.02371148f, -0.00456447f, -0.00724807f, 
    -0.00613021f, 0.02128620f, -0.02238651f, -0.02566078f, -0.03224777f, -0.01140670f, -0.03621691f, -0.00026845f, 
    -0.00719409f, 0.01750533f, -0.01122812f, 0.00729958f, -0.01690799f, -0.01362902f, 0.00159911f, -0.02201565f, 
    -0.01011778f, -0.00472945f, 0.02359249f, -0.02103980f, -0.04029515f, -0.01522572f, -0.00417575f, 0.01206387f, 
    -0.00849971f, 0.01275877f, 0.01761149f, 0.02497641f, 0.00113565f, -0.04041214f, -0.01655059f, 0.01111809f, 
    0.00431946f, -0.00747373f, 0.02521216f, 0.02033240f, -0.03479593f, -0.03403669f, -0.03412531f, -0.01737883f, 
    -0.02972850f, -0.01330915f, 0.02769732f, -0.00827019f, 0.03091094f, -0.01953280f, 0.00271388f, 0.02987382f, 
    -0.01193473f, -0.00281315f, 0.02120842f, -0.02187644f, -0.03371227f, -0.03577446f, -0.03583795f, -0.01361284f, 
    0.00741022f, -0.01793097f, -0.01281316f, -0.00759731f, -0.04092904f, 0.00590637f, -0.01424096f, 0.02441687f, 
    0.00805386f, 0.02243512f, 0.00066317f, 0.00364932f, -0.02669182f, -0.01197431f, -0.02647742f, 0.02325689f, 
    0.00070219f, -0.03315312f, 0.00569862f, -0.00793541f, -0.03419418f, 0.02431242f, 0.01494023f, 0.00722309f, 
    -0.01238959f, 0.00377754f, -0.04053127f, -0.02827363f, -0.01384295f, -0.03454358f, 0.00597125f, -0.01083616f, 
    -0.03203503f, -0.01164762f, -0.03225925f, -0.04019202f, -0.02850764f, -0.02977988f, 0.00480284f, -0.03820888f, 
    -0.02451172f, 0.02242782f, -0.00196118f, -0.02874543f, 0.01509644f, -0.03177579f, 0.00006954f, -0.03735109f, 
    -0.01165362f, -0.03192110f, -0.01819547f, 0.01364443f, -0.00060252f, 0.00547689f, 0.01727818f, -0.03367843f, 
    -0.03086212f, -0.03321467f, 0.00910143f, 0.01905003f, -0.01570694f, -0.04004883f, 0.01775137f, 0.02354762f, 
    0.02679401f, -0.03078512f, 0.01869559f, -0.04024795f, 0.01672923f, -0.03602770f, 0.02184756f, -0.03118707f, 
    -0.03471078f, -0.00376572f, 0.00770261f, -0.03932369f, -0.02315401f, 0.00011195f, -0.01679288f, -0.02376252f, 
    -0.02855133f, 0.02316222f, -0.03128827f, -0.03498975f, 0.02053133f, 0.02393473f, 0.00889105f, -0.03843423f, 
    -0.03170826f, -0.01134288f, -0.01539399f, -0.02198245f, -0.03713556f, -0.03937257f, -0.03434231f, -0.01800407f, 
    -0.00885543f, -0.02274870f, -0.02271073f, -0.02965692f, -0.02216632f, 0.02751726f, -0.01924713f, 0.01258908f, 
    -0.01280840f, -0.00447615f, 0.01016019f, 0.01698031f, 0.02441958f, -0.01559243f, -0.03437764f, 0.02410175f, 
    0.00046657f, 0.00728254f, 0.01672483f, 0.03003823f, 0.02852691f, -0.02014721f, 0.00902127f, 0.01890139f, 
    -0.02103851f, -0.00472101f, -0.00575435f, 0.01114891f, 0.00361504f, 0.02680817f, 0.02463307f, -0.03942847f, 
    -0.02514690f, -0.01086733f, -0.02960677f, 0.00428630f, 0.02134072f, 0.00501443f, -0.00503071f, 0.02041647f, 
    -0.02205569f, -0.02820477f, -0.04110629f, -0.03126406f, 0.01931004f, -0.03390906f, -0.04010881f, -0.02232726f, 
    -0.02287201f, 0.00921484f, -0.01564460f, 0.02507259f, 0.02815148f, -0.03687629f, 0.00506049f, 0.02493569f, 
    -0.02560989f, -0.00801315f, 0.01334755f, -0.00850964f, -0.02552830f, 0.02403093f, -0.01294501f, -0.03035428f, 
    -0.01557335f, -0.03096305f, 0.00527125f, 0.00917492f, -0.02563835f, -0.01986795f, -0.02325065f, 0.02584824f, 
    0.02127289f, 0.02665818f, 0.02355320f, -0.02683579f, -0.00522684f, -0.00061476f, -0.01689147f, -0.03500995f, 
    -0.00512097f, 0.02218068f, -0.01384658f, -0.00843857f, -0.03490407f, -0.02961934f, -0.01116881f, 0.01370744f, 
    0.00673058f, -0.01024964f, -0.00918188f, -0.01215111f, 0.01495069f, 0.03109893f, -0.03466008f, -0.02977963f, 
    0.00691468f, -0.00605857f, -0.02149886f, -0.03143849f, -0.03867203f, -0.01657601f, -0.01667993f, 0.01309445f, 
    -0.03872241f, -0.01350280f, -0.02551167f, -0.00603006f, 0.00037847f, -0.03101279f, -0.00092750f, -0.00186667f, 
    -0.00852792f, 0.01161096f, -0.02102379f, 0.01764893f, 0.00972332f, 0.00256391f, -0.01628668f, -0.02936567f, 
    -0.01815289f, 0.02049485f, 0.00303386f, -0.01955373f, 0.02115392f, 0.01994533f, -0.00286637f, 0.01195708f, 
    -0.04051647f, -0.03993630f, -0.02956704f, 0.00535247f, -0.00331572f, 0.00147759f, -0.00905083f, -0.01796972f, 
    -0.01623395f, -0.00168457f, -0.03111029f, -0.03731712f, -0.02919025f, -0.02704750f, -0.00409891f, -0.01432678f, 
    -0.03082813f, -0.02799878f, 0.02300747f, -0.01094199f, -0.00310470f, 0.00094165f, -0.03986979f, -0.03509608f, 
    0.02772349f, 0.00595628f, 0.00621653f, -0.01923761f, -0.01069259f, -0.00974031f, 0.00514588f, -0.03760385f, 
    0.00985476f, -0.03288069f, -0.00102474f, 0.02659730f, -0.03100641f, 0.01664712f, -0.01114981f, 0.03023932f, 
    -0.02826839f, 0.02600588f, 0.00390260f, 0.00626622f, 0.00227742f, -0.04132069f, -0.02062074f, 0.02761012f, 
    0.02239272f, -0.00692835f, -0.02195706f, 0.02850898f, -0.03419983f, 0.00177231f, -0.02255757f, -0.01812895f, 
    0.01632241f, 0.01369595f, -0.02108753f, -0.01033004f, -0.04186863f, 0.00001856f, -0.01642421f, -0.04115328f, 
    0.01976141f, 0.01631325f, 0.39530274f, -0.13745095f, -0.00552804f, -0.02822530f, 0.02978966f, -0.10558749f, 
    0.17378862f, -0.01443162f, 0.05228780f, 0.03777800f, -0.00418579f, -0.08570536f, 0.06728808f, 0.10140479f, 
    -0.03463995f, 0.07831292f, 0.07989006f, 0.12614647f, 0.01529124f, 0.09249803f, -0.05685844f, 0.07499479f, 
    0.04435109f, -0.04406818f, -0.03819180f, -0.04054650f, 0.08198074f, 0.02787375f, -0.03556779f, -0.00907924f, 
    0.01637137f, 0.04260294f, -0.05890217f, 0.15110914f, 0.09074450f, 0.09293012f, -0.01891668f, 0.13003142f, 
    -0.01017080f, -0.00138416f, 0.07933839f, 0.07016604f, -0.05029257f, -0.07275258f, -0.00116972f, -0.10527734f, 
    -0.25358120f, 0.02991085f, 0.02640214f, -0.02073005f, 0.11156017f, 0.10740852f, -0.17956899f, 0.04922475f, 
    -0.04169897f, -0.01515456f, -0.07103814f, 0.01019247f, 0.15466876f, -0.04857593f, 0.32443672f, 0.13974670f, 
    0.02810052f, 0.12048509f, 0.01721871f, 0.14219856f, 0.05102991f, -0.03216194f, 0.00853345f, -0.05799695f, 
    -0.20889214f, -0.23469096f, 0.08464877f, -0.19469216f, -0.03023561f, 0.04438573f, -0.02205847f, 0.09090753f, 
    -0.07334011f, -0.02792159f, -0.00361608f, 0.01903262f, 0.08385148f, -0.04754211f, 0.08867304f, -0.05141198f, 
    0.03046398f, 0.00414846f, 0.06118523f, 0.09204913f, -0.10540261f, -0.02207430f, -0.05775859f, 0.04236143f, 
    -0.20407292f, 0.00639600f, 0.06038026f, 0.19009417f, 0.06794874f, 0.07943568f, -0.05246779f, -0.02627433f, 
    -0.06789320f, -0.03656192f, -0.07020433f, -0.15139523f, -0.37190786f, 0.57957292f, -0.18015429f, 0.29009539f, 
    0.01194268f, 0.10698232f, -0.06201513f, -0.16202368f, 0.00572173f, 0.10424653f, -0.06557656f, 0.04765975f, 
    0.23322800f, -0.11233390f, 0.23591906f, 0.11641075f, 0.10060811f, 0.05103520f, 0.05916432f, 0.08034188f, 
    -0.04677531f, 0.04332631f, 0.00958472f, -0.19613132f, -0.15868972f, 0.08572528f, 0.00729717f, 0.00213752f, 
    -0.03728460f, -0.12443198f, 0.06046703f, 0.10936036f, 0.17672573f, 0.10982651f, 0.10580754f, -0.10938715f, 
    0.11517758f, 0.16130836f, -0.04709881f, 0.09091465f, 0.04909685f, 0.08064628f, 0.01272688f, -0.07477194f, 
    0.13582245f, -0.00493896f, -0.02002556f, 0.11616460f, -0.04154560f, 0.17659235f, 0.02934863f, -0.08756924f, 
    -0.08469380f, 0.02824101f, 0.06543831f, 0.14708334f, 0.02494476f, 0.04197018f, -0.11539734f, 0.03568687f, 
    -0.02925421f, -0.04034767f, -0.12505586f, 0.09039199f, -0.04419944f, 0.03894482f, 0.07090054f, 0.01410680f, 
    0.03867327f, 0.11611168f, 0.02857603f, -0.07510251f, -0.01165798f, 0.07419308f, -0.09833971f, -0.10716525f, 
    0.13169454f, 0.06290673f, -0.10774805f, -0.04561963f, -0.02502824f, -0.01397277f, 0.05873994f, 0.05983520f, 
    0.18728909f, 0.03019208f, 0.03551615f, 0.05766023f, 0.13116129f, -0.09594212f, -0.04138121f, 0.06430995f, 
    -0.07952620f, -0.01762163f, 0.06957588f, 0.25352222f, 0.22475262f, 0.37480718f, 0.08499307f, 0.38823909f, 
    -0.05456149f, 0.07305573f, 0.12105039f, -0.00213709f, -0.06167497f, 0.02723737f, -0.02852377f, -0.13515864f, 
    -0.07889869f, 0.09318281f, 0.14408953f, 0.10811984f, -0.03288195f, -0.02477048f, 0.09494247f, -0.11470424f, 
    -0.04372189f, -0.02922739f, 0.08846945f, 0.09116010f, 0.01671824f, 0.12156668f, -0.25114202f, -0.22229324f, 
    -0.11531203f, -0.10745216f, -0.07340374f, -0.08495279f, 0.23340061f, -0.07070538f, -0.00285612f, -0.07030277f, 
    -0.68794930f, 0.30959544f, -0.36756843f, 0.16606413f, 0.14175059f, -0.00297667f, -0.06995084f, -0.09446181f, 
    0.18193725f, -0.04711562f, 0.00286757f, 0.03193351f, -0.21943100f, -0.04240167f, -0.12643304f, -0.00543145f, 
    0.04561643f, 0.05366677f, -0.01081638f, 0.08023223f, 0.00419031f, 0.07479524f, -0.02973202f, 0.18931830f, 
    -0.05882061f, 0.06890562f, -0.16149817f, 0.03427964f, -0.06832045f, 0.21532543f, 0.03103558f, -0.03436907f, 
    -0.04610818f, 0.02350918f, 0.02058993f, -0.05310269f, 0.14991513f, -0.37100211f, -0.22295704f, -0.15129077f, 
    0.16540004f, 0.05484687f, 0.03654324f, -0.05480166f, -0.11143459f, -0.00392315f, 0.03541810f, 0.02237044f, 
    -0.16481817f, 0.06252460f, -0.00491409f, -0.05429184f, -0.00548786f, 0.12637021f, -0.02149736f, -0.08656908f, 
    0.10909808f, 0.02546472f, -0.01181710f, 0.00569448f, 0.09053864f, 0.08096083f, 0.09068766f, -0.08018979f, 
    0.09645735f, -0.03990256f, 0.00943430f, 0.01704970f, 0.05743128f, -0.00711188f, 0.07729338f, 0.08742055f, 
    -0.03339180f, -0.03762055f, -0.09811309f, 0.09525870f, 0.05538531f, 0.14137959f, 0.09578771f, 0.05063647f, 
    0.17025661f, 0.06582706f, -0.01054917f, 0.02973718f, -0.01131012f, -0.12255050f, 0.05565018f, -0.17854582f, 
    -0.08197068f, -0.10732738f, -0.11728221f, -0.04458887f, -0.03619686f, 0.13472727f, -0.05012818f, -0.02066598f, 
    -0.00003016f, 0.17486155f, 0.23222750f, 0.23162949f, 0.18736079f, -0.15752289f, -0.03955233f, -0.19009483f, 
    0.05456024f, 0.05784948f, -0.02127531f, 0.03188512f, 0.04572434f, 0.02173897f, -0.20715919f, 0.14837761f, 
    0.02300043f, -0.02034084f, -0.11560072f, -0.11398847f, 0.07508543f, -0.14661621f, 0.06291569f, 0.07855167f, 
    0.20215558f, -0.25687328f, 0.13105051f, -0.27179578f, -0.16044171f, 0.13860112f, -0.00663497f, -0.00678278f, 
    0.07318361f, -0.05545466f, 0.10936239f, 0.01653524f, 0.13601567f, 0.15700735f, -0.05873010f, 0.16395792f, 
    0.07294781f, -0.06553581f, 0.03251182f, 0.08860794f, -0.05415871f, 0.04892027f, 0.09892374f, 0.02293877f, 
    -0.19316836f, 0.04153221f, -0.14051804f, -0.10243807f, -0.03891207f, 0.17618386f, -0.11957780f, 0.01784734f, 
    0.13885361f, -0.09529907f, 0.01631318f, 0.08508530f, -0.22803617f, -0.00367143f, -0.05973010f, 0.08616018f, 
    -0.06910023f, 0.07196416f, 0.05754064f, -0.13232085f, 0.08479329f, 0.01548971f, 0.04629963f, 0.10601805f, 
    0.00167416f, 0.10792422f, 0.18234318f, -0.00473837f, 0.14895013f, 0.06209137f, -0.00868448f, 0.13336092f, 
    0.03442150f, -0.04113195f, 0.08671287f, 0.07302473f, -0.00965671f, 0.05299545f, 0.16398796f, -0.03901892f, 
    0.09873002f, 0.04457823f, 0.02882737f, 0.04678239f, 0.03883922f, 0.00489225f, 0.05703768f, 0.03391479f, 
    0.18698768f, -0.12318560f, 0.00729490f, -0.30245486f, 0.01972906f, 0.03697727f, -0.04869170f, -0.05984472f, 
    -0.10427212f, 0.12378391f, 0.06258224f, -0.00385048f, 0.25723088f, 0.03969087f, 0.11888421f, 0.19174553f, 
    0.04368119f, 0.07287634f, -0.12908113f, 0.05106500f, -0.03871527f, -0.01019497f, -0.01195929f, 0.01467887f, 
    0.16375473f, 0.36618266f, 0.06168570f, 0.12291140f, -0.02259019f, 0.04163164f, 0.06797794f, 0.12779276f, 
    0.21210697f, -0.03326736f, -0.04869442f, -0.15003327f, 0.25850883f, 0.17859933f, 0.21273077f, 0.27171230f, 
    0.06529658f, 0.14813359f, 0.09968587f, 0.19297431f, -0.00863237f, 0.01577694f, -0.02693376f, -0.10389721f, 
    -0.02484450f, -0.19896118f, 0.06814396f, -0.11372240f, 0.17820035f, 0.05604222f, -0.00174892f, 0.03537636f, 
    -0.03404039f, -0.00122476f, -0.07341259f, -0.21197058f, -0.24669027f, 0.36505783f, -0.23487112f, 0.32898661f, 
    -0.06406559f, -0.01841945f, 0.06991615f, 0.01066336f, 0.07649559f, 0.02542546f, -0.05096653f, -0.04499539f, 
    0.16731279f, -0.13626446f, 0.08690524f, -0.23249492f, 0.01099473f, 0.11507353f, -0.12592129f, -0.03869465f, 
    0.00738973f, 0.01027295f, -0.04624037f, 0.04075569f, 0.12225563f, -0.19667771f, 0.35251960f, -0.19203120f, 
    -0.01650168f, -0.17904475f, -0.04302145f, -0.28988546f, 0.00898065f, 0.03994771f, -0.05828880f, 0.08365892f, 
    0.05933502f, 0.29487690f, -0.05689810f, 0.21047793f, 0.03509985f, -0.01020482f, -0.05074858f, -0.03929489f, 
    0.03942475f, 0.04943343f, 0.10475735f, -0.00021721f, -0.07870761f, -0.01339246f, -0.10528251f, -0.15366422f, 
    0.12539782f, -0.06183550f, -0.04087725f, 0.19991320f, -0.14412257f, 0.05254846f, 0.04543288f, 0.07041253f, 
    0.32009804f, -0.03394265f, -0.03424613f, -0.02014751f, 0.21973096f, 0.05265197f, -0.01181936f, -0.05268341f, 
    0.18277591f, -0.08928056f, 0.07861404f, -0.12736149f, 0.05672043f, -0.51583803f, 0.25165251f, -0.38971218f, 
    0.04659883f, -0.08372513f, -0.08452827f, -0.18980828f, -0.02795022f, -0.02755678f, -0.10620739f, 0.03743873f, 
    0.17520896f, -0.21885379f, -0.07302986f, -0.17453870f, -0.10396349f, -0.09944595f, -0.11828452f, 0.02956377f, 
    -0.12621477f, 0.07387604f, -0.11977891f, 0.16885512f, 0.04267854f, 0.18819004f, -0.07555285f, 0.02687877f, 
    0.09998029f, 0.08135144f, 0.06684151f, 0.15026420f, -0.04556493f, -0.01148945f, -0.00338333f, 0.05143177f, 
    -0.11076801f, 0.02061816f, 0.03502961f, 0.04132426f, -0.03049393f, 0.04263557f, -0.03450452f, -0.09333760f, 
    -0.05684941f, -0.08735318f, -0.01643944f, -0.04557515f, 0.04136948f, -0.13569684f, -0.03162410f, 0.20896329f, 
    -0.06223967f, -0.08562289f, -0.02336199f, -0.03461852f, -0.00014863f, -0.04658217f, -0.00856771f, -0.19119960f, 
    -0.11921035f, -0.15547286f, 0.10836605f, -0.10511686f, 0.17629540f, -0.09173153f, 0.11885020f, 0.14834023f, 
    -0.00864567f, -0.02785735f, 0.04739246f, -0.07468069f, -0.10278976f, -0.11556795f, -0.04875167f, 0.15434660f, 
    0.10113030f, -0.02100681f, 0.04459624f, 0.02875621f, 0.13048241f, -0.06307777f, -0.06286295f, -0.04676336f, 
    0.34809226f, 0.13375635f, -0.01433992f, -0.09018123f, 0.03588286f, 0.10646483f, 0.01276282f, 0.12479009f, 
    0.05990899f, 0.07626024f, -0.11777039f, -0.13227825f, 0.17706758f, 0.25148544f, -0.11514836f, -0.02044556f, 
    0.02497408f, -0.10871166f, 0.01553780f, 0.04293160f, -0.00805694f, -0.03069457f, 0.04634975f, 0.11660060f, 
    0.24096261f, 0.29598683f, 0.14704528f, 0.07761288f, 0.03511029f, 0.05501486f, 0.14932844f, 0.03727741f, 
    0.08760454f, -0.03985537f, -0.03702882f, -0.00968966f, -0.06884103f, -0.24298593f, -0.14625351f, 0.14230041f, 
    0.18899949f, 0.13785374f, 0.00081732f, 0.09121410f, 0.12579282f, 0.02701268f, 0.12458163f, 0.01839795f, 
    -0.12423027f, -0.20280723f, -0.12415785f, -0.06487731f, 0.01778991f, 0.06308923f, 0.05402527f, -0.02894249f, 
    0.08733972f, 0.11801143f, -0.06316397f, 0.04820634f, -0.05172494f, 0.02612021f, 0.06606483f, 0.02323079f, 
    0.03543370f, -0.07108482f, 0.14230292f, 0.15941688f, -0.01382243f, 0.00083444f, 0.02807854f, 0.09720113f, 
    0.32383654f, -0.08329243f, -0.11824245f, 0.13092895f, 0.14617300f, -0.03170923f, 0.08731934f, 0.00633589f, 
    0.00657788f, -0.12041817f, 0.06952636f, 0.01681393f, -0.07411885f, 0.12896836f, 0.05964567f, 0.00243699f, 
    0.08198921f, 0.00761776f, -0.05962452f, 0.12327080f, -0.06686679f, -0.06684273f, 0.03066907f, 0.14114237f, 
    0.08237150f, -0.30254942f, 0.04213146f, -0.18775974f, 0.01977688f, -0.01035454f, 0.02129577f, -0.09602435f, 
    0.07686795f, -0.06498393f, -0.07778207f, -0.03356029f, 0.02109988f, 0.06960791f, 0.20166133f, 0.06678412f, 
    0.14435597f, -0.05255524f, 0.01357614f, 0.14894575f, 0.10748734f, -0.07807209f, -0.14913285f, -0.10847648f, 
    -0.10567610f, -0.10348960f, 0.08693823f, 0.17789324f, -0.01533076f, 0.02785503f, -0.04202414f, -0.00448359f, 
    0.25522122f, 0.10241692f, 0.24998982f, 0.17989327f, 0.10981993f, -0.07818174f, 0.03790706f, 0.06828118f, 
    0.02025524f, 0.06357122f, 0.09641353f, 0.07110880f, 0.13699600f, 0.25773224f, 0.16084690f, 0.27638921f, 
    0.03296962f, 0.02875843f, 0.02211996f, 0.11993789f, -0.01135344f, -0.06787634f, -0.08140625f, -0.07551596f, 
    -0.01499697f, -0.05700367f, -0.06747047f, -0.11076543f, 0.02329161f, -0.02270185f, -0.07845900f, -0.07508755f, 
    0.03088697f, 0.03637569f, -0.01007252f, 0.02059223f, 0.01933661f, -0.00745631f, -0.08651897f, 0.01250808f, 
    -0.06250476f, 0.22610824f, -0.00676588f, -0.07227962f, 0.03035450f, 0.08535990f, -0.08422776f, 0.08401003f, 
    -0.12240553f, 0.03658258f, 0.08504078f, -0.07582503f, -0.05007843f, 0.06288242f, 0.01874978f, 0.22944617f, 
    0.13936484f, 0.22453810f, 0.10988148f, -0.07467080f, -0.09475479f, -0.15197764f, -0.06628671f, -0.08552793f, 
    -0.25630528f, 0.08082031f, 0.37570798f, 0.04956876f, -0.02992625f, 0.02629536f, 0.20862493f, -0.07716567f, 
    -0.05114400f, -0.03419296f, 0.07107769f, 0.20104858f, -0.09553784f, 0.04178238f, -0.09120008f, 0.01687496f, 
    0.04117968f, 0.00323043f, 0.13151923f, 0.14438757f, 0.06399667f, 0.05198596f, 0.07314324f, 0.05407090f, 
    -0.00945317f, 0.01930652f, -0.15078694f, -0.09017381f, 0.04644727f, 0.04333219f, 0.02458203f, -0.04301057f, 
    -0.22594990f, -0.29020774f, -0.14961371f, -0.23778297f, 0.22752050f, 0.17901357f, -0.00304910f, -0.09126144f, 
    0.01109981f, -0.10160209f, 0.07355006f, 0.02547652f, 0.02861072f, -0.03308751f, 0.01275479f, 0.05002619f, 
    -0.11898890f, -0.05500447f, 0.07282460f, 0.06021981f, -0.06099581f, -0.04188498f, 0.05646377f, 0.08279060f, 
    -0.02232700f, 0.05420205f, 0.08087417f, -0.19643125f, -0.11915464f, 0.00667970f, 0.01491491f, 0.12548012f, 
    0.12953030f, -0.09630524f, 0.13260710f, -0.07251915f, 0.12373641f, 0.13088536f, 0.09427179f, 0.08088309f, 
    -0.06185196f, -0.02731807f, -0.11261562f, 0.00734562f, 0.07478848f, 0.00673519f, 0.10745650f, -0.07879741f, 
    0.13405576f, 0.10760374f, 0.17272218f, 0.26559255f, -0.01348502f, -0.00466085f, 0.06761191f, 0.18087150f, 
    -0.00702249f, 0.10985166f, 0.07941552f, 0.11677623f, 0.03633427f, 0.06983674f, 0.06427794f, 0.03029456f, 
    0.04163459f, -0.15073492f, 0.05388226f, 0.00402380f, -0.10779750f, 0.11858319f, 0.13995530f, 0.16421781f, 
    0.06547470f, 0.03590021f, -0.12341212f, -0.04930519f, 0.07171806f, 0.23387593f, 0.22081217f, -0.00620947f, 
    -0.03377756f, -0.07947297f, -0.12550318f, -0.03976594f, 0.02374253f, -0.01084284f, 0.02120177f, 0.05506961f, 
    -0.15902084f, 0.02249771f, 0.10205358f, -0.09631594f, 0.09127172f, -0.06351151f, 0.05035495f, -0.00000661f, 
    -0.00578179f, -0.06285558f, -0.01269773f, 0.19845697f, 0.01687572f, -0.02094851f, -0.11927198f, 0.04186055f, 
    -0.03943463f, 0.03541386f, 0.03995539f, 0.05090814f, -0.02933210f, -0.01653527f, -0.08513746f, -0.21328180f, 
    0.27935541f, 0.02335298f, -0.06680329f, 0.09561861f, -0.08296546f, 0.04061636f, 0.08837666f, -0.15423737f, 
    0.13235366f, 0.04621670f, 0.13553685f, 0.21993361f, -0.01544863f, 0.10180781f, -0.18100375f, -0.26503539f, 
    -0.02373281f, 0.03113952f, 0.13961753f, 0.09820338f, 0.07641026f, 0.19099802f, -0.10318968f, -0.11404683f, 
    0.07674830f, 0.04474052f, -0.04558773f, -0.14401163f, 0.10577276f, 0.12602016f, -0.05382911f, -0.00474119f, 
    -0.02437550f, -0.25970381f, 0.01641718f, -0.20887911f, -0.12063102f, -0.10086305f, -0.00455433f, 0.21471393f, 
    0.03715204f, 0.03939967f, 0.00121309f, 0.02697315f, 0.03881555f, 0.08114966f, 0.11149182f, 0.22256877f, 
    0.08163819f, -0.01378193f, 0.09146640f, 0.00241677f, -0.07120720f, 0.14794049f, 0.04165085f, -0.03735950f, 
    -0.03274081f, 0.03159358f, -0.10106835f, -0.12262496f, 0.14429225f, 0.11391096f, 0.25702250f, 0.16413060f, 
    0.01980733f, -0.11653560f, -0.02939495f, -0.05351328f, 0.00675453f, -0.02692658f, -0.09240861f, -0.00894648f, 
    -0.05313209f, -0.10074275f, -0.04645200f, -0.01601620f, 0.01056512f, 0.07510784f, -0.04085290f, 0.16329989f, 
    -0.21181142f, -0.13685884f, -0.11527751f, -0.23289824f, 0.02872019f, -0.10255196f, -0.07216421f, -0.00932799f, 
    0.11351026f, 0.01606550f, 0.00834789f, -0.06161486f, -0.03620370f, 0.02443661f, 0.06990597f, 0.00095518f, 
    0.07780711f, 0.05132981f, 0.03135213f, 0.05514885f, -0.04595273f, -0.06199137f, 0.16830130f, 0.05991017f, 
    0.14702421f, 0.27069873f, 0.20820048f, 0.21241917f, 0.02396624f, 0.11837498f, 0.18677849f, -0.02586727f, 
    -0.10513391f, -0.09218398f, -0.09377335f, -0.10695485f, -0.14977960f, 0.03684001f, -0.00483380f, -0.07945964f, 
    0.10020463f, -0.02657090f, -0.17179354f, 0.14555128f, -0.03492492f, -0.01779509f, -0.00038201f, -0.07368039f, 
    0.04669296f, 0.06675509f, 0.07234343f, 0.07815406f, -0.02414824f, 0.19087537f, -0.08373461f, 0.03990827f, 
    0.06486310f, 0.13022383f, 0.02708916f, -0.07473727f, -0.03284461f, -0.03068406f, 0.10515710f, 0.17207755f, 
    0.09232941f, -0.03464473f, 0.04540875f, -0.10337607f, 0.02667512f, 0.09151303f, -0.03246727f, -0.12078968f, 
    -0.09399337f, -0.16036978f, -0.05163816f, -0.01963693f, -0.03943919f, -0.10969367f, -0.11544288f, -0.02155759f, 
    0.06396758f, -0.14663081f, 0.10527226f, -0.06066101f, -0.13326618f, -0.01327306f, -0.02785603f, -0.09269188f, 
    -0.02326814f, 0.05586521f, 0.06921247f, -0.08437550f, 0.08593475f, -0.00986010f, 0.00985750f, 0.08939419f, 
    0.07580656f, -0.05805646f, 0.15366733f, 0.10439178f, 0.04833391f, 0.00243558f, -0.04734223f, -0.04481411f, 
    -0.10519712f, -0.00710016f, 0.04744392f, -0.10372117f, 0.17897850f, 0.14504072f, 0.28973979f, 0.34373191f, 
    -0.17209835f, -0.16735868f, -0.06407200f, -0.00886708f, 0.01259000f, 0.03303356f, -0.03667706f, 0.10080913f, 
    0.03716478f, 0.03668807f, 0.14700456f, 0.07257761f, -0.13928628f, -0.29470882f, -0.02728859f, 0.04308055f, 
    0.08792298f, -0.07716703f, 0.00136956f, 0.01130110f, 0.01551809f, -0.04025687f, 0.02795092f, 0.01405075f, 
    0.06196134f, 0.10564394f, 0.20247586f, -0.14078359f, -0.02552578f, -0.04825321f, -0.06081346f, 0.08903525f, 
    -0.02099477f, 0.16221112f, -0.02968095f, -0.15949647f, -0.19714032f, -0.08581023f, -0.07813779f, 0.00722440f, 
    0.06465139f, 0.07655029f, -0.03553008f, -0.00670037f, -0.07412917f, -0.10557479f, -0.06053822f, -0.04372961f, 
    0.02813973f, 0.06948369f, -0.01457419f, -0.01348496f, 0.02825282f, 0.00152915f, -0.05919925f, -0.00142347f, 
    0.08636635f, -0.12924406f, -0.04404601f, -0.14121269f, -0.11937317f, -0.06049252f, 0.00358237f, 0.19532491f, 
    0.03289968f, 0.06407770f, 0.15595353f, 0.02376662f, -0.00364006f, -0.10095058f, 0.00320092f, -0.04394522f, 
    0.12718236f, 0.01534464f, 0.04992693f, -0.08182535f, -0.04537385f, -0.03272786f, 0.08509535f, -0.12111270f, 
    0.09600633f, -0.02006544f, 0.03845257f, 0.07926611f, 0.03337439f, 0.19687209f, -0.05302669f, -0.12194835f, 
    0.08854618f, -0.09175341f, 0.05683465f, 0.05299924f, -0.08784624f, -0.16339563f, -0.08437844f, -0.30958390f, 
    0.03385717f, -0.05487857f, 0.07441519f, -0.09037784f, 0.03772899f, 0.14203966f, -0.07642048f, 0.01101848f, 
    -0.03833132f, 0.04900986f, -0.04314833f, -0.03184304f, 0.17705309f, -0.11846591f, 0.05556528f, -0.00760449f, 
    0.10448232f, -0.04603309f, -0.01074504f, -0.00412393f, -0.03259863f, 0.03400423f, 0.07877175f, -0.16906111f, 
    -0.03554765f, 0.11252867f, 0.00240661f, -0.09231036f, 0.07362276f, -0.11463797f, 0.00233565f, -0.00167381f, 
    -0.03143460f, 0.00493424f, -0.06301463f, -0.22561719f, -0.23377188f, 0.26233712f, -0.12546369f, 0.02140492f, 
    0.02542540f, -0.05477487f, 0.15123963f, 0.13594863f, 0.22304441f, 0.13890484f, 0.03750141f, 0.18884780f, 
    0.10598434f, 0.00689761f, 0.05687242f, -0.00648105f, -0.03068790f, -0.20409489f, -0.06926901f, -0.07214026f, 
    -0.20686053f, -0.16592497f, -0.17592600f, -0.28260976f, 0.12820683f, -0.13807540f, 0.08754517f, -0.11341657f, 
    -0.09369258f, 0.07342145f, -0.07715631f, -0.15492962f, 0.02650188f, -0.15674825f, -0.12398858f, -0.04449052f, 
    0.11448815f, 0.08187681f, -0.07213774f, -0.01465650f, 0.04039605f, 0.03115731f, 0.05719978f, -0.10133180f, 
    -0.05308229f, 0.04483719f, -0.26846305f, 0.06496480f, -0.05550523f, -0.20060821f, -0.01847880f, 0.11153881f, 
    -0.01447957f, -0.04540966f, 0.08270600f, -0.00524950f, 0.12948161f, 0.11412883f, -0.03211036f, 0.14929087f, 
    0.13272069f, 0.02876108f, 0.01354547f, -0.14791097f, -0.03103773f, -0.02551024f, -0.04696706f, -0.02186388f, 
    -0.02294039f, 0.00391016f, -0.07639202f, -0.22746617f, -0.00003038f, 0.05665472f, 0.07642134f, -0.08895842f, 
    -0.02166244f, -0.05952770f, -0.04392448f, -0.04608588f, -0.17344107f, -0.27534065f, -0.10304864f, -0.33122110f, 
    -0.42701596f, 0.15011081f, 0.11491825f, 0.00381531f, 0.04646736f, 0.02057179f, 0.09654475f, -0.00038056f, 
    -0.03328242f, 0.01806344f, 0.04547044f, 0.08127199f, -0.02383929f, 0.02176122f, 0.04359802f, -0.05142102f, 
    0.06739072f, 0.11283325f, 0.09626882f, -0.03237167f, -0.17358257f, -0.13466594f, -0.17599256f, -0.22461784f, 
    -0.11751787f, -0.22080737f, -0.00668464f, -0.01025003f, -0.06364413f, -0.02724248f, -0.04317319f, -0.00338792f, 
    -0.08546485f, -0.02785902f, -0.21531780f, -0.19867963f, 0.00960347f, -0.25735131f, -0.13202111f, 0.05462272f, 
    0.07716040f, -0.01325888f, -0.01748473f, -0.02294442f, -0.09265183f, -0.05574949f, -0.09690018f, 0.03309628f, 
    0.06554039f, 0.09691383f, 0.00712972f, 0.01652884f, -0.09632656f, -0.15524776f, 0.04569947f, -0.00899293f, 
    0.20106679f, 0.07891337f, 0.01824406f, 0.07916182f, -0.05243561f, -0.07222781f, -0.03449934f, -0.09750126f, 
    -0.03429615f, -0.03912453f, -0.00294599f, 0.00176468f, -0.07216422f, -0.03256954f, -0.06366160f, -0.10819393f, 
    0.01965446f, -0.05171394f, -0.09140436f, -0.00563236f, -0.09284641f, -0.00016005f, 0.13565299f, 0.08350874f, 
    0.21855082f, 0.16000786f, 0.21323915f, 0.18307449f, 0.05699110f, -0.10299134f, -0.10544680f, 0.04664200f, 
    0.06218472f, 0.03143802f, 0.05495661f, 0.05436346f, 0.06423417f, 0.08645378f, 0.20444147f, 0.20143758f, 
    0.24723564f, 0.15425828f, 0.28654316f, 0.23062299f, -0.05772110f, -0.04675138f, 0.12420025f, -0.02536425f, 
    0.03716242f, 0.09133059f, 0.10310568f, 0.19810197f, -0.09073831f, -0.02345093f, -0.06280091f, 0.03674807f, 
    0.06830294f, 0.12404357f, 0.10074510f, 0.02832582f, 0.11878129f, 0.06257555f, 0.17822129f, 0.25013301f, 
    -0.03602027f, -0.10179835f, -0.04125405f, -0.20155770f, -0.00332138f, 0.10467173f, -0.04697531f, -0.04658032f, 
    -0.01137743f, -0.15870450f, -0.00178875f, -0.01068975f, 0.00086336f, 0.01498776f, 0.02506744f, -0.07094500f, 
    -0.01502467f, -0.15432981f, 0.03240071f, -0.11893489f, -0.21189685f, -0.20215206f, -0.10271159f, -0.35898480f, 
    -0.02832115f, 0.02145057f, 0.00442382f, -0.01145516f, -0.01475205f, 0.03142947f, 0.02884161f, -0.01686625f, 
    0.01035396f, -0.00603821f, -0.02194278f, -0.03359624f, -0.01738160f, 0.02954235f, 0.02788208f, -0.03281352f, 
    0.02649667f, 0.00525670f, -0.02661537f, 0.01773016f, -0.00561014f, 0.02308172f, -0.03575760f, -0.00356857f, 
    -0.03581531f, -0.03962477f, -0.02917132f, 0.01178854f, 0.02538272f, -0.03720215f, -0.02760881f, -0.03335297f, 
    -0.03664846f, -0.03509257f, -0.02188762f, -0.03384153f, 0.00015501f, -0.01695159f, -0.01833243f, 0.02577456f, 
    -0.00278835f, 0.02686462f, -0.01953625f, 0.01945280f, -0.02516226f, 0.02249699f, 0.02275594f, 0.02818142f, 
    0.00457269f, 0.00231400f, 0.02268629f, -0.02859984f, -0.02046139f, 0.03195363f, -0.00235804f, -0.02406744f, 
    -0.00385819f, 0.00757578f, 0.02125525f, -0.03757006f, 0.02716628f, 0.02950302f, 0.00790491f, -0.03621976f, 
    -0.02092063f, 0.00420584f, 0.02442961f, 0.00989195f, 0.00658703f, -0.01382424f, 0.03091295f, -0.03903059f, 
    0.00826451f, -0.02741115f, -0.02363663f, -0.00045289f, 0.01071968f, 0.00294744f, -0.03546496f, 0.02528757f, 
    0.02807658f, 0.02869186f, 0.01689563f, 0.02412102f, 0.01986173f, 0.02660513f, 0.01571268f, 0.00781608f, 
    0.00388221f, -0.02575798f, 0.03380606f, 0.02361310f, 0.01471631f, -0.02665747f, -0.00900058f, 0.03235125f, 
    -0.02143910f, 0.00246854f, 0.03428287f, -0.01912984f, 0.00186238f, 0.00864999f, -0.01362513f, -0.03883694f, 
    -0.03642179f, -0.04170482f, -0.03313281f, 0.00979676f, 0.03276654f, 0.03408354f, -0.01219525f, -0.01225924f, 
    0.00059417f, -0.01812121f, -0.00941723f, 0.00829093f, -0.00821938f, -0.01638508f, -0.01471482f, 0.02276428f, 
    -0.02071959f, 0.01911096f, 0.01302074f, -0.03131553f, 0.03069459f, 0.00895599f, -0.01025959f, 0.03346534f, 
    -0.02620981f, -0.01134108f, 0.03034980f, -0.00822632f, 0.03747053f, -0.02565703f, 0.01043704f, 0.00641570f, 
    -0.03402776f, 0.01259184f, 0.01447108f, -0.03148538f, -0.01034049f, 0.00406096f, -0.00223051f, -0.02939571f, 
    -0.02549389f, 0.00878267f, -0.01465664f, -0.02324942f, -0.01819883f, 0.01786013f, 0.03344853f, 0.01871846f, 
    -0.00887830f, 0.00939675f, -0.01754074f, 0.01150171f, 0.01186874f, -0.03196072f, -0.03783779f, -0.03277389f, 
    0.00120789f, 0.02565845f, -0.02118745f, -0.01990707f, -0.02696460f, -0.01669706f, 0.01974855f, -0.01400592f, 
    -0.00221646f, -0.03723160f, -0.02286628f, 0.02423600f, -0.02667619f, -0.00193434f, 0.03358078f, -0.01584597f, 
    -0.03764505f, -0.03275076f, 0.02961083f, 0.00723525f, 0.03028301f, 0.01816793f, -0.01816604f, 0.01390956f, 
    -0.01125330f, -0.00226829f, -0.03729596f, 0.01690136f, -0.02505759f, -0.01096197f, -0.03375346f, -0.01498616f, 
    -0.03902719f, -0.00551189f, -0.01482567f, 0.01341670f, 0.00693678f, -0.00133339f, 0.02678786f, 0.00869885f, 
    0.00565370f, 0.02199792f, 0.02310315f, -0.02428137f, -0.02199519f, 0.00968552f, 0.02576444f, -0.04040420f, 
    0.01815474f, 0.01286321f, 0.02379419f, -0.02415568f, 0.00359770f, -0.00460922f, 0.02284138f, 0.02871949f, 
    -0.02391748f, 0.01921744f, -0.02848320f, 0.02148996f, -0.02234215f, -0.01166229f, -0.02353037f, -0.01084805f, 
    -0.02777538f, -0.02431847f, 0.01894858f, -0.01988451f, 0.02239112f, -0.02842882f, 0.01534031f, 0.00752668f, 
    -0.00636908f, 0.00862693f, -0.00912264f, -0.02439996f, -0.03643358f, -0.00675650f, -0.00438209f, -0.01824722f, 
    -0.02025162f, 0.00695550f, -0.02136626f, 0.01354055f, 0.00934386f, -0.01196684f, -0.03872950f, 0.01701303f, 
    0.00102300f, -0.02911427f, 0.01481156f, -0.02913619f, 0.03534645f, 0.00979683f, -0.03088748f, -0.03279906f, 
    -0.02923176f, -0.00577890f, 0.03199465f, -0.03323698f, 0.00387321f, 0.02975619f, 0.02832214f, 0.02476769f, 
    0.02997158f, -0.01369381f, -0.02428575f, 0.02222574f, 0.00598013f, -0.00040929f, 0.00066182f, -0.04341133f, 
    -0.00225251f, -0.00079187f, -0.03481755f, -0.04183117f, 0.01696766f, 0.01450166f, -0.00728204f, 0.02331439f, 
    -0.00673894f, -0.03578158f, -0.00958157f, -0.03151916f, -0.03358186f, -0.03984238f, -0.03272294f, 0.01703390f, 
    0.00012114f, 0.00271404f, 0.02584590f, -0.01348910f, -0.02367880f, -0.01373968f, -0.03882031f, 0.02696903f, 
    -0.01503632f, -0.01982658f, -0.03390899f, 0.01683346f, 0.01242625f, -0.01098857f, -0.02196594f, -0.02042447f, 
    0.00765248f, 0.02981989f, -0.03067637f, -0.01420843f, 0.02326545f, 0.01538365f, -0.01654940f, -0.00309741f, 
    -0.00970265f, 0.00677788f, -0.02417225f, 0.00438114f, 0.02768097f, 0.00787569f, 0.02882916f, -0.02992473f, 
    0.01893831f, 0.01624909f, -0.00064002f, -0.03356237f, -0.00698074f, 0.02607415f, 0.02426735f, 0.01573682f, 
    -0.01766110f, 0.01619376f, -0.01475581f, 0.01007084f, -0.01949173f, 0.01773465f, -0.02397270f, -0.01331716f, 
    0.02038485f, -0.01916479f, 0.01721260f, -0.02008358f, -0.02555803f, -0.03252310f, 0.00163271f, 0.00292456f, 
    -0.04271385f, -0.02925233f, -0.01444653f, -0.02810513f, -0.01402050f, -0.00766887f, 0.02884537f, 0.01022861f, 
    0.01851669f, 0.00017624f, 0.03102589f, 0.02940885f, -0.00079913f, -0.03941180f, 0.00102889f, 0.02081388f, 
    0.00343911f, 0.01157470f, -0.01355350f, 0.01207499f, -0.04151042f, 0.01005220f, 0.01076216f, -0.00855108f, 
    -0.00449475f, -0.00439703f, 0.00109236f, 0.02322176f, -0.01713759f, -0.01376188f, -0.04089316f, -0.02722141f, 
    0.00865643f, -0.01252858f, -0.01922628f, 0.01280841f, -0.02628385f, 0.00730163f, -0.03333289f, 0.02320340f, 
    -0.00419186f, -0.01042506f, -0.00686504f, -0.01478046f, 0.00440103f, 0.00156561f, -0.03758742f, -0.02822353f, 
    0.01598476f, 0.00991255f, 0.01479687f, 0.01123332f, -0.00482496f, -0.02111798f, 0.03296265f, 0.01486058f, 
    -0.02551842f, -0.01918158f, 0.01167366f, -0.03871914f, 0.01321210f, -0.01959264f, -0.02852196f, -0.03434349f, 
    0.01738589f, 0.02794072f, -0.03289820f, 0.00265697f, -0.01807559f, -0.01647154f, 0.02688964f, 0.02979183f, 
    0.02182998f, -0.03712351f, -0.02797962f, -0.00003090f, -0.02685209f, -0.01594271f, -0.02368300f, -0.02177870f, 
    0.01948397f, -0.00635544f, -0.02701007f, -0.00329141f, 0.03148483f, 0.01009156f, -0.03180283f, -0.03298442f, 
    0.01253696f, 0.01537207f, 0.02342425f, -0.00270458f, -0.01868566f, 0.03051333f, 0.00161967f, -0.02306618f, 
    0.01189179f, -0.03888933f, 0.02581135f, -0.00220879f, -0.01984846f, -0.03665303f, -0.03175373f, -0.00897597f, 
    -0.01833669f, 0.00707175f, -0.01526856f, -0.02352702f, -0.01857974f, -0.03200033f, -0.03368445f, -0.03097229f, 
    -0.02515806f, 0.00461054f, -0.01520175f, 0.01229001f, -0.00519091f, 0.00056496f, 0.01352114f, -0.01962152f, 
    0.01306593f, 0.02818585f, 0.02192205f, 0.00032198f, 0.00648960f, 0.00451868f, 0.02162557f, 0.00224238f, 
    -0.00357850f, -0.00048970f, 0.01348940f, -0.03006024f, 0.01810710f, 0.01832078f, -0.03256882f, -0.01913482f, 
    0.02907768f, -0.01614771f, 0.01228796f, 0.01572984f, -0.00876511f, 0.00366272f, 0.03338745f, 0.00562283f, 
    -0.02953254f, 0.01537111f, -0.00472381f, -0.00245100f, -0.02633143f, -0.01162445f, 0.01924598f, -0.00006874f, 
    -0.02984747f, 0.00869188f, -0.02584262f, 0.02952347f, 0.02635991f, 0.02292314f, 0.02803144f, 0.02441923f, 
    0.00741505f, -0.00773033f, 0.01968864f, -0.03762472f, -0.02099977f, 0.00888396f, 0.02067475f, -0.03764965f, 
    0.00130663f, 0.00991374f, -0.01567546f, 0.00598533f, 0.00735980f, -0.02762413f, -0.00742163f, 0.01652962f, 
    -0.01033607f, 0.00166524f, -0.02531970f, 0.01291109f, -0.00584822f, -0.00881297f, -0.00527914f, 0.00842766f, 
    -0.02878748f, -0.01075762f, -0.03155769f, -0.00129954f, -0.00788447f, -0.00587646f, 0.02471031f, 0.01480576f, 
    0.00490791f, -0.03260460f, -0.03851759f, -0.03686341f, 0.01718491f, -0.02907880f, 0.02343193f, 0.02680224f, 
    0.03289054f, -0.03567735f, -0.01576160f, 0.01277690f, 0.00724973f, 0.00314815f, -0.00251977f, 0.01916465f, 
    -0.01661000f, -0.03633629f, -0.00602638f, 0.00452035f, -0.01070430f, 0.02080167f, 0.01985043f, -0.03865103f, 
    0.02780380f, -0.01308799f, -0.03130233f, -0.03652981f, 0.01389840f, 0.01210554f, 0.00125009f, 0.00953622f, 
    -0.01179804f, -0.03468072f, -0.00155967f, 0.01200012f, 0.02817963f, -0.02339300f, -0.00062557f, -0.02667896f, 
    -0.02448672f, -0.02311253f, -0.01791026f, 0.01366784f, -0.00506260f, -0.00314645f, -0.01526916f, -0.04224066f, 
    -0.00323693f, 0.01699571f, -0.02922514f, 0.02083983f, 0.00132355f, 0.01898330f, -0.02480512f, -0.03761876f, 
    -0.00139002f, 0.02158433f, 0.02226573f, -0.01863767f, 0.01961876f, 0.01989254f, -0.00089678f, 0.00563858f, 
    0.02394229f, -0.00820029f, -0.01005027f, -0.03412410f, -0.00181818f, -0.00819404f, 0.02519145f, 0.02063296f, 
    0.00933322f, 0.01407674f, -0.00998086f, -0.03104189f, -0.00861622f, 0.01562217f, -0.00520449f, 0.00404970f, 
    0.01653082f, -0.00973963f, 0.00457503f, 0.01559883f, 0.02917848f, 0.00807490f, -0.01803430f, -0.02505992f, 
    -0.04282548f, -0.02695555f, -0.03513465f, 0.01867124f, 0.01041544f, -0.03360840f, 0.01203280f, 0.01974758f, 
    0.01762280f, 0.00025077f, -0.00189078f, 0.02649642f, 0.00328072f, 0.02284180f, 0.00064416f, 0.02221677f, 
    0.02027331f, 0.02809711f, -0.02659469f, 0.00474467f, 0.00974352f, -0.00244608f, -0.02987567f, -0.04195466f, 
    -0.02842700f, 0.02111480f, -0.02817591f, 0.00391850f, -0.03958825f, 0.00222707f, 0.02369301f, 0.02707440f, 
    0.00778412f, -0.01003189f, -0.01672268f, 0.00026547f, 0.00993443f, -0.01896263f, 0.00433435f, -0.01599907f, 
    -0.01088668f, -0.03658421f, -0.03734469f, -0.00573089f, 0.02559172f, -0.03599700f, -0.02602854f, -0.00047546f, 
    0.01039119f, -0.00196369f, -0.03752416f, 0.02176755f, -0.00580706f, -0.01515243f, -0.02016102f, 0.02751409f, 
    -0.03700304f, 0.02574010f, 0.00368875f, 0.01790135f, 0.00225367f, 0.01342244f, 0.00191128f, 0.03041446f, 
    -0.01272519f, -0.02157293f, 0.01494697f, -0.01192785f, -0.02166416f, 0.00457617f, -0.02091176f, -0.03630100f, 
    0.00501753f, -0.00651185f, 0.02804245f, 0.00235384f, -0.02001737f, 0.02683264f, 0.02394781f, -0.04303911f, 
    -0.00660103f, -0.02963658f, 0.02621322f, 0.01333698f, -0.03326573f, 0.01157861f, -0.03058837f, 0.03172767f, 
    0.01040853f, -0.01155971f, -0.01985029f, 0.00764369f, -0.03516763f, 0.00492873f, 0.02418726f, 0.03583555f, 
    0.00982656f, -0.02543301f, 0.02406610f, -0.02966053f, -0.03395564f, -0.03323898f, 0.00099891f, -0.02779667f, 
    0.00008270f, -0.03620598f, -0.01961528f, -0.00555476f, -0.03180982f, 0.00653371f, -0.00581218f, -0.00511940f, 
    0.01198489f, -0.01464459f, -0.01324309f, -0.00285489f, 0.01315560f, -0.00363824f, 0.02997418f, 0.01541869f, 
    -0.01567375f, -0.00457788f, 0.03286016f, 0.00468603f, -0.02516879f, 0.00840268f, 0.01061322f, 0.02822449f, 
    -0.02036816f, -0.03017889f, -0.00404084f, -0.03271047f, -0.00286042f, 0.01195621f, -0.03758216f, 0.01281820f, 
    0.01998963f, 0.02262437f, 0.00510484f, 0.00851408f, -0.00250340f, -0.01484811f, -0.02167798f, 0.00634453f, 
    0.20299767f, 0.13474312f, -0.07390261f, -0.01974206f, -0.09128702f, 0.01991952f, -0.03428292f, 0.07548778f, 
    0.06092257f, -0.04489484f, 0.05129600f, 0.15225695f, -0.02795512f, 0.21426652f, -0.06221741f, -0.07079355f, 
    0.07382315f, -0.06057429f, -0.09170055f, -0.03242408f, 0.05099529f, -0.01775076f, 0.00852075f, 0.04299728f, 
    0.01979365f, 0.09414167f, 0.06910461f, -0.05588662f, 0.14468639f, 0.01099066f, 0.08917680f, 0.00089686f, 
    -0.02366427f, -0.03072246f, -0.09046947f, -0.10429627f, 0.19466275f, 0.09215013f, 0.25001755f, -0.03005768f, 
    0.07728300f, 0.07421923f, 0.06378955f, 0.07779119f, -0.02956273f, -0.04414666f, 0.05278361f, -0.08332106f, 
    -0.02572626f, -0.30286044f, -0.03156039f, 0.10383571f, -0.04326502f, -0.07538219f, 0.08242264f, 0.04773982f, 
    0.01786800f, 0.04896767f, -0.08331840f, -0.01896852f, 0.05678288f, 0.26386914f, 0.24741814f, -0.19388522f, 
    0.05365000f, -0.06093033f, 0.00407727f, 0.15485233f, -0.02833052f, -0.03422671f, -0.04982277f, -0.01841249f, 
    0.13462713f, 0.17821674f, -0.42934093f, 0.01277896f, 0.06671864f, 0.07385405f, -0.09601887f, 0.02021421f, 
    0.00978306f, -0.04528728f, 0.00099047f, 0.00760997f, 0.03447177f, -0.13425042f, 0.27950922f, -0.14547497f, 
    -0.03650259f, 0.12997600f, 0.03409357f, 0.03650808f, -0.03197260f, 0.04363944f, -0.02330867f, 0.00851823f, 
    -0.05831201f, 0.01527885f, 0.12051246f, 0.04676780f, 0.06148225f, -0.05443817f, -0.05205514f, 0.02067441f, 
    -0.06691439f, 0.00131194f, 0.02755671f, -0.05092053f, -0.02585819f, -0.22317946f, 0.19127326f, 0.11708707f, 
    0.07344627f, 0.10857525f, -0.06338625f, -0.17068666f, -0.09071356f, 0.11435007f, 0.06278685f, 0.06264725f, 
    0.17787854f, 0.12169943f, 0.07913614f, 0.06198515f, 0.04903483f, 0.08407845f, 0.04781520f, -0.08544374f, 
    0.04070267f, -0.06741614f, 0.00150024f, 0.05752499f, 0.16400434f, -0.00376002f, 0.08435353f, -0.10149991f, 
    -0.07867940f, 0.11816142f, -0.07255857f, 0.11045479f, 0.05705611f, 0.08642120f, 0.05082077f, 0.04899976f, 
    -0.00161641f, 0.03962021f, 0.19522536f, -0.05395284f, -0.05267355f, 0.08531975f, 0.06453565f, 0.08047403f, 
    0.00899357f, 0.01905995f, 0.07783149f, -0.05721542f, 0.04491467f, 0.04686671f, -0.03451948f, -0.12829712f, 
    0.07130487f, -0.01178707f, 0.14680304f, -0.04688777f, 0.11452402f, 0.06501350f, -0.02898246f, -0.06539597f, 
    0.15246460f, -0.01731024f, 0.05425672f, 0.04944142f, 0.20564912f, -0.01298089f, -0.14885153f, -0.01220669f, 
    0.11754599f, 0.11473266f, 0.06994511f, -0.11516368f, -0.12846643f, -0.13553070f, -0.22825378f, 0.15377282f, 
    0.09998363f, 0.03066272f, 0.07552443f, 0.02175146f, 0.04080086f, 0.13077180f, -0.08719527f, 0.05874905f, 
    0.07040121f, 0.13300470f, 0.08416147f, 0.06436218f, -0.01305342f, -0.02002513f, -0.00244335f, 0.03324216f, 
    -0.04520192f, 0.07376503f, -0.06522914f, -0.03817625f, 0.02435172f, 0.06283271f, 0.23661000f, 0.02384173f, 
    0.01158497f, 0.09889896f, -0.01917028f, -0.02852995f, -0.02966779f, 0.04339294f, -0.07237855f, 0.04738141f, 
    -0.08914894f, 0.03553927f, 0.10933428f, 0.00928076f, 0.04896763f, -0.03828891f, -0.00998305f, 0.06077563f, 
    0.01561069f, -0.00366020f, 0.03620055f, 0.00808692f, 0.06324360f, -0.10574852f, 0.35951492f, 0.08080993f, 
    0.04673605f, 0.02486949f, 0.04739932f, 0.00707461f, 0.11554593f, -0.12105895f, 0.12169297f, 0.16266778f, 
    0.16526508f, -0.15904370f, 0.22900718f, 0.15661773f, 0.04562756f, 0.08219733f, 0.03205107f, -0.06191719f, 
    0.01131177f, 0.00365193f, -0.06048503f, 0.01930968f, -0.06210074f, 0.15352812f, 0.01219360f, -0.14404003f, 
    0.00580441f, -0.05674334f, 0.11795010f, -0.00277145f, 0.00113420f, -0.03530371f, 0.03865641f, -0.07062671f, 
    -0.03121287f, -0.02333640f, -0.02627406f, 0.03872717f, 0.08526353f, -0.10829744f, -0.05409727f, -0.06491312f, 
    -0.06009244f, -0.04081154f, 0.00851116f, 0.05914323f, 0.02043891f, 0.31944650f, 0.05050750f, 0.00302020f, 
    0.02819142f, 0.11550957f, 0.09754987f, -0.11262269f, -0.05685771f, -0.12962520f, -0.00720764f, -0.15798883f, 
    0.03529172f, 0.17673761f, 0.04406519f, -0.01123217f, 0.01857591f, 0.02272024f, -0.00724591f, 0.08095754f, 
    0.08663938f, -0.10404062f, -0.03309973f, -0.01625212f, -0.06354570f, -0.06539021f, 0.04902800f, 0.13726862f, 
    -0.06875724f, 0.05169993f, 0.05762187f, 0.00777252f, -0.04689338f, -0.06822072f, 0.06814934f, -0.02821121f, 
    -0.03897585f, -0.07573661f, -0.20431350f, -0.08032396f, 0.04043606f, -0.02820927f, 0.00147312f, -0.01780313f, 
    0.07030316f, -0.00698473f, -0.01504118f, 0.09986284f, -0.12406923f, 0.02823697f, -0.11541104f, 0.03942335f, 
    0.05801710f, 0.00206311f, 0.00145490f, 0.13226108f, 0.02311258f, -0.08383308f, -0.03944694f, 0.05967833f, 
    -0.39690503f, -0.14090800f, 0.12898386f, 0.14348817f, -0.08673585f, -0.08369403f, 0.05369517f, 0.24027415f, 
    -0.07666907f, 0.02925540f, 0.09184586f, 0.12626942f, 0.07128311f, -0.02570607f, 0.25305885f, -0.11526202f, 
    0.03037023f, 0.01191058f, 0.15511413f, 0.05381582f, 0.02063345f, 0.03727833f, 0.05664713f, 0.04523361f, 
    -0.03397743f, 0.11802369f, -0.10442951f, 0.11510916f, 0.11398716f, -0.03788114f, 0.10032936f, -0.03322216f, 
    -0.09239813f, 0.01442120f, -0.11625511f, -0.01945331f, 0.01485908f, 0.04633103f, 0.03284452f, -0.01903115f, 
    0.03160879f, 0.13914113f, -0.10157546f, 0.05612882f, 0.02565155f, -0.06965064f, -0.05454225f, -0.00387556f, 
    -0.04353911f, -0.02991970f, 0.01694158f, 0.00516333f, 0.06434429f, 0.00179823f, -0.03798461f, -0.04260801f, 
    0.07497338f, 0.08052512f, -0.04459211f, 0.10068829f, -0.05638048f, -0.09002829f, -0.01702045f, 0.03116412f, 
    0.07144012f, -0.06244554f, -0.05854326f, 0.00396132f, -0.05779810f, 0.03843566f, -0.06361451f, 0.04557002f, 
    0.04177164f, 0.04459520f, -0.03887033f, -0.05229840f, 0.03388687f, -0.01507574f, 0.02906353f, -0.09040436f, 
    -0.07289252f, -0.04038488f, 0.02085580f, 0.01897732f, 0.10013992f, 0.07244169f, 0.03937327f, 0.01762540f, 
    -0.02888188f, 0.09458046f, 0.10890005f, -0.06719211f, -0.06761596f, -0.03507099f, -0.12208842f, 0.01358883f, 
    -0.24746796f, -0.02448113f, -0.23409465f, 0.19736926f, -0.01487645f, -0.00503890f, 0.13276365f, 0.00065991f, 
    -0.02685107f, -0.07445164f, -0.06125660f, 0.08356919f, 0.09298411f, 0.09066686f, 0.15329748f, 0.00180848f, 
    -0.11649257f, 0.02659818f, 0.09569518f, 0.03720259f, -0.03678145f, 0.02964719f, -0.09747246f, -0.00966359f, 
    0.05756073f, 0.12566100f, 0.13251585f, 0.02882976f, 0.04855898f, 0.03496271f, 0.10994571f, -0.06411232f, 
    0.07842325f, -0.04217777f, -0.07325878f, 0.07543654f, 0.05933485f, 0.32335287f, 0.02658417f, -0.17396279f, 
    -0.03466064f, -0.05206677f, -0.14516057f, 0.10233103f, 0.01548350f, 0.00118764f, -0.05995091f, -0.00155863f, 
    -0.07632921f, 0.20128246f, -0.17560133f, 0.03218558f, 0.06415024f, -0.07330594f, 0.14320859f, -0.02669294f, 
    -0.10682791f, 0.00873791f, 0.05200178f, 0.07307220f, 0.22472084f, -0.29739973f, 0.04598490f, -0.00128123f, 
    0.16888292f, 0.14756247f, 0.01975910f, 0.07177870f, -0.05557767f, -0.00411060f, -0.08836239f, 0.04366977f, 
    -0.14262851f, 0.04718832f, -0.09414276f, 0.24892834f, 0.13485870f, -0.18038423f, 0.07269729f, 0.01209102f, 
    0.10954897f, -0.01609461f, 0.13555348f, 0.03300825f, -0.30630791f, 0.32024044f, -0.09398631f, 0.41081199f, 
    -0.20678411f, 0.04298073f, 0.01237500f, 0.01204110f, -0.06426413f, -0.10970525f, -0.02768807f, 0.03295147f, 
    0.14423700f, -0.07188165f, 0.12704474f, -0.09892900f, -0.06852721f, 0.16795415f, -0.03925855f, 0.18189648f, 
    -0.03092642f, -0.13715206f, -0.00996926f, -0.11331969f, 0.08411851f, -0.29262292f, 0.10159101f, -0.11968385f, 
    -0.08822680f, -0.00457034f, 0.01558870f, 0.04283009f, 0.00522789f, 0.05204719f, 0.08846053f, -0.07778352f, 
    -0.19490021f, 0.20293629f, 0.08217837f, -0.00556044f, 0.00437851f, 0.05576894f, 0.10625165f, -0.04705469f, 
    0.00781144f, -0.04799418f, -0.08653744f, -0.14864029f, -0.15320565f, 0.16570188f, -0.13440748f, 0.30419469f, 
    0.01689706f, -0.03931496f, 0.08088602f, 0.09984447f, -0.05326577f, 0.00811043f, -0.00140613f, 0.05105219f, 
    -0.12482297f, -0.07674517f, 0.22449477f, 0.19467352f, 0.10376833f, 0.01908539f, 0.02821634f, 0.10836668f, 
    0.08589520f, -0.04492203f, 0.06063694f, -0.09451765f, 0.15985075f, 0.21354164f, -0.06794097f, 0.00664853f, 
    -0.02645778f, 0.09371684f, -0.01209011f, 0.01764814f, 0.00105087f, -0.03491940f, 0.05407551f, 0.05287823f, 
    -0.11641745f, -0.04335374f, 0.04519045f, 0.17933668f, 0.05140031f, -0.00503732f, -0.04773745f, -0.03547310f, 
    0.01117957f, -0.11674570f, -0.03914138f, 0.09248593f, 0.12323201f, -0.12257117f, 0.02456896f, 0.01230616f, 
    0.11018419f, 0.08378492f, -0.04612761f, 0.02606272f, -0.07840020f, 0.00012008f, -0.01662531f, 0.01112350f, 
    0.12985502f, -0.12123363f, 0.03929159f, 0.02417031f, 0.05837757f, 0.07383940f, -0.03170709f, 0.07791200f, 
    0.06726488f, -0.02402881f, 0.01338543f, 0.03038923f, 0.18973306f, 0.08193191f, 0.04178245f, -0.04502186f, 
    0.08912642f, 0.00798381f, -0.06080415f, 0.06126005f, -0.05925081f, 0.00133846f, -0.00035922f, -0.08629407f, 
    0.23277330f, 0.25313437f, 0.12554219f, -0.03893666f, -0.05474995f, 0.02249305f, 0.07112122f, 0.06018582f, 
    0.06208707f, -0.05823698f, -0.03448625f, 0.00575165f, 0.04273475f, 0.26209664f, 0.16642903f, -0.11729869f, 
    -0.04146054f, -0.01766646f, 0.04648042f, -0.04879760f, -0.07756461f, -0.15665510f, 0.02520314f, -0.05407128f, 
    0.05422317f, 0.12856704f, 0.13930468f, 0.04223301f, 0.00727243f, 0.11546714f, -0.02002373f, -0.02494494f, 
    0.17754626f, 0.06678292f, -0.02441484f, 0.03221245f, 0.12724441f, -0.03065908f, -0.04064756f, 0.10656065f, 
    -0.00045988f, 0.04009173f, -0.01345503f, 0.05899912f, -0.04856114f, -0.00183876f, 0.02004541f, 0.00217699f, 
    -0.02909134f, -0.05787470f, -0.03862188f, 0.05595963f, 0.05967849f, -0.01177610f, -0.04781422f, -0.00198912f, 
    0.17733714f, 0.06239794f, 0.00917170f, 0.06059073f, -0.03534342f, 0.14639117f, 0.05725032f, 0.03815028f, 
    -0.02484281f, -0.04469900f, 0.02653526f, 0.00521557f, -0.00964661f, 0.07042629f, -0.01628116f, -0.02185850f, 
    -0.16074263f, 0.05108267f, 0.01185514f, -0.05749938f, -0.03400633f, 0.03666753f, 0.01589721f, 0.04133915f, 
    0.13957861f, 0.00574777f, 0.01190702f, -0.04786758f, -0.02688188f, 0.01171462f, 0.18649973f, 0.01433403f, 
    -0.00119826f, 0.08598132f, 0.11051256f, -0.07153337f, 0.10413254f, 0.08809295f, -0.09884743f, 0.11890075f, 
    -0.02366327f, 0.07504407f, 0.16871804f, 0.33239856f, -0.07013679f, 0.04492846f, 0.00690947f, 0.09815136f, 
    0.06181358f, 0.02886757f, -0.06968223f, -0.08237788f, 0.17523640f, 0.02666774f, 0.01557960f, 0.02760009f, 
    -0.08790827f, 0.14750536f, 0.19176660f, 0.24899952f, -0.02990827f, -0.11339417f, -0.09815797f, 0.03319015f, 
    -0.07503487f, 0.11753353f, -0.11532774f, 0.03250467f, 0.02656489f, -0.03159690f, 0.06688982f, 0.07215896f, 
    0.04204844f, 0.02868112f, -0.07524557f, 0.12933291f, -0.27938005f, 0.09108731f, 0.04184893f, -0.12271298f, 
    0.00957778f, -0.01414759f, -0.03269986f, -0.06571728f, 0.16437685f, 0.04082376f, -0.04062617f, -0.13488343f, 
    0.10558274f, 0.03519271f, 0.19650555f, 0.15979020f, -0.12273647f, 0.03088338f, -0.10639104f, 0.17048407f, 
    0.01043381f, 0.00672190f, 0.00645324f, 0.06753292f, 0.03760467f, -0.07864062f, -0.11865308f, 0.17073151f, 
    0.01499374f, 0.00346126f, 0.11668522f, 0.12440734f, 0.00162362f, -0.04566359f, 0.00109913f, -0.02173565f, 
    -0.11052461f, 0.12296785f, 0.21444321f, 0.19188610f, -0.01480639f, -0.00728743f, -0.04551122f, 0.00749358f, 
    0.03039950f, -0.00535687f, 0.14398365f, -0.05716753f, -0.21445280f, 0.07988431f, -0.05493966f, 0.12566909f, 
    0.06896304f, -0.01260824f, 0.03839071f, 0.08623939f, -0.04285808f, -0.11417978f, -0.03047192f, -0.09772191f, 
    0.29174638f, 0.57307106f, 0.53047419f, -0.17779042f, 0.02090794f, 0.02907993f, -0.15540835f, -0.07647234f, 
    0.03276081f, 0.10176951f, 0.14582574f, 0.03991393f, 0.09638818f, 0.32902980f, -0.09532515f, 0.11310024f, 
    0.05181461f, 0.00470383f, 0.12612280f, 0.13556623f, 0.02727703f, -0.08509462f, -0.00711606f, -0.02735810f, 
    -0.02493048f, -0.11414435f, -0.04337821f, 0.12103980f, 0.07658581f, -0.04861044f, -0.09469490f, 0.00560849f, 
    -0.06458631f, -0.02479158f, -0.00423516f, 0.07872283f, -0.25008073f, -0.09047901f, 0.13043994f, -0.16005714f, 
    0.02974806f, -0.03900190f, -0.18100636f, -0.10111029f, 0.00485375f, -0.10434306f, -0.16199920f, 0.10750556f, 
    -0.22552365f, 0.32691395f, -0.26437715f, -0.33501899f, 0.05545973f, 0.05866212f, 0.02734008f, -0.06181896f, 
    -0.03431929f, 0.01015862f, -0.10701161f, 0.13959064f, -0.01931272f, 0.00877311f, -0.01940294f, 0.14326523f, 
    -0.02231868f, 0.00429385f, -0.08232839f, 0.16453183f, -0.00392248f, -0.07916504f, 0.01918559f, -0.01846323f, 
    -0.01981182f, -0.07039134f, -0.03851473f, 0.07454046f, 0.09220205f, -0.04405968f, 0.00218300f, 0.00224439f, 
    0.12913577f, 0.17699096f, -0.08877818f, -0.00580844f, 0.06399281f, 0.01264145f, 0.05739243f, -0.35640487f, 
    -0.00110363f, -0.04034590f, 0.05174601f, 0.24510968f, 0.11910202f, 0.03756122f, 0.01866535f, -0.16497545f, 
    -0.48116186f, 0.28263819f, 0.01885789f, -0.08875128f, 0.16736613f, -0.08298761f, -0.03293426f, 0.02828271f, 
    -0.01973193f, 0.03508560f, -0.05182372f, -0.08368397f, 0.11681613f, 0.07593203f, 0.22944346f, 0.07449304f, 
    0.03735219f, -0.12193758f, 0.01060954f, 0.02672495f, 0.11772615f, 0.05331273f, 0.15172118f, 0.02267168f, 
    -0.00077059f, 0.06572408f, -0.10299233f, 0.15543450f, -0.11919818f, 0.01709216f, 0.04953979f, -0.07067357f, 
    -0.07041784f, 0.06406292f, 0.02092891f, -0.07439161f, -0.15041482f, -0.03907979f, -0.12063901f, -0.41893566f, 
    0.13413797f, 0.10867155f, 0.08812618f, 0.11024521f, 0.00561946f, -0.05455208f, 0.16184804f, 0.04664746f, 
    0.16959284f, 0.10865394f, -0.03788982f, 0.19160256f, -0.00735484f, -0.03238388f, 0.00980089f, 0.02245669f, 
    -0.03886967f, -0.05326425f, -0.09284988f, 0.16502304f, 0.02923561f, -0.01949072f, -0.24115400f, 0.34129772f, 
    0.15782216f, 0.07385618f, -0.10873919f, -0.15305696f, 0.09052003f, 0.07145924f, 0.03811845f, 0.32423714f, 
    -0.11303177f, -0.01629615f, 0.03051859f, -0.16852230f, 0.08557982f, -0.31302303f, -0.03100314f, 0.05308805f, 
    -0.01154186f, -0.00269721f, -0.10622705f, 0.00714010f, 0.24172151f, -0.01487583f, 0.34680998f, 0.12350322f, 
    -0.02477588f, -0.05663100f, -0.09424033f, 0.07622906f, -0.01595599f, -0.01363817f, -0.07084275f, 0.13600172f, 
    0.03035736f, 0.12611243f, -0.00718130f, -0.11990209f, 0.17078066f, -0.12640211f, 0.04219650f, 0.12413274f, 
    0.13801543f, 0.05856127f, 0.10586590f, 0.12315496f, -0.10424090f, 0.14435731f, 0.12263188f, -0.01462253f, 
    0.00799424f, 0.11677021f, -0.09915536f, 0.10318770f, -0.19263668f, -0.04672469f, 0.08879554f, 0.07784816f, 
    0.04707291f, -0.17136818f, -0.05237778f, -0.05852616f, 0.16815659f, 0.08087976f, -0.02427209f, 0.16700646f, 
    0.06495056f, 0.02298298f, 0.07050570f, 0.11226825f, -0.10594206f, 0.07850937f, 0.17631485f, 0.10558024f, 
    -0.09837495f, 0.10676716f, -0.08232169f, 0.11004455f, -0.01208065f, 0.01664510f, -0.01016638f, 0.00533356f, 
    0.02776704f, -0.04633054f, 0.01520883f, -0.05731298f, -0.02625699f, -0.05077760f, -0.09941538f, 0.05758272f, 
    0.02825095f, 0.04669755f, 0.03854490f, -0.10673977f, 0.17055903f, 0.32883334f, 0.14069429f, 0.06620891f, 
    -0.01041863f, 0.01443426f, -0.17570870f, -0.09139717f, 0.10087751f, 0.06059508f, 0.06448823f, 0.09731971f, 
    -0.06407795f, -0.02051014f, -0.06093892f, 0.18304792f, -0.06941148f, -0.03788043f, -0.07791710f, -0.06149822f, 
    0.03535891f, 0.04524862f, -0.02847050f, 0.02946172f, 0.30915707f, 0.17792454f, 0.08122891f, 0.16620518f, 
    0.07479942f, 0.03886369f, -0.05295967f, 0.11066623f, 0.14595902f, 0.00131240f, 0.11516657f, -0.07089057f, 
    -0.15194266f, -0.18374456f, -0.02540385f, -0.09880281f, 0.06146201f, -0.12483184f, -0.20602676f, -0.04268992f, 
    0.07795909f, 0.10134174f, -0.08114381f, 0.05592078f, -0.03785939f, -0.16321290f, -0.01055849f, -0.13374509f, 
    0.03169997f, 0.13708818f, 0.05027855f, 0.00283561f, -0.01346122f, 0.03230067f, 0.10252507f, 0.00110500f, 
    0.01821543f, -0.00070345f, -0.09134880f, -0.10440969f, 0.03694065f, 0.06851511f, 0.01654968f, -0.01345440f, 
    0.13774958f, 0.17700148f, 0.00834309f, -0.02151809f, -0.09839786f, 0.13401181f, -0.11869870f, 0.02511409f, 
    -0.06759995f, -0.04536190f, -0.03245749f, -0.07173636f, 0.09631458f, 0.05251588f, -0.12933560f, 0.03757954f, 
    -0.23371646f, -0.11666747f, -0.07951098f, -0.19753711f, 0.00524040f, 0.04593387f, 0.03857909f, 0.06460234f, 
    0.02170921f, -0.05658234f, -0.07842781f, 0.09013153f, -0.29325372f, 0.02469086f, -0.16721524f, -0.34329188f, 
    -0.00692371f, 0.09051167f, 0.02447948f, 0.19916807f, 0.00874417f, 0.02476073f, -0.01034886f, 0.04262536f, 
    0.01492826f, -0.02141702f, 0.20553194f, -0.02155218f, 0.07064773f, 0.11957642f, -0.10765658f, 0.01448474f, 
    -0.01261622f, 0.00602497f, 0.12033705f, 0.04587114f, -0.26957342f, -0.01051970f, -0.17818041f, -0.11220177f, 
    0.06269050f, 0.05507346f, -0.01803636f, 0.13009292f, -0.07208433f, -0.07185338f, 0.02969666f, -0.06796543f, 
    0.21257882f, -0.04997508f, -0.20285851f, -0.16718282f, -0.00752874f, 0.08562231f, 0.03673062f, 0.21269174f, 
    0.01848724f, 0.15000375f, -0.04027573f, -0.00981994f, -0.49511427f, -0.43045664f, -0.27422470f, -0.19877656f, 
    0.12415034f, -0.06018727f, -0.01118811f, -0.20173684f, 0.04849469f, -0.05013217f, 0.00978382f, -0.03853300f, 
    -0.32816350f, -0.13926025f, 0.23804423f, -0.08016504f, 0.04979699f, 0.09463176f, -0.16130023f, -0.02713075f, 
    0.07246056f, 0.05507389f, 0.02689126f, 0.11320958f, -0.20398100f, -0.15549386f, 0.11468084f, -0.17552869f, 
    0.13433421f, 0.16100924f, -0.01231887f, -0.11497735f, -0.00044523f, -0.02196748f, -0.05008135f, 0.13335204f, 
    0.07704657f, 0.13290721f, 0.17875540f, 0.14758426f, 0.08852183f, 0.01419720f, -0.17266986f, 0.09442332f, 
    0.01446919f, -0.00981516f, 0.15270908f, -0.00450910f, -0.05755169f, -0.00835479f, 0.16117451f, 0.15570132f, 
    -0.10532375f, -0.00642304f, -0.02479274f, -0.11566809f, -0.00353792f, 0.17974247f, -0.04281445f, 0.13590823f, 
    0.04941112f, 0.10748216f, -0.10223009f, -0.03107666f, 0.05636726f, 0.15660173f, 0.01988630f, -0.07656547f, 
    0.04989404f, 0.04308291f, -0.00992311f, 0.14775239f, -0.10899352f, 0.01697673f, -0.18847498f, -0.07474738f, 
    -0.04120774f, -0.04958306f, -0.13993602f, -0.07280805f, 0.06519666f, 0.01073433f, -0.01847150f, -0.15343075f, 
    -0.13104425f, -0.33245361f, -0.06084663f, 0.05429976f, 0.02887929f, 0.04883021f, -0.14163455f, 0.06342433f, 
    0.01593298f, -0.03452548f, -0.04489104f, -0.07419680f, -0.12692183f, 0.23771279f, -0.04667520f, 0.02754762f, 
    -0.11994351f, -0.03550499f, -0.06139893f, -0.17470720f, 0.04232206f, 0.06334642f, 0.05467649f, 0.13545503f, 
    0.14592770f, 0.18058169f, -0.13221928f, -0.00338456f, -0.10196985f, -0.00356493f, -0.02943577f, 0.22766288f, 
    0.10790072f, 0.03112316f, -0.07282974f, 0.10174043f, -0.02845969f, -0.04821939f, 0.18758264f, -0.11165317f, 
    0.07149522f, 0.09150062f, 0.04084582f, 0.07351026f, 0.02523380f, -0.01597575f, 0.00133300f, 0.01758563f, 
    0.05955156f, 0.05334615f, -0.15053813f, 0.20723285f, 0.02791240f, -0.06062413f, 0.09983053f, -0.08852161f, 
    -0.01424653f, 0.03959700f, 0.09702227f, 0.17405358f, -0.27055988f, -0.04004211f, 0.05528254f, 0.23207286f, 
    -0.03535003f, -0.01026445f, -0.05289723f, -0.17150372f, -0.07671724f, -0.05158163f, -0.07350603f, 0.00992119f, 
    0.21180508f, 0.35113847f, 0.26087022f, 0.08407119f, 0.08901259f, -0.04702753f, -0.02577726f, 0.13684535f, 
    0.04978248f, 0.10308642f, 0.08862978f, -0.10645562f, -0.28780907f, -0.12928320f, 0.12052027f, 0.04798504f, 
    0.04939632f, 0.04538153f, -0.00809431f, 0.04940370f, -0.08241387f, 0.00445472f, -0.06499691f, 0.00313662f, 
    0.00207106f, -0.18422219f, -0.29939401f, -0.08442462f, 0.03116263f, 0.07114605f, 0.04236756f, 0.15261325f, 
    -0.06495418f, -0.00482765f, 0.04052341f, -0.08146653f, 0.15849940f, -0.04054004f, -0.03944774f, 0.09935656f, 
    -0.01202647f, 0.05644970f, -0.07840769f, -0.00296082f, -0.06213319f, -0.04136589f, -0.10623958f, 0.09456426f, 
    -0.05741147f, -0.23537509f, -0.08959252f, -0.04870445f, -0.03268577f, 0.11196770f, 0.05863567f, 0.09866524f, 
    -0.07547184f, 0.01478936f, -0.00684644f, -0.03900336f, -0.23034631f, -0.22257112f, -0.06870605f, 0.00027130f, 
    -0.15191001f, -0.14304411f, -0.09849878f, -0.17992513f, -0.05277132f, -0.04798558f, 0.02589895f, 0.01028401f, 
    -0.02264410f, -0.10742911f, 0.05527557f, -0.00982470f, -0.08228089f, -0.09377380f, -0.09189217f, -0.05740792f, 
    -0.06461513f, -0.00046504f, -0.05830077f, 0.00817362f, 0.04127067f, 0.00496875f, 0.09081291f, -0.06075299f, 
    0.05394409f, 0.08695431f, -0.05253735f, 0.03729406f, -0.09322726f, -0.09105424f, 0.07447186f, 0.05524920f, 
    0.01027433f, 0.26711974f, 0.41575590f, 0.21969642f, -0.00104017f, -0.05540117f, 0.00813214f, 0.00138994f, 
    0.03987709f, 0.13293450f, 0.03973906f, 0.01579355f, -0.00397617f, 0.03766866f, 0.31021860f, 0.12929541f, 
    -0.05917405f, -0.09741349f, -0.14559279f, 0.16563286f, -0.01010160f, 0.07120497f, -0.11944942f, -0.04247753f, 
    -0.21426150f, 0.07904804f, -0.11939095f, 0.05759282f, 0.19679216f, -0.01355472f, 0.03474288f, 0.09550317f, 
    -0.04472015f, 0.09140338f, -0.10676596f, -0.02312995f, -0.21735865f, -0.19199303f, -0.25837722f, -0.19025971f, 
    0.14119121f, 0.04194929f, -0.10132570f, -0.05051753f, 0.04308992f, -0.03407054f, -0.06336334f, 0.07059168f, 
    0.19598873f, -0.09251262f, 0.18976590f, -0.00979864f, -0.10856875f, -0.06695149f, -0.09171420f, -0.09767750f, 
    0.10751325f, -0.05242187f, 0.10009546f, 0.06880222f, 0.14719583f, 0.07871298f, -0.03340610f, -0.05701811f, 
    0.10775211f, -0.10009998f, -0.01728523f, 0.08810824f, -0.02052327f, 0.11083670f, 0.05116554f, 0.22042070f, 
    -0.00745734f, 0.12584837f, -0.04310656f, -0.08376823f, -0.01044231f, -0.00278562f, 0.04891032f, -0.03179368f, 
    0.03479681f, -0.13112700f, 0.01953417f, -0.06717534f, -0.05752077f, 0.04726369f, -0.11364016f, 0.08514753f, 
    0.02081990f, 0.01468767f, 0.04773236f, 0.04663640f, -0.03196811f, -0.04959065f, 0.07935979f, -0.17800654f, 
    0.31928509f, -0.32286039f, 0.16475369f, 0.13680388f, -0.11199137f, -0.20411049f, -0.16297959f, -0.10928053f, 
    0.06331564f, 0.01437886f, -0.04504885f, -0.09503067f, 0.11669394f, -0.01824506f, 0.20459060f, -0.06475679f, 
    0.12363025f, 0.10929207f, 0.01216833f, 0.10726720f, -0.11031715f, -0.03514742f, -0.12601055f, -0.18014017f, 
    -0.09949977f, -0.17054863f, -0.00173299f, -0.02305498f, 0.02390881f, -0.01077575f, -0.12572813f, 0.08638047f, 
    0.06299269f, -0.07222552f, -0.05074492f, 0.02833407f, 0.18455535f, -0.34133309f, 0.22648291f, -0.18936610f, 
    -0.00856347f, -0.02250400f, 0.08361270f, 0.00266092f, 0.00272409f, 0.06140413f, -0.01788551f, 0.01885593f, 
    -0.38932800f, -0.07055131f, 0.14816131f, 0.34143674f, 0.06426729f, 0.23443505f, 0.01377954f, -0.03837217f, 
    -0.17146499f, -0.09330675f, -0.14237654f, -0.34290242f, -0.18747066f, 0.45813453f, -0.31806216f, 0.41079584f, 
    0.01159917f, 0.16050757f, 0.02310513f, -0.17075212f, 0.02273906f, 0.17865278f, 0.04590289f, 0.04868518f, 
    0.23794000f, 0.04464280f, 0.17070565f, -0.04404831f, 0.10253072f, -0.07264253f, 0.04685087f, 0.09600042f, 
    -0.03641597f, -0.13750227f, 0.09018866f, -0.12365634f, -0.23060328f, 0.03572480f, -0.06597567f, -0.09785566f, 
    0.04824084f, -0.01212154f, 0.02437979f, 0.01728241f, 0.16234019f, 0.06521518f, -0.05834940f, 0.02613299f, 
    0.02838362f, 0.10876432f, 0.09729134f, 0.06710046f, -0.02818554f, 0.06654734f, -0.01467111f, -0.04270353f, 
    0.08557584f, -0.04127629f, 0.12112857f, 0.12985647f, -0.03357383f, -0.06157989f, 0.01534599f, -0.09631425f, 
    0.02801893f, -0.01579277f, 0.02236204f, 0.09698328f, 0.04802207f, -0.00164253f, -0.00283627f, 0.09160239f, 
    -0.01251955f, -0.08145721f, -0.42025074f, 0.20800076f, 0.10859141f, 0.09243274f, -0.03580439f, 0.12550749f, 
    -0.04522730f, 0.08596008f, 0.11246305f, -0.13315432f, 0.04296940f, 0.15662639f, -0.04173019f, 0.03380785f, 
    -0.09256398f, -0.14825395f, 0.02848611f, 0.02995508f, 0.03939717f, -0.02167702f, -0.04161157f, -0.02511923f, 
    -0.06998813f, 0.05142746f, -0.04091955f, -0.04359589f, 0.08965061f, 0.04064104f, -0.08834784f, 0.08484009f, 
    0.02325060f, 0.08346534f, 0.07676298f, 0.08112729f, 0.05296922f, 0.20665254f, 0.12640144f, 0.15244113f, 
    -0.07896196f, -0.02663153f, -0.01297236f, 0.07399561f, -0.02129891f, -0.07512242f, -0.00404729f, -0.02889952f, 
    -0.18537493f, 0.10961053f, 0.08120699f, -0.00829677f, -0.12191590f, -0.06111827f, 0.04867442f, -0.08360365f, 
    0.13150935f, 0.04137789f, 0.10484106f, 0.07712039f, 0.01990202f, 0.02213387f, 0.03028788f, -0.07187130f, 
    -0.12570207f, -0.20001155f, 0.00215667f, -0.02688385f, 0.13899092f, -0.18742590f, -0.06143039f, 0.09135222f, 
    -0.70247775f, -0.02450152f, -0.38420314f, 0.37725589f, 0.06513736f, 0.10137425f, 0.17449026f, -0.05681263f, 
    0.10232527f, -0.07002106f, -0.05295994f, 0.02666384f, -0.20798047f, 0.09015942f, -0.11198966f, -0.11159786f, 
    0.04988816f, 0.03583751f, 0.07794920f, 0.14853552f, 0.08056870f, -0.04680077f, 0.05041677f, 0.04286716f, 
    -0.05664117f, -0.08497020f, -0.31852126f, 0.22784242f, -0.09428065f, 0.03449540f, 0.07929167f, 0.16127241f, 
    -0.21860196f, -0.07386353f, -0.04623622f, 0.04341463f, 0.20897730f, 0.07204695f, -0.04123677f, -0.08211124f, 
    -0.07204016f, 0.03626542f, 0.09935784f, 0.04995920f, 0.04694213f, -0.11294997f, -0.00572019f, -0.00051593f, 
    -0.08219949f, 0.05184552f, 0.01900273f, -0.08964874f, -0.06750245f, 0.11704069f, -0.09108898f, -0.00039735f, 
    -0.10245017f, -0.05258694f, -0.09170130f, -0.14070895f, 0.16269116f, 0.06378412f, 0.02288989f, 0.00047618f, 
    0.01948790f, 0.03487013f, 0.05222907f, 0.04253287f, 0.04798443f, -0.05679852f, 0.00240327f, 0.00866058f, 
    -0.15654990f, -0.07205788f, -0.19061182f, 0.16222550f, 0.02519520f, 0.02588421f, 0.09325869f, 0.05324622f, 
    0.09198389f, -0.02434861f, 0.01131528f, 0.17774549f, 0.15442050f, -0.14887801f, -0.04306966f, -0.13308927f, 
    -0.10250838f, 0.01509743f, -0.12273204f, 0.01580191f, -0.13605604f, 0.06045368f, -0.00895103f, -0.07692967f, 
    -0.12769988f, 0.02448723f, 0.32461736f, 0.39168453f, 0.05302607f, -0.11637647f, -0.04460360f, -0.07034620f, 
    0.06447464f, -0.02455632f, 0.10767172f, 0.13670984f, -0.03660497f, 0.12370237f, -0.09941716f, -0.05704991f, 
    -0.09031834f, -0.11252396f, -0.00018036f, 0.10220546f, 0.12881733f, -0.05585101f, -0.12100075f, 0.04944720f, 
    0.26625308f, -0.10473827f, 0.18016492f, -0.03014786f, -0.22663346f, -0.03345260f, -0.02136764f, 0.08266053f, 
    0.01073025f, -0.06020510f, -0.08720706f, 0.01038792f, 0.04163110f, 0.11293329f, -0.07408822f, 0.02840520f, 
    0.00065053f, 0.05746002f, 0.00296036f, 0.05128926f, -0.05307971f, -0.10648903f, 0.01302658f, 0.01363853f, 
    -0.08089441f, -0.04212781f, -0.14350198f, -0.03544239f, -0.01051360f, 0.02180945f, -0.06744618f, -0.05725220f, 
    0.07030963f, 0.04219278f, -0.11445145f, 0.17884251f, -0.16045794f, -0.00696578f, -0.18686055f, 0.17862643f, 
    0.05084598f, -0.11865030f, 0.08678151f, -0.08531383f, -0.02725694f, -0.02395033f, 0.06279881f, 0.23579131f, 
    0.23138903f, 0.12660763f, 0.05658880f, -0.03809766f, 0.03798622f, 0.06094327f, 0.03381315f, 0.07962696f, 
    0.04615900f, -0.00166087f, 0.06897067f, 0.08338596f, 0.21199587f, 0.07323379f, 0.10147306f, -0.00854589f, 
    -0.05647353f, 0.06083842f, 0.01887741f, 0.00469583f, 0.03973363f, 0.04177282f, -0.02120033f, 0.02727405f, 
    0.38230845f, -0.11457899f, 0.12349135f, 0.16640244f, -0.21823625f, -0.11620321f, 0.04555118f, -0.20607348f, 
    -0.00920156f, 0.05255944f, 0.00675749f, -0.02337307f, 0.25519389f, -0.01002480f, 0.11893985f, -0.03812972f, 
    -0.00485121f, 0.01444473f, 0.02007640f, -0.00082510f, -0.03871053f, 0.04573130f, -0.04684818f, 0.05326355f, 
    0.07470076f, 0.20006630f, -0.03131656f, -0.07818154f, -0.06799758f, -0.01435450f, 0.05670123f, 0.03363997f, 
    0.13295417f, -0.12909372f, -0.03727180f, 0.09071662f, 0.23476340f, 0.25508907f, 0.13045144f, -0.14177339f, 
    -0.06192264f, -0.06045981f, -0.04507731f, 0.14310153f, -0.03867533f, 0.01667185f, -0.03009201f, -0.08033694f, 
    -0.00252078f, -0.25605309f, -0.06096971f, -0.19279973f, 0.12458628f, 0.03485764f, 0.02758075f, -0.08247602f, 
    0.06745313f, -0.01282798f, -0.15628065f, 0.08242469f, -0.19020104f, 0.19876666f, -0.34413984f, 0.27811703f, 
    0.03274835f, -0.08806908f, 0.14325191f, 0.10505649f, -0.05956160f, 0.05042003f, -0.16846587f, -0.10964195f, 
    0.15018754f, -0.39983377f, 0.00060152f, 0.05834363f, -0.02378837f, 0.05934285f, -0.11581817f, -0.08913436f, 
    0.09294714f, 0.11754444f, -0.05271367f, -0.05330896f, 0.16528735f, -0.03207329f, 0.23700815f, -0.00526828f, 
    -0.05485590f, 0.01283273f, -0.06282484f, -0.25500259f, 0.00929756f, -0.05263834f, 0.07274801f, -0.02149751f, 
    0.10063822f, 0.15897815f, -0.03526060f, -0.10399764f, -0.00618003f, -0.03394450f, 0.05825409f, 0.07224496f, 
    0.04488662f, -0.06092625f, -0.03481193f, -0.10595471f, -0.06220798f, -0.52310205f, 0.31891912f, -0.16619466f, 
    0.18956950f, -0.08125062f, -0.08166327f, 0.13326450f, 0.01943561f, 0.12851152f, 0.18476382f, 0.12808757f, 
    0.28350103f, 0.17059518f, 0.15973888f, -0.03559018f, -0.04971379f, 0.04229859f, -0.03817705f, -0.05490327f, 
    0.01650009f, -0.06901272f, -0.17440560f, -0.20851685f, 0.11986785f, -0.40937018f, 0.12755719f, -0.21623111f, 
    0.07885081f, 0.00603424f, -0.04022970f, -0.08009604f, -0.07885165f, -0.05710523f, -0.11963930f, -0.02396571f, 
    0.03172474f, -0.21448360f, -0.01032202f, -0.07338363f, 0.03274352f, 0.03710402f, 0.00649070f, 0.00091483f, 
    -0.03478966f, -0.14685516f, 0.03747442f, -0.21563524f, 0.14422005f, 0.07965016f, -0.09673174f, -0.00638615f, 
    -0.02424375f, -0.03386517f, -0.00110275f, 0.17608832f, 0.05379521f, -0.01723119f, -0.00439540f, 0.10235920f, 
    -0.18733381f, -0.05670288f, 0.03648361f, 0.24654853f, 0.09426582f, 0.03175735f, -0.03239065f, -0.09474863f, 
    -0.15721767f, -0.17708193f, -0.03131404f, -0.09180345f, -0.15553465f, -0.10304697f, -0.14663936f, 0.26400185f, 
    0.11993728f, 0.05094596f, 0.03041318f, 0.07495692f, -0.11951791f, -0.19719319f, -0.05710308f, -0.17557986f, 
    0.00467348f, -0.26681879f, -0.01464549f, -0.10301531f, 0.11363482f, -0.05566049f, 0.10559646f, 0.15553896f, 
    0.09344044f, 0.03845185f, -0.11295105f, 0.01886373f, -0.13759948f, 0.00543547f, -0.38860875f, -0.01167673f, 
    0.12441113f, 0.02305983f, 0.08968327f, 0.02537125f, -0.01229166f, -0.09172577f, -0.23445515f, -0.27211803f, 
    0.26631808f, 0.15675469f, 0.04800707f, -0.17182957f, -0.11415871f, 0.06435219f, 0.13459092f, 0.07810415f, 
    0.09172999f, -0.00759166f, -0.06757291f, -0.09171297f, -0.20876168f, 0.16788515f, -0.10248237f, -0.08522192f, 
    -0.00497931f, 0.03932323f, 0.05039396f, 0.13362673f, 0.02828003f, -0.12456141f, 0.11124406f, 0.04063873f, 
    0.16505334f, 0.19598462f, 0.02492445f, -0.05960632f, -0.08913241f, -0.00482142f, 0.03620333f, -0.07697591f, 
    0.17418429f, 0.08908614f, -0.02047838f, 0.07768603f, 0.03619422f, -0.05537232f, -0.05481265f, 0.23067185f, 
    0.20918892f, 0.16292128f, 0.20752820f, 0.17899877f, 0.07133971f, -0.03659854f, 0.07460208f, 0.11920249f, 
    -0.10318013f, -0.18551384f, -0.07336761f, -0.01441719f, 0.01959678f, 0.00976063f, 0.15512285f, -0.20646381f, 
    0.04911780f, 0.08562414f, -0.00284006f, 0.15961258f, -0.14703543f, 0.09219490f, 0.05863666f, 0.03102120f, 
    -0.01392187f, 0.01990303f, -0.05123370f, 0.01431682f, 0.08976629f, 0.13491590f, 0.07936328f, 0.02138143f, 
    0.18901499f, 0.00740034f, -0.02969310f, 0.04949187f, -0.08534262f, -0.01728376f, 0.06968944f, -0.03308836f, 
    0.14100118f, -0.05874369f, 0.05908085f, 0.11523122f, 0.00716548f, -0.11068723f, 0.10796443f, -0.07434643f, 
    0.03406349f, 0.00240529f, -0.00977568f, 0.01039099f, -0.02879041f, -0.00107744f, 0.00115320f, 0.18128325f, 
    0.06555799f, -0.15374988f, -0.09669378f, 0.00364002f, -0.01958995f, 0.05549442f, 0.07962434f, -0.04878630f, 
    0.02129598f, -0.13318668f, -0.07800734f, -0.15640332f, 0.03291048f, -0.07571696f, 0.17258345f, -0.06946494f, 
    0.00366936f, 0.06281357f, 0.15574995f, 0.15103924f, 0.02017854f, -0.11510314f, -0.13349828f, -0.15374990f, 
    0.03005592f, -0.16861787f, 0.12579590f, 0.07889481f, -0.06177828f, 0.02502928f, -0.07725376f, 0.01924064f, 
    0.14960125f, 0.02808497f, 0.17573263f, 0.07609376f, 0.10857940f, -0.01779665f, 0.01406148f, -0.13861896f, 
    -0.00098535f, -0.05983597f, 0.04908608f, 0.07283276f, 0.04347641f, 0.14033446f, 0.10029555f, 0.32606301f, 
    -0.04440120f, 0.08690140f, -0.01268647f, -0.23939911f, -0.03697998f, -0.02674322f, 0.00635884f, 0.00398071f, 
    -0.04079622f, -0.10979129f, -0.04426851f, -0.06778083f, -0.05233842f, 0.03220465f, -0.21883696f, 0.04439929f, 
    -0.06672437f, 0.07450355f, 0.07674513f, 0.07217198f, -0.03933585f, 0.06626458f, -0.01449630f, -0.02533985f, 
    0.25316337f, -0.20752940f, 0.16600321f, 0.20961891f, -0.02424524f, -0.03642203f, -0.16404986f, -0.02163249f, 
    0.12032724f, 0.06217316f, 0.00508399f, -0.05673274f, 0.05715372f, -0.05645745f, -0.00228308f, -0.08447773f, 
    0.18586162f, 0.08703418f, -0.00364451f, 0.04011955f, -0.05700848f, -0.08009544f, -0.09505948f, -0.09518709f, 
    0.10669104f, -0.12982213f, 0.02113153f, -0.09274944f, 0.00057480f, -0.04203828f, -0.04333299f, 0.07746853f, 
    -0.03299745f, 0.05098157f, 0.05296788f, 0.02075404f, 0.08734316f, -0.33985153f, 0.18745086f, -0.13987975f, 
    0.10291375f, 0.02173964f, 0.11808044f, 0.05940973f, 0.03321297f, 0.06028610f, -0.00976024f, 0.05744784f, 
    -0.30823228f, -0.10796702f, 0.11609028f, 0.11455385f, 0.01860775f, 0.20463523f, -0.06122135f, -0.17048471f, 
    -0.16898495f, -0.00040443f, -0.16503933f, -0.33175126f, 0.02048254f, 0.17650294f, -0.15995152f, -0.04235655f, 
    -0.17046821f, 0.11561460f, 0.03456597f, -0.09740117f, -0.02204540f, 0.19370487f, -0.01453598f, 0.00069141f, 
    0.08262769f, 0.06733013f, 0.14085940f, -0.05699404f, 0.06515817f, -0.10782294f, 0.10355865f, 0.01378191f, 
    -0.11833845f, -0.10500598f, 0.12966956f, -0.16156177f, -0.14787117f, 0.04970214f, -0.02592247f, -0.04782416f, 
    0.05942672f, -0.06953476f, 0.17455617f, 0.05958635f, 0.13051516f, 0.09237539f, 0.00372570f, 0.02971044f, 
    0.03406334f, 0.07481965f, 0.04459688f, 0.00229644f, 0.03650309f, 0.07343571f, 0.02489209f, -0.06062406f, 
    0.04847420f, -0.02042264f, 0.15427434f, 0.15360110f, 0.01006080f, -0.15076773f, -0.00164952f, -0.06514420f, 
    -0.00215294f, 0.09820843f, 0.12269056f, 0.11503078f, 0.10388822f, -0.02919465f, 0.01165579f, 0.13607132f, 
    0.00743907f, -0.01364646f, -0.35687280f, 0.05045091f, 0.06534103f, 0.05012150f, 0.06760874f, 0.00344221f, 
    0.03880256f, 0.11206128f, 0.05667004f, -0.04806917f, 0.03982016f, 0.21436225f, 0.08171998f, 0.09392218f, 
    0.00131770f, -0.10764711f, -0.05657497f, 0.03279037f, 0.03874890f, -0.02740782f, 0.01915619f, 0.04320942f, 
    -0.12362204f, 0.14434811f, -0.06070687f, -0.16271514f, 0.09226318f, 0.08686645f, -0.07641957f, 0.03444051f, 
    0.02473480f, 0.11157074f, 0.03552793f, 0.06422948f, 0.05297291f, 0.21239765f, -0.05164531f, -0.08596239f, 
    -0.06697366f, -0.01439583f, 0.02565580f, -0.01964900f, -0.07786991f, -0.04057658f, -0.03044925f, -0.00942811f, 
    -0.14160138f, 0.17507380f, 0.06662172f, -0.08687285f, -0.08613753f, 0.00871121f, 0.03695965f, -0.02222432f, 
    0.14814828f, 0.17328863f, 0.06721612f, 0.12321440f, 0.05690436f, 0.13271941f, 0.06985267f, -0.05762779f, 
    -0.16352522f, -0.07356826f, 0.06112866f, -0.10381372f, 0.21528074f, -0.10044517f, -0.08838891f, 0.02885880f, 
    0.03834473f, 0.00666329f, -0.24601662f, 0.05587700f, 0.11173055f, 0.04904445f, 0.21183360f, 0.04617969f, 
    0.06264268f, -0.09523609f, -0.01192878f, 0.01913903f, -0.18952118f, 0.03488535f, -0.20941561f, -0.17293879f, 
    0.03127672f, 0.11235987f, -0.00835263f, 0.14644457f, 0.05048438f, 0.02049992f, 0.07767750f, 0.11008250f, 
    0.14838977f, -0.13629960f, -0.08691720f, 0.06404131f, -0.04836927f, 0.03045293f, 0.11076878f, 0.07909221f, 
    -0.09457838f, 0.00431836f, -0.06844915f, 0.07780839f, 0.20998742f, 0.11030599f, 0.02427573f, -0.23966692f, 
    -0.10077020f, 0.03625898f, 0.10881278f, 0.05848288f, 0.01581944f, -0.00215131f, -0.00145781f, -0.05567157f, 
    0.00991931f, 0.04757471f, -0.02509925f, -0.10199575f, -0.02640471f, 0.10136546f, -0.00661367f, 0.04929744f, 
    -0.05982903f, -0.13053776f, 0.01230690f, -0.07735696f, 0.22217806f, 0.01783602f, -0.05236544f, -0.04801387f, 
    0.02299566f, -0.03186465f, 0.12122788f, -0.04383564f, -0.04342725f, -0.04870030f, 0.05294985f, 0.00964589f, 
    -0.08892235f, -0.01349611f, 0.01215804f, 0.15718786f, -0.12373037f, -0.00447535f, 0.15251739f, 0.04804245f, 
    0.08719742f, 0.08112558f, 0.15060240f, 0.24561934f, 0.23726438f, -0.00035774f, -0.01497267f, -0.13635291f, 
    -0.06734400f, -0.07530779f, -0.11837162f, -0.05403917f, 0.00966704f, -0.08367939f, 0.01492685f, -0.11191452f, 
    -0.42288202f, 0.02143713f, 0.32569113f, 0.40893224f, 0.05369535f, 0.00535281f, -0.17919077f, 0.04445363f, 
    0.14858778f, 0.03935680f, 0.03387466f, 0.09897677f, -0.04339165f, 0.16363429f, -0.13940781f, -0.10170054f, 
    -0.13339758f, -0.02361663f, -0.00718212f, 0.05258030f, 0.17373711f, -0.07117173f, -0.19340490f, 0.08327921f, 
    0.19991189f, -0.11121494f, 0.06461991f, -0.07070294f, -0.10503082f, 0.04768290f, 0.10546997f, 0.04861477f, 
    0.14545508f, -0.03204567f, -0.01329187f, 0.07455952f, -0.01786961f, 0.08518967f, -0.12312423f, -0.06011970f, 
    0.05921955f, 0.01024733f, 0.00201791f, 0.02200940f, -0.14566872f, -0.04992188f, 0.00216956f, -0.03414160f, 
    -0.01566375f, 0.05132055f, -0.07191318f, -0.05893506f, -0.02264516f, -0.00888004f, 0.05841644f, 0.01788912f, 
    0.12089024f, 0.05116101f, -0.02282843f, 0.26142716f, -0.02223608f, 0.02644268f, -0.06829807f, 0.01703935f, 
    -0.05504985f, -0.04400518f, 0.16774216f, -0.04070173f, -0.01662014f, 0.03512245f, 0.16291744f, 0.25735396f, 
    0.20131996f, -0.00029057f, -0.04081837f, -0.09662934f, 0.06692184f, 0.11644898f, 0.02982825f, 0.07897708f, 
    0.01777191f, 0.01344708f, 0.13671260f, 0.04888495f, 0.17491332f, 0.05608042f, -0.02864887f, -0.10749240f, 
    -0.06439420f, 0.08567916f, -0.00233758f, 0.02586041f, 0.00338626f, -0.02818183f, 0.04373758f, -0.04735343f, 
    0.26626858f, -0.03969882f, 0.26579422f, 0.18643351f, 0.01279625f, -0.07472722f, -0.06642151f, -0.11774381f, 
    0.07489944f, 0.06800792f, -0.00877556f, 0.00586244f, 0.15450275f, -0.11239108f, 0.02124408f, -0.21031001f, 
    0.09892619f, -0.07261720f, -0.01832415f, -0.01954431f, -0.04376924f, -0.01406357f, -0.02979691f, -0.02073192f, 
    0.12885973f, 0.26547328f, -0.17772490f, -0.24901488f, -0.16451599f, -0.03151768f, -0.06007778f, -0.03687066f, 
    0.05974940f, -0.07746678f, -0.06728542f, -0.04615676f, 0.21281639f, 0.16006640f, -0.08092926f, -0.27489936f, 
    0.00641025f, -0.12961107f, 0.00257834f, 0.10838050f, 0.01694536f, 0.02103694f, -0.02703073f, -0.10672168f, 
    0.14300339f, -0.26649761f, -0.08812805f, -0.10860892f, 0.09539164f, 0.13857731f, -0.01074439f, -0.07890885f, 
    -0.05289221f, -0.01967304f, -0.00804708f, 0.07826387f, 0.02445487f, 0.14269781f, -0.30434027f, 0.10215130f, 
    -0.01870259f, -0.16920942f, 0.14743146f, -0.03687942f, 0.00594962f, 0.09468574f, -0.14619331f, -0.14908291f, 
    0.17039222f, -0.40323573f, 0.03264754f, 0.13439018f, -0.00778995f, 0.12678590f, -0.02011413f, 0.02141320f, 
    0.06313471f, 0.09757834f, -0.01874090f, -0.10128134f, 0.02945633f, 0.05591073f, 0.34841534f, 0.19299109f, 
    0.01737506f, -0.10076659f, -0.07308383f, -0.19573319f, 0.04943008f, 0.02699114f, 0.00581479f, -0.09027871f, 
    0.00133873f, 0.08842208f, -0.05167104f, -0.23225468f, -0.03019813f, -0.01506501f, 0.01588091f, 0.01885601f, 
    -0.04024916f, -0.03795220f, -0.01147577f, 0.02762772f, -0.02075741f, -0.32517534f, 0.13630083f, -0.24879952f, 
    -0.01585391f, 0.03427494f, -0.07879103f, 0.17824651f, 0.17722026f, 0.04440258f, 0.08640932f, 0.22126466f, 
    0.10073883f, 0.15106691f, 0.23089966f, 0.08834115f, 0.08185229f, 0.02779977f, 0.02701864f, -0.03058645f, 
    -0.04957148f, -0.03280378f, -0.11412244f, -0.23500603f, 0.07970095f, -0.22715460f, 0.07830432f, 0.08269348f, 
    0.04792710f, -0.00707433f, -0.02857519f, -0.10213888f, -0.03676030f, -0.04723798f, -0.07227933f, -0.14908227f, 
    0.06059533f, -0.07324012f, -0.05724274f, -0.15702575f, 0.07601490f, 0.04774630f, 0.00228405f, -0.02923580f, 
    0.04050865f, -0.00307053f, -0.01257059f, -0.13438337f, 0.08390836f, 0.07708881f, -0.20478934f, -0.11909902f, 
    0.01774297f, 0.06613525f, 0.04720601f, 0.28470799f, 0.07964472f, 0.03549874f, 0.07662625f, 0.08901937f, 
    -0.17199323f, -0.02913837f, 0.07458343f, 0.25254136f, 0.06154738f, 0.03671803f, 0.01260222f, -0.12851329f, 
    -0.10368775f, -0.03523757f, -0.11157952f, -0.19147818f, 0.05650136f, -0.05701888f, -0.16589773f, 0.11863030f, 
    0.01144289f, 0.06181179f, 0.00033964f, -0.13608707f, -0.04868082f, -0.09845073f, -0.11894315f, -0.23005831f, 
    -0.06136090f, -0.28314203f, -0.06090168f, -0.08887359f, 0.17270850f, -0.13654573f, 0.11121965f, 0.17520377f, 
    0.01748581f, 0.04266669f, -0.00816423f, 0.01723935f, 0.07703388f, 0.00134201f, -0.27589908f, -0.04834794f, 
    0.14126195f, 0.03527045f, 0.11109157f, 0.00382823f, -0.07716331f, -0.04905064f, -0.13371237f, -0.19036123f, 
    0.09216298f, 0.19410510f, -0.05210871f, -0.17203124f, -0.12274111f, 0.01195864f, 0.03945078f, -0.01248111f, 
    -0.01893704f, -0.02577711f, -0.07071333f, -0.06038486f, -0.19594452f, 0.05158085f, -0.17294490f, -0.23118678f, 
    -0.06740438f, 0.12989317f, 0.02014023f, 0.18037249f, 0.04850251f, -0.08600144f, 0.09266695f, -0.04188051f, 
    0.21325913f, 0.21870464f, 0.02079586f, -0.22057916f, -0.12890099f, -0.05601821f, 0.02971352f, -0.02760087f, 
    0.11274776f, -0.00959627f, -0.03080634f, 0.08422310f, 0.07537179f, -0.14109486f, -0.11346360f, 0.13795730f, 
    0.10163102f, 0.12773417f, 0.06136022f, 0.07636952f, 0.06256074f, 0.10075296f, 0.13616106f, 0.12692870f, 
    -0.03874734f, -0.17140765f, -0.03898555f, 0.06839654f, -0.02975992f, -0.02093967f, 0.16820781f, -0.05273369f, 
    0.10330563f, 0.11867373f, 0.09450330f, 0.18260810f, -0.14798224f, 0.10024440f, 0.07241643f, -0.01663313f, 
    0.03583490f, 0.08005583f, -0.01694302f, 0.01131051f, 0.11472084f, 0.06355669f, 0.15101227f, 0.11638653f, 
    0.21495400f, 0.01350125f, 0.03149957f, 0.08608659f, -0.04453430f, -0.11992001f, -0.00857829f, -0.05934429f, 
    0.05453070f, -0.05245596f, 0.12072086f, 0.11666255f, 0.06094623f, -0.05773624f, 0.06227972f, -0.02354874f, 
    0.13502020f, 0.03535254f, 0.02484579f, -0.02934336f, 0.07327604f, -0.05075675f, 0.07996526f, 0.17837951f, 
    0.00628622f, -0.08189654f, -0.23242262f, 0.07908683f, 0.00592006f, 0.09522983f, 0.10552842f, -0.09501515f, 
    0.13081175f, -0.09124079f, -0.03293557f, -0.06589234f, 0.12991962f, 0.05072320f, 0.06998066f, -0.16968744f, 
    -0.04305292f, -0.03563196f, 0.05817920f, 0.06315800f, -0.09588277f, -0.06871238f, -0.06926371f, -0.20654489f, 
    0.10907438f, -0.14273322f, -0.10322071f, -0.29728341f, -0.06550435f, 0.09323786f, -0.06690607f, -0.07390469f, 
    0.19849396f, -0.05529882f, 0.17338973f, 0.06192333f, 0.23841575f, 0.00109134f, -0.00137460f, -0.43280241f, 
    0.12897572f, 0.02205546f, -0.04070428f, -0.11879712f, -0.16741967f, -0.05061994f, 0.07110856f, 0.03563009f, 
    -0.08483256f, 0.19090326f, 0.08575006f, -0.02597588f, -0.08457578f, 0.06390148f, -0.06924271f, -0.01006684f, 
    0.01084829f, 0.00759361f, -0.00611228f, -0.14061701f, -0.17172185f, 0.09879759f, -0.27193359f, -0.11192438f, 
    0.18555896f, -0.01089925f, 0.11057382f, 0.04762312f, 0.05333561f, 0.08746063f, -0.00136147f, -0.04331052f, 
    0.24476537f, -0.40284342f, 0.11911651f, 0.31776646f, -0.12623347f, 0.00463045f, 0.03539535f, 0.11485722f, 
    0.28081566f, 0.15485872f, 0.07803588f, 0.08544479f, -0.11454306f, -0.14440769f, -0.10408038f, -0.17559496f, 
    0.08853377f, -0.06399469f, 0.01240864f, 0.00096144f, -0.01048433f, -0.02715516f, 0.05943763f, 0.00764435f, 
    0.98128664f, -0.06072395f, 0.05917671f, -0.33996326f, -0.12323663f, -0.04584497f, -0.22099918f, -0.09469856f, 
    0.04958593f, -0.02269521f, -0.00406178f, 0.05245503f, -0.06129361f, -0.43050292f, 0.16244835f, -0.01646517f, 
    -0.02886022f, 0.01320444f, 0.14705439f, 0.05326887f, 0.11603811f, -0.09289795f, 0.02610437f, 0.05220554f, 
    -0.07340682f, -0.09490190f, 0.00107818f, 0.19161379f, 0.02394956f, 0.03290540f, -0.00352892f, 0.00192167f, 
    -0.00908440f, -0.03995843f, -0.06468753f, 0.13260369f, 0.05178785f, -0.12531357f, -0.34566396f, -0.05008762f, 
    0.23152590f, 0.05983374f, -0.09508857f, -0.04409347f, 0.02125252f, 0.01117629f, 0.03973582f, -0.05010746f, 
    -0.05111939f, 0.21610601f, 0.02736105f, -0.04724626f, -0.00397588f, -0.03935024f, 0.04761487f, -0.13896887f, 
    0.12326258f, 0.03084919f, 0.08004156f, -0.16387337f, -0.11579324f, 0.00959847f, -0.05709032f, -0.06752854f, 
    0.20195469f, -0.00640051f, -0.02079548f, 0.01803903f, 0.16343147f, 0.07644729f, -0.01002902f, -0.03426604f, 
    0.00218961f, 0.03874097f, 0.09357274f, 0.19357391f, 0.06506049f, 0.11948926f, -0.02514406f, -0.06840222f, 
    -0.02954101f, -0.00715667f, 0.02146355f, 0.07776695f, -0.00303430f, -0.12561631f, -0.14435469f, -0.13684009f, 
    -0.04867868f, -0.04325403f, -0.02496330f, 0.14507250f, 0.14166494f, 0.03826357f, 0.06283952f, -0.09472633f, 
    0.10575195f, 0.01200232f, -0.03868065f, -0.17092791f, 0.23015447f, -0.06923857f, -0.23092198f, 0.05819841f, 
    0.07730968f, -0.08654583f, 0.10406021f, 0.03478589f, -0.27075496f, -0.05516369f, -0.00365444f, 0.23988076f, 
    0.01017827f, -0.06617955f, 0.01576279f, 0.01299031f, 0.05581078f, 0.01119714f, 0.06473902f, 0.12560768f, 
    -0.24412647f, 0.32354337f, 0.16593413f, 0.03083254f, -0.00466004f, 0.07678583f, -0.08456676f, -0.05871901f, 
    -0.03582301f, -0.02695410f, 0.03342571f, -0.05088608f, 0.02040179f, 0.25001431f, 0.07128004f, -0.25242382f, 
    -0.01155995f, -0.08619977f, -0.00428928f, 0.02031499f, -0.03688108f, -0.05845183f, -0.03814690f, 0.00453619f, 
    -0.21815914f, 0.10427269f, 0.12315043f, 0.08557484f, -0.02899623f, 0.11028507f, -0.12207653f, -0.00503611f, 
    0.16026908f, 0.21500376f, 0.10477486f, -0.15309772f, -0.01823391f, 0.06566241f, -0.01380296f, -0.08598886f, 
    0.04608657f, 0.00178848f, -0.06833751f, 0.04017596f, 0.20982128f, 0.14574054f, -0.08034403f, 0.17915891f, 
    0.17122044f, -0.05216009f, -0.22723816f, 0.02126797f, 0.03257436f, -0.11724826f, -0.21560273f, -0.10473188f, 
    0.01994375f, 0.02109838f, -0.04396211f, -0.03482079f, -0.00642106f, 0.24325870f, 0.13540529f, -0.05440553f, 
    -0.12223013f, -0.03264903f, -0.04182091f, 0.02570506f, 0.07839538f, -0.01879065f, -0.02464942f, -0.01285300f, 
    0.21161495f, 0.00742870f, -0.17661652f, -0.22371048f, 0.06093752f, 0.00291691f, -0.04611062f, 0.10261502f, 
    -0.01049758f, -0.04281005f, -0.03745114f, -0.01257880f, -0.16324253f, 0.08640324f, 0.09918837f, -0.28250924f, 
    -0.14728525f, -0.01172672f, 0.00921546f, -0.04375890f, -0.01229637f, -0.15556094f, 0.04904143f, -0.08505073f, 
    0.10829284f, 0.05610066f, 0.01636582f, 0.07286450f, 0.06109722f, 0.12208212f, -0.06876145f, 0.03482907f, 
    -0.00379104f, -0.01147684f, -0.05926433f, 0.05984474f, -0.06338399f, 0.10091012f, 0.20342696f, 0.17442529f, 
    -0.05882318f, -0.11991154f, -0.08389454f, -0.11260523f, 0.15542348f, 0.08252585f, -0.15102047f, -0.05016846f, 
    -0.03941716f, -0.05025636f, -0.10458453f, -0.07529768f, 0.04718268f, 0.02181492f, -0.00242155f, 0.05181606f, 
    -0.14169632f, -0.05359432f, 0.06739841f, 0.04912989f, 0.51187903f, -0.20751560f, -0.00949284f, -0.10257287f, 
    -0.07145867f, 0.08980387f, -0.05311907f, 0.05055586f, 0.09974341f, -0.01308051f, 0.10434157f, -0.06167033f, 
    -0.56433332f, -0.12118793f, 0.13662319f, 0.35220727f, -0.04132784f, -0.05386549f, 0.06636821f, 0.19672011f, 
    0.17782281f, 0.01637844f, 0.08471829f, 0.16494448f, -0.18648745f, 0.02856418f, -0.11818628f, -0.19368906f, 
    0.08712297f, 0.13764438f, -0.02616110f, -0.08298638f, 0.05016942f, -0.08466040f, 0.19341670f, 0.02590616f, 
    0.07795143f, 0.01157348f, -0.02815969f, -0.01708622f, 0.04027403f, -0.06049124f, 0.02463741f, 0.06741446f, 
    0.06330823f, -0.04253285f, -0.16172448f, -0.03078507f, -0.03036010f, 0.15002526f, 0.17939614f, -0.10256369f, 
    0.08699434f, 0.05135049f, -0.06096515f, -0.26469126f, -0.02625949f, -0.03803658f, -0.02889819f, -0.07430969f, 
    0.02902569f, 0.15873177f, -0.11017752f, -0.16120139f, 0.15267885f, 0.03041239f, -0.04495948f, 0.03154523f, 
    0.00761927f, 0.12748566f, 0.01226352f, 0.03939211f, -0.03210843f, -0.00459573f, -0.14405626f, -0.17897680f, 
    0.06652735f, 0.06850085f, 0.03326056f, 0.07992556f, -0.10318914f, 0.01097281f, 0.10042412f, -0.00601221f, 
    0.08363019f, 0.25047565f, 0.26639315f, -0.08078243f, -0.06571197f, 0.00623560f, 0.11260431f, 0.00424100f, 
    0.05288204f, 0.03401671f, 0.03929586f, -0.02257537f, 0.05417959f, 0.27394044f, 0.12806466f, -0.07365332f, 
    -0.18574286f, 0.02227081f, 0.10127651f, -0.03925926f, 0.11147804f, 0.01758941f, -0.12064564f, -0.08230557f, 
    0.05467878f, -0.10667263f, 0.06134738f, 0.23069026f, -0.12263337f, -0.02771066f, -0.00528177f, 0.03575335f, 
    0.07904613f, -0.08292806f, -0.09466567f, 0.10733474f, 0.14355491f, -0.06616828f, 0.30351356f, -0.05650907f, 
    0.07855814f, -0.09653046f, 0.04083612f, -0.01849534f, 0.00629682f, -0.01308766f, 0.05327221f, 0.04417239f, 
    -0.02852513f, 0.21087845f, -0.00948815f, -0.19380262f, 0.02608467f, -0.08764626f, 0.02113196f, 0.03540535f, 
    0.02544763f, 0.03052869f, -0.01175787f, -0.01244162f, 0.27009761f, 0.25021091f, 0.12558272f, -0.26734325f, 
    -0.05209544f, -0.16585892f, -0.04868849f, -0.21527711f, -0.02952343f, 0.01034080f, 0.01111126f, -0.03629418f, 
    0.45503449f, -0.15760182f, -0.10343099f, -0.43668258f, 0.10621937f, 0.09333236f, -0.03606115f, -0.14760429f, 
    -0.07049076f, -0.08653004f, 0.06778783f, -0.08937690f, -0.02199940f, 0.05527074f, -0.18025164f, 0.06692968f, 
    0.10908344f, -0.10559980f, 0.00677202f, -0.15182833f, -0.04073892f, 0.02734212f, -0.02919478f, 0.04719069f, 
    0.14918102f, -0.30727428f, 0.08852494f, 0.08130837f, 0.04903450f, 0.04124184f, -0.05452510f, 0.00829480f, 
    0.08007275f, 0.02614326f, 0.07845882f, -0.13747676f, -0.15744613f, 0.08902808f, 0.10148951f, 0.27720988f, 
    -0.11399477f, 0.05433420f, 0.05024266f, 0.12670375f, 0.03622729f, -0.03864493f, -0.04606021f, 0.08476141f, 
    -0.15549727f, 0.22379664f, -0.05708385f, -0.22666201f, -0.00264745f, 0.19537629f, -0.04274743f, -0.26405597f, 
    -0.06278287f, 0.18942477f, -0.04145287f, -0.06455107f, 0.05981284f, -0.17021210f, 0.07048973f, -0.07646611f, 
    -0.01164148f, -0.11790734f, -0.09161715f, -0.07375736f, 0.13244081f, -0.17262028f, 0.18969545f, 0.00253950f, 
    -0.07066940f, -0.00754103f, 0.05584287f, 0.04691631f, -0.03338475f, 0.00152711f, -0.15166233f, -0.07840376f, 
    -0.07456821f, -0.04358729f, -0.13605098f, 0.00379224f, 0.01683818f, -0.01957626f, -0.03785837f, 0.08657803f, 
    0.06131006f, -0.03419526f, 0.01203812f, 0.07952113f, -0.06483613f, 0.05099217f, -0.01007027f, -0.19059364f, 
    -0.05194093f, -0.03380247f, -0.02961741f, 0.19864091f, 0.04939444f, 0.18199643f, 0.13149384f, 0.01918230f, 
    0.20256665f, -0.01979660f, 0.06843184f, 0.09094071f, 0.10858118f, 0.18150410f, 0.21489052f, -0.13698721f, 
    -0.02767536f, 0.04407796f, 0.01353882f, 0.15677357f, 0.10851379f, 0.08451284f, -0.00247867f, -0.08582198f, 
    -0.21754234f, 0.02147676f, 0.01574126f, 0.17419627f, 0.00818467f, 0.02590317f, 0.03857755f, 0.08199275f, 
    0.04633166f, 0.05512225f, 0.03623038f, 0.01736144f, 0.04362135f, 0.05402562f, -0.01502861f, 0.00449854f, 
    0.05111898f, -0.00674053f, 0.02578884f, 0.00772219f, 0.04085965f, -0.00623884f, 0.06264440f, 0.03714977f, 
    0.46373436f, -0.04560323f, 0.04489363f, -0.22947487f, 0.09064438f, -0.14938970f, -0.06402505f, -0.06894370f, 
    0.00252893f, -0.12680277f, 0.05751454f, 0.06394817f, 0.05095970f, -0.01306292f, -0.18849652f, 0.11683571f, 
    0.03832235f, -0.07029712f, -0.01289968f, -0.03942435f, -0.02437728f, 0.00425747f, 0.02665140f, 0.04095552f, 
    -0.08546763f, 0.09472001f, 0.02245219f, 0.01474530f, -0.09305184f, 0.00730191f, 0.07476283f, -0.01413594f, 
    0.02717010f, -0.05521437f, 0.04636715f, 0.01456484f, -0.29027990f, 0.46412084f, 0.06546345f, -0.20747116f, 
    -0.00116304f, 0.06304608f, 0.04817476f, -0.00041853f, 0.05544942f, 0.03644020f, -0.11108579f, -0.04969587f, 
    0.10410495f, 0.18844151f, 0.16726683f, 0.08607963f, -0.01223306f, 0.07989540f, -0.10197385f, 0.00192700f, 
    0.07579737f, 0.08347787f, 0.01261977f, -0.06957699f, 0.05769708f, -0.00346853f, 0.06859471f, 0.08983870f, 
    0.01394350f, -0.00153195f, -0.02851946f, -0.00674594f, -0.03706578f, 0.03987033f, 0.08933407f, 0.15102710f, 
    -0.02401678f, -0.00179475f, 0.00773822f, 0.07927858f, 0.05426263f, -0.01771053f, -0.02921858f, 0.04535169f, 
    0.02951403f, -0.03789384f, 0.10881238f, 0.14130655f, -0.25397778f, 0.24483281f, 0.16273078f, -0.02483136f, 
    -0.10500290f, 0.01172058f, -0.03508592f, 0.01018330f, 0.06515986f, -0.05322105f, -0.01728370f, -0.01633263f, 
    -0.27763891f, 0.25413975f, 0.18626818f, 0.10427939f, -0.04881944f, 0.01128790f, -0.00893608f, 0.00902764f, 
    0.20699871f, -0.06872060f, 0.05821368f, 0.00192471f, -0.05241924f, -0.17224880f, 0.23309083f, 0.09999490f, 
    -0.02294293f, -0.20170593f, -0.17903064f, 0.02005617f, 0.00787435f, -0.11784257f, 0.11409575f, 0.16436721f, 
    -0.01817028f, 0.03508547f, 0.00185973f, 0.10162059f, -0.00704255f, 0.09581427f, -0.07266358f, 0.14982885f, 
    0.00853239f, -0.01113630f, -0.01671186f, 0.10924359f, 0.17577899f, 0.00294920f, -0.02437614f, -0.05217752f, 
    -0.05210617f, 0.04281077f, 0.06673609f, -0.12935096f, -0.03697105f, -0.08335318f, -0.12071888f, 0.00804456f, 
    0.01809018f, 0.06038672f, -0.21328288f, 0.19224989f, -0.08990519f, -0.08987990f, 0.07613759f, 0.10613360f, 
    0.00692645f, -0.02463703f, -0.03799355f, 0.22001787f, 0.14593880f, 0.12191825f, 0.07932735f, -0.19357088f, 
    -0.20136334f, 0.06708863f, -0.05258819f, -0.01459235f, -0.03299531f, -0.01830720f, 0.07342906f, 0.05520812f, 
    0.37394580f, 0.29644597f, 0.09525168f, 0.05831837f, 0.03279986f, 0.14690666f, 0.04647522f, 0.10769467f, 
    -0.03047004f, 0.02331950f, -0.00400398f, -0.07276162f, -0.01799200f, -0.04814241f, -0.00121205f, 0.06638175f, 
    -0.08549880f, 0.02636212f, 0.06656422f, -0.00266250f, 0.10995230f, 0.08959237f, -0.08574515f, -0.05410423f, 
    -0.14619884f, -0.13813455f, -0.18344378f, -0.17284541f, 0.08723089f, 0.05815875f, 0.15015423f, -0.05370735f, 
    0.08225770f, -0.00251548f, -0.02262959f, -0.07481634f, 0.00665364f, 0.22414771f, -0.00921115f, -0.08235241f, 
    -0.08889621f, -0.13147183f, -0.02817668f, 0.07082284f, 0.00709801f, -0.02086184f, 0.01800953f, 0.00136757f, 
    0.72003615f, 0.09233379f, -0.18114381f, -0.17848869f, -0.06850592f, -0.00543266f, 0.06799842f, -0.00347892f, 
    0.03611183f, 0.02514813f, 0.03487250f, 0.15574159f, -0.03651326f, 0.13927874f, 0.02597042f, 0.02455831f, 
    0.14010786f, 0.18235363f, 0.07513881f, -0.03378141f, 0.12301438f, 0.11875842f, 0.03737536f, -0.07048629f, 
    -0.08578782f, -0.05264411f, 0.05087279f, 0.02158797f, -0.04593853f, 0.01159091f, 0.03000163f, -0.06287409f, 
    -0.03315486f, 0.05137285f, -0.00324618f, 0.02356740f, -0.14981379f, -0.11395731f, 0.04043427f, -0.02318740f, 
    -0.06410621f, 0.02196218f, 0.01352586f, -0.16901767f, -0.05950999f, -0.01438143f, 0.01677765f, 0.09257368f, 
    0.01291535f, 0.29536194f, 0.11491764f, 0.11864568f, -0.04987465f, 0.10925242f, 0.24212804f, -0.01628393f, 
    -0.06907575f, 0.09145556f, -0.10584285f, 0.17747338f, 0.15447114f, -0.10633798f, 0.02242346f, -0.08993667f, 
    -0.03026780f, -0.12125494f, -0.04484937f, 0.12797599f, -0.10944377f, 0.06725503f, -0.06113677f, 0.14829406f, 
    0.22877489f, -0.02073779f, 0.01062590f, 0.07272707f, 0.09166082f, 0.11817719f, -0.03953867f, -0.03689001f, 
    -0.13329498f, 0.07122381f, -0.13150337f, -0.09143301f, 0.06924124f, 0.00751702f, -0.28087419f, -0.17700760f, 
    0.06547502f, 0.04316989f, -0.02841585f, 0.09242456f, -0.02546795f, 0.04527375f, 0.06568906f, -0.02465441f, 
    -0.04114940f, 0.15025575f, 0.26835868f, -0.21096252f, -0.11882342f, -0.09701860f, -0.17935237f, -0.06100030f, 
    0.03674621f, -0.10960982f, 0.12094419f, 0.11312857f, 0.01489206f, -0.18533562f, -0.32463408f, -0.07458121f, 
    0.16093795f, -0.03603749f, 0.03154425f, 0.07371201f, -0.03223070f, 0.01541954f, -0.04465986f, -0.01320854f, 
    0.18626164f, 0.14405648f, 0.12962724f, 0.18832999f, -0.03120745f, 0.06414242f, -0.00341866f, -0.07632865f, 
    -0.03059194f, 0.00998450f, -0.08427604f, -0.06376197f, 0.09940225f, 0.20779137f, 0.34749731f, 0.03077326f, 
    -0.07314938f, 0.09244782f, -0.06233436f, 0.19055246f, -0.02136538f, -0.06300242f, 0.09736891f, 0.03473002f, 
    0.02171109f, 0.07235047f, 0.17704612f, -0.06194613f, 0.07110892f, 0.03159975f, -0.11460267f, 0.02516800f, 
    0.08157762f, -0.03215661f, 0.04333876f, 0.19278161f, -0.11630037f, -0.06042250f, 0.09441780f, -0.05595912f, 
    -0.13196066f, 0.13013877f, -0.13626313f, -0.07859319f, 0.01413135f, 0.00379262f, -0.07504264f, 0.08706743f, 
    0.38537875f, -0.04064434f, 0.11573896f, -0.21245977f, -0.07256406f, -0.06798714f, 0.05194436f, 0.14659739f, 
    0.05665813f, 0.05650960f, 0.12329245f, -0.15504345f, 0.41675380f, 0.21472090f, 0.26590598f, -0.00622237f, 
    0.12463377f, 0.07944673f, 0.02267020f, -0.05845873f, 0.01545181f, -0.01267525f, -0.07002201f, 0.02837565f, 
    0.09429894f, 0.03334228f, 0.04172640f, -0.14828789f, 0.03473012f, -0.00859635f, -0.00492804f, -0.05526607f, 
    0.05114828f, -0.02806756f, 0.05086499f, 0.03651409f, 0.42222989f, 0.06198058f, -0.13559686f, -0.15882672f, 
    -0.04358633f, 0.11022628f, 0.05546744f, 0.09788746f, 0.01012123f, 0.03384541f, 0.07102743f, -0.06510387f, 
    0.08444299f, 0.04676329f, -0.12679337f, -0.02688156f, 0.00110199f, -0.04063457f, 0.00547586f, 0.05503593f, 
    0.03740290f, -0.11305550f, -0.02591297f, -0.04539066f, 0.08132063f, 0.22224279f, 0.04846337f, 0.11523147f, 
    0.11539580f, 0.01782168f, -0.01988174f, -0.01570930f, -0.02487372f, 0.06859478f, -0.12114438f, -0.12598269f, 
    0.07022945f, -0.06064399f, -0.05315388f, -0.04870437f, -0.07591835f, -0.01773765f, -0.06810856f, -0.09822033f, 
    -0.18822429f, -0.02155191f, 0.08861931f, 0.15315782f, 0.04144269f, 0.13254958f, -0.08412304f, 0.08559587f, 
    -0.05065186f, 0.10986170f, 0.08182070f, -0.05786376f, -0.04179153f, -0.09597666f, 0.07025354f, -0.15699181f, 
    -0.38153100f, 0.04746161f, -0.16083273f, -0.23988298f, -0.00236704f, 0.03521115f, -0.17321666f, -0.11221735f, 
    0.05388856f, 0.22137465f, 0.05260879f, 0.08840255f, 0.08084721f, -0.11634651f, 0.01915795f, -0.05243133f, 
    0.04511784f, 0.14375292f, 0.00592288f, 0.00028718f, 0.08259068f, -0.12907325f, -0.00575621f, -0.20952353f, 
    -0.04881146f, -0.16014285f, -0.24812131f, -0.05751209f, 0.08177008f, 0.16273773f, -0.00083518f, 0.05707890f, 
    -0.12146448f, 0.02099723f, -0.05186446f, -0.03062692f, 0.21955718f, 0.16877647f, 0.29775709f, 0.21045446f, 
    0.05749787f, 0.09581407f, 0.05377943f, -0.01937907f, -0.08510223f, -0.06118109f, -0.00231322f, -0.19942343f, 
    -0.13186273f, -0.00356818f, -0.09475124f, -0.06508708f, -0.01140852f, 0.07861173f, -0.06198750f, 0.01551891f, 
    -0.06978026f, 0.00260203f, 0.05545751f, -0.00398030f, -0.09956709f, 0.05387803f, 0.03881660f, -0.05281001f, 
    -0.08690061f, -0.06658299f, -0.01438360f, -0.04236029f, -0.11547995f, -0.05413096f, -0.03244281f, 0.11943809f, 
    0.17491020f, 0.16427183f, -0.02146201f, 0.21109459f, 0.04895730f, -0.01400454f, 0.06251173f, 0.08708888f, 
    0.01658027f, -0.03577778f, -0.05631534f, 0.00248747f, 0.09912556f, 0.33471456f, 0.02238963f, 0.28872824f, 
    -0.12538785f, 0.19455548f, 0.02764697f, 0.34791130f, 0.01226032f, -0.08113208f, -0.08964385f, 0.01038765f, 
    -0.07261942f, 0.04389351f, -0.32553914f, -0.08895013f, 0.08203519f, 0.03074453f, 0.02971537f, -0.17486036f, 
    0.07933686f, -0.00416121f, -0.00737858f, -0.04692985f, 0.03177328f, 0.13494419f, 0.18295303f, -0.02384470f, 
    -0.04935402f, 0.01383459f, -0.02268458f, 0.02507868f, 0.02171561f, -0.00012474f, 0.01695299f, -0.21918103f, 
    0.17779823f, 0.21576671f, 0.19282688f, 0.20023268f, 0.02028515f, 0.03888866f, -0.00483822f, 0.11233340f, 
    -0.04539675f, 0.00713349f, 0.01490476f, 0.00159489f, 0.31122571f, 0.16459833f, 0.09058122f, 0.03913036f, 
    -0.13152015f, 0.02627158f, 0.11917960f, 0.19005446f, -0.07417672f, 0.05409560f, -0.04759239f, -0.08073858f, 
    -0.14469054f, -0.12151007f, 0.13988732f, 0.12813362f, -0.28139341f, -0.05521595f, 0.00509723f, 0.12687348f, 
    -0.11709319f, 0.05358823f, 0.15162849f, 0.22126798f, 0.15578873f, -0.10451489f, 0.18921363f, -0.04395683f, 
    -0.01058563f, 0.04368308f, 0.14777178f, 0.03806278f, -0.05751578f, 0.01472360f, -0.06560893f, -0.04137447f, 
    -0.17821039f, 0.03843208f, -0.07803053f, 0.03218616f, -0.00577820f, 0.01931764f, 0.05656757f, -0.07449275f, 
    0.08323399f, -0.10698393f, 0.20926382f, 0.04511395f, -0.26796931f, 0.23688696f, -0.01300213f, 0.03704328f, 
    0.05361579f, 0.08460645f, -0.11745067f, -0.13287982f, -0.08728280f, 0.07026697f, -0.12047284f, -0.03049764f, 
    0.24183328f, 0.14774981f, 0.14698486f, 0.28028655f, 0.04061823f, 0.11996300f, 0.02894625f, 0.09538040f, 
    -0.21698934f, 0.05861120f, -0.00703910f, 0.07217726f, 0.30891627f, 0.03704088f, -0.00998934f, -0.13200478f, 
    0.12226021f, 0.04419120f, 0.00531429f, 0.03906954f, 0.06745020f, 0.02212619f, 0.09080351f, 0.12094592f, 
    -0.07460821f, 0.17811210f, -0.12227218f, -0.01599005f, 0.21016419f, 0.05081877f, 0.03767276f, -0.02286199f, 
    -0.08132794f, 0.01071046f, 0.05856540f, -0.04418640f, -0.25972593f, -0.15634324f, -0.03700856f, -0.01854362f, 
    -0.15859589f, -0.06837251f, 0.06066300f, -0.06049167f, 0.00510816f, -0.00329138f, 0.05529372f, -0.05331647f, 
    -0.17362469f, 0.09529791f, -0.07803202f, -0.28543648f, -0.01137487f, -0.12952115f, 0.09531297f, 0.06303123f, 
    0.03931345f, 0.13642189f, -0.14534868f, -0.01758071f, 0.21320578f, 0.09810720f, 0.16807030f, 0.13443598f, 
    0.08699254f, 0.07568287f, -0.08608770f, 0.13919085f, 0.01359272f, 0.04278897f, 0.08247272f, -0.01229835f, 
    -0.36060485f, -0.06403207f, 0.12033941f, 0.03500167f, -0.01270109f, 0.01280673f, 0.00781222f, -0.07358991f, 
    -0.03408223f, -0.03295611f, -0.13686903f, 0.08835191f, -0.15100579f, -0.19822501f, -0.13809097f, 0.11137103f, 
    -0.11486582f, -0.03745241f, 0.04801701f, -0.12675188f, -0.09112689f, 0.01058565f, -0.09875266f, -0.03747289f, 
    0.29608715f, 0.14075452f, 0.03404326f, 0.31370321f, 0.03685545f, 0.03831242f, 0.00203957f, 0.01881301f, 
    -0.10928538f, -0.05603732f, -0.04142324f, 0.05202299f, 0.06077534f, -0.06677265f, -0.06282683f, -0.23914054f, 
    -0.12496088f, -0.04658740f, 0.00955171f, 0.00435842f, 0.01122788f, -0.01178889f, -0.00052580f, -0.16330387f, 
    -0.10846359f, 0.41166764f, 0.07773370f, 0.01899249f, 0.00768792f, -0.03224916f, 0.05152076f, 0.13316509f, 
    0.02573212f, -0.03116225f, 0.05899333f, 0.01404504f, 0.35697055f, 0.22152449f, 0.35788566f, 0.19007885f, 
    -0.04901467f, 0.11817817f, 0.02364348f, 0.05106481f, -0.00041518f, 0.00345637f, -0.01728537f, -0.06804197f, 
    0.10182846f, 0.05397626f, 0.08128478f, 0.27190587f, 0.07566862f, 0.01113780f, -0.05913472f, 0.03257119f, 
    0.03733831f, -0.01784411f, -0.00953989f, 0.07105292f, 0.01792580f, -0.34295386f, -0.19999962f, 0.02183401f, 
    -0.05664336f, 0.03350301f, -0.05212653f, -0.09527649f, -0.06385204f, 0.03301650f, 0.05687981f, 0.01808798f, 
    -0.07232130f, -0.08943848f, -0.06679273f, -0.00819013f, -0.04039785f, -0.00593358f, -0.15903088f, -0.18108925f, 
    -0.01827849f, 0.00016372f, 0.02291598f, 0.05157774f, 0.20103972f, 0.24870561f, 0.04886263f, 0.05777538f, 
    0.06053362f, 0.09564351f, 0.01756745f, -0.04009082f, 0.08583292f, -0.11036720f, -0.02005018f, 0.01995632f, 
    0.28460521f, -0.04013707f, -0.06610496f, 0.10500426f, 0.08281843f, 0.02252223f, -0.01681642f, -0.12247296f, 
    0.00947004f, 0.10027991f, -0.02142214f, -0.07697657f, 0.14210996f, 0.18730548f, -0.04255002f, 0.17423247f, 
    0.23487416f, -0.04531151f, 0.00747926f, -0.13201375f, -0.05639371f, 0.01275550f, -0.11335512f, 0.02307755f, 
    -0.23561293f, -0.09116652f, -0.01417283f, -0.03954921f, -0.10015114f, -0.05498894f, -0.05040358f, 0.06214494f, 
    -0.01830715f, 0.02568743f, -0.01221399f, -0.17979953f, 0.37447166f, 0.26727709f, 0.00844243f, 0.00282218f, 
    -0.02347785f, 0.07095416f, 0.10406643f, 0.16444065f, -0.20128387f, 0.03117255f, 0.08644658f, -0.00183813f, 
    -0.34227118f, -0.21456188f, 0.24940255f, -0.06355765f, -0.08300172f, -0.02778462f, 0.06477989f, -0.10573485f, 
    -0.11933045f, 0.05806435f, 0.12703249f, 0.02833077f, -0.07765953f, -0.15647149f, 0.02639491f, -0.01866067f, 
    -0.06309868f, -0.12975584f, 0.07286405f, 0.06054051f, 0.17619668f, 0.13447027f, 0.16863067f, -0.00784638f, 
    -0.09494721f, -0.12982211f, -0.07075123f, -0.12110666f, -0.00392561f, 0.03040910f, -0.02569581f, 0.01874949f, 
    -0.02919900f, 0.02423936f, -0.07997461f, -0.02075245f, -0.12503308f, 0.09713110f, -0.03876190f, -0.24389611f, 
    0.01291532f, -0.01503556f, -0.10804847f, -0.03448200f, -0.02496056f, -0.10362390f, 0.07463863f, -0.00156824f, 
    0.06741763f, 0.23855475f, -0.22249143f, -0.03332890f, 0.17458043f, -0.04027614f, 0.05134660f, -0.05630779f, 
    -0.14217192f, -0.01527374f, -0.02423691f, -0.09581128f, 0.12249074f, 0.13477758f, 0.08442977f, -0.15287550f, 
    -0.07865991f, -0.17368455f, 0.08813360f, -0.03462379f, 0.01740285f, 0.02272029f, 0.03246974f, -0.08163974f, 
    -0.48874673f, 0.21424635f, 0.23276302f, -0.06721132f, -0.02231813f, 0.08247172f, 0.25326282f, 0.08108214f, 
    -0.13662705f, -0.06751177f, 0.21487439f, 0.02061380f, 0.15779677f, -0.06449724f, -0.04156022f, -0.08161826f, 
    0.17840615f, -0.08978170f, 0.07651251f, -0.05159656f, 0.04204913f, -0.00117186f, 0.06357550f, -0.08859252f, 
    0.05756522f, 0.09232103f, -0.05408067f, -0.04911539f, -0.11078360f, 0.02942142f, -0.05272289f, 0.02232416f, 
    -0.05988431f, -0.00365384f, 0.00914881f, -0.05295163f, -0.08466266f, 0.27459738f, 0.04616231f, -0.16095492f, 
    -0.00377603f, -0.07024152f, 0.25427556f, 0.02084573f, -0.01185561f, -0.02388345f, 0.10577090f, 0.06292113f, 
    -0.07389201f, -0.23716323f, 0.03228277f, 0.12901507f, 0.01495568f, 0.12704636f, -0.04294184f, 0.00701240f, 
    -0.05506556f, -0.03700362f, -0.01052520f, -0.01293976f, 0.24459939f, -0.04941067f, -0.00877799f, 0.07312848f, 
    -0.03017721f, -0.10628659f, 0.05961650f, -0.01124862f, 0.05359365f, 0.03815408f, 0.16651575f, 0.09226884f, 
    -0.17333795f, 0.00423274f, -0.01491287f, -0.10122231f, -0.06785826f, -0.19022073f, -0.09358323f, -0.15492554f, 
    0.10684210f, 0.19209675f, 0.12046251f, 0.05789001f, 0.03972036f, 0.20713934f, -0.07620065f, 0.02240046f, 
    0.02064339f, -0.13396750f, 0.07906347f, 0.17903355f, -0.06156962f, 0.10409521f, 0.09457982f, -0.00299711f, 
    0.04396524f, 0.04003535f, 0.18131158f, -0.01683796f, -0.09088863f, 0.07357023f, 0.06289800f, 0.13264561f, 
    -0.00733963f, -0.05172730f, 0.07000713f, 0.03786184f, 0.25377646f, 0.14682773f, -0.03829275f, -0.07182100f, 
    0.02998258f, 0.02184827f, -0.03089718f, 0.01927325f, -0.01496416f, -0.00331236f, 0.05105780f, 0.10493986f, 
    -0.07467932f, -0.17758936f, -0.00932711f, -0.12278521f, -0.09592051f, 0.03580787f, 0.16540173f, 0.08274469f, 
    0.06031342f, 0.00164108f, 0.00868106f, 0.02937934f, -0.03221490f, -0.09609842f, -0.09021971f, -0.07657520f, 
    0.05614021f, -0.00863188f, 0.04752893f, 0.14151517f, 0.07661922f, -0.12800269f, -0.06384986f, -0.04084894f, 
    0.05223411f, -0.13822301f, -0.06055574f, -0.08771073f, -0.06524984f, -0.03774759f, 0.00305204f, 0.09254482f, 
    0.14199930f, 0.08989020f, 0.15357213f, 0.08545225f, 0.11967266f, -0.05666304f, -0.13099161f, -0.00290419f, 
    -0.02601821f, 0.20480670f, -0.01722772f, 0.13245089f, -0.06594215f, 0.12922315f, 0.13954389f, 0.02773771f, 
    -0.00155725f, 0.06740257f, 0.16998670f, -0.16759396f, 0.07267675f, 0.17717725f, 0.11478850f, 0.08091097f, 
    -0.01324843f, 0.01968447f, 0.07817098f, 0.05795147f, -0.11057632f, 0.12057061f, 0.01491672f, -0.07778304f, 
    -0.05196764f, 0.11119855f, -0.09953915f, 0.05660559f, -0.01099456f, 0.04525499f, -0.08080883f, 0.03823045f, 
    -0.11311994f, 0.08592714f, 0.39352167f, -0.02810697f, 0.01435141f, 0.01267463f, 0.11063568f, -0.07178122f, 
    0.07967134f, -0.11520488f, 0.17484547f, 0.01565165f, 0.12731627f, -0.01525997f, -0.02425945f, -0.10651871f, 
    -0.13885526f, -0.19643769f, 0.00371477f, 0.08492834f, -0.01290376f, 0.04202297f, -0.06130552f, -0.04264541f, 
    -0.09690397f, 0.00513651f, 0.09857056f, -0.02257226f, 0.02525909f, 0.08755150f, 0.11489329f, 0.15600483f, 
    -0.00207593f, -0.00156615f, -0.07466727f, -0.04421211f, -0.02473879f, -0.15782838f, -0.04225898f, -0.08941236f, 
    0.20877185f, 0.15722165f, -0.12275998f, -0.09616885f, 0.00920264f, -0.10867368f, -0.14140101f, -0.06120775f, 
    0.06281655f, 0.09164200f, 0.04020902f, -0.04030982f, 0.00016877f, -0.06620850f, -0.04805751f, -0.02473870f, 
    0.17760471f, 0.13172624f, 0.10900201f, 0.02706109f, -0.13960448f, -0.13113353f, 0.10719921f, -0.14056222f, 
    -0.02943424f, 0.05426303f, -0.00613178f, -0.02150112f, -0.16339774f, 0.03418970f, -0.06545641f, 0.06908416f, 
    0.28475973f, -0.15397644f, -0.13534501f, 0.03020133f, 0.18098712f, 0.03869715f, 0.00806664f, -0.14114091f, 
    0.16279522f, 0.20070881f, 0.30233338f, 0.10250047f, 0.08038292f, 0.02116808f, 0.20339224f, 0.03858902f, 
    0.14937615f, 0.05082075f, 0.19235960f, -0.00486401f, -0.03007966f, 0.10539767f, 0.08416051f, 0.09122790f, 
    0.05562652f, -0.01264307f, 0.02841146f, -0.02616492f, 0.02726161f, 0.04608734f, 0.12627701f, 0.03967452f, 
    0.00599360f, 0.01045411f, -0.07066460f, -0.01969683f, -0.13418983f, 0.04066117f, -0.11291361f, -0.24565347f, 
    0.11206328f, -0.14270578f, -0.10154638f, -0.00362027f, -0.03675136f, -0.04259089f, -0.09820426f, -0.07785970f, 
    0.11223527f, 0.05656052f, -0.00636106f, -0.09386522f, 0.02530971f, -0.02323513f, 0.10150795f, 0.24214724f, 
    0.03769704f, -0.02454853f, 0.19499385f, 0.07573336f, -0.00881060f, -0.06655674f, 0.06960683f, 0.05701600f, 
    -0.00536497f, 0.00465400f, -0.00316370f, -0.11614297f, 0.19266920f, 0.02902750f, 0.24717025f, 0.18861207f, 
    -0.10354912f, -0.05211265f, -0.02479616f, -0.27983826f, -0.10741213f, 0.00277543f, 0.17606217f, 0.06064674f, 
    -0.04443755f, -0.16365795f, -0.04344738f, 0.01913238f, -0.24068074f, -0.11760781f, -0.11689072f, -0.23363940f, 
    0.04952353f, -0.01845139f, 0.00584440f, 0.00753376f, -0.04652533f, -0.15919790f, 0.03059910f, -0.01866564f, 
    0.10290717f, -0.02416067f, 0.01812425f, -0.04654704f, 0.09886733f, 0.08822611f, 0.06034613f, 0.02071152f, 
    0.12080342f, 0.08373202f, 0.00223695f, -0.08017462f, 0.02157552f, -0.24933399f, -0.08201491f, -0.16133556f, 
    0.10996380f, 0.02916832f, 0.11460591f, 0.00446339f, 0.00744594f, -0.03370645f, -0.07268230f, -0.06677991f, 
    -0.27147558f, -0.03875262f, -0.00272520f, -0.05219454f, -0.07165064f, 0.00414576f, 0.03284521f, -0.02702631f, 
    -0.02231722f, 0.00587678f, 0.00747173f, -0.05565479f, -0.14728425f, -0.31761834f, 0.03623329f, -0.08297790f, 
    0.15757382f, 0.04833005f, 0.18475300f, 0.05835811f, -0.00920069f, -0.03395185f, -0.06274816f, -0.19162375f, 
    -0.26803780f, 0.21699017f, -0.01740085f, 0.21022940f, -0.08310612f, -0.06385232f, 0.23917207f, 0.22909729f, 
    0.20140818f, 0.04221179f, 0.13231748f, 0.18091983f, -0.04751005f, 0.07177465f, -0.00471974f, -0.07463206f, 
    0.06735356f, 0.03202439f, -0.00564839f, 0.21540174f, -0.02745176f, -0.02216483f, -0.01334698f, 0.06628815f, 
    -0.14905326f, 0.09089468f, 0.13454369f, -0.05470861f, 0.08301478f, -0.00521924f, 0.11317009f, 0.05871251f, 
    0.05120283f, 0.01938897f, 0.04810867f, 0.13786966f, 0.31844133f, -0.36511612f, 0.19032066f, 0.11640319f, 
    0.22284645f, 0.00521241f, -0.07083179f, -0.01430451f, 0.08595748f, 0.09354493f, 0.16238105f, -0.15144576f, 
    -0.29214758f, 0.13899030f, -0.13558926f, -0.33280107f, 0.04820580f, 0.00956483f, 0.04153236f, 0.12875456f, 
    0.04339775f, -0.17903519f, 0.04143940f, 0.03444258f, 0.09425196f, 0.02872188f, -0.06910501f, 0.03859521f, 
    0.00815548f, -0.10208149f, 0.24018325f, 0.04023760f, -0.20869856f, 0.08225001f, 0.02413278f, 0.15656233f, 
    0.13010347f, 0.03991985f, -0.07498592f, -0.01588767f, 0.01730947f, -0.14906101f, 0.08731417f, 0.16867496f, 
    -0.03667015f, 0.02224121f, 0.04850155f, -0.02294006f, 0.06756469f, -0.00079696f, 0.13742194f, 0.00843544f, 
    0.01745713f, 0.05135772f, 0.03003152f, -0.01965607f, 0.17925438f, -0.04028583f, 0.03532744f, 0.11143703f, 
    0.17408000f, -0.05663319f, -0.10909603f, -0.04634240f, 0.08119576f, 0.03814214f, 0.06180004f, 0.01565806f, 
    -0.02777502f, 0.16300537f, -0.04442976f, 0.00669178f, -0.10488783f, -0.02565558f, -0.08678386f, -0.14766075f, 
    -0.07501771f, -0.00361368f, 0.11011051f, -0.07799359f, -0.16407101f, -0.07795095f, -0.03500927f, 0.03244561f, 
    0.09687772f, -0.02529124f, -0.02716286f, -0.09886231f, -0.03560835f, 0.03109988f, -0.04771672f, 0.04962361f, 
    -0.00879358f, -0.00529242f, 0.02045008f, -0.09045530f, 0.14406732f, -0.03624681f, 0.14229399f, 0.05821542f, 
    -0.02345082f, -0.02126577f, -0.05327019f, 0.00366289f, 0.00010998f, -0.04059706f, 0.00937389f, -0.06315424f, 
    -0.21144637f, -0.19008176f, 0.15154366f, 0.10306757f, 0.01068081f, 0.02068100f, 0.33788142f, -0.04122628f, 
    -0.08858775f, -0.01209559f, 0.16259979f, 0.07364921f, 0.06594098f, 0.09107561f, 0.03789261f, -0.10710151f, 
    0.01564160f, 0.07639122f, -0.02016398f, 0.05429904f, 0.00974742f, 0.00323820f, -0.00479389f, -0.05930977f, 
    0.12590943f, -0.30603912f, 0.11271451f, -0.05494981f, 0.04216922f, -0.05721319f, -0.00059760f, 0.05067939f, 
    0.04838077f, 0.01876785f, -0.01415135f, -0.08990760f, -0.42348695f, -0.08160727f, -0.20723937f, -0.25629398f, 
    -0.10097747f, 0.06741111f, -0.02080996f, 0.01163156f, 0.03259042f, 0.03839567f, -0.10268936f, -0.00240796f, 
    -0.15102462f, -0.13248229f, -0.12493881f, -0.09991904f, -0.12379205f, -0.25963670f, -0.01208944f, -0.02061791f, 
    0.04576606f, 0.00654060f, -0.03021395f, -0.05199497f, 0.07323381f, 0.03684086f, 0.00472224f, -0.05311331f, 
    0.00648953f, 0.05682309f, 0.04983616f, 0.03285871f, -0.00889937f, -0.00037064f, 0.06198858f, -0.07639118f, 
    0.06140852f, 0.07214231f, -0.03324868f, 0.01061271f, 0.05042167f, 0.04640793f, -0.06756783f, 0.01004733f, 
    0.11977892f, 0.12455594f, 0.05351722f, 0.11079229f, 0.09873965f, -0.10029066f, -0.11850170f, -0.16529965f, 
    0.06593191f, -0.05835184f, 0.11057717f, 0.05045061f, 0.04465190f, -0.18345135f, 0.19388539f, 0.28629297f, 
    0.05937367f, -0.05349895f, 0.00172169f, -0.02920328f, -0.03390734f, -0.09316573f, -0.07758527f, -0.08558386f, 
    -0.09330716f, -0.11596259f, 0.05683567f, 0.12425012f, 0.14002460f, -0.13694124f, -0.01284550f, -0.11648807f, 
    0.16055711f, -0.17824289f, 0.14406124f, 0.06337643f, -0.04108631f, 0.10367281f, 0.20203087f, 0.05657514f, 
    0.05543104f, -0.12183060f, 0.07351876f, 0.01607664f, 0.13916661f, 0.10909775f, 0.04463721f, -0.00484013f, 
    -0.06121498f, 0.04282309f, 0.03373160f, -0.04224045f, -0.11671631f, 0.17684270f, -0.05363170f, 0.04292468f, 
    -0.18865600f, -0.13626751f, 0.03710338f, 0.06879739f, 0.03260633f, -0.02468972f, 0.03448441f, -0.04890466f, 
    -0.04850890f, -0.27856174f, 0.01649580f, -0.01477194f, 0.11493281f, 0.02577386f, 0.05816089f, 0.00443479f, 
    -0.05855535f, 0.04425990f, -0.00622518f, -0.15556204f, 0.15278609f, -0.21963082f, -0.04668711f, -0.09957318f, 
    0.08944308f, 0.02438705f, 0.20254245f, 0.07976358f, -0.03750498f, -0.02528319f, 0.08123321f, 0.07922308f, 
    -0.11531554f, -0.17777571f, -0.07264265f, -0.08662992f, -0.11883652f, 0.16649593f, 0.14856499f, 0.19452497f, 
    -0.03126092f, -0.00533184f, 0.01766516f, -0.18133071f, -0.20389506f, 0.08379502f, -0.32842639f, -0.01322693f, 
    0.18475361f, 0.07426382f, -0.02864843f, 0.01029888f, 0.06917775f, 0.00982653f, -0.05948663f, 0.08833650f, 
    0.38550287f, 0.03882645f, 0.09990597f, 0.14889319f, -0.05491885f, 0.00899796f, -0.03838426f, 0.00427567f, 
    0.17461926f, 0.16409425f, 0.04156492f, 0.11619539f, 0.01503726f, -0.30588153f, -0.42021680f, -0.04874334f, 
    -0.05545727f, 0.05184031f, 0.12408074f, -0.08820941f, -0.04527997f, 0.01020333f, -0.07007220f, -0.08786001f, 
    0.65265024f, -0.03880433f, 0.30297664f, -0.09828877f, 0.01844337f, -0.11345957f, 0.10215886f, -0.04070986f, 
    0.11307095f, 0.16131058f, 0.07375016f, -0.01207833f, 0.11185752f, -0.11911365f, -0.22956392f, 0.11071134f, 
    0.10915282f, -0.01698249f, 0.28251532f, 0.11646873f, 0.14940065f, -0.04213537f, 0.00393110f, 0.03117896f, 
    0.02691896f, 0.00596137f, -0.06556576f, 0.03140055f, -0.09038997f, 0.05120957f, 0.05746242f, -0.03222998f, 
    0.01641220f, -0.01437807f, -0.09249493f, 0.03338145f, 0.07464572f, -0.20089984f, -0.24240479f, -0.18800071f, 
    0.00806490f, 0.02274158f, 0.13086851f, 0.07213063f, 0.02869353f, -0.23620915f, -0.02812933f, -0.12693878f, 
    -0.30010545f, -0.10675035f, -0.20705380f, -0.12187281f, 0.01043622f, -0.01902294f, 0.08647046f, 0.09203827f, 
    -0.01335689f, 0.00718335f, 0.02983306f, -0.03287127f, -0.01236720f, 0.01360405f, 0.06619587f, 0.11621684f, 
    0.03655971f, -0.10549980f, 0.07045300f, -0.05249060f, -0.01696843f, 0.00667320f, -0.11611862f, 0.05802449f, 
    0.05784618f, -0.01169469f, -0.07603108f, 0.09555813f, 0.22788613f, -0.07752375f, 0.05293828f, 0.08401994f, 
    -0.08124264f, -0.01329813f, 0.08484298f, 0.01718643f, -0.06595923f, -0.13176273f, 0.05537272f, 0.20563494f, 
    -0.04815429f, -0.08269873f, -0.03609928f, 0.17436546f, 0.15084040f, 0.02927315f, 0.10818201f, -0.04947435f, 
    -0.00403373f, 0.04228671f, -0.00071349f, -0.16445339f, 0.04012478f, -0.02084891f, 0.02645055f, 0.15813981f, 
    -0.01442559f, -0.05273576f, 0.01741987f, 0.07264043f, 0.20121932f, 0.11244710f, 0.21298559f, 0.04346039f, 
    -0.11082045f, -0.11609294f, -0.07415000f, -0.13281210f, 0.02627503f, 0.09268694f, 0.10509986f, 0.12462141f, 
    -0.07654007f, 0.05508751f, -0.04717034f, -0.13470085f, -0.01479563f, 0.20926653f, -0.06869098f, -0.10965455f, 
    -0.05346368f, -0.13339959f, -0.03607861f, -0.12835948f, -0.14431262f, -0.10227112f, -0.31460893f, -0.40406013f, 
    0.03304438f, -0.19730960f, 0.00841077f, 0.11318348f, 0.00659749f, -0.00089540f, 0.00035111f, 0.01011186f, 
    -0.13032311f, -0.07474137f, -0.05203051f, -0.05868130f, 0.02141969f, 0.16145928f, 0.00616349f, 0.18425079f, 
    0.19557498f, 0.12322777f, 0.14356673f, -0.21952644f, 0.05723173f, 0.05526890f, -0.03674620f, 0.19577278f, 
    0.03555369f, 0.14623569f, 0.20910385f, -0.06963674f, 0.05879410f, 0.15631250f, -0.08136235f, 0.16088672f, 
    0.22256947f, 0.05977481f, -0.22548969f, -0.09623219f, 0.04091793f, -0.00012193f, 0.03478293f, 0.16853608f, 
    -0.05669428f, 0.06185681f, 0.02309946f, -0.04169997f, 0.16776860f, -0.05567676f, 0.00400661f, -0.00985506f, 
    -0.03561280f, 0.19294463f, -0.02697401f, 0.06945231f, 0.05120021f, 0.01070915f, -0.00973677f, -0.06045853f, 
    0.21020372f, -0.00805578f, 0.15896998f, -0.17276856f, -0.00310239f, 0.03789883f, -0.02036824f, 0.24463917f, 
    0.17192526f, -0.03723792f, 0.04007079f, 0.00772115f, -0.09691531f, -0.19008203f, 0.14710300f, -0.13272983f, 
    -0.16767469f, -0.08849355f, -0.03204408f, 0.12619396f, -0.15914200f, -0.01368069f, -0.01428333f, -0.07911505f, 
    0.03992885f, -0.14529821f, -0.03517377f, 0.09296869f, 0.07994299f, 0.06175734f, 0.20741764f, -0.02570346f, 
    0.03110916f, 0.05577130f, 0.00209066f, 0.04382441f, 0.13878568f, 0.03463449f, -0.04539845f, -0.11355285f, 
    0.13292331f, -0.03667242f, -0.00291450f, 0.10764299f, 0.09990918f, 0.07055214f, -0.15141818f, 0.12379445f, 
    -0.02742628f, 0.05975414f, 0.13324058f, -0.01927457f, -0.08513261f, -0.03947825f, -0.04410265f, -0.02326039f, 
    -0.05465065f, 0.03873818f, 0.18274845f, 0.00585712f, 0.39304769f, -0.10632640f, 0.08707152f, -0.00666804f, 
    0.04226221f, 0.12313794f, 0.17159007f, 0.01394936f, 0.38687631f, 0.16598804f, 0.17988169f, 0.01001616f, 
    -0.01056337f, -0.10533089f, 0.00997367f, 0.03681944f, -0.02666999f, 0.03067084f, -0.00498902f, -0.07702447f, 
    0.10262773f, -0.06742501f, 0.03777578f, -0.12487216f, -0.21031755f, 0.05834638f, -0.10012537f, 0.03245125f, 
    0.13991341f, 0.05672055f, -0.01407724f, 0.05489004f, -0.05537375f, 0.03335865f, 0.20273256f, 0.02066972f, 
    0.06281514f, -0.02542338f, -0.00753008f, -0.01448465f, -0.00146423f, -0.10727723f, -0.04996116f, 0.07075777f, 
    0.06535517f, 0.14018942f, 0.00121023f, 0.05358156f, -0.19803216f, -0.10379658f, 0.02027530f, -0.20467903f, 
    0.03848101f, 0.04327622f, 0.15072598f, -0.02611858f, 0.03482813f, 0.04653834f, -0.09291346f, -0.01941655f, 
    0.07241815f, 0.09767515f, -0.15813480f, -0.01970431f, 0.00121414f, -0.05182170f, 0.13793381f, 0.28565198f, 
    -0.06242418f, 0.22028226f, 0.18118311f, 0.11338057f, 0.05996696f, -0.02917933f, 0.00965639f, -0.17016438f, 
    0.06683699f, 0.01631152f, 0.04540607f, 0.15705730f, 0.01701950f, -0.01057708f, 0.02433760f, -0.20178851f, 
    0.18840012f, 0.12932838f, 0.06164660f, -0.07452744f, -0.11846075f, -0.01028807f, 0.07222715f, 0.04574455f, 
    -0.07578193f, -0.01844347f, -0.21036346f, -0.11805634f, 0.01236332f, 0.07477682f, -0.11363805f, -0.15111940f, 
    -0.15088393f, -0.13453162f, -0.06810759f, 0.04122764f, 0.03051328f, -0.03920342f, -0.11603508f, -0.02748837f, 
    0.27388200f, -0.09380530f, 0.24777988f, -0.01778997f, -0.07063474f, -0.00944940f, -0.08306717f, 0.00924948f, 
    0.15087321f, -0.03864514f, 0.01014137f, 0.09556583f, 0.09816593f, -0.08454479f, -0.08490723f, -0.17901185f, 
    0.09535049f, -0.15532339f, 0.03639084f, 0.00109440f, -0.03137729f, -0.02836325f, 0.02632575f, 0.01231598f, 
    -0.12605114f, -0.19693084f, -0.20269236f, -0.16779503f, 0.06557078f, -0.06440414f, -0.07441430f, 0.05620424f, 
    -0.29431391f, 0.03608021f, 0.12051333f, 0.03649918f, 0.23018299f, -0.16596526f, -0.10568270f, -0.19019206f, 
    0.01853731f, -0.13273591f, 0.12035457f, -0.27151483f, -0.17867903f, 0.01208267f, 0.05855840f, 0.05078018f, 
    0.49823901f, -0.01108294f, 0.18198699f, -0.16221949f, 0.05270269f, 0.13138835f, 0.03364696f, 0.14974155f, 
    0.15759656f, -0.02978870f, 0.19143754f, 0.08577646f, -0.02111985f, 0.21598779f, -0.11230407f, -0.13568373f, 
    -0.05487763f, -0.10163969f, 0.18297698f, -0.08131440f, 0.05040959f, -0.03478197f, 0.08603253f, 0.05943343f, 
    0.12358809f, -0.06002922f, 0.20021629f, -0.08496270f, -0.01545962f, 0.14087996f, -0.01187953f, 0.04079152f, 
    -0.01189598f, 0.24166961f, -0.00486545f, -0.05069770f, 0.29491651f, -0.15799767f, 0.07084204f, -0.05627626f, 
    0.08569682f, 0.04334619f, 0.00518470f, 0.17143683f, 0.09444533f, 0.11345258f, 0.26324898f, 0.02998515f, 
    -0.40916607f, -0.09058101f, -0.18797188f, -0.03065119f, 0.08242730f, 0.06972383f, 0.24309377f, 0.00152287f, 
    0.02432847f, 0.21219487f, 0.05987073f, 0.21431227f, 0.01878163f, 0.00527631f, 0.01522701f, 0.07264682f, 
    -0.02280360f, -0.10902808f, -0.14248638f, -0.25882128f, 0.22890493f, -0.03422328f, 0.09689166f, 0.12360428f, 
    0.01398857f, -0.09258315f, -0.08043174f, -0.05301229f, -0.08975764f, -0.14579007f, -0.01014956f, 0.39170960f, 
    -0.16383983f, 0.04128460f, 0.01563985f, 0.09493373f, 0.10312047f, 0.02139103f, 0.12263730f, -0.05365691f, 
    0.04338554f, 0.06882210f, -0.05465563f, -0.00790483f, 0.09844811f, 0.10216838f, 0.07229280f, -0.15121914f, 
    -0.03319432f, 0.09270380f, -0.11581198f, 0.03599965f, -0.03194536f, 0.21651076f, 0.19598478f, -0.04706243f, 
    0.13667433f, 0.00164397f, 0.09542073f, 0.03405416f, 0.00900761f, -0.00313077f, 0.11912907f, -0.18531594f, 
    0.01634552f, 0.02750344f, 0.03012449f, 0.02902206f, -0.02010479f, -0.08925860f, -0.08826602f, -0.12612262f, 
    0.08533224f, 0.07505450f, 0.08272114f, 0.00345964f, -0.04622802f, 0.02556807f, -0.00598351f, 0.05074872f, 
    0.07991964f, 0.11099249f, -0.02385397f, -0.05510234f, -0.03607460f, 0.27214620f, 0.01392371f, -0.10537370f, 
    -0.11241458f, -0.07269511f, 0.02062855f, -0.04798177f, 0.01657959f, -0.00131074f, -0.04428837f, 0.05083969f, 
    0.38017038f, 0.14975503f, -0.16814801f, 0.03386873f, 0.08264714f, -0.03992666f, 0.06466281f, -0.13143063f, 
    0.00774868f, 0.09409066f, 0.07449599f, 0.06809711f, -0.03079266f, -0.00102144f, -0.21639594f, -0.01293499f, 
    -0.10331524f, -0.05142818f, 0.10104122f, -0.10561585f, -0.07320074f, 0.01026005f, 0.00183898f, 0.01712860f, 
    -0.24647325f, -0.15342847f, 0.05706296f, -0.04163661f, -0.07310294f, -0.08630289f, 0.02191640f, -0.06807049f, 
    -0.07345464f, -0.10562979f, 0.03260206f, 0.07207114f, -0.29639256f, 0.06966010f, -0.13908322f, -0.13337165f, 
    0.08428394f, 0.10268737f, -0.06142712f, 0.14991976f, 0.04448971f, 0.04016656f, -0.13712829f, -0.10895283f, 
    -0.17057350f, -0.13995120f, -0.08188674f, -0.14742550f, 0.09131680f, 0.01054107f, -0.14343302f, 0.06037480f, 
    -0.17817558f, -0.03629528f, 0.09854741f, 0.00973391f, 0.01190842f, 0.10158045f, 0.20225473f, -0.01644745f, 
    -0.04749664f, -0.13272657f, -0.03952340f, -0.10707129f, -0.00337505f, 0.08127497f, -0.03644423f, 0.11289443f, 
    0.04330546f, 0.06544846f, 0.06161108f, 0.01874103f, -0.07265092f, -0.01501881f, -0.04185454f, -0.04513799f, 
    0.03013918f, -0.00406059f, 0.14792560f, -0.02084779f, 0.10766380f, 0.09185227f, 0.05676771f, 0.04622002f, 
    -0.03235543f, 0.12581506f, -0.05008231f, -0.00083802f, 0.07217866f, -0.08779770f, -0.01291171f, -0.02411769f, 
    -0.13433716f, 0.14782770f, 0.14903030f, 0.10910913f, -0.12570250f, -0.09772456f, -0.12344252f, -0.10932224f, 
    0.01058794f, 0.04827662f, 0.09106845f, 0.10058706f, 0.32360095f, -0.13094550f, -0.10779004f, 0.13920745f, 
    0.18219224f, -0.02120485f, -0.04501982f, 0.02557994f, 0.03378387f, -0.10273580f, 0.05659148f, -0.14463195f, 
    -0.03396685f, 0.05386109f, -0.06846303f, -0.12957118f, 0.06637391f, -0.00420643f, -0.14675261f, 0.00180877f, 
    -0.00132917f, 0.05757627f, 0.00294494f, 0.13281444f, 0.00038626f, -0.06112796f, -0.10149237f, -0.20299816f, 
    -0.00143672f, -0.09522334f, -0.13571380f, -0.16324709f, 0.00276760f, 0.09166898f, 0.05135897f, 0.09244173f, 
    -0.10490581f, 0.09913186f, 0.16990973f, 0.09538420f, 0.03810965f, 0.01781527f, 0.01937631f, 0.22340879f, 
    0.19711106f, -0.16774619f, -0.10880408f, 0.20101862f, -0.02539201f, 0.06333046f, 0.07661416f, -0.01163625f, 
    -0.04855571f, -0.04898389f, 0.02527804f, 0.02160347f, 0.07089133f, 0.03644446f, -0.05147950f, -0.18360658f, 
    0.09297460f, 0.14805323f, 0.10289275f, 0.11483222f, -0.00415241f, -0.09732081f, -0.05570403f, 0.03757425f, 
    -0.01645292f, 0.01590458f, -0.07702187f, 0.01367370f, 0.04690989f, -0.25065437f, 0.08876633f, -0.02334330f, 
    0.05305864f, -0.08296481f, 0.10068163f, 0.01780322f, -0.01863320f, -0.03090389f, -0.05022731f, -0.05150810f, 
    -0.51884311f, -0.15415308f, -0.04905990f, 0.14580904f, 0.02870299f, 0.14072420f, 0.04137279f, -0.06055688f, 
    -0.03457192f, 0.02901924f, -0.07272346f, 0.02412760f, 0.13554649f, 0.14010866f, 0.05034944f, 0.19467366f, 
    -0.06622251f, -0.12712009f, 0.03737378f, 0.12873285f, -0.00857976f, -0.05335470f, 0.00230387f, -0.02981196f, 
    0.21024287f, 0.40916127f, 0.43003961f, -0.24889995f, -0.03176131f, 0.01412586f, -0.10814705f, 0.10201269f, 
    -0.13324545f, -0.00771905f, 0.08358459f, 0.08459614f, -0.25129166f, 0.17033628f, 0.05567212f, 0.06770093f, 
    0.09352739f, 0.10791460f, -0.14192207f, -0.03185913f, -0.06697883f, -0.04427561f, -0.02682085f, -0.04754360f, 
    0.12384206f, 0.08484404f, -0.03465911f, 0.01415609f, 0.03939694f, 0.00223994f, -0.05457259f, -0.02984782f, 
    0.03544014f, -0.05490313f, 0.03758894f, -0.01427334f, -0.16574542f, 0.00874781f, 0.21178684f, -0.07550896f, 
    -0.04519246f, -0.07581959f, 0.00116394f, -0.11065033f, -0.02498478f, -0.01506152f, 0.00202131f, 0.12128012f, 
    -0.12553838f, 0.15176269f, -0.02497156f, 0.22266886f, -0.03546771f, -0.07927640f, 0.09018184f, 0.00625535f, 
    0.07226654f, 0.03539310f, -0.05916022f, 0.18572779f, 0.28444090f, 0.09644430f, -0.02419603f, 0.01096536f, 
    0.02175305f, -0.08237071f, -0.09522653f, 0.13051350f, -0.02166176f, -0.07454620f, 0.06198166f, 0.05445747f, 
    -0.08191964f, -0.07795000f, 0.10985889f, 0.07635060f, 0.05443410f, 0.06686039f, 0.00204534f, 0.11625212f, 
    0.06778938f, 0.13825859f, -0.14634472f, 0.06771240f, 0.08398128f, -0.03906157f, 0.00811961f, -0.29572988f, 
    -0.06132416f, 0.14345136f, 0.03131515f, -0.00498422f, 0.05412153f, 0.07649649f, -0.02263855f, -0.05633156f, 
    -0.00850009f, 0.01470938f, 0.14870532f, 0.02478424f, 0.00438205f, -0.06554626f, -0.02111402f, -0.05989880f, 
    0.11721054f, 0.00690376f, -0.07935581f, -0.01856698f, -0.03016034f, -0.01009602f, 0.10776274f, 0.05917244f, 
    0.12093725f, -0.03799807f, -0.12896985f, 0.03775080f, 0.19347055f, 0.11832687f, 0.03341650f, 0.09642643f, 
    -0.01526202f, 0.11372662f, 0.01977871f, 0.11214481f, -0.15440433f, -0.28159034f, -0.05541458f, 0.02241331f, 
    -0.01530799f, -0.01178189f, -0.06607658f, -0.06951391f, -0.05906497f, -0.03531009f, 0.03360079f, 0.17090130f, 
    -0.07126269f, 0.02793888f, 0.04451214f, 0.01677139f, 0.07221711f, 0.03310731f, 0.04297026f, 0.00993983f, 
    0.02938099f, 0.11114703f, 0.00769502f, 0.01057020f, -0.00368469f, -0.26605028f, -0.01807502f, -0.07050529f, 
    -0.01408264f, -0.10298161f, -0.02963927f, 0.12427939f, -0.01150756f, 0.12737398f, 0.04054998f, -0.06221332f, 
    0.04876511f, 0.07115569f, -0.13636026f, -0.10226524f, 0.09715638f, 0.09113880f, 0.02704270f, 0.06911974f, 
    0.31649512f, 0.16971044f, 0.26841041f, -0.22653104f, 0.04499350f, -0.00427145f, -0.01474496f, 0.11573065f, 
    0.14483789f, -0.02522261f, -0.02136001f, -0.01151992f, -0.03220956f, -0.00565744f, 0.12142161f, 0.15906560f, 
    0.00427678f, -0.07972635f, -0.00460557f, -0.09011748f, 0.07314845f, -0.01097473f, -0.00753033f, 0.04724765f, 
    -0.06008111f, 0.21203880f, 0.18742894f, 0.05185267f, 0.11848559f, -0.02139857f, 0.08116610f, -0.15280129f, 
    0.06080910f, 0.04218534f, 0.06235651f, -0.00208432f, 0.05709152f, 0.19789387f, 0.04343308f, 0.13168366f, 
    0.04371448f, -0.16938131f, 0.02312236f, 0.02134664f, -0.08132985f, -0.05590787f, 0.02744380f, -0.02695948f, 
    0.04052702f, 0.00623781f, 0.07298381f, -0.03353877f, 0.09490273f, 0.10608532f, 0.03037816f, 0.17582539f, 
    0.05658209f, -0.08490425f, 0.05402773f, 0.12122505f, -0.27928206f, -0.07674962f, 0.05213213f, 0.23093367f, 
    -0.04864176f, 0.09955625f, -0.10979427f, 0.04956045f, 0.08323318f, -0.01686928f, 0.05697316f, 0.03850248f, 
    0.11564505f, -0.03801737f, -0.05284099f, -0.16862464f, -0.06025236f, -0.02874771f, 0.00254308f, -0.01701340f, 
    0.05555620f, 0.03315663f, -0.00261534f, 0.02559649f, 0.08302456f, 0.18013629f, 0.21420860f, 0.11496212f, 
    -0.01647312f, 0.02508942f, -0.09979489f, -0.03424958f, -0.15228911f, -0.08075598f, 0.03304922f, 0.02821560f, 
    -0.33805066f, -0.20800056f, -0.31644025f, 0.19260593f, 0.11199519f, -0.03921348f, -0.22364539f, -0.10159480f, 
    0.12992170f, 0.08184918f, 0.01466530f, 0.04374709f, 0.19000071f, -0.00576443f, 0.15340276f, -0.06008665f, 
    0.10453498f, 0.00172659f, 0.13181356f, -0.03648957f, 0.11413858f, 0.03929804f, 0.07364079f, -0.03721556f, 
    -0.09804189f, 0.03682316f, -0.01270595f, -0.08651540f, 0.18804702f, 0.04346388f, -0.04428370f, -0.00446505f, 
    0.04487255f, -0.03138239f, -0.06891944f, 0.11585315f, 0.04107383f, -0.11092909f, 0.16885304f, 0.04798517f, 
    -0.07986543f, 0.11892175f, 0.14037529f, 0.12213322f, 0.05681611f, 0.06361082f, 0.03313254f, 0.04900961f, 
    -0.01326523f, 0.10931084f, 0.00051150f, 0.01932359f, 0.10315911f, -0.00564845f, -0.11856829f, 0.05808973f, 
    0.14411779f, 0.05485188f, 0.09834392f, -0.06907011f, 0.03664983f, 0.06283999f, 0.01554389f, 0.00756033f, 
    0.00834158f, -0.11397553f, 0.01786357f, -0.10510026f, -0.03621718f, 0.05618577f, 0.00983570f, 0.09603449f, 
    -0.28777057f, -0.19777447f, 0.07253236f, 0.20118104f, -0.09381834f, -0.10917442f, -0.08814717f, -0.02354387f, 
    0.09576937f, 0.00738617f, 0.05427657f, 0.10055781f, -0.19688325f, -0.16253540f, 0.11039919f, 0.22401571f, 
    -0.09489247f, 0.02760538f, -0.03688920f, 0.13864122f, 0.05514707f, -0.02170304f, -0.02294337f, 0.07125921f, 
    -0.21562275f, -0.14274082f, -0.20273450f, 0.05447990f, 0.11482219f, 0.05522288f, -0.04708310f, 0.02995654f, 
    0.06060665f, 0.04463690f, 0.04015044f, -0.00450592f, -0.25954580f, 0.04782869f, 0.11504830f, 0.26799506f, 
    -0.13674815f, -0.03292868f, -0.07683416f, 0.06507147f, 0.00203928f, -0.00982615f, 0.01332173f, -0.08838816f, 
    0.03291743f, 0.25554138f, 0.11612194f, 0.11555789f, -0.00507528f, 0.03124278f, 0.13109681f, 0.07387921f, 
    0.05014251f, 0.00187473f, -0.09439554f, -0.08482008f, -0.18134966f, 0.00374900f, -0.02196669f, 0.15282828f, 
    -0.02387193f, 0.03001905f, -0.16254316f, 0.02106052f, 0.02181874f, -0.00925139f, 0.05058175f, -0.02950474f, 
    -0.17017473f, 0.29112068f, 0.11285384f, 0.06901990f, -0.13984744f, -0.11912053f, 0.07949990f, 0.09674175f, 
    -0.02870069f, 0.08467865f, 0.06410240f, 0.06681145f, 0.05103507f, -0.05153181f, 0.14055929f, -0.22315362f, 
    0.10235009f, 0.14432290f, 0.05061040f, -0.00059675f, 0.01423118f, 0.01534718f, -0.04084556f, 0.12745208f, 
    -0.14054780f, 0.11332054f, -0.03937174f, 0.30313876f, 0.23773751f, 0.03012257f, -0.01405748f, -0.01473028f, 
    0.06480677f, -0.01057163f, 0.23457746f, 0.00859618f, -0.08471321f, 0.01613452f, -0.23280562f, 0.28425232f, 
    -0.12225639f, -0.06440507f, -0.09064081f, -0.18301956f, -0.02239317f, 0.05862862f, -0.12321881f, 0.08162465f, 
    0.05385896f, -0.04076143f, 0.26419204f, 0.06193801f, -0.02905533f, 0.06882604f, -0.08617849f, 0.22275171f, 
    0.03435528f, 0.01435356f, -0.11687256f, 0.05534576f, 0.02917827f, 0.06365680f, -0.19774893f, -0.26492885f, 
    -0.09108277f, -0.16498414f, -0.06646325f, 0.11163954f, -0.02074356f, -0.06791598f, -0.17544729f, -0.03252805f, 
    -0.11845566f, -0.02748417f, 0.08216222f, 0.01176107f, 0.13857737f, 0.11567843f, 0.08763240f, 0.04185193f, 
    0.08913818f, 0.02276218f, 0.15432933f, -0.09939964f, -0.06045033f, 0.08805113f, -0.11484189f, 0.16119450f, 
    -0.04116822f, -0.11329194f, -0.00067009f, -0.05258929f, 0.05415660f, 0.07520294f, 0.10413802f, 0.18569690f, 
    -0.04580203f, 0.15346743f, -0.18872234f, 0.11137112f, 0.12193646f, -0.10724937f, -0.01532505f, -0.07906488f, 
    0.11777975f, 0.08061647f, -0.11313297f, 0.18678883f, -0.03657010f, -0.01388646f, 0.23427026f, 0.19045743f, 
    -0.05569973f, -0.06344137f, 0.06081230f, 0.07866303f, 0.17613700f, 0.04512846f, 0.03246554f, 0.05326476f, 
    0.00242523f, 0.02367335f, -0.17153072f, 0.23134023f, 0.00252057f, -0.01623140f, -0.04541218f, -0.09778680f, 
    0.09757093f, -0.02440200f, 0.03418659f, 0.05036770f, 0.18050072f, -0.07442370f, 0.05504837f, 0.10404635f, 
    -0.13041787f, -0.02911040f, -0.07796032f, -0.08502518f, -0.03555518f, -0.02666354f, -0.02852429f, -0.13123941f, 
    0.00120305f, 0.00301495f, 0.26703438f, -0.01236957f, -0.00590229f, -0.07468086f, -0.16478364f, 0.19430591f, 
    -0.10249098f, 0.01162592f, 0.06739587f, -0.03108744f, 0.28569105f, -0.09244664f, 0.19974494f, -0.07868436f, 
    0.01603140f, 0.05505231f, -0.05463495f, 0.08579168f, -0.02069723f, -0.03428256f, -0.06630654f, -0.08512834f, 
    -0.19071375f, -0.00826930f, 0.06559321f, 0.18412508f, 0.11164880f, 0.04486027f, -0.05538828f, -0.01754029f, 
    -0.06709442f, -0.04250350f, -0.00004339f, -0.02552142f, 0.08352617f, -0.09151623f, 0.25955477f, 0.21488370f, 
    -0.02034596f, -0.06914022f, 0.09889119f, -0.07772321f, -0.00548201f, -0.10523502f, -0.09834883f, -0.05107773f, 
    -0.20315839f, -0.06011202f, 0.08095860f, 0.20091845f, -0.04535887f, -0.04203499f, 0.08672617f, 0.10866058f, 
    0.06849658f, 0.10687738f, -0.02864252f, 0.01613098f, 0.00138232f, -0.16940512f, -0.09830977f, -0.01421671f, 
    -0.10523988f, -0.02305207f, -0.05959258f, -0.04940193f, 0.08520412f, 0.12684710f, 0.06070560f, -0.00151790f, 
    -0.09498776f, -0.08599461f, -0.04119511f, -0.10640465f, -0.10035504f, -0.04584086f, -0.08340560f, -0.02347873f, 
    0.22329734f, 0.09639447f, -0.01157376f, -0.01301871f, -0.01453279f, -0.09881015f, 0.06979103f, 0.09462785f, 
    0.00208550f, -0.08699211f, -0.08696677f, -0.15674423f, 0.03481481f, -0.09262285f, -0.00052496f, 0.08732589f, 
    0.07375060f, 0.07749259f, 0.20360720f, 0.05461864f, 0.01138924f, -0.14360264f, -0.06945565f, -0.00790420f, 
    -0.05310480f, 0.02840780f, 0.02286657f, -0.08635089f, -0.23783238f, 0.06940194f, 0.21350256f, 0.21174087f, 
    -0.01353454f, -0.04299106f, -0.23150395f, 0.03468066f, 0.11798119f, -0.03246804f, -0.10090709f, 0.05192581f, 
    -0.01119384f, -0.09185036f, 0.00926966f, 0.30066743f, 0.19933875f, -0.06376813f, -0.04634404f, 0.05184407f, 
    -0.02615678f, -0.00841036f, -0.10397258f, 0.03664290f, 0.06773497f, 0.06385279f, -0.02729352f, -0.02480755f, 
    0.18707760f, 0.15452924f, 0.14486672f, 0.11948513f, -0.03141315f, -0.05430746f, 0.03334910f, -0.00828991f, 
    -0.03392188f, -0.17113140f, 0.14274935f, 0.14667501f, 0.10281975f, 0.06931657f, -0.04370818f, 0.06587031f, 
    0.18971805f, 0.11507021f, 0.07394073f, 0.04919042f, 0.23664947f, -0.23697591f, -0.11122769f, -0.02667030f, 
    -0.21780874f, 0.09862591f, 0.22070064f, 0.18719114f, -0.00659566f, 0.06821369f, 0.10341395f, 0.30499244f, 
    -0.26593661f, -0.13664632f, -0.32077846f, -0.49008963f, 0.02938201f, 0.00220841f, 0.01493441f, 0.05722814f, 
    0.00340419f, -0.06380715f, -0.04616696f, -0.09495778f, -0.06685450f, -0.11773665f, -0.15432541f, -0.13907768f, 
    0.21730135f, 0.12546419f, 0.12667376f, 0.06927295f, -0.09356601f, -0.02022198f, -0.10185937f, 0.00928607f, 
    0.05802923f, 0.00824579f, 0.14312990f, 0.13623576f, -0.02824319f, 0.13734728f, -0.05679429f, 0.04309418f, 
    0.08353330f, -0.00920731f, 0.04689633f, 0.15630493f, 0.29938498f, -0.14852393f, -0.00924162f, 0.11841268f, 
    0.10920062f, 0.11468709f, 0.15753283f, 0.08468957f, -0.04662530f, -0.01342887f, 0.00259431f, 0.03062781f, 
    0.48970902f, -0.40214226f, -0.23133564f, -0.27635029f, 0.08047596f, -0.10300418f, -0.06667334f, 0.18318760f, 
    -0.00115188f, 0.14644751f, 0.01894445f, 0.00061346f, -0.32147297f, -0.05109128f, -0.07436614f, -0.13437037f, 
    0.11822673f, 0.01106765f, -0.07286203f, -0.02051248f, -0.14817572f, 0.01213126f, -0.01265335f, 0.04146808f, 
    0.11916036f, 0.00591883f, 0.09135554f, 0.12522043f, -0.00670163f, 0.01433918f, -0.01970439f, -0.09209175f, 
    -0.00449760f, -0.06013567f, -0.09368761f, -0.05034284f, 0.13368782f, 0.08062451f, 0.04366230f, 0.06045471f, 
    -0.00456089f, 0.08527440f, -0.04559821f, -0.02130839f, 0.04884434f, 0.04405367f, -0.00488518f, 0.02947443f, 
    -0.26596111f, -0.29939660f, 0.15428369f, 0.23969580f, 0.06210371f, -0.12560098f, 0.03058110f, 0.06632900f, 
    -0.09773416f, -0.04249390f, 0.16578844f, -0.18470009f, 0.10118231f, 0.19802323f, 0.06057450f, 0.00739150f, 
    0.07783620f, -0.09071730f, 0.11084326f, -0.01722301f, 0.10785651f, 0.07806281f, 0.06786783f, -0.01751369f, 
    0.12708892f, -0.03708104f, 0.03908387f, 0.03101825f, 0.05875338f, -0.01653213f, 0.01678586f, 0.08341193f, 
    -0.05128111f, 0.02410738f, 0.09045901f, 0.15164448f, 0.12622249f, -0.01169130f, 0.07126080f, 0.09729047f, 
    -0.01770475f, 0.31140906f, 0.01277496f, 0.03068388f, 0.11422542f, -0.17045684f, 0.09180638f, 0.10071660f, 
    0.18210828f, -0.04059212f, -0.01063744f, 0.08599474f, -0.08341862f, -0.04070266f, 0.16326055f, -0.01508837f, 
    0.13838619f, 0.09877849f, -0.02029741f, 0.10225599f, -0.03526199f, 0.13609847f, -0.05669090f, 0.09290312f, 
    0.00094758f, 0.03410636f, -0.10586683f, -0.02637458f, 0.06294526f, 0.03839992f, 0.03026330f, 0.18910854f, 
    -0.05492764f, 0.11596064f, -0.28635144f, -0.18675472f, -0.05764629f, -0.24817589f, -0.26820731f, 0.00289701f, 
    -0.07825084f, -0.03970652f, 0.03784355f, 0.00567111f, -0.06549918f, 0.18484186f, -0.20192824f, 0.20225017f, 
    -0.06465648f, -0.00139291f, 0.04359457f, 0.05522239f, -0.13850713f, -0.04576216f, -0.06511218f, -0.06105746f, 
    -0.30891079f, -0.06861313f, 0.01488022f, -0.12624422f, -0.03634739f, 0.09350045f, -0.06958030f, -0.03956388f, 
    0.14822315f, 0.10487255f, 0.11532453f, 0.03668471f, -0.03498117f, 0.27659819f, 0.18860656f, -0.15330063f, 
    -0.02798473f, -0.09037396f, 0.13640071f, 0.05513776f, 0.27202395f, -0.00612195f, -0.04095649f, -0.04209543f, 
    0.19832137f, 0.27907988f, -0.04197835f, 0.02985980f, -0.00340367f, 0.02602682f, -0.03399934f, -0.02588365f, 
    0.03692313f, -0.10726964f, 0.06481928f, -0.01377799f, -0.31981373f, -0.11361452f, -0.46471342f, -0.22897144f, 
    0.02842324f, 0.12623972f, -0.02018180f, 0.10147148f, -0.04700784f, -0.04160591f, 0.07089802f, 0.06328611f, 
    0.28125989f, 0.08818747f, -0.04141285f, 0.02646313f, 0.15371917f, 0.10114397f, 0.09444321f, -0.09372406f, 
    0.02924204f, 0.12648605f, -0.08046184f, -0.03570369f, -0.08190679f, -0.57154828f, -0.33063957f, -0.55214322f, 
    0.08414653f, -0.12258705f, 0.03580027f, -0.06621507f, 0.03766510f, 0.01567366f, 0.07758120f, -0.04466144f, 
    0.01524232f, 0.00944534f, -0.04921151f, 0.08716419f, 0.09342153f, 0.11635827f, -0.04763231f, -0.09339341f, 
    0.00582068f, -0.02660649f, -0.04277260f, 0.04791864f, 0.01351180f, -0.11728889f, -0.25523773f, -0.12882265f, 
    0.17321351f, -0.05228712f, 0.03919954f, 0.02407861f, -0.15358375f, -0.07751008f, 0.07349219f, 0.09375348f, 
    0.19152886f, -0.00911169f, 0.07429416f, 0.11282218f, -0.07546132f, 0.01400420f, 0.11028212f, -0.02708845f, 
    -0.03911314f, -0.06842580f, 0.13260752f, 0.18262346f, 0.09589858f, -0.08781393f, 0.07812225f, -0.03271462f, 
    -0.03841128f, -0.15337043f, 0.02040070f, 0.03866753f, 0.06124842f, 0.04731803f, 0.03592476f, 0.11631151f, 
    -0.29678494f, 0.10483997f, 0.21942151f, 0.15575852f, -0.04778251f, 0.02930297f, -0.00899969f, 0.00978831f, 
    -0.01131130f, 0.04971443f, 0.04858954f, -0.01523815f, -0.12361651f, -0.11145799f, -0.16221897f, -0.18064931f, 
    -0.05481093f, -0.04384990f, 0.09623312f, -0.11356425f, 0.11349185f, -0.08128335f, 0.09921252f, 0.02012008f, 
    0.10714363f, 0.11450206f, 0.03170893f, -0.03445152f, -0.00527658f, 0.00927240f, -0.02024335f, 0.02141716f, 
    0.03823270f, -0.02275465f, -0.06750221f, -0.01961117f, -0.16271445f, -0.10474186f, -0.04286644f, -0.07578290f, 
    0.20756705f, 0.02106060f, 0.07907328f, 0.03089011f, -0.14046645f, -0.05204412f, -0.07365987f, 0.02068676f, 
    0.05285163f, 0.23890790f, -0.01372312f, -0.04553780f, -0.03856557f, 0.08028621f, 0.03871851f, 0.07480571f, 
    0.14491871f, -0.03939363f, 0.11755013f, 0.13493681f, 0.04120617f, -0.01669802f, 0.07197943f, -0.05915853f, 
    -0.03210763f, 0.04821189f, -0.00338228f, -0.00488797f, 0.00016837f, 0.06760275f, 0.07244435f, 0.06540771f, 
    0.12522458f, 0.01328907f, 0.01725723f, 0.09160750f, 0.04855724f, 0.06436102f, 0.06982228f, 0.07505035f, 
    -0.06883684f, -0.00344525f, 0.01507576f, -0.06247020f, -0.18785334f, -0.20835458f, -0.01842866f, 0.04747596f, 
    -0.02013538f, 0.12116250f, -0.02353638f, 0.09588431f, -0.04662575f, -0.05299896f, -0.10863465f, -0.02130881f, 
    0.08275712f, 0.08397551f, 0.03919953f, 0.01617560f, -0.04088979f, 0.00585600f, -0.06082121f, 0.02357450f, 
    -0.06993931f, -0.04575339f, -0.05180592f, -0.03333019f, -0.07116183f, -0.05274315f, -0.13415642f, -0.10966219f, 
    -0.05261302f, -0.12333000f, 0.03647447f, 0.02761658f, -0.13501371f, -0.07696445f, 0.00998797f, -0.02827387f, 
    -0.14801750f, 0.23515730f, -0.06192732f, -0.21585384f, 0.11221904f, -0.00745633f, 0.03863652f, 0.03974155f, 
    0.17457162f, -0.13309096f, 0.00740156f, -0.11905499f, 0.70033056f, 0.14526863f, -0.09045508f, -0.01055920f, 
    -0.16321491f, 0.00434987f, 0.12194293f, 0.28584498f, -0.13159469f, -0.07220444f, -0.03226398f, -0.07939222f, 
    0.56021339f, -0.09568753f, -0.02143090f, 0.02411497f, 0.08755649f, 0.14200260f, 0.03318737f, -0.05344713f, 
    0.00324703f, 0.10096899f, 0.13672252f, -0.20066996f, 0.14379027f, 0.26281127f, -0.15772279f, 0.06234169f, 
    -0.15040123f, -0.04463036f, 0.15483022f, -0.08034033f, 0.01225746f, 0.01779966f, -0.04161031f, -0.00461022f, 
    0.26209083f, -0.12933536f, 0.06981996f, 0.04442809f, -0.02206674f, 0.21666847f, 0.04218995f, -0.00085254f, 
    -0.00642969f, 0.14812973f, 0.02149832f, -0.07026129f, 0.03361644f, 0.33563751f, 0.23957747f, 0.01380188f, 
    -0.05838095f, 0.01406635f, -0.00872345f, -0.01794981f, -0.08526916f, -0.04616376f, -0.06220490f, -0.00001812f, 
    -0.34416825f, -0.10706729f, 0.03231614f, -0.00458413f, 0.04256188f, 0.02660561f, -0.02982234f, 0.02783594f, 
    -0.05207775f, -0.00803574f, -0.01741570f, 0.02898948f, 0.13604839f, 0.07837199f, -0.00528030f, 0.03685160f, 
    -0.04256570f, -0.01834566f, -0.06484187f, 0.27216139f, 0.21152413f, -0.12450954f, -0.00338472f, 0.12919636f, 
    0.00318134f, -0.00384580f, -0.02997313f, 0.01078797f, 0.07317669f, 0.04675981f, 0.01664818f, -0.07397681f, 
    -0.08239067f, -0.09157060f, -0.07295740f, -0.01277413f, 0.20214798f, 0.01384893f, 0.13162395f, 0.02602207f, 
    0.04932070f, 0.00951042f, -0.03898005f, 0.03204109f, -0.03303226f, 0.02772453f, -0.01606828f, -0.04232315f, 
    -0.05411053f, 0.09645259f, 0.01966461f, -0.01182355f, 0.00575275f, -0.00233235f, 0.08491173f, -0.02095302f, 
    0.01504096f, -0.04833305f, -0.08433921f, 0.15422615f, -0.15989646f, 0.04369491f, -0.18626112f, -0.07391393f, 
    -0.02588349f, 0.00377244f, 0.00954376f, 0.21391417f, 0.16527341f, 0.08204077f, 0.05999874f, -0.09542421f, 
    0.01451971f, 0.13890396f, 0.14882262f, 0.14533620f, -0.04498326f, 0.08146979f, 0.01938267f, -0.00803909f, 
    0.00122088f, 0.08123250f, -0.03497532f, 0.05507660f, 0.41363540f, 0.25125661f, 0.16889724f, 0.16152856f, 
    -0.12248789f, -0.02289948f, 0.03723698f, -0.06671076f, -0.07942439f, -0.00945357f, -0.08944921f, -0.04343198f, 
    0.08879701f, -0.23698710f, -0.13908254f, -0.12783372f, 0.12150615f, -0.18766810f, 0.04096938f, 0.21920925f, 
    0.01567812f, 0.03603218f, -0.03215439f, -0.06260870f, 0.21985902f, 0.11475812f, -0.04856711f, 0.10304113f, 
    0.05289401f, -0.09971315f, 0.01991653f, -0.09663368f, -0.00059346f, -0.06710941f, -0.03645791f, 0.03749670f, 
    -0.60887945f, 0.22929913f, 0.09623784f, -0.13889319f, 0.07356872f, 0.00788126f, -0.06201250f, 0.05373222f, 
    -0.06581013f, -0.04471842f, -0.03718895f, -0.02800427f, -0.31263179f, -0.07208003f, -0.31561193f, -0.26308858f, 
    0.08808077f, -0.00720465f, -0.00061703f, 0.10649127f, 0.01042522f, -0.01998754f, 0.03486080f, 0.01688387f, 
    -0.13886571f, 0.27791241f, 0.05506024f, -0.10382050f, 0.00438485f, -0.10957930f, -0.04472977f, 0.10333357f, 
    0.05029844f, -0.04141478f, -0.05671911f, -0.09590903f, 0.23412411f, 0.09931437f, 0.16504595f, 0.15788242f, 
    -0.00335530f, 0.04596725f, -0.02262956f, -0.03422008f, 0.05508608f, 0.07308270f, 0.02607374f, 0.03488053f, 
    0.10661313f, 0.06527636f, 0.08973204f, 0.13646561f, -0.02840045f, 0.03237914f, 0.05055641f, 0.05755593f, 
    0.27126190f, 0.13999021f, 0.17610662f, 0.10790016f, -0.30895314f, -0.10678230f, 0.03230444f, -0.02644189f, 
    -0.01916670f, 0.05048117f, -0.08751668f, -0.17646262f, 0.06864492f, 0.07008382f, 0.03484013f, 0.11841679f, 
    0.31411001f, -0.13309506f, -0.30229390f, -0.17764905f, -0.08185297f, -0.12386242f, -0.04187666f, -0.03982674f, 
    0.07969415f, -0.04085793f, 0.05474179f, 0.03598361f, -0.09631016f, -0.04640128f, -0.32459950f, -0.04439743f, 
    0.07890233f, 0.02736154f, -0.11907233f, 0.09967563f, -0.09077884f, -0.16427389f, 0.08317840f, 0.18820809f, 
    0.06385724f, 0.02653709f, 0.04698649f, 0.06036325f, 0.09969601f, 0.03400097f, -0.00983235f, -0.06338079f, 
    0.01091561f, -0.06944742f, 0.02293401f, 0.05128866f, 0.12983200f, -0.07028151f, 0.01719628f, 0.00524709f, 
    0.14816166f, -0.01198807f, 0.03202498f, -0.00165703f, -0.02532882f, -0.04098686f, -0.12306555f, -0.07940652f, 
    0.08851600f, 0.05499316f, -0.42577815f, 0.25226498f, -0.04302774f, -0.05788390f, -0.10025977f, 0.13971700f, 
    -0.15424520f, 0.13917165f, -0.04904092f, 0.05813146f, -0.13676339f, -0.01513493f, -0.02498044f, -0.04699494f, 
    -0.01852548f, 0.05079894f, -0.06860169f, 0.00285633f, 0.00110767f, 0.01579794f, 0.06137353f, -0.05070056f, 
    0.25953227f, 0.02583634f, -0.10697883f, 0.02266488f, -0.06858946f, 0.12086001f, 0.10072752f, 0.21161599f, 
    -0.11083985f, -0.02812615f, -0.00287969f, -0.08792810f, 0.06569674f, 0.09537800f, -0.05682129f, 0.06691366f, 
    -0.07368048f, 0.10384200f, -0.03840275f, -0.04140433f, 0.04070140f, 0.02030400f, -0.09777340f, -0.02199814f, 
    0.19077089f, 0.04003144f, -0.12105311f, -0.14018936f, -0.10758702f, -0.02623014f, 0.07450704f, -0.04080305f, 
    0.07477786f, 0.04613473f, 0.15422848f, 0.08859040f, -0.01937353f, 0.13827631f, -0.37972558f, -0.22490266f, 
    -0.06984970f, -0.09225158f, -0.02475112f, -0.14449508f, -0.09064171f, 0.00450759f, 0.00828526f, -0.00772451f, 
    0.50950509f, -0.08789566f, -0.15705901f, 0.26882800f, 0.05777570f, -0.03730457f, 0.02081407f, -0.12991883f, 
    0.03172390f, 0.26291281f, -0.16122228f, 0.11648101f, 0.21896981f, 0.16454436f, -0.25014716f, 0.10769807f, 
    0.10873280f, 0.11518828f, 0.09527746f, -0.09678707f, 0.18884881f, 0.02763974f, 0.03332832f, -0.05372302f, 
    -0.04666852f, -0.06409110f, -0.03751373f, -0.10641130f, -0.07215659f, -0.03686975f, 0.03876215f, 0.01214316f, 
    -0.00628984f, 0.02781636f, 0.06077728f, 0.12840456f, -0.03945760f, -0.32803786f, 0.25896639f, -0.11536014f, 
    -0.13118662f, -0.12714587f, -0.17948397f, 0.00187591f, -0.00081481f, -0.13538106f, 0.05578978f, 0.08583596f, 
    -0.01370465f, 0.06749320f, -0.26902995f, -0.25725782f, 0.13851760f, 0.17015082f, 0.09357011f, 0.05318488f, 
    -0.08461661f, 0.10044921f, -0.00801974f, 0.15994580f, -0.03337609f, -0.22033870f, 0.18103185f, -0.03002417f, 
    -0.02946264f, -0.01802717f, -0.14114277f, 0.06709620f, -0.14984427f, 0.01092811f, -0.11391292f, 0.10398954f, 
    0.21137573f, -0.11792314f, -0.14653359f, -0.10980183f, 0.04695266f, -0.00877609f, -0.11177520f, 0.10181042f, 
    -0.13418926f, 0.12583470f, 0.11306306f, -0.14629821f, 0.05277414f, -0.05005698f, -0.14458802f, -0.04004521f, 
    -0.05239614f, 0.00667402f, -0.03046119f, -0.00657966f, 0.07614260f, 0.11257228f, -0.00226537f, -0.04950147f, 
    -0.29463097f, 0.07990719f, 0.16360898f, -0.08966415f, -0.03726642f, -0.09580645f, -0.04513176f, -0.04076877f, 
    0.00920103f, -0.04786194f, -0.01915170f, -0.00403579f, 0.17666587f, -0.14107941f, 0.00134876f, 0.07711270f, 
    -0.03334821f, 0.00347435f, 0.12480715f, 0.08920648f, -0.00117295f, 0.09042864f, 0.02639943f, -0.16228119f, 
    0.24975149f, -0.02956438f, 0.11854161f, 0.15729183f, -0.04035487f, 0.08768502f, -0.01415753f, -0.05598246f, 
    -0.16444750f, -0.07968836f, -0.01572965f, -0.09994279f, -0.02995415f, -0.14884922f, -0.05411812f, -0.34550440f, 
    0.04547663f, 0.13799737f, -0.09151246f, 0.09264028f, -0.05717618f, 0.04205003f, 0.15484193f, 0.04111455f, 
    -0.01343856f, 0.11117417f, -0.00242115f, -0.09596482f, 0.25742376f, 0.09824013f, 0.00535650f, 0.10014152f, 
    0.02342030f, 0.09717065f, -0.06283053f, 0.08948834f, -0.27471203f, -0.16079277f, 0.33971950f, 0.18611923f, 
    0.00536256f, 0.07876741f, 0.01408968f, 0.03448910f, -0.02790582f, 0.07223243f, -0.14711809f, -0.03252342f, 
    0.10256151f, -0.06289514f, 0.10654452f, -0.03149214f, -0.05075276f, -0.08010575f, -0.02536876f, -0.00106452f, 
    -0.05600682f, 0.07057443f, 0.10320967f, -0.06777550f, 0.46570805f, 0.01794329f, 0.11286147f, -0.05021380f, 
    0.03582549f, 0.07017186f, 0.02298585f, -0.01783801f, -0.00694678f, 0.03170479f, -0.00670883f, -0.00632850f, 
    0.00162599f, -0.08521185f, -0.00405574f, -0.00749534f, 0.00407769f, -0.15857971f, -0.06023506f, 0.16561380f, 
    0.05485725f, -0.00032971f, -0.01441507f, 0.03739126f, 0.22673221f, -0.02833627f, -0.19110492f, 0.21279790f, 
    0.02184116f, 0.20463152f, -0.06442732f, 0.13525492f, -0.20015149f, -0.10549658f, -0.02958298f, 0.01874465f, 
    0.11500903f, -0.03941813f, -0.15319304f, 0.12518997f, 0.03274691f, -0.15555631f, 0.01764887f, -0.13348228f, 
    -0.01865058f, 0.02967897f, 0.04369399f, 0.02135997f, 0.26737896f, 0.21019864f, -0.19758263f, -0.15634660f, 
    0.07455397f, 0.05583255f, 0.07494105f, 0.04828811f, 0.01062249f, 0.03286636f, -0.12979907f, -0.00088708f, 
    -0.19628592f, -0.18244819f, 0.03641203f, -0.04297693f, -0.05868614f, -0.03033026f, -0.06262529f, -0.03134065f, 
    -0.10633156f, 0.02038961f, 0.00185874f, 0.01901289f, 0.06874073f, 0.19411203f, -0.15580399f, 0.25327271f, 
    0.06666179f, 0.08074325f, 0.12542607f, -0.07977460f, 0.16218130f, 0.05807851f, 0.15929399f, -0.03901259f, 
    0.14392538f, 0.24347879f, -0.04610652f, -0.28336135f, -0.08754388f, 0.17942859f, -0.02401555f, 0.08465603f, 
    -0.08384445f, 0.04409806f, -0.01330867f, 0.07215779f, 0.03865833f, -0.05451451f, 0.01374141f, 0.04702483f, 
    0.05800222f, 0.12909374f, 0.00177341f, 0.03119018f, -0.09453312f, -0.06778350f, 0.00558659f, -0.09170518f, 
    -0.10893858f, 0.01599853f, -0.04531774f, 0.09657200f, -0.07682101f, -0.00760820f, -0.00348815f, 0.07153711f, 
    -0.12914395f, 0.16917104f, -0.12154850f, 0.03102329f, 0.06842516f, -0.06650754f, 0.08853796f, 0.01302916f, 
    0.00865242f, 0.15130487f, 0.09161026f, -0.01491241f, 0.01979427f, -0.06185419f, 0.01488481f, -0.06665952f, 
    -0.13022977f, -0.07236943f, -0.01050715f, 0.21033493f, -0.03337307f, -0.09147950f, -0.02166026f, -0.04901304f, 
    -0.05669032f, 0.04718467f, 0.05872727f, -0.11438155f, -0.19191304f, -0.02152636f, 0.06474631f, -0.06924651f, 
    0.01905261f, -0.10803954f, -0.09990980f, 0.00559632f, -0.04518698f, -0.00626514f, -0.18106081f, -0.03799647f, 
    0.24244919f, 0.02816469f, -0.34604764f, -0.05766938f, 0.03584030f, 0.03957748f, 0.02035275f, -0.02207519f, 
    -0.04827066f, -0.04188585f, -0.21642287f, -0.07594260f, 0.20081879f, 0.15546009f, -0.31089425f, 0.01353959f, 
    -0.11048313f, 0.10111599f, 0.04871453f, 0.21793234f, -0.07875169f, -0.03217982f, -0.09876291f, 0.05274555f, 
    -0.05116314f, 0.12420383f, -0.05996526f, 0.05293005f, 0.01750339f, 0.14304052f, 0.06048001f, 0.01665133f, 
    0.11610012f, -0.06312007f, 0.08007322f, 0.03175788f, 0.04912437f, 0.11401501f, -0.22960280f, -0.28496587f, 
    0.02692368f, -0.00914937f, 0.03210501f, 0.02153713f, -0.03097688f, -0.10109542f, 0.05540234f, -0.02086889f, 
    0.01045645f, -0.29877132f, -0.15463771f, 0.08724579f, 0.08378322f, -0.00957657f, -0.12958689f, 0.04071419f, 
    -0.24620642f, 0.06036807f, -0.00559318f, 0.07309964f, -0.04842184f, -0.23867194f, -0.27133569f, -0.15512495f, 
    -0.02726605f, -0.04655300f, 0.09060194f, 0.08593072f, -0.02209843f, 0.02327559f, 0.07332937f, 0.07900403f, 
    -0.25672191f, -0.26955760f, -0.04100922f, 0.19848943f, -0.21129353f, 0.12689371f, -0.17492983f, 0.14724422f, 
    -0.21280539f, 0.03313365f, 0.13474919f, 0.22390382f, -0.05314071f, -0.28700006f, 0.27850601f, 0.05386184f, 
    -0.05257226f, 0.02975936f, 0.04989095f, -0.09169728f, 0.00363723f, -0.01401975f, 0.06399148f, -0.01193351f, 
    -0.17077795f, 0.20349301f, -0.17179666f, 0.10549717f, -0.07718711f, -0.05775763f, -0.01940553f, 0.05855277f, 
    -0.09872279f, 0.09756274f, 0.17324397f, 0.11529330f, -0.14140512f, 0.47155711f, -0.26725298f, -0.20276769f, 
    0.02238493f, 0.19362311f, 0.07169978f, 0.10450380f, -0.01908570f, 0.11403646f, 0.13315572f, 0.10010694f, 
    0.08607414f, -0.32824427f, -0.14996013f, 0.16167843f, 0.06554434f, 0.15067902f, 0.21323861f, -0.00956677f, 
    -0.10957609f, 0.08948145f, -0.06472788f, 0.07797602f, -0.07377443f, -0.00735315f, 0.10918359f, -0.01615637f, 
    0.01672973f, 0.11083367f, -0.03484204f, -0.02574710f, 0.39717165f, 0.20363471f, -0.19117133f, -0.06100715f, 
    -0.11098540f, 0.08891558f, -0.06435710f, 0.01702813f, 0.05428610f, 0.10825220f, 0.08447196f, 0.06539524f, 
    -0.21209818f, -0.09868459f, -0.05405234f, 0.08534658f, -0.12695631f, 0.19492586f, -0.04872898f, 0.09197941f, 
    -0.11754791f, 0.05386045f, 0.03441624f, 0.06895756f, -0.11172671f, 0.20872109f, 0.11229599f, 0.11840482f, 
    -0.22192965f, 0.38880181f, -0.00640489f, -0.04920388f, -0.00327357f, 0.01341511f, 0.23514853f, 0.07291641f, 
    0.15657699f, 0.00620202f, -0.00411962f, 0.02161221f, 0.13227433f, -0.08898570f, -0.01982594f, -0.01441512f, 
    0.09773390f, 0.02032434f, -0.14775628f, -0.10763662f, 0.00234443f, -0.01337515f, 0.02559613f, -0.05053223f, 
    -0.09937680f, 0.04575931f, 0.06854152f, -0.01046794f, 0.01806316f, -0.05427344f, 0.03686045f, -0.03047082f, 
    0.02826139f, 0.19690648f, -0.00987122f, 0.16893406f, -0.36654508f, 0.05178320f, 0.00451964f, -0.03799090f, 
    -0.05670336f, -0.07055897f, -0.00559561f, 0.01621398f, -0.00428107f, 0.07474066f, 0.05235031f, 0.14668845f, 
    0.29519042f, 0.14451092f, 0.02245279f, 0.28432471f, -0.03943070f, 0.12826698f, -0.08490755f, -0.08791548f, 
    -0.02124458f, -0.01234850f, 0.03333967f, 0.06965190f, -0.09586926f, 0.02865805f, 0.05975963f, -0.01751398f, 
    -0.13870224f, -0.04678688f, 0.06680909f, 0.01788618f, -0.04089716f, -0.03263037f, 0.09485997f, 0.04567904f, 
    0.01708632f, 0.25193548f, -0.05118189f, 0.08744729f, -0.02765890f, -0.06459579f, 0.11086269f, 0.08335235f, 
    -0.06864218f, -0.15830283f, 0.00518604f, 0.03592853f, 0.45053959f, -0.02740526f, 0.06606865f, 0.12627615f, 
    -0.05511751f, 0.18837966f, -0.06805685f, 0.06028605f, -0.10040867f, -0.06940601f, -0.06729472f, -0.00800295f, 
    -0.03447299f, -0.20844877f, -0.29025480f, -0.08900424f, 0.16488875f, 0.06035115f, -0.06134376f, 0.09902029f, 
    -0.06823166f, -0.15887243f, -0.06309491f, 0.00049390f, -0.16563548f, -0.02141467f, 0.08647143f, 0.03775222f, 
    -0.04526294f, -0.00115070f, 0.08091277f, 0.04384052f, -0.01166243f, 0.11285912f, 0.09344453f, 0.14483362f, 
    -0.13097151f, 0.01542236f, 0.04018722f, -0.03331018f, -0.07959588f, -0.01200012f, 0.00389131f, 0.00130215f, 
    -0.07361842f, -0.04692955f, 0.04073828f, 0.03909463f, 0.23649321f, 0.19008934f, -0.14396445f, 0.03033524f, 
    0.01621075f, 0.22902919f, -0.02689002f, -0.13261043f, 0.13032675f, 0.09982855f, 0.02019795f, -0.05996883f, 
    0.03510575f, -0.06585088f, 0.03496865f, 0.05421501f, 0.07186193f, 0.14428341f, 0.02210308f, -0.01518723f, 
    -0.06407942f, 0.19852304f, -0.06718246f, -0.00178528f, 0.32940030f, 0.08579829f, -0.23395301f, -0.01096633f, 
    0.04499886f, 0.10960219f, 0.06787362f, -0.09928644f, 0.08701869f, -0.00249476f, -0.05309774f, -0.13003878f, 
    -0.08065948f, 0.22593804f, -0.06593941f, 0.00898076f, 0.03318257f, -0.01194467f, -0.16584352f, 0.07065779f, 
    -0.09802721f, 0.02931588f, 0.05210049f, -0.04403400f, 0.03082770f, -0.07472734f, -0.02082656f, 0.02390434f, 
    -0.07437272f, 0.15426901f, -0.11029916f, -0.04855119f, -0.11533997f, 0.11273211f, 0.03767750f, -0.01565644f, 
    -0.02715767f, -0.01564508f, 0.00058250f, 0.02016779f, -0.00100850f, -0.00793404f, 0.02490780f, 0.02983520f, 
    0.00011743f, -0.01883657f, -0.02841357f, -0.00204540f, 0.01211917f, -0.01005657f, -0.04435908f, 0.00897106f, 
    -0.02707086f, -0.00541675f, -0.01053895f, 0.02034974f, 0.01483241f, -0.00534482f, 0.02365946f, -0.00153608f, 
    -0.00333771f, 0.00030903f, 0.00391627f, 0.01684647f, 0.01771332f, -0.03937166f, -0.00780944f, 0.01703315f, 
    -0.03805705f, 0.00511187f, -0.03244387f, -0.03396889f, -0.02502834f, -0.04135363f, -0.01391311f, -0.00196702f, 
    -0.02574810f, -0.03736360f, 0.00403903f, 0.01486448f, -0.01655268f, -0.00180260f, -0.02813934f, 0.00708112f, 
    -0.00534507f, -0.01719566f, -0.00126325f, 0.03105703f, -0.03350595f, -0.02393783f, 0.00542786f, 0.00254360f, 
    0.00855030f, -0.00624885f, 0.02312154f, 0.01262126f, 0.01481136f, 0.01468690f, -0.03735486f, -0.00156391f, 
    -0.00427794f, -0.02530977f, 0.00151793f, -0.00639095f, -0.00659906f, -0.01971422f, -0.01385928f, -0.00442394f, 
    0.00324353f, 0.02486628f, -0.00645603f, 0.01142458f, 0.02374770f, 0.02966739f, -0.02216606f, -0.01588039f, 
    0.00709511f, -0.02252637f, 0.00488782f, 0.02759694f, -0.02549043f, 0.02557027f, -0.01637452f, 0.02274366f, 
    -0.00536383f, 0.00915251f, -0.00952915f, -0.00688273f, -0.03005374f, -0.00345423f, -0.04020485f, -0.03290970f, 
    0.01382019f, -0.02600112f, -0.02338531f, 0.00270257f, -0.01105636f, -0.03310947f, -0.02903082f, 0.02948418f, 
    -0.00323053f, -0.00648089f, 0.00667987f, 0.03267876f, 0.02140634f, 0.00357207f, -0.01415918f, -0.02534423f, 
    -0.03491743f, 0.01709171f, 0.01182174f, -0.01526906f, 0.01058448f, -0.03479562f, -0.01616258f, -0.02801921f, 
    -0.03688606f, -0.02816019f, -0.02321896f, -0.02718440f, -0.02289430f, 0.02169947f, -0.04085048f, -0.02699642f, 
    0.01560506f, -0.01314362f, -0.01882857f, -0.01203435f, -0.00894427f, -0.01327804f, 0.00329178f, 0.02872091f, 
    0.02882441f, -0.03251561f, -0.03250276f, -0.02742208f, 0.00778879f, 0.03054514f, 0.01773083f, -0.01656303f, 
    0.02035196f, -0.03702861f, -0.00633674f, 0.01689107f, -0.03770607f, -0.04422375f, 0.01046686f, 0.00932956f, 
    -0.02308564f, -0.03391204f, 0.02595077f, -0.00118405f, -0.03467957f, -0.01215807f, -0.01042264f, 0.02389376f, 
    -0.03062201f, -0.00861858f, 0.01418933f, 0.00314463f, 0.00250340f, 0.03186892f, 0.00282230f, -0.03228330f, 
    -0.02160234f, -0.01254809f, -0.04276568f, 0.00950186f, 0.00629412f, -0.03181680f, -0.03480735f, 0.02350115f, 
    -0.00040064f, -0.03483764f, -0.03300124f, 0.02379078f, 0.00598985f, -0.01445608f, -0.01812724f, -0.00793146f, 
    -0.00265349f, 0.00897100f, -0.03576810f, 0.01356789f, 0.00137146f, -0.00425549f, -0.00864160f, 0.03084777f, 
    0.02201003f, 0.00299316f, 0.02976858f, 0.01609546f, -0.00089390f, 0.01638862f, -0.03553413f, -0.02603927f, 
    -0.02271772f, -0.02009746f, -0.01931374f, 0.00200460f, -0.01195366f, -0.02535444f, -0.01468655f, -0.02376023f, 
    -0.03289016f, 0.00435979f, 0.03025159f, 0.01834988f, -0.00292585f, 0.02478379f, 0.02044856f, 0.02755962f, 
    -0.00232203f, -0.02707935f, -0.03639325f, -0.02249607f, -0.02342081f, 0.01025643f, 0.00404150f, 0.00226853f, 
    -0.02352535f, 0.00324294f, -0.04445684f, 0.02698705f, 0.01847936f, -0.01096955f, -0.02280534f, -0.03591424f, 
    0.00541040f, 0.02023286f, -0.01374337f, 0.01203032f, -0.02154156f, -0.00244022f, 0.03062962f, 0.01148259f, 
    -0.00592957f, 0.02425237f, 0.00815132f, 0.01523000f, 0.01425746f, 0.02398517f, 0.03501714f, 0.01813380f, 
    -0.03449975f, 0.03322597f, -0.02111685f, 0.02471683f, 0.00293663f, 0.02207548f, -0.01650533f, -0.03627193f, 
    -0.03975606f, 0.01563202f, 0.00369922f, -0.03272992f, 0.01726236f, -0.03923414f, -0.02321270f, 0.02085710f, 
    -0.02563950f, -0.01376411f, -0.01954662f, 0.00930039f, -0.02013803f, -0.03071257f, -0.02252204f, 0.02717534f, 
    0.03071596f, 0.02010511f, -0.01532415f, 0.02012411f, 0.00972237f, -0.00805477f, 0.00117889f, -0.03650633f, 
    0.01188231f, -0.02622905f, -0.02137533f, -0.02364750f, -0.02843078f, 0.01353300f, -0.03893735f, -0.03283311f, 
    0.01289811f, -0.01501604f, 0.01896494f, 0.03144693f, 0.03209862f, 0.01347450f, 0.01028055f, 0.00690678f, 
    0.01761371f, 0.02710244f, 0.02333979f, 0.01519898f, 0.00041482f, -0.01957957f, 0.01713693f, 0.00592438f, 
    -0.00646030f, -0.04187462f, 0.00962932f, -0.02922697f, -0.04129040f, 0.02957772f, 0.01366507f, -0.02323798f, 
    -0.01150380f, -0.01226412f, -0.02730895f, -0.03240197f, -0.03176110f, -0.00306369f, -0.01808686f, 0.02475922f, 
    -0.00499411f, 0.01305118f, -0.02424527f, -0.02491221f, 0.00298331f, -0.00740616f, 0.00388153f, -0.02053566f, 
    0.01215854f, 0.02918761f, -0.01874446f, -0.02005264f, 0.00952011f, -0.03614877f, 0.00742463f, -0.00340562f, 
    0.01475488f, -0.03291121f, -0.03288309f, -0.02585377f, 0.00703382f, 0.02949049f, -0.02847948f, -0.00117192f, 
    0.02456549f, 0.02440774f, -0.00230835f, -0.03101811f, -0.00143280f, -0.00567211f, -0.02145943f, -0.03566604f, 
    0.00013472f, -0.01289257f, -0.00427086f, -0.03560774f, 0.02927768f, -0.01606955f, -0.02761628f, 0.01962093f, 
    0.02214285f, -0.02971797f, 0.03024081f, 0.03832051f, 0.00587486f, 0.03144484f, -0.00523363f, 0.00352415f, 
    -0.02962173f, -0.03314864f, -0.00678939f, -0.01747610f, 0.00781838f, 0.01962526f, 0.02176869f, -0.03202985f, 
    -0.03274743f, 0.00058583f, -0.03974355f, -0.01273573f, 0.02675174f, 0.01671901f, 0.02140171f, 0.01574203f, 
    0.01454580f, 0.01166777f, 0.01347266f, 0.03017141f, -0.01451705f, -0.00240887f, -0.03197837f, -0.02671931f, 
    -0.02200379f, -0.00080892f, -0.00699609f, -0.00199353f, -0.01741539f, 0.01198531f, -0.00025421f, -0.01353195f, 
    0.00207743f, 0.00043310f, -0.02590902f, -0.03145116f, -0.02385602f, 0.01124215f, 0.00974813f, 0.00546995f, 
    -0.01117778f, -0.01015676f, -0.00747357f, 0.02262370f, 0.01745190f, 0.00173357f, 0.01417893f, -0.00233045f, 
    -0.01442256f, -0.02833393f, 0.00525240f, -0.02394052f, 0.02633769f, 0.02844585f, 0.01490183f, -0.01188352f, 
    -0.04005042f, -0.01680899f, 0.00252131f, 0.01633834f, -0.03560889f, -0.03912471f, -0.02116387f, -0.01086390f, 
    0.00274707f, -0.02508647f, -0.02987153f, 0.01755234f, 0.01830639f, -0.00423971f, -0.03134445f, -0.02515330f, 
    0.01164089f, 0.03098091f, -0.01583087f, 0.00064638f, -0.03187034f, 0.02098677f, 0.02848609f, -0.03883140f, 
    -0.00447551f, -0.01021949f, -0.03995455f, -0.03435063f, -0.03173468f, -0.02474067f, 0.00706865f, 0.00690695f, 
    -0.01462756f, -0.00671986f, -0.01381019f, 0.02629496f, -0.02759628f, 0.01927863f, 0.01171070f, 0.00796500f, 
    0.01740600f, 0.01481496f, -0.02456021f, 0.02232137f, -0.00023718f, -0.03549117f, -0.02032664f, -0.01326902f, 
    0.02488891f, 0.02885545f, -0.00198342f, -0.00716596f, 0.00894809f, -0.02735689f, -0.02055337f, -0.03511832f, 
    -0.01156624f, -0.02962145f, -0.03303359f, -0.00333758f, -0.01005356f, -0.01300986f, -0.00856921f, 0.02678656f, 
    -0.00864024f, -0.00907602f, -0.01801446f, 0.00266402f, -0.00968990f, 0.01235675f, -0.00107579f, 0.02887017f, 
    -0.01100825f, -0.02457869f, 0.02767009f, 0.01401462f, 0.03228969f, -0.00626353f, -0.02756175f, 0.01289559f, 
    0.01155359f, 0.00483421f, 0.00664555f, 0.00499025f, -0.01387044f, 0.00835637f, -0.02479998f, 0.02589804f, 
    0.00414514f, 0.02728810f, -0.03684802f, -0.01761483f, -0.02844539f, 0.00720919f, -0.01718373f, 0.00849448f, 
    -0.01846651f, 0.01814995f, -0.02865788f, 0.02793041f, 0.02527889f, 0.02214942f, -0.01241058f, -0.01320481f, 
    0.01550275f, 0.00754223f, -0.00656229f, -0.01048188f, 0.01137584f, -0.01516189f, -0.01585182f, -0.00630005f, 
    -0.03043873f, -0.01857050f, 0.00770623f, 0.03251190f, 0.02367060f, -0.01309226f, 0.02139188f, 0.00628507f, 
    0.00609629f, -0.02915769f, 0.00565843f, -0.02752391f, 0.00455804f, 0.01888376f, 0.00633446f, 0.00490309f, 
    0.00169136f, 0.02211153f, 0.00107739f, -0.02434595f, 0.01205962f, -0.00949957f, -0.02906230f, 0.01426713f, 
    -0.01771253f, -0.02322255f, -0.03383789f, -0.03960390f, -0.01310880f, -0.01092219f, -0.02898389f, 0.02739342f, 
    0.00184902f, 0.02865359f, -0.02552611f, 0.00629090f, 0.03323010f, 0.02062047f, -0.01040587f, -0.00169528f, 
    0.02011732f, 0.00529309f, -0.01828447f, -0.03025857f, -0.03218843f, -0.00773440f, 0.01291017f, 0.00875790f, 
    0.03111420f, 0.00474538f, -0.00650360f, -0.00045027f, -0.02211817f, -0.03391425f, -0.01276873f, -0.01561760f, 
    0.02425067f, 0.00526444f, -0.01279949f, -0.00341040f, 0.01632704f, -0.00108369f, -0.02288606f, -0.02644544f, 
    -0.02779271f, 0.02451432f, 0.02464662f, -0.01511543f, -0.02722300f, -0.00224959f, 0.02055204f, 0.00754172f, 
    -0.01402828f, -0.00600544f, -0.01260044f, 0.01959574f, 0.02651249f, 0.00983847f, 0.01564898f, -0.01688492f, 
    0.01694578f, 0.00075106f, -0.00755937f, -0.04162939f, -0.01270582f, 0.02166531f, 0.00893132f, 0.02837568f, 
    -0.02459346f, -0.01193813f, -0.03080140f, -0.02235610f, -0.00950169f, 0.00951211f, -0.01036172f, 0.01417776f, 
    -0.01132828f, -0.01011570f, -0.03663465f, -0.01416457f, 0.01355778f, -0.02413896f, -0.01227649f, -0.00917799f, 
    -0.00567434f, -0.02376147f, 0.02106737f, 0.01981770f, -0.03285323f, -0.00979314f, -0.00975602f, 0.01119155f, 
    0.00029160f, 0.01450229f, 0.01080852f, -0.01056364f, -0.01895254f, -0.03577024f, -0.01770747f, 0.02090159f, 
    -0.00467108f, 0.02304734f, -0.01727519f, -0.02457912f, 0.01286035f, 0.00190605f, 0.00472533f, -0.00213833f, 
    0.00425564f, 0.00891349f, 0.02281456f, 0.01299162f, -0.03230841f, -0.02563000f, 0.02537333f, 0.02893668f, 
    -0.04057206f, -0.02769470f, 0.02124924f, 0.01747903f, 0.01500521f, -0.00593662f, -0.00585599f, 0.02366186f, 
    0.01631603f, -0.02855258f, 0.02428687f, -0.01479401f, 0.01394895f, -0.03032070f, -0.00210638f, 0.00425865f, 
    -0.01373977f, -0.03586614f, 0.02516704f, -0.00478386f, -0.00494537f, 0.03025383f, -0.02836973f, -0.01675654f, 
    -0.00525754f, -0.03101363f, -0.01920095f, -0.00171149f, -0.02340979f, -0.03441441f, -0.01755884f, 0.02114912f, 
    0.00752353f, -0.00473204f, 0.00492730f, -0.02169902f, -0.01384699f, -0.04271645f, 0.00632378f, -0.00250534f, 
    0.02435034f, -0.03805812f, -0.00746672f, 0.02464762f, -0.02732167f, -0.01461544f, 0.01937103f, -0.00304066f, 
    -0.02525121f, 0.00943101f, 0.02159740f, 0.01981097f, 0.01607244f, 0.02616390f, -0.00659410f, 0.03428755f, 
    -0.02581722f, -0.03906705f, -0.00125981f, 0.01409414f, -0.00476090f, 0.01382229f, -0.00071664f, -0.02937998f, 
    -0.03814115f, -0.00282900f, -0.03293342f, -0.00914475f, -0.02304804f, 0.01422193f, -0.02501809f, -0.03339358f, 
    0.00769292f, -0.01462430f, -0.01510977f, -0.01028871f, -0.03739721f, 0.00088551f, -0.03806040f, -0.01212741f, 
    0.01185590f, 0.02032669f, 0.01278988f, 0.00484769f, 0.00276002f, -0.01416770f, 0.01861041f, 0.00478307f, 
    -0.00272929f, -0.03689906f, -0.03126833f, -0.00070932f, -0.00092406f, 0.00794201f, -0.01095812f, -0.00143993f, 
    -0.05825895f, 0.05560957f, 0.22182451f, -0.00777192f, 0.10720830f, 0.04980088f, 0.07479212f, 0.04297660f, 
    -0.28672954f, -0.08348605f, -0.24558897f, -0.15722328f, -0.02309370f, -0.06782872f, -0.05066675f, 0.16524182f, 
    -0.01245233f, 0.09750494f, 0.09178646f, 0.17995302f, 0.03485844f, -0.12827669f, -0.13855784f, -0.27143925f, 
    -0.18006700f, -0.23188549f, 0.03695073f, -0.07191449f, 0.01751557f, 0.09711007f, 0.06322567f, 0.09495184f, 
    0.12909389f, 0.06550355f, -0.06252006f, 0.03264434f, -0.08732602f, -0.00782555f, 0.00846218f, 0.04096168f, 
    0.21072829f, 0.09288646f, 0.07108308f, 0.09005143f, -0.13655838f, 0.02844169f, 0.11595082f, 0.04466774f, 
    0.07472163f, 0.14885221f, 0.23743717f, 0.09781475f, -0.07006834f, -0.07667851f, -0.12041148f, -0.05199618f, 
    0.08989925f, 0.13795355f, 0.02696433f, 0.03100696f, 0.00490850f, -0.21190105f, 0.11237576f, -0.07190136f, 
    -0.03560069f, 0.17094614f, 0.01420026f, -0.01973317f, -0.02294767f, -0.04589554f, -0.13216956f, -0.10695518f, 
    -0.15826455f, -0.17645669f, -0.13178685f, -0.15297157f, -0.05638386f, -0.14489596f, -0.06799761f, 0.12814094f, 
    0.01321085f, -0.02575089f, 0.11835115f, -0.16826019f, 0.11140160f, 0.16786250f, 0.02637143f, -0.06280833f, 
    0.02654743f, 0.01058513f, -0.07876146f, 0.10319616f, -0.12450540f, 0.07043480f, -0.09001360f, -0.00448060f, 
    -0.00027385f, -0.10029791f, 0.02583133f, 0.07316988f, 0.05481197f, -0.03819360f, -0.00618191f, -0.05264651f, 
    0.03865522f, -0.01417448f, 0.04060690f, 0.06235721f, -0.29031819f, 0.02629839f, 0.03704078f, 0.10107551f, 
    -0.19007070f, 0.06823573f, 0.03970872f, -0.01200961f, -0.03543350f, -0.09215984f, 0.01637718f, -0.12585507f, 
    0.06599872f, -0.02490566f, -0.03528045f, 0.15716296f, 0.06750833f, 0.08611581f, 0.01752351f, 0.06725845f, 
    -0.03358337f, -0.00342606f, -0.11183844f, 0.03138422f, 0.02056475f, 0.14221504f, -0.00180334f, 0.20591947f, 
    -0.07816506f, 0.09646320f, 0.09230717f, 0.03562734f, -0.06178002f, -0.09460003f, -0.03703474f, -0.19827811f, 
    0.08726911f, 0.18777722f, 0.10731537f, 0.15597704f, 0.05501502f, -0.05827329f, 0.03067731f, 0.09618779f, 
    0.06774358f, -0.10563911f, -0.14677973f, -0.11417939f, -0.02441209f, 0.11624131f, 0.12634033f, -0.04091555f, 
    -0.07625447f, -0.11382043f, 0.01226987f, 0.09761135f, 0.05970003f, -0.10199182f, -0.05771311f, -0.10205986f, 
    -0.04033330f, -0.02945477f, -0.15513547f, -0.07990909f, 0.04877113f, -0.04235654f, 0.08802247f, 0.20101547f, 
    -0.09594538f, -0.06910767f, 0.03668522f, -0.07283704f, 0.04804828f, 0.12466491f, -0.20135444f, -0.09371469f, 
    -0.10907761f, 0.02939446f, -0.08959579f, -0.10616551f, 0.14499064f, 0.17545614f, 0.09676862f, 0.07078183f, 
    0.00892672f, -0.15385580f, -0.23814708f, -0.05586344f, 0.12274924f, 0.19854797f, 0.08213440f, 0.14874509f, 
    -0.05728504f, -0.02973490f, -0.02568005f, -0.11885617f, -0.01259877f, 0.06333331f, 0.07076854f, 0.16488259f, 
    0.11668907f, 0.07032421f, 0.09387118f, 0.05576180f, 0.00422745f, -0.04919085f, -0.04590811f, 0.12045811f, 
    -0.18106708f, -0.12065109f, -0.05464227f, 0.05816942f, 0.03683566f, -0.04100109f, 0.09529556f, 0.14931877f, 
    -0.11466783f, -0.10367546f, -0.13546807f, -0.09256937f, 0.17480053f, 0.04445875f, 0.01382242f, 0.29196367f, 
    0.06640095f, -0.05935999f, 0.06944502f, -0.02170595f, -0.02179970f, -0.01395526f, 0.38845244f, 0.29203641f, 
    -0.48706445f, 0.11213754f, -0.26781312f, 0.08472414f, -0.07574896f, -0.11362778f, 0.12708005f, 0.02919006f, 
    -0.03503127f, 0.03436338f, -0.07702427f, 0.23781051f, 0.00654391f, -0.03965672f, -0.06056029f, -0.06942892f, 
    -0.02985098f, -0.04984944f, -0.00376311f, 0.18699664f, -0.02396839f, -0.09914856f, -0.07248249f, -0.04070652f, 
    0.03750391f, 0.09036781f, -0.12496179f, 0.08955196f, -0.02314495f, 0.03681749f, -0.04139118f, 0.10128053f, 
    0.13234107f, -0.05709041f, 0.12814860f, 0.13588563f, -0.41798553f, -0.23184428f, -0.06588585f, -0.17355272f, 
    -0.02242109f, 0.06217762f, 0.06023806f, 0.11904311f, 0.03533810f, -0.05016373f, 0.00215899f, -0.00860395f, 
    -0.09366123f, -0.07911737f, 0.09470391f, -0.05088312f, 0.09533354f, 0.10331754f, 0.07770530f, -0.01882830f, 
    0.16862446f, 0.13961457f, -0.02011837f, 0.10030711f, -0.02629852f, -0.01788920f, 0.20718847f, 0.03539401f, 
    0.04395172f, -0.08640572f, -0.07879006f, 0.18515757f, 0.05644677f, -0.01553166f, 0.04900151f, 0.10782763f, 
    0.00316819f, -0.02136328f, -0.02992474f, 0.06609736f, -0.07194436f, -0.00093299f, 0.02803235f, -0.06320978f, 
    -0.03667673f, -0.30655017f, -0.13582690f, -0.36391953f, -0.00113011f, -0.09575079f, 0.10346445f, -0.10478574f, 
    0.05525843f, -0.01809168f, -0.05738908f, 0.12039431f, 0.24712701f, 0.15802321f, 0.06613803f, 0.13967608f, 
    0.35787016f, -0.04099108f, 0.16454117f, 0.03159696f, -0.05802857f, -0.17101301f, -0.01984795f, -0.07343397f, 
    0.01342302f, -0.10304315f, -0.13967773f, -0.16459826f, 0.07535460f, 0.11050937f, 0.00631083f, 0.13897447f, 
    0.03496200f, -0.08231530f, 0.03558058f, 0.18214224f, 0.04335636f, 0.13927154f, 0.06045114f, 0.01171865f, 
    0.04255930f, -0.18420941f, -0.04071396f, -0.04230342f, -0.13854307f, -0.06887200f, -0.15106371f, -0.01830708f, 
    0.12835485f, 0.15298793f, 0.30666703f, -0.00218340f, 0.00652343f, 0.12700155f, 0.01895676f, 0.01628900f, 
    0.18092440f, 0.14540626f, -0.05270434f, 0.19657677f, 0.07206860f, 0.03739186f, -0.00962573f, 0.19354564f, 
    0.09287558f, 0.04318492f, -0.11527862f, 0.06191656f, -0.05371581f, 0.03203004f, 0.16897996f, 0.05161919f, 
    -0.02266382f, 0.11305354f, -0.12064239f, -0.09540293f, -0.06861350f, -0.13908462f, 0.05554987f, 0.11879710f, 
    -0.02080629f, 0.04907990f, 0.05943522f, 0.02307657f, -0.14986123f, -0.12634487f, -0.24882522f, -0.43086001f, 
    0.00057333f, 0.12888755f, 0.16971365f, -0.00357808f, 0.07779385f, 0.02714043f, 0.08797397f, 0.04751003f, 
    -0.00442016f, -0.02894126f, -0.02430789f, 0.03076113f, -0.10152745f, 0.10779812f, 0.22543055f, -0.19393252f, 
    0.06211078f, 0.11799355f, 0.03868826f, 0.10176981f, -0.00625423f, 0.05648356f, 0.16063881f, -0.01887728f, 
    0.07900971f, -0.00331248f, 0.01955636f, -0.14413662f, -0.23613280f, 0.09732793f, -0.07581520f, -0.02048296f, 
    0.10593686f, 0.00193158f, 0.19720860f, 0.08442952f, 0.14779635f, 0.13135754f, 0.01024943f, 0.17839287f, 
    0.10345623f, 0.09778688f, 0.12753664f, 0.17884120f, 0.01287626f, 0.09393972f, -0.02827206f, 0.09189149f, 
    -0.05760894f, 0.06387939f, 0.08648389f, 0.02351541f, 0.04046883f, 0.06854369f, 0.20463639f, 0.14062966f, 
    0.04305536f, 0.08341869f, 0.01226683f, -0.03500774f, 0.01812030f, 0.03514829f, 0.08027543f, -0.08332352f, 
    0.16565043f, 0.05787671f, -0.02638471f, 0.00889042f, -0.01416874f, 0.02618562f, -0.08061253f, 0.03984749f, 
    0.20216745f, 0.14320810f, 0.03162772f, 0.01312186f, 0.28503987f, 0.14305484f, -0.02867435f, 0.12927698f, 
    0.05169958f, -0.07804497f, -0.04270683f, -0.07651929f, -0.13377355f, 0.23810659f, -0.19192947f, 0.09440200f, 
    -0.05430475f, 0.16967073f, 0.17725401f, 0.04530051f, 0.12213276f, 0.07923756f, 0.03948744f, 0.18038528f, 
    0.22897099f, 0.13474245f, 0.23296615f, -0.14042297f, -0.24316160f, 0.08692029f, -0.13422802f, 0.03544863f, 
    0.03752642f, 0.03629235f, -0.05458148f, 0.04601291f, 0.15939851f, -0.26551887f, 0.24626632f, -0.13302511f, 
    -0.18794248f, -0.06466467f, -0.07210674f, -0.07925888f, 0.23409010f, 0.03497338f, 0.19150354f, 0.10895538f, 
    -0.15767360f, 0.07789534f, 0.06207556f, 0.17950396f, -0.02055829f, 0.13257258f, 0.15168530f, 0.09259895f, 
    0.10908248f, -0.06583451f, 0.19471724f, 0.18167819f, 0.00317159f, -0.14400569f, -0.19796731f, 0.03401315f, 
    -0.06024444f, -0.04774313f, -0.14403859f, -0.10560673f, -0.30406812f, 0.03892271f, 0.00687476f, -0.25480315f, 
    -0.04231795f, -0.23321143f, -0.12638724f, 0.00669761f, -0.06965781f, -0.02646343f, 0.05396282f, 0.19990835f, 
    0.19919094f, 0.13551830f, 0.08082458f, 0.08334952f, 0.06192943f, 0.01345801f, 0.01231188f, -0.10697210f, 
    0.06857882f, 0.01965086f, -0.08070611f, 0.00210289f, 0.00752218f, 0.14194413f, 0.03397525f, 0.11480045f, 
    0.13232552f, -0.16652776f, 0.02920023f, 0.03042478f, -0.11926681f, 0.15342300f, -0.02647503f, 0.05194195f, 
    0.05931415f, 0.04971801f, 0.24662180f, 0.03467440f, -0.05575139f, 0.13737646f, 0.01315613f, -0.12599932f, 
    0.03836242f, 0.10771646f, 0.15781075f, 0.10835811f, -0.17008853f, -0.21658567f, 0.02381534f, -0.02295058f, 
    0.02267370f, -0.00012505f, 0.00059797f, 0.16736057f, -0.14293993f, -0.03625872f, -0.06757167f, -0.11820047f, 
    0.04335829f, -0.06115158f, 0.16243102f, 0.19849445f, 0.18482791f, 0.08845264f, -0.12997723f, 0.02643034f, 
    -0.10434502f, 0.02426760f, -0.00654575f, -0.04647758f, 0.07525176f, -0.02130513f, 0.00310320f, 0.11353374f, 
    0.22498803f, 0.09834606f, -0.09626959f, -0.07169043f, -0.03464305f, -0.00479014f, 0.09270002f, 0.19867976f, 
    0.07397749f, 0.17977983f, -0.00660111f, -0.14099793f, -0.12905774f, -0.05867824f, -0.11395772f, 0.05464743f, 
    -0.03755829f, -0.03091860f, 0.02719763f, -0.04415758f, 0.02590306f, 0.07328526f, 0.03953878f, 0.05701952f, 
    0.10168738f, -0.15323503f, 0.11493268f, -0.00096610f, 0.16386919f, 0.16696449f, -0.01298280f, 0.11504389f, 
    0.02561467f, -0.00175456f, 0.05397911f, -0.03386804f, -0.14454003f, 0.10148270f, -0.02447463f, -0.01726307f, 
    0.13081501f, -0.00704550f, 0.02496706f, 0.22649500f, 0.02018845f, -0.04031592f, 0.07878809f, 0.13497250f, 
    -0.05992854f, -0.03931953f, 0.10879640f, -0.02936395f, 0.02538469f, 0.07883399f, 0.05899061f, 0.07077223f, 
    -0.19848107f, -0.18939216f, 0.00262230f, -0.06508302f, 0.07476607f, 0.09953525f, 0.11285433f, -0.01317048f, 
    -0.14004543f, -0.13215950f, -0.07359736f, -0.12424939f, 0.00367731f, -0.05435168f, 0.04466863f, 0.00989646f, 
    0.07205305f, 0.05338982f, 0.04720089f, 0.00212380f, -0.05797897f, -0.07517694f, 0.01339307f, -0.02869130f, 
    -0.24694622f, -0.18521151f, -0.16556212f, -0.26204130f, -0.10831029f, -0.00750259f, 0.04732209f, -0.07093664f, 
    0.09526518f, -0.04309160f, 0.02413205f, 0.21003386f, -0.13224179f, -0.04597916f, -0.21775465f, -0.07965467f, 
    -0.07302942f, -0.09562854f, -0.25114554f, -0.31265783f, -0.18543473f, -0.10735900f, -0.14532240f, 0.06628471f, 
    0.12862863f, -0.13660169f, -0.14971098f, -0.11520695f, 0.09696984f, 0.08862400f, 0.00740433f, 0.00589884f, 
    0.01693170f, -0.02859057f, -0.11822825f, 0.24111882f, -0.22740671f, 0.04521250f, -0.10926445f, -0.32823074f, 
    0.07104881f, 0.08309382f, -0.00683900f, -0.01413757f, 0.16129780f, 0.05027213f, 0.09268764f, -0.01645586f, 
    -0.00239234f, 0.11820537f, -0.00906978f, 0.08685470f, -0.24049886f, -0.04005114f, 0.01102661f, -0.10096983f, 
    0.21520483f, 0.07976872f, 0.08772635f, -0.03411869f, 0.16177461f, 0.02527844f, -0.00128180f, 0.12343625f, 
    -0.00730250f, -0.03418130f, -0.03165721f, 0.01998208f, 0.02970125f, -0.00935199f, 0.00760742f, -0.03105216f, 
    -0.03048125f, -0.02785308f, -0.00080059f, -0.02797641f, 0.00052660f, -0.00055669f, -0.02818836f, -0.03851969f, 
    -0.02382694f, -0.01355606f, -0.01719404f, -0.03477066f, -0.02244310f, -0.00774238f, -0.01228153f, 0.01590186f, 
    0.02277679f, -0.03276533f, -0.00999827f, -0.02716417f, -0.00972138f, 0.01927137f, 0.02568766f, -0.01791706f, 
    -0.03430476f, -0.02499271f, 0.00583522f, -0.01420085f, 0.03009631f, -0.01873058f, 0.02361288f, 0.02896575f, 
    -0.04067285f, -0.02501164f, -0.01888702f, 0.01168007f, -0.01724187f, 0.02008153f, 0.00383863f, -0.02253651f, 
    -0.01914025f, 0.01103395f, 0.00091517f, 0.02663546f, 0.00624857f, -0.00008113f, 0.00943006f, -0.02288139f, 
    -0.02078753f, -0.03893068f, -0.00317508f, -0.00447540f, -0.00641249f, 0.00462506f, 0.02719365f, 0.02840823f, 
    0.01378323f, 0.01819737f, 0.02808185f, -0.03625185f, -0.01253029f, 0.02375243f, 0.02836674f, -0.02156760f, 
    0.01930093f, -0.01687148f, -0.02377183f, -0.03206556f, 0.02978814f, -0.00081128f, 0.02308356f, 0.01792812f, 
    -0.01747481f, -0.01761811f, 0.01413277f, 0.02971263f, 0.00449896f, 0.02903207f, -0.03612958f, -0.01736015f, 
    0.02498508f, -0.03848805f, 0.00260900f, -0.03158175f, 0.00329004f, -0.03295531f, 0.01075596f, 0.01281618f, 
    0.00954581f, -0.01963333f, 0.02207663f, 0.00681419f, 0.01200843f, 0.00333865f, 0.01606542f, 0.01811955f, 
    0.01874210f, -0.02310620f, 0.01570608f, 0.00874217f, 0.01991363f, -0.02290855f, 0.00763534f, 0.02019783f, 
    0.00014980f, -0.01633617f, -0.00529705f, -0.02766662f, 0.02929380f, 0.02499636f, -0.02368939f, 0.01078636f, 
    -0.04123829f, -0.02373813f, 0.03119349f, 0.01697715f, 0.01338484f, 0.01368671f, 0.01387526f, 0.02540308f, 
    0.00537354f, -0.00864285f, -0.03879418f, -0.02111152f, 0.01027208f, -0.03837081f, 0.01728370f, 0.01601428f, 
    -0.00874121f, 0.00273967f, -0.01022412f, 0.00486425f, 0.00461565f, -0.03725619f, 0.01264483f, -0.02700074f, 
    0.02430048f, 0.00312807f, -0.03916336f, -0.01897808f, -0.02547776f, -0.00608116f, -0.02071928f, 0.00463301f, 
    0.01625519f, -0.03053045f, -0.02563768f, -0.04211442f, 0.02458344f, 0.00089706f, -0.00740014f, 0.00984098f, 
    -0.01900310f, -0.01854858f, 0.02910080f, -0.01864000f, 0.02568801f, -0.03188878f, 0.01659444f, -0.03385999f, 
    0.00933099f, -0.02696863f, -0.04061741f, 0.01607024f, 0.00890266f, 0.01858526f, -0.02188491f, -0.02225170f, 
    0.02427851f, 0.00406634f, -0.00393509f, -0.02507374f, 0.01808292f, -0.01385914f, 0.02340538f, -0.03549222f, 
    -0.00517125f, 0.02416899f, -0.01207580f, -0.02021594f, -0.00116437f, -0.03162729f, 0.02796623f, 0.00060995f, 
    -0.02204470f, 0.01642818f, -0.03824275f, -0.00128182f, -0.01695926f, -0.03670916f, -0.02099155f, 0.01452642f, 
    -0.00294052f, -0.03713843f, -0.02198157f, -0.00912847f, 0.00867896f, 0.03006170f, -0.01361421f, -0.01316224f, 
    -0.03738769f, 0.01940211f, -0.00121245f, -0.01014930f, -0.02642414f, -0.04225056f, -0.00152241f, -0.04139148f, 
    -0.02260535f, 0.01965299f, -0.03906555f, 0.00060013f, -0.02987271f, 0.02345545f, 0.01266340f, 0.00343405f, 
    -0.02569768f, 0.00337772f, 0.01527388f, -0.03243978f, -0.01333943f, 0.00186300f, -0.02553066f, 0.01176998f, 
    -0.01639532f, 0.01304496f, 0.01510652f, -0.03150732f, 0.02138752f, -0.01761392f, -0.00085263f, 0.02246229f, 
    -0.03038168f, -0.00268083f, -0.01199973f, 0.01979618f, -0.03645436f, 0.00420448f, -0.00054204f, -0.03692484f, 
    -0.00564055f, -0.00975867f, 0.01736887f, -0.00020980f, 0.01613824f, -0.00289442f, -0.01638389f, 0.00478131f, 
    0.00263006f, 0.00121723f, -0.03762728f, 0.02466134f, -0.00036440f, -0.01379897f, 0.01164222f, -0.02556762f, 
    0.00650422f, 0.00526884f, 0.01136690f, 0.01018703f, -0.02636345f, -0.02227616f, -0.02341332f, 0.01740235f, 
    0.02168086f, 0.01535847f, -0.02770746f, 0.00864401f, 0.01407114f, -0.00710477f, 0.02250242f, 0.01707899f, 
    0.00513761f, 0.02803102f, 0.01188714f, -0.00214979f, -0.01760515f, 0.01846146f, 0.02571187f, 0.02288633f, 
    0.01634946f, 0.00430475f, -0.03085945f, -0.00582327f, -0.02739231f, -0.00854248f, 0.01482014f, -0.01089624f, 
    -0.02627919f, 0.00746505f, 0.01909543f, -0.02142728f, 0.00284761f, 0.02765913f, 0.02529535f, -0.00463183f, 
    -0.00930301f, -0.03080976f, -0.03275644f, -0.02551221f, -0.00671908f, 0.00253454f, 0.02723709f, 0.01725609f, 
    -0.01314490f, -0.02095743f, 0.01828082f, 0.02260489f, 0.00790065f, 0.01660223f, -0.01508840f, -0.01398533f, 
    0.02650189f, -0.03476316f, -0.01245826f, 0.02544072f, -0.03937168f, 0.01955286f, -0.02723268f, -0.01163004f, 
    0.00896368f, -0.02858966f, 0.01142863f, 0.01145960f, -0.02295984f, -0.01641304f, -0.01572031f, 0.02972022f, 
    -0.01891926f, -0.03340575f, 0.01585610f, -0.03191332f, 0.02494335f, -0.00758873f, 0.02429723f, -0.02106375f, 
    -0.04088170f, -0.02129288f, 0.00872494f, -0.00195117f, -0.01188230f, -0.01375388f, -0.00173651f, 0.00294945f, 
    -0.01837287f, 0.02630348f, 0.02729264f, -0.00344067f, -0.02505414f, 0.03139145f, 0.01761838f, -0.00165838f, 
    -0.01978073f, -0.01622379f, 0.00375599f, 0.00614993f, -0.01290820f, -0.00811077f, -0.02842563f, -0.02246188f, 
    0.02515352f, 0.03480943f, 0.01410219f, 0.00493859f, 0.02007594f, -0.00957654f, -0.01207630f, -0.01919915f, 
    -0.02902365f, -0.01979613f, 0.00992093f, 0.00647063f, 0.02778601f, 0.00139371f, -0.02418764f, 0.01320796f, 
    -0.01424972f, -0.03154800f, 0.01806986f, -0.03492275f, 0.01027610f, 0.00657065f, -0.01785537f, -0.00215746f, 
    0.00374430f, 0.02061548f, -0.01602200f, 0.01219088f, -0.01478999f, 0.00740127f, -0.02928402f, 0.00293490f, 
    -0.01217344f, -0.00645001f, -0.00244330f, 0.02913587f, 0.02905111f, -0.02713197f, 0.03017298f, -0.02478698f, 
    -0.01471267f, 0.02626889f, -0.03230336f, 0.02000319f, 0.01215573f, 0.01813258f, 0.00374047f, 0.00688629f, 
    -0.01519220f, -0.03179708f, -0.02580640f, -0.03128465f, 0.01552544f, -0.00116373f, 0.02284498f, -0.03286405f, 
    -0.01438076f, 0.02246787f, 0.00030736f, -0.00852988f, -0.02582236f, 0.02170362f, -0.01527794f, -0.00371692f, 
    0.01600565f, -0.02835385f, 0.00566123f, -0.03873117f, -0.03152660f, -0.02163234f, -0.03227885f, 0.01298614f, 
    -0.01263217f, -0.00114151f, -0.03847013f, -0.03107061f, 0.01966934f, -0.04121784f, -0.03346234f, -0.02725849f, 
    0.00623645f, 0.01174008f, -0.03138046f, -0.00072556f, 0.00529698f, -0.01694666f, 0.02046525f, -0.02658688f, 
    0.01033610f, -0.01355749f, -0.01256483f, -0.01189932f, 0.02260074f, 0.01812462f, 0.00405661f, 0.01656599f, 
    -0.03271011f, -0.03483997f, -0.02970365f, -0.04115389f, 0.02815682f, 0.02806007f, 0.00534429f, -0.00102765f, 
    0.00123125f, -0.03288816f, -0.00424357f, -0.00462139f, 0.02969861f, -0.03253587f, -0.01915749f, 0.02215559f, 
    0.02382392f, -0.02415921f, -0.00184816f, -0.03495988f, -0.00722989f, 0.00408731f, -0.00315803f, -0.01690264f, 
    -0.01502469f, -0.00524672f, 0.02422839f, 0.00772290f, 0.01874517f, 0.02969548f, 0.00662074f, -0.02093711f, 
    0.03050450f, -0.03263234f, -0.03594881f, 0.03031183f, 0.00727455f, 0.00630975f, 0.00556536f, -0.01621901f, 
    -0.01681727f, 0.03367151f, -0.00815836f, -0.02087891f, 0.02518042f, -0.03282038f, 0.00175682f, 0.02722611f, 
    -0.01929835f, -0.03215279f, 0.01300219f, -0.02595861f, -0.01940973f, 0.01635948f, 0.01146451f, -0.00803632f, 
    -0.01184661f, 0.00137265f, -0.03249183f, 0.00456117f, -0.02312502f, 0.00744341f, -0.02857598f, -0.04014155f, 
    -0.01394996f, -0.02545243f, -0.02574992f, 0.00590695f, 0.00153063f, 0.01565486f, -0.04076910f, -0.01766142f, 
    -0.03057785f, 0.02624434f, -0.02844017f, 0.01946633f, -0.04199500f, -0.03973677f, -0.00949853f, 0.00869032f, 
    0.03784323f, 0.01879109f, 0.01316755f, -0.01832169f, -0.01020384f, 0.03153089f, 0.02069293f, -0.02858608f, 
    -0.02989923f, -0.02176633f, -0.03058458f, 0.01270983f, 0.02580574f, 0.00383021f, 0.01717078f, -0.02973215f, 
    0.02206256f, -0.03930688f, -0.00047243f, 0.02274073f, 0.00409726f, 0.03835485f, 0.01598119f, -0.00758781f, 
    0.02686665f, -0.03145289f, -0.00982631f, 0.01502873f, 0.00935776f, 0.01661002f, 0.00638836f, 0.00543042f, 
    0.01118351f, 0.00190594f, -0.02874476f, 0.01151466f, 0.03200935f, -0.01960680f, -0.00363945f, -0.01790702f, 
    -0.01409729f, -0.00171310f, -0.03382176f, -0.03279837f, 0.02050210f, 0.01864222f, 0.01854158f, 0.02229478f, 
    0.02873563f, -0.03580988f, -0.02503744f, -0.02907257f, -0.03019097f, -0.01353397f, -0.01009025f, -0.03553368f, 
    0.01252276f, -0.03145550f, -0.03583439f, -0.00350013f, -0.00198539f, 0.01443908f, 0.01578005f, 0.02152808f, 
    0.00169058f, -0.00046253f, -0.01518041f, 0.02336193f, -0.02745332f, -0.00393734f, 0.01413761f, 0.00899691f, 
    0.00112043f, -0.02358015f, -0.03674246f, 0.01298278f, 0.01941821f, -0.03233685f, 0.03233198f, -0.03496298f, 
    0.02080877f, 0.01151880f, -0.00823849f, 0.00625348f, 0.01831979f, 0.01468400f, 0.01650896f, -0.03397040f, 
    0.01741985f, 0.01796475f, -0.00948283f, -0.02746656f, 0.00685436f, -0.01043072f, 0.00443744f, -0.00916117f, 
    -0.03883317f, 0.01502338f, -0.02442621f, -0.02216064f, -0.02542686f, -0.02422088f, -0.01789963f, -0.03052723f, 
    -0.01758156f, -0.02982647f, -0.00131178f, -0.02926196f, 0.03144759f, -0.02087387f, -0.01444891f, 0.01770002f, 
    0.02065907f, -0.00827926f, 0.01591141f, -0.01736498f, -0.01765324f, -0.03158249f, -0.02098555f, -0.02815771f, 
    0.00165675f, 0.02892511f, 0.00312915f, -0.00761121f, 0.02176678f, -0.03519785f, 0.02985347f, -0.02413981f, 
    -0.01244356f, -0.02937897f, 0.00382087f, -0.00883984f, 0.01699322f, 0.00601790f, -0.01149231f, 0.02138689f, 
    0.01214790f, -0.02556096f, 0.00268869f, -0.00938815f, 0.01891532f, -0.01458440f, 0.00201983f, -0.02537272f, 
    0.02068516f, -0.02752051f, -0.00705405f, -0.02402584f, -0.03607450f, -0.02952237f, -0.02157144f, -0.01106615f, 
    -0.02668304f, -0.01814882f, 0.01783961f, 0.02418950f, 0.00716889f, -0.03201323f, -0.00998498f, 0.00934515f, 
    -0.01990920f, 0.02764860f, -0.04026886f, -0.02113543f, 0.02731760f, -0.00519981f, 0.00153973f, -0.01628329f, 
    0.03123788f, -0.03479696f, 0.01826656f, 0.01579067f, -0.00062846f, -0.00027037f, -0.01042217f, 0.02498398f, 
    -0.03308400f, -0.03117091f, -0.02894208f, 0.01355691f, -0.02190511f, 0.03045509f, -0.02779400f, -0.01781625f, 
    0.02832472f, 0.00217065f, -0.03954666f, -0.03171262f, -0.00257324f, 0.01611636f, -0.00550705f, 0.03094698f, 
    0.00483098f, -0.02735196f, -0.01859531f, -0.02008032f, 0.04262372f, 0.02722339f, -0.03445894f, -0.02679875f, 
    -0.03336698f, -0.00354796f, -0.02402568f, 0.00292213f, 0.02625514f, -0.04115669f, 0.00597640f, 0.00230119f, 
    0.01718192f, 0.03016234f, -0.03543539f, -0.00512296f, -0.03606295f, 0.02759357f, -0.00244471f, 0.02050779f, 
    0.00667937f, 0.00218794f, -0.03286611f, -0.00244735f, 0.01682897f, 0.02677559f, -0.01547644f, -0.00040434f, 
    0.05795903f, 0.07268915f, -0.16271928f, 0.13044122f, 0.00138043f, 0.09235726f, 0.08673303f, 0.11189771f, 
    -0.04055991f, 0.06645541f, -0.05661178f, -0.06331439f, 0.01070944f, 0.11237839f, -0.00987309f, 0.07268671f, 
    -0.00681428f, 0.09115462f, 0.05544465f, 0.09527973f, 0.08747109f, 0.00920480f, 0.03446194f, -0.01505703f, 
    0.00258967f, -0.01836751f, -0.02048289f, -0.18200047f, 0.12925103f, -0.00599546f, 0.10532258f, 0.03509352f, 
    0.01091420f, 0.02517806f, -0.04638871f, -0.08319331f, 0.10774375f, 0.04111610f, 0.28495511f, -0.00305841f, 
    0.00697582f, 0.05513190f, 0.08081335f, 0.09322462f, -0.02507892f, 0.05297685f, -0.03775267f, -0.02421374f, 
    0.02307371f, -0.03285657f, 0.00708321f, 0.09738259f, -0.03867967f, -0.02786048f, 0.08269232f, -0.11063996f, 
    0.10529205f, 0.03531642f, -0.07195517f, 0.14362106f, 0.26616025f, 0.25173971f, 0.04965843f, -0.20741741f, 
    0.02724668f, -0.09072061f, -0.05594309f, -0.03251879f, -0.06010608f, 0.01005338f, -0.02041082f, 0.01667226f, 
    0.14110510f, -0.04854911f, -0.50026530f, 0.12433945f, -0.01660482f, -0.03033323f, -0.03920397f, 0.12021578f, 
    -0.05095585f, 0.08987428f, 0.01859320f, 0.02433955f, 0.10834140f, 0.11194811f, 0.17340234f, -0.03406588f, 
    0.05660807f, 0.18197913f, -0.01558556f, 0.00261964f, 0.00987158f, 0.05157199f, 0.04887253f, 0.04978769f, 
    0.07965457f, 0.14096603f, 0.19858792f, -0.08280387f, -0.05290719f, -0.03673057f, -0.03594913f, -0.06675527f, 
    -0.02336793f, 0.00012306f, 0.00200997f, 0.00131374f, 0.03968483f, -0.21648008f, 0.35290137f, 0.13941564f, 
    0.00842652f, 0.17223020f, 0.06695049f, -0.09324063f, -0.12659463f, 0.01304763f, 0.06311835f, -0.06346779f, 
    0.19258176f, -0.02721625f, 0.01930206f, -0.02728218f, 0.08512740f, 0.01666528f, -0.00037915f, 0.00368694f, 
    0.03541244f, 0.00832308f, 0.06665762f, 0.17222349f, 0.25684798f, 0.04408173f, 0.21403939f, 0.02268379f, 
    -0.06672911f, 0.02961241f, 0.01453192f, 0.12702978f, -0.04822692f, 0.04241002f, -0.02865439f, -0.02393802f, 
    0.08027058f, 0.03481672f, 0.17572509f, -0.12060244f, -0.01484164f, 0.06275763f, -0.00507717f, 0.09954532f, 
    -0.06825895f, 0.01769885f, 0.06189325f, -0.10832944f, 0.06548563f, 0.11988278f, 0.09167365f, 0.02088039f, 
    -0.03159891f, 0.04255825f, 0.14028291f, -0.12055601f, 0.03605627f, 0.08882694f, -0.10491848f, -0.03486731f, 
    0.04168985f, -0.06028184f, 0.12413716f, 0.10163389f, 0.02673903f, -0.01784977f, -0.01034654f, -0.00002747f, 
    -0.07559022f, 0.03429358f, -0.02558746f, -0.07364428f, -0.02624904f, -0.17607246f, -0.21717745f, -0.00890886f, 
    -0.04933118f, -0.04302813f, -0.00600646f, -0.04877162f, 0.02088436f, 0.03926341f, -0.02811178f, 0.03280224f, 
    0.24493341f, 0.01311262f, -0.10579594f, -0.06137265f, 0.02226009f, 0.04318327f, -0.01928996f, 0.04367734f, 
    -0.09950337f, 0.01368429f, -0.07003801f, -0.11147194f, 0.10309074f, 0.01469925f, 0.10679314f, -0.05786689f, 
    0.03949341f, -0.06986766f, -0.11537126f, 0.04309656f, 0.04672940f, 0.05789004f, 0.07915550f, 0.10554463f, 
    -0.11342756f, -0.02305637f, 0.05955715f, -0.21552862f, 0.09359882f, 0.01806568f, -0.00219308f, 0.20665191f, 
    0.04435205f, 0.00094693f, -0.03939118f, -0.10966270f, 0.03287121f, -0.03288299f, 0.49418387f, 0.20173600f, 
    -0.00851470f, 0.07895508f, 0.00866855f, 0.03001785f, -0.07231731f, -0.22345905f, 0.10723823f, 0.05316239f, 
    0.15592696f, -0.01486667f, 0.36851001f, 0.08375125f, -0.05433273f, 0.07653593f, 0.11891282f, 0.07822059f, 
    -0.19702812f, 0.03625512f, -0.08776375f, -0.04110044f, 0.14921266f, 0.11294699f, -0.09911865f, -0.25609031f, 
    0.13275668f, 0.05098790f, 0.07548950f, -0.00102266f, 0.01372936f, -0.00318322f, 0.06394853f, -0.13053893f, 
    -0.06989628f, -0.05533638f, 0.15773281f, 0.15311462f, 0.03980117f, -0.09086648f, 0.00125698f, -0.02621005f, 
    -0.02478122f, 0.00455916f, -0.02673194f, 0.05374068f, -0.01257706f, 0.04040200f, -0.19984768f, -0.05474518f, 
    -0.12250942f, 0.04722484f, 0.03919655f, -0.00414241f, -0.10237480f, -0.01274511f, -0.04434761f, -0.14987825f, 
    -0.05428695f, 0.12703517f, -0.07799783f, 0.01660435f, -0.06310315f, -0.05210795f, 0.02052666f, -0.13489769f, 
    0.05650304f, -0.01454343f, -0.06405843f, -0.01554630f, 0.08604194f, 0.02085210f, -0.14402923f, -0.04068813f, 
    0.00102992f, 0.08872720f, 0.12790097f, -0.02505181f, -0.01842419f, -0.04167820f, 0.06505974f, 0.01184415f, 
    0.04586637f, 0.01333669f, 0.03815391f, 0.00087882f, -0.08248830f, -0.00176732f, -0.07765412f, -0.07114545f, 
    0.04891424f, -0.01443351f, 0.01284375f, 0.05526724f, -0.17292765f, 0.02591373f, -0.17775427f, 0.06982255f, 
    0.04837724f, -0.01682234f, 0.11811038f, 0.08664806f, 0.10853056f, -0.11818773f, 0.07693461f, 0.06948092f, 
    -0.20460543f, 0.02054471f, -0.00853193f, -0.31490034f, -0.02450728f, -0.01335216f, -0.05047448f, 0.13501902f, 
    -0.01998905f, 0.06587417f, 0.10012339f, 0.05738141f, 0.12908484f, -0.02813055f, 0.16798262f, -0.06008318f, 
    0.02649627f, -0.03845933f, 0.13290788f, 0.11009832f, 0.00247837f, 0.11635435f, -0.09033179f, -0.01082263f, 
    -0.13356592f, 0.10689248f, -0.01428903f, 0.15866359f, -0.10157052f, -0.10369573f, 0.03412830f, -0.08816419f, 
    -0.12362443f, 0.03141271f, -0.12749642f, -0.07357751f, 0.08446342f, 0.02941134f, 0.01660550f, 0.03013999f, 
    -0.00419119f, 0.12708473f, -0.13158713f, 0.06573837f, 0.10815274f, -0.04009364f, -0.02064520f, 0.09672058f, 
    0.04002214f, -0.07892342f, 0.14411411f, 0.15791741f, -0.01180833f, -0.02785501f, 0.11208403f, 0.05512540f, 
    -0.02302592f, 0.17272697f, -0.03677391f, 0.04146443f, -0.03562118f, -0.08992271f, 0.16360748f, 0.06792525f, 
    0.05248690f, 0.01364080f, -0.03112745f, 0.07640031f, -0.06277585f, 0.03361389f, -0.12341273f, -0.14937310f, 
    0.25157467f, 0.08749761f, -0.24577495f, 0.01397241f, 0.00044350f, -0.02075911f, -0.00410830f, -0.17618574f, 
    -0.02882603f, 0.04685745f, -0.02865826f, -0.01064808f, 0.21506877f, 0.10266408f, -0.08272611f, 0.07527714f, 
    -0.05657115f, 0.18830051f, 0.00595478f, -0.00365207f, -0.07354277f, 0.00277014f, 0.01095183f, 0.03352562f, 
    -0.16081063f, 0.09624559f, -0.27906555f, 0.17457610f, -0.04487528f, -0.00668472f, 0.02784768f, -0.09739985f, 
    0.00592093f, -0.11287250f, 0.00354964f, 0.13825630f, 0.15334775f, 0.11018094f, 0.00591742f, -0.09156254f, 
    -0.06270446f, -0.00483960f, 0.10591789f, 0.05807127f, -0.05784008f, 0.01239242f, -0.01313864f, -0.00612741f, 
    -0.01429199f, 0.04517205f, 0.04362865f, -0.07034554f, -0.09973748f, -0.01524878f, 0.03047077f, -0.01162221f, 
    -0.02458319f, 0.05842686f, -0.04744412f, 0.09363573f, 0.17479372f, 0.07507870f, -0.12391586f, -0.13844590f, 
    -0.03704135f, -0.08913411f, -0.13893107f, 0.16436648f, 0.03390582f, 0.08896921f, 0.04255711f, 0.06711312f, 
    -0.19115813f, 0.10250757f, -0.16264397f, 0.36906812f, -0.03224169f, 0.03339361f, 0.06778328f, 0.09411776f, 
    -0.21143532f, -0.00209025f, 0.07687289f, 0.09821080f, 0.09103488f, -0.33263057f, 0.17236423f, -0.02992650f, 
    -0.02230311f, 0.16067909f, 0.01311597f, 0.05996849f, -0.06595968f, 0.05027450f, -0.02676568f, 0.06016694f, 
    -0.09972754f, 0.22261471f, -0.09797840f, 0.25088593f, 0.00949106f, -0.09988958f, 0.11000433f, -0.08050293f, 
    -0.07274394f, -0.00163903f, 0.15219326f, 0.10627899f, -0.09360402f, 0.38552156f, -0.10151199f, 0.17550252f, 
    -0.10523869f, 0.08256672f, -0.00104465f, 0.00021991f, -0.01458350f, -0.05754073f, 0.06707519f, 0.01179696f, 
    0.13182928f, -0.25809407f, 0.11652635f, -0.00647449f, -0.08808868f, 0.12999932f, 0.06623997f, 0.21717837f, 
    0.03982677f, 0.01980883f, 0.08227280f, 0.04329221f, 0.12780805f, -0.12708186f, 0.17888573f, -0.08503510f, 
    -0.07789201f, 0.03523416f, -0.00237426f, 0.13274108f, -0.05154490f, 0.07105806f, -0.04221917f, -0.07797341f, 
    -0.25864536f, 0.07306302f, -0.11483251f, -0.12388708f, -0.18227071f, -0.10612535f, -0.01023498f, -0.06608422f, 
    -0.22749095f, -0.09583226f, -0.06834774f, -0.12785117f, -0.06393375f, 0.20190580f, -0.08989436f, 0.21226934f, 
    -0.05899351f, -0.03608269f, 0.07926323f, 0.06107866f, -0.14162976f, 0.06241009f, 0.01545305f, -0.02923506f, 
    -0.13376196f, 0.06026677f, 0.10731374f, -0.02683340f, 0.11520500f, 0.06781182f, 0.06322234f, 0.07968615f, 
    0.13523173f, -0.03473116f, 0.07992129f, -0.06602558f, 0.13589780f, 0.10282846f, -0.12419547f, 0.02853045f, 
    0.02292985f, 0.03590370f, -0.04264262f, 0.00970851f, 0.00097418f, -0.07619528f, 0.05386201f, -0.02119601f, 
    -0.04661589f, -0.00420906f, 0.13487554f, 0.13424683f, -0.01444153f, -0.02815005f, -0.03439580f, -0.01258564f, 
    -0.01422053f, 0.01982993f, -0.00647689f, 0.08341392f, 0.16172366f, 0.06306833f, 0.13318706f, 0.08806086f, 
    -0.04896497f, -0.06564521f, -0.09408401f, -0.02256829f, -0.02502185f, 0.02278218f, -0.01638144f, 0.04439464f, 
    0.25528163f, -0.18566516f, -0.02549791f, 0.14990462f, 0.01333503f, 0.12625107f, 0.02951995f, 0.14812593f, 
    -0.00683569f, 0.12269622f, 0.00262926f, -0.02995736f, 0.13340229f, 0.07399756f, 0.14433174f, -0.03207590f, 
    -0.00433920f, -0.02600947f, -0.13272506f, -0.00186560f, -0.09184670f, -0.06304622f, -0.05075918f, -0.05988207f, 
    0.00429204f, 0.22651260f, 0.05525062f, -0.11017365f, 0.02187944f, -0.07320390f, 0.04369918f, 0.03564307f, 
    -0.05468102f, -0.12520453f, 0.01621232f, 0.03185341f, 0.06252261f, 0.07369052f, 0.09788124f, -0.01345565f, 
    -0.05749943f, 0.14076388f, 0.02674806f, 0.06911948f, -0.06198421f, -0.07348586f, 0.02288412f, -0.00079631f, 
    0.01681786f, 0.03968500f, -0.01032462f, -0.08493462f, -0.03562363f, 0.00585089f, -0.02150401f, -0.01199377f, 
    -0.02767678f, 0.00351746f, -0.01881842f, -0.03072233f, 0.13990130f, 0.13656722f, 0.04422632f, 0.10316883f, 
    -0.11813992f, -0.08551651f, -0.11103100f, -0.08785556f, -0.16236658f, -0.09975725f, -0.04688394f, -0.06137045f, 
    -0.04467074f, 0.12006877f, 0.04907776f, 0.01349235f, -0.09451083f, -0.07080171f, -0.00776825f, -0.03523349f, 
    0.03069808f, 0.08928347f, -0.00792915f, -0.01682610f, 0.12902473f, 0.15965968f, -0.02705219f, -0.03537994f, 
    0.08225207f, 0.07407703f, 0.01331101f, -0.12702797f, 0.04590863f, -0.02194682f, -0.03481692f, -0.03119778f, 
    -0.07707340f, -0.14628986f, -0.26693934f, -0.33052409f, -0.06890378f, 0.02840163f, -0.08507767f, 0.03535043f, 
    -0.03801375f, 0.07997943f, -0.04184184f, -0.05574851f, 0.21580312f, 0.18764548f, -0.01865712f, -0.02775436f, 
    0.10475527f, 0.02401495f, 0.03149506f, -0.04048530f, 0.00564176f, 0.05333169f, -0.02520202f, -0.08251026f, 
    -0.05235333f, 0.09726602f, 0.10888725f, 0.25820002f, 0.02779857f, -0.06402162f, -0.05897391f, 0.02958418f, 
    -0.01048433f, -0.05929013f, -0.00084236f, -0.07099943f, -0.02294073f, -0.08392555f, -0.10990012f, 0.03368706f, 
    -0.14995292f, 0.15456702f, 0.09645417f, 0.15283655f, -0.06616022f, 0.00056966f, -0.05106685f, -0.01096972f, 
    0.01260858f, 0.02981992f, 0.00260887f, 0.00781154f, -0.01369276f, -0.03395159f, -0.03705611f, -0.00413410f, 
    -0.01275932f, -0.02228681f, 0.00262075f, -0.03542180f, -0.03097894f, -0.03304427f, 0.00872388f, -0.02024098f, 
    -0.02427349f, -0.02409389f, -0.04068881f, 0.01243218f, 0.01680283f, 0.01481070f, -0.02787751f, 0.00028347f, 
    -0.01071447f, 0.01802423f, -0.00914270f, 0.02381473f, -0.01219291f, -0.03860490f, -0.02276422f, 0.01482488f, 
    0.01045771f, -0.02057371f, 0.02709532f, 0.00444452f, 0.01988171f, -0.01312453f, -0.00602369f, 0.01565046f, 
    -0.03332053f, 0.00590685f, -0.03104416f, 0.02924847f, -0.02644947f, -0.00116347f, -0.00912314f, 0.01402660f, 
    0.01999540f, -0.01276834f, -0.00879911f, -0.02300311f, -0.00998895f, -0.02254648f, -0.00847481f, -0.00288860f, 
    -0.02508989f, -0.03580752f, -0.03275395f, 0.02992291f, -0.02852438f, 0.00924503f, 0.02670399f, -0.00130420f, 
    -0.02676210f, -0.03906658f, -0.00492001f, -0.02902768f, 0.00833152f, 0.01413842f, -0.03685299f, -0.02762189f, 
    0.00064541f, -0.02037253f, -0.01729812f, 0.00246395f, -0.03772725f, -0.00118463f, 0.02982837f, -0.03882103f, 
    -0.03991871f, -0.03436380f, -0.02149517f, -0.00683937f, -0.02181234f, -0.02788454f, 0.01950333f, -0.00879200f, 
    0.01223591f, 0.01854475f, -0.02261763f, -0.00588582f, -0.02266316f, 0.01170187f, -0.00495417f, 0.00527080f, 
    0.00931306f, -0.00648305f, -0.03398290f, -0.01944173f, 0.00344055f, 0.01598969f, -0.02157863f, 0.01529492f, 
    -0.03014725f, 0.00478794f, -0.00801286f, -0.00915696f, 0.03389225f, 0.02356951f, -0.00954902f, 0.02817250f, 
    -0.00761623f, -0.01931868f, 0.03189059f, -0.02340107f, -0.02684714f, 0.01810927f, 0.01084267f, 0.03133147f, 
    -0.00008448f, -0.00461447f, -0.00252006f, 0.01611477f, -0.02815800f, -0.02338544f, -0.00591394f, -0.01865017f, 
    0.00750417f, -0.00283336f, -0.00804744f, -0.01431112f, -0.01762732f, -0.01515128f, 0.01250472f, 0.01554281f, 
    -0.02784250f, -0.00930118f, 0.00462475f, -0.01892203f, -0.04152318f, -0.01941890f, -0.00082071f, -0.02166720f, 
    0.02120652f, 0.02346998f, -0.01090248f, -0.00095088f, 0.01759414f, -0.02195542f, -0.01439758f, 0.01770934f, 
    -0.02242783f, 0.01455559f, -0.00745133f, 0.01287648f, 0.00810466f, -0.04142590f, -0.01454249f, -0.03619012f, 
    -0.00273357f, -0.00625740f, 0.00307430f, 0.00161535f, -0.03544667f, 0.02380044f, -0.03027609f, -0.02687195f, 
    0.02042201f, -0.02723423f, 0.01969625f, -0.01426848f, -0.04068593f, -0.02986351f, 0.01027583f, -0.01532318f, 
    -0.02792645f, 0.00822357f, -0.00297022f, -0.00258764f, -0.03191800f, -0.01376109f, 0.00169565f, -0.03393935f, 
    -0.00451533f, -0.00258698f, -0.03945498f, -0.02186478f, -0.03727333f, 0.00339700f, -0.02881316f, -0.02198193f, 
    -0.01741771f, 0.01737335f, -0.00331998f, -0.01207340f, 0.01377901f, -0.01291317f, 0.01851512f, -0.02889963f, 
    0.01752522f, 0.00456000f, -0.02680025f, -0.03601963f, -0.03006315f, -0.03197052f, -0.03439979f, -0.00293977f, 
    -0.03299633f, -0.02635892f, 0.02054790f, 0.02738176f, -0.00652517f, 0.00085891f, 0.02955572f, -0.03126289f, 
    -0.00703995f, -0.02560015f, 0.00762235f, -0.02345504f, 0.01510711f, 0.01839644f, -0.00834356f, 0.00062143f, 
    0.00781277f, 0.01296361f, -0.01531967f, -0.03055464f, 0.01703206f, 0.02138383f, 0.02608654f, -0.04153561f, 
    0.00272508f, -0.00743651f, 0.00121099f, 0.00062007f, -0.01763194f, -0.00412734f, -0.02675847f, -0.01654923f, 
    -0.01415129f, -0.03480826f, -0.00953327f, -0.02585384f, 0.00374421f, 0.00814487f, 0.01773078f, 0.01206256f, 
    0.03075830f, -0.01312179f, 0.01064046f, -0.03110904f, 0.00052107f, -0.01074204f, 0.02056226f, 0.02360723f, 
    -0.01746235f, -0.03122359f, 0.01160076f, -0.02349017f, -0.00690388f, 0.02976085f, -0.03731625f, -0.02807538f, 
    -0.00112332f, -0.01864317f, 0.00899468f, -0.02427732f, 0.01842043f, -0.00694936f, -0.00061979f, -0.01528958f, 
    -0.00531337f, 0.03083827f, -0.00722932f, -0.00849093f, 0.02245445f, -0.02492101f, -0.02056622f, -0.00338269f, 
    0.00985423f, -0.02302970f, 0.01905824f, -0.03102372f, 0.00679986f, 0.01797609f, -0.01403014f, 0.00513235f, 
    0.01912458f, 0.02175446f, -0.00131621f, -0.02498189f, -0.00977685f, 0.01160746f, -0.03573370f, -0.02227829f, 
    -0.00584985f, 0.00471503f, 0.00295655f, 0.02517548f, 0.02512141f, -0.02519268f, -0.03595154f, -0.03571183f, 
    -0.01456608f, 0.01310480f, 0.01207302f, 0.02681481f, 0.00631892f, -0.03348607f, 0.01516802f, 0.00101840f, 
    -0.01781164f, 0.02935736f, -0.00607038f, -0.00596714f, 0.00929960f, -0.02243443f, 0.01888523f, -0.00989943f, 
    0.02885273f, 0.02351609f, 0.01343368f, -0.03439279f, -0.00909829f, 0.00796473f, 0.01943710f, -0.01818679f, 
    0.01815921f, -0.04089861f, -0.02590197f, -0.02806163f, 0.02227297f, 0.03027578f, -0.01087738f, -0.00841403f, 
    -0.04040797f, 0.01139305f, -0.01986114f, 0.00822312f, 0.00458383f, 0.02204403f, 0.01180589f, -0.02126869f, 
    0.00161694f, -0.01572254f, 0.02886466f, 0.02290354f, -0.03381781f, -0.02502696f, 0.01664154f, -0.03389657f, 
    0.01543022f, -0.02402136f, -0.01534659f, -0.00456749f, -0.03247160f, 0.00685892f, 0.00720932f, -0.02516592f, 
    -0.02271184f, -0.00532253f, -0.02619526f, 0.00930251f, 0.00503032f, -0.01668060f, 0.02856002f, 0.00665618f, 
    0.01059727f, 0.01881503f, -0.01114653f, -0.00066783f, -0.01116233f, 0.02641191f, -0.01245848f, 0.01282178f, 
    0.01675237f, -0.00803012f, -0.01262623f, 0.02558509f, -0.00318198f, 0.00078139f, 0.01153587f, -0.00575512f, 
    0.01472501f, -0.01943027f, -0.03570749f, 0.00106156f, -0.02792994f, 0.02407433f, 0.03108674f, -0.02081434f, 
    -0.03979406f, 0.02711965f, -0.00549181f, 0.03345032f, 0.02478222f, -0.03788504f, 0.02705907f, -0.01066148f, 
    0.01986759f, -0.02593327f, -0.01134065f, 0.01433077f, -0.00904869f, -0.00422152f, -0.01928809f, 0.02117806f, 
    0.02527247f, -0.01374339f, 0.02651718f, -0.00169262f, -0.02720092f, 0.02117903f, 0.00377441f, 0.01813334f, 
    0.01669532f, -0.00790910f, -0.00017947f, 0.00236163f, -0.04022053f, -0.02008186f, -0.00223520f, -0.00835294f, 
    0.01759696f, 0.01314483f, 0.02716574f, 0.01899153f, -0.00159373f, -0.03374249f, -0.02371418f, -0.03064437f, 
    0.01444466f, 0.02035497f, 0.01391100f, 0.02199749f, -0.01686657f, 0.03544096f, 0.02680920f, -0.02354427f, 
    0.00135682f, -0.01535034f, -0.00718538f, -0.01813584f, 0.00143628f, 0.02821377f, -0.01962525f, -0.04064692f, 
    -0.02921430f, 0.01968231f, 0.01415677f, -0.02517991f, 0.00392794f, 0.01108348f, -0.02591468f, 0.00388125f, 
    0.01251749f, 0.01815062f, -0.00045253f, -0.03330547f, -0.01168141f, -0.02980214f, 0.02711477f, -0.02885124f, 
    -0.01092244f, -0.03010302f, 0.01961816f, -0.01439160f, 0.00199930f, 0.00923172f, 0.02767619f, 0.01644350f, 
    0.02280609f, 0.02524421f, -0.03269043f, 0.02234618f, -0.02631910f, -0.01486491f, -0.00694605f, -0.00050770f, 
    -0.01872718f, -0.00856365f, -0.01933631f, -0.02846440f, -0.01558207f, 0.01945950f, -0.00996296f, -0.03158082f, 
    -0.03334237f, -0.02945664f, 0.00744637f, 0.01953121f, -0.03566168f, -0.00544430f, 0.01746935f, -0.00297969f, 
    -0.00563602f, -0.01781524f, -0.00205734f, 0.02019221f, -0.03637846f, 0.02005633f, 0.02987947f, -0.03621340f, 
    -0.00687857f, -0.02506850f, 0.01879096f, -0.02973087f, 0.01341015f, 0.02461869f, -0.02786367f, -0.00110920f, 
    -0.02673250f, 0.02345955f, -0.02914753f, -0.01638317f, 0.01330755f, -0.03765586f, -0.04136033f, 0.02778367f, 
    -0.02555131f, 0.00198281f, -0.01293787f, -0.00990028f, 0.00301535f, 0.02692178f, 0.00097400f, -0.04153654f, 
    0.02364859f, -0.02768466f, -0.01910892f, 0.00174257f, -0.02043990f, -0.03021106f, 0.01125419f, -0.01887050f, 
    0.00807144f, -0.01572125f, -0.03018173f, -0.00647462f, 0.00822935f, -0.01027217f, -0.02652158f, 0.01447016f, 
    -0.01582699f, -0.00209986f, 0.00315450f, -0.01984556f, -0.03036333f, 0.01458940f, -0.00263252f, 0.01192003f, 
    0.01606933f, -0.04109979f, 0.00039640f, -0.01374362f, 0.01684617f, -0.00525856f, -0.01011502f, -0.03108977f, 
    -0.00412649f, -0.00115408f, -0.03402432f, -0.02885617f, 0.01612182f, 0.00822736f, -0.04031224f, -0.03441620f, 
    -0.02035053f, -0.03440188f, -0.04036653f, 0.02146786f, -0.01642616f, 0.03120008f, -0.00250927f, 0.02135592f, 
    0.02460912f, -0.02620651f, -0.01967257f, -0.04079090f, 0.02773991f, 0.00092956f, -0.02597083f, -0.03990407f, 
    -0.02352802f, -0.02197459f, -0.03052219f, -0.03368101f, 0.01382763f, -0.03937109f, -0.03119433f, 0.02703243f, 
    -0.01800184f, -0.02243553f, 0.00158527f, -0.02951255f, -0.02452999f, -0.02147863f, -0.02185087f, -0.00504469f, 
    -0.02211282f, -0.00025306f, 0.03033403f, 0.01467517f, 0.02144153f, -0.00091797f, -0.01287573f, -0.01616051f, 
    -0.02578653f, -0.02776181f, 0.02449296f, -0.03059129f, -0.00554334f, -0.01178364f, -0.02962879f, -0.00601808f, 
    0.02560415f, -0.00299489f, -0.01619844f, -0.02086092f, -0.00112492f, 0.01847240f, -0.03426583f, 0.01394312f, 
    -0.00096429f, -0.02000173f, -0.00235679f, 0.02514572f, 0.01420222f, 0.00073579f, -0.04091979f, -0.03561201f, 
    -0.02902377f, -0.01072371f, -0.02637702f, 0.00559743f, 0.01389319f, -0.03756017f, 0.03024081f, -0.00811180f, 
    -0.03180149f, -0.00733180f, -0.03889312f, -0.00580008f, -0.00794215f, 0.02663364f, 0.00146630f, -0.02060777f, 
    -0.02927049f, -0.01978269f, -0.03406328f, -0.00025861f, 0.01253176f, 0.03424445f, 0.02545821f, -0.00038895f, 
    0.01114655f, -0.00024643f, -0.02170106f, -0.02577332f, 0.03093346f, 0.03201658f, -0.03160100f, -0.03513321f, 
    0.01892514f, -0.00165454f, 0.01575781f, -0.03389018f, -0.00243345f, -0.00937575f, -0.03138204f, 0.00753870f, 
    0.01480201f, -0.02880927f, -0.00887369f, 0.00186693f, 0.02750944f, -0.01764151f, -0.01626203f, -0.04023141f, 
    0.02332936f, 0.00001853f, 0.00260753f, -0.03834669f, 0.02934566f, 0.00457541f, -0.03694449f, 0.01646782f, 
    -0.03330619f, -0.02278825f, 0.01010789f, -0.00008014f, -0.02311071f, -0.02105111f, 0.00282351f, -0.01071605f, 
    -0.04022676f, 0.02820439f, -0.01316715f, -0.03681980f, 0.00883846f, 0.01762167f, 0.00422433f, -0.02114243f, 
    0.02352673f, 0.01332977f, 0.01857132f, -0.01634475f, -0.02663846f, 0.01211682f, -0.02229614f, 0.00284578f, 
    0.02001447f, 0.00673170f, -0.01747085f, -0.01452419f, 0.01982242f, -0.04153609f, 0.02750217f, 0.02432079f, 
    -0.02874256f, 0.00910349f, -0.01757781f, -0.02123957f, -0.03239695f, 0.00616700f, 0.00436612f, 0.02976280f, 
    -0.02786640f, -0.01021639f, -0.01825686f, 0.02129459f, 0.01631934f, 0.02997267f, -0.03216676f, -0.02512087f, 
    -0.03324863f, -0.02456943f, 0.02827618f, -0.03097756f, 0.02839779f, -0.00638198f, -0.00941454f, -0.00879405f, 
    -0.02430588f, 0.00249750f, 0.00607738f, 0.00703711f, -0.01395146f, -0.02243065f, -0.02330329f, -0.00500229f, 
    -0.02086410f, -0.02476614f, -0.00926324f, 0.01628576f, -0.03605800f, 0.01461896f, -0.00552451f, -0.00471945f, 
    0.02092763f, 0.01214659f, -0.02126321f, -0.03190043f, -0.00388697f, -0.02650703f, -0.01023446f, 0.00519490f, 
    -0.00572999f, 0.11805183f, 0.14116581f, -0.00970948f, 0.04583053f, 0.17002420f, -0.03632614f, -0.01976762f, 
    -0.01726802f, 0.09805711f, -0.04271673f, -0.09243318f, -0.09203811f, 0.08105864f, -0.09426437f, 0.19775559f, 
    0.12333764f, 0.00988205f, 0.07373439f, 0.05545020f, 0.17522071f, 0.06264175f, -0.01728753f, -0.01934789f, 
    -0.19270410f, -0.09104525f, 0.09262703f, -0.02948719f, 0.05994979f, -0.10822248f, 0.07212601f, -0.15034223f, 
    0.03373021f, 0.00779243f, -0.11199261f, 0.00259553f, 0.09516519f, -0.03298460f, 0.22843669f, 0.07065357f, 
    -0.03196690f, 0.03318581f, 0.01364396f, 0.07482135f, -0.03110320f, 0.01189704f, 0.12448141f, 0.06759825f, 
    -0.18561336f, 0.17143905f, 0.11378466f, -0.01520598f, 0.05333808f, 0.01424041f, -0.08288931f, -0.00480294f, 
    -0.07954262f, 0.10492018f, 0.02943689f, 0.05519811f, -0.02884829f, 0.05972284f, 0.23390655f, 0.09038192f, 
    0.05033540f, 0.12677538f, 0.04427299f, -0.00190500f, 0.04307677f, 0.01316184f, -0.08362956f, 0.01255952f, 
    -0.70275754f, 0.24565196f, -0.02531746f, 0.29834378f, 0.04681103f, 0.07911809f, 0.03091923f, 0.08754744f, 
    -0.13000630f, 0.02368006f, 0.09129580f, 0.00590917f, 0.06612935f, 0.15454738f, 0.30618903f, -0.01738147f, 
    -0.03026513f, 0.04840442f, 0.06992317f, 0.12220281f, -0.10892972f, 0.02819669f, 0.05173820f, 0.10854005f, 
    0.08906726f, 0.05418533f, -0.05085751f, -0.15741041f, 0.02550974f, -0.07269664f, 0.00650502f, 0.09965827f, 
    -0.06509817f, -0.03657168f, -0.01419589f, -0.08992131f, 0.03656036f, -0.08797760f, 0.12538098f, -0.01274492f, 
    0.10367180f, 0.11602916f, 0.01240958f, -0.01460519f, -0.15802479f, 0.08083919f, 0.07523192f, 0.01876919f, 
    0.07480107f, -0.02332760f, 0.01321494f, 0.16180055f, -0.00474708f, -0.02565010f, -0.09072040f, 0.01171760f, 
    0.05978626f, -0.04256026f, -0.05047429f, -0.06115764f, 0.02377992f, 0.05474432f, 0.10684100f, 0.01617786f, 
    -0.05026091f, 0.10983961f, 0.03156587f, 0.01940652f, 0.04675616f, 0.00317691f, 0.10717433f, -0.00268318f, 
    -0.18027972f, 0.12198024f, 0.17159009f, -0.14974628f, -0.03840002f, -0.00077885f, 0.08868538f, 0.02316213f, 
    0.24379721f, 0.01585231f, 0.15505601f, 0.10776077f, -0.03627490f, 0.16886610f, 0.15300585f, 0.12266305f, 
    -0.03331717f, -0.00931446f, 0.12742689f, -0.04317106f, -0.01604048f, 0.03748545f, -0.08117484f, 0.02052484f, 
    0.03159064f, -0.24766819f, -0.04794338f, 0.12945937f, 0.04963812f, 0.01980198f, 0.16839592f, 0.05380363f, 
    -0.03654438f, 0.12453646f, -0.03388973f, -0.18512112f, -0.09094919f, 0.16455017f, 0.06734966f, -0.00260170f, 
    -0.09836506f, -0.03056875f, -0.03614256f, -0.01985008f, 0.07620491f, 0.03535652f, 0.06187889f, 0.02120591f, 
    0.03012765f, -0.07496805f, -0.10148329f, -0.12278031f, 0.06765810f, 0.00366214f, 0.14754841f, 0.18532820f, 
    -0.07539384f, -0.02032702f, -0.03942407f, 0.02499075f, -0.02482625f, -0.19671836f, -0.00304589f, 0.15364181f, 
    0.02784770f, -0.02794554f, 0.07931232f, -0.07666455f, 0.08275039f, 0.09843617f, -0.04083809f, -0.03088761f, 
    0.16209689f, -0.01101078f, -0.10144760f, -0.06108780f, -0.07364479f, 0.03344713f, 0.17914093f, 0.06017647f, 
    -0.04113759f, -0.06646883f, -0.03403090f, 0.04546426f, 0.11700698f, 0.00305575f, 0.12906665f, 0.08516534f, 
    0.13993876f, 0.00805437f, 0.12210354f, 0.10224924f, 0.03508598f, 0.05788070f, 0.25770432f, 0.05708978f, 
    -0.19135736f, -0.15586258f, 0.13370803f, 0.09465195f, 0.09425015f, 0.06044091f, -0.04841112f, -0.05759113f, 
    -0.10579994f, -0.07259886f, -0.10275654f, 0.04328300f, -0.32740229f, -0.09987887f, -0.20210241f, -0.03676580f, 
    -0.01670050f, -0.02434539f, 0.11739887f, -0.00887220f, -0.02568098f, -0.03641756f, 0.08184659f, 0.02593124f, 
    -0.14038464f, -0.06086173f, 0.03731573f, 0.14422457f, -0.01976245f, 0.00725987f, 0.02451765f, -0.11508270f, 
    -0.09024785f, 0.01596789f, 0.06077067f, 0.04740915f, -0.17454836f, 0.26562870f, 0.24058028f, 0.26865533f, 
    0.03960830f, -0.07463975f, -0.06628550f, -0.09122641f, -0.01560504f, -0.01511846f, -0.12028474f, -0.04204933f, 
    -0.07563170f, 0.04740965f, 0.13670814f, -0.03793235f, 0.00872823f, 0.05435945f, -0.01151905f, 0.06245597f, 
    -0.00289591f, -0.02051056f, 0.04036007f, -0.00721562f, -0.16115527f, -0.17425074f, 0.02025789f, 0.08655393f, 
    -0.12640929f, 0.13408187f, 0.05616065f, -0.02589308f, -0.06211134f, -0.08515296f, 0.16407543f, 0.14822899f, 
    -0.09074133f, 0.01255870f, -0.10516614f, -0.13437693f, 0.02082285f, -0.05675240f, 0.01832381f, -0.00559910f, 
    0.20135033f, 0.17657444f, -0.00727629f, 0.00155991f, -0.22496858f, 0.14835252f, 0.11601049f, 0.03292086f, 
    0.11745269f, -0.07778550f, 0.01023698f, 0.17218710f, 0.03452526f, 0.05363456f, -0.00258573f, 0.23322801f, 
    0.06168640f, -0.09126766f, -0.06781335f, 0.02116540f, -0.00309968f, 0.01610695f, 0.16897134f, 0.08550859f, 
    0.00959314f, -0.00419732f, 0.03761634f, 0.00559432f, 0.20429592f, 0.18806688f, 0.31146920f, 0.12831794f, 
    0.12096184f, -0.01428729f, 0.12008038f, 0.06561438f, 0.03028681f, 0.11364073f, 0.01526093f, 0.22601537f, 
    -0.17576471f, 0.02577636f, -0.05154383f, 0.06810082f, -0.09961176f, -0.06448527f, 0.01565344f, -0.12802698f, 
    -0.10081854f, -0.05432166f, 0.10663829f, 0.00415270f, -0.02403530f, -0.04618658f, -0.14337187f, -0.11600222f, 
    -0.01048704f, -0.01812597f, -0.09005330f, 0.02352007f, 0.02368549f, 0.01328608f, -0.08565558f, 0.10260018f, 
    0.09588344f, -0.02728665f, 0.14958085f, 0.08925626f, 0.08908445f, -0.02647529f, 0.07424311f, 0.03292833f, 
    0.11548156f, 0.06264371f, 0.00360826f, 0.01767295f, -0.02513620f, -0.14152142f, -0.09613024f, 0.01718229f, 
    -0.03419244f, 0.06097601f, 0.00875933f, -0.04376955f, 0.07153363f, 0.02874110f, 0.08363881f, 0.05165660f, 
    -0.26502168f, -0.22140913f, -0.05270112f, -0.15513644f, 0.01735279f, 0.01657247f, -0.13710223f, -0.11120429f, 
    0.03167258f, -0.00341918f, -0.00868586f, 0.03327291f, -0.09379208f, -0.25474542f, 0.05957134f, -0.04385619f, 
    0.14631560f, -0.02562313f, -0.03553297f, -0.20867969f, -0.02910097f, -0.00114184f, 0.06498400f, -0.01344779f, 
    -0.20189492f, 0.06228695f, -0.01013855f, 0.03222069f, 0.00109417f, -0.01471055f, 0.09298704f, 0.11695936f, 
    -0.07825547f, 0.05123862f, 0.05832842f, -0.01770632f, -0.08722539f, -0.01147309f, -0.04723000f, 0.12804122f, 
    -0.02129439f, 0.08775239f, 0.03132957f, 0.05353080f, 0.02692978f, -0.02033660f, -0.01330062f, 0.01402256f, 
    0.00547443f, -0.07153668f, 0.07740549f, -0.04856516f, -0.00671069f, -0.01571116f, 0.13277851f, -0.03247940f, 
    0.09811137f, -0.04331592f, -0.13712770f, 0.07491662f, -0.33133003f, -0.04327490f, -0.06216924f, 0.00437922f, 
    0.11195791f, 0.02781015f, -0.14364059f, -0.03659162f, 0.15390010f, -0.04758258f, 0.02732198f, 0.03679501f, 
    -0.14224532f, 0.28457642f, -0.24125522f, 0.17834541f, 0.14776187f, -0.01152254f, 0.12000544f, -0.04736054f, 
    0.04829065f, -0.00187593f, -0.00732734f, 0.03187661f, 0.06704713f, -0.13885784f, 0.02449538f, -0.12714335f, 
    0.23738068f, 0.10381252f, -0.08808334f, 0.07096459f, 0.00046667f, -0.03537794f, 0.06040348f, 0.04083657f, 
    -0.10504151f, 0.11641791f, 0.05268035f, 0.02254516f, 0.12381031f, -0.05195946f, 0.04819021f, 0.01768450f, 
    -0.00907745f, 0.05869057f, -0.00638829f, 0.09943815f, 0.06814972f, 0.02605561f, -0.01245004f, 0.17319816f, 
    -0.12111423f, -0.02893072f, 0.05162257f, 0.06036526f, 0.04635346f, 0.03003472f, 0.09010086f, -0.00961903f, 
    0.16252811f, 0.04248668f, 0.18732622f, -0.10854255f, -0.08145879f, -0.09431796f, -0.02601437f, 0.15421845f, 
    0.11730471f, -0.06118036f, 0.04515018f, -0.13394636f, -0.25200412f, -0.02963563f, -0.07360338f, -0.03391934f, 
    -0.10378542f, -0.07918987f, 0.15809628f, 0.13544358f, -0.12124784f, 0.20784761f, -0.01387789f, -0.02436715f, 
    -0.15326841f, 0.12600750f, 0.15768139f, 0.02417875f, -0.24092805f, -0.08263948f, 0.01081860f, 0.05347167f, 
    0.06839519f, -0.01292170f, 0.03759005f, -0.12807934f, -0.05009672f, 0.03314750f, -0.11113045f, 0.12681538f, 
    -0.03569807f, 0.03932282f, -0.04935701f, -0.01568238f, -0.13007331f, -0.04323693f, 0.02354592f, 0.16751058f, 
    0.06533002f, -0.06454706f, 0.09146301f, 0.33126086f, 0.04848306f, 0.17876454f, 0.01899357f, -0.05224441f, 
    0.01220782f, -0.00447335f, 0.11877757f, 0.02642990f, -0.08812069f, -0.07364000f, -0.16735502f, -0.00324190f, 
    -0.07045929f, 0.06278212f, 0.12317196f, -0.08914544f, 0.02776102f, -0.09820340f, -0.07126014f, 0.06036650f, 
    0.21352108f, -0.01808575f, -0.02862482f, -0.01186691f, -0.02403664f, -0.01179716f, -0.01411226f, 0.02027065f, 
    0.01519626f, -0.06606437f, 0.01906823f, 0.03574612f, 0.04264687f, -0.08719697f, 0.02191735f, -0.15309155f, 
    0.03328609f, 0.07076719f, -0.03421450f, 0.04783130f, -0.01080176f, 0.01405388f, 0.00183724f, -0.05321855f, 
    -0.38550678f, -0.04574598f, 0.06956841f, -0.05112512f, 0.04221400f, 0.11144815f, 0.04953245f, 0.17447473f, 
    0.07801889f, 0.13597925f, 0.05516126f, 0.00882297f, -0.07783250f, -0.05590336f, 0.14471897f, 0.04644809f, 
    0.04101960f, 0.06024861f, -0.05442013f, 0.06723277f, -0.09290224f, 0.02937745f, -0.00124963f, -0.04656773f, 
    0.07993296f, -0.18091999f, 0.02284461f, 0.09085277f, 0.09590031f, 0.02883518f, -0.06245396f, -0.02705156f, 
    0.01321873f, 0.10828844f, -0.07514594f, -0.03081914f, -0.07436709f, -0.20000912f, -0.11286603f, -0.00453669f, 
    0.05227932f, -0.08128220f, 0.09983550f, -0.04230854f, -0.09495956f, -0.09430242f, 0.01957706f, 0.00647437f, 
    -0.02399196f, -0.04462046f, -0.01511380f, -0.12695929f, -0.07050818f, -0.02678189f, 0.06047077f, -0.09459945f, 
    0.12717740f, 0.04877666f, -0.04993168f, -0.00354136f, -0.15768832f, -0.10054163f, -0.16504207f, -0.18123071f, 
    -0.11722564f, -0.10134621f, -0.05573455f, 0.03632521f, -0.11463369f, -0.06809422f, -0.11048379f, -0.13956870f, 
    -0.06702639f, -0.04634435f, -0.09783899f, -0.07691265f, 0.01578703f, -0.05879109f, 0.08248377f, 0.13087274f, 
    0.14274979f, 0.14028397f, -0.00783851f, -0.04799642f, -0.03250500f, -0.10145615f, -0.03054318f, -0.02498229f, 
    0.11966895f, -0.05191633f, 0.07568932f, 0.19570965f, -0.01790108f, 0.12187874f, 0.15264976f, 0.00194974f, 
    -0.16548325f, 0.07200244f, 0.09842682f, -0.13637006f, -0.07626413f, -0.05540984f, 0.04011239f, 0.22587705f, 
    0.03875542f, 0.01593946f, 0.09102431f, -0.01276967f, -0.06773853f, 0.10764657f, 0.18656404f, -0.12022801f, 
    -0.09562396f, 0.11388952f, 0.10442752f, 0.10341110f, 0.07135458f, 0.09803564f, 0.07401478f, -0.05373739f, 
    0.01336197f, 0.01295705f, 0.09877215f, 0.16268045f, 0.00282305f, 0.04416744f, 0.03509575f, -0.06916342f, 
    -0.00423573f, 0.00195366f, 0.00307902f, 0.07093675f, -0.22280975f, -0.10498916f, -0.01710218f, 0.06234332f, 
    -0.02289581f, -0.02249285f, 0.10437356f, 0.03806286f, 0.08306297f, -0.08346204f, -0.12135276f, -0.04473686f, 
    0.01198024f, 0.01027639f, -0.02448623f, -0.00683840f, -0.00768627f, -0.03119621f, 0.02179708f, -0.00185745f, 
    0.03818263f, -0.00721220f, -0.02114821f, -0.00988842f, 0.00749954f, 0.01333748f, 0.03003396f, 0.02891270f, 
    -0.00514335f, -0.00451457f, -0.02646183f, -0.01030042f, -0.00517792f, 0.01383236f, -0.02938627f, 0.00572340f, 
    0.00699546f, -0.03694498f, -0.02410851f, -0.03872394f, 0.03104910f, -0.02625770f, -0.03154067f, 0.02754343f, 
    0.01977276f, 0.00623081f, 0.01857197f, -0.01110618f, -0.00628801f, -0.02992998f, -0.02169648f, -0.03412065f, 
    0.01234943f, -0.00032243f, 0.02727669f, -0.03579899f, 0.01999383f, 0.02160820f, -0.03165130f, -0.02431962f, 
    -0.02039441f, -0.02358105f, -0.00310858f, -0.02474860f, -0.02967416f, 0.01784817f, 0.01518800f, 0.01216915f, 
    0.01016317f, -0.01498638f, -0.00878570f, -0.00671345f, -0.00679428f, -0.03892311f, -0.00973851f, 0.01754731f, 
    0.01883794f, -0.01760645f, 0.02819141f, 0.01160749f, 0.02219159f, -0.01144170f, 0.02107837f, 0.00608450f, 
    0.01088895f, 0.01661764f, 0.01778928f, 0.01362957f, -0.01317092f, -0.02924679f, -0.02690856f, 0.02650148f, 
    -0.00098219f, -0.03748005f, 0.00736593f, -0.02736098f, 0.01853469f, 0.00545399f, -0.00347014f, 0.02811182f, 
    -0.03104647f, -0.00444047f, 0.01569884f, -0.04099867f, -0.03262490f, 0.01461967f, -0.00285752f, 0.01644306f, 
    -0.04192603f, -0.02254405f, -0.00232745f, 0.02255543f, -0.02075604f, -0.00492829f, -0.01644498f, -0.00369827f, 
    -0.00392892f, -0.02028306f, -0.01661854f, 0.00315106f, -0.00121013f, -0.00732695f, -0.03576748f, 0.02962268f, 
    0.00495810f, 0.00075498f, 0.02112833f, -0.02678018f, 0.00350996f, 0.00857348f, 0.02046237f, 0.00737858f, 
    -0.03422211f, 0.01157321f, -0.02549834f, -0.00911787f, -0.01068161f, -0.00441330f, 0.00833707f, 0.00591537f, 
    0.01889977f, -0.03876079f, -0.02363297f, 0.02663438f, -0.03561303f, 0.02855260f, -0.03903501f, 0.01953781f, 
    -0.01936267f, -0.00711664f, -0.02172349f, -0.02598766f, -0.01968245f, -0.03809495f, 0.00874701f, 0.01756305f, 
    -0.01431924f, -0.03989550f, -0.02857631f, 0.00668730f, 0.01416123f, -0.01722502f, 0.02167411f, 0.00830100f, 
    0.00330737f, -0.02562759f, 0.01641038f, -0.03399781f, 0.00449608f, -0.02218216f, -0.03956882f, 0.01229678f, 
    -0.03752032f, -0.00765228f, 0.01096048f, -0.02747974f, -0.04056687f, 0.01395633f, 0.00046655f, -0.01206197f, 
    0.00152373f, -0.02701438f, 0.02932368f, -0.02224893f, -0.02731281f, -0.01954923f, -0.02517872f, -0.00507063f, 
    0.02108010f, 0.01580676f, -0.01571964f, 0.01974456f, -0.03601102f, 0.00402876f, -0.02787328f, 0.00658876f, 
    0.00658288f, 0.00335541f, -0.00119725f, 0.00918736f, 0.00923893f, 0.02934281f, 0.02869491f, 0.00681025f, 
    -0.01139642f, -0.02525364f, -0.00543316f, -0.00019356f, 0.00060126f, -0.02280788f, -0.00265634f, -0.02630398f, 
    0.02562225f, -0.00452768f, -0.02837793f, -0.02594575f, -0.00965024f, -0.02769293f, -0.02323661f, -0.03947108f, 
    -0.00993740f, -0.01913074f, -0.03175737f, 0.00242988f, 0.00490553f, -0.01483596f, -0.01257694f, -0.01689385f, 
    -0.02527730f, -0.04017427f, 0.01176848f, -0.02077300f, -0.01112354f, 0.00851643f, -0.01131507f, -0.01607590f, 
    -0.03998166f, 0.00980215f, -0.01619766f, 0.01488448f, -0.02970344f, -0.04136441f, 0.00199932f, -0.00802451f, 
    0.00606328f, 0.02230884f, 0.01517959f, -0.00423155f, 0.01431974f, 0.02892225f, 0.00068382f, 0.02135833f, 
    0.00147596f, -0.00968804f, -0.01843411f, 0.01791472f, -0.01496514f, -0.02182510f, -0.01335660f, 0.00226672f, 
    -0.01043407f, -0.03147371f, 0.01160998f, -0.03442781f, 0.02353965f, 0.02534775f, -0.01426255f, -0.00550002f, 
    0.02953696f, 0.01445989f, 0.01303214f, -0.00970769f, -0.02634595f, 0.01224247f, -0.02371004f, 0.00791973f, 
    -0.01009272f, 0.00296851f, -0.00822904f, 0.02531357f, -0.02846958f, -0.00084608f, 0.02475201f, 0.02217083f, 
    0.01046596f, -0.01827445f, 0.02487382f, -0.01549245f, -0.02272599f, 0.01083651f, -0.00949712f, 0.01605401f, 
    0.01097138f, -0.00667684f, -0.03094265f, -0.02260563f, -0.02076135f, 0.02627410f, -0.02774761f, 0.00558762f, 
    0.00409481f, -0.02556206f, -0.02228737f, 0.00507955f, -0.02203262f, -0.03748974f, -0.03884304f, -0.03848001f, 
    -0.02440907f, -0.00422447f, -0.02627354f, -0.00311961f, -0.00927257f, 0.00766426f, 0.00576231f, -0.00242316f, 
    0.00351469f, 0.00879170f, -0.01710700f, -0.01599253f, -0.00383333f, -0.03426682f, 0.02215067f, 0.01628338f, 
    -0.02660930f, 0.01488484f, -0.02041617f, 0.00705333f, 0.00617064f, 0.01072601f, 0.00907159f, 0.00006937f, 
    0.00141606f, -0.02273064f, 0.01456494f, -0.02776601f, -0.04099865f, 0.01351791f, -0.01285631f, 0.00066049f, 
    0.01741043f, 0.02143177f, 0.02892841f, -0.01484563f, 0.00941908f, -0.01917575f, -0.03165264f, -0.00422017f, 
    -0.00449940f, -0.04136343f, 0.01509503f, -0.02851205f, -0.03273210f, -0.00455547f, -0.00834400f, -0.03724971f, 
    -0.01065058f, 0.01652225f, 0.01997468f, 0.00408042f, -0.00248368f, -0.00154221f, -0.02227169f, 0.01433123f, 
    -0.03204521f, -0.00195296f, -0.02623486f, -0.01617196f, 0.01079634f, -0.00174448f, -0.01861683f, -0.03509351f, 
    0.01281747f, -0.03416206f, 0.00265571f, -0.02470228f, -0.02023713f, -0.02133647f, -0.00645190f, -0.03440061f, 
    -0.01871161f, 0.00058286f, 0.00367038f, 0.01200169f, 0.01962143f, 0.01706254f, -0.01514089f, -0.03413147f, 
    0.00196860f, -0.04028644f, 0.01841627f, -0.00065884f, 0.00657419f, -0.03173854f, -0.02166601f, 0.00122022f, 
    0.01321542f, -0.04194128f, 0.01445879f, 0.02310949f, -0.00348988f, -0.01165200f, 0.00574765f, 0.00584518f, 
    0.01695354f, -0.02118313f, 0.01734607f, 0.01594422f, -0.02328229f, -0.02394832f, -0.00741836f, -0.03987048f, 
    0.00894525f, 0.00196370f, 0.01376445f, -0.01986269f, 0.00608502f, -0.00955138f, 0.01064431f, 0.01145592f, 
    -0.01407929f, 0.04067448f, 0.03671556f, 0.02182910f, -0.03151184f, -0.00245193f, -0.01384864f, -0.00511852f, 
    -0.02657336f, 0.02629832f, 0.02942154f, -0.02678821f, 0.02015926f, 0.01438464f, -0.03134399f, -0.02031100f, 
    -0.01554924f, 0.00307650f, -0.02262344f, 0.01328609f, 0.01360871f, -0.02547021f, -0.02744810f, 0.02356184f, 
    0.02882928f, 0.00523424f, -0.00639343f, 0.02873340f, -0.02226500f, -0.04082223f, -0.01048592f, 0.01659988f, 
    0.00584823f, -0.03258221f, -0.01491595f, 0.00161274f, 0.01365854f, 0.02016495f, -0.00142181f, 0.00622036f, 
    -0.02822838f, -0.02330734f, -0.03846047f, 0.02660564f, 0.00152040f, -0.02006780f, -0.00861193f, -0.02573793f, 
    -0.03971752f, 0.01566196f, -0.02456043f, -0.01586405f, -0.01963217f, -0.02636038f, -0.02215041f, -0.02372067f, 
    -0.02059671f, -0.03742854f, -0.01625189f, 0.01110346f, 0.02951574f, -0.00973565f, -0.02387291f, 0.01033035f, 
    -0.03637698f, -0.01416438f, 0.02842395f, -0.04114045f, -0.01409104f, -0.01636687f, 0.00143788f, -0.00502855f, 
    -0.02923878f, 0.01701243f, 0.00167493f, 0.01999357f, 0.01577946f, 0.00857255f, 0.01500473f, -0.02214735f, 
    0.02844985f, 0.00703691f, -0.00084833f, 0.00243526f, -0.02567686f, -0.01584045f, -0.01685838f, -0.04000944f, 
    0.02237326f, 0.00948482f, -0.02955359f, -0.01950744f, 0.00294782f, -0.03969423f, -0.02865629f, 0.02982822f, 
    -0.00738131f, -0.00386477f, -0.01549086f, -0.01062161f, -0.01190487f, 0.01915785f, 0.00937856f, -0.00977652f, 
    0.01656836f, -0.00967194f, -0.01660922f, -0.00673807f, -0.03458200f, 0.02720534f, -0.03184006f, -0.02672720f, 
    -0.03942018f, 0.02378880f, 0.02679806f, -0.00717642f, 0.02478547f, 0.00950588f, -0.02659736f, 0.00301854f, 
    0.03059443f, -0.02064452f, -0.03518544f, 0.01970770f, 0.00558561f, -0.01671473f, -0.01271289f, -0.02162148f, 
    0.00110364f, 0.01307256f, -0.01595612f, -0.02774251f, -0.03320289f, -0.00019691f, -0.03861036f, -0.00943795f, 
    0.00990946f, -0.00073991f, -0.01028398f, 0.01429921f, -0.00933153f, -0.00574010f, 0.00574079f, 0.01368644f, 
    -0.02888771f, -0.02290585f, 0.01489403f, -0.01123485f, 0.01733523f, -0.01972156f, 0.00118630f, 0.00324428f, 
    0.01714239f, -0.02506680f, 0.00323144f, -0.01356634f, -0.03481076f, -0.00875789f, 0.00405673f, 0.02897657f, 
    -0.02338186f, -0.02616153f, -0.01368491f, 0.02309459f, -0.03547442f, -0.02272588f, -0.03397209f, 0.00911469f, 
    -0.00165627f, -0.00953129f, -0.01459459f, 0.01008079f, 0.03028810f, 0.00925195f, 0.01964195f, -0.01763366f, 
    0.00630336f, 0.01131771f, 0.00062680f, -0.01414583f, -0.00159867f, -0.02889811f, 0.02514203f, -0.02577380f, 
    -0.03750670f, 0.02535170f, -0.01669557f, -0.03470951f, 0.02413023f, -0.03036025f, -0.04096461f, 0.00726688f, 
    0.01260871f, -0.01756716f, -0.01642936f, -0.02628034f, -0.02981567f, 0.01098139f, 0.00315366f, -0.02669691f, 
    -0.02734538f, -0.01039216f, 0.01802888f, -0.03378027f, -0.02374841f, -0.03676068f, -0.02733255f, -0.03420044f, 
    -0.03321525f, 0.02299901f, -0.00022201f, -0.03197644f, -0.00145715f, 0.02351054f, -0.03779664f, 0.02248362f, 
    -0.01132714f, 0.01366721f, -0.03894617f, 0.01221144f, -0.01617470f, 0.02824266f, 0.01219579f, -0.04038477f, 
    -0.00019263f, 0.02706126f, -0.01580113f, 0.01052483f, -0.03174019f, 0.02950134f, 0.00863104f, 0.02234797f, 
    0.02882325f, -0.02718083f, 0.01701922f, -0.03520657f, -0.02155656f, -0.00516355f, -0.02857800f, -0.00375245f, 
    -0.03953489f, 0.02032550f, -0.01104671f, -0.02984869f, -0.02042803f, -0.03232581f, -0.00892518f, -0.01845875f, 
    -0.00675558f, -0.01476786f, 0.01785593f, 0.01657287f, -0.01833403f, -0.03357951f, 0.02342542f, 0.01828255f, 
    0.01841598f, 0.00619197f, 0.01358770f, -0.00985345f, 0.00281717f, 0.01324404f, 0.02627028f, -0.00736944f, 
    -0.00708486f, 0.02004744f, -0.01185744f, -0.01570136f, 0.03068572f, -0.00337323f, 0.02365817f, -0.02665806f, 
    -0.04054063f, -0.02486522f, -0.00928936f, 0.02117020f, 0.00548091f, -0.01903407f, -0.02425646f, 0.02648693f, 
    -0.00154958f, -0.03143439f, 0.00200360f, -0.02266417f, -0.02049392f, 0.02665799f, -0.01665382f, 0.01276418f, 
    -0.03811502f, 0.02929610f, 0.01250031f, -0.02352507f, -0.03287252f, -0.01895266f, -0.00804499f, -0.00412794f, 
    0.01436878f, -0.04074846f, -0.04107883f, 0.01055758f, 0.01887413f, 0.02544036f, -0.00377888f, 0.02724284f, 
    -0.01090217f, -0.02397274f, -0.00597518f, 0.00031517f, -0.00309770f, 0.01107421f, 0.01118299f, -0.00174656f, 
    -0.04139690f, -0.02857358f, 0.02754129f, -0.03009232f, 0.00598777f, 0.02015284f, -0.00388978f, -0.03773592f, 
    -0.01317545f, 0.00245018f, -0.02849136f, -0.00990558f, -0.01003729f, -0.03319005f, -0.04097515f, -0.02491935f, 
    -0.02720589f, -0.04162984f, -0.00142261f, 0.00328616f, -0.02319596f, -0.02729630f, -0.03666408f, 0.02187751f, 
    0.00213528f, -0.00586178f, 0.02809601f, -0.02325902f, -0.01729995f, 0.01073954f, 0.00950981f, 0.02486440f, 
    0.00367961f, 0.01145072f, 0.02203220f, -0.02877552f, 0.02786242f, 0.01516221f, 0.01192132f, 0.01286917f, 
    -0.00648473f, 0.02252682f, 0.02044818f, -0.01375555f, -0.02521991f, 0.03043526f, 0.00616048f, 0.03009880f, 
    0.01948670f, 0.06247531f, -0.33456454f, 0.10487899f, 0.12811372f, -0.07200562f, -0.05935640f, 0.15166880f, 
    0.10841665f, 0.01544253f, -0.10330017f, 0.05366178f, 0.05036404f, 0.03812117f, -0.09611638f, 0.10632265f, 
    0.06659868f, 0.12538972f, 0.04359861f, -0.03132558f, -0.06436202f, -0.13278548f, 0.07336603f, -0.07467218f, 
    0.04154686f, 0.01673228f, -0.06027502f, 0.15479983f, 0.01541559f, 0.05320964f, 0.14442807f, 0.13398203f, 
    -0.07192545f, 0.07723808f, 0.06834234f, -0.10467272f, -0.01669955f, -0.16529435f, 0.09265093f, 0.08437768f, 
    0.08210747f, 0.03793750f, -0.01242539f, -0.11155307f, 0.02092718f, -0.06806830f, -0.14312671f, -0.00064448f, 
    0.12307547f, 0.04281809f, 0.12130079f, 0.03062652f, -0.07900190f, -0.01073499f, 0.03444177f, -0.06408764f, 
    0.10603346f, 0.05628101f, 0.02882098f, 0.16951638f, -0.12996283f, -0.10946424f, -0.33684757f, 0.22048329f, 
    0.00735893f, 0.09979461f, -0.03046065f, -0.20668204f, -0.11362519f, -0.01532454f, -0.05228567f, 0.04723068f, 
    0.46785864f, 0.04882606f, -0.02132028f, 0.23566136f, 0.09131416f, -0.06708090f, 0.01368985f, -0.05085309f, 
    0.04061739f, 0.12276348f, -0.07096927f, 0.17698865f, -0.17443494f, 0.20534627f, -0.11774953f, 0.12215275f, 
    -0.04822081f, 0.12943269f, -0.06874730f, -0.04682158f, 0.12367235f, -0.07154652f, -0.01661276f, -0.03162464f, 
    0.15652892f, 0.06183809f, 0.02697140f, -0.01188292f, 0.03600432f, -0.10402229f, -0.09849941f, -0.06709615f, 
    -0.03193596f, -0.00292856f, 0.06485218f, 0.11330462f, 0.26702571f, -0.41948017f, 0.07016524f, 0.04282490f, 
    0.03151795f, 0.02024010f, -0.05422322f, 0.08085135f, 0.02703168f, -0.00930900f, 0.05212775f, -0.03724279f, 
    -0.17754529f, -0.06133295f, -0.21311814f, 0.00655314f, -0.13435367f, -0.01731789f, 0.08084072f, 0.03323108f, 
    0.11546800f, 0.08481646f, 0.06179045f, 0.11663333f, 0.10506158f, 0.01013665f, 0.09480582f, 0.06151354f, 
    0.01940083f, 0.02113025f, -0.04299647f, -0.14282098f, -0.07317799f, 0.02313633f, 0.01407039f, 0.17295973f, 
    0.02636399f, -0.11956476f, -0.07706556f, -0.10816766f, 0.19887432f, 0.04907309f, 0.15663917f, 0.26075390f, 
    -0.01826424f, 0.09985492f, 0.12645733f, -0.02403734f, 0.04348290f, -0.10685349f, 0.16027379f, 0.29759443f, 
    0.01324946f, 0.11399688f, -0.00397564f, -0.11555900f, 0.07254112f, -0.05258443f, -0.05701552f, 0.01180178f, 
    0.02597605f, -0.07890922f, 0.03198713f, -0.02814618f, 0.00874261f, -0.05820312f, -0.02924276f, 0.01264522f, 
    0.12900309f, 0.02495215f, -0.12571605f, -0.00469407f, 0.02631887f, -0.02092117f, 0.21447089f, 0.04209973f, 
    -0.14048654f, -0.03332985f, 0.00316367f, -0.01510845f, 0.01921298f, 0.11410702f, 0.00955793f, -0.02058910f, 
    -0.09267820f, -0.06115308f, 0.02197490f, 0.02256722f, -0.02149806f, -0.06979258f, -0.01558223f, -0.00898920f, 
    -0.14912690f, -0.18509699f, -0.13879241f, -0.28542271f, -0.19275783f, -0.26842651f, -0.07377338f, -0.00895777f, 
    0.00880875f, -0.01597423f, -0.00100956f, -0.01949487f, 0.02790445f, 0.11807498f, -0.00705160f, 0.01195818f, 
    0.06795380f, -0.08333182f, -0.17746532f, -0.05200055f, 0.15536085f, -0.00863737f, 0.00052688f, 0.15231572f, 
    0.01559300f, -0.05795342f, -0.08387048f, -0.15448943f, -0.04531176f, 0.06772976f, 0.24218196f, 0.14313613f, 
    0.06800647f, 0.06796674f, 0.19745409f, -0.03334143f, -0.06688607f, 0.10523587f, 0.02836231f, 0.03560153f, 
    0.45367715f, -0.00476724f, 0.05714786f, 0.12447422f, 0.07294738f, 0.15315478f, -0.06516040f, 0.04427837f, 
    -0.09702147f, 0.03674908f, -0.00875653f, -0.11785217f, 0.22373597f, -0.16595247f, 0.02020035f, 0.12813701f, 
    0.07264591f, -0.05897372f, 0.07474533f, -0.01464430f, -0.04368920f, -0.00111607f, 0.09596066f, -0.05074608f, 
    0.13597275f, 0.03423941f, 0.03851333f, 0.09355296f, 0.07550427f, -0.05037490f, -0.13230497f, 0.12697887f, 
    0.12551749f, 0.01525672f, -0.07143599f, 0.03278919f, -0.04659588f, 0.07435583f, 0.10238728f, 0.25889975f, 
    0.00384102f, -0.05779957f, 0.02991038f, 0.01937498f, -0.05853312f, -0.02748990f, -0.09499671f, -0.08613332f, 
    0.07520913f, -0.06443720f, -0.04232053f, 0.10929482f, 0.08799006f, -0.10788925f, 0.04128307f, -0.03575826f, 
    -0.10725092f, 0.04336561f, 0.02073853f, -0.02052218f, -0.22590211f, -0.09173590f, -0.16141887f, 0.00456613f, 
    -0.11070760f, -0.02452829f, 0.01648479f, 0.05492616f, 0.02297837f, 0.07035068f, 0.09108604f, 0.06544712f, 
    0.05919045f, 0.09353375f, 0.12810767f, -0.00605040f, -0.11226644f, -0.04390155f, -0.03657176f, -0.13601857f, 
    -0.11737132f, 0.03957245f, 0.11213084f, 0.00006688f, 0.18649724f, 0.15487984f, 0.01051944f, 0.36148620f, 
    0.13279487f, 0.03416169f, 0.14429386f, 0.05375969f, 0.19596638f, 0.01456090f, 0.19960123f, 0.02408802f, 
    -0.03786429f, -0.07455222f, -0.17836376f, -0.30359694f, -0.09870230f, -0.04056166f, -0.07057833f, 0.10253809f, 
    -0.05287801f, -0.02561450f, -0.04493974f, 0.01470163f, -0.06302387f, 0.00473388f, 0.05162034f, -0.01920536f, 
    0.08586155f, 0.03509618f, 0.08966248f, 0.09707234f, -0.09020588f, 0.07478241f, 0.11725436f, 0.05753496f, 
    -0.06818257f, 0.15507443f, 0.02618281f, 0.12342096f, 0.11427996f, -0.05610292f, -0.06598241f, -0.09040733f, 
    -0.19140077f, -0.00939643f, -0.14340337f, 0.02371004f, -0.05441898f, -0.19780187f, 0.14773406f, 0.07969379f, 
    -0.11305071f, 0.07947959f, 0.16041273f, -0.01234192f, 0.09079079f, 0.01593805f, 0.04113485f, 0.06031291f, 
    0.06513052f, 0.06357101f, 0.01303745f, 0.21479654f, 0.02931211f, 0.02416516f, 0.04883595f, 0.01677225f, 
    -0.05954130f, 0.10400450f, 0.06537158f, -0.02833094f, 0.11585625f, 0.00566376f, -0.01587215f, -0.16706292f, 
    0.04620909f, -0.03779576f, -0.13790421f, 0.06037818f, -0.05714778f, 0.05648425f, -0.10328316f, -0.17056713f, 
    -0.11521688f, -0.19482905f, -0.14667638f, 0.17586200f, -0.08943272f, -0.12311955f, -0.13134591f, -0.13361779f, 
    -0.02755757f, 0.10639814f, -0.03142058f, -0.06436582f, -0.04116086f, -0.18306041f, -0.07038361f, 0.26080409f, 
    -0.09702777f, -0.13587369f, 0.01494920f, 0.00002752f, -0.05507503f, 0.02616714f, -0.01399720f, 0.09071176f, 
    -0.00069116f, 0.12954143f, 0.00384105f, 0.04226566f, -0.02738696f, 0.01242640f, 0.00661546f, 0.02668475f, 
    0.09593539f, -0.02189878f, -0.00241303f, 0.17102355f, -0.25640002f, 0.05422740f, -0.08164271f, 0.08140231f, 
    -0.11201706f, -0.03214131f, -0.06250507f, -0.03611255f, -0.05522132f, -0.15514719f, 0.03330227f, -0.00226322f, 
    -0.08556081f, -0.16761149f, 0.06211644f, 0.07720926f, 0.13818738f, 0.00835634f, -0.00166615f, 0.00830970f, 
    -0.18549521f, -0.05382461f, 0.00256643f, 0.01602023f, -0.09332688f, -0.02734453f, -0.13268258f, 0.11957179f, 
    -0.04415759f, 0.05728729f, 0.02535657f, -0.10162016f, -0.03952179f, -0.10194985f, -0.03835922f, 0.12841892f, 
    0.29081115f, 0.14774907f, 0.13820592f, 0.02066994f, -0.09761688f, 0.06711155f, 0.07069076f, 0.05031066f, 
    -0.01572961f, 0.02417430f, 0.11475172f, 0.13678531f, 0.18348576f, -0.09378125f, 0.19241337f, -0.15757290f, 
    0.09865462f, 0.12659743f, 0.06429972f, 0.00343743f, -0.10743456f, -0.04581484f, 0.10394511f, -0.05219790f, 
    0.08618544f, 0.17645387f, -0.00261312f, 0.14376000f, 0.06622624f, -0.02789487f, 0.03874636f, -0.04353972f, 
    -0.01163711f, 0.21880135f, 0.01045270f, 0.06450589f, -0.00416565f, 0.36560979f, -0.36656466f, -0.02359739f, 
    -0.04727033f, -0.02317158f, 0.11437154f, 0.18116002f, 0.03901797f, 0.07915565f, 0.11297043f, 0.20363830f, 
    0.05114903f, -0.42238900f, 0.10588310f, 0.18178849f, -0.05287872f, 0.05317444f, 0.12804943f, 0.05916248f, 
    -0.04227939f, 0.07068308f, -0.03385269f, 0.06326500f, 0.03480244f, 0.10395423f, 0.06471283f, -0.00376949f, 
    -0.17348532f, 0.02973423f, -0.11944168f, -0.08771763f, 0.15271875f, -0.10588361f, 0.06867112f, -0.11310854f, 
    -0.11820986f, -0.01574078f, 0.00339357f, -0.12877278f, -0.12704097f, 0.00365903f, 0.06637906f, -0.00732741f, 
    -0.16977796f, 0.00347020f, 0.00439105f, -0.00609239f, 0.06549686f, 0.22510858f, -0.02930327f, 0.06885561f, 
    -0.00001114f, 0.01054726f, 0.02264409f, 0.05559527f, -0.02279461f, 0.09435640f, 0.16581608f, 0.02327341f, 
    -0.16838229f, 0.17954828f, -0.00956254f, 0.13671918f, 0.12083040f, 0.15543367f, 0.07062910f, 0.04325063f, 
    0.06024460f, -0.10805916f, 0.03313671f, 0.03576256f, -0.03920733f, -0.14353548f, 0.16737849f, 0.13913520f, 
    0.09479798f, -0.07488654f, -0.03231855f, -0.12071582f, 0.09361188f, 0.08262372f, -0.04743817f, -0.01673342f, 
    0.17312445f, 0.11421653f, 0.09176334f, 0.00969550f, 0.02597257f, -0.15104139f, -0.04208234f, -0.00805648f, 
    0.02124556f, 0.11035959f, -0.01673109f, 0.09954941f, -0.02369297f, 0.25886217f, 0.11719612f, 0.01601412f, 
    -0.02846131f, -0.12191869f, -0.00807197f, -0.03754435f, -0.04017627f, 0.04988956f, 0.00224429f, 0.09930401f, 
    0.19069555f, 0.28152865f, -0.04016247f, 0.05471297f, -0.16046020f, 0.19790579f, -0.20962405f, -0.12878726f, 
    0.07055287f, 0.03836681f, 0.00566790f, 0.14303009f, 0.03669536f, 0.01789243f, 0.11550335f, 0.10097978f, 
    0.05500396f, 0.05344997f, 0.11932655f, -0.09712072f, -0.09502922f, -0.06851777f, 0.00294770f, 0.01799616f, 
    -0.47774053f, -0.02083970f, -0.02904329f, 0.19288386f, -0.01697636f, -0.00899309f, 0.00844155f, -0.03094359f, 
    -0.15612911f, -0.17887138f, -0.05329153f, -0.02348495f, 0.15549208f, -0.25606701f, 0.19871758f, 0.30213416f, 
    0.04031085f, -0.05455560f, 0.03258996f, -0.00337942f, -0.12003902f, -0.05481450f, -0.10417302f, -0.05972554f, 
    -0.24484403f, -0.17539209f, 0.03147140f, 0.09519573f, 0.07144886f, 0.06090897f, 0.00772134f, 0.20210344f, 
    -0.00817865f, 0.01385166f, -0.03576557f, -0.07000450f, 0.06559199f, 0.19283453f, 0.17958872f, 0.08631967f, 
    -0.04383656f, -0.10409419f, -0.03886293f, -0.10410034f, -0.01270854f, 0.07088491f, -0.07607127f, 0.09777384f, 
    -0.01561800f, 0.09148961f, 0.08906403f, 0.01834092f, -0.05760827f, -0.06261030f, -0.03743850f, -0.00145374f, 
    0.07957357f, 0.06666192f, 0.19675682f, -0.01565636f, 0.12040966f, -0.09321150f, -0.06870624f, 0.10824433f, 
    -0.04178889f, 0.02238218f, -0.06192411f, -0.08155882f, 0.00122008f, -0.01490343f, -0.10489595f, -0.20812954f, 
    -0.20677169f, 0.07932273f, 0.06479556f, -0.15731996f, -0.05021216f, 0.04476734f, -0.04955328f, 0.01475761f, 
    -0.01412251f, 0.17164144f, -0.02272476f, -0.09186430f, -0.06669411f, 0.01081414f, -0.16141209f, 0.09563271f, 
    -0.06101644f, 0.18673910f, -0.03760900f, -0.03537834f, 0.11683512f, -0.07050814f, -0.04155767f, -0.04280496f, 
    -0.01410136f, 0.13828892f, 0.01319841f, 0.07191080f, -0.03157207f, -0.08620147f, -0.06812292f, 0.03507431f, 
    -0.02031491f, 0.00111526f, 0.00169850f, -0.02510594f, 0.11968046f, -0.10427049f, -0.03787155f, -0.02816671f, 
    0.06300622f, 0.11453782f, -0.11341675f, -0.06098333f, -0.18692605f, 0.06010945f, 0.02161757f, -0.00445954f, 
    -0.11051720f, 0.02696259f, 0.18373854f, 0.15846331f, -0.01365543f, 0.04009578f, 0.02223694f, -0.03331514f, 
    0.16686350f, 0.10765132f, 0.12927993f, 0.09932121f, 0.05263958f, -0.12845337f, 0.05150228f, 0.26812512f, 
    -0.03949544f, 0.08983786f, 0.14754342f, 0.13607326f, 0.00352234f, 0.12139714f, 0.01769492f, 0.11043748f, 
    0.05763246f, -0.01555037f, 0.00086592f, 0.14668794f, 0.00953088f, -0.03074598f, -0.01116745f, -0.08444922f, 
    0.04490322f, 0.02684883f, 0.01803544f, 0.04756601f, 0.09082437f, -0.05398775f, 0.02014405f, 0.01047466f, 
    -0.05823006f, -0.03514949f, -0.01167652f, 0.00846197f, -0.06892852f, -0.02342043f, -0.11124578f, 0.04950334f, 
    -0.37732783f, 0.34879512f, -0.06361963f, -0.28462002f, 0.09010962f, 0.11800116f, -0.06779984f, 0.03095027f, 
    -0.20418724f, -0.03270886f, 0.06443673f, 0.02208461f, 0.07104883f, -0.01656432f, 0.07467622f, 0.42526564f, 
    0.02181413f, 0.12822866f, 0.01379715f, -0.10013653f, -0.08582740f, -0.09311654f, -0.02889314f, -0.02303647f, 
    -0.36924806f, -0.14726472f, 0.23870797f, 0.17982467f, 0.11902738f, 0.08851122f, 0.15723993f, 0.03764571f, 
    -0.08400545f, 0.04702292f, -0.03947946f, 0.17315620f, -0.12425592f, 0.31254175f, -0.16467579f, 0.10087159f, 
    0.02092157f, 0.01222800f, 0.01199079f, 0.06524210f, -0.05216420f, -0.00789779f, 0.02051068f, 0.07971012f, 
    0.20546024f, 0.08864953f, -0.18557379f, -0.18434255f, 0.03814583f, -0.04642120f, -0.04064610f, 0.01529886f, 
    -0.06049196f, -0.20420411f, -0.05380075f, -0.12461957f, 0.04242302f, 0.25385091f, 0.02953856f, -0.05219467f, 
    -0.04482153f, -0.12977667f, 0.03571982f, 0.07366835f, 0.05078598f, -0.06456117f, -0.01332601f, 0.00623655f, 
    -0.04916319f, -0.16736712f, 0.06381901f, 0.10963932f, 0.01395465f, 0.00270908f, 0.02101083f, 0.15865897f, 
    0.00832505f, 0.17284472f, 0.05937546f, -0.12652452f, 0.01570126f, 0.03050678f, 0.05169170f, 0.04373389f, 
    0.02804380f, -0.12047357f, 0.05777342f, -0.02691613f, -0.02720824f, 0.08712276f, 0.08044863f, 0.03619979f, 
    0.01961297f, -0.03886437f, -0.08141257f, 0.02038352f, 0.04013448f, -0.01065362f, 0.06033607f, 0.02393451f, 
    0.03864693f, 0.05720377f, 0.06098709f, 0.21751386f, -0.00970175f, 0.09213411f, 0.11841507f, 0.18936729f, 
    -0.04300375f, 0.12426259f, 0.07940872f, -0.01368097f, -0.01048482f, -0.02739136f, -0.04674679f, 0.19392751f, 
    -0.00654825f, -0.15531430f, 0.05450412f, 0.15049791f, -0.25146949f, 0.06630509f, 0.20518497f, -0.00884124f, 
    0.04312320f, 0.15485987f, -0.15833655f, -0.07752059f, 0.12074668f, 0.11312662f, 0.13367888f, -0.13680106f, 
    0.05079388f, 0.08929783f, -0.10885205f, 0.00399025f, -0.05785863f, -0.01887957f, 0.06814811f, -0.00164812f, 
    0.12935668f, -0.07670586f, 0.07411916f, -0.02226353f, -0.00087307f, -0.12400224f, 0.02252329f, 0.04344051f, 
    -0.06206239f, -0.05911926f, -0.03345212f, 0.11328269f, 0.03241251f, -0.00759854f, -0.09036080f, 0.28214067f, 
    -0.09857024f, 0.12046679f, 0.08042827f, 0.03816748f, 0.03005082f, 0.11837520f, 0.05946347f, -0.18083204f, 
    0.28777689f, 0.00797108f, -0.05942601f, 0.05062078f, -0.05098966f, -0.02208263f, 0.03919873f, -0.11569667f, 
    -0.00161845f, -0.02992136f, 0.06056691f, 0.13552250f, 0.00776336f, 0.14025085f, -0.11264696f, -0.26196614f, 
    0.04735423f, -0.02195036f, 0.04426653f, 0.08531538f, -0.00512722f, 0.15474832f, -0.11080065f, -0.26982602f, 
    -0.12291306f, 0.32463342f, -0.04282273f, -0.04709867f, 0.02040558f, 0.07654422f, -0.25518700f, -0.10398489f, 
    -0.00964586f, -0.21904297f, 0.18031552f, -0.17129055f, -0.02051984f, -0.13539013f, -0.03253889f, 0.21353458f, 
    0.04927509f, 0.00356149f, -0.01514925f, -0.03808249f, 0.00591638f, 0.11118070f, 0.13628475f, 0.21013586f, 
    -0.00719891f, 0.04403335f, 0.03588429f, 0.09436272f, -0.08687479f, 0.11983005f, 0.05066167f, -0.14303778f, 
    0.01602217f, 0.13051169f, -0.06205508f, -0.14176150f, 0.16422144f, -0.18579537f, 0.03930396f, 0.20105122f, 
    0.15196691f, -0.08835865f, -0.05075937f, -0.04808307f, -0.02256293f, 0.05485817f, -0.04315026f, 0.00905041f, 
    -0.11149910f, -0.02827364f, -0.12581408f, 0.01856351f, -0.01330488f, 0.05762520f, -0.01433497f, -0.01620306f, 
    -0.17421909f, -0.02059936f, 0.00183074f, -0.12376205f, -0.00862869f, -0.01859958f, -0.03448515f, -0.05772715f, 
    0.12610206f, 0.05188561f, 0.08206364f, -0.00656908f, -0.08885957f, 0.06937548f, 0.07302891f, 0.08213770f, 
    0.12133329f, 0.02732541f, 0.08854018f, -0.00656008f, -0.01905056f, 0.04742902f, 0.06363228f, 0.02172894f, 
    0.01579878f, 0.23856881f, 0.05154428f, 0.08138146f, -0.11471487f, 0.18494006f, 0.16393249f, 0.09438767f, 
    -0.02487662f, -0.16877311f, 0.03340063f, -0.13302632f, -0.13499480f, 0.06281952f, 0.01971996f, 0.01841575f, 
    0.46452898f, 0.14793287f, -0.20977658f, -0.18699434f, -0.06427541f, 0.02302948f, 0.01193294f, -0.23976246f, 
    0.00483770f, 0.06091733f, -0.00858664f, -0.02370915f, 0.04794948f, 0.00356640f, -0.06296230f, 0.14973876f, 
    0.06957359f, 0.06074223f, 0.00562978f, -0.09808294f, -0.02015938f, -0.06094915f, 0.07309543f, 0.12978351f, 
    -0.09042298f, -0.03509444f, 0.13469559f, -0.13977820f, -0.00791710f, 0.14816809f, -0.08897538f, -0.17525245f, 
    -0.12706399f, -0.07533493f, 0.11397366f, 0.04678389f, 0.08622671f, -0.09258667f, -0.03382658f, 0.18404253f, 
    -0.01913204f, -0.14925115f, 0.13273735f, 0.04143212f, -0.04311956f, 0.02736418f, 0.05391084f, -0.07067521f, 
    -0.01489082f, 0.00496698f, 0.11255045f, 0.02897056f, 0.02268208f, 0.03906176f, -0.03262344f, 0.01508660f, 
    0.12974189f, -0.14517158f, 0.19627841f, -0.02716949f, -0.01065181f, -0.00059540f, -0.00302004f, -0.05556040f, 
    -0.10197826f, 0.05307429f, 0.01185890f, -0.09895685f, 0.16667369f, 0.10390926f, 0.09437206f, 0.25935400f, 
    -0.07116913f, -0.11348645f, -0.02765300f, 0.14932774f, 0.06121224f, 0.01802585f, -0.03052313f, 0.11431709f, 
    0.04901388f, 0.01844654f, 0.12288699f, 0.00348822f, -0.04948471f, -0.20414756f, -0.01227005f, 0.15619543f, 
    0.11139158f, -0.09087391f, 0.00595757f, 0.09712642f, 0.00043565f, -0.03079499f, 0.15116023f, -0.03959569f, 
    -0.00999734f, 0.19547856f, 0.07344475f, -0.37069464f, 0.15952066f, 0.04104321f, -0.03187557f, -0.03937336f, 
    -0.07746827f, 0.11027077f, 0.01828628f, -0.15603483f, -0.11720374f, 0.02438580f, -0.09980913f, 0.08007509f, 
    0.02141746f, 0.07365401f, -0.13797536f, -0.00316512f, -0.01581633f, -0.10005926f, 0.03553266f, -0.04806912f, 
    0.04166478f, -0.01768542f, 0.00331741f, 0.14175548f, 0.07918689f, 0.04242994f, -0.01605990f, 0.03308467f, 
    0.09536108f, -0.13452201f, -0.08219016f, -0.09207162f, -0.03543727f, -0.13776951f, 0.04303420f, 0.36088216f, 
    0.00313055f, 0.18869504f, 0.12746054f, 0.19852178f, 0.00285099f, -0.01923069f, 0.04872216f, -0.06128427f, 
    -0.07758828f, 0.06846534f, 0.14032267f, 0.10755182f, 0.01841384f, 0.00641316f, 0.03294107f, 0.03096101f, 
    0.09584094f, 0.06248020f, -0.00969610f, -0.09124552f, 0.02747314f, 0.24429035f, 0.06425995f, -0.06913571f, 
    0.03728643f, -0.00965874f, -0.03911231f, 0.09049527f, 0.02724585f, -0.13218696f, 0.10353675f, -0.25281391f, 
    -0.00157007f, 0.10576815f, 0.01407847f, -0.15666650f, 0.06519789f, 0.07582620f, -0.02588334f, -0.10065830f, 
    -0.10880723f, 0.11325978f, -0.04988277f, 0.06855707f, 0.19056003f, -0.03089889f, 0.02265420f, -0.28260079f, 
    0.18098250f, -0.07976858f, 0.03458637f, -0.20644434f, -0.08380716f, 0.09109810f, -0.06728556f, -0.04558231f, 
    0.01768157f, -0.02124847f, 0.06224337f, 0.19190177f, 0.04631485f, -0.19629183f, 0.00619375f, 0.05503534f, 
    0.01048012f, 0.07025131f, 0.01346541f, -0.13074602f, -0.30280465f, 0.44271666f, -0.21093480f, 0.01757306f, 
    0.04073673f, 0.01749898f, 0.18194191f, 0.18534939f, 0.02413579f, 0.00775660f, -0.06397732f, 0.11093077f, 
    0.20580824f, -0.05102202f, -0.05491970f, -0.09910451f, 0.08366762f, -0.06793194f, 0.04670834f, -0.05422586f, 
    -0.01889665f, -0.08251932f, 0.05957177f, -0.10518165f, 0.14828385f, -0.23519638f, 0.12405134f, -0.35077658f, 
    -0.20758130f, -0.02369349f, -0.14286219f, -0.20360804f, -0.01252279f, -0.10113271f, -0.05803052f, 0.11390314f, 
    0.03414414f, 0.09661525f, -0.10502344f, -0.14935757f, -0.05285198f, -0.06027329f, 0.03696281f, -0.19035429f, 
    -0.14138934f, 0.10353429f, -0.25694790f, 0.17576876f, -0.07974517f, -0.10201881f, 0.02224759f, 0.22797243f, 
    0.01038227f, 0.03400178f, 0.04672600f, -0.00919665f, 0.07097467f, 0.03222046f, -0.02551363f, 0.04257385f, 
    0.23794235f, 0.04576062f, -0.00072136f, -0.18289998f, -0.04577212f, 0.00618330f, -0.01993043f, -0.02664144f, 
    -0.00715510f, 0.08978900f, -0.00334852f, -0.13853261f, -0.00459764f, 0.04080807f, 0.06843572f, -0.07157167f, 
    -0.02841610f, -0.18378603f, -0.08184455f, -0.07281823f, -0.12934893f, -0.08869006f, -0.01897575f, -0.22603312f, 
    -0.33350545f, 0.07279394f, 0.03405162f, -0.00639737f, 0.08596894f, 0.07979831f, 0.05509537f, 0.02483181f, 
    -0.07248563f, 0.00040940f, 0.01697978f, 0.00622299f, -0.04790982f, -0.10282375f, 0.23257075f, 0.04187015f, 
    -0.01500383f, 0.05492401f, 0.05710377f, -0.08410604f, 0.00272263f, -0.14169335f, -0.02140005f, -0.16653027f, 
    -0.08823070f, -0.09243245f, -0.07812396f, 0.01811633f, 0.05074446f, -0.00674167f, -0.07127564f, -0.00204523f, 
    -0.11347429f, 0.06911287f, -0.18545751f, -0.12247570f, 0.24123727f, -0.24034162f, -0.07146332f, 0.16540456f, 
    0.11815500f, -0.05909605f, 0.07065601f, -0.07517096f, -0.07161993f, -0.01235620f, -0.06793494f, 0.06140311f, 
    -0.00352331f, 0.01327065f, 0.00860305f, 0.06564211f, 0.04171925f, -0.05160487f, 0.12683520f, 0.01262272f, 
    0.05414671f, -0.06143097f, 0.04081925f, 0.05043837f, -0.05058368f, -0.08256589f, -0.02400510f, -0.12890247f, 
    0.02600492f, -0.07167772f, 0.00402049f, -0.04537651f, 0.06916123f, 0.02452471f, -0.12519513f, -0.16252711f, 
    -0.07049464f, -0.09870534f, -0.07971682f, -0.13572820f, -0.10755676f, 0.12150677f, 0.08923790f, 0.08405351f, 
    0.10365958f, 0.15830444f, 0.10488692f, 0.02677835f, 0.16356689f, -0.13973409f, -0.09014904f, 0.06460460f, 
    0.07041688f, -0.01838611f, 0.06974093f, 0.10705796f, 0.04306414f, 0.06494502f, 0.17041890f, 0.11560359f, 
    0.31654051f, -0.05109509f, -0.02209768f, 0.19106948f, 0.14612517f, 0.01853245f, 0.03219127f, -0.06143618f, 
    -0.12176734f, 0.04243736f, 0.06417742f, 0.14190665f, -0.02924203f, 0.14566953f, -0.14557454f, -0.01322900f, 
    0.01533182f, 0.08343738f, 0.07020033f, 0.05006329f, 0.02535107f, -0.01289941f, 0.16653414f, 0.21161415f, 
    -0.00374682f, -0.18276876f, -0.00207173f, -0.33332956f, -0.02681542f, 0.02881246f, -0.05830820f, -0.18697335f, 
    -0.08197892f, -0.01122943f, -0.02534922f, -0.12036779f, -0.07629269f, -0.08018035f, 0.08413314f, 0.09548650f, 
    0.10696375f, -0.10460821f, -0.05625264f, -0.06252237f, -0.06518025f, -0.02289668f, 0.05484202f, -0.31292862f, 
    -0.10136402f, 0.02605957f, 0.15095386f, -0.10765997f, 0.04184819f, 0.19168104f, 0.01725732f, -0.05755948f, 
    -0.14261313f, 0.13319570f, 0.06662337f, -0.17814191f, -0.08799525f, -0.16039769f, -0.05780766f, 0.33148742f, 
    0.03475621f, 0.03810259f, 0.13911398f, 0.16300978f, 0.05850950f, -0.02497834f, 0.04807310f, -0.06111296f, 
    -0.22397600f, -0.21418470f, 0.06512215f, 0.06464905f, 0.07454587f, -0.09857866f, 0.07222790f, -0.04609977f, 
    0.03572319f, 0.02140769f, -0.05117657f, -0.02875385f, 0.08739384f, 0.11092252f, 0.29915193f, -0.05954893f, 
    0.10013992f, 0.02484330f, -0.01598767f, 0.06220116f, -0.07427213f, 0.00746833f, 0.10473526f, -0.02321248f, 
    -0.05279773f, 0.17718847f, 0.08476701f, -0.06771667f, -0.05502121f, -0.06241875f, -0.04742456f, -0.02085647f, 
    0.02515042f, 0.03920262f, 0.08549803f, 0.17296001f, 0.19292510f, -0.00921122f, 0.14380397f, -0.03798831f, 
    0.02563078f, 0.12747632f, 0.04629243f, -0.03145763f, 0.00560348f, -0.02194014f, -0.10290417f, -0.06814151f, 
    -0.63946146f, 0.13557166f, -0.12463822f, 0.28831872f, 0.01483683f, 0.11713423f, 0.14218207f, -0.00067830f, 
    -0.05766754f, 0.04849587f, 0.13948849f, -0.04974851f, 0.19288704f, 0.22342736f, 0.12617867f, -0.00623973f, 
    -0.03981532f, -0.05871263f, 0.07709529f, 0.12188821f, -0.01876595f, -0.05771774f, -0.00034768f, 0.07727727f, 
    0.09670466f, 0.02496294f, -0.08470499f, -0.12505215f, 0.00502504f, -0.04844369f, -0.02986104f, 0.01310996f, 
    -0.04300064f, -0.01543220f, 0.04719404f, 0.00583794f, 0.13202657f, -0.10821009f, 0.00922639f, -0.08495416f, 
    -0.00409687f, 0.01556277f, 0.05974287f, 0.03374388f, -0.13066174f, -0.08189813f, 0.04197672f, -0.07837900f, 
    0.10095686f, -0.25978699f, 0.03494061f, 0.08958928f, 0.07366876f, 0.01720969f, -0.12646464f, -0.00955167f, 
    0.04267675f, 0.01261139f, 0.04121355f, -0.08943924f, 0.02350176f, -0.12817773f, 0.06928799f, -0.01878070f, 
    -0.04426267f, 0.13482042f, 0.03930778f, -0.04966562f, -0.08164655f, -0.02533784f, 0.16014056f, -0.15548012f, 
    -0.05362949f, 0.11680524f, 0.10460837f, -0.07369585f, -0.11653544f, -0.09931064f, 0.08801476f, 0.12272969f, 
    0.09611756f, -0.04829358f, 0.07065852f, -0.02255877f, -0.09004131f, 0.10141260f, 0.11805968f, 0.18476447f, 
    -0.04249658f, -0.01491306f, 0.10764532f, -0.03504753f, -0.08928683f, 0.04752807f, -0.16105740f, -0.01033988f, 
    0.10020572f, -0.14980987f, -0.11509413f, 0.00535740f, -0.02868796f, -0.08188358f, 0.22670856f, 0.16072325f, 
    -0.06106104f, -0.00920808f, -0.07019250f, -0.14995694f, -0.15745744f, -0.02188334f, -0.01560904f, -0.07514404f, 
    -0.03381963f, 0.07573445f, -0.03969037f, -0.05470139f, 0.09066900f, 0.12904446f, 0.10454744f, 0.07052640f, 
    0.19033460f, -0.11113670f, -0.07106058f, -0.20705909f, 0.17142528f, 0.21193340f, 0.21018119f, 0.09291738f, 
    -0.05451183f, -0.07875363f, -0.03172230f, -0.11282142f, 0.10984425f, -0.17431760f, 0.02475874f, -0.01146564f, 
    0.09733824f, -0.09529655f, 0.10567688f, -0.03022055f, 0.03822176f, -0.03748671f, -0.05661473f, -0.04541282f, 
    0.11435915f, -0.13434824f, -0.05087132f, -0.07757194f, 0.01427847f, -0.02688409f, 0.17087473f, 0.09881403f, 
    -0.09555215f, -0.02287185f, 0.00705740f, -0.16328703f, 0.08523174f, -0.05739240f, -0.02128532f, 0.12143796f, 
    0.10883333f, -0.04282873f, 0.09997257f, 0.06490046f, -0.15381601f, 0.03477164f, 0.25040036f, 0.06385473f, 
    -0.10238649f, -0.05524766f, 0.02557256f, 0.00296217f, 0.03860102f, 0.06029438f, 0.07882131f, 0.06389537f, 
    -0.13398120f, 0.01750851f, -0.01806026f, 0.10451017f, -0.18430248f, -0.04093396f, -0.11493228f, 0.01792446f, 
    -0.00954070f, 0.03919283f, 0.11392912f, 0.04496625f, -0.06651634f, -0.06494826f, 0.11436687f, -0.05423784f, 
    -0.10164221f, -0.11300847f, 0.12236666f, 0.09342727f, -0.04077160f, -0.00431876f, 0.00714092f, -0.02027402f, 
    0.02164295f, 0.00513654f, 0.12844174f, 0.00935327f, -0.41536403f, 0.05702611f, 0.28994802f, 0.23243256f, 
    0.11108640f, 0.10081723f, -0.01467007f, -0.00974672f, 0.00846398f, -0.04122621f, -0.16960417f, -0.16252132f, 
    -0.08623166f, 0.01263165f, 0.10709872f, -0.03512720f, -0.01527822f, 0.07333834f, 0.02185894f, 0.01496448f, 
    0.05929200f, 0.01271798f, 0.00610909f, -0.04111662f, -0.03927837f, -0.12181298f, 0.01699365f, -0.00833032f, 
    0.05777884f, -0.00857021f, 0.07041552f, -0.02226749f, -0.00499927f, -0.01293500f, 0.12058559f, 0.18752533f, 
    -0.07670599f, -0.10709674f, -0.09264781f, -0.13377953f, -0.07217243f, -0.06255783f, -0.04977798f, -0.00340007f, 
    0.04919537f, 0.08126754f, -0.08034489f, -0.13900635f, -0.24372873f, 0.02304440f, 0.09803103f, 0.05137340f, 
    0.11870418f, -0.11147411f, -0.00674679f, 0.11143409f, 0.05592027f, -0.00779832f, -0.02660549f, 0.16877316f, 
    0.13992617f, -0.07119415f, 0.01643252f, -0.08392441f, -0.08379925f, -0.04613235f, 0.12762041f, -0.06025034f, 
    0.09151985f, 0.04174798f, 0.04106133f, -0.08516773f, 0.11676908f, 0.09257592f, 0.30530974f, 0.26106721f, 
    0.15701710f, 0.00951676f, 0.10263079f, 0.06121945f, -0.05586791f, 0.06605478f, 0.10292146f, 0.16370973f, 
    -0.11313985f, 0.00855045f, -0.10374698f, 0.07585073f, -0.03679325f, -0.01935507f, 0.08133641f, -0.12286349f, 
    0.08464746f, 0.03555936f, 0.12015945f, 0.04314020f, 0.02794669f, -0.05560534f, -0.09903538f, -0.10567026f, 
    0.03255428f, -0.07011810f, -0.06191600f, 0.01613318f, 0.03802632f, 0.01504890f, -0.07965367f, 0.14222306f, 
    0.10182847f, -0.12130474f, 0.07791929f, -0.00271540f, 0.00072558f, -0.06451594f, 0.14653309f, 0.08765436f, 
    -0.02822259f, 0.00929304f, 0.04717453f, -0.05360148f, -0.06252745f, -0.26434216f, 0.00161461f, -0.09303525f, 
    -0.05262882f, 0.03966440f, 0.00390458f, 0.01643606f, 0.05094638f, 0.01279782f, 0.11153805f, -0.13447650f, 
    -0.01549693f, 0.09063640f, 0.06642863f, -0.11853687f, 0.00990677f, 0.04427206f, 0.02882920f, -0.04351826f, 
    -0.02645627f, -0.01822364f, -0.06517499f, 0.00323438f, -0.07480503f, -0.09125967f, 0.03970399f, -0.09724770f, 
    0.20920034f, -0.06716031f, 0.00395188f, -0.23127821f, -0.05783521f, -0.01285400f, 0.00725586f, -0.05359144f, 
    -0.18344377f, 0.01240168f, -0.02123838f, -0.04882802f, -0.00140379f, 0.00682731f, 0.02332937f, 0.05092818f, 
    0.11330511f, 0.07461939f, 0.15552287f, 0.08352241f, 0.15088917f, 0.04642071f, -0.07698029f, 0.08880707f, 
    0.11803855f, 0.05655152f, 0.12357172f, 0.03819335f, 0.01146241f, -0.01158904f, -0.03668159f, 0.03171172f, 
    -0.03895833f, -0.07746140f, 0.16792390f, 0.02629806f, 0.04889903f, -0.03034509f, 0.06220720f, -0.02977149f, 
    -0.04080651f, -0.06829422f, -0.09726851f, -0.01089555f, -0.16735563f, -0.06740451f, -0.04536304f, 0.07469971f, 
    0.16638650f, 0.00808226f, -0.04579964f, -0.11993631f, 0.06301058f, -0.11881452f, 0.01680090f, 0.05202318f, 
    0.03156714f, 0.27176619f, -0.17155045f, 0.21695864f, 0.05537400f, -0.05762030f, 0.19525389f, -0.03310858f, 
    0.14004400f, -0.05149265f, 0.09388904f, -0.08997588f, 0.14916247f, 0.00637631f, 0.00966229f, -0.10979445f, 
    0.22618006f, 0.05108540f, -0.12942299f, 0.09815945f, 0.02039786f, -0.05350830f, 0.10881016f, 0.06077602f, 
    -0.12893268f, 0.12581797f, 0.06410919f, -0.10728335f, 0.00738363f, -0.07373398f, -0.00607253f, 0.00256929f, 
    0.08315984f, 0.00755684f, -0.00274117f, 0.12031059f, 0.10510682f, -0.18677650f, -0.00807899f, 0.08851375f, 
    -0.01371772f, -0.06278425f, 0.03595068f, 0.06450368f, 0.13392687f, 0.04077132f, 0.14507493f, 0.07780430f, 
    -0.10382550f, 0.02477217f, 0.03299617f, -0.08062176f, -0.03976918f, 0.00565208f, -0.01316633f, 0.01448285f, 
    0.10787193f, 0.06907903f, 0.11709071f, -0.09074131f, -0.14327781f, -0.06252364f, -0.17015603f, -0.01241380f, 
    -0.02516461f, -0.02103243f, 0.10866086f, -0.06166833f, -0.23959441f, 0.11035924f, -0.08654033f, -0.02686320f, 
    -0.11411402f, -0.03411078f, -0.05883387f, 0.00679919f, -0.02861981f, -0.00415421f, 0.09449191f, 0.12232582f, 
    0.17911990f, 0.02687188f, 0.04380282f, -0.04453965f, -0.05475513f, 0.06826018f, -0.08398351f, 0.04812110f, 
    0.09959120f, 0.06112613f, -0.01466393f, 0.01715996f, 0.02483808f, 0.01964960f, 0.08982985f, 0.12068710f, 
    0.11097395f, -0.16907863f, 0.07145379f, 0.18799926f, 0.12080006f, 0.07808458f, 0.02739054f, 0.00340185f, 
    0.03683388f, -0.02561635f, 0.05832172f, -0.03551292f, -0.10490992f, 0.02377157f, -0.05774879f, 0.02323788f, 
    -0.03370551f, 0.08390380f, 0.11591732f, -0.09820098f, -0.13935277f, -0.12785321f, -0.06733137f, 0.01389605f, 
    0.17653950f, -0.10632695f, 0.02013737f, -0.07433189f, -0.05902077f, -0.09185290f, -0.12336917f, -0.01788800f, 
    -0.05219872f, 0.00696725f, 0.09494747f, -0.02822340f, 0.08050805f, -0.00218953f, -0.06225475f, -0.16124824f, 
    0.12334664f, -0.01844124f, -0.05469207f, 0.01571628f, -0.01047183f, 0.00924881f, 0.01525753f, 0.01121222f, 
    -0.12817840f, 0.07774463f, 0.05013516f, -0.11084627f, -0.02297274f, 0.08577476f, 0.04429516f, 0.06558251f, 
    0.08382954f, 0.13079904f, 0.12151154f, 0.07605898f, 0.00648736f, 0.01329430f, 0.07830276f, -0.04627088f, 
    0.09397925f, 0.09630467f, -0.03427345f, 0.05644482f, -0.02261041f, 0.02487882f, -0.01844561f, 0.01182330f, 
    0.23503958f, -0.19428855f, 0.12199657f, 0.04572536f, 0.05976323f, -0.02847312f, -0.09629495f, -0.12232190f, 
    0.01291882f, 0.01091094f, -0.09099142f, -0.08140817f, -0.14217784f, -0.00821290f, -0.13143815f, -0.01051732f, 
    0.07455397f, -0.10625322f, 0.08065607f, -0.04565165f, -0.03387678f, -0.03783847f, -0.00818382f, -0.02136422f, 
    -0.07855171f, -0.11338773f, -0.02404817f, -0.11242122f, -0.06046266f, -0.06476114f, -0.01623607f, -0.03030677f, 
    -0.03334171f, -0.00630336f, -0.05173542f, -0.05225518f, -0.07536615f, 0.02726977f, -0.04956390f, -0.13015589f, 
    -0.02241740f, -0.02359778f, 0.02314438f, -0.01538580f, -0.02273590f, 0.05445585f, -0.04303266f, -0.02702895f, 
    -0.03969184f, -0.05436203f, -0.12779540f, -0.14285043f, -0.03623702f, -0.01022833f, 0.03313196f, 0.04247364f, 
    -0.16865598f, -0.04556103f, -0.04461917f, -0.19408497f, 0.09796473f, -0.08956505f, 0.02184000f, -0.06745603f, 
    0.06779081f, -0.05113433f, 0.21559437f, 0.17006087f, -0.10555063f, 0.02060970f, 0.07288170f, -0.01737204f, 
    -0.31913367f, 0.03185924f, -0.04236513f, -0.19921096f, -0.08679353f, -0.01238852f, -0.04635457f, 0.10554412f, 
    0.07038631f, -0.00561897f, 0.07328466f, 0.04192892f, 0.06420294f, 0.10593559f, 0.05663414f, -0.09486150f, 
    -0.05599450f, 0.13595459f, 0.16915666f, 0.12946895f, -0.03187034f, 0.05659982f, 0.06936866f, -0.13181993f, 
    0.05752503f, -0.01679299f, 0.05394159f, 0.02056463f, 0.13412052f, 0.03519730f, 0.04702645f, -0.06111676f, 
    0.00374455f, -0.03198019f, -0.00412467f, 0.02007215f, -0.13086218f, 0.04038788f, -0.03387822f, 0.03306691f, 
    -0.03994907f, 0.00955724f, 0.03354003f, -0.00491579f, 0.09873683f, -0.03908562f, -0.04355778f, -0.00008233f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15452896f, 0.09590492f, 0.02830916f, 0.02711992f, 0.01409248f, 0.00682534f, -0.03238728f, -0.03810744f, 
    -0.04919911f, 0.01721106f, -0.02888984f, 0.06668351f, 0.20109348f, -0.00640442f, 0.03718377f, 0.14925694f, 
    -0.00036214f, 0.00010641f, 0.18336181f, 0.12758243f, 0.08584569f, -0.00473674f, -0.00757462f, 0.06693362f, 
    0.01550584f, 0.03190243f, -0.02739856f, 0.04579280f, 0.02808502f, 0.15321752f, -0.02890903f, 0.05768473f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03469925f, 0.10556197f, -0.03192579f, -0.07553729f, 0.03275947f, -0.14636573f, -0.38215899f, 0.10043431f, 
    -0.28295088f, 0.14362322f, 0.01434191f, 0.01828009f, -0.29833648f, -0.43408704f, 0.09576871f, -0.18825579f, 
    -0.11946414f, 0.30389553f, 0.22253054f, -0.07671513f, 0.34769145f, -0.00620071f, 0.04903572f, 0.18640560f, 
    0.03911771f, 0.14166141f, 0.08952568f, 0.00343778f, -0.12653916f, 0.11674901f, 0.28153303f, 0.11132415f, 
    0.07523992f, -0.21901555f, 0.10727720f, 0.01941762f, 0.01779646f, 0.04467201f, -0.01722355f, -0.04637148f, 
    -0.15339354f, 0.05335895f, 0.15661025f, 0.17160034f, -0.10803181f, -0.36791313f, -0.03809592f, -0.14539240f, 
    0.20224972f, -0.03795996f, -0.05302714f, 0.14021192f, 0.21929377f, 0.09882736f, -0.08059090f, -0.28362304f, 
    -0.12934001f, 0.11345427f, 0.14253727f, -0.03166052f, -0.00894708f, 0.26119217f, -0.04534569f, -0.04609691f, 
    -0.11086033f, 0.14553511f, 0.16887830f, -0.05329646f, 0.09453300f, -0.04838549f, 0.40654260f, -0.16635421f, 
    -0.04875522f, 0.07250721f, 0.04418954f, 0.00531447f, 0.11373999f, 0.01088787f, -0.23863861f, -0.34592363f, 
    -0.11389443f, 0.10026144f, 0.10429183f, -0.23569955f, -0.22914961f, 0.27423075f, -0.06320046f, 0.15373524f, 
    0.04672874f, -0.00897991f, -0.07614616f, 0.08613507f, 0.08516167f, 0.16138478f, 0.34460664f, 0.18184516f, 
    -0.07586011f, -0.39434677f, 0.05578532f, -0.10451479f, 0.21832806f, 0.20560084f, 0.33214113f, -0.06010538f, 
    0.01595067f, -0.36417606f, -0.03051570f, -0.05368326f, -0.04255838f, -0.02324964f, -0.08196445f, 0.14253433f, 
    0.24838747f, -0.01512527f, 0.17399113f, -0.23393799f, 0.05039823f, 0.00745377f, -0.02821152f, 0.18866783f, 
    -0.16034058f, 0.18495609f, 0.09446446f, -0.31313556f, 0.07349826f, 0.12069879f, -0.46156850f, -0.13900872f, 
    0.05980169f, 0.16399698f, 0.08915181f, 0.11436238f, -0.06714804f, 0.16775644f, -0.23293555f, -0.08187640f, 
    -0.06488659f, -0.30972919f, -0.04871877f, 0.13206805f, -0.09598890f, 0.12018860f, -0.19198228f, 0.12802288f, 
    0.09081135f, -0.28598690f, 0.12092941f, 0.28609622f, 0.17617372f, 0.07796172f, 0.02599449f, 0.03775480f, 
    -0.02064752f, 0.03617711f, 0.08639456f, -0.03522857f, -0.11269689f, 0.31869563f, -0.31438589f, -0.32838306f, 
    0.04979228f, 0.10504048f, 0.21296768f, 0.03266862f, 0.16871697f, 0.08469187f, 0.08192205f, -0.10172506f, 
    0.09472699f, 0.16603778f, -0.06535549f, -0.11726086f, -0.04705953f, 0.16964962f, -0.20125647f, -0.05727802f, 
    -0.19134545f, 0.14816526f, -0.09480777f, 0.04279260f, -0.40236926f, -0.03905423f, -0.02759252f, -0.11694503f, 
    0.02194665f, 0.14183481f, 0.10017286f, 0.36922693f, 0.01552769f, 0.13601731f, 0.23824859f, 0.30963323f, 
    -0.14809296f, -0.23500411f, 0.10873671f, -0.06826386f, 0.27935964f, 0.06298112f, 0.08966083f, 0.08680525f, 
    0.05623021f, -0.34331000f, -0.06696616f, 0.15397742f, 0.14951040f, 0.05732823f, 0.14925401f, 0.07026428f, 
    0.01940098f, -0.13683903f, -0.00427922f, -0.26488188f, -0.11069446f, -0.01264001f, -0.03539145f, 0.34281471f, 
    -0.10628123f, 0.22714095f, -0.09909546f, 0.31359667f, -0.10721961f, -0.12677997f, -0.25655264f, 0.46065265f, 
    -0.24951179f, -0.17373651f, 0.07110797f, 0.15062813f, -0.01125031f, -0.01895952f, -0.13362625f, -0.15615506f, 
    0.04433658f, -0.09707434f, -0.01950235f, -0.01419470f, 0.04785115f, 0.34776285f, 0.30488747f, 0.23803049f, 
    0.02761629f, -0.23708771f, -0.25288972f, -0.23869865f, -0.15933800f, 0.12345000f, 0.14318480f, -0.09534653f, 
    -0.15705873f, 0.02532589f, 0.14078914f, 0.02364519f, 0.09416960f, -0.23280729f, -0.07843146f, -0.03684990f, 
    0.13389352f, 0.23892410f, 0.01682653f, -0.08808203f, 0.03017971f, -0.30739528f, -0.15684143f, -0.02138164f, 
    -0.09155077f, 0.39172778f, -0.09585548f, -0.18450032f, 0.25280312f, -0.10041220f, 0.33125424f, -0.11354622f, 
    -0.23154400f, 0.28465372f, 0.38234138f, 0.14814395f, -0.03699343f, 0.00421118f, 0.10422491f, 0.09673331f, 
    0.12055614f, -0.17141123f, -0.07305458f, 0.13977572f, -0.02952330f, -0.04235457f, 0.38392502f, -0.00635991f, 
    -0.16085674f, 0.19005641f, 0.24139646f, -0.05043837f, 0.31087208f, 0.16231790f, 0.04499352f, 0.05641068f, 
    0.53163236f, 0.08087227f, -0.09632806f, 0.06454954f, -0.19347148f, 0.37264436f, 0.14805253f, 0.02220688f, 
    -0.09979445f, -0.02559729f, -0.30356193f, 0.07011727f, 0.15482619f, -0.18497682f, -0.14941673f, 0.06960383f, 
    -0.03194622f, -0.11269869f, -0.13030332f, 0.06478587f, -0.13967234f, -0.25692719f, 0.19637790f, -0.01290378f, 
    -0.04256475f, -0.25463632f, 0.21074603f, -0.12444894f, 0.29683581f, -0.19860847f, 0.13635083f, -0.09655187f, 
    0.03377816f, -0.26700857f, 0.16112246f, 0.31656551f, 0.09101922f, -0.06285161f, -0.10062536f, 0.16262700f, 
    0.42378542f, 0.26967171f, -0.02892216f, 0.11187985f, -0.04889346f, 0.14676571f, -0.04717099f, 0.15093811f, 
    0.18140416f, 0.23625635f, -0.14215663f, -0.06257509f, 0.07564143f, -0.13640779f, -0.09919923f, -0.11348864f, 
    -0.09126376f, 0.16761114f, 0.18480833f, 0.00306763f, -0.01583457f, 0.09907366f, -0.18253580f, 0.11036310f, 
    0.32797754f, -0.05206972f, -0.04879197f, 0.19564267f, 0.11279874f, 0.31905276f, 0.16647403f, -0.04596313f, 
    0.27104658f, 0.11542030f, -0.19711725f, 0.30812755f, 0.00383932f, 0.04405750f, 0.06463602f, -0.10185197f, 
    -0.07068797f, 0.06979371f, -0.04084283f, 0.07433382f, 0.10882514f, -0.28665164f, -0.11104697f, -0.08867349f, 
    0.20990257f, 0.39532000f, -0.02477423f, -0.17369270f, -0.29457822f, 0.23249823f, 0.01851098f, 0.16087160f, 
    -0.17154348f, 0.17028767f, 0.07474333f, -0.03822520f, 0.37414142f, -0.39844918f, 0.17558271f, 0.12359256f, 
    0.24344291f, -0.11228538f, 0.07659831f, 0.31863302f, 0.02932059f, 0.11824265f, 0.12735824f, -0.22417334f, 
    0.09411822f, -0.04131807f, -0.15280446f, 0.00364823f, -0.06329845f, 0.26189199f, 0.02889877f, -0.21522138f, 
    -0.00966245f, 0.27278206f, 0.08421017f, 0.13945986f, -0.21803916f, 0.16703208f, -0.09409869f, -0.00445861f, 
    0.12763467f, 0.09662057f, -0.12935835f, 0.17483839f, 0.22999193f, 0.40404966f, 0.08427054f, -0.05470468f, 
    -0.18586621f, -0.01201705f, -0.00337536f, -0.08400401f, -0.20182498f, 0.12631932f, 0.11543046f, -0.39339608f, 
    -0.04304300f, 0.05591637f, 0.01206308f, 0.19408229f, 0.03343012f, 0.02484421f, 0.17569517f, -0.08242653f, 
    0.19491920f, -0.12850480f, 0.29696560f, 0.09584609f, 0.15377839f, 0.00419065f, -0.28834960f, -0.07911897f, 
    -0.45504656f, -0.15116353f, -0.16038974f, 0.21933934f, 0.15829208f, -0.41740483f, -0.05110437f, -0.24023268f, 
    -0.20051879f, -0.01303781f, -0.06691729f, 0.09676484f, -0.17828691f, 0.28724813f, 0.09723490f, -0.06433965f, 
    0.11879987f, 0.25053662f, -0.00844175f, 0.45639786f, -0.15646383f, 0.25489032f, -0.08173286f, 0.42542320f, 
    0.14815891f, 0.14733663f, 0.02241082f, 0.10138838f, 0.12862416f, -0.26902962f, 0.20914102f, 0.15946670f, 
    -0.12043103f, 0.45038599f, 0.09507938f, 0.06884287f, 0.01239254f, -0.04913196f, -0.02130420f, 0.06123690f, 
    -0.28749788f, 0.30555087f, 0.13203838f, -0.21270159f, 0.15228587f, 0.03989559f, 0.08398017f, -0.17023326f, 
    0.06806251f, -0.18010551f, -0.11266193f, 0.07138468f, 0.05971411f, 0.04317919f, 0.12093150f, 0.26503211f, 
    -0.14749324f, 0.18735333f, 0.03110953f, -0.07013278f, -0.04493265f, -0.11476788f, 0.22830850f, -0.00046030f, 
    0.30470821f, 0.19327299f, -0.01289571f, -0.14010219f, 0.07532386f, 0.13402452f, 0.26853704f, -0.28167045f, 
    0.21866527f, 0.11566138f, -0.20236340f, -0.08158797f, 0.16763982f, 0.00173537f, 0.09216012f, -0.05055660f, 
    0.12165879f, -0.19240302f, -0.15602025f, 0.14886513f, -0.02734047f, -0.04073241f, 0.53989959f, -0.30557331f, 
    0.07287852f, -0.13381535f, -0.01481637f, 0.13796532f, 0.22869462f, 0.04243258f, -0.12326712f, -0.10617597f, 
    0.15735000f, 0.06464247f, -0.11004516f, -0.15777233f, 0.11017130f, 0.01527082f, -0.03336180f, -0.23819965f, 
    -0.00555845f, 0.29687500f, 0.11590645f, 0.11563203f, -0.08002862f, -0.22722757f, -0.00790562f, 0.42784828f, 
    0.05987753f, -0.03218807f, 0.17165132f, 0.15811323f, -0.11276963f, -0.25612950f, 0.04819839f, 0.18034574f, 
    0.13373519f, -0.08896966f, 0.15417616f, -0.03342645f, 0.09255514f, -0.34827188f, 0.06715292f, 0.12823215f, 
    -0.19674700f, 0.14160433f, 0.10478096f, 0.02769488f, 0.26505136f, -0.27012104f, -0.03013985f, 0.03442809f, 
    0.11602978f, 0.34847105f, 0.01620626f, 0.21950141f, -0.24114443f, -0.03408433f, 0.09556685f, -0.27738500f, 
    0.14514883f, -0.12994824f, -0.10488021f, 0.16383879f, 0.04364612f, -0.22000420f, -0.26056457f, 0.07579818f, 
    0.03833216f, -0.13658015f, 0.00749961f, 0.10948723f, 0.30996418f, -0.23157866f, -0.47779903f, -0.05297056f, 
    -0.11697195f, 0.12578662f, -0.10491047f, -0.04094270f, -0.05610919f, 0.01611124f, 0.09600931f, 0.01780255f, 
    -0.07323412f, 0.26207483f, 0.10604505f, -0.08962802f, 0.29940227f, -0.17155161f, -0.06743156f, -0.10645672f, 
    0.10573428f, 0.09320474f, 0.11242709f, -0.04120497f, 0.09845908f, 0.14139256f, -0.06505708f, 0.00728132f, 
    0.27433413f, 0.19109906f, 0.17403345f, 0.05601249f, 0.01963324f, 0.03921257f, -0.12964948f, 0.16795097f, 
    -0.19473408f, -0.16999957f, 0.09039673f, 0.17558800f, 0.24098103f, -0.31223091f, -0.30373022f, -0.14056326f, 
    0.14780755f, -0.15900354f, -0.20440134f, 0.21581550f, -0.08454701f, -0.06833634f, 0.12183907f, 0.34937951f, 
    -0.14687671f, 0.02415208f, 0.13001069f, 0.39871106f, 0.03182104f, 0.42412865f, -0.07658586f, 0.05979202f, 
    0.15939793f, 0.26767385f, -0.08247583f, 0.09013347f, -0.04879963f, 0.22706571f, -0.26707250f, 0.01295668f, 
    0.10195057f, 0.05508025f, -0.03817987f, 0.23581462f, -0.06633526f, 0.36691785f, 0.21660960f, 0.02024507f, 
    0.05463441f, 0.05652407f, -0.12677252f, 0.13729794f, 0.09226873f, -0.41742125f, 0.15953703f, 0.04623318f, 
    0.14433412f, 0.01619229f, 0.07120568f, 0.31007555f, 0.07053173f, -0.12211590f, -0.04596168f, 0.25361052f, 
    -0.02546394f, 0.15592340f, 0.22560202f, 0.03071327f, 0.04713712f, -0.14942442f, 0.19910578f, 0.01337825f, 
    0.19847889f, 0.45229647f, -0.12085098f, 0.29830104f, 0.16185600f, 0.02440159f, -0.06842729f, 0.13767666f, 
    0.26446232f, -0.03558500f, -0.34722421f, 0.22664201f, -0.41003841f, -0.03397503f, -0.15189445f, -0.59290141f, 
    0.15376551f, -0.18271804f, 0.13452646f, -0.06813771f, 0.08089627f, -0.12724981f, 0.27391148f, -0.19696023f, 
    0.07207831f, 0.15044221f, 0.19131054f, -0.03040403f, -0.17485574f, -0.08734845f, 0.01348799f, 0.05894426f, 
    0.06837688f, 0.30774197f, 0.03773019f, -0.15885316f, -0.21071273f, -0.12565920f, -0.12952864f, -0.18954279f, 
    -0.04640979f, 0.24965760f, 0.11071572f, -0.02610903f, 0.07486623f, -0.11726859f, -0.01810953f, -0.32420284f, 
    -0.09209889f, 0.05453556f, 0.08437841f, 0.25383186f, -0.06322181f, 0.00158650f, 0.32434422f, 0.26760194f, 
    -0.22128677f, 0.06546763f, -0.07039926f, 0.12863703f, -0.13023211f, 0.23482415f, -0.08118922f, 0.15316713f, 
    -0.11085483f, 0.12019008f, -0.05316136f, 0.17453684f, -0.15982750f, 0.27439180f, 0.23134559f, -0.08849604f, 
    0.05389737f, -0.35980871f, -0.06878097f, -0.10004497f, -0.41147095f, 0.26961109f, 0.05163142f, -0.18513811f, 
    -0.10767255f, 0.25016499f, 0.15666831f, 0.13856648f, 0.12150408f, 0.05969980f, -0.20112026f, -0.11897126f, 
    -0.18875791f, 0.05302689f, 0.13196817f, -0.11812527f, 0.12407120f, 0.08711937f, 0.20564413f, -0.03567363f, 
    0.15592593f, -0.26414081f, -0.12926756f, 0.07784697f, 0.19400342f, -0.05247398f, -0.09028713f, 0.13248466f, 
    0.06407902f, -0.17073989f, 0.06172036f, 0.26968336f, 0.15637690f, 0.07712030f, 0.08914071f, 0.28116360f, 
    -0.04833687f, 0.09909902f, -0.07355827f, -0.18796916f, -0.13223554f, 0.19957691f, -0.07764955f, -0.08111440f, 
    -0.10582575f, -0.22138968f, 0.19445172f, -0.10989624f, 0.24207257f, -0.00867446f, 0.23490286f, -0.07323497f, 
    0.11621068f, -0.04461700f, -0.10456996f, -0.14390512f, 0.11040670f, -0.13071263f, -0.29136062f, -0.25543875f, 
    0.09871200f, -0.14627159f, 0.14585318f, 0.05596546f, 0.13758174f, 0.23961790f, 0.15870601f, 0.29491276f, 
    -0.00091669f, -0.06899734f, 0.04446151f, -0.13815182f, -0.17440943f, -0.06292597f, 0.18445744f, -0.03547579f, 
    -0.12905809f, -0.12865926f, -0.03444549f, -0.10598385f, -0.04180247f, 0.08477736f, -0.01376991f, -0.10104030f, 
    0.10941783f, -0.03212320f, 0.11216473f, -0.05117073f, 0.17469698f, 0.40661871f, 0.38619116f, 0.22443782f, 
    0.22903483f, -0.00177906f, 0.10077602f, -0.09653995f, 0.14282522f, 0.11502466f, 0.04692503f, -0.05049582f, 
    -0.09841799f, 0.22355543f, 0.04141414f, -0.18637583f, -0.13162485f, -0.20449299f, -0.06977397f, -0.26472506f, 
    -0.26658487f, -0.21525773f, -0.20054850f, -0.12375592f, 0.22820671f, -0.09105476f, -0.21994251f, 0.03432986f, 
    -0.16075990f, -0.01881823f, -0.10704032f, -0.11144802f, 0.01925466f, -0.18157147f, -0.10546426f, 0.17057134f, 
    -0.10901664f, 0.21202146f, 0.06171023f, -0.05171650f, 0.17587259f, 0.09411250f, -0.07473124f, -0.09514802f, 
    -0.06380513f, -0.10070042f, -0.10357060f, -0.18082596f, -0.14395568f, -0.11745506f, 0.03534034f, -0.07680707f, 
    0.08062315f, 0.11830880f, 0.00925393f, -0.16342939f, -0.02828417f, 0.21629423f, 0.31876701f, 0.16349477f, 
    -0.08196678f, 0.18551484f, -0.15643069f, 0.11595828f, 0.14954293f, 0.27065724f, 0.14947209f, 0.21902470f, 
    -0.19516356f, 0.23879471f, 0.13477494f, -0.12523693f, -0.11488467f, -0.17297406f, 0.12380206f, 0.27744108f, 
    0.13243720f, -0.35732391f, -0.16177535f, 0.08501321f, -0.15431678f, -0.17714621f, -0.27183524f, -0.01795129f, 
    0.14962770f, 0.06790469f, -0.11917391f, 0.02499657f, 0.11481627f, 0.23205888f, 0.04704724f, -0.14473845f, 
    0.08631182f, 0.23864077f, -0.02765026f, -0.10231645f, -0.10025473f, 0.16617660f, 0.14756501f, 0.45129174f, 
    0.02330446f, -0.16959459f, 0.31014881f, -0.00518684f, 0.31076124f, -0.19935867f, -0.10506462f, -0.05517831f, 
    -0.11480705f, -0.33386528f, 0.14658244f, -0.16525896f, 0.08977383f, 0.17232852f, 0.01651898f, -0.00216094f, 
    -0.18191010f, -0.05826328f, -0.05161504f, -0.03906254f, 0.11135650f, -0.08879136f, 0.24758394f, 0.12827836f, 
    -0.14427753f, 0.24550700f, 0.13616009f, -0.01656125f, 0.07636005f, 0.00500502f, 0.09639574f, 0.03147305f, 
    0.13797438f, 0.13104124f, 0.04661834f, -0.14584236f, 0.00961922f, 0.39335978f, 0.03258078f, -0.05483561f, 
    0.03192375f, -0.09350315f, 0.05161703f, -0.29675117f, 0.13740863f, 0.13808352f, -0.11182680f, -0.10993965f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00979176f, -0.25842056f, 0.00702598f, 0.06168125f, 0.20069022f, 0.11263824f, -0.01767803f, 0.15420794f, 
    0.09259208f, 0.18333825f, -0.12518035f, 0.11469071f, 0.10453558f, 0.20614612f, 0.20331211f, 0.13856567f, 
    0.05521796f, -0.16476092f, 0.14436319f, 0.04387488f, 0.22513652f, 0.19226229f, 0.08701881f, -0.18734586f, 
    -0.09874776f, -0.00730749f, -0.06502695f, -0.10996849f, 0.45079955f, 0.21887740f, 0.22344388f, -0.19076402f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.19549462f, 0.09508657f, 0.10157782f, 0.14264151f, -0.14381962f, -0.01611667f, 0.25343809f, 0.28646925f, 
    -0.17224824f, -0.02226589f, 0.11603736f, -0.00187370f, -0.17018686f, 0.16744626f, -0.26934972f, -0.09770212f, 
    0.06077990f, -0.22976054f, -0.35142511f, -0.51654559f, -0.48530146f, -0.04366157f, 0.15970924f, -0.36511236f, 
    0.35057864f, -0.12441584f, -0.01829627f, 0.26406789f, -0.09445962f, 0.00452719f, -0.06152731f, 0.28164211f, 
    0.22123495f, 0.31437662f, -0.35244590f, 0.25472224f, 0.17145489f, -0.39370054f, -0.10322530f, -0.29910848f, 
    -0.06692664f, -0.45897299f, 0.25006664f, -0.09440455f, 0.18238504f, -0.25148007f, -0.11986972f, -0.07199029f, 
    -0.68398935f, -0.20423432f, -0.07951645f, 0.25181547f, 0.01417093f, -0.25361395f, -0.01308267f, -0.20572717f, 
    -0.20518474f, 0.19829212f, 0.11947697f, 0.08369612f, -0.08083729f, -0.05939197f, 0.11058263f, 0.20396337f, 
    -0.36348403f, -0.12538642f, -0.02199320f, -0.16510861f, -0.10212293f, 0.12763101f, -0.16086511f, 0.03242534f, 
    0.09581583f, -0.36819068f, -0.01699843f, 0.06192916f, 0.24630786f, 0.19104019f, 0.06526876f, 0.12084090f, 
    -0.08946549f, -0.02676719f, 0.32460389f, -0.58819842f, 0.04292537f, -0.18408658f, 0.21887431f, -0.09738689f, 
    0.12867120f, -0.06997628f, -0.23784541f, -0.32463095f, 0.10415797f, 0.30152497f, -0.17512515f, 0.25595269f, 
    -0.20645072f, 0.26795554f, 0.22385330f, -0.05619000f, -0.18386605f, 0.05397464f, -0.13243611f, -0.50612342f, 
    -0.12743807f, 0.07638228f, 0.02725345f, 0.04137949f, 0.05700048f, 0.01086496f, -0.15092397f, -0.01380982f, 
    0.29007757f, 0.00222074f, -0.16521944f, -0.39130709f, -0.13773935f, -0.20860918f, 0.19614458f, 0.21721748f, 
    -0.32778853f, 0.15179968f, 0.29107019f, -0.15856276f, -0.62286270f, -0.27435350f, -0.23301375f, 0.11813703f, 
    0.06291592f, -0.14569899f, -0.05774556f, -0.08380617f, 0.15438020f, 0.14385167f, -0.17290081f, -0.14144310f, 
    -0.62015736f, 0.17027947f, -0.05334155f, -0.01527697f, 0.03140395f, 0.22798091f, -0.28871197f, -0.00875907f, 
    0.04247281f, -0.17568584f, -0.25825825f, 0.28012016f, -0.05164612f, 0.25026023f, 0.23592776f, -0.02071470f, 
    -0.04360506f, -0.00485802f, -0.13970323f, -0.07683893f, 0.36484402f, 0.07547020f, 0.19665807f, 0.00057492f, 
    -0.29335085f, -0.32443929f, -0.19485357f, 0.13297586f, -0.06473779f, 0.02276699f, 0.32252607f, -0.04003900f, 
    -0.32635909f, 0.06163291f, 0.14126700f, 0.04300133f, -0.12161934f, -0.18486653f, -0.08409001f, -0.02072104f, 
    -0.29216537f, 0.21222354f, -0.10652436f, 0.04720283f, 0.05287306f, 0.24038878f, -0.19532807f, -0.32375106f, 
    -0.42109859f, 0.23321478f, 0.05160038f, -0.00825883f, -0.16096652f, 0.28315231f, 0.06720291f, -0.24206391f, 
    0.12246785f, -0.08890676f, -0.14897971f, -0.19051965f, -0.03919713f, 0.11500157f, -0.13727894f, 0.05893975f, 
    0.16368942f, -0.58874249f, -0.66697091f, -0.39810047f, 0.21883821f, 0.06724003f, 0.08218382f, 0.24544068f, 
    -0.16320750f, -0.09753605f, -0.11701141f, -0.08134135f, -0.00310448f, 0.04314295f, -0.29125857f, 0.29257971f, 
    -0.24415176f, -0.33280647f, -0.53981769f, -0.51680177f, 0.04316830f, 0.16373996f, 0.22910233f, -0.02011144f, 
    0.10796803f, -0.40747792f, -0.01472464f, 0.09604454f, -0.33165792f, 0.04125819f, -0.15869462f, -0.26757595f, 
    0.16584201f, 0.16421133f, 0.01219266f, -0.28228480f, -0.54314858f, -0.56485283f, -0.45082679f, 0.16321500f, 
    0.33277926f, 0.25980714f, -0.09408833f, -0.07351220f, -0.21182859f, -0.15144056f, -0.47917712f, 0.14268893f, 
    -0.11241935f, -0.17755410f, 0.21686196f, -0.06367207f, 0.02360977f, 0.17049311f, 0.06283017f, 0.19404392f, 
    -0.13267419f, -0.09309326f, 0.27465841f, 0.17223583f, -0.03453875f, 0.23547319f, 0.21424921f, -0.37082377f, 
    0.05634755f, -0.28686032f, 0.03492600f, -0.58475965f, -0.49851704f, 0.04853745f, 0.17281690f, 0.12067927f, 
    -0.23004633f, -0.00105277f, 0.00298362f, -0.18150516f, 0.01024797f, -0.61453187f, -0.51348108f, 0.07750948f, 
    -0.10814286f, 0.04023258f, 0.36059391f, -0.57660252f, -0.26657093f, -0.05862948f, -0.18931225f, 0.05025538f, 
    -0.17647493f, -0.27106389f, -0.50980753f, -0.21722218f, 0.01034265f, -0.16804636f, -0.29765925f, -0.67381936f, 
    0.24417235f, -0.00875454f, -0.30063489f, 0.13466674f, 0.24197346f, 0.09045532f, -0.41468492f, 0.14602874f, 
    0.20467716f, -0.00064937f, -0.00929920f, -0.03015411f, -0.40288863f, 0.04909796f, -0.13684806f, 0.01004400f, 
    -0.49706587f, 0.00326194f, -0.29839063f, 0.17731065f, -0.59374088f, 0.08907634f, 0.28152525f, -0.04756740f, 
    -0.06168079f, 0.22563204f, -0.00740078f, -0.16361082f, 0.25438678f, 0.02211749f, 0.13453554f, -0.77332634f, 
    0.02625200f, -0.42750242f, -0.04843257f, 0.02271556f, 0.21715797f, 0.06698107f, 0.17583957f, -0.37560999f, 
    -0.09888060f, 0.04535839f, -0.23110327f, -0.59579140f, 0.28925121f, 0.10207289f, -0.41717696f, -0.17528091f, 
    0.40007100f, -0.02570121f, -0.08382006f, -0.16428950f, -0.28035548f, -0.38024160f, -0.47695947f, -0.30417877f, 
    0.19607458f, 0.31900856f, -0.35570836f, -0.49753207f, -0.09751876f, 0.19063762f, 0.03769533f, -0.66582322f, 
    0.03898321f, 0.04070456f, 0.21580234f, 0.16258572f, -0.33411500f, -0.14895308f, 0.15404508f, 0.04375241f, 
    -0.22637546f, -0.04754791f, 0.17448874f, 0.05722524f, -0.01618435f, 0.18924785f, -0.01892835f, 0.27652669f, 
    -0.55881619f, -0.22980295f, -0.36126590f, -0.07032118f, -0.52597761f, -0.36444634f, -0.25238317f, -0.34745154f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.27945986f, -0.08140367f, 0.12675218f, -0.26330325f, 0.19087674f, 0.13225593f, -0.07827832f, -0.05064308f, 
    0.06783141f, 0.04225875f, -0.08337973f, -0.20307596f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
