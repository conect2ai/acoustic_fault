#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.58166748f, -0.50933188f, 0.28216124f, -0.10697655f, 0.09516567f, -0.28954941f, 0.15984777f, 0.21320036f, 
    0.39978263f, 0.07918898f, -0.16512142f, 0.16670388f, 0.16776285f, -0.37794065f, 0.18286628f, -0.03105243f, 
    0.27411589f, 0.15873703f, -0.42133498f, -0.07467900f, 0.27360746f, -0.19827402f, 0.18144394f, -0.32941383f, 
    -0.38944921f, -0.99802142f, 0.08892165f, -0.30550894f, 0.29111421f, 0.14309339f, 0.22572382f, 0.98346925f, 
    -0.84768319f, -0.43951207f, 0.24402268f, 0.34620482f, 0.30060464f, -0.20733626f, -0.19750953f, -0.51286572f, 
    -0.14481659f, -0.14805971f, -0.08716153f, 0.15763247f, 0.53686970f, -0.10749604f, -0.17600761f, -0.02459084f, 
    -0.14344402f, -0.25650498f, -0.89292657f, -0.91817385f, -0.31417876f, 0.72299659f, 0.96796471f, -0.58420819f, 
    -0.46830466f, 0.04028857f, 0.19569337f, -0.23160444f, 0.16557427f, 0.10947137f, -0.11625572f, 0.58617026f, 
    -0.43918172f, 0.31625652f, -0.02678457f, -0.09494331f, 0.03169004f, -0.06584021f, -0.19870996f, -0.08603198f, 
    -0.08323175f, -0.06235130f, 0.19941908f, -0.00793089f, -0.42431757f, -0.30022898f, 0.09883101f, -0.10418745f, 
    -0.65875906f, -0.44114235f, -0.75719088f, -0.63909519f, -0.63130826f, 0.01760517f, 0.38043165f, -0.08072125f, 
    0.01616785f, -0.18867756f, -0.31858128f, 0.41547447f, -0.14231706f, -0.34817719f, -0.40354013f, -0.45854554f, 
    0.15055002f, 0.04748349f, -0.12107190f, 0.30939257f, 0.47479144f, 0.18026875f, -0.29286107f, 0.67983216f, 
    -0.25565213f, 0.04430727f, -0.67745990f, -0.44181088f, -0.25030926f, -0.25675473f, 0.51365018f, -0.35924333f, 
    -0.05555680f, 0.24091496f, -0.18485112f, 0.10451552f, 0.31149492f, 0.33607137f, -0.10481558f, -0.57016253f, 
    -0.14308424f, 0.23932683f, 0.26818994f, 0.16190322f, 0.52644497f, 0.49407610f, 0.10100494f, -0.74511570f, 
    -0.46414340f, -0.29697567f, -0.17679381f, -0.31335726f, -0.28527260f, -0.12099759f, -0.11491543f, 0.36756393f, 
    0.43558937f, 0.65195167f, 0.15607078f, 0.30129522f, 0.19144823f, -0.15114528f, -0.01224101f, -0.47911298f, 
    0.07206479f, 0.11265285f, 0.19306701f, -0.10405227f, -0.10949665f, 0.08159167f, 0.52239466f, 0.56126624f, 
    0.43605456f, -0.44036102f, -0.21126103f, -0.70501661f, -0.34523076f, 0.45557588f, -0.38836443f, -0.45484558f, 
    -0.20161793f, -0.08513299f, -0.08938750f, -0.15902384f, -0.08075276f, 0.03392655f, -0.11500517f, -0.17139760f, 
    0.09309762f, -0.31356353f, -0.40177003f, -0.15385592f, -0.45153010f, -0.25397307f, -0.65970331f, -0.11731362f, 
    0.06618225f, -0.15503475f, 0.38133726f, 0.27022350f, 0.37945339f, 0.09183863f, 0.10285458f, 0.35406670f, 
    0.31071144f, -0.22076695f, 0.14387602f, 0.38901538f, 0.00872253f, -0.27363566f, -0.43896115f, -0.16108431f, 
    0.13671990f, -0.03208896f, -0.08384681f, 0.29900867f, -0.03632325f, -0.26556742f, 0.07597089f, 0.29319334f, 
    -0.69272643f, 0.15606225f, 0.38910604f, 0.71708959f, -0.03221470f, 0.47824064f, 0.09366962f, -0.13292293f, 
    0.23904876f, -0.13857397f, -0.32655871f, -0.05620834f, -0.07920806f, -0.07323354f, -0.21296014f, 0.03161504f, 
    -0.04648772f, -0.02604620f, -0.22673585f, -0.17402333f, -0.26246759f, -0.19924591f, 0.40250301f, 0.08745940f, 
    -0.36202404f, 0.37521955f, -0.72783703f, -0.98957807f, -0.54503107f, -0.40911916f, 0.65738833f, 0.41318703f, 
    0.17051481f, 0.40977323f, -0.28569099f, 0.10180219f, -0.28134951f, -0.59569734f, 0.02889664f, -0.10825253f, 
    -0.21640851f, -0.06945826f, 0.24593189f, 0.31695536f, -0.41524464f, 0.01873716f, -0.07692185f, 0.08415064f, 
    -0.46653086f, -0.41013187f, -0.90331990f, -0.38903502f, 0.27808103f, 0.36773458f, 0.24493587f, 0.58439404f, 
    0.46693817f, 0.26512685f, -0.23344895f, -0.02309434f, 0.25321376f, 0.09565957f, -0.03764849f, 0.24809553f, 
    -0.23609315f, -0.46253556f, 0.31675929f, -0.34271961f, -0.17791538f, 0.36258772f, 0.08581784f, 0.03967017f, 
    0.15546729f, 0.25174111f, -0.25098586f, -0.65551955f, 0.11015370f, 0.45867431f, 0.56455410f, 0.02803444f, 
    -0.17191643f, -0.04995124f, -0.15269455f, 0.23169316f, -0.00902018f, 0.01415861f, -0.29486734f, -0.29257870f, 
    0.75507969f, -0.30200374f, -0.32417592f, -0.36656916f, 0.11239562f, 0.01331367f, 0.05351744f, 0.02051396f, 
    0.05084620f, 0.10611132f, -0.00833637f, 0.31597626f, -0.71130681f, -0.02822945f, -0.26021090f, -0.83684981f, 
    -0.29270530f, -0.07832466f, -0.36030576f, -0.32643175f, -0.18011376f, -0.17375360f, -0.45995134f, -0.51914215f, 
    -0.12191881f, -0.37677792f, 0.10928652f, 0.10035039f, -0.05857890f, -0.23221128f, -0.07812349f, -0.05973724f, 
    -0.04275221f, 0.22355194f, 0.02742611f, -0.12897906f, 0.31202182f, 0.54755378f, -0.19737910f, -0.83270311f, 
    -0.73474121f, -1.01065814f, 0.81365079f, 0.47794539f, 0.22463942f, -0.21460369f, 0.29376939f, -0.01586833f, 
    0.75138551f, -0.47307041f, -0.12632217f, -0.11022289f, -0.38808596f, -0.04812749f, 0.12307891f, -0.35504287f, 
    -0.09136826f, 0.11612909f, -0.26241258f, 0.04132582f, 0.37685859f, 0.51707828f, 0.51377243f, 0.71541822f, 
    0.59678000f, 0.38480219f, -0.33217749f, -0.06467178f, -0.38385886f, 0.12818713f, -0.38891694f, -0.13539149f, 
    -0.14079300f, 0.12552011f, 0.60136861f, -0.35053444f, -0.26707563f, -0.11748429f, 0.23824625f, -0.23227702f, 
    -0.12836869f, 0.31264460f, -0.17425369f, -0.00274564f, -0.11674054f, -0.19629978f, 0.20822160f, -0.97286797f, 
    -0.71137309f, -1.06432319f, -0.17624919f, -0.00009336f, 0.37971908f, 0.24254096f, 0.12906602f, 0.10786060f, 
    1.07680559f, 0.21180379f, 0.10987444f, -0.03828334f, -0.06756537f, 0.04000165f, 0.15035960f, 0.22106524f, 
    0.00581180f, 0.01838772f, 0.15604192f, -0.12009194f, -0.17322382f, 0.17975444f, -0.01873890f, -0.11763872f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49973345f, 0.08379756f, 0.19421041f, 0.03301042f, 0.30786365f, 0.06594401f, 0.01543524f, 0.11093894f, 
    0.07729955f, 0.24811122f, 0.43655881f, 0.17289458f, -0.10131519f, 0.30570030f, 0.56264561f, 0.11258241f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05971496f, 0.04474120f, -0.06362873f, 0.07779908f, -0.05748900f, 0.08714809f, 0.05357857f, 0.13084471f, 
    0.02937101f, 0.25660166f, -0.10155828f, 0.07979794f, -0.31151626f, 0.12327981f, -0.24003474f, 0.14798848f, 
    0.05103324f, 0.00493238f, 0.24047476f, -0.18095157f, 0.03173321f, 0.11133420f, 0.10538171f, 0.05226730f, 
    0.13188462f, 0.19283220f, -0.18710215f, -0.08908124f, 0.09709411f, 0.00939732f, 0.04776318f, 0.09291257f, 
    0.21319276f, 0.00881579f, 0.25465888f, -0.03970141f, 0.04145109f, -0.22946447f, -0.40530798f, -0.03240894f, 
    -0.07885305f, 0.06795199f, -0.02994043f, -0.14268915f, -0.00795070f, 0.08345934f, 0.03596033f, 0.04659748f, 
    -0.15275802f, -0.01336178f, -0.09065795f, 0.13428962f, 0.05077736f, -0.14854929f, 0.10552114f, -0.11877429f, 
    0.07816797f, 0.16641074f, 0.02352585f, 0.09337307f, -0.16379650f, -0.04540765f, -0.12915038f, 0.13214402f, 
    -0.16141321f, -0.05778648f, -0.08015450f, -0.00590205f, -0.12962787f, -0.05338630f, -0.11486469f, -0.11100676f, 
    0.25107631f, -0.29888859f, 0.38314992f, -0.25832754f, -0.02775539f, 0.10182969f, -0.12985989f, 0.10322455f, 
    -0.00372312f, 0.10147468f, -0.01455183f, 0.07345824f, -0.16979159f, -0.00506326f, -0.01992104f, 0.00525174f, 
    -0.05863534f, 0.00169285f, 0.00212362f, 0.10324448f, 0.05391576f, 0.12285047f, 0.04000307f, 0.12105509f, 
    -0.05683909f, 0.37103027f, 0.03007362f, -0.15620019f, -0.02264909f, -0.00797286f, -0.11480298f, -0.13020609f, 
    -0.06368576f, 0.10746805f, -0.17613003f, 0.05381573f, 0.10400273f, 0.19553351f, -0.11638729f, 0.23104751f, 
    0.08684770f, 0.23540276f, 0.17157337f, -0.09537929f, 0.01109850f, 0.11175948f, 0.19264388f, -0.01035654f, 
    -0.32008326f, 0.06496163f, -0.03509053f, -0.11197859f, -0.01778570f, 0.05961470f, 0.06653067f, -0.04262278f, 
    0.14667207f, 0.07902398f, 0.13466401f, 0.16740739f, 0.24349348f, 0.28308296f, -0.07502411f, -0.01682421f, 
    0.04936382f, -0.12738273f, -0.07953440f, -0.08187695f, -0.02043204f, 0.04550467f, 0.20368008f, -0.02208234f, 
    0.13765632f, -0.27135247f, -0.22155625f, -0.19220199f, 0.06235418f, -0.06367843f, -0.10240313f, -0.11570787f, 
    0.01529010f, 0.05741116f, -0.07824555f, 0.01019941f, -0.45495293f, 0.12529737f, -0.13307975f, 0.63293636f, 
    0.06316251f, -0.07925302f, 0.01751499f, 0.10375984f, -0.01238606f, 0.08082765f, -0.00183205f, 0.17240635f, 
    0.10641288f, 0.09926376f, 0.43689528f, -0.01286329f, -0.17064199f, -0.06965493f, -0.06213482f, -0.09580742f, 
    -0.10017688f, 0.07012877f, -0.07034822f, 0.11826231f, -0.39397639f, 0.07467780f, -0.31838906f, -0.15327980f, 
    0.16753843f, 0.08630893f, 0.14934772f, 0.00479751f, -0.04859624f, -0.01979222f, -0.02024400f, -0.09313620f, 
    -0.02103076f, -0.00241226f, -0.03548580f, -0.00752970f, 0.00840911f, -0.06604329f, -0.02589202f, -0.06476681f, 
    0.03999249f, 0.00613127f, 0.04057240f, 0.06498972f, 0.04463840f, -0.01859592f, -0.01867439f, 0.04950919f, 
    -0.00689660f, -0.06736731f, 0.02898242f, 0.05699231f, -0.06987720f, 0.00342967f, -0.04021762f, -0.03620791f, 
    0.04591237f, 0.01383180f, 0.06127493f, -0.05880489f, -0.03718838f, -0.04487930f, -0.03791508f, 0.06284849f, 
    0.05688244f, -0.02425125f, 0.00229090f, 0.03808898f, -0.02417268f, 0.00484300f, -0.00809449f, 0.00906138f, 
    0.05981344f, 0.06188030f, -0.06100121f, -0.00547488f, -0.03081671f, 0.06596222f, -0.02625664f, -0.05137053f, 
    -0.06520852f, -0.02273570f, -0.07057321f, -0.04977062f, -0.05651394f, 0.00818678f, 0.05749777f, -0.02238902f, 
    -0.03197599f, -0.00472743f, 0.04368063f, -0.05056214f, -0.05829387f, -0.00275250f, 0.04427595f, 0.03913481f, 
    0.05320303f, -0.02731780f, -0.06385305f, -0.05670587f, 0.02976697f, 0.00979531f, -0.01287351f, -0.05927905f, 
    -0.04315532f, -0.00522716f, -0.03982912f, -0.06755365f, 0.03118186f, 0.05774252f, -0.06366652f, -0.03622071f, 
    0.05569549f, 0.02776006f, -0.07478918f, -0.04524332f, 0.06593856f, -0.05454703f, -0.01519686f, -0.03059400f, 
    0.00064790f, 0.06544004f, -0.00991043f, 0.01987266f, -0.00466779f, 0.01299885f, -0.06315505f, 0.05914723f, 
    0.06202337f, -0.02986899f, -0.02831464f, 0.02665519f, -0.07321308f, -0.02859757f, 0.05066944f, -0.05074269f, 
    0.01811405f, 0.05034069f, -0.04954300f, 0.01510860f, 0.01337970f, 0.00335259f, 0.01842188f, -0.02552147f, 
    -0.00977328f, -0.02890394f, -0.01057600f, -0.03183707f, 0.00940013f, -0.07182384f, -0.01754158f, 0.01199378f, 
    0.03121576f, 0.00398074f, -0.06093392f, -0.04814675f, -0.01147855f, 0.03943967f, -0.06042038f, -0.05741493f, 
    -0.02260869f, -0.06049658f, -0.05086250f, -0.07197714f, -0.00361242f, -0.04750924f, 0.05601762f, 0.05256772f, 
    -0.05921983f, -0.06960671f, -0.05938576f, -0.04633473f, -0.03603083f, -0.02426914f, 0.07115593f, -0.05041887f, 
    -0.05717267f, -0.00856744f, -0.03950810f, -0.04366057f, -0.02984340f, 0.03595543f, 0.01214877f, -0.01376710f, 
    0.03135015f, -0.00180185f, 0.01774909f, -0.03385238f, -0.06744893f, -0.02859537f, -0.03961184f, -0.06968934f, 
    0.04381692f, -0.02255823f, 0.06221223f, -0.04089394f, -0.07512401f, -0.07293677f, 0.04794715f, 0.00761052f, 
    -0.01782690f, -0.00743996f, -0.00976184f, 0.04521701f, -0.06136136f, 0.01765625f, -0.00115155f, -0.05802539f, 
    0.05567819f, 0.05293653f, 0.05391626f, 0.00765763f, -0.03603664f, -0.04927862f, 0.03785669f, 0.02690429f, 
    0.00869695f, -0.01091986f, -0.06635194f, 0.05607319f, -0.02908186f, -0.03455660f, -0.07516626f, 0.01550396f, 
    0.14564139f, -0.16787879f, 0.01410899f, 0.15394486f, 0.06987116f, -0.07421348f, -0.07923951f, -0.05232484f, 
    -0.04874812f, -0.05710296f, 0.11032936f, 0.00909595f, 0.33101928f, 0.22979872f, -0.15154044f, -0.18877082f, 
    0.06980618f, -0.16250737f, 0.20172101f, 0.24449894f, 0.02139926f, 0.17400856f, 0.07158729f, 0.07642888f, 
    0.59369183f, -0.12385590f, 0.26741424f, -0.32553205f, -0.14592505f, 0.03758063f, 0.35125670f, -0.17782526f, 
    0.01275924f, -0.07277988f, -0.01407830f, 0.13605639f, 0.32187265f, 0.28939173f, 0.31915784f, -0.22643356f, 
    0.18676320f, 0.10725696f, 0.04543408f, -0.13447817f, 0.00866022f, -0.11188922f, 0.05332137f, 0.10263459f, 
    0.08577623f, 0.26527694f, 0.09737237f, -0.18054405f, 0.01897845f, 0.01430368f, -0.10959669f, -0.12610975f, 
    0.05961212f, -0.05088606f, 0.08552100f, 0.01653017f, 0.23228033f, -0.11716085f, -0.21985213f, -0.11976091f, 
    0.05936773f, 0.07409804f, 0.11972097f, 0.03795764f, 0.06891082f, -0.00299433f, -0.04883949f, 0.02864172f, 
    -0.06210320f, 0.03595082f, -0.11445475f, 0.30094916f, 0.06672124f, -0.08287112f, -0.10072205f, -0.12717317f, 
    0.02040609f, 0.01344952f, -0.00843668f, -0.15730947f, 0.08623803f, 0.13947506f, -0.01471347f, 0.10627793f, 
    -0.08747301f, 0.09348719f, -0.00772120f, -0.01382899f, -0.06154774f, -0.11375867f, 0.08555149f, -0.05659110f, 
    0.29483703f, -0.31383231f, 0.00327597f, -0.01866269f, 0.07961209f, -0.00510337f, 0.01571401f, 0.03338085f, 
    0.09118948f, 0.13369620f, 0.12378551f, 0.00786940f, 0.03968327f, 0.01479290f, -0.15778017f, -0.34905663f, 
    -0.13313514f, 0.04290028f, 0.11598429f, 0.07126909f, 0.04123655f, -0.16647138f, -0.01737904f, -0.07786591f, 
    0.25841185f, -0.16759710f, -0.02666304f, 0.13114151f, 0.04422190f, -0.02539369f, 0.17675632f, 0.02987855f, 
    0.04863472f, 0.04232413f, -0.08652725f, -0.02710267f, -0.04290812f, -0.04997814f, 0.25727534f, 0.10876258f, 
    -0.03999212f, 0.01274146f, 0.06536634f, 0.10456282f, -0.00472730f, -0.03062446f, -0.01571406f, 0.10175000f, 
    -0.00269823f, 0.31989086f, 0.08747309f, -0.05206802f, 0.14433770f, 0.06719572f, -0.02890361f, 0.12705296f, 
    -0.11913937f, -0.05352183f, -0.06054207f, -0.00221845f, -0.03377301f, -0.22462805f, -0.49072132f, -0.17705505f, 
    -0.01704650f, 0.17494425f, 0.07480159f, -0.17079040f, 0.26947132f, -0.07920154f, -0.12515658f, -0.18916605f, 
    0.08564842f, 0.01618208f, -0.17347050f, 0.22584014f, -0.01436775f, -0.04150708f, 0.05754301f, 0.04867364f, 
    0.03313547f, 0.05638343f, 0.12089285f, 0.06060342f, -0.00518517f, 0.02441649f, -0.06186984f, 0.02131791f, 
    0.01011258f, 0.12995446f, 0.16173731f, -0.00190171f, -0.02217529f, -0.05710039f, -0.01052172f, 0.03684021f, 
    -0.09960463f, -0.12255774f, -0.02820447f, -0.04277900f, 0.03950572f, -0.08517656f, -0.08634849f, 0.01221627f, 
    0.11121992f, -0.14652853f, 0.12378456f, 0.13601112f, 0.11873703f, 0.08123210f, 0.10175139f, 0.13197531f, 
    0.00927515f, -0.13623829f, 0.13733633f, 0.24075314f, -0.03304769f, 0.12136146f, 0.05096347f, 0.07720557f, 
    0.29445493f, 0.32140127f, 0.38997552f, -0.00138187f, -0.11209578f, 0.14406896f, -0.15467867f, -0.00743249f, 
    0.08077680f, -0.05973807f, -0.04519632f, 0.00906324f, 0.18504462f, 0.28283307f, 0.28117776f, 0.08348504f, 
    -0.00697478f, 0.10865992f, 0.09580174f, -0.02440540f, 0.01934617f, -0.13554716f, 0.07406922f, -0.04184946f, 
    0.02755520f, 0.12294222f, -0.05585758f, 0.05243179f, 0.12244847f, 0.15564534f, 0.09303045f, 0.13253638f, 
    0.06533175f, 0.02415503f, 0.13163871f, 0.06200301f, 0.09857137f, -0.08154339f, 0.03425881f, 0.01207925f, 
    -0.01837054f, 0.05040572f, 0.09883613f, -0.00002914f, 0.01592792f, -0.05826135f, -0.09484496f, -0.02907255f, 
    0.02162701f, 0.05198822f, -0.02430579f, 0.12068531f, 0.01718372f, -0.11477470f, -0.05640408f, -0.09305722f, 
    -0.08704419f, -0.12346684f, -0.10854415f, -0.12379566f, -0.18800171f, -0.28301200f, -0.27366182f, -0.04302996f, 
    -0.06597447f, 0.00735496f, 0.03266566f, 0.04223174f, 0.07129936f, -0.18405440f, 0.29384816f, -0.20671938f, 
    -0.23065087f, -0.46253294f, -0.22422916f, 0.01388894f, -0.01726328f, -0.05071382f, -0.07475216f, -0.10894839f, 
    0.02230491f, -0.12305824f, 0.02257606f, -0.01016062f, 0.02716626f, 0.12456664f, 0.08219276f, -0.04052351f, 
    -0.09424965f, -0.03443101f, 0.12434510f, 0.16864789f, 0.04004303f, 0.01373021f, -0.04450508f, -0.07585026f, 
    0.05037623f, -0.22913323f, -0.11889413f, 0.17011437f, 0.02355923f, -0.09344066f, 0.01401386f, 0.00782464f, 
    0.16396022f, 0.18339895f, 0.04213853f, -0.00149591f, -0.21697485f, 0.07475864f, 0.11869329f, -0.02692033f, 
    -0.06586566f, 0.00636470f, 0.10818675f, 0.09583253f, 0.01385370f, 0.08162954f, -0.15306839f, 0.09388287f, 
    -0.16810882f, 0.17875233f, 0.13728563f, 0.03205914f, -0.06360073f, 0.09804994f, 0.03009084f, 0.09179834f, 
    0.00540939f, -0.06001604f, -0.05766199f, 0.03493977f, 0.18310626f, 0.23113506f, 0.17581324f, -0.17875433f, 
    0.01180555f, 0.13200364f, -0.07526304f, -0.07047506f, 0.15301491f, -0.17136165f, 0.01780985f, -0.09161475f, 
    -0.16386187f, -0.29833746f, -0.14755058f, -0.02511535f, -0.01807522f, 0.01556191f, 0.12106933f, 0.13352580f, 
    0.00480724f, -0.12403458f, 0.06344105f, -0.05536790f, -0.03362280f, 0.16311975f, 0.07948053f, 0.14031312f, 
    -0.01006510f, -0.01583565f, 0.11656197f, 0.20248924f, -0.04556175f, 0.10210150f, 0.02589254f, 0.02919772f, 
    -0.01193633f, -0.08112160f, 0.08582345f, 0.15007393f, -0.07652541f, -0.09507222f, -0.03869765f, 0.06539521f, 
    -0.07553126f, 0.01942422f, 0.10746421f, -0.16891840f, -0.01010449f, 0.35173160f, 0.06562532f, -0.13245271f, 
    0.04390567f, -0.01139664f, 0.13988307f, 0.19267102f, 0.10718215f, -0.00305038f, -0.05209269f, -0.01708432f, 
    0.18093574f, 0.55950034f, -0.03328643f, -0.11769295f, 0.01806066f, 0.09593388f, 0.50120562f, 0.01893886f, 
    0.15311287f, -0.09419110f, 0.07790465f, 0.12716803f, 0.08639745f, 0.09457091f, -0.04958619f, -0.10236607f, 
    0.09804818f, 0.06219820f, 0.07626737f, 0.04394273f, 0.08140393f, 0.09234049f, -0.06774353f, 0.21073186f, 
    -0.11853658f, -0.02899799f, -0.20982990f, -0.16595276f, -0.07002936f, 0.09198863f, -0.10363490f, -0.28869814f, 
    0.08911014f, 0.15983374f, 0.16248396f, 0.18895796f, 0.12725380f, -0.06296855f, -0.25773638f, -0.01475653f, 
    0.03709501f, 0.00764573f, 0.11784188f, 0.06630434f, -0.20838007f, -0.08655773f, -0.05427028f, -0.01701838f, 
    -0.17025815f, -0.27657238f, 0.04786566f, 0.22571544f, -0.02159381f, -0.01458704f, -0.03236914f, 0.08488353f, 
    -0.12904559f, 0.00401682f, -0.17202726f, -0.25842249f, -0.09405266f, 0.03193664f, 0.01687515f, -0.11942231f, 
    -0.15138429f, -0.05798418f, 0.03328574f, -0.09722999f, 0.00086134f, 0.07079593f, 0.18648309f, 0.12202998f, 
    0.27077600f, 0.37981179f, 0.11765598f, 0.02739444f, -0.17011213f, -0.10942297f, 0.00549592f, 0.06087824f, 
    -0.05374582f, -0.00184836f, -0.04249188f, 0.16525400f, 0.30378342f, 0.09415369f, -0.33088768f, -0.07674052f, 
    -0.05172471f, 0.05073283f, 0.21061043f, 0.07531577f, 0.05318952f, -0.09724763f, -0.03239185f, -0.14258517f, 
    -0.12751155f, -0.14851424f, -0.04804702f, -0.02204134f, -0.11324216f, -0.04154995f, 0.00939803f, 0.07377469f, 
    0.21213371f, 0.16622221f, 0.05286768f, 0.02098787f, 0.02835179f, 0.35066006f, 0.07918773f, -0.02099666f, 
    -0.10690618f, -0.04791923f, 0.02840058f, -0.09350155f, 0.03788347f, 0.11607862f, 0.10321248f, 0.07189918f, 
    0.23268202f, 0.09013578f, 0.00082649f, -0.10493235f, 0.23429173f, 0.10359300f, -0.04714772f, 0.14389567f, 
    -0.06601639f, 0.05809397f, -0.07720603f, 0.01619313f, -0.11196171f, -0.20800368f, -0.15058327f, 0.24613938f, 
    0.05871631f, 0.23264602f, 0.03018361f, -0.01315857f, 0.38941562f, 0.22794145f, 0.08835909f, -0.00444713f, 
    -0.18640250f, -0.22302547f, -0.25954047f, 0.33840743f, -0.10474017f, -0.06691195f, -0.01924185f, -0.00948899f, 
    -0.10452025f, -0.05471323f, 0.00025795f, 0.15651254f, -0.25236300f, -0.12666398f, -0.13897254f, -0.13810647f, 
    0.18470351f, 0.10151283f, 0.23283800f, 0.17731903f, 0.00873427f, 0.05411613f, 0.00518935f, -0.05882952f, 
    -0.06445468f, 0.09433088f, -0.05321851f, -0.12010244f, 0.00847263f, 0.00913319f, -0.04940988f, 0.05915903f, 
    -0.17217168f, -0.09789523f, -0.03411010f, 0.08360348f, 0.38216487f, 0.07386708f, -0.13994612f, -0.00827644f, 
    0.07583101f, -0.08212979f, 0.20630185f, 0.15059301f, -0.20843929f, -0.02910581f, -0.16601139f, -0.23735942f, 
    0.45508131f, 0.21278720f, -0.12166864f, -0.02916402f, -0.18659124f, 0.21436648f, -0.07137190f, -0.16283335f, 
    -0.01436792f, 0.14252263f, -0.00518422f, 0.03697975f, 0.01536836f, 0.10189774f, 0.18221037f, 0.37160829f, 
    -0.13889231f, 0.30153713f, -0.00246498f, -0.06957752f, -0.00897483f, -0.02737714f, 0.11304139f, 0.15761954f, 
    -0.12590131f, 0.23011546f, 0.14911941f, 0.11212780f, 0.14862131f, -0.09987723f, -0.11500641f, 0.05421899f, 
    -0.02867506f, 0.06623908f, 0.11129188f, 0.08259697f, -0.23076184f, -0.24815825f, 0.16776864f, 0.16564116f, 
    0.04868155f, 0.17163175f, -0.00687433f, -0.07362367f, -0.03484039f, 0.05621452f, 0.05748920f, 0.10063562f, 
    0.10404454f, -0.03455529f, 0.05618585f, 0.27362287f, -0.00842580f, -0.05135449f, -0.08472963f, 0.01473704f, 
    -0.03549002f, 0.00417576f, -0.08237889f, -0.01276083f, 0.11143618f, 0.20352405f, -0.10541655f, -0.18630968f, 
    -0.04728668f, -0.00474757f, 0.11066797f, 0.05214147f, 0.03368500f, 0.01404843f, 0.16934903f, -0.04458662f, 
    0.34439909f, -0.00100602f, 0.17454851f, -0.17022978f, -0.07174602f, -0.14307697f, -0.03982609f, -0.02527403f, 
    0.13217194f, 0.06352200f, -0.04988502f, 0.09991161f, -0.32060537f, 0.02841059f, -0.01801071f, 0.14888363f, 
    -0.01440454f, 0.09419676f, 0.15325578f, 0.10244602f, -0.09199982f, 0.02144152f, -0.07565513f, -0.07734302f, 
    0.17734052f, 0.10095257f, -0.05576677f, -0.33335310f, -0.13209051f, 0.01179787f, 0.17529358f, -0.03205916f, 
    0.06306808f, 0.20952253f, 0.08030032f, 0.06542451f, 0.30659461f, 0.30512679f, -0.00008882f, -0.17153803f, 
    -0.05467620f, -0.10767344f, 0.01913838f, -0.03785229f, 0.14305255f, 0.15889810f, -0.03076687f, 0.06384059f, 
    -0.16314316f, -0.15959054f, -0.05532923f, 0.23209260f, -0.11314090f, -0.06227827f, 0.01250259f, -0.03894109f, 
    0.03822026f, -0.03014983f, -0.01838768f, 0.03532940f, -0.13368240f, -0.05614504f, 0.02168716f, 0.55597621f, 
    -0.05125751f, 0.17409976f, 0.17082779f, 0.19660357f, 0.26858702f, -0.17432064f, 0.09499666f, 0.10913383f, 
    0.08594289f, 0.24286185f, 0.01870372f, 0.04164259f, -0.13957334f, -0.05625795f, -0.07870014f, 0.03340428f, 
    -0.02135376f, 0.14287761f, 0.03894155f, -0.02511542f, -0.00306823f, -0.11106406f, -0.26707339f, -0.20519683f, 
    -0.20048651f, -0.10957599f, 0.16609876f, 0.12644616f, -0.14209351f, -0.02704648f, -0.11198997f, -0.13755761f, 
    0.04013041f, 0.23802224f, -0.07560404f, -0.17776668f, 0.02252281f, 0.03492302f, 0.10443480f, 0.02318306f, 
    0.01958348f, 0.12542483f, -0.06803992f, 0.04829763f, 0.07614182f, -0.08497634f, 0.13617831f, 0.11733495f, 
    0.12308232f, 0.03288266f, -0.03305151f, -0.10950744f, 0.04764591f, 0.07673161f, 0.00768950f, 0.02050019f, 
    -0.37224808f, 0.00148771f, -0.31904754f, 0.23992568f, -0.06118990f, 0.05352730f, -0.31245208f, 0.09541782f, 
    -0.22629240f, 0.19482125f, 0.04438899f, 0.02013947f, -0.34051159f, -0.27923647f, -0.08917820f, 0.28786406f, 
    -0.21880774f, 0.06036048f, -0.00683850f, -0.00441762f, -0.00885404f, -0.04559741f, 0.01477810f, -0.02074810f, 
    -0.09738108f, -0.09067590f, 0.04271910f, 0.19573112f, -0.07086529f, -0.08991738f, 0.15821129f, 0.13042387f, 
    -0.02641485f, -0.07128823f, -0.05132505f, 0.04502086f, -0.17452745f, -0.03149139f, 0.13504605f, 0.16783395f, 
    0.02557360f, 0.09683640f, -0.18802217f, 0.01526167f, 0.14620472f, 0.02604283f, 0.07324146f, 0.06287584f, 
    0.20789585f, 0.06291271f, 0.13180995f, -0.11161064f, -0.04480189f, -0.01609409f, 0.16403767f, 0.00966739f, 
    0.03081406f, 0.06358077f, -0.03172802f, 0.24553399f, 0.13153526f, 0.05310388f, -0.01604243f, -0.12430968f, 
    0.03452765f, -0.02361487f, 0.00855825f, -0.04073326f, 0.07937504f, -0.09123693f, -0.06383517f, -0.03987837f, 
    0.00173992f, 0.31654385f, 0.13285580f, -0.13041268f, 0.04093094f, 0.03645432f, 0.03475569f, -0.05423868f, 
    0.05464808f, -0.02765483f, -0.08317863f, -0.14226352f, -0.23870762f, 0.31582627f, 0.26257223f, 0.22952066f, 
    0.03079029f, 0.02949179f, 0.05484243f, -0.06865823f, -0.03491517f, 0.09222662f, 0.10390823f, 0.05074629f, 
    0.03944217f, 0.19946586f, 0.01533615f, -0.16476054f, -0.04889240f, -0.06052429f, 0.02247941f, 0.00669984f, 
    -0.15956965f, 0.12971616f, 0.12562808f, 0.18586123f, 0.14251259f, 0.09020054f, -0.31728667f, -0.03825356f, 
    -0.03161567f, 0.13365795f, -0.00471451f, -0.00902837f, -0.05950039f, 0.01647196f, -0.05363077f, -0.04459905f, 
    -0.10385887f, -0.34366775f, -0.03404396f, 0.26482406f, -0.05758475f, 0.00323378f, 0.07581487f, -0.10158763f, 
    0.05357565f, 0.00334884f, -0.10116073f, -0.00811876f, 0.12624237f, 0.37209278f, 0.36591142f, 0.27474350f, 
    -0.12357555f, 0.03121921f, 0.01126412f, 0.09861397f, -0.14741455f, 0.08723412f, -0.00569589f, 0.04498183f, 
    0.16560104f, 0.44766670f, 0.21403874f, -0.27671066f, -0.00831981f, 0.07525910f, 0.02724550f, 0.03252884f, 
    -0.04429239f, 0.05006652f, -0.08151787f, -0.07482629f, 0.01749555f, 0.04865414f, 0.03458393f, 0.06885403f, 
    0.02306107f, -0.07896429f, -0.01144548f, 0.14439939f, 0.03051226f, 0.10189553f, 0.02253160f, 0.08696658f, 
    0.18914589f, -0.23099808f, -0.01337406f, -0.05301026f, -0.06710470f, 0.02138294f, -0.07203991f, 0.10775925f, 
    -0.03355140f, -0.11402907f, 0.05087535f, -0.02318528f, -0.26293182f, 0.12217452f, 0.07299867f, 0.07335026f, 
    0.06787945f, -0.15119778f, -0.14726125f, 0.05797392f, 0.20724209f, 0.10023188f, -0.04257990f, -0.01704818f, 
    0.16245605f, 0.20935442f, 0.50184995f, -0.14903001f, 0.03353361f, 0.01261651f, 0.18058085f, -0.14591844f, 
    0.14245634f, -0.04624058f, -0.17895563f, -0.07943127f, 0.22710133f, 0.46776903f, 0.41785094f, 0.14648125f, 
    0.11941761f, 0.01663527f, 0.12189328f, 0.00115770f, -0.01269783f, -0.10058803f, -0.08085422f, 0.07822970f, 
    -0.02950342f, -0.03188545f, -0.08791277f, -0.22985160f, -0.09038001f, 0.14410782f, 0.10401560f, -0.03509005f, 
    0.10367713f, 0.11463362f, 0.13018484f, 0.14200407f, 0.30957308f, -0.03684382f, 0.04468132f, -0.03513581f, 
    -0.08057740f, -0.13875815f, 0.15153638f, 0.22021481f, -0.00336925f, -0.10551167f, 0.00831087f, -0.00591909f, 
    0.15142442f, -0.07446771f, -0.03611119f, 0.07000226f, 0.01855022f, 0.03253401f, 0.03796417f, -0.00381312f, 
    -0.17496729f, -0.17080857f, -0.23796616f, -0.20969234f, -0.15592784f, -0.01395935f, -0.00464089f, -0.04309501f, 
    -0.16578822f, -0.04944738f, -0.00191700f, -0.06516034f, 0.06455281f, -0.07526131f, 0.11891291f, 0.05121775f, 
    -0.18050456f, -0.65465724f, -0.15529414f, -0.09656064f, -0.00760156f, -0.10056902f, -0.04277517f, 0.07746052f, 
    -0.08144408f, -0.05340091f, -0.03485050f, -0.16001935f, 0.30345306f, 0.05889532f, -0.13143724f, -0.14943443f, 
    -0.03658332f, -0.00425387f, 0.08021570f, 0.21708333f, 0.00347639f, -0.13323122f, -0.07281076f, -0.16924198f, 
    -0.06217992f, -0.10557682f, 0.08403698f, 0.25701070f, -0.13580908f, -0.07577830f, -0.12736887f, -0.04752351f, 
    0.11596860f, 0.09089303f, 0.03173607f, 0.04095560f, -0.35157102f, -0.17270526f, 0.10251258f, 0.04321837f, 
    -0.04729601f, 0.08124173f, 0.02698039f, 0.01163511f, 0.16002342f, 0.05342906f, -0.00940470f, 0.04391175f, 
    0.07268194f, 0.45733193f, 0.27260780f, 0.10086028f, 0.26611391f, 0.13628246f, 0.02623898f, 0.21022834f, 
    -0.09109315f, -0.08264238f, 0.03200028f, 0.01340265f, 0.33777949f, -0.13283971f, -0.13039933f, -0.22165312f, 
    0.05410657f, 0.04375403f, 0.19360314f, 0.09151952f, 0.19201562f, -0.04440285f, 0.09181198f, 0.01269676f, 
    0.09115919f, -0.45049557f, -0.42492273f, 0.11486073f, 0.03371559f, 0.09384859f, 0.14795677f, -0.05078291f, 
    -0.09772290f, -0.18622620f, 0.01817827f, 0.12102655f, 0.01312645f, 0.07520282f, -0.22661935f, -0.13361941f, 
    -0.06025572f, -0.05798410f, -0.13085230f, 0.08400750f, 0.16651195f, 0.14058112f, 0.06941362f, 0.01695144f, 
    0.06037550f, 0.02755459f, -0.10041348f, 0.08577868f, 0.05029817f, 0.07987975f, -0.01639533f, -0.06159316f, 
    0.10838626f, 0.19141422f, 0.08142749f, 0.08769652f, -0.42065078f, -0.28008214f, -0.02357837f, 0.17760511f, 
    -0.10809455f, 0.11710718f, -0.00067024f, -0.06070561f, 0.17429972f, 0.09090589f, 0.35541955f, 0.09574506f, 
    0.36857265f, -0.49554047f, 0.18306950f, 0.36026260f, 0.20555510f, -0.07105658f, -0.45051128f, 0.01525785f, 
    0.17306736f, 0.13124204f, 0.16141148f, 0.00129944f, -0.03448984f, -0.12922427f, 0.20883881f, -0.02379989f, 
    0.00708640f, -0.11063299f, 0.03650257f, -0.02476351f, 0.01411892f, -0.03104168f, 0.00582265f, -0.15556534f, 
    0.17366076f, -0.06747371f, 0.07023810f, 0.03286848f, 0.16520739f, 0.12568493f, 0.20079069f, 0.38745049f, 
    0.05428531f, -0.09857012f, 0.00066249f, -0.29559025f, -0.03066030f, 0.13351846f, 0.16991062f, 0.00848499f, 
    -0.16589101f, -0.18673080f, -0.21173714f, 0.04399755f, -0.06056757f, 0.15735276f, -0.02776428f, -0.09866970f, 
    0.17352726f, 0.10742766f, 0.14615075f, 0.04582471f, 0.08022365f, 0.03364669f, 0.06518275f, 0.09159126f, 
    0.01236689f, 0.06902826f, 0.20498703f, -0.05820099f, 0.04275668f, -0.16013952f, 0.14511290f, 0.09554661f, 
    0.11560635f, -0.05142340f, 0.03309459f, -0.06122544f, -0.09678183f, 0.11677811f, -0.22941022f, -0.08466802f, 
    -0.18734552f, -0.10187924f, -0.17668205f, 0.13862127f, 0.14462613f, 0.01401475f, -0.01431037f, -0.13040280f, 
    -0.02813841f, -0.07019868f, -0.10085848f, -0.01102316f, -0.20527275f, -0.05375462f, 0.23481128f, -0.07654451f, 
    -0.15134875f, 0.00169959f, 0.13941531f, 0.04985546f, 0.02598601f, 0.06984413f, 0.24183062f, 0.20338678f, 
    -0.09820674f, 0.05511241f, -0.16273254f, 0.14532043f, 0.03902553f, 0.08162805f, -0.06322285f, -0.03154681f, 
    0.12887283f, -0.07993054f, -0.03915055f, 0.02201781f, 0.15658028f, -0.31903076f, 0.04645495f, 0.14345101f, 
    0.26034674f, 0.01090596f, -0.01471651f, 0.09972119f, 0.03162895f, -0.12741455f, -0.01386478f, 0.07195572f, 
    -0.22326019f, -0.25836316f, -0.04940563f, -0.06826721f, -0.09897830f, -0.16588044f, 0.15311465f, -0.13824067f, 
    0.13822077f, -0.11033220f, 0.00154757f, 0.07375669f, -0.58126420f, 0.23817979f, -0.04701130f, -0.10055315f, 
    -0.01163929f, 0.01119318f, -0.06745394f, 0.12455033f, -0.22962521f, 0.02885374f, 0.05264576f, 0.12439714f, 
    0.12625673f, 0.02609515f, 0.06990113f, 0.09384576f, 0.13010257f, 0.08211698f, 0.13725579f, 0.08258852f, 
    -0.02695638f, 0.09006164f, 0.02087268f, -0.08516727f, -0.09457102f, -0.10382441f, 0.15522590f, 0.07521635f, 
    0.00146206f, -0.03267529f, -0.12699389f, 0.18684098f, 0.30223709f, 0.06185395f, 0.00082981f, 0.10971804f, 
    -0.05800747f, 0.04294603f, 0.02754122f, 0.05163655f, -0.06118711f, -0.01196796f, 0.03488730f, -0.02971406f, 
    0.02291978f, -0.04861014f, -0.01609626f, 0.05002511f, 0.01234408f, 0.03265289f, -0.06152808f, -0.05013029f, 
    0.03754899f, -0.00183784f, 0.01538376f, 0.00227394f, -0.00632205f, -0.04686188f, -0.01672222f, 0.04948699f, 
    -0.04682955f, -0.06865861f, 0.03120250f, -0.06272233f, -0.01436894f, -0.00738223f, -0.04518843f, -0.00748601f, 
    -0.02552129f, -0.06807247f, -0.01178707f, -0.04146170f, -0.04297917f, -0.00509930f, 0.01168640f, -0.03250708f, 
    -0.04734649f, -0.04657452f, -0.06612323f, 0.05219312f, 0.06136894f, -0.07897460f, -0.01692341f, -0.05327290f, 
    -0.02047016f, -0.05431268f, -0.02541913f, -0.05590320f, 0.03640870f, -0.05182172f, -0.05389863f, -0.03540721f, 
    -0.07241520f, -0.04595491f, 0.03202815f, 0.04362785f, -0.03197324f, -0.00419154f, -0.03285878f, 0.06028086f, 
    -0.03402288f, -0.01902523f, -0.03103404f, -0.03054911f, -0.01614503f, -0.02345936f, 0.02320177f, 0.06072002f, 
    0.03586793f, 0.00020101f, -0.04647561f, 0.02386579f, -0.07813331f, 0.00807735f, -0.05498607f, 0.03893845f, 
    0.02784274f, -0.00884307f, 0.05712181f, 0.04179232f, -0.02327358f, -0.03103411f, -0.06599519f, 0.01211340f, 
    0.05062704f, 0.02637100f, -0.02230868f, -0.03918501f, -0.02458341f, -0.06863298f, 0.04221405f, 0.06132104f, 
    0.01845627f, 0.05286412f, -0.00623635f, -0.04817852f, 0.05894285f, -0.01250568f, -0.00360705f, -0.01210869f, 
    0.03099106f, 0.03616069f, -0.06195689f, -0.05387529f, -0.00168135f, 0.01516817f, -0.06709542f, 0.01556385f, 
    -0.04836721f, -0.05108534f, 0.00166462f, -0.00526879f, -0.02720048f, 0.01982703f, 0.05171750f, -0.03252236f, 
    -0.01362295f, 0.02135786f, -0.07439999f, -0.04976951f, -0.05083607f, -0.03029718f, 0.00365954f, 0.05838298f, 
    0.03601111f, 0.03582769f, -0.04816723f, -0.07299846f, -0.04531167f, 0.03840376f, 0.01978946f, -0.07282854f, 
    -0.06408555f, -0.00264581f, -0.00825856f, -0.00726565f, -0.00020282f, -0.02463075f, 0.03088543f, 0.02322816f, 
    0.02279701f, -0.05632554f, -0.06688149f, 0.05171363f, 0.05079195f, 0.03176977f, 0.04611323f, 0.00531876f, 
    0.05376258f, -0.03380571f, -0.03047908f, 0.02116940f, 0.05413089f, -0.00418896f, -0.05792935f, -0.05751992f, 
    -0.07357708f, -0.02487513f, 0.03331622f, -0.04246231f, -0.02143056f, -0.04391551f, -0.00881686f, 0.06890199f, 
    0.05578833f, -0.02221081f, 0.05530027f, -0.07101050f, -0.02333056f, -0.01725284f, -0.04303163f, 0.01970405f, 
    0.05500691f, -0.04962821f, 0.04245473f, 0.03680371f, -0.00581966f, -0.04657042f, 0.01970669f, 0.01283863f, 
    0.04722256f, -0.06354921f, 0.01020215f, -0.04957325f, 0.05225353f, -0.00804923f, -0.05307739f, 0.02220878f, 
    -0.02820470f, 0.00206090f, 0.19670622f, 0.08901713f, 0.02466297f, 0.05298872f, -0.05035394f, -0.13081741f, 
    -0.08617888f, 0.07249642f, 0.10020247f, -0.09617045f, 0.09907052f, 0.19272016f, -0.33419123f, -0.01763381f, 
    -0.01120093f, 0.05456594f, 0.04395260f, -0.00193522f, 0.12557450f, -0.06349520f, 0.04756480f, -0.04530989f, 
    0.19528887f, 0.20271121f, -0.08714013f, 0.12936881f, 0.24459706f, 0.09409827f, 0.33333650f, 0.01928264f, 
    0.21550801f, -0.18057877f, 0.04247194f, 0.09078109f, 0.10833984f, 0.08079187f, -0.04672067f, -0.14885649f, 
    0.10057505f, -0.14617504f, -0.04444686f, 0.07202455f, 0.07935344f, 0.14447086f, 0.00370378f, 0.13775682f, 
    -0.14376615f, 0.05391387f, -0.11992591f, -0.17500982f, -0.15682641f, -0.05120091f, 0.15863283f, 0.01978456f, 
    -0.08005062f, 0.09165329f, 0.08397968f, 0.10706186f, -0.07385784f, -0.10806386f, -0.21396720f, -0.01308219f, 
    -0.03321616f, -0.06888130f, 0.06967959f, -0.06645683f, -0.01134702f, 0.09996066f, 0.01173460f, -0.02203883f, 
    -0.07279036f, -0.20775107f, 0.20108318f, -0.11176682f, 0.00508746f, 0.00409828f, -0.09821100f, 0.25147364f, 
    -0.09325083f, -0.02964409f, -0.20263685f, -0.08887445f, -0.06219395f, 0.11027178f, 0.03736714f, 0.28980580f, 
    -0.01223689f, -0.10912310f, -0.09968231f, -0.15267996f, 0.04042776f, 0.04654015f, 0.05564137f, 0.17675938f, 
    -0.18439731f, 0.18299587f, 0.04528243f, 0.14261906f, -0.10202574f, -0.01111735f, -0.00714900f, -0.04232301f, 
    -0.13769673f, 0.03958823f, -0.00983885f, -0.05253807f, 0.48796836f, 0.02888569f, -0.18216527f, 0.10445745f, 
    0.01084267f, -0.04063841f, 0.11482630f, 0.00656395f, -0.09750318f, -0.03967718f, 0.02230034f, -0.05322778f, 
    -0.09952790f, 0.00394688f, -0.01929339f, 0.17430453f, -0.10596950f, 0.07303315f, -0.00312454f, -0.01986114f, 
    0.04806527f, -0.04554757f, 0.10412233f, 0.01254576f, 0.04657770f, 0.01429116f, 0.21559408f, 0.03786057f, 
    0.10123789f, -0.09157339f, 0.02033783f, -0.11898368f, 0.05662988f, -0.00469112f, 0.06407102f, -0.11001189f, 
    0.24229643f, 0.30372584f, 0.06870285f, -0.19644363f, 0.08225917f, -0.00182041f, 0.02053482f, 0.06221144f, 
    -0.13115238f, 0.06526462f, -0.07748169f, -0.10944200f, 0.11436260f, -0.22609740f, -0.23321019f, -0.05209306f, 
    0.04156386f, 0.12585704f, 0.01379139f, 0.11923134f, 0.02149150f, 0.16820945f, -0.13429867f, 0.03299702f, 
    -0.00977896f, 0.03999859f, 0.11629419f, 0.13952096f, 0.06751192f, -0.01008249f, 0.06896427f, -0.17355628f, 
    -0.08554306f, -0.03071043f, -0.01460563f, 0.06165381f, 0.16184618f, 0.00865905f, -0.15532236f, -0.03802036f, 
    0.18801002f, 0.03694351f, 0.04129274f, -0.08493496f, 0.01675840f, -0.01475044f, 0.01956611f, -0.01519227f, 
    -0.16004948f, -0.27245826f, -0.08416822f, 0.03466907f, 0.03771017f, 0.00807290f, 0.03250074f, -0.04314087f, 
    0.08956365f, 0.23757845f, -0.09245063f, 0.17455900f, 0.17737648f, 0.10113292f, -0.39459744f, 0.10120066f, 
    -0.03421737f, -0.06047581f, 0.08935157f, -0.01845762f, 0.09034041f, 0.01649279f, -0.02739355f, -0.01644279f, 
    0.19667929f, -0.03341205f, -0.18738213f, 0.10193148f, 0.01208404f, -0.03381847f, 0.13904847f, -0.14702925f, 
    0.16744637f, -0.09742468f, 0.02082075f, -0.03421781f, 0.33850375f, 0.14184044f, 0.01703449f, -0.08400150f, 
    -0.05464709f, 0.00763326f, 0.06245713f, 0.09105276f, -0.08277633f, 0.01740874f, -0.08911278f, 0.02858870f, 
    -0.00274673f, 0.26828545f, 0.19237511f, -0.02938376f, -0.14149441f, -0.13224572f, -0.08645962f, -0.25531888f, 
    0.00569983f, -0.00704993f, 0.06616852f, -0.09305991f, -0.04401095f, -0.13154785f, -0.01330662f, 0.10397711f, 
    0.13280475f, 0.09624685f, 0.15788934f, 0.05628048f, 0.22695400f, 0.07920735f, 0.00121253f, 0.06326108f, 
    0.07477181f, -0.20322986f, 0.27428478f, -0.03396640f, -0.03238006f, -0.08269873f, -0.06716010f, 0.03283189f, 
    0.09001751f, -0.02774698f, -0.03271781f, 0.15040959f, -0.31281522f, -0.11790475f, -0.17010173f, -0.03969520f, 
    0.03179561f, 0.00859196f, -0.01859025f, 0.17046592f, 0.00686515f, 0.07495525f, 0.24525249f, 0.13260326f, 
    -0.63668376f, -0.05192367f, -0.18743564f, -0.18526320f, -0.00276383f, -0.08377036f, 0.12863848f, 0.11161055f, 
    -0.01685121f, 0.16952920f, 0.17457984f, 0.16524383f, 0.45124385f, 0.31507605f, 0.14739652f, 0.29596505f, 
    0.00396237f, 0.09419908f, 0.05312915f, 0.07051521f, 0.03900713f, -0.02776803f, 0.06030748f, 0.15444565f, 
    -0.21212174f, -0.12755300f, -0.16571851f, 0.01368024f, 0.09744809f, 0.00608147f, 0.09807998f, -0.00484282f, 
    0.09534183f, 0.03672031f, 0.01582750f, 0.01309893f, -0.07552749f, -0.11667174f, 0.07809024f, -0.00941824f, 
    -0.00029733f, -0.00779526f, 0.09665617f, -0.02140786f, 0.10142428f, -0.07719184f, 0.08257853f, -0.10201016f, 
    0.31840026f, 0.20590363f, 0.15263128f, 0.07127158f, 0.00531523f, 0.19004360f, -0.22697459f, -0.01860417f, 
    0.02934427f, 0.01263334f, -0.03664401f, -0.15909526f, 0.22197533f, 0.21349309f, -0.18432218f, -0.03718730f, 
    0.10822327f, -0.03313230f, 0.02960946f, -0.18972936f, -0.02246023f, 0.07523698f, -0.13806558f, -0.10230124f, 
    -0.14675188f, 0.01598924f, 0.15770221f, -0.34926963f, -0.08832982f, -0.06798699f, 0.00857169f, -0.00949138f, 
    0.03980255f, 0.02219796f, 0.00583349f, 0.08711264f, 0.16268975f, 0.17673059f, -0.13831595f, 0.21640290f, 
    0.22755495f, 0.11353224f, 0.31144026f, -0.01505439f, -0.02466710f, -0.15417404f, -0.24103467f, -0.02329298f, 
    0.01771530f, 0.07582828f, 0.12541455f, 0.08058827f, 0.01411206f, -0.06626973f, 0.01599365f, 0.19613123f, 
    -0.01454418f, -0.24882580f, 0.07571108f, -0.06347610f, -0.25966382f, 0.24741444f, -0.17385167f, 0.29056463f, 
    0.00920248f, -0.20451875f, 0.16773839f, -0.13611777f, -0.00939005f, 0.05026741f, 0.05405805f, 0.02272897f, 
    0.02561179f, 0.41320580f, 0.21840984f, 0.08995118f, 0.28772080f, 0.16439860f, 0.02162921f, 0.04146973f, 
    0.07702382f, -0.05632446f, 0.00626706f, 0.07381362f, 0.14453115f, 0.32311001f, 0.03745433f, 0.00175844f, 
    0.01365413f, 0.01232917f, 0.04118533f, 0.00324410f, -0.00970496f, 0.10828114f, 0.00929747f, -0.08071172f, 
    0.20366290f, 0.11287088f, -0.25220844f, 0.07784568f, -0.04840420f, 0.16110660f, 0.17956054f, -0.00385770f, 
    0.04846609f, 0.05396197f, 0.05664968f, 0.08274646f, -0.17953567f, -0.39264989f, -0.05646834f, -0.02986098f, 
    -0.05196552f, -0.09713809f, 0.09215665f, -0.06211737f, -0.01206375f, 0.08302965f, 0.02099023f, -0.11261284f, 
    0.20456620f, -0.16221240f, 0.38682106f, -0.13941561f, -0.08143164f, 0.03978568f, -0.24212261f, 0.21094058f, 
    -0.17215985f, -0.17122270f, -0.19635241f, -0.09676512f, -0.20446628f, 0.00471880f, 0.01144059f, 0.19422312f, 
    -0.15780042f, -0.10949483f, -0.13646995f, 0.00610769f, 0.17969880f, -0.02161878f, 0.11169271f, -0.06029386f, 
    -0.01035913f, -0.20553716f, 0.06961306f, 0.19846028f, 0.01652609f, -0.00827163f, -0.08945598f, -0.11198504f, 
    -0.09539084f, -0.24222554f, -0.14851522f, 0.05414202f, 0.29933482f, 0.05596982f, -0.29499400f, 0.20262125f, 
    0.00903340f, 0.04459804f, 0.03468303f, 0.20481166f, -0.12572908f, -0.05298733f, -0.04066627f, -0.09678324f, 
    -0.14218809f, -0.03539803f, -0.10113238f, 0.23631401f, 0.00376561f, -0.03790186f, 0.03648359f, -0.16314895f, 
    0.10394627f, 0.05549672f, 0.12809865f, 0.02929172f, -0.01435810f, 0.16185163f, 0.32607377f, 0.13022828f, 
    -0.11123319f, -0.06206065f, 0.04246248f, 0.06459738f, 0.12006950f, 0.21563923f, -0.16298661f, 0.12291431f, 
    0.21090336f, 0.22411472f, 0.23695673f, -0.09841897f, -0.00318973f, 0.04429612f, 0.16071717f, 0.09865048f, 
    -0.01977640f, -0.01640531f, 0.09239167f, -0.09066013f, -0.11707921f, -0.21224110f, -0.11590308f, 0.07211009f, 
    0.04220328f, 0.07712146f, -0.10034044f, 0.13424546f, 0.05504172f, 0.07253718f, 0.14872414f, -0.03772700f, 
    0.21273051f, -0.18800256f, 0.38179156f, 0.13430087f, -0.10648468f, -0.02860684f, 0.04885661f, 0.09036380f, 
    -0.11840247f, -0.03469619f, -0.02356568f, -0.00243644f, -0.19559956f, 0.21207786f, -0.43228778f, -0.10767914f, 
    0.13454530f, -0.09897210f, -0.05228056f, -0.21535391f, -0.12364291f, 0.14268237f, 0.11978133f, -0.00099992f, 
    0.05319306f, -0.05155386f, 0.16173913f, 0.03665667f, -0.01260503f, -0.06348848f, 0.08370785f, -0.01686895f, 
    0.15333092f, -0.04028213f, 0.01636092f, -0.07041958f, -0.13958330f, 0.18897709f, -0.10777672f, -0.06130449f, 
    -0.28806871f, -0.04432075f, -0.20216155f, 0.03635659f, 0.20672826f, 0.14150947f, -0.23938896f, 0.01538737f, 
    -0.39076218f, -0.21533054f, -0.00072890f, 0.00597470f, -0.18084891f, -0.13037144f, 0.08165293f, 0.04456412f, 
    -0.00264386f, 0.11259674f, 0.07552453f, -0.02065376f, -0.02200020f, 0.20201375f, 0.23851077f, -0.18339011f, 
    0.02236822f, -0.09913842f, 0.01300204f, 0.15757291f, -0.00328208f, 0.05373693f, -0.02630277f, 0.11698493f, 
    0.13218240f, -0.09166501f, -0.03852295f, 0.09600895f, 0.13971661f, 0.35178927f, 0.05954656f, -0.08612610f, 
    -0.28394768f, 0.03056166f, -0.07980825f, -0.10814373f, 0.15214618f, 0.07787586f, 0.01482511f, -0.15281935f, 
    0.01854716f, -0.01760678f, 0.09452083f, 0.07371315f, 0.28816187f, 0.11108403f, -0.11823539f, -0.07460648f, 
    0.09974110f, 0.09505972f, 0.11370744f, 0.11642786f, 0.05432967f, 0.13028257f, 0.25458270f, 0.16653636f, 
    0.17178127f, 0.01754735f, 0.03728446f, 0.11200362f, 0.17861950f, 0.14435814f, 0.10671531f, 0.25245064f, 
    -0.12647296f, -0.05913894f, -0.11472533f, -0.01592748f, -0.00038840f, 0.03259251f, -0.01272312f, 0.05926082f, 
    0.26861259f, -0.03845044f, 0.40691984f, 0.36500904f, -0.00879959f, 0.08119189f, 0.08393735f, 0.05112737f, 
    -0.02903554f, -0.05818801f, 0.07990601f, 0.11063015f, 0.14044295f, -0.67825449f, -0.37148994f, -0.18097676f, 
    -0.03510486f, 0.02125166f, -0.01570729f, 0.05248732f, 0.14827402f, 0.00940110f, -0.08322099f, 0.19048297f, 
    0.04775088f, 0.01024704f, 0.03234455f, 0.20910692f, 0.01283371f, -0.05518750f, -0.03786220f, 0.01505850f, 
    0.00250269f, 0.08839736f, 0.08546318f, -0.02895001f, -0.10294139f, -0.10676910f, 0.20580338f, 0.21709956f, 
    -0.04951259f, 0.00615874f, 0.02787394f, -0.02887528f, 0.02447730f, -0.08582521f, -0.03085287f, -0.08627695f, 
    -0.36019844f, -0.11662623f, -0.16231410f, -0.42985463f, -0.01173671f, -0.06965024f, 0.02468823f, 0.10645822f, 
    -0.05324970f, -0.05873676f, 0.03014791f, 0.18550061f, 0.07444955f, -0.29055148f, -0.24057959f, -0.56770962f, 
    -0.01683851f, -0.16036102f, -0.05062637f, 0.08602268f, 0.05802163f, 0.08084770f, 0.04183387f, -0.00041199f, 
    0.37450314f, 0.09155270f, 0.20248817f, 0.27001065f, 0.18240669f, 0.04660831f, 0.07102031f, -0.00475685f, 
    -0.03623029f, -0.12668340f, 0.00221050f, 0.05243577f, 0.01882124f, -0.17834634f, -0.15877029f, -0.12736465f, 
    -0.09997463f, 0.05050201f, -0.03982795f, -0.05315859f, -0.10275732f, -0.00351566f, -0.14435227f, -0.02802231f, 
    0.02287454f, 0.05007190f, 0.03146875f, 0.04063588f, -0.06048420f, -0.02319343f, -0.00501466f, -0.01412686f, 
    -0.00355773f, -0.05485635f, -0.03688175f, -0.03521367f, -0.05230264f, -0.06043243f, -0.03885634f, -0.03837292f, 
    -0.01335901f, -0.06191395f, -0.02844430f, 0.03466164f, -0.04260663f, -0.03764524f, 0.01146726f, 0.06514455f, 
    -0.02390814f, 0.00196614f, 0.04760894f, 0.02328782f, 0.03241258f, 0.05941837f, -0.05935763f, -0.05487813f, 
    -0.06245220f, -0.02068399f, -0.05538949f, 0.02651469f, -0.04734057f, -0.03037408f, 0.04041113f, 0.01484506f, 
    0.04618054f, -0.01602314f, 0.01398878f, -0.07615649f, -0.01353489f, -0.00532370f, 0.01803783f, -0.00105641f, 
    0.01855172f, -0.00709734f, 0.03755442f, -0.03898520f, 0.01837089f, -0.04468800f, 0.03230934f, -0.01501104f, 
    0.01809422f, -0.04520823f, 0.04034314f, 0.03454345f, 0.01448975f, -0.02652496f, -0.05967609f, 0.04571079f, 
    -0.06396914f, -0.02885454f, -0.07567908f, 0.00127283f, -0.06316974f, -0.07000834f, -0.06809597f, 0.03671852f, 
    0.00550875f, 0.04307732f, 0.05456695f, 0.02384845f, -0.06520949f, -0.03108643f, 0.02734244f, 0.05528557f, 
    -0.00720698f, -0.03729257f, 0.05950112f, -0.03881998f, 0.02295418f, 0.04071286f, 0.02140424f, -0.01026569f, 
    -0.00604307f, -0.05259481f, -0.01259363f, -0.06726614f, -0.07708558f, -0.04076258f, 0.05506504f, -0.07121813f, 
    0.00568376f, -0.05117738f, -0.01175279f, 0.05167050f, -0.02565255f, -0.03753306f, -0.07704901f, -0.04620265f, 
    0.02651609f, -0.06595241f, -0.05213712f, -0.00886385f, 0.03348582f, -0.05397451f, 0.05576956f, -0.05216754f, 
    -0.01159686f, 0.04603768f, 0.03660318f, -0.06627445f, -0.07694490f, 0.00424323f, -0.07591268f, -0.06492218f, 
    0.03958768f, -0.06940557f, 0.02279959f, 0.06376426f, -0.03851004f, -0.06156138f, -0.01897143f, -0.04678841f, 
    -0.01664564f, 0.02209287f, 0.01031888f, 0.02051899f, 0.06304897f, 0.00300943f, -0.05017795f, -0.02157428f, 
    0.00119628f, -0.06847396f, -0.06425008f, -0.05358841f, 0.05261597f, -0.05710246f, 0.01819683f, -0.03347128f, 
    -0.06479643f, -0.00185844f, -0.04461598f, -0.03919488f, 0.00791605f, -0.06834978f, -0.00734890f, 0.04061641f, 
    0.00557264f, -0.03065272f, -0.03344482f, -0.02424293f, 0.01063756f, -0.01988989f, -0.04945901f, 0.02798604f, 
    0.03797850f, -0.00114569f, 0.04160824f, -0.06769263f, -0.02505963f, 0.06091212f, 0.00824417f, -0.02583284f, 
    0.00998637f, -0.06042462f, 0.01645726f, -0.05641014f, -0.04965685f, 0.03129622f, 0.05501502f, -0.07538921f, 
    -0.04758789f, -0.07164384f, -0.07017256f, -0.07761869f, -0.06194993f, 0.00285265f, -0.05103654f, -0.04831238f, 
    -0.07103488f, 0.00839966f, -0.02201843f, -0.00004482f, -0.04695921f, 0.02330492f, 0.05579913f, 0.01138318f, 
    0.01201443f, -0.24912338f, 0.04830233f, 0.10917545f, -0.07565901f, -0.00637197f, -0.06748982f, -0.16613799f, 
    0.18968195f, 0.03309314f, 0.18235463f, -0.02163605f, 0.02836863f, -0.08364981f, -0.23307721f, -0.12496319f, 
    0.00115313f, 0.02695036f, -0.13658036f, 0.20275922f, 0.15050018f, -0.08853319f, -0.18738435f, 0.11857992f, 
    -0.30471367f, -0.34295085f, 0.15269838f, 0.27811372f, 0.14484909f, -0.07379466f, 0.15509509f, -0.09598056f, 
    0.19587898f, -0.04465564f, 0.00650967f, 0.13474049f, 0.17112060f, 0.16116504f, 0.45569277f, -0.01926153f, 
    0.11320880f, -0.07488867f, 0.06283375f, 0.18568014f, 0.11604077f, -0.05208509f, 0.02616128f, 0.08763217f, 
    0.20018439f, 0.10750376f, 0.08341102f, -0.08095363f, 0.04470522f, 0.14971283f, -0.10206408f, 0.06871878f, 
    -0.05996741f, -0.12366257f, -0.01744491f, -0.06330243f, -0.06220895f, -0.05928496f, 0.01380434f, -0.15132885f, 
    0.09312228f, 0.01490869f, 0.10670293f, 0.00168261f, 0.18573794f, 0.17648189f, -0.08586290f, 0.07427655f, 
    0.08730190f, 0.03492652f, -0.13784267f, 0.10926487f, 0.03631563f, 0.11148474f, -0.04894852f, -0.04996762f, 
    0.11488811f, 0.01464614f, 0.02026304f, -0.10278589f, -0.16170263f, -0.13201016f, -0.00876455f, 0.12698798f, 
    0.05603340f, -0.03836402f, -0.15342711f, -0.04165778f, -0.02897826f, -0.03812094f, 0.08847322f, 0.12828420f, 
    -0.16542020f, -0.34220031f, 0.00657733f, 0.29438514f, -0.01521799f, -0.06979787f, -0.02136086f, -0.02451032f, 
    -0.00166304f, -0.02743771f, 0.01267482f, -0.06353786f, 0.16492824f, -0.10748640f, 0.03431378f, -0.22227935f, 
    -0.03906687f, -0.05742975f, -0.07218812f, 0.04690213f, 0.08946678f, -0.03576080f, 0.09231716f, 0.11409958f, 
    -0.00427201f, -0.08752829f, -0.28636065f, 0.23253113f, 0.00660657f, -0.00729907f, -0.02691218f, 0.01750937f, 
    0.12459284f, 0.13939077f, 0.11475447f, 0.12026302f, -0.10177008f, -0.31983128f, 0.18953621f, 0.19007249f, 
    0.06055140f, 0.05836331f, 0.05370035f, 0.06223765f, 0.01606138f, -0.05465716f, -0.02606723f, -0.05735916f, 
    -0.00301008f, 0.32821387f, 0.27484405f, 0.09946320f, 0.02063186f, 0.05864459f, 0.11507389f, 0.19419800f, 
    0.12618911f, 0.08422121f, -0.03555128f, 0.01963371f, 0.26625541f, -0.02864457f, -0.15920505f, -0.98046094f, 
    0.06271841f, 0.15011154f, -0.00270436f, -0.00213473f, -0.00698506f, 0.00317412f, -0.12233417f, -0.09387178f, 
    0.12832098f, -0.01505342f, -0.19715039f, 0.14542033f, 0.07029421f, -0.06308011f, -0.02825134f, -0.09748161f, 
    0.04073972f, 0.02929743f, 0.04310855f, 0.03257278f, 0.19033274f, -0.19668154f, 0.09931153f, 0.06742223f, 
    -0.03216470f, -0.07609063f, -0.02519985f, -0.09098239f, 0.08599500f, -0.07127648f, -0.03702147f, -0.00241600f, 
    0.06276464f, -0.18371047f, -0.22855568f, -0.17923257f, 0.16050340f, 0.24732156f, 0.07639156f, 0.02709995f, 
    0.15220135f, 0.12858261f, 0.05548211f, -0.00402145f, -0.41534221f, -0.10801353f, -0.00243719f, 0.29690039f, 
    -0.06942561f, 0.04786876f, -0.00712422f, -0.07826615f, 0.09937306f, 0.03084127f, 0.21914208f, 0.12537028f, 
    0.31602129f, -0.37244257f, 0.14423798f, -0.00449382f, 0.03156769f, -0.11728707f, -0.39269885f, -0.02073718f, 
    0.07125318f, 0.06311619f, 0.20218349f, -0.09761564f, -0.02695836f, -0.06573440f, 0.25982291f, 0.22417882f, 
    -0.09896492f, 0.00570603f, 0.11788553f, -0.07454494f, 0.00791319f, -0.09541401f, 0.05886414f, -0.06397631f, 
    0.37447554f, -0.07068110f, 0.29218280f, 0.21386121f, 0.11599372f, 0.02796194f, -0.05630080f, 0.17312351f, 
    -0.00970893f, -0.14259395f, -0.20631829f, -0.31728268f, 0.07064033f, 0.12547058f, 0.36015108f, 0.04572885f, 
    -0.05482775f, -0.07511874f, -0.02948997f, 0.09867128f, -0.02032406f, -0.06351086f, -0.02870979f, -0.24421939f, 
    0.23430118f, 0.12251803f, 0.12384476f, 0.06848782f, 0.04100906f, 0.14109568f, 0.11129089f, -0.00353006f, 
    0.05566214f, 0.05549080f, 0.23244551f, 0.04729238f, 0.07759401f, -0.17624822f, 0.01773445f, -0.06835594f, 
    0.07956275f, 0.02021362f, -0.05340494f, 0.02247952f, 0.04876173f, 0.07886897f, -0.17828953f, 0.11829744f, 
    -0.08078096f, -0.11356176f, -0.05373313f, 0.08642094f, -0.00958869f, 0.03232589f, -0.10050666f, -0.09976963f, 
    0.02309712f, -0.00219781f, -0.06843481f, 0.12035365f, -0.21369015f, -0.01949949f, 0.16718814f, 0.03343835f, 
    0.03081376f, 0.11828152f, -0.00039976f, -0.05690400f, -0.03335396f, -0.12360410f, 0.27483234f, 0.24903704f, 
    -0.16815948f, 0.05958588f, -0.19316004f, 0.01409232f, 0.06537908f, 0.03545930f, -0.07043164f, -0.02115197f, 
    0.12211937f, 0.05919515f, 0.03742466f, 0.09892365f, 0.16657306f, -0.32370812f, 0.03328007f, 0.31422338f, 
    0.10807613f, -0.03550837f, -0.04166026f, -0.03338596f, -0.21097490f, -0.05131308f, -0.11109909f, 0.04711533f, 
    -0.00582428f, -0.15518473f, 0.07037646f, 0.17501423f, -0.08745870f, -0.24402468f, 0.13749202f, -0.03817511f, 
    0.06518266f, -0.07287489f, -0.03599667f, -0.01340524f, -0.34833348f, 0.18678489f, -0.04414215f, 0.18743323f, 
    -0.06517182f, -0.15322700f, 0.23244587f, 0.05704011f, -0.12559484f, -0.00386473f, 0.08126181f, -0.04666403f, 
    0.25270134f, 0.01210387f, 0.21442071f, 0.01174432f, 0.03697329f, -0.03326250f, 0.08093291f, 0.15900290f, 
    -0.13621761f, -0.11239111f, -0.05514378f, -0.09286307f, -0.12786612f, 0.03971038f, -0.10759479f, -0.02813371f, 
    -0.15409212f, 0.11431025f, 0.00788532f, 0.30019411f, 0.11148205f, -0.08014173f, -0.14733455f, -0.04627880f, 
    -0.06198275f, -0.03784036f, -0.03638899f, -0.06834127f, -0.06691060f, 0.05450747f, -0.01064803f, -0.01377485f, 
    -0.06205222f, -0.05974595f, 0.06205179f, -0.07833390f, 0.02513546f, -0.06213904f, -0.07933930f, 0.02622575f, 
    0.02454400f, -0.00032955f, -0.06499760f, -0.02911895f, -0.06287012f, 0.02168912f, -0.07745820f, -0.01550874f, 
    -0.02326832f, 0.05805657f, -0.00946158f, -0.04457826f, 0.05797961f, -0.01271773f, -0.00776361f, 0.06336609f, 
    0.05130622f, -0.04313561f, 0.01655677f, -0.04982667f, -0.03861771f, 0.06122461f, -0.07506285f, 0.02157474f, 
    0.05991754f, -0.00699038f, 0.00011588f, 0.02224127f, -0.06022668f, -0.04393964f, -0.04762729f, 0.05240903f, 
    -0.07465418f, 0.06314839f, -0.03943853f, 0.01573284f, -0.03359906f, -0.05422274f, -0.02971826f, -0.03138199f, 
    -0.03407900f, 0.03869908f, 0.03797041f, -0.01301921f, -0.04802027f, 0.04409893f, 0.03117546f, 0.00243552f, 
    -0.01609321f, 0.06099755f, -0.03277552f, -0.05676687f, 0.04222535f, -0.06498143f, 0.01815229f, 0.03694929f, 
    -0.04765012f, -0.01472872f, 0.01488291f, 0.03423262f, 0.03313447f, 0.01385191f, -0.06146768f, -0.00572781f, 
    0.04905539f, 0.03581880f, 0.00621393f, 0.05137565f, -0.07455824f, 0.05653247f, -0.01783470f, -0.04655689f, 
    -0.02345857f, 0.04491192f, -0.04444055f, -0.05685131f, -0.05740823f, -0.01086292f, 0.01277676f, 0.04175238f, 
    0.05686539f, 0.04243481f, 0.03536855f, 0.06170892f, -0.04911317f, 0.02058746f, -0.03557464f, -0.00957034f, 
    0.00640268f, -0.06070232f, -0.03560660f, 0.01302174f, -0.03442028f, -0.03417858f, -0.02395058f, 0.00546427f, 
    -0.02985954f, -0.06415049f, -0.03519953f, -0.01782104f, 0.06365478f, -0.02805030f, 0.03811962f, 0.03467204f, 
    0.03901534f, -0.01013209f, -0.02498688f, -0.02050154f, -0.04511628f, 0.04456657f, -0.06149389f, -0.03884567f, 
    -0.07460047f, 0.03368389f, -0.06629684f, 0.00933256f, 0.01254779f, -0.06217148f, -0.03673825f, -0.03490835f, 
    0.04218904f, -0.01632679f, -0.06565203f, 0.03739567f, -0.06588611f, -0.03896936f, 0.00639392f, -0.02323740f, 
    0.02779593f, -0.00171177f, -0.05979081f, 0.00909580f, -0.05588213f, 0.04798787f, 0.02142898f, -0.05166865f, 
    -0.06456283f, 0.03356703f, -0.07745405f, -0.01702329f, 0.00581381f, -0.05052347f, 0.02297800f, -0.00160767f, 
    0.05579165f, 0.04174356f, 0.02377897f, 0.04306050f, 0.04496364f, -0.00427059f, -0.05420771f, 0.04305848f, 
    -0.08106681f, 0.02972668f, -0.06708087f, 0.04333607f, -0.03865068f, -0.00697744f, -0.01699191f, -0.03902418f, 
    -0.01601894f, -0.04046055f, 0.04245701f, -0.02941704f, -0.02869144f, -0.07128200f, -0.05676265f, 0.05965202f, 
    0.02313884f, -0.01598783f, -0.01056732f, 0.01314651f, -0.00685827f, -0.05249468f, -0.04967231f, -0.00453518f, 
    -0.00220046f, -0.25685614f, -0.16774067f, -0.16184579f, -0.00880096f, -0.02516809f, -0.05945725f, -0.06856728f, 
    -0.00780004f, 0.15716742f, -0.17015326f, 0.04544778f, 0.19214948f, -0.01468104f, -0.29816970f, 0.06159578f, 
    0.07737818f, 0.03986905f, -0.02760174f, -0.00947512f, -0.09430097f, 0.06522405f, -0.23264867f, 0.11975399f, 
    -0.19174923f, -0.26550975f, -0.19019337f, 0.00399758f, -0.04074292f, 0.03026220f, 0.43998760f, -0.09710409f, 
    -0.01191646f, 0.05666907f, 0.14803743f, 0.09446222f, 0.14567205f, 0.11903655f, 0.13731474f, 0.20985965f, 
    -0.18939443f, -0.05307077f, 0.09984025f, 0.12469147f, 0.06213310f, -0.01284115f, -0.08394253f, 0.06754837f, 
    -0.06899617f, 0.09807697f, 0.12300346f, -0.13915846f, 0.00687337f, -0.20051782f, 0.13830313f, 0.08001392f, 
    0.00992739f, -0.10413488f, -0.08005843f, -0.05784339f, 0.16030601f, -0.02230070f, 0.04138305f, 0.14125641f, 
    -0.10496149f, 0.02052239f, 0.14948329f, 0.08930483f, -0.02607055f, 0.17457052f, 0.05109411f, 0.11882252f, 
    0.19103689f, 0.02564654f, 0.14382267f, -0.06734072f, 0.02009412f, 0.00313494f, -0.13013767f, 0.01146709f, 
    0.16675693f, 0.09911203f, -0.02831335f, 0.22300237f, -0.60963112f, -0.44753528f, -0.53893930f, -0.17650874f, 
    -0.02620735f, 0.00318954f, -0.09514891f, -0.02727228f, -0.01026237f, -0.04533928f, -0.15067624f, 0.05096169f, 
    -0.44974172f, -0.06796432f, 0.06434127f, -0.51611680f, 0.07880496f, -0.11165678f, 0.02202955f, 0.01239754f, 
    -0.02380977f, 0.16927136f, 0.06082556f, -0.12091623f, 0.07445349f, 0.24335575f, 0.24983414f, 0.22683366f, 
    0.15928951f, 0.17197569f, -0.20431192f, 0.00068026f, 0.13351762f, -0.04984418f, -0.01430686f, -0.01184076f, 
    -0.37764186f, -0.19307888f, -0.17873546f, -0.28093180f, 0.04154184f, -0.04455955f, -0.00030652f, -0.08150741f, 
    -0.13330890f, -0.03986869f, 0.04538506f, 0.04283634f, -0.13209040f, -0.54466164f, -0.38707897f, -0.31760117f, 
    0.08535530f, -0.05732610f, -0.01855725f, -0.02887798f, 0.06760314f, -0.12596568f, 0.10635316f, -0.17931205f, 
    0.18420519f, 0.25543466f, 0.27170530f, 0.42129579f, 0.10657255f, 0.03843214f, 0.05927272f, -0.07880601f, 
    0.06419063f, 0.10867074f, -0.01283177f, -0.09409549f, 0.52230519f, 0.25898376f, -0.07082804f, 0.18574141f, 
    0.06898340f, 0.02147924f, 0.15853360f, -0.00177471f, -0.13880870f, -0.06865194f, -0.12104218f, 0.00926611f, 
    -0.12119953f, 0.23648186f, -0.25750399f, -0.71343344f, 0.09816238f, 0.06075956f, -0.18845999f, -0.15644738f, 
    -0.05281212f, 0.02912767f, -0.02152064f, -0.05325944f, 0.21737024f, -0.05072999f, -0.01230270f, 0.22673768f, 
    0.04726453f, 0.14607416f, 0.12776622f, -0.17789543f, 0.17528769f, -0.01790772f, -0.01552184f, 0.08018489f, 
    -0.02033611f, 0.03494513f, 0.02092475f, -0.02666742f, -0.05893284f, 0.02555170f, -0.02104380f, 0.04642877f, 
    0.00060472f, -0.00946511f, 0.04818752f, 0.04049700f, -0.04347626f, -0.00628111f, 0.00714711f, 0.01155975f, 
    0.05678050f, -0.00373912f, 0.02733336f, 0.01375641f, -0.01825561f, 0.00108168f, 0.03228310f, 0.02406864f, 
    0.01614064f, -0.05790319f, 0.04607724f, -0.00979535f, -0.01974708f, -0.05140989f, -0.06375367f, -0.04029771f, 
    0.00366111f, -0.02000021f, -0.05486657f, -0.01048990f, 0.04459656f, -0.04583621f, -0.04838217f, -0.01282495f, 
    -0.02417704f, -0.02811980f, 0.02184564f, -0.00959555f, 0.06126862f, -0.08013363f, 0.03291716f, -0.06766149f, 
    -0.06588779f, -0.06378876f, 0.03426263f, 0.02038544f, 0.02646063f, 0.01748304f, 0.01897006f, 0.02848253f, 
    -0.01895483f, 0.02572150f, 0.04949180f, 0.01956931f, 0.05357928f, -0.03147402f, -0.01098681f, -0.06012232f, 
    0.03466259f, 0.00887834f, 0.04311079f, -0.07044281f, 0.05930243f, -0.01796199f, -0.00705782f, -0.00972327f, 
    -0.05056828f, -0.05598991f, 0.03846833f, -0.07394639f, 0.00095833f, 0.06061238f, 0.03376228f, 0.04615979f, 
    -0.00730951f, 0.04050218f, 0.05418044f, -0.03055912f, -0.06176793f, -0.07468069f, -0.06096828f, -0.06015145f, 
    -0.03796385f, -0.05945691f, 0.05911271f, 0.01403463f, -0.03426493f, 0.02578622f, -0.08015776f, -0.04528325f, 
    -0.05615795f, 0.02116797f, 0.05621530f, -0.06891781f, 0.03732610f, 0.01658842f, -0.02928192f, 0.03812114f, 
    0.03470632f, -0.07366437f, -0.06249548f, 0.00140842f, -0.05119729f, 0.01820228f, -0.07229315f, -0.00746315f, 
    0.04542162f, 0.01211539f, -0.01371743f, 0.02269208f, -0.05812170f, -0.06882714f, -0.06348548f, -0.02106300f, 
    0.05162981f, -0.01012955f, 0.04948226f, 0.05795782f, -0.05964549f, -0.00564096f, -0.06002189f, 0.01646909f, 
    0.06370672f, 0.02682815f, 0.02519077f, 0.02413877f, 0.00833456f, -0.06235183f, 0.05107589f, -0.06861798f, 
    -0.00489590f, -0.07638305f, 0.05992755f, -0.00497595f, -0.03189677f, 0.03503466f, -0.00671607f, -0.00022105f, 
    -0.07957778f, 0.04899795f, -0.06645148f, 0.06102779f, -0.06816141f, -0.02383497f, -0.04888199f, -0.05023945f, 
    0.03607760f, -0.07684692f, -0.05026395f, -0.05518787f, 0.02797970f, -0.06233069f, 0.05040262f, -0.01921758f, 
    0.04552072f, -0.02958937f, 0.02044552f, -0.00090335f, -0.03258925f, -0.07033604f, -0.01148351f, 0.00921050f, 
    -0.06708949f, -0.02409155f, 0.00904336f, 0.01228265f, -0.03349680f, 0.00642148f, -0.03936291f, 0.05200763f, 
    0.01233047f, 0.05824558f, -0.03975770f, -0.06275227f, -0.05883821f, 0.03943870f, -0.05281547f, 0.00253969f, 
    0.04475328f, -0.05968181f, -0.04386841f, -0.01788462f, -0.01245010f, -0.00560694f, -0.07354982f, -0.00112194f, 
    -0.04446069f, -0.02104294f, 0.01693927f, 0.06248122f, -0.04402884f, 0.05519012f, -0.00489142f, 0.01432598f, 
    -0.04115639f, -0.00743961f, 0.03064753f, -0.03320806f, 0.05202105f, -0.07787862f, -0.01238666f, -0.03313391f, 
    -0.07166896f, 0.03973827f, -0.01536635f, -0.02415098f, -0.04859971f, -0.01332287f, 0.02738436f, 0.05473043f, 
    -0.07151689f, -0.05206729f, 0.02876646f, -0.02829491f, 0.01124021f, 0.04778414f, -0.07992662f, -0.06705669f, 
    0.01544965f, -0.03015560f, -0.03000535f, -0.03488534f, -0.03608308f, -0.04886861f, -0.04823430f, -0.03085250f, 
    -0.01660885f, -0.07206903f, -0.02758253f, -0.00918286f, 0.05123526f, -0.05698356f, -0.04888801f, -0.08019789f, 
    -0.02496070f, -0.00313772f, 0.02232034f, -0.00468335f, -0.02942430f, -0.08200270f, -0.07913811f, 0.05124822f, 
    0.03804189f, -0.00891857f, -0.03616178f, 0.05302119f, -0.01843431f, 0.01492520f, -0.04445278f, 0.02026107f, 
    0.00950851f, -0.03202101f, -0.06552286f, 0.02681089f, -0.06665323f, 0.02596755f, 0.03231128f, 0.03435210f, 
    -0.04984112f, 0.03795201f, 0.02048785f, 0.01820641f, 0.04053259f, -0.03397733f, 0.04289294f, -0.05819317f, 
    -0.01328106f, -0.03906366f, 0.01364986f, -0.06700515f, -0.01089177f, 0.03900565f, 0.00748403f, -0.07076448f, 
    -0.01600871f, 0.04726135f, -0.06632240f, -0.04923943f, 0.04996229f, 0.03677155f, 0.05277311f, 0.03933140f, 
    0.00039419f, -0.05467835f, 0.04381330f, -0.02167970f, -0.05328254f, 0.06033570f, 0.04846284f, -0.00397069f, 
    0.01740419f, 0.04063540f, 0.02523577f, -0.06188836f, -0.06147320f, -0.01677440f, -0.05256941f, -0.02536757f, 
    -0.03536601f, -0.05842985f, -0.00762531f, -0.00011253f, -0.06233616f, -0.06717774f, -0.00524471f, -0.05406703f, 
    -0.00874720f, -0.04092471f, -0.01280869f, -0.08036476f, -0.06012414f, -0.04873408f, -0.07408348f, -0.01628854f, 
    0.03553754f, 0.05167072f, -0.00475782f, -0.01356024f, -0.04965705f, -0.06091931f, -0.03754670f, -0.02130464f, 
    0.04221766f, -0.05931363f, 0.03974133f, 0.03756052f, -0.04379929f, -0.07856348f, -0.05900339f, -0.03272123f, 
    0.02678927f, -0.02392910f, -0.04269092f, 0.05082241f, 0.05585768f, 0.04681645f, -0.08279360f, -0.00472329f, 
    -0.03731469f, 0.04502085f, -0.06158184f, -0.01581804f, -0.00438044f, 0.03463014f, 0.04270699f, 0.03727075f, 
    0.04922107f, 0.00848406f, -0.03119127f, 0.01804623f, -0.06277222f, -0.00874722f, 0.06136407f, 0.02341009f, 
    -0.06574109f, -0.07451674f, -0.00786989f, 0.01404919f, 0.05223281f, 0.00672998f, -0.06838046f, -0.05114974f, 
    -0.01443160f, -0.07522669f, 0.05306299f, -0.00547991f, -0.06931677f, 0.02048102f, -0.00997062f, 0.04295234f, 
    -0.07130549f, -0.06760532f, 0.04635952f, -0.05174782f, 0.04832120f, -0.06075294f, 0.02263333f, 0.01364383f, 
    0.17436391f, 0.15194692f, -0.00686877f, 0.04515517f, -0.01749199f, -0.05920176f, -0.01801002f, 0.07170650f, 
    -0.09805779f, -0.07638849f, -0.00666289f, 0.06009120f, 0.45670769f, 0.14272219f, -0.01623219f, 0.06258703f, 
    0.16363320f, -0.15705416f, 0.13048206f, 0.02782759f, -0.17084235f, 0.10013036f, 0.07259085f, -0.07069559f, 
    0.37852338f, -0.16681586f, 0.20442553f, -0.27281213f, -0.23172721f, 0.19750895f, -0.04073902f, -0.13182408f, 
    -0.16269891f, -0.01811467f, -0.12957591f, 0.02995841f, -0.05732084f, 0.05777562f, 0.16818711f, 0.19741292f, 
    -0.06104739f, 0.29840055f, -0.12720928f, -0.19008380f, -0.06317676f, -0.03752423f, 0.04063790f, 0.06166626f, 
    -0.00174067f, 0.25112692f, 0.24430539f, 0.02421895f, 0.06726149f, -0.07461119f, -0.05258249f, 0.14539051f, 
    -0.00458193f, -0.05950252f, 0.04212345f, 0.07187696f, 0.07329649f, -0.24659741f, -0.07844609f, 0.00905895f, 
    0.00259497f, 0.20990944f, 0.05117425f, 0.03172208f, 0.09755754f, 0.04434659f, 0.04280560f, 0.09117196f, 
    0.10176630f, 0.10435364f, -0.06317112f, 0.18190572f, -0.04306673f, -0.06950389f, -0.02235316f, -0.11539003f, 
    0.04931048f, 0.17582072f, -0.00867933f, 0.07451921f, 0.14895947f, 0.25637859f, -0.14373869f, -0.14915766f, 
    0.07005196f, 0.06073862f, 0.04530967f, 0.02432292f, 0.08946156f, -0.07274931f, 0.08419612f, -0.15624580f, 
    0.27089614f, -0.06197311f, 0.06303829f, -0.22705883f, 0.07595333f, -0.10809703f, 0.01307637f, 0.02863424f, 
    0.11532712f, 0.08516750f, 0.05098618f, 0.01883951f, -0.36505562f, 0.20574354f, 0.04223743f, -0.09551688f, 
    0.00257877f, 0.16203915f, 0.09697989f, 0.03160139f, -0.01993478f, -0.04428796f, -0.04118617f, 0.07755534f, 
    0.17667417f, -0.00357712f, 0.04906121f, -0.36942610f, -0.08568212f, -0.07120806f, 0.16633187f, -0.07589001f, 
    0.02735106f, 0.02609696f, -0.10022877f, 0.04123554f, 0.18038177f, 0.08275963f, -0.00786051f, -0.08441008f, 
    -0.04207539f, 0.03173914f, -0.01622501f, -0.04900942f, 0.08846278f, 0.01466168f, -0.05915786f, -0.00506548f, 
    -0.23362206f, -0.03968837f, 0.00605412f, 0.23072015f, 0.12959035f, 0.04681883f, 0.03521878f, -0.09147920f, 
    -0.09487686f, -0.08255090f, -0.04422980f, -0.00709559f, 0.02846603f, -0.01007930f, -0.20468009f, 0.50721842f, 
    -0.02071720f, 0.21463065f, 0.17357239f, 0.02884789f, 0.20911512f, -0.15722172f, 0.04538840f, -0.07908728f, 
    0.34989974f, 0.36363918f, 0.06049774f, -0.09229454f, -0.08282220f, -0.02993490f, -0.00290719f, -0.01044855f, 
    0.08268259f, 0.15602086f, 0.08256648f, 0.01274646f, -0.09101710f, 0.08280981f, -0.27527526f, -0.04175279f, 
    -0.11944479f, -0.04204611f, 0.11709391f, 0.03358587f, -0.13913147f, -0.07761607f, -0.04439085f, -0.00738671f, 
    -0.03690895f, -0.02695741f, -0.00453648f, 0.01910906f, -0.05506179f, -0.05404484f, -0.03754297f, 0.05131304f, 
    -0.02352807f, 0.04131457f, -0.01798963f, -0.06197792f, 0.06372129f, -0.02835762f, 0.03849220f, 0.01395963f, 
    0.02519591f, -0.06988419f, -0.01701825f, -0.01219424f, 0.04631751f, -0.02563100f, -0.07079034f, -0.02285100f, 
    0.04957201f, 0.01014369f, -0.00542574f, 0.05945210f, 0.05293547f, -0.07343681f, -0.04086396f, 0.04143380f, 
    -0.06686599f, -0.06434196f, -0.02298325f, -0.01890101f, -0.06028856f, -0.00271147f, -0.05507264f, 0.03274965f, 
    -0.05396688f, 0.02275036f, 0.02876944f, 0.00199346f, 0.04338563f, -0.04722248f, -0.04339208f, -0.05636347f, 
    0.01515475f, -0.03453319f, -0.05657242f, 0.06411833f, -0.04677851f, 0.03066221f, -0.00378332f, 0.03138746f, 
    -0.03530303f, -0.02061246f, -0.01172575f, 0.05459776f, -0.02578535f, -0.07864171f, 0.00225312f, -0.04109956f, 
    0.00082315f, 0.04342458f, 0.04595441f, 0.02987696f, 0.00022871f, -0.06513540f, -0.02911340f, -0.04605635f, 
    0.06443983f, -0.06623843f, 0.04448480f, 0.00224309f, 0.04294321f, 0.04143531f, 0.06191758f, -0.02045007f, 
    -0.00339154f, -0.01364749f, -0.02068878f, -0.01836909f, -0.06854355f, -0.04411103f, -0.01859535f, -0.03133124f, 
    0.02843644f, -0.03248129f, 0.04427116f, -0.01279161f, 0.03453660f, 0.03428688f, 0.04498548f, 0.04906184f, 
    -0.01342759f, 0.04943436f, 0.03748517f, -0.03373397f, 0.03945477f, -0.01983201f, -0.01376478f, -0.04866298f, 
    0.04935933f, -0.01103177f, 0.06506978f, -0.04438710f, -0.06967658f, -0.03197088f, 0.00229754f, -0.06827246f, 
    -0.05651939f, 0.02254109f, 0.05209210f, 0.02827098f, -0.04151667f, 0.00346443f, -0.01597088f, 0.04467130f, 
    -0.06548404f, -0.06293851f, -0.02891267f, -0.00693531f, -0.06730389f, 0.06330016f, 0.02743906f, 0.02475005f, 
    -0.04788348f, -0.05346669f, 0.00446994f, 0.02689531f, -0.04289044f, 0.06135291f, 0.06991889f, -0.07047603f, 
    0.03551134f, -0.04102086f, 0.05572024f, 0.00995383f, 0.05495708f, -0.07360715f, -0.02332356f, 0.02212331f, 
    -0.00626401f, 0.01651462f, -0.00735497f, -0.00196432f, -0.06651228f, 0.02473840f, -0.03543541f, 0.02007577f, 
    -0.03060012f, 0.00492730f, -0.04936357f, -0.03533714f, -0.02505781f, 0.02062074f, 0.02165400f, 0.03686168f, 
    0.04974399f, -0.05751070f, 0.03060773f, 0.01264044f, 0.02642464f, 0.03316429f, -0.04308457f, -0.01432269f, 
    0.00285282f, -0.01399425f, -0.07592506f, 0.05477019f, -0.06795826f, -0.06682220f, -0.06234263f, -0.06888792f, 
    0.00640490f, -0.00444513f, 0.04006650f, -0.03657609f, -0.01459821f, 0.01116123f, -0.01505984f, 0.01076818f, 
    -0.02425362f, -0.04547618f, 0.00030409f, 0.05388561f, -0.05761198f, 0.00727240f, -0.06917940f, -0.06475008f, 
    -0.06815860f, 0.07114702f, 0.00045940f, 0.12822860f, 0.05543229f, -0.00912011f, -0.01316776f, -0.02364809f, 
    0.22722654f, 0.16886632f, 0.22350240f, 0.10418107f, -0.20175123f, -0.18327041f, -0.18534456f, -0.01054457f, 
    0.04079014f, 0.04557424f, 0.17132834f, 0.11340915f, 0.13342562f, 0.07087345f, 0.02788417f, -0.01647422f, 
    0.20722644f, 0.00432102f, -0.46525705f, 0.45082229f, 0.16631946f, -0.11489583f, 0.00753570f, 0.07000107f, 
    0.34094557f, 0.05995423f, 0.27464822f, 0.09858432f, -0.13141929f, -0.20404489f, -0.01271231f, -0.04903150f, 
    0.09842438f, 0.04708903f, 0.05135201f, 0.09489381f, 0.09223390f, 0.06908113f, 0.08774044f, 0.10022161f, 
    -0.16568345f, 0.02316976f, -0.14757803f, 0.02075467f, 0.23150429f, -0.03907224f, 0.02358144f, 0.01990439f, 
    0.15220019f, 0.15490174f, 0.06591134f, 0.02498500f, -0.23305777f, -0.14286785f, 0.02553278f, 0.08155927f, 
    -0.09678628f, -0.00993287f, -0.07993860f, 0.00718845f, -0.03695835f, -0.03482750f, -0.19793452f, -0.04022624f, 
    0.01061766f, -0.22165658f, 0.30214688f, 0.13275139f, 0.03012285f, 0.17610058f, 0.05223694f, 0.14477058f, 
    -0.13815434f, -0.13339506f, -0.15291192f, -0.32942683f, -0.20021522f, -0.06749480f, 0.09973241f, 0.07566924f, 
    -0.09469306f, -0.03388866f, 0.05244044f, 0.05775194f, 0.03522662f, 0.04273873f, 0.24336360f, 0.06859145f, 
    -0.06381718f, 0.35750094f, -0.01801054f, 0.09376499f, -0.14162886f, -0.01355436f, -0.12130143f, -0.02080948f, 
    -0.00105035f, -0.17588647f, 0.04079446f, 0.03521277f, 0.18840721f, 0.19681102f, 0.33923069f, 0.07479622f, 
    -0.07721289f, -0.00058892f, 0.21406698f, 0.04360743f, 0.01942147f, -0.09494691f, 0.02528381f, -0.09403504f, 
    -0.06926598f, -0.13434944f, -0.11453654f, 0.06073141f, -0.07749949f, -0.02496164f, 0.01840140f, 0.04678736f, 
    0.29139233f, 0.14092879f, 0.24388358f, 0.05987045f, 0.24748519f, 0.11195255f, -0.14051908f, -0.03401186f, 
    0.05149892f, -0.12179445f, -0.01125162f, -0.08338419f, -0.00512643f, -0.01336946f, 0.14508212f, 0.10210732f, 
    -0.22889514f, -0.17313012f, -0.00203214f, 0.01670896f, -0.03565223f, 0.04795147f, 0.09015688f, 0.14493951f, 
    0.03575114f, 0.10196480f, 0.05439245f, 0.06116504f, -0.46113095f, 0.08435837f, 0.46019500f, -0.01189201f, 
    -0.13373506f, 0.18299079f, -0.03991315f, 0.01077482f, 0.13157642f, 0.01517153f, -0.12551211f, 0.08542476f, 
    -0.05955568f, 0.02808893f, 0.21180597f, 0.16555111f, -0.03883274f, -0.02353425f, -0.01258966f, 0.00763515f, 
    -0.11708328f, -0.08276571f, 0.05713625f, -0.03623699f, -0.25778598f, -0.21512687f, -0.09969652f, 0.01866425f, 
    0.03872146f, -0.03297485f, 0.15137987f, 0.11778031f, 0.12249865f, 0.05378389f, 0.03197714f, -0.10852088f, 
    0.10100990f, 0.04018704f, -0.19569218f, 0.25793508f, 0.17966759f, 0.07471029f, 0.17686608f, 0.01957293f, 
    0.20262893f, 0.28475115f, 0.25568092f, 0.09994479f, 0.15333958f, 0.10679813f, 0.01017563f, 0.09024546f, 
    0.09953816f, 0.02665701f, 0.20611446f, 0.20533165f, 0.01667314f, 0.13505830f, 0.46175569f, 0.02128633f, 
    0.65359545f, -0.17760955f, -0.36507529f, 0.31761000f, 0.19445646f, 0.11787619f, 0.02319475f, 0.17769904f, 
    0.37632924f, 0.01558534f, 0.24843082f, -0.02068606f, -0.22023621f, -0.45719352f, -0.28548968f, -0.13832934f, 
    0.08169501f, 0.02603954f, 0.05933374f, -0.04803776f, 0.22448783f, -0.08371233f, 0.05062304f, 0.00317078f, 
    -0.36777464f, -0.02100098f, 0.25771159f, -0.09043074f, -0.00917863f, -0.09782603f, -0.02666932f, 0.05676425f, 
    -0.03063820f, -0.25928178f, 0.05347298f, 0.01405776f, -0.33442202f, -0.26966640f, -0.53105611f, -0.14164263f, 
    -0.05147687f, 0.07673313f, -0.05119286f, -0.07531497f, -0.09355304f, 0.20360388f, -0.06268677f, -0.16689374f, 
    -0.20212926f, -0.05922104f, 0.06091343f, 0.04066169f, 0.06572616f, 0.12446041f, -0.06422038f, 0.05672567f, 
    0.13856602f, 0.18645085f, 0.14035554f, -0.04606146f, -0.03463629f, -0.05570205f, 0.00046659f, -0.09865262f, 
    -0.10960495f, -0.16472206f, -0.03744625f, -0.07366971f, -0.13120697f, 0.07718796f, -0.04780684f, 0.04183361f, 
    0.10800131f, 0.39395776f, -0.10779110f, 0.00392297f, -0.08776587f, -0.38087770f, -0.05326735f, -0.13504285f, 
    0.04848683f, 0.18952747f, 0.09006939f, 0.10459502f, -0.25966844f, 0.30934942f, 0.25192100f, 0.00101299f, 
    0.03837667f, 0.01171056f, 0.20730902f, 0.16311407f, -0.06373571f, 0.02454472f, 0.40998560f, 0.09141995f, 
    -0.09442600f, -0.00853128f, -0.30427840f, -0.15081552f, -0.11879887f, -0.02779743f, 0.11777496f, 0.05981848f, 
    0.11733144f, -0.00957200f, 0.07961443f, 0.01688012f, 0.27545890f, 0.23906766f, -0.03622792f, -0.05673774f, 
    0.19218269f, -0.18169618f, 0.10638563f, 0.10743906f, -0.18711831f, -0.11116185f, 0.16487902f, 0.01119755f, 
    -0.35060182f, -0.31352836f, -0.21954560f, -0.27700830f, 0.03041082f, -0.01146732f, -0.02645981f, -0.18544813f, 
    -0.06155321f, -0.24432756f, -0.19758914f, -0.01376519f, -0.59045219f, 0.33466861f, 0.08745947f, 0.22020482f, 
    -0.05653100f, 0.08752828f, -0.05090200f, -0.03701100f, -0.02578982f, 0.02866760f, -0.00840722f, 0.12734337f, 
    -0.15388162f, 0.28425914f, 0.05318240f, -0.00162353f, 0.09396571f, -0.23208663f, -0.11089545f, 0.01991462f, 
    0.04728437f, 0.12387558f, 0.12351862f, 0.00108664f, -0.15042651f, -0.18301980f, 0.07228557f, 0.04869010f, 
    -0.03995431f, 0.05847563f, 0.19111894f, 0.14010675f, -0.08596272f, -0.02762899f, 0.07211617f, 0.08025465f, 
    0.02067124f, 0.01426204f, -0.09120329f, -0.07315031f, 0.01042492f, 0.05193622f, 0.03073756f, -0.02894760f, 
    0.31764442f, 0.15754375f, 0.03219404f, 0.19493268f, -0.26639244f, -0.36443472f, 0.33216438f, 0.11216656f, 
    -0.00505037f, 0.01333602f, 0.00607302f, -0.04396718f, 0.12020884f, 0.12702516f, 0.05100111f, 0.01742927f, 
    -0.06246526f, -0.35675102f, 0.02762250f, 0.29896474f, -0.00404753f, -0.07834116f, -0.45571500f, 0.11690002f, 
    -0.25863308f, 0.10433859f, 0.16513410f, 0.00910664f, -0.11418668f, -0.25810969f, 0.04231962f, 0.11171295f, 
    0.00186111f, -0.04693470f, 0.04534495f, 0.07935429f, 0.00978305f, -0.05391538f, 0.11604731f, -0.07835975f, 
    0.13370734f, -0.26223627f, -0.06049979f, 0.09895956f, 0.19374643f, 0.02423193f, 0.06703842f, 0.41726428f, 
    0.01324158f, -0.02879745f, -0.17983817f, -0.13526833f, 0.01959469f, 0.34234637f, 0.23115511f, -0.03477835f, 
    0.01521621f, -0.07407442f, -0.36627510f, -0.06433974f, 0.03111492f, -0.10200021f, -0.00132017f, -0.10429683f, 
    0.07018524f, 0.28866616f, -0.12699783f, 0.05691267f, 0.02029795f, 0.03002410f, 0.28835461f, 0.05066409f, 
    -0.00871660f, 0.00158197f, 0.20147200f, 0.01360386f, 0.03553037f, -0.15522206f, 0.04022881f, -0.11922005f, 
    0.03821963f, 0.03056900f, 0.06652440f, 0.04607138f, -0.00997299f, 0.00696402f, -0.27206814f, -0.01839357f, 
    -0.09497894f, 0.04707922f, -0.15115623f, 0.10860694f, 0.08987871f, 0.01631537f, 0.05125007f, -0.04109619f, 
    0.10250477f, -0.07694852f, -0.01911213f, -0.12993485f, -0.24330047f, 0.08533939f, 0.50197661f, 0.12196641f, 
    -0.02548343f, 0.01453717f, -0.06132668f, -0.16110750f, 0.11236579f, 0.22111261f, 0.13625374f, 0.24397466f, 
    -0.04386744f, -0.05119528f, 0.01561114f, 0.10644808f, 0.00190585f, 0.03491753f, -0.09871786f, 0.02259805f, 
    -0.04619837f, 0.05592735f, -0.07247538f, -0.02201584f, -0.03975243f, -0.33088958f, -0.31596589f, 0.12843530f, 
    0.14543048f, 0.10557511f, 0.00691915f, 0.07473238f, -0.12357339f, -0.08234403f, 0.01842721f, 0.04129666f, 
    -0.20555882f, -0.31651682f, -0.10224943f, 0.12111112f, -0.13457654f, -0.05238848f, 0.03769789f, -0.09958456f, 
    0.09457140f, 0.00970241f, 0.01548780f, 0.01527297f, -0.03736528f, 0.28651309f, 0.44624260f, 0.04407091f, 
    -0.07243397f, -0.14339167f, -0.05118177f, 0.02950776f, -0.09372416f, 0.05939279f, 0.06796703f, 0.09425938f, 
    -0.09334484f, -0.10034153f, 0.02952953f, 0.02276044f, -0.00556650f, 0.14191432f, 0.13825466f, 0.20416486f, 
    0.01793261f, 0.00833751f, -0.09519650f, -0.05429773f, -0.05711433f, -0.12819102f, 0.37161404f, 0.09540744f, 
    -0.07005875f, 0.04133696f, -0.19657637f, 0.13068324f, 0.05266251f, -0.00923872f, 0.01696698f, 0.13370927f, 
    -0.14865917f, -0.06096660f, 0.05470826f, -0.11074249f, 0.00844090f, -0.09207420f, -0.01029967f, -0.14934161f, 
    0.14214467f, -0.00481851f, 0.05586115f, 0.25751439f, 0.50016034f, 0.04181165f, 0.04092010f, -0.10123375f, 
    -0.08088570f, 0.16806449f, -0.18776551f, 0.02300422f, -0.07032676f, -0.04464422f, -0.05682823f, 0.13483599f, 
    0.06606541f, 0.11666385f, 0.06673893f, 0.10327277f, 0.14198762f, 0.09253718f, -0.03420530f, -0.05616022f, 
    -0.07850834f, -0.00944644f, -0.06134627f, 0.09931225f, 0.09927412f, 0.21131685f, 0.13359213f, 0.09917451f, 
    -0.09028386f, 0.01388539f, 0.14247526f, 0.21809062f, -0.06799896f, 0.05144790f, 0.02277578f, -0.02789707f, 
    -0.11926155f, -0.00113766f, -0.11822080f, -0.03170667f, 0.01025543f, 0.08879856f, 0.05751896f, 0.27373609f, 
    -0.12527213f, -0.13654275f, -0.08674577f, -0.12267340f, 0.22511640f, 0.16646071f, 0.30657583f, 0.10847478f, 
    0.02473976f, 0.20970441f, 0.13788778f, 0.07212525f, 0.04442760f, 0.23302980f, 0.10000657f, 0.03763228f, 
    -0.19460402f, 0.05821982f, -0.05652658f, 0.01594648f, 0.04252015f, 0.01920755f, 0.06691837f, -0.00865218f, 
    0.13956930f, -0.02081663f, 0.04077977f, 0.29128230f, -0.20043190f, -0.26958051f, -0.15950756f, -0.04946236f, 
    0.01719053f, 0.01547605f, -0.13109981f, 0.01908660f, 0.01018187f, -0.15922193f, 0.11664464f, -0.11667681f, 
    -0.57036370f, -0.32259998f, -0.14052024f, -0.05031066f, 0.12200143f, 0.00063902f, 0.15524264f, 0.07752478f, 
    -0.00177835f, -0.05444869f, 0.13388865f, 0.07739829f, 0.32540229f, 0.01602463f, 0.19522540f, 0.18836653f, 
    0.10291713f, -0.17503653f, -0.17283915f, 0.12164448f, 0.02303306f, 0.05089760f, -0.02640775f, 0.19498225f, 
    -0.05813894f, -0.10216205f, -0.07568196f, -0.11716940f, -0.01693106f, -0.05671384f, 0.00572015f, -0.08134577f, 
    -0.17211050f, -0.03940232f, -0.07616194f, -0.02845713f, -0.28485534f, -0.33059534f, -0.21384415f, -0.11627947f, 
    0.08825670f, 0.14970358f, 0.05114367f, 0.09135665f, 0.08739923f, -0.15943137f, -0.08801373f, -0.15432590f, 
    0.16237970f, 0.27221748f, 0.06539050f, 0.19732383f, -0.07211944f, 0.13609670f, 0.05243466f, 0.16473520f, 
    -0.05378867f, -0.01734071f, -0.09600801f, -0.07461164f, 0.54166728f, -0.04501294f, 0.26967087f, -0.15795568f, 
    -0.04602184f, -0.00661484f, 0.13282214f, -0.09309977f, -0.18167073f, -0.06927229f, -0.02387152f, -0.05813608f, 
    -0.50401789f, -0.28840318f, -0.30913183f, -0.35445040f, 0.15869023f, 0.04062099f, -0.01015413f, 0.14058559f, 
    0.03865975f, 0.01883012f, 0.03532826f, -0.04890298f, 0.54807019f, 0.21887918f, 0.29069436f, 0.18268956f, 
    0.08305495f, -0.02523074f, 0.09472772f, -0.03124857f, 0.08795177f, -0.01561363f, 0.07909182f, 0.20530646f, 
    -0.05763701f, -0.04308952f, -0.14995472f, -0.05713268f, -0.11670195f, -0.08461098f, 0.11170850f, 0.00280704f, 
    0.03741512f, 0.03654616f, 0.08228563f, 0.25312173f, -0.03099456f, 0.04310599f, 0.63113213f, 0.30128315f, 
    -0.10580982f, 0.03012172f, 0.08738712f, -0.05923050f, 0.28371567f, 0.29844427f, 0.27112335f, 0.20997854f, 
    0.23526452f, 0.01437103f, 0.50480711f, -0.25109348f, 0.07156882f, -0.04873632f, -0.04891198f, 0.10950968f, 
    0.12069470f, 0.09096517f, 0.00880949f, -0.24420026f, 0.20100318f, 0.06314924f, -0.02042534f, -0.05991779f, 
    0.03671791f, 0.07555556f, 0.10588498f, -0.16803350f, 0.05197095f, 0.06346242f, 0.03840147f, -0.01233564f, 
    0.03525445f, -0.47982448f, -0.11540257f, -0.00316841f, 0.00860803f, 0.16287205f, 0.15163280f, -0.03094898f, 
    -0.17389303f, -0.13551374f, -0.36883610f, -0.39457509f, 0.56332219f, 0.72258693f, -0.16563895f, -0.36855567f, 
    -0.21051008f, -0.15631714f, -0.07925170f, 0.02399382f, -0.05321748f, -0.00837940f, -0.04692416f, -0.28176382f, 
    0.00648792f, 0.31049886f, -0.18085745f, 0.11652505f, 0.07031763f, -0.05790824f, 0.31563476f, -0.02248968f, 
    0.16357981f, 0.28756890f, 0.36071071f, 0.21966095f, 0.22765243f, 0.00015372f, -0.03898425f, -0.10377731f, 
    -0.04091570f, 0.08585396f, 0.14437698f, -0.05890746f, -0.14849879f, -0.01484221f, -0.18211889f, 0.10467471f, 
    0.19927932f, -0.01658313f, 0.07952259f, 0.01871825f, -0.02068535f, 0.21297191f, -0.00885243f, -0.01707626f, 
    -0.05069966f, 0.08061677f, 0.01104218f, 0.26841956f, -0.18515088f, 0.02056554f, -0.00255547f, 0.00853451f, 
    0.07774864f, 0.15075569f, 0.13552576f, 0.02213718f, 0.18994011f, 0.16053027f, 0.15887064f, 0.38283661f, 
    0.07971591f, 0.01349983f, 0.23136230f, -0.10648265f, -0.06954917f, 0.02630207f, -0.22781055f, -0.02730753f, 
    -0.03180981f, -0.07075305f, -0.06961656f, -0.00439618f, -0.36662245f, -0.12169728f, 0.02962156f, -0.08237352f, 
    0.11881713f, 0.21689318f, -0.17135984f, -0.13003328f, -0.44993672f, -0.15163618f, -0.34308752f, -0.09421869f, 
    0.03861465f, -0.04366810f, -0.19169289f, -0.22305761f, 0.21464157f, 0.09599321f, -0.01921638f, -0.08497826f, 
    -0.05218961f, -0.20584105f, -0.01429186f, 0.15113212f, 0.10006697f, 0.03741392f, -0.12889856f, 0.33633929f, 
    -0.20474970f, -0.24629557f, -0.06843360f, -0.23952360f, 0.00300820f, 0.05620661f, -0.03758507f, 0.02904358f, 
    -0.06732368f, -0.17548992f, -0.00866070f, 0.20269148f, -0.02596599f, 0.03904586f, 0.12894249f, 0.10905299f, 
    -0.11650609f, -0.05396302f, -0.06850513f, -0.09129304f, -0.02174856f, 0.32742503f, 0.40841356f, 0.06808255f, 
    -0.12521450f, 0.18549870f, -0.07274498f, 0.01543568f, 0.00377125f, 0.03987213f, 0.04604850f, 0.14745753f, 
    -0.01773453f, -0.28670269f, -0.25602415f, -0.19146164f, -0.02448014f, -0.01633653f, 0.03912206f, 0.22107132f, 
    0.10460645f, 0.00040301f, 0.06482255f, -0.11253265f, -0.65585083f, 0.01238800f, 0.20427965f, 0.08294991f, 
    -0.00156309f, -0.16883838f, 0.16723666f, 0.12896805f, 0.06756446f, 0.13357741f, 0.10244082f, 0.18705189f, 
    0.02936323f, -0.02007105f, 0.52174091f, 0.06296331f, 0.08058715f, 0.03399262f, -0.25957492f, 0.14782754f, 
    -0.00877864f, 0.13660659f, -0.02905511f, -0.14109761f, 0.09171853f, 0.15397400f, 0.28964064f, 0.21762736f, 
    0.07624960f, 0.07546603f, -0.01765607f, -0.02287416f, 0.03850396f, 0.00387453f, 0.05717904f, -0.14494672f, 
    0.38945016f, -0.17481337f, 0.10068482f, 0.27067426f, 0.01371252f, 0.20984538f, 0.04992210f, 0.06372920f, 
    -0.06802350f, -0.17104673f, -0.16422316f, -0.24183798f, 0.27822524f, 0.26583090f, 0.21798706f, -0.03777408f, 
    0.04294470f, 0.03570972f, -0.03706624f, 0.00786698f, -0.01507791f, -0.04084040f, -0.02540040f, -0.24243580f, 
    0.16010131f, 0.15585078f, -0.01352279f, 0.05523223f, 0.01121701f, 0.09710108f, 0.14620090f, -0.03159918f, 
    0.02768570f, 0.08812042f, 0.21975867f, -0.09571163f, 0.00600904f, -0.07161012f, 0.02572224f, -0.12963301f, 
    -0.00257686f, 0.08820449f, -0.01028061f, 0.06872737f, -0.00018340f, 0.05420594f, -0.18686773f, -0.01643453f, 
    0.00782349f, -0.19375668f, -0.13087583f, 0.04352426f, 0.10245191f, 0.17936465f, -0.03823854f, -0.03444450f, 
    -0.02188361f, -0.04565807f, 0.00958868f, 0.12694530f, -0.29393950f, -0.02104616f, -0.18471816f, -0.08413457f, 
    -0.02848463f, 0.20471469f, 0.07295963f, 0.01563955f, -0.00817100f, -0.04080155f, 0.20473270f, 0.17074338f, 
    -0.23764786f, 0.08669231f, -0.02024959f, 0.22483902f, 0.07874510f, 0.05051661f, -0.20021941f, 0.00512892f, 
    -0.02545539f, 0.20396464f, -0.00474748f, 0.00061335f, -0.15036015f, 0.00689101f, 0.24642606f, 0.28544772f, 
    0.08177297f, 0.02899181f, -0.09396434f, -0.01821382f, -0.06896533f, -0.00716325f, -0.22783054f, 0.10566153f, 
    0.13883576f, -0.14170216f, 0.00443253f, -0.02128397f, 0.03920483f, -0.18332776f, 0.06290428f, 0.00935946f, 
    0.14886488f, -0.09489973f, 0.05945287f, 0.15851805f, -0.35324976f, 0.24241130f, -0.10791084f, 0.22466221f, 
    0.20959370f, -0.09384184f, -0.04714286f, -0.01097748f, -0.12319698f, -0.03397537f, 0.17321014f, 0.04040927f, 
    0.13638234f, -0.41772136f, 0.09791671f, 0.23953350f, 0.07625762f, 0.03853319f, 0.02402667f, 0.08215991f, 
    -0.07919718f, -0.06178649f, -0.01179324f, -0.03952533f, -0.30436707f, 0.07058370f, 0.06750277f, -0.11227019f, 
    0.13386971f, 0.18681559f, 0.09798812f, 0.32115281f, -0.20847087f, 0.01552444f, -0.05135008f, -0.01890145f, 
    0.17440654f, 0.00827578f, 0.17480227f, 0.19013320f, 0.04488809f, -0.05738876f, -0.08941054f, -0.13320728f, 
    0.04753768f, 0.12175203f, 0.26459369f, 0.02333873f, 0.20179853f, 0.05907848f, 0.05737578f, -0.14039673f, 
    0.11862636f, 0.00894250f, 0.00208277f, 0.19836003f, 0.21130072f, 0.01040987f, 0.06172085f, 0.08181144f, 
    0.05296770f, -0.04438658f, -0.06008810f, 0.03682544f, 0.09323277f, -0.01986923f, 0.33625749f, -0.09742535f, 
    0.23063128f, -0.14542812f, 0.02824846f, 0.09055743f, -0.04070512f, 0.13358745f, 0.07353333f, -0.22090463f, 
    0.15345240f, -0.01013381f, 0.14161938f, -0.01003826f, 0.04858665f, -0.02291352f, -0.02593826f, 0.20885131f, 
    -0.17022343f, -0.06673255f, -0.14467345f, -0.35686207f, -0.01802003f, 0.05922532f, -0.07967509f, -0.07827136f, 
    -0.03463221f, -0.02334085f, 0.02946730f, 0.15234408f, 0.05450728f, -0.13143368f, -0.21978435f, -0.09596813f, 
    0.01686399f, -0.02221856f, 0.12161310f, 0.01048455f, 0.00860924f, 0.00103697f, -0.12472492f, 0.04386413f, 
    -0.12295780f, -0.04025381f, -0.09619020f, 0.18758814f, 0.05532533f, -0.01087446f, 0.05096820f, -0.02947180f, 
    0.01726753f, 0.01309615f, -0.21364857f, -0.13813917f, -0.11327865f, 0.01851078f, -0.01209860f, 0.09961509f, 
    -0.14283617f, -0.05537465f, -0.00042455f, -0.08960992f, 0.10959206f, -0.14904702f, 0.24964169f, 0.05211046f, 
    0.14520907f, 0.02571359f, 0.07852782f, 0.12465464f, -0.11087357f, -0.06765907f, -0.01493996f, 0.03941819f, 
    -0.00475103f, -0.02827759f, 0.04511530f, -0.13174722f, 0.15518652f, 0.06121491f, 0.09113795f, -0.27634904f, 
    -0.12751992f, -0.18021813f, 0.10292807f, 0.09239187f, 0.04421580f, -0.05457522f, 0.03976697f, -0.10763485f, 
    0.23199157f, -0.14676470f, 0.10895067f, 0.15707840f, -0.12191948f, -0.11174286f, 0.04203718f, 0.07786483f, 
    0.22580431f, 0.15805185f, 0.13851622f, 0.02879569f, 0.06115895f, 0.14660719f, 0.00995725f, -0.05863625f, 
    0.02460831f, 0.05408544f, 0.05394262f, 0.03183805f, -0.02461050f, 0.05728028f, 0.06571236f, -0.05341043f, 
    -0.07394005f, 0.35108817f, 0.07317680f, -0.00806832f, 0.10416925f, 0.12556174f, 0.06012223f, 0.18841039f, 
    0.02614404f, 0.10959029f, -0.05391711f, 0.09044793f, 0.23848169f, -0.12091439f, -0.00447579f, -0.43571436f, 
    -0.04148949f, 0.14452691f, -0.03876590f, -0.04701009f, 0.17087281f, 0.01844161f, -0.11809459f, -0.03212451f, 
    -0.08862649f, -0.03245590f, -0.31472540f, 0.14038397f, 0.01846984f, -0.03863912f, 0.07288162f, -0.13943662f, 
    0.07553406f, -0.05269789f, 0.06361044f, 0.00725248f, -0.07156982f, -0.27430061f, 0.13194135f, 0.03530553f, 
    -0.02191775f, -0.03309171f, -0.10965872f, 0.11133850f, 0.04723034f, -0.04153879f, 0.08085935f, 0.13560146f, 
    0.05063320f, 0.01528471f, -0.03288646f, -0.14243105f, 0.05435370f, -0.03836118f, 0.12223757f, -0.02727464f, 
    -0.02687318f, 0.06074857f, -0.08950686f, -0.30464649f, -0.03905237f, 0.24458230f, -0.42462128f, -0.08950860f, 
    0.10854967f, 0.14572181f, -0.06710441f, 0.07641115f, 0.04993272f, -0.09758346f, -0.04157355f, 0.05612397f, 
    -0.05897193f, 0.25303417f, -0.38966635f, 0.40816787f, 0.17549090f, 0.19264498f, -0.07743993f, 0.02600040f, 
    0.02985063f, 0.22537160f, 0.17779960f, 0.08620143f, -0.23210771f, -0.02433782f, 0.02774560f, 0.36377203f, 
    -0.12162848f, -0.04329485f, -0.05321743f, 0.23148483f, 0.04734998f, 0.06715477f, -0.08107967f, 0.00071409f, 
    0.05384545f, 0.07258670f, 0.14691919f, 0.24323346f, -0.07836482f, -0.05293567f, 0.08038878f, -0.10030204f, 
    -0.08751004f, -0.05643465f, 0.16516992f, -0.03043813f, -0.48538476f, -0.32003736f, 0.19972540f, 0.17172658f, 
    -0.08537165f, 0.03366859f, 0.09435631f, 0.06505205f, -0.10614188f, 0.06482242f, 0.09776896f, -0.03027115f, 
    0.11294112f, -0.04532931f, 0.30672345f, -0.03347388f, -0.01545512f, 0.04996048f, -0.16660830f, 0.16263829f, 
    0.04292714f, 0.07311607f, -0.07452425f, 0.04958490f, 0.09245226f, 0.02810991f, 0.00657401f, -0.02640618f, 
    -0.02173222f, -0.03781386f, -0.13847685f, 0.02113725f, -0.07375566f, 0.04522922f, -0.02409046f, -0.01968089f, 
    0.00961795f, 0.36665002f, -0.06327686f, -0.00265931f, 0.05956347f, 0.04625968f, -0.10547315f, -0.08647040f, 
    -0.10038295f, 0.05506235f, 0.04182491f, -0.07602939f, 0.06498126f, 0.05856232f, -0.04784768f, 0.20617373f, 
    0.08748434f, 0.10017437f, 0.23572086f, 0.08853418f, -0.05373885f, 0.04084026f, 0.10987124f, 0.03712691f, 
    -0.04819760f, 0.28751993f, -0.25889617f, -0.10446253f, -0.02020866f, 0.03370463f, -0.07701254f, -0.01478912f, 
    -0.15030158f, 0.03709915f, 0.12416701f, -0.01399718f, 0.26349545f, 0.11528044f, -0.00467009f, 0.11319804f, 
    0.01590461f, -0.09239168f, -0.01216882f, -0.12281460f, 0.05631907f, 0.12244947f, 0.13016459f, -0.09264389f, 
    0.06179192f, -0.15025085f, -0.02519564f, 0.09949894f, -0.09375639f, -0.01302362f, 0.03879313f, -0.05134335f, 
    0.15686725f, 0.00669858f, -0.08024846f, -0.06868880f, -0.33267999f, 0.08456989f, 0.00206933f, 0.10148884f, 
    -0.17831586f, 0.09728415f, 0.12619795f, 0.26418525f, -0.05932241f, 0.01683311f, 0.00163167f, 0.15302357f, 
    0.12533247f, 0.33283570f, 0.27881685f, -0.02086363f, 0.03418108f, -0.00153163f, -0.09870644f, -0.05513155f, 
    -0.02812496f, 0.01898536f, 0.00361623f, 0.05420437f, 0.16291757f, -0.24940583f, -0.29472151f, -0.24112988f, 
    0.07231759f, -0.18328749f, 0.06063318f, -0.04572624f, -0.00930519f, -0.00316356f, -0.00038345f, -0.03098334f, 
    -0.00957195f, 0.11946999f, -0.01607547f, 0.00154845f, -0.03684406f, -0.01056116f, -0.09290880f, 0.03375539f, 
    0.06463159f, -0.09199111f, 0.13534039f, 0.15277724f, -0.18287469f, -0.09958567f, 0.53776586f, 0.14987557f, 
    -0.00106862f, 0.05105635f, 0.15156066f, 0.01914227f, -0.10033206f, 0.19619673f, 0.04540138f, -0.14958550f, 
    0.07301562f, 0.21146125f, 0.28364232f, -0.06762142f, -0.16952008f, -0.11854399f, -0.11378897f, 0.10552515f, 
    0.04359618f, 0.18820240f, 0.15634941f, -0.02161482f, -0.02655762f, -0.03286948f, -0.03989284f, -0.08814687f, 
    0.10647281f, 0.12356375f, 0.03581120f, -0.20875703f, 0.06991438f, 0.14862640f, 0.16997287f, 0.06996248f, 
    -0.13132846f, -0.09551289f, -0.23141389f, -0.06575635f, 0.13251184f, -0.08386133f, 0.10746810f, 0.15763479f, 
    0.07028088f, 0.16587323f, -0.01264327f, 0.00425862f, 0.17150763f, 0.05899139f, -0.15658823f, -0.15576945f, 
    -0.12003782f, -0.02240975f, -0.08740242f, -0.01486750f, -0.01986342f, -0.18165603f, -0.04506269f, 0.07076240f, 
    0.01773073f, 0.05769252f, -0.04962098f, 0.02954691f, 0.16363350f, 0.06763017f, 0.13620734f, 0.09525575f, 
    -0.11592231f, -0.02854331f, 0.06154449f, -0.04189369f, -0.13369749f, -0.01619677f, -0.04698068f, -0.12711740f, 
    -0.16123562f, -0.10952788f, 0.13313650f, -0.04089716f, 0.14871746f, -0.00963567f, 0.01205849f, 0.12654975f, 
    0.22902940f, -0.12424772f, 0.16324665f, -0.05295689f, -0.10890945f, 0.05857330f, -0.14184050f, -0.06896904f, 
    0.18653676f, -0.09142773f, -0.03060639f, 0.11984657f, -0.18397078f, 0.02384374f, 0.08709390f, -0.00177998f, 
    -0.00661528f, -0.00729004f, 0.05115340f, -0.01942145f, 0.08089684f, 0.14960819f, -0.11708364f, -0.03691631f, 
    -0.02637905f, -0.27829227f, 0.24516454f, -0.07841115f, -0.07942772f, 0.03313834f, 0.00679700f, -0.07995623f, 
    0.08970226f, 0.06932630f, 0.06667381f, -0.00200886f, -0.13628255f, 0.05222478f, -0.11275594f, -0.04955414f, 
    -0.14972712f, 0.09843308f, 0.00752082f, 0.02479625f, 0.01679286f, 0.08315008f, 0.01354568f, 0.18541951f, 
    -0.33429316f, 0.02807304f, -0.08194158f, -0.11149480f, -0.02583129f, -0.08187458f, 0.13861382f, 0.05912951f, 
    -0.00265367f, 0.07763571f, 0.09524908f, 0.13448212f, 0.06836941f, -0.07011893f, 0.35471725f, 0.31582159f, 
    -0.01366806f, -0.18135418f, -0.04868381f, 0.12688729f, 0.22462413f, 0.10463519f, 0.16089803f, 0.07385547f, 
    -0.11062507f, -0.24713570f, -0.02016153f, 0.22040948f, -0.10751598f, 0.10554105f, 0.10735013f, -0.02232609f, 
    0.00433588f, 0.02060768f, -0.02558316f, 0.01167717f, -0.35971689f, 0.08782158f, 0.04063641f, -0.04225080f, 
    -0.14930329f, 0.12052230f, -0.12136383f, 0.08426415f, 0.03314333f, 0.01489277f, 0.12352420f, -0.01350761f, 
    0.12685700f, 0.00258374f, -0.00647795f, 0.06159463f, 0.05261392f, -0.02898930f, -0.17621711f, -0.16515286f, 
    0.08665409f, -0.06649935f, 0.14851654f, -0.06674243f, -0.29316917f, -0.19597809f, 0.14208859f, -0.10231922f, 
    -0.00007217f, 0.17458636f, -0.12788945f, 0.18042667f, 0.03698604f, -0.02975590f, -0.10143895f, 0.01229708f, 
    0.11764660f, -0.24604867f, 0.22594397f, 0.30223447f, 0.12682118f, -0.02742651f, -0.09407064f, 0.03492492f, 
    0.09747164f, 0.06324182f, -0.02779544f, 0.10509726f, 0.04190419f, 0.22284295f, 0.42202684f, 0.06454926f, 
    0.23991159f, -0.04079257f, 0.07159430f, 0.17810474f, 0.06388828f, -0.09061347f, 0.09369952f, -0.11625118f, 
    0.19726510f, 0.07394356f, 0.00616140f, -0.02368941f, 0.19485389f, 0.29033342f, -0.05828682f, 0.17511332f, 
    0.09794191f, -0.03381592f, 0.13345776f, 0.04522836f, -0.13239129f, 0.02173709f, 0.20845349f, -0.19790426f, 
    0.02759665f, -0.01212276f, 0.10392576f, 0.09847789f, -0.07475927f, 0.03920122f, -0.02992740f, -0.00674492f, 
    -0.08316832f, 0.21734369f, -0.35534912f, 0.24704254f, 0.16052258f, 0.07620274f, 0.03121941f, -0.02717337f, 
    0.00899733f, -0.07988177f, -0.07003495f, -0.28753841f, 0.19111912f, -0.09071786f, 0.31843734f, 0.08364186f, 
    -0.10274548f, -0.08436673f, -0.07249849f, -0.08358788f, 0.04188711f, -0.00755250f, 0.16891944f, 0.02893446f, 
    0.04492547f, -0.31431308f, -0.10795614f, 0.26328570f, -0.01116623f, 0.04453561f, -0.11961855f, 0.01275774f, 
    0.10250288f, -0.25066027f, 0.11277065f, 0.02998210f, 0.00747383f, -0.27339152f, 0.09091136f, -0.25580427f, 
    -0.11762407f, -0.20793125f, 0.05742475f, 0.10800965f, -0.01054092f, -0.21083157f, -0.07116121f, -0.15628190f, 
    0.23772036f, 0.00914774f, -0.14327702f, 0.34869874f, 0.06384613f, -0.01008930f, -0.22891527f, -0.02984612f, 
    0.20580497f, 0.16000275f, 0.19407919f, 0.00872157f, 0.02218353f, -0.21531683f, 0.16385432f, 0.31330594f, 
    0.01726960f, -0.01107925f, 0.03077159f, 0.04646849f, 0.03477668f, 0.15330671f, -0.10299946f, 0.21757424f, 
    -0.19706057f, 0.16241241f, 0.22785132f, 0.10426962f, 0.07453904f, -0.07192776f, 0.20620614f, 0.13615166f, 
    0.11131249f, -0.01055657f, 0.04264637f, 0.07235791f, 0.05748753f, -0.18888143f, 0.19818655f, -0.64625889f, 
    -0.14767569f, 0.19826613f, 0.05499354f, 0.10727866f, 0.25078532f, 0.06309210f, 0.23956056f, 0.00081717f, 
    0.12911834f, -0.09317746f, -0.41355219f, 0.29963234f, 0.08932824f, 0.00534275f, 0.04503444f, 0.10905449f, 
    0.12719581f, -0.07702084f, 0.10135075f, -0.07609353f, 0.03002635f, -0.36271265f, 0.05028000f, -0.15689763f, 
    -0.16356985f, -0.04928560f, -0.18685968f, 0.19678390f, 0.07518651f, -0.12772252f, 0.01163060f, -0.00323900f, 
    0.00779836f, -0.04308973f, 0.01064749f, 0.05457614f, -0.08350810f, 0.04646281f, 0.02293936f, 0.02832498f, 
    -0.00279290f, -0.07656552f, 0.05334109f, -0.05361819f, -0.06456617f, -0.02684522f, -0.03867449f, 0.01082267f, 
    0.05048037f, -0.01635406f, 0.03515166f, 0.03411897f, 0.05714975f, -0.07343961f, 0.00957586f, -0.01152428f, 
    0.05635717f, 0.04068933f, -0.06910250f, -0.05786994f, -0.03284404f, -0.01616842f, -0.06835053f, 0.04030067f, 
    -0.01556153f, -0.07440330f, -0.04637880f, 0.05019965f, -0.02164952f, -0.05546630f, -0.03260439f, 0.01857292f, 
    0.02485470f, -0.01058196f, 0.04777225f, 0.00551784f, -0.02507047f, 0.00339852f, 0.02635106f, -0.06319415f, 
    -0.01996767f, -0.05507713f, 0.03039066f, -0.03301346f, 0.05571333f, -0.06419781f, -0.01494833f, -0.06937122f, 
    -0.05786676f, 0.03456100f, -0.08347779f, 0.01657883f, -0.02924724f, -0.03180046f, -0.04816596f, -0.01245077f, 
    -0.01786459f, 0.01424359f, -0.06542131f, -0.07390088f, -0.07204909f, 0.00962978f, -0.05115943f, 0.03542539f, 
    -0.03802817f, -0.01295397f, -0.05998129f, 0.01271476f, -0.04988518f, -0.08020849f, -0.02369626f, -0.05223985f, 
    0.00763010f, -0.03398624f, -0.06954981f, -0.04691556f, 0.00368975f, -0.06360754f, -0.06874689f, -0.08834521f, 
    -0.04863657f, 0.01827474f, -0.05204804f, -0.07756781f, -0.02941224f, -0.00901020f, 0.04266027f, -0.03877170f, 
    0.00956376f, 0.07392461f, -0.06950549f, 0.03185436f, -0.00625899f, 0.02288552f, 0.04787041f, 0.04144407f, 
    -0.01251259f, 0.02185411f, 0.01538062f, 0.04679462f, -0.00841506f, 0.04673887f, 0.04472952f, -0.01985719f, 
    -0.06288109f, -0.05991794f, 0.03114842f, -0.05057751f, 0.03123233f, -0.04380538f, 0.02868382f, -0.04458632f, 
    -0.06331439f, -0.01102025f, -0.05160197f, -0.00026659f, 0.00261274f, -0.00684756f, 0.01513572f, -0.08616723f, 
    -0.03003252f, -0.05964491f, -0.05868332f, 0.00452040f, -0.03061775f, -0.01686817f, -0.01429180f, -0.03744314f, 
    0.00670627f, 0.01548759f, 0.02676086f, 0.02961831f, 0.03491011f, 0.02596357f, -0.03674514f, 0.05438142f, 
    -0.05778146f, 0.05914214f, -0.02300164f, -0.04005038f, -0.07828443f, 0.01051224f, -0.04175509f, -0.00194828f, 
    -0.02492948f, -0.00362234f, 0.01202066f, -0.08098656f, 0.04185088f, 0.04867991f, 0.01766376f, 0.02388347f, 
    0.01728819f, -0.00261430f, 0.02033348f, -0.02037559f, -0.05565932f, -0.07531517f, -0.00361818f, 0.03029327f, 
    -0.00178430f, -0.03524074f, 0.04622541f, -0.00616083f, -0.00738807f, -0.07723763f, 0.02735901f, -0.00775206f, 
    -0.03279405f, -0.00853960f, -0.04467454f, -0.03090942f, -0.04127013f, 0.02748784f, -0.04146201f, -0.04616479f, 
    0.05116412f, -0.06068598f, -0.07549568f, -0.04735187f, 0.05497790f, -0.04605177f, 0.02770592f, -0.04879711f, 
    0.08082579f, 0.16146144f, 0.00325400f, 0.09582166f, -0.18686156f, -0.02679439f, -0.01196538f, -0.08221733f, 
    0.00896041f, 0.01827749f, 0.05538163f, 0.14972493f, 0.52946585f, 0.00806213f, 0.14836344f, 0.12879355f, 
    -0.14379169f, 0.37312502f, -0.06661239f, -0.06919245f, 0.12380191f, 0.04111819f, 0.20231122f, 0.04510013f, 
    -0.15771250f, -0.04941689f, 0.17825049f, 0.10306067f, 0.18912719f, -0.11758130f, 0.15721034f, 0.18663135f, 
    -0.08718356f, 0.05219535f, -0.15533391f, -0.10165644f, -0.01692810f, 0.06140123f, -0.04929752f, -0.18977068f, 
    -0.00096554f, -0.06045604f, -0.05286542f, -0.01710323f, -0.17988454f, -0.02699663f, -0.01341250f, -0.05917116f, 
    0.08207018f, 0.07459954f, -0.05420981f, -0.28961825f, -0.20567882f, 0.05284709f, 0.12877263f, 0.05230165f, 
    -0.36000547f, -0.22794950f, -0.47382787f, -0.31778944f, 0.18774210f, 0.32276252f, 0.02053627f, -0.22087279f, 
    -0.07798142f, -0.02610288f, 0.14554150f, 0.03660532f, 0.06242217f, 0.07179027f, -0.03663057f, -0.06976487f, 
    -0.00526263f, 0.21958070f, -0.05459665f, -0.11473201f, -0.07267150f, -0.02611363f, 0.11489251f, 0.05594193f, 
    0.24460775f, 0.25476471f, 0.20894536f, 0.35101411f, 0.21780792f, 0.31151098f, 0.00403776f, 0.14794950f, 
    -0.13893780f, -0.16333808f, -0.27459866f, -0.21334270f, 0.05640592f, 0.10576006f, -0.03716116f, -0.10076434f, 
    0.06322186f, -0.02700059f, 0.11171475f, 0.00615417f, 0.01327108f, 0.06537866f, -0.14634879f, -0.08185858f, 
    0.09857392f, 0.25273100f, 0.27497253f, 0.07779299f, -0.06173177f, -0.09343791f, -0.00745029f, 0.02983636f, 
    0.05251088f, 0.19703370f, 0.19601831f, -0.02859318f, -0.00439886f, 0.05177264f, 0.14979076f, 0.20163788f, 
    0.08799720f, 0.06800000f, 0.06695727f, -0.12073981f, 0.02605402f, -0.22049451f, -0.34414041f, -0.01679947f, 
    -0.19422868f, -0.20454139f, -0.02358086f, -0.03867733f, -0.29039484f, 0.01926517f, 0.08483414f, 0.06039052f, 
    -0.02386634f, -0.12764898f, -0.09732729f, -0.02408940f, 0.03337088f, -0.21994402f, -0.23075269f, -0.00212992f, 
    0.01021011f, 0.20608805f, -0.12815210f, -0.04917517f, 0.05746951f, 0.01809382f, 0.04348134f, -0.07899566f, 
    -0.22467503f, -0.10815019f, 0.04167191f, -0.01575065f, 0.27013040f, -0.22906215f, -0.04297698f, -0.23796919f, 
    -0.15754239f, 0.00343910f, 0.04352877f, 0.01913312f, -0.07180166f, 0.13373423f, -0.14161363f, 0.04648117f, 
    0.17703229f, 0.33787063f, 0.20651956f, -0.16424230f, -0.01763894f, 0.13666897f, 0.04862555f, -0.03307059f, 
    0.06170472f, 0.10087965f, -0.04908086f, 0.08138222f, 0.51214397f, 0.22986460f, 0.26516905f, 0.14037234f, 
    -0.02137648f, -0.05152588f, -0.01507219f, 0.09639344f, 0.06025979f, 0.07028870f, 0.14181086f, -0.02753932f, 
    -0.20815335f, -0.29205757f, -0.30788013f, -0.06688317f, 0.11611605f, 0.16336618f, 0.13693534f, -0.10476547f, 
    0.21645039f, 0.12660821f, 0.02429463f, 0.21631911f, -0.21343285f, 0.06219330f, -0.26625594f, 0.25994104f, 
    0.04511615f, -0.21101347f, 0.32016313f, 0.03868948f, 0.07095312f, 0.12984106f, 0.18395439f, 0.24790357f, 
    0.51609671f, -0.17006247f, 0.41339144f, -0.12650523f, -0.07185349f, 0.05694731f, -0.26712349f, -0.02008749f, 
    0.09688248f, -0.20199423f, 0.05629933f, -0.05714208f, 0.51287162f, 0.21164869f, 0.18389577f, 0.01340053f, 
    0.00530279f, 0.25182873f, 0.11294765f, 0.01455025f, 0.06776468f, -0.06657919f, 0.16243380f, 0.00016675f, 
    0.33123791f, 0.06926554f, 0.36989105f, 0.15971081f, -0.01075937f, 0.09496742f, -0.04763362f, 0.02512954f, 
    -0.10140002f, -0.15157731f, -0.05591884f, -0.54534471f, 0.12402107f, 0.20599471f, 0.01111697f, -0.04549517f, 
    0.11698587f, 0.13434631f, -0.14861706f, -0.03629564f, 0.06248202f, -0.00138102f, -0.13323320f, -0.11423805f, 
    0.07590985f, 0.15483700f, 0.22228752f, 0.25253785f, -0.03975867f, 0.08942229f, 0.01934722f, -0.07869470f, 
    0.06069344f, 0.10634956f, 0.38571370f, 0.07440960f, -0.03303399f, -0.38806781f, -0.15948214f, -0.04387653f, 
    0.01458085f, -0.01268667f, 0.08542096f, -0.03434582f, -0.06384548f, 0.04833775f, -0.02542400f, -0.03854213f, 
    -0.15361881f, -0.13211355f, -0.35576117f, 0.01823576f, 0.09794755f, -0.06122956f, 0.08000114f, -0.02781580f, 
    -0.13094425f, -0.06936453f, -0.07332758f, 0.18132272f, -0.09220005f, 0.19681755f, 0.12008407f, 0.00941688f, 
    0.10424960f, 0.18288131f, 0.02666934f, 0.04448872f, 0.12589158f, -0.01690355f, 0.19878295f, 0.34733766f, 
    -0.09771037f, -0.08854398f, -0.28329569f, 0.24822073f, 0.14335945f, -0.00620236f, 0.09118305f, -0.05266227f, 
    0.14003555f, 0.01563527f, -0.06493320f, -0.14947987f, 0.05460632f, -0.15673454f, 0.26140702f, 0.01956456f, 
    0.07609615f, -0.06098048f, 0.08058643f, 0.00588457f, -0.29867908f, -0.17170201f, -0.17350982f, -0.41376939f, 
    0.17712292f, -0.07018321f, -0.03752862f, -0.14489192f, -0.05489970f, 0.03096940f, -0.05810321f, -0.04497355f, 
    -0.06821321f, -0.14725888f, -0.08311966f, -0.10084457f, -0.51717275f, 0.39926475f, -0.25104570f, 0.18525176f, 
    0.21860094f, -0.10963539f, -0.17068529f, -0.09486248f, -0.07289530f, -0.14638890f, -0.21045603f, -0.03141189f, 
    -0.01897071f, -0.10394800f, 0.30275238f, 0.01613127f, -0.01655966f, -0.27079961f, -0.11059628f, 0.15741746f, 
    0.11402231f, -0.10510099f, 0.11308964f, -0.05863951f, -0.11142711f, 0.26599473f, 0.10591506f, 0.03950343f, 
    0.17236982f, 0.07945006f, 0.22522098f, -0.02985539f, -0.20621774f, 0.04078894f, -0.12057896f, 0.21686408f, 
    -0.15414025f, -0.18102863f, -0.05133918f, -0.09971219f, -0.19353198f, -0.14303470f, -0.13404115f, -0.33045599f, 
    -0.04127717f, -0.14493257f, 0.06644443f, 0.12377691f, 0.12149744f, 0.16175006f, 0.29712412f, -0.01645432f, 
    -0.21825942f, 0.10583113f, 0.05762475f, -0.09071975f, 0.19055782f, 0.08739822f, 0.12068402f, -0.09723600f, 
    0.34736452f, 0.11193194f, 0.31729391f, -0.17410885f, 0.01766210f, 0.03191168f, -0.05622723f, -0.01374579f, 
    0.14936230f, 0.13268751f, -0.06496438f, -0.28122795f, 0.28312042f, 0.20541470f, 0.15934870f, -0.08036125f, 
    0.10927560f, 0.03110638f, 0.02083292f, 0.23244871f, -0.09815372f, 0.02629758f, 0.03526832f, -0.18766038f, 
    0.04319720f, -0.34056118f, 0.08704945f, -0.02985622f, -0.00419153f, 0.26731485f, -0.00706886f, 0.07065102f, 
    -0.28915420f, -0.10191000f, -0.38017729f, -0.54228503f, 0.38736722f, 0.56452549f, 0.15334377f, -0.35825971f, 
    0.01470771f, 0.00183386f, 0.14605784f, 0.01565565f, 0.08467361f, 0.07538922f, 0.09652212f, -0.16327681f, 
    -0.17257574f, 0.46573237f, -0.29417908f, 0.27949402f, 0.07586985f, 0.02579649f, 0.25019625f, 0.04733681f, 
    0.25352588f, 0.01863145f, 0.29968494f, 0.21773557f, 0.26979908f, -0.01916697f, 0.14545678f, 0.00826738f, 
    0.07137933f, 0.03253904f, -0.03800004f, -0.36231065f, -0.04522673f, 0.07507104f, -0.02812494f, 0.18237510f, 
    0.10178936f, 0.04842663f, 0.13512687f, 0.18598440f, 0.01486144f, 0.15282401f, -0.11577347f, 0.05492608f, 
    -0.08186996f, -0.08618630f, 0.02718030f, 0.23726696f, 0.15268147f, -0.51290047f, -0.15002680f, 0.00446503f, 
    0.08605157f, -0.03627606f, 0.03844418f, 0.01614093f, 0.09047218f, 0.16205670f, 0.02379650f, 0.31280917f, 
    0.27474642f, 0.16033167f, 0.16181822f, -0.19962721f, -0.18199353f, 0.09256750f, -0.41529372f, -0.00930412f, 
    0.03049244f, -0.08184232f, -0.02838120f, -0.14136812f, -0.28401089f, -0.17413640f, 0.22144496f, -0.04357665f, 
    -0.04614616f, 0.27647808f, -0.12767988f, -0.11716793f, -0.30313593f, -0.20366322f, -0.37021998f, -0.26819882f, 
    0.14379524f, 0.09634931f, -0.10393562f, -0.20457569f, 0.15700145f, 0.12882556f, 0.00938577f, 0.11085114f, 
    -0.04756372f, -0.13900651f, 0.04586675f, 0.16954675f, 0.22022934f, -0.22126380f, -0.06823174f, 0.06170645f, 
    -0.13539577f, -0.18002476f, -0.01493219f, 0.03938239f, -0.12349822f, 0.04758865f, -0.01294979f, 0.00509019f, 
    -0.22639398f, -0.12792876f, -0.10943556f, 0.20175476f, 0.03531933f, 0.11772452f, 0.07664547f, -0.00007175f, 
    -0.06846225f, -0.01706234f, -0.03354623f, -0.03573690f, 0.51870650f, -0.12876582f, 0.27224579f, -0.01883266f, 
    -0.06931825f, 0.16964318f, -0.09520025f, -0.07492904f, 0.19604981f, 0.02872414f, 0.09986488f, 0.06813927f, 
    -0.11764184f, -0.05904281f, -0.15101542f, -0.18947360f, -0.05554904f, 0.04107457f, -0.03156922f, 0.15129310f, 
    0.16289246f, 0.21353889f, 0.05492019f, 0.04550081f, -0.16184086f, 0.08360883f, 0.10155173f, -0.10376532f, 
    0.18989672f, -0.20271863f, 0.01947699f, 0.25740039f, -0.02015283f, 0.08187138f, -0.09850629f, -0.05365217f, 
    -0.21010131f, 0.27336374f, -0.04992790f, 0.04420410f, -0.12373821f, 0.17113483f, -0.27619275f, 0.00229306f, 
    -0.21947283f, 0.09031857f, 0.00004699f, 0.13681664f, -0.02862142f, 0.07174581f, 0.24018024f, 0.37169617f, 
    0.10959596f, 0.21295457f, 0.14962916f, 0.23849502f, 0.06297057f, 0.00710582f, -0.04651517f, -0.10798205f, 
    0.05143142f, -0.09430080f, 0.03219438f, 0.35523215f, 0.20993307f, 0.23639561f, -0.09122420f, 0.02564548f, 
    -0.07778914f, -0.26355857f, -0.01438175f, 0.07069064f, -0.38204697f, -0.30017418f, 0.17707971f, 0.26801965f, 
    0.15402548f, 0.23738152f, 0.05595545f, 0.02767787f, -0.07274354f, -0.01241120f, -0.09652159f, -0.07241882f, 
    -0.05103736f, 0.06383929f, -0.04381388f, 0.16992706f, 0.12383526f, 0.04906628f, 0.02149447f, -0.10693964f, 
    0.09311333f, -0.11355127f, -0.04484449f, -0.21415338f, -0.12094237f, -0.02144240f, -0.01681367f, -0.25348961f, 
    -0.05164851f, -0.01651591f, 0.01253959f, -0.00535979f, 0.00291992f, -0.12411022f, 0.13599296f, -0.05106517f, 
    0.03386280f, 0.18355589f, -0.02801122f, 0.15460524f, -0.16695285f, -0.07090552f, -0.01373493f, 0.04582334f, 
    0.08007996f, -0.11568163f, -0.04520524f, 0.14499247f, -0.03728525f, 0.30308348f, 0.17806463f, -0.02759438f, 
    0.04317381f, -0.10264854f, -0.08694441f, -0.13362525f, 0.05091349f, -0.00691300f, 0.04699912f, 0.02423733f, 
    0.17310792f, 0.14403848f, -0.09039071f, -0.03522232f, 0.08280531f, -0.17923714f, -0.04471603f, 0.06895908f, 
    0.03670261f, 0.26617324f, 0.00544091f, 0.02759155f, 0.06840211f, 0.22799510f, 0.06902900f, 0.05102363f, 
    -0.17324759f, 0.01660745f, 0.04860467f, -0.01448589f, -0.09786807f, 0.09145500f, -0.07357008f, -0.10527620f, 
    0.03751050f, -0.17064747f, 0.03968215f, 0.33159879f, 0.00347047f, 0.08439695f, -0.01463712f, 0.13964935f, 
    0.10836287f, 0.01109908f, 0.00652911f, 0.12828094f, -0.04585667f, 0.29965314f, 0.18533574f, 0.06717056f, 
    0.07480665f, -0.10359616f, -0.12843953f, -0.10374803f, 0.11721813f, -0.01718048f, -0.05535265f, 0.00120653f, 
    -0.28792450f, -0.11739324f, -0.01154194f, 0.13052188f, 0.11607738f, -0.17555094f, -0.02709493f, 0.21010482f, 
    0.12991355f, -0.05434622f, 0.09516162f, -0.05742338f, -0.09184345f, -0.21915297f, 0.03407330f, 0.00653015f, 
    0.00324843f, -0.18637460f, -0.07484502f, 0.10469890f, -0.12834501f, -0.07512391f, -0.03620594f, 0.09733909f, 
    -0.17606235f, -0.15242325f, -0.11962575f, -0.24103016f, -0.18525104f, -0.06250121f, 0.06290628f, -0.19132619f, 
    0.10800164f, -0.05442256f, -0.01893596f, 0.17859003f, 0.15262794f, 0.49115446f, 0.05660597f, 0.01905840f, 
    -0.01395752f, -0.25877756f, 0.20673215f, 0.17566475f, -0.02490715f, 0.17939077f, 0.19185452f, -0.03461434f, 
    0.44140705f, 0.34623867f, 0.21695730f, -0.13056982f, -0.21046302f, 0.31176469f, -0.22274792f, 0.02935554f, 
    0.06675140f, 0.16730690f, -0.01654076f, -0.03922179f, 0.29150277f, 0.15145278f, 0.31237420f, 0.40130639f, 
    0.13030945f, 0.12710007f, 0.06027436f, 0.21028496f, 0.13192715f, 0.00154607f, 0.15142387f, -0.17729022f, 
    -0.17023301f, -0.07816502f, 0.32415590f, 0.45871425f, 0.25761718f, 0.33377042f, -0.07184689f, 0.03292800f, 
    -0.29101157f, -0.34619090f, 0.00927632f, -0.46498239f, -0.16138202f, 0.02769261f, 0.20155713f, 0.10750405f, 
    -0.07827432f, 0.12902655f, -0.05212827f, -0.19538511f, -0.02959562f, 0.11581490f, -0.05353850f, -0.15264738f, 
    -0.08288261f, 0.34149116f, -0.08683921f, 0.44720647f, 0.15205298f, -0.00520614f, -0.00208884f, -0.11837266f, 
    0.15735215f, -0.10053998f, 0.23783284f, -0.05615509f, 0.16324960f, -0.06858617f, -0.16787940f, -0.17699867f, 
    -0.10956495f, -0.05827484f, 0.05224518f, -0.07026488f, -0.04525949f, -0.16479006f, -0.08752909f, -0.10114362f, 
    0.26509875f, 0.17463151f, -0.01290757f, 0.05719001f, 0.01951136f, -0.06220452f, 0.02214776f, 0.08320460f, 
    -0.13561679f, -0.08369809f, -0.07546433f, 0.05364850f, -0.11117103f, -0.07699557f, 0.06015208f, 0.12840195f, 
    -0.01322062f, -0.03038417f, -0.03068427f, 0.00821116f, 0.09471837f, 0.11444772f, 0.15426797f, 0.17145176f, 
    0.32925817f, 0.10807637f, -0.31406185f, -0.51422685f, -0.35942551f, -0.10533272f, -0.13945343f, 0.14380231f, 
    0.14357287f, 0.08679716f, -0.10066528f, -0.13814211f, 0.13515341f, 0.12948889f, 0.02996117f, -0.10485658f, 
    0.09156804f, 0.08539270f, -0.00756230f, -0.08913121f, -0.36720815f, 0.05228354f, -0.23960671f, -0.36124969f, 
    0.06940906f, -0.15708913f, -0.06780812f, 0.05842950f, 0.15368271f, 0.17963317f, 0.06525626f, 0.06087403f, 
    0.03505084f, -0.22027478f, -0.21517551f, -0.01059318f, -0.15719363f, 0.23015422f, -0.07868075f, 0.29963589f, 
    -0.13191417f, -0.07618662f, 0.00241878f, -0.28335881f, 0.04744787f, 0.05314785f, 0.09748022f, 0.10245877f, 
    -0.26824659f, 0.02377001f, 0.03037504f, 0.07653620f, 0.09274416f, -0.08685775f, -0.06466106f, 0.04120347f, 
    -0.08251437f, -0.06638788f, -0.00794299f, -0.22327797f, 0.14965336f, -0.26367268f, 0.03636019f, -0.01478868f, 
    -0.10446081f, 0.08010124f, 0.05780296f, -0.10050151f, 0.06461412f, -0.01184228f, -0.06081515f, 0.11645290f, 
    -0.15826990f, 0.02113637f, 0.03724932f, -0.06789147f, -0.04102883f, -0.06940386f, 0.07163288f, 0.02229046f, 
    0.00502165f, 0.11907963f, -0.00524660f, -0.08639890f, -0.14195676f, 0.13066235f, -0.14738011f, -0.18636712f, 
    0.18525082f, -0.06467927f, 0.00907518f, 0.02400610f, -0.00559924f, 0.00017792f, -0.14519191f, -0.04014925f, 
    -0.21333200f, 0.57737601f, -0.44138268f, 0.20432061f, 0.09563223f, 0.07183199f, 0.13089046f, 0.16782215f, 
    -0.12816888f, -0.00453149f, 0.05276747f, 0.17941304f, -0.11912100f, -0.03252314f, -0.08362599f, 0.15123354f, 
    0.07640997f, 0.21590887f, 0.10712807f, 0.13641445f, 0.03897344f, 0.00567407f, -0.17067981f, 0.08048030f, 
    -0.13231811f, 0.09912196f, -0.31279549f, 0.06249456f, 0.04648544f, -0.04494940f, -0.01006022f, -0.11738255f, 
    0.00537672f, 0.05693864f, 0.18764800f, 0.24290001f, -0.48164558f, -0.22181916f, -0.11522238f, 0.14456257f, 
    0.11007667f, 0.16231461f, 0.04553176f, 0.04913975f, 0.01351614f, -0.16369469f, -0.04403958f, 0.10018706f, 
    0.02242080f, -0.29090536f, 0.32221726f, 0.01207326f, -0.17660111f, 0.08841551f, -0.05924090f, 0.10753774f, 
    -0.03334642f, -0.10772176f, -0.24901174f, -0.08566874f, -0.32688281f, -0.02372347f, -0.03825785f, -0.04096154f, 
    0.00439923f, -0.10662851f, -0.05282520f, -0.09842544f, -0.00959626f, -0.18182185f, 0.11461072f, 0.09421590f, 
    -0.15662985f, 0.44140857f, 0.00413078f, 0.02129035f, -0.03862286f, -0.03475465f, -0.00611970f, -0.03862097f, 
    -0.05424623f, -0.10112189f, -0.15394434f, 0.01152771f, 0.25334755f, 0.46084124f, 0.14936289f, 0.24406026f, 
    0.12332544f, 0.00888460f, -0.01923272f, 0.01954880f, -0.02333170f, 0.01442407f, 0.01351165f, -0.09542207f, 
    -0.18604252f, 0.01479590f, 0.12686677f, -0.04383329f, 0.06553383f, -0.06691547f, -0.01809813f, 0.01161820f, 
    0.03944198f, 0.13302605f, 0.09037364f, 0.18807286f, 0.20468631f, 0.33514720f, -0.15713932f, -0.06018189f, 
    -0.09228793f, -0.03661475f, -0.11033206f, -0.15111277f, 0.08882198f, 0.06321737f, 0.13887866f, -0.19598433f, 
    0.21211219f, -0.04726266f, 0.07801396f, 0.31744108f, -0.02356022f, 0.19254379f, -0.09174506f, 0.21473664f, 
    0.00588592f, 0.03354463f, -0.12799017f, -0.00509198f, 0.14728276f, 0.29781029f, 0.35093379f, 0.28582007f, 
    0.04781451f, 0.08834933f, -0.03276322f, -0.06022163f, 0.21044673f, 0.05600653f, 0.06918791f, 0.03285988f, 
    -0.05804493f, 0.02595488f, 0.13288468f, 0.14512743f, -0.16188519f, -0.03808656f, -0.10202048f, -0.00319499f, 
    0.05005390f, -0.08218902f, 0.03274543f, 0.12358391f, -0.04091751f, -0.08431423f, -0.01238425f, -0.12226451f, 
    0.23954937f, -0.00904628f, 0.04957326f, -0.11820924f, -0.07692882f, 0.09341148f, -0.05498207f, 0.00873619f, 
    0.08737250f, -0.06542399f, 0.02753385f, -0.04554794f, -0.10378303f, 0.06222276f, 0.00970050f, -0.05403193f, 
    -0.01793087f, -0.01317710f, -0.12142647f, -0.09752478f, -0.01819892f, 0.21381976f, -0.46277207f, 0.00649932f, 
    -0.16744767f, -0.06342260f, -0.07399141f, -0.03583372f, -0.09895103f, -0.05557146f, -0.09924595f, 0.03925750f, 
    -0.17530441f, 0.15810525f, -0.18987113f, 0.14195170f, 0.34512362f, 0.08098990f, -0.12058867f, -0.00928594f, 
    -0.00074280f, -0.03460208f, 0.03687563f, 0.05316934f, 0.00357548f, 0.07611509f, 0.06694030f, 0.18905401f, 
    -0.00904129f, -0.07722883f, 0.01846511f, 0.27634877f, -0.06557015f, 0.06659051f, 0.01255320f, -0.20093279f, 
    0.21563298f, 0.04473687f, 0.10679442f, 0.22881259f, -0.06868659f, 0.09835148f, -0.06376912f, 0.01298068f, 
    -0.19913650f, -0.00856461f, 0.03495435f, -0.14029934f, -0.33080429f, -0.21558294f, 0.15460567f, 0.04546396f, 
    0.00938459f, -0.00002096f, 0.03577044f, 0.03786854f, 0.10596582f, 0.27119711f, 0.05731326f, -0.03896184f, 
    0.01852338f, -0.07124463f, 0.11659961f, -0.03232271f, -0.10625280f, 0.05443216f, -0.04488630f, 0.02488467f, 
    0.13336791f, 0.09191196f, 0.14926238f, 0.15650570f, 0.08363785f, 0.06895661f, 0.20512770f, 0.24326891f, 
    0.11830061f, -0.08347730f, -0.24641949f, -0.00447370f, -0.04268929f, -0.07679244f, -0.10914016f, -0.14444657f, 
    -0.13096951f, 0.05210433f, -0.05368225f, 0.27568537f, 0.09788611f, 0.10003863f, -0.02298641f, 0.00822943f, 
    -0.16444944f, 0.08447056f, -0.02201498f, 0.05029507f, 0.28046533f, -0.21243045f, -0.18228546f, 0.14395605f, 
    -0.04296763f, -0.01553425f, 0.05844384f, 0.10725082f, -0.08427123f, 0.09915352f, 0.16996562f, 0.17525087f, 
    -0.09676617f, 0.21433800f, -0.16440836f, 0.16854024f, 0.06260035f, 0.04657546f, -0.08434279f, -0.08100891f, 
    -0.18752231f, -0.13253757f, -0.06850469f, -0.11719915f, 0.15429680f, -0.04456872f, 0.40896821f, 0.12424861f, 
    0.10717961f, -0.14776425f, 0.05884714f, 0.00880678f, 0.11766072f, -0.07121276f, -0.01615726f, -0.22671567f, 
    0.36692098f, 0.01686294f, -0.08222067f, -0.10856324f, 0.03961949f, 0.05296786f, 0.00042808f, -0.09307349f, 
    0.11653816f, 0.06005248f, 0.07757905f, -0.01906945f, -0.00951360f, 0.02619248f, -0.22713862f, -0.32431111f, 
    -0.05134121f, -0.02057416f, -0.06054047f, 0.02182726f, -0.13655759f, 0.07120901f, -0.03471157f, -0.01682153f, 
    0.14394027f, 0.25142354f, 0.32720691f, 0.07284737f, 0.04067658f, 0.04993054f, 0.01681671f, 0.00773271f, 
    0.02448526f, 0.02334140f, 0.06354893f, -0.02610115f, 0.39462635f, -0.00102251f, -0.28106308f, -0.09029905f, 
    0.18055816f, -0.02901494f, 0.00940330f, -0.19957323f, -0.02377393f, 0.10651968f, 0.08509621f, 0.02945740f, 
    -0.03036145f, -0.07740338f, 0.05769088f, -0.01611721f, -0.02415641f, 0.00851157f, -0.01910913f, 0.04406087f, 
    0.02962598f, -0.02625794f, -0.04962302f, 0.03892190f, 0.04098466f, -0.05445692f, -0.02706548f, -0.03170977f, 
    -0.02229088f, -0.00472024f, -0.02395625f, -0.01267675f, -0.07742142f, -0.02605943f, -0.02095156f, -0.02326369f, 
    0.00012250f, -0.05594180f, -0.02385459f, 0.02435204f, -0.02996692f, 0.01441457f, 0.04107663f, -0.02604156f, 
    0.02178457f, 0.00906409f, 0.00653023f, 0.06299766f, 0.06387684f, -0.01802633f, -0.05843255f, -0.06502789f, 
    -0.00066566f, 0.03259332f, 0.00234097f, 0.02874488f, -0.01287720f, -0.01208721f, -0.02406451f, -0.07169351f, 
    -0.03427201f, 0.04877612f, 0.02181450f, -0.05275534f, -0.05674611f, 0.02295036f, 0.06130414f, -0.02946069f, 
    0.05835989f, 0.01400038f, -0.01605828f, 0.02311984f, -0.05641739f, 0.03619528f, -0.03095151f, -0.01469900f, 
    -0.03800954f, -0.02171260f, -0.06806254f, -0.05508809f, -0.07476477f, -0.05025522f, 0.03803325f, -0.02539170f, 
    -0.03634827f, 0.06011313f, -0.00293106f, 0.05164722f, -0.05051998f, -0.00032122f, 0.00465209f, -0.04926784f, 
    -0.05345658f, 0.01449798f, 0.04687492f, -0.01172772f, -0.02800981f, -0.01737503f, 0.03803210f, 0.04861639f, 
    0.02700272f, -0.02586606f, -0.04637675f, -0.06866900f, -0.05072914f, -0.03116283f, -0.05565314f, -0.01442909f, 
    -0.05841462f, 0.00416385f, 0.03527895f, 0.00149851f, 0.06100010f, -0.02706302f, -0.00658129f, -0.04590818f, 
    0.00682585f, -0.04273055f, -0.07077534f, -0.06483825f, 0.00180838f, 0.05097245f, -0.07177545f, 0.03012638f, 
    0.03060215f, -0.05408219f, 0.03754399f, -0.06149670f, -0.07858759f, 0.00813855f, 0.01892138f, -0.07305974f, 
    -0.02662598f, 0.04445001f, 0.04151262f, -0.03439853f, -0.05041301f, 0.02628754f, 0.02381173f, -0.00872151f, 
    -0.00577241f, -0.01635174f, -0.04153128f, 0.03795087f, 0.01155461f, 0.03068390f, -0.05865222f, -0.02968566f, 
    -0.01553981f, 0.01927546f, 0.00857522f, -0.02826356f, 0.02175633f, -0.01559070f, -0.00989173f, -0.01711684f, 
    -0.01456403f, -0.00915034f, 0.03562391f, -0.00163089f, -0.02148421f, 0.04572207f, 0.05206242f, 0.00660248f, 
    0.01713531f, -0.02470472f, 0.06061755f, 0.01509929f, -0.06770610f, 0.01038612f, 0.02269608f, -0.07592250f, 
    -0.07169443f, -0.02652485f, -0.07063107f, 0.01243616f, -0.03356836f, -0.01026199f, 0.05882961f, -0.05605376f, 
    0.03210001f, -0.02583970f, -0.03693845f, 0.06360456f, -0.06076482f, -0.04127454f, -0.06617694f, 0.04892935f, 
    0.02970386f, -0.02988804f, -0.01919195f, -0.00761148f, 0.05167927f, -0.04838428f, 0.04016397f, 0.00548204f, 
    0.06265730f, -0.06503665f, -0.04872154f, -0.06786115f, -0.03664240f, 0.02475300f, 0.05785254f, 0.02205631f, 
    0.18153192f, 0.14697762f, 0.01144630f, 0.12970263f, -0.00558895f, -0.03303616f, -0.05288629f, -0.05586449f, 
    -0.13923398f, 0.16664012f, 0.13358082f, 0.09534381f, 0.40012002f, 0.11924516f, -0.02760133f, 0.12387624f, 
    0.13334498f, -0.06326936f, -0.03315637f, 0.12284006f, 0.05889893f, 0.03503977f, 0.24001242f, 0.11489558f, 
    0.09603512f, 0.09345981f, -0.15926117f, 0.21447043f, 0.03083388f, 0.29060927f, 0.07834066f, 0.04316372f, 
    0.07218926f, 0.02559241f, 0.09147206f, -0.05541827f, -0.19983940f, -0.19065049f, -0.03739992f, 0.07673935f, 
    0.11657038f, 0.26127604f, -0.13542771f, -0.16997312f, 0.02013019f, -0.06054377f, -0.09376399f, 0.03077627f, 
    -0.26992977f, 0.08901559f, 0.07355890f, -0.11990480f, -0.15179971f, -0.10531260f, -0.11171091f, -0.00403766f, 
    0.00744439f, -0.00674554f, 0.03821835f, 0.07220386f, -0.09563546f, -0.26773360f, -0.17515193f, 0.07174311f, 
    -0.08426183f, -0.02235651f, -0.12327188f, -0.10940965f, 0.02524803f, 0.16762668f, 0.03748104f, 0.04553277f, 
    0.04088527f, -0.06404731f, 0.14314160f, -0.07360923f, 0.05321220f, -0.04766278f, -0.03253735f, -0.09879056f, 
    -0.03678926f, 0.05610329f, -0.28323075f, 0.04543104f, -0.04960564f, 0.10171282f, -0.05221213f, 0.02907496f, 
    -0.07341940f, 0.04655964f, -0.06664585f, -0.00958273f, 0.00812521f, -0.11996138f, 0.01637937f, -0.26392853f, 
    0.11260045f, 0.06246430f, 0.05598298f, -0.00280918f, -0.06200073f, -0.11278877f, 0.03260933f, -0.04064162f, 
    -0.02585316f, 0.00418345f, 0.00876055f, -0.16049477f, -0.30701697f, 0.26788765f, 0.19445522f, 0.06314001f, 
    -0.12829944f, -0.04093432f, 0.17756534f, 0.17863733f, -0.03191986f, 0.06701335f, 0.23839180f, -0.12311932f, 
    0.02198436f, -0.05144756f, -0.07036964f, -0.06448310f, 0.02450705f, 0.01777021f, 0.13500682f, -0.02321897f, 
    -0.15423530f, 0.03679905f, 0.10424276f, 0.14100206f, 0.01227002f, 0.26838028f, -0.12872571f, -0.16050299f, 
    -0.07200186f, 0.01944858f, 0.09913076f, 0.03365988f, -0.08767918f, 0.03343352f, 0.05933133f, -0.11577317f, 
    -0.43073323f, 0.11567988f, -0.03324332f, 0.12228385f, 0.07768365f, 0.00328815f, 0.17796254f, 0.00315202f, 
    -0.03240645f, -0.05660219f, -0.17422712f, -0.11420617f, -0.07185546f, 0.19276205f, 0.13847777f, 0.12478086f, 
    -0.03148808f, 0.20586066f, 0.13932176f, 0.09527788f, 0.02735724f, -0.10083115f, -0.15395427f, 0.06901197f, 
    0.07062536f, 0.28509134f, -0.04570452f, -0.22055027f, 0.07634696f, -0.07222287f, -0.01844988f, -0.01382783f, 
    0.05582754f, -0.02013051f, 0.02440176f, -0.02616333f, -0.08954985f, -0.02322155f, 0.02144352f, 0.00568513f, 
    -0.02297908f, -0.17894451f, -0.05370287f, 0.23268287f, -0.13365948f, 0.03742789f, 0.10476488f, -0.12606697f, 
    0.05746988f, -0.01891296f, -0.05541488f, 0.04360960f, -0.05288058f, -0.04756495f, 0.00846615f, 0.05250661f, 
    -0.03122567f, -0.06316619f, -0.06050491f, -0.06843463f, 0.00175608f, -0.00664514f, 0.05902155f, -0.02091101f, 
    0.05816903f, 0.02165125f, -0.00871836f, -0.06278263f, -0.00704567f, 0.02268545f, -0.06681106f, -0.03366156f, 
    -0.01793610f, 0.02596055f, -0.00428058f, -0.03409095f, 0.02538058f, -0.03445208f, 0.01740024f, 0.02972099f, 
    0.02822451f, -0.01113771f, 0.00574094f, -0.02859437f, -0.02438290f, -0.06837123f, 0.01404636f, -0.03772899f, 
    -0.05909077f, -0.03808760f, 0.02129224f, -0.03320532f, -0.03697911f, 0.04198005f, 0.04665035f, -0.00898086f, 
    0.04347093f, -0.05387347f, 0.04143362f, -0.05503986f, -0.05273257f, 0.06871220f, 0.04766050f, -0.01664821f, 
    -0.03672604f, -0.02191588f, -0.03812296f, 0.02683313f, 0.06924825f, -0.02143586f, -0.05793287f, 0.03363831f, 
    0.03569973f, 0.00848560f, -0.06678000f, 0.00091704f, -0.01337671f, -0.06664420f, -0.05207882f, -0.03121863f, 
    -0.05513594f, 0.04746458f, -0.06026244f, -0.05449372f, -0.03126512f, -0.02531198f, 0.03604531f, -0.05288758f, 
    0.00960072f, -0.07508577f, 0.04492487f, 0.05878768f, 0.01635323f, -0.01713123f, -0.06252906f, -0.06219526f, 
    -0.03995280f, 0.02994063f, 0.01682179f, -0.05326958f, -0.02423692f, 0.05049951f, -0.03923385f, -0.03673919f, 
    0.02750648f, 0.04705474f, -0.05626359f, -0.05117660f, -0.05471061f, -0.06171379f, -0.05287693f, -0.00815720f, 
    -0.05420156f, 0.04301878f, -0.04047983f, -0.00988906f, -0.05626569f, 0.04604140f, -0.06667747f, -0.00223384f, 
    0.01055739f, 0.01573469f, -0.04859723f, 0.00631952f, 0.05494165f, -0.02382033f, -0.04339655f, 0.04889860f, 
    -0.05244030f, -0.05010186f, -0.03751389f, 0.02156752f, 0.00726992f, -0.04667839f, -0.04797817f, -0.01471741f, 
    -0.05932416f, -0.05072464f, 0.05188600f, 0.04542666f, -0.05000683f, 0.00541248f, -0.05440803f, -0.01196515f, 
    0.05001973f, 0.04834241f, -0.03306305f, 0.05495704f, 0.01198737f, 0.00542751f, -0.05504389f, 0.05807422f, 
    0.06426366f, 0.06211647f, -0.05406369f, -0.00923618f, -0.00240510f, 0.00174850f, 0.00846977f, -0.03177955f, 
    -0.02169846f, 0.00361975f, -0.05651807f, -0.03632800f, -0.00632890f, 0.01253551f, 0.02366446f, -0.01968013f, 
    -0.02741569f, -0.03342583f, -0.00160955f, -0.02871978f, -0.01707951f, 0.01626625f, -0.01484346f, 0.02610266f, 
    -0.04484122f, 0.05565033f, -0.01256405f, 0.01840893f, -0.01149890f, -0.06531469f, 0.03393015f, -0.05881704f, 
    0.01571907f, -0.05297687f, 0.00914231f, 0.05036741f, 0.01931105f, 0.00159507f, -0.01000350f, 0.01104231f, 
    0.04415329f, -0.06693283f, -0.02263863f, -0.03392056f, 0.02901546f, 0.05563169f, -0.05806886f, 0.00970159f, 
    0.09334064f, 0.28752846f, -0.04266621f, -0.09046255f, -0.05032401f, -0.17680100f, -0.05763557f, 0.09125201f, 
    -0.16198725f, -0.17141697f, -0.02946634f, 0.21442090f, 0.36664060f, -0.15680178f, 0.09925964f, 0.30770671f, 
    -0.10514049f, 0.13328597f, -0.06306705f, -0.08536743f, -0.12221421f, 0.11832985f, -0.06501529f, 0.12131555f, 
    -0.35249719f, -0.00453195f, 0.17895094f, -0.06631496f, -0.08847905f, 0.14319634f, 0.07863318f, -0.10373090f, 
    -0.06381468f, 0.13629496f, 0.01538734f, 0.11406600f, -0.11394484f, 0.20513406f, -0.03692748f, 0.04427008f, 
    -0.15930487f, 0.09996332f, -0.14797847f, -0.26439300f, -0.04163329f, 0.03692861f, 0.10437683f, 0.09677891f, 
    -0.11858039f, 0.12133355f, -0.23284104f, 0.04336460f, 0.06598126f, -0.14128283f, 0.27211395f, 0.05143329f, 
    -0.14021750f, 0.06615708f, -0.24826388f, -0.11484221f, 0.07974869f, -0.11508489f, 0.02384038f, 0.05762633f, 
    -0.09807085f, 0.07519191f, -0.05418186f, 0.00089537f, 0.23263656f, -0.06916508f, -0.00399209f, 0.00697325f, 
    0.32214636f, 0.06758862f, 0.17774627f, -0.22698711f, -0.04922738f, 0.00430278f, 0.01964289f, 0.00147679f, 
    -0.03349252f, -0.05061221f, -0.06980114f, 0.19706385f, -0.02765318f, 0.09638420f, -0.08314180f, 0.04470279f, 
    -0.19745971f, 0.01616458f, -0.08902615f, -0.04295948f, 0.10480876f, -0.12287479f, 0.09423798f, -0.05463104f, 
    0.03840948f, -0.36704049f, 0.21591683f, -0.06219483f, -0.08025392f, -0.10052073f, 0.07608307f, -0.19436941f, 
    0.17066883f, 0.11498742f, 0.05101313f, -0.10485433f, -0.07812044f, 0.09932654f, 0.01004648f, 0.11634862f, 
    0.02925538f, 0.02314918f, -0.25685617f, 0.16165856f, 0.14773700f, 0.06580730f, -0.16375405f, -0.00837628f, 
    -0.12483065f, -0.03695559f, 0.29585496f, -0.11413807f, -0.11677933f, -0.03998391f, 0.11757586f, -0.13461590f, 
    0.00300882f, -0.01884174f, -0.02626377f, 0.08694743f, -0.22991179f, 0.06171415f, 0.01518821f, -0.05915047f, 
    -0.08475883f, -0.08536483f, 0.03200281f, -0.01815913f, 0.08755273f, -0.06742162f, -0.16797213f, 0.15409921f, 
    -0.04275797f, 0.23939840f, 0.02252533f, 0.07907895f, 0.01532074f, 0.14378931f, 0.11878271f, -0.05040896f, 
    0.01615351f, 0.14995268f, -0.02428916f, -0.17322646f, 0.55326271f, 0.03198138f, 0.21372458f, 0.19685860f, 
    -0.01340854f, -0.01100019f, 0.13428822f, -0.00738955f, 0.10557082f, -0.12741950f, 0.10984351f, -0.12379417f, 
    0.52502519f, 0.12691511f, 0.33402535f, -0.32258695f, -0.13550064f, 0.02267352f, -0.07121877f, -0.00837327f, 
    -0.18850309f, 0.06258012f, -0.08664726f, -0.12984090f, -0.11894386f, 0.40972272f, -0.12960292f, 0.09668080f, 
    -0.20698746f, -0.07412525f, -0.00626413f, -0.07089046f, 0.03254269f, -0.00620977f, -0.04234651f, 0.06347955f, 
    0.03184590f, 0.19980223f, -0.05335297f, 0.13197894f, -0.01011964f, 0.06743406f, 0.04577155f, 0.10337360f, 
    0.15992175f, 0.12032066f, 0.24952160f, 0.20669612f, -0.27981070f, -0.29947045f, 0.26149398f, 0.39064020f, 
    -0.02487492f, 0.03860407f, -0.02732021f, -0.15684275f, 0.20419499f, 0.04970892f, 0.16693136f, 0.10854580f, 
    -0.34279454f, -0.33413199f, 0.12885179f, 0.29884151f, 0.16449785f, -0.19316086f, -0.14769244f, 0.29538882f, 
    0.13463575f, -0.09589863f, 0.12956351f, -0.06966157f, -0.23880713f, -0.15458435f, -0.20871112f, -0.19147705f, 
    -0.20239586f, -0.13672395f, -0.00603157f, -0.26803985f, -0.02708106f, 0.03226218f, 0.00433568f, 0.00456693f, 
    0.10108335f, -0.14477864f, -0.02069327f, -0.04813020f, 0.09869269f, -0.11646051f, 0.33340520f, 0.05865299f, 
    0.02191175f, 0.03211980f, -0.07611393f, -0.08527284f, 0.06738837f, 0.19583473f, 0.11051130f, -0.10298461f, 
    0.00471514f, -0.12658738f, -0.03239802f, -0.07750610f, 0.07299995f, -0.09272721f, -0.02571212f, 0.02083273f, 
    0.01159431f, -0.01388477f, -0.03567907f, -0.28959346f, 0.10279326f, 0.10390627f, 0.16699933f, 0.13781172f, 
    -0.11660281f, 0.00592802f, 0.08155760f, 0.14824636f, -0.12706712f, -0.01206377f, 0.01366715f, 0.17129454f, 
    -0.04097613f, -0.06929740f, 0.00606282f, 0.03076704f, 0.04502355f, 0.05253166f, -0.15480638f, -0.00021700f, 
    -0.21144728f, -0.17860343f, 0.15099379f, 0.16585845f, 0.04065158f, 0.11703888f, -0.08633056f, -0.09441136f, 
    0.05062604f, 0.01405232f, 0.00618550f, -0.03081961f, -0.17197233f, 0.15010576f, 0.24515769f, 0.04329937f, 
    -0.04124847f, 0.11062956f, 0.06047164f, 0.01486349f, 0.02525511f, 0.18005823f, 0.22174141f, 0.10291798f, 
    -0.21610105f, -0.17866425f, 0.17381755f, 0.22063088f, 0.07625345f, 0.06287272f, -0.07828394f, -0.08261561f, 
    0.04193845f, -0.10427298f, 0.06313778f, 0.11401591f, -0.34128836f, -0.23034745f, 0.02897113f, 0.20012207f, 
    0.06405658f, 0.04389910f, -0.03577600f, 0.11907178f, -0.03374554f, -0.06382284f, 0.02757301f, 0.06832723f, 
    -0.30548152f, -0.03928451f, 0.00900095f, -0.15792458f, -0.18647182f, -0.12161031f, 0.04942813f, -0.06626449f, 
    0.01448399f, -0.06391793f, 0.10381757f, -0.11015823f, 0.00252849f, 0.16586253f, 0.25262558f, -0.09972227f, 
    -0.02629801f, -0.31325951f, -0.03579559f, 0.14187640f, -0.16565394f, 0.03097166f, 0.04358747f, 0.02109344f, 
    0.07322647f, 0.02444385f, 0.22708608f, -0.09902703f, 0.06513777f, 0.07969035f, 0.04874313f, -0.01122104f, 
    0.01455700f, 0.09611806f, -0.01699382f, 0.09980713f, -0.32632393f, 0.29953212f, 0.25151548f, 0.22959304f, 
    -0.05332737f, 0.07226632f, -0.09730582f, 0.10535274f, 0.18248765f, 0.03628584f, 0.01145411f, -0.01297943f, 
    0.17745483f, 0.13502704f, 0.09811339f, 0.07213287f, 0.01884097f, 0.11954045f, 0.12681769f, 0.13224278f, 
    -0.10039982f, 0.13966751f, 0.00670876f, -0.07476281f, -0.25299174f, -0.08240842f, 0.08955289f, 0.14293739f, 
    -0.09493542f, -0.12338790f, 0.10276608f, 0.02856134f, -0.05097031f, 0.05161519f, 0.00911560f, 0.15893628f, 
    -0.34326908f, -0.14893742f, 0.22017342f, -0.17327219f, 0.18708245f, -0.08307847f, -0.36707932f, 0.18164074f, 
    -0.00153392f, -0.19378944f, -0.06144461f, 0.00644752f, -0.11239775f, 0.31451052f, 0.15605320f, 0.12890595f, 
    -0.05696758f, 0.13514687f, -0.19144814f, -0.42000866f, -0.01999598f, 0.05781121f, 0.05628730f, -0.03453467f, 
    0.16917229f, 0.00529593f, 0.15720150f, 0.09906711f, -0.02337513f, -0.00360862f, 0.10487831f, -0.22773395f, 
    -0.11372275f, -0.08429600f, -0.03986739f, -0.00364991f, -0.05307327f, -0.03816815f, -0.15979691f, -0.09799954f, 
    0.08756221f, 0.00177874f, 0.07529347f, 0.09856619f, 0.11448230f, -0.00451630f, 0.00011378f, -0.04424227f, 
    0.29269019f, -0.13806517f, 0.21483165f, -0.39720491f, -0.01701473f, -0.03290830f, 0.00215935f, 0.07621415f, 
    -0.09836289f, 0.19681333f, 0.05771100f, -0.06485602f, 0.24244569f, 0.37649262f, 0.06790886f, 0.13792601f, 
    0.06811593f, -0.05927627f, 0.02871862f, 0.04830379f, 0.16232911f, 0.07054836f, -0.13112621f, 0.12275222f, 
    0.12473939f, 0.05260798f, 0.26197705f, 0.13540186f, -0.02131218f, 0.04464908f, -0.00639254f, 0.00658429f, 
    -0.02509991f, 0.08436023f, -0.07038248f, 0.03025905f, -0.10282786f, 0.13125741f, -0.36665258f, -0.24724330f, 
    -0.09597368f, 0.18493022f, -0.05676058f, -0.20760630f, -0.09731119f, 0.10657247f, 0.13149858f, -0.02237430f, 
    0.15838248f, 0.03203952f, 0.02688142f, 0.01952477f, 0.05179496f, -0.10507929f, 0.03310744f, 0.03892589f, 
    0.10942236f, -0.08774320f, -0.07627217f, -0.00250583f, 0.06836218f, 0.24956080f, 0.35530141f, 0.31033137f, 
    0.06243968f, -0.07090328f, -0.03808353f, 0.05763939f, -0.01255336f, 0.02939973f, 0.03339726f, 0.09961466f, 
    -0.14669168f, -0.18362072f, -0.09822046f, -0.10174979f, 0.14010258f, -0.24286659f, -0.04628334f, -0.19619398f, 
    0.07697013f, -0.03234201f, 0.11047626f, -0.01081406f, -0.20389451f, -0.08863954f, -0.36164501f, 0.20663616f, 
    -0.04871888f, -0.18531857f, 0.03581585f, -0.00245792f, -0.06544534f, 0.01645390f, -0.00665932f, 0.03332705f, 
    0.49439621f, 0.21340735f, 0.48594829f, 0.15197909f, -0.09638748f, 0.05182676f, -0.06091180f, -0.00727473f, 
    0.03072947f, 0.08374508f, -0.06553185f, 0.05972070f, -0.35897526f, 0.04778444f, -0.23225240f, -0.06683786f, 
    -0.14792252f, -0.06126031f, -0.11131251f, 0.05771679f, -0.27470386f, -0.24442877f, -0.12464213f, -0.05538686f, 
    -0.15246589f, -0.52403492f, 0.01020957f, -0.04491965f, -0.12140195f, 0.11741371f, -0.08639419f, -0.10469741f, 
    -0.08515479f, -0.00751031f, -0.08605985f, -0.15129310f, -0.20931782f, 0.08314207f, -0.18736790f, -0.14860936f, 
    0.04545797f, 0.19581243f, 0.18085238f, -0.02770119f, 0.09981445f, -0.14541921f, 0.09696593f, 0.17358097f, 
    0.33651051f, 0.24073721f, -0.00542723f, -0.10871289f, 0.18699725f, -0.05067431f, 0.32699257f, 0.11494370f, 
    0.12605779f, -0.25082383f, 0.05275076f, 0.05345841f, 0.36389211f, 0.24574628f, 0.06213404f, 0.00324081f, 
    0.09272859f, -0.02797575f, 0.07083411f, 0.23966172f, -0.04060888f, -0.04316231f, -0.11694913f, 0.10369290f, 
    0.32223743f, 0.00965662f, 0.10405447f, -0.37136501f, -0.17727380f, 0.10726081f, -0.13458836f, 0.02351177f, 
    0.08554635f, 0.05312636f, 0.06266547f, -0.01226936f, 0.22232355f, 0.12643990f, -0.05905843f, -0.05547402f, 
    -0.05655082f, -0.05109563f, 0.02399754f, 0.08381940f, -0.04545033f, 0.05950322f, 0.07419489f, -0.01327921f, 
    -0.02537698f, 0.09538612f, 0.10316148f, 0.15425146f, 0.01076705f, 0.00547058f, 0.07368252f, 0.23404647f, 
    -0.00515130f, 0.12999737f, 0.05257455f, -0.01660164f, -0.27859670f, -0.47424436f, -0.16879219f, 0.01932477f, 
    0.04944107f, -0.05133777f, -0.08030848f, -0.23947644f, -0.01161423f, 0.28404513f, 0.02581022f, 0.32566905f, 
    -0.38344595f, -0.05476033f, -0.09395796f, -0.09942576f, -0.12606698f, -0.00989216f, 0.01060646f, 0.14469954f, 
    -0.07215180f, 0.23272687f, -0.04152576f, 0.10966816f, 0.45198661f, -0.11718165f, -0.19166107f, 0.05338988f, 
    0.06389988f, 0.07349357f, 0.18892543f, 0.00524162f, -0.08729900f, -0.04030987f, 0.02551709f, 0.00191148f, 
    -0.32861546f, -0.04747007f, -0.15750596f, -0.17248657f, -0.04455187f, 0.12415489f, -0.09861590f, 0.02567596f, 
    0.00910751f, -0.04190385f, 0.12638667f, 0.06597863f, -0.10492189f, -0.05041023f, -0.09136546f, -0.01701077f, 
    0.00159045f, -0.00705799f, -0.01097742f, 0.05143822f, 0.04793908f, -0.09881005f, 0.05728014f, -0.07341763f, 
    0.40468630f, 0.26463452f, 0.20209171f, -0.05829456f, 0.18870620f, 0.08560350f, -0.05778398f, 0.07064036f, 
    -0.01713318f, 0.03677247f, 0.05248190f, 0.05959816f, 0.21670799f, -0.29822931f, -0.15859510f, 0.06820773f, 
    0.23033285f, 0.04574071f, 0.09659351f, -0.10857683f, 0.03200484f, 0.28206101f, -0.01373694f, 0.04805963f, 
    -0.35651252f, -0.17779565f, -0.31605625f, 0.15174128f, -0.11484428f, -0.13464679f, -0.00530652f, -0.03340390f, 
    -0.07568990f, 0.00055247f, -0.14001687f, 0.14164658f, 0.41469440f, -0.40370202f, -0.28336704f, -0.26827806f, 
    0.27763745f, 0.18576469f, -0.01381349f, -0.17475270f, 0.16597907f, -0.01230925f, 0.01981964f, 0.10847103f, 
    0.03582238f, -0.01029521f, -0.05438087f, -0.04655187f, -0.02102492f, -0.00073173f, 0.04778489f, -0.07991196f, 
    0.06394783f, 0.01180198f, -0.06996801f, 0.00618143f, 0.03486604f, -0.05982331f, 0.03412216f, -0.03286923f, 
    0.01693693f, 0.00286039f, -0.06658477f, -0.00918536f, 0.03288325f, -0.06830984f, 0.04954597f, -0.03479514f, 
    0.00884793f, 0.04593128f, 0.01934111f, -0.06528912f, 0.00058322f, -0.05069993f, -0.03468744f, 0.00639076f, 
    -0.04170432f, 0.01879130f, 0.03289111f, -0.00827384f, -0.07101892f, 0.03474103f, -0.07028422f, 0.01194257f, 
    -0.05784887f, -0.05350768f, -0.03883245f, 0.01823885f, -0.05077805f, 0.03889421f, -0.05684664f, -0.00027142f, 
    -0.01421741f, -0.05074870f, -0.04474724f, 0.04088382f, -0.04951372f, 0.01481023f, -0.02272327f, 0.05950709f, 
    -0.00132541f, -0.01201976f, 0.04491658f, -0.04326990f, 0.02339449f, 0.05723266f, 0.06020021f, -0.03002484f, 
    0.00061862f, -0.01629045f, 0.04372626f, -0.00914060f, 0.03253040f, -0.03785379f, 0.04799720f, -0.01563976f, 
    0.02204022f, -0.01229897f, -0.02916489f, -0.07076692f, -0.04212852f, 0.01150129f, -0.00850353f, 0.03247388f, 
    -0.03998416f, -0.04666306f, -0.00936390f, 0.06444380f, 0.05149703f, 0.04843212f, -0.08351982f, -0.01660316f, 
    -0.01588005f, -0.03334997f, 0.05669217f, 0.00398161f, -0.04211111f, -0.05482667f, 0.02936298f, -0.07677019f, 
    0.00782948f, -0.03489339f, 0.06183189f, -0.01937260f, 0.04114236f, -0.06557525f, -0.01885154f, -0.04748654f, 
    0.04980728f, -0.02168317f, 0.02320703f, -0.00645268f, 0.04928480f, -0.00546103f, -0.04628276f, -0.00871249f, 
    -0.05099754f, -0.04784755f, -0.06730646f, -0.02702876f, -0.04959981f, 0.00314736f, 0.06114077f, -0.05865516f, 
    0.04132435f, 0.00883916f, -0.02864449f, -0.00294790f, -0.08091778f, 0.03997068f, 0.04530104f, -0.04189305f, 
    -0.05252531f, -0.00806082f, 0.00234047f, -0.06445491f, 0.02245876f, 0.00741806f, -0.06725273f, -0.05401045f, 
    -0.08072615f, -0.00903769f, -0.03142938f, -0.05989914f, 0.03826731f, 0.00152032f, -0.04830916f, -0.04473526f, 
    -0.06984679f, -0.07483907f, -0.07354245f, -0.07400732f, -0.04408733f, 0.04823491f, -0.06538917f, -0.05575123f, 
    0.04473308f, -0.02655547f, -0.07472961f, -0.07582083f, -0.00405392f, 0.06512908f, -0.05663513f, 0.02115176f, 
    -0.03950487f, 0.02390265f, -0.07292689f, -0.03828453f, 0.03473062f, -0.05444846f, 0.06226809f, 0.01663125f, 
    -0.05702880f, 0.04703587f, 0.01568232f, -0.00371717f, -0.01075784f, 0.01947751f, 0.00074773f, 0.00403744f, 
    -0.02668728f, -0.04157263f, 0.05837862f, -0.04032512f, 0.01688041f, 0.01241760f, 0.05318090f, -0.01578478f, 
    -0.03317319f, 0.04341173f, -0.03537752f, -0.07808851f, 0.02413802f, -0.02230730f, -0.07786593f, 0.00264485f, 
    0.08435182f, 0.07506002f, 0.01620669f, 0.06757781f, 0.01574365f, 0.07436676f, 0.09536876f, -0.01909962f, 
    0.01699179f, -0.16666877f, -0.12620401f, -0.21483049f, 0.04963694f, 0.04863572f, 0.20389184f, -0.32249516f, 
    0.06975166f, 0.09951643f, 0.06211840f, 0.16712102f, 0.03942348f, -0.06506129f, 0.03260282f, 0.17908786f, 
    -0.04921157f, -0.10372297f, 0.16482569f, -0.19048694f, 0.15983328f, 0.12466670f, 0.21776587f, 0.07436875f, 
    0.00350120f, 0.02971303f, -0.11359832f, 0.08343272f, -0.20298888f, -0.15422221f, -0.10783689f, -0.12975657f, 
    0.11561344f, 0.07124498f, 0.18009648f, 0.09624521f, 0.07596526f, -0.03713362f, -0.06955846f, -0.03569647f, 
    0.02402529f, -0.01282333f, -0.00859839f, -0.12442454f, -0.33603516f, 0.22213353f, 0.07134091f, 0.02167152f, 
    0.01262530f, -0.06054993f, -0.03792481f, 0.04535418f, 0.07717013f, 0.15337068f, -0.16214281f, 0.08530495f, 
    -0.00699179f, 0.03349918f, -0.10687590f, 0.08139327f, 0.06912417f, 0.03776376f, 0.09690017f, -0.03281568f, 
    -0.27650955f, 0.06972913f, -0.52315015f, 0.04880795f, -0.02576415f, -0.03459747f, 0.20887671f, -0.14741319f, 
    -0.00530935f, 0.05339679f, 0.15642577f, 0.02631075f, -0.01956231f, -0.12275326f, -0.01258506f, -0.04036598f, 
    0.07691611f, -0.05246259f, 0.08745858f, 0.03662076f, -0.07571587f, -0.08384725f, -0.09468152f, -0.09631045f, 
    -0.01142795f, -0.06393522f, -0.17578262f, 0.07692484f, -0.01591064f, 0.04585247f, -0.00942060f, 0.04733351f, 
    0.12013920f, 0.14858457f, -0.08586246f, -0.17469287f, -0.28025278f, -0.08339588f, -0.01075130f, -0.26434052f, 
    -0.04426668f, -0.02648864f, 0.22635373f, 0.03592362f, 0.01638234f, -0.02270320f, 0.14148828f, 0.17585634f, 
    -0.05401976f, 0.15356931f, -0.03068287f, 0.09113240f, 0.05001714f, 0.08911320f, -0.08820866f, 0.07078084f, 
    -0.33098638f, 0.05379214f, -0.11643523f, -0.07519629f, -0.14650212f, -0.05791594f, -0.11813800f, -0.03513571f, 
    0.00714404f, 0.09071391f, 0.04084380f, 0.01169985f, -0.04298670f, 0.06352388f, -0.00981807f, -0.02369851f, 
    0.06181032f, -0.07512860f, -0.10729238f, -0.27399981f, 0.09998832f, -0.16987339f, -0.11960132f, 0.04940484f, 
    -0.01535344f, 0.03063189f, -0.00687967f, 0.05110392f, 0.11320748f, -0.02755655f, -0.19215894f, -0.16074850f, 
    0.09358609f, 0.06903791f, 0.09738267f, 0.00204679f, 0.12810785f, 0.30496255f, 0.21606289f, -0.06692417f, 
    -0.13906474f, -0.09103695f, -0.39246458f, 0.12789281f, 0.10525031f, 0.04110684f, -0.01279690f, -0.02382464f, 
    0.09121791f, -0.04460689f, 0.07594115f, -0.06229981f, 0.25587782f, 0.06652850f, 0.30539703f, 0.06218699f, 
    0.12849832f, -0.10738818f, -0.13729709f, 0.10284507f, 0.07559337f, 0.05298228f, 0.08354313f, 0.10510996f, 
    -0.02774100f, 0.17958154f, 0.02593287f, -0.15602243f, -0.10046782f, -0.03303030f, 0.06973393f, 0.12214530f, 
    -0.12543848f, 0.05752277f, -0.09245798f, -0.00135337f, 0.17013647f, 0.14119489f, -0.10403366f, 0.04493694f, 
    0.12130167f, -0.00060669f, -0.00320208f, -0.15256198f, -0.04210685f, 0.00510587f, -0.10299573f, -0.02701126f, 
    -0.56545645f, 0.34677801f, -0.23058638f, -0.13089769f, -0.03054002f, 0.13018744f, 0.00306740f, 0.03450244f, 
    -0.16626312f, 0.05436063f, -0.07663862f, -0.04217653f, -0.14349934f, -0.15240733f, -0.33265769f, 0.16700353f, 
    -0.10599460f, 0.09340792f, -0.04196481f, -0.04145049f, -0.07855812f, 0.05917526f, -0.16076644f, 0.01192786f, 
    -0.07440546f, -0.01043935f, -0.08233585f, 0.13813922f, -0.13425703f, -0.17474654f, 0.15738578f, -0.13239713f, 
    -0.16524315f, 0.05272466f, 0.05034406f, 0.12188133f, -0.12598392f, -0.09823717f, -0.04599971f, 0.14392085f, 
    0.12202922f, 0.11915827f, 0.07525416f, 0.12185325f, 0.10097156f, 0.00639457f, 0.11386418f, 0.10901956f, 
    0.08848647f, -0.14592808f, 0.28269225f, -0.31741604f, -0.14590181f, -0.05442512f, 0.08341113f, 0.08107243f, 
    0.04891199f, -0.07442590f, -0.08032209f, 0.27946904f, -0.02591223f, 0.22990376f, -0.15829064f, -0.04947769f, 
    0.10246175f, 0.02382176f, 0.00699818f, -0.00516244f, 0.15523593f, -0.03704359f, -0.01485028f, -0.07255679f, 
    -0.09005562f, 0.30437490f, 0.11060510f, -0.21606165f, 0.03024321f, 0.05410725f, -0.00751021f, 0.01014113f, 
    -0.07238372f, 0.14869447f, -0.08946825f, 0.02215312f, -0.07064092f, 0.22016996f, 0.02991924f, 0.40442792f, 
    0.20865425f, 0.03960094f, -0.04099728f, 0.07911982f, 0.01470770f, 0.09905294f, -0.03347607f, 0.09697460f, 
    -0.16286013f, 0.22480485f, 0.23231035f, -0.20443052f, 0.05286833f, -0.04649925f, 0.11854035f, 0.02264620f, 
    -0.16713154f, 0.03526940f, -0.07343972f, -0.00618905f, 0.02245901f, 0.31715423f, -0.15925719f, -0.20868620f, 
    -0.07528746f, 0.02436267f, -0.03473257f, -0.00697115f, 0.07841299f, 0.05286967f, 0.12635832f, -0.13391921f, 
    0.25294280f, -0.04515798f, 0.02421156f, 0.12686622f, 0.08305085f, 0.07651080f, -0.06361078f, -0.00409478f, 
    -0.08167249f, -0.01028291f, -0.14359054f, -0.05602152f, 0.40969869f, 0.21067129f, 0.13698354f, 0.42876929f, 
    0.06061894f, -0.07363663f, 0.04656357f, 0.05234704f, -0.10798343f, 0.07324440f, -0.05348722f, 0.11174407f, 
    0.13867831f, 0.16988401f, 0.31704518f, -0.35994551f, -0.13884369f, 0.03530537f, -0.07308682f, -0.03861441f, 
    -0.00318020f, 0.14059451f, 0.01390740f, 0.03376901f, 0.09324053f, 0.28193575f, -0.00593273f, 0.00276489f, 
    0.16956551f, -0.06871331f, -0.04234458f, -0.20698068f, -0.04734138f, 0.04518780f, 0.04743965f, 0.00812284f, 
    -0.05016859f, -0.02755150f, 0.05668945f, 0.06016980f, -0.08790325f, -0.14652315f, 0.05927899f, -0.35209644f, 
    0.14014322f, 0.06795830f, -0.00096898f, 0.22464806f, 0.73896182f, 0.31076989f, 0.05833679f, -0.02264692f, 
    -0.09184036f, 0.03905220f, 0.05449597f, 0.30855832f, 0.07148309f, 0.08331708f, 0.05201170f, 0.09508836f, 
    0.23888260f, 0.32010528f, -0.04578248f, 0.12965813f, 0.16089556f, 0.37495014f, -0.00901063f, 0.08693731f, 
    -0.02761972f, -0.00283630f, -0.11784801f, 0.15374723f, 0.17795914f, -0.00125625f, 0.14000419f, 0.14469562f, 
    -0.02610959f, 0.09610306f, 0.05999677f, 0.27616692f, 0.03428407f, 0.02711744f, 0.11404595f, -0.02347311f, 
    -0.54875803f, -0.03976388f, 0.22920497f, 0.04163451f, 0.09075815f, 0.21818478f, -0.18579958f, 0.07150690f, 
    -0.29802799f, -0.41906238f, -0.08064575f, -0.46012169f, -0.43057445f, -0.15841997f, 0.10354234f, 0.07367700f, 
    -0.08330267f, 0.07018453f, -0.02128978f, -0.17229523f, 0.10560789f, 0.12098055f, 0.00923367f, -0.07267950f, 
    -0.21226269f, 0.30077755f, -0.13429755f, 0.42886934f, 0.15531199f, 0.09513843f, 0.07539760f, -0.05617555f, 
    0.17562391f, 0.13783777f, 0.19908378f, 0.20111229f, 0.07540225f, 0.03285529f, -0.09122451f, -0.08864423f, 
    -0.02375780f, -0.23267657f, -0.36499432f, -0.16187461f, -0.12082914f, -0.09516438f, 0.10565127f, -0.26763344f, 
    0.08229584f, 0.30021930f, -0.09234624f, 0.20017122f, -0.04950517f, -0.16902459f, 0.09934065f, -0.07743313f, 
    -0.15176398f, 0.04167788f, 0.22538595f, 0.05759431f, -0.00000502f, 0.06418795f, 0.26842085f, 0.09521858f, 
    -0.11727618f, -0.06065355f, 0.18633378f, 0.00023877f, 0.10252709f, 0.11194718f, 0.11634639f, 0.28447098f, 
    0.24172275f, 0.12601180f, -0.23550136f, -0.19789018f, 0.01589755f, -0.26903772f, -0.18011424f, 0.16772093f, 
    -0.01907856f, -0.07259195f, -0.28430870f, -0.20516543f, 0.00081875f, 0.16495512f, 0.03245906f, -0.02089004f, 
    0.12526990f, 0.04624191f, -0.03765879f, 0.00538556f, -0.25267115f, -0.30048525f, -0.32367799f, -0.50448978f, 
    0.12511069f, -0.04826951f, -0.16545536f, 0.07100125f, 0.07022109f, 0.20765127f, -0.06475480f, 0.04035225f, 
    -0.00612151f, -0.18177055f, -0.15693392f, -0.01115556f, -0.04695491f, 0.27976605f, 0.15208578f, -0.16942047f, 
    -0.14850476f, 0.05382401f, -0.10780876f, -0.29363328f, -0.07698876f, -0.09457774f, -0.14448445f, -0.06969243f, 
    -0.26250821f, 0.26422375f, 0.02664768f, -0.05896204f, 0.11208744f, -0.07996260f, -0.18101285f, 0.15221418f, 
    0.11260634f, -0.15813646f, -0.00394780f, -0.13218078f, 0.66144675f, -0.24134678f, 0.47552145f, 0.28870097f, 
    0.12225546f, -0.18758474f, 0.12601221f, -0.02692166f, -0.01682294f, 0.07155705f, 0.14528987f, 0.10944314f, 
    -0.24528748f, -0.03744391f, -0.00159888f, -0.08216353f, 0.01146498f, -0.00236816f, -0.06102689f, -0.02274294f, 
    -0.08843437f, -0.08356706f, 0.01240158f, 0.10624426f, -0.04100988f, -0.05428544f, -0.06807948f, 0.03531415f, 
    -0.08548360f, 0.10730565f, 0.02644378f, 0.00053692f, 0.13993983f, 0.06912004f, -0.04353164f, 0.02308538f, 
    -0.24299909f, 0.22476676f, 0.33725077f, 0.12717719f, 0.21160291f, 0.11081865f, -0.03780788f, -0.04613055f, 
    0.11421918f, -0.12538168f, -0.02457090f, 0.09226207f, 0.14935209f, 0.41526484f, 0.26276231f, 0.17805658f, 
    0.17295635f, 0.07634342f, 0.14221826f, 0.05996107f, -0.00137573f, 0.03081273f, 0.08196913f, 0.01687149f, 
    0.15839133f, 0.07978961f, -0.23909524f, 0.25008574f, -0.04993961f, 0.20999715f, 0.24556684f, 0.03391938f, 
    -0.10650649f, 0.07535240f, 0.00152983f, 0.01433068f, -0.14385857f, -0.06379491f, 0.24457641f, -0.00734048f, 
    -0.00398110f, 0.10442924f, 0.08378897f, 0.04898956f, -0.09219738f, 0.11133719f, 0.04113756f, 0.03453904f, 
    0.10824246f, -0.05592148f, 0.05264537f, -0.14540532f, 0.01475854f, 0.08846309f, -0.04713732f, 0.12861705f, 
    0.01935750f, -0.05763494f, -0.05988516f, 0.01758713f, -0.19264473f, -0.13587163f, 0.05497329f, 0.13561454f, 
    -0.08014742f, 0.00162840f, -0.05389748f, 0.00249825f, 0.08009525f, -0.09472519f, 0.15987034f, -0.06862155f, 
    -0.40397212f, -0.46548694f, -0.14785245f, 0.16825104f, -0.09336168f, -0.06974459f, -0.04808675f, -0.05950954f, 
    0.05461828f, -0.13812129f, -0.10868450f, 0.03166884f, 0.33356673f, -0.12241352f, -0.21250452f, 0.20730618f, 
    0.01551991f, -0.06027289f, -0.10450516f, 0.24873488f, 0.07219770f, 0.10531395f, -0.14122772f, 0.02940646f, 
    -0.20711958f, 0.04723290f, -0.00913676f, 0.21009372f, -0.00287658f, 0.00140465f, 0.01140651f, -0.08271680f, 
    0.01856435f, 0.06247523f, 0.05011250f, -0.03390339f, -0.21249516f, -0.06369841f, 0.32006204f, 0.05092934f, 
    -0.03712133f, -0.04276273f, 0.17792915f, -0.02004579f, 0.15959419f, 0.06520787f, -0.18048230f, -0.02998682f, 
    0.12714511f, 0.25264835f, 0.28871092f, -0.02623659f, -0.05543253f, 0.01852492f, 0.12731747f, 0.07102908f, 
    0.02092469f, 0.06879976f, 0.00865230f, -0.04847281f, 0.19083509f, -0.15211575f, 0.01497236f, -0.29544660f, 
    -0.09069811f, 0.01119214f, 0.01631268f, 0.09962699f, -0.06692333f, -0.13154116f, -0.00433607f, -0.25929397f, 
    0.13628782f, -0.30640706f, 0.09949081f, 0.02152296f, 0.01123683f, 0.09423967f, 0.04539333f, 0.00182068f, 
    0.09188729f, -0.01723443f, 0.00463271f, -0.10888255f, 0.02481378f, 0.29821756f, -0.19520323f, -0.06718697f, 
    0.10911383f, -0.16485403f, -0.09757350f, -0.24981195f, -0.04082129f, 0.09330236f, 0.03619432f, 0.03711264f, 
    -0.07060999f, 0.04818211f, -0.02726694f, -0.12257939f, 0.14364332f, 0.03013265f, 0.00476505f, 0.26749808f, 
    0.29621646f, 0.12978834f, 0.03849291f, -0.02442055f, -0.71139342f, -0.24754418f, 0.35792109f, -0.10238108f, 
    0.17331783f, 0.00829104f, -0.00943781f, -0.01232642f, -0.01365590f, 0.03321280f, -0.01987564f, 0.09423124f, 
    -0.49721107f, 0.12806498f, -0.05621920f, 0.29159445f, -0.01098303f, -0.04701745f, -0.15782312f, 0.25820762f, 
    -0.03479275f, 0.11554126f, 0.09184396f, 0.06629144f, -0.23415674f, -0.10821926f, -0.12049319f, 0.19660039f, 
    0.07083671f, 0.05139076f, 0.20866844f, 0.12855506f, 0.00727456f, -0.05263712f, -0.05403164f, -0.01440720f, 
    0.05703825f, -0.23854454f, -0.38670892f, 0.14698994f, 0.09132463f, 0.15290928f, 0.11232305f, -0.09899452f, 
    0.11861735f, -0.08075298f, -0.07656741f, 0.05688620f, -0.17297390f, 0.24060674f, -0.01923881f, -0.11719061f, 
    0.12347870f, 0.10252883f, -0.05467411f, 0.05863183f, -0.02549594f, -0.28511158f, -0.10444465f, -0.09853183f, 
    0.03183974f, -0.12092508f, 0.06031396f, -0.11243531f, 0.00468084f, 0.16007715f, 0.12284658f, 0.08463320f, 
    0.03768206f, -0.00418308f, 0.06233368f, -0.17869233f, -0.12311868f, -0.10134785f, 0.18872860f, 0.05584899f, 
    -0.01980046f, -0.04242806f, 0.05475568f, -0.04620658f, 0.01908120f, -0.05547112f, 0.02349650f, 0.16182713f, 
    -0.01818768f, 0.24612474f, 0.12689264f, 0.21592300f, -0.08092950f, 0.12939265f, -0.14516842f, -0.00242374f, 
    0.04993089f, -0.09405877f, -0.20176865f, 0.00300040f, -0.06716865f, 0.31482688f, 0.25708261f, 0.09834746f, 
    0.10411942f, 0.05224692f, -0.10645095f, 0.00339160f, 0.01636002f, 0.09433188f, 0.09524108f, -0.05993828f, 
    -0.22154154f, 0.01306777f, 0.28706381f, 0.20572038f, 0.05518222f, -0.01130956f, -0.20600943f, 0.07954783f, 
    0.11716105f, 0.18761165f, 0.22740136f, 0.07587955f, 0.02802625f, 0.28658220f, -0.11230093f, 0.24210954f, 
    0.00670250f, -0.09653164f, -0.06044304f, -0.01804670f, -0.06224240f, 0.09695780f, 0.08829415f, 0.11664508f, 
    -0.03320694f, -0.27908403f, 0.10818803f, 0.15885310f, 0.01383165f, -0.08302172f, 0.19032916f, 0.14850776f, 
    0.07305393f, 0.01408617f, 0.04029970f, 0.10247741f, -0.06335295f, 0.36320570f, 0.49637043f, 0.15257762f, 
    0.05963600f, -0.10662933f, -0.11391827f, 0.03247373f, 0.09323373f, 0.07123558f, 0.18694618f, 0.11987749f, 
    0.09950010f, -0.37236288f, 0.16355741f, 0.39868993f, -0.04702596f, 0.03112325f, 0.11748460f, 0.00428815f, 
    0.03813906f, -0.05391527f, 0.03502264f, 0.04170877f, -0.43773121f, -0.01662103f, 0.19013388f, -0.02406286f, 
    -0.02017372f, 0.06671210f, 0.04598847f, 0.12925911f, -0.07707586f, -0.00627027f, -0.07562007f, -0.06348401f, 
    0.00569984f, 0.17319754f, 0.26640069f, -0.11795389f, -0.00381469f, -0.08834038f, -0.08588838f, -0.02865391f, 
    0.06254164f, -0.04340740f, 0.03880722f, 0.13770239f, 0.23550537f, -0.22596774f, 0.35530970f, -0.06183863f, 
    -0.12602763f, 0.17462066f, -0.26606795f, 0.00640668f, 0.12110496f, -0.02050691f, -0.08670400f, 0.09048992f, 
    -0.62903506f, 0.20340605f, -0.11604151f, 0.05644753f, -0.02944354f, 0.05666825f, 0.12823355f, 0.00782203f, 
    -0.01358880f, -0.07228098f, -0.00738508f, -0.07010037f, -0.11084159f, 0.03606195f, -0.05390808f, -0.04496796f, 
    0.01460492f, -0.12034836f, -0.05131806f, 0.20049487f, -0.04946137f, 0.02113328f, -0.14048219f, -0.10766442f, 
    -0.01810099f, -0.21414658f, -0.22379434f, -0.05097377f, -0.00244418f, 0.13015525f, 0.13009746f, -0.00760112f, 
    -0.05936920f, -0.00944948f, -0.00423857f, 0.05520131f, -0.00759916f, 0.07911058f, 0.09228379f, -0.15636426f, 
    0.15289600f, 0.07862314f, 0.21153691f, 0.24274762f, 0.13450308f, -0.01453119f, 0.11118286f, 0.01328532f, 
    -0.20724824f, 0.13710546f, -0.24275956f, -0.04911699f, 0.03176720f, -0.10489146f, 0.22012256f, 0.05708363f, 
    -0.03984198f, -0.12200809f, -0.07478335f, 0.08409832f, 0.09747382f, 0.08928714f, 0.29659125f, 0.12331805f, 
    0.03416774f, -0.02614068f, -0.04193847f, 0.02949020f, 0.03148848f, 0.03667634f, 0.04850153f, 0.01922621f, 
    -0.20881255f, -0.07596941f, 0.09951574f, 0.20056853f, -0.13078560f, 0.12089044f, 0.02112297f, 0.03880198f, 
    0.03542802f, -0.09050833f, 0.06741466f, 0.04384313f, 0.19176587f, -0.19592150f, 0.18984967f, 0.14980538f, 
    0.14773482f, -0.18912321f, -0.23029464f, 0.05565342f, 0.08878948f, 0.04158856f, -0.18883020f, 0.01825310f, 
    0.09007386f, 0.09037469f, 0.19081432f, 0.15468571f, -0.03011508f, -0.06703829f, -0.03450824f, -0.05522044f, 
    0.00563585f, 0.07166245f, 0.07625592f, 0.01970760f, -0.15744130f, 0.08548783f, 0.07993061f, 0.02944667f, 
    -0.10882722f, 0.14649653f, -0.01059564f, -0.00177011f, 0.11163310f, 0.01656924f, -0.00306313f, -0.11372309f, 
    -0.00720419f, 0.21321686f, 0.08605514f, 0.07962322f, -0.08995283f, 0.04056508f, 0.07799289f, 0.14488886f, 
    0.04636034f, 0.01462227f, 0.06539781f, -0.06709946f, 0.66878521f, -0.16234073f, 0.53985429f, -0.50866967f, 
    -0.17124914f, -0.13901512f, -0.00963612f, -0.03626474f, -0.12327550f, 0.13327160f, 0.08639202f, -0.06088260f, 
    -0.22080877f, -0.06199147f, -0.10651837f, 0.01017831f, 0.08139725f, 0.08858904f, 0.02338776f, -0.07862052f, 
    0.10409981f, -0.00616181f, 0.03802628f, -0.00622606f, 0.30140188f, 0.09598139f, 0.37573352f, 0.15540394f, 
    -0.06097150f, -0.07413498f, -0.15374102f, -0.14990342f, 0.04629116f, 0.03680510f, 0.17252581f, 0.10738394f, 
    -0.08050986f, 0.19472037f, 0.16166596f, -0.07928925f, 0.01704328f, 0.09938764f, 0.05269523f, -0.15945217f, 
    0.05782092f, 0.16347173f, -0.26888067f, 0.02646552f, 0.45077771f, -0.14958930f, -0.20978491f, -0.09628933f, 
    -0.05010732f, 0.33084413f, -0.09165985f, -0.22115701f, -0.02713697f, -0.04723749f, -0.02509621f, -0.09553233f, 
    0.13522552f, -0.14665595f, -0.51225311f, -0.05176626f, -0.12068949f, -0.06268795f, 0.08555208f, -0.02203557f, 
    -0.08252508f, 0.07696532f, -0.02865452f, -0.03235482f, -0.03624457f, -0.11359087f, -0.11758336f, 0.09641365f, 
    0.04255270f, 0.09431726f, 0.03403655f, 0.21196984f, -0.11661858f, 0.07002871f, -0.10272452f, -0.04042914f, 
    -0.12684026f, 0.04307690f, 0.15663956f, 0.02633133f, 0.05208108f, -0.09557139f, -0.21189277f, 0.13323168f, 
    -0.10181211f, 0.11938786f, -0.04539910f, -0.10441973f, -0.22282816f, 0.03341186f, 0.14941353f, 0.12162516f, 
    -0.00420895f, 0.10562133f, -0.03175637f, 0.18135712f, 0.10331251f, 0.18541639f, 0.03722016f, 0.05175728f, 
    -0.06655701f, 0.03743898f, 0.05391468f, 0.06274556f, -0.19109307f, -0.09904727f, 0.16182758f, 0.03412262f, 
    0.05506517f, 0.01198130f, 0.06550232f, 0.31412768f, 0.13403049f, 0.12714076f, 0.10940867f, -0.06084087f, 
    0.17976502f, 0.00498651f, 0.10653412f, 0.06416184f, -0.13219191f, 0.16055122f, -0.18631114f, 0.09623782f, 
    0.26723051f, 0.50197655f, 0.30968004f, -0.16888298f, 0.05672241f, -0.04450924f, -0.07347028f, 0.04899064f, 
    -0.16342597f, 0.08131957f, -0.03241372f, 0.05802123f, 0.09243319f, -0.08235938f, 0.25038654f, 0.31099081f, 
    0.12648901f, 0.10938615f, 0.09246763f, -0.00391248f, -0.10791513f, -0.01669067f, -0.09475969f, 0.16314505f, 
    0.12308007f, 0.29592541f, 0.13098557f, -0.41170686f, 0.01445064f, 0.02054138f, 0.02041734f, 0.00903266f, 
    -0.18399763f, 0.01050554f, 0.09685765f, 0.09730124f, 0.31285143f, 0.01547156f, -0.21786653f, -0.04526491f, 
    0.02536913f, -0.18392247f, -0.09848108f, -0.06731584f, -0.07684661f, -0.11993442f, 0.11341929f, -0.07874019f, 
    0.15530729f, -0.22954299f, -0.10897860f, 0.06558147f, -0.01205371f, -0.05135461f, -0.01445425f, -0.09740362f, 
    -0.16881406f, -0.01280088f, -0.13166428f, -0.04018174f, -0.01846395f, -0.22129914f, 0.14673607f, 0.36792970f, 
    -0.03453250f, -0.09185608f, 0.23077534f, 0.12130839f, 0.04698496f, 0.18798785f, 0.08508825f, 0.03131346f, 
    -0.04746165f, 0.39165193f, 0.02958087f, 0.09180381f, -0.14579877f, 0.03422518f, 0.03219709f, 0.04360665f, 
    -0.02969487f, -0.02016559f, -0.05330912f, 0.08481446f, 0.57009095f, -0.11539217f, 0.02866441f, -0.04434118f, 
    0.13314240f, 0.10646938f, 0.06102121f, -0.01208357f, -0.03310677f, -0.13777469f, -0.04319678f, -0.00239156f, 
    0.05660552f, 0.09315775f, 0.12449396f, 0.11080534f, 0.00218059f, 0.07515155f, 0.02174752f, 0.06095231f, 
    0.28055951f, 0.35176679f, 0.20017351f, -0.12645586f, -0.45960990f, -0.05145568f, 0.06605264f, -0.08334555f, 
    0.23462343f, 0.20201114f, -0.14111625f, 0.07002505f, 0.31688797f, -0.05066577f, -0.00460598f, 0.01894897f, 
    -0.36785549f, -0.17888696f, -0.27177739f, 0.29223326f, 0.09574216f, -0.21342422f, 0.36449224f, 0.20160241f, 
    0.11003159f, 0.04977142f, 0.21898083f, 0.04062921f, -0.20663874f, -0.12703672f, -0.07187045f, -0.03469673f, 
    -0.01012873f, -0.04346653f, 0.12808560f, -0.01994083f, 0.06291131f, -0.02416911f, -0.10244729f, 0.24613845f, 
    -0.08322233f, -0.02058924f, -0.12439222f, -0.16077372f, 0.02774728f, 0.08399781f, 0.04391034f, -0.09868253f, 
    0.04161178f, 0.02442763f, -0.00197682f, 0.13202617f, -0.15834947f, 0.04116699f, -0.12146781f, -0.06419932f, 
    -0.07266541f, -0.11200821f, 0.05090666f, 0.05022180f, 0.04362975f, -0.27057612f, -0.22474606f, -0.00404344f, 
    0.08644263f, -0.27964717f, 0.18968379f, -0.13137668f, 0.12713440f, 0.18916491f, 0.10035551f, 0.28346291f, 
    -0.10303011f, -0.00527751f, -0.20818131f, -0.18918678f, -0.08419324f, -0.01172442f, 0.13595791f, 0.05909490f, 
    -0.05503510f, -0.10791009f, -0.08215830f, -0.10430734f, 0.14981639f, 0.15316594f, 0.08282086f, 0.21240027f, 
    0.08486181f, 0.46219203f, 0.34716478f, 0.12480028f, -0.14068481f, 0.00624108f, -0.09974828f, -0.08678943f, 
    0.08740190f, 0.00814618f, -0.10315416f, -0.15853070f, 0.13658696f, 0.33758107f, 0.15480141f, -0.08254627f, 
    0.07419655f, 0.06438518f, 0.10571539f, -0.03370288f, 0.08362096f, -0.05121635f, 0.13068148f, -0.20527431f, 
    -0.21137956f, -0.08660804f, 0.07866961f, 0.13939098f, -0.02823485f, -0.09882290f, -0.01913793f, -0.01341715f, 
    0.32337177f, 0.12297992f, 0.42415345f, 0.31714720f, 0.10893749f, 0.04770064f, -0.18467914f, 0.03344425f, 
    0.01970305f, -0.08771861f, -0.03686498f, -0.00465575f, -0.02838388f, 0.01983164f, 0.10105544f, 0.10985310f, 
    -0.19463310f, -0.09394771f, 0.14136064f, 0.09827892f, 0.09044760f, -0.00964530f, 0.10904581f, 0.08568566f, 
    -0.06230401f, 0.07887506f, -0.03902138f, -0.04151279f, 0.11999727f, -0.04334519f, 0.39369884f, -0.10248061f, 
    0.00193275f, -0.01343547f, 0.16339822f, 0.02421587f, 0.25838020f, 0.30825108f, 0.15223387f, 0.07380056f, 
    0.29763293f, 0.20914945f, -0.06665347f, 0.09712520f, 0.02183685f, 0.09796159f, -0.05637308f, -0.09553155f, 
    -0.04560645f, -0.02614282f, -0.09165099f, 0.11566344f, -0.39045799f, -0.16903964f, -0.10464294f, -0.04077486f, 
    -0.04542055f, 0.00803867f, -0.07459704f, 0.06281544f, 0.08024398f, -0.13716353f, 0.04428305f, -0.11746631f, 
    -0.05006736f, -0.08909382f, -0.04635333f, -0.06069155f, 0.03135735f, -0.12676510f, -0.06167703f, 0.06277112f, 
    -0.08693729f, -0.29862437f, 0.06495532f, -0.15088828f, 0.03333832f, 0.03668103f, 0.20188427f, -0.05828720f, 
    0.00251759f, -0.01175177f, 0.10928677f, 0.09989708f, -0.08226480f, 0.02760781f, -0.00459698f, -0.10357547f, 
    0.41628453f, 0.24473576f, 0.50005531f, -0.17973520f, -0.11436318f, 0.03973637f, 0.05956369f, -0.08959424f, 
    0.07134151f, 0.04721277f, -0.07225662f, 0.08934055f, 0.26841572f, 0.26821956f, 0.30558136f, -0.02556232f, 
    0.15625305f, 0.04738253f, 0.12441433f, -0.02831562f, 0.05606339f, 0.01877014f, 0.17039628f, 0.01031676f, 
    0.14060254f, 0.04257106f, -0.05857390f, 0.04393832f, 0.16009286f, 0.09290459f, -0.02161534f, -0.01107922f, 
    0.13292041f, 0.01429275f, -0.00960493f, 0.13557304f, 0.15711446f, 0.02959493f, 0.01885887f, -0.04745481f, 
    0.03205294f, 0.06168188f, 0.13595681f, -0.05232463f, -0.16075772f, -0.09286933f, 0.00655753f, -0.03680478f, 
    -0.08335783f, 0.15732339f, -0.20713280f, 0.37855056f, 0.00817556f, -0.07245409f, -0.06064202f, -0.05938105f, 
    -0.15018880f, 0.06347179f, 0.16695872f, -0.13308816f, 0.11542199f, -0.06956714f, -0.00869159f, -0.10660655f, 
    -0.04563867f, 0.00940206f, 0.04333394f, -0.04346469f, 0.03976008f, -0.05275794f, 0.18372886f, 0.09622050f, 
    0.47809261f, -0.36772457f, 0.12773313f, 0.02086182f, -0.06129816f, -0.01035306f, -0.01037021f, -0.03986424f, 
    0.03907415f, -0.07693245f, -0.00867353f, 0.18082780f, 0.03025591f, -0.25806370f, -0.26126251f, -0.14590432f, 
    0.04996326f, 0.02545372f, 0.11588871f, 0.06086743f, -0.03730049f, 0.00267157f, -0.20579532f, -0.10637418f, 
    0.11635435f, -0.14905830f, -0.01046618f, -0.08686436f, -0.06643359f, 0.05586894f, -0.11837962f, 0.03313578f, 
    0.11538125f, 0.00485851f, 0.02385495f, -0.09266257f, 0.10774086f, 0.09854485f, 0.26229981f, 0.07735714f, 
    -0.07019303f, -0.12904818f, 0.05907174f, 0.05921397f, 0.10563567f, 0.11168952f, -0.01463601f, 0.27211818f, 
    0.00939716f, 0.19654848f, -0.01458021f, -0.18009001f, 0.00851242f, 0.02334788f, 0.01460877f, 0.08300626f, 
    -0.04865801f, 0.02210996f, 0.12575188f, 0.23314869f, -0.19923548f, -0.30871016f, -0.08352498f, 0.14818560f, 
    0.04697100f, 0.11505555f, -0.08773828f, -0.06474073f, 0.24728899f, -0.07080700f, 0.38504976f, -0.04187410f, 
    0.01760129f, -0.45003349f, -0.28575155f, 0.56156850f, -0.03891353f, -0.03581350f, 0.00185334f, -0.04473176f, 
    0.03189895f, -0.00703382f, 0.04290775f, 0.01822874f, -0.07737283f, -0.04091315f, -0.15861636f, -0.15774316f, 
    -0.03348018f, 0.12056336f, 0.01248569f, 0.11116248f, 0.05315388f, 0.02169833f, -0.07981898f, -0.10353032f, 
    -0.02521819f, -0.05556922f, -0.00365110f, -0.06083248f, -0.06579436f, 0.02402111f, 0.03835028f, -0.05735349f, 
    -0.00079362f, -0.07327112f, 0.03599734f, 0.00840923f, -0.00295356f, -0.05924599f, -0.03741201f, -0.03263251f, 
    -0.00564768f, -0.01591455f, -0.06108338f, -0.06831857f, 0.05822946f, 0.02070057f, 0.00843243f, -0.01340971f, 
    -0.00622260f, 0.03127678f, -0.00966470f, 0.02980065f, 0.02720622f, 0.03571456f, -0.01226717f, 0.02316910f, 
    -0.04419481f, -0.05726847f, 0.05090111f, -0.01186413f, -0.01639809f, 0.01136644f, -0.03663969f, -0.04611598f, 
    -0.01857044f, 0.05444983f, -0.04685766f, 0.03221293f, -0.02298833f, 0.02789026f, -0.00921476f, -0.01821177f, 
    0.05744302f, 0.01626181f, 0.04446281f, -0.04182614f, 0.01739567f, -0.04781636f, -0.03900045f, 0.00468592f, 
    0.00019050f, 0.04134797f, -0.04836469f, 0.03674434f, -0.05680838f, -0.02801677f, -0.04638625f, 0.05255203f, 
    -0.06077490f, 0.01928998f, 0.05106556f, -0.02379785f, 0.02160466f, -0.02956280f, -0.05599948f, -0.06942813f, 
    0.01661268f, -0.07491920f, 0.01626752f, 0.02503621f, 0.03332602f, -0.03160465f, -0.00152297f, 0.03509686f, 
    0.06323353f, -0.07659856f, 0.05411468f, -0.02054113f, -0.03100110f, 0.04550216f, -0.01655033f, 0.06155378f, 
    -0.00859336f, 0.05361231f, -0.04115980f, -0.06940030f, 0.01505817f, 0.03463584f, -0.04222232f, 0.00674858f, 
    0.05356666f, 0.02032628f, -0.05433365f, -0.02003173f, -0.03366134f, 0.06679205f, -0.04047872f, -0.07639959f, 
    0.01042007f, 0.01669896f, -0.07011352f, 0.00164063f, -0.03155362f, 0.04746530f, -0.03529142f, -0.02821983f, 
    0.01439667f, -0.06005452f, -0.06319370f, 0.02998388f, -0.05336815f, -0.06523088f, -0.04627648f, -0.06311461f, 
    0.01604406f, 0.05145942f, 0.02535335f, -0.00593767f, 0.02343522f, 0.02871938f, -0.05961338f, -0.02189013f, 
    0.05388311f, 0.02984107f, -0.01003216f, 0.03889827f, 0.00317005f, 0.02481519f, -0.00570772f, -0.03331190f, 
    -0.02613541f, 0.00013205f, -0.01662995f, -0.00621791f, 0.01588994f, -0.01113072f, -0.01888313f, -0.04604802f, 
    0.03557977f, -0.03644159f, -0.01088933f, -0.07665606f, -0.04299204f, -0.01659435f, -0.02957724f, 0.04293689f, 
    0.00986043f, 0.02784155f, -0.05700488f, 0.01288316f, 0.06574973f, 0.06249460f, 0.03954765f, 0.02853446f, 
    0.03170622f, -0.02359110f, -0.03942451f, -0.02447613f, 0.05723070f, -0.01550871f, 0.06919055f, -0.07450891f, 
    -0.04434463f, -0.06530038f, 0.02481209f, -0.07729618f, -0.02164964f, 0.02197489f, -0.07538063f, -0.05699251f, 
    0.05706683f, -0.07003463f, -0.00264144f, -0.05117458f, -0.02586279f, -0.04234452f, -0.01883291f, 0.01813730f, 
    -0.04021884f, -0.04860497f, 0.00220558f, -0.05576551f, -0.07639158f, 0.01646752f, 0.00654098f, 0.04024238f, 
    0.05381368f, -0.03263926f, 0.01792156f, -0.06413898f, -0.02833416f, -0.03963078f, 0.05689940f, -0.00900712f, 
    -0.04882805f, 0.00663870f, -0.02877381f, 0.03010624f, 0.00611855f, 0.04549022f, 0.00775896f, 0.02421776f, 
    -0.02631516f, -0.04730077f, 0.00529233f, -0.01738488f, 0.03598404f, -0.05851236f, -0.06591416f, -0.01287298f, 
    -0.05643336f, -0.05510853f, 0.04805192f, -0.01498541f, -0.04103204f, 0.03712252f, 0.00779704f, 0.00281451f, 
    0.05424993f, 0.05030810f, -0.02786755f, -0.00622420f, 0.05022342f, 0.02121954f, -0.01507351f, 0.01608698f, 
    -0.00014625f, -0.00277248f, 0.02999272f, -0.03099285f, -0.06091313f, 0.00890279f, -0.03898826f, -0.00296414f, 
    -0.04576942f, 0.01354364f, 0.02289691f, 0.03427198f, -0.06480403f, -0.04231147f, 0.00492131f, -0.05766924f, 
    -0.04248204f, -0.02045102f, -0.02144074f, -0.02558539f, 0.03579815f, 0.00421801f, 0.05851286f, -0.06736160f, 
    -0.03799624f, 0.00170870f, -0.03257712f, 0.00094372f, -0.06738512f, 0.03041369f, 0.04128319f, 0.03054290f, 
    -0.00949644f, -0.05184697f, -0.04779854f, -0.05480653f, -0.01203349f, -0.04036187f, -0.07688336f, 0.02641718f, 
    -0.05331420f, 0.00961316f, -0.04127622f, -0.00952113f, -0.00829384f, -0.02265980f, -0.05221871f, 0.05231088f, 
    0.03959861f, 0.05053294f, -0.00897576f, -0.07215222f, 0.04902834f, 0.05219999f, -0.03917176f, -0.01052834f, 
    -0.03166930f, -0.01684587f, -0.00336901f, -0.01407919f, 0.04803273f, -0.00294247f, -0.00657966f, -0.00855714f, 
    0.05546359f, -0.01900196f, 0.01936613f, -0.03505613f, 0.00595986f, -0.04671954f, -0.01405152f, -0.01053793f, 
    0.06403304f, -0.00497817f, -0.03809221f, 0.06556894f, -0.02157223f, 0.02282695f, -0.07757279f, -0.03969577f, 
    -0.02520901f, -0.02643256f, -0.01528117f, -0.05428826f, -0.00507257f, -0.05174877f, -0.01096990f, -0.03272462f, 
    0.03024897f, -0.02663891f, -0.01385393f, 0.05297362f, 0.04774765f, -0.01768192f, 0.01856076f, -0.04252017f, 
    -0.02772584f, 0.06191615f, -0.02653346f, -0.02191057f, -0.05666379f, 0.06590689f, -0.06813318f, -0.00543690f, 
    0.00592319f, 0.06481127f, -0.00550897f, -0.02892599f, -0.06884023f, 0.03894198f, -0.01046613f, 0.02771718f, 
    -0.02549147f, -0.05375915f, 0.06410080f, -0.04541999f, -0.01302322f, -0.00505419f, -0.07243215f, 0.03223935f, 
    -0.01421594f, -0.01397634f, -0.04373769f, -0.04177538f, 0.03830138f, 0.00742939f, -0.02905402f, -0.05942546f, 
    -0.02613899f, 0.01752196f, 0.00519001f, 0.04537929f, 0.03923966f, -0.02594182f, 0.00303433f, -0.04171588f, 
    0.01677473f, -0.06450199f, 0.04261099f, 0.06146232f, -0.03994314f, -0.03873510f, -0.06633224f, -0.04811059f, 
    -0.04342908f, -0.04124691f, -0.04851970f, 0.05762536f, 0.00418119f, 0.02113819f, -0.06271914f, 0.01943735f, 
    0.03432812f, 0.00757268f, 0.02124964f, -0.02794084f, -0.04299490f, 0.05292100f, -0.04114971f, -0.04312199f, 
    -0.01990782f, 0.19092555f, -0.04825352f, -0.31763199f, -0.32622734f, 0.25978193f, 0.01822158f, -0.35754523f, 
    0.13643794f, 0.18432909f, -0.02072958f, 0.04639644f, 0.17523287f, -0.06811433f, 0.03055983f, -0.06295800f, 
    -0.17875619f, 0.15903741f, -0.31308201f, 0.16852793f, 0.18086721f, -0.06916407f, 0.04651909f, 0.05994387f, 
    -0.10743075f, -0.00410055f, 0.09029374f, 0.04328744f, -0.17745712f, -0.16757202f, -0.06888469f, 0.18731564f, 
    0.04287795f, -0.06985687f, 0.04581528f, 0.14838359f, -0.00344069f, -0.09279750f, -0.21604094f, 0.10610095f, 
    -0.03032577f, -0.12197389f, 0.03601093f, -0.05417181f, -0.13971658f, 0.18119469f, -0.03547345f, -0.16711861f, 
    0.08256479f, -0.01505742f, 0.13736944f, 0.09525219f, -0.20872256f, 0.01335888f, 0.03836838f, 0.12226745f, 
    0.18744203f, 0.00348414f, 0.01096230f, 0.09611214f, -0.08902653f, 0.08849375f, 0.04588931f, -0.03736844f, 
    -0.07643167f, -0.01703709f, 0.09190196f, 0.12716097f, -0.07407500f, 0.07903150f, 0.07735430f, 0.15605913f, 
    -0.00657642f, 0.06883958f, -0.01551281f, -0.13691857f, 0.03837227f, -0.08669407f, 0.14159457f, -0.15542725f, 
    0.04488520f, -0.03215882f, -0.13520962f, -0.01862754f, -0.07304372f, 0.17787822f, -0.06380605f, 0.14123732f, 
    0.06409913f, 0.73355842f, 0.01538011f, 0.15577820f, 0.00961745f, 0.00135720f, -0.12908003f, -0.00845299f, 
    -0.06978732f, 0.05731247f, -0.24596219f, -0.09614402f, 0.02185086f, 0.05868259f, 0.00441992f, 0.09294344f, 
    -0.01368718f, 0.01714935f, 0.22849728f, -0.00158959f, 0.03438317f, -0.04379283f, 0.22532368f, -0.04377738f, 
    -0.07244036f, 0.31501186f, -0.07856120f, -0.14590563f, 0.08268093f, -0.05106558f, -0.16318139f, -0.04329789f, 
    0.03935703f, 0.13685435f, 0.15603784f, 0.09577326f, 0.33060288f, 0.26512378f, -0.18983348f, 0.09890120f, 
    0.02066026f, -0.02997892f, -0.03402346f, -0.09406934f, -0.01946084f, -0.00249608f, 0.23725185f, -0.05471390f, 
    0.14629850f, -0.19250710f, 0.00505248f, 0.06390765f, 0.11041632f, -0.06381489f, 0.09353266f, 0.14744827f, 
    0.04540938f, 0.05732215f, -0.11276238f, -0.04714529f, -0.13507019f, 0.03399777f, 0.12043039f, 0.07481565f, 
    0.01406212f, 0.03052537f, 0.29934818f, 0.13424680f, 0.09027023f, 0.30072519f, 0.16140224f, 0.14818467f, 
    -0.21299194f, 0.04706813f, -0.23486860f, 0.21479519f, 0.06221051f, -0.05191192f, -0.03866393f, -0.00869345f, 
    0.03733964f, -0.03189167f, -0.09930653f, 0.10386179f, 0.14637698f, -0.39646208f, 0.03954880f, -0.20829703f, 
    0.24578092f, 0.03020139f, 0.04470100f, 0.08380520f, -0.07886103f, -0.03448027f, 0.08007199f, -0.01643619f, 
    0.23383649f, 0.03059892f, -0.07536121f, 0.18293835f, -0.01025970f, 0.04298232f, 0.07076906f, 0.09480467f, 
    0.16513085f, 0.21565638f, 0.16952793f, 0.21886940f, 0.19019879f, -0.12957774f, -0.10427315f, 0.27149484f, 
    -0.00526887f, -0.23792566f, -0.00424125f, 0.11035968f, 0.01339352f, 0.09412266f, 0.17562887f, 0.22031395f, 
    -0.10020092f, -0.50752783f, 0.08369723f, 0.21752185f, 0.06733216f, -0.08815789f, 0.04396942f, -0.02548981f, 
    0.16094957f, -0.05083641f, 0.12282541f, 0.00983544f, -0.08190459f, 0.05752401f, 0.04910495f, -0.20246458f, 
    -0.07433856f, 0.10280520f, -0.02590096f, -0.31400585f, 0.01485895f, -0.09285392f, 0.00989587f, 0.14306557f, 
    -0.16124746f, 0.14144972f, -0.04096446f, -0.17449550f, 0.10362525f, -0.14804982f, 0.11001249f, -0.10004365f, 
    -0.03920459f, -0.02629023f, 0.02022065f, -0.05675513f, 0.05185329f, -0.10716994f, -0.01980059f, -0.04284785f, 
    -0.11016762f, -0.03316461f, 0.01435939f, -0.06733217f, 0.22315049f, 0.02595460f, -0.11869906f, -0.02129916f, 
    0.25074193f, 0.02223372f, 0.00138241f, -0.35277459f, 0.04335839f, 0.08074893f, -0.01823934f, -0.01483332f, 
    -0.08944617f, -0.06961042f, -0.08293609f, 0.06220583f, -0.14398652f, 0.18892519f, -0.09518932f, 0.23135975f, 
    -0.12144236f, -0.03599761f, -0.00026994f, -0.00187113f, 0.11579719f, -0.06320034f, 0.15730961f, 0.03603264f, 
    -0.09025533f, -0.34263337f, -0.02537825f, 0.00215293f, -0.04211878f, 0.01468170f, 0.00067259f, -0.02918791f, 
    0.01562201f, 0.04579924f, 0.20088066f, -0.00132013f, -0.09159825f, 0.27677736f, 0.25290468f, -0.10896815f, 
    -0.08748919f, 0.10525148f, -0.01671428f, 0.02326272f, 0.06149923f, 0.09074960f, 0.17723255f, 0.01243082f, 
    -0.04361100f, -0.12926687f, 0.00799676f, 0.13249765f, 0.01695040f, -0.02398455f, 0.16100357f, 0.03406428f, 
    0.07269312f, 0.09254390f, 0.13879873f, -0.00210866f, -0.07068446f, -0.04869648f, -0.02736643f, 0.05697985f, 
    0.02004850f, 0.06518746f, 0.07033128f, 0.08106572f, -0.02904427f, 0.01473627f, 0.05310452f, 0.01503259f, 
    -0.32781529f, 0.22423491f, 0.07843892f, 0.09023588f, -0.05556557f, -0.00789026f, 0.14876114f, 0.03252577f, 
    0.01512355f, 0.03299140f, -0.00002625f, -0.09713097f, 0.31776872f, 0.21063514f, 0.06278437f, -0.33120269f, 
    -0.06348696f, -0.01003672f, 0.04142457f, 0.06476767f, 0.00175105f, -0.12622516f, -0.27593243f, -0.09964890f, 
    0.33040261f, 0.27873826f, 0.24330775f, -0.36222723f, 0.04163277f, 0.02383372f, -0.00243104f, 0.02984222f, 
    -0.06137872f, -0.01591547f, 0.00110935f, 0.02927293f, -0.25398162f, 0.14422673f, 0.06686263f, 0.15517890f, 
    -0.12097947f, -0.00962959f, 0.01035301f, 0.01836486f, 0.06722275f, -0.10163118f, 0.02798619f, -0.03701214f, 
    0.15286466f, 0.03637916f, 0.03075319f, 0.08879313f, -0.04618157f, 0.02052389f, -0.01629187f, 0.04093250f, 
    0.20630726f, 0.06722848f, 0.26105493f, 0.16863298f, -0.04965873f, -0.19348039f, 0.38929486f, 0.23916022f, 
    0.00700728f, -0.03304130f, -0.11234141f, 0.12015249f, 0.12728980f, 0.14615934f, 0.06615108f, 0.11906464f, 
    -0.55897099f, -0.21984673f, 0.06366593f, 0.22130498f, -0.05849676f, -0.03159808f, -0.08793275f, 0.08129273f, 
    0.11406879f, 0.10378846f, -0.03146151f, -0.04543212f, -0.25014648f, -0.11414789f, 0.05003376f, -0.12782657f, 
    -0.06699883f, -0.04957435f, -0.08241512f, -0.12173437f, -0.00338537f, 0.05151895f, -0.04835072f, 0.06997543f, 
    -0.06517741f, -0.02671598f, -0.13794497f, -0.12332387f, 0.05448011f, 0.02272645f, 0.23386063f, 0.07724639f, 
    -0.08535071f, -0.02656906f, -0.02151508f, -0.05278863f, 0.00598342f, 0.05974064f, 0.07220081f, -0.02910076f, 
    -0.05359608f, -0.13013197f, 0.01031539f, -0.06889406f, 0.12411720f, 0.01921144f, -0.07760829f, 0.09865173f, 
    0.12918440f, 0.10422903f, -0.24524912f, -0.36271805f, 0.09914821f, 0.10456137f, 0.22301418f, 0.08451378f, 
    0.01038132f, -0.03741206f, -0.03723802f, 0.07155156f, -0.09996147f, 0.13451298f, 0.10233554f, 0.07896964f, 
    -0.08105659f, -0.02165972f, -0.04964695f, -0.01537939f, 0.13778156f, -0.02000153f, 0.10395132f, -0.01439858f, 
    -0.03691271f, -0.41327289f, 0.12358278f, 0.06607473f, 0.00345900f, 0.07273188f, 0.02705338f, -0.04052693f, 
    -0.01540261f, 0.02233041f, 0.08961251f, -0.03905470f, -0.08645836f, 0.11545030f, 0.29837698f, -0.07257891f, 
    0.00116031f, -0.02200332f, -0.10451991f, 0.09324507f, 0.15406604f, 0.13661553f, -0.02100745f, -0.07608830f, 
    0.01293186f, -0.13287406f, 0.14455849f, 0.20615608f, -0.05526623f, -0.04401965f, 0.06447493f, -0.03537518f, 
    0.01338870f, 0.12694600f, 0.18644182f, 0.12665720f, -0.28695482f, -0.12623943f, -0.10358705f, -0.00183507f, 
    -0.01212805f, 0.15448439f, -0.01974091f, 0.08381270f, -0.00981863f, -0.06758895f, -0.03797701f, 0.05105247f, 
    -0.35926861f, 0.22869419f, 0.10915733f, 0.12330128f, 0.01305902f, -0.01242020f, 0.21525043f, 0.10594571f, 
    0.06933848f, -0.02148920f, -0.03627885f, -0.01158106f, 0.63414931f, 0.13240340f, 0.51680118f, -0.42439640f, 
    -0.07110626f, -0.12315279f, -0.10482192f, 0.06511489f, 0.01606270f, 0.00829463f, -0.14467084f, 0.02288858f, 
    0.16956817f, 0.02348803f, -0.01243912f, -0.31716284f, -0.01115892f, 0.06083462f, 0.07122286f, 0.06151492f, 
    0.02819287f, -0.03421368f, 0.06571310f, -0.02254893f, -0.27448267f, 0.16569261f, 0.28188780f, 0.09168950f, 
    -0.15156375f, -0.01488472f, -0.17132376f, 0.06509876f, 0.13988557f, 0.01924723f, 0.04668533f, -0.03080677f, 
    0.16909067f, 0.19386272f, 0.09444052f, 0.05883203f, 0.05895730f, -0.01243578f, 0.07112185f, -0.00204966f, 
    0.08259493f, 0.20854627f, 0.08561061f, 0.00377141f, 0.11950945f, 0.01240867f, -0.12389492f, 0.14396112f, 
    -0.19625708f, 0.06212699f, -0.14460337f, -0.10211156f, 0.25956106f, 0.02446604f, 0.20147495f, -0.06435448f, 
    0.03208439f, -0.08526549f, -0.32387090f, -0.37114862f, 0.14739887f, 0.00053918f, -0.13260092f, 0.10332601f, 
    0.12711227f, -0.01581898f, 0.04045019f, -0.02275663f, -0.24453899f, -0.10937481f, -0.23352094f, -0.16965625f, 
    0.06529874f, -0.00045974f, -0.08210725f, -0.08845530f, 0.04138014f, 0.06129325f, 0.01247302f, 0.02435876f, 
    0.06222466f, -0.01437441f, 0.09345776f, 0.13193323f, 0.14743215f, 0.08141431f, 0.04499335f, 0.07495396f, 
    -0.15920950f, 0.09664690f, -0.08783931f, -0.22484061f, -0.21966749f, -0.16945830f, -0.15036489f, -0.00416379f, 
    0.03554545f, 0.01648842f, -0.08867633f, 0.27413413f, 0.11986791f, -0.09761328f, -0.05104954f, -0.04972329f, 
    0.37597126f, -0.06561945f, 0.38912362f, -0.03341755f, -0.11576098f, 0.13206504f, 0.30438215f, 0.12826461f, 
    -0.03907656f, 0.04506218f, 0.15593423f, 0.22996156f, 0.21251845f, 0.22316553f, 0.12953694f, 0.15457585f, 
    -0.05263858f, -0.15802084f, 0.05711544f, -0.19078879f, 0.07161863f, 0.13363563f, -0.10221356f, 0.05951236f, 
    0.54702193f, 0.03454315f, 0.48528185f, 0.07173646f, -0.03794427f, -0.06360181f, 0.04918076f, 0.00933274f, 
    -0.04733486f, 0.09712508f, 0.10771002f, 0.19069421f, -0.13366064f, -0.51856911f, -0.43748602f, 0.04325635f, 
    0.10560164f, 0.14681362f, 0.11381429f, -0.16560677f, -0.02819380f, 0.05151702f, -0.00015966f, 0.21440488f, 
    0.12516406f, 0.01329738f, 0.01377687f, -0.00548582f, -0.00832663f, 0.04597949f, 0.07415345f, -0.12588659f, 
    0.13698864f, -0.03166318f, 0.06276641f, 0.09031950f, 0.42460254f, 0.25254163f, -0.00618214f, 0.07481980f, 
    0.00791649f, -0.07593738f, 0.00500782f, -0.08799198f, -0.13873601f, -0.16014609f, -0.17865977f, 0.02877988f, 
    -0.11312516f, -0.54243034f, -0.53419870f, -0.49694982f, 0.04346651f, -0.17402115f, -0.01301812f, 0.01091667f, 
    0.00708997f, -0.04567316f, 0.10023949f, 0.13219886f, -0.57343185f, -0.42440170f, -0.32605577f, 0.41314200f, 
    0.04892547f, -0.19543867f, 0.10707868f, 0.20728768f, 0.15815583f, 0.24926129f, 0.02508268f, -0.01174705f, 
    0.59052712f, 0.23312393f, 0.37685984f, 0.11511087f, -0.05233499f, -0.02625433f, -0.02673410f, -0.08468742f, 
    -0.03938273f, -0.06726767f, -0.11481138f, 0.05055583f, -0.35732085f, -0.07090319f, -0.37332019f, -0.12443312f, 
    -0.15297262f, 0.08658804f, -0.19668134f, -0.13936400f, -0.08425447f, -0.11361203f, -0.02825981f, 0.11889965f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08076791f, 0.05007093f, -0.00883359f, 0.08023119f, 0.14936015f, -0.01125948f, 0.00011728f, 0.09082001f, 
    -0.03183857f, 0.03831260f, 0.06261276f, 0.03670252f, 0.12131537f, 0.00708243f, 0.04451705f, 0.02693713f, 
    -0.09898433f, -0.07432009f, -0.02320804f, -0.02982841f, 0.01156064f, 0.00335289f, -0.01311217f, 0.28534999f, 
    0.13740575f, -0.00117948f, -0.11398795f, -0.15336008f, -0.03484731f, 0.20574479f, 0.02110602f, 0.09190264f, 
    0.13650396f, 0.04673985f, -0.00604470f, -0.04943737f, -0.15027921f, 0.11697221f, -0.06944276f, 0.17359155f, 
    -0.18388911f, -0.04809901f, 0.16553165f, -0.04442003f, 0.05482236f, 0.17147166f, 0.06945425f, -0.05148014f, 
    0.05118354f, -0.04390233f, -0.11441033f, -0.03271846f, -0.01029390f, 0.24298254f, 0.02275803f, -0.02166188f, 
    0.38739643f, -0.03369420f, -0.05074859f, -0.03998288f, 0.07699705f, 0.24909119f, 0.30281773f, 0.19220178f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03979166f, 0.08685276f, 0.24387547f, 0.07790476f, 0.19314848f, -0.13430399f, -0.50490099f, 0.09408046f, 
    -0.37835509f, 0.05572950f, 0.27997893f, 0.23703644f, 0.09036140f, 0.02811553f, -0.11999986f, -0.04518111f, 
    -0.49486604f, -0.03593279f, -0.00400218f, -0.10233158f, 0.02995787f, 0.00895592f, -0.10438386f, -0.22591592f, 
    -0.20831165f, -0.61505562f, 0.26769707f, 0.26956016f, -0.11188380f, 0.08424236f, -0.46886069f, -0.12975061f, 
    -0.53255308f, 0.07204740f, 0.28442314f, 0.20915879f, 0.41316351f, -0.30121505f, 0.10210738f, -0.19167854f, 
    0.13403425f, 0.11423024f, -0.13940343f, -0.12063600f, -0.02398769f, -0.00195923f, -0.11795330f, 0.28070366f, 
    0.06377771f, 0.11573129f, 0.00135223f, 0.28629372f, 0.12400303f, -0.50956452f, -0.01083927f, -0.14493665f, 
    -0.50579673f, 0.18987566f, 0.05007227f, 0.11433210f, -0.47002795f, -0.21076764f, -0.30899653f, -0.35234314f, 
    -0.07930402f, -0.10854347f, 0.08736290f, 0.00224582f, 0.06534425f, 0.01029584f, -0.03440200f, 0.19597824f, 
    -0.33921677f, -0.11107626f, 0.16045175f, 0.21019880f, 0.09370384f, 0.36305419f, -0.10871735f, 0.24147384f, 
    -0.44442251f, 0.11075487f, 0.48242643f, -0.00268678f, 0.00711446f, 0.07701961f, 0.07279906f, 0.00608179f, 
    -0.54243487f, -0.36670491f, 0.22376363f, -0.61134189f, -0.53778362f, 0.19598521f, -0.03625662f, -0.07545496f, 
    -0.05318662f, -0.04358274f, 0.26629794f, -0.51382595f, -0.50555384f, -0.11475247f, -0.79282391f, 0.13087258f, 
    -0.09090763f, -0.06571738f, 0.06086605f, 0.02360610f, 0.54317111f, -0.04591903f, 0.12443769f, 0.06643272f, 
    -0.05558518f, -0.04782635f, 0.07430438f, -0.24837933f, 0.06224412f, -0.13935156f, 0.01240830f, 0.11707730f, 
    0.20677263f, -0.14417955f, -0.11658416f, -0.08884903f, -0.09020270f, 0.19775143f, 0.13706306f, 0.59161502f, 
    -0.05490767f, -0.11249290f, 0.00475741f, 0.05126026f, -0.07128344f, -0.05963007f, 0.15214348f, -0.47855693f, 
    -0.01772119f, -0.04769518f, -0.10762293f, 0.11748426f, -0.53968251f, -0.59088767f, -0.09061631f, -0.01681718f, 
    -0.24535906f, -0.05671901f, -0.04828655f, 0.05686713f, -0.04477353f, 0.00651748f, 0.09970957f, 0.16086294f, 
    0.42995134f, 0.11609438f, 0.14642355f, -0.04343493f, -0.34281659f, 0.25732192f, -0.22943214f, -0.02025391f, 
    -0.13865614f, 0.10796810f, 0.07019184f, 0.10669840f, -0.44175979f, 0.16254424f, -0.01731908f, 0.20586333f, 
    -0.29446301f, -0.05905135f, 0.16553061f, 0.03521473f, -0.03962900f, 0.06755597f, -0.29249826f, -1.02269530f, 
    0.10333145f, 0.02193702f, 0.07173252f, 0.55591756f, -0.28487253f, 0.04553962f, -0.04210708f, -0.06593503f, 
    0.07420900f, -0.28643513f, 0.07314865f, 0.10517059f, -0.10512253f, 0.24219589f, 0.17423275f, -0.67836559f, 
    0.22175822f, 0.02601765f, -0.21119060f, -0.15834825f, 0.06078273f, 0.00388809f, 0.20296711f, -0.17960778f, 
    -0.13880312f, 0.00333003f, -0.05351521f, 0.16455518f, -0.06206918f, -0.02780125f, -0.10258923f, -0.10197219f, 
    0.14653319f, -0.09943151f, 0.17979106f, 0.06958391f, 0.02244707f, -0.01308668f, 0.06915324f, -0.05880284f, 
    -0.05353262f, 0.03754193f, 0.00351913f, -0.01356719f, 0.16269049f, -0.41068467f, 0.28050107f, -0.28880382f, 
    -0.54590231f, 0.05006076f, -0.25289145f, 0.18108539f, -0.03812392f, 0.19406797f, 0.21522883f, 0.28325176f, 
    0.25997636f, 0.05699729f, -0.35055962f, -0.01352707f, -0.32564482f, -0.79514974f, -0.15508685f, 0.12669982f, 
    0.04977678f, 0.21811174f, 0.35580197f, 0.15758918f, -0.11697544f, 0.11590126f, -0.23127343f, 0.39921880f, 
    -0.06870087f, -0.17522874f, -0.07905173f, -0.05805312f, 0.38596794f, -0.54888326f, -0.53551638f, -0.18106800f, 
    -0.28333721f, -0.08714758f, 0.08812962f, 0.14928105f, -0.35609508f, 0.10746060f, 0.00843047f, -0.02816504f, 
    0.01603849f, -0.10415571f, -0.49673837f, -0.03015895f, -0.08371673f, -0.28074035f, 0.11832969f, 0.07253137f, 
    0.34066567f, -0.03470752f, 0.10276032f, 0.10038171f, -0.05397609f, 0.23376416f, -0.08706925f, -0.16674165f, 
    -0.45362103f, 0.23527758f, 0.20143501f, 0.16338570f, 0.30344138f, -0.30532646f, -0.36006728f, 0.03107369f, 
    0.10328691f, -0.05366000f, 0.01441164f, 0.27616522f, 0.14096770f, 0.13839698f, 0.30363417f, -0.19802371f, 
    -0.01253270f, -0.00041232f, -0.24186307f, -0.01603332f, 0.30227512f, -0.09888527f, 0.22968337f, -0.19813994f, 
    -0.11951768f, -0.09650777f, -0.14809607f, 0.14323160f, 0.03087390f, -0.08689684f, -0.11274540f, -0.05652449f, 
    -0.35115567f, 0.17649448f, -0.08993247f, -0.11025256f, -0.58969498f, -0.08479533f, -0.05997834f, -0.39944318f, 
    -0.13842200f, -0.07874094f, 0.21370047f, 0.15208837f, 0.25019571f, -0.07598694f, -0.34334260f, 0.26422110f, 
    0.01839622f, 0.06883226f, 0.02940596f, -0.05103525f, 0.15997553f, 0.21841392f, 0.01239387f, 0.29279688f, 
    0.12649134f, 0.09365840f, -0.15384689f, -0.09705576f, -0.00003259f, -0.03232431f, -0.04504317f, 0.07493430f, 
    -0.02814445f, -0.12725089f, -0.18511997f, -0.15603296f, 0.22392957f, 0.26032430f, -0.18920992f, 0.01344206f, 
    0.39500627f, 0.09115627f, -0.48101842f, 0.04534562f, -0.16512908f, 0.10992382f, -0.06946768f, 0.01614070f, 
    -0.16598530f, -0.02877551f, -0.09910639f, -0.08722498f, -0.41192412f, -0.12321163f, -0.14872439f, 0.10037538f, 
    -0.00297649f, 0.12829900f, -0.54706514f, -0.28822690f, 0.04858099f, 0.08315003f, -0.20396337f, -0.73980105f, 
    0.10238985f, 0.22829361f, -0.01071072f, 0.00433939f, 0.06079808f, -0.03237516f, -0.03641051f, -0.35966757f, 
    0.14665692f, 0.10511311f, -0.19385003f, -0.56737679f, -0.03361068f, -0.20792137f, 0.15291029f, -0.24089468f, 
    0.05337641f, 0.05374107f, -0.28362200f, -0.48090094f, -0.38446817f, -0.19002588f, 0.00665452f, -0.50842834f, 
    0.25213674f, 0.03510746f, -0.22935799f, -0.08361581f, 0.10207930f, -0.02910852f, 0.06159184f, -0.06525141f, 
    0.09350588f, 0.27897894f, -0.69917566f, 0.49927452f, 0.22666784f, -0.14547579f, -0.42470375f, 0.28269130f, 
    -0.23881061f, -0.02939283f, 0.22944209f, -0.09091981f, 0.00645333f, -0.45575666f, -0.46631339f, -0.26170307f, 
    -0.67358571f, -0.03426960f, -0.00464536f, -0.05986526f, 0.19770458f, 0.35104364f, 0.01188518f, -0.82576382f, 
    0.06074695f, 0.10923975f, 0.10366032f, -0.55545795f, -0.60687649f, 0.22129509f, -0.04676246f, -0.00629323f, 
    0.20904146f, -0.11002175f, 0.06595688f, -0.03855697f, -0.01975981f, 0.01279261f, 0.16672893f, 0.03024198f, 
    -0.34907880f, 0.02374908f, 0.07333806f, -0.33500156f, -0.06164740f, 0.19150472f, 0.17424001f, -0.30812445f, 
    -0.03238626f, -0.10536058f, -0.19689462f, -0.37386024f, -0.41459987f, 0.01465976f, -0.08930318f, 0.05204786f, 
    0.06715343f, -0.11347196f, -0.31940407f, 0.02474236f, 0.06214458f, 0.26102528f, -0.03111750f, -0.19712448f, 
    0.22318417f, -0.24236988f, -0.56618607f, -0.02765402f, -0.01064346f, -0.00012566f, 0.26593557f, -0.36181569f, 
    0.19436446f, -0.04990653f, 0.15610792f, -0.54063582f, 0.22830418f, 0.14927910f, 0.50095278f, -0.53845084f, 
    -0.00829536f, -0.11081436f, 0.16998751f, -0.11505208f, -0.35366702f, -0.31464583f, -0.08526958f, -0.50903368f, 
    -0.03298248f, 0.21114546f, 0.02538130f, 0.43004647f, -0.36097428f, -0.51445788f, -0.03870647f, 0.18710142f, 
    -0.10157155f, -0.03535921f, 0.02867841f, 0.08603752f, 0.22225949f, -0.14890862f, -0.11383034f, 0.01336531f, 
    0.31896490f, 0.01286612f, -0.04831284f, -0.11222915f, 0.26798385f, 0.27516645f, -0.01366346f, -0.73612142f, 
    -0.01337873f, 0.04699991f, 0.13978270f, 0.01605813f, 0.00755477f, -0.30964899f, -0.05410760f, -0.42081740f, 
    0.10396547f, -0.06430878f, -0.09477228f, 0.09613300f, -0.03985875f, 0.07528544f, -0.02869615f, 0.36010230f, 
    0.36214867f, -0.12712742f, -0.50860626f, -0.64859676f, -0.56322819f, -0.01502553f, 0.12663761f, 0.27070081f, 
    -0.00929816f, 0.04760330f, -0.72556454f, -0.22992143f, -0.49699405f, -0.08917558f, 0.21026672f, 0.16426316f, 
    -0.28501800f, 0.01685618f, -0.01108259f, -0.06383763f, -0.58331448f, -0.28859603f, -0.27810681f, 0.06374945f, 
    -0.00448094f, -0.26009551f, -0.27076682f, -0.12998913f, -0.60680801f, -0.04711467f, -0.42383957f, 0.36657059f, 
    0.16134247f, 0.19782728f, 0.10414866f, -0.08384398f, 0.06132497f, -0.19897963f, -0.27124712f, 0.13529801f, 
    -0.49360910f, -0.07917690f, -0.45293820f, -0.19651803f, -0.51805180f, -0.49978587f, -0.05957958f, -0.21765091f, 
    0.17055432f, 0.02310784f, -0.10625125f, -0.13293290f, -0.44554773f, 0.26543853f, -0.09806569f, 0.35563657f, 
    0.11234223f, -0.10758058f, -0.08425757f, 0.05898659f, -0.10249440f, -0.59649235f, 0.08732658f, -0.01616861f, 
    -0.26262268f, 0.30447569f, 0.27660143f, 0.06536737f, -0.01501322f, -0.10847230f, -0.13801275f, -0.08256122f, 
    0.39313215f, -0.04603994f, 0.24624522f, -0.23528537f, 0.36109522f, -0.23870948f, -0.25155625f, -0.32635319f, 
    0.20932153f, -0.01363832f, -0.35892594f, 0.09115506f, -0.35672390f, 0.23087284f, -0.32614055f, 0.29587665f, 
    0.08337085f, 0.11254305f, -0.29560974f, 0.06916881f, 0.14942613f, 0.04523681f, 0.38903987f, 0.16075687f, 
    0.04409765f, -0.15752402f, -0.04635591f, 0.11932246f, 0.00816149f, -0.13591890f, 0.16313507f, -0.18308225f, 
    0.08082283f, -0.01195046f, -0.53602272f, 0.22083229f, 0.19858061f, 0.15119009f, 0.19127330f, 0.02848895f, 
    -0.45753208f, -0.09148117f, -0.14014865f, -0.25412408f, 0.38224953f, -0.52575982f, 0.01408216f, -0.45187330f, 
    -0.55221522f, -0.05470141f, -0.54966176f, -0.02193728f, -0.11133482f, -0.08317576f, 0.02024542f, 0.08138815f, 
    -0.45148081f, -0.23099236f, -0.16837691f, -0.20533668f, 0.14768092f, -0.16683044f, 0.11760622f, 0.25716168f, 
    -0.01372662f, -0.02005921f, -0.30387935f, -0.69134569f, -0.38450605f, 0.30066714f, -0.13744205f, 0.40676028f, 
    -0.14889908f, -0.07176991f, -0.00734313f, -0.06704731f, 0.42085120f, -0.14738278f, -0.16509642f, -0.56726819f, 
    -0.05998499f, -0.21374932f, 0.39553127f, -0.35793209f, 0.25885761f, 0.38934550f, 0.20363404f, -0.29027450f, 
    0.05492791f, 0.18185127f, 0.03028660f, 0.01982113f, -0.03079091f, -0.25101563f, 0.13600571f, -0.47851604f, 
    0.38725743f, -0.05481862f, -0.23303330f, -0.04197084f, -0.37244162f, -0.06429189f, 0.05128031f, -0.31203708f, 
    0.25902504f, 0.02413321f, 0.22327293f, 0.26347312f, 0.46331617f, 0.00952686f, 0.05426041f, 0.03083703f, 
    0.45047691f, 0.00734804f, -0.46089616f, -0.07749428f, -0.01204876f, -0.03227053f, -0.05062232f, 0.08131839f, 
    0.16850409f, -0.12675607f, -0.48765033f, -0.32523820f, 0.28520802f, -0.54408330f, 0.39287421f, -0.28141767f, 
    -0.28298104f, -0.10671376f, 0.07516685f, 0.48826525f, -0.48984143f, -0.45801347f, -0.35305867f, -0.19599901f, 
    0.40920296f, -0.10304571f, 0.12620567f, -0.04698197f, 0.12866190f, 0.29106265f, 0.22105457f, -0.27248481f, 
    0.09305377f, -0.28516707f, 0.08065943f, -0.26436949f, 0.30055088f, -0.10728744f, -0.75377762f, -0.15308478f, 
    0.00240490f, -0.41179729f, 0.07027135f, 0.04525144f, -0.16293538f, 0.23217408f, -0.07614470f, 0.17331709f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12081452f, 0.14862011f, 0.18023247f, -0.06963325f, 0.03224440f, 0.08458490f, 0.12836768f, -0.02352057f, 
    0.20166887f, 0.02527327f, 0.02883423f, -0.17360480f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
