#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20034818f, -0.84671092f, -0.97486818f, -0.22977969f, 0.05960898f, -0.04101759f, 0.54176736f, 0.66954696f, 
    0.40586907f, -1.18332195f, -1.04712808f, 0.24772239f, -0.77808255f, -0.17247364f, -0.51340550f, -0.22194818f, 
    -0.33649567f, 1.18301666f, 1.57448506f, 0.42005378f, -0.02048514f, 0.34799862f, -0.09874319f, 0.27597019f, 
    0.18515611f, 0.61536103f, 0.03046764f, 0.99753201f, -0.45037416f, 0.00347992f, -1.26605392f, -0.60804671f, 
    0.05212762f, 0.28051308f, 0.41595361f, 0.15140234f, 0.60598469f, 0.92826241f, -0.62393755f, -0.48780659f, 
    -0.68964720f, -0.79477447f, -0.29114613f, 1.44154620f, -0.62632394f, 0.35352904f, 1.22891617f, -1.09914720f, 
    -0.30329159f, 0.50921983f, -0.25910816f, 0.07588939f, -0.07534230f, 0.39851767f, -1.19259119f, -0.33208343f, 
    -0.45947617f, -0.01847237f, -0.56356531f, -0.87063462f, -0.97239619f, -0.85663116f, -1.02613831f, -2.08001804f, 
    -1.46788657f, -0.39031821f, 0.76147228f, 0.61856085f, -0.21120873f, -0.31479931f, -0.59051716f, 0.06804585f, 
    0.46222103f, 0.32237706f, 0.80286801f, -0.71069485f, -0.08131427f, 0.93386704f, 0.30715060f, -0.28193763f, 
    -0.11891236f, -1.93778598f, -0.36665580f, 0.06515262f, -1.07240486f, -0.81155491f, 0.08464806f, 0.55300760f, 
    0.13700531f, -0.53640324f, -0.82055062f, 0.22013199f, 0.24076988f, 1.07152736f, 0.07278722f, -0.06104149f, 
    0.61427164f, 0.72360873f, 0.79521680f, 0.56817400f, -1.19529128f, 0.53466624f, -0.75454742f, 0.50867760f, 
    0.92081678f, 0.33215708f, -0.06328935f, 0.48822427f, -0.18645328f, -0.17147011f, 0.56109411f, -0.94422966f, 
    -1.28660274f, -1.43510604f, 0.18582046f, 0.09199958f, -0.25093752f, -1.12044609f, 1.18751299f, -1.58647978f, 
    -0.77858913f, 1.40520537f, -0.27920419f, -0.14322321f, -0.35501528f, -0.18209550f, -0.19254798f, -0.47588420f, 
    -0.70024067f, 1.32421589f, -0.83536768f, 1.11258924f, -0.79669416f, -0.45460838f, 0.41302100f, 0.49775502f, 
    -1.20228171f, -0.35711512f, 0.70120150f, -0.90824950f, -0.94983101f, -0.20174304f, -0.19287845f, 0.03898688f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    1.01952136f, -0.31377673f, 0.59984744f, 0.56878448f, -0.12456038f, 0.65948719f, -0.23669268f, 0.28317836f, 
    0.93923509f, 0.34249640f, 0.26734433f, 0.20224056f, -0.00493226f, 0.13706970f, -0.22050740f, 1.25748956f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03890989f, 0.68093032f, 0.22382095f, -0.00565991f, -0.00583470f, -0.05665645f, -0.02011056f, 0.05538290f, 
    0.08750928f, -0.19601975f, -0.15788262f, -0.18554446f, 0.28981364f, -0.05790484f, -0.10175094f, 0.04022852f, 
    -0.00466103f, -0.03656939f, 0.45906785f, -0.25320309f, -0.11365565f, 0.04929481f, 0.15175569f, 0.01980877f, 
    0.19330232f, -0.02679702f, -0.16174261f, 0.34286889f, 0.11927599f, -0.42263865f, -0.11643878f, 0.14477184f, 
    0.48393866f, -0.05160817f, 0.06202637f, 0.02093760f, -0.26319605f, -0.50810236f, -0.54390287f, -0.14566337f, 
    0.18055092f, -0.07461105f, 0.17109466f, 0.05515122f, -0.02866115f, 0.28746110f, 0.17565639f, -0.54176033f, 
    0.06170976f, 0.18670124f, 0.78681862f, 0.26783159f, -0.01387018f, 0.08045559f, 0.26245695f, 0.01768226f, 
    -0.08742508f, -0.16488813f, 0.05011385f, 0.02751617f, 0.01675224f, 0.11144406f, 0.09813830f, 0.09005475f, 
    0.07378586f, 0.16459225f, -0.06020507f, -0.38411126f, -0.28736779f, 0.03915768f, 0.12568532f, 0.10105823f, 
    -0.03879448f, -0.25924471f, 0.01724173f, 0.11826363f, 0.24121028f, -0.09480561f, 0.10605261f, 0.21705852f, 
    0.09950797f, -0.75240564f, 0.38290909f, 0.72412872f, -0.24307904f, 0.18074009f, -0.21621211f, -0.09384270f, 
    -0.17088412f, -0.10232420f, -0.19337921f, 0.02197183f, -0.12070619f, -0.18743087f, -0.09354079f, -0.29832056f, 
    0.09219377f, 0.40690151f, -0.02585248f, -0.11368052f, -0.20300007f, -0.19934419f, -0.39420491f, -0.09333529f, 
    -0.04688464f, -0.04340051f, 0.04010662f, -0.08419683f, 0.70686150f, -0.12552349f, -0.59315348f, -0.05878916f, 
    -0.01362574f, -0.33018699f, 0.04271090f, 0.01260453f, 0.07100251f, -1.03445506f, -0.23898277f, -0.84912395f, 
    0.12277588f, -0.08985943f, 0.41120982f, -0.15840513f, 0.04010079f, 0.05507044f, 0.30809987f, 0.00312994f, 
    -0.53753394f, -0.30772296f, -0.48087400f, -0.20358586f, 0.00698732f, -0.00809550f, -0.09504163f, -0.00540630f, 
    -0.52155125f, -0.09728959f, -0.03744042f, 0.43309402f, 0.26592699f, 0.01210612f, 0.15670495f, 0.01925383f, 
    0.13074490f, 0.46874681f, 0.40968096f, 0.12389742f, 0.20718014f, -0.44837275f, 0.02371187f, -0.00428652f, 
    -0.15070839f, -0.34241718f, 0.01603103f, -0.53089124f, -0.16591311f, -0.00437743f, -0.01074970f, -0.18232413f, 
    -0.12143610f, -0.15306106f, 0.32760227f, 0.30632275f, 0.19142087f, 0.11633161f, 0.31999838f, 0.20438956f, 
    -0.03136440f, 0.19455031f, -0.30414319f, 0.04956720f, 0.32127130f, -0.06105411f, -0.16155508f, 0.26825243f, 
    0.26258162f, -0.00310260f, -0.06034132f, -0.18514094f, 0.18485270f, -0.92936653f, 0.11351787f, -0.04085563f, 
    -0.21715368f, -0.33991778f, 0.19710612f, -0.12530808f, -0.23802741f, 0.41221029f, 0.00581957f, 0.14144175f, 
    0.18494938f, -0.00510566f, 0.04798634f, 0.09248342f, 0.01850652f, -0.20252052f, -0.16020431f, -0.01717103f, 
    -0.11585539f, -0.01426542f, 0.17261982f, 0.15088925f, 0.13053343f, 0.08520295f, 0.23202832f, -0.58754820f, 
    0.17836861f, 0.47803852f, 0.07544877f, 0.19465750f, -0.05301343f, -0.01450981f, 0.20494179f, 0.33946452f, 
    0.22447330f, 0.23473336f, -0.01212631f, 0.21039058f, 0.29631931f, 0.04425284f, 0.34018651f, 0.03550433f, 
    -0.19457203f, -0.58764344f, 0.06139521f, -0.08586957f, 0.34903041f, 0.02696319f, -0.05408530f, -0.15684989f, 
    -0.02289060f, -0.14947979f, -0.10179549f, 0.01310878f, 0.12757030f, 0.10150678f, 0.04771928f, -0.03038177f, 
    -0.37386602f, -0.16454056f, -0.41490701f, -0.07809070f, 0.64720428f, 0.18710469f, -0.06749558f, -0.02374747f, 
    -0.11552725f, 0.04296726f, 0.13263151f, -0.56373155f, 0.29239994f, -0.07435505f, -0.47266003f, -0.10246996f, 
    0.06248720f, -0.37602052f, -0.09592777f, -0.06120267f, 0.01177658f, -0.19719827f, -0.45736790f, -0.20195839f, 
    0.00208338f, 0.28994223f, 0.06918652f, 0.13466896f, 0.20610146f, 0.17707460f, -0.60204762f, 0.11653715f, 
    0.14548445f, -0.21224144f, -0.23226282f, -0.03145827f, -0.25915518f, 0.20979537f, -0.26314291f, 0.04355629f, 
    -0.16550098f, 0.41139737f, -0.01513132f, 0.02901548f, 0.54458624f, 0.33903071f, -0.03878190f, 0.00529732f, 
    0.01124636f, -0.02559649f, 0.53874123f, -0.14643720f, -0.00836740f, 0.06258279f, 0.23004289f, 0.25295904f, 
    0.23990418f, -0.39616725f, 0.36860552f, 0.13539352f, 0.01270291f, 0.02049923f, -0.29908907f, 0.25637844f, 
    0.12146045f, -0.27447835f, -0.49059704f, -0.38428128f, -0.07519285f, 0.05380054f, -0.03479675f, 0.10562211f, 
    0.20691200f, 0.21099629f, 0.17896235f, -0.17464983f, -0.06864854f, 0.56497574f, 0.16479827f, 0.20506981f, 
    0.11006486f, 0.09759388f, -0.06277478f, 0.20134118f, -0.35031447f, 0.45933345f, -0.42837316f, 0.11139350f, 
    0.15611035f, -0.05621874f, 0.09415928f, 0.25407341f, 0.13570459f, -0.14686416f, 0.45733455f, -0.00409462f, 
    0.34382999f, 0.65632749f, 0.38314241f, 0.59958404f, 0.42806548f, 0.37433740f, -0.24627860f, 0.04770415f, 
    0.31364337f, 0.12509833f, 0.07310253f, 0.20245600f, 0.24317195f, 0.03122450f, -0.05179034f, -0.17602448f, 
    0.25066555f, 0.03738236f, -0.11188234f, -0.10326184f, -0.09376696f, 0.15529443f, -0.25879690f, -0.07207196f, 
    -0.42290911f, -0.04433186f, -0.04797861f, 0.04369583f, 0.28301606f, 0.13428928f, 0.07419790f, 0.25305465f, 
    0.13446444f, 0.04003222f, -0.01783843f, 0.19703990f, -0.01320094f, -0.01502667f, 0.21892342f, 0.14689849f, 
    0.11630094f, 0.06793056f, -0.19531281f, 0.00565777f, 0.03946096f, 0.23285984f, 0.05146041f, -0.29966193f, 
    0.22074609f, 0.27807835f, 0.28155315f, -0.20860539f, -0.08642802f, -0.10666448f, 0.40257719f, 0.24916622f, 
    -0.15791322f, 0.16492106f, 0.34112057f, 0.05014196f, -0.43891090f, -0.86097515f, -0.19367203f, 0.05751896f, 
    0.11624659f, 0.04775592f, 0.18466865f, 0.23528038f, -0.00048782f, -0.04881637f, 0.48987260f, 0.30399820f, 
    0.10177407f, -0.13112149f, 0.06408454f, -0.02107596f, -0.04654647f, -0.05606017f, -0.24298374f, 0.01780979f, 
    -0.24640591f, 0.13175270f, -0.14095411f, -0.51249588f, -0.02807291f, -0.29047233f, -0.28825307f, 0.66282350f, 
    0.25311550f, 0.50901264f, 0.12927543f, 0.18516938f, 0.28970081f, 0.33303756f, -0.04132064f, 0.36385295f, 
    0.34325990f, 0.02181632f, -0.41506976f, -0.24779415f, -0.04893103f, -0.18645012f, 0.24959199f, 0.02331729f, 
    -0.15236546f, 0.68979883f, 0.62881690f, -0.08443710f, 0.03723434f, 0.03794029f, 0.11568052f, 0.06212806f, 
    0.09052653f, 0.23610793f, -0.01786587f, -0.08012401f, -0.13101509f, -0.00265153f, -0.01456147f, 0.01069026f, 
    0.00529851f, 0.08091679f, -0.02072197f, 0.22199030f, -0.19559185f, -0.09078448f, -0.20920219f, -0.31006813f, 
    0.05455251f, -0.12196186f, 0.08816356f, 0.19353090f, -0.43739218f, -0.15390132f, -0.22270603f, -0.13199188f, 
    0.23181780f, 0.02014348f, 0.05363882f, 0.25141665f, -0.02236651f, -0.18152350f, 0.08988906f, 0.17699505f, 
    -0.10139509f, 0.41833526f, 0.14911772f, -0.13547179f, 0.15449497f, 0.14370780f, 0.59681940f, 0.21766764f, 
    0.02352965f, 0.09636610f, 0.15047647f, -0.35396367f, -0.26834941f, -0.27196944f, -0.33799848f, 0.19184218f, 
    -0.16824044f, -0.16920602f, 0.06298643f, -0.03738322f, -0.16791686f, 0.02125216f, -0.06731361f, -0.08975118f, 
    -0.20409133f, -0.11963429f, 0.09156060f, 0.02422133f, -0.28057098f, -0.03648120f, 0.03324519f, -0.14816643f, 
    -0.04804748f, 0.33954307f, 0.32254633f, -0.26852036f, 0.09262531f, -0.16206048f, 0.07790096f, -0.02445147f, 
    0.18748356f, 0.02608803f, 0.17402256f, 0.12039937f, -0.01909604f, 0.11462944f, -0.02606620f, 0.02135155f, 
    -0.13752070f, 0.13055216f, -0.01519467f, 0.16394557f, 0.20065172f, 0.42175692f, 0.05973694f, 0.19399302f, 
    0.09680545f, -0.09954803f, 0.20171402f, -0.05580167f, -0.13169076f, 0.09162097f, -0.74390376f, 0.03916733f, 
    -0.20437329f, 0.30427396f, -0.11447033f, 0.03909715f, 0.11148765f, 0.09537616f, 0.63637459f, 0.49461284f, 
    -0.04412162f, 0.17919822f, -0.13130122f, -0.21915108f, -0.12668847f, 0.08182799f, 0.11426630f, 0.26055023f, 
    0.17793459f, 0.12303962f, 0.23719154f, -0.47356156f, 0.09136228f, -0.19118156f, 0.05628208f, 0.16923133f, 
    -0.22061014f, -0.11030415f, -0.10304347f, -0.01547673f, -0.02271002f, 0.06168289f, 0.02827540f, 0.16802205f, 
    -0.02707910f, 0.06243261f, 0.05939234f, -0.05964502f, -0.04378548f, 0.06267125f, -0.08068115f, -0.07124329f, 
    -0.08005358f, 0.03394851f, -0.07034381f, -0.08477560f, -0.07806153f, -0.01276801f, -0.04802942f, 0.01788473f, 
    -0.08214695f, -0.00242319f, 0.05330555f, -0.02059548f, -0.04189029f, 0.02779895f, -0.08715583f, 0.04384926f, 
    0.00779555f, -0.06002352f, 0.02511096f, 0.02250143f, -0.01354843f, -0.01670246f, -0.02611727f, -0.02842069f, 
    -0.04843494f, -0.03626300f, 0.06163246f, -0.07520336f, 0.05856978f, -0.08791906f, 0.04778360f, -0.02722893f, 
    0.01529713f, 0.02167384f, -0.05437786f, 0.04473850f, 0.00477389f, 0.03873127f, -0.09626555f, -0.02855674f, 
    -0.04816790f, -0.03905118f, -0.07968536f, -0.02469237f, -0.04923088f, 0.00635285f, 0.01898636f, -0.07200816f, 
    -0.03089856f, 0.07128388f, 0.04765343f, -0.06052089f, 0.02733671f, 0.05486212f, 0.06130191f, -0.00057795f, 
    0.02456474f, -0.07606359f, -0.04720395f, 0.04180393f, 0.05592344f, -0.02626356f, 0.05234024f, 0.06307213f, 
    -0.08537115f, 0.02951789f, 0.06118572f, 0.04239862f, 0.05844588f, 0.05976306f, -0.02041125f, -0.05774137f, 
    -0.06504443f, 0.05139824f, 0.01697519f, 0.03699332f, 0.00815413f, 0.02961943f, -0.04119269f, 0.04888209f, 
    -0.02831774f, -0.07738112f, -0.02272771f, -0.09340809f, -0.01217459f, 0.03909243f, -0.02841303f, 0.00680492f, 
    -0.07980898f, -0.02635098f, 0.02078085f, -0.05282298f, 0.03973173f, -0.01628659f, -0.03993354f, 0.01984794f, 
    -0.07863051f, -0.02537448f, -0.06048129f, -0.01401907f, -0.05111082f, -0.02941079f, -0.09005855f, 0.00360522f, 
    -0.03160900f, -0.04984372f, -0.00406517f, -0.04916395f, -0.04348292f, 0.06625260f, -0.04774436f, -0.01614876f, 
    -0.04856097f, -0.05768400f, 0.04332228f, -0.08983784f, 0.02541310f, -0.04530215f, -0.07314353f, 0.05698136f, 
    -0.07266429f, -0.04607395f, 0.05322837f, -0.05959982f, -0.09197865f, -0.05845852f, -0.07307145f, -0.03598147f, 
    0.02421330f, -0.01253605f, -0.02603263f, -0.02933032f, 0.03746891f, 0.04253271f, 0.05790814f, -0.00374301f, 
    0.24607337f, -0.50199074f, -0.38470632f, 0.26634413f, 0.06111795f, 0.34093395f, 0.15804894f, 0.09552345f, 
    0.11266109f, 0.44573486f, 0.06736466f, -0.14406787f, 0.00602260f, 0.07796190f, -0.05127426f, -0.00469556f, 
    -0.09341125f, 0.01689836f, 0.29641733f, 0.10398334f, 0.27372962f, 0.12337615f, -0.07151648f, 0.14714809f, 
    0.34189770f, -0.07618659f, 0.03125428f, -0.91828489f, -0.12908208f, 0.14384714f, 0.22941299f, 0.37232947f, 
    0.04337514f, 0.02906451f, 0.02206716f, -0.21320522f, 0.01069255f, 0.57394171f, 0.38007995f, -0.12450605f, 
    -0.03388657f, 0.28135481f, -0.07093620f, -0.13563249f, 0.07550434f, 0.21854445f, 0.02577610f, 0.10127094f, 
    -0.01032184f, -0.05423787f, 0.41275775f, 0.10796541f, -0.25859958f, -0.07472924f, -0.13446189f, -0.42609981f, 
    -0.16017972f, 0.19830556f, -0.03486471f, -0.23366641f, 0.09116212f, 0.05308101f, 0.14895037f, 0.73618990f, 
    -0.20690331f, -0.76072168f, -0.14110963f, -0.22417162f, -0.20879509f, 0.06591030f, 0.08412442f, -0.05238660f, 
    0.16228588f, 0.16699128f, 0.35335875f, 0.03940221f, 0.11752702f, 0.00451486f, 0.16327842f, 0.01446532f, 
    -0.00415493f, 0.65213192f, -0.12917268f, 0.23943229f, 0.14800723f, 0.01442275f, 0.07641811f, -0.00821410f, 
    0.07086208f, -0.19766620f, 0.43709680f, 0.07812799f, 0.04809558f, 0.03958584f, -0.11001509f, -0.03266533f, 
    0.23494831f, -0.15854591f, -0.29382944f, 0.15790147f, -0.22685385f, 0.13398640f, -0.10131132f, -0.08759698f, 
    -0.04647763f, -0.22119454f, -0.14247699f, -0.39472762f, -0.22821611f, 0.17779775f, 0.51988089f, -0.03730201f, 
    -0.01612118f, 0.05543732f, -0.05360224f, 0.14348976f, -0.08040298f, 0.46972984f, -0.47113737f, -0.80620897f, 
    -0.34649476f, -0.15576388f, -0.28987172f, -0.17756040f, 0.11879513f, -0.12254011f, -0.22899212f, -0.52584332f, 
    -0.32786876f, 0.24688418f, 0.16498876f, -0.20482615f, -0.10896859f, -0.08711404f, 0.00810046f, -0.51488405f, 
    -0.25321850f, -0.80414033f, -0.01947936f, 0.26343623f, 0.04615754f, -0.04390639f, 0.19419952f, -0.15991354f, 
    0.22947702f, -0.19616400f, -0.29736942f, 0.02614353f, 0.12341514f, 0.00877704f, 0.14351809f, -0.11424470f, 
    0.02499527f, 0.37382978f, -0.33117852f, -0.29177868f, -0.09278210f, -0.13164257f, -0.01296548f, -0.03742194f, 
    -0.26369771f, -0.03003918f, -0.38207012f, 0.23586386f, 0.36663505f, 0.01983449f, 0.02273129f, -0.12036231f, 
    0.31043616f, 0.16035728f, 0.03649532f, 0.04957260f, -0.33041567f, -0.23408136f, -0.44730997f, -0.10754459f, 
    0.03775952f, -0.07050119f, 0.24815571f, 0.10558084f, -1.05943811f, -0.25737926f, 0.57779634f, 0.12352319f, 
    0.05581274f, -0.04288999f, 0.01006143f, 0.04812318f, 0.17628647f, -0.62067276f, 0.03949479f, -0.14310420f, 
    0.02815643f, -0.14927204f, 0.02674797f, -0.14167570f, 0.16960391f, -0.15553346f, 0.59490442f, 0.23455946f, 
    -0.29965377f, 0.04923788f, -0.06084490f, 0.00479536f, 0.12296823f, 0.14452136f, 0.07464404f, 0.51616615f, 
    -0.09262948f, -0.41983235f, -0.13636963f, 0.19146442f, 0.18275325f, -0.00175855f, -0.08001772f, -0.10168576f, 
    -0.25154990f, 0.41253057f, 0.05517773f, 0.03802437f, 0.03137594f, -0.08934123f, -0.05436395f, 0.02425904f, 
    0.02605886f, 0.94738454f, -0.16058633f, -0.29227331f, -0.04923868f, -0.05352007f, 0.04595252f, -0.03711517f, 
    0.14082888f, -0.08740426f, 0.02668615f, -0.00603781f, -0.06332984f, -0.20343304f, 0.12070847f, -0.05176280f, 
    0.29490706f, 0.04758536f, 0.03246349f, 0.13090211f, -0.13613598f, -0.19691187f, -0.06485454f, 0.10784394f, 
    -0.31945494f, 0.42361137f, -0.10406894f, -0.04172220f, 0.65783477f, 0.14942531f, 0.82198697f, -0.18786031f, 
    -0.00197535f, 0.15815170f, 0.03873023f, 0.22817448f, 0.13054867f, 0.27444541f, -0.88149667f, -0.71796376f, 
    0.03354960f, 0.12398210f, -0.00101785f, 0.16166627f, -0.03337570f, -0.22424355f, -0.10741266f, -0.32949665f, 
    -0.22369057f, -0.12341931f, -0.12719296f, 0.02096610f, -0.08385062f, -0.07988987f, 0.05468657f, 0.05093170f, 
    0.10382122f, -0.39500380f, -0.25951552f, 0.00163007f, 0.09111556f, 0.25559801f, -0.15198742f, 0.10308145f, 
    -0.76148516f, 0.41815975f, 0.14228606f, -0.15431795f, 0.10173623f, -0.00370566f, -0.00320643f, -0.06674200f, 
    0.02590282f, -0.74774832f, -0.77656537f, 0.01524336f, 0.07171091f, 0.31078437f, -0.11712656f, 0.01396381f, 
    0.11611886f, -0.01017920f, 0.42445096f, 0.07617132f, 0.01624893f, -0.08553239f, 0.13608712f, 0.01770125f, 
    -0.18596496f, 0.02160641f, -0.05426956f, 0.45302019f, -0.64514375f, -0.39955792f, -0.20790534f, 0.02885742f, 
    0.11903936f, 0.09555063f, 0.05039160f, -0.02463073f, -0.08162659f, 0.42405584f, 0.03060573f, 0.34571537f, 
    0.15748374f, -0.18556808f, -0.01104188f, 0.07680680f, 0.34386849f, 0.50486946f, 0.39604506f, 0.06754161f, 
    0.18668990f, 0.22411460f, 0.40614194f, 0.34742779f, 0.16480936f, -0.31425640f, -0.03698290f, 0.09917342f, 
    -0.90132207f, -0.22934638f, -0.09301376f, -0.06674112f, 0.24926932f, -0.03848577f, 0.09929965f, 0.40630296f, 
    -0.67440897f, -0.48122898f, 0.11144621f, 0.18682036f, 0.38176829f, -0.03512529f, 0.03685449f, -0.02323780f, 
    0.53229773f, 0.08697610f, -0.09455263f, 0.05286734f, 0.16393100f, 0.09374361f, 0.01861691f, 0.20448269f, 
    0.14737257f, -0.97735566f, -1.14303088f, -0.70096695f, -0.22303976f, -0.02151809f, 0.08279020f, 0.10280897f, 
    -0.03767448f, 0.05669437f, -0.34907275f, -0.06126588f, -0.11708430f, -0.02085914f, 0.16319254f, -0.03579186f, 
    0.13250633f, -0.00723807f, -0.09702042f, 0.09421932f, 0.06883618f, -0.38814396f, 0.03369384f, -0.20292109f, 
    0.05894492f, 0.18031247f, 0.12284496f, 0.02782449f, -0.69616264f, 0.13527486f, 0.05598718f, 0.03991645f, 
    0.06249890f, -0.24052331f, 0.01745054f, -0.09362483f, 0.03403411f, -1.46784067f, -0.52162409f, -0.43479216f, 
    0.36500740f, 0.31528082f, 0.42052519f, 0.00064877f, 0.00905451f, -0.06137436f, -0.50546342f, -0.32950279f, 
    0.20808415f, -0.10955855f, 0.02161665f, 0.04999781f, -0.01586863f, 0.29567274f, -0.18555148f, -0.47622755f, 
    0.21632197f, 0.08490370f, 0.26500872f, 0.12705366f, -0.07445644f, 0.25746727f, -0.11792618f, 0.09785575f, 
    -0.87178028f, -0.41823485f, 0.36049867f, 0.18603700f, 0.20838143f, 0.16328716f, 0.19705863f, 0.05879311f, 
    0.02635787f, -0.14969398f, 0.07682253f, -0.77298337f, -0.08139594f, -0.04218698f, -0.03659486f, 0.01744834f, 
    0.09821941f, 0.19688965f, 0.02596397f, 0.40894908f, 0.16118206f, -0.23332801f, -0.27980053f, 0.00638821f, 
    0.14416280f, -0.13859837f, 0.16271225f, -0.34758031f, -0.29073930f, -0.06520325f, 0.24128883f, 0.32380423f, 
    -0.01293742f, 0.14863861f, 0.00126287f, 0.08161021f, 0.39457691f, -0.09206385f, -0.29633263f, -0.22384295f, 
    0.07306876f, -0.16181430f, -0.17408352f, 0.26393637f, 0.05033581f, 0.27477363f, -0.20569204f, 0.07343964f, 
    -0.25183907f, 0.04246616f, -0.05343529f, 0.27173769f, 0.35291108f, -0.13152704f, -0.68493009f, -0.52715117f, 
    -0.27418867f, -0.20270035f, -0.19427526f, -0.02176488f, 0.08465318f, 0.12179493f, 0.12775867f, -0.63299632f, 
    0.70730531f, 0.25850186f, -0.24722801f, -0.07915394f, 0.12403493f, 0.02770667f, -0.02102025f, -0.22762425f, 
    -0.06459010f, 0.34516680f, 0.06054199f, -0.01791388f, -0.09537121f, 0.00617213f, 0.02372047f, 0.06961150f, 
    0.21055272f, -0.18913831f, -0.18983336f, 0.16796435f, -0.08775992f, -0.00378597f, 0.17627206f, 0.02377564f, 
    0.00103208f, -0.05014774f, 0.10543399f, 0.15972634f, -0.17163140f, -0.30114898f, -0.24532683f, -0.00713653f, 
    -0.01396504f, 0.11939635f, 0.14383681f, 0.12180633f, -0.30802065f, -0.17797492f, -0.40622902f, 0.05259993f, 
    -0.39577058f, 0.14029478f, 0.11532030f, 0.05183553f, -1.48105323f, 0.65810031f, 0.38983372f, -0.07961059f, 
    -0.19644961f, -0.26450536f, 0.00609115f, 0.03186442f, -0.12257533f, 0.05225538f, -0.27589333f, -0.04525245f, 
    -0.32693347f, 0.31741726f, -0.12819827f, -0.12834537f, 0.13371648f, 0.04402594f, -0.69867587f, 0.28012115f, 
    -0.15004916f, 0.27975073f, -0.19607250f, 0.07359044f, 0.08440497f, -0.24267547f, 0.01542108f, -0.09756941f, 
    1.18481743f, -0.19507615f, 0.22665757f, 0.07300877f, 0.00816323f, 0.24958000f, 0.11213590f, 0.08001576f, 
    -0.19146633f, 0.36817938f, 0.33436793f, 0.11447971f, 0.18801542f, -0.07737004f, -0.04979102f, 0.15490082f, 
    0.01034924f, -0.08123149f, -0.49612403f, 0.17143223f, 0.09608600f, -0.21854198f, -0.15138395f, -0.14125523f, 
    -0.10076465f, -0.01682390f, -0.11875288f, 0.21250546f, -0.04750475f, -0.05075663f, -0.31591851f, -0.26793945f, 
    -0.10171866f, -0.32916859f, 0.00167197f, 0.32451096f, 0.17280988f, -0.69682729f, 0.15143366f, 0.04939830f, 
    -0.04019005f, 0.15076254f, 0.09686387f, 0.17460836f, 0.01793543f, -0.63913536f, -0.73544419f, -0.07281104f, 
    -0.34554198f, 0.06041481f, -0.04945797f, 0.01253383f, 0.02714775f, 0.16698205f, -0.39204365f, -0.40790290f, 
    0.09662588f, -0.04385012f, 0.17407909f, 0.12795606f, 0.28659377f, -0.08607692f, 0.13429588f, 0.35929972f, 
    0.12351528f, 0.04949679f, -0.05337474f, -0.20842111f, -0.06892170f, 0.14574839f, -0.12944339f, -0.20552202f, 
    0.38125521f, 0.92433566f, -0.00599470f, -0.01468742f, -0.03436717f, -0.04697125f, 0.14454471f, 0.00923007f, 
    -0.18087479f, 0.06635451f, -0.21243162f, 0.17964166f, 0.00363059f, 0.00413545f, 0.04743066f, 0.16127357f, 
    0.25097963f, -0.11554386f, -0.11323787f, -0.30041605f, -0.06273326f, -0.00437191f, 0.00151012f, 0.10436816f, 
    -0.16989540f, -0.02389002f, -0.41033137f, -0.08473194f, -0.01358158f, 0.10709996f, -0.06500523f, 0.14527912f, 
    0.28452587f, 0.10281571f, 0.15122926f, 0.26255020f, 0.02736245f, -0.41402924f, -0.03103467f, 0.03364794f, 
    -0.00423585f, 0.21142274f, 0.10242386f, 0.05506773f, -0.86390758f, -0.72762668f, -0.60131586f, -0.22944844f, 
    -0.17913575f, -0.13672115f, 0.11068963f, 0.08968891f, -0.09551179f, -0.48080730f, 0.25568235f, 0.12042603f, 
    -0.08404461f, -0.05179978f, 0.25718477f, 0.03465438f, -0.03809890f, -0.00016369f, -0.29505754f, -0.21873766f, 
    -0.24110676f, -0.66577411f, -0.04404458f, -0.22397403f, 0.02832638f, -0.11223087f, 0.02359940f, 0.30750194f, 
    0.08140137f, 0.04282410f, 0.25642782f, 0.14560062f, -0.10645257f, 0.41727567f, 0.22109362f, 0.11484576f, 
    0.46476033f, 0.07144539f, 0.43660325f, -0.06035157f, -0.12243954f, -0.14399414f, -0.02515512f, 0.02815899f, 
    0.00580397f, 0.14482324f, 0.10267794f, 0.30340394f, 0.31110832f, -0.14828975f, -0.33239573f, 0.01072763f, 
    -0.27287370f, 0.31151849f, -0.05892241f, -0.06568875f, -0.39563093f, 0.29179031f, 0.02102372f, -0.31372383f, 
    0.04704668f, -0.03594152f, -0.04390027f, 0.32031152f, -0.25327110f, -0.08063821f, -0.15203243f, -0.34113255f, 
    -0.25819790f, 0.25213540f, 0.07799695f, -0.25381762f, 0.60191435f, 0.31459606f, 0.52167439f, -0.04109722f, 
    -0.08601156f, 0.42301336f, 0.02156790f, 0.11789267f, 0.28685316f, 0.73361301f, 0.04531970f, -0.15123086f, 
    0.08872599f, -0.00560297f, 0.03350012f, -0.16683805f, -0.03322236f, 0.10001601f, -0.16097324f, 0.12697260f, 
    0.21934442f, 0.06176720f, 0.28988874f, 0.10550219f, -0.06536800f, 0.26949757f, -0.16696362f, -0.33706740f, 
    -0.45342475f, -0.49823880f, 0.00799968f, 0.08300155f, -0.08393801f, -0.11271239f, 0.04780649f, 0.08469892f, 
    -0.73480248f, -0.98528194f, -0.86420208f, -0.07376331f, -0.13808686f, -0.20318940f, 0.00703262f, 0.03828385f, 
    -0.07853051f, 0.11287337f, -0.01988195f, 0.09062584f, 0.10580731f, 0.14982502f, -0.17637716f, 0.15099339f, 
    0.13327096f, 0.05055618f, 0.26306033f, 0.02250148f, -0.01063769f, -0.07906729f, -0.04720808f, -0.01964810f, 
    0.25371253f, 0.20761815f, 0.15662308f, 0.05246684f, -0.13932237f, 0.33882192f, 0.06704290f, -0.22820111f, 
    0.02451102f, 0.01883438f, -0.01858214f, -0.01584777f, 0.32410932f, 0.10410590f, 0.65675074f, 0.11731164f, 
    0.11939906f, -0.13815629f, 0.04909772f, -0.08146910f, -0.22588599f, -0.12775391f, -0.03346619f, 0.16855867f, 
    -0.34155792f, 0.18330716f, 0.10339388f, 0.10723326f, -0.38326618f, 0.18511389f, -0.78630793f, -0.01344585f, 
    0.57964426f, -0.09171978f, -0.40915895f, -0.39816582f, -0.12312556f, -0.07250758f, -0.06904930f, 0.17765339f, 
    0.34299439f, 0.45619309f, -0.12944166f, -0.22105747f, -0.07729588f, -0.03278699f, -0.29442137f, -0.32188386f, 
    -0.13285808f, 0.02445069f, 0.24670088f, 0.15893877f, 0.17566362f, -0.04313480f, -0.05937210f, -0.01436694f, 
    -0.10376699f, 0.15155265f, 0.01440674f, -0.38258186f, 0.27784377f, -0.17243679f, 0.04739341f, 0.07016119f, 
    0.27940384f, -0.10741120f, 0.27630496f, 0.20762737f, -0.05975179f, 0.12949181f, -0.02842286f, -0.07648861f, 
    0.23275280f, 0.03644970f, 0.17683303f, 0.10064957f, 0.47461462f, -0.20929992f, 0.08510325f, -0.06326041f, 
    -0.19203465f, -0.12943360f, -0.12898622f, -0.19239940f, 0.12837391f, 0.11644447f, 0.23684803f, 0.12676577f, 
    0.02536972f, 0.06441183f, 0.06220370f, -0.12832567f, -0.06996359f, -0.15839472f, 0.38563305f, -0.22807723f, 
    -0.09409599f, -0.33174697f, -0.08537196f, -0.03081401f, -0.04766897f, -0.39224645f, 0.38382557f, 0.27024168f, 
    0.49289814f, -0.19570015f, -0.09974290f, -0.08273671f, -0.04340236f, 0.02292018f, 0.21981435f, -0.19117524f, 
    -0.41066897f, 0.05147353f, 0.24601871f, 0.11415073f, 0.34348986f, 0.14813913f, 0.28211948f, 0.28725556f, 
    0.17502183f, -0.18799660f, -0.35988912f, 0.07450281f, 0.14188351f, -0.31963021f, 0.23531234f, 0.13572808f, 
    0.10722993f, 0.35700107f, 0.08279213f, 0.06598915f, 0.16046575f, 0.06790261f, -0.21334445f, 0.22379522f, 
    -0.04472885f, 0.17218286f, 0.04654658f, -0.05509811f, 0.08865611f, 0.32383224f, 0.20415047f, 0.32729706f, 
    -0.29802096f, -0.54298395f, -0.75898814f, -0.11380135f, 0.20802104f, 0.20599362f, 0.10506499f, 0.23018938f, 
    -0.02794162f, -0.05713099f, 0.06553447f, -0.24673019f, 0.44777739f, 0.27101058f, 0.36262503f, 0.06645112f, 
    -0.09089896f, -0.02460599f, -0.01342892f, -0.09188256f, -0.18943061f, 0.48204720f, 0.02829032f, 0.08255022f, 
    -0.04644886f, 0.25851867f, 0.05334586f, -0.12611048f, 0.09892059f, 0.26855180f, -0.20342782f, -0.05846078f, 
    -0.25987238f, 0.19460897f, 0.32178250f, 0.43794373f, -0.13077371f, 0.60799950f, 0.20171490f, -0.23630445f, 
    0.16712740f, -0.12668048f, 0.06520645f, -0.00229078f, 0.00317047f, -0.06602659f, 0.07902008f, -0.01221076f, 
    0.04627545f, -0.07710148f, -0.00353588f, -0.01256210f, -0.00712167f, 0.05793129f, -0.07165500f, -0.06138362f, 
    -0.06381283f, 0.01209545f, 0.04587437f, 0.01247658f, -0.00692597f, -0.01541731f, 0.03688306f, -0.06963217f, 
    -0.05192926f, -0.07678782f, -0.02172009f, -0.03298122f, 0.03178940f, 0.03251250f, -0.05526000f, 0.02892522f, 
    -0.07014938f, -0.02729234f, 0.01550225f, -0.05384180f, -0.06049235f, -0.01287783f, 0.06968279f, 0.01757698f, 
    -0.03451967f, -0.07932276f, -0.08379340f, -0.07597899f, 0.00095456f, -0.06559248f, 0.00965396f, -0.08406287f, 
    -0.01168939f, -0.01681877f, 0.07267718f, -0.00465658f, -0.00034428f, -0.00099974f, -0.07704839f, -0.08422256f, 
    -0.05536089f, 0.01657475f, 0.01595428f, 0.00700478f, -0.02287793f, 0.03837429f, 0.07497399f, -0.05049126f, 
    -0.04840627f, 0.00687304f, -0.05559484f, 0.02701653f, -0.04410278f, -0.06923036f, -0.07422188f, 0.00216638f, 
    -0.05130916f, -0.07202822f, -0.08830902f, -0.02381506f, -0.05422923f, -0.00358129f, 0.00581112f, -0.04679866f, 
    -0.04849390f, 0.05059325f, -0.03039250f, -0.07141192f, 0.07664624f, -0.02673817f, 0.01826799f, -0.01915048f, 
    -0.07501063f, 0.00573487f, -0.06934044f, -0.05472565f, 0.02536625f, -0.06646722f, 0.05935103f, 0.07170027f, 
    -0.05627102f, 0.07101376f, 0.04477874f, -0.01573422f, 0.06876407f, -0.00897477f, 0.03451747f, -0.06831625f, 
    0.01497052f, 0.02279345f, -0.06979766f, -0.07950866f, 0.03772200f, -0.04223973f, -0.00372327f, 0.04184249f, 
    0.03557698f, -0.06999587f, 0.04231047f, 0.00769083f, 0.02297965f, 0.05727300f, 0.00010214f, -0.01394908f, 
    0.01619836f, -0.02069518f, -0.07467651f, 0.03554647f, -0.06855521f, -0.00591815f, 0.05368258f, -0.00340289f, 
    0.05133251f, -0.00727031f, -0.01466982f, -0.08002976f, 0.04196690f, -0.02963989f, 0.03189773f, -0.03944773f, 
    -0.04391643f, 0.01955922f, -0.07410275f, -0.07949893f, 0.07526591f, 0.00746637f, -0.01425137f, 0.06455921f, 
    0.04990442f, -0.03383478f, -0.06247361f, 0.01240267f, -0.00318242f, 0.00237369f, -0.01005019f, -0.00909639f, 
    -0.36345649f, -0.23772500f, 0.32451254f, 0.02544046f, 0.31106433f, 0.18251134f, 0.06841880f, 0.01248082f, 
    0.02783871f, -0.14084014f, 0.56049275f, 0.37206915f, 0.08479509f, 0.10447730f, -0.04527574f, 0.02660178f, 
    -0.03855653f, -0.01942598f, 0.45125315f, 0.14783335f, 0.23085850f, -0.06122333f, -0.02991693f, -0.03810038f, 
    0.11460713f, 0.16522135f, 0.00460369f, -0.13972114f, -0.13165443f, 0.35730886f, 0.06503010f, 0.08813547f, 
    0.39040858f, 0.04227100f, 0.04870611f, 0.25243571f, -0.49036449f, -0.22861436f, 0.95678431f, -0.17666230f, 
    -0.26576737f, -0.30698389f, 0.01095872f, -0.08054477f, 0.21821171f, -0.40374786f, 0.54068553f, -0.12643148f, 
    0.35384077f, 0.41999575f, 0.37003762f, 0.24613346f, -0.02813932f, 0.08434387f, 0.28963009f, 0.08298319f, 
    -0.33527315f, -0.25102761f, 0.12201847f, -0.06497579f, 0.18160410f, 0.05056072f, 0.13291571f, -0.04204678f, 
    0.02352999f, -0.08727176f, -0.12136793f, -0.13026656f, -0.35197523f, -0.06126479f, 0.03762713f, -0.02177873f, 
    0.16385508f, 0.50136232f, 0.02911635f, 0.10954503f, -0.26147667f, -0.06434875f, 0.09461076f, 0.20715959f, 
    -0.05249510f, -0.11757665f, 0.13788322f, -0.21574499f, -0.33044049f, -0.07987648f, -0.02207614f, 0.12200912f, 
    0.10431987f, -0.05344417f, -0.22634766f, -0.27769089f, -0.09336469f, -0.14715967f, 0.03176081f, -0.25458676f, 
    0.10233545f, -0.02677000f, 0.06616602f, -0.46575361f, 0.06255012f, -0.40984669f, 0.08368811f, -0.11106128f, 
    -0.16798817f, -0.05832340f, 0.09294489f, 0.36901185f, -0.07074286f, -0.20017117f, 0.35992673f, -0.59165066f, 
    0.06430775f, -0.23115964f, -0.02522963f, 0.02066853f, -0.08567594f, -0.64337552f, -0.69514841f, 0.26166338f, 
    0.12466590f, 0.16201359f, -0.11014833f, 0.04871213f, 0.07281536f, 0.00990106f, -0.00215873f, -0.03743325f, 
    0.03188428f, -0.36462247f, -0.22403616f, -0.06792529f, -0.03317700f, -0.33587959f, -0.35661390f, 0.22632059f, 
    -0.11121442f, 0.90896875f, -0.17932516f, 0.16998915f, 0.27511320f, 0.15505381f, 0.00442587f, -0.12604709f, 
    -0.16816618f, 0.11680138f, 0.10701960f, -0.00601149f, -0.02630142f, 0.23847896f, 0.03182450f, -0.09958736f, 
    0.02445931f, 0.14865044f, 0.30786979f, 0.11897887f, -0.19789878f, 0.11768182f, 0.10630587f, 0.27942276f, 
    -0.07709359f, 0.18208806f, 0.15144360f, -0.37101176f, -0.43352997f, 0.06532918f, 0.12394360f, 0.46765774f, 
    0.19460462f, 0.23759583f, -0.10555214f, 0.09673825f, 0.40986323f, 0.05655735f, -0.12084917f, -0.10670832f, 
    -0.33761063f, 0.06887865f, -0.04926038f, -0.10279362f, 0.26740956f, -0.62314719f, -0.24200000f, -0.09097537f, 
    0.00296843f, -0.35773462f, 0.11082657f, 0.11229238f, -0.07476456f, -0.34587467f, -1.18216121f, -1.33482337f, 
    0.05514176f, -0.34513837f, 0.02803713f, 0.02469786f, 0.12835309f, -0.02336773f, 0.40543303f, 0.38284883f, 
    0.59011048f, 0.14422065f, 0.03732955f, -0.09324599f, 0.21750146f, -0.06824657f, -0.10333616f, 0.41960800f, 
    -0.09559306f, 0.24592967f, 0.12611848f, 0.02156709f, 0.10602786f, 0.15741020f, -0.01030414f, 0.07829798f, 
    -0.18610290f, -0.55606228f, -0.08037663f, 0.09873562f, -0.04620619f, -0.01071559f, 0.02385698f, -0.02931163f, 
    -0.02547475f, -0.27014321f, 0.29787710f, 0.51204300f, 0.02881858f, 0.01616928f, -0.02842352f, 0.10806204f, 
    0.13067663f, -0.08885309f, -0.20285532f, -0.07716510f, -0.33885014f, -0.07237206f, -0.03209550f, 0.20799163f, 
    0.00571521f, 0.18397899f, 0.35941434f, 0.12746510f, -0.37234870f, -0.75956565f, -0.30954114f, 0.02478251f, 
    -0.09294252f, 0.06532811f, 0.01793516f, -0.01751935f, 0.21158095f, 0.15418032f, 0.24472801f, -0.33211392f, 
    -0.11437091f, -0.11320779f, -0.23058333f, -0.13320450f, 0.05771120f, -0.85923874f, -0.33228385f, 0.00212513f, 
    0.20248580f, -0.05772519f, 0.31960970f, 0.39337891f, 0.21262926f, -0.19843982f, 0.31406084f, 0.13400201f, 
    0.06517664f, -0.22517219f, 0.12958848f, -0.06697941f, -0.00717515f, 0.16992266f, -0.06976251f, 0.17458928f, 
    0.11591730f, 0.00961661f, -0.10341701f, 0.03366661f, -0.00181879f, 0.17186144f, -0.04583593f, 0.01517230f, 
    0.48911658f, 0.08236089f, 0.30230504f, 0.06713122f, -0.02468618f, -0.10447575f, 0.22421862f, -0.02422309f, 
    0.14668341f, 0.10981794f, 0.38595030f, 0.39646906f, -0.19040780f, 0.32643116f, 0.28496823f, -0.00022261f, 
    -0.13803636f, 0.20166825f, 0.23371083f, -0.04301912f, -0.10491128f, -0.10116843f, 0.10058919f, -0.09697277f, 
    0.12744585f, 0.23236829f, 0.05311010f, -0.25676954f, -0.03575466f, -0.31614360f, 0.07379074f, -0.20159012f, 
    -0.15442324f, 0.14822440f, 0.13219890f, 0.08258635f, -0.30493543f, -0.53731036f, 0.40728906f, 0.09408927f, 
    0.18573889f, 0.06195434f, 0.07199530f, 0.05725885f, 0.25989130f, -0.81550193f, -1.52262819f, 0.06277858f, 
    -0.12842935f, -0.24723381f, 0.56647497f, -0.13638595f, -0.15910752f, -0.06728380f, -0.00796918f, 0.16242263f, 
    0.01556982f, 0.06646958f, 0.17926826f, -0.03394065f, -0.02264434f, 0.05641874f, -0.04006283f, 0.18744284f, 
    -0.31527460f, 0.29390702f, -0.36626238f, 0.12539658f, -0.06195093f, 0.16232081f, 0.03261833f, -0.04068349f, 
    -0.05715573f, -0.27775964f, -0.04932454f, -0.05011962f, -0.24568759f, -0.03996855f, 0.05525769f, -0.05851066f, 
    0.02414650f, -0.13430786f, 0.40901238f, 0.17374632f, -0.21102537f, -0.03290689f, -0.13410316f, 0.16030726f, 
    0.00513440f, -0.15098579f, 0.23429886f, -0.06023571f, -0.02382265f, 0.00218338f, -0.04153789f, -0.14510755f, 
    -0.12213010f, 0.12448240f, 0.10352996f, -0.79058719f, -0.38572070f, 0.32927042f, -0.21467751f, 0.05088856f, 
    -0.19684638f, -0.27675813f, -0.13327086f, -0.22178635f, 0.10222454f, -0.06914611f, -0.16088945f, -0.11012553f, 
    0.15930639f, -0.09597208f, 0.00412687f, -0.01106570f, 0.14427552f, -0.66175812f, -0.36198348f, 0.65662271f, 
    0.21545473f, -0.10309699f, 0.18033394f, 0.02478956f, 0.32266411f, -0.33073181f, -0.20912671f, -0.43353397f, 
    0.72788972f, -0.51265091f, 0.16947378f, -0.00811883f, 0.14281458f, -0.03968663f, -0.13272096f, 0.14690493f, 
    0.09344887f, 0.37047893f, -0.01649989f, -0.25392815f, -0.26221451f, -0.03730355f, -0.05323559f, -0.11509435f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.50525558f, 0.34817019f, 0.53094238f, -0.12184694f, -0.04175676f, 0.23878087f, -0.16390757f, 0.29106578f, 
    0.14405349f, 0.48210555f, -0.11056060f, -0.13756476f, -0.01105878f, 0.45224592f, -0.14137955f, -0.07895987f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19730541f, 0.02005325f, -0.60192132f, 0.69294614f, -0.05350793f, 0.40321991f, 0.56573814f, -0.26351520f, 
    -0.29290757f, -0.71310115f, -0.23976570f, 0.01910206f, 0.09863947f, -0.72897214f, 0.57954675f, 0.52116245f, 
    0.05288792f, -0.22385289f, -0.05267902f, 0.22766937f, -0.02700213f, 0.46614477f, -0.48181799f, -0.07138246f, 
    -0.02244714f, 0.14763813f, -0.99236846f, -0.33122823f, 0.06704006f, 0.22158045f, 0.67781949f, 0.26674187f, 
    -0.84526354f, 0.34361148f, 0.06154934f, -0.14109495f, -0.21514018f, -0.24451669f, -0.72322547f, -0.83771962f, 
    0.66381359f, 1.22019231f, -0.56367815f, 0.18325329f, 0.13572368f, -0.54984373f, -0.60717136f, -0.32820478f, 
    -0.71471500f, -0.50947225f, -0.09156790f, -0.01808992f, 0.21594526f, 0.05943328f, 0.66095155f, -0.69299686f, 
    -0.73543155f, -0.89912820f, 0.38132444f, 0.48529854f, -0.13086464f, 0.07276231f, -0.24512503f, -0.63947546f, 
    -0.00662098f, 0.27716628f, -0.09673595f, -0.41695619f, -0.12205925f, 0.20846491f, -0.15373972f, -0.18477260f, 
    -0.50038463f, -1.19437325f, 0.76459396f, -0.13421525f, 0.22477916f, -0.08166153f, 0.12185848f, 0.70510912f, 
    -0.04459654f, -0.16681947f, 0.17419867f, 0.16958123f, 0.10715384f, -0.10672021f, -0.32944256f, -0.22169957f, 
    0.18147118f, 0.11616128f, 0.49985316f, -0.06174385f, 0.06053184f, -0.35129178f, -0.07593682f, -0.40765578f, 
    0.67995715f, 0.48525357f, -0.51258504f, -0.23451449f, -0.00725034f, -0.72676867f, -0.39116305f, 0.57759869f, 
    -0.20301260f, 1.12225878f, -0.21817376f, 0.11430492f, -0.03370393f, -0.10793979f, -1.36650789f, -0.19005762f, 
    -0.39585361f, -0.43904060f, -0.33511692f, 0.10216385f, -0.23968583f, 0.26366243f, 0.64017880f, 0.24807803f, 
    0.97232425f, -0.27925688f, 0.35750020f, -0.11880914f, 0.13994916f, -0.29170650f, -0.19638881f, 0.40572438f, 
    -0.45751917f, -0.19548330f, 0.17269428f, -0.01714151f, 0.12387703f, -0.49065191f, 1.10609627f, 0.65373904f, 
    -0.41164258f, -0.02807971f, -0.12817056f, -0.60233217f, -0.07424174f, 0.15870634f, -0.50080061f, -0.58732951f, 
    1.03886724f, 0.31252718f, 0.07462077f, -0.89937675f, 0.10414132f, -0.06242321f, -0.61893564f, -0.33747080f, 
    -0.74422044f, 0.04294623f, -0.77292359f, 0.10608856f, 0.23441155f, -0.12192703f, -0.08714113f, -0.13626443f, 
    -0.52214956f, -0.27732450f, 0.46292332f, 0.61202675f, -0.11925156f, -0.49804926f, -0.70601034f, -0.08031168f, 
    -0.57316774f, -0.30294514f, -0.04107541f, -0.59982318f, -0.07022181f, 0.13289221f, -1.21665287f, 0.70934272f, 
    -0.44745028f, 0.54757112f, -0.15381901f, 0.15429027f, -0.03478118f, -0.86320502f, -0.15790854f, -0.04377215f, 
    -0.18202604f, -1.13789749f, -0.84565228f, -0.23165964f, -0.23712213f, 1.13384187f, -0.42439663f, -0.87202448f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.43606943f, 0.19037944f, -0.01162676f, 0.39244241f, -0.32054782f, -0.04720367f, -0.11059569f, -0.90680575f, 
    0.28880498f, 0.29347953f, 0.17882495f, 0.24704723f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
