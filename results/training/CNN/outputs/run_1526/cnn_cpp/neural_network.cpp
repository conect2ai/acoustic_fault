#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.02722695f, 0.28579366f, 0.11107015f, -0.53832680f, 0.08688150f, 0.36821315f, -0.16083731f, -0.14078525f, 
    0.60505497f, -0.25380215f, -0.27163726f, -0.32733470f, -0.39728343f, -0.33418339f, -0.26366255f, -0.06494588f, 
    0.34453937f, 0.39438048f, -0.18939988f, -0.20491688f, 0.59383720f, -0.24930605f, -0.07747789f, 0.13564102f, 
    0.36544842f, 0.34131971f, 0.53502905f, -0.48859349f, -0.12793340f, 0.11094889f, 0.26944989f, -0.85735083f, 
    -0.68165559f, -0.27911431f, 0.43826500f, -0.29232273f, -0.82053906f, 1.18410301f, -0.68200892f, -0.09677894f, 
    -0.13819624f, 0.17426291f, 0.04334290f, 0.12754391f, 0.09348612f, -0.72766232f, 0.14165899f, -0.24095620f, 
    0.54014260f, -0.06574739f, -0.12069166f, -0.36390221f, -0.51957363f, -0.46050179f, 0.46979621f, 0.10005749f, 
    -0.18853286f, 0.21548532f, 0.09189980f, 0.56838346f, 0.58617818f, -0.29558676f, -0.50327259f, -0.75276172f, 
    -0.59456766f, -0.51137149f, 0.27742037f, -0.29549870f, 0.38154039f, 0.32449085f, 0.07576404f, 0.00849849f, 
    -0.28414536f, -0.17865227f, -0.36551210f, -0.45600280f, 0.36571881f, 0.68333548f, -0.25124064f, -0.14060171f, 
    -0.24872506f, 0.30231661f, 0.09895647f, 0.04384344f, 0.22368513f, 0.10326869f, -0.32281461f, -0.20501423f, 
    0.06125613f, -0.48470721f, -0.21930386f, 0.23055375f, 0.18042840f, 0.31911689f, 0.42329770f, 0.41002965f, 
    0.11924837f, 0.00651866f, 0.23218222f, 0.88911164f, 0.63739336f, 0.23299465f, -0.24472308f, -0.07072037f, 
    0.08004336f, 0.05819204f, -0.02161495f, 0.15131655f, -0.52128875f, -0.67304814f, -0.32158390f, 0.21446280f, 
    0.70342726f, -0.04458138f, 0.33556649f, 0.18889897f, -0.02202036f, -0.43264821f, 0.13729104f, 0.89337283f, 
    -0.19637971f, 0.44929805f, -0.64704353f, 0.03467892f, -0.12557277f, -0.27328408f, -0.34596226f, -0.05353997f, 
    0.26393545f, 0.45831680f, 0.24742159f, 0.63054329f, -0.12498640f, 0.08657449f, -0.17725141f, 0.06167839f, 
    0.19015945f, -0.14910468f, -0.24215834f, -0.49049982f, -0.60685021f, 0.25299954f, 0.15765128f, 0.61088306f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31235805f, -0.40022308f, 0.10142476f, 0.06301203f, -0.06759930f, -0.03461241f, -0.13722686f, 0.36183622f, 
    -0.08681961f, 0.38329995f, -0.02127064f, 0.33609304f, -0.05014302f, -0.11157443f, 0.21574967f, -0.21037254f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.02619284f, 0.04709295f, -0.01297158f, -0.04702163f, -0.08036515f, -0.02439470f, -0.06123143f, 0.04355584f, 
    -0.04384746f, 0.07568750f, 0.03894304f, -0.03082670f, -0.02374454f, 0.03350141f, 0.06671123f, 0.03741622f, 
    0.04169435f, 0.06912512f, -0.04228574f, -0.03171149f, -0.07797003f, -0.03291124f, 0.03801949f, 0.04916580f, 
    -0.00684324f, 0.04005694f, 0.02237429f, 0.04022715f, -0.02693561f, -0.05653693f, -0.05214364f, -0.08652257f, 
    -0.00859399f, -0.07787739f, -0.00564587f, 0.02080790f, -0.00497154f, 0.07934508f, -0.05174091f, 0.01122106f, 
    0.01028892f, -0.00230949f, -0.07461636f, 0.02845948f, -0.07695265f, -0.02879734f, -0.02318638f, -0.04704886f, 
    -0.05768272f, -0.01054257f, 0.00173243f, 0.05372760f, -0.08212435f, 0.05901915f, -0.08890269f, 0.02249783f, 
    0.02851251f, -0.03073239f, -0.05590383f, -0.07182766f, -0.00754631f, -0.06713104f, -0.01953572f, 0.00324203f, 
    -0.05991742f, -0.01334479f, 0.05824519f, -0.02435917f, 0.04385596f, -0.07106605f, -0.03291260f, 0.05101752f, 
    -0.02060579f, -0.05636844f, 0.02626797f, -0.02912187f, -0.04458137f, -0.08505044f, -0.00272157f, 0.00506989f, 
    0.04210427f, -0.00036295f, -0.03912221f, -0.00393240f, -0.07120975f, 0.01468202f, -0.06707083f, 0.03382188f, 
    -0.08528229f, -0.03577952f, -0.03545049f, -0.03913105f, -0.05960506f, 0.06063355f, 0.04229262f, 0.06304604f, 
    0.00383862f, 0.00799213f, -0.08436395f, 0.03026629f, -0.02528729f, -0.03478084f, 0.03360789f, -0.00810710f, 
    -0.07360479f, -0.02375628f, -0.03643883f, -0.05974472f, 0.05554471f, 0.03590655f, -0.05228951f, -0.01002897f, 
    -0.07938445f, 0.02755627f, -0.02891419f, -0.04687007f, -0.03959776f, -0.08678194f, -0.04191438f, -0.09408257f, 
    0.06946781f, 0.00804700f, 0.06017101f, -0.09157201f, -0.01963296f, 0.00999285f, -0.02851790f, 0.04505090f, 
    -0.07924093f, 0.00052135f, -0.01331517f, 0.07146921f, -0.02350811f, -0.00163206f, -0.01399573f, -0.04129346f, 
    0.07394736f, 0.07643350f, 0.04049050f, 0.06227934f, -0.09054147f, -0.00779735f, 0.06438157f, -0.04057917f, 
    -0.18644324f, -0.16676277f, 0.16796817f, 0.12072433f, -0.00067453f, -0.09230570f, 0.14156044f, 0.05656331f, 
    0.16060765f, 0.11333091f, 0.35850492f, 0.37670556f, 0.06720781f, -0.08645141f, 0.08946956f, 0.03441679f, 
    0.09575590f, 0.14715154f, -0.13664538f, -0.02814177f, -0.01699830f, -0.01875759f, 0.23854432f, -0.05102291f, 
    0.11845492f, 0.11075375f, 0.05384152f, 0.06677271f, 0.34862083f, 0.33062240f, -0.05611357f, 0.11210816f, 
    0.01528820f, -0.04165644f, -0.00594416f, 0.04296938f, -0.43124744f, -0.10506551f, -0.36848754f, -0.17366193f, 
    -0.21646544f, 0.19274309f, 0.04955654f, 0.12244029f, -0.03372518f, 0.16354972f, 0.28053057f, 0.05017438f, 
    -0.11067501f, -0.03188031f, 0.12215016f, 0.04181030f, 0.04554228f, -0.18190056f, -0.05415373f, -0.00638618f, 
    -0.20197460f, 0.06400005f, -0.28187627f, -0.20412575f, -0.05136200f, 0.01775345f, -0.03506114f, 0.26512346f, 
    0.19602141f, -0.01639696f, -0.03652643f, 0.11621197f, 0.16832559f, 0.04629580f, 0.08121178f, 0.00337648f, 
    -0.06090951f, -0.18839003f, 0.02162221f, 0.11895575f, -0.07574008f, 0.09423806f, 0.21262836f, 0.04733952f, 
    -0.01589550f, 0.12470457f, -0.24422359f, -0.04048599f, 0.09870535f, -0.04155549f, -0.02584342f, 0.12332138f, 
    -0.08411761f, -0.20673296f, -0.07653978f, -0.18778765f, 0.01414474f, -0.04248619f, 0.04815660f, -0.17166956f, 
    0.00859339f, 0.16458407f, -0.03660427f, -0.02825059f, -0.26551798f, -0.10175482f, -0.03462742f, -0.03259770f, 
    0.09583723f, -0.08662922f, 0.07984640f, 0.14045970f, 0.35299000f, -0.00251269f, -0.20420372f, 0.05380132f, 
    -0.07733116f, 0.04858159f, -0.05090339f, -0.05284292f, 0.07019075f, -0.57816178f, -0.70891696f, -0.03086057f, 
    -0.02190992f, -0.03707439f, -0.10988987f, -0.06541853f, 0.08795009f, -0.05974836f, -0.35283488f, -0.17801195f, 
    -0.07146151f, -0.14580341f, -0.11617793f, -0.09623855f, 0.08613433f, -0.02348385f, -0.08018617f, 0.18322362f, 
    0.16780129f, 0.12919840f, 0.05021802f, -0.11551414f, -0.15266545f, 0.01779352f, 0.00393359f, 0.09321650f, 
    -0.03090606f, -0.16322525f, -0.02919030f, -0.02304926f, 0.21447700f, 0.14500441f, -0.08801624f, 0.07153939f, 
    0.09533481f, -0.27717325f, 0.04263207f, -0.27346084f, -0.19602723f, -0.04422904f, -0.08212207f, -0.12502658f, 
    0.05380402f, 0.28286567f, -0.01216069f, 0.12284620f, 0.16308756f, 0.25997365f, -0.04010141f, 0.24198379f, 
    -0.07536893f, 0.09996730f, 0.08746579f, -0.75297624f, -0.82379454f, -0.32565230f, -0.26382965f, 0.02938122f, 
    -0.01491116f, 0.05877815f, -0.11134565f, 0.16150434f, -1.02712178f, 0.00431813f, -0.36214057f, -0.15044890f, 
    0.24352461f, 0.11211134f, 0.16980647f, 0.09079178f, -0.09171805f, -0.28363961f, 0.42536235f, -0.33313361f, 
    0.11999000f, 0.01976610f, -0.00944864f, 0.01340040f, -0.02931539f, 0.05493922f, 0.06498174f, -0.14728701f, 
    0.17987701f, 0.10559189f, 0.08269592f, -0.21831544f, 0.01447175f, -0.07422107f, 0.09851156f, -0.01318255f, 
    0.28421679f, -0.08379007f, -0.25382176f, -0.17348902f, 0.15051617f, -0.02219511f, 0.10359364f, -0.09449869f, 
    -0.52810407f, -0.08070759f, -0.29396993f, -0.12508364f, 0.08263604f, -0.30336919f, 0.08015313f, -0.01719519f, 
    -0.27259889f, 0.22214974f, -0.09283741f, 0.04929613f, 0.05334258f, 0.13766940f, 0.01513522f, 0.07656857f, 
    0.08378355f, 0.19669855f, -0.04027596f, 0.03393871f, 0.33846524f, -0.06073859f, -0.03580291f, 0.03598749f, 
    0.06517749f, 0.03952200f, -0.06412835f, 0.37716404f, 0.03467647f, 0.02223572f, 0.07812886f, 0.05050368f, 
    0.08320589f, -0.07835709f, 0.02764365f, 0.05448157f, -0.09893558f, 0.01246255f, -0.26382771f, 0.02616561f, 
    -0.10918877f, -0.13952754f, 0.20744237f, -0.00901435f, -0.14112975f, 0.10229072f, -0.69968903f, 0.23192170f, 
    -0.09290867f, 0.28217015f, -0.08457918f, -0.04538733f, 0.02263630f, 0.15641747f, 0.18211845f, 0.10975868f, 
    0.41349381f, 0.08322337f, -0.00491503f, -0.05344333f, 0.02767764f, -0.05967268f, -0.00869969f, 0.19212390f, 
    -0.00731154f, -0.29102707f, 0.04206419f, 0.04405031f, 0.09202719f, -0.11748549f, -0.06591902f, 0.13605012f, 
    0.17682236f, -0.05452580f, 0.33523020f, 0.05100663f, 0.24311158f, -0.03839390f, 0.15481514f, 0.17823970f, 
    0.15820229f, 0.55663955f, 0.07402369f, -0.12953083f, -0.11597092f, -0.08218632f, -0.09171687f, -0.04774551f, 
    -0.15766259f, -0.08050086f, -0.02789458f, -0.13891532f, -0.10184317f, 0.01451438f, 0.00165396f, 0.02589093f, 
    0.06978883f, 0.23437072f, 0.04649131f, -0.22490436f, 0.25502068f, 0.06307924f, -0.10313734f, 0.04115097f, 
    -0.03543149f, 0.06842647f, 0.00892783f, 0.04086887f, -0.53278518f, -0.84451848f, -0.40529829f, -0.21514584f, 
    0.07355751f, -0.18818006f, 0.11692403f, 0.01486324f, -0.04646309f, -0.19266708f, -0.36014384f, -0.23201169f, 
    -0.12024423f, 0.04749965f, 0.05366573f, 0.05044256f, -0.11980414f, 0.01644460f, -0.10050919f, 0.08206615f, 
    -0.09546145f, -0.06261512f, 0.00940257f, -0.24608770f, 0.02655972f, 0.03113467f, -0.09983856f, -0.09079729f, 
    -0.63736969f, -0.33063057f, 0.11707088f, 0.16320078f, 0.11642368f, 0.10634983f, -0.12421680f, 0.06148829f, 
    -0.24534509f, -0.55836159f, -0.15128914f, 0.05950426f, -0.11996028f, 0.09842385f, -0.05052074f, -0.15187895f, 
    -0.04087675f, 0.10593583f, 0.16508563f, 0.03959953f, 0.12033296f, 0.06326143f, 0.15437892f, 0.09739966f, 
    0.08977258f, 0.18429402f, 0.23274001f, -0.09815214f, -0.09158605f, -0.01567586f, -0.18167494f, -0.23380023f, 
    0.06244959f, -0.16285150f, 0.02047825f, 0.24057987f, 0.17197050f, 0.16338950f, -0.06693424f, 0.10338853f, 
    -0.00718084f, 0.00448828f, 0.03311302f, 0.14974335f, -0.19334862f, -0.71346909f, -0.16746642f, -0.11822216f, 
    0.24240136f, 0.04971683f, -0.04734342f, 0.12555435f, -0.26556224f, -0.14535752f, 0.14959031f, -0.04092537f, 
    0.20743512f, -0.11538856f, -0.05832971f, 0.08473253f, 0.02265181f, 0.08627912f, 0.11424882f, 0.03999211f, 
    0.10546685f, -0.05915825f, 0.03058444f, -0.02748896f, 0.01841577f, -0.15476999f, 0.05961049f, -0.00695081f, 
    0.26006085f, 0.02755045f, -0.11492111f, -0.12756835f, -0.09644809f, 0.05766638f, 0.15495291f, 0.05341072f, 
    0.03023074f, 0.06066160f, 0.05392710f, -0.01046196f, -0.05391353f, 0.04798631f, -0.03172182f, 0.00028591f, 
    0.06422573f, -0.04951236f, 0.00958434f, -0.04628982f, -0.02923715f, -0.06452632f, -0.00342475f, -0.07718366f, 
    -0.05109290f, -0.00918113f, -0.00247417f, -0.00865403f, -0.04788570f, -0.05680183f, -0.09018613f, 0.02737294f, 
    -0.09180171f, 0.02197367f, 0.04761424f, -0.02559334f, 0.04925409f, -0.05681873f, 0.05888252f, -0.00662212f, 
    0.01053394f, -0.05827592f, -0.05093410f, -0.01272422f, -0.01209619f, 0.01695441f, -0.04908339f, 0.04181485f, 
    -0.08483564f, 0.03268460f, -0.00458546f, -0.06297024f, 0.02493559f, -0.08071309f, -0.04491508f, 0.04821978f, 
    -0.01502963f, 0.05898567f, 0.02796557f, -0.07462266f, 0.02344248f, -0.00695814f, -0.01019454f, -0.00246357f, 
    -0.00133709f, 0.03627698f, -0.00666601f, 0.06162326f, -0.01873341f, -0.05962675f, 0.01220445f, -0.03803485f, 
    -0.02449344f, -0.08479898f, 0.06406146f, -0.09026892f, 0.01052811f, -0.02459055f, -0.08579263f, 0.01689843f, 
    -0.00121125f, -0.00198375f, -0.08879816f, -0.02354067f, -0.06474831f, -0.04271512f, 0.05225337f, 0.04003196f, 
    0.05584806f, 0.00300713f, -0.02314291f, -0.05939231f, -0.07030987f, -0.00561304f, -0.05905776f, -0.02700535f, 
    -0.00727573f, 0.01680932f, -0.08525909f, -0.02200115f, -0.08869848f, -0.08696506f, 0.07323193f, 0.00749313f, 
    -0.07726832f, -0.06217826f, -0.05845008f, -0.01638253f, 0.05472982f, -0.06288397f, 0.01067169f, 0.07325865f, 
    0.05769337f, -0.03532627f, -0.01661953f, 0.05536227f, -0.04559360f, -0.03383933f, -0.02797173f, 0.02692186f, 
    -0.04086699f, -0.04767848f, -0.01598878f, -0.04711025f, -0.07438774f, 0.01178525f, 0.00499449f, 0.04038136f, 
    -0.01846122f, -0.03967661f, 0.05760599f, 0.03199603f, 0.03519771f, 0.05021631f, -0.01213778f, 0.06515297f, 
    0.03756174f, 0.07277869f, -0.08103668f, -0.07128768f, -0.05620959f, 0.06088392f, -0.07479934f, -0.07677041f, 
    0.02251215f, -0.00616683f, -0.01176019f, 0.00246649f, 0.06286744f, 0.03373228f, 0.01697104f, -0.05597959f, 
    -0.35643762f, -0.25481591f, -0.28148627f, -0.03075572f, -0.01510233f, 0.12972060f, 0.17821427f, 0.13542470f, 
    -0.07693691f, -0.05354001f, -0.02941579f, 0.34421805f, -0.17370959f, 0.03323913f, -0.08113335f, 0.09866548f, 
    -0.16362709f, -0.14929368f, 0.16654247f, -0.25839144f, -0.28235921f, -0.05383022f, -0.00734457f, 0.19918011f, 
    0.04298936f, -0.08881042f, -0.09114337f, -0.28936198f, -0.46859559f, 0.21540648f, -0.02456717f, 0.20542035f, 
    -0.11125472f, 0.24486592f, -0.07601656f, 0.02098196f, 0.35456917f, -0.00799507f, -0.67795813f, -0.00563184f, 
    0.00605352f, 0.09632402f, 0.05181869f, -0.01327722f, 0.00717112f, -0.23742186f, -0.06868281f, -0.05872838f, 
    0.01274972f, -0.17011781f, 0.07532328f, 0.11591451f, 0.16752982f, 0.16506778f, 0.08722103f, 0.01355476f, 
    -0.11121145f, -0.11517970f, 0.03061037f, 0.01326874f, -0.05661116f, -0.06211225f, 0.22950250f, -0.04000829f, 
    0.12947002f, 0.23245899f, 0.20864794f, 0.10131034f, -0.06595488f, 0.02130186f, 0.00714000f, 0.09685320f, 
    -0.23385276f, -0.22461787f, -0.02510292f, 0.11023366f, 0.20138735f, -0.10411953f, -0.04981264f, -0.08312094f, 
    0.25298160f, 0.05099018f, -0.01019283f, 0.05186346f, 0.13636351f, 0.07496154f, -0.16691281f, 0.23636810f, 
    0.07182336f, 0.34111527f, 0.00823580f, 0.12585373f, -0.03770137f, -0.10806604f, -0.09334763f, -0.10734845f, 
    0.00083233f, 0.03504401f, 0.14207043f, 0.43733406f, -0.25060520f, 0.13490318f, 0.07261512f, 0.02894987f, 
    -0.08183011f, 0.06403570f, -0.06241508f, 0.00732172f, -0.16437009f, -0.28702861f, 0.39072725f, 0.01579222f, 
    0.21554759f, -0.08505744f, 0.11236593f, 0.16131331f, 0.00623860f, -0.24519907f, -0.32780454f, 0.17949614f, 
    -0.18244483f, -0.26742941f, -0.07372831f, 0.02778334f, 0.01208704f, -0.08774132f, -0.00977942f, 0.09626878f, 
    -0.06435042f, -0.10587677f, -0.01096958f, -0.02688912f, -0.03145169f, 0.03699292f, 0.13594125f, -0.10062609f, 
    -0.03805944f, -0.16816594f, -0.07039209f, 0.06082696f, -0.09348860f, -0.00127997f, 0.03104881f, -0.11159845f, 
    0.00463204f, 0.31345645f, 0.09495268f, 0.17773850f, 0.06030745f, 0.07727368f, -0.10980508f, -0.02745312f, 
    0.05032650f, -0.02391187f, 0.15952523f, 0.11785711f, -0.18642077f, -0.01912788f, 0.17934895f, 0.07106936f, 
    0.04235424f, 0.07931923f, 0.04366020f, 0.17791577f, -0.05732565f, 0.10773092f, 0.10429706f, 0.15449809f, 
    0.00944042f, 0.05343435f, 0.18663315f, -0.03007366f, -0.00072882f, 0.22258534f, -0.18668124f, 0.17244403f, 
    0.12144654f, 0.09142087f, 0.05490972f, -0.12455099f, 0.20591018f, 0.20515729f, 0.11878113f, -0.03001796f, 
    0.15180127f, -0.08387165f, -0.04995641f, -0.02275283f, -0.02081769f, 0.09916393f, -0.05449925f, 0.01768886f, 
    0.05070536f, 0.06623813f, -0.13098927f, -0.10081359f, -0.19864108f, -0.01602721f, -0.07791849f, 0.11098570f, 
    0.25743589f, 0.05809904f, -0.01512655f, 0.13876134f, -0.13244645f, 0.03556997f, -0.05555890f, 0.29983786f, 
    -0.12432092f, -0.21292014f, 0.17142934f, -0.16541232f, -0.16321342f, 0.10764638f, 0.07803185f, -0.05816009f, 
    0.10613493f, -0.16452506f, 0.13562298f, 0.04894159f, -0.25494218f, -0.22962052f, -0.01025412f, -0.01708361f, 
    -0.04434624f, -0.07418232f, -0.18972567f, -0.06037367f, -0.13651368f, -0.08077957f, -0.00922298f, -0.07352854f, 
    0.05562675f, -0.12400475f, 0.16190152f, 0.24720322f, 0.04862814f, 0.05977535f, -0.20536615f, -0.01896323f, 
    -0.13452078f, 0.03344770f, -0.15522218f, 0.01511018f, 0.06535257f, 0.15701158f, -0.03449593f, -0.06661201f, 
    0.12834810f, -0.06719961f, 0.02588979f, 0.13465436f, 0.23479845f, -0.27788290f, 0.00408925f, 0.07995414f, 
    -0.09961845f, -0.06696142f, 0.10632297f, 0.01799748f, -0.03529871f, -0.30868009f, 0.08829354f, -0.10196051f, 
    -0.00209135f, -0.01553668f, -0.08566939f, -0.14550811f, -0.00930790f, -0.03139970f, 0.12843430f, 0.19291143f, 
    0.14003477f, 0.00563445f, 0.04880988f, -0.06995296f, -0.03192738f, -0.04876380f, -0.17548737f, -0.09959423f, 
    0.01863050f, 0.16808154f, -0.14099447f, 0.17674218f, -0.02463788f, 0.03917277f, 0.12331168f, 0.34428787f, 
    -0.01942492f, -0.05674837f, 0.05679831f, -0.07030936f, -0.02419702f, -0.08124738f, 0.06556962f, -0.07175590f, 
    -0.06225908f, 0.03758731f, -0.08722007f, -0.06065292f, 0.01621354f, 0.01703953f, -0.03555010f, 0.03010839f, 
    -0.08517956f, 0.04606178f, 0.04062596f, 0.04654136f, -0.08501941f, -0.07695559f, 0.02919124f, 0.05175534f, 
    -0.06316108f, -0.08431441f, -0.01601139f, -0.03764385f, 0.02025383f, -0.01206817f, 0.01819072f, 0.03439334f, 
    -0.01524330f, -0.06163055f, 0.01480399f, 0.06611883f, -0.00154032f, -0.07043017f, 0.05247025f, -0.07102162f, 
    -0.03373086f, 0.06689656f, 0.04786951f, -0.04097540f, -0.01757355f, -0.03746356f, 0.01706951f, 0.02616232f, 
    -0.06667707f, 0.01789531f, -0.07227443f, -0.01992427f, -0.05505583f, -0.05446032f, 0.03365834f, -0.06047852f, 
    0.04134701f, 0.04955230f, 0.01635791f, 0.05072748f, 0.04115349f, -0.00888525f, 0.00941955f, 0.00619173f, 
    -0.08035202f, 0.04545315f, 0.04935991f, 0.03344358f, -0.03967315f, -0.07384680f, -0.03667404f, -0.04715943f, 
    -0.02466718f, 0.00876576f, -0.03966747f, 0.00700442f, -0.02229923f, 0.05207027f, -0.04585184f, 0.05673310f, 
    -0.07570460f, 0.03066345f, 0.03666534f, 0.02154060f, -0.08632818f, 0.02453082f, 0.05769241f, -0.08749301f, 
    -0.06695786f, -0.04828272f, -0.06320527f, -0.06128354f, 0.02022055f, 0.07230295f, -0.01075642f, 0.00698552f, 
    0.03663133f, -0.03663933f, -0.06619812f, -0.06446154f, 0.02193421f, -0.01941013f, -0.06114440f, 0.00243509f, 
    0.03210468f, -0.02973160f, 0.02015175f, 0.04515733f, -0.05910827f, -0.02739855f, 0.01164420f, -0.07894412f, 
    -0.00050267f, 0.02903436f, -0.03316981f, 0.01279735f, -0.02604005f, -0.03733106f, 0.03549793f, 0.03168711f, 
    -0.03011930f, -0.07443764f, 0.03999656f, -0.00977373f, 0.05524453f, -0.07009608f, -0.08830038f, 0.02720898f, 
    -0.06972148f, -0.06324925f, -0.04189827f, 0.01602248f, -0.05691136f, -0.07621781f, 0.02441063f, -0.02646004f, 
    -0.08922613f, 0.02382727f, -0.06851880f, 0.06016559f, 0.05510626f, -0.04064430f, -0.08386017f, -0.01571322f, 
    0.01953896f, -0.04729293f, 0.04625406f, -0.02600117f, -0.03294805f, -0.08611760f, 0.01789669f, -0.00003297f, 
    0.00373778f, -0.00890342f, -0.03196478f, 0.03195507f, -0.07939555f, -0.03078935f, 0.04447756f, -0.08353355f, 
    0.02161555f, -0.00456765f, -0.02564568f, -0.06100474f, 0.05703273f, 0.00933101f, -0.00133022f, -0.03224368f, 
    0.06068587f, -0.06702666f, -0.02355386f, -0.00814303f, -0.03417820f, 0.05798224f, -0.07000215f, -0.05490344f, 
    0.06441542f, -0.06810896f, -0.07793288f, -0.02070272f, -0.00187753f, 0.05099051f, -0.02338484f, -0.08089727f, 
    -0.04502171f, 0.01617490f, -0.05083473f, -0.07836905f, -0.08134178f, -0.08214746f, -0.07810947f, 0.05885958f, 
    -0.04684473f, -0.02474016f, -0.08256124f, -0.00312337f, -0.09662735f, 0.04601396f, -0.07758316f, -0.04701381f, 
    -0.04774190f, -0.01625379f, -0.01464979f, 0.02093066f, -0.01899280f, -0.02762377f, -0.00589501f, -0.07322841f, 
    -0.00988005f, -0.00214861f, -0.04446122f, -0.02782728f, -0.01964481f, -0.06660570f, 0.03449409f, -0.01989404f, 
    -0.08051604f, -0.07967505f, 0.04545835f, 0.04900309f, 0.05368130f, -0.03723457f, -0.01316628f, -0.06822325f, 
    -0.07335593f, 0.02419831f, -0.00373242f, -0.02052035f, -0.01637562f, -0.05906851f, 0.00420468f, 0.00145594f, 
    0.06132472f, -0.05197993f, -0.03503044f, 0.01034612f, -0.03531806f, -0.08093335f, 0.05975323f, 0.02957608f, 
    -0.06063114f, -0.09087582f, -0.00359487f, 0.01178314f, 0.05586703f, -0.05236808f, 0.03712707f, -0.04193597f, 
    -0.02380449f, 0.02567697f, -0.06194825f, 0.04711178f, 0.01918668f, -0.01487752f, -0.00418596f, 0.04264937f, 
    0.06599388f, -0.06249745f, -0.00348617f, 0.06153759f, 0.00963753f, -0.08591510f, 0.05149402f, 0.02924865f, 
    -0.07894032f, 0.00083311f, 0.03463529f, 0.03029024f, 0.00561366f, 0.04219989f, -0.02617471f, -0.03823339f, 
    -0.04052408f, 0.05598170f, -0.01193852f, -0.01688244f, 0.06396081f, 0.01408118f, -0.06994089f, -0.04444659f, 
    0.04653926f, -0.00504972f, 0.02906948f, 0.03435371f, -0.02919854f, 0.04447650f, -0.04667708f, 0.07370319f, 
    0.02669146f, 0.00423440f, -0.04048432f, 0.06528880f, -0.07038351f, 0.05642490f, 0.05563718f, -0.04317326f, 
    -0.05422845f, 0.05992673f, -0.04673150f, -0.01948204f, 0.05019580f, 0.06347752f, -0.07789187f, 0.07103972f, 
    0.05828409f, 0.01332030f, 0.00085602f, 0.07253320f, -0.06029727f, -0.02165795f, -0.06141544f, 0.02222872f, 
    -0.08578064f, 0.05717242f, -0.01142341f, 0.04262199f, -0.02819410f, -0.07847891f, -0.08322380f, -0.00475989f, 
    -0.06180151f, -0.01975880f, 0.01388262f, 0.01932216f, -0.01086299f, -0.01969898f, 0.05991008f, -0.04208439f, 
    -0.01819056f, 0.05441915f, 0.03060426f, -0.05590618f, 0.07081643f, 0.06856430f, 0.04387270f, -0.03410686f, 
    0.06443208f, 0.04906949f, 0.02188525f, -0.05585753f, 0.03770611f, -0.04451549f, -0.05301350f, 0.03030997f, 
    -0.07689355f, -0.07973883f, -0.06886847f, 0.03731662f, 0.06850250f, 0.03957663f, -0.06779510f, 0.01456919f, 
    -0.03735875f, 0.01552607f, -0.07732614f, -0.02555306f, -0.02464956f, -0.05320702f, -0.03196215f, -0.07356352f, 
    -0.00332960f, -0.01219342f, -0.07218729f, -0.08462277f, -0.08969103f, 0.04025156f, -0.01900504f, -0.05859419f, 
    0.07236740f, 0.01065924f, -0.08451770f, -0.02191375f, -0.05331358f, -0.04126858f, 0.03208356f, -0.02422420f, 
    0.01374392f, -0.03151187f, 0.00816421f, -0.01639930f, 0.01511038f, 0.05333995f, 0.07464749f, -0.07110589f, 
    -0.02195079f, -0.00591469f, 0.02480273f, 0.00413707f, -0.07462294f, 0.04902207f, 0.07422411f, -0.09044854f, 
    -0.05347200f, -0.01094653f, -0.00632061f, -0.08778041f, -0.07792425f, -0.06136696f, 0.06554587f, 0.04076429f, 
    0.00718685f, 0.06346576f, 0.06924138f, -0.07962304f, -0.09259941f, 0.05166668f, -0.02844198f, -0.07576723f, 
    -0.00674667f, 0.01124321f, -0.05688535f, -0.00636514f, 0.02156965f, -0.02645080f, -0.05223466f, 0.05293685f, 
    -0.06891429f, 0.00343374f, 0.03986578f, 0.01043711f, -0.06310400f, 0.01569937f, 0.06581806f, 0.04802595f, 
    -0.08881202f, 0.03893497f, 0.05705373f, -0.04397657f, 0.03636719f, -0.05418242f, -0.02854819f, -0.06238289f, 
    0.21721077f, -0.02410898f, 0.22970930f, 0.03020681f, 0.14505135f, 0.27547723f, 0.19572739f, 0.19969426f, 
    0.17414130f, -0.12703685f, -0.17200601f, -0.24338427f, -0.09561359f, -0.07060209f, 0.08501524f, 0.01907790f, 
    0.08192626f, 0.07442383f, -0.00963699f, -0.08986101f, -0.07477144f, -0.11223658f, 0.19402415f, 0.01217769f, 
    0.03790675f, 0.12641196f, 0.46486992f, -0.15098251f, -0.19255981f, 0.05579969f, 0.14091367f, -0.02923282f, 
    0.04849295f, 0.14018185f, 0.05567746f, -0.01609993f, 0.18920612f, 0.09596339f, 0.15931852f, 0.05017706f, 
    -0.10123740f, 0.09471852f, 0.22224528f, 0.06406458f, 0.02681158f, -0.18376552f, -0.14951564f, 0.12121698f, 
    -0.00126036f, -0.07675027f, -0.06467773f, -0.16898316f, -0.25677139f, -0.28488564f, -0.04015425f, 0.12328371f, 
    0.00568236f, -0.16166191f, -0.00772794f, 0.23398624f, 0.03989169f, 0.00399803f, -0.33463573f, -0.07927610f, 
    0.14543493f, -0.08007280f, -0.00609810f, 0.10745902f, -0.11601551f, -0.06848982f, 0.07401671f, -0.03140341f, 
    -0.24924259f, 0.09200726f, 0.00048470f, -0.04488825f, -0.26510218f, -0.00206971f, -0.15238117f, -0.28348252f, 
    -0.13669446f, 0.00534795f, -0.12477611f, -0.06820534f, 0.16005787f, -0.05246142f, -0.00915145f, -0.08308265f, 
    -0.00486868f, -0.17595102f, -0.13630621f, -0.17975660f, -0.09681972f, 0.15330847f, 0.03639877f, -0.02545252f, 
    0.02770363f, -0.02728298f, 0.00796174f, -0.02684875f, -0.01531207f, 0.10968550f, 0.09075335f, 0.01836838f, 
    -0.04440704f, -0.15850589f, 0.11049976f, -0.07997907f, 0.09758665f, 0.25504908f, 0.34101158f, 0.15810920f, 
    0.03500019f, -0.11355294f, -0.07946033f, 0.00982540f, 0.09149686f, -0.09014745f, -0.24477819f, 0.12537493f, 
    0.08661490f, 0.00908604f, 0.05507160f, -0.05140382f, 0.03187976f, -0.06505217f, -0.11389225f, -0.07136338f, 
    -0.11324844f, 0.13933681f, 0.08370110f, 0.12197027f, 0.12923145f, -0.22646606f, -0.07723650f, -0.29946947f, 
    0.07063922f, -0.23932071f, 0.16601051f, -0.09961572f, 0.15679415f, 0.26288077f, 0.35006356f, 0.19380158f, 
    0.31863710f, 0.08308769f, 0.18636343f, 0.14546260f, -0.04164242f, -0.03600758f, 0.12830235f, -0.03025365f, 
    -0.01722657f, -0.17313397f, 0.04429065f, -0.41249231f, 0.17796718f, -0.01575319f, -0.12667976f, -0.08032524f, 
    0.03182385f, -0.12095760f, 0.07336881f, 0.02383661f, 0.11821492f, -0.21818708f, -0.05947888f, 0.04848030f, 
    0.03392060f, -0.00554740f, -0.16131572f, -0.10496868f, -0.39505467f, -0.35665372f, 0.02731075f, -0.09691969f, 
    -0.04739688f, 0.03159957f, -0.02859098f, 0.04787134f, -0.68109608f, -0.32694662f, -0.37981641f, -0.07904288f, 
    -0.14732555f, -0.05490309f, 0.07971468f, 0.06119634f, -0.05074924f, 0.20186432f, -0.08932296f, -0.22196279f, 
    -0.01108261f, -0.10765351f, -0.04041584f, -0.00353622f, -0.01792198f, 0.22385593f, -0.03680322f, 0.30375686f, 
    -0.17987476f, -0.06349942f, -0.09548832f, -0.06600392f, 0.22845702f, -0.10013595f, 0.26264679f, -0.18432650f, 
    0.02161354f, 0.10326430f, 0.06357470f, 0.12514426f, 0.05697494f, -0.08334785f, -0.08096608f, -0.01258773f, 
    0.20122047f, -0.18539274f, 0.09112925f, -0.05444180f, 0.21140304f, -0.02158091f, 0.03234109f, -0.04270102f, 
    0.05167182f, -0.13870315f, 0.06139419f, -0.10356262f, 0.05737628f, 0.08103909f, -0.01286956f, 0.11504276f, 
    -0.12763381f, 0.11457607f, -0.13522682f, 0.00284189f, -0.13087711f, 0.00982280f, 0.03252476f, -0.01272425f, 
    -0.08938715f, -0.02879744f, 0.04607515f, 0.55757308f, 0.19633190f, 0.15811153f, -0.06990471f, 0.10165408f, 
    0.05629367f, -0.01909689f, -0.00565368f, -0.03025152f, -0.27680099f, -0.22121169f, 0.13049029f, -0.18214898f, 
    0.23410985f, 0.07999223f, -0.02885194f, 0.01091769f, 0.17359041f, -0.01242835f, 0.08215141f, -0.24611746f, 
    -0.01798749f, 0.27339676f, 0.01443505f, 0.11855613f, -0.00956835f, 0.07449776f, -0.15753612f, 0.08454640f, 
    0.09871776f, 0.17603523f, 0.07303189f, 0.00633057f, -0.09892386f, -0.07638356f, 0.18578461f, -0.20646845f, 
    -0.34974259f, -0.02459880f, -0.01412591f, -0.21401730f, -0.03737788f, 0.03347388f, -0.01034149f, -0.15508142f, 
    0.13457087f, 0.32051456f, -0.05712613f, -0.17061770f, -0.03601805f, -0.02321054f, 0.01002925f, 0.10639420f, 
    0.01172325f, -0.31059077f, -0.08003490f, -0.23736742f, -0.11940325f, -0.04158847f, -0.21282183f, -0.11180203f, 
    -0.02310714f, -0.14097105f, 0.04505994f, -0.06071532f, 0.03655112f, 0.11719236f, -0.08637089f, 0.04714386f, 
    0.14013360f, 0.26180688f, -0.00847076f, -0.03816628f, -0.05422977f, 0.15768550f, -0.03782689f, -0.11854926f, 
    -0.16753891f, 0.01910006f, 0.01299580f, 0.02527910f, -0.12741825f, 0.00485144f, -0.34393013f, -0.00220114f, 
    -0.09439801f, 0.53923184f, -0.13092798f, -0.19197182f, 0.08046135f, -0.15793878f, 0.16911842f, 0.11843385f, 
    0.02873874f, 0.16436760f, 0.30715495f, -0.01225363f, 0.12587309f, 0.17817014f, -0.08609195f, 0.03849370f, 
    0.20891157f, 0.10530212f, -0.02064245f, -0.03426023f, -0.06186111f, 0.23184775f, -0.05446135f, -0.24049969f, 
    0.33313331f, -0.04934424f, -0.08248734f, -0.05447381f, 0.09297895f, -0.20192496f, 0.12265540f, -0.11140814f, 
    -0.06364116f, -0.07303707f, 0.02055231f, 0.13872211f, -0.10942493f, 0.06260111f, -0.08963931f, -0.10197706f, 
    0.08543778f, -0.13610865f, 0.28586999f, 0.06076493f, 0.11145530f, -0.00261678f, -0.03097596f, -0.03913319f, 
    0.06190814f, 0.12568678f, -0.04291567f, 0.03019980f, -0.21861497f, 0.00341805f, 0.08071168f, -0.09307393f, 
    0.03461825f, 0.06187509f, 0.11080909f, 0.22822955f, 0.25654298f, 0.06384370f, -0.16668385f, 0.05552214f, 
    0.03233253f, -0.07213417f, 0.19900455f, -0.08935646f, -0.22868405f, -0.30964079f, 0.33293152f, -0.01689659f, 
    0.00593617f, -0.05068329f, -0.05723279f, -0.03591171f, -0.09721596f, -0.44549176f, -0.10115662f, 0.19068909f, 
    -0.09474181f, 0.08815447f, -0.15127397f, -0.00828288f, 0.13800788f, 0.09823406f, -0.19261779f, -0.04698464f, 
    -0.19807011f, 0.02061764f, 0.13623014f, -0.07132991f, -0.05575353f, -0.07940652f, -0.05753983f, -0.22934942f, 
    -0.02598430f, -0.11693672f, 0.10222518f, -0.02470209f, -0.12739240f, -0.00905708f, -0.00105496f, 0.07740732f, 
    -0.73002905f, 0.26093009f, 0.09890583f, 0.05118945f, 0.02321975f, -0.06447491f, -0.02655141f, 0.07308515f, 
    0.14564973f, -0.21970151f, 0.19334361f, 0.11661027f, -0.14878494f, -0.19766077f, 0.01024713f, 0.12375295f, 
    -0.01736809f, 0.01912805f, -0.01566211f, 0.25993407f, -0.08613385f, 0.08493617f, -0.04224295f, -0.10000092f, 
    0.07057820f, -0.06401660f, -0.03312257f, -0.25181529f, 0.34306261f, 0.22725129f, -0.08575489f, 0.16446190f, 
    -0.01944680f, 0.13476878f, 0.04032771f, -0.01609943f, -0.42963040f, -0.07070217f, -0.60102367f, 0.08567107f, 
    0.34773847f, 0.14945203f, 0.04269541f, 0.10812566f, -0.17933895f, -0.25571799f, -0.33658570f, -0.03114389f, 
    -0.10970415f, 0.12002502f, 0.13377479f, 0.00278763f, -0.04793728f, 0.01937466f, -0.27386424f, -0.18960141f, 
    0.28470290f, -0.09792306f, -0.37157300f, 0.08273876f, 0.04279085f, 0.00475658f, -0.08875878f, 0.02507059f, 
    -0.14495525f, 0.34995705f, 0.05408493f, -0.04316051f, -0.02371395f, 0.20920162f, -0.08326627f, 0.07164105f, 
    -0.21219911f, -0.11250366f, -0.27305463f, 0.12437404f, -0.42882648f, -0.00732153f, -0.00709704f, -0.07962721f, 
    0.10927338f, 0.09505606f, -0.05485622f, 0.28053439f, -0.04958931f, 0.17373440f, -0.13979089f, -0.05324268f, 
    0.02778691f, 0.05823122f, -0.17378038f, 0.04138817f, -0.02959923f, -0.07225657f, -0.06028407f, 0.03621844f, 
    0.14185838f, -0.02363573f, 0.18227226f, 0.12433159f, 0.01096384f, -0.27988464f, 0.01820980f, 0.04182690f, 
    0.08249679f, 0.05962617f, 0.00744106f, 0.05961717f, 0.03844548f, -0.09798748f, 0.08619518f, 0.04224680f, 
    0.10417105f, -0.13268150f, -0.14548072f, 0.09174949f, -0.00676758f, -0.62568611f, 0.01937580f, -0.17832729f, 
    -0.05505474f, 0.00895078f, -0.21427952f, -0.07637483f, -0.02679180f, 0.00133409f, -0.04290627f, 0.40753222f, 
    0.04808452f, -0.00558447f, -0.05294909f, -0.10202941f, -0.03266590f, 0.05059092f, -0.11566106f, 0.06422502f, 
    0.45583385f, 0.03158109f, -0.00023558f, 0.12312081f, -0.17884691f, 0.04943462f, -0.00853751f, -0.09077564f, 
    0.13912983f, -0.15528861f, -0.33066484f, -0.00056510f, 0.11999089f, -0.03124196f, -0.03586360f, -0.01582332f, 
    0.00022530f, 0.28048378f, 0.28194594f, 0.07865372f, -0.21580474f, 0.13061264f, -0.13598229f, -0.02536371f, 
    -0.06033769f, -0.05887815f, -0.00816082f, -0.08820119f, 0.02400034f, -0.01293375f, -0.11076917f, -0.22758806f, 
    0.10476848f, 0.06947801f, 0.02899565f, 0.00117495f, 0.00969293f, 0.27030510f, -0.04880266f, 0.13767034f, 
    -0.07669046f, 0.01907339f, 0.07047146f, 0.04287362f, 0.32707375f, -0.55647701f, -0.33646312f, 0.00970801f, 
    0.05469871f, -0.02896411f, 0.06231589f, 0.08963493f, -0.09216065f, -0.15990083f, -0.08812604f, 0.10946418f, 
    -0.02853415f, -0.05740959f, 0.00092704f, -0.07638615f, 0.11978322f, 0.20643508f, -0.12691057f, -0.14784020f, 
    -0.28768638f, -0.22757576f, 0.15876605f, -0.21468057f, 0.20072892f, 0.17041408f, 0.08266407f, 0.02291870f, 
    0.36924085f, 0.32343772f, 0.03338766f, -0.11148982f, -0.09035567f, -0.06461848f, -0.03283190f, 0.15874358f, 
    -0.16317157f, 0.06672738f, 0.13936307f, -0.06907500f, -0.01639957f, 0.08290092f, -0.05652798f, 0.01618019f, 
    -0.03457348f, -0.13229039f, 0.13729101f, 0.17078380f, 0.08796317f, 0.07800204f, 0.00698167f, 0.23886074f, 
    0.16728352f, 0.25162834f, 0.28315327f, 0.11494973f, 0.21441773f, -0.25357339f, -0.12751055f, 0.02431033f, 
    0.11260719f, 0.08813696f, 0.11732926f, -0.05007046f, -0.10774161f, 0.01960858f, 0.10658555f, 0.16016170f, 
    -0.09725497f, 0.08239500f, -0.04315131f, 0.05359063f, -0.22390167f, 0.38056490f, 0.21532038f, 0.08176740f, 
    -0.12850544f, -0.11061513f, 0.10153535f, 0.14048040f, 0.15981916f, -0.29330376f, 0.01465450f, 0.16606259f, 
    0.06470334f, -0.24389245f, 0.15757103f, 0.10868799f, -0.06400450f, -0.13079987f, 0.48941496f, 0.11633024f, 
    0.05005881f, -0.34519684f, -0.06153395f, -0.13946438f, 0.05180646f, 0.06018351f, 0.15046158f, 0.27716357f, 
    0.19010253f, 0.22688875f, -0.27292883f, -0.22608884f, -0.30823117f, 0.08550694f, -0.17566168f, -0.05012258f, 
    0.15151663f, -0.05600063f, -0.13556167f, 0.01348004f, 0.17186214f, 0.00348118f, 0.16472149f, 0.07901390f, 
    0.26443243f, -0.10118272f, -0.08169805f, 0.02149610f, 0.19996926f, -0.18550843f, 0.10478763f, 0.19866620f, 
    -0.06578143f, -0.03148163f, 0.11546091f, 0.07501806f, -0.00451164f, -0.09623411f, -0.03278224f, -0.10109010f, 
    0.12245166f, 0.28109005f, 0.18964204f, 0.05963801f, 0.08895952f, -0.00772454f, 0.07573643f, 0.10072883f, 
    0.20012905f, -0.17004940f, -0.16647118f, 0.14877445f, 0.12247973f, 0.02572652f, 0.32831320f, -0.02210395f, 
    -0.30188301f, 0.04986060f, 0.22003567f, 0.02655807f, 0.13213143f, 0.43800297f, 0.23623525f, -0.04651434f, 
    -0.05663936f, 0.11894504f, 0.05916610f, -0.09930138f, -0.05843452f, -0.24080025f, -0.27061409f, -0.19586854f, 
    -0.45585373f, 0.19478711f, -0.04470462f, 0.12231497f, -0.03433795f, 0.08361623f, 0.06643276f, 0.09244739f, 
    -0.05179689f, 0.09911083f, -0.10860491f, 0.03004971f, -0.04968084f, 0.03392354f, 0.15095910f, 0.04912077f, 
    0.38210511f, 0.01082007f, -0.00098787f, 0.10139685f, -0.05124838f, -0.15078956f, -0.03017171f, 0.10587348f, 
    -0.22890311f, -0.15634906f, 0.02224167f, 0.08834732f, -0.07266087f, 0.06714030f, 0.02419206f, -0.06323406f, 
    -0.18371381f, -0.06496006f, 0.05384518f, -0.16337228f, -0.06553064f, 0.07377008f, 0.15247551f, 0.06181810f, 
    -0.23516454f, 0.14033183f, -0.04698021f, -0.55909038f, -0.34400356f, -0.13870873f, 0.06117095f, 0.09744366f, 
    0.11878929f, 0.03497883f, 0.03875360f, 0.07568093f, 0.08237648f, -0.08713225f, 0.04933860f, -0.05320785f, 
    0.09271370f, 0.16792117f, -0.08237147f, -0.00986649f, 0.00031677f, -0.06453457f, 0.27119556f, 0.15377286f, 
    0.01641523f, 0.03410887f, 0.00920395f, -0.00115140f, 0.12308209f, 0.19089456f, -0.10450464f, -0.13852842f, 
    0.07417575f, 0.06293008f, 0.07439340f, -0.01713570f, -0.04175781f, 0.02429254f, -0.21613993f, -0.13121375f, 
    0.00892815f, 0.26410511f, -0.08609404f, -0.12046956f, -0.01684893f, 0.10772556f, 0.07000949f, 0.14560552f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06018696f, 0.12208322f, 0.05654430f, 0.29549164f, -0.08812201f, 0.18505526f, -0.14320998f, -0.08398041f, 
    0.01844609f, 0.06298671f, 0.23328386f, 0.13565421f, 0.27668273f, 0.26787418f, 0.22456490f, 0.06020603f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23094742f, -0.25092784f, -0.34109715f, -0.04524905f, 0.01390929f, 0.05016308f, 0.20612445f, -0.24523801f, 
    -0.17614801f, 0.16968980f, 0.25452054f, 0.22853240f, -0.07398904f, 0.17089279f, -0.11632139f, 0.25887486f, 
    0.06027035f, 0.45470327f, 0.22856033f, -0.03782171f, -0.18576853f, -0.49502900f, 0.12221344f, 0.13691352f, 
    0.20907097f, 0.12356263f, -0.03140736f, -0.01250288f, 0.04500859f, 0.33590391f, 0.19237828f, 0.01454583f, 
    -0.06909183f, -0.25661349f, -0.14898348f, -0.43599266f, 0.07121864f, 0.35866117f, 0.01520302f, 0.06737265f, 
    0.21756992f, -0.19983083f, -0.20492233f, -0.42254555f, -0.26760942f, 0.35533661f, 0.32689565f, 0.17337492f, 
    0.15374686f, -0.21986556f, -0.04894460f, 0.14643426f, -0.11077692f, 0.12341888f, -0.11526595f, -0.23811071f, 
    -0.19467551f, -0.07413904f, 0.16477063f, 0.39430779f, 0.24426126f, -0.07664623f, 0.09785579f, -0.06652480f, 
    -0.19962123f, -0.32477731f, -0.33171481f, -0.16313250f, -0.01802030f, -0.03805502f, -0.18140121f, -0.06606787f, 
    0.10103612f, -0.08126774f, 0.19269997f, -0.29155612f, 0.06280714f, 0.22130193f, 0.42250362f, 0.13085522f, 
    -0.04583156f, 0.39440909f, 0.05200507f, 0.08402254f, -0.08435693f, -0.16054860f, 0.23603016f, -0.01101139f, 
    -0.22740471f, -0.10773736f, -0.34472296f, -0.16431077f, -0.36611891f, 0.27522841f, 0.29539344f, -0.11585356f, 
    0.16135122f, -0.05271304f, -0.63709426f, 0.66941893f, 0.10965137f, -0.13118553f, 0.12986486f, 0.08839330f, 
    0.18521021f, -0.20305736f, -0.23235655f, 0.25963601f, 0.26153401f, 0.09155536f, -0.00881423f, 0.30167821f, 
    0.12762380f, -0.57359618f, 0.06458542f, -0.25197640f, -0.21404052f, -0.27396965f, 0.13758898f, -0.11651656f, 
    -0.19573137f, -0.13758051f, -0.13333552f, 0.13032451f, -0.36082491f, 0.12822600f, 0.11823172f, -0.01635605f, 
    -0.15036324f, 0.02472179f, 0.35734549f, -0.12214759f, -0.09831365f, 0.02045028f, -0.08557525f, 0.05166791f, 
    0.18786812f, -0.13451201f, -0.28077191f, -0.19515932f, 0.30296659f, 0.32796815f, 0.37018856f, -0.19633573f, 
    0.18060540f, -0.32527182f, 0.07097486f, -0.16903943f, -0.07640037f, 0.11560711f, -0.01720476f, 0.03768057f, 
    -0.24009091f, -0.16522339f, 0.09246655f, -0.22134204f, -0.46209425f, 0.23076324f, 0.33785027f, 0.10477858f, 
    0.15588267f, -0.10996918f, -0.10667887f, -0.24460021f, -0.17687701f, -0.18871972f, -0.03273865f, 0.11156235f, 
    -0.00817554f, -0.21429279f, -0.07746145f, -0.03351467f, 0.20563725f, -0.18015952f, 0.08508249f, -0.07690404f, 
    -0.05588822f, -0.22843352f, 0.13923281f, -0.41786772f, -0.11887791f, 0.10909565f, -0.25127295f, 0.07695124f, 
    -0.07926007f, -0.10421386f, 0.23241903f, 0.29952160f, 0.32706654f, -0.05462663f, 0.22030172f, -0.22448781f, 
    -0.11388152f, 0.01683723f, -0.47062650f, -0.46304426f, 0.14008254f, 0.33845913f, -0.17219874f, 0.22770695f, 
    -0.10957053f, -0.19150643f, 0.25101784f, -0.73509067f, -0.19591169f, 0.08453378f, 0.20224902f, 0.19015642f, 
    0.23437849f, -0.25349614f, -0.22392224f, 0.39916721f, 0.08312702f, 0.06506989f, 0.23960093f, 0.20113599f, 
    -0.17819992f, 0.03508824f, -0.27674827f, -0.14503105f, -0.00408180f, -0.20911518f, -0.03015162f, 0.30636159f, 
    0.05571770f, 0.08563427f, -0.06592551f, -0.39816260f, 0.16582653f, 0.32579681f, -0.49374777f, 0.23469540f, 
    0.12733011f, 0.08618769f, 0.14814688f, 0.11565986f, -0.26680395f, 0.17428163f, 0.41203040f, -0.17978927f, 
    -0.20018277f, 0.21380687f, -0.25798321f, 0.59544170f, 0.01848409f, 0.25600049f, 0.36073896f, -0.13981473f, 
    0.12559947f, -0.08800843f, 0.25857773f, -0.11098509f, -0.33916786f, -0.07748496f, 0.19167307f, -0.27001840f, 
    -0.18456766f, 0.22173792f, 0.10285612f, 0.38496378f, -0.21370934f, -0.09692521f, -0.34209991f, -0.04284936f, 
    0.05016360f, 0.10936031f, 0.02806961f, 0.39848739f, -0.00504533f, 0.25000733f, -0.27638254f, -0.10051853f, 
    -0.17949787f, 0.30726808f, -0.09406573f, 0.07751637f, 0.16648167f, -0.00851593f, 0.16784623f, -0.16844591f, 
    -0.07321638f, 0.18395257f, -0.09287273f, -0.44941875f, -0.29978976f, 0.29782370f, 0.24978894f, 0.20771508f, 
    -0.04836799f, -0.27535376f, -0.50711048f, 0.15430862f, 0.17914625f, -0.00781700f, -0.12269201f, -0.00878556f, 
    -0.17838764f, -0.14547034f, 0.20841572f, 0.40648386f, 0.57239664f, 0.21431175f, 0.26906541f, 0.04485543f, 
    -0.04040453f, 0.01801940f, -0.13637850f, -0.22189103f, -0.13261130f, 0.11545761f, -0.20644517f, 0.10703558f, 
    -0.22448856f, -0.21013306f, -0.08666290f, 0.43210867f, 0.47407174f, 0.48118541f, 0.30215508f, -0.36059877f, 
    0.24592914f, -0.08042006f, -0.05661264f, 0.18428580f, 0.10560344f, -0.20759106f, 0.29153192f, 0.13365355f, 
    0.19279645f, -0.08643806f, -0.17117822f, -0.14849156f, -0.14158659f, 0.54248333f, 0.10132802f, 0.22319435f, 
    -0.20050184f, -0.07250812f, -0.05025675f, -0.09040123f, 0.16992174f, -0.22103633f, -0.01539187f, 0.05908138f, 
    0.02234476f, 0.05818805f, 0.07278211f, 0.16799441f, -0.00002326f, 0.03419451f, -0.11366411f, -0.06688317f, 
    0.10335565f, 0.14997979f, -0.42030051f, 0.17413564f, -0.18667603f, 0.24290584f, 0.17683077f, 0.04283955f, 
    -0.11161076f, 0.00529156f, 0.31787992f, 0.05771042f, 0.27664542f, 0.47799489f, -0.14426598f, 0.17452388f, 
    -0.12965553f, -0.20601097f, -0.02915840f, 0.06950852f, 0.16661125f, 0.22143286f, -0.22028063f, 0.07491994f, 
    -0.11576426f, 0.05657152f, -0.28322247f, 0.53800219f, 0.53291422f, 0.00838069f, -0.13463879f, -0.18264833f, 
    -0.02560981f, 0.46885058f, -0.19596860f, -0.38311774f, 0.14995816f, -0.32380006f, 0.29414141f, 0.15794742f, 
    -0.22218168f, -0.08797672f, -0.06931033f, -0.94152468f, -0.05601600f, -0.41647246f, 0.11935964f, 0.17093232f, 
    -0.17591721f, 0.12126867f, -0.50389946f, 0.11289567f, -0.01147084f, 0.28518558f, 0.25525635f, 0.11508591f, 
    0.21784882f, 0.20554407f, 0.23347281f, 0.10290980f, 0.36067817f, 0.32424909f, -0.35675976f, 0.08249413f, 
    -0.03711137f, 0.18360987f, -0.12760575f, -0.02306411f, -0.06068243f, 0.20956326f, 0.12798509f, -0.12431511f, 
    -0.24213733f, -0.00274629f, 0.24123229f, 0.18280150f, 0.40555063f, 0.28736845f, -0.29339898f, -0.05552807f, 
    -0.21988630f, -0.13424766f, 0.29732880f, 0.14730562f, -0.14131156f, -0.04964452f, -0.05964913f, 0.02310613f, 
    0.07043388f, -0.24775302f, -0.16803299f, -0.14367187f, -0.33836609f, 0.39383104f, 0.25063938f, 0.13375333f, 
    0.17735891f, 0.50332266f, -0.11341204f, 0.30142292f, 0.11327299f, 0.29821271f, 0.11452010f, -0.14016217f, 
    -0.07978366f, -0.11246656f, 0.12597609f, 0.27830756f, -0.18955995f, -0.41689420f, -0.02094352f, -0.22010028f, 
    -0.19182697f, 0.31769109f, 0.17471537f, 0.35862303f, -0.20053546f, -0.28715456f, -0.27629668f, -0.22839782f, 
    -0.21925378f, -0.14409733f, 0.03161052f, 0.10871676f, -0.30328295f, -0.60217768f, 0.18214209f, 0.17291181f, 
    -0.01548463f, -0.13891663f, -0.36243698f, 0.26114261f, -0.15262163f, -0.13935582f, 0.16829835f, -0.13157389f, 
    0.12948143f, -0.15361381f, 0.30729198f, 0.07210847f, 0.16885518f, -0.54841399f, 0.14966622f, 0.17339635f, 
    -0.16441864f, -0.43359494f, -0.02970134f, 0.32207200f, -0.21224189f, 0.38111308f, 0.40997785f, -0.12981471f, 
    0.19236699f, 0.07176679f, -0.24829255f, -0.18481900f, 0.03666518f, -0.36410004f, -0.00712920f, -0.21891733f, 
    -0.21478318f, 0.22956148f, -0.58498383f, 0.44459125f, -0.03244719f, 0.09902480f, 0.08095922f, -0.22195545f, 
    0.08723745f, -0.02368847f, -0.50300831f, 0.27896711f, -0.07263885f, 0.21817279f, 0.40814975f, -0.14703366f, 
    0.15973760f, 0.18555500f, 0.34542695f, 0.11832079f, 0.00782375f, -0.13708936f, 0.19325620f, 0.15315261f, 
    0.04256632f, -0.20985632f, -0.34481660f, -0.52382034f, -0.18445598f, 0.22761641f, 0.11842114f, 0.21497773f, 
    0.10062632f, 0.01149314f, 0.19860153f, -0.03494094f, -0.05595139f, 0.03998653f, 0.06949181f, -0.03907287f, 
    -0.07635799f, 0.24673572f, -0.08531493f, 0.18869369f, -0.04643201f, -0.73378348f, -0.48640543f, -0.11157072f, 
    0.17657107f, 0.39213645f, -0.30543002f, -0.39312127f, -0.03063798f, 0.27890664f, 0.09818010f, 0.15830973f, 
    -0.23134917f, -0.17134726f, 0.40745512f, -0.57583880f, -0.20061710f, -0.40771538f, 0.20159426f, 0.31409705f, 
    -0.21408609f, -0.17390472f, 0.17535956f, -0.37673384f, -0.11462265f, 0.22130238f, -0.26910707f, -0.10667917f, 
    -0.24569079f, -0.21619406f, 0.07457184f, 0.10071197f, -0.20488721f, 0.04498507f, 0.38246763f, -0.08572491f, 
    0.21859631f, -0.01804950f, -0.37622958f, 0.15366104f, -0.00731698f, -0.16227528f, 0.02406815f, -0.19856754f, 
    0.15646675f, -0.17690751f, -0.23759218f, -0.31579021f, 0.35914993f, 0.13983881f, -0.12920672f, 0.32166892f, 
    -0.07668905f, -0.04063259f, -0.00090368f, -0.24957280f, -0.12045802f, 0.20817536f, -0.34350562f, -0.15421771f, 
    -0.24113414f, 0.20508182f, 0.15945318f, -0.48579592f, 0.00899392f, -0.10461161f, 0.15426241f, 0.33721766f, 
    -0.07147063f, 0.31755549f, 0.01986380f, 0.01900855f, -0.01113239f, 0.02890921f, 0.26764438f, 0.13719165f, 
    -0.01144280f, 0.04621907f, 0.24259755f, 0.30835253f, 0.34715331f, 0.39142379f, -0.45416334f, 0.19626121f, 
    0.03508162f, 0.30765858f, 0.15204467f, 0.15673706f, -0.17674650f, 0.23279771f, -0.35573661f, 0.01268951f, 
    0.22789171f, -0.02276631f, 0.22442865f, -0.17311722f, -0.03768601f, -0.53321671f, 0.21770456f, 0.06860287f, 
    -0.04804899f, 0.13651635f, -0.62581182f, -0.26125991f, 0.10500211f, 0.30290684f, 0.05341274f, -0.11550534f, 
    -0.04588528f, -0.20267653f, -0.16371340f, -0.72000289f, 0.32800302f, -0.70045805f, 0.25774133f, 0.25488535f, 
    0.01001017f, 0.31564179f, 0.31320274f, 0.19611523f, 0.01130318f, 0.12884919f, 0.32621369f, 0.11679667f, 
    0.11220124f, -0.15210652f, 0.17782789f, -0.00439105f, -0.13767317f, 0.37454799f, -0.20874651f, -0.11951488f, 
    0.13925672f, -0.26650670f, -0.42662397f, -0.13889498f, -0.04597424f, 0.21584243f, 0.26648158f, 0.00466991f, 
    -0.02779986f, -0.16098756f, 0.14746916f, 0.29819885f, 0.06393924f, 0.38008398f, 0.03347785f, 0.10779214f, 
    -0.18138279f, -0.09873854f, -0.18564151f, -0.22971676f, -0.20067714f, 0.35426512f, -0.45979550f, -0.05072677f, 
    -0.00578643f, -0.06954116f, -0.20124705f, -0.14185514f, 0.21332221f, -0.26390576f, 0.52482414f, 0.04415659f, 
    -0.09864802f, 0.44150552f, -0.08123581f, 0.46908817f, 0.10693422f, -0.22718821f, 0.09039484f, 0.16477346f, 
    0.03340242f, -0.12838556f, -0.28013456f, 0.01024259f, 0.20312217f, 0.23945226f, 0.07622195f, 0.01676434f, 
    0.17449489f, 0.33808437f, -0.14175588f, 0.20221896f, 0.21488351f, 0.05103779f, -0.13968527f, -0.21844345f, 
    0.03512549f, -0.23426995f, 0.18203676f, 0.36801088f, 0.03681659f, 0.33877462f, -0.08917762f, -0.05028485f, 
    0.08779245f, 0.45001736f, -0.05382713f, 0.34499297f, 0.11408003f, 0.01245635f, 0.19882296f, -0.04173297f, 
    0.16012733f, -0.11444888f, -0.18883775f, -0.34693518f, -0.12615694f, 0.41419932f, 0.07017310f, 0.07512067f, 
    -0.09892321f, -0.20074059f, 0.03493458f, -0.20316632f, 0.19089358f, 0.45212933f, -0.02177979f, 0.08976234f, 
    0.23442928f, 0.17037013f, -0.17469656f, 0.07412710f, -0.18336865f, 0.09647460f, 0.37973592f, -0.18152061f, 
    0.25201210f, 0.18255097f, 0.08906544f, 0.60219228f, -0.18311375f, -0.36595318f, 0.04325756f, 0.17013076f, 
    -0.01872152f, 0.00637887f, -0.47253528f, -0.30299431f, -0.59212959f, -0.42418885f, -0.02140175f, 0.29749295f, 
    0.20305537f, -0.10528221f, -0.24823420f, -0.04757759f, 0.21823061f, -0.29234421f, 0.03329572f, -0.21729293f, 
    0.06609144f, -0.09598869f, -0.04791813f, -0.61276740f, 0.27375725f, -0.01872494f, 0.43223205f, 0.34318799f, 
    0.21081068f, 0.39577019f, 0.27110690f, -0.08341938f, 0.03940414f, 0.16846557f, -0.20636317f, 0.16839892f, 
    -0.19906053f, -0.17473270f, 0.19981568f, -0.21013710f, -0.07302552f, -0.22476770f, -0.17399037f, 0.20269231f, 
    -0.19319774f, 0.25936472f, -0.31489483f, -0.21966054f, -0.02106950f, 0.23200904f, -0.00866333f, -0.14067221f, 
    -0.19364463f, -0.05871736f, -0.25873604f, 0.42417881f, 0.60618740f, 0.31738210f, 0.33589426f, 0.05673986f, 
    0.18205109f, -0.22696182f, -0.11296942f, -0.32242197f, -0.19541140f, 0.47562435f, -0.20335773f, -0.14190400f, 
    -0.03996193f, -0.18030657f, 0.01194564f, 0.37568903f, 0.38081947f, 0.12794960f, 0.07009551f, 0.11545428f, 
    0.19845772f, -0.45135826f, 0.24079008f, 0.08307119f, 0.11064629f, -0.20749938f, 0.32938337f, 0.09020945f, 
    -0.24642649f, -0.00393716f, -0.02752924f, -0.37182394f, -0.44519463f, 0.45474407f, 0.28212196f, 0.32590371f, 
    -0.09283365f, -0.00457481f, -0.23966840f, -0.01941996f, 0.09359476f, 0.49069598f, -0.23375703f, -0.12826586f, 
    0.17792195f, -0.20216024f, -0.00062308f, -0.01147611f, -0.01982597f, 0.11622588f, 0.33380646f, -0.16452889f, 
    -0.11973908f, 0.40424442f, -0.25202593f, 0.26681095f, -0.12181401f, 0.06204999f, -0.22781660f, -0.07486235f, 
    -0.19164848f, -0.17495707f, 0.31372741f, 0.22907875f, 0.23181722f, -0.40584177f, 0.06556436f, 0.03033899f, 
    -0.24656187f, 0.06645866f, -0.07949477f, 0.48292443f, 0.01653226f, 0.43118179f, 0.27097592f, 0.04860109f, 
    -0.12983139f, 0.15870351f, 0.15125817f, 0.16309880f, -0.14861707f, -0.28818351f, -0.23291948f, 0.04944771f, 
    0.17866836f, 0.45528385f, -0.39573383f, -0.02372154f, 0.10678338f, -0.13715547f, -0.01326688f, -0.07601731f, 
    -0.10922295f, -0.22841237f, 0.29577297f, -0.32584581f, 0.22578606f, 0.25581935f, -0.10613582f, 0.36617172f, 
    -0.11247168f, 0.31269437f, 0.15372473f, 0.39350793f, -0.00778469f, -0.05453484f, 0.13257179f, 0.04411152f, 
    0.21712731f, 0.03810784f, -0.05488637f, -0.21221413f, -0.45091239f, 0.41309789f, 0.21420032f, -0.11534019f, 
    0.23295268f, 0.17382252f, -0.11300978f, 0.32679167f, 0.06676861f, -0.27203104f, -0.13979560f, 0.04337265f, 
    -0.02549980f, 0.21844818f, 0.36109042f, -0.09716226f, -0.19363755f, -0.49039784f, 0.03735871f, 0.16528448f, 
    -0.15845580f, 0.42408702f, 0.10949870f, -0.37723771f, 0.17348348f, -0.09166998f, 0.02597628f, -0.03430545f, 
    -0.15991661f, 0.22781058f, 0.13432737f, -0.09591284f, 0.28324366f, 0.01394323f, 0.21502411f, -0.40007827f, 
    -0.07372731f, -0.09694847f, 0.29245171f, -0.23032665f, -0.09896193f, -0.10507732f, -0.21110670f, -0.16008627f, 
    -0.16126220f, 0.20109908f, 0.11550352f, 0.19263454f, -0.02027579f, -0.31324914f, 0.32036373f, -0.08473816f, 
    -0.11772655f, 0.18526939f, 0.32344604f, 0.49355203f, -0.04649884f, -0.08467744f, -0.08662081f, 0.21811423f, 
    -0.20131141f, -0.23446926f, -0.37868360f, -0.40675533f, -0.50850445f, -0.43958771f, 0.01062255f, 0.37552971f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.54004037f, -0.50881255f, 0.40620035f, 0.34834841f, 0.62843001f, 0.11873624f, -0.13679735f, -0.28366679f, 
    0.12902911f, -0.10452762f, -0.22022025f, 0.12517439f, 0.48962456f, -0.23897022f, 0.04077948f, -0.46811530f, 
    0.68756807f, -0.00244887f, 0.52544910f, 0.08531737f, 0.01588945f, -0.19065410f, 0.08907367f, -0.16185051f, 
    0.18401952f, 0.38507539f, 0.48319212f, -0.31964692f, -0.01465753f, 0.23405159f, -0.01977781f, -0.29223904f, 
    -0.38401154f, -0.33208305f, 0.11848443f, -0.12733431f, 0.16187289f, -0.03743823f, 0.55119365f, -0.26762307f, 
    -0.15789331f, 0.06265040f, -0.17444250f, -0.05038022f, 0.30836412f, 0.15560924f, 0.00853229f, -0.02081611f, 
    0.49108753f, 0.10987283f, 0.11181838f, -0.14389265f, 0.25328124f, 0.58606684f, -0.25278714f, -0.06608248f, 
    -0.22549814f, -0.10880020f, 0.16154447f, -0.18029596f, 0.27815184f, -0.32462606f, 0.29947466f, 0.22729976f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.25837788f, 0.16083574f, -0.10723494f, -0.19473468f, 0.01411580f, 0.31254593f, -0.07833805f, 0.06274739f, 
    -0.01406661f, -0.01982876f, 0.01756515f, -0.02084715f, 0.37513509f, 0.30878565f, 0.20998032f, 0.02534381f, 
    -0.12996028f, 0.33069661f, -0.17726749f, -0.22617549f, -0.00551758f, 0.06330843f, -0.21876229f, 0.38135177f, 
    0.79304504f, -0.14381194f, -0.23791304f, -0.08248143f, 0.19592844f, 0.34889004f, 0.03160092f, -0.17090598f, 
    -0.06090672f, 0.06886543f, 0.13298875f, 0.40312621f, -0.14671381f, 0.29029858f, 0.10787706f, -0.09521451f, 
    0.32082039f, 0.46351045f, -0.21374746f, -0.24858475f, 0.09422848f, 0.28117153f, -0.10881527f, 0.21192814f, 
    -0.40305316f, 0.33399472f, 0.35129631f, 0.31381762f, -0.00446567f, -0.36519533f, -0.24936342f, -0.05185429f, 
    0.16041590f, -0.12404060f, 0.31459948f, 0.04040831f, 0.23226695f, 0.33877021f, 0.14727089f, 0.52970433f, 
    -0.64575559f, 0.32057574f, -0.09104776f, -0.32752779f, -0.10505697f, 0.34600368f, 0.30965766f, 0.11988035f, 
    0.18566093f, -0.21268910f, -0.06785153f, -0.47963917f, -0.09197926f, 0.16469686f, 0.11479967f, -0.16169310f, 
    0.23483017f, 0.12240630f, -0.28345540f, 0.10320160f, -0.10302568f, -0.07710581f, -0.27181780f, 0.23995647f, 
    0.25633907f, -0.49174774f, -0.39661583f, 0.48286170f, 0.14037521f, 0.33077088f, -0.46265286f, 0.28263956f, 
    0.70717263f, 0.27268937f, -0.35872024f, 0.16449532f, 0.02296265f, 0.18533035f, 0.03836537f, -0.26584309f, 
    0.22280371f, 0.19149913f, -0.35478851f, -0.39414477f, 0.27340844f, 0.23939978f, 0.07680020f, 0.25218490f, 
    -0.24570155f, 0.59598219f, 0.10459582f, 0.20702848f, -0.06206817f, -0.49159464f, -0.41900152f, 0.20166464f, 
    0.17639597f, -0.51294869f, 0.13761079f, 0.17620035f, 0.00724002f, 0.28329360f, 0.08204273f, 0.44987336f, 
    0.05949979f, -0.09969123f, -0.57673377f, 0.19481130f, -0.06707469f, -0.12728775f, 0.51374483f, -0.32519472f, 
    -0.24740337f, -0.39382061f, 0.05053742f, -0.12455264f, 0.00755741f, 0.25309625f, -0.10398405f, 0.55154371f, 
    0.07679611f, 0.04404142f, 0.12074747f, -0.02148744f, -0.09767778f, 0.00134150f, 0.26222387f, 0.06131525f, 
    -0.02975309f, 0.17072193f, 0.27886248f, -0.26118961f, 0.42105344f, 0.18008256f, 0.23550145f, 0.15327828f, 
    0.28596520f, -0.20343901f, -0.39430273f, 0.09068388f, -0.42116779f, 0.07249335f, -0.06353012f, 0.10113689f, 
    0.22793195f, -0.00868934f, 0.12054993f, -0.07145894f, -0.24471742f, 0.16121992f, 0.24910727f, -0.06689735f, 
    -0.23310485f, -0.68693316f, 0.02541358f, -0.01521419f, 0.11120358f, -0.10707034f, -0.29895303f, 0.02272441f, 
    0.40052927f, 0.17251833f, 0.14738457f, 0.05971640f, 0.22143376f, 0.20965907f, -0.04978796f, -0.21176721f, 
    -0.09029993f, -0.13319352f, -0.06655698f, -0.04244395f, 0.02311048f, -0.03162769f, 0.03815307f, -0.00016242f, 
    0.08635019f, -0.00231082f, 0.02520861f, 0.08321460f, -0.12182126f, 0.08938702f, 0.11369301f, -0.09632369f, 
    -0.05222078f, 0.09373471f, -0.03683800f, -0.14336410f, 0.06493143f, 0.09021000f, -0.09867193f, 0.11627748f, 
    0.10556663f, -0.06963592f, -0.05602663f, -0.16136728f, 0.00253535f, -0.08676219f, -0.03584439f, -0.08267720f, 
    -0.04992711f, 0.07024997f, -0.02555380f, 0.01959140f, -0.09802359f, -0.06879289f, -0.13327698f, -0.00712020f, 
    0.08480825f, 0.10374247f, -0.01930598f, 0.04145692f, -0.11039397f, 0.00766731f, 0.03177402f, 0.04956941f, 
    0.07911947f, -0.06631516f, -0.04413603f, -0.11400615f, -0.08601815f, 0.02286955f, 0.02366144f, -0.06755561f, 
    -0.05949296f, -0.02425766f, 0.07885071f, -0.04080599f, 0.06242412f, -0.06944094f, -0.00579529f, 0.04133953f, 
    0.05448721f, 0.04593861f, 0.09545706f, -0.12158505f, -0.14579597f, -0.09274325f, -0.10932319f, -0.10871094f, 
    0.05807006f, -0.00173649f, 0.07854899f, 0.03174784f, 0.03217411f, -0.09463768f, 0.07419580f, -0.00013294f, 
    0.07394664f, -0.02876856f, 0.05181593f, 0.02152294f, 0.04169927f, -0.05493444f, 0.03980134f, 0.02955920f, 
    -0.05227700f, -0.14887519f, -0.14473979f, -0.03160968f, -0.05056236f, -0.06538192f, -0.16200642f, -0.10079813f, 
    0.06478884f, -0.08938632f, -0.05333563f, -0.00183170f, 0.01694481f, 0.00948335f, 0.10429841f, -0.05556401f, 
    -0.04094691f, -0.02569735f, 0.05784092f, -0.14915505f, 0.07606286f, 0.07028400f, 0.04742524f, -0.15941222f, 
    -0.07167076f, -0.10255569f, -0.06602965f, -0.02432870f, -0.15220881f, 0.01390480f, 0.01289387f, -0.10920921f, 
    -0.09509835f, -0.16021040f, -0.10405737f, 0.06091982f, 0.03145810f, 0.04685513f, -0.07674629f, -0.04401169f, 
    0.04859493f, 0.09600007f, -0.48740652f, -0.00115509f, -0.31289041f, 0.14976533f, 0.67753804f, 0.24165289f, 
    -0.10748661f, -0.04984820f, -0.00656932f, -0.29979476f, -0.30202082f, 0.68378788f, -0.06822915f, 0.53862572f, 
    -0.39562318f, -0.02475809f, -0.01614513f, -0.15200256f, -0.00400670f, 0.02238524f, -0.01841658f, -0.14518917f, 
    -0.13589059f, 0.22200404f, -0.18842427f, 0.08736873f, 0.44525129f, 0.41398710f, 0.17549039f, 0.07382041f, 
    0.70015126f, 0.04558077f, -0.59460658f, -0.09466057f, -0.24573874f, 0.09309126f, -0.15397441f, 0.08966756f, 
    0.35567412f, 0.21011016f, 0.04860450f, 0.13416049f, -0.07571047f, 0.17083243f, 0.23089758f, 0.17585973f, 
    -0.02519024f, 0.40819862f, -0.23621449f, -0.11020972f, 0.11678837f, -0.07604101f, -0.04622420f, 0.12147591f, 
    0.26243377f, 0.24923621f, 0.03925288f, 0.20534936f, 0.28921956f, 0.02520509f, 0.00745555f, 0.04717066f, 
    0.26798284f, -0.26222137f, 0.05736250f, -0.00177530f, 0.17490590f, -0.28724375f, 0.13453799f, 0.07851545f, 
    -0.31010503f, -0.07822389f, -0.02564619f, 0.14184463f, 0.03518965f, -0.10669190f, -0.09166133f, -0.24113981f, 
    0.47556463f, -0.03474661f, 0.17297333f, -0.02556277f, -0.11173594f, -0.07984353f, 0.06065536f, 0.24556196f, 
    0.08747308f, 0.22073655f, 0.20577598f, -0.42071444f, 0.05485136f, 0.15022974f, 0.29932055f, -0.26460317f, 
    -0.64550632f, -0.29986313f, 0.46676984f, 0.27395311f, 0.01180388f, -0.09477124f, 0.24019521f, 0.20077437f, 
    -0.03195439f, 0.16438212f, -0.20803103f, 0.03959128f, 0.03767445f, -0.12530248f, 0.10969842f, -0.25629935f, 
    -0.16275421f, -0.33855316f, 0.22002819f, 0.00121734f, 0.09285749f, 0.31626913f, -0.25181073f, -0.29358149f, 
    0.12429303f, -0.04726950f, 0.28107825f, -0.31820756f, 0.43462923f, -0.35123011f, 0.02881345f, -0.01624683f, 
    0.08033905f, -0.11687542f, 0.46725914f, 0.01169942f, 0.15147665f, -0.08424816f, -0.19384237f, -0.21223974f, 
    0.09129555f, 0.14269544f, -0.01355342f, 0.13324291f, 0.23643626f, 0.18500644f, 0.44257957f, -0.09496336f, 
    -0.02671655f, -0.16373932f, 0.00659390f, 0.28772411f, -0.13636251f, 0.02686378f, 0.06899331f, 0.21586642f, 
    -0.03754698f, -0.08955256f, -0.05354313f, -0.17456771f, 0.06287028f, 0.04428986f, -0.10623927f, 0.29079136f, 
    0.26631275f, -0.11139127f, 0.38167822f, 0.20897073f, 0.29296672f, -0.01809882f, 0.06750321f, -0.13463286f, 
    0.15864097f, 0.15654166f, -0.23983955f, 0.06616199f, 0.61982763f, -0.11708117f, -0.04592550f, -0.09793607f, 
    0.37546748f, -0.24707122f, 0.04230707f, 0.05161678f, 0.14985462f, 0.30628175f, -0.15194936f, 0.51026666f, 
    0.12359423f, 0.06934344f, -0.26047975f, -0.02385895f, -0.12986757f, -0.35482618f, 0.02425113f, 0.01785626f, 
    -0.11165324f, -0.00394797f, -0.09519739f, -0.13593706f, -0.10392775f, 0.06623590f, 0.10538423f, 0.06223966f, 
    -0.17036399f, -0.02428582f, -0.02991186f, 0.03794499f, -0.11345082f, 0.05960476f, -0.08881841f, -0.07913783f, 
    0.07500261f, -0.05686329f, -0.04479455f, -0.03070866f, -0.15191391f, 0.01181731f, -0.07572267f, 0.08246142f, 
    -0.08878912f, 0.04647237f, 0.00601739f, 0.08733278f, 0.04761467f, 0.03457408f, 0.05345615f, -0.05418548f, 
    -0.10653220f, -0.05395942f, 0.07145018f, -0.07305239f, -0.10677265f, -0.12261678f, 0.05743992f, -0.00345926f, 
    -0.06455424f, -0.05145402f, 0.00989655f, -0.01174816f, -0.17917177f, -0.12872922f, -0.07515920f, -0.02185971f, 
    0.01270988f, 0.08295854f, 0.05382371f, 0.01290355f, -0.11508654f, 0.00529496f, -0.02468251f, 0.07905839f, 
    -0.07072883f, 0.04796134f, 0.11043039f, -0.12047760f, 0.12699667f, 0.05097909f, -0.08980758f, 0.10781459f, 
    -0.02927271f, -0.52288336f, 0.13259596f, 0.14718966f, 0.20369671f, -0.00121003f, -0.09329058f, 0.26195899f, 
    0.08663978f, 0.00436764f, -0.01931785f, 0.14003214f, 0.06569231f, -0.16245262f, 0.27356002f, 0.47231150f, 
    -0.38240382f, -0.23175739f, 0.13586630f, 0.37603971f, -0.26382041f, -0.01853749f, 0.07331605f, 0.19256602f, 
    -0.38170236f, -0.05300538f, -0.02731677f, -0.32156608f, 0.25286540f, -0.16591996f, -0.02883174f, 0.13210455f, 
    0.62169898f, -0.32068321f, 0.59327060f, 0.13580535f, 0.34821591f, -0.48645726f, 0.07877355f, -0.39152902f, 
    -0.05276230f, 0.10176346f, -0.35632128f, 0.12767942f, 0.50214690f, 0.05445874f, -0.13343892f, -0.07854006f, 
    0.55458909f, -0.56455147f, 0.03387263f, -0.44939297f, 0.03777702f, 0.30042708f, -0.29367542f, 0.68977511f, 
    -0.03810162f, -0.04383279f, -0.47629747f, -0.07792462f, -0.20950876f, 0.32725719f, 0.17025468f, -0.56686240f, 
    -0.28437561f, -0.08571845f, 0.35523355f, -0.03677477f, 0.06552351f, 0.07079215f, -0.38417780f, 0.01110603f, 
    0.52092355f, 0.08350675f, 0.09778969f, 0.53611052f, 0.17644095f, -0.04926741f, 0.55389583f, -0.34116769f, 
    0.02161719f, -0.06136455f, 0.10808548f, 0.31297904f, -0.33854920f, 0.05267364f, -0.13168752f, 0.28765637f, 
    -0.09344903f, -0.02013406f, 0.05792500f, -0.18699948f, 0.09033193f, -0.05860793f, -0.12901092f, -0.13127679f, 
    0.18404305f, -0.24032852f, 0.27226567f, 0.04783798f, 0.55044621f, 0.23149320f, 0.21602359f, -0.21732531f, 
    0.29494804f, 0.41073319f, -0.17792313f, -0.08090414f, 0.76658767f, 0.10011360f, 0.06044593f, 0.05346019f, 
    0.37427062f, 0.04148554f, -0.06982826f, 0.02123634f, 0.30423105f, 0.37354916f, -0.22225873f, 0.57972419f, 
    0.01873009f, -0.33821064f, 0.05996507f, -0.05358591f, -0.14625715f, 0.16070677f, 0.33374628f, 0.14857353f, 
    -0.09235246f, 0.24761970f, -0.09164897f, -0.04215025f, 0.14495642f, 0.30365866f, 0.20161791f, 0.06792662f, 
    -0.00901556f, 0.06444292f, -0.10590814f, 0.01933707f, 0.01483110f, -0.29942653f, -0.01605587f, -0.21727879f, 
    0.47196442f, 0.33086821f, 0.08496858f, 0.18248321f, 0.18786427f, 0.04419916f, 0.06676822f, -0.19670570f, 
    0.09848384f, -0.09021653f, -0.00811794f, 0.07445722f, -0.13852814f, 0.14037198f, -0.04147126f, -0.26583639f, 
    -0.03644863f, 0.01911562f, 0.20430297f, 0.19189841f, -0.08923218f, 0.14788613f, 0.19118010f, 0.07029578f, 
    -0.05420458f, -0.07789782f, -0.09329323f, -0.10501198f, -0.13710682f, 0.31379232f, 0.13116728f, 0.23913592f, 
    -0.20069689f, 0.14796361f, 0.39960834f, -0.09744559f, 0.18762338f, 0.00241274f, 0.02823259f, -0.29781356f, 
    0.09223785f, -0.18304114f, 0.30817249f, 0.10537905f, 0.17221127f, 0.23892319f, -0.06722793f, -0.05068424f, 
    0.06909326f, -0.12183174f, 0.18270105f, 0.08543801f, 0.43904060f, -0.14010349f, 0.39485022f, -0.28106588f, 
    0.05766697f, 0.09789622f, 0.08961356f, 0.04857266f, 0.08240046f, 0.50780511f, 0.22570404f, -0.09237383f, 
    -0.10489880f, -0.20107149f, 0.25360349f, 0.14271186f, 0.05395341f, 0.09589811f, 0.02065402f, 0.14704351f, 
    -0.22208986f, -0.07477909f, -0.00394415f, -0.02682082f, -0.02744977f, 0.04163639f, 0.24217407f, 0.51872486f, 
    0.31084031f, -0.08748528f, 0.09442773f, -0.03010451f, 0.15825891f, -0.13911709f, 0.17972806f, -0.04292507f, 
    0.02291938f, 0.14578435f, -0.20495917f, -0.04099926f, 0.39834094f, -0.18752854f, -0.07185751f, -0.07444514f, 
    0.23529409f, -0.16151714f, 0.17260002f, 0.04692598f, 0.01002690f, 0.21230431f, 0.09141981f, 0.26519284f, 
    -0.02526995f, 0.04417581f, -0.06522982f, 0.01761679f, 0.08216377f, -0.41344190f, 0.15167890f, 0.05037730f, 
    -0.06988778f, -0.12931128f, 0.07184470f, -0.02914726f, -0.07834765f, -0.01990752f, -0.02654330f, -0.02800623f, 
    -0.07901974f, -0.01418500f, -0.12228253f, -0.05126708f, -0.08986076f, -0.10470022f, 0.01054723f, 0.00353563f, 
    0.00605671f, -0.11860964f, -0.06692921f, 0.01934123f, -0.02613798f, 0.08506243f, -0.02221153f, -0.01594710f, 
    -0.00001714f, -0.07359982f, -0.06760146f, -0.07293531f, -0.10649452f, -0.02014054f, -0.07383632f, 0.09939399f, 
    -0.07602566f, -0.10456809f, -0.07516631f, 0.07244778f, -0.09173625f, 0.02610767f, -0.01490600f, -0.11490351f, 
    0.04093328f, 0.10305155f, -0.12132893f, 0.05251499f, 0.09782218f, 0.10110614f, 0.09258578f, -0.03033579f, 
    0.04373300f, 0.01419465f, 0.01234348f, 0.04324356f, -0.07458561f, -0.01478459f, -0.01941691f, 0.10365783f, 
    0.06901238f, 0.05950110f, 0.05408039f, 0.04181869f, 0.06012438f, 0.02206406f, 0.09122317f, -0.07162628f, 
    -0.03789017f, -0.26520452f, 0.28179055f, 0.06288328f, 0.13920170f, 0.04736433f, -0.50935751f, -0.01794132f, 
    0.04868025f, 0.05374503f, -0.06284385f, -0.06980917f, 0.18795516f, 0.35451835f, 0.40552935f, 0.25940388f, 
    0.03343990f, -0.02015315f, -0.04570670f, 0.05742380f, -0.08544941f, 0.01708103f, 0.12373336f, -0.25274161f, 
    -0.29028654f, 0.13812645f, 0.22154254f, -0.02813742f, 0.23955670f, -0.21399541f, -0.32263666f, 0.05887369f, 
    0.21163817f, -0.19998276f, -0.19207574f, 0.08250725f, 0.05317931f, -0.35212660f, 0.07211068f, 0.05399639f, 
    0.03292635f, -0.05322060f, 0.04679813f, -0.15497036f, 0.16744329f, -0.14486651f, 0.12166785f, 0.06561252f, 
    0.35624415f, -0.91237092f, -0.22953977f, 0.14776887f, 0.07629950f, 0.18066226f, -0.28427696f, 0.55959231f, 
    0.02987811f, 0.01376922f, -0.16476358f, 0.15260716f, -0.19520554f, -0.10521863f, -0.25597185f, -0.22871783f, 
    -0.12859815f, 0.01421223f, 0.05859077f, -0.02647117f, -0.06506441f, -0.02692326f, -0.06388163f, -0.10387336f, 
    -0.04065669f, -0.12259187f, -0.09009945f, -0.11476114f, 0.08515438f, 0.09931165f, 0.09424725f, -0.10262981f, 
    0.12309155f, 0.02641283f, -0.00662691f, -0.03562048f, 0.02513355f, 0.02005611f, -0.07069314f, -0.09642170f, 
    0.06540182f, 0.04934029f, -0.08463946f, -0.10744962f, 0.04040582f, -0.02374611f, -0.03220907f, 0.03584185f, 
    -0.10894857f, 0.10766865f, -0.10256180f, 0.02649171f, -0.05480732f, -0.08702438f, 0.00001984f, -0.08794654f, 
    -0.07434401f, -0.08714011f, -0.04607579f, 0.01484445f, 0.10681671f, -0.10572858f, -0.07477043f, 0.07074912f, 
    0.00366010f, 0.06572596f, -0.06743070f, -0.13731574f, 0.01887091f, 0.01586826f, -0.05330248f, 0.07964829f, 
    -0.03356559f, -0.05947785f, -0.11938523f, 0.08695100f, 0.04803415f, 0.10829608f, 0.00758437f, -0.07688557f, 
    0.23406427f, 0.08715132f, 0.15282798f, -0.08890225f, 0.32590204f, -0.02814186f, 0.35098040f, 0.03182973f, 
    -0.05291670f, 0.24118085f, -0.01831436f, -0.00805911f, 0.20259517f, -0.14756374f, -0.29258958f, -0.09338919f, 
    0.56545979f, 0.31653902f, 0.14594834f, -0.19079871f, 0.29422709f, 0.00149528f, 0.14088082f, -0.49842551f, 
    0.08716846f, 0.23731603f, -0.17940703f, -0.01205200f, -0.05193765f, 0.25169852f, 0.31843644f, -0.13579412f, 
    -0.39050445f, 0.04673683f, -0.04657328f, 0.34549940f, 0.04342799f, 0.22573566f, 0.25918418f, 0.00650404f, 
    -0.07601481f, 0.25683632f, -0.13728154f, 0.03471272f, -0.09226281f, 0.17511693f, 0.00837041f, 0.15010558f, 
    -0.14733115f, 0.70769238f, 0.39303094f, 0.07811947f, 0.14332600f, -0.07160421f, 0.29250166f, -0.27292752f, 
    0.06630084f, -0.20218331f, 0.38900098f, -0.02149384f, 0.37729013f, -0.26466060f, -0.04311278f, 0.15797858f, 
    0.10847190f, -0.00140930f, 0.30154639f, -0.02216681f, 0.21294118f, 0.10012078f, 1.04369855f, -0.23572952f, 
    -0.10616808f, 0.16199929f, 0.08867580f, -0.28483030f, -0.09096415f, 0.73505998f, -0.13548207f, -0.01808632f, 
    -0.63351893f, 0.09295380f, 0.13061281f, 0.10502627f, 0.44708359f, -0.06272203f, 0.24074875f, 0.04007192f, 
    -0.30511153f, 0.21826099f, 0.14495179f, -0.02502037f, -0.42226458f, -0.55725008f, 0.02560864f, 0.67042935f, 
    0.63865185f, 0.08260861f, -0.05077473f, 0.01892658f, -0.22424981f, 0.22486681f, -0.01600352f, 0.00439072f, 
    -0.59006780f, -0.52823061f, -0.06365632f, 0.31834498f, -0.22648098f, 0.20594352f, 0.01211225f, 0.25927755f, 
    -0.01804802f, 0.49595127f, 0.19063541f, -0.15767139f, 0.18999098f, 0.17043519f, 0.14566748f, 0.18239009f, 
    0.01070507f, -0.09727859f, 0.16464999f, 0.08483339f, -0.18037270f, -0.19659266f, -0.23649357f, -0.29292786f, 
    -0.00300233f, -0.21488307f, 0.52039498f, -0.12720741f, 0.28136227f, -0.17178622f, -0.27021092f, -0.00719144f, 
    0.07619222f, 0.22293079f, -0.15663102f, -0.04277655f, 0.10637509f, 0.35409927f, 0.35910916f, -0.59482342f, 
    0.30139676f, 0.04230175f, 0.06099373f, 0.21225788f, -0.00765454f, -0.03298403f, 0.07190961f, 0.35626602f, 
    -0.13634154f, 0.10583436f, -0.09992655f, -0.06794895f, -0.21619076f, -0.02433892f, -0.42369589f, -0.12911603f, 
    -0.29425511f, 0.02829686f, 0.12258270f, 0.04026383f, 0.27878398f, -0.13762781f, 0.32301718f, -0.00231502f, 
    0.12061585f, -0.13080820f, -0.32294753f, 0.05563462f, 0.21892722f, -0.08124526f, 0.00812179f, 0.08090665f, 
    0.23809654f, -0.39994201f, -0.07475948f, 0.15011168f, 0.17172426f, 0.44703218f, -0.08926770f, 0.45607501f, 
    0.08603609f, -0.22527045f, 0.16777505f, -0.05416573f, -0.01533695f, -0.01443308f, -0.06816170f, -0.04916060f, 
    -0.20535897f, 0.22154711f, 0.20542499f, -0.25277600f, -0.13664448f, 0.16838489f, -0.39112976f, -0.03189318f, 
    0.05532191f, -0.03070240f, -0.07558168f, -0.12422934f, 0.29672727f, -0.22130106f, 0.03563653f, 0.01545104f, 
    -0.75567621f, 0.34963658f, -0.12548956f, -0.12403174f, 0.08585385f, 0.03153637f, 0.08126660f, 0.07143004f, 
    0.55335212f, 0.14565341f, 0.17168665f, -0.15089662f, 0.00088781f, -0.08654832f, -0.28320047f, 0.11103948f, 
    -0.53857487f, 0.08273763f, 0.38529274f, 0.28698885f, -0.26286024f, 0.15461297f, 0.12898734f, 0.03913986f, 
    -0.10896595f, -0.02086148f, -0.02845449f, -0.03902945f, -0.30670360f, 0.08574932f, 0.01804082f, 0.28458339f, 
    -0.21190888f, -0.09549690f, 0.15981711f, 0.22003026f, -0.09794872f, -0.12158680f, -0.22255862f, -0.13889191f, 
    -0.10055972f, -0.12761225f, 0.35714734f, 0.17198403f, -0.01051890f, 0.31767270f, -0.09304102f, -0.01906733f, 
    0.13387376f, -0.27619532f, -0.03363690f, 0.08811764f, 0.33694723f, -0.46583414f, 0.15726005f, 0.18780620f, 
    -0.41760772f, -0.08811229f, 0.11340106f, 0.18845293f, 0.24297467f, -0.04498417f, 0.06495772f, -0.32783437f, 
    0.32506707f, -0.14842089f, 0.18544208f, -0.02480303f, -0.26838014f, 0.00258612f, 0.23276028f, 0.07609396f, 
    0.04462372f, 0.42103425f, 0.25113672f, -0.61733049f, 0.20247267f, 0.04738482f, 0.46737504f, -0.37330562f, 
    -0.59017253f, -0.43416223f, 0.55504882f, 0.30361378f, -0.17555037f, -0.21953486f, 0.19841646f, 0.12161676f, 
    0.18647537f, 0.26802543f, -0.32834813f, 0.07958055f, 0.21150947f, -0.16509147f, -0.02091582f, -0.18291882f, 
    -0.27730924f, -0.36400634f, 0.05495205f, 0.09767994f, 0.05349728f, 0.34921384f, -0.41183013f, -0.01332473f, 
    0.19912238f, 0.09353702f, 0.15439355f, -0.47733104f, 0.31710827f, -0.37050861f, -0.08851540f, -0.18782155f, 
    -0.08437030f, -0.09654357f, 0.43006945f, -0.06276906f, 0.07599044f, -0.05114663f, -0.41394725f, 0.07894150f, 
    0.25326771f, 0.14657177f, 0.02078949f, 0.12262235f, 0.19591457f, 0.04267040f, 0.56838101f, -0.06582864f, 
    0.02985761f, -0.00968233f, 0.12578283f, 0.35855058f, -0.11091615f, -0.00778992f, 0.07739928f, -0.13690737f, 
    -0.22787909f, 0.03057729f, 0.03181606f, 0.11705698f, 0.14659496f, -0.16896217f, -0.33671305f, -0.06902258f, 
    0.40650588f, -0.13310452f, 0.31022665f, -0.04900585f, 0.46635023f, -0.23316942f, 0.16956645f, -0.28430924f, 
    -0.04343360f, 0.02073971f, -0.01656054f, 0.16528545f, 0.52623361f, 0.04934094f, 0.02144820f, 0.05838405f, 
    0.41017383f, -0.77994317f, -0.18464930f, -0.07608497f, 0.20706829f, 0.17960365f, -0.08059004f, 0.52260464f, 
    0.05364780f, -0.25474438f, -0.17383488f, 0.04792925f, -0.35301682f, 0.04054401f, -0.00642592f, -0.25678334f, 
    0.09047251f, -0.21976912f, -0.08173794f, 0.14008665f, -0.03418505f, 0.02529837f, 0.22385234f, 0.01404288f, 
    0.08167849f, -0.25591955f, -0.01064409f, -0.09561433f, -1.06062388f, 0.15205948f, -0.25687215f, -0.08037354f, 
    0.62121600f, -0.07425649f, 0.30572912f, 0.11424427f, 0.13183485f, -0.00481168f, 0.25698814f, 0.28683454f, 
    -0.23396194f, 0.21906203f, 0.24058609f, -0.02272525f, -0.08117568f, 0.04113353f, 0.20284276f, -0.32170784f, 
    0.36031047f, -0.11559147f, 0.34866342f, -0.55924332f, -0.23510332f, -0.37053692f, -0.23559974f, -0.00421459f, 
    -0.17541273f, -0.29393601f, -0.13930240f, -0.00122839f, 0.07311294f, 0.51044643f, 0.21198051f, 0.15462267f, 
    0.11483812f, 1.28452754f, -0.11594289f, -0.16580778f, 0.04601534f, 0.32097912f, -0.13833904f, 0.05674006f, 
    0.01380517f, 0.07788985f, -0.21742570f, -0.02360241f, 0.23274709f, -0.15514529f, 0.07300606f, 0.41118100f, 
    -0.08063006f, 0.17270517f, -0.00172687f, -0.11498475f, 0.01991164f, 0.15542500f, 0.00083091f, 0.04360704f, 
    0.15180898f, -0.06913671f, -0.04501730f, -0.12758753f, -0.01298541f, 0.63608319f, 0.18623231f, 0.18284728f, 
    -0.32821393f, 0.10425419f, -0.02741777f, 0.25186476f, 0.08742139f, -0.15559326f, 0.14699529f, -0.15786448f, 
    -0.04528378f, 0.10840970f, 0.03651259f, 0.08558663f, 0.07616299f, -0.19900744f, -0.45458087f, 0.21890920f, 
    0.41181704f, 0.09779833f, -0.50888151f, -0.03010853f, 0.03070302f, -0.01640643f, -0.08931855f, 0.05943128f, 
    -0.14561801f, -0.31082380f, 0.04185484f, -0.01282259f, -0.33189842f, 0.16510682f, 0.08163505f, 0.20680487f, 
    0.07679411f, -0.06729713f, -0.14154275f, 0.06280942f, 0.13800095f, -0.08171453f, 0.03092612f, -0.03913351f, 
    0.01930539f, -0.09124019f, 0.11441618f, 0.14701520f, -0.09372581f, 0.40028179f, -0.02507617f, -0.27544138f, 
    0.03316401f, 0.14095756f, -0.19891666f, -0.05801697f, -0.63081372f, 0.10682179f, 0.25776392f, 0.15244196f, 
    0.06340326f, -0.13660057f, 0.01628457f, 0.00204292f, 0.05621883f, 0.24333034f, -0.16554518f, 0.10417508f, 
    -0.01939665f, -0.42848456f, 0.08048993f, 0.06951142f, 0.07401516f, -0.10542980f, 0.28060564f, 0.32515144f, 
    -0.59441394f, 0.33546814f, 0.17633760f, -0.08161483f, 0.12339859f, -0.17895091f, -0.09305993f, 0.06891340f, 
    0.29963252f, -0.04876887f, -0.29714471f, -0.56098658f, -0.23564348f, 0.23384562f, -0.33002964f, 0.25503704f, 
    -0.10905399f, 0.49495319f, 0.19323711f, 0.08621193f, -0.07454222f, 0.23756388f, 0.01976761f, 0.26389298f, 
    -0.05582770f, 0.55978501f, -0.60949588f, -0.11932730f, 0.20335935f, 0.14778270f, 0.11909553f, 0.27100217f, 
    0.04123273f, 0.21256381f, -0.26553056f, 0.00811483f, -0.43843159f, -0.11373523f, -0.14932118f, 0.97424829f, 
    -0.10186644f, 0.06830522f, -0.01094988f, -0.09505951f, 0.06709540f, -0.09520311f, 0.06638402f, 0.12490639f, 
    -0.03027556f, -0.03950988f, 0.07445764f, -0.11519150f, -0.11223610f, 0.08775863f, -0.03476096f, 0.07318883f, 
    -0.01141891f, -0.08378413f, 0.00635504f, -0.06461236f, -0.02984286f, 0.09796923f, 0.05455458f, 0.06939942f, 
    -0.03115004f, -0.09880313f, -0.11601288f, -0.10379287f, 0.00701299f, -0.04699146f, -0.06111898f, -0.11402182f, 
    0.05598107f, -0.04352295f, 0.06736888f, -0.11893407f, 0.10127917f, 0.08480579f, 0.06090941f, 0.10701686f, 
    -0.05957874f, -0.08153613f, 0.10862236f, -0.08921390f, 0.09708486f, -0.04735266f, 0.06745350f, 0.04330931f, 
    -0.00343738f, -0.06009302f, 0.02254886f, 0.04840706f, 0.00397738f, -0.04688786f, 0.00473371f, -0.10043995f, 
    0.06043124f, -0.09620705f, -0.12136839f, -0.06050460f, 0.07248251f, -0.02806420f, -0.01632735f, 0.01692602f, 
    -0.04840757f, 0.20214850f, -0.16697340f, 0.14371954f, -0.20273602f, 0.09507051f, -0.12688898f, 0.12801218f, 
    0.07484874f, -0.37610698f, -0.03065277f, 0.31472442f, -0.13626577f, -0.42510951f, 0.01292622f, -0.39233425f, 
    0.38033947f, 0.09305093f, 0.10520643f, 0.43601632f, -0.02599508f, 0.06484327f, 0.08574536f, 0.55133730f, 
    0.18987362f, 0.27602276f, 0.25979552f, -0.12363844f, -0.01597742f, 0.06084289f, 0.00163016f, -0.09682132f, 
    -0.18913651f, -0.14751872f, 0.43269446f, 0.02848433f, -0.12783505f, 0.16020472f, -0.05164281f, 0.22241835f, 
    -0.07394489f, 0.00087411f, 0.07092070f, 0.09169488f, -0.10162076f, 0.27406898f, 0.12906668f, 0.08317155f, 
    -0.31197548f, 0.21199593f, -0.07701656f, 0.03070249f, 0.16689937f, -0.09323953f, -0.35422808f, -0.32300013f, 
    0.22622108f, -0.20345576f, 0.33219004f, -0.15031113f, -0.03234898f, 0.28861323f, 0.07048500f, -0.16716605f, 
    -0.01129968f, 0.07861698f, -0.11593808f, 0.02169917f, -0.03472167f, 0.23969015f, -0.02043157f, 0.25664097f, 
    -0.05919446f, -0.03752998f, -0.07768036f, -0.20881952f, 0.06924344f, 0.35693550f, 0.10281488f, 0.61104047f, 
    0.39392963f, -0.02235087f, 0.09282042f, 0.07739334f, -0.09242278f, 0.02819588f, -0.04383256f, -0.25962251f, 
    0.26865527f, -0.02550182f, 0.01403558f, -0.06111635f, 0.37312087f, 0.41273889f, 0.21779869f, -0.32474577f, 
    0.31434277f, -0.12152453f, -0.12153298f, 0.15217516f, -0.01938189f, -0.20229983f, -0.06611976f, -0.21017538f, 
    0.30447984f, 0.86300349f, 0.08756927f, 0.00479653f, 0.49198797f, 0.01002560f, 0.08698580f, 0.12609546f, 
    0.06171710f, -0.86851454f, -0.11162724f, -0.02440929f, 0.03811429f, -0.11564960f, 0.00430421f, 0.15871531f, 
    0.22942373f, 0.27070332f, -0.20609982f, 0.18110505f, 0.16904588f, -0.02058212f, 0.10017049f, 0.16771629f, 
    0.03521476f, 0.00935728f, 0.04499973f, 0.28662655f, 0.13361168f, -0.12477768f, -0.33218434f, 0.00251555f, 
    0.12631631f, 0.04428134f, 0.00841737f, 0.19294630f, -0.24135301f, -0.16356976f, 0.23902132f, -0.10979910f, 
    0.24187203f, -0.17582496f, 0.11849928f, 0.18973942f, -0.13531683f, 0.07151552f, 0.18286808f, 0.56906348f, 
    -0.15819964f, -0.05351084f, 0.22594489f, 0.00890197f, 0.25637960f, 0.16331096f, 0.00797736f, -0.32479888f, 
    -0.05259471f, -0.04098156f, 0.51834202f, -0.28851020f, 0.16091958f, -0.39511609f, 0.02694402f, 0.08955934f, 
    0.27739799f, 0.01852452f, 0.08959419f, 0.11328527f, 0.19863823f, 0.06242089f, 0.13200195f, -0.05914128f, 
    0.27593890f, -0.13755700f, -0.26338553f, 0.26477772f, 0.17756696f, 0.28690958f, 0.12536456f, 0.09600373f, 
    0.24509829f, 0.08833719f, -0.37278289f, -0.11729045f, -0.19424559f, 0.03419217f, 0.13759798f, -0.10796222f, 
    0.04676785f, -0.05336498f, 0.04677606f, -0.11239140f, -0.00434094f, -0.17337699f, -0.07057630f, -0.10077614f, 
    -0.01308148f, -0.14599064f, 0.01452050f, -0.08793320f, -0.13988425f, -0.10700950f, -0.05686302f, -0.15249208f, 
    -0.11943223f, -0.11014141f, -0.09756739f, -0.07187121f, -0.04636796f, 0.06182662f, 0.01234274f, 0.08369096f, 
    0.03215666f, 0.06340959f, -0.04137061f, -0.06312034f, -0.14091924f, -0.05854944f, -0.02687601f, 0.00619073f, 
    0.01863572f, 0.06708281f, -0.11222948f, 0.04974040f, 0.02969243f, -0.02486585f, 0.05009776f, -0.07651163f, 
    -0.12856819f, -0.04745865f, 0.04380665f, -0.06257007f, -0.03218312f, 0.03490361f, 0.02130946f, -0.08011665f, 
    0.07289812f, -0.00209762f, 0.07625401f, -0.09266346f, -0.10674002f, -0.07086505f, 0.08720982f, 0.02572355f, 
    -0.01062129f, 0.04188606f, -0.05589463f, -0.06652304f, 0.04919793f, -0.08197350f, -0.11701591f, 0.00888591f, 
    -0.01417535f, 0.03203123f, -0.21391009f, -0.03444944f, 0.01566615f, 0.38052309f, 0.09938016f, 0.10484359f, 
    -0.10771031f, 0.12489247f, 0.02446188f, -0.03469743f, 0.01796064f, 0.02239730f, 0.07752205f, 0.39733705f, 
    0.35222286f, 0.29322088f, 0.05845144f, -0.07636256f, -0.01581222f, -0.01788283f, 0.11089633f, -0.31596509f, 
    0.37236309f, 0.08507993f, 0.02916781f, -0.00453182f, 0.16196387f, 0.07872923f, 0.02069432f, -0.19391534f, 
    -0.27175435f, 0.09934678f, 0.04927249f, 0.38153282f, -0.06008280f, 0.05882001f, 0.25086704f, -0.18037644f, 
    0.15390103f, 0.12882550f, 0.08933026f, 0.04959004f, -0.23863426f, 0.20375572f, 0.09244360f, 0.37317264f, 
    -0.03542954f, -0.03587444f, 0.20376387f, 0.10613300f, 0.01437652f, -0.11523091f, -0.06599613f, -0.25919750f, 
    0.07148796f, 0.01748918f, 0.30600467f, 0.24019454f, 0.46871513f, 0.30510679f, 0.00863678f, -0.12562114f, 
    -0.15534079f, -0.07061995f, 0.22837225f, -0.11568513f, 0.08043556f, 0.30620292f, 0.06266847f, -0.02589500f, 
    -0.04018445f, -0.22147295f, -0.06133915f, -0.46479648f, 0.23840798f, -0.09588938f, -0.17967498f, -0.10192519f, 
    0.60410398f, 0.25421581f, -0.14898396f, -0.41266000f, 0.09240033f, 0.01449550f, 0.03365562f, 0.38637921f, 
    0.68618935f, 0.04342669f, -0.00872885f, 0.08078507f, 0.14300700f, 0.28148818f, -0.10320471f, -0.17616852f, 
    0.09259106f, 0.30062935f, 0.26417294f, 0.24313116f, -0.40669793f, 0.43313974f, 0.29473671f, -0.21842428f, 
    0.18435410f, 0.29760969f, -0.11310971f, -0.25256065f, 0.06619328f, 0.18468450f, 0.01525160f, 0.30916622f, 
    -0.18510790f, 1.10775042f, 0.24962318f, 0.13166223f, -0.01692795f, -0.10995796f, -0.08602458f, -0.10445298f, 
    -0.09125052f, 0.09670255f, 0.23322275f, 0.18443963f, 0.06542506f, 0.06872477f, -0.26828206f, 0.78764969f, 
    -0.10119966f, 0.13573307f, 0.20326664f, -0.05849179f, 0.17497407f, 0.58699077f, 0.34525859f, 0.10609866f, 
    0.19936942f, 0.15555783f, 0.09162261f, -0.32286388f, 0.45041448f, 0.05680791f, -0.05483839f, -0.05365170f, 
    0.56333596f, 0.50948930f, 0.11604962f, -0.10396868f, 0.28420493f, -0.09005880f, 0.15131399f, -0.30786839f, 
    0.21007311f, 0.00715816f, 0.13195600f, 0.04757408f, -0.16234733f, 0.17096622f, -0.04945859f, -0.14770198f, 
    0.29127020f, 0.18448579f, -0.20335747f, 0.19147240f, -0.22913267f, 0.33824542f, 0.15352724f, -0.09454227f, 
    0.16693279f, 0.15273371f, -0.16936901f, -0.09280913f, 0.16103101f, 0.59403718f, 0.08065494f, 0.50103492f, 
    -0.04465383f, 0.96587759f, 0.21342888f, 0.08844675f, -0.00936822f, -0.14899170f, -0.05511924f, -0.02868414f, 
    0.26063094f, -0.14584656f, 0.28617695f, 0.23141959f, 0.01879814f, -0.16888198f, -0.09185804f, 0.61584198f, 
    -0.11139027f, 0.04234810f, -0.07270802f, 0.03553122f, -0.06966594f, -0.10219771f, 0.04722020f, -0.11641555f, 
    -0.11438671f, -0.08372290f, 0.04777597f, 0.06524926f, 0.02771731f, 0.10828786f, 0.02191848f, 0.09211082f, 
    -0.12742727f, -0.04010575f, 0.05792535f, -0.06179315f, -0.10273533f, -0.01572162f, 0.00450674f, 0.05898693f, 
    -0.01434070f, -0.09309252f, -0.07683814f, 0.09639804f, 0.08308408f, -0.05159458f, -0.05263533f, -0.04703109f, 
    0.08220423f, -0.08235711f, 0.07542761f, -0.04500037f, 0.06164247f, 0.01881711f, -0.01765400f, -0.11220720f, 
    0.07102782f, -0.04402343f, 0.03975894f, 0.07880025f, 0.02955871f, -0.01883205f, 0.02794678f, 0.02408689f, 
    -0.10802961f, 0.02494389f, -0.10104374f, -0.02284198f, 0.02077892f, 0.09624130f, -0.01741298f, -0.02866652f, 
    -0.08194495f, -0.13119853f, -0.09757322f, -0.12651637f, -0.00422457f, -0.06389505f, -0.00508144f, 0.10580924f, 
    0.03300371f, 0.03811557f, 0.46329501f, 0.02097072f, -0.02923140f, 0.14161155f, -0.44383430f, -0.02273208f, 
    0.15605289f, 0.15158983f, 0.00031346f, 0.03337577f, 0.28365150f, -0.06144775f, 0.35026991f, -0.05009707f, 
    0.61950547f, 0.20184033f, 0.18988809f, 0.28956315f, 0.06654551f, 0.11744086f, 0.08624450f, -0.17083731f, 
    -0.34135428f, -0.13165882f, 0.10599928f, 0.09692271f, -0.04509377f, -0.08414969f, -0.29679635f, -0.23371917f, 
    -0.36208111f, -0.08049741f, 0.04870264f, 0.13991238f, 0.07985368f, -0.22073051f, 0.29087362f, 0.06420059f, 
    0.00470867f, 0.17893519f, -0.07567181f, -0.06609662f, 0.24092694f, 0.04906568f, 0.14283901f, 0.02632583f, 
    0.14127363f, -0.69221884f, 0.06331333f, 0.05049440f, 0.08274622f, 0.17771684f, -0.06760193f, 0.11647865f, 
    -0.08285086f, -0.20620790f, -0.01741203f, 0.15432367f, -0.12555559f, 0.13298708f, -0.01663356f, 0.06632102f, 
    -0.00192718f, -0.09777532f, -0.03626100f, 0.16240384f, -0.07130143f, 0.15918317f, 0.39586017f, -0.15197098f, 
    0.33898067f, -0.13665777f, -0.01879641f, -0.02345057f, -0.41056985f, 0.18177947f, -0.10046786f, -0.25229585f, 
    -0.13992840f, 0.01517437f, 0.26877078f, 0.31949413f, 0.16768263f, 0.00725529f, -0.01022836f, 0.62418431f, 
    -0.09714375f, 0.06732558f, 0.06904536f, 0.03591968f, -0.24553172f, -0.30750632f, -0.01793175f, -0.06118901f, 
    0.73035222f, -0.00229658f, -0.27293980f, -0.55886239f, 0.02516184f, 0.32243216f, -0.26887530f, 0.19545040f, 
    -0.27021253f, -0.26329181f, 0.06865563f, 0.02303379f, -0.08029894f, 0.53539115f, 0.08728521f, 0.17628555f, 
    0.24492064f, 0.87082112f, -0.08713152f, -0.10754608f, 0.30035087f, 0.22187211f, -0.13874391f, 0.00780236f, 
    -0.04827608f, 0.10922924f, -0.45707500f, -0.14227904f, -0.49761829f, -0.16607672f, 0.02609434f, 0.66228402f, 
    -0.03579012f, -0.13748758f, -0.25419435f, 0.15189822f, 0.00821474f, -0.23468383f, 0.30326799f, -0.05135125f, 
    -0.28970593f, -0.34350613f, 0.11354678f, 0.00299770f, -0.08911872f, -0.06380555f, -0.09784275f, -0.11818690f, 
    0.51723164f, -0.09778374f, 0.21460032f, -0.02839045f, -0.19304901f, -0.09629707f, 0.09535561f, 0.34757340f, 
    0.42139077f, 0.19231614f, 0.19180186f, -0.32464105f, 0.31447247f, 0.26054880f, 0.46932593f, -0.45780972f, 
    -0.43709674f, -0.23316427f, 0.02831263f, 0.16236979f, -0.26327950f, 0.06765516f, 0.17088953f, 0.01113204f, 
    0.27341709f, 0.51842302f, -0.24354208f, 0.09737974f, 0.15574718f, 0.08720965f, -0.06549165f, -0.05068712f, 
    -0.14641087f, 0.67205387f, 0.18611975f, -0.01797748f, 0.08251359f, 0.19808051f, -0.37897441f, -0.16559367f, 
    0.14701632f, 0.28340706f, 0.16712768f, -0.28028479f, 0.37801260f, -0.23583107f, -0.11561654f, 0.38442427f, 
    0.16329111f, -0.19239897f, -0.24342012f, -0.06941255f, -0.01253594f, 0.04840775f, 0.02938502f, 0.01086489f, 
    -0.32270181f, -0.06862591f, -0.06011462f, -0.48931298f, -0.03369433f, 0.27483705f, 0.12695183f, 0.39656717f, 
    -0.12382489f, -0.01888567f, 0.12222836f, 0.07408778f, -0.03687900f, -0.00350928f, 0.27370498f, -0.00489354f, 
    -0.23295604f, 0.35331520f, 0.18135233f, -0.45998555f, 0.35556939f, 0.05201779f, -0.21004613f, -0.26496097f, 
    0.02705819f, -0.07788542f, -0.29727072f, 0.18507224f, -0.18753457f, -0.11200439f, 0.14601974f, 0.06889883f, 
    -0.02463455f, -0.18321210f, -0.04504010f, 0.09397383f, -0.10231766f, 0.00758429f, 0.25858042f, 0.15526414f, 
    -0.07570340f, -0.89134592f, -0.13210261f, 0.18113862f, -0.06895066f, 0.10673969f, -0.35994607f, 0.21460514f, 
    0.25701371f, 0.17791307f, 0.27751821f, -0.01179475f, 0.15729658f, 0.09844285f, -0.33703053f, -0.41726163f, 
    0.24404639f, -0.38264847f, 0.48421246f, 0.12366417f, 0.18926936f, -0.23469408f, 0.01327382f, -0.10521296f, 
    -0.06334831f, 0.06074976f, 0.02732164f, 0.38864014f, 0.18723740f, 0.24706885f, 0.20215777f, -0.50810438f, 
    0.00617371f, 0.00804379f, 0.23288150f, 0.30341911f, -0.18090853f, 0.05918325f, 0.11837184f, 0.50559157f, 
    -0.27804863f, 0.21769775f, 0.21525738f, -0.50069332f, -0.31626505f, -0.24703451f, -0.04504199f, -0.10775952f, 
    -0.40076298f, -0.15135103f, 0.32352221f, -0.00555362f, 0.13133004f, 0.08910754f, 0.16301428f, -0.06346031f, 
    -0.11772539f, 0.08751768f, -0.43044177f, 0.16072364f, 0.28833541f, -0.12242416f, -0.02197475f, -0.17736207f, 
    0.25101763f, 0.46803212f, 0.23003833f, -0.01854489f, 0.25566778f, 0.41359627f, -0.03550493f, 0.18225445f, 
    -0.04632070f, -0.20002380f, 0.03440342f, -0.49470407f, -0.26483274f, -0.77096438f, -0.00974898f, -0.02132271f, 
    -0.09753592f, -0.14378504f, 0.42631561f, 0.12467101f, 0.31934041f, 0.10237354f, -0.13065620f, 0.05832210f, 
    0.40214667f, 0.24756272f, 0.07730481f, 0.19483961f, 0.08675958f, -0.07832266f, 0.31528860f, -0.27582482f, 
    -0.13356645f, -0.09321178f, 0.04941618f, 0.14663363f, -0.07862243f, -0.12466473f, -0.16097938f, 0.28418994f, 
    0.13560495f, -0.19871929f, -0.17821319f, 0.10223137f, -0.09604092f, 0.11452377f, -0.01810305f, -0.17507128f, 
    0.06909573f, 0.06167483f, 0.15371315f, 0.01822938f, 0.41894779f, 0.06705006f, 0.22197409f, -0.06047046f, 
    0.12082295f, 0.34290108f, -0.10248762f, -0.02871344f, 0.33203888f, -0.23082547f, 0.07914163f, -0.12632908f, 
    0.37994403f, 0.86361593f, 0.19971019f, 0.14789332f, 0.02335121f, 0.10606920f, 0.01807667f, 0.29678777f, 
    -0.04019391f, -0.11637641f, -0.21102139f, -0.13015129f, -0.15520288f, -0.34815216f, 0.26546106f, 0.37070504f, 
    -0.04582482f, 0.15359876f, -0.07560458f, 0.11193389f, -0.07531627f, 0.11610295f, 0.00625585f, 0.25697020f, 
    -0.09933503f, -0.20943286f, -0.04611484f, -0.10796280f, -0.42311582f, 0.41293135f, 0.17324322f, -0.10833608f, 
    0.29643700f, 0.09773561f, -0.06066511f, 0.01298373f, 0.16034247f, 0.07251050f, -0.29029572f, 0.01688770f, 
    -0.15751064f, -0.30613545f, -0.12009904f, 0.08428599f, -0.04986892f, 0.15900280f, 0.06763839f, 0.19448313f, 
    -0.01449896f, -0.02225774f, 0.69284922f, -0.16844107f, -0.16292283f, -0.07790963f, -0.03317635f, -0.03058943f, 
    -0.36496052f, -0.08638590f, 0.14034319f, -0.34265247f, -0.04895646f, 0.45628238f, 0.10198136f, 0.12284134f, 
    -0.36572534f, 0.83429497f, -0.01360193f, -0.20590927f, -0.15271215f, -0.41276836f, -0.03873300f, 0.02313310f, 
    -0.01029020f, -0.03834271f, 0.08951432f, 0.03948779f, 0.04277959f, 0.10687331f, -0.03454586f, 0.36251068f, 
    -0.02675277f, -0.20846437f, 0.23645335f, 0.12170298f, 0.00456441f, 0.11901621f, -0.51963884f, 0.10861558f, 
    0.35952559f, 0.16926771f, 0.01696761f, 0.26110908f, 0.00050989f, -0.34737286f, 0.32625562f, -0.01405866f, 
    0.25792101f, -0.09860382f, 0.07155817f, 0.31604114f, -0.06846920f, -0.04806207f, 0.04579806f, 0.43177792f, 
    -0.12642276f, -0.05790426f, 0.08820842f, 0.01752658f, 0.11705314f, -0.19734225f, -0.15186265f, -0.47685629f, 
    0.26413843f, -0.13427351f, 0.59185851f, -0.15951659f, 0.39597738f, -0.43260214f, 0.01767229f, 0.07845798f, 
    0.09962657f, -0.09637671f, 0.10884947f, 0.01869784f, 0.24792865f, -0.01811877f, 0.07263787f, 0.00637210f, 
    0.51923400f, -0.53886718f, -0.09488672f, -0.04252153f, 0.19219683f, 0.28136379f, 0.06592378f, 0.26618919f, 
    0.08607763f, 0.05629258f, -0.43137476f, 0.00043847f, -0.22451533f, 0.15631983f, 0.20822991f, -0.33899587f, 
    0.08112132f, -0.06735042f, -0.02094457f, 0.03775982f, 0.23724222f, -0.09641714f, 0.65770233f, -0.04996682f, 
    -0.12569004f, -0.11095681f, -0.06245837f, 0.15644310f, -0.47371301f, 0.12212896f, 0.15443452f, 0.05932393f, 
    -0.50492132f, -0.07237149f, 0.16003393f, 0.30165744f, 0.10983494f, -0.02128576f, 0.22110303f, 0.34206492f, 
    0.16362955f, 0.14234610f, -0.04704423f, -0.10975747f, -0.13616437f, -0.25768477f, 0.21427919f, 0.30860153f, 
    0.70653176f, 0.03782612f, 0.13896136f, -0.38422236f, -0.01547213f, 0.22090805f, -0.05534867f, 0.01706869f, 
    -0.31872562f, -0.43645850f, -0.13121414f, 0.19623324f, -0.10706191f, 0.16911286f, 0.07881801f, 0.07611797f, 
    0.04623872f, 0.28717759f, 0.22778948f, -0.29858166f, 0.16729644f, -0.00608127f, -0.10927060f, 0.08991494f, 
    -0.08425587f, 0.05974250f, -0.00370772f, -0.08187322f, -0.06854662f, -0.08331981f, -0.12073145f, -0.37055263f, 
    0.10753275f, 0.03480792f, -0.22788188f, 0.03105991f, 0.19433852f, -0.26146418f, 0.88496000f, -0.05209730f, 
    -0.10582232f, -0.23824394f, 0.15815055f, -0.00080548f, -0.19352522f, 0.44276509f, 0.09665774f, -0.03011108f, 
    -0.23472160f, -0.12562616f, 0.26571822f, 0.40258121f, -0.11449305f, 0.10001884f, 0.22867942f, 0.33820614f, 
    -0.34385848f, 0.26582173f, 0.04059751f, -0.48322219f, 0.20117974f, -0.25757203f, 0.27481553f, 0.36466342f, 
    0.93153268f, -0.31315678f, 0.23968698f, -0.12564275f, -0.21238711f, 0.13293742f, -0.17963980f, -0.01146570f, 
    -0.18582064f, 0.11867550f, -0.30088583f, 0.09513465f, 0.23385088f, 0.17095017f, 0.16278699f, -0.19833039f, 
    0.01722611f, -0.04687839f, 0.16177513f, -0.39181602f, 0.26738781f, 0.30277643f, -0.46835822f, 0.48718831f, 
    0.27794817f, -0.05872453f, 0.13444990f, -0.46781895f, -0.13437724f, 0.21462505f, -0.20492870f, -0.65136093f, 
    -0.14248581f, 0.08060102f, -0.00283654f, -0.03706477f, -0.18967181f, 0.01967470f, -0.34555730f, -0.14094388f, 
    0.27394348f, -0.21834782f, 0.14641316f, -0.15548861f, -0.19578242f, 0.38671950f, 0.26148739f, 0.27271321f, 
    -0.44984534f, -0.08504678f, 0.06350295f, 0.22132136f, -0.18580961f, -0.00856515f, 0.05444254f, 0.30295756f, 
    -0.13285592f, 0.17071727f, 0.35626692f, -0.11306681f, 0.31082270f, -0.02154984f, -0.46437937f, 0.24077210f, 
    0.37163365f, 0.05657045f, -0.21175270f, 0.08847693f, 0.06240100f, -0.25078452f, -0.19322544f, 0.25455838f, 
    -0.00607892f, -0.25169525f, 0.11175327f, -0.12920079f, -0.00131372f, 0.21536730f, 0.28800681f, 0.11428213f, 
    0.07386919f, -0.91453773f, -0.26753327f, 0.18137670f, 0.15557480f, 0.12811427f, -0.34559697f, 0.28733891f, 
    0.03990958f, 0.08896789f, 0.01062453f, 0.12911542f, -0.16565873f, 0.42219990f, -0.00023321f, -0.15909846f, 
    -0.09967712f, -0.05016364f, -0.10808371f, 0.03662169f, 0.08368509f, -0.08207366f, 0.01759380f, -0.05801488f, 
    0.10945497f, 0.00361645f, -0.13023819f, -0.12519209f, 0.06119139f, 0.11439666f, -0.06721959f, -0.01017007f, 
    0.03461701f, -0.10681504f, 0.02053543f, 0.03009843f, -0.06935645f, -0.12781288f, -0.00248825f, 0.00919370f, 
    0.06731983f, -0.04826080f, 0.09380663f, 0.08167513f, -0.13692595f, -0.09393238f, -0.06883761f, -0.05999066f, 
    0.06063908f, 0.07654919f, -0.03132048f, 0.09389244f, 0.03996255f, -0.08804333f, 0.09679129f, -0.06393272f, 
    -0.06197723f, -0.00152073f, -0.12516460f, -0.14049232f, -0.00159399f, 0.02030074f, 0.09004991f, -0.01006568f, 
    0.09670010f, 0.03527417f, -0.05780698f, 0.11015251f, -0.05859543f, -0.12995934f, -0.06583914f, -0.08198057f, 
    -0.03120104f, 0.03564107f, -0.05665430f, -0.09378581f, -0.07858092f, -0.03870401f, 0.07700285f, -0.11279197f, 
    0.09401612f, -0.12048089f, 0.29033160f, 0.13570255f, 0.26207185f, 0.01483068f, -0.27993521f, -0.10412578f, 
    0.18723108f, 0.13957109f, -0.05255120f, 0.31711400f, 0.33067989f, -0.11865154f, 0.49599409f, -0.10774119f, 
    0.52830690f, -0.01575381f, 0.23837774f, 0.46266252f, -0.13115844f, -0.02884466f, -0.15427947f, -0.04701224f, 
    -0.09352519f, -0.01221932f, -0.04876635f, 0.11246043f, -0.02288964f, 0.11781476f, -0.06330430f, -0.07556283f, 
    -0.11601481f, -0.03953295f, 0.30204460f, -0.00518421f, 0.42002106f, 0.10971476f, 0.25065696f, -0.08590384f, 
    0.18981093f, 0.24263848f, 0.00511448f, -0.01383325f, 0.55584037f, -0.20633775f, 0.06413179f, -0.31015190f, 
    0.21227875f, -0.53293598f, 0.13715141f, -0.05368653f, 0.10271361f, 0.31800941f, 0.06028789f, 0.31389719f, 
    -0.10022476f, -0.17747457f, -0.24593498f, 0.07822680f, 0.02693450f, 0.02749114f, 0.31550872f, -0.03342512f, 
    -0.05089176f, 0.01283764f, 0.04783976f, 0.06910451f, -0.01679954f, -0.11337873f, -0.16646169f, -0.00210857f, 
    -0.07638723f, -0.12058952f, 0.05377127f, 0.00833364f, 0.07950895f, -0.03420937f, 0.10992748f, -0.01695484f, 
    -0.08797847f, -0.08423428f, 0.00101568f, -0.13273881f, 0.07630722f, -0.00739768f, 0.02898734f, 0.07928587f, 
    -0.13722980f, -0.04847715f, -0.03880196f, -0.11478842f, 0.03315609f, -0.11897640f, -0.05657317f, -0.04113021f, 
    -0.02262462f, 0.04204558f, 0.12804355f, 0.09797224f, 0.07471945f, -0.05129325f, 0.09983527f, -0.09879775f, 
    -0.06714337f, -0.08961966f, -0.00244343f, -0.08713125f, -0.05532063f, 0.05787938f, -0.11310709f, -0.00991168f, 
    -0.20001799f, -0.11620262f, -0.09288507f, 0.01800875f, -0.03195344f, -0.12348641f, -0.05038545f, -0.04013980f, 
    -0.01915741f, 0.00440111f, -0.10213413f, 0.03052128f, 0.03098030f, -0.02487771f, -0.07739580f, -0.01249316f, 
    0.12907794f, -0.13119088f, 0.29013911f, -0.03478674f, 0.14737099f, -0.21614085f, -0.12824003f, -0.05650948f, 
    -0.07723006f, -0.08914734f, 0.03785466f, 0.13166344f, 0.19884065f, -0.43611574f, -0.11494126f, -0.34787282f, 
    1.09031928f, -0.09282883f, 0.22832395f, 0.15959154f, -0.06088902f, 0.05966037f, 0.05978158f, 0.20498885f, 
    -0.03615501f, 0.19709279f, 0.08730234f, -0.27686420f, 0.11408601f, 0.17048469f, 0.22973371f, -0.20433624f, 
    -0.58774960f, -0.05543889f, 0.36639252f, 0.07218339f, -0.08145208f, -0.04240404f, 0.29021874f, 0.10570154f, 
    -0.02840302f, 0.19871555f, -0.00812151f, 0.04613256f, 0.09564085f, 0.01752872f, 0.07006121f, -0.21812333f, 
    -0.02745729f, 0.13124487f, 0.06943945f, -0.15936358f, 0.01224146f, 0.26004988f, -0.18320006f, -0.27851975f, 
    0.04120522f, -0.04046852f, 0.06086608f, -0.14722899f, 0.04021335f, -0.42512256f, 0.10043609f, 0.21073553f, 
    0.21241957f, 0.19386218f, 0.44639477f, 0.06844174f, 0.24462533f, -0.03398518f, -0.08737180f, 0.01730508f, 
    0.17371656f, -0.01935966f, 0.08608759f, 0.16566089f, -0.05605597f, -0.61134976f, -0.04380098f, -0.56199825f, 
    0.50407422f, 0.16881557f, 0.18350540f, 0.02411330f, 0.24295425f, 0.00088489f, 0.14205126f, 0.52241296f, 
    0.16086136f, 0.10509473f, 0.17589274f, -0.05976540f, -0.39603645f, -0.01896812f, -0.09531270f, -0.12247532f, 
    -0.32263964f, 0.11614609f, 0.46669856f, -0.04969020f, 0.00979078f, -0.23525921f, 0.01848140f, 0.12183851f, 
    -0.36993343f, -0.11284605f, 0.03833529f, 0.09420657f, 0.04394600f, 0.15240344f, 0.06088730f, -0.01804849f, 
    -0.04578854f, -0.23627444f, 0.30698392f, -0.07721548f, 0.13608629f, 0.00974827f, 0.05636777f, -0.06820701f, 
    -0.11231600f, -0.20646273f, 0.10585241f, -0.05128317f, -0.05472220f, -0.15079224f, 0.10178208f, -0.08458477f, 
    0.16629218f, -0.07713705f, 0.46079737f, 0.07302117f, 0.10897148f, -0.00257894f, -0.32063341f, 0.07329443f, 
    0.03916467f, 0.07671557f, 0.06918588f, -0.17081749f, 0.22360125f, -0.57313788f, -0.22192641f, -0.28691387f, 
    0.55404133f, 0.17443259f, -0.09986864f, -0.09981874f, 0.15007783f, -0.09404457f, 0.11269075f, 0.02186837f, 
    0.14519158f, 0.17041820f, 0.12357496f, 0.12406632f, -0.07595740f, -0.13201976f, -0.18527454f, -0.38098988f, 
    -0.50109041f, 0.17201939f, 0.59727848f, 0.13771816f, -0.12177651f, -0.04714835f, 0.22291927f, 0.16241856f, 
    -0.34738880f, -0.07093202f, 0.10976544f, 0.11640889f, -0.06814115f, 0.08283639f, -0.03114913f, 0.14967926f, 
    0.20023052f, -0.41711780f, -0.01243741f, -0.07588004f, -0.09345716f, 0.05901807f, -0.01233644f, -0.08038063f, 
    -0.24234459f, -0.02493693f, 0.16024230f, 0.11599646f, -0.10913604f, 0.06068708f, -0.07818291f, -0.13793562f, 
    -0.09009431f, 0.19320689f, -0.22038750f, 0.14424908f, -0.14369021f, -0.04436406f, 0.05746448f, -0.33653122f, 
    -0.07358178f, -0.35970914f, 0.04284897f, 0.00912318f, -0.20225929f, -0.16761522f, -0.02548162f, 0.21743096f, 
    -0.03260838f, 0.12213331f, 0.15005341f, 0.27524439f, -0.28825846f, -0.06771293f, 0.23304029f, 0.04706729f, 
    0.08117421f, 0.20221439f, 0.35801151f, -0.39458832f, 0.47413167f, 0.02737170f, 0.11327433f, -0.10662702f, 
    -0.09425326f, -0.21367773f, -0.15592092f, 0.00680840f, -0.24094276f, 0.02953969f, 0.00229364f, 0.14153314f, 
    0.18321063f, -0.06481030f, 0.22498132f, 0.07556798f, -0.24388152f, 0.09390871f, 0.33528653f, -0.01738065f, 
    -0.19239712f, -0.23829649f, 0.02405819f, 0.16625391f, 0.14862084f, 0.01045886f, -0.41646731f, 0.03240508f, 
    0.35189581f, 0.09033787f, 0.23561785f, 0.10512508f, -0.01330697f, 0.71814734f, 0.00607718f, -0.31584641f, 
    0.07113171f, -0.05243161f, -0.10496861f, -0.11745588f, 0.00721661f, -0.03477633f, -0.00945631f, 0.00936148f, 
    0.06137740f, -0.01987018f, -0.12069297f, -0.04595344f, -0.03888898f, -0.07034144f, 0.05666160f, 0.08346186f, 
    -0.06417373f, -0.09926401f, 0.01266915f, -0.02237795f, -0.05836737f, 0.07150595f, -0.01332572f, 0.02514501f, 
    0.06716785f, -0.04892267f, -0.09183336f, 0.04182888f, 0.01992529f, -0.06591508f, -0.07278557f, -0.02329019f, 
    0.06333116f, 0.03316524f, -0.06970337f, -0.05808477f, -0.05790927f, -0.09293145f, 0.05089710f, -0.13743232f, 
    -0.02950303f, -0.06243289f, -0.14927632f, 0.07831533f, 0.03113243f, -0.09061864f, -0.04542739f, -0.03416104f, 
    -0.02788338f, -0.11946186f, 0.09303770f, -0.10635318f, -0.00497553f, -0.01652462f, 0.03308976f, 0.01198186f, 
    -0.11607164f, -0.05771602f, -0.02580545f, -0.12395935f, -0.07143471f, -0.10610888f, 0.08278412f, -0.03306554f, 
    -0.12281042f, -0.03420575f, -0.07097242f, -0.08999335f, -0.06665570f, -0.03980575f, 0.03057002f, -0.05366454f, 
    0.03534828f, -0.11405078f, 0.12042391f, -0.08445337f, 0.04522379f, -0.02499399f, 0.07405896f, -0.02935244f, 
    -0.10291587f, 0.00818997f, -0.09663837f, 0.09034659f, 0.03477125f, -0.08729433f, -0.01378719f, -0.03728493f, 
    0.00568376f, -0.05883693f, 0.04871497f, -0.01044034f, 0.08660545f, -0.06627170f, -0.02423900f, 0.00367115f, 
    -0.01786232f, -0.05717220f, -0.09721191f, 0.00620190f, 0.03743228f, 0.02587995f, 0.03419976f, -0.06280030f, 
    -0.01564682f, 0.07939497f, -0.08591281f, 0.09035155f, 0.08122194f, -0.01410881f, -0.04067968f, 0.07963952f, 
    0.00379393f, 0.01626985f, -0.07556085f, -0.01574552f, -0.13229467f, -0.10454856f, 0.04535387f, -0.00937288f, 
    0.00248047f, -0.03578373f, 0.08316103f, -0.11718759f, -0.06072911f, -0.11986536f, -0.08339552f, -0.08114298f, 
    0.10171612f, 0.19392648f, -0.00337551f, 0.08895648f, 0.04928520f, -0.03892645f, 0.25826547f, -0.09176107f, 
    0.07026245f, -0.15689412f, 0.12618278f, -0.26499563f, 0.02041247f, 0.10282420f, -0.02422526f, 0.11166068f, 
    -0.48792502f, 0.14521535f, 0.17314348f, 0.23690283f, 0.11257821f, -0.05444931f, 0.22322229f, 0.07403710f, 
    -0.30407977f, 0.20675167f, 0.13520557f, -0.21897738f, 0.15996206f, 0.00759647f, -0.06089473f, 0.08456013f, 
    0.24649811f, 0.01944587f, -0.37537315f, 0.15064615f, -0.15503605f, -0.40625909f, -0.17836581f, 0.29638746f, 
    -0.22155017f, -0.31736445f, 0.15813544f, 0.07597356f, -0.13315603f, 0.32475781f, 0.18174918f, 0.20555830f, 
    -0.03112641f, -1.10297751f, 0.01269875f, -0.19825527f, 0.07417285f, -0.10894635f, -0.02343947f, 0.14004235f, 
    0.21849020f, -0.05709727f, 0.08763931f, 0.13242340f, -0.12456959f, 0.22272027f, -0.14231084f, -0.44887975f, 
    0.09657127f, 0.07962182f, -0.09432756f, -0.08271660f, 0.03971239f, 0.03687472f, -0.03829025f, 0.11026564f, 
    -0.10575497f, 0.03456302f, 0.02207083f, -0.07701239f, -0.13543347f, 0.11047076f, -0.08495545f, 0.07778997f, 
    -0.04213582f, -0.01525296f, -0.12563713f, -0.07960077f, -0.09627984f, -0.10349718f, -0.01754664f, 0.06931806f, 
    0.07938951f, 0.07616290f, -0.04442140f, -0.03904469f, -0.09328748f, -0.09155227f, -0.09118586f, 0.01221205f, 
    0.08511191f, -0.05923925f, -0.06977487f, 0.02920844f, 0.06778392f, 0.07736798f, -0.05752308f, -0.12696128f, 
    0.05655959f, 0.02034327f, -0.11843736f, -0.13795148f, 0.10577099f, -0.13467669f, -0.01988501f, 0.06288239f, 
    -0.00708036f, 0.05007436f, -0.05356709f, -0.10208555f, -0.11727469f, -0.08418867f, 0.07068394f, -0.08491096f, 
    0.10681104f, -0.09041920f, 0.02956929f, 0.03331538f, 0.10851953f, 0.03438666f, 0.09882379f, -0.04152418f, 
    0.09437968f, -0.12111270f, 0.25864100f, 0.04210103f, 0.23783413f, -0.01933636f, 0.70192075f, -0.13158222f, 
    -0.12608317f, 0.26989856f, 0.00345019f, -0.30618143f, 0.20762944f, 0.99904621f, 0.10329126f, 0.45118076f, 
    -0.19691829f, 0.28733101f, 0.14044584f, -0.01145126f, 0.24292023f, -0.06244818f, 0.16724311f, -0.26799589f, 
    -0.28184503f, 0.21084967f, -0.08757193f, -0.08932181f, -0.11080499f, -0.19710886f, 0.08165528f, 0.53710049f, 
    0.44808915f, 0.04901164f, 0.18394868f, 0.02706410f, -0.21937458f, -0.14422330f, 0.08063010f, -0.08777046f, 
    -0.05291454f, -0.31989861f, -0.24917264f, 0.20284891f, 0.02549913f, 0.21866974f, 0.08279992f, 0.20420727f, 
    -0.06099468f, -0.68091124f, 0.09872222f, -0.12460089f, 0.09714540f, -0.02006296f, 0.08357996f, 0.19406757f, 
    0.11796448f, -0.06635462f, 0.07404961f, 0.28874868f, 0.10553179f, -0.34835321f, -0.16778523f, -0.23010240f, 
    0.29010567f, -0.04541824f, 0.34696588f, 0.04306290f, 0.29444695f, 0.12053457f, -0.45508736f, -0.07493214f, 
    0.15641622f, 0.07610381f, -0.13765346f, 0.11418431f, 0.05235430f, -0.31059107f, 0.29190397f, -0.23094474f, 
    0.54264313f, 0.07160735f, 0.14622939f, 0.13547194f, 0.10090909f, -0.07130951f, 0.16547851f, -0.03964144f, 
    -0.20996337f, 0.08027975f, 0.21115060f, -0.14158720f, -0.13726817f, -0.24061713f, -0.34255663f, -0.33398411f, 
    -0.40302524f, -0.15063129f, 0.33840376f, 0.06690995f, 0.43999898f, -0.09896866f, 0.23619148f, -0.04955481f, 
    -0.22919275f, -0.33200964f, 0.07298811f, 0.13339362f, -0.10056817f, 0.00982596f, 0.23655041f, 0.19331548f, 
    0.57096189f, -0.51088744f, 0.11242616f, 0.07550180f, 0.20535910f, 0.38535005f, -0.14532577f, 0.08405784f, 
    -0.00794291f, -0.20336190f, 0.08461613f, -0.08558294f, 0.02671353f, -0.06569645f, 0.07265440f, -0.23415603f, 
    -0.02813951f, -0.07977338f, -0.00559614f, -0.07539788f, -0.14729401f, -0.04007524f, 0.03829342f, -0.02619199f, 
    -0.01880767f, -0.04737110f, 0.05278148f, -0.00829980f, -0.14426316f, 0.28170326f, -0.06474683f, 0.07600967f, 
    0.11406700f, -0.11061820f, -0.10329209f, 0.02682595f, 0.07877623f, 0.10542773f, -0.02666228f, -0.01260294f, 
    -0.15853013f, 0.01215423f, -0.16674891f, 0.01477731f, 0.01472615f, -0.12465530f, 0.11136564f, 0.11817537f, 
    0.00783176f, 0.07778923f, 0.15948685f, -0.12775515f, 0.05694542f, 0.15659398f, 0.02381728f, -0.00025917f, 
    0.06925467f, -0.00754480f, -0.11524997f, -0.14706795f, -0.16992369f, -0.13639483f, -0.00142808f, 0.08070620f, 
    0.04376067f, 0.15044910f, 0.03377759f, -0.01811074f, -0.04087089f, -0.02383590f, 0.00024079f, 0.01254019f, 
    -0.11348537f, -0.07566763f, -0.07166339f, 0.00695820f, -0.16466591f, -0.05295117f, 0.07238664f, 0.01476990f, 
    0.08367141f, 0.05986845f, -0.21253672f, -0.00359576f, 0.15993974f, 0.39697415f, 0.74772120f, -0.10987754f, 
    0.01811415f, -0.03376063f, 0.04453416f, -0.22529194f, -0.18610209f, 0.36711180f, -0.12097306f, 0.27984580f, 
    -0.35655120f, 0.44551596f, 0.22631362f, 0.17760158f, 0.30047572f, 0.10761638f, 0.14585841f, -0.18902478f, 
    0.18676344f, 0.05863714f, 0.08665861f, -0.07677183f, -0.08179121f, -0.02107461f, 0.05276323f, 0.02966359f, 
    0.65408868f, 0.06591976f, -0.56883353f, 0.17350727f, -0.13094269f, 0.18963641f, 0.01429819f, 0.10058102f, 
    -0.05923889f, -0.45883372f, 0.02048696f, 0.19079842f, -0.40986213f, 0.60125834f, 0.00571176f, 0.66789758f, 
    -0.00671186f, 0.16209146f, 0.28469312f, -0.00003696f, 0.13325869f, -0.11125450f, 0.09385220f, -0.15517178f, 
    0.17077136f, 0.06357253f, 0.48172385f, 0.34094283f, 0.28814816f, 0.18517171f, -0.23439071f, 0.08851922f, 
    -0.19831175f, 0.25065804f, 0.34547392f, -0.21685882f, 0.34300852f, 0.22872144f, 0.00549594f, -0.13369338f, 
    0.23080145f, 0.03974247f, 0.12238707f, -0.23049203f, 0.33984086f, -0.12031571f, 0.23099367f, -0.08105474f, 
    -0.34364134f, 0.17393650f, 0.04550534f, -0.16922911f, 0.02830097f, -0.08525308f, -0.15365274f, -0.50605279f, 
    0.13455430f, -0.15466309f, -0.19369155f, -0.02140446f, -0.15569995f, 0.23902883f, 0.10455408f, -0.24780037f, 
    0.28986174f, 0.24134523f, 0.05343790f, 0.25227475f, 0.05212981f, -0.05429829f, 0.10022540f, -0.25337133f, 
    0.12705906f, 0.46191785f, -0.55941963f, -0.20987774f, 0.49877614f, 0.10204241f, -0.20456551f, 0.16378242f, 
    0.17392325f, 0.08535549f, 0.46417645f, 0.05562014f, 0.11685843f, -0.05494360f, 0.02614931f, 0.17897128f, 
    0.09030882f, -0.54724860f, 0.10225070f, 0.21216334f, 0.14797948f, 0.22044787f, 0.04443591f, 0.36093837f, 
    0.16196387f, 0.28991529f, 0.28465125f, -0.02454697f, 0.12366395f, 0.13705359f, 0.32069784f, 0.01480108f, 
    0.05102532f, 0.31635007f, -0.03821270f, -0.19022778f, 0.13858692f, 0.06284703f, -0.03110425f, -0.50243437f, 
    0.39557731f, 0.27664906f, 0.13910794f, 0.17103373f, 0.32742384f, 0.11958658f, 0.11869811f, 0.25448945f, 
    -0.16554426f, 0.12066532f, 0.01494289f, 0.07785885f, -0.51028270f, -0.00458396f, -0.05037671f, -0.59942955f, 
    -0.05918756f, 0.17576484f, -0.04916596f, 0.14630078f, 0.00340338f, -0.05513464f, 0.17349860f, 0.12632187f, 
    -0.09425011f, -0.10839256f, -0.04910156f, 0.30718055f, -0.09466380f, -0.03547549f, 0.07116150f, 0.17463027f, 
    -0.29262543f, -0.72233129f, 0.37738606f, -0.04853547f, 0.07186309f, -0.03000114f, 0.11681452f, -0.00387256f, 
    0.04780588f, -0.18283957f, 0.20675912f, -0.05156942f, 0.04228177f, -0.11389329f, 0.05421926f, -0.00334094f, 
    0.11949795f, 0.08045931f, -0.15782559f, 0.18371499f, -0.05857034f, -0.20609716f, -0.16107050f, 0.08871585f, 
    -0.27312478f, -0.17535326f, 0.06600127f, 0.15104963f, -0.00046399f, 0.08295979f, -0.09091319f, 0.13519248f, 
    0.47657412f, -0.01529663f, 0.06043676f, -0.03255263f, -0.26666096f, 0.06932452f, 0.05716918f, 0.13733034f, 
    0.05823071f, 0.17412247f, 0.06830493f, -0.14204679f, 0.25452816f, 0.13424568f, 0.31224245f, -0.29041612f, 
    -0.44183612f, -0.08865410f, 0.46880871f, 0.06226882f, -0.02618512f, -0.08013508f, -0.07300916f, 0.24024206f, 
    0.25641280f, -0.00935962f, 0.13288546f, 0.16613191f, -0.04228299f, 0.01311414f, 0.16510127f, -0.18308680f, 
    -0.08032009f, -0.22100461f, -0.12115122f, 0.15921119f, 0.09668098f, 0.25236413f, -0.22184081f, -0.03818846f, 
    0.28637716f, 0.30296266f, 0.10398120f, -0.03377547f, 0.16173624f, 0.30988669f, 0.14261061f, -0.21142037f, 
    0.13035509f, -0.29873750f, 0.26889554f, 0.10175633f, 0.33666611f, -0.15637171f, -0.02718514f, -0.00765137f, 
    0.17936200f, 0.13999179f, 0.16302885f, 0.06635929f, 0.05292063f, -0.35523087f, 0.07862926f, -0.35061026f, 
    0.58159149f, 0.01477568f, 0.17569548f, 0.08505552f, 0.02732851f, 0.02273315f, -0.16942112f, 0.30834809f, 
    0.12847905f, -0.21301071f, -0.07756645f, 0.08723600f, -0.21183598f, 0.13700086f, -0.01956095f, 0.10436581f, 
    -0.08016477f, -0.10613768f, 0.42599559f, -0.00842213f, 0.07326421f, 0.08827283f, 0.20825721f, -0.24168089f, 
    0.05860934f, 0.32002831f, -0.33840781f, 0.06536113f, 0.29154044f, 0.08345135f, -0.16433424f, -0.24470991f, 
    0.22785871f, 0.75002414f, 0.20508993f, -0.12923577f, -0.03468172f, 0.26141283f, 0.10451680f, 0.12702774f, 
    -0.00112616f, -0.09378349f, -0.18282565f, -0.29296511f, -0.07223133f, -0.54195172f, 0.10435814f, 0.31859091f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07941062f, -0.23608582f, -0.14664838f, -0.13120173f, -0.10903615f, -0.31976742f, 0.31537274f, 0.19224176f, 
    -0.08213679f, 0.34016505f, 0.12891969f, 0.18196858f, 0.19204538f, -0.09583674f, 0.12686831f, -0.04381141f, 
    0.11222433f, -0.04887767f, -0.02963109f, -0.08126559f, 0.29125088f, 0.19506513f, 0.45710829f, -0.09452352f, 
    -0.30897191f, 0.02481743f, -0.13169692f, 0.24669436f, 0.34067711f, 0.05574188f, 0.21816505f, 0.08723430f, 
    0.20484421f, -0.11953509f, 0.28254834f, 0.13270806f, 0.12698290f, 0.08178859f, 0.28182316f, 0.12689777f, 
    -0.02845367f, 0.20308851f, -0.00954985f, -0.18434782f, -0.07266674f, -0.07863497f, 0.30157474f, -0.08084725f, 
    0.58434284f, 0.40051600f, 0.52605563f, -0.25097352f, 0.00190849f, 0.00084510f, 0.12010771f, -0.09654973f, 
    -0.06318919f, 0.55035937f, -0.08258925f, 0.05030915f, 0.29719201f, -0.10480344f, -0.05518045f, 0.26452887f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.15798314f, 0.30513376f, -0.01199873f, -0.04217755f, -0.08624242f, 0.21305542f, -0.54637879f, -0.35568529f, 
    0.01803609f, 0.77181607f, 0.03049723f, 0.15555418f, -0.50038725f, -0.08461604f, -0.35365748f, 0.02969861f, 
    0.14022201f, -0.03343523f, -0.46122631f, 0.11439795f, -0.27529019f, -0.46204871f, -0.96363539f, 0.19479276f, 
    -0.64048827f, 0.01305678f, 0.37422633f, -0.00256742f, -0.14996815f, -0.10759395f, 0.18633509f, 0.18673733f, 
    0.12627655f, 0.04983336f, -0.03068165f, -0.64082009f, 0.06895364f, -0.09086528f, 0.24065752f, -0.03917120f, 
    -0.03489647f, 0.28791094f, -0.07842688f, 0.63187772f, -0.17258039f, -0.06453755f, -0.22124130f, -0.00911823f, 
    -0.41366541f, -0.35116872f, -0.27747032f, 0.18439613f, -0.07101131f, -0.00699057f, -0.19390129f, -0.04211603f, 
    -0.18139598f, -0.46203300f, -0.10113602f, 0.11087772f, -0.01533722f, -0.12093988f, -0.05093497f, -0.20490420f, 
    0.34180498f, -1.04496682f, 0.08726298f, -0.08077932f, -0.09852113f, -0.09528987f, 0.11859474f, -0.19072983f, 
    -0.05020571f, -0.19156384f, -0.20805284f, 0.01891762f, -0.28656831f, 0.02343908f, -0.04419410f, -0.01598002f, 
    0.08549640f, -0.57611322f, -0.19753550f, 0.31645867f, 0.03085924f, -0.23460235f, 0.43251440f, -0.03182734f, 
    0.03912913f, -0.01734256f, 0.12803641f, 0.08386716f, 0.06216560f, 0.07353406f, 0.19312768f, 0.21135511f, 
    0.03816134f, -0.14485683f, 0.01557425f, 0.02870890f, 0.25820360f, 0.08638301f, -0.51335752f, -0.25643110f, 
    0.25892165f, 0.09813362f, -0.34520483f, -0.80110794f, 0.01045845f, -0.06542209f, -0.14078543f, 0.04407447f, 
    0.16603309f, 0.10828464f, 0.22437000f, 0.12747815f, 0.04010591f, -0.05853681f, 0.02241018f, 0.09430535f, 
    -0.20808327f, -0.02730834f, -0.18191032f, 0.05578852f, 0.02315631f, -0.05780870f, 0.12297127f, -0.05398829f, 
    -0.50774837f, -0.43986988f, -0.14927450f, -0.13585916f, -0.11313284f, 0.05106823f, 0.17526370f, 0.27913705f, 
    0.03546281f, 0.19095902f, 0.29196396f, -0.13619177f, 0.08984648f, 0.00926070f, 0.22188810f, 0.09822828f, 
    0.00889621f, -0.65561789f, 0.18144451f, -0.68998939f, 0.56022203f, 0.18326277f, -0.59924763f, -0.27489361f, 
    -0.02233701f, 0.02562225f, -0.49891225f, 0.20042090f, -0.00628902f, 0.06985857f, -0.04503997f, -0.74052167f, 
    -0.28534430f, -0.12264886f, 0.07924543f, -0.91082788f, 0.21042654f, -0.05916400f, 0.40122968f, 0.14327939f, 
    0.11587334f, -0.09311939f, -0.45418298f, 0.11298838f, -0.24214756f, -0.01072577f, 0.30161884f, 0.04857615f, 
    0.21326183f, -0.23942716f, -0.04711781f, -0.17329390f, -0.06292336f, 0.01197082f, -0.16315396f, -0.13220553f, 
    -0.19927041f, 0.00305748f, 0.02136283f, -0.39552972f, 0.00408702f, -0.25958294f, 0.12662904f, 0.29013318f, 
    0.10847552f, 0.04535655f, -0.42115885f, 0.02462598f, -0.07565415f, -0.21140924f, -0.00376876f, 0.02892557f, 
    -0.07815191f, -0.42116138f, 0.05316916f, 0.08852773f, 0.18446754f, 0.00440063f, -0.44281155f, -0.11928525f, 
    0.23927908f, 0.15809812f, -0.03745829f, 0.01199070f, -0.10323977f, -0.16031986f, 0.29641712f, -0.12130443f, 
    -0.28385857f, 0.09344833f, -0.42717499f, -0.02074458f, -1.13734591f, 0.01598483f, 0.04346231f, 0.21880126f, 
    0.15258841f, 0.01979556f, 0.06170355f, 0.16785735f, 0.06064229f, -0.51801908f, 0.25860029f, 0.17292716f, 
    -0.42442515f, -0.73259729f, 0.18651578f, -0.05774252f, -0.70024109f, -0.12864712f, 0.05710074f, -0.16573383f, 
    0.09800671f, 0.06421344f, 0.01733642f, -0.62139940f, -0.02040613f, -0.11705437f, -0.29272437f, -0.10271025f, 
    0.06352290f, -0.22861475f, -0.01148207f, 0.03524804f, 0.24697879f, 0.15896820f, -0.53490794f, 0.52644557f, 
    0.09486707f, 0.16949095f, -0.19399373f, 0.00646115f, -0.03066502f, -0.11706067f, -0.54717040f, 0.01140401f, 
    0.06943411f, -0.56242639f, 0.18745126f, 0.17098223f, -0.07350508f, 0.05599372f, 0.01889504f, -0.10820437f, 
    -0.11693769f, -0.16984390f, 0.08504206f, 0.00905721f, -0.87594485f, 0.20130469f, -0.91870248f, 0.24409193f, 
    0.24516855f, 0.04659282f, -0.14205047f, 0.05640949f, -0.22566228f, -0.03681184f, 0.13924854f, -0.06769868f, 
    0.06138756f, -0.09596402f, 0.18253744f, -0.33763793f, -0.65489346f, -0.16602866f, -0.85453433f, 0.01668064f, 
    0.14264058f, 0.01532930f, -0.25974360f, -0.22107440f, 0.32551041f, -0.00599572f, 0.11969335f, -0.02227657f, 
    -0.52015150f, -0.01938450f, -0.12691827f, 0.03198593f, 0.12705541f, -0.08468553f, 0.10946991f, -0.02957798f, 
    0.04162235f, 0.02801417f, -0.03755336f, 0.07828754f, 0.19802953f, 0.17945048f, -0.21016361f, -0.23300746f, 
    0.06304708f, 0.08952678f, 0.13538969f, -0.09796658f, 0.03602102f, 0.05322881f, 0.22302870f, 0.02227571f, 
    -0.04410094f, -0.72287858f, 0.01523892f, -0.03966809f, 0.01854292f, 0.11282156f, 0.16154352f, -0.03456410f, 
    0.12102560f, -0.02853353f, 0.13014574f, 0.04392805f, 0.24137874f, -0.12189341f, -0.06732466f, 0.03858741f, 
    0.17642966f, 0.06622686f, -0.04944985f, 0.06158395f, -0.05152171f, -0.02448227f, 0.09717742f, -0.04947830f, 
    0.03272844f, 0.03001383f, 0.11290155f, 0.07233636f, 0.10058421f, 0.18837516f, -0.05311943f, -0.15292029f, 
    -0.69648606f, -0.17208512f, -0.25977477f, -0.22786270f, 0.16786359f, -0.04839942f, 0.10712548f, -0.03551687f, 
    0.06007045f, -0.18340920f, -0.09637139f, 0.10482850f, -0.00067942f, 0.07430468f, 0.02835812f, -0.00961712f, 
    0.11854287f, -0.01926994f, -0.01779040f, 0.02340769f, -0.10274553f, 0.09767967f, 0.04059631f, -0.40139785f, 
    -0.21130972f, -0.63250393f, -0.37253946f, -0.06145459f, -0.13570920f, -0.36512619f, 0.06770755f, 0.29910457f, 
    -0.11718546f, 0.11678574f, 0.31809476f, -0.80368847f, 0.20996700f, -0.03519702f, 0.11753413f, -0.08497635f, 
    -1.00110614f, -0.67127198f, 0.30209008f, -0.05460162f, -0.32930088f, 0.16628335f, 0.08508807f, -0.35343251f, 
    -0.31015298f, 0.05737337f, 0.04109096f, -0.15862657f, 0.34815228f, 0.02767183f, -0.45121986f, -0.38527474f, 
    -1.46493018f, 0.06692857f, -0.04116486f, -0.01408659f, 0.04580257f, -0.61044163f, 0.32299942f, 0.33743790f, 
    -0.00973444f, 0.21691456f, 0.07388780f, -0.18893242f, 0.13439947f, -0.11900575f, 0.25504181f, -0.13624837f, 
    0.19868430f, 0.10290380f, -0.12363475f, -0.08966529f, 0.05112430f, -0.02982289f, -0.46970171f, -0.09927587f, 
    -0.95653623f, 0.14508766f, -0.06879963f, -0.79299301f, -0.82022238f, -0.45957977f, 0.10552080f, 0.34930709f, 
    -0.24265878f, -0.34163785f, 0.20657198f, -0.04072608f, 0.03188984f, 0.42173454f, -0.67357606f, -0.01947309f, 
    -0.10462825f, 0.19195843f, -0.73915064f, -0.54824734f, 0.05307645f, -0.00394386f, 0.07339485f, -0.00132911f, 
    -0.21621326f, 0.39800850f, -0.14435390f, -0.15274243f, -0.24334688f, -0.26766732f, 0.10815530f, 0.04708251f, 
    0.15396199f, 0.09377326f, -0.59759760f, 0.08545290f, 0.04678461f, -0.06761539f, -0.06719178f, -0.05484778f, 
    -0.16618565f, 0.05004049f, -0.50196218f, 0.09562205f, -0.05414342f, 0.30848345f, -0.16477320f, -0.21460566f, 
    0.01746697f, -0.13288364f, 0.22671628f, 0.42579335f, 0.15056992f, -0.09147402f, -0.47436407f, -0.04800389f, 
    -0.79997796f, -0.38118041f, -0.16668674f, -0.03009574f, -0.03029157f, 0.08130199f, 0.15948941f, 0.03535736f, 
    0.37415105f, -0.72729778f, 0.12085903f, 0.18058199f, -0.90734535f, -0.72418261f, -0.02724452f, -0.50721985f, 
    -0.67304164f, -0.29440165f, 0.37789229f, -0.07358079f, -0.03675555f, 0.17907509f, 0.44357622f, -0.27306953f, 
    -0.03344725f, 0.14997654f, -0.96635044f, 0.07089370f, 0.07710715f, 0.00630242f, -0.24291757f, -0.05042319f, 
    0.19306651f, 0.12843144f, -0.56246221f, -0.39179528f, 0.47005653f, -0.45012969f, 0.13302302f, 0.02400248f, 
    -0.49443626f, -0.11551128f, 0.03080730f, 0.02162299f, -0.10635834f, 0.07646962f, 0.21554253f, -0.77343738f, 
    -0.27804536f, 0.07282329f, -0.32611981f, -0.23807786f, 0.38359001f, 0.27345809f, -0.35481375f, -0.36449531f, 
    0.06575422f, -0.24840540f, 0.20165025f, 0.12376533f, -0.03144176f, -0.07452964f, -0.15363792f, 0.04139106f, 
    0.06208777f, -0.17611288f, -0.38915396f, 0.27940598f, 0.05367748f, -0.01952217f, 0.13490389f, -0.01680295f, 
    0.12694968f, -0.03045527f, -0.15481365f, 0.19915485f, -0.71767795f, -0.20476310f, 0.21550222f, -0.03346378f, 
    -0.40875942f, -0.35473159f, -0.42256811f, 0.05537844f, -0.09185357f, -0.58089000f, -0.65296769f, 0.17062682f, 
    0.06027221f, 0.26603499f, 0.24440950f, -0.12874447f, 0.02906167f, -0.08327729f, 0.25486961f, -0.10447698f, 
    -0.41551903f, 0.04385965f, -0.07014934f, -0.29541287f, -0.68761957f, 0.19387886f, -0.10392752f, 0.08024065f, 
    -0.20178930f, -0.10242601f, -0.10142109f, -0.10028981f, 0.02015692f, 0.05105942f, -0.11372822f, -0.28599936f, 
    -0.04444117f, 0.06862018f, 0.02615897f, 0.21689473f, -1.00312483f, -0.12379938f, -0.07171578f, 0.18355030f, 
    -0.47475189f, 0.20498770f, 0.05264758f, -0.22188425f, 0.19332774f, 0.05695856f, 0.21249501f, -0.08403311f, 
    -0.04851060f, 0.08224184f, 0.06869046f, -0.06464625f, -0.04697638f, -0.00136475f, 0.09881850f, -0.08851476f, 
    0.04343939f, 0.21533607f, -0.09944381f, -0.02054773f, 0.08273342f, -0.21001026f, -0.14878075f, 0.08154203f, 
    -0.47929057f, -0.05856065f, -0.24741685f, 0.11819749f, -0.09385132f, -0.63472581f, 0.10047490f, -0.28455707f, 
    0.11018461f, -0.49557868f, -0.55119610f, 0.13530302f, -0.16615973f, -0.12065449f, 0.01954734f, -0.03215140f, 
    0.21563980f, 0.44386339f, 0.36514989f, 0.31125867f, 0.07636426f, -0.22473453f, -0.68808800f, 0.24028544f, 
    -0.98364294f, -0.13807362f, -0.03053388f, -0.83671099f, -0.26589388f, -0.06363588f, 0.01937809f, -0.14810193f, 
    0.00105024f, -0.03895985f, 0.12723069f, -0.35603130f, -0.26234657f, 0.18240190f, 0.27497920f, -0.34213161f, 
    -0.45204911f, -0.16492227f, -0.21209057f, -0.47149208f, -0.02892033f, -0.09633113f, -0.20987898f, -0.12009378f, 
    0.10082310f, 0.33793393f, 0.47240874f, -0.08392420f, -0.06076840f, 0.03560505f, 0.18459438f, 0.07823429f, 
    0.18837653f, 0.36012417f, 0.01581436f, 0.11830375f, -0.32330364f, 0.28991824f, -0.11362178f, 0.02390641f, 
    -0.39033890f, -0.44791445f, 0.00066910f, -0.13047636f, -0.10569663f, -0.21611741f, 0.26222450f, -0.04173899f, 
    0.06205573f, -0.04170587f, 0.12002283f, -0.03043328f, -0.04448179f, -0.10779738f, -0.29261804f, -0.11230987f, 
    -0.06687769f, 0.12804732f, 0.06183144f, -0.25244042f, 0.18980667f, -0.16962595f, 0.01139533f, -0.06412628f, 
    0.37515792f, -0.02011107f, 0.48826760f, -0.38405424f, 0.14139429f, -0.03911752f, -0.42420015f, -1.11163962f, 
    -0.35143739f, 0.01278308f, -0.28686446f, 0.32600373f, 0.20922104f, -0.12345519f, 0.26735342f, 0.00616827f, 
    -0.24755104f, 0.02244985f, 0.19724001f, 0.42328873f, 0.11377858f, -0.09622517f, -0.11643255f, 0.03482563f, 
    0.08421846f, 0.27163401f, -0.28228387f, 0.17096347f, 0.05948137f, 0.10782055f, 0.23113762f, 0.04070649f, 
    -0.23548932f, -0.10256450f, 0.02113383f, -0.09223618f, 0.02540767f, 0.28707689f, 0.06894039f, 0.02159794f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.27221540f, 0.27534470f, 0.04183712f, 0.14521752f, -0.03786995f, -0.12894800f, -0.10321234f, -0.06645307f, 
    -0.10168844f, 0.42025694f, -0.05396549f, -0.37688687f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
