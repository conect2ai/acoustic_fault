#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.07443753f, 0.88954109f, -0.13713761f, -0.16882011f, 0.87287641f, -0.23052719f, -0.07544988f, 0.39706388f, 
    0.17435400f, 0.43387890f, 0.28730059f, -0.43494436f, -0.24630733f, -0.36331791f, 0.21589532f, 0.28009772f, 
    0.35580200f, 0.25397003f, 0.37869003f, 0.07639556f, -0.16148695f, 0.05251518f, -0.03670093f, 0.01030515f, 
    -0.00924729f, 0.29535049f, -1.34065187f, -0.14382225f, 0.78038913f, 0.45954582f, -0.68623257f, 0.79125583f, 
    0.44105554f, -0.66121143f, -0.09786221f, 0.36659494f, 0.20737645f, -0.08664870f, -0.28989941f, 0.03298509f, 
    -0.34131432f, 0.02595818f, -0.20901047f, 0.00966080f, -0.37392327f, 0.01754747f, 0.01550242f, 0.00689714f, 
    0.02289434f, 0.21106054f, -0.37524441f, -0.86768484f, -0.52251303f, -0.11196448f, -0.46626714f, 0.12756926f, 
    0.63664281f, 0.43590200f, 0.48327637f, 0.26698413f, 0.32335022f, -0.03633792f, -0.15858312f, 0.05191523f, 
    -0.08185295f, -0.13109694f, 0.18212152f, 0.04843793f, -0.00979198f, 0.00563291f, -0.02510776f, -0.23966816f, 
    0.36032763f, -0.32168734f, 0.22046244f, 0.08797158f, 0.85547006f, 0.68225396f, 0.43915698f, 0.41648507f, 
    0.66871345f, -0.04192958f, -0.94368482f, 0.25589854f, -0.37347800f, 0.07578517f, -0.11514425f, -0.16191763f, 
    0.10732760f, -0.42244387f, -0.12264402f, 0.12711054f, -0.16352783f, -0.16902998f, -0.14270550f, -0.00162646f, 
    0.28236553f, 0.07999152f, -0.03106055f, -0.14398076f, 0.06619272f, 0.40193152f, -0.69578665f, 0.67901534f, 
    0.13659319f, -0.30601180f, 0.19307549f, -0.89520460f, -0.17888772f, -0.23137245f, 0.35282531f, -0.06594703f, 
    -0.33920148f, 0.18838152f, -0.26569387f, -0.19186249f, 0.15039198f, -0.07370275f, -0.05932166f, -0.14948279f, 
    -0.12663773f, 0.22595099f, -0.22785680f, 0.05095708f, 0.17713536f, 0.95218217f, -0.70883489f, -0.23351102f, 
    -0.94514883f, 0.68413246f, 0.53622043f, -0.64306420f, 0.58468372f, 0.26561195f, 0.10382039f, -0.40191993f, 
    0.16720474f, -0.22567728f, 0.04543984f, 0.00667079f, -0.00880176f, -0.15233888f, 0.21853280f, 0.16196610f, 
    0.08150612f, 0.01333837f, 0.07784025f, -0.05261965f, -0.07371347f, -0.20896722f, -1.10105729f, 0.69171458f, 
    0.18494923f, -0.20452525f, 0.16458155f, 0.35899091f, 0.73168403f, 0.46155292f, 0.51301914f, 0.45453504f, 
    -0.22502761f, -0.31074959f, -0.31359902f, -0.14378347f, 0.01280131f, 0.09956656f, -0.11831545f, -0.11187875f, 
    0.13403185f, 0.08662622f, -0.00480422f, 0.14235440f, -0.09694712f, -0.17625679f, -0.20829077f, -0.30805317f, 
    -0.75815719f, -0.61818427f, -0.35471582f, -0.18002693f, 0.43219215f, 0.92700475f, -0.41688854f, 0.10168237f, 
    0.56711882f, -0.00908609f, -0.10588931f, -0.05565419f, 0.04145069f, 0.19366597f, -0.13109128f, 0.29838645f, 
    0.12364714f, 0.11512967f, -0.11246727f, -0.09653760f, 0.04648125f, -0.04829071f, -0.25613809f, 0.17028341f, 
    0.80278540f, 0.02468051f, 0.24785787f, 0.78895187f, 0.99093252f, 0.12344782f, 0.39247680f, 0.19575523f, 
    0.25037459f, 0.34831744f, -0.04461149f, 0.29732051f, -0.37042961f, 0.30352056f, -0.12426265f, -0.21220335f, 
    -0.32451901f, -0.07326946f, -0.00864506f, -0.32182851f, -0.04511318f, -0.09670921f, -0.06120769f, -0.22022332f, 
    0.04070836f, -0.20636342f, 0.47689408f, 0.73470199f, -0.65871984f, -0.30503091f, -0.38244730f, 0.33730322f, 
    0.30643690f, 0.11677348f, -0.15450531f, -0.26916710f, 0.13724661f, 0.07221357f, -0.02294699f, 0.20668525f, 
    0.26309821f, 0.16524331f, 0.46194103f, 0.19040535f, 0.24223401f, 0.18605383f, 0.54096347f, -0.31834558f, 
    -0.03542477f, 0.17525895f, -0.37819958f, 0.88980651f, -0.77120441f, 0.82742375f, -0.77490628f, 0.15811566f, 
    -0.16726153f, -0.49286208f, 0.23839271f, -0.25948963f, -0.03201658f, 0.28604290f, -0.31872323f, -0.15787195f, 
    -0.01293222f, 0.01039352f, 0.06980791f, 0.14272131f, 0.14258572f, 0.09953377f, 0.10316473f, -0.33015108f, 
    -0.07895806f, -0.26341814f, -0.11223695f, -0.33307654f, -0.66271484f, -0.31844503f, 0.17248265f, 0.27830163f, 
    -0.04524856f, 0.47871149f, 0.61266941f, 0.26727459f, 0.29899970f, -0.35286674f, -0.34701672f, -0.35376826f, 
    -0.38623783f, -0.15950428f, -0.04026677f, -0.41813654f, 0.03304432f, -0.04091478f, -0.16461617f, -0.39116511f, 
    0.17343242f, -0.02378730f, -0.00230282f, -0.00068154f, 0.74815887f, -0.11195572f, 0.60543406f, 0.37554702f, 
    -0.51610696f, 0.35061201f, -0.72670299f, -0.70436066f, 0.07187609f, -0.02386654f, 0.29815924f, 0.30459389f, 
    -0.09519390f, 0.11732972f, 0.06004802f, 0.16189688f, -0.01373164f, 0.22929613f, -0.33725783f, 0.37512684f, 
    -0.01572592f, 0.15454909f, -0.09557140f, -0.19650878f, 0.40355927f, -0.14409907f, -0.61643982f, -0.13420554f, 
    0.26860338f, -0.56079525f, -0.67012596f, 0.17822874f, 0.34042874f, -0.49863547f, -0.16879754f, -0.23974901f, 
    0.36879402f, -0.17133477f, 0.07477669f, -0.28374583f, -0.68213910f, -0.11833899f, 0.28307343f, 0.08730786f, 
    -0.21657252f, 0.17128837f, -0.13969512f, -0.25549725f, 0.06367242f, 0.18628351f, -0.39836809f, -0.16741492f, 
    -0.32936335f, -0.22047433f, -0.36389932f, -0.36033189f, -0.60840958f, -0.06520653f, 0.52420032f, -0.54825741f, 
    0.36570781f, 0.05064578f, 0.17312509f, 0.62915808f, 0.00927910f, -0.49936512f, -0.41512600f, 0.03305684f, 
    -0.31055629f, 0.14479029f, 0.33740169f, -0.12013228f, -0.16606869f, -0.07327151f, -0.20144150f, -1.25380731f, 
    0.31853032f, 0.00823850f, -0.66593385f, -0.65736878f, 0.25072592f, 0.30954319f, -0.47583023f, 0.20962250f, 
    -0.02937587f, -0.15070271f, 0.34685761f, -0.17199215f, 0.26168969f, 0.25063342f, 0.07287210f, 0.00584748f, 
    -0.22687091f, -0.00169360f, -0.21446081f, -0.20443745f, -0.38759917f, 0.03213185f, -0.16644800f, -0.25271276f, 
    0.89717323f, 0.45962518f, 0.76545060f, -0.28884700f, -0.69512004f, 0.18492961f, -0.63784003f, 0.37214464f, 
    0.32834432f, 0.49970123f, 0.43209583f, 0.04118564f, -0.21779011f, -0.28727952f, 0.07319148f, 0.03168786f, 
    0.09752905f, -0.12731387f, -0.10791264f, 0.12682666f, 0.39324531f, 0.16881119f, 0.14386688f, -0.02949044f, 
    0.06262293f, 0.04567597f, 0.36094818f, 0.69781566f, 0.64374626f, -0.67510247f, -0.05528422f, 0.40352398f, 
    0.28415108f, 0.34005100f, -0.13696076f, 0.33377686f, 0.08530871f, 0.12943657f, -0.00540487f, -0.13040864f, 
    0.14237522f, 0.33438346f, 0.20023268f, -0.09586835f, 0.12481146f, -0.17238659f, -0.03260120f, -0.26327223f, 
    -0.01708851f, -0.23982027f, 0.80159080f, 0.12544158f, -0.52918756f, -0.66123301f, -0.60152620f, 0.37069759f, 
    -0.03803718f, 0.15653276f, -0.04963041f, -0.00248273f, -0.29700494f, 0.25611374f, -0.37872785f, 0.02186292f, 
    -0.16879372f, -0.03080673f, -0.21709910f, -0.38007709f, -0.11303250f, -0.24838011f, 0.00543413f, -0.10440896f, 
    0.20494130f, 0.00206660f, 0.09260112f, 0.04830594f, -0.31753331f, -0.12995246f, 0.69130391f, 0.64041883f, 
    -0.92026389f, -0.57958180f, -0.34573343f, -0.45808831f, -0.03030498f, 0.12500556f, 0.52133888f, 0.20876424f, 
    0.08767166f, -0.20139317f, 0.01921521f, -0.22453791f, 0.01461799f, 0.00859870f, -0.22477534f, -0.29402384f, 
    0.15763269f, -0.00117273f, 0.16872358f, -0.20026366f, -0.70155442f, -0.56900305f, -0.04449218f, -0.40151879f, 
    0.42133546f, -0.15769772f, 0.44394821f, 0.29449674f, -0.04506505f, 0.44641453f, -0.10583267f, 0.13151950f, 
    -0.20390067f, -0.14644943f, -0.07844684f, 0.21248920f, 0.09244436f, -0.03669934f, 0.12763363f, 0.18548042f, 
    0.14256120f, -0.19212684f, 0.26542544f, 0.07558940f, 0.02628998f, -0.36310866f, -0.76825655f, -0.79793328f, 
    -0.30569020f, 0.06866470f, -0.79521024f, 0.24934205f, 0.42248783f, -0.48977649f, 0.35057381f, 0.17977072f, 
    -0.02652907f, -0.08085625f, -0.39440686f, 0.35312933f, 0.16892785f, 0.22453448f, -0.00391548f, 0.11216814f, 
    -0.16256478f, -0.10029463f, -0.06822053f, -0.06086629f, 0.00964645f, 0.03378603f, 0.83916885f, 0.62059855f, 
    0.13622077f, 0.75759453f, 0.57399052f, -0.42505968f, 0.25999293f, 0.30153090f, 0.36411929f, 0.30094385f, 
    -0.49932867f, 0.01716793f, 0.21536453f, -0.23259380f, -0.02265373f, -0.23156217f, -0.21995160f, -0.06520384f, 
    -0.12568191f, 0.19411434f, 0.16621789f, 0.20774682f, 0.32157749f, 0.26431113f, 0.18834893f, -0.19895750f, 
    -0.68148696f, -0.30242556f, -0.69031668f, 0.38647833f, -0.58177829f, 0.36429712f, 0.40094101f, 0.16488224f, 
    -0.27376813f, 0.23222142f, -0.16132838f, 0.31444249f, -0.03550002f, 0.17363377f, 0.02663798f, -0.33287954f, 
    -0.22621398f, -0.30208808f, -0.22363047f, 0.20643212f, -0.01772661f, -0.07802304f, 0.32620847f, 0.30545747f, 
    -0.44547766f, -0.76374573f, 0.77896953f, 0.46107024f, 0.32760024f, 0.40764162f, 0.33752215f, 0.26493117f, 
    -0.11134390f, -0.02937966f, 0.20899442f, -0.35861969f, -0.19357058f, 0.38995951f, 0.04206310f, 0.30281156f, 
    0.14670484f, -0.22284074f, 0.09499099f, -0.21085714f, -0.45753285f, -0.01278901f, -0.29442859f, 0.41813701f, 
    0.09025978f, 0.09152830f, 0.43592808f, 0.41318622f, 0.86551571f, -0.27075383f, 0.03694712f, -0.25030902f, 
    0.04063134f, 0.04914399f, 0.16476278f, -0.32733846f, -0.05637755f, -0.07157337f, -0.18079020f, -0.29176491f, 
    -0.50847536f, 0.25213826f, 0.40822840f, 0.13111991f, -0.30835584f, 0.03844091f, -0.26285860f, -0.61229354f, 
    -0.27236560f, 0.02013269f, 0.91662836f, 0.77424276f, 0.22865313f, 0.29014662f, -0.63075149f, -0.50244468f, 
    -0.31590804f, -0.19409639f, 0.01730209f, 0.32419047f, 0.08569015f, -0.14656125f, 0.08170661f, 0.01097608f, 
    -0.14083251f, -0.02875482f, -0.39844593f, 0.06363048f, -0.26078251f, -0.13730431f, 0.06711963f, 0.41708615f, 
    0.01726559f, -0.03168738f, -0.15577298f, 0.39375445f, -0.01917137f, -0.57714057f, 1.13164473f, 0.25329638f, 
    0.67620957f, -0.52184927f, -0.14784542f, -0.09568013f, -0.33695480f, 0.41815940f, -0.01420131f, 0.24922830f, 
    -0.28163946f, -0.46111593f, 0.21552584f, 0.13363369f, 0.39281079f, 0.08397268f, 0.01735951f, -0.25165030f, 
    -0.21464241f, -0.06101151f, -0.04257721f, -0.11699160f, -0.40956369f, 0.63669413f, -0.34562927f, -0.74961162f, 
    -0.53638417f, 0.91126978f, 0.27376017f, -0.09564529f, 0.47045299f, 0.52075547f, 0.36403874f, -0.06570996f, 
    -0.16525513f, 0.12517557f, -0.46897373f, 0.01813763f, -0.11337115f, 0.19884580f, 0.12836617f, 0.07010642f, 
    -0.15293784f, -0.22362189f, -0.14955965f, -0.02858511f, 0.01999328f, -0.70757449f, -0.53385258f, -0.69069439f, 
    -0.45254302f, -0.43005115f, -0.45336360f, 0.67807662f, 0.55538863f, 0.06221810f, 0.42245463f, -0.21682636f, 
    -0.11260521f, 0.34547842f, -0.18961556f, -0.14794266f, -0.06782135f, -0.00162900f, 0.16775011f, 0.01204412f, 
    -0.35070074f, 0.08962052f, 0.34357047f, -0.08779595f, -0.02907652f, 0.17283623f, 1.08523369f, 0.30980325f, 
    -0.79407817f, -0.00429503f, -0.74849254f, -0.41370276f, 0.39983219f, -0.19715545f, 0.03207662f, 0.04928244f, 
    0.27726644f, 0.04910887f, 0.27483863f, -0.16820325f, 0.04430724f, -0.12644693f, -0.23300466f, -0.18265057f, 
    0.25881571f, -0.03885999f, 0.20881842f, 0.08316763f, 0.09381095f, 0.04984483f, 0.06946949f, -0.16501778f, 
    -0.49593392f, 0.35253486f, 0.20731065f, -0.22220534f, 0.02444248f, -0.65993667f, -0.05726427f, -0.83625686f, 
    -0.64373791f, -0.13008943f, -0.24035633f, 0.40307114f, 0.46554071f, -0.13183640f, -0.20192918f, 0.10625399f, 
    0.33264944f, -0.32639813f, 0.35770193f, 0.03531874f, -0.14055996f, -0.02680499f, -0.08105835f, 0.09153699f, 
    0.51616853f, -0.18070512f, -0.75716215f, -0.61512440f, -0.26379099f, 0.55595875f, 0.33098304f, -0.08612420f, 
    -0.14243031f, 0.31462687f, -0.18483599f, -0.22868887f, -0.28954679f, 0.09043030f, -0.12867089f, -0.06438114f, 
    0.15274009f, 0.25459409f, -0.00543706f, -0.00288579f, 0.25732642f, -0.20664997f, -0.47954336f, -0.32607082f, 
    0.01311499f, 0.95186472f, 0.85738069f, -0.63540232f, -0.75509501f, -0.47529978f, 0.48780811f, 0.15671827f, 
    -0.33765566f, -0.34505624f, 0.06011382f, 0.37277579f, 0.23866357f, 0.11174648f, 0.18204291f, -0.29646432f, 
    0.09014557f, 0.06868554f, 0.05200829f, 0.17540689f, 0.24874407f, 0.11128937f, -0.05450377f, -0.03584620f, 
    -0.16520458f, 0.15794440f, -0.21746214f, -0.49058673f, -0.40660357f, -0.62834257f, -0.33655599f, -0.01189671f, 
    -0.69527537f, -0.13486756f, -0.13939646f, -0.50684273f, -0.27074754f, -0.30019817f, 0.49233267f, 0.27064985f, 
    -0.06174890f, 0.33177266f, 0.14303471f, 0.16539976f, 0.30461013f, 0.13118011f, 0.24963248f, 0.10033002f, 
    0.17636254f, 0.00819073f, -0.14191133f, 0.70476586f, 0.16187897f, -0.68248010f, -0.27120519f, -0.63673264f, 
    -0.69398957f, -0.39579290f, -0.01871026f, 0.17678238f, -0.12691310f, 0.14826037f, -0.06830396f, 0.32722703f, 
    0.15522240f, -0.45054486f, 0.24384424f, 0.34211314f, -0.04333553f, -0.18002784f, -0.23728879f, -0.25093201f, 
    -0.10183287f, 0.38386390f, 0.33477420f, 0.36295888f, 0.14297251f, 0.38825470f, 0.06197096f, -0.41201848f, 
    0.39907497f, -0.13787775f, 0.10100927f, 0.40636259f, 0.18590087f, 0.53350699f, -0.11231271f, -0.39397672f, 
    0.29624411f, -0.43866301f, 0.54807937f, 0.59642833f, -0.19509678f, -0.56099319f, -0.20727031f, 0.16185771f, 
    -0.30003473f, -0.13603538f, -0.32446656f, -0.42740989f, 0.03970784f, 0.42019686f, 0.95719886f, 0.74867511f, 
    0.11604010f, -0.34970930f, -0.97082525f, 0.69945747f, -0.27293009f, -0.49658564f, -0.48268503f, 0.02587907f, 
    0.02129897f, -0.30086559f, 0.33708018f, 0.22168571f, -0.04644910f, -0.00817368f, -0.07803766f, 0.23603879f, 
    -0.10432953f, 0.23817548f, 0.19114661f, 0.35520935f, 0.31955028f, 0.13032266f, -0.70139217f, 0.44657883f, 
    0.66528207f, 0.33620206f, 0.17735854f, -0.41346973f, 0.36855912f, 0.67507970f, 0.39275160f, -0.36632106f, 
    -0.25452346f, 0.03213003f, -0.40304905f, -0.28547716f, -0.13590482f, -0.05432255f, 0.00784370f, 0.16100273f, 
    0.13158995f, -0.07504322f, 0.15041673f, -0.22211973f, -0.34153005f, -0.22729515f, 0.01317828f, 0.57035762f, 
    0.09729955f, 0.49583289f, -0.67255652f, 0.32975301f, 0.21550545f, -0.18451056f, -0.91818494f, -0.55541420f, 
    -0.32599640f, 0.07992490f, 0.26923549f, 0.24531937f, 0.16930765f, -0.37285253f, -0.35081583f, 0.28075430f, 
    0.19774301f, -0.00743789f, 0.12714177f, -0.33296934f, -0.01821108f, -0.03952542f, -0.13519695f, 0.23431997f, 
    0.55095512f, 0.18002528f, -0.70201623f, -0.31475586f, 0.59414029f, 0.95618671f, 0.28414497f, -0.14767767f, 
    0.42422935f, 0.36203700f, -0.38419980f, -0.12312483f, -0.41270730f, 0.17559201f, 0.02645039f, 0.03187650f, 
    -0.28280705f, -0.18099326f, -0.10175872f, 0.26758161f, 0.03200664f, 0.18890813f, -0.20267457f, 0.10085666f, 
    -0.04216885f, -0.71329159f, 0.34779397f, 0.06012090f, -0.01299826f, 0.33897749f, 0.49747083f, -0.04267728f, 
    0.65599793f, 0.36512759f, 0.27960432f, -0.25016454f, 0.25649112f, -0.54815483f, -0.37624747f, -0.23378859f, 
    -0.00844131f, -0.11904400f, -0.42015031f, 0.17024410f, -0.22505753f, -0.06751698f, -0.09754059f, 0.17545156f, 
    -0.22063777f, -0.11654685f, -0.59675986f, -0.71698833f, -0.17169195f, -0.19404393f, 0.37564322f, -0.04467719f, 
    -0.38721803f, -0.43652329f, -0.46049038f, -0.28823340f, 0.49209091f, 0.33521524f, 0.11285754f, -0.10716034f, 
    -0.11534150f, 0.36287859f, -0.01199018f, 0.35666448f, -0.40229550f, -0.28773999f, -0.18194132f, -0.06854161f, 
    0.27349624f, -0.02919579f, 0.11900304f, 0.28436700f, -0.44535735f, -0.64416647f, -0.61028832f, -0.15839623f, 
    0.13295384f, 0.14005344f, 0.22678408f, 0.24836010f, 0.07915288f, -0.41854075f, -0.05549456f, 0.18292244f, 
    -0.45832437f, -0.39760840f, -0.31316602f, -0.11596883f, 0.23693055f, 0.51265728f, -0.33755040f, 0.20957676f, 
    0.28689557f, -0.38873973f, -0.15696158f, 0.44483283f, -0.83842224f, -0.20798963f, -0.16097766f, -0.17032276f, 
    -0.35803276f, 0.26801053f, 1.01806903f, 0.51341289f, -0.44446754f, 0.04867470f, 0.28864783f, -0.16081046f, 
    0.12913051f, -0.14870517f, 0.37607193f, -0.31324238f, -0.32150874f, -0.04871633f, -0.09245759f, -0.25827762f, 
    -0.09469682f, 0.30126965f, 0.27563018f, 0.25305653f, -0.20337696f, 0.97609317f, -0.85187405f, 0.46839431f, 
    0.10391343f, 0.04524763f, 0.61846566f, 0.46114486f, 0.05875734f, 0.16636802f, 0.03010920f, -0.20196360f, 
    0.08735282f, -0.48171198f, 0.25333253f, -0.16045250f, 0.29631710f, -0.02460327f, 0.10928936f, 0.12823243f, 
    -0.04751014f, -0.13715748f, 0.31111717f, 0.11159593f, 0.20352729f, -0.01654053f, 0.65173012f, 0.70577061f, 
    -0.00640471f, 0.73611462f, 0.40702811f, 0.58539855f, 0.35319123f, 0.47320363f, 0.23729584f, -0.11869309f, 
    -0.67437643f, 0.15088731f, 0.19000162f, -0.15516622f, -0.01909175f, -0.42411539f, 0.02146928f, -0.04530307f, 
    0.05247940f, 0.13250385f, -0.05417990f, -0.37856832f, -0.26806548f, 0.17942956f, 0.20855331f, -0.35208091f, 
    -0.12503913f, -0.22997405f, 0.87637359f, 0.96832526f, 0.72029358f, 0.59083730f, 0.48014301f, 0.20308799f, 
    -0.24396393f, -0.13157952f, 0.11277264f, -0.03517484f, 0.20727184f, 0.02110110f, 0.08629698f, 0.04452217f, 
    0.15211284f, -0.06342676f, -0.01212368f, -0.01651026f, 0.05733822f, -0.02249899f, 0.26842290f, -0.35205123f, 
    0.35287207f, -0.57052523f, -0.53493160f, 0.00682760f, 0.31359443f, -0.03475467f, -0.69122142f, -0.48030633f, 
    0.03568984f, 0.18105163f, -0.48422655f, -0.14398174f, -0.34436852f, -0.24260852f, -0.40748635f, -0.34503713f, 
    0.28098008f, 0.33369112f, 0.12889870f, -0.34217522f, -0.10685629f, -0.05421112f, -0.11463322f, 0.06267376f, 
    0.07163495f, 0.18080924f, -0.08323234f, -0.22718377f, -0.43111005f, -0.27686441f, 0.26797128f, 0.29869944f, 
    -0.49671233f, -0.49120724f, -0.40866390f, -0.11634214f, 0.44194975f, -0.28895140f, -0.02992791f, -0.11804631f, 
    0.17038253f, -0.07581360f, -0.34727904f, 0.18732274f, 0.44553494f, 0.23323266f, -0.12639201f, -0.12011625f, 
    0.22194381f, -0.13932827f, -0.21011250f, 0.05676024f, 0.64637518f, 0.55656648f, -0.27777240f, -0.69773793f, 
    -0.40736124f, 0.13036989f, -0.43761021f, 0.21149124f, 0.19104688f, 0.03983362f, -0.13386571f, -0.12671413f, 
    0.27503511f, 0.32015327f, 0.23825410f, 0.21782394f, -0.53397435f, -0.22220121f, -0.06657079f, 0.05809166f, 
    0.39736402f, 0.26111561f, -0.20254119f, -1.13843060f, 1.48225677f, -0.09762625f, -0.93684214f, 0.89442766f, 
    -0.04229480f, 0.03983233f, 0.03260516f, -0.40979117f, -0.22773704f, 0.00932279f, -0.04763381f, -0.22454973f, 
    0.01452037f, -0.23896646f, -0.10475081f, -0.11341320f, -0.36970994f, -0.24604535f, -0.40286618f, 0.10382398f, 
    0.00389256f, 0.05748984f, 0.25357109f, 0.16112880f, 0.86891532f, 0.41048771f, 0.42205819f, 0.29507741f, 
    0.32259679f, -0.43678343f, 0.46449557f, 0.15760991f, 0.06474259f, 0.03581958f, -0.29069090f, -0.15898964f, 
    0.26921928f, -0.07577433f, 0.16314580f, 0.23190559f, 0.22551177f, 0.01569706f, 0.16734545f, 0.01137220f, 
    -0.25515693f, -0.19086130f, -0.13278545f, 0.09512208f, -0.11078455f, 0.04088372f, 0.08129303f, -0.45593613f, 
    -0.67555827f, -0.01585999f, -0.20313860f, -0.79470944f, 0.47499010f, 0.03791906f, -0.18661737f, 0.12497596f, 
    -0.25839886f, 0.34047735f, -0.01403860f, -0.17884755f, 0.33246437f, 0.05027521f, -0.43961391f, -0.34859768f, 
    0.42685291f, -0.33572870f, 0.39744678f, -0.06504710f, 0.43344882f, -0.06416038f, 0.21390013f, 0.36822930f, 
    -0.05236052f, 0.09836309f, 0.52543086f, -0.04224500f, -0.42373276f, -0.62631500f, -0.07866414f, -0.09297818f, 
    0.29119173f, 0.11039949f, 0.35505205f, 0.30519500f, 0.04077053f, 0.38259614f, 0.24348880f, -0.39725178f, 
    -0.11423191f, -0.09854446f, 0.36056197f, -0.06146022f, -0.20917562f, 0.25335070f, -0.13588354f, -0.80088001f, 
    -0.88094395f, -0.16692989f, 0.21895404f, 0.19965236f, 0.30574018f, 0.45556673f, -0.19064596f, 0.18200439f, 
    -0.12522766f, -0.17541227f, 0.10607925f, 0.21045682f, 0.56015235f, 0.24730958f, 0.03062695f, 0.13783816f, 
    -0.16262457f, 0.00251509f, 0.31496981f, -0.13890733f, 0.08866939f, -0.14090203f, 0.10166214f, 0.07064187f, 
    0.17941165f, -0.92589229f, -0.12527053f, 0.01850197f, 0.61861295f, -0.52556711f, -0.47082916f, 0.34394312f, 
    -0.49125597f, 0.02740178f, 0.33063734f, 0.29415107f, -0.17524879f, 0.10823276f, 0.05963461f, -0.16531464f, 
    0.04430547f, -0.07377737f, 0.10954608f, 0.56943762f, 0.06351066f, 0.02508160f, 0.20851427f, -0.06254765f, 
    -0.11597656f, 0.70400268f, 0.66471332f, 0.51976621f, 0.75690132f, 0.63648957f, -0.12658384f, -0.51467174f, 
    0.12247982f, -0.24223995f, -0.20571868f, 0.15617600f, 0.18906096f, -0.20834841f, 0.48457226f, -0.00070093f, 
    0.31811643f, 0.15177925f, 0.13461265f, 0.29597282f, 0.12517057f, 0.38520607f, -0.30605653f, -0.35668349f, 
    0.29046249f, 0.24683544f, 0.30865526f, 0.79449284f, 0.85299468f, 0.36942503f, 0.46650755f, 0.02873678f, 
    -0.29919252f, -0.59686083f, -0.70698756f, 0.37405032f, -0.11475955f, 0.18787825f, 0.18024746f, 0.20754176f, 
    0.17443828f, 0.12188260f, 0.12290648f, 0.13673657f, 0.15561795f, 0.12324625f, 0.36755463f, 0.01267859f, 
    0.11010952f, 0.01056431f, 0.12913136f, -0.12471978f, -0.43833315f, -0.05906271f, 0.14558694f, 0.45897579f, 
    0.00485550f, -0.53857881f, -0.49333400f, -0.07936225f, -0.01383802f, 0.31953096f, 0.23445499f, -0.40297318f, 
    -0.01052972f, -0.20757636f, -0.10510059f, 0.15042163f, 0.40190962f, 0.25972641f, 0.31724668f, 0.08318422f, 
    -0.25251025f, -0.12840389f, -0.06321626f, 0.39856428f, -0.00527601f, -0.14667925f, -0.49532753f, -0.54634219f, 
    -0.43262407f, -0.02237502f, 0.17079629f, -0.05101255f, 0.52070838f, -0.25201294f, -0.34357142f, -0.46262935f, 
    -0.46809760f, -0.51148665f, -0.43651602f, -0.11042741f, -0.17623380f, -0.05141032f, 0.08001634f, -0.14611237f, 
    -0.26411003f, -0.11540847f, -0.15985624f, -0.16775562f, -0.23106757f, -0.77688694f, 0.00204371f, 0.73869991f, 
    0.36188799f, -0.54148418f, -0.22465129f, -0.05964829f, -0.48570314f, -0.59356767f, -0.21658832f, 0.10251341f, 
    0.55023634f, -0.01532370f, 0.28298974f, 0.36311024f, 0.22836804f, -0.06037318f, 0.26353469f, -0.35139537f, 
    0.11900151f, 0.36798677f, -0.17311771f, -0.09918589f, 0.04926457f, 0.10869332f, -0.91443378f, -0.82784921f, 
    0.50025702f, 0.58560431f, 0.22597553f, 0.67166156f, 0.19474308f, 0.21113256f, 0.15006843f, -0.70352089f, 
    -0.43947929f, 0.12260146f, -0.17836544f, 0.22825329f, -0.33750612f, -0.10249358f, 0.43975344f, -0.25490326f, 
    0.02214964f, -0.02022273f, 0.12687293f, -0.25846460f, -0.11341683f, -0.24928288f, 0.10514402f, 0.75070888f, 
    0.32356453f, -0.47021151f, 0.55896258f, 0.03037544f, 0.18384108f, -0.21782929f, -0.00460669f, 0.41343534f, 
    0.36597601f, 0.12274995f, 0.31878719f, -0.26953942f, -0.42942730f, 0.19235913f, -0.02483709f, -0.48583385f, 
    0.01654097f, -0.30340338f, -0.18778050f, -0.44115761f, -0.06429600f, -0.07572086f, 0.03959890f, -0.33375630f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03628708f, -0.01418641f, -0.05941817f, 0.25335810f, 0.21903187f, -0.00478372f, -0.01927379f, 0.08216773f, 
    0.09605122f, 0.30142510f, 0.02006643f, 0.16093972f, -0.11406987f, 0.16569191f, 0.03650109f, 0.03219243f, 
    0.28939560f, 0.10056709f, 0.06091933f, 0.10194781f, 0.26466832f, -0.06068502f, 0.14301139f, 0.29179332f, 
    -0.00089097f, -0.03880542f, 0.16417028f, -0.16666910f, 0.16252066f, 0.06247104f, 0.15147091f, 0.04195518f, 
    -0.03119004f, 0.33816963f, 0.14127742f, 0.11906753f, 0.23361373f, 0.18140632f, 0.04734805f, 0.27779469f, 
    -0.01305693f, -0.00294701f, 0.17353901f, -0.00755615f, 0.17678934f, -0.07545066f, 0.08897384f, 0.34059465f, 
    0.28954574f, 0.13907643f, 0.29664502f, 0.11683354f, 0.24417913f, 0.17394203f, 0.10811014f, 0.14931132f, 
    0.11865268f, 0.14863120f, 0.05639160f, 0.34301686f, -0.10850959f, 0.08920491f, 0.02656914f, 0.00634624f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00100199f, 0.05237215f, 0.33411607f, -0.19827197f, -0.07590928f, 0.00489524f, 0.02590299f, -0.13133150f, 
    0.10410985f, 0.10770047f, 0.10018795f, 0.00657937f, -0.01043591f, 0.08038720f, -0.16933849f, 0.23282890f, 
    -0.22028665f, -0.01208416f, 0.05735672f, -0.06959758f, 0.01170955f, 0.08442170f, -0.06426480f, 0.13038445f, 
    0.01638011f, 0.16671942f, 0.00104417f, -0.33241850f, 0.06012137f, 0.00837111f, 0.04838798f, 0.08340298f, 
    -0.04873830f, -0.00869352f, -0.08142854f, 0.01932209f, -0.06130278f, 0.00930002f, -0.05126913f, 0.05469472f, 
    -0.16046205f, -0.10795878f, -0.00985428f, 0.03139950f, -0.02166854f, -0.00215194f, -0.09304099f, 0.00492259f, 
    -0.00822900f, 0.06322414f, 0.03815725f, 0.09664442f, -0.05722226f, -0.04737893f, 0.01576377f, -0.03202216f, 
    -0.01101664f, -0.02861299f, -0.02981487f, 0.01200274f, 0.46636572f, -0.10777064f, 0.15499991f, -0.27091619f, 
    0.05464094f, 0.08192871f, 0.05961335f, -0.01203462f, -0.10805140f, -0.08116450f, -0.03510051f, 0.09302323f, 
    0.28549102f, 0.01364175f, 0.22003508f, 0.08985911f, -0.05325929f, 0.10599341f, 0.10138506f, -0.11154292f, 
    -0.00839371f, -0.03824600f, -0.15484647f, 0.08448175f, 0.09595776f, 0.01914215f, 0.19560498f, -0.16738792f, 
    -0.05355425f, 0.03240611f, -0.03526120f, -0.07391550f, 0.07232834f, 0.01909928f, -0.02422134f, 0.14584139f, 
    0.14730144f, -0.06523434f, -0.02963563f, 0.25161970f, -0.16262041f, -0.03566335f, -0.11358285f, 0.01369717f, 
    -0.08004420f, 0.06574401f, 0.03806803f, -0.08717896f, -0.06750813f, 0.17319560f, 0.08475888f, 0.02548016f, 
    -0.00119262f, 0.01023387f, -0.07798945f, -0.05257557f, -0.13262726f, -0.02842910f, -0.06913552f, 0.02523067f, 
    0.20178063f, 0.22621973f, -0.00203076f, -0.05122542f, -0.13888574f, 0.04487128f, -0.00222874f, -0.15422677f, 
    0.02518119f, -0.04253845f, -0.05003956f, 0.02614635f, -0.02813703f, 0.15693723f, -0.02592032f, 0.01971611f, 
    0.02983111f, 0.01026548f, -0.02526895f, -0.06088257f, -0.05200817f, -0.00851020f, 0.01998762f, 0.06304128f, 
    0.13388313f, -0.28845546f, 0.02792697f, 0.15786710f, -0.06132302f, -0.07037964f, 0.01699983f, -0.04177679f, 
    0.08563500f, 0.02625898f, -0.11094478f, 0.10445757f, -0.19573191f, -0.23788399f, -0.06047759f, 0.00246025f, 
    -0.07988920f, 0.08271086f, -0.00316792f, -0.03899959f, 0.13439997f, 0.01526446f, 0.00836892f, -0.05989368f, 
    -0.17561285f, -0.14135011f, -0.03891722f, -0.01797116f, -0.00029181f, -0.00716413f, 0.04934902f, 0.00909084f, 
    0.08933370f, -0.04786995f, 0.09622627f, 0.08793508f, 0.31331798f, -0.11317008f, 0.07551599f, -0.10580340f, 
    0.04983373f, 0.03995885f, -0.00205978f, -0.01135149f, 0.10631395f, 0.06809142f, -0.03972796f, -0.19038172f, 
    0.02904789f, 0.00117215f, -0.04602477f, -0.02147602f, 0.00241339f, -0.09372956f, -0.03138561f, -0.04522588f, 
    -0.06401132f, -0.02503236f, 0.06834816f, -0.00542649f, 0.03618109f, 0.11438765f, -0.14636531f, 0.22986376f, 
    -0.04583724f, 0.04037236f, 0.02720010f, -0.11652011f, -0.05144709f, 0.06008312f, -0.05901893f, -0.07226603f, 
    0.08061647f, -0.18757087f, -0.00214397f, -0.25821203f, -0.01302086f, -0.00767416f, 0.00735875f, -0.08646246f, 
    -0.17969407f, 0.00717027f, 0.00868000f, -0.00431203f, 0.21610674f, -0.12128507f, -0.01042175f, 0.15507220f, 
    -0.08788426f, -0.05391780f, -0.07915275f, -0.01320852f, 0.08078577f, -0.04514637f, -0.02753954f, -0.01252606f, 
    -0.10143930f, 0.11671268f, 0.07109118f, -0.32217848f, 0.04512443f, 0.09902795f, -0.09682356f, 0.07021832f, 
    0.01555504f, -0.04317455f, -0.12648341f, 0.00983991f, -0.50790238f, -0.00047589f, -0.00439394f, -0.02149221f, 
    0.04791130f, -0.06613663f, -0.04792427f, -0.03419457f, 0.06258227f, -0.09399230f, -0.04583788f, 0.03976530f, 
    0.18846902f, -0.00576629f, -0.07841571f, 0.22021003f, -0.06953652f, -0.03066897f, -0.15979269f, 0.04350341f, 
    -0.00947144f, -0.06578649f, -0.02839408f, 0.01008590f, -0.35289192f, 0.14327189f, -0.05765222f, -0.22192693f, 
    0.00500078f, -0.12924212f, -0.03049521f, 0.06451543f, 0.05069121f, 0.04658445f, -0.02068993f, -0.04176321f, 
    -0.10464258f, -0.02496496f, -0.07240462f, 0.14273506f, 0.03659151f, -0.02775756f, 0.13994782f, 0.04445111f, 
    0.01734617f, -0.00810106f, -0.05060750f, -0.09958444f, -0.03043432f, 0.01410852f, -0.16975138f, 0.18789341f, 
    0.01719486f, 0.05058465f, 0.05884359f, -0.04522591f, 0.04513396f, -0.02763695f, -0.17853320f, 0.09972759f, 
    0.04239998f, 0.02825557f, -0.15258816f, -0.04465447f, -0.14641874f, 0.00459703f, -0.14764366f, -0.06977586f, 
    -0.07293757f, 0.00491007f, 0.00507352f, 0.06625363f, 0.18755834f, -0.28914192f, -0.16863392f, 0.22633077f, 
    -0.10023534f, 0.17208460f, -0.11105125f, 0.08524708f, 0.05892938f, 0.06790411f, -0.13258630f, -0.04608658f, 
    0.36945432f, -0.08996992f, -0.13779610f, -0.28198016f, 0.07350910f, -0.10338385f, 0.13478586f, -0.06379898f, 
    -0.03679598f, 0.08172717f, -0.04831775f, 0.03797745f, 0.01625900f, 0.18787247f, -0.09813720f, -0.33793226f, 
    0.07274030f, -0.01239180f, 0.01442479f, 0.01130622f, 0.01273781f, -0.13347164f, -0.03177971f, 0.12538089f, 
    -0.39181969f, 0.05963394f, 0.04755549f, -0.05146439f, 0.02030359f, 0.01626925f, 0.08874860f, 0.02516132f, 
    0.01367984f, -0.04261103f, 0.06673422f, 0.08340267f, -0.20207454f, 0.09637590f, 0.05735564f, 0.05014764f, 
    0.08043838f, -0.00556091f, 0.02298587f, -0.07064609f, -0.00721220f, -0.02226516f, -0.14631113f, 0.01223328f, 
    0.00015438f, -0.06367385f, 0.11279473f, -0.18238242f, -0.03066961f, -0.01635284f, 0.02591570f, -0.03483494f, 
    -0.05973001f, 0.05655176f, 0.04509249f, 0.14555231f, -0.23144211f, 0.12246798f, 0.18077898f, -0.33992904f, 
    -0.04063050f, 0.04414744f, 0.01776120f, 0.12522899f, -0.02775254f, -0.06097650f, -0.03340871f, 0.08218917f, 
    -0.20542637f, -0.21689801f, 0.06064457f, 0.00294948f, 0.04743743f, -0.00243886f, 0.06105265f, 0.03009222f, 
    -0.03126356f, 0.09360687f, -0.00996275f, 0.03886846f, -0.25223181f, -0.12777753f, 0.15749171f, 0.03526058f, 
    -0.05901291f, -0.14582093f, 0.05120163f, -0.04823039f, -0.00345466f, 0.08364568f, 0.09882637f, -0.11431005f, 
    -0.03424974f, -0.06112697f, 0.00427955f, -0.22955585f, -0.18365037f, -0.05769072f, -0.04585305f, 0.12628858f, 
    0.06520917f, 0.01149108f, 0.05034527f, 0.08452570f, 0.03252706f, 0.12748937f, -0.04811719f, 0.02068410f, 
    -0.11438394f, -0.00449749f, -0.12993962f, -0.01405452f, -0.01989791f, -0.11902403f, -0.03025378f, -0.23229183f, 
    -0.18022281f, 0.12121563f, 0.12350374f, 0.07895342f, -0.06911518f, -0.03148091f, 0.11806914f, -0.01876268f, 
    -0.02658891f, 0.00781920f, 0.06279515f, 0.03732826f, -0.10076856f, 0.09924498f, 0.13561291f, -0.36020139f, 
    -0.06926285f, -0.06216003f, 0.11525694f, 0.03499952f, 0.01705544f, -0.00782770f, 0.01938803f, 0.02774281f, 
    0.18591607f, -0.01832539f, 0.16811977f, -0.00379951f, 0.06640894f, -0.05476620f, 0.17219746f, -0.04992517f, 
    0.09922476f, -0.00721160f, 0.00900079f, 0.00627506f, 0.04935172f, 0.04554134f, 0.17014758f, 0.03650210f, 
    -0.01591946f, -0.03101063f, 0.01756671f, -0.11587237f, -0.04413376f, -0.05144367f, 0.00659060f, -0.04510302f, 
    -0.32549807f, -0.37788135f, 0.02221931f, 0.13893285f, 0.10465670f, -0.01981816f, 0.04076096f, 0.05856290f, 
    -0.06585515f, 0.07114134f, -0.07544940f, -0.13262092f, -0.05979817f, -0.06338908f, -0.13141015f, -0.30616975f, 
    0.16243967f, -0.07225668f, 0.08567193f, -0.00525386f, -0.04841574f, -0.00865356f, -0.08082854f, 0.02643362f, 
    0.07074463f, 0.09978282f, 0.12510736f, -0.15326068f, 0.10957558f, 0.04037955f, -0.02189932f, -0.09402561f, 
    0.06882422f, 0.04222297f, 0.03608433f, 0.12343657f, 0.26072222f, -0.06158586f, -0.00710057f, 0.10790562f, 
    0.01315774f, -0.07813624f, 0.01255317f, 0.03856215f, -0.04638509f, 0.07117382f, 0.05151246f, -0.09026282f, 
    0.09849172f, -0.05046611f, -0.17316844f, 0.00828296f, -0.05522430f, 0.03470356f, -0.01239543f, 0.05328243f, 
    -0.02366805f, -0.03938041f, -0.05389151f, 0.13976537f, -0.20192458f, 0.15754822f, -0.02255829f, 0.03758656f, 
    0.03264385f, 0.01869193f, -0.08925764f, -0.12778102f, 0.05481956f, -0.04881646f, -0.01007092f, -0.08751532f, 
    0.04697569f, -0.21778372f, 0.13711542f, 0.16619997f, -0.04064489f, 0.07224920f, 0.01451097f, -0.00230161f, 
    -0.06354484f, 0.00819465f, 0.01519937f, 0.06127322f, -0.23526283f, 0.04490904f, 0.14898463f, -0.24601461f, 
    -0.00676406f, 0.06030871f, -0.00827524f, -0.04088353f, -0.02915614f, -0.01150645f, 0.01769585f, -0.01240693f, 
    -0.03384916f, 0.00620501f, -0.26078305f, 0.17589471f, -0.03725353f, 0.02205434f, -0.04318781f, 0.02540580f, 
    0.02503774f, 0.04313108f, 0.02958531f, -0.02416789f, -0.14067975f, -0.02658707f, 0.36946592f, -0.21252030f, 
    0.00093394f, -0.03848011f, 0.01487145f, -0.04909122f, 0.06144407f, -0.05585161f, 0.01318119f, -0.02850963f, 
    0.06276496f, -0.03484564f, -0.08846316f, 0.02089417f, -0.12316384f, -0.03325573f, -0.04536420f, 0.09965341f, 
    -0.00094141f, -0.06886386f, 0.11830498f, -0.11623327f, -0.06623460f, -0.24951462f, 0.01789209f, -0.24274051f, 
    -0.09279104f, 0.12937659f, -0.02508264f, 0.03126527f, -0.00857469f, -0.02498654f, 0.05972518f, -0.09832995f, 
    -0.02533078f, -0.14664772f, 0.14141503f, -0.04849430f, -0.05317999f, -0.01385096f, -0.00416425f, -0.02024081f, 
    0.05717106f, -0.02664947f, 0.14301123f, -0.01827345f, -0.31703231f, -0.01124172f, 0.02114522f, 0.00705096f, 
    0.02619216f, -0.01253369f, -0.07420719f, 0.04191967f, 0.02719156f, -0.03849939f, -0.01795042f, -0.06855679f, 
    0.15614037f, -0.21082367f, -0.07810456f, 0.02487300f, -0.04390081f, 0.15374270f, -0.01304065f, 0.02484125f, 
    -0.07252959f, -0.11689648f, 0.00626847f, -0.01090792f, 0.16547754f, 0.10218477f, 0.01662102f, 0.01036291f, 
    -0.12303540f, -0.08545198f, 0.05058414f, 0.07521449f, 0.03700751f, -0.00412438f, 0.09639625f, -0.03964286f, 
    -0.00607159f, 0.13016863f, -0.02754243f, -0.07205318f, -0.14004003f, -0.19190609f, 0.02065103f, 0.00291862f, 
    0.06256790f, -0.05997331f, -0.16433336f, -0.01243408f, -0.07307966f, -0.31578031f, 0.10578271f, 0.07836723f, 
    -0.02729949f, -0.10850883f, 0.00325979f, 0.03857484f, 0.02619665f, 0.07547202f, -0.07093420f, -0.10228411f, 
    0.12651299f, 0.08574185f, -0.15671286f, -0.27922443f, 0.05946736f, 0.02796154f, 0.01319990f, -0.06618681f, 
    0.05697251f, -0.01839385f, 0.10667030f, 0.04090822f, -0.25689641f, 0.19437525f, 0.01714482f, 0.19688033f, 
    0.05994504f, 0.04959301f, 0.14536288f, 0.01936487f, 0.02404350f, 0.07408077f, 0.05440443f, -0.07059077f, 
    -0.46292061f, 0.10178214f, 0.04189977f, 0.13575736f, 0.15646361f, 0.01103439f, 0.07763822f, 0.11923321f, 
    0.02324432f, -0.03754881f, 0.05427651f, -0.02406219f, 0.16538227f, -0.07641133f, -0.03687045f, 0.16710953f, 
    -0.13497809f, -0.05393596f, -0.03927119f, 0.05794125f, -0.07484428f, -0.00476179f, -0.04509136f, -0.02051456f, 
    0.20163265f, 0.09998020f, -0.01279263f, -0.08807456f, -0.06852897f, -0.05067059f, -0.05698523f, 0.11955070f, 
    0.08777957f, -0.04863555f, -0.09058921f, 0.03547540f, -0.02786796f, -0.24358620f, 0.04072550f, 0.14756897f, 
    -0.07371198f, 0.04748021f, -0.06798882f, 0.06931867f, 0.09689432f, -0.11031190f, 0.09721811f, -0.12580845f, 
    0.17346817f, -0.05878692f, -0.20221201f, -0.06970083f, -0.01553599f, 0.00989590f, -0.04971891f, 0.10542543f, 
    0.05021655f, 0.00040184f, 0.02955378f, 0.04877965f, 0.15653837f, -0.10683841f, 0.12551053f, 0.06284074f, 
    0.00158850f, 0.03611973f, 0.08485484f, -0.03489847f, -0.13307726f, 0.04763769f, 0.11932607f, -0.10373273f, 
    0.13459162f, -0.25397781f, -0.22268814f, -0.11544476f, -0.03497051f, -0.03513504f, -0.02858499f, 0.11149096f, 
    0.12815118f, -0.00565869f, 0.04337033f, -0.13643757f, 0.13478316f, -0.34578985f, 0.22709401f, -0.32055524f, 
    0.16354910f, 0.02432681f, -0.02848112f, 0.06459577f, 0.07278664f, 0.09257661f, 0.03657501f, 0.01495327f, 
    -0.23038177f, 0.10534260f, -0.07897606f, -0.07697760f, 0.02758420f, -0.00132830f, -0.00253880f, -0.00163723f, 
    0.07451203f, 0.16201636f, 0.08263652f, -0.03240519f, 0.17936181f, -0.09949004f, -0.15972477f, -0.15010455f, 
    0.08046260f, -0.09632761f, 0.07924599f, 0.13011432f, -0.03451851f, 0.02127823f, -0.00325947f, -0.05383288f, 
    0.23124005f, 0.01397872f, 0.13161650f, 0.20436990f, -0.03340859f, 0.07377054f, -0.00344912f, 0.04628780f, 
    -0.02731786f, -0.06552986f, -0.12080764f, 0.06097451f, -0.21148473f, 0.03534924f, -0.07382130f, -0.10608336f, 
    0.05065556f, -0.03264245f, 0.03658247f, 0.06770938f, -0.00022644f, 0.06709679f, -0.03034587f, 0.04124719f, 
    -0.37362608f, -0.35743257f, -0.47053492f, 0.09449631f, 0.13001965f, -0.15571564f, -0.01580350f, 0.09362413f, 
    0.03244681f, -0.00796013f, -0.00094324f, 0.09804046f, 0.04300360f, 0.02844796f, 0.05378083f, 0.00432014f, 
    0.06363973f, 0.07866387f, 0.04510973f, -0.07756891f, 0.11711479f, 0.01828453f, -0.11387435f, 0.00069679f, 
    -0.06357593f, 0.15869275f, -0.01060992f, -0.18315233f, -0.03050512f, 0.04815963f, 0.08101413f, 0.02899415f, 
    -0.00163053f, 0.09657123f, 0.18829225f, 0.00428725f, -0.17678711f, -0.05843371f, -0.23826072f, 0.13329317f, 
    -0.02428752f, -0.07567599f, -0.15615995f, 0.04895912f, 0.00969179f, -0.17732887f, 0.07211200f, 0.06731729f, 
    -0.16162106f, -0.07705172f, 0.00823041f, 0.05227208f, -0.03893399f, 0.13625914f, -0.04829022f, 0.18758224f, 
    -0.02545181f, -0.11815213f, -0.01941686f, -0.10573479f, -0.45167372f, 0.10428781f, -0.03719392f, 0.02895927f, 
    -0.17523210f, -0.02649879f, 0.00780058f, -0.12794645f, -0.02104541f, 0.10382982f, 0.04691348f, -0.00071830f, 
    -0.05492453f, 0.13676047f, 0.04661442f, -0.02345434f, -0.05199884f, -0.07575282f, 0.03817186f, 0.02708727f, 
    0.00614605f, -0.02833169f, 0.05412703f, 0.02031795f, 0.02053767f, 0.01907071f, -0.01770875f, 0.00435615f, 
    -0.02214963f, -0.06603007f, -0.04215614f, -0.11467639f, -0.09689184f, -0.08544791f, -0.01540743f, 0.10356353f, 
    0.14134049f, -0.13071150f, 0.10589059f, -0.22296606f, -0.02712367f, -0.07447526f, -0.00112186f, 0.09637032f, 
    -0.09062175f, -0.07896873f, -0.05882568f, -0.05642302f, -0.21644716f, -0.25532708f, -0.05843618f, 0.03883110f, 
    0.09026797f, 0.02028276f, 0.00423265f, 0.11660977f, 0.03531303f, -0.03787402f, -0.08882499f, 0.00409684f, 
    0.08051524f, -0.11402693f, -0.10353275f, -0.10709924f, 0.01702462f, -0.01584824f, -0.02183392f, 0.06300588f, 
    0.07638285f, 0.07950739f, 0.01085329f, 0.03952059f, 0.32191798f, -0.05035424f, -0.01355486f, 0.04580316f, 
    -0.07723339f, 0.01842469f, 0.02084848f, 0.11511921f, -0.00693281f, -0.01674968f, -0.05087229f, 0.03585536f, 
    0.21270840f, 0.12431326f, 0.05141717f, 0.28720289f, -0.05789692f, -0.00606217f, 0.10946848f, -0.01317581f, 
    -0.15368678f, -0.08140843f, -0.02907940f, 0.02204926f, 0.15567242f, -0.15256603f, -0.00422394f, -0.01376348f, 
    0.09313656f, 0.07712597f, -0.01152875f, -0.00809448f, 0.02158745f, -0.14397325f, -0.06965816f, 0.05404318f, 
    -0.09554195f, 0.22565961f, 0.00728965f, 0.09005996f, -0.12764274f, 0.14622062f, -0.03858612f, 0.00512188f, 
    -0.04453798f, 0.12910149f, -0.07860219f, 0.00959705f, 0.05449383f, 0.01898218f, -0.02800120f, 0.06365836f, 
    0.03972063f, -0.04011458f, -0.04574580f, -0.07540584f, -0.03820828f, -0.17275299f, 0.08343297f, -0.15083712f, 
    0.17487331f, 0.02924539f, 0.03356859f, 0.08796983f, -0.03659371f, -0.03271253f, 0.14829050f, 0.09668135f, 
    -0.08140358f, -0.13736096f, -0.09489663f, 0.06368280f, -0.21696439f, -0.17158476f, 0.00339622f, 0.10560474f, 
    0.17286603f, -0.03885297f, -0.09810824f, -0.06437619f, -0.00971422f, -0.01315021f, -0.10825053f, -0.02869772f, 
    -0.41722989f, -0.16641927f, 0.04810534f, -0.12459619f, -0.03426426f, -0.05608091f, -0.06580850f, -0.00047602f, 
    0.07191816f, -0.00642447f, -0.00428200f, -0.04766870f, 0.16823432f, -0.07509797f, -0.06510966f, -0.12262004f, 
    0.07031262f, -0.05195262f, -0.06050045f, 0.01804712f, 0.02401214f, -0.05826955f, -0.02567001f, -0.08034672f, 
    0.44364351f, -0.32701093f, -0.13690212f, -0.15949266f, -0.02519849f, -0.10743609f, -0.01332288f, 0.13405222f, 
    -0.04083715f, 0.07084057f, -0.09726194f, 0.02823976f, -0.21783446f, 0.03530117f, -0.02821780f, -0.04034868f, 
    -0.06510224f, 0.10136996f, 0.05072305f, -0.06706718f, 0.10396519f, -0.00855220f, 0.10157775f, -0.00431631f, 
    0.15440929f, -0.08840278f, 0.11607651f, -0.29473329f, 0.06122129f, -0.05088958f, -0.12597956f, -0.04287848f, 
    0.00257852f, 0.00135290f, 0.01189844f, -0.12783994f, 0.21026875f, -0.12190324f, 0.09974758f, -0.25172269f, 
    -0.06796118f, -0.05345677f, -0.01620163f, -0.10718098f, -0.00896775f, 0.02939530f, 0.03544766f, 0.00286859f, 
    -0.13059054f, -0.09221112f, 0.07899836f, -0.04616870f, -0.07815542f, -0.00310499f, 0.13381939f, -0.00166908f, 
    0.07366259f, 0.10279983f, -0.03459935f, 0.03063887f, 0.20055170f, -0.24253692f, -0.17949882f, -0.19104804f, 
    0.10080114f, -0.03829233f, -0.04678176f, 0.17633618f, -0.16829251f, -0.03570911f, 0.10175247f, 0.00238889f, 
    0.10256847f, 0.01284671f, 0.01534825f, -0.00895132f, 0.12354469f, 0.03472221f, -0.08212783f, -0.04935753f, 
    0.02774123f, -0.06376218f, -0.12346137f, 0.05088165f, -0.09768140f, 0.09573626f, -0.13395199f, 0.06125853f, 
    -0.00430234f, -0.08028782f, 0.04618344f, 0.07714040f, 0.15474243f, 0.03492640f, 0.01825306f, 0.14708424f, 
    -0.02796880f, 0.05484434f, -0.13621642f, -0.01611258f, 0.13079317f, 0.06807638f, -0.00838177f, -0.05453969f, 
    -0.09621425f, -0.10024442f, -0.04090208f, -0.00727623f, 0.12030964f, -0.09569463f, 0.08349578f, 0.01048742f, 
    0.05012469f, -0.02138592f, -0.06670488f, -0.08781376f, 0.01061342f, -0.01997466f, 0.08824150f, -0.13748205f, 
    0.14111622f, -0.15834576f, -0.06074940f, -0.05328882f, -0.06355066f, -0.02432918f, -0.14701413f, -0.08981137f, 
    -0.09492108f, 0.14917181f, -0.07151078f, -0.09039088f, -0.12257573f, -0.00792284f, 0.00238609f, 0.01820043f, 
    0.06358348f, -0.05246867f, -0.02145387f, 0.03726351f, 0.17333987f, -0.00676111f, -0.01715112f, 0.00651633f, 
    0.04055188f, 0.15597510f, -0.05039933f, -0.15770070f, 0.08961897f, 0.02731052f, -0.10378290f, 0.08830981f, 
    0.10814125f, -0.15153873f, 0.06349765f, 0.07211965f, 0.10061675f, -0.21290933f, 0.02901194f, -0.16164362f, 
    0.08036257f, -0.06252419f, -0.07224122f, -0.01751302f, 0.03538176f, -0.11998638f, 0.09648816f, 0.01473380f, 
    0.04079812f, 0.00615027f, -0.12507527f, 0.00554524f, -0.09212951f, -0.00441678f, -0.05007339f, -0.07204957f, 
    -0.04761573f, -0.11727804f, -0.08681664f, -0.02701027f, 0.39018962f, -0.25596508f, 0.06607527f, 0.00963067f, 
    -0.04316845f, -0.00986905f, -0.09290174f, -0.17798498f, 0.07188895f, 0.04582191f, -0.12708053f, -0.00251542f, 
    0.19007687f, 0.17143233f, 0.00183795f, 0.22295168f, -0.07899480f, 0.00102336f, -0.07156542f, -0.00999242f, 
    -0.00530173f, -0.02426476f, 0.06018262f, -0.04735314f, 0.15476565f, 0.07485789f, -0.11392154f, 0.06618398f, 
    0.06313784f, 0.04758890f, -0.08180387f, 0.02487242f, -0.02744158f, 0.06170570f, 0.10016812f, 0.09956110f, 
    -0.01867176f, -0.08687317f, -0.04445312f, -0.23510024f, -0.03000532f, 0.03742585f, -0.05667488f, 0.02903545f, 
    0.10783309f, -0.21944842f, 0.02189712f, -0.12379429f, -0.00222874f, -0.16414191f, 0.03859380f, -0.11997389f, 
    -0.02897384f, -0.03777068f, -0.01783295f, -0.00118651f, -0.07972945f, 0.13997196f, -0.07483122f, 0.00884485f, 
    -0.24396455f, 0.09077632f, 0.10672424f, 0.09779352f, -0.02058335f, -0.05134478f, -0.01735710f, -0.04522789f, 
    -0.05589219f, -0.03728156f, 0.08268323f, 0.11208875f, -0.11783907f, 0.14012566f, -0.27010462f, -0.48706803f, 
    -0.04529907f, 0.05762113f, 0.01337045f, -0.04583142f, 0.04161318f, 0.10709366f, -0.07467546f, 0.00520690f, 
    0.35008752f, 0.10243557f, 0.01754963f, 0.14405879f, -0.03271704f, -0.00275542f, 0.00680508f, -0.00403520f, 
    0.09385704f, 0.01042446f, -0.12995178f, 0.07695879f, -0.02212840f, -0.01613397f, -0.01715212f, -0.16630265f, 
    0.10901611f, -0.21061935f, 0.04261992f, 0.05100799f, -0.06117392f, 0.08825193f, 0.02593772f, 0.03821367f, 
    -0.16013822f, -0.01081996f, 0.06871429f, -0.01942691f, -0.10766849f, 0.00852921f, 0.02081091f, 0.02016823f, 
    0.00226022f, 0.06061842f, -0.08642983f, 0.06507348f, 0.13092890f, 0.10279873f, -0.14620736f, -0.02547951f, 
    -0.03830705f, -0.00373075f, 0.01735658f, -0.00157663f, -0.04426338f, 0.08143260f, 0.02530802f, 0.10530274f, 
    0.00499941f, -0.11336856f, 0.15569839f, -0.04362387f, -0.01459620f, -0.07765075f, -0.02328756f, 0.11101400f, 
    -0.00961444f, 0.07739392f, 0.11904732f, 0.01485957f, 0.06317247f, -0.01385834f, 0.05443250f, 0.23846418f, 
    -0.05438798f, 0.03606922f, -0.05612874f, -0.01505522f, 0.00886862f, 0.10876617f, -0.15313043f, 0.17747438f, 
    0.20650284f, -0.02369399f, 0.10222004f, 0.10337818f, -0.14471211f, 0.06577793f, 0.04317599f, 0.00652078f, 
    0.05064145f, 0.07678764f, 0.03434746f, 0.05452844f, 0.01757096f, 0.00592193f, -0.11920592f, 0.00904653f, 
    0.00840496f, 0.05742218f, -0.08568879f, 0.10924926f, -0.09074238f, -0.06719878f, 0.12551197f, 0.03962640f, 
    -0.18837631f, -0.04458077f, 0.06852377f, -0.09897660f, 0.05795417f, -0.05598691f, -0.05036034f, -0.00647739f, 
    0.04237813f, -0.02441485f, -0.19451429f, -0.03561540f, -0.34856284f, -0.03584537f, -0.11501953f, -0.07769246f, 
    -0.08963981f, -0.03269926f, -0.06358310f, 0.00349374f, -0.02744789f, -0.06735838f, 0.04118277f, 0.00725299f, 
    0.06959502f, 0.00217089f, -0.26245368f, 0.11446996f, -0.12462064f, 0.05853227f, 0.01641243f, 0.00146767f, 
    -0.08380266f, 0.04170454f, 0.02773770f, 0.01988987f, 0.19261923f, 0.04453670f, 0.15595263f, 0.15883295f, 
    0.00462530f, -0.10878788f, 0.00974596f, -0.04285412f, 0.12962468f, -0.01615431f, -0.25339806f, 0.10528301f, 
    0.00256432f, -0.08325244f, -0.01617223f, 0.08981740f, -0.02942802f, 0.08969449f, 0.08207397f, -0.08575574f, 
    -0.02624213f, -0.03938011f, -0.03650898f, -0.01637085f, 0.60345554f, -0.16233082f, -0.02037070f, 0.00294536f, 
    0.06680252f, 0.02356900f, -0.01442275f, -0.06203545f, 0.05003170f, 0.06952064f, -0.00941255f, -0.05216334f, 
    0.17828985f, 0.01215450f, 0.15036948f, 0.20614760f, -0.10188644f, -0.08535179f, -0.02859989f, 0.11611793f, 
    -0.04167859f, 0.02567119f, 0.05252612f, 0.00313291f, 0.20697162f, -0.03506552f, -0.09795669f, 0.07406662f, 
    0.10445921f, 0.05826512f, -0.01639123f, -0.07369557f, 0.00376625f, 0.07535027f, -0.06679513f, 0.08414306f, 
    0.04951390f, -0.07703828f, -0.10757000f, -0.13682678f, 0.09590530f, -0.00244306f, 0.02040720f, -0.05316176f, 
    -0.11634599f, 0.04862459f, 0.03836988f, 0.02816377f, -0.50465369f, 0.21899423f, -0.06837205f, 0.07375208f, 
    0.11276770f, 0.06707356f, 0.04639957f, -0.03879284f, -0.02358498f, -0.06768809f, -0.13582809f, -0.00214868f, 
    0.26810119f, 0.03576162f, -0.09558357f, 0.07533875f, -0.00166169f, 0.07420687f, 0.04179813f, 0.02043480f, 
    -0.07727345f, 0.01025174f, -0.02035935f, -0.05898072f, 0.24139558f, -0.09975675f, 0.23351282f, 0.06185323f, 
    -0.08980365f, -0.08112929f, -0.06777989f, 0.14393534f, 0.00766547f, -0.09271961f, -0.04180897f, 0.00398279f, 
    0.08070887f, -0.00811189f, 0.02497344f, -0.06327783f, 0.07843820f, 0.04545633f, 0.02716746f, 0.03636242f, 
    0.01032566f, 0.02057520f, 0.04279807f, -0.01726042f, 0.03521189f, 0.01086272f, -0.16320752f, -0.07198857f, 
    -0.07544615f, 0.02653390f, 0.06855507f, -0.01585337f, -0.04261483f, -0.07822452f, -0.08707169f, 0.03827862f, 
    0.07527599f, -0.22707731f, -0.15463144f, -0.19068679f, 0.06301738f, 0.02135873f, -0.03548193f, -0.10880613f, 
    -0.01926266f, -0.06269074f, 0.05828763f, -0.03217225f, 0.10912196f, -0.01530309f, -0.04811765f, 0.16538854f, 
    -0.08969446f, 0.01544667f, -0.04681943f, 0.00506797f, 0.08155190f, 0.01870700f, -0.05974796f, 0.02972079f, 
    -0.23155588f, -0.04783372f, 0.00350792f, -0.15559246f, 0.11689576f, 0.10044963f, 0.08133725f, 0.06662643f, 
    -0.00377922f, 0.01119164f, -0.08586504f, -0.05051072f, 0.26966825f, -0.03353216f, -0.17206565f, -0.03555723f, 
    -0.14943640f, -0.11035645f, 0.11758167f, -0.04955032f, 0.00340124f, 0.03265866f, -0.06355213f, -0.02815630f, 
    -0.25346059f, 0.04276253f, -0.09879870f, -0.04534470f, -0.12577073f, 0.04277897f, 0.05021799f, -0.02727486f, 
    -0.05079283f, 0.14248145f, -0.14398305f, -0.01167896f, 0.32391134f, 0.05055458f, -0.06635166f, -0.16880406f, 
    0.01591970f, -0.05278921f, -0.03625854f, -0.00101149f, -0.10209852f, -0.04446074f, 0.00725923f, -0.13046946f, 
    -0.10520006f, 0.06399824f, 0.12123261f, -0.04642444f, -0.05548694f, 0.07857593f, 0.06828905f, 0.02090749f, 
    -0.06025716f, -0.06695064f, 0.04222731f, -0.00507968f, -0.00951079f, 0.03232713f, -0.08241145f, -0.01054762f, 
    0.00134636f, 0.02670777f, 0.08210837f, 0.08714590f, -0.04772993f, 0.04275345f, 0.02285478f, -0.09534592f, 
    -0.08218216f, -0.07017381f, 0.05022175f, 0.02226608f, -0.05962517f, -0.08110465f, 0.02527868f, 0.01671189f, 
    -0.04673986f, -0.00093573f, 0.05267274f, 0.01814877f, 0.19165875f, 0.01537064f, -0.03459375f, -0.04156210f, 
    0.05375230f, 0.17111821f, -0.07940625f, -0.06719022f, -0.01272858f, 0.02649408f, 0.07984211f, -0.12946106f, 
    0.17001444f, -0.09045012f, -0.01900538f, 0.04578094f, -0.11839657f, 0.01288101f, -0.03415526f, -0.04012667f, 
    -0.02286376f, -0.04017040f, 0.00511225f, 0.04707416f, 0.51293653f, -0.12756810f, -0.14390700f, 0.10421912f, 
    -0.07125050f, -0.00046010f, 0.00220752f, -0.06996594f, -0.06641987f, 0.00247695f, 0.04824218f, -0.06775171f, 
    0.08697757f, 0.04008573f, -0.11286544f, 0.04855578f, 0.09861858f, 0.00513616f, 0.05996819f, -0.00921905f, 
    0.00918379f, 0.08252967f, 0.07997096f, 0.05399920f, 0.18832652f, 0.00929465f, -0.05762561f, -0.05252222f, 
    -0.09374899f, -0.14049138f, -0.05347332f, -0.02592911f, 0.05691284f, -0.01849283f, -0.07309003f, -0.04754757f, 
    0.24006078f, -0.15751114f, -0.05784600f, 0.03950245f, 0.01454789f, -0.04634173f, 0.00893978f, -0.08104885f, 
    0.10597722f, -0.04677180f, -0.02802968f, -0.12085867f, -0.12514652f, -0.12426931f, -0.02814723f, 0.03908254f, 
    -0.05034835f, 0.06644925f, 0.06948541f, -0.03452564f, -0.01527764f, -0.03069531f, -0.08749335f, -0.01855282f, 
    -0.14387302f, 0.11623622f, -0.01744202f, -0.13534363f, 0.01375840f, 0.01338290f, -0.02969673f, -0.05871208f, 
    -0.09730459f, 0.12231088f, -0.04689037f, -0.04181791f, -0.05734195f, -0.21634772f, 0.00748169f, 0.07231965f, 
    -0.06228062f, 0.04557485f, -0.13906707f, 0.04084769f, -0.08251873f, -0.04030125f, -0.05425302f, -0.05455032f, 
    0.21506299f, 0.10995346f, 0.13831596f, 0.09380613f, -0.03905206f, -0.05412652f, 0.10757869f, 0.01279409f, 
    -0.07634886f, 0.08728294f, 0.06289371f, -0.10537539f, 0.27914307f, 0.11194954f, -0.04350401f, 0.34867910f, 
    -0.15421553f, -0.15417399f, 0.02676396f, 0.10215048f, 0.02883854f, -0.00302697f, -0.05631249f, 0.03177467f, 
    -0.07376370f, 0.11735585f, 0.00958208f, -0.07024319f, -0.10636936f, -0.05195451f, 0.00295811f, -0.01809191f, 
    -0.08261660f, 0.00893785f, 0.02924663f, 0.02022428f, -0.16826643f, 0.01671147f, -0.17913629f, -0.11823414f, 
    -0.02944740f, 0.03673318f, -0.04931590f, -0.00327757f, 0.07425811f, 0.04414815f, -0.09399505f, -0.04775342f, 
    0.05161060f, -0.02460217f, 0.02151987f, -0.00380833f, -0.04106965f, -0.07423055f, 0.08318903f, -0.01902412f, 
    0.00976133f, -0.05059560f, -0.04077991f, -0.01634891f, -0.01912067f, -0.04539361f, 0.05206313f, -0.23013474f, 
    -0.02464245f, -0.05399963f, 0.03153501f, -0.06093978f, 0.00185486f, 0.03983556f, 0.06151128f, -0.04048590f, 
    -0.43760833f, -0.11119010f, -0.17333224f, -0.09133084f, -0.09006660f, 0.02528434f, -0.07544901f, -0.04101076f, 
    -0.02591301f, 0.02793352f, -0.13204825f, 0.07938028f, -0.36971244f, -0.04921239f, -0.09719989f, -0.02316194f, 
    -0.02674796f, -0.06629180f, 0.05776389f, 0.02920285f, -0.06918976f, 0.04994883f, 0.03544363f, -0.08213972f, 
    -0.03549327f, -0.01065199f, 0.02640175f, -0.01449671f, -0.10181476f, 0.02310731f, 0.00898858f, -0.00927159f, 
    -0.02815941f, -0.03505809f, -0.01384924f, -0.02672393f, -0.01467324f, 0.14354411f, -0.26546860f, -0.22332473f, 
    0.02558525f, 0.00367972f, 0.02128417f, -0.06847390f, -0.15751518f, -0.02994313f, -0.03021525f, -0.03125218f, 
    0.01907721f, 0.04316748f, -0.24438646f, -0.00858190f, 0.02516381f, 0.04170905f, 0.03554599f, -0.03128032f, 
    -0.03614461f, -0.00860875f, 0.00126598f, -0.02420802f, -0.19123302f, 0.06698179f, -0.04072570f, -0.10868809f, 
    0.07460362f, -0.02236938f, 0.03364966f, -0.05177666f, -0.06793662f, 0.04460641f, -0.09990444f, -0.04601664f, 
    0.08059426f, -0.06512281f, 0.08260337f, 0.10369259f, 0.04207963f, 0.00189603f, 0.04943824f, 0.10161020f, 
    -0.01456641f, -0.00512873f, -0.00598518f, 0.04555468f, 0.20276323f, 0.04200006f, 0.00167835f, 0.11611766f, 
    -0.07830688f, 0.04788982f, 0.05064330f, 0.06643293f, -0.06586033f, 0.05854674f, -0.00584846f, 0.02644155f, 
    0.05550369f, -0.42611000f, -0.06002362f, -0.03845600f, -0.11420903f, -0.10138190f, -0.04608060f, -0.07034068f, 
    -0.06464318f, 0.05566095f, -0.03753663f, -0.13669817f, -0.01728877f, 0.14063773f, -0.00077133f, 0.17659143f, 
    -0.07713845f, -0.08679656f, 0.09386675f, -0.11129686f, 0.03015583f, 0.05978113f, -0.11330000f, 0.10485268f, 
    0.19811045f, 0.11143996f, 0.04998472f, 0.04929642f, -0.01686122f, -0.09798558f, -0.11044116f, -0.01427328f, 
    0.10618124f, -0.00533712f, 0.06742410f, -0.09824200f, -0.26612324f, -0.05716597f, 0.06269074f, -0.11135089f, 
    0.04529584f, -0.09184637f, 0.05672502f, 0.11715585f, -0.02649580f, -0.02571259f, 0.00394745f, -0.09305876f, 
    0.06977818f, -0.06125903f, 0.04120209f, -0.08274782f, 0.03346153f, 0.02238651f, 0.00665391f, -0.03150960f, 
    -0.00616264f, -0.01803580f, 0.00832672f, 0.09972920f, 0.02155781f, -0.11454669f, 0.09449151f, 0.02611878f, 
    -0.06753790f, -0.02918110f, -0.08059277f, -0.03413880f, 0.03706941f, -0.08155332f, -0.02823441f, 0.05052442f, 
    -0.29628581f, -0.22851223f, 0.01602582f, -0.02380537f, -0.04756254f, -0.01030131f, -0.06708900f, -0.05414528f, 
    -0.00546896f, 0.04159430f, -0.09418101f, 0.01399428f, -0.13906759f, 0.00277678f, 0.08022504f, -0.24417308f, 
    -0.11491811f, -0.00807415f, -0.06824571f, -0.00628339f, 0.02660209f, -0.05812388f, -0.01027782f, -0.01503400f, 
    0.05549870f, -0.02869898f, -0.10417318f, -0.02292436f, -0.04952993f, 0.03538105f, -0.02743433f, 0.03434370f, 
    -0.03263200f, -0.04478399f, -0.00432638f, -0.08937647f, 0.22008960f, -0.14096771f, -0.15062471f, -0.14322209f, 
    0.03933483f, 0.02982449f, 0.01485735f, -0.15859850f, 0.00431515f, 0.06998846f, 0.02370751f, 0.02478273f, 
    0.01368289f, 0.05558145f, -0.00649321f, -0.02602815f, 0.07540098f, 0.01155460f, 0.01964017f, 0.03815715f, 
    -0.06067147f, -0.06651546f, -0.02156784f, -0.08080095f, -0.33428171f, 0.07094552f, -0.02179106f, 0.05725336f, 
    0.01476004f, -0.01127109f, -0.08615151f, -0.07263604f, -0.02592839f, -0.02643151f, 0.04425910f, -0.01085212f, 
    0.11670143f, 0.03489377f, 0.05012843f, -0.06379391f, 0.08341122f, 0.00570900f, 0.00865140f, -0.03895835f, 
    0.06754062f, -0.02475783f, -0.05601986f, -0.08414306f, 0.33415541f, -0.10178538f, 0.06018804f, -0.10550632f, 
    -0.05108375f, -0.09344996f, -0.01033981f, -0.01684864f, 0.00268205f, -0.02097371f, -0.05362459f, -0.02978640f, 
    0.19032125f, -0.05842424f, -0.02315647f, -0.01212471f, -0.03606351f, 0.05256384f, 0.03323978f, -0.02136493f, 
    -0.02915707f, -0.04210316f, -0.04765878f, -0.07775116f, 0.04818485f, 0.05609373f, -0.09644145f, 0.03861645f, 
    0.14485343f, -0.00233104f, -0.00430191f, -0.03666618f, -0.00641566f, -0.02565081f, -0.03741898f, -0.00159969f, 
    -0.02577728f, -0.02657809f, -0.06177809f, 0.02764759f, 0.03311569f, 0.09654573f, -0.03014001f, -0.06691695f, 
    0.04600814f, 0.05805914f, -0.03090108f, -0.05677744f, -0.05784881f, -0.19750468f, -0.00164070f, 0.08056296f, 
    -0.00649303f, -0.02908808f, 0.01542205f, -0.01203485f, -0.06391340f, -0.02973585f, 0.04602901f, -0.05275058f, 
    -0.12380931f, -0.02016992f, -0.17431071f, 0.04641238f, -0.06348193f, 0.08917094f, 0.06833387f, 0.06588231f, 
    -0.01052554f, 0.09260608f, 0.08003350f, -0.01363749f, 0.20108476f, 0.03702584f, -0.13995205f, -0.09284215f, 
    -0.00287142f, -0.02066013f, 0.00703948f, 0.14730668f, 0.09330751f, -0.01584787f, -0.08216000f, -0.13423537f, 
    0.14132643f, -0.21354017f, 0.10461224f, 0.01097580f, -0.17106782f, 0.01355414f, -0.03452244f, 0.01063496f, 
    0.12753402f, -0.05255768f, -0.01358305f, -0.03918682f, 0.16473256f, 0.03512989f, 0.01079167f, -0.05817594f, 
    -0.02859697f, 0.01081189f, -0.01463523f, 0.13073309f, 0.00852674f, 0.13407931f, 0.11415306f, -0.11864608f, 
    -0.08520138f, 0.16161674f, -0.19218363f, -0.09451025f, -0.18774095f, 0.01158673f, -0.09075976f, 0.07107324f, 
    0.08716527f, -0.02916713f, -0.08875976f, 0.02482608f, -0.03550949f, 0.01001765f, 0.32542396f, 0.11636823f, 
    0.10118735f, 0.05736277f, 0.09451147f, -0.01489959f, -0.08006302f, 0.13149238f, -0.09063838f, -0.04354048f, 
    0.01524926f, -0.11103152f, -0.06781053f, -0.13390782f, -0.15381227f, -0.05213024f, 0.03415323f, -0.03115888f, 
    -0.10712384f, 0.00029866f, -0.00795772f, -0.05410766f, 0.47906086f, -0.33374602f, -0.22569661f, 0.26010382f, 
    -0.02539793f, 0.02657297f, -0.02512161f, 0.00721031f, 0.03615993f, 0.06766104f, 0.03146073f, 0.00247571f, 
    0.11712331f, 0.04215452f, 0.07459030f, 0.09544688f, 0.11887016f, 0.00637056f, 0.04507081f, -0.00927353f, 
    -0.07577678f, 0.02766039f, 0.02153039f, -0.12215894f, -0.14361720f, 0.17551558f, -0.08214747f, 0.10197004f, 
    -0.10789498f, 0.05851006f, -0.03223009f, -0.04832821f, 0.01398902f, 0.00459872f, -0.02857345f, 0.05429947f, 
    -0.45211485f, 0.21185820f, -0.05769249f, -0.06598011f, -0.04334804f, -0.00341606f, -0.06116443f, 0.06496005f, 
    0.07358153f, -0.05498459f, -0.02086140f, -0.02502669f, -0.05229010f, 0.02018410f, -0.19691786f, 0.01173939f, 
    -0.12054665f, -0.09397517f, -0.01991020f, -0.02576805f, -0.01579771f, -0.11766870f, -0.05448293f, 0.01869241f, 
    -0.40095451f, -0.33715740f, -0.08019187f, -0.10711911f, 0.02748698f, 0.07503065f, -0.04430923f, -0.12781394f, 
    0.02477011f, -0.02489829f, 0.05736220f, 0.02715990f, -0.15320230f, 0.08040883f, 0.09604180f, -0.12141538f, 
    0.01627304f, 0.02715616f, -0.04225111f, 0.03776562f, 0.01215648f, -0.04953809f, 0.00028333f, 0.06003991f, 
    0.38334754f, 0.02880589f, -0.14431196f, 0.04060145f, -0.05704877f, 0.10923733f, 0.07922449f, 0.09694857f, 
    -0.05716168f, -0.00200177f, 0.03049382f, -0.01504169f, -0.05873696f, 0.00972698f, -0.00783472f, 0.00195465f, 
    -0.07666434f, -0.04837462f, 0.06549854f, -0.04550457f, -0.03691855f, 0.00878235f, 0.13941303f, -0.03065270f, 
    0.05928998f, -0.26650953f, -0.25794262f, 0.15383258f, -0.02927964f, 0.08439726f, 0.15372150f, 0.05775410f, 
    -0.06458431f, 0.07643411f, -0.07566012f, -0.05186501f, 0.05998991f, 0.15271370f, 0.11729294f, 0.00448793f, 
    -0.02275961f, -0.03438055f, -0.03396307f, 0.04694464f, -0.04920844f, 0.03437196f, -0.01228350f, 0.14819704f, 
    0.17143868f, 0.15015681f, -0.09207579f, -0.01196172f, -0.11682811f, 0.00107865f, -0.02328064f, -0.05936294f, 
    -0.04001560f, 0.04181425f, 0.18715255f, 0.02962065f, 0.04164751f, 0.13517040f, 0.02283012f, -0.03074627f, 
    -0.08410969f, 0.01874185f, -0.15506023f, 0.10508794f, -0.03003795f, -0.05611716f, 0.02432602f, 0.07103204f, 
    -0.23641181f, -0.31029701f, -0.22640528f, 0.04756859f, -0.06524778f, 0.02337717f, -0.01233952f, 0.05104297f, 
    -0.01933555f, 0.01031101f, -0.06064714f, 0.01463861f, -0.17972416f, -0.04192210f, 0.00707116f, -0.05179906f, 
    -0.09879819f, 0.02039626f, 0.07036004f, 0.07186805f, 0.03434738f, 0.01522576f, 0.03272332f, -0.05996154f, 
    0.03108556f, -0.17085834f, 0.02562360f, 0.08306717f, -0.06169665f, -0.02802213f, 0.05336963f, 0.09583733f, 
    -0.08033597f, 0.12419123f, -0.03709139f, -0.01331901f, -0.01682577f, 0.07945135f, 0.19797260f, 0.22506224f, 
    0.09241451f, 0.12433776f, 0.00486206f, -0.04942831f, 0.04895924f, 0.04241759f, -0.10368932f, -0.08855092f, 
    -0.05365252f, 0.07367756f, 0.03219581f, 0.01035363f, 0.01084011f, -0.07822201f, 0.00782347f, -0.03090886f, 
    -0.05900100f, -0.11857838f, -0.04832856f, -0.09837569f, 0.06924383f, -0.05029328f, 0.11432566f, 0.04054616f, 
    -0.01426008f, -0.07681101f, -0.00588292f, -0.02484086f, -0.03153296f, -0.00673608f, -0.03025558f, -0.01874363f, 
    -0.28598100f, -0.40030250f, -0.13711736f, -0.15800957f, -0.05895438f, -0.07651086f, -0.03345030f, -0.01219933f, 
    -0.01910491f, -0.08217374f, -0.10063297f, 0.06154031f, 0.03786322f, 0.13138317f, 0.08030622f, 0.16076797f, 
    -0.01153348f, -0.16794738f, 0.01760728f, -0.12300506f, -0.09906555f, 0.05830510f, 0.01516935f, 0.02987562f, 
    0.01715564f, -0.07304815f, 0.10992674f, 0.00606459f, 0.08584397f, -0.10805382f, 0.02743143f, -0.06371047f, 
    0.05932000f, -0.09736672f, -0.03565839f, -0.05803442f, 0.00649115f, -0.09109870f, -0.11576816f, 0.19977608f, 
    -0.00596740f, 0.01748232f, 0.09703240f, 0.01294131f, -0.00959423f, 0.09795409f, -0.01308143f, 0.03418045f, 
    0.13943358f, -0.44156438f, -0.31499887f, 0.01476546f, -0.10346818f, 0.05183488f, -0.07351326f, -0.04635154f, 
    0.02813637f, -0.02300970f, 0.03837537f, 0.04206155f, 0.43479905f, 0.07412789f, -0.05015803f, 0.31200618f, 
    0.04286646f, 0.07698441f, 0.21554887f, 0.03520961f, 0.05570023f, -0.06695252f, 0.01112832f, -0.00858681f, 
    -0.03020221f, 0.15352146f, -0.03960791f, -0.20202772f, -0.05333233f, 0.06330974f, -0.00208649f, 0.04538418f, 
    -0.01272556f, -0.08280803f, -0.06280246f, 0.08511643f, 0.02795279f, -0.05581360f, -0.08115750f, -0.15737268f, 
    -0.03769525f, -0.05718606f, 0.00592790f, -0.01986813f, -0.06977082f, 0.00782320f, -0.05521249f, 0.00472451f, 
    0.18239945f, -0.29996789f, -0.12313457f, 0.03028325f, -0.01806636f, 0.02626998f, 0.02220677f, -0.00110496f, 
    0.00617412f, 0.01164853f, 0.01245016f, 0.01717802f, 0.16979335f, -0.05634481f, 0.18214580f, 0.06839851f, 
    0.05590148f, 0.10774220f, 0.02537133f, 0.02479396f, 0.03267696f, -0.03810165f, -0.08744374f, 0.01431675f, 
    -0.09570417f, 0.05186028f, 0.06708264f, 0.03086199f, -0.11363524f, -0.01792411f, 0.01033776f, 0.00749330f, 
    0.01270220f, 0.01231880f, 0.04754831f, 0.02983486f, 0.04457491f, 0.05242660f, -0.00128694f, 0.04376982f, 
    -0.15828544f, -0.03790345f, -0.00950816f, 0.08207463f, -0.02216750f, 0.03429995f, -0.07226221f, -0.00564179f, 
    0.12036692f, -0.09173370f, -0.07728013f, -0.06495260f, -0.07135252f, 0.00723531f, -0.03568196f, -0.07145498f, 
    0.02053466f, 0.01779994f, -0.02505342f, -0.00986077f, 0.16039005f, -0.16483384f, -0.00342128f, 0.00603900f, 
    -0.10560782f, 0.03285044f, -0.05034883f, 0.01375231f, 0.07421882f, -0.02758444f, -0.11580250f, 0.00645078f, 
    -0.16595110f, 0.04232704f, -0.11063889f, -0.01691379f, 0.06667767f, 0.00895407f, -0.05794571f, -0.06604072f, 
    0.01129329f, 0.08830024f, 0.13569292f, 0.00348292f, -0.48162082f, 0.07008301f, 0.01060222f, -0.02951155f, 
    -0.07591331f, 0.06359370f, -0.01185586f, -0.06273612f, -0.04601102f, -0.04773386f, 0.07703244f, 0.00052376f, 
    -0.34813607f, 0.17099109f, 0.13390179f, -0.01916930f, -0.02882878f, -0.01840033f, 0.02824269f, 0.08190419f, 
    -0.03870323f, 0.07005659f, 0.00806965f, -0.04972920f, 0.13058850f, 0.01290957f, 0.11081612f, 0.13496304f, 
    -0.00783416f, -0.02954054f, 0.02396213f, 0.00103243f, -0.02140308f, -0.00435108f, -0.09603360f, 0.04062392f, 
    -0.05910528f, 0.08335198f, -0.09867489f, -0.00882198f, -0.01953325f, -0.00661809f, 0.02327332f, -0.06814564f, 
    -0.05957841f, -0.10587686f, 0.06398651f, -0.09227160f, -0.27418080f, -0.00710050f, -0.12534192f, -0.01707898f, 
    -0.05016631f, -0.03377273f, -0.05299297f, 0.00045018f, -0.08111822f, 0.03023358f, 0.01291573f, 0.01030308f, 
    -0.00783355f, 0.08590675f, 0.05019873f, 0.07914731f, -0.01920195f, -0.07313296f, -0.06070278f, -0.05233454f, 
    -0.00121333f, 0.15525460f, -0.03393107f, -0.07344884f, 0.05618723f, -0.03844531f, -0.04258802f, -0.01772209f, 
    -0.03713008f, -0.07816248f, 0.08138714f, -0.02176433f, -0.08797100f, 0.09116028f, -0.05980260f, 0.11942872f, 
    0.08362614f, 0.08191519f, 0.08378284f, -0.15008384f, -0.00120744f, 0.01985775f, 0.01916697f, -0.02130847f, 
    -0.03248575f, -0.03621426f, -0.06793440f, 0.00142572f, -0.18919927f, -0.18414634f, -0.33197728f, 0.03161761f, 
    -0.21279104f, -0.01407531f, 0.05087591f, -0.01418933f, 0.04271870f, 0.00386976f, -0.01070652f, 0.01027402f, 
    -0.12444908f, -0.43332365f, -0.14038281f, -0.04985812f, -0.05018516f, -0.19471790f, 0.00176230f, 0.01779227f, 
    0.04036544f, 0.02888891f, 0.08713690f, 0.06220703f, -0.14529571f, 0.01599698f, -0.05146275f, -0.01235161f, 
    0.02878987f, -0.06641683f, 0.08450838f, -0.01036106f, 0.00425315f, -0.00066633f, -0.03078624f, -0.05356537f, 
    0.13544495f, 0.13681658f, 0.15043665f, 0.04134339f, -0.01297294f, -0.00491736f, -0.01952219f, -0.06185509f, 
    0.08630005f, 0.06017981f, 0.00443370f, 0.05554292f, 0.08294881f, 0.04419136f, 0.01987422f, -0.00532090f, 
    -0.00271132f, -0.10535672f, 0.08552530f, 0.04939578f, -0.09476577f, -0.04325400f, 0.05616587f, -0.04783398f, 
    -0.14180051f, -0.09947117f, 0.12281633f, 0.09271547f, 0.04426836f, -0.08296028f, -0.01542867f, 0.05022653f, 
    0.00352692f, -0.01662439f, -0.04970107f, -0.06579758f, 0.42473373f, 0.32147494f, 0.13548972f, -0.04136354f, 
    0.03065620f, 0.02250717f, -0.01967440f, 0.10183434f, -0.01612641f, 0.14577931f, -0.10298041f, -0.00954854f, 
    -0.20797102f, -0.17473771f, -0.04392356f, -0.01389808f, -0.10349381f, -0.06324341f, 0.09124114f, -0.01304498f, 
    -0.06665772f, 0.00221651f, 0.05631842f, 0.04557326f, 0.22119898f, -0.03303286f, -0.04944379f, 0.03858024f, 
    -0.05285368f, -0.04001555f, -0.06722450f, -0.02933197f, 0.02123728f, -0.01702604f, 0.02332117f, -0.00641622f, 
    0.18550380f, -0.07336317f, -0.00965692f, 0.03840823f, 0.01162323f, 0.03624221f, -0.01045854f, -0.09706352f, 
    0.01314360f, 0.00321718f, 0.01027839f, -0.02357481f, 0.05225815f, 0.05912082f, -0.09037789f, 0.00345240f, 
    -0.05728968f, -0.17774914f, 0.05251480f, -0.02363792f, -0.00060056f, -0.11033923f, -0.00317041f, 0.01128678f, 
    0.11848504f, 0.20022337f, 0.08112721f, 0.10288808f, -0.02109188f, 0.11561318f, -0.06908253f, -0.00189869f, 
    -0.03347324f, -0.05984288f, 0.01351135f, -0.04164968f, -0.25511345f, -0.48633111f, -0.01685236f, 0.13420168f, 
    -0.10276961f, -0.01793275f, 0.13380584f, -0.15406813f, 0.06104401f, -0.11506424f, 0.06993313f, -0.11520467f, 
    -0.14520769f, -0.44171402f, -0.03739514f, 0.25936779f, 0.00651828f, 0.07686052f, 0.04792010f, -0.17501964f, 
    -0.00099348f, -0.09974207f, -0.11650862f, 0.02954947f, 0.01470674f, 0.11211476f, 0.06104120f, 0.14655949f, 
    -0.01974776f, 0.00270605f, -0.05460263f, -0.13250150f, -0.06495504f, 0.06438953f, -0.06556098f, -0.06839609f, 
    -0.01825846f, -0.01340087f, 0.05470244f, 0.01477582f, -0.08205678f, 0.07644675f, 0.07666194f, 0.08181605f, 
    0.04143424f, 0.06086769f, 0.01947671f, 0.03781657f, -0.17119892f, 0.14019604f, 0.13322352f, -0.04392878f, 
    0.11025311f, -0.05890145f, 0.01653729f, 0.04475258f, 0.00153858f, -0.01023676f, -0.03485854f, 0.04155073f, 
    0.02244190f, -0.07456204f, -0.04896267f, 0.07092323f, 0.03694883f, -0.16830726f, 0.00667704f, 0.06673349f, 
    -0.08312555f, 0.02639518f, 0.05691469f, -0.02200641f, 0.18767101f, -0.15411615f, -0.20753488f, 0.09801376f, 
    -0.00491899f, 0.02290577f, 0.10589772f, 0.00071380f, 0.04117861f, 0.03888113f, 0.04328716f, -0.05743814f, 
    0.16975528f, -0.03685325f, -0.22905402f, 0.02108014f, -0.01415949f, -0.03300368f, 0.02792854f, -0.09364711f, 
    -0.01796446f, -0.05168176f, -0.05423670f, -0.04812642f, -0.55049711f, 0.21087353f, -0.00257988f, -0.17214106f, 
    0.08722978f, -0.11042225f, -0.08709531f, -0.01871498f, -0.11205401f, -0.05617115f, -0.02103749f, 0.06196539f, 
    -0.47131953f, 0.09978461f, 0.08708641f, 0.16849495f, 0.06545608f, 0.06994626f, -0.05406346f, 0.01322043f, 
    -0.11322717f, -0.02697805f, 0.02057864f, 0.07327717f, -0.03247366f, 0.24257345f, 0.05901613f, -0.01775754f, 
    -0.11278120f, 0.04241082f, -0.02135997f, 0.09795622f, 0.02723623f, -0.06393560f, -0.00838119f, 0.05624810f, 
    -0.02191135f, 0.04519977f, 0.10207552f, -0.02688308f, -0.03453878f, 0.10844503f, -0.01341652f, 0.00034534f, 
    -0.00078789f, -0.06604396f, 0.00026606f, 0.02422802f, -0.12989040f, -0.32088649f, -0.32194433f, -0.04584657f, 
    -0.02121846f, -0.04580266f, 0.05921409f, -0.10448485f, 0.00628347f, 0.00855414f, 0.01366569f, -0.07942265f, 
    0.12098888f, 0.18347645f, -0.06842809f, 0.08023848f, -0.08804155f, 0.09909672f, 0.05690955f, 0.04627501f, 
    -0.03078811f, -0.02358691f, 0.01755735f, 0.12184215f, -0.51440948f, 0.10194259f, 0.12335285f, 0.20850562f, 
    -0.04498416f, -0.04715410f, 0.06469473f, 0.00247669f, -0.03852597f, 0.08588441f, -0.01152655f, 0.00086427f, 
    0.05429027f, -0.02033546f, -0.14248675f, 0.12223053f, 0.01445657f, -0.06381528f, 0.06007677f, 0.00512269f, 
    0.01157123f, 0.10116886f, 0.02699265f, 0.04751644f, 0.01583963f, -0.01033908f, 0.08103020f, -0.15635775f, 
    -0.09377378f, -0.13016066f, 0.11441593f, -0.13734747f, 0.10948887f, -0.01174910f, -0.00669853f, -0.00752369f, 
    0.08411055f, -0.00848432f, 0.07590831f, -0.24077395f, 0.00667442f, 0.15949905f, 0.02810656f, 0.02883712f, 
    0.03804827f, -0.01782574f, -0.01370355f, 0.01040356f, -0.20058741f, -0.00617107f, -0.08811119f, 0.07024723f, 
    0.02927284f, 0.01523977f, 0.01848704f, -0.02351422f, -0.04020865f, 0.03111921f, 0.01733497f, 0.12532294f, 
    -0.22738653f, -0.08513526f, 0.12719482f, 0.04794042f, -0.13745227f, 0.02137858f, -0.11203681f, -0.12608260f, 
    0.07190656f, -0.19680594f, -0.09706873f, -0.03655185f, -0.11401789f, -0.00108552f, 0.10344498f, -0.06794281f, 
    0.14457840f, 0.04851612f, -0.01413903f, 0.04432758f, -0.09475281f, 0.02064886f, -0.03287318f, -0.00407241f, 
    0.09935351f, 0.09175193f, -0.05041116f, -0.07673901f, 0.10058194f, 0.00169043f, -0.00319082f, -0.15024029f, 
    -0.04114256f, -0.09496582f, -0.01650333f, 0.08463859f, 0.32341146f, 0.04348622f, 0.07732894f, -0.07365570f, 
    -0.01652275f, -0.10957953f, 0.05374807f, 0.06989873f, 0.06067758f, 0.05350986f, -0.19683637f, 0.10180438f, 
    -0.11127841f, -0.20473461f, 0.16679628f, -0.12109368f, -0.05870205f, -0.01646827f, -0.13167940f, -0.08088530f, 
    0.05115888f, 0.00621526f, 0.00278081f, -0.02755559f, -0.10989353f, -0.13897380f, -0.10523384f, -0.17767553f, 
    -0.03017019f, -0.04235265f, 0.09750485f, 0.09397570f, -0.02719340f, 0.06473543f, 0.01539971f, -0.09544461f, 
    -0.24467619f, -0.03124812f, 0.00329552f, 0.00499189f, 0.02131514f, 0.10953029f, 0.08755660f, 0.01569753f, 
    0.01858406f, -0.00781986f, 0.02443445f, 0.01941641f, -0.34571058f, -0.10923211f, 0.25112042f, 0.21763669f, 
    -0.01562115f, -0.02576594f, -0.01365884f, -0.10454046f, 0.05847784f, 0.06282956f, -0.06792927f, -0.04310136f, 
    -0.19638723f, 0.07884913f, -0.00387278f, 0.09646142f, 0.01397833f, -0.06047817f, 0.00714600f, -0.00833593f, 
    -0.05251825f, 0.05612226f, 0.08667780f, 0.00909995f, -0.08382300f, 0.07354511f, -0.04631031f, 0.08867139f, 
    -0.05442014f, -0.07304775f, -0.01600453f, 0.07944423f, 0.10297338f, 0.03809620f, 0.07144579f, -0.13814458f, 
    0.19203621f, -0.06543839f, 0.08929786f, 0.16155326f, -0.10460613f, -0.01911689f, 0.07436004f, 0.00727983f, 
    0.00668643f, 0.02940567f, -0.10405886f, -0.05630538f, -0.03312435f, -0.01357865f, -0.19662333f, -0.10945007f, 
    -0.01531475f, -0.02393806f, 0.08775408f, 0.00931042f, 0.00253313f, -0.15776834f, 0.05282346f, -0.04841515f, 
    -0.21945591f, 0.11208387f, 0.01658482f, -0.20668787f, 0.02342154f, -0.03013293f, 0.01349989f, 0.13105680f, 
    0.04966450f, -0.10826121f, -0.02199670f, -0.10947510f, -0.10333371f, -0.01735886f, 0.13570863f, -0.13618615f, 
    -0.09315596f, 0.08429291f, 0.02233139f, 0.07279306f, 0.06721225f, 0.08308092f, 0.02565084f, 0.08975878f, 
    -0.13394618f, -0.21795821f, 0.08660691f, 0.06109617f, -0.11983413f, -0.09714958f, 0.05002305f, -0.06288291f, 
    0.07956080f, 0.00596089f, 0.03155686f, -0.04025472f, 0.01017187f, 0.28478470f, -0.14080879f, -0.07045971f, 
    -0.10667522f, -0.03970266f, -0.00862232f, 0.03064060f, 0.01580151f, -0.06228213f, 0.09073067f, -0.01360157f, 
    0.05238969f, 0.15307245f, 0.04256370f, 0.12290464f, 0.09143185f, 0.02694851f, 0.04185059f, 0.02850908f, 
    0.01960514f, 0.01851403f, 0.09091645f, -0.00468916f, -0.36149812f, 0.01428124f, 0.08413449f, 0.11918344f, 
    0.09792478f, 0.01825847f, 0.06083900f, 0.08284611f, -0.00325244f, -0.07767478f, -0.02419159f, 0.02349585f, 
    0.01873456f, -0.07184894f, -0.00090435f, -0.18995619f, -0.07322148f, 0.14478126f, 0.00659059f, -0.10051297f, 
    -0.02527904f, -0.07236111f, 0.04429734f, -0.14216448f, -0.06547189f, 0.09425899f, 0.13326180f, -0.12919213f, 
    -0.04504141f, 0.03021123f, -0.00210507f, -0.02260101f, -0.16353068f, 0.04801881f, -0.01342693f, 0.08087894f, 
    -0.22049311f, -0.06077822f, 0.13167384f, 0.18363917f, -0.02922988f, -0.03760255f, 0.19611917f, 0.00603223f, 
    -0.01993173f, 0.07456919f, 0.00550576f, 0.05210634f, -0.10825677f, -0.22916269f, 0.00514947f, 0.07841063f, 
    0.02107789f, 0.06718788f, 0.06798659f, -0.02050814f, -0.02895070f, -0.04305283f, -0.08194665f, -0.12032554f, 
    0.23588260f, 0.10916427f, 0.13883761f, 0.08449043f, -0.03747870f, 0.02341032f, 0.06888534f, 0.09291464f, 
    0.00045194f, -0.07972614f, -0.00466285f, 0.05748834f, 0.07294601f, 0.00410156f, -0.12396812f, 0.09380122f, 
    -0.13296668f, 0.09105597f, 0.16475558f, 0.00541474f, 0.00397734f, 0.16181302f, -0.00626999f, 0.01649074f, 
    0.09102561f, -0.11367401f, -0.06851061f, 0.02521185f, -0.16811027f, 0.01035323f, -0.00125676f, 0.11277453f, 
    -0.12125460f, 0.05337471f, 0.11513221f, -0.04959447f, -0.27449593f, 0.02305842f, 0.29274166f, 0.00925649f, 
    0.04577553f, -0.04413427f, -0.00197106f, -0.04373999f, 0.13591160f, 0.01089131f, 0.00499775f, -0.15921777f, 
    0.15031393f, 0.04122508f, -0.05141882f, -0.03507388f, -0.04024724f, 0.05261894f, 0.11001994f, 0.02986203f, 
    -0.01189536f, 0.05867282f, -0.01156821f, -0.01252232f, -0.05983673f, -0.07456924f, 0.14051262f, -0.10084689f, 
    0.00661214f, 0.10812962f, -0.09403617f, 0.10004387f, 0.07997759f, -0.04727784f, -0.04113003f, 0.04159582f, 
    -0.06328203f, -0.22319670f, -0.19952463f, 0.09539611f, 0.09691001f, 0.03651470f, 0.00867790f, 0.04181102f, 
    -0.01337066f, -0.12498307f, 0.01539651f, 0.02549697f, 0.32935402f, 0.00122121f, -0.03701608f, 0.00587816f, 
    -0.00901778f, 0.13220957f, 0.08421738f, 0.12411033f, 0.05615259f, 0.03329601f, 0.09246688f, 0.07926270f, 
    -0.05116276f, 0.17928717f, 0.11222164f, -0.09373306f, 0.05781974f, -0.03311118f, 0.00179700f, -0.02209226f, 
    -0.04481754f, 0.01282571f, 0.06782080f, 0.02921334f, -0.21267621f, -0.07016829f, 0.07218544f, 0.15916428f, 
    -0.09660184f, 0.00883517f, 0.11788405f, -0.01994558f, -0.14560321f, 0.04493777f, -0.02442977f, -0.00218784f, 
    -0.38156864f, 0.04259066f, -0.04990829f, -0.02999694f, 0.05703011f, 0.00652888f, 0.00043867f, 0.03929339f, 
    -0.06852584f, -0.10493094f, -0.05488352f, 0.12506007f, -0.31712279f, 0.24073677f, 0.15021975f, -0.08179279f, 
    0.12784289f, -0.01275785f, -0.09215086f, 0.09528952f, 0.11144938f, -0.01154467f, -0.03796908f, 0.05407433f, 
    0.21990719f, -0.04623528f, 0.02608383f, 0.04734618f, 0.07554595f, -0.05796390f, 0.10007522f, 0.06443669f, 
    -0.05872757f, 0.00030665f, 0.00481816f, -0.07958425f, -0.03336162f, -0.15928683f, -0.22431795f, -0.03542188f, 
    0.03334226f, 0.04855680f, 0.11023536f, -0.03407130f, -0.03832122f, 0.04484053f, 0.01952383f, -0.06968750f, 
    0.07212809f, 0.10492607f, -0.20809010f, 0.18220799f, 0.12375505f, -0.08294320f, 0.02930030f, 0.09470592f, 
    -0.04565545f, 0.06855304f, -0.05474982f, 0.06005778f, -0.10614078f, 0.03898894f, 0.08303788f, 0.09811937f, 
    0.04009078f, -0.00757643f, 0.12230824f, -0.02005734f, 0.03528464f, 0.03802638f, -0.02720761f, -0.07008997f, 
    0.09367006f, -0.22045358f, 0.08630251f, 0.01482861f, -0.13921762f, 0.05596245f, -0.06674061f, 0.00084377f, 
    -0.00856385f, 0.10375502f, -0.13450375f, 0.03685877f, 0.38566011f, 0.24732949f, -0.19438262f, -0.10774790f, 
    -0.18743402f, -0.08451082f, 0.15868185f, -0.07195511f, -0.05901688f, -0.01048946f, -0.01123446f, -0.02172768f, 
    0.10712957f, 0.06101898f, 0.08380554f, -0.07626513f, -0.01580581f, -0.01160234f, -0.09670084f, 0.11952373f, 
    0.09729296f, 0.06717636f, 0.06135183f, -0.08329280f, 0.29724279f, -0.09402165f, -0.15140259f, 0.12269795f, 
    -0.10899555f, 0.06298313f, -0.00845269f, -0.05125490f, -0.03102362f, 0.08752842f, -0.05243384f, 0.00592384f, 
    -0.18070604f, -0.07345188f, 0.01388017f, 0.11423891f, -0.11347325f, 0.08594596f, -0.13952936f, -0.13517404f, 
    0.02783586f, 0.04384109f, -0.08627731f, -0.05448005f, -0.41641870f, 0.13908198f, 0.03996335f, -0.06904986f, 
    0.07288267f, -0.02178560f, -0.02681997f, 0.14154978f, 0.01062748f, -0.10505863f, -0.03895318f, 0.04327116f, 
    -0.31276190f, -0.12710142f, -0.08104575f, 0.04315793f, 0.09609159f, -0.00583139f, 0.09659164f, -0.13827688f, 
    0.06682564f, 0.07874585f, -0.01175419f, -0.09356981f, -0.04517962f, -0.04263080f, 0.04652038f, 0.16487029f, 
    -0.15392695f, -0.07485318f, 0.07528451f, -0.02063846f, 0.05153055f, 0.03522371f, -0.01559358f, -0.22856300f, 
    -0.45864415f, -0.05492644f, 0.05892532f, 0.18699448f, -0.13969135f, 0.00084237f, -0.10117131f, 0.04625814f, 
    0.07704763f, -0.05216366f, 0.01385293f, 0.01740499f, 0.02576994f, 0.04283912f, -0.02112650f, 0.05969981f, 
    0.07094157f, -0.03797819f, 0.03627956f, 0.07862981f, 0.06638879f, -0.01112193f, 0.02067197f, 0.02986072f, 
    -0.10415026f, -0.05096912f, 0.13853674f, 0.11006427f, -0.04286508f, -0.10446461f, 0.15935387f, 0.11771952f, 
    0.01293697f, 0.05843280f, 0.15913160f, 0.08185855f, -0.08593361f, -0.21170987f, 0.08823510f, -0.15235822f, 
    -0.10902999f, 0.02545913f, -0.18957862f, -0.06705196f, -0.01307607f, 0.02985509f, -0.06703012f, 0.11361971f, 
    -0.01538706f, 0.30650616f, -0.33980855f, -0.39366511f, -0.05216813f, -0.05500809f, -0.02356965f, 0.05864228f, 
    0.00459265f, 0.02719985f, 0.00852561f, 0.01134793f, -0.05581497f, -0.09396564f, -0.03195207f, 0.08627915f, 
    -0.13340251f, 0.00395151f, 0.04315448f, 0.04121071f, -0.01672767f, -0.12258296f, 0.10141397f, -0.00576764f, 
    -0.04710380f, 0.00578081f, 0.07932488f, -0.11783165f, 0.02163389f, -0.04928595f, -0.03727918f, -0.02438774f, 
    -0.06124496f, 0.05569402f, 0.15498737f, 0.19556004f, -0.38372970f, 0.06199006f, 0.01873695f, -0.33338308f, 
    0.01762450f, 0.06311695f, -0.05151700f, 0.01758379f, 0.04825011f, -0.10281225f, -0.04469921f, -0.12387182f, 
    -0.30617660f, -0.11854260f, -0.26857063f, 0.03016439f, 0.12825286f, 0.03773507f, 0.04340519f, -0.27296525f, 
    0.03927108f, -0.09048416f, -0.08154535f, 0.07443999f, -0.10879721f, -0.01044210f, 0.18118124f, 0.11844057f, 
    -0.00529518f, -0.07210748f, 0.04163909f, -0.00792993f, 0.02349858f, 0.04158358f, -0.18208072f, -0.03656657f, 
    -0.03833578f, -0.05049711f, 0.25281015f, 0.06502132f, -0.11970677f, -0.06933062f, -0.08181737f, -0.05353534f, 
    -0.14387751f, -0.01439472f, -0.07889251f, 0.09458993f, -0.05348410f, -0.04046726f, 0.07475659f, -0.15167958f, 
    -0.02995411f, -0.16834499f, -0.14014119f, 0.03756939f, 0.09835652f, -0.08876683f, 0.03202642f, -0.06685048f, 
    -0.00847004f, 0.10432894f, 0.21731757f, -0.03876989f, 0.07802866f, -0.11778154f, 0.00845776f, -0.12505631f, 
    0.07579552f, 0.00349701f, -0.01803365f, -0.03264345f, -0.33411470f, -0.02167256f, -0.24796465f, -0.06239777f, 
    0.04116302f, 0.06860194f, -0.09778356f, -0.06508478f, 0.02587136f, -0.09977921f, 0.02548064f, 0.00895758f, 
    -0.10327959f, 0.07759000f, 0.12422734f, -0.15582494f, 0.03028675f, -0.00883286f, 0.02756292f, -0.00182372f, 
    0.02873450f, -0.06814291f, -0.00101577f, -0.05435177f, 0.11269327f, -0.07250321f, -0.02256849f, 0.03375267f, 
    0.04872525f, -0.06750055f, -0.02803116f, 0.07355768f, 0.14867319f, 0.03361046f, 0.17339644f, 0.01680887f, 
    -0.01439009f, 0.18677804f, 0.11623290f, -0.09390961f, 0.05091308f, 0.03400984f, -0.07109657f, 0.03702514f, 
    0.01940559f, 0.09428183f, -0.09097660f, -0.11708535f, 0.03387515f, 0.18762620f, 0.00489039f, -0.22475569f, 
    -0.07688420f, -0.01793743f, 0.00532787f, 0.00697480f, 0.04696998f, -0.05586016f, -0.06571331f, -0.20985121f, 
    0.03748015f, 0.10775222f, -0.07738578f, 0.22920863f, -0.12275881f, 0.04506841f, -0.00290485f, -0.06314059f, 
    -0.03099092f, 0.02430024f, 0.02978603f, 0.13126011f, -0.01859198f, 0.03400807f, -0.21621221f, 0.12212460f, 
    0.01112387f, -0.02604738f, -0.03770398f, 0.14017218f, -0.01433054f, -0.00454475f, -0.00722868f, -0.18450195f, 
    -0.19693291f, -0.12184317f, -0.10455675f, 0.13226937f, 0.00444908f, -0.13041335f, 0.00927811f, 0.07598087f, 
    -0.09935635f, 0.18680836f, 0.02596266f, 0.04623744f, -0.52359474f, -0.41854227f, 0.08946074f, -0.09238653f, 
    0.05143274f, 0.01742504f, -0.02750038f, -0.11570130f, -0.00248313f, 0.03686376f, 0.14604521f, 0.12139767f, 
    0.21806081f, -0.02242435f, -0.06467945f, 0.04954387f, 0.02452504f, -0.10283078f, -0.00780911f, -0.01578282f, 
    0.14154004f, 0.08438002f, -0.00351938f, 0.00414061f, -0.04364822f, 0.16731383f, -0.08414411f, 0.10201151f, 
    0.02593285f, 0.02696433f, -0.14155716f, 0.08042438f, 0.08896847f, -0.02280339f, 0.07854309f, 0.04317565f, 
    -0.05170481f, -0.07336803f, -0.04176641f, -0.03106485f, 0.06797429f, 0.02990020f, -0.02054750f, -0.08624204f, 
    0.11082606f, -0.00018452f, -0.08694968f, -0.05299780f, 0.19937828f, 0.02965065f, -0.01424427f, -0.06125953f, 
    -0.06194228f, -0.07279668f, -0.02303134f, -0.05000553f, -0.09576199f, -0.10380429f, 0.09964131f, 0.22949244f, 
    0.07629835f, 0.04329786f, -0.09334738f, -0.12034326f, -0.04039545f, 0.05730259f, 0.07243948f, -0.02586836f, 
    0.00604292f, -0.05646827f, -0.00586197f, -0.05977266f, -0.46475664f, -0.01753845f, -0.01875032f, -0.22186843f, 
    0.07525460f, 0.00671135f, 0.03554769f, 0.03867451f, -0.00525319f, -0.00498039f, -0.16340667f, 0.02769237f, 
    -0.03505382f, -0.01684240f, 0.08756332f, -0.22263427f, -0.05017542f, -0.01786917f, -0.00758176f, -0.03006288f, 
    0.10732902f, -0.01713608f, 0.12129935f, -0.12344028f, -0.26617584f, -0.02115938f, -0.06795333f, -0.00734251f, 
    0.02936718f, 0.01089764f, 0.09228932f, 0.07246540f, -0.03481643f, 0.15914084f, -0.05449511f, 0.03307167f, 
    -0.17435458f, 0.16880669f, 0.09856760f, 0.01938988f, -0.02305937f, 0.12260725f, -0.00537782f, -0.12166270f, 
    -0.08879345f, -0.05238683f, -0.01431529f, 0.03124871f, 0.11137307f, 0.09103931f, 0.10843676f, -0.01483787f, 
    -0.01325399f, 0.11717303f, -0.10739270f, 0.08580771f, -0.00535022f, -0.01859975f, 0.11178558f, -0.08199233f, 
    0.03871800f, 0.13117608f, 0.04199965f, -0.03386450f, 0.01821433f, -0.07599741f, -0.01373591f, 0.06850044f, 
    0.02631732f, -0.10336432f, 0.06018434f, -0.09976226f, -0.13138078f, 0.05585081f, 0.18145406f, -0.43324089f, 
    -0.08668763f, 0.04451895f, 0.08326440f, 0.00760091f, 0.08200332f, -0.06008845f, 0.12556492f, 0.11537368f, 
    0.22353366f, -0.04665903f, -0.17335626f, 0.02246084f, 0.06474201f, 0.00107949f, -0.11420033f, -0.13414913f, 
    0.00915911f, -0.20611145f, 0.00989003f, -0.03575973f, -0.42982170f, -0.26227635f, -0.28944355f, 0.02376069f, 
    0.09963544f, 0.13496339f, -0.00490307f, 0.02673822f, 0.08718687f, -0.06674088f, 0.03401149f, 0.02714259f, 
    0.04558329f, 0.07720947f, 0.09288561f, 0.16195934f, -0.05435227f, -0.17626263f, 0.04116513f, -0.02127966f, 
    0.02087232f, -0.05542706f, 0.03165003f, -0.17249022f, -0.00221884f, -0.20342526f, 0.05566639f, 0.11758888f, 
    -0.02293612f, -0.13866507f, 0.07637808f, -0.12179321f, -0.05740194f, 0.10128023f, 0.13159733f, 0.06440800f, 
    0.13327557f, -0.03290109f, -0.26776886f, -0.01245501f, -0.01279438f, -0.02996475f, -0.19385131f, 0.07687347f, 
    0.09744503f, -0.02615713f, -0.03249005f, -0.08468706f, -0.16044956f, 0.04642459f, -0.05749068f, 0.09795015f, 
    -0.02023630f, -0.00624747f, -0.04518365f, 0.04713020f, 0.01966477f, 0.04235154f, 0.01155889f, 0.07646295f, 
    -0.17283325f, -0.19164327f, -0.02181387f, 0.17019801f, 0.12545811f, 0.00659893f, -0.01945953f, 0.04553225f, 
    0.11895557f, 0.01928826f, 0.16515060f, -0.02320279f, -0.02814771f, 0.11902163f, 0.04105195f, -0.02600814f, 
    0.07223728f, 0.09728612f, 0.01307474f, -0.07259607f, 0.06152194f, -0.28284568f, -0.03586334f, 0.18207103f, 
    0.12552962f, 0.12258824f, -0.00403063f, 0.02998158f, 0.09282621f, 0.04096605f, 0.01689565f, -0.28994432f, 
    -0.20825535f, 0.13206723f, -0.13095917f, 0.04641821f, 0.09850124f, -0.02128504f, 0.03229591f, 0.14170836f, 
    -0.12794839f, 0.10439242f, -0.03267756f, 0.08069014f, 0.01059901f, 0.05968500f, 0.00108252f, 0.00665160f, 
    -0.01116186f, 0.00698737f, 0.12400465f, 0.01089561f, 0.06596030f, -0.02563546f, -0.15696684f, 0.00169640f, 
    0.07909986f, 0.12379730f, 0.01421333f, -0.06710820f, -0.10824976f, 0.02924496f, 0.12210565f, 0.14172949f, 
    -0.03994120f, 0.03907226f, 0.17725839f, 0.08186164f, -0.02366730f, -0.12775344f, 0.01636963f, 0.07805027f, 
    0.12638617f, 0.04057205f, 0.10288824f, -0.14975309f, -0.04320168f, 0.04166140f, -0.04012181f, -0.10660653f, 
    0.02730148f, 0.07933616f, -0.08123735f, -0.08530734f, 0.00151373f, 0.03344312f, 0.11412882f, -0.13024804f, 
    0.08962250f, 0.02072737f, -0.01688854f, -0.20352480f, -0.01634855f, 0.09460571f, -0.12822370f, -0.02010714f, 
    -0.00302580f, -0.08504112f, 0.09555767f, -0.03404238f, -0.00425025f, 0.08670883f, -0.11408114f, -0.07026452f, 
    0.04655354f, 0.01863554f, 0.21097286f, 0.13936481f, 0.15369202f, -0.22547801f, -0.05781147f, -0.03035486f, 
    0.01864156f, 0.20858365f, -0.10514340f, 0.13810164f, 0.14473502f, -0.10419050f, 0.00391553f, -0.05598327f, 
    -0.38155726f, -0.04217520f, -0.07741109f, -0.09241994f, 0.14689593f, -0.12579203f, 0.15600625f, 0.10744143f, 
    0.14399065f, 0.10437203f, 0.05144990f, -0.17403829f, -0.31735271f, 0.18226142f, 0.00008692f, 0.14428245f, 
    -0.11777129f, -0.06167449f, 0.03576600f, 0.06237379f, -0.00444315f, -0.03424577f, -0.03155649f, 0.07987016f, 
    0.06945763f, 0.04105324f, 0.29340613f, -0.12825949f, -0.04996080f, 0.10118321f, -0.00943988f, -0.05197463f, 
    -0.14080621f, -0.03607846f, -0.00380272f, -0.00695359f, -0.23511013f, 0.16275825f, 0.27305159f, -0.29475188f, 
    -0.03774516f, -0.10154693f, 0.07115090f, -0.01272025f, 0.13932714f, 0.02190370f, 0.03223632f, 0.02880707f, 
    -0.00756369f, -0.05450705f, 0.00141952f, -0.00835236f, 0.05587170f, 0.03967936f, -0.04556035f, 0.04600634f, 
    0.02173156f, -0.04899899f, 0.12214495f, -0.10739734f, 0.07081617f, -0.08378465f, -0.00635633f, 0.08125973f, 
    0.07695881f, -0.11553063f, 0.01610746f, 0.02029710f, -0.03441713f, 0.04757828f, 0.00251399f, 0.05415614f, 
    0.19366145f, 0.07964842f, -0.07689218f, 0.00931381f, 0.02482614f, -0.01960401f, -0.00806016f, 0.11779893f, 
    0.10320414f, -0.09790198f, -0.06096121f, -0.08334222f, -0.24005927f, -0.29040894f, 0.22159962f, 0.42298347f, 
    -0.15421019f, 0.04001105f, 0.02231588f, 0.10866620f, -0.02385600f, -0.03573762f, -0.03994484f, -0.03822206f, 
    0.02375424f, -0.02351434f, 0.07360992f, 0.01381957f, -0.00383151f, 0.00233918f, -0.03523440f, -0.08264622f, 
    -0.12347495f, -0.00817144f, 0.07066005f, 0.09468553f, -0.19481656f, -0.07529317f, 0.21011940f, 0.12109972f, 
    0.01772220f, -0.01621460f, 0.03817824f, -0.10152383f, -0.04534351f, -0.13910058f, -0.15281899f, 0.03079601f, 
    0.08138327f, 0.12909621f, 0.09137595f, -0.02876020f, -0.06127986f, -0.03472093f, 0.03246633f, -0.05474262f, 
    -0.02846196f, 0.04757253f, 0.02637353f, 0.14662977f, -0.36875746f, -0.05014946f, -0.07245200f, -0.06590662f, 
    0.05140338f, 0.12919179f, 0.01323098f, -0.08134847f, -0.04867058f, 0.11113849f, 0.08614135f, 0.04767321f, 
    -0.22620203f, -0.05653112f, 0.04658569f, -0.06983086f, 0.04263157f, -0.08091142f, -0.05898755f, -0.05480506f, 
    -0.03084746f, -0.01716824f, -0.01558430f, 0.17687909f, 0.06969352f, 0.05429505f, 0.05034083f, 0.02275841f, 
    -0.01629491f, 0.04374304f, 0.02520127f, -0.01847290f, -0.02855548f, -0.01513703f, 0.04808992f, 0.20669751f, 
    0.01013420f, 0.01273519f, 0.12576547f, 0.01400018f, -0.00355099f, -0.02330238f, 0.10695161f, -0.02306491f, 
    -0.21700120f, 0.09710231f, 0.17329575f, 0.08915623f, -0.01782617f, -0.00411174f, -0.14208026f, -0.14436634f, 
    -0.05766576f, 0.03325992f, 0.06181470f, -0.00315491f, 0.07237632f, 0.02818271f, 0.03460941f, 0.08604147f, 
    0.33363068f, 0.02370330f, -0.11642171f, 0.03087108f, 0.08708796f, 0.14486209f, 0.08124594f, 0.04087925f, 
    -0.18026316f, 0.01169123f, -0.17844869f, -0.19607030f, 0.00806535f, -0.03370494f, 0.05599814f, 0.08076152f, 
    -0.08226123f, 0.00566457f, -0.10162830f, -0.01423385f, -0.01957973f, 0.06632858f, 0.06842767f, 0.13126542f, 
    -0.53510553f, -0.03536319f, 0.06024253f, -0.04816263f, 0.17486762f, -0.05986271f, 0.02534284f, -0.23006687f, 
    0.00141301f, -0.00166079f, -0.04387465f, -0.03702327f, 0.04943963f, -0.07745568f, -0.00575476f, -0.20382445f, 
    -0.00773703f, 0.00680284f, -0.05717559f, -0.06242487f, -0.22247884f, 0.02046943f, 0.02074639f, -0.17213249f, 
    -0.24907233f, 0.04886939f, 0.07863650f, -0.07780840f, 0.08466107f, 0.00886275f, 0.14983946f, -0.03976805f, 
    0.00743912f, -0.03993139f, -0.10979673f, -0.10088685f, 0.64309591f, -0.12768255f, 0.08316963f, -0.11554214f, 
    -0.04148393f, -0.01521985f, 0.12618560f, 0.05724026f, 0.06173714f, 0.06415764f, 0.06214043f, 0.04357032f, 
    -0.10584792f, -0.14420569f, -0.03212579f, -0.18300037f, -0.03525516f, -0.06014164f, 0.04093082f, 0.02448682f, 
    0.00809646f, 0.00210431f, -0.00631536f, 0.01992751f, 0.09112197f, 0.15237412f, -0.02925050f, -0.12670460f, 
    0.02614635f, -0.00241514f, 0.01593222f, 0.07326203f, -0.01632007f, -0.00751711f, 0.11323373f, 0.05829884f, 
    0.04828312f, 0.11571253f, -0.17151952f, 0.09345470f, 0.08622324f, 0.05079495f, 0.11393161f, 0.07635635f, 
    0.05505304f, 0.08271628f, 0.04813998f, -0.08388086f, -0.16205531f, -0.07727548f, 0.19550286f, 0.09783241f, 
    0.03290324f, -0.00061615f, 0.19022623f, 0.05450815f, -0.02176030f, 0.06584149f, 0.01350530f, 0.12037637f, 
    0.07776206f, -0.24905816f, -0.05184435f, 0.07089084f, -0.08232969f, 0.03479502f, 0.04532150f, 0.07025993f, 
    -0.13148992f, -0.07709145f, -0.02476803f, -0.00663466f, -0.06484790f, -0.11253621f, -0.15255783f, -0.15207927f, 
    -0.07486811f, 0.05130954f, -0.03446746f, 0.01356357f, 0.00182802f, 0.10818072f, -0.01021530f, 0.08913903f, 
    0.18522851f, 0.01488083f, 0.16205071f, -0.26075113f, -0.14515178f, -0.03551503f, -0.01559913f, 0.14323200f, 
    0.00171531f, 0.00058086f, 0.03560090f, 0.14102677f, 0.01790665f, -0.03994722f, -0.03231186f, 0.29808873f, 
    -0.03306221f, -0.05232711f, 0.07377705f, -0.00220646f, -0.03931625f, -0.11810597f, -0.17316477f, -0.23700812f, 
    0.10434455f, 0.11008539f, 0.26273304f, 0.33794332f, -0.11424834f, 0.03748599f, 0.05152877f, -0.04576263f, 
    0.06644669f, -0.17621325f, 0.10120984f, 0.05063473f, 0.03056995f, -0.32954827f, 0.05118855f, -0.19752739f, 
    0.02770137f, 0.07849106f, -0.06701258f, 0.01966313f, 0.00883044f, -0.06126387f, 0.11824349f, 0.18892919f, 
    -0.17929035f, 0.04755642f, -0.01895308f, -0.05932854f, -0.03675044f, -0.04069424f, 0.04815068f, 0.02118497f, 
    0.04729481f, -0.02047298f, -0.07280552f, -0.15316550f, 0.04519240f, -0.09818382f, 0.05964256f, -0.18330449f, 
    0.08311437f, -0.05233746f, 0.11040883f, -0.05641618f, 0.01399302f, 0.11273219f, -0.03494877f, 0.11121814f, 
    -0.32066649f, 0.08219700f, -0.01386589f, -0.05588788f, 0.05494301f, 0.08099917f, -0.09488301f, -0.06490261f, 
    0.03023893f, -0.10140626f, -0.11791857f, 0.08420428f, 0.21375461f, 0.03132226f, -0.08662994f, 0.03130463f, 
    -0.12708074f, 0.04049346f, -0.05317855f, 0.06653417f, -0.14910781f, 0.07154270f, -0.09846439f, 0.07869300f, 
    -0.44445473f, 0.20092022f, -0.03297157f, 0.27778119f, -0.06971973f, 0.05072539f, 0.06845113f, 0.06402542f, 
    -0.07110173f, -0.03657266f, 0.10538090f, -0.13997741f, 0.10486281f, -0.12191088f, 0.24618220f, 0.05455859f, 
    -0.03244411f, 0.01633346f, 0.01800214f, 0.04216177f, 0.06101148f, -0.01536921f, -0.02194430f, -0.07823718f, 
    0.04086847f, 0.01896757f, -0.26414248f, 0.20344491f, -0.10025773f, 0.02518188f, -0.05761769f, -0.04018492f, 
    0.04643053f, 0.00349438f, 0.00695190f, 0.06960078f, 0.17880209f, 0.23568009f, 0.01733654f, -0.19256759f, 
    -0.03865669f, 0.12112618f, 0.07342520f, 0.06917639f, -0.06275538f, -0.01309416f, 0.03424354f, -0.02181890f, 
    0.00935199f, -0.08917125f, -0.02936838f, 0.08898375f, 0.01353779f, 0.03919781f, -0.03703016f, 0.05546854f, 
    0.03546510f, 0.06268742f, -0.03666656f, 0.12656809f, -0.17804486f, -0.10321058f, 0.01036066f, -0.22263472f, 
    0.03235286f, 0.01722942f, -0.02157083f, 0.04339085f, 0.02989952f, -0.04459646f, 0.07783356f, -0.03262268f, 
    -0.18376322f, 0.16132291f, 0.14965375f, -0.17748865f, -0.02347242f, -0.01403511f, -0.01447293f, 0.01498716f, 
    -0.04726575f, 0.04676768f, -0.01062796f, 0.04928274f, 0.06371104f, -0.03138772f, -0.00162947f, -0.01602112f, 
    0.01299012f, -0.02078881f, -0.04465565f, -0.04299385f, 0.01893585f, -0.06148814f, 0.04015319f, -0.10699102f, 
    0.31385523f, -0.36356652f, -0.06813053f, -0.02787229f, -0.01536842f, 0.00277399f, 0.07691976f, -0.09023409f, 
    0.04709100f, 0.11555988f, 0.10507833f, -0.04985195f, 0.20546763f, 0.11312955f, 0.10789368f, -0.29758924f, 
    0.06440749f, -0.13025795f, 0.12200618f, 0.03582918f, 0.12290014f, 0.09657152f, -0.08779142f, 0.11333939f, 
    -0.25132936f, 0.11794939f, 0.01969954f, 0.16541997f, 0.01801446f, 0.09544972f, -0.03084335f, 0.10804298f, 
    0.01267080f, 0.05041711f, 0.00890197f, 0.00647688f, 0.18204354f, -0.08694083f, -0.03158034f, -0.05437929f, 
    -0.02466173f, 0.08755293f, 0.01293200f, -0.00632664f, 0.01321273f, 0.02486007f, -0.19236434f, -0.01099833f, 
    -0.14518012f, -0.07545647f, -0.19002351f, 0.30074292f, -0.05965960f, 0.03283199f, -0.01524370f, -0.02806432f, 
    -0.01353385f, 0.13162191f, -0.02367373f, 0.04692896f, -0.15738095f, -0.14577368f, -0.06109070f, -0.26705083f, 
    -0.09091084f, -0.02192614f, 0.05290213f, -0.12766013f, -0.02537395f, -0.04509496f, 0.07978807f, 0.17422272f, 
    -0.15329731f, -0.00307438f, 0.00670130f, 0.18454850f, 0.14118157f, 0.19057599f, 0.03677968f, 0.03384751f, 
    0.02890101f, 0.00972847f, -0.05629715f, -0.03105727f, 0.08249558f, -0.01600792f, -0.01846154f, -0.05408465f, 
    0.16708761f, 0.05637566f, -0.04084007f, 0.00587608f, -0.02989611f, -0.11227002f, -0.02120154f, 0.06802817f, 
    -0.08769891f, -0.04488730f, -0.15639931f, 0.05108098f, 0.03461700f, -0.02977420f, -0.05166016f, 0.03754937f, 
    0.01121452f, 0.00745062f, 0.08064160f, 0.03672864f, 0.07880788f, -0.14041641f, -0.20663916f, 0.29797417f, 
    0.05506151f, 0.06411437f, 0.02757642f, 0.01376291f, 0.00988970f, -0.06170617f, -0.04268650f, -0.08063552f, 
    -0.14082491f, 0.02186863f, -0.10979436f, -0.18822019f, -0.02220513f, -0.12549312f, -0.10264841f, -0.02519974f, 
    -0.08865146f, 0.02813222f, -0.07228584f, -0.07588794f, -0.06064428f, -0.02780696f, -0.05668173f, 0.15912479f, 
    0.09963255f, -0.07865565f, -0.18854806f, -0.03181547f, 0.09636122f, 0.08022493f, -0.09627987f, -0.10234065f, 
    -0.28926748f, 0.00752294f, -0.00930190f, 0.09815297f, 0.00593206f, -0.02016613f, 0.16004735f, 0.21142004f, 
    0.12145240f, -0.11213542f, 0.12180633f, -0.02462404f, -0.09528501f, -0.05485452f, 0.03982325f, -0.09111648f, 
    0.18229097f, -0.09573387f, 0.05230021f, -0.00181225f, -0.13985547f, 0.07210711f, -0.04874412f, 0.06552825f, 
    0.16987067f, -0.09357831f, 0.03444130f, -0.09001172f, -0.01877609f, -0.00360766f, 0.13300191f, 0.00247468f, 
    0.06067298f, -0.07499935f, -0.02923317f, 0.10626169f, 0.12471851f, -0.02048567f, -0.10424478f, 0.08614597f, 
    -0.10379427f, -0.15317056f, -0.14080267f, -0.01865375f, 0.01749777f, 0.02813617f, -0.00593212f, -0.02362350f, 
    -0.31340593f, -0.09175790f, 0.11080489f, -0.02952065f, -0.09613037f, 0.01801401f, 0.03008442f, 0.05787970f, 
    -0.01134151f, -0.01469289f, 0.05529625f, 0.09308759f, -0.04821161f, -0.09374286f, -0.09204719f, 0.01851234f, 
    -0.13607365f, -0.10367235f, 0.03568728f, 0.14929214f, -0.05600569f, -0.04895632f, -0.00966316f, 0.14354403f, 
    0.03065496f, 0.00514873f, -0.27476594f, -0.22786103f, -0.03049934f, 0.01735337f, 0.03077864f, -0.03470204f, 
    -0.02122820f, 0.01084112f, -0.23965265f, -0.03550402f, -0.09877715f, -0.01243831f, -0.14277105f, -0.15288448f, 
    -0.06575165f, -0.08532139f, 0.15891415f, -0.02313468f, -0.05603329f, 0.11587652f, 0.00680610f, 0.03043367f, 
    0.15130097f, -0.17721082f, -0.10892752f, 0.05140213f, -0.06550436f, -0.02556221f, -0.01238664f, 0.01298620f, 
    -0.00022798f, -0.04016742f, 0.00857649f, 0.13073491f, 0.16138987f, -0.02828414f, -0.00778225f, 0.02624730f, 
    0.12209953f, 0.04775264f, -0.09678615f, -0.03670434f, -0.17407964f, 0.00659879f, 0.03427051f, -0.00022411f, 
    -0.22210155f, 0.08200797f, -0.00346016f, -0.05515296f, -0.28990054f, -0.07404157f, 0.06836961f, -0.06666220f, 
    0.04392792f, 0.02360350f, -0.04112530f, 0.00113684f, 0.14831586f, -0.31924191f, 0.09282023f, 0.05225526f, 
    -0.00479445f, 0.08826247f, -0.03043614f, 0.11017963f, -0.02716814f, -0.02802822f, -0.03231415f, -0.09304557f, 
    0.07853659f, -0.07151283f, -0.13523097f, -0.30674106f, -0.04713670f, 0.00685984f, 0.07945330f, -0.02401536f, 
    -0.03472338f, 0.06469212f, -0.10701765f, 0.14463370f, 0.06352689f, -0.08066212f, -0.11894199f, 0.00722342f, 
    -0.02972091f, 0.14810994f, -0.02868082f, 0.02841774f, 0.03187947f, -0.15957984f, 0.06410323f, 0.00234306f, 
    0.00410594f, 0.00339584f, -0.03846385f, -0.22450350f, 0.04848080f, -0.06966920f, 0.06148171f, 0.00657057f, 
    -0.10162199f, 0.12045673f, -0.05606481f, -0.01073054f, -0.25836238f, -0.11837342f, 0.03177584f, 0.05404268f, 
    0.08734347f, -0.11182223f, 0.00752489f, -0.01538069f, -0.16219690f, -0.00438637f, 0.00315904f, 0.02643243f, 
    -0.09804969f, 0.13460241f, 0.10594282f, 0.02404256f, -0.08233108f, -0.01182864f, 0.06395969f, 0.10439705f, 
    -0.02839032f, 0.02634585f, 0.04848567f, -0.02574217f, -0.27598459f, -0.04578700f, -0.10416727f, -0.12595078f, 
    -0.06965896f, 0.04506399f, -0.03178388f, -0.00023643f, 0.12443325f, 0.01929853f, 0.01435298f, -0.05533502f, 
    -0.00696840f, 0.04439792f, -0.05974193f, -0.04712381f, 0.06452170f, -0.03230739f, 0.00790161f, 0.06619347f, 
    -0.09746894f, -0.02464990f, 0.05811883f, -0.22348428f, 0.05097297f, -0.23579803f, -0.12692140f, -0.08536042f, 
    -0.07046942f, 0.05620131f, -0.01926570f, -0.10953801f, 0.00750281f, -0.01092299f, -0.07202639f, -0.13515212f, 
    0.27003542f, 0.17161384f, 0.01532281f, -0.16099361f, 0.02002385f, -0.02581851f, 0.04471221f, 0.03492815f, 
    -0.03740712f, -0.01222753f, -0.03994875f, -0.07939129f, 0.18062082f, 0.17396353f, 0.06275181f, -0.42470261f, 
    -0.04439128f, 0.02170825f, 0.01873843f, 0.06084047f, 0.03235466f, -0.05585580f, -0.06140291f, -0.14289488f, 
    0.02955437f, 0.19337894f, 0.11489468f, -0.20615606f, 0.06974706f, 0.04144635f, 0.03420816f, 0.03945662f, 
    0.06924271f, -0.13088372f, -0.13958456f, -0.12368319f, 0.07970230f, 0.05311862f, -0.02847914f, -0.25875139f, 
    0.07300244f, -0.01577219f, 0.00615644f, -0.11844394f, 0.01817714f, -0.12837726f, -0.23666213f, -0.05772218f, 
    -0.28313854f, -0.15865125f, -0.12404034f, -0.08516071f, 0.01982860f, -0.03801525f, -0.12904660f, -0.08337746f, 
    0.05372907f, 0.02542526f, 0.06795886f, 0.18172517f, 0.08510308f, -0.03020567f, 0.04011279f, -0.11740115f, 
    0.12364881f, 0.01950892f, 0.10216277f, 0.02244351f, -0.09715785f, 0.02229889f, 0.09562432f, -0.23146355f, 
    0.09938966f, -0.34743482f, -0.05514643f, 0.02113983f, -0.02152653f, 0.11938030f, -0.00661760f, 0.02834816f, 
    0.06261888f, 0.01432920f, -0.04097692f, 0.11308844f, -0.26267555f, 0.13076086f, 0.04760187f, -0.10171507f, 
    0.00823801f, 0.04916710f, 0.00845744f, 0.02239118f, 0.02785559f, 0.03612953f, 0.01898162f, 0.09571498f, 
    -0.22325213f, 0.09856082f, 0.01026300f, 0.03754192f, 0.12388510f, 0.03304878f, 0.00304099f, 0.02691006f, 
    -0.01330028f, -0.06194411f, 0.00068313f, 0.01026773f, 0.32134748f, -0.10726733f, 0.05062891f, -0.07797301f, 
    -0.09358985f, -0.00966050f, -0.01138128f, -0.09493790f, -0.00223293f, 0.09579299f, -0.06774070f, -0.01425689f, 
    0.06925115f, 0.18229587f, 0.14670911f, 0.09688238f, 0.09075903f, 0.06867287f, 0.06905459f, -0.01943030f, 
    -0.01288752f, 0.05392549f, 0.00497976f, -0.03423142f, -0.36588374f, 0.09689447f, -0.03963658f, -0.04827828f, 
    -0.09165806f, 0.02079548f, -0.01559306f, -0.06929090f, -0.09936357f, -0.03440604f, 0.02812632f, 0.07963968f, 
    -0.15048084f, 0.02150169f, 0.05806262f, 0.02503973f, -0.09812229f, -0.13272557f, -0.06161148f, -0.02778753f, 
    -0.02511706f, -0.04222100f, -0.01726309f, -0.03524182f, 0.16193353f, 0.03598145f, -0.10724587f, 0.07045549f, 
    -0.04404071f, -0.00037803f, -0.01457606f, -0.09792369f, -0.11353545f, -0.03647936f, -0.06787021f, -0.02721526f, 
    -0.10215134f, -0.00278590f, 0.02164501f, -0.04677531f, 0.05555127f, -0.00643886f, -0.03839816f, -0.07678080f, 
    0.03931335f, -0.04130565f, 0.00248018f, 0.02691979f, -0.09901743f, 0.21504641f, 0.14420286f, 0.03646915f, 
    0.03107581f, 0.04024682f, 0.04413798f, 0.01101573f, 0.00999616f, 0.03620600f, 0.00755456f, -0.07117930f, 
    -0.17223279f, -0.01611758f, -0.13187915f, -0.07433739f, -0.06104847f, -0.00849916f, -0.02923419f, -0.06018497f, 
    -0.10103132f, -0.05861782f, -0.04639978f, -0.08122987f, 0.19101065f, -0.22519542f, -0.02940040f, 0.00995470f, 
    0.05285899f, -0.04746567f, -0.02289709f, -0.10377764f, -0.02085198f, -0.05944610f, -0.05834597f, -0.03913143f, 
    -0.07706974f, -0.01229792f, 0.03886224f, 0.15749928f, -0.08644548f, -0.08540444f, 0.00860611f, 0.03053304f, 
    -0.03691288f, -0.05165650f, 0.03506659f, -0.10867618f, 0.02609266f, -0.04840693f, 0.04043861f, -0.03709454f, 
    -0.02123236f, 0.01506764f, -0.03703674f, -0.00416094f, 0.02745521f, 0.05564687f, 0.02336571f, -0.01570089f, 
    -0.06752557f, 0.16977467f, -0.18493657f, 0.17014812f, -0.06180268f, -0.06035600f, -0.03848983f, -0.01868650f, 
    -0.08376546f, 0.05553190f, -0.01876616f, -0.00390700f, 0.23439085f, 0.00754729f, 0.13888633f, 0.06277449f, 
    -0.00031765f, 0.04201029f, 0.00524893f, -0.05877765f, -0.02840667f, 0.07024294f, -0.06193820f, -0.08678312f, 
    0.10642781f, 0.12201332f, 0.01242432f, 0.06356116f, -0.02131424f, -0.07528511f, -0.06342017f, -0.02741477f, 
    -0.07808860f, -0.03035710f, 0.01000300f, -0.03888329f, 0.14350608f, 0.13654587f, 0.03502576f, 0.20249346f, 
    0.19284779f, 0.01485355f, 0.08493561f, 0.06297483f, 0.01374443f, 0.00863537f, 0.01894245f, -0.05295137f, 
    -0.25604573f, -0.18001974f, -0.12971538f, -0.23736484f, 0.01493033f, -0.02902587f, -0.04195177f, -0.02928291f, 
    -0.02194707f, -0.00302524f, 0.00471034f, -0.01929698f, -0.00873629f, -0.05362163f, 0.01211991f, -0.04537461f, 
    -0.07889018f, -0.01182258f, 0.02204072f, -0.04552455f, -0.02358579f, -0.01574172f, -0.00793830f, -0.01706371f, 
    0.03618803f, 0.10104076f, -0.07625864f, 0.14704765f, -0.09214157f, 0.04857456f, -0.05018780f, 0.06197093f, 
    0.02003603f, -0.00436887f, 0.01522501f, 0.00105418f, 0.10955372f, -0.09411887f, -0.02002082f, -0.07998123f, 
    -0.03650410f, -0.01678382f, -0.01201381f, -0.04621937f, -0.04475641f, 0.00543608f, 0.04652398f, -0.00860858f, 
    -0.03309482f, -0.02669127f, 0.11280227f, 0.07411671f, 0.09719504f, -0.00166398f, 0.06527317f, -0.01890596f, 
    -0.01672496f, 0.02235967f, 0.04591125f, 0.00640629f, 0.20956914f, -0.00496537f, 0.28562960f, 0.01657478f, 
    0.08462766f, 0.02727184f, -0.05781636f, -0.02364052f, -0.02867320f, 0.01818054f, -0.01423359f, -0.03602396f, 
    -0.11080182f, -0.00004639f, -0.06514394f, -0.15604240f, 0.06135240f, 0.09163470f, -0.09642689f, -0.02763007f, 
    -0.04205835f, -0.00286583f, 0.06138798f, -0.09074903f, 0.07389386f, -0.08289713f, 0.06588085f, 0.10286484f, 
    -0.04947290f, 0.02205844f, -0.04430727f, -0.01066195f, -0.04170299f, -0.05389354f, 0.08321224f, -0.02486695f, 
    -0.05689561f, -0.15138139f, 0.05110831f, -0.12067427f, -0.08611384f, -0.01881522f, -0.11756468f, -0.06064650f, 
    0.01150774f, 0.03511802f, -0.02684789f, -0.04003026f, -0.02550575f, 0.04579475f, -0.03310046f, -0.08348280f, 
    -0.01601259f, -0.02272028f, 0.00012133f, -0.04085513f, -0.00754504f, 0.05526875f, -0.04965799f, -0.01067417f, 
    -0.12686639f, -0.00607905f, -0.15252556f, -0.05880757f, -0.07623777f, -0.00121369f, -0.09209491f, -0.02289731f, 
    -0.09068938f, -0.01212717f, 0.05737566f, -0.04557800f, -0.20304506f, 0.14703907f, -0.01073234f, -0.04415254f, 
    -0.08951236f, 0.03575101f, -0.03411675f, -0.04864334f, -0.09904230f, 0.01859670f, 0.08423528f, -0.10687949f, 
    -0.24665184f, 0.20571239f, -0.02821700f, 0.05639981f, 0.04387286f, -0.13612425f, 0.02280574f, -0.00284486f, 
    0.02560897f, -0.00354324f, 0.05964757f, -0.04848962f, 0.10557723f, 0.08222386f, 0.18019898f, 0.12907897f, 
    0.10528802f, 0.05846764f, 0.08999588f, -0.01618019f, -0.04500581f, 0.05733207f, -0.01548951f, -0.00345921f, 
    -0.07140704f, 0.14684378f, 0.01904740f, -0.02800150f, -0.12743729f, -0.05049126f, -0.01391526f, -0.04497445f, 
    -0.02875905f, -0.03019465f, 0.00589078f, -0.04306463f, 0.05010900f, -0.03208917f, 0.02802721f, 0.18644463f, 
    -0.11594573f, -0.10055196f, -0.04987125f, -0.00316810f, 0.04007123f, 0.04268352f, 0.00039433f, -0.10664761f, 
    -0.04301997f, 0.08181783f, 0.00830410f, 0.05757371f, -0.03584791f, 0.10280716f, 0.07984664f, -0.02939246f, 
    -0.07722414f, -0.00091110f, 0.00734466f, 0.01323523f, -0.22214474f, 0.13493119f, -0.09480850f, 0.03456656f, 
    -0.03892247f, -0.05551475f, -0.08037586f, 0.00395203f, 0.02157929f, -0.00068696f, -0.03216683f, -0.04754099f, 
    0.10994823f, 0.24411616f, 0.06445011f, 0.18938230f, 0.07241557f, -0.00692689f, -0.04074078f, 0.00311618f, 
    0.01484098f, -0.13397095f, -0.03399350f, -0.05011947f, 0.05124520f, 0.14882027f, -0.01820887f, 0.06506342f, 
    -0.01087924f, -0.01155977f, -0.02693536f, -0.01879170f, -0.05172637f, 0.07625377f, 0.06570543f, -0.09228403f, 
    -0.06616604f, -0.12167897f, -0.09753507f, 0.02434293f, -0.02725615f, -0.04755765f, -0.04033441f, -0.02647760f, 
    0.06426582f, -0.05270968f, -0.00842482f, -0.09749404f, 0.15335371f, -0.42715231f, 0.02477550f, -0.02447715f, 
    -0.06759836f, -0.05869313f, 0.00326290f, -0.04845711f, 0.00894504f, -0.07639760f, 0.01285143f, -0.03278514f, 
    0.17841285f, -0.24200168f, 0.00718967f, -0.15278569f, -0.08928244f, 0.03919603f, -0.02148845f, -0.09217326f, 
    0.00175118f, 0.03071634f, 0.03691997f, 0.03302041f, -0.11895934f, -0.10969554f, -0.14455041f, 0.17778148f, 
    -0.08338706f, -0.02583353f, -0.02923603f, 0.02448399f, -0.05942411f, 0.01396704f, 0.00827369f, -0.03592786f, 
    0.08643273f, 0.10355783f, -0.09574722f, -0.03770322f, -0.05370327f, -0.00163114f, -0.11020732f, -0.05829837f, 
    0.04494791f, 0.04486492f, -0.01031155f, -0.00463474f, 0.01164704f, 0.03357463f, -0.01438244f, -0.02553290f, 
    -0.01536706f, 0.00771010f, 0.03590304f, -0.04691889f, 0.01852244f, 0.02283876f, 0.06834307f, -0.02458415f, 
    -0.04734815f, -0.06103578f, 0.10764199f, 0.05861585f, -0.06028309f, 0.02090025f, -0.01597443f, -0.00859554f, 
    -0.04488374f, 0.01724001f, -0.06211564f, -0.04858489f, 0.13890921f, 0.12297358f, 0.07383126f, 0.16585167f, 
    0.00099310f, 0.04170205f, 0.12214334f, -0.04790389f, 0.05786837f, 0.08782930f, 0.00200513f, -0.03900450f, 
    0.11217941f, 0.04041935f, 0.07873056f, 0.07401225f, 0.00935396f, 0.01419566f, 0.01389133f, 0.01753923f, 
    -0.06263201f, 0.00947484f, -0.01397908f, 0.00739491f, -0.14810109f, -0.01154166f, -0.03032166f, -0.03414729f, 
    -0.12712532f, 0.07903396f, 0.04201996f, 0.06441870f, 0.00450108f, 0.02551318f, -0.04741614f, -0.04870072f, 
    0.00169493f, 0.19823003f, 0.03328080f, -0.09428819f, -0.10769732f, -0.05856850f, 0.01740095f, -0.03272300f, 
    -0.02413349f, 0.00766789f, -0.04622894f, -0.05808364f, -0.15253988f, -0.03824554f, -0.02259839f, -0.13922223f, 
    -0.07007067f, -0.05026564f, -0.08007820f, -0.04410988f, 0.02461365f, -0.02731757f, -0.00434897f, -0.06338122f, 
    0.08993046f, 0.05477821f, 0.01878837f, 0.04296133f, -0.06039681f, 0.04113195f, -0.02293924f, -0.09081937f, 
    -0.10003988f, 0.02378344f, -0.02738109f, -0.04153160f, 0.04473406f, 0.03272746f, 0.00653934f, 0.10754696f, 
    0.00207047f, -0.00656096f, -0.00032104f, -0.00753778f, 0.08225688f, 0.03061784f, -0.09030890f, -0.00081056f, 
    0.12909147f, -0.07327805f, -0.05565022f, -0.05602621f, 0.02990566f, 0.01989124f, -0.04043546f, -0.07240421f, 
    -0.07938436f, 0.04272595f, 0.03222791f, -0.02216180f, -0.11415102f, -0.06670900f, 0.20278729f, 0.21356891f, 
    0.09980412f, -0.09963983f, -0.03465674f, 0.04555989f, 0.02013183f, -0.06712563f, -0.05612347f, -0.05348133f, 
    -0.02422109f, -0.02996459f, -0.01836916f, -0.12070108f, -0.10660257f, -0.01031719f, -0.00426185f, -0.05546468f, 
    -0.01855214f, -0.02569644f, -0.05583911f, -0.07053561f, 0.11103128f, 0.12506451f, 0.02237522f, 0.16796297f, 
    0.09200180f, 0.00227325f, -0.10433204f, 0.01067721f, -0.07832442f, 0.04090645f, -0.02720906f, -0.10877599f, 
    -0.29081973f, 0.03830344f, -0.03057681f, -0.07099513f, 0.06476093f, -0.06277307f, -0.08440901f, -0.03126528f, 
    -0.04053162f, -0.01552191f, -0.00752522f, -0.02594899f, -0.05574301f, -0.00536210f, 0.12412877f, -0.02050423f, 
    0.12185085f, 0.05707976f, -0.00992703f, -0.03397661f, -0.05232977f, 0.04151311f, -0.03608158f, 0.01197802f, 
    0.04154753f, -0.09177765f, -0.00082367f, -0.00756747f, -0.05695312f, -0.05056481f, -0.08361715f, -0.02937749f, 
    -0.02241891f, -0.01291269f, -0.01703732f, -0.01816023f, -0.22984283f, 0.01083690f, -0.15079945f, -0.16511631f, 
    0.05325869f, -0.02682447f, 0.00029027f, -0.05557205f, -0.04523274f, 0.00153578f, 0.02790198f, -0.07010290f, 
    -0.00829152f, -0.14579478f, -0.11609287f, -0.12208193f, 0.02078673f, -0.09177212f, -0.01725171f, -0.03804125f, 
    -0.01133921f, 0.04880320f, -0.03692917f, -0.00675164f, -0.15111935f, 0.05589870f, 0.01968930f, 0.01331618f, 
    -0.04972770f, 0.00362813f, 0.00840661f, -0.07796577f, -0.02683042f, 0.02393998f, -0.01691208f, -0.05877468f, 
    0.15816891f, 0.16225527f, 0.04045644f, 0.12768093f, 0.07437927f, 0.06625903f, 0.07270697f, 0.05251710f, 
    -0.03308794f, -0.02647596f, -0.00914449f, -0.05089440f, 0.18976587f, -0.14828610f, 0.09315837f, 0.08096212f, 
    0.06609231f, -0.04146457f, -0.00870868f, -0.02419167f, 0.03751811f, -0.04260727f, -0.01590682f, -0.07067226f, 
    0.06653516f, -0.03897348f, 0.15784892f, 0.03523755f, 0.02527925f, 0.04995909f, 0.01224418f, 0.01748838f, 
    -0.03742267f, 0.04579137f, -0.04374243f, -0.03753706f, -0.17399810f, 0.13471265f, -0.20935284f, -0.10045355f, 
    -0.00652655f, -0.01542784f, -0.05812049f, 0.01147711f, -0.03877285f, -0.04582631f, 0.01905884f, -0.03866797f, 
    0.08682901f, 0.11739097f, -0.02322140f, 0.13710114f, 0.11133749f, -0.06111582f, -0.05903830f, 0.00120019f, 
    -0.07217253f, 0.01834177f, 0.06633703f, 0.02386082f, -0.15411346f, -0.06336650f, -0.04325965f, -0.14693524f, 
    0.03722031f, -0.09897324f, -0.00758638f, -0.10083271f, 0.04386356f, -0.12319785f, -0.07448390f, 0.02999744f, 
    -0.03562666f, -0.06803349f, 0.15495734f, 0.10658979f, -0.10650501f, -0.04521247f, -0.04428976f, -0.04403540f, 
    -0.02867768f, -0.03899755f, -0.03821986f, 0.01934928f, 0.09277067f, -0.11428241f, 0.00966785f, 0.15401997f, 
    0.14421187f, 0.01005225f, -0.03499757f, -0.02809436f, 0.14715862f, -0.00166659f, 0.06560189f, -0.01603514f, 
    -0.04905171f, -0.02139223f, -0.19885488f, 0.05633912f, 0.08987860f, -0.04733832f, -0.10149559f, -0.01066327f, 
    0.04519662f, -0.07864721f, 0.06855450f, 0.09884849f, -0.28502896f, 0.22150587f, -0.11445369f, -0.06639221f, 
    -0.20264286f, -0.03126575f, -0.10338540f, 0.01361571f, 0.03292804f, 0.11754582f, 0.00645820f, -0.12110696f, 
    0.12356562f, 0.08381201f, 0.00552367f, 0.08131286f, -0.02160073f, -0.13743617f, -0.09970403f, 0.02865484f, 
    0.03851519f, -0.05723462f, 0.00067942f, -0.10447839f, -0.06466137f, 0.10897809f, 0.09936895f, 0.08710951f, 
    -0.06338569f, 0.00300312f, -0.09605313f, -0.08248929f, -0.03100674f, -0.03093705f, 0.10011291f, 0.00982733f, 
    0.08184408f, 0.08568412f, 0.06192559f, 0.19364934f, 0.13400282f, -0.04825598f, -0.02435924f, -0.05886423f, 
    -0.05250622f, -0.04674567f, -0.03789037f, 0.01110236f, 0.14442961f, -0.05801799f, 0.03372725f, -0.10265399f, 
    0.03651498f, 0.07398900f, -0.05737850f, 0.01771586f, -0.01672009f, 0.06380656f, 0.06150057f, 0.00310860f, 
    0.07744763f, -0.15455905f, -0.22141656f, -0.17796816f, 0.14460222f, -0.27591506f, -0.32402629f, -0.15662828f, 
    0.06409550f, 0.05217821f, -0.05286302f, -0.01461551f, 0.07725320f, 0.00047757f, 0.11086538f, 0.08719910f, 
    -0.02826464f, -0.08760033f, 0.03940019f, -0.10328075f, 0.02983506f, -0.03288688f, -0.12902214f, -0.20458682f, 
    0.04964913f, -0.08682745f, 0.12213681f, -0.06988257f, -0.01098660f, 0.00031876f, -0.03091205f, -0.09608521f, 
    -0.04391880f, 0.05660515f, 0.04079801f, 0.02814240f, -0.02636737f, -0.21147157f, -0.05350318f, -0.16970293f, 
    0.03998692f, -0.05735834f, -0.04383922f, -0.01923956f, 0.05744371f, -0.02724895f, 0.05677844f, -0.00546744f, 
    0.01609413f, -0.02060706f, 0.08959591f, -0.15291855f, 0.03565511f, -0.09565558f, -0.04525003f, 0.03509820f, 
    -0.05114851f, 0.09010497f, 0.17196178f, 0.01529448f, 0.04941479f, -0.03090743f, -0.03361007f, -0.02579364f, 
    0.07871081f, -0.05720047f, 0.10052608f, 0.01079706f, 0.02969677f, -0.04561402f, 0.04185772f, -0.02420651f, 
    0.15674432f, 0.20999023f, -0.17300792f, -0.06973033f, 0.09143490f, 0.03001757f, 0.02322317f, -0.04578226f, 
    0.03651439f, -0.02173496f, -0.05582441f, 0.09134179f, 0.19458205f, -0.05435965f, -0.01555013f, 0.05089409f, 
    0.02727676f, -0.05513448f, -0.07207721f, -0.05218452f, -0.04340940f, 0.03648509f, 0.04511662f, 0.05894626f, 
    0.08048001f, 0.14661065f, -0.07960822f, -0.10257025f, -0.00855745f, -0.00332125f, -0.05076209f, -0.04175397f, 
    0.07479563f, -0.00904586f, -0.10209461f, 0.03567619f, -0.12403658f, -0.03621835f, -0.15981643f, -0.10836148f, 
    -0.08513002f, -0.00726583f, -0.01193327f, -0.09908066f, 0.03447002f, -0.02244372f, 0.03414199f, 0.01481247f, 
    -0.02318332f, -0.01999357f, 0.16273867f, 0.12949024f, -0.15213954f, -0.03220589f, 0.09785569f, -0.14885825f, 
    0.05338085f, -0.01448440f, 0.02157501f, 0.03760853f, -0.26506889f, 0.06849410f, -0.10144537f, -0.14209414f, 
    -0.13312404f, -0.08953610f, -0.02365354f, -0.16530886f, 0.03084730f, 0.05462705f, 0.05443950f, 0.00838181f, 
    0.18468818f, -0.12802950f, 0.03930894f, 0.12165158f, 0.15321989f, -0.00766600f, -0.03442581f, -0.04980846f, 
    0.04824069f, 0.04250772f, -0.07411923f, -0.00070781f, -0.15760593f, 0.03257162f, 0.05228207f, -0.09112147f, 
    0.01814850f, 0.06860702f, -0.14360224f, 0.00131689f, 0.04274975f, -0.00720406f, 0.00126528f, 0.05755474f, 
    -0.02134422f, -0.14275566f, 0.04895810f, 0.12729152f, -0.07093555f, -0.01832082f, -0.02274796f, -0.15633103f, 
    -0.06652696f, 0.02170452f, 0.03496366f, 0.10910361f, 0.00484202f, -0.15354656f, 0.02857166f, 0.09250114f, 
    0.06646569f, -0.09884378f, -0.05545710f, -0.00158627f, -0.01238981f, -0.04617376f, 0.13009603f, -0.06577211f, 
    0.08691266f, -0.17591035f, -0.14366782f, -0.02346505f, 0.12325762f, 0.02512269f, 0.03327954f, 0.04915661f, 
    0.07881185f, -0.05359595f, 0.02131680f, -0.07041559f, -0.18231000f, -0.05006931f, 0.08179797f, 0.05244722f, 
    -0.00952830f, -0.07281079f, 0.01960889f, 0.03294087f, 0.04737546f, 0.08801807f, 0.09923752f, 0.05447779f, 
    0.08602789f, 0.19111119f, -0.03930556f, 0.12056304f, -0.02558602f, 0.03318138f, -0.02997102f, 0.01731892f, 
    -0.05958234f, -0.18349527f, 0.02322014f, 0.10216149f, -0.12715536f, 0.00385444f, 0.15830733f, 0.07700435f, 
    -0.14585143f, 0.04667949f, -0.08451462f, 0.00728729f, -0.05481232f, -0.02822015f, -0.01631982f, -0.17305696f, 
    0.01548113f, 0.16875078f, -0.18861736f, -0.08938350f, -0.00727401f, -0.04024414f, -0.07449946f, -0.02375511f, 
    -0.00567923f, 0.09172590f, 0.06062216f, 0.04630359f, -0.07882718f, -0.05879659f, -0.13238028f, -0.13040833f, 
    0.02882888f, -0.01256314f, -0.02784660f, 0.04299194f, -0.00875732f, -0.04106316f, 0.09730147f, -0.16420339f, 
    -0.12906528f, 0.22429007f, 0.01191322f, -0.09608115f, -0.08187541f, 0.08800194f, -0.18326484f, 0.03755367f, 
    0.03454027f, 0.06347668f, 0.05223644f, -0.08998463f, 0.07599206f, 0.19263852f, -0.21535684f, -0.07311770f, 
    -0.05906286f, 0.05442382f, -0.12443481f, -0.08030492f, 0.06885911f, -0.07259442f, 0.08858500f, 0.09167129f, 
    -0.24376217f, 0.05715100f, 0.02985695f, -0.20087788f, -0.07486317f, -0.02221004f, -0.08501147f, 0.03541690f, 
    0.03748533f, -0.06152966f, 0.11349047f, -0.11673827f, -0.14905456f, 0.14557531f, -0.07945003f, -0.09961723f, 
    0.04710186f, 0.00080025f, -0.01409619f, 0.00367515f, 0.07817059f, -0.18045671f, 0.07474943f, 0.16118723f, 
    0.09129274f, 0.04298674f, -0.02473818f, 0.07095371f, 0.06766444f, -0.01916271f, -0.05965507f, -0.03228848f, 
    -0.04233080f, 0.08066726f, -0.17117417f, -0.12620112f, 0.01928097f, -0.17238861f, -0.28636232f, 0.00825421f, 
    0.08720310f, 0.09509351f, 0.09072205f, -0.07671957f, 0.10198754f, 0.06532843f, 0.04899847f, 0.09832048f, 
    0.09632647f, -0.12092862f, 0.10877800f, 0.06860224f, -0.01337085f, -0.08932562f, -0.04385588f, -0.04867074f, 
    0.02701170f, 0.09292938f, -0.03306027f, 0.05028371f, -0.02860045f, -0.04984489f, -0.29419187f, -0.12026820f, 
    0.02860617f, 0.01355648f, -0.07275525f, -0.07780571f, 0.01678091f, 0.06634057f, 0.06647473f, 0.08459910f, 
    0.13774402f, 0.07673374f, 0.05661364f, 0.05213041f, -0.11351261f, 0.03502792f, -0.03223710f, 0.04372689f, 
    0.03405507f, -0.01229951f, -0.08265319f, 0.01118788f, 0.03747034f, -0.02187162f, -0.01371034f, 0.12577800f, 
    0.02442380f, -0.04142145f, -0.03054941f, -0.10529043f, 0.05825289f, -0.07713611f, -0.08205560f, 0.06874012f, 
    -0.25592959f, 0.00108703f, 0.03514255f, -0.05454274f, 0.00541765f, 0.06322583f, 0.05129262f, -0.17463183f, 
    -0.04816554f, -0.03659714f, -0.02555024f, 0.07027484f, -0.15351324f, 0.16485123f, -0.08851556f, 0.09010464f, 
    -0.01645278f, 0.10531776f, -0.17217088f, 0.07333499f, 0.06502649f, -0.12106743f, 0.07082462f, -0.10217115f, 
    0.01875103f, -0.08038784f, 0.07712881f, -0.05256251f, -0.10105352f, -0.04527337f, 0.11738881f, -0.02342948f, 
    -0.01914866f, 0.03584111f, 0.00358296f, -0.03361205f, 0.22742112f, 0.22294609f, 0.01239501f, 0.02534742f, 
    -0.07309325f, -0.08858324f, 0.00686272f, -0.15572265f, 0.09177382f, -0.06520985f, 0.06931438f, -0.03111435f, 
    0.19911534f, -0.08185387f, 0.01189270f, 0.08173132f, 0.09252795f, -0.02504757f, 0.00971484f, -0.06728771f, 
    0.01102220f, 0.04807303f, 0.07715449f, -0.08257741f, 0.10524713f, -0.04473270f, 0.06697354f, 0.13752843f, 
    -0.13210428f, -0.04602684f, 0.07106078f, -0.01920136f, 0.02554874f, -0.00871393f, -0.05885889f, 0.01492510f, 
    -0.23314552f, -0.04091954f, 0.06720701f, -0.16715412f, -0.07702079f, -0.05622758f, -0.03125918f, 0.05238093f, 
    0.07267496f, -0.08314697f, 0.05601594f, -0.05550140f, 0.11471054f, 0.08164527f, -0.16844051f, -0.12790805f, 
    -0.03968728f, -0.07544940f, 0.05868812f, 0.02020176f, -0.06471573f, -0.10724335f, -0.05277015f, 0.00356557f, 
    -0.01975035f, -0.25735775f, 0.01352372f, -0.14154978f, 0.10710214f, -0.14614181f, 0.02853667f, -0.04541397f, 
    0.11826330f, -0.00071580f, -0.05019246f, 0.05597288f, -0.08813884f, 0.12799579f, -0.03208370f, 0.05492456f, 
    -0.00069971f, 0.04746102f, -0.16494867f, -0.00922273f, -0.04312796f, -0.06172025f, 0.02487187f, 0.04820735f, 
    0.05727781f, -0.09661150f, -0.01666094f, 0.01223599f, 0.05192266f, 0.05014441f, -0.02824749f, -0.07397085f, 
    -0.06270187f, 0.02123388f, 0.06462417f, 0.06198264f, -0.18000048f, 0.28154075f, 0.01132674f, -0.21197663f, 
    -0.03529970f, -0.03621432f, 0.08303022f, 0.06306865f, 0.08244272f, -0.01551997f, 0.06953220f, 0.09346234f, 
    0.00430252f, -0.09473605f, -0.10703173f, -0.02413941f, 0.04011549f, -0.01499014f, 0.02119694f, 0.06410050f, 
    0.07853904f, 0.07606279f, 0.05099533f, 0.05513117f, -0.05386312f, -0.11901673f, 0.12840450f, -0.05746419f, 
    0.07561161f, -0.06333152f, 0.01184578f, -0.21305738f, 0.01442822f, 0.00401524f, 0.08635307f, -0.02779963f, 
    -0.26728392f, 0.13080297f, -0.05348926f, -0.11617769f, -0.11989442f, -0.10249621f, 0.01446254f, 0.04351725f, 
    0.01606705f, 0.02939710f, -0.00601271f, 0.06001569f, -0.05665443f, -0.11611190f, 0.07900700f, 0.19554961f, 
    0.09127544f, 0.00899895f, -0.00563905f, 0.01985814f, -0.05458295f, 0.07245001f, 0.12933448f, 0.07402571f, 
    -0.05211234f, -0.08252148f, -0.12796941f, 0.09745340f, 0.08684971f, -0.08657057f, 0.02012323f, -0.01099391f, 
    0.05770573f, 0.10695491f, 0.10395446f, -0.10846934f, -0.28068385f, -0.04468081f, 0.10199968f, -0.00373673f, 
    -0.05838383f, 0.05708442f, -0.00892732f, -0.10866661f, -0.01778318f, -0.02006417f, 0.00126550f, 0.09307691f, 
    -0.08106521f, -0.07210454f, -0.12046012f, -0.09727535f, -0.01770328f, -0.03384143f, -0.06229049f, -0.13927713f, 
    -0.08505525f, -0.08128564f, -0.07098921f, -0.19289203f, 0.10366275f, -0.23712319f, -0.07231399f, -0.17052661f, 
    -0.05553501f, -0.05151638f, 0.07232124f, 0.01700608f, 0.06171264f, 0.04837414f, -0.01199601f, 0.05546188f, 
    -0.06387183f, -0.06591979f, 0.19398548f, -0.05800565f, -0.06477235f, -0.06351899f, -0.07612489f, -0.10604831f, 
    -0.05293373f, -0.07684655f, -0.03667651f, -0.09324089f, -0.00629256f, 0.00351421f, 0.00971935f, 0.12413492f, 
    0.09030539f, -0.05004320f, -0.05915575f, 0.01460207f, -0.01297324f, 0.09232189f, -0.12992007f, -0.09937170f, 
    0.10122430f, -0.30829686f, -0.11112393f, 0.02915731f, -0.00374634f, 0.05122083f, -0.03004698f, 0.00546095f, 
    -0.11757626f, -0.03704873f, 0.11066057f, -0.19135270f, -0.18116663f, -0.02778862f, -0.19827594f, 0.03045713f, 
    -0.00653787f, -0.08721475f, -0.00311525f, 0.06947008f, -0.02283910f, 0.07375573f, 0.10896870f, 0.08789334f, 
    -0.01515468f, -0.13885973f, -0.08629523f, 0.01462184f, 0.11469021f, 0.04120846f, -0.01134609f, 0.03072154f, 
    0.05048846f, -0.00865894f, -0.01517896f, -0.14265689f, -0.18817627f, 0.09330334f, -0.01264228f, -0.29280785f, 
    0.00105636f, 0.04315739f, -0.08131141f, -0.01107735f, -0.03242956f, -0.03498850f, 0.07096707f, -0.07035137f, 
    -0.35878202f, 0.07137736f, 0.07746612f, -0.21538500f, -0.04160375f, -0.07556694f, -0.05295715f, 0.01341452f, 
    0.00956795f, 0.05180321f, -0.07286609f, -0.02307790f, 0.32297376f, 0.39139211f, -0.28452352f, 0.25055155f, 
    -0.13703434f, 0.06052308f, -0.07222272f, 0.08630413f, -0.00013045f, 0.02975513f, 0.04489382f, 0.04375517f, 
    0.14157602f, -0.38387120f, 0.03168475f, 0.06714503f, 0.07607955f, 0.00610494f, 0.05612417f, -0.02386907f, 
    -0.02399017f, -0.03897091f, -0.00791178f, 0.05466643f, -0.25593436f, -0.32583404f, -0.06511338f, -0.03070352f, 
    0.14881609f, -0.04023694f, -0.05292837f, -0.01979587f, 0.03835226f, -0.00234787f, -0.01982422f, -0.05037171f, 
    -0.36866707f, 0.27202344f, -0.16557713f, -0.19118144f, 0.04713902f, -0.08033241f, 0.07978117f, -0.13261922f, 
    0.00068500f, 0.06797444f, 0.02025549f, 0.03212876f, 0.11312257f, -0.17273852f, 0.15754618f, -0.07579050f, 
    0.10879671f, 0.09356245f, -0.01886994f, -0.01717910f, -0.18407217f, 0.01591839f, -0.03734063f, 0.06020305f, 
    -0.40610403f, -0.07068520f, 0.04788819f, -0.00974968f, -0.07274074f, 0.06254385f, 0.11303493f, 0.01844977f, 
    -0.20334122f, 0.04918665f, -0.00899326f, 0.00215709f, 0.05676314f, -0.02404250f, -0.05590037f, 0.16386910f, 
    0.04143221f, 0.01697056f, 0.01351855f, 0.07401572f, 0.02241122f, -0.01769871f, 0.03604671f, 0.06996398f, 
    0.24035269f, 0.25116870f, -0.02703157f, -0.40616530f, 0.05427333f, 0.04830753f, -0.01630898f, 0.00388357f, 
    -0.16986153f, -0.00281356f, 0.08582035f, -0.11634560f, -0.06592733f, -0.04705090f, -0.06016618f, 0.00769307f, 
    -0.02508035f, 0.03977997f, 0.11880323f, -0.03989321f, -0.10350782f, 0.04601275f, 0.00625095f, 0.09429661f, 
    -0.04286063f, -0.21309407f, 0.11250031f, 0.20214710f, -0.04427836f, -0.09226365f, 0.07067604f, -0.01836479f, 
    0.11679521f, -0.00099075f, -0.03351999f, -0.09758561f, -0.32999647f, -0.15101221f, -0.00522338f, 0.11152899f, 
    0.07075855f, -0.04021567f, 0.01631394f, -0.02142206f, 0.06232623f, -0.16002649f, 0.03776691f, -0.13173737f, 
    0.35154921f, 0.02134259f, 0.11199553f, -0.11186930f, -0.01041883f, 0.06394488f, 0.08532023f, -0.02433290f, 
    -0.07745674f, -0.04917352f, -0.12554777f, -0.04517171f, 0.13727392f, 0.20691319f, 0.02535714f, 0.14905785f, 
    0.07189600f, 0.02836913f, -0.01517238f, -0.04485953f, 0.17881113f, -0.03490984f, -0.01575189f, -0.03102493f, 
    -0.06996553f, 0.27538398f, 0.21253704f, 0.15257026f, -0.02891404f, -0.04868395f, -0.03477674f, 0.05477132f, 
    0.09435426f, 0.00640436f, 0.13434041f, 0.06886967f, -0.35828483f, 0.01590899f, -0.08075505f, -0.14956798f, 
    -0.15017526f, -0.00637557f, 0.06388053f, 0.09151328f, 0.00911366f, 0.07222605f, 0.03868940f, 0.02362005f, 
    0.06070621f, -0.29124203f, -0.05433263f, -0.02629869f, 0.11898120f, 0.07138957f, -0.03950247f, -0.14052810f, 
    -0.01028814f, -0.09987654f, 0.09710576f, -0.14090048f, 0.04944561f, -0.16220443f, -0.35496372f, 0.11010375f, 
    -0.03527769f, 0.03666886f, 0.02717977f, -0.05632113f, -0.06343625f, 0.00797369f, 0.06199951f, 0.00573503f, 
    -0.14071637f, -0.02513909f, -0.08260982f, -0.18615444f, -0.02762455f, 0.02582002f, -0.00521128f, -0.12046743f, 
    -0.05770779f, -0.10100749f, -0.02689155f, 0.05918664f, 0.05392109f, -0.20522904f, -0.06868520f, 0.16474277f, 
    0.02102970f, -0.04532167f, -0.03152458f, 0.08350344f, 0.03349355f, 0.09906495f, 0.00799698f, 0.00417182f, 
    0.39858159f, 0.04860279f, -0.27210814f, -0.24501693f, 0.08848131f, -0.03573220f, -0.01980395f, 0.10307947f, 
    0.17982119f, -0.05995693f, 0.01462713f, 0.14353628f, -0.14257339f, -0.03358983f, -0.02730438f, 0.11421236f, 
    -0.07948235f, -0.09790798f, 0.02762846f, 0.00043769f, -0.06319100f, 0.03510551f, -0.02248782f, -0.01171022f, 
    0.00030863f, 0.12304327f, 0.18487726f, -0.05958387f, -0.03980009f, 0.00653843f, 0.05723551f, -0.09267920f, 
    -0.01404227f, -0.06921633f, 0.00524300f, 0.01730900f, -0.25934997f, 0.31302407f, -0.04530870f, -0.07569027f, 
    0.06080286f, -0.04278295f, -0.02884960f, 0.08745863f, -0.05472763f, 0.07473934f, -0.05747036f, -0.07988612f, 
    -0.26062611f, -0.18018706f, 0.26173258f, -0.21051255f, -0.01179215f, 0.02960814f, 0.03369815f, 0.09649165f, 
    -0.02129639f, 0.03251117f, -0.02410960f, -0.02902004f, 0.10845014f, -0.29693684f, -0.02731813f, -0.00002439f, 
    -0.02509209f, -0.05300379f, -0.05122048f, 0.11813837f, -0.01906784f, 0.22485544f, -0.06499302f, 0.04047448f, 
    -0.46604118f, 0.18385035f, 0.05019434f, -0.06971996f, 0.01718461f, -0.00513659f, -0.01790972f, -0.07947418f, 
    -0.01498976f, -0.00931156f, 0.03647662f, 0.05212136f, 0.17540446f, 0.11231784f, -0.19487903f, -0.15718968f, 
    0.10705981f, -0.10146687f, -0.00144540f, 0.16577390f, 0.06636022f, -0.05818268f, -0.12010313f, -0.10005306f, 
    -0.12067136f, 0.22754380f, 0.03621797f, 0.12160461f, 0.08607455f, 0.08013729f, 0.09220215f, -0.00191109f, 
    -0.06462096f, -0.00824710f, -0.03775271f, 0.05495519f, -0.07567166f, 0.15129273f, 0.23884954f, 0.00620132f, 
    0.07979135f, -0.00618070f, -0.07861666f, 0.04251324f, -0.05053957f, 0.08381522f, 0.06045502f, -0.05065449f, 
    -0.08649357f, -0.20870914f, -0.10297963f, 0.07947944f, 0.08552936f, 0.04504940f, -0.07295193f, -0.00689332f, 
    0.02430158f, -0.07422085f, -0.14656310f, -0.05443992f, -0.12624118f, -0.04081910f, 0.13575476f, 0.04080898f, 
    -0.08284371f, -0.01285324f, -0.01294656f, -0.04383876f, -0.06274743f, -0.09310768f, 0.01121398f, -0.07552563f, 
    0.14020409f, -0.06972156f, 0.04472093f, -0.10492573f, 0.12463039f, -0.10486215f, 0.02174132f, -0.03871887f, 
    0.11420277f, -0.02192589f, 0.05960194f, 0.04679378f, 0.08321810f, -0.27060631f, 0.09256060f, -0.06562151f, 
    -0.00329028f, 0.08723792f, -0.08764985f, 0.04683371f, -0.20481409f, -0.14221855f, -0.05944259f, -0.07213533f, 
    0.06590186f, -0.12300818f, 0.00652259f, 0.32308647f, 0.03728283f, -0.03956505f, 0.01195995f, -0.01267304f, 
    -0.00468753f, 0.00813904f, -0.00647948f, -0.06218417f, 0.00494107f, 0.12925692f, -0.08990181f, -0.24809228f, 
    0.05188574f, -0.00309643f, -0.01469013f, 0.06313054f, -0.01056595f, 0.04108777f, -0.07078273f, 0.03006605f, 
    -0.49129197f, 0.52778351f, 0.05928597f, 0.02772276f, 0.15823583f, 0.02843988f, -0.08542758f, 0.07101451f, 
    0.04452943f, -0.02809782f, 0.05855080f, 0.00482823f, -0.14116928f, -0.04252768f, -0.08494219f, 0.14126815f, 
    0.07136762f, -0.01905585f, -0.10890321f, -0.02511172f, -0.04965283f, -0.02701211f, 0.13224953f, -0.03349445f, 
    0.06990632f, -0.05798934f, -0.19755760f, 0.30992237f, -0.02790795f, 0.04012826f, 0.00844885f, -0.00204609f, 
    0.12750173f, 0.06882922f, -0.04500334f, -0.10887402f, -0.11517178f, 0.03579357f, 0.13626713f, 0.07098768f, 
    0.10533539f, -0.05609864f, -0.05528386f, 0.03453380f, -0.03944701f, 0.09546149f, -0.06146997f, 0.08961260f, 
    0.16571924f, -0.04409934f, 0.07878729f, 0.07852069f, 0.05356280f, 0.04651505f, -0.17307201f, 0.00061302f, 
    0.01750295f, 0.15440826f, -0.00820156f, 0.05554291f, 0.29522052f, 0.02817844f, -0.22839500f, -0.01051733f, 
    0.07911589f, 0.02345088f, 0.06071952f, 0.16029158f, -0.01864479f, -0.10678208f, 0.05098326f, 0.20871364f, 
    -0.26577175f, 0.05945163f, -0.24450515f, 0.02547786f, 0.11152632f, -0.04219390f, -0.01214492f, 0.03187111f, 
    0.02286659f, 0.02974974f, -0.03895373f, 0.06036761f, 0.12686242f, 0.16733721f, -0.27576312f, 0.07058066f, 
    0.03785423f, 0.01984147f, -0.05717526f, 0.06780765f, -0.08176637f, -0.03666812f, -0.03059012f, -0.01133336f, 
    -0.15502584f, 0.10501654f, 0.02468111f, -0.00891627f, -0.04726654f, 0.02021749f, -0.00532861f, -0.08706364f, 
    -0.04886571f, 0.04829258f, 0.07523945f, 0.06126210f, -0.23575613f, 0.07314146f, -0.07957075f, 0.05981834f, 
    0.02535756f, -0.00935671f, -0.06842252f, 0.04775055f, 0.04718048f, -0.00065888f, 0.07481986f, 0.06375545f, 
    0.05169325f, 0.20425160f, 0.10964220f, -0.05541334f, 0.05188227f, 0.09448414f, -0.06731057f, -0.15172318f, 
    -0.05672130f, -0.05721372f, 0.10888889f, -0.10709756f, 0.08925527f, -0.53209114f, -0.19767466f, -0.18647921f, 
    0.05733419f, -0.03385635f, -0.06386013f, 0.05726036f, -0.10889707f, -0.01009844f, 0.13226397f, 0.02783940f, 
    -0.13886622f, -0.16015133f, -0.02000790f, 0.08020812f, 0.06248897f, -0.00297891f, 0.00065309f, 0.00639313f, 
    0.02650143f, -0.05101097f, -0.01416662f, 0.01979858f, -0.01592718f, -0.06759974f, -0.00068365f, 0.03427039f, 
    0.00497844f, -0.04111149f, 0.01763264f, 0.18893367f, -0.01470535f, -0.05825777f, 0.08707181f, 0.09128070f, 
    -0.09771714f, 0.14945431f, -0.07949156f, -0.10420719f, 0.06517737f, 0.09268919f, -0.07423537f, 0.07043079f, 
    0.01273593f, -0.07323235f, 0.07666866f, 0.04659126f, 0.21764515f, -0.11713604f, -0.05165077f, 0.10343634f, 
    -0.01276499f, -0.03945728f, 0.00960479f, -0.00637832f, 0.04036850f, -0.00556146f, -0.04495953f, 0.01318562f, 
    0.04831931f, -0.08493649f, -0.08839203f, 0.04228054f, -0.07745161f, -0.01198807f, 0.05085928f, -0.08003026f, 
    0.02239386f, -0.02426776f, -0.04786611f, -0.01435708f, -0.14965121f, 0.04901138f, -0.00938332f, -0.19643492f, 
    0.12851320f, -0.05902757f, -0.04886604f, -0.04326961f, -0.05362213f, -0.02143675f, 0.03692188f, -0.21728468f, 
    -0.07495545f, 0.09028750f, 0.00441089f, -0.39834595f, 0.04393134f, 0.09795985f, -0.13609131f, 0.11126591f, 
    -0.12604654f, -0.06059800f, -0.14458616f, -0.02160130f, 0.03304233f, 0.11907376f, -0.09919567f, -0.01268574f, 
    0.00145750f, -0.06013622f, 0.06754138f, -0.06553247f, 0.03916608f, 0.01117702f, -0.00356853f, -0.03352360f, 
    -0.03911620f, 0.01602165f, -0.01277072f, 0.07015666f, -0.00157731f, -0.02098894f, -0.12341312f, 0.03129448f, 
    0.00387931f, 0.03143977f, 0.03822470f, 0.05347825f, -0.05055812f, 0.06346328f, 0.00118607f, -0.02941334f, 
    0.04301594f, -0.00651740f, 0.02860657f, 0.01482196f, 0.01147299f, -0.05621261f, -0.15860642f, -0.13286072f, 
    0.41308993f, 0.03639999f, -0.12562241f, 0.19853611f, 0.13344775f, -0.04280627f, 0.01050886f, -0.04417515f, 
    -0.04358149f, -0.06009443f, 0.13047922f, 0.09922919f, -0.21778606f, 0.26702824f, -0.01363705f, -0.09152150f, 
    -0.10027685f, 0.08183654f, 0.00619688f, 0.03988704f, 0.12279932f, 0.03647118f, 0.17701355f, 0.00808400f, 
    -0.37925079f, -0.09146700f, -0.05838392f, -0.02760579f, 0.11962755f, -0.14881119f, 0.02128494f, -0.02984359f, 
    -0.04222153f, 0.07975709f, 0.05952169f, 0.08187439f, 0.06152746f, 0.01021290f, -0.15533252f, 0.21383823f, 
    -0.05634009f, 0.04726752f, -0.13798942f, 0.06530069f, -0.06797414f, -0.11122365f, -0.10358593f, -0.04828049f, 
    0.24591377f, 0.06277875f, 0.09039553f, -0.14849414f, -0.11728312f, -0.05679531f, -0.05403037f, 0.00526312f, 
    0.04876301f, 0.01656261f, -0.06245427f, -0.00352264f, -0.51390219f, -0.14379585f, -0.06227099f, -0.38580596f, 
    0.16285382f, -0.10658443f, 0.02604659f, 0.03339371f, 0.08630463f, -0.07119565f, -0.04749144f, -0.01699177f, 
    0.07134771f, 0.00391692f, -0.01415213f, 0.12497074f, -0.00271833f, 0.08532245f, -0.03140803f, 0.06695037f, 
    0.07533813f, -0.04498644f, 0.05157882f, 0.08412312f, -0.20892358f, -0.17541765f, 0.26316926f, 0.05294282f, 
    0.03836796f, -0.08126174f, -0.00812913f, 0.08980148f, 0.03557291f, 0.04202255f, 0.04283228f, -0.08771401f, 
    0.01392951f, -0.03820712f, -0.14637437f, -0.13575946f, 0.05103623f, -0.12279528f, -0.15089394f, -0.00155130f, 
    -0.07561280f, 0.01940826f, -0.06317227f, 0.00004440f, 0.24897297f, 0.08114164f, -0.08206528f, 0.03967363f, 
    -0.06987832f, -0.07164232f, 0.09210438f, -0.06186446f, 0.04631518f, -0.00993705f, 0.06405790f, -0.02487305f, 
    -0.16083311f, -0.21448739f, -0.13286670f, -0.05514488f, 0.03137301f, -0.00019802f, -0.03166309f, -0.01801934f, 
    -0.05432749f, -0.02994155f, -0.09152593f, -0.03929111f, -0.14057709f, 0.06493178f, -0.07299066f, 0.03956441f, 
    -0.03732568f, 0.05241081f, -0.05011626f, 0.10392106f, 0.07054532f, 0.18480557f, 0.06920381f, 0.07290679f, 
    -0.23942262f, 0.02850582f, 0.04652697f, 0.13280013f, -0.00234640f, -0.13907725f, -0.00322427f, 0.00182788f, 
    0.07467498f, 0.08671582f, -0.02519335f, 0.10047635f, 0.25339603f, -0.00548580f, -0.07718430f, -0.08939970f, 
    0.01717036f, -0.05795524f, -0.02236445f, -0.01564873f, -0.01420399f, 0.06680720f, -0.21777675f, -0.11536560f, 
    -0.20878474f, -0.09518836f, 0.09099281f, 0.03256048f, 0.13299988f, -0.08571151f, -0.03995654f, -0.05301102f, 
    -0.01091483f, 0.01231774f, -0.01432333f, 0.07974648f, 0.14817402f, 0.06594866f, -0.01212951f, -0.09514497f, 
    0.00997635f, 0.14987481f, -0.05817297f, -0.00116898f, 0.03238271f, 0.02292759f, 0.02688556f, -0.05457146f, 
    0.24185047f, -0.00928688f, 0.13465491f, -0.14532223f, 0.01328590f, 0.01924052f, -0.01075162f, 0.15627663f, 
    -0.02541166f, 0.07323992f, -0.11601745f, -0.04832940f, -0.04074602f, 0.01871076f, -0.11368959f, 0.01732039f, 
    -0.00129330f, -0.15797932f, 0.08025131f, -0.11150598f, -0.03539827f, -0.11021508f, 0.04448273f, -0.12646149f, 
    -0.43884903f, -0.14943375f, 0.02359361f, 0.06367100f, 0.08906766f, -0.01686876f, -0.01141461f, -0.05600765f, 
    0.09105084f, 0.10669918f, -0.01364227f, 0.13199906f, -0.36136645f, -0.20811565f, -0.01167387f, -0.12938902f, 
    0.08480099f, -0.02014129f, -0.15655437f, -0.14429498f, -0.06967730f, -0.06710975f, -0.03112326f, 0.09667494f, 
    -0.15982127f, -0.01148494f, 0.03212027f, -0.03866025f, -0.02864719f, 0.00044568f, -0.04944122f, -0.07652614f, 
    0.13819118f, -0.17182180f, -0.14224270f, -0.09507081f, 0.29347426f, 0.06691402f, -0.01483332f, -0.00915869f, 
    0.07645950f, -0.08539417f, -0.06948625f, 0.04004020f, -0.08490033f, -0.06508343f, 0.03163084f, 0.02520478f, 
    0.14096184f, 0.05999040f, 0.05319122f, 0.02012968f, -0.00275364f, -0.00840652f, 0.06316730f, 0.05419964f, 
    0.03492286f, 0.12068494f, 0.01924727f, 0.10826796f, 0.01889428f, 0.02434647f, -0.00166576f, -0.00331773f, 
    -0.00645010f, 0.09181595f, -0.00930264f, 0.00330648f, -0.05179106f, -0.02366312f, 0.04450913f, 0.03991792f, 
    -0.33541030f, -0.29030541f, -0.19927202f, -0.16476879f, 0.05946799f, 0.08216688f, -0.00856636f, 0.03154222f, 
    0.12095160f, 0.13755992f, 0.02319890f, 0.06595855f, 0.13866380f, 0.04024396f, 0.07487695f, -0.03177126f, 
    0.02238600f, 0.17618296f, 0.05950662f, 0.11504370f, 0.00324503f, 0.03603218f, 0.03310352f, 0.00456109f, 
    -0.19029869f, 0.05182485f, -0.05757192f, 0.03141656f, 0.05370905f, 0.00258040f, -0.09792228f, 0.06553775f, 
    -0.07752657f, -0.00379120f, 0.06551773f, 0.02788049f, -0.30326980f, -0.05760903f, -0.02387096f, -0.07404529f, 
    0.02958678f, -0.04507389f, -0.16567068f, -0.08920968f, -0.03008517f, -0.13891247f, 0.00659121f, -0.10348483f, 
    -0.46910203f, -0.12756585f, 0.22297934f, 0.07395360f, 0.11626829f, 0.02526144f, 0.02732477f, -0.03486990f, 
    -0.00061893f, 0.01293048f, -0.06344064f, -0.00677798f, -0.08093660f, -0.27393579f, -0.10401117f, -0.13637066f, 
    0.08986755f, -0.25770137f, 0.03969780f, -0.05789761f, 0.00775371f, -0.05034939f, -0.03219485f, 0.08355711f, 
    -0.09567171f, -0.05888487f, -0.11809453f, -0.02662348f, 0.00956037f, 0.00080250f, -0.02825304f, 0.02815393f, 
    -0.04666714f, -0.01827157f, -0.02758093f, 0.01024916f, 0.24129267f, 0.05240894f, 0.01178418f, -0.06575750f, 
    -0.13682085f, 0.07791362f, -0.06411120f, -0.00890565f, 0.02891844f, 0.04999155f, 0.04459850f, -0.09655353f, 
    -0.36743677f, -0.10030143f, 0.14860088f, 0.00854071f, 0.07497822f, 0.06252432f, -0.01207343f, 0.02816876f, 
    0.17581818f, 0.14357254f, -0.03807252f, 0.06033587f, 0.12920330f, 0.11594333f, -0.03969274f, 0.05199886f, 
    -0.00918082f, 0.04793245f, 0.01432785f, -0.00558979f, 0.01338347f, 0.09329491f, 0.02827519f, -0.04108799f, 
    0.07130980f, -0.07771901f, -0.08630743f, -0.04004851f, -0.01473192f, -0.02371620f, -0.07365930f, 0.07012074f, 
    -0.09491810f, -0.04774335f, -0.02067341f, -0.00812298f, -0.22898531f, -0.19401710f, -0.07480983f, 0.05805529f, 
    0.10973380f, -0.02009681f, -0.03680771f, -0.03576764f, 0.06012942f, 0.02302428f, 0.07526405f, 0.05571524f, 
    0.14909549f, 0.08576319f, -0.03557225f, -0.12448514f, 0.06137548f, 0.08532223f, 0.02813323f, -0.08102860f, 
    -0.10240812f, 0.17802300f, 0.11500253f, 0.01899916f, -0.15529521f, -0.12088884f, 0.27548259f, -0.02034817f, 
    0.11049339f, 0.07817199f, 0.07121139f, -0.09646048f, 0.03931978f, -0.11049346f, 0.05181507f, 0.10621763f, 
    0.11435104f, 0.10821338f, 0.04445861f, 0.07437351f, -0.00748238f, -0.02704549f, -0.01660834f, 0.06339376f, 
    -0.04249573f, -0.08325337f, -0.03665580f, 0.15894361f, -0.35133737f, -0.01980400f, 0.06772054f, -0.09729452f, 
    -0.02473917f, 0.03446775f, 0.11473248f, 0.08411765f, 0.05668245f, 0.00722566f, -0.00987882f, 0.07793280f, 
    -0.20935872f, -0.01813753f, -0.21018213f, -0.22863489f, 0.09215098f, 0.01848661f, -0.19141082f, 0.00649893f, 
    -0.01258780f, -0.03008135f, -0.05779316f, -0.02246809f, -0.00921186f, -0.01715937f, -0.03385446f, -0.13552557f, 
    0.00660654f, 0.03927496f, -0.02337564f, -0.00300645f, 0.01028810f, -0.01837102f, 0.03924948f, -0.03304524f, 
    -0.06349459f, -0.22593245f, -0.05321733f, 0.05066849f, -0.05362111f, -0.00622990f, 0.16154598f, 0.08391890f, 
    0.12895891f, 0.01541543f, -0.06337259f, 0.05529619f, 0.08445916f, 0.08227819f, -0.00129164f, -0.20482735f, 
    0.05335035f, -0.04482438f, -0.04214465f, -0.03027145f, -0.04334956f, -0.00529881f, -0.10015327f, 0.01744718f, 
    0.33822966f, 0.17513716f, -0.03293252f, -0.14207007f, 0.06216247f, -0.04417915f, 0.04381594f, 0.08485071f, 
    0.02292678f, -0.20711185f, 0.07250869f, 0.06383351f, 0.07488435f, -0.01303084f, 0.08407616f, -0.02338864f, 
    -0.10001920f, 0.10962696f, -0.11974088f, 0.02348250f, 0.14753041f, -0.05650577f, 0.10998449f, -0.09886665f, 
    0.16313456f, 0.03929175f, -0.09591034f, 0.09394255f, -0.13279188f, -0.08506915f, 0.05928667f, -0.00147891f, 
    0.04988441f, 0.02224168f, -0.02086331f, 0.00093450f, -0.18400170f, -0.19664823f, 0.09988219f, 0.06690782f, 
    -0.02122103f, 0.09321410f, 0.05703517f, -0.10519730f, 0.06675719f, 0.08926605f, 0.18133169f, -0.03094225f, 
    -0.34588766f, -0.16431682f, -0.20980723f, -0.28076592f, 0.01028347f, 0.08926905f, -0.08880720f, -0.00402159f, 
    0.13245413f, -0.00246074f, -0.05317149f, -0.09232847f, 0.15249215f, -0.02691321f, -0.08858562f, 0.00695227f, 
    0.01427024f, -0.14485125f, 0.01145667f, 0.10712133f, -0.06326011f, -0.01683248f, 0.06550897f, 0.01416506f, 
    -0.04324549f, 0.04754292f, 0.02399023f, 0.03258025f, 0.00461870f, 0.02927624f, 0.07045132f, 0.05497577f, 
    -0.02554348f, -0.04423694f, 0.03322810f, -0.17766206f, 0.13197009f, 0.02661005f, -0.04356277f, -0.00300244f, 
    -0.05727506f, 0.07232781f, 0.00416332f, -0.07365880f, 0.04351252f, -0.05973654f, -0.03444503f, 0.05981318f, 
    -0.20212656f, 0.11359423f, -0.00849298f, 0.09394341f, 0.08945566f, 0.13592388f, 0.07149094f, -0.00802017f, 
    0.08951826f, -0.08659737f, 0.12994727f, 0.19725084f, -0.20188375f, 0.11789761f, -0.16620187f, -0.04599902f, 
    0.16398479f, 0.14269701f, -0.03969408f, -0.04849421f, 0.09485228f, 0.02282120f, -0.05027780f, 0.01437872f, 
    -0.57985318f, -0.38365462f, -0.11071295f, -0.13238896f, 0.03628340f, 0.07971311f, -0.06651192f, -0.07197452f, 
    0.02145738f, 0.00646954f, 0.04943786f, -0.02415033f, 0.05761296f, -0.06073710f, 0.06633861f, -0.10898371f, 
    -0.01375593f, 0.08072656f, 0.09975122f, -0.05607744f, 0.04973221f, -0.00998898f, 0.03391556f, 0.06650630f, 
    0.14641546f, -0.09116910f, -0.03548309f, -0.01776488f, 0.10528407f, -0.00310579f, 0.07188128f, 0.09055472f, 
    0.06633891f, -0.01618487f, 0.00043883f, 0.08109911f, 0.21352603f, 0.13744323f, -0.08806413f, 0.15747775f, 
    -0.06748272f, 0.00161789f, 0.02256305f, -0.00779215f, -0.00043617f, 0.03385289f, 0.09341311f, -0.03054397f, 
    0.16361611f, 0.04250227f, 0.11679940f, -0.09186020f, 0.06203131f, -0.01072046f, 0.01177206f, 0.07224214f, 
    0.03680973f, 0.07562613f, 0.07187025f, 0.15393388f, -0.37176451f, -0.16719346f, -0.19117045f, -0.21979059f, 
    -0.01948499f, -0.01638133f, -0.12468731f, 0.01934291f, -0.00515207f, 0.15303127f, 0.04819397f, 0.10855589f, 
    -0.26885074f, 0.02060426f, -0.12989727f, -0.15902169f, 0.06164205f, -0.13575874f, -0.04962251f, 0.04094302f, 
    0.11009838f, 0.10683529f, 0.19232915f, 0.04145102f, 0.15613991f, 0.14326988f, 0.09361658f, -0.03604278f, 
    -0.02039589f, 0.06744469f, 0.02875299f, 0.11937539f, -0.01428824f, 0.03216645f, 0.13902372f, 0.03734441f, 
    0.04177945f, -0.10755975f, 0.03118141f, -0.11098102f, -0.02879619f, -0.05093098f, 0.00351705f, -0.18093570f, 
    -0.01807258f, -0.20397013f, -0.24018440f, -0.19298202f, 0.02413468f, 0.12198193f, -0.03858989f, 0.04218430f, 
    0.00732867f, 0.06432884f, 0.05951457f, 0.01333309f, -0.04405881f, 0.00434177f, 0.12405140f, -0.00402125f, 
    0.16278368f, 0.11988616f, 0.06458870f, -0.01929093f, -0.07221665f, 0.04434249f, -0.04581587f, 0.12606324f, 
    0.10212667f, -0.12706366f, -0.08594295f, -0.10739520f, -0.36619544f, -0.36387157f, -0.08674017f, -0.04943635f, 
    0.04293043f, -0.01014750f, -0.05595407f, -0.19672769f, -0.01184890f, -0.13124444f, -0.19224024f, 0.07864322f, 
    -0.03944346f, -0.06795411f, -0.03571995f, 0.15719740f, -0.03782572f, 0.15336162f, 0.01488768f, 0.13916554f, 
    0.01571693f, 0.00436036f, -0.12924838f, -0.12411978f, -0.50585139f, 0.16444458f, -0.14444678f, 0.04682928f, 
    0.17054935f, -0.09006983f, 0.08763047f, -0.13669398f, -0.04704749f, 0.00108953f, 0.06501688f, 0.12056185f, 
    -0.14812148f, -0.02782214f, 0.02903443f, -0.01499596f, -0.00924479f, -0.06328851f, -0.06935490f, -0.03874551f, 
    -0.01230174f, 0.03366243f, 0.06682392f, -0.16882201f, 0.19887814f, -0.05075181f, -0.07634171f, 0.01868088f, 
    -0.04714887f, -0.02622006f, 0.06655910f, -0.04638800f, 0.03825187f, -0.00740272f, 0.05047693f, -0.01659774f, 
    0.15896595f, 0.06487247f, -0.09787185f, -0.08496219f, 0.05647575f, 0.00942231f, 0.09420728f, -0.13480808f, 
    0.00516425f, 0.07180244f, 0.04623013f, -0.03366124f, -0.12508115f, 0.06411026f, -0.15777403f, 0.12485680f, 
    0.04072209f, -0.14251012f, -0.06408720f, -0.00879327f, -0.12882419f, 0.01233202f, 0.00563406f, -0.02641631f, 
    -0.50408089f, -0.09854022f, -0.05844674f, -0.11109004f, -0.02605086f, 0.05365261f, -0.01294563f, 0.13583772f, 
    -0.09917247f, 0.00940826f, 0.00711626f, 0.01840135f, 0.30244523f, -0.13062833f, -0.00166153f, 0.05682365f, 
    -0.00400291f, 0.05611034f, 0.04542137f, 0.02243132f, -0.10434971f, -0.08808614f, -0.00913066f, -0.14221421f, 
    -0.03953253f, -0.14281513f, -0.18638778f, -0.25512242f, -0.06047827f, -0.00983535f, 0.05068488f, 0.01298570f, 
    0.06597388f, 0.04664054f, -0.03206075f, -0.03422247f, -0.08602382f, 0.17442524f, -0.05312304f, 0.11871309f, 
    -0.13183707f, 0.04922362f, 0.03621014f, -0.00335809f, -0.03473471f, -0.09760597f, -0.00999301f, -0.02380273f, 
    0.01994402f, 0.04539665f, -0.00704341f, -0.13561803f, 0.03946554f, 0.04997977f, 0.05569955f, -0.09920052f, 
    -0.08833243f, -0.02067843f, 0.07848907f, 0.08580442f, -0.27506807f, -0.04004243f, -0.06141149f, -0.05653030f, 
    0.02481698f, -0.00296691f, -0.02554049f, 0.12721555f, 0.05871368f, 0.02084907f, 0.03281901f, -0.07113307f, 
    0.28771526f, -0.12125179f, 0.15724817f, -0.05404261f, 0.19848454f, -0.17729132f, -0.14336136f, 0.07352293f, 
    0.06630037f, -0.09759440f, 0.00608118f, 0.04330867f, -0.27318290f, 0.15083738f, -0.01847655f, 0.05362076f, 
    -0.01107457f, -0.03360396f, -0.06042417f, -0.07810312f, 0.05870862f, 0.01218844f, -0.00226640f, -0.07315261f, 
    0.06901560f, 0.05832396f, 0.01857201f, -0.15133467f, 0.01308812f, 0.00318709f, 0.03566954f, -0.09753209f, 
    0.04492486f, 0.01305677f, -0.03139959f, -0.06155493f, 0.02022243f, 0.00317055f, -0.02751083f, 0.09747634f, 
    -0.04502393f, 0.07611834f, -0.05180800f, -0.03146750f, 0.05565110f, 0.00744185f, -0.00463302f, 0.06313144f, 
    0.31002310f, 0.04651791f, 0.02123219f, -0.18420072f, 0.00119588f, -0.02685353f, -0.06537003f, 0.14909671f, 
    -0.02733272f, 0.00189217f, 0.07906576f, 0.03980887f, 0.02131463f, -0.05026694f, 0.02324861f, -0.11062028f, 
    0.06067500f, -0.04767099f, 0.00851070f, 0.02449889f, -0.05632570f, 0.11485524f, -0.01836299f, -0.08131144f, 
    -0.06674082f, -0.04849267f, -0.10613625f, -0.02561696f, 0.14780447f, -0.03890050f, -0.06674705f, -0.13228442f, 
    -0.00282127f, 0.05304012f, 0.14991161f, -0.01216420f, -0.20459567f, 0.12543370f, -0.18905766f, -0.16962066f, 
    0.15938103f, 0.00724734f, 0.04381360f, 0.04278491f, -0.00692843f, 0.02560869f, 0.03781497f, -0.01930784f, 
    -0.12426290f, 0.13468887f, -0.09783614f, 0.00730295f, -0.12764809f, -0.03100976f, 0.03428125f, 0.04968355f, 
    0.01104238f, -0.03631530f, -0.06305367f, -0.11972886f, -0.12991339f, 0.21473560f, -0.04749831f, 0.02595981f, 
    -0.00548931f, -0.10985527f, 0.02383992f, -0.11888171f, -0.06998476f, 0.02458350f, -0.03203583f, -0.05665598f, 
    -0.20937525f, 0.06536551f, -0.14190947f, -0.18567576f, 0.08379095f, 0.02532960f, -0.02291142f, 0.13542908f, 
    -0.02393475f, -0.06431637f, -0.05565307f, -0.06459892f, -0.10472124f, 0.14636266f, 0.13177966f, -0.05835488f, 
    0.03953901f, -0.03924704f, 0.06096166f, -0.04258190f, -0.06965031f, 0.05433895f, 0.04901826f, 0.08059315f, 
    -0.29134881f, -0.00164162f, 0.07644030f, -0.05228183f, 0.08549293f, -0.04102647f, -0.05099680f, 0.04140138f, 
    -0.05589306f, 0.07199537f, 0.05554972f, 0.12413850f, 0.06203243f, -0.00833524f, -0.04217478f, -0.31859800f, 
    -0.01597214f, -0.01618088f, 0.00769186f, -0.01743414f, 0.03067329f, -0.00305889f, 0.02933781f, 0.01067417f, 
    0.48216683f, 0.24092408f, -0.08944349f, -0.10198616f, 0.10282889f, -0.00326022f, -0.08990715f, 0.02348119f, 
    0.04379874f, 0.08624094f, 0.03490835f, 0.05340080f, 0.03263982f, -0.35325179f, 0.17554848f, -0.00541290f, 
    0.10286436f, -0.08813804f, -0.01362985f, -0.03392799f, -0.17026819f, 0.08269098f, 0.10948402f, -0.03846737f, 
    -0.01175506f, -0.30444396f, 0.02264439f, 0.01960622f, -0.09721055f, 0.03826424f, -0.02283694f, 0.06643412f, 
    0.00495112f, 0.10409803f, -0.08747604f, 0.08329619f, -0.11605277f, 0.12554808f, -0.04652243f, 0.07678415f, 
    -0.09019516f, -0.07318560f, -0.09727412f, -0.05223445f, 0.01799799f, 0.03520897f, 0.09575985f, -0.16453196f, 
    0.03079780f, 0.23407336f, 0.01026816f, 0.14436240f, 0.16570048f, -0.02136704f, -0.14082895f, -0.00802710f, 
    -0.00962375f, -0.00522659f, -0.00619978f, 0.10272525f, -0.23124573f, -0.07788040f, -0.01480153f, 0.10272747f, 
    -0.14638644f, 0.02152756f, -0.02452530f, 0.08427625f, 0.07100032f, -0.05218091f, 0.00289679f, 0.04308994f, 
    0.15713382f, -0.26781249f, -0.14637913f, 0.07627153f, -0.01035377f, 0.06228913f, 0.07855462f, -0.07168324f, 
    -0.02304586f, -0.01147224f, -0.07089632f, -0.01701982f, 0.20743413f, -0.12942985f, -0.15565403f, 0.12014945f, 
    0.09328860f, -0.02243135f, -0.04345692f, -0.02857604f, 0.03441143f, 0.04781759f, -0.02655181f, -0.00779681f, 
    0.18276118f, 0.15236451f, -0.14396043f, 0.05294598f, -0.04029280f, -0.05789306f, 0.01689779f, 0.03276005f, 
    -0.03549040f, -0.12718165f, -0.01447629f, -0.07979038f, 0.12835647f, 0.20189460f, -0.04622676f, -0.08892262f, 
    0.09145848f, -0.01488159f, -0.09634598f, -0.06349421f, -0.03114640f, 0.18805474f, -0.02841720f, -0.07331833f, 
    -0.23433748f, 0.00437647f, -0.02730990f, 0.07240478f, -0.10107935f, 0.01785358f, 0.04512782f, -0.01242882f, 
    0.07866889f, 0.02925026f, 0.01592556f, -0.10045741f, 0.55277461f, 0.11563043f, -0.10855868f, 0.02854994f, 
    0.04172472f, -0.09470195f, -0.02688804f, 0.01822626f, -0.01646749f, -0.00583442f, -0.00190875f, -0.03944879f, 
    -0.29212043f, -0.00994882f, -0.03555928f, -0.26229361f, -0.05235364f, 0.02201799f, -0.00526218f, 0.05655318f, 
    0.05148424f, 0.04297174f, -0.02148342f, 0.01663442f, 0.13538571f, -0.12892060f, -0.34168020f, 0.32826039f, 
    -0.03925419f, -0.01633406f, 0.03385150f, -0.06190706f, -0.00508859f, 0.09266384f, -0.00179029f, -0.00815302f, 
    0.07182635f, -0.23237440f, -0.04229799f, 0.10383718f, -0.03117776f, 0.01514432f, 0.15145461f, 0.01506253f, 
    -0.05612932f, -0.00603266f, 0.00764792f, -0.03856566f, -0.23543873f, -0.04271916f, -0.06006541f, -0.16098972f, 
    -0.01190077f, 0.09760971f, -0.05755185f, 0.12229953f, -0.02740397f, 0.05127648f, 0.00289293f, -0.03716613f, 
    -0.08006626f, 0.07679370f, -0.03719534f, 0.04926326f, -0.07099853f, -0.02153706f, 0.10153469f, 0.07626374f, 
    -0.00441851f, -0.00633105f, 0.03171029f, -0.03685396f, -0.07560240f, 0.18063959f, -0.15266569f, 0.12585618f, 
    -0.01895129f, -0.07754599f, -0.10332610f, -0.16605859f, 0.01656624f, -0.01841199f, -0.10613220f, -0.04233883f, 
    -0.24967727f, -0.14573130f, -0.01350627f, 0.05053388f, -0.03085428f, 0.11151555f, -0.04978342f, -0.02942738f, 
    -0.02097520f, 0.01657789f, 0.10073888f, -0.06998193f, -0.28147823f, -0.28525516f, -0.00588026f, -0.19331664f, 
    0.00746234f, 0.03122890f, 0.03523893f, 0.02196580f, -0.09855804f, -0.06289371f, -0.14441831f, -0.21413738f, 
    -0.24441269f, -0.22452472f, 0.02632858f, -0.16309330f, 0.09221119f, 0.02487048f, 0.01221770f, 0.04423251f, 
    0.05381128f, -0.06291367f, -0.04333964f, -0.00060385f, -0.02566845f, -0.07819877f, 0.06936991f, -0.03880742f, 
    0.01058591f, -0.04766170f, 0.00232283f, -0.06650605f, -0.03065376f, 0.02877272f, 0.00514457f, 0.08788845f, 
    0.05900830f, 0.01499621f, -0.11025212f, 0.04280584f, 0.08015776f, -0.10475582f, -0.02058985f, 0.03060438f, 
    0.04859682f, 0.01586464f, 0.00069254f, 0.00482155f, 0.04532222f, -0.08701992f, -0.07181600f, 0.05730600f, 
    -0.04904095f, -0.00131839f, -0.06870202f, 0.00275219f, 0.01837099f, -0.03392310f, -0.04376797f, -0.02459388f, 
    0.07079451f, 0.07873104f, 0.06966218f, -0.09511457f, -0.05571076f, 0.01524987f, 0.03386227f, 0.06902075f, 
    -0.00203778f, 0.02508289f, -0.06606477f, -0.00146491f, -0.32687947f, 0.01488641f, 0.10815754f, 0.32572895f, 
    0.06197719f, 0.09758861f, -0.03275454f, 0.09692249f, 0.09335970f, -0.02213002f, 0.14789571f, 0.09605942f, 
    -0.04476762f, 0.17050214f, -0.10259630f, -0.09652358f, 0.08165131f, -0.04193547f, 0.05202995f, -0.01292713f, 
    0.00557082f, 0.00219111f, -0.13093881f, -0.02324188f, 0.02361038f, 0.10539555f, -0.04598047f, 0.02875859f, 
    0.13133527f, -0.04184140f, -0.09540682f, 0.03107730f, -0.03998333f, 0.03962022f, -0.06565094f, 0.01463708f, 
    0.12015860f, -0.11745039f, -0.06327905f, 0.09827609f, 0.00794857f, -0.05993262f, 0.06103792f, 0.07886445f, 
    -0.03926098f, -0.01818919f, -0.01590277f, 0.01330525f, 0.08897526f, 0.05197262f, 0.07214515f, 0.03782903f, 
    0.02684977f, -0.04877366f, 0.00073006f, 0.07232987f, -0.04423727f, -0.02905614f, 0.01580963f, 0.04306274f, 
    -0.15277058f, 0.09304798f, -0.17805193f, 0.04760785f, 0.10757295f, -0.07551018f, 0.07743789f, 0.06989678f, 
    0.05690019f, -0.03377591f, -0.00922618f, -0.00285255f, 0.13719177f, -0.01245430f, -0.09876443f, -0.07774100f, 
    0.15206872f, 0.00121635f, -0.08829464f, 0.02885783f, 0.02497648f, -0.06322826f, -0.05867716f, 0.00406681f, 
    0.41212153f, -0.06593845f, -0.25696558f, -0.00556838f, -0.04477598f, -0.02980378f, 0.02082232f, -0.01182390f, 
    0.03774720f, -0.06940087f, -0.00063798f, -0.02077353f, 0.03577115f, 0.04080722f, -0.02108631f, 0.10478587f, 
    0.07312877f, -0.06551916f, -0.01944730f, 0.00906321f, -0.07904074f, 0.01653043f, -0.04986518f, -0.10077272f, 
    -0.08048885f, -0.01281319f, -0.00218032f, -0.02787838f, -0.03890604f, -0.01146807f, -0.07875920f, -0.12913390f, 
    0.02422197f, -0.03037828f, 0.12300070f, -0.01669113f, 0.15977885f, 0.03741337f, 0.01171706f, 0.13788332f, 
    -0.07690620f, 0.02054307f, 0.04956780f, -0.05310882f, 0.08572222f, -0.13523632f, -0.02160981f, 0.04122838f, 
    0.01811675f, -0.15374948f, 0.25567725f, -0.15551192f, -0.15717059f, 0.11302849f, -0.09132635f, -0.05811103f, 
    0.00060237f, -0.00305062f, 0.03359591f, 0.02700007f, 0.07971225f, -0.03590402f, 0.01157894f, -0.20654298f, 
    0.14060584f, -0.00738216f, -0.00766668f, 0.06851936f, 0.00353758f, 0.03695353f, 0.11036909f, 0.08558463f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00952919f, 0.00609577f, -0.03348015f, 0.02429540f, 0.03571859f, -0.03500875f, -0.01650726f, -0.05587877f, 
    0.02258500f, 0.03299142f, 0.05423812f, 0.05077546f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
