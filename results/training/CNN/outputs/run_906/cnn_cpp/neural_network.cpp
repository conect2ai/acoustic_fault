#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.78614718f, -0.69573253f, 0.64403963f, 0.57451737f, -0.83660525f, 0.70370996f, -0.44048947f, 0.08199141f, 
    -0.10499015f, 0.85619628f, 0.62609845f, 0.31360054f, 0.15845455f, -0.61925864f, 0.56461513f, -0.16025482f, 
    0.59192449f, -0.42867178f, -0.67406547f, -0.36758280f, 0.72878808f, 0.56043345f, 0.33983415f, -0.01028989f, 
    0.42666492f, 0.28566021f, 0.40689698f, 0.31803182f, 0.61000991f, 0.72471833f, 0.51132315f, 0.13496125f, 
    0.22584446f, -0.54634267f, -0.30916652f, -0.20080015f, 0.16572790f, -0.47840136f, -0.06853873f, 0.67705256f, 
    0.22157983f, 0.67758769f, 0.08628064f, -0.81081593f, -0.85123867f, 0.34805968f, 0.71354580f, 0.20833792f, 
    0.02829921f, 0.73735762f, 0.67300862f, -0.56787521f, 0.50419879f, 0.10159688f, -0.74894488f, -0.76771992f, 
    0.93902755f, -0.09725932f, -0.70453906f, 0.63067198f, 0.03003666f, -0.22075514f, -0.37508634f, 1.09986186f, 
    0.12643276f, 0.25761259f, -0.60530984f, -0.60073650f, -0.63133985f, -0.70281750f, -0.20498398f, -0.38439971f, 
    -0.60674119f, -0.39475664f, -0.09984633f, 0.66320086f, 0.80727649f, 0.45143598f, 0.32533038f, -0.31599665f, 
    -0.29330537f, -0.43059069f, -0.39718366f, -0.30219200f, -0.27701962f, 0.99304688f, -0.55324155f, -0.13122368f, 
    -0.09641709f, -0.04365277f, 0.63882154f, 0.50687927f, 0.86775708f, 0.85151219f, 0.51257122f, -0.03580371f, 
    0.46213716f, 0.68910617f, -0.00592072f, -0.65092111f, -0.68666679f, -0.68723673f, -0.84319127f, 0.29765344f, 
    0.48027906f, 0.54363066f, -0.50872421f, 0.30296820f, -0.77342248f, -0.14596778f, 0.86155719f, -0.56806391f, 
    0.10922539f, 0.55352563f, -0.02748412f, 0.10741913f, 0.49638352f, 0.34593242f, 0.28806478f, 0.54771692f, 
    0.19915825f, -0.68866926f, -0.89141428f, 0.14430057f, 0.55056840f, 0.50573850f, -0.79777580f, 0.90694994f, 
    -0.49864861f, -0.27706707f, -0.52225357f, -0.46482918f, -0.28600660f, -0.37129772f, -0.01435581f, -0.09185234f, 
    -0.09764587f, -0.52955109f, 0.70988584f, 0.77312857f, -0.53170478f, -0.09571915f, -0.41068617f, -0.37866455f, 
    -0.06816688f, -0.38761374f, -0.78666967f, -0.03205295f, -0.84226984f, -0.15858755f, 0.43386731f, -0.00379120f, 
    0.39576975f, -0.51591128f, -1.00737834f, -0.55567038f, 0.55459905f, 0.24952079f, -0.07266836f, -0.06628156f, 
    0.40058604f, 0.09862914f, -0.54693997f, 0.52483463f, 0.35031322f, -0.45808825f, -0.57406926f, -1.00291705f, 
    0.26206058f, -0.06762273f, 0.18282376f, -0.53835553f, -0.56995612f, -0.95635408f, 0.66655105f, 0.50940192f, 
    0.49355143f, 0.43267158f, 0.02288296f, 0.36409092f, -0.47869879f, 0.62661284f, -0.36925989f, 0.77248484f, 
    -0.38984898f, -0.71615154f, -0.34498429f, 0.12252852f, -0.02929754f, 0.20428142f, 0.62407523f, 0.75474012f, 
    -0.32899609f, -0.39292219f, 0.87284136f, -0.25263965f, 0.01041855f, 0.18786675f, 0.90497267f, -0.48963293f, 
    0.65120113f, -0.07427654f, 0.26742068f, -0.33097699f, -0.15271589f, -0.63179719f, 0.02192833f, 0.45882949f, 
    -0.59599131f, 0.16709715f, 0.36922935f, -0.93147522f, 0.71899354f, 0.41944355f, 0.06061293f, 0.38741159f, 
    -0.72056901f, -0.86787546f, -0.77632433f, -0.62174231f, -0.42028874f, 0.65606970f, -0.38545164f, -0.23388742f, 
    0.23606528f, -1.41902030f, 0.28806734f, 0.32416371f, 0.60583687f, 0.65102535f, 0.38381770f, -0.25373814f, 
    -0.00050935f, 0.30214953f, 0.74616998f, 0.36547348f, 0.80877364f, 0.13459566f, -0.32895154f, 0.06925628f, 
    0.32089496f, -0.01363747f, -0.01361281f, 0.79025507f, 0.82665539f, -0.47771913f, 0.92390037f, -0.31170192f, 
    -0.22890230f, -0.22213714f, -0.31080896f, -0.14012766f, -0.75236756f, -0.11510686f, 0.07523552f, -0.73824984f, 
    0.07139824f, -0.38035429f, -0.17951277f, 0.65365916f, -0.35966524f, 0.63806200f, 1.02725601f, -0.19022320f, 
    -0.20475566f, -0.64754140f, -0.43420359f, 0.47921970f, -0.10450063f, 0.01799162f, -0.36131632f, -0.57691681f, 
    -0.62773949f, 0.53791243f, -0.43888056f, 0.24070509f, -0.60794199f, -0.22986305f, -0.09711208f, -0.56857640f, 
    0.75277472f, -0.13760981f, 0.34246039f, 0.48221165f, 0.44945553f, -0.06117375f, -0.58502293f, 0.23956616f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15915437f, 0.04049721f, -0.04216455f, 0.33444366f, -0.10671236f, -0.01691296f, -0.17416917f, -0.05348564f, 
    -0.25177366f, -0.05398303f, -0.06663425f, 0.07428411f, 0.19177419f, -0.14653017f, 0.08468536f, 0.20732680f, 
    -0.02510016f, 0.17342624f, 0.00224349f, 0.26432645f, -0.32382599f, 0.04575294f, 0.28902262f, 0.04053698f, 
    -0.06186850f, -0.12282915f, 0.10702399f, 0.02926571f, 0.24795662f, -0.21749552f, -0.14382879f, 0.14378867f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.21795943f, -0.01798401f, -0.20964956f, -0.02499483f, 0.00186465f, 0.03025430f, -0.05331618f, -0.15148704f, 
    -0.16127612f, 0.10551216f, 0.11328090f, 0.13326013f, -0.06575069f, 0.05512036f, 0.07524353f, -0.08992235f, 
    -0.23217648f, -0.13554963f, 0.19963792f, 0.12957893f, -0.11801603f, 0.08827445f, 0.07442937f, 0.09961627f, 
    0.07342355f, 0.01126433f, -0.03754423f, 0.04671231f, 0.17595766f, -0.27656204f, -0.00254439f, 0.02807163f, 
    -0.01190373f, 0.04794789f, -0.01745888f, -0.07610992f, 0.22605911f, 0.03290792f, -0.02096414f, 0.00455603f, 
    0.11850119f, -0.13347706f, 0.04758635f, 0.12765974f, 0.14388055f, -0.14947751f, 0.16329622f, 0.08491347f, 
    -0.09655780f, 0.01541717f, -0.01662572f, 0.10415799f, 0.01891985f, -0.18800776f, 0.11104735f, 0.05241292f, 
    -0.39158005f, 0.21665269f, 0.16355826f, -0.00481247f, 0.00440543f, 0.05205610f, 0.09773302f, 0.10990570f, 
    -0.13730784f, -0.13611212f, -0.15176286f, -0.09185345f, -0.04250276f, -0.03541496f, 0.19181344f, 0.07632390f, 
    -0.00221558f, 0.11787445f, 0.13903466f, 0.23932171f, 0.05278158f, -0.16789491f, -0.09568983f, -0.13904975f, 
    0.14341661f, -0.12644112f, 0.06825674f, 0.38606170f, -0.03888126f, 0.09839277f, 0.01215533f, -0.07406204f, 
    0.00929115f, 0.10718899f, 0.20632394f, 0.18771882f, -0.07428096f, 0.18374985f, 0.07648725f, 0.22181787f, 
    0.19751525f, -0.04480097f, 0.05698827f, -0.04945794f, -0.18448548f, 0.05743973f, -0.06561276f, 0.06836964f, 
    0.08980823f, 0.19343796f, -0.14893427f, -0.02601093f, 0.13195486f, 0.03745969f, -0.19047213f, -0.08553948f, 
    0.01029759f, -0.00331924f, -0.09484307f, -0.09039266f, 0.01833676f, 0.09195922f, -0.09640963f, -0.17610571f, 
    -0.09518902f, -0.07449068f, -0.01414793f, -0.12135668f, 0.14125413f, 0.00144639f, -0.30946827f, -0.05509756f, 
    -0.00100395f, 0.01964220f, -0.01047509f, -0.16588365f, -0.05723722f, 0.02313158f, 0.11410689f, 0.06679863f, 
    0.15672442f, 0.13940001f, -0.02847381f, -0.20619522f, -0.06707388f, 0.11925735f, 0.07453539f, 0.06445857f, 
    -0.09071425f, 0.04884522f, 0.21849622f, 0.09131161f, 0.03601933f, -0.05776408f, 0.15498595f, 0.15883632f, 
    -0.13666326f, -0.20940229f, -0.14291355f, 0.26010984f, 0.17678934f, 0.09756047f, -0.03006565f, -0.12446019f, 
    0.08509677f, -0.00271709f, 0.04021594f, -0.25424120f, -0.09725372f, 0.04438832f, -0.01603007f, -0.10076717f, 
    -0.05505723f, 0.07695262f, 0.15876085f, -0.04643323f, -0.09885716f, 0.08432028f, 0.01484035f, 0.04806236f, 
    0.06676130f, -0.02472190f, -0.07593917f, 0.14796665f, -0.12922564f, 0.05701140f, 0.01385107f, 0.07110258f, 
    -0.14604521f, -0.08610672f, 0.03293864f, -0.11740372f, 0.02073994f, -0.10730008f, 0.09190073f, -0.33479539f, 
    -0.12741959f, -0.06945091f, -0.08543162f, -0.05591681f, 0.08231997f, 0.19573428f, 0.08193788f, -0.10663742f, 
    -0.06713928f, -0.06649406f, 0.19226117f, 0.02859418f, -0.02122288f, -0.10417154f, -0.08645476f, 0.13758928f, 
    -0.11497250f, -0.12087813f, -0.06093624f, 0.13841222f, -0.03975400f, 0.11436681f, -0.01979405f, -0.15491386f, 
    0.10529645f, 0.00983773f, 0.21164677f, 0.04676372f, 0.06147698f, 0.11197075f, 0.02714342f, -0.05375984f, 
    0.10874511f, 0.17715490f, 0.02659851f, -0.00557000f, 0.07720574f, -0.03558706f, -0.01899655f, -0.03114044f, 
    -0.08986869f, -0.02438911f, -0.15025434f, 0.08458931f, -0.22683114f, -0.06340341f, 0.04991928f, 0.10224253f, 
    -0.16010620f, -0.08071251f, -0.00966854f, 0.30413264f, 0.26677093f, 0.03103441f, -0.12996188f, -0.01296857f, 
    0.12027248f, 0.11310228f, -0.15252334f, 0.01964675f, -0.21734823f, -0.07463266f, 0.21503378f, 0.03876898f, 
    -0.08613656f, 0.01009995f, -0.07874051f, 0.01440350f, -0.11924244f, -0.21590276f, 0.28327978f, -0.11624879f, 
    -0.15510824f, -0.19870751f, -0.00422583f, -0.08635651f, -0.07392004f, 0.21011560f, 0.33455437f, 0.13049565f, 
    0.25576982f, 0.04955798f, 0.04061450f, 0.08879794f, -0.16359645f, -0.00686519f, 0.12047104f, -0.04640863f, 
    -0.13270932f, -0.19747451f, -0.05228569f, 0.07831016f, 0.01666048f, 0.05480422f, -0.04564640f, 0.05337931f, 
    -0.05640977f, -0.00307289f, -0.00895467f, 0.02374978f, -0.02484021f, 0.04332311f, 0.01189965f, -0.01056796f, 
    -0.05061865f, 0.03899211f, -0.00124340f, -0.00957249f, 0.01227181f, -0.00324697f, -0.03722269f, -0.03052932f, 
    -0.03952949f, -0.02611820f, -0.04069578f, 0.04907143f, -0.00983535f, -0.06158436f, -0.04689701f, -0.04003664f, 
    -0.02954330f, -0.00458400f, 0.02449241f, -0.03326526f, 0.03582444f, -0.04095233f, 0.01831520f, -0.00059862f, 
    -0.02013768f, -0.03862756f, 0.04123691f, -0.04081814f, 0.04107672f, -0.01841520f, -0.01131258f, -0.04498219f, 
    0.01549740f, 0.02936813f, -0.02308941f, 0.04221071f, 0.04147920f, 0.02578436f, -0.01439271f, -0.06216866f, 
    -0.04290913f, -0.05307739f, 0.00046918f, -0.04127157f, -0.04567497f, -0.01840491f, 0.03341091f, -0.01105400f, 
    0.02543056f, -0.02092994f, -0.05084495f, -0.04439058f, 0.01684467f, 0.04466614f, 0.04642899f, -0.00057549f, 
    0.01127759f, -0.05748303f, 0.02074653f, -0.01786618f, -0.04921243f, -0.04489804f, -0.00352849f, 0.04374084f, 
    -0.06327699f, -0.04237453f, 0.04629726f, -0.01274620f, 0.03741159f, 0.02436607f, 0.01856971f, -0.03641453f, 
    -0.00625249f, -0.02799033f, -0.05472305f, -0.03115214f, 0.04699511f, 0.03290868f, 0.02875615f, 0.04893506f, 
    -0.01137259f, -0.03726958f, -0.01074818f, -0.05833239f, -0.00902063f, -0.05960789f, 0.01351791f, -0.03606065f, 
    -0.06295010f, -0.01346567f, 0.01253855f, 0.04862931f, 0.02517899f, 0.01356442f, 0.02840331f, 0.04555527f, 
    0.03925372f, -0.05331087f, -0.01538930f, -0.03885161f, -0.00491181f, -0.00746814f, 0.04057536f, -0.02182338f, 
    -0.00509906f, 0.02339604f, 0.03471283f, -0.02344485f, -0.00869474f, 0.01503716f, 0.01664044f, 0.04574590f, 
    0.04439761f, -0.06052905f, -0.02205019f, -0.05382561f, -0.06151929f, -0.01749173f, -0.05070472f, -0.05551097f, 
    -0.02502011f, 0.00705603f, 0.03013244f, -0.03823230f, 0.01597639f, -0.04459259f, -0.04246191f, -0.00360237f, 
    0.02871160f, -0.01358894f, -0.03969200f, 0.02782324f, -0.00711177f, -0.03583411f, 0.02117696f, -0.04562230f, 
    0.03002097f, -0.02924745f, 0.01477880f, -0.04394716f, -0.00731619f, 0.04509761f, 0.02906407f, 0.03577478f, 
    0.01256792f, 0.01236663f, -0.05257588f, -0.05157296f, 0.00086481f, -0.01504430f, -0.01340665f, -0.04316592f, 
    0.02677579f, 0.03984129f, -0.00593851f, 0.00028901f, -0.06210411f, -0.03404643f, -0.01410887f, 0.03050416f, 
    0.02250458f, -0.02983191f, -0.02115235f, -0.00788605f, 0.02599967f, -0.02816728f, 0.01447995f, -0.01490150f, 
    0.00978652f, 0.01259823f, -0.01944918f, -0.02025338f, -0.02959972f, -0.00640574f, 0.03488268f, 0.00922914f, 
    0.00134151f, -0.04403749f, -0.06788526f, -0.04704671f, -0.03118224f, -0.03810218f, 0.03960091f, 0.00884706f, 
    -0.01371117f, -0.05275484f, -0.00794946f, 0.01957143f, -0.02100547f, -0.04823926f, -0.01602601f, -0.05291318f, 
    0.04361032f, -0.01401599f, -0.00602808f, 0.00013245f, -0.04713195f, -0.03260262f, 0.00006127f, -0.02129143f, 
    -0.02461498f, -0.02450909f, 0.00264981f, 0.04909354f, -0.03197185f, -0.06247873f, -0.00859423f, -0.01467267f, 
    -0.01275886f, 0.03419947f, 0.02663417f, -0.06338771f, -0.00765923f, 0.00998291f, 0.00125359f, -0.02470881f, 
    -0.04195900f, 0.00105703f, 0.01196900f, -0.04613781f, -0.03171623f, -0.02601455f, 0.01503208f, -0.03637448f, 
    -0.04062685f, 0.02769805f, 0.01779731f, 0.02145703f, -0.02882970f, 0.02793506f, -0.05865591f, -0.02613276f, 
    -0.03349847f, -0.06126963f, 0.02753488f, 0.03658101f, -0.02947221f, -0.03625717f, 0.01438375f, -0.06720866f, 
    -0.02322007f, 0.01426854f, 0.03320943f, 0.04403630f, -0.06322946f, 0.03219476f, 0.00089233f, -0.05021291f, 
    0.01982045f, 0.04637190f, -0.01855478f, -0.02075225f, 0.00835028f, -0.06543249f, -0.03512665f, 0.05005190f, 
    -0.01415408f, 0.01986896f, 0.03073229f, 0.01578443f, -0.02817577f, 0.02395310f, -0.01666149f, -0.02381907f, 
    -0.05542549f, -0.03854343f, -0.05467562f, -0.02174864f, -0.04435900f, -0.00504907f, -0.02679656f, -0.02461842f, 
    -0.01007025f, 0.04735334f, 0.00731566f, 0.04331843f, -0.04435262f, -0.02840780f, 0.02142944f, -0.04270266f, 
    0.22722977f, -0.09200356f, 0.00406099f, 0.06119433f, -0.07223764f, 0.09590956f, 0.05028955f, -0.01012722f, 
    0.00381123f, -0.26431590f, -0.32801303f, -0.04560306f, 0.20138030f, 0.10137308f, 0.13909286f, -0.11227514f, 
    -0.03409001f, -0.15913151f, 0.12388878f, -0.01701718f, -0.27345315f, -0.03214029f, -0.06240169f, 0.10267927f, 
    -0.10724975f, -0.04806839f, -0.11075991f, -0.18002558f, -0.10961729f, -0.02645972f, -0.02672929f, -0.06655531f, 
    0.11727031f, 0.01418518f, 0.02114154f, 0.03823146f, 0.09393483f, -0.17236018f, -0.18278736f, -0.10918900f, 
    0.10409149f, 0.00416525f, -0.08168170f, 0.04275647f, 0.01776757f, -0.26297140f, 0.14835499f, 0.06116317f, 
    0.11131348f, 0.14682771f, -0.04964330f, 0.01460214f, -0.05677288f, -0.02068593f, 0.40784413f, -0.06030279f, 
    -0.04847050f, -0.01902577f, 0.07132676f, 0.06517111f, 0.08405301f, -0.05824633f, 0.12325705f, -0.33342940f, 
    0.03738207f, 0.08021172f, 0.25340652f, 0.01879353f, -0.13230741f, 0.05740448f, -0.05965688f, -0.20241129f, 
    0.24929079f, -0.14260139f, -0.00070381f, -0.14852831f, -0.07430430f, 0.02211624f, -0.04488892f, 0.08558612f, 
    0.07888031f, -0.07247230f, 0.00003878f, 0.03756384f, -0.01856804f, -0.16017799f, -0.09431634f, -0.11395279f, 
    0.15467986f, 0.11471724f, -0.24465407f, -0.15974045f, -0.26095697f, -0.00129289f, -0.07332402f, 0.11230536f, 
    -0.00569384f, 0.02026650f, -0.11029214f, -0.08917425f, -0.23428166f, 0.08662180f, -0.11123566f, 0.19462800f, 
    -0.13428830f, -0.03805719f, 0.15931596f, 0.00929874f, -0.00589857f, 0.10114050f, -0.11667843f, -0.06411289f, 
    -0.15068530f, 0.05234634f, 0.17813982f, -0.03627792f, -0.12401123f, 0.15239234f, -0.25549573f, 0.06943252f, 
    -0.13146225f, -0.05116814f, -0.04358752f, 0.06380623f, 0.00787287f, 0.05538783f, 0.30396259f, 0.07427564f, 
    -0.05609252f, 0.11325388f, 0.01122450f, 0.02284685f, 0.02576623f, 0.00685210f, -0.04733951f, 0.25349644f, 
    0.00349431f, -0.07649521f, 0.03126475f, -0.06624779f, 0.14639357f, -0.03048554f, 0.19723746f, 0.30413771f, 
    0.11805575f, -0.01275972f, 0.11121175f, -0.20021828f, 0.07184622f, -0.13735227f, 0.13309231f, -0.00554370f, 
    0.20426120f, 0.02953338f, -0.13871771f, 0.03249006f, -0.04753568f, -0.02857350f, -0.01777262f, -0.20332910f, 
    0.14524809f, 0.11484661f, 0.42094448f, 0.17125618f, 0.01171911f, 0.04268931f, -0.14672013f, 0.08373336f, 
    -0.03935206f, 0.15427439f, 0.02197506f, 0.14746547f, -0.12415010f, 0.09882163f, -0.11233718f, 0.15119323f, 
    0.07937140f, -0.12888829f, 0.10956535f, 0.16222998f, 0.32220203f, -0.09519429f, -0.18779011f, -0.11111061f, 
    -0.16354370f, 0.05874112f, -0.07503672f, 0.16648470f, -0.11042716f, -0.15402366f, -0.18808964f, 0.05294086f, 
    0.12466190f, 0.00017113f, 0.11924548f, -0.02146881f, -0.06116245f, -0.19773617f, -0.03461273f, 0.25120160f, 
    0.02433701f, 0.02574508f, -0.02628670f, 0.08037035f, 0.06329370f, 0.08895776f, 0.04496493f, 0.29157856f, 
    -0.17840606f, -0.10662736f, -0.10518754f, -0.01841624f, 0.08368053f, 0.08320049f, 0.03178103f, 0.13795370f, 
    -0.11795003f, -0.30335096f, 0.23284364f, -0.05526199f, 0.00486292f, -0.03223831f, 0.05364623f, -0.01597990f, 
    0.03262313f, -0.07013935f, 0.03504474f, -0.18064892f, 0.01840802f, -0.14085552f, 0.10594229f, 0.15369098f, 
    0.07908190f, -0.12219246f, -0.29884517f, -0.17359385f, 0.03558666f, 0.08809348f, -0.06990691f, 0.15022232f, 
    -0.13120794f, -0.07541616f, -0.10388425f, -0.16114195f, 0.21916258f, 0.13793711f, 0.04053156f, 0.04101276f, 
    -0.01610122f, -0.12355786f, -0.12919490f, -0.19520199f, 0.02319330f, 0.18535429f, -0.00850595f, 0.06306073f, 
    0.19595368f, -0.19902289f, -0.17161088f, -0.04290019f, 0.25279850f, -0.06407250f, -0.16703071f, -0.22299312f, 
    0.21760316f, 0.14465591f, -0.06056790f, -0.07991590f, 0.12733693f, -0.11048223f, -0.12798482f, -0.13639030f, 
    0.16773038f, -0.10924796f, 0.09115637f, 0.15125181f, 0.13929740f, 0.09800854f, 0.02878048f, 0.02934080f, 
    -0.16566849f, 0.11482887f, 0.05912239f, 0.01579611f, 0.10760149f, 0.03590693f, 0.04710608f, -0.04843875f, 
    -0.02350756f, -0.05773863f, 0.01048632f, 0.11727764f, 0.00517255f, 0.01693886f, 0.05478625f, 0.14679372f, 
    -0.01472405f, -0.06278216f, -0.12813881f, -0.01835859f, 0.35219595f, 0.19742313f, -0.01954833f, 0.13695487f, 
    0.00404869f, -0.06904629f, 0.06412054f, 0.06053713f, 0.22499585f, -0.16952120f, -0.13079429f, 0.07358143f, 
    -0.10688534f, 0.00340092f, 0.14078146f, -0.08824371f, 0.22131687f, 0.11466966f, 0.18912724f, -0.01420635f, 
    -0.21062854f, 0.03969298f, 0.13780199f, -0.07713787f, 0.13075326f, 0.02094234f, -0.05346560f, -0.15255798f, 
    -0.04736971f, -0.10899546f, 0.03656631f, 0.08432659f, -0.04966024f, 0.13424847f, -0.03071484f, -0.25510702f, 
    0.15141119f, -0.13970681f, -0.19149290f, 0.00417358f, 0.09056394f, -0.00386108f, 0.22678751f, 0.10723008f, 
    0.18615964f, -0.15375760f, 0.01131348f, -0.15277134f, 0.08138508f, -0.05278412f, 0.24152593f, -0.09782366f, 
    -0.33324057f, -0.20937578f, 0.14195837f, 0.18389823f, 0.23112078f, 0.07867350f, 0.06945898f, -0.14583951f, 
    -0.03426638f, -0.31418344f, 0.14317442f, -0.17167065f, -0.12371899f, -0.10737016f, -0.00103173f, -0.19811732f, 
    -0.16460504f, -0.24646220f, -0.25029245f, -0.22641435f, -0.10090756f, 0.07600666f, 0.12982444f, 0.17000239f, 
    0.00649533f, -0.04225845f, 0.38077980f, 0.29252914f, -0.17562756f, 0.02768009f, -0.19815357f, -0.04961930f, 
    0.02877000f, 0.01280772f, 0.16851604f, -0.07551060f, -0.07257310f, 0.37828952f, 0.01578864f, -0.09714749f, 
    0.12234645f, 0.09800757f, -0.01966222f, 0.03483501f, 0.04611552f, 0.27364096f, 0.30329978f, 0.00356004f, 
    0.00393802f, 0.05419125f, 0.00446907f, -0.11554441f, 0.07515295f, 0.30571035f, -0.31379172f, -0.40270251f, 
    0.28670990f, 0.14042179f, -0.05337881f, 0.12951994f, 0.02381051f, 0.12988970f, -0.28476039f, -0.01684234f, 
    -0.21854371f, 0.20827645f, -0.04544673f, 0.07512427f, 0.03346310f, 0.18885253f, 0.04743700f, 0.19277488f, 
    -0.14904302f, -0.11599400f, -0.10287583f, -0.09491858f, 0.08765139f, 0.13280149f, -0.08400878f, 0.04833148f, 
    -0.17828873f, 0.30311847f, 0.24022903f, 0.02736937f, 0.09207613f, 0.15993758f, -0.02207393f, 0.06288636f, 
    0.00814293f, -0.25656497f, -0.00463696f, 0.28427887f, -0.01863665f, -0.06279609f, 0.09175889f, -0.21329013f, 
    -0.06603078f, 0.13058275f, -0.37872556f, -0.27426717f, -0.11265904f, 0.27299520f, 0.29129785f, -0.07243951f, 
    0.06830358f, 0.03954070f, -0.03265788f, -0.08154612f, -0.02748780f, 0.19064975f, -0.17733574f, -0.14994149f, 
    -0.02704689f, -0.17312843f, 0.00367107f, -0.01183829f, -0.21308631f, -0.19726090f, -0.40053004f, -0.03815848f, 
    -0.19265243f, -0.05701670f, 0.14626719f, -0.16895904f, 0.04564123f, 0.00301359f, 0.07801831f, 0.15113279f, 
    0.14027558f, -0.01361224f, -0.07230680f, 0.23643354f, 0.16018151f, 0.05858132f, -0.20308238f, -0.05023174f, 
    0.02138045f, 0.09536512f, -0.08834790f, 0.05554791f, 0.00912045f, 0.08221915f, 0.00556085f, 0.14082569f, 
    0.24518380f, 0.02928097f, -0.05076019f, 0.07358289f, 0.02191061f, 0.19926664f, -0.01518186f, 0.22650626f, 
    -0.31440896f, -0.10540526f, 0.32099786f, -0.08119886f, -0.00729767f, -0.00357901f, 0.17101036f, 0.04030040f, 
    0.12248918f, 0.13745365f, 0.05415004f, 0.13497218f, -0.22108515f, -0.14475703f, 0.05879071f, -0.02935079f, 
    -0.04082694f, 0.12914959f, -0.00616055f, 0.07299606f, -0.00203244f, 0.14558195f, 0.04459804f, -0.09030670f, 
    0.04409073f, 0.02668196f, 0.04251622f, 0.01616851f, 0.08796284f, 0.05829901f, 0.10398797f, -0.02364694f, 
    0.02202236f, 0.04991445f, 0.01451710f, 0.13096692f, -0.65441346f, -0.11427020f, -0.17241485f, -0.00582009f, 
    0.14710677f, 0.13059644f, 0.14949782f, -0.02275258f, -0.11568740f, 0.26532745f, 0.05491006f, -0.11943287f, 
    0.09747657f, 0.14141412f, -0.03794309f, -0.15368681f, -0.04483224f, 0.06919640f, 0.18252994f, -0.12741520f, 
    0.11184616f, -0.00458512f, 0.01806216f, 0.00470456f, 0.07440250f, -0.07260311f, 0.15772490f, 0.13136123f, 
    -0.00520576f, 0.08580246f, -0.03111866f, -0.31072712f, 0.06031946f, 0.10401788f, 0.17924932f, 0.10175309f, 
    -0.18191357f, 0.33474442f, -0.12717129f, 0.13792810f, -0.00276857f, 0.03370854f, 0.05123469f, -0.12976712f, 
    -0.01476039f, -0.18202966f, 0.16496475f, -0.17552353f, -0.01874902f, 0.00663725f, 0.10574687f, 0.08751289f, 
    -0.13252148f, -0.08259980f, -0.30610025f, 0.02948402f, -0.07119378f, 0.10465711f, -0.03889278f, -0.09493468f, 
    -0.00216910f, -0.10804636f, -0.09959650f, 0.16951993f, 0.08192462f, 0.13629700f, -0.01665070f, 0.00007058f, 
    -0.05986692f, -0.02817681f, 0.08060752f, -0.01713570f, -0.12186184f, 0.23210110f, -0.00214649f, 0.08359941f, 
    -0.09306858f, 0.02788278f, -0.04664565f, -0.01659529f, -0.17336947f, -0.02903557f, 0.37253731f, -0.00541952f, 
    0.05537218f, -0.12436907f, 0.00283597f, -0.03269200f, -0.01046367f, 0.17020462f, -0.20918529f, -0.07258464f, 
    -0.08092404f, -0.18129368f, -0.02870780f, -0.21561544f, -0.08116227f, 0.08019168f, -0.16646838f, 0.22064769f, 
    0.17332004f, -0.09102550f, 0.19735454f, -0.08762562f, 0.11658377f, 0.01923916f, -0.06172835f, 0.15240376f, 
    0.20251524f, 0.05488551f, -0.26662260f, 0.02326948f, 0.07649535f, 0.04032368f, -0.02681278f, 0.05142335f, 
    0.04309413f, 0.15856978f, -0.41487134f, -0.32063803f, -0.04351470f, 0.25084478f, 0.23550941f, 0.01685881f, 
    0.10794821f, -0.17694497f, -0.06032348f, 0.03110571f, 0.21679737f, -0.20268184f, -0.01085495f, -0.21357985f, 
    0.00532925f, 0.00140125f, -0.08487628f, 0.55537641f, 0.09716622f, 0.02125586f, 0.14439698f, 0.17271626f, 
    -0.03768073f, 0.01174958f, -0.02253215f, -0.09335101f, -0.18690310f, -0.09238958f, -0.02516399f, 0.00905631f, 
    -0.04312445f, 0.01572409f, -0.00595292f, -0.09634940f, -0.01906609f, 0.07760305f, 0.16941124f, 0.00350803f, 
    0.03245553f, 0.08181769f, -0.02371464f, 0.09576240f, -0.16117229f, 0.10394233f, -0.08596262f, -0.21618582f, 
    -0.34106454f, 0.22790915f, 0.09133230f, 0.18247263f, -0.09002809f, -0.04524787f, 0.07068889f, 0.14575569f, 
    -0.57749969f, 0.06020818f, 0.04660814f, 0.11731793f, 0.04992377f, 0.04931889f, 0.06216271f, -0.10891368f, 
    -0.07011896f, -0.14593425f, 0.22399588f, -0.09229846f, 0.23697051f, -0.11544363f, -0.01684216f, -0.03335326f, 
    -0.09664693f, 0.31799370f, -0.19789422f, -0.05167001f, -0.00582694f, 0.00077477f, 0.01129920f, 0.02308098f, 
    0.02220094f, 0.16378209f, 0.01511020f, -0.25060993f, -0.18174125f, 0.16145250f, -0.01458831f, 0.02986397f, 
    -0.10049699f, 0.07373720f, 0.21113735f, 0.34456313f, 0.11906201f, -0.09874143f, 0.09121660f, -0.01423445f, 
    -0.17653507f, 0.04912713f, 0.08659496f, 0.02160564f, -0.20620586f, -0.22986040f, -0.23216729f, -0.02388755f, 
    0.03638586f, 0.25697136f, 0.00998021f, -0.12319307f, -0.04098891f, 0.05190526f, 0.03596406f, -0.33168206f, 
    -0.05761564f, -0.02946118f, -0.05427313f, 0.03856109f, 0.02944068f, 0.08354706f, -0.11634745f, -0.07593489f, 
    0.07480340f, 0.11750715f, 0.03996212f, -0.04981698f, 0.16434142f, 0.31419683f, -0.26775539f, -0.40799379f, 
    0.17858517f, 0.14580379f, -0.02502678f, 0.02523369f, 0.08014946f, -0.11236509f, 0.03561331f, -0.08391297f, 
    0.09644084f, -0.11281857f, 0.20980661f, -0.00744786f, 0.05117116f, -0.03540114f, -0.06035059f, -0.05936871f, 
    0.28380382f, -0.20048100f, 0.04629856f, -0.13363002f, -0.01109741f, 0.09929527f, 0.01677089f, 0.06256645f, 
    -0.04583565f, 0.01677877f, -0.09035786f, 0.08710266f, 0.20116068f, -0.20870516f, 0.03291279f, 0.05739368f, 
    -0.09622815f, -0.01045444f, 0.10196818f, -0.34551981f, -0.34604371f, 0.08542359f, -0.09724547f, -0.06539430f, 
    0.05625004f, -0.15587181f, -0.05460658f, -0.03300570f, 0.00860685f, -0.19807678f, -0.12015980f, -0.04954718f, 
    -0.00437706f, 0.15758994f, -0.02551075f, 0.07564607f, 0.09424323f, 0.07688438f, -0.16377366f, 0.06532381f, 
    -0.05423640f, -0.02033276f, 0.09379482f, -0.04028144f, 0.03690959f, 0.05438223f, 0.08916856f, 0.04247607f, 
    -0.32837927f, -0.07655519f, 0.19966325f, -0.04757465f, 0.10762320f, 0.10806358f, 0.23955423f, 0.04468653f, 
    0.25416803f, -0.09410486f, -0.00042803f, 0.16163839f, 0.03066550f, -0.02347324f, 0.00303636f, 0.05657754f, 
    0.02508669f, -0.05089319f, -0.00565443f, -0.01713935f, 0.01687140f, -0.05236970f, -0.02151322f, 0.04838256f, 
    0.02632264f, 0.03627768f, 0.00326236f, -0.06842533f, 0.03027722f, -0.00929892f, 0.02955700f, -0.03390065f, 
    -0.02583979f, 0.01355102f, -0.04020836f, -0.04339798f, -0.05514945f, -0.04426368f, -0.03774231f, -0.06293309f, 
    0.02878427f, -0.00757493f, -0.06480784f, 0.01697763f, 0.02755699f, -0.00796142f, 0.02742474f, -0.06324974f, 
    0.00336084f, -0.00705457f, 0.04104626f, -0.05970700f, -0.02014554f, 0.01913422f, -0.04681813f, 0.04920603f, 
    -0.02736142f, -0.04506623f, -0.05050952f, 0.03969400f, -0.02004065f, 0.04753681f, 0.04801529f, -0.04970634f, 
    0.01583032f, -0.06249125f, 0.05031636f, -0.00221588f, 0.02442460f, 0.02147180f, -0.03385155f, -0.00891124f, 
    -0.06352321f, -0.06254826f, -0.05540610f, 0.01715118f, -0.05873058f, 0.02989679f, 0.03843616f, -0.02448534f, 
    -0.00282335f, -0.06311361f, -0.04570545f, -0.04651492f, -0.03049528f, 0.03608579f, -0.04427109f, -0.02178345f, 
    0.03781121f, -0.02854604f, -0.01097021f, 0.00566094f, -0.00555508f, -0.01145894f, -0.05830212f, 0.00856207f, 
    -0.01362149f, 0.04081533f, 0.00864523f, -0.05844275f, -0.00932237f, -0.02327349f, -0.06877830f, 0.04650004f, 
    -0.05972430f, 0.01240206f, 0.02055197f, 0.03032037f, 0.00097291f, -0.00584502f, -0.04235125f, -0.01965579f, 
    -0.05446275f, -0.05227944f, -0.03380948f, 0.01988321f, 0.00912709f, -0.01439336f, -0.01584939f, 0.01626174f, 
    0.01032648f, -0.01438381f, -0.02497012f, 0.01672179f, 0.00483409f, 0.03333641f, 0.03952393f, -0.03924115f, 
    -0.01657045f, -0.06035122f, -0.01023365f, -0.04820038f, 0.04665992f, -0.02461967f, -0.04988880f, 0.00717742f, 
    -0.05945800f, -0.04634004f, -0.06093915f, 0.04272046f, -0.00325944f, -0.00469611f, 0.04741332f, -0.03066978f, 
    0.04203869f, -0.02916923f, -0.01241937f, -0.03802766f, 0.01477830f, 0.01467190f, -0.01779026f, 0.05630002f, 
    -0.04990650f, 0.01620903f, -0.03014589f, -0.03648595f, -0.01854467f, -0.05145423f, -0.03475311f, -0.06033245f, 
    -0.03946786f, -0.05276549f, 0.02389748f, -0.01155372f, 0.04684424f, -0.05165886f, 0.04161549f, -0.03717746f, 
    0.01469546f, -0.03232121f, -0.01760952f, 0.02559910f, 0.01571265f, 0.00174172f, 0.03959941f, -0.04426423f, 
    0.03600799f, -0.00790353f, 0.00033373f, -0.02748702f, -0.00648837f, -0.03108500f, -0.04230573f, 0.02517926f, 
    0.00569217f, 0.03664631f, -0.02436527f, 0.05088247f, -0.02356318f, -0.02290586f, 0.00701993f, -0.00659141f, 
    -0.06948608f, -0.03687546f, -0.02528426f, 0.03773481f, 0.00878308f, 0.01890939f, -0.00155727f, 0.03478589f, 
    -0.03030935f, -0.05365328f, -0.04694651f, 0.03675999f, -0.02013836f, 0.03986410f, -0.04045070f, -0.02815066f, 
    0.00676857f, -0.02326764f, -0.02149832f, 0.03274938f, -0.03383683f, -0.00814540f, 0.01832482f, -0.02421618f, 
    -0.04497470f, 0.00524635f, -0.01973508f, -0.03785378f, -0.02625047f, 0.00824848f, -0.04569007f, 0.00656226f, 
    -0.04522754f, -0.05566566f, 0.01059435f, -0.02025709f, -0.02220170f, -0.04301314f, 0.02245338f, 0.02491426f, 
    -0.01086221f, -0.04001776f, 0.02682194f, -0.03852721f, 0.05329224f, -0.02345642f, 0.01090416f, 0.04031121f, 
    0.02332618f, -0.02789650f, -0.02538800f, 0.04978436f, -0.05931736f, 0.01296337f, 0.04489257f, -0.04964223f, 
    0.00583313f, 0.02492734f, -0.02559252f, -0.02577513f, 0.00810935f, -0.04614495f, 0.01366701f, -0.02445637f, 
    -0.06798261f, 0.03709135f, 0.04631273f, 0.03546205f, -0.01111719f, 0.04396585f, 0.03732366f, 0.01873938f, 
    -0.05730238f, 0.02253737f, -0.02465655f, 0.01456402f, -0.06597916f, -0.05506645f, -0.06412636f, -0.02976867f, 
    0.03958480f, 0.02859093f, -0.03588508f, -0.00473150f, 0.02198688f, -0.00806709f, -0.05491942f, 0.01592749f, 
    -0.02220533f, 0.02252708f, -0.05520034f, 0.02193206f, 0.03777186f, -0.05806170f, 0.03568891f, 0.05791501f, 
    -0.01411054f, 0.06054658f, 0.03126523f, -0.04419926f, -0.00432995f, 0.03808840f, 0.01205995f, -0.04797829f, 
    0.02739481f, -0.04836585f, -0.05897373f, -0.00984847f, 0.04026702f, 0.00509697f, 0.00458958f, 0.02152588f, 
    0.02215099f, 0.03284232f, -0.12732877f, 0.09623754f, -0.09195694f, 0.03634785f, -0.04917343f, -0.09446698f, 
    -0.00597292f, -0.11943816f, 0.16363385f, 0.18418051f, 0.01405256f, 0.12235157f, 0.19032447f, -0.04657021f, 
    0.02296231f, -0.11807285f, -0.24384601f, -0.46119356f, -0.02023034f, -0.06975953f, -0.12675433f, -0.06995519f, 
    0.16005795f, 0.00461521f, -0.07850234f, 0.10680132f, 0.11420566f, 0.12669416f, 0.07196990f, -0.07465965f, 
    0.06716939f, 0.16377881f, 0.06324051f, 0.01794959f, 0.03675428f, -0.00909704f, -0.03539863f, 0.00000360f, 
    -0.06357273f, 0.07619793f, 0.15684585f, 0.05340435f, -0.13315365f, -0.11989095f, 0.09679355f, 0.02312952f, 
    0.08232676f, 0.11106010f, -0.08513698f, 0.04666812f, -0.01002365f, 0.07478961f, 0.10597096f, -0.62631428f, 
    -0.23577803f, -0.04783502f, -0.03839838f, -0.29623500f, -0.08610637f, 0.08307362f, -0.00431781f, -0.11235962f, 
    0.14227341f, 0.16509771f, 0.00638092f, -0.14470154f, 0.13073729f, 0.03710779f, 0.15520301f, 0.12579715f, 
    -0.36309224f, -0.01379992f, -0.11606025f, -0.03863748f, 0.05624105f, 0.09374437f, 0.02904588f, -0.02962280f, 
    -0.17343652f, -0.49074590f, -0.18084170f, -0.13897376f, 0.11413120f, -0.02022243f, 0.24350402f, 0.01551913f, 
    0.01801193f, -0.19109681f, -0.09057344f, 0.03595315f, 0.22557746f, -0.09835515f, 0.08376985f, -0.08908352f, 
    -0.05330469f, -0.12497949f, -0.11686057f, -0.62236392f, -0.12246306f, -0.17938007f, 0.25053623f, 0.11405934f, 
    0.01940699f, 0.20235024f, -0.01882667f, -0.08077013f, -0.08871901f, -0.26593775f, -0.22279765f, 0.03796202f, 
    -0.05179279f, -0.03200492f, 0.15289912f, -0.00878115f, 0.01787162f, 0.27482095f, -0.00702066f, -0.35916176f, 
    -0.17872384f, 0.12811284f, -0.04890605f, -0.04129108f, 0.10240187f, 0.10331164f, -0.21180591f, -0.23884833f, 
    0.24885231f, -0.01438055f, -0.01561021f, -0.03482425f, -0.01869887f, 0.14340635f, 0.16582727f, 0.11219557f, 
    0.11067709f, -0.02568983f, 0.01663485f, -0.09719988f, 0.17357895f, 0.11515011f, 0.02091873f, 0.03962678f, 
    -0.20866933f, -0.06168205f, -0.14004761f, 0.12988622f, 0.05044779f, -0.07859335f, 0.05602646f, -0.12730674f, 
    0.02877784f, -0.35198122f, -0.23718786f, -0.02068146f, 0.10393291f, 0.01614028f, -0.05370278f, -0.03965574f, 
    0.17769484f, -0.05325813f, 0.29993454f, -0.08644483f, -0.03785753f, 0.08110378f, 0.02304164f, -0.01274325f, 
    0.22771059f, 0.31224060f, 0.08416250f, -0.42327312f, -0.01211589f, 0.17829105f, 0.07931685f, 0.02483024f, 
    -0.09719989f, -0.08624066f, -0.00413663f, -0.10614665f, -0.28695643f, -0.38601896f, 0.17359422f, 0.13325426f, 
    0.12483976f, -0.07030129f, 0.10815656f, 0.05872960f, -0.11066367f, -0.20407344f, 0.17858985f, 0.21321993f, 
    0.16320682f, 0.03017581f, 0.08070799f, 0.09707116f, -0.01441092f, 0.22032814f, 0.22506763f, 0.00609760f, 
    -0.06467258f, 0.05324859f, 0.14584452f, 0.07055982f, -0.15152732f, 0.00271698f, 0.19222145f, -0.21442176f, 
    -0.22626165f, 0.06001529f, 0.00004513f, 0.00039767f, 0.01782827f, -0.00946007f, -0.07190445f, 0.00121672f, 
    -0.34368721f, -0.14953411f, 0.00946032f, 0.28190178f, 0.21568896f, -0.06851209f, 0.09103501f, -0.07996568f, 
    0.09734148f, -0.27400431f, -0.07633967f, -0.15953776f, -0.02460985f, 0.07411207f, 0.08749824f, -0.09483155f, 
    0.04077928f, 0.03949359f, 0.05523522f, 0.13044800f, 0.24632570f, 0.06471310f, 0.25037315f, -0.00494414f, 
    0.02750112f, -0.15846635f, 0.01415653f, -0.05304779f, 0.12715025f, 0.13338895f, 0.07853142f, -0.12583835f, 
    0.04292045f, 0.10225891f, -0.14756924f, -0.10575574f, -0.01588154f, -0.25297323f, -0.09021750f, 0.17972705f, 
    0.18013370f, 0.11279127f, 0.12192120f, 0.16670413f, 0.09281486f, -0.02439727f, -0.05594939f, 0.01348030f, 
    0.11589705f, -0.07780069f, 0.02442226f, -0.08190043f, -0.07861667f, -0.08457705f, -0.09983501f, 0.01730431f, 
    0.17230970f, 0.31289145f, -0.00615665f, -0.05223753f, -0.21616848f, 0.18695675f, 0.12642741f, 0.04353214f, 
    0.07469410f, 0.04161904f, -0.18238267f, -0.06952437f, 0.16606902f, 0.02095308f, -0.00510394f, 0.05611515f, 
    -0.03601359f, 0.01413692f, 0.02392193f, -0.01209273f, 0.01130993f, -0.05355277f, -0.04583297f, -0.01901942f, 
    -0.04895909f, -0.06452699f, -0.04601839f, -0.04706508f, -0.05739762f, -0.00688250f, 0.02207632f, 0.01883619f, 
    0.02746144f, 0.04086734f, -0.00086348f, 0.03636257f, -0.03273090f, -0.01908344f, 0.00297662f, -0.05865052f, 
    0.02175118f, -0.04282120f, -0.00217974f, -0.00018187f, -0.05033950f, -0.05577631f, -0.01624801f, -0.06288454f, 
    0.01213642f, 0.00592434f, 0.03765818f, 0.00765918f, -0.05355576f, -0.04335345f, -0.05039116f, 0.01356377f, 
    -0.01779234f, -0.03321445f, -0.04983833f, 0.00811653f, 0.02050734f, 0.02571610f, 0.02970905f, -0.05024280f, 
    -0.03077084f, -0.00034988f, -0.03211584f, -0.00534876f, -0.06230070f, 0.04852862f, 0.04642676f, -0.04104807f, 
    -0.03665682f, -0.00898735f, -0.00392731f, 0.01273844f, 0.02581989f, 0.04522537f, -0.00756789f, 0.00236392f, 
    -0.02445238f, -0.05423784f, -0.00364276f, -0.00993788f, 0.03269347f, -0.03556461f, -0.01314715f, -0.04653109f, 
    -0.04880834f, 0.05017417f, -0.03985765f, 0.03364661f, -0.02698676f, -0.04616391f, -0.04546033f, 0.01634968f, 
    -0.01707708f, -0.03563160f, -0.05845228f, -0.05768454f, 0.04871388f, -0.06437800f, -0.04189420f, -0.03132946f, 
    0.04862073f, 0.04441448f, -0.05798742f, 0.03133285f, 0.01988763f, 0.00633789f, -0.05932837f, 0.02330691f, 
    0.05295227f, 0.01921364f, -0.01257308f, 0.04601009f, -0.04300343f, -0.05327210f, 0.04623062f, 0.03115245f, 
    0.04826607f, -0.01921646f, -0.06147562f, 0.01914706f, 0.00554206f, 0.00484708f, -0.01671923f, -0.02439964f, 
    0.00930621f, -0.00846365f, -0.01477829f, 0.05207036f, -0.01103045f, -0.02485412f, -0.04559035f, 0.01042838f, 
    0.03490745f, 0.00332179f, -0.03714684f, 0.03084099f, 0.02992995f, -0.01225320f, 0.02991756f, 0.02507131f, 
    -0.03132504f, -0.05760848f, 0.03621939f, 0.03705771f, -0.01072602f, -0.03290318f, -0.01550103f, 0.02550440f, 
    -0.05786253f, 0.00130071f, -0.06177105f, -0.06102348f, 0.04721882f, -0.02794369f, 0.00243183f, -0.06450944f, 
    -0.04879516f, 0.05553719f, -0.00888681f, -0.06372253f, -0.03597609f, -0.02529772f, -0.01851486f, -0.05541114f, 
    0.03050965f, -0.04055304f, -0.05212237f, -0.01010933f, -0.04652558f, 0.03995125f, -0.06188850f, -0.05905787f, 
    0.02679536f, -0.03455913f, -0.04925470f, 0.02084242f, 0.01278307f, -0.03106216f, -0.03301536f, 0.04179414f, 
    -0.00264548f, -0.02652531f, -0.02113719f, -0.02851938f, -0.04491150f, -0.05875784f, 0.01117116f, -0.01053907f, 
    0.01283616f, -0.05947125f, -0.03359968f, 0.04905360f, -0.01756696f, 0.04325565f, 0.00053672f, -0.02119164f, 
    0.02840471f, 0.03733037f, -0.00489586f, 0.00916857f, 0.04076198f, -0.03989872f, 0.01837157f, -0.05074769f, 
    0.05155225f, 0.04275551f, -0.02951775f, 0.04017267f, -0.04332101f, 0.04876679f, -0.06404595f, 0.02745625f, 
    -0.01098225f, -0.04146542f, -0.00709486f, -0.02247170f, -0.03398217f, 0.01390210f, -0.02795156f, -0.00447206f, 
    0.00755842f, 0.00845891f, -0.00870143f, 0.02595596f, -0.03499006f, 0.01124518f, -0.05923062f, -0.05862178f, 
    0.03207728f, 0.00394610f, 0.04716868f, -0.06133152f, -0.01163265f, 0.03551510f, 0.02060506f, -0.05688070f, 
    -0.04951266f, 0.04774853f, -0.03205981f, 0.05130177f, 0.04472934f, -0.02766229f, 0.03648411f, 0.02251285f, 
    -0.00218802f, -0.01361056f, 0.02060321f, 0.04852287f, -0.06018290f, 0.03844412f, 0.04701162f, 0.01230284f, 
    -0.04963952f, -0.01442776f, 0.01811122f, 0.02926346f, -0.00528130f, -0.03650953f, -0.04613918f, -0.04686293f, 
    0.00980800f, -0.04108487f, 0.04722461f, -0.01473537f, 0.03202254f, -0.01895076f, -0.05746477f, -0.03067161f, 
    -0.03002723f, 0.02962750f, -0.02902424f, 0.01372216f, -0.04799528f, 0.00809527f, 0.02260593f, 0.02136739f, 
    -0.04785392f, -0.00031604f, -0.00748362f, -0.06075466f, 0.04773508f, -0.02378607f, 0.00537159f, 0.04126398f, 
    -0.01712982f, 0.00723596f, -0.02456179f, 0.02200820f, 0.02689953f, 0.02966870f, 0.04644371f, 0.01238972f, 
    -0.05754987f, -0.03663884f, -0.05638867f, -0.01539475f, -0.01430256f, -0.00774779f, 0.04846238f, -0.02190360f, 
    -0.27631187f, -0.01810208f, -0.21249777f, -0.11987703f, 0.04562949f, 0.06164550f, 0.12113898f, 0.04362149f, 
    0.00235848f, 0.09481074f, 0.06683072f, 0.19535448f, -0.05856237f, 0.24597183f, -0.01073814f, 0.13630874f, 
    -0.05863623f, -0.02703929f, 0.04900406f, -0.19239473f, -0.01410602f, -0.05092112f, 0.21386521f, 0.19780208f, 
    0.10627773f, -0.03323725f, -0.23628578f, 0.30555931f, 0.24118961f, 0.16403203f, 0.07863297f, 0.02209167f, 
    0.31608683f, 0.02825176f, 0.10722391f, -0.09690044f, -0.25804281f, -0.13075899f, -0.11549091f, 0.00881504f, 
    0.19470516f, 0.32351109f, -0.09300426f, -0.21539672f, -0.08505492f, -0.17675544f, 0.23379098f, 0.07127260f, 
    -0.01641968f, 0.24599898f, 0.20115693f, -0.11456706f, -0.09668627f, -0.09126872f, -0.03426177f, -0.02288839f, 
    -0.25967538f, -0.12529919f, -0.01985313f, -0.00781426f, -0.03156786f, -0.10671201f, 0.10101379f, 0.37136757f, 
    0.34556839f, 0.04568413f, 0.08219501f, -0.22037004f, -0.13752663f, 0.35855612f, 0.08163840f, 0.12220244f, 
    -0.18530241f, -0.27365404f, 0.12389764f, 0.12481831f, 0.19729073f, 0.21735491f, 0.07163947f, -0.14205390f, 
    0.04179116f, -0.13854153f, -0.02213833f, -0.03343070f, 0.00704950f, -0.07190704f, 0.07422084f, -0.20566830f, 
    0.09306107f, 0.13205859f, -0.22722945f, -0.40809414f, -0.28575504f, -0.03028509f, 0.11360119f, 0.20670412f, 
    -0.17489383f, 0.07849348f, -0.05672064f, -0.04673367f, 0.11434128f, 0.07725032f, -0.05250045f, 0.18800524f, 
    0.01849248f, -0.13153239f, -0.15535036f, 0.09667220f, -0.23014139f, 0.02169010f, 0.03790237f, 0.15852766f, 
    0.08595464f, 0.02485153f, 0.01731691f, -0.11723703f, -0.29323786f, 0.10153669f, 0.10367122f, 0.13458073f, 
    -0.15028432f, -0.15587689f, -0.25725290f, 0.05696024f, -0.02277734f, -0.04814617f, 0.07140368f, 0.11548349f, 
    0.02653921f, -0.07126428f, -0.17082569f, -0.16388784f, 0.13522732f, 0.02861672f, 0.23096789f, -0.20104358f, 
    -0.26700300f, 0.06770071f, 0.19089983f, 0.02533963f, 0.15103082f, -0.17881386f, 0.12016471f, 0.12744704f, 
    0.27254570f, -0.15850733f, -0.00275373f, 0.18225269f, 0.04322203f, -0.04185127f, 0.12697223f, -0.17698550f, 
    -0.12513724f, -0.02638409f, 0.04484316f, 0.19833264f, 0.09564272f, -0.00218471f, 0.05954294f, 0.12511440f, 
    0.04680339f, 0.01796287f, 0.09030635f, 0.14514010f, 0.07431229f, -0.02789202f, -0.14777906f, -0.14364262f, 
    0.04313063f, 0.05204214f, 0.07159545f, 0.09227813f, -0.04307999f, 0.12928559f, 0.12601908f, 0.25729889f, 
    0.11244713f, -0.13141213f, -0.18796895f, -0.01753497f, 0.28305262f, 0.01729615f, 0.01710761f, -0.16219954f, 
    -0.07392480f, -0.13988438f, 0.20924285f, 0.09919430f, 0.01954949f, 0.14192896f, 0.16255786f, 0.07685657f, 
    -0.06867085f, 0.15614589f, -0.00322928f, 0.09632254f, -0.24089567f, 0.00321567f, 0.34015703f, 0.29229277f, 
    0.04665096f, 0.12495344f, 0.04467706f, 0.11557142f, -0.00666520f, 0.19600776f, 0.02227821f, -0.21358070f, 
    -0.34567010f, -0.22988370f, -0.00744705f, 0.00543924f, -0.03159413f, -0.03304145f, 0.02043184f, -0.28153658f, 
    0.01009576f, -0.04389243f, 0.00126390f, 0.06420835f, -0.00944604f, -0.10488101f, 0.04808404f, -0.09759390f, 
    0.03724225f, 0.34551629f, -0.35725239f, -0.11327246f, 0.06914449f, 0.23179290f, 0.18864632f, 0.12328306f, 
    -0.12124345f, -0.18480533f, 0.13656202f, 0.09852476f, 0.19700204f, 0.07254950f, -0.00119910f, 0.00621653f, 
    0.09346267f, 0.20317599f, 0.16843478f, 0.28326982f, 0.13585740f, 0.16447985f, 0.22785056f, 0.05159077f, 
    0.00257113f, 0.01562909f, 0.08138704f, -0.08838331f, -0.07789102f, 0.25937635f, -0.10829818f, -0.03317804f, 
    0.09787264f, -0.04534999f, -0.02251629f, -0.03945984f, 0.10888176f, 0.21437678f, 0.13610949f, 0.17318134f, 
    0.04059673f, -0.13418946f, -0.29613101f, 0.27532798f, 0.17376350f, 0.05456274f, -0.20545626f, -0.41383016f, 
    0.00272967f, 0.00687621f, 0.05405897f, 0.04986417f, 0.10124553f, -0.26197198f, 0.25162518f, 0.03468562f, 
    -0.08699329f, 0.10779826f, 0.11179038f, 0.13902929f, 0.16025814f, -0.00902007f, 0.00574763f, -0.15175705f, 
    -0.14666183f, 0.12217008f, 0.03860665f, -0.16585615f, -0.04389125f, 0.15441796f, 0.07516106f, -0.12396085f, 
    -0.02855755f, 0.22761963f, 0.34398252f, 0.26124862f, -0.16573358f, -0.13744307f, -0.07384537f, 0.25547498f, 
    -0.05111003f, 0.03157105f, -0.24805461f, -0.26086026f, 0.21278346f, 0.12672213f, -0.15769191f, 0.00749972f, 
    0.00562037f, 0.00952926f, 0.12089669f, 0.08840248f, 0.15642428f, 0.23516563f, 0.12809053f, -0.05275803f, 
    0.02999492f, 0.14350764f, 0.09530666f, 0.02881954f, -0.06759565f, -0.04529121f, -0.27918917f, -0.09021094f, 
    0.21326230f, -0.00082689f, 0.18750876f, -0.04450586f, 0.09708232f, -0.03716182f, 0.12413950f, -0.06599303f, 
    0.22838338f, -0.08984787f, 0.09115034f, 0.12792011f, 0.03202160f, -0.03980887f, -0.35278958f, -0.21790247f, 
    0.08154584f, -0.01053721f, -0.02263695f, -0.07511656f, -0.08100519f, -0.14788224f, 0.03315528f, 0.03364075f, 
    0.02300079f, 0.04874835f, -0.17557143f, 0.13499154f, 0.12261587f, 0.12144662f, 0.13645741f, 0.14797306f, 
    0.16598926f, -0.05620352f, -0.37985724f, -0.08641357f, 0.22661178f, 0.15304711f, -0.01762442f, -0.17269944f, 
    0.06366979f, 0.07820085f, -0.24422607f, -0.39894816f, -0.04721263f, 0.16395770f, 0.00986054f, -0.09542604f, 
    -0.28859392f, -0.18193237f, -0.06854083f, 0.05443801f, 0.36001980f, 0.17135681f, 0.02060618f, -0.03841764f, 
    -0.13993207f, 0.12990797f, -0.07948005f, -0.09508391f, -0.15734780f, -0.23347375f, 0.16108686f, 0.08748984f, 
    0.15851356f, -0.00168131f, -0.10094515f, 0.01747151f, -0.22232887f, -0.26678136f, 0.06318291f, -0.02522625f, 
    -0.04120324f, 0.01396687f, 0.09428467f, 0.07154737f, 0.11687427f, 0.21607476f, 0.12972240f, 0.10255880f, 
    -0.19231814f, 0.13390805f, -0.02282336f, -0.03408458f, 0.00935306f, 0.19373609f, -0.05567935f, 0.09272322f, 
    0.12051889f, 0.08718587f, -0.09645917f, -0.09175722f, -0.05134311f, 0.07282616f, 0.15046187f, 0.13344467f, 
    -0.13558134f, -0.09800440f, -0.05465730f, 0.11118565f, -0.11309335f, 0.23043425f, -0.11898774f, -0.04166810f, 
    -0.21890381f, -0.08704191f, 0.16693853f, 0.01267370f, -0.05142927f, -0.14620253f, 0.00511054f, -0.07719939f, 
    -0.14744845f, 0.01681015f, -0.04067220f, -0.40045437f, -0.02967839f, -0.01402183f, -0.02506923f, 0.12013038f, 
    0.18120086f, 0.06870028f, 0.14720802f, 0.02103016f, 0.10608016f, 0.21733104f, -0.06421687f, -0.17996527f, 
    -0.07428104f, 0.03965865f, 0.31836605f, 0.11822841f, -0.11153494f, -0.35038450f, 0.04753436f, 0.04404342f, 
    -0.06713868f, 0.10621566f, -0.02057063f, -0.06983432f, -0.19960885f, -0.06538745f, -0.11932514f, 0.19265056f, 
    0.19414961f, -0.11094008f, 0.05521826f, -0.01577865f, 0.28969145f, 0.02606093f, 0.28895995f, 0.22875795f, 
    0.17015393f, -0.25679329f, 0.15715148f, 0.19548482f, 0.07074676f, 0.05131714f, -0.06903317f, -0.18051229f, 
    0.09787683f, -0.03467066f, 0.07235182f, 0.06797689f, -0.08763083f, -0.08480929f, -0.03153450f, -0.50185841f, 
    -0.07882996f, 0.07036843f, 0.03850960f, 0.14757504f, 0.12153951f, -0.16626154f, -0.13300709f, -0.00902868f, 
    -0.22648223f, -0.08185712f, -0.23271762f, 0.13098718f, 0.05788146f, 0.03531831f, -0.08057059f, 0.05750599f, 
    0.11341391f, -0.06223065f, -0.15685752f, 0.06208541f, 0.16139217f, -0.07660811f, 0.05741064f, -0.04519736f, 
    -0.08642287f, -0.06413484f, 0.06841077f, 0.25023925f, 0.30816868f, 0.08634495f, -0.05729955f, 0.08551010f, 
    0.03226610f, 0.19783643f, -0.02784103f, -0.03783077f, -0.06334847f, 0.02193229f, -0.01696566f, 0.23884955f, 
    -0.00156350f, 0.06406452f, -0.12189738f, -0.04350233f, 0.08665338f, -0.17126761f, -0.05657866f, -0.00626787f, 
    0.15863937f, -0.03023031f, 0.03743641f, 0.09356529f, 0.02346322f, 0.05652612f, 0.13499922f, 0.09856917f, 
    0.16966350f, -0.06963863f, -0.06704705f, -0.11774322f, -0.12269281f, -0.15974459f, -0.03122676f, -0.02771116f, 
    -0.37020132f, -0.08557426f, 0.03640230f, 0.00931381f, 0.01699976f, 0.05341453f, -0.13170634f, 0.07598394f, 
    0.03619557f, 0.03530173f, 0.01308424f, -0.00985579f, 0.01597832f, 0.09070793f, 0.01946985f, 0.04656024f, 
    -0.21177849f, -0.07610153f, 0.01552643f, 0.09701405f, 0.05879272f, -0.00007393f, -0.07528734f, 0.07800873f, 
    0.16104028f, -0.39020401f, -0.24074475f, -0.02418332f, -0.01599460f, -0.01542202f, -0.09102198f, -0.00666889f, 
    0.06760468f, 0.11667132f, 0.07324311f, 0.13263606f, 0.06434591f, 0.04622212f, -0.07318016f, -0.14874996f, 
    0.04513588f, 0.07573591f, 0.05072546f, -0.16545935f, -0.03309368f, -0.14061938f, 0.00551585f, 0.05055621f, 
    0.01251440f, -0.13452664f, -0.01064866f, 0.08702838f, 0.06692187f, -0.20449753f, 0.04729342f, 0.15042400f, 
    0.09109118f, -0.11779810f, 0.08945504f, 0.03542779f, -0.00135388f, -0.19168967f, 0.06153924f, -0.01744531f, 
    0.03614166f, -0.02932663f, -0.22857566f, 0.02929727f, -0.13156582f, -0.00864522f, -0.08717041f, -0.18206236f, 
    0.14442590f, -0.03869995f, -0.07148814f, -0.07557556f, -0.13621639f, 0.12130450f, -0.07957866f, -0.42470863f, 
    0.03371388f, 0.19967620f, -0.12549259f, 0.02478207f, 0.05584823f, -0.18989763f, -0.07723898f, 0.04430591f, 
    0.41092250f, 0.28438199f, 0.12765220f, 0.03350408f, -0.05740002f, 0.09313895f, 0.05448103f, 0.08641116f, 
    -0.07254536f, 0.09378760f, 0.13736869f, 0.09473225f, 0.09598997f, -0.15504156f, 0.22318068f, 0.14204606f, 
    -0.05157138f, -0.25732288f, -0.21504475f, 0.13964170f, -0.35656762f, 0.27717111f, -0.13141224f, -0.10341174f, 
    0.21303478f, -0.00612397f, 0.23178335f, 0.06110795f, 0.13149357f, -0.10068323f, 0.13373671f, -0.00042459f, 
    0.01477745f, 0.04929366f, -0.02930975f, -0.12044837f, 0.12098259f, 0.05046820f, 0.12522849f, -0.14990146f, 
    0.02733509f, -0.04937042f, -0.08546865f, 0.03184709f, 0.09716488f, -0.13218859f, -0.12780577f, 0.10530649f, 
    0.01034734f, 0.07992754f, 0.03978831f, 0.05599174f, 0.13121684f, 0.06953014f, 0.37989926f, -0.15468080f, 
    -0.09131918f, -0.01033285f, -0.04292569f, -0.00968566f, -0.17022699f, 0.08229061f, -0.27509817f, 0.06904662f, 
    0.07271664f, -0.10312122f, 0.18513493f, -0.03169887f, 0.30066916f, 0.10377669f, -0.04054345f, -0.10317612f, 
    0.25093451f, 0.09197967f, -0.24920972f, -0.02093334f, -0.14055501f, 0.31322062f, -0.03477181f, 0.14250416f, 
    -0.14508350f, 0.16429837f, 0.33087564f, 0.00066031f, -0.19490843f, -0.11072085f, -0.00805953f, 0.00617578f, 
    0.18673022f, -0.00095804f, 0.29208601f, -0.04383814f, 0.08254097f, -0.21065590f, -0.05025189f, 0.00636442f, 
    -0.10819416f, 0.01146274f, 0.00891539f, 0.11927975f, 0.27148506f, -0.02858790f, -0.01625506f, -0.06231942f, 
    0.02149327f, 0.13149934f, 0.03923741f, 0.14931998f, 0.22445112f, -0.02496698f, -0.01732168f, -0.09944025f, 
    0.02828201f, -0.15749283f, 0.10419878f, 0.26625264f, -0.21905139f, -0.17432944f, -0.31077722f, 0.06008616f, 
    -0.00783550f, 0.12505662f, -0.16268095f, -0.03088995f, -0.01267081f, 0.10902089f, -0.27624345f, 0.14135459f, 
    0.02508776f, 0.07860719f, 0.09483247f, -0.07887891f, 0.01071026f, 0.13896982f, -0.02406242f, -0.06811405f, 
    -0.15233500f, -0.09987802f, 0.12638830f, 0.14570197f, 0.10291052f, 0.06418132f, 0.10386634f, 0.04608749f, 
    0.14721256f, 0.19946027f, -0.05090455f, 0.06522018f, -0.07078931f, -0.07843894f, -0.09362275f, 0.05210771f, 
    -0.01982420f, -0.03525935f, 0.02468892f, 0.11509894f, 0.07119254f, -0.00587125f, -0.10885474f, -0.04800886f, 
    0.14664650f, -0.04736636f, -0.26069826f, -0.17343813f, 0.01566040f, 0.11464640f, 0.05345283f, 0.10894967f, 
    -0.10061292f, -0.04630211f, 0.19661315f, -0.32908320f, 0.13851653f, 0.03918258f, 0.13006099f, 0.18140456f, 
    -0.04189942f, 0.04723526f, 0.14557551f, -0.13072354f, 0.12022331f, 0.16896175f, 0.11864284f, 0.05533786f, 
    0.00820102f, -0.00945528f, -0.14849515f, -0.00413241f, -0.06588133f, -0.11207514f, -0.35011768f, -0.11420010f, 
    -0.05360599f, 0.00696533f, 0.13055290f, -0.09469236f, 0.07363575f, 0.02272307f, 0.18115756f, 0.24241155f, 
    0.05579344f, 0.08723255f, 0.23840399f, 0.01234458f, 0.03976775f, 0.02780647f, -0.05125437f, 0.09773281f, 
    -0.25597292f, 0.02155056f, -0.01863240f, 0.05645851f, -0.02686928f, 0.10826054f, -0.08967416f, -0.07461127f, 
    0.05568895f, -0.18877305f, 0.12702945f, 0.08749565f, 0.20926206f, 0.01635704f, 0.01953195f, 0.11949901f, 
    0.11739452f, -0.20569204f, -0.14425415f, 0.02238750f, -0.03127835f, 0.13358924f, 0.10149540f, 0.07456434f, 
    -0.03756833f, 0.08802613f, -0.02880815f, -0.08079934f, 0.17709781f, 0.19523112f, 0.06113361f, 0.11122502f, 
    -0.16823682f, -0.03909319f, 0.00871946f, -0.10939735f, 0.09805494f, 0.03475009f, 0.03849900f, 0.04270842f, 
    0.19764924f, 0.19495460f, 0.13078213f, 0.00944156f, -0.02498067f, 0.12966435f, -0.16392252f, 0.08766041f, 
    0.08495179f, 0.06534528f, 0.19611301f, 0.06288484f, 0.17161405f, -0.50285256f, 0.28696215f, 0.02397505f, 
    0.03338455f, 0.10769580f, 0.14077196f, 0.03257414f, 0.16903804f, 0.06632581f, 0.06736212f, -0.23093751f, 
    -0.13122399f, -0.06013626f, 0.07276515f, 0.01205552f, 0.13496664f, 0.07132851f, 0.22380058f, 0.08278325f, 
    -0.12307739f, -0.10938563f, 0.04621695f, -0.15178400f, 0.11548758f, 0.29046345f, 0.05245587f, 0.16336994f, 
    -0.22513770f, -0.05745650f, 0.07108668f, 0.21778943f, -0.08153041f, 0.05092816f, -0.24945143f, 0.03217656f, 
    0.13509168f, -0.15397507f, 0.14839506f, -0.03391881f, -0.06692500f, -0.02606452f, 0.12246955f, -0.09945250f, 
    -0.15746514f, -0.06992821f, -0.04886043f, 0.27328065f, -0.00145959f, 0.18491293f, -0.00329296f, 0.17985098f, 
    0.02770860f, 0.24653205f, -0.07931714f, -0.09004234f, 0.09494420f, -0.06117197f, -0.11039419f, -0.10080360f, 
    0.03985598f, 0.14163189f, 0.05302006f, 0.06872429f, 0.12352856f, -0.08010839f, 0.01313963f, -0.05950908f, 
    -0.03722682f, 0.00194973f, 0.02363840f, 0.09072893f, 0.05679698f, -0.21867168f, -0.08297415f, 0.21941212f, 
    -0.10103132f, -0.07675742f, 0.15009488f, 0.06282406f, -0.13539124f, 0.30456322f, 0.10262782f, -0.10604633f, 
    0.11991664f, -0.32535926f, 0.05184440f, -0.18376845f, -0.00302735f, 0.18657309f, 0.08192432f, 0.14407282f, 
    -0.10796580f, -0.01190219f, 0.00077846f, -0.16316639f, 0.09869194f, 0.05582773f, 0.16544317f, 0.03348716f, 
    0.15289697f, 0.20188592f, -0.13540648f, 0.20434169f, -0.19063161f, -0.11716283f, 0.05354026f, 0.04938277f, 
    0.03228563f, 0.03750027f, 0.00286301f, -0.07573192f, 0.14835574f, -0.01771802f, 0.06343434f, -0.04616638f, 
    -0.01939867f, 0.00980402f, 0.08901103f, 0.21034038f, 0.33006886f, -0.29046941f, 0.08919428f, 0.05160961f, 
    0.01925913f, 0.12365889f, 0.13848747f, 0.05813775f, 0.13191223f, -0.12297836f, 0.19985715f, 0.03391044f, 
    -0.00655405f, -0.14024098f, 0.02103307f, 0.17563815f, 0.39211065f, -0.06160571f, -0.22873618f, 0.09832065f, 
    -0.02481351f, -0.14648885f, 0.10354943f, 0.17772824f, 0.01310075f, -0.27953544f, -0.14151880f, 0.15778396f, 
    -0.18311326f, 0.30490682f, 0.16836445f, 0.16857897f, -0.01846939f, 0.16580236f, 0.03505399f, -0.06877793f, 
    0.07492428f, -0.02307932f, 0.05349674f, 0.18087246f, 0.14360341f, 0.17313325f, 0.09887079f, 0.08979992f, 
    -0.12172762f, 0.02977256f, 0.14241807f, 0.15316451f, -0.07323466f, 0.12501505f, -0.00819283f, -0.16208355f, 
    0.11914324f, 0.20475385f, -0.28911996f, -0.10054147f, 0.00554263f, -0.04583997f, 0.11504547f, 0.12551580f, 
    0.01397165f, -0.10972460f, 0.05919363f, 0.12273392f, 0.16922109f, 0.09137014f, 0.09994122f, -0.19008787f, 
    -0.03825605f, 0.06943721f, -0.07666341f, -0.06786463f, 0.15231173f, 0.01847958f, 0.12836280f, 0.18563111f, 
    -0.02971831f, 0.04273643f, 0.12512195f, 0.02752807f, 0.04705144f, -0.17344163f, 0.16717704f, -0.09269711f, 
    0.20415469f, 0.17393042f, 0.01767374f, 0.02110563f, -0.13282289f, 0.34577358f, 0.20609899f, -0.09895218f, 
    0.00212252f, 0.01841173f, 0.07101148f, 0.19622552f, 0.15707450f, -0.08699302f, -0.27761689f, -0.15345933f, 
    0.06492664f, -0.12089230f, 0.03885885f, -0.13383974f, -0.11115282f, 0.01814362f, 0.07357859f, 0.03386567f, 
    -0.22723429f, -0.05167622f, 0.01020627f, 0.07148095f, 0.07681325f, 0.20156416f, -0.02191091f, -0.10152810f, 
    0.09744749f, 0.11767617f, 0.12941754f, 0.07714143f, 0.02901872f, 0.07221807f, 0.07242442f, 0.16806266f, 
    -0.02725966f, -0.04637602f, 0.04335297f, 0.00777498f, 0.00204132f, 0.04992643f, -0.00292584f, -0.02826365f, 
    -0.02083281f, 0.00133435f, -0.01606460f, -0.06072248f, 0.03724052f, 0.00850384f, -0.01700352f, 0.01086054f, 
    0.01060193f, 0.04578314f, -0.02840494f, 0.03043018f, 0.01418809f, 0.05665699f, 0.02939817f, 0.03763784f, 
    -0.04369726f, 0.03209689f, 0.01934275f, 0.01681437f, 0.01352051f, -0.05138613f, 0.03212427f, -0.03874030f, 
    -0.04694306f, -0.05147107f, 0.01774361f, 0.05110247f, -0.05361395f, 0.02244304f, -0.04468810f, 0.00594779f, 
    0.02726896f, -0.05174880f, 0.00029086f, -0.06140259f, -0.04824420f, 0.05322161f, -0.03275212f, 0.05117935f, 
    -0.02520994f, 0.00006157f, -0.00565010f, -0.01174278f, -0.04159849f, -0.05375602f, -0.04654803f, 0.04113907f, 
    -0.03983082f, 0.01667836f, 0.03963937f, 0.04100387f, 0.00780177f, 0.01428350f, -0.04459321f, -0.05131271f, 
    0.00765710f, -0.05202117f, 0.00050029f, 0.05015608f, -0.02244340f, 0.00606332f, -0.02048325f, 0.04323111f, 
    -0.05730133f, 0.03577680f, -0.00260100f, 0.01646733f, 0.05378357f, -0.05969472f, 0.03352012f, -0.05481398f, 
    0.03980975f, -0.01308780f, -0.01892282f, -0.06545113f, -0.02897668f, -0.04009806f, -0.06150146f, -0.04796516f, 
    0.04382168f, -0.00819445f, -0.03439738f, 0.00947552f, -0.01081940f, 0.03762884f, 0.01068097f, -0.04836108f, 
    -0.04289540f, 0.00281305f, 0.01581719f, -0.04843839f, -0.05020118f, 0.04229780f, -0.05183659f, 0.01263813f, 
    0.05267011f, 0.02157217f, 0.03729833f, -0.04110040f, 0.01274719f, 0.02905729f, -0.00239875f, -0.06087503f, 
    -0.01671365f, -0.04839032f, 0.02827486f, -0.06105999f, 0.00849202f, 0.04944384f, -0.02234009f, 0.02196360f, 
    0.03789049f, -0.01864135f, -0.02984474f, 0.04927712f, -0.02153332f, 0.02516433f, 0.03013199f, 0.02164488f, 
    0.02366259f, -0.05399320f, -0.05829105f, 0.03360588f, 0.04962643f, -0.03986106f, 0.05063999f, -0.02636964f, 
    -0.06311321f, -0.00615756f, 0.03759471f, 0.02586953f, 0.03229780f, -0.01514107f, -0.03176512f, -0.05368971f, 
    -0.05303038f, -0.00349710f, 0.00508296f, 0.00600400f, -0.01045002f, 0.03621470f, -0.05616127f, -0.05464698f, 
    0.00032603f, -0.02876740f, 0.02114326f, -0.04418128f, 0.00906141f, 0.00947975f, -0.00530736f, -0.03485314f, 
    -0.04688021f, 0.02915517f, 0.03164354f, -0.03096025f, 0.01967443f, 0.01021320f, 0.01726874f, 0.04897613f, 
    0.02363608f, -0.04072977f, 0.03866775f, 0.01281154f, 0.03727981f, 0.02298057f, 0.02577399f, 0.05689039f, 
    -0.05429617f, -0.03225075f, -0.04969890f, -0.00729010f, 0.02037480f, 0.00613006f, -0.00290252f, -0.05048407f, 
    -0.04890469f, -0.01565369f, -0.01450726f, 0.04243007f, 0.00179586f, -0.00405194f, 0.01320811f, 0.01832778f, 
    0.00549285f, -0.03384642f, -0.03358601f, -0.00037216f, -0.04659581f, 0.01182348f, 0.03262789f, -0.01023515f, 
    -0.05322154f, 0.01727043f, 0.04331204f, -0.03070330f, -0.01065860f, 0.01771167f, -0.03067198f, -0.02620881f, 
    -0.05875149f, -0.02230783f, -0.05474532f, -0.05500287f, 0.03311129f, -0.01281974f, 0.01769264f, -0.00018100f, 
    0.00477069f, -0.00533130f, -0.04287068f, 0.04208650f, -0.05227654f, -0.01756015f, -0.05920970f, -0.00694890f, 
    0.01863103f, 0.00400323f, -0.04818142f, -0.03683116f, -0.02821387f, 0.03485389f, -0.05794759f, -0.04428219f, 
    -0.05228294f, -0.05286981f, -0.02697047f, -0.05154953f, -0.00912129f, -0.03051610f, 0.00068403f, -0.00969290f, 
    0.04058819f, 0.00760543f, 0.01852339f, -0.03862299f, 0.00410314f, -0.05992125f, -0.01578051f, 0.05160453f, 
    0.00351706f, -0.05721045f, 0.01782789f, -0.01319991f, 0.00104151f, -0.02339030f, 0.02113053f, -0.04614898f, 
    -0.02200137f, 0.04487440f, -0.02519610f, -0.00159754f, -0.01976486f, -0.01767006f, 0.04852859f, -0.03013004f, 
    -0.01993960f, 0.01670373f, -0.00670554f, 0.00716101f, 0.02469314f, 0.02341103f, 0.04238592f, -0.01319288f, 
    0.02261828f, -0.00483410f, -0.03281732f, -0.01031660f, 0.02595055f, -0.03335662f, -0.03156916f, -0.02056062f, 
    0.03896309f, -0.05573936f, -0.05380790f, 0.03431107f, 0.03583811f, 0.04196731f, -0.03252885f, -0.01078842f, 
    -0.00550246f, -0.00226016f, -0.05763688f, 0.02043167f, 0.04446204f, -0.03696848f, -0.01519038f, -0.01034438f, 
    -0.01937103f, -0.03169434f, 0.00711066f, -0.01341914f, -0.03661868f, -0.05543079f, 0.00623452f, 0.03714219f, 
    0.00480166f, 0.00950871f, -0.05890014f, 0.02500780f, -0.00549094f, 0.00421056f, 0.04556673f, -0.00277191f, 
    0.05205647f, -0.02815646f, -0.00477288f, 0.03248289f, -0.00360527f, 0.03664277f, -0.01434724f, -0.00964116f, 
    -0.02183611f, 0.00684361f, -0.01418980f, -0.06223300f, 0.03151411f, -0.02922969f, -0.04476885f, 0.01662747f, 
    -0.04624401f, -0.01015908f, -0.05575676f, -0.02434964f, -0.00942344f, 0.04503254f, 0.01333750f, -0.02652530f, 
    -0.01954938f, -0.04736404f, -0.00659177f, -0.03371142f, 0.05511461f, 0.04659192f, -0.04475668f, -0.04494766f, 
    0.02955342f, 0.00280687f, -0.00614906f, -0.01957396f, 0.02858909f, -0.03775188f, 0.00586987f, 0.02236140f, 
    0.04629129f, 0.03144908f, -0.04049645f, -0.03450767f, -0.00498970f, 0.02703652f, 0.04002983f, -0.01704961f, 
    -0.03759754f, -0.00156990f, -0.02238332f, -0.02521328f, -0.01759637f, -0.00976737f, 0.02400293f, 0.03455856f, 
    -0.02362043f, -0.05657120f, -0.04564656f, 0.02689840f, -0.00907104f, -0.05781071f, -0.06382311f, -0.02142208f, 
    0.01970381f, -0.06562640f, -0.04425905f, -0.03165149f, -0.03101620f, -0.01739525f, -0.00785779f, -0.04547392f, 
    -0.00078307f, 0.05306989f, 0.04684317f, -0.02757925f, 0.01791793f, 0.04221793f, -0.04706596f, 0.03579682f, 
    0.03670200f, 0.00250133f, 0.05455289f, -0.01942153f, 0.02646890f, 0.04320518f, -0.06561875f, 0.03985595f, 
    -0.00097881f, 0.02276717f, 0.00947464f, -0.00025865f, -0.00777452f, -0.01071810f, -0.06588918f, 0.01691845f, 
    0.00911350f, -0.02630158f, -0.03633733f, -0.03793676f, -0.02790607f, -0.00950931f, -0.04590944f, 0.01641923f, 
    -0.01070631f, -0.02952824f, -0.03031883f, 0.03850352f, -0.03070939f, 0.00673925f, 0.03834144f, -0.02272763f, 
    0.02427375f, -0.01347576f, -0.02789381f, -0.03835372f, -0.04799011f, -0.03062498f, -0.01065280f, -0.02880266f, 
    0.03825299f, 0.00167003f, -0.01369928f, 0.01760976f, -0.01559454f, -0.03463130f, 0.00787031f, -0.04666263f, 
    -0.01129044f, -0.03773244f, 0.03426952f, 0.01369812f, 0.03538398f, 0.04846143f, -0.04395666f, 0.03218989f, 
    -0.05923684f, 0.03229262f, 0.02026436f, -0.01677210f, -0.02422080f, -0.00175235f, -0.05569548f, -0.01898005f, 
    -0.00586550f, -0.03920623f, 0.01888094f, -0.01821272f, 0.04842949f, 0.00440713f, 0.00711601f, -0.01482225f, 
    0.00747820f, -0.02268145f, -0.00220170f, 0.03445909f, -0.01983319f, -0.06816232f, -0.05204509f, 0.02809395f, 
    -0.03754812f, -0.06084386f, -0.02384068f, 0.03743721f, 0.02695008f, 0.03052997f, -0.00175280f, -0.03272040f, 
    0.01012220f, -0.00092445f, 0.00547422f, -0.03414809f, 0.03863673f, -0.00430392f, -0.04837450f, -0.01053382f, 
    0.03310934f, -0.04536794f, 0.00862772f, 0.04402003f, -0.03969482f, 0.04527454f, -0.00591784f, 0.05642960f, 
    0.04013473f, -0.02666462f, 0.02393436f, -0.02135056f, 0.03583720f, -0.00265163f, 0.01003001f, -0.03311703f, 
    0.02548042f, 0.04906474f, -0.03932996f, -0.04917036f, -0.02426766f, 0.04089838f, 0.01155574f, -0.06355521f, 
    0.03143800f, 0.00134805f, 0.03704294f, -0.03007571f, -0.05451963f, 0.05006778f, -0.04204182f, 0.03107100f, 
    0.05756387f, -0.00374235f, 0.00100889f, 0.01569443f, 0.03571207f, 0.02966739f, 0.04048874f, 0.00825673f, 
    0.02135092f, -0.05529233f, 0.00489495f, -0.05610879f, -0.05774530f, 0.02071159f, -0.05949754f, -0.03622297f, 
    -0.01029454f, -0.04036407f, 0.02279766f, 0.01152881f, -0.04073950f, -0.05388737f, 0.04092874f, -0.04446510f, 
    -0.00591623f, -0.04075029f, -0.05540206f, 0.00131858f, -0.03963732f, 0.00940131f, 0.00887255f, -0.00064339f, 
    0.01277600f, -0.03411001f, 0.02834275f, 0.03721033f, 0.01797814f, 0.03110430f, 0.04370364f, 0.03715764f, 
    -0.01446311f, 0.04266411f, 0.00381765f, -0.03488448f, -0.05046383f, 0.02283124f, -0.01605812f, -0.03802476f, 
    0.01796773f, -0.04782750f, -0.06321891f, -0.00818196f, -0.06488236f, -0.05783946f, -0.00084356f, 0.02532143f, 
    0.02833012f, -0.01453712f, -0.04237542f, -0.02264518f, 0.01993700f, 0.05468816f, 0.00090307f, -0.03322385f, 
    -0.05397061f, 0.00297864f, 0.00470305f, -0.00115659f, -0.05455969f, 0.04631123f, 0.04105364f, 0.05092203f, 
    0.01222258f, -0.05706097f, -0.05284845f, 0.05027928f, -0.05046753f, -0.03404325f, -0.05112194f, 0.04298497f, 
    -0.02114136f, -0.05031918f, 0.02891350f, 0.00647410f, -0.01303507f, -0.00017548f, -0.01710057f, -0.01724305f, 
    -0.04629331f, 0.03250080f, -0.03455846f, -0.03715996f, -0.00297043f, -0.06011770f, -0.05930921f, -0.02609088f, 
    -0.05864287f, -0.00964815f, -0.02372839f, 0.01180512f, -0.04634359f, 0.03943907f, -0.03279381f, -0.05187852f, 
    -0.01663565f, -0.02929195f, 0.03832692f, 0.04751062f, -0.02036305f, 0.01621902f, 0.03386317f, -0.03926650f, 
    -0.02323398f, 0.01130831f, 0.01400833f, -0.04675435f, 0.02333704f, 0.04942333f, -0.02640165f, 0.02101639f, 
    0.04164626f, 0.01161301f, -0.02462342f, -0.03195901f, 0.01585260f, 0.02647558f, -0.01815278f, -0.00859053f, 
    0.00873006f, 0.05210948f, 0.03108459f, -0.02580531f, -0.03159553f, -0.01820343f, -0.06222029f, -0.01488129f, 
    -0.06277440f, -0.02435972f, 0.05072004f, -0.03458332f, 0.00141098f, -0.05433419f, 0.05076225f, 0.02758976f, 
    0.01982093f, -0.05269604f, -0.05470575f, -0.04046115f, 0.00582513f, -0.04214006f, 0.01364288f, -0.05906365f, 
    -0.02678682f, 0.04327682f, 0.02633137f, 0.06101425f, 0.00918466f, -0.03152937f, 0.03012030f, -0.01212661f, 
    0.01191629f, 0.03796144f, 0.03455242f, -0.04302921f, 0.02388082f, 0.00865275f, 0.04753854f, 0.04691791f, 
    -0.02357925f, -0.05333013f, -0.04104410f, -0.03042071f, -0.05565695f, -0.03535013f, -0.01506800f, -0.05401371f, 
    0.04255658f, -0.04907200f, 0.04161704f, -0.02514425f, -0.06416944f, -0.05092975f, -0.04868582f, -0.05654578f, 
    -0.02849074f, -0.02199853f, -0.01663665f, 0.04236256f, 0.05245331f, -0.01941521f, 0.03789918f, -0.01546226f, 
    0.04881033f, -0.01269097f, -0.03141879f, 0.02454515f, 0.01384461f, 0.01470443f, -0.02657176f, 0.04189099f, 
    -0.06450906f, -0.01639842f, 0.01842337f, 0.00329885f, 0.05208188f, 0.02626048f, -0.05404297f, 0.04584198f, 
    -0.03358037f, -0.03663909f, -0.01690346f, 0.01217826f, -0.06053302f, 0.01155917f, -0.05200633f, -0.03722917f, 
    -0.05356387f, -0.03256437f, -0.02961388f, 0.02028937f, -0.03764331f, -0.00539624f, -0.03887782f, -0.01216811f, 
    -0.01152282f, -0.00434309f, -0.01383338f, -0.00547973f, -0.02781357f, -0.00629535f, -0.00150290f, 0.03749814f, 
    0.04245223f, 0.01225753f, -0.02769304f, 0.02603939f, 0.02426433f, 0.05207459f, -0.04364310f, -0.03509459f, 
    -0.04437679f, -0.06973183f, 0.03020516f, 0.00536870f, 0.00850187f, 0.02727442f, 0.01175540f, 0.01409325f, 
    0.04214408f, -0.00671740f, -0.01236411f, 0.05148017f, 0.02258356f, 0.04604061f, 0.00721712f, -0.01271057f, 
    -0.02719874f, 0.00801012f, -0.03350405f, -0.03360354f, 0.05048191f, 0.00552939f, -0.01839126f, 0.04096746f, 
    -0.05124105f, 0.03550439f, -0.05527274f, 0.02501611f, -0.05805477f, 0.05140999f, 0.03649037f, -0.05460957f, 
    -0.03633585f, 0.03901551f, 0.00125131f, 0.03412116f, 0.03725946f, 0.01408263f, -0.05060105f, 0.00565432f, 
    0.04982130f, 0.03253489f, -0.04134229f, 0.00685120f, 0.05055416f, 0.00787975f, -0.04380047f, -0.02413855f, 
    -0.05010514f, -0.06843466f, 0.02233408f, -0.02122555f, -0.01447608f, 0.03175407f, -0.04164846f, -0.00886187f, 
    -0.00254360f, -0.04796059f, -0.04175640f, 0.03177568f, -0.01035277f, -0.04119271f, -0.05624413f, 0.03658776f, 
    -0.04771479f, 0.00757094f, 0.03222422f, -0.00475354f, -0.03374515f, -0.01905422f, 0.03796575f, -0.04322018f, 
    -0.05208946f, -0.03349388f, 0.04377591f, 0.00871400f, 0.01442931f, -0.02182388f, 0.04059047f, 0.05457185f, 
    0.02234404f, -0.02546523f, -0.04171811f, -0.03751139f, 0.03455513f, -0.06080589f, -0.05272484f, -0.04308777f, 
    0.01758813f, -0.01476980f, -0.05278161f, 0.03093516f, -0.03135977f, 0.02170395f, 0.00231436f, -0.04083315f, 
    0.01588284f, -0.03989789f, -0.03855096f, -0.03456056f, -0.03019649f, -0.04679998f, 0.00240850f, -0.02200265f, 
    -0.41068220f, 0.05183186f, -0.02956184f, 0.08833873f, -0.07589899f, -0.06288618f, -0.03884380f, 0.06501977f, 
    0.17380124f, -0.14094868f, 0.12589394f, 0.00494742f, -0.02103455f, 0.09574378f, 0.07416526f, 0.15671007f, 
    0.02469969f, 0.06764554f, 0.34229773f, -0.03111744f, 0.12039501f, -0.08694959f, 0.09436294f, -0.02046034f, 
    0.04390745f, 0.02281393f, -0.04315122f, -0.06556796f, -0.20641452f, -0.14409982f, -0.06711356f, -0.04768477f, 
    -0.05630329f, 0.05233424f, 0.06983226f, 0.00602882f, -0.04517664f, 0.03388796f, 0.06033938f, 0.04215325f, 
    -0.09604190f, 0.10419298f, 0.11614423f, -0.21629933f, 0.11678106f, 0.18405977f, -0.00184492f, -0.05295692f, 
    -0.19552381f, -0.00713882f, 0.02493592f, 0.00930074f, 0.09167068f, 0.11167600f, 0.04010341f, 0.04821312f, 
    -0.36550674f, -0.18774794f, -0.16640396f, 0.14424014f, 0.07230283f, -0.11290155f, 0.00311906f, -0.27166104f, 
    0.14302227f, 0.02330842f, -0.03780454f, 0.11951718f, 0.05094684f, -0.23389040f, -0.02529407f, 0.01823120f, 
    0.26637012f, 0.15584786f, 0.01738955f, 0.27220115f, -0.04143283f, 0.05213617f, 0.14445347f, 0.09933180f, 
    -0.06501119f, 0.24857205f, -0.18524574f, -0.50642961f, 0.02937112f, 0.04435087f, 0.02816393f, -0.07116903f, 
    -0.00596647f, -0.11366349f, -0.02954808f, -0.15530896f, -0.06890092f, -0.21223943f, 0.05999932f, -0.08069672f, 
    -0.05215607f, 0.18589886f, -0.00340738f, 0.57576650f, 0.10471804f, 0.03589918f, -0.00434756f, -0.01266273f, 
    -0.01691832f, -0.03891484f, 0.07636349f, 0.06877548f, 0.05114857f, -0.01979246f, -0.09340771f, -0.05788613f, 
    0.03003476f, 0.08862186f, -0.09992600f, -0.01147657f, -0.05780481f, -0.20997468f, 0.01537830f, -0.19357328f, 
    0.10626553f, 0.22826281f, -0.13237220f, 0.02922433f, 0.08163022f, 0.00070764f, -0.24803130f, -0.08225765f, 
    -0.25444886f, 0.05970532f, 0.13154714f, 0.04983077f, -0.34749451f, 0.00517109f, 0.03839700f, 0.12539855f, 
    -0.14231110f, -0.06892194f, 0.11931142f, 0.02846453f, -0.08732528f, 0.08096474f, 0.17769599f, 0.07178106f, 
    -0.07339518f, 0.05106472f, -0.11563534f, -0.00380836f, -0.05872849f, -0.05769233f, -0.09511164f, 0.19479376f, 
    -0.05252010f, 0.15514083f, -0.01559910f, 0.23700547f, -0.10023867f, 0.04191345f, 0.11326122f, 0.01298642f, 
    -0.00810337f, 0.00089626f, -0.10234209f, 0.18323597f, -0.40645710f, -0.08723950f, -0.00307496f, -0.00675358f, 
    -0.06014343f, -0.05026574f, 0.13618793f, 0.16908655f, 0.20717923f, 0.18312390f, 0.00520606f, -0.01990692f, 
    0.04144843f, 0.02119590f, 0.06977434f, -0.05391834f, -0.18611923f, -0.02177316f, -0.16126883f, 0.11180321f, 
    0.16005754f, -0.10637090f, -0.21232279f, -0.06199075f, 0.16762814f, -0.08988598f, 0.12371225f, -0.25535429f, 
    -0.09606418f, 0.05574644f, -0.04437441f, -0.07985029f, -0.02611033f, 0.12863891f, -0.34673032f, -0.05094732f, 
    -0.18891235f, 0.08754199f, 0.05902421f, -0.00621356f, -0.12895258f, -0.01607070f, -0.05725276f, -0.27853227f, 
    0.08969803f, -0.06637617f, 0.03013295f, -0.09670432f, 0.02007814f, 0.13432236f, -0.07556161f, 0.00410595f, 
    0.47620758f, -0.05697050f, -0.13519669f, 0.02556490f, -0.01367970f, -0.09487484f, -0.08288636f, -0.01645601f, 
    0.26030165f, 0.41059428f, 0.18520324f, -0.06204590f, -0.11425959f, 0.07797845f, 0.02173004f, -0.01246132f, 
    0.18939541f, 0.00683707f, -0.17436995f, 0.14415635f, 0.00945503f, -0.08177070f, 0.11458825f, -0.04137871f, 
    -0.01992638f, 0.01299876f, 0.05433380f, 0.15556900f, -0.27789980f, -0.14774533f, 0.01146349f, 0.08039094f, 
    0.03745362f, -0.25636956f, -0.04501605f, 0.02134541f, 0.08094028f, -0.05246308f, -0.44513187f, -0.04487715f, 
    -0.11933351f, 0.17188154f, -0.11173297f, 0.00351358f, -0.05307092f, -0.10582953f, -0.00310381f, 0.16013499f, 
    -0.05139748f, -0.02941651f, 0.09096524f, 0.03329867f, 0.00442187f, 0.15479821f, -0.10666931f, 0.39015433f, 
    -0.08079647f, 0.00401487f, 0.06663024f, -0.02566877f, -0.04434628f, 0.05582763f, -0.12034138f, 0.05582381f, 
    0.05892135f, -0.23479180f, 0.12737980f, 0.07606219f, 0.00441912f, 0.13626023f, 0.00798247f, 0.13104425f, 
    0.06770638f, -0.14883873f, 0.01740607f, 0.02538644f, 0.00594160f, 0.07921433f, 0.09544121f, -0.01025937f, 
    0.18845135f, 0.30318195f, -0.07233930f, -0.13907091f, 0.02164399f, -0.07791743f, -0.00025582f, 0.15164533f, 
    -0.04972790f, 0.17008476f, -0.21710899f, -0.13049260f, -0.09190014f, -0.22740513f, 0.16718714f, 0.08861704f, 
    0.19021648f, -0.01833626f, 0.14972426f, 0.00014982f, -0.13240780f, -0.14034419f, -0.07408036f, 0.08784249f, 
    -0.14952916f, -0.00568335f, -0.12495451f, 0.07051996f, 0.12824349f, -0.05427638f, -0.03751665f, 0.12773858f, 
    0.04194914f, -0.29054520f, 0.05404018f, -0.04649321f, -0.00671382f, -0.11953217f, -0.11732990f, -0.20907259f, 
    0.16229683f, -0.25333309f, -0.15174140f, 0.07018755f, 0.11378789f, 0.02939856f, -0.11008641f, 0.29825839f, 
    -0.10848056f, -0.01741255f, 0.05909415f, -0.12861764f, -0.12234241f, -0.02791644f, 0.29772794f, -0.02986553f, 
    0.28724113f, -0.23831849f, -0.17959997f, 0.03760973f, 0.27399540f, -0.03271519f, -0.14518428f, -0.03719907f, 
    -0.19926335f, -0.22174078f, -0.08637428f, 0.02925126f, 0.00233439f, -0.01087372f, -0.01612649f, -0.08135232f, 
    0.09464049f, -0.00194922f, -0.10587884f, 0.07893916f, 0.11476398f, -0.05878160f, 0.03302240f, -0.16208372f, 
    -0.02728619f, -0.02473770f, 0.39756081f, 0.01940549f, -0.09606551f, -0.10559946f, 0.00257018f, -0.02102912f, 
    0.12160464f, 0.01595161f, 0.30173376f, -0.15965815f, 0.21772580f, -0.02665742f, 0.12629437f, -0.14147353f, 
    0.00432771f, -0.08663937f, 0.16894343f, 0.03933946f, 0.00456993f, 0.23080546f, -0.06274544f, 0.17241023f, 
    0.09030197f, 0.07364729f, -0.04909961f, 0.12194367f, 0.03855544f, 0.32845306f, -0.03171937f, -0.24200660f, 
    -0.05096823f, 0.05316748f, 0.13670206f, 0.11497465f, 0.14413923f, -0.04615667f, -0.34339768f, -0.28136989f, 
    -0.00631945f, 0.18566586f, 0.10903579f, 0.08803423f, -0.03424497f, -0.15890691f, -0.17255294f, 0.08749766f, 
    -0.04644348f, 0.00338812f, -0.12489375f, 0.10660168f, -0.03141876f, 0.01109592f, -0.07118629f, -0.12882268f, 
    -0.10169586f, 0.23634185f, -0.15669683f, 0.13399878f, -0.03311846f, 0.16891660f, -0.01555273f, 0.26726532f, 
    -0.11042549f, 0.16050021f, 0.02017008f, -0.05203575f, -0.06116202f, 0.04133933f, 0.17475414f, -0.03758094f, 
    -0.03916828f, -0.01003300f, 0.01422914f, -0.35320857f, -0.12100322f, 0.11231144f, 0.10987975f, 0.15851726f, 
    0.03898925f, -0.09440477f, -0.36640957f, -0.11775229f, -0.00244428f, 0.07627883f, 0.03362199f, -0.05934281f, 
    0.11590409f, -0.04008197f, 0.02121603f, -0.11656247f, -0.29392076f, -0.27588484f, -0.26035702f, 0.01249641f, 
    0.03186188f, 0.04114869f, -0.20531160f, -0.08162290f, -0.09142746f, 0.04759479f, 0.08074809f, -0.16485590f, 
    0.08800034f, -0.10881478f, -0.00631593f, 0.04641383f, -0.03164979f, 0.16026491f, -0.26764178f, -0.04415939f, 
    -0.06727694f, 0.04655797f, 0.09949171f, -0.14939198f, 0.09591693f, -0.05178694f, 0.08055136f, 0.10233122f, 
    0.06926952f, 0.21642394f, 0.25501886f, -0.04315665f, 0.12150123f, 0.11665279f, 0.12614581f, 0.08838636f, 
    -0.02071572f, 0.35445732f, -0.31221777f, 0.03543314f, -0.00875441f, 0.01071626f, -0.05239813f, 0.09537929f, 
    -0.04750353f, -0.32970476f, 0.05183361f, -0.01739552f, 0.03046780f, 0.07269739f, -0.04737294f, -0.07096923f, 
    0.18552643f, 0.08556842f, 0.34554756f, -0.07084627f, -0.05585605f, -0.05294592f, 0.01608939f, 0.03412210f, 
    -0.04633661f, 0.10434425f, 0.09514179f, -0.01782597f, 0.27614778f, -0.31528246f, 0.09457787f, 0.07537874f, 
    0.09065507f, 0.04498344f, 0.04895350f, 0.19491701f, -0.13317476f, 0.13682839f, -0.07952470f, -0.03624127f, 
    -0.08165751f, -0.03276268f, -0.06999657f, -0.17858385f, -0.04270480f, 0.54361045f, 0.15273739f, -0.14270440f, 
    0.09623749f, -0.05908025f, 0.11928351f, -0.15631858f, 0.01774725f, 0.09436452f, 0.50104177f, 0.10987318f, 
    -0.04891123f, -0.06405615f, 0.04595938f, 0.00589816f, -0.05990730f, 0.14610386f, 0.01259688f, -0.27444288f, 
    -0.40213215f, -0.10642173f, 0.05590846f, 0.09066308f, -0.00151374f, 0.02823824f, 0.05948680f, 0.20786212f, 
    -0.02326619f, -0.00593502f, -0.03022162f, -0.00006432f, 0.04030208f, -0.04520423f, 0.01439045f, 0.03791716f, 
    0.05251031f, 0.00610144f, 0.04040602f, 0.03760124f, -0.02487647f, -0.01990979f, -0.01934015f, -0.00830008f, 
    -0.05139390f, 0.02340561f, -0.02429454f, -0.04662627f, -0.05126498f, 0.03056780f, -0.03280529f, -0.05551326f, 
    -0.01926610f, 0.00257489f, -0.02142769f, 0.02863937f, 0.01977128f, 0.04169787f, 0.03948708f, -0.00189783f, 
    -0.03874110f, -0.01434724f, -0.01284261f, -0.05778814f, -0.00263456f, 0.04191284f, 0.04335685f, -0.02312306f, 
    0.04720381f, -0.02812886f, -0.03472895f, -0.01427726f, -0.00033715f, -0.04503643f, -0.03330414f, -0.02565349f, 
    0.01581265f, 0.01064474f, -0.04963575f, -0.00684399f, -0.02717135f, 0.04068483f, -0.01332791f, -0.03746083f, 
    -0.03132675f, 0.04959866f, -0.05023480f, -0.00923082f, -0.00559193f, -0.04794869f, -0.05979722f, 0.02133779f, 
    0.03272358f, -0.04401629f, 0.00703706f, 0.00983320f, -0.03875233f, 0.02657433f, -0.03363017f, -0.05741551f, 
    -0.04289767f, 0.00277101f, 0.02593292f, -0.01328334f, -0.03341173f, 0.04291825f, 0.01901452f, 0.03029525f, 
    0.00281626f, 0.02114447f, -0.06382867f, 0.05189666f, 0.01726916f, 0.00746098f, -0.01768192f, 0.00904505f, 
    0.00814925f, -0.00452403f, -0.05651401f, 0.01163728f, -0.01692587f, -0.01284257f, -0.03213013f, -0.02488496f, 
    -0.05658621f, -0.01824864f, 0.04664593f, 0.03445425f, 0.00582017f, 0.01732364f, 0.01346511f, 0.03326388f, 
    -0.03004528f, -0.00224941f, -0.03638431f, 0.04018343f, -0.02990753f, -0.05284652f, 0.00698551f, -0.02114742f, 
    -0.00534279f, 0.01460915f, -0.04080534f, -0.00868268f, 0.04586940f, -0.05298965f, -0.01800467f, -0.05934197f, 
    -0.06231653f, -0.00111737f, -0.01326491f, -0.03657134f, 0.02803068f, -0.03894595f, -0.00673567f, -0.04240702f, 
    0.01642752f, -0.02765853f, 0.00435725f, -0.01341616f, -0.02441748f, -0.00460600f, -0.00447455f, -0.05468164f, 
    -0.04256366f, -0.00973466f, -0.04141176f, -0.01544318f, -0.01429987f, -0.04342225f, -0.06300597f, 0.03505731f, 
    0.02800336f, -0.05806659f, -0.03194406f, 0.01393977f, -0.04242314f, -0.05596754f, 0.04989050f, 0.02259242f, 
    -0.04232668f, -0.02822456f, -0.02689097f, -0.00407646f, 0.05282420f, -0.06025681f, 0.04043009f, -0.05765479f, 
    -0.00830609f, -0.05786982f, 0.04052992f, 0.02949259f, 0.01172662f, -0.00599056f, -0.01913649f, 0.03516062f, 
    -0.03287665f, -0.05185307f, -0.03864221f, -0.01632080f, 0.04301590f, 0.04519582f, 0.01641577f, -0.05970434f, 
    0.01929798f, 0.00446930f, -0.01431270f, 0.01572988f, 0.02756338f, 0.03595157f, 0.02313569f, -0.00521918f, 
    0.00052233f, 0.04114039f, -0.02041836f, -0.00874590f, 0.00275718f, 0.05112087f, -0.06265920f, 0.03043337f, 
    -0.04850408f, -0.02868589f, -0.04640678f, 0.00859006f, -0.01419801f, 0.03480025f, -0.00860228f, 0.00830417f, 
    0.01773089f, 0.01097723f, -0.00875845f, -0.05016075f, -0.04976989f, -0.00750536f, 0.03689238f, -0.03986235f, 
    -0.04216009f, -0.01178080f, -0.05721341f, 0.04850572f, -0.02992724f, 0.04759095f, 0.02433631f, -0.05437705f, 
    -0.05959677f, -0.05031203f, -0.00648380f, -0.00393114f, -0.00531373f, 0.01974746f, 0.00876547f, 0.03529676f, 
    0.01155614f, 0.01512829f, -0.04850126f, -0.05546600f, -0.05145008f, -0.02552467f, -0.02025006f, 0.04358593f, 
    -0.06227585f, -0.00138064f, 0.01306246f, -0.03376122f, -0.03605984f, -0.05852683f, 0.02920888f, 0.04692350f, 
    0.02481627f, 0.00985694f, -0.00269339f, 0.01447187f, -0.00772948f, 0.00046554f, -0.03896890f, -0.01325055f, 
    -0.01244421f, -0.03587325f, -0.06424532f, -0.04355741f, -0.04943056f, -0.02953262f, 0.00729406f, 0.04354273f, 
    0.03691416f, 0.03941987f, 0.03343779f, -0.00066351f, 0.00638565f, 0.00618942f, 0.00281680f, -0.02321447f, 
    0.03530477f, -0.03217938f, -0.01075743f, -0.02730741f, 0.04889501f, 0.03007810f, -0.05293901f, -0.00667868f, 
    -0.04555717f, 0.00743221f, 0.01156741f, -0.01885820f, 0.01183434f, 0.01162751f, -0.02028001f, 0.04542053f, 
    -0.02408756f, -0.04883566f, -0.01146432f, -0.03267734f, 0.05182348f, -0.03651366f, -0.03589501f, -0.04518589f, 
    0.31243309f, -0.18164104f, -0.13480642f, 0.11468064f, 0.03717375f, 0.07547772f, -0.09777191f, 0.09899577f, 
    0.08579760f, 0.00758393f, 0.02329887f, -0.04318245f, 0.10567043f, -0.14675876f, 0.07319773f, -0.04211073f, 
    -0.14647691f, -0.01551010f, -0.30816212f, 0.19980752f, 0.17664661f, -0.11288404f, 0.19302443f, 0.08717836f, 
    -0.07205866f, 0.05791964f, 0.17209122f, 0.16725425f, 0.01766655f, 0.06692097f, -0.01127230f, -0.17895973f, 
    -0.07483758f, 0.04891726f, 0.06533098f, 0.04794700f, 0.31620261f, 0.08326389f, 0.11257453f, -0.01884855f, 
    0.02502559f, -0.09918991f, 0.06874278f, 0.09919193f, 0.11638783f, -0.08505160f, 0.10395389f, -0.26235518f, 
    -0.03960052f, -0.15151419f, -0.03986073f, -0.01301989f, -0.14161713f, 0.00159837f, -0.38897029f, 0.17748147f, 
    -0.12805301f, 0.00421776f, 0.02603772f, -0.08651748f, -0.04904359f, -0.15607361f, 0.05275261f, -0.08621535f, 
    -0.04817083f, 0.04911858f, -0.02734233f, -0.10417969f, -0.00592549f, 0.04628218f, -0.14007346f, 0.14677122f, 
    0.05095929f, 0.28197822f, 0.22661579f, -0.08019213f, 0.00720521f, -0.12162049f, 0.06827684f, -0.11414374f, 
    -0.07809597f, 0.08327393f, 0.14248630f, -0.16178566f, 0.04883444f, 0.11080004f, 0.13107269f, 0.01748378f, 
    0.02911200f, -0.16254309f, -0.13522775f, 0.01523810f, 0.18651004f, -0.02421787f, -0.00848460f, -0.03661498f, 
    -0.14342096f, 0.05772772f, -0.10487133f, -0.24006726f, 0.36609492f, -0.16556951f, -0.01155661f, 0.01566285f, 
    0.13203897f, 0.09341324f, 0.00324556f, -0.02708766f, -0.39057505f, 0.25896695f, -0.16264148f, -0.06916936f, 
    -0.08747482f, 0.06311156f, -0.07956606f, -0.02294810f, 0.21009503f, -0.21859351f, -0.41223505f, 0.36550620f, 
    0.04582527f, -0.08949049f, -0.08172961f, -0.00369238f, 0.13260840f, 0.20516011f, 0.13895160f, -0.17200555f, 
    -0.12772061f, 0.02569830f, 0.08267420f, -0.01051450f, 0.19492808f, -0.06241343f, -0.11320467f, 0.10127019f, 
    0.05065908f, -0.02066741f, -0.17604850f, 0.07777006f, -0.00211554f, 0.02693230f, 0.03004646f, 0.08517554f, 
    0.19820310f, 0.09176648f, -0.09070364f, -0.27394387f, 0.18155438f, -0.06446487f, 0.19209462f, 0.10501269f, 
    0.07829402f, -0.02320876f, 0.33584151f, -0.07039724f, -0.07315661f, 0.01269087f, 0.11571456f, -0.00229466f, 
    0.14051130f, -0.11396962f, -0.36525294f, -0.33403704f, -0.32580152f, -0.09535537f, -0.00659907f, -0.13851148f, 
    0.06014170f, 0.19018608f, 0.06440184f, 0.03796546f, 0.21338397f, -0.17951368f, -0.04828838f, 0.16642208f, 
    -0.05297364f, 0.08210688f, 0.06250852f, -0.06476017f, -0.16883698f, -0.37083802f, -0.23920947f, 0.10565083f, 
    -0.03951073f, 0.14387399f, -0.08584100f, 0.02241572f, -0.16389246f, -0.24169938f, 0.12994213f, -0.13731658f, 
    0.11055787f, -0.15490931f, -0.02212751f, 0.03645304f, -0.07415257f, 0.02739421f, -0.04225792f, -0.08471150f, 
    -0.14020897f, -0.01551683f, -0.07228488f, -0.09849426f, -0.06731861f, 0.18156409f, -0.01327136f, 0.19784826f, 
    -0.22185135f, -0.04874961f, 0.09800363f, 0.31206435f, -0.09692633f, -0.03238802f, 0.01284623f, 0.16648546f, 
    -0.34161001f, 0.33471948f, -0.39545384f, 0.12574701f, -0.13199081f, 0.05021323f, 0.23095812f, -0.06862571f, 
    0.06338767f, 0.13278942f, 0.26181099f, 0.18578418f, -0.13273479f, -0.01407898f, -0.17662482f, -0.07764979f, 
    -0.03399078f, 0.03835277f, 0.10506709f, -0.12679720f, 0.06836884f, 0.02888837f, -0.20245938f, -0.03392938f, 
    -0.14759183f, 0.05387856f, -0.02083058f, 0.01873335f, -0.33069927f, 0.08486962f, -0.11101417f, 0.01996540f, 
    0.11707155f, 0.02379077f, 0.05612550f, 0.10299203f, -0.12050217f, -0.15269981f, 0.03140816f, 0.07757775f, 
    -0.16963312f, 0.04416096f, -0.06850775f, 0.08821656f, 0.04532335f, 0.26434541f, -0.21114181f, 0.19952081f, 
    0.02005310f, -0.09599517f, 0.01577126f, -0.03188297f, -0.09552518f, 0.07471425f, 0.01016191f, 0.03849672f, 
    -0.17161532f, -0.08360477f, 0.11671823f, -0.04336796f, 0.08760276f, -0.02215458f, -0.14170404f, 0.40827200f, 
    0.01927352f, -0.04284004f, -0.03602182f, 0.01524880f, -0.17841710f, -0.04176654f, -0.02133655f, -0.01547448f, 
    -0.35530913f, 0.13059555f, 0.14198160f, 0.15797849f, 0.10202247f, 0.02813643f, 0.01282413f, 0.16507621f, 
    0.02748108f, -0.52475089f, -0.18607900f, 0.02599899f, 0.04160859f, 0.08688229f, 0.12824915f, -0.19454716f, 
    0.03817949f, -0.05974226f, 0.24583326f, 0.01518918f, 0.03504635f, -0.01013921f, -0.14683330f, 0.01218231f, 
    0.09708469f, 0.03771382f, 0.09452390f, -0.50323546f, -0.06856979f, 0.00083320f, 0.01913256f, 0.07434454f, 
    -0.09657182f, 0.13648516f, -0.08279658f, -0.03935884f, 0.18775235f, -0.09502342f, -0.14979064f, -0.01667076f, 
    0.01593887f, 0.02590879f, -0.05290569f, 0.03251282f, -0.19502972f, -0.59974766f, -0.04590946f, -0.22275417f, 
    -0.11573657f, -0.21282101f, 0.01383670f, 0.14176181f, 0.12495740f, 0.13450868f, -0.18239123f, 0.04604765f, 
    -0.08507701f, -0.01772173f, -0.46467859f, 0.04865219f, -0.11710643f, -0.01384029f, 0.00864059f, -0.12387589f, 
    0.55533504f, 0.04532357f, 0.10234624f, 0.13291508f, 0.01741452f, 0.09730794f, -0.14869152f, -0.27811274f, 
    0.31068504f, -0.08832251f, -0.07880745f, -0.04961779f, -0.07794273f, 0.05029830f, -0.25138232f, 0.05767697f, 
    -0.00822635f, 0.03222816f, -0.09254747f, -0.18846355f, -0.15161844f, -0.04882369f, -0.03498066f, 0.15527032f, 
    -0.00374035f, -0.19204840f, -0.82979071f, -0.15081514f, -0.17891660f, -0.00350401f, 0.02324620f, -0.04771074f, 
    0.11112710f, -0.05588337f, 0.05987645f, -0.02207924f, 0.05313417f, 0.02395000f, 0.08422943f, 0.22287442f, 
    0.02263802f, -0.04997790f, 0.08197159f, 0.10626297f, 0.21887670f, -0.04704146f, 0.00435940f, 0.07424728f, 
    0.16632807f, -0.02538382f, 0.21159814f, 0.05681911f, 0.00628088f, 0.27095658f, 0.14958692f, 0.15331769f, 
    0.08437651f, 0.03160118f, 0.08018019f, -0.10314637f, 0.13631512f, 0.15686564f, 0.25506356f, -0.01519936f, 
    -0.01989522f, 0.18863519f, 0.26343834f, 0.02513731f, 0.04580545f, -0.06200765f, 0.06950055f, 0.13540041f, 
    0.03327900f, -0.21330455f, 0.11136384f, 0.00378653f, 0.21859077f, -0.07153833f, 0.11983925f, -0.01148732f, 
    0.10705693f, 0.05105913f, -0.14435309f, 0.23131190f, -0.08713520f, -0.10873336f, -0.04842369f, 0.04811458f, 
    0.04257837f, 0.13645920f, 0.04580595f, -0.16888285f, -0.21920617f, -0.20712103f, 0.08235729f, 0.01468461f, 
    0.04143135f, -0.05815173f, 0.52364761f, 0.15077800f, 0.05487840f, 0.01920489f, -0.02529038f, 0.12336726f, 
    -0.08452141f, 0.01961575f, 0.18854398f, 0.28677562f, 0.26220682f, 0.00618988f, -0.09482411f, 0.01997839f, 
    0.07163919f, -0.08581920f, -0.03127789f, 0.03630170f, 0.08391256f, -0.26707324f, -0.16439250f, 0.09453994f, 
    -0.01418881f, -0.05842203f, 0.12894984f, -0.11794695f, 0.12909435f, -0.35469308f, 0.09655684f, 0.00276918f, 
    0.06110250f, 0.10786670f, 0.05460754f, -0.04691623f, -0.05589118f, -0.05939566f, -0.22996069f, -0.02461964f, 
    0.17974018f, -0.09414101f, 0.13365723f, 0.03770961f, 0.04100301f, 0.10392276f, -0.08000961f, -0.04386468f, 
    0.09605134f, 0.10737104f, 0.01125685f, 0.06881264f, 0.07198688f, -0.09786934f, 0.10327601f, 0.04087650f, 
    -0.15396181f, -0.07263457f, 0.04739921f, -0.08569799f, 0.02548187f, 0.03071424f, 0.09104985f, 0.07742888f, 
    -0.00456724f, 0.44739577f, 0.00890540f, -0.12723187f, -0.13936415f, -0.21037361f, -0.04878739f, 0.28233108f, 
    -0.05520903f, 0.02021059f, -0.72647232f, -0.05682612f, 0.12066155f, -0.03293490f, 0.08718873f, 0.06053092f, 
    -0.00215352f, -0.00565924f, 0.00518392f, -0.16183229f, -0.08978180f, -0.11810625f, 0.03846399f, 0.14527483f, 
    -0.00409218f, 0.19920085f, -0.16576308f, 0.08993899f, 0.13691680f, 0.01053164f, -0.02395212f, 0.11975513f, 
    0.00511805f, 0.03926035f, 0.08313116f, 0.05556022f, -0.03339688f, 0.25858647f, 0.18507473f, -0.09983146f, 
    0.22912535f, -0.09323127f, 0.02411228f, -0.02346533f, 0.08094341f, 0.04564264f, -0.01468415f, 0.16835503f, 
    -0.30384687f, -0.13277934f, -0.06971221f, 0.03624151f, 0.18033884f, -0.04116743f, 0.03423914f, 0.10940257f, 
    -0.15982999f, -0.09101003f, -0.02305602f, 0.05700057f, -0.07557621f, -0.00631663f, -0.04262924f, 0.13611345f, 
    -0.04104053f, 0.04629158f, -0.07791485f, -0.06060156f, 0.02099687f, 0.01768878f, -0.04074448f, 0.00620353f, 
    -0.04086206f, 0.02550778f, -0.03147256f, -0.04239199f, -0.01919428f, -0.07837158f, 0.03524468f, 0.03419113f, 
    -0.05390804f, 0.01106818f, -0.05556629f, 0.02051895f, -0.01526553f, 0.00321887f, 0.00566650f, -0.06243761f, 
    0.01610992f, -0.04046097f, -0.02719892f, 0.03428770f, -0.01428350f, 0.01656323f, -0.01869138f, -0.03861103f, 
    -0.05537470f, -0.01943555f, -0.04302638f, -0.03848790f, 0.04958760f, -0.00358978f, -0.06108204f, -0.04917686f, 
    -0.00902342f, -0.08201596f, -0.01376956f, 0.03078140f, -0.04417491f, -0.01270032f, -0.05247267f, -0.00056110f, 
    -0.00217240f, -0.05221000f, -0.02401185f, 0.05559444f, -0.03072555f, -0.01505429f, 0.00775241f, -0.06144221f, 
    -0.05471513f, -0.02531440f, -0.06759826f, -0.03762500f, -0.08043570f, 0.00623239f, 0.00728047f, 0.01683961f, 
    0.04138114f, -0.05272488f, -0.08840135f, -0.02301127f, -0.02899276f, -0.07483549f, -0.00031898f, -0.07901883f, 
    0.00435007f, 0.06660417f, -0.01761228f, -0.06799425f, 0.01275114f, 0.00805607f, -0.04340634f, -0.04251415f, 
    0.00140226f, -0.00851527f, 0.01709463f, -0.03503420f, -0.01876094f, -0.00394668f, -0.03773412f, -0.01007154f, 
    -0.06672452f, 0.01134400f, 0.02535434f, -0.03344655f, 0.01028829f, 0.03909038f, -0.03063217f, 0.03375097f, 
    0.05791780f, -0.02845938f, 0.02279940f, -0.01882960f, 0.04709326f, -0.06397773f, -0.02627164f, 0.03286102f, 
    0.03114535f, -0.04643060f, 0.01056160f, -0.02530631f, 0.02232839f, 0.02848459f, -0.02956242f, -0.04678738f, 
    0.00011182f, 0.03043870f, -0.03561841f, -0.07553614f, -0.03307252f, -0.05538533f, 0.01662646f, -0.00010400f, 
    -0.05355555f, -0.07527800f, -0.03240608f, 0.05651740f, 0.00365009f, -0.04143408f, 0.01422135f, 0.02565444f, 
    -0.02211870f, 0.02141344f, -0.02689283f, -0.07663594f, -0.03435405f, -0.03262898f, -0.03308283f, 0.01042025f, 
    0.03494682f, 0.03742876f, -0.00789000f, 0.01788705f, -0.06277597f, 0.02469024f, -0.06687304f, 0.02114108f, 
    0.02267238f, -0.04871421f, -0.01009394f, 0.00443036f, -0.00277231f, -0.05352022f, -0.05066878f, 0.00440531f, 
    -0.04583311f, -0.03953256f, -0.02350134f, -0.06544586f, 0.03498160f, 0.01699016f, -0.06441060f, 0.01058829f, 
    0.00764283f, 0.03403602f, 0.02059941f, -0.05928592f, -0.04259963f, -0.04895788f, 0.05300920f, -0.01673278f, 
    0.02809627f, -0.03038689f, -0.01157713f, -0.01404400f, -0.06474452f, 0.00133510f, -0.05671566f, -0.06315637f, 
    0.03917290f, 0.02388777f, -0.05620809f, -0.05998974f, 0.03461231f, 0.02849866f, 0.02405674f, 0.02306158f, 
    0.03429390f, -0.03444212f, -0.00518872f, 0.04354402f, 0.02269628f, -0.03236640f, -0.01103463f, 0.00652764f, 
    0.04181508f, -0.01442342f, -0.04530988f, -0.03257706f, -0.08483782f, -0.03140038f, 0.04712797f, 0.00590706f, 
    0.02643060f, 0.01554608f, -0.06134544f, -0.00634405f, -0.03379999f, 0.03946746f, -0.02291709f, 0.00669268f, 
    0.02559686f, -0.01760410f, -0.04193598f, -0.03770554f, -0.01044461f, -0.02837085f, 0.03420387f, 0.01525731f, 
    -0.01198899f, -0.05834489f, 0.00008704f, -0.05715935f, -0.05913172f, 0.01852772f, -0.06590549f, 0.03531129f, 
    -0.01652141f, -0.00384482f, -0.02407049f, -0.02012788f, 0.02714720f, -0.01837691f, -0.00803541f, 0.05846091f, 
    -0.01418289f, 0.00556307f, 0.06378751f, -0.02901362f, -0.08114527f, -0.07888053f, -0.06652430f, -0.03342812f, 
    -0.03566744f, 0.01644532f, -0.00154367f, -0.02171856f, 0.00252712f, 0.02652641f, 0.01744504f, -0.03057331f, 
    0.02732161f, -0.01851514f, -0.05915073f, -0.04525132f, -0.00100491f, -0.04949119f, 0.00721951f, -0.06320573f, 
    -0.02716514f, -0.04250503f, 0.00863447f, -0.06225132f, -0.06863709f, 0.00287752f, 0.03216712f, -0.03981762f, 
    0.02367467f, -0.06122946f, -0.01201920f, 0.03954066f, -0.06029582f, -0.04165278f, 0.04413649f, -0.05138056f, 
    -0.03465357f, 0.06098376f, 0.03037564f, -0.00442295f, 0.02557091f, -0.01077448f, -0.01283161f, 0.00045830f, 
    -0.01341674f, -0.05300829f, -0.00799655f, 0.01762440f, -0.05737957f, -0.05976232f, 0.03240024f, -0.01061240f, 
    0.28874296f, -0.09549248f, -0.02694770f, 0.06542774f, 0.04820829f, 0.09707057f, 0.01711914f, 0.09257799f, 
    0.00315379f, 0.20851466f, 0.06025484f, 0.08671680f, -0.36153650f, 0.01585984f, -0.08892044f, -0.13565190f, 
    0.09644470f, 0.04224851f, -0.08661558f, 0.15155959f, 0.25422183f, -0.15139593f, -0.02143728f, 0.01804922f, 
    -0.14389151f, 0.02913672f, 0.11089371f, 0.13254265f, 0.13126339f, 0.04412683f, -0.05952637f, 0.02229806f, 
    -0.34227946f, 0.15444288f, 0.11423350f, 0.09287818f, 0.06614780f, 0.06372938f, -0.13854325f, -0.11786633f, 
    -0.10207066f, 0.13068233f, 0.35528162f, -0.02369992f, 0.07317676f, -0.04195258f, -0.04601432f, -0.37409189f, 
    -0.03333462f, -0.00955591f, -0.28065956f, 0.00697301f, 0.32362604f, 0.18387610f, -0.42398018f, -0.03766073f, 
    -0.16133957f, 0.03487969f, -0.01407209f, 0.01578156f, -0.06314464f, -0.06158990f, -0.13190860f, 0.04856842f, 
    -0.13380365f, 0.27357337f, -0.29586026f, 0.14966752f, 0.04147069f, 0.02812966f, -0.01419653f, 0.09253287f, 
    0.29145905f, 0.32079041f, -0.16241319f, -0.07556806f, 0.13547742f, -0.02238329f, -0.00316465f, -0.19981909f, 
    0.00456623f, -0.07925205f, 0.19293229f, 0.07843712f, 0.02442773f, 0.02804950f, 0.17743231f, -0.01759048f, 
    -0.15874344f, -0.04465278f, -0.24832608f, 0.22714421f, 0.07965329f, -0.03407016f, 0.07878149f, 0.11825132f, 
    0.02268828f, 0.10316695f, 0.03448193f, -0.38361725f, 0.23962298f, -0.03818096f, 0.12688632f, 0.05049082f, 
    0.06198352f, -0.12726741f, -0.00033269f, -0.01067913f, -0.28380463f, -0.42915735f, -0.42594039f, -0.11849084f, 
    -0.12822802f, 0.03320316f, -0.19247614f, 0.09672391f, 0.06483483f, -0.31199250f, 0.11589311f, 0.11085932f, 
    -0.28651294f, -0.02014584f, -0.11798522f, -0.02380172f, 0.05545934f, 0.21887189f, -0.05722072f, -0.09806445f, 
    0.10569447f, 0.12579982f, 0.13367337f, -0.14007382f, 0.13922037f, -0.08940139f, -0.03444675f, 0.20820090f, 
    0.18296428f, -0.19012244f, -0.12647620f, 0.04909264f, 0.00215834f, 0.31998491f, 0.06836314f, 0.07393226f, 
    -0.54866755f, -0.05899807f, 0.37265068f, 0.07631347f, 0.06350833f, -0.09501861f, -0.03658165f, 0.02735829f, 
    0.13465154f, -0.29342967f, 0.21692209f, -0.04929194f, 0.03841229f, 0.12232173f, 0.14827402f, -0.07028471f, 
    0.04283993f, -0.08779514f, -0.40741694f, -0.04311909f, -0.14362578f, 0.07159708f, 0.05290182f, -0.16877855f, 
    0.10608289f, 0.15232413f, 0.15252984f, -0.05302691f, 0.24350791f, -0.33219853f, 0.07983832f, 0.12683348f, 
    0.08550930f, 0.05470372f, -0.10016987f, 0.09175153f, -0.11797182f, -0.06732386f, -0.16663751f, 0.01992765f, 
    0.05870327f, -0.12756258f, -0.06063426f, 0.11283766f, 0.17555928f, -0.03900109f, 0.03043846f, -0.12801874f, 
    -0.19687966f, -0.13345656f, -0.26678473f, 0.04992796f, 0.06450384f, 0.09599721f, 0.17181928f, 0.05995586f, 
    -0.06749772f, -0.06417663f, 0.20635030f, -0.01258600f, 0.08692773f, -0.00008696f, 0.12794152f, 0.01146131f, 
    -0.10951970f, -0.04388470f, 0.15972042f, 0.11224189f, -0.04178124f, 0.04187042f, -0.03095928f, -0.04510136f, 
    -0.10014902f, 0.21726525f, -0.01113693f, 0.14728269f, 0.06105658f, 0.01804804f, 0.16441853f, 0.02546824f, 
    0.18537839f, 0.45806545f, 0.08129048f, 0.23774140f, -0.11990926f, -0.08735272f, -0.12820026f, -0.11646684f, 
    0.02240856f, 0.09824929f, 0.09194063f, 0.09969617f, 0.04363297f, -0.16819537f, 0.03777745f, 0.00521931f, 
    -0.11120819f, -0.00819477f, 0.02561323f, 0.00140224f, -0.19814916f, -0.01269180f, -0.01560367f, -0.00746513f, 
    -0.14337917f, -0.09188321f, 0.02499173f, 0.05030556f, -0.33292764f, -0.29042318f, 0.12587625f, 0.17150284f, 
    0.09848748f, 0.02597131f, -0.04185199f, 0.03904806f, -0.17933494f, -0.39308462f, 0.32439464f, 0.26909924f, 
    -0.39047629f, 0.00286468f, -0.10492298f, -0.14708309f, 0.00364342f, 0.09225936f, 0.10637026f, 0.05142039f, 
    -0.01277070f, 0.07917845f, 0.07743974f, 0.02265380f, 0.03155003f, 0.02286032f, -0.16948700f, 0.40821931f, 
    0.01673679f, -0.11892514f, -0.01965332f, -0.05028710f, -0.10707974f, 0.17555238f, 0.06493739f, 0.01764010f, 
    0.09062139f, 0.15157966f, 0.15408348f, -0.02322827f, 0.04801329f, 0.00191952f, 0.08155922f, 0.05638891f, 
    -0.06583227f, 0.44910640f, 0.15581584f, 0.11410856f, -0.00758759f, -0.24276181f, 0.03600650f, 0.13791950f, 
    -0.01619386f, 0.11602128f, -0.41962585f, -0.12148353f, -0.04497576f, -0.01632354f, 0.20815718f, -0.02684506f, 
    -0.08569188f, -0.07137612f, -0.17858805f, 0.29113558f, 0.01154722f, 0.14366855f, -0.03141697f, 0.02731622f, 
    -0.19351266f, -0.03933415f, 0.08038854f, -0.06485184f, 0.05900432f, 0.01249354f, -0.03751360f, 0.01586208f, 
    0.02073297f, 0.04265837f, 0.13684839f, -0.01423498f, 0.02010647f, 0.27138740f, 0.14356071f, -0.08594801f, 
    -0.01881778f, -0.02822796f, -0.07043108f, -0.04512150f, 0.08393188f, 0.02556988f, -0.44261187f, 0.12504287f, 
    0.08442923f, -0.04517503f, -0.06845231f, -0.08130588f, 0.10043298f, 0.08433919f, 0.15498668f, 0.38485301f, 
    0.03499208f, -0.07852494f, 0.01024473f, -0.05178039f, 0.01170626f, -0.05358178f, 0.11007962f, -0.00234577f, 
    -0.31475249f, -0.05701219f, -0.12062912f, -0.07021824f, -0.04826447f, -0.07373402f, 0.00818502f, -0.06537604f, 
    -0.10865590f, -0.00824880f, -0.19763640f, -0.24096258f, -0.02790918f, 0.23385437f, 0.08010323f, -0.07347728f, 
    -0.11982015f, -0.15075983f, 0.27894381f, 0.08451257f, 0.10127330f, -0.17403533f, 0.03340891f, -0.10896184f, 
    0.07922173f, -0.09044620f, -0.05595936f, 0.02238147f, 0.21563856f, 0.00916497f, -0.17125855f, 0.10182004f, 
    0.08712898f, 0.15232611f, 0.01253421f, -0.01229249f, -0.22217028f, 0.03138124f, -0.00552250f, 0.02265114f, 
    0.04358545f, -0.14086781f, -0.00348562f, -0.00770969f, 0.00408066f, 0.16435969f, 0.10961495f, -0.10836019f, 
    0.12637043f, 0.02033673f, 0.06600841f, 0.05801192f, 0.09217332f, 0.03312062f, -0.01145375f, -0.06051859f, 
    -0.01991719f, 0.08709332f, 0.06258418f, -0.03025043f, 0.08035121f, -0.01004623f, 0.02276029f, -0.15805301f, 
    -0.12673727f, -0.11628118f, 0.08725020f, 0.03072191f, -0.02184185f, -0.09790410f, -0.05389100f, 0.08294760f, 
    -0.26977044f, 0.00091708f, -0.23816772f, 0.06468737f, 0.09481192f, -0.01964280f, -0.03488673f, -0.17686126f, 
    0.03161233f, 0.21437867f, 0.07750878f, -0.10252243f, 0.05013919f, 0.05704928f, 0.09826502f, 0.05243647f, 
    -0.16349630f, 0.06152964f, -0.07101639f, -0.08388228f, -0.38149819f, -0.00289329f, 0.01604613f, 0.06296842f, 
    -0.00608610f, 0.07552775f, -0.00432508f, -0.06966548f, 0.07769903f, 0.09013440f, -0.06833936f, -0.00957871f, 
    0.02407810f, -0.06374266f, -0.06819736f, 0.00921587f, -0.34638107f, -0.20904593f, -0.02379113f, 0.13095275f, 
    -0.07502090f, 0.00212537f, -0.07728844f, -0.05363164f, 0.17902598f, 0.42125973f, 0.06617196f, 0.10596249f, 
    0.12645303f, -0.13561870f, -0.10576407f, 0.08536381f, -0.01343009f, 0.06333812f, 0.15678111f, -0.03977344f, 
    -0.02190886f, 0.03910667f, -0.12847331f, -0.02386150f, 0.18096162f, 0.07373027f, 0.18221954f, 0.02155146f, 
    0.24560603f, 0.15446371f, 0.20855352f, 0.07339224f, 0.13508084f, -0.00249408f, -0.01218551f, 0.05472205f, 
    -0.13651133f, 0.13775328f, -0.31974480f, -0.03063906f, -0.02626090f, 0.10878456f, 0.02149050f, 0.20657167f, 
    -0.08561599f, -0.55031085f, -0.06946105f, -0.00586020f, 0.09391917f, -0.00972490f, -0.04122277f, -0.10641992f, 
    -0.02374914f, -0.15843883f, 0.34587052f, 0.18982174f, 0.10210802f, 0.07163312f, -0.27679995f, 0.12438411f, 
    0.26492584f, 0.05453271f, -0.13727489f, 0.18756406f, -0.13131425f, 0.04622326f, 0.09239809f, 0.00613459f, 
    -0.09719442f, -0.04834579f, 0.01043732f, 0.03378293f, -0.16331914f, -0.14070822f, -0.10631833f, -0.07546809f, 
    0.14186922f, 0.26071745f, 0.09622665f, -0.01072834f, -0.27499688f, 0.45804912f, 0.04846997f, -0.08927124f, 
    0.09556350f, -0.04509917f, 0.05674064f, 0.04019205f, -0.09871773f, 0.03501064f, -0.20720308f, 0.15763244f, 
    -0.19194095f, -0.00946003f, -0.06542229f, 0.06844754f, 0.12375940f, -0.04031309f, -0.15804195f, -0.12311063f, 
    0.01996014f, 0.00243615f, -0.04654244f, 0.05060014f, 0.01055950f, 0.09135587f, 0.04689619f, 0.09867327f, 
    -0.29030618f, 0.07545027f, 0.03532960f, 0.10589607f, -0.04941379f, -0.10447510f, -0.05034566f, 0.06891643f, 
    0.03049601f, -0.28965259f, -0.01772171f, -0.10270221f, 0.07978775f, -0.16159894f, 0.06242814f, 0.07796485f, 
    0.02634727f, 0.19870347f, -0.18879314f, 0.05498211f, 0.12982543f, -0.12080829f, 0.03117111f, -0.17232479f, 
    0.11757621f, 0.10409819f, -0.06922682f, 0.03975644f, -0.01917694f, -0.00297020f, 0.08364242f, -0.02137515f, 
    0.00936182f, -0.09356324f, 0.10404886f, 0.13001046f, -0.05975671f, 0.16725358f, 0.11278417f, 0.06776141f, 
    0.04448119f, -0.28856799f, 0.04590429f, 0.07821281f, -0.16926152f, 0.09242246f, 0.09420627f, 0.18039154f, 
    0.03829046f, -0.07398804f, -0.05837043f, 0.03095351f, -0.06343117f, 0.22132388f, -0.23670799f, 0.04400875f, 
    0.21749057f, 0.13992742f, -0.13028976f, -0.24739642f, 0.02667348f, -0.07948114f, -0.11665105f, -0.14165938f, 
    -0.19487604f, 0.02111647f, 0.08628888f, 0.19440010f, 0.13946383f, -0.21179619f, -0.15939420f, -0.29958236f, 
    0.21822797f, 0.10108963f, 0.03614097f, 0.07007603f, 0.00439902f, -0.23048514f, -0.02266491f, 0.05852235f, 
    -0.09648750f, -0.14246994f, -0.14754742f, -0.25003806f, 0.01051196f, -0.11727383f, 0.14291295f, 0.16191463f, 
    -0.13902798f, -0.15220407f, 0.02137963f, -0.06621391f, 0.04985342f, -0.08825194f, -0.04700539f, -0.17931029f, 
    0.10694721f, 0.03560443f, 0.37560028f, 0.16539554f, 0.16452457f, -0.09193623f, 0.28942230f, -0.04403099f, 
    -0.03960100f, 0.00758990f, -0.00829993f, 0.06818713f, 0.02382194f, 0.06613043f, -0.14415547f, 0.09987718f, 
    -0.07579054f, 0.16899052f, 0.11669745f, 0.02773536f, 0.03507314f, -0.30347911f, -0.17882101f, 0.05813905f, 
    0.01892036f, 0.25155580f, -0.05478697f, 0.06333421f, 0.00761391f, 0.19300108f, 0.00647359f, -0.06723408f, 
    -0.39609563f, 0.01889918f, 0.14317238f, 0.19310059f, -0.24986148f, -0.13028353f, -0.28516391f, 0.17574382f, 
    -0.04497850f, -0.02791016f, -0.02497523f, -0.05159958f, 0.03111501f, -0.01599642f, -0.07540623f, -0.06977545f, 
    -0.04140738f, -0.02535688f, -0.18377422f, -0.05870524f, 0.17988430f, 0.03642973f, 0.25894475f, -0.00185595f, 
    -0.12771501f, 0.13642563f, 0.07163917f, 0.10445543f, -0.08480200f, -0.04413316f, 0.02279532f, 0.11282950f, 
    0.05206081f, -0.01208827f, -0.18652752f, -0.09850403f, -0.45819506f, 0.04049201f, -0.00523346f, 0.29690751f, 
    -0.03422028f, 0.00662970f, -0.17990062f, 0.30231789f, 0.28440413f, 0.25396529f, 0.00418268f, 0.00206687f, 
    -0.14725356f, 0.19181342f, 0.15299550f, -0.01701803f, -0.01017201f, -0.17665516f, -0.25326264f, -0.00558768f, 
    0.07453661f, 0.00776876f, -0.01345238f, -0.17888083f, -0.02123935f, 0.11277370f, -0.05194321f, -0.29252848f, 
    0.00462331f, -0.02741569f, -0.05440997f, -0.05284622f, 0.09105287f, 0.26300386f, -0.30110937f, 0.06894960f, 
    0.06636514f, 0.21221650f, -0.02572136f, 0.01972689f, -0.08209964f, -0.01579176f, 0.00817637f, -0.31425634f, 
    0.09286088f, 0.20023586f, 0.08222267f, -0.05162453f, -0.06635826f, 0.21402068f, 0.14889288f, 0.10415882f, 
    -0.04413468f, -0.05901866f, 0.18947861f, -0.00033116f, 0.02095131f, 0.02564379f, -0.00169334f, 0.14885683f, 
    0.11074740f, -0.07897460f, -0.05496204f, -0.05260991f, 0.14131795f, -0.01229591f, 0.11835997f, 0.08245915f, 
    0.02653574f, 0.06059963f, -0.08810204f, 0.00736512f, 0.04237885f, 0.24268450f, 0.06390230f, -0.10731896f, 
    -0.06956867f, -0.05939588f, 0.12906662f, -0.04355586f, -0.17158972f, 0.00126642f, 0.17456207f, 0.09570824f, 
    -0.04445970f, 0.05289941f, -0.07197019f, -0.15088637f, -0.06879313f, -0.08907762f, -0.18989231f, 0.04368541f, 
    -0.08132578f, 0.18041684f, 0.14409599f, -0.00498946f, -0.12108047f, -0.33440015f, -0.40385643f, 0.11652376f, 
    0.09610175f, -0.04903661f, -0.00068923f, 0.01263383f, -0.19474515f, -0.13917905f, 0.01174340f, 0.13394697f, 
    0.00529636f, 0.12901962f, 0.04965037f, -0.12582844f, -0.04013682f, 0.22666989f, -0.08569587f, 0.09279640f, 
    0.13202442f, 0.04318080f, 0.03272051f, -0.04131288f, 0.03029315f, 0.00406497f, 0.01393736f, -0.05176016f, 
    -0.15349385f, -0.17158258f, -0.09526301f, -0.07982428f, -0.00280147f, -0.07002468f, 0.07321452f, -0.11329585f, 
    -0.08824968f, -0.23532116f, -0.31452379f, 0.11923484f, 0.12018123f, 0.02224001f, -0.09167548f, 0.00426542f, 
    0.02500706f, -0.09865417f, 0.13974278f, 0.07717125f, 0.02175523f, 0.05585946f, -0.09565616f, 0.16985716f, 
    -0.13146669f, 0.06352559f, 0.07364913f, -0.06455807f, -0.38152936f, -0.08764244f, -0.05551039f, 0.09149671f, 
    0.09206647f, -0.06572001f, -0.01383206f, 0.06055458f, -0.18272854f, 0.02118961f, -0.12105559f, 0.18002796f, 
    0.15973371f, -0.01445047f, -0.16423859f, 0.00733290f, 0.17556480f, 0.04259018f, -0.10579885f, 0.01760657f, 
    0.05726565f, 0.02934210f, 0.01064331f, -0.03242727f, -0.00791990f, -0.03593824f, -0.16939521f, 0.09273738f, 
    -0.08276778f, -0.10179824f, -0.11529949f, -0.10822791f, -0.17689826f, 0.11537614f, 0.22900514f, 0.16727445f, 
    0.05361995f, -0.27155289f, 0.19447763f, 0.08460795f, -0.08407384f, -0.07698230f, -0.17011628f, -0.10151645f, 
    0.06626591f, 0.28344572f, 0.20630942f, -0.02364010f, 0.15290032f, -0.11161819f, 0.11850749f, 0.16062635f, 
    0.24798422f, -0.00338762f, 0.27942887f, 0.25036258f, 0.02809462f, 0.06898133f, 0.07174429f, -0.07136876f, 
    0.06489205f, -0.17807060f, 0.09201138f, -0.14017685f, -0.41439766f, 0.08390460f, -0.08655265f, 0.22808602f, 
    -0.00236229f, 0.15718904f, -0.09388670f, 0.05487334f, 0.10418460f, -0.13126788f, -0.13749869f, -0.04849172f, 
    0.01712174f, -0.01702658f, -0.06697886f, 0.03739611f, -0.01155827f, -0.00819710f, 0.01354137f, -0.13928710f, 
    -0.04072025f, -0.08791947f, 0.02370864f, -0.00943328f, -0.03247380f, 0.14875205f, -0.10156889f, 0.27675435f, 
    0.17240819f, -0.02061848f, 0.27203712f, 0.03988241f, -0.01123347f, -0.02455181f, 0.24377455f, -0.12478236f, 
    -0.12687463f, 0.04521806f, 0.05953750f, -0.03398567f, 0.17308450f, -0.08057740f, -0.10496382f, -0.02056878f, 
    -0.13032065f, -0.13619432f, -0.17217389f, 0.16468877f, 0.06340036f, -0.11228465f, 0.07211461f, 0.05656847f, 
    0.31527570f, -0.02078317f, -0.19828084f, -0.08192586f, -0.11427393f, -0.22134456f, -0.08366647f, 0.07128966f, 
    -0.10319187f, -0.00115261f, 0.12137905f, 0.01854940f, 0.02831200f, -0.13395186f, -0.10223098f, -0.06526834f, 
    0.17135392f, -0.00888438f, 0.20866327f, 0.20362407f, 0.15734313f, 0.03758146f, 0.03608609f, 0.03254588f, 
    -0.01513504f, -0.08606800f, 0.04742411f, 0.11568841f, 0.01202931f, 0.07585113f, -0.00888606f, 0.12024401f, 
    -0.01143726f, -0.00907087f, 0.10469170f, 0.11481191f, 0.56991619f, -0.30443692f, 0.22425476f, -0.16702569f, 
    0.01660866f, -0.19175501f, 0.02179583f, -0.04126564f, -0.06559580f, -0.33573127f, -0.32744303f, 0.15096804f, 
    0.03435591f, 0.15981261f, 0.05766673f, 0.13341331f, 0.01633273f, -0.13501121f, -0.22738570f, -0.00355969f, 
    0.03233115f, 0.18094689f, 0.05884530f, 0.13824661f, -0.14656116f, 0.00027304f, 0.00448144f, 0.08257839f, 
    -0.30153337f, -0.23944099f, 0.04946789f, -0.01855017f, -0.19800259f, -0.06396816f, 0.01468474f, -0.10998103f, 
    0.07675154f, 0.09148829f, -0.09755068f, -0.04262187f, -0.18423551f, 0.01478185f, -0.02313713f, -0.00211407f, 
    -0.02888378f, -0.02945977f, -0.00851338f, 0.30543816f, -0.04416395f, -0.08899718f, 0.04125210f, -0.16723379f, 
    0.10638721f, 0.04709721f, -0.11989311f, -0.35693085f, -0.18357402f, 0.08099983f, 0.03752168f, 0.22119233f, 
    0.00124719f, 0.07340952f, -0.19557077f, 0.18543160f, 0.12892921f, -0.24499133f, 0.01616666f, 0.04463336f, 
    0.00422542f, 0.02422206f, 0.04040639f, 0.03493764f, -0.02650814f, 0.21845295f, 0.02285932f, -0.02469112f, 
    -0.05042842f, -0.07283787f, 0.14400850f, -0.21250543f, -0.14690442f, 0.61086494f, 0.00968178f, -0.19106871f, 
    0.00994227f, -0.00022895f, 0.03592951f, 0.05042151f, 0.11544561f, -0.31222901f, 0.26255512f, 0.14522627f, 
    0.14982654f, -0.04794417f, -0.02939190f, 0.10023184f, 0.05535347f, 0.04028787f, -0.01464149f, -0.15258403f, 
    -0.19624211f, -0.03722812f, -0.02293156f, 0.09631120f, -0.11168204f, -0.00094375f, 0.05019360f, -0.11112438f, 
    -0.04210559f, 0.02735499f, 0.04729561f, 0.02616453f, 0.03029221f, 0.03319062f, -0.02586770f, -0.07099646f, 
    -0.06045792f, -0.01218611f, -0.02877151f, -0.00723313f, -0.02798334f, 0.02033086f, -0.00150239f, -0.00831956f, 
    -0.00346843f, -0.02852391f, -0.05785871f, -0.00845842f, -0.03918303f, 0.04998660f, 0.03663656f, 0.01379607f, 
    -0.05446545f, 0.04790652f, 0.03823062f, -0.03270042f, -0.06492628f, 0.00943486f, -0.06583512f, -0.01786725f, 
    -0.06837433f, -0.03485446f, 0.00516310f, -0.06503177f, 0.02051358f, 0.00140433f, -0.01184718f, 0.00047310f, 
    -0.01430852f, -0.05416220f, 0.01617705f, -0.02179264f, -0.02714501f, -0.01940096f, -0.05518741f, 0.02881820f, 
    0.04570991f, -0.01588777f, -0.03510826f, -0.00446371f, -0.01532259f, -0.02038298f, -0.06510866f, 0.00923917f, 
    -0.04712182f, 0.03574660f, 0.05090370f, -0.02628243f, 0.00658992f, -0.06096737f, 0.01584535f, -0.02920429f, 
    -0.01525160f, 0.01026822f, 0.00076959f, 0.00478905f, -0.01161887f, 0.00394459f, -0.04625175f, -0.06085835f, 
    0.04117272f, -0.03215388f, -0.05915942f, -0.00115448f, 0.00583916f, 0.01936333f, -0.02784942f, -0.00611123f, 
    -0.05727905f, -0.06499849f, 0.00610137f, -0.02629290f, -0.02792232f, -0.04961139f, -0.02353184f, 0.03370982f, 
    -0.05301255f, -0.04800949f, -0.02903990f, 0.03989409f, 0.01911722f, -0.00424633f, 0.03033996f, -0.04331086f, 
    -0.06270616f, 0.01277752f, -0.05576679f, 0.02287848f, -0.05296142f, 0.01993979f, 0.01918102f, 0.03476603f, 
    0.04229734f, -0.04504728f, 0.02327840f, 0.00769934f, 0.03944112f, 0.01164638f, 0.01276689f, 0.01033115f, 
    -0.02031653f, -0.01852275f, 0.00143776f, -0.00413576f, 0.03544505f, -0.04193084f, -0.03982269f, 0.03891538f, 
    0.04507265f, -0.00804859f, -0.02150203f, -0.00297866f, -0.00025636f, -0.05914505f, 0.03213769f, 0.01285111f, 
    0.02223049f, 0.00757622f, -0.00763888f, -0.00589940f, -0.05978468f, 0.01223332f, -0.02552562f, -0.04384238f, 
    0.01199434f, 0.01302510f, -0.01822335f, 0.02515669f, 0.03799736f, 0.04255405f, 0.01342798f, -0.02756671f, 
    0.00540144f, 0.02116275f, -0.05850890f, 0.01766316f, -0.01510904f, -0.00895071f, 0.03148652f, 0.03364855f, 
    -0.05605457f, 0.03797159f, 0.04188259f, -0.05422319f, -0.03173495f, -0.02865375f, 0.02119426f, -0.03280612f, 
    0.02574481f, -0.00772296f, 0.00394249f, 0.02447303f, 0.00692542f, -0.03969320f, -0.02897022f, -0.01850636f, 
    -0.03505830f, -0.03341204f, 0.03230792f, -0.02303446f, -0.02790199f, -0.02249070f, -0.04534918f, -0.05399881f, 
    0.04057140f, 0.04117070f, -0.03528786f, 0.04264158f, 0.04046326f, 0.02885775f, -0.04265069f, 0.05839660f, 
    0.04147481f, 0.04100655f, 0.04538760f, -0.03337219f, -0.00437103f, -0.07009169f, -0.06159092f, -0.01695188f, 
    0.02926730f, -0.04327961f, -0.05897838f, -0.04980682f, 0.02168775f, 0.03326724f, -0.00569421f, 0.03620310f, 
    -0.01779972f, -0.03882217f, 0.03726678f, -0.05340404f, -0.05015504f, 0.00574001f, -0.04695981f, -0.00711580f, 
    0.04292382f, -0.01773171f, -0.05898418f, -0.03867022f, -0.02048584f, -0.00262300f, 0.04075256f, 0.00673536f, 
    0.02803037f, 0.01192283f, -0.03969045f, -0.02434624f, -0.01289568f, 0.01843317f, 0.03473565f, -0.02386145f, 
    -0.05549933f, 0.04693935f, 0.02605394f, -0.02478658f, 0.03251785f, -0.01332781f, -0.05416980f, -0.02249520f, 
    -0.02040500f, -0.01847184f, -0.05862577f, -0.02759425f, 0.01652896f, -0.06566282f, -0.04103016f, -0.05554136f, 
    -0.05195149f, 0.04688019f, -0.04391318f, -0.03533219f, -0.01458529f, -0.01717510f, 0.00694296f, -0.02003736f, 
    -0.03676825f, -0.04524258f, 0.00906171f, 0.01975088f, -0.02124729f, 0.01361191f, 0.02384920f, -0.03019737f, 
    -0.02500259f, -0.05547466f, -0.06732450f, 0.03789702f, -0.00014219f, 0.00253663f, -0.00767120f, 0.03527515f, 
    -0.04088274f, 0.01633563f, 0.00606412f, -0.04830839f, -0.04028562f, 0.03515254f, -0.02385095f, 0.02129496f, 
    -0.01294328f, -0.02685138f, -0.04436275f, -0.00824168f, 0.05207025f, 0.02572798f, -0.04641857f, 0.03017919f, 
    -0.02492880f, -0.02907608f, 0.05028879f, -0.05085341f, -0.02262016f, 0.04406250f, 0.02023688f, 0.04455232f, 
    0.02325416f, -0.04210162f, -0.05467860f, 0.05031983f, -0.04734846f, -0.00485360f, -0.04202817f, 0.03264308f, 
    -0.03699874f, 0.03564411f, -0.01499662f, 0.03546295f, -0.02893430f, -0.01371003f, -0.01047929f, 0.04102435f, 
    -0.05653455f, 0.02693448f, -0.02028970f, -0.02117647f, -0.02180410f, -0.06331314f, 0.04490035f, 0.00201206f, 
    0.02726113f, -0.04176192f, -0.03609928f, 0.02126891f, 0.04075584f, -0.05074820f, -0.04464950f, -0.04859826f, 
    0.02456238f, -0.00870904f, -0.01399573f, -0.06214722f, 0.02475105f, -0.04020621f, 0.02095952f, 0.00189820f, 
    -0.01846264f, 0.02998168f, -0.01834023f, 0.00750923f, -0.01973379f, -0.03366311f, -0.03285920f, 0.01389137f, 
    -0.02613190f, 0.03639324f, 0.01856923f, -0.06251269f, -0.03564171f, -0.03393534f, 0.01614149f, -0.02967118f, 
    0.04261881f, -0.00595267f, 0.00712688f, -0.00580830f, -0.01072134f, -0.01405887f, -0.01687643f, -0.06127687f, 
    0.00197952f, -0.04007019f, 0.04266003f, 0.00209614f, -0.00472479f, -0.03970367f, 0.05132069f, 0.01142369f, 
    0.00669554f, -0.00464080f, -0.00415918f, 0.03908543f, -0.02026208f, 0.01426652f, 0.04406376f, -0.05845333f, 
    -0.04543412f, -0.04381956f, -0.02647915f, -0.04298394f, 0.02381415f, 0.04957955f, -0.01028907f, -0.01007918f, 
    0.04593347f, -0.02277601f, 0.02208157f, -0.04201362f, 0.02598095f, 0.03512681f, 0.01817666f, -0.04501806f, 
    0.00384856f, -0.03865259f, -0.05226959f, -0.06522217f, 0.00470958f, 0.02579454f, -0.03743241f, -0.05964060f, 
    0.00705226f, 0.03814906f, 0.00697117f, -0.03425520f, -0.04872528f, -0.04524283f, -0.05111706f, -0.01738182f, 
    -0.04234513f, -0.02632194f, -0.02614129f, -0.03078466f, -0.03059573f, -0.04279236f, -0.01922604f, 0.00412701f, 
    0.01612503f, 0.01159126f, -0.04360062f, 0.01818047f, -0.05747998f, -0.03704840f, -0.01824754f, -0.06444682f, 
    0.03946983f, 0.02180632f, 0.01770027f, -0.01217132f, 0.00907269f, -0.03152031f, -0.02405482f, -0.05081661f, 
    0.00004480f, -0.05694574f, 0.03411419f, -0.01904020f, 0.03875319f, -0.01573830f, -0.04889245f, 0.00416806f, 
    -0.00129373f, -0.02402271f, 0.04984191f, -0.02049422f, 0.00324946f, 0.02024377f, -0.05528155f, -0.01697090f, 
    0.03757322f, 0.01424117f, -0.00567243f, -0.03726783f, -0.02305233f, -0.05943640f, 0.02014770f, -0.01170341f, 
    -0.02771243f, 0.03157964f, 0.05237680f, -0.01519389f, 0.02200211f, 0.00541847f, 0.00994884f, 0.01319001f, 
    -0.00505410f, -0.03554500f, -0.02368265f, 0.01936357f, -0.00738072f, 0.03272277f, 0.01334351f, -0.06137481f, 
    0.04355615f, 0.02885279f, -0.01968783f, -0.01823195f, -0.02223739f, 0.04839029f, -0.05109508f, -0.04869251f, 
    0.00916477f, -0.03257010f, 0.01696755f, -0.04055339f, 0.03898752f, -0.05023589f, 0.03902064f, -0.00418582f, 
    0.03830351f, -0.01372791f, -0.05317269f, -0.05850903f, -0.00004511f, -0.00404757f, 0.04860122f, -0.03337192f, 
    -0.03901571f, -0.00609277f, 0.03539314f, -0.06260549f, 0.01614198f, 0.02818783f, 0.03747373f, 0.00422816f, 
    -0.06430361f, 0.04350457f, -0.04902233f, 0.04303687f, -0.03566119f, -0.03947269f, 0.04391805f, -0.00020844f, 
    -0.06013054f, -0.05446811f, 0.04608798f, -0.01591115f, 0.04855596f, -0.02103717f, -0.00210986f, 0.04280332f, 
    -0.00109772f, -0.06106341f, 0.01608278f, -0.00052971f, -0.02878916f, -0.04775996f, 0.04998142f, -0.01188536f, 
    0.01981023f, 0.02355205f, -0.04409220f, -0.02574305f, 0.04411038f, -0.04231801f, -0.03227680f, -0.02318528f, 
    0.01471502f, 0.02685487f, -0.04952492f, -0.02207745f, 0.00158017f, -0.00104353f, -0.02870695f, 0.05005331f, 
    -0.02845647f, 0.03479987f, -0.00789490f, 0.03822355f, 0.04288666f, -0.05541852f, 0.01341324f, -0.03366969f, 
    -0.04551273f, -0.04755282f, -0.05190954f, 0.02206399f, -0.01753867f, 0.00973147f, 0.00891754f, 0.02955992f, 
    -0.02914785f, -0.06105834f, 0.03261370f, -0.02761897f, -0.04595537f, -0.01204172f, -0.04168765f, -0.04344732f, 
    -0.00813912f, -0.05530437f, -0.03020702f, 0.00768150f, -0.01771915f, -0.02614424f, -0.04772015f, 0.04379996f, 
    -0.03972551f, 0.02351893f, 0.01458532f, -0.01508184f, 0.04337079f, 0.02389107f, 0.03856491f, -0.05185509f, 
    -0.07315110f, 0.08658280f, -0.11105687f, 0.09820137f, 0.01536885f, -0.00023838f, 0.02758810f, 0.06349408f, 
    -0.08639514f, -0.02140059f, 0.07868215f, 0.03701080f, 0.16823892f, 0.19645631f, 0.17285381f, -0.02086989f, 
    -0.02321145f, 0.06767725f, 0.40138596f, -0.12029562f, -0.04099071f, -0.28504395f, 0.05645793f, -0.05804115f, 
    -0.12792930f, -0.09152437f, -0.08493365f, 0.00761127f, -0.10025748f, -0.10066659f, 0.03117669f, 0.02217080f, 
    0.20497338f, 0.13992421f, 0.10130116f, 0.14651805f, 0.02108742f, 0.15245333f, 0.19377075f, -0.08918107f, 
    0.00072711f, 0.01300072f, -0.01403376f, -0.06582743f, 0.10539351f, 0.23096712f, 0.05102623f, 0.09985637f, 
    -0.01691083f, 0.09569703f, 0.00846734f, -0.07069715f, 0.03164295f, 0.17603081f, 0.02105968f, 0.18585935f, 
    -0.48880205f, -0.36249313f, 0.10593883f, -0.06981250f, 0.20262130f, -0.08611456f, 0.00015032f, -0.12760170f, 
    0.17257002f, -0.03615142f, 0.12738544f, 0.04801265f, 0.05925384f, 0.26959565f, 0.07574604f, -0.13074908f, 
    0.40153712f, 0.10675564f, 0.29320839f, -0.11598732f, -0.14080815f, -0.00778478f, -0.14455916f, 0.07345107f, 
    -0.02198857f, -0.03515919f, 0.01528049f, -0.06190741f, -0.03538316f, -0.03936276f, -0.00275857f, -0.00166358f, 
    -0.13911654f, 0.13925569f, 0.11364815f, -0.26300439f, 0.01915309f, 0.05305297f, 0.16722453f, 0.15232070f, 
    -0.12956345f, 0.01362347f, 0.02698877f, 0.16210732f, -0.02943861f, 0.04890873f, -0.11684003f, -0.00800748f, 
    0.05551419f, -0.07164646f, 0.02194807f, 0.07133742f, 0.10489715f, -0.07172515f, -0.05043985f, -0.36530763f, 
    -0.03698672f, 0.09602514f, -0.08273713f, 0.11222556f, -0.07971432f, 0.02939348f, 0.02026553f, 0.03367649f, 
    -0.05450440f, 0.21654905f, -0.23365805f, -0.04209685f, 0.08582493f, -0.27558708f, -0.27788571f, 0.01440953f, 
    -0.24326189f, 0.10271876f, 0.13050392f, 0.02376008f, 0.06257479f, 0.24367097f, 0.02853846f, 0.12782529f, 
    0.03160546f, 0.08633360f, 0.10611746f, -0.10678601f, 0.07447664f, 0.02585277f, 0.08042461f, 0.14786413f, 
    -0.07614607f, -0.01615104f, 0.21265543f, -0.07384686f, -0.03581012f, -0.03865023f, -0.10655007f, 0.10874879f, 
    -0.03264296f, 0.06107775f, -0.10937265f, 0.47763020f, -0.20145188f, -0.15205881f, 0.04440828f, 0.03016504f, 
    -0.03865553f, -0.05461342f, 0.09648435f, 0.17019968f, -0.06384433f, -0.01818290f, -0.11401229f, -0.06763847f, 
    -0.01955540f, 0.00861172f, -0.13381980f, 0.08051203f, 0.19775750f, 0.39645854f, -0.13921440f, -0.15350123f, 
    0.05828706f, 0.02928259f, 0.02305709f, -0.02933726f, -0.05716584f, -0.25811279f, -0.07430770f, -0.07097733f, 
    -0.05614265f, 0.03556097f, 0.02013313f, -0.15032813f, 0.00577915f, -0.24445193f, 0.12106510f, -0.08314238f, 
    0.09966145f, 0.15758300f, 0.09569795f, -0.08638477f, -0.12754671f, 0.16333285f, -0.13162111f, 0.14498754f, 
    -0.09412273f, 0.09855177f, 0.05031046f, 0.08431677f, -0.01443651f, -0.00632435f, 0.09385459f, -0.19135897f, 
    0.05117468f, 0.01600770f, 0.01530399f, -0.14048576f, -0.10275508f, -0.17708099f, -0.09139393f, -0.05142379f, 
    0.10417303f, -0.09979483f, 0.25118610f, -0.18235239f, 0.08087782f, -0.17636701f, 0.04065808f, 0.14082515f, 
    0.20261696f, 0.50959212f, 0.13843644f, -0.03421002f, -0.19875909f, -0.00765520f, 0.11264168f, -0.04972075f, 
    0.12223551f, 0.02775454f, -0.03621898f, 0.16953123f, 0.02779722f, 0.23106954f, 0.09436917f, -0.01188833f, 
    -0.00337588f, 0.06102434f, -0.06346778f, 0.33263135f, -0.19291492f, -0.14647174f, 0.07468423f, 0.11039146f, 
    -0.04147524f, -0.10865963f, -0.01713601f, -0.00869263f, 0.12706564f, -0.12437016f, -0.25110453f, -0.08057882f, 
    -0.11813541f, -0.01803930f, -0.08201693f, 0.07772909f, 0.06267558f, -0.04147298f, -0.04231007f, 0.11233818f, 
    0.01016506f, 0.13597292f, 0.03370248f, 0.10693620f, 0.00622432f, -0.14417851f, -0.17835492f, 0.01845438f, 
    0.23705290f, 0.02430636f, 0.02788239f, 0.06874315f, -0.07511204f, -0.01014781f, -0.13606906f, 0.20888600f, 
    0.09936517f, -0.06780016f, 0.11023956f, -0.00081126f, 0.11354116f, 0.04409600f, 0.10669357f, 0.09508215f, 
    0.05210880f, 0.03519042f, 0.11267863f, -0.07673994f, -0.01254875f, 0.00721229f, 0.04463352f, 0.04218122f, 
    -0.06223683f, -0.17679703f, -0.28043473f, 0.00836664f, 0.01382618f, 0.09809840f, 0.06529979f, 0.08566564f, 
    0.05289789f, -0.16899286f, 0.04017593f, 0.11071774f, -0.16026092f, 0.01402355f, 0.02900928f, -0.01374161f, 
    0.11663542f, 0.05339025f, -0.06536981f, 0.12368789f, 0.08477051f, -0.11721175f, -0.01154266f, -0.07004087f, 
    0.18475497f, 0.17573261f, -0.05748744f, -0.08196278f, -0.06076649f, -0.05748894f, -0.17729189f, 0.05925204f, 
    0.01700909f, 0.04338589f, -0.01107460f, -0.06950219f, -0.05261531f, -0.24835306f, -0.00150094f, 0.00354129f, 
    -0.04410871f, -0.01092776f, 0.19329852f, 0.02323033f, 0.03674047f, 0.02058056f, 0.39711785f, -0.36791375f, 
    0.21399669f, 0.10583539f, 0.08901906f, 0.03075129f, 0.02772844f, 0.18136503f, -0.03605681f, -0.22158502f, 
    0.09186914f, 0.12593769f, 0.03645784f, 0.03274135f, -0.14257038f, 0.22158726f, -0.15612237f, 0.01714588f, 
    0.03426940f, 0.04587999f, -0.14061728f, 0.08960936f, -0.07842860f, -0.03239543f, -0.01194938f, 0.08571792f, 
    0.05675313f, -0.31014559f, 0.11912362f, 0.26315528f, 0.01917348f, -0.14902161f, 0.04834947f, -0.14699513f, 
    -0.00211554f, 0.04510871f, -0.24936156f, 0.09738395f, -0.14101771f, 0.03169796f, -0.18994929f, 0.07061921f, 
    0.09622367f, 0.01167701f, -0.06336001f, 0.05620814f, -0.23827401f, -0.03405167f, -0.03926393f, -0.00616311f, 
    0.05208157f, -0.00688828f, -0.07057979f, 0.09810118f, 0.15282951f, -0.09230071f, -0.08420791f, -0.16549267f, 
    -0.06244098f, 0.10060725f, -0.01009433f, 0.05333322f, -0.22505756f, -0.10577162f, -0.14315419f, 0.09901496f, 
    0.05907438f, -0.16222471f, -0.22487484f, -0.05724338f, -0.04954648f, -0.00846426f, 0.15390544f, 0.08367690f, 
    -0.05963165f, 0.07673426f, 0.03964056f, 0.01884903f, 0.01936455f, -0.10992639f, 0.07367083f, -0.21642996f, 
    0.09469577f, -0.01463104f, 0.01905789f, -0.14551489f, 0.26445144f, -0.09414146f, 0.15531741f, 0.10048651f, 
    0.15663621f, -0.04674893f, -0.00235199f, 0.07596926f, 0.24074395f, 0.04101369f, -0.05428021f, -0.09219322f, 
    0.02653638f, -0.13772956f, -0.11465894f, 0.03747158f, 0.05244670f, -0.06445933f, -0.02592710f, 0.03288636f, 
    0.13060321f, 0.04402797f, 0.22461921f, 0.11041794f, -0.03092765f, 0.21476217f, -0.21255171f, -0.03571844f, 
    -0.09907629f, 0.16158573f, -0.03998388f, 0.04917641f, -0.04129922f, -0.13729466f, 0.06380088f, -0.01250066f, 
    -0.11046876f, 0.03708583f, 0.14569636f, 0.07967815f, 0.42088091f, -0.10328606f, -0.01349887f, -0.06101483f, 
    -0.02683659f, 0.15132512f, -0.08232302f, 0.13115335f, 0.01664143f, -0.05428383f, -0.33833295f, 0.13263682f, 
    -0.01966325f, -0.09580254f, 0.15563588f, 0.10683838f, -0.09143407f, -0.11021714f, -0.09606563f, 0.17229377f, 
    0.19333577f, 0.09674410f, -0.00716594f, 0.03743868f, 0.04754190f, 0.03003147f, 0.05256788f, 0.19064310f, 
    0.03649108f, -0.13832827f, -0.03990345f, 0.04692704f, -0.14912255f, -0.06743526f, -0.04972517f, 0.03606822f, 
    0.09706324f, -0.16371287f, 0.09777600f, 0.07974317f, 0.06293317f, 0.07170969f, 0.00116590f, 0.02816363f, 
    -0.00219101f, 0.02963504f, 0.21260430f, -0.10228983f, -0.06209484f, -0.03008466f, -0.08565548f, 0.11147583f, 
    -0.04655297f, -0.15099461f, -0.31907627f, -0.11485581f, 0.04035214f, 0.05745080f, 0.12830728f, -0.03337229f, 
    0.07669451f, 0.12437400f, 0.10926711f, -0.05319532f, 0.31958371f, -0.15151386f, -0.00553191f, -0.09662073f, 
    0.08808337f, 0.02233347f, 0.09833451f, 0.04889338f, 0.05594873f, 0.16355152f, 0.12072017f, 0.20050645f, 
    0.07234018f, -0.03009126f, -0.12783764f, -0.02149757f, 0.05895469f, -0.42828053f, -0.15414767f, -0.13353901f, 
    0.04723986f, 0.13106775f, -0.07114056f, -0.17383975f, 0.26119348f, 0.03528717f, -0.13867138f, -0.22777043f, 
    0.12680088f, -0.08750430f, 0.08828259f, 0.06220300f, -0.03998576f, -0.07429959f, -0.00214014f, -0.09450252f, 
    0.13277674f, -0.13525780f, 0.19030485f, -0.04341666f, 0.03583952f, 0.07798611f, -0.03806742f, -0.12083459f, 
    -0.02842261f, -0.07552487f, 0.05323550f, -0.08589564f, -0.04563053f, 0.02416822f, 0.00406201f, -0.01598728f, 
    -0.05751496f, -0.03690622f, 0.00309629f, -0.04064089f, -0.05733798f, 0.02219383f, 0.03040627f, -0.02954671f, 
    0.05429867f, -0.01936312f, 0.04068490f, -0.05417156f, -0.01189682f, -0.04075384f, -0.03643275f, 0.02367169f, 
    -0.03854246f, -0.00682673f, -0.04986960f, -0.02283428f, 0.00449727f, -0.03817713f, 0.02469501f, -0.07473547f, 
    -0.02141736f, -0.00772290f, 0.01822922f, -0.02275045f, -0.07954278f, -0.08264100f, -0.07785761f, -0.03874001f, 
    -0.03834831f, -0.01307747f, -0.02015778f, 0.00854953f, -0.03290737f, 0.00518563f, 0.03919230f, -0.05105412f, 
    -0.02095217f, 0.01423173f, 0.04180686f, -0.01675921f, 0.00214856f, 0.01538369f, 0.04190622f, -0.01251119f, 
    0.02670274f, -0.03526138f, -0.00231312f, -0.05505306f, 0.00784794f, -0.01590394f, 0.01728752f, -0.01123613f, 
    -0.02252384f, -0.00793691f, 0.05718743f, 0.03719296f, 0.04692001f, -0.04186426f, 0.05780075f, 0.05426535f, 
    -0.07726789f, -0.05212221f, -0.04239634f, -0.02316944f, -0.01024043f, -0.00245954f, -0.05518153f, -0.02869129f, 
    0.02230828f, 0.02265564f, -0.04321577f, -0.02703361f, 0.01870104f, -0.07056531f, -0.09217404f, 0.04482352f, 
    0.05154754f, 0.06623821f, -0.02865815f, 0.04678889f, -0.03363298f, -0.05705870f, 0.03499443f, 0.00716264f, 
    -0.08601245f, -0.02549973f, -0.05210753f, -0.04849101f, -0.05729040f, -0.01506738f, -0.06267173f, -0.02308237f, 
    -0.08920237f, 0.01526096f, -0.04792019f, -0.03807009f, 0.00551532f, -0.02064761f, -0.05933963f, 0.01401872f, 
    -0.04232346f, -0.07186832f, -0.03693657f, -0.05099371f, 0.00982817f, -0.06029332f, 0.04692286f, 0.02474116f, 
    0.00803419f, -0.00165133f, -0.04415520f, -0.10332786f, -0.01578515f, 0.02794003f, -0.04486691f, 0.04202218f, 
    -0.04914987f, -0.04946035f, -0.05889963f, -0.04510260f, -0.06370959f, 0.05368879f, -0.07510570f, -0.08211841f, 
    -0.01408466f, -0.08190240f, -0.05918526f, -0.05607189f, -0.08856012f, -0.05779812f, -0.01731726f, 0.02904032f, 
    0.01704078f, -0.05727407f, -0.05653650f, -0.06449494f, 0.03035176f, -0.00844606f, -0.04490796f, -0.03706409f, 
    -0.03536033f, 0.01309628f, -0.01552023f, -0.00056390f, 0.04321815f, 0.02263847f, -0.02013326f, 0.01044471f, 
    -0.07682733f, -0.02869569f, -0.05352331f, -0.05276380f, -0.03351957f, -0.02698774f, 0.03122971f, -0.03429128f, 
    0.03336767f, 0.05278607f, 0.03246396f, -0.02202286f, -0.04998513f, -0.03400972f, 0.00561987f, -0.03422854f, 
    -0.00025587f, -0.08318958f, 0.00242167f, 0.04964226f, 0.00386724f, 0.05492037f, -0.04063756f, 0.01172451f, 
    -0.02015509f, -0.04399831f, 0.03465151f, 0.05199018f, -0.02704333f, 0.00873673f, 0.01825995f, 0.01097765f, 
    0.00947961f, 0.01497858f, -0.04481476f, 0.03415776f, -0.03736953f, 0.03616751f, 0.00370433f, -0.04528157f, 
    0.01585331f, -0.01884566f, 0.01442597f, -0.02057669f, 0.03472470f, -0.02163790f, -0.05414139f, -0.00384690f, 
    -0.04479397f, -0.06459073f, -0.04607784f, 0.00861731f, -0.07902989f, -0.03919107f, 0.00897065f, -0.01421550f, 
    -0.07144066f, 0.03191437f, 0.01274824f, -0.01889768f, 0.00158641f, -0.01069437f, 0.03626737f, -0.01890738f, 
    -0.02548653f, 0.04626318f, 0.00716533f, -0.07262593f, 0.02443487f, 0.00299047f, -0.04782796f, 0.02551422f, 
    -0.00213987f, 0.05052080f, 0.01871118f, -0.02388207f, -0.01536789f, -0.00232237f, 0.02070188f, 0.02649082f, 
    -0.10377171f, -0.02834318f, 0.03602837f, -0.01219650f, 0.01607093f, 0.00988289f, -0.01128502f, -0.03522480f, 
    0.02326058f, 0.01396214f, 0.06706917f, 0.04196103f, -0.00740610f, 0.02884766f, 0.00632303f, -0.04052624f, 
    0.02969896f, -0.08160904f, -0.05704220f, -0.05374916f, 0.04786197f, -0.05088747f, -0.04505704f, -0.02057585f, 
    -0.07168137f, -0.01259211f, 0.03363125f, -0.01065970f, 0.03447397f, 0.04168446f, -0.05203346f, -0.04411887f, 
    -0.06445576f, 0.02468324f, 0.01234255f, -0.07220701f, -0.03241461f, -0.04530840f, 0.02346722f, 0.01406902f, 
    0.02784241f, -0.03294067f, -0.07760773f, -0.08358237f, -0.03464955f, 0.03575879f, -0.00555017f, -0.05528031f, 
    0.55730164f, -0.00215230f, -0.16474657f, -0.14533119f, -0.11328106f, 0.08516330f, -0.04522783f, 0.07659225f, 
    -0.11064124f, 0.09816378f, 0.20827232f, 0.08589627f, -0.03596633f, -0.17705330f, -0.18034752f, -0.06976685f, 
    -0.03354533f, 0.17054653f, -0.07006419f, -0.03033843f, 0.39851323f, 0.09861811f, -0.00681482f, -0.00511032f, 
    -0.12490930f, -0.11576163f, -0.09723601f, -0.22402029f, 0.05299229f, 0.11217196f, 0.07897039f, -0.05724799f, 
    -0.07767347f, 0.04374167f, -0.03965059f, -0.18450098f, 0.41696462f, 0.11838015f, -0.17903125f, 0.26771998f, 
    0.22696073f, 0.24512476f, 0.03889750f, 0.03870622f, 0.06002053f, -0.27743864f, -0.15307786f, -0.07448247f, 
    0.03764498f, -0.01083937f, -0.08315521f, 0.07922226f, 0.10457000f, -0.07294781f, 0.27866974f, 0.07447994f, 
    -0.36915192f, 0.01804799f, -0.07660484f, 0.02809580f, -0.03139810f, 0.07914048f, -0.03029259f, 0.11851650f, 
    0.18377618f, 0.08833510f, -0.09102774f, -0.01407378f, -0.08672355f, -0.15507518f, 0.18728173f, 0.04853272f, 
    -0.00714298f, 0.14043914f, -0.01451598f, 0.22582354f, 0.24196175f, 0.10832552f, 0.10326914f, -0.10150816f, 
    0.03945501f, 0.18328939f, -0.10414536f, -0.38918674f, 0.10010795f, 0.02628051f, 0.03864149f, -0.05607583f, 
    -0.02740704f, -0.04597018f, -0.04221509f, -0.01032589f, 0.16552325f, -0.04699485f, 0.10040440f, 0.02089081f, 
    0.09500533f, 0.02755091f, -0.11210902f, -0.20867524f, -0.02083793f, -0.15571524f, 0.03319090f, 0.20308369f, 
    -0.05341578f, -0.11740317f, -0.12351432f, -0.04405294f, 0.04208167f, -0.08825217f, 0.13569202f, -0.07821717f, 
    -0.00002018f, -0.06765320f, 0.03229101f, 0.07200055f, -0.03467691f, 0.00326740f, 0.13407347f, -0.11025997f, 
    -0.03478597f, -0.15269846f, -0.04076364f, -0.07545850f, 0.10874791f, 0.00020550f, 0.04708795f, -0.11916409f, 
    0.21283549f, -0.15553895f, 0.01549318f, -0.00654089f, 0.13632751f, 0.00713423f, -0.10457040f, 0.02451379f, 
    0.06151080f, -0.22275467f, 0.17741193f, -0.02433690f, -0.01072208f, 0.07615206f, 0.16916904f, 0.03586211f, 
    -0.30032468f, -0.07126123f, 0.11064804f, 0.17057544f, 0.15179424f, 0.01024481f, -0.10864852f, -0.07845305f, 
    -0.03137257f, -0.13598229f, 0.02883812f, -0.32680550f, 0.21809608f, 0.12601328f, 0.03294989f, 0.02250523f, 
    0.09442513f, -0.05236372f, -0.12431883f, 0.07930090f, -0.15031454f, 0.06162675f, -0.06577662f, 0.04636144f, 
    0.03566745f, 0.08302724f, 0.08822972f, -0.12753063f, -0.00843585f, -0.01502722f, 0.19924201f, 0.09658655f, 
    0.05865050f, -0.10944429f, -0.02628344f, -0.07811631f, -0.30137354f, -0.24421623f, 0.08635636f, 0.04720459f, 
    -0.09635984f, -0.28380454f, 0.14368574f, 0.07417228f, 0.28140691f, -0.28380492f, 0.03758933f, -0.05454578f, 
    -0.01631900f, 0.05078609f, -0.11375961f, -0.13565111f, 0.08155780f, -0.02554495f, 0.11324872f, -0.11130805f, 
    -0.18266156f, -0.06004745f, -0.18203470f, -0.15673774f, -0.02405332f, 0.06920505f, 0.03977390f, 0.22165474f, 
    -0.23414825f, -0.19263403f, -0.02424424f, 0.11107718f, 0.06256422f, -0.00643628f, 0.16554627f, -0.19870953f, 
    0.14537175f, 0.07992893f, -0.33824146f, 0.02904964f, 0.08010479f, 0.07418837f, -0.17601778f, 0.31644148f, 
    0.02337951f, 0.46950302f, 0.05621833f, 0.30087557f, 0.05725579f, 0.00902148f, 0.01537456f, -0.31740892f, 
    -0.04998128f, -0.01594163f, 0.15015860f, -0.00391594f, -0.01804179f, 0.02981689f, -0.13212509f, 0.10320498f, 
    -0.13414851f, -0.04823246f, -0.08855899f, -0.06719751f, -0.05632479f, 0.24005568f, -0.07210325f, 0.10003540f, 
    -0.13184403f, 0.00079593f, 0.04161522f, -0.07010666f, -0.32800743f, -0.30057165f, 0.01534022f, 0.07822865f, 
    0.04659097f, -0.08611546f, -0.04593275f, -0.22871982f, -0.04489303f, 0.22008273f, 0.31495756f, 0.16392179f, 
    0.00593032f, -0.26735911f, 0.01633390f, -0.00054796f, -0.08449371f, -0.04772453f, 0.21074151f, -0.00942600f, 
    -0.20410430f, 0.28070405f, -0.03132828f, 0.09022016f, 0.01568680f, 0.12380037f, 0.08310499f, 0.34622160f, 
    -0.12405631f, -0.14480434f, -0.05991716f, -0.06008065f, 0.04553330f, 0.11042008f, 0.17774810f, -0.01931759f, 
    0.30009156f, -0.00695811f, 0.00644478f, 0.03935912f, -0.12568186f, -0.03735453f, -0.03227061f, -0.20254998f, 
    0.05374370f, 0.07450759f, -0.06397088f, 0.12045278f, 0.01918468f, -0.15744559f, 0.02796530f, -0.13974851f, 
    -0.02631236f, 0.05312276f, 0.22849910f, -0.09240570f, 0.08089126f, -0.09044950f, -0.06101114f, -0.03169345f, 
    0.09793581f, -0.10162656f, 0.00269277f, 0.20740281f, -0.18438153f, -0.13403711f, -0.22388351f, -0.04967376f, 
    0.12735371f, -0.15113480f, 0.00162809f, 0.02857275f, 0.09610970f, 0.03171628f, -0.17346287f, -0.04458547f, 
    0.16227162f, -0.20611501f, 0.12378044f, -0.08030774f, 0.02279998f, 0.13529940f, -0.01025434f, -0.08919632f, 
    0.05841966f, -0.02016899f, -0.08112404f, -0.13034043f, 0.13632755f, 0.09185120f, -0.01663575f, 0.00679778f, 
    0.11886800f, -0.01182343f, -0.13470817f, 0.03266641f, 0.05751723f, 0.00624498f, 0.04312634f, 0.12030099f, 
    -0.39265054f, 0.29144883f, -0.10042220f, -0.13009360f, 0.04267665f, -0.24174313f, -0.06325188f, 0.07024483f, 
    0.29942101f, 0.37420049f, 0.13586102f, 0.05936913f, 0.17544697f, 0.00174106f, 0.13770916f, -0.02469079f, 
    0.09704477f, -0.01602846f, 0.32069308f, 0.14380075f, 0.17106491f, 0.02237800f, 0.05366231f, -0.00190079f, 
    0.00768724f, 0.00504941f, -0.24177329f, -0.09655391f, 0.01850903f, 0.06619098f, -0.09571638f, -0.14349444f, 
    0.01131620f, 0.09602194f, -0.05174193f, 0.32761475f, -0.16185272f, 0.01761821f, 0.11738630f, -0.04251277f, 
    0.06028170f, -0.13128801f, -0.02752790f, -0.04286274f, 0.01143743f, -0.05417729f, -0.05726327f, -0.09073129f, 
    -0.18886065f, -0.16453841f, -0.00338246f, -0.07921683f, -0.07007809f, -0.22334681f, -0.17639922f, -0.06606641f, 
    -0.00719038f, -0.02273785f, 0.13147494f, -0.25072765f, -0.03393976f, -0.02553484f, 0.11454074f, 0.05022827f, 
    0.02191580f, 0.04913677f, -0.11111762f, -0.08852056f, 0.07110568f, 0.02177034f, -0.08521432f, -0.09633183f, 
    0.20589933f, -0.21871036f, 0.06373913f, 0.01246795f, -0.05306214f, 0.12759703f, -0.01534634f, -0.18287095f, 
    0.19361097f, 0.27439016f, 0.05393242f, -0.06253524f, 0.03725205f, -0.06762657f, 0.04719019f, -0.08644464f, 
    -0.12780304f, 0.08513498f, 0.24139765f, 0.08593383f, 0.04585758f, 0.07180160f, 0.07401943f, 0.01299840f, 
    0.12346074f, 0.11997126f, 0.18154570f, -0.11169814f, -0.04882209f, 0.03294205f, -0.17309017f, 0.08894972f, 
    0.04885217f, -0.14529333f, -0.02921745f, 0.09012353f, -0.06794463f, 0.07510476f, -0.03121464f, 0.03158899f, 
    0.06185119f, -0.02983192f, 0.06895318f, 0.04971898f, 0.24174483f, 0.23111996f, 0.13416232f, -0.07285298f, 
    0.10425795f, 0.04648504f, 0.17029037f, 0.10811713f, -0.15615298f, -0.11320715f, -0.13263793f, 0.03675934f, 
    -0.18980077f, -0.11368787f, -0.03996083f, 0.01031157f, 0.20017795f, -0.00992987f, -0.09750576f, -0.06438309f, 
    0.07618655f, -0.16935965f, 0.13044605f, 0.07923283f, -0.05183646f, 0.01704690f, 0.01817624f, -0.02657469f, 
    -0.13537864f, -0.09668013f, -0.01400359f, -0.04539632f, -0.11146668f, -0.00982476f, -0.08337045f, -0.17333762f, 
    0.31794226f, 0.07822673f, 0.10062301f, 0.08971857f, -0.01620063f, -0.00928799f, -0.07484071f, 0.17935884f, 
    -0.07110602f, -0.01963537f, -0.12038762f, 0.09895736f, 0.03745820f, 0.12728360f, -0.08520546f, 0.05003837f, 
    0.04679906f, 0.04229585f, -0.17139678f, -0.15024273f, 0.10091622f, -0.07278759f, 0.06263628f, 0.09350827f, 
    -0.05570501f, 0.02003604f, -0.00475070f, 0.49531892f, 0.14125410f, 0.00413632f, -0.10080481f, -0.00671330f, 
    0.05389729f, -0.05581278f, -0.03880332f, -0.02859114f, 0.05375279f, -0.01243830f, 0.17092696f, 0.04693705f, 
    -0.02273428f, -0.08202093f, -0.10146780f, 0.00910937f, 0.02120520f, -0.41844767f, -0.07619235f, -0.27678278f, 
    -0.21988082f, -0.16393946f, 0.10789764f, -0.26049986f, 0.00532145f, -0.16844353f, 0.41771170f, 0.26130956f, 
    0.14046639f, 0.17364983f, 0.13772754f, 0.22127643f, -0.04538385f, 0.05710809f, -0.07449863f, 0.02688923f, 
    -0.32427427f, -0.03563194f, -0.00765278f, 0.04718167f, -0.21835382f, 0.03010473f, -0.05361168f, 0.08175220f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.01963845f, 0.03477845f, 0.03940707f, 0.10984123f, 0.12248866f, -0.00233962f, 0.10649619f, -0.00280100f, 
    0.02337287f, 0.02736192f, 0.06372881f, 0.16713408f, -0.03419073f, 0.00087704f, 0.03742336f, 0.06131318f, 
    0.00007114f, 0.01782664f, -0.02890611f, 0.15818644f, 0.00407996f, -0.01775820f, 0.08391589f, 0.11278623f, 
    -0.05765477f, 0.03236897f, -0.04020537f, 0.06317753f, 0.01891957f, 0.02351958f, -0.06511721f, -0.09524310f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09414922f, 0.00571214f, -0.09196873f, 0.23057275f, -0.68313897f, 0.13729057f, 0.25736633f, 0.09542260f, 
    -0.12110902f, 0.09390391f, 0.08109958f, 0.07556775f, 0.07315358f, 0.09968092f, -0.17403977f, 0.48115429f, 
    -0.06033351f, -0.10787661f, 0.07426884f, 0.39064917f, 0.04639532f, 0.24100609f, 0.17604898f, -0.17644441f, 
    -0.69199765f, 0.06889282f, 0.10015102f, -0.01335226f, -0.12541233f, -0.14733265f, 0.44398856f, -0.17163278f, 
    -0.09330283f, 0.14704797f, -0.14908819f, 0.01440641f, -0.02630933f, 0.05372379f, 0.00647781f, 0.01427381f, 
    -0.10695869f, -0.02033640f, -0.11343174f, -0.09301613f, 0.07056101f, 0.06208090f, -0.10905533f, -0.08650188f, 
    0.02402768f, 0.06717965f, 0.16380589f, 0.04749824f, -0.02495201f, 0.02620941f, -0.10743496f, -0.19998379f, 
    0.10949583f, 0.11350830f, 0.00327702f, 0.12586977f, 0.14193898f, 0.02848039f, 0.12005601f, -0.08369374f, 
    -0.06729773f, 0.09850807f, 0.45282251f, -0.01859644f, 0.38978559f, -0.07229377f, -0.46663544f, -0.16764440f, 
    -0.06702475f, -0.21340457f, 0.23295960f, 0.24507947f, -0.08283612f, 0.04798014f, -0.05316099f, -0.43516383f, 
    0.25144565f, -0.15158866f, -0.11338737f, 0.32440984f, -0.09089387f, -0.29351649f, 0.19018917f, 0.19280958f, 
    0.33073568f, 0.13315266f, -0.02476996f, -0.11578961f, 0.28806409f, -0.13618658f, -0.42693537f, 0.12831376f, 
    -0.14317824f, -0.05955901f, 0.12648387f, 0.08309530f, -0.09290157f, 0.10308224f, 0.08856579f, -0.00354015f, 
    -0.16333652f, -0.14196725f, -0.14219886f, -0.15245324f, -0.13241558f, -0.07400277f, 0.05937610f, -0.09378873f, 
    -0.14956529f, -0.16383308f, 0.16525471f, 0.05522967f, -0.07791869f, 0.04386501f, -0.07375977f, -0.11581437f, 
    -0.21000060f, 0.05831752f, 0.00386068f, 0.05752303f, 0.09266292f, -0.05910745f, 0.14245950f, 0.06534942f, 
    -0.07294730f, -0.06830552f, -0.00779927f, 0.11155804f, -0.46398902f, 0.04953652f, 0.10057311f, -0.06882057f, 
    0.06410431f, 0.46342397f, -0.04213322f, 0.27868509f, 0.12934348f, 0.14796869f, -0.00525674f, -0.43975627f, 
    0.38881132f, 0.12416806f, -0.00800013f, 0.42287278f, 0.01436610f, 0.09067157f, 0.35669002f, -0.46538070f, 
    -0.03936725f, -0.11329396f, -0.03290640f, -0.42986092f, 0.00456184f, 0.16566725f, 0.47178406f, -0.34174532f, 
    -0.17872161f, 0.12304091f, 0.30544347f, -0.40122166f, 0.32139730f, 0.09883924f, 0.46926272f, -0.04537338f, 
    0.36361256f, 0.35089391f, -0.00528690f, 0.13729596f, -0.04745413f, 0.00203075f, 0.02246022f, 0.06562057f, 
    -0.38459101f, -0.03568215f, -0.55576277f, 0.15657251f, -0.16136879f, -0.03863204f, 0.16385266f, -0.11040312f, 
    0.02489418f, -0.17588107f, 0.01081605f, 0.24211088f, 0.41042772f, -0.12230159f, -0.39369068f, 0.18890230f, 
    0.20982520f, -0.16121687f, -0.00088652f, 0.60040021f, 0.17218892f, -0.15991437f, 0.22247547f, 0.04114883f, 
    -0.10090679f, -0.16801243f, -0.44817296f, 0.03695316f, 0.10160138f, 0.04432265f, 0.08574079f, 0.23107037f, 
    0.26030064f, 0.11737573f, -0.46120900f, -0.29642588f, -0.12835102f, 0.27545089f, 0.16118577f, -0.10285090f, 
    -0.16772583f, 0.12275057f, -0.02486212f, -0.07711979f, -0.21548100f, -0.07829831f, -0.23004395f, -0.37695646f, 
    0.34707394f, -0.14639226f, 0.04346915f, -0.15840669f, -0.00786109f, 0.06634518f, 0.14748102f, 0.15415040f, 
    -0.29494780f, -0.03438947f, 0.34228927f, 0.16796246f, -0.05463997f, 0.13962753f, 0.02233399f, 0.11786917f, 
    -0.06383953f, -0.06651353f, 0.00020430f, -0.11331111f, -0.15072685f, -0.14577630f, -0.31319159f, 0.02349926f, 
    0.49073571f, -0.01223032f, -0.09870824f, -0.12699315f, -0.23690827f, 0.16706893f, 0.30196691f, 0.77989942f, 
    0.23943828f, 0.02586908f, -0.55838329f, -0.05126007f, 0.17518520f, 0.14502382f, -0.22224940f, -0.14524463f, 
    -0.14917250f, 0.16166097f, 0.32543772f, -0.03207488f, 0.04218974f, 0.07790404f, 0.05623211f, 0.37530917f, 
    -0.17212884f, 0.09820464f, 0.85351551f, -0.47667214f, 0.08655152f, 0.56818795f, -0.16655661f, 0.23480776f, 
    0.02380513f, 0.13035017f, -0.05702537f, 0.15791339f, 0.07953317f, 0.05104200f, 0.18845953f, 0.36264271f, 
    0.57703251f, 0.03549832f, 0.07821003f, -0.24711107f, -0.37727639f, 0.16359161f, 0.35684213f, 0.13611309f, 
    0.21797478f, 0.24729770f, 0.06476498f, 0.29817352f, 0.05817349f, 0.00223577f, 0.14178400f, -0.28157309f, 
    0.18117686f, -0.11853965f, -0.29361397f, -0.33356908f, 0.17496452f, 0.29861945f, -0.26338068f, -0.44569027f, 
    -0.19090807f, -0.06666070f, 0.00111097f, -0.18479386f, 0.24531162f, 0.01594671f, 0.56683356f, 0.35328910f, 
    -0.35812578f, 0.16149116f, -0.37750205f, 0.31594726f, 0.49860108f, 0.13747083f, 0.23253158f, 0.02031428f, 
    -0.18949914f, 0.23765294f, 0.25956672f, 0.00091245f, -0.03317707f, 0.12874235f, 0.14497399f, 0.50566953f, 
    0.35917300f, -0.15781386f, -0.02887392f, 0.28237510f, -0.01997263f, 0.16075584f, 0.50663543f, 0.61245310f, 
    -0.50666904f, -0.08919498f, 0.05152211f, 0.02108908f, -0.32629687f, -0.15552901f, -0.09882624f, -0.09403365f, 
    -0.17785016f, 0.15417115f, 0.17971438f, -0.24213231f, 0.81988710f, 0.17738691f, -0.11048218f, -0.09427472f, 
    0.06173209f, -0.01351961f, 0.02635865f, 0.07521399f, -0.04695648f, 0.03270882f, -0.06178338f, 0.22347379f, 
    -0.19721535f, -0.07262021f, -0.35961488f, 0.24851428f, 0.02766355f, 0.11307943f, 0.33184177f, 0.47248048f, 
    -0.31613845f, 0.00145238f, 0.07027583f, 0.09539166f, 0.13660415f, 0.03829757f, -0.31923959f, 0.04612326f, 
    0.20093933f, 0.00757419f, 0.73839879f, 0.23626916f, -0.21921022f, 0.06080861f, -0.30471313f, 0.02448058f, 
    0.13593310f, -0.25496376f, 0.27939376f, 0.23607807f, 0.07045294f, -0.10081189f, -0.10291912f, -0.38606736f, 
    -0.07763600f, 0.00808745f, -0.10170042f, 0.16093282f, -0.04376377f, -0.25725636f, -0.35363191f, -0.10315934f, 
    0.44266802f, -0.12768027f, 0.09859075f, 0.03375804f, 0.51413035f, -0.07832725f, -0.21723546f, -0.07724156f, 
    0.28118372f, -0.11923178f, 0.35826868f, 0.04757077f, -0.09189637f, 0.05615997f, -0.18690385f, 0.14547041f, 
    0.39684671f, -0.31094906f, -0.29941344f, 0.14878291f, 0.13562702f, 0.03803365f, 0.12877616f, 0.15764041f, 
    0.04034473f, 0.06096132f, -0.39080295f, 0.07760052f, 0.10533877f, -0.48927000f, 0.11151045f, -0.39818126f, 
    0.47952917f, 0.02997291f, 0.17164233f, 0.39380798f, 0.09731775f, 0.05011074f, 0.05611932f, -0.45359910f, 
    0.42359909f, -0.07817929f, 0.17202131f, -0.14512853f, 0.12848872f, -0.11961900f, 0.16074730f, 0.16413398f, 
    -0.22714266f, 0.20400113f, 0.24787928f, 0.26056862f, -0.09806247f, 0.18325624f, -0.01991576f, -0.06087968f, 
    -0.35347807f, 0.17731474f, -0.13120316f, -0.33711007f, -0.00126743f, 0.57602423f, -0.37043262f, -0.03433790f, 
    -0.27236536f, -0.03722991f, 0.07565903f, 0.10318676f, 0.48510346f, 0.02699393f, 0.03233651f, 0.55723917f, 
    -0.48965839f, 0.14354926f, -0.24690251f, 0.12462857f, -0.19526963f, 0.12555939f, 0.28197864f, -0.02826440f, 
    -0.09348274f, 0.36536291f, 0.18973155f, 0.07693239f, 0.13767497f, -0.01523083f, -0.13757649f, 0.40489867f, 
    -0.08882030f, 0.12144113f, -0.30852729f, 0.38977313f, -0.04188835f, 0.40205890f, 0.15466259f, 0.34370884f, 
    -0.44433871f, -0.00190109f, 0.00507023f, 0.09925901f, -0.12289360f, -0.13223863f, -0.11255666f, 0.04357734f, 
    0.29725260f, 0.02489382f, 0.18210484f, 0.11210832f, 0.21443334f, 0.09862179f, -0.37831578f, 0.13091418f, 
    0.44111216f, -0.23653249f, -0.42981556f, -0.17573535f, 0.04027012f, -0.02337508f, 0.10016340f, 0.42713439f, 
    -0.08973345f, 0.09366375f, -0.09924678f, -0.14365476f, 0.07632203f, 0.11902107f, 0.21133508f, -0.43623438f, 
    0.13215013f, 0.11174341f, -0.13487792f, 0.38048023f, 0.18839259f, -0.09127641f, 0.38769111f, -0.16603611f, 
    0.09381102f, 0.06050343f, 0.60501081f, -0.04242555f, -0.20936486f, 0.12713239f, -0.32165119f, -0.10591518f, 
    0.28820041f, -0.29837465f, 0.15620925f, -0.00645477f, -0.08908101f, -0.08527912f, -0.05941055f, -0.09351239f, 
    -0.27137947f, 0.07549042f, 0.11884944f, 0.15328401f, -0.06697486f, 0.23611750f, -0.32248521f, 0.14361344f, 
    0.53112239f, 0.01048228f, -0.02741125f, 0.52967274f, 0.35471347f, 0.02960086f, -0.44122878f, -0.10248032f, 
    0.16506208f, -0.03281013f, 0.15195625f, 0.27201289f, -0.02199629f, 0.12904575f, 0.11271890f, 0.17635405f, 
    -0.34912986f, -0.25511724f, 0.46321025f, -0.10608756f, -0.13718429f, -0.01496819f, -0.12929517f, 0.30412981f, 
    0.27190551f, -0.00941402f, -0.21219718f, 0.41370258f, -0.06902168f, -0.03074698f, -0.04811409f, 0.40412459f, 
    0.18101190f, 0.05211795f, 0.07629702f, 0.38944966f, -0.08045015f, -0.08611025f, -0.48073664f, 0.01639368f, 
    -0.02947798f, 0.12603031f, -0.03606777f, 0.02170772f, 0.34054047f, -0.03043566f, 0.25726092f, 0.00282257f, 
    -0.09172499f, 0.19922137f, 0.14938639f, 0.13345465f, 0.11420608f, 0.08518974f, -0.00220597f, -0.37692469f, 
    0.05879116f, -0.06311215f, 0.15150699f, -0.49825025f, -0.07732989f, -0.26486114f, 0.01332641f, 0.36696488f, 
    0.33216652f, -0.00054114f, -0.13777147f, 0.26902127f, 0.02670617f, -0.07236952f, -0.29529044f, 0.07749201f, 
    0.44190538f, -0.09094220f, -0.24604955f, 0.29849017f, -0.10461152f, -0.12572093f, 0.04768266f, -0.16746649f, 
    0.16241440f, -0.15390082f, -0.11321776f, -0.02370736f, -0.12823752f, 0.17400596f, 0.02179338f, -0.03113659f, 
    0.62294245f, -0.12474396f, -0.32016936f, -0.01082571f, -0.06575452f, -0.24853341f, -0.03265090f, 0.17892464f, 
    -0.07785015f, -0.05972000f, -0.10280135f, -0.07718889f, -0.43587804f, -0.12536292f, 0.43587485f, 0.25260347f, 
    0.52053213f, 0.18382609f, 0.23840702f, 0.35187721f, -0.57071763f, 0.00162752f, 0.51056427f, 0.01045575f, 
    -0.13103540f, -0.23916744f, 0.02133686f, 0.07181232f, -0.01123155f, -0.07623941f, 0.01855314f, 0.25296515f, 
    -0.20513727f, -0.01295291f, -0.04394899f, -0.28795710f, 0.16651787f, 0.37621957f, -0.41281682f, -0.02999963f, 
    -0.42155302f, 0.09084772f, -0.07447618f, 0.24759276f, 0.21596159f, 0.04522472f, 0.23193130f, 0.21958691f, 
    -0.19142132f, 0.16922066f, -0.19001175f, 0.25829312f, -0.01359714f, 0.07215523f, 0.58220583f, 0.12139378f, 
    0.45137551f, 0.11681706f, -0.12310153f, 0.24192734f, -0.14267023f, 0.00288204f, 0.05195599f, -0.01031956f, 
    0.39187986f, -0.08619700f, -0.30211496f, -0.21816079f, -0.14013438f, -0.39222309f, 0.05575295f, -0.08080736f, 
    -0.09025056f, -0.11715481f, -0.04187211f, 0.11459642f, -0.42477766f, -0.00468278f, 0.02692938f, -0.17382421f, 
    -0.27588990f, -0.09015901f, -0.26982829f, 0.28270757f, 0.69469357f, -0.05712134f, -0.19218449f, 0.10341813f, 
    -0.20923793f, 0.15831594f, 0.06912721f, 0.10648243f, -0.07540594f, 0.02660380f, -0.12477080f, -0.23332876f, 
    0.30581346f, 0.05863670f, 0.76611352f, -0.33032742f, 0.08572128f, 0.34061736f, 0.36774176f, 0.36823785f, 
    0.08911074f, -0.07613055f, 0.06702525f, -0.29433635f, -0.14797449f, -0.01689545f, 0.20368505f, 0.51075268f, 
    -0.14453800f, -0.08216830f, -0.32573181f, 0.12527901f, -0.34680936f, -0.16145539f, 0.12108008f, -0.06188628f, 
    0.39054203f, 0.46925521f, -0.30491847f, 0.05899351f, 0.14029151f, -0.11871169f, 0.00852734f, -0.14977415f, 
    -0.13678689f, -0.09412826f, 0.52947426f, 0.08488844f, 0.10764139f, 0.29693598f, 0.33823392f, -0.49384376f, 
    -0.51058561f, 0.11840430f, -0.12947223f, 0.03695417f, 0.13674557f, 0.02551303f, 0.31808719f, -0.21336630f, 
    -0.06248873f, 0.05709605f, 0.29891863f, -0.00405928f, 0.47748473f, 0.01591363f, -0.28296641f, -0.01503258f, 
    0.09944257f, 0.02197257f, -0.15674110f, -0.07791611f, 0.15842524f, -0.06474198f, -0.02251559f, 0.08849333f, 
    0.21312599f, 0.05450729f, 0.02854098f, 0.09025326f, 0.13809261f, 0.01460912f, 0.06014052f, 0.12650609f, 
    -0.36333781f, -0.06554066f, -0.09892288f, 0.00526347f, -0.13199240f, 0.13479452f, -0.05577794f, -0.07393032f, 
    0.29100841f, -0.15264927f, 0.00825280f, 0.30019513f, 0.33535376f, 0.00388388f, -0.59030545f, 0.06538312f, 
    -0.13543385f, -0.12429176f, -0.10340121f, -0.26128510f, 0.01731832f, -0.08614200f, -0.14384221f, 0.35244977f, 
    0.26306352f, -0.15922865f, 0.59715402f, 0.18535383f, 0.14021945f, -0.03348660f, 0.26029089f, 0.09881120f, 
    0.42250922f, 0.12789261f, -0.12793005f, 0.19012363f, 0.06543362f, -0.19850506f, 0.29532853f, -0.09204913f, 
    0.08555141f, 0.05473888f, -0.17545108f, -0.02769045f, -0.02247979f, -0.00644487f, -0.11694414f, -0.14817624f, 
    -0.07626163f, -0.16240522f, 0.13774636f, 0.03448806f, 0.09323255f, 0.06547204f, -0.16095655f, -0.02116492f, 
    -0.17758648f, -0.07051095f, 0.10437106f, 0.07842526f, 0.07656304f, -0.04977358f, -0.07571595f, 0.00075064f, 
    -0.05464046f, -0.06431352f, 0.00447893f, -0.17689238f, -0.15814872f, 0.07584166f, -0.16198248f, -0.01364587f, 
    -0.12101809f, -0.13003288f, -0.18495230f, 0.11313546f, -0.10220527f, -0.15611073f, -0.14934890f, -0.07892802f, 
    0.02835058f, -0.13011129f, 0.04207669f, 0.00071749f, -0.04970032f, 0.10301632f, -0.09784231f, 0.02785303f, 
    -0.19195172f, 0.07719579f, 0.07679632f, 0.09161247f, 0.14831120f, -0.17223847f, 0.09183776f, -0.08183157f, 
    -0.19951928f, -0.08612999f, -0.10881992f, -0.03870153f, -0.19292346f, -0.12344600f, -0.07258102f, -0.17158970f, 
    -0.12847339f, -0.05215810f, 0.00931070f, 0.03044790f, -0.15940373f, 0.17369998f, -0.16562136f, 0.09940511f, 
    0.05218940f, 0.02743541f, 0.07869761f, -0.18193668f, 0.10282299f, -0.01707409f, 0.09867720f, -0.05129176f, 
    0.13590997f, -0.16634674f, -0.15548581f, -0.15985802f, -0.11139552f, 0.13979286f, -0.15734892f, 0.14397380f, 
    -0.13538188f, 0.09626510f, 0.07016534f, 0.01917861f, -0.12533221f, -0.15698043f, 0.02071251f, -0.14605425f, 
    -0.16972734f, -0.10648192f, -0.01288086f, 0.01970122f, -0.16437756f, 0.11104480f, -0.02765261f, 0.00911971f, 
    0.02688665f, -0.10011124f, -0.01083433f, -0.18633918f, 0.12808986f, 0.10023688f, -0.03391127f, 0.06342652f, 
    0.08964255f, 0.02700699f, 0.00875194f, -0.09094568f, 0.09891207f, 0.00747256f, 0.16552714f, -0.07942744f, 
    0.14276975f, 0.12659714f, 0.16079159f, -0.06011603f, -0.14764936f, -0.04699337f, -0.14967079f, 0.10105354f, 
    0.19541834f, -0.12272261f, 0.11305165f, 0.00033034f, -0.09690589f, -0.14644259f, -0.16298503f, -0.01593364f, 
    0.12926301f, 0.04694607f, 0.21121632f, 0.20911559f, -0.09371709f, 0.04603406f, -0.01531795f, -0.52307379f, 
    0.09981059f, -0.13936146f, 0.67814273f, 0.04613859f, 0.19307289f, 0.08636602f, -0.21541643f, -0.11443170f, 
    0.39375347f, 0.10573602f, 0.14092678f, -0.19104485f, 0.24520794f, -0.12438434f, -0.00494537f, 0.19632134f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08202979f, -0.17899245f, 0.10365889f, -0.13252430f, 0.18886915f, -0.05215879f, 0.13586839f, -0.30975175f, 
    0.07614341f, 0.23712450f, 0.23839091f, 0.26479214f, -0.09924551f, -0.02230688f, -0.03794222f, 0.17458828f, 
    0.06928192f, 0.25793684f, 0.23243801f, 0.10302377f, 0.18478554f, 0.02223403f, 0.27874357f, 0.05478620f, 
    -0.04170019f, 0.18375760f, -0.06930787f, 0.04445920f, -0.14058925f, 0.13970765f, -0.10741123f, -0.11234089f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.18927632f, 0.06217435f, -0.31814158f, -0.02769362f, 0.22776942f, -0.33285657f, -0.66697001f, -0.48900211f, 
    0.61668992f, 0.27070713f, -0.16812183f, -0.28461567f, -0.19989306f, -0.48145205f, 0.25382522f, 0.07725948f, 
    0.19265555f, -0.04308299f, -0.57108361f, -0.60544157f, -0.41849059f, 0.09876376f, -0.42964661f, 0.20461428f, 
    0.27060255f, -0.18880582f, 0.24671303f, 0.02678801f, 0.08541307f, -0.17036337f, -0.17172961f, 0.30129585f, 
    -0.30432111f, -0.08771542f, 0.13996182f, -0.22574723f, -0.26409948f, 0.02887153f, 0.07746971f, -0.07759174f, 
    0.09276236f, -0.39886427f, 0.35810488f, 0.59479654f, -0.40960020f, -0.48772874f, 0.07766140f, 0.09847908f, 
    0.01882680f, -0.42527166f, -0.17877929f, 0.14200972f, -0.09210567f, -0.39392617f, -0.02984628f, 0.49823606f, 
    -0.10139143f, 0.38529593f, 0.18928765f, 0.00040534f, -0.16082042f, 0.01789697f, -0.06370527f, -0.26950756f, 
    0.24373093f, 0.01885847f, -0.61455190f, -0.00715172f, -0.48425400f, 0.13499114f, 0.17851813f, -0.67985779f, 
    0.11027213f, -0.74461514f, 0.16445148f, 0.20202380f, -0.54067594f, 0.44955635f, -0.29446331f, 0.23055214f, 
    0.59053987f, 0.11642767f, 0.32418922f, -0.35762823f, -0.29092535f, 0.07188459f, 0.05286107f, -0.59186709f, 
    0.03243297f, -0.00750406f, 0.39360026f, 0.12146661f, 0.12756218f, 0.18162911f, 0.12510467f, -0.96711445f, 
    -0.69352251f, -0.08226122f, 0.40094405f, -0.06616646f, 0.10862900f, 0.19852024f, -0.93647152f, 0.17990950f, 
    -0.49086711f, -0.24326910f, -0.55480468f, -0.11682285f, 0.37689009f, 0.40532663f, -0.04402884f, -0.24141692f, 
    -0.11065682f, 0.43710658f, 0.11907026f, 0.38830388f, -0.70295769f, -0.45213330f, -0.19465193f, -0.15429203f, 
    -0.67817861f, -0.58163381f, 0.09518848f, -0.05592029f, 0.06412097f, -0.15808301f, -0.00713198f, 0.28653431f, 
    -0.19911602f, -0.20428160f, -0.15292610f, 0.06716160f, -0.37131518f, 0.30325755f, -0.52091402f, -0.37530330f, 
    0.03020984f, 0.12063651f, -0.30160484f, 0.11958564f, 0.19000670f, 0.15252513f, 0.22780570f, 0.06378395f, 
    0.07918535f, 0.41595748f, -0.17601189f, 0.25366622f, -0.48208508f, 0.42434648f, 0.19701129f, -0.43897393f, 
    0.02794258f, -0.06832486f, -0.57298863f, 0.06456123f, -0.17389055f, -0.10432125f, 0.05251485f, -0.05482316f, 
    0.13093674f, 0.05070043f, -0.26883173f, -0.07295116f, 0.13999230f, 0.12009137f, 0.38282245f, 0.59323496f, 
    0.18324502f, 0.31075913f, 0.12369270f, -0.08888844f, -0.55117619f, -0.60920322f, 0.21522948f, 0.33685407f, 
    -0.74398762f, -0.57321531f, 0.11888517f, 0.17909230f, 0.10317262f, 0.03273721f, 0.21409348f, 0.02221822f, 
    -0.07593036f, -0.53594476f, -0.66363710f, 0.04228293f, -0.01431151f, -0.15683693f, -0.03153172f, -0.08305637f, 
    0.16665243f, 0.02198444f, 0.00007743f, -0.18843479f, 0.57454324f, 0.41307229f, -1.13153625f, -1.10470402f, 
    -0.56909335f, 0.08295682f, 0.08601236f, 0.07349142f, -0.21419539f, -0.00065524f, -0.22739592f, 0.24029623f, 
    0.06621574f, -0.47466788f, -0.69076502f, -0.32415289f, -0.31343985f, -0.57033348f, 0.20295067f, -0.16056617f, 
    0.52144587f, -0.09363970f, -0.42447948f, 0.04014934f, -0.14830558f, -0.08665728f, -0.09765195f, -0.05910688f, 
    -0.48179394f, 0.14344634f, 0.09512128f, 0.03148331f, -0.64240444f, -0.21639323f, -0.45570573f, 0.61658156f, 
    0.45331281f, 0.32175347f, -0.42504486f, -0.56097490f, 0.12739304f, -0.28597260f, 0.38699171f, -0.34701255f, 
    -0.10241859f, -0.02379681f, 0.15329936f, 0.37883434f, 0.10980892f, 0.33640873f, -0.51619697f, 0.00388963f, 
    -0.46221066f, -0.27033088f, 0.08882903f, -0.05399506f, 0.06049692f, -0.03256113f, -0.07476778f, 0.13090247f, 
    0.24193513f, -0.13747926f, -0.28858602f, -0.02535632f, 0.06807777f, -0.92632812f, 0.19749036f, 0.38158873f, 
    0.17537148f, -0.94635236f, 0.30166122f, -0.84174961f, -0.25394166f, -0.33964565f, -0.71043038f, 0.16606855f, 
    -0.26713315f, -0.42356682f, 0.28777140f, 0.10264347f, 0.31815031f, 0.17755564f, 0.25060949f, 0.38412815f, 
    0.23281333f, -0.14120620f, 0.42962885f, 0.11630566f, -0.10566298f, -0.08781011f, -0.08959091f, 0.08083818f, 
    0.26276577f, -0.02860229f, -0.33779269f, -0.22489563f, 0.29857585f, -0.26240054f, 0.69770145f, 0.47570041f, 
    -0.55489159f, 0.46076521f, -0.23259823f, -0.51251924f, -0.01938840f, 0.26482388f, 0.03322029f, -0.08644985f, 
    0.21130350f, -0.45614204f, -0.29530528f, -0.52035075f, 0.68674231f, 0.56622601f, 0.17602065f, -0.38636196f, 
    -0.03077302f, 0.04190021f, -0.13243547f, 0.17010839f, -0.05536206f, 0.05645664f, -0.04912095f, -0.20987324f, 
    0.17991282f, 0.03911594f, 0.38395828f, 0.15320136f, -0.01298813f, -0.20594333f, -0.38156560f, -0.33133242f, 
    -0.35248205f, -0.56390733f, 0.37196741f, 0.37178433f, 0.28159907f, -0.17794909f, -0.22534734f, 0.34388155f, 
    -0.42231175f, 0.11789863f, 0.70797497f, -0.52535236f, 0.01542777f, -0.22625296f, -0.33624783f, -0.30435312f, 
    -1.02112758f, 0.15115651f, 0.10235284f, 0.07571190f, 0.02633527f, 0.03318816f, 0.09426261f, -0.15904307f, 
    -0.51245975f, -0.15622813f, 0.22558017f, 0.11969159f, 0.12399351f, -0.21833588f, -0.67771626f, -0.37828782f, 
    -0.04155732f, -0.02606412f, -0.13289657f, -0.06277178f, 0.04033374f, 0.57368833f, -0.70692682f, -0.26305255f, 
    0.36868897f, -0.01427217f, -0.19363344f, 0.14591014f, 0.59812576f, -0.90396881f, 0.39161971f, 0.01049151f, 
    -0.20345026f, 0.16711088f, 0.34203625f, 0.04158088f, -0.14441457f, -0.16803013f, -0.03658725f, 0.10172730f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00155209f, 0.07838347f, 0.05422470f, 0.06726421f, 0.10836934f, 0.21089624f, 0.15850832f, -0.38775122f, 
    -0.10519243f, 0.09685247f, 0.20636013f, 0.11780553f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
