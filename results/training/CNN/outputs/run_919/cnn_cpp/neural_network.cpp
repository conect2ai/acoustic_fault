#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.25376016f, 0.53704071f, 0.64358169f, -0.27389434f, 0.94123620f, -0.03506781f, 0.17822675f, -0.72337842f, 
    0.44854757f, 0.40089872f, 0.01993432f, 0.19079521f, -0.31317544f, -0.41050875f, -0.39997923f, 0.36671239f, 
    0.16735677f, -0.07231484f, 0.55043721f, 0.39858204f, 0.65102017f, 0.31143740f, 0.05568113f, 0.07350378f, 
    0.17723247f, 1.02824128f, -0.00644022f, -0.85445386f, 0.90288299f, -0.02353394f, -0.76637310f, -0.13224690f, 
    -0.46650413f, 0.52829462f, -0.59496069f, -0.73827964f, -0.09780651f, 0.53800803f, 0.25471151f, -0.19006138f, 
    -0.26847544f, -0.29316115f, 0.17982258f, 0.15195544f, 0.09315573f, -0.22800368f, 0.10559946f, -0.12603831f, 
    -0.18142450f, -0.10172448f, -1.18552315f, -0.51970780f, -0.53574216f, -0.33086088f, -0.54596215f, -0.30105913f, 
    0.04631219f, -0.80078775f, 0.39922968f, 0.67915761f, 0.51632720f, 0.00917113f, -0.43858767f, 0.10988614f, 
    0.14760943f, -0.24320927f, 0.47475806f, 0.05066278f, 0.17059891f, -0.14265889f, -0.01580608f, 0.29103270f, 
    0.37108129f, -0.31595153f, 0.18048394f, 0.66617858f, 1.06037176f, -0.75315243f, -0.99306685f, -0.23467535f, 
    0.16642551f, 0.37843162f, -0.87099850f, 0.47084603f, 0.43849164f, -0.21310659f, 0.14489880f, 0.08824854f, 
    -0.04846854f, -0.01247413f, 0.22259140f, 0.09713105f, 0.50223440f, 0.46421650f, 0.16715659f, -0.14666952f, 
    -0.22182408f, 0.16827279f, -0.27381802f, -0.19455546f, 0.79619908f, 0.98502231f, 0.94546413f, 0.44118315f, 
    0.57177490f, -0.04617928f, -0.79977685f, -0.52414286f, -0.61834347f, -0.01326042f, -0.13694383f, 0.49446744f, 
    0.33868310f, 0.04643391f, 0.34095845f, 0.01057495f, 0.14401162f, 0.36513355f, 0.24330787f, 0.33238956f, 
    0.42417061f, 0.03439187f, -0.25307196f, -0.24527657f, 0.35702780f, 1.16764593f, 0.88114715f, -1.37841129f, 
    0.56711161f, 0.01294369f, -0.34592500f, 0.22023658f, 0.58605796f, 0.69751668f, -0.29256001f, -0.01073938f, 
    -0.10554551f, 0.05533059f, -0.12229598f, -0.04937681f, 0.03192237f, -0.31465167f, -0.18236245f, -0.19003874f, 
    -0.03072587f, 0.19374481f, 0.08791494f, -0.03755731f, 0.13784876f, -0.01669471f, -1.01174784f, 0.44316310f, 
    -1.10478139f, -0.43501854f, -0.05405766f, -0.63860047f, 0.79760158f, 0.28714806f, -0.19978403f, 0.09983313f, 
    -0.36262199f, -0.01776392f, 0.41679120f, -0.43160075f, 0.17878161f, -0.23017050f, 0.10868671f, -0.35812163f, 
    0.27339926f, -0.37922421f, 0.03727141f, -0.25794894f, -0.15421452f, -0.09589876f, 0.23614430f, 0.93043399f, 
    0.03492597f, -0.75054252f, -1.19776189f, -0.79444569f, 0.01567086f, 0.87253064f, 0.78234297f, 0.24755895f, 
    0.26711568f, 0.49363744f, -0.16051881f, -0.30233622f, -0.51033735f, 0.13789080f, -0.00330887f, 0.31299335f, 
    -0.05588034f, 0.07796562f, -0.00668803f, -0.04513949f, 0.09873619f, -0.11894000f, -0.25075778f, -0.00546480f, 
    1.31201684f, 0.65733850f, 1.15153062f, 0.34899434f, 0.31319273f, -0.28638431f, -0.15036501f, -0.13813151f, 
    -0.46057644f, -0.23481251f, 0.02085125f, -0.00270913f, -0.36223635f, 0.59514523f, 0.54904222f, 0.28050351f, 
    -0.25388676f, -0.06536447f, 0.53707767f, 0.04808113f, -0.28719747f, 0.16366403f, -0.03054079f, 0.26342958f, 
    0.42739981f, -0.27728972f, -1.35736001f, -0.61290771f, 0.21994148f, 0.46540612f, -0.79951930f, 1.27597058f, 
    0.64185274f, 0.39081481f, 0.53761321f, -0.30163378f, -0.05725945f, -0.41494936f, 0.06805545f, -0.22369809f, 
    -0.18559308f, 0.25175509f, 0.00290981f, 0.16854522f, -0.13526553f, 0.16225228f, 0.31991041f, -0.20971067f, 
    0.04884050f, 0.10532808f, -0.85925269f, -0.69589025f, 0.95432895f, 0.83849937f, 0.15009953f, 0.50928313f, 
    0.21333113f, 0.75391096f, -0.04389653f, -0.34854946f, 0.27678213f, -0.41263831f, 0.41362408f, 0.52222538f, 
    -0.00993162f, 0.38967460f, 0.27376804f, -0.31797695f, -0.06643387f, 0.35942423f, -0.20679332f, 0.41569787f, 
    0.04812828f, 0.28116027f, 0.22882594f, 1.07920408f, -0.58874804f, -1.01764536f, -0.46675047f, 0.50756198f, 
    -0.21294059f, -0.73880482f, -0.46295482f, -0.14309010f, 0.35595992f, -0.35325536f, -0.48067659f, 0.08698089f, 
    0.12734221f, -0.11883707f, 0.16185306f, 0.27072129f, -0.25044948f, -0.03894540f, 0.25198606f, 0.34920397f, 
    0.11333890f, 0.49393046f, -0.07332701f, -0.17394611f, -0.20601913f, -0.95260400f, -0.91088700f, -0.69099206f, 
    -0.27795488f, -0.47701707f, 0.01692076f, 0.31413019f, 0.10027482f, 0.39378518f, 0.65515816f, -0.01646327f, 
    -0.13673389f, -0.10980645f, 0.52064294f, 0.35007134f, 0.15541618f, -0.45108631f, 0.29228452f, 0.68284309f, 
    0.04538717f, -0.37401003f, -0.13292073f, -0.20700638f, 0.28876895f, -0.63564515f, -0.59812945f, -0.54541969f, 
    1.10192442f, -0.11487541f, 0.81214172f, 0.36771205f, 0.41207522f, -0.21577518f, -0.42953014f, -0.41866663f, 
    0.24780984f, 0.01216863f, 0.20127846f, 0.76100844f, -0.50503534f, -0.32962161f, 0.06354844f, -0.42659694f, 
    -0.31222820f, 0.41391578f, -0.15171234f, -0.03022566f, 0.47066560f, -0.45910680f, 0.75357074f, 0.48878556f, 
    -0.09241079f, -0.18342249f, -0.72124481f, -0.68657917f, -0.47132954f, -0.42940694f, 0.09690967f, -0.57396317f, 
    -0.49109033f, -0.63331366f, 0.33324417f, -0.00315630f, 0.42369828f, -0.44577298f, -0.52994466f, -0.63910502f, 
    -0.29036078f, 0.13557041f, 0.48262858f, 0.35576963f, 0.13774350f, -0.12559761f, 0.00449764f, 1.09500659f, 
    0.36937228f, 0.45370978f, 1.30850661f, 1.07993817f, -0.17449600f, 0.38998041f, 0.05046941f, -0.56085443f, 
    0.09633012f, 0.20174226f, 0.00044103f, -0.02398053f, 0.24966018f, 0.32809624f, 0.04319363f, -0.02301119f, 
    0.36156127f, 0.07784329f, 0.23699388f, 0.12773693f, -0.13849527f, 0.00772189f, -0.00693925f, 0.22045410f, 
    -0.33995345f, 0.35942727f, 0.95715028f, 0.22219783f, 0.52968276f, 1.07176852f, 0.56549287f, 0.84806401f, 
    0.49212348f, 0.15760605f, 0.09638350f, -0.20536467f, -0.40824160f, -0.42402011f, -0.19030394f, 0.20687118f, 
    -0.30186495f, -0.40798613f, -0.12526233f, -0.20268542f, 0.09394544f, 0.36973596f, 0.12551135f, 0.09416717f, 
    0.03268675f, -1.21484518f, 0.30718714f, -0.03635309f, -0.09765413f, 0.55794275f, -1.16014600f, 0.68194783f, 
    0.47103938f, -1.17454827f, -0.77955538f, 0.03334009f, 0.43641046f, 0.34201214f, 0.19826543f, 0.61067349f, 
    0.09407061f, 0.10802656f, 0.07268548f, 0.07549248f, 0.10478097f, -0.00072519f, -0.04943901f, -0.14292865f, 
    0.27372861f, 0.02044265f, 1.32961893f, 0.42099556f, 0.23772341f, 0.55447894f, 0.25812566f, 0.34747908f, 
    0.09894746f, 0.42146221f, 0.67124629f, 0.36457437f, -0.47750595f, 0.05020821f, -0.40816325f, -0.18346900f, 
    -0.08519249f, 0.25053102f, -0.06098993f, -0.47581708f, -0.00887654f, 0.24956259f, -0.46161178f, -0.30590796f, 
    0.24429819f, -0.20917152f, -0.48717856f, 0.59213454f, 0.02526116f, 0.72607565f, 0.58561438f, 0.15055735f, 
    -0.74226141f, -1.34340668f, -0.26091102f, -0.46732724f, 0.24606833f, 0.55959851f, 0.34208506f, -0.51951599f, 
    -0.08031373f, -0.47837275f, 0.14627826f, -0.04945932f, -0.03548485f, -0.17443492f, 0.56999415f, -0.06109314f, 
    0.21065420f, 0.60647994f, -0.00138490f, -0.19150673f, -1.37110817f, -0.08180427f, -0.01368779f, 0.56127155f, 
    -1.22547197f, 0.59542835f, 1.05140269f, -0.13846339f, 0.65220970f, 0.31365260f, -0.11513036f, -0.27252671f, 
    0.10632512f, -0.08489598f, 0.00443184f, 0.13104936f, -0.19423313f, -0.03368896f, -0.35108757f, -0.18810292f, 
    -0.05664283f, 0.11592500f, 0.39089635f, 0.45583609f, 0.15190625f, 0.23145540f, 0.70019037f, 0.58370972f, 
    -0.09624871f, 0.96762431f, -0.54493397f, 0.65622312f, 0.47643584f, 0.13098019f, 0.74534994f, 0.03273860f, 
    -0.20514742f, 0.21404552f, -0.06196479f, 0.26100785f, -0.13744049f, 0.07750146f, -0.33578017f, 0.22555214f, 
    -0.04290451f, -0.23676462f, -0.10736736f, -0.52907199f, -0.43050849f, -0.14375179f, -0.80432773f, -0.55171537f, 
    -0.42094627f, -0.75638264f, -0.38964078f, -0.90770435f, -0.25384766f, 0.02550312f, -0.58154380f, 0.20636702f, 
    -0.05749269f, 0.10493880f, -0.05269517f, 0.22486542f, -0.41424325f, 0.44469866f, -0.33537057f, 0.17495908f, 
    -0.06585155f, 0.13760063f, -0.23254433f, -0.13292561f, 0.30263057f, -0.02050288f, 0.16658208f, -0.72196609f, 
    -0.17343229f, -0.64872956f, -0.79608202f, -1.03802562f, 0.66029400f, 0.41987577f, 0.18442439f, -0.08333712f, 
    0.61340636f, -0.79870719f, -0.29765752f, -0.33773226f, -0.32982665f, -0.77871305f, -0.17285419f, -0.20675553f, 
    0.00359509f, -0.12146984f, 0.10631060f, 0.01359863f, -0.28646347f, -0.38543597f, -0.40556327f, 0.26449093f, 
    1.07743835f, 0.06313279f, -0.40063930f, -0.98242724f, -0.68466586f, 0.78915167f, 0.31604731f, -0.06749335f, 
    -0.22745796f, -0.15083678f, 0.58638662f, 0.56508809f, -0.01042906f, 0.29862866f, 0.36513844f, -0.18271159f, 
    -0.37950909f, 0.01686563f, 0.08010597f, 0.14160457f, 0.23339613f, 0.54790568f, 0.19646245f, 0.51038998f, 
    -0.17752802f, -0.37502450f, -1.15040350f, -0.76135337f, -0.19580074f, -0.49935961f, 0.54823732f, 1.18875980f, 
    -0.03661487f, -0.01167986f, 0.33017415f, 0.07517904f, -0.24946947f, -0.34008023f, -0.26559770f, -0.04050471f, 
    -0.02770540f, 0.32780626f, -0.37200731f, -0.12519562f, 0.01311349f, -0.11484417f, 0.08344844f, 0.33605188f, 
    0.36943248f, -0.07667244f, -1.11915040f, -0.38429719f, -0.47417548f, -0.48975325f, 0.10147240f, 0.58070135f, 
    0.94853431f, 0.12784474f, -0.16007389f, 0.49241391f, 0.12208698f, -0.24230373f, 0.20278300f, -0.31701902f, 
    0.22916904f, -0.06383707f, -0.02899154f, 0.52489239f, 0.00019506f, -0.30672297f, 0.13295954f, -0.30112556f, 
    -0.14806555f, -0.46751013f, -0.28543687f, -0.30796596f, -0.31253147f, 0.02469124f, 1.14631641f, -0.42485100f, 
    -0.56084085f, -1.03277421f, -0.35892043f, 0.02224659f, 0.05663291f, 0.18535285f, 0.23330662f, 0.17256771f, 
    -0.06142611f, 0.33837554f, 0.43660060f, -0.31577331f, 0.18285576f, 0.47184280f, -0.26249245f, 0.02514098f, 
    0.29797855f, -0.15219447f, -0.16361715f, -0.43747798f, 1.38610554f, 0.28070474f, 0.19105029f, 0.95884413f, 
    0.48894769f, -0.51942909f, 0.72214323f, -0.67145199f, 0.16191578f, 0.46104971f, 0.33592078f, 0.12175358f, 
    -0.39169061f, -0.03769263f, -0.59489357f, -0.31443551f, -0.25641859f, -0.20518421f, -0.18479019f, -0.09640678f, 
    -0.00660724f, 0.49946666f, -0.00253240f, 0.21661547f, 0.06085696f, -1.18339670f, -0.07498012f, 0.88919008f, 
    -0.93209726f, -1.00070333f, 0.65549314f, -0.29545906f, -0.34188646f, -0.44531143f, -0.42077073f, -0.12897469f, 
    0.52776510f, -0.05642273f, 0.36559165f, 0.26772916f, -0.15565087f, 0.17338450f, 0.24754439f, -0.14184861f, 
    -0.06327351f, 0.17900960f, -0.11156092f, -0.24735467f, -0.19065389f, -0.35601899f, 1.00129449f, 1.25452471f, 
    -0.07773108f, -0.36153430f, -1.02463984f, -0.37314874f, -0.39117810f, 0.59780401f, -0.35478717f, 0.43111169f, 
    0.34000558f, 0.24530442f, -0.23575719f, 0.35670164f, 0.19743460f, 0.22832391f, 0.12158580f, -0.17145650f, 
    -0.28459951f, 0.03431706f, -0.21902086f, 0.15341991f, 0.04459563f, -0.12557156f, -0.02710405f, 0.47190928f, 
    -0.04948980f, 0.27755648f, 1.14941049f, -0.79976696f, 0.46990821f, -0.12826537f, -0.20582968f, -0.29699355f, 
    -0.76933527f, 0.04869060f, -0.14206822f, 0.34594810f, -0.14615117f, 0.40534690f, 0.15420154f, 0.13553390f, 
    -0.33342853f, 0.03286668f, -0.22618994f, -0.14207935f, 0.13329065f, 0.37965032f, -0.31028992f, 0.20383042f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13686545f, 0.17195526f, 0.13104048f, 0.32930592f, 0.04676563f, 0.19094126f, 0.25668326f, 0.29489598f, 
    0.17289747f, 0.32509384f, 0.17309019f, 0.54851562f, 0.45243561f, -0.00078935f, 0.12805001f, 0.12648264f, 
    0.20030133f, 0.14463007f, 0.29947889f, 0.17768566f, 0.02504153f, 0.24347529f, 0.31984952f, -0.25415608f, 
    0.28353739f, 0.33558166f, 0.09022913f, 0.19319627f, 0.20502645f, 0.49203262f, 0.14620346f, 0.20692004f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13794822f, 0.00193402f, 0.23838896f, -0.04836126f, -0.01313651f, 0.12367634f, -0.10032076f, -0.04082407f, 
    0.07140754f, 0.07884590f, -0.08370120f, 0.16492769f, -0.02497882f, -0.13428932f, 0.00181898f, 0.10975590f, 
    -0.11170069f, 0.02619766f, -0.13490635f, 0.08505482f, 0.14444833f, -0.02202435f, -0.12414832f, 0.03939183f, 
    0.39061242f, -0.22991048f, -0.28919253f, 0.03235101f, 0.05876670f, -0.01076022f, -0.09384204f, 0.01465686f, 
    -0.03842413f, 0.16896020f, -0.16987149f, 0.11379205f, 0.15455809f, 0.00260428f, 0.10167067f, -0.42256638f, 
    -0.03287469f, 0.04879624f, -0.02512718f, -0.06012163f, 0.12448099f, 0.04020264f, -0.03408551f, 0.10167084f, 
    0.10993083f, 0.05189893f, 0.15618160f, -0.21471874f, -0.10864763f, -0.05219527f, 0.08230036f, 0.07626824f, 
    0.07182917f, 0.05085939f, -0.21590360f, 0.08315290f, -0.11663967f, 0.16665785f, 0.03951227f, -0.03390610f, 
    -0.24108662f, -0.09149332f, -0.11203036f, 0.05758195f, -0.10578166f, 0.07219259f, 0.10253342f, 0.01560267f, 
    0.12548672f, 0.15480860f, 0.11369655f, -0.22085598f, 0.06779840f, -0.14988522f, -0.02615743f, 0.07274569f, 
    -0.03252601f, -0.11955418f, -0.11435532f, 0.10795175f, -0.34463358f, -0.07234851f, -0.03331131f, -0.65949607f, 
    0.06251860f, 0.01379137f, 0.05398167f, -0.14932203f, 0.00108464f, -0.06770421f, 0.04917460f, 0.02289734f, 
    0.34876534f, 0.01607594f, -0.22696406f, -0.20964839f, -0.24546601f, -0.06911689f, 0.00442950f, 0.12810931f, 
    0.03671065f, 0.03201666f, -0.13051602f, -0.20275116f, -0.42203897f, 0.31328723f, -0.06742037f, -0.11832320f, 
    -0.08753962f, 0.06525978f, 0.08872418f, 0.04294111f, -0.08549540f, 0.09628165f, 0.01849689f, 0.07784867f, 
    -0.35948464f, -0.01445123f, -0.00096236f, 0.32850155f, 0.08115364f, 0.08732676f, 0.10842058f, -0.01025785f, 
    0.07107062f, -0.18407094f, -0.04512398f, -0.08460443f, 0.12723203f, -0.25717911f, 0.19932042f, 0.01643970f, 
    0.02786900f, 0.08734047f, 0.06899937f, -0.02430745f, -0.18021719f, -0.09343579f, 0.03781513f, -0.03433021f, 
    -0.17083430f, 0.06749783f, -0.13108981f, -0.15081459f, -0.02342848f, -0.02380332f, 0.04659989f, -0.05295057f, 
    0.01422876f, -0.07573151f, 0.06094181f, 0.02558243f, 0.02518059f, 0.16039707f, -0.21996073f, 0.10436797f, 
    0.04752264f, -0.00552470f, -0.03301215f, -0.03098487f, 0.15490337f, -0.09704889f, 0.06472019f, -0.00557373f, 
    -0.07248266f, -0.13676776f, -0.08531237f, -0.18229784f, -0.01874005f, 0.12840800f, 0.02438782f, 0.05413409f, 
    -0.03452919f, -0.03357521f, 0.03008078f, 0.11341022f, 0.36768079f, -0.05846632f, -0.01495931f, 0.32410714f, 
    -0.40036219f, -0.07491487f, -0.00273535f, 0.10309049f, -0.05573315f, -0.03156414f, -0.02183298f, -0.08686658f, 
    -0.13056614f, -0.00429598f, 0.18097864f, 0.08535317f, -0.07576264f, 0.00445608f, 0.13466488f, -0.26596469f, 
    -0.06800367f, 0.04379279f, 0.08986238f, -0.06373728f, -0.68465233f, 0.19859931f, -0.19477445f, 0.16797592f, 
    0.05838195f, -0.05482695f, 0.03817545f, 0.02569540f, 0.05905391f, -0.02470724f, -0.09170038f, -0.07188583f, 
    0.36841455f, -0.33631131f, -0.07669758f, 0.13455863f, -0.22600134f, 0.06528101f, -0.11435952f, 0.17825371f, 
    0.00151146f, -0.08750537f, 0.06096575f, -0.11534928f, 0.16183355f, -0.28900772f, -0.04715306f, 0.32550311f, 
    -0.20339890f, -0.15235236f, -0.15660031f, 0.01599176f, 0.00601068f, -0.23146860f, 0.06175565f, -0.06038176f, 
    0.82465822f, 0.36278892f, -0.07229458f, -0.00480130f, 0.03968139f, 0.00683116f, -0.16372032f, 0.00480256f, 
    0.02742025f, -0.03494593f, 0.03205122f, 0.03976224f, -0.09879378f, -0.12598091f, 0.01634577f, -0.14735165f, 
    -0.06829000f, 0.15406774f, -0.00406737f, 0.03014228f, -0.02210720f, 0.01378968f, 0.08963201f, -0.02521757f, 
    -0.48033702f, -0.33009830f, -0.11724239f, -0.14389586f, -0.15425965f, -0.03789167f, 0.09329259f, 0.23444922f, 
    0.06631980f, -0.04445790f, -0.01227869f, -0.15709186f, 0.41846347f, 0.08064629f, -0.13333432f, -0.37488765f, 
    0.16929178f, 0.00480710f, 0.04459056f, 0.04680366f, 0.02090710f, -0.10766583f, -0.05917973f, 0.00842547f, 
    -0.08568458f, -0.15267609f, -0.01774458f, -0.22453123f, -0.01832242f, 0.12117432f, 0.16148995f, -0.24125564f, 
    -0.02820699f, -0.09960388f, 0.08063106f, 0.11131863f, 0.00424059f, 0.19034584f, 0.21283722f, -0.33172059f, 
    0.01490498f, 0.19456062f, -0.04453762f, 0.06772316f, 0.00955108f, 0.03821942f, 0.08867591f, 0.08858905f, 
    0.25072169f, 0.03388498f, 0.16503614f, -0.23435226f, 0.18217386f, -0.02915116f, -0.05799963f, 0.06133758f, 
    0.04375046f, -0.04412508f, -0.04133729f, 0.17651324f, -0.15570128f, 0.06582656f, -0.22512396f, 0.21469831f, 
    0.16171709f, 0.08598571f, 0.05468736f, -0.02857545f, -0.15740865f, -0.03151423f, -0.21544176f, -0.02439414f, 
    0.22195183f, 0.04595049f, 0.00131515f, 0.43359560f, -0.07305747f, -0.20345861f, -0.08191676f, 0.10636648f, 
    -0.16298962f, 0.07098112f, -0.04349004f, -0.08552346f, -0.59186256f, 0.21128574f, 0.23012903f, 0.04218721f, 
    -0.10105189f, 0.00280408f, 0.00387566f, -0.09093477f, 0.09201736f, 0.07028394f, -0.00857934f, -0.15570182f, 
    -0.48754704f, 0.02312814f, 0.06507799f, -0.27910838f, -0.03841164f, -0.02812313f, -0.01005655f, 0.10363686f, 
    -0.21949124f, 0.00578000f, -0.01621190f, -0.00847004f, 0.08924834f, 0.15595368f, -0.16536966f, 0.21393649f, 
    -0.02377269f, 0.07860082f, -0.06274924f, 0.04790810f, -0.22377221f, 0.05791315f, -0.01334160f, 0.08447886f, 
    0.10494012f, -0.05458999f, -0.03025047f, 0.17021590f, -0.13097574f, -0.02605672f, -0.03160875f, 0.17553553f, 
    0.06746137f, -0.01606696f, -0.12975213f, -0.09446091f, 0.27931142f, -0.73165476f, -0.20876458f, -0.14706072f, 
    -0.09456149f, -0.14566657f, -0.18063796f, 0.07920275f, -0.19384293f, -0.08952281f, -0.11837466f, -0.00167565f, 
    -0.15419883f, 0.21272965f, -0.25486806f, 0.05333802f, -0.04521893f, -0.10994375f, 0.12748015f, 0.25569803f, 
    0.10162134f, -0.17608695f, 0.03202732f, 0.04272304f, -0.00436846f, -0.03159493f, 0.22706689f, -0.36898807f, 
    0.00295655f, -0.15964280f, -0.02169680f, 0.12666272f, -0.08176526f, -0.01420827f, 0.10038423f, -0.02767768f, 
    0.20313638f, 0.04855086f, 0.00160455f, 0.12662143f, -0.10447148f, -0.03980073f, 0.09011649f, 0.03419778f, 
    0.04781373f, -0.04451708f, 0.10139731f, 0.05699584f, 0.39197630f, -0.37565479f, 0.14576523f, 0.13239554f, 
    -0.06527055f, -0.14665547f, -0.14521360f, 0.10013156f, 0.02001549f, 0.07213059f, -0.23360129f, 0.03404631f, 
    0.20918287f, 0.00097935f, 0.01489915f, -0.39559630f, 0.08553983f, 0.07985511f, 0.03134531f, -0.12542592f, 
    -0.08489139f, -0.20900106f, 0.15287073f, -0.20095959f, 0.52574223f, -0.34280828f, 0.00660856f, -0.42582220f, 
    0.03425780f, -0.14797264f, -0.05497276f, 0.17703323f, -0.07849669f, -0.03197692f, -0.09510592f, -0.01927740f, 
    0.00080231f, 0.03813218f, 0.11910167f, 0.21216032f, -0.01281414f, -0.08895296f, 0.10251772f, -0.05836508f, 
    0.03899356f, 0.05331783f, -0.17471252f, 0.09548531f, 0.36981130f, -0.33731607f, -0.01789336f, -0.00824492f, 
    0.00396212f, 0.08976382f, 0.06698102f, 0.05592974f, 0.27672324f, 0.07435548f, -0.12369158f, -0.06569243f, 
    -0.13764863f, 0.35133082f, -0.16074625f, 0.10971718f, -0.24323367f, 0.03818554f, -0.02010427f, -0.08858719f, 
    -0.07374645f, 0.17667824f, 0.02576251f, -0.08049691f, 0.21689774f, -0.29703942f, -0.03676282f, -0.53070307f, 
    -0.05874895f, -0.01106655f, 0.08876307f, 0.00699878f, -0.03263200f, 0.03942553f, 0.07930322f, 0.11803106f, 
    0.23317721f, -0.22926037f, 0.08983263f, -0.05093785f, -0.01128003f, 0.01141826f, -0.10769816f, 0.11645988f, 
    -0.19386218f, 0.08952122f, -0.00496758f, 0.17791101f, 0.24507779f, 0.01143121f, -0.28301293f, 0.30870673f, 
    0.02693893f, 0.05992971f, -0.17103444f, -0.10694848f, -0.07522866f, 0.05924290f, -0.13601521f, 0.15722226f, 
    -0.11363599f, -0.24988878f, -0.16364318f, -0.10314701f, 0.00719438f, -0.00837844f, 0.08046947f, 0.13963848f, 
    -0.26677129f, -0.01579395f, -0.29016209f, -0.03663392f, 0.23835470f, -0.02977662f, 0.06037424f, 0.33517668f, 
    -0.13051541f, 0.06749725f, 0.02431970f, 0.06096627f, 0.09325727f, 0.10604454f, -0.03592140f, 0.04319648f, 
    0.09412095f, 0.20086379f, 0.10200670f, 0.16784053f, -0.07855246f, 0.11662912f, 0.05672066f, 0.00440578f, 
    0.14822166f, 0.05250820f, 0.01532682f, -0.00803971f, -0.25808522f, 0.09414595f, -0.11673674f, -0.22150914f, 
    0.01562167f, 0.03009607f, -0.02198062f, -0.07079368f, 0.02374641f, 0.09879202f, 0.09426436f, -0.04193682f, 
    0.50141627f, 0.03970169f, 0.15602899f, 0.24539928f, -0.06818627f, -0.15477669f, -0.03107848f, -0.08638083f, 
    -0.05356696f, -0.00117203f, -0.04645170f, -0.04666136f, -0.24961816f, 0.04780602f, 0.16365597f, 0.11031874f, 
    0.05672211f, -0.03196403f, 0.14513531f, 0.07098065f, -0.00598601f, 0.18330944f, 0.07127810f, 0.11226983f, 
    -0.71886605f, -0.06836671f, -0.16614400f, -0.08358944f, 0.07968967f, -0.01244438f, 0.02728065f, -0.07671341f, 
    -0.03947694f, -0.08611976f, 0.11794972f, 0.16225156f, 0.23492303f, 0.18612926f, 0.03932573f, 0.14408217f, 
    -0.04136929f, -0.12098488f, -0.02035761f, 0.06189552f, 0.11707724f, -0.00193752f, -0.23173867f, -0.01895120f, 
    0.02663058f, 0.02088025f, 0.03662224f, -0.13856165f, 0.10331547f, -0.05443873f, 0.07188440f, 0.01253896f, 
    -0.06017615f, 0.08193501f, 0.04808271f, 0.07465155f, -0.53237593f, -0.17216988f, 0.06028458f, -0.16888730f, 
    0.12719263f, -0.16707699f, -0.22282679f, 0.02297105f, 0.04302869f, 0.10805926f, -0.09036854f, -0.15386519f, 
    0.26160058f, -0.29763469f, 0.14787231f, -0.15386733f, 0.02870331f, -0.14779663f, -0.12060940f, 0.01733035f, 
    -0.23046139f, -0.01061095f, -0.22787769f, 0.00882082f, 0.16208462f, -0.19105759f, -0.35149285f, -0.06276817f, 
    0.02023859f, -0.03150982f, -0.06438462f, -0.22559789f, 0.07315014f, 0.02359031f, -0.14547610f, 0.10429063f, 
    0.11461078f, 0.06390132f, -0.15515777f, -0.03168554f, 0.03614062f, 0.07077969f, -0.15065838f, 0.13252003f, 
    0.00496185f, 0.10922723f, 0.00080217f, 0.02259536f, -0.33499417f, -0.08495498f, -0.30230898f, 0.03333087f, 
    -0.08716372f, -0.06346153f, -0.12345897f, 0.01719174f, -0.11318344f, 0.00903878f, 0.07630694f, 0.19346470f, 
    0.42325616f, -0.06199936f, 0.15428372f, 0.15139024f, -0.13434659f, 0.09938548f, 0.12213618f, -0.00268991f, 
    0.04105613f, -0.00099675f, 0.01016964f, -0.05269308f, -0.27125886f, 0.02078167f, -0.08950630f, 0.14272383f, 
    0.01744686f, 0.02169977f, -0.00254711f, -0.06188313f, 0.03377855f, -0.01222233f, -0.15453164f, 0.05941386f, 
    0.11701444f, 0.03404735f, -0.11488911f, -0.16523001f, -0.24652119f, -0.12906963f, -0.09157908f, -0.07983044f, 
    -0.13022208f, 0.06756447f, 0.06905027f, 0.16121899f, -0.26915145f, -0.17264602f, -0.18316749f, -0.03739876f, 
    -0.05593275f, -0.07305401f, 0.08305719f, 0.03502901f, 0.17734353f, -0.00593138f, -0.07719978f, 0.04776933f, 
    0.34729850f, -0.32506037f, -0.03102986f, 0.09203811f, -0.06321276f, 0.09801479f, -0.02312495f, -0.12609123f, 
    0.08405233f, -0.03849622f, 0.12209777f, -0.04400541f, -0.35095266f, -0.00065345f, -0.10397021f, -0.19528176f, 
    0.08857215f, 0.02662315f, 0.09507713f, 0.07523321f, 0.03298348f, 0.14286141f, -0.14711528f, -0.06795177f, 
    0.25378212f, -0.41935405f, 0.32685748f, 0.08043265f, -0.23261455f, -0.11824018f, -0.12361900f, -0.06020579f, 
    -0.13191786f, -0.03319342f, -0.00693074f, -0.05988783f, 0.10207354f, -0.00117945f, -0.05943658f, -0.03428674f, 
    0.03747971f, -0.03775927f, 0.14081162f, -0.07726924f, 0.02005966f, -0.09548831f, -0.00970348f, -0.07733805f, 
    -0.27133748f, 0.03068190f, 0.06513768f, 0.00569064f, 0.11181150f, 0.06485058f, 0.11045501f, -0.16667271f, 
    -0.03277727f, 0.05472005f, -0.08526648f, -0.08254874f, 0.35750401f, -0.11494204f, -0.31862077f, -0.01653672f, 
    0.01654188f, -0.17428033f, 0.07515629f, 0.04334345f, -0.00356171f, -0.01819482f, 0.23595290f, -0.08197185f, 
    0.16559543f, 0.05400277f, -0.28926980f, 0.16288778f, 0.01113753f, -0.07553975f, -0.08738394f, 0.00833106f, 
    -0.03946701f, 0.04350109f, 0.01002724f, -0.16626607f, -0.06660555f, 0.05419947f, 0.06474714f, 0.26054689f, 
    -0.11673786f, -0.27623427f, 0.11814348f, 0.12353973f, -0.10961571f, -0.16663200f, 0.08987177f, -0.02240719f, 
    -0.18776594f, 0.12734973f, -0.24453720f, -0.13701244f, 0.06223945f, 0.09808497f, -0.02109777f, 0.01961947f, 
    -0.04251634f, -0.05342221f, 0.02751660f, -0.00768192f, 0.39163053f, -0.10641561f, 0.01008658f, 0.16645335f, 
    -0.19026403f, 0.03091474f, 0.11821024f, -0.04297239f, -0.00239066f, -0.02129175f, 0.05818867f, 0.19062746f, 
    0.24051453f, -0.03913837f, -0.18950385f, 0.17289439f, -0.19649068f, 0.12115467f, -0.19357757f, -0.10288908f, 
    0.13384372f, -0.11282431f, 0.06564452f, -0.20683974f, -0.33808753f, -0.30950627f, 0.07060459f, -0.31991687f, 
    0.11340271f, 0.12454613f, 0.15149578f, -0.22317788f, -0.05756270f, -0.07775507f, 0.02773610f, -0.05561989f, 
    0.18166025f, -0.10478549f, 0.23252174f, 0.17896375f, -0.16891102f, -0.05388153f, 0.03096181f, -0.00399427f, 
    -0.10826433f, -0.12009210f, 0.09576356f, -0.03021460f, 0.03220426f, 0.04169478f, 0.07326193f, 0.00327850f, 
    -0.15925382f, -0.04014605f, -0.15042621f, 0.17554235f, 0.17038894f, -0.17557172f, -0.04546570f, -0.00610369f, 
    -0.41980222f, 0.06453081f, -0.05006618f, -0.25938848f, -0.08337998f, -0.12329115f, 0.15151447f, -0.31531161f, 
    -0.03357803f, 0.16450134f, 0.05540801f, 0.00331490f, 0.15604340f, 0.00721165f, 0.00602372f, 0.03386031f, 
    0.24012823f, 0.11975086f, 0.00937197f, 0.02770777f, -0.05255264f, -0.04027968f, -0.04045618f, -0.01371553f, 
    0.31861460f, 0.02817227f, -0.05971113f, 0.04114645f, -0.02492692f, -0.04187630f, 0.02837079f, -0.02586942f, 
    0.04310721f, 0.05209165f, -0.06773286f, -0.00861777f, 0.63795024f, 0.02164394f, -0.32258469f, -0.18251303f, 
    0.06459018f, 0.19714218f, -0.13979380f, 0.01639114f, -0.10308445f, -0.05179061f, -0.07179877f, 0.01801769f, 
    -0.11933603f, 0.04910538f, -0.10522653f, -0.08462436f, 0.22868294f, 0.04574078f, -0.02502817f, 0.12783751f, 
    -0.13548534f, -0.01560445f, 0.00545463f, -0.19764933f, -0.17208944f, 0.16769473f, -0.18278335f, 0.03025701f, 
    -0.14992321f, 0.11371358f, -0.06238446f, -0.00940973f, -0.19334322f, -0.15181313f, 0.06655420f, -0.06080819f, 
    0.51611942f, -0.02326478f, 0.06766385f, 0.05354651f, 0.03525417f, -0.09758759f, -0.13297345f, 0.15731417f, 
    -0.02215830f, 0.06451161f, -0.03357229f, -0.05098008f, 0.05562843f, -0.01604172f, 0.06755316f, -0.01475192f, 
    0.06718487f, -0.00743124f, 0.10258700f, -0.19474971f, -0.02396826f, 0.01973734f, 0.03780907f, 0.09616391f, 
    0.15627605f, -0.15142626f, -0.30890423f, -0.02373213f, -0.14908986f, -0.03379398f, -0.20018379f, -0.09220075f, 
    -0.09249117f, -0.09573111f, -0.10722001f, 0.12200547f, 0.29819801f, 0.11653788f, 0.00120953f, 0.22573283f, 
    0.01950334f, -0.00735257f, 0.13604102f, 0.03353680f, -0.00456827f, 0.17483255f, 0.00362104f, -0.09550212f, 
    -0.22407082f, 0.08736087f, 0.16447583f, -0.21974880f, -0.07569222f, -0.08058251f, 0.13751377f, -0.13933066f, 
    -0.01498011f, -0.15150142f, 0.02150744f, -0.03114094f, 0.30246705f, -0.26261455f, 0.35360056f, 0.09193917f, 
    -0.13048944f, -0.20859617f, -0.05120616f, 0.14825846f, 0.10252878f, 0.00037187f, 0.09623227f, -0.08871713f, 
    0.43459550f, -0.01711835f, 0.17256555f, 0.13603222f, 0.00634444f, -0.20723549f, 0.07495773f, 0.01448817f, 
    -0.00980490f, -0.03592717f, -0.05727173f, -0.07150888f, 0.07019323f, -0.18781595f, -0.02813488f, -0.17695664f, 
    0.02559968f, 0.14135508f, -0.28069755f, -0.14264371f, 0.05340577f, 0.02884585f, -0.04210128f, -0.06937687f, 
    0.09794988f, 0.22712751f, 0.13726960f, -0.25270280f, 0.08230475f, -0.06803256f, -0.03886156f, 0.09579749f, 
    -0.18150102f, 0.18196392f, 0.07110922f, 0.06453821f, 0.09639866f, -0.08306316f, -0.26811567f, -0.42999586f, 
    -0.13420717f, -0.10533633f, 0.06895880f, 0.10748824f, -0.00651017f, -0.04842020f, -0.10874340f, -0.16004667f, 
    -0.27269852f, 0.14679962f, 0.06765024f, -0.18907313f, -0.14171962f, -0.09212772f, 0.19541050f, 0.04459516f, 
    -0.10341751f, -0.06954030f, -0.12117129f, -0.04598581f, -0.21657149f, -0.07671597f, -0.21869680f, -0.24465692f, 
    0.03578373f, 0.07740926f, -0.24392608f, 0.04023772f, 0.06497196f, 0.13224874f, -0.11274979f, -0.15230340f, 
    0.35391989f, 0.08648922f, 0.03624144f, -0.05143294f, 0.09948221f, -0.01041759f, 0.05251353f, 0.02615244f, 
    -0.16318853f, -0.02150543f, 0.02601761f, -0.02146589f, 0.48794723f, 0.03901508f, 0.38157895f, -0.07173721f, 
    -0.00400095f, 0.07136621f, 0.00891886f, 0.04273245f, -0.00118433f, -0.09395080f, -0.02931834f, -0.05360803f, 
    -0.01421794f, 0.23966314f, 0.02387214f, -0.22695616f, -0.18275225f, 0.06182735f, -0.03986535f, 0.09460415f, 
    0.15346855f, -0.03669122f, 0.01144334f, 0.08326996f, 0.10821170f, 0.11862265f, 0.16825072f, -0.11587285f, 
    -0.29945719f, 0.09560260f, 0.02932288f, 0.01884270f, -0.06371885f, -0.09397365f, 0.04513882f, 0.20766491f, 
    0.03346737f, -0.52853429f, -0.19859758f, 0.35554561f, 0.01276498f, 0.02256031f, 0.10363361f, -0.19154507f, 
    0.04107250f, 0.01457010f, -0.22191489f, -0.05298407f, 0.48810211f, -0.51396000f, 0.03844983f, -0.18189305f, 
    0.09137783f, 0.04107375f, 0.07178932f, -0.01520116f, -0.07342701f, 0.00550227f, -0.00919698f, -0.13197130f, 
    -0.25898591f, 0.20938647f, 0.03296342f, -0.03424021f, -0.00755664f, 0.06667472f, 0.13265787f, 0.05380105f, 
    -0.01082103f, 0.08778896f, 0.02584941f, 0.12874746f, -0.01197302f, -0.33636531f, -0.04064951f, 0.05729121f, 
    -0.05381722f, 0.04015741f, -0.05044885f, -0.03717134f, -0.04041135f, -0.01342506f, -0.03711883f, 0.08356393f, 
    -0.65182394f, -0.44120485f, -0.05828348f, 0.01503309f, -0.08381162f, -0.03714144f, 0.12822920f, 0.07534019f, 
    -0.04399092f, -0.27379614f, 0.12082121f, -0.17883831f, -0.16218953f, 0.12413079f, -0.04746251f, 0.09405361f, 
    -0.16059904f, -0.05756200f, 0.07444873f, -0.00135968f, -0.18342026f, 0.07821391f, -0.04268560f, -0.06705146f, 
    -0.11042043f, 0.04359656f, 0.17213972f, -0.05018681f, 0.02926473f, -0.12757346f, -0.00279396f, 0.08101036f, 
    -0.05061740f, -0.01145839f, 0.03658681f, -0.04091383f, 0.06814013f, 0.37819648f, 0.19648445f, 0.05937333f, 
    0.03793807f, 0.17093693f, -0.04657511f, -0.02705819f, 0.01850654f, -0.02362039f, -0.05209537f, -0.00202768f, 
    0.09502125f, -0.22099657f, -0.11190459f, -0.30518818f, -0.12123258f, -0.15983735f, -0.01755118f, -0.00011223f, 
    -0.01528882f, -0.07978329f, 0.06693286f, -0.00853175f, 0.32490706f, 0.20752864f, -0.17532010f, -0.08748163f, 
    0.02573363f, 0.02057823f, 0.03203798f, -0.11555185f, 0.03502908f, 0.00340785f, 0.07734434f, -0.02314622f, 
    0.29422477f, 0.05670318f, 0.17017925f, -0.17267577f, -0.05047776f, 0.00067129f, -0.03734221f, 0.02962957f, 
    0.13589682f, 0.18549375f, 0.09165464f, 0.08286113f, -0.70650756f, -0.60598546f, 0.18996857f, 0.11700851f, 
    -0.02181302f, 0.05110779f, -0.01943997f, -0.15891320f, 0.06819399f, -0.07791920f, -0.02524173f, -0.12598522f, 
    -0.98586732f, -0.22229017f, -0.13370275f, -0.12442460f, -0.07377298f, -0.26809591f, -0.08582474f, -0.12864105f, 
    0.08378698f, 0.07144013f, 0.10141346f, -0.07975955f, -0.36537674f, 0.32607436f, 0.47066554f, -0.10010763f, 
    0.06636179f, -0.04235912f, 0.04329460f, 0.17848901f, 0.01969361f, 0.03172058f, -0.26972523f, 0.07111870f, 
    -0.31667313f, -0.43456727f, -0.18592265f, -0.14139457f, -0.21197754f, -0.03172441f, 0.00497156f, -0.08519678f, 
    0.12114158f, 0.04436252f, -0.04109331f, 0.06620597f, 0.19611564f, -0.03241573f, -0.04202290f, 0.46114853f, 
    0.16273879f, 0.27167273f, -0.09457568f, -0.05969209f, -0.09049425f, -0.06362202f, -0.00494844f, -0.21757509f, 
    -0.01747135f, 0.22704950f, 0.04643923f, -0.18320136f, -0.00953776f, -0.04255306f, -0.03728695f, 0.02772837f, 
    -0.10970146f, -0.10776883f, 0.02434118f, -0.14090897f, -0.88329297f, -0.04101604f, -0.21241947f, -0.19678783f, 
    -0.01644497f, 0.05088218f, 0.00762047f, -0.05214904f, -0.02408747f, -0.06302896f, 0.08501958f, 0.01609973f, 
    0.04690203f, 0.22363004f, 0.18878630f, 0.01713139f, -0.18969451f, -0.09834692f, -0.04435803f, 0.07065603f, 
    0.15650442f, -0.00671276f, 0.09490974f, 0.05958051f, -0.21965572f, 0.04623801f, 0.11697279f, -0.23935890f, 
    0.01230861f, -0.06809375f, 0.12653393f, 0.07816099f, -0.13246655f, -0.03606966f, -0.02936425f, -0.02261636f, 
    -0.07911336f, -0.17676459f, 0.00412583f, 0.03254320f, -0.10270651f, -0.00265734f, 0.09250645f, 0.17917898f, 
    -0.10554691f, -0.13269910f, 0.05822255f, -0.02726582f, 0.12279770f, -0.14240380f, -0.12918136f, -0.04306066f, 
    -0.20795935f, -0.17441206f, 0.05482314f, 0.05939350f, -0.01807577f, -0.01979545f, 0.09239814f, -0.09253272f, 
    -0.25543740f, 0.08510830f, -0.03723650f, -0.16920820f, -0.05322885f, -0.15241584f, -0.01283180f, 0.12179787f, 
    0.03814737f, -0.08592302f, -0.07747947f, 0.03418653f, 0.38329718f, -0.01892671f, 0.11453931f, 0.21722651f, 
    0.07807010f, 0.22494213f, 0.16082151f, 0.06318428f, -0.03223209f, -0.07077004f, 0.01145770f, -0.03365198f, 
    -0.44984514f, -0.49697965f, -0.18488362f, -0.01296416f, -0.01167263f, 0.10814442f, -0.05104249f, 0.03766093f, 
    0.02199980f, 0.13658275f, 0.15459616f, 0.01753337f, 0.19007574f, 0.07984140f, 0.22383875f, -0.22842379f, 
    -0.04587177f, 0.01643587f, 0.06747639f, 0.15770791f, 0.03617315f, 0.01265180f, -0.01958079f, 0.04971210f, 
    0.06518975f, -0.56764036f, -0.08404839f, 0.09005162f, -0.17403361f, -0.00861338f, -0.12863778f, 0.18637130f, 
    0.18957222f, 0.08808976f, -0.06393722f, 0.00919736f, 0.34294608f, -0.06700210f, -0.11691045f, 0.16347751f, 
    0.07521515f, 0.02627775f, 0.01271291f, 0.04569168f, 0.03187020f, -0.01711861f, -0.06981523f, -0.01604985f, 
    0.03098302f, 0.27130559f, -0.23973213f, 0.05694544f, 0.07766479f, -0.20561276f, 0.07372090f, -0.00630876f, 
    0.05917660f, -0.03578757f, 0.00171186f, -0.05874045f, 0.18913028f, 0.24229412f, -0.07113016f, 0.17493281f, 
    -0.06211144f, 0.09531451f, -0.02201163f, -0.11174943f, 0.12701908f, -0.15391614f, 0.00674273f, 0.09323511f, 
    0.33907413f, 0.08385052f, -0.02898020f, -0.01585906f, 0.05243504f, 0.01470215f, 0.00770897f, 0.03303792f, 
    -0.02103697f, -0.01975811f, 0.19024985f, 0.02501610f, -0.14338543f, -0.08871111f, 0.01896838f, 0.08873421f, 
    -0.19700553f, -0.09020679f, 0.07775538f, 0.00716816f, 0.06432560f, -0.00291964f, -0.15630466f, 0.03751883f, 
    -0.31718221f, -0.30885097f, 0.21283780f, 0.08875335f, -0.12574565f, -0.01634571f, -0.03988098f, 0.07461935f, 
    0.21749206f, -0.04313508f, -0.08496024f, -0.06505477f, 0.49419507f, -0.23612720f, -0.23061356f, 0.02390227f, 
    -0.10423139f, -0.03491081f, 0.08736807f, -0.27640358f, -0.02486525f, 0.09370819f, -0.06334679f, -0.13243945f, 
    -0.01626731f, -0.05946579f, 0.07763320f, -0.11912803f, -0.12985550f, -0.08477793f, -0.02575480f, 0.00645990f, 
    0.09467872f, -0.00099108f, 0.08029623f, 0.09588773f, -0.30731347f, -0.00458445f, 0.22473827f, 0.03816706f, 
    -0.09916590f, 0.21813326f, 0.05998559f, -0.03028237f, 0.09061141f, 0.00706847f, 0.16684854f, 0.05560841f, 
    -0.14244485f, 0.04753058f, 0.37331504f, -0.00973271f, 0.11122926f, -0.01635116f, -0.04100666f, 0.05257288f, 
    0.14582200f, -0.00730861f, 0.11009906f, -0.20443052f, -0.66153824f, 0.35663593f, 0.05509415f, 0.11693233f, 
    -0.07074595f, 0.03714400f, -0.12693799f, -0.08401228f, -0.07276962f, 0.03434474f, 0.12180988f, -0.02584198f, 
    -0.04399111f, 0.06675320f, -0.08485913f, -0.40449953f, 0.07733741f, -0.01156687f, -0.09565980f, 0.15777370f, 
    0.00352714f, -0.12844503f, -0.10596675f, -0.00168376f, 0.08759467f, -0.04985931f, -0.11325337f, 0.14492771f, 
    -0.00195533f, -0.01982660f, 0.07390321f, 0.08306838f, 0.13095751f, 0.04753054f, -0.02398944f, -0.13901800f, 
    0.00223609f, 0.06996518f, -0.08511045f, 0.27259076f, -0.03460312f, -0.04027264f, -0.01390693f, 0.15563978f, 
    -0.00091068f, -0.10767446f, -0.08645275f, -0.07750726f, -0.55243808f, -0.08531956f, -0.32835573f, -0.37758124f, 
    0.07466485f, 0.01744512f, 0.13584280f, 0.03145039f, -0.25153589f, -0.08760400f, -0.00082008f, -0.06368982f, 
    0.10839787f, -0.19149135f, 0.13472378f, -0.02272205f, 0.02714958f, -0.03073862f, 0.02447617f, -0.25197303f, 
    -0.00819255f, 0.13492613f, 0.09042424f, 0.00072533f, 0.18617673f, 0.08220568f, 0.05253528f, 0.11043078f, 
    -0.06612611f, 0.00540178f, 0.06040629f, 0.04736556f, 0.04533024f, 0.06928539f, -0.04137594f, -0.04043404f, 
    0.28165323f, 0.31201220f, -0.22543775f, 0.05337524f, -0.09224389f, -0.10489869f, 0.13594691f, 0.16356577f, 
    -0.07734559f, -0.05619083f, 0.10223100f, -0.02213586f, -0.49570939f, -0.02723949f, 0.28433907f, 0.16647483f, 
    0.01174899f, -0.10024147f, -0.01006341f, -0.09534680f, -0.14859459f, -0.09248728f, 0.04277682f, 0.05082358f, 
    -0.05524841f, 0.00035783f, 0.07950252f, 0.05643822f, 0.01619171f, -0.03845205f, 0.10204444f, 0.19158600f, 
    0.13068034f, -0.00902668f, 0.12668200f, 0.14277674f, -0.33668649f, -0.19992293f, 0.20006321f, -0.01103019f, 
    -0.15421268f, 0.17258500f, -0.15076005f, -0.24898346f, 0.08712551f, 0.08460207f, -0.07648063f, -0.17310555f, 
    -0.41665277f, -0.23149773f, -0.18942431f, 0.03924697f, 0.10451714f, 0.08267140f, -0.06330460f, 0.03574077f, 
    -0.01777493f, -0.16661212f, -0.19775562f, -0.06548510f, -0.12026350f, -0.04437548f, -0.28289765f, 0.03824086f, 
    -0.17106670f, -0.03704023f, 0.11418048f, 0.06830009f, -0.07002591f, 0.04156825f, 0.10051335f, -0.00270525f, 
    0.25508681f, -0.04436493f, 0.10840779f, 0.27281743f, 0.12060003f, -0.02387675f, 0.11637492f, 0.12917960f, 
    0.07351013f, 0.02683477f, 0.00664167f, 0.08848411f, -0.34281662f, -0.42617062f, 0.17742257f, 0.37085772f, 
    0.00707338f, -0.07888072f, -0.06194212f, 0.14322913f, -0.10897972f, 0.22403529f, 0.13456093f, 0.13060983f, 
    -0.24781539f, 0.02456098f, -0.02469604f, -0.26064041f, 0.06522536f, -0.00488461f, 0.00339396f, -0.02850993f, 
    -0.06226293f, 0.04637104f, 0.02262870f, -0.10598952f, -0.89371747f, 0.10840756f, 0.05913714f, 0.14691666f, 
    0.08759911f, 0.02449806f, -0.01298327f, 0.14910549f, -0.13322632f, -0.10696229f, 0.04633970f, 0.00079654f, 
    -0.43502504f, 0.19455774f, 0.01962134f, 0.09755336f, 0.00728608f, -0.02006936f, 0.29723835f, -0.08304258f, 
    -0.06496885f, 0.08166877f, 0.03000752f, 0.05672462f, -0.10845877f, -0.25922483f, 0.05446263f, 0.12277105f, 
    -0.05224412f, 0.15987967f, -0.20691840f, -0.11447688f, 0.21539582f, -0.26771024f, -0.19044051f, 0.03001261f, 
    0.03928735f, 0.15301420f, 0.18496385f, 0.07519332f, -0.12177292f, 0.08284598f, 0.00203533f, 0.03895976f, 
    -0.02675485f, -0.03463728f, -0.17416577f, -0.02455254f, 0.47832093f, 0.03147794f, 0.15624844f, -0.40351573f, 
    -0.08449209f, 0.03909313f, 0.09958562f, 0.09865730f, 0.00106025f, 0.00994014f, -0.04167552f, 0.14124285f, 
    -0.09924337f, -0.61288249f, 0.03155653f, -0.02673770f, -0.20294870f, 0.00929979f, 0.11396341f, -0.21672161f, 
    -0.03286422f, 0.08743743f, 0.00008684f, 0.06516679f, -0.04929225f, 0.19739248f, -0.00332704f, -0.28789961f, 
    0.02446708f, -0.00341976f, -0.15319958f, -0.11044875f, 0.07419311f, -0.02579077f, 0.07618713f, 0.11887933f, 
    0.00501796f, -0.08685438f, 0.07236852f, -0.16997454f, -0.02058398f, -0.00889192f, 0.04361580f, -0.10695086f, 
    0.09373844f, 0.25563523f, 0.04073589f, -0.00776434f, -0.05280660f, -0.06112051f, -0.01640059f, 0.05975695f, 
    -0.05198691f, -0.16745244f, 0.08653703f, -0.03541277f, -0.09541681f, 0.00568730f, 0.14867242f, 0.07328926f, 
    -0.52941167f, -0.32866976f, 0.00548981f, 0.16122575f, 0.04985439f, 0.14656283f, 0.06574789f, -0.15763398f, 
    -0.02171064f, -0.14516370f, -0.07538522f, 0.09955522f, 0.14394282f, -0.18758534f, -0.16231154f, -0.11526192f, 
    0.01485837f, -0.06518359f, 0.03156834f, -0.15429907f, -0.18100314f, -0.05804792f, 0.05923859f, 0.01091600f, 
    0.09509750f, -0.07768826f, 0.11686932f, 0.14048140f, -0.00089428f, 0.07567243f, -0.08599513f, -0.02204659f, 
    -0.38913622f, 0.18245986f, 0.15697823f, 0.16137855f, -0.11778449f, 0.19347869f, 0.02055771f, -0.18268213f, 
    -0.01633101f, 0.13235763f, -0.07048133f, -0.20214865f, -0.08573759f, -0.17000870f, -0.18199794f, -0.03704935f, 
    -0.68907189f, -0.13935979f, -0.18884207f, 0.15047546f, -0.01435689f, 0.13341445f, 0.02589726f, -0.12153533f, 
    0.06125378f, 0.00759721f, -0.05180471f, 0.07731254f, 0.04041318f, -0.06687923f, -0.17395559f, 0.13904543f, 
    -0.01490218f, -0.10157464f, -0.11864825f, -0.12254739f, 0.01953150f, 0.15894042f, -0.15510207f, 0.12025739f, 
    0.26204661f, 0.08925958f, 0.12437099f, 0.15281151f, -0.18209505f, 0.24384899f, -0.10617045f, -0.01474991f, 
    -0.17488804f, -0.04371651f, 0.22523052f, 0.07285836f, -0.09086561f, 0.25364554f, -0.07880861f, -0.36351964f, 
    0.12491434f, 0.03833218f, -0.13942486f, -0.07580711f, 0.11481597f, -0.09608585f, -0.03014099f, -0.18984935f, 
    -0.35531199f, -0.09599110f, 0.22623850f, 0.04083315f, 0.04241715f, 0.07441349f, 0.23261705f, -0.01090609f, 
    -0.05842361f, 0.03380478f, 0.09293587f, 0.14083783f, 0.01340140f, -0.10677222f, -0.04867978f, -0.00889760f, 
    0.07623214f, -0.15251139f, -0.04487859f, 0.07601375f, 0.25208232f, -0.03222127f, 0.02709022f, -0.03095951f, 
    -0.43900338f, -0.12052183f, -0.28978443f, 0.12871996f, 0.12957314f, 0.03752113f, -0.12835780f, -0.07231012f, 
    -0.04536013f, 0.33717024f, -0.23962066f, 0.20253699f, -0.77891201f, 0.01470137f, 0.42053741f, -0.46419895f, 
    -0.06353606f, 0.11343026f, -0.05485537f, 0.29003373f, -0.07528055f, 0.08834378f, 0.00304232f, -0.29329711f, 
    0.28617284f, 0.13165814f, 0.23668571f, 0.35999960f, 0.03072858f, 0.01076536f, 0.15371387f, 0.17686455f, 
    0.03538348f, 0.08426526f, -0.05633578f, -0.31590962f, -0.13787653f, 0.09053940f, 0.17843252f, -0.31934977f, 
    0.05729182f, 0.13145517f, 0.03215113f, -0.10034223f, 0.09295953f, -0.01576063f, 0.01836437f, 0.16155009f, 
    0.00117734f, 0.01069259f, 0.21265604f, -0.00374625f, 0.11042921f, -0.02410889f, 0.00122198f, 0.02361955f, 
    0.11122117f, 0.02503201f, -0.24466012f, 0.09699371f, -0.05583937f, -0.27876446f, 0.02376989f, 0.14705864f, 
    0.06193971f, -0.04797501f, 0.02052448f, 0.05545329f, 0.03560156f, 0.16401306f, 0.06881883f, 0.18697986f, 
    0.02388146f, 0.20245735f, 0.06053043f, 0.00128910f, 0.05233362f, 0.00181693f, -0.06091598f, -0.27106792f, 
    -0.04825698f, 0.10993203f, -0.15483335f, -0.03624469f, 0.00444362f, -0.01884204f, -0.15938655f, 0.24222195f, 
    -0.14810346f, -0.10862622f, 0.01885049f, 0.04518483f, 0.12655383f, -0.04672248f, -0.06317669f, 0.30438894f, 
    -0.52272946f, 0.02527892f, -0.13972932f, -0.06680211f, -0.00615348f, 0.01718408f, 0.24799801f, -0.00083501f, 
    0.11598994f, 0.03988745f, -0.12597767f, -0.03668258f, 0.17835131f, 0.12051264f, 0.28572020f, -0.09460410f, 
    0.00939420f, -0.08905991f, -0.08776923f, -0.11622788f, -0.07481346f, 0.07889956f, -0.03816171f, -0.06721624f, 
    -0.13790856f, -0.22709964f, -0.21932955f, 0.19194253f, -0.06021345f, 0.11522245f, 0.08364931f, -0.04013014f, 
    0.05457353f, 0.01839047f, 0.06385932f, 0.03885222f, 0.39433920f, -0.01549012f, -0.36308080f, -0.14531681f, 
    -0.00672940f, 0.06356722f, -0.08503050f, -0.04866951f, -0.08160973f, -0.19223577f, 0.00380815f, -0.16221337f, 
    -0.07864069f, 0.07213845f, 0.00197150f, 0.12743591f, -0.02521692f, -0.11407516f, 0.06014480f, 0.18100417f, 
    0.21175553f, 0.15339294f, 0.00531961f, -0.05149671f, -0.28707665f, 0.10103951f, -0.28643581f, -0.05491740f, 
    0.15647325f, 0.03418967f, 0.01749526f, 0.03209435f, 0.02197129f, 0.10739851f, -0.12422510f, -0.04490175f, 
    -0.45240805f, 0.03973549f, -0.13378993f, -0.21834338f, 0.04708787f, 0.04900992f, -0.13025750f, -0.20425887f, 
    0.23220533f, -0.18003164f, 0.08629086f, -0.20206624f, 0.30652955f, 0.08377875f, 0.07133912f, -0.06162559f, 
    -0.11056974f, -0.26657307f, -0.12292496f, 0.08575759f, 0.02967956f, 0.02256849f, 0.21838078f, 0.00116085f, 
    -0.25074831f, -0.16634676f, 0.08741435f, 0.00267092f, -0.05861415f, -0.15336986f, 0.05723279f, -0.11346871f, 
    0.14120927f, -0.04373544f, -0.13592274f, -0.08235116f, -0.69122869f, -0.40125391f, 0.00151067f, 0.22323811f, 
    0.10359138f, -0.05694498f, -0.14959395f, 0.12100347f, 0.01020487f, -0.01377447f, 0.22925591f, 0.05951536f, 
    0.07391325f, 0.27655023f, 0.00753631f, -0.05306974f, 0.20351434f, 0.06198362f, -0.00507921f, 0.01197164f, 
    -0.10010421f, -0.00880813f, 0.00949021f, -0.12552795f, 0.17321986f, 0.19838202f, 0.18953609f, 0.24520618f, 
    -0.14426811f, 0.08822312f, 0.14298491f, 0.07721370f, -0.12446222f, -0.05476597f, -0.20347732f, -0.07185679f, 
    -0.15255439f, 0.03593113f, -0.03227325f, 0.01568251f, 0.10781322f, -0.05065964f, -0.05890950f, -0.13520578f, 
    -0.15448710f, -0.20022796f, -0.19068773f, -0.00242380f, -0.02888517f, 0.20580904f, 0.02905072f, -0.08118786f, 
    0.10552184f, 0.26148641f, 0.18091951f, -0.04085837f, -0.08316431f, -0.06277447f, 0.10215794f, 0.08478352f, 
    -0.18834329f, 0.29390326f, -0.05681216f, -0.04633974f, -0.12439749f, -0.14608717f, 0.01724306f, -0.14285035f, 
    0.03624979f, 0.13546133f, -0.04360208f, -0.07578305f, -0.11422080f, -0.04845031f, -0.02268957f, 0.39228258f, 
    0.17748737f, 0.25168353f, 0.11936542f, 0.05403181f, 0.08092215f, 0.01022953f, -0.01104571f, -0.03493831f, 
    -0.11216573f, 0.41733935f, 0.06408016f, -0.24252932f, -0.01449685f, 0.05352718f, 0.00592085f, 0.09376306f, 
    0.19912770f, -0.14143348f, -0.03822309f, -0.14789100f, -0.71754056f, 0.05883653f, 0.16630639f, 0.31301963f, 
    0.07420815f, 0.03691118f, 0.15760674f, 0.04228889f, 0.02059846f, 0.05938678f, 0.04876757f, 0.02956137f, 
    -0.32095596f, -0.09969374f, -0.21288753f, 0.11800194f, 0.05263578f, 0.08196314f, 0.15493850f, 0.01508645f, 
    0.11137268f, 0.14492768f, -0.00464376f, 0.05970856f, -0.45425475f, -0.14001594f, -0.21103865f, 0.16388538f, 
    0.13306117f, -0.07310614f, -0.03566689f, 0.02810587f, 0.19721375f, -0.04395984f, 0.16440690f, -0.21199818f, 
    -0.24233215f, 0.23143587f, 0.11549845f, -0.11810029f, 0.07057945f, -0.11648705f, -0.02314719f, 0.01907005f, 
    -0.09735031f, 0.04832060f, -0.24474025f, -0.03944884f, 0.14362670f, -0.40886310f, 0.22850965f, -0.22526021f, 
    0.16141713f, 0.09885862f, 0.13678892f, -0.02601862f, -0.10602634f, -0.01215577f, 0.08483944f, 0.12947974f, 
    0.23980866f, -0.52316850f, 0.01064564f, -0.08154929f, -0.00813511f, 0.01439692f, 0.07058360f, -0.10668534f, 
    0.05686429f, -0.02454931f, -0.20471686f, -0.14141181f, -0.03194460f, -0.04162149f, -0.12187146f, -0.28566089f, 
    -0.02429557f, 0.00233231f, -0.12214985f, 0.05213303f, -0.02718414f, -0.06757607f, 0.07708212f, -0.02954285f, 
    -0.45982975f, -0.05410530f, -0.02036359f, -0.14786659f, 0.18101658f, 0.00303869f, 0.03202515f, -0.02276292f, 
    0.17498179f, -0.27003318f, 0.24512166f, -0.26737618f, 0.24469641f, -0.15891108f, 0.10334887f, -0.12280152f, 
    -0.11092185f, 0.05942065f, 0.10081845f, -0.17628324f, 0.15092753f, -0.01810323f, 0.06287567f, 0.05018174f, 
    -0.28920132f, 0.05495255f, -0.25878504f, 0.01595963f, 0.14347251f, -0.09956646f, -0.06376873f, 0.02561942f, 
    -0.06669043f, -0.25088653f, 0.20969726f, 0.07199379f, 0.33969319f, 0.29689988f, 0.26862043f, -0.61790639f, 
    -0.21596530f, 0.04508876f, -0.12761508f, 0.18304440f, -0.01413864f, 0.08737687f, -0.08340488f, -0.10128171f, 
    0.19221768f, -0.15621616f, -0.13441820f, 0.18308194f, -0.07852939f, -0.09361930f, -0.03279335f, 0.10741994f, 
    -0.22640742f, -0.06401047f, 0.09737382f, 0.13152511f, -0.06146940f, -0.20097673f, -0.02568745f, 0.02885078f, 
    -0.09254596f, 0.07915794f, 0.05886512f, 0.00717182f, 0.02203851f, -0.11931375f, -0.03700031f, -0.01358373f, 
    -0.53390795f, 0.08238327f, 0.16876476f, -0.15557438f, -0.14005770f, 0.10877119f, 0.03747952f, 0.01002296f, 
    -0.03565884f, 0.05417473f, -0.01125869f, 0.09966979f, 0.05333593f, 0.31506056f, 0.04305481f, -0.31199667f, 
    0.00120423f, 0.08310883f, 0.11074156f, -0.00465799f, -0.25524023f, 0.05719970f, -0.13155203f, -0.05051386f, 
    0.50094098f, -0.19178990f, 0.29189661f, -0.20179823f, -0.11657009f, 0.02747692f, -0.02360781f, -0.11261103f, 
    -0.07613724f, -0.02269406f, 0.21570092f, 0.00679353f, -0.28796193f, 0.25600886f, 0.17514746f, 0.05277947f, 
    -0.03803121f, 0.11155669f, 0.04825924f, 0.03269109f, 0.03315676f, -0.10105719f, -0.00955742f, 0.14996319f, 
    -0.14777929f, 0.25019291f, -0.55483651f, -0.20671672f, -0.09285918f, 0.00406547f, -0.11688643f, -0.12562847f, 
    0.00384877f, -0.00469284f, -0.02814744f, 0.02664605f, -0.02811875f, 0.02581975f, -0.35320735f, -0.01504696f, 
    -0.27834848f, -0.08573177f, -0.00179278f, -0.34170258f, 0.01653649f, 0.01105075f, 0.02012673f, 0.25956541f, 
    0.01796889f, -0.06596152f, -0.36317697f, 0.20747447f, 0.07679059f, 0.11498340f, -0.08246711f, 0.01943090f, 
    -0.15689079f, -0.14222020f, -0.14186686f, -0.04512819f, 0.23295878f, -0.24025986f, -0.06562329f, -0.12922218f, 
    -0.13949001f, 0.11827114f, -0.01234080f, 0.02159580f, -0.00153102f, 0.02973892f, -0.00875300f, 0.06985444f, 
    -0.18317096f, -0.32209718f, -0.07226591f, 0.02700178f, -0.11454171f, 0.00233412f, -0.06771024f, 0.16336566f, 
    -0.18159510f, 0.10448000f, -0.13571256f, 0.22397235f, -0.17685555f, 0.12219051f, 0.12112683f, -0.16566418f, 
    0.08356968f, 0.03542808f, 0.09871463f, 0.15352707f, -0.08891511f, 0.09046949f, -0.11269927f, -0.06111572f, 
    0.04189093f, 0.22912362f, -0.04188357f, -0.25503260f, -0.00392466f, 0.09224762f, -0.12499530f, 0.02823445f, 
    -0.10881938f, 0.10568572f, 0.24898751f, 0.21437581f, 0.20737453f, -0.15794048f, -0.10452122f, 0.11413690f, 
    0.02224210f, -0.07421421f, -0.09593140f, -0.09745339f, -0.08389077f, 0.05891161f, -0.02696259f, 0.00006470f, 
    -0.18467852f, 0.24491434f, -0.12613088f, 0.45090812f, 0.01594142f, 0.15108053f, -0.06225764f, 0.13682003f, 
    0.07012687f, 0.05636436f, 0.03003515f, -0.20730929f, -0.01450840f, 0.01296500f, 0.32822469f, -0.12985982f, 
    -0.10537633f, 0.03287382f, 0.07622236f, -0.08475967f, -0.00063311f, 0.01520490f, 0.14874797f, -0.17872457f, 
    -0.31641161f, 0.09851661f, -0.04627440f, -0.05325053f, -0.01746334f, -0.04624621f, -0.02317865f, -0.07407495f, 
    0.17071839f, -0.05848026f, 0.14058931f, 0.05779152f, 0.19409078f, 0.29383910f, -0.03226477f, -0.00059886f, 
    -0.18767315f, 0.04686620f, -0.01313910f, -0.10873888f, -0.07669918f, 0.04072796f, -0.12675622f, -0.16437395f, 
    -0.05620047f, 0.29942310f, 0.16679883f, 0.14077069f, 0.13261877f, 0.06611306f, -0.05128124f, -0.00760468f, 
    -0.09407444f, -0.03706915f, 0.04202366f, -0.24075902f, -0.26600596f, 0.14469621f, -0.25501689f, 0.12684937f, 
    0.13503107f, -0.11285563f, -0.10109975f, 0.06244981f, 0.10015734f, -0.01206781f, -0.03606280f, -0.04582744f, 
    -0.44193190f, -0.01562856f, -0.25272614f, -0.06757983f, 0.05435110f, -0.13077712f, 0.03476540f, -0.02740578f, 
    -0.04407672f, 0.00286347f, 0.02650441f, 0.02754617f, -0.16845404f, 0.35244316f, -0.13496083f, -0.12190061f, 
    -0.01078228f, 0.11680713f, 0.04336752f, -0.05057742f, -0.04318283f, 0.06103928f, -0.00751308f, -0.06673989f, 
    0.24772537f, -0.04081629f, 0.22877659f, 0.00271643f, 0.04543089f, -0.08150265f, -0.04614752f, 0.04958850f, 
    -0.07914720f, 0.00870148f, -0.17376371f, -0.07306290f, -0.08119935f, 0.23797648f, -0.00744190f, 0.06415882f, 
    0.01086195f, 0.03643296f, -0.00181675f, -0.07636169f, 0.06180130f, 0.03105572f, -0.03934844f, -0.12388678f, 
    0.02977583f, -0.32881096f, -0.35695809f, 0.02036301f, -0.11525312f, -0.03291144f, 0.04276023f, -0.07554991f, 
    0.02997867f, -0.00348552f, 0.08658585f, -0.02643489f, 0.13330370f, -0.18897937f, 0.23531303f, -0.17448929f, 
    -0.03339766f, -0.00432533f, -0.10562801f, 0.02680355f, -0.13042749f, 0.02921669f, 0.01046996f, -0.00867672f, 
    0.13070567f, -0.37422663f, -0.05314870f, -0.14054888f, -0.02969385f, 0.01397604f, -0.13430962f, -0.06164883f, 
    -0.10826741f, 0.13467057f, -0.00875892f, 0.00585784f, -0.10063493f, -0.00800489f, -0.06790791f, 0.06772039f, 
    -0.07999043f, -0.02943011f, -0.20498493f, -0.04273114f, -0.15566014f, -0.04061342f, -0.04741030f, -0.06575439f, 
    0.10515279f, 0.18683775f, 0.09575895f, -0.00899113f, -0.04203344f, -0.00074766f, 0.06749158f, -0.01347025f, 
    0.06568309f, 0.03627354f, -0.06738655f, -0.11431658f, 0.07229727f, -0.08243544f, 0.13810839f, -0.04022956f, 
    -0.04838075f, -0.09952827f, 0.04674713f, 0.08712822f, -0.02488789f, 0.07206824f, -0.04727626f, 0.01116534f, 
    -0.03103736f, -0.01962657f, -0.28763208f, 0.21599589f, -0.03644159f, -0.00053020f, -0.05523694f, -0.11722298f, 
    -0.14494376f, -0.09139756f, 0.09045123f, 0.09966596f, -0.18254864f, -0.05014352f, -0.17268039f, -0.12642907f, 
    -0.10897326f, 0.01960589f, 0.00489656f, -0.06954580f, -0.08628749f, -0.01608342f, 0.05817963f, -0.12535958f, 
    -0.07479494f, -0.01678626f, -0.10161527f, -0.13796091f, -0.05580620f, -0.02629402f, -0.04614230f, -0.11104476f, 
    -0.02645058f, -0.03024410f, 0.00310036f, -0.03393706f, 0.42326719f, -0.40835580f, 0.29831406f, -0.01644800f, 
    -0.02472574f, -0.09513252f, -0.09012450f, -0.21491453f, 0.07855061f, 0.02172603f, -0.05167147f, -0.10037654f, 
    -0.10483257f, -0.03349438f, -0.16257951f, -0.13066582f, -0.06861912f, 0.14681405f, -0.08675027f, -0.13803394f, 
    -0.03643959f, -0.06582294f, -0.04500794f, -0.14261764f, 0.06273892f, -0.07657906f, -0.32883903f, -0.06793778f, 
    -0.11195812f, -0.02572767f, -0.18874514f, -0.11174735f, -0.06715976f, 0.08877060f, 0.09600693f, -0.12359004f, 
    -0.00074551f, 0.13613202f, 0.22046599f, 0.17626998f, 0.17982407f, 0.06284696f, 0.05174631f, 0.01006193f, 
    -0.04918939f, 0.05146994f, 0.06944400f, 0.05775495f, 0.07475859f, -0.02304388f, 0.01576246f, -0.01860115f, 
    -0.02213870f, 0.04075763f, 0.04259785f, -0.06473076f, -0.12336768f, -0.15300991f, -0.07547624f, -0.05767630f, 
    0.22538154f, 0.11225270f, 0.28445181f, 0.23635568f, 0.11916647f, 0.09334700f, -0.04426033f, -0.06100447f, 
    -0.05028626f, -0.11999852f, -0.14945950f, -0.13275465f, 0.11563084f, 0.13882712f, 0.11466606f, 0.27726641f, 
    0.17119806f, 0.00781717f, 0.17868568f, -0.04647249f, -0.00889982f, 0.01147918f, -0.01691568f, -0.12202767f, 
    -0.26719502f, 0.14086600f, -0.15344699f, 0.11581687f, -0.21656702f, 0.03693671f, 0.00899165f, -0.11339644f, 
    0.03962616f, -0.07804202f, -0.09504190f, -0.03491767f, 0.01876934f, 0.27330503f, 0.24761705f, 0.09931490f, 
    0.11696272f, 0.08266394f, 0.05582956f, 0.12479088f, -0.08552794f, 0.02590582f, 0.00658936f, -0.07537231f, 
    -0.03204455f, 0.14551654f, 0.09686278f, 0.14641328f, 0.10572742f, 0.04885804f, 0.13021480f, -0.10866930f, 
    -0.07382251f, -0.05026708f, 0.09748284f, -0.01334704f, 0.24867798f, 0.13972968f, -0.08542462f, -0.13699105f, 
    -0.00454228f, -0.05092146f, 0.12795842f, -0.18479092f, -0.03467266f, -0.06573763f, -0.06260772f, -0.21405891f, 
    -0.12611964f, -0.04917933f, -0.24880804f, -0.10479821f, -0.03804313f, -0.08896831f, -0.13554956f, -0.03133608f, 
    -0.07039119f, -0.00709697f, -0.02529691f, -0.14137568f, 0.29461798f, 0.16948445f, -0.00674565f, 0.33388841f, 
    0.25145578f, -0.02963929f, 0.00692452f, -0.02580486f, -0.04776757f, -0.13980378f, -0.14358489f, -0.23073278f, 
    -0.39631134f, -0.07009934f, -0.06740185f, -0.03661435f, 0.04831056f, 0.00221038f, 0.01848772f, -0.00805460f, 
    -0.06981802f, -0.12915963f, 0.06179775f, -0.11837871f, -0.01151687f, 0.14519612f, 0.10085387f, 0.15163586f, 
    -0.15185244f, -0.03990279f, 0.09768705f, -0.08388777f, -0.01276981f, 0.04575579f, 0.03448574f, -0.17013146f, 
    0.11987308f, 0.06988437f, -0.00256793f, 0.14996980f, -0.05028829f, -0.11168856f, 0.02503617f, 0.16062871f, 
    0.14981554f, -0.01203621f, -0.04785898f, 0.09789497f, -0.04653553f, -0.26546839f, -0.11585531f, -0.17427705f, 
    -0.02345526f, -0.11256985f, -0.10982434f, 0.00658992f, 0.01271898f, 0.04298754f, 0.15655793f, -0.18883175f, 
    -0.05653609f, -0.12724349f, 0.31057861f, -0.12752752f, 0.10684267f, 0.04641961f, -0.07734601f, -0.16413364f, 
    0.11452460f, -0.01182222f, -0.08222146f, 0.09493777f, -0.01618234f, 0.27205443f, -0.47983810f, 0.18290949f, 
    -0.02087389f, -0.06136427f, -0.13340431f, -0.06383792f, 0.01670878f, 0.02226686f, 0.06392394f, 0.11556343f, 
    0.09716035f, -0.21185622f, -0.10706665f, 0.00856529f, 0.09225060f, -0.05611330f, -0.09953465f, 0.02785671f, 
    0.10484184f, 0.11742979f, 0.20972396f, -0.18806086f, -0.01630579f, -0.07969899f, -0.25644138f, -0.13074553f, 
    0.09709381f, -0.12882616f, -0.20416386f, 0.10503197f, 0.05998330f, -0.12564297f, -0.02167412f, -0.04248083f, 
    0.02076365f, 0.11093441f, -0.10539316f, 0.21246783f, 0.01806170f, 0.06701224f, -0.15954667f, -0.15510146f, 
    -0.03924777f, 0.07221124f, -0.03481702f, 0.03101269f, -0.02333277f, 0.42457590f, -0.29399252f, 0.15984660f, 
    0.05366471f, 0.13215517f, -0.14335237f, -0.05066176f, 0.10813398f, 0.00347776f, -0.08150569f, -0.02819162f, 
    -0.11588598f, -0.12256343f, -0.12005463f, 0.16970384f, 0.02380817f, 0.11562245f, -0.06263174f, -0.11809119f, 
    0.04507261f, 0.15084779f, 0.19465838f, 0.14428255f, -0.10705932f, 0.12054311f, 0.18395963f, 0.04381530f, 
    0.01180108f, -0.03762009f, -0.11479873f, 0.03418051f, 0.18184236f, -0.13826026f, -0.23505488f, -0.09573613f, 
    -0.03442553f, -0.20783749f, 0.09895663f, 0.01826677f, 0.00440371f, -0.03598708f, 0.04907705f, -0.13953586f, 
    -0.21219924f, 0.02293340f, 0.06048377f, 0.09174579f, -0.40996665f, 0.13403109f, -0.07481056f, -0.29782704f, 
    -0.11000555f, -0.12301743f, -0.03980758f, 0.07316262f, 0.11166566f, 0.05907995f, -0.06946311f, -0.04127556f, 
    -0.14860645f, 0.21037759f, 0.13079013f, -0.04812891f, -0.10578528f, 0.08753500f, -0.12644164f, -0.08924201f, 
    -0.06411804f, 0.08525670f, -0.04527915f, 0.17157960f, 0.12384341f, -0.20741580f, 0.01409895f, 0.02508077f, 
    -0.20431863f, -0.07940127f, 0.10351904f, -0.03501536f, -0.03170607f, 0.09503431f, -0.11816824f, -0.44278842f, 
    -0.19651432f, -0.11459024f, -0.16714853f, -0.20616956f, -0.04902630f, -0.02715878f, -0.07913069f, 0.01403198f, 
    0.21844065f, 0.08092327f, -0.00873600f, -0.30072540f, 0.07989497f, 0.02595999f, -0.03648711f, 0.40508881f, 
    0.14052123f, -0.06676386f, 0.00169018f, -0.04925410f, -0.00706216f, 0.04123035f, 0.11092526f, -0.03879334f, 
    0.24605399f, 0.11199399f, 0.04846365f, 0.16101705f, -0.02844199f, -0.15634499f, -0.06150126f, -0.13496216f, 
    0.05578418f, -0.00361948f, -0.11852068f, -0.10325572f, 0.12842116f, -0.05568343f, -0.15011889f, -0.09694599f, 
    0.07439701f, -0.08481403f, 0.05784530f, -0.27117589f, 0.12324619f, 0.07526942f, 0.05924061f, 0.20634817f, 
    0.17786945f, 0.02390163f, 0.08464489f, 0.11872590f, -0.00138334f, -0.09832701f, -0.02398594f, -0.11217127f, 
    -0.08346626f, 0.18328366f, -0.20777866f, 0.08790978f, -0.25602296f, -0.24896751f, -0.07252569f, -0.32549050f, 
    0.04997021f, 0.01608085f, 0.20384784f, -0.04217455f, 0.06532192f, 0.17509693f, -0.11191833f, 0.15363926f, 
    0.15689002f, -0.36639637f, 0.15130767f, 0.01856104f, -0.11971263f, -0.06673630f, 0.07110810f, -0.13460207f, 
    -0.10849267f, -0.08315135f, -0.05577268f, -0.14059648f, 0.27247825f, 0.18586431f, 0.02290304f, 0.27411202f, 
    0.12383770f, -0.08066367f, -0.20451494f, -0.05886825f, -0.07496262f, 0.00416635f, -0.05208494f, -0.21513492f, 
    -0.27702618f, -0.09577569f, 0.10445331f, -0.18199280f, 0.14831986f, 0.09937969f, 0.03552206f, -0.13635400f, 
    -0.05419458f, -0.08052453f, 0.01882110f, 0.10448194f, -0.17065828f, -0.00450540f, 0.18333885f, -0.09173434f, 
    -0.04937755f, 0.04096671f, -0.19960660f, -0.01269457f, -0.06727139f, -0.16464205f, 0.02409087f, -0.08840542f, 
    0.19102928f, 0.36144054f, -0.28726903f, 0.02652982f, -0.11049321f, -0.03993571f, 0.19498941f, -0.04517101f, 
    0.10949352f, 0.02420900f, 0.10565322f, 0.15291639f, -0.11809896f, -0.05172369f, 0.14312544f, -0.00510213f, 
    -0.20377989f, -0.15982501f, 0.14783914f, -0.14375933f, -0.04167201f, -0.13982695f, -0.22922701f, -0.03951688f, 
    -0.03294284f, -0.13141687f, 0.11156532f, 0.20631902f, -0.08300905f, 0.02082959f, -0.21267970f, -0.04466862f, 
    -0.15603779f, -0.03028724f, 0.04750684f, -0.19558319f, -0.07898437f, -0.50964636f, 0.10797770f, -0.39065102f, 
    -0.04225629f, -0.15073614f, 0.00715099f, 0.18040068f, 0.19975244f, 0.15902762f, 0.10033668f, -0.02668366f, 
    0.10824898f, -0.06306805f, -0.12043086f, 0.21710120f, 0.21145868f, -0.03063263f, -0.00329501f, -0.06604695f, 
    -0.00843386f, -0.16400309f, 0.05384419f, -0.00745324f, 0.14964481f, -0.25454372f, -0.00483219f, -0.44848806f, 
    -0.09977438f, 0.06190575f, 0.18628825f, 0.04789174f, -0.08880030f, -0.01632651f, 0.09325665f, -0.01829904f, 
    0.16380239f, 0.33312050f, -0.37493351f, -0.23707595f, 0.12081901f, -0.03517999f, -0.14126465f, -0.09854182f, 
    0.23297638f, -0.08014013f, 0.03372841f, 0.16445293f, 0.11337465f, -0.34013218f, -0.03720941f, -0.01408085f, 
    -0.07301150f, -0.11387485f, -0.09251548f, 0.05459912f, 0.06446789f, 0.06649393f, -0.02530028f, 0.07813053f, 
    -0.12668459f, 0.02339232f, 0.38758135f, -0.33199367f, -0.05708693f, 0.03455194f, -0.00032221f, -0.01399070f, 
    -0.08173684f, -0.09122893f, 0.19241111f, -0.17491376f, -0.42432126f, 0.14656012f, -0.05596736f, 0.10834336f, 
    -0.01380920f, -0.09466250f, 0.07902103f, -0.10574231f, 0.03559260f, 0.05434042f, -0.04618789f, 0.08745909f, 
    -0.54743630f, -0.81107259f, -0.09607708f, -0.01116099f, -0.02092090f, 0.08247415f, -0.06255841f, -0.09802391f, 
    0.05088939f, 0.00162749f, 0.16444528f, -0.18074219f, -0.14613360f, 0.16758795f, 0.36963418f, 0.01167940f, 
    -0.13184863f, 0.03904502f, -0.10332104f, 0.22747999f, -0.07451792f, 0.11785213f, -0.16936912f, -0.14195211f, 
    0.03564922f, 0.09973625f, -0.08545629f, -0.43846476f, -0.00194505f, -0.01358945f, -0.10892934f, -0.07407814f, 
    -0.23921165f, -0.00258352f, -0.27099282f, -0.12912707f, -0.52987093f, 0.16279975f, 0.30340502f, -0.04939659f, 
    0.11237741f, -0.00162744f, 0.10013328f, -0.02117648f, 0.04628935f, 0.06667027f, 0.09015781f, -0.01459828f, 
    0.44532970f, -0.56042993f, 0.01614095f, 0.00702629f, -0.08166093f, -0.13827990f, 0.10463329f, 0.12967910f, 
    -0.05026793f, 0.10220127f, 0.01991220f, -0.00946903f, 0.11755165f, 0.10530401f, 0.21002574f, 0.28894556f, 
    0.05002566f, 0.06235741f, -0.03554398f, 0.26338059f, -0.21682815f, 0.01378787f, 0.01146140f, -0.03797625f, 
    0.05656279f, -0.06803782f, -0.09782262f, -0.19205710f, 0.13081779f, 0.01274829f, 0.06811327f, 0.00306102f, 
    -0.09498554f, -0.13735549f, -0.09412178f, -0.06207119f, -0.07479861f, -0.38471103f, 0.02231568f, 0.09681230f, 
    0.03462587f, -0.03202045f, -0.09478591f, -0.05655008f, -0.11713370f, -0.00312164f, -0.04948305f, 0.06414426f, 
    0.63637060f, 0.29796579f, -0.30117494f, -0.08270080f, 0.10699859f, -0.09397963f, -0.19342130f, 0.17357814f, 
    -0.00348125f, 0.02156644f, -0.04252099f, 0.14602943f, -0.31544608f, 0.29881302f, -0.04918426f, 0.33028674f, 
    0.08396203f, 0.25157616f, -0.13319042f, -0.13526551f, -0.11092727f, -0.05376925f, -0.00610481f, 0.12000624f, 
    0.14344361f, -0.15562589f, -0.07115633f, 0.01544124f, 0.05557996f, 0.02756660f, 0.02769337f, -0.01145085f, 
    0.03290956f, -0.21838897f, 0.06779018f, -0.17468129f, -0.17258853f, 0.08070489f, -0.15252206f, 0.19070159f, 
    0.19320476f, 0.09696609f, -0.08313539f, 0.01224974f, -0.05823759f, 0.09705197f, 0.05916741f, 0.19235483f, 
    0.02420550f, 0.12872225f, 0.06932074f, -0.02595124f, -0.05136819f, 0.04795651f, -0.03303413f, -0.08056261f, 
    0.12736467f, -0.24567400f, 0.01873341f, 0.10878412f, -0.52767652f, 0.19397801f, -0.37094918f, -0.35333920f, 
    0.09730999f, -0.27358571f, 0.04093315f, -0.05606088f, -0.03994463f, -0.20364594f, -0.01847712f, -0.18997888f, 
    -0.04003800f, -0.09705413f, 0.07647284f, -0.23912099f, 0.25646254f, 0.00779397f, -0.17898172f, -0.19912919f, 
    -0.03012867f, -0.02430639f, 0.10704453f, -0.02990943f, 0.56763041f, -0.27725264f, -0.28057215f, -0.09311806f, 
    -0.11261225f, 0.06777038f, -0.11037578f, 0.15878315f, 0.10038271f, -0.13221255f, -0.09665962f, -0.33690295f, 
    -0.09798101f, 0.22961003f, -0.12160421f, 0.07187498f, 0.03041303f, 0.07086467f, 0.04344461f, 0.05874368f, 
    0.17719784f, -0.06446578f, 0.17331885f, -0.01582417f, 0.12627475f, 0.06688193f, 0.26530883f, -0.47040620f, 
    0.04115626f, -0.13230614f, -0.05392020f, -0.11516707f, 0.07024708f, -0.07811067f, -0.05730415f, -0.18017073f, 
    -0.21050863f, 0.03698928f, -0.11882856f, 0.17936304f, 0.07631625f, 0.08033106f, -0.11593486f, -0.03260395f, 
    0.14182442f, 0.12844972f, 0.00607661f, 0.01151592f, 0.28013366f, -0.43150103f, -0.01927733f, 0.02181881f, 
    0.13794133f, 0.12461168f, 0.13510484f, 0.04358000f, 0.01018719f, -0.09419700f, 0.18661261f, 0.09924387f, 
    -0.22125262f, -0.63258934f, -0.01969022f, -0.08282245f, 0.04034709f, 0.06362424f, -0.07718530f, 0.02570059f, 
    -0.07813490f, -0.02238214f, -0.02256109f, -0.03570311f, -0.18806462f, 0.05855808f, 0.27803534f, -0.29847053f, 
    0.12068296f, 0.09384955f, 0.10709642f, 0.13919498f, 0.03967600f, 0.07602103f, 0.11299996f, 0.15961990f, 
    -0.02648090f, 0.32500231f, 0.25735250f, 0.37083411f, -0.03859267f, 0.02035865f, -0.18387775f, 0.01598081f, 
    0.00631302f, 0.02204390f, 0.10692915f, 0.12676226f, -0.09880040f, -0.20284513f, -0.08753394f, 0.12864356f, 
    0.17097963f, 0.02415437f, -0.20511721f, -0.06672075f, 0.04095154f, 0.04426051f, 0.14920409f, -0.08239309f, 
    0.12203664f, -0.37125954f, -0.02370541f, -0.01457670f, 0.01202314f, 0.11710396f, -0.02278381f, -0.13349606f, 
    0.03761031f, -0.04192851f, -0.00621655f, -0.00561146f, -0.25889033f, 0.11638633f, 0.08598048f, 0.05968392f, 
    -0.10406392f, 0.17467321f, 0.13687189f, -0.08003699f, -0.14683378f, 0.06456444f, 0.11619300f, -0.11802748f, 
    -0.73917705f, 0.26678351f, 0.01177775f, -0.24851757f, -0.10849050f, -0.02432498f, 0.05117634f, -0.02612104f, 
    -0.05024790f, -0.01034818f, -0.14487992f, 0.06764127f, -0.02936021f, -0.05683292f, 0.04116486f, -0.11838836f, 
    -0.01443802f, -0.04536344f, -0.02104592f, -0.05771896f, 0.09701577f, -0.03592511f, 0.00334903f, 0.04995085f, 
    0.35003158f, -0.14024657f, 0.42875332f, 0.10591670f, 0.10889986f, -0.01700058f, 0.12965296f, -0.06718181f, 
    0.05207194f, -0.03957367f, 0.05903330f, -0.02120686f, 0.17170167f, 0.13002715f, -0.22059020f, -0.14214037f, 
    0.13133977f, -0.02393411f, 0.02904115f, 0.01507024f, -0.15136933f, -0.05126736f, 0.02789948f, -0.04747293f, 
    -0.37778682f, 0.04309429f, -0.12971881f, -0.05302980f, 0.21290378f, 0.08166312f, -0.11601964f, 0.08836707f, 
    0.12345223f, 0.21015111f, 0.04157456f, 0.29436642f, -0.26110780f, -0.40697041f, 0.21938580f, 0.11889547f, 
    0.06602184f, 0.10435019f, -0.10835525f, 0.12137885f, 0.04558073f, 0.17243971f, 0.04834873f, -0.02963416f, 
    0.11168203f, 0.06168852f, -0.03620129f, 0.09071258f, 0.16361241f, -0.08141403f, 0.07594674f, -0.05857420f, 
    -0.03211015f, 0.04863494f, 0.02424663f, 0.00110838f, -0.40764233f, -0.18705291f, -0.10631886f, 0.11726049f, 
    0.19834918f, -0.15013798f, 0.01507807f, -0.13224871f, 0.03844819f, 0.11423210f, 0.12980558f, -0.10645054f, 
    -0.31506905f, -0.17230505f, -0.00888538f, -0.37369409f, 0.13413483f, 0.05890737f, -0.15244903f, 0.06083356f, 
    0.05428978f, 0.15515901f, 0.11685600f, 0.04909750f, -0.78366745f, -0.55181503f, -0.04543853f, 0.13569501f, 
    -0.07558809f, 0.05047218f, -0.04038240f, -0.01734716f, 0.03791142f, -0.03049148f, -0.09357813f, 0.18803264f, 
    0.10852327f, 0.08723452f, 0.07454362f, 0.11591949f, -0.05289994f, 0.11362274f, -0.19431727f, 0.02837845f, 
    0.13016838f, -0.00881117f, -0.10856784f, -0.07099693f, 0.10464003f, -0.09275061f, 0.14962251f, -0.12287427f, 
    0.02806043f, -0.03266689f, 0.12305910f, -0.16331151f, 0.06793125f, -0.15627854f, -0.11438856f, -0.12496728f, 
    -0.82523453f, -0.16379990f, -0.01348975f, -0.18933052f, 0.01346175f, 0.01498988f, -0.02605686f, -0.02722510f, 
    0.17104402f, 0.22365646f, 0.04920478f, 0.09658324f, 0.47821042f, -0.16672312f, -0.10933378f, 0.04453399f, 
    0.03515112f, 0.00606854f, -0.03848996f, -0.00229761f, 0.07013515f, 0.10255266f, -0.12645622f, -0.04955084f, 
    -0.17903125f, -0.00226431f, -0.23935272f, -0.06326090f, -0.04771333f, -0.06541254f, 0.10463090f, 0.08643861f, 
    0.05868518f, 0.00815508f, 0.09558075f, 0.11921200f, -0.04716352f, -0.19958180f, 0.02418175f, 0.20333557f, 
    0.09204402f, -0.02926720f, -0.00870056f, 0.12233128f, 0.14665109f, 0.13316560f, -0.01801600f, -0.03529949f, 
    0.23374020f, 0.08770642f, 0.16014668f, -0.18198818f, 0.07089362f, -0.04304142f, -0.03398867f, 0.01238739f, 
    0.06624278f, 0.04417937f, -0.10157329f, 0.13882260f, 0.31108978f, -0.05339495f, 0.03826208f, 0.36831763f, 
    0.03705029f, -0.24100679f, 0.06222013f, 0.02719873f, 0.00151070f, 0.00283308f, -0.18541411f, -0.12671658f, 
    -0.29366386f, -0.16038901f, 0.35647696f, 0.06637508f, 0.05481887f, 0.06812023f, -0.02557750f, 0.02217407f, 
    0.02531406f, 0.02751028f, -0.21372148f, -0.05930576f, -0.86630249f, -0.46905315f, -0.37377933f, -0.25062880f, 
    0.00525454f, -0.05746046f, -0.11539423f, 0.03584965f, -0.02003673f, 0.09083652f, 0.06979986f, 0.07068514f, 
    -0.01961370f, -0.04716162f, -0.21994857f, -0.32472247f, 0.05236689f, 0.16045372f, -0.02364842f, -0.00978580f, 
    -0.14547728f, -0.01584777f, -0.16510935f, 0.02958266f, 0.02842890f, 0.14870714f, -0.22539851f, -0.04540822f, 
    -0.02014273f, 0.16105479f, 0.06991918f, -0.02528481f, -0.02254576f, 0.12439100f, -0.02563708f, 0.11088923f, 
    -0.61863941f, -0.65161657f, -0.19821845f, -0.16017221f, 0.06068274f, 0.03512718f, 0.01819786f, -0.20093121f, 
    -0.01937697f, -0.02846760f, -0.07256345f, 0.05848230f, 0.14838411f, 0.27024114f, 0.23504058f, -0.18756382f, 
    0.04967183f, -0.07428570f, 0.03456002f, 0.06997596f, -0.01000071f, 0.11277078f, -0.02783705f, 0.20938411f, 
    0.29009175f, 0.19338715f, -0.04894843f, 0.04154709f, -0.23570479f, -0.00438218f, 0.02768272f, -0.04961399f, 
    0.13332765f, 0.11602119f, 0.05563173f, 0.05343945f, -0.32004598f, -0.04471587f, -0.22194265f, -0.09813979f, 
    0.01913203f, -0.00371692f, -0.14075296f, 0.02984864f, -0.05996692f, 0.03077069f, 0.00841096f, 0.00716892f, 
    0.26339167f, 0.13140219f, -0.00136429f, -0.22294006f, 0.10282613f, 0.06156297f, 0.04309611f, 0.05365774f, 
    0.00373535f, 0.09992373f, 0.00646281f, -0.03804775f, 0.12544163f, 0.00998602f, -0.21634829f, -0.10733005f, 
    -0.25022629f, -0.16753684f, -0.09261253f, -0.03832399f, 0.01609434f, -0.31406245f, -0.20479937f, -0.15422440f, 
    -0.08379022f, -0.22492111f, 0.05654572f, 0.02619791f, -0.02936582f, -0.02760650f, 0.04891051f, 0.05145385f, 
    0.13966192f, 0.16823071f, 0.05476733f, 0.07132328f, 0.34241813f, 0.08048794f, -0.14662543f, -0.05633812f, 
    -0.20803504f, -0.07696845f, 0.15102902f, -0.06065394f, 0.08128527f, 0.10649098f, -0.05804871f, -0.08360315f, 
    0.23103851f, 0.10395177f, -0.14414428f, 0.08435369f, -0.09844624f, -0.20303215f, -0.15117860f, -0.05246798f, 
    -0.04039086f, -0.06794967f, -0.01681954f, -0.06350736f, 0.30883217f, 0.32759213f, 0.11106429f, 0.17004628f, 
    0.04112833f, -0.12311233f, -0.07701245f, -0.07457303f, -0.17272776f, 0.10564478f, 0.06445509f, 0.19260104f, 
    -0.32583475f, -0.41425031f, -0.10733867f, -0.11726952f, 0.20138143f, 0.10882840f, 0.12709369f, -0.11629645f, 
    0.21637379f, -0.00178184f, -0.08455370f, 0.01865278f, 0.06483039f, 0.07711657f, -0.20772037f, 0.10770553f, 
    -0.12812805f, -0.04053074f, 0.04038041f, -0.03915889f, -0.06219442f, 0.03037727f, 0.08240388f, -0.03923504f, 
    -0.51290250f, 0.11752930f, 0.02762064f, 0.28950086f, 0.20871571f, 0.09221981f, 0.00646321f, -0.19688030f, 
    0.03678741f, -0.22528829f, -0.10074725f, 0.04681145f, -0.35217774f, -0.30662522f, 0.12302096f, 0.08586372f, 
    0.16340089f, -0.10013502f, 0.16546503f, -0.16965629f, 0.15633896f, 0.00743117f, 0.03938017f, 0.11132614f, 
    0.23807907f, -0.06719187f, -0.33620179f, 0.22901075f, -0.11359876f, 0.14682522f, 0.10549727f, 0.12277048f, 
    -0.22651702f, -0.21333958f, 0.01604602f, -0.18663085f, -0.29925203f, 0.26340881f, -0.02659252f, -0.02184476f, 
    0.07879364f, 0.12669541f, -0.15264986f, -0.00934245f, 0.12156761f, 0.03327831f, -0.09662078f, -0.08625313f, 
    0.24536452f, 0.09731834f, 0.01571079f, -0.32345265f, -0.13594602f, -0.14632462f, 0.04366666f, 0.04051121f, 
    -0.04530065f, 0.07690801f, -0.14414771f, -0.13648443f, 0.32389426f, 0.15148959f, -0.24394846f, 0.25342056f, 
    0.01076696f, 0.03275574f, -0.10792286f, -0.12097733f, 0.00555676f, 0.10094304f, -0.07314713f, 0.04276119f, 
    0.44137320f, 0.16345052f, -0.36593542f, 0.12992007f, 0.11347309f, -0.08930742f, -0.08737805f, 0.02819827f, 
    0.00772109f, -0.05076898f, -0.00970401f, 0.01672026f, -0.46071261f, 0.46843049f, -0.02976086f, -0.14564882f, 
    0.10862008f, 0.22328633f, 0.04722091f, 0.06906348f, 0.08460993f, 0.02962444f, 0.07238391f, 0.04625259f, 
    -0.20146437f, 0.24219365f, -0.03420370f, 0.20531014f, 0.01145464f, -0.05213396f, 0.01257068f, 0.05821856f, 
    -0.00955697f, -0.08499182f, 0.01244627f, -0.09492470f, -0.10760929f, 0.10917239f, 0.00006725f, 0.10523518f, 
    0.09404505f, 0.09796644f, 0.09564642f, -0.03881769f, -0.08028046f, -0.00960769f, 0.05558937f, -0.06614892f, 
    0.49824351f, -0.07182971f, -0.28863388f, -0.00603973f, -0.04015962f, -0.15267283f, -0.03165758f, -0.03593742f, 
    0.01140716f, -0.20525827f, -0.11169805f, 0.06609567f, -0.29689747f, 0.27735519f, -0.20420939f, -0.00757190f, 
    0.06051116f, -0.32552728f, 0.10613010f, 0.09253865f, 0.02963574f, -0.07602118f, 0.09366588f, -0.04795520f, 
    -0.39536506f, 0.16152237f, 0.18095942f, -0.07135026f, 0.01246936f, -0.07956216f, -0.18085901f, -0.00914441f, 
    0.00025803f, 0.13967338f, -0.01507205f, 0.03124862f, 0.26079854f, 0.27746800f, -0.16926052f, 0.19821674f, 
    0.06554423f, -0.43304509f, -0.02574495f, 0.01497103f, -0.01281828f, 0.05667716f, -0.02924671f, 0.06576922f, 
    -0.01840289f, 0.24560246f, 0.01662100f, -0.00682696f, -0.08786085f, -0.11334978f, 0.17016795f, -0.12760878f, 
    -0.01549146f, 0.06504325f, -0.09863497f, -0.25046924f, 0.07235595f, -0.34097847f, 0.21899745f, 0.03883728f, 
    0.05828339f, -0.14944915f, -0.04031615f, -0.07927021f, -0.03225552f, -0.06623551f, 0.18444991f, 0.31947181f, 
    0.16114366f, 0.31856978f, -0.06942672f, 0.08997086f, -0.10203434f, 0.08860232f, -0.25353694f, 0.11543082f, 
    0.04947467f, -0.00261821f, 0.02062793f, 0.05397162f, 0.00663750f, -0.06223031f, -0.24843687f, -0.05595011f, 
    0.07688079f, -0.07260551f, -0.01425225f, -0.14661694f, -0.04562811f, -0.15418452f, -0.06726687f, 0.05015688f, 
    -0.45044968f, -0.41769418f, -0.10616552f, -0.27169198f, -0.16661599f, 0.19977416f, -0.00956817f, 0.06976097f, 
    -0.00123937f, 0.07593032f, 0.02581859f, -0.08721232f, -0.38547093f, 0.16572945f, 0.08153933f, 0.18177451f, 
    0.17798385f, -0.07812029f, 0.06220685f, 0.11575709f, -0.23613691f, -0.16061850f, 0.12678605f, -0.06152840f, 
    -0.22057101f, -0.10348096f, -0.19387503f, -0.27264246f, 0.06339891f, -0.06195958f, 0.04624196f, 0.14574669f, 
    0.01130624f, -0.12146129f, 0.15334910f, 0.00661887f, 0.31808585f, 0.01596333f, -0.28348225f, -0.12988685f, 
    0.19554757f, -0.18555915f, 0.02405924f, 0.28203499f, 0.02196351f, -0.08843926f, 0.18866809f, -0.04788497f, 
    -0.33937171f, -0.13420612f, 0.06713099f, 0.00051799f, -0.04321562f, -0.00076181f, -0.11445077f, 0.09858517f, 
    -0.14830296f, 0.11437351f, -0.06235160f, -0.01738162f, -0.31855693f, -0.12409099f, -0.36400828f, -0.01492358f, 
    -0.07631035f, -0.00797756f, 0.13897805f, 0.15093257f, 0.12333095f, 0.10131107f, -0.05990202f, 0.00167360f, 
    -0.13423525f, 0.28462675f, -0.16954695f, -0.08293246f, -0.03177471f, -0.07273842f, -0.08801877f, -0.04644747f, 
    0.11145038f, 0.00225125f, 0.02664242f, -0.14851366f, -0.19877173f, -0.25568283f, -0.33484736f, 0.13902456f, 
    -0.25559407f, 0.05353634f, 0.00816666f, -0.08484178f, 0.09741867f, -0.03302250f, 0.03556518f, -0.16518106f, 
    0.16383471f, -0.35257873f, 0.00113127f, 0.10099415f, 0.16306324f, -0.01709300f, -0.07227990f, -0.09668333f, 
    0.00571394f, 0.02532319f, 0.07610901f, -0.18623039f, 0.05474946f, -0.16555081f, 0.07555034f, 0.06471086f, 
    -0.02082938f, -0.09449538f, 0.16068685f, -0.10711346f, -0.18823013f, -0.14560945f, 0.02886320f, -0.14474078f, 
    0.07858771f, -0.11289758f, 0.03545871f, 0.06346714f, -0.12405060f, 0.11267318f, 0.09089330f, 0.07998405f, 
    -0.15794763f, 0.00145990f, 0.03163899f, -0.02168908f, -0.04637611f, 0.12249981f, -0.11078211f, -0.22535333f, 
    0.00896282f, 0.00630740f, 0.21365365f, -0.04316925f, 0.07187275f, 0.00050421f, 0.06941921f, 0.01761529f, 
    0.47120383f, 0.05264927f, -0.23570852f, -0.25454122f, 0.19810572f, 0.02823908f, 0.01378533f, -0.05883581f, 
    0.06368220f, -0.07519294f, 0.10560043f, 0.07235190f, -0.29770812f, 0.01550793f, -0.20162955f, 0.32957467f, 
    -0.15907216f, 0.20967215f, -0.06090000f, -0.13265736f, 0.02876238f, -0.05622868f, -0.02555212f, -0.07759878f, 
    0.45154783f, 0.04107517f, 0.07399381f, -0.04960300f, 0.11950047f, -0.07794262f, -0.06724011f, 0.07756706f, 
    0.10971934f, 0.06858601f, 0.06461763f, -0.03102753f, -0.10766055f, -0.40597045f, 0.09584652f, 0.11871887f, 
    0.19428644f, -0.11853460f, -0.00042460f, 0.09386183f, -0.03255543f, 0.10922552f, 0.06828497f, -0.05148856f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13348751f, 0.01114515f, -0.05821323f, -0.01102158f, -0.01412862f, 0.02360078f, -0.01685260f, -0.07151809f, 
    -0.05535869f, 0.03446858f, 0.07211681f, 0.05677759f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
