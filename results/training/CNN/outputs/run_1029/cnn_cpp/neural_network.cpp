#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.36936295f, -0.68431425f, 0.00100407f, 0.87405419f, 0.42162958f, 0.52468836f, -0.60782689f, -0.05020086f, 
    0.44947326f, 0.20387828f, 0.23544860f, 0.43589589f, -0.47458470f, 0.51362127f, -0.41777647f, -0.32230562f, 
    -0.03159447f, -0.19926555f, -0.11915112f, -0.20191284f, 0.18445423f, 0.25432587f, -0.05434305f, 0.01626849f, 
    0.17532702f, 0.68688965f, -0.58633262f, -0.77198100f, 0.11068223f, 0.52601719f, 0.90085274f, 1.26165414f, 
    0.60424447f, -0.54098225f, -0.43256766f, -0.46356648f, -0.17055093f, 0.00006779f, -0.29563421f, -0.02960454f, 
    -0.03829032f, -0.11700192f, 0.06781658f, -0.36632922f, -0.13853073f, 0.25202081f, -0.15691285f, -0.08050247f, 
    0.13208368f, 0.07407115f, -0.61036348f, 0.18115488f, -0.11196454f, 0.39193472f, 0.55793351f, 0.30057213f, 
    0.37098020f, -0.29924935f, -0.30256960f, 0.38226259f, 0.17145948f, 0.04690425f, -0.18232563f, -0.09299410f, 
    0.10973092f, 0.26537344f, -0.01641198f, -0.11761483f, 0.04698059f, -0.08448524f, -0.10791078f, -0.35031357f, 
    -0.05922534f, -0.33147910f, -0.51667696f, -0.10800989f, 0.12257505f, -0.16825087f, 0.36000326f, 0.28809893f, 
    -0.41356376f, -0.44434735f, -0.84845406f, -0.75533009f, -0.01822728f, -0.00047949f, 0.55884492f, -0.40529743f, 
    0.26887956f, 0.30117980f, 0.02861804f, 0.34915647f, -0.06822743f, 0.13016158f, -0.28879023f, 0.12198738f, 
    0.06033966f, 0.00629786f, -0.00220360f, -0.33489156f, 0.27535066f, -0.26963207f, -0.28053904f, -0.20632036f, 
    -0.38850853f, -0.84140038f, -0.75801349f, -0.22927740f, -0.23568799f, -0.62626535f, 0.99605644f, 0.41152912f, 
    0.01493014f, 0.30601591f, -0.30577576f, -0.27160963f, -0.12801954f, -0.11404858f, -0.51956612f, -0.72403640f, 
    -0.10976039f, 0.01293028f, 0.19017607f, -0.36858439f, -0.41677481f, -0.19577643f, -0.27257594f, -0.61138779f, 
    -0.20523031f, 0.11791264f, -0.39798769f, -0.77042162f, -0.41030216f, 0.37044021f, 0.06970030f, -0.31588164f, 
    -0.42996678f, -0.23324050f, -0.16605560f, -0.23154338f, -0.57527751f, -0.63619322f, 0.26185590f, -0.01250783f, 
    -0.90052176f, 0.14520927f, 0.02547796f, -0.32396531f, 0.39759246f, 0.62953675f, -0.47598693f, -0.39731717f, 
    -0.10152552f, -0.00732129f, 0.05561789f, -0.06062760f, 0.04081831f, 0.25129262f, 0.28785202f, 0.05469433f, 
    -0.33503515f, 0.27003232f, 0.24985147f, 0.41961524f, -0.12713470f, -0.28780863f, -0.02378491f, 0.15010306f, 
    -0.37519738f, -0.18186183f, 0.32758185f, 0.38820362f, 0.30536923f, -0.08250507f, 0.27293867f, -0.37057137f, 
    -0.33994356f, -0.01948215f, -0.75552607f, -0.74322236f, 0.03701245f, -0.10221951f, -0.43382481f, 0.10779241f, 
    0.81741518f, 0.19760583f, 0.34282854f, 0.02679682f, 0.10341007f, 0.02198633f, 0.24313334f, -0.33542353f, 
    -0.24699455f, -0.60663694f, -0.46200466f, -0.07833336f, -0.30439028f, 0.19619289f, 0.24347252f, 0.58551401f, 
    -0.47220680f, -0.69941884f, -0.50601077f, -0.85263169f, -0.43763414f, -0.37548679f, -0.91367972f, -0.67031658f, 
    -0.79641575f, -0.55210418f, 0.25293502f, 0.25352582f, 0.10157404f, 0.02636683f, -0.03498492f, 0.20143770f, 
    -0.16228272f, -0.02454535f, 0.08404637f, 0.11090269f, -0.07479339f, 0.25107244f, 0.14548466f, -0.03825925f, 
    0.20209572f, -1.18745911f, -0.71006024f, -0.48104295f, -0.18186551f, -0.49989232f, 0.43486077f, 0.41267988f, 
    0.29009089f, 0.36504406f, 0.31544828f, 0.14787567f, 0.39608449f, 0.18516268f, -0.18386741f, -0.41205075f, 
    -0.33682972f, -0.30344409f, -0.18567944f, 0.05173940f, -0.21461824f, -0.06466394f, -0.12686594f, -0.20099720f, 
    -0.23678988f, -0.24147215f, 0.43997711f, 0.27519742f, -0.06077152f, -0.43754184f, 0.10503905f, -0.23921442f, 
    -0.35641173f, 0.38462511f, 0.37680370f, 0.07273485f, -0.42289013f, 0.17023607f, 0.31067413f, 0.42877975f, 
    -0.27315408f, 0.17845437f, 0.35215190f, -0.31080049f, -0.35341844f, -0.09333727f, -0.01196531f, 0.18010573f, 
    -0.16773248f, 0.04224664f, -0.19962108f, -0.37970001f, -0.87742662f, -0.71444607f, -0.25278765f, 0.27330661f, 
    -0.33128202f, 0.52994359f, 0.25225520f, -0.23161720f, -0.17522638f, 0.70366180f, -0.11493119f, 0.57824951f, 
    0.04786209f, 0.27321890f, 0.05747125f, -0.12038498f, 0.11591141f, -0.11258911f, 0.16064179f, 0.15634039f, 
    0.02451121f, -0.00024295f, -0.13167314f, 0.17523143f, 0.63235849f, 0.76688242f, 0.65596205f, 0.06800798f, 
    0.13741878f, -0.58951384f, -0.57598943f, -0.10191299f, 0.54315597f, 0.29915008f, 0.33353734f, -0.06719162f, 
    -0.28492308f, -0.14714210f, 0.34353152f, -0.14753596f, 0.30828872f, -0.15919167f, -0.08118317f, -0.07358184f, 
    -0.08222798f, 0.23411742f, 0.06391022f, 0.13734727f, -0.23332478f, 1.46278632f, 0.77527755f, -0.27045214f, 
    -0.80658054f, -1.15777469f, 0.68411207f, 0.07114143f, 0.17717655f, -0.54939425f, -0.43007571f, 0.12785579f, 
    0.02009647f, -0.13582309f, -0.00822496f, 0.43184960f, 0.14202259f, 0.03021320f, 0.18647215f, -0.08214326f, 
    -0.33994108f, 0.06190094f, -0.24131635f, -0.13516733f, 0.38408282f, -0.19983946f, -0.18001299f, 0.15554138f, 
    0.71040958f, -0.22631490f, -0.69090652f, -0.12913239f, -0.06283090f, -0.16403651f, 0.08784869f, -0.28406537f, 
    0.53222126f, -0.97863716f, -0.23583780f, -0.00542058f, 0.21840909f, -0.28801686f, -0.15913011f, 0.04450327f, 
    0.49671131f, 0.16897252f, -0.11511201f, 0.28552109f, -0.01396896f, -0.27652884f, -0.10013269f, 0.65902984f, 
    -0.87290120f, -0.27810654f, 0.04671738f, -0.13823530f, 0.43760806f, 0.55027467f, -0.13422492f, -0.33991230f, 
    -0.31797391f, 0.53408051f, -0.18262625f, 0.07570823f, -0.19272894f, -0.08128355f, 0.07587534f, 0.28217119f, 
    0.03176053f, -0.03369568f, 0.06494416f, -0.19205682f, 0.52276433f, 0.26427877f, -0.34482476f, -0.13499418f, 
    0.27765259f, -0.41873759f, 0.02536483f, 0.02523250f, -0.30742788f, -0.64350224f, -0.62113810f, 0.18541408f, 
    0.18634103f, -0.74822760f, -0.23241204f, -0.70092732f, -0.21090533f, 0.73651803f, -0.23484990f, -0.06165211f, 
    -0.07095099f, -0.03762510f, -0.04640039f, 0.07469341f, 0.42776504f, -0.06610097f, 0.15789227f, 0.42492253f, 
    0.06556756f, 0.28522289f, 0.31786069f, -0.65207452f, -0.89347082f, -0.93280846f, 0.61937863f, -0.18749404f, 
    0.82996112f, -0.28063723f, -0.00495207f, -0.03777013f, 0.50984144f, -0.19473146f, -0.21528473f, -0.16878460f, 
    -0.52577108f, -0.15333641f, -0.07837383f, -0.30146366f, 0.57723916f, -0.15022798f, -0.15576671f, 0.17475270f, 
    0.11600944f, 0.53691673f, -0.55455357f, -0.75212270f, -0.48686770f, -0.46997514f, -0.37574929f, 0.72484887f, 
    0.33269930f, 0.03852559f, 0.15911679f, 0.56515574f, -0.00670849f, -0.00707570f, 0.08699766f, 0.17827204f, 
    0.08756401f, -0.21417032f, 0.07359939f, 0.05545043f, -0.17708202f, -0.00852032f, -0.16007032f, -0.19831137f, 
    0.20033172f, 0.36214390f, -0.21630219f, -0.79331642f, -0.17491740f, -0.30691156f, 0.41076204f, 0.03923717f, 
    0.10403049f, -0.55082166f, -0.45764467f, -0.16433899f, -0.06057531f, -0.40977189f, 0.00905490f, -0.00909450f, 
    -0.07861257f, 0.05465811f, 0.17608191f, -0.10625663f, -0.40303791f, -0.46029046f, -0.77734107f, -0.06015978f, 
    -0.29266527f, -0.50103402f, -0.34500915f, -0.26353478f, -0.73925513f, -1.03969657f, 0.39561850f, 1.22620618f, 
    0.85916126f, -0.34130821f, -0.61742502f, -1.21322107f, -0.44002053f, -0.16397773f, -0.48856679f, -0.15910462f, 
    -0.64241976f, 0.21935514f, -0.26554438f, 0.03562316f, -0.21228971f, 0.10759833f, 0.20757492f, 0.34810379f, 
    0.33941695f, -0.45980009f, -0.15598877f, -0.06421393f, -0.24571243f, -0.40088862f, -0.01583217f, -0.62324351f, 
    -0.53831452f, -0.46014094f, -0.33552945f, -0.12402554f, -0.32996991f, -0.29181170f, -0.04147245f, -0.08127399f, 
    0.12725449f, 0.10678044f, -0.48099229f, 0.05734884f, -0.13436142f, 0.29083869f, 0.18075863f, 0.24705465f, 
    0.32708335f, -0.39964840f, -0.22492847f, -0.08431890f, -0.33495426f, -0.56880349f, 1.31439757f, 0.25879014f, 
    -0.07547139f, -0.53442127f, -0.48554653f, 0.31339836f, -0.01221204f, 0.26908585f, 0.05604988f, -0.24167800f, 
    0.01315749f, 0.02501567f, -0.16312996f, -0.34908232f, -0.10262293f, -0.23923959f, -0.19231535f, 0.04414392f, 
    -0.15671362f, -0.25836357f, -0.25690317f, -0.26647383f, -0.67217761f, -0.65413523f, -0.53228581f, -1.51505494f, 
    -0.23502228f, 0.59112936f, -1.08230865f, -0.84128737f, 0.20181087f, 0.25620407f, 0.18388243f, 0.40631294f, 
    0.28348768f, -0.67167372f, -0.24848233f, 0.08598254f, 0.35938859f, 0.22720413f, 0.19597602f, -0.06766270f, 
    -0.26524329f, -0.45313126f, -0.19893034f, 0.09162664f, 0.41580668f, 0.12206328f, -0.27970770f, -0.29135934f, 
    0.29761186f, -0.19113445f, -0.26427051f, 0.28576434f, 0.02344679f, 0.56089377f, -0.38471335f, -0.05764095f, 
    0.52922225f, 0.07777727f, -0.22478876f, -0.00697372f, -0.41818911f, 0.36604729f, -0.40214443f, 0.34134445f, 
    0.27037704f, 0.15532461f, -0.09391535f, -0.14510858f, -0.19948243f, 0.23403984f, 0.22147976f, -0.05755364f, 
    -0.19119094f, -0.93327528f, -0.84280080f, -0.49186891f, 0.08340406f, 0.74989825f, 0.35361755f, 0.04463344f, 
    -0.30881757f, 0.33266306f, 0.65508509f, -0.10971930f, -0.09720754f, 0.21845420f, -0.44043985f, -0.12796086f, 
    -0.10055925f, 0.51130712f, 0.10363941f, 0.15521821f, 0.13979258f, -0.10296480f, -0.01810007f, -0.21031311f, 
    -0.19054063f, 0.04294608f, -0.82112056f, 0.41178301f, 0.19525190f, 0.06685646f, 0.26809460f, 0.13245688f, 
    0.50841945f, 0.21371010f, 0.18569899f, -0.02550508f, -0.32880950f, 0.38906133f, -0.02896787f, -0.20548424f, 
    0.06563083f, 0.27446565f, 0.08059214f, -0.28436223f, -0.29858458f, -0.20427510f, 0.11914793f, 0.26434091f, 
    0.11896890f, -0.14405668f, -0.01230750f, 0.20886691f, 0.55958003f, -0.84532332f, 0.03106660f, -0.67509812f, 
    -0.95010334f, -0.12121285f, -0.09437881f, -0.88226086f, -0.70468891f, -0.30369526f, -0.30795917f, 0.11772805f, 
    -0.07848214f, -0.16082315f, 0.07934831f, 0.18855475f, 0.25956875f, -0.42436022f, -0.41748255f, 0.12351454f, 
    0.00368298f, -0.01200412f, -0.00773689f, 0.37489823f, -0.12694460f, -0.35870618f, -0.71971118f, -0.45174620f, 
    0.24288112f, 0.15078129f, -0.49368346f, -1.01134682f, -1.00011909f, -1.00878358f, -0.04823365f, -0.25860810f, 
    0.78450489f, 0.36613882f, 0.09317079f, 0.03198658f, -0.22173125f, -0.25132948f, 0.00017514f, -0.26415521f, 
    -0.30979416f, 0.10320845f, -0.11903440f, 0.01845618f, 0.18862106f, -1.22553635f, -0.62073046f, -1.08020198f, 
    -0.20175222f, 0.37648702f, 0.30210957f, 0.46573168f, 0.04155396f, 0.06169217f, -0.22155650f, 0.05303286f, 
    -0.04892546f, -0.48995128f, -0.39478397f, -0.63301700f, 0.17387828f, 0.61033779f, -0.48438802f, 0.09412204f, 
    0.25096980f, 0.16421032f, -0.23052819f, -0.10602829f, 0.08000457f, -0.44193709f, 0.09379732f, 0.95623589f, 
    0.63441145f, -0.15573439f, 0.37633494f, -0.11820440f, -0.29821163f, -0.11531836f, -0.01944786f, -0.61736047f, 
    -0.42647627f, -0.26850119f, -0.06813747f, 0.12873617f, 0.00306633f, -0.09627211f, 0.28585598f, 0.09750414f, 
    -0.03202013f, 0.17349328f, 0.06651694f, -0.15348440f, -0.12373307f, -0.38394091f, -0.01801581f, -0.97639358f, 
    0.79961002f, 0.22106639f, -0.44049969f, -0.57704359f, 0.37429029f, 0.26630777f, -0.18187602f, 0.00646260f, 
    -0.15453696f, -0.14418225f, -0.03186445f, 0.15259692f, 0.00362959f, 0.09578130f, 0.19430536f, -0.03994481f, 
    -0.05191836f, -0.03649847f, -0.00180890f, -0.35531098f, -0.17837097f, -0.02453198f, -0.33268547f, -0.68772310f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.38672951f, 0.60563749f, 0.06884790f, 0.35454991f, -0.11507590f, 0.14582200f, 0.09016339f, 0.59499878f, 
    -0.41197106f, -0.09678240f, 0.61491960f, 0.29909900f, 0.05572318f, 0.64679766f, 0.27737126f, 0.56287390f, 
    0.12486055f, 0.63499147f, 0.24298488f, -0.13275258f, 0.18117534f, 0.01716443f, -0.02623033f, -0.00425636f, 
    0.35171825f, 0.16960947f, 0.53692275f, -0.10296370f, -0.14620952f, 0.38235554f, 0.41193280f, 0.27278587f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24227679f, 0.29958060f, 0.49656063f, -0.45424807f, -0.00905306f, 0.10181178f, 0.11859582f, 0.00166001f, 
    -0.20754702f, -0.11847206f, -0.31562066f, -0.29188854f, 0.35549960f, -0.70678747f, -0.55773288f, 0.07322757f, 
    0.00523842f, -0.03923785f, 0.08194374f, 0.02407662f, 0.03168198f, -0.11913817f, -0.12053230f, 0.00235398f, 
    -0.07136460f, 0.10162823f, 0.05237797f, 0.10715080f, 0.04456975f, 0.01051830f, 0.01372169f, 0.03517061f, 
    -0.12117275f, -0.03541818f, 0.23666617f, 0.12069214f, 0.16267459f, 0.20152269f, -0.09287711f, -0.07542256f, 
    -0.15383060f, -0.18912879f, -0.10598636f, -0.00290560f, 0.00876737f, -0.01269358f, -0.05124352f, 0.03480438f, 
    0.38991982f, 0.32006949f, -0.10305735f, -0.18483040f, 0.01903979f, -0.09111970f, 0.00470061f, 0.17299686f, 
    0.02431697f, 0.15359442f, -0.21059205f, -0.03923321f, 0.08021725f, 0.22233526f, 0.01806856f, -0.04548145f, 
    0.24082811f, 0.03791671f, -0.26419282f, -0.32232720f, -0.10195133f, -0.21308631f, -0.10361811f, -0.14241934f, 
    -0.12934540f, 0.06828431f, 0.17968187f, -0.02166545f, -0.03972391f, -0.00760646f, 0.07446381f, -0.17900091f, 
    -0.10300856f, -0.34348008f, 0.06304254f, -0.14293559f, 0.18743554f, 0.00064393f, 0.02799603f, -0.16129997f, 
    -0.02552368f, 0.08697963f, 0.03675733f, -0.20310082f, -0.24879424f, -0.06730575f, -0.06413435f, 0.03360743f, 
    0.45590109f, 0.35175383f, -0.20728424f, -0.24522941f, 0.24957339f, 0.17434941f, -0.04616807f, 0.03754885f, 
    0.06658494f, 0.03573574f, 0.10520155f, 0.03213004f, 0.32118940f, 0.25297269f, -0.12631042f, -0.03384749f, 
    0.17977197f, 0.16121766f, 0.07375946f, -0.02144529f, 0.00790468f, 0.15837158f, 0.05599902f, 0.15888454f, 
    -0.60869879f, -0.62311912f, -0.05132826f, 0.02937276f, -0.13214701f, -0.16349050f, -0.06511836f, -0.06741261f, 
    -0.06952173f, -0.13758351f, -0.18777418f, -0.03335661f, 0.10513042f, 0.28338540f, -0.07360687f, -0.02901144f, 
    0.07631120f, -0.04095739f, 0.02375136f, -0.42483822f, -0.11652327f, -0.05054809f, -0.03582782f, 0.04813138f, 
    -0.46225190f, -0.06236966f, 0.01320504f, -0.23614749f, 0.07052129f, 0.04152393f, -0.04092380f, 0.05663577f, 
    -0.02179573f, -0.05242017f, -0.07441773f, 0.01466488f, 0.00095918f, -0.21992758f, -0.48683575f, 0.17506035f, 
    -0.06961459f, -0.09208243f, -0.43828249f, -0.27958593f, -0.11026435f, -0.03158550f, -0.08022970f, -0.04793685f, 
    -0.13294828f, -0.13733174f, 0.11812983f, -0.19950247f, -0.42097867f, -0.22481161f, -0.08044460f, -0.02676714f, 
    -0.03293414f, -0.08050372f, -0.00322013f, 0.05525669f, 0.35545263f, -0.13539782f, -0.40335649f, -0.05598747f, 
    -0.20992620f, -0.25503671f, 0.00091915f, 0.02904428f, -0.02238164f, 0.17883269f, -0.22146983f, -0.03554644f, 
    0.07567471f, 0.19604506f, 0.18755750f, -0.36523774f, 0.10156386f, 0.05683567f, -0.08410477f, -0.00428313f, 
    0.03577828f, 0.03903182f, 0.02262352f, -0.01313359f, 0.07855073f, -0.33353302f, -0.27941570f, -0.15137883f, 
    0.05518762f, -0.01621334f, -0.16232403f, 0.01483522f, 0.00373293f, -0.15916292f, 0.05576602f, -0.28849992f, 
    0.11995707f, -0.11506856f, -0.08275983f, 0.11808156f, 0.01460130f, 0.13067360f, 0.03935008f, 0.02146667f, 
    -0.05749400f, 0.00775758f, -0.01324330f, 0.03750390f, 0.17413762f, 0.29878414f, 0.05586260f, -0.01725432f, 
    -0.25488746f, -0.11523405f, 0.02347782f, -0.02504445f, -0.11052296f, -0.15165329f, 0.13284272f, 0.14502814f, 
    0.57811350f, 0.20328946f, -0.03181330f, -0.18453628f, 0.09555784f, -0.06994309f, 0.01524588f, 0.10566241f, 
    0.03506362f, -0.05546939f, -0.07736182f, 0.00046915f, 0.21620199f, 0.24049692f, 0.03877913f, -0.09434807f, 
    0.16311347f, 0.20502310f, 0.16972144f, 0.00586036f, 0.00382308f, 0.12736015f, 0.01141064f, 0.03941659f, 
    -0.43231860f, -0.62122995f, -0.41645545f, 0.12218152f, 0.04518892f, 0.08700658f, -0.02288532f, 0.01200721f, 
    -0.11721661f, -0.03330692f, -0.14350165f, 0.01611859f, -0.02571052f, -0.00099987f, 0.15179577f, -0.24275166f, 
    0.01202848f, 0.25367045f, -0.08210739f, 0.09147418f, -0.10063462f, 0.03257670f, 0.03414346f, 0.01015249f, 
    -0.07996623f, -0.00622508f, -0.26041394f, -0.05662600f, -0.03763147f, -0.05564425f, 0.04960655f, 0.00320449f, 
    -0.04980652f, 0.20737144f, -0.26265761f, -0.16244327f, 0.33722383f, 0.20818953f, 0.02761818f, 0.04683212f, 
    -0.05265570f, 0.05688691f, 0.10345103f, -0.08762775f, 0.03013649f, 0.07349705f, -0.05163007f, -0.12231703f, 
    -0.32557404f, -0.21294403f, -0.18629055f, -0.18909644f, -0.02403441f, -0.03322887f, 0.03433010f, 0.04789921f, 
    -0.14249185f, 0.17943873f, -0.10541571f, -0.16371681f, 0.24022004f, 0.13425609f, -0.09472412f, -0.15614980f, 
    0.07903510f, -0.09892309f, 0.13383301f, -0.04252850f, -0.00006205f, 0.03673273f, -0.08202817f, 0.05718797f, 
    0.46368384f, 0.21674740f, -0.37294966f, -0.20134628f, -0.00953178f, 0.10047153f, 0.10853489f, 0.06419755f, 
    -0.04240929f, -0.06505906f, 0.02428216f, 0.02616620f, 0.42539224f, -0.03441237f, -0.26929206f, -0.32065055f, 
    0.08905157f, 0.04516990f, 0.09735786f, 0.01860629f, -0.02250288f, 0.05155944f, -0.07460473f, -0.07765726f, 
    -0.63992393f, -0.29710507f, -0.15400109f, 0.30732968f, 0.05085540f, -0.03508974f, -0.14410180f, 0.02776426f, 
    -0.00182291f, -0.03062404f, -0.01904426f, 0.00182807f, -0.18529055f, -0.12469646f, -0.13225490f, 0.10076153f, 
    -0.00291264f, 0.02698977f, 0.04241654f, 0.01438752f, -0.07948904f, 0.09924574f, -0.03902593f, -0.02168872f, 
    -0.23459116f, 0.05680626f, -0.31608367f, 0.10162290f, -0.12092696f, -0.14043505f, 0.11330212f, 0.15958025f, 
    -0.18535005f, -0.08315012f, -0.11389252f, 0.18809007f, 0.95513600f, -0.57184076f, 0.57472903f, 0.39444557f, 
    -0.06966639f, 0.00971928f, 0.03530368f, 0.02630763f, 0.12637261f, 0.13359194f, -0.04227512f, -0.24321082f, 
    0.07383098f, 0.11882185f, 0.09007046f, 0.12522082f, 0.00556456f, -0.04476127f, 0.00448941f, 0.01474141f, 
    -0.06364749f, -0.25214204f, -0.04399291f, -0.16553369f, -0.19933975f, 0.11009637f, -0.26252019f, -0.14667818f, 
    -0.00804870f, -0.15639716f, -0.07526827f, 0.24320196f, -0.03769103f, -0.00852511f, 0.02508221f, 0.05631482f, 
    -0.44977698f, -0.12845294f, -0.07079156f, -0.27825841f, -0.09520679f, -0.07179224f, 0.03417123f, 0.50829053f, 
    0.05864248f, -0.17032024f, -0.15831903f, 0.11923325f, -0.07269201f, 0.27772865f, -0.00156393f, 0.01653028f, 
    -0.00073953f, 0.12811531f, 0.01142696f, 0.01993112f, 0.08766471f, -0.05451012f, -0.02261607f, -0.35729223f, 
    -0.15475868f, 0.05937599f, 0.05285757f, 0.03246009f, -0.13683359f, 0.10587419f, 0.08444239f, 0.15879045f, 
    -0.15925899f, -0.13747339f, -0.00531503f, 0.05043676f, -0.18394855f, -0.23347618f, -0.18857306f, -0.22181258f, 
    0.27861884f, 0.23681337f, -0.01685773f, 0.17279594f, 0.19125058f, -0.05614362f, -0.07798869f, -0.05458909f, 
    0.04811833f, 0.19239897f, 0.28358260f, 0.40582052f, -0.18660276f, 0.19121845f, -0.24892877f, -0.17384991f, 
    -0.12016794f, -0.02708088f, -0.04862716f, 0.06850321f, 0.10520054f, -0.24095705f, -0.43162808f, -0.13430314f, 
    -0.16681491f, 0.01164854f, -0.00574869f, -0.00086267f, -0.11751191f, -0.12499864f, -0.15926652f, -0.12174165f, 
    0.10661823f, -0.01517606f, 0.11342262f, 0.04785809f, 0.03230431f, 0.02026934f, 0.01549922f, 0.06859220f, 
    -0.01704476f, 0.06314828f, -0.13475159f, 0.10246925f, -0.14395395f, -0.13262421f, -0.15455255f, -0.04463146f, 
    -0.06471014f, 0.18281202f, 0.21073778f, -0.17852823f, -0.04923992f, 0.00177425f, 0.11440967f, -0.02495313f, 
    0.16675104f, 0.21364443f, 0.17171177f, 0.17076230f, 0.03280739f, -0.03447294f, -0.03280592f, 0.03588975f, 
    0.04598080f, -0.02212366f, -0.06672892f, 0.06369687f, 0.63402092f, -0.42903802f, 0.29151055f, -0.30260122f, 
    -0.04448903f, -0.08129401f, 0.08420917f, -0.09193591f, 0.05238316f, 0.12046435f, -0.29380405f, 0.09663096f, 
    0.03551424f, -0.03997239f, -0.03296636f, -0.38424167f, 0.02613392f, 0.21934253f, -0.15033056f, 0.12938726f, 
    -0.09877534f, 0.04993926f, -0.00247525f, -0.12864409f, 0.33296719f, -0.10726213f, -0.13331932f, 0.04677901f, 
    0.10808180f, 0.10424289f, 0.06385851f, 0.06183564f, 0.01838983f, -0.12363319f, 0.16773722f, 0.04140509f, 
    -0.01539569f, 0.04681432f, 0.30080023f, -0.10286790f, -0.04398328f, -0.05159552f, 0.25535849f, -0.04151315f, 
    -0.10337698f, -0.06694289f, 0.10579783f, -0.03607208f, 0.30811360f, -0.10560534f, -0.34521630f, -0.33969855f, 
    0.06615778f, 0.11242975f, 0.23068768f, 0.13080427f, 0.12339783f, 0.13260895f, -0.38021332f, 0.01069957f, 
    0.30456674f, 0.00063748f, -0.09632079f, -0.18129940f, -0.00162748f, -0.03582848f, 0.02436573f, -0.03259959f, 
    0.10415749f, 0.02015405f, 0.12429794f, -0.32212505f, 0.00200810f, 0.00595429f, -0.05774911f, 0.13195273f, 
    0.11777818f, 0.04354370f, 0.07535355f, -0.02259403f, -0.06310339f, -0.06645270f, -0.05688445f, -0.21494623f, 
    -0.19548522f, -0.00805872f, -0.41712707f, -0.61534464f, -0.07927661f, -0.16095060f, -0.17535491f, -0.06453473f, 
    0.07161260f, -0.04517023f, 0.06582933f, -0.05680349f, 0.09520666f, 0.16922262f, 0.10289161f, 0.10294680f, 
    -0.11637043f, 0.09998772f, -0.21015069f, -0.27989143f, -0.01103261f, 0.01412955f, -0.07983848f, 0.05538388f, 
    0.54671854f, -0.08782464f, 0.20402654f, -0.24469057f, -0.07079495f, -0.03188398f, -0.13263680f, 0.02906813f, 
    -0.32663727f, -0.13343902f, -0.16915910f, -0.16182519f, -0.38779187f, 0.15784012f, 0.33122167f, 0.01275711f, 
    0.15430906f, 0.08722734f, -0.37821227f, 0.14470476f, -0.16280217f, -0.03623363f, 0.07916865f, -0.20914559f, 
    0.05500184f, 0.23382767f, -0.01048112f, 0.13528232f, 0.04226040f, -0.02241910f, 0.01244064f, 0.01114503f, 
    -0.01503078f, 0.07316604f, -0.17118822f, 0.11540084f, 0.05418947f, 0.09431744f, -0.21950078f, -0.04379663f, 
    -0.02044730f, 0.09390719f, -0.05866654f, -0.14223875f, 0.06461509f, -0.16704050f, -0.26564574f, -0.09838948f, 
    -0.02381871f, -0.09128425f, 0.25744456f, 0.29609546f, -0.03246091f, 0.01848175f, -0.05328754f, 0.08087189f, 
    0.02692772f, 0.07468353f, -0.14429751f, 0.03421147f, 0.12590569f, 0.01131376f, 0.20178448f, -0.55909741f, 
    0.00951503f, 0.00692894f, 0.03185831f, -0.22748132f, -0.02055183f, -0.00396671f, 0.02179779f, 0.09647796f, 
    0.03817879f, -0.13738930f, 0.15357278f, 0.26443183f, -0.04823119f, -0.02903689f, 0.07668034f, -0.15455030f, 
    0.09335341f, 0.00228859f, 0.05583918f, 0.03926067f, 0.19824713f, -0.11141235f, 0.03669652f, 0.01598604f, 
    -0.04913178f, -0.05234093f, 0.08755271f, -0.15248810f, 0.05085469f, -0.11940842f, -0.18543573f, 0.00125969f, 
    0.17130144f, 0.17175557f, -0.05633028f, -0.07294954f, -0.03607422f, -0.14009279f, -0.15471391f, 0.04486473f, 
    0.02438642f, 0.13288462f, -0.01912947f, 0.02951324f, -0.11733084f, -0.01512531f, 0.13074689f, -0.15327802f, 
    0.08402107f, -0.02443784f, -0.18200332f, 0.05209401f, -0.28811318f, 0.25860310f, 0.02284528f, -0.33029354f, 
    -0.16112933f, -0.24631777f, -0.55727375f, -0.05923929f, 0.16152281f, -0.04449509f, 0.01325006f, 0.12793639f, 
    0.08628704f, -0.05140484f, -0.30535164f, 0.13045110f, 0.06084965f, -0.19144835f, 0.17282225f, -0.24291608f, 
    0.03231999f, -0.08855113f, 0.03593182f, -0.05166654f, 0.05817807f, 0.05623815f, 0.08073663f, -0.17314801f, 
    0.14180033f, -0.19388074f, 0.05208328f, 0.00114902f, -0.03140038f, 0.00239236f, 0.06279399f, -0.02062676f, 
    0.03272630f, 0.15299733f, -0.04693003f, 0.08126964f, -0.04102144f, -0.31403607f, 0.03653024f, 0.07705970f, 
    0.03329795f, -0.28059828f, -0.16458583f, 0.00918922f, 0.05558200f, -0.05052006f, -0.02289927f, 0.10035710f, 
    -0.91077912f, -0.00615177f, -0.39945060f, -0.04994781f, 0.08012658f, -0.05839714f, 0.12287696f, -0.38688034f, 
    0.17112076f, -0.14053831f, -0.20793162f, 0.06962416f, -0.08164191f, 0.15307699f, 0.02358578f, -0.17426826f, 
    0.07704881f, 0.10844008f, 0.09189451f, 0.06717782f, -0.00429171f, -0.08491626f, 0.14233477f, -0.13244404f, 
    -0.00793374f, -0.06438677f, -0.08026478f, 0.06998336f, 0.03675310f, 0.12211415f, -0.04550646f, -0.08793233f, 
    -0.08491218f, -0.11692864f, -0.03090723f, -0.09431375f, 0.32951400f, 0.20845820f, 0.05609161f, 0.27943265f, 
    0.03118829f, 0.16082226f, -0.11992223f, -0.08543792f, 0.02968188f, -0.08086520f, -0.09293544f, 0.20580164f, 
    -1.08804023f, -0.56773299f, -0.44410834f, -0.21146399f, -0.19504133f, -0.20784348f, -0.05451756f, -0.01624611f, 
    0.00955861f, 0.05586396f, -0.01836609f, -0.01011268f, 0.14652699f, 0.30770648f, 0.34808093f, 0.28504410f, 
    -0.04176390f, -0.07475567f, 0.03052079f, 0.00243068f, -0.11050458f, -0.08487543f, 0.25224832f, -0.08836184f, 
    -0.04072665f, 0.09292311f, -0.02712887f, 0.21625488f, -0.11320923f, 0.06427997f, 0.14781204f, 0.03456985f, 
    -0.01697106f, -0.04785852f, -0.06756183f, 0.28803077f, -0.01476226f, -0.05195582f, 0.07217266f, 0.02485076f, 
    -0.06531238f, -0.06872732f, -0.09814129f, 0.24833593f, 0.01099305f, 0.12929682f, 0.01297830f, 0.00257680f, 
    -0.64641070f, -0.42269093f, 0.33205169f, 0.08054414f, -0.01680451f, -0.01377457f, 0.00776204f, -0.00954727f, 
    -0.01592616f, 0.02792863f, -0.11191329f, 0.09589787f, -0.24892634f, 0.12422344f, 0.40957928f, -0.35943827f, 
    -0.06180304f, -0.01088432f, -0.18879154f, -0.26529339f, 0.03234583f, 0.10103631f, -0.02904184f, 0.06042824f, 
    0.01079363f, 0.15805061f, -0.13909715f, -0.17448585f, 0.05767077f, -0.00767640f, 0.01808848f, -0.15594265f, 
    0.04211920f, 0.10654099f, -0.07734381f, 0.06556024f, -0.04459472f, 0.11885358f, 0.21373020f, 0.00383342f, 
    -0.02941278f, -0.09186144f, -0.04208287f, 0.02559563f, 0.16160712f, -0.03773327f, -0.02651733f, 0.00224743f, 
    -0.34178433f, -0.27468973f, -0.28866500f, 0.07604697f, -0.28740153f, 0.18044668f, 0.20487843f, -0.24015197f, 
    -0.06372521f, -0.00330660f, -0.02051848f, -0.07908656f, -0.05834604f, 0.63730580f, 0.12462395f, -0.02809190f, 
    -0.00466640f, 0.15193877f, 0.02556556f, -0.17933875f, 0.04633481f, 0.09969246f, -0.29542297f, -0.04770779f, 
    -0.08499610f, -0.03267364f, 0.41168815f, 0.23982653f, 0.01224530f, 0.01062449f, 0.12426996f, -0.00442786f, 
    -0.11652586f, 0.00918848f, 0.07319002f, 0.00705367f, -0.21932329f, -0.13439564f, -0.01158029f, 0.14851755f, 
    0.00402718f, -0.06438719f, -0.11336891f, 0.10646223f, -0.01640393f, 0.00695407f, -0.12115470f, -0.05802805f, 
    -0.50894856f, 0.40724140f, -0.34078991f, -0.02463506f, -0.08484020f, -0.14237638f, -0.14793254f, -0.01668318f, 
    0.00566299f, -0.00303317f, -0.01881621f, -0.01403928f, -0.18892017f, -0.15094666f, 0.08692772f, 0.26171142f, 
    0.05904716f, -0.01097959f, -0.00275947f, -0.04831788f, 0.00435574f, 0.08137064f, 0.08461016f, -0.03723834f, 
    -0.23836845f, 0.23342609f, 0.05522441f, -0.08482020f, -0.05395474f, -0.03309102f, -0.08158754f, -0.06296727f, 
    0.10540807f, 0.25395522f, 0.06182936f, 0.37334493f, 0.57677400f, 0.25582224f, 0.57957345f, 0.82448763f, 
    -0.06617340f, 0.14113374f, 0.05506654f, -0.01410075f, -0.02032097f, -0.17776778f, -0.03172987f, 0.04087781f, 
    -0.21537037f, -0.00435728f, 0.04640058f, 0.10033450f, 0.07924660f, -0.05296789f, 0.08993781f, 0.03927836f, 
    0.00604473f, 0.14960659f, 0.02582995f, 0.13308084f, -0.09257550f, -0.21298175f, 0.02235036f, 0.32530335f, 
    0.06054543f, -0.05527302f, 0.02796584f, 0.19824962f, 0.05705395f, 0.11121718f, 0.09251007f, 0.03366018f, 
    0.19556239f, -0.52973276f, -0.43427482f, 0.02399972f, -0.00291256f, -0.00742313f, 0.06364376f, 0.03881672f, 
    -0.04600582f, -0.00947586f, -0.24400136f, 0.22940929f, -0.54849195f, -0.77811027f, 0.10164442f, -0.23421726f, 
    -0.08466375f, 0.10926879f, -0.20704605f, -0.31653059f, 0.01795185f, -0.10249788f, 0.02550785f, -0.06544667f, 
    -0.72402841f, -0.76575202f, -0.11212777f, -0.39493608f, 0.09066849f, -0.03129030f, 0.04706059f, -0.28132936f, 
    -0.00452225f, -0.06528398f, 0.05655795f, -0.16061608f, 0.04266554f, 0.32532856f, 0.73150831f, 0.47319925f, 
    0.06282926f, -0.43402955f, 0.15108062f, 0.18954930f, 0.10394768f, -0.02680926f, -0.13954899f, -0.01381327f, 
    0.01288619f, 0.05115848f, 0.13196169f, -0.40828899f, 0.01176588f, 0.01870675f, 0.00741995f, 0.01847266f, 
    0.01044424f, 0.01130331f, -0.00209036f, 0.01418778f, 0.29060268f, 0.03809765f, 0.10085578f, 0.11370199f, 
    0.08903550f, -0.03796206f, 0.13518406f, -0.24992450f, -0.11386238f, 0.24683589f, 0.29205868f, 0.07797121f, 
    -0.02753370f, 0.22553867f, -0.11782149f, -0.77882838f, 0.10890361f, -0.02414723f, -0.01909438f, 0.21579893f, 
    -0.15774526f, 0.17483689f, -0.15390651f, 0.02404621f, 0.05362453f, 1.19818795f, -0.57711691f, -0.01227764f, 
    0.29366559f, 0.11548133f, 0.07910499f, -0.01857472f, -0.33281684f, -0.24770591f, 0.10573789f, -0.06452825f, 
    0.05758722f, 0.36996457f, -0.47264665f, -0.38126364f, -0.02116020f, 0.24806358f, 0.30591345f, -0.13492362f, 
    -0.08270857f, 0.02355347f, 0.10909851f, -0.02507381f, 0.12448894f, -0.05942307f, -0.17750578f, 0.25895905f, 
    -0.00813608f, 0.08829604f, 0.10104772f, -0.01387716f, 0.14237243f, -0.04724132f, -0.16088502f, 0.22690251f, 
    0.05653621f, -0.05917282f, -0.04583653f, 0.09986456f, 0.02229247f, 0.14467253f, 0.12627299f, 0.22872823f, 
    -0.06933910f, 0.09454420f, 0.16819420f, 0.16435595f, 0.11560852f, -0.02902998f, 0.03328266f, 0.25243968f, 
    -0.05851097f, -0.21850148f, 0.01536593f, -0.10002973f, -0.22881895f, 0.06708912f, 0.08988217f, -0.24942477f, 
    0.17585097f, -0.03730128f, 0.03566975f, 0.06989732f, 0.16593230f, -0.01849833f, -0.08230068f, 0.10945505f, 
    0.16855501f, 0.23787938f, -0.29653367f, -0.00307235f, 0.14208807f, -0.04584830f, -0.00346661f, 0.18144004f, 
    -0.09952752f, -0.03739679f, -0.11959967f, -0.15152977f, 0.03160366f, 0.13199976f, -0.00766267f, 0.04251190f, 
    -0.12077866f, -0.17891406f, -0.15264183f, 0.15026626f, 0.10526066f, 0.00592029f, -0.04503779f, -0.04325807f, 
    0.09312162f, -0.01612308f, -0.01208030f, 0.00068248f, -0.08834754f, -0.23781195f, 0.16703880f, 0.19407523f, 
    0.21887450f, 0.08438326f, -0.08175144f, -0.07949878f, -0.00910379f, 0.03664273f, 0.02069992f, 0.02966493f, 
    -0.17024423f, -0.26836246f, 0.00116913f, -0.48161423f, -0.41386402f, -0.25670189f, -0.08736749f, -0.05255004f, 
    -0.10935088f, -0.10659429f, -0.03700568f, -0.07299989f, -0.04734447f, -0.05979513f, -0.13913961f, -0.00851031f, 
    -0.02149267f, 0.05060345f, 0.01696611f, 0.04098962f, 0.17036709f, -0.09783405f, 0.06257538f, -0.14740233f, 
    -0.42685205f, -0.43469724f, 0.21223924f, -0.39414370f, -0.46829513f, 0.02239862f, -0.32085517f, -0.10082290f, 
    -0.22090945f, 0.04843994f, -0.11284191f, 0.04594217f, -0.56612605f, -0.29865888f, 0.13069366f, 0.34914652f, 
    0.03184740f, -0.23403196f, 0.14080189f, 0.01247248f, -0.10498751f, -0.00605670f, 0.02278646f, -0.14094515f, 
    0.25301898f, -0.16433774f, 0.65215969f, -0.04965614f, -0.24714077f, 0.21839043f, -0.04591601f, -0.07477690f, 
    -0.05059856f, -0.26824689f, 0.19722781f, -0.32303604f, -0.69361460f, 0.49688497f, -0.03180042f, -0.04792853f, 
    -0.02072340f, -0.13184687f, -0.26757613f, -0.21879405f, -0.19970807f, 0.04617051f, -0.32466674f, -0.03526045f, 
    -0.03079950f, -0.28836316f, -0.07234934f, 0.12299039f, -0.20513858f, -0.12636988f, 0.02825136f, -0.00401714f, 
    -0.04125730f, 0.06041783f, 0.03774413f, -0.21836615f, -0.14911701f, -0.00957689f, -0.01214046f, 0.36843011f, 
    0.06433161f, -0.26774862f, -0.20927837f, -0.19315095f, -0.01134793f, 0.06204982f, -0.02312738f, 0.13107152f, 
    -0.26719749f, -0.38857678f, 0.02589762f, 0.02723854f, 0.26102421f, 0.10460482f, 0.17291896f, -0.17295429f, 
    -0.03887838f, -0.09269116f, -0.12998897f, 0.07162578f, -0.02829009f, 0.10817877f, -0.21817897f, 0.07189989f, 
    -0.04721247f, 0.01363868f, -0.11617691f, 0.10575976f, -0.11934616f, 0.10818633f, -0.13422707f, 0.03717072f, 
    -0.18606372f, 0.39376086f, -0.25693747f, 0.37747771f, 0.02870942f, 0.11263762f, 0.03803492f, -0.04435566f, 
    -0.01524432f, 0.08081538f, 0.03521224f, 0.09810553f, 0.05613574f, -0.32083711f, -0.14641935f, 0.15125030f, 
    0.05945801f, -0.13436186f, 0.19418767f, 0.10089154f, 0.03193727f, -0.03450282f, -0.11346001f, 0.18188055f, 
    -0.40844467f, -0.13913193f, 0.36378115f, 0.24456505f, -0.14945292f, 0.09529570f, -0.12377414f, -0.00672118f, 
    0.14141878f, 0.13702323f, -0.00299175f, 0.04380042f, 0.80731064f, 0.00471788f, 0.24393360f, 0.45531613f, 
    -0.01104736f, 0.05930325f, -0.04129962f, -0.05298771f, -0.10525720f, 0.08338100f, -0.06159774f, 0.25826699f, 
    -0.11699574f, -0.06496270f, -0.02884671f, -0.46832919f, -0.21758917f, 0.12099873f, 0.06123028f, 0.15255435f, 
    -0.21831857f, -0.03000535f, 0.17167342f, -0.04942332f, -0.00748208f, 0.17808811f, -0.21082109f, -0.54107952f, 
    0.40586144f, 0.12431335f, 0.10600516f, -0.04178738f, -0.16889682f, 0.10672171f, -0.08173200f, -0.07685412f, 
    0.34507054f, 0.16708378f, -0.23843566f, -0.48544571f, 0.02321137f, 0.03965779f, 0.01080153f, 0.07319265f, 
    -0.34971920f, -0.09663314f, -0.08545616f, 0.01878056f, 0.02702332f, -0.25570518f, 0.08178859f, 0.38087070f, 
    -0.09790640f, 0.06765637f, 0.02499816f, 0.12176295f, -0.24946268f, 0.02227999f, -0.06671830f, -0.28724015f, 
    -0.05627130f, -0.23932686f, -0.08269726f, 0.33539256f, 0.01420721f, 0.09107352f, -0.06341386f, 0.14790997f, 
    0.01483399f, -0.12625441f, -0.14611959f, -0.16647206f, 0.15503342f, 0.00588595f, -0.22143114f, -0.16543946f, 
    0.17306307f, -0.04277410f, -0.08293962f, -0.04154239f, 0.04507977f, 0.02708127f, -0.04224342f, 0.10422552f, 
    0.27294260f, -0.05801006f, 0.86937726f, -0.06955028f, -0.40151212f, 0.13460764f, 0.02106074f, -0.07393364f, 
    0.14856061f, 0.03719750f, 0.02659107f, 0.02144329f, 0.50155222f, 0.13109422f, 0.20069481f, 0.19762239f, 
    -0.04620535f, -0.07460409f, 0.03767719f, -0.19676995f, -0.10953956f, -0.01351409f, 0.23826273f, -0.05912394f, 
    0.35515669f, -0.11491283f, -0.17126216f, 0.10204679f, -0.16206090f, -0.01859883f, -0.02444065f, -0.17867386f, 
    0.00795919f, -0.08430459f, -0.28989962f, 0.07269966f, -0.56711346f, -0.64063448f, 0.00014482f, -0.24101837f, 
    0.08744924f, 0.09323113f, -0.06164259f, 0.01227789f, 0.02975489f, -0.06583806f, -0.00355476f, -0.07249142f, 
    -0.02825405f, -0.05924077f, -0.05671022f, 0.00891587f, 0.04494604f, -0.08000905f, -0.02053991f, -0.03961385f, 
    -0.07141125f, 0.21552943f, -0.03508420f, 0.30062306f, 0.00943659f, 0.02834771f, 0.16675442f, 0.26801664f, 
    -0.07375626f, -0.00292194f, 0.00985185f, 0.06343242f, -0.14219132f, -0.00455947f, -0.02026994f, -0.13567068f, 
    0.09701214f, 0.17187665f, 0.45519790f, 0.25604251f, 0.06902590f, -0.00334006f, -0.08709975f, -0.23657648f, 
    0.12167808f, -0.01309683f, 0.22125115f, 0.06651822f, -0.23967583f, 0.03366652f, 0.14700639f, 0.11319951f, 
    -0.03600323f, -0.01306204f, -0.06546551f, 0.08356287f, -0.19099429f, -0.10533745f, -0.01035309f, -0.00223080f, 
    0.22322662f, -0.00779884f, 0.03164428f, -0.02181407f, -0.06099360f, 0.07766347f, -0.07638457f, -0.06533074f, 
    -0.02492845f, -0.12007429f, -0.06122626f, -0.19502299f, 0.03282863f, 0.23595539f, -0.09216473f, 0.24946225f, 
    0.04119296f, -0.10386396f, -0.08723450f, -0.18683764f, -0.26763722f, -0.26306424f, 0.10611193f, -0.03992962f, 
    0.10336893f, 0.17343572f, 0.28161773f, 0.13622515f, -0.20945300f, -0.08753662f, -0.07156420f, 0.12283201f, 
    0.08506152f, 0.03940031f, 0.05158415f, 0.03111032f, 0.18678445f, 0.30318025f, 0.07972693f, 0.10231604f, 
    -0.07496225f, -0.08901925f, 0.08304327f, 0.08685474f, 0.18338397f, -0.01585242f, 0.01800750f, 0.08189427f, 
    -0.12272076f, -0.24308945f, -0.20275380f, -0.17712264f, -0.01747920f, 0.02060180f, -0.19739035f, -0.13095224f, 
    0.00283583f, -0.03807907f, -0.05616264f, -0.31429937f, 0.17936352f, -0.05864881f, 0.05209747f, -0.06121941f, 
    0.03064668f, 0.00367513f, -0.24260938f, -0.07713518f, -0.06550571f, 0.05812892f, -0.10043198f, -0.03387635f, 
    -0.14397116f, -0.04402926f, -0.10928062f, 0.14931536f, 0.03489281f, 0.07211633f, 0.12207227f, 0.05065398f, 
    -0.00630964f, -0.08112971f, 0.04360114f, 0.02897209f, 0.03385641f, 0.28992659f, -0.29668260f, 0.21272972f, 
    0.13866958f, -0.05576189f, -0.17494252f, -0.16338384f, -0.08891059f, 0.06858409f, 0.05608638f, 0.02120472f, 
    -0.12279672f, 0.19148263f, -0.28089386f, 0.26564926f, -0.08573478f, 0.06567851f, -0.36511809f, -0.18378694f, 
    0.00556149f, -0.00158606f, -0.07469545f, -0.03505259f, -0.07142285f, -0.23583594f, 0.06356667f, -0.06091781f, 
    -0.01312600f, -0.15350607f, -0.13828059f, -0.09077414f, 0.06674469f, -0.10151968f, 0.04809563f, -0.05164050f, 
    -0.03091604f, 0.05766427f, 0.05071070f, 0.07573721f, -0.27667394f, 0.07032954f, -0.02133122f, 0.04348407f, 
    -0.04595541f, -0.01027439f, -0.06350016f, 0.06932323f, -0.08947068f, 0.15545417f, 0.02975615f, 0.14918245f, 
    -0.02365640f, -0.14336140f, -0.35023591f, -0.00730752f, -0.19944604f, -0.21267574f, 0.08933830f, -0.11659647f, 
    0.04706157f, 0.22246514f, 0.00837606f, 0.09235124f, -0.08308867f, -0.13356866f, 0.03896576f, 0.13420400f, 
    -0.03422830f, -0.13987055f, -0.08854802f, 0.12407292f, 0.15585080f, -0.11261782f, -0.04941832f, 0.00784238f, 
    0.01806706f, 0.06134598f, -0.05449197f, -0.04643588f, 0.08446985f, 0.05272614f, 0.09853346f, 0.29274109f, 
    0.02516833f, -0.20289153f, 0.46889448f, 0.22327778f, -0.04349967f, 0.17305306f, -0.11984809f, 0.03151586f, 
    -0.12153362f, -0.08823918f, -0.03364490f, 0.06656767f, -0.08657983f, -0.01073839f, 0.08341230f, 0.10831864f, 
    -0.07884686f, -0.05941020f, -0.05712722f, 0.03459415f, -0.04746701f, -0.01428466f, 0.10350855f, -0.00290249f, 
    0.14183603f, 0.16000459f, -0.14065464f, -0.11821112f, 0.11642608f, -0.00765839f, 0.14996324f, -0.11309903f, 
    0.15855241f, 0.03477325f, 0.10181449f, 0.32523403f, -0.21026354f, -0.02907736f, -0.11690117f, -0.06505751f, 
    -0.34296748f, -0.29487318f, 0.05829652f, -0.21542865f, 0.03399154f, -0.14305522f, 0.09910413f, -0.06547466f, 
    -0.04240541f, -0.14481935f, 0.13201536f, -0.08261009f, 0.03199961f, 0.00057387f, 0.00016163f, -0.02558433f, 
    0.10949319f, 0.08872339f, -0.17669912f, -0.07742473f, -0.05801651f, -0.25539663f, -0.07491394f, -0.00796383f, 
    -0.34134391f, -0.05222027f, -0.05120138f, 0.01553542f, -0.27120510f, -0.06240438f, 0.11094911f, -0.05581939f, 
    0.22732383f, -0.09913809f, -0.03615094f, -0.08441456f, 0.02081112f, 0.00353645f, -0.00125698f, -0.02220969f, 
    0.13431789f, -0.18397476f, -0.07013778f, -0.25838229f, -0.13080508f, 0.16974944f, 0.01784490f, 0.05234009f, 
    0.07154539f, 0.07956690f, -0.01903427f, 0.27023479f, -0.02921013f, -0.10464640f, 0.02331822f, -0.09910902f, 
    0.28956559f, 0.30367044f, 0.25781929f, 0.02700043f, 0.09402095f, 0.02533612f, 0.02449813f, 0.35810152f, 
    0.06382801f, -0.01273866f, -0.05229003f, -0.04628131f, -0.27012584f, -0.26178288f, -0.00392992f, 0.15401863f, 
    -0.30797347f, -0.00882870f, -0.13294767f, -0.13496622f, -0.12243722f, 0.03034417f, -0.11265673f, 0.02567702f, 
    0.41223165f, 0.12269498f, -0.12105420f, 0.35483462f, 0.15358390f, 0.00034053f, 0.04170397f, 0.05626585f, 
    0.13333397f, -0.07682869f, 0.00847027f, 0.03103845f, 0.04694810f, -0.24444973f, -0.14522754f, -0.05309506f, 
    0.04370449f, -0.19866759f, -0.03737185f, -0.16197693f, 0.12555948f, -0.06665264f, -0.10259325f, 0.35916862f, 
    -0.01219093f, -0.25344175f, 0.51163554f, 0.15538879f, -0.16047660f, 0.09236233f, -0.10964058f, -0.18126258f, 
    0.24783711f, 0.05405421f, 0.30956811f, -0.06068480f, -0.40089157f, 0.47252065f, -0.48507181f, -0.26605144f, 
    -0.14114478f, -0.06937116f, -0.01361903f, -0.00484749f, -0.04302160f, -0.03520687f, -0.04294981f, 0.08374732f, 
    -0.10996148f, -0.01481811f, 0.03900582f, -0.07102747f, 0.00907478f, -0.02128124f, -0.02564779f, 0.00384859f, 
    -0.04004877f, -0.16879220f, -0.20644110f, -0.21973479f, 0.05821801f, -0.11943266f, 0.35331875f, -0.33471301f, 
    0.12711512f, -0.10012426f, 0.06432572f, -0.02686514f, -0.01205679f, 0.02924614f, 0.10615350f, -0.06611747f, 
    0.19632255f, 0.10384946f, -0.01483809f, -0.01681915f, 0.03225366f, 0.01784357f, -0.03032049f, -0.36896232f, 
    -0.31459588f, -0.13424958f, -0.05668357f, -0.12112417f, 0.15130401f, -0.07650618f, 0.11353844f, -0.18288366f, 
    -0.08510682f, 0.05555889f, 0.06559195f, -0.09690893f, 0.12132212f, 0.02916096f, -0.10570794f, 0.46766537f, 
    0.05889951f, -0.20194404f, -0.10023126f, -0.00900463f, 0.13045189f, -0.25737679f, -0.05716419f, -0.12373082f, 
    0.31137452f, 0.20098059f, 0.09994397f, 0.02147372f, -0.23815034f, -0.05221813f, 0.12178478f, -0.19316061f, 
    -0.15178619f, -0.07008467f, -0.02175993f, 0.19125286f, 0.12598792f, 0.11146177f, -0.17494683f, 0.02892692f, 
    -0.02861976f, 0.02486056f, 0.08783487f, -0.21270837f, 0.34082904f, 0.19323651f, 0.25705481f, -0.12955189f, 
    -0.01322967f, -0.07595567f, 0.00280445f, 0.08098216f, -0.51678592f, -0.16765775f, -0.21372215f, -0.18993253f, 
    0.00084619f, -0.04470025f, -0.07421290f, -0.01091320f, -0.02429988f, -0.20680986f, 0.05700315f, -0.08991495f, 
    0.24088570f, 0.22059700f, -0.02767162f, 0.20830475f, 0.28077701f, 0.00459037f, 0.03405918f, 0.00191221f, 
    0.16173501f, -0.01483008f, 0.03769954f, -0.00471738f, 0.25562987f, -0.06789536f, -0.01996743f, -0.11735043f, 
    0.01305052f, -0.16131525f, -0.01719670f, 0.24991773f, -0.00062972f, -0.05469038f, -0.08179807f, 0.17444363f, 
    -0.36724547f, -0.19333982f, 0.04236232f, -0.01483816f, 0.02738140f, -0.04221231f, -0.03305373f, 0.02507371f, 
    0.12375932f, 0.07856423f, 0.01705392f, -0.08737758f, 0.02056542f, 0.16427884f, -0.38874677f, -0.56570709f, 
    -0.00187764f, 0.19940251f, -0.02419457f, 0.20162703f, 0.05502345f, -0.24999635f, -0.01563130f, -0.16237244f, 
    -0.26154694f, -0.03031892f, -0.18933919f, 0.25481480f, 0.40349990f, -0.29267067f, 0.23427397f, 0.01582009f, 
    0.05062892f, -0.12376845f, -0.02483170f, 0.09152471f, 0.05700990f, 0.14274506f, -0.19397967f, -0.14811496f, 
    0.12610233f, 0.06596034f, 0.27684647f, -0.09703682f, -0.01696868f, 0.10859068f, 0.13334908f, 0.06583104f, 
    0.37295574f, 0.02149963f, -0.06334895f, 0.06593198f, 0.18055393f, 0.23531370f, -0.09931193f, -0.04096362f, 
    0.06250028f, 0.10711408f, -0.02016298f, 0.15779780f, 0.00351433f, -0.03325494f, -0.12912834f, -0.10417046f, 
    -0.15432842f, 0.17098822f, -0.10471059f, -0.15313558f, 0.16210259f, -0.06809907f, 0.32343194f, 0.16622853f, 
    -0.47069475f, -0.39862257f, -0.12716760f, -0.08967730f, 0.00271454f, 0.02280940f, -0.10725383f, 0.00725077f, 
    0.11361562f, 0.03741891f, -0.11319894f, -0.03524436f, -0.11068355f, 0.15603541f, 0.35706756f, 0.01263449f, 
    -0.01485451f, -0.06577943f, -0.02423188f, -0.07639284f, 0.16947250f, -0.35712788f, -0.16645125f, -0.26084289f, 
    -0.00488110f, -0.02460640f, 0.34504741f, -0.02470067f, 0.16715983f, -0.06859547f, 0.19700208f, 0.10976068f, 
    -0.08556294f, -0.01166050f, 0.00878341f, -0.07454055f, -0.02633839f, 0.10793499f, 0.02791126f, -0.15583126f, 
    0.07765064f, -0.05217946f, -0.10084737f, 0.26791167f, -0.06427954f, 0.03485252f, 0.09932570f, -0.05215064f, 
    -0.03292561f, -0.27382386f, -0.52367866f, -0.03673053f, 0.04365885f, 0.10156258f, 0.00514389f, 0.04612734f, 
    0.14798497f, -0.47604236f, -0.25331295f, -0.61407858f, -0.43203869f, -0.08658738f, -0.25191221f, -0.15245149f, 
    0.26751506f, -0.10926587f, 0.16396835f, 0.10673483f, 0.15406248f, 0.07559019f, -0.11736740f, -0.04940852f, 
    0.31214234f, -0.16992687f, 0.01728559f, -0.29653573f, -0.05350036f, 0.06159142f, -0.13674292f, -0.05586648f, 
    -0.03970342f, -0.40884539f, 0.22612117f, -0.20266095f, -0.33881167f, -0.30360955f, 0.34141320f, -0.12709315f, 
    -0.06014911f, -0.13801654f, -0.00957928f, 0.06411753f, -0.07958854f, -0.12316391f, 0.13733496f, 0.17320459f, 
    -0.30545720f, 0.19073641f, -0.10922832f, 0.28331581f, 0.10043304f, -0.14968859f, -0.09338665f, -0.03570241f, 
    0.12797366f, -0.06203894f, 0.20864220f, 0.21051374f, 0.27798274f, 0.21726598f, 0.01184235f, 0.04156472f, 
    0.14591014f, 0.21079762f, -0.24269168f, 0.16991863f, 0.03711272f, 0.02978099f, 0.02765510f, 0.07924742f, 
    -0.06204184f, 0.37002894f, -0.05365909f, -0.34981447f, 0.00070475f, 0.01915849f, -0.03062926f, -0.35898674f, 
    -0.04207403f, -0.05045253f, 0.01970713f, 0.14691487f, -0.48165336f, 0.22042724f, -0.13687377f, -0.16796759f, 
    0.07893082f, 0.03227799f, -0.01786775f, 0.02498753f, -0.01428964f, -0.03489918f, 0.08043732f, 0.07259993f, 
    -0.34491569f, -0.30099231f, -0.11197352f, 0.19893685f, 0.10458968f, -0.03410161f, 0.03895051f, 0.00243908f, 
    -0.12217322f, -0.00860001f, -0.02676096f, -0.04610357f, -0.32060048f, 0.13832657f, -0.23042034f, -0.12947105f, 
    -0.13842189f, 0.09727857f, 0.05389022f, 0.05669774f, 0.20550595f, -0.37108010f, -0.02189476f, -0.25909606f, 
    -0.25369695f, -0.14063872f, 0.27038622f, 0.13621475f, 0.03795806f, 0.00701949f, -0.02556799f, -0.12766600f, 
    -0.04268306f, 0.06103921f, 0.26699597f, -0.19376557f, -0.41587326f, -0.14595832f, 0.18956706f, -0.17814581f, 
    0.06168265f, 0.01530236f, -0.08688810f, 0.01531686f, 0.02715385f, 0.13067603f, 0.06339702f, 0.24140932f, 
    0.03294814f, -0.03773017f, 0.07325973f, -0.08412977f, 0.08578510f, -0.03535395f, 0.01300416f, 0.04364581f, 
    0.36048907f, 0.06343672f, 0.13789354f, 0.07336809f, -0.16508925f, -0.62302595f, -0.29857513f, 0.25659254f, 
    0.03028110f, 0.14338200f, -0.11649034f, -0.25902072f, 0.06786127f, -0.02823378f, 0.00882815f, -0.02171035f, 
    0.02713066f, -0.33024934f, 0.21683808f, -0.78346401f, -0.07082278f, 0.18429211f, -0.13153514f, -0.16060920f, 
    0.05984052f, 0.06160342f, -0.08132214f, -0.02803071f, -0.29848877f, -0.60771793f, -0.56324118f, -0.36336985f, 
    -0.10449845f, -0.16796966f, 0.17159000f, 0.01451724f, 0.01301736f, 0.09558170f, -0.06142723f, 0.05474342f, 
    -0.20034081f, 0.02969727f, 0.08890356f, -0.05955051f, -0.16292378f, -0.28345689f, -0.09765457f, 0.08358333f, 
    -0.23309112f, 0.11019659f, -0.08085692f, 0.03153760f, 0.30097583f, -0.06627566f, 0.08838758f, 0.56370413f, 
    -0.13190730f, -0.27096668f, 0.10688249f, 0.10934751f, -0.06320213f, 0.13272044f, 0.11765797f, -0.13365164f, 
    -0.92412800f, -0.82308400f, -0.35436064f, -0.39170164f, -0.27958032f, -0.08606768f, -0.40022624f, -0.49939558f, 
    0.02054166f, -0.06788667f, -0.01010776f, -0.09768638f, -0.69525081f, 0.43978089f, 0.49462014f, 0.02669784f, 
    -0.07108027f, 0.02310441f, 0.01503671f, -0.07573215f, -0.06062101f, 0.22189839f, -0.07205654f, 0.16400875f, 
    0.24830785f, 0.33328706f, -0.18993862f, -0.40058368f, -0.04468324f, -0.02955183f, -0.00995879f, 0.21562624f, 
    -0.06797814f, 0.01832797f, 0.05845461f, -0.12632233f, -0.22539136f, 0.49472889f, 0.23219135f, -0.09138272f, 
    -0.24661484f, -0.19516543f, -0.00494749f, -0.07963483f, 0.01825430f, 0.00055899f, -0.10365057f, -0.06026973f, 
    0.25927049f, -0.24377967f, -0.36404270f, -0.17129403f, -0.07059219f, 0.03398953f, 0.10605792f, -0.09155748f, 
    -0.03685752f, -0.02217314f, 0.04586213f, -0.15743311f, 0.70074910f, -0.07345450f, 0.22548647f, -0.48992363f, 
    0.13855267f, -0.04894586f, 0.06365291f, -0.09535499f, 0.08898024f, -0.09168120f, 0.24511494f, -0.11295771f, 
    0.03328483f, -0.27911890f, 0.01263186f, 0.23212506f, 0.06893027f, -0.05765612f, 0.20450367f, -0.11605372f, 
    -0.01715332f, -0.06033231f, 0.16434692f, -0.01460127f, -0.09048489f, 0.12515789f, 0.29770571f, -0.11933357f, 
    0.13220353f, -0.06848031f, -0.01670581f, -0.06521904f, 0.04309708f, -0.11738888f, -0.01603641f, -0.13864863f, 
    -0.45037690f, -0.29916134f, -0.41940165f, -0.51663506f, 0.18083851f, -0.11520673f, -0.16926664f, -0.23810345f, 
    0.04076061f, -0.03858347f, -0.02799781f, 0.07538231f, 0.23087338f, 0.24455267f, 0.38263637f, 0.59153759f, 
    -0.05998047f, -0.15671544f, -0.08103748f, 0.08569876f, -0.01087730f, -0.14638868f, -0.09291918f, -0.06070669f, 
    -0.21647334f, 0.26600724f, 0.21390183f, 0.10035665f, 0.01170068f, -0.04944162f, -0.01867669f, 0.16019896f, 
    -0.24591927f, -0.00151597f, 0.04857414f, 0.26520613f, -0.30348140f, -0.27292880f, -0.28522891f, -0.23567563f, 
    -0.12981293f, -0.10065509f, 0.08849204f, 0.05908076f, -0.10655969f, 0.22827967f, 0.09969010f, 0.16854963f, 
    -0.40507621f, -0.90911794f, -0.88184971f, 0.58261138f, 0.07533272f, 0.22595260f, 0.24985091f, -0.19741894f, 
    -0.04009959f, 0.02150652f, 0.07645448f, 0.14627454f, -0.55842018f, -0.28378031f, -0.29160678f, 0.02605581f, 
    -0.35594878f, 0.40960872f, 0.13148952f, -0.20336638f, 0.01815849f, -0.02707996f, 0.00109160f, 0.06393946f, 
    0.28089014f, 0.17505904f, -0.01073854f, -0.13268347f, 0.04637579f, -0.03709317f, 0.13419627f, -0.09771858f, 
    0.06965891f, 0.13250732f, 0.25869966f, 0.17928559f, -0.35670999f, -0.56852555f, -0.18002830f, -0.40085617f, 
    -0.04905578f, 0.05004859f, 0.02246032f, -0.16530403f, -0.08249177f, 0.09853684f, 0.07887748f, 0.14933895f, 
    0.06339829f, 0.10734531f, -0.03918317f, -0.09815565f, -0.04462297f, 0.12540354f, -0.13878410f, 0.04550244f, 
    0.10282345f, 0.04087395f, 0.01032272f, -0.07282745f, -0.15181704f, 0.16741358f, 0.30842236f, 0.05049909f, 
    0.03973123f, -0.05679059f, -0.08106523f, 0.25841182f, -0.05959829f, 0.22485915f, 0.15589650f, 0.20263848f, 
    -0.02232704f, -0.09093241f, 0.17077759f, -0.17901975f, 0.03455465f, 0.07914048f, -0.01541987f, -0.03991706f, 
    0.10383168f, 0.12323201f, 0.27265933f, -0.07874528f, -0.51275408f, -0.60013157f, 0.11512046f, -0.66065300f, 
    -0.35945657f, -0.02448305f, 0.19607213f, -0.14510347f, -0.02454267f, 0.01362084f, -0.06032640f, -0.03771073f, 
    -1.23190498f, -0.62372053f, -0.28546476f, 0.32267269f, 0.15146275f, -0.64506888f, -0.11560009f, -0.33231059f, 
    -0.07647066f, -0.03615317f, -0.08587750f, 0.10516234f, -0.21720453f, -0.32716081f, 0.40583384f, -0.00119310f, 
    -0.24152903f, -0.11170861f, -0.06724091f, 0.02790669f, -0.02524351f, 0.10470346f, 0.19993089f, -0.32996738f, 
    -0.28935930f, -0.08299596f, 0.12620755f, -0.17969158f, 0.02368410f, 0.12107105f, 0.08293848f, -0.07385463f, 
    -0.01948291f, -0.06313650f, 0.01608739f, 0.04842503f, 0.06637061f, 0.00168423f, 0.18544535f, -0.05686150f, 
    -0.02309816f, 0.10036755f, -0.00462473f, 0.08423010f, 0.25284064f, 0.01375394f, -0.04201312f, 0.14395739f, 
    0.48549154f, 0.00484933f, -0.05811264f, -0.63503450f, 0.04470836f, 0.12391700f, -0.06042563f, 0.07112323f, 
    -0.07072563f, 0.16284294f, 0.09989864f, -0.16465683f, 0.01201195f, 0.02645475f, 0.02959847f, 0.06577799f, 
    0.10025378f, -0.07456045f, 0.16933249f, -0.00388578f, 0.02940539f, 0.00125607f, -0.05345909f, -0.20690092f, 
    0.30812517f, 0.06392625f, 0.01035938f, -0.04767584f, 0.00695365f, 0.06003286f, -0.00743906f, 0.02695559f, 
    -0.05939313f, -0.00863798f, 0.10323448f, -0.10617887f, -0.22800285f, -0.38953331f, -0.03209598f, 0.09136622f, 
    -0.10732526f, 0.07147074f, -0.12118095f, -0.18394352f, -0.00469925f, 0.01209316f, 0.06924314f, -0.00449008f, 
    -0.21147187f, -0.29614612f, -0.59324408f, 0.80905986f, 0.14341620f, 0.16317643f, 0.07558654f, -0.06329456f, 
    -0.00169545f, -0.10314633f, 0.13010050f, -0.05166481f, -0.31940782f, -0.14552447f, 0.26427630f, 0.13321412f, 
    -0.01217901f, -0.09554706f, -0.16287553f, -0.09096129f, -0.02677165f, -0.03317467f, -0.20304124f, -0.10223400f, 
    0.16438630f, 0.05336860f, 0.04628503f, -0.03910095f, -0.00021861f, 0.04622209f, 0.11922593f, 0.02931594f, 
    0.03010669f, 0.05668250f, 0.09964123f, 0.07990318f, 0.33875108f, -0.83032691f, -0.37824753f, -0.12628852f, 
    -0.21506910f, 0.12038927f, -0.14463606f, -0.01226000f, 0.10035688f, 0.07255267f, 0.06671993f, -0.00775513f, 
    -0.35824943f, -0.34173131f, -0.22836296f, 0.01950929f, -0.03626037f, -0.11306182f, -0.04316518f, 0.07363270f, 
    0.03401362f, 0.01158778f, 0.04303849f, 0.02103886f, 0.57294679f, -0.23748718f, -0.44657817f, -0.41255635f, 
    0.06077525f, 0.00330537f, -0.04409563f, 0.08885515f, 0.21483083f, 0.10841652f, -0.06869173f, -0.05111676f, 
    -0.16019501f, -0.13034867f, -0.14020410f, 0.15207009f, -0.04712824f, -0.02455464f, 0.03390308f, -0.08708515f, 
    0.08002587f, -0.21722578f, 0.00519181f, -0.04931206f, 0.20417078f, 0.03842923f, -0.08591422f, -0.00779283f, 
    0.07259207f, -0.18801318f, 0.05043641f, -0.06834076f, -0.07483257f, 0.11612875f, 0.03775764f, 0.14340878f, 
    -0.03807222f, -0.05538823f, 0.08889623f, -0.05504235f, 0.00445650f, 0.04509837f, -0.07358224f, -0.00130282f, 
    0.09173776f, -0.00846307f, 0.10332702f, -0.07079372f, -0.38858891f, 0.56424904f, 0.09655803f, 0.21733136f, 
    0.01629165f, -0.02896901f, 0.12680446f, 0.24869040f, -0.07001656f, -0.00235029f, 0.12627985f, -0.08435731f, 
    -0.06360645f, 0.07886422f, 0.21437439f, -0.11348554f, -0.36572409f, 0.04164906f, -0.01731528f, -0.04259264f, 
    0.04785338f, 0.05371169f, 0.13268732f, 0.02381247f, -0.22172743f, -0.02153206f, 0.13941309f, -0.08412353f, 
    -0.14588812f, -0.38778713f, 0.32910430f, -0.12594973f, 0.00764460f, 0.01687908f, -0.08577526f, 0.10596517f, 
    -0.64977825f, -0.25810975f, -0.11447185f, 0.30736801f, 0.19050334f, -0.03765928f, 0.02595327f, -0.26938877f, 
    -0.01299679f, 0.14317465f, 0.02996211f, -0.03063697f, -0.54934561f, 0.45843819f, -0.59977740f, -0.28749222f, 
    -0.18274938f, 0.06897785f, 0.31596264f, -0.02726245f, -0.12060019f, -0.14323880f, 0.00439414f, -0.03989779f, 
    0.28108594f, -0.16768804f, -0.14604066f, -0.19012740f, -0.08156522f, 0.06926556f, -0.00771285f, -0.01377033f, 
    -0.02889345f, 0.04450628f, 0.09421256f, 0.02693173f, 0.05355597f, -0.42325124f, 0.20127030f, -0.24626942f, 
    -0.07615883f, -0.12024160f, -0.05394397f, -0.01944995f, -0.00593110f, 0.16073720f, 0.18082595f, -0.04829388f, 
    -0.08965436f, -0.84727144f, 0.38317430f, -0.27785468f, 0.08869959f, -0.04696370f, -0.05805962f, 0.04336472f, 
    -0.00177055f, -0.02771622f, -0.03433211f, 0.08010752f, -0.28077945f, -0.14684114f, -0.21897271f, -0.15306167f, 
    0.10360117f, -0.09409370f, 0.11250264f, 0.16719200f, -0.01445363f, -0.11292950f, -0.02428169f, 0.02973234f, 
    -0.11420715f, 0.04687959f, -0.02065893f, 0.05913834f, 0.03557145f, 0.01427245f, 0.01837837f, 0.00717085f, 
    -0.01683070f, 0.09794086f, 0.17206405f, 0.08434175f, 0.30632320f, -0.21676981f, -0.41590363f, -0.51948792f, 
    -0.09100550f, 0.31456119f, -0.20154479f, -0.07878985f, 0.02579866f, 0.06588307f, 0.11501320f, 0.22458121f, 
    0.09608920f, -0.09871429f, 0.17568985f, -0.06160352f, 0.03598868f, -0.01560731f, 0.09260938f, -0.05754068f, 
    -0.06860352f, -0.13525380f, 0.18277280f, 0.12422580f, 0.49815288f, -0.09042028f, -0.07299642f, -0.23231146f, 
    0.03818621f, 0.08186990f, -0.14532681f, -0.06834346f, 0.01565000f, -0.00543528f, -0.03892417f, -0.20787787f, 
    0.27613568f, 0.10020714f, -0.07001997f, -0.10239465f, -0.03018402f, 0.01620554f, 0.05673966f, -0.02910276f, 
    -0.07014900f, -0.00278340f, -0.12216773f, -0.50116712f, -0.59575021f, 0.78877842f, -0.03256420f, 0.50267524f, 
    0.26817009f, -0.24052161f, 0.11362799f, 0.05838241f, 0.06670967f, 0.06700912f, -0.12281279f, 0.00973722f, 
    -0.74425983f, -0.12907816f, 0.61835539f, -0.14185947f, 0.03411051f, 0.14385626f, 0.09010785f, 0.18783632f, 
    -0.10288168f, -0.02221335f, 0.06734926f, 0.01953881f, 0.26268357f, -0.82755780f, -0.48573434f, -0.21096443f, 
    -0.12101999f, -0.12756559f, -0.14250530f, 0.21487615f, -0.01437741f, -0.06732926f, -0.11879361f, 0.01050043f, 
    0.05738861f, 0.11803776f, -0.10203031f, -0.09626392f, -0.02335874f, -0.01137426f, 0.04137678f, -0.08273362f, 
    0.04974980f, 0.06067131f, 0.08304661f, 0.01855333f, 0.25688192f, 0.10209289f, -0.02756427f, 0.16704674f, 
    -0.07087884f, -0.02216937f, 0.02197409f, 0.02223653f, -0.04596861f, -0.14395319f, -0.05574385f, -0.01809652f, 
    0.12936912f, -0.18077102f, -0.42789966f, -0.45787072f, -0.00398721f, -0.08275462f, 0.15136793f, -0.10536955f, 
    0.12342985f, 0.12199822f, 0.19386633f, 0.04214768f, -0.19687161f, -0.16867302f, 0.18248969f, -0.11316703f, 
    -0.38120797f, -0.02841538f, -0.02214103f, -0.13232221f, 0.03089237f, 0.11191057f, 0.15426844f, 0.12170691f, 
    -0.19558364f, -0.29173061f, -0.06700870f, -0.36504066f, -0.12595807f, -0.10185803f, 0.01235729f, -0.09114774f, 
    -0.18378150f, -0.06569480f, -0.24552497f, -0.31021887f, -0.14267311f, 0.02585110f, 0.26643443f, -0.09439927f, 
    0.01875120f, 0.15454079f, 0.14853884f, -0.11270969f, -0.14314114f, 0.11038923f, -0.08750387f, -0.00560889f, 
    0.23845047f, -0.14107628f, -0.74395132f, -0.46985140f, -0.00586894f, -0.13233107f, 0.04804160f, 0.09986023f, 
    -0.22516470f, -0.03748997f, -0.17680292f, -0.26578164f, 0.15961632f, -0.35868508f, -0.39542970f, -0.11956900f, 
    0.41006112f, -0.01980325f, 0.12720831f, 0.03470202f, 0.17861126f, -0.02392102f, 0.18402596f, 0.19565377f, 
    -0.00671376f, -0.03386942f, -0.18163395f, -0.05499376f, 0.09598052f, 0.02366824f, 0.03660721f, 0.00911995f, 
    -0.01559157f, 0.07278638f, 0.12174448f, 0.23368362f, 0.07273729f, -0.53553140f, -0.25735837f, 0.34439129f, 
    0.14469026f, 0.13880840f, 0.01850159f, -0.00087714f, 0.08414984f, 0.11587457f, 0.11982967f, -0.08325126f, 
    -0.21839461f, -0.83665496f, -0.62857288f, -0.00523869f, -0.11032468f, -0.13717975f, -0.06182105f, 0.15490623f, 
    -0.14106360f, -0.07806269f, 0.01713645f, -0.01987145f, -0.07673815f, -0.09763956f, -0.20075507f, 0.16693200f, 
    -0.04887603f, 0.05146024f, 0.12546226f, -0.00270485f, -0.06153413f, 0.09414333f, -0.09277561f, -0.34281251f, 
    -0.17509152f, 0.07198279f, 0.09301188f, 0.07731801f, 0.21695441f, -0.00562915f, 0.03103797f, 0.02330745f, 
    -0.22552539f, 0.04963188f, 0.14660907f, 0.19258276f, 0.14003018f, -0.22967969f, -0.16941202f, -0.15367334f, 
    -0.09604392f, 0.10923638f, 0.07143065f, 0.14597042f, 0.00126770f, -0.03452984f, -0.08000672f, -0.05205099f, 
    -0.06051874f, 0.21198042f, 0.10324758f, -0.03202668f, 0.06739508f, -0.11363728f, 0.01434163f, 0.00889499f, 
    -0.05884085f, -0.00091416f, 0.04432646f, 0.07777008f, -1.06950641f, -0.14964455f, 0.28838518f, 0.29699716f, 
    0.13194259f, 0.04197830f, -0.11747888f, 0.28906006f, -0.06090789f, -0.18719906f, -0.08994237f, 0.00987268f, 
    -0.01325724f, 0.08423521f, 0.03026536f, 0.00411187f, 0.34842554f, 0.09252609f, -0.10965658f, 0.22975232f, 
    -0.15966271f, 0.13829669f, 0.05898412f, 0.06857517f, 0.06747047f, -0.01076370f, 0.18690416f, 0.13705927f, 
    -0.03830184f, 0.09944311f, -0.08551361f, 0.26184282f, -0.02093650f, 0.09751770f, -0.13874182f, 0.01104662f, 
    0.14137822f, -0.11569947f, -0.04607968f, 0.06901841f, 0.34120134f, -0.10529342f, 0.02021871f, -0.14560635f, 
    0.05371574f, -0.01802957f, 0.14986086f, 0.01894531f, -0.25024155f, -0.33787268f, 0.22104463f, 0.49875417f, 
    -0.23748276f, 0.13630171f, 0.28985766f, 0.00917181f, 0.02104460f, 0.06885176f, 0.16762431f, 0.25621638f, 
    -0.08202220f, -0.16329266f, -0.00289803f, 0.11251017f, -0.11474171f, 0.06534608f, 0.09985584f, 0.06810340f, 
    0.10688460f, 0.00862643f, -0.04821180f, 0.02085243f, 0.11487124f, -0.10958334f, -0.07334924f, -0.50787634f, 
    0.15695994f, -0.00154153f, 0.05520536f, -0.01557326f, 0.06186929f, 0.04963654f, -0.35603479f, -0.54428190f, 
    0.83222193f, 0.39798069f, 0.03414708f, -0.09899590f, 0.04850426f, -0.05878042f, -0.00819138f, -0.32831234f, 
    -0.01302557f, 0.03725826f, -0.02126025f, -0.03177520f, -0.02662356f, -0.15031974f, -0.16075113f, 0.04853901f, 
    0.23048618f, 0.07714211f, -0.02292608f, 0.04942988f, -0.11059615f, -0.11786849f, -0.20694666f, -0.12525058f, 
    -0.76295358f, -0.03198057f, 0.13180998f, 0.05251433f, 0.01347395f, 0.09240583f, -0.08076061f, -0.03113637f, 
    -0.43708879f, 0.10968447f, -0.30068251f, -0.36191005f, -0.59033102f, -0.67062783f, -0.51016963f, 0.29205140f, 
    0.19839624f, 0.21543986f, 0.15950780f, 0.26711407f, -0.01488762f, 0.11515346f, 0.00357505f, -0.01036233f, 
    -0.18401700f, 0.05424460f, 0.02660367f, 0.07430498f, 0.00436805f, -0.10217345f, 0.09864179f, -0.13870358f, 
    0.18828499f, 0.23526493f, -0.06022822f, 0.14613698f, 0.12238546f, -0.00089630f, -0.51643294f, -0.13820386f, 
    0.00677012f, -0.09670053f, 0.16627797f, -0.00922021f, 0.16806163f, 0.13652295f, 0.03493997f, 0.04367251f, 
    -0.03560334f, 0.09207641f, 0.08770303f, -0.36026850f, -0.12246794f, 0.03903325f, 0.03222100f, 0.02626695f, 
    -0.02672711f, 0.22826059f, 0.00386545f, 0.19742398f, -0.78002656f, -0.13287733f, 0.21831061f, 0.18939623f, 
    -0.25597128f, -0.21181561f, -0.05158988f, -0.04540442f, 0.00596925f, 0.10332596f, 0.02392103f, 0.13036756f, 
    -0.14761421f, -0.70908839f, -0.32592589f, -0.02679862f, -0.05269339f, -0.12900785f, 0.22708046f, -0.06631697f, 
    0.09472666f, 0.14039093f, -0.04601410f, 0.08517077f, 0.48325193f, -0.22315238f, -0.52313250f, -0.17222644f, 
    -0.00766591f, 0.23788185f, 0.21403258f, 0.06675331f, -0.06713387f, -0.07523221f, 0.02706457f, -0.03208147f, 
    -0.47028685f, 0.18090662f, 0.19249573f, 0.12113307f, 0.05104705f, -0.09037016f, -0.04320115f, -0.02823884f, 
    -0.06194724f, -0.06436507f, -0.04396814f, -0.03399499f, -0.10366552f, -0.18209580f, -0.02638312f, 0.21178238f, 
    0.07992255f, 0.06650390f, -0.02589191f, 0.15986072f, -0.16467911f, 0.12714462f, -0.23465846f, -0.15337616f, 
    -0.11210940f, 0.12442191f, 0.13904014f, 0.50645196f, 0.03029456f, 0.06200067f, -0.23778488f, 0.02256119f, 
    -0.02662087f, -0.15499364f, -0.06271596f, -0.04166577f, -0.01573219f, 0.05740675f, 0.28226340f, -0.04643227f, 
    0.03746618f, -0.02629259f, 0.03919700f, 0.05355516f, -0.10520282f, 0.05839503f, 0.05769736f, 0.05563593f, 
    -0.05626620f, -0.11841676f, 0.22977084f, 0.18866773f, -0.03632438f, 0.14276011f, -0.24507871f, -0.07155650f, 
    0.01359076f, 0.09930709f, 0.26145655f, -0.02061590f, 0.42121825f, 0.13476461f, -0.17582215f, -0.26378086f, 
    -0.01581913f, 0.14475726f, 0.01751836f, 0.04059235f, -0.10402714f, 0.14201678f, -0.19385846f, -0.15551744f, 
    -0.00213775f, 0.25886488f, 0.06560509f, 0.05071774f, -0.01659302f, -0.18464893f, 0.00025941f, -0.02130290f, 
    0.13541302f, 0.07206743f, -0.03966564f, -0.07966283f, 0.30255821f, -0.15998611f, 0.02010699f, 0.21442257f, 
    -0.16358070f, -0.03475412f, 0.11514423f, 0.00836170f, 0.06383546f, 0.12269660f, 0.07131494f, 0.04586192f, 
    0.28241527f, 0.27736360f, -0.12922995f, 0.15473896f, 0.01146523f, 0.01400461f, -0.19697183f, 0.07888145f, 
    0.16959625f, -0.22546548f, -0.09430146f, 0.07313830f, 0.03991640f, 0.00362513f, 0.35454303f, -0.55085146f, 
    -0.26360217f, -0.30347508f, -0.11433361f, 0.02984413f, -0.18894845f, -0.09364866f, 0.07240915f, 0.06534641f, 
    -0.32818380f, 0.22540103f, 0.46173292f, -0.41827920f, -0.28937313f, -0.13342845f, 0.28448644f, 0.28306645f, 
    -0.02375510f, -0.03238588f, 0.03716207f, -0.04465981f, -0.08020844f, -0.02047642f, 0.29043382f, 0.25716284f, 
    0.07773447f, -0.04210744f, -0.24915974f, -0.11546135f, -0.05438904f, 0.05319932f, -0.09767795f, 0.16922353f, 
    -0.16484630f, 0.31703204f, -0.08202046f, 0.04088606f, 0.15630044f, -0.35446373f, 0.09096514f, -0.27692220f, 
    0.23471820f, -0.05427068f, 0.05248444f, -0.02041291f, -0.01110621f, -0.10291025f, 0.31409973f, -0.02951956f, 
    0.37972063f, -0.08363408f, -0.02551148f, -0.04205145f, 0.08738907f, -0.10941256f, -0.02597411f, 0.03448398f, 
    -0.03897898f, -0.23942171f, -0.94191098f, 0.13468948f, 0.02593876f, 0.21326900f, 0.23240380f, -0.00050013f, 
    0.08551922f, -0.12126479f, 0.01428389f, -0.03136108f, -0.21244268f, 0.10609405f, -0.00704004f, -0.39793259f, 
    -0.14853464f, -0.00829839f, 0.14963935f, 0.10010417f, -0.00240000f, 0.12553179f, 0.01215968f, 0.22390255f, 
    0.11741014f, -0.05914839f, -0.24649324f, -0.43133333f, -0.25155833f, 0.11951802f, -0.16621801f, -0.03448167f, 
    0.12511583f, -0.23037642f, -0.14693415f, -0.00053809f, 0.23287158f, -0.31257147f, 0.03875601f, -0.52552074f, 
    0.07903124f, 0.15733011f, -0.26361778f, 0.19978358f, 0.15310532f, -0.10889532f, 0.02083907f, -0.16376369f, 
    -0.40453327f, 0.08473594f, -0.78076780f, 0.12564138f, -0.14876689f, -0.40033010f, -0.00779529f, 0.02899008f, 
    -0.00395550f, 0.03237941f, -0.00442774f, -0.12948479f, -0.22138096f, 0.15969802f, -0.02475306f, -1.13691890f, 
    0.08416824f, -0.34352317f, 0.22518992f, 0.08259275f, -0.20351140f, -0.05290328f, 0.12455900f, 0.11856043f, 
    0.46349218f, 0.10562847f, 0.21953705f, 0.16690375f, -0.03006028f, -0.07644143f, -0.21245775f, -0.29521319f, 
    -0.07942871f, -0.04387310f, 0.07535310f, 0.05533470f, 0.09637854f, -0.07381798f, -0.10914473f, 0.09190914f, 
    0.09710961f, 0.11619548f, 0.08356929f, -0.00138712f, -0.04200670f, 0.16875261f, 0.16818665f, 0.08599925f, 
    -0.15663047f, -1.03646612f, 0.07602832f, -0.14264822f, -0.01822104f, 0.01968650f, -0.02541552f, 0.31809959f, 
    -0.04168359f, 0.12553763f, 0.07813557f, 0.01327487f, -0.09648327f, -0.03306116f, 0.17350513f, -0.48717144f, 
    -0.00983558f, -0.19208491f, -0.07541922f, 0.07838874f, 0.11197476f, -0.00315251f, 0.06729057f, 0.13069782f, 
    0.00297577f, 0.04244829f, 0.09724332f, -0.25091785f, -0.02891958f, 0.04757377f, 0.24628307f, 0.12703130f, 
    0.01574858f, 0.13972680f, 0.18706731f, 0.03952369f, -0.40720776f, 0.51719946f, -1.03289151f, 0.25045240f, 
    -0.41318598f, 0.04335800f, -0.14114635f, -0.04273637f, 0.19496787f, -0.09969142f, 0.03491787f, -0.07117921f, 
    0.24474664f, -0.23849836f, -0.26260254f, -0.07155197f, 0.09233434f, -0.01875592f, 0.09613994f, -0.00293829f, 
    0.29462752f, -0.15309078f, 0.09113146f, -0.10913359f, 0.14660615f, -0.02564355f, 0.40620309f, 0.45333743f, 
    0.08497275f, -0.10576364f, -0.02232748f, -0.19754860f, 0.33026519f, -0.22624518f, -0.05426780f, 0.06285708f, 
    -0.51025504f, 0.37498966f, 0.04193581f, 0.43423516f, 0.07902105f, 0.08085056f, -0.06526111f, -0.14585637f, 
    -0.07033993f, -0.02862895f, -0.06196831f, -0.06768569f, -0.41792735f, 0.44569027f, -0.56958669f, -0.26115781f, 
    0.17653398f, -0.21916778f, 0.01304796f, -0.03160891f, -0.07394812f, 0.12931816f, -0.04734226f, -0.00324507f, 
    -0.33727816f, -0.11591834f, -0.04110798f, -0.17255765f, -0.24976973f, -0.09446091f, 0.06829192f, 0.14804806f, 
    0.02688379f, 0.03373256f, 0.06032250f, -0.07656182f, -0.26342461f, 0.17165186f, 0.05987467f, 0.28561693f, 
    0.03150603f, -0.07874078f, -0.31344843f, 0.12392713f, 0.09692354f, -0.10243168f, 0.10094877f, 0.05464830f, 
    -0.17735514f, -0.17548679f, -0.51177073f, 0.12683055f, 0.09899779f, 0.09841980f, 0.33154118f, 0.09214927f, 
    0.00332983f, -0.11012842f, -0.10191695f, 0.04694140f, -0.32362226f, 0.24552469f, -0.14705570f, -0.13420478f, 
    -0.09047567f, -0.09380278f, -0.11949610f, -0.09212727f, 0.02392034f, -0.00353034f, 0.05839688f, 0.31111982f, 
    -0.24886465f, 0.72845185f, 0.10071628f, 0.20529068f, -0.05756931f, -0.02724927f, 0.03581915f, 0.00827752f, 
    -0.05888198f, -0.04764834f, 0.16535905f, 0.12144836f, -0.11546894f, 0.18155468f, 0.10312124f, 0.13001390f, 
    -0.14107695f, -0.00481031f, -0.06456219f, 0.16008972f, 0.12766318f, -0.05454233f, -0.15687147f, 0.26005340f, 
    -0.09787029f, 0.12617213f, 0.20318682f, -0.23798661f, -0.06406736f, -0.02136513f, -0.02843138f, 0.06384547f, 
    0.03318584f, -0.12742846f, -0.31885672f, -0.12457182f, -0.35334504f, -0.04847775f, 0.38619587f, 0.08285622f, 
    0.11038332f, 0.11627345f, 0.05324574f, 0.05751359f, -0.05264506f, -0.02024739f, 0.16813870f, 0.00503096f, 
    -0.35690087f, -0.22124065f, -0.14014715f, 0.20170906f, -0.07319160f, -0.04102194f, -0.02970829f, -0.04191084f, 
    -0.01658298f, -0.00977350f, -0.01093843f, -0.19712269f, -0.11555279f, 0.04007065f, -0.53573662f, -0.09251656f, 
    -0.27965945f, 0.21764192f, 0.10090607f, -0.18993528f, 0.10018370f, 0.09903163f, -0.00489086f, 0.02011215f, 
    -0.20211804f, 0.38790676f, 0.07748370f, 0.02020259f, -0.00270185f, 0.02439639f, -0.03590664f, -0.11132227f, 
    -0.01017291f, 0.17291553f, 0.20164922f, 0.21037133f, -0.17691182f, 0.10039733f, 0.01923561f, -0.09817591f, 
    0.05882936f, 0.00125196f, 0.09765495f, -0.02282309f, -0.15803780f, -0.16908643f, 0.00491836f, 0.03282417f, 
    -0.27634928f, -0.40739006f, -0.31213173f, 0.14021674f, -0.02575549f, -0.34596100f, 0.09126483f, 0.00514215f, 
    -0.08768094f, 0.10989168f, 0.11389908f, 0.04150420f, 0.20961750f, -0.29996055f, 0.14616185f, -0.35958987f, 
    0.09025668f, 0.05318585f, -0.13665392f, 0.03909566f, -0.16389537f, -0.08170586f, -0.41201425f, -0.34435421f, 
    -0.10453766f, 0.17049704f, -0.07110139f, 0.05898323f, -0.01404914f, 0.13431360f, 0.13314070f, 0.16854808f, 
    -0.21815272f, 0.06683005f, -0.13011310f, 0.04012443f, -0.23747770f, -0.09284164f, 0.27608737f, 0.46137112f, 
    -0.13127343f, 0.13273035f, -0.02168933f, -0.03338679f, -0.05859320f, 0.07768168f, 0.21574159f, 0.20789269f, 
    -0.07231849f, -0.14221129f, -0.67576510f, -0.45856062f, -0.40246543f, -0.22850674f, 0.19416106f, -0.12684235f, 
    -0.27813873f, 0.16025883f, 0.04104639f, 0.18760198f, 0.18574715f, 0.01504660f, -0.09963268f, 0.45556095f, 
    0.13375130f, 0.18179770f, -0.06089368f, 0.05069967f, -0.14548892f, -0.19487247f, -0.12982321f, -0.10707966f, 
    0.22209463f, -0.12691619f, 0.25076684f, 0.11625652f, -0.06162915f, -0.24628152f, 0.19217530f, -0.14511433f, 
    -0.28631303f, 0.26183221f, -0.41519946f, -0.00057582f, -0.30479190f, 0.11854007f, 0.09054366f, 0.32873863f, 
    -0.08578506f, -0.24646659f, -0.11474990f, 0.25991109f, -0.36090916f, 0.00895082f, 0.07074761f, 0.17828108f, 
    -0.12371681f, 0.51615810f, -0.05956598f, 0.06452402f, -0.08526697f, -0.01919807f, -0.37112319f, 0.29884872f, 
    -0.04136641f, 0.19822915f, -0.04810464f, 0.12038106f, 0.17365356f, -0.39493468f, 0.50219351f, 0.42276514f, 
    -0.08728874f, 0.13421154f, 0.03825463f, 0.11138301f, 0.19178709f, 0.16215393f, 0.25456211f, -0.08651534f, 
    -0.30208835f, 0.29092115f, -0.06498882f, 0.16267887f, 0.21668918f, -0.04439398f, -0.05649755f, 0.07513744f, 
    -0.11634032f, 0.19646920f, 0.06446788f, -0.20206945f, -0.06889808f, 0.09691945f, -0.24323550f, -0.19831711f, 
    -0.06684032f, 0.14535378f, 0.16923378f, 0.07135890f, -0.17994913f, -0.15230775f, -0.24789076f, -0.43278149f, 
    -0.56232905f, 0.18089107f, -0.51192462f, 0.24382457f, -0.13284291f, 0.19560647f, -0.27100250f, -0.12495642f, 
    -0.02779797f, -0.09370121f, -0.12069102f, -0.13466229f, -0.15300393f, -0.07335203f, 0.02783999f, 0.05673946f, 
    0.04380031f, -0.05542113f, -0.22604875f, -0.11799717f, -0.23158312f, 0.05722979f, -0.10231957f, -0.08473290f, 
    0.08029733f, 0.13631377f, -0.29719684f, 0.22338338f, 0.12846683f, -0.20823753f, 0.01482952f, 0.15576518f, 
    -0.24199896f, -0.30038881f, -0.32768938f, -0.45735466f, 0.68186784f, 0.14980362f, 0.13884635f, -0.33609679f, 
    0.02723337f, -0.15698704f, 0.04938124f, 0.13416100f, -0.24116790f, 0.12819408f, -0.25050092f, -0.27980256f, 
    -0.19804886f, 0.45282546f, -0.25422159f, 0.28162932f, -0.10835124f, -0.05011276f, 0.10069666f, -0.21838863f, 
    -0.21574266f, 0.15636908f, 0.07121690f, 0.07415035f, -0.52094340f, 0.06781721f, -0.12954870f, -0.03747358f, 
    -0.04187816f, 0.10562745f, 0.01152310f, -0.11538933f, -0.32252252f, 0.00580980f, 0.06853840f, -0.33749184f, 
    0.42760459f, -0.44437575f, 0.33224511f, -0.36297169f, -0.08135733f, -0.17593911f, 0.10324188f, 0.06862162f, 
    0.09261279f, 0.04855399f, -0.02382880f, 0.00265883f, -0.13067289f, -0.40280265f, -0.17901573f, 0.34584701f, 
    -0.17600007f, 0.31658587f, 0.43760961f, 0.02633036f, 0.03752895f, 0.07211118f, 0.07738804f, 0.20517801f, 
    -0.18221071f, -0.32171401f, -0.00347559f, 0.22499876f, -0.09713725f, 0.11534188f, -0.12619253f, 0.05199872f, 
    0.17579174f, 0.12392741f, 0.10769377f, -0.00451429f, -0.15500979f, -0.06855977f, 0.05030333f, 0.14386196f, 
    -0.04688693f, 0.13918208f, -0.31232637f, -0.02193811f, -0.22943957f, 0.15685244f, 0.02435368f, -0.30562609f, 
    0.09674153f, -0.09820925f, -0.25597644f, -0.02505139f, -0.47751674f, -0.14980242f, 0.05068257f, -0.15736671f, 
    -0.09635743f, 0.09194653f, -0.16654003f, -0.12374534f, 0.50681102f, -0.26831323f, 0.22002068f, 0.05131602f, 
    0.10859989f, -0.06390640f, 0.05298002f, 0.14478208f, -0.20655936f, -0.24344312f, -0.38682067f, -0.14421231f, 
    -0.45394683f, -0.27898669f, -0.19833043f, 0.46575120f, 0.28821427f, -0.21568812f, -0.03882002f, -0.07357941f, 
    0.02247562f, -0.07288276f, -0.02969124f, -0.05712916f, -0.71881270f, 0.38635656f, -0.53851503f, 0.21108782f, 
    0.02562370f, 0.12319920f, -0.11961117f, 0.05665338f, -0.31042796f, -0.06072449f, 0.11795832f, 0.02718177f, 
    -0.42725807f, 0.22033146f, -0.52882409f, 0.11582784f, -0.09712702f, -0.03733383f, 0.02991042f, 0.00597701f, 
    0.24741243f, 0.10885589f, 0.19117218f, 0.09234272f, -0.15044539f, 0.45561063f, -0.05634406f, 0.37459150f, 
    -0.06103206f, 0.06267179f, -0.05008647f, -0.02126627f, -0.00546433f, -0.04868420f, 0.01235414f, -0.07678865f, 
    -0.15096384f, -0.70759457f, -0.06602198f, 0.25246578f, -0.00414293f, 0.10198312f, -0.26257908f, -0.11973964f, 
    -0.06047051f, 0.07767718f, 0.14183193f, 0.01097262f, 0.13875265f, -0.64477038f, -0.26020995f, 0.00733626f, 
    0.12880911f, -0.28712219f, -0.34206903f, 0.11802841f, -0.06825691f, 0.16116546f, 0.04786858f, -0.12654576f, 
    -0.06609114f, -0.18068345f, -0.06457657f, -0.05074999f, 0.07798688f, -0.02772218f, 0.06495515f, -0.08381461f, 
    0.10892583f, -0.11456091f, -0.25359803f, -0.34043530f, -0.43548998f, 0.35265812f, -0.23192033f, -0.07398904f, 
    0.18440287f, -0.17733383f, 0.20530470f, -0.20563205f, -0.07592872f, 0.10988935f, -0.06168905f, 0.03090916f, 
    0.06360309f, -0.51100594f, -0.24904594f, -0.34807903f, -0.01660356f, -0.18545970f, -0.01363675f, -0.21771294f, 
    0.04811499f, -0.05772802f, -0.17112274f, -0.16271834f, -0.06654290f, -0.33503151f, -0.72085768f, -0.36394969f, 
    0.03271773f, -0.04067006f, -0.06497177f, -0.21031314f, -0.07291079f, 0.04899643f, 0.08417851f, -0.04543359f, 
    0.38652521f, -0.39148489f, 0.47206023f, -0.11705066f, -0.01803938f, 0.33357018f, -0.10063870f, 0.06334561f, 
    -0.11557694f, -0.04718051f, 0.34040827f, 0.04384611f, -0.15474869f, -0.12848917f, -0.03205047f, 0.45670015f, 
    -0.03565403f, 0.00156863f, -0.04909111f, -0.07841567f, -0.00758869f, -0.10698499f, 0.00239786f, -0.32393354f, 
    0.63251370f, 0.41622588f, 0.28547353f, 0.02660124f, -0.09445705f, 0.12000376f, -0.12910943f, 0.04468184f, 
    -0.25383154f, -0.03777622f, -0.11840580f, -0.12015447f, -0.22006278f, -0.12296388f, 0.12026999f, 0.10196318f, 
    -0.02719823f, 0.10327166f, 0.18058030f, 0.06041163f, -0.16083698f, 0.09638015f, 0.12270037f, 0.12044024f, 
    0.13197243f, 0.07393114f, 0.22521231f, 0.62649435f, -0.01682448f, -0.06668671f, 0.20621002f, -0.13595919f, 
    0.11812650f, -0.18537314f, 0.19760570f, 0.21947490f, -0.73601454f, 0.06439271f, -0.01804495f, 0.38864335f, 
    -0.15994373f, 0.26283321f, 0.11050451f, 0.11012895f, -0.28337842f, -0.06189841f, 0.13845921f, -0.10815571f, 
    0.32807663f, -0.27203959f, 0.76924062f, 0.04684054f, 0.06166984f, -0.22711392f, -0.11324462f, 0.22311893f, 
    -0.00052241f, -0.10496315f, -0.04538022f, -0.06978413f, -0.08579984f, -0.12914330f, 0.57953924f, -0.29680014f, 
    0.02485374f, 0.07250235f, 0.00324803f, 0.14661846f, -0.04999772f, 0.15495829f, -0.18013111f, 0.01465817f, 
    -0.43110463f, 0.25299376f, -0.26644117f, 0.13090746f, 0.05429592f, -0.09884884f, -0.02508894f, -0.05247443f, 
    -0.01198355f, -0.04943482f, -0.29272977f, -0.01378065f, -0.62014794f, -0.23838706f, -0.09315403f, 0.03850503f, 
    0.10047755f, 0.07717917f, -0.05952331f, -0.00331424f, 0.12585762f, 0.11481065f, 0.05638400f, 0.05899625f, 
    -0.35470068f, -0.21802163f, -0.14402379f, -0.02497680f, -0.17283441f, -0.28327638f, 0.23679164f, -0.09976026f, 
    0.08995056f, 0.13029802f, 0.13009876f, 0.08125067f, 0.00899145f, -0.01556132f, -0.25926122f, -0.25013354f, 
    -0.29092926f, -0.21753792f, 0.05860183f, -0.24751437f, 0.16479734f, 0.07592376f, -0.11424325f, -0.03433912f, 
    -0.06196234f, -0.07486804f, 0.15980518f, 0.17328325f, -0.06995021f, 0.08349874f, -0.09533568f, 0.07436531f, 
    -0.04778607f, 0.17099981f, 0.22109365f, 0.11913653f, -0.09149484f, -0.24483062f, 0.41830516f, -0.92005533f, 
    -0.21139844f, -0.05353064f, 0.26291859f, -0.24702999f, 0.00856095f, -0.09655168f, -0.04689437f, 0.01380065f, 
    -0.14199524f, -0.31202200f, 0.07479963f, 0.38463995f, -0.01625585f, -0.11762148f, -0.05710281f, 0.03714871f, 
    -0.18636058f, -0.12248409f, 0.10910779f, 0.06631588f, -0.39696848f, 0.16152686f, -0.57829267f, -0.04237747f, 
    0.11921493f, 0.06666125f, 0.15052420f, 0.02529112f, -0.06831115f, 0.03640608f, 0.15135916f, 0.02643818f, 
    -0.41127095f, 0.03566326f, -0.28473988f, -0.17591201f, -0.04169938f, 0.17164974f, -0.11861153f, 0.00317835f, 
    -0.11981075f, 0.07003553f, 0.10114282f, -0.05290916f, 0.37456769f, -0.04449337f, 0.03713411f, -0.02748934f, 
    -0.20338015f, -0.21782553f, -0.17452748f, -0.01448302f, 0.01837115f, -0.03743191f, 0.03962470f, -0.35614106f, 
    -0.48938900f, -0.56974703f, 0.44820178f, -0.13108104f, -0.22447909f, 0.12014114f, -0.51447761f, -0.02251077f, 
    0.04126414f, -0.05700240f, -0.07400262f, 0.00484101f, -0.16351911f, 0.10753018f, 0.14620067f, 0.11498082f, 
    0.17237420f, 0.26430655f, 0.02176644f, -0.02284264f, 0.12603158f, 0.06432120f, 0.21101438f, 0.20413983f, 
    0.61017388f, -0.00797816f, 0.22234839f, -0.28177768f, -0.07013254f, 0.07527633f, -0.01134252f, 0.07179046f, 
    -0.06411032f, 0.10825472f, 0.01303863f, -0.02300546f, -0.10064278f, -0.08612774f, 0.00685532f, -0.05482201f, 
    -0.03111454f, 0.22560540f, 0.07509474f, 0.10685462f, -0.01614013f, 0.19240567f, 0.06551722f, 0.02383151f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.26377746f, 0.10769533f, 0.11047461f, -0.19133709f, -0.08836312f, 0.14371434f, -0.02123039f, -0.18983492f, 
    0.09508944f, 0.03116987f, 0.05193833f, -0.00659379f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
