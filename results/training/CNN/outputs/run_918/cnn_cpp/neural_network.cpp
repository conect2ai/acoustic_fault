#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.20362639f, 0.74072570f, -0.69427842f, -0.71886778f, -0.84701997f, 0.36351642f, -0.32310191f, -0.14209925f, 
    -0.52693558f, -0.38036245f, 0.18214270f, 0.34103444f, -0.35193446f, 0.02555844f, -0.14713527f, -0.01016599f, 
    -0.22779500f, -0.37242872f, -0.09523948f, -0.19898662f, -0.08591215f, -0.06326984f, 0.34145752f, 0.03920847f, 
    0.13838811f, -0.42441565f, 0.86642683f, 0.56160325f, -0.57207304f, 0.60079145f, -0.27153119f, 0.29157296f, 
    0.98909914f, 0.42803663f, 0.75133723f, -0.52463406f, 0.11806393f, -0.54348385f, -0.66689914f, -0.29621419f, 
    0.15596704f, 0.08091689f, -0.31758577f, 0.10188929f, 0.21344849f, -0.39969254f, -0.06392988f, 0.09503740f, 
    -0.08533985f, -0.05348194f, -1.37174392f, 0.68371177f, -0.31952450f, -0.66790271f, -0.22145788f, 0.05190582f, 
    -0.04464657f, -0.32480887f, 0.53651923f, -0.18240802f, -0.04497502f, -0.32203531f, 0.16943586f, -0.04697110f, 
    -0.47541201f, 0.19573164f, -0.05147465f, 0.26982340f, -0.48655343f, -0.59599066f, -0.09063464f, 0.00998461f, 
    0.03753802f, 0.29643562f, 0.37630510f, -0.08752907f, -1.13088679f, -0.49999428f, 0.63885170f, 0.70879871f, 
    -0.45049763f, 0.67647809f, 0.61104834f, -0.09556974f, -0.09464115f, 0.67321694f, 0.29713821f, -0.45603806f, 
    0.19031224f, 0.03987167f, -0.20598854f, -0.36325493f, -0.19146566f, 0.09947714f, -0.37474948f, -0.28606284f, 
    -0.01765831f, -0.03626386f, 0.28543928f, -0.35291204f, 0.18191187f, -0.65753031f, -0.13045923f, 0.96613908f, 
    0.72788334f, -1.13116646f, -0.57397938f, -0.09768789f, -0.84036708f, 0.24229906f, -0.01421155f, 0.19266291f, 
    -0.31819817f, 0.01309639f, 0.17119080f, -0.24476349f, 0.21601093f, 0.34751609f, 0.00903487f, 0.31878516f, 
    0.35416004f, -0.11751880f, -0.28457701f, -0.21866447f, -0.04449019f, 0.41205952f, -0.24289010f, 0.56930304f, 
    0.74288636f, 0.87313187f, 0.70600349f, 0.27267098f, 0.47973296f, 0.05378279f, -0.36512661f, -0.28126732f, 
    -0.10700222f, -0.59841347f, 0.30092984f, -0.07745784f, 0.23962276f, -0.02928872f, 0.05567643f, 0.39149842f, 
    0.25398004f, -0.25839368f, 0.33045122f, 0.40341741f, -0.12195828f, 0.16748971f, -1.10927582f, -0.45505816f, 
    -0.03444064f, 0.87882262f, -0.90628302f, 0.33956259f, 0.90217310f, -0.53859007f, 0.27420250f, 0.29639351f, 
    0.27589253f, -0.54955530f, -0.46013314f, -0.20890421f, -0.05613472f, 0.12077588f, 0.25307962f, -0.02946787f, 
    -0.08470429f, -0.33145231f, -0.11841264f, 0.00140117f, 0.12375686f, -0.00822281f, -0.10249139f, 0.83770877f, 
    0.09382478f, 0.24200876f, 1.10215640f, 0.60406744f, 0.22559492f, 0.27570021f, 0.09774189f, -0.17588632f, 
    0.58023930f, -0.23671615f, -0.15780278f, 0.04559500f, -0.48122481f, 0.02279989f, -0.49410993f, -0.39215371f, 
    -0.15176384f, -0.13453022f, -0.43633720f, 0.57415664f, 0.27754042f, 0.00226562f, 0.26127818f, 0.10826833f, 
    0.65900105f, -1.40118957f, 0.68023157f, 1.02364933f, 0.07453082f, 0.10536143f, 0.85143417f, 0.37804917f, 
    0.52614993f, 0.43785328f, -0.38530484f, 0.25659460f, -0.40045995f, 0.33660430f, -0.11166961f, -0.29054427f, 
    -0.34052566f, -0.24423748f, 0.10274563f, -0.15810575f, 0.09832772f, 0.05649490f, -0.21346903f, -0.15165387f, 
    -0.15961197f, 1.25318182f, 0.65449661f, -0.93915880f, -0.19741502f, -0.46284264f, 0.50843179f, 0.63013369f, 
    -0.25725046f, 0.94324023f, 0.12503488f, 0.06021985f, -0.01538851f, -0.63536066f, -0.20371032f, 0.16487245f, 
    0.15665853f, -0.44920048f, -0.13664880f, 0.02833918f, -0.02754112f, 0.01761700f, 0.20149535f, -0.03711348f, 
    -0.29022813f, -0.01733864f, 0.54851830f, -0.30276304f, -0.57333642f, 0.67570925f, -0.10059361f, -0.69372934f, 
    -0.91097385f, -0.96887612f, 0.06078031f, -0.01949769f, -0.39659551f, -0.20057653f, -0.24340855f, 0.03821085f, 
    -0.12444932f, 0.21815652f, 0.15936799f, -0.15285906f, -0.33718854f, 0.52819562f, -0.12441035f, 0.36857995f, 
    -0.28097409f, 0.18339296f, 0.02002023f, 0.07150681f, 0.05322236f, -0.07717586f, 0.42260844f, -0.53282392f, 
    -0.59379023f, -0.88005775f, -0.89961845f, -0.80516142f, -0.53701991f, 0.48109886f, 0.29855767f, 0.56045753f, 
    -0.26037142f, -0.09738742f, -0.50340569f, -0.06663377f, -0.05658431f, 0.39236310f, -0.09336440f, -0.10139456f, 
    0.13778605f, 0.01670272f, 0.35110757f, 0.17062286f, -0.13760303f, -0.19979148f, 0.50153595f, 0.90582788f, 
    0.71759820f, -0.99357802f, 0.17505908f, -0.03292738f, -1.15964913f, 0.13058069f, 0.40127614f, 0.47612447f, 
    0.16127457f, 0.30048597f, 0.14555149f, 0.36012027f, 0.17113827f, 0.11480612f, 0.08604181f, 0.03140233f, 
    -0.28851324f, 0.02722752f, 0.15935853f, 0.13873813f, -0.15477134f, -1.32932603f, 0.80358320f, -0.19227064f, 
    -0.55522990f, 0.07411771f, 0.47872627f, 0.27316499f, -0.33041245f, 0.43087742f, -0.74335623f, -0.03958074f, 
    0.09559347f, -0.58847767f, 0.51570123f, -0.12341244f, -0.29411444f, 0.00288419f, -0.45225900f, -0.28921071f, 
    -0.08804429f, -0.05829036f, 0.27430999f, 0.23829864f, 0.21524604f, -0.36829609f, -0.72396046f, -0.41120389f, 
    -0.83524680f, -0.47343403f, -0.73061579f, 0.50964189f, 0.09370895f, -0.64834434f, 0.25412729f, 0.44637495f, 
    -0.19007288f, 0.08035753f, 0.07693189f, 0.44740644f, 0.49438205f, -0.13246708f, -0.10444501f, 0.20563710f, 
    0.30778971f, -0.07564270f, 0.07221778f, 0.06063842f, -0.06975077f, -0.00913145f, -0.12117372f, 0.07268119f, 
    0.40710616f, 0.54516965f, -0.24201091f, 0.87095964f, 0.06300719f, 0.50465137f, 0.40031105f, 0.17582321f, 
    0.12831239f, 0.17402120f, 0.22419299f, 0.62223095f, -0.17561844f, 0.02725804f, 0.45039082f, -0.47207007f, 
    -0.32184395f, 0.21599609f, 0.59998876f, 0.49532259f, -0.03998226f, -0.03489605f, -0.13608298f, 0.17556158f, 
    -0.06617245f, 0.64380306f, 0.52943039f, 0.36449254f, 1.16719043f, 1.32830691f, -0.29985023f, -0.97887653f, 
    -0.39184904f, -0.51735061f, 0.24179509f, 0.39563939f, 0.18182552f, 0.58430123f, -0.18721382f, -0.22011530f, 
    -0.21222498f, 0.30363753f, -0.05021039f, 0.36916128f, -0.00897579f, 0.08097044f, -0.03367041f, -0.02707381f, 
    0.04558757f, -0.24884969f, -1.22251308f, -0.89453745f, -0.00941663f, -0.10047243f, -0.93818396f, 0.07506383f, 
    0.17538090f, -0.49607378f, 0.28149411f, 0.28308845f, 0.35591841f, 0.18179804f, -0.22246675f, 0.06100838f, 
    0.01111482f, 0.09518305f, 0.10296390f, -0.25313836f, -0.35447872f, 0.17241745f, -0.59184033f, -0.13989319f, 
    0.29149377f, 0.13626425f, -0.82206589f, -0.20438048f, -0.76559359f, 0.14148898f, 0.14293468f, 0.53318298f, 
    1.14677131f, 0.00150603f, 0.44382894f, 0.40283561f, 0.33284235f, -0.14386758f, 0.27529952f, -0.29760939f, 
    0.54995710f, 0.10585897f, 0.10851595f, -0.14955272f, 0.30898991f, -0.06955183f, 0.01338636f, 0.03359390f, 
    -0.24681698f, 0.40012002f, -0.07800222f, -1.57120633f, 0.38961652f, 0.98139620f, -0.12176020f, -0.91605723f, 
    0.58858275f, 0.45621756f, 0.19756772f, 0.62455016f, 0.50964975f, 0.16737270f, 0.22017212f, 0.30057812f, 
    -0.16551973f, -0.19847347f, 0.13173102f, -0.29908910f, -0.02522890f, -0.13181746f, 0.13959180f, 0.32221544f, 
    0.23505700f, 0.13479730f, 0.02628149f, 0.12888019f, 1.51069021f, 0.91598916f, 0.08042961f, 0.91145790f, 
    0.88514704f, 0.10863469f, -0.51581180f, -0.04781843f, -0.28172734f, -0.48991221f, 0.01778880f, 0.41167864f, 
    0.14408779f, 0.05712843f, -0.10074659f, 0.32760069f, -0.16005018f, 0.06171712f, 0.09279852f, -0.03331028f, 
    0.16611743f, 0.01925939f, 0.04545806f, -0.21892501f, 0.19868687f, -0.92045337f, -0.64326239f, -0.57398635f, 
    -0.63642627f, -0.12725133f, -0.28974882f, 0.90926242f, 0.44241443f, 0.32884574f, 0.47659808f, -0.43670762f, 
    -0.42460594f, 0.25956830f, -0.36609569f, -0.11006847f, 0.10289966f, -0.07518841f, 0.09129007f, -0.14448087f, 
    0.03395928f, 0.48089805f, 0.08232188f, -0.00412048f, 0.05698106f, -0.12394638f, -1.30172312f, -0.81515145f, 
    0.04044111f, 0.37824169f, 0.86685437f, 1.12381136f, -0.05293104f, -0.38219869f, 0.18082231f, -0.67399788f, 
    -0.04552846f, 0.33290994f, -0.03530939f, 0.26437715f, 0.07092304f, 0.17774135f, 0.07008481f, -0.11296585f, 
    -0.21365248f, 0.31811124f, 0.16079296f, 0.14947230f, 0.27272719f, -0.19070455f, -0.19776982f, 0.98796105f, 
    -0.34825718f, 0.94890499f, 0.20738293f, 0.71204352f, -0.11646891f, 0.15297760f, 0.40798512f, 0.22651662f, 
    -0.17389452f, -0.17597185f, -0.51215136f, -0.36113840f, -0.31656793f, -0.02194318f, -0.10385377f, -0.19034055f, 
    -0.31503254f, -0.06701514f, 0.17664315f, -0.41864330f, -0.28799623f, -0.14012775f, -0.13484479f, -0.23701413f, 
    -0.05689915f, -0.76290882f, -0.87790561f, -0.89002818f, 0.37118983f, 0.05272983f, -0.91453284f, -0.53504223f, 
    -0.46745718f, -0.24742784f, 0.04506623f, 0.16082737f, 0.50542611f, 0.26910025f, 0.25629193f, 0.42705601f, 
    0.17674768f, -0.07274218f, 0.36684263f, 0.45687822f, 0.17768382f, -0.09318648f, 0.54262239f, 0.00872873f, 
    -0.45249316f, -0.17180417f, -0.91053641f, -0.95640606f, -0.67520750f, -0.59682494f, -0.18489140f, 0.91949177f, 
    0.72680378f, -0.21177371f, 0.58581007f, -0.10623847f, -0.32279387f, -0.31084350f, -0.18852884f, -0.23379181f, 
    -0.15926227f, 0.30756170f, -0.08094864f, 0.07373281f, -0.10542607f, -0.32061779f, 0.05957423f, 0.02308865f, 
    -0.25229549f, 0.11832585f, 1.35013139f, 0.91076475f, 1.12781322f, -0.08900312f, -0.59568828f, -0.31865898f, 
    0.19039698f, -0.28690448f, -0.02167274f, 0.54790986f, -0.11936869f, 0.27148449f, -0.35627174f, 0.12373144f, 
    0.25471833f, 0.25578189f, -0.06748462f, 0.47045526f, 0.07904447f, -0.14203513f, -0.11814971f, 0.25119194f, 
    0.11542337f, -0.11019386f, 0.44224888f, -1.14079595f, 1.30415380f, -0.56861031f, -0.48680729f, 0.88330460f, 
    -0.21086971f, 0.68714702f, 0.56251889f, -0.59262168f, -0.32913390f, -0.05883392f, -0.25099725f, 0.09492634f, 
    -0.14738016f, 0.32563722f, 0.19621615f, 0.03275979f, -0.08014472f, 0.06975847f, -0.13138486f, 0.23195150f, 
    0.11168075f, 0.15667684f, -0.00888499f, 0.07984481f, 0.13856043f, 0.01777277f, -1.01901293f, -0.97404450f, 
    -0.10628544f, 0.63493806f, 0.44031745f, -0.79126996f, 0.25788555f, 0.71111614f, -0.16134460f, -0.15166160f, 
    0.43256962f, 0.16144496f, -0.30119210f, 0.08458184f, 0.18927933f, 0.20683983f, 0.23033169f, 0.17611384f, 
    0.15082665f, -0.22283944f, -0.18917498f, 0.05540760f, 0.01427477f, 0.74802572f, 0.90293813f, 0.97467911f, 
    0.67003429f, 0.12417600f, -0.60730302f, 0.73926789f, -0.82148755f, -0.71191418f, -0.02486220f, 0.49451032f, 
    0.04729101f, -0.17055877f, 0.31337681f, -0.11632516f, -0.10264671f, 0.26036224f, 0.00380737f, -0.01830607f, 
    -0.01683327f, -0.23626201f, 0.38704544f, 0.30955744f, -0.00490209f, 0.29464719f, 0.00627951f, -0.45679709f, 
    -0.13837980f, 0.34169701f, -0.15472186f, -0.47434899f, 0.25192547f, -0.64534855f, -0.75951344f, -0.33935243f, 
    -0.73205853f, 0.21015237f, 0.29418367f, -0.31313661f, -0.53503245f, 0.16733816f, 0.22002406f, 0.13959807f, 
    -0.34564999f, -0.76157248f, -0.30390140f, 0.17940928f, -0.01353622f, -0.43750948f, 0.16164379f, -0.23616847f, 
    -0.47629473f, 0.93529505f, -0.64568293f, -0.97381496f, -0.10666623f, -0.44136319f, 0.35950601f, 0.08495138f, 
    -0.26477575f, 0.25036070f, 0.20544770f, -0.38945037f, 0.26596701f, 0.01028751f, 0.09238440f, -0.07397424f, 
    -0.33698857f, -0.03502767f, -0.37880251f, 0.46309680f, 0.58511817f, 0.22273405f, 0.28876665f, 0.38897693f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18636538f, 0.24305706f, 0.17993188f, 0.10071740f, 0.33606929f, 0.24871087f, 0.00101731f, 0.30978999f, 
    0.08852705f, 0.30726919f, 0.25093758f, 0.07453959f, 0.22174388f, 0.03690861f, 0.54237777f, 0.16128370f, 
    0.15311131f, 0.29130393f, 0.36271387f, 0.07284534f, -0.05809751f, 0.00280694f, 0.51516575f, -0.00531799f, 
    0.48512089f, 0.16162311f, 0.33718461f, 0.06131218f, 0.38715598f, 0.17452377f, -0.05297614f, 0.11186539f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17004345f, 0.01694521f, 0.15512353f, -0.36675259f, -0.31495905f, -0.01245989f, 0.04628975f, 0.05338188f, 
    -0.21018793f, -0.11411978f, -0.07950477f, -0.03292210f, -0.11313314f, 0.02508807f, 0.07494258f, -0.03575239f, 
    -0.11957345f, -0.05230894f, 0.06424032f, -0.22686918f, -0.03011628f, -0.13770530f, 0.05206056f, -0.01189563f, 
    0.45776927f, 0.06935159f, -0.05842160f, -0.18635896f, 0.07020101f, -0.01050297f, -0.08109047f, -0.12762319f, 
    0.08423780f, -0.14266136f, -0.12873012f, -0.10067420f, -0.16213666f, 0.25933987f, -0.18665230f, 0.17242502f, 
    -0.01525307f, 0.01586858f, -0.22019893f, -0.01413681f, 0.06437002f, 0.05437904f, 0.01005358f, 0.07721505f, 
    0.27842081f, -0.22643644f, -0.04301161f, 0.27185553f, -0.23274188f, -0.01965632f, -0.07657088f, -0.04271244f, 
    -0.12706695f, -0.11899702f, -0.05394951f, 0.07880870f, 0.11369245f, -0.06174108f, -0.07393122f, 0.18614529f, 
    -0.05089424f, 0.01360791f, -0.03082388f, 0.02998178f, -0.06699958f, -0.09025475f, 0.02491127f, -0.12795061f, 
    0.65268022f, 0.26410654f, 0.10899510f, 0.02207105f, -0.04243118f, 0.15298451f, -0.17608629f, 0.09443577f, 
    0.13279016f, -0.02629810f, -0.03447253f, 0.00465611f, 0.15735395f, -0.04057462f, -0.06825719f, 0.34040138f, 
    -0.19981867f, -0.06870132f, 0.00465184f, 0.01130270f, -0.20971277f, 0.06168121f, -0.02701441f, -0.02167000f, 
    -0.01668555f, -0.14296505f, -0.20137776f, 0.43570533f, -0.02517301f, 0.03920504f, 0.11406957f, 0.03510841f, 
    -0.02381171f, -0.06076034f, 0.03573757f, -0.08425297f, 0.07425559f, -0.13942777f, 0.01304389f, -0.19403976f, 
    -0.07088314f, -0.12577115f, 0.08462673f, -0.04151249f, -0.00061868f, 0.02921560f, 0.03185635f, -0.03060767f, 
    0.04604126f, -0.43127897f, 0.02907070f, 0.34513676f, 0.10175089f, 0.01564594f, 0.03965954f, 0.02921245f, 
    0.02724986f, -0.09399743f, 0.02815158f, 0.19995824f, -0.13216369f, -0.02638044f, 0.14092979f, 0.16815136f, 
    -0.07695749f, 0.03588663f, 0.10604937f, -0.05227438f, -0.05947327f, 0.02698549f, -0.19109349f, -0.02510136f, 
    0.04318086f, -0.03345060f, -0.30324978f, 0.20553778f, 0.02774743f, -0.01603519f, 0.02678647f, 0.02823053f, 
    0.00889275f, -0.02006483f, 0.08584620f, -0.07416149f, -0.03353832f, -0.01813552f, -0.07202548f, -0.25300261f, 
    0.06640193f, 0.07048339f, 0.04779209f, 0.00499401f, 0.10301501f, -0.14503945f, 0.08012924f, -0.01976074f, 
    0.22838946f, -0.17557885f, -0.11889171f, -0.28381029f, 0.05380756f, -0.02473359f, 0.03331050f, 0.02013502f, 
    0.02693702f, -0.13312872f, -0.09923992f, 0.00363807f, -0.28303966f, -0.09662571f, -0.02474893f, -0.27354380f, 
    -0.17527424f, 0.01076797f, 0.08280370f, 0.04195224f, 0.09747569f, -0.06981666f, 0.02538791f, -0.01536233f, 
    -0.12233577f, -0.07632261f, 0.17651628f, -0.04361011f, -0.12777416f, -0.07404094f, 0.15244235f, 0.03936927f, 
    0.06569616f, 0.05055113f, -0.08998094f, 0.05150551f, -0.73226094f, -0.35351512f, -0.15775904f, 0.06399259f, 
    0.01338434f, -0.08587547f, -0.07136628f, 0.08615769f, -0.05371711f, 0.12881407f, -0.12185115f, -0.08264022f, 
    0.34370038f, 0.25588661f, 0.08063108f, -0.14310132f, -0.00786867f, 0.10564766f, -0.09788651f, -0.02747970f, 
    0.01646866f, -0.07552119f, -0.06530465f, -0.03362458f, 0.50619513f, 0.05750248f, 0.04299458f, 0.24577826f, 
    -0.08582268f, -0.05280158f, 0.01098882f, -0.16786213f, 0.05960822f, -0.01690842f, 0.07871810f, -0.15985952f, 
    0.38197789f, -0.12628002f, 0.13134207f, -0.12233245f, -0.35392424f, 0.00018367f, -0.07429682f, 0.19121885f, 
    0.05180407f, 0.01808256f, -0.00116527f, -0.10261439f, 0.12923069f, 0.36916450f, -0.04073667f, -0.47815371f, 
    0.09928320f, 0.15099102f, 0.03437567f, 0.03483003f, -0.09497056f, 0.08958223f, -0.04789214f, 0.16953041f, 
    -0.54291821f, -0.24404308f, 0.27458176f, 0.11902039f, 0.11727166f, 0.06630693f, -0.13969703f, -0.06498846f, 
    -0.05615449f, -0.09538611f, 0.14533359f, -0.16813532f, 0.28353009f, -0.15936045f, -0.10828082f, 0.16172798f, 
    -0.30035535f, -0.01903242f, 0.04569980f, 0.03207926f, 0.05541666f, -0.06909105f, 0.00979098f, -0.09140251f, 
    -0.17071785f, -0.26462629f, 0.11559831f, -0.15154664f, -0.04043330f, 0.07187843f, 0.11455315f, -0.01487236f, 
    -0.06230673f, -0.07349472f, -0.03621489f, -0.01631774f, -0.17167306f, 0.28156918f, 0.06697262f, -0.59345067f, 
    0.08495178f, 0.04233253f, 0.00781953f, -0.02875285f, -0.08570497f, -0.08121482f, -0.07378541f, 0.08803729f, 
    -0.00749217f, 0.03448461f, 0.06788597f, -0.03624800f, -0.18294190f, -0.10720715f, -0.06200895f, 0.07889114f, 
    0.04786970f, 0.02236803f, 0.02420063f, -0.02416029f, -0.07742249f, 0.21694483f, 0.39859620f, -0.34359726f, 
    -0.00549038f, -0.07386044f, 0.11486287f, 0.04453125f, -0.03597836f, 0.07759441f, -0.03435165f, -0.05669058f, 
    0.25866279f, -0.04756454f, 0.01097778f, -0.42338631f, 0.00933909f, -0.04614799f, 0.05094271f, -0.00140822f, 
    -0.07400255f, 0.05279345f, 0.05568651f, 0.10688169f, 0.07445323f, 0.14656666f, 0.00633789f, 0.16686106f, 
    -0.23477086f, -0.14495103f, 0.00133645f, 0.16993824f, -0.08098464f, 0.07270426f, -0.20430957f, -0.02479592f, 
    -0.12903728f, 0.07018039f, 0.15165459f, 0.26836908f, 0.01815742f, 0.08818246f, 0.07733476f, -0.16066121f, 
    -0.06508634f, 0.14578709f, -0.10069111f, -0.02523891f, -0.44550928f, -0.27823663f, 0.07454419f, 0.21715838f, 
    -0.10126938f, 0.06787160f, -0.04297688f, -0.06509173f, 0.13934740f, 0.25356415f, -0.21900640f, 0.04021143f, 
    0.30750254f, -0.28173247f, 0.03478480f, -0.25090590f, 0.09610387f, 0.03741254f, 0.11462089f, -0.04952777f, 
    -0.32471481f, -0.06867211f, -0.00749614f, -0.02449726f, -0.04167645f, 0.21512799f, 0.04158501f, -0.09774587f, 
    0.11615244f, -0.02103715f, -0.02967538f, 0.08625671f, 0.13275746f, 0.03385670f, -0.04508258f, 0.00799261f, 
    -0.45119226f, -0.08426328f, -0.09394225f, -0.33562198f, -0.03628978f, 0.07233787f, -0.00558152f, 0.16870105f, 
    0.12919047f, -0.22150317f, -0.09596908f, -0.11101924f, 0.12999098f, -0.29888916f, 0.07743303f, 0.17660719f, 
    -0.11099876f, 0.04842162f, 0.01817390f, 0.12604061f, -0.05020459f, -0.07942992f, -0.18620513f, -0.04419484f, 
    -0.39195359f, -0.20972177f, -0.10131271f, 0.10596409f, 0.05360409f, 0.02790538f, -0.13155960f, 0.13757822f, 
    -0.01361611f, 0.06466715f, 0.15226267f, 0.09249393f, 0.21150574f, 0.12844232f, 0.15528670f, 0.24591263f, 
    -0.08300983f, 0.07087513f, -0.04632125f, 0.07496310f, -0.12182627f, 0.14702356f, 0.01733625f, 0.19168071f, 
    -0.31560767f, -0.04066541f, -0.48488688f, 0.14965855f, 0.10125895f, -0.22389847f, 0.09643319f, -0.00378970f, 
    -0.05638710f, 0.04314061f, 0.04103440f, 0.06021952f, 0.23535402f, 0.12063789f, 0.18953110f, 0.37843168f, 
    -0.12392818f, 0.21000175f, 0.07369459f, 0.02385650f, 0.13437876f, 0.01758901f, -0.04352124f, 0.17032878f, 
    0.56752944f, -0.06897304f, 0.06626141f, 0.26510909f, -0.05041522f, 0.02820536f, 0.02548547f, -0.11097033f, 
    0.08477496f, -0.09034590f, -0.02323932f, -0.03917597f, 0.34561652f, -0.35284638f, 0.11346474f, -0.04934211f, 
    0.01117857f, -0.22548711f, -0.11934232f, 0.07083363f, 0.00588739f, -0.01164369f, -0.24057722f, 0.09296390f, 
    0.06590857f, -0.11786941f, -0.26685059f, -0.41551924f, -0.11431006f, 0.04595690f, -0.08973005f, 0.03135697f, 
    -0.09648507f, 0.06693654f, 0.11338089f, -0.02743265f, -0.46503741f, -0.25760642f, -0.23992644f, -0.03070090f, 
    0.07767469f, 0.00195957f, 0.00119335f, 0.10897714f, 0.09184831f, 0.18465266f, 0.06790093f, -0.05791981f, 
    -0.32316226f, 0.00095623f, -0.06942810f, 0.15561515f, -0.03156479f, -0.00651581f, -0.04480654f, 0.00221117f, 
    0.09448990f, 0.11590873f, -0.02783512f, 0.10365897f, -0.47405648f, 0.03651766f, -0.32652742f, -0.17750204f, 
    -0.07842578f, 0.10454654f, -0.03184082f, -0.00835094f, 0.04132747f, 0.14687066f, -0.22256155f, -0.32365328f, 
    -0.02057598f, 0.04491321f, 0.01429847f, 0.02119143f, 0.01973445f, -0.02779155f, 0.04881852f, 0.06703893f, 
    -0.02948724f, 0.02587556f, -0.02165430f, 0.05671422f, 0.01870773f, 0.19570695f, 0.02780758f, 0.20313030f, 
    -0.00964348f, -0.08587603f, 0.01533556f, -0.15084982f, -0.07360669f, -0.06285440f, -0.10013856f, 0.07398281f, 
    0.10750724f, -0.16180915f, 0.17972961f, -0.10566077f, 0.01583993f, 0.06620133f, -0.10649753f, -0.08449708f, 
    -0.19948390f, -0.01894461f, 0.14415854f, -0.17270568f, 0.25863612f, -0.07115348f, -0.04628041f, 0.05600679f, 
    -0.19644903f, 0.09539461f, -0.06135386f, -0.00591663f, -0.03101729f, -0.25120941f, 0.21285450f, 0.07223637f, 
    0.12271056f, -0.00805453f, -0.16191310f, -0.13197522f, 0.13467552f, 0.05323264f, -0.06329124f, -0.01470056f, 
    0.04101124f, 0.02651218f, 0.04224758f, 0.12948948f, -0.93886107f, -0.08725493f, -0.04475218f, -0.06200356f, 
    0.04719793f, 0.06638645f, 0.07449158f, 0.09439264f, -0.00670759f, 0.01234792f, -0.00874541f, 0.08389472f, 
    0.10790112f, -0.15656208f, 0.32521757f, 0.33852184f, -0.03859216f, -0.10032330f, 0.01203708f, -0.05394092f, 
    0.05845536f, -0.02820096f, -0.19297868f, 0.01541686f, 0.31266466f, -0.02419931f, -0.13008299f, -0.17853218f, 
    0.05788802f, -0.23999725f, -0.05894987f, -0.01723491f, 0.18675882f, 0.05792617f, -0.11955179f, 0.09359795f, 
    0.01325160f, 0.13384335f, -0.38478184f, -0.08284119f, 0.00982836f, 0.03577563f, 0.08035392f, -0.03961485f, 
    -0.07769606f, 0.18728468f, -0.04552459f, 0.07897288f, 0.06694917f, -0.01620542f, 0.06971920f, 0.18777129f, 
    -0.02081552f, -0.08058275f, -0.05199775f, -0.03185580f, -0.05084857f, 0.09962197f, -0.11998203f, -0.14927582f, 
    0.07385905f, 0.08866309f, 0.21942189f, -0.24004412f, -0.09906884f, 0.00839884f, 0.20986614f, 0.00700296f, 
    0.07678183f, 0.23766124f, 0.03325712f, 0.05593070f, 0.33308622f, -0.10485678f, -0.12080833f, -0.23449768f, 
    -0.03947140f, 0.00314573f, 0.01873619f, 0.05232493f, 0.03360081f, -0.07080821f, -0.13073796f, -0.11926483f, 
    0.36243385f, 0.15820405f, -0.11408039f, 0.05250556f, -0.11528552f, -0.10688891f, 0.05197297f, -0.02772936f, 
    -0.04885742f, -0.14151637f, -0.05689537f, 0.00153853f, 0.09517014f, 0.07914862f, -0.36951742f, -0.63472974f, 
    0.06097315f, 0.18653870f, -0.09443627f, -0.04111588f, 0.15884103f, 0.09720209f, 0.13070582f, -0.01717166f, 
    -0.09304954f, -0.29015312f, 0.23904549f, -0.41040757f, -0.02634330f, -0.05318685f, 0.05137238f, -0.04594152f, 
    -0.05325387f, -0.01652257f, 0.03229453f, -0.13272436f, 0.23476477f, 0.13477494f, 0.03118728f, -0.08386078f, 
    -0.16895325f, 0.05891131f, 0.08459611f, -0.05541819f, 0.10900856f, -0.08758962f, 0.11908855f, -0.07493228f, 
    0.00862867f, -0.24039961f, -0.23522410f, -0.28492695f, -0.08909208f, -0.00665043f, -0.04611045f, 0.22926916f, 
    0.00295170f, -0.54747117f, 0.04046374f, -0.27645653f, -0.51974505f, 0.19579604f, -0.34586814f, -0.03405315f, 
    0.12820274f, -0.00317761f, -0.01481739f, 0.03766239f, 0.03383893f, 0.04409169f, -0.02275806f, -0.03923445f, 
    -0.11914555f, -0.04799191f, -0.05623315f, -0.45591336f, -0.12492131f, -0.16091949f, 0.27594563f, -0.01957632f, 
    -0.07880586f, 0.11180060f, 0.16461943f, -0.02958979f, 0.37565145f, -0.02115368f, -0.15572265f, 0.15313371f, 
    -0.00486895f, 0.12888697f, 0.09234187f, 0.06870259f, -0.17556709f, 0.00960006f, 0.01615062f, 0.04186215f, 
    -0.06616177f, 0.00387082f, -0.34825867f, 0.05523336f, 0.02835540f, 0.00049793f, -0.15680075f, -0.07282414f, 
    -0.05640983f, 0.13283314f, -0.04344208f, 0.06521144f, 0.41293165f, -0.20847741f, 0.14521395f, 0.19350284f, 
    -0.12794113f, 0.05167769f, -0.05341321f, -0.07743994f, 0.07419559f, -0.02178515f, 0.03084690f, 0.03795358f, 
    0.39404142f, -0.21342893f, -0.07652638f, 0.05370383f, 0.00752020f, 0.07359017f, -0.05689910f, -0.08143134f, 
    -0.10796794f, -0.01386568f, 0.00873447f, -0.03685687f, -0.13337952f, -0.11001856f, 0.03706622f, 0.03407739f, 
    0.01541173f, -0.02341092f, -0.16713460f, 0.00902872f, 0.00462897f, 0.00927994f, 0.04645636f, -0.04463372f, 
    0.40881327f, -0.53240091f, 0.14581980f, -0.16655675f, 0.02665096f, -0.11659453f, -0.00063407f, 0.07482550f, 
    0.03934949f, 0.07891766f, -0.00041822f, -0.12924655f, -0.10963440f, 0.08270001f, 0.04836774f, -0.07692146f, 
    0.15017872f, 0.02884729f, -0.03201414f, -0.05371082f, 0.09363588f, 0.11143890f, 0.05252208f, 0.06705166f, 
    -0.09510712f, 0.01263995f, -0.12327828f, -0.09982518f, -0.09788739f, 0.18209316f, -0.00820184f, 0.06308684f, 
    0.04707281f, 0.13086632f, 0.04629100f, -0.07751849f, 0.30913216f, -0.05264246f, 0.01771942f, -0.04964837f, 
    -0.04728483f, -0.09595963f, 0.08131853f, 0.14692278f, 0.02131958f, 0.02307171f, 0.22174749f, -0.09377091f, 
    -0.40488264f, -0.28234968f, -0.16224049f, -0.07963561f, -0.01431754f, -0.04826298f, -0.04301861f, -0.01550334f, 
    -0.02415934f, 0.00201025f, 0.04673688f, -0.01244752f, 0.02261616f, -0.04321946f, -0.12352455f, -0.41727418f, 
    0.00372568f, -0.01958320f, -0.02159003f, 0.01812266f, -0.05241652f, 0.05907745f, 0.08667160f, -0.11578165f, 
    0.36835626f, -0.05856284f, -0.17516810f, 0.08539191f, 0.06174493f, 0.10762751f, -0.12601686f, -0.02401255f, 
    -0.15775533f, -0.12450252f, 0.02073052f, -0.10438900f, 0.24238935f, 0.11256722f, -0.45911673f, -0.15003067f, 
    -0.13210487f, 0.00157949f, -0.17881387f, -0.16342737f, -0.01590170f, -0.00499889f, 0.04163485f, -0.06459676f, 
    0.24714203f, 0.12011560f, 0.11019041f, -0.06586624f, -0.21002844f, -0.12126681f, -0.06641156f, 0.13090673f, 
    -0.10842165f, -0.04813872f, -0.12064301f, -0.05899473f, 0.02435945f, 0.06002341f, -0.08710565f, 0.05224987f, 
    0.04729944f, -0.00498391f, 0.04350986f, -0.15751977f, -0.16871220f, 0.00562122f, 0.01413372f, -0.00153710f, 
    0.07273621f, -0.13807510f, 0.07291701f, 0.05149104f, 0.06486291f, -0.06324440f, 0.06808446f, -0.03686624f, 
    -0.05383986f, 0.04386762f, -0.15191932f, 0.01279716f, 0.72891814f, -0.33364731f, -0.08354001f, -0.12298808f, 
    -0.08965852f, 0.01859145f, -0.05408439f, -0.06122506f, -0.10493374f, 0.07149514f, 0.00199862f, -0.17389937f, 
    0.19428022f, 0.02332468f, 0.22521958f, 0.12498149f, -0.11553221f, -0.19558403f, -0.03947815f, 0.07805941f, 
    0.05078660f, -0.05937409f, -0.08278754f, -0.02279848f, 0.46370655f, 0.20894918f, -0.02667762f, -0.07958951f, 
    -0.19883367f, 0.07342811f, 0.07784361f, 0.00345875f, -0.12764131f, 0.12106279f, 0.01792943f, -0.07560235f, 
    -0.10995062f, 0.06385766f, -0.09946111f, -0.09481096f, 0.13825995f, -0.01849522f, 0.12879431f, -0.14288928f, 
    -0.07492865f, 0.13658668f, 0.10013677f, -0.12731783f, 0.25311700f, 0.01764889f, -0.03451004f, 0.42951724f, 
    -0.12673612f, -0.11086465f, -0.03603242f, 0.04506713f, 0.09728692f, 0.06465789f, 0.01232180f, -0.09926465f, 
    0.18419929f, -0.37185794f, 0.05030522f, 0.10416474f, -0.23681264f, 0.01937830f, -0.08236604f, -0.11479282f, 
    -0.03559236f, -0.01239891f, -0.05745472f, -0.08106763f, -0.48792538f, 0.26255351f, -0.18923527f, -0.14491370f, 
    0.16863559f, 0.04118493f, -0.02050591f, 0.10149476f, -0.06882350f, 0.02763881f, 0.02660226f, -0.05894212f, 
    -0.63150668f, -0.36825287f, -0.07196359f, -0.24523558f, -0.07036389f, 0.13074923f, -0.04623553f, -0.06634273f, 
    -0.12252158f, -0.18204214f, -0.03248681f, 0.00128021f, 0.27973202f, 0.09634522f, 0.19691309f, 0.43306804f, 
    -0.11878388f, -0.16258407f, 0.11595658f, 0.08133294f, -0.00971642f, 0.10517063f, -0.00879096f, 0.03773317f, 
    -0.12968193f, -0.03566922f, -0.04473889f, -0.30597022f, -0.12238259f, 0.11172415f, 0.04518345f, 0.03564458f, 
    -0.08867905f, -0.00972221f, -0.02254850f, -0.03633352f, 0.06102501f, -0.04012183f, -0.29164958f, -0.10560738f, 
    0.10672640f, 0.05475733f, 0.00747078f, -0.22029696f, 0.02947941f, 0.01986892f, -0.01654496f, 0.01738877f, 
    0.04293549f, -0.00353690f, 0.14357872f, -0.06280276f, -0.12879542f, -0.05999617f, 0.06326967f, 0.00724935f, 
    -0.09182511f, -0.06657238f, -0.02907110f, -0.00257870f, 0.02869866f, 0.19329901f, -0.00446314f, -0.05546468f, 
    0.02555750f, 0.06067294f, 0.04015511f, -0.03026128f, -0.05675709f, 0.03093001f, -0.14761941f, -0.05703359f, 
    -0.07300238f, -0.11171199f, -0.26759517f, -0.23263416f, -0.10208521f, 0.10362457f, -0.04901366f, 0.02036677f, 
    0.00586097f, 0.22640039f, -0.17602199f, -0.06981048f, -0.35175300f, -0.05985874f, 0.11124744f, -0.08571762f, 
    -0.23798074f, 0.17965890f, 0.03557474f, -0.06211280f, 0.07900684f, -0.23028414f, -0.10865476f, -0.01716344f, 
    0.19764917f, -0.16576220f, -0.18632156f, 0.03946999f, -0.01237658f, 0.02181633f, -0.02976282f, 0.31641114f, 
    -0.00921832f, 0.07891631f, -0.05638053f, 0.00348984f, -0.57108718f, -0.02150366f, -0.16146666f, -0.23792249f, 
    -0.02339550f, 0.05606664f, -0.11201649f, 0.10147203f, 0.01168411f, 0.01316795f, -0.13540591f, 0.11225015f, 
    0.27148712f, 0.44586757f, 0.00159201f, -0.14974685f, -0.03935557f, -0.06348402f, -0.01223801f, 0.09554726f, 
    0.03457966f, 0.10992491f, -0.04500001f, 0.04260517f, 0.02445578f, 0.01466429f, 0.22014754f, 0.05960768f, 
    -0.00416622f, 0.07918077f, 0.25250494f, 0.01088422f, 0.01521942f, 0.11244612f, 0.06744325f, 0.09831417f, 
    0.05300267f, 0.02194514f, 0.24576724f, 0.34237278f, 0.10065535f, 0.20429990f, 0.00965011f, -0.23369487f, 
    -0.06160827f, 0.01652517f, 0.08455516f, -0.06554290f, -0.58405101f, -0.24913934f, -0.13148600f, 0.08511836f, 
    -0.21184359f, -0.10184158f, -0.01500401f, -0.03375988f, -0.06487542f, -0.21854556f, 0.07684930f, -0.00326818f, 
    -0.18036941f, 0.08899122f, 0.02324939f, -0.03275501f, 0.07423924f, -0.13820843f, 0.12729648f, 0.17525271f, 
    0.11534134f, -0.08433712f, 0.07331289f, -0.12623623f, -0.44701609f, -0.45963058f, -0.28326675f, 0.00074943f, 
    -0.03702305f, -0.02738231f, -0.05691496f, -0.25439060f, 0.03104634f, 0.03433277f, 0.05286174f, -0.05790357f, 
    -0.29709673f, -0.11045612f, -0.12323508f, -0.15744066f, -0.11406209f, 0.01834951f, -0.13034725f, -0.10837235f, 
    0.00669152f, -0.00701090f, 0.14823259f, 0.01609617f, 0.14597189f, -0.12691702f, 0.07071786f, -0.22446583f, 
    -0.02003738f, 0.11737128f, -0.01085360f, -0.09471756f, -0.11218316f, -0.03218767f, 0.10152180f, -0.08865400f, 
    0.35725752f, 0.00521260f, 0.12295827f, 0.05227602f, 0.01636355f, 0.02202014f, 0.03511350f, -0.06737711f, 
    0.01130112f, -0.09903731f, 0.09182374f, -0.17078733f, 0.25302672f, -0.11059414f, 0.11565791f, 0.12601723f, 
    0.10771684f, 0.07007433f, -0.10351696f, 0.11178441f, 0.02559760f, -0.04262598f, -0.00550407f, -0.17954028f, 
    -0.69477451f, -0.08134489f, 0.44311559f, 0.18280464f, 0.17073530f, 0.08217885f, -0.03506061f, -0.04444989f, 
    -0.06017263f, 0.03065458f, -0.15878312f, -0.07651095f, 0.60686010f, 0.44515073f, 0.16524009f, 0.02968750f, 
    -0.05139735f, 0.03010501f, -0.05853615f, 0.01814817f, -0.09069123f, 0.01854761f, 0.07770997f, -0.08850445f, 
    -0.09978044f, -0.08034895f, -0.02888164f, -0.30038682f, -0.12695721f, -0.09316078f, -0.13079767f, -0.04856147f, 
    -0.03982469f, -0.18101908f, 0.00930004f, 0.20549700f, -0.48576298f, -0.09006707f, -0.00322530f, 0.01856354f, 
    -0.10380287f, 0.04450088f, 0.08863849f, 0.00643491f, 0.03173589f, 0.07400782f, 0.07449626f, 0.02879645f, 
    0.71833658f, -0.04413649f, 0.17705558f, 0.29415154f, 0.09416448f, -0.00377872f, -0.20381631f, 0.02834420f, 
    -0.03227903f, -0.09130431f, -0.13110025f, -0.03607044f, 0.16635235f, 0.00369698f, 0.09096845f, 0.06504647f, 
    -0.09512421f, -0.15577336f, 0.01649360f, -0.01717035f, 0.01533297f, 0.24586710f, 0.00758278f, 0.03833098f, 
    -0.25701094f, -0.00167093f, -0.22351219f, -0.14631316f, -0.01057500f, -0.12836458f, 0.10954608f, -0.05324339f, 
    -0.04111747f, -0.10492446f, -0.01507109f, -0.01431168f, -0.43776208f, 0.28544113f, 0.14079763f, -0.30715296f, 
    0.11005738f, -0.01446413f, 0.02681885f, 0.03578696f, 0.06929078f, -0.16861621f, -0.03518232f, 0.00069802f, 
    0.35955271f, -0.49075782f, -0.24016191f, 0.17818199f, 0.02170203f, 0.08391675f, -0.02702413f, 0.00896311f, 
    0.14488535f, -0.09312142f, -0.03237522f, -0.02805020f, -0.18259022f, 0.04886277f, -0.06003056f, -0.16471347f, 
    -0.12961182f, -0.19578318f, 0.07030603f, 0.02315127f, -0.05212866f, 0.02501539f, -0.03625007f, -0.01177738f, 
    0.19246438f, -0.12075640f, -0.06771750f, 0.16302356f, -0.01665403f, -0.15304458f, -0.12168504f, 0.18948315f, 
    -0.05896555f, -0.01968672f, 0.08118174f, 0.01802605f, -0.25985190f, -0.17691743f, 0.06392687f, -0.00474937f, 
    -0.02875935f, 0.07125520f, 0.00931788f, 0.12936902f, 0.00495501f, 0.04211614f, 0.21835186f, -0.04916069f, 
    0.03222797f, 0.03624981f, -0.06781362f, 0.06687445f, -0.05775643f, 0.08800536f, -0.03612092f, 0.03617937f, 
    0.06294613f, -0.08837511f, -0.00695296f, -0.13091192f, -0.01926915f, -0.30443844f, -0.03180315f, -0.14266621f, 
    -0.06409171f, 0.06315432f, 0.08584883f, 0.01763415f, -0.14447224f, -0.01964176f, 0.02311633f, 0.05994168f, 
    -0.77691346f, -0.28219151f, -0.46195126f, -0.07329062f, -0.00273278f, 0.00545255f, -0.05464360f, 0.03530904f, 
    -0.07478287f, -0.03998819f, 0.02483035f, 0.05499377f, -0.19622612f, 0.48595732f, 0.10018551f, 0.04522991f, 
    -0.10179251f, -0.09950777f, 0.07689872f, 0.13938253f, 0.10717243f, -0.03537837f, -0.19825089f, 0.05403320f, 
    0.03323843f, 0.20508984f, -0.10888796f, -0.11462688f, -0.14836328f, -0.08444896f, 0.07374929f, -0.18983932f, 
    -0.18048033f, -0.08219617f, -0.03296619f, 0.10001482f, -0.87017101f, -0.39385673f, -0.10554674f, 0.17902550f, 
    -0.14618380f, 0.03820041f, -0.00259472f, 0.10813611f, -0.04259843f, -0.04753755f, 0.10629917f, -0.13789573f, 
    0.12145291f, 0.01168684f, 0.17627563f, -0.01894685f, 0.04758849f, 0.11016629f, -0.00696064f, 0.01156720f, 
    -0.01805852f, 0.12951395f, -0.11710425f, 0.24031679f, 0.33654517f, -0.02744301f, 0.26290831f, -0.18031913f, 
    -0.00953265f, 0.01122048f, 0.07100837f, -0.08271714f, 0.04977710f, 0.04752313f, 0.03127483f, -0.07888107f, 
    -0.29165936f, 0.02757049f, -0.09832799f, -0.06184375f, -0.09818873f, -0.00910394f, 0.02139168f, -0.11253146f, 
    -0.04412018f, 0.09383515f, 0.06628887f, -0.09425785f, 0.27969009f, 0.03104855f, 0.05963757f, 0.09584806f, 
    -0.20442520f, 0.05493287f, 0.01532791f, -0.04040734f, -0.01284294f, 0.01727346f, 0.16056725f, 0.17371185f, 
    0.36101234f, 0.21471784f, 0.03345792f, -0.14606318f, 0.01342842f, 0.03419947f, 0.23252985f, 0.05130516f, 
    0.01940697f, 0.07519826f, -0.01550911f, 0.05431255f, -0.61436129f, 0.03628589f, -0.15446062f, -0.01809971f, 
    0.01523749f, -0.03083351f, 0.08209732f, 0.00215503f, -0.05744163f, -0.05906280f, -0.08891877f, 0.05773689f, 
    -0.26060352f, -0.13222431f, 0.01203586f, 0.18508588f, -0.04156692f, -0.04273191f, -0.06756696f, -0.08392648f, 
    0.14556856f, -0.00292831f, -0.11370917f, -0.04352220f, 0.03671527f, 0.11674000f, -0.20411393f, -0.11940088f, 
    0.08772906f, -0.08524880f, 0.05746390f, 0.10097483f, 0.10113408f, -0.13251065f, 0.04977539f, -0.14095014f, 
    -0.49740389f, -0.06370230f, -0.07301138f, -0.27086908f, -0.08223873f, 0.25331050f, -0.12289353f, 0.01685567f, 
    -0.10140020f, -0.01362533f, 0.00598543f, 0.12357701f, 0.17960508f, 0.04180924f, 0.15363277f, 0.05165565f, 
    -0.02503930f, 0.01304059f, 0.00571518f, -0.06979247f, -0.03642871f, -0.14677460f, 0.00267636f, 0.02060840f, 
    -0.66517752f, 0.48591048f, 0.02890355f, -0.00152976f, 0.16872182f, 0.12624319f, 0.08072085f, 0.09750640f, 
    -0.07722618f, 0.13062815f, -0.03711332f, 0.02399044f, -0.17098616f, 0.01964434f, -0.01682926f, -0.01859669f, 
    -0.11861847f, 0.07876287f, 0.04639618f, -0.07792295f, 0.02718820f, -0.01772330f, 0.06285559f, 0.09733903f, 
    0.02970665f, 0.17847645f, 0.01211442f, 0.34380147f, -0.17691898f, 0.07099155f, 0.05420953f, 0.04599351f, 
    -0.05719576f, -0.01911961f, 0.01477483f, 0.08092269f, -0.11933468f, -0.20487100f, 0.23740193f, -0.07574385f, 
    -0.11245140f, 0.06168001f, -0.04976896f, 0.06759241f, 0.16628735f, -0.16772963f, -0.05501628f, -0.02284254f, 
    -0.46157888f, -0.11308236f, 0.21207114f, 0.11658309f, -0.09709944f, -0.05852962f, -0.03880151f, -0.14302738f, 
    0.02100067f, 0.02364975f, -0.20252886f, -0.05181242f, 0.53533292f, 0.25661802f, -0.16576482f, -0.38828340f, 
    0.02895646f, -0.11562726f, 0.18609835f, -0.04909431f, -0.00244143f, -0.11706037f, 0.03296274f, 0.20412616f, 
    0.19951846f, 0.16573143f, 0.07259782f, 0.11062255f, 0.05470159f, -0.00653333f, -0.00987614f, 0.04499978f, 
    0.04316684f, 0.05079692f, -0.02031150f, 0.09049482f, -0.12046301f, -0.03370108f, -0.37786645f, -0.13501874f, 
    -0.11037470f, -0.06851873f, 0.07638861f, 0.01756924f, -0.03892427f, -0.09198409f, 0.06552087f, -0.13749728f, 
    -0.40090412f, 0.21338822f, -0.13224840f, -0.27262563f, 0.07641289f, 0.00455967f, -0.02157540f, 0.10201841f, 
    -0.10881925f, -0.09817444f, 0.08533350f, 0.01614263f, -0.18662100f, 0.07870638f, 0.10175122f, 0.03123846f, 
    0.11018555f, -0.16322774f, 0.05573492f, 0.20480821f, -0.05065227f, 0.03204810f, -0.03964367f, -0.13421692f, 
    -0.38919184f, 0.00495993f, -0.05783586f, 0.05456081f, 0.02636277f, 0.09642189f, -0.00780069f, -0.09940259f, 
    -0.07685368f, 0.02455307f, 0.08652744f, -0.07660592f, 0.16420758f, 0.31975114f, -0.16170801f, -0.22575957f, 
    0.10551241f, 0.01001374f, -0.16514212f, 0.19796318f, 0.10942337f, -0.09533108f, -0.13649641f, -0.04280657f, 
    0.27264878f, 0.03429724f, 0.17851719f, 0.30018139f, -0.17218660f, -0.08123812f, 0.00488970f, -0.03404797f, 
    -0.03500096f, -0.02297812f, -0.01608123f, -0.03760640f, -0.58533448f, -0.01824381f, 0.08966256f, 0.31029269f, 
    -0.07653609f, 0.05603687f, 0.04834636f, 0.09302755f, 0.04164757f, -0.10296545f, -0.01491623f, 0.00269181f, 
    -0.15167902f, 0.29881582f, -0.20499864f, -0.59830940f, 0.07142816f, 0.03268686f, -0.00088125f, 0.00709675f, 
    0.12681775f, -0.14991345f, -0.05237708f, -0.02787195f, 0.01392727f, 0.00798435f, -0.00267116f, -0.19899608f, 
    0.17406020f, 0.03000808f, 0.05936649f, 0.09034864f, 0.01322535f, -0.00743135f, 0.14442571f, -0.05238080f, 
    0.16106062f, -0.03501488f, 0.01307823f, 0.32909819f, 0.06835279f, -0.05287361f, 0.10168152f, 0.13515943f, 
    0.21351664f, -0.16049004f, -0.00906212f, -0.04413354f, -0.78920269f, 0.01104710f, 0.12120819f, 0.28375652f, 
    0.02424618f, -0.03536119f, -0.03650051f, 0.14764315f, -0.09778830f, 0.03767848f, 0.16868281f, 0.12505251f, 
    -0.46354410f, -0.02306804f, 0.22951137f, -0.12083352f, -0.01974861f, -0.01184487f, -0.06966858f, -0.02290532f, 
    0.12625751f, 0.00353398f, -0.00301260f, 0.02930787f, 0.03828213f, 0.16793112f, -0.30453566f, -0.07042219f, 
    -0.16285884f, -0.09816217f, 0.12284616f, -0.19206806f, -0.04567328f, -0.18211393f, 0.03096991f, 0.03195982f, 
    -0.16896196f, -0.18963683f, 0.03523329f, 0.30782491f, 0.05398617f, -0.09639894f, -0.00985087f, -0.01326396f, 
    0.12680772f, -0.03630000f, -0.07923786f, -0.06551027f, -0.44049978f, -0.10548493f, 0.15811831f, -0.01418761f, 
    -0.08543522f, 0.13833633f, 0.00760012f, 0.06460316f, 0.09570297f, 0.05605645f, -0.00907992f, -0.12258410f, 
    -0.13899119f, -0.09471313f, 0.30070111f, -0.05840776f, -0.00261825f, 0.00753878f, -0.21576476f, 0.04788464f, 
    0.00197048f, 0.17626788f, 0.03629735f, 0.22315803f, 0.22310948f, -0.16421939f, -0.04598032f, -0.30213895f, 
    -0.09676010f, 0.07326627f, 0.01450186f, 0.12412888f, -0.19094041f, -0.15777795f, -0.03230771f, -0.10870409f, 
    -0.15579264f, 0.16881827f, 0.02454278f, 0.18716997f, 0.08893312f, -0.06192908f, -0.07193016f, -0.05517270f, 
    0.17295615f, 0.02412352f, -0.17275882f, -0.09152824f, 0.28970456f, 0.02046071f, 0.09368579f, -0.16672264f, 
    -0.07984957f, -0.11525892f, -0.03000117f, -0.08242843f, -0.10322096f, 0.05364219f, -0.06307974f, 0.01007057f, 
    -0.19203725f, -0.25508237f, 0.13476722f, 0.47446379f, -0.03064538f, -0.03024741f, 0.05925856f, -0.11519387f, 
    0.01764078f, -0.15345323f, 0.02136975f, -0.01241065f, -0.39959583f, 0.23534246f, 0.08519322f, -0.54194427f, 
    0.19637351f, -0.08429907f, -0.11780030f, -0.21422789f, -0.08467817f, -0.02408950f, 0.02295872f, -0.06776539f, 
    0.01935718f, 0.00219671f, -0.09347700f, -0.50628662f, 0.00626511f, 0.10024595f, -0.04666220f, 0.11558276f, 
    0.00016519f, 0.13528842f, -0.03635168f, 0.04888823f, -0.15566261f, 0.22315001f, 0.26253822f, -0.07045126f, 
    -0.08971971f, -0.00667006f, 0.28310221f, -0.04963351f, 0.26638719f, 0.11006187f, -0.07351504f, 0.18433228f, 
    -0.52595627f, 0.26542425f, -0.05127655f, 0.02111203f, 0.09502323f, 0.06113531f, 0.08537921f, -0.18177962f, 
    0.05888703f, -0.19224763f, -0.14220122f, -0.13273013f, 0.04029707f, 0.01372262f, 0.26716974f, -0.31897643f, 
    -0.12965828f, 0.01652451f, -0.14491276f, 0.18037608f, 0.16040322f, 0.03486753f, -0.02987508f, -0.40762180f, 
    -0.40741384f, 0.30199680f, 0.16421930f, -0.12498583f, 0.03225097f, -0.18584949f, -0.16059606f, 0.01870115f, 
    -0.01174888f, -0.05979962f, -0.11618571f, -0.25666276f, 0.31701043f, -0.01738558f, -0.34922934f, -0.10529166f, 
    0.02530979f, -0.08857319f, 0.01831052f, -0.14547724f, -0.16631009f, 0.02582473f, -0.17413752f, 0.02920431f, 
    0.10500927f, -0.10859229f, 0.08044644f, -0.09467679f, -0.09729655f, -0.11791126f, -0.01204313f, -0.03456609f, 
    0.09030602f, 0.15868126f, -0.12604253f, 0.06796770f, 0.05032182f, 0.09166808f, 0.25726113f, 0.20006140f, 
    -0.15794963f, -0.19890101f, 0.12771906f, 0.03360678f, -0.09395161f, -0.08746219f, 0.11057997f, 0.13627210f, 
    0.22253205f, 0.08988144f, 0.16096599f, -0.22521286f, -0.08292928f, -0.07989775f, 0.11589180f, 0.00048903f, 
    0.04347065f, -0.14106898f, 0.09235727f, 0.21589531f, -0.26545966f, -0.39777946f, 0.36385131f, 0.15790258f, 
    -0.05730621f, -0.12374443f, 0.20355844f, 0.22855432f, -0.02317167f, 0.05737161f, -0.13748449f, -0.17085850f, 
    -0.71941036f, -0.29849622f, -0.17220604f, 0.06249063f, 0.05814159f, 0.15826811f, 0.03894431f, 0.03681310f, 
    0.01555720f, 0.16050614f, 0.17788365f, -0.07501455f, 0.16907094f, 0.08486965f, 0.20581716f, -0.15158440f, 
    0.24146584f, -0.01761798f, -0.14974339f, 0.03051815f, -0.05308474f, 0.27470192f, -0.02193224f, 0.06345623f, 
    0.00466147f, -0.15637866f, 0.19596271f, 0.06866503f, -0.14206719f, 0.09195352f, 0.02863580f, 0.01438658f, 
    -0.01363969f, 0.04809470f, 0.02023293f, 0.15527001f, -0.46978545f, -0.21720161f, -0.02774818f, -0.05648163f, 
    0.14363816f, 0.09583750f, -0.00022050f, 0.02013920f, 0.08297858f, -0.07468017f, -0.05961628f, 0.10457250f, 
    -0.49645168f, 0.28824246f, 0.01346246f, -0.25407013f, -0.00022242f, -0.01237708f, -0.05147200f, -0.09452792f, 
    0.05716284f, 0.07945789f, 0.03058495f, -0.05821105f, -0.22305796f, -0.11609673f, -0.12317210f, 0.13900720f, 
    0.02436284f, -0.27083665f, -0.11447096f, -0.12415337f, 0.00235491f, -0.02924897f, 0.00824225f, 0.08752057f, 
    0.02334171f, -0.08344451f, 0.08505694f, 0.04801527f, 0.03338093f, -0.00953157f, 0.13079177f, -0.03887669f, 
    0.04517468f, -0.01681600f, 0.14014223f, 0.25675979f, -0.15593955f, -0.22305943f, -0.31284556f, -0.06685727f, 
    0.16839015f, 0.16585888f, 0.02454077f, -0.03072566f, 0.07837502f, -0.10765389f, -0.02455404f, -0.26130649f, 
    -0.32697147f, -0.12157968f, 0.18336926f, -0.17406638f, 0.03117877f, 0.00443292f, 0.13738924f, 0.05025830f, 
    0.01275926f, 0.13895659f, -0.03962521f, 0.05944544f, -0.05588970f, 0.20962685f, 0.13533723f, 0.20949450f, 
    -0.22368222f, 0.14985333f, -0.07517402f, -0.21081534f, -0.02867437f, -0.03973853f, -0.09222043f, 0.02284236f, 
    -0.23604970f, -0.25748405f, -0.06401031f, 0.19674514f, 0.19963528f, -0.16507451f, -0.28485724f, 0.05892406f, 
    0.11356019f, 0.23204924f, 0.32127318f, 0.18430914f, -0.14342153f, -0.02847289f, -0.54675239f, -0.08419018f, 
    0.12446944f, 0.04576964f, -0.27149123f, -0.06712871f, -0.00008155f, -0.01008490f, -0.14952382f, 0.01980274f, 
    0.10760108f, 0.04944548f, -0.00886160f, -0.09784792f, -0.09833286f, 0.08334419f, 0.05055364f, 0.07046512f, 
    -0.05767538f, 0.01511321f, 0.14973754f, 0.00297068f, -0.49101597f, 0.00076142f, 0.24583022f, 0.31071982f, 
    0.00379679f, 0.08549852f, -0.00862823f, -0.02955850f, 0.20785302f, 0.03799957f, 0.04042608f, 0.06990273f, 
    -0.05018832f, -0.22344485f, -0.24137771f, -0.22026610f, 0.00105100f, 0.12359054f, -0.04525972f, -0.00160558f, 
    0.19556330f, -0.08752982f, 0.12425573f, -0.05423848f, -0.11646793f, -0.04180775f, 0.19537891f, 0.25191823f, 
    -0.11168343f, -0.06219291f, 0.07595142f, -0.01139412f, -0.16168821f, -0.08146081f, -0.02996267f, 0.09738147f, 
    0.01200582f, 0.17398140f, -0.05885769f, 0.06685228f, 0.04719801f, -0.12421075f, -0.00130938f, 0.06785814f, 
    0.11143307f, -0.16094127f, 0.10422343f, 0.11667604f, -0.25720194f, -0.02856764f, -0.11518944f, 0.18006703f, 
    -0.01362740f, -0.14284298f, 0.12631951f, 0.17166580f, 0.16238308f, 0.05375051f, -0.14808674f, 0.07186720f, 
    0.22994606f, -0.18228976f, -0.31550694f, 0.43550813f, 0.01568954f, 0.12469196f, -0.08949150f, 0.17011346f, 
    0.02459139f, 0.01709992f, -0.01909324f, 0.12588046f, -0.43759936f, 0.05915834f, 0.01754967f, 0.28751418f, 
    0.06491646f, 0.09797355f, 0.13129604f, 0.02728884f, -0.02834226f, 0.00172395f, -0.01472701f, 0.06637743f, 
    0.10350715f, -0.02038061f, 0.10287718f, -0.13826421f, -0.01623014f, -0.07275262f, -0.06679837f, -0.00438347f, 
    -0.16450752f, 0.31872243f, -0.27086848f, -0.04307356f, 0.54449439f, -0.23243354f, 0.02662053f, -0.14836553f, 
    -0.09876690f, 0.05316159f, 0.11380988f, 0.11024518f, 0.15757978f, -0.03273483f, 0.22208641f, 0.02556967f, 
    0.36000630f, 0.28587753f, 0.13346595f, -0.33182478f, 0.04004524f, 0.08263218f, 0.09287552f, -0.00182515f, 
    0.00731445f, -0.11129152f, -0.19822058f, 0.05166019f, 0.03057634f, -0.15064412f, 0.00853855f, -0.30248359f, 
    0.10711024f, 0.02451049f, -0.04413444f, 0.09002820f, -0.02599568f, 0.01349602f, -0.08721865f, -0.15058254f, 
    0.46318790f, -0.29418993f, 0.23932031f, -0.21107411f, -0.02299451f, 0.13290243f, 0.05473284f, -0.08422208f, 
    0.04173015f, -0.00201906f, 0.23922807f, 0.07828699f, 0.09383260f, 0.08562678f, 0.01914243f, -0.26210162f, 
    -0.12938535f, -0.06620346f, -0.00648283f, 0.03011967f, -0.12869467f, 0.09312058f, 0.24276799f, 0.18113458f, 
    0.42677918f, -0.42950758f, 0.13719454f, -0.13137123f, -0.14173025f, 0.04976601f, 0.04240257f, -0.09908016f, 
    -0.07563217f, 0.11190692f, 0.10217857f, 0.12002717f, -0.53660071f, -0.02847257f, -0.05880751f, 0.38656592f, 
    0.10322404f, 0.09872766f, 0.09969199f, 0.07972915f, 0.00210673f, -0.01674731f, 0.18088420f, -0.05400658f, 
    -0.22958471f, 0.24045388f, -0.43208942f, -0.00651033f, -0.03709157f, 0.09724598f, 0.07746119f, 0.03710149f, 
    -0.14923018f, -0.26775464f, 0.04040343f, -0.07547864f, -0.10581801f, -0.17455560f, -0.02627179f, 0.08715082f, 
    0.02215084f, 0.15851276f, -0.03446050f, -0.06380720f, -0.04292621f, -0.18330126f, -0.07214357f, 0.15080857f, 
    0.18755253f, 0.20251556f, 0.00913654f, -0.06828915f, -0.05594800f, 0.02680300f, 0.15192780f, 0.00911923f, 
    -0.08532640f, 0.08369793f, 0.09983454f, -0.18003383f, 0.18224987f, -0.09873043f, 0.09850216f, 0.23494580f, 
    0.08526357f, -0.01215826f, -0.15946285f, -0.08784438f, -0.07987813f, 0.16753326f, 0.08843797f, 0.28418249f, 
    -0.07045356f, 0.12572601f, 0.00963483f, 0.11275406f, -0.14879143f, 0.06878550f, -0.09650102f, -0.08546354f, 
    -0.11420736f, 0.05535154f, -0.04047177f, -0.02454961f, 0.01612042f, -0.25162098f, 0.20910437f, 0.06726003f, 
    0.02072579f, 0.12464909f, 0.01680014f, 0.01941243f, 0.21431592f, -0.17145137f, 0.07875875f, -0.07500659f, 
    0.09610000f, -0.20128039f, -0.10810744f, -0.16903289f, -0.08625036f, 0.08546636f, 0.04564537f, -0.04424893f, 
    0.18643934f, -0.09453022f, -0.06864479f, -0.13701440f, -0.21640146f, 0.10669823f, -0.04744815f, -0.31224769f, 
    -0.06170673f, -0.01670770f, 0.06430557f, 0.03547774f, 0.11733780f, 0.10500346f, 0.01582307f, -0.09071310f, 
    -0.13377677f, -0.38764194f, -0.12000336f, 0.02065456f, -0.00047333f, 0.11754397f, 0.12823908f, -0.08251908f, 
    0.01870736f, 0.03271286f, -0.09015907f, -0.00254912f, 0.37069401f, -0.36119834f, 0.11279561f, 0.14141637f, 
    -0.10428216f, -0.00165861f, 0.12904021f, 0.03364812f, -0.14686820f, -0.08731803f, 0.00728394f, -0.06028965f, 
    -0.07692771f, 0.35881612f, 0.06970453f, -0.57384378f, -0.18929176f, 0.17338483f, -0.04111031f, -0.00691845f, 
    0.07397046f, -0.01021490f, -0.00057901f, -0.09433881f, -0.26570103f, -0.30303776f, -0.20212144f, -0.35652801f, 
    -0.00614380f, -0.00592967f, -0.06833494f, -0.12899770f, -0.12961768f, -0.01973429f, 0.12256181f, 0.22376826f, 
    0.19784562f, -0.15114585f, -0.19306836f, 0.08298060f, -0.02755432f, 0.10788193f, -0.08733111f, -0.06245502f, 
    0.01651961f, -0.05437062f, -0.10972805f, -0.01689672f, 0.07280105f, 0.14207572f, 0.22454447f, -0.02664277f, 
    -0.08632581f, -0.03043197f, 0.09857494f, 0.17160894f, -0.04958673f, 0.11943390f, 0.05196447f, 0.14184211f, 
    -0.20405559f, 0.15489267f, -0.08611590f, -0.45441085f, -0.07056949f, -0.04111306f, -0.03683641f, -0.03759171f, 
    -0.04659007f, -0.19531408f, -0.05188900f, -0.07817440f, -0.36080262f, -0.31566226f, -0.02597038f, -0.23011565f, 
    0.09804189f, 0.01607413f, -0.01522161f, -0.20041853f, 0.15795766f, -0.04802065f, 0.11283765f, 0.19031668f, 
    -0.42483103f, 0.27638030f, 0.14270957f, 0.42970222f, -0.02920798f, -0.05656748f, -0.02548493f, 0.04019509f, 
    0.04550385f, 0.08071310f, -0.12017342f, -0.24716541f, -0.28327000f, -0.13420261f, 0.11506010f, 0.40064457f, 
    0.00761358f, -0.13049668f, -0.01119385f, 0.08155049f, -0.11445587f, 0.00439887f, -0.13563043f, -0.08050539f, 
    -0.24194285f, 0.06259391f, -0.35396832f, 0.11700843f, 0.00544643f, 0.08745805f, -0.03097006f, -0.12318639f, 
    -0.10059776f, 0.06419582f, -0.04787340f, -0.00547151f, -0.00526895f, 0.21770701f, 0.14681551f, -0.34464097f, 
    0.18612206f, -0.09886898f, 0.01801071f, 0.05293611f, 0.08287541f, 0.05546495f, 0.05330636f, -0.07927456f, 
    0.03151989f, -0.27296188f, -0.27430713f, -0.15132068f, 0.15186739f, 0.03976630f, -0.12456404f, -0.04357279f, 
    -0.08326792f, 0.11768351f, 0.13595949f, -0.01464875f, -0.36011273f, 0.05147522f, -0.16565457f, 0.11807451f, 
    0.01016588f, -0.08321986f, -0.15916143f, -0.18014325f, -0.17256792f, -0.12533921f, 0.12956879f, -0.27749580f, 
    -0.26460421f, 0.06285130f, -0.10249219f, 0.14079720f, -0.23189062f, -0.03975472f, -0.13619497f, -0.00258881f, 
    -0.03501600f, -0.01788704f, 0.10269164f, -0.02327923f, -0.02104446f, -0.16115314f, -0.10239063f, -0.05736059f, 
    -0.02789565f, -0.00013926f, -0.08804952f, -0.01403387f, 0.01458752f, -0.04872778f, -0.06508766f, -0.01346502f, 
    -0.10503848f, 0.13808373f, 0.04509043f, 0.18288907f, 0.17547078f, -0.12522541f, -0.00695611f, -0.07018370f, 
    -0.04860893f, 0.09468690f, 0.14680533f, -0.07268728f, 0.08678742f, -0.22282612f, -0.01429921f, -0.28092194f, 
    -0.14139391f, 0.03760582f, -0.06935121f, -0.08409290f, 0.03254106f, 0.04339709f, -0.02068587f, -0.02526437f, 
    0.20933014f, -0.04568773f, 0.01914926f, -0.09765575f, -0.01419867f, -0.05806110f, -0.01822196f, -0.07208510f, 
    -0.00805322f, -0.03221455f, -0.07695970f, -0.08529711f, -0.10420211f, -0.14193632f, -0.06195475f, -0.10283001f, 
    -0.20316628f, 0.04821777f, -0.06469701f, -0.12971453f, 0.01928381f, 0.01844944f, 0.09426317f, -0.10681116f, 
    -0.04325465f, 0.37138557f, 0.27235574f, 0.08338361f, 0.18525776f, 0.02127442f, -0.06034230f, 0.03727810f, 
    -0.18718946f, 0.09690937f, 0.12628940f, 0.04472511f, -0.23789933f, 0.04555619f, -0.16665240f, -0.25703633f, 
    0.05058514f, -0.00567430f, -0.01318856f, -0.09169870f, -0.02308778f, -0.15289143f, -0.14112546f, -0.12868175f, 
    0.17754929f, 0.11359557f, -0.12176192f, -0.21192044f, -0.09790125f, 0.03838390f, 0.01713008f, -0.02753644f, 
    -0.07893584f, 0.02212536f, -0.08125340f, 0.00241530f, -0.29221451f, 0.15704471f, -0.25690624f, 0.02961219f, 
    -0.16771005f, 0.02184057f, -0.01105061f, -0.10021297f, 0.01527563f, -0.04130941f, 0.07747524f, -0.08479962f, 
    0.07176348f, 0.27785268f, -0.13609351f, 0.13149950f, 0.09242561f, -0.00799037f, -0.05158220f, -0.06024952f, 
    0.02918399f, 0.03080712f, -0.04151515f, -0.09146516f, 0.14719713f, 0.00419347f, -0.09273839f, 0.22286376f, 
    -0.14445549f, -0.16847999f, -0.10452740f, -0.11067005f, -0.07559709f, 0.04754291f, -0.12984057f, -0.05525992f, 
    0.11135557f, -0.37583360f, -0.11150002f, -0.04569111f, -0.16084804f, -0.06278386f, 0.04606191f, -0.01427128f, 
    0.03793842f, 0.00129004f, 0.01201560f, -0.09189364f, -0.11343168f, 0.21071462f, 0.11044692f, 0.09188647f, 
    0.06542572f, -0.00113267f, -0.05699868f, -0.04016494f, -0.11215185f, -0.07514998f, -0.06540063f, 0.00321304f, 
    -0.02756979f, 0.23311961f, -0.00154437f, 0.19517548f, 0.09104952f, -0.00823315f, 0.03959683f, -0.01821033f, 
    0.01997178f, -0.00238768f, -0.03330398f, -0.09032698f, 0.10204387f, 0.08684146f, 0.07373810f, 0.07090352f, 
    -0.13381109f, 0.03992893f, -0.03853786f, 0.00298257f, -0.03719462f, -0.24222676f, -0.04195579f, 0.01358985f, 
    -0.48665777f, 0.24941085f, -0.25798962f, -0.06274443f, -0.09002746f, -0.06259764f, 0.09210975f, -0.08507061f, 
    -0.09259957f, 0.04612064f, -0.02960147f, -0.09761516f, 0.29013699f, 0.02473121f, 0.29151529f, -0.02613985f, 
    -0.01281731f, 0.08389997f, -0.00057256f, -0.08705855f, 0.01473499f, 0.11916581f, -0.11757122f, 0.00969847f, 
    -0.29297808f, 0.06966121f, 0.18409891f, -0.07680174f, -0.00497571f, -0.06078032f, -0.00148648f, -0.01213188f, 
    -0.05850009f, -0.03297909f, 0.00191981f, -0.07597938f, 0.26924729f, 0.10685717f, -0.00375078f, 0.04157043f, 
    0.20080519f, 0.05108488f, 0.03229715f, -0.10713492f, 0.03947917f, 0.01225010f, -0.03813770f, -0.04153210f, 
    -0.68640649f, 0.20356032f, 0.02386274f, -0.00269171f, 0.02226331f, 0.00240276f, -0.08292162f, -0.02206487f, 
    -0.10762060f, 0.02529920f, 0.11047858f, -0.02574844f, 0.08643395f, 0.10536633f, 0.16368198f, 0.15214495f, 
    0.16841146f, 0.19505413f, 0.17591882f, 0.04069695f, -0.01473572f, 0.10289622f, 0.06969112f, 0.03823925f, 
    -0.38384432f, 0.12516883f, 0.13044572f, -0.13834822f, -0.02868706f, 0.02496153f, -0.03983188f, -0.14114845f, 
    -0.15033391f, -0.07642034f, 0.01606964f, -0.10183714f, 0.18261011f, -0.09214723f, -0.03335886f, 0.15011664f, 
    -0.20561381f, 0.03380381f, 0.02514539f, -0.05412646f, -0.00257335f, -0.04473299f, -0.05296163f, -0.06783908f, 
    -0.01629427f, 0.23713392f, 0.02346525f, 0.18658464f, 0.02332984f, -0.02396107f, -0.06783970f, -0.08705685f, 
    -0.04473282f, -0.12426837f, -0.18039575f, -0.06205170f, 0.23866811f, 0.21158786f, 0.27596113f, 0.13500528f, 
    0.07061421f, 0.09717366f, 0.09111490f, -0.08607117f, 0.01174828f, 0.13159457f, -0.09739032f, -0.07902079f, 
    -0.14479996f, -0.30436346f, -0.36025101f, -0.20120186f, 0.05894284f, 0.00155108f, -0.02810176f, -0.02066691f, 
    -0.00785203f, -0.04470590f, -0.04217157f, -0.06912351f, -0.09770996f, -0.42845282f, 0.24243434f, 0.19820483f, 
    0.01632246f, -0.13538922f, -0.09568688f, -0.01358578f, -0.10174747f, -0.04802258f, -0.17777210f, -0.04793206f, 
    -0.21222651f, 0.26421195f, -0.08624443f, 0.15895101f, 0.05979162f, 0.06161531f, -0.06417606f, 0.00178021f, 
    0.04943339f, 0.00289869f, -0.00511801f, -0.07426590f, -0.00700226f, -0.41699907f, -0.22934479f, -0.08042476f, 
    -0.12772222f, 0.00129035f, -0.06068530f, -0.02098274f, -0.03765304f, -0.03685937f, -0.03014576f, 0.04300447f, 
    0.18472128f, -0.04569917f, 0.27717733f, 0.15268190f, -0.03213590f, 0.01538216f, 0.04522852f, -0.09045266f, 
    -0.11177940f, 0.16102716f, -0.16508797f, -0.07643219f, 0.17240819f, 0.06734025f, 0.03727818f, 0.34166560f, 
    0.18636914f, 0.13816956f, 0.07682683f, -0.00878182f, -0.03938987f, -0.10697705f, -0.04120778f, -0.11845422f, 
    0.18016948f, 0.49760750f, -0.46575183f, -0.24086116f, 0.04376086f, -0.00402409f, -0.10801265f, -0.08295372f, 
    0.10496343f, 0.04883502f, -0.16499218f, 0.06522178f, 0.42321649f, 0.09504534f, -0.11191578f, 0.06963395f, 
    0.00664718f, -0.05880626f, -0.04799646f, -0.10542627f, 0.04906008f, 0.01824549f, -0.19561988f, 0.01687921f, 
    -0.23214817f, -0.12226815f, -0.05367974f, -0.28419229f, -0.02103150f, -0.01345132f, -0.23990630f, 0.04082072f, 
    0.03512267f, 0.00384039f, 0.11755597f, 0.01411305f, -0.26431161f, -0.02358146f, 0.12660129f, -0.01242504f, 
    -0.06006979f, -0.06250146f, 0.03547205f, -0.22967069f, -0.00292346f, -0.08258990f, -0.05716204f, 0.16765195f, 
    -0.24731971f, -0.07576250f, -0.12148613f, -0.13935097f, -0.08268988f, -0.20293903f, -0.00211862f, 0.04636047f, 
    0.18268867f, 0.12365052f, 0.00902088f, -0.01324557f, 0.12471965f, 0.04122169f, 0.10866878f, 0.21058232f, 
    -0.00186820f, 0.03752918f, 0.04474344f, -0.13927591f, -0.05585914f, -0.00207009f, 0.06495849f, 0.04036715f, 
    -0.05609221f, -0.63965142f, 0.19584127f, -0.15349720f, -0.09286930f, -0.28463522f, -0.06945690f, -0.07696263f, 
    0.07136467f, -0.06619873f, -0.20990734f, 0.07804995f, 0.20177065f, -0.04229251f, -0.05094998f, 0.23520222f, 
    0.01224262f, -0.04644362f, 0.02841375f, 0.00390595f, -0.00426187f, -0.11501368f, -0.21843706f, -0.25899860f, 
    0.15013362f, -0.11577635f, 0.10290217f, 0.10234410f, 0.09205069f, -0.13684957f, -0.03588951f, -0.02659409f, 
    0.11154387f, -0.11093242f, -0.01048717f, -0.13392814f, 0.14393790f, 0.31222242f, -0.22761980f, 0.03484184f, 
    -0.06628789f, 0.00893765f, -0.24466042f, 0.10462089f, -0.03356415f, -0.04066075f, -0.11367916f, -0.14726032f, 
    -0.32129446f, -0.15654524f, -0.02679427f, -0.34278092f, -0.14912590f, -0.06786825f, 0.04470977f, 0.05495737f, 
    0.12699191f, 0.14720196f, -0.11625476f, -0.07579523f, 0.05987227f, -0.00727956f, -0.31600049f, -0.41238365f, 
    -0.07954971f, -0.16545020f, 0.15917248f, 0.10468836f, 0.07629446f, 0.02230409f, 0.04427905f, 0.02073384f, 
    0.06337263f, -0.26309082f, -0.18203768f, 0.02027818f, -0.01091947f, -0.10189103f, 0.05846153f, -0.07412815f, 
    0.03074860f, 0.04430441f, 0.13506570f, 0.15134157f, -0.06852930f, -0.15876284f, -0.16150284f, -0.34758195f, 
    0.15244861f, -0.01618353f, -0.17114069f, -0.09358142f, 0.09212304f, 0.01706897f, 0.02985960f, -0.04910891f, 
    0.16298893f, 0.01304470f, 0.16150385f, 0.03427537f, -0.09925623f, 0.03348317f, -0.04292770f, -0.04989536f, 
    -0.02833072f, 0.05865403f, 0.12313114f, -0.04472370f, 0.33693576f, -0.01716061f, 0.06233058f, 0.14095894f, 
    0.07132186f, -0.02209506f, -0.02093164f, 0.00006316f, -0.07732379f, 0.13343787f, -0.00658661f, -0.03684690f, 
    0.11091902f, -0.18782894f, -0.00095942f, 0.20122343f, -0.00430307f, -0.02657952f, -0.12979861f, -0.01185695f, 
    0.09568448f, 0.10914766f, 0.12031718f, -0.05225298f, -0.38421476f, 0.23437928f, 0.05746878f, -0.23601097f, 
    0.15404400f, -0.06051666f, 0.03215810f, 0.01237955f, 0.02260542f, -0.01052890f, 0.01541382f, 0.15247202f, 
    0.06157758f, 0.00805200f, 0.02967890f, 0.21198712f, -0.28613594f, -0.04268172f, -0.06877730f, 0.07220557f, 
    0.06866674f, -0.14409946f, 0.01400839f, -0.03576352f, 0.23210815f, -0.27528763f, 0.07909378f, 0.08846624f, 
    -0.04255067f, -0.06932443f, 0.10993721f, 0.11062708f, 0.05977264f, -0.06856135f, 0.05771677f, 0.10106215f, 
    -0.23547685f, -0.18385689f, -0.07260106f, 0.30423665f, 0.15654236f, 0.09203847f, -0.05754327f, -0.05786411f, 
    0.03261222f, 0.01868347f, -0.02456925f, -0.04269484f, -0.19970754f, -0.05094874f, 0.28197134f, 0.06016423f, 
    -0.15138195f, -0.00093914f, 0.14806138f, -0.07603423f, 0.02231246f, -0.04916621f, -0.16913895f, -0.20760816f, 
    -0.17700146f, -0.15881813f, 0.18147445f, 0.08453328f, -0.15497090f, -0.17811626f, -0.03896070f, -0.01294105f, 
    0.03737471f, 0.06893285f, -0.13431163f, 0.05170534f, 0.02536640f, 0.01793057f, 0.11796623f, 0.11236274f, 
    0.09370746f, -0.12463190f, -0.09938687f, -0.17922144f, 0.00144869f, 0.11332223f, 0.02812314f, -0.08157521f, 
    -0.41067314f, 0.19518958f, -0.03710510f, -0.33456466f, -0.26507583f, -0.14036570f, -0.13544644f, -0.02086623f, 
    0.01340287f, 0.01557414f, 0.07863762f, -0.01052016f, -0.23876518f, 0.11171969f, 0.10636578f, -0.01777608f, 
    -0.05668304f, -0.07395344f, -0.01027525f, -0.06703652f, -0.02283346f, -0.09475311f, -0.18939330f, -0.10964800f, 
    0.19203772f, 0.02405900f, -0.34880409f, 0.07360084f, 0.16316895f, 0.12020863f, -0.04927975f, -0.12800528f, 
    0.08852739f, 0.05801590f, 0.10969138f, -0.00164884f, 0.15862200f, 0.18336965f, -0.18558259f, 0.01640046f, 
    -0.09449894f, -0.04789201f, -0.26636547f, -0.18131228f, -0.05818079f, 0.11994757f, 0.05880007f, 0.05207425f, 
    -0.21685955f, 0.29502505f, -0.06356263f, 0.13113309f, -0.14900295f, 0.16614141f, -0.14543158f, 0.00360063f, 
    -0.04501110f, -0.09873980f, 0.18988794f, 0.04515561f, 0.03603708f, -0.17348875f, -0.50041610f, 0.23304468f, 
    0.26205754f, 0.04451289f, 0.00892271f, -0.13757618f, -0.04782420f, -0.00067899f, 0.01245359f, 0.17589571f, 
    -0.05596583f, -0.36655667f, -0.18940662f, -0.02265682f, -0.00310438f, -0.03368724f, 0.18731512f, -0.07593333f, 
    0.08924089f, -0.22556521f, -0.02339248f, 0.06779318f, 0.09205333f, 0.10176931f, 0.11519472f, -0.22601710f, 
    0.13478473f, 0.06605534f, 0.23400131f, 0.15966108f, -0.02303704f, -0.08838032f, 0.11217161f, 0.12155092f, 
    -0.04365357f, 0.18930472f, 0.51913512f, 0.05841024f, -0.02658563f, -0.02387788f, -0.11474162f, -0.00773644f, 
    0.03869964f, -0.02118384f, 0.11229231f, 0.10669848f, 0.06703618f, -0.48788199f, 0.01977316f, 0.04243661f, 
    0.16156466f, -0.16108048f, -0.09698132f, 0.10475659f, 0.12800962f, -0.00692798f, 0.23246409f, -0.07284246f, 
    -0.17545934f, -0.50949103f, -0.02654332f, 0.09642843f, -0.10330607f, -0.01470657f, 0.02384200f, 0.13122062f, 
    -0.04789422f, -0.01644349f, 0.23980971f, 0.06671171f, -0.07141713f, 0.09405145f, -0.12811476f, 0.19799693f, 
    -0.02268169f, -0.01410805f, -0.06226372f, 0.15652871f, 0.09625707f, 0.06551180f, 0.14122716f, -0.04913414f, 
    -0.18215504f, -0.02070430f, 0.07716322f, -0.15426347f, 0.00522970f, -0.16841283f, 0.20574020f, 0.00408032f, 
    0.06206527f, -0.10844429f, 0.10231496f, -0.12356813f, 0.16106254f, 0.23620671f, -0.14574088f, -0.11797412f, 
    0.22156397f, 0.00855640f, -0.00294253f, -0.08459403f, -0.04941803f, -0.19018310f, -0.00868678f, 0.04789786f, 
    -0.09755537f, -0.11738762f, -0.26086810f, 0.15729173f, -0.13082726f, 0.08554216f, 0.04136990f, -0.05878573f, 
    0.06325576f, 0.06258735f, 0.06484246f, -0.09459967f, -0.35015294f, 0.13973859f, -0.26573604f, -0.21742871f, 
    0.13530408f, 0.08193054f, 0.10337117f, -0.22284982f, -0.09860794f, -0.04641384f, -0.06940765f, 0.04413535f, 
    -0.04314265f, -0.00900805f, 0.00876892f, -0.26681229f, 0.04788772f, -0.01820612f, 0.11903113f, -0.09177369f, 
    0.08351488f, -0.06056608f, 0.08193339f, 0.25535044f, -0.29339802f, 0.53265339f, 0.40877599f, 0.10352782f, 
    0.16170229f, 0.08709235f, -0.00630484f, 0.12902960f, 0.11972616f, 0.11595487f, 0.09998094f, 0.00252151f, 
    -0.35956302f, 0.04315167f, 0.21309744f, -0.25586024f, 0.00435705f, 0.08280242f, 0.03404718f, -0.19566020f, 
    -0.16501443f, 0.02506441f, -0.03332583f, -0.04174891f, -0.20116015f, 0.20352699f, -0.27381584f, -0.26252151f, 
    -0.02635040f, 0.06048642f, 0.06026009f, -0.06778497f, -0.13114053f, 0.04242977f, -0.07149912f, -0.12126192f, 
    0.00693190f, 0.18075392f, 0.01484916f, -0.35199797f, -0.00212826f, -0.02071880f, -0.08266184f, 0.07167937f, 
    0.00576913f, -0.03113916f, 0.10170395f, -0.22163323f, -0.35252514f, -0.54337114f, -0.09051179f, 0.37254301f, 
    0.00701870f, 0.03020501f, -0.06769625f, 0.13376042f, 0.00719540f, -0.16127180f, 0.11694036f, -0.09495429f, 
    -0.46450964f, -0.30158260f, 0.19802202f, -0.09262192f, 0.08929498f, -0.01529872f, -0.00064486f, -0.06316213f, 
    0.10047013f, -0.15227190f, -0.05483769f, 0.06682720f, 0.06809464f, -0.17320718f, 0.04561823f, -0.07968193f, 
    0.01787821f, -0.00549465f, -0.01176483f, -0.25097430f, -0.14963168f, 0.00297172f, -0.16749255f, -0.12124953f, 
    -0.29692760f, 0.61445528f, -0.45677060f, -0.43411988f, 0.12797858f, -0.07682812f, -0.11183866f, 0.14283498f, 
    -0.03438715f, 0.04008303f, -0.08058358f, -0.08169422f, -0.21138185f, -0.20414694f, -0.22709592f, 0.24365872f, 
    -0.06221681f, 0.12706050f, 0.10498470f, -0.13873819f, -0.05564555f, 0.10587013f, -0.13676995f, -0.04718872f, 
    0.08498917f, -0.27880654f, -0.03574577f, 0.01738211f, 0.09238721f, -0.07823547f, -0.01558148f, 0.01092406f, 
    0.07468725f, -0.08787789f, 0.11107685f, 0.07187975f, -0.08639298f, -0.04715484f, 0.08145408f, -0.11687615f, 
    0.14450358f, 0.02809071f, -0.01017051f, -0.30943030f, -0.00647607f, 0.06286718f, -0.01585392f, 0.05234739f, 
    -0.49681625f, 0.24869412f, -0.35958335f, -0.29070055f, 0.02881273f, 0.01807541f, 0.09600981f, -0.02131591f, 
    -0.23135544f, 0.03085181f, -0.06552910f, -0.04780686f, 0.30385253f, -0.23937044f, 0.06263578f, -0.13200635f, 
    0.06092309f, -0.01439624f, -0.12471821f, 0.14913063f, -0.11093651f, 0.08375582f, -0.00177266f, 0.09138242f, 
    0.04835927f, 0.12783746f, -0.07977691f, 0.42733791f, 0.07134566f, -0.08939388f, -0.03701232f, 0.06737792f, 
    0.02168900f, 0.01557389f, 0.02246631f, -0.09124411f, 0.28350711f, -0.15482041f, -0.03608437f, -0.02833323f, 
    0.17508909f, -0.03436640f, 0.10951828f, 0.05282320f, 0.02919617f, -0.14452218f, 0.02638897f, 0.16664989f, 
    -0.11851607f, -0.22573473f, -0.13940041f, 0.11528154f, 0.07866880f, 0.21308906f, -0.01930315f, 0.00071911f, 
    -0.12864515f, -0.09112266f, -0.16848819f, 0.00279717f, 0.11242007f, -0.16214725f, -0.07759463f, -0.02598160f, 
    -0.01769122f, 0.02115394f, 0.10154109f, 0.20646380f, -0.12968324f, 0.04563528f, 0.07103061f, -0.03824034f, 
    0.32676849f, -0.06970174f, 0.24628669f, 0.00240632f, 0.10298476f, 0.09767899f, -0.04277871f, 0.06686942f, 
    -0.13357034f, 0.02315325f, 0.02370916f, -0.02835460f, 0.73018175f, -0.78165597f, -0.37077233f, -0.18149486f, 
    0.00410717f, -0.11025478f, 0.08889908f, 0.20105863f, -0.18363464f, -0.02571203f, -0.00489656f, -0.08931641f, 
    -0.26929060f, 0.04414738f, 0.28118429f, -0.05113827f, 0.08773877f, 0.09774847f, -0.03656077f, 0.23198852f, 
    0.00806633f, 0.11070518f, -0.18305191f, 0.11133254f, -0.28042692f, 0.10027821f, 0.01970105f, -0.25700837f, 
    0.03764082f, 0.01773573f, -0.11745711f, 0.09228925f, 0.04298250f, -0.06873545f, -0.06256709f, 0.04189528f, 
    -0.11295231f, 0.27269515f, -0.09866683f, -0.16161183f, -0.11918341f, -0.12036578f, 0.14797784f, 0.10467716f, 
    -0.14143403f, 0.27646378f, -0.12265894f, 0.00427025f, 0.61137086f, -0.08175345f, 0.22505930f, -0.14238909f, 
    -0.09232655f, -0.08546413f, 0.06512876f, -0.24034151f, -0.13378279f, 0.15452130f, -0.10074835f, 0.13491610f, 
    -0.52484757f, -0.24326771f, 0.05167101f, -0.07464750f, 0.13695996f, 0.08662453f, 0.02891163f, -0.11388317f, 
    0.13245699f, -0.05391711f, -0.10285939f, -0.00982971f, -0.51466578f, 0.15241443f, 0.01672698f, -0.12055594f, 
    0.06108464f, 0.08319990f, -0.06548363f, -0.09802316f, 0.00532101f, -0.04895632f, -0.25841999f, -0.05296481f, 
    -0.09058200f, -0.05915979f, -0.01835310f, 0.01937373f, -0.04405113f, 0.16901989f, 0.01821765f, -0.08133362f, 
    -0.06622168f, -0.15371385f, 0.13494614f, -0.04423829f, 0.30679694f, -0.07396936f, -0.16633552f, 0.09990766f, 
    0.08216326f, -0.16494091f, -0.21555801f, -0.01448537f, -0.16046867f, -0.20947511f, -0.30366823f, -0.07872862f, 
    0.17926039f, 0.20667207f, 0.12956689f, -0.01726237f, 0.04138501f, -0.03108955f, -0.00055153f, 0.10224465f, 
    -0.01105895f, 0.11246863f, 0.17823716f, 0.08618755f, -0.05672536f, -0.33253357f, -0.02765602f, -0.19478698f, 
    -0.04998002f, -0.06799928f, 0.00612616f, 0.13866109f, -0.00164950f, 0.25967121f, -0.05442308f, -0.00002204f, 
    0.19754086f, 0.11368636f, -0.08716311f, 0.27429998f, -0.10175599f, -0.22064912f, 0.05292189f, -0.10590552f, 
    -0.06233916f, 0.01912697f, -0.06757573f, 0.09911313f, -0.07375155f, -0.16478080f, -0.13236871f, -0.04156457f, 
    0.10462446f, -0.06485566f, -0.01460346f, 0.12017349f, 0.07463643f, 0.04498231f, 0.04934201f, 0.17012735f, 
    0.19687313f, -0.32293993f, -0.14431226f, -0.04995904f, 0.07988685f, -0.09866833f, -0.10472335f, 0.06757724f, 
    0.05613953f, -0.11296296f, -0.19094512f, -0.10758023f, -0.36655107f, -0.48883176f, 0.06862188f, -0.06564283f, 
    -0.05150586f, 0.02627372f, 0.07813124f, 0.01147190f, 0.12658003f, -0.07666036f, -0.10842831f, 0.02377290f, 
    0.04200268f, -0.05254420f, 0.18005919f, 0.10723436f, 0.23036452f, -0.01125536f, 0.03093436f, 0.08929909f, 
    0.07730325f, -0.00756754f, -0.13383131f, 0.09134807f, 0.33035645f, 0.36962965f, 0.16962740f, -0.07616237f, 
    0.10870223f, 0.12962069f, 0.04318171f, 0.00668358f, -0.02042481f, 0.13963415f, 0.07882758f, -0.00449285f, 
    0.05482358f, 0.13685001f, -0.21102843f, 0.04297702f, 0.01526024f, 0.02520989f, 0.02150489f, 0.01878269f, 
    0.01094282f, -0.01086692f, 0.05247061f, 0.08338814f, -0.13908751f, -0.19765598f, -0.20325753f, 0.00428308f, 
    0.06341114f, -0.00793065f, -0.03402390f, -0.03611038f, 0.01677175f, 0.06525581f, -0.18965618f, -0.20617245f, 
    0.19543836f, 0.11345865f, -0.29402640f, 0.06480730f, -0.00108075f, -0.03006355f, 0.14985661f, 0.04733454f, 
    0.03925534f, 0.08329079f, 0.16921346f, -0.06087122f, -0.08531098f, -0.05586432f, -0.23395693f, -0.31447795f, 
    0.01186673f, 0.08493144f, -0.14238206f, 0.21556982f, -0.03889129f, 0.13124788f, -0.00016890f, 0.35384083f, 
    -0.25631091f, -0.10615196f, -0.08288487f, -0.23262095f, 0.08022986f, -0.10887142f, 0.15181749f, 0.18028896f, 
    0.16182891f, 0.04317405f, 0.13170961f, 0.11244043f, 0.06355475f, 0.03326264f, -0.10605627f, -0.15026470f, 
    0.05562909f, 0.22843020f, -0.05598573f, -0.07502387f, -0.02181224f, -0.24061126f, -0.00323550f, 0.00076526f, 
    0.35234720f, 0.12859653f, -0.01231709f, 0.23342465f, -0.15874092f, -0.02220461f, 0.07636973f, 0.18561333f, 
    0.00799323f, 0.11470056f, 0.02068266f, 0.07267375f, -0.16451789f, -0.01031990f, -0.24998119f, -0.00196365f, 
    -0.28172272f, -0.05928520f, -0.05054866f, 0.06066108f, -0.02597114f, 0.09964596f, 0.05859271f, 0.04305702f, 
    -0.58348054f, -0.68597037f, -0.14514746f, -0.38725689f, -0.01170546f, -0.14798486f, -0.04116171f, -0.04753330f, 
    0.02376118f, 0.12033694f, 0.01125811f, 0.07594813f, 0.24815750f, -0.03392752f, 0.01139034f, 0.00392717f, 
    -0.15082829f, -0.10321242f, 0.02108225f, -0.21326621f, -0.02040114f, 0.10018060f, -0.02762073f, -0.08363894f, 
    0.26861632f, 0.25175533f, -0.01212402f, 0.07242600f, 0.02758705f, -0.14235602f, 0.11796832f, 0.03642700f, 
    0.09346950f, -0.02005086f, -0.00045001f, 0.03739305f, -0.63064653f, -0.27390787f, -0.20435411f, -0.43071643f, 
    0.02839151f, -0.02220332f, -0.21837811f, -0.13916999f, -0.07761069f, -0.08019747f, -0.21936545f, -0.17128287f, 
    0.38072130f, -0.02316828f, -0.03624913f, -0.19184603f, 0.12341025f, 0.01490789f, 0.10256577f, -0.04203498f, 
    0.02256187f, 0.22084908f, 0.02503174f, 0.01378510f, 0.41185096f, 0.08823144f, -0.00847385f, -0.05484939f, 
    -0.27023771f, -0.07249448f, 0.08699940f, -0.18941064f, 0.05581000f, -0.04203572f, -0.14044663f, -0.23560506f, 
    -1.02865553f, -0.34074932f, 0.15274946f, 0.10809565f, 0.18856224f, 0.06193682f, -0.09219571f, -0.04317105f, 
    0.06004545f, 0.01031934f, 0.07096792f, 0.17059840f, -0.03180881f, -0.07281557f, -0.08509351f, -0.03973328f, 
    -0.07945900f, 0.05587957f, -0.03374581f, -0.05932290f, 0.12416030f, 0.17674851f, 0.04906473f, 0.09298580f, 
    0.05405406f, -0.03214688f, -0.20426907f, 0.06981334f, 0.01857284f, -0.04487317f, 0.04744588f, -0.02793325f, 
    0.03915957f, 0.01126298f, 0.15646915f, -0.02984434f, -0.63467568f, -0.07935019f, -0.21312834f, -0.26608798f, 
    0.19727580f, 0.12621228f, 0.01353887f, -0.12548321f, 0.04705402f, 0.05336771f, -0.02646067f, 0.05541756f, 
    0.11401688f, 0.08068950f, 0.10261987f, 0.11408161f, 0.06701332f, -0.01561591f, 0.14663626f, 0.11033362f, 
    -0.06342434f, -0.33094192f, 0.00008494f, -0.24438964f, -0.10795294f, 0.15327445f, 0.06545409f, -0.01271342f, 
    0.18656059f, 0.09023853f, -0.00374528f, 0.05913445f, 0.05425382f, 0.22505285f, 0.13796540f, -0.00235066f, 
    0.27282897f, 0.02353267f, -0.06377127f, 0.03756862f, 0.20453145f, -0.14808495f, -0.05352870f, -0.15658017f, 
    0.06038201f, 0.15964586f, 0.11353073f, 0.00948591f, -0.56137264f, 0.14018096f, -0.19900393f, -0.07998125f, 
    -0.12987237f, 0.14602402f, -0.02587444f, 0.19327684f, 0.02902275f, -0.05329346f, 0.00406844f, -0.14488384f, 
    -0.06319660f, -0.00924288f, 0.03155372f, -0.00952455f, -0.14561009f, -0.05203887f, 0.06007364f, -0.14611797f, 
    0.05340272f, 0.13397582f, -0.00561475f, 0.10551854f, -0.39354527f, 0.11267814f, -0.17774691f, -0.23664050f, 
    0.09706189f, 0.04839752f, 0.04999390f, -0.04916757f, -0.05375183f, 0.05926213f, 0.06387328f, -0.06119438f, 
    -0.29838654f, 0.14102425f, -0.06137826f, -0.03923595f, 0.11683654f, 0.04621797f, -0.07189815f, -0.00668914f, 
    -0.03815283f, -0.16516082f, -0.06564862f, 0.02467364f, -0.18114759f, -0.37438056f, 0.03709731f, -0.17782451f, 
    0.04671887f, 0.11317794f, -0.03830669f, 0.00411544f, -0.06665804f, -0.04355852f, -0.09907963f, -0.23806790f, 
    0.01933014f, -0.17382205f, -0.07239905f, -0.04428926f, -0.12015723f, -0.11171196f, -0.02154121f, -0.07274126f, 
    -0.15452676f, 0.19736841f, -0.00746424f, -0.05228125f, -0.14386874f, -0.07727457f, -0.07231909f, -0.31945294f, 
    0.17467938f, -0.07345384f, -0.00808478f, -0.04594043f, 0.02836643f, -0.16015422f, 0.03757453f, -0.01387525f, 
    -0.71399939f, -0.18416856f, -0.16905680f, -0.37713754f, 0.03819142f, -0.07759786f, -0.12435554f, 0.14757366f, 
    0.11219834f, -0.00855419f, 0.03463813f, 0.20666583f, -0.21528256f, 0.03003303f, 0.04943637f, 0.04155698f, 
    0.04583043f, 0.10838705f, -0.07075530f, -0.07821514f, 0.05938534f, 0.11881430f, 0.04688074f, 0.03808054f, 
    -0.02935327f, 0.19062753f, 0.02737291f, -0.17081580f, 0.12337627f, 0.00743767f, -0.02448682f, 0.01450929f, 
    0.04454668f, -0.00519049f, -0.06216176f, -0.04066513f, -0.01117801f, -0.21411714f, -0.22724837f, 0.10577106f, 
    0.22564517f, -0.13782775f, 0.01276542f, -0.07211539f, 0.02889627f, -0.00651962f, -0.05262630f, -0.07092857f, 
    -0.04183559f, 0.13858904f, -0.15464984f, -0.03068363f, 0.08827955f, -0.00795999f, -0.11978219f, 0.09666712f, 
    -0.13907470f, 0.00334227f, 0.01594160f, -0.01289663f, -0.27748027f, 0.04061932f, 0.12291612f, 0.27799603f, 
    -0.05545041f, 0.18063131f, 0.00593662f, 0.01092581f, -0.00842134f, -0.12113794f, 0.12171946f, 0.16362537f, 
    0.18169686f, -0.11442600f, -0.13844632f, 0.10071411f, -0.03588917f, 0.06109349f, -0.10227771f, 0.01414824f, 
    0.02057593f, -0.11630073f, -0.22119211f, -0.13323349f, -0.24747142f, 0.07654493f, -0.32067102f, 0.25330830f, 
    -0.18443936f, -0.02851301f, 0.12598905f, 0.11499719f, 0.04679099f, -0.12652604f, -0.06477398f, -0.11857963f, 
    0.22630906f, -0.31454381f, 0.05731738f, 0.45426995f, 0.05209439f, -0.04497831f, 0.10114637f, -0.09413451f, 
    0.02968721f, -0.02227573f, 0.04190740f, 0.11576676f, -0.07612804f, 0.26585516f, -0.07681394f, -0.01474396f, 
    0.09872743f, -0.06369783f, 0.02462917f, -0.20565376f, 0.09468855f, -0.01943531f, 0.02965399f, 0.04876292f, 
    0.03780191f, -0.35262176f, 0.14372744f, 0.08669510f, 0.07007438f, -0.03431014f, -0.03275015f, 0.13446669f, 
    -0.05638958f, -0.02128828f, 0.05242743f, -0.03121954f, -0.46466795f, -0.10148437f, 0.12120049f, -0.02148486f, 
    -0.11024778f, 0.38925144f, -0.03449617f, 0.06157909f, 0.03702562f, 0.10669990f, -0.12204097f, -0.04757462f, 
    0.16854174f, 0.17916340f, -0.37330285f, 0.12627354f, 0.24763855f, -0.08953565f, 0.05161414f, -0.03398068f, 
    0.06795803f, -0.02568224f, -0.04783314f, -0.03257212f, -0.18229523f, 0.06655681f, -0.02572312f, 0.03988831f, 
    -0.13183047f, 0.02102858f, -0.01907209f, -0.14377174f, -0.07226167f, -0.01187808f, 0.22837128f, -0.11125538f, 
    0.33441034f, -0.07691356f, 0.18679672f, 0.19226743f, -0.01545163f, -0.03125471f, -0.00651346f, 0.02456444f, 
    -0.12619868f, -0.04701789f, 0.04963325f, 0.12612027f, -0.30024791f, -0.12306121f, -0.23938438f, -0.24575311f, 
    0.03337021f, -0.15549234f, 0.02878260f, 0.07404202f, 0.13001132f, 0.02992013f, 0.04184737f, 0.14212133f, 
    0.23022412f, -0.00667778f, -0.10486066f, 0.13270769f, 0.04867641f, -0.19540809f, -0.06972496f, 0.12156235f, 
    -0.11433476f, -0.05507644f, -0.13757077f, -0.10652307f, -0.10470182f, 0.04902958f, -0.14137286f, 0.14256673f, 
    0.01889538f, -0.08494311f, 0.07398475f, -0.07262617f, 0.05021474f, 0.11635478f, 0.09601497f, -0.13852751f, 
    0.80372059f, 0.19145115f, -0.04999589f, -0.08287332f, -0.05127661f, -0.12422946f, 0.02927217f, 0.04729797f, 
    0.04654142f, 0.01916816f, -0.03842258f, 0.05566850f, -0.38507199f, 0.03087859f, 0.19508918f, 0.22284867f, 
    0.11999379f, 0.11017524f, -0.01998062f, 0.04609138f, -0.27560413f, -0.03544381f, -0.00725009f, 0.07742051f, 
    0.36722153f, -0.19907461f, -0.21032396f, 0.08545221f, 0.05717515f, -0.02910392f, 0.03355189f, 0.02527876f, 
    -0.03886706f, 0.01138611f, -0.23644118f, 0.04597237f, 0.78209311f, -0.05127854f, -0.27510613f, 0.02928373f, 
    -0.00982341f, -0.14180201f, -0.09217262f, -0.04166996f, -0.01467118f, 0.05423189f, 0.07456458f, 0.10060544f, 
    -0.16475633f, 0.16019320f, -0.18989383f, 0.08291040f, 0.08033326f, 0.18629959f, 0.08229078f, -0.32393849f, 
    0.02633765f, -0.19130294f, 0.09167201f, -0.10790200f, -0.10036539f, 0.06015206f, -0.03756043f, -0.09878834f, 
    -0.22862417f, 0.00438159f, -0.23276818f, -0.04909799f, 0.10921812f, -0.11562108f, 0.13782346f, 0.03391444f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13752663f, 0.04874920f, -0.02595030f, -0.01863218f, 0.03387307f, -0.01306217f, -0.05756231f, -0.05836857f, 
    -0.06851467f, 0.02884780f, 0.08516130f, 0.03108673f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
