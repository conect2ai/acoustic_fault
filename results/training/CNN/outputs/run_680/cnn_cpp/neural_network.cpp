#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.76225936f, 0.29541478f, -0.24967678f, 0.45645937f, 0.26408488f, 0.55363351f, 0.34361747f, -0.24371286f, 
    -0.00917904f, -0.16848911f, 0.00196250f, -0.12982006f, -0.20385753f, -0.14568093f, -0.23613593f, -0.12520321f, 
    -0.16915472f, -0.25862923f, -0.18229815f, -0.23625015f, -0.02815370f, 0.00613498f, -0.07702429f, -0.01463203f, 
    0.15215071f, 0.13076878f, 0.40145436f, 0.03312727f, -0.24216303f, 0.32054454f, -0.41218507f, -0.10843077f, 
    0.65002507f, 0.17819074f, 0.46988276f, 0.00644269f, -0.02779778f, -0.00354297f, -0.40936348f, 0.19460468f, 
    0.18723454f, -0.08521470f, -0.19081131f, -0.02248356f, -0.14895907f, 0.25654012f, -0.05198858f, 0.01492343f, 
    0.05433766f, 0.10139244f, 0.37891662f, -0.17374167f, 0.20535219f, 0.42059520f, 0.22099334f, 0.54323518f, 
    0.64299649f, 0.19940701f, -0.09868795f, 0.37038898f, -0.32050008f, -0.06031234f, 0.10168121f, 0.02731910f, 
    -0.01606540f, -0.08536256f, 0.21108069f, 0.22393185f, 0.16048302f, -0.20011827f, 0.07572253f, -0.00163050f, 
    0.02329866f, 0.02385320f, 0.04273143f, 0.72556537f, 0.15974280f, -0.39057708f, 0.66739976f, 0.40387636f, 
    0.18493763f, -0.46325269f, -0.01554433f, 0.10643958f, 0.39129540f, -0.25384876f, -0.09247177f, -0.22318546f, 
    -0.12339375f, 0.01300646f, 0.17576376f, 0.12962697f, -0.08006433f, -0.06115649f, 0.09928639f, 0.14601277f, 
    0.09944247f, -0.04218869f, -0.24115404f, -0.15081672f, -0.17429866f, -0.38431266f, -0.21961036f, 0.15645970f, 
    -0.10910639f, -0.54077107f, -0.50012386f, -0.36109927f, -0.32702237f, -0.02457145f, 0.39998892f, 0.27249771f, 
    0.12671305f, 0.31052801f, -0.36281273f, 0.30921644f, 0.12112839f, -0.03260802f, 0.02145883f, 0.22043841f, 
    -0.06731708f, -0.00041532f, 0.19707295f, 0.24204366f, -0.02937332f, 0.71101081f, 0.58586973f, 0.37266809f, 
    0.47095451f, 0.47815320f, -0.09602679f, -0.07620932f, -0.31672823f, 0.12131558f, -0.01636963f, 0.11503890f, 
    0.44086885f, 0.04371360f, 0.05424318f, 0.09183181f, -0.02700469f, -0.17898872f, 0.09380937f, 0.10474173f, 
    0.10399678f, -0.06719666f, -0.08571249f, 0.13121681f, -0.14385085f, 0.21533059f, 0.75356972f, 0.69322550f, 
    0.39614829f, -0.49080208f, -0.48001516f, -0.29078493f, -0.15413122f, -0.17951767f, -0.19354215f, 0.18074588f, 
    0.09436134f, -0.07942567f, -0.29122910f, -0.09052669f, 0.11857409f, 0.08161484f, -0.19404633f, -0.18731527f, 
    -0.20011674f, -0.01674467f, -0.03270992f, 0.10741124f, -0.02445777f, -0.17800200f, 0.08608765f, -0.70764047f, 
    0.42014697f, -0.18250917f, -0.42676196f, 0.37799245f, 0.22771978f, -0.26601291f, 0.21076728f, 0.21720177f, 
    0.45083156f, 0.34869224f, -0.10916835f, 0.13440692f, -0.02604313f, -0.25091994f, 0.07426588f, 0.22230680f, 
    -0.05056909f, 0.12325466f, -0.03932852f, 0.03238213f, -0.14826500f, 0.03697703f, -0.10733739f, -0.18747017f, 
    0.06981103f, 0.73688358f, -0.03418421f, -0.82623303f, 0.30306330f, 0.14047521f, 0.23662308f, -0.25363392f, 
    -0.16342191f, -0.18644392f, 0.19956541f, 0.25715733f, -0.00847362f, 0.02657999f, 0.00597806f, 0.06467884f, 
    0.08612504f, -0.02952766f, 0.17625652f, 0.26183593f, 0.17920399f, -0.16009334f, -0.04209091f, -0.23291403f, 
    0.09077319f, 0.20874476f, 0.26153189f, 0.62286639f, 0.68569779f, 0.46121410f, 0.16310765f, 0.14423583f, 
    -0.32455644f, -0.20755224f, -0.03533136f, -0.01455939f, -0.18251075f, -0.12936634f, 0.19020769f, -0.21322043f, 
    -0.09181849f, -0.08467400f, 0.00841834f, 0.10536247f, -0.11751943f, -0.12163447f, 0.27252457f, 0.06449896f, 
    0.13134101f, 0.12828586f, -0.13662624f, -0.29705325f, -0.60931742f, -0.60332394f, -0.21395326f, 0.56003159f, 
    0.11349306f, -0.26677924f, 0.00201565f, 0.06431405f, -0.26546314f, -0.29960096f, -0.02930762f, -0.03415884f, 
    -0.00376453f, 0.20951030f, 0.04370974f, -0.00139915f, 0.35029384f, 0.08989276f, 0.31427687f, -0.13603729f, 
    -0.09329534f, 0.09161002f, 0.12992093f, -0.47660494f, -0.90511632f, -0.49725956f, 0.43890700f, 0.40139642f, 
    0.19811013f, 0.64328039f, 0.16668859f, 0.16528317f, -0.30660087f, 0.04321656f, 0.04039031f, -0.03787829f, 
    0.11504916f, -0.13109484f, -0.19743440f, -0.10701472f, -0.25642592f, -0.10830916f, -0.00239845f, -0.04207541f, 
    0.03673279f, -0.03156751f, 0.05273202f, -0.05345522f, -0.30602545f, -0.59427458f, -0.52878296f, -0.15788862f, 
    -0.19195896f, 0.03044878f, 0.64607310f, 0.21778341f, 0.32524186f, 0.39617842f, -0.07314173f, 0.16215102f, 
    -0.48196551f, -0.05294232f, 0.00823853f, 0.03955575f, 0.13547997f, -0.01939906f, -0.01876274f, -0.14698216f, 
    -0.12356792f, -0.08470132f, 0.18232618f, -0.15466920f, -0.00581624f, -0.70172554f, 0.27667949f, 0.46169364f, 
    -0.12528792f, 0.38214523f, -0.57318294f, 0.12491418f, -0.43173948f, -0.45844993f, -0.12337115f, -0.18861790f, 
    0.13372605f, 0.16757800f, -0.07993741f, -0.16845512f, -0.08484372f, -0.34173930f, -0.03101821f, -0.12948610f, 
    0.01333286f, 0.13965864f, 0.07894101f, -0.03029161f, 0.00094950f, -0.08175509f, -0.49477649f, 0.58503002f, 
    -0.41199470f, -0.27489930f, -0.31953508f, 0.35334164f, -0.47599593f, -0.56996006f, -0.09740569f, -0.13936521f, 
    -0.04109976f, 0.15046060f, 0.03271351f, 0.34743500f, -0.18657991f, -0.17773671f, 0.10756285f, -0.08749752f, 
    -0.14829884f, -0.19274384f, -0.06752944f, 0.08848606f, 0.26275566f, 0.04823267f, 0.06974514f, 0.36212847f, 
    -0.40886274f, -0.47552422f, -0.60753709f, -0.33075660f, 0.14313331f, -0.43646806f, -0.02245321f, 0.24953665f, 
    -0.29599136f, 0.16179690f, 0.25332204f, -0.11804870f, 0.04441599f, -0.02824231f, 0.02759079f, 0.08228546f, 
    0.20790485f, 0.00673075f, 0.09062702f, -0.10896335f, -0.04421179f, 0.05962436f, -0.08634743f, 0.13644241f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09895910f, 0.05547883f, -0.03222897f, -0.12204597f, 0.14276107f, 0.20848717f, 0.14346066f, 0.00859159f, 
    0.18253556f, 0.05587925f, 0.00697879f, 0.23992757f, -0.08958060f, 0.21975839f, 0.10791746f, 0.12799804f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02058962f, -0.27787906f, 0.04298316f, -0.08396018f, 0.17494519f, 0.03847960f, -0.04312091f, -0.12741125f, 
    0.02286296f, 0.15378822f, -0.08979673f, 0.12897608f, 0.12593904f, 0.00314005f, -0.07383132f, -0.16101749f, 
    -0.01574649f, 0.08422524f, 0.06457292f, 0.05996591f, -0.06273738f, 0.07799554f, -0.04096334f, 0.02228156f, 
    0.17524543f, -0.15388025f, -0.09789231f, -0.02962969f, 0.09482056f, -0.01446295f, 0.12039018f, -0.01459065f, 
    -0.00476364f, -0.04717020f, -0.00099114f, 0.04722371f, 0.18280932f, -0.04779477f, -0.18987963f, 0.22590320f, 
    0.06118068f, -0.07273848f, -0.21510832f, -0.01510850f, -0.06540601f, -0.06618232f, 0.08152688f, 0.06652702f, 
    -0.04056214f, 0.02777741f, -0.05017109f, -0.01674483f, 0.06521481f, -0.09308486f, 0.03585308f, 0.06039249f, 
    -0.02979963f, -0.00743896f, 0.12117842f, -0.07547037f, 0.24200754f, -0.16640662f, -0.25795609f, 0.09792775f, 
    0.22173256f, -0.02543324f, 0.03187797f, -0.07704964f, -0.05738838f, -0.01071639f, 0.02194428f, -0.04301794f, 
    0.41267025f, 0.01066721f, 0.03130220f, -0.22319829f, 0.00633794f, 0.06977952f, 0.01144165f, 0.03587728f, 
    0.04490000f, -0.01854504f, 0.02653405f, 0.14823979f, 0.01241933f, 0.13847341f, 0.07034031f, 0.12462153f, 
    0.00815316f, 0.12999977f, -0.12582298f, 0.14755513f, 0.02064614f, -0.05409651f, -0.18274058f, -0.08959374f, 
    0.16746041f, 0.09142189f, 0.12303349f, -0.06030083f, -0.00935442f, 0.03195680f, -0.02730758f, -0.05997083f, 
    -0.06462297f, 0.06346883f, 0.10610425f, -0.02637055f, 0.05826752f, -0.23217174f, -0.22847517f, 0.08006495f, 
    0.00307527f, 0.06436783f, -0.08369771f, -0.11180365f, 0.03280589f, -0.00992715f, 0.06095877f, 0.06319001f, 
    0.15987338f, 0.19559422f, 0.23909007f, 0.14153427f, -0.08290333f, -0.09403108f, 0.07972958f, 0.04633904f, 
    -0.00649756f, -0.03259460f, -0.05950402f, 0.00582694f, 0.17260171f, -0.05102549f, 0.08513010f, 0.07524693f, 
    -0.01052138f, 0.00727465f, -0.04253156f, 0.06359906f, -0.02584740f, 0.07073603f, 0.00221865f, 0.02312807f, 
    0.44890079f, 0.30021098f, 0.05208004f, -0.03995083f, -0.02568153f, -0.13974395f, 0.05709374f, 0.19793467f, 
    0.01327207f, -0.01491226f, -0.06456541f, -0.13297552f, 0.11091281f, -0.12138945f, -0.10356702f, 0.05353430f, 
    -0.07724774f, 0.02827299f, -0.05873369f, 0.03657279f, -0.07083107f, 0.06276973f, 0.13667014f, -0.11204618f, 
    -0.20512784f, 0.08791044f, -0.17542286f, -0.06708391f, 0.08903614f, -0.04829922f, -0.12071432f, -0.02098665f, 
    0.04554138f, 0.13040103f, -0.01693325f, -0.12269225f, 0.15058669f, 0.06541026f, 0.25658530f, -0.07196210f, 
    -0.09055945f, -0.02908462f, -0.12912361f, 0.13452417f, -0.01279495f, 0.05277297f, -0.02150522f, -0.02053297f, 
    0.26789585f, -0.03639745f, -0.04050193f, 0.03603465f, 0.09110368f, -0.01242780f, 0.08613990f, -0.00893000f, 
    -0.00786799f, 0.05962582f, 0.20944086f, 0.13622519f, -0.11299238f, -0.02055619f, 0.03584477f, 0.02243151f, 
    -0.11627486f, -0.07095011f, 0.15917912f, -0.04298246f, 0.10316523f, -0.02581709f, 0.18476482f, 0.01459832f, 
    -0.08171184f, -0.18878193f, 0.08927979f, -0.10375256f, 0.13140455f, 0.01567389f, -0.05599646f, -0.04933647f, 
    -0.03355652f, -0.05654777f, -0.09136321f, 0.21711361f, 0.15928417f, 0.10933309f, 0.07918667f, -0.03493179f, 
    -0.01966658f, 0.10668646f, 0.11972671f, -0.01304634f, -0.00727797f, -0.04783235f, -0.01306434f, -0.01517018f, 
    -0.08835647f, 0.01354679f, -0.07255271f, 0.10149344f, -0.14832993f, 0.15537922f, 0.03244476f, 0.02170112f, 
    0.02732213f, -0.01668543f, -0.10306010f, -0.13429803f, 0.25405213f, 0.22345664f, 0.17216399f, 0.05057251f, 
    -0.03930601f, 0.09518615f, -0.02533569f, 0.04244222f, 0.10212616f, -0.06510767f, -0.10054187f, 0.04171747f, 
    0.13013081f, 0.14503929f, -0.03816628f, 0.00977104f, -0.08293298f, 0.01569681f, 0.11145409f, 0.00505863f, 
    0.05865793f, 0.07399511f, 0.06430811f, -0.09680403f, 0.15993501f, -0.01584779f, -0.01839787f, 0.04359782f, 
    -0.08942854f, 0.06854159f, 0.17354520f, -0.00749264f, 0.01802632f, 0.11019834f, -0.01078830f, 0.08203465f, 
    0.01318183f, 0.00673371f, -0.13532099f, 0.20303047f, 0.04783221f, -0.00537512f, 0.19997367f, -0.12380086f, 
    -0.11627232f, -0.00563462f, -0.09592421f, 0.00248398f, 0.19842999f, 0.23941450f, 0.08639949f, 0.09285659f, 
    0.10270921f, 0.07436490f, 0.02288671f, -0.01844159f, 0.05884558f, -0.00555942f, 0.03584110f, 0.01429861f, 
    -0.14439157f, -0.25154629f, -0.04487034f, 0.04971866f, -0.17014004f, 0.00332739f, -0.03794649f, 0.06475534f, 
    -0.02247979f, -0.08815154f, -0.05206578f, 0.01012344f, -0.24673474f, -0.10242842f, -0.05222198f, -0.16378906f, 
    0.06178007f, 0.07406260f, 0.12062553f, 0.11834554f, 0.12721902f, -0.00272722f, 0.05314217f, 0.10868813f, 
    -0.42365646f, -0.07548168f, -0.01309197f, 0.08824290f, 0.01824315f, 0.03654952f, 0.03341595f, 0.00317357f, 
    -0.09246861f, 0.03759568f, 0.12352853f, 0.06643531f, -0.25971580f, 0.19954868f, 0.02220808f, 0.13220397f, 
    0.09361351f, 0.06525380f, -0.00837273f, -0.09618161f, 0.10241626f, 0.02415650f, 0.05748191f, 0.16842574f, 
    0.20361859f, -0.08564355f, 0.13034518f, -0.16430043f, -0.11621375f, 0.07997645f, 0.01424114f, -0.00226334f, 
    -0.00367565f, -0.00622099f, -0.01471248f, 0.14543438f, -0.26625887f, -0.04082142f, -0.03804759f, 0.00068798f, 
    0.00279992f, -0.05808214f, 0.06960918f, -0.08363219f, -0.03357398f, -0.07859079f, -0.00968578f, 0.03164062f, 
    -0.14480756f, 0.12630454f, -0.03802587f, -0.08507656f, 0.15573566f, 0.08700696f, 0.04259361f, -0.12682773f, 
    0.10410097f, -0.11744423f, -0.02233241f, -0.04437727f, 0.14860700f, 0.05308678f, -0.10723494f, 0.08063699f, 
    0.11513747f, 0.18446635f, -0.10514063f, 0.15251485f, -0.04675899f, 0.10320602f, -0.04018502f, 0.00925761f, 
    0.30344617f, 0.03883928f, -0.14188986f, 0.01519486f, -0.06862987f, -0.02894126f, 0.04377110f, -0.03437160f, 
    0.00314736f, -0.08302292f, 0.18667588f, 0.00737476f, -0.32851312f, -0.16976286f, -0.20147485f, 0.10278343f, 
    0.10797892f, -0.16903818f, -0.14455646f, -0.04320516f, -0.06480025f, 0.19376668f, 0.11252135f, 0.03360624f, 
    0.05714093f, 0.06656813f, 0.06529552f, -0.12803318f, 0.00512878f, -0.14298868f, 0.03120559f, 0.12766397f, 
    0.10503253f, 0.08344019f, 0.11162427f, 0.20041785f, -0.12764877f, -0.04923704f, -0.23209378f, 0.04666669f, 
    0.12008932f, 0.08233369f, 0.09417056f, -0.07185434f, -0.01511166f, -0.02361824f, 0.14656600f, 0.14577112f, 
    -0.01160272f, 0.00704514f, 0.03522529f, -0.04616813f, 0.16054700f, 0.11645851f, -0.08955690f, -0.02033997f, 
    0.07573066f, -0.03564105f, -0.14834931f, 0.13649482f, -0.09708259f, 0.04423534f, 0.05676898f, 0.07602667f, 
    0.03096678f, -0.20442154f, -0.07697741f, 0.09365792f, 0.04971426f, -0.04745350f, -0.01032504f, -0.00106545f, 
    0.11303076f, 0.15379761f, -0.09470363f, -0.10529021f, -0.04774065f, -0.14265731f, -0.07275949f, 0.07665835f, 
    0.00735070f, 0.04951388f, 0.08900981f, 0.12856516f, -0.22171797f, -0.20169429f, -0.21138437f, 0.04792520f, 
    0.12231015f, -0.01128202f, -0.10278543f, -0.09861574f, 0.08436204f, 0.02184557f, 0.11867294f, 0.16745341f, 
    -0.02140608f, 0.24522898f, 0.02862373f, 0.16946036f, 0.07800697f, 0.00826352f, 0.02060669f, 0.01093789f, 
    0.12487427f, 0.04502013f, 0.04101872f, -0.14006326f, -0.02024038f, -0.00646135f, 0.07844569f, 0.08663610f, 
    0.02758997f, -0.12749520f, -0.06609257f, 0.02059481f, 0.01744643f, 0.06846135f, -0.11357996f, -0.09488269f, 
    0.08359268f, 0.20468433f, 0.05921136f, 0.09293033f, -0.10974970f, -0.06893446f, 0.13823022f, -0.11020201f, 
    0.10780157f, -0.07405480f, -0.15691234f, 0.01563911f, 0.17450477f, -0.04163938f, -0.03621349f, -0.20722640f, 
    0.01000484f, -0.08930213f, -0.05446309f, 0.00887788f, 0.02320947f, 0.04073522f, -0.03978496f, -0.06299101f, 
    -0.21250634f, 0.17060286f, -0.03151719f, 0.04412978f, 0.05580977f, -0.20800106f, 0.08281779f, -0.01589423f, 
    0.15430738f, -0.00697696f, 0.12692098f, -0.05283813f, 0.08314437f, 0.27996421f, 0.25871184f, -0.06744869f, 
    0.03168897f, 0.12508431f, -0.20320463f, 0.09133129f, 0.06863329f, -0.11119132f, 0.05126190f, -0.01090594f, 
    -0.13100661f, 0.28292927f, 0.20080809f, 0.03446795f, 0.07669400f, -0.00706590f, -0.13113776f, -0.01623391f, 
    -0.02057111f, 0.02896238f, -0.03464732f, 0.06404914f, 0.38463050f, -0.00052354f, 0.07291906f, 0.02734521f, 
    0.14254613f, -0.04211821f, -0.06103344f, -0.02239103f, -0.05325842f, -0.05816925f, 0.02488127f, 0.04008236f, 
    0.47986558f, 0.25018573f, 0.08384911f, 0.05138576f, 0.02843115f, 0.02710566f, 0.00619572f, 0.01295632f, 
    0.15083851f, -0.00960385f, -0.05470528f, -0.04945721f, -0.14814492f, 0.13391325f, 0.18242995f, 0.04137361f, 
    0.07736976f, -0.04709041f, -0.09132688f, -0.02826595f, 0.06616130f, 0.16114041f, 0.03438117f, 0.10714085f, 
    -0.22925803f, -0.07200702f, -0.06597005f, -0.12615065f, -0.02136735f, -0.00531088f, -0.03207795f, -0.08853053f, 
    0.04010177f, -0.02498589f, -0.02489511f, 0.15058956f, -0.01595767f, 0.10447288f, 0.14396904f, 0.13833918f, 
    0.09424506f, 0.12032622f, 0.03926789f, -0.11754879f, -0.20024942f, -0.02175387f, -0.00172245f, 0.10875243f, 
    -0.00467897f, 0.14786024f, -0.09029547f, 0.04159886f, 0.08902565f, 0.11144957f, -0.02475438f, 0.01477365f, 
    -0.08219112f, -0.08052857f, 0.02331684f, 0.01980500f, 0.02858881f, -0.26471248f, -0.00275989f, 0.05371281f, 
    -0.03629785f, -0.07325312f, 0.02635483f, -0.02721757f, 0.05120059f, -0.00513723f, 0.09104155f, 0.06712854f, 
    -0.04371312f, -0.00618604f, 0.06155338f, -0.21965672f, -0.00818923f, -0.08021142f, -0.11468357f, 0.08668118f, 
    -0.11648484f, 0.11732931f, 0.14052935f, -0.01370074f, 0.08078659f, 0.16384782f, 0.14433046f, 0.04257569f, 
    0.12674752f, 0.08054128f, 0.00518076f, -0.00197189f, -0.05758445f, -0.00479570f, -0.03281099f, -0.01555445f, 
    -0.30541739f, -0.12730063f, 0.08187608f, -0.21940553f, 0.09326153f, 0.08084391f, -0.08429570f, 0.08706852f, 
    0.11300173f, 0.05822293f, 0.05655031f, 0.02992687f, -0.04987053f, 0.05104109f, -0.12489156f, 0.09558842f, 
    0.07367856f, 0.03251334f, -0.09742451f, -0.02648202f, -0.06141720f, 0.07293901f, -0.03990456f, 0.01576580f, 
    -0.02113886f, -0.14417042f, -0.14170989f, -0.07151652f, -0.04427393f, -0.04241682f, 0.10486123f, 0.03702413f, 
    0.14770606f, -0.08078525f, -0.00399129f, -0.02034976f, 0.20193763f, -0.13360856f, -0.12029962f, -0.13724738f, 
    0.12609394f, 0.04020251f, 0.05427377f, 0.01426919f, -0.00109788f, 0.07831325f, -0.01224199f, 0.02772715f, 
    -0.35015464f, -0.02905435f, 0.06254541f, -0.09151024f, 0.05190194f, -0.01903847f, 0.06035878f, -0.01360598f, 
    -0.07592953f, -0.18758111f, 0.08098736f, 0.01183967f, -0.13724570f, -0.04482479f, 0.08176059f, -0.05926036f, 
    0.03816569f, 0.07752267f, 0.02143924f, 0.17817903f, 0.06414621f, 0.05839130f, -0.00137644f, 0.18002279f, 
    -0.04511993f, 0.14678004f, -0.05721295f, 0.00553440f, -0.07953181f, 0.03425710f, 0.04289224f, 0.02802003f, 
    0.03196018f, -0.08795612f, 0.16333747f, 0.06650405f, -0.08370136f, -0.25828192f, -0.14772405f, 0.07596433f, 
    -0.03845391f, 0.05212318f, 0.06545521f, -0.01468491f, -0.08867387f, 0.00104594f, 0.04060489f, 0.00487076f, 
    -0.27425107f, -0.02668191f, -0.01640770f, -0.06145442f, -0.12239681f, 0.02693367f, 0.01334114f, -0.16034351f, 
    -0.03483944f, 0.09137508f, 0.02898577f, 0.01327251f, 0.06299136f, -0.00629044f, -0.09985425f, 0.05498971f, 
    -0.01277237f, 0.07759183f, 0.11521239f, -0.00839537f, -0.00651792f, -0.00529919f, 0.07017152f, -0.08142170f, 
    0.12598363f, 0.06332319f, 0.05450211f, 0.02073293f, 0.05628029f, 0.00119669f, -0.09993991f, 0.00193164f, 
    -0.05922700f, 0.03261608f, -0.02723460f, -0.22807060f, -0.06015721f, 0.08354090f, 0.07945324f, -0.24535549f, 
    -0.08869755f, -0.03683993f, -0.13338631f, 0.04387193f, 0.09120118f, -0.06484381f, -0.07302576f, -0.08905163f, 
    -0.34223771f, -0.09793290f, 0.05912059f, 0.18388227f, -0.08100957f, 0.15696456f, 0.05514886f, -0.08632369f, 
    0.09430034f, 0.05478813f, 0.01654855f, -0.00180318f, -0.02637180f, 0.10541102f, -0.16018178f, -0.14372812f, 
    0.12948826f, 0.04116340f, 0.15166409f, -0.00690819f, -0.01042681f, 0.13383837f, 0.03240306f, -0.05184352f, 
    0.09576433f, 0.12462242f, -0.02207325f, 0.01238089f, 0.07344624f, 0.02995005f, 0.12579599f, 0.10863670f, 
    0.15426813f, -0.09793467f, -0.02626774f, -0.11088397f, -0.12128089f, 0.06380628f, -0.09571642f, -0.09531120f, 
    -0.00523445f, -0.03409006f, -0.17673856f, 0.01665239f, 0.02424144f, -0.16895631f, -0.01985953f, -0.03885961f, 
    -0.02003589f, -0.11713017f, -0.04452257f, -0.03773490f, -0.06866954f, -0.09047028f, 0.05402580f, -0.10026830f, 
    -0.06802141f, -0.16597262f, -0.12390473f, 0.02810976f, 0.16458929f, -0.07234260f, -0.00693840f, 0.12234148f, 
    0.03361645f, 0.10548836f, 0.15374996f, 0.13134342f, 0.15473263f, -0.07316101f, 0.06130497f, 0.07537869f, 
    -0.08442001f, -0.05859527f, 0.12319954f, -0.04702177f, 0.10467552f, 0.21497862f, -0.04358182f, 0.18468092f, 
    -0.00201973f, -0.00971930f, 0.18642969f, 0.08978854f, -0.10532326f, 0.09993097f, 0.19603193f, 0.09334315f, 
    -0.01140638f, 0.09818491f, -0.00001385f, 0.06792597f, 0.06893490f, 0.01898854f, -0.01833626f, 0.14977689f, 
    0.31558114f, -0.04971026f, 0.17897980f, -0.01903965f, -0.01822666f, 0.00777788f, -0.16063885f, 0.12667510f, 
    0.10842426f, 0.19941677f, 0.02775667f, 0.06534082f, -0.06496794f, -0.03472185f, -0.05296195f, 0.00659939f, 
    -0.07495997f, -0.01753909f, 0.08740345f, 0.08286145f, 0.06875442f, -0.06863777f, -0.01855095f, -0.00177112f, 
    0.07297974f, 0.26447871f, 0.03776747f, 0.15246874f, -0.03800228f, -0.06558313f, 0.12402651f, 0.01297113f, 
    -0.06009212f, 0.00208804f, 0.09971114f, 0.12180678f, 0.00072324f, 0.01347949f, -0.06178415f, 0.01389155f, 
    -0.08141091f, 0.05609950f, 0.03187464f, -0.10323882f, 0.04792560f, 0.02537401f, -0.02540135f, -0.00438038f, 
    -0.14243184f, 0.15355229f, 0.02532871f, -0.03201567f, 0.07795428f, -0.05510952f, -0.08988184f, -0.05519841f, 
    0.05735695f, 0.01392518f, 0.00114669f, -0.00769416f, 0.22877704f, 0.28157479f, 0.02129737f, -0.14901994f, 
    0.01906087f, 0.18952443f, 0.13335420f, -0.01889633f, 0.02364269f, 0.02341270f, -0.00794641f, -0.10606294f, 
    -0.11333684f, -0.06253690f, 0.00296933f, 0.13694231f, 0.08521695f, -0.03216000f, 0.06281728f, 0.03442020f, 
    0.03280089f, 0.08009776f, -0.06480400f, 0.11005773f, 0.01492393f, 0.27240679f, 0.04264518f, 0.00229187f, 
    -0.12146651f, 0.00054052f, -0.04432660f, 0.09970080f, 0.03978400f, -0.09981667f, -0.05610127f, 0.02001021f, 
    0.08987223f, -0.01484326f, 0.06003523f, 0.25666919f, 0.02931168f, -0.00971435f, 0.05691057f, -0.04076273f, 
    -0.01496343f, 0.06712680f, 0.02919285f, -0.02261873f, -0.07563352f, -0.03386768f, -0.03336935f, 0.00213934f, 
    0.02485374f, -0.04728853f, 0.01222315f, -0.00038736f, 0.06327961f, 0.01489734f, 0.01419461f, 0.00397748f, 
    -0.05748234f, -0.04770987f, -0.02287094f, 0.26664570f, 0.05394858f, -0.01055280f, 0.06985467f, -0.02738514f, 
    0.05070940f, -0.02290740f, -0.13085783f, -0.01974734f, 0.11962710f, 0.27254018f, 0.15473750f, 0.06805225f, 
    -0.05970976f, -0.06057812f, 0.05501898f, 0.13521716f, 0.00050190f, 0.05530084f, -0.00052927f, 0.10731112f, 
    0.04681158f, 0.02228813f, -0.11817059f, 0.03817798f, 0.07428931f, 0.02999331f, 0.07520682f, 0.00374434f, 
    0.14396854f, -0.02401870f, -0.03333839f, 0.04200082f, -0.20690525f, 0.15290157f, 0.05408850f, -0.12679893f, 
    0.11601419f, 0.01216678f, 0.05565682f, 0.06255236f, -0.01368294f, 0.00602636f, 0.07105404f, 0.07233853f, 
    -0.41665468f, -0.02087871f, 0.10888343f, 0.03123947f, 0.18425858f, 0.15529846f, 0.02863962f, -0.06489886f, 
    -0.02941063f, 0.09845760f, 0.06515896f, 0.01702043f, -0.20403430f, -0.16372423f, 0.15164271f, 0.26014277f, 
    0.06935686f, -0.05016633f, 0.01607907f, 0.09462277f, -0.05403892f, -0.03649386f, -0.08863495f, 0.20067675f, 
    0.20193115f, -0.10726291f, 0.10948769f, 0.27349296f, -0.03956407f, 0.00558438f, 0.04276459f, 0.05792247f, 
    0.00874283f, -0.01518827f, 0.01090064f, 0.15106310f, 0.11893835f, 0.15304960f, -0.07427100f, 0.21857251f, 
    0.01548062f, -0.00618304f, 0.07846300f, 0.08070087f, -0.01510895f, -0.05960672f, 0.00227799f, -0.00993563f, 
    0.07179961f, -0.34651300f, 0.01296971f, 0.02284205f, 0.00419114f, -0.09022012f, -0.00864306f, -0.06710822f, 
    0.13762565f, -0.02629457f, -0.02513286f, -0.01899849f, -0.27259788f, 0.01292022f, 0.10334115f, 0.02669141f, 
    0.14285444f, 0.05836241f, -0.01452117f, 0.03728137f, 0.03849658f, 0.00696337f, 0.02258324f, -0.01810553f, 
    0.38916573f, -0.17859796f, 0.19478385f, -0.05029026f, -0.03730626f, 0.11873941f, -0.04279142f, 0.09599597f, 
    0.12211521f, 0.02170327f, -0.00997663f, 0.01182024f, 0.04976219f, -0.17192703f, 0.21530162f, -0.03652366f, 
    0.01908673f, -0.10440778f, -0.20856713f, 0.07543656f, -0.00600349f, 0.00979886f, 0.05824185f, -0.04330633f, 
    0.05057945f, 0.11660817f, -0.00843973f, -0.14687537f, 0.01109936f, 0.02310422f, -0.14374894f, -0.08286905f, 
    -0.07171274f, -0.04038038f, -0.03018979f, 0.07379672f, 0.12506847f, 0.04304307f, 0.07329233f, -0.02480979f, 
    0.11965097f, 0.00632883f, 0.02706854f, 0.00452057f, 0.05720149f, 0.02202426f, 0.06944410f, 0.08302302f, 
    -0.16605830f, 0.13409014f, -0.02270934f, -0.04509073f, 0.03263932f, -0.07226127f, 0.01229243f, 0.00143969f, 
    -0.06084462f, -0.10248473f, -0.05953219f, -0.05713642f, -0.14851652f, 0.08730490f, 0.18514223f, 0.04178588f, 
    -0.02980464f, 0.06038073f, 0.04354205f, -0.04469267f, -0.12786667f, -0.00415087f, -0.05678315f, 0.02606086f, 
    0.07253793f, -0.06558621f, 0.02410692f, 0.02048510f, 0.09973953f, 0.01442921f, 0.02561207f, -0.01246296f, 
    0.03215832f, 0.04748960f, 0.02415173f, 0.17146605f, 0.09184039f, -0.13140766f, 0.15632276f, 0.01113119f, 
    0.03135543f, 0.04143751f, 0.07736159f, -0.11965648f, 0.12797795f, 0.06679256f, 0.11458711f, -0.04843033f, 
    0.11423597f, 0.15031949f, 0.10643430f, -0.06778026f, 0.00037561f, 0.12359301f, -0.07217739f, 0.06714744f, 
    0.05857734f, 0.02168707f, 0.00337515f, -0.03631506f, 0.23974295f, -0.18440366f, 0.12096471f, 0.02499001f, 
    -0.04332845f, -0.02153720f, 0.07527381f, 0.02591926f, 0.08233702f, 0.06581835f, -0.00182489f, -0.10313043f, 
    0.34698871f, 0.06637704f, 0.00311585f, -0.09431652f, -0.00207318f, -0.02516551f, 0.06076672f, 0.04180007f, 
    -0.03562301f, -0.04796451f, -0.03899861f, -0.00130251f, 0.23490816f, 0.03245117f, -0.12305392f, -0.05961728f, 
    0.04717013f, 0.11080728f, -0.03343611f, -0.08914442f, -0.05026994f, 0.08850557f, 0.07999740f, 0.05713268f, 
    -0.15562271f, 0.03553467f, -0.04533200f, -0.07771634f, 0.04807017f, -0.13981777f, 0.06629545f, 0.00323602f, 
    0.03475915f, 0.11229539f, -0.08830220f, -0.05924820f, -0.02468982f, -0.00934064f, -0.05837735f, -0.11232275f, 
    0.05412667f, -0.14653677f, -0.02625504f, -0.02881851f, 0.02069770f, 0.06414606f, -0.00624322f, 0.08280469f, 
    -0.04197539f, 0.00194524f, 0.05574776f, -0.07643916f, -0.04214444f, -0.06624913f, -0.00243412f, -0.03369366f, 
    -0.07448594f, 0.01916586f, -0.02910138f, -0.00867173f, -0.00142029f, -0.01893594f, -0.04098966f, -0.02054179f, 
    -0.02670909f, -0.01671127f, -0.02430789f, -0.05693223f, -0.00175712f, -0.00766546f, 0.02565399f, 0.03432499f, 
    -0.05480614f, 0.03245991f, -0.06120338f, -0.04703257f, 0.06411658f, 0.04586107f, -0.02226609f, -0.01621706f, 
    0.02269700f, -0.07648277f, 0.03899745f, -0.07527565f, 0.05141873f, -0.07157301f, 0.02984252f, -0.03046919f, 
    0.05203373f, -0.00173574f, 0.05763172f, 0.04237309f, 0.04095784f, -0.06410462f, -0.04967766f, -0.06080969f, 
    -0.07281238f, 0.04309690f, -0.00866996f, -0.02876870f, 0.05053448f, 0.01564601f, 0.04611669f, -0.06635305f, 
    0.01148948f, 0.00256101f, -0.04281248f, 0.05731658f, 0.04359020f, -0.01929127f, 0.03676867f, -0.06876162f, 
    0.06159839f, 0.02434245f, 0.01126518f, 0.00762429f, -0.00511671f, -0.05802010f, -0.06896310f, 0.00954831f, 
    -0.07410816f, 0.06196506f, -0.03945636f, -0.03259372f, 0.00003552f, 0.04657922f, -0.00103358f, -0.00366487f, 
    -0.02250530f, -0.01991941f, 0.02147492f, 0.04147271f, -0.01171807f, -0.06141989f, -0.04119629f, 0.05363396f, 
    -0.00617336f, 0.04289272f, -0.05201180f, 0.06151005f, -0.01785649f, 0.00102931f, -0.00020390f, -0.05757907f, 
    0.04310660f, 0.03525290f, -0.02580838f, 0.04863917f, -0.01726683f, -0.05508130f, 0.04943583f, 0.04225834f, 
    0.03037660f, -0.04995263f, 0.06051528f, 0.06137346f, -0.02864639f, -0.07877851f, -0.01571283f, -0.05012862f, 
    -0.05056930f, -0.01620510f, 0.03274997f, -0.06262311f, 0.03230220f, -0.01388563f, 0.03959937f, -0.00876647f, 
    -0.06209595f, 0.05981577f, 0.00581974f, 0.01796580f, 0.00425841f, 0.06299607f, -0.07659175f, 0.05577625f, 
    -0.01361838f, 0.02055585f, 0.00566881f, -0.03476083f, -0.04075923f, -0.02941030f, 0.04262142f, 0.01678967f, 
    -0.04213487f, -0.07146108f, -0.04009302f, -0.07435787f, 0.04150014f, -0.06625038f, -0.05016721f, -0.01192736f, 
    -0.05031734f, -0.06479836f, 0.05572020f, -0.02185801f, -0.03142361f, 0.04893075f, 0.04420392f, 0.02178221f, 
    -0.04466957f, 0.03670018f, -0.05799504f, -0.01866025f, -0.06807760f, -0.02570802f, 0.01333297f, -0.03578446f, 
    0.03316209f, -0.05850128f, 0.00922256f, -0.02820793f, -0.02879737f, -0.03284267f, 0.00259643f, -0.01849963f, 
    -0.03880901f, 0.03027771f, -0.03984665f, -0.06195056f, -0.04860118f, -0.06784414f, 0.02358995f, -0.07038930f, 
    -0.03269007f, 0.02459721f, -0.05382126f, 0.04255450f, -0.02242274f, -0.01131304f, -0.00060735f, 0.05344845f, 
    -0.05629456f, 0.01761140f, 0.03092092f, -0.05798894f, -0.03979915f, -0.03514302f, -0.03610258f, -0.07560194f, 
    -0.02081499f, 0.07758887f, 0.01078156f, 0.09133234f, -0.05453731f, -0.00830243f, -0.02641430f, 0.23022065f, 
    -0.14345993f, 0.04678509f, -0.03746832f, -0.06965021f, -0.13278081f, -0.07284392f, 0.06325326f, -0.12750955f, 
    0.00543126f, -0.07411449f, 0.00130887f, 0.00506988f, 0.05915829f, -0.03594148f, 0.15232816f, -0.08635594f, 
    -0.00945545f, 0.16921434f, 0.06354380f, 0.11307861f, -0.04718433f, 0.00609578f, 0.03232518f, 0.08722326f, 
    0.18349251f, 0.09855635f, -0.01086858f, 0.10580654f, 0.26342696f, -0.09396428f, 0.10336424f, 0.22884065f, 
    -0.06954284f, 0.17743498f, -0.00230383f, 0.08154682f, 0.01267095f, -0.07658195f, 0.11735668f, -0.07640599f, 
    -0.10798123f, -0.11313805f, 0.03838527f, 0.21395715f, 0.02245565f, 0.14347094f, 0.01186545f, 0.06625059f, 
    0.11722171f, 0.02273829f, 0.02310238f, -0.22203223f, 0.08786961f, 0.06378397f, 0.18288949f, -0.02397670f, 
    -0.20743822f, -0.13627137f, -0.03252328f, 0.09311758f, -0.00005322f, 0.00911075f, -0.05514428f, -0.09196491f, 
    -0.19906381f, 0.13603820f, 0.10247385f, -0.12282198f, -0.04693924f, 0.08796661f, 0.04178884f, 0.04322547f, 
    -0.06732239f, -0.06775998f, 0.10178638f, -0.02915461f, 0.12902144f, -0.10150941f, 0.13817520f, -0.22483288f, 
    0.06592888f, 0.02592842f, 0.04933636f, 0.01971230f, -0.02230799f, 0.02712562f, 0.10484903f, -0.24996763f, 
    -0.14384136f, 0.25723848f, 0.14220300f, -0.39323649f, -0.04865536f, 0.14094433f, 0.12998441f, 0.11099569f, 
    0.24559861f, -0.15125455f, -0.08809655f, -0.03724657f, 0.13200824f, -0.00591214f, -0.05316130f, 0.18294111f, 
    -0.17431793f, -0.07170708f, 0.04973955f, 0.13832377f, -0.08921973f, 0.04851141f, -0.02001045f, 0.09728689f, 
    0.05992347f, -0.05001869f, 0.05373874f, -0.37553680f, 0.09760547f, 0.00278409f, 0.11100790f, 0.05976152f, 
    0.14618991f, -0.02395889f, 0.01502225f, 0.22751126f, -0.08628896f, 0.24864906f, -0.18947552f, 0.23909281f, 
    -0.02601006f, 0.01456262f, 0.03406944f, 0.03029414f, 0.07825124f, 0.02518401f, 0.02441120f, -0.06062445f, 
    0.00495214f, -0.03975730f, -0.01614547f, -0.26970550f, 0.04071347f, 0.14596714f, -0.06939930f, 0.00156252f, 
    0.06937142f, 0.06184959f, 0.20594104f, 0.08931142f, -0.22756225f, 0.03391086f, 0.15645368f, 0.02464389f, 
    0.06447441f, 0.01788689f, -0.07145383f, 0.02891263f, 0.08205591f, -0.05438574f, 0.03112610f, 0.04974310f, 
    0.13021535f, -0.00039311f, -0.01116858f, -0.15082160f, 0.05889470f, 0.05609433f, 0.07376096f, 0.04528777f, 
    -0.07104637f, 0.01396735f, -0.03490666f, -0.04296829f, 0.01423229f, -0.21698080f, -0.09861499f, -0.19137141f, 
    0.00735065f, 0.01887319f, 0.18752177f, -0.16745220f, -0.03332783f, -0.05361673f, 0.00872767f, 0.05766425f, 
    -0.06458550f, 0.05375622f, -0.02573342f, -0.00895399f, -0.02001383f, -0.01590962f, -0.04137698f, -0.00695076f, 
    0.03475314f, 0.03738563f, -0.06991040f, -0.06575274f, -0.05622247f, -0.07650554f, 0.04477481f, -0.08405064f, 
    0.02177819f, -0.04252511f, 0.00709615f, 0.00998279f, 0.00731989f, 0.04722897f, -0.00591820f, -0.04251882f, 
    0.04248863f, 0.02934591f, 0.01653187f, -0.01253818f, 0.00806555f, -0.05157274f, 0.04937368f, 0.01099414f, 
    -0.02311019f, 0.02635331f, 0.05074359f, -0.03885173f, 0.00916168f, -0.00621104f, -0.07693176f, 0.02395482f, 
    0.01547195f, -0.02066535f, 0.02665879f, 0.02652835f, -0.04230165f, 0.03087982f, 0.01787742f, 0.02068140f, 
    -0.03796576f, -0.07096791f, -0.05016803f, 0.00714739f, 0.03237806f, -0.02139395f, -0.03820397f, -0.07787718f, 
    0.01445785f, -0.01203971f, -0.08331013f, -0.06830378f, 0.02077478f, 0.02824713f, -0.04697527f, -0.05866349f, 
    0.02377540f, -0.03639913f, 0.00731716f, 0.00770950f, -0.01182208f, 0.01733298f, 0.03963878f, -0.02912107f, 
    0.04142176f, -0.05997767f, -0.01441642f, 0.03410158f, -0.04610031f, 0.01514244f, 0.05882334f, 0.01779103f, 
    0.04936327f, -0.02796428f, 0.00719612f, -0.08615609f, -0.05947085f, 0.01616500f, -0.03835449f, 0.04157760f, 
    -0.00717296f, 0.06867924f, 0.01659029f, 0.04099082f, -0.00947167f, -0.06643201f, -0.06062991f, 0.00184237f, 
    -0.04335012f, 0.01537514f, -0.02880682f, -0.01708768f, 0.04326563f, 0.06464876f, -0.06716855f, -0.04319136f, 
    -0.05034620f, -0.04486620f, -0.02808413f, 0.03221976f, 0.04525172f, -0.06109103f, -0.05533477f, -0.07105584f, 
    0.00168111f, 0.03415278f, 0.01587942f, 0.02084833f, -0.03493208f, -0.06955902f, 0.01679963f, -0.02960973f, 
    -0.04860124f, 0.04011829f, -0.06360351f, -0.07283970f, -0.03073215f, -0.01318916f, -0.03498680f, -0.07266651f, 
    -0.00697883f, 0.05489296f, 0.00081292f, -0.00401018f, -0.01172012f, -0.06215073f, 0.05003591f, 0.00084864f, 
    0.03495240f, 0.04939032f, -0.04751890f, 0.04244010f, 0.05493334f, 0.00974187f, -0.06183267f, -0.04076830f, 
    -0.06752501f, 0.02520566f, -0.01107518f, 0.02215517f, 0.02255367f, -0.04672252f, -0.02591179f, -0.04375813f, 
    -0.05456770f, 0.02733926f, -0.03376754f, 0.04138835f, 0.01156764f, 0.00087110f, -0.02847795f, 0.03006942f, 
    0.02166808f, -0.02360275f, 0.00462511f, -0.06283680f, -0.02891015f, 0.03421764f, 0.01588126f, 0.04397125f, 
    -0.05700865f, -0.03086661f, 0.05134818f, -0.03897665f, -0.00541470f, 0.04529490f, -0.05331201f, -0.00359940f, 
    0.01824858f, 0.02775636f, 0.00981243f, -0.01179189f, 0.05034010f, 0.00812213f, 0.04931521f, -0.00046878f, 
    0.02328802f, -0.05389357f, -0.05936562f, -0.00143278f, 0.04993464f, -0.02886637f, 0.06097603f, -0.08437266f, 
    0.15765528f, -0.09200741f, 0.12972365f, 0.11590612f, 0.17656617f, 0.16336049f, -0.03355956f, -0.01136115f, 
    -0.02156605f, 0.23659837f, 0.04663078f, 0.13676667f, 0.38553634f, -0.11156801f, 0.08481019f, 0.16415237f, 
    0.00229290f, -0.08616245f, 0.04040994f, -0.01215728f, -0.08281063f, 0.08242171f, 0.01371659f, -0.04654377f, 
    0.36361453f, -0.02725900f, -0.06913093f, 0.14771201f, 0.07209380f, -0.02048977f, -0.03473466f, 0.06436095f, 
    0.00131619f, -0.00742752f, -0.09498150f, -0.04597331f, 0.10653378f, 0.00164341f, -0.01512898f, 0.25765288f, 
    0.07416376f, -0.02606131f, -0.00147370f, -0.03085992f, 0.00873822f, -0.05051670f, -0.02060828f, 0.00114128f, 
    -0.25694072f, -0.12191434f, -0.14423639f, -0.15448590f, 0.09717002f, 0.02951843f, 0.01027581f, 0.13867524f, 
    -0.05057450f, 0.07956753f, -0.03965393f, -0.09311730f, 0.20484050f, 0.04452205f, -0.04980387f, 0.28067857f, 
    0.20574962f, 0.01223868f, -0.02426364f, -0.10253116f, 0.00602615f, 0.02804088f, -0.01206902f, -0.06521676f, 
    0.25058684f, -0.11822096f, 0.00680845f, -0.23554759f, 0.07616717f, 0.05498237f, 0.08338777f, -0.11009844f, 
    0.05072550f, -0.05894081f, -0.09558457f, -0.03053405f, 0.17411093f, 0.18400005f, -0.02622336f, 0.02753287f, 
    -0.02397916f, -0.00774605f, -0.11562900f, 0.04179334f, -0.00866918f, -0.08085449f, 0.07940616f, 0.05770662f, 
    -0.01159051f, -0.04777107f, -0.01462971f, -0.14123268f, 0.11206983f, -0.00275172f, -0.09742612f, -0.12011313f, 
    -0.12059690f, 0.00858629f, 0.06023155f, -0.14783068f, 0.14228773f, 0.01131877f, 0.06094271f, 0.13929117f, 
    0.04919676f, 0.01373620f, -0.00331503f, -0.04125541f, -0.01497424f, -0.03110704f, -0.07126882f, -0.03571794f, 
    -0.08741364f, 0.12147643f, 0.16400936f, 0.03775558f, 0.00615337f, 0.02458225f, 0.03238798f, 0.07972373f, 
    -0.04392534f, -0.05456464f, -0.09882312f, -0.01711041f, 0.22937229f, -0.10055251f, -0.03893964f, 0.14999530f, 
    -0.13106366f, 0.07499911f, -0.02880117f, 0.00826623f, -0.01457868f, 0.00517304f, -0.10612544f, 0.02219754f, 
    0.30272844f, 0.08267421f, 0.09193141f, 0.22263314f, -0.16325253f, -0.01426174f, -0.06292064f, 0.17043979f, 
    0.11594440f, 0.15140568f, 0.09579474f, 0.01766285f, -0.29916176f, -0.08774595f, -0.27424708f, -0.31815833f, 
    -0.12716340f, -0.00131920f, -0.03053188f, -0.04355924f, -0.04787138f, -0.01313218f, -0.04326360f, -0.11061286f, 
    -0.29295427f, -0.02283297f, -0.25762251f, -0.43698075f, 0.13663720f, -0.07010619f, 0.01169360f, -0.09403065f, 
    0.13615739f, -0.00118722f, 0.01784647f, -0.08197746f, 0.16184609f, 0.21176504f, 0.24821785f, -0.06230045f, 
    -0.03607206f, 0.10504685f, 0.03094747f, 0.21922551f, -0.10688559f, 0.04398087f, 0.07436988f, -0.04010863f, 
    0.41053882f, -0.29268211f, 0.03145296f, -0.03250883f, 0.11435775f, 0.01272412f, -0.03380521f, 0.04051830f, 
    0.03932288f, -0.01868084f, -0.08468266f, 0.03293143f, 0.07803417f, 0.09432939f, 0.00414347f, 0.09676882f, 
    -0.04304575f, 0.04661671f, 0.09925110f, -0.02076494f, -0.05416478f, 0.00781542f, -0.07149978f, 0.03978578f, 
    0.17275406f, 0.06111511f, 0.07818338f, 0.08364338f, -0.01478023f, 0.05000729f, -0.08136182f, 0.05257268f, 
    0.02991563f, -0.13166904f, 0.11587282f, -0.08861698f, 0.14956777f, -0.30379352f, -0.00821663f, 0.13026913f, 
    0.07182571f, -0.05381599f, 0.00117517f, 0.01146057f, -0.05128631f, -0.00061035f, -0.13645989f, 0.05870849f, 
    0.09846158f, -0.01049439f, 0.07091398f, -0.05299952f, 0.06042838f, -0.06212594f, 0.00451086f, 0.07670234f, 
    -0.01191643f, 0.05239451f, 0.06352944f, 0.21090481f, 0.02807333f, -0.23823193f, 0.08012080f, 0.27567559f, 
    0.16444457f, 0.06890752f, 0.10694917f, -0.05700741f, -0.08642544f, 0.01215728f, 0.01790805f, 0.12306610f, 
    -0.12962157f, -0.04654451f, -0.00440297f, -0.21937205f, -0.03903717f, -0.05129366f, 0.19752973f, 0.04962808f, 
    -0.03768670f, -0.01754686f, -0.04433973f, 0.07722228f, 0.19696537f, 0.27573821f, 0.04241126f, 0.10183381f, 
    -0.04659664f, -0.07043814f, -0.06832632f, -0.03995324f, 0.08762790f, 0.07656071f, -0.08768629f, 0.06835090f, 
    0.05301131f, -0.00454902f, 0.02748386f, -0.31753963f, -0.08017608f, -0.10581142f, 0.00100180f, -0.15410432f, 
    -0.07072927f, 0.17012043f, 0.01222292f, 0.06789158f, -0.00911348f, -0.10174809f, 0.05856873f, 0.23901626f, 
    0.11080359f, 0.16699316f, 0.05982238f, -0.05692234f, -0.04328161f, -0.01144691f, 0.04365442f, -0.07522553f, 
    -0.11040667f, 0.03869794f, 0.11010396f, 0.06622548f, -0.04498440f, -0.09455074f, -0.05812413f, 0.12706974f, 
    0.06234616f, 0.00296387f, 0.06855228f, -0.03039864f, -0.04090644f, 0.00449096f, -0.03129337f, -0.06919792f, 
    -0.00950648f, 0.05790856f, 0.04628693f, -0.00689281f, -0.00186690f, 0.00879510f, -0.04553570f, -0.03180413f, 
    0.31678596f, 0.15305062f, 0.04912015f, 0.17502210f, -0.13556610f, -0.10354096f, 0.09755658f, -0.01124639f, 
    0.00245080f, -0.05122009f, -0.16192590f, -0.04715549f, 0.01241936f, 0.17215426f, -0.04986276f, -0.00129605f, 
    0.02301666f, -0.01502483f, 0.06888904f, -0.03016761f, -0.06303561f, 0.13251103f, 0.12608491f, -0.08737203f, 
    -0.06791516f, 0.06015655f, -0.21027917f, -0.31659743f, 0.18092337f, -0.01312381f, 0.02539656f, 0.01153499f, 
    0.00405819f, -0.06570188f, -0.04207021f, -0.06047797f, -0.13028733f, -0.04949157f, 0.14523755f, -0.05001308f, 
    -0.11974613f, -0.08947107f, 0.02308002f, 0.09203832f, 0.03297424f, 0.09182746f, 0.20030092f, 0.10231652f, 
    -0.02920763f, -0.04080915f, 0.05086694f, 0.01371767f, -0.03534888f, 0.01692402f, 0.03264344f, 0.02277180f, 
    -0.07132614f, -0.05680486f, -0.07261070f, 0.02613555f, -0.01575770f, -0.00587229f, 0.00779519f, 0.00643252f, 
    -0.06256443f, -0.01668219f, 0.03757714f, 0.05043396f, 0.05650230f, 0.00895567f, -0.01110023f, -0.04266571f, 
    0.03845351f, -0.01797044f, 0.01834716f, 0.01210404f, 0.04812306f, 0.04071392f, -0.02908020f, -0.05060180f, 
    -0.05277810f, 0.01538387f, -0.05624341f, -0.00196334f, -0.03220856f, 0.04406313f, -0.05701233f, 0.03100861f, 
    -0.06674565f, 0.05372794f, -0.03965615f, -0.02120521f, -0.03248950f, -0.02509879f, 0.03258538f, -0.07281765f, 
    -0.00466322f, -0.04025838f, 0.05208341f, 0.00991327f, -0.05208126f, -0.05024728f, -0.04469831f, -0.07029493f, 
    0.01639384f, -0.06421819f, 0.04696138f, 0.00047210f, 0.01737153f, -0.01341368f, 0.01803901f, -0.06734641f, 
    0.04654269f, -0.03106355f, -0.07015096f, -0.04607989f, -0.03818408f, 0.02190552f, 0.03701623f, -0.01007654f, 
    -0.06805328f, 0.02409053f, -0.07196093f, 0.01086614f, -0.06172494f, -0.04392108f, 0.01474058f, 0.00934194f, 
    0.05778063f, -0.02412843f, -0.01468202f, 0.01219422f, 0.01238927f, -0.01178256f, -0.06281023f, 0.00294741f, 
    0.05557978f, 0.05384595f, 0.02736082f, -0.03013786f, -0.02639154f, 0.05293684f, -0.01229328f, -0.04166370f, 
    0.00309302f, -0.05262124f, -0.05216454f, -0.02656358f, -0.02425562f, 0.04470227f, 0.02936252f, 0.04051350f, 
    0.04203226f, -0.02361954f, -0.04273306f, 0.00082246f, -0.05861746f, 0.06635875f, 0.00336796f, -0.04077552f, 
    -0.06785757f, 0.01283557f, -0.03813746f, -0.05370055f, -0.00246506f, -0.00246937f, -0.02479546f, -0.06794282f, 
    0.00923459f, -0.05257595f, 0.04225108f, -0.03869532f, 0.01947369f, -0.02394089f, 0.01308504f, 0.01641201f, 
    -0.00216401f, 0.04236791f, -0.06085938f, 0.02959353f, 0.02400221f, -0.07485273f, 0.00139202f, -0.02002553f, 
    0.00265275f, 0.03640055f, -0.02872874f, 0.00333105f, 0.03272257f, 0.05566207f, 0.00985754f, -0.07100967f, 
    -0.05464499f, -0.05290658f, -0.04538669f, -0.02995013f, 0.00627801f, -0.06963687f, -0.02553405f, -0.02885667f, 
    -0.05943792f, -0.03903886f, -0.05896693f, -0.02213374f, -0.04698860f, -0.01335473f, 0.01140052f, 0.04056033f, 
    0.02430215f, -0.04384246f, -0.01630952f, 0.05543870f, -0.03043494f, 0.04250617f, 0.00404751f, 0.04446427f, 
    0.01351066f, -0.05881809f, -0.01484417f, -0.04296662f, 0.05140204f, 0.00773243f, 0.01464518f, -0.07164932f, 
    0.02196047f, -0.00169705f, -0.01177604f, 0.06298221f, 0.04869776f, -0.00519568f, 0.03877367f, -0.07467753f, 
    -0.06617010f, -0.03613283f, 0.01728872f, 0.00154970f, 0.05858118f, -0.02890289f, -0.02913596f, -0.06596407f, 
    -0.04837185f, -0.03314307f, -0.06813504f, 0.01822608f, 0.02927718f, 0.02817764f, 0.05387557f, 0.01381635f, 
    -0.03561459f, 0.01458040f, -0.07882034f, 0.02010754f, -0.05323086f, 0.01572151f, -0.03597876f, 0.04167421f, 
    0.02784835f, -0.04762812f, -0.00609790f, -0.07906131f, 0.01628456f, -0.01791046f, 0.03283260f, -0.07636397f, 
    0.02407335f, -0.00091514f, -0.07968926f, -0.00076668f, -0.06295790f, -0.04211648f, -0.06735447f, 0.05115690f, 
    0.06040619f, 0.03846922f, -0.05184728f, -0.07587890f, 0.02381445f, -0.04902529f, -0.00946527f, -0.00758360f, 
    0.01706367f, -0.07439215f, -0.01429710f, -0.02342062f, 0.00015777f, -0.04528187f, 0.03997197f, 0.03860408f, 
    0.02920787f, -0.00290638f, 0.04781801f, 0.03404550f, 0.04012235f, -0.07226988f, 0.03352362f, 0.00139196f, 
    -0.04842167f, 0.04196572f, -0.02214896f, -0.04939293f, -0.00102074f, 0.04344663f, 0.02025009f, -0.05592430f, 
    -0.05815232f, 0.05317460f, -0.04770547f, 0.03032753f, -0.00430658f, -0.07936203f, 0.03268084f, -0.02702081f, 
    0.03486793f, -0.04506185f, 0.01889371f, -0.05368006f, -0.05530553f, 0.02345571f, -0.01124786f, 0.02550081f, 
    -0.03692482f, -0.02292520f, -0.07391284f, 0.01159091f, 0.04148961f, -0.06208230f, 0.03074014f, -0.02417286f, 
    -0.02300030f, 0.05771783f, -0.00144609f, 0.03397691f, -0.04327113f, 0.01949765f, -0.06968582f, -0.03258617f, 
    -0.07928125f, 0.03397874f, 0.03313219f, 0.02908228f, 0.04961994f, -0.02169292f, -0.07442760f, -0.01575243f, 
    -0.03110368f, 0.03231475f, -0.07146930f, -0.01555254f, -0.02133943f, 0.00503054f, 0.04621565f, 0.03215169f, 
    -0.02861009f, -0.07947185f, 0.05114314f, 0.03880467f, 0.01329418f, -0.08217504f, -0.03663478f, 0.05348429f, 
    -0.05467998f, 0.05065265f, 0.02246646f, -0.07484541f, 0.05813825f, -0.07276427f, 0.04976309f, -0.00479669f, 
    -0.01559298f, 0.01801079f, 0.02940148f, 0.04079736f, -0.07714490f, -0.05855701f, -0.06773834f, -0.07272704f, 
    0.00018825f, -0.07409526f, 0.04537253f, -0.06259190f, 0.03631998f, -0.06262755f, 0.05032384f, 0.02721029f, 
    0.02649515f, 0.02301507f, -0.07230779f, 0.04962216f, 0.05283616f, 0.03264289f, 0.05230604f, 0.01761644f, 
    -0.02142069f, -0.05906938f, 0.03069602f, -0.05146354f, 0.03919819f, 0.04005073f, 0.04096170f, -0.01321445f, 
    -0.06803803f, -0.08581792f, 0.04226314f, -0.06519355f, 0.02666948f, 0.02103961f, 0.01996967f, 0.05043691f, 
    -0.02343179f, 0.04651416f, -0.01903482f, 0.02378440f, 0.01433806f, -0.05375848f, -0.01405085f, -0.04781999f, 
    -0.02624393f, -0.02467422f, -0.05761808f, -0.04069177f, -0.06976153f, -0.05884589f, 0.00727307f, 0.05809225f, 
    0.01004279f, -0.06743850f, -0.00848930f, 0.03630115f, 0.03239888f, -0.06036348f, 0.03832705f, -0.05595615f, 
    -0.24390545f, 0.31748137f, -0.16192991f, 0.04468544f, 0.03904545f, 0.00272696f, 0.04246999f, 0.01387668f, 
    0.00395448f, 0.03737892f, -0.08050048f, -0.06303920f, 0.32339385f, -0.16751944f, -0.03746206f, 0.06448894f, 
    0.01757026f, 0.08575939f, 0.16513032f, -0.03635724f, -0.05495828f, 0.08993812f, -0.07083523f, 0.03145915f, 
    -0.21166207f, 0.18087660f, -0.09652171f, 0.09321997f, 0.11035342f, -0.01295616f, 0.07174642f, 0.00047400f, 
    0.00565153f, 0.12211365f, -0.00601425f, 0.04371039f, -0.14170578f, 0.28542680f, -0.11296079f, 0.06584204f, 
    0.01072544f, -0.04091848f, 0.23781095f, -0.18066099f, -0.04784514f, 0.05180259f, 0.07290019f, 0.03211719f, 
    -0.14199427f, -0.13935719f, 0.14559725f, 0.13596050f, 0.05077090f, -0.07579579f, -0.00331489f, -0.03936692f, 
    0.09040307f, 0.14295250f, 0.01205164f, 0.09459630f, -0.17799941f, 0.02602579f, -0.00788257f, 0.05802246f, 
    -0.03087212f, -0.03019127f, -0.00713168f, 0.04964946f, -0.03967601f, -0.00928474f, 0.01400791f, -0.07001040f, 
    0.14740959f, -0.19103269f, 0.08650208f, 0.02050633f, -0.04132694f, 0.10420030f, -0.06871928f, -0.00446702f, 
    0.11690971f, 0.13352256f, 0.06227177f, 0.02088979f, 0.13347265f, -0.09796926f, -0.18761371f, 0.05308967f, 
    0.07871064f, 0.00685726f, 0.06749149f, 0.03799267f, 0.05051849f, -0.06156822f, 0.08370610f, 0.01598327f, 
    0.07158556f, 0.07404606f, 0.05915893f, -0.12761037f, -0.13288392f, 0.04370117f, 0.03354764f, 0.16276953f, 
    0.07548036f, 0.01331490f, 0.07104739f, -0.08869632f, -0.18626644f, 0.20070395f, -0.11796560f, -0.15797237f, 
    -0.07448336f, -0.04259339f, -0.06140106f, -0.00279327f, 0.04329050f, -0.05198438f, -0.10799956f, 0.05450257f, 
    -0.23723972f, -0.17862754f, -0.00682350f, 0.06462310f, -0.05481328f, 0.03987428f, 0.07150151f, 0.02273487f, 
    -0.11181584f, -0.16295470f, -0.04576787f, 0.08593516f, -0.42997000f, 0.09430942f, -0.18829289f, 0.21034211f, 
    0.12489575f, 0.04009003f, 0.00272463f, 0.10596908f, -0.03737772f, -0.04940576f, -0.05127862f, 0.09443837f, 
    -0.36866051f, -0.04015333f, -0.07282016f, 0.03513486f, 0.12211604f, 0.11692619f, 0.00809918f, 0.06556813f, 
    0.04358109f, 0.06606735f, -0.05538809f, -0.06841477f, -0.17276317f, 0.02823024f, 0.11647048f, -0.05213624f, 
    -0.06357852f, -0.00475301f, 0.07626010f, -0.02655959f, 0.02356117f, 0.03953225f, -0.03397202f, 0.09769492f, 
    0.03439919f, -0.21024944f, 0.16919658f, 0.04429606f, -0.08558146f, -0.04004885f, -0.02745176f, 0.13697472f, 
    -0.00617479f, -0.04228887f, 0.16222449f, 0.04304046f, 0.08292731f, -0.12822303f, 0.03579379f, 0.10391646f, 
    -0.17937519f, -0.03330599f, -0.02602756f, 0.08429418f, -0.07828077f, -0.02144276f, -0.06573338f, 0.05346644f, 
    -0.06030520f, -0.00258996f, 0.01941738f, 0.00143670f, 0.02382064f, 0.01004050f, 0.00535115f, -0.02364562f, 
    -0.02154672f, 0.04679734f, 0.04535162f, 0.05935593f, -0.06404579f, -0.00203986f, 0.05932557f, 0.03119832f, 
    0.03395457f, -0.07432923f, -0.07720499f, -0.07128295f, 0.04721403f, 0.00629395f, 0.00201220f, -0.00619235f, 
    0.06215983f, 0.05200099f, 0.06193556f, -0.01630439f, 0.05151135f, -0.05926447f, -0.06891934f, -0.05513458f, 
    0.03233761f, -0.06427581f, -0.07064255f, 0.03913406f, -0.04704005f, -0.04673880f, -0.01491350f, -0.06418201f, 
    -0.07044841f, -0.04233834f, 0.03323400f, -0.05071788f, 0.00127900f, 0.02329914f, -0.01880853f, -0.06199961f, 
    -0.00119909f, 0.00698917f, 0.03893020f, -0.05139704f, -0.05062521f, 0.01368509f, -0.04572282f, 0.06413963f, 
    0.02807624f, -0.06534359f, 0.03561671f, -0.00593763f, -0.05537287f, 0.00911620f, 0.01445604f, 0.03843601f, 
    0.01208085f, -0.01173017f, -0.06298157f, -0.00691656f, -0.07511149f, -0.03330659f, -0.04078299f, 0.00417442f, 
    -0.01038108f, -0.00410480f, -0.00904613f, -0.07046852f, -0.00435552f, 0.06334470f, -0.03110875f, 0.02819724f, 
    -0.00267930f, 0.05345966f, 0.00216199f, 0.04548882f, -0.03024189f, -0.04340556f, -0.01903290f, 0.05911787f, 
    0.03798306f, -0.02078870f, -0.02036461f, -0.02233840f, 0.03799008f, 0.00577044f, 0.01087539f, 0.02270684f, 
    -0.04818865f, -0.03022063f, -0.00335608f, -0.01245696f, -0.02494632f, -0.00766057f, -0.06411754f, 0.01680481f, 
    -0.02040920f, 0.00779524f, -0.03125934f, -0.02536366f, 0.05480609f, -0.07687912f, -0.02510238f, 0.02623074f, 
    -0.05879052f, -0.00354296f, -0.04119257f, -0.00461881f, 0.03908715f, 0.04962106f, -0.03744621f, -0.01501646f, 
    0.04622985f, 0.04197055f, -0.01400284f, 0.01439314f, 0.03288946f, 0.02508286f, -0.06464034f, 0.00220681f, 
    0.04724241f, -0.03503164f, -0.05296201f, -0.04275189f, -0.00368140f, -0.03253409f, -0.01940512f, -0.02508236f, 
    -0.04022364f, 0.05558372f, -0.03789631f, -0.05013574f, 0.03778145f, 0.05524194f, -0.00823472f, -0.04791081f, 
    -0.05958366f, -0.01242011f, 0.06580092f, -0.02553315f, 0.00410504f, -0.06742172f, 0.00210735f, -0.00027191f, 
    -0.05545552f, 0.04967460f, -0.06411358f, 0.00992788f, -0.03159298f, 0.04549405f, -0.06415814f, -0.01025597f, 
    0.05890220f, -0.04424551f, -0.02834581f, 0.00937372f, 0.01600240f, 0.03349805f, -0.02948036f, 0.02660773f, 
    -0.00116197f, -0.06332340f, -0.00580837f, 0.04819666f, -0.06539950f, -0.04258079f, 0.00838394f, -0.02092771f, 
    -0.07451071f, 0.02418919f, -0.05418056f, 0.01648821f, -0.02477662f, -0.02738723f, 0.02073547f, -0.06225028f, 
    -0.04071010f, 0.02757628f, -0.03193341f, -0.03257171f, -0.07431114f, -0.03171100f, -0.06364654f, -0.00425124f, 
    -0.03463785f, -0.05244308f, 0.12701787f, -0.00143198f, -0.02934420f, -0.05182475f, -0.01484501f, -0.10116961f, 
    0.14940114f, -0.13367786f, -0.12518914f, -0.04613072f, -0.21573980f, 0.18146111f, 0.13463667f, -0.02311705f, 
    0.14212990f, 0.01258642f, 0.06391647f, 0.05826939f, -0.00120251f, -0.11912512f, -0.04325072f, 0.10768584f, 
    0.14481679f, -0.05611775f, 0.28449994f, -0.04874497f, -0.01567809f, 0.00569554f, -0.06809948f, 0.07014725f, 
    0.14116412f, -0.05592872f, 0.10385782f, 0.03870563f, -0.05191737f, 0.08813579f, 0.10552384f, -0.28487810f, 
    0.10715005f, -0.16297533f, -0.20119432f, 0.13734061f, -0.08190355f, 0.02376557f, -0.08920774f, 0.02080997f, 
    0.12487733f, 0.05358215f, -0.13278383f, -0.02961821f, 0.02177516f, -0.09998178f, -0.10291058f, 0.02126400f, 
    0.17299841f, -0.08587620f, 0.04656051f, 0.17181374f, 0.06543184f, 0.12770383f, 0.09732637f, 0.10382698f, 
    0.03691331f, 0.13324831f, 0.05250083f, -0.03918352f, -0.09601112f, -0.00081757f, 0.02774255f, 0.15390356f, 
    0.07601853f, 0.22858070f, -0.22192456f, 0.26192161f, 0.08354109f, 0.04239873f, 0.04585686f, 0.02834975f, 
    0.01257682f, -0.06222961f, -0.00576576f, -0.09190180f, -0.29072306f, -0.22932258f, 0.01140168f, -0.01656189f, 
    0.01156991f, 0.02783175f, 0.07632469f, -0.01250995f, -0.04684855f, -0.04078428f, -0.09451654f, 0.12817705f, 
    0.11356366f, -0.17571548f, -0.05714295f, 0.19781832f, 0.05816355f, -0.06042762f, 0.00988337f, -0.07365619f, 
    0.05342794f, 0.11269166f, -0.04890857f, 0.05316378f, 0.13217741f, -0.00832022f, 0.28375468f, 0.03245660f, 
    0.07991700f, 0.01586590f, 0.04291508f, -0.03393703f, -0.09714231f, 0.07406253f, -0.00152388f, 0.06215166f, 
    0.08333951f, 0.02488346f, -0.16867976f, -0.10388570f, 0.06821261f, 0.22194658f, -0.02193551f, 0.06885955f, 
    0.05140958f, 0.09617798f, 0.05360822f, -0.09246955f, 0.00014500f, -0.04470496f, 0.11231806f, -0.21992795f, 
    0.04934125f, 0.07041312f, -0.02655484f, -0.11152959f, 0.09963912f, 0.00800348f, 0.06086446f, -0.04049782f, 
    -0.09701588f, -0.09947222f, -0.16398153f, -0.19126780f, 0.09780622f, 0.07037359f, 0.03348846f, -0.12654668f, 
    0.09803875f, -0.05775705f, -0.04246528f, 0.10117253f, 0.32936966f, 0.04933331f, -0.11954104f, 0.10475300f, 
    0.04521799f, 0.09066715f, 0.01198346f, 0.02018934f, -0.05334041f, 0.09828471f, 0.04882958f, 0.00499549f, 
    -0.05731414f, -0.08320685f, 0.00289757f, 0.30210450f, 0.01177613f, -0.03813755f, 0.05359071f, 0.06489874f, 
    0.07049871f, 0.01143579f, -0.00334440f, -0.03024016f, -0.17640844f, -0.05949143f, -0.18979199f, 0.00359905f, 
    0.19252200f, -0.15749763f, -0.02668619f, -0.12303916f, 0.09841988f, -0.03411430f, -0.10958626f, 0.13488311f, 
    -0.01317876f, -0.06029215f, 0.00574612f, -0.01908789f, 0.03770524f, -0.01755270f, 0.05734449f, -0.03085306f, 
    -0.03602335f, -0.04625475f, -0.03142353f, -0.08192939f, -0.01203259f, 0.06398296f, -0.02704176f, 0.02770595f, 
    -0.02209233f, 0.03866910f, 0.01179887f, -0.06608746f, -0.05843098f, -0.06041883f, -0.00403006f, -0.06536891f, 
    0.04598607f, -0.05712218f, 0.03915257f, 0.01976301f, 0.02485713f, -0.06972221f, -0.01175035f, -0.01462827f, 
    -0.02039646f, -0.00916595f, -0.04731891f, -0.00272648f, 0.02895705f, 0.05694278f, 0.02392022f, 0.03000238f, 
    0.04554354f, -0.03631353f, 0.00133052f, -0.00663874f, 0.01556663f, -0.04915595f, -0.01121354f, -0.02235208f, 
    -0.01009959f, -0.04225518f, 0.00708111f, -0.03877172f, -0.00595024f, 0.05091935f, -0.06301937f, -0.00012070f, 
    -0.03458337f, 0.02293891f, -0.05956531f, 0.01116135f, -0.04981779f, -0.03219069f, -0.07295261f, 0.06094773f, 
    -0.05404402f, -0.04512256f, 0.00982302f, 0.00193250f, -0.00832274f, -0.06743877f, -0.05847276f, -0.07542784f, 
    0.03288521f, -0.10159311f, 0.00977751f, -0.06384057f, -0.04280607f, -0.01489438f, 0.04859979f, -0.07347871f, 
    -0.05431545f, 0.02066115f, 0.02594372f, -0.07734378f, -0.05732446f, -0.03095595f, 0.03857434f, 0.02019596f, 
    -0.01460784f, 0.01722805f, 0.03990350f, 0.05479696f, -0.05356684f, -0.01437317f, -0.04207505f, -0.07120833f, 
    0.00854418f, -0.05778001f, 0.02573490f, -0.06817706f, -0.05016218f, -0.06710554f, -0.08538859f, -0.07394101f, 
    0.03988747f, -0.02066902f, -0.01135659f, -0.00171559f, -0.00823856f, 0.06178799f, 0.03672630f, -0.04983057f, 
    0.04770368f, -0.05454457f, -0.02645201f, -0.08356082f, -0.05404017f, -0.03570324f, 0.01580228f, -0.07457951f, 
    -0.06091909f, 0.00599492f, 0.00754723f, -0.10060600f, -0.00701652f, -0.00440750f, 0.05571119f, 0.04211793f, 
    0.00355720f, -0.00854996f, 0.03001570f, 0.05043243f, -0.04165868f, 0.03565608f, 0.00387670f, 0.04831360f, 
    0.03526265f, -0.06496931f, -0.03189172f, 0.01137987f, -0.03996288f, -0.00571729f, 0.06749223f, 0.02960151f, 
    0.02770699f, -0.01542452f, 0.01649500f, -0.05407827f, 0.04543528f, 0.01662797f, -0.03447936f, 0.03759848f, 
    -0.02065925f, 0.03708072f, 0.00506306f, -0.01433529f, -0.05911779f, -0.01984924f, 0.03820203f, -0.08295973f, 
    0.02743339f, 0.04801473f, -0.05472860f, 0.04084478f, -0.07627039f, 0.02787397f, -0.00940652f, 0.03335723f, 
    -0.08785355f, 0.02791065f, -0.01022710f, -0.06909726f, 0.05364056f, 0.05693095f, -0.05878805f, -0.04822082f, 
    -0.02572516f, 0.03688415f, 0.02496681f, -0.04658183f, -0.05466347f, -0.06500724f, 0.04613645f, -0.04836233f, 
    -0.00795200f, -0.01653756f, -0.06212700f, -0.05060588f, 0.05505326f, -0.01717427f, -0.03806430f, -0.00280369f, 
    -0.01350738f, 0.26122525f, -0.16668192f, 0.10164799f, -0.06119332f, 0.06163369f, 0.09127983f, 0.04038644f, 
    -0.09110942f, 0.09269772f, 0.18463530f, -0.00237463f, -0.11796387f, 0.01463893f, -0.14048609f, 0.06097390f, 
    -0.06871054f, 0.05268755f, 0.01581569f, -0.01314378f, -0.03600543f, -0.02858406f, 0.00237176f, -0.04388485f, 
    -0.39319512f, -0.08252969f, -0.18130407f, -0.03426316f, -0.10318038f, 0.01862859f, 0.00975371f, 0.01552894f, 
    -0.15683305f, 0.08786991f, 0.01641563f, 0.07805707f, 0.12370840f, 0.19601645f, -0.27900153f, 0.04035458f, 
    -0.05784936f, 0.15268116f, 0.12450532f, -0.07210098f, -0.01402199f, -0.13085580f, -0.01060625f, 0.06687449f, 
    -0.07334720f, 0.02927637f, 0.06262452f, 0.10572747f, 0.18424682f, 0.09736671f, 0.00920119f, 0.04121270f, 
    -0.11279679f, 0.00863859f, -0.06061501f, -0.06593079f, -0.13646568f, -0.02528471f, -0.10862587f, 0.01490204f, 
    0.04103676f, 0.01290534f, 0.06201639f, 0.04843822f, 0.09451297f, -0.04392794f, -0.07108240f, -0.01562194f, 
    -0.06165872f, -0.15636648f, -0.08404360f, 0.09128699f, 0.02418500f, 0.07361376f, -0.01925924f, 0.01144229f, 
    0.05078784f, 0.00783720f, 0.02455471f, -0.04883876f, 0.01326771f, 0.17978007f, -0.06933742f, -0.03164048f, 
    -0.05506782f, -0.01841465f, 0.00760339f, 0.06662622f, 0.04129771f, 0.02413501f, -0.01364615f, 0.06488214f, 
    0.26223114f, 0.16763914f, -0.05445664f, 0.27200216f, -0.04301034f, -0.03977844f, -0.03115667f, 0.01751351f, 
    0.04308687f, -0.03906554f, -0.07449555f, -0.00184223f, -0.20372371f, -0.12820274f, -0.12279619f, 0.06317837f, 
    -0.05464694f, -0.05020740f, -0.09604408f, -0.00245389f, 0.06628571f, -0.07428858f, 0.10287665f, -0.02979661f, 
    -0.05910010f, -0.00077039f, -0.02556573f, 0.04527826f, -0.03370002f, -0.13543195f, -0.00104817f, -0.01674934f, 
    -0.07676227f, -0.08619872f, 0.04166171f, 0.04434265f, 0.13206431f, 0.04539241f, 0.08297399f, 0.11343774f, 
    0.04002548f, -0.11547805f, -0.00628881f, 0.12916559f, -0.02857886f, -0.07648913f, 0.09370352f, 0.03751808f, 
    -0.14397039f, 0.03267465f, 0.14680381f, 0.06394614f, -0.00960798f, 0.09586887f, 0.00396926f, 0.12765239f, 
    -0.04661378f, 0.03350739f, 0.21439098f, -0.05432887f, -0.05527408f, 0.00020462f, 0.30235913f, 0.21791473f, 
    0.04115935f, 0.09273463f, -0.00616282f, 0.06016936f, 0.00457325f, 0.02567852f, -0.02993108f, -0.01960796f, 
    0.37662849f, 0.13614742f, 0.14243716f, 0.11239550f, -0.02671113f, 0.02920233f, -0.07114934f, 0.13661629f, 
    0.05472909f, 0.13072738f, 0.11413632f, 0.02546521f, 0.14314860f, 0.06355467f, -0.02675304f, 0.17790517f, 
    -0.08785502f, 0.05083113f, -0.01277026f, 0.11673959f, -0.03348755f, 0.04267699f, -0.10275090f, -0.03921159f, 
    -0.18051057f, 0.27241418f, -0.03353412f, -0.15091358f, 0.06414697f, 0.09027886f, 0.08759134f, -0.10399380f, 
    -0.04346538f, 0.02926463f, 0.00812762f, 0.02733306f, 0.32279423f, -0.27773502f, -0.23737508f, 0.06593553f, 
    -0.04405018f, 0.09669707f, 0.07358447f, -0.04641555f, -0.04226128f, -0.00474803f, 0.03583981f, 0.00418891f, 
    -0.21348941f, 0.20955792f, 0.06426553f, -0.23844796f, 0.03793686f, -0.07316815f, 0.05413781f, -0.14861110f, 
    -0.17196842f, -0.01029703f, -0.10644525f, -0.03031085f, 0.00905059f, 0.14341924f, -0.14697762f, -0.03368427f, 
    0.11321338f, 0.02600975f, -0.04197289f, -0.17343618f, -0.11234224f, -0.02849521f, 0.02414910f, 0.01403842f, 
    -0.03104414f, 0.06490283f, 0.13273604f, -0.05162106f, 0.11542578f, -0.15374827f, -0.06519506f, -0.04871869f, 
    0.08381827f, 0.03345127f, 0.00558821f, 0.00512340f, -0.22637580f, 0.15197524f, 0.05660253f, -0.13026610f, 
    -0.04501113f, 0.07331790f, -0.00377294f, -0.01470814f, -0.18769166f, -0.08437026f, -0.12709385f, -0.09129171f, 
    0.12198533f, -0.27265725f, 0.13207892f, 0.03846330f, -0.05089115f, 0.11707032f, 0.04833831f, -0.09496966f, 
    0.03697805f, -0.01336480f, 0.04303658f, 0.12789820f, 0.16843006f, -0.02267748f, -0.19764717f, 0.00452941f, 
    0.17954750f, 0.02741387f, 0.04073022f, -0.01995846f, 0.06533502f, -0.04694440f, 0.06547759f, 0.02073111f, 
    0.07247896f, -0.00561664f, -0.01050311f, -0.06031470f, -0.02643723f, 0.03275981f, -0.03948025f, 0.13384497f, 
    0.08225196f, 0.05538352f, 0.00618453f, -0.06396873f, -0.21101001f, 0.04186576f, -0.12097148f, -0.11821616f, 
    0.12163990f, 0.04021034f, -0.10610895f, -0.02748828f, -0.10025650f, -0.12963115f, -0.10661580f, -0.01020539f, 
    -0.05851794f, -0.06243851f, 0.13667662f, 0.17356202f, 0.06385257f, -0.03437316f, 0.15125875f, 0.02237281f, 
    -0.03747354f, -0.13068734f, -0.06784273f, -0.00834658f, -0.21886612f, 0.10286181f, -0.06758687f, -0.03448045f, 
    0.10955856f, 0.02642948f, 0.02107012f, 0.17145967f, 0.01331204f, 0.00809315f, 0.05809362f, 0.04139834f, 
    -0.21829112f, 0.03984554f, 0.00031566f, 0.19156237f, 0.05198538f, 0.21597351f, 0.05594104f, 0.18202358f, 
    0.06217180f, 0.08461753f, -0.05056270f, 0.00179925f, 0.15155731f, -0.11505502f, 0.05652788f, 0.13148220f, 
    0.11105520f, -0.01698888f, 0.07070018f, 0.01532085f, 0.05036702f, 0.18486628f, 0.00385652f, -0.06787167f, 
    -0.08274249f, 0.02769626f, 0.15995042f, 0.05858659f, -0.03060629f, 0.01762862f, -0.13223694f, 0.14396508f, 
    -0.08249857f, -0.01603341f, 0.07817344f, -0.01863437f, 0.00045200f, 0.08951183f, 0.05150055f, 0.27226856f, 
    -0.14880262f, 0.04830367f, -0.00596460f, 0.24034204f, -0.00059445f, 0.08756629f, 0.05966998f, 0.00419385f, 
    -0.32607189f, 0.17365621f, -0.05010284f, -0.13072957f, -0.02836694f, 0.03623627f, 0.11974224f, 0.03567324f, 
    0.02158258f, 0.04066443f, 0.11889563f, 0.08071475f, 0.08987685f, -0.11801641f, 0.00481672f, 0.16130617f, 
    0.03865049f, 0.02723809f, 0.07658669f, 0.07092515f, 0.08328892f, 0.00434462f, 0.03278738f, 0.00523653f, 
    -0.22872348f, -0.06457049f, -0.13296756f, -0.07096942f, -0.07099173f, 0.09877143f, 0.02849121f, -0.02985078f, 
    -0.12848082f, 0.02146959f, 0.02392959f, 0.02037364f, -0.14970264f, 0.03595475f, -0.17927232f, -0.01156879f, 
    0.02827623f, 0.11500854f, 0.18028817f, -0.00918792f, 0.03526275f, -0.08533883f, 0.03025751f, -0.00559437f, 
    0.11078860f, 0.17316265f, 0.12447712f, 0.04632045f, 0.13606831f, 0.06402882f, -0.03961862f, 0.01447301f, 
    0.09632277f, -0.06163172f, -0.10899923f, -0.07981206f, -0.21225382f, 0.05636748f, -0.04254301f, -0.19603422f, 
    0.04694485f, 0.06810412f, 0.05994352f, -0.00486063f, 0.09520985f, 0.10670125f, -0.06471667f, -0.13392006f, 
    -0.12325174f, -0.21251452f, 0.13295540f, 0.02739919f, -0.02729112f, 0.10435499f, -0.03493578f, 0.04680557f, 
    -0.08625182f, 0.06125197f, 0.05722401f, 0.04226633f, 0.01490136f, 0.06721131f, -0.10053036f, -0.01324273f, 
    -0.00184283f, 0.13232210f, 0.04260415f, 0.02548232f, 0.01384559f, 0.02254820f, 0.04317167f, 0.04599657f, 
    0.10169812f, -0.02158700f, 0.05711617f, 0.05830591f, -0.03521039f, 0.01650489f, 0.00832193f, 0.12241023f, 
    -0.07827111f, 0.07055110f, 0.04073469f, -0.11931251f, -0.28043911f, -0.07620452f, -0.21612839f, -0.27261871f, 
    0.00343535f, -0.06742965f, -0.07248607f, -0.04959474f, -0.01922561f, -0.13195746f, -0.03073057f, 0.06721549f, 
    0.02125862f, -0.09667999f, -0.04997427f, 0.13289332f, 0.02138242f, -0.08569870f, 0.09583870f, 0.00202547f, 
    -0.10102182f, 0.00271909f, 0.02067109f, 0.06801369f, 0.16280311f, 0.01812008f, -0.05659110f, 0.20599453f, 
    -0.04454429f, -0.00151501f, -0.02598776f, 0.12207514f, 0.04175730f, 0.06908356f, 0.05154885f, 0.06690315f, 
    -0.02132492f, -0.11530975f, 0.07516062f, 0.12733296f, -0.04397711f, 0.01752858f, -0.03534504f, 0.11047918f, 
    0.00016183f, 0.05548321f, 0.16652520f, -0.01254537f, 0.20310988f, -0.00529629f, 0.12039382f, -0.00199951f, 
    -0.00055448f, 0.04281219f, -0.03220417f, 0.10884638f, 0.06816743f, -0.08356161f, 0.01109667f, -0.02956122f, 
    -0.01283389f, 0.13022473f, 0.10299435f, 0.09257337f, -0.05870591f, 0.03240131f, -0.14539778f, 0.03833566f, 
    0.00415106f, -0.00710974f, 0.02099185f, 0.04191383f, 0.00736554f, 0.00390960f, 0.05052611f, 0.02928070f, 
    -0.07414490f, 0.02886756f, -0.09305687f, 0.14103709f, 0.02834253f, 0.05415124f, -0.02409336f, -0.14461479f, 
    -0.26513290f, 0.05940944f, 0.00954789f, 0.04290401f, -0.03036723f, -0.09412621f, 0.04450703f, 0.10219433f, 
    0.02111216f, -0.14295001f, -0.00795840f, -0.09653332f, -0.13127112f, 0.01704113f, 0.15713485f, 0.08986991f, 
    0.11425555f, 0.02358370f, -0.07772313f, -0.08426191f, 0.10093856f, 0.02870196f, 0.03221130f, 0.15255576f, 
    0.24147651f, 0.06394424f, 0.23355949f, 0.06039056f, 0.03709698f, 0.02621840f, -0.12183332f, 0.05953214f, 
    0.20174906f, 0.03891506f, 0.17688365f, 0.03575099f, -0.34579036f, -0.14984038f, 0.16772400f, -0.10518623f, 
    0.12027425f, -0.10086509f, 0.09629160f, 0.02529436f, -0.00501635f, 0.07096506f, -0.00383127f, -0.00244068f, 
    0.09106270f, 0.02403373f, 0.06035699f, -0.10262363f, 0.03380927f, 0.10955310f, -0.03174029f, -0.03901210f, 
    0.09855869f, 0.08263492f, 0.01419683f, 0.06548531f, -0.24080239f, 0.14609659f, 0.31939521f, -0.06125881f, 
    0.06295478f, 0.05609005f, 0.02659977f, 0.05091997f, -0.03757496f, 0.11203919f, -0.00763855f, 0.07353893f, 
    -0.58285409f, 0.12955615f, -0.01313514f, 0.23840973f, 0.15317063f, 0.12719515f, -0.00400839f, 0.03078640f, 
    0.00441212f, -0.01936833f, -0.06610123f, -0.06333052f, -0.04206892f, -0.09313694f, -0.03120886f, -0.15821889f, 
    -0.05431586f, -0.20649144f, 0.09579656f, -0.06213446f, -0.04739566f, 0.09385322f, 0.08887729f, 0.08244745f, 
    0.09037884f, 0.02090222f, 0.05224568f, -0.22331493f, 0.12551631f, 0.00109558f, 0.08289328f, 0.04107672f, 
    0.10298176f, -0.01567412f, 0.01078534f, 0.15473115f, -0.12475930f, 0.04340474f, 0.18404901f, -0.08663983f, 
    0.10523587f, -0.01614550f, -0.07851398f, 0.10391464f, 0.03430041f, 0.06626766f, -0.00456446f, -0.00818425f, 
    -0.19390695f, -0.16782364f, -0.19783756f, -0.24964064f, -0.02720681f, 0.05016189f, 0.05875571f, 0.03818798f, 
    0.00803578f, 0.12891553f, 0.13275835f, 0.06603331f, 0.34031913f, -0.09429140f, -0.00607934f, 0.26027748f, 
    -0.06378975f, -0.07944021f, -0.13279432f, -0.06642587f, 0.10897093f, 0.08389500f, 0.00827663f, -0.09273494f, 
    0.16927683f, -0.24764055f, -0.23672161f, -0.19204994f, -0.03167097f, 0.02762104f, 0.09815574f, 0.00695876f, 
    0.13613473f, -0.02526971f, 0.07267652f, 0.03956811f, 0.27697244f, 0.30939308f, 0.06327183f, 0.01483703f, 
    0.18894829f, 0.08654036f, 0.14953209f, 0.01400432f, 0.08524479f, -0.01400221f, -0.06723674f, 0.07545891f, 
    0.07338375f, 0.13793910f, 0.05032881f, 0.07003761f, -0.08953924f, 0.12357714f, 0.06494647f, 0.13507935f, 
    -0.05482900f, -0.07535404f, 0.10639768f, -0.04678409f, -0.11694104f, -0.16260226f, -0.10568069f, -0.22945477f, 
    0.09757375f, -0.09281851f, 0.05010748f, 0.09398198f, 0.10242171f, -0.04758800f, -0.09927098f, 0.10823568f, 
    -0.04566101f, 0.01146365f, -0.06626315f, -0.01428535f, -0.01418896f, -0.03292036f, -0.04466983f, -0.06948771f, 
    0.05509275f, 0.06162687f, -0.07270971f, 0.00023769f, 0.06150597f, -0.07180052f, -0.02114094f, -0.07566136f, 
    0.04213962f, -0.02441850f, 0.03316673f, 0.05060640f, 0.01876307f, -0.03870564f, -0.05954868f, -0.06360834f, 
    -0.05246926f, 0.03700520f, 0.05275214f, -0.02702093f, 0.05205306f, -0.06598152f, -0.00348138f, -0.06200754f, 
    0.03353542f, 0.05600131f, 0.04815945f, -0.06143209f, -0.01356073f, -0.05973531f, -0.04725190f, -0.04054793f, 
    0.04792510f, -0.03267253f, 0.01903405f, -0.01118283f, 0.03948068f, -0.03202263f, -0.06324513f, -0.02252599f, 
    -0.03098200f, 0.02618033f, -0.04050128f, -0.05853212f, 0.00452231f, 0.02863022f, -0.05410861f, -0.06263952f, 
    -0.02236365f, 0.01937165f, -0.00271499f, 0.02878786f, -0.04245365f, -0.03527572f, -0.00724987f, -0.00363135f, 
    0.00636710f, -0.07090037f, -0.04590326f, -0.01892744f, 0.04963537f, -0.07235851f, -0.00040330f, -0.02715740f, 
    -0.01315471f, -0.01071193f, -0.07837657f, -0.02418576f, 0.05685570f, -0.05991280f, -0.07430061f, -0.00531226f, 
    -0.01669630f, 0.01096180f, -0.05536493f, -0.04202291f, 0.00818894f, 0.02704454f, -0.01631165f, 0.04414535f, 
    -0.04447481f, 0.03541818f, 0.04277556f, 0.02892037f, -0.02094835f, 0.00246889f, -0.06245163f, 0.03907225f, 
    -0.02734339f, -0.00031648f, -0.01589124f, 0.05768880f, -0.02522149f, 0.00248672f, 0.00229074f, 0.00805416f, 
    0.03301886f, -0.03437752f, 0.01055131f, -0.00510926f, -0.07811991f, -0.04958113f, 0.06045059f, -0.04623700f, 
    -0.07230446f, -0.03585726f, 0.02453282f, -0.07008390f, -0.02454640f, 0.05385921f, -0.05956818f, 0.05519087f, 
    -0.06969314f, -0.03541017f, -0.05668339f, 0.05752644f, -0.05658200f, 0.04809749f, -0.04349457f, -0.07171921f, 
    0.03424444f, 0.03735751f, -0.07633612f, -0.06495116f, -0.03127874f, -0.04946277f, 0.05110823f, 0.06254975f, 
    -0.00136048f, -0.02866189f, 0.00011957f, -0.01353279f, 0.06306720f, 0.00625071f, -0.00530025f, -0.05229602f, 
    -0.01898323f, 0.02809175f, 0.05164289f, -0.01605080f, -0.01849990f, -0.06079559f, 0.02299779f, -0.07328709f, 
    0.06218898f, 0.04095891f, 0.04625387f, 0.04148584f, -0.07006032f, -0.00134761f, -0.00895564f, -0.07256778f, 
    -0.04605616f, 0.04642158f, 0.01976137f, 0.02042189f, -0.07531784f, 0.03638729f, -0.04342123f, 0.00047171f, 
    -0.00080973f, -0.04580997f, -0.01503260f, 0.02410720f, -0.04046562f, 0.02245576f, 0.02593018f, -0.03623131f, 
    0.05753354f, 0.00829146f, -0.07343026f, 0.03874952f, 0.06397033f, 0.00614880f, 0.05660636f, 0.06158102f, 
    -0.02478521f, 0.03928449f, -0.06340086f, -0.04410012f, 0.01327659f, 0.05237472f, -0.07327875f, 0.02150633f, 
    0.08989284f, 0.14713548f, -0.08780160f, -0.07629224f, 0.22906817f, -0.06152932f, -0.00151515f, -0.05906658f, 
    -0.05909489f, 0.16111664f, 0.19465110f, 0.09738545f, 0.18219033f, -0.03332480f, -0.12322184f, 0.16682783f, 
    -0.07970244f, -0.07219586f, 0.13114376f, -0.05764590f, -0.06571019f, -0.00346721f, -0.01328642f, -0.11466081f, 
    0.04889792f, -0.06880266f, -0.04505906f, 0.04966435f, 0.04282937f, -0.07881197f, 0.19063950f, -0.04018778f, 
    -0.13631408f, 0.06190404f, -0.11630768f, 0.01145329f, 0.07040952f, 0.07360188f, -0.04088345f, 0.15553589f, 
    0.12324683f, 0.13217849f, 0.12143776f, 0.00830158f, 0.01045506f, -0.06078744f, -0.00510567f, 0.07122281f, 
    -0.17451197f, 0.11151630f, -0.09335858f, -0.15776402f, -0.03782171f, 0.08626603f, -0.05199445f, 0.02225852f, 
    -0.09515321f, -0.04998818f, -0.03960589f, -0.16822329f, 0.06054818f, 0.24583614f, -0.11201145f, 0.01000133f, 
    0.26047793f, 0.03829423f, -0.01727833f, -0.03399310f, 0.05187957f, -0.01651728f, 0.01095865f, -0.14579345f, 
    0.25771964f, -0.07919248f, 0.12344139f, -0.18160208f, -0.03527985f, -0.05321526f, 0.04302139f, -0.11363199f, 
    -0.04080606f, -0.04898769f, 0.08228478f, -0.02175512f, 0.24549142f, 0.05366807f, 0.08033268f, 0.13341798f, 
    -0.04246206f, 0.04267196f, 0.07717770f, 0.11726322f, -0.07752524f, -0.00622276f, 0.05775093f, -0.00966886f, 
    -0.06368679f, 0.02426872f, -0.15086457f, 0.13254327f, 0.07575550f, 0.02329437f, -0.05784822f, -0.06764836f, 
    -0.10872571f, 0.02058529f, 0.04247880f, -0.10669058f, 0.04565603f, 0.03449576f, -0.08053728f, -0.02236015f, 
    0.16446455f, -0.04353835f, -0.05276236f, -0.04428333f, 0.10899501f, -0.08606768f, -0.10256676f, -0.04596799f, 
    -0.07966079f, 0.12346993f, 0.29664949f, 0.23949723f, 0.02084699f, -0.03089816f, 0.02213724f, -0.01307005f, 
    -0.12740348f, -0.22138147f, -0.10647130f, 0.08026353f, 0.13187353f, -0.06248640f, 0.25592595f, 0.12288062f, 
    -0.01240056f, 0.02673656f, -0.04094733f, 0.05821171f, 0.02150090f, 0.00566247f, -0.06716589f, 0.04003484f, 
    0.10959776f, 0.09899844f, 0.31603274f, 0.28941235f, 0.02200316f, -0.07002987f, 0.01435233f, 0.11068817f, 
    -0.00638670f, 0.03312724f, 0.13677552f, 0.03862770f, 0.07156029f, -0.29087350f, -0.10682518f, -0.08832196f, 
    0.00386018f, 0.02214628f, -0.03671125f, 0.02654443f, 0.03622311f, 0.02357486f, 0.00777384f, -0.07761449f, 
    -0.10116842f, 0.06234965f, -0.12056292f, -0.31484285f, 0.03891424f, 0.05713765f, -0.07634804f, -0.05809564f, 
    -0.01387132f, 0.17766950f, -0.00157613f, 0.14024860f, 0.05659510f, 0.29152536f, 0.11542491f, 0.14806375f, 
    0.03816683f, -0.03520108f, 0.04993818f, 0.05897003f, -0.03826989f, 0.05402429f, 0.14939493f, -0.19943818f, 
    -0.00954761f, -0.00727972f, -0.03353360f, -0.08732256f, 0.03390557f, 0.02472161f, -0.04762076f, -0.03667939f, 
    -0.01533839f, -0.03478479f, -0.02846062f, -0.08657309f, -0.04382324f, -0.08773711f, -0.02623866f, 0.05415814f, 
    -0.04941915f, -0.04477751f, 0.00996963f, -0.09484143f, 0.01982421f, -0.09020425f, -0.07255420f, 0.01178158f, 
    -0.03490173f, -0.03153427f, 0.00094078f, -0.03837836f, 0.04764792f, -0.05383712f, 0.01382745f, -0.01906333f, 
    -0.04208777f, -0.02863903f, -0.05785336f, -0.07540305f, -0.04864730f, -0.01796845f, -0.07449628f, -0.03585741f, 
    -0.07998347f, -0.07070654f, -0.00294798f, -0.02079439f, 0.01544549f, 0.01291587f, 0.06291147f, 0.03127090f, 
    0.02596257f, -0.06160989f, -0.05579531f, -0.00077466f, -0.04017205f, 0.02425521f, -0.09574310f, 0.01533895f, 
    -0.00726850f, -0.00839113f, -0.03649210f, -0.07357536f, 0.04827090f, 0.02022625f, 0.00984630f, 0.02688937f, 
    -0.05499177f, 0.00498886f, -0.05885782f, 0.04639862f, 0.05297559f, 0.00143381f, 0.01186007f, -0.06265898f, 
    -0.08196504f, 0.01260257f, -0.07486349f, -0.03066154f, 0.05207953f, -0.08558987f, 0.03039910f, -0.07382333f, 
    -0.03667497f, -0.09235065f, 0.02239266f, 0.03917442f, -0.07542247f, -0.03997802f, 0.02333847f, 0.02259691f, 
    -0.07504652f, -0.01576803f, 0.00621133f, -0.03742260f, -0.01372290f, -0.07466490f, -0.09261564f, 0.03582574f, 
    -0.09252913f, 0.01067450f, -0.08615648f, -0.00902282f, -0.03100246f, -0.08344813f, 0.02276394f, 0.00310677f, 
    -0.03288965f, -0.02336528f, 0.04031465f, -0.03727490f, -0.04466139f, 0.05463365f, -0.00229643f, -0.05852338f, 
    0.03678932f, -0.05885798f, 0.04693517f, -0.03090389f, 0.04369618f, 0.03057879f, -0.05716851f, -0.10499325f, 
    0.04888173f, 0.03897144f, -0.00804048f, 0.01585842f, -0.08729909f, -0.11236522f, -0.02320041f, -0.09907780f, 
    -0.05021724f, 0.01428993f, -0.00836316f, -0.08167803f, 0.03723986f, 0.00598999f, -0.09216689f, -0.04952284f, 
    -0.00523475f, -0.10809399f, 0.00624228f, -0.01470616f, -0.05091827f, -0.08930212f, 0.01507643f, 0.00805220f, 
    0.02343299f, 0.02813252f, 0.00482597f, 0.03037527f, -0.03232685f, -0.10191912f, 0.00297062f, -0.05985056f, 
    0.02792993f, -0.01078132f, -0.06687878f, -0.09243260f, -0.08803088f, 0.01779716f, -0.07209140f, -0.04403330f, 
    -0.05662458f, 0.00620000f, -0.05194532f, -0.00787646f, 0.04062643f, -0.05486616f, 0.04445646f, 0.00210545f, 
    -0.02402749f, 0.01742465f, -0.06451266f, -0.10828908f, -0.04105591f, -0.07415261f, 0.02129043f, 0.03971658f, 
    -0.02017352f, 0.04198918f, 0.05308244f, 0.00735073f, -0.07879355f, -0.09240828f, 0.01393363f, 0.01822347f, 
    -0.03561365f, -0.00723624f, -0.05952855f, -0.06253213f, 0.02508334f, 0.00245782f, -0.03656206f, -0.07662435f, 
    -0.03327961f, 0.06932149f, -0.04332114f, -0.16209532f, -0.02902708f, -0.03225048f, -0.00688750f, -0.03185631f, 
    0.12443474f, -0.08425683f, 0.04979704f, -0.03067607f, 0.28480774f, -0.07015423f, 0.02049318f, 0.06609812f, 
    0.03146824f, 0.01676229f, -0.09522539f, 0.11448979f, -0.08660450f, 0.05724806f, -0.01951782f, -0.03966624f, 
    -0.11353248f, 0.02994330f, -0.17283674f, 0.06798611f, -0.09417548f, -0.06400208f, -0.06706270f, 0.04955055f, 
    0.00231929f, 0.07660342f, 0.08753414f, -0.06156081f, -0.42208856f, -0.29528385f, -0.00980070f, -0.06246971f, 
    0.05299266f, -0.07350329f, -0.07126888f, 0.11674011f, 0.02728719f, 0.13086313f, 0.08132138f, -0.02855562f, 
    0.29902545f, 0.12320395f, 0.07798383f, -0.22772761f, 0.06134757f, -0.05067995f, 0.23793297f, -0.08897848f, 
    -0.08738925f, 0.01305328f, 0.00780441f, 0.23168428f, -0.60857135f, -0.03234316f, -0.02937797f, -0.26900887f, 
    -0.01123420f, 0.01063376f, -0.11576845f, 0.05243633f, 0.11815596f, 0.10630400f, 0.10965626f, 0.09755991f, 
    -0.21194454f, -0.10877699f, 0.26835886f, 0.06860700f, 0.01380764f, -0.09184361f, 0.06010550f, -0.21446694f, 
    -0.08844692f, -0.04058303f, -0.16368057f, 0.16712049f, -0.20260791f, 0.08798564f, 0.04221387f, 0.09547250f, 
    0.15874413f, -0.13914609f, -0.04023115f, 0.07158609f, -0.07688531f, 0.12278835f, 0.17145422f, 0.11204218f, 
    -0.15664530f, -0.15159908f, -0.25169763f, -0.07351198f, -0.04090928f, 0.00673693f, -0.05896574f, 0.02933448f, 
    0.06992257f, 0.09603500f, 0.13451412f, 0.08169943f, -0.21821706f, 0.24487455f, -0.15123826f, -0.38603836f, 
    -0.03706891f, 0.04469378f, -0.11048448f, 0.05572782f, 0.05196704f, -0.00636081f, -0.00583973f, 0.03902673f, 
    0.10000344f, 0.10308129f, 0.17085883f, 0.23515451f, 0.05169868f, 0.12394676f, 0.15105203f, -0.03087435f, 
    0.06539187f, 0.09132490f, 0.04208032f, -0.10927050f, 0.12913352f, 0.07296867f, 0.00240039f, -0.14960344f, 
    0.02094113f, 0.05421827f, -0.13191502f, 0.10825095f, -0.02898694f, -0.18915755f, -0.09201460f, -0.09508672f, 
    -0.03648965f, 0.14187317f, 0.14542815f, 0.07763906f, 0.12971234f, 0.00470940f, 0.11844832f, -0.00004639f, 
    0.16699542f, 0.09623461f, -0.08239511f, 0.03018937f, 0.10892814f, 0.07050908f, -0.05414202f, -0.31267750f, 
    -0.25661099f, -0.05129584f, -0.11313573f, 0.05084644f, 0.05137944f, -0.07987293f, 0.11926698f, 0.11201220f, 
    -0.18473405f, 0.06020040f, -0.09934336f, 0.10966757f, 0.10769139f, 0.15328190f, 0.05532425f, -0.16451029f, 
    -0.00890966f, 0.13310902f, -0.02979699f, -0.12080082f, 0.14000252f, 0.15345520f, 0.10126811f, 0.17740276f, 
    0.18583849f, 0.24381368f, -0.05604368f, -0.00300518f, -0.03471955f, -0.02825410f, 0.24195671f, -0.06049219f, 
    0.06581723f, 0.00206581f, -0.02332003f, -0.05844468f, -0.04077296f, -0.03634854f, -0.00589396f, -0.04194670f, 
    -0.08012548f, 0.04826233f, 0.05899823f, 0.00216335f, 0.05029126f, 0.03731262f, 0.00159803f, -0.00845821f, 
    0.04900290f, 0.03143979f, 0.03379635f, -0.06596408f, 0.00474825f, 0.01665158f, 0.01233829f, -0.01557189f, 
    -0.00706834f, -0.00910998f, -0.07704762f, 0.01273198f, 0.06149374f, -0.04409941f, -0.04847565f, -0.04208148f, 
    0.02886072f, 0.06022999f, -0.06724733f, -0.03095097f, -0.01672506f, -0.03687720f, 0.03898767f, 0.00567205f, 
    0.02712281f, -0.05521613f, 0.06703798f, 0.03810428f, -0.01543606f, -0.04341112f, -0.00542506f, -0.03401214f, 
    -0.05052045f, -0.06891800f, 0.01730856f, -0.05890916f, 0.04285283f, 0.06963044f, 0.04594344f, -0.06805973f, 
    0.00243220f, -0.07804257f, -0.00122687f, -0.01510672f, 0.06317980f, -0.00433226f, 0.03738244f, 0.05311589f, 
    0.01205214f, -0.07768051f, -0.05321257f, -0.05548785f, -0.02916901f, 0.03051261f, 0.02302787f, 0.01141932f, 
    -0.05576264f, -0.04601225f, -0.07153427f, -0.07191927f, -0.04781248f, -0.06504388f, -0.05718226f, -0.01734162f, 
    0.05437363f, -0.00889840f, 0.06218561f, 0.04698375f, 0.04474081f, -0.05379298f, -0.03415484f, -0.03871794f, 
    -0.04627509f, 0.04475853f, -0.01346012f, -0.01771107f, -0.04881617f, -0.01986907f, 0.00999431f, -0.03021877f, 
    -0.00636048f, -0.04660806f, 0.05555301f, 0.03645581f, -0.01631152f, -0.02025269f, -0.01472395f, -0.07261274f, 
    0.01323398f, -0.05620854f, 0.04924115f, 0.00857087f, -0.04999134f, 0.06326160f, 0.02497777f, 0.03502564f, 
    0.02684719f, -0.08007003f, -0.02691300f, -0.06493673f, -0.06674042f, -0.05911811f, -0.03414088f, 0.03141243f, 
    0.04240795f, 0.02446110f, 0.00217021f, -0.05399334f, 0.02722956f, 0.04954056f, 0.03269029f, 0.03050854f, 
    -0.08024693f, 0.00161468f, -0.02257382f, 0.04516394f, -0.06300534f, 0.00422373f, 0.03376812f, -0.07131486f, 
    -0.04961291f, -0.01290233f, -0.04663449f, -0.07055425f, 0.04081293f, -0.06488036f, 0.05681777f, 0.00718878f, 
    -0.00818472f, 0.04116900f, -0.06204630f, 0.03862435f, -0.05968267f, 0.02091201f, 0.05074359f, -0.04158248f, 
    -0.01511014f, 0.00164083f, -0.04287019f, -0.05971746f, -0.06136304f, -0.00448870f, 0.03521092f, 0.03445316f, 
    -0.03445262f, -0.02620873f, -0.03519196f, -0.04243285f, 0.02114833f, -0.00515960f, 0.02721550f, -0.00517213f, 
    0.06327894f, -0.05153216f, 0.01876281f, 0.01532572f, 0.05643422f, -0.03694389f, -0.03666452f, -0.03254601f, 
    0.00989839f, -0.06369837f, 0.04951528f, -0.04014535f, -0.07156231f, 0.04360505f, -0.02701970f, -0.01641767f, 
    -0.05696707f, -0.06106762f, -0.08068043f, -0.05538780f, -0.08716273f, -0.04204126f, 0.03934271f, -0.07599220f, 
    0.19642575f, -0.03044734f, -0.00989118f, -0.19286886f, -0.14008389f, -0.14521828f, 0.04572435f, -0.00644674f, 
    0.15286626f, -0.12255955f, 0.02833389f, -0.00156412f, -0.14838956f, -0.00624279f, -0.14462167f, -0.04602413f, 
    -0.03875246f, 0.12591769f, 0.09730246f, 0.01895275f, -0.04579938f, 0.07054108f, -0.05130073f, 0.02776830f, 
    -0.35730270f, -0.07530496f, 0.01024233f, -0.18386596f, 0.08843483f, 0.05683505f, 0.01608054f, 0.08154768f, 
    -0.06509797f, 0.03360006f, -0.01362845f, -0.00938444f, -0.02154452f, -0.10439271f, -0.07300160f, -0.08862606f, 
    0.06842000f, 0.02315069f, 0.09001312f, 0.07987889f, -0.05494960f, 0.11212121f, 0.02569916f, 0.00454099f, 
    0.39765629f, 0.07725815f, 0.08931287f, 0.11575039f, 0.06860320f, -0.05889596f, 0.15465352f, 0.00676073f, 
    -0.00225160f, 0.10809793f, 0.10736399f, 0.08331686f, -0.07059472f, -0.11208091f, -0.09049603f, -0.12545924f, 
    -0.08473664f, -0.04184340f, 0.00806350f, -0.03315970f, 0.19104286f, 0.06112704f, 0.02715666f, 0.05631313f, 
    0.05432488f, -0.05733128f, 0.29632488f, 0.14734784f, -0.05298092f, -0.10806792f, 0.03384677f, -0.04148731f, 
    0.00221527f, 0.05658206f, 0.03940147f, -0.00148728f, -0.03608888f, 0.06118495f, 0.04299277f, 0.01320669f, 
    0.11663434f, 0.04129513f, 0.12466176f, 0.09337632f, 0.11002795f, 0.06103771f, -0.00418479f, -0.03709409f, 
    -0.12140178f, -0.18051009f, -0.03749098f, 0.29445559f, -0.04934368f, 0.02324013f, 0.09316488f, -0.04623441f, 
    0.08888648f, 0.01373476f, -0.14653696f, 0.02851759f, -0.06598256f, 0.09883052f, -0.12615077f, -0.21579352f, 
    -0.14266646f, 0.04014064f, -0.03311526f, 0.08664582f, 0.03619044f, 0.06642890f, 0.00746904f, 0.13218756f, 
    0.23646615f, -0.05981085f, -0.01277166f, 0.26995307f, -0.04038424f, 0.06223618f, 0.09810404f, -0.10941605f, 
    0.03589756f, 0.02984403f, 0.00501947f, -0.12696917f, -0.25245941f, 0.14195737f, -0.04762971f, -0.23382084f, 
    0.03916046f, 0.06117245f, 0.15876363f, 0.07470808f, 0.08241972f, -0.08254600f, 0.09257685f, 0.09066994f, 
    -0.23668888f, 0.15169974f, 0.03869860f, 0.06784766f, 0.11487834f, 0.10514991f, 0.11891581f, 0.02545954f, 
    -0.11655406f, 0.03267599f, -0.11743698f, 0.04775532f, -0.10123329f, 0.20022295f, 0.14368773f, 0.27247122f, 
    -0.17509761f, -0.14506224f, -0.04381902f, 0.04363459f, 0.07281734f, -0.00855727f, 0.01572723f, 0.23277988f, 
    0.16178407f, -0.13876176f, 0.01635896f, 0.18373850f, -0.08581368f, 0.08525441f, 0.08762048f, -0.07792675f, 
    0.00988335f, 0.10535426f, 0.02982960f, 0.06890679f, -0.09050876f, -0.07029856f, -0.06031563f, 0.06628432f, 
    0.08555143f, -0.00439507f, 0.09806950f, -0.06180064f, -0.08439322f, 0.04576735f, 0.00644808f, 0.00601344f, 
    0.22418754f, -0.08567428f, 0.01302375f, 0.13225394f, -0.26394847f, -0.03255076f, -0.06902065f, 0.02139287f, 
    -0.04536490f, 0.03128634f, 0.01203473f, -0.01090379f, -0.31409416f, -0.04231045f, -0.12507205f, -0.19726494f, 
    0.05625078f, 0.00776737f, 0.01421120f, -0.06960300f, 0.03276137f, 0.00259677f, 0.01506776f, -0.14144205f, 
    -0.07416565f, 0.11441941f, 0.01630379f, -0.05064505f, -0.00834889f, 0.00209733f, 0.05011325f, -0.03360508f, 
    0.08476614f, 0.06132629f, -0.12575562f, 0.02744992f, 0.35924408f, -0.00000826f, 0.09833537f, 0.21416636f, 
    -0.17515194f, 0.07810902f, -0.12581618f, 0.00748659f, 0.08364597f, -0.03183161f, 0.04029419f, -0.00243238f, 
    -0.03737127f, -0.16341399f, -0.04989574f, 0.14319836f, -0.06176486f, 0.00581722f, -0.08487764f, 0.06511799f, 
    -0.01406074f, -0.05325040f, 0.07527202f, -0.02490395f, 0.15782838f, -0.14790273f, -0.11876101f, 0.12007173f, 
    -0.02841319f, -0.07981070f, 0.02000154f, 0.07521427f, 0.04310381f, 0.03102401f, 0.00561961f, -0.08977411f, 
    0.00323333f, -0.04185659f, -0.03430002f, -0.17281531f, -0.08320625f, -0.00658440f, -0.09014426f, 0.09840216f, 
    0.07297857f, -0.02134848f, 0.12571613f, -0.01116962f, 0.05659986f, 0.17387864f, 0.24239741f, 0.07162780f, 
    0.11164294f, 0.10950562f, -0.10389946f, -0.04732478f, 0.01806919f, 0.03776519f, -0.05201665f, -0.17866184f, 
    -0.11022954f, 0.24318241f, 0.23619817f, 0.09734181f, 0.13734853f, 0.07710017f, 0.08098187f, 0.12075988f, 
    0.15654850f, -0.14210017f, -0.12501250f, 0.01717692f, 0.14789820f, -0.12622645f, -0.00124156f, 0.34380299f, 
    -0.20029448f, -0.10800222f, -0.01563321f, -0.02035533f, -0.03931081f, 0.08885692f, 0.10077755f, 0.09420753f, 
    0.31136152f, 0.14483203f, 0.06639307f, -0.01538204f, 0.00712317f, -0.09429400f, 0.05641158f, -0.00229024f, 
    0.05900568f, -0.06581454f, 0.09568910f, 0.03090711f, -0.29489529f, 0.19152562f, 0.06427936f, -0.07893836f, 
    0.11496749f, 0.03066103f, 0.05477233f, -0.05263247f, 0.09773106f, 0.04913217f, 0.04447804f, 0.00929775f, 
    0.15226357f, 0.27483493f, 0.20158659f, -0.07842486f, 0.15487882f, 0.16017382f, 0.00807277f, 0.05358008f, 
    -0.01804800f, 0.04872267f, -0.07762446f, 0.03359086f, -0.08098105f, -0.21078028f, 0.18778834f, 0.18527637f, 
    0.05162145f, -0.04124806f, -0.11643914f, 0.02557992f, -0.01682966f, 0.08624870f, -0.05658315f, -0.00901043f, 
    0.28313845f, 0.21608561f, -0.12809452f, 0.14260443f, 0.02691302f, -0.10348252f, -0.07359225f, -0.02188846f, 
    0.03146592f, 0.03039936f, -0.07902524f, -0.06940966f, 0.07454835f, 0.09819207f, -0.08078000f, 0.04665145f, 
    -0.02508461f, -0.08266304f, -0.01046990f, -0.12611473f, 0.07019994f, 0.01613268f, -0.03296010f, -0.10238500f, 
    0.24945198f, -0.27769652f, 0.13915488f, 0.09953634f, -0.10510131f, 0.07231383f, -0.04624973f, -0.03524286f, 
    -0.00322250f, -0.10011890f, -0.06840318f, 0.04646539f, 0.03844979f, -0.03866002f, -0.01820523f, -0.03273948f, 
    -0.02909691f, 0.02484260f, 0.02111538f, -0.04627398f, 0.03675667f, 0.05348289f, -0.09423354f, 0.03125320f, 
    0.01866592f, 0.15066029f, -0.02836805f, 0.04545962f, -0.03461041f, -0.02145892f, -0.03724514f, 0.05273327f, 
    -0.04934705f, -0.01234720f, 0.13971062f, 0.03917027f, 0.15079838f, -0.34164977f, -0.03299462f, 0.22188769f, 
    -0.03607697f, -0.11435269f, 0.01882352f, 0.02789654f, -0.02289961f, 0.04713445f, -0.07812680f, 0.05678593f, 
    0.07224708f, -0.16586651f, 0.13374019f, 0.14647470f, 0.00131381f, 0.01073790f, 0.08284771f, 0.04879014f, 
    -0.00213571f, -0.00425513f, 0.14787120f, 0.11242553f, 0.03289543f, -0.30402610f, -0.03910223f, 0.25336719f, 
    -0.03087777f, -0.07893735f, 0.00964309f, 0.02295936f, 0.04122927f, 0.04447304f, -0.03905826f, 0.04109999f, 
    -0.26740220f, -0.05590246f, 0.03419161f, -0.23679988f, 0.01529096f, -0.06669931f, 0.05336440f, 0.01948259f, 
    0.00744612f, 0.02527343f, -0.05235939f, 0.11840487f, 0.14776777f, 0.22819948f, 0.10279872f, -0.02425912f, 
    0.04276359f, -0.03095195f, -0.06271221f, 0.03425132f, 0.14126909f, 0.03450661f, -0.09609429f, -0.04846893f, 
    0.08402615f, 0.26450720f, 0.00163755f, -0.34797752f, -0.07633406f, 0.04097843f, -0.03499167f, -0.07254115f, 
    0.00969952f, 0.02582575f, 0.02665303f, 0.09799045f, 0.01634755f, -0.08180561f, 0.05014120f, 0.38696259f, 
    -0.06437544f, 0.11807014f, -0.02579215f, 0.10266768f, -0.03706902f, 0.00120207f, 0.14996749f, -0.02225954f, 
    -0.04015063f, 0.07948868f, -0.06198238f, -0.12439077f, -0.09240411f, -0.08882182f, -0.00446106f, 0.08740189f, 
    0.02791462f, 0.04149382f, 0.01457277f, 0.07759739f, -0.21191020f, 0.20432910f, -0.13620204f, -0.03233826f, 
    -0.05601308f, 0.01804159f, 0.04647881f, 0.01968062f, 0.05945119f, 0.07050461f, -0.03622992f, -0.07081156f, 
    0.21220982f, 0.19928148f, -0.00536272f, 0.05610357f, -0.04765667f, 0.01585272f, 0.01454801f, 0.04931665f, 
    -0.04718825f, -0.02637973f, -0.11300944f, -0.04986001f, -0.21930447f, 0.28324670f, 0.21819358f, 0.06133271f, 
    0.07820386f, 0.02863353f, 0.02700275f, 0.01134330f, 0.08664475f, 0.10030448f, 0.02507655f, 0.03287566f, 
    0.27547020f, 0.12180106f, -0.14293179f, -0.12510717f, 0.07839613f, -0.01067636f, 0.08074447f, -0.03071135f, 
    0.03392556f, -0.07777578f, -0.01753921f, -0.00461855f, -0.04191417f, -0.04592691f, 0.20320643f, -0.14064783f, 
    -0.06091783f, 0.08438928f, 0.01975792f, 0.06122708f, 0.07713890f, 0.07547358f, 0.06140568f, 0.09786579f, 
    0.22979884f, -0.27943632f, 0.07756339f, -0.15736136f, 0.07556310f, -0.06578045f, 0.00229565f, -0.01198232f, 
    0.11918298f, 0.05237933f, 0.09001012f, 0.09704471f, -0.17352800f, -0.05993962f, -0.23984480f, 0.05156246f, 
    -0.05494937f, 0.06065154f, 0.19832323f, 0.00458544f, -0.05236705f, -0.03207826f, 0.00705532f, 0.02601769f, 
    -0.12089684f, -0.18819749f, 0.24834682f, -0.22410344f, 0.02470118f, 0.03971996f, -0.00381442f, 0.03169191f, 
    -0.06378458f, 0.01771325f, 0.11729756f, 0.08127380f, -0.06124064f, -0.13942859f, -0.14693223f, -0.06657539f, 
    0.13100447f, -0.06155360f, 0.04365350f, -0.08730861f, 0.01395499f, 0.00318565f, -0.07323014f, 0.03036836f, 
    0.17394790f, 0.17472430f, -0.05866920f, -0.06185042f, 0.02319733f, 0.01292592f, -0.13270044f, -0.03187336f, 
    -0.06459881f, 0.06024220f, 0.00335447f, -0.03036279f, -0.11544285f, 0.01511096f, 0.06716961f, 0.05493743f, 
    -0.02721751f, 0.07442887f, 0.04211861f, -0.07841004f, 0.08137717f, 0.09257732f, 0.06104655f, -0.00111721f, 
    -0.34598133f, -0.07605819f, -0.01624307f, 0.05860702f, -0.06046290f, -0.00651248f, 0.14489689f, -0.01434756f, 
    0.11538707f, -0.02254331f, 0.02298303f, -0.08008264f, -0.01830816f, 0.23830763f, 0.03673262f, 0.04690417f, 
    0.05535180f, -0.16462921f, 0.11019321f, 0.06339102f, -0.03134730f, 0.11669096f, -0.07935470f, 0.15508275f, 
    0.25956872f, -0.20077328f, -0.07642023f, 0.28066537f, 0.15118520f, -0.08199666f, 0.12751603f, -0.13756652f, 
    -0.00331365f, 0.04900638f, -0.05819800f, 0.02184990f, 0.01466465f, -0.09794488f, 0.16721007f, -0.10413366f, 
    0.00209265f, 0.09211939f, -0.03239153f, -0.17303401f, 0.16005923f, -0.04431685f, 0.16285463f, 0.02008329f, 
    -0.17068656f, 0.06468219f, -0.15257274f, 0.31688011f, -0.16241734f, -0.07426760f, 0.00772469f, 0.04186881f, 
    -0.17720427f, -0.05599529f, -0.06941894f, -0.02609200f, 0.32588765f, -0.24786456f, 0.01036994f, -0.09207748f, 
    -0.07414605f, -0.07456723f, 0.07933585f, 0.12009204f, 0.09579125f, -0.09475065f, 0.04713489f, 0.06904665f, 
    0.12885745f, -0.04766500f, -0.06931165f, 0.08945491f, -0.15920576f, -0.14957930f, 0.15769094f, 0.10753986f, 
    -0.02742910f, -0.05830959f, -0.07033978f, 0.04798257f, 0.21432893f, 0.30203742f, 0.10768864f, 0.09780130f, 
    0.04401751f, 0.13528672f, 0.06122507f, -0.00950313f, 0.08598648f, 0.09834286f, 0.09424762f, 0.02719542f, 
    0.15507692f, 0.10234857f, -0.06181187f, -0.03650699f, 0.06243616f, 0.05511162f, -0.04635833f, 0.09592746f, 
    -0.01517546f, 0.13163064f, 0.06085883f, 0.07600101f, -0.20426720f, -0.04206619f, -0.01775658f, 0.07730968f, 
    0.10595606f, -0.19415505f, 0.02784032f, 0.04582996f, 0.04243832f, 0.12100179f, 0.03975002f, 0.04546679f, 
    -0.04916576f, -0.09450665f, 0.09799096f, -0.02932619f, 0.22494324f, 0.14255525f, 0.05370846f, 0.05103384f, 
    0.06069193f, 0.19455071f, 0.11672463f, 0.17005242f, 0.17751105f, 0.13724367f, 0.19542252f, 0.23997949f, 
    0.14986144f, 0.07299932f, 0.14693508f, 0.11027823f, 0.00835007f, 0.03222227f, 0.00081270f, 0.15525146f, 
    0.35520250f, -0.08336388f, 0.07770407f, 0.05133690f, 0.19233920f, 0.04130608f, -0.03739293f, 0.03195138f, 
    0.13928038f, 0.06149611f, 0.09520959f, 0.02271743f, -0.15306871f, 0.02862279f, 0.14112234f, -0.15681285f, 
    0.14811948f, 0.04557711f, 0.06452614f, 0.02053998f, 0.02975750f, 0.00839199f, 0.01873436f, -0.01757966f, 
    -0.02165304f, 0.09743468f, -0.10538792f, -0.08730434f, -0.03573676f, -0.04331018f, -0.06813612f, 0.02770937f, 
    0.00315386f, 0.10640837f, -0.06157545f, 0.12008390f, 0.18571970f, 0.28737846f, 0.21146895f, 0.12440896f, 
    0.23452115f, 0.06561956f, 0.08391912f, 0.00548851f, -0.00208762f, -0.01586790f, -0.04556762f, 0.03163127f, 
    0.19268847f, 0.14633170f, -0.02307790f, 0.18739909f, 0.07340027f, 0.10368093f, 0.14332600f, 0.01897983f, 
    0.01878521f, 0.02107703f, -0.01440168f, 0.02937802f, 0.08170057f, -0.16135861f, 0.04555325f, 0.04503934f, 
    -0.16271056f, 0.04320314f, 0.11739346f, 0.09988838f, 0.02971574f, 0.11681172f, -0.08606583f, 0.11220715f, 
    0.08214147f, -0.20312612f, 0.04287415f, 0.06319706f, 0.01292485f, -0.05166466f, 0.02958039f, 0.00786018f, 
    -0.02451191f, 0.14001788f, 0.13784446f, -0.05404302f, 0.06828655f, 0.05776750f, 0.14897165f, -0.11929005f, 
    0.21268168f, 0.09582345f, 0.06874684f, 0.02130406f, 0.10056236f, -0.03448423f, 0.08635470f, -0.03526433f, 
    -0.00319805f, 0.00275772f, -0.00173778f, -0.04370931f, -0.00944725f, -0.00543442f, 0.00777899f, 0.08171166f, 
    -0.02452976f, 0.12263709f, -0.09628447f, 0.00561725f, 0.32270357f, -0.04819154f, 0.02898142f, 0.12188543f, 
    -0.11171443f, 0.07291944f, 0.10862145f, 0.13088605f, 0.07979655f, 0.08500431f, 0.06202315f, 0.11531196f, 
    0.17588210f, 0.00031888f, -0.15700898f, 0.04259963f, 0.01013399f, -0.08012179f, 0.10082106f, 0.05447068f, 
    0.07824383f, 0.02255226f, 0.01166717f, 0.06157296f, 0.17298600f, 0.01279551f, -0.24358861f, -0.07120766f, 
    0.11571972f, 0.03626937f, 0.14056097f, 0.09301960f, -0.08067576f, 0.00740744f, 0.20643683f, -0.01376996f, 
    -0.31826004f, -0.16342455f, 0.00124413f, -0.09043479f, -0.08732904f, 0.13750419f, -0.01187334f, 0.08520361f, 
    0.05484539f, 0.05329096f, 0.09003665f, 0.13875246f, -0.02715003f, -0.00262199f, -0.03392331f, -0.01674253f, 
    0.12864247f, -0.05253166f, 0.06152776f, 0.19735532f, 0.07029247f, 0.08921105f, 0.03547715f, 0.13481079f, 
    -0.06235956f, 0.25643721f, 0.03964152f, -0.01867539f, -0.10925658f, -0.11027292f, -0.06954767f, 0.04007971f, 
    0.04309468f, 0.01317071f, -0.08328483f, -0.02864017f, 0.26382801f, -0.20336375f, 0.13736150f, -0.03148807f, 
    0.06664688f, -0.10714191f, -0.10828201f, 0.03556684f, 0.13862389f, 0.00626954f, 0.05048548f, 0.05922859f, 
    0.03821961f, 0.38178813f, 0.02504290f, -0.02008396f, -0.04204370f, 0.00968700f, -0.03746894f, -0.04734618f, 
    0.17828256f, 0.11831563f, 0.05135744f, 0.00350693f, -0.01283642f, 0.06532644f, 0.07147966f, 0.08645160f, 
    -0.04453588f, -0.09205454f, -0.03930580f, 0.05002426f, 0.10784994f, 0.12427562f, 0.06661762f, 0.08312682f, 
    0.01698737f, -0.11339224f, 0.22292551f, 0.13704219f, -0.08342876f, -0.00754797f, 0.03817324f, 0.04062751f, 
    0.11046857f, -0.00767985f, 0.02382062f, 0.07988306f, 0.04494529f, 0.05086105f, 0.08862625f, -0.18908323f, 
    -0.07121411f, -0.04253693f, 0.00997747f, 0.11437389f, 0.00476059f, 0.06661405f, 0.04759297f, 0.07852877f, 
    -0.08629757f, -0.05558633f, 0.16705641f, -0.04656516f, 0.08611704f, 0.02583805f, 0.01174379f, -0.04957151f, 
    0.00048940f, -0.00811759f, -0.03752539f, 0.01940455f, 0.12084688f, -0.08812059f, 0.05632354f, -0.05146618f, 
    0.11874627f, 0.01352615f, 0.00925738f, -0.09738854f, 0.16990785f, 0.01332218f, 0.06767986f, -0.02596146f, 
    -0.12668897f, 0.23923935f, 0.16281863f, -0.29853243f, -0.08032973f, 0.09608744f, -0.03108501f, 0.10675474f, 
    0.08359575f, 0.12376823f, -0.00744551f, 0.10661587f, 0.08091477f, 0.20935133f, -0.04133556f, 0.13231857f, 
    -0.02629649f, -0.14524849f, -0.01788779f, 0.01259116f, -0.03205995f, -0.00638465f, -0.05439043f, 0.02700178f, 
    -0.10429279f, -0.13345569f, 0.09040709f, -0.19064878f, 0.20225339f, 0.09418927f, 0.08541814f, 0.08571423f, 
    0.05927958f, -0.03208650f, 0.03953845f, 0.04553863f, -0.47236490f, 0.18203259f, -0.04389968f, 0.09032670f, 
    0.04698479f, 0.00306678f, -0.01761571f, -0.00827510f, -0.05110445f, 0.03419607f, -0.04669994f, -0.03505021f, 
    -0.32816732f, -0.02115870f, -0.01022451f, -0.15728095f, 0.06023290f, 0.12959248f, -0.03209198f, 0.01844621f, 
    0.11795247f, -0.03714965f, -0.08725905f, 0.02857553f, -0.06290136f, -0.21782734f, 0.02925746f, 0.03691133f, 
    -0.00689956f, -0.18010019f, 0.00481599f, -0.04022643f, 0.13659886f, 0.02589970f, -0.13145791f, 0.03622929f, 
    -0.16031025f, 0.10821806f, 0.16349261f, -0.04665725f, -0.01194010f, -0.01285996f, 0.07009482f, 0.00255669f, 
    -0.14127308f, -0.11183315f, -0.04281298f, 0.02275470f, -0.18941694f, 0.01620747f, 0.04570712f, -0.04012775f, 
    -0.05263412f, 0.13502130f, 0.05779042f, -0.02499704f, -0.05794748f, -0.14048795f, 0.04560778f, 0.03596858f, 
    0.02761279f, -0.03742040f, 0.05720024f, -0.06185107f, 0.00012228f, -0.04449391f, -0.00197653f, -0.04855317f, 
    0.03626494f, 0.06595824f, -0.05049020f, 0.02718238f, 0.02722982f, -0.04904141f, 0.02948159f, 0.06404436f, 
    -0.00975668f, -0.07416381f, 0.02651718f, -0.06779023f, -0.02408163f, 0.04338827f, -0.00969430f, 0.02276704f, 
    0.02010537f, -0.02267424f, 0.04140472f, 0.02212819f, 0.01872434f, 0.01649683f, -0.07788300f, -0.06080466f, 
    0.05150865f, 0.01569203f, -0.00643544f, -0.02429174f, 0.00457112f, 0.02347395f, -0.03969845f, -0.01887688f, 
    -0.07511141f, -0.06871705f, -0.06896054f, -0.05338985f, 0.03802196f, 0.03332517f, -0.04514952f, 0.03078534f, 
    -0.07089218f, -0.06336346f, -0.03559053f, 0.00183935f, 0.03176443f, -0.03084951f, 0.01153579f, -0.02688490f, 
    -0.04907342f, 0.04527480f, 0.02198089f, 0.03742999f, 0.04358692f, -0.00272704f, -0.07075144f, 0.06349762f, 
    0.05449126f, 0.05709255f, 0.04827542f, 0.05809184f, -0.05540440f, -0.02845857f, -0.02400678f, -0.06273908f, 
    0.03253154f, -0.03199028f, 0.03488456f, -0.05158288f, -0.03946245f, -0.05798776f, -0.02454046f, -0.05526010f, 
    0.04153436f, -0.05512983f, -0.00893301f, 0.04732579f, -0.07414941f, -0.07416893f, -0.04458105f, 0.01165749f, 
    -0.00774169f, -0.03510351f, 0.05182542f, 0.06935667f, 0.04891098f, -0.03751722f, -0.00868102f, 0.02053982f, 
    -0.01238080f, -0.05042427f, -0.03388206f, -0.02766329f, 0.05825226f, -0.06945644f, 0.01352835f, 0.03671988f, 
    -0.05108359f, -0.01256680f, 0.00741189f, -0.01777845f, 0.01865009f, 0.05560003f, -0.01722246f, 0.00279726f, 
    0.05612869f, -0.02410544f, 0.01798373f, 0.01453497f, -0.03812356f, -0.04099367f, -0.07452920f, 0.03538602f, 
    0.05226834f, 0.01398028f, 0.03904444f, 0.02339248f, -0.03373331f, 0.04767241f, -0.00715595f, -0.02693616f, 
    -0.01035027f, 0.04276497f, -0.01535554f, -0.06824922f, -0.05098137f, -0.06432324f, 0.01265519f, -0.04600546f, 
    -0.06823602f, -0.06024779f, 0.00164804f, -0.03788546f, -0.02167892f, -0.07238571f, -0.01415253f, 0.03960779f, 
    -0.02681826f, 0.06763881f, -0.07337710f, -0.05258396f, 0.03675503f, 0.01563258f, -0.06643446f, 0.03638693f, 
    -0.07102414f, -0.01919537f, -0.01461472f, -0.02073841f, -0.05732426f, -0.00684778f, 0.02071661f, -0.06259732f, 
    -0.01235351f, 0.02649701f, 0.05582646f, -0.04865403f, 0.04009567f, -0.03626045f, -0.05083466f, 0.02967259f, 
    0.06345759f, -0.07071130f, 0.05412832f, 0.02505973f, -0.02341310f, -0.01912606f, -0.07707743f, -0.07924619f, 
    0.00675684f, -0.06823201f, 0.00664621f, -0.00400996f, 0.05521888f, 0.00703703f, -0.01174289f, 0.03771864f, 
    -0.04701009f, -0.05935521f, 0.03470662f, 0.05228578f, -0.00165290f, -0.05630482f, 0.00343927f, 0.06012941f, 
    0.36175352f, -0.12920870f, 0.16054423f, 0.12531234f, -0.03768601f, 0.11287475f, 0.00442980f, 0.12886004f, 
    0.00621524f, 0.03903564f, -0.13086404f, 0.07608838f, 0.06188339f, -0.04478445f, -0.04088911f, -0.02824184f, 
    -0.06754008f, -0.07396544f, -0.03029705f, -0.07983544f, 0.01992145f, 0.02749841f, 0.02041145f, 0.00731663f, 
    0.07976144f, 0.14163813f, -0.08357679f, 0.09612039f, -0.10069147f, 0.02054816f, -0.10744864f, -0.00984052f, 
    0.03169885f, -0.09218949f, 0.02648319f, -0.04284932f, 0.38248369f, -0.06645380f, 0.04367354f, 0.18097678f, 
    -0.10067946f, 0.10708790f, -0.10772967f, 0.04059719f, -0.05453745f, 0.02001737f, -0.02604609f, -0.10492947f, 
    0.07150894f, -0.21636717f, 0.08198567f, 0.29562438f, -0.05937004f, 0.00597218f, -0.00110186f, 0.16025369f, 
    0.06800022f, -0.00755856f, 0.08573689f, 0.10252035f, 0.17254946f, -0.18412966f, 0.07386930f, 0.22887842f, 
    -0.15203698f, -0.02753114f, -0.02759640f, 0.09486138f, -0.01045498f, -0.06967316f, 0.01960706f, 0.07530498f, 
    -0.11806332f, -0.14009571f, -0.02007267f, -0.16371742f, -0.06747932f, -0.09540912f, 0.11255996f, 0.04959354f, 
    -0.06914309f, -0.03484175f, -0.08061765f, -0.04763770f, 0.02362947f, 0.21505710f, 0.06683420f, -0.01039446f, 
    0.02915757f, -0.02973553f, -0.18885404f, -0.09012844f, 0.07007264f, -0.01063486f, -0.10457400f, -0.05073553f, 
    -0.16687620f, 0.10551661f, 0.02822884f, -0.13876462f, -0.00250868f, 0.09121551f, 0.01006220f, -0.04623795f, 
    -0.02111313f, 0.10098490f, -0.02946053f, 0.01523373f, 0.10648050f, 0.02997092f, 0.09384454f, 0.19901276f, 
    -0.16429013f, 0.12416920f, 0.13627633f, 0.11300273f, -0.04814849f, 0.03833760f, 0.05116204f, -0.03633865f, 
    0.11741772f, 0.15036894f, 0.14912465f, 0.04028955f, -0.01723189f, -0.03328371f, 0.01819105f, 0.04772767f, 
    0.15637988f, 0.09646557f, 0.07185314f, 0.05919167f, -0.30321220f, 0.15265530f, -0.19767179f, -0.19848061f, 
    -0.04516298f, 0.16671370f, -0.01343930f, -0.02162649f, 0.01035154f, 0.08302520f, -0.06312781f, 0.01471574f, 
    0.01110765f, 0.17323074f, 0.07542600f, -0.00352456f, 0.04383546f, 0.04526597f, -0.00751748f, -0.03424482f, 
    -0.07322070f, 0.03243410f, 0.03384803f, 0.00218901f, -0.26676142f, 0.02720076f, 0.12389486f, 0.09788930f, 
    0.02030988f, -0.03297579f, -0.09398422f, 0.02948675f, -0.09898092f, 0.06351279f, 0.02849546f, -0.02050070f, 
    0.12288836f, -0.01930106f, -0.14802679f, -0.05035733f, 0.07970395f, -0.05799941f, 0.16815209f, 0.04036725f, 
    -0.03239928f, 0.00219225f, -0.03785867f, -0.07333831f, 0.06553976f, 0.04330875f, 0.00077356f, 0.17089002f, 
    -0.15217447f, 0.00550431f, 0.03273753f, -0.01173116f, -0.13429204f, -0.00388127f, 0.12057746f, 0.03883862f, 
    0.23767096f, 0.05355234f, -0.04721216f, -0.03645518f, 0.01799332f, 0.07728299f, -0.06947096f, -0.04785676f, 
    0.03445156f, -0.08320332f, 0.01854887f, -0.05372110f, 0.11929015f, -0.13868833f, -0.00747271f, 0.01557967f, 
    -0.02125970f, -0.11152881f, -0.04979124f, -0.09116268f, 0.01365763f, 0.04720264f, -0.05474256f, -0.05328796f, 
    -0.04076710f, 0.22480230f, 0.08811779f, -0.03985543f, 0.11240402f, -0.03282546f, -0.09311622f, -0.00891261f, 
    0.10848163f, -0.02150154f, 0.10446583f, 0.06512392f, 0.26464841f, -0.06732995f, 0.14391747f, -0.09786242f, 
    -0.07740166f, 0.04645752f, 0.06865875f, 0.06902242f, 0.08090736f, 0.11615695f, -0.07963677f, -0.02494600f, 
    0.15974198f, -0.18146949f, 0.07157172f, 0.16893190f, 0.03383618f, -0.04308537f, 0.03645527f, -0.03740299f, 
    0.00172127f, -0.01426978f, 0.01797435f, 0.16761239f, -0.04781794f, -0.18576872f, 0.17525540f, 0.07052118f, 
    -0.12883048f, 0.12595947f, 0.03581190f, 0.11657959f, -0.07870772f, -0.05683786f, -0.06337901f, -0.01865074f, 
    -0.23349017f, -0.14362989f, 0.09230419f, 0.11120262f, 0.00343388f, 0.06816132f, 0.15960494f, 0.00641730f, 
    0.02470952f, -0.02336993f, 0.02393937f, -0.01062690f, 0.18825732f, 0.23737542f, -0.02273284f, 0.07420038f, 
    0.04821502f, 0.00191432f, -0.11205097f, -0.03970872f, 0.04535560f, 0.01130537f, -0.03817409f, -0.07086477f, 
    -0.06306481f, 0.16386749f, 0.02745628f, -0.06724653f, -0.02335034f, 0.10234434f, -0.02323673f, -0.03640242f, 
    0.08714078f, 0.00096560f, -0.04301734f, -0.09002624f, -0.13015811f, 0.10834394f, 0.10841087f, 0.30429313f, 
    -0.07105778f, 0.05876385f, 0.03997230f, 0.11958373f, -0.07836087f, 0.01816244f, -0.05109495f, 0.08168294f, 
    0.03409763f, -0.04894806f, -0.06080243f, 0.03722737f, -0.05253515f, -0.07704946f, 0.06967067f, 0.12519982f, 
    0.11927617f, 0.02007671f, 0.10248945f, 0.05704622f, -0.61662406f, 0.29226685f, -0.14485964f, -0.35556209f, 
    -0.00437011f, 0.02121009f, 0.02254549f, -0.05258256f, 0.02259322f, -0.03712763f, 0.00900400f, -0.07777137f, 
    -0.27729544f, 0.18076131f, 0.01779648f, 0.10132112f, 0.02578352f, 0.07741513f, -0.11858444f, -0.14291939f, 
    0.01965781f, -0.04422901f, -0.09377845f, 0.16184217f, -0.08773650f, 0.07176957f, 0.22338398f, 0.21347572f, 
    -0.06399023f, -0.06638166f, -0.05632505f, -0.05340789f, -0.05084987f, 0.04576975f, -0.04904205f, 0.11107481f, 
    0.10641562f, 0.05783563f, 0.03075113f, 0.11389175f, -0.08798163f, -0.05692180f, 0.08440792f, 0.07289166f, 
    -0.06380175f, -0.12088781f, -0.10861229f, 0.02234076f, -0.14703847f, 0.05377020f, -0.00297701f, 0.21997483f, 
    -0.10679694f, 0.00752637f, 0.03965921f, -0.06230970f, -0.06205414f, -0.00892152f, 0.05477590f, 0.10299976f, 
    -0.18369506f, 0.20948555f, -0.08356780f, 0.04699944f, -0.21757388f, -0.03182602f, 0.03005578f, -0.12950449f, 
    0.03854208f, -0.13928339f, -0.30067262f, -0.13262266f, -0.02842738f, -0.01876779f, -0.16615231f, 0.01717659f, 
    -0.08861269f, 0.12083148f, -0.07616071f, -0.01351899f, -0.01330168f, -0.09740360f, -0.09437568f, -0.03557144f, 
    -0.25789189f, 0.03012630f, 0.03692156f, 0.01716128f, -0.08487340f, -0.09948776f, 0.02574644f, 0.02756335f, 
    0.06390481f, -0.04122572f, 0.10408327f, -0.05891289f, 0.03813223f, 0.09974538f, -0.05525291f, -0.07477511f, 
    -0.19079150f, 0.03174625f, -0.11137074f, -0.05110851f, -0.05213500f, -0.01793394f, -0.03897627f, -0.06135479f, 
    0.21016453f, 0.07583062f, 0.29905501f, -0.02377518f, 0.19895971f, 0.00297818f, 0.01541510f, -0.04137445f, 
    0.00550085f, -0.02801921f, -0.05310549f, 0.00891074f, -0.28595340f, -0.23298132f, -0.12878105f, -0.00141755f, 
    -0.05491084f, 0.07535828f, -0.02504667f, -0.06035948f, -0.11485080f, -0.13021296f, 0.04107999f, -0.01235567f, 
    -0.07767273f, -0.06884841f, -0.20855357f, 0.14103971f, -0.11145761f, -0.05897765f, -0.05749828f, 0.06691235f, 
    -0.14525311f, 0.01506956f, -0.15431002f, -0.00942237f, -0.19047099f, 0.16716094f, -0.07256620f, -0.03364197f, 
    0.20172742f, -0.08298725f, -0.06832475f, -0.06528100f, -0.10026511f, 0.02087029f, 0.07949394f, -0.02650573f, 
    0.21066329f, 0.13724825f, -0.02754348f, 0.15868503f, 0.02345137f, -0.08519424f, -0.10759525f, -0.08341730f, 
    -0.09896468f, -0.03564369f, 0.01074020f, 0.05666572f, -0.41471767f, -0.19822183f, 0.07402530f, 0.06999959f, 
    -0.16099221f, -0.00529656f, 0.00515684f, 0.05542930f, -0.03896379f, -0.08969792f, 0.04106959f, -0.07812896f, 
    0.16675355f, 0.21599747f, -0.03072046f, 0.08564381f, 0.20230667f, 0.12747744f, 0.15800148f, -0.01393152f, 
    -0.07647461f, 0.03101053f, 0.06681417f, 0.05957187f, 0.20430262f, 0.14770177f, 0.06637190f, 0.06264801f, 
    0.11223609f, 0.04339921f, 0.05762985f, 0.08164560f, -0.03303615f, 0.05308403f, 0.01873872f, -0.01731558f, 
    0.17997569f, 0.24811171f, 0.09029354f, 0.10653404f, 0.01498251f, 0.16778821f, 0.17533463f, -0.00999854f, 
    -0.11625186f, -0.08480030f, 0.05395082f, -0.00087890f, 0.35344636f, 0.16621895f, 0.21940993f, 0.10928036f, 
    0.05158937f, -0.06840762f, -0.02764263f, 0.19050097f, -0.05116035f, -0.14918320f, -0.06074042f, -0.13693656f, 
    0.25521177f, 0.30834463f, 0.03776729f, 0.18670353f, 0.14295350f, -0.03668132f, 0.12201233f, 0.14726363f, 
    0.03881415f, 0.02959881f, -0.11062568f, -0.18339621f, 0.21159118f, 0.10775316f, -0.03831193f, 0.11928850f, 
    0.11054449f, 0.03221781f, -0.16133004f, 0.13715367f, 0.04972612f, 0.06840912f, -0.01568867f, -0.04070003f, 
    0.09059450f, -0.12483320f, 0.02463897f, 0.08865222f, 0.24436165f, 0.02678316f, 0.11189288f, -0.11352468f, 
    0.13055226f, 0.10604911f, 0.05085436f, 0.02186636f, 0.02431465f, 0.22022353f, -0.05089231f, 0.11533600f, 
    -0.09968926f, 0.07109462f, 0.08461722f, -0.00053942f, -0.06862937f, 0.04865875f, -0.09703111f, -0.02430515f, 
    -0.01028769f, -0.16529423f, -0.08845880f, -0.02924622f, 0.09605804f, -0.09234565f, 0.10049698f, 0.05113915f, 
    -0.10607293f, -0.08410431f, 0.02210573f, 0.09044867f, -0.11076778f, -0.00001265f, -0.12442096f, 0.06318080f, 
    0.08794986f, -0.13583949f, 0.13443667f, -0.09166445f, -0.08751819f, 0.04899816f, -0.02259029f, -0.02642044f, 
    -0.13208218f, 0.11464742f, -0.06789706f, -0.20098685f, 0.11285254f, 0.06841074f, 0.04893788f, 0.12471668f, 
    0.01967521f, 0.04125788f, 0.10925528f, -0.00532203f, -0.03258241f, -0.18991865f, -0.23262499f, 0.18657565f, 
    0.17791907f, 0.13471398f, -0.02883178f, -0.03684576f, -0.01999938f, 0.02663918f, 0.02068491f, -0.00520293f, 
    0.14742048f, 0.02470339f, -0.06104365f, 0.00349636f, 0.02405085f, -0.00561638f, -0.04032180f, -0.01681913f, 
    0.07128451f, 0.09326399f, -0.03633755f, 0.01374705f, 0.23445164f, 0.23574160f, -0.03907847f, 0.12827224f, 
    -0.15190364f, -0.00010747f, -0.05642251f, 0.09633372f, 0.09264034f, -0.00635163f, 0.02567754f, 0.26537484f, 
    0.33532351f, -0.03998438f, -0.20680548f, 0.22470911f, -0.00689086f, 0.04731753f, -0.04054498f, -0.05037920f, 
    -0.12366239f, -0.00819726f, 0.08392988f, -0.01124964f, 0.00927870f, -0.16488184f, -0.00817000f, 0.11000837f, 
    0.19218947f, 0.03054954f, -0.07769497f, 0.06060008f, 0.08210845f, -0.06058518f, 0.08494070f, 0.07610830f, 
    -0.12549691f, -0.07434379f, -0.27297688f, 0.06112643f, -0.15665215f, -0.07685996f, -0.09594527f, -0.11960724f, 
    -0.02491819f, -0.16059336f, 0.01239199f, -0.12425211f, 0.08942522f, -0.01914817f, 0.11952610f, 0.03055680f, 
    0.02698287f, -0.15231779f, -0.01015776f, 0.01114172f, 0.06690666f, -0.08936483f, 0.07806266f, 0.11224177f, 
    0.02272845f, 0.03289907f, 0.03364695f, 0.17082269f, -0.27087134f, -0.17312257f, -0.03298596f, 0.01948310f, 
    -0.09083481f, -0.00446782f, 0.01886336f, -0.10171897f, -0.01677752f, 0.34091130f, -0.01729300f, 0.04331367f, 
    0.02107791f, 0.08644280f, 0.16469640f, -0.00646634f, -0.00792227f, 0.07204190f, 0.03925975f, -0.10703430f, 
    0.34108472f, -0.02115699f, 0.02608042f, -0.17957002f, -0.00059287f, 0.12659976f, -0.04824902f, 0.06575567f, 
    0.14896247f, 0.04528471f, 0.07626946f, 0.05436144f, -0.12525822f, -0.06083680f, 0.07194679f, -0.22150658f, 
    0.02981936f, -0.06519430f, -0.19780062f, -0.02819499f, 0.12863603f, 0.04531635f, -0.02521474f, 0.02983843f, 
    -0.23904188f, 0.10505319f, -0.09388786f, -0.15130818f, 0.08118734f, -0.01526751f, 0.09050765f, 0.08303974f, 
    -0.07303603f, 0.13901635f, 0.06457599f, -0.04396946f, -0.17224781f, 0.00709330f, -0.01588855f, 0.03150635f, 
    0.04945040f, 0.02142989f, 0.08339377f, 0.11412391f, 0.09227209f, -0.05339805f, 0.02480719f, 0.05052245f, 
    -0.27884197f, -0.15269472f, 0.14954060f, -0.12247067f, 0.11823061f, 0.15933239f, 0.11638413f, -0.04025851f, 
    -0.03078381f, 0.06543370f, -0.03580436f, -0.04071219f, 0.05500918f, 0.26924771f, -0.17395176f, -0.16242349f, 
    0.04166299f, 0.21869937f, 0.05354703f, -0.06010087f, 0.04659661f, -0.03876460f, 0.05467467f, 0.05915272f, 
    0.19343214f, 0.11552238f, -0.00857977f, 0.08112287f, 0.07949821f, 0.08829779f, -0.10157093f, -0.04221326f, 
    -0.02384330f, -0.08805107f, -0.05495987f, -0.10771658f, 0.02707182f, 0.26637927f, -0.00468951f, -0.28545016f, 
    -0.03551880f, 0.05445897f, 0.00184543f, -0.02041185f, 0.01772855f, 0.03449149f, -0.03652427f, -0.04608898f, 
    0.15620416f, -0.01129659f, 0.09006440f, 0.02489274f, -0.08599844f, -0.00064992f, -0.02126223f, 0.06527342f, 
    0.00133342f, -0.01620506f, 0.02222937f, -0.05904306f, -0.03823434f, -0.07111119f, 0.02386893f, -0.00131288f, 
    0.04224830f, 0.07772081f, 0.20138840f, -0.01947386f, -0.11174832f, -0.00314396f, -0.00093089f, 0.00588489f, 
    -0.00621325f, -0.24708255f, 0.22522891f, 0.17421179f, 0.13995141f, 0.04591509f, 0.10660080f, 0.14547035f, 
    -0.00290116f, -0.01629789f, -0.02599987f, 0.07204574f, -0.07723328f, -0.00181496f, -0.12124868f, -0.26397690f, 
    0.00740879f, -0.00796187f, 0.07391275f, -0.05180851f, -0.07301457f, -0.00022162f, -0.11702561f, 0.04457191f, 
    0.26005515f, 0.05720278f, 0.08894871f, 0.13857621f, 0.04969339f, 0.04422837f, 0.09146609f, -0.04071013f, 
    -0.06843188f, 0.01553831f, 0.03139669f, 0.13097091f, 0.14182965f, 0.09631559f, 0.01631135f, 0.10596040f, 
    0.03637182f, 0.06559815f, -0.07233427f, 0.07453036f, 0.07337244f, 0.02197226f, 0.10722092f, -0.03006649f, 
    0.04827927f, 0.09193944f, 0.01894809f, -0.02145462f, 0.05287234f, -0.01428257f, -0.01144669f, 0.13598010f, 
    -0.04336771f, -0.02897134f, 0.05480962f, -0.05287508f, 0.32747290f, -0.25750017f, -0.08873096f, 0.25037897f, 
    0.07901502f, 0.09035067f, 0.03592304f, 0.02317991f, -0.08036835f, -0.10216656f, 0.02807461f, 0.14343502f, 
    -0.12655725f, 0.00882359f, 0.08625521f, 0.26192522f, -0.03928242f, 0.10539722f, -0.04190916f, 0.04068333f, 
    -0.15623257f, 0.03057174f, -0.05621071f, 0.08943932f, 0.07753510f, -0.14348096f, -0.06816294f, 0.18484992f, 
    0.00244287f, -0.10563672f, 0.06295956f, 0.12734395f, -0.01903447f, 0.03983887f, -0.06669661f, -0.18184604f, 
    0.05421642f, -0.01437602f, -0.00217874f, -0.07293894f, 0.02597731f, -0.04321565f, 0.03823055f, 0.03902255f, 
    -0.06255184f, -0.03450506f, 0.03184681f, 0.00759847f, -0.03408825f, 0.02590388f, 0.03073567f, -0.01962038f, 
    -0.00488532f, -0.03017015f, -0.02553777f, 0.00240358f, -0.06326750f, 0.03828726f, 0.05500549f, -0.06330024f, 
    -0.02028497f, -0.04685785f, -0.07364895f, -0.05188740f, 0.05833544f, -0.05075876f, 0.04213355f, -0.01547453f, 
    -0.05799332f, 0.03011691f, -0.03390830f, -0.02033840f, -0.06616373f, 0.01812968f, -0.06913449f, -0.04426127f, 
    0.05348777f, -0.06486794f, 0.00172437f, 0.04899738f, -0.04059271f, 0.00896029f, 0.04107983f, 0.01818385f, 
    -0.04518079f, -0.06140867f, -0.06659056f, -0.07976538f, 0.02930476f, -0.06848039f, -0.03161708f, -0.02116420f, 
    0.05817444f, -0.00817200f, 0.04504016f, -0.02277498f, 0.00454413f, -0.02008601f, 0.05358555f, 0.01642167f, 
    -0.00987368f, -0.06370749f, -0.00422819f, 0.00929988f, 0.05228218f, -0.02405777f, -0.02078263f, -0.03161216f, 
    -0.02969196f, -0.07448872f, 0.00036647f, -0.00245744f, -0.02457129f, 0.05930598f, -0.00284824f, -0.00178144f, 
    0.03173015f, 0.04766053f, 0.02692802f, -0.00929536f, -0.05678079f, -0.04462835f, 0.04906717f, 0.02645605f, 
    -0.06893037f, -0.00189512f, 0.03484863f, 0.02496326f, -0.02327977f, 0.02341334f, -0.06375500f, -0.04314382f, 
    0.01403399f, 0.01148889f, 0.01573086f, -0.01677148f, 0.04234829f, 0.01221569f, 0.03563486f, -0.07410912f, 
    -0.03937979f, 0.02836064f, 0.05745799f, -0.05664890f, -0.03699177f, -0.05265038f, -0.00371682f, 0.04175469f, 
    -0.06564474f, -0.07826388f, 0.03258312f, -0.01793666f, 0.02985197f, 0.03885707f, 0.01037134f, 0.00938443f, 
    -0.04215149f, -0.07913799f, -0.05912299f, 0.02390451f, 0.04313068f, -0.07731597f, -0.05531051f, -0.03017276f, 
    -0.03657758f, -0.04914962f, -0.02890626f, -0.01383811f, -0.03846029f, 0.00939859f, 0.04749151f, 0.04109332f, 
    -0.08002389f, -0.00041668f, 0.00940688f, 0.02630819f, 0.03540222f, 0.04863038f, -0.07440379f, -0.00723145f, 
    0.04483643f, 0.04032089f, -0.02501687f, -0.04681046f, 0.00380379f, 0.03857706f, -0.04225067f, 0.03437652f, 
    0.00805643f, -0.07838590f, -0.07306159f, 0.02782000f, 0.00693820f, 0.00461995f, 0.04494280f, -0.00713742f, 
    -0.00783659f, -0.06838566f, -0.03648644f, -0.01287430f, 0.00388564f, -0.02393655f, 0.03819238f, -0.02285595f, 
    0.01092460f, -0.04200115f, -0.00717371f, -0.05385121f, 0.00956034f, -0.04718859f, -0.02732689f, 0.00865302f, 
    -0.05699768f, -0.06946740f, -0.05031702f, 0.05843866f, -0.02994660f, -0.01616807f, -0.05071849f, -0.03814561f, 
    -0.04946476f, 0.05710680f, -0.06322327f, 0.04417075f, -0.07937084f, -0.05986806f, -0.07167413f, -0.04829293f, 
    0.39032367f, -0.32345891f, -0.00069589f, 0.10246718f, 0.10879748f, -0.02059838f, -0.03515542f, 0.01756334f, 
    0.00561733f, 0.05285746f, -0.01872393f, 0.14677675f, 0.13468222f, 0.00833180f, -0.11404952f, -0.06349274f, 
    0.02583417f, -0.04317460f, 0.11489472f, 0.07070502f, -0.00912202f, 0.10175461f, -0.01280210f, -0.02948677f, 
    0.01325072f, -0.01134075f, -0.18115352f, 0.08534088f, -0.00411842f, 0.00193228f, 0.08340714f, 0.03615188f, 
    -0.07334598f, 0.06635370f, 0.03777895f, 0.03408529f, 0.13591200f, -0.20248532f, -0.00372941f, 0.32850820f, 
    0.04462145f, -0.06215777f, -0.03584861f, -0.03796512f, 0.05609096f, -0.00461363f, 0.06343505f, 0.06324533f, 
    -0.03404156f, 0.00771781f, -0.00480206f, -0.05080423f, -0.06714982f, -0.04545775f, 0.07572990f, 0.13579603f, 
    0.05242782f, -0.02023804f, 0.10886373f, 0.12744150f, 0.30300346f, -0.30375609f, -0.00377264f, 0.23700936f, 
    0.10604118f, 0.06192408f, 0.01949133f, -0.04005683f, -0.00321559f, 0.01869538f, -0.01236194f, 0.05531343f, 
    0.19495060f, 0.09634436f, -0.01516903f, -0.22437121f, 0.03405180f, 0.03602095f, 0.03918511f, 0.05195431f, 
    0.10390001f, 0.08919170f, 0.01024802f, 0.05784947f, 0.27675089f, 0.18035671f, 0.13638252f, 0.04913418f, 
    -0.03380498f, 0.06324586f, -0.10010488f, 0.02057285f, 0.11479805f, 0.01028920f, -0.11633833f, 0.06784252f, 
    0.12691301f, 0.19178966f, 0.11885077f, -0.20701359f, -0.04989589f, -0.01920023f, -0.06753352f, -0.03132636f, 
    -0.03501798f, 0.13632393f, 0.08566067f, -0.04016487f, 0.15946189f, -0.11979474f, -0.07563053f, 0.26737073f, 
    0.02994874f, -0.00475202f, -0.01219198f, 0.04041173f, 0.04584587f, 0.05029960f, 0.05797317f, 0.06181259f, 
    0.02934963f, -0.05953186f, 0.10862268f, -0.03782725f, -0.13775685f, -0.09790279f, 0.07134099f, 0.00268182f, 
    0.08969974f, -0.09164155f, -0.06666633f, 0.00548499f, -0.32907754f, 0.17687798f, -0.13847655f, 0.05594372f, 
    -0.02152878f, 0.04001369f, -0.00461547f, 0.02448148f, 0.06748709f, 0.01093745f, -0.02279628f, 0.00041037f, 
    0.09449915f, 0.05866776f, -0.07563660f, 0.04852300f, -0.01271916f, -0.10334221f, 0.07631155f, -0.00352011f, 
    -0.00165296f, 0.02411381f, -0.10034952f, -0.05187547f, -0.29247212f, 0.26132736f, 0.08990218f, 0.00803129f, 
    -0.08432566f, 0.02270181f, 0.00898829f, -0.06277863f, -0.03219866f, -0.01513664f, -0.04425109f, -0.06308240f, 
    0.13462850f, -0.01692330f, -0.11911143f, -0.31276017f, 0.04259278f, -0.01813525f, -0.03481593f, -0.06015148f, 
    0.08977074f, -0.08680774f, -0.05651529f, -0.02976623f, -0.05610554f, -0.07385997f, 0.20135264f, -0.14733757f, 
    -0.21679902f, 0.08621154f, -0.01988834f, 0.00096883f, 0.08450378f, 0.00961216f, 0.06120736f, 0.14951189f, 
    0.04603818f, 0.00599456f, -0.06971666f, -0.02113942f, -0.01003888f, 0.05443419f, -0.00303651f, 0.06198094f, 
    0.01661797f, -0.01730447f, 0.05385952f, -0.00903940f, -0.06678139f, 0.03471509f, -0.00192386f, -0.02186694f, 
    -0.00840101f, 0.02225862f, 0.01156812f, 0.02082700f, -0.00711995f, -0.07649375f, 0.06320932f, -0.01873309f, 
    -0.02549453f, -0.07792860f, -0.06298807f, 0.06224069f, -0.05054229f, 0.04021889f, -0.02533010f, 0.00915088f, 
    0.02336875f, 0.05659808f, 0.01554800f, -0.02386116f, -0.02306219f, -0.05329238f, 0.02938574f, 0.04678959f, 
    0.00298907f, -0.02849121f, -0.05228285f, -0.04235204f, 0.04743496f, 0.05351815f, -0.00401804f, -0.05320089f, 
    -0.04643049f, 0.01196203f, -0.02504477f, -0.05759190f, -0.04829900f, 0.01439502f, 0.05956861f, 0.00266485f, 
    -0.01267041f, -0.04285912f, 0.02352699f, -0.06842081f, -0.02661614f, -0.04306977f, -0.03959144f, 0.04570968f, 
    0.01589888f, -0.05670384f, -0.05985588f, -0.04372008f, 0.00588942f, -0.02360467f, -0.01741258f, -0.07701170f, 
    -0.00481311f, 0.06487199f, 0.04064198f, -0.00889728f, -0.03243683f, -0.00153490f, -0.02454961f, -0.00388965f, 
    -0.03835273f, -0.01063771f, -0.03515578f, 0.00170288f, -0.02314019f, 0.04422970f, 0.02755797f, -0.00851881f, 
    -0.04678473f, -0.00484719f, 0.05915236f, -0.05237649f, -0.00629666f, -0.02805628f, -0.02480284f, -0.06982075f, 
    0.01543342f, -0.03371044f, -0.05302826f, 0.01009616f, 0.04077616f, 0.00345627f, -0.05702871f, -0.02183679f, 
    0.01325025f, 0.02738572f, -0.06445771f, -0.01557325f, 0.02414636f, -0.03588586f, -0.00477825f, 0.03605660f, 
    -0.02306365f, -0.06745364f, -0.02949971f, -0.04634263f, 0.02243718f, 0.00062542f, 0.04799300f, -0.03567777f, 
    -0.01299479f, 0.06195962f, -0.00572048f, -0.01762388f, 0.03477012f, 0.01543356f, 0.00456578f, -0.03717390f, 
    -0.05517525f, -0.07222547f, 0.00723599f, -0.04153822f, 0.03788820f, -0.06175392f, 0.06325711f, 0.05242899f, 
    0.05777402f, -0.00614865f, -0.00588238f, -0.06261735f, -0.06144509f, -0.03223322f, -0.06302650f, 0.03450751f, 
    0.04513235f, -0.04609552f, -0.07228556f, 0.03023819f, -0.00645044f, 0.06018865f, 0.02777083f, -0.07495203f, 
    -0.05207006f, -0.00537831f, 0.02239261f, 0.00090133f, -0.00282908f, -0.03014570f, 0.05092516f, -0.00849259f, 
    0.01861743f, 0.06437051f, -0.05110757f, -0.00474521f, 0.04497186f, 0.02904983f, -0.03055172f, 0.05193460f, 
    -0.06247056f, -0.03735700f, 0.01997604f, -0.05533326f, -0.03473455f, -0.03386027f, -0.05508779f, 0.00949459f, 
    -0.01934342f, 0.05334502f, 0.00388438f, 0.01722529f, -0.01564884f, -0.06428650f, 0.06871373f, 0.02472126f, 
    -0.00123017f, 0.00117811f, -0.04382801f, -0.04293051f, 0.01358659f, -0.04708692f, 0.05572585f, 0.04321937f, 
    -0.17838269f, 0.00007265f, 0.02556182f, 0.11164296f, -0.22606452f, 0.09518611f, -0.09843618f, 0.06365187f, 
    -0.09697617f, -0.18321250f, -0.19650383f, 0.04193744f, -0.05648100f, -0.03298886f, -0.02135966f, -0.14374875f, 
    0.02521654f, 0.05324772f, -0.15105577f, 0.02180146f, 0.02536800f, -0.04330796f, 0.02688342f, 0.12883069f, 
    0.19164447f, 0.12166988f, 0.05777726f, 0.08997909f, -0.00396994f, 0.00992757f, -0.13746516f, -0.02133830f, 
    0.08317208f, 0.15452427f, 0.16097876f, -0.11464016f, 0.07914199f, -0.06112686f, 0.07083672f, -0.06186040f, 
    -0.05523936f, -0.13989076f, -0.20508365f, 0.01860615f, 0.03375266f, -0.01542949f, 0.04156090f, 0.06273106f, 
    0.12174226f, -0.14905803f, 0.18855113f, 0.04696932f, 0.03709270f, -0.11387048f, -0.00864047f, 0.00503643f, 
    -0.05577488f, -0.01879138f, 0.06469125f, 0.10953332f, -0.04229924f, -0.16003378f, 0.03988832f, -0.05894585f, 
    -0.10341235f, 0.01722784f, 0.03517994f, 0.06545120f, 0.02279391f, -0.03014573f, 0.02794660f, 0.05393571f, 
    -0.18497913f, 0.07066755f, 0.05938334f, 0.05969007f, 0.04893081f, 0.07797858f, -0.01394624f, -0.00020231f, 
    -0.04450846f, 0.00181700f, 0.00444636f, 0.09149262f, -0.19127347f, 0.02512586f, 0.06921297f, -0.22987352f, 
    0.05799248f, -0.09389344f, -0.08251430f, 0.01155034f, 0.06293579f, 0.06965562f, -0.05487178f, -0.06560840f, 
    -0.11773425f, 0.05541900f, 0.17884453f, -0.18926895f, -0.11532774f, 0.03262953f, -0.08741192f, 0.08436941f, 
    0.10335811f, 0.14409719f, 0.05810068f, 0.12897827f, -0.11313972f, -0.09659226f, 0.14560963f, -0.00448220f, 
    -0.01681525f, 0.05126119f, 0.07790546f, 0.04228844f, -0.17750666f, 0.00794993f, -0.01572030f, 0.07565641f, 
    0.17109030f, 0.23490071f, -0.05989694f, -0.40495482f, 0.18083735f, 0.17233635f, 0.14237018f, 0.07346328f, 
    0.01995332f, 0.17215319f, 0.08559107f, 0.02233284f, 0.17832126f, 0.18436944f, -0.11489002f, 0.16371363f, 
    0.07170215f, 0.06440604f, -0.10145759f, -0.04521577f, -0.08173145f, 0.09314091f, -0.05885631f, -0.08125166f, 
    0.29187927f, 0.06565351f, -0.11592136f, -0.32911691f, 0.15741125f, 0.03902055f, 0.05477999f, -0.03685663f, 
    0.01458281f, -0.01626555f, 0.04870378f, 0.06613184f, 0.11935602f, -0.02599238f, -0.00439164f, -0.00048533f, 
    0.06505338f, 0.00904099f, -0.06687031f, 0.00543855f, -0.07296374f, -0.00598509f, 0.02614870f, -0.00946181f, 
    -0.15975347f, 0.10461151f, 0.02754669f, 0.21724065f, 0.06753784f, -0.12568377f, 0.05586689f, 0.07904363f, 
    -0.11605836f, -0.07793505f, -0.03140995f, -0.08819915f, 0.26564670f, -0.08051094f, -0.07966784f, -0.04793923f, 
    -0.05206173f, 0.06417537f, 0.00490870f, 0.09383040f, 0.04045591f, 0.08103641f, 0.08399041f, 0.16363604f, 
    0.19492918f, -0.30101776f, 0.02510865f, -0.11060948f, -0.07752613f, 0.08170682f, 0.00410773f, -0.06583046f, 
    0.17131706f, -0.04134050f, -0.06594188f, 0.03166515f, -0.15073739f, -0.00175903f, -0.04373698f, -0.04262041f, 
    -0.05078713f, 0.07803206f, -0.04095710f, 0.08574431f, -0.11928414f, 0.09092115f, -0.08579233f, 0.08382582f, 
    -0.09083970f, -0.04144089f, -0.21212208f, -0.05837980f, 0.09792079f, -0.03928356f, 0.02385265f, -0.01094654f, 
    -0.00670857f, 0.04831063f, 0.09955484f, 0.02959360f, 0.11483955f, -0.35643077f, -0.13727589f, -0.00091010f, 
    0.04226883f, -0.20800798f, 0.02657416f, -0.09510580f, 0.00075668f, 0.08806433f, 0.07026853f, 0.02944180f, 
    0.23675177f, 0.08798018f, 0.10902049f, 0.11532530f, 0.07458546f, -0.17624578f, 0.15765330f, -0.00847108f, 
    0.02583283f, 0.02846167f, 0.17199105f, 0.24493198f, -0.02123021f, -0.37602267f, -0.01508341f, 0.07720906f, 
    -0.03397080f, 0.03310843f, -0.07023033f, -0.05702769f, 0.04125236f, 0.07442650f, 0.03977376f, 0.14365911f, 
    0.20128609f, 0.00672565f, 0.12114154f, 0.09503257f, -0.07337624f, -0.00799217f, -0.05672887f, -0.08554965f, 
    0.12515134f, 0.02035899f, -0.06727613f, 0.08002035f, -0.20571031f, 0.16602260f, -0.04602175f, -0.07610581f, 
    0.01187522f, -0.05746184f, 0.01816213f, 0.11597000f, 0.07440202f, -0.03527517f, -0.06105591f, 0.08546925f, 
    0.07784803f, -0.00111018f, 0.04902979f, 0.11342292f, -0.09686114f, 0.09445573f, -0.03168983f, -0.04140899f, 
    0.05516998f, 0.17705990f, -0.02818429f, 0.02046439f, -0.04838683f, -0.08861869f, 0.11083981f, 0.01485339f, 
    -0.06049950f, 0.02039235f, 0.07636578f, -0.04558137f, 0.08584249f, 0.10901970f, 0.16142526f, 0.08578058f, 
    0.24011032f, 0.06099489f, -0.02377450f, 0.10720964f, -0.03665290f, 0.07739040f, 0.14063826f, 0.01187161f, 
    0.05441506f, 0.09451462f, 0.06300388f, -0.18188144f, -0.10201542f, 0.26941791f, -0.14660025f, -0.25852755f, 
    0.10537746f, -0.07872096f, 0.09155907f, 0.04031313f, 0.00160012f, -0.00356910f, 0.02832409f, 0.06649816f, 
    -0.03540593f, 0.11679392f, -0.07697131f, 0.08045261f, 0.01508426f, -0.07717561f, 0.15166163f, -0.11643379f, 
    -0.02539887f, 0.01080030f, -0.10327666f, -0.05258697f, -0.19448188f, 0.30725420f, 0.16853130f, 0.06441595f, 
    -0.06452132f, -0.15057743f, -0.00634827f, 0.06948762f, -0.10272376f, 0.07839556f, 0.06021191f, 0.11941992f, 
    0.14704002f, -0.08319342f, -0.04432735f, 0.12373126f, -0.02189217f, 0.03113975f, 0.12180949f, 0.00692851f, 
    0.09727541f, -0.01284397f, -0.01812471f, -0.04265101f, 0.17700578f, -0.04387320f, 0.11606441f, 0.09166305f, 
    0.07081304f, 0.09063037f, -0.09097391f, -0.00684117f, -0.08320290f, -0.00697417f, -0.00744413f, 0.09009787f, 
    0.12767702f, -0.14124665f, 0.08228887f, 0.01203848f, 0.01899121f, 0.00200002f, -0.05577945f, -0.09793906f, 
    0.00008894f, -0.04485823f, -0.06357738f, -0.05096767f, 0.22896264f, 0.10015017f, 0.00355016f, -0.12786600f, 
    0.13932356f, -0.01479863f, -0.03858299f, -0.02130751f, 0.11049981f, 0.09121685f, -0.08440745f, 0.09206916f, 
    0.27935603f, 0.20061928f, 0.00563605f, -0.03728661f, 0.00973164f, -0.08840698f, -0.05852171f, -0.00777772f, 
    0.17618039f, -0.05825537f, 0.04834482f, -0.05771906f, 0.00785945f, -0.21716014f, 0.07458957f, 0.01473426f, 
    0.04258014f, -0.20281759f, -0.11384205f, 0.03599011f, 0.04176446f, 0.17303105f, 0.07118978f, 0.02279975f, 
    -0.02469981f, -0.06896851f, 0.02240999f, -0.01922598f, 0.02482371f, -0.01946610f, 0.16251308f, 0.02459318f, 
    0.07194893f, -0.04009549f, 0.15637930f, 0.28343511f, 0.14944528f, -0.18228495f, 0.00487375f, 0.16799806f, 
    0.01290024f, -0.05203079f, -0.02998082f, -0.00376850f, -0.04435160f, 0.01202524f, 0.08914115f, 0.10516277f, 
    0.20131218f, 0.13695930f, 0.09570213f, -0.16328567f, 0.10427560f, -0.02246341f, 0.05591778f, -0.04117395f, 
    0.06373197f, -0.05157214f, -0.10183717f, 0.01175282f, 0.16265717f, -0.09723396f, 0.01851463f, 0.01843132f, 
    -0.04900425f, 0.06033401f, -0.16730881f, -0.01578778f, 0.16836251f, -0.06022488f, -0.01171584f, -0.04170148f, 
    -0.05681858f, 0.11441977f, 0.06387147f, -0.33818048f, -0.08836862f, -0.02098806f, -0.00351924f, 0.08585379f, 
    0.05876792f, 0.23820750f, 0.11642656f, 0.11301096f, 0.07661937f, 0.00927610f, -0.03979739f, 0.20699199f, 
    0.01609810f, 0.06620368f, 0.04197128f, 0.03965681f, -0.06942124f, 0.07066658f, 0.02581646f, 0.04106427f, 
    0.01196058f, 0.02062516f, 0.03248971f, -0.12698141f, 0.10058025f, 0.11522075f, 0.09739670f, 0.14922804f, 
    0.19413927f, 0.12133381f, 0.15181965f, 0.00373493f, -0.41623780f, 0.20071720f, -0.06190277f, -0.03275229f, 
    0.03447592f, 0.02896393f, -0.02270816f, -0.09310611f, 0.00217432f, -0.02129577f, -0.04551418f, -0.05138782f, 
    -0.00699963f, 0.12176092f, -0.08621690f, -0.08484531f, 0.07410805f, 0.01663043f, -0.00972429f, -0.14072034f, 
    0.06095394f, 0.01112653f, -0.18099199f, 0.07498217f, -0.10064459f, -0.01964891f, 0.01522006f, -0.06522552f, 
    -0.00262969f, -0.02503290f, 0.02509874f, -0.04856093f, -0.04077239f, 0.03836887f, -0.11016931f, 0.02634554f, 
    -0.24745293f, -0.04685246f, -0.02981976f, -0.15250953f, 0.01308436f, -0.01295582f, 0.05649523f, -0.11077403f, 
    0.00456464f, -0.14701276f, -0.03335422f, -0.10854770f, -0.05127228f, 0.08796806f, 0.16430308f, -0.12106265f, 
    -0.09710733f, 0.17889984f, -0.03222669f, -0.00305334f, 0.07353890f, -0.01963148f, 0.07756417f, 0.22002742f, 
    0.23263533f, 0.02803905f, -0.01888059f, -0.14478920f, 0.08757056f, -0.11254930f, -0.02228497f, -0.01441368f, 
    -0.09182180f, 0.12412622f, 0.25953716f, 0.02125285f, -0.03621056f, -0.28153336f, -0.27897114f, 0.03840398f, 
    0.06924792f, -0.08067848f, 0.02042821f, -0.10558549f, -0.04069615f, -0.11480446f, 0.11778320f, -0.10064900f, 
    -0.20785937f, -0.03566405f, 0.02291328f, -0.12479957f, -0.07359486f, -0.01378731f, 0.12242960f, -0.03219043f, 
    0.01159534f, -0.02643185f, -0.18954641f, 0.12015709f, 0.23736297f, -0.15793341f, 0.08673777f, 0.24512443f, 
    0.07592224f, 0.07103231f, 0.14540511f, -0.15393415f, 0.14247385f, -0.04124148f, 0.09223018f, -0.03842561f, 
    0.11451346f, 0.04439877f, 0.06004799f, 0.15095297f, -0.02652097f, 0.01881075f, -0.02709441f, -0.04498265f, 
    -0.10296316f, 0.01017195f, 0.02219965f, -0.25336769f, 0.20389825f, 0.07335374f, 0.01372451f, -0.18552424f, 
    -0.00003609f, -0.09125042f, -0.14477809f, 0.02495593f, 0.00376730f, -0.08054400f, -0.16776459f, -0.13528387f, 
    -0.11631195f, 0.02044005f, 0.18849355f, -0.07857754f, -0.05456532f, 0.15846117f, 0.13646039f, 0.02899899f, 
    -0.13272360f, 0.03370569f, 0.20941754f, 0.07718101f, 0.47593412f, 0.07879797f, 0.10680385f, 0.00463378f, 
    0.11005064f, 0.09351858f, -0.02848319f, 0.03708220f, 0.01145976f, 0.09135313f, -0.10459298f, -0.30762020f, 
    -0.11396321f, 0.09605654f, 0.20204745f, -0.35558653f, -0.05212261f, -0.02236594f, 0.03763470f, 0.02141436f, 
    0.13741778f, -0.13577995f, -0.05444086f, -0.13654298f, 0.11876082f, 0.01521903f, -0.16984108f, 0.14035203f, 
    0.05576096f, -0.09728767f, -0.23538257f, -0.02144413f, -0.12350294f, -0.14295031f, -0.01615378f, 0.11197712f, 
    0.22101787f, 0.02402678f, 0.24817234f, -0.09065746f, -0.12831599f, -0.08803032f, -0.01600545f, 0.03887367f, 
    0.03174267f, -0.17586727f, -0.09370563f, 0.24233350f, -0.17624678f, 0.24339403f, 0.07520920f, 0.08614293f, 
    0.04352815f, 0.07136818f, 0.03857346f, 0.15932170f, 0.05040818f, 0.06455540f, 0.15613030f, 0.07812821f, 
    0.18113559f, 0.09270774f, 0.12459433f, -0.00088575f, -0.01839093f, 0.11193541f, -0.01261525f, 0.27182886f, 
    -0.02340833f, -0.14931941f, 0.05459854f, -0.05539091f, 0.09136692f, -0.09729439f, 0.22503065f, 0.20680349f, 
    0.14367771f, 0.04444590f, -0.13901964f, -0.10439370f, 0.21829619f, -0.02771652f, 0.07259902f, 0.08445856f, 
    0.09644023f, 0.17813091f, 0.04015603f, -0.21605316f, 0.03551174f, 0.00414304f, -0.16463055f, -0.07918727f, 
    -0.00905585f, 0.18325219f, -0.04087909f, 0.06758346f, -0.12340400f, -0.13141760f, 0.05158369f, -0.03273468f, 
    -0.09766050f, -0.02236660f, 0.07460924f, -0.03123096f, 0.05465227f, -0.11293890f, 0.06405909f, -0.07212302f, 
    -0.14129385f, 0.13528886f, -0.12345815f, 0.05539287f, -0.01923829f, -0.01134385f, 0.07134974f, 0.04571201f, 
    -0.01326756f, 0.03019682f, 0.16035387f, 0.03479522f, -0.33898804f, 0.02421305f, -0.03964579f, -0.00721174f, 
    0.05623392f, 0.10285015f, 0.10435182f, 0.11830167f, -0.07170053f, 0.01724591f, 0.07226733f, -0.06001072f, 
    -0.26425108f, -0.14427836f, -0.03559563f, 0.00104449f, 0.04201768f, 0.03719207f, 0.07870198f, -0.08290840f, 
    -0.10214924f, 0.01827868f, -0.05061952f, 0.10666139f, -0.01081359f, 0.19628115f, -0.08613808f, 0.01387204f, 
    -0.01938697f, 0.17085171f, 0.10656069f, -0.00496740f, 0.10563933f, 0.03792363f, 0.00275224f, -0.00400316f, 
    0.02599584f, 0.04952729f, -0.21390347f, -0.03303196f, 0.08899100f, 0.09103291f, -0.08536580f, -0.06494301f, 
    0.03699171f, -0.02455861f, -0.03428810f, -0.22639725f, 0.00055033f, 0.16007257f, -0.04174953f, -0.12283810f, 
    0.09093863f, 0.02025222f, -0.12077045f, -0.02758192f, 0.15419181f, 0.00365217f, -0.04782895f, -0.05173265f, 
    0.17324068f, 0.03605267f, -0.06425001f, 0.15106903f, 0.04263288f, -0.00048298f, -0.04445095f, -0.00639096f, 
    0.04763313f, 0.09119796f, 0.02325621f, -0.05107042f, -0.15707351f, -0.00431045f, 0.04766010f, 0.06994167f, 
    0.03161335f, -0.02045875f, 0.12025960f, 0.12786868f, -0.05897991f, 0.04055602f, 0.00863563f, 0.00507336f, 
    0.11101732f, 0.02407724f, -0.04409139f, 0.51387620f, 0.14123687f, -0.04098875f, 0.11965092f, 0.04838096f, 
    0.05394562f, -0.13839525f, -0.04501313f, -0.00853369f, -0.00741340f, 0.00473039f, -0.12866309f, -0.19805478f, 
    -0.03426078f, 0.01474439f, -0.03906187f, 0.01684955f, 0.04076323f, -0.03045824f, 0.12375581f, 0.02180463f, 
    0.18154828f, -0.01306034f, -0.15059477f, 0.13014929f, -0.06185848f, 0.01581809f, -0.07507380f, -0.05440105f, 
    -0.00550061f, -0.12093077f, -0.02397463f, 0.01325601f, 0.20469671f, -0.20629296f, 0.23479107f, -0.03989321f, 
    0.02626055f, 0.05543200f, 0.13708489f, 0.00878266f, 0.05862691f, 0.04368940f, 0.08946767f, 0.06579557f, 
    -0.08212857f, -0.06203818f, 0.15473683f, 0.08590451f, 0.03917377f, -0.00711242f, 0.03168081f, 0.01182270f, 
    -0.10171022f, 0.02534224f, 0.16891699f, 0.01016448f, 0.10353733f, -0.13474251f, 0.10022182f, 0.10446401f, 
    0.01743156f, 0.06433221f, -0.09793146f, 0.01887488f, 0.02087807f, -0.01920625f, -0.06217346f, 0.06029065f, 
    0.29963621f, 0.02580161f, 0.05017623f, 0.11488280f, -0.04344197f, -0.01796847f, -0.07965179f, -0.08953539f, 
    0.06504173f, 0.08465134f, 0.02426015f, 0.14918680f, 0.03910585f, 0.14778700f, -0.16052477f, 0.07147590f, 
    0.02816090f, -0.10285672f, -0.00501983f, -0.12637165f, -0.01560968f, -0.03724126f, -0.14957955f, -0.10482962f, 
    -0.18676905f, -0.15831432f, -0.06983253f, 0.01790937f, 0.08592153f, 0.03918381f, -0.05383706f, 0.15163533f, 
    -0.05213604f, 0.06306623f, 0.17085110f, -0.04469468f, -0.34440368f, 0.08964379f, 0.15917033f, -0.00235361f, 
    0.11989632f, 0.03630123f, 0.00469992f, 0.04998495f, 0.02036035f, -0.03263292f, 0.19160077f, 0.00277516f, 
    0.06829150f, -0.30944407f, 0.00233123f, 0.13761653f, 0.03948968f, 0.05962763f, -0.06294435f, -0.07856190f, 
    0.06772204f, 0.09306327f, 0.06225537f, 0.02220159f, -0.11507716f, 0.00870330f, 0.03789850f, 0.09351714f, 
    -0.00257457f, 0.12037794f, -0.00995618f, 0.12847702f, 0.05890383f, -0.02987223f, 0.10434079f, -0.00623846f, 
    0.03248228f, 0.10520911f, -0.13115180f, -0.14906508f, -0.00067864f, 0.09130201f, -0.11136848f, -0.06254363f, 
    0.04014786f, -0.05053839f, -0.07103916f, -0.27064613f, 0.13909730f, 0.24488695f, -0.03227152f, 0.02338186f, 
    0.15686613f, -0.08055437f, -0.09402408f, 0.01999594f, 0.16619191f, 0.02758615f, -0.05751985f, -0.01976025f, 
    0.02334365f, 0.30452582f, 0.01272937f, 0.04207443f, 0.00758480f, 0.15082248f, 0.06246402f, 0.10787266f, 
    0.07466450f, 0.02950254f, 0.01971622f, 0.04414904f, 0.01688279f, -0.21538286f, 0.07026220f, -0.12882663f, 
    -0.12092841f, 0.05138450f, 0.18033221f, 0.19607858f, -0.17886034f, 0.00033555f, 0.09872658f, -0.02810891f, 
    0.08812402f, -0.06987781f, 0.03199691f, -0.05284046f, 0.05954566f, 0.07290190f, 0.12632425f, -0.02854966f, 
    0.00165067f, -0.06514353f, 0.06528858f, -0.03592841f, 0.21291348f, -0.06925751f, -0.07248278f, -0.18169288f, 
    0.14645721f, -0.04473648f, 0.05029337f, -0.02152995f, 0.09479737f, 0.07046966f, 0.08937771f, 0.00759486f, 
    0.12535287f, -0.05896455f, 0.07984293f, -0.21242072f, -0.13672651f, -0.06027928f, -0.06015863f, -0.07003246f, 
    -0.04005128f, -0.05237146f, -0.02446473f, 0.02286883f, 0.47878793f, -0.13823821f, 0.15063944f, 0.26798302f, 
    -0.03213296f, -0.01361048f, 0.10725966f, 0.02945671f, 0.01890071f, 0.00958828f, 0.07954989f, 0.10390542f, 
    0.25114614f, -0.23069428f, 0.02616502f, -0.13076809f, 0.02001847f, -0.06836109f, -0.05190979f, 0.11579016f, 
    0.02174039f, 0.12230089f, 0.13014463f, -0.02177104f, 0.08807007f, 0.06072002f, -0.10715091f, -0.22642341f, 
    -0.04846897f, 0.10071467f, -0.00744475f, 0.08975043f, -0.05712831f, -0.10075519f, 0.09946649f, 0.02575739f, 
    0.06190982f, -0.10947041f, -0.02207491f, -0.08674751f, -0.06253640f, 0.07461753f, -0.04590525f, 0.01232100f, 
    0.10443095f, 0.15078185f, 0.02953560f, 0.02116388f, 0.06788923f, -0.16586508f, 0.08109682f, -0.17291234f, 
    0.04284026f, -0.08224917f, 0.06237923f, -0.04060674f, 0.07423635f, -0.05055115f, 0.01117215f, -0.02902855f, 
    0.05547708f, -0.06146001f, -0.06318071f, -0.00644005f, -0.08167119f, -0.01982742f, 0.02281867f, 0.03651182f, 
    -0.06262554f, 0.00020062f, 0.04698783f, 0.05662918f, 0.05167648f, 0.03260370f, 0.06016394f, 0.05221112f, 
    -0.01745214f, 0.00770044f, 0.01346728f, -0.04285530f, 0.02213419f, -0.04808218f, -0.01864156f, 0.05079753f, 
    0.04791294f, -0.00482979f, 0.01441352f, 0.06395184f, -0.05559902f, 0.01069414f, 0.01537270f, 0.00972407f, 
    -0.01853209f, 0.05329262f, -0.07248951f, 0.02008174f, 0.05850174f, 0.04165522f, -0.01518088f, 0.00695064f, 
    0.05734410f, 0.01720556f, -0.03814897f, -0.06339930f, -0.04726626f, 0.03491857f, -0.05918625f, 0.02602953f, 
    0.01785254f, -0.07174417f, 0.06695827f, -0.01968678f, 0.02104200f, -0.07695550f, -0.06000588f, -0.06060343f, 
    0.01064766f, 0.01202114f, -0.03039771f, -0.07562962f, -0.04162872f, -0.02383815f, 0.04516693f, -0.04290776f, 
    -0.03831431f, -0.00159949f, 0.05044043f, -0.07277721f, -0.00408792f, 0.03999833f, 0.05201427f, 0.00700685f, 
    0.06317983f, -0.07762643f, -0.02460182f, -0.07655847f, -0.06444778f, 0.03290175f, 0.05160745f, -0.05094652f, 
    0.01894839f, -0.01406885f, 0.04751159f, -0.02812540f, -0.05123900f, -0.04102016f, -0.05620868f, 0.04421368f, 
    -0.06239140f, -0.04163812f, -0.02776361f, 0.02406309f, -0.04868111f, -0.02982434f, 0.05666944f, 0.05498741f, 
    0.00007197f, -0.02159070f, -0.04651222f, -0.02202998f, 0.05275920f, 0.03570770f, 0.01642750f, -0.06101208f, 
    -0.06121188f, 0.01266867f, 0.06473141f, 0.03218737f, -0.06510455f, 0.00273218f, -0.07331038f, -0.07947377f, 
    -0.02697458f, 0.04049580f, 0.03363698f, 0.01312499f, -0.03998708f, 0.00619115f, 0.00548024f, -0.05432817f, 
    -0.01877245f, -0.00447862f, -0.06957677f, -0.07803094f, -0.02125293f, -0.04614351f, -0.00014718f, -0.02723144f, 
    -0.07973407f, -0.00122383f, 0.00912105f, 0.00898192f, -0.01198277f, -0.03799406f, -0.07424435f, 0.06416900f, 
    0.05725166f, -0.06522083f, 0.01162664f, 0.06351263f, -0.02939273f, 0.01708883f, -0.04841860f, -0.03026807f, 
    -0.03347176f, -0.03084565f, 0.00164795f, -0.05488959f, 0.02276862f, 0.04187020f, -0.03550385f, -0.00394884f, 
    -0.06775607f, -0.00838900f, 0.03903902f, 0.04042139f, -0.01721659f, 0.01954039f, 0.03905776f, 0.02260228f, 
    0.03539661f, -0.01900051f, -0.04493519f, -0.06238959f, 0.03454031f, 0.01381867f, 0.01516199f, -0.06455991f, 
    0.05390620f, 0.01260023f, -0.01780525f, -0.02180902f, 0.05763929f, 0.00211500f, -0.03774403f, -0.05457503f, 
    0.04722913f, 0.05115458f, -0.00127012f, -0.03575583f, -0.05767095f, 0.04235370f, 0.00654373f, -0.03680620f, 
    -0.02625928f, 0.03346054f, -0.06763501f, 0.03558739f, -0.07142948f, -0.06512170f, -0.04986224f, 0.01798256f, 
    0.03999079f, -0.06886710f, -0.05273161f, -0.04168355f, 0.03767051f, 0.05104753f, -0.04332831f, -0.03613127f, 
    0.04836397f, -0.06185638f, -0.03521467f, -0.07414462f, -0.04635767f, 0.04112148f, -0.00595416f, 0.01204959f, 
    0.05632735f, 0.05613687f, -0.02637156f, -0.07379638f, 0.04217284f, 0.05924530f, 0.01027817f, -0.00917043f, 
    0.01113658f, -0.07033583f, -0.05547560f, 0.05877481f, -0.04833426f, 0.04799436f, -0.08006323f, -0.01127736f, 
    -0.00190621f, -0.02823482f, -0.01495394f, -0.05852100f, -0.00792515f, -0.02279888f, -0.02376683f, -0.00253364f, 
    -0.07056493f, -0.07839184f, 0.05829979f, -0.04096949f, 0.04708984f, -0.05848698f, -0.06431154f, 0.03137929f, 
    0.02210963f, -0.08104758f, 0.05270553f, 0.00294371f, -0.04220945f, -0.06389870f, -0.01151785f, -0.02621629f, 
    -0.00969228f, -0.04395612f, -0.01427097f, -0.01771001f, -0.00658499f, 0.04036649f, 0.01318542f, -0.03267336f, 
    -0.05362485f, -0.02532568f, 0.03707160f, -0.01366252f, 0.00885955f, -0.00525993f, 0.02404775f, 0.05061143f, 
    0.04398111f, -0.00546327f, -0.06865048f, -0.07190984f, -0.02032699f, -0.06925336f, -0.04705169f, -0.05213565f, 
    0.04028020f, -0.01695085f, 0.05626292f, 0.01341334f, -0.00976635f, -0.03008712f, -0.03201919f, 0.03048315f, 
    -0.07664636f, 0.05365876f, 0.02042366f, 0.00029797f, 0.02073661f, 0.03519390f, -0.04938469f, -0.07577183f, 
    -0.00379603f, -0.07166585f, 0.01670764f, -0.03558158f, 0.00009344f, 0.00920965f, -0.02584520f, -0.04142845f, 
    0.02040661f, -0.07549236f, -0.03092110f, -0.00511705f, 0.05530080f, 0.00784290f, -0.01178241f, -0.02398922f, 
    -0.02085707f, 0.01894280f, 0.00199701f, -0.06166588f, 0.05292391f, 0.00045659f, 0.04504021f, -0.03477477f, 
    0.00213730f, 0.00816119f, 0.02735349f, 0.03782469f, 0.00323155f, -0.08435305f, 0.05997387f, -0.08047906f, 
    -0.01740493f, -0.05337797f, -0.02815840f, -0.07048218f, 0.03825995f, -0.00630375f, 0.03481184f, -0.02793535f, 
    -0.04504123f, 0.04428785f, -0.06406438f, 0.03983730f, -0.04361346f, 0.02146805f, -0.03162064f, -0.00354240f, 
    0.04841984f, -0.07918230f, 0.05952457f, -0.05484405f, 0.01926904f, -0.01018538f, -0.07909853f, 0.06041134f, 
    0.01183497f, -0.02848568f, -0.06872196f, 0.00849249f, -0.00127379f, 0.03921346f, 0.04728740f, 0.02238280f, 
    0.06033718f, -0.05299962f, 0.02902960f, 0.04288273f, -0.05684221f, -0.06902856f, 0.01118885f, 0.04184399f, 
    -0.00608969f, 0.02326465f, 0.03972582f, 0.04063153f, 0.05520369f, 0.04996049f, 0.00890895f, -0.07124493f, 
    -0.05845603f, 0.03262631f, 0.00422206f, 0.02723298f, -0.06845537f, 0.02937060f, 0.01355836f, -0.01513076f, 
    -0.01894938f, 0.03990243f, -0.07043055f, -0.00574650f, 0.01944486f, -0.00229786f, -0.01488249f, -0.03708710f, 
    -0.11437538f, 0.29822075f, -0.18113224f, 0.24163166f, 0.05419689f, 0.07322414f, -0.09093321f, -0.01417344f, 
    -0.14043844f, 0.01318113f, -0.08094624f, -0.00498260f, 0.08732813f, -0.05885108f, 0.04564738f, 0.03366260f, 
    0.04450209f, -0.01578891f, 0.00908810f, -0.03592465f, 0.03016466f, 0.03462576f, 0.03287780f, -0.10488040f, 
    0.33270413f, 0.17217559f, 0.01357452f, 0.14356759f, -0.09274242f, -0.10929186f, 0.07098294f, 0.01593358f, 
    -0.08761676f, -0.05138034f, -0.06078523f, -0.02475727f, -0.05775531f, 0.24610949f, 0.24916452f, 0.11372051f, 
    -0.04857340f, 0.09288806f, -0.21511160f, 0.05957960f, -0.01476300f, 0.08630561f, 0.10319658f, 0.02342186f, 
    -0.22816655f, -0.13962276f, 0.04987881f, -0.02535005f, 0.00654144f, -0.11456498f, -0.06147514f, -0.00992937f, 
    -0.02823666f, -0.04388987f, 0.00361512f, 0.04555066f, 0.05370874f, 0.15977742f, -0.00748163f, 0.03079041f, 
    0.08676562f, 0.14205444f, 0.10421930f, -0.03902601f, -0.04745257f, -0.06127942f, 0.06613524f, -0.01197569f, 
    0.02902067f, 0.18065593f, -0.43242106f, -0.01326859f, 0.12797913f, 0.06178356f, -0.09002501f, 0.02618312f, 
    -0.10675680f, 0.04717542f, -0.07197837f, 0.00745576f, -0.04169594f, 0.03359308f, 0.11526222f, 0.06361277f, 
    0.01715562f, -0.05146844f, -0.09720369f, -0.06318281f, 0.05015276f, -0.05568001f, 0.07438140f, -0.01323988f, 
    0.03065010f, 0.32622805f, -0.15652232f, 0.01803345f, 0.06166250f, -0.05717782f, -0.08060632f, -0.05296098f, 
    0.03429054f, -0.02108523f, -0.02464689f, -0.04206595f, 0.08307173f, -0.01902392f, 0.02943463f, 0.25365633f, 
    0.05352521f, -0.00568124f, 0.01386274f, 0.07818326f, -0.03908927f, 0.04210150f, 0.12141874f, 0.02654928f, 
    -0.22295181f, 0.19368631f, 0.01216165f, -0.29965818f, 0.12593223f, 0.07780705f, -0.16440469f, -0.01629231f, 
    0.17899209f, -0.06317770f, -0.00893039f, -0.07673255f, -0.14719217f, -0.16063850f, 0.26321176f, 0.04242069f, 
    0.05472900f, 0.06509212f, 0.00246690f, -0.00241543f, 0.09181160f, -0.07491799f, -0.07224230f, 0.02849849f, 
    -0.23019645f, 0.01299300f, 0.14483662f, -0.00900433f, 0.07697944f, 0.16763626f, -0.10848887f, -0.15106073f, 
    0.06131811f, -0.01341677f, 0.12448932f, 0.00505338f, -0.12594053f, -0.22160321f, 0.09693342f, -0.15245347f, 
    0.02959234f, -0.05766152f, -0.10564630f, -0.03083974f, 0.04614830f, -0.04628696f, -0.09733211f, -0.03172356f, 
    -0.05972321f, 0.14447397f, 0.02656387f, -0.05714213f, 0.00256870f, -0.11163449f, 0.00345820f, -0.09700304f, 
    0.03893881f, 0.05791541f, 0.16384812f, 0.08160550f, 0.06215125f, 0.37705630f, 0.04026709f, -0.02978758f, 
    0.09186405f, -0.00151320f, -0.08109768f, -0.06620605f, 0.01569369f, 0.03906916f, 0.01031184f, 0.08211466f, 
    -0.03296447f, 0.02441874f, -0.03878791f, 0.00675849f, -0.07685010f, -0.06640714f, -0.02291969f, -0.00934116f, 
    -0.05088767f, 0.03356153f, 0.03665455f, 0.01122080f, -0.06297620f, -0.04921377f, -0.00999473f, -0.05584684f, 
    0.02508284f, -0.06594045f, -0.03841079f, -0.04508120f, -0.00281347f, -0.03790513f, 0.05468507f, -0.00153970f, 
    -0.03713468f, -0.06934841f, -0.06040023f, -0.02670078f, -0.06210976f, -0.01142109f, 0.05297241f, -0.01546178f, 
    0.03648690f, 0.01230200f, -0.06552751f, -0.00838013f, -0.02942695f, 0.06045551f, -0.02228216f, -0.00936610f, 
    0.06299893f, -0.02387519f, -0.07894351f, 0.05394220f, -0.04829585f, -0.04311895f, 0.00441886f, 0.04546111f, 
    -0.00872978f, 0.02402639f, 0.01160801f, -0.05515474f, 0.02746227f, -0.01279313f, 0.02920114f, -0.01887388f, 
    -0.07438613f, -0.06479092f, -0.05895207f, -0.04684687f, -0.01972004f, -0.03724713f, 0.05228073f, -0.04772885f, 
    0.04429497f, -0.07190487f, 0.00244133f, -0.08420192f, 0.04444592f, 0.01121028f, 0.04910879f, 0.00059767f, 
    0.04163507f, 0.03994009f, -0.04267430f, 0.05749845f, -0.05761222f, 0.00865018f, 0.04912142f, -0.07151024f, 
    0.03397578f, 0.03629937f, -0.03506908f, -0.07576811f, 0.04874063f, -0.04598144f, -0.00489519f, -0.07533921f, 
    -0.06693945f, 0.00735470f, 0.04872359f, -0.07400396f, 0.03815544f, -0.00587372f, -0.07225560f, 0.00598884f, 
    0.06710721f, 0.05597183f, -0.04919525f, 0.02410057f, 0.03510973f, -0.00900722f, -0.04850495f, 0.01061455f, 
    0.03018948f, -0.00093719f, -0.03489142f, -0.04462713f, -0.00048859f, 0.00764647f, -0.00540297f, 0.00466222f, 
    0.03168274f, 0.02187722f, 0.02916056f, 0.01992670f, -0.05430551f, 0.01743927f, 0.01078042f, -0.00834183f, 
    -0.07871521f, -0.01124835f, -0.07308022f, -0.04879730f, 0.00367327f, -0.07004225f, -0.01845773f, -0.07299556f, 
    0.05758509f, -0.08149981f, 0.05163026f, -0.07959691f, 0.05124438f, -0.02181276f, -0.00165413f, 0.00010363f, 
    0.05982787f, 0.00804997f, 0.04266716f, 0.01109873f, -0.07752875f, -0.07103296f, -0.04456642f, 0.04302073f, 
    0.02951802f, -0.00921202f, -0.00260886f, -0.03311046f, 0.01211485f, 0.00978883f, -0.06428844f, -0.01697018f, 
    -0.05590662f, -0.04724757f, -0.02067891f, 0.01331371f, 0.03419337f, 0.01412136f, 0.00650546f, 0.06131747f, 
    0.03569883f, 0.01834978f, -0.05002786f, -0.05146892f, 0.02541123f, 0.01189017f, -0.03931162f, 0.04099159f, 
    -0.02980376f, 0.02587115f, -0.00275382f, -0.02803611f, -0.02360054f, -0.00564038f, -0.02555095f, 0.03810221f, 
    -0.06467963f, -0.01750386f, 0.05471824f, 0.04047934f, 0.01204581f, 0.04825849f, -0.01837501f, -0.01525005f, 
    0.03781902f, 0.01150623f, -0.03621578f, -0.08203918f, 0.05408150f, -0.05268677f, 0.02846909f, -0.07223192f, 
    0.24987356f, -0.33056208f, 0.25151351f, -0.03829235f, -0.00918290f, -0.05891623f, 0.02280615f, 0.04809058f, 
    0.03090893f, -0.01523196f, -0.04524073f, 0.04537134f, -0.02201876f, -0.00876338f, 0.05106973f, -0.11600530f, 
    -0.00676510f, -0.02783154f, -0.10598846f, 0.13201112f, 0.11082426f, -0.15897600f, -0.01563787f, -0.01800751f, 
    0.20469521f, 0.04041446f, 0.15940388f, -0.09091744f, -0.00662233f, 0.13588268f, -0.05385992f, 0.00060502f, 
    0.05076626f, 0.05695210f, -0.04484599f, 0.02109472f, 0.35268041f, -0.07278246f, 0.20770434f, 0.04424036f, 
    0.04008184f, -0.05934487f, -0.12366300f, -0.03621377f, 0.02192329f, 0.01975600f, -0.04538912f, -0.03204067f, 
    -0.02942043f, -0.09183449f, -0.01886677f, 0.17293872f, -0.03032745f, -0.01579737f, 0.05426560f, 0.09676971f, 
    -0.00487671f, 0.03002005f, 0.02795454f, -0.00630731f, 0.31009018f, 0.04337084f, 0.12683184f, 0.15510736f, 
    -0.15134805f, -0.02920720f, 0.08991545f, 0.01837446f, 0.02290637f, -0.02628675f, 0.01852230f, 0.16677958f, 
    0.05056102f, 0.14948885f, 0.08613124f, -0.07626182f, -0.14491296f, -0.03643070f, 0.12405072f, 0.09569519f, 
    -0.06656253f, -0.15026905f, -0.03153256f, -0.01465742f, 0.09869485f, -0.10372320f, 0.04107262f, -0.04942809f, 
    0.10597722f, 0.06085787f, 0.08443420f, 0.04291202f, 0.01297967f, 0.12659237f, -0.05272396f, -0.15259078f, 
    -0.18673716f, -0.13029276f, 0.13462774f, -0.14253078f, 0.07889669f, -0.03491773f, 0.10044561f, -0.06750874f, 
    0.05481386f, 0.09820636f, -0.03935640f, 0.03006983f, 0.25742009f, 0.01810084f, 0.22532195f, 0.07893734f, 
    -0.11366467f, 0.11117913f, 0.04218247f, -0.00942918f, -0.06742080f, 0.19295259f, 0.01515483f, -0.02300459f, 
    0.22039729f, -0.01927202f, 0.06175189f, -0.02386706f, 0.09811078f, -0.00089072f, 0.09720247f, 0.12626928f, 
    0.05417667f, 0.10531851f, -0.08130343f, 0.14004779f, -0.05421387f, 0.05431650f, -0.32025549f, -0.18368869f, 
    0.08820778f, 0.20024294f, 0.00681536f, -0.06489744f, -0.02465853f, 0.08728443f, -0.06202630f, -0.01445138f, 
    0.20032889f, -0.00429181f, -0.21648569f, -0.19299681f, 0.08215474f, 0.03705653f, -0.02913414f, 0.10366306f, 
    -0.08737440f, -0.00637120f, -0.09076464f, -0.04293938f, -0.00040274f, 0.08964828f, -0.12658510f, 0.02537913f, 
    0.00739135f, -0.04217058f, -0.03188868f, -0.03651527f, -0.08056719f, -0.03076820f, 0.09901381f, 0.02452550f, 
    -0.21499348f, -0.14459953f, -0.17864326f, -0.06152883f, 0.09716878f, 0.00779565f, 0.12439135f, -0.00502260f, 
    0.01445628f, 0.00933173f, -0.22600289f, -0.06506597f, -0.07662844f, -0.19469826f, 0.01413898f, -0.05553127f, 
    0.04933713f, -0.01570340f, 0.10461092f, -0.03495611f, -0.00546922f, 0.01665375f, 0.08819332f, -0.00245873f, 
    0.20475684f, 0.12640215f, -0.00461391f, 0.17116405f, 0.06773233f, -0.09969787f, 0.03147360f, -0.02676018f, 
    0.01355841f, 0.05604904f, 0.04176342f, -0.02957736f, 0.04640573f, -0.00589289f, 0.06597871f, 0.03922700f, 
    -0.03967567f, -0.05069749f, 0.07684109f, -0.10017338f, -0.05377001f, 0.13942604f, 0.01003761f, -0.16172901f, 
    0.27487075f, 0.04111034f, 0.08293819f, 0.07860918f, -0.03052725f, -0.08082099f, 0.01755234f, 0.10506862f, 
    -0.05258174f, 0.04919117f, 0.00161021f, 0.11745458f, -0.02859098f, 0.03851460f, 0.15744393f, 0.02809868f, 
    0.00261638f, 0.00888531f, -0.06622824f, 0.15150088f, 0.01109320f, 0.22437659f, -0.08050306f, 0.04019501f, 
    -0.27543148f, -0.12113964f, -0.05997100f, -0.28339201f, -0.08040164f, 0.04437657f, 0.03486155f, 0.02038171f, 
    -0.12822519f, 0.06360961f, 0.06141742f, -0.02159142f, -0.04368340f, 0.02354899f, -0.07650249f, 0.03830533f, 
    0.15929295f, 0.09888464f, 0.03173805f, -0.08857985f, 0.02911838f, -0.01710151f, 0.03636355f, -0.00556068f, 
    -0.28799006f, 0.06623380f, -0.18599334f, -0.07457438f, 0.05577989f, 0.10211514f, -0.07440934f, -0.00281015f, 
    0.05328670f, 0.09244505f, 0.02113437f, -0.08421350f, 0.25127506f, 0.16466761f, 0.09207419f, 0.19564483f, 
    0.05530516f, -0.11662618f, -0.05829133f, -0.08509395f, -0.00125490f, -0.08696398f, 0.21410066f, 0.07911881f, 
    0.09064826f, 0.22658560f, -0.28500986f, -0.04558501f, 0.10813894f, -0.07561360f, -0.10014624f, -0.07473634f, 
    -0.08170574f, -0.13377871f, 0.07320099f, -0.05811862f, -0.05761195f, 0.09254473f, -0.07237684f, 0.15829980f, 
    0.15109970f, 0.00970832f, -0.07575762f, -0.04411938f, 0.14040509f, 0.13874613f, 0.06718246f, 0.01660357f, 
    -0.29992637f, 0.09277695f, 0.00104774f, 0.07683367f, -0.09899414f, 0.07605085f, -0.16032811f, -0.06354646f, 
    0.05193238f, -0.09751976f, 0.01202575f, -0.02095892f, 0.01026564f, -0.27709705f, 0.32496282f, -0.14222227f, 
    -0.09346382f, -0.05489571f, -0.04319142f, 0.00401783f, 0.10108569f, -0.07338083f, -0.08870945f, 0.01310567f, 
    0.01755979f, 0.07459255f, 0.28007784f, 0.17222881f, -0.06504050f, -0.01815778f, -0.05111870f, -0.09267801f, 
    0.11489130f, -0.00599257f, -0.00940877f, 0.10606074f, 0.12329225f, 0.09205014f, -0.08596002f, -0.07163534f, 
    0.00458325f, -0.00521011f, 0.05277335f, -0.05038475f, 0.20318235f, -0.03102406f, -0.11682910f, -0.11315159f, 
    0.08368313f, 0.23752628f, -0.07822336f, -0.33934900f, 0.04244610f, 0.02510958f, 0.03990149f, -0.07562201f, 
    0.13614076f, 0.06216750f, 0.11584742f, 0.07198807f, -0.17475800f, 0.24229541f, -0.03151983f, -0.06933429f, 
    0.03523012f, 0.03759054f, -0.06044379f, -0.08218973f, 0.03037657f, -0.00188281f, 0.00703050f, 0.07533401f, 
    -0.09227016f, -0.12017369f, 0.02955041f, -0.23670542f, 0.04765945f, 0.12596126f, 0.05619346f, -0.04350727f, 
    0.16455612f, 0.00442185f, 0.02158231f, -0.01317950f, 0.09147277f, 0.05197104f, 0.07164361f, 0.14888676f, 
    0.15434748f, 0.09891339f, -0.04024037f, 0.07317922f, 0.01875426f, 0.02409680f, -0.02556794f, 0.06586118f, 
    0.21671058f, -0.07598313f, -0.03604039f, 0.11184501f, 0.03227105f, 0.02472151f, -0.02340216f, 0.01047860f, 
    0.09865753f, 0.00554408f, 0.11059583f, -0.13037969f, -0.21368787f, -0.30489445f, -0.08674404f, -0.02722635f, 
    0.13201641f, -0.17999402f, -0.00875574f, 0.02128931f, -0.01276287f, 0.11353971f, 0.11388393f, 0.09822027f, 
    0.16558152f, 0.02046267f, 0.01824132f, -0.07644184f, -0.09208652f, -0.00754539f, -0.03384845f, -0.02429359f, 
    -0.03293015f, 0.08289273f, 0.15131621f, 0.04273131f, -0.18727614f, -0.09568248f, -0.02095738f, -0.13746087f, 
    0.10825858f, -0.05116280f, 0.08117108f, -0.07255307f, -0.02355031f, 0.11323152f, 0.12436760f, 0.14467438f, 
    -0.12625416f, -0.02864961f, 0.19942516f, -0.03392341f, 0.12383819f, -0.07863346f, 0.05120702f, 0.03615566f, 
    0.06995421f, -0.04279399f, -0.05713741f, 0.12706622f, 0.02234733f, 0.01381684f, 0.02057826f, -0.01904471f, 
    0.06970327f, 0.00641985f, 0.09140202f, 0.07889694f, -0.10945650f, -0.08128153f, -0.08357644f, 0.06882327f, 
    -0.07756858f, -0.19764893f, 0.04476058f, -0.15379910f, 0.06333106f, 0.03159598f, -0.02388107f, -0.00496277f, 
    0.03098072f, 0.05581367f, 0.13046803f, 0.01625974f, -0.08796420f, -0.11031283f, -0.10204485f, -0.31504840f, 
    0.01160016f, 0.06234819f, -0.09302562f, -0.11694195f, 0.00171610f, 0.08350436f, -0.05198941f, 0.09244851f, 
    0.00057692f, 0.00403376f, 0.08233713f, 0.12499480f, -0.00013261f, -0.08038459f, 0.04835546f, 0.08767036f, 
    -0.05308337f, 0.14324579f, -0.04237024f, -0.05567483f, 0.38523281f, -0.07264042f, 0.09453070f, 0.17060012f, 
    -0.05363704f, -0.08750985f, -0.01830203f, 0.05931020f, 0.04599673f, -0.00693920f, -0.02948560f, 0.03692702f, 
    0.37447223f, -0.01248006f, -0.01588786f, 0.08906185f, -0.10014176f, -0.19764474f, 0.05979836f, 0.00935430f, 
    -0.01321845f, -0.08736811f, -0.00146206f, -0.02181667f, 0.23784621f, 0.04925220f, -0.22114481f, -0.20602880f, 
    -0.02311960f, 0.03605650f, -0.01044888f, -0.04416961f, -0.04000577f, -0.01811953f, 0.15880607f, 0.03720392f, 
    -0.39628571f, 0.02098521f, -0.07572298f, -0.02734159f, 0.04074393f, 0.00193909f, 0.06163079f, -0.06630117f, 
    -0.04397525f, 0.10495938f, -0.07814993f, -0.11139471f, 0.04836177f, 0.08435456f, 0.11073446f, -0.10169701f, 
    0.04217445f, -0.02102884f, -0.02555710f, 0.12928842f, 0.04520714f, 0.13743420f, 0.12808056f, -0.11878379f, 
    -0.17420524f, 0.06917022f, 0.03896353f, -0.02401046f, 0.18883114f, -0.05443773f, 0.04804524f, -0.23047291f, 
    0.06025769f, 0.05883640f, 0.07703733f, -0.03970911f, -0.12060515f, 0.22648735f, -0.02551827f, -0.05704574f, 
    0.08606146f, 0.09845789f, 0.02510364f, 0.01460514f, 0.04062542f, 0.06458903f, -0.05111802f, -0.00517259f, 
    0.02199488f, -0.28650737f, 0.13196433f, -0.25426424f, 0.15040748f, 0.06374478f, 0.15667532f, -0.02821784f, 
    0.01772328f, -0.02171418f, -0.06272168f, -0.04029818f, -0.01879740f, 0.15689714f, -0.09301060f, -0.00737092f, 
    0.04572195f, -0.09883171f, 0.01527109f, -0.05034751f, -0.10069320f, 0.08688756f, 0.16614853f, 0.03293234f, 
    -0.07312395f, 0.10549327f, -0.23872438f, -0.10412045f, -0.05822302f, -0.04930083f, 0.01506182f, -0.03887701f, 
    0.03993209f, -0.04080106f, 0.07505712f, 0.05503512f, 0.25754970f, 0.06116983f, -0.31635737f, -0.11895481f, 
    0.11950895f, 0.13658698f, 0.07292604f, -0.04618129f, -0.04482092f, 0.02872943f, 0.05911179f, 0.05811710f, 
    0.60987943f, 0.29766673f, -0.02303994f, -0.06354147f, 0.09931064f, 0.02364498f, -0.06432676f, 0.03999715f, 
    0.10548232f, 0.04825770f, 0.11541322f, -0.02189975f, -0.03361905f, -0.20797215f, 0.12687825f, 0.08600979f, 
    -0.16404721f, 0.07475895f, 0.01522229f, 0.05941283f, 0.11195257f, -0.11403377f, -0.03863080f, 0.04494651f, 
    0.12855722f, -0.14192910f, 0.18809916f, 0.34729612f, 0.01536949f, 0.03818893f, -0.00834734f, 0.01010240f, 
    -0.08943456f, 0.06868344f, 0.03157785f, -0.00542633f, 0.09330430f, -0.19945917f, -0.18627883f, 0.00388219f, 
    0.17144273f, -0.08448397f, -0.04699157f, -0.12107196f, -0.07559046f, -0.01785118f, -0.05000768f, 0.09884220f, 
    0.23770252f, -0.05524340f, 0.09476615f, 0.06016144f, -0.02302215f, 0.22209424f, -0.05419635f, -0.03567350f, 
    0.04973006f, 0.03827182f, -0.06352512f, 0.06594454f, -0.23357227f, 0.04390735f, 0.16446197f, -0.14633399f, 
    0.10098793f, 0.05156585f, 0.06175143f, -0.10589652f, 0.08808322f, 0.06001493f, 0.04484700f, -0.00637851f, 
    -0.05329543f, 0.20494696f, -0.05337055f, -0.05334086f, 0.03615615f, 0.03174222f, 0.03986844f, -0.01567812f, 
    -0.05773578f, -0.06386854f, 0.00794058f, -0.04937642f, 0.19071980f, -0.22446837f, -0.21773212f, 0.24684861f, 
    -0.02612653f, 0.03620080f, 0.02333016f, -0.01962821f, -0.08779372f, 0.12004873f, 0.09113213f, 0.05110598f, 
    -0.09991021f, -0.11523007f, 0.02878975f, 0.14321268f, -0.02055367f, -0.03120532f, -0.07372253f, -0.07211003f, 
    -0.01887611f, -0.03125000f, 0.10310081f, 0.07093415f, -0.03914840f, -0.04949065f, 0.02107892f, -0.04004210f, 
    0.08892134f, -0.11154576f, -0.07643425f, -0.12844673f, 0.18418948f, 0.01967593f, -0.06060220f, -0.08405233f, 
    -0.06250901f, 0.18503071f, -0.15775149f, -0.05910939f, 0.04798163f, -0.12612672f, -0.03471743f, -0.03453242f, 
    0.02501052f, 0.07831703f, 0.15185231f, -0.17282635f, -0.19355780f, -0.01733874f, -0.13247754f, 0.00820134f, 
    0.13422634f, 0.04444119f, 0.07193577f, -0.01041163f, -0.06051311f, 0.01775427f, 0.00606389f, -0.09218428f, 
    -0.25052860f, -0.04557464f, 0.01709951f, -0.11852050f, 0.06159844f, 0.00884316f, 0.01981078f, -0.13540699f, 
    0.00389889f, 0.03479914f, -0.06535765f, 0.02835486f, 0.06796590f, 0.09956493f, -0.02019318f, 0.14308566f, 
    0.06001244f, 0.06360967f, 0.14404851f, -0.24520224f, 0.04385719f, -0.04266372f, 0.04712879f, -0.02315055f, 
    0.12999074f, 0.07332879f, 0.02147350f, -0.03412509f, 0.03956619f, 0.03565397f, -0.04072477f, -0.16640973f, 
    -0.01490269f, 0.08358470f, 0.05639850f, -0.16433001f, 0.04777585f, -0.00942111f, -0.07363015f, -0.30250293f, 
    -0.03376479f, 0.01965926f, -0.08772021f, -0.05417636f, 0.00714786f, -0.06301912f, -0.04815840f, -0.14813074f, 
    -0.02454871f, 0.04562136f, 0.22504786f, 0.06595416f, 0.05996973f, 0.04853690f, -0.00549770f, -0.00285344f, 
    0.08312424f, 0.04377813f, 0.16152237f, 0.00223752f, 0.22796346f, 0.09874609f, -0.03337109f, 0.00664619f, 
    0.02035998f, -0.09014100f, 0.15518987f, 0.11725532f, -0.05416460f, 0.03748399f, -0.08614425f, -0.07397339f, 
    0.03444525f, 0.03804744f, 0.08892102f, 0.00954338f, 0.04971246f, 0.11940727f, 0.04078329f, 0.02261581f, 
    0.19759598f, -0.14365073f, -0.09094179f, 0.06182401f, -0.03186782f, -0.16000059f, -0.15593992f, -0.03713023f, 
    -0.02215956f, -0.18979257f, -0.07651397f, -0.13326661f, 0.00780941f, -0.12042931f, 0.08285974f, 0.11734643f, 
    0.17427023f, 0.03958676f, -0.02840281f, 0.02902300f, -0.01055197f, -0.01125871f, 0.09640053f, -0.07800961f, 
    -0.06508043f, -0.17831568f, 0.03748586f, -0.01233365f, -0.02926399f, 0.19585678f, 0.17394474f, 0.02780791f, 
    0.03504619f, -0.04162025f, 0.13627391f, 0.16683738f, -0.01548364f, 0.01047042f, 0.12503488f, 0.00250659f, 
    -0.04767448f, 0.13482869f, 0.07125651f, 0.01280052f, 0.05663604f, 0.10407853f, 0.01412809f, 0.14972235f, 
    -0.00879828f, -0.00470605f, 0.08187637f, -0.06857262f, 0.19346948f, 0.00606198f, 0.21120293f, 0.30112424f, 
    0.07788541f, 0.02364432f, -0.00588740f, 0.01935670f, -0.01074276f, -0.05866675f, 0.00240886f, 0.21497455f, 
    0.24471000f, 0.03552637f, 0.22612219f, 0.12027708f, -0.04672701f, 0.12805344f, -0.18667217f, -0.04280222f, 
    -0.03450949f, 0.05533031f, 0.15695497f, 0.12938030f, 0.02347293f, 0.00890195f, -0.06086731f, 0.03474880f, 
    0.04637380f, 0.04758896f, -0.00896211f, 0.02834541f, 0.17983517f, -0.00858229f, -0.11852115f, -0.11636507f, 
    0.05146949f, 0.05426519f, 0.00642035f, 0.19810952f, -0.10857687f, 0.05698134f, -0.03777681f, -0.08863792f, 
    -0.06453966f, -0.09313269f, -0.04820571f, 0.05463551f, 0.17173108f, 0.04323723f, 0.09360084f, -0.00742758f, 
    0.00930122f, 0.00630167f, -0.13161679f, 0.03431790f, -0.01875724f, 0.08666418f, 0.05422478f, -0.08227892f, 
    0.28915027f, 0.18831868f, -0.11427894f, 0.12648581f, 0.07848106f, -0.03053969f, -0.09788424f, -0.04591426f, 
    0.01252267f, -0.05587228f, 0.00354506f, -0.07593015f, 0.14999166f, 0.01271293f, 0.10594996f, 0.10909708f, 
    -0.02196936f, -0.11478704f, -0.02975426f, -0.04171993f, -0.07949531f, 0.06988174f, 0.03864699f, 0.04745102f, 
    -0.10476997f, -0.01478314f, -0.04178042f, 0.02669944f, 0.06489662f, -0.15149952f, 0.12155253f, 0.02991275f, 
    -0.00568644f, 0.05628388f, -0.03894133f, 0.22269459f, 0.22199905f, -0.00529281f, 0.15750954f, 0.13683735f, 
    0.02091086f, -0.08583326f, 0.05410614f, 0.01527436f, 0.09647241f, -0.07242102f, -0.06030599f, 0.17848225f, 
    0.44077328f, 0.14941843f, -0.02037098f, 0.08756999f, -0.01088866f, 0.12821096f, -0.01707543f, 0.01371415f, 
    0.07752279f, 0.06317232f, 0.02383708f, 0.06618349f, -0.08275853f, -0.26159075f, 0.03352154f, -0.05997368f, 
    0.02944692f, 0.02629448f, -0.04155782f, 0.00761385f, 0.04399486f, 0.01062701f, -0.01014118f, -0.05864257f, 
    -0.07583288f, 0.20873398f, -0.02175814f, -0.04398223f, -0.14125788f, -0.00633083f, -0.00609558f, 0.03801209f, 
    0.01907639f, 0.02247387f, -0.00737953f, 0.02272370f, 0.15744337f, 0.21423677f, 0.15876824f, 0.15552229f, 
    -0.00914266f, 0.01082528f, 0.05134716f, 0.14436595f, 0.02893301f, -0.01032457f, 0.10036362f, -0.01415694f, 
    0.03235449f, -0.10628898f, 0.02275351f, -0.25799409f, 0.13009690f, 0.06949327f, 0.05830797f, -0.02804782f, 
    0.07188649f, 0.05238396f, -0.07155190f, -0.14603327f, -0.31138289f, 0.15639836f, -0.09804000f, -0.05516024f, 
    0.06748093f, 0.02495331f, 0.07883268f, -0.01499075f, -0.06291586f, -0.03171419f, 0.07195749f, 0.09212317f, 
    -0.31825328f, -0.10045651f, -0.06131447f, -0.02351456f, 0.22218628f, 0.10066257f, 0.07764578f, -0.11616816f, 
    0.10848918f, 0.05170836f, -0.02946299f, -0.03062250f, -0.46407670f, -0.07243121f, 0.09094791f, -0.07696950f, 
    -0.10533704f, -0.03114600f, 0.03411386f, 0.08017177f, -0.04115347f, -0.03712136f, 0.06915798f, 0.02841902f, 
    -0.06157106f, -0.25964868f, 0.10397910f, 0.01065235f, -0.02131449f, -0.04006957f, 0.08244202f, -0.06421221f, 
    0.05763804f, -0.11389912f, 0.11131985f, 0.05525534f, 0.19980408f, 0.11004412f, -0.01538899f, 0.03624330f, 
    0.09729020f, 0.14084540f, 0.08558109f, -0.13209993f, -0.05781247f, 0.00168362f, 0.08358628f, 0.21910368f, 
    -0.02271205f, -0.08711631f, 0.01847238f, 0.03051081f, -0.06667049f, -0.01393061f, 0.06517914f, 0.04431883f, 
    -0.06380473f, -0.02542413f, -0.00582315f, 0.03553563f, 0.00878057f, 0.05985910f, -0.02258872f, -0.07079041f, 
    -0.02298373f, -0.00709049f, -0.04537696f, -0.06201746f, -0.07953445f, -0.06991126f, 0.06145270f, 0.04910838f, 
    0.04170357f, -0.02283841f, -0.02743825f, -0.02886362f, -0.03499229f, 0.03907672f, 0.01925274f, 0.03215795f, 
    0.02337200f, -0.05501548f, 0.04073394f, -0.05389009f, 0.06344924f, -0.06904795f, 0.04229633f, 0.05673923f, 
    -0.05796678f, -0.06444700f, 0.04324263f, 0.00915314f, -0.05875648f, 0.03547974f, 0.04803845f, -0.05777117f, 
    -0.03808089f, -0.01001996f, 0.01966132f, -0.01644160f, -0.07614580f, 0.02211715f, -0.04138490f, -0.06397519f, 
    -0.06839532f, 0.01487788f, -0.05175099f, 0.03633310f, 0.03821203f, -0.00792602f, 0.04650891f, -0.06427018f, 
    0.01327346f, 0.01148847f, -0.01594301f, 0.02582562f, 0.01057588f, 0.04298972f, -0.02468481f, -0.07442746f, 
    0.03177090f, -0.06220230f, -0.04048461f, 0.01215947f, -0.06006419f, -0.06771649f, -0.05069202f, -0.04849272f, 
    0.03840473f, 0.04908738f, -0.07092791f, 0.00874187f, -0.03061493f, -0.02640977f, -0.00593749f, -0.02340853f, 
    -0.05789861f, -0.01538861f, 0.05100080f, -0.01515631f, -0.04492964f, -0.01952792f, -0.04991639f, -0.03862132f, 
    0.00051107f, -0.07511384f, -0.00278434f, -0.03304271f, 0.05823667f, -0.05303937f, -0.03061775f, 0.05214656f, 
    0.05855923f, -0.04019612f, -0.08026333f, -0.05573365f, -0.06108581f, 0.01121743f, 0.03065390f, -0.02656944f, 
    0.03063047f, -0.02886425f, 0.04860713f, 0.00801130f, 0.01474439f, -0.07531361f, -0.04229184f, 0.03527907f, 
    0.05355845f, -0.00714946f, 0.01086915f, -0.04963336f, 0.06697472f, -0.07546365f, 0.03549201f, 0.04205915f, 
    -0.07887615f, -0.07097627f, 0.00344136f, 0.02543611f, 0.03901571f, 0.03060566f, -0.01576008f, -0.03590323f, 
    -0.00321779f, 0.02672935f, -0.02795742f, -0.00375344f, -0.07001545f, -0.07563129f, 0.00700277f, 0.04130557f, 
    -0.03978841f, 0.00675892f, -0.00825452f, 0.05736279f, -0.05537963f, 0.03124621f, -0.07622361f, -0.08252734f, 
    0.02607619f, 0.04321798f, 0.05324129f, -0.06346935f, -0.02873291f, -0.04590015f, 0.04964465f, -0.00817255f, 
    -0.06650785f, -0.02040639f, -0.07804403f, 0.01267450f, -0.07504297f, 0.00907944f, 0.03320347f, 0.05859287f, 
    -0.02098158f, -0.01532267f, -0.06872289f, 0.05221721f, -0.01034452f, 0.04063740f, 0.05257810f, -0.07658581f, 
    -0.01224588f, 0.01804389f, -0.01354927f, 0.02587485f, -0.03567855f, -0.05372491f, 0.00891147f, 0.03911142f, 
    0.01970848f, -0.04107390f, -0.07509979f, -0.00491633f, -0.02020719f, -0.05078263f, 0.02785571f, -0.07466587f, 
    -0.16271324f, 0.25537321f, -0.05069404f, -0.04316544f, -0.07359815f, 0.05183862f, 0.07275597f, -0.06085328f, 
    0.07068313f, -0.16529948f, -0.01372452f, -0.04376382f, -0.02366814f, -0.03232639f, -0.11371327f, 0.12550148f, 
    -0.05039036f, 0.09751499f, -0.00501571f, -0.04687753f, -0.02505912f, 0.02183705f, -0.02428517f, 0.07880785f, 
    -0.09436110f, 0.14678450f, -0.05706286f, -0.01731581f, -0.04732070f, -0.03936107f, 0.01436505f, 0.02660163f, 
    -0.02684677f, -0.04313683f, 0.16137126f, 0.04071255f, -0.26066312f, -0.03132340f, -0.10870317f, -0.18117538f, 
    0.10908882f, -0.04849231f, -0.09211177f, 0.00586729f, -0.05768785f, 0.11289520f, -0.07122394f, -0.04314082f, 
    0.12169518f, 0.01904568f, 0.09317498f, 0.05248016f, 0.09469629f, -0.03047984f, 0.11668177f, -0.02694754f, 
    0.01109113f, 0.02035970f, 0.02280630f, 0.14203796f, -0.32434630f, -0.00462744f, -0.04452622f, -0.04906270f, 
    -0.03798556f, 0.10972793f, 0.02709351f, 0.03535905f, -0.03344282f, 0.03099816f, -0.02094169f, 0.15705043f, 
    -0.24993384f, -0.23485416f, 0.02592426f, 0.32284495f, 0.16732828f, 0.06644168f, -0.01410182f, -0.06608389f, 
    -0.08491947f, -0.00989793f, -0.13950036f, 0.11423878f, -0.17651489f, 0.11438016f, -0.04299800f, 0.11106323f, 
    0.12293632f, -0.16859928f, -0.03298512f, -0.06162684f, -0.01271230f, 0.01140640f, 0.02409485f, 0.07379559f, 
    0.07417984f, 0.01098378f, -0.02586525f, 0.15517610f, 0.09859302f, -0.03264932f, 0.02145035f, -0.01559529f, 
    0.05467104f, 0.08335448f, 0.01294544f, 0.00356479f, -0.23457569f, -0.02288701f, 0.08585346f, -0.06966341f, 
    -0.01974121f, 0.01855073f, 0.00372336f, 0.02427849f, -0.01587214f, 0.02463573f, 0.07752160f, 0.02249674f, 
    -0.04122344f, 0.10954748f, -0.09427729f, 0.11413076f, -0.03885095f, 0.03464929f, -0.00889078f, -0.03282463f, 
    -0.00950320f, 0.07574239f, 0.06938419f, -0.12319857f, 0.11758657f, 0.07544979f, 0.01821267f, -0.00428487f, 
    -0.08510770f, -0.08659715f, 0.05364636f, 0.06863688f, -0.00083283f, 0.01901547f, -0.01723870f, 0.00957815f, 
    -0.03294491f, 0.00932598f, -0.09718435f, 0.10228217f, 0.02595938f, 0.07649735f, 0.17744720f, -0.06555498f, 
    0.02081324f, -0.00858895f, 0.00027057f, -0.02482015f, 0.03036397f, 0.04728984f, 0.16348384f, 0.12732236f, 
    0.11350191f, -0.04919463f, -0.00490416f, 0.06315331f, -0.00943825f, 0.01863238f, -0.00995044f, 0.13310331f, 
    0.08894500f, -0.00546461f, 0.09604712f, 0.35678223f, -0.06676220f, -0.03416587f, 0.05481189f, 0.16211239f, 
    0.10795934f, 0.09455138f, 0.11258966f, -0.09456371f, 0.12334348f, 0.10342079f, -0.09658299f, 0.23958577f, 
    0.10876208f, 0.06753855f, 0.00947133f, 0.12908620f, 0.05971577f, 0.06440844f, -0.07377372f, 0.00034703f, 
    -0.12951709f, 0.21121822f, 0.04410001f, -0.10389408f, 0.19392528f, -0.01160414f, 0.06991953f, 0.04112746f, 
    0.07807758f, -0.02215621f, 0.05224412f, 0.06997123f, 0.30204302f, -0.10946204f, 0.10120156f, 0.29872176f, 
    0.11740061f, -0.04538348f, 0.00371370f, 0.02324916f, 0.01255227f, 0.09019409f, 0.09915773f, 0.09787560f, 
    0.19984277f, 0.01703847f, 0.26824260f, -0.04458113f, 0.17622679f, 0.12737305f, 0.00420653f, 0.04616076f, 
    0.07739766f, 0.06280618f, 0.04868837f, -0.08748322f, -0.29547411f, 0.21340057f, 0.19176276f, -0.32566476f, 
    0.11628954f, -0.07042746f, 0.11019717f, -0.03947236f, -0.03612252f, 0.07038381f, -0.08975149f, 0.05996060f, 
    0.07634351f, 0.00415271f, -0.07040238f, -0.10957072f, 0.01619337f, -0.05672588f, 0.01448183f, -0.10663603f, 
    0.02496884f, -0.00718243f, -0.09295723f, 0.12013321f, -0.03485692f, 0.36702091f, 0.17631517f, -0.18152523f, 
    0.05055450f, 0.08722274f, -0.01149306f, 0.00693333f, -0.09388385f, -0.00025510f, -0.00478463f, 0.03042345f, 
    -0.06807727f, 0.08863788f, 0.08164734f, 0.23494698f, 0.05221897f, 0.01916208f, 0.08200618f, -0.06775598f, 
    -0.00566124f, 0.08708310f, 0.03377014f, -0.01415346f, 0.01822203f, -0.22049887f, -0.08189819f, 0.09126688f, 
    0.01254307f, -0.08743074f, 0.11660749f, 0.01536738f, -0.03767096f, 0.05243572f, 0.07197078f, 0.14767855f, 
    -0.03092693f, -0.23183095f, -0.16129386f, 0.00457997f, 0.11454223f, -0.04570256f, -0.02042695f, -0.05390573f, 
    0.01207488f, 0.05385737f, 0.09082282f, -0.04726309f, 0.03347718f, 0.25785109f, 0.19860116f, -0.28751233f, 
    0.17690988f, 0.05658542f, 0.02485479f, -0.04692202f, 0.04357293f, -0.01256539f, -0.08969704f, -0.04261174f, 
    -0.10177427f, -0.12379837f, 0.00793354f, 0.15126877f, 0.10476758f, 0.19774523f, 0.01942254f, -0.08257414f, 
    0.04422845f, 0.02518828f, -0.01747982f, 0.01732267f, 0.10073675f, -0.12562163f, 0.02384159f, -0.00695587f, 
    -0.11100621f, 0.01618455f, -0.04827619f, 0.03778782f, -0.03626905f, 0.02433426f, 0.01907674f, 0.00272118f, 
    -0.15620166f, -0.11336319f, -0.14577343f, 0.15692542f, 0.05769201f, 0.02398214f, 0.04180957f, -0.04809136f, 
    0.09041502f, 0.07309263f, 0.00073958f, 0.02893235f, 0.23522609f, -0.05056966f, -0.31779590f, -0.07852863f, 
    0.02648220f, 0.05317187f, 0.00249171f, 0.02991669f, 0.02753113f, -0.00520884f, 0.10002434f, 0.12459614f, 
    -0.29684457f, -0.09601440f, 0.04556697f, 0.04698495f, -0.07801548f, 0.06742872f, -0.01530433f, -0.01547228f, 
    0.03883174f, -0.02085352f, 0.00557759f, 0.08903826f, -0.15466312f, -0.03598696f, -0.08441988f, 0.16392708f, 
    0.20500591f, -0.06787595f, 0.10550360f, 0.09928292f, -0.00817919f, 0.02663388f, 0.04174500f, -0.04152925f, 
    0.00221249f, 0.16762525f, 0.11877078f, -0.07543670f, 0.14128922f, 0.06973712f, -0.03345527f, -0.01316520f, 
    0.01721225f, 0.08693413f, 0.13365246f, 0.08324557f, 0.48550475f, -0.10477793f, 0.25564218f, -0.01191702f, 
    0.07907593f, -0.03728338f, -0.00399972f, 0.04072081f, 0.02660951f, 0.02541958f, 0.01167006f, -0.05911633f, 
    0.26167944f, 0.17045118f, -0.01017109f, 0.19482704f, 0.13186063f, 0.04173112f, -0.02530257f, -0.02436716f, 
    0.01283736f, 0.00805741f, -0.12851711f, -0.03459014f, 0.00574559f, 0.13433389f, 0.17589432f, 0.08817881f, 
    0.05078848f, -0.09225178f, 0.01595801f, -0.16463585f, 0.01101912f, -0.06891493f, 0.05746259f, 0.14290953f, 
    -0.24746355f, -0.04759026f, 0.04605195f, 0.07718841f, 0.03001536f, -0.05557236f, -0.04514926f, 0.01143138f, 
    -0.05793479f, 0.01861672f, -0.02275851f, -0.01152777f, 0.16141838f, 0.24974664f, 0.24169740f, 0.15362042f, 
    0.01739947f, -0.04260142f, 0.08392606f, 0.02594909f, -0.01740049f, 0.00370681f, 0.04007121f, 0.06927976f, 
    0.32665259f, 0.12688769f, 0.08412365f, 0.05987868f, -0.08732948f, -0.00074935f, 0.14228584f, 0.00128021f, 
    -0.07828952f, -0.07345332f, -0.02093844f, 0.04331742f, 0.01415353f, -0.24228880f, -0.01250638f, -0.10501461f, 
    -0.05341479f, 0.13261345f, 0.14370695f, 0.09422376f, -0.07526883f, -0.01395612f, 0.02341225f, 0.00616394f, 
    -0.07593944f, -0.01210691f, 0.10495232f, -0.24263708f, -0.04054713f, -0.09851248f, -0.05493940f, 0.06149177f, 
    -0.09906969f, -0.01506157f, 0.15066276f, -0.06837609f, 0.13335818f, 0.15821171f, 0.09205052f, -0.02390308f, 
    0.01989602f, -0.02257225f, 0.00140267f, 0.03801169f, 0.01781498f, 0.05007003f, -0.09304234f, -0.05898695f, 
    -0.12436666f, -0.21358025f, 0.17942809f, -0.01947400f, 0.21052198f, 0.14424691f, 0.04053874f, 0.11474194f, 
    -0.04026458f, 0.02215330f, -0.10819252f, -0.03046051f, -0.09865658f, 0.11151078f, -0.14669666f, 0.12519576f, 
    0.07622209f, 0.11457121f, -0.05447612f, 0.04522957f, -0.04253095f, 0.02964695f, 0.03503794f, -0.02252282f, 
    -0.12839952f, -0.19402754f, -0.09934258f, 0.04791598f, 0.07198977f, 0.06858341f, 0.05761124f, 0.02141728f, 
    -0.05687069f, -0.03070045f, 0.02971539f, -0.00795786f, -0.03170800f, -0.20585543f, -0.18236598f, -0.03993340f, 
    -0.01223606f, 0.02003403f, -0.01033956f, -0.10391285f, -0.14148615f, 0.05696449f, 0.02839952f, 0.01626751f, 
    -0.34553564f, -0.16921237f, 0.04821150f, -0.20495400f, 0.01244666f, 0.05900008f, -0.01939600f, 0.01012609f, 
    0.00559477f, -0.10066203f, -0.01767310f, 0.01962318f, 0.03017653f, -0.02501373f, 0.08925395f, 0.01785356f, 
    0.06723885f, -0.02738099f, 0.16119336f, 0.10363598f, -0.11137647f, -0.08949336f, -0.00444030f, 0.02625390f, 
    0.11676497f, 0.01041720f, -0.06432508f, -0.14624380f, 0.18998483f, -0.10939430f, 0.11213513f, -0.11271532f, 
    0.09074222f, 0.08194300f, 0.23755555f, 0.11445288f, -0.18840450f, 0.12536271f, -0.10767523f, 0.18911326f, 
    -0.08178560f, 0.11178185f, 0.21084899f, 0.02303159f, 0.01478192f, 0.06709310f, 0.06725367f, 0.01794126f, 
    -0.20973195f, -0.16808361f, 0.15193641f, -0.08115865f, 0.08984289f, 0.03049993f, 0.03819523f, -0.00943206f, 
    -0.12966654f, 0.03807820f, 0.09154314f, 0.10494642f, -0.17719498f, 0.00997822f, -0.03254480f, -0.04035703f, 
    0.12663586f, 0.05172024f, 0.10375127f, -0.04478743f, 0.04874736f, -0.05452670f, -0.05783084f, 0.00578529f, 
    0.15271857f, 0.22233079f, -0.05661536f, -0.18605098f, 0.05333837f, 0.00694170f, 0.02356710f, -0.07992115f, 
    0.03794612f, 0.05108607f, 0.01332083f, -0.00396147f, -0.12886785f, -0.01623228f, -0.07101993f, -0.09836466f, 
    0.06468266f, 0.02811750f, -0.09130643f, 0.00711240f, 0.07123597f, -0.03070419f, 0.08357552f, 0.08000924f, 
    0.06757363f, 0.04942465f, 0.06268368f, 0.20448035f, 0.03840078f, -0.02620014f, -0.05900779f, -0.02648232f, 
    0.08048450f, 0.04360161f, 0.02851684f, 0.00276033f, 0.05733592f, 0.14561950f, -0.06336370f, 0.17126667f, 
    0.02696283f, 0.03126127f, 0.09147402f, 0.02153557f, -0.12328479f, -0.01657836f, 0.06869680f, 0.11241163f, 
    0.26425737f, -0.29256055f, -0.13914870f, 0.42370993f, 0.13534704f, 0.05756970f, 0.12427591f, -0.12259690f, 
    -0.08745161f, 0.07051463f, -0.04305683f, 0.06087019f, -0.04167396f, -0.02753481f, 0.06227660f, -0.09787589f, 
    0.08814921f, 0.05368011f, -0.03318854f, -0.10424448f, 0.13146432f, 0.02438010f, 0.09371905f, 0.01562558f, 
    0.12974317f, -0.07726657f, -0.13388060f, 0.27188718f, -0.16048428f, 0.01195684f, -0.00910538f, -0.09998933f, 
    -0.11205944f, -0.07883930f, -0.06481926f, -0.09297241f, 0.02718683f, 0.03607127f, 0.17832582f, -0.12383883f, 
    -0.03100994f, -0.06994409f, 0.08190673f, 0.09221516f, 0.09059390f, -0.11777509f, 0.11992450f, 0.04006608f, 
    -0.12959693f, 0.09706618f, -0.07468008f, 0.18635470f, -0.10606538f, -0.14704564f, 0.04221693f, -0.03654877f, 
    -0.06895263f, -0.00566215f, -0.07624312f, -0.07294578f, 0.11711688f, 0.19413382f, -0.10006637f, 0.14788380f, 
    -0.07301737f, -0.04551654f, 0.04871908f, 0.04188756f, -0.03739250f, 0.03701753f, 0.05168764f, 0.05389756f, 
    0.10377543f, -0.07581778f, 0.06373589f, 0.09387338f, -0.11748061f, 0.19290023f, -0.11985631f, 0.00371497f, 
    0.02506846f, 0.08215255f, 0.04054533f, 0.12448083f, -0.11168130f, -0.01864047f, -0.13261832f, -0.00943723f, 
    0.05257950f, -0.09593841f, 0.02182137f, -0.07121699f, 0.04846737f, 0.02987370f, -0.06502376f, 0.00127490f, 
    0.12064935f, -0.34018141f, 0.17553401f, 0.03050798f, -0.12743190f, 0.19854413f, 0.05299666f, 0.03927514f, 
    0.02474165f, -0.01702955f, 0.02835663f, 0.11346202f, -0.15029182f, 0.07796678f, 0.05616457f, -0.05596518f, 
    -0.10668680f, 0.12478084f, -0.02182769f, 0.12958828f, -0.01126926f, 0.03409133f, 0.04228502f, 0.01779370f, 
    -0.04245886f, -0.13985793f, -0.23183805f, 0.07838928f, 0.01166997f, -0.03257369f, -0.05014696f, -0.06794398f, 
    -0.02353662f, -0.00139064f, 0.02915790f, 0.06306515f, 0.11849868f, -0.26957533f, -0.02145820f, 0.17690755f, 
    0.00567125f, -0.02872143f, -0.00316643f, 0.02525873f, 0.06686728f, -0.16049752f, 0.04739189f, 0.07069716f, 
    0.12785503f, -0.00521528f, -0.03313792f, 0.16137336f, 0.11199497f, -0.01948824f, 0.12260621f, 0.15987945f, 
    0.04909549f, 0.11273768f, -0.02255885f, -0.05591225f, 0.05176032f, -0.16474082f, 0.08764825f, 0.29111183f, 
    -0.04865820f, -0.13860744f, -0.11581104f, 0.03110688f, 0.27247009f, 0.02281373f, -0.03467316f, 0.03406914f, 
    0.21160807f, -0.01697326f, 0.09378631f, -0.02017058f, -0.03933506f, 0.04819319f, 0.03057336f, -0.03483414f, 
    0.07917004f, 0.06459295f, -0.03744436f, 0.12266725f, -0.12386521f, 0.09096862f, -0.05039581f, -0.17595963f, 
    -0.00074018f, 0.02850142f, -0.10456847f, 0.22225453f, -0.05425891f, 0.10572387f, -0.06203694f, -0.04707608f, 
    -0.04288059f, 0.06289707f, 0.07504445f, 0.02034831f, -0.04205646f, 0.03627177f, 0.09258159f, 0.05113553f, 
    -0.01351061f, -0.01208952f, 0.01282822f, -0.00381649f, 0.13722500f, -0.03480471f, 0.02844402f, -0.10722089f, 
    -0.10369414f, 0.06177826f, -0.00514941f, 0.07938877f, -0.01893930f, 0.06338931f, 0.17366935f, 0.04790217f, 
    0.16402286f, -0.13289769f, -0.05192126f, 0.00060053f, -0.07988533f, -0.13489385f, 0.07400116f, -0.05786573f, 
    0.05729410f, -0.03978881f, -0.06919061f, -0.05827776f, 0.19917552f, -0.10335308f, -0.27989900f, 0.04674799f, 
    0.03493492f, -0.00050139f, 0.10908188f, -0.04850319f, -0.02354323f, 0.03134475f, 0.00263927f, 0.13662399f, 
    0.11342558f, -0.10378039f, -0.05114393f, -0.14448814f, 0.10718066f, -0.02507931f, 0.05278167f, -0.02820885f, 
    -0.04989563f, 0.05156771f, 0.09487674f, -0.07446853f, -0.38165438f, 0.36596784f, 0.09131553f, -0.14154439f, 
    -0.10129971f, 0.10792740f, 0.03691037f, 0.06540602f, 0.03800559f, -0.10899066f, 0.14051932f, -0.06398597f, 
    0.33500051f, -0.17620391f, -0.08715358f, 0.00095850f, 0.05928915f, 0.02438555f, 0.09292389f, 0.02416495f, 
    0.20081040f, 0.06566957f, -0.03344106f, 0.04105624f, 0.19660302f, -0.15033376f, 0.11311974f, -0.19937998f, 
    0.04071728f, 0.05986995f, 0.03037689f, -0.14048983f, -0.09618913f, 0.08311930f, 0.09815256f, 0.07210608f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04437230f, 0.03735187f, 0.07896791f, 0.07371868f, 0.09422708f, -0.06522962f, 0.02226044f, -0.01238067f, 
    -0.05311904f, 0.00198418f, -0.01370010f, 0.09444658f, 0.05475651f, -0.00465093f, 0.04079062f, 0.00027086f, 
    -0.02275474f, -0.07325429f, 0.03054945f, 0.06966975f, 0.04985269f, 0.02724117f, -0.02674798f, -0.04066373f, 
    -0.09227040f, 0.08718141f, -0.05875739f, 0.01776796f, -0.12810530f, -0.05138118f, 0.06534503f, 0.12209567f, 
    0.04213446f, -0.01742664f, -0.09659008f, -0.08022690f, -0.03763351f, 0.03077576f, -0.04697051f, 0.03775387f, 
    -0.00284891f, -0.04567240f, 0.06353047f, 0.13453719f, 0.03849713f, 0.04662719f, -0.00831680f, 0.01352979f, 
    -0.02029729f, -0.04308473f, -0.06404745f, -0.02753619f, -0.00009238f, -0.08909505f, 0.09707492f, 0.01942766f, 
    -0.03098543f, 0.03777197f, -0.01650855f, 0.10653418f, 0.09843099f, 0.06261453f, 0.14175311f, 0.01992545f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00399433f, 0.19676417f, -0.01899277f, -0.20137642f, 0.25566965f, 0.20475015f, -0.10933369f, 0.03152507f, 
    0.16173944f, 0.10021264f, -0.27353802f, -0.17382725f, 0.08377657f, 0.00336381f, 0.11981069f, 0.05989181f, 
    0.08070093f, -0.08121584f, 0.30001372f, -0.07768646f, 0.01792214f, 0.18335724f, -0.02534526f, 0.02732512f, 
    -0.10169929f, -0.26012447f, -0.12533756f, 0.01461449f, 0.25974599f, 0.07581399f, 0.08093418f, -0.06144420f, 
    0.16002645f, 0.05466852f, 0.05849101f, 0.01570648f, 0.12313142f, 0.26535055f, -0.10313530f, 0.10335736f, 
    0.12151553f, -0.02776608f, -0.12662238f, -0.03527754f, -0.14267686f, 0.13663822f, 0.21711390f, 0.03880831f, 
    -0.02334793f, -0.06576046f, 0.26165053f, 0.07527037f, -0.13461134f, 0.36197394f, -0.30158660f, 0.01533413f, 
    0.28811631f, 0.13439582f, 0.08834234f, 0.11184596f, -0.22069827f, -0.16694200f, -0.00764031f, 0.09548235f, 
    -0.14473981f, -0.12676698f, 0.02139715f, -0.09034601f, -0.08940104f, -0.12524797f, -0.01190885f, -0.11548174f, 
    0.04721943f, -0.05762541f, 0.07892010f, 0.02094119f, -0.12684676f, -0.01535808f, 0.02838279f, 0.10039704f, 
    -0.10759112f, -0.06526396f, 0.00792506f, -0.09444746f, 0.00440051f, -0.13111189f, 0.06470920f, 0.01848079f, 
    -0.03095412f, -0.11380144f, -0.05785862f, -0.09634370f, -0.03740547f, -0.13687669f, -0.00974682f, 0.02126453f, 
    -0.11648995f, 0.05153295f, -0.09181205f, 0.06050010f, -0.00954759f, -0.01731874f, -0.00184379f, -0.02121668f, 
    -0.03352683f, 0.06435481f, -0.10847232f, -0.05392863f, 0.06707572f, -0.09105526f, 0.00826542f, -0.05401908f, 
    -0.02478101f, 0.09369881f, -0.11799065f, -0.07341995f, -0.00725062f, 0.05999072f, -0.02847854f, 0.04711566f, 
    -0.01741778f, -0.08454354f, 0.11938978f, -0.03792774f, -0.00658122f, -0.04007899f, -0.16134119f, -0.14785150f, 
    -0.19778419f, 0.12776907f, -0.21333791f, 0.02518374f, -0.13714693f, 0.19236813f, 0.03689187f, -0.03064057f, 
    -0.09235432f, 0.05974498f, -0.12282673f, 0.00949042f, 0.03278714f, 0.08610522f, -0.22093265f, 0.07060488f, 
    0.38670155f, 0.05350084f, -0.14175023f, -0.34980065f, -0.10204297f, 0.06539910f, -0.09531744f, -0.24602491f, 
    0.03109917f, 0.00022439f, 0.08075231f, 0.19128369f, -0.06668799f, -0.13407037f, 0.18037482f, 0.06129454f, 
    -0.06874705f, -0.07994155f, 0.05088977f, -0.04077195f, -0.05279065f, -0.01815586f, 0.12479606f, -0.01099767f, 
    -0.08935563f, 0.00952843f, 0.09438030f, 0.23573211f, -0.02466018f, -0.41217083f, 0.19344234f, 0.17223348f, 
    -0.00444934f, -0.13413395f, -0.11661508f, 0.04780471f, 0.23575000f, -0.13139266f, -0.09940004f, 0.16607003f, 
    -0.17323026f, 0.22710764f, -0.09748206f, 0.02667517f, 0.02201678f, -0.03679635f, 0.18322809f, 0.28206289f, 
    0.16168131f, -0.10377458f, 0.34952343f, 0.38043118f, -0.19708851f, 0.05903252f, -0.15628389f, 0.06751540f, 
    -0.04589518f, -0.11007294f, 0.45340863f, 0.19065870f, 0.00030155f, 0.08751439f, 0.49450910f, 0.02587763f, 
    -0.04896789f, -0.11411575f, -0.03372946f, 0.09084844f, 0.09640267f, -0.01272460f, 0.12160770f, 0.21879648f, 
    -0.08174209f, 0.28397530f, -0.03858491f, -0.18783438f, -0.37946662f, 0.09154852f, -0.18714750f, 0.07415234f, 
    0.15424089f, 0.02092867f, 0.01535511f, -0.14672871f, 0.09490965f, 0.17425957f, -0.23555291f, -0.01961279f, 
    0.24096394f, 0.08302949f, 0.03817501f, -0.05452402f, 0.19192415f, -0.39069134f, -0.23801857f, -0.08962053f, 
    0.02298457f, 0.04558963f, 0.30188128f, -0.08496585f, -0.08518913f, 0.02312673f, 0.16995622f, -0.06429641f, 
    -0.22201826f, 0.27045551f, -0.10900120f, 0.12237242f, 0.14269817f, 0.21934098f, -0.10786795f, 0.03035260f, 
    -0.18440688f, 0.00383016f, 0.05683060f, 0.29002935f, -0.05963286f, 0.23244974f, 0.11706156f, -0.04502331f, 
    0.06280398f, 0.00685212f, -0.17315257f, -0.20608543f, -0.03936123f, 0.13303895f, -0.08958731f, -0.05093356f, 
    0.29506323f, -0.02078182f, -0.00336546f, 0.22485575f, -0.00230247f, 0.13883826f, -0.00365764f, 0.02036269f, 
    0.06954200f, 0.13790548f, -0.08002754f, -0.02408163f, -0.10796118f, -0.33035478f, 0.05162371f, 0.13254628f, 
    0.18051694f, 0.06304283f, 0.03929486f, 0.02082078f, 0.13613640f, -0.19893508f, 0.20913409f, 0.03771655f, 
    -0.31631023f, -0.07118350f, 0.18788855f, -0.11999836f, -0.18793051f, -0.17249253f, 0.19044988f, 0.09037491f, 
    -0.04401676f, -0.06930902f, 0.18856953f, -0.10251170f, 0.05142223f, -0.04629743f, -0.00097682f, 0.06619856f, 
    0.07342534f, 0.00467442f, 0.07552049f, 0.04211989f, 0.38005343f, 0.08692989f, 0.06709028f, -0.28641912f, 
    -0.14949839f, 0.09740811f, -0.31661096f, -0.07741822f, 0.17726946f, 0.03544184f, 0.11899353f, -0.00494111f, 
    0.40231839f, 0.09470338f, -0.26039368f, 0.15361866f, 0.11420928f, -0.07573681f, -0.23157880f, -0.12897766f, 
    0.23817892f, -0.09509543f, 0.06225519f, -0.24423084f, -0.05630885f, 0.16007398f, 0.06387146f, -0.16765364f, 
    -0.05745589f, -0.24400747f, 0.05181520f, 0.14029235f, 0.36129415f, 0.19739957f, 0.30972895f, 0.12930039f, 
    -0.03536014f, -0.03479108f, 0.28800929f, 0.21440803f, -0.18410291f, -0.17898409f, 0.16132073f, -0.10822163f, 
    0.01927183f, -0.05672302f, 0.09599706f, -0.03714243f, -0.17065497f, 0.37680650f, -0.04603344f, 0.10118783f, 
    0.02690838f, 0.07663256f, -0.19035067f, -0.10089485f, 0.38049495f, -0.19087692f, -0.00096185f, -0.16231082f, 
    0.20704962f, -0.10088938f, -0.01775512f, 0.07443529f, 0.02233594f, -0.07357476f, -0.02367883f, 0.11614964f, 
    0.00374351f, 0.02195672f, -0.12993246f, 0.14209095f, 0.05409023f, -0.09593537f, 0.05467097f, 0.07677139f, 
    0.34533912f, -0.07039422f, 0.40095636f, 0.08582669f, -0.03406779f, -0.12459074f, -0.19164875f, -0.03539474f, 
    0.10998058f, -0.03751202f, -0.21548957f, -0.40375629f, -0.37490156f, 0.13478048f, -0.05052219f, -0.02733085f, 
    -0.02589420f, -0.16857108f, -0.06324810f, -0.29200101f, 0.06019592f, 0.22190928f, -0.19596480f, 0.11713054f, 
    -0.07708678f, -0.08078018f, 0.11834698f, -0.24025108f, -0.38740605f, 0.20934503f, -0.36552483f, 0.11912984f, 
    0.10201664f, 0.07701389f, 0.10892282f, -0.14830892f, 0.18739288f, -0.06210503f, -0.19590710f, 0.13989738f, 
    0.08713526f, -0.03234409f, 0.28203058f, -0.04569003f, 0.22692704f, 0.23039548f, -0.09214306f, -0.14030012f, 
    -0.34001380f, 0.06499936f, -0.03905843f, -0.14215796f, -0.10153947f, 0.08411096f, -0.19624740f, 0.33600298f, 
    0.07383228f, -0.13909076f, -0.08887192f, 0.06579063f, -0.02230108f, -0.09186378f, -0.06171187f, -0.00952739f, 
    0.10576363f, -0.05736023f, -0.14961860f, -0.11008744f, 0.01204679f, -0.01885796f, -0.04256261f, 0.09879181f, 
    0.01323810f, 0.03792858f, -0.14069419f, -0.03881738f, 0.10691065f, -0.08024187f, 0.05397755f, -0.08350380f, 
    0.01238338f, 0.01027868f, -0.10936546f, -0.09440392f, 0.05250189f, 0.04939982f, 0.10067427f, -0.11377440f, 
    -0.03904773f, -0.04249087f, -0.12927285f, -0.02001508f, -0.01881911f, -0.04955881f, -0.09908857f, 0.12730959f, 
    -0.01069342f, -0.04524677f, 0.07494426f, -0.09239072f, -0.15139498f, -0.04154383f, -0.07363378f, -0.05490664f, 
    0.07203767f, 0.04908695f, 0.05939879f, -0.03933748f, -0.02195298f, 0.06754629f, -0.07689174f, -0.03167157f, 
    0.01220675f, 0.07986400f, 0.01008042f, 0.07447230f, 0.07282821f, -0.09583203f, 0.05859900f, -0.09045504f, 
    -0.03766410f, 0.22156964f, -0.21974148f, -0.02303749f, 0.26750761f, -0.09144303f, 0.12180104f, 0.00176603f, 
    0.06020378f, 0.08752201f, -0.09784825f, 0.07218038f, -0.04128487f, 0.02823487f, 0.04352600f, -0.03677026f, 
    0.04223517f, 0.05365453f, 0.17078471f, -0.01274096f, 0.21981497f, 0.28723747f, 0.09873980f, 0.11656955f, 
    0.11015882f, -0.10611077f, -0.01268958f, 0.00308189f, -0.27883142f, -0.11437543f, 0.34010121f, 0.20338145f, 
    -0.13808461f, 0.04733523f, -0.27185056f, -0.29177806f, -0.17923450f, 0.30985582f, 0.08643746f, 0.06473467f, 
    0.02664991f, -0.06581937f, -0.27726117f, 0.02512536f, -0.33127129f, 0.00346901f, 0.00513574f, 0.28209701f, 
    0.10392529f, -0.03572694f, -0.01213656f, 0.02309547f, 0.06236080f, 0.07613720f, 0.12161950f, -0.00205803f, 
    0.16131578f, -0.03040761f, -0.02008020f, 0.02488231f, 0.17694432f, -0.02584510f, 0.24635349f, 0.02124402f, 
    -0.12899749f, -0.13815230f, 0.17649205f, 0.18819600f, 0.25228152f, 0.19596371f, -0.00915664f, -0.09938878f, 
    0.14048162f, -0.05941701f, -0.01287392f, -0.33564618f, -0.06252867f, 0.06582945f, 0.36137450f, -0.08787674f, 
    0.12066372f, -0.05561201f, 0.08097643f, 0.27353370f, 0.21633086f, 0.11614108f, 0.06717696f, -0.10485081f, 
    -0.09339468f, 0.06148432f, -0.10454533f, -0.08682718f, 0.01005561f, -0.16318062f, -0.30483595f, 0.07459730f, 
    0.24285036f, -0.11415237f, -0.22364995f, -0.03255828f, 0.16706179f, -0.16758884f, 0.20077451f, -0.09274780f, 
    -0.27241391f, -0.02285160f, 0.15186311f, -0.14099015f, -0.11692432f, -0.00652160f, 0.08091428f, -0.04042098f, 
    -0.06865469f, -0.10014905f, 0.11226453f, 0.11113410f, -0.18239775f, -0.12572783f, 0.12355244f, 0.13348022f, 
    0.30487311f, 0.16244695f, 0.00987651f, 0.10810381f, 0.06952902f, 0.01111948f, 0.12503874f, -0.18031242f, 
    0.21777716f, -0.11201029f, -0.03502985f, 0.11019245f, 0.00215706f, -0.02185417f, 0.14404440f, 0.00305875f, 
    0.32727990f, 0.08209277f, 0.04844007f, 0.16688727f, 0.05781722f, 0.06692593f, -0.07407019f, 0.09788919f, 
    -0.08236145f, -0.04843505f, 0.13658293f, -0.20499617f, -0.05644565f, 0.10701835f, 0.12490763f, -0.17114359f, 
    0.02079534f, 0.04750861f, -0.08973683f, 0.05434778f, 0.25676456f, 0.36167958f, -0.05804591f, -0.07923026f, 
    0.10243287f, -0.08077309f, 0.29287139f, 0.07570478f, -0.00662579f, -0.23758025f, -0.18658434f, 0.00273523f, 
    0.25816447f, -0.06453088f, 0.31692973f, 0.20086756f, 0.01412099f, 0.20149250f, -0.21745324f, 0.08318646f, 
    0.07037465f, 0.02750863f, -0.12018004f, -0.01425562f, 0.23351218f, -0.07162582f, -0.03305643f, -0.27404872f, 
    -0.09241390f, 0.15981485f, 0.09399872f, -0.05690212f, -0.20258324f, 0.07481103f, -0.10424049f, 0.35288364f, 
    -0.02065490f, -0.07991543f, 0.02073151f, -0.06545416f, 0.26771575f, 0.00407710f, -0.13717027f, -0.00321323f, 
    -0.17029653f, 0.00836621f, 0.37478378f, 0.18947218f, 0.05106511f, -0.03703482f, 0.32820955f, -0.05907335f, 
    -0.33549482f, 0.04279828f, 0.18113217f, 0.31635937f, 0.16955934f, -0.11783551f, 0.07299259f, 0.25136265f, 
    -0.01835591f, 0.62883908f, -0.07223468f, 0.11234301f, -0.05242448f, 0.08510204f, 0.10534283f, 0.07315335f, 
    0.03035009f, 0.13350227f, 0.09707841f, 0.24313228f, 0.16100897f, -0.00768400f, -0.06622881f, 0.07497527f, 
    -0.07505703f, -0.09186199f, -0.02755604f, 0.19460045f, -0.13665242f, 0.11317901f, 0.01540715f, -0.19577456f, 
    -0.08449551f, -0.05855557f, -0.10304788f, 0.09098909f, -0.16351585f, 0.01372179f, 0.18337445f, -0.34501156f, 
    -0.01263954f, 0.08511881f, -0.07884818f, 0.08230434f, -0.00322534f, -0.00983504f, 0.14629026f, -0.03999449f, 
    -0.14954585f, 0.01091847f, -0.14905445f, -0.04117490f, 0.12297332f, 0.19223368f, -0.17526698f, 0.03432476f, 
    0.11239199f, 0.01476940f, 0.07237362f, 0.05857946f, -0.00460911f, 0.05188587f, 0.30380493f, -0.07765803f, 
    -0.27368724f, 0.11079182f, 0.24379802f, 0.24662155f, 0.05861394f, -0.10406243f, 0.10651090f, 0.19521412f, 
    0.09307984f, -0.10788855f, -0.03367888f, -0.06003708f, 0.25289461f, 0.09605948f, -0.24582902f, 0.01514260f, 
    0.14268884f, 0.01591761f, 0.18367237f, 0.12909772f, -0.09359677f, -0.06525251f, 0.11461686f, -0.06355453f, 
    0.08254202f, -0.02159449f, -0.07448982f, -0.11737411f, 0.08876024f, 0.41728160f, 0.18709899f, 0.07114720f, 
    0.05414838f, 0.06390852f, 0.27551591f, -0.00779919f, -0.07665949f, 0.21342826f, -0.34283268f, 0.07722946f, 
    0.22870125f, 0.03813014f, -0.08779059f, -0.07019985f, -0.13120298f, 0.12023310f, -0.12376329f, -0.08776475f, 
    -0.05446322f, 0.19213359f, -0.06668504f, 0.11638516f, -0.00052329f, -0.00564782f, 0.06213763f, 0.07501984f, 
    0.25845540f, 0.11414833f, -0.16456433f, -0.15797615f, 0.05838038f, -0.03945842f, 0.12189808f, 0.09499221f, 
    0.21191548f, 0.10932374f, 0.03669309f, -0.25118175f, -0.17004260f, 0.09975901f, 0.01702155f, -0.08029075f, 
    -0.02763887f, -0.24693152f, 0.06568772f, 0.07242318f, 0.12114606f, -0.16847247f, -0.15694720f, 0.10769699f, 
    0.10440084f, 0.08621258f, -0.16403742f, -0.04881877f, -0.11568005f, -0.21322452f, 0.13305083f, -0.08802806f, 
    0.04027992f, 0.01600720f, 0.14401489f, -0.07102810f, 0.07873794f, 0.10397647f, -0.00014159f, 0.29170269f, 
    0.01203320f, 0.04833174f, 0.06907967f, 0.02678261f, 0.19841687f, -0.16318834f, -0.14621991f, 0.40473667f, 
    0.06163142f, 0.21248941f, 0.01287653f, -0.19643554f, 0.13763890f, 0.17060536f, 0.06583793f, 0.03220872f, 
    -0.00436596f, -0.04666094f, 0.07630908f, -0.03135779f, 0.10609925f, 0.15419331f, -0.23940298f, -0.07110576f, 
    0.02680435f, -0.04198905f, -0.00885526f, -0.06148038f, 0.09100605f, -0.08300762f, 0.40837330f, -0.05737984f, 
    -0.16888952f, 0.08186840f, 0.05377790f, 0.14450094f, 0.13699877f, -0.18765412f, -0.01335193f, 0.10545739f, 
    0.11769316f, 0.32551825f, 0.02394422f, 0.19994357f, -0.00596754f, -0.04672613f, -0.11777834f, 0.03056855f, 
    0.07019147f, 0.03599162f, 0.25791743f, 0.23295598f, 0.31049344f, -0.00611009f, 0.18778186f, -0.04210015f, 
    0.07284454f, -0.12180555f, 0.12366685f, 0.08293662f, 0.14724237f, 0.05078951f, -0.06207216f, -0.19634140f, 
    0.06434704f, 0.00469975f, -0.26522923f, 0.01911714f, 0.20751797f, -0.31415856f, 0.00511284f, 0.06558037f, 
    0.05091322f, 0.05443298f, 0.05231480f, 0.08319620f, -0.03036018f, 0.01775552f, 0.05388824f, 0.11792752f, 
    0.00015114f, 0.13318764f, -0.17539991f, -0.02934182f, -0.07798263f, 0.23588982f, -0.08160409f, 0.01032222f, 
    -0.16663235f, -0.07897540f, 0.07062631f, -0.21532027f, -0.01251754f, -0.12028476f, 0.05552695f, -0.02652360f, 
    0.08932905f, -0.02658587f, -0.10636011f, 0.25359350f, 0.02325753f, -0.16850853f, 0.12465329f, 0.19214533f, 
    0.00173445f, 0.19405065f, 0.04969539f, 0.23792276f, 0.10182717f, -0.33139256f, -0.04422469f, 0.03313967f, 
    -0.01400618f, -0.00875927f, 0.00908247f, -0.02389072f, 0.07150893f, -0.08409677f, 0.11709069f, -0.02937431f, 
    -0.22262439f, -0.08376586f, -0.20056230f, -0.03172325f, -0.13323863f, 0.02162891f, 0.09125622f, -0.06653004f, 
    0.10618364f, 0.01066013f, -0.06668334f, 0.05422008f, 0.03576567f, -0.01423422f, -0.04756267f, 0.39324877f, 
    0.03563203f, 0.00770635f, 0.01428759f, 0.12995595f, 0.30457515f, 0.16141458f, 0.20015760f, -0.04501754f, 
    0.17403625f, 0.23512599f, -0.04468567f, 0.07137503f, -0.01133262f, 0.05809155f, -0.13862085f, 0.01548693f, 
    -0.05422390f, -0.09950573f, 0.46872115f, 0.26546529f, -0.10439645f, -0.10091668f, 0.02830888f, 0.02943246f, 
    -0.21496964f, -0.01024871f, -0.08060339f, 0.16909884f, -0.16557904f, -0.25815135f, 0.11500697f, 0.20416158f, 
    0.05689072f, -0.11708927f, -0.03231665f, -0.09533463f, -0.03367518f, 0.11787707f, 0.08010283f, 0.16172680f, 
    -0.09962998f, -0.04704625f, 0.26551840f, 0.13846771f, 0.00313548f, -0.06717687f, -0.06727099f, 0.13236974f, 
    0.32772306f, 0.05273173f, -0.07342356f, 0.12122303f, 0.00904220f, 0.07559977f, -0.17897852f, -0.12016555f, 
    0.03103087f, 0.07644001f, -0.04148518f, 0.01316468f, 0.26158321f, -0.10992065f, -0.03742653f, -0.06080331f, 
    -0.09454887f, 0.05349408f, 0.01026919f, -0.15974605f, -0.06490634f, 0.14354430f, 0.00630054f, 0.11603750f, 
    -0.09100500f, -0.04666825f, 0.09651402f, -0.05917688f, 0.02359225f, 0.05351834f, -0.08773915f, 0.10157869f, 
    -0.04636901f, 0.04981188f, 0.09073849f, -0.13962644f, -0.08301596f, 0.03421095f, 0.04420184f, 0.06988423f, 
    -0.02794884f, 0.04853344f, -0.07968459f, -0.14013419f, -0.08978678f, -0.04285188f, -0.04822975f, 0.01668731f, 
    -0.12728739f, -0.02276733f, 0.09280127f, -0.04316122f, -0.05992657f, -0.06966811f, 0.01633121f, -0.10814211f, 
    0.05239566f, 0.07343569f, 0.11345986f, -0.03831164f, -0.09741085f, -0.05690223f, 0.06411634f, -0.08753050f, 
    0.10287617f, 0.10258715f, -0.15859886f, 0.01637023f, 0.08387364f, -0.02379403f, -0.02571827f, 0.10751154f, 
    -0.06737465f, -0.07806048f, 0.01681588f, -0.00651481f, -0.06897153f, -0.11890414f, -0.07093795f, 0.11422104f, 
    -0.02027280f, -0.07337105f, 0.06999867f, 0.09792440f, -0.02488660f, -0.02725346f, 0.05401385f, -0.13326503f, 
    -0.07437859f, 0.11274411f, -0.01435905f, -0.19270551f, 0.24689434f, 0.07027829f, -0.26488742f, 0.01025726f, 
    -0.06172981f, -0.07261226f, -0.18447419f, -0.21242392f, -0.07657465f, 0.01026744f, 0.14762312f, 0.00152975f, 
    0.01065656f, 0.01037737f, 0.06544486f, 0.38583201f, 0.18687223f, -0.13794306f, 0.03504722f, -0.13242532f, 
    0.00590028f, 0.41141534f, 0.10514638f, 0.28896707f, -0.04307032f, -0.00451861f, 0.25166735f, -0.08224472f, 
    -0.00085592f, 0.13413529f, -0.03955047f, 0.06521887f, 0.20243444f, -0.34418315f, 0.15646900f, -0.01916711f, 
    -0.20884782f, 0.08916990f, 0.00622800f, 0.10944969f, -0.00925210f, 0.14799544f, 0.08958533f, -0.37927520f, 
    0.04306815f, -0.08273381f, -0.33566469f, -0.11187983f, 0.13483249f, -0.31244609f, 0.14049539f, -0.17185549f, 
    0.05279271f, -0.06768497f, -0.04179680f, 0.21913090f, -0.00284462f, -0.17068283f, -0.07836770f, -0.00190973f, 
    -0.10008503f, 0.30256134f, -0.05704594f, -0.03387284f, 0.07594087f, 0.05932786f, 0.06570550f, -0.04204381f, 
    -0.02714696f, -0.08738479f, -0.02987960f, 0.17538537f, 0.06149763f, -0.00765148f, 0.08338290f, 0.07981589f, 
    -0.02891164f, 0.11551813f, 0.06407490f, 0.22240479f, -0.01638266f, 0.00321785f, -0.04359720f, 0.03599525f, 
    0.11479684f, -0.47030497f, 0.01562728f, -0.01411903f, 0.12095302f, 0.23946267f, 0.09842573f, -0.09344856f, 
    0.09551885f, -0.03938706f, 0.15601915f, 0.41577509f, 0.02500266f, 0.30147576f, -0.05096407f, 0.08628538f, 
    0.22497387f, 0.01358128f, -0.27428311f, -0.04744735f, 0.03344381f, 0.32346427f, -0.06734110f, -0.12123794f, 
    0.09127042f, -0.11883351f, 0.10056452f, 0.04418559f, 0.03942453f, 0.20141616f, -0.13428298f, 0.12710604f, 
    0.10054310f, -0.11970188f, 0.11416725f, -0.04671250f, -0.11414585f, -0.14123818f, 0.14396808f, -0.06677048f, 
    0.18523674f, 0.17787661f, 0.00631741f, 0.32584482f, 0.04450604f, -0.00593446f, 0.01073898f, -0.11959207f, 
    0.30062625f, -0.09597179f, -0.06646058f, -0.08049697f, 0.01666102f, -0.00852552f, 0.14333946f, 0.00585739f, 
    0.09996078f, 0.07411390f, -0.15008894f, 0.01908282f, -0.01910291f, -0.04883659f, -0.02770753f, 0.13520877f, 
    -0.03379867f, -0.22587375f, -0.02219591f, -0.07354008f, 0.07323804f, -0.04865025f, -0.25739944f, 0.10752239f, 
    0.30615965f, -0.01533285f, -0.05945464f, 0.02389421f, 0.04651970f, -0.30064040f, -0.04398150f, -0.06267503f, 
    0.09531562f, -0.12506910f, 0.25979760f, -0.10546142f, 0.21923298f, 0.26736164f, -0.04314800f, 0.09503379f, 
    -0.07114938f, 0.02859747f, 0.16846599f, 0.00842228f, 0.11551104f, 0.06839250f, 0.07739046f, 0.11215338f, 
    0.04377098f, 0.14766327f, -0.03618160f, -0.17191422f, 0.12331277f, 0.31181136f, -0.11580116f, -0.20628990f, 
    0.16753727f, 0.08020779f, 0.16724211f, -0.05237847f, -0.12211929f, 0.20692676f, -0.02190282f, 0.09214585f, 
    -0.15157607f, -0.02904367f, -0.05826998f, -0.04132331f, 0.04134687f, -0.11025742f, -0.05747291f, 0.09710231f, 
    0.24122757f, -0.08251595f, 0.14001213f, 0.06178300f, -0.31321678f, -0.20325027f, -0.06805397f, -0.06613355f, 
    0.02810575f, -0.17824899f, 0.09344324f, 0.06362738f, 0.42289001f, 0.11497215f, 0.02039536f, 0.08976793f, 
    0.12131373f, -0.10497908f, 0.20286563f, 0.30477074f, 0.08381148f, 0.00098595f, -0.18902270f, 0.00103241f, 
    0.05996147f, 0.02828505f, -0.03625432f, 0.17621307f, 0.30137143f, -0.31759575f, 0.14700095f, -0.19819993f, 
    -0.05374946f, -0.02318205f, 0.39785352f, 0.05581988f, -0.09020893f, 0.26997679f, -0.27541563f, 0.26193547f, 
    0.02206305f, 0.14950044f, 0.03066590f, 0.14969809f, -0.16795713f, -0.03100535f, -0.06675784f, -0.11031283f, 
    -0.05334298f, -0.13671416f, 0.20089974f, -0.04033732f, 0.33243763f, 0.05403100f, -0.17238097f, -0.03192428f, 
    0.18294230f, -0.09715598f, 0.06247071f, -0.11254273f, -0.07893584f, 0.00136604f, 0.28216344f, 0.00730041f, 
    -0.31273440f, 0.04285892f, 0.03633894f, 0.21027002f, 0.11045599f, 0.08091455f, 0.05453148f, 0.11918830f, 
    0.01061372f, 0.25396100f, 0.14139442f, 0.08639007f, 0.06678012f, 0.11064637f, -0.01860967f, 0.05250801f, 
    0.13255750f, -0.05224952f, -0.00885559f, -0.01350305f, -0.16563372f, 0.07280190f, -0.10185527f, 0.01385357f, 
    0.12369644f, 0.01212807f, -0.08262637f, 0.05240402f, 0.03982237f, 0.22432256f, 0.04632064f, 0.13081539f, 
    0.02965122f, 0.03280044f, 0.14781120f, 0.01816165f, -0.22643426f, 0.23767465f, 0.23836474f, -0.10563720f, 
    0.23126756f, -0.12653126f, -0.00469745f, 0.12961182f, 0.03096867f, -0.10634793f, 0.10052909f, -0.01706922f, 
    0.20307331f, -0.26074341f, 0.25665709f, -0.09804984f, -0.11659590f, 0.02745216f, 0.13744301f, -0.08743094f, 
    0.00173790f, -0.07143912f, 0.27733535f, 0.02874437f, 0.05617050f, -0.09744146f, 0.05226277f, 0.11310788f, 
    -0.04980571f, -0.08822650f, 0.19300812f, 0.06023680f, 0.03907090f, -0.35018897f, -0.06177922f, 0.22754216f, 
    -0.05040020f, 0.11857874f, 0.02959318f, -0.00132287f, 0.32877609f, -0.09153488f, -0.25841552f, -0.09357488f, 
    -0.14130129f, 0.07247463f, 0.16242540f, 0.06167154f, 0.34865358f, -0.18694513f, 0.12529899f, -0.10207998f, 
    -0.19896822f, 0.11531928f, 0.21163246f, 0.11324453f, -0.23328178f, -0.10819867f, 0.17626461f, -0.06360509f, 
    -0.07709784f, 0.10368638f, 0.30062330f, 0.02983043f, -0.19712164f, 0.03867142f, 0.00593298f, 0.25617945f, 
    0.21731047f, 0.02062130f, 0.04740967f, 0.02727097f, -0.04712286f, 0.08786594f, -0.04617103f, -0.13542949f, 
    0.40498316f, -0.23563790f, 0.38675493f, 0.01631639f, -0.07324888f, -0.18463615f, 0.28829378f, -0.06143339f, 
    -0.11634576f, -0.10320501f, -0.07935853f, 0.05773332f, -0.10455460f, 0.08257698f, -0.16873369f, -0.10843543f, 
    0.13314258f, 0.09058227f, 0.15359332f, -0.27587646f, 0.14438055f, 0.22874473f, -0.03264106f, -0.11104683f, 
    -0.04260941f, -0.23757234f, -0.11555202f, -0.06811510f, 0.04884821f, 0.05422164f, 0.23567432f, 0.17881539f, 
    -0.25963908f, -0.02024874f, -0.35230339f, -0.44276610f, 0.29784963f, 0.23028523f, 0.13636985f, 0.00131051f, 
    0.02644173f, 0.08132030f, 0.32791829f, 0.18779252f, -0.17604490f, 0.00114594f, 0.05010249f, 0.33496591f, 
    0.06735244f, -0.05852412f, -0.31829226f, -0.03655937f, -0.09519229f, -0.19127007f, 0.41242766f, 0.22568414f, 
    0.15381895f, -0.04925144f, 0.07183170f, 0.19783750f, -0.15139085f, -0.10358434f, 0.06460784f, 0.07365641f, 
    0.08473654f, 0.15985802f, -0.12909797f, -0.11953278f, 0.07900427f, 0.14546305f, 0.01189531f, -0.11817719f, 
    0.22250120f, 0.07140300f, 0.01397130f, -0.10622662f, 0.07590709f, 0.08238611f, 0.06632112f, 0.09298014f, 
    0.04771479f, -0.06144825f, -0.07292115f, 0.32106984f, 0.26326656f, -0.05041957f, 0.10704928f, 0.11371632f, 
    -0.02491551f, -0.08149340f, 0.07257481f, 0.09514764f, 0.16953084f, -0.18806453f, -0.01869768f, 0.04866307f, 
    0.09079689f, 0.02704750f, -0.10188594f, -0.12008750f, -0.31283054f, -0.19011500f, 0.27462149f, 0.09383705f, 
    -0.02937916f, 0.02703041f, -0.24496420f, -0.06293724f, -0.03858354f, 0.58354276f, 0.29739538f, 0.22217500f, 
    -0.04380868f, -0.10599715f, -0.17291665f, -0.01534559f, 0.11134950f, -0.03424598f, -0.03674256f, 0.31157365f, 
    0.29205331f, -0.11057866f, -0.09381422f, -0.09258842f, 0.07523052f, 0.03779860f, 0.06336020f, -0.19843207f, 
    -0.18243499f, 0.21842682f, 0.13101064f, 0.08147158f, 0.01869446f, 0.06299224f, 0.16612327f, 0.10307091f, 
    -0.14786999f, -0.05039461f, -0.06562160f, 0.09288625f, -0.01280965f, -0.02522199f, -0.27206531f, 0.01969779f, 
    0.19381444f, -0.04760182f, -0.09118181f, -0.35343406f, -0.19488370f, 0.03319369f, 0.04903184f, 0.00068130f, 
    0.10324901f, 0.19109096f, -0.07623474f, 0.05629276f, -0.04430791f, 0.00373620f, 0.25427073f, 0.12120422f, 
    -0.18758856f, 0.09501828f, -0.18734246f, -0.18267892f, -0.16314384f, 0.23619047f, -0.11355054f, 0.07136589f, 
    0.10442712f, 0.05653605f, -0.23179105f, 0.14542325f, -0.11644365f, -0.27250183f, 0.19565944f, 0.19397919f, 
    0.00427644f, -0.03868004f, 0.04981114f, -0.10580049f, -0.09908091f, 0.31814191f, 0.08395844f, 0.01886138f, 
    0.01906536f, 0.03120678f, -0.02521745f, 0.06441181f, 0.09918664f, 0.00297090f, 0.26694140f, 0.09712719f, 
    0.04529672f, -0.08936626f, 0.26336256f, 0.25869131f, -0.24900258f, 0.09372894f, 0.11474524f, 0.09824098f, 
    -0.02738482f, 0.12486112f, -0.06331234f, 0.07624082f, 0.05607065f, -0.01524701f, 0.14480695f, -0.06851304f, 
    0.15787028f, 0.10679703f, -0.27688512f, -0.07654923f, -0.28833500f, -0.03694956f, 0.06012487f, -0.11818024f, 
    0.00387426f, 0.12193502f, 0.09723277f, 0.15260805f, 0.22670780f, 0.21627796f, -0.19593531f, -0.06351954f, 
    0.18310325f, 0.01388406f, 0.03338372f, 0.11347649f, -0.06747491f, -0.16446427f, -0.10976850f, 0.07498739f, 
    0.25693521f, 0.08688126f, 0.29435295f, 0.27256170f, 0.43897751f, -0.17696013f, -0.15018012f, -0.04005343f, 
    0.08733505f, 0.02368582f, 0.14307739f, 0.04047304f, 0.17824198f, -0.07911718f, 0.11859310f, 0.18936527f, 
    -0.11924930f, 0.28324831f, -0.09946207f, 0.08407454f, -0.07142109f, 0.00685274f, -0.13555685f, -0.02014824f, 
    0.18844238f, 0.08080816f, 0.02987541f, 0.33489197f, -0.03121457f, -0.01859956f, 0.09623063f, -0.06718703f, 
    0.13526149f, -0.06405494f, 0.07767411f, -0.10300420f, 0.11663326f, -0.02459013f, -0.00559424f, -0.03919807f, 
    0.15941042f, 0.03469906f, -0.21356313f, -0.06678965f, -0.18306763f, 0.04345100f, -0.06189490f, 0.14923108f, 
    0.04571972f, -0.11696585f, 0.05298359f, -0.13868569f, -0.03641881f, -0.18937284f, -0.04591434f, 0.18516049f, 
    0.26803234f, -0.00185487f, 0.06363228f, -0.11635373f, -0.18045323f, -0.05111198f, 0.12878320f, 0.07243462f, 
    0.14225490f, 0.07511114f, 0.11760934f, -0.14354578f, 0.23993111f, 0.15403043f, -0.18316837f, 0.05996695f, 
    -0.12089674f, -0.00828483f, 0.23575690f, -0.11569124f, 0.21803156f, -0.02392205f, 0.14275247f, 0.25121096f, 
    -0.12673070f, 0.23576643f, 0.01177485f, -0.07457934f, 0.10432554f, 0.31502721f, 0.02445421f, -0.22124179f, 
    -0.16570318f, 0.19017991f, -0.08950791f, -0.19068079f, 0.11481956f, 0.20031209f, -0.00894261f, -0.06579813f, 
    0.19758041f, 0.00753932f, -0.12174505f, -0.01601021f, 0.10084219f, 0.08644135f, -0.00008316f, -0.01833813f, 
    0.10735183f, 0.04167612f, 0.16663027f, -0.26856017f, -0.20317712f, 0.08116088f, 0.09579727f, -0.30035716f, 
    0.09982362f, -0.41600990f, 0.04150953f, -0.01211120f, 0.20929919f, 0.24518342f, 0.05774045f, 0.12202258f, 
    -0.07811758f, -0.00187189f, 0.23197894f, 0.16661298f, 0.08058628f, -0.01407623f, 0.06689527f, 0.02506409f, 
    0.01567946f, 0.07498738f, 0.05939521f, 0.27088571f, -0.08677608f, -0.19142620f, 0.12357548f, -0.00614623f, 
    0.06045325f, 0.08613284f, -0.04547898f, -0.02347414f, 0.09414032f, -0.30499956f, -0.27688187f, -0.10150371f, 
    -0.08581190f, 0.21389805f, -0.00640748f, 0.07725296f, -0.00298104f, -0.00516254f, 0.15151076f, 0.27601898f, 
    0.06293616f, 0.09880971f, -0.10860281f, -0.09537678f, 0.00654109f, 0.10008784f, -0.29191256f, -0.07343381f, 
    -0.00220178f, 0.03461396f, 0.39449811f, 0.09870961f, 0.07887296f, -0.07719117f, 0.42020831f, -0.03142763f, 
    -0.29785734f, 0.03125699f, -0.04968758f, 0.08812787f, 0.12289998f, -0.21418995f, -0.07984106f, 0.09597314f, 
    0.12049600f, 0.27468157f, 0.00737285f, 0.12894329f, -0.16553375f, 0.15551655f, -0.01307748f, 0.05008497f, 
    0.02000622f, 0.03751466f, 0.19950482f, -0.10328949f, -0.14453015f, 0.15980570f, -0.00282640f, -0.04253656f, 
    0.44504440f, 0.11058855f, -0.16968343f, 0.05211928f, 0.18134040f, 0.11527327f, -0.06248103f, 0.02909020f, 
    -0.07457139f, 0.07644522f, -0.17607310f, 0.08571967f, 0.05082321f, -0.08903599f, -0.06666695f, -0.05647890f, 
    -0.07309746f, 0.23073903f, 0.12005904f, -0.17250143f, 0.01921858f, 0.11968911f, -0.08796155f, 0.38100615f, 
    0.13362469f, -0.03398162f, 0.27944645f, 0.08177226f, -0.27043483f, 0.00804094f, 0.28777373f, -0.11332431f, 
    -0.01808011f, 0.08989419f, 0.24166510f, 0.33115259f, -0.05353852f, -0.03816642f, -0.32357803f, 0.08963969f, 
    0.12623879f, 0.08281956f, -0.23519255f, -0.06365966f, -0.23310335f, 0.07680003f, -0.00254429f, -0.06719674f, 
    -0.06104355f, 0.27879226f, 0.10662162f, -0.11699880f, 0.15692826f, 0.08640409f, 0.16870557f, 0.12261599f, 
    0.13594285f, 0.03550424f, 0.21351711f, 0.04903940f, -0.12465893f, 0.00754789f, -0.06620192f, 0.09194390f, 
    0.09939101f, 0.07765784f, 0.23775844f, -0.08351510f, 0.18188432f, -0.10904203f, -0.03813391f, -0.06957620f, 
    0.11136720f, 0.07255834f, -0.08112129f, -0.11375225f, 0.06466001f, -0.00897650f, 0.31544462f, -0.02783558f, 
    -0.12344280f, -0.01979979f, -0.10593192f, -0.09935762f, -0.06359662f, 0.08497220f, -0.10836745f, 0.01235352f, 
    0.25521827f, -0.04515235f, 0.12794666f, 0.20012687f, -0.18906288f, -0.01712186f, -0.10589516f, 0.01981559f, 
    -0.08537962f, -0.10417382f, -0.02572281f, -0.23046322f, 0.07124115f, 0.03757117f, 0.10391471f, -0.12030159f, 
    0.07048207f, 0.03179841f, -0.12885936f, 0.03968101f, -0.00000529f, -0.14161529f, 0.02487374f, 0.21173623f, 
    -0.07607266f, -0.10254123f, -0.11300400f, -0.02034938f, 0.07111855f, -0.33183020f, -0.30432647f, 0.15795533f, 
    -0.06249705f, 0.08419671f, -0.29924825f, -0.32953385f, -0.01276500f, 0.10804006f, 0.18060285f, 0.00394780f, 
    -0.05847082f, 0.09662524f, -0.20579496f, 0.10323279f, 0.27749950f, 0.18796155f, 0.14836979f, 0.02628730f, 
    -0.04818619f, -0.00446077f, -0.05362142f, 0.05160438f, -0.00263856f, -0.25709698f, 0.13407452f, 0.62274694f, 
    0.16302314f, 0.17734377f, -0.08910812f, -0.14957884f, 0.07933626f, 0.05048174f, 0.15223287f, -0.12350654f, 
    0.13387254f, 0.01979505f, -0.03369111f, 0.05136403f, 0.23040044f, 0.13913228f, 0.29953504f, -0.10186002f, 
    -0.08250561f, 0.02249531f, 0.27379805f, -0.12866066f, 0.05933408f, 0.09799429f, -0.31310552f, 0.11037380f, 
    0.16196518f, -0.01829423f, 0.06999945f, -0.08377169f, 0.27032629f, 0.16513103f, -0.09548943f, 0.38527590f, 
    0.05075524f, 0.17912850f, -0.04141868f, -0.10993857f, -0.13602930f, -0.31025377f, 0.32801580f, 0.22254047f, 
    -0.22187780f, 0.01436581f, -0.25607446f, -0.44019639f, 0.04386919f, -0.03308937f, 0.11312497f, 0.00690594f, 
    -0.32451719f, -0.08345963f, 0.08174246f, -0.18861748f, -0.33247420f, -0.11536714f, 0.26984990f, 0.33432743f, 
    -0.09119391f, -0.11440268f, 0.00512990f, 0.00120995f, 0.03617543f, 0.26095983f, 0.30327117f, 0.03895725f, 
    0.15086438f, -0.19600086f, 0.10822690f, 0.10922623f, 0.19955713f, 0.09190391f, 0.12969910f, 0.05764101f, 
    -0.30163440f, 0.16695505f, -0.21152662f, 0.17437112f, -0.04943340f, 0.17906888f, -0.20137164f, -0.09016357f, 
    -0.09954084f, 0.09014164f, -0.08168908f, -0.05445752f, 0.03345701f, 0.02226532f, 0.36827210f, -0.11814146f, 
    0.19013265f, -0.02386378f, 0.00579104f, 0.30246797f, -0.01798441f, 0.11782597f, 0.02131131f, -0.23360014f, 
    0.04362587f, 0.26707429f, 0.06769858f, 0.14389086f, -0.15526091f, -0.05297317f, 0.10988168f, 0.01806758f, 
    0.08134346f, -0.07842346f, 0.09460579f, 0.24802160f, 0.20703128f, -0.06919902f, -0.06754308f, -0.10043904f, 
    -0.14798005f, -0.09826374f, -0.04352323f, -0.01337890f, -0.01480240f, -0.16218020f, -0.09486949f, -0.22536175f, 
    0.03383093f, 0.04220713f, 0.06050447f, -0.05896465f, 0.06959210f, 0.09468319f, -0.03588699f, -0.12583643f, 
    0.00126500f, 0.21437147f, 0.00919975f, 0.18639955f, 0.27640092f, 0.21869858f, 0.04478667f, -0.11046503f, 
    0.01971997f, 0.18444988f, -0.22591946f, -0.18761408f, 0.10410886f, 0.11051820f, -0.26516500f, 0.05387388f, 
    0.32287028f, -0.01988746f, 0.06179724f, -0.16793452f, 0.08987933f, 0.04303702f, 0.33668926f, 0.01689629f, 
    -0.27713540f, 0.08381495f, 0.21634996f, 0.04346935f, 0.22673093f, -0.07021343f, 0.05930631f, 0.01665756f, 
    -0.03090306f, -0.30719936f, -0.04361326f, -0.08984567f, 0.16262661f, 0.11207281f, -0.13872007f, -0.04273368f, 
    0.16070555f, 0.01902534f, 0.19281763f, 0.16141811f, 0.02731013f, 0.16365562f, 0.09674681f, -0.06757985f, 
    0.18504804f, 0.11073013f, -0.14074162f, -0.09978963f, -0.04444759f, 0.28598666f, 0.20895267f, 0.16297424f, 
    -0.09565933f, 0.06918810f, 0.23009850f, 0.01052688f, -0.14057586f, -0.04808458f, -0.39281952f, -0.11389789f, 
    0.13066511f, -0.03963833f, -0.03846820f, 0.07506301f, -0.04995912f, -0.09679290f, 0.04915963f, 0.06031495f, 
    -0.07271098f, -0.07022097f, -0.10355926f, 0.09324021f, -0.11599632f, 0.05010064f, -0.00430235f, 0.10487449f, 
    0.05327839f, -0.10328729f, -0.04909861f, -0.13667202f, -0.07760471f, 0.01105896f, 0.07537568f, 0.04056229f, 
    -0.06182899f, 0.11870877f, -0.06373677f, 0.05302794f, -0.06259695f, -0.01971575f, 0.03873385f, -0.09367069f, 
    -0.08549918f, -0.11326435f, 0.08652270f, -0.14457460f, 0.04112186f, -0.04398539f, -0.02329073f, -0.03166465f, 
    -0.05827927f, -0.04400281f, -0.12048009f, 0.10888521f, -0.12767175f, -0.12788799f, -0.00313514f, 0.01778520f, 
    -0.04929280f, 0.01219514f, 0.04152673f, -0.04315713f, -0.00046180f, -0.03358823f, -0.03079977f, -0.09692537f, 
    0.08110405f, -0.03203224f, 0.07102904f, -0.07454473f, 0.03854843f, -0.11052737f, 0.07771702f, -0.03066826f, 
    -0.14142098f, -0.12113891f, -0.02803312f, -0.01098186f, 0.08889496f, 0.03361874f, -0.03470494f, 0.00033824f, 
    -0.18860999f, 0.20406546f, -0.03209772f, 0.09597947f, 0.20050497f, 0.07846718f, 0.08146597f, -0.06854486f, 
    -0.02255102f, 0.08784830f, -0.32859379f, 0.25079083f, 0.09468723f, 0.02058190f, -0.04566602f, 0.00146381f, 
    0.22786324f, -0.03400059f, 0.00379255f, -0.02742594f, 0.19762939f, 0.32570043f, 0.03610947f, -0.07293320f, 
    0.00453536f, -0.41491118f, 0.09004690f, 0.00495226f, -0.24012868f, 0.04009996f, 0.40635690f, 0.19841255f, 
    -0.12556313f, 0.08751715f, -0.05036869f, 0.17993620f, 0.06769560f, 0.20367926f, 0.07445307f, 0.07655903f, 
    -0.12148052f, -0.08884140f, 0.06339996f, -0.11619145f, -0.05711712f, -0.00566318f, 0.08064831f, 0.12225037f, 
    0.08389565f, 0.11450516f, -0.04965514f, -0.09176859f, -0.12488049f, 0.09363713f, 0.03458994f, -0.06572002f, 
    -0.01239844f, -0.22241324f, -0.05122676f, 0.16672958f, 0.19658981f, -0.04608063f, 0.15191601f, -0.18996963f, 
    0.25141737f, 0.22029112f, -0.01320393f, -0.04585896f, -0.18455814f, -0.02990372f, 0.17694384f, -0.07943071f, 
    -0.16080154f, -0.09984544f, 0.00879626f, 0.14402114f, 0.09146480f, 0.08295347f, -0.25380257f, -0.05841883f, 
    0.19375542f, -0.07237990f, -0.21510811f, -0.07756129f, -0.21378225f, -0.20742518f, -0.11003178f, 0.25880659f, 
    -0.01623485f, -0.13260449f, -0.10037655f, 0.10347510f, 0.30105892f, 0.05204874f, -0.14156647f, 0.08322736f, 
    0.00649255f, -0.03041859f, 0.13251175f, 0.20717940f, -0.20671652f, 0.10000998f, -0.07082833f, -0.08497313f, 
    0.12899126f, 0.02118690f, -0.09385269f, -0.02790965f, 0.22475183f, 0.14603281f, -0.03481506f, -0.11201227f, 
    0.07043156f, -0.11421796f, 0.15724757f, -0.06097904f, 0.26910204f, 0.20232394f, -0.17196032f, 0.36113212f, 
    0.03337649f, 0.18442036f, -0.08982985f, -0.15757118f, 0.01988564f, 0.06099735f, 0.00516779f, 0.02483798f, 
    -0.27995524f, 0.31732476f, -0.21633762f, -0.10711882f, 0.29035598f, 0.03994762f, 0.14318462f, -0.03694451f, 
    -0.11434352f, -0.06433009f, -0.06042612f, -0.02358921f, 0.03775970f, -0.11370156f, 0.04846305f, 0.07419990f, 
    0.08498069f, -0.00408348f, -0.09072579f, -0.11396181f, 0.00117626f, 0.13473067f, 0.06646158f, 0.13919070f, 
    0.00960510f, 0.07245632f, 0.07845935f, 0.17131418f, -0.27596170f, -0.04397911f, 0.17631193f, 0.18375960f, 
    0.02140409f, 0.04551043f, -0.15627559f, 0.00752922f, -0.34176636f, 0.12674312f, -0.04861811f, 0.10622776f, 
    -0.15358455f, 0.05985618f, -0.41714424f, 0.08372187f, -0.21152653f, 0.16545345f, 0.06868161f, 0.16039501f, 
    -0.02049130f, 0.01331557f, -0.04677565f, 0.05426519f, 0.09728869f, -0.02051331f, 0.22303449f, -0.09821133f, 
    0.01085301f, -0.01289563f, -0.06740834f, 0.03492755f, 0.21836346f, 0.15641490f, 0.23135568f, 0.10346196f, 
    0.09452505f, 0.28426287f, 0.02916797f, -0.01725417f, -0.11096701f, 0.08806201f, -0.09374326f, -0.08075966f, 
    0.02801715f, -0.04985713f, 0.02766385f, 0.29868555f, 0.01689942f, -0.02036564f, 0.11798429f, 0.11216624f, 
    -0.13797437f, -0.00483089f, 0.03932772f, 0.18342589f, -0.12403670f, -0.23764594f, -0.12351202f, 0.10541304f, 
    -0.06400476f, -0.21085168f, 0.02550858f, -0.04123240f, 0.15860456f, 0.21168403f, 0.01872221f, -0.00656661f, 
    0.19300301f, 0.08679679f, 0.12456505f, 0.44199303f, -0.18625921f, 0.19977807f, -0.12741452f, -0.05965657f, 
    0.39748839f, 0.02368240f, -0.31418115f, 0.17906690f, 0.26317313f, 0.32844880f, -0.08770458f, -0.23707223f, 
    0.00724098f, -0.04390660f, -0.01332662f, 0.02867379f, 0.04017796f, 0.28231460f, -0.24662593f, 0.22892810f, 
    0.00343433f, 0.04953559f, -0.03349376f, -0.16163695f, -0.08358056f, 0.09989846f, 0.13684241f, -0.11710490f, 
    0.02495443f, -0.15989144f, 0.33277148f, 0.26507184f, -0.16335298f, -0.03800154f, 0.13801204f, 0.03697209f, 
    -0.13747303f, -0.11450351f, 0.15454540f, 0.22845915f, 0.09799165f, -0.03647612f, -0.14638464f, 0.09937838f, 
    0.10497142f, 0.13375792f, -0.29321757f, -0.05571019f, -0.06384713f, 0.22642870f, 0.08795385f, -0.04751527f, 
    0.04693458f, 0.52701592f, 0.04628772f, 0.01138340f, -0.15681070f, 0.15596668f, -0.00458350f, 0.12262283f, 
    0.17245883f, -0.09667973f, 0.10799020f, 0.12934898f, -0.05197261f, -0.09780788f, 0.00804124f, -0.03956029f, 
    0.11759124f, -0.10118915f, 0.05912456f, 0.13905406f, 0.39325306f, -0.15270795f, -0.29455680f, -0.03590161f, 
    -0.00772341f, 0.05129765f, -0.20615330f, 0.02532141f, 0.10559838f, 0.21881828f, 0.44026780f, -0.08085118f, 
    0.03676252f, -0.06062200f, -0.00332218f, 0.15714616f, 0.18703008f, 0.00406511f, 0.06702784f, -0.15598479f, 
    0.26047325f, 0.03519974f, 0.06619510f, 0.03624011f, -0.20663367f, -0.09859358f, -0.01973255f, -0.04004356f, 
    -0.24043928f, -0.11244610f, -0.14446190f, 0.11389761f, 0.04521349f, -0.02695894f, 0.26828355f, -0.06964919f, 
    0.14058287f, -0.00164763f, 0.05342404f, -0.01974197f, -0.01188949f, -0.06507229f, 0.07350183f, -0.01576716f, 
    0.07719932f, -0.12750714f, 0.12403911f, 0.08246945f, -0.10352241f, -0.02382995f, 0.03755822f, 0.18583880f, 
    -0.09126101f, -0.09389777f, -0.19576748f, -0.10465615f, 0.02468207f, 0.30852625f, 0.11332300f, 0.08200139f, 
    0.28855237f, 0.02424210f, -0.19095418f, 0.05331354f, 0.10992966f, -0.10566343f, -0.07142696f, 0.02217915f, 
    -0.10927627f, -0.00189072f, -0.10792449f, 0.00775009f, -0.11237473f, -0.14251038f, 0.03625118f, 0.49595997f, 
    0.09675199f, -0.08066283f, 0.02902233f, -0.08299549f, 0.01244636f, 0.03462622f, 0.18732165f, -0.09154682f, 
    -0.02837683f, -0.01004118f, 0.03154710f, -0.06708933f, -0.16339715f, 0.00939098f, 0.09966381f, 0.05971578f, 
    0.04240645f, -0.10933015f, -0.07418168f, -0.10328142f, 0.06808616f, -0.07655891f, 0.08452546f, -0.04538533f, 
    0.02566607f, -0.05947307f, 0.07211725f, 0.02243346f, -0.12762223f, -0.07525448f, 0.05432699f, 0.06737700f, 
    0.01383934f, 0.00545509f, -0.05417895f, 0.00748650f, -0.05369207f, -0.12527603f, -0.05082729f, 0.00045828f, 
    -0.06978179f, -0.05930521f, 0.04228876f, -0.05183370f, 0.09771619f, -0.08839435f, -0.09109005f, 0.07760648f, 
    -0.07947630f, -0.00417329f, -0.01709435f, -0.10540634f, 0.10848901f, 0.07190634f, -0.14118874f, -0.09233012f, 
    0.00673497f, 0.07070282f, 0.07277023f, 0.11386633f, -0.01909792f, -0.12059528f, 0.05861043f, 0.01505217f, 
    0.09115410f, -0.08390554f, 0.02568073f, 0.01867332f, 0.07776360f, -0.06775946f, -0.13282958f, -0.02363786f, 
    0.27055231f, 0.03547189f, 0.14212486f, -0.16670300f, -0.08265975f, -0.16274874f, 0.14962630f, -0.01618848f, 
    -0.04158891f, 0.11665804f, 0.19945382f, 0.30685601f, 0.04429357f, 0.08299471f, -0.20426321f, 0.12182878f, 
    -0.11918660f, 0.00637411f, -0.08549695f, -0.16460256f, -0.03058073f, -0.05555281f, 0.05944933f, 0.13306026f, 
    0.10729217f, 0.28801763f, -0.00848440f, 0.16999152f, 0.03943998f, 0.30581278f, 0.23820125f, 0.04627482f, 
    0.08287048f, -0.12415792f, 0.02931589f, 0.00975702f, -0.19744569f, 0.30827448f, -0.15093683f, -0.03888713f, 
    0.37202764f, 0.05570122f, -0.23668139f, 0.02560537f, 0.23744297f, 0.21188760f, 0.07950167f, 0.09092815f, 
    0.03394029f, 0.01090391f, -0.16266060f, 0.09020010f, -0.00455235f, 0.26414090f, 0.23204681f, 0.00531477f, 
    0.02221526f, -0.12598433f, -0.09799322f, -0.04129887f, -0.04027347f, -0.06538590f, 0.21342032f, 0.14527985f, 
    -0.03842707f, -0.03818057f, -0.01346828f, -0.10367453f, -0.05902149f, -0.11458541f, -0.06821565f, -0.03199157f, 
    0.06822643f, -0.12483630f, -0.05338879f, -0.10506161f, -0.11359937f, -0.12209052f, -0.01472163f, 0.10123654f, 
    -0.11187994f, -0.09274440f, -0.12493692f, 0.08146676f, -0.11969253f, -0.03181739f, 0.08370171f, -0.04653975f, 
    -0.10009980f, 0.07416573f, -0.03046657f, -0.06220321f, -0.06122658f, 0.00238706f, 0.09221824f, -0.06744395f, 
    0.09647602f, 0.00356852f, 0.04332192f, -0.03206114f, -0.07958853f, -0.06914535f, 0.01688586f, 0.04953995f, 
    0.02207302f, 0.05541070f, 0.06701569f, -0.00258389f, -0.09174311f, -0.10293120f, -0.11083785f, 0.04623003f, 
    0.00805329f, 0.04307224f, -0.05091520f, 0.00800145f, -0.07476908f, -0.10322405f, 0.08012338f, -0.04234171f, 
    0.09986849f, 0.10180202f, -0.01083162f, -0.04850920f, 0.01690993f, 0.07510489f, -0.08424158f, -0.11471550f, 
    -0.03362349f, -0.08296291f, -0.05427277f, 0.03529220f, 0.03454341f, -0.11812524f, -0.03667305f, 0.05655697f, 
    0.01335846f, -0.12431496f, -0.04849872f, -0.08462876f, -0.05673079f, -0.01936568f, -0.01450704f, 0.11242209f, 
    -0.05761364f, -0.04285706f, 0.09275854f, 0.00925210f, 0.04694312f, 0.04795416f, -0.03169072f, -0.11365596f, 
    -0.06996803f, -0.10428928f, -0.03392030f, -0.12634026f, -0.07151196f, -0.10027027f, -0.08364708f, -0.05067586f, 
    -0.11840483f, -0.09202364f, -0.04393582f, 0.06127392f, -0.07809243f, -0.00924571f, 0.00926861f, 0.06264517f, 
    -0.00193172f, -0.05505041f, 0.00955675f, 0.04631930f, -0.01981321f, 0.07790902f, 0.01149326f, 0.06501616f, 
    0.04528353f, -0.07577004f, -0.13964421f, -0.09546242f, 0.03942886f, 0.04560767f, -0.14982991f, -0.12559627f, 
    0.08390816f, -0.02591894f, -0.11696698f, -0.07610927f, -0.10300375f, -0.00808385f, -0.06320241f, 0.07315560f, 
    0.08457631f, 0.03250713f, 0.31879386f, 0.12008323f, 0.02132166f, -0.13647947f, 0.00847080f, -0.10067470f, 
    -0.28626338f, 0.00310893f, 0.27069542f, 0.07887977f, 0.12207976f, -0.08219482f, -0.13934264f, -0.09210487f, 
    -0.07969467f, 0.00422326f, 0.13249540f, 0.03610709f, 0.00913757f, 0.13115090f, -0.10972710f, 0.20154805f, 
    0.00810211f, 0.10246782f, -0.10018431f, 0.04918253f, -0.16809623f, 0.00010125f, 0.33456829f, 0.17383580f, 
    -0.22946225f, 0.01461038f, -0.04423175f, -0.22765058f, 0.24006101f, 0.33468127f, -0.11050151f, -0.12623265f, 
    0.07344396f, 0.06105443f, -0.09841660f, 0.05233764f, 0.10043027f, -0.18667564f, 0.16145630f, -0.02106985f, 
    -0.09745284f, -0.02974563f, -0.01592484f, 0.08228675f, -0.17903861f, 0.35313663f, 0.23545656f, 0.12914686f, 
    -0.07686425f, 0.04118911f, -0.06959570f, 0.00240283f, 0.15931775f, 0.02396036f, 0.19138768f, -0.07747836f, 
    0.00372444f, 0.02766824f, -0.09841531f, 0.04680028f, -0.04574678f, 0.03590225f, 0.03130883f, -0.09159665f, 
    -0.08284847f, -0.06048029f, -0.10078719f, 0.03128200f, -0.03731303f, -0.02728852f, 0.02801784f, 0.01366164f, 
    -0.01605091f, -0.04822426f, 0.01843627f, 0.01332197f, 0.05518600f, -0.11076549f, -0.04294279f, 0.07977011f, 
    -0.09857906f, -0.13023700f, -0.00849994f, -0.09749719f, 0.02172241f, 0.05080412f, -0.05198859f, -0.00303970f, 
    -0.03440658f, 0.03588685f, -0.12532821f, -0.14731638f, -0.01068028f, -0.10963034f, 0.04004767f, -0.03124405f, 
    -0.05717923f, 0.04943024f, 0.05743375f, -0.10537786f, -0.05703599f, 0.01400846f, -0.04764847f, -0.08300236f, 
    -0.10680123f, -0.10763588f, -0.10106841f, -0.09125891f, -0.03959565f, 0.03894771f, 0.08927372f, -0.05512464f, 
    0.02251304f, -0.01111755f, 0.02717923f, 0.02822638f, 0.05255538f, -0.14902543f, -0.11451283f, -0.11393924f, 
    0.31709519f, -0.09061370f, 0.10246926f, -0.26400301f, -0.00068895f, 0.12528245f, -0.03405859f, -0.05116341f, 
    -0.28913903f, -0.01429641f, 0.01963024f, 0.13812162f, -0.06234730f, 0.02341486f, -0.21138580f, 0.11082616f, 
    -0.09366815f, 0.04879921f, 0.28862280f, 0.01850711f, 0.13427228f, -0.24279693f, 0.10957791f, 0.29738206f, 
    -0.06381219f, -0.06601652f, -0.00222370f, 0.16178164f, -0.02529305f, -0.03319988f, 0.27438018f, 0.10433447f, 
    -0.24381652f, -0.05853552f, -0.05788023f, -0.29751664f, 0.15670554f, 0.15383242f, 0.28586635f, 0.03086109f, 
    0.02450277f, 0.04554068f, 0.02922023f, 0.14683655f, -0.27511159f, -0.04218038f, 0.11194204f, 0.17208976f, 
    0.12150008f, 0.07868518f, -0.15343516f, 0.06956971f, -0.16963029f, -0.16285661f, 0.11962800f, 0.22346637f, 
    0.13173443f, -0.22223145f, -0.11626424f, 0.13734753f, -0.19697504f, -0.12253457f, 0.17216872f, 0.04989588f, 
    0.13884664f, 0.03119344f, 0.23091774f, 0.09458442f, -0.25950491f, -0.09969747f, 0.01304024f, 0.10151653f, 
    -0.21632406f, -0.03854527f, -0.11253427f, 0.02518575f, 0.04029423f, 0.10025286f, 0.21552849f, 0.05559617f, 
    0.29226115f, -0.06631441f, -0.11045633f, 0.03535081f, 0.03036510f, 0.09032729f, 0.08286051f, -0.29042980f, 
    -0.05899222f, 0.02066212f, -0.04481468f, -0.05006910f, -0.24056679f, 0.01256669f, -0.00832947f, 0.13504922f, 
    0.09071022f, 0.06842381f, -0.04979448f, -0.10314898f, 0.43588880f, 0.11983687f, -0.00717848f, 0.03744673f, 
    0.11353175f, -0.08739897f, 0.15287144f, 0.28440157f, 0.25607842f, -0.49376494f, -0.16074404f, 0.12281694f, 
    0.05816674f, -0.03930774f, -0.09886804f, 0.05612184f, 0.03779979f, -0.35853228f, 0.30430573f, 0.26728129f, 
    -0.11229202f, -0.02671088f, -0.09099399f, 0.11265314f, 0.18354224f, 0.08995034f, 0.02724112f, 0.21394631f, 
    0.08888153f, 0.12681805f, -0.14962542f, -0.18621771f, -0.11815168f, 0.12226558f, 0.04837852f, 0.04885649f, 
    0.42189121f, -0.07052325f, -0.26284003f, -0.17199519f, -0.04615039f, 0.06431310f, -0.03995362f, 0.01655228f, 
    0.17207459f, 0.08115439f, -0.16694905f, -0.22247145f, -0.20519872f, -0.06812938f, 0.00588349f, -0.18800797f, 
    -0.08719499f, -0.17585818f, 0.01607354f, 0.20863520f, 0.07700468f, -0.03950531f, -0.23988031f, 0.09206263f, 
    -0.02606457f, 0.05087154f, 0.18100686f, -0.02267925f, -0.24118142f, -0.07136368f, 0.02666426f, 0.09447582f, 
    0.18840639f, -0.09784096f, 0.23007463f, 0.20509693f, 0.23550497f, -0.00052851f, 0.16593809f, 0.29251310f, 
    -0.12111267f, 0.07873274f, -0.17007071f, -0.12459415f, 0.37077734f, -0.47620979f, 0.02493972f, 0.30641294f, 
    0.14077584f, 0.22925672f, 0.03971016f, -0.10597084f, -0.14887559f, 0.04960014f, -0.02374015f, 0.45545399f, 
    0.17724200f, -0.14736439f, -0.02075729f, 0.09371947f, -0.18530484f, -0.02135131f, 0.14410083f, 0.09424134f, 
    0.16048151f, -0.04964978f, -0.00402308f, 0.25223330f, 0.06352109f, -0.10088696f, -0.16280542f, -0.11881995f, 
    -0.02083824f, 0.10597143f, -0.18826436f, 0.19050422f, -0.12958951f, 0.18769810f, 0.06608528f, -0.05506890f, 
    0.00075290f, 0.06143066f, 0.11456767f, -0.01140794f, 0.20194846f, 0.32426524f, -0.00946235f, 0.05436991f, 
    0.24073516f, 0.03073753f, 0.19696350f, 0.36110327f, 0.20756066f, -0.17528538f, 0.06654646f, 0.04961490f, 
    -0.07658880f, 0.03901291f, 0.36404291f, 0.16630808f, 0.23021397f, 0.08181956f, -0.26447171f, -0.17773642f, 
    0.11421566f, -0.08245084f, -0.01902502f, 0.02739524f, 0.22443016f, -0.23404796f, 0.15079626f, -0.18782850f, 
    0.04609120f, -0.09537800f, 0.03193382f, 0.12696213f, 0.11786603f, 0.15598960f, -0.01020855f, -0.16567086f, 
    0.03521131f, 0.09394901f, 0.07034915f, -0.07670195f, 0.26453114f, 0.04118278f, -0.23650156f, 0.01665339f, 
    -0.18030730f, 0.04312390f, 0.24178559f, -0.34749624f, 0.06746554f, 0.11110006f, 0.20106238f, 0.04723753f, 
    -0.09778385f, 0.10505791f, 0.20374474f, 0.34643587f, 0.28788954f, -0.17572224f, -0.00945805f, 0.31266722f, 
    -0.03708557f, 0.51385218f, 0.03140767f, 0.08234128f, 0.00164654f, -0.34330651f, 0.01409255f, -0.04532893f, 
    -0.04382398f, 0.09577604f, -0.25904846f, -0.01220892f, -0.04444157f, -0.19036940f, 0.06392720f, -0.02758878f, 
    -0.15280432f, 0.03646632f, -0.00131953f, 0.10600033f, -0.17177595f, 0.03962411f, 0.16726601f, -0.01978773f, 
    -0.09413114f, -0.09152414f, 0.01804001f, -0.00973780f, -0.14898266f, -0.04563477f, 0.09105787f, 0.01056823f, 
    0.12370211f, 0.11674905f, -0.12272437f, 0.12244631f, 0.06858420f, 0.22680020f, -0.00554085f, 0.18000104f, 
    -0.08993063f, 0.01330102f, -0.11823691f, -0.04962664f, -0.02773318f, 0.00263731f, -0.09577464f, -0.11971065f, 
    -0.12993102f, 0.12190077f, -0.04587311f, 0.04665011f, 0.10691239f, 0.01094561f, -0.12184179f, 0.01096676f, 
    -0.06342941f, -0.11375907f, -0.00717150f, -0.14687987f, 0.08083734f, -0.07428958f, -0.02716824f, 0.08160046f, 
    0.03387408f, -0.07070634f, -0.07463768f, 0.00242993f, -0.12122444f, -0.02302804f, 0.08457090f, 0.02149284f, 
    0.08757526f, 0.01507559f, -0.11308620f, 0.01358478f, -0.01539970f, -0.14533028f, 0.08589841f, 0.05334069f, 
    0.00262984f, 0.10900891f, -0.10798717f, -0.01038554f, -0.06825832f, -0.01954998f, 0.03391675f, 0.08385484f, 
    0.10437524f, 0.06499574f, -0.11699947f, -0.05612215f, -0.03608472f, -0.00749747f, -0.05079857f, -0.10068714f, 
    -0.13472554f, -0.13359471f, -0.06167397f, -0.12370458f, -0.04276160f, -0.12669288f, -0.08629964f, 0.10853045f, 
    -0.04656246f, 0.00709969f, 0.25086874f, 0.12412481f, 0.20184022f, 0.19645852f, -0.15115993f, -0.06540364f, 
    0.00736138f, 0.08502107f, -0.18956670f, -0.14879680f, 0.07259876f, 0.07156209f, 0.44768551f, -0.09130628f, 
    0.08421993f, -0.02011640f, 0.13028087f, 0.42100841f, 0.19811377f, 0.33613428f, -0.09525053f, -0.09039228f, 
    0.07959287f, 0.22737840f, 0.06035037f, 0.08706139f, -0.26699191f, -0.22701907f, -0.02113492f, 0.16981062f, 
    0.24209006f, -0.00384433f, -0.31574556f, 0.07435724f, 0.50972027f, 0.04359611f, 0.11132306f, 0.08289154f, 
    -0.25776839f, -0.00427524f, 0.09592337f, -0.06953170f, -0.01348361f, -0.11746285f, 0.05752999f, -0.10490903f, 
    0.04889769f, 0.05438179f, 0.03161617f, 0.08200704f, -0.18656753f, 0.12372795f, 0.01392400f, 0.00753924f, 
    0.13258596f, 0.03315454f, -0.02605205f, 0.07859566f, 0.21195745f, 0.09091292f, 0.03896070f, -0.24022914f, 
    -0.10396505f, 0.02541655f, 0.15649636f, 0.02798455f, 0.23306084f, -0.07944709f, -0.07852134f, 0.05839567f, 
    0.18549965f, 0.02035283f, -0.06596743f, 0.19595817f, 0.10183725f, 0.10847736f, 0.02940640f, -0.05962007f, 
    -0.23317948f, -0.04237172f, 0.00229557f, 0.09157230f, -0.01360252f, 0.10072114f, 0.07444940f, -0.06127616f, 
    0.06394181f, 0.32555661f, 0.01727172f, 0.17647283f, 0.10611413f, 0.32654184f, 0.07423857f, -0.03459702f, 
    0.23618713f, 0.10853421f, 0.05505174f, 0.25302511f, 0.09376859f, 0.03386804f, -0.15591142f, 0.04146004f, 
    0.02556253f, 0.06428053f, 0.18600665f, 0.14182720f, 0.06225431f, 0.33752993f, -0.13746168f, -0.02555622f, 
    0.06116926f, -0.07465147f, -0.12447144f, -0.05590381f, -0.11631113f, 0.14286448f, -0.00846359f, -0.31905380f, 
    0.22097589f, -0.02206860f, -0.11427570f, 0.05120042f, -0.00142758f, -0.12735814f, 0.02059972f, 0.11507989f, 
    -0.09114768f, 0.15676811f, -0.05963393f, 0.17092139f, 0.06148598f, 0.18014289f, -0.02104735f, -0.03968951f, 
    0.16406906f, 0.05793092f, 0.26867244f, -0.00534577f, 0.05702773f, -0.02436793f, 0.43030047f, -0.02220400f, 
    -0.18242916f, 0.08080975f, 0.00855404f, 0.13945898f, -0.13609523f, 0.00476879f, -0.00583821f, -0.03796051f, 
    -0.02490663f, 0.10805207f, -0.01801930f, 0.00434330f, -0.19288322f, 0.00340359f, -0.20513348f, 0.17252560f, 
    0.18480860f, 0.10167189f, -0.06183824f, -0.05655373f, 0.00604065f, -0.07145890f, -0.03971980f, 0.07116750f, 
    0.00593614f, 0.08118188f, 0.04991772f, 0.10760992f, 0.07456005f, -0.23536107f, -0.12138014f, 0.11651313f, 
    -0.03809124f, -0.02370872f, 0.09757353f, 0.10961560f, 0.02454433f, -0.06405516f, -0.24106760f, -0.23796174f, 
    -0.15862969f, 0.37660247f, -0.03566453f, 0.09721499f, 0.02886032f, 0.33940020f, -0.13298139f, 0.09680843f, 
    -0.00903576f, -0.09429758f, 0.14999841f, -0.16074924f, 0.13898592f, 0.19369839f, 0.05737295f, -0.02219142f, 
    -0.11658583f, 0.05340297f, -0.23233147f, 0.14819999f, -0.02271253f, -0.01645462f, 0.17788200f, -0.08347350f, 
    0.22334570f, 0.07869438f, 0.14473139f, 0.19540519f, 0.05877675f, -0.08449753f, 0.02029883f, -0.14277470f, 
    -0.05615836f, -0.01965499f, 0.01226379f, 0.15249054f, 0.33444881f, 0.26389271f, 0.25717703f, -0.14310168f, 
    0.06669421f, -0.03802844f, 0.12085564f, 0.22097269f, 0.36437941f, 0.06286360f, -0.01451911f, 0.05931556f, 
    0.22655936f, 0.07707784f, -0.05735120f, 0.20590813f, -0.04200149f, 0.02676867f, -0.05844787f, -0.38700962f, 
    -0.05065126f, 0.09063874f, 0.06617320f, 0.13121670f, 0.13426487f, 0.02980919f, -0.09434970f, 0.07809647f, 
    0.08794377f, 0.08075488f, 0.00260829f, 0.19828205f, -0.12761240f, -0.20142919f, 0.17887366f, 0.06740656f, 
    0.17028314f, -0.22701138f, 0.21669884f, -0.25777730f, 0.21080737f, 0.00881759f, 0.03363545f, 0.06261272f, 
    -0.17987983f, 0.01062944f, 0.00227839f, -0.13469125f, -0.06522006f, 0.02637942f, -0.00473343f, -0.03241315f, 
    -0.08638309f, 0.08214326f, 0.21487688f, -0.19986986f, 0.25551730f, -0.01052732f, -0.02359239f, 0.01514650f, 
    -0.04335139f, 0.24211209f, 0.04753016f, 0.13026357f, 0.06210968f, -0.00477642f, 0.15755008f, 0.00414322f, 
    -0.07847487f, 0.08616187f, -0.16075054f, -0.26058960f, 0.19353029f, 0.17929293f, 0.15649661f, 0.06483696f, 
    -0.10746498f, -0.02738394f, 0.10798367f, 0.17537931f, -0.11922136f, -0.04573266f, 0.33282396f, 0.11218152f, 
    -0.03875755f, 0.07650167f, -0.03139675f, 0.04956057f, -0.17382234f, -0.12707058f, 0.14990497f, 0.14333394f, 
    0.18163653f, -0.07434877f, -0.01818960f, 0.19042340f, -0.09619781f, -0.13463457f, 0.21023394f, 0.38579690f, 
    0.10683081f, 0.07178049f, -0.06615413f, 0.13686410f, -0.10514639f, 0.16065325f, 0.11659986f, 0.06686525f, 
    -0.10840501f, 0.03686484f, 0.27240303f, 0.00971830f, -0.02071921f, 0.08031418f, -0.38329777f, 0.02391806f, 
    0.08256233f, -0.01326919f, 0.04445951f, -0.16688208f, -0.22574520f, -0.15621424f, 0.03048138f, 0.27618438f, 
    0.02906949f, 0.14397840f, -0.01330092f, -0.01382003f, 0.04733907f, -0.01982172f, 0.18446909f, 0.08465961f, 
    -0.15321094f, -0.04761235f, 0.09214700f, -0.04689380f, -0.35834470f, 0.17676814f, -0.14143953f, 0.08545176f, 
    0.04736780f, 0.10501689f, -0.21812092f, -0.07224415f, 0.01603067f, -0.25531149f, 0.11304741f, 0.14889050f, 
    0.13241214f, 0.05360680f, 0.30338278f, -0.09366032f, 0.00470911f, 0.33399549f, -0.18872336f, -0.03931970f, 
    -0.18636893f, 0.21944486f, -0.06607954f, 0.03267053f, 0.13412890f, -0.06532794f, 0.06499042f, 0.15014017f, 
    0.21905780f, 0.03646247f, -0.30881301f, 0.11715472f, -0.09107427f, -0.09144846f, 0.07209756f, -0.06704944f, 
    0.28135499f, -0.11861330f, 0.35585931f, 0.15780364f, 0.09033647f, -0.00867822f, -0.17466109f, -0.06882095f, 
    -0.17596363f, 0.03603087f, -0.04916488f, 0.01414252f, 0.15483196f, 0.12756777f, 0.06386067f, 0.11124402f, 
    0.06365965f, -0.18833576f, -0.05718589f, -0.17943953f, 0.06746782f, 0.01280712f, -0.01094619f, 0.15749905f, 
    0.06483906f, -0.08581164f, 0.05193838f, -0.24139677f, -0.34815946f, -0.20258740f, 0.22016920f, 0.01595474f, 
    0.18213582f, 0.06431670f, 0.04251736f, -0.12786776f, -0.07211391f, 0.35123622f, -0.03391177f, 0.27675295f, 
    0.07533533f, -0.04843860f, 0.00283566f, -0.00055049f, 0.29746756f, -0.03133534f, 0.13273813f, -0.22092468f, 
    -0.08984743f, -0.07178260f, -0.09671717f, -0.20235172f, 0.02667103f, 0.25611302f, -0.20820172f, 0.07506495f, 
    0.30861583f, 0.00345187f, 0.11717370f, -0.14641558f, -0.12062046f, -0.09554991f, 0.07696036f, -0.01995152f, 
    -0.32544848f, -0.06338853f, 0.27245697f, 0.23802045f, -0.01786666f, -0.00896550f, -0.19956020f, -0.02928546f, 
    -0.09027379f, -0.00356128f, 0.22082737f, 0.18564349f, -0.06055019f, -0.27603832f, -0.04391585f, 0.24634780f, 
    0.08953948f, -0.23941514f, 0.06982256f, 0.10177963f, 0.12774524f, 0.04697945f, 0.40121654f, 0.05149365f, 
    -0.33371681f, 0.10415965f, 0.13636816f, -0.02188002f, 0.24862012f, 0.27771196f, 0.16098250f, 0.05080101f, 
    0.08636183f, 0.09093373f, -0.29847324f, 0.15672584f, -0.23532394f, 0.05151701f, 0.16426645f, -0.07592800f, 
    -0.03291864f, -0.01073868f, -0.10229814f, -0.05721874f, 0.01250236f, 0.08836529f, 0.00348833f, 0.22566099f, 
    0.19219635f, -0.23976769f, 0.12469552f, -0.04505917f, 0.02423399f, -0.11651193f, 0.24848969f, -0.21452409f, 
    0.19524555f, -0.05689320f, -0.08397280f, -0.11507175f, 0.09448677f, 0.13179609f, -0.07777987f, -0.07536298f, 
    0.23770268f, -0.05901532f, -0.11640086f, -0.09087284f, 0.08381961f, 0.01316668f, 0.16113855f, -0.11779758f, 
    -0.11256055f, -0.11429800f, 0.12779677f, 0.35623434f, 0.12855215f, 0.01724801f, 0.04173483f, -0.10652127f, 
    -0.09319714f, -0.01725768f, 0.06182509f, 0.11307398f, 0.08181628f, 0.25051844f, 0.02284412f, -0.14785923f, 
    0.20938584f, 0.01086189f, -0.04428975f, 0.18308499f, 0.23633496f, 0.08857615f, 0.07521163f, -0.09561180f, 
    0.15463193f, 0.00179490f, 0.21190029f, 0.14048712f, 0.10895294f, 0.48017699f, -0.05243505f, -0.18721940f, 
    0.00125482f, -0.09433844f, -0.24405204f, -0.08940794f, 0.06218557f, -0.37662885f, -0.12342989f, 0.07717082f, 
    0.30326515f, -0.05588089f, -0.10324391f, 0.03238525f, -0.18866082f, 0.01914223f, 0.01912371f, 0.22963312f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04643721f, 0.05805966f, 0.05678399f, 0.17410092f, 0.13094297f, 0.09511825f, -0.03859933f, 0.00654448f, 
    0.05275599f, 0.11954648f, -0.02961356f, 0.07046521f, 0.04242198f, 0.07608255f, 0.11064605f, -0.03324182f, 
    0.09944607f, -0.07749385f, -0.07342217f, 0.00657675f, -0.00349842f, -0.00172116f, -0.00977501f, -0.14950646f, 
    0.17062138f, -0.10504231f, 0.05309665f, 0.09716558f, 0.09875306f, -0.01961016f, 0.14183764f, -0.02924240f, 
    -0.08111417f, -0.05382272f, -0.03995047f, -0.10873783f, -0.04464434f, 0.07313810f, -0.11784225f, 0.05104583f, 
    0.03009398f, 0.05414707f, 0.15312396f, -0.10977713f, 0.09353703f, -0.04974464f, -0.06228824f, 0.01748415f, 
    -0.11892084f, 0.02541641f, 0.05347819f, 0.17570817f, -0.02606214f, -0.06432700f, -0.10611466f, 0.07833058f, 
    -0.07402869f, -0.00075204f, -0.10211147f, 0.13486408f, -0.11834341f, -0.08286440f, 0.05098787f, 0.09405935f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.03570534f, -0.04989794f, -0.16854955f, -0.24196039f, -0.22797924f, 0.21683323f, 0.09808684f, 0.07538574f, 
    -0.19700515f, -0.07197864f, 0.35333487f, -0.32944489f, 0.24934380f, 0.14765143f, 0.06112959f, -0.21726280f, 
    0.05156087f, 0.08631606f, -0.19872750f, 0.00803003f, 0.18521918f, -0.01116192f, 0.08545767f, -0.38686460f, 
    -0.29281443f, 0.17032422f, -0.37725317f, 0.22050536f, 0.09114307f, 0.01708753f, 0.09907752f, 0.04973438f, 
    -0.11268955f, -0.40363407f, -0.32002625f, 0.22294942f, -0.05178276f, -0.29423052f, 0.12036999f, -0.17750941f, 
    0.15877239f, -0.03605373f, -0.42690620f, 0.03807597f, 0.03712096f, -0.05238684f, -0.09214284f, -0.51676089f, 
    0.05619295f, -0.67404217f, -0.33228093f, 0.25895229f, 0.22529806f, -0.14902820f, -0.07966896f, -0.33152509f, 
    0.23967229f, -0.03326290f, -0.15705484f, -0.23965327f, -0.11975662f, 0.18737288f, -0.47962445f, 0.19809362f, 
    -0.35144931f, 0.08856139f, 0.20022091f, 0.22221591f, -0.07000864f, 0.07963449f, 0.33716884f, -0.03190657f, 
    -0.09720381f, -0.47236714f, 0.21372269f, 0.10684869f, -0.19726245f, 0.00246417f, 0.04969077f, -0.17515382f, 
    0.26769468f, -0.07023098f, -0.09048992f, -0.25635436f, 0.06935126f, -0.00132816f, -0.27437985f, 0.16008259f, 
    0.03348055f, -0.32460177f, -0.09134249f, 0.15284833f, 0.08719759f, 0.15250918f, 0.12759732f, 0.16655646f, 
    -0.36403027f, -0.04941946f, 0.00617766f, -0.19722123f, -0.00522545f, -0.09450003f, 0.00812951f, -0.04956939f, 
    -0.11715774f, 0.07925213f, -0.16392715f, -0.06488725f, -0.04897349f, 0.04130346f, -0.09333433f, -0.03495265f, 
    -0.06337924f, 0.18673138f, 0.21433486f, 0.10861939f, 0.18185568f, 0.35642660f, -0.11802179f, -0.30253303f, 
    -0.16386460f, 0.14501461f, -0.16658789f, -0.03305656f, 0.13005993f, 0.21766537f, 0.05569804f, -0.20859624f, 
    -0.28120336f, -0.09212168f, -0.30555350f, -0.25988546f, 0.02986097f, 0.10103981f, -0.20285471f, 0.12136512f, 
    0.19866429f, -0.40042892f, -0.21653333f, -0.05723123f, -0.04893677f, -0.04740747f, -0.16268963f, 0.02648123f, 
    0.15566732f, -0.01325289f, -0.12142675f, 0.23928569f, 0.06902953f, -0.34943253f, -0.09477252f, -0.55223984f, 
    -0.04651016f, 0.21868913f, -0.05018977f, -0.27985620f, 0.10136596f, -0.50524235f, -0.11491898f, 0.14698648f, 
    -0.06268496f, 0.23785295f, -0.27345189f, -0.27000508f, -0.04812308f, 0.21079271f, 0.13732491f, 0.13846725f, 
    0.16672520f, 0.19090478f, 0.05801239f, 0.02359610f, 0.18096970f, 0.02641928f, -0.07951965f, 0.15764914f, 
    -0.02926776f, 0.15925051f, -0.25543761f, -0.40962455f, 0.15249516f, -0.35149580f, 0.12256476f, -0.18358557f, 
    -0.11376489f, -0.20631315f, -0.19418283f, -0.31770009f, 0.05556653f, 0.31221738f, 0.32190606f, -0.10398126f, 
    0.32992706f, 0.02174975f, -0.13203798f, -0.14632007f, -0.42005304f, 0.10571733f, -0.41035810f, -0.06051087f, 
    0.13284269f, -0.12637031f, 0.10688489f, -0.07675022f, 0.07901235f, -0.18334672f, -0.01396684f, -0.30099010f, 
    -0.22685041f, -0.06113345f, -0.06916866f, 0.33355701f, -0.18464112f, 0.03363513f, 0.04021615f, -0.20688590f, 
    0.18774217f, -0.09638635f, -0.16458596f, -0.36414775f, -0.56326443f, 0.20684077f, -0.09817094f, -0.17465755f, 
    -0.34763786f, -0.08935291f, -0.29398727f, 0.32452458f, -0.10471622f, 0.19065538f, -0.37388131f, -0.21929459f, 
    0.07683282f, -0.40788564f, 0.10382011f, 0.07246765f, 0.02715182f, 0.02269264f, 0.07152960f, 0.09043526f, 
    -0.09342846f, 0.09001146f, 0.00630276f, -0.09837151f, -0.05177689f, -0.34088019f, -0.06829494f, 0.02263129f, 
    0.13119373f, -0.21514346f, 0.25104976f, 0.10850221f, -0.48023897f, -0.65764499f, 0.09469891f, 0.21920307f, 
    0.10472544f, -0.04424251f, 0.00200146f, 0.02404706f, -0.11019313f, 0.01576708f, 0.08967833f, 0.06372175f, 
    0.06890213f, -0.11438639f, -0.14710557f, 0.27684373f, 0.19079709f, -0.13745040f, 0.15955769f, 0.11567937f, 
    0.23434727f, -0.05599049f, 0.32789242f, 0.19829650f, -0.09413316f, -0.05844320f, 0.14226317f, -0.35233027f, 
    -0.64604324f, 0.02284733f, -0.01478996f, -0.20322464f, -0.17992158f, 0.07499894f, 0.29352048f, -0.25129971f, 
    -0.34362549f, -0.23781091f, 0.27444914f, 0.23863065f, -0.00083554f, -0.02651812f, -0.11312889f, 0.21088423f, 
    0.27360484f, -0.09050506f, -0.11268401f, -0.07267350f, 0.01022355f, 0.01175851f, 0.05325933f, -0.03187275f, 
    0.09275449f, -0.23107818f, -0.27424404f, -0.06354600f, -0.05717335f, 0.13110568f, 0.06660139f, -0.00449539f, 
    0.20915037f, 0.11175512f, 0.08929718f, -0.19559322f, 0.07925704f, -0.11074270f, -0.12081355f, 0.04475595f, 
    -0.10856195f, -0.00545183f, 0.19378369f, -0.12003972f, 0.21535774f, 0.09777437f, -0.85442775f, -0.10468835f, 
    -0.08460990f, 0.02635201f, -0.14081983f, -0.40374860f, -0.13167661f, 0.09553638f, 0.11658462f, 0.09670225f, 
    -0.15706614f, -0.02567570f, -0.27472314f, 0.06632154f, 0.14131285f, 0.19349413f, -0.18744099f, 0.07919337f, 
    -0.08465561f, -0.02869545f, -0.10206664f, 0.25454602f, 0.10312295f, 0.11500372f, -0.22557171f, -0.00536853f, 
    0.05721996f, -0.25828978f, 0.29028657f, -0.29890162f, -0.02991375f, 0.12707362f, 0.03145713f, -0.04296890f, 
    0.13035282f, 0.22753273f, 0.21898311f, 0.03805467f, -0.15347357f, -0.02203511f, -0.00616918f, -0.10509582f, 
    -0.11818118f, -0.36072981f, 0.29366896f, 0.06815214f, 0.25096592f, -0.68469059f, 0.02522778f, 0.15986554f, 
    -0.04919507f, -0.01975690f, 0.16983996f, -0.33550277f, -0.18393053f, -0.30358052f, -0.12948360f, 0.06268550f, 
    0.21909423f, 0.05315610f, 0.24571666f, -0.65579158f, 0.31099370f, 0.17544909f, -0.25006038f, -0.07578238f, 
    0.23964766f, 0.09313521f, -0.22864315f, -0.49781436f, 0.01363331f, 0.17507967f, -0.23935238f, 0.04908367f, 
    -0.62318808f, 0.07775706f, -0.67912859f, -0.19739479f, 0.03792502f, -0.12438903f, 0.00203001f, -0.11666647f, 
    0.02891730f, 0.11139363f, 0.23345736f, -0.27953538f, 0.03720507f, 0.12771818f, -0.36713681f, -0.26465946f, 
    -0.12110564f, 0.34901679f, 0.03143436f, 0.12512271f, 0.03218755f, 0.20236504f, -0.17161426f, 0.26245162f, 
    -0.34236163f, -0.19218010f, -0.15615295f, -0.11622101f, -0.24923129f, -0.07145117f, 0.06137487f, -0.00581488f, 
    -0.05641703f, -0.20308565f, -0.15615128f, 0.05323255f, -0.20877133f, -0.03375803f, -0.11123618f, 0.06454033f, 
    -0.20496966f, 0.05637606f, -0.40164322f, -0.06268677f, 0.16394153f, 0.01007249f, -0.33716178f, -0.33662248f, 
    0.04561242f, 0.01387648f, -0.20752124f, -0.05962173f, 0.19281182f, -0.06929009f, -0.19980247f, -0.09591223f, 
    -0.30674791f, 0.19451797f, -0.19398509f, 0.05799009f, 0.05931775f, -0.37045422f, 0.11063739f, 0.24708265f, 
    -0.13322413f, -0.00527660f, 0.36508435f, -0.13374180f, -0.17005423f, 0.22173680f, 0.01254876f, 0.36063090f, 
    -0.01535269f, 0.11467732f, -0.25772411f, -0.14524333f, 0.02516833f, -0.12709704f, -0.53342468f, 0.10853127f, 
    -0.02728332f, 0.18948953f, -0.02758569f, 0.09129168f, 0.05038096f, -0.16751376f, -0.14129670f, -0.40633696f, 
    -0.27733657f, -0.21939680f, -0.27094543f, -0.07983503f, -0.22157387f, 0.07118651f, -0.06213322f, 0.04189854f, 
    -0.10850264f, 0.16295873f, -0.27334124f, -0.45854080f, 0.01572478f, 0.29069790f, 0.07261328f, 0.03863296f, 
    -0.06255016f, -0.30387437f, 0.15989251f, 0.11241315f, 0.12185566f, 0.10725364f, 0.20776783f, -0.00635219f, 
    0.10150213f, 0.02965745f, -0.16187486f, 0.33017340f, -0.27510133f, -0.57054889f, 0.16046301f, -0.02593601f, 
    -0.11885129f, -0.20549187f, -0.04408336f, -0.02720324f, -0.00543822f, -0.07179829f, -0.35472763f, -0.26480466f, 
    0.00510405f, 0.10917478f, -0.03591007f, 0.13624647f, 0.01572406f, 0.37100062f, 0.06621175f, -0.06906504f, 
    -0.11921688f, -0.51854140f, 0.22990003f, 0.28375971f, 0.07088508f, -0.27300429f, -0.03270412f, 0.16185331f, 
    -0.11627142f, -0.12723431f, -0.17925099f, -0.19938204f, -0.04591622f, -0.15748622f, 0.23251390f, -0.14510339f, 
    0.22136800f, 0.18396047f, -0.01445793f, -0.06951416f, 0.19228888f, -0.00337617f, -0.03228901f, 0.27646291f, 
    -0.13065872f, -0.05287734f, -0.00894971f, -0.39313793f, -0.10385176f, -0.11391455f, -0.04829945f, -0.15540347f, 
    -0.00201502f, 0.05432070f, -0.04845351f, -0.15091039f, 0.27515656f, -0.35003993f, 0.02455116f, -0.44501704f, 
    -0.15705064f, 0.05293180f, -0.26022720f, 0.32069963f, 0.11287499f, -0.32446897f, 0.17005643f, -0.00801103f, 
    0.11718047f, 0.29075032f, -0.32769549f, -0.04271343f, 0.13123699f, 0.10373804f, 0.07914630f, 0.12720813f, 
    -0.00996248f, -0.03300605f, -0.01694166f, -0.30153942f, 0.17243278f, -0.39349368f, 0.09634063f, 0.03190404f, 
    0.08689043f, 0.15869124f, -0.28130332f, -0.18419407f, 0.12864229f, -0.38118654f, 0.11134811f, -0.27216643f, 
    0.29173896f, 0.13677993f, 0.13199016f, 0.10189976f, 0.09673363f, -0.08479028f, -0.24899074f, 0.00653602f, 
    -0.15078488f, -0.11235489f, 0.15755297f, 0.08240510f, -0.24212350f, -0.02950667f, -0.08168363f, 0.04854316f, 
    0.02750476f, -0.05982248f, 0.14735207f, -0.12897453f, -0.11961237f, 0.31609511f, -0.02409405f, 0.28290930f, 
    -0.18051746f, 0.18334700f, -0.27959079f, -0.05577750f, -0.24366744f, 0.13466991f, -0.27492177f, 0.04794940f, 
    -0.13951030f, -0.00064931f, 0.01076314f, 0.03715454f, -0.11916556f, -0.00110813f, -0.04551429f, 0.01873527f, 
    0.13035616f, -0.06554577f, 0.02073688f, 0.15639000f, -0.49486452f, -0.24015136f, 0.04301378f, -0.13680179f, 
    -0.55676496f, 0.07757365f, 0.19883160f, -0.39877278f, -0.53024286f, -0.42056936f, 0.20119761f, -0.26258317f, 
    0.29348665f, -0.09570168f, 0.08799053f, 0.00774951f, -0.23314048f, -0.18312839f, -0.06872369f, 0.15580182f, 
    -0.27057913f, 0.16631144f, -0.12198091f, -0.48089477f, 0.00865998f, 0.06051776f, -0.45678347f, 0.02317960f, 
    -0.32404861f, 0.40820587f, 0.06429678f, -0.06616363f, 0.22922711f, 0.11996253f, 0.06845959f, 0.20320292f, 
    -0.09295234f, 0.03628796f, 0.21357167f, -0.08252122f, 0.09206416f, 0.01243311f, -0.03710398f, 0.08121990f, 
    0.26833114f, -0.22393896f, 0.01047029f, 0.21477859f, -0.15208997f, -0.21579419f, -0.05741419f, 0.03169254f, 
    -0.02981453f, 0.07878778f, 0.25452295f, -0.46512222f, -0.20412472f, -0.05271048f, -0.20853724f, 0.04447659f, 
    0.11483759f, -0.25772059f, -0.28246850f, -0.31875321f, -0.08103272f, 0.09658505f, 0.03342677f, 0.27193239f, 
    -0.01716297f, 0.07304695f, -0.35521013f, -0.04952803f, -0.23333311f, 0.02393041f, -0.16014382f, -0.14602137f, 
    0.05822846f, 0.19808112f, 0.16226605f, -0.12349752f, -0.14757434f, 0.05977941f, 0.14302889f, -0.20667034f, 
    0.40575179f, 0.06674104f, -0.35837463f, -0.03644355f, 0.00190636f, -0.16322410f, 0.16002700f, 0.11076967f, 
    0.08777582f, -0.31364980f, 0.33902022f, 0.04543187f, 0.14032744f, 0.03199008f, 0.07412524f, 0.09441713f, 
    0.01952188f, 0.16722240f, 0.07647965f, 0.28906843f, -0.48720673f, -0.05658169f, -0.00461171f, -0.27372718f, 
    -0.34775281f, -0.19106281f, -0.02329306f, 0.08802924f, 0.11380380f, -0.32673603f, 0.16169316f, -0.01663550f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10685843f, 0.00220840f, -0.00386371f, 0.09957932f, -0.05754285f, 0.04219326f, 0.16363853f, -0.06023342f, 
    0.00899152f, 0.04266068f, 0.12684266f, -0.06894513f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
