#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.60146713f, -0.99040622f, -1.04121184f, -0.76799333f, -0.75664902f, 0.13513154f, 0.25953799f, 0.43118769f, 
    0.84649992f, 0.60643446f, -0.47353238f, -0.47506607f, -0.27165765f, -0.29058295f, -0.18191609f, 0.46590090f, 
    0.26163262f, 0.17323695f, 0.11807007f, 0.24646698f, 0.50979644f, -0.29285792f, 0.15707611f, -0.14472626f, 
    0.03442898f, 0.77748495f, -0.05800789f, 0.70385128f, 0.17170161f, 1.26517320f, -0.93170023f, 0.73669440f, 
    1.03738713f, -0.47845718f, 0.51399899f, -0.30378598f, -0.36681744f, 0.13309622f, 0.29742599f, 0.23076460f, 
    -0.30982658f, -0.03559782f, -0.11037228f, 0.65185565f, -0.25329116f, 0.23748715f, -0.53336096f, -0.44866443f, 
    -0.27428350f, 0.31459936f, 1.79716158f, 0.84998208f, -0.98510420f, -1.33681202f, -1.20679152f, -0.25010341f, 
    0.08114944f, 0.23493235f, -0.14968784f, -0.15825626f, 0.07659150f, 0.11875195f, 0.19824927f, 0.20691292f, 
    0.24574105f, -0.02839648f, -0.01832199f, -0.39534783f, -0.08177762f, 0.20082279f, 0.27660641f, 0.37597525f, 
    0.33203769f, 0.27533704f, -0.21666302f, -1.14988482f, 0.81962150f, -0.68366969f, 0.05809146f, 1.29141569f, 
    -0.34360251f, 0.31584921f, 0.11300929f, 0.09649046f, -0.76130974f, 0.27788240f, 0.06686024f, 0.38563114f, 
    0.23914699f, 0.56726825f, 0.45299956f, -0.10395426f, -0.46601096f, 0.36715615f, 0.20411465f, -0.32502469f, 
    0.09644271f, -0.19140312f, 0.46532241f, 0.10573769f, 0.92343897f, -0.09342504f, 0.91955358f, 1.14701343f, 
    1.34131920f, 1.11786461f, -0.45692870f, -0.14739566f, -0.11462703f, -0.07561409f, 0.26334140f, 0.06262259f, 
    0.00518843f, 0.28567228f, 0.13725320f, 0.43746865f, 0.12283719f, 0.40789852f, 0.59945011f, 0.20623010f, 
    0.42151138f, 0.22584365f, -0.04339183f, -0.04239137f, 0.24810061f, -1.50232053f, 0.55410343f, -0.38468120f, 
    -0.99156481f, -1.08279991f, 1.46831095f, 0.77002400f, -0.37320033f, 0.65523332f, 0.40514645f, 0.17988078f, 
    -0.11982787f, 0.41792297f, 0.29835343f, -0.12729740f, -0.08769531f, -0.17374370f, 0.00632776f, 0.08368772f, 
    -0.09730197f, -0.29076287f, -0.28069681f, 0.27207825f, 0.12744687f, 0.27039203f, 1.49695206f, 0.76795971f, 
    -0.24832846f, 0.84002674f, 1.26060343f, -0.41364935f, -0.09150798f, -0.40366045f, 0.91503990f, 0.60987830f, 
    -0.33245808f, 0.37452990f, -0.11256718f, -0.18879725f, -0.28848433f, -0.35796103f, -0.34970954f, -0.28219205f, 
    -0.31692615f, -0.46832514f, 0.20726515f, -0.06894514f, 0.41792029f, 0.06912749f, 0.32705253f, 0.36327150f, 
    0.19661473f, -1.23322284f, -0.89014786f, 1.00397360f, 0.76300091f, -1.08016789f, -0.72204864f, -0.74107015f, 
    -0.19045566f, 0.56635970f, -0.02524844f, -0.22084871f, 0.12953167f, -0.20106962f, 0.05547246f, 0.35182413f, 
    0.06805007f, 0.13517475f, 0.14124404f, 0.36260748f, 0.14431928f, 0.07650102f, 0.00606484f, 0.13876034f, 
    -0.21078373f, 0.68177974f, -0.06134722f, 0.40003613f, 0.46175426f, -1.05654168f, -1.02204657f, -1.30460882f, 
    -0.72543555f, -0.27929941f, 0.27950850f, 0.08208725f, 0.54936790f, -0.02104352f, 0.35511333f, -0.42091638f, 
    -0.03876569f, 0.26972184f, -0.03926091f, 0.37491798f, 0.67313498f, 0.15555446f, -0.05635905f, -0.20225826f, 
    0.49536943f, 0.75029254f, -1.48886192f, -0.81087577f, 0.84542537f, 0.90535009f, 1.25344861f, 0.88104701f, 
    0.56960261f, 0.64613205f, 0.22908257f, -0.28472188f, 0.22552568f, -0.71707922f, 0.43369967f, 0.12609057f, 
    -0.13346180f, -0.21571855f, 0.19651319f, 0.05020124f, 0.02976723f, -0.11048724f, -0.19103220f, -0.20479159f, 
    -0.03775571f, -0.13482425f, 1.12227523f, 0.70274174f, -0.43183357f, 1.40598750f, -0.23233031f, 0.25800362f, 
    0.65862632f, -0.16298400f, 0.58808881f, 0.63009495f, -0.01343839f, 0.06608393f, 0.50722659f, 0.30683482f, 
    0.45506069f, 0.21296221f, 0.25404572f, 0.43864644f, -0.14103353f, 0.59069908f, 0.23450845f, -0.08956485f, 
    -0.28429875f, -0.45400959f, 0.43620220f, 0.55487204f, -0.27732006f, -1.34558892f, -1.53501618f, 0.01327329f, 
    0.14864650f, -0.00722671f, -0.52043289f, 0.49114412f, 0.62072468f, -0.75039208f, -0.02776524f, 0.10200404f, 
    0.22994652f, -0.56862909f, -0.23927891f, 0.18153475f, 0.11667999f, 0.00483679f, -0.06650525f, -0.07656529f, 
    -0.04659794f, -0.25923371f, -0.01994704f, 0.38815421f, -0.80263913f, -0.22419174f, -0.19700551f, -0.92807817f, 
    -0.10672104f, -0.49691710f, 0.73679179f, -0.58845812f, -0.68596679f, -0.91764784f, -0.67616004f, 0.48349598f, 
    -0.17592928f, -0.05358107f, -1.00557947f, -0.50580049f, -0.01028497f, 0.46346220f, -0.00875275f, 0.10490207f, 
    0.17444918f, -0.18658864f, -0.46397236f, -0.15617895f, 0.00323868f, -0.99220294f, -1.82455587f, -0.81953740f, 
    0.04055850f, -0.48372933f, -1.02995908f, 1.11630905f, 0.95439923f, -0.47719789f, 0.01005070f, 0.29522491f, 
    -0.24554859f, 0.16257557f, 0.44878462f, -0.11121799f, -0.07783081f, -0.14295824f, -0.03650897f, -0.40695497f, 
    -0.22112924f, 0.07117734f, 0.13837253f, 0.19812238f, -0.05728929f, 0.26205537f, 1.68051529f, 1.07871342f, 
    1.19763672f, -0.23380144f, -0.48493695f, -0.37807074f, -0.13227654f, -0.47695822f, 0.26119575f, 0.83912790f, 
    0.15292631f, 0.33958051f, -0.09369922f, -0.04881119f, 0.02484962f, 0.16768064f, -0.09252605f, 0.73351544f, 
    0.05876218f, -0.27860567f, -0.09184732f, 0.32784140f, -0.32306409f, -0.24043098f, 0.07610852f, 1.50953102f, 
    0.73639184f, 0.90160036f, 1.05530047f, -0.11249185f, 0.42613348f, -0.61101580f, 0.14430328f, -0.18625700f, 
    -0.41369382f, -0.12495939f, -0.46068743f, -0.61225933f, -0.03354860f, 0.04560158f, -0.03111930f, -0.27904671f, 
    -0.19085678f, -0.12589560f, -0.11867748f, 0.34844658f, 0.03771087f, 0.27788550f, -0.20893870f, -0.06918263f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.32277989f, 0.25246677f, 0.30114371f, 0.15058675f, 0.02541377f, -0.06239457f, 0.24634241f, 0.19768678f, 
    0.46192968f, 0.18498170f, 0.63265431f, 0.16412033f, 0.22382064f, 0.15585393f, 0.15625814f, 0.21359888f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.33655530f, 0.24840051f, -0.21828863f, -0.54617828f, 0.12670469f, 0.21014379f, 0.08372922f, 0.08503903f, 
    0.04377740f, 0.05509252f, -0.02586230f, 0.28518704f, 0.10950139f, 0.12614834f, -0.13172598f, -0.36764747f, 
    -0.29256338f, 0.14252147f, -0.20130019f, -0.09691004f, 0.19067767f, -0.13244545f, -0.04785715f, -0.02316516f, 
    -0.77958041f, -0.11144917f, 0.22530152f, -0.62103093f, -0.24705644f, 0.05497653f, 0.02011728f, -0.04119184f, 
    -0.19383477f, -0.04191061f, -0.14283344f, 0.09226657f, -0.10990056f, 0.46484861f, 0.23843142f, -0.01888347f, 
    -0.20075978f, 0.01371905f, -0.06246408f, 0.22541718f, 0.21953917f, 0.06696783f, -0.04407031f, 0.05885413f, 
    0.22182418f, -0.39278936f, -0.04506724f, 0.30985329f, -0.08159913f, 0.05828969f, 0.08084131f, -0.03932507f, 
    -0.03921017f, 0.16100194f, -0.07329100f, -0.04532642f, 0.93847448f, 0.07189330f, -0.06520007f, -0.38647801f, 
    0.09640097f, 0.03247248f, -0.03420299f, 0.10126296f, -0.00452379f, -0.19171877f, -0.14599800f, 0.07205343f, 
    0.31438568f, -0.05853857f, 0.26871318f, 0.36670330f, -0.25843892f, -0.19960977f, -0.11108774f, 0.12256663f, 
    -0.17989251f, 0.29295772f, 0.19908214f, -0.19492815f, 0.10253566f, -0.48578796f, 0.64711440f, -0.16246548f, 
    -0.13291122f, 0.04759462f, 0.15675680f, -0.05319073f, 0.02685941f, -0.05458149f, 0.23604318f, 0.08971336f, 
    -0.11561033f, -0.02739719f, 0.12778923f, 0.01791844f, -0.16655703f, -0.13946421f, 0.04724701f, -0.00409747f, 
    -0.13612367f, -0.07559519f, -0.13024068f, 0.16448241f, -0.08965746f, 0.17570487f, -0.10595986f, 0.22327355f, 
    0.00718684f, 0.11976416f, -0.10516503f, -0.11842954f, -0.10861877f, -0.02431754f, -0.00442001f, -0.02416327f, 
    -0.10535194f, 0.02825560f, -0.22989909f, 0.16912010f, -0.32606766f, -0.10546112f, -0.12263865f, 0.11285940f, 
    0.18237402f, 0.00639858f, -0.00766432f, 0.30244365f, 0.16862224f, -0.16436353f, 0.21628235f, -0.72210467f, 
    0.17933883f, -0.10855842f, 0.33227062f, -0.07458181f, -0.08774891f, 0.07749078f, 0.07350359f, 0.08886431f, 
    -0.88543266f, 0.00132126f, -0.02579868f, 0.08787982f, -0.05238143f, -0.10487463f, 0.07948584f, 0.11303475f, 
    -0.16102254f, -0.00585494f, -0.03025582f, -0.08615807f, -0.66140151f, 0.27079201f, -0.04409766f, -0.06292523f, 
    -0.09409846f, -0.04939874f, -0.02391536f, -0.02751057f, 0.17810051f, 0.13869864f, -0.14755398f, 0.02787989f, 
    0.09630040f, 0.21896185f, -0.18574351f, -0.11111235f, -0.15236641f, -0.31447583f, -0.06954509f, 0.12413723f, 
    0.04592053f, 0.17007172f, -0.18200660f, -0.08594359f, 0.42202249f, -0.20367157f, -0.11003321f, 0.15116185f, 
    -0.32685527f, -0.00435859f, -0.16822076f, 0.23404123f, -0.12488443f, -0.04095642f, -0.22347763f, -0.29555720f, 
    0.10517561f, -0.12629966f, 0.03404174f, -0.42202285f, 0.14653125f, -0.00939818f, 0.00116156f, 0.17766613f, 
    0.31509927f, 0.05733499f, -0.15487581f, 0.08471107f, 0.13470028f, 0.12285644f, -0.02098620f, 0.08400508f, 
    0.11177575f, 0.15746291f, -0.22557411f, 0.22337593f, 0.06570204f, 0.19150537f, -0.09165301f, -0.07364684f, 
    0.60532773f, -0.35072514f, 0.19082475f, -0.55344003f, -0.17589740f, -0.12599979f, -0.10736316f, 0.13324276f, 
    -0.26316217f, 0.05517618f, -0.03055470f, 0.06205453f, -0.17317392f, -0.05082584f, -0.20974672f, -0.21275842f, 
    -0.05324339f, 0.18545130f, 0.07720467f, -0.20558272f, -0.10037018f, 0.08310695f, -0.25186422f, 0.04706132f, 
    0.41452509f, -0.07818106f, 0.20020655f, 0.15461521f, -0.23538162f, 0.00984814f, -0.06751194f, 0.11527037f, 
    0.10536747f, 0.11927167f, 0.14266254f, 0.15745512f, -0.93190420f, -0.39995372f, -0.07473725f, -0.28433761f, 
    -0.01264866f, 0.02371786f, 0.17622423f, -0.17512600f, 0.04265979f, -0.00774939f, -0.12971504f, 0.02195638f, 
    0.47399840f, 0.00295865f, 0.15119497f, 0.58140373f, 0.01517321f, -0.00794953f, 0.21839117f, 0.16020705f, 
    0.03622345f, -0.16897149f, -0.31061691f, 0.03890751f, 0.08781785f, -0.13073578f, -0.13415165f, -0.64934158f, 
    -0.17770219f, -0.04425304f, 0.07108989f, 0.04558643f, -0.02887763f, 0.16588996f, 0.00449334f, -0.12860505f, 
    -0.35081729f, -0.23799767f, -0.21962999f, -0.12663287f, 0.06333014f, -0.05869364f, -0.02272354f, -0.17515767f, 
    -0.02984790f, 0.13507992f, 0.19453555f, -0.00212040f, 0.79646742f, -0.49458522f, -0.05558296f, -0.04517532f, 
    0.02115415f, 0.19736697f, -0.33207226f, 0.01391199f, 0.05657296f, 0.16216719f, -0.00052123f, 0.07048188f, 
    0.53570300f, -0.13225450f, -0.14060964f, 0.11849904f, -0.08319321f, -0.23969342f, -0.08230185f, 0.11209954f, 
    -0.11639423f, 0.09618037f, 0.03932825f, 0.04560543f, 0.16405191f, -0.21727964f, 0.32641003f, -0.63470501f, 
    0.17451531f, -0.04321435f, -0.08554380f, 0.14227977f, -0.26540434f, -0.19599812f, 0.16640525f, -0.32068130f, 
    0.08223183f, -0.13289802f, -0.36836803f, -0.15207356f, 0.04071558f, -0.09069200f, -0.12394300f, 0.13327754f, 
    0.03018709f, 0.01179988f, 0.04882713f, -0.17424527f, 0.23913532f, -0.29820356f, -0.29473257f, 0.22288987f, 
    -0.16299739f, -0.08663037f, -0.11510692f, 0.17963284f, 0.01121978f, -0.27046949f, 0.02500342f, 0.05030734f, 
    0.41519415f, -0.00424946f, -0.16840273f, 0.02002695f, 0.03786694f, -0.13272604f, 0.11879757f, -0.01425478f, 
    0.02419703f, -0.30676794f, -0.09935861f, 0.00837851f, 0.06273009f, 0.14745182f, 0.25792587f, 0.32585227f, 
    -0.16626145f, -0.06593363f, 0.10974133f, 0.04493642f, -0.04807813f, -0.02678471f, -0.05032976f, 0.08704425f, 
    0.07379632f, -0.08487066f, 0.00733106f, 0.61211020f, -0.13235073f, -0.06300436f, -0.17739293f, 0.11603483f, 
    -0.02679373f, -0.09524973f, 0.07561284f, 0.02824079f, 0.21201780f, 0.06372231f, -0.13782842f, -0.13313207f, 
    0.26711503f, -0.11729478f, 0.30344301f, 0.04874543f, -0.07450992f, -0.17583500f, -0.09167198f, 0.15770505f, 
    -0.75880206f, 0.26563317f, -0.06988204f, -0.42514947f, 0.07819692f, -0.50696623f, 0.27379212f, -0.05099817f, 
    -0.19641177f, -0.23121656f, 0.00392937f, 0.05749693f, 0.48698562f, -0.12728405f, -0.16232535f, -0.23267123f, 
    0.10194401f, 0.10657612f, -0.01378218f, -0.33137572f, -0.05536062f, 0.01140804f, 0.05347135f, -0.08083399f, 
    -0.25252607f, -0.15878057f, 0.17635892f, 0.17433716f, 0.19368094f, 0.11521251f, -0.19988877f, -0.24091788f, 
    -0.03964444f, -0.25561914f, -0.10600916f, 0.02104654f, 0.89136904f, 0.40223399f, 0.12355373f, 0.02287778f, 
    0.03803133f, -0.32696605f, -0.30628207f, 0.18211168f, -0.23277034f, 0.28086695f, 0.08919038f, -0.15063600f, 
    0.21959552f, 0.23716204f, -0.16255163f, -0.10246953f, 0.15572028f, -0.13674590f, -0.00827886f, -0.12379471f, 
    -0.22138399f, 0.27585536f, 0.14183630f, -0.04398828f, -0.87462384f, -0.41207212f, -0.17733115f, -0.35561836f, 
    0.20249955f, 0.00468453f, -0.00107699f, -0.13537936f, -0.06559971f, -0.19607973f, -0.08681119f, -0.17053677f, 
    0.10487660f, 0.28803802f, -0.22831464f, -0.31197214f, 0.08244023f, 0.08093647f, -0.07361764f, -0.16855772f, 
    -0.07385512f, 0.02544163f, -0.12980457f, -0.00603264f, -0.14689237f, -0.18057014f, 0.29020947f, -0.03158294f, 
    -0.02565024f, 0.01007111f, -0.29819801f, 0.24473459f, 0.00596513f, -0.13355103f, 0.11597912f, -0.00520933f, 
    0.42214295f, -0.29817542f, 0.19227350f, -0.07445769f, 0.09404308f, 0.09654257f, 0.03005549f, -0.05735543f, 
    -0.12068847f, 0.08676271f, -0.05484571f, 0.12664779f, -0.47502038f, -0.16084269f, -0.03741972f, 0.05322556f, 
    0.04153752f, -0.08996654f, -0.00648657f, -0.03543784f, -0.14159654f, 0.11128628f, -0.13706107f, 0.15239967f, 
    -0.05695080f, 0.14731875f, -0.38859919f, -0.36615250f, -0.11983500f, -0.10329627f, -0.09576442f, -0.12890282f, 
    0.20128539f, 0.12553142f, -0.11225413f, 0.12476309f, 0.94742399f, 0.11614987f, -0.06722991f, 0.47024587f, 
    -0.43180352f, 0.03290469f, 0.07646140f, 0.09722067f, -0.08195522f, 0.03872867f, 0.11792562f, -0.04517261f, 
    -0.34538209f, 0.13031352f, 0.17247792f, -0.16974047f, -0.02911225f, 0.06311522f, 0.04010510f, 0.10764745f, 
    -0.06103262f, -0.10652802f, -0.03238541f, -0.14912163f, -0.39495298f, 0.06186111f, -0.25584185f, -0.16719386f, 
    0.21807350f, 0.01652450f, -0.06497013f, -0.13942198f, 0.09142119f, 0.15382589f, 0.03582033f, -0.07830133f, 
    -0.23200078f, -0.21890955f, -0.03336215f, -0.33598852f, -0.07889763f, -0.13474579f, 0.06508920f, -0.02545679f, 
    0.00777636f, 0.06970616f, 0.09704603f, 0.03508233f, -0.82350844f, -0.30867383f, 0.35193393f, 0.11753755f, 
    -0.09306697f, 0.12832940f, 0.19155802f, -0.02845639f, -0.19889075f, -0.04697241f, -0.01203524f, 0.00256697f, 
    0.16946596f, -0.74895716f, 0.11667497f, 0.05922186f, -0.14969729f, -0.09711085f, 0.00543414f, 0.29023373f, 
    -0.14283852f, 0.13885292f, -0.01423224f, 0.05427657f, 0.10511690f, 0.54797953f, 0.17150135f, -0.20013170f, 
    0.11559591f, 0.10365617f, 0.09354363f, 0.30514067f, 0.17450716f, -0.09633306f, -0.18596296f, 0.04899838f, 
    -0.43669423f, -0.39905566f, -0.16812460f, 0.52304840f, -0.14191063f, 0.13922547f, -0.07564970f, -0.10217363f, 
    -0.03873914f, -0.24061231f, -0.13052973f, -0.11355818f, -0.35952547f, 0.52069080f, -0.06116733f, -0.45211902f, 
    -0.04923549f, 0.07112228f, -0.03308864f, 0.04445574f, -0.00835295f, -0.18815626f, -0.01783037f, 0.04231311f, 
    0.29553589f, -0.54299927f, -0.52126926f, 0.05639534f, -0.01922047f, 0.04022939f, -0.14771403f, -0.13838175f, 
    -0.05696877f, -0.05781901f, -0.11454390f, 0.13787355f, 0.52293253f, 0.49107733f, -0.02282737f, 0.21172830f, 
    -0.02687047f, 0.28000376f, -0.05028552f, -0.20997497f, 0.00121322f, -0.12501198f, -0.07713308f, -0.11349097f, 
    0.26384112f, 0.20420913f, 0.16841651f, 0.34628832f, 0.27018124f, 0.15755060f, 0.16594981f, -0.01640376f, 
    0.04062737f, 0.06668076f, -0.16646756f, -0.15751594f, 0.05548650f, 0.06017391f, -0.18636002f, 0.03118430f, 
    0.07267977f, 0.10484891f, 0.15428855f, -0.30565205f, 0.10218196f, -0.13298443f, 0.25065255f, -0.02311662f, 
    -0.07868904f, -0.20341970f, -0.41319132f, -0.24927065f, -0.27043128f, -0.13125499f, 0.18397698f, -0.10936893f, 
    0.04283289f, -0.19068874f, 0.09035125f, 0.00450668f, -0.00205236f, 0.09071718f, 0.22651178f, 0.10219791f, 
    -0.22957759f, -0.22448973f, -0.01925401f, -0.14605860f, 0.04066960f, 0.10893957f, 0.05490934f, 0.22225620f, 
    -0.06008642f, 0.43242031f, 0.22910166f, 0.04138008f, -0.12524346f, 0.05267445f, 0.05116730f, 0.17864396f, 
    0.09045546f, 0.14205092f, 0.02136295f, 0.33134562f, 0.39507964f, -0.17377087f, 0.11393239f, 0.00966547f, 
    -0.08588941f, -0.24996577f, 0.08649901f, -0.07327870f, -0.18963753f, 0.13012369f, -0.29455665f, 0.08791879f, 
    -0.86411536f, -0.22935277f, -0.43381655f, 0.28142452f, -0.14183383f, 0.16868615f, -0.00262856f, -0.00677581f, 
    -0.15029161f, 0.01604144f, -0.05476599f, 0.13827550f, 0.20112085f, -1.06870067f, -0.34673432f, 0.11723240f, 
    -0.26255482f, -0.22074451f, -0.12365720f, 0.01386209f, -0.01147866f, 0.04428709f, 0.08193121f, -0.07953952f, 
    -0.42570275f, -0.35046503f, 0.03976924f, 0.54364902f, 0.14227065f, -0.23826589f, -0.12799804f, 0.11380656f, 
    -0.06462882f, -0.09164065f, 0.10895391f, 0.04785883f, -0.05668646f, 0.08429154f, -0.17056455f, -0.04524776f, 
    -0.13031754f, -0.37076455f, -0.01525889f, 0.02727950f, -0.07974663f, -0.08319174f, 0.17011181f, 0.03845492f, 
    0.19298626f, -0.41624513f, -0.12897234f, -0.04983046f, -0.13672628f, 0.04434373f, 0.00208956f, -0.14759608f, 
    -0.00881710f, 0.13320671f, 0.09566883f, -0.00707043f, 0.04061675f, 0.11305844f, -0.20213072f, -0.04546164f, 
    -0.00796613f, -0.17257178f, -0.13469930f, -0.03357983f, -0.00149415f, -0.04120763f, -0.08205794f, -0.08180012f, 
    -0.10841502f, 0.25077581f, 0.03861600f, -0.07452973f, 0.09892122f, 0.01724902f, 0.17621285f, 0.28319272f, 
    0.21410875f, -0.19317347f, -0.20826718f, -0.28885883f, 0.13911179f, 0.05677914f, -0.10676849f, 0.18845290f, 
    0.15304235f, 0.05279797f, 0.03800045f, 0.01784541f, -0.03176085f, 0.20227368f, 0.00920213f, -0.06264178f, 
    0.25772598f, -0.31613982f, 0.31024751f, 0.16848332f, -0.25572708f, -0.02597017f, 0.00143725f, -0.08796051f, 
    -0.02664457f, -0.00410652f, -0.16109908f, 0.08055693f, -0.23433179f, 0.08263374f, -0.34277281f, 0.26750579f, 
    0.09520316f, -0.07146082f, -0.04820896f, -0.07603786f, -0.13447650f, -0.12119853f, 0.05356903f, -0.07689866f, 
    -0.43533716f, -0.32596666f, 0.34845912f, 0.14898193f, -0.08724002f, 0.16154698f, -0.15125820f, -0.10341551f, 
    0.39269164f, -0.19683026f, -0.13712671f, 0.06568106f, -0.66967559f, 0.30378512f, -0.42699376f, 0.14002475f, 
    0.00994172f, -0.06917722f, 0.26940244f, -0.15123200f, -0.07817792f, -0.11322314f, 0.08256133f, 0.07182430f, 
    -0.10122009f, -0.26262793f, -0.09070543f, 0.10477113f, 0.01144587f, 0.19430393f, 0.31349826f, 0.02664712f, 
    -0.03755188f, 0.03492453f, -0.01388660f, -0.20133232f, -0.09314220f, 0.00162309f, -0.01991472f, 0.39336616f, 
    -0.10120976f, -0.19595130f, 0.05138552f, 0.04773204f, 0.06455240f, -0.04665988f, -0.17408647f, 0.02887625f, 
    -0.02840259f, 0.21252197f, 0.53239465f, -0.01102696f, 0.10310008f, -0.12983578f, -0.04046046f, 0.13690962f, 
    0.15133375f, 0.20922406f, -0.01228744f, 0.07090402f, -0.95618963f, 0.11483978f, -0.03868764f, -0.01102198f, 
    0.30141908f, 0.02927225f, -0.00762707f, 0.04534194f, -0.15831465f, -0.06660020f, -0.09565397f, 0.17889565f, 
    -0.58487058f, -0.49481401f, 0.15937968f, -0.26937062f, -0.30895013f, 0.16756618f, 0.07851414f, 0.09192861f, 
    0.20057482f, 0.02221635f, -0.03244555f, 0.05425743f, 0.17212616f, 0.16951953f, 0.52391487f, 0.01310751f, 
    0.02953687f, 0.11489800f, 0.07691641f, -0.01081224f, 0.11892414f, 0.04968332f, 0.27217674f, 0.03429480f, 
    0.27942964f, 0.07620175f, -0.31937304f, 0.18341292f, 0.22311911f, 0.17607497f, 0.04645341f, -0.36787003f, 
    -0.04879333f, -0.03830816f, -0.10506773f, -0.05169016f, 0.07024150f, 0.31747171f, 0.48858306f, -0.17999572f, 
    -0.05213674f, 0.11208642f, -0.12958652f, -0.16808534f, -0.09493276f, -0.08446210f, -0.08031249f, -0.28056505f, 
    0.11496133f, 0.28374770f, -0.05722615f, 0.11664378f, -0.09316757f, -0.07950519f, 0.15220992f, 0.21590748f, 
    0.02884780f, 0.07522629f, 0.03148046f, -0.17932846f, -0.22547029f, -0.25807726f, 0.28627750f, -0.15408106f, 
    -0.08865462f, 0.00516328f, 0.09078065f, -0.20415621f, -0.06829326f, -0.04042772f, 0.17043762f, 0.35047901f, 
    -0.06022640f, 0.03497713f, 0.18325229f, 0.10458677f, 0.08582702f, -0.01098794f, -0.07210336f, 0.08740614f, 
    0.09133250f, 0.20390333f, 0.05406868f, 0.42936265f, -0.48311597f, -0.14982067f, -0.09607267f, -0.14505124f, 
    0.01476903f, -0.03992038f, 0.12439025f, -0.17432873f, 0.06671698f, -0.28966978f, 0.07193808f, -0.08419984f, 
    0.02336848f, -0.12670916f, -0.08269432f, -0.28916237f, -0.22919995f, -0.08377936f, 0.06791267f, 0.08252306f, 
    0.23834294f, -0.23416865f, -0.01875773f, -0.20954549f, -0.24349478f, -0.04698277f, 0.26747954f, 0.10611645f, 
    -0.10295864f, -0.12281002f, 0.20180231f, 0.09934921f, -0.04009356f, 0.13006575f, -0.17075056f, 0.10696515f, 
    0.09548372f, -0.11223130f, -0.01991390f, 0.28023177f, -0.16843680f, -0.11108536f, 0.07407282f, 0.04804096f, 
    -0.34384462f, 0.10179961f, 0.13735744f, 0.26702410f, -0.49945310f, 0.40465075f, -0.06951132f, -0.42759421f, 
    0.16057082f, -0.23132882f, -0.35743430f, -0.11937144f, 0.10291986f, -0.07886828f, -0.04028687f, -0.16381374f, 
    0.17888789f, 0.13758326f, 0.33742368f, -0.31178871f, -0.03231474f, 0.01720597f, -0.21267040f, 0.08702917f, 
    -0.12519996f, -0.07753237f, 0.15460061f, 0.33305201f, 0.31737950f, -0.38452375f, -0.30277482f, -0.31856820f, 
    0.09851004f, 0.39111352f, -0.00325084f, -0.18160680f, 0.02581124f, -0.25769937f, 0.09442187f, -0.15108995f, 
    0.21409488f, -0.26943576f, -0.31007278f, 0.35318404f, 0.20209751f, 0.10257099f, 0.08027239f, 0.09100918f, 
    -0.03420698f, 0.08731075f, 0.22092718f, -0.10778786f, -1.12869275f, -0.28491682f, -0.37645370f, -0.14240733f, 
    0.21774778f, 0.00817390f, -0.06677186f, -0.03643403f, 0.19192727f, -0.01028574f, 0.01617493f, -0.03806907f, 
    0.30231506f, 0.04115116f, 0.12796687f, 0.11750300f, 0.21303582f, -0.04263462f, -0.01271003f, -0.01190167f, 
    -0.04699783f, -0.05449535f, 0.34864786f, 0.01171259f, -0.07557419f, -0.08256184f, -0.00048856f, 0.41397360f, 
    -0.11759209f, -0.10688402f, 0.16215619f, -0.00471158f, 0.06526761f, -0.00540954f, -0.27079001f, 0.08302563f, 
    -0.57251060f, -0.14375032f, -0.26250309f, -0.50782698f, -0.19347775f, -0.02313832f, -0.09078502f, 0.15755524f, 
    -0.10235908f, -0.02526037f, 0.16514145f, -0.01184770f, 0.31975585f, -0.04466336f, 0.43858242f, -0.05345117f, 
    -0.00093804f, 0.02799019f, 0.12426591f, 0.10231630f, 0.18631050f, 0.00484021f, -0.03256764f, 0.39641222f, 
    -0.23849283f, 0.03293177f, -0.43684202f, 0.47277662f, 0.16031992f, 0.22547840f, -0.08093334f, -0.10105516f, 
    0.07431813f, -0.27701828f, -0.09721135f, -0.05817023f, -0.33794481f, 0.01300248f, 0.22996822f, 0.40625596f, 
    -0.03876901f, -0.01193277f, 0.02371683f, -0.21108064f, 0.03092657f, -0.00839647f, -0.01096881f, -0.28775141f, 
    0.17465343f, 0.10569932f, 0.08852750f, -0.77752417f, -0.20162924f, 0.03546637f, 0.13679525f, 0.09049586f, 
    -0.02322633f, -0.13436055f, -0.13099122f, -0.32689822f, 0.21382730f, -0.23843631f, -0.21744782f, 0.27913648f, 
    -0.21602255f, 0.17999186f, 0.01536484f, 0.12834063f, -0.23387328f, 0.19859478f, -0.20351066f, -0.03353407f, 
    -0.73452657f, 0.36750355f, 0.32526037f, -0.31282228f, 0.00293711f, 0.13928984f, -0.16083331f, -0.01235354f, 
    -0.07278269f, 0.06945059f, 0.09991274f, 0.31433198f, 0.19238761f, -0.20643497f, -0.36511070f, -0.15509132f, 
    0.02689798f, -0.01811964f, -0.07787060f, 0.16745931f, -0.00573767f, -0.26454875f, -0.14335714f, -0.23051062f, 
    0.02449012f, 0.25441533f, -0.11115690f, 0.01363902f, 0.22382455f, 0.13289505f, 0.03591539f, 0.03136018f, 
    -0.05901306f, -0.19295590f, -0.12352585f, 0.07991517f, 0.05322948f, -0.89648664f, 0.16042656f, -0.35862347f, 
    -0.21575253f, 0.09378222f, 0.15228800f, 0.25342461f, 0.13417289f, -0.01421206f, -0.08727694f, 0.17803831f, 
    -0.11895139f, 0.44680753f, 0.15434408f, 0.03363456f, -0.23022939f, 0.07858568f, -0.07506232f, -0.05258787f, 
    0.06574644f, -0.02281181f, 0.02172929f, -0.33271152f, -0.18578780f, 0.08937642f, -0.02762902f, 0.18069994f, 
    0.03882864f, -0.01716707f, 0.02036513f, -0.07921182f, 0.11887563f, 0.05802595f, -0.11323678f, 0.08993341f, 
    0.14273064f, -0.45910361f, -0.28631845f, -0.01132991f, -0.10542392f, -0.12919484f, 0.18285437f, 0.03334109f, 
    0.01242452f, -0.11394575f, -0.19427447f, 0.27584264f, 0.15030259f, -0.29539847f, -0.08614278f, -0.27471533f, 
    -0.06376836f, -0.10429061f, 0.15506384f, -0.33072990f, 0.00751007f, -0.02752321f, 0.21830285f, 0.17266567f, 
    -0.33221397f, 0.50758874f, 0.17439108f, 0.38031575f, -0.05979304f, -0.03086217f, 0.01226972f, -0.07141624f, 
    0.16263495f, 0.23014255f, -0.09031721f, -0.12642510f, -0.25698090f, 0.31946552f, -0.03915143f, -0.51631248f, 
    0.00033296f, 0.14399903f, -0.02087800f, 0.17245707f, -0.01029225f, 0.08690374f, 0.12806894f, 0.17781846f, 
    0.01077196f, 0.41393304f, 0.16083863f, 0.51839149f, 0.26838630f, 0.30864498f, 0.08283652f, -0.19333577f, 
    -0.16096137f, -0.04769332f, 0.10412242f, -0.01224347f, 0.48118177f, -0.50403810f, -0.01056047f, 0.16573915f, 
    -0.23672156f, 0.01142893f, 0.13095687f, -0.32116607f, -0.09945087f, 0.10827956f, -0.09121401f, -0.04650316f, 
    -0.39899519f, 0.01503832f, -0.32689738f, 0.38527039f, -0.14060159f, 0.05315483f, -0.08547545f, -0.08768371f, 
    0.12724568f, 0.00026614f, 0.21323954f, -0.05827170f, -0.55104893f, -0.23737663f, 0.18849750f, -0.00442127f, 
    0.21263978f, -0.12026029f, -0.04048027f, 0.08977138f, 0.08324327f, -0.14685738f, 0.08635057f, -0.11244048f, 
    -0.43236712f, 0.28582147f, -0.52366990f, -0.14247492f, 0.09949603f, 0.03873378f, -0.09413866f, -0.17245053f, 
    -0.13513057f, 0.12337867f, -0.01559099f, -0.09269175f, -0.09054749f, 0.39251682f, 0.05457506f, 0.30846062f, 
    0.41849267f, -0.22825065f, 0.20137995f, 0.20310730f, 0.10611439f, 0.17055269f, 0.05641506f, 0.11102378f, 
    -0.70242184f, 0.12553936f, -0.29880163f, -0.33984500f, 0.24755193f, 0.03282760f, -0.22116588f, -0.13852456f, 
    -0.31461307f, 0.02111641f, 0.13924025f, -0.07651243f, -0.26031631f, 0.35832042f, -0.16929941f, 0.27391428f, 
    -0.02621328f, -0.02410791f, -0.21776335f, 0.09653016f, 0.08136411f, -0.16611207f, -0.11482105f, 0.09712266f, 
    -0.21333748f, -0.25433776f, 0.01275488f, 0.10437372f, -0.24785419f, -0.34930551f, -0.19980326f, 0.03376628f, 
    -0.14188629f, -0.16511494f, 0.03281870f, -0.10307373f, -0.02937021f, 0.13273472f, 0.21094550f, -0.19975044f, 
    -0.20405248f, -0.09530145f, -0.06447195f, -0.06923147f, -0.26198936f, 0.01584956f, -0.26847643f, -0.13723089f, 
    -0.44949394f, 0.47146943f, 0.11165390f, -0.18708882f, -0.17147088f, 0.15666486f, 0.07356021f, -0.09419982f, 
    0.05115909f, -0.08802952f, -0.01812692f, -0.06634758f, 0.30020025f, 0.32609230f, -0.15892762f, 0.42495868f, 
    0.12085775f, 0.04698166f, 0.01099319f, 0.02734601f, -0.13540903f, -0.02356492f, -0.01844931f, -0.10103253f, 
    0.13321468f, 0.04079980f, 0.37022546f, 0.07245464f, 0.21745959f, -0.00093181f, 0.12125066f, -0.15575919f, 
    -0.15666217f, -0.06975469f, -0.17425230f, -0.14494073f, 0.44352257f, 0.22889663f, 0.40458509f, -0.01215679f, 
    0.01357618f, 0.16076434f, -0.11978703f, -0.05387112f, -0.24003009f, 0.08937905f, -0.27262297f, -0.02659166f, 
    -0.22794139f, -0.23321640f, -0.70523244f, -0.36090580f, 0.02195375f, -0.09886590f, -0.03509778f, -0.07517655f, 
    -0.01235905f, -0.01089974f, 0.04016560f, -0.02002133f, -0.12997359f, 0.09684388f, -0.01147642f, -0.01428704f, 
    -0.26420513f, 0.06585465f, -0.02298708f, -0.13781001f, -0.05600987f, -0.11901614f, 0.06924895f, -0.06032885f, 
    -0.42387989f, -0.11811127f, 0.35307238f, 0.22587194f, -0.24993747f, 0.21149667f, -0.05932987f, 0.08824412f, 
    0.05360461f, -0.00621914f, -0.33820435f, -0.09481563f, 0.33429861f, 0.01063429f, -0.08698501f, 0.28705305f, 
    0.08653051f, -0.14073785f, -0.17507619f, -0.13536458f, 0.05359169f, 0.01620728f, 0.20587549f, -0.22395520f, 
    0.33684534f, 0.63515973f, -0.43393978f, -0.22200190f, 0.11302482f, -0.00354099f, -0.04074600f, -0.01887766f, 
    0.34365392f, 0.00804837f, -0.17155419f, 0.03642072f, -0.51904517f, -0.19173792f, -0.04765643f, 0.00556862f, 
    -0.19114080f, 0.10963674f, -0.12842572f, -0.24558735f, 0.14351474f, 0.03246603f, 0.08338586f, 0.15895015f, 
    -0.16963176f, -0.06069298f, 0.15831563f, 0.40346378f, -0.08641008f, -0.08758719f, -0.06567052f, -0.07410653f, 
    0.07732587f, 0.07802264f, 0.25760069f, 0.03067542f, 0.10048588f, 0.08142634f, 0.19060923f, 0.16106665f, 
    -0.07866549f, 0.02007781f, -0.02455584f, 0.05645352f, -0.10546241f, -0.26987907f, 0.18265441f, 0.01449952f, 
    -0.09238982f, -0.16607572f, 0.09408060f, 0.04405889f, 0.20482773f, 0.01770884f, -0.08576524f, -0.04093201f, 
    0.15477136f, -0.10591192f, 0.05588242f, -0.05403489f, -0.49128601f, 0.25679561f, -0.10405378f, -0.11631864f, 
    -0.28510630f, 0.15074769f, -0.11992871f, 0.10227989f, 0.28147641f, -0.02901425f, 0.13498650f, 0.33825502f, 
    -0.21122511f, -0.03188366f, -0.39462394f, -0.65318924f, -0.04445682f, 0.07054109f, -0.08289084f, 0.07478979f, 
    0.22766724f, 0.11540320f, 0.14368261f, 0.10730204f, 0.05354066f, 0.15065336f, 0.28952751f, 0.11591578f, 
    -0.28158966f, -0.27582407f, 0.15381148f, -0.03234196f, -0.08707059f, -0.08299886f, -0.02938159f, -0.16435735f, 
    0.30549309f, -0.12175331f, -0.12181893f, 0.25871009f, 0.01812831f, -0.08410983f, -0.09725320f, -0.21375456f, 
    -0.11713533f, 0.15706925f, 0.01796054f, -0.11456064f, -0.35194030f, 0.26839733f, -0.04740877f, -0.15808336f, 
    0.08907670f, 0.11153176f, -0.61160213f, 0.02216208f, 0.10936356f, -0.14257251f, 0.12997811f, -0.08902630f, 
    -0.41357419f, -0.37965837f, -0.19677600f, -0.61045635f, 0.15202677f, -0.16257308f, -0.41853446f, -0.33321345f, 
    0.13720839f, -0.02438433f, 0.09223688f, -0.18396899f, -0.19323911f, -0.18501794f, 0.23871440f, -0.31426880f, 
    0.13287878f, 0.08984601f, -0.02053980f, 0.15250097f, 0.01959033f, -0.27567407f, -0.04819940f, 0.03957331f, 
    0.08883964f, -0.17723021f, -0.45686820f, 0.02915202f, 0.29265189f, 0.11639651f, -0.15182719f, -0.07862745f, 
    -0.00641959f, -0.28429890f, 0.13633375f, 0.11177528f, -0.19853967f, 0.03672091f, 0.14957595f, 0.21209942f, 
    0.17396978f, -0.05508455f, 0.01260517f, -0.10935724f, 0.21319705f, 0.09437285f, -0.27825868f, -0.37187693f, 
    0.01150911f, -0.35247844f, -0.13385998f, -0.28207108f, 0.03298343f, 0.05875370f, 0.14657705f, 0.16139092f, 
    -0.26066992f, -0.22222899f, 0.07453556f, -0.00626554f, -0.05359143f, -0.53376895f, -0.44191566f, 0.31233332f, 
    0.10474262f, 0.08233643f, 0.17457138f, -0.06609931f, -0.15165213f, 0.00400911f, 0.09525440f, -0.09520293f, 
    -0.15880577f, 0.27685687f, 0.43616405f, 0.23874938f, 0.02272565f, 0.08451755f, -0.09892640f, -0.03371989f, 
    -0.08132599f, -0.19490846f, 0.06402603f, 0.11995517f, 0.66588253f, -0.37059382f, -0.74549997f, 0.13088124f, 
    -0.22698399f, -0.08350437f, 0.14514412f, 0.22949754f, 0.11977292f, -0.10164198f, 0.25951728f, -0.28602791f, 
    0.12619632f, 0.63708258f, -0.61248541f, -0.52267826f, 0.31050989f, -0.05132404f, 0.06814451f, -0.27626315f, 
    -0.41454631f, -0.03834311f, -0.07769446f, -0.17810135f, -0.62967128f, -0.45275331f, 0.28981659f, -0.09100626f, 
    0.11129192f, -0.08852708f, -0.04419890f, 0.15006496f, 0.13634066f, -0.04107081f, 0.22170220f, -0.00873180f, 
    -0.53243768f, 0.57252252f, 0.00889804f, -0.20832478f, 0.00621971f, 0.01303079f, -0.22451712f, -0.40804499f, 
    0.05568971f, -0.07185814f, 0.12183204f, 0.19889601f, -0.09022895f, 0.28879300f, 0.14552455f, -0.14114359f, 
    -0.03749364f, 0.10280310f, -0.21711339f, -0.05425655f, -0.06703909f, -0.03549391f, 0.00450480f, -0.16166441f, 
    -0.11218454f, -0.21869691f, 0.11873177f, -0.50597817f, -0.04148379f, -0.15195809f, 0.07613077f, -0.08005411f, 
    -0.01977724f, -0.04390904f, -0.15424593f, -0.25394821f, -0.03199996f, 0.60866392f, -0.19016153f, 0.18566655f, 
    0.17524838f, 0.04537285f, 0.06517027f, 0.08410566f, 0.09437837f, 0.05008713f, 0.03850067f, 0.10438306f, 
    -0.53708529f, 0.31693476f, 0.04473544f, -0.02522988f, 0.42589077f, -0.02706132f, 0.24477835f, -0.18733855f, 
    0.24094753f, -0.12633558f, -0.13658701f, 0.08313850f, -0.42738214f, 0.30192548f, 0.21430099f, 0.07264451f, 
    0.02586199f, -0.06489535f, -0.17321478f, 0.41163591f, 0.03145986f, 0.27033243f, -0.12718192f, 0.12611683f, 
    -0.03695434f, -0.40512004f, -0.06954030f, -0.20004474f, 0.10489491f, 0.11207650f, -0.07140946f, 0.07980545f, 
    -0.11393861f, -0.00514901f, 0.11416927f, -0.00441442f, 0.05925590f, -0.03905175f, -0.04584402f, 0.24579008f, 
    -0.09516021f, -0.05347237f, -0.10205585f, 0.18857911f, 0.01240351f, 0.36856902f, -0.10434942f, -0.12351152f, 
    0.47004846f, -0.00723249f, 0.33192098f, -0.00267567f, -0.10781056f, -0.06244228f, 0.02875495f, 0.12082327f, 
    -0.14453202f, 0.20670530f, -0.02497880f, -0.07306062f, 0.00116292f, 0.01388222f, -0.28533301f, -0.41063946f, 
    -0.04470239f, 0.11450700f, -0.04723581f, -0.04269759f, -0.11095063f, -0.10559816f, 0.09694389f, -0.08533219f, 
    0.42980096f, 0.07781895f, 0.15477324f, -0.18958081f, -0.22857200f, -0.26647297f, -0.10759398f, -0.25619808f, 
    0.08667195f, 0.10534327f, 0.06367950f, -0.00799186f, -0.44245151f, -0.08877259f, -0.14699616f, -0.25007710f, 
    -0.01592769f, 0.18232459f, -0.15281622f, 0.09726170f, 0.03686454f, 0.17150924f, 0.07662461f, -0.17094064f, 
    -0.61993355f, -0.12312726f, 0.33201182f, 0.01121263f, 0.05185032f, 0.20181325f, 0.08266456f, -0.05772211f, 
    0.17974108f, -0.04841471f, -0.10455433f, 0.20148756f, 0.32256559f, -0.06556336f, -0.29427969f, 0.33330995f, 
    0.31896555f, -0.08356857f, -0.02460545f, -0.10565396f, 0.05744860f, 0.17476024f, -0.01100975f, 0.29355326f, 
    -0.79028863f, -0.40657616f, -0.22802554f, -0.65093589f, 0.00736749f, -0.20810190f, 0.04069559f, -0.00900467f, 
    0.02549674f, 0.19227129f, 0.34697855f, 0.06911331f, 0.09561124f, 0.08457079f, -0.25098059f, 0.06654052f, 
    -0.46206063f, -0.13826136f, -0.08101138f, -0.01490260f, -0.05376042f, -0.11079191f, -0.04854858f, -0.06433055f, 
    -0.62755519f, -0.71884775f, -0.15022418f, -0.14128798f, 0.07345003f, 0.03470650f, 0.25398019f, -0.11068410f, 
    0.10359377f, 0.06139072f, 0.04670375f, -0.09326886f, 0.09033565f, -0.19386557f, 0.14999165f, 0.08000600f, 
    0.19135244f, 0.12472976f, 0.05251566f, 0.20563956f, 0.01100172f, 0.23312597f, 0.04147858f, 0.22689180f, 
    0.61347622f, 0.48420745f, 0.10184862f, -0.04886517f, 0.08590440f, 0.31380567f, -0.05545808f, 0.18409087f, 
    -0.03652858f, 0.25236535f, 0.26883498f, 0.07824861f, 0.31914815f, -0.13836935f, 0.04700919f, 0.19716755f, 
    0.05903753f, -0.16336580f, -0.04862658f, 0.21469229f, -0.19418134f, -0.07453725f, -0.11535112f, -0.15641080f, 
    -0.86284548f, -0.40700403f, -0.17937641f, 0.15567270f, 0.29074854f, -0.16755696f, -0.15047351f, 0.16267537f, 
    0.04125370f, 0.25638875f, 0.21717021f, 0.18344317f, -0.13927814f, -0.21358886f, -0.04135983f, 0.24911167f, 
    -0.36667970f, 0.23388490f, 0.14658117f, 0.02962149f, 0.01286780f, -0.13774060f, 0.00820771f, -0.18554997f, 
    0.37136689f, 0.01251814f, 0.13010365f, -0.11373173f, -0.38784239f, 0.13499257f, -0.09492923f, 0.04902745f, 
    -0.05664348f, -0.22535911f, -0.09033174f, -0.12098034f, 0.38788593f, -0.07900102f, 0.14063759f, -0.34575373f, 
    -0.03856705f, 0.03862124f, -0.04748957f, -0.05391172f, 0.24517097f, 0.04541671f, 0.15902551f, 0.06126182f, 
    -1.33611715f, -0.24130803f, 0.10275705f, 0.30659410f, 0.18428779f, 0.03166761f, -0.27895877f, -0.28912595f, 
    -0.12137193f, 0.02812816f, -0.11839085f, 0.12441930f, -1.08204937f, -0.20770505f, 0.05293864f, -0.54585743f, 
    0.11626016f, -0.03228636f, 0.06063462f, -0.18861054f, 0.02352845f, -0.11231212f, -0.18650487f, 0.07779604f, 
    0.09497670f, 0.25079167f, -0.06048626f, -0.04962915f, -0.27623594f, -0.09020475f, -0.02444567f, -0.00010448f, 
    0.00095924f, 0.12622274f, -0.01795539f, -0.23598918f, -0.81323689f, 0.22505893f, -0.51805621f, 0.00408150f, 
    0.23541895f, -0.16101703f, 0.27491459f, -0.09358032f, 0.00706173f, -0.00544841f, -0.11154415f, 0.15074295f, 
    0.05077005f, 0.27511305f, -0.10799474f, 0.09768663f, 0.35654703f, -0.05691090f, -0.45802698f, -0.00383695f, 
    -0.10940667f, 0.03553787f, 0.18394779f, 0.01261131f, -0.27560496f, 0.06850643f, 0.42428875f, 0.07191703f, 
    0.15077057f, -0.19010572f, -0.15374595f, 0.39791778f, -0.20138057f, -0.29303724f, -0.12221153f, -0.03968165f, 
    0.12395228f, -0.54712671f, 0.18388492f, 0.15090965f, -0.11169164f, -0.00902701f, -0.10477705f, -0.05024970f, 
    -0.02288063f, -0.06549825f, 0.04133851f, -0.08072812f, -0.12107161f, -0.57843155f, -0.24335882f, 0.12953424f, 
    -0.06381381f, 0.28200820f, -0.15547608f, -0.02785406f, 0.02163560f, 0.03038293f, -0.06881437f, 0.09136008f, 
    0.27704468f, 0.31516150f, -0.45845222f, -0.21464083f, 0.41898477f, 0.15517385f, -0.05363568f, 0.08197220f, 
    0.08515322f, 0.09514865f, 0.14879233f, 0.01361769f, 0.27535960f, -0.20186126f, -0.24369937f, 0.57617342f, 
    0.16012120f, -0.11898852f, -0.07075489f, -0.02867757f, 0.01636280f, 0.11110745f, 0.05703352f, 0.06297807f, 
    0.07089342f, 0.26481634f, -0.34106588f, 0.28489313f, 0.01316171f, 0.07555173f, 0.03202366f, 0.03123431f, 
    -0.02342648f, 0.01440552f, 0.07233498f, -0.27289912f, -0.34907046f, -0.47851828f, 0.14989032f, -0.06835333f, 
    -0.08311073f, 0.03621383f, 0.19425327f, -0.01561194f, -0.14159739f, 0.12229071f, -0.08742094f, 0.12517580f, 
    -0.23156182f, -0.32686847f, 0.30007428f, -0.13748388f, 0.22147588f, 0.11198889f, 0.12393723f, -0.14911750f, 
    0.03913671f, -0.13334450f, -0.22018667f, -0.20071734f, 0.33531958f, -0.03935880f, -0.70901531f, 0.03188344f, 
    -0.38755587f, -0.15744154f, 0.01336474f, 0.10000937f, 0.11101723f, 0.11893849f, 0.07864005f, 0.04227259f, 
    -0.29791203f, 0.06975760f, -0.11060133f, 0.25377297f, -0.69870615f, 0.31433645f, 0.11443902f, -0.44100764f, 
    -0.10833938f, -0.19203949f, -0.00519616f, -0.08434384f, -0.43639374f, 0.47076923f, 0.06758520f, 0.04253015f, 
    -0.02106133f, 0.08588797f, -0.02334704f, -0.03087708f, -0.00470808f, 0.06495681f, 0.04752727f, -0.25519460f, 
    0.69868624f, 0.37314117f, -0.06331731f, -0.30621913f, -0.10935787f, 0.05208975f, -0.09081808f, -0.04835665f, 
    0.03175806f, 0.10549370f, -0.00432659f, 0.11497820f, 0.57371163f, -0.09890483f, -0.34256715f, -0.44629547f, 
    0.30015728f, -0.12932968f, -0.10506926f, -0.03530197f, 0.04503822f, -0.10671883f, 0.13970622f, -0.00931579f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18399706f, 0.04809701f, -0.10742364f, -0.00627486f, 0.01607536f, -0.07043457f, 0.06611839f, -0.12361643f, 
    -0.11251380f, 0.03085302f, 0.25073653f, 0.09202560f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
