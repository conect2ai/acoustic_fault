#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.16554300f, -0.63650602f, -0.75108767f, 0.07132140f, -1.36466515f, -0.12410196f, -0.73217267f, -0.44590768f, 
    -0.14436349f, 0.63819492f, 1.16310012f, -0.89536458f, 0.72876966f, -0.49674308f, -0.61762929f, 0.81747526f, 
    0.61789697f, 0.02255876f, 0.90930623f, 0.39473182f, 1.01697385f, -0.55103528f, 0.47793564f, 0.00812660f, 
    0.52062321f, 0.11360023f, -0.46770763f, 0.18265240f, 0.75199085f, 0.40094891f, -0.37736887f, 1.01817369f, 
    -0.41343206f, 0.82263243f, 0.74844307f, 0.53454733f, -0.04130154f, 0.91517347f, -1.30521274f, 0.02010710f, 
    1.04342532f, 0.09473599f, 0.77630049f, -0.22650659f, -0.44733125f, 0.57117218f, -1.31024647f, -0.79831064f, 
    -1.10496247f, -0.24248868f, -0.16048822f, 0.27796558f, 0.49463636f, 0.21962501f, 1.00776947f, 0.98588574f, 
    0.85962015f, 0.13524230f, -0.91459936f, 0.53936625f, -0.27386531f, 0.13302736f, -0.44480792f, -0.52490276f, 
    0.63075548f, 0.59081864f, -1.63497174f, -0.00073957f, -1.15989923f, 0.16096549f, -0.13598868f, -0.18715324f, 
    -0.08812749f, -1.25846469f, -1.13984954f, 0.36674455f, -0.06087802f, -0.51349950f, 0.14103962f, -0.25495547f, 
    -0.15590659f, 0.68268299f, 0.34064433f, 0.68912143f, -0.27483162f, -1.02607810f, -1.10920632f, 0.03283597f, 
    0.81739223f, -0.01294911f, 1.07986200f, 0.26622248f, 0.69481391f, 1.32830107f, 0.72167438f, 0.46847099f, 
    0.31846750f, 0.62967312f, 0.40010685f, 1.17097569f, 0.93954271f, 0.65997076f, -0.43516567f, 0.66976303f, 
    -0.49080542f, -0.42391086f, 0.00899000f, 0.33964035f, -0.38317439f, -0.74446470f, 0.54942763f, 0.03905633f, 
    -1.11888552f, 0.47244418f, 0.48651028f, 0.56606692f, 0.46159038f, 1.14089727f, 0.96241474f, 0.69608343f, 
    -0.22677402f, -0.63786846f, 0.14093381f, 0.22146733f, -0.35408115f, 0.49111259f, -1.20818985f, -1.41505563f, 
    -1.06438291f, 0.02442969f, 1.22754014f, 1.08998811f, -0.28444722f, -0.11623231f, -0.20751972f, -0.05035316f, 
    0.13001543f, 0.97743732f, 0.82378197f, 0.81078327f, 0.73286551f, -0.41541660f, -0.89119005f, -0.16676790f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14685905f, -0.32056791f, 0.09320430f, -0.28488359f, 0.13709694f, 0.27549273f, 0.22480239f, 0.91325045f, 
    0.24080400f, 0.21437708f, -0.25212380f, 0.46806404f, 0.54799724f, 0.43290526f, 0.39976391f, 0.50607914f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05808121f, -0.07094640f, 0.02283372f, 0.02351733f, 0.05462565f, -0.03640572f, 0.05864390f, 0.04966228f, 
    -0.05696006f, 0.06632124f, -0.05813164f, 0.07434240f, -0.08049163f, 0.00844075f, 0.05620819f, 0.06290153f, 
    0.04778373f, -0.04344515f, 0.03432005f, -0.06653485f, 0.03358026f, 0.02448026f, -0.08746880f, -0.07232270f, 
    -0.02937268f, 0.01577879f, -0.06794102f, 0.06982530f, -0.07488167f, 0.05757441f, 0.02913704f, -0.02868197f, 
    -0.00411540f, 0.07280102f, 0.03851413f, 0.02788691f, -0.08110304f, -0.05086056f, 0.07303982f, -0.02313431f, 
    -0.01879000f, -0.09163230f, 0.01518219f, 0.04333870f, -0.06074421f, 0.00322163f, 0.05816814f, -0.01164201f, 
    0.05947763f, -0.04362712f, -0.00331942f, 0.01989443f, -0.04479920f, 0.00230952f, 0.00968550f, -0.03216983f, 
    -0.04207242f, -0.03751453f, -0.06919277f, -0.07922019f, 0.01424655f, -0.03919421f, -0.04591862f, -0.08999544f, 
    -0.03252265f, -0.07537606f, 0.02563279f, -0.08927578f, 0.00560751f, -0.04493799f, -0.05915120f, 0.05945594f, 
    0.06935505f, -0.07440586f, -0.01383948f, -0.08842751f, -0.02062443f, 0.05337584f, -0.01519381f, 0.02282573f, 
    -0.00571128f, -0.08662394f, 0.02728673f, -0.07935707f, 0.02920792f, -0.00148608f, 0.04388132f, -0.03666539f, 
    0.01702501f, -0.06240921f, -0.02011409f, -0.01546007f, 0.04276579f, 0.04998751f, -0.00960593f, -0.04081934f, 
    0.06128982f, -0.05154664f, 0.04643797f, -0.06212901f, -0.00685340f, -0.04813178f, -0.00627311f, 0.01262721f, 
    -0.02120678f, 0.03291936f, 0.00265939f, -0.00400713f, 0.00289285f, -0.06483871f, 0.04036071f, -0.01831888f, 
    -0.03972937f, -0.02719891f, 0.07037106f, -0.03321227f, 0.02360680f, -0.09016841f, -0.00133672f, -0.02158139f, 
    -0.05492870f, -0.04732615f, -0.01195190f, -0.03971281f, -0.06055102f, 0.06294185f, 0.04948780f, 0.03777216f, 
    -0.04741203f, -0.08635577f, -0.07659582f, -0.08769453f, -0.05871200f, 0.03286666f, -0.03172938f, -0.02220033f, 
    0.05224778f, -0.02218323f, 0.01730182f, 0.00599157f, -0.07877398f, 0.02553187f, -0.07370722f, 0.06276622f, 
    -0.97112817f, 0.00129597f, 0.39619187f, 0.37967443f, 0.21547453f, 0.35827723f, 0.00979374f, 0.08619783f, 
    0.18811728f, 0.08678687f, -0.61029828f, -0.00907753f, -0.22224770f, -0.22238863f, 0.24953832f, -0.13226624f, 
    0.27098656f, -0.11100328f, -0.28808382f, 0.32076016f, -0.31036660f, 0.13879389f, -0.03837599f, 0.23195270f, 
    0.28999364f, 0.05121894f, -0.18570983f, -0.19885814f, 0.19493194f, -0.24103530f, 0.06050560f, -0.38156322f, 
    -0.03782670f, 0.02857713f, -0.13182159f, 0.05491994f, 0.20120122f, 0.10048192f, 0.16657157f, 0.01320336f, 
    -0.10867121f, -0.15271005f, 0.16378821f, 0.12455437f, 0.18313804f, 0.60816634f, -0.34131983f, -0.27810824f, 
    -0.07772318f, 0.16016214f, -0.04672471f, 0.01078260f, -0.16118531f, -0.10810748f, -0.42266139f, -0.20386556f, 
    -0.49538761f, 0.09938398f, 0.30869758f, 0.19549800f, -0.05656103f, -0.20745105f, -0.04392272f, 0.67691880f, 
    0.54662788f, 0.00640569f, -0.00067321f, -0.16814560f, 0.05849333f, -0.16871750f, 0.07981151f, -0.18737140f, 
    -0.39106491f, -0.37810737f, 0.15577450f, -0.18903281f, -0.05558613f, 0.03324587f, -0.03111261f, -0.19837239f, 
    0.00307988f, -0.17426220f, 0.43720898f, 0.08787846f, 0.15081263f, -0.02581514f, -0.17473924f, -0.13813211f, 
    0.29069585f, -0.06712668f, -0.76055759f, -0.31228223f, 0.22807628f, 0.14439438f, 0.21220127f, 0.11620821f, 
    -0.05080649f, -0.07161359f, 0.06772292f, -0.31882054f, 0.27232963f, -0.04588000f, 0.23048805f, 0.11391389f, 
    0.11371610f, 0.06326677f, -0.12773548f, 0.08180951f, -0.16780430f, -0.09846611f, 0.01414781f, 0.01212226f, 
    -0.05635373f, 0.21827640f, -0.05023321f, -0.07018039f, 0.11374197f, -0.38325757f, 0.02082147f, -0.24389490f, 
    0.40687120f, 0.26472801f, 0.24409659f, -0.11202420f, -0.02808722f, 0.02544123f, 0.72526562f, 0.18474823f, 
    0.04739411f, -0.23159677f, -0.12876692f, -0.00016384f, -0.14573243f, 0.19813335f, 0.11905009f, 0.00006204f, 
    -0.07452686f, -0.14973132f, 0.13165697f, 0.28744406f, 0.22392492f, -0.04804301f, 0.05041873f, -0.13867733f, 
    0.02189744f, -0.09835644f, 0.04864785f, -0.03618905f, -0.03764104f, 0.02823675f, -0.05915347f, 0.04583129f, 
    -0.03049364f, -0.01702584f, -0.03925639f, -0.03717167f, 0.03404394f, -0.05532915f, 0.04611595f, 0.04618317f, 
    -0.01442780f, 0.01224431f, -0.00737908f, -0.05255027f, 0.00131207f, 0.05291586f, -0.01144738f, -0.09066419f, 
    -0.00842691f, -0.08020788f, -0.07164352f, -0.09557934f, -0.04728077f, 0.06516071f, -0.02394349f, 0.01874075f, 
    -0.06111081f, 0.06498368f, -0.01462035f, 0.02188482f, 0.04444970f, -0.07159975f, 0.05122175f, 0.03799284f, 
    -0.08907294f, 0.03814401f, -0.04776427f, 0.03190887f, -0.06141278f, 0.00343830f, 0.01786931f, 0.05799425f, 
    0.03772642f, -0.09209207f, -0.07114608f, -0.01205523f, -0.02483499f, -0.00532823f, 0.02311605f, -0.03322746f, 
    -0.08269639f, -0.02214584f, 0.05106525f, -0.08556862f, 0.05150208f, 0.01236327f, -0.05984116f, 0.00393727f, 
    -0.07915475f, -0.03949069f, -0.00730551f, 0.06266508f, -0.01901514f, 0.00047632f, 0.05685003f, -0.03788722f, 
    -0.01939707f, 0.03197033f, 0.06694646f, -0.02259629f, 0.03090023f, -0.07460144f, -0.00570086f, -0.05436198f, 
    -0.08491821f, 0.00988677f, 0.06618518f, -0.04941629f, 0.01055673f, 0.04685122f, -0.09911329f, -0.06017112f, 
    -0.09898746f, 0.05612202f, -0.00060740f, -0.01386744f, 0.07320149f, 0.05361336f, 0.04986969f, -0.08734743f, 
    -0.03772237f, -0.01281898f, -0.07318326f, 0.00627333f, 0.03562726f, 0.04320696f, 0.02245536f, 0.06537574f, 
    -0.07588392f, 0.01198963f, 0.04588113f, -0.00697948f, -0.07569953f, -0.03766330f, 0.03644461f, -0.08596435f, 
    0.00689814f, 0.01088610f, 0.01764783f, 0.05778619f, -0.04675626f, -0.09039601f, -0.00487346f, 0.07368787f, 
    -0.00888606f, -0.06337523f, 0.06413937f, 0.05684735f, 0.05544779f, -0.02783002f, 0.06369279f, -0.09191959f, 
    0.04322962f, -0.07769941f, 0.01360730f, 0.06088902f, -0.06066633f, -0.07707497f, -0.09590565f, 0.05395125f, 
    -0.04859484f, -0.01436340f, 0.05617800f, -0.04684000f, -0.01060383f, 0.02239763f, 0.02416890f, -0.00949261f, 
    -0.09517176f, 0.24898046f, 0.01196888f, -0.25236818f, 0.00947536f, 0.09592434f, -0.04817112f, 0.21416175f, 
    0.08331072f, 0.33864522f, -0.28865987f, 0.10388847f, 0.06951431f, -0.19730896f, 0.03832527f, 0.15416305f, 
    0.07009179f, 0.23899940f, 0.48566133f, 0.13559918f, -0.18576545f, -0.18665595f, -0.24734566f, -0.28773651f, 
    -0.07174199f, 0.10025637f, 0.15183361f, 0.34260607f, -0.25499576f, -0.28495997f, -0.17104471f, 0.19316159f, 
    -0.17047778f, -0.05767407f, -0.01415046f, -0.31375483f, -0.02806696f, -0.24625239f, 0.31924659f, -0.26180589f, 
    -0.05812490f, 0.15607227f, -0.13541047f, -0.06456983f, -0.05715394f, 0.28486675f, -0.17289202f, 0.08505169f, 
    -0.13289471f, 0.12766808f, -0.08456431f, 0.08557724f, 0.13599411f, -0.13851674f, 0.59738088f, 0.04750390f, 
    0.35375068f, -0.05705801f, -0.08404048f, 0.25274172f, 0.13343066f, 0.03123281f, 0.11603133f, -0.20302099f, 
    -0.38945240f, -0.54447246f, 0.13100491f, 0.05133897f, -0.07450183f, -0.00434703f, -0.09907513f, -0.06360104f, 
    -0.05306369f, -0.05445139f, -0.48726887f, -0.19663526f, -0.19500984f, -0.09217114f, -0.16805409f, -0.13747990f, 
    -0.11677609f, -0.04246921f, 0.16255479f, -0.23555313f, 0.25020817f, -0.08833196f, 0.06726217f, 0.10125265f, 
    0.05343302f, -0.07471892f, -0.18044858f, -0.37031767f, 0.13901064f, -0.17903858f, 0.13949589f, -0.05204896f, 
    -0.03285795f, 0.07322650f, -0.25797972f, 0.30132949f, 0.51798588f, -0.10570957f, -0.07732188f, -0.05821072f, 
    -0.01837005f, 0.06404479f, -0.13263990f, 0.12326244f, -0.18685220f, 0.33922258f, -0.03433197f, 0.23518276f, 
    0.06463018f, -0.12505148f, -0.17390001f, 0.02586738f, -0.04519701f, 0.78964692f, 0.22861856f, 0.20733857f, 
    -0.05321309f, 0.02576457f, 0.05245854f, -0.06384593f, 0.09357323f, -0.00467705f, -0.25014436f, 0.25624600f, 
    -0.21716143f, 0.00934634f, 0.07639475f, 0.07279351f, -0.03588679f, 0.01446038f, 0.09409026f, -0.55475968f, 
    0.12506901f, 0.15528041f, 0.12080218f, 0.04169152f, -0.03560874f, -0.16580386f, 0.21363103f, -0.00579026f, 
    -0.01512234f, 0.04641781f, 0.03970304f, 0.08338139f, 0.04837627f, 0.05077563f, -0.04775589f, -0.07211932f, 
    0.04131855f, 0.01101157f, 0.00299080f, -0.02003685f, -0.00854665f, -0.00466339f, 0.06122359f, -0.04953659f, 
    0.00899869f, 0.04362727f, -0.00437182f, 0.07818205f, -0.02941750f, 0.03952488f, -0.00507704f, -0.07621536f, 
    0.07378245f, 0.05696149f, -0.01961764f, -0.04621911f, 0.00430593f, -0.07698265f, -0.08631938f, -0.01744349f, 
    -0.00949726f, -0.08000869f, 0.04660631f, 0.03856394f, -0.02127023f, -0.07894215f, -0.00272419f, 0.01871827f, 
    -0.03965847f, -0.04205469f, -0.07997180f, -0.02544900f, 0.04790405f, -0.04270264f, -0.07611968f, -0.06998684f, 
    -0.06959133f, -0.03355201f, 0.04253959f, -0.09211310f, -0.06921919f, -0.07048631f, -0.00707819f, 0.04113833f, 
    -0.04413507f, -0.01887365f, -0.00054612f, 0.02576450f, 0.01423003f, -0.00284873f, 0.02086260f, 0.02733131f, 
    0.01242123f, -0.06801199f, -0.03490930f, 0.00821443f, -0.03937422f, 0.00579957f, 0.02287468f, -0.00105120f, 
    0.07607799f, -0.03587205f, -0.05610512f, -0.04086826f, 0.02832794f, -0.01499741f, -0.06687161f, 0.00898225f, 
    -0.02905646f, -0.04686206f, 0.06307655f, -0.07053626f, 0.07265189f, -0.02619604f, 0.06147462f, -0.00495205f, 
    0.07818466f, -0.01830594f, -0.01478204f, 0.01007862f, -0.03974319f, 0.05346243f, -0.03226777f, -0.07351291f, 
    -0.03074853f, -0.06288250f, 0.02427733f, -0.06147698f, 0.06932770f, 0.02891213f, -0.01282461f, -0.08924306f, 
    -0.00169138f, 0.02860991f, -0.00266353f, -0.03506482f, -0.01192884f, 0.01129559f, -0.06173991f, -0.08197645f, 
    0.00516464f, -0.04165117f, 0.03524346f, -0.07386080f, -0.07383712f, 0.06082765f, -0.04395282f, 0.02574263f, 
    0.03987772f, -0.03770007f, 0.05311123f, 0.02864900f, -0.06134319f, 0.01835880f, -0.02371198f, -0.01381938f, 
    -0.06772301f, 0.00870735f, -0.01043329f, -0.09523284f, 0.03880468f, -0.04322755f, -0.02155993f, 0.00806128f, 
    -0.06615862f, -0.00881510f, -0.01246666f, -0.04913643f, 0.02361193f, -0.00031905f, 0.07102581f, 0.00005582f, 
    0.01437365f, 0.04639358f, 0.03477331f, -0.06751972f, 0.05572807f, 0.01352669f, 0.05490502f, -0.03450526f, 
    -0.05817063f, -0.02884609f, -0.03003331f, -0.07285152f, -0.00639768f, -0.04192289f, -0.01853079f, -0.01048863f, 
    0.03733832f, 0.02834303f, -0.07938945f, -0.06093301f, -0.00808880f, -0.02127631f, 0.05494714f, -0.04336438f, 
    -0.06414253f, -0.08788472f, 0.01730473f, -0.02943973f, -0.04204895f, -0.03278957f, -0.02119404f, 0.01035356f, 
    -0.05820666f, -0.03683807f, 0.06951592f, 0.01872064f, -0.07152058f, -0.05288207f, -0.06188626f, -0.06291771f, 
    -0.06359618f, -0.06202959f, -0.01358013f, -0.06984698f, -0.00213008f, -0.09549434f, -0.09654382f, 0.01026810f, 
    0.04990405f, -0.06604440f, -0.02730366f, -0.04698903f, -0.00933790f, 0.02217647f, -0.03457928f, -0.02344337f, 
    0.02985242f, -0.00741877f, -0.07954039f, 0.04660848f, 0.02926960f, 0.02202983f, -0.07956323f, -0.00992301f, 
    -0.09979788f, -0.07197613f, -0.05465017f, 0.05355966f, -0.09884042f, 0.05510167f, -0.07652431f, -0.09235249f, 
    -0.08638363f, -0.02755200f, -0.06151142f, 0.02011538f, -0.02871294f, -0.09382081f, -0.04626608f, 0.05713234f, 
    0.02913257f, 0.03998453f, -0.00598839f, 0.05084074f, -0.07996698f, -0.09719541f, 0.03975175f, -0.08979284f, 
    -0.02972092f, 0.01568354f, 0.01640183f, -0.01990580f, 0.03874471f, -0.02054231f, -0.09076127f, -0.05785253f, 
    -0.04959873f, -0.02708839f, -0.01244458f, -0.01918470f, -0.07046633f, 0.02891090f, -0.06621336f, -0.01196257f, 
    -0.08402752f, 0.04737558f, -0.05044146f, 0.05829758f, -0.00969296f, -0.01958468f, 0.03540200f, 0.05555248f, 
    -0.03907793f, -0.03930951f, 0.01656255f, -0.08099466f, 0.02688612f, 0.05336146f, -0.01323919f, -0.01224665f, 
    -0.03811853f, -0.02035658f, 0.04330275f, 0.03426937f, -0.08763660f, -0.08328577f, -0.05622865f, -0.08481172f, 
    -0.05714901f, -0.00083958f, -0.07749359f, -0.04218851f, -0.04517297f, 0.05294608f, 0.01716690f, 0.03912197f, 
    -0.00651267f, -0.02584188f, -0.06404121f, -0.04650607f, -0.02124060f, -0.00838796f, -0.09055661f, 0.03913290f, 
    -0.00380843f, -0.18715583f, -0.07965001f, 0.29082662f, -0.23629904f, 0.13891678f, -0.08021528f, -0.01109505f, 
    0.14560857f, 0.26938078f, 0.45929500f, -0.57625645f, -0.39425236f, -0.08895961f, -0.09991986f, -0.18313512f, 
    0.09191281f, -0.09171918f, -0.35831457f, 0.25627300f, -0.05187415f, 0.15894535f, -0.03146945f, 0.16420175f, 
    0.00179037f, 0.05461475f, -0.12537436f, -0.11763489f, -0.34774315f, -0.32952431f, 0.00478006f, 0.00262678f, 
    -0.01448520f, -0.01962083f, -0.10222290f, -0.09769602f, -0.23506217f, 0.39410385f, 0.20023803f, 0.02112027f, 
    -0.25147918f, 0.20787911f, -0.07243095f, 0.13641781f, 0.05766608f, -0.21248421f, 0.05060811f, -0.02263749f, 
    -0.08665349f, 0.02442282f, -0.06138295f, -0.07616963f, 0.08857781f, -0.18035358f, -0.05140325f, 0.29813269f, 
    0.06228672f, -0.02488140f, 0.22809324f, 0.17796345f, 0.08733716f, 0.12645654f, 0.02187457f, -0.53784287f, 
    0.35771364f, -0.48785651f, 0.05175547f, 0.08180272f, -0.00238445f, -0.02404301f, 0.28623018f, -0.01323691f, 
    0.14917079f, -0.09172522f, 0.33292857f, 0.12875776f, -0.21507810f, 0.04707154f, -0.19812088f, -0.00136668f, 
    0.12907499f, 0.22549398f, 0.35068011f, -0.66312563f, -0.00477769f, 0.01148019f, -0.26580352f, 0.15334830f, 
    0.01898373f, -0.09884817f, 0.48048189f, -0.32462695f, -0.11546606f, -0.00012342f, 0.08619592f, 0.12045498f, 
    0.04408777f, -0.10344405f, 0.04807359f, -0.03042636f, 0.37966955f, -0.23101856f, 0.18472393f, -0.13830517f, 
    0.06861776f, -0.01785969f, -0.13797989f, 0.09210838f, 0.12364563f, -0.29637471f, -0.39368677f, 0.06916291f, 
    0.23058586f, -0.11253867f, 0.02729586f, 0.08108561f, -0.06942770f, 0.02034028f, 0.30150610f, 0.00642591f, 
    0.05148712f, 0.00428325f, 0.08985148f, 0.12167333f, -0.18577209f, -0.15538415f, -0.21260628f, -0.52987653f, 
    0.58213550f, 0.03777320f, -0.11948130f, 0.23276547f, -0.05584031f, -0.00355820f, 0.09488754f, 0.00693118f, 
    0.05238037f, -0.11805549f, -0.14447518f, 0.04409248f, 0.08579700f, 0.06985231f, 0.02055303f, 0.32175195f, 
    -0.27424276f, -0.17846872f, -0.07200817f, -0.16569278f, -0.00861709f, 0.05795392f, -0.06116487f, 0.23551762f, 
    -0.13845390f, -0.55385470f, -0.34780353f, -0.04098370f, -0.39192820f, -0.11333279f, 0.17048939f, 0.00880640f, 
    -0.16893247f, -0.08408025f, -0.07691509f, -0.15371650f, -0.09281079f, 0.03909451f, -0.09941509f, -0.05056715f, 
    -0.12363667f, 0.16443972f, -0.02247124f, -0.22707582f, 0.42400244f, -0.02634292f, 0.09473827f, 0.07425683f, 
    0.13908093f, 0.13187654f, 0.05437030f, -0.13710068f, 0.24958381f, -0.06146126f, -0.44011012f, 0.17876706f, 
    -0.01676311f, 0.18433072f, 0.00769702f, 0.17620474f, 0.26874310f, -0.60807723f, -0.13418084f, 0.12219127f, 
    -0.25689629f, 0.09389934f, 0.18487750f, 0.12935382f, 0.00551974f, 0.07323352f, 0.11170138f, 0.08789598f, 
    0.28838432f, -0.22941907f, -0.23860617f, -0.33114272f, 0.14397462f, 0.02604331f, -0.10509377f, -0.29640692f, 
    -0.11968517f, -0.09912416f, 0.30039373f, -0.02161515f, 0.20744221f, 0.15861756f, -0.00772325f, -0.03957094f, 
    0.35462227f, 0.28038490f, 0.30596122f, 0.15967257f, -0.00827458f, 0.18109712f, 0.17686960f, 0.20612957f, 
    0.04876876f, -0.06876206f, -0.16915502f, 0.32277668f, -0.45676821f, -0.15305576f, -0.19524722f, -0.14533445f, 
    0.12871744f, 0.27853826f, -0.07217495f, 0.10950410f, -0.13571532f, 0.20463172f, -0.06398764f, 0.12677923f, 
    0.05818061f, -0.08692648f, -0.07408081f, 0.11479547f, 0.04465991f, -0.08629148f, -0.16365519f, 0.00658562f, 
    0.08166368f, -0.25726414f, 0.01684836f, 0.34909561f, -0.18100463f, -0.34043658f, 0.04082705f, 0.16256061f, 
    -0.08876267f, -0.16587092f, -0.01475050f, 0.02579310f, 0.04347574f, -0.14968880f, 0.18023920f, 0.04336855f, 
    -0.28427964f, -0.20765339f, -0.03390978f, -0.04553945f, -0.08421808f, 0.06441348f, 0.27527151f, 0.41658869f, 
    -0.48130465f, 0.40421733f, 0.23059984f, 0.16724104f, 0.06564576f, -0.12036568f, 0.05958430f, 0.22446705f, 
    0.28650385f, 0.23226689f, 0.03196670f, -0.11358935f, -0.39785391f, 0.21906568f, 0.20175730f, 0.18249421f, 
    0.05345381f, -0.03065249f, -0.04319210f, -0.00607532f, -0.08739246f, 0.01524045f, 0.03723818f, -0.07700729f, 
    -0.08168408f, -0.07045820f, 0.01067560f, -0.03294190f, -0.02609606f, -0.04633655f, 0.04915416f, 0.06579155f, 
    0.05661108f, -0.06708778f, 0.01472248f, 0.04854450f, -0.06788428f, 0.04527966f, -0.04109763f, -0.00231524f, 
    0.03835530f, -0.00628925f, -0.03017604f, 0.00956594f, 0.05421299f, 0.01409081f, -0.00062150f, -0.08021370f, 
    0.02583295f, -0.06661405f, 0.01779509f, 0.04020251f, -0.04576562f, 0.00132348f, 0.05497940f, -0.06687400f, 
    -0.08759304f, 0.02952733f, 0.07445738f, 0.01167164f, -0.02314185f, 0.02352673f, -0.06117314f, -0.03049097f, 
    0.02171042f, 0.06826372f, -0.00172471f, -0.05655279f, 0.05740007f, -0.01607519f, -0.01758382f, -0.06376735f, 
    -0.06918023f, -0.02509508f, -0.08477318f, -0.02554174f, -0.06760979f, -0.02930601f, -0.05288741f, -0.01888819f, 
    0.05234338f, -0.01810126f, 0.00348377f, 0.00194517f, -0.07290450f, 0.04710961f, -0.02110772f, -0.06809712f, 
    0.03442634f, -0.03571845f, -0.05505165f, 0.03824373f, 0.07206699f, 0.02537047f, 0.00176396f, -0.01121995f, 
    -0.00196586f, -0.06461838f, -0.07290954f, 0.05662970f, -0.00589156f, -0.01711397f, -0.01916460f, 0.06717382f, 
    -0.01056816f, -0.00397174f, 0.06541631f, -0.03395021f, 0.01467156f, 0.07715667f, -0.02016509f, -0.07185395f, 
    -0.07280573f, 0.06589982f, 0.02695144f, 0.02536880f, 0.02170111f, 0.02196749f, -0.04873974f, -0.07761931f, 
    0.02854836f, -0.03221453f, -0.04238807f, 0.01231608f, 0.04567520f, -0.09123970f, 0.05011904f, -0.06083142f, 
    -0.06008545f, 0.01046763f, -0.04755927f, -0.07571359f, 0.05642512f, 0.01539209f, -0.03772289f, -0.08368882f, 
    -0.02340879f, 0.04587668f, 0.04976454f, 0.02515214f, 0.02168613f, -0.08514063f, 0.04843800f, 0.00102060f, 
    0.03792996f, 0.01782737f, -0.08031740f, -0.06769911f, -0.05209981f, -0.08428819f, -0.04877427f, -0.06200809f, 
    -0.07600182f, -0.08686125f, -0.04384835f, 0.05521543f, -0.07970595f, -0.08540162f, -0.06902484f, -0.03851088f, 
    -0.04978629f, 0.03523898f, 0.04956708f, 0.05325945f, -0.01014497f, 0.01296626f, 0.04587365f, -0.05042693f, 
    -0.01105507f, -0.09405965f, 0.00047369f, -0.02690100f, -0.04510343f, -0.02752536f, -0.00420226f, 0.03569423f, 
    0.04917645f, 0.05989844f, 0.00271421f, -0.06211633f, 0.02711666f, -0.07950622f, -0.07216282f, -0.02921021f, 
    0.00572534f, -0.08386396f, 0.06527199f, 0.02368214f, 0.01494152f, 0.02452238f, 0.04244165f, 0.00437249f, 
    0.01964893f, -0.03917427f, -0.06023961f, 0.01278783f, 0.00027887f, -0.03659922f, -0.04684094f, -0.00534985f, 
    -0.00297630f, -0.01240323f, 0.03076402f, 0.04966975f, 0.00358944f, -0.06604033f, 0.00366085f, -0.02888038f, 
    0.04370690f, -0.05407122f, -0.09091855f, 0.03646618f, 0.01999734f, -0.07524109f, 0.06226615f, -0.00523636f, 
    0.04646693f, -0.00810773f, -0.06726772f, 0.04782308f, -0.07007227f, 0.02772127f, -0.02417732f, -0.01288066f, 
    -0.07068927f, -0.05415737f, 0.00050724f, 0.00679687f, -0.02357993f, -0.00794257f, -0.00610960f, 0.01675301f, 
    0.03052154f, -0.02988888f, -0.02250162f, 0.00147909f, 0.01623709f, -0.04031776f, -0.04304665f, -0.05754420f, 
    0.01462830f, 0.05875688f, -0.06067753f, 0.05144460f, -0.03069846f, 0.03637557f, 0.06401312f, 0.05262589f, 
    -0.00194637f, -0.07762039f, 0.04230540f, -0.03057341f, -0.05231051f, -0.07328088f, -0.01169517f, 0.05240574f, 
    0.02582222f, 0.01323490f, 0.02885900f, 0.02273663f, 0.05154430f, -0.07736907f, 0.01821668f, -0.08506152f, 
    0.06144184f, 0.04605721f, -0.00859142f, -0.02172293f, 0.01077129f, 0.00604153f, -0.08856217f, 0.05566852f, 
    -0.00501191f, 0.05235866f, 0.00950456f, 0.03210170f, 0.03077477f, -0.01459601f, -0.08376532f, -0.02118153f, 
    -0.07891760f, -0.04170757f, 0.01025083f, 0.03834968f, 0.06150277f, 0.00841924f, -0.08910722f, 0.00844806f, 
    -0.08768617f, -0.00940526f, -0.07211570f, -0.01743302f, -0.09307948f, 0.02868095f, 0.02998342f, -0.08197904f, 
    -0.02504103f, 0.00164489f, 0.04123865f, 0.00659734f, -0.08339309f, -0.06467792f, -0.03871466f, -0.07072883f, 
    -0.09126440f, -0.07314391f, 0.03587236f, -0.06607885f, -0.08107650f, -0.07651958f, 0.03782932f, -0.03753019f, 
    -0.00602072f, 0.01175651f, 0.04119695f, -0.02988908f, -0.06264630f, 0.06631903f, -0.06005291f, -0.10551738f, 
    -0.03737896f, -0.06856654f, -0.01254544f, -0.00020095f, -0.03593770f, -0.08989776f, -0.08390681f, -0.00533052f, 
    -0.04775284f, -0.02499140f, 0.03171052f, 0.08165716f, -0.07210154f, 0.03897154f, -0.07234524f, -0.02956432f, 
    -0.05298782f, -0.07555903f, 0.00688735f, 0.06235858f, -0.08599260f, 0.05914256f, -0.00374963f, -0.05842533f, 
    0.00405880f, -0.07585097f, -0.02656130f, 0.02522737f, -0.02498506f, -0.04118403f, 0.04874878f, -0.05413569f, 
    0.01130527f, 0.02130781f, -0.04341232f, 0.03268044f, -0.08515083f, 0.00281044f, -0.01238781f, 0.02998449f, 
    0.06069336f, -0.04225579f, 0.04232218f, 0.04646473f, -0.01243303f, -0.06124435f, 0.06780718f, -0.01650899f, 
    0.03342510f, 0.02619586f, -0.00236582f, -0.00385843f, -0.04994224f, 0.05191698f, 0.00324720f, 0.00909786f, 
    0.01270280f, 0.02686361f, -0.03466693f, -0.09053383f, 0.06305211f, -0.03786596f, -0.08272372f, 0.02283877f, 
    0.05860261f, -0.02506491f, 0.02844231f, 0.03614856f, -0.07187144f, -0.02433670f, -0.05190831f, -0.00657971f, 
    -0.05674722f, 0.02265834f, 0.05785755f, 0.05757446f, -0.09359664f, -0.07147945f, -0.04227452f, 0.04451329f, 
    0.02432528f, 0.05286325f, -0.02449833f, 0.05790985f, -0.02657150f, 0.00557736f, -0.04963718f, -0.04068881f, 
    -0.01786687f, 0.06828443f, -0.00796571f, 0.03694933f, -0.05846702f, -0.03166270f, -0.04128017f, 0.00822708f, 
    0.01648035f, -0.06295892f, -0.02216594f, 0.02257345f, -0.04243954f, -0.03598179f, -0.02656576f, 0.01568167f, 
    -0.04454093f, 0.04119730f, 0.05812671f, 0.06649108f, -0.06772150f, -0.02110105f, 0.05942312f, -0.00207996f, 
    -0.05800263f, 0.00524598f, -0.08715320f, -0.03997258f, -0.02420770f, 0.07088453f, -0.05134940f, 0.04490377f, 
    -0.09309446f, -0.09257594f, 0.00032077f, -0.08147871f, -0.04768145f, -0.01203654f, 0.00888956f, 0.00327267f, 
    0.57615554f, 0.08725515f, -0.13726826f, 0.01507084f, -0.12280255f, 0.25805748f, 0.10669603f, -0.03088528f, 
    0.09525047f, 0.48274621f, -0.21399233f, 0.36613721f, -0.05037336f, -0.14662094f, -0.07188252f, 0.03963294f, 
    -0.07579982f, -0.20224129f, 0.09551774f, -0.09972144f, 0.18698612f, -0.13316643f, 0.16263363f, -0.01582554f, 
    0.16474135f, 0.03926395f, -0.06535917f, 0.27754158f, 0.07207946f, 0.02852055f, 0.07591764f, -0.11971758f, 
    -0.17019124f, -0.35221383f, 0.28373590f, -0.08884124f, 0.05874969f, 0.00296743f, -0.33989450f, -0.06427858f, 
    -0.01474999f, -0.14684245f, 0.10674413f, -0.00857293f, 0.07815419f, -0.09615231f, 0.31552643f, -0.02290742f, 
    -0.23668067f, -0.40143117f, -0.06035282f, 0.05542999f, 0.11534891f, 0.00680849f, -0.04971927f, -0.45080212f, 
    -0.35910225f, 0.05863922f, 0.03837737f, 0.17867112f, -0.02318248f, 0.02096353f, 0.20599960f, -0.17712490f, 
    0.14037198f, 0.18335457f, -0.12490932f, 0.08735393f, 0.13743630f, -0.07842021f, -0.03355119f, -0.00086577f, 
    -0.00467758f, 0.00041855f, -0.37119734f, 0.13256612f, 0.21414940f, -0.05530669f, -0.18755160f, 0.22162810f, 
    0.14842133f, -0.08107757f, -0.65643638f, 0.31519160f, -0.18860167f, -0.12019636f, 0.11326174f, 0.06473485f, 
    -0.18747528f, -0.07617743f, -1.03616238f, -0.23088202f, -0.26156539f, 0.28282765f, -0.15426725f, 0.10264134f, 
    0.29556608f, 0.14555925f, -0.10651322f, 0.35619631f, -0.17951666f, 0.06051574f, -0.08014182f, 0.17580111f, 
    0.01664772f, -0.02569232f, -0.01310438f, 0.15856452f, -0.18491422f, -0.28435135f, -0.22825709f, 0.22379315f, 
    0.00716868f, 0.02471842f, 0.05477757f, 0.03085954f, -0.14694624f, 0.57124156f, -0.22381820f, 0.00924512f, 
    0.04308310f, 0.13835430f, 0.06448994f, 0.03961597f, 0.17211556f, 0.12280616f, 0.17713979f, 0.54989088f, 
    0.08675572f, 0.22392762f, -0.00855199f, -0.10500067f, -0.04654947f, 0.13035630f, 0.06344985f, -0.68008870f, 
    -0.09780978f, -0.12999500f, 0.10818480f, 0.13404641f, 0.14984077f, -0.28719217f, 0.23623288f, 0.23952439f, 
    -0.20451529f, -0.13279976f, 0.10032295f, 0.06965632f, -0.17520931f, -0.07332181f, 0.08937573f, 0.23192787f, 
    -0.26031530f, 0.42471632f, -0.37218454f, -0.34741876f, 0.04792487f, 0.14930686f, -0.24602725f, 0.01791731f, 
    0.16667655f, 0.19704646f, -0.29366380f, -0.11082770f, -0.07736095f, 0.21940728f, 0.22220944f, 0.12277172f, 
    0.01229309f, 0.17383845f, 0.01128372f, -0.43398684f, -0.61131161f, -0.22001573f, -0.06469671f, -0.06312452f, 
    0.11245678f, 0.08520957f, 0.05079700f, 0.17464358f, 0.34303862f, -0.19396435f, -0.17255354f, -0.13913885f, 
    -0.18735845f, -0.03178742f, 0.02927202f, 0.19873956f, -0.15325774f, 0.13259365f, -0.06208746f, -0.13604055f, 
    -0.28753978f, -0.35933650f, -0.01474280f, -0.02831287f, -0.04573642f, 0.07151254f, -0.38198492f, -0.23997968f, 
    0.25787681f, 0.17015631f, -0.09776172f, -0.25954536f, -0.30625165f, -0.31838706f, -0.04070893f, 0.21346943f, 
    -0.03739902f, 0.21735506f, 0.12060444f, -0.01276013f, 0.33707556f, -0.11868757f, 0.04813637f, 0.06128067f, 
    0.21334308f, 0.36120260f, -0.15306889f, -0.03671733f, -0.36648649f, 0.07531171f, 0.05215093f, 0.10940457f, 
    -0.12238782f, 0.01515318f, -0.27155671f, 0.09950715f, 0.11138404f, 0.13973969f, 0.13809107f, 0.11179212f, 
    0.08757366f, 0.11165256f, -0.28801063f, 0.05710484f, 0.12132382f, -0.06102731f, 0.14475620f, 0.05038505f, 
    0.18112043f, 0.24004407f, 0.06371524f, -0.74091303f, -0.87740844f, -0.05614072f, -0.09602864f, 0.14618962f, 
    0.18550542f, -0.03550006f, 0.10879403f, -0.05770305f, 0.03286833f, 0.32326505f, -0.28287849f, -0.12276860f, 
    -0.08634058f, 0.09348288f, -0.11063942f, 0.27172539f, 0.50752723f, 0.02668852f, -0.43486241f, 0.28171808f, 
    0.18217902f, 0.03838319f, 0.12945162f, 0.03924352f, -0.09909320f, 0.02410046f, 0.07038794f, 0.51356250f, 
    0.13709469f, 0.05829810f, 0.11249163f, -0.36230156f, 0.21535604f, 0.18364316f, -0.19696520f, -0.10179271f, 
    -0.17918706f, -0.22472934f, -0.08995300f, 0.12015180f, -0.27243590f, 0.22996022f, 0.09318732f, -0.16428824f, 
    -0.00117898f, -0.01044428f, 0.36555368f, -0.20492555f, 0.26878712f, -0.26097241f, -0.04884245f, 0.04912405f, 
    0.39369294f, -0.09783487f, -0.47733077f, -0.09821825f, -0.37060171f, -0.00670339f, -0.21642596f, -0.02820194f, 
    -0.20638525f, 0.01715165f, -0.01067089f, 0.17281730f, 0.29486132f, -0.00392683f, 0.27604929f, 0.01294568f, 
    0.01999155f, 0.30885214f, 0.06902057f, 0.15387231f, 0.05978451f, -0.34855309f, -0.02500010f, 0.07049874f, 
    0.04884462f, 0.06698758f, -0.29385588f, -0.16253057f, -0.73928219f, -0.22726694f, 0.29259416f, -0.11983169f, 
    0.02116181f, -0.01313169f, 0.29825351f, 0.11143468f, -0.00092495f, -0.51644260f, -0.17492083f, -0.51257855f, 
    0.10156248f, 0.23705375f, -0.14388938f, 0.23481515f, -0.12415534f, -0.15605082f, -0.18178959f, 0.33803853f, 
    0.50084424f, 0.14474055f, 0.15004392f, 0.08979139f, 0.33437178f, 0.21429850f, 0.05709741f, 0.14525427f, 
    0.24249710f, -0.03029563f, 0.06437808f, 0.24151523f, 0.18584001f, 0.00327980f, 0.12357234f, 0.06838434f, 
    -0.38144520f, -0.01450596f, -0.21954037f, 0.12671021f, -0.09053276f, -0.14789806f, 0.10149125f, 0.14800088f, 
    0.02969955f, 0.59771430f, 0.36451173f, -0.04676539f, -0.43327552f, 0.10572456f, 0.16966070f, -0.01383542f, 
    -0.02442024f, 0.13947558f, -0.11926027f, 0.05545630f, 0.21212779f, 0.22698553f, 0.25715885f, 0.02666083f, 
    0.24735940f, -0.20396003f, -0.18443798f, -0.07059243f, 0.26269212f, 0.26148823f, 0.27126780f, 0.11238628f, 
    0.01445162f, -0.30211142f, -0.00499382f, 0.06825105f, -0.46126658f, -0.34751752f, -0.40695751f, 0.11922753f, 
    0.18072480f, 0.08631034f, -0.05287275f, -0.01169294f, 0.08662874f, 0.06388136f, 0.26198319f, 0.38521636f, 
    -0.02461954f, -0.21232668f, 0.05657076f, 0.09177665f, 0.05218104f, -0.12361575f, -0.40240917f, -0.70306343f, 
    -0.75009435f, 0.24579576f, 0.21450922f, 0.21582785f, -0.03307918f, -0.16011879f, -0.05739698f, 0.46472153f, 
    -0.07981602f, 0.07437529f, 0.24734139f, 0.12808824f, 0.05529674f, 0.04023802f, 0.24637146f, 0.07171215f, 
    -0.02248372f, -0.03274835f, -0.39286676f, 0.11355048f, 0.26178706f, 0.25801006f, -0.01865097f, -0.07311855f, 
    0.09314835f, -0.23527320f, -0.24685375f, -0.39228618f, -0.05560355f, -0.04639315f, -0.23230074f, 0.12079179f, 
    -0.04705667f, 0.12620297f, -0.24231660f, -0.10414658f, 0.01663881f, 0.09592835f, 0.02888928f, 0.01941884f, 
    -0.02176188f, -0.10576746f, -0.06050136f, 0.36467800f, 0.26048389f, -0.28129581f, -0.14459418f, 0.06776609f, 
    -0.22717425f, 0.19217451f, -0.02727824f, 0.17108501f, -0.02723913f, -0.08193343f, -0.55697113f, -0.12430541f, 
    -0.02880811f, -0.04448014f, 0.07908512f, -0.24790804f, -0.06148051f, -0.46747491f, 0.24914174f, -0.07548432f, 
    -0.00870850f, -0.00344596f, 0.13701811f, -0.07318996f, -0.01493034f, -0.00250184f, 0.07439817f, 0.03555472f, 
    0.28305486f, 0.09382024f, 0.12716003f, 0.12968148f, 0.18475294f, 0.26028723f, 0.23947495f, -0.07752575f, 
    -0.82220870f, -0.66538316f, 0.08946888f, 0.00465277f, 0.15015487f, 0.17304222f, -0.04137944f, 0.12299678f, 
    0.46520200f, 0.37195253f, 0.34609598f, -0.17475061f, -0.30972764f, -0.07118136f, 0.12436611f, -0.16654170f, 
    -0.00370387f, 0.20023829f, -0.17078671f, -0.00795054f, 0.18048620f, 0.09660531f, 0.13059382f, -0.04983961f, 
    -0.05005927f, 0.22081754f, 0.35202116f, 0.50468141f, 0.08527866f, 0.07868320f, -0.30117509f, 0.00629557f, 
    -0.07898585f, -0.01216934f, 0.46824852f, -0.02165072f, -0.19573078f, -0.24524146f, -0.02585185f, -0.03143337f, 
    -0.04980851f, -0.13599658f, 0.00106841f, -0.02328846f, 0.21783060f, 0.02725342f, -0.08605560f, 0.23857650f, 
    -0.06892857f, 0.06012950f, -0.02518010f, -0.02823367f, 0.23408180f, 0.05767882f, 0.07404281f, 0.24995807f, 
    0.12757942f, 0.13802679f, 0.10541898f, 0.01767441f, -0.09836680f, 0.04672981f, -0.20251803f, -0.16963995f, 
    0.48679668f, -0.26641276f, 0.06552763f, -0.24760476f, -0.08525360f, 0.01096109f, -0.10101723f, 0.45550042f, 
    0.02501741f, 0.30921429f, -0.07545945f, -0.05570567f, -0.08059310f, 0.15010589f, -0.08953833f, -0.12069981f, 
    0.34331542f, 0.48096195f, 0.37332606f, -0.22338614f, 0.09652431f, 0.15584375f, 0.03676859f, -0.04008383f, 
    0.09744086f, -0.36554340f, 0.15580571f, 0.21586923f, -0.13049723f, -0.42292127f, 0.10984545f, 0.11919528f, 
    0.19307441f, 0.21199615f, -0.11795491f, -0.43602753f, -0.16622624f, 0.12530288f, 0.16094489f, 0.16193795f, 
    -0.04252509f, -0.23046707f, -0.01674846f, 0.15398762f, 0.06115369f, 0.36917523f, -0.00590423f, 0.07617030f, 
    0.05662517f, -0.18261768f, 0.10836093f, 0.04360445f, -0.05366609f, 0.31673178f, 0.24739465f, 0.04497122f, 
    -0.20128599f, -0.27544194f, 0.02673411f, -0.03757934f, -0.00233511f, 0.18790744f, 0.42277911f, -0.04242691f, 
    -0.04771435f, 0.04302484f, -0.26924843f, 0.05536608f, -0.12017459f, 0.01596121f, 0.24794514f, 0.13989356f, 
    0.00510089f, 0.05484284f, 0.21132603f, 0.06345994f, 0.08277474f, 0.07896845f, -0.18605025f, 0.08815441f, 
    -0.22943716f, -0.08921205f, -0.05106805f, -0.05132223f, -0.35234973f, 0.01780897f, -0.06713857f, 0.05080642f, 
    -0.22245455f, 0.09859552f, 0.21110657f, -0.15743597f, 0.27235600f, -0.21469438f, 0.26510018f, -0.03105811f, 
    0.09997350f, -0.05207558f, -0.17262168f, -0.24019498f, -0.23376414f, 0.02442193f, -0.03741549f, 0.00940434f, 
    0.10592523f, -0.18815416f, 0.36364269f, -0.09443641f, 0.28110304f, 0.03754716f, -0.03473835f, 0.23178448f, 
    -0.13258746f, 0.10522913f, -0.31840059f, -0.10207026f, -0.33889616f, -0.11272402f, 0.02123711f, 0.11987766f, 
    -0.07411239f, 0.12475355f, 0.01972991f, -0.16599578f, 0.24348167f, -0.05068263f, -0.46664938f, 0.08005705f, 
    -0.26763201f, -0.10168011f, 0.03093443f, -0.03470087f, -0.18000379f, -0.61959660f, -0.05151577f, -0.28067040f, 
    0.01463733f, 0.00981909f, -0.08868637f, -0.00607824f, -0.08130355f, -0.14641464f, 0.08391008f, 0.10842630f, 
    0.73229557f, -0.09093205f, 0.03349113f, 0.25939974f, -0.20427923f, 0.19740964f, 0.24253140f, 0.41013607f, 
    0.16219029f, -0.16078217f, -0.17628407f, -0.09139916f, -0.02412602f, 0.27854386f, 0.17476706f, -0.04430656f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.06836054f, 0.31707832f, -0.01353372f, -0.14445873f, -0.03024941f, -0.05131738f, 0.27424869f, 0.06476881f, 
    0.04665371f, -0.09937610f, 0.05301596f, -0.12582141f, 0.24748081f, 0.38750049f, 0.08554963f, -0.23562215f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06737053f, -0.16158074f, 0.22659184f, 0.35883713f, 0.09157776f, 0.19632928f, -0.06373684f, 0.74202406f, 
    0.11388206f, 0.09966736f, -0.02443410f, -0.18186423f, -0.18336378f, -0.17355418f, -0.29923663f, 0.06550580f, 
    -0.12632121f, -0.11261545f, -0.09614315f, 0.05741531f, 0.02756839f, -0.05164784f, -0.67709929f, 0.45184234f, 
    -0.16067682f, -0.16096942f, 0.03262241f, -0.09022099f, -0.03716892f, 0.14393523f, 0.50181341f, -0.54118663f, 
    0.17444269f, 0.92832857f, 0.11048125f, 0.42399037f, 0.01744591f, -0.05801931f, 0.33979535f, -0.63800430f, 
    -0.04507183f, 0.16634919f, 0.23006861f, -0.58215880f, -0.68354553f, -0.28794664f, 0.24173352f, -0.32874697f, 
    0.03009957f, 0.39336461f, -0.14801794f, -0.28588089f, 0.22145838f, -0.15360758f, 0.23283370f, -0.63750720f, 
    -0.08183991f, 0.06764140f, 0.23000513f, 0.52893853f, 0.45158657f, -0.39620334f, -0.33485541f, -0.23346275f, 
    -0.01944434f, -0.00334349f, 0.20548585f, -0.89322925f, -0.22627668f, -0.22602972f, 0.36098588f, 0.14701591f, 
    -0.20826580f, -0.24252567f, -0.11527582f, -0.05306644f, -0.21434514f, 0.08383486f, -0.08981369f, 0.15608378f, 
    0.18506970f, -0.39542374f, 0.15673600f, -0.55766451f, 0.22695661f, 0.13566904f, -0.47248179f, 0.31209999f, 
    -0.01280317f, 0.15075369f, -0.03191891f, 0.14604950f, -0.16794075f, 0.51409906f, 0.01600342f, -0.47355330f, 
    0.07478783f, -0.24649979f, 0.02031472f, 0.62291569f, 0.19853684f, -0.06025087f, -0.13832334f, -0.33528423f, 
    0.04153319f, -0.16446857f, 0.00513545f, -0.23148695f, -0.18583299f, 0.54795873f, -0.84608108f, -0.21319246f, 
    -0.18693951f, -0.03955031f, -0.21066512f, -0.19194293f, 0.13252717f, 0.18345273f, -0.74708778f, -0.29099199f, 
    -0.16088974f, -0.12934448f, -0.20706250f, 0.42030928f, -0.08227213f, -0.53741902f, -0.15198438f, 0.98016435f, 
    0.07394957f, -0.82725585f, -0.16953152f, 0.06944948f, 0.09024582f, 0.04849089f, 0.23724408f, 0.12781365f, 
    0.11023184f, -0.23462015f, 0.10155577f, -0.56441039f, 0.85939074f, -0.33815086f, 0.92918515f, 0.13630998f, 
    -0.17133386f, -0.36295542f, 0.09874986f, -0.41578215f, 0.02890978f, 0.17421137f, 1.21119452f, -0.05398263f, 
    0.17644489f, -0.09038990f, -0.10838922f, -0.34995279f, -0.10546729f, 0.18678747f, -0.42583233f, 0.13739648f, 
    -0.06221363f, 0.93572283f, -0.04927481f, -0.24375892f, 0.04873781f, 0.02224386f, -0.21957862f, -0.56704009f, 
    0.16470002f, 0.15985191f, 0.22145623f, -0.46241659f, 0.66919690f, -0.54374033f, 0.28523213f, -0.35357338f, 
    -0.03920631f, 0.20820469f, -0.20890623f, 0.61115390f, -0.10858886f, -0.06081859f, -0.39613992f, -0.54583937f, 
    -0.20043097f, -0.00529632f, -0.04004949f, 0.71613836f, -0.26649243f, -0.31813902f, 0.10212510f, -0.11208377f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01486246f, -0.51141000f, -0.37854728f, -0.37379751f, 0.99845660f, 0.11218105f, 0.23808928f, -1.23263049f, 
    -0.97140205f, 0.08269630f, 0.38163117f, 0.53963131f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
