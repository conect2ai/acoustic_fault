#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24858661f, 0.49012393f, 0.78748280f, 0.40522805f, -0.44370940f, 0.01286155f, -0.56042492f, -0.34318152f, 
    -0.08286241f, -0.12929569f, -0.05087991f, -0.14894621f, -0.19754963f, 0.23905034f, 0.09400119f, 0.24780774f, 
    -0.10796855f, -0.22277263f, -0.22428341f, -0.34391063f, 0.13778900f, 0.05562542f, -0.12021191f, 0.20046797f, 
    -0.07278856f, -0.38924929f, 0.54305702f, 0.57453680f, -0.25646532f, 0.13245343f, -0.18200980f, -0.35718501f, 
    -0.08646625f, 0.55951083f, -0.51216757f, -0.34414586f, 0.21388763f, 0.12995043f, -0.15167837f, -0.27145261f, 
    -0.01787273f, 0.08386371f, 0.07642174f, -0.14934860f, 0.12602615f, 0.15072799f, 0.07172129f, 0.04325175f, 
    -0.29156643f, -0.28352094f, 0.32180482f, 0.56836355f, -0.14157008f, -0.37546882f, -0.41423216f, 0.27103683f, 
    -0.57488269f, -0.40771675f, -0.19146270f, -0.63279545f, 0.40386757f, 0.21135058f, 0.28606570f, 0.48582122f, 
    0.18182673f, 0.38953629f, -0.20977621f, 0.03015108f, -0.18109727f, -0.30204478f, -0.19811280f, 0.05132747f, 
    0.15228420f, -0.11616620f, 0.09369806f, -1.03353763f, -0.12723720f, -0.53245717f, -0.45531359f, 0.54839748f, 
    -0.18056160f, -0.05930842f, 0.16952801f, 0.45967689f, 0.11892118f, 0.28405693f, -0.06771085f, -0.09762309f, 
    0.12674135f, 0.17734140f, -0.08293557f, -0.01601260f, -0.02060445f, 0.06989779f, -0.17712657f, -0.05838224f, 
    -0.00511428f, 0.12048545f, -0.14280385f, -0.32729954f, 0.38220304f, -0.11569721f, 0.12993515f, 0.35166264f, 
    0.05041301f, 0.29138538f, 0.10729495f, 0.16330314f, 0.03955407f, -0.07013049f, 0.04573096f, -0.05159618f, 
    -0.29424304f, -0.16647241f, -0.08333877f, 0.20104007f, 0.23525685f, -0.06776306f, -0.09940346f, 0.08744565f, 
    0.06415594f, 0.00975142f, -0.01686284f, -0.33938360f, -0.28617013f, 0.06211914f, -0.09463563f, 0.30975479f, 
    -0.03861985f, -0.53872502f, -0.31926367f, -0.17617154f, -0.45050392f, -0.25787002f, -0.62666827f, -0.03535118f, 
    -0.18091211f, 0.25167671f, -0.26407582f, -0.15934977f, 0.11983391f, -0.11946817f, -0.03941495f, -0.13153449f, 
    0.01544355f, -0.00477552f, -0.15985906f, -0.02340025f, -0.42428872f, 0.00143100f, -0.20158817f, -0.29267016f, 
    -0.37504584f, -0.07593859f, -0.26551545f, -0.25551268f, -0.25629997f, -0.20321298f, -0.03997196f, -0.45652920f, 
    0.45679316f, -0.37503570f, -0.14408864f, 0.36137095f, -0.46721724f, -0.23238133f, -0.25518307f, -0.00329137f, 
    -0.27546883f, -0.33855286f, 0.07018220f, 0.30677566f, -0.30298808f, 0.34678096f, 0.31867233f, 0.11068099f, 
    -0.37023258f, -0.11107420f, 0.17997985f, 0.54303926f, -0.04487456f, -0.13104454f, -0.04666294f, 0.32120270f, 
    0.48650986f, -0.16901785f, 0.17887652f, -0.30688131f, -0.15359327f, 0.57841724f, -0.15759391f, -0.13006575f, 
    -0.09275498f, -0.14542022f, -0.10712447f, 0.23976220f, -0.35243234f, 0.29108262f, 0.02479405f, 0.01599914f, 
    -0.31300873f, -0.06728490f, -0.25918412f, 0.69661254f, 0.16406326f, -0.46308270f, -0.50473964f, -0.29817387f, 
    0.15157598f, 0.36139435f, 0.50172246f, -0.45542532f, 0.32847887f, -0.02534076f, -0.15859470f, -0.03804148f, 
    0.11180723f, 0.29731986f, -0.11091224f, -0.56703526f, -0.29498026f, -0.16696990f, 0.21121502f, 0.18335170f, 
    0.13426928f, -0.34890455f, 0.15074860f, 0.28603798f, 0.26016155f, 0.32691705f, 0.17470811f, -0.17129362f, 
    0.23260169f, -0.19898908f, 0.09416641f, -0.02965497f, -0.16692871f, 0.13751021f, -0.11056699f, 0.25174922f, 
    -0.01533611f, -0.01143658f, -0.07379285f, -0.00452618f, -0.24501683f, -0.24181092f, -0.04984994f, 0.03631321f, 
    -0.21850918f, -0.19590025f, -0.71801007f, -0.45968142f, -0.30742410f, -0.22203641f, 0.12178908f, 0.51186633f, 
    -0.00906194f, -0.42142829f, -0.44460729f, -0.21031830f, 0.21692190f, -0.21569864f, -0.35411140f, 0.09725893f, 
    -0.57570964f, 0.07490203f, -0.08927887f, -0.13685453f, -0.20802139f, -0.05964128f, -0.31958652f, -0.34657922f, 
    -0.10481153f, 0.07212172f, 0.04404265f, -0.49587932f, 0.41631866f, -0.18205573f, 0.09428721f, 0.49005646f, 
    -0.51775253f, -0.27481383f, 0.14364697f, 0.37591967f, 0.33423477f, -0.04216405f, -0.45502174f, 0.26463160f, 
    0.35330600f, -0.10765521f, 0.05809922f, -0.00253199f, -0.35933384f, -0.04607357f, 0.15470907f, 0.11932486f, 
    -0.10373121f, -0.06932703f, 0.05684597f, -0.36046708f, -0.11855312f, -0.13911112f, 0.12230311f, 0.21740589f, 
    -0.23210773f, -0.03392901f, 0.13933408f, 0.13737319f, -0.03144192f, -0.00557362f, 0.08807900f, 0.36355031f, 
    -0.48809052f, 0.50051612f, -0.31219250f, -0.00979821f, -0.20072106f, -0.21822147f, 0.13784896f, 0.18666795f, 
    0.23286144f, -0.16991453f, 0.20963109f, 0.07265609f, -0.20157762f, 0.13844715f, 0.04654432f, 0.01610072f, 
    0.43127859f, -0.50358093f, 0.38947007f, 0.02614943f, 0.13809367f, -0.17188165f, 0.50763905f, -0.22330427f, 
    0.75548398f, -0.24511337f, -0.44258887f, -0.17647649f, -0.06129180f, -0.06937675f, 0.04276329f, -0.20484073f, 
    -0.17064410f, 0.27748072f, 0.13624984f, 0.15703607f, -0.09801674f, 0.07472935f, -0.50195801f, 0.26951507f, 
    0.32190785f, -0.12031391f, -0.20793113f, 0.07278767f, -0.42407340f, 0.68895119f, 0.10575818f, 0.01591365f, 
    0.16735703f, -0.43240318f, 0.72470665f, -0.49741441f, 0.06584895f, -0.02566474f, -0.24710080f, -0.05423649f, 
    -0.00153182f, -0.03878465f, 0.17370944f, -0.23766886f, 0.18445168f, -0.11729049f, 0.36999172f, -0.17309481f, 
    -0.28770971f, -0.30714685f, 0.24525332f, -0.31125563f, 0.68002146f, -0.36212122f, 0.02033321f, 0.27301481f, 
    0.61169940f, 0.45991796f, -0.26648250f, -0.34100083f, 0.20020510f, 0.20162907f, -0.41201237f, -0.15622523f, 
    0.09508705f, 0.12166769f, -0.08359669f, -0.10197762f, 0.13951559f, 0.19806996f, -0.09212895f, -0.02398801f, 
    -0.12474785f, 0.00168165f, -0.87119555f, -0.61089748f, -0.03046259f, 0.50885159f, 0.57766414f, 0.30619547f, 
    -0.52211505f, -0.36886364f, -0.01357600f, -0.12119687f, -0.02039750f, 0.29106092f, -0.13603260f, -0.47582024f, 
    -0.49920091f, -0.02766444f, -0.04936084f, 0.08756905f, 0.32177234f, 0.23142338f, -0.23863468f, 0.20560260f, 
    0.13566805f, 0.58872420f, 0.32347724f, -0.52023715f, 0.20147745f, -0.11161248f, -0.16241351f, -0.31311107f, 
    0.18076991f, 0.28124696f, 0.14007021f, 0.03309808f, 0.08080169f, -0.30386797f, 0.17635624f, 0.28788373f, 
    -0.00019548f, -0.06861840f, 0.15930775f, -0.23196742f, -0.12539972f, -0.19685620f, 0.13460156f, 0.23237230f, 
    -0.17624614f, -0.02532515f, 0.19455002f, -0.44776025f, -0.31885132f, 0.13098787f, 0.22483635f, -0.22448872f, 
    0.14968662f, 0.18580569f, 0.03600688f, -0.36372203f, 0.17768760f, -0.11042270f, 0.10611400f, 0.29236165f, 
    0.16120219f, -0.10094053f, -0.17188253f, -0.14937259f, -0.19073531f, 0.15486251f, 0.14434941f, 0.08044375f, 
    0.31432018f, 0.33548900f, 0.15108928f, -0.85304886f, -0.32303092f, -0.05853833f, -0.16826764f, -0.18343674f, 
    -0.23145261f, -0.57044303f, -0.43075392f, -0.50767833f, 0.23569632f, 0.04455970f, 0.43527746f, 0.18273684f, 
    0.52091378f, -0.17350274f, 0.01221082f, 0.10169757f, 0.12901439f, -0.16117127f, -0.08015249f, 0.16240509f, 
    0.34863338f, 0.18192118f, -0.09485301f, 0.08521139f, 0.40948486f, -0.16316481f, -0.03863199f, 0.08352848f, 
    -0.11689916f, -0.22727177f, 0.21561360f, 0.22906475f, -0.11335111f, -0.12012643f, 0.07393361f, 0.16302067f, 
    -0.37259847f, -0.01130109f, 0.34296796f, 0.18014283f, -0.16497961f, -0.12946534f, -0.01082019f, 0.08135778f, 
    -0.24254356f, 0.04259308f, 0.31180120f, -0.23520857f, 0.36269540f, 0.28274688f, -0.27527353f, -0.20411578f, 
    0.24632947f, 0.10291046f, 0.54494530f, -0.50133908f, -0.10471036f, 0.15647358f, 0.16820295f, -0.06473082f, 
    0.14337654f, -0.20874275f, -0.23576641f, -0.13824065f, -0.20662637f, -0.02118810f, 0.27454272f, -0.28070778f, 
    0.19471054f, -0.32765305f, 0.21671036f, 0.24886392f, 0.17434785f, -0.21684833f, 0.01899419f, 0.25366113f, 
    0.43471527f, 0.12420057f, -0.40882102f, -0.35388568f, -0.05516735f, 0.28586304f, -0.02576532f, -0.04325366f, 
    0.03931158f, -0.28601602f, 0.05770625f, 0.07085844f, 0.04936286f, 0.20866200f, -0.00903816f, 0.02511423f, 
    0.20458692f, -0.27280569f, -0.10141674f, -0.03727340f, -0.40098107f, -0.38786018f, -0.42250571f, 0.61366206f, 
    0.68621778f, -0.17307940f, -0.03828830f, -0.18167394f, -0.66885293f, -0.24390474f, 0.08789029f, -0.11454519f, 
    0.39268169f, -0.02759498f, 0.24437176f, -0.32630095f, -0.33254009f, 0.15794629f, 0.03994809f, 0.18231381f, 
    -0.14063750f, 0.03474384f, -0.26063916f, -0.15212891f, 0.10205036f, -0.03463960f, -0.21826255f, -0.12755860f, 
    -0.78733844f, 0.62102991f, 0.61656082f, -0.18924940f, -0.21421832f, 0.08779994f, -0.67730111f, -0.16647670f, 
    0.52501291f, 0.27532005f, -0.15950796f, -0.37830436f, -0.26893297f, -0.29636043f, 0.01272785f, 0.06829378f, 
    0.18609691f, 0.32869309f, 0.09598862f, 0.24515684f, -0.09235673f, -0.11903021f, -0.22994028f, -0.21218941f, 
    -0.07959183f, -0.92872310f, 0.12871832f, -0.41886002f, -0.81092256f, 0.10920965f, 0.02968159f, -0.19673744f, 
    0.22930081f, 0.83606696f, -0.40116701f, -0.20388988f, -0.55141318f, 0.13739717f, -0.54936129f, -0.15381294f, 
    0.19977091f, 0.14916527f, -0.26106817f, 0.13234076f, 0.25689173f, -0.02707132f, 0.21682577f, -0.03881266f, 
    0.03127078f, 0.00245245f, 0.23941509f, 0.40240309f, 0.30326071f, -0.40520591f, -0.06550597f, -0.30829662f, 
    -0.29750532f, 0.09329718f, -0.25595877f, 0.28683692f, -0.29701588f, -0.09416226f, 0.36376619f, -0.13276739f, 
    -0.03439715f, 0.38151985f, -0.23499349f, -0.15195410f, 0.32175142f, -0.29087871f, -0.03177998f, 0.30002460f, 
    -0.08142372f, -0.22630434f, 0.18681926f, 0.54570574f, 0.12103108f, 0.10864148f, -0.25363117f, -0.61332226f, 
    -0.17070876f, -0.35551992f, -0.21502613f, 0.38120615f, 0.24102823f, 0.03276524f, 0.26534647f, 0.15422677f, 
    -0.21994451f, -0.00916553f, -0.09509630f, 0.06065374f, -0.51417685f, -0.21855609f, -0.07326213f, 0.05533305f, 
    0.04875276f, -0.06218256f, -0.11029048f, -0.47676444f, 0.18303947f, -0.17192855f, -0.62024212f, -0.70689982f, 
    -0.52864480f, 0.00070398f, -0.12686457f, 0.45207128f, 0.11996953f, 0.05509449f, 0.17707630f, 0.36398664f, 
    0.19166137f, 0.09952944f, 0.13882460f, 0.01468598f, 0.29741329f, -0.17474116f, -0.16703244f, 0.08896369f, 
    0.01142106f, -0.18550214f, -0.25270343f, -0.01548194f, -0.02308526f, 0.49236387f, 0.39136636f, -0.19402885f, 
    -0.32581747f, 0.10322540f, 0.15026890f, 0.11718800f, 0.13761519f, 0.03770236f, 0.08599001f, -0.04526065f, 
    -0.21007825f, 0.33676812f, -0.34625912f, -0.19751039f, 0.17437853f, 0.01728077f, -0.17813221f, -0.01692008f, 
    -0.00381581f, -0.31213042f, 0.02663730f, -0.10029553f, -0.04763681f, -0.35968900f, -0.28759688f, -0.52962488f, 
    -0.76163477f, -0.33381319f, -0.60588825f, 0.69400489f, 0.15037726f, 0.40988415f, 0.29212114f, 0.26942694f, 
    -0.14091808f, 0.00521140f, 0.01620687f, 0.05982140f, -0.21061413f, -0.06536646f, -0.11767497f, -0.15125763f, 
    0.37688047f, 0.20309581f, -0.09787931f, 0.00876747f, 0.09363844f, -0.03920605f, -0.40593189f, -0.25249833f, 
    -0.25250790f, -0.38359076f, -0.55141109f, -0.42661676f, 0.10567849f, -0.17046002f, 0.10839803f, -0.05341724f, 
    0.22832802f, -0.28271347f, -0.21629414f, 0.01171774f, 0.24512231f, 0.07337265f, 0.01097495f, -0.05796269f, 
    0.01295447f, -0.00611144f, -0.36365244f, -0.21073769f, -0.17983365f, -0.19044656f, -0.26612198f, -0.27101120f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01021683f, 0.05626624f, -0.02563729f, -0.09696337f, -0.00906216f, 0.00320247f, -0.23295960f, 0.23416167f, 
    -0.01502033f, 0.09486591f, -0.12135445f, 0.17949481f, 0.26158845f, -0.18309864f, 0.02766872f, 0.09118034f, 
    0.09051835f, -0.07525225f, -0.17612243f, 0.17029651f, 0.30513194f, 0.07440302f, -0.12910360f, 0.18486175f, 
    -0.15813142f, -0.09184793f, 0.25779966f, -0.12340966f, 0.29453164f, -0.05174233f, 0.14557065f, -0.05538742f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14509915f, 0.32952923f, 0.29529560f, 0.34454918f, -0.05543299f, -0.11912495f, 0.11951248f, -0.14494576f, 
    -0.02489408f, -0.01312655f, -0.02098854f, -0.00283152f, 0.41170773f, -0.06948981f, 0.08939335f, -0.16367131f, 
    0.05985955f, -0.01017904f, 0.16577485f, -0.04957804f, -0.02436710f, 0.16675743f, -0.15176158f, 0.10542578f, 
    -0.31001067f, -0.16422613f, 0.43373033f, 0.23947310f, 0.10887554f, 0.04866338f, 0.13186811f, 0.10945783f, 
    -0.01878944f, -0.00222580f, 0.01090816f, 0.02538357f, 0.31584793f, 0.02438375f, -0.15572876f, 0.10321531f, 
    0.08202527f, -0.15643512f, -0.09648048f, -0.17806005f, -0.18351668f, 0.01779811f, -0.03144852f, 0.02295811f, 
    0.05599411f, 0.06747615f, 0.10736679f, 0.05753776f, -0.02552581f, -0.00840146f, 0.09801543f, 0.08967886f, 
    -0.00668445f, 0.11301108f, 0.13103704f, -0.01018436f, -0.16212912f, -0.26275909f, 0.12170563f, 0.18509740f, 
    -0.03867850f, 0.01365218f, 0.19972803f, -0.01040842f, 0.04709322f, 0.01755496f, -0.06752058f, -0.06435734f, 
    -0.09959429f, -0.17874323f, -0.23746325f, 0.26674065f, -0.06754504f, -0.10493910f, -0.01562603f, 0.05836134f, 
    0.04635709f, 0.18234654f, -0.00060132f, 0.08931356f, 0.12471485f, 0.02203595f, -0.02205119f, -0.36221352f, 
    0.08265699f, 0.04340567f, -0.00959083f, -0.17755593f, -0.05018265f, 0.08103258f, 0.03219886f, 0.07134117f, 
    0.11879773f, 0.00725595f, -0.10141781f, 0.24387778f, -0.07786021f, 0.01028829f, 0.03166211f, -0.10689647f, 
    -0.00899346f, -0.05204115f, 0.03526620f, -0.05088135f, 0.19013721f, 0.07349762f, -0.06539716f, -0.18340486f, 
    -0.07693759f, 0.00446076f, -0.13522661f, -0.05373396f, -0.04471355f, 0.06033871f, 0.08453623f, 0.07359157f, 
    -0.29871571f, -0.12522455f, -0.13526326f, 0.13435012f, 0.13580123f, 0.01683220f, -0.02938656f, -0.02739268f, 
    0.03178692f, 0.11903731f, 0.00287710f, 0.03722261f, 0.41498321f, 0.11585300f, -0.25277275f, -0.22354981f, 
    -0.12672196f, 0.02170517f, -0.00029199f, -0.07000098f, -0.01452358f, 0.21482907f, -0.13282798f, -0.14455281f, 
    0.05112372f, 0.33674017f, 0.02434164f, -0.16339318f, 0.10880055f, -0.12553674f, -0.03361684f, 0.04076182f, 
    -0.03921279f, -0.15171498f, 0.08955248f, 0.04553398f, -0.12260972f, 0.10447488f, 0.25795904f, 0.06853952f, 
    -0.06342296f, 0.18843433f, 0.00314376f, 0.08786149f, -0.06544268f, 0.00630898f, -0.10894836f, -0.01525679f, 
    0.54520190f, -0.01114368f, -0.04157271f, -0.02532683f, 0.07086919f, 0.08033635f, -0.13664483f, 0.09492968f, 
    -0.00067460f, -0.04207809f, 0.11847417f, -0.01106674f, 0.15362434f, 0.04273418f, 0.12703906f, 0.06425514f, 
    -0.00422170f, -0.00071269f, 0.11355944f, -0.20101380f, -0.05581840f, -0.01453878f, -0.08099623f, 0.09706610f, 
    0.08564629f, -0.02323638f, 0.24985982f, 0.29652557f, -0.08171486f, -0.17141418f, 0.18622462f, 0.01861157f, 
    -0.15259553f, -0.00200603f, 0.04603389f, -0.01882425f, -0.15857892f, 0.04704872f, 0.02211791f, -0.01927072f, 
    0.00230466f, 0.02658393f, -0.08580705f, -0.10457864f, 0.02710668f, -0.13421404f, 0.25797549f, 0.16231585f, 
    0.03614904f, 0.03355632f, -0.00386156f, -0.06988811f, 0.04157747f, -0.07136726f, -0.00074413f, 0.22641942f, 
    0.01868226f, 0.00355516f, 0.04325718f, 0.05670888f, -0.03321874f, -0.09343272f, -0.21647836f, 0.11477450f, 
    -0.05590235f, -0.02002899f, -0.10599295f, -0.01606740f, -0.12276384f, 0.10194084f, -0.07024454f, -0.00886209f, 
    -0.07831284f, 0.03673264f, -0.04242836f, -0.07100784f, 0.10613988f, 0.13856642f, -0.02459517f, -0.06482759f, 
    0.02820769f, 0.05433653f, 0.15472087f, -0.00702038f, -0.23675343f, -0.01624544f, 0.16870116f, 0.03309291f, 
    -0.01946598f, -0.03226489f, 0.01926091f, -0.02493231f, -0.01339359f, 0.09389797f, -0.07361647f, -0.01019439f, 
    0.08356704f, 0.00818443f, 0.08379518f, 0.03158664f, -0.13365720f, 0.02266695f, -0.02180010f, -0.00128490f, 
    0.07507642f, 0.07280788f, 0.01285600f, -0.00039054f, -0.24852577f, 0.05566019f, 0.02375189f, -0.06552324f, 
    -0.13897891f, 0.01730551f, -0.11810007f, -0.04945643f, -0.03451406f, -0.01723619f, -0.03891777f, 0.07232451f, 
    0.54472613f, -0.15006018f, -0.08033871f, -0.08729890f, -0.04322959f, 0.00131729f, 0.11712896f, -0.21013422f, 
    0.04789318f, -0.03281982f, -0.16288391f, -0.02074146f, 0.42907971f, -0.14371575f, 0.01412200f, 0.05029424f, 
    -0.03745165f, -0.08371697f, -0.10510163f, 0.13620931f, 0.01333606f, 0.06645266f, 0.01713219f, 0.06441525f, 
    -0.10777671f, 0.10944836f, 0.14449872f, -0.09111636f, 0.01014156f, -0.02724880f, -0.05896877f, -0.23633140f, 
    -0.06846564f, 0.10376409f, 0.13942175f, -0.01260492f, -0.17337355f, 0.18375260f, 0.01827705f, 0.01871586f, 
    0.01469777f, 0.05312164f, 0.11505615f, 0.01256198f, 0.06600820f, 0.09275692f, -0.13417359f, 0.11359140f, 
    -0.40436864f, -0.11375806f, 0.03796949f, 0.10918486f, 0.00992185f, -0.15385832f, 0.09829867f, 0.04602407f, 
    -0.03952031f, -0.06277832f, -0.12810555f, 0.01834344f, -0.11156858f, 0.26303405f, 0.16140987f, -0.08824217f, 
    0.00258279f, -0.08658892f, -0.05640139f, 0.03118458f, 0.14251877f, 0.13545097f, 0.06477570f, -0.08708435f, 
    0.09659322f, -0.04502892f, 0.18590893f, 0.17376685f, -0.01503110f, -0.07765860f, 0.09205849f, 0.01822693f, 
    -0.02049158f, -0.07049465f, 0.05428670f, -0.00012767f, -0.04965032f, -0.02464297f, -0.00705492f, 0.15818323f, 
    -0.05998669f, -0.07397395f, 0.06301928f, 0.02738402f, 0.10049091f, 0.13559639f, 0.10653361f, 0.07198062f, 
    0.13056305f, 0.08233566f, 0.15791065f, 0.01881464f, 0.03400008f, -0.05518584f, 0.00404512f, 0.00855779f, 
    0.05079239f, -0.00845896f, 0.03336171f, -0.06646489f, 0.07782859f, -0.19755127f, 0.11635946f, -0.10517985f, 
    -0.02590012f, 0.04537545f, 0.04302056f, 0.06398392f, 0.05612387f, -0.00221187f, 0.11949572f, 0.05743582f, 
    0.25261289f, -0.11289518f, 0.39102006f, 0.12887101f, -0.02683281f, 0.16889490f, -0.14886297f, 0.17177154f, 
    -0.01984311f, 0.11905600f, 0.05970293f, -0.01406697f, 0.17851055f, -0.07085088f, -0.02771543f, -0.15706363f, 
    0.16080117f, 0.17623238f, -0.12196822f, 0.00861515f, -0.05729846f, 0.09306218f, 0.17855421f, 0.10668775f, 
    0.10020976f, -0.04068743f, -0.05181048f, 0.16227894f, -0.01811650f, -0.00093947f, 0.08239055f, 0.04723947f, 
    0.01063714f, 0.24434993f, 0.02450936f, 0.01284845f, 0.04646631f, 0.22789572f, 0.03569985f, -0.03916642f, 
    -0.03829218f, -0.10249655f, -0.06212207f, -0.09197270f, -0.05951375f, 0.00242938f, 0.04797922f, 0.10102776f, 
    0.16169347f, 0.08242977f, 0.26436850f, 0.10636102f, 0.18459803f, -0.03772945f, -0.02510346f, 0.00057511f, 
    -0.06766935f, -0.07674063f, -0.05241111f, -0.09973960f, -0.04664189f, -0.19768901f, -0.28558788f, 0.12442143f, 
    0.09882665f, 0.04046384f, -0.09587641f, 0.00969178f, -0.03632477f, -0.11812659f, -0.13563102f, 0.08913918f, 
    -0.33121708f, 0.27795586f, 0.23239239f, -0.09716804f, -0.03078609f, 0.06809821f, 0.09271278f, 0.08153145f, 
    -0.20774351f, -0.05043630f, -0.16098893f, -0.30118722f, -0.15808055f, 0.10845879f, -0.08006132f, -0.09532111f, 
    0.00365408f, -0.07707156f, -0.06948154f, -0.00130149f, 0.05205948f, 0.12286828f, 0.16275632f, 0.07534371f, 
    0.09975606f, -0.06756189f, 0.02593816f, 0.04250812f, 0.22639541f, 0.03785462f, -0.01340837f, -0.01233914f, 
    -0.11368901f, 0.02807126f, 0.23946150f, 0.13181259f, -0.00430222f, -0.20150422f, 0.10884248f, -0.28521854f, 
    0.05252542f, -0.00940735f, -0.15251692f, 0.03986011f, -0.04392210f, -0.00792542f, 0.19161865f, -0.06191628f, 
    -0.28788924f, -0.30972409f, -0.00376232f, -0.03851910f, 0.01976194f, -0.03228826f, 0.02333480f, -0.11128321f, 
    -0.07170435f, -0.04894422f, -0.20475774f, 0.06126029f, 0.11505292f, 0.08515074f, -0.28099382f, -0.11249574f, 
    0.19791448f, -0.01596027f, 0.19949405f, 0.05474060f, -0.29447913f, 0.16974553f, -0.12935960f, -0.19358152f, 
    -0.23095192f, 0.01470458f, 0.07674392f, -0.51454902f, 0.09342065f, 0.02431164f, -0.04289834f, 0.04870711f, 
    0.13600184f, 0.20033997f, 0.03844757f, -0.25327310f, -0.06866821f, 0.01173345f, -0.20508744f, -0.02599878f, 
    0.00723973f, -0.10112543f, 0.05324312f, 0.05427368f, 0.11129640f, -0.18038961f, 0.07727477f, -0.00517066f, 
    0.07707474f, 0.11016025f, -0.09225307f, 0.14900227f, 0.09850977f, 0.00852471f, -0.22236206f, -0.08308759f, 
    0.00072775f, -0.14774972f, -0.12074357f, -0.03884944f, 0.20750377f, -0.06349023f, -0.13951300f, 0.25686586f, 
    -0.03225367f, 0.04958298f, -0.01243228f, 0.06807604f, -0.02194631f, 0.07392129f, -0.13311486f, -0.07475453f, 
    0.07071516f, 0.06606326f, 0.04636383f, 0.00028385f, 0.04040131f, 0.13622667f, -0.01810059f, 0.04091777f, 
    -0.12681490f, -0.24837558f, -0.04345492f, -0.17354548f, 0.15523753f, 0.22082837f, 0.05185894f, -0.06340419f, 
    -0.03064190f, -0.00693645f, 0.05061860f, -0.13952015f, 0.09965128f, -0.00773299f, -0.05495622f, -0.04335377f, 
    0.02643301f, -0.09095342f, -0.24254966f, 0.06264164f, -0.13478382f, 0.00529424f, -0.06293461f, -0.06181166f, 
    -0.07668231f, -0.14808081f, -0.08780051f, -0.19476253f, 0.01252337f, 0.19945022f, -0.06934976f, 0.02060062f, 
    0.03816848f, -0.04642476f, -0.06971848f, 0.01544366f, -0.12941952f, -0.03155101f, -0.12962885f, -0.20285812f, 
    0.02189936f, 0.04427276f, 0.16779593f, -0.04590106f, 0.04602912f, 0.01659508f, -0.15068263f, -0.03247356f, 
    0.17891012f, 0.02361341f, 0.24638309f, 0.45888063f, 0.15498136f, 0.01625739f, -0.06089712f, 0.11589238f, 
    -0.10988978f, 0.00605117f, -0.16804492f, -0.02167431f, -0.08226125f, 0.09234392f, 0.01592683f, -0.03208398f, 
    0.32800689f, 0.18720876f, 0.17381361f, -0.13710159f, -0.05106645f, 0.10326283f, 0.16027510f, 0.26893783f, 
    0.16801079f, 0.00064485f, 0.25598249f, 0.09524260f, 0.19625606f, -0.05345332f, 0.05057259f, -0.05576981f, 
    0.05526576f, 0.18455192f, -0.27395916f, 0.12961440f, 0.02415415f, -0.01096376f, 0.10047205f, 0.02897451f, 
    0.26719841f, -0.08427812f, 0.17679530f, -0.26443958f, -0.06985945f, -0.02478109f, -0.02620990f, -0.09346539f, 
    -0.08147869f, -0.15459527f, -0.10293398f, -0.19661801f, 0.04698292f, -0.13543855f, -0.01693287f, -0.12754673f, 
    -0.05506726f, -0.05038182f, 0.04646157f, -0.03337836f, 0.04371816f, 0.11952140f, -0.04178986f, 0.26811925f, 
    0.13210790f, -0.10442118f, -0.01801698f, 0.05220244f, 0.01114234f, 0.05953167f, -0.07976538f, -0.01707250f, 
    -0.00214508f, 0.02248387f, 0.01354115f, 0.11480554f, 0.08722122f, -0.07018576f, 0.22519036f, 0.00553748f, 
    -0.07620332f, 0.08069945f, -0.10397076f, 0.06122492f, -0.08267708f, 0.13704914f, 0.15377815f, 0.32516780f, 
    0.10035785f, 0.12768257f, 0.03941715f, 0.06951713f, -0.02323326f, 0.05033524f, 0.04051394f, 0.03018030f, 
    -0.05238590f, -0.05751456f, -0.06271645f, 0.19040109f, 0.03836849f, 0.03144947f, 0.00349762f, 0.07083448f, 
    0.00154608f, 0.08020485f, -0.11996607f, 0.05053599f, 0.03215965f, 0.23081686f, 0.17170870f, 0.40933198f, 
    -0.00032700f, 0.03278880f, 0.00843138f, -0.01902538f, 0.01953835f, 0.02399009f, 0.00413207f, 0.00532557f, 
    -0.04070436f, 0.04083812f, -0.04836396f, -0.00706616f, -0.00925946f, 0.03048200f, 0.03570826f, -0.03056336f, 
    0.01111043f, 0.03839059f, 0.02572437f, -0.03064752f, 0.03718264f, 0.03141211f, 0.02728397f, -0.04942203f, 
    -0.03523710f, -0.05166925f, 0.02953877f, -0.02241605f, -0.03535539f, 0.01309599f, 0.02195044f, -0.03383274f, 
    0.02415456f, 0.03058123f, -0.03726948f, 0.00708111f, 0.03732077f, -0.02721019f, -0.00396947f, 0.00870019f, 
    -0.05574407f, 0.00256025f, 0.02278950f, 0.04475630f, -0.04220544f, -0.05395956f, -0.03787254f, 0.02747973f, 
    -0.04066490f, 0.01435905f, 0.00005420f, 0.01907229f, -0.02368313f, -0.05200727f, -0.05525650f, -0.04350626f, 
    0.03618252f, 0.04249710f, -0.04629498f, -0.05469352f, -0.02158044f, 0.04458251f, 0.00709032f, 0.02480250f, 
    -0.05629721f, 0.00673922f, -0.02745787f, 0.01701685f, -0.02345390f, 0.03426199f, -0.04069933f, -0.01784877f, 
    -0.03347082f, 0.03158323f, -0.04361568f, 0.04106781f, -0.01290517f, -0.05605936f, -0.00481907f, -0.00199694f, 
    -0.01818970f, 0.03819844f, -0.02880270f, 0.00555647f, -0.04984450f, 0.03814444f, -0.01720086f, -0.04696139f, 
    -0.05640228f, 0.01752765f, -0.05146254f, -0.03587533f, 0.01122449f, 0.01836957f, 0.01313938f, -0.00922785f, 
    -0.04419940f, -0.01311592f, -0.03545243f, -0.00047921f, -0.02206076f, 0.01505375f, 0.03430911f, 0.02768352f, 
    -0.02624148f, -0.01859251f, -0.00357974f, 0.02393637f, -0.04749164f, 0.02538623f, -0.03678516f, -0.03523779f, 
    -0.01207289f, 0.01148413f, -0.05144487f, -0.01533840f, 0.01893976f, -0.01678915f, -0.00487021f, 0.02120158f, 
    0.00982152f, -0.05252941f, 0.02829365f, -0.01573304f, -0.04640056f, -0.04674900f, -0.02559580f, -0.02469653f, 
    0.03325697f, -0.01651286f, -0.04169975f, 0.00685971f, 0.00226211f, -0.02418025f, 0.01626097f, 0.03788295f, 
    -0.03364956f, -0.00057345f, -0.01144402f, -0.00023792f, -0.03285310f, -0.03496688f, 0.00896225f, -0.00359742f, 
    -0.02868867f, 0.00945233f, 0.00005411f, -0.02023024f, 0.04342073f, 0.02587179f, 0.01336421f, -0.01844748f, 
    0.01296206f, -0.00462311f, 0.00313529f, 0.03573469f, -0.02210194f, -0.05242277f, 0.04015799f, -0.03438234f, 
    -0.03254434f, -0.04881497f, -0.01480419f, -0.04393963f, 0.00399289f, -0.02068562f, 0.02065731f, 0.04217956f, 
    0.02651781f, -0.03987811f, -0.03316324f, -0.01459480f, 0.03381877f, -0.04344857f, 0.00388743f, 0.04396740f, 
    0.01266144f, 0.00743391f, 0.01770522f, 0.01325023f, -0.02251614f, -0.00546352f, -0.04199744f, 0.02345580f, 
    -0.04448375f, -0.05422473f, 0.03712596f, -0.00270695f, -0.02678692f, -0.00881225f, -0.00014332f, 0.00378060f, 
    -0.03910293f, 0.04098511f, -0.05044626f, -0.00443406f, -0.00679416f, -0.01828178f, 0.01587096f, -0.05546005f, 
    0.00100672f, 0.02203158f, 0.03837796f, 0.00024979f, -0.03373792f, 0.03190024f, -0.01848016f, 0.00106151f, 
    0.02995349f, 0.02121846f, -0.03086217f, -0.04577288f, -0.00413731f, -0.05195011f, -0.05290545f, 0.00808878f, 
    -0.01522528f, 0.02192249f, 0.03487625f, 0.03277585f, -0.05178094f, -0.01071440f, 0.03222653f, -0.05620215f, 
    -0.01571062f, 0.02417321f, -0.00963184f, 0.03285069f, -0.03007045f, -0.01905970f, 0.01755583f, -0.03153590f, 
    -0.04162953f, 0.02107018f, -0.03925494f, -0.00855667f, -0.05296528f, -0.05478327f, -0.02110037f, -0.00940403f, 
    -0.04658297f, -0.00174076f, -0.02203321f, 0.02257885f, 0.02090229f, 0.01428494f, 0.01245450f, 0.02220056f, 
    -0.02437426f, -0.01539622f, 0.04111497f, 0.03494160f, -0.03964925f, 0.01071432f, 0.02502367f, -0.03716658f, 
    0.02741490f, 0.02448583f, -0.03644593f, -0.04052163f, 0.00277677f, -0.03887593f, 0.01530727f, -0.04145040f, 
    -0.01341286f, -0.02346601f, -0.02559466f, -0.00847909f, -0.05490786f, -0.00338990f, -0.03871321f, -0.04364716f, 
    0.00443229f, 0.01570644f, 0.04146351f, -0.03034490f, -0.00336572f, 0.02572295f, -0.04287905f, 0.01166337f, 
    0.00378056f, -0.03939921f, -0.01632643f, -0.05005838f, -0.01264903f, -0.04167772f, -0.00779550f, -0.05486098f, 
    -0.04309491f, 0.03281825f, 0.01785460f, -0.04649555f, -0.01102640f, 0.04139667f, 0.03881694f, 0.01300825f, 
    0.00217057f, -0.00679714f, -0.03594714f, -0.04744403f, -0.01223083f, -0.02712915f, -0.04232381f, -0.01961605f, 
    0.04345784f, 0.04163027f, -0.02955825f, -0.02259654f, 0.01193689f, -0.02214875f, 0.01454576f, 0.02872359f, 
    -0.04067895f, 0.02021473f, -0.00579018f, -0.02313444f, 0.03312696f, 0.01873612f, -0.04540964f, 0.00853138f, 
    -0.03493131f, -0.02574823f, -0.02471704f, -0.04299104f, 0.01325697f, -0.05693180f, -0.05707675f, 0.03243826f, 
    0.03750994f, -0.03739275f, -0.03436800f, 0.01404344f, 0.03477929f, -0.02856838f, 0.04471142f, -0.00390037f, 
    -0.04864978f, -0.03331182f, 0.03632208f, -0.05437347f, 0.03930140f, -0.01869249f, -0.00043873f, 0.02259232f, 
    -0.02691444f, 0.00602410f, -0.03671221f, -0.00941797f, -0.04662701f, -0.02704731f, 0.03761316f, 0.00348979f, 
    -0.02664096f, -0.03189839f, -0.03025066f, 0.03549658f, -0.03769441f, 0.01360642f, -0.02295745f, -0.05084085f, 
    -0.04903875f, 0.02034191f, -0.01107721f, -0.04040870f, -0.02710794f, -0.02105118f, -0.01646436f, -0.02626813f, 
    -0.00692941f, 0.00951154f, 0.00940672f, -0.01095290f, -0.05545573f, -0.02330412f, 0.01065213f, -0.03068712f, 
    -0.03518717f, -0.05112169f, -0.03931022f, -0.04247293f, -0.02506131f, -0.03889939f, -0.04667982f, -0.03699033f, 
    -0.00912374f, 0.25894004f, 0.57999116f, -0.01016459f, 0.09735833f, -0.32914418f, -0.02421287f, 0.08754195f, 
    -0.08662022f, 0.03119705f, 0.23369315f, 0.14026558f, 0.01761813f, 0.06795365f, 0.37569806f, -0.27047810f, 
    0.07321648f, 0.19025241f, 0.00996889f, 0.08445819f, -0.06773826f, 0.13739493f, -0.07520825f, 0.07513579f, 
    -0.20016304f, -0.44287401f, 0.22721814f, -0.19216117f, -0.09310811f, 0.09954379f, -0.13594152f, 0.00401757f, 
    0.05946191f, 0.01566138f, 0.09855226f, -0.02799084f, 0.40810058f, -0.04386959f, 0.08754625f, -0.10764308f, 
    0.19582702f, 0.03629806f, 0.08191374f, -0.14747837f, -0.20331953f, -0.02528833f, -0.07008132f, 0.00961880f, 
    -0.25194341f, 0.05410757f, 0.05971743f, -0.00113883f, -0.03723571f, -0.01328287f, 0.00595122f, 0.02703136f, 
    -0.02964049f, 0.03221719f, -0.11351541f, 0.07511380f, 0.11281866f, 0.04184832f, 0.02267064f, -0.08310766f, 
    0.04001104f, 0.13073435f, -0.01569815f, -0.21095392f, -0.19799596f, -0.04405750f, -0.06192105f, -0.07275811f, 
    -0.04879846f, -0.12153652f, 0.03512140f, -0.00607147f, 0.14533703f, -0.00278129f, 0.17977715f, 0.12809598f, 
    -0.11464629f, 0.01522310f, -0.03301026f, -0.09878162f, 0.14535126f, -0.32937029f, 0.12589677f, 0.07847056f, 
    0.04321722f, 0.02180053f, -0.02656096f, 0.00150011f, 0.19061717f, 0.06704190f, 0.02420280f, 0.09860418f, 
    0.21821642f, 0.18246856f, 0.24942349f, -0.28057376f, 0.12825182f, -0.06804764f, -0.06240618f, 0.05752234f, 
    0.09420379f, -0.00345923f, 0.19774176f, -0.13652578f, -0.05225545f, 0.22097753f, -0.14282653f, -0.27435967f, 
    -0.02346398f, -0.06358766f, -0.04839998f, -0.01458703f, -0.19545242f, 0.21798910f, 0.09870753f, -0.16552205f, 
    0.15802380f, 0.03013354f, 0.02475950f, -0.11431837f, 0.07384907f, 0.02199084f, 0.12169679f, -0.07699863f, 
    -0.04725919f, -0.11157746f, 0.10232584f, 0.03468731f, 0.48298368f, -0.21068236f, 0.14750639f, -0.07993810f, 
    0.18335797f, -0.13895389f, 0.04123632f, 0.08240002f, -0.00552824f, 0.10565040f, 0.19303679f, 0.06392921f, 
    -0.13626441f, -0.26482058f, -0.21300323f, -0.00041385f, 0.00493654f, -0.20009485f, 0.20683973f, -0.00440673f, 
    -0.06673837f, -0.02217791f, 0.16553129f, 0.10456632f, -0.12317481f, -0.09857541f, -0.11063065f, -0.09600124f, 
    -0.01076189f, -0.12182730f, 0.00630674f, 0.03448643f, -0.01376383f, 0.13140126f, -0.19605964f, -0.03390561f, 
    -0.09913904f, 0.02446113f, -0.47338602f, -0.35904810f, 0.30519673f, 0.08928595f, -0.02483664f, -0.07515501f, 
    0.18676795f, 0.42198190f, -0.07022132f, -0.10567236f, -0.32145885f, -0.09804336f, 0.12245043f, -0.12017217f, 
    0.09750652f, 0.05710411f, 0.03668586f, 0.00077466f, 0.10627263f, -0.21602011f, 0.33526814f, 0.05895427f, 
    0.00297616f, 0.00784306f, 0.03383837f, 0.13266715f, 0.01227081f, 0.01813548f, 0.23070559f, 0.08189926f, 
    -0.03486923f, -0.02154182f, -0.00967245f, -0.05664470f, -0.05397356f, 0.07611240f, 0.22114311f, -0.00100238f, 
    -0.05620257f, 0.10741959f, -0.10075686f, 0.04457342f, 0.04852184f, 0.05302421f, -0.03877566f, 0.19262938f, 
    -0.03893301f, -0.04568395f, -0.07521343f, -0.01705053f, 0.00902844f, -0.03771228f, 0.28183335f, -0.06348429f, 
    0.01828492f, 0.05085654f, -0.02189331f, -0.03821275f, 0.18891647f, -0.19847836f, -0.13258357f, 0.02702397f, 
    0.06924306f, 0.04650250f, -0.08874714f, -0.01360361f, -0.11949231f, -0.04928005f, -0.01368334f, -0.02369469f, 
    0.00520125f, 0.07688766f, -0.08975310f, 0.03902762f, 0.06420460f, 0.22220469f, -0.06855427f, -0.08512547f, 
    -0.00069996f, -0.05748080f, 0.16526617f, 0.14167503f, -0.15052462f, 0.38818493f, 0.15843701f, -0.04654057f, 
    -0.12819581f, -0.17883967f, -0.07197480f, -0.00251056f, 0.03978379f, 0.06263856f, -0.09573963f, -0.02142293f, 
    -0.17118880f, -0.09706093f, 0.26494884f, 0.01550517f, 0.08076951f, 0.06191744f, 0.00216003f, 0.08389407f, 
    0.00873505f, -0.14331304f, 0.04383744f, -0.17068920f, -0.26632285f, -0.11977033f, 0.40128529f, -0.02629723f, 
    -0.00592310f, 0.15503752f, -0.36228186f, 0.12515566f, -0.05345892f, -0.04152099f, -0.23646301f, 0.12407755f, 
    -0.02042674f, 0.34563896f, 0.45850477f, -0.44925660f, 0.05966021f, 0.04491404f, -0.05376046f, 0.17523092f, 
    0.11413882f, 0.08801817f, -0.04023731f, -0.01822926f, 0.39253601f, 0.05639525f, -0.18961705f, 0.00288556f, 
    0.21920215f, 0.17628403f, 0.09288229f, -0.02700347f, -0.02054140f, -0.05336957f, -0.07751948f, 0.01316623f, 
    -0.02731139f, -0.04705713f, 0.23028687f, 0.08768190f, 0.09493330f, 0.11757267f, -0.16327909f, -0.07751319f, 
    -0.12791279f, 0.04974570f, 0.00569458f, 0.09389485f, 0.05568744f, -0.10333764f, 0.04854080f, 0.02183143f, 
    -0.11104888f, -0.10732456f, -0.10993075f, -0.01012672f, 0.10482420f, 0.12240069f, -0.18844835f, 0.02847207f, 
    -0.00854453f, -0.15752697f, -0.05829619f, 0.18555650f, 0.03696186f, 0.17630868f, 0.18698356f, -0.04031275f, 
    0.06972348f, -0.03105060f, -0.08316932f, 0.06062520f, -0.12712821f, -0.15740955f, 0.06841166f, -0.02107289f, 
    -0.00829838f, -0.01812593f, -0.05534780f, 0.07694990f, -0.03825374f, 0.23195870f, -0.02907023f, -0.00483022f, 
    0.22724503f, -0.11481892f, -0.07513564f, 0.13360126f, 0.12154391f, 0.21153779f, 0.15904191f, -0.07327604f, 
    -0.03110145f, -0.04318352f, 0.25366321f, 0.09925297f, 0.04802215f, -0.08328190f, -0.01282901f, 0.12877694f, 
    0.09439756f, 0.14243607f, -0.07821872f, -0.05347916f, -0.15722936f, -0.01091824f, 0.01257799f, -0.14155264f, 
    0.07509326f, -0.27068514f, -0.20045137f, -0.18552399f, -0.02663453f, 0.01352125f, 0.15941510f, 0.00464100f, 
    -0.02659631f, 0.03166525f, 0.12921183f, 0.01363828f, -0.00757282f, 0.12906276f, 0.01511037f, -0.07525258f, 
    0.03468978f, -0.13824387f, -0.15430366f, 0.03709678f, 0.02388310f, 0.08000159f, -0.02735215f, 0.02379825f, 
    0.01857376f, -0.26115191f, -0.02071108f, -0.03693385f, 0.08969384f, -0.12168060f, -0.09645916f, -0.04683942f, 
    0.01467761f, 0.09584191f, 0.09256341f, 0.15397730f, -0.16019671f, 0.07794961f, -0.11094138f, -0.05246557f, 
    -0.01277287f, 0.17071284f, -0.12111657f, -0.02118533f, -0.12725471f, 0.05688343f, -0.00218453f, -0.08476453f, 
    0.00305713f, 0.05288596f, 0.00961656f, 0.06616983f, -0.03384269f, 0.05106058f, -0.08031428f, -0.08296177f, 
    -0.12853706f, -0.09390848f, -0.11836020f, 0.00355172f, -0.10289041f, -0.13600893f, -0.02728002f, 0.02150865f, 
    -0.15372807f, -0.00379707f, -0.06092637f, -0.03825454f, 0.07052853f, 0.04352956f, -0.08441050f, 0.02668393f, 
    -0.18263872f, -0.01268326f, -0.27905479f, 0.03777065f, -0.08286623f, -0.33812889f, 0.02459107f, 0.12964781f, 
    -0.03120188f, 0.11198702f, 0.04931254f, 0.10202103f, -0.03991316f, 0.26211116f, -0.03684355f, -0.03362860f, 
    0.05335502f, 0.14655416f, -0.01576717f, 0.02424770f, 0.07177330f, -0.06823651f, 0.29768732f, 0.10074439f, 
    -0.04604347f, 0.09166636f, -0.52492613f, -0.00904975f, 0.12614524f, -0.15434407f, 0.20290181f, 0.07292435f, 
    0.15227935f, 0.26291320f, -0.07517628f, 0.07324627f, 0.12086703f, 0.12165528f, 0.08680828f, 0.02233490f, 
    -0.02182855f, 0.02269362f, 0.06272621f, 0.06721172f, 0.03219408f, -0.03174899f, 0.02369814f, 0.00104451f, 
    0.22898872f, -0.08099912f, 0.00488747f, 0.23506711f, 0.06103991f, -0.11514894f, 0.05937170f, 0.03944720f, 
    0.01014645f, 0.01726940f, -0.06622861f, -0.21285495f, 0.08261598f, 0.21844673f, -0.14841487f, -0.04582116f, 
    0.00277019f, 0.12874393f, 0.05870499f, -0.03171578f, 0.10043510f, 0.05890414f, -0.02852341f, 0.11244671f, 
    0.11749959f, 0.09635871f, 0.24268882f, -0.13048947f, 0.05573212f, 0.11846022f, 0.10953996f, 0.10946456f, 
    0.05718922f, -0.08340820f, 0.32587671f, -0.10560943f, -0.08920866f, 0.01524435f, -0.06232885f, 0.29497063f, 
    -0.21568573f, -0.03218993f, -0.03033797f, 0.04564959f, -0.02833694f, 0.04766529f, -0.06800898f, 0.02839887f, 
    0.03885743f, -0.07756127f, 0.23602594f, 0.23964901f, -0.13101517f, -0.08254158f, 0.08165506f, -0.03888876f, 
    0.22831792f, -0.01616893f, -0.01109484f, 0.14885353f, -0.14240512f, 0.30178702f, -0.24591815f, 0.17966783f, 
    0.05593393f, 0.00837875f, 0.02366501f, 0.05647823f, -0.07282064f, 0.00855173f, 0.04229091f, -0.05658371f, 
    -0.03333686f, -0.37991810f, 0.35758510f, 0.17273445f, -0.22314595f, -0.08619825f, 0.18324065f, 0.14421670f, 
    -0.09155907f, 0.08309828f, 0.02888386f, 0.04624011f, 0.05980853f, 0.16450195f, 0.09182030f, -0.00913125f, 
    -0.01833521f, 0.01268546f, 0.11318496f, 0.05267623f, -0.04202813f, 0.04475783f, 0.04843944f, 0.22082099f, 
    -0.07052340f, 0.10122628f, 0.07128926f, -0.04343728f, -0.11906313f, -0.02800335f, -0.03799558f, 0.09406276f, 
    -0.07534383f, -0.04061024f, 0.14222564f, 0.08037397f, -0.36176190f, -0.00918304f, -0.13268602f, 0.15854152f, 
    -0.07319050f, -0.17535304f, -0.05307890f, 0.10868441f, -0.23428790f, -0.05937830f, -0.03832468f, 0.05310779f, 
    0.19260658f, 0.12665519f, 0.05574828f, 0.08265585f, -0.13240440f, 0.00549931f, 0.11815963f, 0.09700068f, 
    0.02313130f, 0.23127779f, 0.11983700f, 0.04998627f, -0.09084882f, 0.07802510f, -0.19368097f, 0.29897577f, 
    -0.00894174f, -0.12902282f, -0.02066250f, 0.06393564f, 0.00411204f, 0.11753450f, 0.00274590f, 0.15958659f, 
    0.07447370f, 0.10379406f, 0.08375964f, -0.04849861f, -0.10399877f, -0.06131608f, -0.01674167f, -0.06030502f, 
    -0.14404781f, 0.00254399f, -0.11112308f, -0.25419950f, -0.01605994f, 0.00440203f, 0.06134552f, -0.26031721f, 
    0.01705611f, 0.00037136f, 0.19699274f, 0.00498729f, -0.11640823f, -0.03557100f, -0.05254208f, -0.06402403f, 
    -0.03411248f, 0.00285256f, -0.25054768f, -0.29521975f, -0.03160666f, 0.06096191f, -0.12222424f, -0.05543883f, 
    0.12771386f, 0.00980867f, 0.04009767f, -0.08681365f, 0.01437509f, -0.03977985f, -0.01593606f, 0.22407092f, 
    0.01527825f, -0.09565973f, -0.02510910f, -0.01358275f, -0.01809963f, 0.10783954f, -0.08262756f, -0.30669487f, 
    0.31256571f, -0.00698185f, 0.02148559f, -0.02923242f, -0.01423604f, 0.03952957f, 0.14376889f, 0.02980039f, 
    -0.06074855f, 0.07129094f, 0.09560292f, 0.01708927f, -0.11380005f, 0.15554176f, -0.01184626f, -0.15436459f, 
    0.07496354f, 0.04980483f, -0.07669589f, 0.02513058f, -0.08239941f, 0.00565798f, -0.00674755f, 0.05786676f, 
    0.04798621f, -0.05840768f, 0.10635722f, -0.07820013f, -0.08255561f, 0.12035396f, -0.02194681f, 0.00467691f, 
    0.30261338f, -0.03176450f, -0.04238100f, -0.10351976f, -0.20575885f, -0.00369620f, 0.04857634f, 0.09983235f, 
    0.00308350f, -0.14384720f, -0.04387121f, 0.09487107f, -0.33345366f, 0.25618228f, -0.19466946f, -0.02093926f, 
    0.12005579f, 0.23426226f, -0.04033868f, 0.16870652f, -0.02143821f, -0.11255939f, -0.08504228f, -0.22354168f, 
    0.11711271f, -0.04449828f, 0.01204718f, -0.14760208f, 0.02398468f, 0.10836881f, -0.01941969f, 0.14133276f, 
    0.09723353f, 0.01799123f, -0.02391321f, 0.03249403f, -0.12044710f, 0.05578416f, -0.09192911f, -0.16560502f, 
    0.06412087f, 0.25845152f, 0.01615097f, 0.18805368f, -0.12750506f, 0.24995734f, 0.13649954f, -0.02149392f, 
    0.01722628f, -0.06270267f, -0.14200689f, -0.08282233f, -0.05240202f, -0.03849146f, -0.22853802f, 0.22004160f, 
    -0.04971419f, 0.07195785f, 0.03813700f, -0.01420249f, 0.06037819f, -0.01820294f, -0.00863351f, -0.01501454f, 
    -0.20884748f, 0.23461945f, 0.13190389f, 0.19268657f, -0.03277175f, -0.03532693f, 0.20374608f, 0.02161771f, 
    -0.04250329f, -0.02210236f, 0.08218993f, -0.03334443f, 0.23838602f, 0.05560244f, 0.24638350f, 0.22662134f, 
    0.03576555f, -0.08349367f, -0.08695784f, -0.13580404f, 0.16762806f, -0.14673275f, -0.00997420f, 0.00884066f, 
    -0.09443052f, -0.06042760f, 0.08245636f, -0.04087187f, -0.01505541f, -0.04794852f, 0.03442973f, 0.00864006f, 
    0.03698879f, -0.02109224f, 0.08433013f, 0.01083450f, -0.06741609f, -0.20156571f, 0.03245202f, 0.13140443f, 
    0.07778223f, 0.07703882f, 0.01814807f, 0.10216287f, 0.06131804f, -0.00571089f, -0.00305973f, -0.07662954f, 
    0.01356751f, -0.02433568f, -0.21480265f, 0.02494545f, -0.05100915f, -0.02631316f, -0.07647328f, -0.04562681f, 
    0.09232918f, 0.06700709f, -0.11830051f, 0.03463298f, 0.10125438f, 0.04370963f, 0.15466468f, -0.14406027f, 
    0.07137822f, -0.07585575f, 0.00847597f, -0.08587257f, -0.08345813f, 0.07044911f, 0.01970256f, -0.09761491f, 
    0.24197534f, -0.26032010f, 0.13097689f, 0.15868568f, 0.08722266f, 0.13409495f, 0.05715922f, -0.01796026f, 
    0.03065273f, -0.09026308f, -0.03733317f, 0.16905491f, 0.02833031f, -0.08518229f, 0.00668469f, -0.00714519f, 
    -0.11393082f, 0.04784121f, -0.03208125f, -0.03308685f, 0.01430673f, 0.01901227f, 0.07007582f, -0.00109992f, 
    -0.31720170f, -0.12362989f, -0.05672862f, -0.04170317f, 0.06941332f, 0.11253703f, -0.14749464f, -0.02622657f, 
    0.01195913f, 0.00353896f, -0.03413855f, -0.00378750f, 0.16411614f, 0.22794488f, -0.07639282f, -0.02456360f, 
    0.05933809f, 0.07316492f, 0.00628320f, -0.11353873f, 0.01351367f, 0.02390277f, -0.05054782f, -0.06738865f, 
    0.05675441f, 0.21156055f, 0.06951959f, 0.05721832f, 0.01938288f, -0.05724720f, -0.15478739f, 0.04544014f, 
    -0.01241158f, -0.09900636f, 0.05978333f, -0.08519003f, -0.14416318f, -0.13180478f, 0.19636317f, -0.06797232f, 
    -0.09848202f, 0.10730429f, -0.07453198f, -0.07063431f, 0.15831976f, -0.04192989f, 0.07598979f, -0.03214679f, 
    0.28472340f, 0.12199842f, 0.07670294f, 0.16407171f, -0.04554605f, -0.01077267f, -0.02162735f, 0.06694338f, 
    0.03351462f, -0.13057347f, 0.23257802f, 0.10725780f, 0.33801985f, -0.22952121f, 0.33885497f, 0.14669766f, 
    -0.04277654f, -0.08541951f, -0.02686886f, -0.11978634f, 0.02909250f, 0.07931204f, -0.06678120f, 0.16023970f, 
    -0.01901744f, 0.15777893f, 0.05143193f, -0.07702833f, -0.03597314f, -0.06430861f, 0.06139281f, 0.05761877f, 
    -0.00854538f, 0.00583115f, -0.00735317f, 0.07032242f, -0.00327118f, -0.04619865f, -0.11229371f, -0.13220169f, 
    -0.07552943f, -0.02446557f, -0.07703984f, -0.00001333f, 0.06360612f, -0.18414542f, 0.15619631f, -0.14081374f, 
    -0.05973753f, -0.00103170f, -0.00280248f, -0.13344760f, 0.11016374f, -0.10996246f, -0.01774918f, 0.24207452f, 
    0.06342179f, 0.08453626f, 0.05091138f, -0.07159261f, 0.01831986f, 0.08165050f, 0.07279629f, 0.03778355f, 
    -0.05660809f, 0.02289561f, 0.09245101f, -0.04968241f, 0.03340497f, 0.01072678f, 0.08044054f, -0.06247192f, 
    -0.10512388f, 0.04793357f, 0.04032551f, -0.04820938f, 0.13300714f, -0.00688401f, 0.03613194f, -0.04378036f, 
    -0.07749623f, -0.07065780f, 0.10587444f, -0.00593730f, 0.07261857f, -0.22126995f, 0.22698958f, -0.10237084f, 
    0.03031531f, 0.04939793f, -0.01335617f, -0.13389425f, -0.01113375f, -0.03275428f, 0.08960305f, -0.09542995f, 
    0.01111619f, -0.02040127f, -0.16646865f, -0.04972284f, 0.02032864f, -0.01258536f, 0.13467498f, -0.01251134f, 
    0.02714760f, 0.06788306f, 0.12637213f, 0.00496845f, -0.01415099f, 0.16989942f, -0.20039290f, -0.11903130f, 
    0.02807097f, -0.02979653f, -0.05904680f, 0.04256349f, 0.02304046f, 0.00253407f, 0.14803372f, -0.03151976f, 
    0.15486228f, -0.10202079f, -0.02212424f, 0.34783423f, -0.06908084f, -0.00825325f, 0.03471449f, -0.23160727f, 
    -0.00027377f, 0.06532275f, 0.04202836f, 0.10176541f, 0.02963667f, 0.01194309f, 0.10369734f, -0.13636638f, 
    -0.05037122f, -0.14099364f, -0.00922585f, 0.11716349f, 0.07308703f, -0.08221784f, -0.02522268f, 0.10595287f, 
    -0.16027781f, 0.06095340f, -0.26502103f, -0.08347220f, 0.05446066f, 0.05426596f, 0.05675903f, 0.03037821f, 
    0.07992618f, -0.03936320f, 0.01348227f, 0.05329354f, 0.00918567f, 0.01997726f, 0.11381509f, 0.10875732f, 
    0.02213292f, 0.03112394f, 0.15447848f, -0.05957980f, 0.06837708f, 0.01965838f, 0.13432944f, -0.12103545f, 
    -0.26338327f, 0.19209844f, 0.19259353f, -0.12472328f, -0.03368178f, -0.21615729f, -0.03795894f, 0.16821341f, 
    -0.18736956f, 0.06781296f, 0.13700625f, 0.02296831f, 0.00093312f, 0.18131198f, 0.04313281f, -0.06978049f, 
    0.03235725f, -0.03148392f, -0.10977842f, -0.03045058f, 0.25358132f, -0.00000523f, 0.05255054f, -0.07848924f, 
    0.08300769f, -0.15483122f, 0.24009120f, -0.05602257f, 0.03808627f, -0.13609526f, -0.08646471f, 0.20822775f, 
    -0.00700620f, -0.02020052f, 0.08550924f, -0.01531408f, 0.07849567f, -0.01975476f, 0.01724077f, -0.25408289f, 
    -0.03149846f, -0.21314497f, 0.04404418f, 0.03928072f, 0.06224431f, -0.00180081f, -0.08812900f, -0.07164486f, 
    -0.01363794f, -0.06589577f, 0.00313904f, 0.00669204f, -0.02012703f, 0.00260084f, -0.06463352f, -0.02478288f, 
    -0.05001247f, -0.03512041f, -0.02597670f, -0.03465467f, -0.01519701f, -0.00456491f, -0.00180718f, 0.02784290f, 
    -0.00150445f, -0.01662110f, 0.01273253f, -0.01122079f, -0.02367777f, -0.03215728f, 0.00786201f, 0.02948905f, 
    0.00896519f, -0.03733275f, -0.00622243f, 0.03421982f, 0.02062715f, -0.01554833f, -0.04782792f, -0.02603132f, 
    -0.03692153f, -0.03139809f, 0.02491581f, -0.05105784f, -0.03157172f, -0.04713955f, -0.02461383f, -0.04587641f, 
    -0.06249326f, -0.04528528f, -0.02066528f, -0.04931664f, 0.01765848f, -0.01939852f, -0.05155360f, -0.04867913f, 
    -0.00481197f, -0.00388705f, -0.04313386f, 0.02556265f, -0.04317636f, -0.03921110f, -0.06523629f, 0.02423643f, 
    0.03333095f, 0.01497386f, 0.01685395f, -0.01759916f, -0.02424318f, -0.04472410f, -0.00399876f, 0.02173826f, 
    0.03303990f, -0.00418794f, 0.02298321f, -0.01483763f, -0.03048879f, -0.05496576f, 0.02105798f, 0.02819053f, 
    0.01348157f, -0.05501797f, -0.01013825f, 0.01108525f, -0.04269616f, -0.03729538f, 0.01883287f, -0.03184363f, 
    -0.06021429f, -0.00711764f, -0.03188534f, -0.06586298f, -0.02074202f, -0.05230137f, 0.03775981f, -0.02343479f, 
    0.02197196f, 0.01873956f, -0.03682899f, -0.03939657f, 0.01861760f, -0.05294975f, -0.00188162f, -0.02885882f, 
    -0.06020066f, -0.05667993f, -0.06606987f, -0.02774681f, 0.03121029f, 0.00641493f, -0.01221225f, -0.06361222f, 
    0.00678341f, 0.04793162f, -0.01854575f, 0.01677608f, 0.01033677f, -0.04032398f, 0.01981246f, 0.01827384f, 
    -0.05228275f, -0.01778246f, -0.01803734f, 0.00998710f, -0.02480505f, -0.04605469f, -0.03731340f, -0.04955529f, 
    0.02544583f, 0.01880151f, 0.03360327f, -0.00622700f, -0.02880861f, 0.00385257f, -0.02291465f, 0.02713346f, 
    0.01886007f, -0.01322069f, 0.02824644f, 0.01188036f, 0.00799596f, -0.05074366f, -0.01586201f, -0.04867361f, 
    0.02219483f, -0.05899043f, -0.00743699f, -0.02246111f, -0.00529507f, -0.02812418f, -0.02469358f, -0.00905992f, 
    -0.02188887f, -0.04679779f, -0.04962365f, -0.03030200f, -0.01973232f, -0.01961673f, 0.02813333f, 0.00510709f, 
    -0.02363026f, -0.00009606f, -0.02900746f, -0.05059255f, 0.00401154f, 0.04237562f, -0.03956963f, 0.02491678f, 
    -0.00064522f, 0.01871494f, -0.03467904f, 0.02335106f, -0.00189116f, 0.01947818f, -0.05336166f, 0.01224587f, 
    -0.05515331f, -0.04774123f, -0.03278976f, -0.05376816f, 0.01457758f, 0.01201659f, -0.05566811f, -0.00094969f, 
    -0.02830930f, 0.00272061f, -0.06511904f, 0.04042669f, -0.06538801f, 0.00387948f, -0.02368379f, 0.01214472f, 
    0.01623396f, 0.02905056f, 0.02817655f, -0.02987893f, -0.05423861f, 0.01361252f, -0.04359615f, -0.06550519f, 
    -0.00044828f, 0.01661657f, -0.00094042f, -0.04158563f, 0.01405766f, -0.05109180f, -0.05263082f, 0.02299237f, 
    -0.00049996f, -0.05891727f, -0.01474890f, -0.05800046f, -0.03101263f, -0.01480997f, -0.03822795f, 0.04337371f, 
    -0.01418696f, -0.05064910f, 0.03179099f, -0.03872605f, -0.02054913f, -0.02855485f, 0.02700610f, 0.03488199f, 
    0.01620583f, -0.04205945f, -0.04868596f, 0.02427643f, -0.02691116f, -0.05108432f, 0.01347276f, 0.01029155f, 
    0.02082324f, -0.04445007f, 0.03838105f, 0.00211284f, -0.06391408f, 0.00699501f, -0.05546708f, -0.06168097f, 
    0.01420497f, -0.06222745f, -0.04382228f, -0.00417873f, -0.06211844f, -0.00756087f, -0.06267170f, -0.04692636f, 
    -0.03549949f, 0.00327833f, -0.02068819f, 0.03085297f, 0.02466609f, -0.01838502f, 0.00294851f, -0.01025950f, 
    -0.04416099f, -0.01150227f, -0.00974645f, -0.06064971f, -0.06389046f, 0.02421978f, -0.02780647f, -0.02453170f, 
    -0.04128201f, -0.03312986f, 0.02002255f, -0.04728220f, -0.04220233f, -0.01362354f, -0.03989396f, -0.03323734f, 
    0.01460371f, 0.02807096f, -0.03327719f, -0.03247654f, -0.04529371f, -0.00856190f, -0.00710307f, -0.02164315f, 
    0.00269258f, -0.04787391f, -0.00667483f, -0.05174180f, 0.02613709f, 0.03042880f, 0.00476826f, 0.03279017f, 
    -0.05439210f, 0.00178328f, 0.03552987f, -0.04582869f, -0.02226285f, 0.02147417f, -0.03805166f, 0.02738764f, 
    -0.06174471f, -0.02906134f, -0.04778053f, 0.01258826f, 0.03469210f, 0.02355183f, -0.03841612f, -0.02488912f, 
    -0.06561458f, -0.00793306f, 0.01948339f, -0.00450952f, 0.00425795f, -0.06534293f, -0.06586970f, -0.06287967f, 
    -0.04541276f, -0.06179642f, 0.02851935f, 0.00360739f, -0.02183265f, 0.00003812f, -0.04058330f, -0.06044151f, 
    -0.03614343f, -0.03560362f, -0.05005023f, -0.03532136f, -0.00728121f, -0.02324118f, -0.01787444f, -0.04479012f, 
    -0.05227048f, -0.06009503f, -0.04363303f, 0.01576230f, -0.06476314f, -0.00049236f, 0.02466139f, 0.02087551f, 
    -0.02054116f, -0.06330504f, 0.00174851f, 0.02894195f, -0.03231486f, -0.04196179f, -0.02440174f, -0.04643537f, 
    -0.00284615f, -0.06339869f, -0.01298247f, 0.03179725f, 0.02019158f, -0.06266781f, -0.06427151f, -0.05428321f, 
    0.01395330f, -0.00663973f, 0.00533572f, -0.05208035f, 0.01866789f, -0.01152804f, -0.05711143f, 0.01477492f, 
    -0.00877224f, -0.02387028f, 0.03064119f, 0.01216236f, -0.06447756f, 0.03194515f, -0.01021172f, -0.04014489f, 
    -0.04786051f, 0.01759633f, 0.01595884f, -0.03023965f, -0.06413433f, 0.01598989f, -0.04570491f, -0.03382618f, 
    0.02686298f, -0.00020922f, -0.05107469f, -0.03114359f, 0.01751658f, -0.00258608f, -0.01439777f, 0.00323467f, 
    -0.04099915f, 0.02816849f, 0.02619843f, 0.02118738f, 0.02467721f, -0.02689611f, -0.03023980f, -0.02935476f, 
    0.20132270f, -0.12050155f, -0.37947732f, -0.05824932f, -0.00868829f, 0.23119409f, 0.23105788f, -0.08545592f, 
    0.00927821f, 0.03144894f, 0.09947739f, -0.14220104f, 0.01680682f, -0.03508771f, -0.08898312f, -0.19398329f, 
    0.09160881f, 0.14076839f, 0.00860682f, -0.01048329f, -0.06024936f, -0.00464742f, 0.01858624f, 0.02211082f, 
    0.05292251f, 0.00528713f, 0.01010660f, -0.09397865f, 0.12251122f, -0.24576545f, 0.01850428f, 0.06862282f, 
    0.16769554f, 0.09866170f, 0.14984429f, 0.09800440f, -0.22065781f, 0.02447971f, 0.06935239f, 0.15524870f, 
    0.01379175f, 0.11983050f, -0.18754007f, -0.07252689f, -0.06084397f, 0.05620810f, 0.11950795f, 0.16697411f, 
    0.03401853f, 0.06998802f, -0.01582111f, 0.02250429f, -0.04762736f, -0.03980692f, -0.05662646f, -0.12360582f, 
    -0.04655671f, -0.20840323f, -0.02620270f, 0.03193348f, -0.16148417f, -0.21339351f, -0.05564076f, -0.17070293f, 
    -0.12053314f, -0.04047033f, 0.05989079f, -0.02479292f, 0.07736412f, 0.01906329f, 0.07356231f, 0.12927863f, 
    -0.20717703f, -0.21072720f, -0.12784185f, -0.03824765f, -0.06662754f, -0.44162342f, -0.00581035f, 0.11289838f, 
    0.01742584f, 0.12184235f, 0.09197177f, 0.02329233f, 0.21900004f, 0.12981218f, -0.13508396f, 0.01757248f, 
    0.03415656f, 0.06059728f, -0.01454640f, 0.07495683f, 0.00343344f, -0.14697984f, 0.12282651f, 0.13812158f, 
    -0.05044659f, 0.00462394f, -0.47262475f, -0.08070686f, 0.09604745f, -0.07404374f, 0.08176643f, 0.25584263f, 
    -0.02124406f, 0.31125146f, -0.24686070f, -0.05846134f, 0.14997955f, 0.10410596f, 0.00119379f, 0.16069636f, 
    0.04381371f, 0.09189386f, -0.01119171f, 0.01100305f, -0.01619403f, 0.01020311f, 0.09268621f, 0.13105243f, 
    -0.10130893f, -0.23335639f, 0.04534968f, 0.15610859f, 0.08778948f, -0.07505206f, 0.07631026f, 0.04413726f, 
    -0.00575694f, 0.07466925f, 0.06032092f, -0.12897347f, 0.18628636f, 0.19793461f, -0.36812875f, 0.06713841f, 
    -0.01902111f, 0.08781578f, 0.00427057f, -0.07838283f, 0.06209166f, -0.02250706f, 0.14083834f, 0.23269191f, 
    0.06974986f, 0.07479455f, 0.08166381f, 0.01041766f, 0.09471755f, 0.18711983f, -0.02330568f, -0.06036338f, 
    0.12348019f, -0.09388376f, 0.13909873f, -0.07170863f, -0.09016023f, -0.16863091f, -0.17843595f, 0.27652627f, 
    -0.09724484f, -0.06120429f, 0.00424159f, -0.03734905f, -0.07248706f, 0.13356745f, -0.18265896f, -0.09628956f, 
    -0.01885108f, 0.16327561f, -0.00603224f, 0.11169839f, -0.18140216f, -0.06262480f, 0.06130684f, 0.00995548f, 
    0.18685412f, -0.01817067f, -0.08390778f, 0.03691613f, 0.09634946f, 0.32205731f, 0.02168237f, 0.28762200f, 
    0.03960378f, -0.00564589f, 0.04038966f, -0.03022137f, 0.05939433f, -0.06905278f, 0.05592928f, 0.13052678f, 
    -0.12899953f, -0.34608254f, 0.43415943f, 0.12246899f, -0.14478388f, -0.16177699f, -0.01677574f, 0.20966811f, 
    -0.00575793f, 0.04150474f, 0.07675764f, 0.02078383f, 0.08937455f, 0.06682364f, 0.07386881f, 0.02199365f, 
    0.01839801f, -0.12524833f, 0.01292891f, 0.00373874f, 0.04316786f, -0.10958166f, -0.00102027f, 0.09346056f, 
    -0.14315332f, -0.08529285f, 0.04527412f, -0.07185981f, -0.00150684f, -0.04580776f, -0.17586190f, 0.09057903f, 
    -0.01768142f, -0.12812099f, 0.03953968f, 0.00349081f, -0.30647299f, -0.06406155f, -0.13944501f, 0.14428382f, 
    -0.06142002f, -0.15199056f, -0.08260887f, -0.09386183f, -0.09942906f, 0.01879892f, -0.04181324f, 0.06599043f, 
    0.13225418f, 0.03344326f, 0.04422263f, 0.02481885f, -0.02150810f, -0.00291547f, 0.05586556f, 0.12803176f, 
    -0.02238521f, 0.02465666f, 0.08368214f, -0.07216085f, 0.00074858f, -0.15581186f, -0.11013818f, 0.28689989f, 
    0.06226213f, -0.09689941f, -0.01632320f, 0.09020633f, -0.03182518f, -0.04247059f, -0.01668811f, 0.02334865f, 
    0.18085955f, 0.16158146f, -0.17362380f, -0.10891229f, -0.04606666f, 0.00883861f, 0.15642366f, -0.08596702f, 
    -0.05214156f, 0.13031806f, 0.07599854f, -0.06270735f, 0.25256997f, -0.06501256f, -0.16008094f, -0.22621103f, 
    -0.13513955f, -0.02176879f, 0.19088069f, -0.01417771f, -0.05312925f, 0.03579061f, 0.03479272f, 0.00512074f, 
    0.21716654f, -0.00331987f, -0.32324976f, 0.09030290f, -0.04937784f, 0.09309629f, 0.05013455f, -0.00497767f, 
    0.04046509f, 0.07145419f, 0.12409484f, 0.05597920f, -0.22518945f, -0.05130361f, 0.01734717f, 0.21823777f, 
    -0.05822313f, -0.11206885f, 0.00136738f, -0.00633284f, 0.03600017f, 0.06935486f, -0.06929621f, -0.13636620f, 
    0.34972620f, -0.09645820f, -0.11332366f, -0.11612374f, -0.09880752f, 0.04878518f, 0.23836853f, 0.17004991f, 
    -0.01022651f, -0.01567534f, 0.01416759f, -0.15485321f, 0.02219272f, 0.34908000f, -0.07168783f, -0.09991138f, 
    0.11576402f, 0.08760215f, 0.09393208f, 0.00307737f, 0.06163641f, 0.16393512f, 0.05405857f, 0.05650458f, 
    0.07423531f, 0.28717005f, 0.21714409f, -0.05468911f, -0.11023906f, -0.06672774f, -0.12835160f, 0.06886135f, 
    0.21962239f, 0.14957248f, 0.08246464f, -0.02090520f, 0.02937333f, 0.09060206f, 0.14133616f, -0.00673506f, 
    -0.06966986f, -0.15401773f, -0.05949501f, 0.10033528f, -0.13388962f, 0.34251037f, 0.11918885f, 0.11111683f, 
    0.08078802f, 0.42648458f, 0.21804835f, 0.20097405f, -0.04602240f, -0.04922990f, -0.02442672f, -0.01907152f, 
    0.12947330f, 0.02888343f, 0.05972375f, 0.06413889f, 0.03518676f, 0.09410548f, 0.00781538f, 0.06223133f, 
    -0.05784673f, -0.01169988f, 0.12993814f, 0.08865761f, -0.09118225f, 0.08538261f, 0.14669691f, 0.04324517f, 
    -0.02692501f, -0.12570155f, 0.08928803f, 0.01479805f, -0.04182687f, -0.12129535f, 0.09948021f, 0.16488115f, 
    -0.00355464f, -0.03668516f, 0.11942439f, 0.11301816f, -0.15062936f, 0.15849204f, 0.01301684f, 0.06385023f, 
    -0.00075191f, -0.15045729f, 0.02781620f, 0.19353971f, -0.00072946f, 0.10670955f, -0.19050196f, -0.02060812f, 
    -0.07075343f, -0.06249400f, -0.15401341f, -0.02926188f, 0.02792386f, 0.02146572f, 0.17445131f, 0.09493002f, 
    -0.01221309f, 0.03812034f, 0.00370227f, -0.02041886f, -0.02797248f, -0.03930197f, -0.22067112f, -0.27601531f, 
    -0.07769463f, 0.08562311f, 0.22828361f, 0.08350363f, -0.04057966f, 0.01450451f, -0.19971825f, -0.17096914f, 
    0.04100716f, -0.04921697f, 0.13370679f, -0.03514200f, -0.05862598f, 0.00201644f, -0.20462415f, -0.09236941f, 
    -0.17767254f, -0.15725444f, -0.11773067f, -0.04669288f, 0.15210368f, -0.00809904f, -0.08775071f, -0.03201633f, 
    0.01682612f, -0.03382266f, -0.19465344f, 0.02881197f, 0.06333649f, 0.06030594f, 0.09262244f, 0.09283111f, 
    0.04969810f, 0.06807682f, -0.20332423f, -0.06774575f, -0.01246036f, 0.15513149f, 0.13397396f, 0.13591728f, 
    0.01908098f, 0.01409844f, 0.13387968f, 0.13267010f, 0.00897744f, 0.19116896f, 0.14956570f, -0.29906610f, 
    -0.13923687f, -0.04469732f, -0.04234115f, -0.06606025f, 0.05066483f, -0.00842592f, 0.27699026f, -0.02761177f, 
    -0.02655562f, 0.23850100f, 0.15428981f, -0.11747612f, 0.15833318f, -0.13409109f, 0.00577108f, -0.08532854f, 
    0.02812851f, 0.18624811f, 0.10591681f, 0.13840637f, 0.00030947f, -0.01617019f, 0.20438854f, 0.00326614f, 
    -0.13184492f, 0.01491216f, 0.00753069f, -0.07835416f, -0.18035376f, -0.18559152f, -0.17758694f, -0.13030668f, 
    0.39701772f, 0.21970408f, -0.17656349f, -0.08107594f, 0.05932343f, 0.06364512f, 0.09652494f, -0.07668491f, 
    0.15268184f, -0.02588813f, -0.16018894f, -0.07054810f, -0.11404759f, 0.18223883f, 0.09100228f, -0.12165049f, 
    -0.16827095f, -0.05261255f, 0.07964597f, -0.06930118f, -0.05250677f, -0.04146836f, -0.09625649f, 0.03543470f, 
    0.02288955f, 0.05733322f, -0.03815211f, -0.15893589f, -0.10610551f, 0.06705314f, -0.00506565f, -0.00434373f, 
    -0.01073033f, 0.02364266f, 0.11721078f, -0.08046094f, 0.07097925f, -0.05901133f, 0.26888198f, 0.07019471f, 
    -0.18990545f, -0.04550408f, -0.10164279f, -0.02479317f, -0.01408176f, -0.00114496f, 0.14197615f, 0.20159090f, 
    0.03039163f, -0.11306711f, 0.12676269f, 0.29413927f, -0.04411965f, -0.02953819f, 0.03007723f, -0.05861126f, 
    -0.00493378f, 0.18078916f, -0.02767272f, 0.23635103f, -0.01291072f, -0.01758166f, -0.26515481f, -0.42566499f, 
    0.03873544f, 0.11340336f, -0.20402485f, 0.03598233f, 0.08635838f, 0.18114796f, 0.00210170f, -0.05980721f, 
    0.23153678f, -0.08277567f, -0.11215700f, 0.10929447f, 0.00099117f, 0.14839473f, 0.21398982f, 0.07833389f, 
    0.12426854f, 0.13182083f, 0.16903591f, 0.17722993f, -0.19116232f, 0.07506157f, 0.00936943f, -0.30476794f, 
    -0.00635474f, -0.04424800f, -0.04159855f, -0.07376144f, -0.05688193f, 0.03990977f, -0.02021448f, 0.22737844f, 
    -0.17593598f, 0.09051891f, -0.13364004f, -0.02795134f, 0.04189502f, 0.02524457f, -0.06331113f, -0.23017076f, 
    0.07913919f, 0.14287499f, 0.04196055f, 0.22730307f, -0.00572174f, 0.07206614f, -0.06001408f, -0.09842277f, 
    0.10002376f, -0.01575943f, -0.06846573f, 0.24960253f, -0.17232759f, 0.01100941f, -0.00925688f, 0.09847297f, 
    0.02022904f, 0.05009222f, 0.11525116f, -0.10408871f, 0.03125196f, -0.09120359f, -0.07748092f, -0.00127604f, 
    -0.05389097f, 0.18662445f, 0.07556023f, 0.24439502f, -0.04901497f, 0.14651440f, -0.07054010f, 0.09628491f, 
    -0.05342676f, -0.00095177f, -0.03613839f, -0.05279330f, 0.09136111f, 0.07054888f, -0.07385319f, 0.17629643f, 
    -0.09669609f, -0.13115034f, 0.20020647f, 0.06949770f, -0.10148818f, -0.05928290f, 0.03124517f, 0.10790531f, 
    -0.33850968f, -0.17661324f, -0.28652599f, -0.31512642f, -0.29025161f, 0.12651543f, 0.21967077f, -0.16279882f, 
    0.04109282f, -0.05791217f, 0.10187823f, 0.00466980f, -0.07150243f, -0.04565632f, -0.05703428f, -0.01295219f, 
    -0.47700158f, 0.37379286f, 0.04584523f, -0.14968263f, 0.06220947f, -0.02379355f, -0.11663989f, 0.01097261f, 
    0.01852679f, -0.08242466f, -0.14610456f, -0.09684484f, 0.18633756f, 0.07195693f, -0.03540669f, 0.01155008f, 
    0.07987569f, 0.00348983f, 0.15391533f, -0.05459585f, -0.06829577f, -0.01901192f, -0.10711552f, -0.07311631f, 
    -0.11704206f, 0.22983125f, -0.02321690f, 0.22444813f, 0.01654193f, -0.07147398f, 0.12995814f, -0.07782836f, 
    -0.00153552f, 0.16269462f, 0.06272765f, 0.25239253f, -0.03209152f, -0.12403680f, 0.13114347f, -0.01691402f, 
    -0.05246541f, -0.04387356f, -0.02779350f, 0.18557958f, -0.08245885f, -0.07257742f, -0.09795388f, -0.21700233f, 
    -0.04581530f, -0.43247196f, -0.34599721f, -0.10768823f, 0.10892697f, 0.20971592f, 0.11632638f, 0.10125152f, 
    0.15111819f, -0.01800915f, -0.06953488f, -0.06224160f, -0.23667882f, 0.12197775f, -0.13957618f, 0.21365304f, 
    -0.08351312f, -0.06547109f, 0.03843865f, 0.01373908f, -0.00466222f, -0.06598201f, -0.19664462f, -0.19881189f, 
    0.29124999f, -0.16047765f, -0.35241145f, -0.19383843f, 0.03241310f, 0.15012056f, 0.02073981f, -0.02611912f, 
    0.07880794f, 0.11488437f, 0.05361692f, -0.12766901f, 0.14130102f, -0.05827006f, -0.08825222f, 0.02414818f, 
    0.11740139f, 0.09155822f, -0.03978081f, 0.02410416f, -0.06006877f, -0.01586873f, -0.04799021f, -0.26663727f, 
    0.13343829f, -0.07514986f, -0.16851489f, -0.13926627f, -0.13498445f, 0.22735974f, 0.14682022f, -0.01572816f, 
    -0.08202311f, 0.00878261f, 0.03840553f, 0.00790058f, -0.16127041f, 0.22535089f, -0.12981084f, 0.20967306f, 
    -0.05794591f, -0.14344274f, 0.01483390f, 0.12619400f, -0.08180518f, -0.10288284f, 0.04488396f, -0.02511495f, 
    0.01602639f, -0.12584409f, -0.10330237f, 0.08613876f, 0.07062859f, -0.16874930f, 0.09428496f, -0.15336685f, 
    0.01490560f, 0.06112539f, 0.03918516f, 0.09219304f, -0.28909430f, 0.03723764f, -0.00432512f, 0.01112319f, 
    -0.03079351f, 0.09005280f, -0.14345153f, 0.06512826f, 0.11761577f, 0.03796559f, -0.06713204f, -0.03093241f, 
    0.23133200f, -0.10074433f, -0.06589381f, 0.22271653f, -0.09432117f, -0.05342605f, -0.10861810f, -0.00714493f, 
    0.09544209f, -0.04487478f, 0.00619951f, 0.06169702f, -0.05986709f, -0.07304117f, -0.03642646f, -0.06436968f, 
    -0.11969241f, -0.03423565f, 0.02319151f, 0.11808489f, -0.05367318f, -0.03393012f, -0.03685211f, 0.05089578f, 
    -0.04118457f, 0.11299571f, -0.19008139f, -0.00682023f, -0.04188282f, -0.12145156f, -0.05954323f, -0.05620896f, 
    -0.02037102f, -0.01416362f, -0.03864529f, 0.03235237f, -0.10510439f, 0.41034815f, 0.02586158f, 0.35391653f, 
    -0.07551584f, 0.12342107f, 0.06291048f, 0.05410434f, 0.01548864f, -0.06289703f, 0.09513488f, -0.06935042f, 
    -0.32293278f, 0.13871026f, -0.30083185f, 0.10235835f, 0.20130731f, -0.00480409f, 0.09414551f, -0.16402373f, 
    -0.00624082f, 0.05609011f, -0.10918874f, 0.04795644f, 0.07683869f, 0.01474945f, 0.18067838f, 0.22084294f, 
    -0.08170582f, 0.11607213f, 0.06716299f, 0.01015309f, 0.06657756f, 0.01124897f, 0.00424223f, 0.00562545f, 
    0.13375367f, -0.00238785f, -0.04781185f, 0.20343070f, -0.06004174f, -0.08290266f, 0.04702512f, 0.06640495f, 
    -0.03856208f, -0.07305317f, -0.15195353f, -0.06486633f, -0.22977322f, 0.34578949f, -0.01253479f, 0.19789359f, 
    -0.08606607f, 0.19275983f, 0.07235359f, 0.02030770f, -0.11167131f, -0.03743150f, -0.14508346f, 0.09929487f, 
    0.19688241f, 0.12245295f, 0.24094902f, 0.05468062f, -0.00037791f, 0.19831583f, 0.12671465f, 0.12396296f, 
    0.07834125f, 0.03801495f, 0.09214971f, 0.04995401f, -0.05550744f, 0.09007746f, -0.00402402f, 0.12317108f, 
    -0.12387157f, -0.05016245f, -0.03979156f, -0.06224005f, 0.06661587f, -0.13186629f, 0.14036728f, 0.05326887f, 
    -0.10296061f, -0.02092644f, 0.43864948f, 0.17932254f, -0.24869969f, 0.00011049f, 0.07968815f, 0.09301233f, 
    0.06380327f, -0.12412536f, 0.07968429f, 0.02037711f, 0.02511208f, 0.30775183f, -0.14262438f, 0.32598585f, 
    -0.08363492f, -0.04957232f, 0.00115772f, -0.02317294f, -0.08367804f, 0.13124272f, -0.17217720f, 0.03817257f, 
    0.03069616f, -0.25405696f, 0.13556570f, 0.05248829f, -0.13438034f, -0.02717101f, -0.03079467f, 0.15204288f, 
    -0.06584471f, 0.03223746f, -0.12457290f, -0.00657060f, 0.10458062f, 0.05887369f, 0.08983888f, 0.14376031f, 
    -0.05693049f, -0.08376857f, 0.12889557f, -0.03153352f, 0.00073588f, 0.06240760f, -0.04037892f, 0.02718965f, 
    0.01669073f, 0.05333946f, -0.00961880f, -0.06997040f, -0.11957725f, -0.01092928f, -0.13199733f, -0.00022770f, 
    -0.09955372f, -0.05657024f, -0.02904055f, -0.05455107f, -0.21321516f, 0.23681167f, -0.01803151f, 0.01520893f, 
    -0.04451095f, -0.11448303f, -0.04581294f, -0.03056759f, -0.16917767f, -0.06416213f, 0.00418942f, -0.03027577f, 
    0.16033144f, 0.08114193f, 0.09839332f, 0.04099020f, -0.17922011f, -0.00817603f, 0.09802992f, 0.11811735f, 
    -0.00890563f, 0.17735592f, 0.03323444f, -0.04997433f, 0.03264164f, 0.15834127f, -0.20572519f, 0.40900022f, 
    0.03461238f, 0.02484947f, 0.08191741f, 0.02659429f, -0.10615148f, 0.03412541f, -0.00258468f, 0.00487083f, 
    0.11621194f, -0.01125888f, -0.02520033f, 0.00739400f, -0.08493894f, -0.04248412f, 0.07756662f, -0.11033580f, 
    -0.05536963f, -0.06177055f, -0.15460034f, -0.00262013f, 0.34964609f, 0.13073282f, 0.09554057f, -0.07053332f, 
    0.03064699f, -0.12796433f, 0.30676049f, 0.04539713f, -0.04219200f, 0.02000245f, 0.04648623f, 0.03242270f, 
    -0.02455978f, 0.01749416f, -0.33556789f, 0.01003946f, -0.11863320f, -0.00499526f, 0.01684709f, 0.09421428f, 
    -0.02664261f, -0.03498708f, 0.01398435f, 0.01152981f, -0.31291500f, -0.02700758f, 0.25664940f, 0.18619367f, 
    -0.00296886f, -0.02981737f, 0.04003897f, -0.08959261f, -0.04305686f, 0.02418812f, -0.05235374f, -0.11193234f, 
    0.28294978f, 0.06464797f, 0.04431731f, 0.03007993f, -0.22080727f, 0.07256268f, 0.25455257f, -0.00038645f, 
    -0.06946336f, -0.01001185f, -0.02069489f, 0.05450513f, -0.13388611f, 0.08414763f, 0.02558830f, -0.09697003f, 
    0.13356172f, 0.00108299f, 0.00465857f, -0.08961076f, -0.03422346f, 0.02439327f, 0.10807423f, 0.00811053f, 
    0.01270643f, 0.09880621f, 0.12855794f, -0.18502392f, 0.02697476f, -0.03483640f, -0.10950069f, 0.07388008f, 
    0.15989020f, 0.10111799f, 0.04422978f, -0.06998894f, -0.00015297f, 0.04206084f, 0.07599112f, 0.16508809f, 
    -0.01374561f, -0.09362706f, 0.07448915f, 0.02245507f, -0.05915677f, 0.13104552f, 0.02273804f, 0.13078777f, 
    0.00278370f, 0.10512531f, 0.02804545f, 0.02209174f, 0.03516757f, -0.05279762f, -0.06015877f, -0.10165233f, 
    -0.01832078f, 0.09611432f, -0.09097782f, -0.13121814f, -0.00959173f, 0.11660159f, 0.02075233f, -0.07253029f, 
    -0.05191191f, -0.16252223f, -0.00859614f, 0.06672203f, -0.10634193f, -0.01875906f, -0.09129906f, -0.15330431f, 
    -0.10815757f, -0.32070345f, -0.00003801f, -0.12628895f, 0.01083159f, -0.10629241f, 0.04452537f, 0.10181835f, 
    -0.05935285f, -0.03916364f, 0.06150332f, 0.03811207f, -0.33396435f, 0.14489518f, -0.06608705f, 0.12802389f, 
    0.04159579f, -0.09399428f, -0.08789152f, 0.26559916f, -0.07731903f, 0.03125127f, 0.01033064f, -0.13668725f, 
    0.15771057f, -0.14623842f, -0.14427114f, 0.06072429f, -0.04208420f, -0.00855646f, 0.17377178f, 0.01260618f, 
    -0.08408315f, 0.10864264f, -0.07610756f, 0.05611441f, -0.14351608f, 0.04002535f, -0.12353561f, -0.12812974f, 
    -0.00448402f, 0.09254470f, 0.09656311f, -0.05212518f, 0.02861667f, 0.01810608f, 0.02619130f, -0.03788644f, 
    0.18243083f, -0.05504202f, -0.01127047f, 0.13452548f, -0.08359327f, -0.12099414f, -0.13046379f, -0.04160123f, 
    -0.00159213f, -0.08117554f, -0.09277705f, -0.01691126f, 0.21336551f, 0.22089000f, 0.01359585f, -0.15844215f, 
    -0.07601375f, -0.13477212f, -0.19841629f, 0.09186823f, -0.03555943f, 0.00569364f, 0.00975202f, 0.06570085f, 
    0.12035702f, 0.28203577f, 0.08145855f, 0.05018267f, -0.00688929f, 0.06900654f, 0.07204583f, 0.11610179f, 
    -0.04541119f, -0.06066863f, 0.02197454f, 0.03533605f, -0.00772445f, 0.05609754f, 0.11480101f, 0.16495378f, 
    -0.08342239f, 0.07586806f, -0.03922588f, -0.02810993f, 0.07581482f, -0.12361107f, 0.16364871f, -0.01075565f, 
    -0.47507641f, 0.42072949f, 0.07751486f, -0.00956399f, 0.19265243f, -0.12553376f, 0.07517359f, -0.20589182f, 
    0.09479173f, -0.04315466f, 0.03411858f, 0.12492185f, 0.04586209f, -0.03724361f, 0.09051210f, 0.15199564f, 
    -0.00586203f, -0.00267237f, 0.01343279f, -0.06227019f, -0.13913675f, -0.10638600f, -0.09267560f, -0.14662535f, 
    0.51304388f, 0.17970146f, 0.04509892f, 0.06455383f, 0.07220784f, 0.00824732f, 0.16181310f, -0.06008331f, 
    0.12546125f, -0.04442874f, -0.18886249f, -0.22058053f, -0.23748906f, 0.11541026f, 0.16736916f, 0.13918909f, 
    0.03914529f, -0.09231910f, 0.04780664f, 0.01070899f, -0.01998158f, -0.06593880f, 0.00794134f, 0.09137984f, 
    0.03407944f, -0.13551040f, 0.01640901f, -0.04296835f, -0.00085620f, 0.08186881f, 0.05621649f, 0.07353860f, 
    0.09591770f, 0.04231669f, 0.03794990f, 0.08128713f, 0.01391395f, 0.02290066f, 0.03428343f, -0.02761239f, 
    -0.09340069f, 0.00213426f, -0.13752533f, -0.01693421f, -0.01339817f, -0.01364568f, 0.08672581f, 0.04723844f, 
    -0.38686499f, -0.17631362f, 0.15624718f, 0.07675467f, -0.08506483f, 0.05700468f, 0.12245873f, -0.04184007f, 
    0.02954629f, 0.17442785f, -0.00600110f, 0.03961683f, -0.07770573f, 0.17068680f, -0.31769004f, -0.25618377f, 
    -0.05056410f, 0.00710239f, -0.09070145f, 0.00121223f, 0.00176385f, 0.01593871f, 0.01494508f, -0.10668376f, 
    0.23853406f, -0.13971156f, -0.05823592f, 0.03158462f, 0.00851571f, 0.14276101f, 0.00414887f, 0.19265980f, 
    -0.04500544f, 0.02219558f, 0.00156223f, 0.06566892f, -0.08449177f, -0.00261631f, 0.02526539f, -0.13352172f, 
    0.02773308f, -0.11033816f, 0.06396919f, -0.09557913f, -0.05335331f, 0.09249487f, -0.12970437f, 0.11026873f, 
    0.02557749f, 0.00921046f, 0.00347709f, -0.01281689f, 0.03463132f, 0.06419300f, 0.05284799f, -0.13636112f, 
    -0.03655837f, -0.01735143f, 0.04762731f, 0.03197268f, 0.01797541f, 0.28437781f, 0.22040570f, 0.07969446f, 
    -0.01664384f, -0.05923237f, -0.01140580f, 0.11249958f, -0.02435890f, -0.07982381f, 0.00344280f, 0.02773020f, 
    0.17381094f, 0.04726825f, 0.03793898f, 0.01584062f, -0.09019946f, -0.05412704f, 0.02148747f, 0.04025539f, 
    -0.01242269f, 0.26133034f, 0.03036566f, 0.12735784f, 0.13341831f, 0.22399016f, -0.26679790f, 0.29010001f, 
    -0.01542368f, -0.03137440f, -0.07074687f, 0.03766001f, -0.00532604f, 0.02472136f, -0.09629036f, 0.00384113f, 
    -0.06285461f, -0.05442328f, 0.10970128f, 0.10593741f, 0.04436991f, 0.01536876f, -0.10828124f, -0.03440135f, 
    -0.23468432f, -0.24572939f, -0.21001543f, -0.12010327f, -0.00177429f, 0.12950811f, 0.27012682f, -0.03021012f, 
    0.06175536f, 0.01823253f, 0.15827277f, -0.00629517f, -0.06952657f, -0.09627143f, -0.10652092f, -0.03811707f, 
    -0.53579265f, 0.32707787f, 0.06588524f, -0.27423939f, 0.04002601f, -0.03438237f, -0.01208168f, 0.08146741f, 
    -0.03379964f, -0.08330958f, -0.02123918f, -0.04234643f, -0.05999541f, 0.22774386f, 0.08886465f, 0.00563126f, 
    0.11697553f, 0.09647771f, 0.02197494f, -0.10040426f, -0.02491084f, -0.02958493f, -0.00962295f, -0.18456665f, 
    0.11750683f, -0.01817757f, 0.15911008f, 0.12125688f, -0.06097563f, 0.06275793f, 0.19823825f, 0.01664778f, 
    -0.00453228f, 0.13191955f, -0.01895627f, 0.14034635f, -0.11160194f, -0.08855419f, 0.19628040f, -0.15420383f, 
    0.01478926f, -0.05086942f, -0.04137299f, 0.12926820f, -0.07686092f, -0.02730769f, -0.06830762f, -0.16576546f, 
    0.06269808f, -0.29191503f, -0.16150768f, -0.13080914f, 0.12566772f, 0.17818344f, -0.10525708f, 0.02506246f, 
    0.19508879f, 0.09000179f, -0.01040153f, -0.03187505f, 0.03164950f, 0.00568561f, 0.06898861f, 0.17119555f, 
    -0.06445870f, -0.04705152f, 0.02031456f, 0.03345553f, -0.27368933f, -0.01433906f, -0.15668026f, -0.07056754f, 
    0.27993798f, 0.05671821f, -0.22728786f, -0.25067809f, 0.14120829f, 0.02042932f, 0.06166212f, -0.16643354f, 
    -0.00895238f, 0.03394479f, -0.05255025f, -0.04181188f, 0.10399742f, 0.02496248f, 0.08418423f, 0.07448812f, 
    0.19710624f, 0.17436862f, -0.07890305f, -0.11120754f, -0.10871362f, 0.00687075f, 0.00569369f, -0.28752160f, 
    -0.08717468f, 0.11313546f, 0.11044303f, 0.15418057f, 0.17928159f, 0.29447743f, -0.04544859f, 0.04185773f, 
    -0.05765172f, -0.03185488f, -0.18089263f, -0.02018618f, 0.36920118f, -0.06782048f, 0.18297720f, 0.10832657f, 
    0.06080452f, 0.20852940f, 0.25021183f, -0.07315221f, 0.09645776f, -0.12797755f, -0.02508509f, -0.01910142f, 
    -0.14414214f, 0.31398520f, 0.18564935f, -0.01156213f, -0.00867747f, -0.01999931f, -0.00218575f, -0.04911035f, 
    0.02632052f, -0.07513376f, -0.12479095f, -0.04349277f, -0.11067997f, 0.07672214f, 0.09180979f, 0.25653699f, 
    0.03742557f, -0.14810230f, -0.00596014f, 0.13347475f, 0.21197528f, 0.07671500f, -0.02098891f, 0.03029895f, 
    -0.27060997f, -0.01113886f, -0.15738161f, -0.24151602f, -0.02441774f, -0.03510075f, -0.06029979f, -0.01590840f, 
    0.07553147f, 0.02712961f, 0.05381305f, -0.03824886f, -0.03108249f, 0.03041340f, 0.17343459f, 0.21479611f, 
    0.12666295f, 0.16794871f, 0.23884107f, 0.10656394f, 0.06398208f, -0.04054688f, 0.07128254f, 0.02735914f, 
    0.02988550f, -0.04198761f, 0.09445271f, 0.12056491f, 0.07413588f, 0.21239029f, 0.03263716f, -0.07035690f, 
    0.01174481f, -0.01290584f, -0.02591293f, 0.16502242f, -0.02379925f, -0.04257818f, -0.06048562f, -0.14262383f, 
    -0.04858673f, -0.14006183f, 0.01091844f, -0.01731806f, -0.09350735f, 0.16989295f, -0.18337902f, 0.14689270f, 
    0.54322708f, -0.29464954f, 0.01102064f, 0.42193496f, -0.03845464f, 0.24255288f, 0.09554918f, 0.08364199f, 
    -0.03492055f, 0.03318284f, 0.18840367f, 0.04946285f, 0.03152437f, -0.04508961f, -0.11135645f, -0.04500304f, 
    -0.05234306f, -0.16047506f, -0.00321582f, -0.04581291f, 0.17224972f, 0.08520000f, 0.03697282f, 0.20787972f, 
    -0.32989463f, 0.06288025f, 0.21357444f, 0.12619612f, 0.05933863f, 0.14539310f, 0.03216516f, 0.03678568f, 
    0.02254056f, 0.00576831f, 0.12299798f, 0.21346892f, 0.15920548f, -0.01045782f, -0.13744181f, 0.00750154f, 
    -0.02178616f, -0.03808887f, -0.07457153f, 0.00821141f, 0.01511457f, 0.02838799f, -0.00146991f, -0.02404050f, 
    -0.07586983f, 0.09243272f, -0.09227221f, -0.01889117f, -0.02346733f, -0.06586613f, -0.07882024f, -0.07971775f, 
    0.13114041f, 0.16607757f, 0.03233537f, 0.08467395f, -0.25517488f, -0.05548780f, -0.18301336f, -0.06284638f, 
    0.06867588f, -0.06462183f, -0.06938045f, -0.12110566f, 0.14742798f, -0.13515770f, 0.15270904f, 0.05796927f, 
    0.48715699f, 0.11187770f, 0.00331962f, 0.20651640f, 0.07343441f, -0.05799736f, -0.22473298f, -0.04534038f, 
    0.07785723f, -0.09190831f, 0.17642094f, 0.23154978f, 0.06334913f, -0.08597402f, 0.28359970f, 0.15710013f, 
    -0.02258850f, 0.00772061f, -0.01940670f, -0.00000574f, 0.13626379f, 0.17576715f, 0.00153821f, 0.28190798f, 
    -0.11190077f, 0.39733553f, 0.02375113f, 0.03690383f, 0.15424900f, 0.09193178f, 0.02107226f, -0.10085551f, 
    0.06193206f, -0.05565223f, -0.04486489f, -0.07644733f, 0.01232963f, -0.15292871f, -0.24411558f, -0.02514721f, 
    -0.01431428f, -0.10425502f, -0.10180630f, -0.11588764f, 0.01477224f, -0.01481272f, 0.08345760f, -0.05263689f, 
    -0.07383298f, -0.21094102f, -0.20742893f, -0.18975836f, -0.03439352f, 0.03655279f, 0.00833001f, 0.02757613f, 
    0.08158182f, 0.10596050f, -0.04191631f, -0.09240963f, 0.14988120f, -0.13843769f, 0.07027929f, 0.09533688f, 
    0.09656074f, 0.19209810f, 0.21243262f, 0.09920844f, 0.05110496f, 0.03192594f, -0.04285153f, -0.07773797f, 
    -0.24892089f, -0.14196049f, -0.15581992f, -0.15673870f, 0.09170765f, 0.06043019f, 0.03992030f, -0.00975812f, 
    0.13932407f, -0.09624410f, -0.01072445f, -0.07055159f, -0.01985468f, -0.21966365f, 0.27228022f, -0.18629149f, 
    0.02169831f, 0.04346935f, -0.05116978f, -0.16967322f, -0.04139110f, -0.09341886f, 0.06779332f, -0.09666301f, 
    -0.03720386f, 0.00505619f, -0.23546548f, -0.04113135f, -0.09878670f, -0.05603139f, -0.04436244f, -0.06355976f, 
    0.18408927f, 0.21540003f, 0.11302025f, 0.12898950f, 0.08896360f, -0.10013581f, -0.23720881f, 0.10133313f, 
    -0.02165283f, -0.10754334f, 0.02827410f, -0.00344806f, 0.02937225f, 0.00243601f, 0.03886677f, 0.03381006f, 
    0.48232597f, -0.40577304f, -0.16204420f, 0.48218229f, 0.02505763f, -0.11739560f, 0.09297124f, 0.07366537f, 
    -0.04987462f, 0.13427311f, 0.09745811f, -0.03548227f, 0.01837392f, -0.00822625f, 0.07336110f, 0.11762679f, 
    0.05552352f, 0.00881674f, 0.04979430f, 0.27185911f, -0.04335354f, 0.01437408f, 0.13732414f, 0.27581590f, 
    -0.26772264f, -0.19890358f, -0.22489102f, -0.02259186f, 0.22336699f, 0.10953578f, -0.08123002f, 0.09425380f, 
    0.02705484f, 0.01683334f, 0.02949840f, -0.10150095f, 0.16614529f, 0.20042098f, -0.00827422f, 0.30883262f, 
    0.03214056f, -0.02468585f, -0.02470009f, -0.08093649f, 0.09977346f, 0.00693041f, 0.13687570f, 0.04793863f, 
    0.12034166f, 0.37487793f, 0.15683460f, 0.20593217f, 0.01503369f, -0.10696907f, 0.14023770f, 0.13962826f, 
    -0.09207702f, 0.03625581f, 0.01605093f, 0.00962915f, 0.13549253f, -0.13345353f, -0.17114669f, -0.17180653f, 
    -0.00675845f, 0.04604766f, -0.07829356f, -0.11209777f, 0.35309637f, -0.23370682f, 0.21375836f, -0.01954910f, 
    -0.32981569f, 0.05960055f, 0.30968481f, 0.22249168f, 0.12397555f, -0.01240170f, 0.14376485f, 0.34325412f, 
    0.08539680f, 0.13975546f, 0.05409861f, 0.08393037f, -0.06569737f, 0.16621023f, 0.12396364f, 0.08505150f, 
    -0.05082309f, -0.13643327f, 0.17930600f, 0.26755255f, 0.22937194f, -0.00922887f, -0.00112828f, 0.15438542f, 
    -0.00033764f, -0.05594182f, -0.00187196f, -0.05159507f, -0.00120042f, -0.05610242f, -0.00365697f, -0.00375910f, 
    0.02044579f, -0.00722569f, -0.03715236f, 0.01733469f, 0.00304371f, -0.04329982f, 0.00051668f, -0.05484555f, 
    -0.04421563f, 0.01814282f, 0.01155129f, 0.04068279f, 0.03271975f, -0.01115288f, -0.03409170f, -0.03856879f, 
    -0.02050535f, 0.02256884f, 0.02809862f, -0.02665634f, 0.01246632f, 0.03970256f, -0.01167432f, -0.05557926f, 
    -0.01125302f, -0.02328510f, 0.02549827f, -0.04143824f, -0.01332846f, 0.02593732f, -0.01777402f, -0.03970556f, 
    -0.05576759f, 0.02316358f, 0.00763526f, 0.03635424f, -0.03794136f, -0.03503294f, -0.04012325f, 0.03425097f, 
    0.02507464f, -0.02210574f, -0.00203515f, -0.04658334f, 0.04364327f, -0.02074888f, 0.03935918f, -0.00750908f, 
    -0.02730660f, 0.03842285f, 0.02854203f, -0.01660993f, -0.03426752f, -0.05702726f, 0.00373225f, -0.04546075f, 
    0.03825855f, 0.00993287f, -0.05268059f, 0.00978225f, 0.02028945f, 0.00662862f, -0.04451939f, -0.03325307f, 
    -0.03533511f, -0.00142913f, -0.00392996f, -0.00679601f, -0.01647841f, 0.03354619f, 0.02580266f, 0.00644866f, 
    -0.00652022f, -0.00417529f, -0.04933211f, 0.03559325f, 0.03686603f, -0.05649620f, -0.00642207f, -0.00422691f, 
    -0.03350701f, 0.01369785f, -0.00820681f, 0.01751198f, -0.05342735f, -0.01385678f, 0.01307119f, -0.00057751f, 
    -0.03084415f, 0.02267746f, -0.01120312f, -0.04741026f, 0.01019488f, 0.03264208f, 0.04084637f, -0.03383864f, 
    -0.01956878f, -0.04366375f, 0.02232183f, -0.03609436f, -0.02068158f, 0.00348976f, -0.00302799f, 0.04896406f, 
    -0.03751205f, -0.03008997f, -0.04930954f, 0.01210387f, 0.00403402f, 0.00886180f, 0.01180425f, -0.00791023f, 
    0.02127521f, 0.02181013f, -0.00836058f, -0.00049167f, 0.00517585f, -0.01339401f, -0.02059999f, -0.05461974f, 
    -0.00502831f, -0.02204489f, 0.03757350f, 0.04250064f, 0.00690022f, 0.01803652f, -0.03968570f, -0.04918894f, 
    0.02745771f, 0.01829373f, -0.01667376f, 0.00645235f, -0.00265851f, -0.05370319f, 0.01014005f, -0.02568390f, 
    -0.03713762f, -0.01371255f, -0.04148979f, -0.04054365f, 0.02588245f, 0.03154318f, 0.01911877f, 0.02636578f, 
    -0.04998355f, 0.01520251f, -0.01495652f, -0.00341223f, -0.02857215f, -0.00216800f, 0.02548131f, -0.01574155f, 
    -0.05269736f, -0.01348988f, -0.04071133f, 0.00828425f, -0.01623935f, 0.02919463f, -0.03660468f, -0.04969111f, 
    0.01327278f, -0.03465392f, -0.03172916f, -0.04218371f, 0.02575662f, -0.01758492f, -0.02937974f, 0.01869241f, 
    -0.01367703f, 0.04110886f, 0.04399685f, -0.03010975f, -0.02836187f, 0.01801251f, 0.01144616f, 0.02242189f, 
    -0.04951702f, -0.02198219f, -0.03577923f, -0.04490339f, -0.05524264f, -0.02825876f, -0.00228072f, 0.02646854f, 
    0.04019347f, 0.04352798f, 0.03656950f, 0.03991823f, -0.00020792f, 0.01659370f, -0.03222016f, -0.05081255f, 
    -0.04270541f, -0.05655119f, -0.01697810f, 0.04126524f, 0.01474784f, 0.02642846f, -0.01824045f, -0.03106144f, 
    -0.01983270f, 0.04490560f, -0.01312518f, -0.02923593f, -0.02001416f, -0.04761485f, -0.02771776f, 0.03725630f, 
    0.04211679f, 0.00659010f, 0.02327255f, 0.04217048f, 0.02396268f, 0.02784231f, -0.03619993f, 0.03277671f, 
    -0.05336316f, -0.05121656f, 0.02184187f, -0.03085729f, 0.03582175f, 0.01093642f, 0.00152433f, 0.01675578f, 
    0.02955711f, -0.04475589f, -0.04629916f, -0.02255299f, -0.00257382f, -0.04002691f, 0.01226812f, -0.03075750f, 
    -0.02501896f, -0.04742087f, 0.00919077f, -0.03227970f, -0.01768360f, 0.00781718f, -0.03691408f, -0.04325491f, 
    -0.03781959f, 0.03458769f, -0.00949426f, -0.01446385f, 0.01609366f, -0.04013783f, -0.04035063f, -0.02695184f, 
    -0.03819578f, 0.04253475f, 0.01709310f, -0.01441979f, 0.01376808f, 0.03001329f, -0.00719863f, -0.03025531f, 
    -0.04120341f, 0.02901958f, -0.03169007f, -0.02151299f, 0.03711407f, -0.05294178f, -0.00828077f, 0.03524138f, 
    0.02510005f, -0.05286178f, 0.03766209f, 0.01868219f, -0.03532458f, -0.03119196f, -0.01306961f, -0.00140086f, 
    0.01991354f, 0.01783574f, 0.02818817f, -0.01927251f, 0.04464765f, -0.02057190f, 0.04342965f, -0.04444097f, 
    -0.03574460f, -0.02289213f, -0.02263432f, 0.01293684f, 0.02849786f, -0.05205554f, -0.00167315f, -0.02646735f, 
    -0.05009185f, 0.02627943f, -0.04095959f, 0.02613897f, 0.00984986f, 0.00436271f, -0.00001102f, 0.00059972f, 
    0.00025250f, -0.02632806f, 0.04371347f, 0.03825893f, -0.04919233f, -0.05420982f, 0.03754074f, 0.02259933f, 
    0.03255248f, 0.03628017f, -0.02128155f, 0.01305264f, 0.03741490f, 0.02379873f, -0.03733202f, 0.04214455f, 
    -0.05390530f, 0.03675489f, 0.02659319f, -0.03284747f, 0.03550267f, 0.02493233f, -0.01896095f, -0.00131306f, 
    -0.03091923f, -0.01798254f, 0.03999759f, 0.01350460f, -0.05509746f, 0.02880411f, -0.03783205f, -0.01809326f, 
    0.03640331f, 0.03871861f, 0.00015254f, 0.01776761f, -0.05036708f, -0.03916701f, -0.05132665f, -0.03424747f, 
    -0.01374671f, -0.02142096f, 0.02336535f, 0.02687980f, 0.02709026f, 0.02398837f, 0.00942541f, -0.04727753f, 
    -0.00759579f, -0.00004004f, -0.04959209f, -0.01966947f, 0.03933633f, -0.05235509f, -0.03234857f, -0.00671209f, 
    0.02809350f, -0.04799642f, -0.04430519f, -0.04319355f, 0.04054379f, 0.01632441f, 0.02428902f, 0.03946843f, 
    0.02604467f, -0.00548803f, 0.02996220f, -0.02777662f, -0.04095295f, 0.00056553f, -0.04518044f, -0.03238933f, 
    0.03799690f, 0.02606731f, 0.02955426f, 0.01414370f, -0.03670100f, -0.01515840f, -0.00714787f, -0.02961222f, 
    -0.21354660f, 0.01356950f, -0.09829842f, 0.30461141f, 0.08062222f, -0.13625854f, 0.07867669f, 0.17060411f, 
    0.04531154f, -0.10912216f, 0.04379288f, -0.04818324f, 0.10463616f, 0.03918834f, -0.26737380f, -0.07471352f, 
    -0.02706393f, -0.16722423f, 0.05216919f, 0.07776552f, 0.14498927f, -0.00373219f, -0.02941462f, -0.03102240f, 
    -0.03186157f, -0.03389541f, 0.02334375f, 0.15595821f, 0.08595634f, 0.14676449f, 0.10161380f, 0.14261295f, 
    0.04358476f, 0.15880838f, 0.00125145f, 0.06893191f, 0.38195989f, 0.00120582f, 0.08416088f, 0.31648660f, 
    0.11717244f, -0.02467889f, -0.11731881f, -0.00990091f, -0.12557712f, 0.04352693f, 0.04944511f, 0.08392553f, 
    0.01869443f, -0.18169862f, -0.01085717f, -0.04247422f, 0.00392285f, -0.00341138f, 0.05226693f, 0.09379988f, 
    -0.08364262f, 0.24016632f, -0.09726808f, 0.15304618f, -0.05010821f, 0.06445020f, -0.05023659f, -0.02839822f, 
    0.02881970f, -0.02255123f, 0.08727519f, 0.20828086f, -0.01434257f, 0.07277536f, -0.05829179f, -0.10815973f, 
    -0.04827654f, 0.12080804f, 0.14232962f, 0.07310013f, -0.06268692f, 0.11580449f, 0.13723417f, 0.13704778f, 
    0.01645221f, -0.06249493f, 0.08061857f, -0.12455286f, 0.01156837f, 0.00317904f, 0.24221578f, -0.00247301f, 
    -0.08674219f, 0.05348940f, 0.02367180f, -0.12700748f, 0.02562680f, 0.04164340f, -0.04015137f, 0.01092385f, 
    -0.21942280f, 0.29409093f, -0.05043287f, -0.07980469f, -0.04589509f, -0.00973348f, -0.04540575f, -0.05133212f, 
    0.01720374f, -0.00284703f, 0.00987984f, 0.09331910f, -0.00832664f, -0.08181582f, -0.11653318f, 0.05723800f, 
    -0.06357757f, -0.01948383f, -0.03609543f, -0.08288725f, -0.12244330f, -0.07736959f, 0.01997154f, 0.06782935f, 
    -0.03995129f, 0.11709650f, 0.05301094f, 0.04728737f, 0.02305567f, 0.11353616f, -0.00584509f, 0.19115300f, 
    0.14677909f, 0.07590253f, -0.08521388f, -0.09454387f, -0.29450592f, -0.03294851f, -0.28793299f, 0.18043357f, 
    -0.06906255f, 0.00506991f, 0.02280302f, 0.03919435f, 0.11544985f, 0.09863676f, -0.18488306f, -0.01764180f, 
    -0.03812965f, 0.14543971f, -0.25214523f, -0.23920465f, 0.14554982f, -0.03376644f, 0.12816688f, 0.07539388f, 
    -0.00947376f, -0.02101670f, -0.15461501f, 0.07491621f, 0.10245536f, -0.05767586f, 0.26815104f, -0.46378732f, 
    -0.00873135f, 0.18885505f, -0.09788321f, 0.17032148f, 0.02016778f, 0.04597090f, 0.00375691f, -0.00280478f, 
    -0.03586375f, 0.15973480f, -0.18609035f, -0.05321717f, 0.00477793f, 0.08579376f, 0.08098751f, 0.01212323f, 
    0.07432397f, 0.13486636f, 0.01721577f, -0.10442881f, 0.21518365f, 0.27907136f, 0.22120735f, -0.08706357f, 
    -0.05697108f, 0.01831594f, -0.09053031f, -0.02035465f, -0.02685970f, -0.07173923f, -0.12068716f, -0.16183025f, 
    0.42724407f, 0.07899112f, 0.34028220f, 0.21790314f, 0.10592020f, 0.05749969f, 0.02375583f, 0.07023687f, 
    0.01846549f, -0.09823239f, 0.12011081f, -0.13584745f, -0.33642179f, -0.15419169f, 0.08029361f, -0.14857465f, 
    0.03317641f, -0.11652379f, 0.03894945f, -0.10070538f, -0.00532412f, 0.06326397f, 0.04128573f, 0.06597316f, 
    0.08679029f, 0.05405552f, 0.10213110f, 0.02551289f, 0.15566428f, 0.08915021f, 0.15325353f, -0.05381465f, 
    0.05215079f, 0.00377704f, 0.14309038f, -0.01891619f, 0.16345841f, 0.15423617f, -0.00897984f, 0.28421995f, 
    -0.05824081f, 0.10887590f, 0.01835485f, 0.25046796f, 0.14180230f, 0.08752072f, 0.03816585f, 0.09833847f, 
    -0.09894525f, -0.08869027f, -0.05709593f, -0.07723082f, 0.10515275f, -0.00126349f, 0.04340981f, 0.01799322f, 
    -0.01334764f, 0.23923619f, -0.07729626f, -0.04961660f, -0.11298819f, -0.08828708f, 0.03306882f, -0.16485479f, 
    0.04756750f, -0.01491597f, 0.07147259f, 0.06344507f, -0.02032995f, -0.06430665f, -0.09389201f, 0.06243433f, 
    -0.11951013f, -0.03454540f, -0.03781070f, 0.01239310f, 0.00351207f, -0.11429439f, -0.13801210f, -0.05603491f, 
    -0.07123122f, 0.04278785f, -0.01584271f, 0.12140345f, -0.68575698f, -0.21069509f, 0.17352639f, -0.15427113f, 
    0.04278658f, 0.09213978f, -0.07962972f, -0.24242412f, 0.08111370f, -0.04644474f, -0.08511414f, 0.12986511f, 
    0.10551114f, 0.16788612f, -0.02119411f, -0.28450131f, -0.02427163f, 0.07849380f, -0.00636179f, -0.24606739f, 
    0.06799226f, 0.05495816f, -0.04540026f, -0.03403511f, 0.11902474f, 0.34900680f, -0.14874426f, 0.25739533f, 
    -0.08615485f, -0.14293355f, 0.04765585f, 0.13588652f, 0.00138373f, 0.02188695f, -0.09221189f, -0.09879776f, 
    -0.13911425f, -0.01644145f, 0.02030737f, 0.03454751f, -0.12733032f, 0.08154202f, -0.11383644f, 0.01575471f, 
    0.04011917f, -0.05107329f, 0.19174695f, 0.04486954f, -0.25522611f, 0.30497900f, 0.09110810f, -0.06626072f, 
    -0.09189665f, 0.05707016f, 0.00658550f, -0.06544762f, 0.10172211f, -0.14822435f, -0.09784433f, 0.15537922f, 
    -0.01611798f, 0.05308281f, 0.26540741f, 0.15714939f, 0.07263581f, 0.06371117f, 0.12106056f, -0.27441153f, 
    0.08205758f, 0.21005200f, -0.09556616f, 0.11294109f, -0.17742369f, -0.00231842f, 0.07624973f, 0.04582103f, 
    0.03754967f, -0.04373806f, -0.00119072f, -0.16353178f, -0.09236607f, 0.02605034f, 0.04614304f, 0.03834907f, 
    0.14802624f, 0.47358659f, 0.23270001f, 0.23464751f, 0.03917227f, -0.10009854f, 0.06638883f, -0.00124917f, 
    0.01163862f, -0.05357715f, 0.08628420f, -0.00816228f, 0.10213231f, -0.04708765f, 0.21782161f, 0.33899233f, 
    0.08208071f, 0.05273065f, -0.05698638f, -0.09119241f, 0.07912274f, 0.10471355f, 0.14169389f, -0.07216408f, 
    0.42195180f, 0.04427018f, -0.10447557f, 0.19668822f, -0.36438456f, -0.01061898f, 0.21194482f, 0.01134542f, 
    0.05050683f, -0.09625047f, -0.04058279f, -0.09047643f, -0.22235982f, -0.10607624f, -0.34400406f, 0.15900318f, 
    -0.05205161f, 0.08651439f, 0.03892940f, 0.09738882f, -0.07124449f, 0.03048569f, 0.03257657f, -0.06175192f, 
    0.15624493f, 0.28079882f, -0.23243572f, -0.00404540f, 0.19802792f, -0.03842587f, 0.29850549f, 0.20078930f, 
    0.21238735f, -0.01155379f, 0.16039215f, -0.11991621f, 0.05038685f, -0.15134096f, 0.18309994f, -0.06502860f, 
    -0.02656704f, -0.01150614f, -0.15315655f, -0.07426522f, 0.06413542f, -0.11529963f, 0.00706689f, 0.00539914f, 
    0.31721023f, 0.00277861f, 0.23926704f, 0.06991645f, 0.03767704f, 0.01964531f, -0.07926507f, -0.01335291f, 
    0.16296804f, -0.00655014f, 0.19457750f, 0.02565679f, -0.11141401f, -0.10015013f, -0.22476630f, 0.00004096f, 
    0.12521504f, 0.14184041f, 0.03944102f, 0.14187442f, 0.01154083f, -0.01781188f, -0.03996775f, -0.02805281f, 
    -0.26692656f, -0.23490508f, -0.10741099f, 0.09975689f, -0.03793526f, -0.04495763f, 0.07246578f, 0.06866464f, 
    0.03952450f, -0.07204762f, -0.18297140f, -0.05551848f, 0.16088364f, -0.02111330f, 0.17615929f, -0.03833492f, 
    0.01194261f, -0.05249206f, -0.01289019f, -0.13204226f, 0.00152592f, -0.16728309f, 0.14531262f, -0.16448744f, 
    -0.31984311f, -0.06761289f, 0.15700434f, -0.02744847f, 0.05157175f, 0.11067884f, -0.07307515f, -0.02650495f, 
    -0.05018816f, 0.00261599f, -0.23147984f, -0.01887634f, 0.10213053f, -0.09202323f, 0.19949397f, 0.25421098f, 
    -0.06391112f, 0.05651807f, 0.03519108f, 0.03135710f, 0.01356809f, -0.05983124f, 0.05149591f, 0.05878840f, 
    -0.05454598f, -0.46059173f, -0.22050446f, -0.07011384f, 0.11845447f, 0.14642917f, -0.03761268f, 0.32841295f, 
    0.00984077f, -0.02790972f, 0.01565722f, -0.03217444f, -0.02680755f, 0.17319395f, 0.02086803f, -0.07218534f, 
    0.01860685f, 0.00050806f, 0.00377418f, -0.11276308f, -0.11282362f, -0.04013541f, 0.05000397f, -0.00576028f, 
    0.12026020f, 0.12309864f, 0.06772880f, 0.07369585f, 0.03166858f, 0.03641980f, -0.05853855f, -0.07163083f, 
    0.07004487f, -0.02259640f, -0.02511144f, -0.01291186f, 0.27434766f, -0.03252725f, 0.30497152f, 0.02362559f, 
    0.01765114f, 0.02055928f, 0.03579006f, 0.01008612f, 0.07569980f, 0.11688592f, -0.10230222f, -0.03745617f, 
    -0.04661865f, 0.25816631f, -0.03632687f, 0.22408730f, -0.18197736f, 0.06615271f, -0.02553092f, -0.01326879f, 
    -0.08085480f, -0.02356154f, 0.12593280f, -0.10126816f, 0.43260327f, -0.16247880f, 0.12885953f, -0.25985473f, 
    -0.06648751f, -0.04384703f, -0.13685857f, 0.00786131f, 0.09357777f, -0.12248471f, 0.11146126f, -0.11988116f, 
    -0.04654382f, -0.00456174f, 0.00351659f, -0.21006295f, 0.17521548f, -0.15316880f, 0.00973604f, 0.05429975f, 
    0.01386319f, 0.04973459f, 0.05616096f, 0.21479362f, 0.19292518f, 0.09148832f, 0.09742545f, -0.13163711f, 
    0.02879824f, -0.06119763f, -0.11394459f, 0.07211424f, 0.23922367f, -0.08176004f, 0.17716210f, -0.33634159f, 
    0.04229092f, 0.11823843f, 0.06328803f, -0.00949197f, 0.28434646f, -0.15255386f, -0.02511902f, 0.10677809f, 
    0.03626294f, -0.04067858f, 0.06708471f, 0.10782098f, -0.46700403f, 0.19597811f, 0.00757249f, -0.22876213f, 
    0.03755660f, 0.02115496f, -0.08599269f, -0.02269154f, -0.00622828f, 0.04902099f, 0.03647487f, -0.00467736f, 
    0.23040487f, 0.10900129f, 0.12628843f, -0.04894223f, 0.05793671f, 0.01812756f, 0.04623678f, -0.07493828f, 
    -0.17262018f, 0.04796156f, 0.16349757f, -0.04521533f, 0.31857973f, -0.05396654f, 0.21037741f, -0.08304042f, 
    0.05234874f, 0.09589696f, 0.02116783f, 0.04833381f, 0.05225648f, -0.05016088f, 0.13346942f, -0.07516935f, 
    0.04834373f, 0.03922589f, 0.00698997f, 0.08308810f, -0.01801674f, 0.05416906f, 0.20786797f, -0.00690707f, 
    -0.01804014f, 0.09172680f, 0.13314345f, 0.02154851f, 0.21207303f, 0.11735941f, -0.19611852f, -0.16907829f, 
    -0.02055950f, -0.03880407f, 0.11308722f, 0.13114282f, 0.12068059f, 0.03271721f, 0.12755196f, -0.04675828f, 
    -0.10775470f, 0.21266454f, 0.03871011f, 0.09433052f, -0.08611576f, 0.10831348f, -0.07141919f, 0.00186430f, 
    0.01656320f, 0.02375096f, 0.09373872f, 0.26171872f, -0.55798429f, -0.36157894f, -0.05997438f, -0.15924598f, 
    -0.05578402f, -0.11109819f, 0.01455006f, 0.01249048f, -0.00554482f, -0.06284479f, -0.09682387f, -0.07923628f, 
    0.14667962f, 0.25740978f, -0.21183713f, -0.01319892f, -0.06382630f, 0.07078534f, 0.28247508f, -0.07815223f, 
    0.10107801f, -0.04795220f, -0.08241412f, -0.01153836f, 0.13615318f, 0.06096575f, -0.05930884f, -0.14831410f, 
    -0.08536956f, -0.00416953f, 0.12494691f, 0.17692764f, 0.05261476f, 0.12120562f, 0.15687208f, -0.04819719f, 
    -0.16381517f, 0.06632628f, -0.04869668f, -0.33231962f, -0.01891354f, -0.09758788f, -0.11661644f, 0.23307796f, 
    0.02495259f, 0.07019291f, 0.25757366f, 0.02014392f, 0.27232558f, 0.28995040f, -0.06138470f, -0.01918859f, 
    0.08046733f, -0.04222521f, 0.03158483f, 0.00523937f, 0.06178685f, 0.15851018f, 0.12337908f, 0.08469357f, 
    0.07667698f, -0.06805716f, -0.01925059f, -0.41833109f, -0.14909557f, -0.09137238f, -0.23903689f, 0.18389276f, 
    -0.04216281f, -0.09647317f, 0.01831896f, 0.00542000f, 0.12324624f, -0.09957927f, -0.20481923f, -0.27093503f, 
    -0.04710041f, -0.03623152f, -0.03951172f, -0.03613411f, -0.00186822f, 0.06958879f, 0.01580685f, 0.15220909f, 
    0.00481721f, -0.02831197f, 0.11676838f, -0.18143281f, 0.05521938f, 0.18740822f, 0.02666720f, -0.05764226f, 
    -0.01435393f, 0.03761262f, -0.01798271f, -0.00411710f, -0.30774328f, 0.03169453f, 0.34874436f, -0.11830458f, 
    0.06217041f, 0.32435396f, 0.07011270f, -0.01903870f, 0.02528447f, 0.00799505f, -0.06020246f, -0.03658841f, 
    -0.06822111f, 0.19154638f, -0.13470657f, -0.31991407f, -0.11579411f, -0.18806335f, 0.01248153f, -0.02603996f, 
    0.07696961f, -0.19018579f, -0.00582160f, -0.00300965f, -0.40889564f, -0.00543427f, 0.09086925f, -0.05321383f, 
    0.05715730f, 0.01923037f, 0.15391894f, 0.02990208f, 0.09635054f, -0.09569773f, 0.04524148f, -0.08793961f, 
    -0.23899677f, -0.02065839f, -0.06384935f, -0.14440200f, -0.08716287f, 0.00296701f, -0.12447454f, -0.21740967f, 
    -0.15352182f, -0.36141440f, 0.03815971f, -0.20982420f, 0.04542944f, -0.03190803f, -0.04027144f, 0.08630953f, 
    0.05042938f, 0.17070094f, 0.08653677f, -0.11677457f, 0.00064573f, 0.02050255f, 0.00192495f, 0.22494967f, 
    -0.05118973f, -0.15352939f, -0.14266071f, -0.10264190f, -0.03793303f, -0.12754300f, 0.09438345f, -0.05159334f, 
    0.11690617f, 0.14637634f, 0.07062373f, 0.16678461f, 0.12060922f, -0.00559069f, 0.00527151f, 0.10796354f, 
    0.03922117f, -0.10313396f, -0.03499341f, 0.05892633f, 0.08095753f, 0.07822196f, 0.10687047f, 0.11572950f, 
    0.63652366f, -0.33608350f, 0.09303085f, 0.13510507f, 0.13574804f, 0.05521936f, -0.01923666f, 0.32356721f, 
    0.17781940f, 0.24978195f, 0.05396917f, 0.17523663f, 0.06471924f, 0.02377233f, 0.07866143f, -0.04391139f, 
    0.03890290f, 0.00479088f, 0.06829919f, 0.07743981f, -0.02812483f, -0.06099247f, -0.11352970f, -0.17738950f, 
    -0.17290561f, 0.03535332f, 0.05551992f, -0.15140627f, -0.10945646f, -0.01829928f, 0.02636486f, -0.14049467f, 
    0.10820951f, 0.01642989f, 0.08820945f, 0.05781028f, 0.28697783f, -0.06481491f, 0.15100482f, 0.00427033f, 
    0.15393823f, -0.15403712f, -0.02060097f, 0.01466971f, 0.05049642f, 0.08244563f, 0.17255679f, 0.06737568f, 
    -0.07591220f, -0.15720564f, 0.02253545f, 0.09284060f, -0.00577867f, 0.02093025f, -0.16440071f, -0.04798312f, 
    0.11473230f, 0.09700482f, 0.24937211f, -0.00052449f, -0.28918576f, -0.20474227f, -0.30590585f, 0.28472126f, 
    -0.05851107f, -0.23547758f, -0.13689481f, -0.25941876f, 0.16447720f, -0.02387406f, 0.09072664f, 0.10787288f, 
    -0.08467564f, -0.03105546f, -0.04375367f, 0.37356928f, 0.07736464f, -0.04264319f, -0.14696629f, -0.09698908f, 
    0.04204183f, 0.05240301f, -0.05955170f, 0.34677419f, -0.11160699f, -0.30754638f, 0.08946668f, 0.07505588f, 
    0.05826962f, -0.00049309f, -0.08217122f, 0.02595553f, 0.23007002f, 0.07061203f, 0.37572622f, 0.10942078f, 
    -0.38527930f, 0.08474966f, -0.05881386f, -0.18449128f, -0.02715885f, -0.02281872f, 0.14152449f, 0.08930063f, 
    0.13315603f, 0.11055925f, 0.06928809f, 0.12306015f, 0.15600266f, 0.04123805f, -0.11069089f, -0.04502220f, 
    -0.06841817f, -0.05477438f, -0.08905473f, 0.02727990f, 0.05740478f, -0.12945250f, 0.02612654f, -0.05124787f, 
    -0.14367956f, -0.21316756f, -0.22845551f, -0.11336193f, 0.02524996f, -0.05057325f, -0.06310172f, 0.03474038f, 
    0.06989431f, 0.15702754f, 0.01873390f, 0.13633494f, -0.11926405f, -0.29657903f, -0.00450439f, 0.04420099f, 
    0.17281741f, -0.01277367f, 0.10454820f, 0.00840770f, -0.03301881f, 0.03888986f, 0.00768177f, 0.02521721f, 
    -0.08059203f, -0.03407743f, -0.01533901f, -0.01534371f, 0.07518175f, 0.06174257f, 0.01589728f, 0.03966214f, 
    0.15829232f, -0.14233589f, 0.17700008f, 0.14048518f, 0.12817241f, 0.00216889f, 0.07731756f, 0.11816364f, 
    -0.09287661f, 0.00159215f, -0.07603450f, -0.08613102f, 0.15809463f, -0.05633253f, 0.08546160f, 0.08964919f, 
    0.02170999f, -0.00993765f, -0.07750367f, -0.10320748f, 0.04207254f, 0.07557479f, 0.09553264f, 0.15433960f, 
    -0.10457115f, 0.06316077f, 0.00534719f, -0.34078911f, 0.42872474f, -0.03586324f, -0.16325472f, 0.00012173f, 
    0.07868715f, 0.04312323f, 0.07463352f, 0.23290834f, 0.02596541f, 0.01164896f, 0.01000591f, -0.16584551f, 
    -0.38496602f, -0.10327646f, 0.27222615f, 0.28410929f, 0.14728138f, -0.11561627f, -0.01919992f, 0.17802121f, 
    -0.06132247f, 0.02187203f, 0.04196798f, 0.05377791f, -0.14725657f, -0.00494780f, -0.02970663f, 0.00190027f, 
    0.15999021f, 0.12108482f, 0.15688606f, -0.03924698f, -0.04087010f, 0.09507785f, 0.11899535f, 0.20004471f, 
    -0.02411805f, -0.01517811f, -0.25305918f, -0.03660642f, 0.27270278f, 0.05470582f, 0.00875499f, 0.22057596f, 
    0.07765438f, 0.12866600f, -0.03491816f, 0.05971576f, 0.39918602f, -0.11443292f, 0.00790916f, 0.12144089f, 
    0.05276344f, -0.03314669f, -0.00490367f, 0.09429247f, 0.01070838f, 0.17302655f, 0.15028726f, -0.29982990f, 
    0.10009221f, 0.18112645f, -0.18757775f, -0.04317250f, -0.00054285f, 0.07460043f, 0.09531336f, 0.13746358f, 
    0.00097967f, -0.17273809f, 0.15259664f, -0.03234309f, 0.16233136f, 0.03231723f, -0.10530897f, 0.02543115f, 
    -0.04245757f, 0.02509465f, -0.06022396f, -0.03484350f, -0.05057019f, -0.08123963f, -0.00263579f, -0.11873388f, 
    -0.11395924f, -0.18345110f, -0.09073646f, -0.10736687f, 0.08851915f, 0.22177735f, -0.05758289f, 0.08763978f, 
    0.08919121f, 0.10393116f, 0.24708723f, 0.11810715f, -0.05994051f, -0.00498170f, -0.11574763f, -0.22468518f, 
    0.09598891f, 0.08988899f, 0.11376058f, 0.10527925f, -0.01928640f, -0.14729992f, -0.22974473f, -0.17380880f, 
    0.28768054f, 0.23856069f, 0.13782740f, -0.23214430f, 0.04936646f, 0.18562010f, -0.06553390f, -0.14970703f, 
    0.04242129f, -0.03083333f, 0.03992344f, -0.08226521f, -0.04230661f, -0.15020989f, 0.13579865f, -0.09914476f, 
    0.02943434f, 0.25483668f, 0.01474861f, -0.10264871f, -0.08351777f, 0.06277822f, 0.10980261f, 0.05165244f, 
    0.07862548f, -0.14505856f, 0.39194366f, -0.05540198f, -0.04797646f, 0.12065459f, -0.06768607f, -0.18026698f, 
    -0.11260606f, 0.00874117f, 0.00491941f, 0.06355180f, -0.05387058f, 0.03869918f, 0.15744829f, -0.13136995f, 
    -0.01187315f, -0.10710359f, -0.30603069f, -0.03340586f, -0.10713458f, 0.07892652f, 0.09439499f, -0.04665893f, 
    0.04277881f, 0.07507901f, -0.19820148f, 0.15413913f, -0.05865322f, -0.10388439f, 0.12753604f, 0.07574226f, 
    0.07993574f, 0.07227224f, 0.14037246f, 0.01739912f, -0.21338160f, -0.10301531f, 0.09186199f, 0.04611778f, 
    -0.10653441f, -0.00735528f, 0.10121772f, -0.13466072f, -0.00564369f, 0.03990584f, -0.04056249f, 0.10513101f, 
    -0.13383737f, -0.16154228f, -0.04012288f, -0.02473947f, 0.10926671f, -0.38594815f, -0.20234056f, -0.10858718f, 
    -0.05789806f, -0.03554792f, -0.14306173f, -0.04144485f, 0.02955315f, -0.04863374f, -0.23174611f, 0.25419003f, 
    0.09264331f, -0.00482313f, -0.00648778f, 0.04871252f, 0.06346922f, 0.01444299f, -0.09905948f, 0.06053517f, 
    -0.11951395f, -0.10433426f, 0.05082940f, 0.24176183f, 0.08419174f, 0.09989639f, 0.10524045f, 0.15601663f, 
    -0.08194569f, -0.14324500f, -0.16373132f, -0.28891870f, -0.02065746f, 0.14965187f, -0.10240297f, -0.17504232f, 
    0.01747607f, 0.00571048f, -0.04917607f, 0.04724652f, 0.16261683f, 0.20305996f, 0.21060930f, 0.00472996f, 
    -0.14122000f, -0.25627199f, 0.19338222f, 0.22771794f, 0.05783963f, -0.09317013f, -0.02136705f, 0.02996744f, 
    -0.11580054f, 0.10257563f, 0.20623560f, 0.07522133f, 0.21360317f, -0.14159946f, 0.03133554f, -0.07744082f, 
    0.18254957f, 0.15032580f, -0.09017350f, 0.06377707f, 0.05725105f, 0.04817717f, 0.19991286f, 0.11791436f, 
    -0.11267462f, -0.02131218f, 0.15926713f, 0.20250948f, 0.05543104f, -0.02764848f, -0.00496137f, 0.03066004f, 
    0.00428299f, -0.04213869f, -0.05292834f, 0.17915033f, -0.04455554f, 0.10688277f, -0.19643383f, 0.12080067f, 
    0.03294002f, -0.06979889f, 0.07702722f, -0.01464092f, -0.13528091f, 0.10727523f, -0.05519979f, -0.10731482f, 
    -0.04229284f, -0.00604660f, 0.26555118f, -0.28836814f, 0.11053403f, 0.07767189f, -0.07159489f, 0.07621974f, 
    0.09098836f, 0.02360646f, 0.02627315f, -0.15509428f, -0.06148668f, 0.03388149f, -0.03572425f, 0.45675763f, 
    -0.02417172f, -0.07889102f, 0.08920922f, -0.06312467f, 0.03079483f, -0.12543082f, 0.21557023f, 0.11380749f, 
    -0.39599970f, -0.02130189f, 0.03201138f, 0.04884825f, -0.01721438f, -0.08760380f, -0.13948131f, -0.00398657f, 
    -0.13159713f, -0.03767616f, -0.07865743f, -0.09391420f, 0.31777310f, -0.06455986f, 0.00267356f, 0.24576443f, 
    -0.02935006f, 0.10680792f, -0.02281428f, 0.08286201f, -0.02065131f, 0.01005616f, 0.05591805f, -0.12817301f, 
    0.04064552f, 0.04100516f, 0.00272053f, -0.04201850f, 0.07403461f, 0.04060487f, -0.10686770f, 0.22263223f, 
    -0.08193004f, -0.23790944f, -0.18596938f, -0.25796849f, -0.14853217f, -0.00530532f, 0.08204810f, -0.02150627f, 
    -0.15861276f, -0.21004915f, -0.07814252f, -0.37153608f, -0.01425559f, -0.06677297f, -0.07388505f, -0.18622634f, 
    0.15088540f, 0.06722280f, -0.12607230f, 0.16160542f, -0.01914772f, 0.02191004f, 0.05499006f, -0.01788532f, 
    -0.03425364f, -0.06528316f, 0.08535171f, -0.12952340f, -0.00930277f, 0.10669743f, 0.02979278f, 0.18269072f, 
    0.01970419f, -0.00307068f, 0.00984327f, 0.01033438f, -0.10589831f, -0.05605828f, 0.06940839f, -0.21863098f, 
    0.05571044f, 0.05809864f, 0.01699173f, -0.17807640f, 0.03699588f, 0.14745708f, -0.00009736f, -0.09150146f, 
    0.21855547f, 0.10784853f, 0.27513635f, 0.29266116f, 0.49898785f, -0.05092667f, -0.07514266f, 0.13743433f, 
    -0.01070937f, -0.07923894f, -0.07088567f, 0.03921639f, -0.04596355f, 0.08009348f, 0.05172475f, -0.01656813f, 
    0.32294583f, -0.21980760f, 0.14475106f, 0.00791370f, -0.02888325f, 0.03743538f, 0.12485206f, 0.20159143f, 
    0.12358496f, -0.01196075f, 0.16706912f, 0.09605309f, -0.04105209f, -0.13997045f, 0.40346360f, -0.01246381f, 
    0.08371258f, 0.08577727f, -0.19929792f, 0.10955571f, 0.04843823f, -0.03561617f, 0.09513225f, 0.05048591f, 
    0.33804220f, -0.06567967f, 0.14604801f, -0.20819579f, -0.02389441f, -0.02376662f, -0.01930939f, -0.05648087f, 
    -0.00181518f, -0.10383361f, -0.12637287f, -0.17668420f, 0.12520416f, -0.15920366f, -0.03796697f, -0.06160681f, 
    0.03890881f, 0.05129433f, 0.05152300f, -0.13366096f, 0.12347389f, 0.32187834f, 0.14945805f, 0.18251930f, 
    -0.02386245f, 0.12149907f, 0.26922640f, -0.14932844f, -0.25459325f, -0.08977703f, -0.02505115f, 0.00577309f, 
    -0.11317057f, 0.03803025f, 0.02901565f, -0.07505061f, 0.22055446f, -0.01252299f, 0.18288127f, -0.11510338f, 
    -0.00521453f, 0.01726940f, -0.06189218f, 0.09281962f, 0.08192094f, 0.30429924f, 0.27464083f, 0.25282207f, 
    0.00186369f, -0.02494582f, 0.06690801f, 0.02731302f, -0.00620583f, 0.01474604f, -0.00006416f, 0.05387380f, 
    -0.11340345f, -0.10719827f, -0.02107912f, 0.09250080f, -0.08111530f, 0.12935200f, -0.06865091f, -0.30189848f, 
    -0.19114175f, -0.10071369f, 0.10379216f, 0.10923249f, -0.04323317f, 0.17626011f, 0.07252040f, 0.20471273f, 
    -0.22101288f, -0.27133939f, -0.39785865f, -0.01919494f, 0.33175567f, 0.01786021f, -0.02949889f, 0.11380012f, 
    -0.13380861f, -0.02659070f, -0.06188103f, -0.10250128f, -0.07835542f, 0.20669678f, -0.34209555f, 0.31690720f, 
    0.07482047f, -0.12501925f, 0.08120000f, 0.09529255f, -0.00410363f, -0.17834349f, 0.18652207f, -0.05325616f, 
    0.06885534f, 0.04498544f, -0.17312883f, 0.05066412f, -0.04111211f, -0.05378191f, -0.00361456f, -0.09672011f, 
    0.02210194f, 0.12664635f, -0.04774313f, 0.09504715f, 0.12809002f, 0.03030236f, 0.08140063f, 0.25291067f, 
    0.00312675f, -0.00157688f, 0.06555651f, 0.03882790f, 0.17808104f, 0.05747379f, -0.05751735f, 0.14196594f, 
    -0.03915822f, -0.22038637f, -0.03530674f, -0.05205041f, -0.11691252f, -0.24914801f, -0.12515891f, -0.00153534f, 
    0.18112856f, 0.11960214f, -0.16706157f, 0.23740809f, 0.07815945f, 0.26752537f, -0.11556235f, -0.19238667f, 
    0.09680825f, 0.04645590f, -0.01080806f, 0.18477802f, 0.03748333f, 0.08645511f, 0.04038292f, -0.01456245f, 
    0.10217179f, 0.21345714f, 0.15158185f, -0.11072266f, 0.08540534f, 0.21088469f, 0.10440651f, 0.05566584f, 
    -0.03916620f, -0.24333690f, -0.01345654f, -0.16916426f, -0.00376979f, 0.03592299f, 0.16870639f, 0.14044291f, 
    -0.23736638f, -0.00938647f, 0.09880037f, -0.23911449f, 0.05426134f, -0.13708857f, -0.09491814f, 0.13572240f, 
    -0.27108335f, 0.30159619f, 0.21434958f, 0.02226911f, 0.10916197f, 0.02339171f, 0.05804304f, -0.14374168f, 
    -0.03301762f, -0.06601315f, 0.02782371f, 0.02898341f, -0.10649082f, -0.06055041f, -0.07267752f, 0.22112709f, 
    -0.04262027f, -0.07460649f, -0.10988308f, -0.19352826f, -0.04169523f, -0.00051819f, 0.07867382f, 0.13545802f, 
    0.21892217f, 0.15380916f, 0.09799439f, -0.06684823f, -0.03138920f, 0.07294118f, 0.06180671f, 0.11586852f, 
    0.07323597f, 0.06235894f, -0.01236276f, -0.07714779f, -0.19661082f, -0.01067413f, -0.01640723f, 0.31099230f, 
    0.05458779f, 0.00926983f, -0.00637562f, 0.03041932f, 0.14385839f, -0.01429868f, -0.10374063f, 0.05469451f, 
    0.09167544f, -0.00815361f, -0.24753323f, -0.13905807f, -0.06510555f, -0.01338475f, 0.15079856f, 0.02865842f, 
    0.04359483f, 0.01015282f, -0.21577369f, 0.16273004f, -0.07747903f, -0.13288860f, 0.10262490f, -0.60109311f, 
    -0.09669750f, -0.01525441f, -0.11924323f, 0.04430332f, -0.11360925f, -0.08809956f, -0.04647652f, 0.02535994f, 
    -0.13381903f, 0.14236815f, -0.09032074f, -0.00240253f, -0.08480722f, -0.05682622f, 0.19725268f, -0.04466031f, 
    -0.03292743f, 0.03314248f, -0.00998587f, -0.14149147f, 0.08903967f, 0.48971805f, 0.20483153f, -0.10437915f, 
    -0.23216726f, -0.07301057f, 0.01450896f, -0.15844035f, 0.07046237f, -0.00899118f, -0.16067880f, 0.05451496f, 
    0.16422564f, -0.00606167f, 0.02975770f, 0.00612928f, 0.09116025f, 0.16207655f, -0.08356861f, 0.24223466f, 
    -0.00001988f, -0.17975326f, -0.23596467f, -0.23640579f, -0.55232477f, -0.33240551f, 0.05498316f, -0.15072663f, 
    -0.15827762f, -0.21436211f, 0.21917406f, -0.37124157f, -0.10778663f, 0.01322133f, -0.03561567f, 0.19753215f, 
    0.16740231f, -0.00312313f, -0.05943465f, -0.10224772f, -0.00960502f, 0.14111988f, 0.26581487f, -0.13015701f, 
    -0.17067380f, -0.09315771f, -0.17704287f, -0.09296221f, 0.12180480f, 0.25292715f, 0.13072371f, 0.00492318f, 
    -0.04655956f, 0.08963906f, 0.01021366f, 0.08685690f, 0.09908480f, -0.03269109f, 0.09846164f, 0.08207260f, 
    -0.07262963f, -0.14837828f, -0.05506050f, -0.11771554f, -0.05759515f, -0.07089317f, 0.20639326f, 0.13535112f, 
    0.07806776f, 0.10101016f, -0.32254830f, 0.03850599f, -0.11780681f, -0.02126175f, -0.11823149f, 0.04910778f, 
    -0.07093910f, -0.04180004f, -0.05517839f, -0.02220039f, -0.03119963f, -0.15244967f, -0.11636715f, -0.03752409f, 
    -0.17336361f, -0.09803090f, -0.13859639f, 0.10622159f, 0.18352452f, -0.01927955f, -0.14777218f, -0.18105967f, 
    0.07561991f, 0.07036888f, -0.11704510f, 0.25480098f, -0.56324202f, -0.10569603f, 0.03724734f, 0.18528967f, 
    0.09324238f, 0.18284348f, -0.01050211f, -0.18559815f, 0.01993563f, -0.00359392f, -0.02507422f, 0.05449431f, 
    -0.01638972f, 0.17834802f, -0.21705332f, -0.12097773f, 0.13801247f, 0.15451871f, -0.06430726f, -0.02097221f, 
    0.19242965f, 0.08911239f, 0.04875285f, 0.04833234f, -0.32445976f, 0.25434878f, -0.01400300f, 0.15268336f, 
    -0.03537255f, 0.02736165f, 0.06016591f, 0.03521090f, 0.05845560f, 0.06466036f, -0.05335240f, -0.05131684f, 
    -0.18680938f, -0.24931099f, 0.04686910f, 0.08734791f, -0.05963607f, 0.02394762f, -0.08990334f, 0.04397480f, 
    -0.09886400f, -0.03475924f, 0.11055964f, -0.01870749f, -0.17645402f, 0.22149095f, 0.10215465f, 0.06654995f, 
    -0.05879564f, 0.07260934f, -0.04064187f, -0.16304733f, 0.08330440f, -0.14992630f, 0.02959221f, 0.29877585f, 
    0.16712001f, 0.09453559f, 0.21210767f, 0.03245751f, -0.05997931f, 0.05638342f, -0.01680793f, -0.13749290f, 
    0.08785702f, 0.16741408f, -0.00767602f, 0.12162996f, -0.27117705f, -0.11226245f, 0.06074648f, 0.18349271f, 
    -0.06222427f, -0.11158169f, 0.06861170f, -0.23324171f, -0.00153372f, -0.05032158f, 0.15823410f, 0.25993800f, 
    0.11434517f, 0.29734409f, 0.20653860f, 0.17290011f, -0.13475208f, -0.10570360f, 0.15015244f, -0.04143662f, 
    0.11482698f, 0.04109358f, -0.12253805f, 0.02149178f, 0.10078110f, 0.09843154f, 0.10918330f, 0.14148824f, 
    0.03985599f, 0.17329985f, 0.02918971f, -0.10279581f, 0.15690166f, 0.00252711f, 0.14053899f, 0.14175278f, 
    0.09706213f, 0.34710875f, 0.49466619f, 0.09366424f, 0.02960405f, -0.08450934f, 0.05568753f, 0.05284907f, 
    -0.06372181f, 0.00268886f, -0.01994690f, 0.10668451f, 0.15826946f, 0.07712649f, 0.34941915f, 0.02036483f, 
    -0.02555766f, 0.08839560f, 0.12216111f, 0.10382947f, 0.00899433f, 0.13765422f, -0.23879924f, 0.06772728f, 
    -0.30833778f, -0.11860336f, 0.25011677f, 0.12367968f, -0.04871544f, 0.02878724f, 0.01211143f, 0.18403892f, 
    -0.04249340f, -0.06083611f, 0.05003879f, -0.04083725f, 0.40333650f, -0.07574720f, -0.11757348f, -0.13593467f, 
    0.07829559f, -0.02983183f, 0.21971270f, -0.11399314f, 0.03946956f, -0.04139998f, -0.07785964f, 0.02813349f, 
    -0.19696945f, 0.13406292f, 0.08887395f, -0.03007067f, -0.09906685f, -0.05052738f, 0.09535316f, -0.01931239f, 
    -0.10019580f, -0.06656580f, -0.01175258f, -0.10788703f, 0.13154572f, -0.05430457f, 0.06253146f, 0.12137844f, 
    -0.00208555f, 0.04782180f, -0.00451414f, -0.11700355f, 0.02490229f, 0.07913249f, 0.06899639f, 0.08498320f, 
    0.08800618f, -0.12441409f, -0.11396338f, 0.09729803f, 0.03888660f, 0.09088312f, 0.11661435f, 0.10331383f, 
    0.02072919f, 0.13481778f, 0.07715488f, 0.08788110f, 0.15525617f, 0.03818576f, 0.18982893f, -0.18887860f, 
    0.06881216f, 0.01298118f, -0.05797611f, -0.15379718f, 0.08707343f, 0.13407761f, 0.15929721f, 0.18179531f, 
    0.50937885f, -0.00591332f, 0.11421177f, -0.02073495f, 0.20663640f, 0.01507785f, 0.00664918f, -0.05308114f, 
    0.12892097f, -0.03173854f, 0.22503024f, 0.09938591f, 0.07282936f, 0.10510568f, -0.00541776f, -0.19391748f, 
    -0.10953084f, 0.00028918f, -0.09813579f, -0.07215094f, -0.05525762f, 0.12749156f, 0.05945199f, -0.01495385f, 
    0.03396053f, 0.02757580f, -0.15058042f, -0.08543336f, 0.01774438f, 0.09552866f, -0.00289324f, -0.06936812f, 
    0.05038867f, -0.05354116f, 0.06683698f, 0.13592577f, 0.32618049f, 0.12476454f, 0.18754548f, -0.19442153f, 
    0.01880982f, -0.07569158f, 0.04224570f, -0.10917969f, 0.07391363f, 0.08714474f, 0.07483152f, 0.10840546f, 
    0.00051946f, 0.05703349f, -0.15146658f, -0.12336171f, 0.02166080f, -0.11096538f, 0.04988088f, 0.05292726f, 
    0.00221463f, 0.04568870f, 0.15421006f, 0.10988624f, -0.20176160f, -0.01924091f, 0.08110107f, 0.11234545f, 
    -0.05935798f, -0.00135756f, -0.04083562f, -0.11188451f, 0.02887633f, 0.08307518f, 0.05391191f, 0.14217803f, 
    0.23960313f, -0.03058739f, -0.26281592f, 0.03708464f, 0.16334856f, -0.10008889f, -0.01558673f, -0.04883304f, 
    0.10810764f, 0.21467066f, 0.00395042f, 0.15175287f, -0.09544548f, -0.33918428f, -0.00669286f, -0.09648702f, 
    0.08533075f, 0.03416437f, -0.05716761f, -0.07683239f, 0.15539619f, 0.01295303f, 0.14073013f, 0.24299231f, 
    0.03322015f, -0.01668634f, -0.17332646f, 0.15292598f, 0.02137999f, 0.04751695f, 0.21915510f, 0.10038616f, 
    -0.00221838f, 0.05986888f, 0.06290754f, 0.02351288f, -0.11697344f, 0.03667434f, 0.04932609f, -0.13871573f, 
    -0.01183360f, -0.00285323f, -0.07529150f, 0.03001243f, -0.02070712f, -0.01507179f, 0.07997525f, 0.22156948f, 
    -0.11538485f, -0.20053929f, -0.16874176f, -0.12642972f, 0.05169763f, -0.04688386f, 0.15418150f, 0.04551990f, 
    0.10471559f, 0.12250180f, -0.07444736f, 0.06546682f, 0.29072058f, -0.16072276f, -0.11628057f, -0.09931202f, 
    0.09745114f, 0.07574543f, 0.05261387f, 0.14854106f, -0.12107415f, -0.01411618f, -0.06443951f, -0.05124114f, 
    -0.12785444f, 0.04519977f, -0.04297258f, -0.03478052f, 0.18176855f, 0.12782425f, -0.09422382f, -0.06075618f, 
    0.03608023f, -0.04541805f, 0.12250458f, 0.18252943f, -0.10942155f, 0.15915139f, 0.25346488f, 0.00267161f, 
    -0.17875513f, -0.07763822f, -0.00121913f, -0.07071741f, 0.08905409f, 0.00442004f, -0.02007984f, 0.08891496f, 
    -0.17779920f, -0.03839275f, 0.21352600f, 0.08196177f, -0.04818791f, 0.06365817f, 0.04499523f, 0.03496468f, 
    0.00326204f, 0.06665410f, 0.02717298f, -0.18060550f, -0.28706041f, 0.14157167f, 0.20452559f, 0.09846310f, 
    0.00835295f, -0.02087466f, -0.16913106f, 0.06669698f, -0.01913011f, -0.01914488f, -0.11587587f, 0.06130107f, 
    0.03439529f, 0.13567452f, 0.22617994f, -0.10774624f, 0.06105897f, -0.12523505f, 0.10392275f, 0.02778208f, 
    0.07670934f, 0.01569221f, -0.09798257f, 0.00772091f, 0.49657416f, -0.07300603f, -0.13597234f, -0.23145117f, 
    0.09170666f, 0.09517774f, 0.11139710f, -0.03831271f, -0.01572710f, 0.00317850f, 0.05601610f, 0.11871800f, 
    -0.28145066f, 0.05595909f, 0.04055641f, 0.11086973f, 0.23513082f, 0.02466995f, -0.06224165f, -0.04903512f, 
    -0.00863036f, 0.08391301f, 0.10159449f, 0.18757403f, -0.14258087f, -0.02871508f, 0.18464479f, 0.09604723f, 
    -0.01552164f, 0.00047570f, -0.02373055f, 0.03670871f, 0.10716030f, 0.05730802f, -0.08482483f, -0.05422590f, 
    -0.24086323f, -0.37206781f, -0.23084514f, 0.08429079f, 0.02332275f, 0.04783122f, 0.15847994f, 0.08148069f, 
    -0.04520397f, -0.11592943f, -0.04193531f, 0.06366409f, -0.22447111f, 0.01930489f, -0.04197787f, 0.05583940f, 
    -0.04680398f, -0.05288513f, -0.06682320f, 0.04578580f, 0.18752405f, 0.00676945f, 0.02765943f, -0.13245548f, 
    0.13020398f, -0.52734500f, -0.23657864f, -0.11736673f, 0.06155822f, 0.16210784f, 0.13067147f, 0.01623414f, 
    0.04044053f, -0.01538931f, 0.18219739f, 0.09893107f, -0.01237695f, -0.17456904f, -0.08654916f, 0.05300602f, 
    0.12114586f, 0.05976938f, 0.01256137f, 0.06291188f, 0.03887951f, -0.06546433f, -0.01733253f, -0.05480854f, 
    0.23233014f, 0.25733468f, 0.09163308f, 0.38252708f, 0.05333429f, -0.17081288f, 0.02628650f, -0.11865745f, 
    -0.07277559f, -0.14359951f, 0.04089632f, -0.07472710f, 0.46935511f, 0.09121911f, 0.07013906f, -0.16417347f, 
    0.14989892f, -0.01762936f, 0.14833139f, -0.00685326f, -0.02130628f, -0.04200240f, -0.05342095f, 0.04136712f, 
    -0.14898454f, -0.11599386f, 0.19662802f, -0.11870815f, 0.11013892f, 0.19310813f, -0.10971400f, 0.20408213f, 
    0.15662180f, 0.04913468f, -0.08415841f, -0.10822088f, -0.00123479f, -0.12560250f, -0.07653234f, 0.20277105f, 
    0.02460028f, -0.02365132f, -0.12921514f, 0.00356184f, -0.13762330f, 0.04369273f, -0.04887735f, 0.12164257f, 
    0.06566596f, 0.11672221f, 0.02110017f, 0.14239089f, 0.01606207f, 0.08374248f, 0.16749032f, 0.11567949f, 
    0.13253923f, 0.08849230f, 0.01845911f, 0.07302545f, -0.11500499f, -0.04172580f, 0.11222711f, 0.02082649f, 
    -0.02927790f, -0.00582267f, 0.16485804f, 0.08735900f, -0.01270319f, 0.01590856f, -0.06382195f, -0.06357647f, 
    -0.19098094f, -0.10276406f, -0.00761970f, 0.13318092f, 0.01697353f, -0.07005358f, -0.01368463f, 0.19432947f, 
    -0.00154514f, 0.11015649f, 0.11595299f, -0.11691708f, 0.17623508f, 0.04725843f, 0.14015698f, 0.06954665f, 
    -0.07476626f, 0.03977050f, -0.04916668f, -0.10086881f, -0.04571831f, 0.03019843f, -0.00814775f, 0.18315282f, 
    -0.07814073f, 0.00501509f, -0.28998229f, -0.10181636f, -0.09140108f, -0.17816035f, -0.12806934f, -0.00102960f, 
    -0.02119306f, 0.20281591f, 0.07080802f, -0.13203572f, 0.05008301f, 0.23936467f, -0.07071955f, 0.00085940f, 
    -0.00426846f, -0.03029072f, -0.13296305f, 0.05650837f, 0.08345642f, 0.25931993f, 0.22435059f, 0.29881811f, 
    -0.23931645f, -0.10187171f, 0.09484375f, 0.12133027f, 0.11205804f, 0.07060228f, 0.02856491f, 0.18064223f, 
    0.09035982f, 0.15176012f, 0.04280882f, 0.12620059f, -0.02684225f, 0.07251001f, -0.28470415f, 0.21114445f, 
    -0.07449120f, -0.05377851f, 0.03804095f, -0.00746596f, 0.15479955f, 0.01505002f, 0.05704799f, 0.13963811f, 
    0.04509167f, 0.13820340f, 0.02195063f, -0.04632187f, 0.17312658f, -0.03274406f, 0.12896262f, 0.00664841f, 
    0.11784724f, -0.08877262f, 0.13779776f, 0.05161296f, 0.13347602f, 0.07491368f, 0.03763584f, -0.05833156f, 
    0.01965999f, 0.07661701f, 0.00032117f, 0.08187986f, -0.00322059f, 0.10476102f, -0.19704060f, -0.05398009f, 
    0.00196205f, 0.34712368f, -0.31593511f, -0.04386950f, 0.00875835f, 0.05199735f, 0.00386500f, -0.10221722f, 
    0.17442824f, 0.08499681f, -0.03146794f, -0.13781728f, 0.12925145f, 0.18616170f, 0.06692122f, 0.01610947f, 
    -0.00127492f, 0.05087774f, 0.05989204f, -0.03242422f, -0.03485503f, 0.00311322f, -0.01420290f, 0.05067429f, 
    0.01655518f, -0.18951757f, 0.34027132f, 0.14669181f, -0.01953844f, 0.02311621f, 0.11293124f, 0.17053027f, 
    -0.06192145f, 0.04633191f, 0.04420571f, -0.17821962f, -0.16434823f, -0.00491860f, 0.16785964f, 0.03942184f, 
    -0.03706615f, 0.01577045f, 0.00949599f, -0.10707569f, -0.03084570f, 0.11817583f, 0.05329412f, 0.26348835f, 
    0.07743122f, -0.17806025f, 0.12462604f, 0.03290851f, 0.06239413f, -0.03071116f, 0.18032585f, -0.11070914f, 
    -0.01678609f, -0.15161793f, -0.08615117f, -0.18107085f, 0.06673430f, -0.04749049f, -0.15318422f, 0.21839778f, 
    -0.05007434f, -0.06811507f, -0.01451819f, 0.04645246f, -0.06579705f, -0.10976343f, -0.13988343f, -0.13549763f, 
    0.12747632f, -0.08436996f, 0.09846277f, 0.08593076f, 0.08691075f, 0.11619572f, -0.05734392f, -0.00971860f, 
    0.04416237f, 0.20526123f, 0.06435809f, -0.04127863f, 0.00349297f, 0.03597231f, 0.07083809f, -0.00190665f, 
    -0.01013611f, -0.01361479f, -0.06903578f, 0.02719677f, -0.08457886f, -0.00805294f, -0.13926157f, 0.11254739f, 
    -0.01315499f, 0.15482563f, 0.00942054f, 0.06827082f, -0.02891668f, -0.03484943f, -0.10087622f, -0.08724175f, 
    0.08527990f, 0.03172893f, 0.12283195f, 0.05564592f, -0.16255872f, -0.11376818f, 0.23969388f, 0.09618721f, 
    -0.06956536f, -0.01562726f, -0.06579667f, -0.09065126f, 0.04497335f, 0.04858436f, -0.12670201f, 0.10970753f, 
    0.53404611f, -0.18591863f, -0.08827633f, -0.18845499f, -0.16657200f, -0.11641601f, 0.12575665f, -0.08861082f, 
    -0.10520506f, -0.01024249f, -0.12559474f, -0.05429517f, 0.08873151f, -0.03041028f, -0.14311039f, 0.20182000f, 
    -0.00624518f, -0.15403022f, -0.02494837f, 0.10872669f, -0.07952055f, -0.01846184f, -0.13138901f, 0.03704454f, 
    0.22190517f, -0.00855658f, 0.19281179f, -0.01927542f, -0.00290726f, 0.02231916f, -0.13004169f, -0.07711181f, 
    -0.05827216f, -0.04459526f, 0.06910361f, -0.13428313f, -0.22461443f, 0.43206784f, -0.02402804f, -0.00190997f, 
    0.00052763f, 0.09541568f, -0.06470308f, -0.06776372f, 0.04219183f, 0.07349659f, -0.22952266f, 0.12331016f, 
    -0.17055030f, -0.05624287f, 0.15500639f, 0.14918065f, 0.00757652f, -0.00093013f, 0.12156039f, -0.14293085f, 
    0.17269015f, 0.11118082f, -0.20842338f, 0.03557403f, 0.03621731f, -0.05064096f, 0.15590714f, -0.05897499f, 
    -0.08013902f, -0.07636587f, 0.02934245f, 0.09069443f, 0.02876872f, 0.16730954f, 0.10304527f, 0.02276427f, 
    0.06299644f, 0.23805130f, 0.07748231f, 0.11790251f, -0.10059202f, -0.06686590f, 0.11507057f, -0.05406426f, 
    -0.03628629f, -0.06144499f, -0.01883154f, 0.01592264f, -0.00477905f, -0.00547481f, 0.06963622f, 0.29032293f, 
    -0.04492396f, -0.02222204f, 0.03227071f, 0.05478425f, -0.07182427f, 0.06676210f, 0.10664478f, 0.09305490f, 
    0.04054847f, -0.04795460f, -0.03947004f, 0.01561510f, -0.04352415f, -0.00244425f, 0.02186829f, -0.04431564f, 
    0.03375185f, -0.00945096f, -0.00106979f, -0.02441888f, 0.03204260f, 0.00022800f, -0.01473228f, 0.02019958f, 
    0.04467820f, -0.00866667f, -0.01173831f, 0.00472166f, -0.02884999f, -0.01382220f, 0.03575945f, 0.01539993f, 
    -0.05261288f, -0.03448093f, 0.02441870f, -0.00136966f, -0.05365704f, -0.03567017f, -0.01067351f, 0.01329168f, 
    -0.04114905f, -0.01231705f, -0.04963723f, -0.04113267f, 0.00869348f, 0.01962370f, -0.01516220f, 0.01096107f, 
    -0.00283630f, 0.03668477f, -0.02686570f, -0.02786539f, 0.00313968f, -0.04166035f, -0.05543925f, -0.00375574f, 
    0.03099940f, -0.01786719f, 0.01456560f, -0.00002251f, -0.03470797f, 0.00102336f, 0.03076623f, 0.03046416f, 
    -0.01790462f, -0.05122289f, -0.03154366f, -0.02705989f, -0.05529380f, 0.00791124f, 0.01851295f, -0.01767729f, 
    0.03023322f, -0.01575973f, -0.02169317f, 0.04416535f, 0.03819861f, 0.04153366f, -0.02784664f, 0.01239426f, 
    -0.00729703f, -0.02043188f, -0.01322430f, 0.00989551f, 0.00628766f, 0.01833725f, -0.04065646f, 0.03869509f, 
    -0.02283012f, 0.02412554f, 0.02173517f, 0.00850857f, 0.00420387f, -0.04849520f, -0.03412039f, -0.05161696f, 
    -0.01676868f, -0.03852893f, 0.03913248f, -0.02345648f, 0.01837075f, 0.00011305f, 0.00805879f, -0.01987179f, 
    0.04228424f, 0.01401617f, -0.03149065f, -0.05514588f, -0.00028224f, 0.04271162f, 0.04157376f, -0.02968539f, 
    -0.01132254f, -0.01165131f, 0.01858263f, 0.00660868f, -0.01287700f, -0.00379683f, -0.05292155f, -0.05494027f, 
    -0.00147177f, 0.01759674f, -0.04322306f, 0.03734257f, 0.01474734f, 0.00829534f, -0.00504154f, -0.04640603f, 
    -0.03606387f, -0.01176356f, 0.01290871f, -0.05476131f, 0.00282081f, -0.00223300f, -0.01141854f, -0.01777282f, 
    0.00693246f, -0.00594890f, -0.00894917f, 0.01388140f, 0.04130178f, -0.02572142f, -0.03112832f, -0.03846631f, 
    0.03742140f, 0.00521640f, -0.00979889f, 0.00990978f, -0.04020023f, -0.03147428f, 0.01370408f, -0.00691299f, 
    0.03165489f, -0.05432451f, -0.04532323f, -0.04875603f, -0.03864398f, -0.02574712f, -0.02865876f, 0.03224920f, 
    -0.02509069f, -0.03899841f, -0.00352471f, -0.01383226f, 0.03956137f, -0.01322247f, 0.00659414f, -0.03312759f, 
    -0.00404544f, 0.03044294f, 0.02115237f, -0.04862865f, -0.03933668f, -0.05295219f, 0.02026397f, -0.04562143f, 
    0.00689881f, -0.02786810f, -0.01256985f, 0.03699899f, -0.01637859f, 0.01020040f, 0.03006903f, -0.01723534f, 
    -0.04169322f, -0.02217435f, -0.04538778f, -0.03231429f, 0.02498432f, -0.04776100f, 0.02874633f, -0.00264011f, 
    0.03330942f, 0.04311571f, 0.03471258f, -0.05667486f, 0.03456610f, 0.04078582f, 0.00893962f, 0.04340577f, 
    0.03738067f, -0.04286597f, 0.03233460f, 0.02632252f, -0.02859161f, 0.02359072f, 0.01657700f, 0.03002819f, 
    -0.05017510f, -0.00160915f, -0.00156399f, 0.02490811f, -0.01750853f, -0.04738647f, 0.03167905f, -0.01914834f, 
    0.00069521f, 0.03191226f, 0.02360805f, -0.02950958f, 0.01840726f, -0.01675502f, -0.00085629f, 0.00432583f, 
    0.01952613f, -0.02708019f, -0.03704787f, -0.01301983f, -0.02598014f, -0.04724688f, 0.01182487f, -0.01494374f, 
    0.04450563f, 0.01608771f, -0.01350722f, 0.01262037f, 0.03021178f, -0.03423823f, -0.01778014f, 0.01441482f, 
    -0.05091859f, -0.04223581f, -0.04224490f, -0.04754038f, -0.02035927f, -0.04138839f, -0.05419588f, -0.01667537f, 
    -0.03113673f, -0.03481771f, -0.01881116f, 0.02346033f, 0.02833866f, -0.04986225f, 0.00141803f, 0.03170113f, 
    0.02058611f, -0.01343497f, -0.05468513f, -0.02135232f, -0.04691457f, -0.02268721f, -0.05005611f, 0.01502744f, 
    0.03431219f, -0.02075598f, -0.00691904f, 0.02846223f, -0.03229586f, -0.04626758f, 0.02367453f, -0.02744327f, 
    -0.03307306f, 0.03848932f, -0.05087751f, -0.03577100f, -0.02117240f, 0.02509591f, 0.02369403f, -0.05241622f, 
    -0.05270306f, -0.01839550f, -0.03677356f, 0.03156094f, 0.00452663f, -0.02201032f, -0.04081645f, -0.00326535f, 
    0.01168848f, -0.00340653f, -0.00066797f, 0.00672617f, -0.00488353f, -0.02026925f, 0.00582949f, -0.00942432f, 
    -0.03520060f, -0.01918592f, -0.04319409f, -0.04031394f, -0.02132370f, 0.03728164f, -0.02506553f, 0.03442226f, 
    -0.00057576f, 0.01919065f, -0.03762990f, -0.04061884f, -0.00132774f, -0.01764996f, -0.03662309f, -0.04037922f, 
    0.00360839f, 0.01933367f, 0.02257427f, 0.03716270f, 0.03539167f, 0.04297789f, -0.04179439f, 0.00687764f, 
    -0.00682133f, 0.01491704f, 0.02844370f, 0.01108811f, -0.01393655f, -0.02266425f, -0.02728001f, -0.04337804f, 
    0.03029365f, -0.05252607f, 0.02670914f, -0.00094188f, -0.01326676f, 0.00177636f, -0.04703778f, 0.00072227f, 
    0.00933187f, -0.02107958f, -0.05447023f, -0.00261834f, -0.01445186f, -0.02658492f, 0.03120489f, -0.00694347f, 
    0.00931389f, -0.01469850f, -0.05350228f, -0.00799238f, 0.00341183f, 0.02082557f, 0.02872908f, -0.05268194f, 
    -0.00061717f, -0.00976420f, -0.01968712f, 0.04216483f, 0.00821887f, 0.01877651f, -0.05537371f, -0.01547884f, 
    -0.03063150f, 0.03281778f, -0.05449810f, -0.03999354f, 0.04103860f, -0.00153639f, 0.00222285f, -0.01354305f, 
    0.01440163f, -0.03687681f, -0.02785405f, -0.02009237f, -0.04832378f, 0.03164963f, 0.01159745f, 0.04414444f, 
    -0.00079824f, -0.03219430f, 0.01857769f, 0.02051361f, -0.02053011f, 0.02852729f, -0.01666394f, -0.00728251f, 
    0.00078562f, -0.04740607f, -0.01366782f, -0.00675253f, -0.03775693f, -0.01029809f, 0.03449015f, -0.02469432f, 
    0.01031995f, -0.04092182f, -0.00638795f, 0.02483680f, 0.04054984f, -0.01762975f, 0.01878197f, -0.02268651f, 
    0.01445725f, 0.03899051f, 0.00744896f, -0.01798885f, -0.00430298f, 0.01373393f, -0.05170267f, -0.00132920f, 
    -0.00713025f, -0.01522557f, -0.01803591f, -0.00125736f, -0.03699002f, -0.03634093f, 0.02650410f, 0.01233911f, 
    0.00040581f, -0.04747948f, 0.03098447f, 0.03138031f, -0.03498879f, 0.03709628f, 0.01172898f, -0.00288820f, 
    0.01255547f, 0.03631808f, 0.00693028f, -0.01032586f, 0.02265448f, 0.01476646f, 0.04294465f, 0.02098191f, 
    0.02275643f, -0.02877068f, 0.02706907f, -0.02554117f, 0.01765153f, 0.00795194f, 0.01698307f, 0.03964207f, 
    0.03884869f, -0.05888076f, -0.02409633f, 0.02952174f, -0.04819576f, -0.02374602f, 0.02968655f, -0.02795256f, 
    -0.03574385f, 0.02731656f, -0.02971800f, -0.01653612f, 0.02073728f, 0.02194558f, 0.00569436f, 0.02378382f, 
    0.00197346f, 0.03357282f, 0.02273849f, -0.05750602f, -0.01342305f, -0.05261637f, -0.03060860f, -0.03436152f, 
    -0.01661610f, 0.05520726f, -0.01905845f, -0.03119097f, 0.02569107f, -0.03432568f, 0.01805293f, 0.01978436f, 
    0.03892617f, 0.02817627f, 0.01408923f, -0.04347126f, -0.03921821f, -0.02546744f, -0.05884949f, -0.02541817f, 
    -0.05421273f, 0.01320631f, -0.03128337f, 0.01024649f, -0.02307785f, 0.02197212f, 0.02861762f, 0.01454924f, 
    0.01448066f, -0.01240906f, 0.02941180f, 0.01882362f, -0.01044733f, -0.02624922f, -0.00436985f, -0.00788087f, 
    0.00654114f, -0.01325764f, -0.00494825f, -0.02086658f, -0.01051352f, 0.03706359f, -0.03159599f, -0.01691418f, 
    0.02368532f, -0.03059536f, 0.01891807f, 0.00732312f, 0.01947965f, 0.00728710f, 0.00099752f, 0.03543141f, 
    0.03062648f, -0.00335437f, -0.02245381f, -0.03218462f, 0.04450003f, 0.04652101f, 0.00270420f, -0.00883337f, 
    -0.02931672f, -0.05360741f, -0.00587271f, -0.04319559f, -0.04997592f, -0.00512170f, -0.04621655f, -0.05839649f, 
    0.00782428f, 0.03714857f, -0.02362286f, 0.01754156f, 0.02579258f, 0.03236138f, -0.03473575f, 0.02344101f, 
    -0.02317912f, -0.00829188f, 0.00451893f, -0.03966067f, -0.00151260f, 0.01126185f, 0.01186192f, -0.00873892f, 
    0.01937903f, -0.00472338f, -0.03274083f, -0.02546691f, 0.02542213f, 0.01267223f, -0.03006511f, 0.02764352f, 
    0.04392863f, 0.00394058f, -0.02212457f, 0.02977366f, -0.01119939f, -0.00572954f, -0.05293971f, -0.01387003f, 
    -0.02603738f, -0.01294136f, 0.03616702f, 0.01660809f, -0.00906740f, -0.02444502f, 0.04480074f, -0.01427658f, 
    0.00064571f, -0.03642156f, -0.02488979f, 0.03259282f, -0.01490102f, -0.04464111f, 0.03137381f, -0.03503578f, 
    -0.02126705f, 0.03295653f, -0.02259986f, -0.00737383f, -0.00758128f, -0.05188543f, 0.02664698f, -0.01285490f, 
    0.05793956f, 0.00741887f, 0.01810832f, 0.00329303f, -0.05381828f, -0.03649001f, -0.03591212f, -0.05289364f, 
    0.00249558f, -0.00791298f, -0.01740621f, -0.02994663f, 0.03018370f, 0.04013154f, 0.03242773f, -0.00259084f, 
    -0.04878742f, -0.03307540f, -0.04007193f, -0.01191356f, -0.04414731f, 0.01570721f, 0.02022835f, -0.01241513f, 
    0.02868531f, -0.02589000f, 0.02013668f, -0.00583911f, -0.03231255f, 0.01073081f, -0.01372376f, 0.00731289f, 
    -0.00043905f, 0.00968052f, 0.03483723f, -0.00117326f, 0.03276891f, -0.04386412f, -0.02964118f, -0.02054677f, 
    -0.03459453f, 0.01057914f, 0.03026088f, 0.00539039f, -0.02925383f, -0.02014084f, -0.00681279f, -0.03552044f, 
    0.03047218f, 0.02401124f, -0.01070600f, 0.01459662f, -0.04594811f, -0.03766925f, 0.01982525f, -0.03074075f, 
    -0.01598519f, -0.03762937f, 0.01183809f, -0.02092404f, 0.00407101f, 0.00719198f, -0.05776060f, -0.05897408f, 
    0.02798343f, 0.03904393f, 0.02532904f, -0.00831120f, -0.02054432f, -0.04981352f, -0.05591202f, -0.01402563f, 
    -0.02518133f, 0.02601828f, -0.01137431f, -0.02825912f, -0.02292461f, 0.01677861f, -0.06058128f, 0.03557754f, 
    0.00471853f, 0.01612069f, -0.02874474f, -0.04945213f, 0.00628228f, 0.03894968f, -0.04633806f, 0.00445780f, 
    -0.02570763f, -0.00427313f, 0.01619847f, 0.01199965f, -0.04899964f, 0.02693775f, -0.04079834f, 0.00754891f, 
    -0.04998913f, 0.01629241f, 0.01629981f, 0.03511402f, -0.00313706f, -0.04785854f, 0.04419963f, -0.00505063f, 
    -0.04918037f, -0.04307351f, -0.00922422f, -0.03355236f, 0.01141104f, 0.03693411f, -0.01748891f, -0.01659077f, 
    0.03193032f, 0.03959281f, 0.02188742f, -0.01079399f, -0.01383338f, 0.04194204f, -0.01835812f, -0.01517880f, 
    -0.02553382f, -0.02321637f, -0.05597612f, 0.04103960f, -0.00764229f, -0.03093450f, -0.05217139f, -0.04626001f, 
    -0.01445524f, 0.01332169f, 0.00356932f, -0.00070234f, -0.05687536f, 0.02805477f, -0.01823391f, 0.02634390f, 
    0.01968879f, -0.02343358f, 0.03054862f, 0.00187449f, 0.03241719f, -0.02660296f, -0.04466110f, 0.02596612f, 
    -0.01646104f, 0.00409716f, 0.00879742f, 0.02883265f, -0.05475495f, -0.01965471f, -0.03853488f, -0.04164659f, 
    -0.04483868f, -0.03796013f, 0.03771325f, -0.05234234f, -0.02779758f, -0.02435226f, -0.02508075f, -0.04990355f, 
    -0.02580920f, -0.02782331f, -0.02422558f, -0.03971682f, 0.03163626f, -0.02112539f, -0.04837052f, 0.00143587f, 
    -0.03733159f, -0.03790470f, -0.00576267f, -0.05144022f, 0.03444559f, 0.04174418f, 0.01678338f, -0.02504724f, 
    0.01824943f, 0.01884902f, 0.00261172f, -0.05438664f, 0.01144290f, -0.03363791f, -0.03474484f, 0.01179277f, 
    -0.05778005f, -0.04471507f, -0.00223629f, 0.00332413f, 0.03263789f, -0.05247178f, 0.00794878f, -0.03480192f, 
    -0.23789364f, -0.34857067f, -0.34306687f, 0.03993107f, 0.04227861f, -0.01774033f, 0.03752431f, 0.05065509f, 
    0.07528641f, -0.05060666f, 0.08815566f, -0.07931972f, -0.17252475f, -0.05468018f, -0.24887228f, 0.20962720f, 
    -0.08705998f, -0.15066870f, -0.04242700f, 0.04813309f, 0.03100143f, 0.05813071f, 0.07031526f, -0.12899970f, 
    0.31911692f, 0.13125043f, 0.12308570f, 0.25582322f, -0.09861668f, 0.14909655f, 0.25817576f, 0.17946373f, 
    -0.05168142f, 0.14365110f, -0.07241719f, 0.09619768f, 0.18897438f, 0.06662410f, 0.03414685f, 0.02685745f, 
    0.06844941f, 0.15916179f, -0.00045990f, 0.09772222f, -0.09904845f, -0.08132550f, 0.11596503f, -0.06402656f, 
    -0.15311241f, -0.34878457f, -0.00479105f, -0.25095797f, -0.04766120f, -0.07746944f, -0.14464834f, -0.04955190f, 
    -0.10287170f, 0.17983507f, -0.01001958f, -0.03466810f, 0.13689789f, 0.29101637f, 0.08158406f, 0.02427795f, 
    -0.01789389f, -0.08217780f, -0.10606077f, 0.07855804f, -0.02164803f, 0.06865083f, -0.02609564f, -0.06638812f, 
    0.22136681f, 0.26995155f, 0.23248452f, 0.24449864f, -0.10222281f, 0.00363971f, 0.09796426f, 0.13325629f, 
    0.03781571f, -0.02238264f, -0.02941136f, -0.06903809f, -0.09155667f, 0.04935853f, -0.20705453f, -0.22731023f, 
    -0.02094239f, -0.11689708f, -0.05786381f, -0.04224487f, 0.00348133f, -0.12188403f, 0.18294555f, 0.01221806f, 
    -0.24341361f, 0.38395393f, 0.26517180f, 0.06966694f, -0.03581992f, -0.07573812f, 0.05321188f, 0.11707168f, 
    -0.00237127f, 0.16033974f, -0.18242788f, 0.03369182f, -0.25031054f, -0.36429435f, -0.10641924f, -0.03641408f, 
    0.00343618f, 0.03259682f, -0.06297494f, -0.03937986f, -0.13696122f, -0.23553221f, -0.05203857f, 0.10406377f, 
    0.39418262f, 0.15465479f, 0.09011570f, 0.14540087f, 0.16333701f, 0.10265503f, 0.03673613f, 0.09718265f, 
    0.04453027f, -0.02605826f, -0.08368057f, -0.14000331f, -0.30799463f, -0.08244199f, -0.05354897f, -0.19261889f, 
    0.01710238f, 0.05666011f, -0.05739366f, 0.03372054f, 0.06599078f, -0.04428833f, 0.00351218f, 0.02312904f, 
    -0.15066022f, 0.06679731f, 0.06049469f, -0.17191233f, -0.02943300f, 0.01560797f, 0.00605845f, 0.01512791f, 
    0.01960620f, -0.00931058f, -0.08057125f, 0.11323715f, 0.00661100f, -0.10695367f, 0.09589209f, -0.30990428f, 
    -0.03251718f, 0.15992013f, -0.05393861f, 0.05420024f, -0.21437317f, 0.10608280f, 0.09122908f, 0.01362476f, 
    -0.22223018f, 0.08608294f, 0.22445433f, -0.09487386f, -0.05374146f, 0.11174468f, 0.08020859f, -0.01306793f, 
    0.06932136f, 0.06681442f, -0.01776192f, 0.08914953f, 0.15889037f, 0.04395769f, -0.18548617f, -0.19264489f, 
    -0.05785038f, -0.04009432f, -0.06537453f, -0.01048230f, -0.01175042f, 0.07994063f, -0.00154354f, -0.23787518f, 
    0.48046076f, 0.09143944f, 0.12341201f, 0.18851322f, 0.09299758f, 0.09758271f, 0.01148714f, 0.10425664f, 
    -0.02281714f, 0.02743209f, 0.04520403f, 0.18041304f, -0.27446952f, -0.29160926f, -0.12804280f, -0.29972762f, 
    -0.07595041f, -0.10364605f, 0.13250916f, -0.02033566f, -0.09008490f, 0.05340542f, -0.04719717f, -0.06660446f, 
    -0.09366339f, 0.14227168f, 0.02614114f, 0.00320092f, 0.12561196f, 0.15494815f, -0.04555653f, 0.02157330f, 
    0.08703095f, -0.01146460f, 0.18836236f, 0.20781606f, 0.11804933f, 0.44113535f, 0.21079740f, 0.20105669f, 
    -0.13736698f, -0.04009993f, -0.00718300f, 0.15364972f, 0.05696465f, 0.01889744f, 0.01427170f, 0.03258889f, 
    0.00969408f, -0.13439086f, -0.07287831f, -0.13457075f, -0.04478867f, -0.20956689f, 0.03135253f, -0.05160363f, 
    -0.11795247f, 0.12564223f, -0.02269708f, 0.11767081f, -0.00668757f, -0.24140024f, -0.18085825f, 0.02168890f, 
    0.00869307f, -0.02483997f, -0.07749805f, -0.01414827f, -0.01202061f, 0.02686801f, -0.02634506f, 0.02595339f, 
    -0.11921494f, -0.13280773f, -0.05057031f, -0.07736786f, -0.00144632f, -0.01179078f, -0.08243196f, -0.04749722f, 
    -0.29687700f, -0.00685295f, -0.08948007f, 0.08055882f, -0.46191615f, -0.00191293f, -0.10484160f, -0.16468899f, 
    -0.00460762f, 0.00406120f, -0.02587462f, -0.11607675f, -0.03239116f, -0.03297192f, 0.01056189f, -0.10459257f, 
    -0.15539640f, 0.17659093f, -0.03907928f, -0.14444497f, 0.03152294f, 0.04904417f, 0.01833977f, -0.05240015f, 
    0.07325416f, -0.01641012f, 0.02532911f, 0.02297212f, 0.07608369f, 0.22679116f, 0.16923319f, 0.08759172f, 
    -0.15145363f, 0.05484667f, -0.01441331f, 0.17293090f, 0.01386051f, -0.08201090f, -0.09599271f, -0.07449768f, 
    -0.10830835f, 0.00496389f, -0.03647122f, 0.04938654f, -0.21267439f, -0.07782865f, 0.14499685f, -0.07571170f, 
    0.00027520f, 0.02731338f, -0.02989438f, 0.02953826f, -0.09224954f, -0.08490888f, 0.20115755f, -0.03341516f, 
    -0.00189422f, -0.05650264f, -0.03270722f, 0.05457261f, -0.03348774f, -0.12822336f, -0.03162287f, -0.04893446f, 
    0.20367496f, -0.09512831f, 0.03033689f, 0.02013280f, 0.04570500f, 0.08598846f, -0.08008258f, 0.11706080f, 
    0.04732163f, 0.03852607f, 0.06847395f, -0.03215527f, -0.35626692f, -0.07344180f, -0.06506580f, -0.03934029f, 
    -0.03794549f, -0.05347982f, -0.02992448f, -0.04911381f, -0.14096597f, -0.03058662f, -0.01489621f, 0.15649319f, 
    0.26760831f, 0.24200664f, 0.00809081f, 0.00191370f, 0.11176971f, 0.09945238f, 0.09723724f, 0.07532118f, 
    -0.00165320f, 0.00200057f, -0.09659701f, 0.10476831f, 0.20441382f, 0.10371116f, 0.17337835f, 0.24932891f, 
    0.03844258f, 0.06650040f, -0.10066587f, 0.00728126f, 0.07063642f, 0.08898340f, 0.04095874f, 0.02833386f, 
    -0.01822953f, -0.11990304f, -0.15919892f, -0.04948333f, 0.21887323f, 0.11295080f, -0.08106302f, 0.05806018f, 
    -0.07084943f, -0.02445735f, -0.15333165f, -0.11727192f, 0.03153249f, 0.00831272f, 0.15031801f, 0.00479002f, 
    0.13803349f, 0.15167186f, 0.09262311f, 0.07139315f, -0.05080099f, -0.11661389f, 0.05682586f, -0.04483595f, 
    0.01880301f, 0.20025414f, -0.10577360f, -0.39080316f, 0.12075118f, -0.05791626f, -0.00840175f, -0.07128188f, 
    0.07171862f, 0.01325495f, -0.09055983f, 0.10811286f, -0.72726178f, 0.03411268f, 0.11298984f, 0.14331341f, 
    -0.13337676f, -0.18668517f, -0.06562822f, 0.09409538f, 0.10167743f, 0.02347514f, -0.00028855f, 0.04297013f, 
    -0.03770268f, -0.02295653f, -0.21767013f, -0.07479531f, -0.00731637f, -0.02027478f, -0.12489550f, -0.06571721f, 
    0.11532240f, -0.13419473f, 0.10677087f, 0.03292939f, 0.02026780f, 0.07658675f, 0.00794899f, 0.07181524f, 
    0.08939379f, 0.12815432f, 0.13509060f, 0.03008605f, -0.02810444f, -0.07825644f, 0.07288308f, 0.11172793f, 
    -0.13077269f, -0.03033837f, 0.19621211f, -0.07224710f, -0.02883108f, 0.01895452f, 0.03585383f, -0.05053202f, 
    -0.00038157f, -0.10557576f, 0.01389023f, 0.07926755f, 0.07747883f, -0.13003430f, -0.08078042f, 0.26627788f, 
    -0.10555711f, -0.11539451f, -0.02709525f, 0.18611754f, 0.06494059f, 0.02128041f, -0.17582016f, 0.15709491f, 
    -0.05514212f, -0.25958079f, -0.14008333f, 0.21705301f, -0.04679745f, 0.00348188f, 0.00587359f, 0.11792012f, 
    0.12961042f, 0.04935836f, 0.02906355f, 0.05733772f, -0.03333430f, -0.04412653f, -0.03554158f, 0.14540419f, 
    0.12426066f, -0.09673774f, -0.02404509f, 0.03366784f, 0.11778945f, 0.03832101f, -0.13265687f, 0.05562271f, 
    -0.29161075f, 0.03008406f, 0.35300237f, 0.15392324f, -0.07443249f, -0.03440000f, 0.15017170f, 0.08637953f, 
    0.09188826f, 0.04099564f, 0.02809221f, 0.19149327f, -0.01792930f, -0.13625538f, -0.17647786f, 0.25727859f, 
    0.02002102f, -0.10667527f, -0.07647919f, 0.00730322f, 0.02038482f, 0.04576290f, 0.10546198f, 0.15348050f, 
    0.05820655f, -0.14494520f, -0.03615009f, 0.17389916f, 0.12164725f, 0.08729908f, -0.09177182f, -0.03634897f, 
    0.23044682f, 0.30664557f, 0.16473171f, 0.12771684f, -0.12481525f, -0.08847364f, -0.37983108f, -0.01669932f, 
    0.08842047f, -0.21429811f, -0.07948514f, -0.13038836f, 0.23557147f, -0.11434478f, -0.02629149f, 0.10075555f, 
    0.01039687f, 0.10021116f, -0.09498638f, 0.22678870f, -0.02696499f, -0.04044079f, -0.03056900f, -0.20453304f, 
    -0.06694636f, -0.09501408f, 0.08403480f, 0.09073218f, -0.12023593f, 0.31688070f, -0.04572834f, 0.11873208f, 
    -0.00317973f, -0.01601967f, -0.04909806f, 0.03881397f, 0.15270352f, 0.12549892f, 0.04783141f, 0.08130261f, 
    -0.27236146f, 0.09368210f, 0.25458661f, -0.09500233f, 0.04275434f, 0.05266651f, 0.01632799f, 0.04747753f, 
    0.04042010f, -0.04069525f, -0.03694366f, -0.02494216f, 0.09626374f, 0.03705706f, -0.08406541f, 0.00458645f, 
    -0.06290834f, -0.15367867f, -0.04831976f, -0.09606900f, 0.24324431f, 0.03431582f, 0.06072378f, -0.10834143f, 
    -0.02897239f, -0.17709731f, -0.14291185f, -0.06213139f, -0.02180950f, 0.09638279f, 0.07313123f, -0.07096514f, 
    0.01835091f, 0.07533186f, 0.06726680f, -0.12398490f, -0.15266816f, -0.20597886f, 0.16769534f, 0.22018667f, 
    0.08621097f, 0.01756955f, 0.15064499f, 0.04738910f, 0.07369781f, -0.09148730f, -0.02627966f, -0.00598167f, 
    0.05779608f, 0.01951054f, -0.08340672f, 0.00272464f, 0.11718579f, 0.23206328f, 0.07416136f, 0.03502878f, 
    0.25256613f, 0.08487489f, -0.05464419f, -0.02284045f, 0.19120364f, -0.07546918f, 0.00241216f, 0.12590347f, 
    -0.01353590f, -0.02793645f, -0.03215996f, -0.08892089f, 0.03749745f, -0.10429506f, -0.00050549f, -0.07011069f, 
    0.01560704f, 0.00943227f, -0.35134035f, -0.10772125f, 0.02984230f, -0.07476564f, -0.06755464f, -0.09550935f, 
    0.04639585f, -0.00901460f, 0.08230422f, -0.05091946f, 0.51566845f, -0.17002453f, -0.11169480f, 0.06846094f, 
    0.03191829f, -0.01752269f, 0.07091928f, 0.00735397f, 0.19262481f, 0.05635111f, 0.03033198f, -0.04107071f, 
    0.02302582f, -0.26833373f, -0.17680359f, 0.22249155f, 0.02217874f, -0.15543558f, -0.16132741f, 0.13109541f, 
    -0.10703310f, 0.08880737f, 0.06974276f, -0.00486722f, -0.49601552f, 0.09278881f, 0.01899470f, 0.30037978f, 
    0.10535345f, -0.01281520f, 0.10438251f, 0.02182166f, -0.07822096f, 0.01684178f, -0.07312736f, 0.12759130f, 
    0.17426443f, -0.13180453f, -0.10610577f, -0.06458128f, 0.22255063f, 0.19234867f, -0.04817647f, 0.21658924f, 
    0.12821727f, 0.03753179f, -0.05562970f, -0.12492929f, 0.30648574f, 0.18575686f, -0.07139014f, 0.19484296f, 
    0.00392546f, -0.09421453f, -0.06323273f, 0.07532062f, 0.03410587f, 0.05324286f, 0.13075244f, -0.02630471f, 
    0.27021244f, 0.43141896f, 0.12979181f, 0.02296571f, 0.07007726f, 0.05318481f, 0.08738053f, 0.06139823f, 
    0.00268377f, -0.00092860f, -0.00939404f, -0.01231518f, 0.38683525f, -0.15469424f, -0.03843905f, -0.07589588f, 
    -0.07754378f, -0.01587485f, -0.02667226f, -0.12710030f, 0.06814129f, -0.13803869f, 0.05264978f, 0.05218119f, 
    -0.35238293f, 0.30101267f, 0.17109999f, 0.22139849f, 0.02388163f, -0.02470517f, -0.05655678f, 0.08545033f, 
    0.10570357f, 0.08799480f, 0.07325227f, -0.02406108f, -0.06248258f, 0.23848279f, 0.08288746f, 0.08849488f, 
    -0.00629794f, -0.05194490f, 0.10185224f, 0.18147629f, 0.09440241f, -0.03111362f, 0.02068343f, -0.00621960f, 
    0.11758937f, 0.18665245f, 0.39153007f, -0.05625525f, 0.08884460f, 0.18973206f, -0.01991416f, -0.13614807f, 
    -0.02053532f, 0.07456251f, -0.06223107f, 0.09260557f, 0.33626914f, 0.02030173f, 0.39599669f, 0.08992397f, 
    0.05301539f, 0.04640497f, 0.03359040f, -0.07074224f, -0.02965482f, 0.02348970f, -0.18860695f, -0.10316341f, 
    -0.15060766f, -0.00457955f, 0.33522299f, 0.20609201f, -0.05502875f, 0.06814073f, 0.10004235f, -0.05542113f, 
    -0.02211468f, -0.01227928f, -0.09985222f, 0.08334900f, -0.12735701f, 0.03782433f, -0.16860858f, -0.11983996f, 
    -0.02884792f, -0.03135179f, 0.01726826f, -0.12817585f, -0.09697746f, -0.09557483f, 0.02428179f, -0.11358159f, 
    -0.24353988f, -0.00096494f, -0.13924415f, -0.04357481f, -0.09844346f, -0.01936847f, -0.07153174f, -0.08394793f, 
    -0.09058022f, -0.06055505f, 0.00061226f, -0.16956827f, 0.17028402f, -0.05662093f, 0.23924127f, 0.33299437f, 
    -0.10554431f, -0.06990793f, 0.10007843f, -0.02111270f, 0.04010095f, 0.04003067f, 0.00986976f, -0.00447580f, 
    0.21759102f, 0.14433791f, -0.00329588f, 0.23487197f, -0.15051593f, 0.06895486f, 0.02168729f, -0.04414044f, 
    0.08038846f, 0.10636792f, 0.03533429f, 0.16432051f, -0.30825156f, 0.30308074f, -0.26464841f, 0.00008953f, 
    0.03555435f, -0.00942800f, -0.04304446f, 0.02348716f, -0.02727057f, 0.06784806f, 0.06230592f, 0.19934295f, 
    0.28490478f, -0.12391330f, 0.07931204f, 0.53033233f, 0.01153659f, -0.03013504f, 0.21001621f, -0.01018658f, 
    0.02924182f, 0.03731346f, 0.13666268f, 0.02226737f, -0.10364869f, -0.04206343f, 0.08519503f, -0.29638925f, 
    -0.03920347f, 0.01906783f, -0.08634625f, -0.08413640f, -0.02273856f, 0.00302747f, -0.09065089f, -0.04381454f, 
    -0.18299957f, 0.19045025f, -0.10521672f, 0.23900878f, 0.00597699f, 0.14019814f, 0.09599105f, -0.21656772f, 
    -0.05380100f, -0.08333057f, 0.00183328f, 0.03458498f, 0.15096220f, -0.02699950f, 0.23372625f, -0.28461173f, 
    -0.01963163f, 0.22456916f, -0.00273769f, 0.02957455f, -0.16078034f, 0.05126457f, -0.03057965f, -0.04050384f, 
    -0.05947209f, 0.07897237f, 0.18941221f, 0.00076861f, 0.00970878f, 0.01539970f, -0.18673168f, 0.10852145f, 
    0.06407864f, 0.10233842f, 0.14252375f, 0.07576080f, -0.34902158f, 0.17791645f, -0.23999488f, 0.20682576f, 
    -0.10245479f, 0.07685062f, -0.04224860f, -0.08596081f, 0.04821667f, -0.02824511f, 0.28970397f, 0.20465036f, 
    0.28037801f, -0.48061472f, 0.54791182f, 0.08160502f, 0.14628093f, 0.08819821f, -0.16745377f, 0.04690458f, 
    0.04019395f, -0.11454424f, -0.05098313f, 0.29561093f, -0.23778664f, -0.05692331f, -0.40004551f, 0.48190287f, 
    0.08772624f, 0.00969467f, 0.08254715f, -0.02847845f, 0.06326739f, 0.14203882f, 0.08925740f, 0.07003384f, 
    0.14661171f, 0.16398185f, -0.23872216f, 0.21858767f, -0.06612260f, 0.01431171f, 0.17273562f, -0.06444670f, 
    -0.01269289f, 0.10924046f, 0.00864859f, 0.01352463f, 0.12524067f, -0.04775113f, -0.21502687f, 0.19977102f, 
    -0.03654366f, 0.10022841f, -0.02172593f, 0.06645750f, -0.00308935f, -0.03894380f, 0.18284160f, 0.11521968f, 
    -0.12295464f, -0.04981341f, -0.19170748f, -0.12417239f, -0.06035929f, 0.04352872f, -0.09470318f, 0.30322626f, 
    0.14158143f, 0.12982875f, 0.10198408f, 0.05623468f, 0.09443597f, 0.18678975f, 0.08736573f, 0.10398962f, 
    0.02866087f, -0.09002665f, -0.04275297f, -0.07244707f, -0.16817090f, -0.00702977f, 0.03639555f, 0.00811583f, 
    -0.16811688f, 0.01868160f, -0.03965960f, -0.03076006f, 0.11280614f, 0.05125074f, -0.05866626f, 0.08132709f, 
    0.17881891f, -0.04828694f, 0.09731822f, 0.06956678f, -0.21057655f, 0.07406660f, -0.10605145f, 0.26273674f, 
    -0.07849319f, 0.02776978f, -0.07741216f, -0.11171850f, -0.03176932f, 0.04398400f, 0.00211731f, 0.01654664f, 
    0.09095199f, -0.06749257f, 0.01453088f, -0.11957870f, -0.05082089f, -0.00314177f, -0.05607153f, 0.03346371f, 
    -0.25842300f, -0.07582858f, -0.07140300f, -0.15470281f, 0.26607785f, 0.29635048f, -0.09577362f, 0.19208091f, 
    0.00938149f, -0.09473770f, 0.03560094f, 0.12191366f, -0.21344344f, 0.02247894f, 0.12579571f, -0.13163482f, 
    0.09789741f, -0.33397293f, 0.04756173f, 0.21105345f, -0.03659606f, -0.17723180f, 0.19262606f, 0.03667479f, 
    -0.02844624f, -0.03008171f, -0.11450917f, -0.08247038f, 0.42685437f, -0.14004053f, 0.32193843f, -0.19682443f, 
    0.05881732f, 0.12947774f, 0.03170046f, 0.01956199f, -0.00275427f, -0.02615454f, 0.07418934f, 0.04929557f, 
    -0.08514469f, 0.05778439f, 0.13629895f, 0.01947013f, 0.16536944f, -0.05620765f, 0.04147168f, 0.01568124f, 
    0.02434532f, 0.14823227f, 0.15416279f, 0.13176559f, 0.07055675f, -0.21601689f, 0.16841669f, 0.18243249f, 
    0.11003149f, 0.08492916f, 0.03165517f, -0.00840328f, -0.16942441f, 0.08077276f, 0.17327312f, -0.09958927f, 
    -0.13050531f, -0.29387698f, -0.02426340f, -0.01852852f, 0.00806610f, -0.07718156f, -0.09508409f, 0.17507540f, 
    -0.05807521f, -0.09293593f, -0.00279585f, -0.10951588f, 0.09308197f, 0.03793954f, 0.02582645f, -0.15698335f, 
    -0.05146553f, 0.04364178f, -0.18976764f, 0.10833672f, 0.08164277f, -0.16997139f, -0.09070725f, -0.20311330f, 
    -0.07318850f, -0.39294231f, -0.15237541f, -0.11792927f, 0.21620281f, -0.00206137f, 0.06371141f, 0.06661693f, 
    -0.03028170f, 0.20353518f, 0.06066692f, -0.04280952f, 0.02260744f, 0.08026521f, -0.00676222f, -0.00282774f, 
    0.02685276f, -0.22404881f, -0.09780412f, 0.17285745f, -0.11948930f, 0.02320448f, -0.17652941f, -0.14995062f, 
    0.06851835f, -0.01814608f, 0.09107236f, -0.07299825f, 0.15107664f, -0.03210336f, -0.03217826f, 0.03441390f, 
    0.01002801f, -0.00883012f, 0.06201416f, -0.02868610f, -0.02985979f, 0.04488265f, -0.01582509f, 0.25801608f, 
    0.00034369f, -0.14834319f, 0.00947753f, 0.03080371f, -0.08719423f, 0.00922123f, 0.03333159f, -0.07233530f, 
    0.15876193f, -0.10698279f, 0.16488859f, 0.20992421f, -0.01947232f, 0.18449637f, 0.02894869f, 0.00308380f, 
    -0.10737961f, 0.07735357f, 0.01540415f, 0.08834197f, -0.11616755f, -0.02191721f, -0.08286769f, -0.13447405f, 
    0.01231391f, 0.04229938f, -0.11234932f, -0.04986889f, -0.08711539f, -0.00292062f, 0.10653868f, -0.00813943f, 
    0.20588313f, -0.07007395f, -0.10448801f, 0.18562905f, -0.10785528f, -0.14104998f, -0.03146240f, 0.11018249f, 
    -0.00729161f, 0.00873819f, 0.01720795f, 0.02395156f, 0.20176920f, 0.19832312f, 0.15496866f, -0.04610287f, 
    -0.02647030f, -0.11951587f, 0.00698126f, 0.20216121f, 0.04604472f, 0.02714610f, -0.03563749f, 0.05924620f, 
    0.21078287f, 0.21392310f, 0.13017362f, 0.10771619f, 0.00686731f, 0.16364072f, 0.01416343f, 0.00235870f, 
    -0.01468604f, -0.09648506f, -0.01405935f, -0.01405540f, -0.19561762f, 0.23903105f, -0.09984334f, 0.39283359f, 
    0.00443360f, 0.03622417f, -0.09583008f, -0.03123394f, 0.07206976f, -0.05273684f, -0.03321896f, -0.00894714f, 
    -0.54049391f, 0.30110824f, 0.15111098f, 0.30283484f, 0.10097171f, 0.01750826f, 0.10557805f, -0.25234264f, 
    -0.01186730f, 0.01028346f, -0.06859433f, -0.03997890f, -0.10486762f, 0.02883682f, 0.09816553f, -0.01189263f, 
    -0.01915320f, 0.07549112f, -0.02393021f, -0.07640859f, 0.04977240f, 0.03163013f, -0.04321780f, 0.04258757f, 
    0.25391492f, 0.16219746f, 0.01192714f, 0.20153710f, 0.05374473f, 0.02053328f, 0.12046138f, 0.02707050f, 
    0.07709248f, 0.02611416f, -0.07641309f, -0.04162455f, -0.33587912f, -0.06375650f, 0.24803488f, -0.00350591f, 
    0.04427101f, 0.12634091f, -0.00511578f, 0.01607087f, -0.12050072f, 0.05310577f, -0.08007559f, 0.02415793f, 
    -0.03629094f, 0.01513769f, 0.09249616f, 0.03493147f, 0.06621555f, 0.02506276f, 0.07432444f, 0.11619642f, 
    0.04933803f, 0.05810706f, -0.03733043f, 0.19345817f, -0.02698088f, 0.20224836f, -0.15269276f, -0.07949439f, 
    -0.05135529f, 0.06538071f, -0.04011634f, -0.00093135f, -0.02531922f, -0.16637392f, 0.10249294f, 0.05002123f, 
    -0.18060817f, -0.22045305f, 0.51612282f, -0.17348079f, -0.11509468f, 0.17439342f, 0.09221271f, 0.02197778f, 
    0.07101852f, 0.05393884f, -0.09067765f, -0.13132313f, 0.02280177f, 0.26234078f, -0.37012616f, 0.20845377f, 
    -0.16191734f, -0.18596897f, -0.01562482f, 0.01049472f, -0.07917470f, 0.07521649f, -0.12801805f, -0.12365683f, 
    0.34907043f, 0.00349329f, -0.13770746f, 0.03759589f, 0.01473673f, 0.14118290f, -0.05038736f, 0.14342912f, 
    -0.01491727f, 0.00275211f, -0.16189785f, -0.11777102f, 0.06540073f, -0.10197990f, -0.07037280f, 0.12988713f, 
    -0.07876353f, -0.03313768f, 0.05968846f, -0.03284131f, -0.06327372f, 0.20128119f, -0.06053968f, -0.00903129f, 
    0.07124330f, -0.04269323f, -0.08725800f, -0.01765253f, -0.09370162f, 0.04162301f, -0.04998978f, 0.00941174f, 
    -0.12393484f, -0.10926238f, 0.02421320f, -0.11351968f, 0.02416588f, 0.48611978f, 0.26354656f, 0.05904351f, 
    -0.04139377f, -0.09821820f, -0.11878131f, -0.03779009f, 0.07170784f, -0.06737864f, 0.04973125f, 0.00755783f, 
    0.12023015f, 0.01057511f, -0.03023226f, 0.09812817f, -0.11869644f, -0.12170875f, 0.05019770f, 0.11910119f, 
    0.06035906f, 0.22173546f, -0.08451241f, -0.05577208f, 0.03093792f, 0.18568948f, -0.24897718f, 0.31316164f, 
    0.01914323f, 0.01938389f, -0.01300766f, -0.04166903f, -0.03696871f, 0.02137662f, -0.05715237f, -0.10139330f, 
    -0.02900562f, -0.05388163f, 0.10427052f, -0.03257374f, 0.06986425f, -0.03587034f, -0.14001870f, -0.10479409f, 
    -0.16176322f, -0.11424493f, -0.07822923f, 0.25336224f, 0.23178141f, 0.23928352f, 0.14625396f, 0.19590625f, 
    -0.00344665f, -0.11825074f, 0.01367652f, -0.02892025f, -0.06188044f, 0.11185201f, -0.02766486f, 0.01303852f, 
    -0.08580982f, -0.06426879f, -0.01501531f, -0.13123122f, -0.03534385f, -0.05533253f, 0.06121938f, 0.06203106f, 
    0.07813507f, 0.03495764f, -0.03981786f, 0.03323664f, -0.02955008f, 0.08380539f, 0.40058357f, -0.05620571f, 
    0.02676314f, 0.05175782f, -0.01972531f, -0.03838358f, 0.00738794f, 0.07096507f, -0.03422040f, -0.13188234f, 
    0.08560424f, -0.00588534f, 0.25311297f, 0.04720685f, -0.14952010f, -0.01836683f, 0.03930407f, -0.05358863f, 
    -0.04929345f, 0.05136310f, 0.07911114f, 0.05424914f, -0.13613753f, -0.12563761f, 0.31998256f, -0.02534075f, 
    0.08891936f, -0.03420896f, -0.05551443f, -0.00583795f, -0.06564849f, 0.02297974f, 0.07141254f, 0.07272734f, 
    0.02743188f, -0.25800616f, 0.13153166f, -0.14261627f, -0.01714479f, -0.06725094f, -0.14179681f, -0.03788029f, 
    0.09053491f, 0.10647479f, 0.05432825f, -0.00535959f, 0.15681170f, 0.01935945f, 0.21664532f, -0.02306165f, 
    -0.04481060f, -0.02306862f, -0.01176874f, 0.05872227f, -0.13942777f, -0.08766451f, 0.00339050f, 0.16598959f, 
    0.18008654f, 0.09793792f, -0.10988401f, -0.10804154f, 0.11434095f, -0.07911571f, 0.04495422f, -0.06410886f, 
    -0.01586208f, 0.01332976f, -0.12738539f, -0.07881755f, 0.11245721f, 0.15417805f, 0.13374543f, 0.05930293f, 
    0.00622873f, -0.04973046f, -0.06921447f, 0.01251082f, -0.05642721f, 0.09087935f, 0.09452078f, -0.09312998f, 
    0.03091502f, 0.01045261f, -0.00312646f, -0.02201185f, 0.04137861f, -0.01658043f, -0.04839716f, -0.02491453f, 
    0.02517918f, -0.01522528f, 0.03049258f, -0.00974941f, 0.02018302f, -0.03192064f, -0.03765284f, 0.00581819f, 
    -0.02252627f, -0.03002545f, -0.02655258f, 0.03378147f, -0.00470267f, -0.01014407f, -0.02039895f, -0.05170443f, 
    0.03814844f, -0.05534121f, -0.02829136f, -0.01321964f, -0.02069254f, -0.05320555f, -0.00692888f, -0.05128105f, 
    -0.01852144f, -0.05607770f, 0.01768083f, 0.01812514f, -0.03677149f, 0.01865487f, 0.03951591f, -0.04009173f, 
    0.04380440f, -0.04656630f, 0.02567011f, -0.03199352f, -0.02119423f, -0.05184196f, -0.03979038f, -0.04406321f, 
    0.01204348f, -0.04993347f, 0.03537120f, -0.02206420f, 0.00448576f, -0.02428827f, -0.03828128f, -0.05723172f, 
    -0.04541110f, -0.04534918f, -0.00630753f, 0.03798330f, -0.00149972f, -0.04014131f, -0.04534666f, 0.02664771f, 
    -0.02921427f, 0.03526995f, 0.02731397f, -0.05197700f, 0.00966126f, 0.01339658f, 0.01875188f, -0.05351372f, 
    0.03906369f, -0.05305659f, -0.02973184f, -0.02727741f, -0.03369729f, 0.01750359f, 0.00700877f, -0.04096469f, 
    0.03130892f, -0.02504208f, 0.00776161f, 0.01671966f, 0.04527836f, -0.03684044f, 0.02076460f, 0.02899277f, 
    -0.00075069f, -0.03141299f, -0.00251910f, -0.02853304f, -0.00963112f, -0.03316091f, -0.01347226f, 0.03353621f, 
    -0.05747283f, 0.01469773f, -0.03078006f, 0.00664712f, 0.02269892f, -0.03363850f, 0.03175736f, 0.00170188f, 
    -0.04217019f, 0.04296527f, -0.04776847f, -0.00019744f, 0.00710224f, -0.00144014f, -0.00551407f, 0.01889199f, 
    -0.01764496f, -0.04768490f, -0.01775567f, 0.04293903f, -0.00435642f, 0.00164339f, 0.03864844f, 0.02790237f, 
    -0.03103476f, -0.02747451f, 0.00163650f, 0.00358256f, 0.03130346f, 0.04730053f, -0.04637064f, -0.04031118f, 
    0.00097046f, 0.01694168f, 0.03837744f, -0.02064819f, 0.01181081f, 0.02935828f, -0.03176918f, 0.04428963f, 
    -0.03523540f, -0.02625632f, -0.03252253f, -0.00475566f, 0.03776067f, -0.03988766f, 0.00701478f, 0.02659923f, 
    -0.01685416f, 0.00546672f, -0.01348561f, 0.01398877f, -0.03455659f, 0.01796508f, -0.01551626f, -0.04167668f, 
    -0.00136575f, -0.01056240f, 0.03565130f, 0.00501044f, -0.02685123f, 0.00600596f, -0.03492457f, -0.02922212f, 
    -0.03211083f, 0.01233399f, -0.03261523f, -0.04874730f, 0.03491721f, -0.00587490f, -0.05028262f, 0.03353266f, 
    -0.03004666f, 0.00494926f, -0.02722560f, 0.02361881f, -0.01263869f, 0.01909866f, -0.03912010f, -0.05096135f, 
    0.02775965f, -0.03218865f, -0.03700502f, -0.01292356f, 0.02017507f, -0.03715887f, 0.04239071f, 0.01578205f, 
    0.02477097f, -0.00735319f, -0.03585694f, -0.02071457f, -0.04488431f, 0.00310555f, -0.03998207f, 0.01058139f, 
    0.01425937f, 0.03591445f, -0.04843786f, 0.01035696f, -0.03519417f, 0.02749143f, 0.02474174f, 0.04176218f, 
    0.00866433f, 0.02764347f, 0.01819869f, 0.00686981f, -0.00830257f, -0.01632732f, -0.02853946f, 0.03602649f, 
    -0.04934712f, 0.03252687f, -0.03654546f, 0.03180485f, -0.02739480f, 0.01068709f, 0.02006499f, -0.02660235f, 
    -0.02425643f, 0.04185798f, -0.00449524f, -0.04274109f, 0.01976422f, -0.03836448f, 0.04213109f, 0.04383440f, 
    -0.03821183f, -0.03741815f, -0.03057298f, 0.02873693f, -0.04578783f, -0.00075131f, 0.00583161f, 0.00526390f, 
    -0.02969134f, 0.00518632f, -0.02491556f, 0.03868093f, 0.01862252f, 0.00312561f, 0.03431880f, -0.03024366f, 
    -0.00232570f, 0.03729252f, -0.02758537f, -0.03663719f, -0.04702301f, 0.03078852f, -0.03537802f, -0.04668309f, 
    -0.01043968f, -0.04443469f, -0.01924556f, -0.04482573f, 0.04596802f, -0.04604171f, 0.02062682f, 0.02872095f, 
    0.03616086f, -0.04453309f, 0.01222040f, -0.02877526f, 0.01800705f, -0.00256917f, 0.04175075f, 0.03326560f, 
    0.02814599f, -0.05076260f, 0.04723402f, 0.00611378f, -0.00501788f, -0.03151426f, 0.03045714f, 0.00559683f, 
    0.01653134f, -0.00675090f, -0.02283179f, 0.02061898f, -0.02622833f, 0.04165641f, -0.02393165f, 0.03588823f, 
    -0.05004217f, 0.02597723f, -0.02197297f, -0.02447215f, -0.00286460f, -0.00595332f, -0.01637923f, -0.05826770f, 
    0.01881471f, 0.03788487f, -0.03842339f, 0.03204780f, 0.05139177f, -0.02317923f, -0.00365512f, -0.03980863f, 
    -0.03605253f, 0.01592154f, 0.03089623f, -0.03426035f, -0.03321014f, -0.05151978f, -0.05192663f, -0.00132629f, 
    -0.03689870f, -0.05256984f, -0.03600641f, 0.02821993f, -0.04175114f, -0.02567241f, 0.03644098f, -0.04251269f, 
    -0.05485376f, -0.00115607f, 0.02693892f, 0.00414791f, -0.00072742f, 0.02805210f, -0.00967676f, 0.04199377f, 
    -0.03352268f, -0.05789818f, -0.04351133f, -0.03010604f, -0.01329560f, -0.02758836f, -0.05265779f, 0.02462744f, 
    0.01833975f, -0.01281285f, -0.04481675f, -0.03926397f, 0.03366346f, -0.01640573f, 0.03111984f, -0.04387765f, 
    -0.04503802f, 0.01117186f, 0.03787681f, 0.00146517f, -0.05230774f, -0.03275308f, 0.03175808f, 0.01419874f, 
    0.04106865f, -0.01989048f, -0.02103720f, 0.00049019f, 0.01074249f, 0.00997395f, 0.00307612f, -0.04184183f, 
    -0.04419706f, 0.02660382f, -0.05387878f, 0.02798660f, -0.03475764f, -0.04378127f, 0.01151227f, -0.02561079f, 
    -0.00920610f, -0.04515859f, 0.03475948f, -0.00657517f, 0.02707971f, -0.00267340f, -0.00774594f, -0.04863045f, 
    0.00270443f, 0.03882267f, 0.01325647f, 0.02539062f, -0.05252593f, 0.04625120f, -0.00488829f, 0.01135370f, 
    0.02174852f, -0.00900121f, -0.04771343f, -0.04204855f, 0.04624952f, -0.03840263f, -0.04029970f, -0.01977909f, 
    -0.14596188f, -0.16355693f, -0.31449252f, -0.13481209f, 0.13136049f, 0.11122126f, -0.13062325f, 0.04097823f, 
    0.10798639f, -0.00096434f, -0.06835391f, 0.01292421f, -0.19019406f, -0.07501352f, -0.20040695f, 0.35579461f, 
    -0.03586542f, -0.04715132f, -0.01328948f, -0.07610841f, 0.08755933f, 0.01724504f, 0.07146923f, -0.01662374f, 
    0.36878550f, 0.42255700f, -0.14871790f, 0.13454086f, -0.18172307f, 0.15604842f, -0.03470360f, 0.02590024f, 
    0.00435053f, 0.00786706f, 0.00898177f, -0.15132354f, -0.18147947f, 0.05073511f, 0.14987853f, -0.04482143f, 
    0.03642730f, 0.06740168f, 0.16733074f, -0.00813615f, 0.23648886f, -0.16463126f, 0.12254822f, 0.04148040f, 
    -0.10573418f, -0.05681313f, -0.04757818f, -0.04079968f, 0.04423652f, 0.03289542f, 0.05439202f, 0.09283060f, 
    0.08020408f, 0.12570532f, 0.16017860f, -0.05168714f, 0.08285366f, 0.27657619f, -0.01861503f, -0.09239396f, 
    -0.00278548f, -0.10235275f, -0.09173618f, 0.12629025f, 0.05409358f, 0.03468251f, 0.10727695f, 0.04123845f, 
    0.30950859f, 0.11971964f, 0.15435298f, -0.06003079f, 0.00239707f, 0.14816155f, -0.11937822f, -0.16510311f, 
    0.01265890f, -0.08000888f, 0.05253569f, -0.04926601f, -0.25086582f, 0.04818156f, -0.07959699f, 0.20323880f, 
    0.06711442f, -0.08971164f, 0.01724838f, 0.02418972f, -0.06868179f, -0.13413167f, -0.08169522f, 0.06264494f, 
    0.10408477f, 0.12390269f, 0.21328710f, 0.09048036f, -0.01482195f, -0.06429900f, 0.02947609f, -0.01269196f, 
    -0.04314550f, -0.15961137f, -0.08534634f, 0.13680157f, -0.19313879f, -0.22082791f, 0.17566119f, 0.12027829f, 
    0.05331390f, 0.02428029f, 0.06570501f, 0.04594747f, 0.12837827f, -0.10614881f, -0.00196246f, 0.14871018f, 
    0.19149841f, 0.06693281f, -0.05330581f, -0.02692909f, -0.11906341f, 0.00906876f, -0.05642835f, -0.14470610f, 
    -0.10181916f, -0.03816048f, 0.03347130f, 0.04745169f, -0.44094005f, -0.17328759f, 0.35886914f, 0.05490528f, 
    0.06056157f, -0.09215838f, 0.02810797f, 0.07418522f, 0.07700700f, -0.08052650f, -0.05985601f, 0.09269580f, 
    -0.12997016f, -0.17291373f, 0.01827475f, 0.09819889f, -0.04821951f, 0.12395944f, -0.10133673f, 0.07108565f, 
    0.04039257f, 0.05584010f, -0.23004864f, 0.05822534f, 0.02961847f, 0.04903105f, -0.21521680f, -0.06625000f, 
    0.09827250f, -0.00329506f, 0.15557082f, -0.06789283f, -0.02250860f, 0.04676991f, 0.19064336f, -0.07376297f, 
    -0.31329381f, -0.04879958f, 0.15190391f, -0.13900600f, 0.01102181f, -0.14501782f, -0.02116357f, 0.08175139f, 
    -0.21537985f, -0.05873167f, -0.14457679f, -0.01011102f, 0.02444083f, -0.14147872f, -0.00964638f, -0.03249038f, 
    0.00147821f, 0.02810629f, 0.07855004f, 0.04369520f, 0.09963350f, 0.03352464f, -0.08826467f, 0.01321347f, 
    0.05645870f, 0.12481051f, -0.33968759f, -0.19830191f, 0.16472687f, 0.17471066f, -0.29554525f, -0.11531458f, 
    0.07631890f, -0.03284552f, -0.08005331f, -0.05817920f, 0.00934986f, -0.04207999f, -0.09678764f, 0.01532642f, 
    0.01710592f, -0.02793807f, 0.06647056f, -0.00855517f, -0.01064124f, 0.11993655f, -0.03450083f, -0.19947012f, 
    0.06330932f, -0.06259133f, 0.08264923f, 0.02812601f, 0.16088431f, 0.12753411f, -0.04230597f, -0.14732832f, 
    0.03507114f, -0.02057428f, -0.10919396f, 0.06115389f, 0.19730721f, 0.37043121f, 0.27313057f, -0.12989786f, 
    0.01380505f, 0.10484068f, 0.15236303f, 0.02761946f, 0.18604401f, 0.02115944f, 0.01739706f, 0.02412516f, 
    -0.03077117f, -0.04765182f, -0.01154340f, 0.00400217f, 0.07365465f, -0.14126346f, -0.04157934f, 0.09947514f, 
    0.11923905f, -0.15752248f, -0.17974511f, -0.04491096f, 0.24880977f, -0.13026680f, -0.11021299f, -0.05768128f, 
    0.05674697f, 0.11326429f, 0.02744933f, -0.05844956f, 0.03745337f, -0.05312212f, 0.00469992f, -0.03914855f, 
    -0.07360515f, 0.00377946f, -0.06248908f, 0.05289824f, 0.05264521f, -0.03241957f, 0.03487667f, -0.03831373f, 
    0.07163844f, 0.14285159f, 0.13112694f, 0.31354216f, 0.15253681f, 0.14170343f, -0.16060519f, 0.15846796f, 
    0.05403013f, -0.01384391f, 0.09738697f, -0.04805948f, 0.07973157f, 0.08921301f, 0.18056622f, -0.04844246f, 
    -0.19760656f, -0.00794523f, 0.05779688f, 0.40065101f, 0.11773690f, -0.13862231f, 0.01461384f, 0.10899848f, 
    0.02370982f, -0.07932664f, 0.02534814f, 0.11212192f, -0.26287526f, -0.01023471f, 0.15543264f, -0.20162262f, 
    -0.06935988f, -0.02528226f, -0.01809599f, -0.03531687f, 0.07726371f, 0.03631616f, 0.14095125f, 0.14177968f, 
    -0.05155625f, 0.06097113f, -0.08884241f, -0.10898577f, 0.00937147f, -0.09727928f, -0.00522338f, 0.07382665f, 
    0.10006127f, 0.00955996f, -0.14189084f, -0.09309438f, 0.07130522f, -0.10982405f, 0.04432599f, -0.03069906f, 
    0.03697763f, -0.05078176f, 0.06229107f, -0.00570112f, -0.16235840f, -0.12173048f, 0.16138574f, -0.02027816f, 
    0.24748677f, 0.08134206f, 0.05227447f, -0.02731592f, 0.10199243f, 0.02214221f, -0.12714255f, 0.07092693f, 
    -0.20242082f, -0.05548951f, 0.17881767f, -0.01624443f, 0.00551688f, -0.19622405f, -0.00861990f, 0.01747206f, 
    0.02537049f, 0.13890582f, 0.01618658f, -0.04751093f, 0.05265988f, -0.21958886f, 0.00655315f, 0.17413497f, 
    -0.05110707f, -0.17320330f, 0.04600987f, -0.09657075f, 0.12766290f, 0.11119315f, -0.05421517f, 0.20020382f, 
    0.05296327f, 0.05962400f, -0.09835050f, 0.03843942f, -0.04640079f, 0.01963171f, 0.03810969f, -0.19988307f, 
    -0.00476201f, 0.00441639f, -0.05661786f, -0.06534524f, 0.08182533f, -0.08024121f, -0.06836201f, 0.19361915f, 
    0.07121682f, 0.10625471f, 0.05789993f, -0.16277146f, 0.01354313f, 0.14985502f, 0.04559857f, 0.05007293f, 
    0.00798008f, -0.07535263f, -0.04533326f, 0.06492800f, -0.30477220f, 0.21317533f, 0.02695267f, 0.40227494f, 
    0.02929406f, 0.00306964f, -0.01338709f, 0.06237059f, 0.00972764f, -0.03913726f, -0.02465265f, -0.15286690f, 
    -0.05583397f, -0.03266171f, -0.26248518f, -0.03180934f, -0.11733941f, 0.08812014f, 0.21459892f, -0.03409136f, 
    -0.10963067f, -0.03175307f, -0.12417497f, 0.00522318f, -0.08798968f, 0.08436117f, 0.10263857f, 0.00635089f, 
    -0.13511081f, -0.12135451f, 0.09988411f, 0.01993597f, 0.02954114f, -0.11404488f, 0.16384763f, -0.11379277f, 
    0.07693878f, -0.13092910f, -0.10960290f, 0.08788081f, -0.15649444f, -0.09211226f, -0.14612301f, 0.01764338f, 
    0.05459986f, -0.11340424f, -0.08113461f, -0.04921861f, 0.09065228f, 0.05938594f, 0.00360608f, -0.07099713f, 
    -0.06747189f, -0.04951193f, -0.11087758f, 0.10108697f, 0.05168196f, 0.15799057f, 0.13724248f, 0.04142396f, 
    0.16951972f, 0.18879931f, -0.17049886f, -0.14162102f, -0.11436772f, 0.18500207f, -0.08031728f, -0.06187493f, 
    0.09252883f, 0.00208722f, 0.16081922f, 0.10092929f, -0.07341646f, 0.49626085f, 0.25863126f, 0.44664940f, 
    -0.07401271f, -0.01306692f, 0.03481634f, -0.16056468f, 0.04825132f, 0.14512429f, 0.16027592f, -0.04999084f, 
    -0.05344012f, -0.03022963f, 0.29724398f, 0.26753786f, 0.29731095f, 0.12552047f, 0.02016778f, -0.16286108f, 
    0.08131140f, -0.04059574f, 0.16976745f, 0.20078337f, 0.00044860f, -0.00444719f, 0.24508546f, 0.13265342f, 
    -0.04063115f, 0.10016952f, 0.01966570f, -0.13229042f, 0.00756357f, -0.05057677f, 0.02807528f, -0.14636394f, 
    0.22722344f, 0.12163938f, -0.09277660f, -0.00069818f, -0.04839988f, 0.05688865f, -0.02165986f, -0.00745938f, 
    0.22274989f, 0.06277821f, 0.00810414f, 0.04705300f, -0.36584362f, 0.11556840f, 0.40791449f, 0.27058777f, 
    -0.02545534f, 0.12139598f, 0.12955502f, -0.11039976f, -0.06524120f, 0.02420143f, -0.03183188f, -0.03857134f, 
    0.05848228f, 0.05674297f, 0.06476506f, 0.12971488f, 0.03989668f, 0.00526583f, -0.04729423f, 0.14849700f, 
    0.09558264f, -0.02610468f, 0.12599403f, 0.03637716f, -0.19784291f, 0.11328583f, 0.12927078f, -0.00340168f, 
    -0.29031208f, 0.10978455f, -0.26620039f, -0.09733925f, 0.21906435f, -0.19309077f, 0.23392592f, 0.15040983f, 
    -0.10474657f, -0.18518743f, 0.54391080f, 0.18046130f, -0.03095682f, -0.04403454f, 0.13570644f, -0.02508009f, 
    0.02682064f, -0.08824847f, -0.05906595f, 0.23283978f, 0.14112288f, -0.13379836f, -0.10184307f, 0.26954240f, 
    -0.13897222f, -0.08528542f, -0.11477742f, -0.05655358f, -0.00038865f, 0.27522522f, 0.04642266f, 0.02805417f, 
    0.17207994f, 0.06339765f, -0.29004410f, -0.13388136f, -0.04084019f, 0.14888458f, 0.09718222f, 0.14054698f, 
    0.04355192f, 0.07352155f, -0.10506622f, 0.06889221f, 0.11936453f, -0.10137443f, -0.17843169f, -0.04123311f, 
    -0.11897925f, -0.07423804f, -0.00780484f, -0.02399009f, -0.11870933f, 0.10980576f, 0.02140408f, -0.02061995f, 
    -0.06339185f, -0.11036447f, -0.20162880f, -0.16891786f, -0.03984215f, -0.04780764f, -0.11122797f, -0.08885251f, 
    -0.04154685f, 0.02726770f, -0.19669263f, -0.13520059f, 0.14582783f, 0.19688432f, 0.12563725f, -0.14505887f, 
    0.02291702f, 0.00264057f, 0.04481287f, -0.03375959f, -0.04314633f, -0.17000827f, 0.00358662f, -0.07383993f, 
    -0.10019729f, 0.02235689f, 0.15032540f, -0.00540287f, -0.00987222f, -0.07542263f, -0.09742185f, 0.07701958f, 
    0.05686817f, 0.04796064f, -0.00332209f, -0.00309878f, 0.12612092f, 0.09630439f, 0.00192941f, 0.29212496f, 
    -0.12732057f, 0.08235229f, -0.00667680f, -0.07357963f, 0.01675730f, 0.00353379f, 0.01773106f, 0.05960331f, 
    -0.13651772f, -0.05261912f, 0.04291898f, 0.14280450f, 0.02203764f, 0.06106109f, -0.00533530f, 0.10950080f, 
    -0.16331890f, -0.15430899f, -0.16491155f, -0.11825467f, 0.16991891f, 0.31665382f, 0.22840808f, 0.21211657f, 
    0.20841689f, 0.00031618f, -0.01084229f, 0.14052269f, 0.07149979f, 0.11305251f, 0.04873897f, 0.00799845f, 
    -0.59689260f, 0.01840052f, 0.10475199f, 0.05934828f, -0.02872946f, -0.16907395f, -0.01092652f, -0.02460238f, 
    0.09930804f, 0.13155554f, -0.14113118f, -0.09375590f, -0.14317308f, 0.23268469f, 0.25977570f, -0.15862814f, 
    0.11935200f, -0.03598148f, 0.11617973f, -0.09784311f, -0.05433972f, -0.00675597f, 0.07415836f, 0.10094301f, 
    -0.17661250f, 0.18557957f, -0.07381114f, 0.18471296f, 0.14282924f, -0.06647936f, 0.03126951f, -0.01897142f, 
    0.04903086f, -0.02933074f, 0.09727100f, 0.19084752f, -0.11426082f, -0.22133756f, 0.32655868f, 0.07760756f, 
    0.00565785f, 0.06271473f, 0.06052100f, 0.02399126f, 0.04926904f, 0.06335498f, 0.21860752f, -0.15164641f, 
    -0.05540096f, -0.14365891f, 0.05061935f, -0.34022179f, -0.02536729f, -0.09615143f, -0.05759536f, 0.05911897f, 
    -0.02255142f, 0.09890014f, 0.05510779f, 0.03564294f, 0.13990684f, 0.06902482f, 0.06901427f, 0.08438721f, 
    -0.03200984f, -0.04289020f, 0.06949629f, 0.04895180f, 0.08965101f, -0.05552682f, -0.04039359f, -0.00819298f, 
    0.12728617f, -0.27776682f, -0.19890821f, -0.36960530f, 0.08752943f, -0.08368249f, -0.02212424f, -0.00114530f, 
    -0.01797866f, 0.07690721f, 0.08469686f, -0.12956968f, 0.18537939f, 0.06775192f, 0.07107026f, -0.22431144f, 
    0.00396259f, -0.05554736f, -0.03953105f, 0.00217442f, -0.05247627f, 0.06575263f, -0.02243994f, -0.20254299f, 
    0.04360031f, 0.33589000f, 0.15093759f, 0.22897723f, -0.10178534f, 0.13419114f, -0.00391116f, -0.09528103f, 
    -0.04583995f, -0.13400927f, -0.17431125f, -0.19668892f, 0.00826403f, -0.00280541f, -0.12883706f, 0.11781713f, 
    0.02178279f, 0.18584204f, 0.10736094f, 0.07651995f, 0.10091160f, -0.16036436f, -0.06527992f, -0.03177067f, 
    0.27704501f, 0.35204560f, 0.09632333f, 0.24217524f, -0.10966632f, 0.11465073f, -0.03112799f, 0.09424258f, 
    -0.03653427f, -0.05429580f, 0.03484226f, -0.25622439f, 0.75130546f, 0.02641574f, 0.30925381f, 0.31410831f, 
    0.11346430f, 0.11000229f, -0.03629151f, -0.06757040f, 0.18372019f, -0.06616444f, 0.09742622f, 0.02618151f, 
    -0.06880561f, -0.07391579f, 0.08282521f, 0.06463045f, 0.04237149f, 0.21203269f, 0.30302003f, 0.12296036f, 
    0.00130036f, 0.17724931f, -0.02518910f, 0.14493813f, 0.19033726f, 0.12346494f, 0.15398847f, 0.19179766f, 
    0.08987656f, 0.02354372f, 0.10659629f, 0.10029387f, 0.04722027f, 0.12816747f, -0.00014528f, -0.05425523f, 
    0.32883975f, 0.03126691f, 0.08015523f, 0.23224378f, 0.10339611f, 0.09401107f, 0.10422767f, 0.12662561f, 
    -0.08094923f, 0.10376212f, -0.02702109f, -0.04190063f, 0.05193458f, 0.02422525f, 0.18245336f, -0.23670733f, 
    0.19237487f, -0.22545268f, -0.13904358f, -0.61584210f, -0.07187862f, 0.04982479f, 0.04412699f, -0.10202318f, 
    0.35657609f, -0.00653180f, 0.23261711f, 0.04158609f, -0.03311586f, 0.14734000f, -0.08851054f, -0.02089380f, 
    -0.01466172f, 0.09984560f, -0.07769542f, -0.14665155f, -0.01290951f, -0.07372604f, 0.01472874f, -0.00919769f, 
    -0.11291197f, -0.01912355f, -0.18892737f, -0.17487545f, -0.01703237f, 0.07768885f, 0.09638213f, 0.14968929f, 
    0.18949382f, 0.07306139f, -0.13604277f, -0.03117805f, 0.10723505f, 0.11709391f, -0.02099931f, 0.15647250f, 
    0.13647859f, 0.07524756f, 0.14519557f, 0.03340410f, -0.03060994f, 0.11755972f, 0.12039085f, 0.00323821f, 
    0.10895237f, 0.07785500f, -0.14935486f, -0.20408943f, 0.09573490f, -0.03629972f, -0.05723882f, -0.02717537f, 
    -0.13226111f, 0.06182572f, -0.11999767f, -0.24466032f, -0.10609068f, -0.09443835f, -0.14922677f, -0.17078429f, 
    -0.06756561f, -0.17851648f, -0.21983357f, -0.19224901f, 0.13357612f, -0.07341187f, 0.34179151f, -0.20812660f, 
    -0.05019877f, 0.41483408f, -0.19822615f, -0.12807688f, 0.06994109f, 0.05913730f, -0.01385894f, -0.15846181f, 
    -0.02173544f, 0.21649387f, -0.11387332f, -0.11610634f, -0.20946459f, 0.06397129f, -0.21185830f, 0.10905471f, 
    0.16465180f, 0.10118339f, -0.02044493f, -0.08720210f, 0.30115592f, -0.54671532f, 0.45086774f, -0.14588782f, 
    -0.13715899f, -0.14347440f, -0.15112604f, -0.44400024f, 0.08719660f, 0.09403116f, 0.04867520f, 0.04784197f, 
    0.21191743f, 0.16068701f, -0.20005299f, 0.04551497f, -0.02953334f, 0.06242444f, -0.09099519f, 0.03765337f, 
    -0.03397731f, -0.14819470f, 0.01088486f, -0.16614364f, 0.00868642f, -0.25802276f, -0.11729514f, -0.13463676f, 
    0.03368816f, -0.10878947f, -0.23500504f, -0.08474083f, -0.10394343f, -0.02001828f, 0.12896396f, -0.18018757f, 
    -0.05924843f, -0.19539751f, 0.03259078f, -0.29815245f, 0.14911908f, -0.16058064f, -0.02140559f, 0.07787815f, 
    -0.08004588f, -0.22060183f, -0.33693361f, -0.56730944f, 0.31485757f, 0.19812110f, -0.06245569f, -0.21267498f, 
    0.02003290f, 0.08241952f, 0.13859145f, 0.01677896f, -0.03451815f, 0.04269695f, -0.17123416f, -0.03190207f, 
    -0.18748076f, -0.24318676f, -0.04363665f, -0.21517681f, 0.13635646f, -0.12308580f, -0.03600743f, -0.11624821f, 
    -0.21203177f, -0.24754238f, -0.05549210f, -0.24172592f, 0.01064331f, -0.24672927f, 0.22735626f, -0.30270648f, 
    0.03895408f, 0.08360042f, -0.08430649f, -0.05056868f, -0.12546057f, -0.06906533f, -0.04687447f, -0.20870809f, 
    -0.13943207f, 0.02221880f, 0.03217118f, 0.13978051f, -0.06211642f, 0.07829232f, 0.06616164f, 0.07274816f, 
    0.11505213f, 0.20343271f, 0.18179677f, 0.29316205f, -0.33167124f, 0.08148465f, -0.09952750f, 0.08864515f, 
    -0.08397167f, -0.04380443f, -0.02849875f, -0.01859495f, -0.02465900f, 0.04154149f, 0.11457864f, 0.05018648f, 
    0.21521604f, -0.04923629f, 0.11423535f, -0.04136254f, -0.24168161f, 0.13886230f, 0.24913052f, -0.12666510f, 
    0.19472228f, 0.24535412f, 0.03651704f, 0.24196367f, 0.46681079f, -0.13352288f, 0.04889366f, -0.30756837f, 
    -0.06716531f, 0.14847301f, -0.12923013f, 0.19827551f, 0.09825251f, 0.01317915f, 0.11439533f, 0.10200185f, 
    -0.33051607f, 0.09146006f, -0.28844061f, -0.06278377f, 0.04692119f, -0.03986478f, -0.08734568f, -0.15481795f, 
    -0.09906321f, -0.31863201f, -0.05268281f, -0.23883474f, -0.09284716f, 0.01165864f, 0.19014080f, 0.02404132f, 
    -0.05236484f, -0.01092569f, 0.05944455f, -0.20799491f, 0.08342475f, 0.03291003f, 0.09507549f, 0.19743647f, 
    -0.15338220f, -0.07756689f, 0.21758956f, 0.09677321f, -0.01913374f, -0.09012236f, -0.02173867f, -0.08812599f, 
    -0.01450237f, 0.08917556f, -0.02250821f, 0.10437970f, -0.15304261f, 0.09499392f, -0.06402969f, 0.12631747f, 
    0.18086679f, 0.07201177f, 0.14982115f, -0.01279231f, 0.16107285f, 0.03183924f, 0.21482380f, 0.14993614f, 
    0.11446497f, -0.45999104f, -0.12677009f, -0.16285445f, 0.08660397f, 0.08679371f, -0.06642894f, 0.04032843f, 
    0.03000764f, 0.03553994f, 0.11842459f, 0.12132328f, 0.22076863f, -0.03408308f, 0.00031876f, 0.01308087f, 
    -0.03548418f, 0.02222770f, 0.04710180f, 0.03970737f, 0.10636889f, 0.01717680f, 0.07355548f, 0.25772873f, 
    -0.13454640f, -0.29844093f, -0.33672780f, -0.17143996f, 0.10927321f, -0.07904761f, 0.01264847f, 0.02592514f, 
    -0.01603469f, -0.09856759f, -0.04779417f, -0.05982798f, -0.29494703f, 0.09386294f, -0.06874087f, 0.14124705f, 
    0.04202951f, 0.00669522f, -0.02206472f, 0.20484187f, -0.20144004f, -0.03760012f, 0.13631891f, -0.05434557f, 
    0.05362874f, -0.00468494f, -0.25153404f, -0.32471377f, 0.00901945f, -0.00470175f, 0.11775579f, -0.04514867f, 
    0.09775994f, 0.01049897f, -0.00170716f, 0.06356829f, -0.61400908f, -0.00508110f, 0.17514394f, 0.08914173f, 
    -0.09759145f, -0.10589117f, -0.10210541f, 0.06211559f, 0.04059440f, -0.05500572f, 0.11298396f, 0.00765686f, 
    0.06730723f, -0.01679563f, -0.11366753f, 0.02474052f, -0.09530123f, -0.10515622f, -0.11790168f, 0.03066025f, 
    0.16966619f, -0.05905953f, -0.03037336f, 0.10997944f, 0.03339170f, 0.25527695f, -0.01825558f, -0.11791418f, 
    -0.11306661f, 0.01050087f, -0.04717062f, 0.15747909f, -0.11566766f, -0.06825268f, -0.05437436f, 0.12330715f, 
    -0.08089866f, 0.11070901f, 0.17733648f, -0.05880274f, -0.17241390f, -0.16134827f, -0.01023571f, 0.09403987f, 
    -0.01365527f, -0.21044944f, 0.05047126f, -0.07358710f, 0.09449558f, -0.05127824f, 0.03761426f, 0.39198691f, 
    -0.02881073f, 0.03529491f, 0.04570985f, 0.02970808f, 0.16931546f, -0.04817753f, -0.04749157f, 0.00056485f, 
    -0.26317814f, -0.00194805f, -0.10901543f, -0.04634295f, 0.05186797f, -0.14424597f, 0.03494075f, -0.06529989f, 
    0.16894259f, 0.07115383f, -0.12892434f, 0.04491007f, -0.09821204f, -0.05457644f, -0.13432746f, 0.16966535f, 
    0.13411844f, 0.00643393f, -0.01077388f, 0.06776213f, 0.11159501f, 0.08476204f, 0.09836924f, 0.04280753f, 
    0.08882462f, 0.07455514f, 0.38430437f, 0.08130044f, -0.01396683f, -0.03613861f, 0.18258893f, 0.14010070f, 
    0.15981367f, 0.01484160f, -0.09261085f, 0.03091519f, -0.23760900f, -0.06008057f, -0.06644368f, 0.29308850f, 
    0.17088218f, -0.04960060f, -0.04291201f, -0.01848335f, 0.10991839f, -0.03843448f, 0.13542992f, 0.15951717f, 
    0.07602939f, -0.07629698f, -0.03249875f, 0.10552140f, 0.10458583f, 0.11049241f, 0.10511938f, 0.02612649f, 
    0.18930061f, 0.16393986f, 0.16557379f, 0.09826425f, -0.00396079f, -0.02762463f, -0.18317911f, 0.06270746f, 
    -0.09138542f, -0.08730001f, -0.00248644f, 0.02115155f, 0.10703032f, 0.04181862f, -0.06348471f, 0.00838803f, 
    -0.41995528f, 0.17238808f, 0.00155424f, 0.11289864f, -0.03685812f, 0.03146535f, 0.10427255f, -0.09788086f, 
    0.04837116f, 0.07757453f, 0.01999069f, -0.01169250f, 0.03413333f, 0.28326562f, 0.02716329f, -0.06805508f, 
    -0.09220486f, -0.10294160f, -0.02869937f, 0.04998649f, -0.01065855f, -0.02533059f, 0.08434049f, -0.06829687f, 
    -0.09208231f, -0.12932144f, 0.31734511f, -0.21363200f, -0.00201587f, 0.05947103f, 0.00584544f, 0.16291839f, 
    -0.11539043f, 0.02924611f, -0.00686876f, -0.05199613f, 0.05652170f, -0.06291382f, 0.01060042f, -0.03797551f, 
    0.03292365f, -0.10364814f, 0.02938429f, -0.07143406f, 0.17785901f, 0.09562620f, -0.01198559f, 0.01014140f, 
    0.02425185f, -0.00555443f, 0.05697747f, -0.03832016f, 0.04265244f, -0.01285374f, 0.07563065f, -0.15488310f, 
    -0.04551800f, -0.10164880f, 0.05761699f, -0.14629224f, -0.19348022f, 0.02017430f, 0.16774696f, 0.20581821f, 
    -0.01480197f, -0.03145324f, -0.01199988f, 0.09042776f, -0.00838598f, -0.22639105f, -0.11890534f, -0.02154473f, 
    0.24506934f, -0.00459482f, 0.00891762f, 0.03819002f, 0.01122242f, 0.15231021f, 0.04482555f, 0.07235964f, 
    0.00117611f, 0.23355873f, -0.03263960f, -0.02197854f, 0.22336680f, -0.08612424f, -0.14725658f, 0.17192943f, 
    -0.09635431f, -0.04798160f, -0.04268457f, 0.03542273f, 0.00715812f, -0.13120043f, 0.00736656f, -0.00797305f, 
    -0.09436201f, 0.03550691f, -0.27790064f, -0.15028039f, 0.12367987f, -0.06002010f, -0.12208935f, -0.09668056f, 
    -0.04157503f, -0.17918971f, -0.01735045f, -0.06159458f, 0.32551131f, -0.18650958f, -0.04834933f, -0.08727892f, 
    0.05621648f, -0.06940059f, 0.08707657f, -0.05544216f, 0.14981277f, 0.12736030f, -0.06520396f, 0.12381538f, 
    -0.46964440f, 0.00824581f, -0.10675655f, -0.15758350f, -0.06031788f, -0.08825435f, -0.08636273f, 0.05959584f, 
    -0.15580656f, 0.02043042f, 0.04073175f, -0.06067498f, -0.63242614f, 0.29800808f, 0.04928289f, 0.33115259f, 
    0.07152487f, -0.05196827f, 0.13951907f, -0.02671586f, -0.09176886f, -0.04933130f, -0.12349370f, -0.07266051f, 
    0.29362041f, -0.05173323f, 0.06244655f, 0.01303332f, -0.00940576f, 0.11490195f, -0.01725313f, 0.21514538f, 
    0.06000566f, 0.06481228f, -0.05462056f, -0.00897918f, 0.10719766f, 0.04210830f, 0.03645669f, 0.00387683f, 
    -0.02588097f, -0.09743126f, -0.09492130f, -0.04940139f, -0.00790221f, 0.14197159f, 0.03948142f, 0.00379473f, 
    0.19861192f, 0.29359508f, 0.18746054f, -0.18191704f, 0.00536054f, 0.02563933f, -0.02185440f, -0.10514517f, 
    0.04314712f, 0.08160722f, 0.03146628f, -0.06295338f, 0.17395467f, -0.23053159f, -0.01390647f, -0.03623639f, 
    -0.08281240f, -0.05086714f, -0.02776003f, 0.01911272f, -0.19903965f, 0.18428476f, 0.10068355f, 0.16257901f, 
    0.03982248f, 0.54643399f, 0.02654639f, -0.05530450f, -0.03774995f, 0.02636969f, -0.02477172f, -0.03813587f, 
    0.02215081f, -0.12461092f, 0.06065384f, -0.04129268f, 0.03587107f, 0.19529568f, 0.20813152f, 0.03604322f, 
    0.06688746f, -0.00235392f, 0.09144173f, 0.07302488f, -0.02850306f, 0.07776856f, 0.02121168f, -0.01542611f, 
    0.10730600f, 0.08972299f, 0.51704067f, 0.01996847f, 0.02747723f, -0.19764714f, -0.05177481f, 0.00426707f, 
    -0.05525928f, 0.00528610f, 0.22543824f, 0.13409379f, 0.34845158f, 0.09697177f, 0.36546004f, -0.34446207f, 
    -0.03255641f, -0.03590820f, 0.04879271f, 0.16720217f, -0.08628511f, 0.08999594f, -0.00268554f, 0.10136629f, 
    -0.33311152f, -0.59616005f, 0.15368071f, 0.08176281f, 0.22767061f, 0.26592860f, -0.09887002f, -0.08496586f, 
    -0.05323907f, 0.06155214f, 0.02284615f, 0.12366641f, 0.20551151f, -0.05994462f, -0.44532934f, -0.23860927f, 
    -0.13764752f, 0.15100805f, 0.08534790f, 0.17896484f, -0.11876395f, 0.17348355f, -0.15148188f, -0.15625481f, 
    0.11123334f, 0.16495229f, 0.10449947f, 0.17717594f, -0.02132818f, 0.00601925f, -0.07168701f, -0.01304396f, 
    0.06886603f, 0.04662340f, -0.04195198f, 0.03082514f, -0.00502342f, -0.18314670f, 0.18760566f, 0.11242762f, 
    0.02428152f, 0.09621534f, 0.09159926f, -0.17322221f, -0.03676916f, -0.09574455f, -0.09118868f, 0.04070532f, 
    -0.19054230f, -0.05701995f, -0.04158979f, 0.18963349f, 0.08017772f, 0.07743262f, 0.16512908f, 0.03249498f, 
    -0.10597493f, -0.01409298f, 0.06778872f, 0.13877806f, 0.07210007f, 0.04115773f, -0.06621382f, -0.10316454f, 
    -0.06738359f, 0.09045884f, 0.07787433f, 0.07658185f, 0.07811668f, 0.02973582f, -0.04324370f, 0.07839417f, 
    -0.35544613f, 0.17338364f, -0.01136538f, -0.02374617f, -0.00453256f, -0.02343898f, 0.02959620f, -0.02109680f, 
    0.00024670f, -0.07924192f, 0.18256304f, -0.07779935f, 0.10120793f, 0.27082154f, 0.02352650f, -0.14201725f, 
    -0.02701223f, -0.04410225f, -0.06752546f, 0.02247405f, 0.06506018f, 0.18997219f, -0.04312070f, -0.11020041f, 
    0.03767594f, 0.09480860f, 0.05515883f, 0.08602836f, 0.03348011f, -0.22716734f, 0.07151907f, 0.04278878f, 
    -0.00132224f, 0.05637152f, -0.00219271f, 0.06144685f, 0.28994185f, -0.04192159f, -0.00654305f, -0.07738724f, 
    -0.17020889f, 0.02768801f, -0.01783713f, 0.11362647f, -0.10742176f, 0.10465859f, 0.03204855f, -0.01893157f, 
    0.07639375f, 0.12495025f, 0.04930790f, -0.07511679f, -0.00940791f, -0.07105470f, 0.22044395f, 0.01583276f, 
    -0.19919337f, 0.08837394f, 0.08830124f, 0.02295765f, 0.06839845f, 0.27747089f, 0.13220100f, 0.07095833f, 
    0.05465597f, -0.04447886f, 0.00792938f, 0.16278376f, -0.21719313f, -0.03760174f, -0.05667834f, -0.00486893f, 
    0.19966519f, -0.08834341f, 0.12691116f, -0.09430356f, 0.07086158f, 0.08566422f, -0.07778561f, 0.02592143f, 
    0.20760261f, 0.19110776f, 0.22896306f, -0.01244664f, -0.27183813f, 0.27184725f, -0.26712972f, -0.08238232f, 
    0.05464315f, 0.08612747f, 0.05595525f, 0.07315284f, -0.07072340f, -0.10881069f, 0.02623684f, -0.04824007f, 
    0.06331071f, -0.00617268f, 0.21261212f, 0.40194255f, 0.00000882f, -0.00772349f, 0.27981606f, 0.02433869f, 
    -0.00397265f, 0.04009044f, 0.00660887f, -0.00443215f, 0.02531768f, 0.10133188f, 0.13119064f, 0.07472495f, 
    -0.00622294f, 0.03543839f, -0.01015444f, -0.00050063f, 0.04445361f, 0.00311659f, -0.04588675f, 0.21503295f, 
    -0.07121368f, 0.10192662f, -0.07921549f, 0.10612673f, -0.22689803f, -0.01410448f, 0.09682851f, -0.10673250f, 
    -0.12003168f, 0.00974473f, 0.07722882f, 0.00508445f, -0.21582149f, -0.32355136f, -0.14644210f, 0.10852500f, 
    0.16206789f, 0.01711304f, -0.05188736f, 0.05286866f, -0.09083004f, 0.01803350f, -0.03413741f, -0.03844782f, 
    0.13450593f, 0.10579867f, 0.00488912f, 0.18158500f, -0.11863483f, 0.17875484f, 0.10564087f, -0.16829921f, 
    -0.02987120f, 0.23438182f, -0.02312930f, 0.05084448f, -0.10614030f, 0.56756228f, -0.02235887f, 0.12740107f, 
    0.04468076f, -0.13176122f, -0.07081499f, 0.03325557f, 0.04309543f, 0.04670863f, -0.10321257f, 0.00565308f, 
    0.05406500f, -0.05603948f, 0.18643546f, 0.03312033f, -0.06956048f, 0.02985281f, -0.11771380f, 0.05792975f, 
    0.06156341f, -0.10324324f, -0.15597272f, -0.08801281f, -0.04475640f, -0.10247462f, 0.38731349f, 0.03738937f, 
    -0.00596575f, -0.04440022f, -0.04204839f, 0.00761767f, -0.02343319f, 0.05865327f, -0.12183917f, 0.12240534f, 
    0.22692996f, 0.09016637f, 0.20048200f, -0.32028025f, 0.00412191f, 0.06754729f, -0.11135261f, 0.20941955f, 
    -0.05377715f, -0.00267839f, 0.01270937f, -0.07093993f, 0.36973029f, -0.05429864f, -0.13541482f, 0.28566971f, 
    -0.00450899f, 0.15028395f, -0.02553549f, -0.04212945f, -0.04209697f, -0.03167957f, -0.03921304f, -0.11767271f, 
    0.10015585f, -0.07077041f, 0.37184328f, 0.18103850f, -0.04994248f, 0.18937033f, -0.08983313f, -0.08116601f, 
    -0.10412476f, 0.03299468f, 0.13026802f, 0.11496987f, -0.07616042f, -0.05289741f, -0.04880452f, 0.06593744f, 
    -0.00477326f, 0.03733917f, -0.07680693f, 0.10751815f, -0.01965250f, 0.02697804f, -0.21147791f, 0.04801704f, 
    -0.18086383f, -0.33760867f, -0.28150928f, 0.23229645f, -0.02654652f, 0.20636758f, 0.24745840f, -0.06426150f, 
    0.13073216f, -0.03448859f, -0.22130191f, -0.02167397f, 0.03750801f, 0.10086744f, 0.13060880f, 0.13579875f, 
    -0.03546036f, 0.01283586f, -0.01439433f, 0.10187842f, -0.02618958f, 0.03429069f, -0.03629349f, -0.10167661f, 
    0.02143304f, 0.05997593f, -0.05536831f, 0.20321018f, -0.07762282f, 0.00747125f, 0.19196640f, -0.19156094f, 
    -0.05604696f, -0.03361994f, 0.01129212f, -0.09080388f, -0.16242021f, -0.09081537f, -0.01593566f, 0.28943020f, 
    0.08659657f, 0.12538064f, 0.08845470f, 0.03124538f, -0.00354956f, 0.04701242f, 0.02453652f, -0.13625421f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01947080f, -0.11186805f, 0.00268867f, -0.01029231f, 0.11942354f, 0.04976536f, -0.03131530f, 0.23587018f, 
    0.04037004f, 0.08372553f, 0.05261363f, 0.06245343f, -0.05441504f, -0.01629644f, 0.04546274f, 0.11495490f, 
    -0.02767406f, 0.08174064f, 0.07849690f, 0.24080984f, -0.00062028f, -0.04057576f, 0.02151437f, 0.22471569f, 
    -0.04063423f, 0.05490695f, -0.00151345f, -0.13590704f, 0.05069623f, -0.11336376f, 0.27703193f, 0.02922298f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01006234f, 0.22300339f, 0.17501238f, -0.37773746f, -0.01175564f, 0.10765015f, -0.13151596f, -0.04342388f, 
    -0.19268937f, 0.09002418f, 0.15874395f, 0.16250893f, -0.02243590f, -0.23175485f, 0.02166092f, -0.00510124f, 
    0.38122991f, -0.13705489f, -0.15450560f, -0.30399942f, -0.08165220f, -0.07640050f, -0.08321106f, 0.06715437f, 
    0.21772866f, 0.27043667f, 0.08482187f, 0.21563253f, 0.12633686f, -0.15058021f, 0.19501314f, 0.14466481f, 
    -0.13426448f, -0.01482769f, -0.02181108f, -0.03122623f, -0.06108974f, 0.10457899f, 0.06495786f, 0.03562136f, 
    -0.01259400f, -0.00792886f, 0.08715180f, -0.12932186f, -0.01607732f, 0.02766199f, -0.03960651f, 0.13162336f, 
    0.02079947f, -0.10201817f, -0.18737496f, -0.01094575f, -0.06672847f, -0.12571566f, 0.11105294f, 0.09334253f, 
    -0.10371010f, -0.16465652f, -0.07080851f, -0.15916479f, 0.02923669f, -0.12184983f, -0.15799451f, -0.11611854f, 
    0.00681595f, 0.43694735f, -0.09993123f, 0.25246543f, -0.37414572f, -0.05895540f, -0.12541862f, -0.09850881f, 
    -0.34453556f, -0.35840026f, 0.16060410f, 0.12782140f, -0.14827389f, 0.26997963f, -0.18398336f, -0.35853377f, 
    0.09091275f, 0.26476905f, 0.06455343f, 0.24429204f, 0.12891944f, 0.10967230f, 0.42406908f, 0.06742035f, 
    0.01472977f, 0.20186728f, -0.09107617f, 0.21745101f, -0.25018993f, 0.56362772f, 0.26737034f, -0.42575336f, 
    -0.40835819f, 0.07893949f, 0.15511122f, 0.24179423f, -0.53220838f, -0.14103529f, 0.03207036f, -0.53826058f, 
    0.37291238f, -0.31055054f, 0.29085159f, 0.01756166f, -0.12149665f, -0.05694553f, 0.34738648f, 0.26979068f, 
    -0.58883351f, 0.02019298f, 0.12905160f, -0.13795987f, -0.11739941f, 0.03432569f, 0.23098980f, 0.18054298f, 
    0.05888778f, 0.12264942f, 0.00061042f, 0.11226825f, 0.34756601f, 0.16354591f, 0.18794423f, 0.06491337f, 
    0.10403498f, 0.04645219f, 0.03851936f, 0.54492491f, -0.03993824f, 0.06602609f, -0.12441946f, 0.09344686f, 
    -0.12505363f, -0.08192794f, 0.11975213f, 0.10320907f, -0.12244866f, -0.16409765f, 0.04924583f, 0.22372368f, 
    0.47216558f, -0.15095308f, 0.16891454f, 0.21664353f, -0.11357407f, 0.04087754f, -0.25105986f, 0.29946336f, 
    -0.33117032f, -0.11968539f, 0.05738604f, -0.18641627f, 0.07971783f, -0.35331842f, 0.28969678f, 0.05076748f, 
    -0.06984421f, 0.09281360f, 0.09252396f, 0.27472997f, 0.08039416f, -0.26214227f, -0.13633659f, 0.00532343f, 
    0.31513658f, 0.12023125f, 0.47027394f, -0.19859079f, -0.05760264f, -0.07835092f, -0.08150514f, -0.06112988f, 
    0.03065064f, 0.20444295f, 0.22823498f, 0.14715090f, 0.09769698f, -0.16226684f, 0.10378470f, -0.19003762f, 
    0.13862786f, 0.25806352f, 0.15665996f, -0.20054381f, 0.28654286f, -0.52746844f, 0.00865506f, 0.11043426f, 
    0.02222680f, -0.06462253f, -0.06009696f, -0.17068903f, 0.04785815f, 0.21959098f, -0.05687182f, 0.08433919f, 
    0.21934277f, 0.15674168f, 0.05994302f, 0.07297525f, 0.09978515f, -0.35910049f, 0.67218214f, 0.02466712f, 
    -0.04968750f, -0.49699569f, 0.01722529f, -0.00022547f, 0.04097121f, 0.16230507f, -0.51325399f, 0.16492604f, 
    -0.43835130f, -0.37067246f, -0.00021666f, 0.06910753f, -0.05616266f, 0.10668360f, -0.18802683f, 0.17232488f, 
    0.03911356f, 0.03194920f, -0.10815510f, -0.13240884f, -0.48047152f, 0.26525003f, -0.14468004f, -0.13475311f, 
    -0.31701750f, -0.15937735f, -0.32456508f, 0.25336593f, -0.10185564f, -0.04283030f, -0.36021471f, 0.13813138f, 
    0.07847672f, 0.06984724f, 0.17685270f, 0.24944398f, -0.12971362f, 0.00521812f, -0.16076195f, 0.22491580f, 
    0.18537906f, -0.16194938f, 0.02045053f, 0.13542239f, 0.06221172f, 0.12758064f, -0.05328063f, 0.00022948f, 
    -0.28529555f, 0.07282469f, -0.09703878f, 0.46142626f, 0.02622573f, 0.07917660f, -0.10557602f, -0.19980121f, 
    0.01690903f, 0.01390832f, 0.16101779f, -0.04336963f, 0.13319387f, -0.11573685f, -0.06349624f, 0.12278179f, 
    0.38187611f, 0.05735271f, 0.21199247f, -0.16242847f, -0.02313946f, -0.02163634f, -0.14722158f, -0.20477332f, 
    -0.10891319f, 0.08678288f, 0.02483273f, 0.23685767f, 0.14138599f, 0.42309409f, 0.02370649f, -0.19627707f, 
    0.22784448f, -0.14931947f, -0.16769992f, 0.31898895f, -0.53447920f, 0.22789596f, 0.02019559f, -0.16198234f, 
    -0.02056532f, -0.15498839f, -0.19966024f, 0.22137716f, 0.11117059f, 0.16870679f, -0.22008894f, -0.12762815f, 
    -0.05053512f, 0.17850874f, 0.18286626f, 0.18594819f, 0.11717726f, -0.10873158f, -0.15561318f, -0.06151827f, 
    -0.22412565f, -0.12123144f, 0.04198733f, -0.15928292f, 0.35125828f, 0.27834198f, -0.07000679f, -0.15659632f, 
    0.20117101f, -0.07560037f, 0.14965105f, -0.17401470f, 0.00609819f, 0.17926747f, -0.14482124f, -0.11724177f, 
    0.30953255f, -0.03210335f, 0.10901667f, 0.06135980f, 0.05289672f, -0.16331151f, 0.14769164f, -0.28438205f, 
    -0.14502864f, 0.00420542f, 0.21552189f, -0.06752149f, 0.09466064f, -0.17386372f, 0.33470321f, -0.27650207f, 
    0.27283001f, 0.01630325f, 0.07426353f, -0.01271102f, 0.10666735f, 0.54758686f, -0.33578682f, 0.25985047f, 
    0.12350979f, -0.12252976f, -0.05902283f, 0.04411224f, -0.13384223f, 0.10183919f, 0.09734626f, -0.13603228f, 
    0.03558397f, -0.25907418f, -0.14540555f, 0.23592576f, -0.06755198f, 0.02148557f, -0.14912181f, 0.39813611f, 
    0.09846739f, -0.10301231f, 0.19377653f, -0.01869885f, 0.03209023f, 0.08087786f, -0.16530134f, 0.09789836f, 
    0.13354349f, -0.20486034f, 0.05698374f, -0.02056594f, -0.06203416f, 0.10015247f, -0.13558057f, -0.00713328f, 
    0.04245729f, -0.20550847f, -0.09656123f, -0.06155875f, 0.09603478f, 0.16870949f, 0.15449595f, 0.17411603f, 
    0.22528793f, -0.01292895f, 0.18014713f, 0.03345320f, -0.10098688f, -0.00437206f, 0.24541864f, 0.49848884f, 
    -0.30590534f, -0.31897703f, 0.16879326f, -0.12387566f, -0.04056244f, 0.05176476f, 0.08087997f, 0.16958086f, 
    0.15586059f, -0.21481392f, -0.03631375f, 0.14426413f, 0.26511481f, -0.25803265f, 0.33310372f, -0.35511044f, 
    0.34393662f, -0.07089380f, 0.05486561f, 0.31990558f, 0.09482924f, -0.11797295f, 0.11986139f, -0.20631550f, 
    0.00859222f, -0.22408566f, -0.03664520f, 0.14244172f, -0.03534745f, -0.00149726f, 0.02997578f, -0.26811445f, 
    0.05948474f, -0.03989850f, 0.28837416f, 0.22247285f, 0.10363539f, 0.14026311f, 0.13527957f, -0.26738173f, 
    0.16563769f, 0.02950166f, -0.09637597f, -0.07115404f, -0.19705966f, 0.32290280f, -0.55155790f, 0.37443405f, 
    -0.26730189f, -0.10696898f, 0.10259049f, -0.09107246f, -0.15414448f, 0.05423256f, -0.02042046f, 0.06212990f, 
    -0.15419164f, -0.06582161f, -0.21949326f, 0.31782916f, -0.13881688f, -0.35704103f, -0.02531345f, 0.40683377f, 
    0.22906800f, -0.24836558f, -0.04734077f, -0.19937213f, -0.12220280f, -0.05235633f, -0.04204380f, 0.26754567f, 
    0.36722833f, 0.05212238f, 0.03380665f, 0.00284175f, 0.10865253f, 0.02162813f, 0.20327564f, -0.29900321f, 
    0.41252008f, 0.18865605f, -0.13896582f, -0.08944047f, 0.11228359f, -0.16446379f, 0.12077078f, 0.30028981f, 
    -0.21520256f, -0.05493884f, -0.33608660f, 0.20723237f, 0.04957145f, -0.03824287f, -0.20670922f, 0.01121014f, 
    0.36903977f, -0.19211575f, 0.08170105f, 0.34246314f, 0.04532962f, 0.08289140f, -0.25653714f, 0.30172849f, 
    0.21320412f, 0.08916152f, 0.01720379f, -0.19656329f, -0.00247066f, -0.28465447f, 0.15904471f, 0.24820903f, 
    0.01111349f, -0.10287935f, 0.09241077f, -0.53212935f, -0.08045060f, -0.03744613f, -0.09191246f, 0.11304096f, 
    0.21900232f, 0.05373225f, 0.16231480f, 0.15706742f, 0.10629771f, 0.06154334f, -0.03110070f, 0.00887797f, 
    -0.04697579f, 0.23273684f, -0.03754496f, -0.01387045f, -0.06497025f, 0.10157979f, 0.29145262f, 0.18561327f, 
    0.31537789f, 0.32591423f, -0.12339718f, 0.12301022f, 0.37692666f, -0.17509598f, 0.07399484f, -0.36769751f, 
    -0.00378787f, -0.13156809f, -0.00379102f, -0.24987328f, -0.04686388f, 0.21578828f, 0.01376572f, -0.01386567f, 
    -0.16647498f, 0.26349646f, -0.06565403f, 0.11976714f, 0.06013195f, 0.26279375f, 0.35156012f, -0.16414723f, 
    0.12385173f, 0.23298912f, -0.09265427f, 0.03431771f, 0.04081104f, -0.04658480f, 0.01703802f, 0.26707515f, 
    -0.19304214f, 0.34464768f, 0.04050850f, 0.01300051f, 0.35848427f, 0.10846335f, 0.41769275f, -0.14733872f, 
    0.30058441f, -0.32424155f, -0.13827774f, 0.01462202f, 0.17878412f, 0.11931761f, -0.11228803f, 0.12389086f, 
    0.30505779f, 0.04333213f, 0.15046357f, 0.03463819f, -0.14934406f, 0.14797692f, -0.00223363f, -0.08558880f, 
    -0.11020971f, -0.04563779f, 0.02241926f, 0.29293379f, -0.17149675f, -0.02949258f, 0.02807961f, 0.10820436f, 
    -0.20995155f, -0.11131021f, -0.02005539f, -0.35660580f, -0.15062238f, -0.30330539f, 0.18398862f, 0.17018303f, 
    -0.08978458f, -0.16031459f, 0.13037355f, 0.20614161f, 0.06319016f, 0.01304331f, -0.15727943f, 0.17517550f, 
    -0.05297259f, 0.19066137f, -0.16307063f, 0.06470883f, 0.13259333f, -0.16920702f, -0.34110010f, 0.26336598f, 
    -0.06827802f, 0.01116926f, 0.22661279f, -0.13198608f, -0.09530342f, 0.07410905f, -0.31227398f, 0.20801377f, 
    -0.07040451f, -0.34100258f, -0.16304605f, 0.15073735f, -0.04784013f, -0.19960137f, -0.02542735f, 0.02214712f, 
    0.15977082f, -0.37388855f, 0.10706753f, 0.02297430f, -0.13009363f, 0.26770246f, -0.08230057f, 0.02766109f, 
    0.05439856f, -0.01346364f, -0.11209965f, -0.02824319f, -0.02025391f, 0.12657376f, 0.28425226f, 0.18824269f, 
    -0.19765802f, 0.02959854f, 0.29671127f, 0.24338581f, -0.14120610f, 0.03184798f, -0.02995571f, -0.15822026f, 
    -0.35522068f, -0.27670759f, -0.14592583f, -0.11570394f, 0.05984005f, 0.50041991f, -0.06127826f, -0.27741656f, 
    -0.12441830f, -0.34810686f, -0.16454986f, 0.23999153f, 0.09374995f, -0.02373600f, -0.12241965f, -0.15516089f, 
    0.46560240f, 0.07128413f, 0.42167529f, -0.17785603f, -0.05717157f, -0.19894978f, -0.27252072f, 0.25636035f, 
    -0.10865137f, -0.12720430f, 0.17225648f, -0.02802298f, -0.04583446f, -0.02005864f, 0.16304064f, -0.02730435f, 
    0.30824253f, 0.19224684f, -0.11980353f, -0.32562554f, 0.44070461f, -0.58627552f, 0.24654114f, 0.25494874f, 
    0.37131125f, -0.15047328f, -0.07607257f, -0.09967941f, 0.06096118f, 0.19695413f, -0.05402801f, -0.13047509f, 
    -0.18873201f, -0.03702496f, -0.00924766f, 0.16859916f, -0.07633540f, -0.05019911f, -0.51141661f, 0.16398025f, 
    -0.01532380f, -0.21494032f, -0.00168527f, 0.26452303f, -0.03067104f, 0.09152599f, -0.09901981f, 0.24498276f, 
    0.47089553f, 0.03607091f, 0.01361322f, -0.08918326f, -0.15138972f, 0.03931789f, -0.22137517f, -0.07398794f, 
    -0.00993229f, -0.10363375f, 0.05163512f, -0.44596756f, -0.12577485f, 0.13244781f, -0.15243557f, -0.11506212f, 
    -0.07015296f, 0.16836774f, 0.05050158f, 0.19402885f, -0.14479570f, -0.11372980f, -0.17221469f, -0.19953223f, 
    -0.20712700f, 0.40449244f, 0.09156165f, 0.18602139f, -0.13956258f, 0.15370667f, 0.05929632f, 0.21561955f, 
    -0.08434618f, 0.09106778f, 0.02342357f, 0.22661604f, 0.30287489f, 0.00485167f, -0.04609396f, -0.46128899f, 
    0.16058944f, 0.03199512f, 0.00288191f, 0.17555025f, -0.17306873f, -0.11830752f, -0.10538674f, -0.31439748f, 
    0.46508235f, -0.04311702f, 0.33545357f, 0.09802467f, 0.02361020f, -0.02264683f, -0.32936925f, 0.06876488f, 
    -0.20163384f, -0.25973102f, 0.37831029f, -0.10161567f, -0.12725632f, -0.02516265f, 0.11619021f, -0.02463051f, 
    0.62352580f, 0.27508116f, -0.10325643f, 0.18040381f, 0.34014288f, -0.19595766f, -0.40707672f, 0.28190610f, 
    0.27790940f, -0.15953033f, 0.02450822f, -0.15050919f, 0.14636248f, 0.13989218f, 0.02728395f, 0.32885674f, 
    0.16784732f, -0.08467192f, -0.27589294f, -0.03439617f, -0.02005896f, -0.03664745f, 0.34777462f, 0.16208658f, 
    0.09281503f, -0.28465569f, 0.23530437f, 0.10257164f, 0.04018524f, -0.07738111f, 0.02515943f, -0.06122052f, 
    0.15833713f, -0.18758309f, 0.11453015f, -0.16338459f, 0.16051650f, 0.47094429f, -0.05467223f, -0.36783090f, 
    -0.13445266f, -0.04089512f, 0.16289848f, 0.12142096f, -0.13192342f, -0.17702349f, 0.11753927f, 0.14909914f, 
    0.18908887f, -0.19028328f, 0.04646122f, 0.21554276f, -0.01532522f, 0.03505740f, -0.15296862f, 0.18024458f, 
    -0.25947997f, 0.17094746f, 0.08790085f, 0.20008089f, 0.05674418f, -0.17586589f, 0.12733001f, 0.30003306f, 
    -0.38725746f, -0.05948254f, 0.16259816f, -0.06596515f, -0.35546014f, -0.36841068f, 0.17822245f, 0.07425946f, 
    0.25817156f, 0.09539085f, 0.10651921f, 0.17394954f, -0.29702243f, 0.11359685f, 0.10672557f, -0.21564576f, 
    0.26363817f, -0.03934183f, -0.18771967f, 0.05124267f, 0.15531887f, 0.16900551f, 0.16871098f, -0.10839145f, 
    -0.11679792f, -0.07732084f, 0.11543991f, -0.17526898f, -0.11077460f, -0.06878399f, 0.03556101f, -0.21102242f, 
    -0.05192082f, -0.11483230f, -0.04413909f, -0.16800292f, -0.16375287f, 0.39853439f, -0.45496202f, 0.20899472f, 
    -0.03388288f, -0.11413139f, -0.10088595f, -0.04780595f, 0.12615441f, -0.11606181f, 0.06450632f, -0.12391607f, 
    0.06069891f, -0.10712803f, -0.16810046f, -0.19646908f, 0.05556766f, -0.03124077f, 0.07152874f, -0.04682723f, 
    -0.06482213f, 0.05066587f, -0.20782752f, -0.10548369f, -0.06086861f, 0.05798471f, 0.04032356f, 0.07938538f, 
    0.13334042f, 0.09813221f, 0.07464536f, -0.14047626f, 0.16618805f, -0.07386617f, 0.07366458f, -0.05831535f, 
    -0.15178625f, -0.03760616f, -0.14437908f, -0.04112985f, 0.16710867f, -0.22071844f, 0.12592460f, -0.06179130f, 
    0.10465491f, 0.03983354f, 0.31039780f, -0.08919301f, -0.08875723f, 0.27628446f, 0.03186694f, 0.07545073f, 
    -0.03988619f, 0.48714539f, -0.09043277f, 0.15881409f, -0.15552746f, 0.15339684f, 0.12806882f, 0.22977887f, 
    -0.36634928f, 0.03992218f, -0.00600375f, 0.19329533f, -0.09071296f, -0.56757122f, 0.35461190f, 0.24249826f, 
    0.13100311f, 0.08885217f, 0.15384419f, 0.45716923f, -0.18054752f, -0.07547651f, 0.10244670f, 0.08035054f, 
    -0.30351964f, 0.10896897f, -0.10839290f, -0.10583381f, 0.05994738f, -0.42229301f, 0.10285367f, -0.04948087f, 
    0.53451324f, -0.28536963f, 0.13194641f, 0.20152372f, -0.03712210f, -0.03894922f, -0.57372272f, 0.16289663f, 
    0.20214011f, 0.15133248f, -0.14632061f, -0.23464014f, 0.11090885f, -0.10817531f, -0.02729729f, 0.23279074f, 
    0.05377211f, 0.27776232f, -0.05795061f, -0.12952305f, -0.18331242f, 0.26870984f, -0.04832979f, 0.18800667f, 
    -0.11148800f, 0.06667642f, 0.12571219f, -0.09511224f, 0.12657788f, -0.57055861f, 0.39083764f, 0.20635781f, 
    0.55108321f, -0.33057755f, -0.01529734f, 0.16698156f, -0.04483065f, -0.11270336f, 0.05342717f, -0.03075760f, 
    -0.07022714f, 0.28297007f, -0.14792161f, 0.07254802f, 0.03678140f, 0.00424183f, 0.04619065f, -0.28839007f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21388061f, -0.15087841f, -0.02205726f, -0.13441931f, 0.22833887f, -0.07426818f, 0.05247796f, 0.15492138f, 
    -0.14366388f, 0.12567531f, -0.22841826f, 0.09336026f, -0.01292923f, -0.04275702f, 0.16903786f, 0.26295072f, 
    0.07568407f, 0.17597823f, 0.15782341f, 0.15600491f, 0.23973623f, 0.06220986f, 0.10939274f, 0.14223365f, 
    0.04865433f, 0.13892339f, 0.10390007f, -0.19776449f, 0.05116196f, 0.16672979f, 0.02326570f, -0.04167787f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.00581736f, -0.10374696f, 0.08272170f, 0.29971895f, -0.38299617f, 0.16538696f, -0.50685310f, -0.24106756f, 
    0.39384881f, 0.08598126f, 0.19331817f, -0.61797380f, -0.50037760f, 0.11284416f, -0.30748087f, -0.61433977f, 
    0.12168565f, 0.01546553f, -0.48143280f, 0.02867605f, 0.18650433f, -0.10773740f, -0.67677593f, 0.16721398f, 
    0.13400480f, -0.43164685f, -0.16233335f, 0.04221351f, -0.04626552f, 0.03663150f, -0.29624739f, -0.19612841f, 
    -0.00816391f, -0.12915505f, 0.16521874f, 0.07532450f, 0.17214525f, 0.36065146f, 0.12295514f, -0.44271702f, 
    -0.12566291f, -0.52054787f, -0.18163827f, -0.41867572f, 0.02477560f, -0.05890285f, -0.50990236f, 0.00226883f, 
    0.01263254f, 0.04294663f, 0.20679350f, -0.28240067f, 0.11222600f, 0.29192042f, -0.42194352f, -0.18238804f, 
    0.01908977f, -0.01394475f, 0.28072330f, -0.19124801f, 0.04611299f, 0.30495670f, 0.19958679f, 0.18975905f, 
    0.04894795f, 0.13779823f, -0.24652648f, -0.46685177f, 0.25529110f, -0.03999137f, -0.54426211f, 0.14559042f, 
    -0.17651318f, 0.50650436f, -0.50538266f, 0.09819048f, -0.17769375f, -0.18682539f, -0.21303658f, 0.23192863f, 
    -0.04642648f, 0.28090048f, 0.17486028f, 0.28206688f, -0.06133837f, -0.03662975f, -0.03217063f, 0.20507871f, 
    -0.34750903f, -0.44012326f, 0.24874775f, -0.32280904f, 0.03845311f, 0.26836371f, 0.16230483f, -0.45863688f, 
    -0.19600274f, 0.14381076f, 0.14589453f, -0.01893550f, -0.08630024f, -0.04832186f, -0.70699120f, 0.15691972f, 
    -0.07437456f, 0.17657645f, 0.04535148f, 0.09373290f, -0.39663088f, 0.33930787f, -0.39848182f, 0.20715766f, 
    -0.15226844f, -0.26411161f, -0.04288549f, -0.36986166f, -0.06573656f, -0.20544948f, 0.18160947f, -0.22930565f, 
    0.16966785f, 0.11752030f, 0.08542191f, 0.37312585f, -0.07612835f, -0.24927035f, -0.31799150f, -0.39720002f, 
    0.17248400f, 0.00492616f, 0.25416422f, -0.19215624f, -0.34043056f, -0.27675408f, 0.24546678f, 0.19446212f, 
    -0.19454092f, -0.12351212f, 0.06010938f, -0.17657658f, -0.28030202f, 0.09570628f, -0.07452631f, 0.00226401f, 
    0.14973038f, 0.16887562f, -0.13638398f, -0.20091663f, -0.30419102f, -0.60556120f, 0.06263825f, 0.36024949f, 
    -0.07257140f, -0.43722987f, 0.22592564f, -0.24728647f, 0.04747047f, 0.00152444f, 0.05210370f, 0.10237323f, 
    0.03373089f, -0.10760628f, -0.18215267f, 0.32271013f, -0.05756630f, -0.03143235f, 0.09172304f, 0.09134060f, 
    0.07133609f, -0.00725479f, -0.13938436f, 0.12187461f, 0.14942026f, -0.23898041f, 0.40142316f, -0.13971107f, 
    0.09676614f, -0.03544608f, -0.21402286f, 0.09918250f, -0.20171463f, 0.16233787f, 0.04479132f, 0.18462828f, 
    0.19293252f, -0.41705611f, -0.00690889f, -0.15595864f, -0.11988579f, -0.05306266f, -0.47955820f, -0.03057179f, 
    0.13677883f, 0.10417435f, -0.57427925f, -0.44745845f, 0.28458384f, -0.39905542f, 0.28967655f, -0.01081568f, 
    0.00550236f, -0.53921342f, -0.66036904f, 0.21786439f, 0.22108226f, -0.55600619f, 0.38152903f, 0.14144497f, 
    0.07726519f, -0.02973595f, -0.02636864f, 0.18272878f, -0.36754176f, -0.26679835f, -0.09379317f, -0.22959268f, 
    -0.71594220f, 0.13599306f, 0.17620948f, -0.37985641f, 0.13877939f, -0.18514207f, -0.00073948f, 0.20204541f, 
    -0.02220040f, -0.02689573f, -0.38546291f, 0.11078161f, -0.04427432f, -0.03221666f, 0.14861792f, -0.08133797f, 
    0.18250133f, 0.34449202f, 0.23445156f, 0.24345309f, -0.16673337f, 0.27386370f, -0.04954691f, -0.22103812f, 
    -0.52067953f, 0.08683833f, 0.07398298f, -0.07294617f, 0.52137792f, -0.28099614f, -0.18364134f, -0.34006220f, 
    -0.16636203f, 0.12687576f, -0.47171068f, 0.35005310f, -0.24860606f, -0.25704953f, 0.03462679f, -0.11467422f, 
    -0.45512438f, 0.05589673f, -0.63869500f, -0.41818234f, 0.01241566f, 0.18959351f, -0.16279289f, -0.12297251f, 
    -0.07687370f, 0.07129069f, 0.10882678f, 0.14039917f, 0.21004152f, 0.21210089f, -0.06979406f, -0.04901107f, 
    -0.29841718f, -0.69263846f, 0.19389981f, 0.37950006f, 0.06881296f, 0.23345985f, 0.16829246f, -0.37702009f, 
    0.12000001f, 0.32403263f, 0.04419842f, -0.11476596f, -0.00767996f, -0.31610137f, -0.01145149f, -0.34753302f, 
    -0.14836302f, -0.18119396f, 0.17252605f, -0.41772330f, 0.02945044f, -0.31592417f, -0.17996734f, -0.00230656f, 
    0.11753849f, 0.32178223f, -0.21316111f, -0.16675547f, 0.20597567f, -0.38119489f, 0.07914619f, -0.02254653f, 
    0.17449202f, 0.39035413f, 0.12949432f, -0.13839924f, 0.38920876f, -0.22100428f, -0.10290278f, 0.24978153f, 
    -0.67229396f, 0.41317934f, -0.28439325f, -0.37037426f, -0.08581031f, -0.20759891f, -0.40521890f, 0.04392459f, 
    0.24258627f, -0.00075565f, -0.60253781f, -0.51764774f, -0.38143748f, 0.24950697f, -0.90240747f, -0.24471429f, 
    -0.72527128f, -0.49654496f, 0.32733023f, -0.16527274f, 0.03821913f, 0.03361212f, -0.02407925f, -0.00110447f, 
    0.31439295f, 0.12148992f, 0.23749514f, -0.32526761f, -0.35861066f, 0.31272545f, 0.15065500f, -0.00198319f, 
    0.24856524f, 0.04135050f, -0.20670727f, -0.24303947f, 0.17122212f, -0.06781466f, -0.26601997f, -0.46883082f, 
    0.25921604f, -0.07842582f, 0.06619496f, -0.50496012f, 0.17492826f, 0.00428740f, -0.31714457f, 0.04876882f, 
    0.19141969f, -0.10713209f, -0.23278844f, 0.01277610f, -0.21682596f, -0.00045555f, 0.24350631f, 0.26124346f, 
    -0.07970699f, -0.11181480f, -0.25401559f, 0.08593005f, -0.57836854f, 0.18295588f, 0.11052734f, -0.16758810f, 
    0.09822121f, -0.09939922f, -0.51320451f, -0.38752171f, -0.08050027f, -0.47566929f, 0.43295464f, 0.21465833f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.00748730f, 0.02311409f, -0.01988106f, -0.18583626f, 0.09572201f, -0.13739859f, 0.20908955f, -0.15484126f, 
    -0.23704018f, 0.12138228f, -0.08129666f, -0.16784941f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
