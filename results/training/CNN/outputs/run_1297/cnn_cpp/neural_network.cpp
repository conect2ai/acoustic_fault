#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.06497169f, 0.09833909f, 0.15518157f, -0.62427545f, 0.61905557f, 0.47133923f, 0.01766437f, 0.57658553f, 
    0.04438549f, 0.08748206f, 0.82157183f, -0.64693499f, 0.42926401f, -0.88850462f, -0.81600785f, -0.30151537f, 
    -0.64427185f, -0.94217110f, 0.26697680f, 1.60763168f, 0.83352017f, -1.22930992f, -0.91062319f, -0.67214096f, 
    0.30637610f, -0.08094230f, 0.14380109f, -1.44840443f, 1.83925354f, -0.07690640f, -0.87101936f, -0.55178690f, 
    0.24800985f, -0.59516889f, 0.11122179f, -0.61455536f, -0.50272173f, -1.20130968f, 0.34140867f, -1.07844841f, 
    -1.26258385f, -1.13638091f, 0.22784336f, -0.26388627f, -0.78629249f, 1.16736090f, -0.32031870f, 0.04820591f, 
    0.30652985f, -0.07536536f, -0.07758000f, 0.08096616f, 0.57256341f, -0.00447631f, -1.20485461f, 0.35724440f, 
    0.20541424f, -1.02167833f, -0.92950726f, -0.27076808f, 0.50125039f, 0.34021324f, 0.26815715f, 0.38498300f, 
    0.23764531f, -0.22650805f, 0.81104279f, 0.56032228f, -0.13143711f, -0.21006739f, 0.74090636f, -0.42961726f, 
    -0.48959121f, -0.17215036f, 0.17884915f, -0.62557513f, 0.15365995f, -0.78176081f, 0.89767224f, 0.40138739f, 
    0.40524784f, 1.73740959f, -0.77538824f, -0.86551344f, 0.48901409f, -0.31125993f, -0.53409511f, 0.81367218f, 
    -0.57336581f, 0.02920248f, 0.64078957f, 0.47135493f, 0.33884200f, -0.28123894f, 0.65549225f, 0.16042273f, 
    -0.11978990f, -0.20630114f, -0.26090080f, -1.58578908f, -0.96914756f, -1.39787734f, 0.76072699f, 0.77681810f, 
    -0.64389712f, -0.36226943f, -0.56715220f, -0.09474181f, 0.91790646f, -0.54370427f, -1.02507615f, 0.34584856f, 
    0.68595558f, 0.61803120f, -0.42154753f, -0.18187653f, -0.38554040f, 0.50804585f, 0.45038757f, 0.20123635f, 
    -0.30905002f, -0.58127993f, 0.92621636f, 0.26464960f, -0.55695283f, -0.77267754f, -1.26115572f, -0.82529604f, 
    -0.51588392f, -0.66023207f, -0.97453755f, -1.13967490f, 0.32188958f, -0.49643633f, 0.95292652f, -1.51360476f, 
    -0.74426711f, -0.18979988f, 0.43525198f, 0.54731137f, 1.00742829f, 0.38785985f, 0.32268614f, -0.22569740f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08479740f, 0.38607985f, 0.30188668f, 0.13611737f, 0.24290140f, 0.37900054f, 0.50436211f, 0.00175890f, 
    0.01117302f, 0.45950258f, 0.23040169f, -0.22117563f, 0.45211849f, 0.48650122f, -0.39522278f, 0.12919651f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04128214f, -0.02141684f, 0.18596551f, 0.09032534f, 0.09487073f, 0.02852367f, 0.01493220f, 0.11478452f, 
    0.03288187f, -0.00924279f, -0.20055199f, -0.04218372f, -0.08066401f, -0.04845147f, 0.03268442f, 0.00860007f, 
    -0.05034384f, 0.01522250f, -0.05715192f, -0.02403744f, -0.27765572f, 0.31720969f, -0.15954149f, -0.12651238f, 
    -0.20226179f, -0.36859256f, -0.19337402f, -0.31939057f, -0.27198535f, -0.00391892f, -0.05205352f, -0.15927069f, 
    -0.01115337f, 0.01339458f, 0.07037953f, -0.06919310f, -0.00118327f, 0.28296188f, -0.13661084f, 0.10495839f, 
    -0.28418487f, 0.20061094f, 0.03962356f, -0.24975005f, -0.03038031f, 0.00903231f, -0.16457699f, -0.39536047f, 
    -0.00126398f, -0.15918279f, 0.03096795f, -0.03371781f, -0.03582389f, 0.00419968f, -0.00835165f, -0.01597567f, 
    0.13594733f, 0.05341213f, 0.04883702f, -0.14623092f, -0.67282403f, 0.33969384f, 0.09973032f, -0.00172479f, 
    -0.36177444f, -0.51537889f, -0.06623705f, -0.05546654f, -0.00285729f, -0.21673620f, 0.02049875f, -0.03491757f, 
    -0.08382928f, -0.02165249f, 0.00710225f, -0.27214456f, 0.12481178f, -0.05675562f, -0.15967937f, 0.09028491f, 
    0.54016554f, 0.35150731f, 0.18639246f, -0.70153785f, -0.07156903f, 0.25089657f, 0.18298811f, 0.11688629f, 
    -0.06164122f, 0.14109865f, 0.02335114f, -0.08760802f, -0.08169249f, -0.02612515f, -0.03229974f, 0.00986361f, 
    -0.12460656f, -0.15298969f, -0.00253608f, 0.14291658f, -0.05364923f, -0.06320765f, -0.14571199f, 0.09621822f, 
    -0.00031744f, -0.04521527f, -0.03610049f, -0.03920620f, 0.11348277f, 0.01853045f, -0.10721479f, -0.01427029f, 
    0.02486548f, -0.07654149f, -0.16693383f, -0.19302107f, -0.19269527f, -0.36183387f, -0.12660612f, -0.05377033f, 
    0.30618858f, 0.45868745f, 0.23791407f, -0.22675176f, -0.03724037f, -0.22810774f, 0.00151858f, 0.00467052f, 
    0.22916797f, 0.00343321f, 0.06639651f, -0.04726410f, -0.04010674f, 0.02197430f, 0.02999343f, -0.05829572f, 
    -0.07671367f, 0.04389844f, -0.34747031f, -0.05746371f, 0.01642976f, -0.03782076f, -0.28101835f, 0.12029140f, 
    0.10199588f, 0.07691917f, -0.06590296f, 0.03003531f, 0.08174372f, 0.08340120f, -0.18224679f, -0.15007403f, 
    -0.23491898f, -0.41820601f, -0.06592443f, -0.06965507f, 0.08526073f, -0.05243811f, 0.04188530f, 0.02999019f, 
    0.25266808f, 0.32056573f, 0.11856765f, -0.07974085f, -0.05067807f, -0.03160056f, 0.11664233f, 0.16855423f, 
    0.00043749f, -0.09249074f, -0.03134099f, 0.18393974f, 0.02684461f, -0.01483035f, -0.04476032f, 0.00491082f, 
    -0.10885639f, -0.08284719f, -0.15874198f, -0.01670785f, -0.04738485f, -0.03642033f, -0.91360235f, -0.16522786f, 
    -0.15128063f, -0.33320364f, -0.14262353f, -0.06737409f, 0.00492761f, -0.25359419f, -0.24280170f, 0.17684408f, 
    -0.14017059f, -0.26096195f, -0.09632939f, -0.18049933f, -0.00199210f, -0.07995233f, -0.27077663f, 0.08775293f, 
    -0.14761202f, -0.15989068f, -0.20771524f, 0.03028090f, -0.09394380f, 0.04017654f, -0.02463976f, -0.02608869f, 
    -0.00127082f, 0.03052440f, 0.02891805f, 0.01520304f, 0.02608763f, 0.09836908f, -0.02555991f, -0.05847302f, 
    -0.15635297f, -0.04032629f, -0.01275265f, 0.06865999f, 0.74601716f, 0.34169149f, -0.38914314f, -0.19199416f, 
    -0.17338754f, 0.34363109f, 0.15213870f, 0.34293792f, -0.17818992f, 0.04782366f, 0.06584127f, 0.03212570f, 
    -0.06410395f, 0.04130550f, 0.08309862f, -0.05087319f, 0.14897646f, -0.01663689f, -0.00754062f, 0.06346061f, 
    0.05695494f, -0.90511489f, -0.95036316f, 0.23001081f, -0.24534194f, -0.03766248f, -0.01679934f, -0.03700897f, 
    -0.04027839f, 0.04178964f, 0.09388416f, -0.01432336f, -0.36176425f, -0.00782497f, -0.19440743f, 0.01836818f, 
    0.14755608f, -0.09860890f, 0.08192936f, -0.01620682f, -0.77422291f, 0.26268452f, 0.26068529f, -0.01889929f, 
    0.03793286f, -0.01444909f, -0.07639811f, -0.08993175f, 0.03986495f, 0.06988078f, -0.03253935f, 0.02692183f, 
    -0.00527970f, -0.02345807f, 0.08081502f, 0.05427891f, -0.01174732f, -0.00930909f, 0.12858509f, -0.05653208f, 
    0.69929391f, 0.51041263f, 0.18300909f, -0.59303057f, -0.01450901f, 0.27083775f, 0.35077983f, 0.21091093f, 
    0.07192761f, 0.11243975f, 0.04227031f, -0.03536059f, 0.03225568f, 0.02265973f, 0.08073822f, -0.00386870f, 
    -0.12591836f, 0.02449037f, 0.07626939f, -0.10091174f, 0.13183622f, -0.06357884f, -0.03286147f, 0.01538220f, 
    0.08128053f, 0.06392848f, 0.08222881f, 0.12146831f, 0.07160617f, 0.02868317f, -0.05117243f, -0.04902850f, 
    0.08345046f, 0.09377555f, 0.04464525f, 0.03785238f, 0.02579801f, 0.05562039f, 0.04335163f, -0.04428606f, 
    -0.08486848f, -0.19435006f, -0.07321657f, -0.08387852f, -0.01807447f, -0.10044944f, 0.03015412f, 0.04957446f, 
    0.00490951f, -0.01590191f, 0.13256875f, 0.09655058f, -0.15587761f, -0.01483107f, -0.14149778f, -0.10215276f, 
    -0.02660271f, -0.02244097f, 0.07228226f, 0.03878101f, -0.12051460f, 0.46958575f, -0.40056926f, -0.05094380f, 
    -0.28372493f, 0.22519860f, -0.09545527f, -0.12397868f, 0.02176299f, 0.08411865f, -0.08206511f, 0.10071541f, 
    -0.01064628f, 0.02416902f, 0.08519901f, -0.17943648f, -0.19804537f, -0.29679474f, -0.24737602f, -0.19050656f, 
    0.18625423f, -0.25057834f, 0.17752770f, -0.39908588f, -0.17942770f, -0.04016509f, -0.20558219f, -0.50949395f, 
    -0.07593361f, 0.11636402f, -0.03135400f, -0.02624953f, 0.05871030f, 0.05903438f, 0.04316169f, 0.08416961f, 
    -0.04172594f, -0.16756567f, 0.09735702f, 0.02573794f, -0.84767169f, -0.54933888f, -0.12524998f, -0.43491030f, 
    -0.41560093f, 0.03914439f, -0.02559252f, -0.23345079f, -0.09634043f, -0.06109807f, 0.06007427f, -0.03521848f, 
    -0.07746201f, 0.02197843f, -0.04786942f, -0.19699766f, -0.22013848f, -0.24373698f, -0.17023292f, -0.35853735f, 
    -0.20970662f, 0.31092930f, -0.23748858f, 0.00573318f, 0.32670987f, 0.00393159f, -0.06377576f, -0.15512618f, 
    0.27556154f, 0.04258017f, 0.01833162f, 0.01821014f, 0.06173120f, 0.03987353f, 0.17385437f, 0.05121574f, 
    0.05946844f, 0.17864411f, -0.18194422f, -0.11886599f, 0.16455236f, 0.05278139f, 0.01307812f, -0.01946343f, 
    -0.01082077f, 0.01987918f, -0.06418830f, -0.12272444f, -0.01454329f, -0.04187977f, 0.00485500f, 0.11013772f, 
    -0.05825680f, 0.19316688f, -0.00483451f, -0.11491765f, 0.19625758f, 0.12346802f, 0.07391031f, -0.03414889f, 
    -0.43489924f, 0.01342085f, 0.05453797f, 0.12100483f, 0.23477897f, 0.16541144f, 0.05223371f, -0.14471184f, 
    0.08763883f, 0.08230996f, -0.06375583f, 0.01709598f, 0.01255853f, 0.06893638f, 0.02286043f, -0.03376887f, 
    -0.04479457f, 0.05971061f, 0.02552890f, 0.05870668f, 0.30613187f, 0.08307470f, -0.01699387f, 0.19307840f, 
    0.11607182f, -0.08768480f, -0.04698792f, -0.05683632f, 0.04378000f, -0.15534322f, -0.10290396f, 0.17175801f, 
    -0.33653519f, -0.14352797f, 0.20422029f, -0.15297394f, -0.17369890f, -0.19986334f, 0.07210433f, -0.09063924f, 
    -0.27023450f, -0.03543494f, -0.08318544f, -0.03392516f, 0.00050419f, -0.21242067f, 0.36459485f, 0.13993995f, 
    0.30180633f, -0.18393683f, -0.17499423f, 0.05228527f, 0.00566865f, 0.14424407f, 0.03983200f, -0.00092987f, 
    -0.06082453f, 0.08100458f, 0.04358099f, -0.05024661f, 0.55606580f, 0.30421150f, -0.30245000f, -0.27310082f, 
    -0.56237918f, -0.21003115f, -0.14664151f, 0.07516417f, -0.05049456f, -0.00190796f, 0.11898183f, 0.06533036f, 
    0.07847996f, 0.03992004f, 0.14725438f, 0.02255902f, -0.08833845f, 0.10306089f, 0.35659543f, 0.13209768f, 
    0.40886071f, 0.01908656f, 0.04434972f, 0.08171077f, 0.23444651f, -0.13698713f, -0.01475166f, 0.04389359f, 
    -0.06647104f, 0.03978482f, -0.07054954f, -0.00588732f, -0.01301342f, -0.00348220f, 0.04998553f, 0.12210409f, 
    0.07764855f, -0.03850953f, 0.08690982f, 0.10639288f, 0.41366020f, 0.16732930f, 0.43278328f, -0.02458298f, 
    -0.20381443f, 0.16041006f, -0.20300433f, 0.22771949f, 0.11978782f, -0.45287430f, 0.15614533f, -0.18364695f, 
    -0.04813975f, -0.27082130f, -0.08915013f, 0.17644970f, -0.02310832f, -0.27047414f, 0.05102474f, 0.05107497f, 
    1.42029989f, -0.03158049f, 0.40823987f, 0.32953739f, -0.33951187f, -0.04624578f, 0.02529882f, 0.09994096f, 
    -0.04888078f, -0.00382867f, 0.19540693f, -0.24857011f, -0.04909228f, -0.19888254f, -0.06773382f, 0.14213975f, 
    0.02362535f, -0.18551065f, -0.00657216f, -0.03633057f, 0.35155481f, 0.32437769f, 0.22359374f, 0.20679653f, 
    0.48595509f, -0.05868364f, 0.00854470f, 0.03184911f, -0.04888664f, -0.00357319f, -0.03358027f, 0.01390896f, 
    -0.04539292f, -0.03031561f, 0.03886274f, -0.17357880f, -0.24561219f, 0.26159012f, 0.28599608f, -0.24242821f, 
    -0.30190945f, 0.21015507f, -0.07657305f, 0.46177945f, 0.07809098f, -0.04641895f, -0.20074271f, 0.37597036f, 
    -0.36537614f, -0.04179755f, -0.04849919f, 0.02050593f, -0.00197631f, -0.09459931f, 0.00442368f, -0.06577022f, 
    0.09594407f, 0.06381333f, -0.41333401f, -0.01908571f, -0.19884817f, -0.49657708f, -0.17738155f, 0.03731721f, 
    -0.15192626f, -0.01981317f, 0.04526280f, 0.09325682f, 0.01772915f, -0.16816919f, -0.12452978f, 0.10712584f, 
    -0.04002274f, -0.06028336f, -0.02912364f, -0.02338295f, 0.00574832f, -0.03956451f, -0.00324956f, -0.02776653f, 
    0.18583438f, 0.13362685f, 0.03562250f, 0.05967865f, 0.20814124f, -0.08164457f, 0.00322748f, 0.07890090f, 
    0.09029399f, 0.02672263f, -0.24712679f, 0.15359615f, -0.01387346f, 0.00399143f, 0.05320418f, 0.03550781f, 
    -0.14075758f, -0.07997326f, 0.03067518f, -0.03071212f, 0.43883720f, -0.02347896f, 0.48199001f, -0.42005727f, 
    -0.18806858f, 0.06393272f, 0.07860646f, 0.01124771f, 0.08879507f, 0.04078596f, -0.02448989f, 0.01203329f, 
    -0.00181586f, -0.01996838f, -0.00244141f, 0.24502078f, 0.04010847f, 0.20160456f, 0.28196555f, 0.15880774f, 
    -0.61027575f, -0.38558495f, 0.57281965f, -0.50122160f, 0.06156980f, -0.14689653f, 0.21018067f, -0.04748444f, 
    -0.24539055f, 0.26007780f, 0.10672981f, -0.02856201f, 0.01863786f, 0.01585761f, -0.05873892f, 0.01791876f, 
    -0.15179291f, -0.04671596f, -0.10856481f, 0.04816243f, 0.52756155f, 0.11238682f, 0.49052274f, 0.04004927f, 
    0.12447834f, -0.02128635f, 0.08537846f, 0.00815677f, -0.11035342f, 0.30032417f, -0.01670475f, -0.09984349f, 
    0.02119432f, 0.02036278f, -0.01787128f, 0.13910662f, 0.10210390f, -0.02110547f, 0.47326863f, 0.28074691f, 
    -0.34642071f, -0.49115673f, -0.63153172f, 0.17885509f, -0.68135732f, 0.10850087f, 0.13644794f, -0.11750139f, 
    0.27923721f, 0.09631785f, -0.04503173f, 0.00153287f, -0.06625980f, 0.00377731f, -0.11072630f, -0.10451769f, 
    -0.01842903f, -0.02176092f, -0.16702823f, 0.22646238f, -0.33322853f, 0.04859941f, 0.01686641f, -0.11669295f, 
    -0.00493656f, -0.00481513f, -0.06790265f, -0.07411428f, 0.02017216f, 0.12794156f, 0.02654314f, 0.02202089f, 
    -0.08492566f, 0.08551843f, -0.12112369f, 0.02052287f, -0.15711662f, 0.01139825f, 0.06707598f, -0.01759002f, 
    0.07125349f, 0.03499974f, -0.35131413f, 0.09792293f, -0.08326828f, 0.21502420f, 0.28600988f, -0.03970452f, 
    0.06203889f, -0.09139681f, -0.02482208f, 0.00587210f, 0.00435663f, 0.06250153f, -0.09474083f, 0.01017548f, 
    -0.07344361f, 0.02762896f, -0.14756423f, 0.14016940f, -0.05967135f, -0.41198212f, -0.23054811f, -0.28711560f, 
    -0.00533749f, 0.07223788f, -0.13393535f, 0.00320091f, 0.08980306f, 0.07987564f, -0.11326194f, -0.24642116f, 
    -0.07018907f, 0.23678751f, -0.02830647f, 0.13081574f, -0.02661920f, -0.07484998f, 0.11032049f, 0.04238927f, 
    0.12216688f, -0.10589056f, -0.13579623f, 0.03963553f, 0.09978071f, -0.00337988f, -0.10687858f, -0.41105381f, 
    -0.20266740f, -0.06350219f, 0.04513656f, -0.15816340f, 0.07932808f, 0.01387187f, -0.09952748f, 0.01528194f, 
    0.04069901f, 0.00486353f, -0.04837172f, 0.01172336f, -0.70425731f, 0.54717416f, 0.10207751f, -0.28662971f, 
    -0.52219576f, 0.05065872f, -0.32917029f, -0.42674649f, -0.14047046f, -0.11559004f, 0.13987523f, 0.19065228f, 
    0.07543737f, 0.06304955f, -0.10783628f, 0.11209633f, 0.22777732f, -0.09699079f, 0.04117209f, -0.04429721f, 
    -0.22044475f, -0.21635808f, -0.10909180f, -0.27534169f, 0.17853205f, 0.08867279f, 0.00252355f, -0.01618134f, 
    0.01883653f, 0.04941996f, 0.07708958f, -0.00285738f, -0.00899145f, 0.07172513f, -0.06882136f, -0.04028945f, 
    -0.34529096f, -0.03994919f, 0.10406191f, -0.02866455f, -0.03077784f, -0.65418935f, 1.41322494f, 0.85378182f, 
    0.50683057f, -0.02243564f, -0.22554825f, 0.00274239f, 0.29420948f, -0.09410008f, -0.01370699f, -0.03567370f, 
    0.02010074f, -0.06598701f, 0.04027662f, -0.06221522f, -0.05152246f, -0.05238602f, 0.00330643f, -0.15021677f, 
    -0.16258197f, 0.46482310f, 0.82504451f, 0.07393701f, 0.24485289f, 0.05229650f, -0.17477910f, 0.02056891f, 
    -0.01982279f, 0.16755800f, 0.13332306f, 0.09657462f, -0.11366165f, 0.05395798f, 0.21314164f, 0.03413660f, 
    0.10491091f, 0.15533842f, 0.13892151f, -0.09070065f, -0.05993191f, -0.36155605f, -0.39995000f, -0.09550904f, 
    -0.41449907f, -0.04381254f, 0.02756865f, 0.04628389f, -0.06518465f, 0.12923945f, 0.06560582f, 0.00087495f, 
    -0.07060577f, 0.15232655f, -0.05947597f, 0.07250362f, -0.06721852f, 0.30392635f, -0.03913470f, -0.45052934f, 
    -0.29772905f, -1.31826544f, -0.62644154f, 0.41550803f, -0.96201825f, -0.19903018f, -0.33693576f, -0.04568340f, 
    -0.06871034f, -0.18295707f, -0.03894612f, 0.04223796f, -0.03892497f, -0.03533471f, -0.06547049f, -0.06117591f, 
    -0.03844471f, -0.07328310f, -0.21357025f, 0.03119855f, 0.12929508f, 0.12086499f, 0.35609594f, 0.15271924f, 
    0.39665812f, -0.11439815f, 0.04480480f, 0.10896621f, 0.09312114f, -0.18111348f, -0.07794391f, 0.05604005f, 
    -0.11569708f, 0.00157358f, 0.05250956f, 0.09851139f, -0.08014242f, -0.03518448f, -0.05618081f, -0.01378314f, 
    0.67656863f, 0.27881503f, -0.30130610f, -0.41950440f, 0.36301309f, 0.00855477f, -0.21565774f, -0.04875803f, 
    -0.35959831f, -0.09656546f, -0.35699537f, 0.02739273f, -0.13365465f, -0.12888992f, 0.01483808f, 0.24610688f, 
    0.08790021f, -0.22124772f, 0.13886032f, 0.09267821f, -0.05884664f, -0.53269643f, 0.18092081f, 0.06148667f, 
    0.53335488f, -0.17461695f, 0.13960612f, -0.10116489f, 0.03184524f, 0.11532093f, -0.02086277f, -0.07730827f, 
    -0.19056250f, -0.23132807f, -0.01541292f, 0.15148465f, -0.14111437f, -0.02237341f, -0.00861108f, 0.19002156f, 
    -0.11635572f, -0.23164614f, 0.92232364f, -0.12681553f, 0.45080844f, -0.39344335f, 0.23109801f, -0.05278780f, 
    0.07789789f, -0.01977616f, 0.16053909f, -0.06177239f, -0.01180908f, -0.08494501f, 0.12474684f, -0.25364554f, 
    0.04407317f, -0.04630958f, 0.03413705f, -0.07016216f, 0.71092284f, 0.19203494f, 0.47003365f, -0.69625759f, 
    0.55014241f, -0.08685602f, 0.08395758f, -0.03530254f, -0.05639214f, -0.02324568f, -0.00418601f, -0.07881308f, 
    -0.00621068f, -0.06936244f, 0.02233850f, 0.02704075f, -0.05243782f, 0.13140859f, 0.15459701f, -0.06610655f, 
    -0.18062934f, -0.01829170f, -0.22531976f, 0.11791973f, 0.30776796f, 0.03999440f, 0.16806181f, -0.10441220f, 
    0.08694833f, -0.10649586f, -0.01539882f, -0.05272661f, -0.01029145f, -0.12228918f, -0.12260586f, -0.06318867f, 
    -0.04081934f, 0.20347880f, -0.40554354f, 0.05118675f, -0.94583911f, -0.25959781f, -0.16599378f, 0.18004331f, 
    -0.38728321f, -0.02502701f, -0.14235455f, 0.02348439f, -0.36482999f, -0.18167341f, -0.11910040f, 0.05815079f, 
    -0.22250810f, 0.10013317f, -0.12470714f, 0.24633515f, -0.06596134f, 0.26842359f, -0.15836142f, -0.33960557f, 
    0.33368886f, 0.01466386f, -0.20279567f, -0.28736749f, 0.34247658f, 0.12441245f, 0.14349613f, 0.01947910f, 
    -0.07437523f, 0.04951321f, -0.01205381f, -0.12136817f, -0.08636818f, -0.04323601f, 0.02201607f, -0.05745412f, 
    -0.16678575f, -0.25533488f, -0.03244804f, 0.05284274f, -0.44716972f, -0.12037200f, -0.38463399f, 0.15873198f, 
    -0.65090460f, 0.47181857f, 0.26136792f, 0.05324845f, 0.23181865f, 0.23856974f, -0.07937117f, -0.15309763f, 
    0.27976260f, 0.10660193f, -0.37726811f, -0.02604106f, -0.06702162f, -0.02314348f, 0.03184138f, -0.12349395f, 
    0.04578180f, -0.20754053f, -0.24686576f, -0.14877300f, 0.14151289f, 0.24023525f, 0.08119433f, 0.18915154f, 
    0.15377906f, 0.26513323f, 0.19520448f, -0.06377199f, 0.00199187f, -0.10649621f, -0.22424313f, 0.17579547f, 
    0.01345110f, -0.00168208f, 0.11614726f, 0.07104975f, -1.06010830f, 0.06280734f, 0.10862184f, 0.38434222f, 
    0.40360472f, 0.09035898f, 0.02053817f, -0.08659262f, -0.47009549f, -0.26192650f, -0.00554719f, 0.03778534f, 
    -0.00053643f, 0.09309010f, -0.22506835f, 0.08813123f, 0.18165237f, 0.15694262f, -0.15165123f, -0.32297257f, 
    -1.23306954f, -0.41339451f, -0.00904182f, 0.22710735f, -0.55606055f, -0.01846970f, -0.29048395f, 0.19625480f, 
    0.17582068f, 0.04208641f, -0.08557391f, -0.03036879f, 0.29700902f, -0.05680525f, -0.03699446f, -0.03191948f, 
    0.09975826f, -0.30040514f, 0.07426598f, -0.07527053f, -0.07588939f, 0.12191968f, -0.52755517f, 0.12227015f, 
    0.64797664f, 0.31909850f, 0.12962262f, -0.09566803f, -0.06660590f, 0.11264440f, -0.13975452f, 0.11462488f, 
    0.09980393f, 0.30537260f, 0.26331270f, -0.03137107f, -0.08197282f, 0.30074924f, 0.11272269f, 0.04837948f, 
    0.51487231f, 1.09348691f, -0.08720949f, 0.29408258f, 0.15603194f, 0.25279692f, -0.04707690f, 0.21005119f, 
    0.07584936f, -0.07228801f, -0.21109754f, -0.13964337f, 0.00024505f, 0.00705607f, -0.07120197f, -0.07877502f, 
    -0.08073756f, 0.00103170f, -0.07829676f, -0.07472712f, -0.41250348f, -0.73582023f, 0.25521711f, -0.26219261f, 
    -0.45339346f, 0.04623548f, -0.05505312f, 0.01628701f, 0.13257855f, -0.07284706f, 0.02217790f, 0.04454085f, 
    -0.14431469f, 0.03739195f, -0.14227359f, -0.17565373f, 0.07386415f, 0.08542838f, -0.38303185f, -0.00402609f, 
    -0.07977416f, -0.25270873f, -0.60181916f, -0.11989847f, 0.31220865f, 0.26728201f, 0.17912126f, -0.12513360f, 
    0.11332297f, 0.15017202f, -0.06299388f, 0.12897520f, -0.08688156f, -0.01584135f, -0.10463959f, -0.02395306f, 
    -0.10573933f, 0.04038889f, -0.11092266f, 0.06851850f, -0.05766710f, 0.28848529f, -0.36637890f, -0.23217167f, 
    0.35610178f, 0.41488275f, -0.02215568f, -0.04184298f, 0.16573641f, -0.48828954f, -0.26933920f, -0.09231334f, 
    -0.03760813f, -0.03185263f, 0.06454630f, -0.07385031f, 0.12138082f, -0.06809661f, 0.06104922f, -0.04729595f, 
    0.04192035f, -0.00673256f, 0.06864811f, -0.02167875f, 0.08788089f, 0.07056174f, -0.10294177f, 0.03981159f, 
    0.02572201f, 0.05397510f, 0.17322010f, -0.07807932f, 0.14572655f, -0.15916337f, 0.04630497f, -0.01867872f, 
    -0.11728010f, 0.08292356f, -0.21810496f, -0.03291230f, 0.04123690f, 0.07163403f, -0.05288149f, 0.01010796f, 
    -0.09867060f, 0.07939515f, -0.10391559f, 0.04675373f, 0.05009480f, -0.02550779f, -0.04252059f, -0.07247835f, 
    -0.08343747f, 0.03357082f, -0.12285838f, -0.06532121f, 0.17035834f, 0.07376347f, 0.24623698f, 0.21357965f, 
    0.21737888f, 0.11402503f, -0.26750496f, 0.55689901f, 0.43743250f, 0.21540295f, 0.17178796f, 0.10961289f, 
    0.00362067f, 0.07808210f, 0.09330098f, -0.00144289f, -0.02643894f, -0.05143250f, -0.02039159f, -0.11485956f, 
    -0.01134763f, -0.07369169f, -0.04442866f, -0.20417227f, 0.59918678f, -0.23553704f, -0.41993296f, 0.54986757f, 
    0.10238037f, 0.01542487f, 0.07242835f, 0.09027639f, 0.07533884f, 0.01926101f, -0.00785531f, -0.17726469f, 
    0.01102066f, 0.02812248f, 0.06536842f, 0.01997227f, 0.20693019f, 0.14130536f, -0.15080523f, 0.11027219f, 
    -0.11815510f, 0.07337040f, 0.32664520f, 0.13574474f, 0.03951882f, -0.25525329f, 0.07232262f, 0.04437735f, 
    -0.15167250f, 0.06652568f, 0.00380649f, -0.00004229f, -0.11550641f, 0.01491740f, -0.02925020f, 0.01254093f, 
    0.06756127f, -0.18994278f, 0.10044074f, 0.22669971f, 0.10628325f, 0.00246254f, -0.00688958f, -0.12145742f, 
    0.06573459f, 0.16840997f, 0.10714322f, 0.21907823f, -0.02410062f, 0.01394108f, 0.04910789f, 0.01757382f, 
    0.01872776f, -0.12058462f, -0.02304795f, 0.15916876f, -0.13896205f, -0.26246572f, -0.11379781f, -0.00017923f, 
    -0.15509884f, 0.15662836f, 0.10015275f, 0.24143504f, 0.03847061f, -0.10962724f, -0.03036634f, -0.01119613f, 
    -0.15248592f, 0.16301236f, -0.00053492f, -0.10117410f, 0.04951536f, 0.00454484f, 0.00755143f, -0.03680109f, 
    -0.09606593f, -0.06992294f, -0.22733516f, -0.38677475f, 0.26058292f, 0.18183444f, -0.02477987f, -0.14171098f, 
    -0.07755080f, 0.16499914f, 0.09320530f, 0.06661104f, 0.09292040f, 0.21048196f, 0.18518636f, -0.27217340f, 
    0.00806186f, -0.02550276f, -0.12389021f, 0.07732595f, -0.05523833f, -0.11413790f, -0.17842501f, 0.04783010f, 
    -0.00524494f, 0.15927871f, 0.10440052f, 0.16495724f, -0.04420632f, 0.16490513f, 0.14993355f, -0.24561705f, 
    -0.23216240f, 0.25142217f, 0.16836171f, 0.11727666f, -0.09144416f, 0.03262804f, 0.06218278f, -0.04156237f, 
    -0.08902050f, -0.11425886f, -0.26923743f, -0.13758142f, 0.41616702f, -0.31956089f, 0.14745158f, -0.54993331f, 
    -0.40625250f, 0.17064065f, 0.00921476f, -0.24833503f, -0.10815378f, -0.12305690f, 0.08381967f, -0.17655917f, 
    -0.05213999f, -0.13349082f, -0.21513008f, -0.23121884f, -0.09795418f, -0.52925682f, -0.35085455f, -0.36256585f, 
    -0.00088449f, 0.02529955f, -0.10862118f, -0.04722342f, -0.05035873f, 0.09175628f, 0.05386341f, 0.02076931f, 
    0.07651528f, 0.06780128f, 0.14557071f, 0.02690132f, 0.04749955f, 0.00621361f, 0.05651148f, -0.10205170f, 
    -0.04043870f, 0.09773968f, -0.16059405f, 0.12564312f, -0.21164279f, -0.33543620f, 0.20198859f, 0.32277507f, 
    0.24935040f, -0.38513744f, 0.04799575f, -0.18946500f, -0.17265277f, -0.02054396f, -0.10601872f, 0.06255013f, 
    0.09777731f, -0.01169910f, 0.12490699f, -0.06245481f, 0.12544012f, 0.08660933f, -0.00573942f, -0.01744818f, 
    -1.24569798f, -0.23473363f, -0.06228241f, -0.75580162f, -0.21105641f, 0.01151565f, 0.12638783f, -0.23015255f, 
    0.08364251f, 0.06314499f, -0.06029015f, -0.16601913f, -0.02480551f, 0.15366659f, -0.11311962f, -0.10722093f, 
    0.06416570f, -0.04136022f, -0.13396490f, 0.02486598f, -0.05173248f, 0.32889503f, -0.39628950f, -0.60174161f, 
    -0.31218782f, 0.00353534f, -0.02883709f, 0.02639290f, 0.15539807f, 0.04338712f, 0.13656187f, -0.02775870f, 
    0.04874840f, -0.02521995f, 0.00464200f, 0.23933178f, 0.01660423f, -0.13558571f, -0.31795397f, 0.22353773f, 
    0.06786112f, 0.36692882f, 0.34906408f, 0.27398974f, 0.25816053f, -0.35123590f, -0.09525308f, -0.04134624f, 
    0.06370030f, 0.21155384f, 0.06300218f, 0.07321923f, 0.03805573f, 0.05701846f, 0.14477864f, 0.00347738f, 
    -0.02083267f, -0.11641284f, 0.06941406f, -0.13549426f, 0.23857591f, -0.18663602f, 0.07399565f, -0.10638285f, 
    0.05028693f, -0.25225401f, -0.20157747f, -0.01697307f, -0.05518964f, 0.36584920f, 0.17418419f, 0.01232663f, 
    -0.14758256f, -0.14093488f, -0.08200186f, 0.12404705f, 0.02449595f, -0.01723899f, -0.05514820f, 0.03888008f, 
    -0.12393904f, -0.01702158f, -0.20357992f, 0.20643441f, -0.14802264f, 0.08824494f, -0.09959485f, -0.10907799f, 
    0.08006196f, 0.14976494f, 0.05652621f, -0.07102671f, -0.21015066f, 0.08750921f, 0.06892674f, 0.00488774f, 
    0.08223238f, 0.18929279f, -0.04833990f, 0.05344263f, 0.41291994f, 0.05229886f, 0.26781297f, -0.18303685f, 
    0.25857821f, -0.00570720f, 0.11340370f, -0.07422544f, 0.20949145f, -0.17506906f, 0.11813780f, 0.07178532f, 
    0.06578370f, -0.02358483f, -0.09654681f, -0.06909326f, -0.09780993f, -0.35072133f, -0.06285384f, -0.45509622f, 
    -0.34047329f, 0.20061451f, -0.32043040f, 0.28284559f, -0.20242983f, 0.00905383f, -0.31655613f, 0.18267857f, 
    0.03934667f, -0.02283791f, -0.02849353f, 0.06119070f, -0.09729443f, -0.05935340f, 0.00249811f, 0.05227124f, 
    0.01863639f, 0.33353731f, -0.14863965f, -0.07300591f, -0.46641511f, 0.48660830f, 0.33273694f, 0.30418023f, 
    -0.11223161f, 0.05045547f, -0.29416463f, -0.08636622f, 0.01690558f, 0.16793513f, -0.06626412f, 0.11851643f, 
    -0.08938362f, 0.01138563f, -0.08462788f, 0.06772193f, -0.43432692f, 0.14231576f, -0.06292770f, -0.01953104f, 
    0.31353971f, -0.07357708f, 0.54756814f, 0.24070969f, -0.41071588f, 0.09091734f, 0.09618814f, 0.10223131f, 
    0.02403744f, -0.13799742f, 0.13940655f, -0.03541784f, 0.02591978f, 0.04822328f, 0.02220692f, -0.05946705f, 
    -0.02245714f, -0.01724610f, -0.01794419f, -0.35608757f, 0.02703432f, -0.07185277f, -0.29294366f, -0.01749381f, 
    0.17764696f, -0.02847130f, 0.12550750f, -0.02654644f, -0.10232607f, -0.03217120f, 0.10592023f, -0.26939866f, 
    0.17841320f, -0.08962741f, 0.19490546f, 0.06328990f, -0.07943019f, -0.00136772f, -0.04371447f, 0.06019884f, 
    -0.05964383f, -0.10690139f, 0.32700309f, 0.12397683f, -0.50348908f, -0.02512136f, -0.04279951f, 0.09987316f, 
    0.01331692f, -0.13107932f, 0.02550366f, 0.01667076f, 0.00991348f, -0.04420022f, 0.04980206f, 0.04383776f, 
    0.10840370f, -0.04189630f, 0.09400025f, 0.25665036f, -0.04978770f, 0.00163319f, -0.41408944f, -0.25697494f, 
    0.14433277f, 0.05821816f, 0.07907727f, -0.08595246f, -0.16280524f, -0.08655470f, 0.38968325f, 0.06990662f, 
    0.08715747f, -0.07809570f, -0.01124447f, -0.06409504f, -0.01733067f, 0.34355068f, 0.07891060f, 0.08042293f, 
    0.06151436f, 0.03448106f, 0.23482633f, -0.21350214f, -0.12534885f, 0.04594325f, -0.35107210f, 0.04168507f, 
    0.10857664f, -0.12944281f, -0.09381462f, -0.08725967f, 0.01033142f, 0.00412876f, 0.01561232f, 0.03210231f, 
    0.09061749f, 0.08580408f, 0.03053405f, 0.22914515f, 0.12262047f, 0.02207433f, 0.06454150f, -0.68314630f, 
    0.37467131f, 0.14227352f, 0.31721288f, 0.02358855f, -0.07403753f, 0.01830922f, 0.01906354f, -0.22425927f, 
    -0.16835184f, 0.01348897f, 0.09802534f, 0.03768058f, 0.00913355f, -0.06580804f, 0.10669529f, 0.27008149f, 
    -0.01945806f, -0.05514535f, -0.14489616f, 0.22101611f, 0.19143057f, 0.15510058f, -0.00639281f, -0.05248806f, 
    -0.07981322f, 0.00383811f, 0.12786226f, -0.00728438f, -0.11739630f, 0.10270080f, 0.08436118f, -0.17229040f, 
    -0.00162460f, 0.19015157f, -0.09869584f, -0.24443153f, -0.84809828f, 0.33005723f, -0.22097328f, -0.55759537f, 
    -0.45766306f, -0.05858354f, -0.05955999f, 0.04607347f, -0.22346553f, 0.25672448f, 0.00874027f, 0.06483001f, 
    -0.08275640f, -0.00998407f, -0.09945563f, -0.15095027f, -0.09953094f, -0.04943819f, -0.07050799f, 0.00028077f, 
    -0.29894373f, -0.21321557f, -0.40017417f, -0.33820900f, 0.26317170f, -0.04396888f, -0.00738611f, 0.00643679f, 
    -0.04374973f, -0.16075346f, -0.02357461f, 0.11330202f, -0.02170004f, -0.08313436f, 0.15989381f, -0.23947144f, 
    -0.21242945f, 0.12371083f, -0.04287457f, -0.00578136f, 0.14261600f, -0.19090387f, -0.23161872f, -0.13366692f, 
    0.20964517f, 0.07039192f, 0.01535464f, -0.16305347f, -0.08203118f, 0.11393619f, 0.05642599f, -0.00754874f, 
    0.04370602f, 0.06355961f, 0.13446061f, -0.01907982f, -0.01499380f, 0.01737696f, 0.11362437f, 0.06434269f, 
    -0.00527205f, -0.05597875f, 0.43843794f, -0.02831132f, -0.22310691f, 0.32874736f, 0.23227108f, -0.10414140f, 
    0.24940144f, -0.28494006f, 0.15187773f, -0.07551037f, 0.08054619f, 0.19951750f, 0.02837192f, 0.01835736f, 
    0.02790203f, -0.09818465f, 0.10424881f, 0.29372221f, -0.37446466f, 0.21293649f, -0.65948641f, -0.04003221f, 
    -0.19392717f, 0.14853160f, -0.00337710f, -0.09352081f, -0.00179564f, -0.09207780f, 0.17916518f, -0.10496026f, 
    0.01203628f, 0.02183836f, -0.09755559f, -0.08964108f, 0.01051597f, 0.09981694f, -0.07772814f, 0.00789313f, 
    -0.40990731f, 0.13497229f, 0.44614846f, -0.06418838f, 0.01072441f, -0.19926126f, -0.10640581f, -0.08819284f, 
    -0.06951559f, 0.11746666f, 0.08819230f, 0.16241775f, 0.03823491f, -0.01024498f, 0.14408855f, 0.04670344f, 
    -0.07882391f, -0.12959717f, -0.00254137f, -0.09444487f, -0.60380125f, -0.46434098f, -0.17978396f, 0.17575197f, 
    -0.38505915f, 0.04926886f, 0.20160753f, -0.01513426f, 0.07023225f, -0.12583342f, 0.06105429f, -0.04384477f, 
    0.15394628f, 0.05100840f, 0.03882379f, 0.16714150f, 0.16567092f, 0.33170894f, 0.01287449f, 0.01577436f, 
    0.39186031f, -0.88215005f, -1.03982806f, -0.32003653f, 0.25403041f, 0.03129658f, 0.31231338f, 0.45876518f, 
    0.11006892f, -0.07290883f, 0.01521360f, -0.02639094f, -0.04493023f, 0.06148084f, 0.09701732f, -0.00411856f, 
    0.09802867f, -0.02793412f, 0.18463348f, 0.04106816f, -0.70055073f, -0.10211723f, -1.29388428f, -0.32394618f, 
    0.48484403f, -0.29201218f, 0.28033766f, -0.03619974f, 0.07251585f, 0.14515053f, 0.05554237f, 0.03248799f, 
    0.09780909f, 0.00975390f, 0.05059947f, 0.04370278f, 0.09217359f, -0.00158821f, 0.20527516f, -0.01473916f, 
    -1.11758947f, -1.06244421f, -1.50823724f, 0.17178066f, 0.26963475f, -0.24262163f, 0.12402483f, -0.31490612f, 
    -0.19439071f, -0.54001063f, -0.04054265f, -0.08504853f, -0.06299725f, -0.15092307f, 0.01906407f, 0.00489483f, 
    0.09085032f, 0.06572578f, 0.34775797f, 0.10239141f, 0.18429826f, -0.01341773f, -0.07768268f, -0.13890605f, 
    -0.07240420f, 0.03320644f, 0.06091730f, 0.14211720f, -0.04184859f, 0.03819515f, -0.09918216f, -0.11301028f, 
    -0.08683616f, -0.20036025f, -0.01702937f, -0.03650527f, -0.17992403f, 0.02067188f, -0.20606729f, -0.06658456f, 
    -1.03926027f, -0.63016790f, -0.45534921f, -0.51202816f, 0.20443267f, -0.03746748f, -0.07169274f, 0.09831509f, 
    -0.18590955f, -0.15633802f, 0.01204529f, 0.05101396f, -0.04569459f, -0.05805039f, 0.10778862f, 0.00529607f, 
    0.00052649f, 0.05424182f, 0.30365437f, -0.02558168f, -0.18149638f, -0.13619658f, 0.07388578f, -0.15901950f, 
    -0.21573702f, 0.09625982f, -0.09923149f, -0.02050124f, -0.21622056f, -0.02006556f, -0.07375833f, 0.15378374f, 
    0.22593473f, 0.09340651f, -0.02568556f, 0.18183592f, -0.06489178f, 0.12372191f, -0.31599000f, -0.04005462f, 
    -0.21455631f, -0.07204259f, 0.17767642f, -0.13862969f, 0.21839838f, -0.23070461f, -0.21224053f, -0.30088639f, 
    -0.09211065f, -0.13081060f, 0.14324342f, -0.20192270f, -0.10568967f, -0.02812483f, 0.11920732f, -0.03836971f, 
    -0.07239603f, 0.07529638f, 0.11526621f, -0.23863024f, 0.26214078f, 0.56363773f, -0.04192597f, -0.38441017f, 
    -0.12072360f, 0.14910543f, 0.15433164f, 0.03838950f, -0.01434865f, -0.13117458f, 0.11799026f, 0.17038542f, 
    0.03721406f, -0.18473929f, 0.31192866f, -0.05307548f, 0.09184120f, 0.20089035f, -0.18866688f, -0.16944656f, 
    0.05792101f, 0.02449409f, -0.02945963f, -0.05373395f, -0.04838351f, 0.06507511f, 0.06424466f, 0.07321484f, 
    -0.16866468f, -0.00877068f, -0.02856835f, -0.08393324f, -0.08418418f, -0.11410484f, -0.09737058f, 0.03343257f, 
    0.05682805f, -0.22973746f, -0.08713594f, 0.18122669f, -0.52074832f, -0.15911363f, 0.45765260f, -0.38407344f, 
    0.72471577f, -0.05296993f, -0.16393383f, -0.31955874f, 0.14914934f, 0.02885627f, -0.04856408f, 0.08492693f, 
    0.05141740f, 0.16820523f, -0.13943975f, 0.00655285f, 0.00970191f, 0.06256098f, 0.12293060f, -0.01782615f, 
    -0.28740823f, 0.35937589f, 0.08093493f, 0.02931346f, 0.48852277f, 0.00964326f, -0.07134239f, -0.01950831f, 
    0.08955877f, -0.07351971f, 0.28615758f, 0.02495307f, 0.34936583f, 0.03603302f, -0.03301919f, 0.15881388f, 
    0.04077478f, -0.05517630f, 0.15479396f, 0.12972733f, -0.09919842f, 0.30363664f, -0.25461066f, 0.02970026f, 
    -0.12674330f, 0.03571659f, 0.02994388f, 0.06678150f, 0.02148182f, 0.03682771f, 0.01981910f, 0.02279404f, 
    0.12247024f, -0.10751275f, -0.05939452f, 0.20624816f, 0.13460965f, -0.48105437f, 0.06991947f, 0.25271547f, 
    -1.11177754f, -1.28242719f, 0.03474900f, -0.25507253f, -0.27084187f, -0.19327545f, -0.19285466f, -0.18493046f, 
    -0.29559013f, -0.67381608f, -0.03116641f, 0.06364711f, -0.12615299f, 0.04794399f, 0.05477864f, 0.03197762f, 
    -0.08769115f, 0.10326449f, 0.15268740f, -0.12700140f, -0.74112421f, 0.36231241f, 0.54304963f, 0.04136820f, 
    0.17819127f, -0.15830265f, -0.10132594f, -0.14859469f, -0.12749250f, 0.38267133f, -0.41055104f, 0.04313300f, 
    0.22015202f, 0.01350265f, 0.16027839f, 0.00849569f, 0.01737673f, -0.19308132f, 0.04253057f, -0.05332119f, 
    0.42473602f, 0.22678609f, -0.31768405f, -0.09134736f, -0.21355546f, 0.10371097f, -0.02539106f, 0.07114356f, 
    -0.14555073f, 0.01464926f, -0.09043444f, -0.29440963f, 0.21861851f, 0.05515793f, -0.06610518f, 0.06708726f, 
    -0.08102497f, 0.03062931f, -0.05397064f, -0.14097336f, -0.00865019f, -0.26264104f, 0.22898224f, -0.17407992f, 
    -0.11748117f, -0.19748366f, -0.11826708f, -0.08839680f, -0.00221624f, -0.00077621f, -0.00727595f, -0.13462323f, 
    0.04862726f, -0.04212265f, -0.04159118f, -0.00735736f, -0.07068961f, -0.00125374f, -0.15009166f, -0.15481560f, 
    -0.38941911f, 0.06322900f, -0.15253197f, 0.20264713f, -0.40840095f, -0.04409932f, -0.04426811f, -0.13706174f, 
    0.18494196f, 0.09018985f, 0.07559231f, 0.01152909f, 0.04383456f, -0.00547714f, -0.06671140f, 0.10278252f, 
    -0.03783191f, -0.16579495f, 0.07610154f, 0.10379147f, 0.00905739f, 0.61429203f, -0.80531853f, 0.57681042f, 
    -0.73961258f, 0.17852393f, -0.00879279f, 0.05680220f, -0.29866529f, -0.04391702f, 0.01978966f, -0.02289970f, 
    -0.02295095f, -0.03039575f, 0.03832014f, -0.10864806f, 0.12550576f, 0.07737038f, -0.05997156f, 0.09423769f, 
    -0.51013285f, -1.07385492f, 0.18561429f, 0.75556290f, 0.38857308f, 0.01653727f, 0.13697311f, -0.10669090f, 
    0.14768171f, 0.11203785f, 0.07339682f, -0.03097371f, -0.11625492f, -0.19943793f, 0.03457379f, -0.08313464f, 
    0.10246108f, -0.12846078f, 0.14454152f, -0.07145673f, -0.07992351f, 0.01870707f, 0.10843640f, -0.01139459f, 
    0.02540930f, 0.02071010f, -0.05828054f, 0.00588430f, -0.00747123f, -0.01640161f, 0.06095374f, -0.09646558f, 
    0.01808820f, -0.01364895f, -0.08494768f, -0.02002084f, -0.05038527f, -0.05395581f, 0.04832601f, -0.01624639f, 
    0.03730138f, -1.12105751f, -0.47398421f, 0.85749120f, -0.29928461f, -0.05131311f, 0.03452927f, -0.09888991f, 
    -0.11053291f, -0.09341118f, 0.04847689f, 0.03023744f, 0.07768057f, 0.01414525f, -0.02970901f, 0.01915586f, 
    0.05401205f, -0.03769640f, -0.13603929f, -0.29173553f, 0.02567972f, 0.21688581f, 0.17697284f, -0.09097525f, 
    -0.09629632f, 0.05195864f, 0.00535551f, 0.10465932f, 0.06302854f, -0.05051151f, 0.13750443f, -0.42119384f, 
    -0.28576097f, -0.44353053f, -0.41211271f, -0.08372205f, 0.02647141f, 0.05759444f, 0.02970167f, -0.00204423f, 
    0.04517700f, -0.41259295f, -0.17597441f, 0.17220435f, -0.11821148f, 0.23726372f, 0.02484899f, 0.30364877f, 
    -0.03718735f, 0.20815596f, 0.20527159f, 0.04420286f, 0.06152289f, 0.09758467f, 0.06312760f, 0.02048610f, 
    0.04544504f, -0.11137366f, -0.10394613f, -0.12054656f, -0.07560434f, -0.61488068f, 0.70601654f, -0.70705068f, 
    0.64879656f, -0.03541743f, -0.10989954f, 0.24725740f, -0.11004552f, 0.10286483f, 0.04144123f, -0.10440493f, 
    0.03058459f, 0.04063496f, 0.06224034f, -0.00363885f, -0.05409775f, -0.09447949f, 0.17061645f, -0.26141849f, 
    0.01267232f, 0.13501468f, -0.00842871f, 0.07993400f, -0.21932662f, 0.02110114f, 0.00423618f, 0.01468786f, 
    -0.06663172f, -0.05432808f, 0.09985086f, 0.08189460f, 0.06961714f, -0.02951399f, -0.09171710f, -0.11177382f, 
    -0.22873780f, 0.10713375f, 0.06482773f, 0.02852366f, 1.16089308f, -1.84593141f, -0.87380594f, -1.51441324f, 
    -0.63993031f, 0.00041552f, -0.06300977f, -0.01558645f, 0.48487756f, 0.03681884f, 0.03038496f, 0.06483019f, 
    0.03175713f, 0.07659825f, 0.05397519f, -0.18550754f, -0.00580563f, -0.04082133f, 0.04849394f, 0.04930595f, 
    -0.30780911f, -0.06931416f, -0.37030298f, 0.10625435f, -0.20937631f, 0.06358551f, -0.04165991f, 0.26393279f, 
    -0.10135461f, 0.02053254f, -0.27828351f, 0.18048124f, -0.12431524f, 0.01291159f, 0.01429895f, 0.00437323f, 
    -0.01475394f, 0.01076593f, 0.13945885f, 0.16157882f, -0.17666210f, 0.08730248f, 0.24189214f, -0.10301816f, 
    -0.15781783f, -0.01645893f, 0.06771957f, 0.02932634f, -0.11038237f, -0.08259038f, 0.08782884f, 0.09914823f, 
    0.07455777f, 0.05193037f, 0.06147352f, 0.06443259f, 0.06783764f, -0.27542335f, 0.02887672f, 0.03047014f, 
    0.85303241f, -1.24450922f, 0.02378941f, -0.12782601f, -0.11894906f, 0.11932676f, 0.27648911f, -0.01469316f, 
    0.10950231f, 0.09580918f, 0.06227735f, -0.00341399f, -0.00345625f, -0.08283972f, 0.06006056f, 0.04871727f, 
    -0.00462834f, -0.07630713f, 0.13561288f, -0.05998747f, 0.59338737f, 0.23291537f, -0.28540385f, -0.33678350f, 
    -0.34701180f, 0.10162142f, -0.03087349f, -0.04229523f, 0.02094374f, 0.08862639f, 0.09518101f, 0.05086536f, 
    -0.01477209f, -0.03307627f, 0.10858183f, 0.01834915f, -0.02443659f, 0.00721341f, 0.08839910f, -0.06712123f, 
    0.09046002f, -0.17135456f, -0.33748195f, -0.20823218f, -0.20105383f, -0.15314293f, 0.19109017f, 0.12572215f, 
    0.05272152f, -0.03543976f, 0.27229396f, -0.08220837f, -0.04011799f, 0.00167466f, 0.04360669f, 0.00636374f, 
    0.12888449f, -0.02660647f, 0.21608375f, 0.10120155f, -0.23877223f, 0.07155226f, 0.40233746f, 0.15867105f, 
    -0.11038079f, 0.25715756f, -0.23704965f, 0.22901767f, -0.00173201f, -0.04464843f, 0.04782769f, -0.01134078f, 
    0.00913726f, -0.04289922f, 0.06231808f, -0.34684101f, -0.06761204f, -0.13818295f, -0.16403873f, -0.51887029f, 
    0.24136345f, 0.34418908f, 0.30422142f, 0.04200459f, -0.33845967f, 0.16234989f, -0.05686522f, -0.10706115f, 
    -0.09318794f, -0.37772325f, 0.00536542f, 0.03035016f, 0.07204963f, -0.06005954f, -0.08134940f, -0.05813828f, 
    0.11157583f, 0.10583756f, -0.00194779f, 0.05079329f, 1.23181319f, 0.28720227f, 0.21796754f, 0.12756918f, 
    0.00436566f, 0.24182174f, 0.31888908f, -0.08284026f, 0.14235501f, -0.17195047f, 0.13620619f, 0.06174206f, 
    0.10245326f, 0.01869425f, 0.02600458f, 0.36352533f, 0.01523870f, -0.25246957f, -0.10297642f, -0.21621856f, 
    0.53795940f, -0.34879494f, -0.40790284f, -0.15330823f, -0.15894201f, -0.06052220f, -0.39999026f, -0.19495419f, 
    -0.11873712f, -0.22605228f, 0.01019040f, 0.00533329f, 0.11612768f, 0.11164398f, 0.01452660f, 0.05239646f, 
    0.05361671f, 0.16203466f, -0.21001044f, -0.23804206f, -0.23921083f, 0.00504306f, 0.07806692f, 0.01043541f, 
    -0.13789089f, -0.05883206f, -0.03806080f, -0.13730031f, -0.02499975f, -0.00228110f, 0.02752346f, 0.01431787f, 
    -0.01705082f, 0.12822719f, 0.19040027f, -0.01614231f, 0.27385673f, 0.14874458f, 0.15997162f, 0.12702794f, 
    0.85877901f, -0.18989117f, -0.36523673f, -0.38210163f, -0.03535347f, 0.04131334f, -0.05407089f, -0.11870919f, 
    0.03553211f, -0.04480806f, 0.01452190f, 0.15143719f, 0.08099626f, -0.01345189f, -0.00734138f, -0.04302230f, 
    0.14130965f, 0.21400636f, 0.16213356f, 0.23025204f, -0.46950197f, -0.13575660f, 0.14784040f, 0.05515094f, 
    -0.35491395f, -0.21756935f, -0.07650639f, 0.02236989f, 0.04744662f, -0.06112890f, 0.11107641f, 0.20341939f, 
    0.08606382f, 0.09468592f, 0.23490973f, -0.07177319f, 0.04165696f, 0.00018470f, -0.03193780f, 0.05412523f, 
    0.31778863f, -0.12667218f, -0.27693671f, 0.00464495f, -0.07268861f, -0.19823781f, -0.09541839f, -0.21923742f, 
    -0.10852320f, -0.03055357f, -0.12484731f, -0.04103463f, 0.01399232f, -0.05630260f, 0.07419037f, -0.04935970f, 
    0.19357646f, 0.17802091f, 0.21157575f, 0.17344519f, -0.13172275f, -0.41819453f, -0.25041747f, 0.02841727f, 
    0.61240774f, 0.29895094f, -0.08344631f, 0.08323634f, -0.04407854f, 0.22584122f, -0.09747093f, -0.11405475f, 
    0.12596473f, 0.07096384f, -0.05676692f, -0.09556445f, -0.06907882f, 0.16911009f, -0.18645385f, 0.36517349f, 
    -0.57309687f, 0.29104918f, 0.24737133f, 0.05671724f, -0.19579594f, -0.18613562f, -0.09565314f, -0.18476030f, 
    0.01899178f, -0.00114892f, -0.15350010f, -0.06317909f, 0.02508136f, 0.00262285f, 0.04891120f, 0.02859099f, 
    0.10459288f, -0.05541651f, -0.05493156f, 0.01743080f, -0.07748377f, -0.79683155f, -1.68568563f, -0.66059917f, 
    0.17904282f, 0.03212762f, 0.12592462f, 0.27359128f, 0.13420431f, -0.08111812f, -0.18892470f, -0.14482096f, 
    -0.14599946f, -0.02026536f, 0.06007862f, 0.07364094f, -0.07351397f, -0.00809246f, -0.06311338f, -0.17379087f, 
    -0.41849989f, -0.48574755f, 0.52153200f, 0.08284713f, 0.30793864f, -0.22110055f, 0.01079210f, -0.11269005f, 
    -0.06825120f, -0.12661459f, 0.09465465f, 0.10518982f, 0.17074330f, 0.18396612f, 0.02424813f, -0.00128869f, 
    -0.03935612f, -0.14634791f, 0.03971539f, -0.14336599f, -0.49450630f, 0.45314553f, 0.29544422f, 0.13967310f, 
    0.09642719f, -0.02471861f, -0.12751549f, 0.06322626f, -0.12082871f, -0.09277682f, -0.06031078f, -0.07001326f, 
    -0.05884755f, -0.02453599f, -0.13237959f, -0.23008533f, -0.13693066f, -0.27692679f, -0.20406973f, -0.32760245f, 
    -0.35161325f, -1.01924694f, -1.22734094f, -0.41475639f, -0.26231569f, -0.00030744f, -0.29905945f, 0.08912225f, 
    -0.03417670f, -0.05586454f, -0.10256157f, -0.05250201f, -0.07521824f, -0.05539637f, -0.00657370f, 0.05727461f, 
    0.05899803f, 0.13731559f, 0.03638033f, 0.17512020f, -0.07825979f, -0.52447093f, -0.41700116f, -0.27260539f, 
    -0.04276766f, -0.15968104f, 0.12688223f, 0.19342092f, 0.16871475f, 0.03621427f, 0.18789241f, -0.03293049f, 
    0.05986426f, 0.00095965f, 0.02191124f, -0.03420161f, 0.07559919f, -0.05752025f, 0.10874821f, 0.00312311f, 
    -0.44029269f, 0.27467284f, 0.22673944f, 0.34305692f, -0.01835770f, 0.20883818f, -0.17938980f, -0.26654997f, 
    -0.30121943f, -0.14976896f, 0.02858416f, -0.05522750f, 0.02736531f, 0.00623693f, 0.05501815f, 0.04791583f, 
    -0.23050466f, -0.15171310f, -0.01534851f, -0.12281739f, 0.44883513f, -0.80927414f, -0.35687536f, 0.21453953f, 
    0.15766257f, -0.00975937f, 0.09857237f, 0.16337518f, -0.06847154f, 0.31719482f, -0.02968900f, 0.05532225f, 
    -0.04861266f, 0.02358408f, -0.00743104f, 0.03287744f, 0.09345962f, 0.12484256f, 0.09518643f, 0.23685880f, 
    -0.22808632f, 0.71948874f, -1.28129685f, 0.33772781f, -0.05846415f, 0.04997671f, 0.14948761f, 0.36894122f, 
    0.04948568f, 0.13875967f, 0.10544561f, -0.01360894f, -0.12241666f, -0.07254994f, -0.08557848f, 0.11763953f, 
    0.00492303f, -0.17801335f, 0.12555595f, -0.13013443f, -1.22485244f, 0.02826057f, -1.61730945f, 0.11615577f, 
    -0.41604194f, 0.09696416f, -0.24730748f, 0.25834790f, -0.34209478f, 0.08658330f, 0.05660827f, -0.04209991f, 
    0.07274652f, 0.06096150f, -0.03393009f, 0.15685420f, 0.13141967f, 0.03623976f, 0.04772313f, 0.08464758f, 
    0.01117381f, -0.27733514f, 0.28668609f, 0.16935541f, -0.49836788f, -0.02182463f, -0.50572455f, 0.15405807f, 
    0.03132585f, 0.24207494f, 0.01077050f, 0.09875344f, 0.09945466f, 0.06283986f, 0.01977656f, 0.04287822f, 
    0.05101901f, 0.05634087f, 0.25706705f, 0.15962589f, 0.05218250f, -0.17532602f, -0.08750831f, -0.11561901f, 
    0.07144716f, 0.11466126f, 0.12501390f, 0.02784109f, -0.01694053f, -0.10605074f, 0.14954461f, -0.03611347f, 
    -0.01513644f, -0.08162287f, -0.10718219f, 0.09771308f, -0.18418442f, -0.06002954f, -0.04689540f, -0.00479414f, 
    -0.03595141f, 0.18900216f, -0.16167411f, 0.13745417f, -0.42572179f, 0.06298099f, -0.25033566f, 0.06739239f, 
    0.13625793f, 0.07242426f, 0.01163088f, -0.09194117f, -0.03365464f, -0.10555467f, -0.07555123f, 0.10836330f, 
    -0.05553208f, -0.05298755f, 0.14649862f, -0.28199437f, 0.01717709f, -0.02948823f, 0.01198658f, -0.42612788f, 
    0.28568959f, -0.22744016f, -0.06233357f, -0.13382319f, 0.08747481f, -0.03551667f, -0.04134845f, 0.15487780f, 
    -0.06681100f, -0.15114115f, -0.06997530f, 0.22656684f, 0.23521300f, -0.13401376f, -0.15132493f, 0.14499092f, 
    0.00544991f, 0.14251864f, -0.03045860f, -0.01448760f, -0.09959362f, 0.00674082f, 0.02385191f, 0.03126381f, 
    0.04499805f, 0.00410972f, 0.10440803f, -0.02523817f, 0.07295939f, 0.00052543f, -0.13334541f, 0.13215612f, 
    -0.15834193f, -0.14213850f, -0.14688888f, -0.15821201f, 0.07705229f, -0.66097111f, 0.17164341f, -0.75582153f, 
    -0.62261993f, -0.10801897f, -0.43009812f, 0.09408185f, 0.16268416f, 0.31590620f, -0.12357547f, 0.00648457f, 
    -0.13742034f, -0.09383937f, -0.21146461f, 0.15341780f, 0.08749578f, 0.19195150f, -0.21851265f, -0.34919733f, 
    -0.26882094f, -0.14845632f, -0.32118320f, -0.20601797f, 0.28289440f, -0.05934705f, 0.17602083f, 0.22742561f, 
    0.02206384f, -0.02642651f, 0.12173960f, 0.04432987f, 0.03786315f, 0.06270626f, -0.04803992f, -0.03997286f, 
    0.11936276f, 0.11554673f, 0.05707441f, -0.04895303f, -0.09477000f, -0.09554859f, -0.02411045f, 0.56367517f, 
    -1.41587377f, -0.34479743f, 0.17013755f, -0.39754394f, 0.25199592f, -0.06711911f, 0.04285751f, -0.06857989f, 
    0.08167204f, 0.20449048f, 0.03049417f, 0.12739673f, 0.13704476f, 0.15208963f, 0.00438151f, 0.04654365f, 
    0.12591133f, -0.14149323f, 0.15561892f, -0.07217270f, -0.25689611f, -0.01729027f, -0.26452485f, 0.01534422f, 
    0.11815804f, -0.19455045f, -0.23001386f, 0.18999946f, -0.12511809f, -0.01890852f, 0.00936133f, 0.19203937f, 
    0.17775433f, 0.15151562f, -0.02462440f, 0.22148423f, -0.17483866f, -0.41406199f, -0.97205943f, -0.00536098f, 
    0.07000722f, -0.14187223f, 0.15613145f, 0.30498973f, -0.03021850f, -0.18946917f, -0.05248610f, -0.06527253f, 
    -0.07066682f, -0.02138205f, 0.04949119f, -0.06905123f, 0.29459018f, -0.20453671f, 0.06650820f, 0.21338804f, 
    -0.73061687f, -0.60631651f, 0.01093856f, 0.38989925f, -0.38240290f, -0.28871691f, -0.12350479f, 0.20615870f, 
    0.17979246f, 0.34238291f, 0.06320950f, -0.02226619f, -0.07046198f, -0.00399702f, -0.04908678f, 0.03743565f, 
    -0.02351496f, 0.10175507f, 0.08452330f, -0.20856625f, 0.08793235f, 0.44222000f, 0.60680383f, 0.77087212f, 
    -0.32788613f, 0.17401797f, -0.15876780f, -0.36876991f, -0.16456914f, -0.34179884f, 0.14682873f, -0.05070868f, 
    -0.02724064f, 0.06404746f, 0.13022487f, 0.11432042f, -0.02339084f, -0.18134798f, -0.03537945f, -0.00659828f, 
    0.67935205f, -0.34810612f, 0.34673297f, -0.24556626f, -0.07725830f, -0.08920436f, 0.06750465f, -0.03507971f, 
    0.31652820f, 0.02355965f, 0.01527905f, 0.02007490f, -0.13327903f, -0.07682612f, 0.12224407f, -0.05367385f, 
    0.18011680f, 0.08816040f, 0.26995668f, -0.07020149f, 0.09805665f, -0.18613954f, -0.26901042f, 0.18701553f, 
    -0.06486350f, -0.06026246f, -0.12338495f, 0.31002739f, -0.31683940f, 0.06641518f, -0.03967100f, -0.09708595f, 
    -0.13298978f, -0.00324320f, 0.05680940f, -0.04966307f, -0.20725195f, -0.20195782f, -0.43010849f, -0.14172542f, 
    -0.35852715f, -0.44148874f, -0.13463931f, 0.04282596f, -0.00073922f, -0.09859736f, -0.30887526f, 0.32019442f, 
    -0.40799451f, 0.00932486f, -0.10543520f, 0.18042664f, -0.11019591f, 0.03850828f, 0.03610266f, -0.02943012f, 
    -0.18149598f, -0.03005088f, -0.06033061f, 0.17083235f, 0.34565005f, -0.31234854f, 0.33251399f, -0.07059456f, 
    0.09246007f, -0.23586933f, 0.21423952f, 0.53336978f, 0.24571963f, 0.05795032f, -0.13833568f, 0.14161122f, 
    0.05356810f, -0.02944315f, 0.10021964f, -0.04372349f, -0.11034406f, 0.04554545f, -0.06319083f, -0.52490330f, 
    -0.78685403f, 0.01789242f, -0.52220094f, -0.16540629f, -0.04806927f, 0.18101284f, -0.16433963f, 0.09038817f, 
    -0.07875541f, 0.06714591f, -0.15214649f, 0.09259089f, -0.02914100f, 0.14592387f, -0.01785502f, 0.11984195f, 
    -0.16516538f, -0.22008318f, -0.14782652f, -0.07907765f, -0.35309377f, -0.33931291f, -0.09152340f, 0.07183140f, 
    -0.26829985f, -0.16058436f, -0.05100172f, -0.07343042f, 0.16755897f, 0.39395550f, -0.18619926f, -0.02139906f, 
    0.08913313f, -0.12270815f, 0.06252283f, -0.02670141f, -0.00855486f, 0.20174518f, 0.37127918f, 0.41419113f, 
    -0.38442910f, -0.05259095f, 0.20765832f, 0.03338517f, 0.32871103f, -0.07706601f, 0.05635149f, 0.21687475f, 
    0.13991013f, 0.12468714f, -0.11094202f, 0.22246090f, -0.17953995f, 0.12618031f, 0.05088622f, 0.17376645f, 
    0.11309041f, 0.02880987f, 0.12103786f, 0.16651668f, -0.16029485f, -0.39805299f, 0.51287019f, 0.20069109f, 
    -0.61334342f, 0.21415208f, -0.29041812f, -0.28232354f, -0.39161557f, 0.10412987f, -0.14083903f, 0.04016897f, 
    0.25888067f, 0.04344237f, -0.15196633f, -0.21817555f, 0.13728270f, 0.04773213f, -0.13270716f, 0.04203418f, 
    -0.40943372f, -0.11746670f, 0.21035044f, 0.05479931f, 0.20597860f, -0.05906306f, 0.22051987f, 0.14406481f, 
    -0.11315046f, 0.17812236f, 0.09793326f, 0.12449992f, -0.15864697f, 0.19356956f, -0.00953232f, 0.15901990f, 
    0.24651112f, 0.15743594f, 0.22280042f, 0.38922960f, -0.04740015f, 0.37663940f, -1.24024212f, 0.86082816f, 
    0.38921145f, 0.16776535f, -0.21465753f, 0.00694540f, 0.35083023f, 0.51617342f, -0.31619418f, 0.02188408f, 
    -0.15004119f, 0.14197062f, 0.33186632f, 0.16457705f, 0.07381967f, -0.32859737f, 0.25065902f, 0.29788557f, 
    0.05953873f, -0.38245735f, -0.00274984f, -0.56137174f, -0.51281846f, -0.20082046f, -0.27017841f, -0.08169759f, 
    -0.11246526f, -0.19229765f, -0.13991122f, 0.17048047f, -0.14612988f, -0.05342442f, 0.05593408f, 0.16087987f, 
    -0.00095713f, -0.15142097f, 0.02931816f, -0.13205871f, -0.32550475f, 0.03343424f, 0.01483042f, -0.04359807f, 
    0.17803821f, 0.10835865f, -0.28972837f, 0.07876064f, 0.14380088f, -0.04161505f, -0.24842906f, 0.08867901f, 
    0.05409538f, -0.25798699f, -0.47120789f, 0.08592438f, -0.02740538f, -0.06878443f, -0.00559715f, -0.25951001f, 
    -0.30085981f, 0.38196093f, 0.04069550f, 0.05159299f, -0.12706631f, 0.21011823f, -0.02440618f, -0.02052392f, 
    -0.04776209f, -0.01221613f, 0.18023534f, -0.02015346f, -0.05741911f, -0.02191340f, -0.16688721f, -0.32851574f, 
    -0.28028157f, -0.05273892f, -0.22818045f, -0.28270227f, 0.07584888f, -0.17347875f, 0.18074916f, 0.14590493f, 
    0.03486590f, -0.06017422f, -0.16256490f, -0.25269359f, -0.14086643f, -0.07250202f, -0.14861171f, -0.03390520f, 
    -0.11372296f, 0.08075108f, 0.08977663f, 0.12134775f, -0.22822013f, -0.00237344f, -0.21232000f, 0.20461436f, 
    -0.73784453f, -0.23523712f, 0.11607271f, 0.10466169f, 0.33327603f, -0.22772400f, -0.04039266f, -0.43971846f, 
    -0.08440293f, -0.08174826f, -0.05816251f, 0.12726720f, 0.15109672f, 0.15849741f, 0.13455316f, 0.14289898f, 
    -0.02665236f, -0.29006636f, 0.06582151f, 0.00264608f, 0.59832108f, 0.11806922f, 0.34448799f, -0.14952257f, 
    0.03260500f, 0.00086764f, -0.07923010f, -0.32577506f, 0.06765088f, 0.01535721f, -0.14848542f, 0.10953628f, 
    0.01407874f, -0.01464558f, -0.01515027f, -0.10157868f, -0.12276500f, 0.02287033f, 0.11429358f, -0.08565039f, 
    -0.24437392f, -0.17276919f, -0.17104746f, 0.11023684f, 0.24798374f, 0.17207396f, 0.13309844f, -0.09093057f, 
    -0.11751841f, 0.05344181f, -0.09507947f, 0.21371953f, 0.17498462f, -0.08130450f, -0.10524609f, 0.00178204f, 
    -0.05402015f, 0.10287118f, -0.25537038f, -0.04345466f, -0.09693472f, -0.26719588f, 0.21989889f, 0.26649848f, 
    0.11022797f, -0.07871421f, -0.15698382f, -0.09639882f, -0.04239712f, 0.07649729f, 0.01255750f, 0.11104622f, 
    -0.04392328f, -0.10318025f, 0.02434221f, 0.24579743f, 0.13845792f, -0.02442270f, 0.28419152f, 0.15473130f, 
    0.93183213f, 0.21076193f, 0.68749887f, -0.20807052f, -0.31922486f, 0.12219557f, -0.09906173f, -0.24189918f, 
    0.18057935f, -0.11893626f, -0.14154364f, 0.01679123f, 0.05597180f, 0.08841448f, 0.09024971f, -0.24078587f, 
    -0.01558578f, -0.20683539f, 0.04029834f, 0.28029376f, 0.34162217f, -0.74665958f, 0.33260351f, -0.44197160f, 
    0.42937964f, 0.11044915f, -0.28871745f, -0.32576707f, 0.22248225f, -0.03131020f, -0.07225354f, 0.18997884f, 
    0.02506650f, 0.25494701f, -0.07361440f, 0.15305936f, 0.10146912f, 0.10597039f, 0.00886876f, 0.10812473f, 
    0.31655288f, -0.46088466f, -0.26871967f, 0.07639890f, 0.23198472f, -0.11159129f, -0.29376593f, 0.34682286f, 
    -0.41893741f, -0.09911366f, 0.06849916f, -0.03096524f, 0.05308733f, -0.09614039f, -0.02105632f, 0.14799851f, 
    -0.08119397f, 0.13127598f, 0.19868764f, -0.07005764f, 0.14360657f, 0.16601613f, 0.01406728f, 0.36666951f, 
    -0.17047301f, -0.04674726f, 0.27840093f, 0.16646072f, 0.38495439f, 0.03464597f, -0.24447091f, 0.02816666f, 
    -0.06176763f, 0.03535477f, 0.01078699f, -0.05368605f, 0.04952638f, 0.10043178f, -0.30361965f, -0.12742375f, 
    0.05808575f, -0.74314237f, 0.01078292f, -0.08075619f, 0.31666434f, -0.12949894f, -0.23057899f, -0.09599387f, 
    0.01668824f, -0.20307024f, 0.02058630f, 0.10578329f, -0.04181456f, 0.03434544f, -0.15029033f, 0.13327087f, 
    -0.04639037f, -0.00526736f, -0.08868528f, 0.05748763f, -0.53637862f, 0.04896016f, -0.81296396f, 0.38772649f, 
    0.32101369f, -0.04040042f, 0.37557578f, -0.13543540f, 0.22086658f, 0.30095065f, -0.41647428f, -0.12416536f, 
    -0.04942542f, 0.30152997f, 0.05461304f, 0.10383129f, -0.02038726f, 0.11219364f, -0.09529395f, -0.23804556f, 
    -0.15106738f, -0.11653388f, -0.39507523f, 0.47787836f, 0.05663689f, -0.01236869f, -0.10508524f, -0.02444433f, 
    -0.43560958f, -0.02144477f, -0.02384289f, 0.02908280f, -0.06050133f, -0.16655372f, -0.12742460f, 0.15249047f, 
    -0.18277335f, -0.09601700f, -0.20312898f, -0.15792927f, -0.67116886f, -0.39646903f, 0.22105765f, 0.98118353f, 
    -0.38695818f, -0.18123797f, 0.26417997f, 0.19349705f, 0.16525491f, -0.03209165f, -0.14135273f, -0.05426672f, 
    0.22463602f, 0.27253732f, 0.01525795f, 0.00486037f, -0.10193230f, 0.31739151f, 0.07149818f, -0.14343585f, 
    0.28292704f, -0.03437269f, 0.01611624f, -0.04421109f, -0.06714169f, -0.00749069f, 0.00156871f, -0.04347305f, 
    0.01509691f, -0.09665366f, -0.14943758f, -0.11885270f, -0.07637649f, -0.19325097f, -0.05047442f, 0.20240441f, 
    -0.04388430f, 0.03501189f, -0.03714236f, 0.00465015f, -0.80513251f, -0.00155640f, -0.65071660f, 0.19260775f, 
    -0.86885184f, -0.21134232f, 0.06022161f, 0.04334839f, -0.24468060f, 0.10297676f, -0.05280519f, 0.00675369f, 
    0.14570537f, 0.10405821f, -0.01863806f, 0.08100647f, 0.20050173f, 0.14745133f, 0.00142029f, 0.16477938f, 
    -0.70877928f, -0.03601222f, -0.60584015f, 0.37543997f, -0.07604352f, 0.03082895f, 0.42988202f, -0.11510605f, 
    0.24854010f, -0.04219504f, -0.42217982f, 0.01620582f, 0.16329838f, 0.19553874f, 0.20983312f, -0.02411650f, 
    -0.19083267f, 0.12490075f, -0.10828633f, 0.21012589f, 0.60476112f, -0.36572552f, 0.32575640f, 0.13604605f, 
    -0.13100024f, -0.04534536f, -0.05952750f, -0.24616705f, 0.08741271f, -0.18897650f, -0.01115667f, -0.26054603f, 
    -0.02338079f, -0.01997256f, -0.18696691f, 0.02698891f, -0.01829579f, 0.14941365f, 0.06313435f, -0.11263308f, 
    0.10209254f, -0.46347642f, -0.09781484f, -0.25678146f, -0.18773934f, -0.13029805f, -0.53114986f, -0.21632344f, 
    -0.28563899f, 0.01066053f, 0.01539896f, -0.00889876f, 0.15303314f, -0.11971264f, -0.32829428f, 0.05356890f, 
    -0.01161881f, -0.00668868f, -0.02467101f, -0.10749100f, -0.58637822f, -0.16105896f, -0.06518325f, 0.13631660f, 
    -0.38340709f, 0.14843056f, 0.09809750f, -0.01205109f, -0.26395437f, 0.15630306f, -0.04847984f, -0.05707557f, 
    0.06907415f, 0.03269766f, -0.17246656f, -0.12147204f, -0.07562619f, 0.16147129f, -0.07564373f, 0.00911364f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33556855f, 0.27401948f, 0.14768222f, -0.21443592f, -0.13507001f, 0.02792907f, 0.04345439f, -0.23797677f, 
    0.10692755f, 0.10460359f, 0.06796049f, -0.04712950f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
