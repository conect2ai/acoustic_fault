#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.52177423f, -0.57765532f, -0.23955840f, -0.08562095f, -0.07292925f, 0.11247339f, -0.37532693f, -0.21207510f, 
    0.18648191f, -0.69400227f, -0.30594715f, -0.17805618f, -0.09660790f, -0.00433240f, 0.02126176f, 0.46267924f, 
    -0.53150505f, -0.53507012f, 0.16483186f, -0.06094489f, -0.09383557f, 0.36471730f, -0.58483547f, 0.49453995f, 
    -0.14839575f, -0.01015218f, -0.08093365f, -0.42779467f, -0.40884817f, -0.50981724f, 0.47411329f, 0.53021896f, 
    -0.15398115f, -0.32261732f, 0.24538904f, 0.19611855f, 0.22569861f, -0.58507389f, 0.37025133f, -0.19966802f, 
    0.12898590f, 0.49005017f, -0.25390965f, -0.33902669f, -0.31614283f, -0.37445861f, -0.55728501f, 0.88417929f, 
    -0.58795786f, -0.81900674f, -0.67607212f, 0.47752523f, -0.35059756f, -0.50599146f, -0.64988780f, -0.16543040f, 
    -0.48155496f, 0.48268431f, -0.48972872f, 0.03575695f, 0.46823347f, 0.36068511f, -0.01428513f, 0.11365128f, 
    -0.45118892f, -0.28437746f, -0.38900757f, -0.53636605f, -0.32602015f, -0.11163113f, 0.19344722f, -0.49559557f, 
    0.08405925f, -0.41181839f, 0.15125625f, 0.31906724f, 0.24543290f, -0.28102347f, -0.56810880f, 0.09397702f, 
    0.32110608f, -0.53048396f, -0.58381563f, -0.18786673f, -0.23219462f, -0.28181216f, -0.15437707f, -0.48013353f, 
    0.11645944f, -0.59582609f, 0.07582130f, -1.11758506f, 0.17805658f, 0.27962390f, 0.20629194f, 0.24685253f, 
    -0.06729331f, -0.50975364f, 0.37458676f, -0.29094064f, 0.27500221f, 0.44240221f, -0.47615781f, 0.35559613f, 
    -0.18620427f, -0.09932185f, -0.13697426f, 0.07585829f, 0.36435664f, -0.28502870f, -0.19592099f, 0.68492585f, 
    -0.68281448f, -0.17364180f, -0.42282978f, 0.19576746f, -0.64922744f, 0.19971737f, -0.12138753f, 0.38605016f, 
    -0.60509950f, -0.04359679f, 0.38802296f, 0.23862264f, -0.21940933f, -0.04505668f, 0.09866898f, -0.87744945f, 
    -0.72027630f, 0.25549492f, 0.33964685f, 0.18179180f, 0.21827807f, -0.07323619f, 0.18107310f, 0.29099947f, 
    0.57872498f, 0.03352137f, -0.56047457f, 0.23005849f, -0.37495676f, 0.02220203f, -0.36147001f, 0.43347529f, 
    0.22185314f, -0.79558671f, 0.08030778f, -0.66766250f, -0.49472073f, 0.13653447f, -0.14835364f, -0.33157307f, 
    0.32061559f, -0.59353966f, -0.48171049f, -0.38444126f, 0.01206990f, 0.50004953f, -0.24845272f, 0.01348194f, 
    0.51922303f, 0.02678713f, -0.03968832f, 0.58546358f, -0.43561524f, -0.42963925f, -0.60667634f, -0.74467903f, 
    -0.38189700f, -0.38540110f, -0.28126156f, 0.43054920f, 0.19681902f, 0.20410296f, -0.05019339f, 0.16613421f, 
    0.04083117f, 0.09677393f, 0.17189130f, -0.32652035f, 1.27227592f, -0.73341298f, -0.94206589f, 0.61113268f, 
    0.33925790f, -0.17224242f, -0.30280089f, 0.26854041f, -0.23462632f, -0.95983052f, 0.73114061f, -0.03362311f, 
    0.56335843f, -0.48172927f, -0.36998793f, 0.25052255f, 0.02440007f, 0.18896592f, -0.66685253f, -0.82290727f, 
    0.18212317f, 0.46397659f, 0.57015800f, -0.01562811f, 0.01026719f, -0.00486584f, -0.07008927f, -0.53171033f, 
    -0.52601385f, -0.58263612f, 0.31767067f, 0.39540872f, 0.59790999f, -0.45836636f, -0.34460527f, -0.63413620f, 
    0.51101220f, 0.13305621f, -0.61351150f, -0.27107495f, -0.07694776f, -0.42976367f, 0.10814583f, 0.42278767f, 
    0.42233148f, -0.17968363f, -0.44073144f, 0.15355103f, -0.88332099f, -0.24866763f, 1.03157413f, -0.22321551f, 
    -0.25264162f, 0.23291764f, 0.39689034f, -0.71185726f, -0.41910198f, -0.19389218f, -0.19320931f, -0.26786551f, 
    0.14487670f, 0.01043054f, 0.21069899f, -0.88109499f, 0.69957465f, 0.44794828f, -0.12025483f, -0.51246238f, 
    -0.11050236f, -0.48726642f, 0.55091065f, -0.54891026f, -0.22668585f, 0.16269314f, 0.00667635f, -0.12408140f, 
    0.22569518f, 0.06293674f, -0.43115503f, 0.23538300f, 0.20815735f, 0.46395138f, -0.03824404f, -0.29900005f, 
    0.07487009f, 0.28517729f, -0.46252403f, -0.03267602f, 0.12949812f, 0.21481426f, 0.49083015f, -0.33843070f, 
    0.30049580f, -0.43894315f, -0.36694425f, -0.22933960f, 0.26092255f, 0.27745467f, 0.41733783f, -0.64401132f, 
    -0.29518330f, -0.39406222f, -0.50745165f, 0.36127007f, -0.11451364f, 0.44428647f, -0.09500499f, 0.05394560f, 
    -0.40047577f, 0.07776069f, -0.13470806f, 0.42944512f, 0.61276186f, 0.07641844f, -0.31705904f, -0.26640776f, 
    -0.40136606f, 0.64239544f, -0.33944365f, -0.11058609f, 0.64651972f, -0.32946768f, -0.08332969f, 0.36470884f, 
    -0.08145697f, -0.33837923f, -0.21934201f, -0.35130903f, -0.00038298f, 0.30770516f, -0.75375110f, -0.31807986f, 
    -0.43682691f, -0.31112808f, -0.03893630f, -0.20979024f, 0.43506551f, 0.44556507f, -0.65241581f, -0.62292492f, 
    -0.14795747f, -0.11326664f, 0.41766977f, 0.42556071f, 1.24261820f, -0.15610310f, -0.55563247f, -0.38540486f, 
    0.04730077f, -0.48688847f, 0.15375482f, 0.17378630f, -0.04855407f, 0.46694091f, 0.34494716f, 0.58281314f, 
    -0.39357951f, 0.13063988f, -0.06451306f, -0.15879925f, -0.04533922f, 0.09334370f, -0.25689140f, -0.06531100f, 
    0.37586942f, -0.17801435f, 0.54885012f, -0.45383251f, -0.30543169f, 0.30458435f, 0.11203829f, 0.48670766f, 
    -0.44095966f, -0.31828019f, 0.16661309f, 0.30981320f, 0.19141953f, -0.10119002f, 0.25350693f, -0.22678292f, 
    -0.15802883f, 0.29906440f, 0.12348036f, 0.58430117f, -0.63184828f, -0.14603247f, 0.05838156f, -0.29895514f, 
    0.12368666f, 0.71976948f, -0.39490569f, -0.10665328f, -0.31297344f, -0.18232624f, 0.34181440f, -0.41645414f, 
    0.29241207f, -0.00263385f, -1.19203985f, 1.09197569f, 0.19472466f, -0.23751740f, -0.57826847f, 0.12793365f, 
    -0.17080900f, -0.02453887f, -0.43776667f, -1.11576402f, 0.65616232f, 0.64142334f, 0.35363889f, -0.30163178f, 
    -0.12398001f, -0.16686998f, -0.26857692f, 0.00318593f, 0.10763557f, 0.17536268f, -0.04024272f, -0.04487709f, 
    -0.06800871f, 0.00361566f, 0.26065707f, 0.19602077f, -0.41810188f, -0.40782014f, 0.71026927f, -0.83282399f, 
    0.64921188f, -0.58886653f, 0.33040783f, 0.26962507f, -0.36648804f, 0.10795499f, -0.06998114f, -0.05772685f, 
    0.07294113f, -0.23689015f, -0.30539203f, 0.40090173f, -0.01296841f, 0.17144117f, 0.11984640f, -0.75908101f, 
    -0.92903686f, 0.04529660f, 0.80673182f, 0.51583332f, -0.32752639f, -0.09708753f, -0.18153456f, 0.14649333f, 
    -0.51286614f, -0.20812955f, 0.79316443f, -0.30765429f, -0.54287326f, 0.72775739f, -0.48941997f, 0.21513560f, 
    0.27549237f, 0.03903250f, -0.39983064f, 0.61556727f, -0.48953655f, -0.42808029f, 0.51205581f, 0.41378686f, 
    0.16570604f, -0.33492786f, -0.37675172f, 0.24100229f, -0.11931988f, 0.13121268f, 0.11248643f, 0.08216770f, 
    0.25559852f, -0.18765241f, -0.17670599f, 0.35919282f, -0.86229497f, 0.28918242f, -0.53003389f, 0.16534640f, 
    -0.55539632f, -0.46047178f, -0.50480425f, -0.13065371f, -0.99794817f, -0.28397384f, -0.15085390f, 0.31069225f, 
    0.29611823f, 0.25984797f, 0.29128572f, -0.15633070f, 0.15462521f, 0.09401956f, -0.37367803f, -0.06908079f, 
    0.16466676f, 0.13957058f, 0.16560221f, 0.07663134f, 0.14290395f, -0.10774652f, -0.19191797f, -0.33708748f, 
    -0.56208020f, -0.57414770f, -0.70014697f, -0.78812492f, 0.37119782f, 0.11185141f, 0.25354224f, 0.01170262f, 
    0.27640516f, -0.35155943f, -0.12383924f, -0.00073046f, 0.07775016f, -0.21482792f, -0.03487985f, 0.39774424f, 
    0.01752238f, 0.33485535f, 0.20195767f, 0.16494504f, 0.31255010f, -0.00908264f, 0.20919089f, -0.20110896f, 
    -0.22694588f, 0.69517386f, -0.93405730f, 0.23624006f, 0.58820814f, 0.04201292f, -0.26752159f, -0.23336945f, 
    -0.17720537f, 0.00784941f, -0.10800381f, 0.40080938f, 0.05782101f, -0.19937165f, 0.37724262f, -0.13495110f, 
    -0.54595226f, 0.60451192f, -0.10416491f, 0.17131372f, -0.68757570f, 0.42112887f, -0.52344370f, -0.73742020f, 
    0.85770345f, -0.20378928f, -0.22448494f, -0.55841339f, 0.02751839f, -0.08452462f, 0.06263209f, -0.74069905f, 
    0.28551313f, 0.43003756f, -0.09271926f, -0.24787423f, 0.51688266f, -0.77108902f, -0.49323040f, -0.48954639f, 
    0.74380785f, -0.02431396f, -0.74109942f, -0.15747529f, -0.38353470f, 0.08041257f, 0.50650746f, -0.04086860f, 
    -0.71281016f, -0.08938895f, 0.50316900f, 0.23147321f, -0.08949227f, -0.33246970f, 0.09276697f, -0.43416333f, 
    -0.70848811f, 0.76878989f, -0.02553470f, 0.40053779f, -0.23270556f, 0.20316795f, -0.26008415f, -0.01887911f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06699888f, -0.01235598f, -0.02133393f, -0.09523515f, -0.13727412f, 0.13994539f, 0.25692913f, -0.15260383f, 
    0.02123580f, -0.42841384f, -0.00599403f, 0.13354486f, -0.05360768f, 0.30012965f, 0.05344991f, 0.06423149f, 
    0.07743821f, -0.14103703f, -0.21183163f, -0.20073314f, 0.09287661f, -0.04929147f, -0.07778279f, -0.32465222f, 
    -0.11153719f, 0.11514322f, 0.23351935f, -0.02792403f, -0.25998807f, -0.17000322f, -0.13850826f, 0.13053921f, 
    0.00918754f, 0.05424211f, -0.21051298f, -0.04176107f, -0.02023085f, -0.17953876f, 0.13490525f, 0.19834094f, 
    -0.01955701f, 0.07315242f, -0.05978089f, -0.00091792f, -0.17013541f, -0.02082813f, 0.12231720f, -0.26335841f, 
    0.09618163f, -0.12165342f, -0.17929113f, -0.28112841f, -0.07527851f, -0.28817296f, -0.13254370f, 0.06000701f, 
    -0.29848710f, 0.10948412f, 0.09871302f, -0.19485612f, 0.06931182f, -0.29029936f, 0.10741410f, -0.10318145f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20799726f, 0.13181654f, 0.01790686f, -0.10701913f, -0.01015269f, 0.09402174f, 0.13587323f, 0.13281810f, 
    -0.08433667f, 0.01331581f, -0.01721174f, -0.04507431f, -0.01463692f, -0.00334354f, 0.04136577f, 0.00920795f, 
    -0.00980651f, 0.01185339f, -0.04136542f, -0.08577175f, 0.26051196f, 0.07080368f, 0.06243521f, -0.17444624f, 
    -0.02651685f, 0.07495461f, 0.12562712f, -0.06891546f, 0.06885074f, 0.02154973f, 0.00128526f, 0.00338402f, 
    -0.04185624f, -0.07773236f, 0.05676768f, -0.03941508f, -0.05475054f, -0.04545731f, -0.07528096f, -0.00687995f, 
    -0.23577189f, 0.05282003f, 0.10389747f, -0.22798441f, -0.06058762f, -0.05247038f, -0.01080743f, -0.02769330f, 
    0.01345913f, 0.03189590f, 0.01836547f, 0.05525146f, 0.03445321f, -0.04692189f, -0.07079329f, -0.05058853f, 
    -0.21904436f, -0.11589265f, 0.08214457f, -0.01165945f, 0.11654911f, 0.02375367f, -0.42154935f, 0.04005291f, 
    0.07288051f, 0.10043235f, 0.05672532f, 0.08972801f, -0.12301371f, 0.07050455f, -0.05577653f, 0.02886679f, 
    0.00473257f, 0.02000124f, 0.01569154f, 0.00456286f, 0.06193274f, 0.01769816f, -0.00906626f, 0.01994023f, 
    0.02110792f, -0.07549627f, 0.29307175f, 0.06485802f, 0.07855167f, 0.00516771f, -0.01007083f, 0.02037669f, 
    0.02715574f, 0.06536089f, 0.04676964f, 0.04914183f, -0.01309213f, -0.00883935f, -0.03918529f, -0.08072874f, 
    0.03280938f, 0.04824780f, 0.05506924f, -0.02571145f, 0.24316779f, 0.21797957f, 0.13122331f, -0.50435823f, 
    0.00441341f, 0.05630770f, 0.13652910f, -0.10377009f, 0.05747470f, 0.06519833f, 0.06958681f, -0.04191647f, 
    -0.04246186f, -0.00399690f, -0.07264296f, 0.01108597f, -0.00192020f, -0.06863555f, 0.07845091f, -0.03108726f, 
    0.24213311f, 0.14899087f, 0.06478618f, -0.08558989f, 0.05064368f, 0.04757878f, 0.10075373f, 0.05723307f, 
    -0.11067051f, -0.12903625f, 0.01688084f, -0.12096138f, -0.01762927f, -0.03351642f, 0.01450326f, -0.07759252f, 
    -0.02058007f, -0.05790421f, -0.04195117f, -0.01808791f, 0.25811121f, 0.22477034f, 0.02153541f, -0.27515867f, 
    -0.08988504f, 0.15218286f, 0.11925422f, 0.12145235f, -0.00103972f, 0.15264042f, 0.00527511f, -0.03860172f, 
    -0.02342134f, -0.03116370f, -0.05417331f, -0.02470790f, -0.04102558f, -0.07593548f, 0.21052861f, 0.07945321f, 
    -0.06919592f, 0.01267011f, -0.05120196f, 0.03007152f, 0.02385387f, -0.03091429f, -0.08936045f, -0.01622207f, 
    -0.09715611f, 0.06565239f, -0.03209151f, -0.04128748f, 0.06131189f, -0.10374935f, 0.03978791f, -0.09487411f, 
    0.10139042f, -0.06065556f, -0.02770058f, -0.03796040f, 0.29226059f, 0.17197928f, 0.12183630f, -0.15781720f, 
    -0.02062145f, 0.14426325f, 0.19410652f, 0.21767108f, 0.02095560f, 0.10810044f, -0.01632164f, 0.00119434f, 
    -0.05378122f, -0.07707354f, -0.15724827f, 0.02861222f, -0.14566663f, -0.14886484f, 0.06571180f, -0.01275691f, 
    0.22565499f, -0.07904214f, -0.08623055f, -0.08174567f, 0.05639513f, 0.14900346f, 0.03511000f, 0.11090074f, 
    -0.06253913f, -0.10413840f, -0.10139768f, 0.06821263f, -0.02010317f, -0.00109184f, 0.00214052f, -0.02256188f, 
    0.11066132f, 0.06665820f, 0.02023695f, -0.04021779f, -0.20443913f, -0.05891651f, 0.10130683f, 0.04956890f, 
    0.10050932f, -0.04072026f, -0.12172135f, -0.07145327f, 0.03940736f, 0.00856448f, -0.01822729f, -0.01499352f, 
    -0.01989801f, 0.04128627f, -0.00684636f, -0.01279974f, -0.08044660f, 0.00356005f, -0.08812148f, -0.16432628f, 
    0.02381418f, 0.15354390f, -0.10633548f, -0.15149143f, 0.06268230f, -0.16346772f, -0.14591795f, 0.02110806f, 
    -0.17406373f, 0.04385098f, -0.01553303f, 0.01237181f, -0.02920642f, -0.04231041f, -0.05012207f, -0.02809985f, 
    -0.01392618f, 0.00287505f, -0.01059992f, 0.09041782f, -0.56682599f, -0.18928312f, 0.10683843f, -0.18913244f, 
    -0.10189470f, -0.06546848f, -0.02441247f, -0.09497920f, -0.05796237f, -0.00406061f, -0.02966780f, -0.03770593f, 
    -0.03391178f, 0.02599539f, 0.02848723f, 0.03856792f, 0.01752306f, -0.06019871f, -0.04832755f, -0.03027504f, 
    0.26930875f, 0.14870767f, -0.31318772f, 0.07726012f, 0.09696015f, 0.14260252f, 0.06437658f, 0.11497937f, 
    -0.07469153f, -0.09434774f, -0.04962010f, -0.00807168f, -0.15307027f, 0.00150431f, 0.00849199f, 0.05483327f, 
    0.09032003f, 0.00473261f, 0.04282789f, 0.02796091f, -0.24382706f, -0.19675080f, 0.05056652f, -0.02046304f, 
    -0.20591502f, 0.03115538f, -0.11268406f, -0.08240359f, -0.05293337f, 0.02838156f, 0.00462855f, 0.06598570f, 
    -0.01655500f, 0.03596500f, 0.01938731f, -0.10430383f, 0.01821389f, -0.10704442f, -0.12354636f, -0.10864508f, 
    0.16187926f, 0.18958041f, 0.16014622f, -0.35250661f, -0.03686222f, 0.06657157f, 0.06785832f, 0.10067028f, 
    -0.11063493f, -0.09238282f, -0.03980511f, -0.02587173f, -0.00504870f, -0.00358504f, -0.09889373f, -0.06770822f, 
    -0.00900080f, 0.00737740f, 0.08105988f, -0.15076451f, 0.25715676f, 0.23646912f, -0.16268778f, -0.06828099f, 
    0.07872965f, 0.14002374f, 0.07327518f, 0.13393632f, -0.12075243f, -0.13338976f, -0.03407263f, -0.05018343f, 
    0.00272702f, 0.01818560f, 0.01158137f, -0.00456964f, 0.02294891f, -0.00868761f, 0.00001790f, 0.04492522f, 
    -0.01095436f, 0.27766183f, 0.09285881f, -0.13888174f, -0.11771567f, -0.02308443f, -0.00473979f, 0.00883412f, 
    -0.01375104f, -0.00304061f, 0.00112611f, -0.06150645f, 0.00867078f, 0.00343232f, 0.04550059f, -0.07162052f, 
    -0.01252227f, 0.05588216f, -0.02832157f, 0.02613279f, -0.11844356f, -0.10489378f, -0.10809725f, 0.01029454f, 
    -0.02215870f, -0.00310371f, 0.02508329f, 0.03804743f, 0.00624053f, 0.05526765f, -0.04641607f, 0.04873043f, 
    0.05405821f, 0.03244000f, 0.05975171f, -0.08590313f, -0.16408508f, 0.04113431f, -0.00682933f, 0.00449718f, 
    -0.05812438f, -0.19713508f, -0.36300233f, 0.22344360f, -0.04697795f, 0.00880926f, -0.03828650f, 0.03776190f, 
    -0.21021518f, 0.03379237f, -0.01196949f, -0.05465261f, -0.19155367f, -0.18793686f, -0.00109696f, 0.00182795f, 
    0.06356191f, 0.03730696f, -0.01884232f, 0.09016902f, 0.11557003f, 0.18214507f, -0.02043297f, -0.06660390f, 
    0.01249340f, -0.25015828f, 0.05192100f, -0.04059156f, -0.02633203f, -0.22633655f, 0.10163441f, -0.19370101f, 
    -0.06909645f, -0.03397344f, -0.01819776f, -0.00742460f, 0.01647478f, 0.01124407f, -0.13161609f, -0.11233113f, 
    0.36013535f, 0.01761436f, -0.34120223f, -0.08393749f, 0.03645864f, 0.11549474f, 0.02556007f, 0.14339259f, 
    0.05735553f, 0.08207276f, 0.01759429f, 0.02378940f, -0.04531064f, 0.08290686f, -0.02786019f, 0.01149969f, 
    0.07578536f, 0.05137156f, 0.03585421f, 0.04763331f, 0.27616686f, -0.01550542f, 0.00014556f, -0.05867074f, 
    -0.06829788f, -0.00060613f, 0.08604896f, 0.13163438f, -0.08003178f, -0.04661340f, 0.05615960f, 0.05150259f, 
    0.04753793f, 0.05065775f, -0.05589296f, 0.05336278f, 0.06832597f, 0.09510002f, 0.02198498f, 0.03610151f, 
    0.13501859f, 0.12507483f, -0.11874934f, 0.02713114f, -0.04874070f, 0.02899049f, -0.04367835f, 0.00927288f, 
    -0.00101688f, -0.05524320f, -0.03234427f, 0.02400993f, 0.01070851f, -0.03081967f, 0.02698659f, -0.04206138f, 
    -0.03310978f, -0.03026970f, -0.10133169f, -0.10918525f, 0.00326888f, 0.11329540f, 0.23323791f, -0.11366044f, 
    0.05006121f, -0.06125605f, 0.04538334f, 0.03848739f, -0.08012141f, -0.13438380f, -0.06512119f, -0.00898394f, 
    -0.02042115f, -0.11233816f, 0.04966308f, -0.00642364f, -0.00629322f, 0.01363557f, -0.03268946f, -0.26800627f, 
    0.22901003f, 0.21816817f, -0.07088388f, -0.19031985f, -0.07156315f, 0.04090183f, -0.07089716f, 0.04598324f, 
    -0.08565775f, -0.03778249f, -0.02085985f, -0.00497418f, -0.02190342f, 0.00918011f, 0.03971452f, -0.01100655f, 
    -0.02613585f, -0.02933915f, -0.00058770f, 0.04578804f, -0.27279481f, 0.30744052f, 0.06108436f, -0.22643971f, 
    -0.15238202f, -0.11258484f, -0.02163127f, -0.08196381f, 0.04201641f, -0.10145139f, -0.00674955f, -0.01001309f, 
    -0.04444282f, -0.03574277f, -0.03679724f, -0.08732386f, 0.09762255f, -0.10725252f, -0.11701332f, 0.12608999f, 
    -0.05049074f, -0.07578367f, 0.07125940f, 0.03094713f, 0.05978265f, 0.02751576f, -0.00180722f, 0.01478594f, 
    0.05584236f, 0.05158042f, -0.09995445f, 0.01321568f, 0.09404735f, -0.09512512f, -0.06493493f, 0.00306671f, 
    -0.02196076f, 0.03475535f, -0.03728052f, -0.00274810f, 0.00389436f, -0.03457627f, -0.04241419f, 0.05933266f, 
    0.06304311f, 0.03462250f, 0.00148257f, -0.00610216f, 0.07764077f, 0.04522607f, -0.11798936f, -0.09249010f, 
    -0.18944407f, -0.03317250f, -0.09260589f, -0.13248546f, -0.02521616f, -0.20106196f, -0.03369527f, -0.00347963f, 
    0.06279193f, 0.07471889f, 0.04803634f, -0.09616685f, -0.03569169f, -0.17911085f, -0.02498524f, -0.05007172f, 
    0.03211243f, -0.03843258f, 0.00735513f, 0.05206800f, 0.05839108f, -0.04476009f, 0.02361912f, -0.02190478f, 
    -0.02544481f, -0.03571961f, -0.12090900f, -0.01212401f, 0.17847417f, 0.20593496f, -0.06661519f, -0.21224619f, 
    -0.14267454f, 0.03961768f, 0.04172107f, 0.07618073f, -0.03342776f, -0.08945566f, -0.01734899f, -0.02186061f, 
    -0.05156484f, -0.00763979f, 0.03689031f, 0.02382459f, -0.05128930f, -0.05070225f, -0.01244987f, 0.04674162f, 
    0.19222833f, 0.04496981f, -0.15846100f, -0.03294818f, -0.25263762f, -0.02500333f, 0.02566855f, 0.02544527f, 
    0.03141609f, 0.03258984f, -0.00993278f, 0.09465882f, -0.06301444f, 0.05327813f, 0.01301988f, -0.01896986f, 
    -0.00500478f, 0.09893095f, -0.05710794f, 0.02120801f, -0.21961020f, -0.22582187f, -0.21835123f, 0.01559073f, 
    -0.04744613f, -0.04864881f, -0.02784225f, 0.03048729f, 0.01094236f, 0.03757240f, -0.09266537f, 0.01607449f, 
    0.00446885f, -0.02886970f, -0.01690355f, -0.17472267f, -0.12596633f, 0.00133215f, -0.04409740f, -0.01228167f, 
    0.25435153f, 0.23894402f, 0.02601076f, -0.16728608f, 0.01560581f, 0.06834016f, 0.09291262f, 0.05116415f, 
    -0.03463634f, 0.02814200f, -0.00488281f, 0.00074458f, 0.02061766f, -0.10361573f, -0.14117323f, 0.00320190f, 
    -0.12806958f, -0.04872269f, 0.00660036f, 0.07243872f, 0.01921771f, 0.08963458f, 0.09271213f, -0.10117735f, 
    -0.06337903f, -0.07217807f, -0.04665774f, -0.11536160f, -0.05193980f, -0.13317350f, 0.06544809f, -0.00539347f, 
    0.01566773f, -0.00331575f, -0.06741744f, -0.06484249f, 0.02109840f, 0.02715962f, -0.02486772f, -0.04714556f, 
    -0.10887997f, 0.10540779f, -0.43241721f, -0.11646180f, -0.13470532f, -0.16321951f, -0.13685383f, -0.02776681f, 
    -0.06423253f, -0.12822749f, -0.05340899f, 0.00139377f, 0.03577368f, 0.02962612f, 0.03978030f, -0.09355682f, 
    -0.03654771f, -0.07368366f, -0.22559367f, 0.06965291f, -0.17109543f, -0.09218556f, -0.06131942f, 0.02941244f, 
    -0.02167447f, 0.01595411f, -0.01675951f, -0.00690518f, 0.04236642f, 0.03354860f, 0.04303339f, 0.00349510f, 
    0.04583817f, 0.04635278f, 0.06201319f, 0.06574517f, 0.10053089f, -0.03223648f, -0.05184488f, -0.02649700f, 
    -0.03418698f, -0.11212581f, 0.03204848f, -0.02102015f, -0.05654056f, -0.07212268f, -0.06898776f, -0.00288599f, 
    0.02987082f, -0.01723377f, -0.08032584f, -0.08395780f, -0.03994067f, -0.22343534f, -0.20585459f, -0.05402742f, 
    -0.15151572f, -0.06889406f, -0.01166985f, -0.01107319f, -0.11879419f, -0.16846298f, -0.20635939f, 0.08675732f, 
    0.02742386f, 0.05291545f, -0.06078518f, 0.01779914f, -0.03514840f, 0.03706525f, -0.01100490f, -0.04718121f, 
    -0.20535038f, -0.16665773f, -0.09026401f, 0.01714128f, 0.04451806f, 0.01148062f, -0.05575832f, -0.00594754f, 
    -0.27101898f, 0.27140218f, -0.24425986f, -0.02062860f, -0.02225804f, -0.15564111f, -0.09618534f, -0.06667741f, 
    0.08689088f, 0.06281640f, -0.02828137f, -0.01500222f, -0.00114471f, 0.03780948f, 0.00472037f, -0.09231246f, 
    -0.00543810f, -0.11115272f, 0.01427438f, -0.03029008f, -0.56041104f, 0.01062425f, 0.07121260f, -0.09894651f, 
    -0.14254096f, -0.20387132f, 0.03101123f, -0.05124582f, -0.11561970f, -0.02766019f, 0.01371361f, 0.00890858f, 
    -0.07417621f, 0.00820617f, 0.08441401f, -0.08778939f, 0.02140508f, 0.03628564f, 0.05597476f, -0.02179221f, 
    -0.32225940f, 0.35311857f, 0.23173094f, -0.08031216f, -0.05833181f, -0.29880548f, 0.04503199f, -0.05810237f, 
    0.08001162f, -0.10810199f, 0.01732124f, -0.05299972f, -0.03676989f, 0.00206298f, 0.02544564f, -0.09565194f, 
    0.17562574f, -0.02649870f, -0.14818308f, 0.13982657f, -0.32612398f, 0.23514749f, -0.17330362f, -0.11910721f, 
    0.14937408f, -0.05617552f, -0.11961500f, 0.04044470f, 0.03679394f, 0.00895338f, -0.01410869f, 0.04972195f, 
    -0.01200182f, 0.01019049f, 0.02280304f, 0.06621815f, -0.00291541f, 0.02267198f, -0.00730677f, 0.10083595f, 
    -0.11858200f, -0.05023437f, -0.04104377f, 0.00652619f, -0.02287248f, -0.03747964f, -0.00095645f, -0.01346236f, 
    0.01169464f, 0.06493893f, -0.06510168f, 0.05325365f, -0.01258359f, 0.04865086f, 0.01872524f, -0.06287297f, 
    -0.12978317f, -0.01417243f, -0.08067855f, -0.01251948f, -0.23886175f, -0.27571967f, -0.23648487f, -0.19379793f, 
    0.05227954f, -0.06284536f, 0.14861847f, 0.02288256f, -0.03879694f, -0.00460256f, -0.16066372f, 0.06335993f, 
    0.02453033f, -0.15113464f, 0.02625693f, -0.00911388f, 0.02655775f, -0.07218645f, -0.06884582f, -0.09636382f, 
    -0.03819305f, -0.00806473f, 0.06026207f, -0.02343676f, 0.01237017f, -0.06105603f, -0.01594859f, 0.05964746f, 
    0.00333101f, 0.01403500f, -0.01081170f, -0.03171686f, -0.01136838f, -0.03961645f, 0.00685775f, -0.04409217f, 
    -0.10225894f, -0.02803734f, -0.00182122f, -0.09640327f, 0.47315204f, 0.17024918f, -0.43818983f, -0.18959318f, 
    -0.00626235f, 0.09920254f, 0.09172666f, 0.09716797f, -0.10451911f, 0.03728652f, 0.01847345f, 0.02047934f, 
    -0.08041494f, 0.10330623f, 0.05709926f, 0.01167850f, 0.08755518f, 0.10217681f, -0.00856099f, 0.00071757f, 
    -0.48290139f, -0.18291071f, 0.41261727f, -0.09354489f, 0.09302282f, -0.24482961f, -0.03751696f, 0.00690195f, 
    0.01394295f, -0.06908572f, 0.07992021f, -0.20013963f, 0.04766215f, -0.08825607f, -0.10446854f, -0.16983090f, 
    -0.09425374f, -0.02798428f, -0.01684624f, -0.09980024f, -0.17312190f, 0.10387070f, 0.23328842f, -0.20633678f, 
    0.09953577f, -0.11402342f, 0.03219460f, 0.03161182f, -0.13947999f, -0.04880148f, -0.01112264f, 0.01875493f, 
    -0.05392354f, 0.08448505f, 0.00963132f, 0.01859227f, -0.03353794f, -0.03079031f, -0.23098473f, -0.03762425f, 
    -0.01814958f, 0.01305356f, 0.02895384f, -0.00184318f, 0.00877518f, 0.00278373f, 0.01178650f, 0.03502526f, 
    0.01840870f, 0.01191203f, -0.06049576f, -0.06831465f, -0.07357846f, -0.04129815f, -0.01736105f, -0.01525480f, 
    0.01674358f, 0.04535952f, -0.02216303f, -0.06381696f, 0.25487319f, 0.06226217f, 0.12590326f, -0.17533560f, 
    -0.03032987f, 0.09937324f, -0.10084570f, 0.10798056f, -0.15274245f, -0.03659729f, -0.01895528f, 0.03736677f, 
    0.00519234f, 0.00183573f, 0.01539621f, 0.01153099f, -0.16130547f, 0.13184480f, 0.13660707f, 0.10567131f, 
    0.22712408f, 0.11100390f, -0.01856568f, -0.07193793f, 0.07929170f, 0.07011828f, 0.10698725f, 0.09854332f, 
    0.10155839f, -0.07263350f, -0.01504141f, -0.02885070f, -0.09254324f, 0.02007879f, 0.07142674f, 0.04129893f, 
    0.04546849f, 0.05785640f, 0.01170681f, -0.02067586f, 0.04172431f, -0.00621251f, 0.00476152f, 0.01807243f, 
    0.06379531f, 0.02489450f, 0.04673940f, 0.00923398f, 0.04571882f, 0.05178650f, -0.11342090f, -0.14891736f, 
    -0.15018846f, -0.00748621f, -0.04136298f, 0.01469070f, 0.05129602f, 0.02924933f, 0.01076882f, 0.00198847f, 
    0.38951895f, 0.31145665f, 0.01128787f, -0.39039570f, -0.19001530f, 0.11801758f, 0.09184571f, 0.03091330f, 
    0.09861766f, 0.09723997f, 0.07254397f, 0.00033214f, -0.00881690f, 0.01228454f, 0.01309249f, 0.00885771f, 
    -0.01456576f, 0.01502314f, 0.11863547f, 0.02075543f, -0.03929481f, -0.01835730f, -0.02145417f, 0.01731170f, 
    -0.05959811f, 0.04550778f, -0.04748372f, 0.00465054f, -0.07594144f, 0.00103982f, -0.02479536f, -0.08800043f, 
    -0.04215030f, 0.04294664f, 0.05477291f, -0.06625006f, -0.07858817f, -0.04875518f, -0.09693448f, -0.05614487f, 
    -0.04092309f, -0.06821114f, -0.07668035f, -0.00302781f, 0.01317822f, 0.00034450f, 0.02229626f, 0.02588038f, 
    0.01915623f, 0.05926762f, 0.02492543f, 0.06470101f, 0.08104916f, 0.13279042f, 0.00364482f, -0.06810176f, 
    -0.13595200f, 0.09076900f, -0.02702223f, 0.03873961f, 0.10376270f, -0.32183382f, -0.30014285f, -0.01580922f, 
    -0.01941657f, -0.03186418f, -0.07133345f, 0.04848992f, -0.03425882f, 0.04989132f, 0.00159262f, 0.02358941f, 
    0.03942038f, 0.05759386f, 0.00842960f, -0.13109243f, 0.15216416f, -0.02906510f, -0.16980566f, -0.04643763f, 
    -0.28110677f, -0.28238747f, -0.02347656f, 0.03078826f, -0.12662394f, 0.05459910f, -0.05019632f, 0.02642204f, 
    0.03613806f, 0.00877716f, -0.06803480f, 0.06859105f, 0.00220391f, -0.13539082f, -0.06776899f, -0.14443108f, 
    -0.00517574f, -0.00703618f, -0.06566035f, 0.03201699f, 0.16127720f, 0.28231773f, 0.35281014f, -0.25778162f, 
    0.07867470f, -0.15119559f, -0.14227320f, 0.04842483f, -0.14024629f, -0.13699639f, 0.03941290f, -0.02564890f, 
    -0.11594083f, -0.00202370f, -0.05801975f, 0.19435053f, -0.09435377f, -0.08726727f, -0.01227058f, -0.11817735f, 
    -0.20648552f, 0.02436654f, 0.19659634f, 0.08769871f, 0.01804385f, -0.00634767f, -0.16762432f, 0.06891151f, 
    -0.00356362f, -0.01273543f, -0.06891420f, -0.12767729f, -0.01921041f, -0.11320563f, -0.04076455f, -0.02213199f, 
    -0.07012042f, 0.02117110f, -0.15067896f, -0.12082961f, 0.33890000f, 0.18866944f, -0.10565431f, -0.17486300f, 
    -0.05594335f, 0.06309864f, 0.10777852f, 0.15903676f, -0.00098267f, 0.03415443f, 0.00920127f, -0.04475732f, 
    0.00877756f, 0.00581867f, 0.09206849f, 0.03371637f, 0.01572727f, 0.00590009f, -0.04593870f, -0.07295176f, 
    -0.19659996f, -0.06204904f, -0.26319078f, 0.06254915f, -0.04474237f, -0.02534673f, -0.01914421f, -0.07348466f, 
    -0.02104050f, -0.03893049f, -0.02332496f, -0.07135351f, -0.17685059f, -0.05444252f, 0.03839891f, -0.05311468f, 
    0.06008879f, -0.04374137f, 0.01088314f, -0.06983633f, 0.30108926f, -0.07605337f, 0.09041404f, -0.26474124f, 
    0.03118857f, -0.06909312f, 0.00590373f, 0.07931091f, -0.00773861f, -0.00512936f, -0.00717473f, 0.06296001f, 
    -0.16655326f, 0.10455389f, -0.00940652f, -0.03726199f, 0.01809051f, 0.01105497f, -0.03279094f, 0.02253615f, 
    -0.03161998f, 0.14182372f, 0.16557391f, 0.08295693f, -0.05790452f, 0.00931632f, 0.01032458f, 0.02451480f, 
    0.05560680f, -0.00383707f, 0.02820616f, 0.01450215f, 0.00804332f, -0.01941140f, -0.00912921f, 0.02758565f, 
    0.06770588f, -0.04132481f, -0.03530644f, 0.02273131f, -0.01271657f, 0.15446714f, 0.01332316f, -0.08094914f, 
    0.09502651f, 0.19842333f, -0.07036909f, 0.13383119f, -0.00258061f, 0.07709375f, -0.00905738f, -0.00254308f, 
    -0.01439545f, -0.08874866f, 0.00009347f, 0.12906681f, 0.01114552f, 0.04660140f, -0.13012086f, 0.01849183f, 
    0.40153039f, 0.25706893f, -0.01196266f, 0.03533680f, 0.03945505f, -0.06937889f, 0.00403590f, -0.05847274f, 
    0.07826910f, 0.00163308f, 0.00019809f, 0.06215586f, 0.03689318f, -0.09369698f, -0.01672119f, -0.00312164f, 
    0.05185128f, 0.08297620f, 0.02943267f, -0.12974948f, 0.08461725f, -0.24857876f, -0.13860372f, 0.02883348f, 
    -0.01352696f, -0.03586128f, 0.03724267f, 0.04015270f, -0.01818698f, -0.23296420f, -0.01919214f, -0.12981276f, 
    -0.02105452f, -0.02037472f, -0.01553248f, 0.00634047f, 0.01315445f, -0.03606452f, 0.02868043f, 0.00936749f, 
    0.02558467f, 0.15781371f, 0.10421046f, 0.14315680f, 0.11383546f, -0.04051927f, 0.01841038f, 0.00153795f, 
    -0.03643676f, 0.03450906f, 0.02649627f, 0.03839396f, -0.03140428f, -0.03797613f, 0.00547901f, 0.08522328f, 
    -0.13489206f, -0.06228283f, 0.05538294f, -0.10598802f, -0.21111868f, 0.05539959f, -0.25986990f, -0.23488998f, 
    0.24759148f, 0.07183459f, -0.14451735f, -0.18831033f, 0.28605986f, -0.06457278f, -0.01028484f, 0.04929556f, 
    0.06320380f, -0.01722324f, 0.05697267f, 0.02423757f, 0.00343088f, 0.14606138f, -0.21080433f, -0.21028739f, 
    -0.29972094f, -0.05397459f, -0.21209551f, -0.06300240f, -0.09407122f, 0.01224600f, 0.09588894f, 0.10230881f, 
    0.16546464f, -0.07981329f, -0.17865761f, 0.07414011f, -0.00112423f, 0.03290452f, 0.04199386f, -0.02649686f, 
    0.00547277f, 0.07170764f, -0.02915918f, 0.03035587f, -0.03505661f, 0.24189512f, -0.05935207f, 0.20086743f, 
    0.18862860f, -0.01478696f, -0.04560652f, -0.08918175f, -0.06791650f, -0.14584230f, 0.00245739f, -0.00369824f, 
    0.01067739f, -0.00404466f, 0.09865873f, 0.00957694f, 0.02576930f, 0.08259898f, -0.19876863f, 0.01690529f, 
    0.12132755f, -0.09940007f, 0.19193485f, 0.09663505f, 0.05562607f, 0.05002740f, 0.05315227f, 0.02360543f, 
    0.06461905f, -0.06890173f, 0.00934552f, -0.00201105f, 0.07387521f, 0.03836219f, -0.18096909f, 0.14718482f, 
    0.05811632f, -0.07196903f, -0.01582758f, 0.00302419f, 0.05275047f, 0.26887545f, 0.12019799f, 0.16775157f, 
    0.19199422f, -0.03989889f, 0.06454381f, -0.11107607f, 0.17923887f, 0.00607528f, -0.01240214f, 0.00782173f, 
    -0.04754248f, -0.00564569f, -0.01370730f, -0.07301406f, -0.02784966f, 0.02872231f, 0.05121979f, 0.10538966f, 
    -0.15535274f, -0.36756742f, 0.19721442f, 0.05499288f, -0.09435503f, -0.10345341f, 0.06928100f, 0.06478199f, 
    -0.15715691f, -0.12254922f, 0.07150596f, -0.27544835f, 0.07791428f, -0.14972125f, -0.11381362f, 0.05114762f, 
    0.01903948f, 0.02732019f, -0.07063745f, -0.01402136f, 0.35492513f, -0.03265281f, 0.03835750f, -0.20074753f, 
    0.22636499f, -0.04547602f, -0.05474051f, -0.00591724f, -0.09293930f, -0.02901632f, 0.00308386f, 0.06063443f, 
    0.06901550f, -0.02758783f, 0.03131694f, 0.06513856f, 0.04505388f, -0.03055918f, 0.07505361f, 0.03166416f, 
    0.35372695f, 0.17067267f, -0.44745526f, -0.06793225f, -0.17982939f, 0.01782976f, 0.01753287f, -0.03696132f, 
    0.10081841f, -0.04033290f, 0.00850340f, 0.05027095f, -0.05626199f, -0.00086966f, 0.09293237f, -0.05342938f, 
    -0.06314365f, -0.14210181f, 0.04634295f, 0.00555169f, 0.14273778f, 0.18546036f, 0.06526420f, 0.05533461f, 
    0.13701557f, -0.00520658f, 0.07911799f, 0.00759561f, -0.07021875f, 0.07355873f, 0.01059339f, 0.01729786f, 
    0.00707076f, -0.01056659f, 0.04807894f, 0.10904097f, 0.00429411f, 0.11143645f, -0.00922600f, -0.03183700f, 
    0.17722228f, -0.19397664f, -0.20934676f, -0.01372619f, -0.14422338f, -0.05826847f, 0.02425428f, 0.10527466f, 
    -0.16235632f, -0.09575738f, 0.04018511f, -0.07724945f, 0.02017857f, -0.01497368f, -0.00057259f, -0.00107108f, 
    0.00535041f, -0.01095191f, -0.05139421f, 0.01483406f, 0.25973922f, 0.09664030f, -0.04226887f, -0.05910668f, 
    0.05187742f, -0.06763090f, -0.07543278f, -0.08179796f, -0.01384810f, 0.02429280f, -0.05436171f, -0.01522212f, 
    0.03132473f, 0.05616247f, -0.01799543f, 0.04932391f, 0.06606523f, -0.05837319f, 0.00756068f, 0.06432734f, 
    -0.27295241f, 0.18629345f, -0.10686948f, 0.13296631f, 0.00716271f, -0.11123090f, -0.01269691f, 0.09397720f, 
    -0.16981359f, 0.04273194f, -0.01735798f, 0.02245800f, 0.03911541f, -0.02190170f, 0.04778922f, 0.06867003f, 
    0.02603096f, 0.05180873f, -0.28509772f, 0.04453174f, -0.11315425f, -0.02692540f, -0.11113255f, 0.01517668f, 
    -0.03432577f, -0.05045545f, 0.15043682f, 0.13028768f, 0.01443499f, -0.06939477f, -0.06193859f, -0.03113365f, 
    -0.02581765f, 0.01420457f, -0.01635388f, 0.00268852f, -0.01519869f, -0.04498914f, 0.03276563f, 0.00783763f, 
    -0.18191552f, 0.07092999f, -0.21029612f, -0.00366071f, -0.42873755f, 0.14505333f, -0.06789723f, -0.24807234f, 
    -0.16538183f, 0.02851606f, -0.07558415f, 0.06198573f, 0.05105793f, 0.02316510f, -0.00272939f, -0.07999287f, 
    -0.03994924f, -0.21725097f, -0.14835952f, -0.17233108f, 0.23688373f, 0.09539057f, 0.08916987f, 0.08046167f, 
    0.09870963f, 0.00398344f, -0.03515718f, 0.01269952f, -0.04964245f, -0.03840033f, -0.00283590f, 0.02170720f, 
    0.01796299f, 0.05086032f, 0.01672988f, -0.10495746f, 0.04446835f, -0.03860518f, -0.00077572f, -0.03172716f, 
    1.05923927f, 0.16577375f, -0.34618372f, 0.02672657f, -0.43756837f, 0.04605201f, 0.00585748f, -0.07099423f, 
    -0.04753275f, -0.03924562f, 0.06010123f, -0.01674444f, 0.03508855f, -0.11115319f, 0.08730984f, 0.07595123f, 
    -0.04309921f, -0.09882589f, -0.00612380f, 0.15996428f, -0.31692076f, -0.00695412f, -0.08021596f, 0.00264082f, 
    0.05225591f, 0.15804310f, 0.01820941f, 0.04935523f, 0.11938586f, -0.05192333f, -0.28516248f, 0.15939054f, 
    0.00201983f, 0.05364721f, 0.02912269f, -0.04449800f, 0.01611032f, 0.01806404f, -0.09840515f, 0.02644869f, 
    0.18901318f, -0.21777658f, -0.17838335f, -0.00964357f, -0.01295241f, -0.05674617f, -0.00459195f, 0.04327829f, 
    0.01203158f, -0.00695593f, 0.09486265f, -0.12456368f, -0.01294815f, -0.03380941f, -0.13973875f, -0.01692579f, 
    -0.06447036f, -0.00378106f, -0.01703056f, -0.05782890f, -0.03631128f, 0.18083350f, 0.22384718f, 0.05185734f, 
    -0.33355200f, -0.00440954f, -0.05396662f, 0.07633592f, 0.03241991f, -0.05062134f, 0.06384769f, -0.04068322f, 
    -0.11405981f, -0.16588202f, -0.02834848f, 0.13412011f, -0.03311827f, -0.18405139f, 0.04499617f, -0.00583103f, 
    -0.15245496f, -0.09354495f, -0.14271121f, -0.08950811f, -0.14500098f, 0.08744448f, 0.00725672f, 0.01782373f, 
    -0.03482433f, -0.00141748f, 0.07059312f, 0.01956069f, 0.04478522f, 0.09584150f, 0.04977203f, -0.03110578f, 
    -0.03381164f, -0.02824421f, 0.16915137f, 0.04860206f, -0.69374126f, 0.25273168f, -0.00295118f, 0.13569136f, 
    -0.09070287f, -0.07023115f, -0.06075650f, 0.03231790f, -0.12422357f, 0.01756378f, -0.01506740f, 0.02955251f, 
    -0.02008374f, 0.03600513f, -0.06305782f, 0.17094715f, -0.01449800f, 0.02037760f, 0.03638563f, 0.08561818f, 
    -0.18384612f, 0.02999248f, -0.06778821f, 0.12902616f, 0.01208418f, 0.06319434f, 0.16203229f, 0.03131936f, 
    -0.04868132f, 0.03512790f, 0.05360426f, -0.04891873f, 0.05869809f, 0.03122767f, 0.02246222f, 0.00486029f, 
    0.02164009f, 0.04488340f, -0.04971220f, 0.07445043f, -0.42739341f, -0.28567481f, -0.23307586f, -0.24102610f, 
    -0.11012390f, 0.06644038f, -0.12005730f, -0.09656371f, 0.15287161f, -0.15018077f, -0.05444537f, -0.01313617f, 
    0.07291368f, 0.03699709f, 0.01460659f, -0.22370034f, 0.05589748f, -0.13297626f, 0.09002977f, -0.25630906f, 
    0.04011464f, 0.00220748f, 0.09844631f, 0.02307404f, 0.05557433f, -0.03135951f, -0.02463903f, 0.01314518f, 
    -0.02743965f, -0.01781663f, 0.06071323f, 0.00800477f, -0.10107082f, -0.02708926f, 0.03726025f, -0.02563981f, 
    0.02001042f, -0.05203293f, 0.02917190f, -0.05035309f, 0.06546973f, -0.01295965f, -0.03332845f, 0.03133426f, 
    0.01524553f, -0.00635297f, -0.02011525f, -0.02015945f, -0.01515273f, -0.01404631f, -0.01499746f, 0.07930162f, 
    0.07562448f, 0.03539636f, 0.06731891f, -0.02758311f, 0.03182161f, -0.04775201f, 0.02060106f, -0.04482978f, 
    -0.06361716f, -0.03371165f, -0.04488010f, -0.08785875f, -0.02038620f, 0.04435348f, 0.04172570f, -0.01747132f, 
    0.00810652f, 0.06334764f, -0.01310440f, -0.05781462f, 0.08788501f, 0.07983425f, 0.05969205f, -0.02068417f, 
    -0.02657795f, 0.00238053f, 0.03863369f, -0.07531239f, -0.18645771f, -0.01035950f, -0.06867135f, -0.08985174f, 
    0.02726419f, 0.07613868f, 0.13218401f, 0.13751356f, -0.22745456f, -0.04214566f, -0.05658454f, 0.01384998f, 
    -0.00436633f, 0.00522711f, -0.00113196f, 0.01743575f, 0.01066890f, -0.00820891f, -0.03431992f, 0.01715975f, 
    0.00817886f, -0.17906757f, 0.15195410f, 0.13748829f, 0.09309541f, -0.00138643f, 0.01359454f, 0.03086506f, 
    0.00084111f, 0.01637109f, 0.13628584f, -0.00232491f, 0.01211429f, -0.08650450f, 0.01707330f, 0.14168538f, 
    -0.05569964f, -0.25338411f, 0.05684189f, -0.00704551f, 0.41739610f, 0.17137733f, -0.12191751f, 0.14938185f, 
    -0.01854483f, -0.02293532f, -0.04393443f, -0.03856124f, 0.03031892f, -0.00097257f, 0.02756740f, 0.04938537f, 
    -0.10966153f, -0.05734850f, 0.10293294f, -0.08394802f, -0.20393112f, -0.07557423f, 0.02820726f, -0.06405341f, 
    0.00514942f, 0.16983059f, -0.06401850f, 0.16629940f, -0.01690817f, 0.12891307f, 0.03944051f, -0.01373574f, 
    0.04719411f, 0.03703138f, 0.02053045f, 0.02300249f, 0.03981937f, -0.03415869f, 0.04269318f, -0.07228813f, 
    -0.02661608f, -0.02956228f, -0.12869491f, 0.06714443f, -0.15063149f, -0.07575677f, -0.02795011f, -0.09580098f, 
    0.04952431f, 0.08834243f, -0.11456379f, -0.18707253f, 0.06557351f, 0.13199002f, -0.05192825f, -0.04141775f, 
    0.04617914f, 0.12334630f, 0.10021949f, -0.04022124f, 0.06312811f, -0.08169851f, 0.04101223f, 0.09438869f, 
    0.14846587f, 0.10315169f, -0.24010462f, -0.04440003f, -0.33911899f, -0.09572654f, -0.14447795f, -0.01156929f, 
    -0.06503170f, -0.00566519f, -0.02873887f, -0.02706821f, -0.00427778f, 0.08574476f, -0.00548691f, 0.06564524f, 
    -0.04804790f, -0.02482132f, 0.19189009f, 0.11219135f, 0.28734747f, 0.11067910f, 0.10376713f, 0.05927407f, 
    0.16762201f, -0.05008353f, -0.02791852f, -0.06793457f, -0.06999215f, -0.03455869f, 0.01048967f, 0.00173731f, 
    0.03952158f, 0.00816435f, -0.02215639f, -0.00035316f, 0.11876590f, -0.04899691f, -0.02464491f, 0.00025975f, 
    0.05913201f, 0.03589714f, 0.04630769f, -0.01803972f, 0.20804507f, -0.03451382f, 0.04000124f, 0.01058084f, 
    0.01308050f, 0.03846699f, 0.13785008f, 0.08448437f, 0.12735125f, 0.11059607f, -0.00136822f, -0.10608178f, 
    0.10735299f, -0.00305394f, 0.01304657f, -0.06565701f, 0.44253457f, -0.01958803f, 0.00491946f, 0.07442861f, 
    -0.06402715f, -0.05924608f, 0.04332026f, -0.00299785f, 0.00432373f, 0.03945056f, 0.09420516f, 0.07489851f, 
    -0.05005992f, -0.07315987f, -0.02287019f, -0.01137999f, -0.01069057f, -0.06530461f, 0.01058807f, 0.03147193f, 
    -0.09825776f, 0.26835117f, -0.17081419f, 0.03203763f, 0.10798106f, 0.04532437f, -0.09944209f, -0.05663707f, 
    0.03705160f, -0.05337120f, 0.01077169f, 0.07780429f, 0.09851154f, -0.02464910f, 0.06321302f, 0.03421431f, 
    0.07144122f, 0.13492334f, -0.03163253f, 0.11983531f, 0.72663808f, 0.34646177f, -0.11993369f, -0.05390836f, 
    0.04572936f, 0.00533833f, 0.04276761f, -0.05765181f, -0.15191928f, 0.07985044f, -0.04055361f, -0.03050563f, 
    -0.04376011f, 0.08417025f, -0.04669269f, 0.01816000f, 0.15404195f, 0.00163435f, -0.00731645f, 0.12419036f, 
    -0.66050869f, -0.28892261f, -0.26402804f, -0.23677437f, -0.21632849f, 0.09692745f, -0.14425494f, -0.17245619f, 
    -0.00201165f, -0.09860134f, -0.01455267f, 0.02598319f, 0.00768594f, -0.00842011f, 0.01464492f, -0.03986343f, 
    -0.11047203f, -0.20458752f, -0.05768986f, -0.21525778f, -0.25460595f, -0.11749206f, -0.03104251f, 0.13559698f, 
    0.12540339f, -0.00099123f, -0.02782555f, -0.00406513f, -0.06692323f, -0.02763699f, 0.04402484f, 0.03652230f, 
    0.09793573f, -0.01727048f, 0.05127140f, -0.07814410f, -0.06292675f, 0.10933928f, 0.02615239f, -0.00908997f, 
    0.06952479f, 0.02852312f, 0.04678232f, 0.05025678f, 0.01991408f, -0.01974121f, 0.01097021f, -0.04880199f, 
    -0.02257479f, -0.01699542f, 0.03795258f, -0.04063139f, 0.00432245f, 0.06520405f, 0.02960430f, -0.04174942f, 
    0.05245616f, -0.02805897f, 0.03909896f, -0.07219014f, -1.04387438f, 0.36403328f, -0.05150380f, -0.19320160f, 
    0.05545390f, 0.04279770f, -0.03868761f, 0.01232679f, -0.01552610f, -0.10577759f, -0.11006897f, 0.09847300f, 
    0.18876323f, -0.00202285f, -0.01458210f, 0.03100853f, -0.06535308f, 0.02810103f, -0.09510567f, -0.00221704f, 
    -0.08328240f, -0.07069992f, 0.01063784f, -0.06695522f, 0.01223185f, 0.01852011f, 0.06712997f, 0.06396068f, 
    0.00140937f, 0.03860793f, 0.11252120f, 0.07326777f, -0.03891818f, 0.06933360f, -0.02355501f, -0.06556848f, 
    0.05495642f, 0.00847665f, -0.00262197f, 0.05481076f, 0.30334556f, -0.04581029f, 0.23080412f, -0.00103408f, 
    0.12712015f, 0.07618795f, -0.05099798f, 0.04595167f, 0.09953553f, -0.23578250f, 0.12209497f, -0.12524553f, 
    0.00527299f, -0.17144337f, -0.22035816f, 0.06471942f, -0.04476435f, -0.00742826f, 0.00017163f, -0.06555454f, 
    -0.41106820f, 0.07834076f, 0.09335398f, -0.10011896f, 0.08719485f, -0.04960824f, -0.13464063f, 0.10476695f, 
    0.01249401f, 0.05379694f, 0.12057427f, 0.11144653f, 0.02776310f, 0.00466751f, -0.03629642f, -0.10592391f, 
    0.27891132f, 0.08164346f, -0.05455902f, 0.14326161f, -0.36023602f, -0.12284954f, 0.04793019f, -0.05885835f, 
    0.18723068f, 0.03337319f, 0.02172644f, -0.03199944f, 0.17954266f, 0.03873195f, -0.01913281f, -0.14319609f, 
    -0.04852267f, 0.11093402f, -0.13974854f, 0.05553600f, -0.06822786f, 0.03492146f, 0.03152144f, -0.03182035f, 
    0.00831065f, -0.01312244f, 0.00191888f, 0.04173855f, 0.00030876f, -0.01430328f, -0.00884853f, 0.00123069f, 
    0.00456278f, 0.00799717f, -0.10648177f, 0.00664424f, -0.00728070f, 0.02593491f, 0.10757425f, 0.02106688f, 
    -0.03337294f, -0.05627597f, -0.00444551f, -0.01230945f, -0.11604838f, 0.09990191f, -0.04223444f, -0.13718167f, 
    0.05587934f, 0.05817677f, -0.04718084f, -0.11383591f, 0.15070601f, 0.08698715f, 0.02959252f, -0.01871043f, 
    0.08400895f, 0.01402594f, -0.05173730f, -0.15114185f, -0.17014997f, -0.22887000f, -0.33106846f, -0.15234947f, 
    -0.10682899f, -0.24931198f, -0.08684514f, -0.04662003f, -0.07492742f, 0.01356072f, -0.03815121f, 0.06711151f, 
    0.00592266f, -0.28329745f, -0.09957362f, 0.01960671f, -0.05602781f, -0.06034499f, -0.01481939f, 0.02349620f, 
    -0.04093885f, -0.01727787f, -0.02474555f, 0.00558562f, 0.10371476f, -0.00782982f, 0.00317721f, 0.05606579f, 
    -0.04684434f, -0.06567707f, -0.01706047f, 0.00588885f, -0.02320224f, 0.01397096f, -0.02301020f, 0.07801730f, 
    -0.00471075f, -0.05088037f, -0.03329735f, -0.05288051f, -0.01765253f, -0.00037821f, -0.00349045f, -0.00508011f, 
    -0.24833874f, 0.07271139f, -0.00001213f, 0.30301347f, -0.01616241f, 0.00790978f, -0.12003578f, -0.05676322f, 
    -0.08621557f, -0.00098730f, -0.00534446f, -0.01244865f, 0.00150136f, 0.02498676f, 0.04130179f, 0.00886446f, 
    0.01680400f, 0.06025677f, -0.25294557f, -0.01474553f, -0.07293401f, -0.14305995f, -0.00154742f, 0.00522699f, 
    -0.07283130f, 0.00931498f, 0.08710172f, 0.05726342f, 0.08320251f, 0.04154380f, 0.03784247f, 0.06651025f, 
    0.02604623f, 0.09444534f, -0.02920036f, 0.01160886f, 0.06566860f, -0.05017836f, 0.05845702f, 0.03061886f, 
    0.13472323f, 0.08494018f, 0.08835309f, 0.11891659f, 0.09901040f, -0.01504677f, -0.04645337f, -0.02920031f, 
    -0.03254027f, -0.01232626f, 0.04528308f, 0.02370739f, 0.03529356f, 0.00959356f, 0.08301337f, -0.04123552f, 
    -0.14799029f, -0.08329691f, -0.00514598f, -0.07405242f, 0.54660881f, -0.06392196f, 0.04522073f, 0.11891570f, 
    0.01966830f, 0.01960634f, -0.03544958f, -0.03116036f, 0.00456299f, -0.01268780f, -0.05898806f, 0.07172839f, 
    0.03389126f, 0.06555376f, -0.03840505f, 0.16358107f, 0.08651171f, -0.05210717f, -0.03150450f, 0.02865920f, 
    0.12659401f, 0.02295074f, 0.08283012f, -0.00321272f, 0.09899181f, -0.00380269f, 0.00439794f, -0.06568582f, 
    -0.01154582f, 0.02206314f, 0.07507653f, 0.03297603f, -0.04219752f, 0.01176599f, 0.01486330f, -0.12378883f, 
    0.24948487f, -0.13702776f, 0.06034508f, 0.04360969f, -0.61121428f, 0.59588104f, -0.28945464f, -0.00240108f, 
    -0.01293933f, -0.01007944f, 0.06901695f, -0.06366573f, 0.00206635f, -0.11473909f, -0.05029561f, -0.00507449f, 
    -0.06031751f, -0.03727624f, -0.00587059f, -0.16905491f, -0.14782612f, -0.08838250f, -0.08418872f, 0.11168215f, 
    0.01693683f, -0.06739729f, 0.08327582f, 0.04792757f, -0.06802582f, -0.13694836f, 0.03397433f, 0.12298677f, 
    -0.07245859f, 0.10401467f, 0.08263928f, 0.01831977f, 0.03101489f, -0.01130033f, -0.02379862f, -0.03081468f, 
    0.03224086f, 0.10265193f, 0.02410581f, 0.00470918f, 0.24209785f, 0.25922674f, 0.23218513f, 0.14711259f, 
    0.10974415f, 0.14339334f, -0.07177071f, -0.00222906f, 0.07855888f, -0.27845147f, 0.05693240f, -0.00624348f, 
    0.04095228f, -0.13632636f, -0.04895353f, 0.02735486f, 0.02806313f, 0.05295930f, -0.05181805f, 0.03916800f, 
    0.45214611f, -0.16246672f, 0.21921931f, 0.06152941f, -0.11381452f, 0.00331387f, -0.03262528f, 0.07869968f, 
    0.05308286f, -0.04696966f, 0.01150659f, -0.10885686f, 0.00620761f, -0.08035423f, -0.00494741f, -0.02837538f, 
    -0.01630153f, -0.02261156f, -0.00121380f, -0.02934033f, 0.09276421f, -0.07456470f, -0.20475362f, -0.12651238f, 
    0.06924314f, -0.16993766f, 0.08336578f, 0.04214904f, 0.11862224f, 0.02223109f, 0.06419074f, -0.05221114f, 
    0.19670752f, -0.07287904f, -0.26301414f, -0.03076590f, -0.04769786f, 0.01366166f, -0.02431051f, -0.16216840f, 
    0.07056949f, 0.06699904f, 0.21227907f, 0.27777356f, 0.25417259f, -0.09164061f, -0.01811616f, 0.02273229f, 
    0.00380356f, 0.06700648f, 0.02921061f, 0.00657412f, 0.02926155f, -0.01548120f, 0.02087183f, -0.04231521f, 
    -0.02662415f, -0.04785369f, 0.00255058f, -0.01177173f, -0.15450272f, 0.16472419f, 0.14967066f, 0.11759559f, 
    0.20309404f, -0.02763027f, -0.00014206f, 0.05899842f, 0.05055742f, -0.03473952f, 0.01289605f, 0.01614227f, 
    0.05704908f, 0.06951470f, -0.02790540f, 0.02824337f, 0.00353051f, 0.00889247f, -0.05134239f, 0.09050842f, 
    -0.29290795f, -0.07948601f, -0.29402977f, -0.00153389f, -0.18235476f, 0.02937192f, 0.00322569f, -0.02675143f, 
    0.00804313f, 0.07926121f, -0.02462669f, 0.01095514f, -0.10698308f, 0.03849826f, 0.04822502f, -0.06549997f, 
    0.03173602f, 0.05123542f, 0.06468299f, -0.10410722f, -0.00484064f, -0.21033406f, 0.37822220f, 0.09578732f, 
    0.07479080f, 0.02422873f, -0.03976011f, 0.06613725f, 0.08967621f, -0.14318638f, 0.06501382f, 0.03300713f, 
    0.08469431f, 0.02300562f, 0.06740361f, -0.00119821f, -0.04431166f, 0.00686207f, 0.07358633f, -0.05226926f, 
    -0.04274844f, -0.12516750f, -0.10475604f, 0.03554107f, -0.00738168f, 0.00448850f, 0.02894710f, 0.01863229f, 
    -0.02610323f, 0.02059059f, 0.00167926f, -0.02452210f, 0.00763776f, 0.01582550f, -0.02005635f, 0.12638928f, 
    0.08471638f, 0.18059744f, 0.06948648f, 0.02952628f, -0.09054132f, -0.11449692f, -0.29043469f, -0.13950206f, 
    -0.25829077f, -0.02619223f, -0.05525849f, 0.02162016f, 0.09627478f, 0.04542078f, -0.00249128f, 0.00212651f, 
    0.03207840f, 0.01198782f, -0.06044741f, -0.04347187f, -0.00151289f, 0.05043128f, -0.13327564f, 0.03523221f, 
    0.05858824f, 0.07618593f, 0.06440479f, 0.09634141f, 0.01882551f, 0.03095561f, -0.07880996f, -0.05292459f, 
    0.08996452f, -0.11638967f, -0.00509127f, 0.12944685f, -0.06846858f, 0.07583782f, 0.00082915f, 0.02901542f, 
    -0.03076193f, -0.00729128f, 0.05811371f, -0.02180836f, -0.35834500f, -0.40045300f, -0.22653636f, 0.01741477f, 
    -0.60781705f, 0.08162547f, -0.00241281f, 0.10064664f, 0.07475198f, 0.00141558f, -0.04023509f, 0.01481314f, 
    -0.04454248f, -0.00373810f, -0.04195288f, -0.03605757f, -0.01178523f, -0.03199145f, -0.02486933f, -0.01858098f, 
    0.02219144f, 0.03154709f, -0.02982333f, -0.03352664f, -0.00802341f, 0.02835912f, -0.00173273f, 0.05832730f, 
    0.04286996f, -0.09613127f, 0.03527613f, 0.03545192f, 0.11413973f, 0.08076067f, 0.02019230f, 0.00104252f, 
    -0.05415533f, 0.02478681f, 0.18279079f, -0.08688206f, -0.26996619f, -0.31994602f, 0.08109718f, 0.13817462f, 
    -0.16539218f, -0.08314739f, -0.01398988f, 0.04902754f, 0.03955492f, -0.07200003f, -0.00842728f, -0.01292693f, 
    -0.04405368f, 0.08796792f, 0.01060847f, -0.00054873f, -0.02657015f, -0.05750307f, -0.13002922f, -0.05220140f, 
    0.21737702f, 0.03810570f, 0.42645931f, 0.21416627f, 0.21340746f, -0.17005095f, 0.03116244f, 0.04155055f, 
    -0.10995417f, -0.13252302f, 0.11753336f, -0.01517675f, 0.07874296f, -0.20418274f, 0.00777446f, -0.06393562f, 
    0.00253251f, 0.02894897f, -0.02050879f, -0.03503228f, -0.02276642f, 0.05314215f, 0.00680522f, -0.15871371f, 
    0.10594883f, 0.04190177f, 0.04007054f, -0.01064028f, 0.00968366f, -0.03375759f, -0.04570485f, 0.03255223f, 
    0.04503036f, -0.01039788f, 0.01124704f, 0.09363218f, 0.03953008f, -0.02452374f, 0.03772856f, -0.00919380f, 
    -0.26378310f, 0.22049223f, -0.00863350f, 0.13661394f, -0.32281286f, 0.09863907f, -0.03142478f, -0.07291685f, 
    0.01429203f, 0.05921004f, -0.03991164f, 0.05575981f, -0.02455212f, -0.06087453f, 0.04217527f, 0.13299188f, 
    0.12486129f, 0.21685603f, 0.18842667f, 0.01131048f, -0.08176624f, -0.07311217f, -0.14290923f, 0.01508172f, 
    -0.12165622f, 0.08778220f, 0.01748709f, 0.03509424f, -0.03693220f, -0.00144699f, 0.04428904f, 0.05785186f, 
    -0.00169288f, 0.06532457f, -0.07514152f, -0.01788576f, -0.01860919f, 0.13519229f, 0.01937436f, -0.05424355f, 
    0.05610906f, 0.06931104f, 0.33300635f, 0.09545892f, 0.15934303f, -0.05028081f, -0.04136838f, 0.08736205f, 
    0.04610055f, -0.14959866f, 0.06542663f, -0.01329718f, 0.08081931f, -0.04309872f, 0.06460506f, -0.03390586f, 
    -0.03619057f, 0.02232190f, 0.03231425f, -0.04896995f, -0.21745145f, -0.23267719f, 0.08901420f, -0.13949284f, 
    0.00747224f, 0.07633600f, -0.04662191f, -0.02812218f, -0.03828464f, 0.09218504f, -0.01243653f, -0.03039757f, 
    0.01544514f, 0.00548657f, 0.05168484f, 0.05569396f, -0.10756225f, -0.21329829f, 0.09653011f, -0.02055387f, 
    0.03901209f, -0.10644891f, -0.43034524f, 0.15782690f, -0.17300758f, -0.04867052f, 0.09242220f, 0.07399692f, 
    -0.06474131f, 0.09245507f, -0.00449535f, 0.01034929f, 0.05538748f, -0.01715741f, -0.04070658f, -0.02132318f, 
    0.02776932f, -0.01842211f, -0.02833268f, -0.02825501f, 0.09663930f, -0.10158958f, 0.19483358f, 0.07304006f, 
    0.10024795f, -0.06499060f, -0.10406326f, -0.00564717f, 0.21383807f, -0.02231962f, 0.06098381f, 0.02552624f, 
    0.04263954f, 0.02062384f, 0.04662346f, 0.01438223f, -0.06040480f, -0.02684271f, 0.04014622f, 0.00511441f, 
    -0.20147140f, -0.70365304f, 0.29728499f, -0.21703449f, -0.06858070f, 0.03447964f, -0.13174546f, -0.15906948f, 
    0.06910011f, -0.14538373f, -0.00989288f, -0.02923894f, 0.01252232f, -0.05372437f, -0.01869867f, -0.03494610f, 
    -0.01046975f, 0.03256026f, 0.11787011f, 0.14898033f, -0.15889439f, -0.23301357f, -0.04091513f, -0.15273198f, 
    0.00898548f, -0.01337320f, -0.06292806f, -0.00144711f, -0.01323504f, 0.07761426f, 0.03064078f, -0.01406140f, 
    -0.06803724f, 0.05567498f, -0.02617129f, -0.03088053f, -0.16527757f, 0.01449567f, 0.05673421f, -0.01985692f, 
    -0.45501974f, 0.40312424f, 0.37907383f, -0.11430749f, -0.21347612f, 0.01951351f, -0.13600881f, -0.14044988f, 
    -0.06548822f, 0.18474254f, 0.01177404f, -0.04319914f, -0.10314485f, -0.05947729f, -0.10903584f, 0.02054723f, 
    -0.02477589f, -0.08537982f, 0.15686963f, -0.07490700f, 0.34753358f, -0.08674452f, -0.05479776f, 0.02764660f, 
    0.05643821f, 0.27032501f, -0.29218602f, -0.27302513f, 0.07041934f, 0.11516801f, -0.07770412f, 0.22011544f, 
    0.06787410f, 0.04649702f, -0.05609227f, 0.01447774f, -0.03818582f, -0.19366027f, 0.22986819f, 0.02543502f, 
    0.10809154f, -0.32711825f, 0.61402196f, 0.13877149f, 0.24876559f, -0.04910746f, -0.02239204f, 0.01515360f, 
    0.15926380f, -0.08888587f, 0.04106009f, 0.03500112f, 0.04987762f, -0.09247974f, 0.05602752f, 0.03504891f, 
    -0.07398911f, -0.03721683f, 0.02499278f, -0.00588714f, -0.24466661f, -0.08749400f, 0.57272035f, 0.13374856f, 
    0.16660990f, -0.07608554f, -0.14883128f, -0.03774690f, -0.10218894f, 0.04537708f, 0.02211943f, 0.02205186f, 
    0.02588029f, -0.05765842f, 0.06907472f, -0.00279150f, 0.07745940f, 0.02407586f, -0.06033529f, -0.02366726f, 
    -0.14899290f, -0.04914112f, 0.03097308f, -0.01910708f, 0.05827134f, -0.05274388f, -0.09763125f, -0.30018547f, 
    -0.09794305f, -0.11463510f, 0.13991991f, -0.08607478f, 0.01683554f, 0.00788437f, -0.00968969f, 0.05969777f, 
    -0.03894391f, -0.05896279f, -0.01845035f, -0.04542828f, 0.13782847f, 0.34052798f, -0.43846205f, 0.07702927f, 
    0.14669488f, -0.04365180f, 0.13714013f, 0.06510828f, -0.12003966f, 0.12017837f, 0.02001637f, -0.01528362f, 
    0.08997991f, -0.10428665f, -0.02227505f, -0.10162508f, 0.00863653f, 0.03646160f, -0.04249450f, 0.08877365f, 
    -0.09911326f, 0.02476846f, -0.11024187f, 0.10619485f, -0.02041582f, 0.03549420f, 0.02299449f, 0.02096482f, 
    0.02634811f, -0.10478215f, 0.02470499f, 0.05896411f, 0.04527611f, -0.02773102f, 0.00923086f, 0.01807635f, 
    0.01424763f, -0.00923573f, 0.06499565f, -0.06636542f, 0.29260284f, 0.11864905f, -0.02755207f, -0.12319602f, 
    0.01278065f, -0.01756649f, 0.07029606f, -0.03951786f, 0.05724692f, 0.08276332f, -0.01528459f, -0.04040195f, 
    -0.00664209f, 0.02654557f, -0.00763804f, 0.09663687f, -0.00226822f, -0.10724980f, 0.04526060f, 0.05668996f, 
    -0.07131845f, -0.01020128f, -0.05890790f, -0.00701938f, 0.06114516f, -0.01222340f, 0.00884916f, 0.06043183f, 
    0.05572966f, 0.00939009f, -0.13223092f, 0.02333038f, 0.05192105f, 0.01914766f, 0.02196879f, 0.04402298f, 
    0.01102073f, 0.00793079f, 0.04367675f, -0.09009307f, -0.13266751f, -0.07181707f, -0.02584009f, -0.05716024f, 
    0.03635735f, 0.04623489f, -0.06346312f, -0.06815752f, 0.01421201f, 0.02461712f, 0.02403248f, -0.18073368f, 
    -0.03617127f, -0.09782615f, 0.00368901f, -0.00969520f, -0.05820915f, -0.14298329f, 0.04487766f, 0.02533088f, 
    -0.18446426f, -0.01754909f, -0.01575264f, 0.03666455f, 0.03103561f, -0.13553955f, -0.03394486f, -0.22976698f, 
    -0.05827260f, 0.01365093f, 0.10801316f, -0.02147769f, -0.08106499f, 0.04567340f, -0.05557828f, -0.02255175f, 
    -0.04679943f, -0.03132980f, -0.22068755f, -0.06209033f, -0.02926921f, 0.02857117f, 0.07150798f, -0.05096551f, 
    0.15330413f, -0.08048393f, 0.03537605f, -0.04163904f, 0.17120299f, -0.00779680f, 0.05034426f, 0.04364994f, 
    0.06868760f, 0.01800663f, 0.01353558f, 0.04250902f, -0.01714912f, -0.02184899f, -0.01435954f, 0.00182637f, 
    -0.08813503f, -0.20604958f, 0.08590048f, -0.00312974f, 0.21490328f, 0.02101899f, 0.00326259f, 0.01315634f, 
    0.02288011f, -0.01946617f, 0.06614159f, -0.04769799f, -0.09401304f, -0.07137366f, 0.06151324f, 0.05305646f, 
    0.06027169f, 0.03108004f, -0.00836737f, 0.03722230f, -0.34073028f, 0.24459380f, -0.21894535f, -0.29738030f, 
    -0.00068855f, 0.01775158f, -0.01116362f, -0.01982187f, 0.04363716f, 0.04027791f, -0.02649246f, 0.02886337f, 
    -0.16724744f, -0.02589246f, -0.10306787f, 0.07174364f, 0.06227735f, 0.00954202f, 0.08239900f, 0.02505764f, 
    -0.32836476f, -0.08437990f, -0.28342256f, 0.27906328f, -0.17998962f, -0.03648203f, -0.01802790f, -0.01973037f, 
    0.01173783f, -0.08729982f, -0.02743337f, 0.01522303f, -0.00886646f, -0.03533406f, 0.03707805f, -0.08829017f, 
    0.04173967f, 0.07067925f, -0.00824724f, 0.05422736f, -0.06830620f, -0.08040317f, 0.01373050f, -0.01983967f, 
    0.03329857f, 0.05415350f, -0.03293011f, -0.19467133f, -0.15887728f, 0.09612750f, 0.03817425f, -0.00461501f, 
    -0.02582268f, 0.00732667f, -0.02341902f, -0.00592986f, -0.00625928f, 0.04765420f, -0.07842819f, -0.10869782f, 
    -0.64449465f, 0.13925771f, 0.15040140f, 0.01712022f, -0.28130740f, -0.19428809f, 0.08904138f, -0.54720092f, 
    -0.33650020f, -0.02236950f, 0.06782785f, -0.00195892f, 0.02880427f, 0.04433336f, -0.03908659f, 0.05235343f, 
    0.07164787f, -0.15445960f, -0.02153851f, 0.06747795f, -0.36277321f, -0.21018454f, -0.05054408f, -0.32813033f, 
    -0.06576240f, -0.03333959f, -0.01700490f, -0.00980677f, 0.01976772f, 0.03518027f, -0.03384574f, -0.02019084f, 
    0.00118666f, -0.00019022f, 0.01424561f, -0.19411674f, -0.13531516f, -0.03325381f, 0.05346268f, 0.00393071f, 
    0.15059528f, 0.12758282f, -0.09373455f, -0.11037737f, 0.09036369f, 0.06378434f, -0.12225883f, 0.07330666f, 
    0.02512372f, 0.16569316f, -0.09902456f, -0.05179952f, 0.07619154f, 0.00120554f, 0.05669003f, 0.08887507f, 
    -0.06902807f, -0.01838202f, 0.04352432f, 0.01577255f, -0.05180912f, 0.06115026f, 0.19392805f, -0.02614897f, 
    0.08152514f, -0.00856651f, -0.02219944f, 0.06933861f, 0.00017950f, 0.01993894f, 0.02081807f, -0.08764480f, 
    -0.13134860f, 0.06791011f, 0.01029638f, 0.02817985f, -0.02866205f, 0.05924813f, 0.03766342f, -0.06912971f, 
    -0.36540097f, -0.03684480f, -0.14347886f, -0.21399705f, -0.00935892f, 0.04196259f, 0.05553644f, -0.08172341f, 
    0.04349351f, -0.08341455f, 0.06286355f, 0.03276663f, 0.06772424f, -0.00068354f, 0.04971538f, 0.03824541f, 
    -0.08189063f, 0.05654092f, 0.07099592f, 0.05778224f, -0.40208742f, 0.23368640f, -0.17007573f, 0.01495117f, 
    -0.12578578f, -0.19217911f, 0.04446734f, -0.00689243f, -0.02718341f, 0.14070506f, -0.00309528f, 0.00183567f, 
    -0.06110027f, 0.06489345f, -0.03296385f, 0.09541515f, -0.12205176f, -0.02887213f, -0.05157334f, -0.12789638f, 
    0.09675948f, -0.00764115f, -0.07875728f, -0.13245861f, 0.09821191f, 0.00181451f, -0.01703613f, -0.08150129f, 
    -0.02558494f, 0.10749820f, -0.02907947f, -0.03551436f, 0.00205327f, 0.01276971f, -0.06650358f, 0.04335901f, 
    0.07395583f, -0.02238229f, 0.16373861f, 0.15196468f, 0.21286057f, 0.15812448f, -0.03125332f, 0.01506423f, 
    0.22839220f, 0.09007631f, 0.08086327f, -0.10663176f, 0.06421620f, -0.07528596f, 0.04896461f, 0.03044215f, 
    0.00931146f, -0.02046808f, 0.02246465f, 0.01362582f, 0.09680135f, 0.05736949f, 0.07551004f, 0.04674452f, 
    -0.05875643f, -0.16263990f, 0.01480391f, -0.06150120f, 0.01662389f, -0.01825445f, -0.02548885f, 0.00028004f, 
    0.00185892f, 0.10178582f, 0.04976088f, -0.00342302f, -0.02880138f, 0.08487815f, -0.08943960f, -0.02836420f, 
    -0.12513818f, -0.11356828f, -0.00600400f, 0.00837415f, 0.21491924f, -0.03567966f, -0.23306380f, 0.02915578f, 
    -0.17514420f, 0.10910026f, -0.01311779f, 0.03474852f, -0.10231994f, -0.04254789f, -0.17637147f, 0.04622000f, 
    -0.04192320f, -0.04973224f, 0.11346770f, 0.01582113f, 0.02313419f, -0.15957645f, 0.02113389f, -0.00690607f, 
    0.03353514f, 0.09180425f, -0.11902770f, 0.05889910f, 0.08465880f, -0.05236856f, 0.00111712f, -0.00880443f, 
    0.03097011f, -0.04476678f, -0.07434231f, 0.00912799f, -0.08333240f, 0.03223737f, -0.00447414f, -0.03742877f, 
    -0.07359505f, 0.03417025f, -0.04039312f, 0.01610853f, -0.09869859f, -0.31416836f, 0.74713701f, 0.33150780f, 
    0.17104486f, -0.04826802f, -0.10158990f, -0.00562377f, 0.21515177f, -0.14510788f, 0.01813785f, 0.10353979f, 
    0.04703031f, -0.04877680f, -0.01820364f, -0.01179539f, -0.01262552f, -0.00513269f, 0.01919842f, -0.01612902f, 
    0.54510665f, 0.30238685f, -0.30501491f, 0.01818561f, 0.18422544f, -0.28300992f, 0.18134572f, -0.10740994f, 
    -0.01435956f, -0.09124456f, -0.02931408f, -0.02239707f, -0.06764475f, -0.00547211f, -0.10121963f, 0.04348529f, 
    -0.17392395f, 0.07481179f, -0.03937523f, -0.04276798f, -0.01286287f, 0.06024380f, -0.14748253f, 0.01412858f, 
    -0.00274769f, -0.04204242f, -0.13005947f, -0.35736412f, 0.06649648f, -0.10085677f, 0.07147963f, 0.04804078f, 
    -0.02842511f, 0.00485954f, -0.16309403f, -0.11108484f, -0.01013168f, 0.06849694f, -0.27209952f, -0.16033682f, 
    -0.05849838f, -0.16031960f, -0.01687839f, -0.02774382f, 0.15932086f, 0.03579678f, -0.00430788f, 0.02288108f, 
    0.00648198f, -0.00735222f, -0.02151103f, -0.03735987f, -0.07617006f, 0.01690375f, 0.05486479f, 0.04083968f, 
    -0.03230531f, -0.03178148f, -0.02395958f, 0.02751401f, -0.21141493f, -0.00625764f, -0.17797491f, 0.19306616f, 
    -0.23843047f, -0.22735436f, -0.12888338f, -0.03511794f, -0.06878820f, 0.02202465f, -0.00298340f, -0.03322003f, 
    0.00815417f, -0.03859733f, -0.01402518f, 0.05097262f, -0.03930639f, 0.04021712f, 0.08581645f, 0.05671778f, 
    -0.05011939f, -0.13399471f, 0.28243303f, 0.17279963f, 0.20562389f, -0.04594768f, -0.02571773f, 0.03173179f, 
    0.12640885f, -0.14737740f, 0.04759408f, 0.01887985f, 0.04457545f, 0.00274780f, 0.01587195f, -0.00508081f, 
    -0.04038418f, -0.02801663f, -0.01078269f, -0.00934606f, -0.00954863f, -0.05867767f, 0.05545051f, 0.00041098f, 
    0.07837967f, -0.01233114f, -0.03919091f, 0.05308535f, 0.04825091f, -0.02142624f, -0.09974529f, -0.05580653f, 
    -0.06907624f, -0.05646303f, 0.07597519f, -0.00775999f, -0.03107467f, -0.02621746f, 0.03298472f, -0.03673588f, 
    -0.70986056f, -0.74666369f, -0.59955889f, -0.26441833f, -0.73959708f, 0.18802372f, 0.03903330f, -0.09667531f, 
    -0.11215416f, -0.31698143f, -0.02708771f, 0.05572133f, 0.03103559f, 0.00962694f, -0.05662275f, -0.04151037f, 
    -0.02668580f, -0.04735500f, -0.08440331f, -0.02568106f, -0.00191118f, -0.00479128f, -0.03481400f, 0.09883069f, 
    0.08196632f, -0.01333016f, -0.02764814f, 0.03272326f, -0.05482820f, -0.15909937f, -0.03000551f, 0.00794485f, 
    0.03861150f, 0.01433855f, 0.07436469f, 0.01887250f, -0.01247887f, -0.03981009f, 0.10176191f, -0.16080916f, 
    -0.19405752f, -0.23954748f, -0.18656060f, -0.10638669f, 0.07479985f, 0.01142596f, -0.06526720f, 0.00771337f, 
    0.03679620f, 0.05936727f, -0.04333177f, -0.06142027f, -0.07297006f, 0.08939584f, -0.07429618f, 0.04098731f, 
    -0.04603477f, -0.03528724f, 0.03855729f, -0.01310379f, -0.22925989f, 0.32404494f, -0.02729448f, 0.00593039f, 
    -0.17002375f, 0.07275297f, 0.00991448f, -0.02815362f, -0.00225593f, 0.01620700f, 0.01048838f, 0.04906772f, 
    0.03731090f, -0.23224171f, 0.15141572f, 0.00190486f, -0.02264630f, 0.16268648f, 0.19882314f, -0.01902652f, 
    0.14470938f, 0.00409601f, -0.07332628f, -0.22751190f, 0.12987830f, 0.00798169f, -0.02063509f, -0.03367021f, 
    0.03785772f, 0.03739480f, 0.04813718f, -0.03803781f, -0.00074812f, 0.04752143f, 0.03309115f, -0.02041060f, 
    -0.06052263f, -0.07354346f, 0.04178771f, 0.00877368f, -0.15529707f, -0.26738551f, -0.53859514f, 0.21210966f, 
    -0.16050510f, -0.05103111f, 0.03754377f, 0.06337435f, -0.13505204f, 0.16114166f, 0.00313493f, 0.05979930f, 
    0.00724037f, 0.00389068f, -0.11982009f, -0.04110415f, 0.06323045f, 0.01113940f, -0.08846682f, 0.04532534f, 
    0.01617979f, 0.06506410f, -0.12952986f, 0.02918149f, 0.10421441f, -0.08827256f, 0.08745340f, 0.03401452f, 
    -0.04232944f, -0.06432892f, -0.09035552f, 0.07693592f, 0.04579925f, -0.01693270f, 0.00213312f, 0.02765800f, 
    -0.04914241f, 0.04048547f, 0.05020400f, 0.01434537f, -0.17734706f, -0.45369086f, 0.39629939f, 0.50303042f, 
    -0.06861328f, -0.01774171f, -0.03644202f, -0.07220879f, 0.05991739f, -0.09316135f, 0.02188075f, 0.01929411f, 
    -0.03611388f, -0.03308927f, -0.05994488f, -0.03044326f, -0.00744448f, 0.02916074f, 0.03337541f, -0.08311276f, 
    -0.15203989f, 0.16446799f, 0.22399725f, -0.01201019f, 0.00796022f, 0.01207015f, -0.06087814f, 0.00833827f, 
    -0.04203383f, 0.11947515f, 0.02297501f, -0.08275407f, 0.18179412f, -0.03903178f, 0.01646068f, 0.01937882f, 
    0.03826023f, -0.05335322f, 0.06432796f, -0.11989555f, 0.46732098f, 0.14099984f, 0.15018916f, -0.00102939f, 
    0.23149532f, -0.03629372f, -0.06077499f, -0.08668323f, 0.03901734f, 0.01948112f, 0.06371213f, -0.05153336f, 
    0.15716454f, -0.01798088f, 0.04313230f, 0.00838316f, 0.01231399f, -0.01197959f, -0.04001712f, -0.01193188f, 
    -0.06417688f, -0.02090019f, -0.13693023f, -0.01404958f, 0.22614776f, -0.03374426f, -0.03067484f, -0.05146151f, 
    -0.03173625f, -0.06037861f, -0.05907612f, 0.11252884f, -0.00792801f, 0.06784913f, 0.06819043f, -0.02335125f, 
    -0.00091861f, 0.07224178f, -0.04042498f, 0.01105694f, 0.09326667f, -0.04260378f, -0.05963833f, -0.12633795f, 
    0.18836708f, 0.08268768f, 0.05326819f, 0.00131147f, -0.00130994f, -0.04686637f, -0.00221249f, 0.00071072f, 
    0.05397386f, 0.04963102f, 0.14102107f, -0.09792450f, 0.02148299f, 0.01350433f, 0.00433375f, -0.02252775f, 
    0.03775433f, -0.01745398f, -0.04183335f, -0.40087810f, -0.05973315f, 0.10324144f, 0.11679142f, 0.05786410f, 
    0.16242997f, -0.08653723f, 0.06912327f, 0.00801326f, -0.02013156f, 0.02290973f, -0.00868735f, 0.02542166f, 
    0.00974702f, 0.17994063f, -0.11467442f, -0.12793170f, -0.16257413f, 0.11269419f, -0.14986496f, -0.01555176f, 
    0.17291085f, 0.14405176f, 0.10893317f, -0.01495752f, 0.06347053f, 0.02918182f, -0.04582290f, 0.00288502f, 
    -0.03455060f, 0.04162074f, 0.00194274f, -0.03771742f, -0.06130197f, 0.00382725f, 0.05131336f, -0.04220394f, 
    -0.37806013f, 0.20218022f, -0.00872026f, -0.26458085f, -0.27928475f, 0.04762838f, 0.02749576f, 0.03034831f, 
    0.11650790f, 0.08828338f, 0.05882640f, 0.00776196f, 0.04690308f, -0.04580154f, -0.01098263f, 0.00519389f, 
    0.04296818f, -0.01799304f, -0.11801978f, -0.03392453f, 0.05156861f, 0.00352154f, -0.00637448f, 0.06833202f, 
    0.18130933f, 0.02530787f, 0.06145636f, -0.03899571f, 0.02000540f, -0.02782836f, -0.01375824f, -0.00399325f, 
    -0.02554771f, 0.03578983f, -0.01326545f, -0.07256581f, -0.05561734f, 0.08148025f, -0.18597554f, -0.08809189f, 
    -0.09044289f, -0.26394409f, -0.20060490f, -0.03043449f, 0.23583454f, 0.08038995f, -0.03808432f, 0.04155742f, 
    0.09490692f, -0.00877133f, -0.02300061f, 0.05942637f, 0.06921165f, 0.01501005f, -0.04594513f, 0.04715069f, 
    0.02373236f, 0.13730116f, 0.06704501f, 0.05356321f, -0.04424725f, -0.12790167f, -0.07936912f, 0.05364230f, 
    0.18025523f, -0.01065654f, 0.00655149f, 0.05717386f, 0.05016258f, -0.03253101f, 0.01571133f, -0.00992936f, 
    0.04012696f, -0.10296198f, 0.00971100f, -0.00977737f, 0.00627428f, 0.08336607f, -0.07624409f, 0.02335028f, 
    -0.48793224f, 0.35489672f, -0.29119569f, -0.07329562f, -0.30390313f, 0.03057739f, 0.01293252f, 0.08322184f, 
    0.10018395f, 0.04468030f, -0.08505166f, -0.07604621f, -0.11977482f, -0.08076493f, -0.00771264f, -0.15228423f, 
    -0.15012828f, -0.14431167f, -0.13097242f, -0.12307226f, -0.01662419f, -0.06604544f, -0.16157693f, -0.07777151f, 
    0.16184226f, 0.00094667f, 0.00828520f, 0.06340072f, 0.08080700f, 0.04918269f, -0.08196221f, 0.02906533f, 
    -0.00958469f, 0.03350538f, -0.01299066f, 0.08184707f, 0.09525680f, 0.18646148f, -0.06010071f, 0.09466858f, 
    -0.84024096f, 0.75118601f, -0.09194262f, -0.26694381f, 0.23766807f, 0.16596738f, 0.06262683f, -0.03995181f, 
    -0.05493104f, 0.02563800f, -0.11271261f, -0.05893558f, 0.08310412f, -0.09286469f, 0.08756055f, -0.02620379f, 
    0.17774044f, -0.03622699f, -0.09672756f, -0.08160647f, 0.23121692f, 0.08835293f, 0.10947144f, -0.12628467f, 
    -0.09588967f, -0.14415027f, -0.12303234f, -0.01753499f, -0.10768119f, 0.02475826f, 0.06165812f, -0.01926793f, 
    0.06820703f, 0.02325369f, -0.02334795f, -0.02183973f, -0.05553373f, -0.08372509f, 0.07436500f, -0.00058745f, 
    -0.16127762f, -0.02095467f, -0.01240582f, 0.03610883f, 0.03252763f, -0.01212697f, 0.02571368f, 0.05419849f, 
    0.05636042f, 0.02199079f, -0.05028418f, 0.08213422f, -0.00538719f, 0.02936372f, 0.01189610f, 0.01323616f, 
    -0.05448414f, 0.14582285f, -0.04976796f, 0.05005438f, -0.13549222f, -0.11579813f, -0.01858810f, -0.02859299f, 
    -0.31322700f, -0.01390058f, -0.07022998f, -0.22209232f, -0.01473954f, -0.08961418f, 0.01552885f, 0.00043359f, 
    0.00478174f, -0.11817460f, -0.08305521f, -0.08802976f, -0.03098678f, -0.02005355f, -0.07076465f, -0.09449063f, 
    -0.15651946f, 0.29240125f, -0.02152624f, 0.05044213f, 0.25310293f, 0.11433826f, -0.04267887f, -0.06536226f, 
    -0.12948193f, -0.00793234f, -0.03287648f, 0.02457637f, -0.01129287f, 0.01942212f, 0.01961458f, 0.08820097f, 
    -0.03503820f, 0.11228579f, -0.00253811f, -0.01035034f, -0.29223597f, -0.05976539f, 0.22025034f, 0.10158031f, 
    -0.00804855f, -0.18002780f, -0.22321890f, 0.01321407f, 0.09785769f, -0.01156536f, 0.07329026f, -0.01023212f, 
    0.09451810f, -0.09168934f, -0.01179834f, -0.07171534f, -0.01972714f, 0.00259617f, 0.17927201f, -0.08815233f, 
    -0.08905388f, 0.00639237f, -0.24294573f, -0.00918799f, 0.09754819f, -0.03864179f, -0.07065683f, -0.03968689f, 
    0.02280733f, 0.00237853f, -0.11927286f, 0.01205281f, -0.01576047f, -0.05737053f, 0.00384176f, -0.00166984f, 
    -0.05515604f, 0.02239816f, -0.12583120f, -0.04158811f, -0.07594263f, -0.03864357f, -0.13758309f, -0.03255150f, 
    0.25359482f, 0.11561399f, -0.06063009f, 0.07865199f, -0.05775126f, 0.03838875f, -0.11735353f, 0.04273000f, 
    -0.02477071f, 0.02577249f, 0.03579370f, 0.08846904f, -0.01703188f, -0.04455769f, -0.02002731f, 0.10486016f, 
    0.06757319f, -0.13112743f, -0.03220090f, 0.04772602f, 0.32939941f, -0.12980519f, 0.11193541f, 0.00184793f, 
    0.03630226f, 0.12200566f, 0.00432198f, 0.02517689f, -0.05159456f, -0.04708241f, 0.03113378f, -0.00865319f, 
    -0.06825461f, 0.00474424f, 0.05664068f, -0.00386906f, -0.42480317f, -0.23055084f, -0.10183088f, -0.04690142f, 
    -0.17040575f, 0.03587747f, -0.09949876f, -0.00755219f, -0.00127241f, -0.02404497f, 0.02292214f, 0.05286961f, 
    0.02768083f, 0.02701249f, -0.10239366f, -0.02599710f, -0.00658390f, -0.04707858f, -0.04025161f, -0.12073894f, 
    -0.11869176f, 0.16266491f, -0.02312753f, 0.28741571f, 0.33794060f, -0.02126914f, -0.02652096f, -0.00165491f, 
    -0.01347946f, -0.04679422f, -0.03048748f, -0.02568113f, 0.14513880f, 0.03082333f, -0.02469083f, 0.02730500f, 
    -0.02750717f, -0.01479442f, -0.02849595f, -0.06701079f, 0.12758410f, 0.18396203f, 0.37743121f, -0.11424364f, 
    0.34605074f, 0.01946040f, 0.12893106f, -0.03120311f, -0.00893930f, -0.10826549f, -0.06257849f, 0.00687933f, 
    -0.13088478f, 0.00042585f, -0.18603277f, -0.02612358f, -0.05734606f, 0.08381317f, 0.10093433f, -0.02267121f, 
    -0.49792004f, 0.62744784f, -0.02053352f, -0.15937105f, 0.20430200f, 0.27801648f, 0.01454074f, -0.04521313f, 
    -0.05896640f, -0.01646395f, -0.18939699f, -0.01313837f, -0.01893001f, -0.01357358f, 0.05434826f, -0.00817482f, 
    0.04315650f, -0.09420633f, 0.02522071f, 0.02872152f, 0.23720597f, 0.13198096f, -0.08898463f, -0.06654423f, 
    0.17602500f, 0.13336845f, 0.03773744f, 0.04725792f, 0.11924914f, 0.00661309f, -0.09274877f, 0.05740861f, 
    0.05113517f, 0.15072758f, 0.11086620f, -0.08245113f, 0.12565380f, -0.02200850f, -0.01676790f, 0.08724131f, 
    -0.23401517f, -0.02145775f, 0.02865980f, 0.25179419f, 0.31437489f, 0.08015589f, 0.05068786f, 0.09267993f, 
    0.06321576f, 0.11364555f, -0.00637128f, 0.02170509f, 0.03296437f, -0.06475012f, -0.11247241f, 0.03083489f, 
    -0.04275439f, 0.09626281f, 0.06112333f, -0.06352067f, 0.23268692f, 0.10699292f, -0.18491636f, -0.23058929f, 
    0.08484697f, -0.06801062f, -0.07438315f, -0.11007932f, 0.04364510f, -0.13194326f, -0.08954142f, -0.00974228f, 
    -0.08966704f, -0.04969936f, 0.02921642f, 0.02252323f, -0.00137136f, -0.10713585f, -0.10108959f, -0.00805108f, 
    -0.10341024f, -0.02275608f, -0.18558927f, 0.08107369f, 0.19995172f, 0.02762180f, -0.00426900f, 0.03084891f, 
    0.00985856f, 0.08384424f, -0.01180263f, 0.03948716f, 0.05101621f, -0.01795790f, -0.06787284f, 0.04490104f, 
    -0.08008666f, 0.06557970f, -0.01123819f, -0.05805363f, 0.31188050f, 0.39697638f, 0.10894187f, -0.38024256f, 
    0.18355177f, -0.07645495f, -0.03180657f, 0.05377118f, -0.06532859f, 0.09511594f, 0.04875635f, -0.00482378f, 
    -0.01353192f, 0.06229286f, -0.02635016f, -0.04368876f, -0.05748839f, 0.05551104f, 0.04339606f, 0.03396533f, 
    -0.03656071f, -0.26055497f, -0.02788523f, -0.16781659f, -0.15978859f, 0.10897697f, -0.07200725f, 0.14587002f, 
    -0.07341851f, 0.04172463f, -0.04689874f, -0.08480809f, -0.07174002f, 0.07713875f, -0.05092605f, -0.01008350f, 
    0.04721842f, -0.08795389f, -0.05538929f, -0.05122542f, -0.19862454f, -0.24091282f, -0.15257376f, -0.01492489f, 
    0.04217598f, 0.13175775f, -0.08789501f, 0.05832694f, 0.04629540f, -0.01848027f, -0.02257505f, -0.05502335f, 
    -0.15842277f, -0.11047387f, -0.08489576f, 0.12467513f, 0.09104282f, 0.17602809f, 0.07302983f, -0.21332091f, 
    -0.15154532f, -0.12458605f, -0.01431639f, 0.07122609f, 0.06385764f, 0.10884469f, 0.04006090f, 0.15844645f, 
    0.12248001f, 0.02478097f, 0.05429726f, 0.05680020f, -0.03473635f, 0.01365403f, 0.04183261f, 0.08554062f, 
    -0.03575834f, 0.13905664f, -0.02352085f, -0.14579783f, 0.07882100f, -0.07256959f, -0.03291810f, -0.09082734f, 
    0.16904190f, 0.06793331f, -0.05240924f, 0.03333366f, -0.02775683f, -0.02176445f, -0.08148947f, 0.07806619f, 
    0.06768960f, 0.00791082f, 0.03065126f, -0.02789475f, -0.05085190f, 0.00918293f, 0.06285184f, 0.11336296f, 
    0.26490772f, 0.13471569f, -0.27226889f, -0.03267801f, -0.25482297f, 0.12681773f, 0.09342678f, 0.06840266f, 
    0.05391208f, 0.13482268f, -0.11284314f, -0.12350117f, 0.02404992f, -0.07867540f, 0.02570831f, -0.15349959f, 
    -0.06589049f, -0.12524576f, 0.12579809f, 0.02690545f, -0.80558795f, -0.07337771f, 0.13684267f, -0.18020624f, 
    0.16615491f, 0.03552905f, 0.04574924f, 0.05485561f, -0.15481378f, -0.02835318f, -0.13174735f, 0.06990931f, 
    0.03881572f, 0.15255025f, -0.04524511f, -0.02770504f, 0.02144947f, 0.05810210f, -0.05958053f, 0.02567099f, 
    -0.09310576f, -0.01230398f, -0.14537716f, -0.03645859f, 0.14865279f, -0.00481246f, -0.01534080f, 0.00941138f, 
    0.02174814f, 0.07783454f, -0.18090446f, 0.07650734f, -0.09930629f, -0.01056051f, 0.08484645f, -0.06797850f, 
    0.01502209f, 0.15819372f, -0.06270312f, -0.01893419f, 0.17588991f, 0.05627188f, 0.15015018f, -0.22610950f, 
    0.21648440f, -0.08080006f, -0.02462252f, 0.02949970f, -0.02143121f, 0.00767679f, 0.12638439f, -0.00700150f, 
    -0.03349363f, 0.02274892f, 0.11532647f, -0.02526034f, -0.11226649f, -0.02914041f, -0.08808178f, 0.06580308f, 
    -0.67714155f, 0.11264436f, 0.16504215f, 0.58119029f, 0.41963658f, -0.03448959f, -0.12919526f, 0.10677363f, 
    0.07036197f, -0.07383942f, 0.01693777f, 0.14950958f, 0.00141960f, 0.03920152f, -0.05340302f, -0.03694790f, 
    0.13867174f, -0.07202623f, 0.05317508f, -0.19824602f, -0.46454886f, -0.42092347f, -0.08993247f, -0.15489206f, 
    -0.29860410f, -0.10024532f, -0.25426352f, 0.02442189f, -0.08912466f, -0.16591303f, 0.13749915f, 0.04825693f, 
    0.09720118f, 0.04682845f, 0.07044261f, 0.00645247f, 0.00501096f, -0.06140254f, 0.01227372f, -0.13490161f, 
    -0.04487210f, 0.44362792f, -0.14066042f, -0.28761062f, -0.25512296f, -0.04586679f, -0.24550253f, -0.02255516f, 
    -0.04758137f, 0.02418199f, -0.13478151f, -0.12670183f, -0.12628916f, 0.02345826f, -0.00539580f, -0.02674735f, 
    -0.03849902f, -0.05250011f, -0.03742472f, -0.01683603f, -0.26588234f, 0.24089530f, -0.09824111f, -0.02968735f, 
    0.00345637f, 0.07374779f, -0.05315605f, 0.11550147f, -0.05144080f, -0.01040234f, -0.11535203f, -0.02644516f, 
    -0.00406851f, 0.01435539f, -0.03156926f, -0.05480279f, -0.04259672f, -0.11345705f, -0.08256740f, -0.01462947f, 
    -0.06118189f, -0.07586224f, 0.42775267f, -0.23240450f, 0.24311183f, -0.23945108f, 0.05856925f, -0.04678346f, 
    -0.02845069f, -0.03696925f, 0.08647963f, 0.01333025f, -0.02099557f, -0.01242817f, 0.08620860f, -0.02701540f, 
    0.01518624f, 0.15105678f, -0.15777494f, -0.07504472f, -0.36130512f, -0.10315051f, 0.04032542f, 0.16455857f, 
    0.00819544f, -0.21051572f, -0.20843256f, -0.04228062f, -0.08943588f, -0.26568231f, 0.03226310f, 0.07569040f, 
    -0.06319648f, -0.10130979f, 0.03449221f, -0.06074129f, 0.02433838f, 0.08155363f, -0.06558244f, -0.00234883f, 
    0.46428874f, 0.20879483f, 0.10931518f, -0.43287981f, 0.31946805f, 0.04051122f, 0.04644718f, 0.09047160f, 
    -0.01989161f, 0.01549631f, -0.00778562f, -0.00301285f, -0.02501757f, -0.03989681f, -0.04993049f, -0.02420439f, 
    -0.11271168f, 0.06855626f, 0.14851405f, 0.01669304f, 0.43252173f, 0.42675176f, 0.51361662f, -0.30675238f, 
    0.34070683f, -0.10902335f, -0.00303351f, -0.10370915f, -0.12159648f, 0.04301831f, -0.01927309f, 0.03715864f, 
    0.09937215f, -0.01729533f, 0.00824249f, 0.02452223f, -0.05679789f, -0.10264971f, -0.01356299f, -0.05061157f, 
    -0.23181728f, -0.00707632f, -0.15734424f, 0.03389079f, -0.14536431f, -0.11727158f, -0.04289486f, -0.01800600f, 
    0.02999325f, -0.18760990f, 0.05752454f, 0.02631820f, 0.02245047f, -0.02813494f, -0.09432199f, -0.02220794f, 
    -0.03217136f, -0.00412444f, -0.07122648f, 0.00796297f, 0.17853279f, -0.45770246f, -0.00025676f, -0.00567181f, 
    0.15904085f, 0.06275406f, 0.02927432f, -0.03723260f, -0.00735794f, -0.10030413f, 0.02799033f, -0.14035872f, 
    0.10313486f, -0.04092328f, -0.08283121f, -0.09246165f, -0.06772507f, 0.19457665f, 0.00632599f, -0.16850020f, 
    -0.04780775f, -0.05578107f, -0.23483624f, -0.12392277f, -0.03272168f, 0.02552799f, -0.08418287f, 0.01069854f, 
    0.02428176f, -0.05450436f, -0.00094709f, -0.02840415f, -0.12511191f, -0.04402866f, -0.00853611f, 0.10518234f, 
    -0.06571320f, 0.03064023f, -0.04605585f, -0.03684325f, -0.50493842f, 0.52224874f, -0.14260751f, -0.10244265f, 
    0.26434824f, 0.26011112f, 0.10972860f, -0.02196045f, 0.03325677f, 0.02141901f, -0.19383799f, -0.01790355f, 
    0.00987952f, -0.01300133f, 0.12103434f, -0.05067238f, 0.03902665f, 0.00108912f, 0.12186471f, 0.00098553f, 
    0.23376481f, 0.55673605f, -0.28855839f, -0.57364309f, -0.10399032f, -0.11214752f, -0.03734694f, -0.15038931f, 
    -0.14310072f, -0.15043053f, -0.00634370f, 0.05147433f, -0.15725426f, -0.01695608f, 0.03145402f, 0.17826691f, 
    -0.02296058f, -0.03519746f, -0.16767751f, -0.14971067f, 0.16962302f, -0.10266133f, -0.11528604f, -0.29821286f, 
    -0.19401041f, 0.09906447f, 0.08048873f, -0.06977718f, 0.01856142f, 0.06657239f, -0.03560377f, 0.03690365f, 
    -0.08568026f, 0.01618375f, 0.02654716f, -0.00754665f, -0.06898803f, 0.06905348f, -0.10351466f, -0.03469933f, 
    0.20828617f, -0.03959108f, -0.22177243f, -0.12477360f, -0.21290624f, 0.26324606f, 0.10902856f, 0.15754400f, 
    0.03173250f, -0.02397823f, -0.08396341f, -0.00737841f, 0.08947139f, -0.13429159f, -0.00859811f, -0.06200025f, 
    -0.03062548f, -0.20459302f, -0.01769872f, 0.03842400f, -0.33961141f, 0.12146664f, -0.08364026f, 0.15032610f, 
    -0.04555117f, -0.07192907f, 0.03507319f, 0.04891266f, 0.02752410f, 0.07453031f, -0.01540996f, 0.05568948f, 
    0.01142015f, -0.14860110f, 0.00719630f, 0.12543908f, 0.02524919f, 0.00709593f, 0.01267057f, -0.05419840f, 
    0.17926849f, 0.03135695f, -0.00374242f, -0.15489307f, 0.25877059f, 0.21342422f, 0.05256360f, -0.06954955f, 
    -0.06207395f, -0.21372414f, -0.15966225f, 0.08674554f, 0.10496487f, 0.01475839f, 0.01816261f, -0.07324160f, 
    0.07096373f, -0.08287516f, 0.11482598f, 0.03653478f, -0.06602053f, 0.00100477f, -0.16708302f, -0.06027084f, 
    -0.05122611f, 0.14532143f, 0.04000934f, 0.06765361f, -0.01776603f, 0.07749417f, -0.13674326f, 0.02098373f, 
    0.01478406f, -0.05809967f, -0.01179667f, 0.03206221f, 0.07410160f, -0.00627916f, 0.01802991f, 0.02980193f, 
    0.03656089f, -0.11329705f, -0.35184282f, -0.01028498f, 0.26712748f, 0.09109085f, 0.11263440f, 0.09853417f, 
    0.08615175f, 0.15148206f, 0.02031650f, -0.03718361f, 0.03233463f, -0.04989231f, -0.07064028f, -0.04446941f, 
    -0.08540132f, 0.04668437f, -0.07282341f, 0.07812361f, -0.08960041f, -0.08811375f, -0.08248388f, -0.01261417f, 
    0.10327591f, 0.02554980f, 0.00690165f, 0.03514124f, -0.07203019f, 0.01806203f, -0.01109297f, 0.02097891f, 
    -0.00273351f, -0.06952102f, -0.15931000f, 0.00396761f, -0.06650855f, 0.08219358f, -0.00946478f, -0.11402173f, 
    -0.33506879f, -0.38988557f, -0.29278269f, 0.14847478f, -0.25248536f, 0.20935731f, 0.01410183f, 0.15913473f, 
    0.13586704f, 0.11758716f, -0.03753917f, 0.02158117f, 0.15675639f, -0.17058015f, -0.09034628f, -0.13733993f, 
    -0.08759665f, -0.20661293f, 0.02844348f, 0.10912891f, -0.84503824f, 0.41320279f, -0.08711383f, 0.06062915f, 
    -0.07598874f, 0.01443139f, -0.00418645f, 0.07967480f, -0.03606490f, 0.04620850f, -0.09151355f, -0.03084311f, 
    -0.05651067f, -0.06506664f, 0.02964639f, 0.00085472f, -0.01864187f, 0.03927171f, -0.06495126f, -0.05174593f, 
    -0.09644322f, 0.30823383f, 0.18295036f, -0.32606709f, -0.29392293f, -0.20060149f, -0.19135761f, -0.02302046f, 
    -0.13254395f, 0.02811435f, -0.07825131f, -0.16599548f, -0.07416319f, 0.21485786f, 0.05105478f, -0.01335673f, 
    0.02269324f, -0.14309421f, 0.03149645f, 0.01736499f, -0.31383586f, -0.00146016f, -0.08961441f, -0.45965490f, 
    0.03804243f, 0.11268491f, -0.01609551f, -0.06757278f, 0.16391577f, 0.02725998f, -0.05665996f, 0.03315413f, 
    -0.12323330f, 0.02738681f, 0.06335717f, 0.07805893f, 0.05802684f, 0.13160625f, -0.22447738f, -0.01163177f, 
    0.14020538f, 0.00969497f, -0.08229535f, -0.20347843f, -0.25610700f, 0.01335050f, -0.18800551f, -0.01458227f, 
    0.00824057f, -0.05293145f, 0.03651408f, -0.01407663f, 0.01898626f, -0.09105224f, -0.03436720f, 0.09429246f, 
    -0.10675585f, -0.20567828f, 0.04317908f, 0.05786471f, -0.03934655f, -0.00602252f, -0.30551329f, -0.00183198f, 
    0.25476027f, 0.03271540f, 0.05016311f, -0.06415675f, -0.03014516f, 0.00765386f, -0.09687931f, 0.07759531f, 
    -0.06063338f, 0.04041571f, 0.08092007f, -0.05782233f, 0.02486298f, 0.13253957f, 0.12129416f, -0.01932324f, 
    0.24828731f, 0.15918164f, -0.12948856f, 0.20702747f, -0.11737782f, 0.03000911f, -0.06450544f, 0.02868836f, 
    0.10660233f, -0.01658108f, -0.04929158f, -0.05920528f, -0.11301336f, -0.09451205f, -0.03382536f, -0.07771422f, 
    -0.08561912f, -0.03242748f, 0.05958455f, -0.08713958f, -0.46918949f, 0.66527474f, 0.23479192f, -0.46569937f, 
    0.11417108f, 0.17417346f, 0.02568489f, -0.16246828f, 0.01129260f, -0.06836645f, 0.07201767f, -0.02619712f, 
    0.07525060f, -0.08269948f, -0.02861085f, 0.14146358f, 0.14054075f, -0.06287936f, 0.01202677f, -0.01459584f, 
    -0.03930535f, -0.05276129f, 0.08343229f, 0.08200932f, 0.05870538f, -0.17201352f, -0.01656991f, -0.04009243f, 
    -0.00542064f, -0.11607770f, -0.02475856f, -0.00627175f, 0.00411744f, 0.00624812f, 0.03783322f, -0.05100558f, 
    0.00741011f, -0.01306444f, 0.03317701f, 0.06100904f, -0.11966277f, -0.04593901f, 0.04665304f, 0.04062967f, 
    -0.03053778f, -0.08387205f, -0.12397617f, -0.10103723f, -0.18960853f, -0.05221235f, -0.05725002f, 0.02961440f, 
    -0.08182133f, 0.06035670f, -0.13964155f, 0.08847358f, 0.02497962f, 0.04155556f, 0.03523473f, 0.12387226f, 
    0.01071594f, -0.18011527f, -0.06113831f, 0.04993481f, -0.26403919f, 0.01298483f, 0.01589833f, 0.05718672f, 
    0.00440520f, 0.01188605f, 0.01616359f, -0.01637901f, -0.14748825f, -0.04419199f, 0.15746471f, -0.06694816f, 
    0.06094107f, 0.10662545f, -0.22499277f, 0.14393538f, 0.18571860f, -0.11072001f, 0.21237975f, 0.02654458f, 
    -0.01019847f, -0.10017632f, -0.08321048f, -0.05010998f, 0.08131284f, 0.03416982f, 0.05923531f, -0.10681283f, 
    0.03907597f, -0.10588522f, 0.09599093f, 0.00472810f, 0.02928421f, 0.00676063f, -0.04566050f, -0.03785649f, 
    -0.21312343f, -0.08358498f, -0.22943701f, -0.31445080f, -0.15107602f, 0.02874727f, 0.03528069f, 0.01888991f, 
    0.05266142f, 0.05926352f, -0.02974226f, -0.04189856f, 0.04026641f, 0.01542270f, 0.01793607f, -0.00133794f, 
    0.14477079f, -0.01808766f, 0.11928316f, 0.19578891f, -0.05789801f, 0.03662900f, 0.18547362f, 0.22328077f, 
    -0.01087862f, -0.04546259f, 0.00216868f, -0.04222384f, -0.08002016f, -0.01760813f, -0.01454723f, -0.03448288f, 
    -0.02562578f, -0.03182598f, -0.03823630f, 0.01497617f, 0.02195660f, -0.18876827f, 0.07821289f, 0.14385824f, 
    0.10553317f, 0.11936878f, 0.08146020f, 0.12732185f, -0.01194432f, -0.03371244f, -0.06686116f, -0.14642759f, 
    -0.07183499f, 0.03708266f, 0.14928122f, 0.04732380f, 0.00860100f, 0.04593412f, 0.03058138f, 0.10508648f, 
    0.03427152f, -0.05436533f, -0.05421885f, -0.06324334f, -0.00663291f, 0.04051963f, 0.23464657f, 0.08361223f, 
    0.11245293f, -0.05135382f, -0.00054983f, -0.06064910f, 0.00822645f, 0.10512003f, 0.02463408f, 0.01781336f, 
    0.05107792f, 0.01561357f, 0.03126830f, 0.05260921f, 0.04841182f, -0.09135091f, -0.02110958f, 0.03098226f, 
    0.15487617f, -0.28750193f, -0.12282775f, -0.14450763f, -0.14275748f, 0.02603365f, 0.04547929f, 0.02617561f, 
    -0.01350433f, 0.00934118f, -0.02880999f, -0.04622676f, -0.06410124f, 0.01500505f, -0.10272955f, -0.06856409f, 
    -0.06916023f, 0.03011618f, -0.07577112f, -0.11285322f, -0.06465507f, -0.03594416f, 0.10801332f, 0.10759326f, 
    0.03431995f, -0.09088068f, 0.05047869f, -0.09917271f, -0.08992814f, -0.00969913f, 0.02011498f, -0.00882012f, 
    0.02707719f, 0.03727426f, 0.09143098f, 0.10347679f, 0.03632773f, 0.02669480f, 0.02076780f, 0.04890160f, 
    -0.04425323f, -0.34963107f, -0.11213502f, -0.09905989f, -0.05222712f, -0.19041893f, -0.15808243f, 0.05837760f, 
    0.05814593f, -0.07321454f, -0.10477123f, -0.01696579f, -0.05511154f, 0.01990875f, -0.08101127f, -0.04364141f, 
    -0.04713264f, 0.01702781f, 0.02031231f, -0.06072225f, -0.04629908f, 0.01480168f, 0.00530208f, 0.11299074f, 
    -0.09186649f, 0.00287528f, 0.04113884f, 0.03615762f, -0.01956262f, 0.03266598f, 0.11778294f, -0.05902825f, 
    -0.05266730f, 0.02217395f, 0.01619022f, -0.01824098f, 0.10547874f, 0.04492920f, -0.16555856f, -0.01580612f, 
    0.01473378f, -0.10047781f, 0.23662686f, -0.03344690f, 0.02068521f, -0.12313311f, 0.04188696f, 0.07197775f, 
    -0.07413066f, -0.06291704f, 0.02131051f, -0.02683555f, -0.05725253f, -0.01348350f, -0.01208561f, 0.03585581f, 
    0.10508570f, 0.03070895f, -0.07362620f, 0.11184010f, -0.15331684f, -0.03191682f, -0.05504251f, -0.13595188f, 
    -0.02107553f, -0.06571009f, 0.01267678f, 0.01452714f, 0.07145870f, -0.02528483f, 0.02160017f, -0.03397544f, 
    0.00625627f, 0.00011822f, 0.00213009f, -0.05367056f, 0.02900092f, -0.08702403f, -0.04283678f, 0.08749519f, 
    0.02320545f, -0.10262618f, 0.17158663f, 0.07147615f, 0.04599962f, -0.08917131f, -0.03352010f, -0.07029813f, 
    -0.01637021f, -0.10028497f, 0.07545734f, -0.09299572f, -0.04186220f, 0.04294572f, -0.03851805f, 0.04383577f, 
    0.01676181f, 0.06698420f, 0.00069193f, -0.08774178f, -0.00386481f, 0.00033222f, -0.02468622f, 0.11448671f, 
    0.09536753f, -0.07627844f, 0.08245210f, -0.05894835f, 0.01581518f, -0.00868304f, 0.10296609f, -0.03267710f, 
    -0.05230309f, -0.02213164f, 0.00000661f, -0.09156835f, -0.08431881f, 0.06618427f, -0.08884002f, -0.06595984f, 
    0.00031999f, 0.02854422f, 0.18453188f, 0.10277006f, 0.12521221f, -0.09440358f, 0.08923304f, 0.02418728f, 
    0.06865317f, -0.04172564f, 0.00259164f, -0.04334783f, 0.01052833f, 0.05682740f, 0.04668124f, -0.03193142f, 
    -0.02745546f, -0.03689006f, 0.00263513f, -0.03874698f, 0.12341864f, -0.01397944f, 0.15916371f, 0.15981387f, 
    0.05360751f, -0.11464858f, -0.08693534f, -0.09303325f, -0.07840123f, 0.05188464f, 0.06695806f, -0.01306622f, 
    0.09238226f, -0.02175493f, 0.05654455f, 0.02790555f, 0.01718237f, 0.05701607f, -0.04665300f, -0.04541305f, 
    0.14930366f, 0.08964960f, 0.14337035f, 0.16593488f, 0.09032133f, 0.13868478f, 0.12785618f, 0.00775577f, 
    0.17598507f, 0.08766599f, 0.04490289f, -0.02507611f, 0.00892487f, 0.00340357f, -0.04645059f, 0.10106456f, 
    0.16414972f, 0.00773564f, 0.13011228f, 0.23191552f, 0.02299703f, 0.06458433f, 0.03034815f, 0.00394755f, 
    -0.01372134f, 0.08173905f, 0.02880917f, 0.04590823f, 0.05900452f, 0.03693857f, 0.09323663f, 0.09119924f, 
    0.02612149f, 0.04891181f, 0.11854828f, 0.14426480f, 0.09164338f, -0.06100082f, -0.02483678f, 0.07042525f, 
    -0.16704330f, -0.07927404f, 0.04283017f, -0.16187522f, -0.12727344f, 0.01781108f, 0.16836889f, -0.17935403f, 
    0.00273406f, -0.10035873f, 0.00119422f, -0.04783370f, -0.07320261f, 0.15118176f, 0.08043883f, -0.08497092f, 
    0.01714886f, -0.07046185f, -0.02768305f, -0.04682367f, 0.12602077f, 0.12809293f, -0.19135468f, 0.00737202f, 
    -0.23595276f, 0.11175019f, -0.13206732f, -0.19650319f, -0.22226374f, 0.00514617f, 0.00534004f, -0.05919950f, 
    0.06398898f, 0.01578584f, 0.07514064f, 0.02071528f, -0.01623933f, 0.03137695f, -0.20265925f, -0.18146285f, 
    0.06363944f, -0.26049832f, 0.25106934f, 0.11978927f, 0.01669428f, -0.16160999f, -0.10256309f, 0.01428866f, 
    -0.05022817f, 0.07941455f, -0.00402323f, 0.04283647f, -0.09013455f, -0.11696527f, -0.01326091f, 0.05571338f, 
    0.06053633f, 0.07481442f, -0.01420038f, 0.00098269f, -0.31609127f, -0.13714682f, 0.08402926f, 0.04393212f, 
    0.14974873f, 0.03549447f, 0.15138184f, -0.05248817f, -0.01604562f, 0.09653300f, 0.03157351f, 0.02275092f, 
    -0.16326760f, -0.10711556f, 0.00242952f, -0.03576482f, 0.02773232f, 0.03787850f, 0.07142091f, 0.09477828f, 
    0.05430201f, 0.05375644f, 0.21227515f, -0.10384996f, 0.04267182f, 0.13328986f, 0.02356642f, 0.15166137f, 
    -0.11654957f, 0.09922021f, 0.03249077f, 0.07578411f, 0.11882728f, -0.04440469f, -0.00666687f, -0.00265237f, 
    -0.04817786f, -0.08295055f, -0.16630471f, -0.19625090f, -0.18725556f, -0.08627671f, 0.10431101f, -0.16702972f, 
    0.00730868f, -0.09681036f, 0.05280880f, -0.03869081f, 0.09112996f, -0.09183930f, 0.02775953f, -0.02373654f, 
    -0.03892565f, -0.00700335f, -0.02523193f, -0.08508414f, -0.14597481f, -0.00722060f, -0.07787044f, 0.00116347f, 
    0.16314617f, -0.02185615f, 0.30400547f, 0.06776119f, 0.10481863f, -0.06836589f, -0.05045380f, -0.02148806f, 
    -0.06817030f, -0.07257374f, -0.01762694f, 0.00890013f, 0.00946989f, 0.03966669f, 0.02347323f, -0.01956652f, 
    -0.04740653f, -0.06611251f, -0.05460608f, -0.17262030f, 0.26664793f, -0.34691563f, -0.08496794f, 0.47395790f, 
    0.10430354f, 0.11747470f, -0.04787739f, 0.08086555f, -0.06079678f, 0.01357473f, -0.02404227f, -0.07280427f, 
    -0.05668898f, -0.04334137f, 0.05562725f, 0.09673882f, -0.07634794f, 0.06557165f, -0.05898141f, -0.18976466f, 
    0.07223082f, 0.03980879f, -0.09109465f, -0.04323712f, -0.03791427f, 0.04152200f, -0.03758652f, -0.03520666f, 
    0.05426322f, 0.01065455f, -0.01849385f, -0.14339824f, 0.02223065f, -0.16514093f, 0.10736501f, 0.01907159f, 
    -0.02838421f, 0.01877085f, -0.01694157f, -0.03737449f, 0.04464657f, 0.00275896f, 0.04053064f, -0.03190397f, 
    -0.01424015f, 0.07341258f, 0.10069316f, 0.11270015f, 0.01747997f, 0.07847568f, 0.01198066f, 0.09683429f, 
    0.13177946f, -0.01616324f, 0.03389220f, 0.12885846f, -0.11234674f, -0.07391119f, -0.08148957f, -0.04613650f, 
    0.02652848f, 0.03709818f, 0.14511034f, 0.04008837f, 0.16128117f, 0.11311809f, 0.07600921f, 0.05005750f, 
    -0.07687569f, 0.10812931f, 0.01058229f, 0.09442179f, 0.00447997f, -0.02592185f, 0.05063590f, 0.03448786f, 
    -0.08378890f, -0.08484818f, -0.06589265f, -0.15181665f, 0.15167888f, 0.09139924f, 0.19200532f, 0.27809906f, 
    0.16426271f, -0.02690168f, 0.00740873f, -0.06736866f, -0.08691751f, 0.01113723f, 0.02239005f, 0.03610480f, 
    -0.06089143f, -0.00004497f, 0.02576181f, -0.03663441f, 0.00102932f, 0.03591976f, -0.07647460f, -0.09333497f, 
    -0.10830554f, -0.25726128f, 0.10892364f, -0.16588326f, -0.17256783f, 0.07320394f, 0.02875286f, 0.02780416f, 
    0.00432892f, 0.10826744f, -0.02601741f, -0.00514263f, 0.13345133f, -0.07205385f, -0.06180536f, -0.14489928f, 
    0.02896885f, 0.08739687f, -0.06133742f, 0.15189056f, 0.18312445f, 0.01069348f, 0.13785510f, -0.10879449f, 
    -0.20367891f, 0.11234179f, 0.02960049f, 0.02566371f, 0.03921724f, -0.01927296f, 0.10501195f, 0.10552787f, 
    -0.12146265f, -0.20130806f, -0.08188318f, 0.04079153f, -0.02878604f, -0.10411356f, -0.13734679f, 0.01050336f, 
    -0.02925000f, -0.10643288f, 0.19647990f, -0.01188817f, 0.00990432f, -0.12866791f, 0.09003317f, 0.07570182f, 
    0.00041888f, -0.10374960f, -0.00317580f, -0.02921914f, -0.01114454f, 0.06019323f, -0.00169869f, 0.03353056f, 
    0.06664114f, -0.04295518f, 0.02246078f, 0.02567790f, -0.07968336f, 0.02730771f, 0.06645610f, 0.14279860f, 
    0.16877200f, -0.01831469f, 0.02179143f, 0.02985916f, 0.00403744f, 0.14782727f, 0.01615632f, -0.02180417f, 
    -0.01298005f, -0.04813078f, 0.01151509f, -0.01667670f, -0.05586409f, -0.06214766f, 0.00347131f, -0.21401769f, 
    0.24468084f, -0.18895939f, 0.13629425f, -0.32432076f, 0.11445238f, 0.10953493f, 0.02870870f, 0.20665438f, 
    -0.18611257f, -0.08403847f, 0.01405519f, -0.01444662f, 0.04842564f, -0.05997666f, -0.00520055f, 0.00420645f, 
    0.02174868f, -0.05064445f, -0.12744820f, -0.10356414f, 0.00398391f, 0.04345508f, 0.04476598f, 0.09962159f, 
    0.18644379f, 0.01524422f, 0.07428958f, 0.02687686f, 0.08276650f, 0.03520585f, 0.09035430f, 0.05464065f, 
    0.02265482f, 0.01816745f, 0.08859731f, -0.03506288f, -0.01001048f, -0.00246116f, 0.01340222f, 0.03764974f, 
    -0.00933429f, -0.15981112f, 0.05570980f, -0.01704989f, -0.11786610f, 0.09333531f, -0.01243726f, -0.07509331f, 
    -0.03068240f, -0.00423182f, -0.01674855f, -0.01578577f, -0.06181442f, -0.10580418f, 0.02332030f, -0.01033714f, 
    -0.13219677f, 0.03867372f, -0.17732516f, -0.15952420f, -0.08585978f, -0.01692564f, 0.04954484f, -0.04188393f, 
    -0.01077694f, -0.05151942f, -0.01659335f, 0.01982696f, 0.02925853f, -0.03566574f, 0.00467638f, -0.07476298f, 
    -0.04206896f, 0.01409438f, 0.02474626f, 0.04815682f, 0.03228062f, 0.00396135f, -0.05864313f, -0.04747565f, 
    0.44619891f, -0.16652586f, -0.05485041f, -0.03449109f, -0.23499352f, 0.00229669f, 0.00004481f, 0.13517445f, 
    -0.05438250f, -0.02014012f, -0.02242188f, -0.03418222f, -0.05911917f, -0.00981822f, -0.00836779f, -0.09633812f, 
    -0.10219166f, -0.03565152f, 0.10632582f, -0.05493034f, 0.03230860f, -0.27640560f, -0.06608952f, -0.31237662f, 
    0.05070314f, 0.11344088f, -0.11478015f, 0.08163369f, 0.04233151f, -0.15173663f, -0.07618970f, 0.00358801f, 
    0.07337516f, -0.08983828f, -0.04834216f, -0.04477723f, 0.00495578f, -0.03618353f, -0.11931862f, -0.12819135f, 
    0.42080975f, -0.26095849f, -0.30104855f, 0.42932612f, 0.04183061f, 0.19180475f, 0.02942281f, 0.11023673f, 
    -0.00004408f, 0.01094907f, 0.01724549f, -0.13039418f, -0.00034930f, 0.04062106f, -0.00899236f, 0.07503193f, 
    0.16838652f, 0.10685873f, -0.02948220f, 0.02724801f, 0.38463426f, -0.54919124f, -0.51135230f, 0.18463874f, 
    -0.35980615f, 0.03820268f, -0.00105760f, 0.02870358f, -0.05181515f, 0.00475261f, 0.05140406f, -0.02802637f, 
    -0.07743216f, 0.01654755f, 0.01029032f, -0.05471220f, 0.02107340f, 0.06377654f, -0.00813056f, 0.02485004f, 
    0.02084162f, -0.06932436f, 0.00548830f, -0.05101137f, 0.02368608f, 0.06814630f, 0.02980669f, 0.10597675f, 
    -0.05163758f, 0.00915883f, 0.02270149f, 0.04050720f, 0.07999728f, -0.04118164f, 0.05326953f, 0.12943314f, 
    0.05486018f, -0.06262159f, -0.04083145f, 0.01173372f, 0.23880824f, -0.07728921f, 0.25874376f, 0.19640166f, 
    -0.29900941f, -0.08115014f, -0.10765451f, -0.20806772f, 0.00859647f, -0.11963652f, 0.09886855f, -0.11010851f, 
    -0.11662861f, -0.00826336f, -0.15025680f, 0.06725691f, 0.02494008f, -0.05070439f, -0.05177817f, -0.02703678f, 
    0.03634341f, 0.00046741f, 0.02350892f, -0.00817208f, -0.03396561f, 0.02594756f, -0.02918372f, 0.00293408f, 
    -0.01151366f, 0.05572125f, -0.03241020f, -0.00720536f, 0.05949307f, -0.04262549f, 0.03009032f, -0.06399968f, 
    -0.09844006f, -0.03180474f, -0.08518668f, -0.06696915f, 0.00350188f, -0.35095611f, 0.15638278f, 0.21341436f, 
    0.06156396f, -0.22243202f, -0.11286631f, 0.01764685f, -0.21950881f, 0.06851321f, -0.12345863f, 0.04759738f, 
    0.03520481f, -0.04625243f, -0.01639056f, -0.01387677f, 0.02001905f, 0.05073303f, -0.05534992f, 0.00040039f, 
    -0.03407452f, -0.22807990f, -0.11844130f, -0.09580688f, -0.08887802f, 0.05796840f, -0.16231738f, -0.04499600f, 
    0.08090343f, 0.04472420f, -0.10674923f, -0.17841081f, 0.06313661f, -0.05690677f, 0.04137593f, -0.17539644f, 
    -0.31799647f, -0.04397856f, -0.06443483f, -0.00246986f, -0.13279940f, -0.14455923f, 0.07929957f, -0.06388521f, 
    0.02570475f, -0.13640088f, -0.21009742f, -0.04888013f, -0.16047041f, -0.08537954f, 0.01057060f, 0.02496602f, 
    0.08708861f, -0.12778370f, 0.04162769f, 0.06553385f, -0.09724375f, -0.11160208f, -0.11500067f, 0.21874544f, 
    0.07512073f, -0.01051263f, -0.00143427f, -0.01564800f, -0.07644992f, 0.00066411f, -0.00830348f, -0.02929898f, 
    0.01421404f, 0.08690961f, -0.00930957f, -0.10446917f, -0.05083469f, -0.04667886f, -0.10610590f, 0.06626171f, 
    0.02264168f, 0.03010513f, -0.04785940f, -0.01018263f, -0.03809048f, 0.02242181f, 0.10952057f, -0.10782409f, 
    0.14880547f, -0.01943100f, 0.22538956f, 0.05853874f, 0.04567489f, -0.01566432f, -0.00290161f, 0.00551731f, 
    -0.02045833f, 0.02849030f, -0.03724794f, -0.03318727f, 0.14263138f, -0.03875784f, 0.03047747f, 0.11316603f, 
    0.12081719f, -0.08572512f, 0.05735890f, 0.09572355f, 0.00130651f, -0.09136341f, -0.04039116f, 0.03275760f, 
    -0.06936867f, 0.12170006f, 0.09384367f, -0.07561001f, -0.03917889f, -0.02606569f, -0.00379713f, 0.04807457f, 
    0.02399696f, 0.04374484f, -0.02676502f, 0.00990772f, 0.02627479f, 0.03941422f, -0.01350446f, 0.01327781f, 
    -0.01467388f, 0.00882274f, 0.00827474f, -0.00130843f, 0.04253712f, 0.09459263f, 0.08226586f, -0.12356434f, 
    -0.08447535f, -0.03633536f, -0.04399183f, 0.11580033f, 0.05336409f, 0.05008541f, -0.02241855f, 0.02089461f, 
    0.18576081f, 0.28223854f, 0.45794556f, 0.25774279f, 0.25942421f, -0.15118323f, -0.10661861f, -0.10938846f, 
    0.07127119f, 0.25127774f, 0.08701639f, 0.03186404f, 0.04450889f, -0.00575746f, 0.02934570f, 0.00663035f, 
    -0.04570984f, -0.10201182f, -0.01399477f, -0.25552189f, 0.04133773f, 0.02023668f, 0.02164469f, -0.10723338f, 
    0.00314766f, 0.00490756f, -0.03776458f, -0.10933859f, 0.01211403f, -0.07501720f, -0.03463982f, -0.08538143f, 
    -0.00914164f, -0.11273263f, -0.00055752f, -0.00701279f, -0.06544421f, -0.09134273f, -0.01453296f, 0.00906929f, 
    0.09465858f, 0.07625289f, 0.05179561f, -0.04484336f, -0.01830122f, 0.11014191f, 0.04745641f, -0.00515740f, 
    0.01366321f, 0.07725057f, 0.09715895f, 0.07598208f, 0.02839198f, 0.06271479f, 0.06719369f, 0.10717599f, 
    0.08769435f, 0.05814110f, -0.03169110f, 0.07419591f, 0.08953712f, -0.25000095f, 0.06491411f, -0.28600416f, 
    -0.10313701f, 0.03929101f, 0.08236248f, 0.01902224f, 0.01932228f, 0.00580222f, 0.01136801f, 0.01701557f, 
    0.01320768f, -0.04894579f, -0.06651130f, -0.16605201f, -0.19339521f, 0.00970403f, -0.07165092f, -0.00692743f, 
    0.08268096f, -0.13244367f, -0.18213926f, 0.06989203f, -0.10825448f, 0.11794976f, 0.02753774f, 0.06530001f, 
    0.03505559f, 0.01616875f, 0.04011929f, 0.03697138f, -0.01440533f, -0.12802555f, 0.04010218f, 0.04648321f, 
    -0.19493254f, 0.03535774f, -0.14865227f, -0.03565470f, -0.13738701f, -0.18574603f, -0.05594250f, -0.11606807f, 
    -0.09835165f, -0.13214149f, 0.09686196f, 0.02308629f, 0.04683952f, -0.00728772f, 0.03084071f, -0.04938864f, 
    0.05383085f, 0.02076004f, 0.04881326f, -0.06723630f, 0.19595814f, 0.02639319f, 0.09120189f, 0.10465410f, 
    -0.02992256f, -0.08477205f, -0.02744690f, -0.05999332f, -0.01092705f, 0.07797011f, 0.07206186f, -0.05556051f, 
    0.07597125f, -0.02531822f, -0.03110894f, -0.07023045f, -0.12530951f, -0.06831621f, 0.05333680f, -0.10722855f, 
    -0.07581886f, 0.02072685f, -0.09812460f, -0.15147150f, -0.03862398f, -0.06233859f, 0.15370068f, 0.10114672f, 
    0.06079306f, -0.15472943f, -0.02457789f, -0.05565353f, -0.09748307f, -0.13705601f, -0.02789314f, -0.01548291f, 
    0.04250737f, 0.05385094f, 0.04057453f, -0.02178585f, 0.00899055f, -0.04519336f, 0.00342857f, -0.01659293f, 
    -0.64681619f, -0.15579116f, -0.01931330f, -0.20318869f, -0.05110257f, 0.02146793f, 0.06224293f, -0.18902194f, 
    0.01074356f, 0.03634772f, -0.07429732f, -0.13295564f, -0.01673383f, 0.04754627f, 0.00466316f, -0.07193179f, 
    0.00673376f, -0.01379973f, -0.04130426f, -0.03983561f, 0.00298891f, -0.14358719f, -0.07325353f, 0.22103311f, 
    -0.06862150f, -0.03039891f, -0.09086498f, 0.05140302f, -0.19048780f, -0.04257684f, -0.29185045f, 0.12472776f, 
    -0.08077055f, 0.01650721f, -0.01311347f, 0.01425816f, -0.09244785f, 0.00464797f, -0.09756865f, 0.00154600f, 
    -0.06022907f, -0.03682139f, 0.04265127f, -0.01652674f, -0.10893935f, 0.12339573f, -0.04511119f, -0.06604794f, 
    -0.04407563f, 0.06946409f, 0.02974132f, 0.02656054f, -0.03397933f, 0.02631866f, -0.04186644f, -0.00822922f, 
    0.02633692f, -0.02574375f, 0.03203385f, 0.07293411f, -0.12055040f, 0.02900466f, 0.00666211f, 0.14733325f, 
    -0.02399668f, -0.15057687f, 0.05310186f, 0.07668201f, -0.05152850f, -0.06355505f, 0.06602181f, -0.03657269f, 
    0.01494502f, 0.00436238f, 0.01843634f, -0.16060695f, -0.02088844f, -0.00212316f, -0.00762295f, -0.20763944f, 
    -0.28102946f, -0.21228281f, 0.05473993f, -0.12478514f, 0.19479617f, 0.08658790f, 0.05421817f, -0.10763326f, 
    -0.04246565f, 0.05270281f, 0.03063826f, -0.04391593f, 0.09574741f, 0.11780476f, -0.06419090f, 0.11976919f, 
    -0.05155613f, -0.20364779f, 0.12607040f, -0.02046614f, -0.27608278f, 0.11275127f, -0.20500582f, -0.29739213f, 
    -0.08738814f, 0.03338666f, -0.01726577f, -0.02782928f, -0.12183639f, 0.15886457f, -0.02957848f, 0.19157955f, 
    -0.04439317f, -0.08311439f, -0.12161483f, 0.01799307f, -0.01957563f, 0.06309559f, -0.04440947f, 0.08083652f, 
    0.38372171f, -0.19473922f, -0.03907936f, -0.11269081f, 0.04276409f, 0.03971101f, -0.05104396f, 0.00039514f, 
    -0.02040699f, 0.00357996f, -0.06894127f, 0.07269593f, 0.01623742f, 0.00239905f, 0.11213066f, -0.18420601f, 
    -0.05837701f, 0.00195661f, -0.01448536f, -0.18309674f, 0.17067255f, -0.03149240f, 0.31808102f, 0.12505084f, 
    -0.39907360f, -0.01269943f, 0.05286618f, 0.17229323f, -0.05205403f, -0.02464703f, 0.05342312f, 0.00924382f, 
    -0.04191759f, -0.01550945f, 0.03523384f, 0.00146756f, 0.00817014f, 0.07998121f, 0.04241186f, 0.00132166f, 
    -0.07563578f, 0.12481637f, 0.07123797f, -0.11436296f, -0.08951929f, -0.02447335f, 0.04179702f, 0.05779114f, 
    -0.13311100f, 0.02182042f, 0.16889828f, -0.04428753f, -0.02879409f, -0.04452050f, -0.05013084f, 0.02403572f, 
    0.03232029f, -0.02382850f, 0.00479552f, 0.04471742f, 0.13404784f, 0.00744860f, 0.25443968f, 0.00339628f, 
    -0.09869010f, 0.02167304f, 0.09692827f, 0.01131207f, 0.02111341f, -0.02294720f, 0.04460707f, 0.01670215f, 
    0.04086242f, 0.06703962f, 0.01500147f, -0.02064385f, -0.01212395f, -0.10171702f, -0.09206568f, -0.07558630f, 
    0.01525742f, -0.10030114f, -0.25099000f, 0.03758275f, -0.02647397f, -0.09081513f, -0.13784520f, -0.15441231f, 
    -0.06746670f, 0.12923397f, 0.02661634f, 0.16560790f, -0.02789759f, -0.11707201f, 0.03332246f, -0.06944848f, 
    -0.14274907f, 0.07930180f, 0.11285893f, 0.23705900f, -0.00169770f, -0.10464082f, 0.12918384f, 0.06104475f, 
    -0.14976597f, 0.08084726f, -0.04749373f, -0.00459501f, -0.12740992f, -0.20269419f, 0.06633395f, -0.01128064f, 
    0.07805599f, -0.02173286f, 0.02842581f, 0.01343741f, 0.01777235f, -0.09893073f, -0.20993403f, -0.14440882f, 
    0.24961276f, -0.16877738f, -0.12907618f, -0.18299842f, -0.06024059f, 0.08182001f, -0.10990117f, -0.08245467f, 
    -0.01748426f, 0.18206148f, -0.04710246f, 0.25951925f, -0.09954391f, 0.04246255f, 0.04277105f, -0.01817829f, 
    -0.09716167f, 0.00710538f, 0.03216884f, 0.17929056f, -0.41036859f, -0.10468396f, 0.01059461f, 0.23972672f, 
    -0.10445035f, 0.11341985f, -0.05113639f, -0.00782372f, 0.08356646f, 0.01342264f, -0.04307524f, 0.00223538f, 
    0.01559188f, 0.02218112f, 0.02877342f, -0.03952970f, -0.07674215f, 0.13637584f, -0.05330428f, 0.04877987f, 
    -0.17255552f, 0.04720079f, 0.17864951f, -0.12657976f, 0.24471740f, 0.04251499f, 0.02041873f, -0.20553088f, 
    0.03557542f, -0.02453505f, 0.05873923f, -0.01696389f, 0.16721927f, -0.00535984f, -0.11086452f, -0.10432030f, 
    -0.21054485f, -0.38942027f, -0.06267855f, -0.14657614f, 0.06171035f, -0.22768238f, -0.13764000f, 0.12769741f, 
    0.02357717f, 0.07123680f, -0.12431473f, -0.05829851f, 0.02847911f, 0.06668988f, -0.03833416f, 0.03353888f, 
    0.02470199f, 0.02900023f, 0.01425745f, -0.02797243f, -0.03100665f, -0.00299592f, -0.01173735f, 0.00044758f, 
    -0.07962129f, -0.11109779f, -0.16374348f, -0.23719172f, -0.07781976f, 0.06033291f, 0.01112461f, -0.07281309f, 
    0.02598972f, 0.19608715f, -0.01899855f, 0.11491726f, -0.02756473f, -0.00927144f, -0.11137721f, -0.01921185f, 
    0.01680019f, 0.03361174f, 0.02081597f, 0.11001133f, -0.02103298f, -0.02364615f, -0.37849331f, 0.03205677f, 
    0.19375177f, 0.05710913f, 0.04294178f, 0.02872624f, -0.06878297f, 0.05587095f, -0.00015422f, -0.02151994f, 
    0.05394838f, 0.03073139f, 0.02431671f, 0.06350565f, 0.02162946f, 0.21088722f, -0.03227234f, 0.07339929f, 
    0.28919324f, -0.02662823f, 0.21581990f, 0.05529813f, -0.15284090f, 0.25214028f, 0.10055317f, -0.07182413f, 
    0.08674283f, 0.05015950f, 0.09677919f, 0.02941914f, -0.01137691f, 0.04511626f, 0.00620227f, -0.02527374f, 
    0.03604790f, -0.07147870f, -0.04882127f, 0.15607925f, -0.22962750f, 0.02409565f, 0.02808854f, -0.20981321f, 
    -0.19135691f, 0.08740550f, 0.02105789f, 0.01575575f, -0.02912659f, -0.01667949f, 0.03449542f, 0.03857915f, 
    -0.03372902f, -0.02283773f, -0.01109144f, -0.00068083f, 0.04141222f, 0.07125767f, -0.03272584f, 0.03569353f, 
    0.13668738f, 0.09820285f, 0.17077143f, 0.05033684f, 0.01875143f, -0.06128844f, -0.00849721f, 0.18792486f, 
    0.07202220f, 0.03575554f, 0.06027059f, 0.01028907f, 0.03676861f, -0.01128196f, 0.00255950f, 0.05897835f, 
    -0.01184105f, -0.06586922f, -0.30731699f, -0.35316178f, -0.21275136f, -0.16393253f, -0.13877633f, 0.04225203f, 
    0.06456742f, 0.08734100f, 0.02771111f, -0.00097557f, 0.00033982f, -0.00371208f, 0.02872758f, -0.07472062f, 
    -0.04550514f, -0.00895365f, 0.01397263f, -0.08551710f, -0.05966159f, 0.04778961f, 0.00946296f, -0.01405551f, 
    -0.28241202f, 0.10674392f, 0.11429417f, -0.52857792f, -0.01143617f, -0.09947773f, 0.01987834f, 0.02316683f, 
    -0.02301850f, -0.04632026f, 0.02882290f, 0.02047718f, -0.03619928f, -0.19249488f, -0.09797206f, 0.01705736f, 
    -0.11870130f, 0.01339429f, 0.03205344f, -0.17369051f, -0.30636773f, 0.08013167f, 0.21007459f, -0.09773968f, 
    -0.05167508f, -0.13603471f, 0.02664389f, 0.05201422f, 0.13563232f, -0.07640596f, 0.29995602f, -0.06437211f, 
    0.03604599f, -0.06337290f, 0.05141453f, 0.09905044f, 0.04480454f, -0.02765010f, 0.15889534f, 0.18281370f, 
    -0.41572422f, -0.10330487f, -0.32001600f, -0.23179308f, -0.18609245f, 0.05199638f, 0.07223471f, -0.01649016f, 
    -0.03347017f, -0.07974139f, -0.06468410f, 0.06338857f, -0.04315557f, 0.01664406f, 0.01539314f, 0.01622933f, 
    -0.01911975f, 0.05725349f, -0.00083942f, 0.06241304f, -0.11204896f, 0.10152189f, -0.17664477f, -0.07400634f, 
    -0.05397279f, -0.08063985f, -0.08797015f, 0.01652210f, -0.14216851f, -0.11943269f, -0.08120117f, -0.04261812f, 
    -0.02116667f, -0.01604990f, -0.00637064f, -0.16905375f, -0.13721159f, -0.02526621f, -0.10636676f, -0.17552899f, 
    0.26106578f, 0.04747412f, 0.03644668f, -0.14455344f, 0.08492108f, -0.07412261f, -0.01036606f, 0.12558424f, 
    -0.00673987f, -0.02422614f, -0.15814762f, -0.13204525f, -0.05528472f, -0.03674207f, -0.03399348f, 0.04798965f, 
    0.11660045f, 0.00043732f, -0.07081301f, 0.10972567f, 0.31163645f, -0.26263759f, 0.06282359f, 0.13252814f, 
    -0.10975546f, 0.15636054f, 0.03730553f, 0.01023476f, -0.00958421f, 0.33153954f, -0.01155118f, 0.04216809f, 
    0.02084300f, 0.02035770f, 0.09991195f, -0.05715926f, 0.14497122f, -0.04491214f, -0.03402993f, 0.15096919f, 
    0.20270862f, -0.06296890f, 0.15853240f, -0.13032052f, -0.11027460f, 0.10961056f, 0.07322718f, -0.03148643f, 
    0.03573646f, 0.07344426f, 0.02234816f, 0.04526228f, -0.00209715f, 0.02204530f, -0.01782568f, -0.00474230f, 
    0.00759788f, -0.00388873f, 0.05500548f, 0.11503803f, -0.32107636f, -0.06705558f, 0.26638666f, 0.06163853f, 
    -0.04336399f, -0.13426302f, -0.08763140f, -0.11858585f, 0.02995516f, 0.03421667f, 0.02096107f, 0.10626532f, 
    -0.03421362f, -0.00017513f, -0.05177552f, 0.05315796f, -0.15287489f, 0.01494802f, -0.00364710f, 0.17566583f, 
    0.04124693f, -0.09027824f, -0.10657391f, 0.05830161f, -0.02393046f, 0.03603999f, -0.01943780f, -0.06880074f, 
    -0.02624105f, -0.06711897f, 0.04834490f, -0.00698921f, -0.02389222f, 0.16293398f, -0.20883739f, 0.04351503f, 
    -0.03554206f, 0.05475582f, 0.01772319f, 0.16095197f, 0.09905487f, -0.02515707f, -0.07678951f, -0.02859074f, 
    0.05668941f, -0.00169436f, 0.01567540f, -0.00313465f, -0.04641789f, -0.00446915f, 0.15421772f, -0.09766536f, 
    -0.10391758f, -0.09348731f, -0.00813749f, 0.05294739f, 0.04750756f, 0.07650856f, -0.03631589f, 0.01946382f, 
    0.06477755f, -0.01450600f, 0.00840363f, -0.01314001f, -0.02385323f, -0.02674517f, -0.03489419f, 0.11759151f, 
    0.00587610f, -0.07101558f, -0.17754039f, -0.10498554f, -0.03158462f, -0.06914747f, -0.06454478f, -0.00374569f, 
    0.09756830f, 0.01564903f, -0.02844808f, 0.24196512f, -0.00070686f, 0.08493540f, 0.08566323f, 0.10415613f, 
    -0.11075615f, -0.02154904f, -0.01005479f, 0.02129655f, 0.11640667f, 0.03955874f, 0.02963380f, -0.06541607f, 
    -0.06500173f, 0.03005836f, -0.01570224f, -0.09459310f, 0.03671730f, 0.07609589f, -0.00380621f, -0.00808109f, 
    -0.12766555f, 0.34013650f, -0.18415149f, -0.18735793f, 0.03950177f, -0.00845782f, -0.06769557f, 0.03486317f, 
    -0.02631242f, -0.06100709f, -0.09864907f, -0.03811920f, -0.17994069f, 0.03397205f, -0.01681598f, -0.10078240f, 
    -0.05099884f, 0.23043673f, -0.04561346f, -0.27008763f, -0.16530912f, -0.10026578f, -0.04328268f, -0.37320441f, 
    0.17477436f, -0.00361468f, 0.08860411f, -0.02373097f, -0.05278753f, -0.06992390f, 0.07108272f, -0.16252595f, 
    0.10157736f, 0.12878495f, 0.07995966f, 0.05716217f, 0.04985321f, 0.02453455f, 0.10041501f, 0.00212046f, 
    0.01963600f, 0.02266707f, 0.18711451f, -0.04178940f, -0.08850620f, 0.09179500f, -0.03304338f, 0.02854997f, 
    0.03144980f, 0.05109465f, 0.05248930f, 0.00018283f, 0.01594226f, 0.02451922f, -0.04804386f, 0.08602015f, 
    0.02175166f, -0.21889089f, -0.10012040f, -0.08440858f, 0.02265106f, -0.02398104f, 0.03857900f, 0.18035559f, 
    -0.12601170f, -0.05539288f, 0.07979229f, 0.06444013f, 0.05053412f, -0.04270595f, -0.09633671f, 0.02347599f, 
    -0.05078139f, -0.02121147f, 0.03321306f, 0.06553931f, 0.03514239f, 0.10939744f, -0.14818566f, 0.03790509f, 
    0.25812459f, -0.14898925f, -0.03750506f, -0.44128323f, 0.13819528f, 0.19350651f, 0.16344798f, -0.03974478f, 
    0.02550896f, 0.04394495f, 0.01148022f, 0.00791420f, -0.06861319f, -0.08556130f, -0.01985874f, -0.10028072f, 
    0.03631670f, 0.07534769f, 0.01094205f, -0.16272409f, -0.23675025f, -0.25375658f, -0.12693653f, 0.16775747f, 
    0.10180385f, 0.08453418f, 0.08207776f, 0.01291868f, 0.03847538f, 0.03031719f, -0.05500451f, -0.05005664f, 
    -0.08129828f, -0.02778767f, -0.03359174f, -0.03887947f, -0.11495196f, 0.17397948f, -0.03403650f, -0.02087126f, 
    -0.12809607f, -0.35056177f, -0.08167364f, 0.15372406f, -0.04578408f, 0.04601078f, -0.13802949f, -0.13566738f, 
    0.13474751f, -0.12823534f, 0.04230327f, -0.01855454f, 0.03209361f, 0.04254083f, 0.01568097f, 0.18410102f, 
    0.04651864f, 0.06909426f, 0.12485852f, 0.19800949f, -0.20381981f, -0.17639557f, -0.10499554f, -0.11618055f, 
    0.07031547f, 0.10164139f, 0.00102589f, -0.05529674f, -0.06989720f, -0.06829798f, -0.01069841f, 0.03280362f, 
    0.13544574f, -0.02814876f, 0.07574724f, -0.00718261f, -0.02002442f, 0.08973891f, 0.03189109f, -0.00441181f, 
    -0.08789856f, -0.15861838f, 0.06031502f, -0.01587413f, -0.00851536f, 0.06791899f, 0.00458782f, -0.10992732f, 
    -0.03473179f, 0.10942993f, 0.07253263f, -0.04201548f, -0.04253996f, 0.02437253f, -0.04611630f, 0.12654763f, 
    -0.02348745f, 0.09009759f, -0.05539526f, -0.01614342f, -0.09738994f, -0.51854086f, 0.12286463f, 0.16246510f, 
    -0.07030449f, 0.13040505f, 0.05045458f, -0.08171011f, 0.03595345f, 0.07463598f, 0.16705674f, 0.06145043f, 
    0.14052793f, -0.07209081f, 0.07088700f, -0.02939559f, -0.11770919f, -0.02549829f, 0.09704652f, -0.00357934f, 
    -0.52168870f, 0.22063757f, 0.40564337f, 0.03301765f, -0.18355973f, -0.05533193f, -0.07254556f, -0.08404677f, 
    0.04916519f, -0.03240492f, -0.03449377f, 0.07570700f, -0.00060596f, -0.02602570f, -0.04339624f, -0.07844945f, 
    -0.22759248f, 0.11302444f, -0.08472803f, -0.14629552f, -0.59020954f, 0.06048567f, 0.27454934f, 0.04032822f, 
    -0.28258070f, 0.04198503f, -0.05092085f, -0.08375099f, 0.13905501f, 0.01174091f, -0.01651112f, -0.10000746f, 
    -0.11965404f, 0.03475790f, -0.07714532f, 0.07964090f, 0.00885025f, -0.09863760f, -0.05239580f, -0.07885020f, 
    -0.10458563f, 0.07176915f, -0.15808608f, -0.07142786f, 0.09177512f, 0.14597708f, -0.02100129f, -0.08696936f, 
    0.00513520f, 0.03825931f, -0.07099898f, 0.08771820f, -0.04320248f, 0.03294684f, 0.02278353f, -0.05401566f, 
    -0.05328631f, 0.06465659f, 0.03174468f, 0.00619616f, 0.15065348f, 0.19661959f, -0.17676435f, -0.18671781f, 
    -0.02039060f, 0.00955187f, 0.04709135f, 0.01762179f, -0.03443085f, 0.33730713f, 0.03341231f, -0.06281386f, 
    -0.09907222f, 0.06600619f, 0.15848532f, -0.07050544f, 0.02614000f, 0.05675991f, 0.17284736f, 0.12211026f, 
    0.06819509f, -0.02480890f, -0.00612947f, 0.12558515f, 0.00583431f, 0.00078223f, -0.05204606f, -0.03859318f, 
    -0.00144421f, 0.02923363f, -0.10127494f, -0.06817336f, 0.09852148f, -0.05474363f, -0.03189182f, 0.10750986f, 
    0.13303925f, 0.03870280f, 0.02195354f, 0.05285357f, -0.52242661f, -0.03440982f, -0.25175577f, -0.31488097f, 
    -0.38593581f, -0.03063122f, 0.05503527f, -0.02654803f, -0.15300736f, 0.10523409f, -0.00352948f, 0.11761265f, 
    -0.12398317f, 0.05007321f, 0.02178599f, -0.03442163f, -0.06131336f, 0.00248881f, 0.02035499f, 0.05458799f, 
    -0.07831625f, -0.64969903f, 0.03411571f, 0.34028187f, -0.23570229f, 0.14724693f, 0.07908403f, -0.14620243f, 
    0.02348583f, 0.11987887f, -0.05196838f, 0.05947679f, -0.08198302f, 0.04445336f, 0.10543118f, 0.10558582f, 
    0.00717852f, 0.01640062f, 0.06553604f, 0.08623380f, 0.23440298f, 0.15267694f, -0.03248985f, 0.21014498f, 
    -0.35107484f, 0.04233843f, -0.08514733f, -0.01052663f, -0.18374826f, 0.07471396f, -0.10029639f, 0.04746271f, 
    -0.03159569f, 0.03265705f, 0.11429128f, -0.16660717f, 0.07030487f, 0.06272298f, 0.06695433f, -0.08729167f, 
    -0.09681613f, 0.12716512f, -0.24755856f, -0.02886543f, 0.01432999f, 0.04090979f, 0.04660124f, -0.04566971f, 
    -0.04228587f, -0.02171501f, 0.11144884f, -0.01617086f, -0.06240160f, 0.06961849f, 0.01327775f, -0.05552666f, 
    0.04671325f, 0.10484662f, 0.00793718f, -0.06577470f, 0.33625290f, 0.02349458f, 0.14559256f, 0.11288730f, 
    -0.24367192f, 0.04600215f, -0.09095211f, -0.13606729f, -0.17198400f, 0.06304377f, 0.00679535f, 0.02068264f, 
    0.04229116f, 0.02505989f, 0.10163996f, -0.05659543f, 0.08264647f, -0.16422261f, -0.22628786f, -0.12996294f, 
    -0.51995122f, 0.20048153f, -0.38497701f, -0.08863696f, -0.07525748f, 0.00808979f, -0.00400087f, -0.11555931f, 
    0.08675360f, -0.00905511f, 0.10562002f, -0.03625876f, -0.02960189f, 0.01897020f, -0.13387063f, -0.03730492f, 
    -0.00730095f, 0.06963457f, -0.00830761f, 0.02152655f, 0.00776781f, -0.01605523f, -0.11051094f, -0.05797342f, 
    0.00773898f, 0.06246704f, 0.02327094f, -0.04107073f, -0.03182848f, -0.01766104f, 0.05727126f, 0.02209800f, 
    0.09181113f, 0.00854260f, 0.01939302f, -0.02166287f, 0.03303260f, 0.01383051f, -0.00689622f, 0.01907071f, 
    0.09543284f, -0.03079033f, 0.27511027f, -0.09652485f, -0.13433371f, 0.18848492f, 0.19447003f, 0.07762914f, 
    -0.14626276f, -0.25306532f, -0.01143391f, 0.00246518f, 0.00637961f, 0.02798590f, 0.02197762f, 0.04521176f, 
    0.07624847f, -0.04508543f, 0.15091766f, 0.19711757f, 0.19181082f, 0.08825304f, -0.02079755f, 0.00964705f, 
    -0.05629522f, -0.04110241f, -0.08801454f, 0.04042510f, -0.06748483f, 0.12192157f, 0.08685941f, 0.01888465f, 
    0.02295923f, -0.03614021f, -0.04491115f, 0.13485336f, -0.03351317f, -0.00860776f, -0.01768644f, 0.16256021f, 
    -0.09129279f, -0.05220515f, -0.12123601f, -0.05219605f, 0.12342227f, 0.09568360f, -0.02486421f, -0.02777365f, 
    -0.04414620f, -0.03607584f, 0.02017293f, -0.11668114f, -0.13284375f, 0.06219752f, 0.04376798f, -0.15127878f, 
    0.14175020f, 0.06220859f, 0.02301604f, -0.00805885f, 0.15117119f, 0.15724696f, -0.01774529f, -0.22108564f, 
    -0.02558792f, -0.09708717f, -0.01053663f, -0.04387925f, -0.05095563f, 0.07676755f, 0.05620895f, 0.02284814f, 
    -0.14934789f, -0.08474478f, 0.11559101f, -0.04581713f, -0.15123436f, -0.05287016f, 0.27382287f, 0.04078270f, 
    -0.12681887f, -0.14201987f, -0.27735183f, 0.21935423f, 0.02143208f, 0.01222273f, -0.06825726f, -0.00638821f, 
    -0.03401969f, -0.06383213f, -0.01420323f, 0.00113326f, 0.11840966f, 0.11801632f, -0.07625213f, 0.20476663f, 
    -0.16641602f, 0.12255695f, 0.12737316f, -0.10226500f, 0.62530345f, -0.50540972f, 0.15958084f, 0.07017414f, 
    -0.11085793f, -0.09539650f, -0.00521766f, -0.06269788f, -0.05321551f, 0.19877894f, 0.05465638f, 0.01232856f, 
    0.07081141f, -0.04335605f, 0.03924773f, -0.06952199f, -0.15149291f, 0.01114372f, 0.01427153f, -0.20457377f, 
    0.06208239f, -0.16755727f, -0.04305349f, 0.03446937f, 0.03586085f, 0.05517951f, -0.18231654f, -0.20009056f, 
    0.07497342f, 0.16388005f, 0.02066060f, 0.05399946f, 0.05897837f, 0.07874561f, -0.02453307f, 0.14452483f, 
    0.14625676f, -0.07999443f, -0.07484024f, 0.26128840f, -0.38178065f, 0.04775047f, 0.10704374f, -0.15423881f, 
    -0.16080333f, 0.02309426f, 0.00272998f, 0.05180776f, -0.07205934f, 0.22327666f, 0.01032650f, -0.01972229f, 
    -0.06978494f, 0.06890462f, -0.01228020f, 0.05205497f, -0.05676930f, -0.05801111f, 0.02100269f, 0.07812018f, 
    0.20298024f, 0.10167567f, -0.18617244f, -0.19922642f, 0.15755978f, -0.05889409f, -0.01313209f, 0.06319363f, 
    -0.15907386f, 0.03249434f, 0.16548970f, 0.12144718f, 0.03536091f, 0.07687914f, -0.01715629f, 0.03152839f, 
    -0.02751306f, 0.13342120f, -0.00696987f, 0.13615763f, -0.19689409f, -0.14624962f, 0.03100432f, 0.03802642f, 
    -0.28539246f, 0.20404279f, -0.06413526f, 0.02057200f, 0.01105664f, 0.02038556f, 0.02876937f, -0.03281295f, 
    -0.22765614f, 0.08092815f, 0.22908638f, -0.00795837f, 0.05880651f, -0.00109522f, 0.12742414f, 0.13483709f, 
    -0.25605237f, -0.29069984f, -0.16122958f, -0.32566339f, 0.00601293f, -0.01631632f, 0.03574694f, 0.07672146f, 
    -0.14700708f, -0.04090282f, -0.02571807f, 0.03075164f, -0.04412491f, 0.03700029f, -0.04221413f, -0.07768336f, 
    -0.02228812f, 0.02316084f, 0.05423397f, 0.02037248f, -0.18649198f, -0.46095476f, -0.12378608f, 0.08269276f, 
    0.12501366f, -0.08192094f, -0.15297756f, 0.00169464f, -0.11257751f, -0.04821422f, 0.00892801f, 0.00051383f, 
    0.02693377f, -0.14140479f, -0.03457533f, 0.00146658f, 0.02615744f, -0.02972312f, 0.14026192f, -0.08985430f, 
    -0.02138572f, 0.15868026f, 0.14874718f, 0.04868989f, 0.09935129f, -0.00369106f, 0.02150629f, -0.01906350f, 
    -0.00244786f, 0.03589194f, -0.06414055f, -0.08340682f, 0.02190915f, -0.02166724f, 0.04712774f, 0.00185490f, 
    0.07856914f, -0.11900956f, -0.01623190f, -0.04176708f, -0.37045717f, 0.24753632f, 0.40716487f, 0.05435954f, 
    0.17239355f, 0.02139888f, -0.02004877f, 0.00305553f, -0.16581544f, 0.09084287f, 0.02014149f, 0.14089547f, 
    0.00759178f, 0.08920176f, 0.00726165f, -0.01048848f, -0.02607683f, 0.00259354f, -0.01985571f, 0.02075136f, 
    -0.16147427f, 0.10528420f, 0.01732929f, -0.20037922f, -0.09801623f, -0.04405035f, 0.01628756f, 0.02752198f, 
    -0.00991782f, 0.05249275f, -0.02739913f, -0.03683745f, 0.05592926f, 0.04489095f, -0.02895099f, 0.01780520f, 
    0.14893907f, 0.02677547f, 0.08993200f, 0.06378073f, -0.74997127f, -0.69505107f, -0.74370217f, -0.20783430f, 
    0.30671135f, -0.04831662f, 0.13995753f, -0.01054150f, -0.23503090f, -0.28738341f, -0.03466830f, 0.00698328f, 
    0.00569860f, 0.02650973f, 0.05123270f, 0.03727892f, 0.04881306f, -0.02808329f, 0.25637403f, 0.08719219f, 
    -0.38775435f, 0.17335600f, 0.31036529f, 0.10092750f, -0.10074427f, -0.09406584f, -0.06762785f, -0.07621706f, 
    -0.20939586f, 0.08323092f, -0.04470176f, -0.05798238f, 0.05577724f, 0.00129122f, 0.05775710f, -0.01909253f, 
    0.03722231f, 0.00541606f, -0.00706960f, -0.00211311f, -0.37038663f, -0.44107080f, -0.63802594f, 0.07105980f, 
    -0.15421188f, -0.10698757f, 0.07942477f, -0.12066592f, -0.10045025f, -0.29001039f, 0.00484488f, -0.05376009f, 
    -0.00217159f, -0.06690415f, -0.01192497f, -0.02210314f, 0.00787890f, 0.06296644f, 0.12680040f, 0.03542956f, 
    -0.08647730f, -0.02757321f, 0.08709623f, 0.01345418f, 0.06011897f, 0.02030486f, 0.00303040f, -0.02614059f, 
    0.03580798f, 0.00521022f, 0.03712129f, 0.06264856f, -0.02188354f, 0.12585664f, 0.00995127f, 0.04663144f, 
    -0.04970335f, 0.02917240f, -0.07044639f, 0.08287977f, -0.26222092f, -0.30467939f, -0.47585228f, -0.01196206f, 
    0.07685349f, -0.09671971f, -0.13805601f, -0.11610015f, -0.19308905f, -0.02721533f, -0.03822678f, -0.01626357f, 
    0.02495110f, -0.06766865f, -0.06779839f, -0.06801893f, -0.05978334f, 0.03479156f, 0.13281403f, -0.01492670f, 
    -0.34663299f, 0.48240477f, 0.25892836f, 0.12495986f, 0.30568114f, -0.01889990f, -0.00527237f, -0.07842720f, 
    0.16739185f, 0.19787705f, 0.01338480f, 0.06873480f, -0.05169370f, 0.14832251f, -0.04012352f, 0.01043059f, 
    -0.02850104f, -0.03047640f, 0.07455423f, 0.06898379f, -0.08086465f, -0.13521639f, -0.12908223f, -0.09571128f, 
    0.12667982f, -0.00831165f, 0.07342780f, 0.12315520f, -0.04537568f, 0.00028664f, 0.01174969f, -0.02185831f, 
    0.00514990f, 0.03929412f, 0.00605453f, 0.02891830f, 0.01829548f, -0.07519047f, 0.05954454f, 0.06314848f, 
    -0.02837707f, -0.17506920f, -0.07113241f, 0.05884473f, -0.18648824f, 0.06490799f, 0.07737394f, 0.07146475f, 
    0.04277522f, 0.03993788f, 0.02872199f, -0.03241821f, 0.02781984f, 0.05683491f, 0.02161781f, 0.05140236f, 
    0.11486468f, 0.15910178f, 0.01852352f, 0.05815157f, 0.07256568f, 0.11562430f, -0.20424221f, -0.00974686f, 
    0.01131743f, 0.02779295f, 0.02947778f, 0.07264904f, -0.01385508f, 0.11343811f, -0.02666556f, -0.00674886f, 
    0.01060707f, -0.04082409f, 0.00839576f, -0.05626652f, 0.01554585f, -0.09421905f, 0.08272171f, 0.06961694f, 
    -0.53012079f, 0.53367442f, 0.26985064f, -0.02807751f, 0.20144062f, -0.06787084f, 0.03478915f, -0.09095804f, 
    0.01266537f, 0.17845312f, 0.06120588f, 0.00868114f, 0.07909099f, 0.04034313f, 0.03455273f, 0.03778250f, 
    -0.00957379f, -0.00813699f, 0.00977714f, 0.01029896f, 0.14034247f, -0.18965673f, -0.21464506f, -0.03405559f, 
    0.09818559f, -0.04305387f, 0.01663342f, 0.19936380f, 0.09320688f, -0.02808012f, 0.01863979f, 0.02162719f, 
    -0.06655964f, -0.09704646f, 0.01727524f, -0.03028066f, -0.10055206f, 0.06653232f, -0.04058881f, 0.04257152f, 
    -0.37073138f, -0.49019507f, -0.46381003f, -0.13701819f, 0.04367633f, -0.12742032f, 0.03487445f, -0.04203597f, 
    0.06125633f, -0.13569930f, -0.00207561f, -0.00963093f, -0.01743542f, 0.01230149f, -0.01355081f, -0.01611866f, 
    -0.00271684f, 0.03462690f, 0.14313558f, 0.07239087f, -0.49655995f, 0.19213733f, 0.47604460f, 0.13751040f, 
    -0.01814105f, -0.03449316f, -0.13861416f, -0.03494261f, -0.09481420f, 0.10552746f, 0.02038935f, 0.09564722f, 
    0.04162450f, 0.03078943f, -0.00485556f, 0.01309522f, -0.01315945f, -0.01677047f, 0.03072399f, -0.02886400f, 
    -0.40861815f, -0.36601537f, -0.64592671f, -0.17828222f, -0.02140242f, -0.19408809f, 0.03847651f, -0.11201081f, 
    0.06994563f, -0.32460830f, -0.00067047f, -0.03764083f, -0.04630074f, 0.07209500f, 0.06711385f, -0.04075890f, 
    -0.04024068f, 0.17981477f, 0.12691839f, 0.07011301f, 0.03312352f, -0.03871549f, -0.09356050f, -0.11881816f, 
    -0.09115930f, 0.00647959f, 0.00857528f, 0.01427260f, -0.05842556f, -0.01100192f, -0.03598034f, -0.07254282f, 
    -0.08604509f, -0.13389969f, -0.04543237f, -0.05152199f, -0.11177520f, -0.10012516f, -0.02180255f, 0.01512071f, 
    -0.29389361f, 0.25708398f, -0.20031816f, 0.13124071f, 0.13307351f, 0.07468067f, 0.09288292f, -0.00331256f, 
    0.03819635f, -0.19140241f, 0.08130433f, 0.06820488f, 0.11718379f, 0.10537653f, 0.10875469f, 0.08802501f, 
    -0.07111569f, 0.03926335f, -0.03797421f, -0.04385275f, -0.48526752f, -0.19349641f, 0.18008755f, 0.19237207f, 
    0.07902601f, -0.08801497f, -0.16483699f, 0.03696376f, -0.01496212f, 0.04031119f, 0.16373433f, -0.15829623f, 
    -0.02014029f, -0.01515257f, -0.04193155f, -0.04467563f, 0.00707051f, 0.04781959f, 0.02715172f, 0.00243969f, 
    -0.39132121f, 0.08886641f, 0.33591011f, 0.05212422f, 0.18395628f, -0.07406576f, -0.01378658f, -0.07855376f, 
    -0.14652714f, 0.11123032f, -0.10615715f, 0.08381087f, 0.08570366f, 0.02737741f, -0.00191416f, 0.00627672f, 
    -0.00083753f, -0.01538303f, -0.00993397f, 0.00156901f, -0.15257403f, -0.34945148f, -0.25370955f, -0.20610879f, 
    0.54104483f, -0.11712252f, 0.00083742f, -0.04113423f, 0.02759753f, 0.10057069f, 0.00018211f, 0.05846446f, 
    0.08553429f, -0.01884623f, -0.14322186f, -0.00353636f, 0.01988247f, 0.10082181f, 0.10103592f, -0.01302963f, 
    0.17235990f, 0.06275430f, -0.18876915f, -0.01513057f, -0.00753045f, -0.07674580f, -0.05350052f, -0.14283900f, 
    0.03504495f, -0.25582737f, 0.03302171f, -0.03126465f, -0.13997267f, -0.03515043f, 0.04720604f, 0.00102656f, 
    -0.05085116f, 0.12649804f, -0.21077394f, -0.15746565f, 0.17506430f, -0.05693492f, -0.39473361f, 0.04647585f, 
    0.16881645f, -0.16126256f, -0.05127355f, 0.12887728f, 0.13824977f, 0.20740791f, 0.05004787f, -0.01018189f, 
    0.02886765f, -0.00159688f, -0.02576262f, -0.10105864f, 0.05347411f, -0.06233159f, 0.19288491f, -0.08752596f, 
    -0.38519672f, 0.20632640f, -0.15755452f, -0.14476742f, -0.23337173f, -0.14573312f, 0.07244730f, -0.12450943f, 
    -0.00198997f, -0.12828982f, 0.02694259f, -0.01100458f, -0.05472133f, 0.00632848f, 0.00982078f, -0.01473341f, 
    0.00593227f, 0.11105735f, -0.01239604f, -0.09693182f, -0.29918963f, -0.26909330f, -0.51405197f, 0.05495007f, 
    0.13726839f, -0.05401267f, 0.19970571f, 0.04166261f, -0.07475684f, 0.05905216f, 0.06319120f, 0.00863676f, 
    0.01761942f, -0.04953812f, 0.04366164f, 0.03082438f, 0.03143783f, -0.03616619f, 0.07743407f, 0.03959319f, 
    -0.07447422f, -0.01679081f, 0.05095854f, -0.06242251f, 0.00330019f, 0.04708995f, 0.01857523f, -0.02590946f, 
    -0.05351565f, -0.01866270f, -0.03631498f, -0.02769840f, -0.03863721f, 0.10046721f, -0.07265681f, 0.01997508f, 
    -0.00056174f, -0.04098838f, -0.05001865f, 0.04350498f, 0.08245862f, -0.00487925f, -0.02490364f, 0.05205413f, 
    -0.05358741f, 0.01592322f, -0.10094485f, -0.02954231f, -0.05195363f, -0.05832782f, -0.14641322f, -0.09462662f, 
    -0.10035592f, -0.07544719f, 0.04458724f, 0.05291057f, -0.16555525f, 0.04242473f, -0.13047299f, -0.05807054f, 
    0.14419591f, -0.03665311f, -0.15955473f, -0.08751141f, 0.05216942f, -0.14135817f, -0.06072909f, -0.02396885f, 
    0.09275479f, -0.04509161f, 0.00770821f, -0.03201950f, -0.18311247f, -0.04531624f, 0.05740057f, -0.02765187f, 
    -0.03242119f, 0.00618592f, -0.03818552f, -0.07383615f, -0.60140640f, -0.11198239f, 0.17179522f, -0.13526985f, 
    -0.12351190f, -0.24871157f, -0.06752503f, -0.05501020f, -0.05868452f, 0.00893033f, 0.05137348f, 0.00143656f, 
    0.01423120f, -0.02382073f, 0.02616738f, 0.01641002f, -0.05526299f, -0.00554580f, 0.07293276f, -0.03241250f, 
    -0.03898090f, -0.03275616f, 0.15292141f, -0.02649718f, 0.06684404f, -0.00473724f, -0.02275829f, -0.01845835f, 
    0.02180802f, 0.01710916f, -0.00278530f, 0.07660089f, 0.10142042f, 0.14066130f, 0.01290268f, 0.05205643f, 
    0.03565457f, 0.10152417f, 0.01546495f, 0.04722791f, -0.08172109f, 0.07249835f, 0.08585849f, 0.00068614f, 
    -0.14504163f, 0.08099917f, 0.05385444f, -0.01261489f, -0.01157532f, 0.00239003f, 0.01245312f, -0.01577396f, 
    0.09103246f, -0.02793126f, -0.02184674f, 0.04605014f, 0.14816773f, -0.13106357f, -0.03963843f, 0.05147290f, 
    -0.18136008f, -0.38039905f, -0.44280282f, -0.00870814f, -0.02089319f, 0.06348900f, -0.11968230f, -0.02201370f, 
    -0.12694310f, -0.14233319f, 0.01284065f, -0.01844693f, -0.05793154f, 0.03205918f, 0.01133662f, -0.03468379f, 
    -0.06434457f, 0.13425998f, 0.12784936f, 0.08748189f, -0.02901529f, -0.28895962f, -0.32908383f, -0.10520039f, 
    0.20775317f, -0.09069585f, 0.15177816f, 0.17816696f, 0.10831488f, -0.13299203f, 0.02071021f, -0.04794521f, 
    -0.07355428f, -0.01317227f, 0.00461678f, -0.00134815f, 0.03407898f, 0.00435494f, 0.23204534f, -0.02328194f, 
    0.52014166f, 0.05438101f, -0.53210843f, -0.00807975f, -0.21074048f, 0.03717791f, 0.20864145f, 0.14856108f, 
    -0.06026674f, -0.04293908f, 0.09106934f, 0.02484965f, -0.05219411f, -0.03354288f, 0.12103166f, 0.02265458f, 
    -0.05350396f, 0.10738258f, -0.07081249f, 0.05987223f, 0.03085168f, -0.19475618f, -0.14702475f, -0.12784190f, 
    0.05320590f, -0.04299715f, 0.05580391f, 0.09260604f, -0.05411603f, -0.03532611f, -0.04067405f, -0.06069421f, 
    -0.08492011f, -0.03811385f, 0.00221673f, -0.06759939f, -0.07789011f, -0.15544212f, 0.00249588f, 0.02929557f, 
    -0.02449056f, -0.12274021f, 0.10810494f, 0.09799000f, 0.03547785f, 0.01150662f, 0.09203963f, 0.01021254f, 
    -0.02328433f, -0.04320623f, 0.05135418f, -0.11449741f, -0.04385940f, 0.02401843f, -0.09723514f, -0.01171478f, 
    -0.01942317f, 0.01099271f, 0.04131123f, 0.02858050f, -0.07579766f, 0.10713583f, 0.05541762f, 0.01223002f, 
    0.06830513f, -0.00168556f, 0.02248655f, 0.01046451f, -0.01102128f, 0.00480322f, 0.02190976f, 0.01087494f, 
    0.11373083f, 0.02862480f, 0.01918387f, 0.02761951f, -0.02811774f, -0.03921149f, -0.01568805f, -0.01070357f, 
    -0.15527113f, -0.16648738f, -0.01155657f, 0.13303168f, 0.20840520f, -0.01257529f, 0.07472111f, 0.01965201f, 
    0.00856600f, 0.04116331f, 0.04642042f, -0.04912550f, 0.02902524f, 0.03700181f, -0.00171949f, 0.04914899f, 
    -0.02505979f, 0.04500471f, 0.00655412f, 0.01970512f, 0.05327167f, 0.14092964f, -0.17458858f, -0.39949167f, 
    0.06841858f, -0.08274954f, -0.08376036f, 0.12966321f, 0.15586282f, -0.01361039f, -0.00572362f, -0.03590139f, 
    0.02771805f, -0.00829545f, -0.00876288f, 0.09681738f, 0.08455297f, 0.06631199f, -0.03229273f, 0.14439082f, 
    -0.54233122f, -0.25709841f, -0.86214626f, -0.02063522f, 0.12994544f, -0.25235283f, 0.05278811f, -0.09559318f, 
    -0.05912517f, 0.07218411f, 0.02483756f, -0.00432631f, 0.05627002f, -0.05206772f, 0.07310519f, 0.04983279f, 
    -0.06476242f, 0.06584875f, 0.06435080f, 0.04556127f, -0.18186213f, -0.10960685f, -0.23837353f, 0.11124811f, 
    0.00265432f, -0.04561522f, 0.07468884f, 0.01391876f, -0.03689528f, 0.08134034f, 0.04643964f, 0.01317695f, 
    -0.00856785f, 0.04566225f, -0.03434549f, -0.01137028f, -0.06073625f, -0.03339354f, 0.14942704f, 0.06127921f, 
    0.10068569f, -0.04711351f, -0.07370358f, -0.02929146f, -0.08653625f, 0.01543240f, -0.00685848f, 0.00924452f, 
    0.00316615f, 0.01352337f, -0.00707043f, -0.05899946f, -0.07814702f, -0.18595180f, -0.04619191f, -0.05909632f, 
    -0.06487237f, -0.14744323f, -0.02863455f, -0.00068429f, -0.21152553f, 0.25146315f, 0.34243405f, 0.17335266f, 
    0.25172457f, 0.02747518f, -0.21282905f, -0.07182575f, 0.08222210f, 0.00228777f, 0.06202144f, 0.03595875f, 
    0.10314120f, 0.10312038f, 0.07777786f, 0.00441222f, 0.10800710f, -0.12295824f, -0.07919157f, 0.05660606f, 
    0.02286619f, 0.07509918f, 0.00516342f, -0.01489649f, 0.01545358f, -0.04916006f, -0.03659027f, -0.04664739f, 
    0.00125615f, 0.02971157f, 0.04399464f, -0.02586100f, 0.02010666f, 0.03174977f, 0.01198849f, -0.02056800f, 
    -0.02738640f, -0.06053004f, 0.06230766f, -0.10939732f, -0.23152068f, -0.12186506f, 0.33947751f, -0.23507379f, 
    0.21678150f, -0.03863651f, -0.11430978f, -0.01255044f, -0.15542196f, 0.02509882f, -0.03272740f, 0.06877802f, 
    0.04633643f, 0.05181693f, -0.06607105f, 0.03606173f, 0.02562535f, 0.01119716f, 0.01077208f, 0.02120114f, 
    -0.07257283f, 0.06743912f, -0.20413212f, 0.02002366f, 0.15544479f, 0.00189081f, 0.14786309f, 0.02067182f, 
    0.09264187f, 0.15277918f, -0.06322385f, 0.02212623f, 0.02210507f, 0.00243170f, 0.07140833f, 0.09390662f, 
    0.08848109f, -0.12923709f, 0.13920778f, -0.08672680f, 0.05570460f, 0.13040495f, -0.22417012f, -0.04121709f, 
    -0.04270525f, -0.14280556f, 0.00579442f, 0.00164464f, -0.12118322f, 0.22791032f, -0.09379616f, 0.11994032f, 
    0.05459373f, -0.13098039f, 0.09892831f, -0.02798701f, 0.03873919f, -0.09225321f, 0.22224548f, -0.03002887f, 
    -0.10955219f, -0.00684680f, 0.10536059f, 0.03102508f, 0.02376136f, -0.02891450f, -0.04413378f, -0.05414221f, 
    -0.03027616f, 0.03708178f, 0.04308634f, 0.02911653f, 0.01869950f, 0.01439739f, -0.00793166f, 0.02234024f, 
    -0.00983654f, -0.06069451f, -0.06504201f, 0.01424704f, -0.24679157f, -0.43372539f, -0.41642603f, 0.03873488f, 
    0.15287544f, -0.07923588f, 0.00761473f, 0.00405800f, -0.08389520f, -0.15290789f, -0.01417238f, -0.06269527f, 
    -0.07979788f, 0.05858696f, 0.06373256f, -0.07651854f, 0.13007089f, 0.19029847f, 0.17093123f, 0.07522592f, 
    -0.56579727f, 0.13393864f, 0.41641927f, -0.00621053f, 0.08742861f, -0.06070840f, -0.02857919f, -0.01122222f, 
    -0.14224419f, 0.28084892f, -0.17932281f, 0.02658809f, 0.04897643f, 0.04193758f, 0.07700249f, 0.00717628f, 
    -0.01255785f, -0.07577378f, 0.03664907f, 0.01559549f, -0.11876439f, 0.11833058f, 0.10091027f, -0.04848662f, 
    0.05016610f, -0.00914262f, -0.01304195f, -0.04961401f, -0.05087415f, 0.02269105f, -0.04585082f, -0.08910950f, 
    0.02193715f, 0.04089016f, 0.05839055f, 0.03968894f, -0.04363055f, -0.06573611f, -0.04320131f, -0.02043047f, 
    -0.90618569f, -0.86422807f, -0.61977071f, -0.54520345f, -0.02098945f, -0.30762097f, -0.15891127f, -0.36715427f, 
    -0.14145614f, -0.63662064f, 0.03891977f, -0.01795442f, -0.04484022f, -0.04849004f, 0.03286076f, -0.00922404f, 
    -0.00142917f, 0.12482988f, 0.03446479f, 0.00808879f, 0.01450127f, 0.11393620f, -0.03200314f, -0.04420252f, 
    0.07702875f, -0.02223010f, 0.01177421f, 0.01560982f, 0.11244143f, -0.07583937f, -0.00626229f, -0.03520370f, 
    -0.03684160f, 0.06231858f, -0.00549935f, -0.00550985f, 0.02986932f, 0.03401383f, -0.06761792f, -0.03600913f, 
    -0.04724125f, -0.03597823f, -0.07681166f, -0.06200912f, -0.10616964f, -0.00054011f, -0.03754042f, -0.05516544f, 
    -0.04839467f, 0.00073341f, -0.05267571f, -0.04848843f, -0.03592607f, -0.12624826f, -0.15112647f, -0.01840898f, 
    -0.06059157f, -0.02981211f, -0.02349698f, 0.02585879f, -0.17957263f, -0.04227515f, 0.05564880f, -0.04741407f, 
    0.06767254f, 0.00765459f, 0.07715409f, 0.00740906f, 0.03461884f, 0.01294489f, 0.08089257f, -0.01500027f, 
    0.00370717f, -0.00262027f, 0.00374124f, 0.04755316f, 0.04313216f, -0.00422452f, 0.00219385f, -0.01948381f, 
    -0.06717097f, -0.07541358f, 0.12457938f, -0.03387650f, 0.01944198f, 0.04478691f, 0.03269855f, 0.06636249f, 
    -0.02359478f, 0.03496243f, -0.00750875f, -0.07772662f, 0.05988057f, -0.06041563f, -0.00591088f, -0.11730940f, 
    -0.07358880f, 0.01123739f, -0.01611511f, 0.04387804f, -0.01872258f, 0.45487005f, -0.28035977f, -0.19029924f, 
    -0.24668853f, -0.16179478f, 0.06817550f, 0.03868704f, 0.13925165f, 0.10394048f, 0.04159147f, -0.00466444f, 
    0.09430661f, 0.01211596f, -0.01210688f, -0.00577918f, 0.10643912f, -0.22072233f, 0.19337842f, -0.01536822f, 
    0.07253332f, 0.12583148f, -0.14023232f, -0.06674893f, 0.11443280f, -0.09716029f, 0.01654908f, 0.00988299f, 
    0.04960141f, 0.23384759f, 0.12079775f, 0.04353804f, -0.04828660f, 0.01363402f, -0.00728926f, 0.00211885f, 
    0.02697556f, -0.05480751f, 0.03071275f, -0.13409959f, -0.36051285f, -0.42057770f, -0.01130497f, -0.17828062f, 
    -0.29914480f, 0.04595524f, -0.12196878f, -0.00145038f, -0.07899682f, -0.06934997f, 0.01759064f, 0.03151860f, 
    -0.02469553f, 0.08152935f, -0.04449384f, -0.04578344f, -0.01400384f, -0.02098416f, -0.03243138f, 0.03280436f, 
    -0.02462864f, 0.19633000f, -0.04010574f, -0.02594091f, 0.18865725f, -0.06629398f, -0.02331265f, -0.03302336f, 
    0.10209690f, -0.06334940f, 0.22904909f, 0.03098514f, 0.00555743f, -0.02509691f, -0.00391150f, 0.04548841f, 
    0.01043898f, -0.11931232f, 0.05414246f, -0.01908683f, -0.10232461f, -0.10661667f, 0.21411489f, 0.02587794f, 
    0.03193379f, 0.02204783f, -0.02287244f, -0.09548859f, -0.00297898f, 0.14768474f, -0.11299724f, -0.02025847f, 
    0.04303891f, -0.01957928f, -0.07804342f, -0.03163927f, -0.01840553f, -0.06627383f, 0.07999611f, -0.03075685f, 
    0.24780339f, -0.34354037f, -0.21175829f, -0.38043779f, -0.14989416f, 0.08488475f, 0.00633384f, -0.01104655f, 
    0.11522392f, -0.04092519f, 0.00516724f, 0.01612981f, 0.01753638f, -0.04392914f, -0.00079853f, -0.01731328f, 
    -0.06876502f, 0.01480905f, -0.02355344f, -0.02686067f, 0.25123084f, -0.44880643f, -0.06976350f, -0.24715523f, 
    -0.27739108f, -0.05954589f, 0.03310002f, -0.10763802f, 0.15518895f, 0.01545656f, -0.01133012f, 0.04709358f, 
    -0.11173394f, 0.01302647f, 0.02693036f, -0.07460495f, 0.00041108f, -0.07669259f, 0.03740977f, -0.05716511f, 
    0.03383528f, -0.03972439f, -0.02872043f, -0.02867215f, 0.01324530f, 0.01697996f, 0.04302510f, 0.06518392f, 
    -0.02574031f, -0.01979311f, -0.01625741f, -0.13190123f, 0.01500286f, 0.00525777f, 0.06206851f, -0.07876907f, 
    -0.11040843f, 0.03685334f, -0.00628443f, 0.13076766f, 0.23091552f, 0.03442301f, -0.06467535f, -0.11202936f, 
    -0.10976154f, -0.12227485f, 0.03290314f, -0.04325897f, 0.02775144f, -0.02533913f, 0.01949053f, -0.06454250f, 
    0.07838763f, -0.04536843f, 0.01456982f, -0.01782673f, 0.03756781f, -0.00231027f, 0.03710698f, 0.03240461f, 
    -0.00749404f, -0.00518065f, -0.08794974f, 0.11038034f, -0.08208871f, 0.04523893f, 0.03886028f, 0.06036605f, 
    -0.02036682f, -0.01523426f, 0.00001038f, 0.01750304f, 0.01781351f, 0.01451126f, 0.00181740f, 0.00868251f, 
    -0.01307605f, -0.21916012f, -0.03024516f, 0.06978344f, -0.48063567f, -0.61696547f, 0.14942418f, 0.55431300f, 
    0.12260000f, -0.07153490f, 0.12576857f, -0.03851944f, 0.01005239f, 0.13452542f, 0.04873957f, -0.01889439f, 
    -0.01086621f, -0.02975379f, -0.05304433f, -0.04177830f, 0.04066875f, -0.32887533f, 0.08682380f, -0.01888843f, 
    0.39340639f, -0.27643913f, -0.15888466f, -0.20146711f, -0.13167965f, -0.02299791f, 0.05401852f, 0.00010490f, 
    0.02597786f, 0.05446663f, 0.01352246f, -0.09401353f, 0.05865322f, 0.02224797f, 0.04429855f, 0.01039742f, 
    -0.01384566f, -0.01193427f, 0.01791151f, -0.06633153f, -0.39716285f, -0.32381544f, 0.06791425f, 0.06278206f, 
    0.13800351f, -0.00296210f, 0.05311022f, 0.01800882f, 0.03678685f, 0.11541925f, 0.03021294f, 0.01189606f, 
    -0.00522541f, -0.07039128f, -0.05435042f, 0.02501418f, 0.01866276f, -0.00569132f, 0.07802886f, -0.15898055f, 
    0.08751445f, 0.10571242f, 0.00263314f, -0.06062588f, 0.01865412f, -0.01258436f, 0.09934270f, 0.04737323f, 
    0.01139067f, 0.01637583f, -0.07363033f, -0.03182542f, 0.02889355f, -0.12016116f, -0.03398536f, -0.15363523f, 
    0.04604153f, 0.00022177f, -0.10129098f, 0.07119132f, 0.07316614f, -0.22092402f, -0.16466643f, -0.26696324f, 
    -0.09608719f, 0.08206247f, 0.01584859f, -0.10012998f, 0.18509421f, 0.11034652f, 0.00290967f, 0.00229855f, 
    0.02597260f, -0.04332290f, 0.01237010f, 0.03755772f, -0.02768541f, -0.04129094f, 0.10898320f, -0.10711991f, 
    0.26153395f, -0.41558298f, -0.55152547f, -0.18237969f, -0.07251602f, 0.14503039f, 0.02333203f, -0.20331661f, 
    0.11893601f, 0.04463981f, 0.00798776f, 0.08008813f, 0.05589061f, 0.04516960f, 0.04507959f, -0.00547337f, 
    -0.00510675f, -0.00636435f, 0.03197384f, 0.01731597f, -0.03217322f, 0.13972795f, -0.29289147f, 0.02522160f, 
    -0.28793636f, 0.00298325f, 0.11200126f, -0.07710510f, -0.04786346f, 0.08740813f, -0.03052751f, 0.02801861f, 
    -0.01226340f, 0.00369766f, -0.00407876f, -0.09139398f, -0.09445056f, -0.05756964f, -0.07466946f, -0.03853637f, 
    0.13509656f, -0.29373547f, 0.44093558f, -0.33665055f, 0.11941158f, 0.01739113f, -0.15502271f, -0.04663494f, 
    0.05439610f, -0.07560828f, -0.02749993f, -0.01737927f, 0.00010997f, -0.03973306f, -0.00972528f, 0.02085095f, 
    -0.06706247f, 0.11651494f, -0.12487537f, -0.16263276f, 0.08287848f, -0.01316034f, 0.08068209f, 0.01133053f, 
    -0.06878334f, -0.01391811f, 0.07533024f, -0.04957995f, -0.09480287f, -0.01045863f, -0.00944767f, 0.04914377f, 
    -0.00479191f, -0.00671116f, 0.00331169f, -0.16407098f, -0.10134935f, -0.00682923f, -0.01809116f, 0.02844836f, 
    0.07213543f, -0.26916042f, -0.21884006f, -0.17559928f, -0.11513793f, -0.02479694f, -0.03932421f, 0.10559618f, 
    0.14835612f, -0.03913218f, -0.06406559f, 0.01110810f, 0.04291417f, 0.05586611f, 0.07103788f, -0.00132532f, 
    -0.00246172f, 0.04013942f, 0.04702177f, -0.01220419f, -0.01221050f, 0.08924469f, 0.06286918f, 0.01106773f, 
    -0.12203749f, -0.01905508f, 0.02528238f, -0.11316057f, -0.00416000f, -0.03642519f, 0.04203019f, 0.02849706f, 
    0.03078431f, -0.02668474f, -0.02600736f, -0.07356691f, -0.10611241f, -0.08099770f, -0.03688511f, 0.00786241f, 
    -0.49028519f, -0.33840409f, -0.16195542f, 0.20089166f, 0.09438446f, 0.03609151f, 0.05479442f, 0.00321722f, 
    0.06044705f, -0.02261360f, 0.00556215f, -0.01527175f, -0.01164749f, -0.03602510f, -0.07447827f, -0.00647994f, 
    0.00577270f, 0.02430567f, 0.09253280f, -0.10667013f, 0.50207710f, -0.50421125f, -0.28060472f, -0.20647991f, 
    -0.13814802f, 0.00058538f, -0.12184668f, -0.12662758f, 0.19247206f, -0.05364634f, 0.02184594f, -0.04241422f, 
    0.11652482f, 0.00713566f, 0.04596496f, 0.02131605f, -0.02966058f, 0.04803329f, 0.03586254f, 0.02890977f, 
    -0.32117286f, -0.27066204f, 0.12884784f, 0.32622913f, -0.07827774f, 0.03516300f, 0.02882043f, 0.08039206f, 
    -0.01068725f, 0.15186007f, -0.00984344f, -0.04839039f, -0.01139867f, -0.00719942f, -0.04071896f, 0.05351342f, 
    0.08366614f, -0.09201937f, 0.05835370f, 0.00471158f, 0.01688118f, 0.06736851f, 0.06101879f, 0.02407526f, 
    -0.06821102f, 0.00610577f, 0.02443977f, 0.01238528f, -0.02816800f, -0.00938983f, 0.04896839f, 0.00243018f, 
    0.04111554f, -0.02074354f, -0.00149578f, -0.03443529f, -0.13821326f, 0.05960737f, 0.06915570f, 0.03013609f, 
    -0.35580930f, -0.36647475f, 0.42431757f, -0.04945038f, 0.28466317f, 0.04809460f, -0.08195343f, 0.23585062f, 
    -0.02534645f, 0.04809384f, -0.06628916f, 0.02558844f, 0.11339730f, 0.09446649f, -0.15900092f, -0.12681465f, 
    0.02931580f, 0.00388770f, -0.04531810f, 0.02509822f, 0.45928657f, -0.27572739f, 0.16224301f, -0.06075145f, 
    -0.17780462f, -0.11002593f, 0.18436450f, 0.10636593f, 0.07388359f, -0.07338878f, -0.09104526f, -0.11923534f, 
    0.15044771f, 0.01399285f, 0.00585727f, -0.01065583f, 0.01589284f, 0.02388776f, -0.03115643f, -0.11322600f, 
    0.33567163f, 0.09371586f, -0.33241791f, -0.09984864f, -0.21410820f, 0.01165091f, -0.00756411f, -0.19827774f, 
    0.04083683f, -0.03413766f, -0.01714675f, 0.01162553f, 0.02600683f, 0.00349068f, 0.10336935f, 0.02883938f, 
    0.03398353f, -0.04213183f, 0.03606523f, 0.03517851f, 0.10684328f, -0.48327225f, -0.55453050f, -0.35410434f, 
    -0.36968732f, 0.02746020f, -0.00163499f, 0.09816743f, 0.19803090f, 0.08791042f, 0.03221572f, 0.05044302f, 
    -0.05725798f, 0.08072677f, 0.11591578f, -0.09915368f, -0.00003849f, -0.02493750f, 0.04184874f, 0.10739855f, 
    -0.15327357f, -0.10303064f, 0.08121921f, 0.05277614f, 0.04523799f, -0.00659957f, -0.01430177f, -0.00272274f, 
    0.10807359f, 0.13499813f, 0.12854367f, -0.09390850f, 0.02928026f, -0.01194995f, -0.02898024f, 0.04226837f, 
    0.00000295f, -0.06410097f, -0.13584799f, 0.10325292f, 0.17751120f, -0.13120301f, -0.41228783f, 0.12598489f, 
    -0.24225388f, 0.01077412f, 0.03169044f, 0.03799195f, -0.03736803f, -0.08322248f, -0.00951504f, 0.01859768f, 
    -0.00722292f, -0.00418538f, -0.14874297f, -0.02619244f, -0.06327739f, 0.12174369f, -0.11376875f, -0.09659155f, 
    -0.60992163f, -0.42644849f, 0.03751929f, -0.15604097f, 0.10656560f, -0.07216993f, 0.01031629f, 0.12614179f, 
    -0.00782951f, -0.12577304f, -0.04656889f, 0.04013533f, -0.02970153f, -0.00207598f, 0.00031969f, 0.01865829f, 
    -0.01497155f, 0.00408304f, -0.05881875f, -0.00522626f, 0.03232674f, 0.00165550f, 0.03472988f, 0.22061008f, 
    -0.23560178f, 0.06800929f, 0.00363910f, -0.03201406f, -0.04157937f, -0.02514789f, -0.06111996f, 0.07118631f, 
    0.00946645f, -0.03915057f, 0.01469000f, 0.02704087f, 0.09339146f, 0.18518138f, -0.03242657f, -0.01017751f, 
    0.09143494f, 0.09080420f, -0.06422593f, 0.00263786f, -0.09926426f, -0.00989956f, 0.05508170f, 0.01025599f, 
    -0.04890820f, -0.03164413f, -0.14910182f, -0.21287853f, 0.12850288f, -0.05899968f, -0.06430773f, -0.03902160f, 
    -0.00859214f, 0.06219000f, -0.01661835f, 0.01633362f, -0.06227373f, 0.08613718f, 0.07262114f, -0.00934025f, 
    0.03146210f, -0.01249975f, 0.04396870f, 0.00131227f, -0.00875071f, -0.00854552f, 0.08535900f, -0.05304687f, 
    -0.04315956f, -0.00772084f, -0.06852851f, -0.03637534f, -0.01054439f, 0.04292710f, 0.04136137f, 0.02333053f, 
    -0.07566942f, -0.08183894f, -0.04583706f, 0.09674145f, 0.00816119f, 0.01717957f, -0.02367028f, 0.03704907f, 
    0.05353124f, 0.01851108f, 0.05608913f, 0.02548722f, -0.01819184f, 0.00914234f, -0.04185929f, 0.00924016f, 
    0.01184634f, -0.04453737f, 0.02021331f, 0.06051851f, 0.41064143f, -0.44888148f, -0.35247400f, -0.31189817f, 
    -0.18805939f, 0.05276987f, -0.17455810f, -0.03530467f, 0.10108111f, 0.02493557f, -0.01048304f, 0.05464333f, 
    0.03215839f, 0.00414912f, 0.01827691f, -0.00662756f, -0.00791818f, 0.02725259f, -0.01569934f, -0.05805748f, 
    0.08206856f, -0.04486699f, -0.10110743f, 0.04026125f, -0.07751936f, 0.01116862f, 0.01003327f, 0.01216681f, 
    0.04687261f, 0.03697628f, -0.02852517f, -0.06540518f, -0.04253457f, -0.04209547f, -0.05192379f, -0.04088070f, 
    0.02333289f, -0.15104304f, 0.03379245f, 0.11799181f, 0.00719159f, -0.05384415f, 0.15707161f, -0.13808502f, 
    0.10216185f, 0.03494553f, 0.03833215f, 0.05083146f, -0.02568175f, -0.01226804f, 0.13892910f, -0.02138147f, 
    0.04537335f, -0.02794548f, -0.04352405f, -0.10502218f, -0.03724022f, -0.09495940f, 0.04911529f, -0.04479634f, 
    -0.31543326f, -0.24727887f, 0.44241709f, -0.10145784f, 0.00869462f, 0.03977164f, 0.03027692f, -0.16435276f, 
    0.08967889f, -0.01273991f, 0.00210280f, -0.03113594f, -0.00505909f, -0.02196498f, -0.08123598f, 0.10088841f, 
    0.04491261f, 0.00213864f, 0.04307981f, -0.10307611f, -0.18205388f, -0.09733600f, -0.11853219f, 0.21261445f, 
    -0.22272192f, 0.09356505f, 0.00722153f, 0.05616115f, -0.02919550f, -0.02030161f, 0.02745873f, 0.02021760f, 
    0.07138447f, 0.01129353f, -0.01458174f, 0.06300565f, -0.01759152f, -0.03194042f, -0.08725217f, 0.03272267f, 
    -0.25815418f, -0.21403791f, 0.38916445f, -0.09207255f, 0.15301985f, -0.06748025f, -0.03452709f, 0.01736634f, 
    0.00934931f, 0.10676044f, 0.08393838f, 0.05897891f, 0.04441440f, 0.02500034f, -0.03350870f, 0.07549565f, 
    -0.04393103f, -0.06676980f, -0.06680725f, -0.02593701f, 0.03305957f, 0.09857631f, -0.02048257f, 0.02961740f, 
    -0.14169520f, 0.03144941f, 0.03015054f, -0.03971881f, -0.04085309f, -0.02136939f, 0.03347255f, 0.02876405f, 
    0.01764940f, 0.04585950f, -0.00940400f, -0.12217304f, -0.20579690f, 0.00748887f, 0.01685997f, -0.01849498f, 
    0.03586297f, 0.13944535f, -0.06179501f, -0.01789301f, -0.04524831f, -0.05276560f, 0.04909392f, 0.04338472f, 
    -0.03428736f, -0.04821669f, -0.15802284f, 0.03455326f, 0.04052908f, -0.12082915f, -0.18810821f, -0.01174848f, 
    -0.07505785f, -0.03837657f, -0.09827240f, 0.01157666f, -0.01934799f, 0.04939260f, -0.00197550f, -0.05374810f, 
    -0.07997833f, 0.01361369f, -0.03822029f, 0.02867397f, 0.00636437f, -0.02252637f, -0.14835048f, -0.10377839f, 
    -0.14590025f, -0.06570103f, -0.11878891f, -0.00699918f, -0.01289887f, -0.00090169f, -0.00789164f, 0.02459469f, 
    0.10433139f, 0.11224227f, 0.11733261f, -0.14938869f, -0.07959583f, -0.01547134f, 0.02662749f, -0.05720709f, 
    0.02994023f, -0.02082695f, -0.03319041f, -0.02710466f, 0.04233720f, 0.02892956f, -0.02071919f, -0.06091160f, 
    -0.02005501f, -0.15669671f, -0.06349862f, -0.10320419f, -0.01140640f, -0.07403854f, -0.09087113f, 0.02858205f, 
    0.06084692f, -0.12007503f, 0.05805853f, 0.11135241f, -0.10916900f, -0.00484903f, 0.04548734f, 0.04155200f, 
    0.01479236f, 0.05120851f, -0.00770332f, 0.07081379f, -0.09740379f, 0.07959463f, -0.10179894f, 0.10185930f, 
    0.10150839f, 0.07143033f, -0.00085464f, 0.51850122f, -0.59909749f, -0.06194033f, 0.00413792f, -0.02862316f, 
    -0.02684660f, 0.04694670f, -0.02682301f, 0.01988456f, 0.02235334f, 0.00115893f, 0.04280399f, -0.07913579f, 
    0.11991113f, 0.08025101f, 0.00984487f, -0.02485448f, 0.06669921f, 0.13285364f, -0.08618890f, -0.08988125f, 
    -0.22388262f, 0.00732416f, 0.07785565f, -0.02446942f, 0.04080999f, -0.00446727f, -0.09059179f, 0.07715900f, 
    0.04997798f, -0.01419682f, -0.04602607f, 0.00348162f, -0.04188022f, 0.06441653f, -0.13066758f, -0.08743508f, 
    -0.00743976f, 0.06630900f, 0.01599245f, -0.04068127f, -0.00640484f, -0.01974123f, 0.01061883f, 0.00275854f, 
    0.00209383f, -0.01937044f, 0.05622289f, -0.02199259f, 0.02365063f, -0.02706393f, -0.00134666f, -0.04904104f, 
    -0.06517740f, 0.04169736f, 0.04865508f, 0.00334045f, 0.70220518f, -0.19110793f, -0.07136294f, -0.35010579f, 
    0.10537906f, -0.13407603f, -0.05280128f, 0.07625891f, -0.06311713f, -0.07483666f, 0.15873094f, -0.02759760f, 
    -0.00800341f, -0.02457944f, -0.22798930f, 0.00816639f, -0.04232561f, -0.05232153f, 0.02630554f, -0.01846310f, 
    0.05427570f, -0.00370586f, -0.16729060f, 0.00289746f, -0.08044380f, 0.04530237f, 0.02109185f, 0.01238030f, 
    -0.03343887f, 0.01902562f, -0.08726980f, -0.11090896f, 0.06334064f, 0.00771589f, -0.06219664f, -0.01080327f, 
    -0.04314755f, 0.00277706f, -0.01780609f, -0.02462505f, 0.52037448f, -0.66805249f, -0.18165378f, -0.38032490f, 
    -0.13330618f, -0.15487865f, 0.08789466f, -0.37545034f, 0.28676811f, -0.08590155f, -0.02583373f, 0.04095097f, 
    0.03460225f, 0.04082421f, 0.12749420f, -0.05244810f, 0.02441691f, -0.05902237f, 0.06327131f, 0.05812603f, 
    0.28992179f, 0.14287224f, -0.25168741f, 0.12483967f, -0.12253031f, -0.00263246f, 0.05157405f, -0.11332367f, 
    -0.09205545f, 0.02318225f, -0.05225824f, 0.12418719f, 0.12365247f, -0.08093185f, -0.04110889f, -0.01071491f, 
    -0.20036806f, 0.11155371f, -0.11777831f, -0.04552331f, 0.17367114f, -0.07149594f, -0.13574767f, 0.07257115f, 
    -0.03108087f, 0.12273126f, 0.01616736f, 0.10893103f, 0.00549352f, 0.14812486f, 0.05858396f, 0.04535945f, 
    -0.02067087f, -0.05552479f, 0.06143756f, -0.08696622f, 0.04208691f, -0.00578699f, -0.00646869f, 0.06661937f, 
    0.11829171f, 0.10123630f, 0.02978915f, -0.10835389f, -0.08706366f, 0.00632887f, -0.00657022f, 0.02751611f, 
    -0.01626879f, -0.00509582f, -0.00813859f, -0.13066904f, -0.05992197f, -0.20503943f, -0.08097390f, 0.03775311f, 
    -0.00506992f, 0.00608549f, 0.00215453f, 0.01959057f, -0.33166942f, -0.33976820f, 0.28481430f, 0.06846768f, 
    0.22789128f, 0.06276762f, -0.02680836f, 0.08996398f, -0.09624690f, -0.03665945f, -0.01192975f, -0.00146087f, 
    -0.06076621f, 0.04825533f, -0.05366774f, 0.11994069f, 0.10245108f, 0.01420129f, 0.08996384f, -0.02666693f, 
    0.44782174f, 0.23858671f, -0.36661401f, -0.23858224f, -0.20944414f, -0.02453308f, -0.05258529f, -0.09570135f, 
    0.03278262f, 0.00754704f, 0.01869949f, -0.01023418f, 0.01226339f, 0.06447043f, 0.02921882f, 0.01323955f, 
    0.04255542f, -0.01154040f, 0.07070566f, 0.02663719f, 0.03254785f, 0.07398883f, 0.02124286f, -0.04858706f, 
    -0.05970935f, 0.02987929f, 0.03966491f, 0.00309865f, -0.01093714f, -0.01930285f, -0.05747755f, -0.10099966f, 
    -0.19629951f, -0.02676212f, 0.00005139f, 0.01247684f, -0.01827601f, -0.02137385f, 0.01552573f, -0.00230677f, 
    -0.56529462f, -0.66457534f, 0.24049491f, 0.33662435f, 0.08799459f, -0.10176583f, 0.19548567f, -0.02317746f, 
    0.10629159f, 0.12549160f, 0.00701735f, 0.01801999f, -0.04625925f, -0.03336096f, -0.01302888f, -0.01649502f, 
    -0.02577705f, -0.07740055f, 0.10373760f, -0.02864652f, 0.06639281f, -0.01145225f, -0.10609341f, -0.00294212f, 
    0.04063511f, -0.02427774f, 0.07172351f, -0.03088521f, -0.01788157f, -0.03641224f, -0.03368492f, -0.10363814f, 
    0.00680199f, -0.02790270f, -0.07326123f, -0.03815684f, -0.05486715f, 0.04061877f, -0.10047542f, 0.01075631f, 
    0.03678428f, 0.07812893f, 0.07046828f, -0.00086846f, -0.06205621f, 0.00228749f, 0.01920428f, 0.02298672f, 
    0.04040403f, -0.03202068f, 0.06465258f, 0.00758179f, 0.01746666f, -0.02585106f, -0.01565024f, 0.03171740f, 
    -0.04415951f, 0.04745761f, 0.02263474f, 0.00692243f, -0.09907877f, -0.11606665f, 0.11130418f, -0.02031591f, 
    0.18035729f, 0.04029177f, 0.02299709f, 0.06986126f, -0.02768934f, 0.02076503f, 0.05672659f, -0.02094578f, 
    -0.00269314f, -0.00772793f, -0.11633015f, -0.04800063f, 0.01419036f, -0.12989390f, -0.10690770f, -0.05830380f, 
    0.02958240f, 0.13365707f, -0.03078958f, 0.05067553f, -0.11397921f, 0.01248756f, -0.02769404f, 0.03733535f, 
    0.01941039f, -0.04768974f, -0.02091530f, 0.01258645f, 0.00506483f, -0.05611746f, -0.03139593f, -0.14412437f, 
    -0.25462154f, 0.10156829f, -0.10262492f, -0.01399465f, -0.02605411f, -0.03721942f, -0.10719406f, 0.18964659f, 
    0.19240411f, 0.15051909f, -0.01412406f, -0.08960685f, -0.28437501f, -0.06546168f, 0.00547870f, -0.02022694f, 
    0.01212701f, 0.02539649f, 0.08654055f, 0.10675603f, 0.07691592f, 0.10905699f, 0.13703948f, 0.05909523f, 
    0.09913851f, 0.09586519f, -0.26300633f, 0.05382285f, -0.11244164f, 0.10874263f, 0.03811736f, 0.03870333f, 
    -0.09627334f, -0.06907256f, -0.25739726f, -0.04789698f, 0.04432539f, -0.00003749f, -0.17635669f, -0.09139936f, 
    -0.06022588f, 0.07069051f, -0.05308229f, -0.02722898f, 0.36629432f, -0.41225705f, 0.09333687f, -0.38070011f, 
    -0.31233689f, -0.08134162f, 0.14191861f, -0.07679965f, 0.33629337f, -0.03730783f, -0.00235699f, 0.01774930f, 
    0.02476984f, -0.01166995f, 0.01407413f, -0.04906211f, -0.03113262f, -0.20978853f, 0.00865810f, 0.02541448f, 
    -0.17485140f, 0.05613572f, -0.13894893f, 0.05613274f, -0.06411266f, 0.02516273f, 0.00455404f, 0.09935014f, 
    -0.06886501f, 0.02650196f, -0.15803169f, 0.10249276f, -0.00432856f, -0.04240635f, 0.00804756f, -0.02959972f, 
    -0.01221822f, 0.05555067f, -0.04436857f, 0.05310456f, 0.13003887f, 0.06579901f, -0.12466437f, -0.26254410f, 
    -0.01155337f, 0.03776595f, 0.03689688f, -0.10513987f, -0.00986331f, -0.03103114f, -0.00974545f, 0.05861467f, 
    -0.09438090f, 0.02922036f, 0.07666144f, 0.01646816f, 0.00660417f, 0.00404306f, 0.04236899f, -0.01242048f, 
    -0.08654423f, -0.30421832f, -0.48409528f, -0.27457079f, 0.06709149f, 0.02591037f, 0.06192612f, 0.17345500f, 
    0.06549083f, -0.03041289f, -0.01743148f, -0.06648441f, -0.04579314f, 0.00371099f, 0.00921334f, 0.06222706f, 
    -0.02247474f, -0.02980790f, 0.07589991f, 0.02279892f, -0.04036880f, -0.15899263f, -0.45140710f, -0.32263720f, 
    0.03237998f, 0.01839139f, 0.08663750f, 0.10022467f, 0.09285194f, -0.00664859f, -0.03164194f, -0.02299233f, 
    -0.01165803f, 0.07765960f, 0.07255138f, 0.07955715f, 0.04476954f, 0.08166647f, -0.01089889f, 0.07935183f, 
    -0.20374545f, 0.00216386f, 0.02679174f, 0.09506561f, 0.06796382f, 0.01953460f, -0.09794851f, 0.01709514f, 
    -0.03483684f, -0.04870473f, 0.04813798f, 0.10793027f, 0.05866123f, 0.02994641f, -0.00930439f, -0.06686930f, 
    0.01264918f, -0.13338672f, -0.09430897f, 0.03936870f, -0.12814291f, -0.26953167f, -0.27063000f, 0.01819683f, 
    -0.00713075f, -0.06809938f, 0.05154593f, 0.10925230f, 0.08683853f, 0.06443858f, 0.08043797f, -0.10566258f, 
    -0.00371666f, -0.04524802f, -0.05505193f, -0.00817995f, 0.02870791f, 0.00419792f, 0.05598553f, -0.00233829f, 
    0.14896148f, 0.12119731f, 0.16354664f, 0.00633049f, -0.07315419f, 0.00026522f, -0.07445969f, -0.11674958f, 
    -0.01810024f, -0.03034213f, 0.00076709f, 0.02011663f, 0.01895405f, -0.03334307f, -0.04994286f, -0.21880464f, 
    -0.10013357f, -0.06257910f, -0.12932529f, -0.25934798f, 0.32618663f, 0.05433501f, 0.06442326f, -0.17494129f, 
    -0.10634226f, -0.01123331f, -0.24082065f, -0.04333381f, -0.02500973f, -0.18652026f, -0.01311491f, 0.08339467f, 
    0.08235925f, 0.06042740f, 0.00870398f, 0.03913624f, 0.06665995f, 0.15032931f, -0.02249098f, -0.12488789f, 
    -0.02500183f, -0.29543942f, -0.28855833f, -0.07126790f, 0.03492764f, -0.04846389f, 0.00436228f, 0.04144549f, 
    0.04108464f, 0.13494462f, -0.05603436f, -0.10353396f, -0.07597510f, -0.05472139f, -0.09209091f, -0.02968044f, 
    0.01928708f, 0.06904199f, -0.02197573f, 0.04659870f, 0.10316719f, -0.38471597f, -0.45922995f, -0.16181262f, 
    -0.10739209f, -0.07202078f, -0.14498785f, 0.03119444f, -0.07012453f, -0.26991251f, -0.00509304f, -0.02922894f, 
    0.02016186f, 0.00235081f, 0.04893702f, 0.01456375f, 0.04802909f, 0.05739339f, -0.14329688f, -0.08144227f, 
    -0.01810969f, -0.00794362f, 0.00918238f, 0.02945002f, -0.02707090f, -0.01245253f, 0.03349923f, 0.03846606f, 
    -0.01408286f, 0.06442977f, 0.05865509f, -0.02163501f, -0.02361257f, 0.06317084f, 0.10757691f, 0.10425730f, 
    0.05695470f, 0.04070379f, 0.04949504f, -0.05829219f, -0.08245575f, -0.18641128f, -0.47006163f, -0.27461192f, 
    -0.09099854f, -0.02320366f, -0.10687899f, 0.03859935f, -0.06522098f, -0.22050886f, 0.02632826f, -0.02369071f, 
    -0.02918557f, 0.06677811f, 0.06525607f, 0.03422737f, 0.06102668f, 0.06402989f, -0.08492873f, -0.13370417f, 
    0.27465346f, -0.37817898f, -0.26357245f, -0.11138907f, 0.18503579f, -0.03128960f, 0.10999940f, 0.11197565f, 
    0.02569827f, 0.03050040f, 0.04228157f, -0.15466157f, -0.09284699f, 0.03195949f, -0.02460440f, 0.00083850f, 
    -0.03666183f, 0.02327047f, -0.01816253f, -0.04052357f, 0.04321733f, 0.18296562f, 0.08477183f, 0.00443390f, 
    -0.11017947f, -0.00744988f, -0.04323387f, -0.08427925f, 0.05667271f, -0.07939308f, -0.02302966f, -0.00366901f, 
    0.03078965f, -0.06244557f, 0.00564883f, 0.02584676f, -0.00089049f, -0.14508960f, -0.01273018f, -0.08827556f, 
    0.05670013f, -0.06893743f, 0.00051060f, 0.10998910f, 0.07320419f, 0.15773265f, -0.05711460f, 0.10968939f, 
    -0.00746281f, 0.04326427f, 0.03999031f, 0.03821727f, 0.05027693f, 0.03849494f, -0.02733932f, 0.00507569f, 
    0.01609473f, -0.11818699f, -0.19739977f, -0.24956335f, 0.10261035f, 0.22518754f, 0.08150199f, -0.02702902f, 
    -0.05469071f, 0.01129146f, -0.01389047f, 0.00107541f, -0.00355497f, -0.03223531f, 0.04195233f, -0.05162132f, 
    0.01466742f, 0.00395206f, -0.00340832f, 0.00581719f, 0.03370710f, 0.02666820f, 0.04272727f, -0.01038188f, 
    -0.14296024f, -0.39770794f, -0.31465280f, -0.15158811f, 0.07781395f, -0.02766310f, 0.04558106f, 0.07051501f, 
    0.02550204f, 0.08496950f, 0.01161666f, -0.07011089f, -0.08312889f, -0.06975151f, -0.11333954f, 0.01741131f, 
    -0.02730571f, -0.01188727f, 0.00776078f, -0.05676968f, -0.27912524f, 0.05977985f, 0.04204225f, 0.08342909f, 
    -0.09894387f, 0.07508697f, 0.06085110f, 0.00462318f, 0.01576170f, -0.03375273f, -0.05023869f, 0.01034761f, 
    0.01663818f, 0.02692685f, 0.02629542f, 0.03096109f, 0.00978857f, 0.05700493f, 0.04303640f, 0.01049807f, 
    0.43755126f, -0.34682617f, -0.39048404f, -0.02347429f, -0.03052802f, 0.06711724f, -0.04780796f, 0.01572655f, 
    -0.03720603f, -0.09157853f, -0.02033901f, -0.00046253f, 0.01008099f, -0.01842945f, 0.01687576f, 0.04490391f, 
    -0.01149554f, 0.06178964f, -0.00378766f, 0.12257635f, -0.10230404f, -0.17164397f, -0.34748182f, -0.01356207f, 
    0.05230141f, -0.04041484f, 0.14568426f, 0.16924401f, 0.04697519f, 0.06341402f, 0.02636291f, -0.10680655f, 
    -0.08763972f, -0.05668668f, -0.06214254f, -0.02901327f, 0.00698143f, -0.02572824f, 0.03968846f, -0.06384507f, 
    -0.15141825f, -0.14775060f, 0.05820735f, -0.20623651f, -0.27258793f, 0.03547987f, -0.22654434f, -0.10189457f, 
    -0.18792477f, -0.36841559f, 0.05159992f, -0.00879904f, 0.00277733f, -0.00982911f, 0.02642608f, 0.03188616f, 
    0.01774378f, -0.11517373f, -0.03247527f, -0.31830654f, -0.24896671f, 0.08582405f, 0.13425604f, -0.02939402f, 
    -0.12820573f, -0.06508890f, -0.02534426f, -0.01910223f, -0.00277975f, 0.00012388f, -0.10350973f, -0.07580902f, 
    -0.06558690f, 0.01706770f, -0.00328899f, 0.03208813f, 0.06928298f, 0.04469368f, -0.03014145f, 0.04425339f, 
    -0.34781194f, -0.64777237f, 0.07776410f, 0.12823828f, 0.29210293f, -0.03922934f, 0.02007196f, 0.01494285f, 
    -0.12144461f, 0.06239056f, -0.02276578f, -0.04171780f, 0.03698649f, 0.13635632f, 0.07928172f, 0.03994714f, 
    -0.00871592f, -0.12514319f, -0.03362386f, 0.00440505f, 0.41277879f, -0.16962077f, -0.06174271f, -0.28259853f, 
    0.00177013f, 0.07507656f, -0.22095296f, 0.03462061f, -0.00196352f, 0.08481397f, 0.03772211f, 0.08341557f, 
    -0.04247028f, -0.04507656f, 0.08642277f, -0.05909530f, 0.08962805f, 0.10178611f, 0.04714131f, 0.19963160f, 
    -0.10323722f, -0.32658568f, -0.44935429f, -0.13486582f, -0.03889722f, -0.15742715f, 0.06718815f, 0.12965728f, 
    0.10275131f, 0.07823966f, 0.13191329f, -0.06784309f, 0.09346830f, 0.03494468f, -0.00915508f, 0.00382699f, 
    -0.00765161f, -0.02262707f, -0.01725652f, -0.01851888f, 0.13417381f, -0.19242260f, -0.37081072f, -0.13912721f, 
    0.25243309f, -0.11596455f, 0.04121955f, 0.01029803f, 0.03928242f, 0.01335549f, 0.03123623f, -0.04951520f, 
    0.01820609f, -0.00846314f, -0.08514822f, 0.05129673f, -0.01389993f, -0.03497701f, -0.14116532f, -0.21122141f, 
    -0.14287810f, -0.14644690f, -0.05071313f, 0.06782009f, -0.04183807f, -0.04227275f, -0.05856458f, -0.07733435f, 
    -0.06048889f, -0.07710692f, -0.03362995f, 0.14711457f, 0.00616632f, 0.00207823f, -0.05038235f, 0.00155916f, 
    0.13805811f, 0.10729931f, 0.20162715f, 0.13467334f, 0.35507175f, -0.08937021f, -0.23298395f, -0.02074108f, 
    0.15146840f, 0.06653447f, 0.22088042f, 0.13164884f, 0.20994626f, 0.01333511f, 0.02646830f, -0.00528784f, 
    0.03530315f, 0.03216113f, -0.03339308f, 0.05288446f, -0.14539118f, -0.01518937f, 0.12254544f, -0.08549558f, 
    0.35747984f, -0.37782505f, -0.34195086f, -0.06534319f, 0.17193325f, 0.00939516f, -0.00666681f, -0.05917439f, 
    0.01947307f, 0.08611472f, -0.04073915f, -0.00500677f, -0.02771513f, 0.00289051f, 0.01069927f, 0.02792119f, 
    0.05122523f, 0.03645191f, 0.02400463f, 0.10610492f, 0.51610881f, 0.29994541f, 0.18533683f, -0.10750008f, 
    -0.06254973f, 0.21182135f, 0.14571325f, 0.00465949f, 0.01828790f, -0.10296240f, 0.01847538f, 0.03546665f, 
    -0.00746129f, 0.03165724f, 0.01583484f, 0.06191961f, 0.04996001f, -0.10282272f, -0.02492438f, -0.08499312f, 
    -0.09029601f, -0.09470520f, -0.06314034f, -0.06443603f, -0.16903505f, -0.10049663f, -0.02481309f, 0.00043957f, 
    0.03024649f, -0.01692075f, 0.05977075f, 0.04420965f, -0.01939361f, 0.02585613f, 0.08917025f, 0.02070508f, 
    0.11585727f, 0.02121214f, 0.11856334f, 0.00701753f, -0.17022929f, -0.10046615f, -0.06674349f, 0.04619720f, 
    -0.10519654f, -0.04689288f, -0.02740625f, -0.05677999f, -0.01968974f, 0.01657743f, -0.00137659f, 0.04189000f, 
    0.04632634f, 0.08829711f, 0.07145939f, 0.08333641f, 0.11465313f, 0.08506823f, 0.06035299f, 0.08896858f, 
    0.23793080f, -0.05136062f, -0.07065588f, -0.00269100f, -0.10069031f, -0.04743267f, -0.07828896f, -0.16042034f, 
    -0.16332664f, -0.10230414f, 0.04911813f, 0.02893850f, 0.07044530f, 0.01133079f, 0.00513686f, 0.02032877f, 
    0.09526832f, 0.14149454f, 0.16456737f, 0.13311648f, -0.08901128f, -0.37587342f, -0.54178500f, -0.32507640f, 
    0.08720829f, -0.04527771f, 0.11002427f, 0.07873850f, 0.07059166f, 0.06977585f, -0.00424061f, -0.09873562f, 
    -0.04878858f, -0.05108060f, -0.06686378f, 0.03841181f, 0.01820395f, 0.00274464f, -0.00889681f, 0.00684236f, 
    0.01762607f, 0.06518246f, 0.12174185f, 0.09119792f, -0.08885652f, -0.07463583f, -0.07465603f, -0.07149776f, 
    -0.04847976f, -0.12010908f, 0.01706846f, 0.01969443f, 0.06412431f, 0.01198961f, 0.02392722f, 0.00468659f, 
    -0.11475281f, -0.04382889f, -0.10461660f, -0.19089675f, -0.21802211f, -0.08859527f, 0.06931134f, 0.06323061f, 
    0.00510370f, -0.00188364f, -0.09247468f, 0.02612844f, 0.02258582f, -0.03010344f, 0.01933833f, -0.11977613f, 
    0.00385547f, 0.06064997f, 0.01017321f, -0.07646864f, 0.12300550f, 0.07250571f, -0.09499536f, 0.04370109f, 
    0.18755838f, -0.14156024f, -0.26701644f, -0.23882444f, -0.21244606f, -0.08764103f, -0.17115740f, 0.04724099f, 
    -0.06007310f, -0.14554812f, 0.03220762f, 0.01091015f, -0.03366052f, 0.09791833f, 0.07036354f, 0.01949615f, 
    0.00190389f, 0.08857920f, -0.12176322f, -0.26201689f, 0.29748589f, 0.06676515f, 0.00021414f, -0.04762703f, 
    -0.22070374f, -0.06199352f, -0.09492624f, -0.05356036f, -0.06925696f, -0.23140813f, 0.00638653f, 0.02497478f, 
    0.08939993f, -0.05793399f, -0.03170557f, -0.03653235f, 0.06355064f, 0.09089817f, 0.25525072f, 0.07869741f, 
    -0.07301909f, -0.18170811f, 0.01294123f, 0.19126964f, 0.14755784f, 0.12487531f, -0.00370677f, -0.18256666f, 
    -0.18950519f, 0.04766544f, -0.01234389f, -0.02286045f, 0.03534846f, 0.00973486f, -0.04127965f, -0.09737560f, 
    -0.06563081f, 0.09831746f, -0.06099277f, 0.11496685f, -0.25975117f, 0.17579184f, 0.13658677f, 0.05567086f, 
    -0.23821272f, -0.01365375f, -0.06052630f, -0.09098938f, 0.00025902f, -0.04568812f, -0.05218115f, -0.05798438f, 
    0.00365518f, -0.04993509f, -0.04931760f, 0.07073759f, 0.07590056f, -0.00766330f, -0.00533873f, 0.01406855f, 
    -0.00980925f, 0.06560228f, 0.03009528f, 0.04747219f, -0.20204890f, -0.05946518f, 0.05840758f, 0.02556368f, 
    -0.00047187f, -0.00820764f, 0.01433820f, -0.01053985f, -0.07718617f, 0.07270052f, 0.16002296f, 0.02233029f, 
    0.16854516f, 0.01722066f, 0.09377751f, 0.04658752f, -0.13689491f, -0.07916800f, 0.02796793f, -0.03564614f, 
    -0.04658982f, -0.03424877f, 0.04865103f, 0.04133146f, -0.03033336f, 0.03361201f, 0.09755565f, 0.06166233f, 
    0.10098813f, 0.16410671f, 0.06972476f, 0.04462058f, 0.05373733f, -0.00039805f, 0.07321835f, 0.04294019f, 
    -0.00898316f, 0.04251836f, 0.10670649f, -0.01263923f, 0.00356208f, 0.13548316f, -0.11965279f, 0.02159093f, 
    0.00283276f, -0.07954399f, -0.05383204f, 0.02378388f, -0.01856735f, -0.07698647f, 0.05841149f, -0.00260471f, 
    -0.03230387f, -0.13345170f, -0.07931472f, 0.05548543f, 0.12608100f, 0.02835318f, 0.05633674f, 0.07138231f, 
    0.10880806f, 0.15518133f, 0.07187638f, -0.04205841f, -0.03467669f, 0.09659439f, 0.04593723f, -0.03267431f, 
    0.05657039f, -0.00799723f, -0.03279066f, -0.11610346f, -0.03749789f, -0.06178461f, 0.01074025f, 0.02566312f, 
    0.72315836f, 0.10344514f, -0.02383981f, -0.23649766f, 0.06770202f, 0.21835850f, 0.01184100f, 0.02565945f, 
    0.08034921f, -0.19016731f, 0.04906058f, 0.00547869f, -0.01790359f, 0.04937057f, 0.00552409f, 0.04670872f, 
    -0.03149953f, -0.23892406f, -0.11099545f, -0.11551885f, 0.37365726f, 0.13636427f, 0.09391002f, -0.14904581f, 
    -0.13584088f, 0.02721946f, -0.18283862f, -0.09106868f, 0.00463718f, -0.14329261f, -0.06083326f, 0.01209983f, 
    -0.00533420f, 0.01085446f, 0.00373556f, -0.08941887f, -0.06721207f, -0.13465860f, -0.05683252f, -0.00774663f, 
    -0.13116546f, 0.05604814f, 0.03838358f, 0.01306921f, -0.05361193f, -0.02522523f, -0.04828779f, 0.00059005f, 
    -0.00269901f, -0.02749614f, -0.03730922f, -0.02032369f, -0.00410318f, 0.03315965f, 0.04451247f, 0.01849137f, 
    0.08174796f, 0.07239366f, 0.05973135f, 0.05414597f, 0.00764345f, -0.32114223f, -0.28625223f, 0.02425455f, 
    0.26927763f, 0.13022380f, 0.06636398f, 0.05510537f, -0.00196662f, -0.02698267f, 0.13117917f, 0.03539835f, 
    -0.02275063f, -0.05288863f, 0.10883719f, -0.04517760f, 0.07795048f, -0.10899865f, -0.13346337f, 0.10426083f, 
    0.04496741f, -0.01164198f, -0.06978013f, -0.01531909f, -0.06812702f, -0.06033104f, 0.01604890f, 0.01457676f, 
    -0.02749927f, 0.00014977f, -0.00550902f, 0.03705329f, -0.00990502f, 0.02861781f, 0.00641086f, 0.02785591f, 
    0.11299960f, 0.05251742f, 0.10345472f, 0.05797806f, -0.12794952f, -0.21904704f, -0.81166703f, -0.10095719f, 
    0.12291387f, -0.14023158f, 0.05617601f, 0.26694521f, 0.17167763f, 0.01031562f, 0.10107514f, -0.13469478f, 
    -0.06101783f, 0.04792169f, 0.05060292f, 0.00447993f, 0.01274342f, 0.01023303f, -0.07410768f, -0.02078656f, 
    0.40497246f, 0.08833481f, -0.08536946f, -0.09062202f, -0.16211887f, 0.11523654f, -0.03865589f, 0.10142128f, 
    -0.01767376f, -0.04072656f, -0.00480111f, 0.01658585f, 0.03552350f, 0.06203362f, 0.06194220f, -0.05660832f, 
    0.06358560f, -0.06884041f, 0.23658229f, -0.04967665f, 0.57268071f, 0.38023350f, -0.16333777f, -0.10088341f, 
    -0.01697268f, -0.00477106f, 0.03935343f, 0.06170063f, -0.00317756f, -0.13633342f, 0.13478208f, -0.04378391f, 
    0.08731671f, 0.08009469f, 0.05988618f, -0.12756507f, 0.08230133f, 0.02598504f, 0.19151331f, 0.09825993f, 
    -0.08225803f, -0.09821691f, -0.07732053f, -0.07839360f, -0.03036350f, -0.08152434f, -0.01245545f, -0.00530302f, 
    0.03108874f, -0.03357846f, 0.09247793f, 0.09531668f, 0.05096054f, 0.06376980f, 0.06608979f, 0.00947278f, 
    0.00845011f, 0.00020665f, 0.05192647f, 0.02617140f, 0.43501067f, -0.21861485f, -0.07429194f, -0.08101691f, 
    -0.02870669f, 0.10626698f, 0.03787312f, -0.14691190f, 0.02751736f, 0.05432799f, 0.03618387f, 0.01328681f, 
    0.02292831f, 0.03194934f, -0.00099268f, 0.05317860f, -0.03875457f, -0.07373237f, -0.17381266f, -0.22717822f, 
    -0.09440227f, -0.42541936f, -0.46950117f, -0.25491941f, -0.08306807f, -0.08726203f, 0.01790961f, 0.10317423f, 
    0.09538740f, 0.12149227f, 0.09074965f, 0.01959256f, -0.07265028f, -0.05515581f, -0.10593582f, -0.00870641f, 
    -0.02906941f, 0.02983156f, -0.02310613f, -0.02031333f, -0.12373543f, -0.11936124f, -0.05773530f, -0.09223152f, 
    -0.10850415f, -0.07641962f, -0.01468874f, -0.00720580f, 0.01796130f, 0.00953697f, 0.09262228f, 0.08069635f, 
    0.10700305f, 0.08427496f, 0.04286132f, 0.00515163f, 0.06518303f, 0.01299195f, 0.08779160f, 0.06511679f, 
    -0.29177380f, -0.64880449f, -0.66283226f, -0.31639248f, -0.20184995f, -0.08800518f, -0.16967855f, -0.02157593f, 
    0.00817459f, -0.00078557f, -0.04857977f, 0.00035463f, -0.02036167f, -0.00097533f, -0.02392055f, 0.04847660f, 
    0.05429845f, 0.10469784f, 0.05349719f, 0.13363956f, -0.02063934f, -0.12766632f, -0.03092655f, 0.04781938f, 
    -0.01103998f, -0.01935028f, 0.00801485f, 0.00705814f, 0.07977164f, 0.03190860f, -0.06086323f, 0.02353200f, 
    -0.04720772f, 0.03809473f, 0.04495226f, 0.01113007f, 0.09962233f, 0.08666158f, 0.13111801f, -0.00543504f, 
    -0.15055339f, 0.06448367f, 0.03733046f, -0.07473379f, -0.16584258f, -0.06834208f, -0.03655019f, -0.04302626f, 
    -0.01364364f, -0.07679502f, -0.12376086f, -0.03547601f, 0.01339772f, -0.02343511f, 0.04392584f, 0.04888748f, 
    0.02846214f, -0.06178357f, 0.00533283f, 0.02698730f, 0.16385898f, -0.13949981f, 0.13865823f, 0.08846010f, 
    0.08050553f, -0.02850103f, -0.05092863f, -0.09024686f, -0.02616597f, 0.01060222f, 0.04362910f, -0.05264442f, 
    0.02544611f, 0.06535084f, -0.04219239f, -0.00382008f, -0.09326819f, -0.00583634f, -0.23751226f, -0.02599732f, 
    -0.13485914f, 0.08593620f, 0.10767750f, 0.02158684f, -0.22616434f, -0.03839751f, 0.03018409f, -0.00574246f, 
    0.04842054f, -0.03286452f, -0.05759332f, -0.02098693f, -0.03893642f, -0.00581044f, 0.03471043f, 0.02688295f, 
    0.19458884f, -0.01848214f, 0.04986871f, 0.01196449f, 0.52730465f, 0.01591739f, -0.34038532f, 0.05959908f, 
    -0.04025434f, 0.17156975f, -0.01692355f, 0.19729677f, 0.16598938f, 0.04955454f, 0.05342635f, 0.01516357f, 
    0.08170661f, 0.05650642f, -0.04407519f, -0.20667225f, -0.18067583f, -0.02783149f, -0.13001126f, -0.21523286f, 
    0.12078357f, 0.03186120f, -0.13596584f, -0.01479062f, -0.06104553f, -0.00231244f, 0.10456318f, 0.05202398f, 
    0.03579539f, -0.02537932f, 0.09411258f, 0.00222169f, -0.03215575f, 0.07206376f, 0.06952289f, 0.03808460f, 
    0.02378892f, 0.06938555f, 0.15992980f, -0.07744404f, -0.23423795f, -0.29411238f, -0.58576614f, -0.32176906f, 
    -0.08358554f, 0.03088094f, -0.10985025f, 0.19311251f, 0.03853434f, -0.04897528f, -0.00056418f, -0.01839860f, 
    -0.04700657f, 0.02899110f, 0.05425250f, 0.03978188f, 0.02132277f, 0.10330027f, 0.02443418f, -0.03544322f, 
    -0.33505353f, -0.27886251f, 0.16936077f, -0.05358478f, 0.18554077f, -0.08317545f, 0.07973200f, -0.01971426f, 
    -0.03656389f, -0.01068137f, -0.02870376f, 0.01397039f, -0.03194262f, 0.15180860f, 0.09618105f, 0.04033201f, 
    -0.01940172f, -0.10760635f, 0.05426979f, -0.07805098f, 0.05461180f, 0.02801309f, -0.19386739f, -0.11558826f, 
    -0.13326034f, -0.09210011f, 0.01873622f, 0.01076203f, 0.08069856f, 0.03329638f, 0.13562970f, 0.03837533f, 
    0.09443610f, -0.10404947f, 0.12462652f, -0.03861623f, 0.04329718f, 0.00496431f, 0.03326216f, 0.04657923f, 
    -0.09311324f, 0.04460887f, -0.05135663f, 0.28696707f, -0.30277583f, -0.03665438f, -0.07159550f, -0.05807697f, 
    0.10696947f, 0.09623704f, 0.01513391f, 0.00511227f, 0.04134420f, -0.00061599f, 0.06158591f, -0.05545393f, 
    0.05339814f, 0.10272446f, 0.01017511f, -0.03326675f, -0.01937968f, 0.20455040f, 0.34883443f, 0.31108639f, 
    -0.43802574f, 0.08476648f, -0.13110101f, -0.09270471f, 0.02927714f, 0.13130115f, 0.04938838f, -0.00561366f, 
    -0.00611302f, 0.07167806f, 0.04894407f, 0.04752148f, 0.02413214f, -0.02146304f, 0.09453426f, 0.07269523f, 
    0.05198205f, 0.00395277f, -0.29890701f, -0.09877204f, -0.01732474f, 0.01266386f, -0.00680168f, 0.16497597f, 
    -0.05443325f, -0.07653815f, 0.06101619f, -0.02625091f, -0.00600616f, 0.01989762f, -0.10816331f, 0.08923065f, 
    0.05805678f, -0.04800639f, -0.05438431f, 0.18349910f, 0.12537898f, 0.12259264f, 0.02795447f, 0.03939759f, 
    -0.01660110f, -0.12192193f, -0.05122980f, -0.28982255f, -0.02536268f, -0.16563010f, 0.02403140f, 0.01506960f, 
    0.04970451f, 0.07986894f, 0.02833016f, 0.04428654f, 0.00462883f, 0.03637342f, -0.02134723f, -0.01573990f, 
    0.01405161f, -0.00568983f, -0.21924855f, 0.15632494f, 0.15961719f, 0.06307363f, -0.04270748f, 0.04106810f, 
    0.01635097f, -0.10112143f, -0.02271215f, 0.00441977f, 0.02573531f, -0.01695125f, -0.03249390f, 0.06884890f, 
    0.08156250f, -0.02119469f, 0.04955843f, 0.15972096f, 0.23300861f, -0.16187796f, -0.38594362f, 0.12464889f, 
    -0.31625098f, -0.00759195f, -0.06527540f, 0.02121994f, -0.02032105f, 0.18975382f, 0.01680941f, -0.01591576f, 
    -0.00575245f, 0.01065901f, -0.02861651f, 0.01876459f, 0.00172122f, -0.00614609f, 0.07296306f, 0.01378642f, 
    0.09582041f, -0.02848493f, 0.32911444f, -0.02503371f, -0.08324135f, 0.03412275f, -0.03744248f, -0.24284260f, 
    -0.02466604f, -0.01483092f, 0.03545143f, 0.08160227f, 0.11810700f, 0.00781586f, 0.05817420f, 0.00015745f, 
    -0.07630416f, -0.07947999f, -0.00551016f, -0.06097277f, -0.04912380f, -0.29642010f, 0.17240849f, -0.06995743f, 
    -0.16224405f, -0.12005587f, -0.34630302f, 0.04227213f, 0.08043952f, 0.24076623f, -0.00565905f, 0.02942987f, 
    0.00215771f, 0.00119432f, -0.03621922f, 0.03592458f, 0.06295331f, 0.07918784f, 0.03374320f, 0.12502995f, 
    -0.04364466f, -0.04263214f, 0.05068677f, -0.04257986f, 0.19845666f, -0.05227976f, 0.07205956f, -0.12977594f, 
    -0.04418324f, -0.14065653f, 0.10253959f, -0.01878875f, -0.03022715f, 0.10093606f, -0.05307378f, 0.05226227f, 
    -0.03051871f, -0.01489716f, -0.11225256f, -0.02833918f, 0.04815385f, -0.04292620f, -0.00522096f, 0.16248153f, 
    -0.21933353f, -0.04336379f, -0.29207751f, 0.00287686f, 0.06506580f, 0.14967591f, 0.02458820f, 0.03881618f, 
    0.07081705f, -0.01444070f, 0.01903402f, -0.04308939f, 0.03884866f, 0.09053013f, 0.11081524f, 0.16565531f, 
    0.08670023f, 0.09849946f, -0.05195813f, 0.38520515f, -0.38501778f, -0.03152457f, 0.01921001f, -0.10027210f, 
    -0.01813340f, -0.21222848f, 0.05757669f, 0.03045592f, 0.01721515f, 0.11575191f, 0.06660424f, 0.06055399f, 
    0.06124813f, -0.05906999f, -0.01656859f, 0.07473974f, -0.19621927f, 0.01281080f, -0.24298871f, -0.07264329f, 
    -0.00119774f, 0.11929727f, 0.08004002f, 0.04355232f, 0.12391078f, 0.05325101f, -0.00610600f, -0.00810428f, 
    -0.01873822f, 0.04889159f, -0.03516376f, 0.01761503f, -0.03971578f, 0.07654996f, 0.09387168f, 0.00305844f, 
    0.16389443f, -0.52724409f, -0.18880129f, -0.07639820f, -0.00389786f, -0.11959904f, 0.02853713f, 0.09348651f, 
    0.00136426f, 0.04675061f, -0.00743752f, 0.00086287f, 0.08012414f, -0.00026427f, -0.04075148f, 0.00581542f, 
    0.00765247f, 0.05616971f, 0.02656774f, 0.11859146f, -0.15907592f, -0.07242084f, -0.31708291f, -0.01767736f, 
    0.15376556f, -0.02706249f, 0.09122838f, 0.11962641f, 0.06025244f, -0.12207741f, 0.01185221f, -0.00208932f, 
    -0.05760780f, -0.05803046f, -0.03226155f, 0.01643293f, 0.06688470f, -0.15974517f, 0.10338792f, 0.05350968f, 
    0.24323477f, 0.01224616f, 0.39053655f, 0.19938031f, -0.39585298f, 0.09789182f, -0.09357459f, -0.21119218f, 
    -0.02144062f, -0.17278081f, 0.06870211f, 0.04524823f, 0.06076606f, 0.11810701f, 0.03423055f, 0.02375930f, 
    0.00449320f, -0.00080876f, -0.00732829f, -0.00434876f, -0.21804711f, 0.30430910f, -0.24456047f, -0.24609113f, 
    0.02772211f, 0.17818636f, 0.03579038f, 0.15129966f, 0.00948975f, 0.04089366f, 0.04940804f, 0.01237127f, 
    -0.12093114f, 0.07244763f, -0.02137415f, -0.07002737f, -0.01288643f, -0.07416508f, -0.00179740f, 0.02293264f, 
    -0.10371281f, -0.05113649f, -0.01805042f, -0.01858922f, -0.19658014f, -0.00782110f, -0.22819045f, 0.08724112f, 
    -0.03175730f, 0.13304546f, -0.03495422f, 0.02878900f, 0.02306120f, -0.03582663f, 0.03956363f, -0.04818683f, 
    0.07662410f, 0.04912110f, 0.07145231f, 0.00821492f, -0.08359563f, -0.05833325f, 0.06871342f, -0.03554897f, 
    -0.19099511f, 0.02873020f, -0.02863825f, -0.31337732f, -0.04508530f, -0.03942680f, 0.05855853f, 0.06270150f, 
    -0.02669585f, 0.10044141f, 0.01128283f, -0.00560635f, -0.00730448f, 0.00971044f, 0.01199009f, 0.04025164f, 
    0.00035045f, -0.13476977f, -0.36615944f, 0.08846020f, 0.12715811f, 0.01685577f, 0.02122677f, 0.08777762f, 
    -0.16115732f, 0.16242053f, 0.00055714f, 0.00177925f, 0.00197273f, -0.00855956f, 0.00800630f, 0.00636584f, 
    0.12299876f, 0.15164846f, 0.09871663f, 0.16634136f, -0.16403836f, -0.12979485f, -0.18927990f, -0.13085476f, 
    0.16739798f, -0.05444819f, 0.11125159f, 0.08110920f, 0.05412442f, -0.00265166f, 0.10971514f, 0.07889447f, 
    0.01211619f, -0.03914322f, 0.00761152f, 0.09432670f, 0.01129074f, 0.02101906f, 0.04549661f, -0.01828397f, 
    0.01171805f, -0.63872886f, 0.23420697f, -0.67268890f, -0.28555995f, -0.16709670f, -0.18773369f, 0.03645602f, 
    0.14922801f, 0.02609470f, -0.09921669f, 0.06718811f, 0.01818990f, 0.05842730f, -0.00682691f, -0.00574378f, 
    0.15612803f, 0.06106830f, -0.03200178f, 0.11697783f, -0.31532410f, -0.19331670f, -0.23323110f, 0.00451639f, 
    -0.14272295f, -0.22650561f, 0.24123371f, -0.13122220f, -0.22436795f, 0.03557155f, 0.02677900f, -0.08399107f, 
    0.08889773f, -0.05763937f, -0.01922963f, 0.10637919f, -0.09134015f, -0.05582540f, -0.06822412f, -0.30022311f, 
    -0.14877309f, 0.12009765f, 0.07061840f, 0.47517365f, -0.20427296f, -0.07450897f, 0.06001282f, -0.25318041f, 
    -0.06307732f, -0.20030756f, 0.10098455f, -0.04442511f, 0.04134629f, 0.14794321f, 0.07615821f, 0.09518399f, 
    0.01203123f, -0.02634378f, 0.05593953f, 0.01435706f, 0.18372495f, 0.18747102f, 0.01279073f, 0.56513703f, 
    -0.30866644f, 0.11637902f, -0.11678892f, -0.16318552f, 0.11893666f, -0.05626752f, -0.00240035f, -0.06939199f, 
    0.03584170f, 0.02135361f, 0.12665498f, 0.07497271f, 0.04944779f, 0.09692715f, 0.12359032f, 0.18310626f, 
    0.06621489f, 0.33008313f, 0.31423327f, -0.19701128f, -0.19850907f, 0.03290173f, -0.09547772f, 0.02825385f, 
    0.01642181f, 0.12831169f, -0.01551561f, 0.02705180f, 0.03032015f, -0.03088446f, -0.04228969f, -0.01542185f, 
    0.01605756f, -0.07088502f, -0.07469377f, -0.13425572f, -0.43544322f, 0.02613474f, -0.22181033f, 0.19921866f, 
    -0.31846738f, 0.17679696f, -0.41141653f, -0.01507747f, -0.19275564f, -0.24848670f, -0.05253587f, 0.01458132f, 
    0.01824439f, -0.00511983f, 0.08355553f, -0.10321688f, 0.00201338f, 0.02535996f, 0.01290245f, 0.05505386f, 
    0.00646580f, 0.00927058f, 0.35841489f, -0.10974971f, -0.34112677f, -0.09373733f, -0.13598531f, 0.06821433f, 
    0.05288283f, 0.06762520f, -0.07161331f, 0.02113107f, 0.04121317f, -0.00838118f, 0.02744459f, 0.03409666f, 
    0.00800589f, -0.02406915f, -0.08481935f, -0.11100743f, -0.39015588f, -0.20690492f, -0.59991187f, -0.05055100f, 
    -0.06644907f, -0.11826029f, 0.09394164f, 0.11701473f, -0.21690051f, 0.12456915f, 0.02779777f, -0.07193760f, 
    -0.01804217f, -0.00264309f, -0.09634344f, 0.09947562f, -0.04057255f, 0.03378933f, 0.15553901f, 0.03494334f, 
    -0.12364750f, 0.08188000f, 0.05858657f, 0.03586164f, 0.17990164f, -0.03910012f, -0.02905327f, -0.08375228f, 
    -0.06964854f, -0.01945506f, 0.06437699f, 0.12295462f, 0.00376952f, -0.03746702f, -0.02233444f, 0.01129964f, 
    -0.13855243f, -0.03684400f, -0.02883601f, 0.01729957f, 0.06236755f, 0.09320980f, 0.04792729f, -0.12671518f, 
    -0.06021104f, 0.04466988f, 0.02767782f, -0.01813066f, 0.03340849f, -0.02895981f, 0.01612075f, 0.11355761f, 
    -0.06095991f, 0.12244799f, -0.04244778f, -0.06374567f, 0.00135815f, -0.03902280f, -0.06038262f, 0.06690701f, 
    0.07929948f, 0.17546080f, 0.05146707f, -0.02663480f, -0.02553627f, 0.14900953f, -0.00456479f, 0.04163450f, 
    -0.04807691f, -0.03136142f, 0.01879226f, -0.14888476f, -0.03018855f, -0.07118877f, -0.07701945f, 0.04556866f, 
    -0.09077831f, -0.06130302f, -0.02891072f, -0.12108904f, -0.21591689f, -0.08294892f, 0.28752160f, 0.18830572f, 
    -0.41852009f, 0.25044131f, -0.18991002f, -0.06236491f, 0.00863966f, 0.02199920f, 0.01946312f, -0.06714547f, 
    0.03101423f, 0.03748520f, -0.02065699f, -0.01733410f, -0.01511994f, -0.00236417f, 0.00303868f, 0.00061662f, 
    0.00346846f, 0.09562277f, 0.05142743f, 0.20819379f, 0.19854340f, -0.03744646f, -0.02315917f, -0.05690864f, 
    0.00457526f, -0.03869576f, 0.02361469f, -0.01444241f, 0.04491521f, 0.00679037f, -0.01253752f, 0.09182473f, 
    0.14950921f, 0.01422151f, 0.09314092f, 0.14731790f, 0.09170631f, -0.44023257f, -0.04149748f, -0.08321323f, 
    0.16091239f, -0.19573511f, 0.00806530f, -0.10112102f, 0.05103534f, 0.05197041f, -0.12678896f, 0.01124502f, 
    0.14889956f, -0.04289167f, -0.02369882f, 0.21491022f, 0.00737429f, 0.02959564f, -0.06966788f, -0.06674282f, 
    0.12296236f, -0.30625093f, -0.04685621f, -0.01394495f, -0.05707076f, -0.23790266f, -0.01398017f, -0.01605428f, 
    0.08792927f, 0.08920000f, 0.04633373f, 0.02588669f, 0.04293162f, 0.08715610f, 0.07234580f, -0.14601219f, 
    0.10879760f, 0.01560785f, 0.13356496f, 0.02131306f, -0.03942667f, 0.33664849f, -0.51777577f, 0.04950627f, 
    -0.16988440f, 0.06283426f, 0.01646055f, 0.14836323f, -0.04599957f, 0.00868401f, 0.06753834f, -0.06499644f, 
    -0.03559388f, -0.13302013f, -0.13988787f, 0.08414257f, -0.06551984f, 0.00471833f, -0.02505353f, -0.18726133f, 
    0.04429192f, 0.09724965f, 0.18798915f, -0.61241990f, 0.10694686f, -0.06578420f, -0.10028211f, 0.15393192f, 
    0.14301817f, 0.15507224f, -0.06162593f, -0.00424082f, 0.03735366f, -0.14097251f, -0.05767876f, 0.04398007f, 
    0.10708724f, -0.03099024f, -0.09845709f, -0.12318093f, -0.26571330f, -0.06265069f, -0.33609584f, -0.12965655f, 
    0.01146613f, 0.14314869f, 0.07317946f, 0.14672145f, 0.07472649f, 0.07926044f, 0.07636628f, 0.03020484f, 
    -0.00006774f, 0.01518251f, -0.07901183f, 0.03424307f, 0.01465793f, 0.07897151f, -0.00244809f, 0.05431037f, 
    -0.16288461f, -0.09290407f, 0.05697213f, -0.11581639f, 0.14429268f, 0.01911832f, 0.17339513f, -0.14997691f, 
    0.02407857f, -0.05625999f, -0.01491032f, 0.04719651f, -0.07779864f, 0.02714673f, 0.02458288f, 0.09078775f, 
    -0.10994500f, -0.05423981f, -0.09559504f, -0.06905973f, 0.05761896f, 0.04781239f, 0.17066841f, -0.01631130f, 
    0.04420383f, 0.04360062f, -0.05914386f, -0.12181573f, -0.00002208f, -0.13205552f, 0.02962869f, 0.11775751f, 
    -0.00553253f, 0.02823178f, 0.07524729f, 0.05778981f, 0.01950107f, -0.02589684f, -0.00458594f, 0.08651234f, 
    -0.02171672f, -0.33553514f, -0.12227008f, 0.01919238f, -0.07931513f, 0.00664038f, 0.16188353f, 0.24075326f, 
    -0.09622133f, 0.15582907f, -0.01827504f, -0.06507566f, -0.03880709f, 0.00112610f, -0.01856771f, 0.01587637f, 
    0.09139065f, -0.07694529f, -0.00246784f, -0.04612827f, -0.32171255f, -0.08272711f, 0.03961114f, -0.07739713f, 
    -0.05840331f, 0.27223274f, -0.19039290f, 0.08847196f, -0.11705827f, -0.16662228f, 0.03171522f, -0.07073278f, 
    -0.04719960f, -0.09479565f, 0.04195160f, 0.01235843f, -0.13080342f, -0.03921133f, 0.03649321f, -0.01023810f, 
    -0.87325257f, -0.31897300f, -0.79389954f, 0.07401045f, -0.23424725f, 0.00694034f, -0.02590685f, 0.14411813f, 
    -0.30227801f, 0.04867774f, 0.03773617f, 0.00147273f, 0.08191100f, 0.05619923f, -0.04768659f, 0.02144797f, 
    0.08467565f, -0.00624505f, 0.14628908f, 0.13320059f, -0.37792072f, -0.25690177f, -0.12311643f, 0.02100375f, 
    -0.01190139f, -0.03025121f, 0.07890017f, 0.15305918f, -0.07886615f, 0.18106352f, -0.03433742f, -0.11038521f, 
    -0.00243167f, -0.00042313f, -0.07469770f, 0.03847076f, 0.09490680f, 0.00615342f, 0.07599072f, 0.01333976f, 
    -0.06832770f, -0.09875645f, -0.18053687f, -0.08662026f, 0.13035254f, -0.07180809f, 0.17146827f, 0.09612589f, 
    0.01984684f, 0.02572134f, 0.02624754f, 0.05762252f, -0.06395202f, -0.10084742f, -0.01453088f, 0.07964187f, 
    0.03300563f, -0.04989282f, -0.01438773f, -0.04531829f, 0.12662138f, -0.05273780f, 0.07456251f, -0.32399482f, 
    -0.32670677f, -0.00431323f, 0.12018620f, -0.12396787f, -0.28063670f, -0.05481952f, 0.16140684f, 0.04143373f, 
    -0.07835924f, -0.06330580f, -0.10103666f, 0.06222260f, -0.02216624f, -0.07380627f, -0.08503134f, -0.04772894f, 
    0.03465047f, 0.08277966f, 0.07930534f, 0.08683283f, -0.00456027f, 0.03070964f, 0.02862735f, -0.03718997f, 
    -0.09539238f, -0.06297337f, -0.00728370f, 0.05445713f, 0.04493826f, -0.00436308f, -0.04052627f, 0.01617357f, 
    -0.01391517f, -0.08856934f, 0.00136878f, -0.01383791f, -0.28605065f, 0.02448378f, -0.25038508f, 0.30272502f, 
    -0.37542596f, -0.32064039f, 0.16047372f, -0.40325126f, 0.03481541f, -0.12104513f, 0.06575490f, -0.08224919f, 
    0.05642533f, 0.09765825f, 0.05031997f, 0.02328695f, 0.07745777f, -0.00650473f, 0.02482170f, 0.02755540f, 
    -0.27105936f, 0.04761149f, -0.46922711f, 0.15588276f, -0.06448013f, -0.00084805f, -0.08030178f, 0.03995828f, 
    -0.16137514f, -0.13349760f, 0.03004624f, -0.10707683f, -0.02847843f, -0.05265737f, -0.16605531f, -0.00275775f, 
    -0.06290855f, -0.08061201f, 0.02199171f, 0.02196029f, -0.27986738f, -0.32055613f, -0.20111822f, 0.20085081f, 
    0.01920814f, -0.03210870f, 0.16985252f, 0.01912252f, -0.17143179f, -0.14172621f, -0.00586888f, -0.04039484f, 
    -0.06377375f, -0.06869518f, -0.08208735f, 0.08260370f, 0.00821121f, -0.22077315f, -0.05517020f, -0.01305472f, 
    0.00698683f, 0.12483157f, 0.16387644f, 0.21641366f, 0.06793206f, 0.02490817f, 0.02633044f, -0.04530941f, 
    -0.12363262f, -0.10980660f, 0.10954251f, -0.01223150f, 0.03222848f, -0.06060103f, -0.05479234f, 0.04196183f, 
    0.00093554f, -0.06041916f, 0.00001498f, -0.01484104f, -0.06019529f, -0.43403617f, -0.13949029f, -0.15463217f, 
    -0.03537165f, 0.18511356f, -0.03204450f, 0.01725147f, 0.12869439f, -0.01325123f, 0.02316050f, 0.04911753f, 
    0.05943067f, -0.04713029f, 0.00051094f, 0.00691724f, 0.06057291f, -0.01914228f, 0.16358735f, 0.20351116f, 
    -0.04223383f, 0.26442236f, 0.18103303f, 0.48876974f, -0.32626942f, 0.03913775f, -0.07772826f, -0.25231150f, 
    -0.15650529f, -0.16055757f, 0.14329542f, -0.08271232f, 0.09254050f, 0.09079901f, 0.03779608f, 0.10227179f, 
    -0.01955809f, -0.01712897f, -0.00634044f, -0.02265312f, 0.03885814f, -0.01686250f, 0.18388097f, 0.14478107f, 
    0.05906253f, 0.06369902f, -0.05876078f, -0.03784374f, -0.05525009f, -0.16779980f, 0.04442883f, 0.10601961f, 
    0.00953162f, 0.09409358f, 0.03780982f, 0.02207087f, -0.04883221f, -0.05955693f, 0.01840401f, -0.00263275f, 
    -0.04600763f, 0.01941619f, 0.21063836f, 0.02404508f, -0.32058060f, -0.16236217f, -0.17010495f, 0.24018158f, 
    0.19583863f, 0.31880137f, -0.04580166f, 0.04423318f, 0.01027308f, -0.02810308f, -0.03936858f, 0.04492933f, 
    -0.03217622f, 0.04135840f, -0.04402363f, -0.23370682f, -0.14407276f, 0.27345154f, 0.03396424f, -0.03079005f, 
    -0.08584046f, -0.00649487f, -0.08283013f, -0.08926233f, -0.08764640f, 0.04215721f, -0.01413945f, 0.08478177f, 
    0.01431782f, 0.02020031f, 0.05972878f, -0.08611761f, -0.10430773f, 0.01414520f, -0.02330465f, 0.01683388f, 
    -0.12439274f, -0.14792386f, -0.10250790f, 0.03726991f, 0.22843480f, -0.07229542f, 0.11835369f, 0.06679241f, 
    -0.00790232f, -0.03763730f, 0.02273916f, 0.08151250f, -0.01012941f, -0.12851363f, -0.06040558f, 0.04021671f, 
    0.00890912f, 0.08080191f, -0.01107835f, 0.01978244f, -0.05129623f, -0.30796736f, 0.04745418f, -0.10045735f, 
    0.03362839f, -0.03983206f, 0.03817486f, -0.06508599f, 0.00335801f, -0.04433576f, 0.02028801f, -0.09065951f, 
    0.11641067f, 0.13880624f, -0.09881973f, 0.06411961f, 0.12267201f, 0.00172375f, -0.11461032f, 0.06736803f, 
    -0.09948384f, 0.02588376f, -0.07430010f, -0.22748888f, 0.12742780f, 0.04018432f, 0.02084762f, 0.02095006f, 
    0.04238940f, 0.06374943f, 0.10132538f, -0.04818166f, -0.14659402f, 0.04084320f, -0.04102489f, 0.18592243f, 
    0.01415275f, 0.00236549f, -0.01156355f, 0.04197771f, -0.07234994f, -0.24331334f, -0.61935884f, 0.22493340f, 
    -0.24404024f, -0.04529171f, -0.19375268f, 0.09010390f, -0.08466329f, -0.13500875f, -0.03311239f, 0.03466459f, 
    0.00867365f, -0.05968105f, 0.06021739f, 0.00516671f, 0.09267612f, -0.03323605f, 0.06434512f, 0.30096984f, 
    -0.28221023f, 0.19820583f, -0.09675005f, 0.00957436f, -0.02422135f, 0.17673586f, -0.29657319f, -0.02004780f, 
    0.01349913f, -0.35105476f, -0.01644728f, -0.02390117f, -0.01409722f, 0.00818686f, 0.03651746f, -0.13432492f, 
    -0.14186111f, -0.04996010f, -0.01043592f, 0.05763238f, -0.06233765f, -0.25612256f, -0.33047190f, -0.07083584f, 
    -0.37774286f, -0.35461727f, 0.19976321f, -0.08202107f, 0.03120067f, 0.16052011f, 0.06136394f, -0.02894193f, 
    0.03246769f, 0.02009414f, 0.04243705f, -0.01394657f, 0.00506176f, 0.07332793f, -0.03005461f, -0.07225388f, 
    -0.00340333f, -0.06678279f, 0.02410012f, -0.17903414f, -0.14660138f, 0.02729271f, -0.18522374f, 0.03140070f, 
    -0.02686668f, -0.10068407f, -0.05036500f, 0.17836268f, -0.10378939f, 0.03492248f, -0.03590481f, 0.06377175f, 
    0.06337606f, 0.10630082f, -0.00509326f, 0.12863888f, -0.46832648f, -0.05622150f, -0.01377775f, 0.46913078f, 
    -0.13957861f, -0.05748143f, 0.14100559f, -0.24846129f, 0.03618775f, -0.20511492f, 0.06621899f, -0.13229245f, 
    0.00579385f, -0.14033371f, 0.09833934f, 0.10481775f, 0.00706836f, -0.04353274f, -0.09986306f, 0.07498590f, 
    -0.13752331f, 0.01806202f, -0.01223284f, 0.03651939f, 0.10535052f, -0.06329083f, -0.07741864f, -0.11372151f, 
    0.02716064f, 0.05558775f, -0.04724456f, 0.04986448f, -0.01651948f, -0.08867055f, -0.04017103f, 0.09461010f, 
    0.04648350f, -0.02415646f, 0.03037826f, -0.07925803f, -0.17746058f, -0.05411295f, -0.16093160f, 0.11346618f, 
    0.04964023f, -0.04871507f, -0.07909680f, -0.02878287f, 0.00221074f, 0.07581764f, -0.02879903f, -0.02422317f, 
    -0.08921574f, -0.01813766f, -0.05889184f, 0.01747623f, -0.08068989f, 0.03901714f, -0.05872548f, 0.00286367f, 
    -0.19434185f, 0.08249676f, 0.17322035f, 0.31863636f, 0.16911641f, -0.00406008f, -0.03268815f, -0.14224263f, 
    -0.12924117f, -0.01383494f, -0.09084403f, 0.07061253f, 0.00881470f, -0.04030973f, -0.01043522f, 0.05797815f, 
    -0.17816885f, 0.00854698f, 0.08067058f, 0.09245823f, 0.05226747f, 0.11205720f, 0.01004501f, 0.01238344f, 
    -0.07248709f, 0.12717552f, -0.01771944f, -0.06036473f, 0.01738808f, 0.06870015f, -0.12751903f, 0.07890720f, 
    -0.02053387f, -0.12639010f, -0.17563732f, -0.00641377f, 0.05784412f, -0.00469688f, 0.04192574f, -0.04407799f, 
    -0.21608999f, -0.03889942f, 0.09953751f, 0.04099532f, -0.00569186f, -0.02173789f, 0.01098690f, 0.02511940f, 
    0.11107855f, -0.07371442f, 0.02201848f, 0.04686781f, -0.07471345f, 0.05746707f, -0.02303719f, -0.02385432f, 
    -0.06822451f, -0.02336549f, -0.16805185f, -0.15590911f, -0.26733559f, 0.01837350f, -0.38049138f, -0.18973118f, 
    0.05219815f, 0.07827754f, -0.08730403f, 0.12526280f, -0.08847334f, 0.11200795f, -0.04215828f, 0.07108137f, 
    -0.03743027f, 0.09671964f, -0.03122882f, 0.13300078f, -0.08047342f, -0.10666499f, -0.10764597f, -0.02103753f, 
    0.03797562f, 0.07316246f, -0.06284926f, 0.11483352f, 0.13502097f, -0.02416544f, 0.07314437f, 0.00253385f, 
    0.02100400f, 0.02205159f, -0.10034005f, -0.01811168f, -0.03168363f, -0.00361092f, 0.00382384f, 0.05732647f, 
    0.05120663f, -0.02471302f, 0.09485686f, 0.12896197f, -0.26855835f, 0.02657920f, -0.07778753f, 0.01138985f, 
    -0.02559598f, 0.06631853f, -0.05351622f, -0.15036340f, -0.08278050f, -0.10273249f, -0.05105711f, 0.08793093f, 
    -0.01412213f, 0.00366049f, -0.01611612f, 0.03081348f, 0.00997149f, -0.18162222f, -0.07810581f, -0.14845870f, 
    -0.12644477f, 0.06563924f, 0.04883828f, 0.06989302f, -0.05939897f, 0.05104756f, -0.08211245f, -0.06500056f, 
    0.04449827f, 0.09446655f, -0.06554358f, 0.03834993f, 0.00296507f, 0.01171723f, 0.04179244f, -0.05885122f, 
    0.17234598f, 0.00944103f, 0.03024969f, -0.12326339f, -0.22804558f, 0.05304190f, -0.12664981f, 0.06996917f, 
    -0.01774731f, -0.07482670f, -0.04061046f, -0.15589757f, -0.01574604f, -0.08271684f, -0.05544212f, 0.10914158f, 
    0.05042911f, -0.04686964f, 0.01249238f, -0.03700255f, 0.00973913f, -0.04520746f, 0.01614827f, -0.08470441f, 
    -0.34765372f, 0.14571385f, 0.02233700f, 0.09162837f, 0.00430451f, 0.04473410f, -0.15180781f, -0.09579840f, 
    0.28236869f, 0.01767092f, -0.08391546f, 0.03806129f, 0.00725840f, 0.08894136f, -0.07384000f, 0.02085906f, 
    -0.06921750f, -0.03749543f, 0.07442415f, 0.01316891f, 0.04172619f, -0.14656404f, 0.23445205f, 0.06774737f, 
    0.00587273f, -0.10911836f, 0.06792524f, -0.02500054f, -0.00412171f, -0.11989321f, -0.03276117f, -0.00715819f, 
    -0.10181978f, 0.06970236f, -0.02523609f, -0.02493091f, -0.06544029f, -0.00017007f, -0.04731660f, -0.09170089f, 
    -0.08559891f, 0.07288002f, -0.18556724f, 0.21488737f, 0.12400080f, 0.05118401f, -0.00489926f, -0.01638587f, 
    -0.10317153f, -0.03398499f, -0.11696376f, -0.09859771f, -0.01016513f, -0.04247357f, -0.02641935f, -0.11778758f, 
    -0.00059906f, -0.27263606f, -0.04747791f, 0.02199684f, -0.09542220f, -0.15720317f, 0.09522314f, -0.03750859f, 
    0.00528907f, -0.00079905f, -0.02341816f, 0.05069094f, 0.08302302f, -0.00056240f, -0.13601986f, 0.00253074f, 
    -0.05046588f, 0.04957904f, 0.05511999f, 0.10032897f, -0.06953505f, 0.08046578f, 0.02577525f, 0.00043561f, 
    -0.21611477f, 0.18968317f, -0.12286586f, 0.16190904f, 0.07838964f, -0.01375616f, -0.05154067f, -0.15464272f, 
    -0.04821190f, 0.01471067f, -0.01534863f, -0.02143088f, 0.02967141f, -0.02450980f, -0.05205857f, 0.02727709f, 
    -0.06178860f, -0.04467900f, 0.07046209f, 0.06450067f, -0.00846262f, -0.24655402f, 0.18858348f, 0.19137751f, 
    -0.14165971f, -0.08020406f, 0.04372973f, 0.04479485f, -0.06309062f, -0.22814626f, -0.09705236f, 0.00227461f, 
    -0.00655982f, 0.04531398f, -0.09603612f, 0.03473136f, -0.02284629f, 0.07370881f, 0.02360447f, 0.06371693f, 
    -0.33209041f, 0.00284352f, 0.03040268f, 0.04696953f, 0.09316452f, -0.05523571f, -0.01670038f, -0.18763971f, 
    0.14931929f, -0.05827068f, -0.00929129f, 0.04924063f, -0.00134528f, 0.07917327f, 0.05574841f, 0.07193749f, 
    0.06083671f, -0.11070319f, 0.01209687f, -0.13114779f, -0.04973544f, 0.10024345f, 0.10959732f, -0.04547244f, 
    0.00439533f, -0.04808550f, 0.01830491f, -0.19701794f, -0.00359068f, -0.00380963f, -0.09659417f, 0.04515859f, 
    -0.00116500f, -0.06175881f, -0.07678787f, -0.01367393f, 0.08024049f, 0.01797536f, 0.09644452f, 0.07544407f, 
    -0.07625487f, -0.17153256f, -0.34770310f, -0.07740161f, 0.07418593f, -0.07595613f, 0.00727451f, 0.17151640f, 
    -0.18438214f, -0.14642656f, 0.04102554f, 0.06525706f, -0.03778939f, 0.04498928f, -0.03700543f, 0.08606870f, 
    -0.15774760f, 0.01570128f, -0.36322391f, -0.21294068f, 0.08414501f, -0.32531011f, -0.03124786f, -0.34820208f, 
    -0.38570067f, -0.03557803f, -0.17210099f, -0.11897806f, 0.05165429f, -0.04830683f, -0.16269261f, 0.11252100f, 
    0.04166754f, -0.05458659f, -0.02401791f, 0.02843534f, 0.02716468f, -0.01766336f, -0.02278062f, -0.00157149f, 
    -0.26891494f, 0.24182793f, -0.07992826f, 0.14122313f, 0.14209257f, 0.07274632f, -0.07907348f, 0.01467217f, 
    0.08176205f, 0.07617982f, 0.01612684f, -0.00329445f, -0.02599945f, 0.01304769f, -0.07529312f, -0.04383042f, 
    -0.03655985f, -0.06841140f, 0.03404592f, -0.10344091f, 0.17850840f, -0.09037996f, -0.09958777f, 0.11078200f, 
    0.16466334f, 0.04739098f, 0.05083642f, 0.20906511f, -0.04062061f, 0.17605801f, -0.02276786f, 0.10516390f, 
    0.00406170f, 0.07220391f, 0.08019480f, 0.03043813f, 0.03791379f, 0.11434929f, 0.06229052f, 0.13966127f, 
    0.15219614f, 0.20163326f, 0.03027547f, -0.19958709f, -0.07479467f, 0.11413699f, -0.10520346f, -0.00094284f, 
    -0.05459959f, -0.05193941f, -0.13683011f, 0.12290642f, -0.09404664f, -0.07091931f, -0.07861380f, -0.08190142f, 
    -0.05242104f, -0.00607082f, 0.01733079f, -0.01614143f, -0.17151991f, -0.06191578f, -0.05974505f, -0.02296518f, 
    -0.07640385f, 0.03011353f, 0.02349712f, -0.04535688f, 0.00637904f, -0.01785183f, -0.02039007f, 0.04804085f, 
    -0.05382369f, -0.12397064f, -0.24928051f, -0.05858385f, -0.15332529f, -0.03775763f, -0.08475465f, -0.12689039f, 
    -0.19855243f, -0.18446441f, -0.04092780f, 0.07301113f, -0.13267638f, 0.00846259f, 0.10808852f, 0.02970452f, 
    0.08339469f, -0.03334961f, -0.07227836f, -0.27580866f, 0.06492205f, 0.02156317f, -0.00758396f, 0.02698984f, 
    0.04329402f, 0.00684096f, 0.13238969f, 0.23626496f, -0.22251830f, -0.15475395f, 0.16884011f, -0.13026173f, 
    0.06175993f, -0.05154275f, 0.00159477f, -0.22046530f, 0.11761840f, -0.05786920f, 0.00117015f, -0.04041941f, 
    -0.10543648f, 0.08493374f, 0.06582234f, 0.08767918f, 0.03752297f, 0.10938787f, -0.01769880f, -0.10643257f, 
    -0.23897959f, 0.18405111f, -0.19947419f, 0.13032195f, 0.09771640f, -0.02013876f, -0.05328581f, -0.07378085f, 
    0.11304955f, -0.00188508f, -0.09732805f, -0.09849031f, 0.00422229f, 0.03298037f, 0.07900482f, 0.09777632f, 
    0.02627387f, -0.19978681f, 0.10514130f, 0.06910931f, 0.08600426f, -0.04878768f, 0.26773417f, 0.08020796f, 
    0.16446871f, -0.15334189f, 0.03438183f, 0.02906045f, -0.04147941f, -0.10028858f, -0.01632303f, 0.05129618f, 
    0.20904289f, -0.07936832f, 0.05334483f, -0.00926466f, -0.13026147f, -0.09866521f, -0.10319135f, -0.13532273f, 
    0.09204745f, -0.23272456f, 0.16177659f, -0.21389723f, -0.06511340f, 0.02988243f, 0.01541341f, -0.03856455f, 
    -0.01951480f, 0.07312717f, 0.01561536f, 0.11302570f, -0.07220164f, -0.00259053f, -0.06980879f, -0.02200679f, 
    0.08325101f, 0.10014593f, 0.10418887f, -0.09856591f, -0.04011679f, -0.11105118f, 0.03353158f, -0.02752874f, 
    -0.21939737f, -0.01682206f, 0.02883015f, -0.09387606f, 0.10592637f, 0.02494385f, -0.18280998f, -0.08046819f, 
    0.06243035f, 0.03407612f, -0.03476328f, -0.01786332f, 0.10793629f, 0.11451696f, 0.19594461f, 0.09430289f, 
    -0.40975255f, -0.19847399f, 0.02878532f, -0.02795612f, -0.10130218f, -0.00631134f, 0.01521036f, 0.09457944f, 
    0.11103352f, 0.04713548f, -0.11346117f, 0.01416222f, 0.02331378f, 0.00432206f, -0.07213067f, 0.08055171f, 
    0.06089185f, 0.01417438f, 0.21020915f, 0.22850530f, -0.14183111f, 0.00867858f, 0.07316007f, 0.16310133f, 
    0.14371561f, -0.15293749f, -0.00064642f, -0.08506209f, -0.05760419f, -0.00052867f, 0.03655982f, 0.00977570f, 
    -0.06925626f, 0.01941120f, 0.01939811f, 0.02300121f, 0.02298499f, 0.03100389f, -0.00096761f, 0.09889429f, 
    0.10417554f, -0.03842140f, 0.11962353f, -0.01113549f, -0.07884303f, 0.05162744f, 0.00098886f, -0.02105727f, 
    -0.03173399f, -0.04945095f, 0.01569627f, 0.04244935f, -0.05804514f, 0.03039147f, -0.07445753f, -0.04431733f, 
    -0.05261498f, 0.01417180f, -0.18905336f, -0.27988297f, -0.04494091f, 0.13367009f, -0.33801019f, 0.26326540f, 
    0.19979283f, -0.06558998f, -0.08816184f, -0.15491052f, 0.01248476f, 0.24878041f, -0.18514055f, 0.10779011f, 
    -0.19282949f, -0.02842700f, 0.10244145f, -0.03808133f, -0.02529727f, -0.16087720f, 0.09841632f, 0.20992509f, 
    -0.21280228f, -0.00925243f, -0.29015094f, 0.08423094f, 0.09786050f, -0.06161096f, -0.00965612f, -0.02176881f, 
    -0.06723566f, 0.02014573f, 0.01580339f, 0.03504149f, -0.02403920f, 0.00332646f, 0.00381310f, 0.07026564f, 
    -0.04803389f, -0.15410003f, 0.00880710f, -0.09456374f, -0.32911962f, -0.25738120f, 0.09624050f, -0.14985916f, 
    0.07805344f, 0.01948091f, 0.00175928f, 0.07212697f, -0.12272344f, -0.04253894f, -0.05808157f, 0.00581781f, 
    0.03707100f, 0.04359812f, 0.04987396f, 0.03581949f, 0.08557259f, 0.05747944f, 0.07439236f, 0.05156579f, 
    -0.27122751f, -0.09389744f, 0.02881440f, 0.29817674f, -0.24594083f, 0.07097021f, -0.06076057f, -0.07689761f, 
    0.16864219f, 0.00335403f, -0.22223110f, -0.05158474f, 0.04243965f, -0.02974829f, 0.02201183f, 0.09781606f, 
    -0.05877172f, -0.02978901f, 0.04638941f, 0.06438605f, -0.18364765f, -0.62865400f, -0.11047103f, -0.26770040f, 
    -0.17585652f, -0.21481122f, -0.16609289f, 0.06306000f, 0.14163758f, -0.06784531f, -0.18145275f, 0.08722670f, 
    -0.07874694f, -0.07734297f, -0.01168090f, 0.00933167f, -0.07260172f, 0.03364869f, 0.05873037f, -0.04735251f, 
    0.07831860f, -0.10796757f, 0.27663344f, -0.01301461f, -0.09091556f, -0.02143661f, -0.01586763f, 0.00268177f, 
    0.02282972f, -0.00407131f, -0.03532794f, 0.03628827f, 0.00187648f, 0.09801690f, 0.04944524f, -0.06119132f, 
    0.14499868f, 0.13534358f, 0.01890713f, 0.03474129f, -0.12889597f, 0.08254071f, 0.01836532f, -0.01641779f, 
    -0.08850062f, 0.04078212f, -0.04236925f, -0.06305590f, 0.01491289f, 0.03341818f, -0.01851343f, 0.00953716f, 
    -0.00920102f, -0.06920508f, -0.05500529f, -0.08847670f, -0.06811737f, 0.00163869f, 0.05112212f, -0.04718532f, 
    0.01858143f, -0.15019970f, -0.03439291f, 0.24141046f, 0.08727361f, 0.00573712f, -0.01865154f, 0.04956615f, 
    -0.25090146f, 0.01365494f, -0.04686322f, -0.00594410f, -0.09923547f, 0.02895530f, 0.05891181f, -0.01294678f, 
    -0.08797313f, -0.16800733f, 0.09818883f, 0.07704445f, -0.45999339f, 0.10237791f, 0.02673689f, 0.13454074f, 
    0.04093415f, 0.06589612f, 0.01736474f, -0.15579009f, 0.14224832f, 0.04642196f, -0.15263729f, -0.00700910f, 
    -0.00734238f, 0.02151088f, 0.09608740f, -0.00572498f, 0.05405714f, -0.16914746f, 0.03072987f, -0.07470851f, 
    0.12220553f, -0.08124179f, 0.09276964f, 0.03641978f, 0.16087069f, -0.13747229f, 0.14951554f, 0.19921538f, 
    -0.01628026f, -0.01428969f, -0.08210531f, 0.10381059f, -0.02259316f, 0.03989695f, 0.04810828f, 0.01022238f, 
    -0.14849795f, -0.10680490f, -0.24915905f, -0.36315429f, 0.22564200f, -0.16109633f, 0.00011926f, 0.15164934f, 
    0.05181423f, -0.02593665f, 0.07202661f, 0.05822455f, -0.09584768f, -0.05949602f, 0.02856020f, 0.03292717f, 
    -0.08106789f, -0.01362142f, 0.09295465f, -0.03881287f, -0.17804372f, -0.09476659f, -0.06875783f, -0.08753020f, 
    0.03977598f, -0.21265589f, 0.12386267f, -0.02131407f, -0.08115672f, -0.02021132f, 0.01012350f, 0.06832669f, 
    0.02222471f, -0.00588219f, -0.09240393f, 0.03528890f, 0.05199066f, -0.02385666f, 0.08873095f, -0.02287386f, 
    0.03836530f, 0.08784886f, -0.01332658f, 0.11119881f, 0.50838673f, -0.22193560f, 0.01773319f, 0.30541536f, 
    0.25535125f, 0.01993606f, 0.11986341f, 0.28639671f, -0.15595147f, 0.00871408f, -0.05560185f, 0.00324052f, 
    -0.12035093f, 0.02479369f, 0.02374075f, 0.01536234f, -0.00107776f, 0.22190750f, 0.14282650f, 0.17582983f, 
    -0.12910664f, -0.13275932f, 0.08933957f, -0.02779076f, -0.05952235f, -0.00580932f, 0.00567885f, -0.01809384f, 
    0.05953101f, -0.00618355f, 0.00437108f, -0.00687383f, -0.01844416f, -0.02516358f, 0.04250605f, 0.07529465f, 
    0.12504555f, 0.08891907f, 0.11432427f, 0.05615539f, 0.02771654f, 0.23228385f, -0.06640217f, -0.05774224f, 
    0.05956881f, 0.20597680f, -0.12867515f, -0.08897386f, -0.07077355f, -0.02080288f, -0.19288749f, 0.09432014f, 
    -0.09243146f, -0.11390178f, -0.09281400f, -0.00295821f, -0.02319053f, -0.11442633f, 0.02044308f, -0.06092475f, 
    -0.07290413f, -0.13057145f, 0.24446349f, 0.17526801f, -0.00920472f, -0.13637295f, -0.04140156f, 0.08877919f, 
    0.04920418f, -0.12105113f, -0.03082342f, -0.02879309f, -0.02651479f, 0.03289617f, -0.00395358f, 0.11710640f, 
    0.11263409f, 0.06222998f, 0.06013480f, -0.00922731f, -0.35014760f, -0.19304413f, 0.19794452f, -0.23855957f, 
    0.08316210f, 0.03638606f, -0.02901300f, 0.22367318f, 0.18004951f, 0.04183202f, -0.10677963f, -0.09084036f, 
    0.03720219f, 0.05058401f, 0.17471056f, 0.16632953f, -0.07728338f, 0.09577969f, -0.01535820f, 0.09259593f, 
    0.10365244f, -0.29705417f, 0.17106073f, 0.05919108f, -0.05533429f, -0.04351963f, -0.02012783f, 0.02566107f, 
    -0.03231249f, 0.00664809f, 0.02438592f, 0.05635824f, -0.08773595f, 0.01364886f, -0.03826888f, -0.09518516f, 
    -0.00091949f, 0.08727328f, 0.02947401f, 0.04922327f, -0.29059494f, 0.07820176f, 0.00852292f, 0.19905223f, 
    0.03148814f, -0.05452481f, 0.04754087f, 0.02721622f, 0.19730151f, -0.12069628f, -0.00318049f, 0.04381828f, 
    0.04715204f, -0.00072857f, 0.02715470f, -0.00653869f, -0.04863136f, -0.06556647f, -0.22263435f, -0.24932562f, 
    0.29456437f, 0.03145645f, 0.12149217f, -0.02282904f, 0.06407210f, 0.03931467f, -0.06390717f, -0.10618366f, 
    -0.04522923f, 0.09443795f, -0.10419966f, 0.13910794f, -0.08817919f, -0.05388166f, -0.10368118f, 0.04013105f, 
    -0.03588428f, -0.04483916f, 0.08108714f, 0.11700741f, -0.13191441f, -0.11577078f, -0.07842734f, 0.07138506f, 
    -0.03796406f, -0.05402419f, 0.02298426f, -0.15713611f, -0.00577604f, -0.00774712f, -0.00612351f, -0.01648100f, 
    -0.05298804f, -0.05130282f, -0.04450467f, -0.04442418f, -0.08320891f, -0.01980496f, 0.05188789f, 0.07678796f, 
    -0.37496558f, -0.10883173f, -0.52838343f, 0.00268699f, 0.07666871f, -0.06783371f, -0.11034762f, 0.13694116f, 
    -0.06579224f, -0.09967722f, -0.02359412f, 0.07274418f, 0.03724433f, 0.11282761f, 0.05986801f, 0.07609980f, 
    -0.04867080f, -0.16368027f, -0.00349056f, 0.10280786f, -0.00874432f, 0.02684318f, 0.07736854f, -0.03921990f, 
    -0.01745572f, 0.04026117f, 0.10112003f, 0.04067953f, 0.02361415f, 0.01930724f, -0.05696714f, -0.11233778f, 
    0.02269404f, -0.01301691f, -0.02742957f, 0.01322686f, 0.09893945f, 0.05720855f, 0.12917723f, 0.12604260f, 
    -0.07325602f, -0.50452495f, -0.04337228f, -0.17515953f, -0.39168769f, -0.11228342f, -0.17434016f, -0.02288110f, 
    -0.17497122f, -0.09086780f, 0.01646756f, 0.02813807f, -0.14346357f, 0.05241119f, 0.02838935f, 0.06232770f, 
    0.02675146f, -0.01035956f, -0.13290618f, -0.11955304f, -0.30593848f, 0.26825196f, -0.30842796f, 0.15677603f, 
    0.06324281f, 0.01005154f, -0.03462353f, -0.01384017f, 0.19203451f, 0.01786151f, -0.07756949f, 0.00899957f, 
    0.02634423f, -0.01183845f, 0.03550318f, -0.15865606f, 0.05511229f, -0.13598078f, 0.04655469f, -0.01606673f, 
    0.09631512f, -0.12277038f, 0.31586263f, 0.03679364f, 0.03446238f, -0.07376316f, 0.03175121f, 0.00471402f, 
    0.06800209f, -0.08701774f, -0.00732423f, 0.03737982f, 0.14279802f, 0.00484501f, 0.04189865f, -0.11620624f, 
    0.14315702f, 0.08216318f, 0.01468837f, -0.01524955f, -0.51014721f, -0.11782742f, 0.19283284f, 0.25982460f, 
    0.15798829f, -0.08201171f, -0.05034870f, -0.06080934f, 0.06834242f, -0.05107743f, -0.10560307f, -0.01391019f, 
    -0.02773480f, 0.03693552f, 0.03942596f, 0.21604952f, -0.21853304f, 0.00359979f, -0.31155077f, -0.10441020f, 
    -0.21027687f, -0.21211135f, 0.21061499f, 0.00542594f, 0.01810784f, 0.01119871f, 0.05903562f, -0.15200604f, 
    0.04670824f, -0.06530743f, 0.03385234f, 0.00433572f, -0.00593499f, 0.10041663f, 0.07493693f, -0.01403386f, 
    0.15578990f, -0.00019711f, 0.09912053f, 0.01478453f, -0.13307694f, 0.03791833f, -0.14701441f, -0.07102550f, 
    0.19438760f, 0.07523504f, -0.06708761f, -0.01362568f, -0.11562028f, 0.06477061f, -0.09013106f, 0.06127218f, 
    0.04422859f, -0.09513654f, -0.04519817f, 0.09916703f, 0.02653094f, -0.09175152f, 0.02679854f, -0.04310646f, 
    0.01677120f, 0.05073187f, 0.01730103f, 0.08061416f, -0.02237420f, -0.00306516f, -0.06850843f, 0.08284792f, 
    -0.01596715f, -0.04950051f, 0.10034370f, 0.02862868f, -0.01641652f, 0.08151572f, 0.03675914f, 0.01716912f, 
    -0.08106812f, 0.04233948f, -0.06431609f, -0.05022142f, -0.03842653f, 0.12571038f, 0.18255138f, 0.02385511f, 
    -0.00795496f, 0.04793670f, -0.12841390f, 0.10454269f, 0.11719589f, 0.09775107f, -0.15667157f, 0.03665696f, 
    -0.14754666f, 0.08256587f, -0.07669835f, -0.14355727f, -0.11178809f, 0.02637763f, -0.05294970f, 0.09464609f, 
    0.07338373f, -0.03106537f, -0.00452861f, -0.13463698f, -0.25861767f, -0.06752987f, -0.17372303f, -0.04618929f, 
    0.03353354f, 0.05944032f, 0.03855214f, 0.02366432f, 0.03746034f, -0.01373567f, 0.01350705f, -0.00413330f, 
    -0.01676738f, 0.02913622f, -0.00191736f, 0.00634381f, 0.11506940f, -0.05030103f, -0.07262160f, -0.04465846f, 
    -0.14511484f, -0.10077786f, 0.09737247f, -0.00743547f, -0.04144968f, 0.04340352f, -0.00189299f, 0.03466216f, 
    0.19587353f, 0.06413750f, -0.04023209f, 0.00690980f, -0.00351669f, 0.06560683f, 0.15489581f, 0.00720317f, 
    0.10878480f, -0.33230054f, 0.09825120f, 0.06765275f, -0.16007778f, 0.00473799f, -0.05272518f, -0.00872859f, 
    0.01536246f, -0.03412967f, -0.01553203f, -0.04627108f, -0.13136335f, -0.04681531f, -0.02506357f, 0.06058183f, 
    -0.01989203f, 0.11246973f, 0.00692981f, -0.07458116f, -0.39271376f, 0.18103579f, -0.15142411f, 0.18449664f, 
    -0.10871871f, -0.03236479f, -0.04261943f, -0.03908487f, 0.03428419f, 0.08799781f, -0.04776341f, -0.14273301f, 
    -0.09279162f, -0.01337851f, 0.03403524f, 0.00032275f, -0.08590236f, -0.07803887f, -0.08938712f, 0.05685029f, 
    -0.04328533f, -0.21250103f, -0.00417709f, 0.07041983f, 0.08165166f, 0.04348645f, 0.01489217f, 0.00110076f, 
    -0.04107757f, -0.12234520f, -0.00294899f, -0.13459647f, -0.02584461f, 0.01962380f, -0.02909071f, 0.11557599f, 
    -0.03344365f, 0.03132980f, -0.09765116f, 0.00294298f, 0.10289028f, -0.20762950f, 0.15410656f, 0.17427023f, 
    0.12171392f, -0.14323059f, -0.22740632f, 0.09799500f, -0.17927530f, -0.02729068f, 0.09032219f, -0.04680786f, 
    0.11649374f, -0.06427583f, -0.01305528f, 0.00738488f, -0.06465808f, 0.00672028f, 0.05085903f, 0.02240421f, 
    -0.19340365f, -0.07190601f, -0.15812068f, 0.22033362f, 0.07265297f, -0.03164612f, -0.06811763f, -0.03972488f, 
    -0.09644007f, 0.01648585f, 0.02085463f, -0.01987476f, -0.09059964f, -0.08123486f, -0.07990710f, -0.02854798f, 
    -0.07660691f, 0.02184858f, -0.00450887f, -0.17671566f, 0.06218837f, -0.15456188f, -0.29784063f, -0.04826860f, 
    -0.07050747f, -0.03046052f, -0.18020973f, -0.05591664f, -0.02315696f, -0.04783362f, 0.01677395f, 0.03999748f, 
    -0.01340799f, -0.01151299f, -0.00771587f, 0.05002986f, -0.07003521f, 0.07999759f, 0.09729008f, 0.02062128f, 
    -0.29560417f, 0.14675149f, -0.20769718f, -0.05964990f, -0.04003610f, 0.07034676f, 0.00629036f, 0.13560200f, 
    -0.01505809f, -0.00790970f, 0.00372033f, -0.15012285f, -0.07305540f, 0.02174167f, 0.08595259f, 0.05036620f, 
    -0.11694580f, 0.02886971f, 0.08710137f, -0.02894233f, 0.05680075f, -0.13153097f, -0.15053976f, -0.36296290f, 
    -0.17463277f, -0.00908093f, 0.00354441f, -0.02268014f, -0.05715826f, 0.04852840f, 0.01814806f, -0.01428903f, 
    0.04986193f, 0.02212266f, -0.03577585f, 0.03287640f, -0.03376843f, -0.03619793f, 0.00733783f, 0.05991723f, 
    -0.21444976f, 0.02069438f, -0.16752903f, 0.15392448f, -0.37627357f, 0.16437578f, 0.10695918f, 0.01649297f, 
    -0.05303653f, 0.07516941f, -0.07328378f, -0.13434465f, 0.06857108f, 0.06145142f, -0.04297371f, 0.10248331f, 
    -0.07110582f, 0.04112544f, -0.04455772f, -0.01222466f, 0.18247172f, -0.01132117f, 0.03730674f, 0.03284679f, 
    0.11179283f, 0.08897074f, -0.02723175f, 0.04059833f, -0.06681812f, -0.07065610f, -0.02042925f, 0.03825676f, 
    0.00612673f, -0.03991942f, -0.01788299f, -0.04361604f, 0.10540996f, 0.04566286f, 0.09196001f, 0.02264629f, 
    -0.19169329f, -0.19311398f, -0.00814194f, 0.19334798f, -0.08741992f, 0.07871296f, -0.09058664f, 0.03516329f, 
    -0.13548276f, 0.01094532f, -0.03175429f, -0.00236460f, -0.12394031f, 0.06494809f, 0.05235071f, 0.14001130f, 
    0.10851175f, 0.22229512f, 0.14775749f, 0.02528282f, 0.23706566f, -0.01712084f, 0.16688851f, 0.05195585f, 
    0.08595890f, -0.00794772f, 0.05041894f, 0.02409940f, 0.06371034f, -0.11661424f, -0.02445607f, -0.12001281f, 
    -0.02793436f, -0.06854062f, -0.04767425f, 0.02676566f, -0.05475446f, -0.05126458f, -0.06899852f, -0.00160697f, 
    -0.49760890f, -0.22112636f, -0.18336289f, 0.25139877f, -0.28906760f, -0.05876054f, -0.00307194f, -0.05040915f, 
    0.16396660f, 0.00602190f, -0.06559189f, 0.00764681f, 0.02426836f, -0.10413892f, -0.03630631f, 0.00252463f, 
    -0.06640901f, -0.01889546f, -0.07138918f, 0.00771386f, 0.34149751f, 0.11511499f, 0.28294867f, 0.04778215f, 
    -0.04176168f, 0.04544866f, -0.03071806f, -0.15585998f, 0.02820398f, 0.01534573f, -0.05039752f, 0.03743686f, 
    -0.05634032f, -0.02028033f, -0.07585885f, -0.02461356f, 0.13326257f, -0.03218556f, 0.05053507f, 0.07251038f, 
    0.10723550f, -0.15342218f, 0.11463933f, -0.19432840f, -0.05526196f, -0.02643027f, -0.35941395f, -0.10717876f, 
    0.00455695f, -0.05876384f, -0.01255133f, -0.03003414f, 0.04608963f, 0.01565387f, 0.01408394f, 0.05754285f, 
    -0.00591480f, -0.00052179f, 0.21131600f, -0.04990340f, -0.15754370f, 0.11535539f, -0.29924661f, 0.29007033f, 
    -0.13161474f, -0.05526811f, -0.03684977f, -0.06948324f, -0.04097893f, -0.00849449f, 0.00521198f, -0.04631910f, 
    -0.07836965f, -0.01053142f, -0.03699294f, 0.01336984f, -0.03206838f, -0.03335371f, -0.06206963f, 0.03838001f, 
    0.10250508f, -0.26318645f, -0.09030890f, -0.10501701f, 0.10311662f, -0.13759211f, -0.22643168f, -0.07372614f, 
    0.02933324f, -0.08750155f, -0.01124538f, 0.10167842f, 0.01197690f, -0.07059697f, -0.03443049f, 0.02303393f, 
    -0.02227627f, -0.02023040f, 0.12639989f, 0.08861121f, 0.14907740f, 0.05574120f, 0.03010276f, 0.14415325f, 
    -0.06210465f, -0.07586163f, 0.03080982f, -0.05224952f, 0.06037982f, 0.04572705f, -0.12453274f, -0.05374423f, 
    0.01683472f, -0.02285272f, -0.05805739f, 0.02979686f, 0.07195831f, 0.01554756f, -0.17906752f, 0.05969805f, 
    -0.67386615f, -0.05683376f, -0.50038505f, 0.46372008f, 0.06188874f, 0.04214903f, 0.22935532f, 0.01042813f, 
    0.19177362f, 0.05873383f, -0.19161257f, -0.02185370f, -0.07893661f, 0.06546334f, 0.02229328f, 0.12198777f, 
    -0.02268044f, 0.17085046f, -0.05606548f, 0.09434474f, -0.36624694f, -0.20440707f, -0.16100289f, 0.13988470f, 
    0.08501393f, -0.10492674f, 0.00013903f, -0.09725647f, 0.05944233f, 0.10249764f, -0.12128459f, 0.08341964f, 
    -0.11339014f, 0.03628127f, -0.08245505f, 0.04995153f, -0.02189488f, -0.04931195f, -0.10662147f, -0.10735498f, 
    -0.62962514f, -0.04280354f, -0.41005400f, 0.16096435f, -0.32064626f, 0.09872865f, 0.03116096f, 0.02034818f, 
    -0.09137758f, 0.12698510f, -0.05198689f, -0.09782701f, -0.00132696f, 0.10329330f, -0.01851418f, -0.04216879f, 
    -0.02083458f, 0.00282266f, 0.00589835f, 0.02541273f, -0.11502774f, -0.18701854f, 0.03740780f, -0.25429967f, 
    -0.40632284f, 0.16845998f, 0.05783315f, -0.03935660f, -0.13648960f, -0.01410050f, -0.10082255f, -0.07321123f, 
    0.15578936f, 0.18306886f, 0.03871296f, -0.02654434f, 0.02499764f, 0.02187190f, 0.01298290f, 0.12986815f, 
    0.05594731f, -0.14673160f, 0.05828357f, 0.30143738f, 0.06706978f, -0.25023997f, 0.03579057f, -0.07886028f, 
    -0.00945121f, -0.01562967f, -0.01393211f, 0.07074507f, -0.04616365f, 0.05283028f, 0.11463971f, -0.11324213f, 
    -0.07480020f, 0.07164703f, -0.11724327f, -0.14344981f, 0.46267992f, -0.26561630f, 0.42459646f, -0.28221306f, 
    0.15719621f, 0.02706630f, 0.05298335f, -0.10198410f, 0.10128947f, -0.19384801f, -0.00213645f, -0.03744676f, 
    0.05649380f, 0.09635004f, 0.03454340f, 0.01547655f, 0.11509197f, 0.01866659f, 0.06153200f, 0.02332887f, 
    -0.17248662f, -0.26554519f, -0.09331961f, 0.14873298f, -0.08075502f, -0.04490246f, -0.18178767f, 0.00750252f, 
    -0.01925257f, -0.04471077f, 0.01748648f, 0.05886023f, -0.04163911f, -0.06972660f, 0.00219701f, 0.09229432f, 
    0.02614988f, 0.09038652f, -0.01926236f, -0.05812323f, 0.02546284f, -0.23139738f, 0.02422872f, -0.15276182f, 
    0.07901505f, 0.06722128f, -0.01670796f, 0.00773799f, 0.04520627f, 0.04681477f, -0.00796735f, 0.05701335f, 
    -0.14330393f, 0.15008624f, 0.02235194f, 0.02764690f, 0.05491091f, 0.20043124f, -0.17255463f, 0.14167963f, 
    -0.03187566f, 0.00476530f, -0.04417977f, -0.01729899f, 0.15343830f, -0.00945122f, 0.09825417f, 0.05146315f, 
    0.04957328f, 0.04490406f, -0.07071567f, 0.09577032f, 0.06021582f, -0.06291026f, 0.06246456f, -0.11243556f, 
    -0.14527237f, -0.01893031f, -0.11549088f, -0.04905890f, 0.01522700f, 0.02637628f, -0.00361723f, 0.10346603f, 
    -0.04538920f, -0.10766031f, 0.13712268f, 0.01744046f, 0.05430662f, 0.02115335f, -0.08519018f, 0.03434105f, 
    -0.00506850f, 0.07204152f, 0.06051830f, -0.03680475f, 0.00642355f, 0.02453135f, -0.13067816f, -0.09878642f, 
    0.05607232f, 0.15259670f, 0.12827341f, 0.03712948f, -0.06482763f, -0.12529616f, -0.11160310f, -0.03496975f, 
    -0.05460556f, -0.10998832f, -0.03990513f, 0.07880631f, -0.00775117f, -0.00816007f, 0.07178135f, 0.00126460f, 
    -0.16063447f, -0.05036316f, -0.13975976f, -0.15786771f, 0.04192927f, -0.07554272f, -0.25840119f, 0.15673874f, 
    -0.11406172f, -0.06695610f, -0.05052887f, -0.09717570f, -0.06545537f, -0.01474347f, 0.04759298f, 0.07305033f, 
    0.05259880f, -0.06866516f, -0.04068277f, -0.00009399f, 0.02685925f, -0.04926031f, 0.06172004f, 0.02803964f, 
    -0.24479403f, -0.00063608f, -0.26773933f, -0.10653403f, 0.11638343f, 0.01770119f, 0.06572510f, 0.01914072f, 
    -0.09590591f, -0.01628583f, -0.04651536f, -0.01131041f, 0.07265188f, 0.11110577f, 0.09243478f, -0.00074812f, 
    0.00129434f, 0.05307607f, 0.11956318f, 0.12197375f, -0.39188886f, 0.05281575f, -0.09710564f, 0.25752285f, 
    -0.32140160f, -0.02201292f, -0.03111242f, 0.16604675f, -0.08877817f, 0.08270742f, -0.14451239f, -0.07226934f, 
    0.09215705f, 0.07964390f, -0.10096110f, 0.02083879f, 0.10560766f, 0.21257582f, -0.09833078f, -0.17101958f, 
    -0.02379515f, -0.28331175f, -0.19372292f, 0.06324470f, -0.03144141f, -0.03742181f, -0.16654429f, 0.08310760f, 
    -0.07779679f, -0.02375489f, 0.01835198f, -0.02476810f, 0.03466576f, -0.04022723f, 0.00671708f, 0.06952823f, 
    -0.05511400f, 0.05350544f, 0.05533053f, -0.01966626f, 0.34854007f, 0.08606628f, 0.25849825f, -0.08558734f, 
    0.01436418f, 0.04452604f, -0.04782052f, -0.09332652f, 0.00809196f, -0.08509921f, -0.06130302f, 0.11069021f, 
    0.01421221f, 0.09617037f, 0.01736403f, -0.05412732f, -0.08050323f, -0.03872422f, -0.16198373f, 0.07190112f, 
    0.25470719f, 0.05699078f, 0.06644427f, 0.41749191f, 0.12497956f, -0.12697722f, 0.04858352f, -0.07144090f, 
    0.21530262f, -0.09465697f, -0.19388190f, -0.02790571f, 0.01310669f, 0.00701808f, 0.11255094f, 0.06387843f, 
    0.00956823f, 0.07483576f, 0.02708962f, 0.04101130f, 0.37688404f, 0.21037345f, 0.26384047f, -0.12879451f, 
    -0.15402122f, -0.00277410f, -0.02385887f, -0.02873336f, 0.07712930f, -0.03274129f, -0.06988809f, 0.01133365f, 
    0.04926983f, -0.03972992f, -0.04001092f, 0.04150403f, 0.07630066f, -0.07043150f, 0.06886217f, 0.04311360f, 
    -0.09707589f, 0.14463297f, -0.25951827f, 0.04368618f, 0.05608205f, -0.01235320f, 0.05128895f, 0.10721751f, 
    -0.07831226f, 0.02215677f, -0.03163140f, 0.04691580f, -0.05586193f, -0.00282138f, 0.06377853f, -0.05719385f, 
    -0.05335521f, -0.00834814f, 0.01032013f, -0.08397084f, -0.27774107f, 0.00538762f, -0.29769817f, 0.13734832f, 
    -0.09020174f, -0.00877036f, 0.11248028f, 0.03983618f, 0.13107233f, 0.00837523f, -0.10837173f, -0.08172376f, 
    0.04595982f, 0.07353459f, -0.06830781f, 0.04762922f, -0.03151839f, 0.06238500f, -0.13763814f, 0.06720974f, 
    0.28184932f, -0.02280767f, 0.11944198f, -0.01864116f, -0.25614849f, -0.03845710f, -0.02910676f, 0.05524293f, 
    0.12917884f, 0.03997342f, -0.02669372f, 0.07186843f, -0.03091929f, -0.00550647f, -0.05749380f, -0.08319265f, 
    0.09020249f, 0.02071998f, 0.08305265f, -0.04861388f, 0.30330294f, -0.04496665f, 0.08410510f, 0.47150213f, 
    -0.06845325f, -0.07126550f, 0.08841107f, -0.10699037f, 0.13678388f, -0.23549473f, -0.16534021f, -0.01882699f, 
    -0.06684567f, 0.04667264f, -0.02473680f, 0.07489105f, -0.12093764f, 0.16446061f, 0.02359955f, -0.01707900f, 
    -0.17051211f, -0.53193021f, 0.10749932f, -0.45697975f, 0.30836058f, 0.03977073f, -0.03610618f, -0.08121756f, 
    0.18464312f, 0.02683500f, -0.05928641f, 0.07368404f, -0.04023859f, 0.10595112f, -0.01717570f, 0.08684976f, 
    0.12151717f, 0.05046695f, -0.00389364f, 0.07730489f, -0.09234902f, -0.20017390f, 0.12625919f, -0.13268851f, 
    0.10642204f, 0.08121140f, 0.06317589f, 0.12535803f, 0.02710952f, 0.00845724f, -0.06607507f, 0.05680959f, 
    0.02408436f, 0.00661895f, 0.05551298f, -0.03475237f, 0.12171329f, -0.01904162f, -0.00369729f, -0.04000880f, 
    0.07635500f, 0.09646785f, 0.08395316f, 0.16522309f, -0.05833265f, -0.12071493f, 0.03640373f, -0.04169746f, 
    0.04864625f, -0.00723701f, -0.09482630f, 0.00767519f, 0.00196590f, 0.02124325f, 0.00756185f, 0.07660946f, 
    0.02745400f, 0.03029829f, -0.11628263f, 0.00751497f, -0.38853151f, -0.18264385f, 0.14364646f, -0.09955124f, 
    -0.16037008f, -0.06353527f, 0.02150446f, -0.22160177f, 0.33229971f, 0.15534715f, -0.07340483f, 0.01090054f, 
    -0.17078653f, 0.04927425f, -0.16512924f, -0.00287997f, -0.10219480f, 0.08948889f, 0.19519369f, -0.05457800f, 
    -0.01104008f, -0.07652683f, 0.06413782f, -0.05202204f, 0.01809079f, 0.05455608f, 0.08804136f, -0.05006639f, 
    0.03331937f, -0.05807497f, -0.01931069f, 0.05725818f, 0.04071217f, 0.02738397f, 0.10136266f, -0.02392930f, 
    -0.01199036f, -0.00943768f, -0.13005202f, -0.13100561f, -0.63065243f, -0.09001927f, -0.38326880f, 0.25519171f, 
    -0.44523025f, 0.15995438f, 0.02964841f, 0.12246424f, -0.11387545f, 0.07328158f, -0.11748838f, -0.14361437f, 
    0.04240335f, 0.04896146f, 0.02740780f, 0.03557608f, 0.03302465f, 0.07077087f, 0.04797124f, 0.04710567f, 
    0.12667081f, -0.15621032f, 0.29501796f, -0.09417234f, 0.16154198f, 0.19437325f, 0.14427409f, 0.07798567f, 
    0.10312179f, -0.04490928f, -0.05119417f, 0.04375954f, 0.10809440f, 0.04211240f, 0.11170312f, 0.02794019f, 
    0.09940302f, -0.11098790f, -0.17019732f, 0.05018314f, 0.18530287f, 0.00006783f, 0.21999004f, 0.16083625f, 
    0.14692089f, 0.07719639f, 0.10223114f, 0.01446440f, 0.23768878f, -0.23052786f, 0.03041789f, -0.16215077f, 
    0.00921388f, -0.04496842f, 0.00338932f, 0.15719968f, -0.05998465f, 0.14432639f, -0.05591525f, -0.17321345f, 
    -0.22314371f, -0.07091764f, -0.09593913f, -0.07580660f, -0.04108168f, -0.00435914f, 0.09169874f, 0.05388201f, 
    0.02352496f, 0.06430993f, -0.09051412f, 0.04572497f, 0.04093156f, -0.02028087f, 0.00715502f, -0.00129161f, 
    -0.06365442f, -0.03521460f, 0.05888580f, 0.07010678f, -0.33071905f, -0.09879150f, -0.36327970f, 0.09806675f, 
    -0.03247018f, -0.07587781f, -0.11648110f, 0.08350614f, -0.00423256f, -0.17002562f, -0.03332185f, 0.03251830f, 
    -0.02964559f, 0.02706682f, 0.01669058f, 0.17915921f, -0.13972265f, 0.14828384f, 0.14408767f, 0.06942666f, 
    -0.49586514f, -0.21308871f, -0.20394042f, 0.10248227f, -0.20635910f, 0.02685492f, 0.04211733f, 0.02949496f, 
    -0.12202758f, 0.17575219f, -0.14134783f, -0.06759029f, 0.05587829f, -0.04596168f, -0.11900506f, -0.07779041f, 
    -0.06166073f, -0.02963342f, 0.06139836f, 0.04188877f, -0.18875034f, -0.02044587f, -0.13927042f, 0.06139220f, 
    -0.04850677f, -0.00031347f, -0.00944756f, 0.03931585f, 0.04892642f, 0.02201394f, -0.03993598f, 0.05481030f, 
    0.06289452f, 0.03701148f, -0.03118371f, 0.01656641f, -0.05716892f, -0.00280262f, -0.06800317f, -0.00476749f, 
    -0.20743167f, -0.44762617f, -0.34827709f, -0.02129488f, -0.05652644f, -0.09483778f, -0.32269490f, 0.01742276f, 
    -0.19732732f, -0.12802060f, 0.00047722f, 0.02555119f, -0.06639668f, -0.06718860f, 0.00019403f, 0.00888168f, 
    -0.02726177f, 0.02686461f, -0.02858075f, -0.16016290f, 0.08750333f, -0.06219773f, 0.15830712f, -0.04782397f, 
    0.08421565f, 0.00071837f, 0.04351726f, -0.11426820f, 0.09652646f, 0.07302496f, 0.06453659f, 0.07871314f, 
    -0.04432626f, 0.01541739f, 0.01791160f, -0.10027107f, -0.02291698f, 0.02246510f, -0.07748238f, -0.15920308f, 
    -0.05644748f, -0.07713901f, -0.05774543f, -0.10100736f, 0.00059809f, -0.01975272f, 0.04441541f, -0.00549086f, 
    0.02971125f, 0.04123086f, -0.12295362f, -0.02079382f, 0.02292586f, -0.08637151f, -0.07974265f, 0.09231414f, 
    0.05289288f, 0.07131802f, 0.03894331f, -0.10618920f, -0.48238334f, 0.10685103f, -0.19691226f, 0.15801851f, 
    -0.20050323f, 0.04925831f, -0.00812477f, 0.11677771f, -0.03967340f, -0.04275979f, -0.03162278f, -0.07796429f, 
    0.01228949f, 0.06039646f, -0.01769692f, 0.19358529f, -0.03239612f, 0.12409066f, 0.02575005f, -0.04982946f, 
    0.09982418f, 0.02606836f, -0.13516781f, -0.01693444f, 0.17340726f, -0.06165813f, 0.14312164f, -0.05313932f, 
    0.05315122f, -0.00173331f, 0.00854020f, 0.13431549f, -0.06067683f, 0.03895193f, -0.01707470f, -0.05861695f, 
    -0.03832847f, 0.10646835f, -0.08491486f, 0.05343845f, 0.33159515f, -0.87289047f, 0.38004491f, 0.28207278f, 
    0.17274165f, 0.21546921f, 0.02123592f, -0.04926963f, 0.03175248f, -0.16043884f, 0.01043746f, -0.05634027f, 
    0.09360410f, 0.01628091f, -0.02955541f, 0.09400599f, 0.05017520f, 0.15603699f, -0.01025537f, -0.17550540f, 
    0.29394129f, -0.06024747f, 0.19163471f, -0.04911734f, 0.14061606f, 0.05620040f, 0.19077566f, 0.01681218f, 
    0.02011370f, -0.09530720f, -0.01062732f, 0.01431163f, -0.00353420f, 0.02242402f, 0.04093653f, -0.00039923f, 
    0.08115967f, -0.04451931f, -0.06733604f, 0.04502795f, -0.08786165f, -0.10107128f, -0.15230624f, 0.16805157f, 
    -0.18279508f, -0.05889828f, -0.16315843f, 0.01940270f, -0.02113567f, 0.04073091f, -0.00393639f, 0.00841439f, 
    0.03402602f, -0.01031369f, -0.02693645f, 0.03779097f, 0.03133757f, 0.06960433f, 0.03481285f, 0.00286601f, 
    -0.01929764f, -0.03309665f, -0.04475359f, 0.17637853f, -0.03214388f, -0.03449327f, 0.23564920f, -0.11342701f, 
    0.13787718f, -0.11424213f, -0.29297411f, 0.03213407f, 0.09699789f, 0.00033130f, 0.02071904f, 0.10517107f, 
    -0.06060222f, 0.07674678f, -0.01967713f, 0.13023525f, -0.48075658f, -0.09261782f, -0.28050557f, 0.18419173f, 
    0.09159004f, 0.11836436f, 0.14703076f, 0.11608410f, -0.17156158f, 0.01051474f, 0.02886518f, -0.02026413f, 
    0.04298575f, 0.10631817f, -0.03087295f, 0.02494711f, 0.00673762f, 0.00723336f, 0.05717066f, -0.07433984f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12636240f, 0.12775974f, 0.03991657f, -0.05545387f, -0.02247173f, 0.03537830f, -0.01522484f, -0.11128194f, 
    0.05173707f, 0.02746117f, 0.02336303f, -0.00827019f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
