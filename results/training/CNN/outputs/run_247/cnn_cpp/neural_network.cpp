#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.23784159f, 0.56830543f, -0.38672560f, -0.78953028f, 0.47709781f, -0.09744570f, -0.47392452f, -0.14952590f, 
    -0.11454239f, -0.28547484f, 0.17554818f, -0.29209474f, -0.06415659f, -0.00236081f, -0.00125577f, 0.19179404f, 
    -0.02709580f, -0.21190010f, -0.01861968f, -0.06165221f, 0.09552335f, 0.21274450f, 0.22130695f, 0.30137983f, 
    0.10735574f, -1.06002498f, 0.94499600f, -0.35065809f, -0.52591997f, -0.35710987f, -0.24720211f, 0.42741340f, 
    -0.06188472f, 0.24029826f, 0.48060203f, -0.29019755f, 0.04432587f, -0.32181743f, -0.25678933f, -0.05669146f, 
    0.09388848f, 0.17396089f, -0.04672815f, 0.19308259f, -0.17890431f, -0.29434341f, -0.00169911f, -0.14837712f, 
    -0.13473621f, -0.01300523f, -0.54561371f, -0.75424057f, -0.43844721f, -0.30799806f, -0.57810020f, -0.04599389f, 
    0.69744396f, 0.55655873f, -0.04477134f, 0.47283554f, -0.05569012f, -0.17716168f, -0.11323912f, -0.39281631f, 
    -0.12228275f, -0.09424835f, -0.08598719f, 0.12389363f, 0.15004010f, -0.08962675f, 0.09027939f, -0.03902973f, 
    -0.00082583f, 0.33639586f, 0.08688988f, 0.45431149f, -1.26723802f, -0.14093687f, 0.71429539f, 0.17228796f, 
    -0.59429145f, 0.62073648f, 0.38247818f, -0.41815671f, 0.23364379f, 0.33600503f, 0.31518948f, -0.14125347f, 
    0.09193522f, 0.16740705f, -0.11986489f, 0.07487590f, 0.05501872f, 0.07713097f, -0.17436810f, 0.09240198f, 
    -0.07975089f, -0.06991248f, -0.00156327f, 0.07037382f, -0.31195039f, -0.44391003f, -0.76996058f, -0.39422554f, 
    0.30770749f, 0.40681508f, 0.29083163f, -0.31375048f, -0.05786292f, -0.20162116f, 0.20694035f, 0.10107139f, 
    -0.23592259f, -0.07574472f, -0.13551517f, 0.33560243f, -0.04888503f, -0.24394907f, -0.11487575f, -0.28138369f, 
    -0.20807688f, -0.15235360f, 0.19035588f, -0.16330029f, -0.03336561f, 0.78722608f, 0.26844722f, 0.20714895f, 
    1.05400646f, 0.59131968f, -0.04147345f, 0.51103473f, 0.43015766f, -0.13612890f, 0.13372907f, -0.41580492f, 
    -0.30157396f, -0.29585707f, -0.07277955f, -0.08659586f, -0.06001971f, 0.02182006f, 0.19510148f, -0.14781201f, 
    0.09068883f, 0.12648641f, -0.00586527f, -0.27743143f, 0.28487176f, -0.04542626f, 0.46925747f, 0.17846861f, 
    0.71856630f, 0.88753140f, 0.49553248f, 0.12997732f, -0.15662885f, -0.52627450f, -0.76627558f, 0.00889301f, 
    0.18697661f, 0.31518471f, -0.11342470f, -0.00440249f, -0.19096786f, -0.11693773f, -0.14750348f, -0.07813052f, 
    0.02607324f, -0.10591386f, 0.04105300f, 0.04452000f, -0.02528739f, 0.05088318f, 0.28192055f, -0.94925576f, 
    0.49620163f, 0.56652254f, -0.75302708f, -0.26743129f, 0.49556303f, 0.15737280f, -0.40659380f, 0.12164390f, 
    -0.30363825f, -0.00698408f, 0.22342508f, -0.17855978f, -0.05928588f, 0.11882976f, -0.19875953f, -0.08174262f, 
    0.01920098f, -0.04848536f, -0.03491648f, 0.11198904f, -0.04324871f, 0.13355161f, 0.24761610f, 0.08836141f, 
    -0.53465295f, -0.84851050f, -0.63051903f, -0.50469434f, -0.00171930f, -0.35152408f, -0.59743840f, 0.33292693f, 
    0.11863086f, 0.19780613f, 0.33627057f, 0.30266330f, 0.41911274f, 0.23622791f, 0.11957277f, 0.17776996f, 
    0.03328743f, 0.14181936f, 0.38151360f, 0.21609746f, 0.05737909f, -0.11072517f, -0.19458580f, -0.20243667f, 
    0.03378265f, -0.45256090f, -0.84848988f, 0.48886415f, 0.69308889f, -0.30137229f, 0.43005988f, 0.17693578f, 
    0.42736384f, -0.48521796f, -0.49442959f, -0.28693467f, -0.21904017f, 0.04012296f, 0.23539326f, -0.07587238f, 
    -0.17490828f, 0.10214488f, 0.04402953f, -0.18733485f, -0.10447812f, -0.07175725f, 0.10738756f, 0.19112527f, 
    -0.03709269f, -0.20789705f, -0.13341706f, 0.76056439f, -0.05562898f, -0.17213953f, 0.33189216f, 0.21652734f, 
    -0.59882963f, -0.72246039f, -0.21076137f, -0.39985824f, 0.19772561f, 0.13973872f, 0.22265962f, 0.15686823f, 
    0.20823961f, 0.08282267f, 0.08590799f, -0.10331263f, -0.17029339f, 0.38468885f, -0.03123220f, 0.00651654f, 
    0.05573246f, -0.26443112f, -0.10682331f, -0.65018606f, -0.33014041f, 0.35513923f, 0.67967874f, 0.37011790f, 
    0.45429361f, 0.45623800f, 0.08352631f, 0.34314078f, -0.43464074f, 0.10161441f, 0.08232234f, -0.10349980f, 
    0.31923798f, 0.37081563f, 0.03142533f, 0.19872610f, -0.17076465f, 0.15601310f, 0.23407409f, 0.14832141f, 
    -0.07881214f, -0.15638828f, -0.02269192f, 0.18804286f, -0.46071669f, -0.11123516f, 0.06579812f, 0.31549543f, 
    0.62327105f, -0.67362309f, 0.15351433f, -0.13385198f, -0.65876991f, 0.20871438f, 0.34500906f, 0.43474758f, 
    -0.02377537f, -0.07254716f, 0.25415835f, 0.20873649f, -0.00377104f, 0.10183290f, 0.08801728f, 0.23871610f, 
    0.01472326f, 0.02158394f, 0.11350717f, 0.13223876f, 0.04217333f, -0.12498052f, -0.44529486f, 0.18449166f, 
    -0.44858629f, 0.58286613f, 0.15113570f, -0.10866989f, -0.22263235f, -0.29080409f, 0.39165062f, -0.29982096f, 
    0.37052432f, 0.19241492f, 0.10372858f, 0.33414280f, -0.44162035f, -0.26986894f, -0.23699780f, -0.39907885f, 
    -0.10670234f, -0.17881376f, -0.29456875f, 0.10722371f, -0.05116209f, -0.17436080f, -0.65081954f, -0.34062052f, 
    -0.36143982f, 0.05174917f, 0.01689286f, -0.62990612f, -0.47304556f, -0.36447534f, -0.03315603f, -0.04873841f, 
    0.20552514f, 0.61776018f, -0.17215337f, 0.04989347f, -0.20289636f, -0.08280795f, -0.00303814f, -0.11124597f, 
    -0.32741266f, -0.38332897f, 0.07370701f, 0.20762137f, 0.03126805f, 0.02615238f, -0.01465791f, 0.21151491f, 
    -0.46513546f, 0.59975129f, -0.33499360f, -0.44619444f, 0.43474394f, 0.57715267f, 0.41227549f, 0.05076200f, 
    0.12054404f, -0.11767781f, -0.04026977f, -0.22540499f, -0.21701416f, -0.40379947f, -0.18431684f, 0.04778348f, 
    -0.10713538f, -0.17362736f, -0.15959656f, -0.13007072f, -0.06254853f, -0.02432970f, -0.28402060f, 0.00845338f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35075098f, -0.05142706f, 0.04471556f, -0.00845008f, 0.06869008f, 0.23689166f, 0.04951194f, 0.01691733f, 
    0.16871315f, 0.01161802f, 0.23885131f, 0.26582977f, 0.05397012f, -0.02172854f, 0.30422837f, 0.01177770f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.28527176f, -0.06088119f, -0.03187345f, -0.24825676f, -0.03655320f, -0.01458540f, -0.11145449f, -0.14952582f, 
    -0.07842057f, 0.08281885f, 0.05655306f, -0.00212579f, -0.05386211f, 0.06496447f, -0.16370410f, 0.18099530f, 
    -0.11713498f, 0.13088530f, 0.07880876f, 0.04957769f, -0.02108151f, -0.04801756f, -0.06890599f, -0.07142868f, 
    0.55147862f, 0.00622497f, 0.29128638f, 0.09057306f, -0.04066043f, 0.01079619f, -0.00101353f, -0.09389807f, 
    0.04978053f, 0.07695076f, 0.10838894f, 0.05435471f, 0.77610320f, -0.15162680f, 0.12904577f, 0.03824673f, 
    -0.06228949f, 0.10811682f, 0.15277731f, 0.11565201f, 0.04835049f, 0.17768791f, 0.01068940f, 0.02317940f, 
    0.01247377f, 0.20370670f, 0.00892524f, -0.06477996f, -0.04679724f, -0.06765102f, 0.02957895f, 0.07527863f, 
    -0.17397396f, -0.06927887f, 0.04601110f, 0.05995557f, 0.01114290f, -0.02466342f, -0.07364359f, 0.00958965f, 
    0.02502752f, -0.10270376f, 0.06160143f, 0.05698948f, 0.00398611f, -0.03749374f, 0.07723634f, 0.04051973f, 
    -0.01335390f, 0.12869954f, -0.15993227f, 0.00140821f, -0.10397457f, -0.07597860f, -0.07865877f, -0.08614913f, 
    0.06508195f, 0.05958895f, -0.07745559f, -0.12328092f, 0.23874597f, 0.33283842f, -0.32792863f, 0.03386975f, 
    0.01718404f, 0.15927336f, -0.06105002f, 0.02323451f, -0.05157471f, 0.04406925f, 0.03453999f, -0.03914733f, 
    -0.05019576f, 0.19055940f, 0.22880886f, 0.00943213f, 0.03773371f, 0.03853171f, 0.17265522f, 0.15935230f, 
    0.02291400f, -0.04856010f, -0.07229015f, -0.06512140f, 0.12222996f, -0.20440710f, 0.00303829f, 0.02081407f, 
    -0.02378294f, 0.01339376f, -0.06459461f, 0.02941374f, 0.10751899f, 0.16281454f, 0.05583687f, 0.03929107f, 
    -0.16440044f, 0.01585869f, -0.07269573f, -0.24623360f, 0.11714268f, -0.04066949f, 0.00706154f, 0.10375948f, 
    0.17992865f, 0.00339328f, -0.03013577f, -0.17936489f, 0.31908688f, -0.17518318f, -0.12537941f, 0.18429542f, 
    -0.09392720f, -0.02865948f, -0.03089161f, 0.09433863f, 0.12696110f, -0.00115173f, -0.08107786f, 0.00138336f, 
    0.31033975f, 0.09261516f, -0.12721619f, 0.06006157f, -0.00401993f, 0.11381260f, -0.08972383f, 0.00857144f, 
    -0.09420139f, -0.00782269f, 0.07849074f, -0.08359014f, 0.13511783f, 0.04324669f, 0.02126060f, -0.02723044f, 
    0.02714241f, -0.09095604f, 0.01030753f, 0.12638348f, 0.13363841f, 0.05460323f, -0.06166916f, 0.15478684f, 
    0.16270413f, -0.10441609f, -0.01882626f, -0.37501317f, 0.14738815f, 0.04974715f, 0.04818042f, -0.00914800f, 
    -0.03640826f, -0.19279140f, 0.09041940f, -0.01945800f, 0.30220288f, 0.16719694f, 0.09145174f, 0.00195175f, 
    -0.07415365f, 0.19238622f, 0.15017152f, 0.13331829f, 0.08556519f, 0.17066859f, 0.03517359f, 0.09396216f, 
    0.03402537f, 0.06848679f, 0.07474841f, -0.50532645f, 0.04234323f, 0.00996612f, 0.04089382f, -0.11490379f, 
    0.00808968f, 0.07502173f, 0.04765108f, -0.01722054f, -0.36915010f, 0.43653271f, -0.23520543f, -0.28811800f, 
    -0.10092577f, 0.13514784f, -0.05366648f, 0.03559402f, 0.03508077f, 0.01549488f, 0.15201952f, 0.04413302f, 
    0.30553856f, -0.11037067f, -0.16310732f, -0.31171095f, -0.07841621f, -0.14513899f, -0.14236069f, 0.06954581f, 
    -0.00104243f, -0.10141102f, 0.01689779f, 0.26584190f, 0.46202886f, -0.36252856f, 0.18500370f, 0.21062516f, 
    -0.09810264f, 0.15713634f, -0.05195151f, -0.02815323f, 0.03180979f, -0.04665682f, 0.02001957f, 0.05776322f, 
    0.29302090f, 0.16831975f, -0.21144730f, -0.07868551f, -0.07185861f, -0.02838850f, -0.09005632f, 0.07257528f, 
    -0.02412598f, 0.15811259f, 0.16443074f, -0.01063308f, 0.03995224f, -0.20331989f, 0.09542954f, 0.24153687f, 
    -0.29649478f, -0.01216664f, 0.02061613f, 0.05127194f, 0.02503412f, -0.01544249f, 0.17063819f, 0.11380873f, 
    -0.07244704f, -0.31704828f, 0.29154113f, 0.42566377f, -0.05890271f, 0.19962968f, 0.06087293f, 0.00553051f, 
    -0.05440063f, -0.03262405f, 0.03749239f, -0.15697564f, -0.06714559f, 0.11526433f, 0.18614392f, -0.19674543f, 
    -0.06651814f, -0.10938731f, 0.01534932f, 0.28166541f, -0.00423693f, 0.05939498f, -0.09582616f, -0.05910190f, 
    0.02494067f, -0.00519065f, -0.00653523f, -0.14824656f, -0.24443093f, -0.08127494f, -0.01612024f, 0.04710619f, 
    -0.12137422f, -0.00317397f, 0.01889566f, 0.10949619f, -0.25134116f, -0.01982036f, -0.16074997f, 0.17226799f, 
    -0.01460790f, -0.01404567f, 0.01118304f, 0.14222449f, 0.00984355f, 0.06842344f, -0.04885266f, 0.12518789f, 
    0.32837203f, 0.00715902f, 0.05620029f, -0.11343862f, 0.05505487f, 0.06218037f, 0.06250707f, 0.02808610f, 
    0.13374661f, 0.13381667f, 0.02102323f, 0.01768485f, -0.07165272f, 0.01062847f, -0.18268797f, 0.01497272f, 
    -0.07101425f, 0.11259774f, -0.06864306f, 0.01010789f, -0.01043222f, 0.13211726f, -0.03828756f, -0.05554381f, 
    -0.25867817f, 0.14461598f, -0.06796517f, 0.06873786f, 0.05349622f, -0.00946197f, -0.06766245f, -0.08522467f, 
    -0.00843135f, -0.10469540f, -0.11190678f, -0.17885160f, 0.50866932f, 0.14288794f, 0.21462291f, 0.01112476f, 
    0.10185567f, 0.02504010f, -0.19854696f, 0.15761155f, -0.04352128f, -0.08066909f, 0.07795592f, 0.10523386f, 
    0.09567947f, 0.15585494f, -0.26825291f, 0.25812882f, 0.11370990f, 0.08472738f, -0.10005280f, 0.11710818f, 
    -0.05243981f, 0.04327133f, -0.00381926f, 0.04514323f, 0.05917600f, -0.10391776f, -0.05589293f, 0.06794364f, 
    0.00755055f, -0.06702530f, 0.11055570f, 0.07356491f, -0.04698724f, 0.09946807f, -0.02454725f, -0.11080796f, 
    -0.02756586f, -0.22581765f, 0.05922119f, -0.19920211f, 0.10808415f, 0.15863198f, 0.12166078f, -0.01041128f, 
    0.17551804f, 0.10190645f, 0.19772905f, 0.08958176f, 0.22020903f, -0.04064876f, -0.15596636f, 0.09720112f, 
    0.04230294f, -0.01198611f, 0.05959686f, -0.06480479f, -0.05243792f, -0.04449261f, -0.10345730f, -0.04330227f, 
    0.55066800f, 0.25367299f, 0.13313900f, 0.21650195f, -0.01038660f, 0.03677300f, 0.02640886f, 0.05455764f, 
    0.23622522f, 0.13381115f, 0.04025153f, 0.05239451f, 0.44130647f, -0.16601808f, -0.23102418f, 0.01755481f, 
    -0.04908553f, -0.00523624f, -0.07810257f, 0.11175520f, 0.07352488f, -0.06168094f, 0.00496210f, -0.08613399f, 
    -0.03027201f, 0.15656368f, 0.23201796f, 0.13529371f, 0.06667379f, -0.08997486f, -0.07400631f, 0.03228958f, 
    -0.03103180f, -0.09791891f, -0.12701358f, 0.03661110f, -0.00333169f, -0.09645227f, -0.31239712f, 0.06380806f, 
    0.04670644f, 0.03872336f, -0.12208903f, 0.12731026f, 0.04355288f, 0.11297018f, -0.07208580f, 0.06239757f, 
    -0.33066657f, 0.14434972f, -0.21974419f, -0.10279062f, -0.05226829f, 0.06071364f, -0.08240370f, 0.04959312f, 
    -0.16257614f, 0.00887725f, -0.08615255f, 0.04991420f, -0.19289450f, 0.23579416f, -0.12612478f, -0.17985652f, 
    0.07512842f, 0.05745827f, 0.11133538f, 0.09342327f, 0.02028458f, 0.09304154f, 0.06318898f, -0.08958069f, 
    0.39377895f, 0.15123090f, 0.19362336f, 0.03581908f, 0.14699078f, -0.11473540f, -0.01372287f, 0.16124195f, 
    -0.01983859f, 0.13732974f, -0.06265850f, -0.01763926f, 0.04702901f, 0.27502164f, -0.25232017f, 0.16132125f, 
    -0.08654054f, 0.00670223f, -0.01149110f, 0.04949066f, 0.03379587f, 0.09387643f, 0.11845648f, -0.09891228f, 
    -0.32136944f, -0.10986932f, 0.01310595f, -0.19811016f, 0.05882519f, -0.11456569f, 0.00178729f, 0.07624349f, 
    0.04743486f, 0.13375625f, 0.03806215f, 0.01482119f, 0.07361618f, 0.04154587f, -0.14031255f, 0.01950663f, 
    -0.05407732f, 0.06456503f, -0.00884626f, 0.12526028f, 0.13106942f, 0.02329829f, -0.02187020f, -0.01008848f, 
    0.42395875f, -0.03953701f, -0.15713297f, -0.20760316f, -0.02520468f, 0.04590982f, -0.06125599f, 0.03087695f, 
    0.09120785f, 0.14891762f, 0.25370887f, 0.21352495f, 0.04925032f, -0.12718548f, -0.01718780f, -0.17671187f, 
    -0.16888531f, -0.03590942f, -0.08453056f, 0.21652198f, 0.02152394f, -0.22239220f, -0.04878106f, -0.08126336f, 
    0.28962368f, -0.06790791f, -0.05400244f, 0.02158350f, 0.16558793f, -0.05642715f, 0.02657762f, 0.04472834f, 
    -0.05127197f, -0.09658319f, -0.02069580f, -0.17417018f, 0.22092757f, 0.43040663f, 0.22961067f, -0.04312886f, 
    0.05720001f, 0.02756002f, 0.23690265f, -0.00242136f, 0.06095048f, -0.04212023f, -0.20627435f, -0.16315646f, 
    0.05631425f, 0.04309041f, 0.04215309f, 0.02817719f, -0.04043259f, 0.02321243f, -0.00536111f, -0.01573267f, 
    -0.02992876f, -0.00982848f, -0.07023118f, 0.03347944f, -0.04484195f, -0.05758904f, -0.03727867f, -0.05234213f, 
    -0.03645948f, -0.06963023f, -0.07070602f, -0.01262494f, -0.02056586f, 0.02626001f, -0.02458581f, 0.01623897f, 
    0.00841460f, -0.06165702f, -0.06530855f, 0.04368642f, 0.02073308f, -0.04259698f, 0.04157445f, -0.00958503f, 
    -0.07055689f, 0.02373800f, -0.01711582f, -0.07504418f, 0.01973793f, 0.05933802f, 0.05265135f, 0.00961665f, 
    0.05595966f, 0.05080762f, -0.03809362f, -0.05798804f, -0.04397403f, -0.07224418f, -0.00459608f, 0.03489503f, 
    -0.07009506f, 0.02412437f, -0.06665497f, -0.05841940f, -0.07574962f, -0.02663605f, 0.06243073f, 0.01486148f, 
    -0.02617891f, 0.06270786f, -0.04489838f, -0.04729001f, -0.02048303f, -0.03519858f, -0.01807859f, 0.05403220f, 
    -0.07497569f, 0.03679645f, -0.06157004f, -0.07227848f, 0.03678769f, -0.05555245f, 0.03826928f, 0.05628165f, 
    0.05397310f, 0.06363543f, -0.04869207f, 0.00734966f, 0.02154361f, -0.05732227f, -0.07392295f, -0.07073531f, 
    0.04134743f, 0.00463384f, 0.02693792f, -0.07259241f, -0.03145771f, -0.03038539f, -0.03856970f, 0.04602229f, 
    -0.04599020f, 0.04982789f, 0.00575500f, -0.00263938f, 0.02857934f, -0.06585248f, 0.00679729f, -0.06853134f, 
    -0.04990894f, 0.03132502f, 0.05686205f, -0.07154809f, -0.03639477f, -0.01042106f, 0.00961966f, 0.06571403f, 
    0.03262521f, -0.04921092f, -0.04876275f, -0.05391682f, 0.05395095f, -0.03804319f, -0.06331166f, 0.04413955f, 
    -0.03208162f, 0.02268090f, -0.01680404f, -0.06232168f, -0.07449593f, -0.06097137f, -0.01401338f, -0.01360198f, 
    0.05490607f, -0.02065669f, -0.02716537f, 0.05050921f, 0.01996076f, -0.00899772f, -0.00648582f, 0.04352385f, 
    0.00876651f, 0.05591812f, -0.06620882f, -0.03844565f, 0.01531605f, 0.05499729f, -0.00927381f, 0.05213716f, 
    -0.00360734f, -0.06435883f, 0.00803884f, 0.00826454f, -0.01707669f, 0.00739546f, -0.04145604f, -0.01635440f, 
    -0.04269495f, -0.00464202f, -0.00201971f, -0.07269146f, -0.05408654f, 0.01511767f, -0.05345351f, -0.00900663f, 
    0.02894832f, -0.04902447f, -0.05527598f, 0.03898274f, -0.07151490f, 0.04952720f, 0.01917378f, 0.03595122f, 
    0.00044940f, -0.05842756f, 0.01448534f, -0.00687471f, -0.02908465f, 0.02695999f, -0.07504114f, 0.03354418f, 
    -0.07201596f, -0.01748882f, 0.02116562f, 0.01415342f, -0.02840743f, 0.01668791f, 0.00407720f, -0.03612257f, 
    -0.01900829f, 0.00139814f, -0.05818470f, 0.05631412f, -0.02491214f, -0.06082454f, -0.05417245f, 0.04078456f, 
    0.04506784f, -0.03758724f, -0.03538671f, -0.03974274f, -0.02911439f, -0.01415875f, 0.00315106f, -0.00168962f, 
    0.19257577f, 0.14064565f, 0.15130612f, 0.11576880f, 0.05370586f, -0.09032515f, 0.00292526f, 0.00251892f, 
    -0.00375296f, 0.02468210f, -0.21930823f, -0.11097205f, 0.04831316f, 0.37719828f, 0.16017009f, -0.22835685f, 
    0.23972812f, 0.05805012f, -0.13597369f, 0.00493160f, 0.05367878f, 0.01513357f, 0.16332704f, 0.12734909f, 
    0.16246416f, 0.13005440f, 0.05461039f, -0.28712511f, 0.12657951f, 0.07006735f, -0.02285722f, 0.06540293f, 
    0.07287380f, 0.12025480f, 0.09996899f, 0.05229587f, -0.19316006f, 0.00483970f, -0.07937858f, -0.04675437f, 
    0.00160678f, -0.09022604f, -0.01806188f, -0.02133567f, -0.00026407f, 0.16369365f, -0.07962584f, 0.00758970f, 
    -0.00956471f, 0.15920067f, -0.03282643f, -0.01826464f, -0.08099543f, -0.02483081f, -0.00537878f, 0.05688290f, 
    0.02692092f, -0.04389352f, 0.12486963f, -0.16975076f, -0.14513527f, -0.27419987f, 0.03240617f, 0.05278026f, 
    -0.44073519f, 0.04252782f, 0.06844124f, 0.00295733f, -0.03915961f, -0.07525137f, 0.12740067f, -0.11107294f, 
    -0.16716699f, -0.24410133f, -0.03111175f, 0.30686256f, -0.19595806f, -0.03250789f, 0.13718462f, -0.04050376f, 
    -0.18125612f, 0.00517095f, -0.04949777f, -0.01243514f, 0.39525807f, 0.32337299f, 0.20774928f, -0.09586363f, 
    -0.02274722f, -0.04041540f, 0.15071301f, 0.04868333f, -0.04985288f, -0.03708900f, 0.10047884f, -0.07486086f, 
    0.20983651f, -0.11661920f, -0.21099962f, -0.08111069f, -0.11301430f, -0.04871111f, -0.03443135f, -0.00251851f, 
    -0.04709690f, 0.01024072f, 0.01041339f, 0.03003945f, 0.03936048f, 0.13337497f, -0.04724764f, 0.13792349f, 
    0.13731432f, 0.07260623f, 0.12170319f, 0.00803740f, -0.04260384f, -0.19090253f, -0.05958788f, -0.05009361f, 
    0.17365396f, 0.22412172f, 0.12396201f, 0.14081727f, -0.06205894f, -0.00048051f, 0.05458389f, 0.06508707f, 
    -0.05638733f, -0.04125683f, 0.07332560f, -0.01092350f, -0.56595266f, -0.02358638f, -0.05043774f, -0.12369756f, 
    -0.19002810f, -0.01867328f, 0.03619632f, -0.05265698f, 0.23799449f, -0.15676014f, 0.03804147f, 0.00838330f, 
    -0.46283242f, -0.09301554f, 0.18612824f, -0.00913706f, 0.17960593f, -0.04206618f, -0.07259503f, -0.07888172f, 
    0.01022631f, -0.15985246f, -0.13396081f, -0.00991049f, -0.10005341f, -0.18325728f, 0.09279200f, -0.09747237f, 
    0.07159267f, 0.03234388f, -0.16246080f, 0.01884720f, 0.01609717f, 0.05816854f, 0.05619256f, -0.02304668f, 
    0.13382673f, 0.14327249f, 0.20173717f, 0.29543388f, 0.08784436f, -0.15194903f, -0.04852026f, 0.05306794f, 
    -0.19251528f, 0.03362773f, -0.01709956f, -0.04278873f, -0.18685678f, 0.18569656f, 0.15809137f, -0.03783360f, 
    -0.20264535f, -0.04659525f, 0.05512472f, -0.10934830f, -0.02568915f, 0.19892390f, 0.04175755f, -0.08448202f, 
    0.28536248f, -0.07747916f, 0.05133791f, 0.44043794f, -0.07913367f, -0.04630493f, -0.01009632f, 0.08890635f, 
    -0.12591022f, 0.18602240f, 0.03792275f, 0.09640306f, -0.31434175f, -0.32071033f, 0.25197077f, 0.00375754f, 
    0.06445439f, -0.11537612f, 0.10555737f, 0.18461917f, -0.08940673f, 0.05744215f, 0.10708801f, 0.14892204f, 
    -0.21314433f, -0.04917936f, -0.18184371f, -0.19466206f, 0.14571562f, 0.03509935f, 0.08571623f, -0.04720346f, 
    -0.14943765f, -0.00349681f, -0.08091874f, 0.01522395f, -0.09043871f, 0.01083564f, -0.03353460f, -0.24654396f, 
    -0.06773402f, -0.04615903f, -0.05673846f, -0.02572987f, 0.00889799f, -0.00966919f, 0.07726099f, -0.05564076f, 
    0.13780811f, 0.00438348f, -0.25788194f, 0.23209825f, 0.01324045f, 0.04320382f, 0.16766144f, 0.13989937f, 
    0.08409776f, 0.03909548f, 0.11253012f, -0.08108971f, -0.27913606f, 0.01658752f, 0.16046889f, -0.46256778f, 
    -0.20442653f, 0.03419606f, -0.04893439f, -0.05358172f, 0.00914985f, -0.03900756f, -0.10012518f, 0.07650987f, 
    0.21812657f, 0.22605483f, 0.08792844f, -0.56683373f, -0.06846317f, -0.08811598f, 0.05422954f, 0.07394235f, 
    0.10036585f, -0.00110284f, 0.04484536f, 0.01399633f, -0.36671245f, -0.15780130f, -0.02456795f, 0.29063725f, 
    0.05884235f, -0.11711282f, -0.00294636f, -0.05519252f, -0.08032749f, 0.09869216f, -0.10881459f, 0.00411588f, 
    0.06224642f, -0.00255768f, -0.21294805f, -0.04119609f, 0.25805786f, 0.13509518f, 0.05028762f, 0.09209895f, 
    -0.07553774f, -0.07511162f, -0.07255975f, -0.06261161f, 0.46194360f, -0.28240812f, 0.01025782f, -0.04199566f, 
    0.15016319f, 0.03520641f, 0.07734431f, 0.04059492f, 0.05308145f, 0.03785124f, -0.00247425f, -0.02010257f, 
    0.22135222f, 0.17685394f, -0.02657646f, 0.27036422f, -0.04115961f, 0.04119994f, 0.14225958f, 0.03621428f, 
    -0.08576361f, -0.07089913f, -0.02286418f, 0.06309029f, -0.11247415f, 0.01684852f, -0.10594594f, 0.00135534f, 
    0.03724726f, 0.02601098f, 0.08782706f, 0.01062841f, 0.10328554f, -0.06451698f, 0.05066875f, -0.08720963f, 
    0.07425497f, 0.28582400f, 0.22217302f, -0.06488255f, 0.10362134f, -0.00344689f, -0.00367342f, 0.17830440f, 
    0.05699624f, -0.09665775f, 0.04295219f, -0.09901790f, -0.03327414f, 0.11814422f, -0.10070274f, 0.09520247f, 
    0.03311751f, -0.01600333f, 0.21089423f, -0.01998273f, 0.20466371f, -0.11002961f, -0.01207237f, 0.11103373f, 
    0.38878095f, 0.30356273f, -0.00115025f, 0.10121764f, 0.10966074f, 0.11919880f, 0.21067670f, -0.04423963f, 
    -0.10239205f, 0.14237121f, 0.06762614f, -0.02503922f, -0.11028879f, -0.32093203f, -0.15694426f, 0.19838718f, 
    -0.00003995f, 0.08665577f, -0.03427914f, 0.02612851f, 0.02345583f, -0.04957160f, 0.05667388f, 0.12210834f, 
    0.10795676f, 0.01839807f, -0.01759149f, 0.03204348f, 0.07203801f, -0.14287832f, -0.21379180f, -0.02438768f, 
    0.09552057f, -0.00472471f, 0.15064168f, -0.13682263f, 0.70781469f, 0.07501730f, 0.07548558f, 0.11343043f, 
    0.03758745f, 0.12607554f, 0.09012759f, 0.04779099f, -0.00391518f, 0.09507705f, -0.03461549f, -0.01406871f, 
    -0.01519200f, 0.12380167f, 0.00848916f, -0.27850059f, 0.11435934f, 0.19806397f, -0.09167424f, 0.13254444f, 
    -0.07898974f, -0.04673548f, 0.10915474f, 0.09889613f, 0.07656932f, 0.06128002f, -0.29846901f, -0.16770753f, 
    0.04541771f, -0.18444772f, 0.09400254f, -0.07444689f, -0.02618223f, 0.15853481f, -0.12356762f, -0.03843665f, 
    -0.12795098f, -0.03145671f, 0.24674624f, 0.00256460f, 0.09704237f, -0.04612917f, -0.03722003f, 0.07311932f, 
    -0.00417390f, 0.13457428f, 0.22795422f, -0.16742609f, -0.09619748f, 0.15117402f, -0.10030594f, -0.03629602f, 
    -0.04178125f, -0.25659421f, -0.04559780f, -0.15034644f, -0.07075345f, -0.03689864f, 0.25205526f, 0.01518940f, 
    -0.07535519f, 0.10812538f, -0.15424073f, 0.10897283f, -0.04536434f, -0.32766804f, -0.06202184f, 0.00891307f, 
    0.02157388f, 0.04666933f, -0.08356178f, -0.03293778f, 0.64049739f, 0.15439762f, 0.16021223f, -0.24485499f, 
    0.05303110f, -0.01645167f, -0.00258952f, -0.00982005f, 0.05521366f, 0.10872010f, 0.02961114f, 0.12278040f, 
    0.26032528f, -0.22499281f, -0.27060664f, 0.02190895f, 0.01267831f, 0.03832641f, 0.04403733f, -0.08461084f, 
    -0.04330643f, -0.17156628f, -0.14003716f, -0.16505183f, 0.15525785f, 0.23834985f, 0.08435806f, -0.11738519f, 
    0.07932975f, 0.02331564f, -0.17625876f, 0.13542953f, -0.08298334f, -0.04428256f, 0.01838147f, 0.21757737f, 
    -0.06228610f, 0.05627311f, 0.16244745f, -0.17084806f, -0.20004465f, 0.12496457f, -0.08660287f, 0.12458532f, 
    0.03209596f, -0.23977306f, 0.07244460f, -0.19414301f, -0.08252337f, -0.03290001f, 0.20208360f, 0.03674562f, 
    0.10245719f, -0.24822751f, 0.03435609f, 0.03342051f, 0.05974611f, -0.27788055f, 0.05352763f, -0.17683494f, 
    -0.17012699f, -0.36442530f, 0.11044043f, 0.00748092f, 0.09842388f, -0.03088379f, -0.32226482f, -0.08160860f, 
    0.13939565f, -0.18565702f, -0.11184613f, -0.22839387f, -0.35607773f, -0.27714396f, -0.28425157f, -0.12598304f, 
    0.03233010f, 0.01434438f, -0.12206014f, 0.15050320f, 0.02090921f, -0.05807024f, -0.12283231f, 0.19612287f, 
    -0.04546669f, -0.03946579f, 0.22144717f, 0.12814555f, 0.00198182f, -0.01162496f, -0.11331517f, -0.18032514f, 
    -0.14584149f, 0.25281921f, 0.10425804f, 0.03857282f, -0.02654673f, 0.07289799f, 0.16228592f, -0.23993739f, 
    0.03380348f, 0.19312437f, 0.17985031f, 0.06558671f, -0.00499736f, 0.32421339f, 0.10185088f, 0.23321895f, 
    0.04951812f, -0.09223068f, -0.22065437f, 0.15780778f, -0.13801672f, -0.01416154f, -0.01861452f, 0.13218467f, 
    -0.21440563f, -0.00804417f, -0.00974954f, 0.04125101f, 0.08887555f, -0.33948112f, 0.18003376f, 0.08163909f, 
    -0.10548613f, -0.04041696f, 0.14730653f, 0.10218807f, -0.06660906f, 0.11100806f, 0.10159718f, 0.14855289f, 
    -0.50896931f, -0.07213525f, -0.04176707f, 0.02310341f, -0.04371025f, -0.01293320f, -0.12538914f, 0.01123939f, 
    -0.15788072f, 0.04890100f, 0.07812537f, 0.01839831f, -0.07728121f, 0.11689614f, -0.00696218f, -0.13157713f, 
    0.12058163f, -0.05288084f, 0.00629854f, -0.03381950f, 0.03805446f, -0.00530905f, 0.09450702f, -0.04055260f, 
    -0.05743877f, -0.16066991f, -0.00853077f, 0.12867874f, 0.08150643f, 0.09159415f, 0.15737021f, 0.13388094f, 
    0.18698102f, 0.01942701f, 0.07672348f, -0.05807550f, -0.23262517f, 0.12283890f, 0.14927727f, -0.23357208f, 
    0.12607822f, 0.03417941f, 0.24212006f, 0.06354680f, -0.06746309f, -0.07980312f, -0.01907300f, 0.00864740f, 
    0.10502568f, 0.19681895f, -0.09590980f, -0.42393899f, 0.09352773f, 0.10759438f, 0.08597527f, 0.05429738f, 
    0.00444322f, 0.07327087f, 0.00625153f, 0.10249021f, 0.07178912f, -0.07548753f, 0.06723502f, 0.05156779f, 
    0.05773941f, -0.02467664f, -0.17719856f, -0.07428560f, -0.05450713f, 0.10162903f, -0.01423784f, -0.01894102f, 
    -0.07172561f, -0.12459524f, -0.22481479f, 0.20895182f, 0.14539325f, 0.13958116f, 0.13376901f, 0.01101644f, 
    0.12822928f, -0.00973864f, 0.03091383f, -0.06639608f, 0.17712910f, -0.14744444f, 0.16611415f, -0.20640631f, 
    0.10244947f, 0.19658947f, -0.14251794f, 0.13884872f, -0.03393156f, -0.03195035f, -0.06296536f, 0.09374892f, 
    0.04539657f, 0.18672110f, 0.16245823f, 0.03616541f, -0.03060421f, 0.13240515f, 0.04202287f, 0.03268429f, 
    -0.11109950f, -0.05987233f, -0.08010282f, -0.12424679f, 0.09999570f, 0.05592576f, -0.00025606f, -0.03559468f, 
    -0.01542246f, -0.03381207f, 0.05556215f, 0.05627329f, -0.01121589f, -0.04774163f, 0.12822674f, 0.00572750f, 
    0.09960897f, 0.06269147f, 0.27314106f, 0.22861585f, 0.08519200f, -0.02237296f, -0.02837636f, 0.01486788f, 
    -0.03853271f, -0.18413028f, -0.00944893f, -0.18884519f, -0.17287219f, 0.20685053f, -0.03617113f, 0.06003945f, 
    0.05760141f, 0.09141106f, 0.06252676f, -0.02364649f, 0.03352681f, 0.08142315f, 0.06439433f, 0.22661476f, 
    0.12294345f, -0.05512858f, 0.03909648f, 0.00560670f, -0.02963555f, 0.05898759f, 0.06781655f, 0.00339882f, 
    -0.08432669f, 0.09189670f, 0.01440778f, 0.04514584f, -0.15610862f, -0.22577465f, 0.08839079f, 0.08252710f, 
    0.14219914f, 0.15557459f, -0.03605499f, 0.14286107f, 0.07485787f, 0.04859432f, 0.13072519f, 0.26831004f, 
    0.22628488f, -0.03104292f, 0.19428207f, 0.05044373f, 0.16754195f, 0.20798045f, 0.11363088f, 0.07814108f, 
    0.11973839f, 0.12003410f, -0.14791426f, 0.15109572f, -0.47402930f, 0.09475096f, -0.18645951f, -0.29462889f, 
    -0.01543234f, 0.07219338f, -0.08743976f, 0.06512848f, 0.03798029f, 0.06655869f, 0.03753008f, -0.07582064f, 
    0.20303932f, 0.14500667f, -0.30158591f, -0.15726697f, -0.14933878f, -0.06796051f, 0.05321877f, -0.05902897f, 
    0.07980328f, 0.07276273f, -0.09019903f, 0.08733849f, -0.36448959f, -0.12442226f, -0.11945746f, 0.09876950f, 
    0.10448320f, -0.01579768f, 0.01562670f, -0.08104029f, 0.00712909f, -0.00502516f, 0.02457911f, 0.05727825f, 
    0.38183883f, -0.06715705f, -0.24560288f, -0.24745549f, -0.11097610f, -0.15109761f, -0.01183137f, -0.04380917f, 
    0.05970578f, -0.10955603f, -0.06452423f, 0.07154991f, -0.22808626f, -0.25294432f, -0.13360435f, -0.11192643f, 
    -0.20151447f, 0.05841321f, -0.13273136f, -0.00766523f, 0.02732047f, 0.03976188f, -0.09794392f, 0.02975539f, 
    0.34340847f, -0.21391088f, 0.22720267f, 0.00372758f, -0.10895243f, -0.00173598f, -0.04930571f, 0.04430801f, 
    -0.01270366f, 0.03000329f, 0.08932912f, 0.11008003f, -0.47102162f, -0.09438986f, 0.00414654f, 0.10396381f, 
    -0.13639018f, 0.09819520f, -0.04543131f, -0.00182335f, 0.02939316f, 0.02948525f, 0.11089783f, -0.00584069f, 
    0.12635055f, -0.01301663f, -0.29932418f, -0.33056682f, 0.04374302f, -0.11285240f, -0.01230653f, 0.00780929f, 
    -0.14381862f, 0.07757431f, 0.02092575f, 0.00517746f, -0.20301767f, 0.10330097f, -0.16584229f, 0.25852650f, 
    -0.02515805f, -0.05884124f, 0.03213549f, -0.06815911f, 0.07776873f, -0.04042990f, 0.02114941f, -0.05989976f, 
    0.34524491f, -0.12721036f, 0.03166890f, 0.26200005f, 0.20746045f, 0.00505011f, 0.03377003f, -0.00362101f, 
    -0.00006455f, 0.01008449f, 0.05689079f, 0.13440515f, 0.08660062f, 0.23170321f, 0.01660935f, 0.01982316f, 
    0.07981967f, 0.08827999f, -0.00118536f, 0.13634905f, -0.08313950f, 0.08155210f, -0.03566094f, 0.09489629f, 
    -0.02644957f, 0.26859653f, -0.26895127f, -0.05521927f, 0.12099676f, -0.07275035f, 0.10180054f, 0.09266242f, 
    -0.08350994f, -0.00277791f, -0.03016394f, -0.06575775f, 0.26284429f, -0.09378397f, 0.13665028f, 0.03126837f, 
    0.00235189f, 0.09877159f, 0.04976354f, 0.09588557f, 0.07408316f, -0.03286543f, 0.05359682f, -0.03927644f, 
    0.16934334f, 0.12294003f, -0.20427385f, -0.00011587f, 0.14366993f, 0.08566123f, 0.25175947f, 0.05413639f, 
    0.08906362f, -0.05664354f, -0.11313070f, 0.01308198f, -0.11277524f, -0.01012615f, -0.22901674f, -0.14333035f, 
    -0.07895263f, -0.05267649f, -0.21593253f, 0.06450934f, -0.01803868f, -0.05321933f, -0.07388200f, -0.24971192f, 
    0.20357138f, -0.11364349f, 0.12699494f, -0.12318958f, 0.02407817f, 0.02109585f, 0.17657582f, 0.24995139f, 
    -0.00289855f, -0.04713203f, 0.05430060f, 0.02332047f, 0.46253952f, -0.29748660f, 0.09562171f, -0.15920478f, 
    0.00020893f, -0.01544922f, 0.03370575f, -0.05224032f, 0.06296636f, 0.16409747f, 0.02243210f, 0.04999778f, 
    -0.35662723f, 0.11546314f, -0.36511204f, -0.15316430f, 0.05894982f, 0.02427204f, -0.11310706f, 0.07801877f, 
    0.04540592f, 0.03986911f, 0.00163101f, 0.07975448f, -0.67960215f, -0.05045640f, -0.13968490f, 0.15065289f, 
    0.12628107f, -0.02713161f, -0.06538690f, -0.08587154f, 0.04351887f, 0.06621162f, -0.12167902f, -0.02998723f, 
    -0.10305647f, -0.30387709f, 0.13309054f, -0.10168563f, -0.02103186f, 0.13214526f, 0.04506506f, 0.09581669f, 
    0.13522135f, -0.05092315f, 0.07031650f, -0.02424626f, 0.16293262f, 0.23987241f, -0.03773776f, 0.31041560f, 
    -0.09104967f, 0.01190562f, 0.01077204f, 0.08913739f, 0.02657314f, 0.06878445f, 0.04646396f, -0.02358920f, 
    0.08175971f, 0.38389954f, 0.09469571f, -0.06648494f, -0.21562916f, 0.03670882f, 0.07966337f, 0.09012357f, 
    -0.01721395f, 0.04854735f, -0.04014318f, 0.05329585f, -0.23323806f, -0.30628517f, 0.18104385f, -0.16296482f, 
    -0.01766406f, -0.08372878f, 0.05545050f, -0.05404215f, 0.06065541f, -0.02319036f, 0.04533991f, 0.03304156f, 
    0.03409950f, -0.36730972f, -0.20593536f, 0.04402079f, 0.16322966f, 0.09218825f, 0.05547473f, 0.16528666f, 
    -0.02830412f, 0.05399162f, 0.02732010f, -0.03669335f, -0.00419908f, 0.29299352f, -0.11576675f, 0.12528583f, 
    0.09769242f, 0.05497028f, -0.01131585f, -0.02746571f, -0.01890046f, -0.03758476f, 0.10026589f, 0.02711160f, 
    -0.16790663f, -0.03132039f, 0.23148160f, 0.04015397f, -0.10478292f, 0.15951499f, 0.08860833f, -0.03692951f, 
    0.02123020f, -0.03856993f, 0.11511848f, 0.08799100f, -0.19189963f, 0.30575186f, 0.17284366f, -0.03193675f, 
    0.08471499f, -0.02810994f, 0.11616463f, -0.04060855f, -0.00072467f, -0.04614111f, 0.09427266f, -0.02770798f, 
    -0.25956261f, -0.12906453f, 0.17203294f, -0.00225526f, -0.12256570f, 0.01487457f, -0.05905478f, 0.03336201f, 
    0.19093700f, -0.01731802f, -0.06585304f, -0.01697788f, -0.35108009f, -0.07303093f, 0.01573310f, -0.13585004f, 
    -0.06531353f, -0.03270213f, -0.01375491f, 0.04921734f, -0.09320233f, -0.01885953f, -0.01654929f, 0.08725269f, 
    -0.30187002f, -0.14486918f, 0.00909641f, 0.25060973f, -0.14748099f, 0.11213166f, 0.08165372f, 0.02404632f, 
    0.09427517f, 0.05702432f, -0.07498454f, -0.04261629f, -0.06267239f, 0.03524913f, 0.24717379f, -0.07974480f, 
    -0.02545570f, 0.04384758f, 0.03690101f, -0.06368990f, -0.03290526f, 0.15395057f, 0.02405583f, 0.00417804f, 
    -0.01615373f, 0.00256978f, -0.16492851f, -0.16383141f, -0.13040271f, 0.00948354f, 0.11934055f, 0.21969759f, 
    -0.15530096f, 0.08147894f, 0.17864211f, 0.00264535f, 0.05902046f, -0.57010072f, 0.07239354f, 0.26610240f, 
    -0.07063999f, -0.12366921f, 0.01954974f, 0.05745827f, -0.04837579f, 0.13049172f, 0.00259823f, 0.03086718f, 
    -0.45824912f, -0.35363498f, -0.14488460f, 0.04905124f, -0.00780127f, 0.02135321f, -0.08470819f, -0.02345443f, 
    -0.15973063f, -0.01496172f, -0.10816285f, -0.02122077f, -0.34825888f, -0.02416193f, -0.13247749f, -0.02929370f, 
    0.01078855f, -0.06163618f, -0.06078531f, 0.01093990f, 0.03049837f, -0.02693198f, 0.08276020f, -0.07075818f, 
    -0.25926238f, 0.04770899f, -0.04829943f, 0.26746345f, 0.16736679f, 0.04556110f, 0.00790163f, 0.03647292f, 
    0.10536797f, -0.06304783f, 0.05513479f, 0.06814978f, 0.18325858f, 0.49283057f, 0.15541896f, 0.24191132f, 
    0.17565326f, -0.06948685f, 0.01744234f, 0.04789215f, 0.03550279f, 0.10750853f, 0.03512521f, 0.12163057f, 
    -0.22980618f, 0.58726078f, 0.10700340f, -0.57111716f, 0.06997029f, -0.10614974f, -0.04438259f, 0.13491553f, 
    0.03748678f, -0.15397322f, 0.07726642f, 0.01747943f, -0.24275118f, -0.13499992f, -0.11734759f, -0.15907308f, 
    0.19934222f, -0.02364525f, 0.15638953f, -0.08847909f, 0.04404502f, 0.09275513f, -0.15383045f, 0.08333385f, 
    -0.13638070f, -0.12709770f, 0.02087259f, 0.17904107f, 0.07144602f, 0.12447394f, 0.12988335f, 0.22540964f, 
    0.06922197f, 0.05511872f, 0.14439671f, -0.02535044f, 0.43423113f, -0.05985750f, -0.03200862f, -0.18819776f, 
    0.00578525f, -0.12150807f, -0.00936059f, 0.09541923f, -0.07035822f, 0.08971355f, 0.01846584f, 0.09181616f, 
    -0.31661576f, -0.03649122f, 0.02190731f, -0.15326129f, -0.02446279f, 0.05971395f, -0.04075918f, 0.15314879f, 
    0.09088445f, 0.01401945f, 0.09594724f, -0.04220611f, 0.27620313f, 0.21825573f, -0.27677792f, 0.09600071f, 
    0.19463105f, -0.16493599f, -0.01642038f, 0.01025864f, 0.05700267f, 0.03223442f, 0.00187341f, -0.04177826f, 
    -0.03286993f, 0.08318266f, 0.31636438f, -0.06297328f, -0.05516601f, 0.10380201f, -0.00026053f, 0.00920455f, 
    0.13846326f, 0.11223581f, 0.04870564f, 0.08220416f, -0.21143137f, 0.31817165f, -0.29357666f, 0.10676534f, 
    -0.04167224f, -0.13942052f, 0.02932742f, -0.03812024f, 0.06878061f, -0.05436368f, -0.11476481f, 0.15332192f, 
    -0.13294448f, -0.13699618f, -0.00704615f, -0.10266022f, -0.10788805f, 0.29225686f, 0.03215680f, 0.10359395f, 
    0.15511408f, -0.00416959f, 0.03234783f, 0.06130513f, 0.36473039f, -0.23200786f, 0.10690746f, 0.03335256f, 
    0.11758683f, 0.07937236f, 0.02990226f, -0.13894479f, -0.05911124f, 0.00217839f, 0.10045531f, 0.27899721f, 
    0.14532472f, 0.28587478f, -0.36220765f, -0.03744470f, 0.02390903f, -0.11417477f, 0.01809757f, -0.00878372f, 
    -0.05520150f, 0.01961287f, 0.04439998f, 0.06665409f, -0.32301170f, 0.22586970f, 0.04632349f, -0.06153973f, 
    -0.04333534f, -0.04372710f, 0.00568759f, 0.09659722f, 0.03955797f, 0.16722594f, 0.15667053f, 0.14761448f, 
    -0.15141870f, -0.20468792f, 0.19495444f, 0.30035275f, -0.18282992f, -0.07191443f, -0.16831881f, 0.14637557f, 
    -0.15937005f, -0.16292571f, -0.05209128f, 0.07608691f, -0.29399413f, -0.03577511f, 0.03505377f, 0.10362057f, 
    -0.06005319f, 0.10737658f, -0.05503730f, 0.03986353f, -0.10922790f, -0.02366670f, 0.00277328f, 0.02788091f, 
    0.25570643f, 0.13220932f, -0.17934819f, 0.09458388f, -0.15933599f, -0.11234616f, 0.08207190f, 0.07422090f, 
    -0.09752006f, -0.06095842f, 0.22898515f, -0.06530006f, 0.40791538f, 0.17372623f, 0.08243397f, 0.21863963f, 
    0.23296551f, -0.08741070f, 0.13380750f, -0.07525089f, -0.02287023f, 0.09638617f, 0.08900627f, 0.05080513f, 
    -0.33204666f, -0.11487188f, 0.32671690f, 0.13798249f, 0.19934843f, 0.11584306f, -0.07525944f, -0.01305110f, 
    0.12796803f, -0.10993269f, 0.04178983f, -0.11574753f, 0.25382546f, 0.17990784f, 0.10171027f, -0.44010997f, 
    0.04806834f, -0.07921822f, -0.11874612f, 0.05777394f, 0.17066208f, -0.05810143f, -0.11066031f, -0.01755297f, 
    0.20568140f, 0.28336242f, 0.15385990f, 0.21195348f, -0.18817592f, 0.20414259f, 0.09802638f, 0.04734127f, 
    0.10540748f, 0.00761633f, 0.14921238f, -0.03414900f, -0.11742295f, -0.05743589f, -0.10886740f, -0.23402864f, 
    -0.19479261f, 0.07792934f, -0.01345622f, 0.29466608f, -0.00962831f, 0.09434458f, -0.07774411f, 0.05808045f, 
    0.10883629f, 0.14950770f, -0.10209094f, -0.01399573f, 0.06548064f, 0.10566246f, -0.15180556f, 0.00195803f, 
    0.07450956f, 0.02224528f, -0.00572938f, -0.24273093f, 0.07290131f, 0.10743457f, -0.15505730f, -0.26023263f, 
    -0.15607004f, -0.16608870f, -0.18750043f, 0.00344471f, -0.14001757f, 0.09787350f, -0.08223625f, 0.10015094f, 
    -0.61508316f, -0.01978066f, 0.00143178f, 0.11012428f, 0.09457739f, -0.16121419f, -0.03057877f, -0.10670877f, 
    0.02363514f, -0.08663391f, -0.15114054f, -0.06985147f, 0.26793677f, 0.13462393f, -0.04916555f, 0.15492405f, 
    0.05686193f, -0.10776173f, 0.00024971f, 0.10222528f, -0.07585798f, -0.00302113f, -0.15477856f, 0.02218904f, 
    -0.04483118f, 0.11445448f, -0.06500924f, 0.00480188f, -0.12777996f, 0.30469537f, -0.01853209f, 0.16301396f, 
    0.18438627f, -0.01209564f, -0.03292055f, 0.20140433f, -0.03428823f, -0.13442804f, 0.14641911f, -0.11102904f, 
    -0.07284618f, 0.05716313f, -0.00019364f, 0.16603284f, 0.00368781f, 0.18610840f, 0.08497235f, -0.15543877f, 
    0.01695422f, -0.03110238f, -0.01596279f, -0.07649551f, 0.03405410f, -0.03851380f, -0.06928704f, -0.02307628f, 
    -0.00532275f, 0.01214918f, 0.04407845f, 0.02753969f, 0.03666565f, 0.05071817f, 0.02721483f, 0.02717401f, 
    -0.03509440f, 0.03520118f, 0.06361324f, 0.01016607f, -0.04891090f, 0.00960107f, -0.07383332f, -0.02643279f, 
    0.03318772f, -0.00278886f, -0.04121284f, 0.03594815f, -0.02911594f, -0.00281541f, 0.02498282f, 0.00157330f, 
    0.05793208f, 0.01964417f, -0.01794570f, -0.03085653f, -0.04067545f, 0.01310284f, 0.06158254f, -0.04410232f, 
    -0.01378938f, -0.05728333f, -0.04133024f, -0.02327863f, 0.03897797f, 0.01231832f, -0.05839485f, -0.05666683f, 
    -0.05150532f, -0.05083213f, 0.01297900f, -0.06409774f, -0.01429692f, 0.05300592f, -0.01522067f, 0.02988366f, 
    -0.02729912f, 0.02740681f, -0.06595121f, -0.03128086f, 0.03341935f, -0.04743534f, -0.01180570f, -0.05981507f, 
    -0.05648553f, 0.05516373f, 0.04171153f, -0.07504308f, -0.06056217f, 0.03661332f, -0.08065978f, -0.00017940f, 
    0.05904626f, -0.04439509f, 0.00977590f, 0.03597326f, -0.00526396f, -0.04937867f, 0.01463179f, -0.07358264f, 
    -0.07815422f, 0.02708524f, 0.04936982f, -0.04663435f, 0.01887096f, -0.05968647f, -0.04903745f, 0.00436578f, 
    -0.00824982f, 0.03605849f, -0.00792839f, 0.02652134f, 0.03296249f, 0.04298431f, -0.03595265f, -0.05425761f, 
    -0.03114051f, -0.00651010f, -0.02332098f, -0.06707080f, 0.05207803f, -0.08398013f, -0.07284052f, 0.04392974f, 
    -0.01696429f, -0.02270512f, -0.02693270f, -0.08257598f, -0.03799659f, 0.05306194f, 0.03298173f, -0.01031844f, 
    0.06456648f, -0.05734202f, 0.05167916f, -0.07650262f, -0.05325669f, 0.05334808f, 0.02352588f, -0.00037243f, 
    0.00325289f, -0.04297997f, -0.04104069f, -0.06245802f, -0.07678997f, 0.00292502f, -0.00278227f, -0.03122579f, 
    -0.00309436f, -0.04024071f, 0.03102268f, 0.02370742f, 0.00313997f, 0.04107848f, 0.06387040f, -0.00617081f, 
    -0.02279297f, -0.06154455f, 0.05442604f, 0.02551471f, 0.01056283f, -0.05360725f, -0.03231239f, -0.06070507f, 
    -0.02740407f, 0.06981684f, -0.01147841f, 0.03778027f, 0.00622861f, -0.06873983f, 0.04651663f, 0.04655841f, 
    0.06483839f, -0.02168420f, -0.01706208f, -0.05531915f, -0.05984235f, 0.02459632f, -0.07610071f, 0.04341985f, 
    0.00901549f, 0.00490671f, 0.03488979f, 0.05019155f, -0.02559654f, -0.07074912f, 0.05578913f, -0.01331521f, 
    0.06276157f, 0.02931979f, -0.07810015f, 0.00463548f, 0.01091666f, 0.05648632f, -0.04082583f, 0.05757219f, 
    0.03089930f, -0.05738052f, -0.06946839f, -0.01734219f, -0.06720360f, 0.01580188f, 0.05123659f, -0.01435895f, 
    -0.01542521f, 0.02244473f, 0.01798861f, -0.01993646f, -0.06120677f, 0.04425487f, 0.05549864f, 0.05377295f, 
    0.02310129f, 0.24576002f, -0.06978143f, 0.28178266f, -0.05934830f, 0.05563748f, -0.22571804f, -0.02419690f, 
    -0.10057379f, 0.02984748f, -0.03151872f, -0.01207513f, -0.17597848f, -0.07689331f, 0.20691015f, 0.10696369f, 
    -0.09515315f, -0.05072638f, -0.03477818f, 0.20564343f, -0.16219983f, 0.01688153f, -0.08642943f, 0.16916665f, 
    0.04070548f, -0.18181591f, 0.29479933f, -0.09249439f, 0.00255074f, -0.06695130f, 0.08739723f, -0.15531522f, 
    -0.08760741f, 0.06908125f, 0.13089661f, -0.01053438f, 0.11909951f, 0.01507300f, 0.14919373f, -0.18380250f, 
    0.07625398f, -0.08121248f, 0.22255220f, -0.07674195f, -0.00683686f, 0.19365664f, 0.13303620f, 0.11978199f, 
    -0.01111703f, 0.18222477f, -0.01216333f, 0.41426826f, 0.05647188f, -0.11149828f, -0.06345016f, 0.07719833f, 
    0.06491879f, 0.08548734f, 0.16471207f, -0.08253572f, -0.67358136f, -0.19911455f, -0.16005236f, -0.31297228f, 
    0.07141355f, -0.08932846f, 0.14977288f, -0.06424808f, -0.09599451f, -0.31110397f, 0.06458762f, 0.04990659f, 
    -0.19782069f, -0.12441125f, -0.21177469f, -0.18551782f, 0.31631792f, -0.17485590f, 0.08195376f, -0.06106112f, 
    0.10433188f, -0.01405561f, 0.01459051f, 0.10095901f, 0.39116558f, 0.24670301f, 0.16982906f, 0.25442591f, 
    0.08267240f, 0.04115329f, -0.10256939f, -0.00483882f, 0.05019140f, -0.06133518f, 0.05793950f, 0.05222666f, 
    -0.08068217f, 0.13210106f, -0.08784597f, 0.00264130f, -0.17318897f, -0.02632935f, 0.00555131f, -0.18718828f, 
    0.00182038f, -0.04274574f, -0.09369296f, 0.00216818f, 0.99004275f, -0.29900399f, 0.13693477f, 0.12233751f, 
    0.06987069f, 0.07101924f, 0.05047346f, -0.01214299f, -0.04423210f, -0.05316040f, -0.00283001f, 0.07847946f, 
    0.31930479f, 0.28995365f, -0.10526221f, 0.02939110f, -0.02074882f, 0.03680794f, 0.02955499f, 0.26520726f, 
    0.11571025f, -0.11116380f, -0.04918398f, -0.18907271f, 0.09916940f, -0.24891451f, -0.12142414f, 0.15895413f, 
    -0.06141509f, -0.25390983f, 0.10759846f, -0.04152033f, 0.17036949f, -0.01058538f, 0.11914471f, 0.01886356f, 
    -0.18196733f, 0.07280321f, 0.29168791f, 0.14363781f, 0.17236459f, 0.02428782f, -0.11544149f, 0.17984925f, 
    0.19671755f, 0.06793583f, -0.10803016f, -0.09853853f, -0.01316893f, 0.06583759f, -0.34662044f, 0.22715549f, 
    0.18705586f, 0.17065345f, 0.03961390f, -0.21995348f, 0.31324989f, 0.29626235f, 0.12217826f, 0.03038280f, 
    0.01486446f, 0.16744839f, 0.13346355f, -0.02095795f, -0.09360737f, 0.04502425f, -0.05009587f, -0.10343068f, 
    -0.17356156f, 0.15172502f, 0.05577608f, 0.08257242f, 0.39503059f, -0.12824813f, 0.06697801f, -0.05120129f, 
    0.08889820f, 0.15287925f, 0.07813801f, 0.10500719f, -0.04850473f, 0.07864709f, 0.12585962f, 0.03892635f, 
    -0.04578484f, -0.01967785f, 0.00023676f, 0.03205651f, -0.01526637f, -0.07825083f, 0.02956510f, -0.04500889f, 
    0.02322882f, -0.05150355f, 0.02891136f, -0.07421383f, -0.07331937f, 0.03761894f, -0.04805399f, -0.06350719f, 
    0.03477798f, 0.06192166f, -0.01005041f, -0.06133565f, 0.03672193f, -0.01714575f, 0.01627328f, -0.05664793f, 
    0.01714087f, -0.05539893f, 0.05022231f, -0.03069948f, -0.06277103f, 0.01577266f, 0.01744041f, -0.06549221f, 
    0.05369354f, -0.05801238f, -0.02138363f, -0.07913934f, -0.06315430f, -0.04461930f, 0.04553500f, 0.04083708f, 
    0.00233716f, 0.06162404f, 0.01244280f, 0.05740878f, -0.02108614f, -0.04486441f, 0.05235997f, -0.07822699f, 
    -0.02913500f, -0.07072929f, -0.05334411f, 0.04671638f, -0.01216908f, -0.05004704f, -0.06690225f, -0.03766488f, 
    0.00857428f, -0.00942283f, -0.04598515f, -0.03488840f, 0.01900206f, -0.00693387f, -0.00149533f, 0.00145969f, 
    -0.02528594f, 0.02259570f, -0.02232560f, 0.06254311f, -0.04649722f, -0.00883444f, -0.01651886f, -0.03397086f, 
    0.04972972f, 0.00491366f, -0.02969366f, 0.04478383f, 0.01511620f, -0.03386325f, 0.02228979f, -0.06777849f, 
    -0.05028462f, -0.07071856f, 0.05263015f, 0.03107368f, 0.01498174f, 0.00260689f, -0.00789948f, -0.00621401f, 
    -0.04972754f, 0.00157025f, -0.06239525f, -0.06483538f, 0.03117828f, -0.06095373f, -0.05103602f, 0.01879982f, 
    0.05622797f, -0.01461721f, 0.03734453f, -0.03815298f, -0.00510223f, 0.02504241f, -0.03110009f, -0.00542476f, 
    -0.01915712f, -0.07360692f, -0.03074671f, -0.03602880f, 0.03784818f, 0.00091976f, -0.01014682f, -0.07991652f, 
    0.05168248f, -0.03242325f, -0.04159169f, 0.05174778f, 0.02121469f, -0.08074238f, 0.01623947f, 0.02304041f, 
    0.01572515f, 0.05223521f, 0.02979008f, 0.04229702f, 0.00450876f, -0.01137328f, 0.05290681f, 0.03670269f, 
    -0.03550156f, -0.03832846f, 0.01869947f, -0.02020520f, 0.00773794f, -0.07235929f, 0.03054144f, 0.05504473f, 
    0.04210975f, -0.03591616f, -0.07442974f, 0.01247789f, -0.02163885f, 0.04184522f, -0.06545844f, -0.06468225f, 
    -0.05288324f, -0.05450375f, -0.05252221f, -0.03238618f, 0.05996976f, 0.04649446f, 0.01248582f, 0.01358392f, 
    0.06315457f, -0.04116474f, -0.03640207f, 0.04570130f, -0.05649653f, -0.06962207f, 0.00908902f, 0.00712878f, 
    0.05769837f, 0.04446311f, 0.00416443f, 0.01286787f, 0.01376701f, 0.03986935f, -0.08084397f, 0.01744675f, 
    -0.02623641f, -0.04424947f, 0.03826804f, -0.05794931f, 0.03022282f, 0.03304433f, 0.00715059f, -0.03325639f, 
    0.05433713f, -0.00100838f, -0.04166474f, 0.05262070f, 0.01163545f, -0.05969407f, 0.04942033f, -0.04685539f, 
    0.04561495f, -0.07702319f, 0.02425582f, 0.05192911f, 0.02898911f, 0.01030901f, 0.02664998f, -0.05994119f, 
    -0.05409579f, -0.03834947f, 0.07065601f, 0.29385296f, -0.02825587f, -0.03406376f, -0.10281315f, 0.02565642f, 
    0.01140081f, -0.12385786f, -0.01662752f, 0.01647045f, 0.13590333f, -0.07185008f, -0.02363401f, 0.17495418f, 
    0.11506594f, 0.12015325f, -0.09247765f, -0.02886512f, -0.05190278f, -0.01288157f, -0.06163041f, -0.05783669f, 
    -0.23985291f, 0.09353300f, -0.11147294f, -0.18271703f, -0.02959209f, 0.02709026f, 0.04138725f, -0.05654672f, 
    -0.09595090f, 0.09429381f, 0.00060924f, -0.09443970f, 0.10713258f, 0.30237791f, 0.07097426f, -0.12349518f, 
    0.09622426f, -0.02263938f, 0.06231467f, 0.04795546f, 0.00694484f, -0.14095423f, 0.07171352f, -0.00359780f, 
    -0.00544765f, -0.22094169f, 0.13838816f, -0.17552477f, 0.18016183f, 0.07004318f, 0.11711743f, -0.13115451f, 
    0.07018386f, 0.18809190f, -0.04421438f, 0.06788254f, -0.13078146f, 0.06283221f, 0.27651119f, -0.37310195f, 
    0.11032318f, 0.03163443f, 0.02664287f, 0.06794737f, 0.00628317f, -0.03365758f, -0.08247577f, 0.00140814f, 
    0.67969930f, -0.06136743f, -0.12533489f, 0.02728803f, 0.04265468f, 0.01134994f, 0.07912529f, 0.02168483f, 
    0.04362472f, 0.05318831f, 0.06325007f, 0.07085122f, -0.00097510f, -0.43010941f, 0.05164540f, 0.41408324f, 
    -0.02748397f, 0.03352249f, -0.06209565f, -0.05140263f, 0.00552486f, 0.08527988f, 0.02331146f, -0.01330712f, 
    -0.35585994f, 0.05522726f, -0.10637543f, -0.03238288f, 0.06706291f, 0.09265669f, -0.02052825f, -0.15504143f, 
    0.14076191f, -0.08204329f, -0.03373761f, 0.18068346f, -0.33492228f, -0.12472531f, 0.37095031f, -0.06417467f, 
    0.07105253f, 0.07182360f, -0.07930474f, -0.05895543f, 0.15352488f, -0.02558480f, -0.02445859f, -0.07626726f, 
    0.16961072f, -0.15001751f, 0.01273341f, 0.12416055f, 0.09489897f, 0.00373363f, 0.10950303f, -0.06320816f, 
    0.00239542f, 0.00221748f, 0.00134465f, 0.08531720f, 0.04403236f, -0.21074179f, 0.39564058f, 0.02641091f, 
    -0.00342404f, 0.09028168f, 0.02935909f, -0.12079137f, -0.02480344f, -0.02274948f, 0.08787454f, -0.06567357f, 
    0.37850547f, 0.10930192f, -0.13972118f, 0.15957122f, 0.07023861f, 0.02613910f, 0.23198348f, -0.01682046f, 
    -0.07134663f, -0.12516233f, 0.06741853f, -0.01037743f, -0.06031769f, -0.00746699f, 0.01821010f, 0.02640371f, 
    -0.02165152f, 0.11089630f, 0.14927931f, -0.19011389f, -0.08519598f, 0.11641614f, 0.11834610f, 0.09534749f, 
    -0.03384700f, 0.10802949f, -0.00587536f, -0.26070887f, -0.01237017f, -0.15057042f, -0.04312664f, -0.12869020f, 
    -0.02880970f, 0.13240029f, -0.01509980f, 0.08807353f, -0.22203298f, -0.11882304f, -0.30214861f, 0.19679789f, 
    -0.07360203f, 0.00347061f, -0.19624026f, 0.04184866f, 0.08331530f, -0.12527224f, 0.02929109f, 0.09875019f, 
    0.00785753f, -0.06737365f, 0.01695412f, 0.00886831f, 0.03634525f, 0.01469802f, -0.07788661f, 0.04119874f, 
    -0.03035516f, 0.04689272f, -0.02873188f, -0.07119091f, 0.02118759f, -0.03714141f, -0.03364787f, -0.02128921f, 
    -0.02023717f, -0.08223283f, -0.06014987f, -0.07633372f, -0.03591514f, -0.06678234f, 0.01843634f, -0.03497116f, 
    -0.08039781f, -0.05470125f, 0.05634725f, 0.04854413f, 0.05613329f, -0.00771255f, -0.05323732f, -0.04517017f, 
    -0.01197509f, -0.06023825f, -0.01560874f, -0.02194494f, 0.01580452f, 0.04234605f, -0.04465618f, -0.03525453f, 
    -0.02239025f, -0.06076041f, 0.00370892f, -0.04474460f, 0.04282689f, -0.00747312f, -0.02856671f, -0.05979111f, 
    0.04828466f, -0.04552108f, -0.04194058f, -0.01970189f, -0.02698872f, -0.00475551f, -0.08023506f, -0.03989762f, 
    0.00175625f, -0.00120100f, -0.05460074f, 0.05068319f, 0.04992038f, -0.08123590f, 0.04703880f, -0.05924791f, 
    -0.05838723f, -0.08456668f, -0.03439047f, 0.01027828f, 0.04811136f, 0.03716676f, -0.06680579f, -0.07793306f, 
    0.00919090f, 0.06002622f, -0.05463991f, -0.01035809f, 0.03597634f, -0.06916584f, 0.02319973f, -0.00111563f, 
    0.01639066f, -0.03800163f, 0.00279752f, -0.00116366f, -0.04926385f, -0.03032188f, -0.03236873f, 0.01003239f, 
    0.00401662f, -0.02371272f, -0.00782737f, 0.04940786f, -0.00115871f, 0.01872678f, -0.03557544f, 0.05834212f, 
    0.02629146f, -0.02158134f, -0.07657471f, -0.07214348f, -0.05612984f, 0.04553815f, -0.03286307f, -0.05713935f, 
    -0.02831668f, -0.03682495f, 0.02381466f, 0.01510306f, -0.05468156f, 0.01557249f, 0.00914348f, -0.00597230f, 
    0.03629817f, -0.02911558f, 0.00862732f, 0.01532538f, 0.03883154f, -0.05038119f, 0.02982162f, 0.00121879f, 
    0.03595196f, -0.06640106f, -0.06075347f, 0.02789485f, 0.03643372f, -0.07105360f, -0.01458842f, 0.02697512f, 
    -0.07751439f, 0.04109485f, -0.01051709f, -0.02152351f, 0.00415504f, 0.04568410f, 0.05175806f, 0.00166294f, 
    -0.06010277f, -0.03798821f, 0.01509525f, 0.01935915f, -0.03586391f, 0.05228778f, 0.00734811f, -0.07005981f, 
    0.05196350f, -0.00095405f, -0.05118893f, -0.02848524f, 0.03714678f, 0.00091838f, 0.01597784f, -0.04699513f, 
    0.00702971f, 0.00762649f, 0.00997334f, 0.05572338f, 0.04169295f, 0.01371759f, -0.01372162f, -0.06383396f, 
    0.02192439f, 0.01267188f, -0.03938659f, -0.01373656f, -0.04775324f, 0.00401736f, 0.02193742f, -0.04790880f, 
    -0.03215229f, -0.07433954f, 0.04851466f, 0.00005820f, 0.02936591f, -0.00402772f, -0.06049774f, -0.01940210f, 
    -0.06917844f, -0.06421038f, -0.04278919f, -0.05556411f, -0.04739290f, 0.04714847f, 0.00722041f, 0.04908125f, 
    -0.03838607f, 0.02616003f, 0.02900417f, -0.06651378f, 0.04643605f, -0.06148671f, -0.02062063f, -0.02693565f, 
    -0.21936071f, -0.19224700f, 0.08290166f, 0.05952235f, -0.04849188f, -0.05784339f, -0.05737320f, -0.09734773f, 
    0.01805718f, 0.00411170f, 0.06192037f, -0.02045000f, 0.06837579f, -0.09168891f, -0.14214705f, 0.20179385f, 
    -0.01305116f, 0.09867639f, -0.01282317f, -0.12674503f, 0.04986631f, -0.06357996f, -0.09298613f, -0.12436410f, 
    0.16643783f, 0.03779446f, -0.13279401f, -0.06832618f, -0.05865767f, -0.03419334f, 0.19192667f, 0.10225157f, 
    0.05805780f, 0.05982507f, -0.02820386f, 0.04516607f, 0.53288591f, 0.03117225f, 0.03189234f, -0.00655471f, 
    -0.01514908f, 0.00155876f, 0.02255318f, 0.07761861f, 0.12307427f, -0.12970111f, 0.15205199f, -0.01610912f, 
    -0.02569961f, -0.20857297f, 0.15327916f, -0.29993328f, 0.14855827f, -0.00288036f, -0.02447293f, 0.04860156f, 
    0.11116207f, 0.09672768f, -0.22507001f, 0.08925973f, 0.17305095f, 0.16998886f, 0.23069103f, -0.17517155f, 
    0.16384919f, 0.13206023f, -0.14590023f, 0.00827184f, 0.12635815f, 0.12899449f, -0.03464723f, 0.00794665f, 
    0.53418726f, 0.03807545f, 0.07909227f, 0.00058377f, 0.05419929f, 0.04332308f, 0.03897895f, -0.03038580f, 
    0.11722666f, 0.11714009f, 0.07894775f, 0.06364512f, -0.16826952f, -0.33534446f, -0.16295093f, 0.09894023f, 
    -0.07520340f, 0.06997226f, -0.02326991f, 0.00283891f, 0.02060157f, 0.11560985f, -0.03031860f, -0.07497226f, 
    -0.35592899f, 0.11347023f, -0.00674625f, -0.14699987f, 0.09354231f, -0.01096730f, 0.05157718f, -0.04330412f, 
    0.08742230f, 0.00360043f, -0.08805549f, 0.04018600f, -0.47668090f, 0.01060318f, 0.16923355f, -0.11208455f, 
    -0.07420049f, 0.00641575f, -0.17963217f, -0.06225428f, 0.16426654f, 0.14313184f, 0.07575075f, -0.05063388f, 
    0.02581844f, -0.25024828f, 0.11119609f, 0.02176157f, 0.08933675f, -0.12706460f, 0.05579608f, -0.01013188f, 
    0.07194119f, 0.10082331f, 0.04026501f, 0.18459454f, 0.31286642f, -0.09517080f, 0.20887777f, 0.01887737f, 
    0.08080376f, 0.17931357f, -0.11816552f, -0.04911903f, -0.05017312f, -0.01332976f, 0.00859821f, 0.04214368f, 
    0.55863005f, 0.08381595f, -0.19454305f, 0.06303602f, -0.08111839f, 0.05804453f, 0.06203577f, -0.04271627f, 
    -0.17902116f, -0.06913429f, 0.20237198f, 0.07143638f, 0.10011706f, 0.01451305f, 0.08130407f, -0.03889353f, 
    -0.00236238f, 0.05633694f, 0.02345144f, 0.05358788f, 0.05255452f, -0.04598006f, 0.00227935f, 0.03219389f, 
    -0.00023715f, -0.02572826f, -0.10035924f, -0.22193779f, 0.26378059f, -0.07245550f, -0.02232825f, -0.06449760f, 
    -0.00799591f, -0.10135575f, 0.11488327f, -0.01342842f, 0.05616298f, 0.12293454f, -0.29301921f, 0.09149531f, 
    -0.04404559f, -0.02570012f, 0.05660091f, 0.04563999f, 0.07673623f, -0.08888789f, 0.00082870f, 0.25720993f, 
    -0.04122107f, 0.01217662f, 0.22326711f, -0.21267192f, -0.06760319f, 0.11034006f, 0.03455658f, 0.19001126f, 
    0.05631648f, -0.02887594f, 0.17533408f, 0.10630829f, 0.25388563f, -0.30275673f, -0.14506087f, -0.10610790f, 
    -0.14699610f, 0.05164777f, -0.01850373f, 0.05716313f, 0.04073457f, 0.03337134f, -0.08704998f, -0.21600001f, 
    -0.02593986f, 0.05101892f, -0.34990400f, -0.03835063f, 0.03666772f, -0.03885677f, -0.05849494f, 0.07866755f, 
    0.12746193f, 0.12225205f, -0.16719496f, 0.01164518f, -0.19609191f, -0.10603052f, -0.17758016f, 0.07779840f, 
    0.04398782f, -0.06431730f, 0.00202441f, -0.13845854f, 0.07919911f, 0.05621936f, 0.03406765f, -0.01757570f, 
    -0.05487213f, -0.13842086f, 0.21081549f, -0.09617174f, 0.17571051f, 0.04839373f, -0.12604076f, 0.12037002f, 
    0.07511926f, 0.14415547f, -0.16419950f, 0.01217744f, 0.08881356f, 0.13697085f, -0.08199690f, 0.18212640f, 
    0.23098046f, 0.02065978f, -0.11729729f, -0.03745218f, 0.07931180f, 0.13554244f, -0.08524275f, 0.16923165f, 
    0.25250444f, 0.38333336f, 0.13174899f, -0.09538513f, 0.06294932f, -0.09187047f, 0.00522822f, 0.00157318f, 
    -0.04753674f, 0.18231533f, 0.07730941f, 0.13363674f, -0.41672015f, -0.35013524f, 0.11641040f, 0.08951523f, 
    0.00031875f, 0.04875302f, -0.05659929f, -0.02162423f, 0.12607187f, -0.01328056f, 0.09077151f, -0.06429508f, 
    -0.20024513f, -0.33186179f, -0.08424816f, -0.26479995f, 0.03312007f, 0.09809241f, -0.04646289f, 0.12083031f, 
    0.07852940f, 0.12334611f, -0.19141135f, -0.01192575f, -0.00310400f, 0.17325385f, -0.02040620f, 0.12338155f, 
    0.03630320f, 0.05668947f, -0.19635032f, -0.03482688f, 0.06416319f, -0.01233800f, 0.07886650f, -0.00016093f, 
    -0.08980203f, -0.15287463f, 0.17018399f, -0.11334726f, -0.11110739f, 0.08170124f, 0.05293987f, 0.05017214f, 
    0.07527235f, 0.17051607f, 0.02279120f, 0.10796456f, 0.31826261f, 0.29095852f, 0.11046124f, 0.20073883f, 
    0.09614780f, 0.20548610f, -0.06994459f, -0.09690320f, -0.06475408f, 0.03846954f, 0.02797858f, 0.17992142f, 
    0.22696005f, 0.01097462f, 0.07114173f, -0.05151523f, -0.06434789f, 0.14115962f, 0.04980822f, -0.08682847f, 
    0.06492849f, -0.00293908f, 0.16254361f, -0.02078487f, -0.02542742f, -0.02866982f, -0.00446435f, -0.09243152f, 
    -0.10519905f, 0.12268628f, 0.00885331f, -0.00060750f, -0.05364290f, 0.04360986f, 0.11603016f, -0.05260469f, 
    -0.50307047f, -0.18009838f, -0.02130209f, 0.04582885f, -0.12081870f, 0.13396046f, 0.16463593f, 0.11116911f, 
    0.08788319f, -0.01180695f, -0.06121283f, -0.24226287f, 0.18009458f, -0.02781679f, 0.02006886f, -0.05152454f, 
    0.14632681f, -0.03606141f, 0.04394187f, 0.02902338f, 0.06888930f, -0.03522599f, 0.00405187f, 0.09695371f, 
    0.32781345f, 0.09221465f, -0.10620841f, 0.35215271f, -0.07782681f, -0.06776217f, 0.01125734f, -0.01859655f, 
    0.03032118f, 0.04607455f, -0.05486803f, 0.05962458f, -0.20707172f, -0.14250170f, 0.12562494f, 0.16957299f, 
    -0.09372943f, -0.10825527f, 0.18900147f, 0.01665977f, -0.12060129f, 0.06775546f, 0.07536344f, 0.08358610f, 
    -0.37761930f, 0.04197289f, 0.07695391f, 0.31501964f, -0.02162155f, -0.00456298f, -0.00906877f, -0.04286754f, 
    -0.18072082f, -0.05192953f, 0.04996729f, -0.01791142f, -0.46929234f, 0.21557215f, -0.00953791f, -0.07356041f, 
    0.17358756f, 0.00651488f, 0.10460945f, 0.02649237f, -0.06218027f, -0.02543834f, 0.00433758f, -0.05643718f, 
    0.06885415f, 0.03831059f, 0.07923581f, 0.10494346f, -0.02221707f, 0.01404256f, 0.17708114f, -0.00504203f, 
    0.04149235f, -0.20323150f, 0.07808124f, -0.03418040f, -0.16273382f, -0.01927054f, -0.10585652f, -0.33521715f, 
    0.17520486f, -0.12192725f, 0.01942352f, 0.03365705f, 0.06071236f, -0.13565136f, -0.16508585f, 0.00792297f, 
    0.10144153f, -0.00786211f, -0.01704095f, -0.22891329f, 0.03271865f, -0.05086560f, -0.01409894f, -0.10338521f, 
    0.11467279f, 0.00594821f, -0.02679649f, -0.00075968f, 0.00260278f, 0.01144186f, -0.08151847f, 0.09242985f, 
    0.05571514f, 0.06981706f, -0.21502894f, -0.03982906f, -0.01976244f, 0.02620082f, 0.06225884f, 0.02018487f, 
    0.18770461f, 0.25256938f, -0.18575814f, 0.15781976f, 0.09199802f, 0.07441692f, 0.08165436f, -0.00529750f, 
    -0.04066430f, 0.01314401f, -0.05633527f, 0.03591913f, 0.19460249f, -0.13966030f, 0.12753816f, -0.17820029f, 
    0.01522966f, 0.13406509f, -0.05791313f, 0.04746101f, -0.00483335f, 0.07824470f, -0.05064197f, 0.05509365f, 
    0.07492315f, 0.03119824f, 0.00809306f, 0.12601751f, 0.12701032f, 0.04981354f, -0.05315322f, 0.07256228f, 
    0.03384307f, -0.09174879f, 0.01753295f, -0.11940342f, 0.02513966f, 0.08178532f, 0.01982819f, -0.18591458f, 
    0.00129273f, -0.08981021f, 0.01546780f, 0.09137007f, 0.01554462f, -0.00369721f, 0.11287644f, 0.03229346f, 
    0.00692535f, 0.19756216f, -0.02271901f, 0.15551233f, 0.08029371f, -0.02153978f, 0.08460669f, 0.07547466f, 
    -0.07643881f, -0.07323803f, -0.01364340f, -0.01700144f, -0.08312108f, 0.07132288f, -0.20137687f, 0.23644841f, 
    0.10867612f, -0.08429214f, 0.21651378f, -0.06067477f, 0.12495961f, 0.04991743f, -0.03228090f, 0.01252123f, 
    0.20687503f, 0.10033652f, 0.09619492f, -0.21383014f, 0.07087828f, 0.09622706f, 0.08800040f, -0.03741202f, 
    -0.06327506f, 0.03031148f, 0.03156252f, 0.10717455f, -0.28001192f, -0.16212440f, 0.02252425f, -0.13982670f, 
    -0.04873173f, 0.09313875f, -0.10918223f, 0.17161076f, 0.07209405f, 0.00569524f, 0.07007183f, 0.09796108f, 
    -0.18334879f, 0.09890818f, 0.05406753f, 0.24457669f, -0.10029043f, -0.03291348f, 0.04431959f, 0.04322117f, 
    0.00118503f, -0.08973101f, -0.08864948f, -0.06789491f, 0.01469052f, 0.17657213f, -0.01060756f, 0.01011132f, 
    0.20105216f, -0.02945694f, -0.21588393f, 0.03745446f, 0.15958492f, 0.05263780f, 0.14533338f, 0.13447160f, 
    -0.37385505f, -0.12771699f, -0.05560574f, -0.23980972f, 0.07406129f, 0.03863948f, 0.21089618f, 0.05519968f, 
    -0.04264661f, -0.02127054f, -0.03090257f, 0.05210829f, -0.12710164f, 0.20769507f, 0.14419410f, -0.29889822f, 
    0.00087009f, 0.00588414f, -0.05271463f, 0.04053228f, 0.13904379f, -0.08316201f, -0.02294372f, 0.03748041f, 
    -0.18295677f, -0.00504190f, -0.22412556f, -0.11975861f, 0.04669061f, 0.02585137f, 0.05435190f, -0.06271123f, 
    0.12556638f, 0.17182155f, 0.08101381f, 0.09250692f, 0.23876233f, 0.20977513f, 0.59719169f, 0.01607211f, 
    -0.06373841f, 0.04203117f, 0.07303995f, -0.14454022f, -0.01793508f, 0.10152798f, 0.11073165f, 0.02917621f, 
    0.28211707f, -0.09937964f, 0.37949991f, 0.35054791f, -0.01414004f, 0.03369911f, 0.06692458f, -0.03782890f, 
    0.03247390f, -0.14927559f, 0.14444566f, -0.04221078f, 0.13493855f, -0.14155923f, 0.12958373f, 0.26070201f, 
    -0.02069611f, -0.14908791f, 0.02970789f, 0.09538115f, -0.06499425f, -0.08315683f, -0.04088526f, 0.00541402f, 
    -0.42390695f, -0.16261944f, 0.02296920f, 0.10807448f, -0.05217137f, -0.00629896f, -0.03904137f, -0.18841262f, 
    0.29769766f, 0.03436289f, 0.05831962f, 0.19144905f, -0.18477298f, -0.09816319f, 0.26396990f, -0.21492897f, 
    0.05048501f, -0.11634576f, -0.00818888f, 0.07024612f, -0.02836704f, 0.00935482f, -0.02755538f, -0.03991983f, 
    0.13051806f, -0.05531703f, 0.03232547f, 0.17701083f, -0.15133049f, 0.01317299f, 0.08979172f, -0.11392447f, 
    -0.12856549f, -0.04809152f, 0.08397448f, 0.11571550f, -0.21337046f, -0.01426576f, 0.24091111f, -0.03700555f, 
    0.11951309f, -0.03768416f, 0.00189705f, -0.05147832f, -0.03836850f, -0.03028160f, 0.09826369f, -0.07541654f, 
    -0.07392678f, -0.05705143f, 0.16977204f, -0.07116561f, -0.00109490f, -0.06123958f, 0.14446786f, -0.20420018f, 
    0.00373773f, -0.01053776f, -0.12590121f, 0.02109405f, -0.08871596f, 0.14685845f, 0.08512774f, 0.00240471f, 
    0.01292124f, 0.08127555f, -0.03927343f, -0.16582417f, -0.13945386f, 0.09003257f, -0.00563925f, 0.02758117f, 
    -0.17462514f, 0.21109726f, -0.00291268f, 0.09696677f, 0.02861455f, -0.09908866f, -0.13153534f, 0.08430167f, 
    0.06614132f, 0.15635896f, 0.00388635f, 0.15731208f, -0.13549854f, -0.09527794f, -0.23218076f, 0.15899934f, 
    -0.06635284f, -0.25117874f, -0.20795541f, -0.13878952f, 0.00288672f, -0.11950123f, 0.03339127f, 0.17664759f, 
    -0.27093750f, -0.01945267f, 0.11786942f, 0.00083397f, -0.01659741f, 0.09562584f, -0.01067584f, 0.01360154f, 
    0.04422526f, -0.10404847f, 0.17113441f, 0.00904253f, 0.04328109f, 0.00256528f, -0.11250823f, 0.04096315f, 
    0.26109520f, 0.01143180f, -0.13651447f, -0.00519376f, 0.15033676f, -0.01540492f, 0.00882624f, -0.05481340f, 
    0.42631871f, 0.00922454f, -0.16870941f, -0.17055480f, 0.18345854f, 0.15776555f, 0.14163151f, 0.07291277f, 
    0.23977904f, 0.07333685f, -0.11484601f, 0.14007585f, 0.27000093f, -0.15068552f, 0.04047497f, -0.18426701f, 
    -0.14184839f, 0.00665511f, -0.17716131f, 0.05773696f, 0.00513619f, -0.13128270f, -0.00608961f, 0.01439548f, 
    -0.26943386f, 0.25038949f, -0.12116452f, 0.16183203f, 0.13620247f, 0.17586970f, -0.00076144f, -0.18439963f, 
    0.06227211f, 0.17191415f, -0.07281574f, 0.04589969f, 0.26333803f, 0.18408532f, 0.28471053f, 0.18158297f, 
    -0.19493322f, 0.10647234f, -0.12727623f, -0.05666745f, 0.06736682f, 0.14505754f, 0.10289970f, 0.01671573f, 
    -0.15033534f, 0.13583307f, 0.23449579f, -0.03904857f, -0.02647145f, 0.05526745f, -0.03237634f, -0.02227427f, 
    -0.22833097f, -0.11743853f, 0.20251551f, -0.02873132f, -0.22969286f, -0.24280253f, 0.14476703f, 0.30171040f, 
    0.00198201f, -0.05669232f, 0.24210297f, -0.05163388f, 0.05414686f, -0.11998313f, 0.08161031f, -0.04050900f, 
    -0.08914423f, -0.03674774f, 0.33989435f, 0.03865040f, 0.17004812f, -0.00743559f, -0.14590399f, -0.01729025f, 
    -0.00026360f, 0.10508630f, 0.09848694f, 0.09820870f, 0.22051048f, -0.08198436f, 0.03407840f, 0.30115351f, 
    0.05745635f, -0.31029409f, 0.23900223f, -0.08890395f, -0.05529219f, 0.00950912f, 0.02064615f, -0.10624936f, 
    -0.29213536f, -0.05715927f, -0.01074587f, -0.02542838f, -0.10318962f, -0.14902976f, 0.00997325f, -0.05618056f, 
    -0.00955534f, 0.15976250f, 0.05089367f, 0.13167827f, -0.17162643f, -0.00167156f, 0.07475669f, -0.07486927f, 
    0.13422033f, 0.07707766f, 0.01449674f, -0.18089412f, 0.08336117f, 0.11141688f, -0.16992976f, 0.00725836f, 
    0.02426642f, -0.23796561f, -0.02851502f, -0.46388641f, -0.10320149f, -0.02822559f, -0.04960313f, -0.09376016f, 
    0.06811360f, 0.17151901f, -0.00578848f, 0.21264234f, -0.20791033f, 0.08109301f, 0.13585073f, -0.21620841f, 
    -0.14626530f, 0.01260726f, 0.00955680f, 0.01839043f, -0.05060553f, -0.13968229f, 0.09554581f, -0.17057838f, 
    -0.13823795f, 0.13691160f, 0.11450932f, 0.06319257f, 0.19321999f, -0.02403265f, -0.08190002f, 0.00142330f, 
    0.04208234f, -0.06931445f, 0.01459301f, 0.07500323f, 0.37375903f, 0.23082055f, -0.23011248f, 0.26245350f, 
    0.10151488f, -0.20795840f, 0.08727337f, -0.16158731f, -0.05477494f, -0.13173893f, -0.03805154f, 0.01181288f, 
    0.00766522f, -0.08096933f, -0.22871839f, -0.51817411f, -0.11123761f, -0.05760769f, -0.01545299f, 0.01173594f, 
    -0.18114758f, 0.09457836f, 0.03426551f, -0.14972273f, 0.22845477f, -0.04153743f, 0.09454252f, -0.11618540f, 
    -0.14630601f, 0.09890922f, 0.23821801f, 0.16620395f, -0.01635199f, 0.15508486f, 0.10907075f, 0.04021580f, 
    0.05420498f, -0.20157938f, 0.06341787f, 0.02390125f, -0.04027653f, -0.09657275f, -0.20457074f, -0.08045063f, 
    -0.13749139f, -0.06237853f, 0.14213198f, 0.19146708f, 0.53287899f, -0.26197731f, 0.14341910f, 0.28656614f, 
    -0.04554021f, 0.07839589f, 0.06916030f, 0.08138308f, -0.09595984f, 0.16005094f, -0.03009097f, 0.05504235f, 
    0.01338179f, -0.12848429f, -0.14704716f, -0.04403851f, -0.16234547f, 0.18836889f, -0.02130954f, 0.25997359f, 
    0.03465704f, 0.04956231f, 0.12676910f, -0.02034277f, 0.27179840f, 0.24743636f, 0.21620674f, 0.29708695f, 
    -0.00345366f, -0.06565205f, 0.15278579f, 0.05817544f, -0.02615267f, 0.08911836f, 0.04434270f, 0.05235044f, 
    -0.12202947f, 0.26061341f, 0.17498545f, 0.04827756f, -0.11208595f, 0.17338118f, -0.02960400f, 0.06865032f, 
    -0.02418122f, 0.02601567f, -0.11874649f, -0.19696455f, 0.24552006f, 0.12810262f, -0.10863715f, -0.30711299f, 
    0.12732884f, -0.08834113f, -0.00643404f, 0.05871164f, -0.05852538f, 0.09111405f, -0.10339989f, 0.03836649f, 
    -0.06062658f, -0.22276279f, -0.12019097f, 0.09660984f, 0.00011957f, 0.13044636f, 0.21520321f, 0.14318137f, 
    -0.06329679f, 0.00484765f, -0.07821082f, -0.18783362f, -0.11567402f, 0.03487693f, -0.15778351f, -0.05731881f, 
    -0.01865031f, 0.12932862f, -0.04037108f, 0.00502808f, 0.01884766f, 0.00871703f, -0.07931655f, 0.15017089f, 
    -0.25680998f, 0.11319824f, 0.11802559f, -0.25159889f, -0.10290923f, 0.12079298f, -0.01514237f, 0.03436871f, 
    -0.04156935f, -0.08305477f, -0.08329193f, -0.19046743f, 0.19014184f, 0.23032311f, -0.27767903f, 0.01162474f, 
    -0.08801519f, -0.00218157f, 0.00069663f, 0.05989117f, -0.07139825f, 0.02825600f, -0.11717998f, -0.06107541f, 
    -0.10119346f, -0.07402015f, 0.23210430f, 0.24133798f, -0.04252137f, 0.20618200f, -0.19880036f, -0.03463837f, 
    -0.00483681f, -0.17611851f, 0.00192436f, -0.26394844f, 0.09191448f, 0.18522561f, 0.20614958f, -0.11398518f, 
    -0.04108782f, -0.13337344f, -0.30988708f, 0.10299382f, 0.00151546f, -0.05212728f, -0.05772791f, 0.33455092f, 
    -0.12345680f, -0.20016387f, -0.10079585f, 0.11050094f, 0.03532325f, 0.16049019f, 0.01711314f, -0.00387358f, 
    -0.00380345f, -0.05938832f, 0.08624596f, -0.13671832f, -0.07421896f, -0.17640492f, 0.38994244f, 0.00683242f, 
    0.15717806f, 0.08130860f, 0.20598121f, 0.07069769f, 0.12166460f, 0.33103997f, 0.14005204f, 0.06617334f, 
    0.18379100f, 0.12991720f, 0.19620727f, -0.18241468f, 0.19484077f, 0.15949950f, 0.16422233f, 0.10047004f, 
    0.10814855f, -0.00186231f, 0.10728474f, 0.17161338f, 0.10353522f, 0.20543090f, -0.30592504f, -0.26429120f, 
    0.14797111f, 0.07205876f, -0.23098817f, -0.10376325f, 0.14271231f, -0.07454430f, 0.09554472f, -0.12424012f, 
    0.11111462f, 0.16335104f, -0.35770017f, -0.14673713f, 0.01889096f, 0.06613311f, 0.06012530f, 0.09135526f, 
    0.17682162f, -0.03423336f, -0.09496203f, -0.00109323f, -0.51302552f, -0.04244170f, 0.00789899f, 0.23731311f, 
    0.08175647f, 0.07251911f, -0.20811151f, -0.05702634f, 0.03317994f, -0.07622012f, 0.06623595f, -0.00644842f, 
    0.25307727f, -0.08086807f, 0.07898300f, -0.16351432f, 0.06112691f, 0.11097392f, -0.03949501f, -0.10087549f, 
    -0.07193765f, -0.00811582f, -0.09739135f, 0.05785226f, 0.17990087f, 0.04057593f, -0.10814644f, 0.36049688f, 
    0.08603873f, 0.07798220f, -0.12207805f, -0.02167894f, 0.11619807f, 0.11516173f, 0.01373229f, 0.11833151f, 
    0.24682777f, -0.15870827f, 0.11412760f, 0.30825961f, -0.00211313f, 0.09357757f, -0.03832504f, 0.15021892f, 
    -0.03560423f, -0.01736347f, 0.07185506f, 0.15332831f, -0.46869349f, -0.33058605f, 0.12862447f, -0.03776886f, 
    -0.14401200f, 0.05846306f, 0.04680924f, 0.10185629f, 0.17205465f, 0.00140252f, 0.08178782f, -0.01237135f, 
    0.08484507f, -0.04276525f, 0.14505886f, -0.10228472f, 0.02801091f, -0.02340295f, -0.06950929f, 0.11682926f, 
    0.00171347f, 0.15267438f, 0.17428467f, 0.13391268f, -0.38148555f, 0.36693308f, -0.06562478f, 0.25977695f, 
    0.03556531f, -0.05300314f, 0.08496388f, -0.00617722f, 0.05078430f, -0.01101567f, 0.16391368f, -0.05113063f, 
    0.07075045f, -0.15469250f, 0.03719146f, -0.04652454f, 0.04527286f, -0.00851048f, 0.04597960f, -0.06074238f, 
    -0.01592558f, 0.21238403f, 0.12337775f, 0.14063662f, -0.01061620f, 0.19923842f, 0.20181061f, 0.08446192f, 
    0.11670318f, 0.19807430f, -0.01534767f, -0.04566979f, -0.07573023f, 0.17784666f, 0.05576714f, 0.14040041f, 
    -0.07210092f, -0.06073763f, -0.19549903f, -0.14765856f, 0.04929953f, -0.02657861f, 0.06005662f, -0.03969747f, 
    -0.01857193f, 0.05397927f, -0.00695197f, 0.16041981f, 0.13352987f, -0.08136489f, 0.13475582f, -0.08382037f, 
    -0.10127205f, -0.00531597f, -0.01473502f, 0.11234151f, -0.14121348f, -0.06512200f, 0.01130300f, -0.19760878f, 
    -0.25315049f, -0.03316300f, -0.18262987f, 0.12467355f, -0.01917741f, 0.04863633f, -0.02746400f, 0.16097128f, 
    0.20259920f, -0.09237199f, -0.07804135f, 0.03237393f, -0.04679198f, 0.13387512f, -0.16063327f, -0.11034071f, 
    0.06499087f, -0.15631200f, -0.01337362f, -0.12617809f, -0.07180121f, -0.06461140f, -0.08084919f, -0.21292622f, 
    0.06208636f, -0.03026974f, 0.01665409f, 0.05639538f, 0.02460339f, 0.00461998f, -0.06749387f, -0.00773637f, 
    -0.04147150f, -0.04497384f, -0.01986518f, 0.02441103f, 0.06193231f, -0.00940197f, 0.03270023f, -0.03055936f, 
    0.02536670f, -0.07384931f, -0.03464307f, 0.06195321f, -0.06691126f, 0.05185494f, -0.06516863f, -0.07270287f, 
    0.00223857f, 0.05088324f, -0.03114007f, -0.04484862f, -0.03177718f, 0.00331597f, -0.07376140f, -0.05491983f, 
    0.03786910f, 0.02676471f, 0.04021352f, 0.02640644f, -0.02783734f, -0.03370004f, -0.03004065f, -0.07309970f, 
    -0.05267964f, 0.00880715f, -0.01527475f, 0.00760022f, 0.03788326f, 0.01745895f, -0.02344193f, -0.07247590f, 
    -0.01053531f, -0.07868569f, -0.03314235f, -0.03966535f, -0.00145494f, -0.05934331f, -0.04568825f, 0.04436933f, 
    -0.00451374f, 0.04728387f, -0.01628103f, -0.04231167f, 0.00725899f, -0.04614745f, -0.04712988f, -0.01178800f, 
    -0.06836011f, -0.04191237f, 0.06422227f, 0.04595642f, -0.00470811f, 0.02453097f, 0.01823194f, 0.00150233f, 
    0.02797403f, -0.06587899f, 0.06616449f, -0.06851974f, 0.05285948f, 0.06806825f, 0.01909325f, -0.06403510f, 
    -0.03722940f, 0.00417368f, -0.02666949f, -0.00748225f, 0.04590489f, 0.00108984f, -0.06474961f, 0.00202912f, 
    -0.05397700f, -0.04849771f, 0.02365777f, -0.05756282f, 0.03154454f, -0.07367407f, 0.01691289f, -0.07048487f, 
    0.05353663f, 0.00464571f, -0.03205254f, -0.02630909f, 0.05692189f, -0.06324547f, 0.06683479f, 0.05728109f, 
    -0.04377332f, -0.04870226f, 0.05948982f, -0.02640076f, -0.04963464f, -0.06668206f, 0.01866349f, -0.06125009f, 
    -0.04595515f, -0.03831323f, 0.04659529f, -0.02281342f, -0.00162374f, 0.05145852f, -0.06989902f, -0.01603255f, 
    -0.05539798f, -0.07676788f, 0.01682702f, -0.02523491f, -0.03680906f, 0.01607420f, -0.01854085f, 0.01965330f, 
    0.01743702f, -0.06946318f, -0.07532364f, -0.04727453f, -0.02208025f, 0.01165706f, -0.02771650f, -0.00713044f, 
    -0.02079512f, -0.00659685f, -0.01482535f, -0.02456532f, -0.06714664f, 0.01339942f, -0.05147845f, -0.07160681f, 
    -0.07761335f, -0.03726398f, 0.02947809f, 0.05471935f, -0.00001229f, 0.05890619f, -0.07259747f, -0.05816722f, 
    -0.02018564f, -0.01623190f, 0.03468081f, -0.06985464f, -0.06046865f, 0.05111622f, -0.02603594f, -0.02200848f, 
    0.04518091f, 0.03662119f, 0.04492524f, 0.02984882f, -0.02761090f, 0.04711670f, 0.06005162f, 0.00272979f, 
    -0.03607041f, -0.05139412f, 0.01490852f, -0.05740367f, -0.03488918f, 0.00086019f, -0.02799758f, -0.07964954f, 
    -0.04225873f, 0.05066006f, -0.07030156f, 0.00115731f, -0.00274823f, 0.01477230f, 0.03237499f, 0.06607778f, 
    0.01881745f, -0.03618690f, -0.00103173f, 0.06401987f, 0.03293803f, -0.03791571f, -0.02800238f, -0.01745709f, 
    0.34330404f, 0.08879701f, -0.12716579f, 0.46581301f, 0.08385701f, -0.17402090f, -0.01853264f, 0.11063083f, 
    0.10571615f, -0.02136805f, -0.10206953f, -0.00266051f, 0.16527967f, 0.15159766f, 0.26961324f, 0.06450338f, 
    0.12848525f, -0.01327729f, 0.02357581f, -0.06573904f, 0.06630324f, 0.00918542f, 0.03000665f, 0.05077347f, 
    -0.41208062f, 0.14755531f, 0.06200352f, 0.13296877f, 0.11814651f, 0.13682781f, 0.06767162f, 0.11268301f, 
    -0.10086682f, -0.08458382f, 0.08221500f, -0.11283109f, -0.68951494f, 0.25266740f, -0.15451138f, -0.18245144f, 
    0.11011924f, 0.02037982f, -0.02524967f, -0.00965456f, -0.00714659f, 0.05595864f, -0.10624495f, 0.01234766f, 
    -0.22135136f, -0.01029100f, 0.12267593f, -0.00185227f, 0.03888896f, 0.02925461f, 0.07381725f, -0.07106727f, 
    0.16450827f, -0.08708628f, 0.08998790f, -0.05551370f, 0.10875732f, 0.02329040f, 0.01502786f, -0.02512194f, 
    -0.04268294f, 0.01570171f, -0.00866512f, -0.05907287f, -0.02471154f, -0.01197631f, -0.04777014f, -0.10117340f, 
    -0.04598001f, -0.06617498f, -0.05120426f, 0.14629960f, 0.02967089f, -0.06633801f, -0.01900548f, -0.04883908f, 
    0.10518670f, -0.01537812f, 0.03059017f, 0.12729745f, 0.36665705f, 0.22756982f, 0.07739624f, 0.00816835f, 
    -0.04478278f, -0.02695474f, 0.05471345f, -0.07482292f, -0.01279003f, -0.04866187f, -0.00325065f, 0.08291036f, 
    0.06634406f, 0.02168238f, -0.06582984f, 0.18409435f, 0.08813825f, 0.03117958f, 0.03285379f, -0.16736291f, 
    0.17152645f, 0.08418359f, 0.05465236f, 0.08367348f, -0.20278972f, 0.12303842f, 0.11054546f, -0.12577607f, 
    0.01590975f, 0.07190017f, 0.05888846f, 0.04857279f, -0.03317441f, -0.10684157f, -0.06807111f, 0.04402964f, 
    -0.08434888f, 0.12499391f, 0.08700753f, 0.19641916f, -0.01458941f, 0.03735753f, -0.00831724f, -0.04507870f, 
    -0.14008114f, -0.09041274f, 0.07653993f, 0.12644465f, -0.43396145f, 0.06805700f, 0.25513893f, -0.25350329f, 
    0.00851798f, -0.03751145f, 0.19016021f, -0.04892832f, -0.03498016f, -0.14249107f, 0.07864565f, -0.07822221f, 
    -0.17972259f, -0.20961021f, 0.21548727f, 0.07027098f, 0.02127636f, -0.06337925f, 0.13144021f, 0.08226842f, 
    0.01188374f, 0.04507788f, -0.03621976f, 0.04200641f, -0.34048781f, -0.18560950f, -0.12408035f, -0.00802179f, 
    0.05504924f, -0.04015987f, 0.15295622f, 0.00993678f, -0.08117674f, 0.10159311f, -0.04889001f, -0.04639242f, 
    0.20041305f, 0.02910158f, 0.20687041f, 0.06104499f, 0.03583835f, -0.07417994f, 0.03472693f, -0.07712362f, 
    -0.01354061f, 0.15041725f, -0.02037511f, 0.09378757f, -0.33125389f, 0.14306892f, 0.16903132f, -0.10922005f, 
    -0.11542995f, 0.01267341f, -0.13111143f, 0.11999497f, 0.04310668f, 0.01044948f, -0.04676164f, -0.00109855f, 
    -0.02410581f, 0.19757944f, -0.03245422f, -0.02066205f, 0.01449178f, 0.10861054f, 0.02387903f, 0.05166874f, 
    0.09696137f, 0.07244543f, -0.16813673f, -0.04595099f, -0.52926266f, 0.33236781f, -0.07335366f, 0.23953548f, 
    -0.09124817f, -0.08322036f, -0.22150671f, 0.18246603f, 0.06642319f, -0.08014725f, -0.14148366f, -0.06919816f, 
    -0.06418313f, -0.31670561f, 0.25388265f, -0.05889900f, -0.18801358f, -0.01524029f, 0.30911332f, -0.08065131f, 
    -0.05850068f, -0.11027130f, 0.11723270f, -0.04376540f, -0.04608244f, 0.06784810f, -0.04228803f, -0.10160683f, 
    0.00762212f, -0.06647968f, 0.12976366f, 0.03016767f, 0.15102506f, -0.02579360f, 0.03514473f, 0.01867498f, 
    -0.04638759f, 0.27655819f, -0.09731395f, -0.10561657f, 0.07252987f, -0.14522997f, 0.10724217f, -0.07603194f, 
    -0.14159462f, -0.18372609f, -0.05060425f, 0.07513202f, -0.06895558f, -0.12300612f, -0.11192059f, 0.04559839f, 
    0.05133820f, -0.05866754f, -0.06466531f, -0.06932452f, -0.02409980f, -0.03661752f, 0.08063111f, 0.06863969f, 
    -0.27909419f, -0.08813459f, 0.03376272f, 0.05276736f, 0.05833535f, -0.08813596f, -0.10317888f, -0.10918787f, 
    0.12323444f, -0.14099321f, 0.05373950f, 0.10177210f, 0.15247303f, 0.34278640f, -0.25818995f, -0.08901726f, 
    0.14567386f, 0.23536466f, 0.01052376f, 0.07313884f, 0.03665483f, 0.10799182f, 0.00902959f, 0.04218141f, 
    -0.13157240f, 0.29132068f, 0.16345419f, -0.13725922f, -0.24659963f, -0.00729274f, 0.04150945f, 0.04998120f, 
    0.12501311f, -0.04101498f, 0.09057150f, 0.04711156f, 0.07802752f, -0.20911068f, -0.00569995f, -0.04664254f, 
    -0.06182164f, -0.21974128f, 0.14799455f, 0.06436466f, 0.00790187f, 0.03798050f, -0.01877973f, 0.07683948f, 
    0.18156213f, 0.04856714f, -0.25663242f, -0.19969843f, 0.10272019f, -0.04988550f, -0.22619373f, 0.14925544f, 
    0.17733943f, 0.11320809f, 0.02428203f, -0.00446107f, -0.02835477f, -0.16607752f, -0.21310428f, -0.05657532f, 
    0.12572999f, -0.12134611f, -0.12002771f, 0.08936909f, 0.13681176f, 0.15845093f, 0.02546838f, 0.08072156f, 
    -0.12936038f, 0.40087220f, -0.21442039f, 0.03756400f, 0.04169175f, -0.11479475f, 0.14948130f, 0.14081931f, 
    -0.01144999f, 0.28932077f, -0.00945174f, 0.15071921f, 0.14587794f, 0.11032019f, -0.03934426f, 0.24947728f, 
    0.02774072f, 0.02511244f, 0.05894358f, -0.13792080f, 0.21585216f, 0.20814280f, 0.01747979f, -0.12340893f, 
    0.19132556f, 0.26441941f, -0.02266820f, -0.23892035f, 0.07069426f, -0.14143533f, 0.00412969f, 0.02384962f, 
    -0.04945933f, -0.00081852f, 0.02554712f, 0.13544725f, 0.14692859f, 0.04107754f, -0.03075734f, -0.07001191f, 
    -0.13985258f, 0.05777768f, -0.01345522f, -0.12147216f, 0.05165920f, -0.05593068f, 0.08014596f, -0.06083737f, 
    -0.03355442f, -0.01528452f, -0.07843789f, -0.02807309f, -0.04160038f, -0.01502090f, -0.01591505f, -0.03251462f, 
    -0.06173208f, 0.04805310f, 0.00958932f, -0.02904848f, 0.00497282f, 0.03046505f, -0.04626617f, -0.05825365f, 
    -0.05523219f, -0.03247781f, -0.06962296f, 0.03381543f, -0.03400622f, -0.06382526f, 0.02105242f, 0.02057954f, 
    0.01416026f, -0.01475173f, -0.04012160f, -0.00722277f, -0.01346524f, 0.04659374f, -0.00662773f, 0.02642589f, 
    0.01192228f, -0.05333364f, 0.01697871f, 0.03429349f, -0.06985999f, -0.05853045f, 0.02013802f, 0.05877321f, 
    0.03996238f, -0.00335492f, 0.04411429f, -0.04923278f, -0.02460109f, 0.02916552f, -0.03802427f, 0.04542539f, 
    -0.05350323f, 0.06028849f, -0.03788536f, 0.01333699f, -0.02013408f, 0.04111880f, 0.04987632f, -0.04756248f, 
    -0.06331890f, 0.03352606f, -0.07941777f, -0.01480574f, 0.00599665f, -0.01535362f, -0.05025627f, 0.00474468f, 
    0.05087088f, -0.01825678f, 0.01475213f, -0.00803054f, 0.03606114f, 0.04371677f, 0.05959981f, 0.00798181f, 
    -0.04691495f, 0.01854812f, -0.06599993f, -0.07021401f, -0.06963565f, 0.02843232f, 0.01202047f, -0.04398994f, 
    -0.01516750f, 0.04423897f, 0.06578466f, -0.03903162f, -0.00410104f, 0.04488369f, -0.02887339f, -0.03242719f, 
    -0.05930379f, -0.03412597f, -0.07122877f, -0.01835250f, -0.00268078f, 0.01768924f, -0.02444575f, 0.03477639f, 
    0.02907494f, 0.02991645f, -0.04136717f, 0.01028693f, -0.03353696f, 0.05569775f, -0.04181400f, -0.07297149f, 
    0.05256425f, -0.04239044f, -0.04854186f, 0.04671571f, -0.05285197f, -0.03079427f, -0.05486982f, 0.04185468f, 
    0.03490494f, -0.04363557f, -0.08168353f, -0.05483622f, 0.00710812f, 0.05900093f, -0.03025599f, -0.02597616f, 
    -0.04700666f, 0.04725889f, 0.01271682f, 0.02911239f, 0.03123093f, -0.00411146f, 0.04836371f, 0.03713285f, 
    -0.07776052f, -0.03192960f, -0.07465134f, -0.04272235f, -0.01112435f, -0.02823880f, 0.03210234f, 0.00085945f, 
    -0.00822473f, 0.00129041f, 0.01028808f, -0.06173086f, -0.03309481f, -0.04723922f, -0.05397615f, -0.04058281f, 
    -0.03886512f, -0.00606865f, 0.02096679f, 0.03332624f, -0.04977579f, 0.05138486f, -0.05052444f, -0.02917483f, 
    -0.06616212f, -0.01465986f, 0.03470259f, -0.02087708f, -0.07333339f, 0.00448832f, -0.07405259f, 0.03651521f, 
    0.01582533f, 0.05011411f, 0.01289611f, -0.07428824f, -0.05875357f, 0.02591739f, -0.00949265f, 0.01986049f, 
    0.02820326f, -0.03288290f, -0.04016707f, 0.01015738f, -0.05478874f, -0.07113295f, 0.02406392f, -0.01755154f, 
    -0.01654995f, 0.01524753f, 0.02040265f, 0.02632058f, 0.05113737f, 0.02445387f, -0.00436925f, -0.04163389f, 
    0.04550854f, 0.02508407f, 0.05480551f, -0.06404865f, 0.01047062f, 0.05755783f, 0.05740517f, 0.02064279f, 
    0.05985150f, -0.01773004f, -0.01818636f, 0.00406908f, -0.03312267f, -0.05560055f, -0.06539728f, -0.00967448f, 
    0.01861720f, 0.03686275f, -0.07934364f, -0.03836444f, 0.01990779f, 0.00596206f, 0.02009819f, -0.02058769f, 
    -0.06017429f, 0.04485740f, -0.02739514f, -0.03044678f, 0.04967472f, -0.03214783f, 0.04838818f, 0.04190437f, 
    0.04724794f, 0.01645400f, -0.07301620f, 0.01693253f, -0.03302783f, 0.01676516f, 0.01525811f, 0.00846289f, 
    -0.02414376f, -0.07661172f, 0.05472343f, 0.03811354f, -0.03867037f, -0.03645555f, -0.02736444f, 0.05290298f, 
    0.05014363f, -0.02489256f, 0.01940485f, 0.02684039f, 0.02389582f, -0.03403877f, -0.01107089f, 0.01741475f, 
    -0.05526908f, 0.01888219f, -0.04552858f, -0.02881140f, 0.03455042f, -0.02375149f, -0.04041500f, 0.03982283f, 
    -0.05010686f, 0.05495698f, -0.07862083f, -0.07097162f, 0.03554881f, -0.07360645f, -0.00414527f, 0.03036349f, 
    0.02815112f, 0.03962627f, 0.02262283f, 0.01548141f, 0.06206261f, 0.04565421f, -0.05089895f, -0.06522644f, 
    -0.04791616f, 0.01290125f, -0.05821406f, -0.03538953f, 0.05391114f, -0.03712324f, 0.02144907f, 0.03691202f, 
    -0.03920084f, 0.01611915f, -0.01717470f, -0.05960559f, -0.04979519f, -0.00805994f, 0.04131915f, 0.02713638f, 
    0.00953587f, 0.01979236f, 0.03272776f, 0.02207365f, -0.00942324f, -0.04868609f, 0.04366370f, -0.06981403f, 
    -0.07133181f, 0.04783973f, 0.05702875f, 0.03648293f, 0.05744066f, -0.05491120f, -0.05937272f, -0.08073977f, 
    0.01387002f, 0.04132660f, 0.03681152f, -0.01284590f, 0.02199980f, 0.03905968f, -0.06358916f, -0.08427589f, 
    -0.06217162f, -0.00571343f, 0.03960734f, -0.03515302f, -0.06491155f, -0.04630321f, -0.02808171f, 0.01188631f, 
    -0.00019241f, -0.03292186f, 0.03421381f, -0.02091073f, 0.02730968f, 0.01190562f, -0.06186871f, 0.05208829f, 
    -0.06338710f, -0.06793470f, 0.05325733f, -0.02817912f, -0.04565272f, 0.05203938f, -0.02765160f, 0.03971566f, 
    -0.03517053f, 0.01044976f, -0.02414044f, 0.05109607f, -0.07095721f, -0.04551735f, -0.01371048f, -0.06731178f, 
    -0.04907324f, 0.00300739f, -0.05876057f, -0.02241021f, -0.07906505f, 0.01969189f, -0.03939938f, 0.03572307f, 
    -0.01280524f, -0.02808128f, -0.03494830f, -0.06871630f, 0.03303275f, -0.07745055f, 0.02493855f, -0.02035219f, 
    -0.02563617f, -0.06458127f, -0.07319102f, -0.05089470f, 0.00864094f, 0.03851225f, 0.03148389f, -0.03463956f, 
    0.05190047f, -0.05432137f, 0.01397459f, -0.06219613f, -0.02746528f, 0.01312212f, -0.01627686f, 0.01333094f, 
    -0.07062554f, -0.04805473f, -0.06257146f, 0.05137608f, -0.06691136f, -0.07847061f, -0.01466566f, -0.06856405f, 
    -0.06460569f, -0.02550662f, -0.01735588f, -0.04913353f, 0.00401166f, 0.03116763f, -0.03399025f, -0.05698185f, 
    0.16149330f, 0.09229279f, -0.04807834f, 0.41800523f, 0.22934881f, 0.01368054f, 0.07815184f, 0.01856818f, 
    0.18258126f, -0.04157371f, 0.03849552f, 0.08783245f, 0.11632828f, 0.13975848f, 0.07436989f, 0.02495121f, 
    0.10011346f, -0.13573903f, -0.01358200f, 0.01592696f, 0.02108005f, 0.07080345f, 0.15664504f, 0.07002869f, 
    0.09990709f, 0.37375885f, 0.23372382f, 0.40787181f, 0.03570659f, 0.07915758f, 0.03635683f, 0.25688797f, 
    0.06952156f, 0.00997067f, -0.01153383f, -0.10198778f, -0.43330589f, 0.07470500f, -0.11753264f, -0.11375855f, 
    -0.06798458f, 0.05565020f, -0.09177272f, 0.07569149f, -0.09069683f, -0.07628886f, -0.05770827f, 0.07295604f, 
    0.01560109f, 0.11276665f, 0.14676745f, 0.14015231f, 0.00284073f, -0.09996755f, 0.07626946f, -0.03327797f, 
    0.12600896f, -0.09892260f, -0.01875599f, -0.02301557f, 0.18618384f, -0.00535608f, -0.09179648f, 0.05565920f, 
    0.00752263f, -0.00625215f, -0.04305006f, -0.02391913f, 0.03029700f, 0.05948061f, 0.06065639f, -0.03462354f, 
    -0.39463633f, -0.20041175f, 0.06485628f, 0.28550681f, 0.01560903f, 0.04878543f, -0.10370492f, -0.03186120f, 
    -0.13207613f, -0.06002417f, 0.06178118f, 0.05594942f, 0.13920131f, 0.24492137f, 0.19839561f, -0.11671001f, 
    0.04720521f, 0.00794525f, 0.00726809f, 0.02607585f, 0.05553529f, -0.04686028f, 0.07285564f, 0.03749938f, 
    0.38917005f, 0.00733710f, 0.10352309f, 0.30485436f, 0.01313005f, -0.13059166f, 0.02479186f, 0.04726562f, 
    -0.01105354f, 0.13069436f, 0.10324930f, 0.05841274f, -0.22799346f, 0.21217558f, -0.07538047f, 0.04126244f, 
    -0.01382186f, -0.06486565f, 0.10219163f, 0.12715732f, -0.14799054f, -0.02252193f, 0.06011578f, -0.07532136f, 
    -0.20143378f, 0.09324517f, -0.04088747f, 0.21809341f, 0.09459059f, -0.01236185f, 0.00426410f, -0.16274312f, 
    -0.20375647f, 0.01313808f, 0.07752941f, 0.08092628f, -0.39504969f, 0.06714608f, 0.13793559f, -0.40960586f, 
    -0.08792187f, -0.03707088f, 0.03879987f, -0.06042538f, -0.01838053f, -0.09811150f, -0.05495605f, 0.00098125f, 
    -0.21134579f, -0.32524347f, -0.01688986f, -0.25099885f, -0.11250979f, -0.11090232f, 0.01915836f, -0.04648248f, 
    0.06403774f, 0.04646454f, 0.01510722f, 0.29713216f, -0.22541396f, -0.22634184f, -0.06979251f, -0.18662339f, 
    0.00593417f, 0.01364410f, 0.07323547f, 0.13960063f, -0.11653528f, -0.03615333f, 0.00776932f, -0.29997638f, 
    0.12830162f, -0.01839610f, 0.09331919f, 0.10774321f, -0.01891568f, -0.04278111f, -0.05504507f, -0.03641722f, 
    0.01670275f, 0.07684952f, -0.04959324f, 0.12601092f, -0.25998759f, 0.40257439f, 0.25595456f, -0.14828864f, 
    -0.01189718f, -0.06754473f, 0.06794316f, 0.12588568f, 0.07641233f, -0.00072299f, -0.03282232f, -0.16774070f, 
    0.20912869f, 0.16627957f, 0.04882637f, 0.11788617f, 0.03712633f, 0.11964741f, -0.00203780f, 0.04210728f, 
    0.08402825f, 0.10667869f, 0.00421750f, 0.19009709f, -0.44308674f, 0.03119324f, -0.05106900f, -0.14505932f, 
    -0.07877926f, -0.08202232f, -0.09055267f, -0.05875726f, 0.00372787f, -0.07184184f, 0.11311627f, -0.03054005f, 
    -0.07857686f, -0.02313750f, -0.09054106f, -0.01266042f, -0.11823010f, -0.05461621f, 0.05202817f, -0.02940364f, 
    -0.06927843f, -0.12369169f, -0.10211544f, -0.05580017f, -0.42745548f, 0.03585889f, 0.10438486f, 0.08326028f, 
    0.15721604f, -0.03027467f, 0.10263608f, -0.00888622f, -0.04058916f, -0.11151828f, 0.05866791f, 0.00313839f, 
    0.29371324f, 0.00809786f, -0.04666357f, 0.00324627f, 0.01187012f, -0.09354986f, -0.04720775f, 0.05588443f, 
    -0.12497117f, 0.05494290f, 0.01055420f, -0.02326830f, -0.21131355f, -0.15565734f, -0.19794476f, -0.20351151f, 
    0.08143277f, 0.09258512f, -0.04056440f, 0.00224672f, 0.03368356f, -0.04822577f, -0.01399286f, 0.07684574f, 
    0.32239830f, -0.26191527f, 0.02333167f, -0.03337902f, 0.17138991f, 0.02469107f, -0.00479077f, -0.01430985f, 
    0.11236321f, 0.03431079f, 0.13248627f, 0.09565469f, -0.29862669f, -0.11426758f, 0.17353384f, 0.13022557f, 
    -0.11266746f, 0.03388410f, -0.10788152f, 0.05742850f, 0.01497735f, 0.07162895f, 0.05481228f, -0.00514798f, 
    0.05936024f, 0.27241912f, 0.00999303f, -0.22894940f, -0.10782806f, 0.03961276f, -0.00115066f, -0.00344627f, 
    -0.16983283f, 0.01662896f, 0.06682843f, 0.09817483f, 0.06807050f, -0.00302561f, 0.07349963f, 0.06160269f, 
    0.04142618f, 0.00881979f, 0.00349620f, 0.05287543f, 0.07195697f, 0.04583578f, 0.11682667f, -0.08900575f, 
    0.41888711f, -0.02476770f, -0.03632158f, 0.15529089f, 0.22712810f, -0.03779038f, 0.01981286f, 0.04696428f, 
    0.14136021f, 0.07777409f, 0.01298866f, -0.05709763f, 0.30238247f, 0.10305256f, 0.10982427f, 0.03543013f, 
    0.02012211f, -0.00766833f, -0.05396492f, -0.03745145f, -0.02149978f, 0.07919092f, 0.03890413f, 0.10202485f, 
    -0.04134577f, 0.27718902f, -0.08706681f, 0.00212796f, 0.17633057f, -0.07475441f, 0.05459430f, 0.11584602f, 
    -0.20884149f, 0.05276399f, -0.09233871f, -0.07300317f, 0.22310181f, 0.00039450f, 0.00577621f, 0.14838760f, 
    0.08676644f, 0.08534104f, 0.09531531f, -0.07439569f, 0.08502860f, 0.03743962f, 0.06346623f, -0.12217541f, 
    -0.05105750f, 0.11997606f, -0.12952715f, 0.04524515f, 0.00134348f, 0.17862892f, 0.09355056f, 0.01833500f, 
    0.06639672f, 0.01132643f, -0.04360472f, 0.16583315f, -0.01154607f, -0.18135561f, -0.14008246f, -0.14380743f, 
    -0.01830504f, 0.00990984f, -0.12072662f, 0.08900637f, 0.00691753f, -0.11467188f, 0.08444922f, -0.12781130f, 
    -0.08681270f, 0.22251447f, -0.04945346f, -0.04683613f, 0.09253458f, -0.11190925f, -0.04090102f, -0.06222106f, 
    0.10750125f, 0.05245283f, -0.05278694f, -0.16347036f, -0.34962460f, 0.34096229f, -0.19867103f, 0.32999548f, 
    0.02072789f, -0.07636179f, -0.10188323f, -0.07667504f, 0.16029109f, -0.07157229f, -0.03186148f, -0.02972850f, 
    -0.26649225f, -0.25467739f, 0.09053149f, 0.08034576f, -0.02199996f, -0.03951041f, 0.19439536f, -0.04590568f, 
    -0.06084377f, -0.06745467f, 0.09753529f, 0.06624285f, -0.16833667f, 0.27328888f, -0.00191601f, -0.08824448f, 
    -0.01747003f, 0.02715855f, 0.02510104f, 0.20791565f, 0.15057293f, 0.03876869f, 0.02456606f, -0.00750555f, 
    -0.25069338f, 0.07281385f, -0.00693421f, -0.50706226f, -0.03678788f, -0.11723929f, 0.13826130f, -0.01670654f, 
    0.00751270f, -0.05424251f, -0.15675473f, 0.12859730f, 0.46818537f, 0.25665769f, 0.26872486f, 0.27952880f, 
    -0.12302398f, -0.03510701f, -0.13125613f, 0.02768385f, 0.01926274f, 0.12786755f, 0.13427086f, 0.04136197f, 
    0.04581248f, -0.21205658f, 0.32727355f, 0.42308071f, -0.03858723f, -0.00659395f, 0.02134356f, 0.05909640f, 
    0.16004726f, -0.02065211f, 0.03291479f, 0.02857306f, 0.35429883f, 0.31134424f, -0.24587075f, -0.24834566f, 
    0.03246520f, 0.15236606f, 0.13423501f, -0.02859730f, 0.05915758f, 0.06277689f, -0.15046000f, 0.00464096f, 
    -0.18857943f, 0.20814730f, 0.11270247f, -0.04720503f, -0.00669070f, 0.08042308f, 0.14381081f, 0.15964182f, 
    0.18686377f, 0.03024302f, 0.16826397f, 0.00560350f, -0.45730224f, -0.07523306f, 0.03803023f, -0.45679471f, 
    -0.04717043f, -0.14365345f, 0.05924829f, 0.02807984f, 0.00539753f, 0.14082852f, 0.06368031f, 0.00041641f, 
    -0.10785943f, -0.06857065f, -0.11441532f, -0.01350586f, 0.13788940f, -0.03839611f, -0.17281769f, -0.02231049f, 
    0.11627546f, 0.12823251f, 0.15032005f, 0.21385138f, -0.11503733f, -0.04475536f, -0.03095747f, -0.07081942f, 
    -0.04668232f, 0.01545147f, -0.12986527f, 0.20929286f, -0.10717274f, 0.10880505f, -0.05351667f, -0.04196436f, 
    -0.01176212f, 0.18152438f, -0.13960193f, 0.16145094f, 0.09308083f, -0.01799312f, 0.18678184f, -0.01058026f, 
    -0.00446464f, 0.23558588f, -0.04533090f, 0.07411661f, 0.04217691f, 0.03958366f, 0.06706842f, 0.18775895f, 
    0.03646767f, -0.07631745f, 0.02462262f, 0.05996432f, -0.10657139f, 0.10514754f, -0.12870730f, -0.02210057f, 
    0.12210976f, 0.05942276f, 0.01689494f, -0.29624495f, 0.10533544f, -0.18977393f, -0.09092440f, 0.07044803f, 
    0.00572025f, -0.01381215f, 0.02894763f, 0.12319230f, -0.18068832f, 0.17046471f, -0.00127904f, -0.20264122f, 
    -0.27271390f, 0.02217399f, -0.02837089f, -0.07479113f, -0.04852887f, -0.13646567f, 0.07818756f, 0.10285058f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05724408f, 0.09707652f, 0.01696471f, 0.00709823f, -0.10252267f, 0.17350718f, -0.14980319f, -0.04049775f, 
    0.14231645f, 0.00177958f, 0.07816895f, 0.13599099f, -0.02950966f, 0.03563381f, -0.03222114f, 0.05016509f, 
    -0.08390160f, 0.08883667f, 0.00690756f, 0.00997818f, -0.02919807f, 0.01973785f, -0.08698482f, 0.12628080f, 
    -0.05734360f, 0.00201338f, 0.08215275f, -0.01265572f, -0.04958710f, -0.05974934f, 0.20860200f, 0.10926200f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.18477292f, -0.14780460f, 0.10008927f, 0.02236588f, 0.30347556f, -0.14214487f, 0.24598631f, -0.21043324f, 
    -0.00599810f, 0.68815631f, 0.15750265f, 0.04998793f, -0.02177000f, -0.35739687f, -0.06687319f, -0.23068984f, 
    0.03983296f, 0.01629200f, 0.11830423f, -0.12295242f, 0.03052093f, 0.08206870f, -0.10844164f, 0.33638567f, 
    0.06047124f, 0.57631958f, -0.29543498f, -0.02819690f, 0.05125381f, 0.28556827f, -0.23566803f, 0.33639002f, 
    0.18636763f, 0.00702291f, 0.17699870f, -0.05261642f, 0.50422496f, 0.11956348f, 0.40878257f, -0.23021887f, 
    0.28906888f, -0.22886428f, -0.42413595f, -0.46985283f, 0.08843739f, 0.24660902f, -0.10403699f, 0.46081713f, 
    0.03855161f, 0.00506775f, -0.17608252f, -0.06025406f, -0.01455379f, 0.06797191f, -0.31827939f, 0.09188762f, 
    0.11594532f, 0.35721403f, 0.39235070f, -0.17497183f, 0.04054380f, 0.18463770f, 0.02755796f, 0.29031387f, 
    0.08713172f, 0.22080269f, -0.25423953f, 0.08526956f, 0.42594135f, -0.28533486f, 0.41693768f, 0.01671345f, 
    -0.22209871f, 0.00290948f, -0.07866656f, 0.42493626f, -0.13807781f, -0.02216972f, 0.15842296f, 0.04100484f, 
    0.11470030f, -0.06890825f, -0.33628696f, 0.08585697f, 0.43270129f, -0.02097878f, 0.22339195f, -0.03417903f, 
    0.07922275f, 0.43502802f, 0.20867866f, 0.09853376f, -0.00317307f, 0.09376421f, -0.16012253f, 0.61516309f, 
    -0.22895852f, 0.12287335f, -0.28778729f, 0.01767164f, -0.04180673f, 0.38069308f, 0.10017557f, 0.57258177f, 
    0.24511859f, 0.74998236f, 0.32835031f, -0.05061922f, -0.05038675f, -0.43568632f, 0.08339333f, 0.22841920f, 
    0.09000424f, 0.23519205f, 0.42617208f, -0.05287733f, 0.37286803f, 0.02189669f, 0.32420325f, 0.07121299f, 
    0.12959133f, 0.03260067f, -0.51803750f, -0.06015893f, 0.16354591f, 0.03811765f, -0.01321623f, -0.01342149f, 
    0.07934228f, 0.33657026f, 0.17645320f, -0.15176788f, 0.44760492f, -0.18690570f, 0.21964531f, -0.22923256f, 
    0.29143557f, 0.37664333f, -0.27283314f, 0.12191311f, 0.05362589f, -0.28256270f, -0.09257137f, -0.23394577f, 
    0.08068515f, -0.10597277f, 0.06267340f, -0.35172155f, -0.14007834f, -0.03696521f, 0.25063372f, 0.37022197f, 
    -0.11413309f, 0.02081350f, -0.22712864f, 0.03823952f, 0.04134842f, 0.31314084f, -0.23177058f, 0.05575044f, 
    -0.32158855f, -0.09572412f, -0.25566906f, 0.08646625f, 0.22196619f, 0.36238354f, 0.27866885f, 0.26357976f, 
    -0.05518400f, 0.35394520f, 0.27857184f, -0.08823382f, 0.04787825f, 0.31180379f, 0.06012447f, 0.18263353f, 
    0.18690762f, -0.28938270f, -0.05078683f, -0.05632183f, 0.33510703f, 0.19327897f, 0.00328350f, 0.16245678f, 
    -0.00630957f, 0.26642156f, -0.16300239f, -0.07176261f, 0.14457797f, -0.01662163f, 0.02629850f, -0.21345539f, 
    0.15930822f, -0.14110726f, -0.16800064f, -0.08239848f, 0.11573183f, -0.09463515f, -0.00314476f, -0.09271392f, 
    0.14698114f, -0.02840538f, -0.15452503f, -0.11462421f, -0.06015627f, -0.13171907f, 0.15929779f, 0.09819885f, 
    -0.02089097f, 0.10492307f, -0.16553469f, -0.10030820f, 0.13737983f, -0.09872366f, 0.00269677f, -0.14637433f, 
    -0.10338616f, 0.12557776f, -0.00968490f, -0.10586078f, -0.14321096f, -0.16056551f, 0.15178235f, -0.16123062f, 
    0.01217889f, 0.02502621f, 0.18471520f, 0.06648783f, 0.22873698f, 0.29060939f, 0.07903926f, 0.17414969f, 
    -0.25441307f, 0.23157100f, 0.12673466f, 0.45436332f, -0.10549790f, 0.20956269f, -0.15810184f, -0.53644264f, 
    0.05455886f, -0.41649085f, -0.28043941f, 0.13506737f, -0.21934575f, 0.20935553f, 0.14705536f, -0.34731489f, 
    -0.12864020f, 0.26480415f, 0.03374922f, 0.02807361f, -0.08159344f, 0.29461619f, -0.17589119f, -0.30789945f, 
    -0.06243699f, -0.02723452f, 0.02406556f, 0.06511399f, 0.31709319f, 0.37526500f, 0.18873443f, 0.28258434f, 
    0.47273198f, 0.33189005f, -0.09293701f, 0.12938710f, 0.14762641f, 0.17096487f, -0.14856310f, 0.20227118f, 
    0.07168535f, -0.02614069f, -0.03112638f, 0.35616904f, -0.17656268f, -0.36654398f, -0.12926549f, -0.01817251f, 
    -0.06811731f, 0.43180329f, 0.10198090f, -0.03027916f, 0.12277550f, 0.06362074f, 0.19863270f, -0.31142274f, 
    0.22461399f, -0.35187438f, 0.07354854f, -0.10029931f, 0.05179213f, 0.01206405f, 0.27909806f, -0.04260079f, 
    0.02808228f, -0.36923724f, -0.15354446f, 0.24551336f, -0.08386700f, 0.49220690f, -0.07679004f, -0.05333387f, 
    -0.01464670f, -0.09856167f, -0.15195830f, 0.38669187f, -0.21032171f, -0.01204544f, -0.29569069f, -0.02838802f, 
    -0.14418729f, 0.11278802f, -0.01560801f, 0.07860521f, 0.00851623f, 0.31375846f, 0.35663897f, -0.42696223f, 
    -0.22688983f, -0.40711832f, 0.11450610f, 0.12498749f, -0.05707527f, -0.00085448f, 0.01739814f, 0.30607292f, 
    -0.05180772f, -0.09758182f, 0.06778692f, 0.17213629f, -0.11993903f, -0.09873032f, 0.06936268f, 0.29590425f, 
    0.01320983f, 0.18353555f, 0.17412487f, 0.22812304f, 0.03946693f, -0.28105858f, -0.16621070f, 0.25129902f, 
    -0.04243578f, 0.31232870f, -0.04853482f, 0.14650308f, 0.01673050f, 0.20764309f, 0.21151304f, 0.11073399f, 
    -0.03484897f, 0.00217382f, -0.00476559f, 0.15487044f, -0.05917053f, -0.03898662f, 0.04019029f, -0.16235362f, 
    0.06648235f, -0.02867891f, -0.11973103f, -0.14580598f, -0.12088874f, -0.06245190f, 0.00144725f, -0.17064814f, 
    0.06284532f, -0.00324732f, -0.12268692f, 0.12152544f, -0.06071527f, -0.08364892f, -0.07233512f, -0.09453654f, 
    0.06194221f, -0.16873226f, -0.14356272f, -0.02731896f, -0.00139911f, 0.10749661f, -0.04268698f, -0.06936793f, 
    -0.15908888f, -0.08440746f, 0.14062935f, -0.07626822f, 0.03830499f, -0.00262478f, 0.00346490f, 0.10107785f, 
    -0.05940505f, -0.07029119f, 0.02402944f, 0.09349684f, -0.12655872f, -0.10909428f, 0.10107554f, 0.16264328f, 
    0.08482455f, -0.16717108f, 0.04884600f, -0.11235497f, -0.14444858f, 0.15546396f, -0.02791433f, 0.03668093f, 
    0.08923281f, 0.07778396f, -0.09915391f, 0.14324026f, -0.10525601f, -0.04611236f, -0.14014882f, -0.01568760f, 
    0.41806033f, 0.29798403f, 0.42727485f, 0.13295239f, -0.41379115f, 0.11439260f, -0.52043903f, -0.12466434f, 
    0.04896158f, -0.54685605f, 0.10721455f, 0.06054100f, 0.14691296f, -0.19656006f, -0.12509437f, 0.30771917f, 
    0.00805505f, 0.40066272f, -0.09262455f, -0.12179917f, -0.15857226f, 0.17232169f, -0.00040188f, 0.05553626f, 
    -0.11312774f, -0.33290365f, 0.36342505f, 0.06079213f, 0.12968613f, 0.06875717f, -0.01135598f, 0.46183050f, 
    -0.07672990f, -0.10184343f, -0.21925710f, 0.06673279f, 0.45380223f, 0.25321686f, -0.06284604f, -0.00745396f, 
    -0.31846720f, -0.24456182f, 0.18110628f, -0.15243302f, 0.02990915f, 0.18980326f, 0.09927611f, 0.06874993f, 
    0.13442780f, 0.05223375f, -0.13568084f, -0.37595922f, 0.56866968f, 0.59557509f, -0.26446408f, -0.07696782f, 
    -0.08955733f, 0.09704110f, 0.27974945f, -0.00430275f, 0.16304231f, 0.04084226f, -0.27380532f, 0.17062557f, 
    0.21500561f, -0.16160117f, -0.06455148f, 0.12184787f, -0.14378680f, 0.00019616f, 0.28491750f, 0.36777738f, 
    -0.05129487f, -0.31723586f, 0.10829526f, 0.07591701f, 0.01328888f, 0.26159126f, 0.06441412f, 0.23934878f, 
    0.09126445f, 0.18356800f, -0.22355020f, 0.45539847f, -0.20340584f, -0.27909091f, 0.02759606f, -0.26753113f, 
    -0.13008432f, 0.22061189f, 0.49328393f, 0.01664807f, 0.08199152f, 0.04557547f, 0.17216471f, 0.14430200f, 
    -0.22634001f, 0.48023683f, -0.29006273f, -0.01746524f, 0.22300957f, 0.15507288f, -0.23768997f, 0.00139609f, 
    0.68576425f, 0.07772139f, -0.30982238f, 0.20034952f, -0.13379253f, -0.13506888f, 0.02505176f, 0.19094715f, 
    -0.13691555f, 0.11887603f, 0.16188271f, 0.02340866f, 0.16101146f, 0.14205833f, 0.12971546f, 0.34131393f, 
    0.14877088f, -0.02723525f, -0.18705907f, -0.09163501f, -0.15834659f, 0.06942409f, 0.42115256f, -0.22206326f, 
    0.04655382f, 0.43202347f, 0.34549052f, -0.00191513f, 0.27746758f, -0.10704738f, 0.19915557f, -0.18596952f, 
    0.20587246f, 0.29864079f, 0.04432560f, -0.13892302f, -0.11195342f, 0.04639361f, 0.15173210f, -0.32547271f, 
    0.02856459f, 0.11664085f, 0.22164333f, -0.25991127f, -0.38202715f, 0.28344050f, 0.06493151f, 0.27178979f, 
    0.07378019f, -0.29812047f, -0.07079753f, -0.11476224f, 0.07786556f, 0.00637417f, 0.04278862f, -0.26515254f, 
    0.09486093f, 0.39465418f, 0.05531223f, 0.12423630f, -0.02148080f, 0.33208555f, -0.38059485f, -0.20830074f, 
    0.36634851f, -0.19044764f, 0.30736399f, 0.35366842f, 0.10286985f, 0.18202457f, 0.12603384f, -0.54294670f, 
    -0.09144653f, -0.19889407f, 0.03001746f, -0.14471874f, 0.02153396f, 0.14996278f, 0.07864221f, 0.13664110f, 
    0.05323534f, -0.39947850f, 0.27337882f, 0.10333207f, -0.17616841f, -0.08556686f, 0.09782232f, 0.22372492f, 
    -0.06771762f, -0.65787661f, 0.21088529f, 0.08697420f, -0.18989657f, -0.10800026f, 0.36449388f, 0.19829620f, 
    -0.47746494f, 0.49678430f, 0.28801906f, -0.19284458f, -0.06034113f, 0.05790177f, -0.07032316f, 0.26403335f, 
    -0.03533400f, 0.20495318f, 0.42331696f, 0.06075863f, 0.26776910f, 0.49537084f, -0.04336020f, 0.15312175f, 
    -0.05479653f, 0.24316016f, -0.40179142f, 0.11984999f, -0.04566471f, 0.31723934f, -0.30766019f, -0.25683984f, 
    0.04565643f, 0.36691651f, -0.29331762f, 0.14702523f, 0.29669499f, 0.05074109f, 0.71250683f, 0.11493712f, 
    -0.26639283f, -0.01412839f, -0.17862207f, 0.13030100f, 0.00630450f, 0.33781165f, -0.02078876f, -0.02546346f, 
    0.09675150f, 0.11598495f, -0.15192996f, -0.01240471f, 0.31280321f, -0.16998361f, 0.29549664f, -0.25968075f, 
    -0.00106699f, 0.02866697f, -0.01970278f, -0.00860630f, -0.09467673f, 0.07059307f, -0.20991385f, 0.28083858f, 
    -0.03734161f, -0.36596659f, -0.17800617f, -0.07340963f, -0.15607287f, 0.40461284f, -0.33735171f, -0.02533602f, 
    0.22816233f, 0.01665539f, -0.12427366f, -0.46563756f, -0.08336242f, -0.00867075f, -0.12162497f, 0.54957354f, 
    0.01746721f, 0.31225675f, 0.06421620f, 0.31365061f, 0.22755414f, 0.29989409f, -0.35948300f, 0.01696282f, 
    0.06517348f, 0.07936625f, -0.10623691f, -0.04459851f, 0.09070732f, -0.08181980f, 0.16605182f, 0.14855598f, 
    0.38424730f, -0.11846511f, 0.45739862f, -0.13999830f, -0.01254749f, 0.46482512f, 0.38956052f, 0.37398070f, 
    -0.07841639f, -0.09689000f, 0.13826181f, -0.41358241f, 0.04822902f, 0.18634644f, -0.02651667f, -0.13667993f, 
    0.06573834f, 0.19164258f, 0.01274614f, 0.24175315f, -0.40999258f, 0.08807901f, 0.40460730f, -0.28214324f, 
    -0.13176721f, -0.23196861f, -0.19522011f, 0.03028318f, 0.05881227f, -0.04954729f, -0.32976031f, -0.27208051f, 
    -0.12782575f, -0.40544915f, -0.06824754f, -0.08176185f, 0.06931400f, 0.27319625f, 0.05167215f, 0.27506226f, 
    0.21804558f, 0.18768683f, 0.29546928f, 0.24102616f, 0.11752991f, 0.25333783f, 0.00461333f, -0.28178623f, 
    0.04293099f, -0.25290260f, -0.02588684f, 0.52490926f, -0.37719333f, -0.44589850f, -0.12043291f, 0.14174424f, 
    -0.07174512f, 0.32210630f, 0.12762421f, -0.17310987f, 0.12754616f, 0.19260788f, 0.38341138f, -0.03858742f, 
    0.39186108f, -0.04898036f, 0.05871859f, 0.14604215f, -0.37698129f, -0.10641426f, 0.33191901f, 0.15602678f, 
    -0.49645567f, 0.45918596f, 0.38178799f, 0.18351106f, 0.09102347f, -0.07415794f, 0.17763312f, 0.07432990f, 
    -0.06957081f, 0.12628703f, 0.31209469f, -0.30219859f, 0.05107757f, 0.24486515f, 0.41422409f, 0.01169288f, 
    -0.07638741f, -0.35582897f, -0.13160117f, -0.01845356f, 0.04518704f, -0.13103646f, -0.35050920f, -0.04978435f, 
    0.28847912f, 0.35609797f, -0.07093767f, 0.06119197f, -0.44003990f, -0.21685684f, -0.18198866f, -0.11344469f, 
    -0.15653372f, -0.40941882f, 0.01397602f, 0.41654038f, 0.16895157f, 0.17442808f, -0.14930861f, 0.02794177f, 
    -0.07012993f, 0.36394528f, 0.21251990f, -0.20463681f, -0.00588176f, 0.06538600f, 0.21491320f, 0.24592477f, 
    0.03252319f, -0.56125456f, 0.15195158f, -0.10223012f, -0.14881022f, -0.08015367f, 0.21768959f, 0.19770187f, 
    -0.11523491f, 0.33079070f, -0.33679181f, -0.15087596f, -0.03686539f, 0.30326891f, -0.27727622f, 0.37190047f, 
    0.40265557f, -0.03237073f, 0.10652337f, -0.02300391f, 0.08274105f, 0.19760391f, -0.13590643f, 0.46209580f, 
    0.17486900f, 0.10242371f, -0.09127899f, 0.24649145f, 0.36627224f, -0.02149168f, -0.12997724f, 0.11630061f, 
    -0.09713474f, -0.11247703f, 0.09535649f, -0.11893310f, 0.09692080f, -0.15459573f, 0.47206536f, -0.10782581f, 
    -0.00364420f, -0.20342763f, -0.35905042f, 0.07103495f, -0.12775540f, 0.28390729f, -0.07130136f, 0.22453274f, 
    -0.09004380f, 0.01295587f, 0.15105240f, 0.34665957f, -0.00595398f, -0.12536173f, 0.16515973f, 0.06105529f, 
    0.17184375f, 0.07286582f, 0.00553353f, 0.31286508f, -0.09200528f, -0.44684747f, 0.12904455f, -0.08630188f, 
    0.09143613f, 0.15231392f, 0.09660634f, -0.17368869f, -0.01198383f, -0.20020966f, -0.04588187f, 0.33411923f, 
    -0.12572637f, 0.09099998f, -0.06345998f, -0.05632330f, -0.03331513f, -0.07145103f, -0.08857071f, -0.01629253f, 
    0.04259763f, -0.12000805f, -0.06157714f, -0.10239241f, -0.07015897f, -0.19631976f, -0.05794216f, 0.01773444f, 
    0.12766561f, -0.14933601f, 0.08378751f, -0.10459922f, 0.09305114f, 0.12369636f, -0.10961280f, -0.16984136f, 
    0.12654151f, 0.06262688f, 0.04442931f, 0.01767835f, 0.16620812f, -0.06607524f, 0.02016874f, 0.00436118f, 
    -0.00176671f, -0.02414557f, -0.18610969f, 0.04990370f, -0.05503171f, -0.09018299f, -0.05912714f, -0.15229897f, 
    -0.09523904f, 0.15705009f, -0.06252006f, 0.05935473f, -0.07396004f, -0.19163528f, 0.06061920f, -0.07194164f, 
    -0.04860872f, 0.10801448f, 0.19264044f, -0.08783800f, 0.16902240f, 0.03029876f, 0.07004705f, -0.15801147f, 
    -0.09988733f, 0.10315102f, -0.02050166f, -0.07971400f, -0.03686593f, -0.08870085f, -0.00689425f, -0.02946722f, 
    -0.07564314f, -0.17878325f, -0.02424136f, -0.06898491f, -0.29654497f, 0.03312112f, -0.10638428f, 0.14659670f, 
    -0.03594256f, 0.48323414f, 0.63222241f, 0.04479301f, -0.00664312f, 0.07343575f, 0.06716038f, -0.14141661f, 
    -0.00376350f, -0.07295693f, 0.48551366f, 0.21537918f, -0.27821660f, 0.07221507f, 0.10921851f, 0.18843649f, 
    -0.11635480f, -0.16397132f, 0.31130034f, -0.07064541f, 0.17164299f, -0.10200095f, 0.24802683f, 0.20891626f, 
    -0.14735135f, 0.02101273f, 0.13015100f, -0.02845680f, -0.07326327f, -0.08760978f, -0.43285218f, -0.29417953f, 
    0.28436509f, -0.12259246f, 0.01945563f, 0.45442981f, -0.05438808f, -0.36167434f, -0.00906071f, -0.24962808f, 
    -0.10185166f, 0.04417408f, -0.12616459f, 0.23744966f, 0.27324188f, 0.35072589f, -0.10107428f, 0.21828695f, 
    0.11078426f, 0.42838302f, 0.36735114f, -0.16111061f, -0.14905047f, 0.40088558f, 0.09663559f, 0.57599944f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03848399f, -0.01986524f, -0.11656914f, 0.03416932f, -0.01005463f, 0.02534692f, -0.03200685f, 0.14115657f, 
    -0.08972424f, 0.19767083f, 0.25006381f, -0.00535709f, -0.11172067f, 0.25411126f, -0.10294668f, -0.02291662f, 
    0.02979054f, -0.07749156f, 0.06885817f, -0.00409270f, 0.04344777f, -0.02854641f, 0.20432958f, 0.00056987f, 
    0.10529087f, 0.14912634f, 0.07260758f, -0.08847602f, -0.00845543f, -0.16754919f, 0.18049671f, -0.00964613f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.50208807f, 0.23680288f, 0.17901377f, 0.13629876f, 0.46652293f, 0.07247915f, -0.03910767f, -0.34971362f, 
    0.02242964f, -0.72479832f, -0.00481992f, 0.08846834f, 0.11657652f, -0.38325286f, -0.08409634f, -0.48054588f, 
    -0.00885320f, 0.47010085f, -0.57911891f, 0.21349250f, 0.08826625f, -0.40701839f, -0.02569288f, -0.18553844f, 
    0.19941851f, -0.29408738f, -0.27859485f, -0.84221715f, 0.06520779f, -0.13321465f, -0.00640650f, -0.30955812f, 
    0.10724010f, -0.29560295f, -0.13820331f, 0.18623178f, 0.23735292f, -0.24766731f, -0.06436389f, 0.32424474f, 
    -0.27207208f, 0.14925791f, -0.19392659f, -0.11293049f, 0.15168403f, 0.15372659f, -0.28403622f, -0.70490414f, 
    0.31766632f, 0.32224762f, 0.34058103f, -0.09561840f, -0.42176497f, -0.08243567f, -0.21381131f, -0.39258230f, 
    0.16181207f, 0.19255199f, -0.00651744f, 0.05402839f, 0.12249975f, 0.13008577f, 0.18228188f, 0.23779258f, 
    -0.46224588f, -0.10759207f, -0.09892605f, -0.03036142f, -0.01140037f, -0.71247965f, -0.00039142f, -0.47440249f, 
    -0.28794798f, -0.10602512f, 0.17843668f, -0.00980031f, 0.03975175f, 0.35180327f, -0.57995611f, 0.19802456f, 
    -0.30521053f, 0.03176173f, -0.45612577f, 0.11344013f, 0.21156026f, -0.64243901f, 0.47392887f, -0.49399218f, 
    0.37188625f, 0.36563635f, -0.29720235f, -0.26727551f, -0.02729417f, -0.01031151f, -0.25813690f, -0.34590426f, 
    -0.39900562f, 0.10622697f, 0.32591265f, -0.36569259f, 0.09897866f, 0.19663242f, 0.15049364f, 0.25404787f, 
    0.14298980f, 0.29607251f, -0.24433428f, 0.00000556f, -0.03888089f, -0.41105601f, 0.12040070f, 0.10594002f, 
    0.24752246f, 0.09939597f, 0.33981797f, -0.89547914f, 0.36902654f, -0.69775188f, -0.38453066f, 0.15105921f, 
    -0.70161533f, -0.03071377f, 0.12852859f, -0.34048244f, 0.05988989f, 0.04694593f, -0.39306179f, -0.10099067f, 
    0.36507475f, -0.24649838f, 0.38635194f, 0.19926530f, -0.11048908f, 0.08392087f, -0.00269872f, 0.33178455f, 
    0.03365749f, -0.31091696f, 0.21804102f, -0.09330676f, -0.02114205f, -0.33019486f, -0.18893486f, 0.13845739f, 
    -0.23391095f, -0.42726552f, -0.15440740f, 0.02141424f, 0.07961588f, -0.44898349f, 0.05725126f, 0.25283095f, 
    0.03242858f, -0.36001188f, -0.17110150f, 0.34701338f, -0.03497089f, 0.11494354f, 0.08034193f, 0.19013707f, 
    0.11039321f, 0.00499312f, -0.15457480f, 0.26494741f, -0.24492809f, 0.26162335f, -0.01753984f, -0.41839230f, 
    0.01808172f, -0.40430701f, 0.30219501f, 0.07382195f, -0.11451360f, -0.14312904f, 0.39578369f, -0.40305901f, 
    0.24447663f, -0.19265249f, -0.30927283f, 0.29314741f, -0.20879465f, 0.37084189f, -0.31610721f, -0.17171554f, 
    -0.18157427f, -0.29931122f, 0.20940235f, -0.32964188f, 0.03987953f, -0.04295678f, -0.09227601f, 0.18497930f, 
    -0.69781667f, 0.03858234f, 0.04792841f, 0.16103598f, -0.67527729f, 0.05566048f, -0.13684583f, -0.36761713f, 
    -0.12037320f, -0.63070983f, -0.18284181f, 0.03697728f, -0.13353813f, 0.11968182f, 0.37727717f, 0.10401201f, 
    -0.02295020f, -0.27598804f, 0.07787724f, -0.15528068f, 0.24659579f, 0.15880297f, 0.23515908f, -0.34877297f, 
    0.27731434f, 0.10517088f, 0.27594042f, 0.11105400f, -0.14941138f, -0.02585006f, 0.02285738f, -0.49481702f, 
    0.06305830f, 0.29402184f, 0.20498683f, -0.62691784f, 0.03922636f, 0.05823001f, -0.08461584f, 0.32482234f, 
    -0.06813310f, 0.30941927f, -0.35355255f, -0.11646084f, -0.19709706f, -0.22867110f, 0.50145352f, 0.08594078f, 
    -0.54158658f, -0.06974511f, -0.49835497f, 0.27166888f, 0.02222420f, 0.17321466f, 0.23076618f, -0.20383658f, 
    -0.12275681f, -0.43024406f, -0.52297151f, -0.15008938f, -0.00890652f, 0.19227402f, -0.88526791f, 0.08086089f, 
    0.02891286f, 0.01872304f, 0.30938125f, -0.49774823f, -0.32716635f, -0.31134203f, -0.03647879f, -0.38525569f, 
    -0.56348920f, -0.00338493f, 0.06515487f, 0.13679047f, 0.03543207f, 0.21664606f, 0.30587503f, 0.04736648f, 
    -0.36974993f, -0.12082034f, 0.12675326f, 0.11819853f, -0.11110149f, -0.30605808f, -0.83791161f, -0.19575423f, 
    0.24208021f, 0.35186088f, -0.20158273f, 0.05370769f, -0.05487904f, -0.09086789f, 0.32864460f, 0.35226682f, 
    -0.10771726f, -0.41982651f, -0.69109976f, 0.14284217f, -0.50833857f, 0.31388491f, -0.04630585f, 0.37636802f, 
    0.04630833f, 0.22893395f, -0.07758724f, -0.03228180f, -0.03946939f, -0.48456067f, -0.07831892f, -0.07822438f, 
    -0.27210334f, 0.28882232f, 0.08271065f, 0.37302285f, -0.21894707f, -0.35095608f, 0.24975049f, 0.27457732f, 
    0.32886806f, -0.11812593f, -0.05963822f, -0.21787892f, -0.10462154f, 0.04891561f, 0.44209859f, -0.75326115f, 
    -0.14209148f, 0.25909522f, -0.44044125f, -0.59378731f, -0.18808708f, -0.34989256f, 0.12422308f, -0.18636286f, 
    0.12115678f, 0.12216642f, 0.10413612f, 0.10083936f, 0.04978834f, 0.26639542f, -0.15743625f, 0.21039474f, 
    -0.13209896f, 0.26581943f, 0.36660397f, -0.60273445f, -0.38044482f, 0.13060060f, 0.29391494f, 0.28443134f, 
    -0.53379822f, -0.15598726f, -0.03250538f, -0.49841204f, 0.13693748f, 0.12359186f, 0.13415639f, 0.27950040f, 
    -0.15168093f, 0.08740928f, -0.14612050f, -0.03728180f, -0.25099117f, -0.01954265f, -0.10909660f, -0.56616122f, 
    0.28797731f, 0.29103491f, 0.30489868f, -0.13646799f, -0.17554472f, -0.16129354f, -0.56609958f, 0.11599532f, 
    0.20022808f, -0.43858001f, -0.58438265f, -0.12651940f, -0.12042280f, 0.37987679f, -0.19241704f, 0.30387896f, 
    -0.42061195f, 0.01142544f, 0.27714655f, 0.23877189f, -0.16452414f, 0.00623089f, 0.01917222f, -0.13382381f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.06437078f, -0.00551354f, 0.17617126f, -0.01705726f, -0.10735220f, -0.05473128f, 0.13369559f, -0.27546015f, 
    0.10506824f, -0.18733944f, 0.33835065f, -0.06094431f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
