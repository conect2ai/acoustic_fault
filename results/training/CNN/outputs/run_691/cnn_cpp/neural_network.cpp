#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.02241094f, 0.04288686f, -0.00192855f, 0.32371372f, 0.58172762f, 0.72358513f, -0.10587880f, -0.70638788f, 
    -0.25928065f, -0.36784187f, -0.44733921f, -0.80375195f, 0.31389081f, -0.01344702f, -0.62597221f, -0.46428224f, 
    -0.26868489f, -0.08952831f, -0.55641448f, -0.60239702f, -0.85561484f, 0.48963931f, 0.42822143f, 0.66316926f, 
    0.14512070f, 0.02314935f, -0.27927688f, 1.35169554f, 0.41427517f, -1.13667595f, -0.32048172f, 0.14329697f, 
    -0.47235030f, -0.12610345f, -0.00757155f, 0.64018905f, 0.97192317f, -0.03141703f, -0.70167720f, -0.01253123f, 
    0.73180473f, 0.60553771f, 0.47744814f, -0.22442855f, -0.67315626f, -1.07541597f, 0.48448673f, 0.96714187f, 
    -0.71062934f, 0.58626926f, 0.44229460f, -0.12290192f, 0.30366430f, 0.24211882f, 0.80708647f, 1.13644779f, 
    1.00531006f, -1.06364751f, 0.35821003f, -0.31586921f, 0.38508302f, 0.24572718f, -0.27617925f, -0.94438672f, 
    -0.84727448f, -0.63626987f, 0.22495079f, -0.32339546f, 0.18297189f, 0.35999930f, 0.17107083f, -0.21146767f, 
    0.62587166f, -0.50387883f, -0.84902853f, -0.78499663f, -0.91919559f, -0.34366176f, 0.12492264f, 0.49428564f, 
    0.34547535f, -0.49834985f, 0.55355108f, 0.60498816f, 0.24264915f, 0.65888506f, 0.53207785f, -0.69095075f, 
    0.43116108f, 0.31871668f, 0.48705950f, -0.74059695f, 0.26944908f, -0.60848260f, -0.94704431f, -0.66022164f, 
    -0.33842412f, -0.33755365f, -0.29266301f, -0.41643590f, -0.89558333f, -0.06884444f, -0.13582559f, 0.82189935f, 
    -0.54391748f, -0.32264858f, -0.23671244f, -0.22161789f, -0.35765329f, -0.70742929f, -0.13089913f, -0.40053481f, 
    0.78312218f, 0.72332710f, -0.17996718f, 0.54620457f, -0.31316334f, 0.13741717f, 0.91910911f, -0.91191572f, 
    1.14562416f, -0.03962371f, 0.28901467f, -0.12684751f, -0.24393846f, 0.05614116f, 0.41222787f, 0.68830991f, 
    0.39052403f, 0.59509236f, 0.73594052f, 0.54891676f, 0.18514010f, 0.21227553f, -0.31378326f, 0.82015765f, 
    0.94726247f, 0.84582281f, -0.81294638f, -0.85675430f, -0.01250523f, 0.06586065f, 0.21322361f, -0.56268233f, 
    1.15824080f, 0.94725627f, 0.12551461f, 0.35186404f, 0.18326867f, 0.10287290f, -0.66874802f, 0.20339353f, 
    -0.36035562f, -0.57719380f, -1.14097095f, -0.64989370f, -0.66726279f, 0.79958856f, 0.46620515f, 0.32976779f, 
    0.07527626f, 0.29843041f, -0.79600513f, -0.45266098f, 0.86074036f, 0.03084686f, -0.52606618f, 0.85347474f, 
    -0.32862672f, -0.36811182f, -0.34896851f, 0.35392895f, 0.28782532f, 1.03438973f, 0.74423271f, 0.17632033f, 
    -0.50203604f, 0.36614010f, 0.87397522f, 0.50153291f, 0.28228894f, -0.53372812f, -0.84783375f, -0.91986269f, 
    0.33512104f, -0.01075691f, 0.58435005f, -0.28967711f, 0.30115288f, 0.62416786f, -0.85280025f, 0.81232798f, 
    -0.32551193f, 0.09143071f, 0.66998315f, 0.27597573f, 0.04154752f, 0.10610442f, -0.41078827f, -0.60513383f, 
    -0.54580003f, 0.31386507f, 0.90129852f, -0.42502102f, -0.14864622f, -0.24938986f, -0.17775437f, -1.24758911f, 
    0.72078812f, 0.73481709f, 0.47496960f, 1.06970477f, -0.27921951f, -0.13520885f, -0.23647548f, -0.31543452f, 
    0.91633606f, 0.59034246f, 0.67660755f, 0.29464930f, -1.22582376f, -0.84913212f, 0.50859427f, 0.09467930f, 
    0.34047282f, -0.00268996f, -1.23727906f, -0.21406427f, 0.74182498f, 0.48590299f, 0.60900915f, -0.46803302f, 
    -0.01107215f, -0.41821930f, -0.18948390f, -0.94417721f, -0.57626224f, -0.84250051f, -0.17020573f, 0.54648787f, 
    0.07741639f, -0.13046540f, -0.23398906f, 1.11384809f, -0.82033479f, -0.37942177f, 0.46942362f, -0.83046901f, 
    0.68686801f, -0.15877774f, -0.24195632f, -0.26124391f, -0.11665113f, -0.86715859f, 0.62418002f, -0.86102104f, 
    -0.55629611f, -0.38297826f, 0.22187789f, 0.57138985f, 0.32891095f, -1.28855884f, 1.44984627f, -0.67114580f, 
    -0.18360426f, 0.39898419f, 0.06162334f, -0.00135706f, -0.19727603f, 0.21969962f, -0.78409320f, -0.72435266f, 
    0.65510100f, 0.77448875f, 0.20078132f, 0.66116184f, -0.05483911f, -0.22680758f, 0.19093105f, -0.42989209f, 
    -0.37167412f, 0.80596566f, -1.28730392f, -0.47368026f, -0.13656627f, 0.21727961f, -0.47984675f, -0.31248128f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34187770f, -0.02846590f, 0.01924121f, 0.23158158f, 0.00660549f, 0.14504667f, -0.05907341f, 0.09050129f, 
    0.51521432f, -0.11582187f, 0.08759455f, 0.00997251f, -0.07873704f, 0.24617943f, 0.24860671f, 0.36160457f, 
    0.09252954f, 0.08225811f, 0.24470058f, -0.02953813f, 0.17611489f, 0.09718901f, 0.19973563f, -0.14612889f, 
    -0.15481238f, 0.11099057f, 0.03439713f, -0.04019193f, 0.09180243f, 0.30315182f, 0.30015066f, 0.38513154f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06781431f, 0.04998327f, 0.06722931f, -0.07545785f, 0.01643906f, -0.04750165f, 0.03629027f, 0.02804672f, 
    -0.01420268f, -0.03241051f, -0.01910951f, 0.01607970f, 0.02148090f, 0.03557995f, 0.04681095f, 0.09836375f, 
    -0.02062268f, 0.02218559f, -0.05512750f, 0.03110644f, -0.02353359f, 0.14473851f, -0.01537580f, -0.19328915f, 
    0.25043517f, -0.01865799f, 0.03204606f, -0.08512176f, 0.03096949f, 0.06706050f, -0.00275373f, 0.00651917f, 
    -0.04833554f, -0.04737156f, -0.04145986f, 0.00267617f, 0.05572560f, 0.06403316f, -0.03146430f, -0.11317778f, 
    0.11822195f, -0.04177642f, 0.08600828f, -0.06903908f, -0.05521248f, -0.04487959f, -0.12522395f, 0.02422405f, 
    -0.10280473f, 0.02733811f, 0.02100308f, 0.00374631f, -0.02961386f, 0.02469178f, 0.09671677f, 0.11060537f, 
    0.15452451f, -0.02297690f, -0.02473681f, 0.06906691f, 0.10374989f, -0.15797101f, -0.03865854f, 0.02766027f, 
    0.06877436f, -0.07158720f, 0.04337898f, 0.05866163f, 0.03841355f, 0.07892615f, 0.05363011f, -0.00078718f, 
    0.03470800f, -0.05816417f, -0.10379244f, 0.04151149f, -0.14910454f, -0.06926537f, 0.05980083f, 0.07353259f, 
    0.18374093f, -0.13385852f, -0.21416558f, 0.02365435f, 0.25395459f, -0.13033082f, -0.10344521f, -0.08471811f, 
    0.04313896f, -0.13101017f, -0.01977908f, 0.08793835f, -0.08867072f, 0.00894063f, -0.00059324f, 0.06109164f, 
    0.07245940f, 0.02914711f, 0.10071988f, 0.02838522f, 0.09775271f, -0.22867969f, 0.00847622f, -0.10342635f, 
    -0.06702510f, 0.07226909f, -0.01465670f, -0.04082734f, -0.08545051f, 0.00786539f, 0.04133456f, -0.03164061f, 
    -0.03626047f, -0.00027920f, -0.06163384f, -0.02559083f, 0.05243092f, 0.11633717f, 0.04303350f, -0.03394186f, 
    -0.37352625f, 0.24129951f, -0.10411937f, 0.12722464f, 0.13544789f, 0.19113481f, 0.12158439f, -0.00357223f, 
    -0.03191275f, 0.00819135f, -0.08569308f, 0.01282452f, -0.01088707f, 0.14684297f, -0.04324821f, 0.01811596f, 
    0.09720085f, -0.08694195f, -0.00963087f, -0.08433957f, -0.09978237f, -0.04610155f, 0.10991617f, -0.05376920f, 
    0.01915679f, 0.04781702f, -0.04070326f, -0.04276749f, -0.04458542f, 0.06044511f, 0.06864214f, 0.09130945f, 
    -0.04940364f, 0.09897177f, 0.01510097f, -0.02547525f, 0.03923745f, 0.04280997f, -0.00798223f, 0.13864718f, 
    0.21740121f, 0.05585356f, 0.10881885f, -0.14059113f, 0.05688518f, -0.01907568f, 0.08189072f, -0.02168983f, 
    0.08394811f, 0.05042116f, -0.03623948f, -0.11461528f, 0.08264022f, 0.06089226f, -0.11851156f, 0.08036203f, 
    0.07868700f, -0.00236334f, 0.01802730f, 0.06756999f, 0.12693757f, -0.10704248f, -0.00594964f, 0.01100305f, 
    -0.05410640f, -0.08112166f, 0.00252513f, -0.01560505f, -0.08151946f, -0.02363849f, 0.06420209f, -0.00174619f, 
    -0.05556749f, 0.00457852f, 0.04069062f, 0.13040787f, 0.00174625f, 0.01419911f, 0.03308745f, 0.03226716f, 
    0.03709153f, 0.18555431f, 0.02147098f, -0.04754428f, 0.06923891f, -0.02204946f, 0.05435460f, 0.07248424f, 
    0.00592762f, 0.04795941f, -0.00383562f, -0.01670415f, 0.01352460f, -0.02506833f, -0.02880010f, -0.05095786f, 
    -0.14386342f, 0.02439355f, 0.01235332f, -0.04863589f, 0.19484891f, 0.02027494f, -0.07078803f, -0.05761184f, 
    -0.00679293f, -0.01214750f, 0.07607289f, 0.06411010f, 0.02734297f, -0.04701269f, 0.05477704f, -0.04568762f, 
    0.06172623f, -0.04562027f, -0.02963132f, 0.02678527f, -0.04740904f, -0.02031520f, 0.01359862f, 0.07440395f, 
    0.45170212f, -0.26942730f, 0.10319440f, -0.03358844f, -0.04470374f, -0.03209136f, 0.06831705f, 0.03051657f, 
    -0.01504897f, -0.16385567f, -0.04764511f, 0.02026506f, -0.09380137f, 0.05860415f, -0.02505036f, 0.01842957f, 
    -0.05860807f, 0.03557843f, -0.01375361f, 0.13868278f, 0.17131099f, 0.31550851f, -0.10308391f, -0.07083219f, 
    -0.07929577f, -0.28704935f, 0.01906256f, -0.12406154f, 0.06651011f, -0.02999427f, 0.09876250f, 0.00573425f, 
    -0.02591207f, -0.03211826f, 0.06316725f, 0.05607614f, 0.07651997f, 0.02044602f, 0.01455597f, -0.00876360f, 
    0.07657890f, 0.17666723f, 0.06587850f, 0.06781795f, -0.02166813f, -0.15441096f, -0.06735227f, -0.09921921f, 
    0.01738263f, -0.00564581f, -0.00731565f, -0.05015912f, -0.03715234f, -0.00454814f, 0.07008386f, 0.01229652f, 
    -0.03956492f, 0.01676779f, 0.00679271f, -0.01483261f, -0.37086874f, 0.18076894f, -0.19409153f, 0.08645592f, 
    0.12268940f, 0.11976036f, -0.03685142f, -0.05979165f, 0.01433393f, -0.02543067f, -0.08675675f, 0.05972910f, 
    -0.07039490f, 0.12732586f, -0.05482673f, -0.00400177f, 0.07567524f, -0.05033936f, 0.03464418f, -0.01305180f, 
    -0.19436823f, -0.12199223f, -0.10747012f, 0.08812227f, 0.02764278f, -0.21856533f, -0.04328723f, -0.08759446f, 
    -0.07370479f, -0.04615001f, -0.04232685f, -0.07381791f, 0.03236021f, 0.13317657f, 0.10786938f, -0.05911012f, 
    0.02768603f, -0.06540298f, 0.10417278f, 0.01852659f, 0.28741479f, -0.21815164f, 0.11251253f, -0.16294616f, 
    0.02124938f, -0.06942911f, 0.00828279f, 0.06924687f, -0.07581065f, 0.01372667f, 0.05850083f, 0.02182424f, 
    0.03344095f, 0.12752855f, 0.05174824f, 0.07885369f, -0.04295127f, -0.05556309f, -0.01928336f, 0.09590814f, 
    -0.18990569f, -0.13312875f, 0.07143997f, 0.09019260f, -0.10821696f, 0.11604394f, -0.03955312f, 0.03187259f, 
    -0.17915642f, 0.13269369f, -0.03519296f, 0.00002190f, -0.10455316f, -0.04716088f, 0.08981780f, -0.07023647f, 
    0.00188990f, 0.08585809f, 0.05252885f, -0.03022816f, -0.02387427f, -0.15550667f, 0.09853455f, 0.29912058f, 
    0.01647575f, -0.04892389f, 0.13811183f, 0.09132024f, -0.04136229f, -0.00113666f, -0.01966920f, 0.05751286f, 
    -0.05096205f, -0.09010115f, -0.05776034f, 0.02355079f, -0.05061666f, 0.13475516f, -0.10288140f, 0.03107199f, 
    0.02020977f, -0.05843776f, -0.03045788f, -0.03904203f, 0.07105406f, -0.01921554f, 0.02495908f, 0.00963174f, 
    0.08929260f, 0.01638125f, -0.04688593f, -0.10390508f, 0.04810754f, -0.01866742f, 0.04332514f, 0.05878562f, 
    0.13619509f, -0.03996225f, -0.01836930f, 0.11244994f, 0.27595398f, 0.03520415f, 0.07546910f, 0.33376610f, 
    0.14314471f, 0.02802001f, -0.01702405f, 0.01489888f, 0.04291771f, -0.14174618f, 0.02202528f, -0.00293399f, 
    -0.03219679f, 0.06522305f, 0.08928333f, -0.01395301f, 0.03353991f, 0.05662005f, 0.11935649f, -0.07014574f, 
    0.17065328f, 0.03553710f, -0.14331929f, -0.09942371f, 0.04612730f, 0.01343195f, 0.07560584f, 0.05821184f, 
    0.05957798f, -0.00222053f, 0.12081179f, 0.03601419f, -0.00495148f, 0.01815653f, 0.05448092f, 0.13464017f, 
    -0.03773877f, -0.08049468f, -0.03004340f, 0.04989742f, 0.16768008f, -0.01682323f, 0.02941125f, 0.16223386f, 
    -0.14074454f, 0.04886450f, 0.03171233f, -0.10879081f, 0.08508233f, 0.02804727f, 0.10419434f, -0.07713915f, 
    -0.03002349f, -0.08702179f, -0.05299011f, -0.01524590f, -0.09497412f, 0.05632466f, 0.11529784f, -0.06090869f, 
    -0.23683114f, 0.04417513f, -0.19833590f, 0.26859540f, 0.12563229f, 0.08353469f, 0.06093080f, 0.16283250f, 
    0.00526131f, -0.00909726f, 0.01278272f, 0.13791089f, 0.00298332f, -0.01294222f, -0.02143412f, 0.05299053f, 
    0.06293554f, 0.12478119f, 0.05179553f, -0.02345371f, 0.27480406f, -0.15884070f, 0.09748179f, -0.19762926f, 
    -0.01390470f, -0.16818546f, 0.01697511f, 0.04150931f, 0.08614490f, -0.05812670f, -0.01281078f, 0.10677154f, 
    -0.01436235f, -0.06171154f, 0.07336818f, -0.05663189f, 0.11470714f, -0.06769824f, -0.01116975f, -0.00260484f, 
    0.08051947f, -0.14135700f, 0.20150161f, -0.18030544f, -0.01626635f, 0.03044458f, 0.04010949f, 0.03637239f, 
    -0.07422717f, -0.04852351f, -0.02376578f, 0.00170944f, -0.08889966f, 0.05080196f, -0.00238431f, -0.04940671f, 
    -0.03147122f, 0.03360120f, -0.05541114f, 0.03628667f, -0.18426436f, -0.03752859f, 0.19084287f, -0.09968867f, 
    0.25379804f, 0.01571652f, 0.24280949f, 0.07033551f, 0.05902874f, -0.02890835f, 0.02184730f, 0.03724252f, 
    -0.11331608f, 0.03023648f, 0.03348529f, -0.06088296f, -0.10403302f, 0.01841702f, 0.13806120f, 0.00409471f, 
    0.26446557f, 0.19285148f, 0.04372799f, 0.10201084f, -0.07742806f, -0.00442135f, 0.08567601f, 0.06521670f, 
    -0.08579293f, -0.14122331f, 0.05799223f, -0.03145295f, 0.06885612f, -0.01277172f, -0.11168607f, 0.06270479f, 
    0.01040490f, 0.02487466f, -0.08695143f, -0.03309494f, -0.27091220f, 0.52913839f, 0.02632963f, 0.20879743f, 
    0.05761977f, 0.07791647f, -0.06360571f, -0.14413166f, 0.00212725f, 0.21835506f, 0.03159166f, 0.04244477f, 
    -0.05082499f, 0.16134575f, -0.01628525f, -0.08841752f, -0.05609578f, -0.08242287f, 0.09654362f, 0.06470405f, 
    0.07213020f, -0.32434148f, 0.06062907f, 0.13631545f, -0.12630849f, -0.08603053f, -0.04160196f, 0.02152659f, 
    -0.13628866f, 0.03899770f, -0.04417965f, 0.00107223f, 0.03892296f, -0.02177457f, 0.02404421f, 0.02224407f, 
    -0.01544103f, -0.01805715f, 0.06358687f, 0.05068688f, 0.09970778f, 0.11389697f, 0.12057783f, -0.06773824f, 
    -0.13473457f, 0.04718969f, 0.08920866f, -0.01233296f, -0.09010176f, -0.04141331f, -0.12954743f, -0.02414385f, 
    -0.04180145f, -0.03334744f, 0.01118441f, -0.06363473f, 0.01179368f, 0.01461799f, -0.04585069f, 0.00866688f, 
    0.04593878f, 0.01293714f, -0.05658017f, 0.16357197f, 0.21525395f, 0.03917521f, -0.04538232f, 0.02049729f, 
    0.09504372f, 0.09468924f, 0.02949202f, -0.02971285f, 0.12739153f, 0.07134002f, 0.03451401f, 0.02703345f, 
    0.10481922f, 0.08432192f, 0.05490546f, -0.03346435f, -0.15849507f, -0.06012386f, -0.04091683f, -0.02046623f, 
    -0.16582976f, -0.02147537f, -0.08746734f, -0.02205130f, 0.12359038f, 0.07627420f, -0.05065279f, 0.06554214f, 
    0.08357465f, -0.00034196f, 0.12582776f, 0.07446928f, -0.00674277f, 0.17498685f, 0.08601726f, 0.08870135f, 
    -0.06312456f, -0.04579772f, -0.14993736f, 0.22385864f, 0.17003629f, -0.13096438f, -0.06797458f, -0.04531272f, 
    0.10410400f, 0.21727392f, 0.09173714f, -0.01632394f, 0.04199710f, -0.00651043f, 0.19154486f, -0.04788071f, 
    0.06150090f, 0.05189112f, 0.02242952f, -0.00810900f, 0.36390719f, -0.19119191f, -0.02272519f, -0.20547423f, 
    -0.52204305f, -0.01207174f, -0.06015817f, 0.06637323f, -0.04550549f, -0.06656916f, -0.02022848f, 0.01794202f, 
    0.04055670f, -0.02547375f, 0.05182010f, 0.05550876f, -0.02158113f, 0.06251175f, 0.02601031f, -0.01060383f, 
    0.29994598f, -0.15959086f, 0.04535390f, -0.04011675f, -0.08732571f, -0.06709637f, -0.11166941f, 0.04324075f, 
    0.18259966f, 0.00760986f, 0.06492519f, -0.03564431f, 0.14180467f, 0.18096165f, 0.01228706f, 0.13965556f, 
    -0.13156092f, -0.00651413f, -0.08188856f, 0.02071469f, 0.09435792f, 0.22253756f, -0.02008501f, -0.06922958f, 
    -0.00116786f, -0.13482420f, -0.01752947f, 0.08917277f, 0.03119239f, -0.05101315f, -0.12375549f, -0.06641500f, 
    -0.09621949f, -0.02049485f, -0.04758750f, 0.04284396f, -0.07336292f, -0.07488128f, 0.01734574f, -0.07139026f, 
    -0.57544684f, 0.00419458f, 0.22072582f, 0.13291858f, 0.23372601f, 0.06254403f, 0.11703084f, 0.12534688f, 
    -0.06119733f, -0.03023517f, 0.01961785f, 0.00340079f, 0.05373440f, -0.07934429f, -0.08529510f, 0.01337753f, 
    0.09294101f, 0.00020622f, 0.03005119f, -0.01645941f, -0.02910572f, -0.06282019f, 0.01996472f, 0.08984728f, 
    0.13529393f, -0.05974927f, -0.03925143f, -0.09252448f, 0.08585700f, 0.19450785f, 0.01978057f, -0.02871934f, 
    0.13657774f, 0.03897836f, 0.07992858f, -0.04504988f, 0.09489788f, 0.03547374f, 0.08159046f, 0.10930745f, 
    0.02889441f, 0.04809376f, -0.01422443f, 0.09643883f, -0.31632736f, -0.01627167f, 0.06212604f, 0.04212621f, 
    0.01492431f, -0.06364696f, 0.00775034f, 0.05824103f, 0.04099422f, -0.03960405f, 0.04666116f, 0.04464820f, 
    0.04528543f, 0.05584289f, 0.04812226f, 0.10453811f, 0.30905932f, 0.18031204f, -0.05505868f, -0.03336692f, 
    0.05546049f, -0.00593988f, -0.03689997f, 0.05023268f, 0.05412968f, -0.08359937f, -0.10131996f, 0.13577351f, 
    0.04299985f, 0.06277305f, 0.06288979f, 0.12849961f, -0.05028881f, 0.01694391f, -0.00113877f, -0.14906287f, 
    -0.16595790f, -0.00832176f, 0.17427206f, 0.05258909f, -0.29637140f, 0.01255854f, 0.28188580f, 0.03665933f, 
    -0.11481432f, -0.02201851f, 0.08757571f, 0.01056708f, 0.02163841f, -0.02354144f, -0.05021454f, -0.00660917f, 
    0.08677968f, 0.17714097f, 0.03751368f, 0.06010826f, -0.09063941f, -0.25366187f, -0.03385589f, -0.02973503f, 
    -0.07097693f, -0.13876264f, -0.16856374f, -0.13788356f, 0.01585213f, 0.12584047f, 0.08123706f, 0.00181645f, 
    0.02955266f, 0.10801272f, 0.07003957f, -0.02016762f, 0.01994939f, 0.03349299f, 0.18715306f, -0.04024351f, 
    -0.09541795f, 0.04771785f, 0.11032932f, 0.17459689f, 0.21599415f, 0.02309545f, -0.05701963f, -0.01936745f, 
    -0.04837993f, 0.14600985f, 0.01405496f, -0.00962933f, 0.02256408f, 0.10426499f, 0.00846135f, 0.05042676f, 
    0.07374961f, -0.08642075f, 0.12332106f, 0.12980364f, -0.06357107f, 0.00105080f, -0.08897614f, 0.22273333f, 
    0.07666282f, 0.10831704f, -0.06457360f, 0.07201750f, -0.00087144f, -0.03409867f, -0.08163431f, -0.00729255f, 
    -0.02225685f, -0.05342539f, 0.06804200f, -0.03218075f, 0.04304663f, 0.06408431f, 0.07258847f, 0.03918796f, 
    0.00275557f, 0.10155422f, 0.01027590f, 0.02688349f, 0.22746667f, 0.07456789f, -0.00888562f, -0.07640693f, 
    0.03951977f, -0.02187726f, 0.02583902f, -0.01973104f, 0.07159450f, -0.02997931f, 0.04637344f, 0.03878464f, 
    0.01871482f, -0.07745875f, 0.02081469f, 0.05849842f, -0.19859050f, -0.24244994f, 0.10155611f, 0.13494156f, 
    0.02320993f, 0.05127100f, 0.16623107f, 0.12967278f, -0.13285737f, 0.02374335f, -0.01538004f, -0.00237079f, 
    0.07878301f, -0.11363006f, -0.00612875f, 0.01351748f, 0.03078489f, 0.03096745f, -0.06677628f, -0.08041535f, 
    0.09577733f, -0.02902257f, 0.14859909f, -0.00949375f, 0.16685316f, 0.05080668f, 0.01574899f, 0.09395389f, 
    0.02711625f, -0.01126467f, -0.02972260f, 0.08497572f, 0.04003215f, 0.02370194f, -0.00227808f, 0.05725880f, 
    0.03251216f, -0.00416280f, -0.03847020f, -0.05768600f, 0.25655505f, -0.06982104f, -0.01443786f, 0.23583977f, 
    0.17901450f, -0.06308717f, -0.01526596f, -0.01634314f, 0.09214900f, 0.16040382f, 0.01708170f, 0.01638882f, 
    -0.00833484f, 0.02895159f, -0.00848760f, 0.07854008f, 0.05076114f, 0.04488267f, 0.02424312f, 0.01872926f, 
    0.40307611f, -0.08264860f, -0.06028210f, -0.10549564f, 0.00937099f, -0.00636520f, -0.06445815f, 0.05038987f, 
    0.01136671f, -0.10527225f, -0.01810206f, 0.13049386f, 0.06907729f, 0.03156998f, 0.06837554f, -0.01491265f, 
    0.01760450f, -0.04303129f, -0.00280215f, 0.04774163f, -0.09768102f, 0.15109688f, 0.02724794f, -0.33076790f, 
    0.07537053f, -0.07105004f, -0.01126739f, -0.08329507f, -0.03960027f, -0.08138325f, -0.05097368f, -0.05065617f, 
    0.06855562f, -0.02467079f, -0.04960923f, -0.02716461f, -0.02004419f, 0.02322131f, 0.01584588f, 0.00266581f, 
    0.28400901f, -0.04459691f, -0.17936483f, -0.04709344f, -0.12598333f, 0.00505044f, 0.02793478f, 0.13009962f, 
    0.03814439f, 0.06878348f, 0.05569280f, 0.06375340f, -0.04563821f, -0.01091393f, 0.03844474f, 0.08353937f, 
    -0.11493385f, 0.02527593f, 0.03667390f, -0.00761350f, 0.10016774f, -0.10658974f, 0.09699737f, -0.11612353f, 
    -0.12199534f, 0.07099216f, 0.04869187f, 0.02672042f, -0.05925313f, -0.05974266f, -0.10867899f, -0.03165100f, 
    0.01462299f, -0.05310388f, -0.00327628f, 0.03722918f, 0.05237279f, 0.04170748f, 0.12464804f, 0.00102749f, 
    -0.20263028f, -0.18364443f, -0.10176723f, 0.10871599f, 0.11685590f, -0.01523647f, -0.13514037f, -0.08489536f, 
    0.06035138f, 0.17318955f, 0.05823149f, -0.00020357f, 0.03910856f, 0.05383381f, 0.15121336f, 0.02607974f, 
    -0.05179610f, 0.04462923f, 0.17403544f, -0.02758011f, 0.08572034f, 0.13902728f, -0.30623201f, -0.11406065f, 
    0.30114025f, -0.03735619f, -0.03559266f, 0.02906310f, 0.07021289f, 0.11753265f, 0.07377680f, -0.02407757f, 
    -0.02427210f, -0.01447604f, 0.10407915f, -0.00476981f, 0.01409069f, -0.09508646f, 0.04765518f, -0.00028887f, 
    -0.21786003f, 0.04307123f, 0.33048970f, -0.00779859f, -0.05058963f, 0.00874732f, 0.24292834f, 0.02466004f, 
    -0.14873156f, -0.06270526f, -0.05379183f, -0.02032400f, -0.01462440f, -0.13224286f, 0.01641652f, -0.17917739f, 
    0.04184136f, -0.04255378f, -0.05749426f, -0.00561070f, -0.06530152f, 0.05422323f, -0.03668734f, 0.12701888f, 
    0.11736295f, 0.08023613f, -0.10712999f, 0.00871938f, -0.00244924f, 0.19110349f, 0.07854390f, -0.03693249f, 
    0.00219356f, 0.04305360f, 0.13743985f, 0.07228069f, 0.03937990f, 0.01455468f, 0.13366516f, -0.00023706f, 
    0.16965485f, -0.16119263f, -0.05252454f, 0.26925489f, -0.09398934f, -0.08723202f, 0.07069790f, 0.10207630f, 
    0.12640220f, 0.10104404f, -0.02738114f, 0.02449436f, 0.04701044f, 0.04005236f, 0.02301663f, -0.01680503f, 
    0.02029342f, 0.19176075f, 0.00437225f, -0.03211521f, -0.05734084f, 0.26541767f, 0.03352510f, -0.01608883f, 
    -0.09730449f, -0.02077902f, 0.03248158f, 0.01928381f, -0.04188856f, 0.04690627f, 0.22901675f, -0.01616052f, 
    0.02825267f, 0.06481643f, -0.06923973f, 0.01264932f, 0.12764847f, 0.01747977f, -0.04705330f, -0.03336376f, 
    -0.12203378f, -0.04043378f, 0.14885099f, -0.05662513f, -0.24594024f, -0.06867168f, 0.16843081f, -0.09614271f, 
    -0.04483387f, -0.07225872f, -0.00581867f, 0.06501031f, -0.03784449f, -0.03091355f, -0.14670621f, -0.03679742f, 
    0.01600092f, -0.02078039f, 0.06790000f, -0.02133238f, 0.36024940f, 0.11660352f, -0.21092001f, -0.32001916f, 
    -0.00319592f, 0.01696241f, 0.13923272f, 0.07172460f, 0.00200370f, -0.03529266f, 0.02614933f, -0.06522316f, 
    0.09891968f, 0.02943562f, -0.02721265f, 0.06299940f, 0.00892339f, 0.02845114f, 0.14219911f, 0.10430542f, 
    0.38024405f, 0.21103293f, -0.14054680f, -0.16290133f, 0.11474409f, 0.04087991f, -0.07869514f, -0.07394462f, 
    0.06880797f, 0.05746584f, 0.00437307f, 0.06196839f, -0.05098063f, -0.04791955f, 0.04501024f, 0.06079636f, 
    0.04668780f, -0.08953506f, 0.08811863f, -0.00255149f, -0.12382591f, -0.07631493f, 0.08248089f, 0.10387582f, 
    -0.37414640f, 0.08850610f, 0.06337228f, 0.03620062f, -0.12941870f, 0.03303340f, 0.05103366f, 0.07721861f, 
    0.03073380f, -0.00882335f, -0.01094756f, 0.07455795f, 0.04936405f, 0.08633149f, 0.11433402f, -0.08564561f, 
    0.15405805f, 0.05215430f, -0.03755308f, 0.00117215f, -0.09697428f, 0.00037266f, 0.08917764f, 0.06864868f, 
    -0.09781753f, -0.03075220f, -0.01170427f, -0.00830982f, -0.02859886f, 0.05978917f, -0.05969157f, 0.03956810f, 
    -0.01941171f, 0.10887887f, 0.00908772f, -0.05428878f, -0.04709504f, 0.31484964f, 0.11853008f, 0.11283875f, 
    0.09987678f, 0.04368599f, 0.25858495f, 0.05099695f, 0.08191649f, 0.13089243f, 0.02418183f, 0.12232082f, 
    0.07443409f, 0.00052219f, 0.00689381f, 0.06988569f, 0.10785712f, -0.04768516f, 0.15708537f, 0.05773738f, 
    -0.13302755f, 0.09126304f, -0.11566007f, 0.01864960f, 0.14876510f, 0.17404336f, 0.02832004f, 0.10730653f, 
    -0.05538580f, -0.07651852f, -0.01111202f, 0.11691302f, 0.03633762f, 0.02614174f, -0.04325785f, 0.00487545f, 
    -0.03497807f, 0.00050636f, -0.02867749f, 0.04280784f, 0.06800050f, 0.23225392f, -0.01797492f, 0.21805547f, 
    0.07873230f, -0.01295285f, 0.02444106f, -0.01898624f, -0.11185112f, 0.02035481f, 0.02311691f, -0.07976422f, 
    -0.09611858f, 0.04540981f, 0.07043340f, 0.00876479f, 0.09025241f, -0.04142684f, -0.01985288f, 0.08152630f, 
    -0.10041849f, 0.07644822f, -0.00981458f, 0.01308447f, -0.14833930f, 0.04397979f, 0.12790860f, -0.07001597f, 
    -0.21155971f, -0.00247931f, 0.02479439f, 0.04321365f, -0.01025580f, 0.01011737f, 0.00677201f, 0.02468626f, 
    0.11753540f, 0.05394663f, -0.03731958f, -0.03597490f, 0.12130434f, -0.10563578f, 0.04934290f, 0.00184300f, 
    -0.05605776f, 0.06112232f, -0.02490526f, -0.09208909f, -0.01703187f, 0.08498446f, -0.03091703f, 0.06602289f, 
    0.04135900f, -0.00771858f, 0.08721930f, -0.00811771f, -0.01657747f, 0.02887290f, -0.06849634f, -0.01266037f, 
    0.21393973f, -0.27318755f, 0.17370626f, 0.11277277f, -0.25761330f, -0.08137970f, -0.02952225f, 0.02827761f, 
    0.00780763f, 0.09221571f, -0.00470201f, -0.01067156f, 0.11175056f, 0.05284313f, 0.09588624f, 0.06661688f, 
    0.00143234f, 0.00091933f, -0.03588520f, 0.04940299f, -0.06378878f, 0.15012601f, -0.04720449f, 0.07963452f, 
    0.15708227f, 0.12726615f, 0.22736838f, 0.20002507f, -0.02107756f, 0.00624977f, -0.01930268f, 0.08356532f, 
    -0.01206271f, -0.01895144f, -0.05288407f, 0.05347184f, 0.00342889f, -0.02414440f, -0.02436878f, -0.07528658f, 
    -0.06390906f, 0.11269499f, -0.03406908f, 0.14476001f, 0.16477554f, -0.06366483f, -0.06465006f, 0.02284238f, 
    0.03032131f, 0.01848607f, -0.00908081f, -0.04657733f, 0.07248969f, 0.07102751f, 0.08954899f, -0.04103446f, 
    0.06216602f, -0.09366156f, -0.04338218f, 0.03458184f, -0.10272751f, -0.05540492f, 0.06388348f, 0.00146095f, 
    -0.00860911f, 0.06218296f, 0.02452907f, -0.00889508f, 0.04615792f, 0.02661873f, 0.03886135f, -0.06060635f, 
    -0.03854485f, 0.07231544f, -0.05377607f, -0.00840636f, 0.10612089f, 0.04671468f, 0.09974822f, -0.03639904f, 
    0.16745974f, 0.09597624f, -0.10413334f, 0.09155000f, 0.28496721f, 0.01670887f, -0.12214535f, 0.03325336f, 
    0.08119140f, 0.04671330f, -0.00793987f, 0.04680661f, 0.15773940f, 0.02794578f, 0.06872848f, 0.06184825f, 
    0.03188674f, 0.04201849f, -0.08807945f, -0.00504212f, -0.32155582f, 0.43827200f, -0.02928345f, 0.03877081f, 
    0.15617707f, 0.21448554f, 0.12384923f, -0.00687511f, 0.01566584f, -0.01606876f, -0.08171318f, -0.02347916f, 
    0.05959821f, 0.02192060f, 0.09026320f, -0.00748383f, 0.13905475f, -0.06142704f, 0.04797903f, -0.03081059f, 
    -0.16573666f, -0.03171381f, -0.03434272f, 0.03710150f, 0.00764877f, 0.09123335f, 0.00786612f, 0.00747382f, 
    0.04019241f, 0.01136516f, -0.01623776f, -0.01134212f, -0.11390559f, 0.03183677f, 0.01419138f, 0.09884086f, 
    -0.00231170f, 0.03214292f, -0.04627093f, -0.05785216f, -0.06878159f, 0.13400358f, 0.02203193f, -0.06866569f, 
    -0.15496430f, 0.15411364f, 0.02740185f, -0.03377533f, 0.00477516f, 0.11662796f, -0.05231968f, 0.03087982f, 
    -0.04140400f, -0.06187652f, -0.04304102f, 0.05043786f, 0.10465062f, -0.05040068f, 0.02436408f, -0.03579260f, 
    0.03632982f, 0.04045274f, -0.02328033f, 0.12937285f, -0.07267445f, 0.07184445f, 0.11647397f, 0.00973818f, 
    0.02408569f, -0.03487522f, 0.12126750f, 0.03508213f, -0.00594194f, -0.01965511f, -0.00447312f, 0.09101626f, 
    0.06788833f, 0.12452483f, 0.00209899f, 0.04097467f, 0.19163975f, -0.04135223f, 0.12329357f, 0.09889624f, 
    -0.04986498f, -0.11481685f, 0.02966391f, 0.02694844f, 0.01382930f, 0.04880972f, 0.00126700f, -0.01183950f, 
    0.03020940f, 0.10205232f, 0.05829268f, 0.00596799f, -0.04806115f, 0.05952049f, 0.01893003f, 0.01680989f, 
    0.05599887f, 0.13121204f, 0.16135667f, 0.15775122f, -0.24618211f, 0.07238063f, 0.05250523f, 0.04273601f, 
    -0.05809016f, -0.06370417f, 0.06703325f, -0.05902876f, -0.02467720f, -0.07191253f, 0.00574417f, -0.02933755f, 
    0.06588130f, 0.02239909f, -0.02420990f, -0.07143224f, -0.37783211f, -0.03706215f, -0.01547641f, -0.03729768f, 
    0.09708948f, 0.18058980f, 0.03988117f, 0.05498265f, 0.01308714f, -0.08753078f, -0.03088050f, 0.03238280f, 
    0.05215413f, -0.10777240f, -0.04809134f, -0.04651869f, -0.00279495f, -0.00059218f, -0.01051256f, -0.06337477f, 
    0.25145116f, 0.07700756f, -0.03595822f, -0.02077992f, 0.11104079f, 0.13022105f, 0.03632871f, 0.00324740f, 
    0.03108450f, -0.01528503f, 0.01710879f, 0.00860396f, -0.05738670f, 0.08686512f, -0.08757146f, 0.02564813f, 
    0.11827447f, 0.05537774f, -0.04526066f, 0.04831467f, 0.05198626f, 0.12853487f, -0.07891326f, 0.06906041f, 
    0.00487911f, 0.10385498f, 0.00257438f, -0.10283068f, 0.11032870f, 0.06157466f, -0.05036750f, -0.07696599f, 
    -0.02529663f, 0.11257214f, -0.00023253f, 0.05517862f, 0.12703910f, -0.15285748f, 0.06491105f, -0.10835705f, 
    -0.12268855f, 0.09267480f, 0.11136539f, -0.01711429f, 0.12654129f, 0.06713296f, 0.01042606f, -0.12530316f, 
    0.04398127f, -0.04773625f, 0.03867320f, 0.15513718f, 0.02965862f, -0.05052475f, -0.01187178f, -0.04042212f, 
    0.03504983f, -0.01528687f, 0.00111177f, -0.01585018f, -0.25565907f, 0.00844119f, 0.06990501f, 0.00589021f, 
    0.07682980f, -0.07809387f, 0.00156208f, -0.04081086f, 0.02046198f, 0.05450010f, 0.02232400f, -0.05691193f, 
    0.00894304f, -0.00022712f, -0.06337053f, 0.10226267f, -0.01840365f, -0.04673525f, -0.16266353f, 0.00935862f, 
    -0.33910578f, 0.25989121f, -0.02203401f, -0.02402063f, 0.11204371f, 0.09445125f, 0.09948774f, 0.09726763f, 
    0.04592572f, 0.01848064f, -0.02418120f, -0.02781191f, 0.05958745f, -0.05510367f, -0.03275495f, -0.05867451f, 
    0.07892261f, -0.02943546f, 0.03847580f, 0.08971561f, -0.36429214f, 0.17905633f, -0.08125211f, -0.01694263f, 
    -0.31202063f, 0.05123653f, -0.01374545f, 0.07948444f, -0.06403653f, -0.11351433f, -0.02085092f, -0.03155818f, 
    -0.00263144f, 0.06641441f, -0.03536671f, -0.05706155f, 0.14839111f, 0.03323923f, -0.02886791f, 0.02186825f, 
    0.10570335f, -0.02172211f, -0.06722661f, 0.10153287f, -0.00463109f, -0.08528060f, -0.10948405f, -0.12562405f, 
    0.04907281f, 0.04272484f, 0.00625328f, -0.08666391f, 0.03385829f, 0.04308581f, 0.11862773f, -0.05488238f, 
    -0.03148855f, -0.10973366f, 0.05483854f, 0.07604587f, -0.19238900f, 0.11139517f, -0.16272201f, 0.02612089f, 
    0.11877288f, 0.07996940f, 0.03868783f, 0.08755525f, -0.01267966f, -0.03319003f, -0.00598368f, 0.06387716f, 
    -0.02341966f, 0.02945864f, -0.06340659f, -0.00681418f, -0.03044421f, 0.05579118f, 0.07923685f, -0.03861954f, 
    -0.37318391f, 0.19725631f, 0.03567237f, -0.07131708f, 0.21854444f, 0.19856034f, 0.03580969f, 0.01076661f, 
    0.07458384f, 0.02269743f, -0.01345896f, 0.02781896f, -0.02871158f, -0.01274407f, 0.08906869f, 0.05327725f, 
    0.10040349f, -0.00850172f, -0.05201759f, -0.00826459f, 0.01713516f, 0.03804503f, -0.16067167f, -0.15065770f, 
    0.03164912f, -0.03195881f, -0.10951798f, -0.09487655f, -0.05225693f, 0.05434051f, 0.08583643f, 0.06188394f, 
    0.03677918f, 0.02399480f, -0.01666344f, 0.00166973f, -0.09332773f, -0.04036643f, -0.14729980f, 0.00343102f, 
    -0.16126436f, 0.04303563f, -0.00526080f, 0.07833493f, 0.32549697f, 0.03675587f, -0.19516161f, 0.02141028f, 
    -0.03176742f, 0.15579572f, -0.00138015f, -0.04636285f, 0.06685823f, 0.10323692f, 0.16929491f, -0.02393940f, 
    -0.04966713f, 0.05769535f, -0.05319375f, -0.04230717f, -0.37505174f, -0.27306345f, 0.25065771f, 0.30633759f, 
    -0.07832460f, 0.07132083f, -0.03741176f, 0.05752227f, -0.07268745f, 0.05937463f, 0.09799961f, 0.03255790f, 
    0.02750486f, 0.04613403f, -0.14632651f, 0.10716086f, 0.01478358f, -0.14155710f, 0.04263884f, 0.13590516f, 
    -0.10407542f, 0.00276073f, -0.16789301f, 0.04491819f, 0.03145374f, 0.10334019f, -0.01333084f, -0.00182348f, 
    -0.00723557f, 0.02599560f, -0.00394132f, -0.05812931f, 0.01302679f, 0.06011537f, -0.03671043f, 0.05403152f, 
    -0.01853725f, 0.07388984f, -0.02580882f, -0.00237101f, 0.08019614f, -0.02419757f, 0.10214008f, 0.01766839f, 
    0.26388270f, 0.04906549f, 0.02836237f, 0.02653537f, 0.02566587f, 0.09981493f, -0.04755134f, -0.02621027f, 
    0.03026729f, 0.09726720f, 0.14727224f, -0.04619861f, 0.04456433f, 0.06352167f, -0.08131310f, 0.10427713f, 
    -0.04043472f, 0.02725666f, -0.00209847f, -0.02357890f, -0.02082266f, -0.02715259f, -0.00916673f, 0.02038114f, 
    -0.01193385f, 0.02439801f, -0.00053047f, 0.02640976f, -0.00738229f, 0.02061013f, 0.02662662f, -0.03894916f, 
    -0.00646624f, 0.01148885f, 0.02998664f, -0.04566740f, -0.01709793f, 0.02582433f, -0.03571708f, 0.01108101f, 
    -0.04537740f, -0.01310210f, 0.00521183f, -0.01754182f, 0.00363732f, 0.01815564f, -0.02390393f, -0.01419337f, 
    -0.00093104f, 0.00323346f, 0.00381670f, 0.00358485f, -0.01109085f, -0.01215839f, -0.02754176f, -0.03384290f, 
    0.02950865f, -0.03559426f, 0.00096482f, -0.04019713f, -0.03664422f, 0.00077635f, 0.02229460f, 0.03128309f, 
    0.00251311f, -0.04506772f, -0.01541290f, 0.01033484f, -0.00246474f, -0.02767104f, -0.02104425f, 0.02437114f, 
    -0.04609478f, -0.03204721f, -0.03268650f, -0.02357122f, -0.03989298f, -0.01882477f, -0.00487217f, -0.00253757f, 
    -0.03757843f, 0.01819861f, -0.03740192f, 0.00598243f, 0.00337500f, -0.00090579f, 0.01383514f, -0.00818801f, 
    0.00162267f, -0.00297118f, 0.00382050f, -0.00381931f, 0.01225777f, -0.02104832f, -0.02567358f, -0.04560528f, 
    -0.02532235f, -0.04493701f, 0.00052295f, -0.01507148f, -0.02152523f, -0.02464794f, 0.02210158f, -0.00723000f, 
    -0.03485498f, 0.02288268f, 0.02001439f, -0.03792989f, -0.00715015f, 0.01505202f, 0.01304601f, 0.03081279f, 
    -0.00805886f, 0.02809467f, 0.01990618f, 0.00588849f, -0.00277344f, 0.02411585f, 0.01519431f, -0.01877402f, 
    -0.03713439f, 0.02521394f, 0.02813376f, 0.02238383f, -0.03319162f, -0.03581744f, -0.03398920f, -0.03401019f, 
    -0.00643109f, -0.00907018f, -0.00476964f, -0.03338920f, -0.00746351f, -0.02166700f, 0.00498558f, -0.02165104f, 
    0.02941955f, 0.02813071f, 0.03040875f, -0.02882394f, 0.00941032f, -0.02908660f, -0.04438667f, -0.01829073f, 
    0.01151922f, -0.02459246f, -0.04516596f, -0.02894118f, 0.00282122f, 0.00108628f, -0.02198309f, -0.02755897f, 
    0.01821661f, -0.01727241f, -0.00413499f, 0.03014773f, -0.00453084f, -0.01046813f, -0.02112527f, 0.01072844f, 
    -0.04007743f, -0.00526310f, -0.04469524f, 0.02523908f, -0.00166964f, 0.00312048f, -0.03791342f, -0.02363092f, 
    -0.00084711f, -0.00854687f, -0.00138125f, -0.00843455f, -0.03987695f, 0.01734431f, 0.02745841f, -0.01245684f, 
    -0.00996479f, -0.00010055f, -0.04602892f, -0.00623590f, 0.00915589f, -0.04012733f, -0.01366374f, -0.01680714f, 
    0.02416705f, 0.03026148f, -0.00473063f, -0.02065759f, 0.00075530f, 0.02604662f, 0.01863584f, -0.03540385f, 
    -0.00083417f, -0.00653460f, -0.02791453f, -0.00689329f, 0.02337969f, -0.03802294f, 0.02033465f, -0.00863838f, 
    -0.02115561f, 0.00019644f, -0.00031558f, -0.02143293f, -0.03401268f, 0.02954684f, -0.00594538f, 0.01797471f, 
    -0.03935986f, -0.00155902f, -0.02950411f, 0.00488837f, 0.00910725f, 0.01385662f, -0.01967951f, -0.03638849f, 
    0.02625070f, 0.01761490f, -0.00267826f, 0.01107444f, 0.01358398f, -0.00062458f, -0.00679836f, 0.00728099f, 
    0.00698198f, -0.00034953f, 0.02791036f, -0.04392421f, 0.01477001f, 0.00997236f, 0.01298779f, -0.02263901f, 
    0.00605388f, -0.01171866f, -0.00223320f, -0.00238217f, -0.00267881f, 0.02548760f, 0.01372362f, -0.03124621f, 
    0.02021283f, -0.02967151f, -0.03782165f, 0.02156590f, -0.03206067f, -0.04279941f, -0.03051116f, -0.03432589f, 
    0.02884471f, -0.04517592f, -0.02783155f, 0.00063451f, -0.01815448f, 0.00455031f, 0.01770445f, 0.00632721f, 
    -0.02465822f, -0.03536936f, 0.01991509f, 0.00199257f, -0.00023844f, 0.00330242f, 0.02661203f, -0.01490310f, 
    -0.01513552f, -0.03054093f, -0.02067493f, -0.01815848f, -0.03298342f, -0.01763403f, 0.01287202f, 0.00619860f, 
    -0.01353400f, -0.00926966f, -0.02032648f, -0.03980771f, -0.04124539f, -0.01022917f, -0.00389208f, 0.01979969f, 
    0.02000427f, 0.01969503f, -0.00102153f, 0.00958503f, 0.00416701f, -0.02020255f, -0.01260894f, 0.01128468f, 
    0.00317030f, -0.02174645f, -0.03802019f, -0.01119506f, -0.00487955f, 0.01696780f, 0.03273067f, 0.03232257f, 
    0.02405633f, 0.00044537f, -0.00115558f, -0.03014118f, -0.01220553f, -0.01408448f, 0.00063212f, -0.03110491f, 
    -0.01656635f, -0.03684188f, -0.02412650f, -0.01117796f, -0.00556147f, 0.01653996f, 0.01721912f, -0.01728628f, 
    0.02644257f, 0.02130773f, -0.01331160f, -0.00236971f, -0.02043768f, 0.02998466f, -0.03645147f, 0.02536225f, 
    -0.01574639f, -0.03364780f, 0.02262757f, -0.01143429f, 0.00421880f, -0.03106259f, -0.03515598f, -0.02575659f, 
    0.01724608f, -0.02823912f, 0.01082800f, 0.02114239f, -0.00155330f, -0.01874652f, -0.02213876f, -0.01743199f, 
    -0.04076703f, -0.00809837f, -0.04371514f, 0.03073221f, -0.00905571f, -0.02031919f, 0.03261112f, 0.01735218f, 
    -0.03269153f, -0.02057477f, 0.01594241f, 0.00251639f, 0.03069935f, -0.03630043f, -0.03725580f, -0.02584739f, 
    -0.01028407f, -0.02545909f, -0.01752261f, -0.03557318f, 0.01195613f, 0.03039993f, -0.01344568f, 0.00068879f, 
    -0.02414484f, -0.03732324f, -0.02729219f, -0.00410682f, -0.04244480f, 0.02122875f, -0.00616936f, 0.01387786f, 
    -0.01257981f, 0.01184638f, 0.01842147f, 0.00453485f, 0.02234580f, -0.01655601f, -0.02792350f, -0.00134791f, 
    0.00790193f, -0.00460170f, -0.03660784f, 0.02233528f, 0.00487976f, 0.01470597f, 0.00594475f, 0.02139688f, 
    0.00645594f, 0.02480186f, -0.03487469f, -0.03885492f, 0.02798179f, -0.00057605f, -0.02067585f, -0.00498808f, 
    -0.04469436f, 0.01155558f, 0.00148719f, -0.03076280f, 0.01216760f, -0.03979630f, 0.00937177f, -0.00131698f, 
    -0.02894711f, -0.02455958f, -0.00624313f, -0.04388487f, -0.02000827f, -0.03071012f, -0.02773330f, 0.00535822f, 
    -0.04270185f, -0.01172465f, -0.04052506f, -0.03737452f, 0.00601385f, -0.01294632f, 0.02912572f, -0.01102640f, 
    0.02661063f, -0.01730798f, 0.00005565f, -0.01817728f, 0.02256488f, 0.02997573f, -0.04246780f, -0.00189738f, 
    -0.02771091f, -0.02745057f, 0.02147570f, -0.02487787f, 0.02839899f, -0.00289123f, 0.02374730f, -0.04650073f, 
    -0.04386451f, -0.00963731f, 0.01967170f, -0.01388461f, -0.00832072f, -0.02837200f, 0.01515712f, -0.03596677f, 
    -0.02835670f, -0.03111420f, -0.02478179f, 0.03122265f, 0.02985818f, -0.01185113f, -0.01689583f, -0.04573033f, 
    -0.02253048f, -0.04311002f, 0.01655636f, -0.04118727f, 0.00644596f, -0.03222539f, 0.02570640f, -0.01257742f, 
    -0.01154939f, -0.04126211f, -0.02166270f, -0.01335717f, -0.03258596f, 0.00725384f, -0.03235521f, 0.02064783f, 
    0.02629849f, 0.00374812f, -0.03471343f, 0.02188775f, -0.04515237f, -0.01546158f, -0.02866184f, 0.01127513f, 
    -0.02764330f, 0.00416674f, 0.01182787f, -0.02059805f, 0.00964364f, 0.00603413f, -0.02419190f, 0.02283844f, 
    0.02849423f, -0.03328991f, -0.03709417f, 0.00117047f, -0.01697562f, -0.03812426f, -0.02096101f, -0.01010699f, 
    0.01868892f, -0.03376356f, -0.02300696f, 0.00551011f, -0.04415452f, -0.02536905f, 0.00396712f, 0.01557445f, 
    -0.01392236f, -0.03404221f, 0.01379904f, -0.01471179f, -0.02058577f, -0.03983480f, -0.00549712f, -0.01514525f, 
    -0.03285946f, -0.00806481f, -0.04149545f, -0.03031414f, 0.00336809f, -0.04381560f, 0.02604007f, -0.03371375f, 
    0.00438249f, -0.04175670f, -0.04228302f, 0.01915514f, -0.00895651f, -0.03207218f, 0.02987331f, -0.03686623f, 
    0.00663383f, 0.02159642f, 0.00904966f, 0.00842900f, -0.03601175f, 0.01084987f, 0.02481194f, -0.02947194f, 
    -0.01455020f, -0.02401895f, 0.02051926f, -0.00179832f, 0.00714624f, -0.02011031f, 0.02533339f, -0.00245489f, 
    0.01307352f, -0.03255296f, -0.00247967f, -0.04540012f, 0.01973149f, -0.01562508f, 0.03149824f, -0.02191501f, 
    -0.00721458f, 0.01918465f, -0.01344888f, -0.01936416f, -0.03543859f, -0.02116068f, 0.02852260f, -0.00326905f, 
    0.03248565f, 0.00688052f, -0.03837199f, 0.00871716f, -0.04304359f, 0.01000352f, -0.03960397f, 0.02258359f, 
    0.01309604f, 0.02965250f, 0.01163383f, -0.01423126f, 0.01176281f, -0.00172085f, -0.01829716f, -0.02875763f, 
    0.02774815f, -0.04097735f, 0.00378043f, -0.01676830f, -0.01083613f, -0.03941103f, -0.00263722f, -0.03583995f, 
    0.00571705f, -0.03592164f, 0.01489195f, -0.03819719f, 0.02113731f, -0.00353413f, -0.01582260f, 0.02051775f, 
    -0.04538511f, -0.00465558f, -0.03784144f, 0.00850375f, -0.02712933f, 0.01866573f, -0.01468120f, -0.00267806f, 
    -0.03200990f, -0.03932643f, 0.00456599f, -0.02038997f, -0.00813480f, 0.02181485f, 0.00221095f, 0.00365350f, 
    -0.04171532f, -0.01441145f, 0.02705919f, 0.00429038f, -0.03708128f, -0.02536000f, 0.00251995f, 0.03161132f, 
    -0.03478954f, -0.01067333f, 0.00737405f, 0.01058279f, 0.02552969f, -0.00585143f, -0.00974960f, 0.02160618f, 
    0.00507138f, -0.00065068f, 0.02925464f, -0.03958437f, -0.02623743f, 0.02785694f, 0.01745446f, 0.01448143f, 
    0.02391094f, -0.00548452f, 0.00710427f, -0.00828074f, -0.03958468f, -0.03705764f, -0.01951223f, -0.01614621f, 
    -0.02631993f, 0.01406345f, -0.01890921f, -0.00548649f, 0.01101282f, -0.04264696f, -0.04295910f, 0.00903168f, 
    -0.01325752f, 0.01815191f, -0.02018798f, -0.00572331f, 0.01580667f, 0.03113410f, 0.00832958f, 0.00242330f, 
    -0.01989762f, 0.01976757f, -0.03402625f, -0.02663107f, -0.03576980f, 0.02626964f, -0.01866096f, -0.03202593f, 
    0.02558126f, -0.02545924f, 0.02673654f, 0.02700826f, -0.01627961f, 0.02471628f, 0.02761241f, 0.00621185f, 
    0.02796942f, -0.01698586f, -0.00764686f, -0.03620767f, 0.03092353f, -0.01176898f, 0.00245120f, -0.00973226f, 
    -0.02282768f, -0.02896581f, -0.03167414f, 0.02777326f, -0.01826479f, 0.01874093f, 0.02953055f, -0.04374181f, 
    -0.03200040f, -0.00334017f, 0.02345356f, 0.00595945f, 0.02942119f, -0.01345608f, -0.02572254f, 0.00686394f, 
    -0.01982476f, -0.04167969f, -0.03849293f, 0.00054824f, 0.02689144f, 0.03214078f, -0.00318955f, -0.02963962f, 
    -0.01533638f, 0.02824786f, -0.02869187f, -0.01981146f, 0.01046898f, -0.02002749f, -0.02275637f, 0.00707844f, 
    -0.01321438f, 0.00194099f, -0.00151537f, -0.00153035f, -0.01590679f, -0.04236495f, -0.03145931f, -0.00091471f, 
    -0.02905705f, 0.01087257f, 0.02926328f, 0.02614814f, 0.01162913f, -0.02011229f, 0.00457405f, -0.04122049f, 
    0.02331783f, -0.03739252f, 0.00630899f, -0.02966947f, -0.04347820f, -0.03006593f, -0.02192452f, 0.03281449f, 
    -0.01211482f, 0.01590461f, 0.02642768f, -0.01373434f, 0.01179484f, -0.03441538f, -0.02913657f, -0.03526641f, 
    -0.02001026f, 0.02466972f, -0.03108423f, -0.04370107f, 0.01755349f, 0.02045878f, 0.01619194f, -0.02170580f, 
    -0.01934823f, 0.01789122f, -0.02039459f, -0.00579521f, -0.01261023f, 0.03200918f, -0.03423286f, 0.01978787f, 
    0.03254600f, 0.03202662f, -0.02670701f, -0.01467235f, -0.00580007f, 0.00768632f, -0.01350615f, -0.04215804f, 
    0.00629306f, 0.00842793f, -0.00474988f, 0.00159529f, 0.00276936f, 0.00901611f, -0.02601326f, 0.02179189f, 
    0.02949455f, 0.04514533f, -0.00505261f, 0.01760567f, 0.00584210f, -0.01937235f, 0.01580327f, -0.02748941f, 
    0.02556188f, -0.03036082f, 0.01854817f, 0.00377109f, 0.01528634f, -0.02435570f, -0.02981431f, -0.04196827f, 
    -0.04487711f, 0.01715763f, 0.01320846f, 0.02816965f, 0.01916337f, -0.01646038f, 0.01318698f, -0.02269909f, 
    -0.03201246f, -0.01245865f, -0.02418815f, 0.00395604f, -0.00028294f, -0.02589365f, -0.02566291f, -0.02439947f, 
    -0.02619896f, 0.02162804f, -0.01066757f, 0.01333285f, 0.01290424f, -0.01303290f, -0.04452597f, -0.03466788f, 
    -0.00103162f, -0.03887863f, -0.00717154f, 0.01057278f, -0.02504081f, -0.00324701f, -0.04335259f, -0.01259663f, 
    -0.04099545f, -0.01937973f, -0.02596308f, 0.01081505f, -0.00818168f, -0.01701965f, -0.02562154f, 0.01388191f, 
    -0.03598907f, -0.00948321f, 0.01630677f, -0.04387023f, 0.00047000f, -0.02808501f, 0.01851351f, -0.01210577f, 
    -0.03408709f, -0.00665526f, -0.02948444f, 0.00292496f, -0.02418666f, 0.01187252f, -0.02805762f, 0.00969063f, 
    -0.01896322f, -0.00896687f, 0.03299910f, 0.03244359f, 0.02562798f, 0.01907702f, 0.04117366f, 0.02969684f, 
    -0.00708172f, -0.03284918f, 0.01987831f, 0.01886721f, 0.01696303f, 0.03167202f, -0.03941457f, 0.02598580f, 
    0.01786037f, -0.00449870f, -0.00002965f, -0.04018265f, 0.03170922f, 0.03270529f, 0.02382729f, -0.02542170f, 
    -0.00668172f, -0.02102939f, 0.00112765f, -0.03838362f, -0.03945267f, -0.03360409f, -0.03098447f, 0.03306021f, 
    0.01519144f, -0.02646630f, -0.01320843f, 0.00924232f, 0.00711228f, 0.00602559f, 0.02794968f, 0.03288930f, 
    -0.03254053f, -0.03819438f, -0.03241148f, 0.02943394f, -0.02857746f, -0.03065092f, -0.02070794f, -0.00741796f, 
    0.01467744f, -0.01561750f, -0.01624817f, 0.00482467f, 0.00032817f, -0.03708008f, 0.00481701f, 0.03640385f, 
    0.02084394f, -0.01955283f, 0.00443528f, -0.01983192f, 0.03522979f, -0.02442180f, 0.00829991f, -0.03518987f, 
    -0.04507796f, -0.04049276f, -0.02836098f, -0.02580263f, -0.00480404f, 0.03059309f, 0.02674288f, -0.02620136f, 
    0.01115290f, -0.00684047f, 0.02563140f, -0.00539173f, -0.00030070f, -0.01521782f, -0.00430812f, -0.00509884f, 
    -0.00950070f, -0.00364567f, -0.01707413f, 0.02719005f, -0.02346801f, -0.00843434f, 0.01038506f, -0.01549152f, 
    -0.02253399f, -0.03219410f, -0.02224299f, 0.03266663f, -0.03091261f, -0.02867013f, -0.03683819f, -0.03174313f, 
    -0.01925771f, -0.04546853f, 0.02941405f, -0.03693916f, 0.00260177f, 0.02738024f, 0.00972309f, -0.01964750f, 
    -0.02686578f, 0.00130993f, -0.00476302f, -0.00274582f, -0.01769926f, 0.02520306f, -0.04080209f, -0.01888608f, 
    -0.02435943f, -0.00846470f, 0.02238592f, 0.00711389f, -0.00729210f, -0.03571711f, 0.03256141f, -0.02740233f, 
    0.01648380f, -0.00867166f, -0.01068071f, 0.01536803f, -0.00717279f, -0.01816774f, -0.01928180f, -0.04174455f, 
    0.02883323f, 0.02881699f, -0.03606671f, 0.01198847f, -0.02426830f, -0.02719546f, -0.02496815f, 0.01332525f, 
    0.00798932f, -0.04470890f, 0.03856629f, -0.00944020f, -0.02697954f, -0.02484167f, 0.01322982f, -0.00635993f, 
    0.01410682f, 0.02728719f, -0.00032294f, 0.00302003f, -0.01852412f, 0.00543648f, 0.00068458f, -0.03521433f, 
    0.02929032f, -0.03752083f, 0.02419046f, 0.01706044f, -0.01864341f, -0.02559183f, 0.00668776f, 0.02966609f, 
    -0.01701584f, -0.03573622f, 0.02995616f, -0.03395498f, -0.03065116f, -0.02869085f, 0.01534466f, 0.01718785f, 
    0.03266173f, -0.00631654f, -0.00190867f, 0.01386290f, -0.04162093f, 0.01623932f, -0.01587980f, 0.02916718f, 
    0.00114496f, 0.01224447f, 0.02423852f, 0.01612459f, -0.03109676f, 0.00900422f, -0.01194221f, 0.00419350f, 
    -0.01380245f, 0.02740337f, 0.00590801f, 0.02017884f, -0.04205331f, -0.03268129f, -0.01951443f, -0.03519461f, 
    0.01282752f, 0.03333211f, -0.02551966f, 0.02207396f, 0.02766578f, -0.02695987f, 0.02025239f, -0.02718101f, 
    -0.03541298f, -0.00991973f, -0.00039827f, 0.02573783f, -0.03696169f, -0.00187648f, -0.02515704f, -0.01486390f, 
    0.00570276f, -0.00894064f, -0.01378265f, 0.01215357f, -0.03811744f, 0.01632291f, 0.00052726f, 0.00700492f, 
    -0.02127628f, -0.01818235f, 0.00630487f, 0.00069432f, 0.00935166f, -0.02457662f, -0.03415201f, -0.01563568f, 
    0.01358650f, -0.02914339f, -0.03040290f, 0.00821834f, -0.00123249f, -0.04379632f, -0.04066024f, -0.00828366f, 
    -0.00551211f, 0.01280742f, -0.02748824f, 0.03310425f, -0.02726492f, 0.03947341f, -0.03197999f, -0.01254304f, 
    -0.02249162f, 0.00137556f, 0.03270926f, -0.03521235f, 0.01699430f, -0.02243622f, 0.00828831f, 0.00166233f, 
    -0.03478148f, -0.04507864f, 0.01244223f, 0.02468020f, 0.02405117f, 0.02870402f, -0.02340059f, -0.01425579f, 
    0.00364330f, -0.02462843f, 0.01202384f, -0.03310530f, -0.03962670f, -0.02777703f, -0.01563743f, -0.03701687f, 
    0.01580578f, 0.03050239f, -0.02868833f, 0.03102368f, -0.00873842f, 0.01501052f, 0.00540921f, -0.02888160f, 
    0.00748405f, -0.03435410f, -0.03077750f, -0.00049689f, -0.02589940f, -0.00475684f, 0.03390992f, 0.00152665f, 
    0.00069245f, 0.02211896f, 0.02836101f, 0.00706866f, -0.02630269f, 0.00660726f, -0.03121297f, -0.02300243f, 
    0.02314036f, -0.03553868f, -0.02621274f, 0.00798758f, -0.02615828f, 0.02074148f, -0.02084021f, -0.00036938f, 
    -0.04412747f, -0.00101942f, -0.00943177f, 0.00207093f, 0.03090122f, 0.01298624f, 0.00318811f, 0.02453137f, 
    -0.01367577f, 0.02246950f, 0.00216845f, -0.02927354f, -0.01839881f, -0.01507068f, -0.00082032f, 0.00357385f, 
    -0.01277507f, -0.01594329f, 0.01632945f, 0.00123060f, 0.02615505f, 0.01583349f, 0.01219028f, -0.00276195f, 
    -0.01576436f, 0.00147244f, -0.03180780f, -0.00309696f, 0.01209989f, -0.03880027f, -0.04540562f, -0.03542322f, 
    -0.01201833f, -0.03073167f, 0.03145092f, -0.01647886f, 0.01394015f, -0.01240093f, 0.01267285f, -0.00687077f, 
    0.01043204f, 0.01539653f, 0.03116646f, -0.01777058f, -0.01525335f, 0.00668793f, 0.00036408f, -0.03623946f, 
    0.01958239f, -0.02373545f, -0.01068777f, -0.00825172f, -0.03270313f, 0.02764439f, -0.00890622f, 0.03664930f, 
    0.00901676f, 0.02023359f, 0.03943990f, 0.03589147f, 0.01807780f, 0.03098442f, 0.00822008f, 0.01965806f, 
    -0.01873062f, -0.03923245f, 0.01831444f, -0.00131867f, -0.01710777f, 0.00744729f, 0.01956086f, -0.02614663f, 
    0.02231358f, -0.01497168f, -0.03890709f, 0.03221468f, 0.00903963f, -0.03763358f, -0.02851826f, 0.00936764f, 
    0.01973450f, -0.02583050f, 0.01635858f, -0.02251457f, -0.01644258f, 0.00484912f, -0.00705027f, 0.02707175f, 
    -0.02674413f, -0.03395626f, 0.04538021f, 0.01305468f, -0.03711401f, 0.02230999f, 0.00721520f, -0.04406407f, 
    -0.01444535f, -0.03516139f, 0.02536716f, 0.00077068f, -0.04316175f, 0.00672627f, -0.01966576f, -0.04123820f, 
    -0.00002450f, -0.01307277f, -0.03027346f, -0.00321627f, 0.01529946f, -0.00616333f, -0.02184562f, 0.01467311f, 
    -0.02532104f, -0.00129609f, 0.01234259f, -0.01882662f, -0.02474794f, -0.00210224f, -0.03181704f, -0.02121668f, 
    -0.03966692f, -0.04118785f, -0.03914636f, -0.01947582f, 0.02506673f, -0.02516231f, -0.02365728f, 0.00536395f, 
    0.03238179f, 0.02670065f, -0.02287288f, -0.01689606f, 0.01877280f, 0.00188767f, 0.01958651f, -0.01846271f, 
    -0.02975312f, -0.02026713f, 0.02103776f, -0.00142286f, 0.01847147f, -0.01412267f, 0.02777582f, 0.01602116f, 
    -0.02763148f, -0.01242876f, -0.02335257f, 0.00242137f, 0.03172735f, -0.03956730f, -0.02232750f, -0.03730810f, 
    -0.00814860f, 0.02504844f, -0.03149622f, -0.02209391f, -0.00952435f, -0.00912300f, 0.01449037f, -0.00542928f, 
    0.01575094f, -0.02467110f, 0.01546227f, -0.01775561f, -0.03097860f, -0.03264342f, 0.00126626f, -0.00804826f, 
    -0.03845972f, 0.01993950f, -0.03227044f, -0.03403771f, -0.02549427f, 0.02298592f, -0.02465320f, -0.02947435f, 
    0.02953050f, 0.02995686f, -0.02095794f, 0.02364584f, 0.03924418f, -0.00715511f, 0.02585240f, -0.02459551f, 
    0.04038705f, -0.02135006f, 0.00684232f, 0.03661872f, 0.01681902f, -0.00740853f, -0.00338442f, 0.00714588f, 
    -0.02455210f, -0.01876828f, 0.02365503f, -0.02619605f, 0.02117236f, 0.04334750f, -0.00161505f, 0.01616333f, 
    0.01916114f, 0.02394845f, 0.03001045f, 0.00534694f, -0.01103684f, 0.00258919f, -0.03572324f, 0.03317046f, 
    0.01231091f, -0.00652249f, 0.01331909f, -0.01206121f, 0.02585533f, -0.01741261f, 0.03185571f, -0.00662216f, 
    0.02424777f, -0.01347500f, -0.03219212f, -0.01463745f, -0.01442225f, -0.01747140f, 0.02395142f, -0.02198028f, 
    0.03062540f, -0.01435915f, -0.01362635f, 0.02164917f, -0.03689480f, -0.00820108f, 0.03238924f, -0.01536485f, 
    -0.01876363f, -0.00305536f, 0.01083911f, 0.03759090f, -0.01213618f, 0.02159815f, -0.02693780f, -0.02725754f, 
    0.00897254f, -0.02450930f, 0.00100561f, -0.00615138f, 0.02339181f, 0.00102742f, -0.02642240f, -0.03939110f, 
    0.02859921f, -0.04723203f, 0.00988444f, -0.01408612f, 0.00239045f, 0.02184928f, -0.00190361f, -0.04741273f, 
    -0.04098394f, -0.04670399f, -0.01731117f, 0.00599134f, -0.02556753f, -0.03394300f, -0.01145907f, 0.01959939f, 
    0.02123855f, -0.01380254f, 0.01157773f, -0.03830536f, -0.04939877f, -0.02307090f, 0.02751198f, 0.00892775f, 
    0.00131372f, -0.04163541f, -0.03609091f, -0.03245554f, -0.02254181f, 0.00905873f, 0.02059617f, -0.00680500f, 
    -0.03856329f, 0.01896703f, -0.01652788f, -0.01754307f, -0.04196327f, -0.00565387f, -0.01273345f, -0.01704052f, 
    -0.00715653f, 0.01201189f, -0.02944904f, -0.03033224f, 0.01828780f, -0.01114550f, -0.03678447f, -0.01180506f, 
    0.00832192f, 0.00746495f, -0.03802654f, 0.03519817f, 0.02167758f, 0.00414268f, 0.00555381f, 0.03625146f, 
    0.03916727f, 0.01630867f, -0.03719563f, 0.00558536f, 0.00840160f, 0.02058964f, 0.01761961f, 0.03185178f, 
    -0.01378682f, 0.00516801f, -0.03007597f, -0.02926883f, 0.01259784f, 0.00873964f, -0.02954098f, 0.00406942f, 
    0.02807427f, -0.02796108f, -0.02026731f, -0.02259381f, -0.03051880f, -0.03643204f, -0.03689481f, 0.03397753f, 
    -0.02183893f, 0.01558002f, -0.04178279f, 0.01518683f, -0.01653589f, -0.01635735f, -0.04208484f, 0.02933308f, 
    -0.01262289f, -0.03418572f, 0.00958408f, 0.01733587f, 0.01275044f, 0.02467756f, -0.00310754f, -0.00990054f, 
    -0.01762496f, 0.01331072f, -0.02412059f, 0.00655271f, -0.00614580f, 0.00047761f, 0.00744238f, 0.02533829f, 
    -0.01015696f, -0.04490360f, 0.01475436f, 0.00960773f, -0.03654392f, -0.05258496f, -0.00649882f, 0.01645470f, 
    -0.00882277f, 0.03865714f, 0.03099297f, 0.02667971f, 0.03475871f, -0.01692079f, 0.03657492f, -0.02711497f, 
    0.00254451f, 0.03895450f, -0.04336676f, 0.00631814f, 0.01380151f, -0.00845924f, 0.02453857f, 0.00275089f, 
    0.03458728f, -0.02710883f, 0.03994989f, 0.01976064f, 0.00766944f, 0.02859803f, -0.00234380f, 0.02318868f, 
    0.04141726f, 0.01142327f, 0.02807720f, 0.02015225f, -0.03103056f, -0.02453641f, -0.00557792f, -0.01257248f, 
    -0.03063213f, 0.01146023f, -0.02842029f, 0.01858533f, -0.02298698f, -0.03935699f, 0.01895115f, 0.03090025f, 
    0.02247415f, -0.00536746f, 0.00001991f, -0.01691407f, -0.03787736f, -0.01551528f, 0.01212923f, -0.04032456f, 
    -0.03341722f, -0.00972203f, -0.01165036f, -0.01137813f, 0.01339509f, -0.00066508f, 0.00500094f, 0.00543252f, 
    0.02374277f, -0.03777626f, -0.04136838f, -0.02923387f, -0.00853929f, 0.03263177f, -0.04040889f, 0.00905022f, 
    0.02513308f, 0.03214886f, 0.02659791f, -0.03570934f, 0.02449795f, -0.03695924f, -0.00303139f, 0.00422151f, 
    -0.01280195f, 0.01100045f, -0.02537331f, 0.02691077f, 0.00669225f, -0.02092456f, -0.01840585f, -0.02259203f, 
    -0.01958378f, -0.03635037f, 0.01859305f, 0.00713005f, 0.02236728f, -0.04497055f, -0.01572176f, -0.00707825f, 
    -0.01446997f, 0.01108616f, 0.01523292f, 0.00425323f, 0.01027464f, -0.01030027f, -0.00255870f, -0.02484178f, 
    -0.03907951f, 0.02011598f, 0.01621037f, -0.00069041f, -0.02561638f, -0.03360727f, -0.01059435f, 0.00271541f, 
    0.02747602f, -0.02088182f, -0.00009104f, -0.01668659f, 0.00506153f, -0.02423349f, -0.00832016f, 0.02400273f, 
    0.02155362f, 0.02907038f, -0.01040112f, -0.00930395f, 0.00688413f, 0.03025298f, 0.01673308f, 0.00165806f, 
    0.02296995f, 0.03307997f, -0.04588429f, -0.02734352f, 0.01559148f, 0.02068244f, -0.00079719f, -0.01599900f, 
    0.02096251f, -0.00991384f, 0.00810889f, 0.01387715f, 0.01915267f, 0.01802094f, 0.00717811f, 0.02574315f, 
    0.03731451f, -0.02215163f, 0.01208659f, -0.03813365f, 0.01686490f, 0.01882575f, -0.03744004f, -0.01607108f, 
    0.01482882f, -0.02346905f, -0.00934369f, 0.00123560f, -0.01283908f, 0.03959873f, -0.02735625f, -0.03329565f, 
    0.02482521f, 0.00325759f, -0.02451486f, -0.01567820f, 0.02063891f, 0.01537172f, 0.01756370f, -0.00232905f, 
    0.01500434f, -0.04096754f, -0.00500303f, 0.01940588f, -0.03891334f, 0.02987747f, 0.03189718f, 0.02607633f, 
    -0.03911717f, 0.02476485f, 0.00025255f, 0.00624889f, -0.00777826f, 0.00526470f, 0.03501136f, 0.00141482f, 
    -0.03018874f, -0.02907080f, 0.02035737f, 0.02242496f, -0.03391577f, -0.02185701f, -0.02488662f, -0.01603252f, 
    0.01925440f, -0.03991184f, 0.00696835f, -0.03884847f, -0.00286929f, 0.02100120f, -0.01922634f, -0.01601181f, 
    -0.01520536f, 0.00599912f, -0.00330890f, -0.04020785f, -0.04135082f, -0.01879027f, -0.03009163f, 0.00833793f, 
    0.00829666f, -0.03017296f, 0.01630337f, 0.01013897f, 0.01167723f, 0.02441378f, -0.04114049f, -0.00780797f, 
    0.02197434f, -0.03870327f, -0.01335495f, -0.00199971f, 0.00956055f, -0.00055484f, -0.00321171f, -0.02901388f, 
    0.02527154f, -0.01042618f, 0.03500348f, 0.03433852f, 0.02432597f, 0.01455466f, -0.04262560f, 0.00708313f, 
    0.01158356f, -0.00986699f, -0.04769569f, -0.03572190f, 0.02240434f, 0.03020905f, 0.03498168f, -0.00544573f, 
    -0.01202111f, 0.02006475f, -0.01905051f, 0.01286386f, 0.01494029f, -0.02960331f, -0.00856796f, -0.00226672f, 
    0.03705357f, 0.02049118f, -0.02205797f, -0.00418494f, 0.02408064f, 0.01940612f, -0.03708775f, -0.03078095f, 
    -0.02224251f, -0.02702278f, 0.03182642f, -0.03402396f, 0.02276049f, 0.03086238f, -0.01455004f, 0.03041812f, 
    0.02365262f, 0.02835369f, -0.01540702f, 0.03229334f, -0.02766512f, 0.00943689f, 0.00815671f, 0.01296289f, 
    0.00537517f, -0.00863116f, -0.03678010f, 0.00571323f, -0.03597176f, 0.01417439f, 0.01816874f, 0.03313342f, 
    -0.02727793f, 0.00377054f, 0.00453016f, -0.00342108f, -0.00296332f, 0.01969024f, 0.03170349f, 0.00952708f, 
    -0.02995307f, 0.02068368f, -0.00492901f, 0.02075777f, -0.04196569f, -0.00881320f, 0.03414176f, -0.00512346f, 
    -0.00610504f, -0.01114638f, 0.00284282f, -0.00981543f, -0.01884533f, 0.01357389f, 0.00283702f, 0.00217215f, 
    -0.00616659f, -0.02848587f, -0.01143395f, -0.02358072f, -0.02221439f, 0.01659404f, 0.02602611f, -0.04257027f, 
    -0.03077103f, -0.02882190f, -0.01026224f, -0.01529686f, -0.04026815f, -0.01185052f, -0.01323098f, 0.01113211f, 
    -0.01634566f, -0.01689139f, -0.01024830f, -0.00964327f, -0.02989158f, 0.00716032f, -0.04007926f, 0.00214821f, 
    -0.01475651f, 0.02148942f, 0.03544047f, -0.01004043f, -0.02994915f, 0.03504554f, 0.03314455f, -0.00335996f, 
    -0.01396445f, -0.01799770f, 0.00044153f, 0.02977268f, -0.00662037f, 0.04143989f, -0.02965433f, 0.03112753f, 
    0.00360730f, -0.00684606f, 0.00901979f, 0.02676321f, 0.00818611f, -0.04136855f, 0.00556247f, 0.01605258f, 
    0.03302231f, 0.02002624f, -0.02238315f, -0.01919724f, -0.00405446f, 0.03178479f, -0.00994389f, 0.00211378f, 
    0.01626387f, -0.04153990f, -0.02384355f, -0.01451512f, 0.03263890f, -0.02890722f, -0.02044171f, 0.02049887f, 
    0.00799896f, 0.02232745f, -0.03396906f, 0.00090317f, -0.00641864f, -0.01391866f, 0.01802343f, 0.00707682f, 
    0.00993530f, 0.00703510f, -0.03958786f, 0.03326215f, 0.03243590f, -0.04353984f, 0.01423670f, -0.03061793f, 
    -0.00330308f, -0.04146121f, 0.02026911f, 0.00724244f, 0.01963046f, 0.03401579f, -0.04259239f, 0.01848414f, 
    -0.00937220f, 0.01569316f, -0.00705058f, -0.02947441f, -0.02342948f, -0.03253595f, 0.00801614f, -0.02988390f, 
    -0.03181836f, 0.01448271f, -0.01651050f, -0.01726224f, -0.00207005f, -0.00884166f, -0.01199235f, -0.00651452f, 
    0.02291083f, 0.00399712f, -0.00095742f, -0.00142794f, -0.00782140f, 0.03280125f, -0.03679756f, 0.00885885f, 
    -0.00010198f, -0.00258893f, -0.01769213f, -0.03689074f, -0.03829767f, 0.00701259f, 0.00298000f, -0.01020108f, 
    -0.02303054f, -0.04591075f, -0.04807082f, 0.00416716f, -0.01346237f, 0.03364100f, -0.01360530f, 0.02207740f, 
    -0.00810492f, -0.00617667f, -0.00842042f, -0.01436048f, 0.01344170f, 0.01415345f, -0.01896088f, -0.03018465f, 
    0.03148415f, -0.01720674f, 0.02627020f, -0.00024700f, -0.02923323f, -0.00073107f, -0.00777582f, 0.03759492f, 
    0.16660477f, 0.35308751f, 0.11133680f, 0.02054794f, 0.02235417f, -0.00500817f, 0.01300854f, 0.01958180f, 
    0.08916215f, -0.03839792f, 0.09474868f, 0.11472001f, -0.04340024f, -0.01316426f, 0.00644902f, -0.02155067f, 
    -0.06161717f, 0.10454532f, -0.03818243f, 0.00286624f, -0.07034501f, -0.00347390f, -0.09581657f, -0.05937482f, 
    -0.05866668f, 0.19475706f, 0.01009473f, 0.11143679f, 0.08709089f, 0.14690004f, 0.05908240f, 0.07417619f, 
    0.07177956f, -0.05227163f, 0.00683649f, -0.14689659f, 0.12994274f, -0.19508979f, -0.02635158f, -0.06935126f, 
    0.14042823f, 0.19149756f, -0.02247307f, 0.00342046f, -0.07626318f, 0.11897460f, 0.00462488f, -0.06943662f, 
    -0.00803308f, -0.02141024f, 0.10573854f, 0.02434496f, -0.15174878f, -0.04485984f, -0.08678704f, 0.10949440f, 
    0.00883115f, -0.04106814f, -0.04177323f, 0.02134692f, 0.16155075f, 0.11593819f, 0.03164755f, -0.05181779f, 
    0.11692401f, -0.01783832f, -0.21325520f, 0.13682796f, -0.03997649f, 0.08820751f, -0.02782986f, 0.03123421f, 
    -0.01429649f, -0.03806162f, 0.17504165f, -0.07819216f, -0.02760700f, -0.07044727f, 0.01439866f, 0.01887139f, 
    0.26825705f, 0.12551489f, 0.00576853f, 0.00426054f, 0.05997347f, 0.03630336f, -0.00505190f, -0.01928273f, 
    -0.05739037f, -0.08217179f, 0.05746676f, 0.06448948f, -0.13493168f, 0.01618763f, -0.00067158f, 0.04092117f, 
    0.03392302f, 0.06849351f, 0.08397731f, -0.06266673f, -0.03499318f, 0.04513061f, -0.23943356f, -0.11271506f, 
    -0.16377354f, -0.02871531f, 0.13908333f, -0.10102960f, -0.01177838f, 0.01286109f, -0.00219459f, 0.04290339f, 
    0.09334813f, -0.04809932f, 0.00633148f, -0.00360836f, -0.03123843f, 0.13246982f, -0.07865850f, 0.10395721f, 
    0.69434631f, 0.09037133f, -0.18281193f, 0.07431366f, -0.04394610f, -0.06091755f, 0.12999733f, 0.02613762f, 
    0.03220298f, -0.02791634f, -0.06606615f, -0.12223767f, 0.12418725f, 0.17829132f, 0.09012664f, 0.02785468f, 
    0.02063158f, 0.07580543f, -0.14651699f, 0.00035396f, 0.00763863f, -0.00132679f, 0.05008035f, 0.09493988f, 
    -0.04576578f, 0.11250396f, 0.10576020f, 0.12920588f, -0.06895880f, 0.06722720f, 0.05309605f, -0.00567834f, 
    -0.04130760f, 0.11109657f, -0.14430751f, 0.14907664f, 0.17784680f, -0.06113836f, 0.00629517f, -0.05126099f, 
    -0.03161673f, -0.17592038f, 0.03277845f, -0.07328500f, 0.10820755f, 0.01631149f, -0.05446303f, 0.06052768f, 
    0.06771842f, 0.09826059f, -0.11531269f, 0.06245637f, 0.11164894f, 0.14415760f, 0.07297172f, 0.14040232f, 
    -0.00465986f, -0.07631833f, -0.08920046f, -0.12954421f, 0.06868801f, 0.22280326f, 0.03951858f, -0.02106027f, 
    -0.05189067f, -0.03692058f, 0.11524373f, -0.04171108f, 0.01270676f, -0.00643969f, 0.02883443f, -0.01589825f, 
    0.05064953f, 0.03513346f, -0.01064676f, -0.07514973f, -0.05872584f, 0.06270818f, 0.13124153f, 0.02205276f, 
    -0.04610612f, -0.08350058f, -0.10563117f, -0.20630328f, 0.13128395f, -0.00499577f, -0.11891276f, -0.00732720f, 
    0.05196660f, -0.01371128f, -0.05551364f, -0.00444216f, 0.19654663f, 0.10301661f, -0.01665847f, -0.13820912f, 
    -0.05270179f, -0.15125428f, -0.16708666f, -0.09486236f, 0.16968739f, 0.00394234f, -0.21600148f, -0.10218398f, 
    0.03369249f, 0.11438313f, 0.10441728f, 0.05130973f, -0.03965189f, 0.14691743f, 0.07513452f, -0.03741729f, 
    -0.02976803f, -0.05505132f, 0.02026056f, -0.05776975f, 0.04765106f, -0.16161337f, -0.07534229f, 0.03742744f, 
    0.25540319f, 0.13834639f, -0.16645238f, 0.03059370f, -0.10139944f, -0.01481949f, -0.01082122f, 0.08148157f, 
    0.06660065f, -0.00027514f, 0.09884629f, -0.02166225f, -0.05331178f, -0.10944423f, -0.12093940f, 0.06620318f, 
    -0.15179066f, 0.04883188f, -0.08166751f, 0.10143378f, 0.03749515f, 0.06396405f, 0.19649276f, -0.18909374f, 
    0.07897749f, -0.00264275f, -0.11903823f, -0.08868788f, -0.05930674f, 0.06283221f, 0.10183069f, 0.01459847f, 
    -0.05955863f, -0.05972366f, -0.05540247f, 0.01723070f, 0.09906169f, -0.06586510f, 0.05973722f, -0.06719653f, 
    0.50888371f, 0.28384498f, 0.16423818f, 0.07271736f, 0.06914096f, -0.01165089f, 0.14252804f, 0.02016299f, 
    -0.00874046f, -0.00088975f, 0.04779141f, -0.00405693f, -0.05310060f, 0.06987737f, -0.03761766f, 0.01397671f, 
    -0.03694544f, 0.11483539f, 0.04112029f, 0.02162371f, 0.20700468f, 0.23854291f, -0.06645808f, 0.02082668f, 
    0.05335209f, -0.01832202f, 0.03059979f, 0.04378246f, 0.03264809f, -0.01335938f, -0.04280415f, -0.10666703f, 
    0.05845824f, 0.26235104f, 0.08597882f, -0.00609339f, 0.01541372f, 0.03846181f, -0.08467226f, 0.00168227f, 
    0.45475271f, 0.08040403f, 0.16215955f, 0.05515613f, 0.14761740f, 0.15135282f, 0.06011985f, 0.04067373f, 
    -0.08208977f, -0.03156535f, -0.00733105f, -0.03511756f, 0.03231033f, 0.04986145f, -0.08511182f, -0.08632598f, 
    -0.02457283f, 0.05663424f, 0.09999994f, -0.07942629f, 0.25564197f, -0.11566605f, -0.07056262f, 0.02351310f, 
    -0.05238136f, 0.03117000f, 0.13138880f, -0.01214934f, 0.05463981f, -0.00221606f, 0.02953354f, -0.03850145f, 
    0.06915082f, -0.02877687f, 0.05344163f, 0.07276972f, -0.11894079f, -0.05400981f, -0.05243140f, 0.03712820f, 
    -0.28702620f, 0.25150198f, -0.13828990f, 0.06516107f, -0.11702019f, 0.08872164f, -0.01831376f, 0.04202124f, 
    -0.15574610f, 0.08147039f, 0.01035449f, 0.03498035f, -0.07290260f, 0.02616653f, -0.05452343f, 0.02474695f, 
    0.02657459f, 0.14497374f, -0.03306710f, -0.00077878f, 0.25553042f, 0.14906237f, 0.21031877f, 0.07311451f, 
    -0.03221329f, -0.06486690f, 0.16639215f, 0.04830677f, -0.05009437f, 0.16271749f, 0.05155503f, -0.08894091f, 
    -0.00602448f, 0.00971509f, 0.08993794f, 0.05137872f, 0.05685969f, -0.05767944f, 0.04959075f, -0.01933091f, 
    0.23091701f, -0.15713044f, 0.10600249f, 0.14527510f, 0.06519707f, 0.02520860f, 0.05692952f, -0.08385076f, 
    0.06549278f, 0.01698950f, -0.02251937f, 0.10193418f, 0.04057319f, -0.00294718f, 0.06392863f, -0.01782921f, 
    0.00183984f, 0.01059527f, -0.04717152f, 0.07010313f, -0.33666354f, 0.13674510f, 0.07398221f, -0.03788555f, 
    -0.04285282f, -0.02720987f, -0.09581676f, -0.00818395f, 0.00708613f, 0.12673648f, 0.08617189f, -0.12679063f, 
    -0.03989017f, -0.07986577f, -0.08477731f, 0.13938004f, -0.04681354f, 0.06546338f, -0.01709309f, 0.03729278f, 
    0.24461173f, -0.05512499f, -0.24030510f, -0.09150533f, 0.00359901f, 0.10925315f, 0.03594106f, -0.00197091f, 
    0.04727860f, 0.08303261f, 0.06298234f, 0.01736769f, 0.01759130f, -0.07014579f, -0.00644032f, 0.00084598f, 
    0.08947281f, -0.17043632f, -0.05596375f, -0.03544947f, -0.27545983f, -0.10653222f, -0.01598438f, -0.02187438f, 
    0.01422060f, -0.00458967f, 0.01958725f, 0.03057445f, -0.11863445f, 0.04205589f, -0.01541682f, 0.03706136f, 
    0.04895063f, -0.03914706f, -0.09626715f, -0.00046029f, -0.10081998f, 0.03877225f, -0.01430355f, -0.09888136f, 
    0.19495559f, 0.11241125f, 0.10756189f, -0.03862285f, 0.23027915f, 0.06742759f, -0.09567262f, 0.09319446f, 
    -0.03560469f, 0.01794304f, -0.02123371f, -0.08379588f, 0.08685435f, 0.13140240f, 0.02824563f, 0.17856950f, 
    0.04940123f, -0.22011173f, -0.07927595f, 0.03821790f, 0.08195911f, 0.22665165f, 0.01485881f, 0.01743289f, 
    -0.04341996f, -0.04835619f, 0.08491167f, -0.00377867f, -0.04623425f, -0.05195190f, 0.08866139f, -0.02831007f, 
    -0.05084158f, -0.10832977f, -0.05281681f, 0.00886413f, 0.03972145f, -0.02754637f, 0.05680926f, -0.02296781f, 
    0.01919440f, -0.08669974f, -0.05712752f, 0.01862472f, -0.05343274f, 0.04496369f, 0.11233297f, -0.08791605f, 
    0.03777229f, 0.03298603f, 0.04535791f, 0.06503402f, 0.04098481f, 0.16219313f, -0.09309159f, 0.04608407f, 
    -0.08249374f, 0.02333699f, -0.17082451f, -0.08278538f, -0.06828333f, -0.04092872f, 0.00748226f, -0.10715070f, 
    -0.04771985f, 0.00951089f, -0.19206312f, -0.01575678f, 0.02026245f, 0.19287355f, 0.15809624f, 0.01413134f, 
    0.07473583f, 0.00205559f, -0.00702361f, -0.03678497f, -0.05898666f, -0.10993712f, 0.04784378f, -0.06799198f, 
    -0.04380098f, -0.11971693f, 0.03206925f, -0.03871693f, -0.02192647f, -0.01874001f, -0.00240848f, 0.00575994f, 
    0.16003889f, 0.01973543f, -0.05230268f, -0.02098625f, 0.10271505f, 0.03776013f, 0.11426136f, 0.06101042f, 
    0.08777022f, 0.01224663f, -0.04697802f, 0.04101079f, -0.47329444f, -0.05444226f, -0.04752427f, 0.10608099f, 
    0.11859800f, 0.08954629f, 0.14013618f, -0.07571931f, -0.07555086f, 0.15309580f, 0.10707073f, -0.02426057f, 
    0.10031415f, -0.01394281f, 0.02452388f, 0.06765994f, 0.06784090f, -0.01461317f, -0.08575905f, -0.08501446f, 
    -0.35824668f, 0.22499231f, 0.01214041f, 0.08227228f, -0.09426811f, -0.00896511f, 0.04993822f, 0.06154145f, 
    -0.05668763f, 0.08490933f, 0.08355214f, 0.06068045f, -0.02411348f, 0.00513150f, 0.02917175f, 0.09372056f, 
    -0.04313061f, 0.05265089f, 0.01559410f, 0.03610313f, 0.06646990f, -0.00422348f, -0.22729352f, -0.05134388f, 
    -0.02623205f, 0.05669341f, 0.09016982f, -0.04955714f, 0.12133487f, -0.03940656f, -0.01856999f, 0.00673904f, 
    0.11232626f, 0.15727796f, 0.06339316f, -0.05841239f, -0.03066492f, -0.03434880f, -0.23059867f, -0.10039771f, 
    -0.09775911f, 0.04991539f, -0.14794108f, -0.15323667f, -0.09482033f, -0.00506611f, 0.00129396f, 0.19579723f, 
    0.05135556f, 0.10102069f, -0.02400960f, -0.02801397f, 0.04970011f, -0.01178579f, -0.03441744f, 0.05827318f, 
    0.08428869f, -0.26071721f, -0.05661184f, 0.02671375f, 0.21323542f, -0.20877442f, 0.10958774f, 0.12774678f, 
    0.00431726f, -0.07677112f, -0.02211257f, 0.08885935f, -0.05619122f, 0.01896086f, 0.02147022f, -0.03530568f, 
    0.03621919f, 0.11118557f, 0.05997349f, 0.08266120f, -0.01186044f, 0.12172051f, -0.10072995f, 0.12838411f, 
    0.11339521f, 0.07642724f, 0.05380819f, -0.15071291f, -0.00205522f, 0.08516552f, 0.17894770f, 0.09347504f, 
    0.09577657f, -0.05333785f, -0.03913343f, 0.01092642f, 0.11276487f, -0.02047219f, -0.10269676f, 0.13799386f, 
    -0.01954187f, 0.09576789f, 0.13126077f, -0.07864012f, -0.32992032f, 0.41174921f, 0.10484185f, 0.02765934f, 
    0.27952954f, -0.01885635f, -0.01718535f, 0.02030846f, 0.00472405f, 0.07516189f, -0.10116625f, -0.02209131f, 
    0.06504135f, -0.03620889f, 0.01883115f, 0.11590762f, 0.13257301f, 0.04088867f, -0.01068049f, -0.10039421f, 
    -0.32637900f, 0.39600271f, -0.04834969f, -0.02550619f, 0.04441998f, -0.02289685f, 0.05012396f, 0.12607378f, 
    -0.07974831f, 0.09954844f, -0.06255566f, -0.04833179f, 0.18027020f, -0.14228570f, 0.08639743f, 0.01292068f, 
    0.02200993f, -0.12226442f, -0.09503637f, -0.22487575f, 0.19986247f, 0.09567203f, 0.17055741f, 0.40666604f, 
    0.01411889f, 0.06169057f, 0.00483724f, 0.07915170f, 0.03854921f, 0.03093159f, 0.09021946f, -0.03739821f, 
    0.03197640f, 0.12210540f, 0.04586396f, 0.01237373f, 0.08870380f, -0.14794225f, 0.02129652f, 0.04643241f, 
    0.19895148f, 0.04484565f, -0.05305022f, -0.19840685f, 0.18156974f, -0.05293921f, 0.01528224f, -0.24796754f, 
    -0.07180314f, 0.01517391f, -0.11732166f, 0.02045820f, -0.03898003f, -0.16217764f, 0.02626395f, -0.07948654f, 
    0.07604011f, -0.09971179f, 0.06063695f, -0.06546313f, 0.06619793f, -0.19933556f, -0.15021628f, -0.01237955f, 
    0.02133356f, -0.06441250f, 0.07749041f, -0.03844237f, 0.04935700f, 0.03094289f, 0.00976751f, -0.02821809f, 
    0.08325189f, -0.20753035f, 0.14583932f, 0.08167245f, -0.09969716f, 0.10063443f, 0.11781812f, 0.04205151f, 
    0.02519352f, 0.03211820f, 0.06448870f, 0.10864983f, -0.04028347f, 0.08215033f, 0.00300476f, 0.00029915f, 
    -0.09449538f, 0.00161236f, -0.06966060f, 0.03227477f, -0.11256376f, -0.15168566f, 0.09061728f, -0.03708145f, 
    0.07210522f, 0.07255137f, 0.12655681f, 0.03792426f, -0.00085668f, -0.09041002f, 0.16953765f, 0.03087353f, 
    -0.05216320f, -0.09310654f, -0.00569473f, 0.07128216f, 0.01346541f, -0.00582779f, 0.05312314f, -0.13105668f, 
    -0.01291355f, 0.06261384f, 0.02437414f, -0.02818162f, 0.09843978f, -0.20778522f, -0.17983964f, 0.06784149f, 
    0.27179524f, -0.19942212f, 0.12508148f, 0.19320571f, 0.04687043f, 0.12670970f, -0.01112934f, -0.09461632f, 
    -0.04438733f, 0.03374770f, -0.15178394f, 0.04109707f, 0.02916859f, 0.05254032f, 0.10679833f, 0.10802829f, 
    0.14948003f, 0.09150895f, 0.07496613f, 0.04015829f, -0.06566801f, 0.03866819f, 0.27344933f, 0.08685491f, 
    0.01984166f, 0.02401876f, 0.16220169f, 0.08612514f, 0.10931837f, 0.00558966f, -0.03692554f, 0.07196694f, 
    -0.08058246f, 0.10543511f, -0.00117697f, 0.07343130f, -0.07253443f, 0.09748068f, 0.09204343f, -0.06811648f, 
    -0.01825471f, 0.26513344f, -0.16676645f, -0.13311563f, -0.16452157f, 0.00865271f, 0.12559389f, 0.04930891f, 
    0.15316331f, -0.00743181f, 0.05323052f, 0.09042379f, 0.05863801f, -0.04110147f, 0.01151549f, -0.06554716f, 
    0.09065484f, -0.12331606f, -0.01490190f, -0.08197191f, 0.15459551f, -0.00925132f, 0.17563313f, -0.31825954f, 
    -0.03787392f, -0.00503800f, 0.04181874f, 0.12887701f, 0.11159146f, 0.00346422f, 0.11992410f, -0.05869455f, 
    0.14262842f, 0.18669437f, -0.08398546f, 0.00382922f, 0.04716000f, -0.06624170f, -0.26508364f, 0.01406503f, 
    -0.18763652f, -0.13159737f, -0.13047320f, -0.32738692f, -0.13532723f, -0.04596695f, -0.07935224f, 0.05707140f, 
    -0.08437013f, -0.04979724f, 0.01367960f, 0.06612011f, -0.04883467f, 0.00351179f, -0.00719310f, -0.02175264f, 
    -0.07275137f, -0.33229455f, -0.09897502f, -0.07621176f, 0.19735841f, -0.02213692f, -0.02046406f, -0.05682216f, 
    0.17378227f, -0.06089178f, 0.03383399f, -0.15188052f, -0.04300211f, 0.01324956f, -0.02186730f, -0.02912907f, 
    0.05893939f, -0.13462698f, 0.00890964f, 0.05650960f, 0.08679487f, -0.18681072f, 0.08499966f, -0.03044158f, 
    0.06778989f, -0.06667114f, -0.12756377f, -0.36187309f, 0.13362873f, -0.17658153f, -0.00676300f, -0.13767608f, 
    -0.07710063f, -0.10193560f, -0.05817274f, 0.17897381f, -0.00236879f, 0.15526852f, 0.02300556f, 0.20287278f, 
    -0.00434660f, -0.09309775f, -0.25620049f, -0.01836022f, -0.13234226f, 0.31166196f, -0.17455406f, -0.03286364f, 
    -0.11850469f, 0.00611822f, -0.08015064f, -0.11401763f, 0.00802048f, 0.02458525f, -0.02469695f, 0.16909644f, 
    -0.03950478f, 0.11335560f, 0.00684352f, -0.07824631f, 0.09073387f, 0.02954438f, 0.08119970f, 0.02186987f, 
    -0.00677653f, 0.11110768f, -0.08486013f, 0.12572105f, 0.10987617f, -0.17898476f, -0.04334632f, -0.06806163f, 
    0.13908544f, 0.03313712f, 0.01354918f, -0.06071750f, 0.18068020f, 0.00493073f, -0.01079170f, 0.10449120f, 
    -0.07090789f, -0.25527114f, -0.05245616f, 0.07261661f, 0.06960706f, -0.04017374f, -0.02911293f, -0.08473414f, 
    -0.16384660f, 0.02349721f, -0.01989698f, 0.02650835f, 0.05872486f, -0.14355683f, -0.12443298f, 0.19092146f, 
    -0.23654610f, -0.00365623f, -0.12737559f, -0.04123100f, 0.04518430f, -0.02877025f, -0.15031582f, -0.16017045f, 
    -0.16092612f, 0.18744592f, 0.08660296f, 0.12722799f, -0.17829685f, -0.08947878f, -0.06135153f, -0.04615640f, 
    -0.13315187f, 0.11123803f, -0.07182489f, -0.10240669f, -0.05917683f, -0.00219814f, 0.02368475f, -0.02699696f, 
    0.06278995f, 0.01087913f, 0.00214249f, -0.04122183f, 0.39949399f, 0.14266597f, -0.30526069f, -0.03981204f, 
    -0.28800178f, -0.03196280f, 0.05826045f, -0.05995913f, -0.08256379f, -0.03460155f, -0.01873126f, 0.08962233f, 
    -0.07461660f, -0.03158931f, 0.04514571f, -0.08632351f, -0.08047089f, -0.20496829f, -0.03079710f, 0.12302354f, 
    0.07603215f, 0.15650460f, 0.34840843f, -0.00648067f, 0.05963581f, -0.06276301f, 0.09157672f, 0.03424622f, 
    0.04971236f, 0.01575998f, -0.03624386f, -0.02348865f, 0.04476334f, 0.14642118f, -0.04914466f, -0.03858604f, 
    0.04704949f, 0.14502683f, 0.06245894f, -0.04837445f, 0.61630780f, 0.13062970f, 0.36984143f, 0.05605733f, 
    -0.06314064f, 0.07800219f, -0.02724218f, 0.07753503f, 0.01028208f, 0.00225843f, -0.00174657f, 0.03195179f, 
    0.08635192f, 0.18920448f, 0.02340072f, 0.09982717f, 0.02781506f, -0.21713823f, -0.09122460f, -0.01860531f, 
    0.28543276f, 0.01976862f, -0.04178681f, -0.16029152f, 0.04222004f, 0.08332849f, -0.02489271f, -0.04432337f, 
    -0.03208838f, 0.01293636f, -0.04559672f, -0.14559640f, -0.22808053f, -0.14103988f, -0.09718584f, 0.25348389f, 
    0.07131450f, 0.18165630f, -0.04305037f, -0.03608316f, 0.04459086f, 0.19686185f, -0.01015849f, -0.12724918f, 
    -0.08455594f, 0.09651292f, 0.02978827f, 0.11586655f, 0.06244031f, -0.00605829f, 0.02004523f, -0.02221859f, 
    0.16647631f, 0.07845561f, 0.07265572f, 0.10120083f, 0.03711907f, 0.01876235f, -0.16730365f, 0.03530233f, 
    0.36036551f, 0.15504304f, -0.28296548f, 0.24859378f, -0.26249230f, -0.07625672f, 0.06699590f, 0.03539035f, 
    -0.09228049f, 0.08103255f, -0.03007208f, 0.11626534f, 0.15642336f, -0.15953252f, 0.04909913f, 0.05035909f, 
    0.00434730f, 0.00361925f, 0.11806660f, 0.10651705f, 0.48404849f, 0.07141400f, -0.22490259f, 0.28702953f, 
    -0.12530021f, 0.10262195f, 0.08191942f, 0.00528213f, 0.05048989f, -0.11694353f, -0.14779606f, 0.04320448f, 
    0.11866499f, -0.02244440f, 0.15797079f, 0.12017961f, 0.05076000f, 0.02887479f, -0.20183110f, -0.03493997f, 
    0.36805353f, -0.03754291f, -0.26513666f, 0.11526144f, -0.10286729f, 0.04013947f, -0.00864170f, -0.15216441f, 
    -0.06108776f, -0.03044289f, -0.08493922f, 0.05212592f, -0.13802893f, -0.07033023f, 0.02891253f, 0.07571256f, 
    0.11359526f, 0.04340309f, 0.18842891f, 0.01817681f, 0.79794925f, -0.03888048f, 0.00773661f, -0.18465747f, 
    -0.17235559f, -0.00514314f, -0.05417039f, -0.03612255f, 0.16272348f, -0.09962641f, -0.15327628f, -0.00648149f, 
    -0.13500628f, -0.03587255f, 0.04857576f, -0.05997336f, -0.03678889f, -0.03510178f, -0.08535856f, -0.05371439f, 
    0.16797964f, 0.10817985f, 0.29378095f, -0.12667240f, 0.02410593f, -0.01383005f, -0.00122128f, -0.00337231f, 
    0.11584445f, -0.05055112f, 0.00576106f, -0.02950372f, 0.02739547f, 0.00443129f, -0.03799930f, 0.01766790f, 
    -0.01988098f, -0.02305514f, -0.10224983f, -0.00266013f, 0.23986825f, 0.03993082f, -0.18680897f, 0.20166683f, 
    0.12446248f, -0.06918117f, 0.03674746f, -0.02574736f, 0.04828800f, 0.08870955f, 0.00658569f, 0.10952488f, 
    0.11544287f, -0.02116730f, -0.01177685f, 0.07633123f, -0.00588042f, -0.06011705f, 0.10628224f, 0.11909830f, 
    0.02470177f, -0.02066794f, 0.00593061f, 0.03398380f, -0.00989240f, -0.03996038f, 0.01493776f, -0.02152579f, 
    0.01062267f, 0.01066685f, 0.02175056f, -0.00549064f, 0.03264282f, -0.00862333f, 0.01175990f, 0.02367887f, 
    -0.02586646f, 0.00284313f, -0.01788526f, -0.03273415f, 0.02498979f, -0.01133336f, 0.01786899f, 0.01991478f, 
    -0.00714448f, 0.00791641f, -0.01555541f, -0.03704507f, -0.00804986f, 0.02293480f, -0.01618154f, -0.00194263f, 
    0.02153530f, -0.00667060f, -0.00059043f, -0.00885161f, -0.00977241f, 0.00554833f, -0.01446811f, 0.02676953f, 
    0.04054960f, 0.04508370f, -0.03292362f, 0.00130513f, -0.00662059f, -0.03500840f, 0.02228803f, 0.00676377f, 
    0.01320274f, 0.03007624f, -0.01059960f, -0.02895960f, 0.01381001f, -0.03354228f, 0.03073032f, -0.00272047f, 
    -0.04507360f, -0.00808242f, -0.01998631f, -0.00381385f, 0.02774059f, -0.03975253f, -0.04358315f, 0.02592976f, 
    -0.01128312f, 0.00799501f, -0.02902355f, 0.01277021f, -0.00486525f, -0.03678289f, -0.02826971f, 0.01666499f, 
    -0.02851992f, -0.01876442f, 0.00750972f, -0.04094939f, -0.02476406f, -0.00084239f, -0.00245808f, -0.00515679f, 
    -0.02610761f, -0.04194850f, -0.01425664f, 0.01939626f, 0.02459380f, 0.03014739f, 0.02732067f, -0.00012482f, 
    -0.03254424f, -0.02210165f, -0.04225543f, -0.02634639f, -0.02189580f, 0.02668027f, -0.00400705f, 0.01979061f, 
    -0.02762295f, -0.01175716f, -0.02929439f, 0.02680445f, -0.02303622f, 0.02132553f, 0.02400239f, -0.02834642f, 
    0.01482306f, -0.01689278f, -0.03963054f, -0.03034918f, 0.00693530f, -0.00507406f, 0.00275488f, -0.03949401f, 
    -0.02814195f, 0.02576495f, -0.03931729f, -0.01764292f, -0.02059622f, -0.00613551f, 0.01473534f, 0.03041165f, 
    -0.01686518f, 0.03333051f, 0.02714823f, -0.02466302f, 0.00624174f, 0.04014367f, 0.02042673f, -0.01139875f, 
    0.02551938f, -0.00415776f, -0.03187658f, -0.01204758f, -0.02132915f, -0.00243752f, 0.03186036f, -0.02738818f, 
    -0.02392190f, -0.00389325f, 0.03239728f, -0.01680033f, 0.04452445f, 0.03542309f, -0.00362102f, 0.00154304f, 
    -0.04389448f, -0.02389483f, -0.03620908f, -0.00307105f, 0.00349004f, -0.02006332f, -0.03552573f, -0.01679286f, 
    0.00006901f, 0.01717990f, -0.03769796f, -0.04381633f, 0.01159870f, 0.01130845f, 0.02524028f, -0.00715560f, 
    -0.02560342f, -0.03116466f, -0.01310089f, -0.01981866f, -0.03126333f, 0.02037483f, -0.01168003f, 0.02603166f, 
    0.00544589f, 0.01772635f, -0.03336035f, 0.00750224f, 0.01845562f, -0.02012851f, 0.03630446f, -0.02776683f, 
    -0.01865140f, 0.03437512f, 0.02438485f, 0.00245349f, -0.00881467f, -0.01148778f, 0.00581127f, 0.00396145f, 
    0.00845249f, -0.00754756f, -0.00693614f, 0.02602351f, -0.01977817f, 0.02907156f, -0.01016511f, -0.02558279f, 
    0.02077010f, -0.01128108f, 0.01041803f, -0.00062474f, 0.01030207f, 0.01427022f, 0.02462622f, -0.00814822f, 
    -0.03597215f, 0.03381160f, 0.02393696f, -0.00757245f, -0.02635967f, -0.03929312f, -0.02556593f, 0.03005633f, 
    0.01109527f, 0.00014005f, -0.01913653f, -0.00075779f, -0.01977655f, -0.02649192f, -0.01143778f, -0.02873407f, 
    0.01712667f, -0.03145785f, 0.01737969f, 0.00976418f, 0.03511333f, 0.01304147f, 0.01715042f, 0.02990556f, 
    -0.03160922f, -0.04528405f, -0.02770811f, -0.01553506f, -0.03059291f, -0.02836506f, -0.03442223f, 0.03269913f, 
    -0.02956312f, -0.00849868f, -0.01979152f, -0.02297253f, 0.01799651f, -0.02046159f, -0.03652779f, -0.01339353f, 
    0.03545150f, 0.04554022f, -0.00932965f, -0.03586688f, -0.00424801f, -0.04302068f, -0.01081080f, -0.02235981f, 
    -0.02954102f, -0.01304571f, -0.04510227f, 0.00970955f, 0.01984845f, 0.00316844f, -0.02630439f, 0.03590152f, 
    -0.02894970f, 0.01168281f, 0.00377133f, -0.02845761f, 0.01887356f, -0.03367533f, -0.02732910f, -0.03712344f, 
    -0.02364567f, -0.02572841f, 0.02327415f, 0.02574613f, -0.03679185f, -0.02210420f, -0.01847431f, -0.00530075f, 
    -0.01305402f, 0.00046082f, -0.00212754f, -0.02695174f, 0.00439974f, -0.02077987f, -0.00278291f, -0.02978394f, 
    0.00810141f, -0.00400509f, -0.02082316f, -0.00397899f, -0.03287316f, 0.00599631f, 0.00940725f, 0.01908812f, 
    -0.00391873f, -0.02592466f, 0.00957821f, -0.03304919f, 0.01594188f, -0.00621063f, -0.01388731f, 0.00773581f, 
    0.03548512f, -0.00756353f, -0.01963370f, -0.03697355f, 0.00829827f, 0.02422042f, -0.01339693f, 0.02155711f, 
    -0.02576625f, 0.03726251f, 0.02429399f, -0.03711676f, 0.03559458f, 0.01699503f, -0.03026539f, -0.01052495f, 
    0.01137132f, 0.03099848f, 0.03399962f, -0.01575067f, 0.01364895f, -0.01205324f, -0.01332954f, -0.00283783f, 
    -0.02041789f, 0.00117412f, 0.00694812f, -0.03495300f, -0.00792145f, 0.02549335f, 0.00517693f, -0.01266479f, 
    -0.02457366f, -0.02588851f, -0.03317459f, -0.01096046f, 0.00598548f, 0.02414935f, 0.00072863f, -0.02895247f, 
    0.01961315f, 0.02423985f, -0.00597121f, -0.02394430f, 0.00672812f, -0.02883284f, -0.00558851f, -0.02886797f, 
    0.01907214f, 0.01178319f, -0.01360348f, -0.00922816f, -0.02460631f, -0.01691776f, 0.01525457f, -0.03571545f, 
    -0.01784662f, -0.00524408f, 0.02047275f, 0.03599032f, 0.04542149f, 0.03349288f, -0.04082804f, 0.02533000f, 
    0.00294446f, 0.01858673f, -0.04084935f, -0.02446139f, -0.01587581f, -0.01497001f, -0.01715247f, -0.02017190f, 
    -0.00184214f, 0.00841787f, -0.01568883f, 0.03330751f, 0.01232603f, 0.01312522f, 0.01596069f, -0.01128973f, 
    -0.01704551f, -0.02625710f, 0.04664354f, -0.00604779f, -0.00088627f, 0.01224866f, -0.01074322f, -0.02069937f, 
    -0.02514274f, -0.04191975f, -0.02427219f, -0.00819626f, 0.01737272f, -0.01529780f, 0.02727345f, 0.01562218f, 
    -0.02016754f, 0.01193996f, -0.00759364f, -0.03942246f, 0.03301289f, 0.03023788f, -0.03730685f, 0.01616718f, 
    -0.02077501f, -0.01691789f, 0.02635174f, -0.02369997f, -0.00655742f, 0.02214546f, 0.00595416f, 0.02904228f, 
    -0.04071051f, 0.01670393f, -0.04197990f, -0.02251567f, -0.00421948f, 0.00435654f, -0.03014462f, -0.01289504f, 
    -0.02513695f, 0.00398480f, -0.04255946f, -0.00930001f, -0.00678768f, -0.00823706f, -0.02599947f, -0.00727298f, 
    0.00740345f, 0.00722894f, -0.02151646f, -0.04283966f, -0.00602844f, -0.00701372f, -0.03655864f, -0.00916582f, 
    0.03178702f, -0.02638819f, -0.01225373f, -0.03277611f, 0.03158068f, -0.01867963f, 0.03196174f, 0.02186935f, 
    -0.04432635f, 0.03283752f, 0.02433049f, 0.03093238f, 0.03090825f, -0.00017471f, -0.01645474f, -0.03981563f, 
    -0.03658968f, -0.00620791f, 0.01091020f, 0.03487615f, 0.02284107f, -0.01204219f, -0.00762566f, 0.01573960f, 
    -0.01364142f, -0.01919666f, -0.01170403f, -0.04140950f, 0.01839779f, -0.01049322f, 0.03443085f, 0.02440671f, 
    0.02832489f, 0.03121770f, -0.03127691f, -0.01225157f, 0.02594829f, 0.02600232f, 0.02811251f, -0.04392744f, 
    0.02458201f, 0.02964644f, -0.01790915f, -0.01559939f, -0.00397373f, -0.02564685f, -0.02202195f, 0.01189322f, 
    0.02683040f, -0.01682036f, -0.01885279f, -0.00070349f, 0.01795160f, -0.00908986f, 0.01996320f, 0.02382051f, 
    -0.02558226f, -0.00895057f, 0.00261821f, 0.01218036f, 0.02186763f, 0.00655222f, -0.01240144f, -0.03942303f, 
    0.00406975f, -0.00001544f, -0.00791841f, -0.00079860f, -0.03756950f, -0.01388197f, 0.01289231f, 0.01134247f, 
    0.00672616f, -0.03333995f, 0.01570105f, 0.00359536f, -0.02336100f, -0.03169017f, -0.00152973f, 0.03341864f, 
    0.02751806f, -0.00311560f, 0.03311702f, -0.01862951f, 0.02482351f, -0.02031924f, -0.01946143f, 0.01222474f, 
    -0.03629794f, -0.01909486f, 0.01819414f, -0.02226218f, -0.03865294f, 0.00415253f, 0.02842027f, 0.01408114f, 
    -0.04416542f, 0.02644067f, 0.00675007f, -0.01145625f, 0.02105719f, -0.04156224f, -0.04150505f, -0.01252224f, 
    0.02112373f, -0.00390730f, -0.01512158f, 0.03004463f, -0.03998157f, 0.02421452f, 0.03347500f, -0.01172910f, 
    -0.01457190f, -0.04003192f, -0.00106896f, 0.00741649f, 0.00457976f, 0.01589101f, 0.02477889f, -0.03172097f, 
    -0.02801911f, -0.00763456f, 0.01955232f, -0.01529020f, 0.01745710f, 0.02900885f, -0.01590413f, 0.01427400f, 
    0.00178565f, 0.01426301f, 0.00723737f, -0.00842560f, 0.01692501f, 0.00509367f, -0.03205981f, 0.01099395f, 
    -0.02469192f, -0.02684338f, -0.04332780f, 0.02939203f, 0.01151082f, 0.00857005f, 0.00894043f, 0.01914359f, 
    -0.01702094f, -0.00266534f, -0.02312304f, -0.01163853f, -0.03493166f, -0.00850873f, -0.00133772f, 0.04569982f, 
    -0.00177472f, 0.02251751f, 0.02677412f, 0.00872445f, -0.02360934f, -0.02962018f, -0.03259276f, -0.00518896f, 
    -0.01094408f, 0.02002748f, -0.00428512f, 0.02235850f, 0.02153824f, -0.00648857f, 0.02260964f, -0.01943865f, 
    0.01229824f, 0.02776349f, 0.02597317f, 0.02965451f, 0.00246583f, 0.03033166f, 0.03571575f, 0.00529840f, 
    -0.02709807f, -0.00500915f, -0.01120079f, -0.02176051f, -0.03526350f, -0.00190162f, -0.01223065f, 0.02713127f, 
    0.00233639f, -0.04452332f, -0.03775522f, 0.00549639f, -0.00160127f, -0.04321007f, 0.02753844f, -0.03975914f, 
    -0.03767227f, 0.02867476f, 0.03012080f, -0.03318376f, -0.01421886f, -0.02905325f, -0.04080112f, -0.02902913f, 
    0.01042170f, 0.03356834f, 0.02340487f, -0.01292273f, 0.02124183f, -0.00316587f, -0.03074283f, -0.02627435f, 
    -0.17121081f, -0.27434650f, -0.10567948f, -0.00865480f, -0.05960165f, 0.01198078f, -0.03393929f, 0.06763347f, 
    0.06118412f, 0.04893410f, -0.00709337f, -0.02600452f, 0.14106056f, 0.14642848f, -0.03054339f, -0.00668853f, 
    0.03587209f, -0.01490657f, -0.07791588f, -0.04686590f, 0.04354892f, -0.00468845f, -0.02473294f, 0.02506903f, 
    0.20072405f, -0.09311170f, 0.02505560f, -0.09771191f, 0.05347756f, -0.06875425f, -0.05889591f, 0.03913542f, 
    0.08841895f, 0.03615099f, 0.01310306f, 0.11951411f, -0.07769597f, 0.18626618f, 0.14451274f, 0.12937178f, 
    -0.10065430f, -0.12930562f, -0.04657512f, 0.07830457f, 0.34943837f, -0.03405654f, -0.05713988f, 0.14203300f, 
    0.02515118f, 0.03784116f, 0.02021229f, -0.00149791f, 0.20680217f, -0.00948434f, 0.00686431f, -0.03390624f, 
    -0.09624616f, 0.07205313f, 0.05185512f, -0.11478717f, 0.06814527f, 0.04751697f, -0.07082159f, 0.07889590f, 
    -0.21558404f, 0.12694770f, 0.17222026f, 0.06939472f, -0.08834859f, -0.00745287f, -0.00582383f, -0.04403574f, 
    -0.00111491f, -0.00424413f, -0.01052960f, -0.01180442f, 0.13734348f, 0.17879558f, -0.05732321f, 0.01702407f, 
    -0.24529237f, -0.31763595f, 0.11906640f, -0.03565155f, -0.22584000f, 0.07896216f, 0.02513422f, 0.17769349f, 
    0.16621609f, 0.15114506f, 0.05572399f, -0.03622845f, 0.09964713f, 0.03157861f, -0.08090886f, -0.00644111f, 
    0.07997587f, -0.01093991f, -0.02373369f, 0.05089261f, 0.32710245f, 0.16767167f, -0.15212519f, 0.09119094f, 
    -0.13103913f, -0.07379475f, -0.03596118f, 0.11127464f, 0.02095162f, 0.04366347f, -0.01850591f, 0.05076164f, 
    -0.01386038f, -0.07448117f, 0.01293623f, -0.04570255f, 0.04713266f, -0.09991574f, 0.08065504f, -0.09455139f, 
    -0.38926217f, -0.04542936f, 0.15160453f, 0.01034413f, -0.17597064f, 0.00936433f, 0.09670746f, 0.17697892f, 
    -0.02570307f, 0.03472988f, 0.02656012f, 0.02095451f, -0.05640908f, -0.15493098f, 0.02246489f, 0.05351590f, 
    0.03439881f, -0.05066391f, 0.05608762f, 0.11929341f, 0.10503075f, 0.16181359f, -0.03301039f, -0.02306276f, 
    0.22594346f, -0.07033257f, -0.06205101f, 0.00363407f, 0.00395578f, -0.04966234f, 0.02356930f, -0.00742205f, 
    0.07285958f, -0.10364050f, 0.00904737f, 0.00564439f, -0.14332707f, 0.09933985f, 0.06943975f, -0.02529990f, 
    0.16663000f, 0.29746088f, -0.09722625f, 0.05580303f, -0.00407039f, 0.06148554f, 0.04355161f, -0.04618451f, 
    -0.10471284f, 0.01070794f, 0.07452744f, -0.02229916f, 0.01191378f, -0.12266266f, -0.03359836f, -0.07916987f, 
    0.09810414f, 0.15516487f, -0.04334902f, 0.06632501f, -0.09059542f, -0.10413157f, -0.08185447f, -0.09323683f, 
    -0.14210589f, -0.08970765f, -0.04376048f, 0.07747665f, 0.10842521f, 0.10815385f, 0.06822519f, 0.11256193f, 
    -0.07111327f, 0.09770571f, 0.05670513f, 0.03210427f, 0.09092496f, -0.08831149f, -0.03092186f, -0.04542128f, 
    -0.01442594f, 0.22862868f, -0.05798113f, 0.15703671f, 0.17475694f, 0.10504372f, 0.04030545f, 0.00128034f, 
    0.00256380f, 0.02325464f, 0.06775668f, 0.01251654f, -0.06732653f, -0.02650196f, -0.04795068f, 0.20084873f, 
    0.05273606f, 0.09914772f, 0.13452558f, 0.05975953f, -0.09040924f, 0.17552395f, 0.08300019f, 0.05823363f, 
    0.24663667f, -0.01160229f, -0.02582890f, -0.09961991f, 0.10320373f, -0.16423050f, -0.05946339f, 0.00470778f, 
    0.06606255f, 0.10228487f, 0.01372026f, 0.06997017f, 0.07671686f, 0.10902043f, 0.11555697f, 0.00504779f, 
    0.01485988f, 0.08796130f, 0.13639863f, 0.03673318f, 0.10665789f, 0.00211451f, -0.03090225f, -0.04933453f, 
    -0.02924873f, 0.07900701f, -0.13446030f, 0.00217507f, 0.09545221f, 0.02353499f, 0.01560531f, -0.07307306f, 
    0.09430379f, -0.01927465f, 0.03360571f, -0.14811343f, -0.10914249f, 0.01650677f, -0.10060377f, 0.19251803f, 
    -0.13723475f, 0.18876985f, -0.03727360f, 0.08880648f, 0.03682199f, 0.15412116f, -0.10726471f, -0.05270111f, 
    0.02142655f, 0.07312892f, -0.05612095f, 0.03789998f, -0.09760186f, 0.04285582f, 0.01306696f, -0.02942007f, 
    -0.33731893f, -0.29444706f, -0.07762747f, -0.10035274f, -0.15788744f, 0.02868944f, -0.06874780f, 0.04352076f, 
    0.09708421f, 0.02116612f, 0.03860184f, -0.03325426f, 0.13579503f, -0.05227689f, -0.07660720f, 0.04113600f, 
    0.04061999f, -0.07187519f, -0.03760447f, 0.01928606f, -0.11850089f, -0.13276093f, -0.04024542f, 0.09119948f, 
    -0.05272268f, 0.01621790f, 0.13056293f, 0.11121309f, -0.03770050f, -0.00721183f, 0.03982753f, 0.05239915f, 
    0.00181192f, -0.05623011f, 0.01073364f, 0.03569417f, 0.02119794f, -0.02332671f, -0.02490468f, 0.05782347f, 
    -0.41647741f, -0.21881546f, 0.03183979f, -0.10539637f, -0.45318907f, 0.08715703f, 0.06760976f, 0.29450554f, 
    0.04556583f, 0.07359583f, 0.10702373f, -0.04293029f, 0.11715601f, -0.01707189f, 0.06467383f, 0.11897785f, 
    -0.02362865f, 0.06951554f, -0.12674586f, 0.08896766f, 0.05362128f, 0.03446233f, 0.05133579f, 0.00966231f, 
    0.21820574f, -0.00981804f, 0.03914034f, 0.03447064f, -0.03834818f, 0.01780390f, -0.02323169f, 0.03065229f, 
    0.04618697f, -0.01883151f, -0.10697425f, -0.05737402f, 0.07369253f, 0.07993777f, 0.15164526f, -0.10224500f, 
    0.28512818f, -0.06217444f, -0.11453339f, -0.09112671f, 0.14875020f, -0.02464499f, 0.08489957f, -0.01523570f, 
    0.12556472f, -0.10066935f, 0.02326024f, -0.01331194f, 0.07337687f, -0.01324561f, 0.01993152f, -0.01953042f, 
    0.06177231f, -0.12209476f, -0.04864097f, 0.00393875f, -0.05904797f, -0.14019367f, -0.08061892f, 0.00429463f, 
    -0.04198859f, 0.10698172f, 0.06328346f, -0.00977907f, 0.10641769f, -0.06347644f, 0.02309003f, -0.03554319f, 
    -0.04777250f, 0.05088639f, 0.01538237f, 0.02775845f, -0.06127391f, -0.04121619f, 0.03207272f, -0.04992406f, 
    0.18557999f, 0.10283030f, 0.05390693f, -0.08199299f, -0.00620886f, -0.01497890f, 0.07489984f, 0.06924967f, 
    -0.04053179f, -0.04794497f, 0.04947750f, 0.01425808f, -0.00663173f, -0.08731722f, -0.04743887f, 0.04002602f, 
    0.03742929f, 0.01202880f, 0.13996875f, -0.02365021f, -0.03910303f, 0.17659302f, -0.04455371f, -0.02067420f, 
    0.22780882f, -0.07850052f, 0.09503738f, 0.02736379f, 0.06286967f, 0.05117058f, -0.15219557f, 0.02559325f, 
    0.07797942f, -0.04986368f, 0.10074914f, -0.02812645f, -0.01757429f, -0.11178362f, 0.00831831f, -0.07086070f, 
    -0.24275176f, -0.00059672f, 0.20457776f, 0.06584725f, 0.32739770f, -0.08050387f, 0.02381610f, -0.01210853f, 
    0.08857071f, -0.03354620f, -0.04768093f, -0.03082390f, 0.11342159f, 0.11222868f, -0.01075221f, -0.02531355f, 
    -0.00036517f, 0.17934951f, 0.09794043f, 0.07396951f, 0.13186273f, 0.19376899f, -0.23019154f, -0.02571643f, 
    -0.28190339f, 0.05342319f, 0.02348139f, 0.09707890f, 0.12149535f, -0.02510757f, 0.01801066f, 0.07606056f, 
    0.01810027f, 0.11514445f, 0.03547525f, -0.03748149f, 0.10520726f, -0.01323668f, -0.09615934f, 0.05675327f, 
    -0.08234128f, -0.06550191f, -0.06441282f, 0.27558419f, -0.01053812f, -0.00912668f, 0.17440258f, -0.03834353f, 
    0.05670075f, 0.08378917f, 0.01048139f, 0.08467334f, -0.08369615f, -0.03621929f, 0.01012353f, -0.09398080f, 
    -0.08642717f, 0.03257555f, -0.07238412f, 0.03938822f, -0.50552928f, -0.12652649f, 0.02814137f, 0.12467089f, 
    0.28560013f, -0.00452691f, -0.14700478f, 0.04161111f, 0.03905098f, 0.13861360f, -0.10557531f, 0.07309839f, 
    -0.00269189f, 0.07459459f, 0.12651446f, 0.03701564f, -0.08083535f, -0.00770604f, 0.02637456f, -0.00139635f, 
    0.25892261f, 0.10915983f, -0.04304089f, 0.14253823f, 0.17450389f, 0.04521607f, -0.05340261f, 0.06766292f, 
    -0.07754965f, -0.03410529f, -0.01258121f, 0.08872227f, 0.08966818f, -0.15074211f, 0.02273449f, 0.08664296f, 
    0.11834910f, 0.01154690f, 0.22233585f, 0.01149811f, -0.15880173f, 0.22188541f, -0.14109656f, 0.12553400f, 
    0.10666989f, 0.11648181f, -0.05551379f, 0.03362343f, 0.03665252f, 0.09862956f, -0.03938101f, -0.03064395f, 
    -0.06904238f, 0.00227248f, -0.01071182f, 0.05506997f, 0.02478110f, 0.08429285f, -0.08679198f, 0.00751035f, 
    0.26900625f, 0.34436217f, 0.00995743f, 0.09656695f, 0.26902911f, 0.00896382f, -0.01969878f, -0.09189253f, 
    -0.10912219f, 0.17621462f, 0.14731155f, -0.04510164f, -0.00338530f, -0.03052612f, -0.02710825f, -0.07883867f, 
    -0.07791678f, 0.14515871f, 0.12756741f, -0.16597633f, -0.04490292f, 0.03271981f, 0.03170919f, 0.01860197f, 
    -0.22356485f, 0.07874001f, 0.01790038f, 0.19062991f, 0.01608532f, -0.00766027f, -0.05210418f, 0.09480885f, 
    -0.06097177f, 0.11178287f, -0.16364242f, -0.03358674f, 0.05759189f, 0.02126325f, 0.00981477f, 0.20101076f, 
    0.14148055f, -0.09866919f, -0.24471819f, -0.09348447f, 0.21491839f, -0.02027789f, -0.06505382f, -0.03190368f, 
    0.15121734f, -0.03316199f, 0.05169374f, -0.03290464f, 0.01879409f, 0.07975411f, -0.03332922f, -0.02185189f, 
    0.04032511f, -0.09398689f, -0.02767260f, -0.07725549f, 0.18638678f, 0.09343658f, 0.12554501f, 0.13716437f, 
    0.27098143f, 0.02892637f, 0.04882585f, 0.11465126f, -0.06171598f, 0.04214000f, -0.03031738f, -0.05908402f, 
    0.00176257f, 0.04162562f, 0.08068087f, -0.01480500f, 0.09969568f, 0.02450126f, 0.16378188f, -0.01452053f, 
    0.30489677f, 0.08303373f, -0.10947818f, -0.08915701f, 0.03523672f, -0.15062921f, 0.00274460f, 0.02514532f, 
    -0.04975785f, -0.04343726f, -0.00247577f, -0.06360420f, -0.00196242f, -0.04718313f, -0.04987249f, -0.00972389f, 
    0.05190196f, 0.10959875f, -0.00532411f, 0.06931484f, 0.05141969f, 0.25132418f, 0.12376690f, 0.10747071f, 
    -0.11458204f, -0.00213855f, -0.01262798f, 0.14620791f, 0.04142412f, 0.12748274f, -0.08469855f, 0.02185141f, 
    0.02588299f, -0.06472883f, -0.02505037f, 0.00828633f, 0.00757126f, -0.05825870f, 0.10945453f, -0.02873370f, 
    0.04900268f, 0.05478310f, 0.14726718f, 0.16772333f, 0.19367976f, -0.03578220f, -0.09257594f, 0.11207127f, 
    -0.02941905f, 0.04469116f, -0.01265152f, 0.02692027f, -0.06732902f, -0.00445460f, 0.05459221f, 0.09676049f, 
    0.03403021f, 0.07748243f, -0.00361480f, 0.03923992f, 0.00810372f, -0.03131999f, -0.06719586f, -0.11366254f, 
    -0.05798648f, -0.08180285f, -0.01988551f, 0.02987033f, -0.15998688f, -0.04869931f, 0.10345779f, -0.00916223f, 
    0.00129228f, -0.02233312f, 0.10148738f, -0.01456624f, -0.03409789f, -0.06136775f, 0.12118279f, 0.03328395f, 
    0.03216875f, 0.00835168f, -0.12800874f, -0.05936798f, -0.07966688f, -0.10170749f, 0.03570320f, 0.00004094f, 
    -0.02710757f, -0.01210371f, 0.07492626f, 0.04562693f, -0.00410807f, 0.04031935f, 0.10816628f, 0.01395151f, 
    -0.00142627f, 0.07449862f, 0.07054826f, -0.01219207f, 0.18326573f, 0.06526504f, 0.15235706f, -0.02398273f, 
    -0.00060742f, 0.06273574f, -0.02177332f, -0.05185461f, -0.05909331f, -0.01669996f, -0.07302672f, 0.00143459f, 
    -0.04162776f, -0.01561064f, 0.01433615f, -0.00069965f, 0.04059903f, -0.02732313f, -0.02040299f, 0.04107700f, 
    -0.52145368f, -0.45431697f, -0.15888950f, 0.06529023f, 0.18791388f, 0.03915256f, 0.10863890f, 0.04024565f, 
    -0.10169036f, -0.02998601f, -0.04091183f, 0.00554481f, 0.05589224f, -0.00338005f, 0.05853177f, 0.05502142f, 
    0.15392587f, 0.05596668f, 0.00554540f, -0.06175012f, -0.08791245f, 0.03622158f, 0.23622462f, 0.20102006f, 
    0.13853346f, 0.10590111f, 0.01984253f, 0.05764659f, 0.03365466f, 0.13954651f, 0.01682820f, 0.03549488f, 
    0.07489267f, 0.07263692f, 0.02646850f, -0.03783034f, 0.08677492f, -0.05391276f, -0.00839052f, 0.09274524f, 
    0.10860053f, 0.29937544f, 0.05816827f, -0.02093717f, -0.16006078f, -0.07818545f, 0.06423549f, -0.01783548f, 
    0.01536322f, -0.04195729f, 0.03447777f, 0.05939886f, 0.10936621f, -0.00306524f, 0.01707174f, 0.04212048f, 
    0.02166789f, -0.09302881f, -0.07616501f, 0.09318236f, 0.18250422f, 0.05296213f, 0.02417706f, -0.09402563f, 
    0.02402669f, 0.03182028f, -0.02107499f, -0.08585685f, -0.00900748f, -0.08443374f, -0.10078648f, 0.04323186f, 
    -0.01100167f, -0.11481959f, -0.01326095f, 0.08141464f, 0.12290338f, 0.07647610f, 0.05344818f, -0.00444756f, 
    0.01353070f, 0.13380083f, 0.18529867f, 0.15318617f, -0.00197478f, 0.05148371f, 0.04949422f, -0.04461392f, 
    -0.08852816f, 0.02428264f, 0.08618411f, 0.10873823f, 0.02061962f, -0.00235645f, -0.08082967f, -0.09226058f, 
    0.09037337f, 0.05614109f, -0.11511380f, 0.00583028f, -0.20030499f, 0.16048166f, 0.08057626f, 0.04230392f, 
    0.10390668f, -0.03121898f, -0.03413109f, 0.06504315f, 0.00742887f, 0.13079619f, 0.06938282f, -0.02387799f, 
    -0.02855186f, 0.10608266f, 0.00104071f, -0.07611726f, 0.07709173f, -0.10013070f, 0.11992449f, -0.05962546f, 
    0.14227013f, -0.07847790f, 0.18573318f, 0.11081104f, 0.11203397f, 0.00855703f, -0.03717390f, 0.08038003f, 
    -0.05950508f, 0.01956622f, 0.05793199f, 0.05757301f, -0.22270600f, 0.12916918f, -0.01120014f, 0.04917785f, 
    0.04574975f, -0.08004745f, 0.11633991f, 0.13853647f, -0.01327496f, 0.26965672f, -0.07020517f, -0.05293180f, 
    -0.11899637f, 0.02855644f, -0.03423362f, -0.00818385f, 0.03703646f, -0.02911799f, -0.00071811f, -0.02649099f, 
    -0.01019148f, -0.02649459f, 0.04917282f, 0.00546629f, 0.01944986f, -0.00244004f, 0.13272455f, 0.05362736f, 
    0.13172571f, 0.10241370f, -0.02331686f, -0.04771770f, -0.03087911f, 0.02557284f, 0.01096882f, -0.12215801f, 
    -0.07181621f, -0.02100729f, 0.00949534f, -0.08209482f, -0.01578886f, -0.08789120f, 0.00914870f, 0.07733259f, 
    0.09258888f, 0.08168176f, 0.07899534f, 0.07697672f, -0.26090214f, -0.31396282f, 0.02627449f, 0.08764223f, 
    0.12290642f, 0.04511770f, 0.02022299f, -0.00996830f, -0.07478803f, -0.01833749f, 0.01842615f, 0.08047997f, 
    0.02018703f, 0.05994325f, 0.03609246f, 0.02646460f, 0.05673013f, 0.08808917f, -0.08330893f, -0.08693314f, 
    0.03866969f, -0.37748519f, -0.09143754f, 0.06351081f, 0.09318240f, 0.01579925f, 0.09010199f, -0.08959805f, 
    -0.11364178f, -0.08606777f, -0.01258813f, 0.02537498f, -0.04267816f, 0.07080069f, -0.07639056f, -0.02305779f, 
    -0.00909163f, -0.03755428f, 0.06691398f, -0.05594238f, 0.12294172f, -0.07420039f, 0.26452011f, 0.06146723f, 
    0.10774133f, -0.00442650f, 0.00176634f, -0.06047039f, 0.03115622f, 0.06709243f, -0.02151173f, 0.15023398f, 
    -0.05216227f, 0.03172542f, -0.03949948f, 0.07262285f, 0.05546154f, -0.01170358f, 0.05803932f, 0.00543682f, 
    0.29419577f, -0.06806303f, 0.13044564f, -0.03794795f, 0.24006335f, 0.05666580f, -0.05075660f, -0.05554284f, 
    -0.03654657f, 0.06731503f, 0.01040644f, 0.01213703f, 0.02396911f, 0.01094698f, -0.08009829f, -0.15687467f, 
    0.04762948f, 0.05130118f, -0.13441426f, 0.04906647f, 0.00208653f, -0.22418724f, -0.11858889f, -0.10260764f, 
    0.10263712f, 0.14351048f, 0.02984593f, 0.05646201f, 0.05459901f, -0.01730948f, 0.01540116f, -0.05452493f, 
    -0.03269380f, -0.03779529f, -0.02671558f, 0.05754035f, 0.07555496f, 0.04971620f, 0.05380299f, 0.05345505f, 
    0.18738535f, 0.02940260f, -0.03617155f, -0.11814720f, -0.04853480f, 0.02621619f, 0.04646160f, -0.04757096f, 
    0.05506507f, 0.03359714f, -0.04267235f, 0.07738789f, -0.02928332f, 0.02084067f, 0.02359425f, 0.00829020f, 
    -0.03789301f, 0.02712147f, -0.04398372f, -0.02395744f, -0.16420445f, 0.04223683f, -0.03937664f, -0.10477559f, 
    0.08239622f, 0.03137296f, 0.00096953f, -0.04372928f, -0.04507760f, -0.12782250f, -0.05212821f, -0.01758733f, 
    0.01802087f, 0.08725455f, -0.03598164f, 0.04937588f, 0.08646058f, 0.12547921f, -0.01621261f, 0.04499560f, 
    -0.19755091f, 0.18498969f, 0.06449974f, 0.11333711f, 0.10827602f, -0.01503366f, -0.13499756f, 0.09260049f, 
    0.01706458f, 0.14212134f, 0.04113126f, 0.00963396f, -0.07162344f, 0.03532473f, 0.00421662f, -0.01950007f, 
    -0.04186425f, -0.10638831f, 0.17094009f, -0.10102620f, -0.03236146f, 0.39172044f, -0.22666527f, 0.04628535f, 
    0.01592438f, -0.00511556f, -0.03653494f, -0.07353327f, -0.00088941f, -0.00625060f, 0.09882365f, -0.06655963f, 
    -0.01170552f, -0.03314752f, -0.01800161f, -0.06655681f, 0.08933092f, 0.02624415f, 0.14851500f, -0.08691153f, 
    -0.31884712f, -0.20343131f, -0.14878221f, 0.11591758f, 0.05507465f, 0.13728234f, 0.07820442f, -0.06013628f, 
    -0.10376030f, -0.02984698f, -0.02767057f, 0.05318700f, -0.02017494f, -0.07231508f, 0.05418661f, -0.08115915f, 
    0.06541198f, -0.00545118f, -0.03609311f, -0.00618153f, 0.01844340f, 0.17625143f, 0.11582842f, 0.06138876f, 
    0.04619155f, -0.08559825f, -0.05846812f, 0.09644030f, 0.00016140f, 0.03994850f, 0.08587790f, -0.03369267f, 
    -0.05487404f, -0.15403324f, 0.09566563f, -0.06589458f, 0.02504678f, 0.07512955f, 0.12580755f, -0.01973048f, 
    0.09004733f, -0.02849515f, 0.25330049f, 0.04845227f, 0.04802784f, 0.13474207f, 0.12612091f, 0.03019347f, 
    0.03914533f, 0.04188878f, -0.04530532f, 0.03604841f, -0.09438784f, 0.01171384f, 0.03574626f, -0.06343664f, 
    0.10687894f, 0.11995066f, -0.08857709f, 0.01392585f, -0.20223463f, 0.30518523f, -0.08630333f, 0.01305624f, 
    -0.09879249f, -0.12618268f, 0.02657107f, -0.07895464f, 0.02284181f, -0.02418321f, 0.19065545f, 0.07237889f, 
    -0.07016722f, 0.03428847f, -0.07205185f, -0.10589305f, -0.08916218f, -0.05647524f, -0.05825041f, 0.04154158f, 
    0.17124920f, 0.22153053f, 0.14523509f, -0.10288059f, -0.01539881f, 0.00060310f, 0.03491160f, -0.07163682f, 
    -0.02829983f, -0.07702418f, 0.01608880f, 0.01322092f, 0.06704046f, 0.07580191f, -0.06152517f, 0.10815482f, 
    0.04922361f, -0.00471008f, -0.09344044f, 0.02634201f, -0.07134458f, 0.10991609f, -0.00361766f, -0.00564281f, 
    -0.19928074f, 0.08120301f, 0.06217195f, -0.17533042f, 0.01810354f, 0.14216305f, 0.05441665f, -0.00838423f, 
    0.08549090f, 0.02058632f, -0.11839136f, 0.07268963f, 0.01259934f, -0.08581206f, 0.04413288f, 0.18334423f, 
    0.21620227f, 0.12800097f, 0.04505154f, -0.02468706f, 0.18051213f, -0.01571475f, -0.16551384f, -0.06511302f, 
    0.02056069f, -0.05915819f, 0.05267171f, -0.07103599f, 0.04513350f, -0.12288924f, -0.06257053f, 0.03216242f, 
    -0.04113417f, 0.02857082f, 0.02717129f, 0.08589201f, -0.04097746f, 0.04924117f, 0.20108891f, 0.08144680f, 
    -0.05297049f, 0.06509798f, 0.02735947f, 0.02913949f, -0.07709935f, 0.05994801f, -0.07119692f, 0.06085602f, 
    0.10029788f, 0.02101984f, 0.04325336f, 0.00321530f, 0.03998127f, 0.06741222f, -0.09870227f, -0.08506095f, 
    -0.13758154f, -0.24606709f, -0.06118563f, -0.01452898f, -0.10198917f, -0.01998451f, -0.00472581f, 0.03337646f, 
    -0.05063841f, 0.05047759f, -0.04033158f, -0.06094582f, 0.06039667f, -0.05475064f, -0.02445088f, -0.08652659f, 
    0.05492228f, 0.00055536f, 0.00740129f, 0.02705555f, 0.15949114f, 0.02856980f, 0.16734609f, 0.08584283f, 
    -0.05667260f, -0.11721010f, -0.00340194f, -0.03773475f, -0.09054554f, -0.05064370f, 0.00625697f, -0.00724257f, 
    0.02050529f, 0.06339522f, -0.04614566f, 0.10482904f, -0.09163606f, 0.15313429f, 0.05738265f, 0.12509055f, 
    -0.15888755f, -0.04357785f, 0.13836566f, 0.12744440f, 0.05925346f, -0.06869902f, 0.01949810f, 0.10016429f, 
    -0.09959587f, 0.05940556f, -0.08702610f, 0.03096092f, 0.18986835f, 0.08438750f, -0.01798660f, -0.10852507f, 
    -0.12493627f, 0.02504559f, 0.04358177f, -0.06520572f, 0.11201700f, 0.31729683f, -0.15178770f, 0.00348930f, 
    -0.13506700f, 0.07318888f, 0.12472231f, -0.10141543f, 0.02499010f, -0.00896832f, 0.01930202f, 0.01259715f, 
    0.00220088f, -0.01870049f, 0.02623784f, -0.01865454f, 0.06440106f, 0.09362435f, -0.00061462f, 0.06257658f, 
    -0.19053136f, 0.02193155f, 0.08072661f, -0.01756944f, -0.21497735f, 0.10948479f, 0.07455481f, 0.14185892f, 
    0.07612676f, 0.12654150f, -0.00249204f, -0.01788136f, 0.09761237f, 0.00582727f, 0.04655602f, -0.03809559f, 
    0.00219527f, -0.08397645f, -0.04012484f, 0.09460532f, -0.00147881f, 0.26538283f, 0.23963983f, 0.15343694f, 
    0.13603601f, -0.03780570f, -0.05373051f, -0.00239366f, 0.00063448f, 0.00469739f, 0.00657165f, 0.00008643f, 
    -0.04972712f, 0.00847327f, -0.02092699f, 0.02304687f, 0.01948561f, -0.15449011f, 0.08488607f, -0.04864673f, 
    0.17174484f, -0.18334050f, -0.17022911f, -0.04715523f, 0.22587049f, -0.00296458f, -0.06260428f, 0.06011540f, 
    0.00173386f, 0.00646905f, 0.21271744f, 0.07405826f, -0.08396588f, -0.17736122f, 0.03345411f, 0.01879163f, 
    0.07824229f, 0.00098408f, 0.08313384f, -0.00514642f, 0.08497570f, 0.10214899f, 0.11622749f, -0.06596874f, 
    0.08960839f, -0.17208979f, -0.01503807f, -0.07479551f, -0.00932573f, -0.12885794f, -0.02591925f, 0.03131292f, 
    0.11321244f, -0.06492218f, 0.07991835f, -0.06964972f, -0.08494414f, 0.05387617f, -0.03072346f, -0.01180629f, 
    -0.07858182f, 0.30374897f, -0.05133233f, 0.03146091f, -0.00955507f, -0.00884769f, 0.00344977f, -0.04244805f, 
    -0.01453473f, -0.05605708f, 0.07553263f, 0.09288730f, -0.07364234f, -0.04785419f, -0.01497380f, -0.04822471f, 
    -0.03216128f, 0.11651380f, 0.04694457f, 0.10760049f, -0.12090213f, -0.02995894f, 0.04969148f, -0.04724269f, 
    0.00896737f, 0.03052491f, -0.09403859f, 0.04585978f, 0.01586211f, 0.04089711f, -0.04531812f, -0.02758897f, 
    -0.02220184f, -0.02890576f, 0.00172854f, 0.04283776f, 0.01244313f, -0.01033001f, -0.04755928f, -0.02622056f, 
    0.03190365f, 0.07378373f, -0.00974331f, 0.03881472f, 0.17820293f, 0.06846258f, 0.03158310f, -0.06119113f, 
    -0.09750505f, -0.01000819f, 0.11594428f, 0.03955726f, -0.19003609f, 0.01332764f, 0.00566012f, 0.12131350f, 
    0.18292467f, 0.12423483f, 0.12477489f, 0.10187028f, -0.27090722f, 0.07019465f, 0.31306249f, 0.10664352f, 
    0.06514449f, 0.01952032f, -0.09183680f, 0.00629630f, -0.03850317f, -0.06776889f, -0.04470827f, 0.05172632f, 
    -0.00507859f, 0.10433108f, 0.10313198f, 0.05405892f, -0.06967007f, 0.17404634f, 0.05943681f, -0.02852225f, 
    -0.22419485f, 0.04323218f, 0.15819669f, 0.11173627f, 0.10051683f, 0.06983801f, -0.03354423f, 0.02238339f, 
    -0.08267412f, 0.17326090f, -0.02132277f, 0.05489497f, 0.11850367f, 0.12585939f, 0.05453036f, 0.00767304f, 
    0.12555884f, -0.03270892f, 0.04809055f, -0.19678095f, 0.02569640f, -0.08245389f, -0.15617558f, 0.18010268f, 
    -0.05566421f, 0.10342091f, 0.02558602f, 0.05184861f, 0.04599520f, 0.04640172f, -0.09197642f, -0.06358342f, 
    0.06701266f, 0.03259912f, -0.02534392f, -0.06339903f, -0.04701882f, -0.01286174f, -0.03892117f, 0.01551720f, 
    -0.13982357f, -0.23218742f, -0.16433112f, -0.00001765f, -0.08011232f, -0.05906259f, -0.08926913f, 0.01860373f, 
    -0.00319968f, 0.04948760f, -0.05669217f, 0.02510954f, 0.02267795f, -0.05252147f, -0.05037676f, 0.01908128f, 
    -0.02440331f, -0.09227780f, -0.05002163f, -0.04038042f, 0.14755002f, -0.30660534f, -0.09305646f, -0.05051623f, 
    0.11835143f, 0.06048405f, 0.07207006f, -0.01645523f, -0.00476268f, -0.02531829f, 0.18299367f, 0.04314736f, 
    -0.01174870f, -0.11400129f, -0.00404360f, 0.01174205f, -0.03966893f, -0.00448652f, 0.06805551f, 0.07619241f, 
    0.08701354f, -0.00132709f, -0.21799374f, -0.05175230f, -0.15876675f, 0.02836244f, 0.01094479f, -0.00217911f, 
    0.11587565f, 0.05611804f, 0.03918996f, 0.01479451f, -0.02594430f, -0.06061446f, 0.00964271f, 0.04186472f, 
    0.02723565f, -0.06772380f, -0.01958691f, 0.02095040f, -0.16240864f, 0.20683090f, 0.22186220f, 0.10556161f, 
    0.04943035f, 0.04109425f, -0.09350234f, 0.04005652f, -0.06881440f, 0.02820167f, 0.01057917f, 0.06281620f, 
    0.03187039f, 0.05147309f, 0.03050440f, -0.00560105f, 0.12170041f, 0.02049968f, 0.07607654f, -0.09909543f, 
    0.15122283f, -0.16410853f, 0.13133588f, -0.04874851f, 0.25059301f, -0.12090016f, 0.07279868f, -0.04370007f, 
    0.10156562f, -0.11572682f, 0.00398714f, -0.02502477f, 0.10159326f, 0.01437125f, -0.08000416f, 0.01308805f, 
    0.00113601f, -0.06704553f, -0.08113403f, 0.02394632f, 0.34915906f, -0.05269493f, -0.23527619f, -0.02863758f, 
    0.08190406f, 0.06537374f, -0.15376669f, 0.01372624f, 0.07633824f, -0.13393393f, 0.10542261f, -0.01076443f, 
    -0.08819666f, 0.04808766f, 0.01105184f, -0.01540828f, -0.07841443f, -0.03904810f, 0.04253053f, 0.01283501f, 
    -0.03636833f, 0.27913713f, -0.04002653f, -0.16337270f, -0.08224872f, 0.06392217f, -0.00748992f, 0.05289798f, 
    -0.05809046f, 0.08926523f, -0.01278957f, 0.06640597f, 0.00376072f, -0.03834730f, 0.04393896f, -0.00259615f, 
    -0.05021394f, 0.00413268f, 0.10611388f, -0.08130273f, -0.02503463f, 0.18208945f, -0.13293205f, -0.20671250f, 
    0.19868876f, 0.05654500f, 0.06201863f, -0.02928405f, -0.00244713f, 0.01790356f, 0.00585147f, 0.11431838f, 
    0.05785028f, 0.04216551f, 0.04229769f, -0.04886858f, 0.05580756f, -0.05550791f, -0.06117813f, -0.11016542f, 
    -0.20985235f, 0.06524701f, 0.36463413f, 0.12246468f, -0.01243657f, -0.05295076f, -0.01546825f, 0.00544143f, 
    -0.01063691f, -0.02188719f, -0.11816553f, 0.01927333f, 0.05223387f, 0.10548254f, 0.00534562f, -0.02639024f, 
    -0.03571840f, 0.12200822f, 0.11682783f, -0.02343196f, 0.13652916f, 0.28880477f, -0.03006846f, 0.07400213f, 
    -0.04301237f, 0.03218869f, -0.02883461f, -0.00087912f, 0.03835737f, -0.02893780f, -0.03298020f, 0.05002592f, 
    0.07918543f, 0.12006045f, 0.09482358f, 0.07996755f, 0.15917212f, -0.10847178f, -0.04486193f, 0.07868329f, 
    0.26032457f, -0.15882657f, -0.26791647f, 0.00793988f, 0.05602410f, 0.06774824f, 0.07714456f, -0.12384677f, 
    0.04714527f, -0.06656574f, 0.03553531f, 0.07128579f, -0.02600609f, -0.03502249f, 0.00853452f, -0.11824069f, 
    0.01444798f, 0.14646694f, 0.02766494f, 0.03896240f, -0.25290427f, -0.13594368f, 0.13185082f, 0.09279365f, 
    0.00769295f, 0.00460058f, -0.00829884f, 0.00374977f, -0.01506369f, 0.09501515f, -0.01144434f, -0.02104545f, 
    -0.01412529f, 0.09307425f, 0.01648253f, 0.02198646f, -0.03384436f, 0.02786870f, -0.04131566f, 0.01794096f, 
    -0.00042027f, 0.25094029f, 0.16529612f, -0.00489149f, 0.11167235f, -0.06519236f, -0.05528893f, 0.01674165f, 
    -0.02292415f, -0.03070552f, 0.03006086f, 0.02718900f, -0.04030142f, -0.12986863f, 0.13201961f, 0.09409881f, 
    0.07054092f, 0.00496712f, 0.21772704f, 0.00586732f, -0.00312331f, 0.36828324f, -0.04292230f, 0.01760452f, 
    -0.15071136f, 0.06394140f, 0.08189961f, -0.01744192f, 0.06761304f, -0.09478556f, -0.07448503f, 0.06754383f, 
    -0.01946854f, 0.00529721f, -0.04787166f, -0.02397494f, 0.08102657f, 0.13643533f, -0.05614655f, 0.03954903f, 
    -0.16065402f, 0.03856080f, -0.04695006f, -0.02198743f, 0.27279571f, 0.02150923f, -0.04582092f, -0.03442935f, 
    -0.01409063f, 0.04010396f, 0.01178057f, 0.08607049f, -0.03097750f, 0.02262967f, 0.00560049f, -0.01095630f, 
    -0.14993054f, 0.05614924f, 0.07040741f, -0.01526301f, 0.17215733f, 0.14005138f, -0.00060306f, -0.10358052f, 
    -0.08260425f, 0.01767809f, -0.01442212f, -0.01784998f, 0.00858128f, -0.12295902f, -0.08829168f, 0.00100087f, 
    -0.02953755f, -0.01844700f, -0.08748622f, 0.06004455f, -0.00977784f, 0.00058871f, 0.08922875f, 0.09302686f, 
    0.10583430f, -0.01211372f, 0.09853214f, -0.09893707f, 0.18666634f, -0.01758559f, -0.02783785f, -0.04982673f, 
    0.08576713f, -0.08047438f, -0.00836895f, -0.03823127f, 0.07121687f, -0.03444529f, -0.07937834f, -0.04074398f, 
    -0.02361221f, 0.00331825f, -0.00204449f, -0.03049225f, -0.23948409f, -0.07994408f, 0.11352597f, 0.04724861f, 
    0.28534803f, 0.04003844f, -0.11801248f, 0.06514519f, -0.05355082f, 0.03657275f, 0.04627019f, -0.03171381f, 
    -0.06396560f, -0.04369557f, -0.01685555f, 0.00867834f, 0.10003211f, 0.05202176f, 0.15527196f, 0.01534001f, 
    -0.03937670f, -0.04709360f, -0.01917990f, -0.01376264f, -0.00790216f, 0.03596297f, -0.01540363f, -0.03948243f, 
    0.00563919f, 0.03067463f, 0.01501451f, 0.01029428f, 0.00707660f, -0.03053076f, 0.02575519f, 0.01325746f, 
    -0.04497123f, -0.00004905f, -0.00586930f, -0.04042566f, 0.01511914f, 0.03048293f, 0.01688023f, -0.01227787f, 
    -0.03857547f, 0.00765057f, -0.03469960f, 0.01168716f, -0.04016948f, -0.00013366f, 0.01997335f, -0.03166066f, 
    0.02072386f, 0.00524020f, -0.02007364f, -0.03188884f, -0.01793312f, 0.00638945f, -0.02987050f, 0.00875505f, 
    -0.03274781f, -0.03747009f, 0.01537413f, -0.03898216f, 0.01227317f, 0.01185319f, 0.03059116f, -0.00068833f, 
    -0.02752726f, 0.02376482f, 0.00108990f, -0.01370711f, -0.01947864f, 0.00077412f, 0.00101421f, 0.00657829f, 
    -0.00761179f, 0.02723320f, -0.04535227f, -0.05068964f, -0.02349811f, 0.01740195f, 0.02093214f, 0.02986681f, 
    0.00455585f, 0.01417762f, -0.02534290f, -0.01968305f, 0.01036382f, -0.00170071f, -0.02093831f, 0.01638920f, 
    0.02094741f, 0.00985049f, 0.00222701f, -0.03018979f, -0.00539676f, 0.00394219f, -0.04661576f, 0.02254593f, 
    0.01427186f, 0.00200660f, -0.01198355f, 0.00454847f, 0.03006700f, -0.03578168f, -0.02415595f, 0.00973138f, 
    -0.02650099f, 0.01377223f, -0.04165047f, -0.02131799f, -0.04394656f, -0.03536060f, -0.04903019f, 0.02947603f, 
    0.02365808f, -0.00747809f, -0.00631172f, -0.00364365f, -0.03022517f, 0.02181211f, -0.02352622f, -0.00749113f, 
    -0.03111399f, 0.01369885f, 0.03471488f, -0.02955306f, -0.04044944f, 0.00332422f, -0.01504366f, 0.02986664f, 
    0.01736712f, 0.00588332f, -0.01637780f, -0.04117053f, 0.02800163f, -0.00831034f, -0.00031614f, 0.02504848f, 
    0.04548626f, -0.02624645f, 0.02660496f, 0.02329372f, 0.01321304f, 0.01129072f, -0.00375156f, -0.00943129f, 
    -0.03551693f, 0.02866452f, -0.01953601f, 0.02101432f, -0.03361885f, 0.01996486f, 0.00843699f, -0.00991445f, 
    -0.02748895f, 0.01604027f, -0.01117328f, -0.04493837f, -0.04401472f, -0.04239678f, -0.02738771f, 0.00159456f, 
    0.03442258f, -0.03538902f, 0.01085552f, 0.00127657f, 0.01382711f, -0.00386058f, 0.02931860f, -0.00091040f, 
    -0.00372097f, 0.02216901f, 0.00800717f, -0.00302604f, -0.02296921f, -0.04278676f, 0.03511658f, 0.00673642f, 
    -0.00109728f, 0.03306087f, 0.02385469f, 0.02241848f, -0.00376933f, -0.02826676f, 0.01123469f, -0.02301254f, 
    0.01033501f, -0.01761356f, -0.00511643f, -0.01603229f, -0.00311231f, -0.00249817f, 0.01897112f, -0.01329731f, 
    -0.03732238f, 0.02604879f, 0.01962361f, 0.00311723f, 0.02467896f, -0.02404118f, 0.02339394f, -0.02480387f, 
    0.00172541f, -0.02761827f, -0.01627425f, 0.03114328f, -0.00484037f, 0.02142383f, -0.01230977f, 0.01319196f, 
    -0.04867861f, -0.02039921f, 0.00051294f, 0.02247881f, -0.02229914f, 0.02233826f, -0.02444592f, -0.02630347f, 
    0.00706924f, 0.02023312f, 0.02338384f, -0.04544825f, 0.02354393f, -0.00958229f, -0.00671014f, -0.03087853f, 
    0.03287672f, 0.00691261f, 0.02279755f, 0.00066258f, -0.03968653f, -0.01109663f, 0.00043732f, -0.00955371f, 
    -0.02963573f, 0.00056848f, 0.03984697f, 0.01707183f, -0.03180320f, -0.02945432f, -0.04253323f, 0.01973622f, 
    -0.00816854f, 0.01123161f, -0.01093181f, -0.00020253f, 0.01517630f, -0.01077984f, -0.00575335f, 0.01117586f, 
    0.02075966f, -0.01049290f, 0.03172444f, 0.02022018f, -0.02077581f, -0.03838878f, 0.00795432f, -0.02119370f, 
    -0.02455304f, 0.03574674f, 0.03332041f, -0.02527907f, -0.03136932f, -0.01834635f, 0.03297715f, 0.00546150f, 
    -0.01074633f, 0.01376467f, 0.02701538f, -0.00996284f, -0.01482254f, -0.03070612f, 0.00556460f, 0.00811144f, 
    -0.03053726f, -0.03619519f, 0.00188516f, 0.02856242f, 0.01895263f, -0.01486845f, 0.02416704f, 0.02758208f, 
    -0.00899302f, 0.02932532f, -0.04299219f, 0.01124104f, -0.01084406f, 0.01015918f, 0.02863773f, -0.03030440f, 
    -0.02915145f, 0.01499429f, 0.02780405f, -0.03459214f, 0.03016577f, -0.00542820f, 0.00034993f, -0.02731562f, 
    -0.02028555f, -0.03720918f, 0.01521502f, -0.00093764f, -0.00335048f, -0.00496810f, -0.03542718f, 0.01657324f, 
    0.01186620f, -0.03375713f, 0.01889134f, 0.00352764f, -0.03805644f, 0.02136633f, -0.02901527f, 0.00566419f, 
    0.00032927f, -0.02402352f, -0.00499591f, -0.00462143f, 0.02527440f, 0.01961319f, 0.02192979f, 0.00547674f, 
    0.01122833f, 0.02945863f, -0.04648608f, 0.00489380f, 0.02768919f, 0.01403995f, 0.00961333f, -0.01374839f, 
    0.00776483f, -0.03850764f, 0.00552840f, -0.01739607f, -0.03212005f, -0.00757988f, -0.02965935f, 0.00117004f, 
    -0.02673475f, 0.01532132f, 0.01662822f, -0.02447612f, -0.04791333f, -0.04161819f, 0.02569269f, -0.00917428f, 
    0.00005488f, -0.00771978f, -0.02015354f, -0.03604972f, -0.02322491f, 0.02987755f, -0.02036508f, 0.01097623f, 
    -0.02614889f, 0.01366413f, 0.01513827f, 0.02677844f, 0.02887800f, -0.00003678f, 0.01668764f, 0.02929313f, 
    0.00647525f, -0.03852929f, 0.01599842f, 0.01846296f, -0.00615057f, 0.01618732f, -0.00851976f, 0.01940570f, 
    -0.03077142f, -0.01115913f, -0.01674415f, -0.03191487f, -0.01607725f, -0.02389312f, -0.01170279f, 0.02031259f, 
    -0.00981024f, 0.03292155f, 0.01676015f, -0.02623153f, 0.01788947f, -0.03004439f, -0.02484388f, -0.00743977f, 
    0.01797669f, -0.01434614f, -0.01739546f, -0.01369768f, -0.04421590f, -0.01786319f, -0.01574895f, -0.00289792f, 
    0.01351924f, -0.02235843f, 0.00137822f, -0.03854550f, -0.02385858f, 0.01560075f, -0.01480349f, -0.00874921f, 
    0.02413593f, -0.02964317f, -0.04154504f, -0.04253877f, 0.01770127f, 0.03579649f, 0.01728824f, 0.01937179f, 
    -0.00681956f, -0.03723851f, -0.02164808f, -0.03493602f, 0.00205266f, -0.04545567f, -0.01947002f, 0.01278239f, 
    0.03598659f, 0.01292471f, 0.02950045f, -0.01926583f, -0.01148385f, -0.01686867f, -0.02266424f, -0.01194933f, 
    0.00271879f, -0.03510875f, 0.00872576f, -0.01133639f, -0.03690526f, -0.04159542f, -0.00412996f, 0.00805628f, 
    0.00796467f, -0.01980878f, -0.02813712f, -0.01066637f, 0.03074469f, -0.00358138f, -0.01785068f, -0.01876448f, 
    0.02339200f, 0.00018324f, -0.03928947f, -0.02222711f, -0.03332894f, 0.00388730f, 0.02602933f, 0.02586447f, 
    -0.01748150f, 0.00609599f, -0.00093046f, -0.03895258f, 0.01029258f, -0.01746594f, 0.01725322f, -0.02605195f, 
    0.01436062f, 0.02026863f, -0.02239735f, -0.01719534f, 0.03320156f, -0.03995854f, 0.00913084f, -0.03188989f, 
    0.03184043f, 0.00805260f, -0.01422912f, 0.01988533f, 0.00265160f, -0.02200400f, 0.01300681f, 0.00760976f, 
    -0.01921109f, -0.03613872f, -0.00059040f, -0.03343525f, 0.02036955f, 0.02675465f, 0.01798454f, -0.01344217f, 
    0.02296432f, -0.03801892f, 0.02134912f, -0.01278125f, -0.01703727f, -0.00628357f, -0.03703346f, 0.02652179f, 
    0.03698766f, -0.02160420f, -0.00195028f, 0.00543116f, -0.00195620f, -0.01343811f, -0.02745153f, 0.00522018f, 
    0.03234322f, 0.02198137f, -0.02545714f, 0.02781294f, 0.02049626f, -0.03647875f, -0.01417132f, 0.02728529f, 
    0.01933379f, 0.01635084f, 0.01922134f, 0.03067663f, 0.03214572f, 0.00426046f, 0.01306527f, 0.03816087f, 
    0.00850004f, -0.01250078f, -0.00545236f, -0.01731469f, -0.02889823f, -0.02490845f, 0.01578255f, 0.02775803f, 
    0.00946583f, -0.00567853f, 0.02475740f, -0.00983208f, -0.01670331f, 0.02136709f, -0.02238603f, -0.04598583f, 
    -0.00062006f, -0.00437966f, -0.03512114f, -0.00344831f, 0.02397283f, -0.03356374f, 0.01627566f, -0.00031883f, 
    -0.01398684f, -0.00752869f, -0.01023228f, -0.01780128f, 0.01098916f, -0.00223707f, 0.00559813f, 0.01540142f, 
    -0.04310316f, -0.02712530f, 0.01651290f, 0.02830194f, 0.02595600f, 0.02241253f, -0.02993249f, -0.03147683f, 
    -0.01439243f, -0.03408319f, 0.00261997f, -0.04287675f, -0.00465441f, 0.01153503f, -0.03656774f, -0.02408532f, 
    -0.02198314f, 0.00696609f, -0.03429219f, -0.04154996f, 0.01697787f, -0.01317886f, -0.00946942f, -0.03348244f, 
    -0.03462378f, -0.01624819f, -0.01673748f, 0.02865496f, -0.03150585f, 0.01133005f, -0.01692383f, 0.01725521f, 
    -0.04285559f, -0.01923055f, -0.00763720f, -0.01666960f, -0.03417766f, 0.00931923f, 0.03793873f, 0.00248611f, 
    0.01816935f, 0.02683108f, -0.01688412f, -0.01486709f, 0.00144081f, -0.02612369f, 0.03220659f, -0.01125977f, 
    0.03133141f, -0.00580626f, -0.01335613f, -0.04574383f, -0.02801736f, -0.04152769f, 0.00962035f, -0.03817678f, 
    0.02318981f, 0.01791209f, 0.02286519f, 0.02054494f, -0.00284436f, 0.01886414f, 0.03316797f, 0.01835402f, 
    -0.00892239f, 0.00829721f, -0.02870639f, 0.01397633f, -0.00148193f, -0.02064487f, -0.03210996f, -0.04733621f, 
    0.00122244f, -0.03312577f, -0.04199529f, 0.02669723f, -0.01921119f, 0.02238694f, 0.00888496f, -0.00699130f, 
    -0.01338882f, 0.02114831f, -0.00231124f, 0.00323149f, 0.01620767f, -0.00593247f, -0.03753503f, 0.00506145f, 
    -0.02009512f, 0.02158227f, -0.03565358f, 0.03102706f, 0.01440814f, 0.01544517f, -0.01160756f, -0.01502788f, 
    -0.03626601f, -0.01197388f, -0.03994655f, -0.02374286f, -0.03346827f, 0.03015591f, -0.00227924f, -0.00466435f, 
    -0.01902272f, 0.02691630f, 0.01815045f, -0.00019481f, -0.03545652f, -0.02372323f, -0.00651434f, 0.03275448f, 
    0.29624027f, 0.12741174f, -0.11245674f, -0.10742192f, 0.00823021f, -0.01498753f, 0.07714676f, 0.00403078f, 
    -0.00287826f, -0.03057933f, -0.02270130f, 0.07775249f, -0.03732762f, -0.00843118f, -0.06531990f, -0.06076936f, 
    -0.03933558f, 0.09397522f, -0.02229973f, -0.02127644f, 0.00306900f, 0.05659708f, 0.11622652f, 0.23856790f, 
    0.08606548f, 0.00293951f, 0.03610577f, 0.04778153f, -0.11798806f, 0.03817287f, -0.02267842f, 0.01473765f, 
    -0.01904627f, -0.07543156f, -0.10690573f, 0.02340188f, -0.00639831f, -0.14993942f, 0.08042973f, -0.08499262f, 
    0.21219681f, 0.02052993f, 0.33717623f, 0.08059646f, 0.09956744f, -0.12238102f, -0.10239656f, -0.08097330f, 
    0.07870790f, -0.15168919f, -0.04434779f, 0.05370433f, -0.16123380f, 0.04679548f, -0.03779122f, -0.03861612f, 
    0.01941812f, -0.01941508f, -0.02747658f, 0.02028042f, -0.46417934f, 0.10966823f, -0.08226266f, 0.15149382f, 
    0.20479506f, 0.17519954f, 0.14910097f, 0.06234945f, -0.05252603f, 0.01698147f, 0.07191952f, -0.05909497f, 
    -0.00038978f, 0.08919708f, -0.00204718f, 0.05150546f, 0.06705678f, 0.01350449f, 0.04855944f, 0.00897360f, 
    -0.20100410f, 0.15880159f, -0.08774795f, 0.13490938f, 0.02700440f, 0.10977202f, -0.01333068f, 0.08083472f, 
    -0.07498938f, 0.02595444f, 0.04004088f, -0.03452955f, -0.01710101f, -0.09563312f, 0.01888687f, -0.04539246f, 
    0.02638942f, 0.03243786f, 0.09126745f, -0.01872167f, 0.26352826f, -0.18012846f, -0.09123543f, 0.01838287f, 
    0.17196830f, 0.05676743f, 0.07957432f, -0.04327443f, 0.02112069f, 0.05738090f, 0.06761333f, 0.16203749f, 
    0.04207193f, -0.02994338f, 0.10104313f, -0.00278257f, 0.01628147f, 0.13074867f, -0.07354547f, 0.13147292f, 
    0.09867365f, -0.37821499f, -0.04924300f, -0.29731593f, -0.41475588f, 0.24199025f, 0.10674278f, -0.09609886f, 
    -0.05714340f, 0.00216851f, -0.10579395f, -0.02413738f, -0.01041831f, 0.17403348f, 0.06336363f, 0.09896509f, 
    -0.05991883f, 0.14935188f, -0.01587097f, 0.00346532f, 0.03248705f, 0.09100831f, 0.22787905f, 0.15378065f, 
    -0.00497183f, -0.09667356f, -0.01461379f, 0.13724266f, -0.10179954f, -0.12101026f, 0.03382197f, 0.03386269f, 
    -0.13746099f, 0.02823492f, -0.00715727f, 0.01412718f, -0.00625008f, 0.12677538f, 0.03446873f, 0.01107270f, 
    0.00309233f, 0.07417568f, -0.01808935f, -0.12960847f, 0.18420066f, 0.00321675f, -0.00932417f, -0.01516987f, 
    -0.00941706f, 0.05686265f, 0.06482168f, 0.02010343f, 0.04783620f, 0.12169668f, -0.01898741f, 0.06259890f, 
    0.06599062f, -0.06287427f, -0.00263149f, 0.01038649f, 0.20904444f, -0.18179347f, -0.00398733f, -0.10714941f, 
    -0.00736925f, -0.01948906f, 0.02825104f, -0.10465232f, 0.04628345f, 0.03299016f, 0.00223138f, 0.04998460f, 
    0.02220244f, -0.04664799f, 0.03786308f, -0.13524784f, -0.00194018f, 0.01571685f, -0.00611394f, 0.13790983f, 
    -0.14168084f, -0.04364578f, -0.08029751f, -0.15607947f, -0.06326624f, 0.02644519f, -0.09000637f, 0.05303971f, 
    0.11141685f, -0.05987789f, -0.01807959f, 0.02587388f, 0.08971265f, 0.07686234f, -0.06485725f, -0.03200389f, 
    0.12362832f, -0.19874318f, -0.12929380f, -0.11936156f, 0.30703184f, 0.09867526f, -0.07718834f, 0.02049164f, 
    0.20955840f, 0.00945853f, 0.02376244f, 0.10861976f, -0.11878780f, 0.05138310f, 0.01939839f, 0.02837476f, 
    -0.00652489f, -0.03374718f, -0.17161225f, -0.02396725f, 0.07194255f, -0.15723047f, -0.00617369f, -0.05435100f, 
    0.43632591f, 0.02523708f, 0.00892718f, 0.08212724f, 0.06956228f, -0.17203552f, -0.02704951f, 0.03994955f, 
    0.05338041f, -0.11264026f, -0.04984043f, 0.03420721f, -0.12296788f, -0.12019853f, -0.00348288f, -0.03634815f, 
    -0.00387220f, 0.05777509f, 0.05115514f, 0.05009540f, -0.09670539f, 0.09979634f, 0.27564350f, -0.26171154f, 
    -0.04581679f, 0.04570149f, 0.02319320f, -0.10978196f, 0.02616585f, 0.02977076f, 0.07219899f, 0.06462420f, 
    0.06235951f, -0.01862808f, 0.05775054f, 0.07041183f, -0.00271629f, 0.02070599f, 0.07178260f, -0.06094816f, 
    0.24730505f, 0.00573188f, -0.08636206f, -0.08595974f, -0.16924775f, 0.09617457f, 0.05064140f, 0.04366498f, 
    -0.00818182f, 0.00647657f, -0.00495201f, -0.00014164f, -0.07381782f, -0.03748505f, 0.01080159f, 0.01978301f, 
    0.03921574f, 0.13588867f, 0.01059282f, 0.02143927f, -0.19694088f, -0.00500116f, 0.12255315f, -0.24838670f, 
    -0.12077530f, 0.16767439f, 0.03708698f, -0.00041789f, -0.00005020f, -0.02270156f, -0.07527623f, 0.06307875f, 
    -0.01048054f, 0.16460408f, 0.03305884f, -0.05481873f, 0.04779756f, 0.08841493f, -0.00353579f, -0.00866510f, 
    -0.55855221f, -0.11165853f, -0.21866019f, 0.00428888f, -0.26871306f, 0.11701863f, 0.19575387f, -0.05665869f, 
    -0.16210540f, -0.12571251f, 0.02758290f, -0.05579281f, -0.04849085f, -0.06559823f, 0.03898980f, -0.07875896f, 
    -0.05842209f, 0.09139124f, 0.06973254f, -0.07181812f, 0.23015547f, -0.02339738f, 0.15880194f, -0.08260986f, 
    -0.06056809f, -0.10972866f, 0.07739881f, 0.04323584f, -0.00166734f, -0.07304316f, -0.00193275f, 0.07545141f, 
    -0.03028898f, -0.06181702f, -0.08230642f, -0.02355145f, 0.01159353f, -0.03319696f, -0.02833963f, 0.09267552f, 
    -0.22183417f, 0.07411150f, -0.11484021f, 0.05987893f, 0.10027967f, 0.11890202f, 0.00778446f, -0.07364735f, 
    -0.02874388f, 0.00585082f, 0.01167688f, -0.05313735f, 0.00417076f, 0.01565685f, 0.06081460f, 0.01558419f, 
    0.05733522f, 0.07302525f, -0.11449488f, -0.01841638f, 0.16627431f, -0.04806627f, -0.22573656f, -0.12113540f, 
    -0.04927272f, 0.16792180f, 0.12332638f, 0.00014474f, -0.00671038f, 0.09167343f, 0.00052816f, -0.01421421f, 
    0.13416204f, -0.01458943f, -0.03830953f, 0.11829416f, 0.08632887f, 0.04461869f, 0.08350568f, 0.11869789f, 
    0.00629392f, -0.02225887f, 0.16698432f, 0.05881106f, -0.01023684f, 0.06120028f, 0.08854963f, 0.00090971f, 
    -0.00717292f, -0.03551801f, -0.00832026f, 0.10355638f, 0.03493256f, 0.04541501f, -0.00803248f, -0.03626889f, 
    0.16593610f, 0.04197846f, 0.05376536f, 0.05755273f, -0.04130593f, 0.11438602f, -0.05531610f, -0.03134987f, 
    0.18009682f, 0.07738908f, -0.00115181f, -0.06441560f, -0.01148017f, -0.09243300f, -0.02211161f, -0.03718108f, 
    0.02483026f, 0.13166587f, -0.01772257f, 0.04699812f, 0.08454286f, 0.04933059f, 0.00219775f, 0.13157365f, 
    0.24311680f, 0.02431652f, -0.02937484f, 0.13092120f, 0.08769108f, -0.02052020f, -0.06969991f, 0.04172896f, 
    -0.09232068f, 0.05044563f, 0.06988672f, -0.03071403f, -0.01443458f, -0.07472101f, -0.07279623f, 0.05846429f, 
    -0.01462521f, -0.16635588f, 0.00696672f, -0.05021076f, -0.21696740f, -0.19384269f, -0.22540788f, -0.04625113f, 
    -0.01909950f, 0.05886383f, 0.05384653f, -0.21994776f, -0.03558820f, -0.08214246f, 0.01449506f, 0.01448165f, 
    0.03403751f, 0.00602743f, 0.08249932f, -0.08642263f, 0.00065634f, 0.02502415f, -0.03550195f, 0.00362367f, 
    -0.20476247f, -0.01428141f, -0.14446789f, -0.28469616f, -0.20476092f, 0.17359246f, -0.03448625f, -0.07301803f, 
    0.00170932f, 0.04851857f, 0.08602615f, -0.02377193f, 0.07211811f, 0.11105484f, -0.02002562f, 0.05858941f, 
    0.03354237f, -0.08701769f, -0.02293711f, -0.01493847f, 0.26403034f, 0.12718713f, 0.16441159f, 0.05018475f, 
    0.23071696f, -0.24084722f, -0.08879370f, -0.01814078f, 0.12535723f, -0.07056267f, -0.08246285f, 0.00556728f, 
    -0.05823446f, -0.04602011f, 0.08541854f, -0.10867506f, -0.03635648f, 0.05783844f, 0.05159054f, -0.06436078f, 
    0.07771634f, 0.13391690f, 0.10689681f, -0.10344192f, 0.11681539f, 0.06960744f, 0.05678849f, -0.05040698f, 
    -0.07095559f, -0.04955427f, 0.01176567f, 0.06726430f, 0.01514757f, 0.10440482f, -0.04254429f, -0.04345169f, 
    0.00844169f, -0.05058068f, -0.07159548f, 0.06782895f, -0.31861138f, 0.01740975f, -0.07492255f, 0.09418837f, 
    0.11858266f, 0.06012960f, -0.16533141f, 0.03206693f, 0.07818461f, 0.06449614f, 0.03529366f, -0.00040727f, 
    0.05131289f, 0.01562837f, 0.07573628f, 0.01198832f, 0.03626946f, -0.04571606f, 0.04481298f, 0.08616684f, 
    0.24835309f, 0.22404987f, -0.14493646f, -0.19029924f, 0.10504644f, 0.09715942f, -0.03781287f, 0.07354813f, 
    0.03988257f, 0.02880055f, -0.05826537f, 0.03003905f, 0.07069001f, 0.01066924f, 0.05245639f, 0.02362002f, 
    0.08878831f, 0.09114639f, -0.06446286f, 0.09243023f, -0.32372060f, -0.35993940f, 0.01705354f, 0.35009202f, 
    0.00984037f, -0.08140209f, 0.02255437f, -0.17047495f, 0.05844887f, 0.07994494f, -0.01068984f, 0.09377242f, 
    0.09671215f, -0.02423975f, 0.05485271f, 0.11127936f, 0.11956175f, 0.01869518f, -0.14718176f, 0.01209343f, 
    -0.01371776f, 0.07509319f, 0.02290158f, 0.11091667f, 0.17201254f, -0.06998369f, -0.05197865f, 0.00999950f, 
    0.02344587f, 0.07064078f, 0.07725726f, -0.00079958f, 0.11387483f, 0.01213051f, -0.00658806f, -0.01558666f, 
    -0.07367972f, 0.03081534f, -0.05490615f, 0.00773894f, 0.18063825f, 0.08425991f, 0.03486492f, -0.11431438f, 
    0.24186979f, -0.00059755f, 0.00554442f, -0.00447522f, 0.01415650f, -0.03975504f, 0.03732569f, 0.09248395f, 
    0.04367348f, 0.01731107f, -0.04577567f, -0.00174476f, 0.04134876f, 0.01537455f, -0.09648468f, 0.04334871f, 
    0.06281090f, -0.09543519f, -0.02895792f, -0.15835682f, -0.17384511f, 0.00161038f, 0.11438853f, 0.02966215f, 
    -0.14569050f, -0.01892089f, -0.05602853f, -0.01948506f, -0.05944658f, 0.06966639f, 0.03885251f, 0.17704532f, 
    0.04970613f, 0.04511801f, 0.00024277f, 0.02536897f, 0.14642285f, 0.08291902f, -0.09695701f, 0.01550857f, 
    0.15849952f, -0.09047357f, 0.13054572f, -0.02922391f, -0.06403558f, 0.02786940f, 0.06814674f, 0.05742625f, 
    -0.02192108f, -0.02390361f, -0.03787218f, 0.09712067f, 0.11610646f, 0.02892870f, -0.03738753f, 0.04876608f, 
    -0.10730786f, -0.01084047f, -0.07982151f, -0.28758845f, -0.08796836f, 0.09570551f, -0.01345383f, 0.13951340f, 
    -0.05872573f, -0.16625404f, -0.06594615f, 0.12353967f, 0.00075332f, 0.06582315f, -0.04826041f, 0.05002316f, 
    0.01383901f, -0.04477399f, -0.03731123f, 0.02579664f, -0.25866303f, -0.03993166f, 0.11053688f, 0.30782193f, 
    0.33955225f, -0.01105003f, 0.13641293f, -0.03004623f, 0.01360892f, 0.08940130f, 0.10745119f, -0.06321971f, 
    0.06142334f, 0.05344889f, -0.15538511f, 0.12790073f, 0.11403412f, -0.03161427f, -0.00692277f, 0.12638721f, 
    -0.30953908f, 0.07901711f, -0.10187135f, 0.00156752f, 0.00306558f, 0.02237387f, 0.13263121f, -0.04804617f, 
    -0.11555569f, 0.01533529f, -0.11261870f, 0.08005575f, -0.07062088f, -0.05086537f, 0.07754736f, 0.00787850f, 
    0.16382618f, 0.00509364f, 0.00713640f, 0.00507123f, -0.01202507f, -0.15673803f, 0.11546128f, 0.09924646f, 
    0.06172076f, 0.10490436f, -0.05637465f, -0.01953043f, 0.02833358f, 0.08862891f, 0.11257885f, 0.04650423f, 
    0.07381506f, 0.03597299f, 0.02808878f, -0.00070626f, 0.06053008f, 0.05025579f, 0.09080413f, -0.05864589f, 
    -0.24349156f, 0.01016475f, 0.20539284f, 0.06892425f, -0.17511249f, -0.04649230f, -0.01285007f, -0.08606663f, 
    -0.01648031f, 0.14222392f, -0.11665307f, 0.05038512f, -0.00050067f, -0.01523455f, 0.15105635f, -0.05248907f, 
    -0.05364250f, -0.02398550f, 0.03292486f, 0.01208822f, -0.14344700f, 0.00973025f, -0.22234501f, -0.23480247f, 
    -0.01636804f, 0.00579306f, 0.01531248f, 0.11453177f, 0.01801460f, -0.08958212f, 0.00824302f, 0.10333980f, 
    -0.08299997f, -0.05950582f, 0.06371669f, 0.02689572f, -0.15524490f, 0.07716212f, -0.03784688f, 0.02249448f, 
    0.09024724f, 0.07829612f, 0.02150344f, 0.05361441f, 0.24367042f, 0.01112615f, -0.01182622f, -0.02988780f, 
    -0.00077327f, 0.04579860f, 0.06073188f, -0.10956953f, 0.03139105f, 0.05674258f, 0.02403385f, -0.04893173f, 
    0.07300600f, -0.05280810f, -0.01488658f, 0.06197038f, -0.25850511f, -0.23913005f, 0.10533129f, 0.04965482f, 
    -0.06229808f, 0.04725714f, 0.01889931f, -0.00987525f, -0.00416859f, 0.02579621f, 0.07823782f, -0.12666319f, 
    -0.05970063f, 0.07608391f, 0.02259472f, -0.00990538f, 0.12622561f, 0.00917011f, 0.03985666f, 0.00358060f, 
    0.20679647f, 0.18443802f, 0.11153316f, 0.14488423f, 0.17403513f, 0.07723702f, -0.11581165f, 0.03000727f, 
    0.10861054f, 0.16314901f, -0.02968696f, 0.02641189f, 0.00191019f, 0.02763784f, 0.12837648f, 0.09131856f, 
    0.00098311f, 0.01948254f, 0.01412371f, -0.06777375f, -0.16644256f, 0.28025097f, -0.10462891f, 0.14308117f, 
    0.09344714f, 0.08160978f, 0.13639054f, 0.06221649f, 0.08907810f, -0.06902039f, -0.09615828f, -0.01801920f, 
    0.06568892f, -0.10383739f, 0.05091118f, 0.00651042f, -0.01406498f, 0.01233226f, 0.04986109f, 0.01749404f, 
    -0.09638536f, -0.13271581f, -0.02589323f, -0.22510499f, -0.12598740f, 0.05324154f, 0.07986125f, -0.03271827f, 
    0.05784263f, -0.16067971f, -0.02122758f, 0.02730081f, -0.06732710f, 0.01503726f, 0.15307450f, -0.00613908f, 
    0.01058167f, 0.06358119f, -0.02065384f, -0.02733517f, 0.06393266f, 0.16886541f, -0.02085855f, -0.05362409f, 
    -0.12880461f, -0.12082814f, 0.16966832f, -0.02904549f, 0.04619817f, 0.09078678f, 0.01781695f, -0.01232602f, 
    0.05829953f, 0.06117042f, 0.01142045f, 0.06940444f, 0.00027582f, 0.01551978f, 0.01756938f, 0.06204854f, 
    -0.26401755f, -0.19959116f, -0.08894369f, 0.08212489f, -0.23449294f, -0.02848319f, -0.01606933f, -0.02877096f, 
    0.03013253f, -0.05085573f, 0.08421704f, 0.03261522f, 0.00367535f, -0.04824162f, 0.05292481f, -0.00098422f, 
    0.01145444f, 0.02956233f, 0.07938645f, 0.07222049f, -0.02653845f, 0.11143054f, -0.00887324f, 0.12208440f, 
    0.03341688f, 0.04698935f, -0.02967903f, -0.01499085f, 0.09751293f, 0.02826520f, -0.06419490f, 0.03372955f, 
    -0.01047338f, -0.00048237f, 0.08241155f, -0.00598187f, -0.03955965f, 0.05236211f, 0.11164636f, 0.03559857f, 
    -0.53243881f, -0.14059077f, -0.14833514f, 0.12144405f, -0.23403622f, -0.10574631f, 0.06231368f, -0.08372663f, 
    -0.04425909f, -0.04503692f, -0.02303563f, -0.06069599f, 0.04396642f, 0.07437775f, 0.14263928f, 0.02207698f, 
    0.00899028f, 0.07094927f, 0.03148192f, 0.12717025f, -0.39986742f, -0.07598674f, -0.13181892f, -0.25995591f, 
    -0.13848861f, 0.09911824f, -0.12456033f, 0.08261380f, -0.02543915f, -0.16220385f, -0.05153444f, 0.08735923f, 
    -0.01111957f, 0.04683961f, 0.00357034f, -0.09300745f, 0.08720961f, 0.01186153f, -0.01670448f, 0.03206280f, 
    -0.02034045f, -0.12529047f, 0.12033583f, 0.10368881f, 0.05079104f, 0.09871756f, 0.07195832f, 0.03832522f, 
    0.03392167f, 0.06473821f, -0.02638436f, -0.01504716f, -0.03235686f, 0.00435636f, -0.00629809f, -0.00480009f, 
    0.16109739f, 0.02793326f, 0.02236067f, -0.00423704f, -0.04495911f, -0.20524175f, -0.04783110f, 0.29812932f, 
    -0.01745004f, 0.19804978f, 0.03253534f, 0.12280711f, 0.10482629f, 0.02824709f, -0.02761110f, 0.00263244f, 
    -0.01020924f, 0.01729961f, -0.01632143f, 0.05726499f, 0.08282932f, 0.02748029f, -0.03239593f, -0.06121678f, 
    -0.46350890f, 0.06228482f, 0.13001221f, 0.08211587f, 0.13059327f, 0.00862910f, -0.11951143f, -0.05040981f, 
    0.03491605f, -0.04033998f, -0.00367703f, -0.02983805f, 0.04082772f, 0.02295858f, -0.00818381f, 0.02883137f, 
    0.15391505f, 0.01106913f, -0.06762602f, 0.03288176f, 0.08308592f, -0.04062564f, 0.14136243f, 0.30289182f, 
    0.05753792f, -0.06812350f, 0.09693727f, -0.01341636f, 0.09323224f, -0.03098126f, 0.06614073f, 0.04618580f, 
    -0.00149659f, 0.06145149f, 0.03531078f, -0.08193962f, 0.08502918f, -0.03260820f, -0.01629912f, 0.03798727f, 
    -0.10999587f, 0.24581949f, -0.07659498f, 0.01620533f, 0.04928700f, -0.02710954f, 0.08777963f, 0.11580357f, 
    0.02083341f, -0.11802545f, 0.01013173f, 0.06209926f, 0.02937691f, 0.00786962f, 0.04101308f, 0.02497745f, 
    0.08639936f, 0.00069460f, -0.02665230f, 0.06135884f, -0.05801851f, 0.00991060f, 0.23195240f, 0.13981535f, 
    -0.33134311f, 0.10061790f, -0.00187967f, 0.02469170f, 0.10662483f, -0.15055266f, 0.08007570f, -0.06649316f, 
    -0.00233257f, -0.02422538f, -0.03398757f, -0.06743523f, 0.06815015f, 0.09654739f, 0.04112301f, 0.10165693f, 
    0.13228525f, -0.01584792f, -0.21809262f, 0.25171497f, -0.12179892f, 0.01620831f, -0.03445869f, 0.03825953f, 
    0.10568094f, 0.08198397f, 0.03817435f, -0.01128977f, -0.08554395f, 0.02135007f, 0.07676010f, 0.02779201f, 
    0.07141322f, 0.14555329f, 0.11564468f, -0.03000605f, -0.01388512f, 0.03192753f, -0.13765834f, -0.23935390f, 
    -0.08529111f, -0.00039457f, -0.01689651f, 0.06926522f, 0.05540983f, -0.10201770f, -0.09149454f, 0.06961310f, 
    -0.00707386f, 0.01307581f, -0.01370409f, 0.02358076f, -0.05052167f, 0.09536494f, -0.07904346f, 0.03048227f, 
    -0.22695483f, 0.11478811f, -0.00196156f, -0.28302273f, 0.06900904f, 0.14028051f, -0.09264882f, 0.01080897f, 
    -0.07205915f, -0.07741156f, 0.06472436f, 0.09281913f, -0.04436805f, -0.03922289f, 0.10705879f, -0.02085597f, 
    0.05283391f, -0.06611449f, -0.05951979f, 0.16277477f, 0.00923996f, -0.23113838f, -0.00347219f, 0.04887040f, 
    0.22447945f, -0.01396263f, 0.15539873f, 0.07093070f, 0.04976958f, -0.06164552f, -0.05914690f, 0.06831121f, 
    -0.00287339f, 0.01562216f, 0.07678970f, 0.03447060f, -0.08019475f, 0.02253094f, -0.05100470f, 0.05665433f, 
    0.24158596f, 0.31942964f, 0.03862568f, 0.15730931f, 0.20441826f, 0.06676596f, -0.13068323f, 0.09068951f, 
    -0.09576339f, 0.10156568f, 0.16069192f, -0.02885511f, -0.00175377f, 0.11296103f, 0.08014373f, 0.09474977f, 
    -0.00616525f, 0.09756993f, -0.02076005f, 0.00894677f, -0.15676941f, 0.04066212f, 0.26934138f, 0.36537668f, 
    -0.07339860f, -0.12949686f, -0.08179097f, 0.05701782f, 0.05703456f, 0.06751005f, 0.04348487f, 0.10496248f, 
    -0.02876564f, 0.04464171f, 0.06235314f, -0.06367243f, 0.01568244f, -0.02956240f, 0.07365908f, 0.09346733f, 
    0.02966985f, -0.25942174f, 0.05197167f, 0.01986729f, -0.11061956f, 0.05084446f, 0.06580033f, 0.05105459f, 
    0.01109485f, -0.05301661f, 0.02500884f, -0.03950099f, 0.08579843f, 0.02562615f, 0.00147850f, -0.04163583f, 
    0.08249102f, 0.08874173f, -0.05327570f, -0.09599322f, 0.14549348f, 0.27007261f, 0.26267362f, 0.04894457f, 
    0.34674084f, -0.06873574f, 0.01520803f, 0.06967776f, 0.10037618f, 0.14603560f, -0.01383228f, -0.01985751f, 
    -0.00100003f, -0.09449401f, 0.10690891f, -0.01875369f, 0.06461697f, 0.03048170f, -0.01701862f, 0.14926346f, 
    -0.16536149f, 0.05216777f, 0.17772672f, -0.11044573f, -0.03104408f, -0.05513508f, 0.01198308f, 0.08996688f, 
    0.01686549f, 0.04471619f, -0.03152501f, 0.05281672f, 0.00532208f, -0.04744798f, 0.04408323f, -0.01770430f, 
    -0.06090776f, -0.01468175f, -0.00338637f, -0.00636201f, 0.18188711f, -0.02544743f, -0.26140463f, -0.18714802f, 
    -0.03455822f, -0.04574092f, -0.12258206f, 0.10065943f, 0.02899775f, 0.04534413f, 0.08416792f, -0.02021456f, 
    0.00551413f, -0.01899000f, -0.01262920f, -0.11016300f, 0.05511168f, -0.03018990f, -0.07539484f, -0.08173707f, 
    0.06987250f, 0.07391800f, 0.06157715f, -0.18383265f, -0.05454509f, 0.03826183f, -0.12129301f, 0.07880517f, 
    -0.16490039f, -0.08270316f, -0.00205503f, -0.06490882f, -0.00805728f, -0.04798090f, -0.03467344f, 0.20279767f, 
    0.01651459f, 0.03056637f, -0.02288974f, 0.04963510f, 0.27188888f, 0.07549759f, -0.00730873f, -0.05719941f, 
    0.20760861f, -0.00927715f, -0.15068948f, 0.08176247f, 0.01217701f, 0.10227562f, 0.03468013f, 0.03466483f, 
    -0.03054994f, -0.06013888f, 0.03038266f, -0.06129955f, -0.10258345f, -0.06960336f, 0.02042419f, 0.08484919f, 
    -0.00554832f, -0.02277833f, -0.05354788f, -0.03508749f, 0.10250100f, 0.01293415f, 0.03240507f, 0.04169871f, 
    0.05348513f, 0.00695362f, 0.00037542f, 0.08592876f, -0.19610585f, -0.02141395f, 0.01061268f, -0.05863186f, 
    0.07936303f, -0.07058237f, 0.19233881f, 0.04845986f, -0.23828848f, 0.28373221f, -0.20560664f, 0.05327058f, 
    -0.13538767f, -0.00748552f, 0.05355441f, 0.00965073f, 0.02191722f, -0.01555688f, 0.02343410f, 0.05462976f, 
    0.06087710f, 0.01316030f, -0.02867697f, -0.04723225f, -0.00070175f, 0.07085301f, 0.13742967f, 0.02049416f, 
    0.24255152f, 0.40647721f, -0.43327603f, 0.12782280f, 0.41369495f, 0.01077495f, 0.11991227f, 0.08895364f, 
    0.09642769f, -0.09146373f, 0.03648325f, 0.00180076f, -0.04420334f, 0.05389088f, 0.14226769f, -0.10577311f, 
    0.07531549f, -0.05342666f, 0.06324200f, 0.02936837f, 0.01553805f, -0.05447786f, 0.04591585f, -0.18860339f, 
    -0.04217761f, 0.01792123f, -0.07681495f, -0.06318823f, -0.12433670f, -0.07230373f, 0.00377220f, -0.01707503f, 
    -0.01648651f, 0.01098575f, 0.00511488f, 0.07022888f, 0.06746318f, 0.04400134f, -0.00347978f, -0.06112078f, 
    0.15756007f, 0.07957360f, 0.13635226f, -0.13233826f, 0.00365214f, 0.05421013f, -0.10480516f, 0.00450075f, 
    -0.01622957f, 0.09964614f, 0.08250259f, -0.00825965f, 0.05588479f, 0.00966944f, -0.05462950f, 0.13718189f, 
    0.04292852f, -0.00871285f, -0.01174765f, 0.01475153f, -0.20131417f, 0.11380742f, 0.00065676f, -0.10060916f, 
    -0.09781930f, -0.08621347f, 0.13543156f, 0.01025777f, 0.03394829f, 0.03012066f, 0.06301284f, -0.10527246f, 
    0.02824153f, -0.05252165f, 0.03747667f, -0.06826936f, -0.04115862f, 0.08227350f, 0.16045047f, 0.10466270f, 
    -0.01822593f, 0.08338510f, 0.06467365f, -0.09965631f, 0.38571954f, 0.13626534f, -0.05336147f, -0.00879172f, 
    0.00853397f, 0.06274027f, 0.04510381f, -0.01505288f, 0.00411962f, 0.06525886f, -0.03987300f, -0.01390829f, 
    -0.10465798f, 0.04887659f, 0.01341685f, -0.07506131f, -0.00680450f, 0.09577076f, -0.05607005f, 0.05554973f, 
    -0.01516282f, 0.01584320f, -0.03248086f, 0.07405338f, 0.07766957f, -0.07506087f, 0.11926275f, -0.03169372f, 
    0.02123682f, -0.08557042f, 0.07285690f, 0.06254629f, -0.06623212f, 0.05539356f, 0.03387891f, 0.03670172f, 
    0.13584273f, 0.23468868f, -0.01756672f, -0.01152696f, -0.09904078f, -0.02893423f, -0.09397007f, 0.05222531f, 
    0.02244896f, -0.04807089f, 0.05113104f, 0.03488468f, -0.00824592f, 0.05723100f, -0.03939424f, 0.09855260f, 
    -0.11888113f, 0.00775165f, 0.01497991f, -0.07335033f, 0.33421043f, 0.15858056f, -0.00484876f, -0.00481756f, 
    0.00512314f, -0.04268902f, -0.04471553f, 0.10017657f, 0.02599774f, 0.09124315f, 0.06659759f, -0.09887496f, 
    0.02892705f, 0.07283515f, -0.12397765f, 0.08059469f, -0.00240150f, -0.03240186f, 0.05305116f, 0.04661127f, 
    0.12873217f, 0.04553153f, 0.11911500f, -0.15385613f, -0.05979445f, -0.10227114f, -0.04145646f, 0.11929237f, 
    -0.06476483f, 0.09649674f, -0.01950374f, 0.00699310f, 0.10334769f, 0.08366787f, 0.02219648f, 0.00884318f, 
    -0.13115136f, 0.00351968f, -0.00260249f, 0.01418588f, -0.04177715f, 0.26914653f, -0.35985172f, 0.08313640f, 
    0.41038972f, 0.02895930f, 0.08852688f, -0.04952238f, 0.10190117f, -0.01339099f, -0.00611930f, -0.11959933f, 
    -0.08717703f, 0.13093519f, 0.02533040f, 0.04193050f, -0.02234701f, 0.05271615f, 0.06261117f, 0.04721912f, 
    0.29754862f, -0.28708783f, -0.16260907f, -0.19958979f, 0.18313508f, 0.04585280f, -0.02648024f, 0.00179576f, 
    -0.04561258f, 0.00890426f, -0.09083605f, 0.03565962f, 0.08833738f, 0.09539774f, 0.07469592f, -0.04475844f, 
    0.03336672f, 0.02968840f, 0.06006040f, 0.06953167f, 0.22579633f, 0.04536593f, -0.01475991f, -0.09950632f, 
    -0.07983886f, -0.06744990f, -0.13427018f, 0.01740035f, -0.03906626f, -0.07597937f, 0.08589454f, -0.04431862f, 
    0.05763372f, 0.07021283f, 0.07910164f, 0.09563621f, 0.01551068f, -0.00102651f, 0.03676356f, 0.08834190f, 
    -0.41452435f, -0.00149674f, 0.17298050f, 0.02242048f, 0.01048189f, -0.12968478f, -0.03048713f, 0.04791329f, 
    -0.11537144f, 0.02784014f, 0.02447517f, 0.00894251f, -0.05455992f, -0.09124385f, -0.03210710f, -0.10795232f, 
    0.07385316f, 0.08672488f, 0.01138910f, -0.00064657f, 0.30198896f, -0.32599115f, 0.22681588f, 0.51162809f, 
    0.03443385f, 0.03896909f, 0.23225284f, 0.23097150f, 0.03054910f, -0.03061717f, 0.18594490f, 0.03597276f, 
    -0.13929005f, -0.04693360f, 0.09136784f, 0.05695655f, -0.09234883f, 0.14613083f, -0.03319376f, -0.02672214f, 
    0.09483833f, 0.00996572f, 0.00270448f, 0.05121421f, 0.00207339f, 0.02705658f, -0.02304477f, -0.01357585f, 
    -0.04368578f, 0.07443124f, 0.01652731f, -0.01906283f, 0.03621536f, 0.05222018f, 0.02389690f, 0.01447825f, 
    0.06822036f, 0.06297354f, -0.04496980f, 0.10436996f, -0.18671158f, 0.27356538f, -0.00867219f, 0.11897807f, 
    0.08880661f, -0.05659125f, 0.00265338f, 0.02904586f, 0.07386347f, 0.06292143f, 0.05594449f, 0.04493212f, 
    0.03795383f, -0.08597881f, 0.05302912f, -0.00555369f, 0.00279910f, 0.05296800f, 0.05681611f, -0.08983275f, 
    0.27183798f, 0.09711221f, -0.02548650f, -0.17007257f, -0.05524246f, -0.06443914f, -0.02445581f, 0.04649201f, 
    0.05289562f, -0.05859618f, 0.09865385f, 0.01374423f, 0.03687732f, 0.00625118f, 0.05636155f, 0.01878002f, 
    0.05684155f, -0.06274427f, 0.00322440f, -0.03264742f, 0.08824136f, 0.09743343f, 0.12882058f, 0.04450138f, 
    -0.20781897f, -0.09326114f, 0.00215908f, -0.04668355f, 0.05545336f, 0.02452703f, 0.02432649f, 0.03235947f, 
    0.04655785f, -0.07240778f, -0.06258086f, 0.03039124f, -0.12425635f, 0.04762148f, 0.12467697f, -0.03159429f, 
    0.31577188f, -0.14794962f, -0.26098204f, 0.34002408f, 0.41939583f, 0.17144728f, 0.04390407f, 0.19050229f, 
    -0.02483282f, -0.09040911f, 0.05059584f, 0.06855908f, -0.07604711f, 0.14268756f, -0.01581639f, 0.23419106f, 
    0.09950831f, 0.11954935f, 0.03037461f, 0.02491545f, -0.11561337f, 0.07147368f, 0.11010161f, -0.03136078f, 
    -0.15018079f, -0.13352649f, 0.03086237f, 0.01228816f, 0.01174262f, -0.04750637f, 0.02086394f, 0.00759686f, 
    0.02197791f, -0.13928895f, 0.02330869f, -0.06247642f, 0.05038448f, -0.04699179f, -0.06502189f, 0.10651337f, 
    0.06763908f, -0.03927847f, 0.04917170f, -0.07201594f, -0.14604232f, -0.00488777f, -0.00134127f, -0.03599762f, 
    -0.12778959f, -0.04699468f, 0.05158644f, 0.03906898f, -0.08927301f, 0.03477590f, -0.08484982f, -0.04367643f, 
    0.01539861f, 0.01120324f, 0.00555875f, -0.01019904f, -0.24980114f, 0.02877197f, 0.03206901f, 0.00473947f, 
    -0.00897569f, 0.10698117f, 0.08852369f, -0.05249149f, 0.12787749f, 0.02162561f, -0.03075143f, 0.09214197f, 
    -0.04796791f, -0.00694757f, -0.01669790f, -0.09221310f, 0.04479156f, -0.08132808f, 0.15781537f, 0.00106693f, 
    0.18690571f, 0.13039114f, 0.06489742f, 0.11192458f, 0.02163573f, 0.02276373f, 0.00682531f, 0.03566694f, 
    0.07109886f, -0.00279965f, 0.05667786f, -0.03204110f, 0.07770644f, 0.02027479f, 0.07369687f, 0.13972437f, 
    0.02135447f, 0.00796116f, -0.07371569f, -0.08779981f, -0.19369231f, 0.78793669f, -0.04866821f, -0.11573742f, 
    0.01885365f, -0.01999109f, 0.05820856f, -0.10652182f, -0.03430206f, 0.16316131f, 0.14435993f, -0.01209580f, 
    -0.05005758f, 0.07899122f, 0.04377105f, -0.10119732f, 0.01799821f, -0.10781083f, 0.07236129f, -0.07844990f, 
    -0.28105611f, -0.08064285f, 0.30545321f, 0.03496293f, -0.11964627f, -0.16624027f, 0.07147129f, 0.01739274f, 
    -0.06621213f, -0.07825498f, -0.00319515f, 0.02837138f, 0.02935302f, -0.12324644f, -0.06400008f, -0.06663713f, 
    -0.05359716f, 0.05392629f, -0.04597333f, 0.07250972f, 0.02122990f, 0.22672501f, -0.02197079f, 0.13139066f, 
    0.09461081f, 0.07881726f, -0.01250055f, -0.05876788f, 0.10423667f, -0.04265768f, -0.09956200f, -0.07261477f, 
    -0.00534418f, 0.04734746f, 0.13172346f, -0.03168805f, 0.01678057f, -0.02707523f, -0.03388270f, -0.12251308f, 
    0.02178873f, 0.10840847f, 0.08539828f, 0.14203526f, 0.09330250f, 0.10942444f, 0.11810012f, 0.00509606f, 
    0.04855394f, -0.00983221f, 0.03070666f, 0.05196040f, 0.14358044f, 0.14550999f, 0.14373548f, 0.03392354f, 
    0.07740641f, 0.04074674f, 0.05145229f, -0.03591140f, 0.00739398f, -0.11883337f, -0.11578494f, -0.06715347f, 
    -0.12219591f, -0.00994300f, -0.03246083f, 0.05857234f, 0.06205522f, -0.07276008f, 0.09140338f, 0.07679290f, 
    0.08498896f, 0.05950205f, 0.09712180f, 0.00568359f, 0.14194080f, -0.03939596f, 0.10351372f, 0.10516145f, 
    -0.06342902f, 0.01987640f, -0.20994844f, -0.12743221f, -0.07844156f, 0.09956753f, 0.05699518f, -0.02367897f, 
    0.04621249f, 0.10649235f, 0.04314610f, -0.00262858f, -0.04799646f, 0.03303964f, 0.02961427f, 0.06122904f, 
    0.16830273f, -0.03787822f, 0.00869271f, 0.03166571f, 0.12756376f, -0.34636107f, 0.04096356f, 0.11378223f, 
    -0.05654464f, -0.00986348f, -0.02855483f, 0.06125803f, -0.02291057f, -0.01911536f, 0.04468232f, 0.03158752f, 
    0.10670108f, 0.02153917f, 0.07210600f, 0.01646278f, 0.06169072f, -0.13580604f, -0.01426008f, -0.00373965f, 
    0.16860582f, -0.13176364f, -0.01581756f, 0.02077803f, 0.10185059f, 0.10638689f, 0.00394674f, 0.02225675f, 
    -0.05478549f, 0.00158115f, 0.06544697f, 0.06907082f, 0.04668532f, 0.13381691f, -0.04594024f, 0.00422114f, 
    0.11977556f, -0.02717788f, 0.03802480f, 0.03403831f, -0.28452340f, 0.21441518f, -0.19913332f, -0.10603385f, 
    0.01590349f, -0.04698934f, 0.10045279f, 0.02512550f, 0.14641137f, 0.11533870f, 0.01124299f, 0.13718916f, 
    0.02454508f, -0.08695081f, 0.03779820f, 0.10115379f, 0.00064763f, 0.12286985f, -0.10355769f, 0.00966076f, 
    0.05021080f, 0.49027997f, 0.27916124f, 0.23678279f, -0.04145135f, -0.08320437f, -0.11442538f, 0.00795985f, 
    0.01407846f, 0.11772114f, 0.06056045f, 0.06546783f, 0.11724123f, 0.18409002f, 0.06238937f, 0.15549763f, 
    0.00897892f, 0.05182803f, -0.01939512f, 0.05375101f, 0.02202168f, 0.00763639f, -0.09319191f, -0.17636156f, 
    -0.10544997f, 0.06071251f, 0.04320619f, 0.14525236f, 0.08600505f, 0.04674925f, 0.05002404f, -0.03641475f, 
    -0.03559026f, 0.07661307f, -0.08248299f, 0.09783542f, 0.07703092f, 0.03384577f, 0.01981765f, 0.12467097f, 
    0.00351266f, -0.25568923f, -0.03394721f, 0.10445962f, 0.03952760f, 0.08054899f, -0.04241698f, 0.16914038f, 
    0.08602037f, 0.01445619f, -0.01517152f, -0.02988615f, 0.12928790f, 0.15106012f, 0.07779223f, 0.08001928f, 
    0.14254464f, 0.03310102f, 0.04740006f, -0.00456130f, -0.13937439f, 0.35144261f, -0.09136177f, 0.03270506f, 
    0.13714260f, 0.03810070f, 0.19768533f, 0.01216125f, 0.09080011f, 0.18476048f, 0.03528555f, 0.08428758f, 
    0.01617150f, -0.01510628f, 0.09668455f, -0.01831685f, -0.06017845f, 0.03499172f, 0.01557172f, -0.05213517f, 
    -0.04949500f, -0.09966626f, 0.07956344f, 0.03838644f, -0.15291758f, 0.00234689f, 0.02758547f, 0.12135424f, 
    0.06849213f, 0.04802148f, 0.02253931f, -0.00243214f, 0.10033199f, 0.03467221f, 0.10675488f, 0.02526901f, 
    -0.05118345f, 0.02086584f, 0.01911101f, 0.00087143f, 0.03900651f, -0.12227045f, -0.28010938f, 0.02039327f, 
    -0.17891423f, -0.01697201f, -0.01582031f, -0.08336568f, 0.01145481f, -0.02977368f, 0.06822271f, 0.01183964f, 
    0.03142479f, -0.06276824f, 0.06965770f, 0.05322503f, 0.08127791f, -0.03203785f, -0.09713101f, 0.10942457f, 
    -0.25236851f, 0.20649475f, -0.15978612f, -0.09535511f, 0.12177297f, 0.06395173f, 0.02904441f, 0.06696694f, 
    0.08843561f, 0.03899126f, -0.00964763f, 0.00206812f, 0.08966253f, -0.07147646f, -0.02943309f, 0.01715480f, 
    0.03527974f, 0.00864316f, -0.05358562f, 0.08593542f, 0.03238697f, -0.09268410f, -0.19056195f, 0.08577403f, 
    0.14776337f, 0.10737828f, 0.13716415f, 0.04630048f, -0.04974071f, 0.11582438f, 0.10682417f, 0.10117406f, 
    0.00554517f, -0.04835397f, 0.08143993f, 0.10443763f, 0.07630873f, 0.01253150f, 0.04977025f, 0.01576417f, 
    0.08122191f, 0.25093263f, 0.03111154f, 0.10793764f, 0.13903095f, 0.16772105f, 0.25753444f, 0.02841401f, 
    0.11336655f, 0.14369911f, 0.02551380f, 0.06995298f, 0.18458115f, 0.09392604f, 0.03615888f, -0.04057051f, 
    0.05027626f, 0.06465601f, 0.02315459f, -0.00992069f, 0.07420334f, 0.40194127f, 0.18920796f, 0.15024090f, 
    -0.06733828f, -0.07886538f, -0.01042673f, 0.04350246f, 0.05602726f, 0.11429863f, 0.05488871f, 0.02206835f, 
    0.09709111f, 0.16336191f, 0.05881140f, 0.19489607f, 0.03149722f, 0.08374572f, -0.00086038f, 0.03923764f, 
    0.05151743f, 0.10197379f, 0.37690738f, 0.09788104f, -0.00540393f, 0.10961180f, 0.02141666f, 0.04759921f, 
    -0.04028516f, 0.08798867f, 0.12339050f, 0.00351954f, 0.15103371f, 0.01888145f, 0.06173550f, -0.02163369f, 
    0.11751710f, 0.02706048f, 0.03670071f, -0.04159697f, -0.12313418f, -0.01360761f, -0.25703794f, -0.02968967f, 
    0.01615304f, 0.09975401f, 0.10675061f, 0.18644527f, 0.10218725f, 0.00654223f, 0.00766678f, -0.09264383f, 
    0.11913880f, -0.04190669f, 0.03533654f, 0.03609112f, 0.04254348f, -0.00054715f, -0.06038427f, 0.09336298f, 
    -0.06929934f, 0.13697429f, -0.02754472f, -0.13255244f, -0.10582369f, 0.03469377f, 0.11467627f, 0.01991757f, 
    0.07317305f, 0.07763036f, 0.00035807f, 0.13890228f, -0.06378756f, 0.05445570f, 0.12931493f, 0.10040741f, 
    0.15610833f, 0.08116037f, 0.04383101f, 0.10267451f, -0.23235676f, 0.18376392f, 0.09856600f, 0.05725553f, 
    0.06841993f, -0.08480964f, 0.08755057f, -0.09718547f, 0.00010557f, 0.27896479f, 0.12368435f, -0.01001250f, 
    0.08212873f, 0.02437889f, 0.05426082f, 0.10823721f, 0.08890010f, 0.01047993f, -0.02668332f, 0.04656029f, 
    -0.02992271f, -0.03216359f, -0.04577457f, 0.07240211f, 0.10711799f, 0.09056178f, 0.10795933f, 0.12315313f, 
    0.06897949f, -0.06283166f, 0.07869852f, -0.00774967f, 0.10307657f, -0.00575381f, 0.09913300f, 0.10747531f, 
    0.01267642f, 0.06413986f, 0.05791698f, 0.09418512f, -0.23389639f, -0.17650561f, 0.14618988f, 0.06330384f, 
    -0.03291271f, 0.02304056f, 0.06705879f, 0.05628148f, 0.05143693f, 0.16191331f, 0.07462173f, 0.03391754f, 
    0.13860320f, -0.12994330f, 0.02198893f, 0.04935609f, 0.05051817f, 0.01006739f, -0.01292037f, -0.03255154f, 
    0.05856768f, -0.15268716f, -0.28081912f, -0.09654888f, -0.11488203f, 0.01660398f, 0.08470208f, 0.02206485f, 
    0.04046016f, -0.04880994f, 0.03691812f, 0.02610235f, -0.03323011f, 0.02780083f, 0.18426065f, 0.04961153f, 
    0.07238772f, -0.01908476f, -0.06618596f, 0.10050026f, -0.24665618f, -0.16175263f, -0.15311149f, -0.06595819f, 
    0.07323886f, -0.07966012f, 0.09923182f, 0.05306292f, -0.02672521f, 0.10038645f, -0.06214584f, 0.05095155f, 
    -0.08682474f, -0.07752709f, 0.05530068f, -0.01002771f, -0.04678443f, 0.13601749f, -0.01141786f, 0.02130610f, 
    0.04829178f, 0.07157009f, 0.52833521f, 0.12814625f, 0.01510639f, -0.02271085f, 0.06155239f, 0.07235014f, 
    -0.01602248f, 0.09059065f, 0.07093515f, 0.02221242f, 0.10395982f, 0.21252519f, 0.07988936f, -0.06373572f, 
    0.03710234f, -0.12910487f, 0.04258334f, 0.00466868f, -0.23205802f, 0.00695678f, -0.18560135f, -0.04495246f, 
    -0.04382381f, 0.11318997f, 0.02189001f, 0.03249806f, 0.06855827f, 0.01421669f, 0.00029047f, 0.03292802f, 
    0.03350635f, 0.06269214f, 0.01782335f, 0.08730753f, 0.14135531f, -0.05504078f, 0.04829788f, -0.01889733f, 
    -0.28105450f, -0.08077963f, -0.20159091f, -0.06750377f, -0.01334526f, 0.05288213f, 0.02515794f, 0.06851951f, 
    0.16822802f, 0.03245824f, 0.00324212f, -0.05023809f, 0.03237546f, 0.10933112f, -0.05114432f, 0.01404820f, 
    0.06669673f, -0.01848484f, -0.04735089f, -0.02410449f, -0.08313914f, -0.28749272f, 0.01705876f, -0.17038755f, 
    0.13412416f, 0.08884002f, -0.08103862f, 0.09220542f, -0.17554080f, 0.11369197f, 0.14226086f, 0.01333541f, 
    0.11608283f, 0.04582308f, 0.08095738f, 0.05043441f, 0.04708155f, -0.08795322f, 0.06992826f, -0.02312879f, 
    -0.21617000f, -0.06731831f, 0.05174444f, 0.00384752f, -0.18239285f, 0.07759595f, -0.03155776f, 0.04391004f, 
    0.13114290f, 0.10515331f, 0.05404745f, 0.03253175f, 0.03719554f, 0.04765866f, 0.12245739f, 0.10514849f, 
    0.06761335f, -0.01986239f, -0.06518084f, 0.03000195f, -0.17154045f, 0.18654729f, -0.02394845f, 0.09353931f, 
    0.26418817f, 0.05555095f, 0.19252405f, 0.15578982f, -0.05878472f, 0.06926065f, 0.14094152f, 0.03418765f, 
    0.03883781f, 0.00669502f, 0.19620346f, 0.00258970f, 0.07300044f, 0.04478626f, 0.01959997f, -0.01006162f, 
    -0.16699801f, 0.14746018f, -0.09430066f, -0.02552753f, -0.16323724f, 0.04034621f, 0.15504414f, 0.08304329f, 
    0.05967134f, 0.09275639f, 0.03446517f, 0.12148942f, -0.01877965f, 0.12260006f, 0.10462177f, 0.09141558f, 
    0.13368240f, 0.01956672f, 0.03139873f, 0.03346855f, -0.02884585f, 0.07440620f, -0.02046441f, 0.00228612f, 
    -0.17145047f, 0.06797153f, 0.13454098f, -0.00186885f, 0.12212184f, 0.07343730f, 0.03925437f, -0.00058471f, 
    0.04253186f, 0.12602627f, 0.14307413f, 0.09444276f, 0.05521812f, 0.03806652f, 0.00393024f, 0.01866824f, 
    -0.01064578f, 0.02698742f, -0.02038857f, -0.02055643f, 0.00581016f, -0.03424555f, -0.00422029f, -0.01561671f, 
    0.02037135f, -0.02906820f, -0.02177670f, -0.04423776f, -0.00382940f, 0.00340115f, 0.02524521f, -0.00785893f, 
    -0.03573265f, -0.01280042f, 0.03229750f, -0.04651795f, 0.01251124f, -0.03323667f, 0.03612252f, -0.03398415f, 
    0.02197613f, 0.02661003f, -0.00217100f, -0.03143497f, 0.01171838f, 0.00355719f, 0.00535104f, -0.00420187f, 
    -0.03023759f, -0.02513198f, 0.02528780f, -0.03121241f, 0.00620001f, 0.00510433f, -0.02017088f, -0.00515161f, 
    -0.03408677f, 0.01429046f, 0.00529397f, -0.01270023f, -0.01759805f, 0.01196811f, 0.00941476f, -0.00910465f, 
    -0.03416134f, -0.02929911f, 0.00979154f, -0.00712880f, 0.01233733f, 0.01793488f, -0.02366504f, 0.02806050f, 
    -0.03453530f, -0.01214278f, 0.01723900f, -0.03060626f, -0.00652208f, -0.02534732f, -0.03704343f, -0.00409717f, 
    -0.02096196f, -0.01451277f, -0.02378396f, -0.01257962f, -0.03835546f, -0.04042792f, -0.02989805f, -0.04480235f, 
    0.02732874f, -0.00874868f, -0.02974360f, -0.00367427f, -0.04300468f, 0.01734704f, -0.02999311f, 0.01881607f, 
    -0.01999951f, 0.01258602f, -0.00581015f, 0.02597269f, -0.02289958f, -0.00541501f, -0.02871214f, -0.04710800f, 
    -0.03208180f, 0.02946231f, 0.01849552f, 0.02064891f, -0.00607850f, -0.00847323f, -0.03180500f, -0.02655738f, 
    -0.01010079f, -0.01241960f, 0.01449159f, 0.00240721f, 0.00701100f, -0.03413028f, 0.00600843f, -0.04194878f, 
    -0.01203965f, -0.01128948f, -0.00267970f, -0.02928530f, -0.00323620f, 0.03393316f, 0.00409957f, 0.00486014f, 
    -0.01830837f, 0.00656050f, -0.03038577f, -0.02608786f, 0.02356841f, 0.01156446f, 0.02270849f, -0.00059593f, 
    0.00059493f, -0.03270834f, 0.03182610f, 0.02217358f, 0.01638318f, 0.00611029f, -0.01322656f, -0.03323193f, 
    -0.03807608f, -0.00070787f, -0.00792412f, -0.03963937f, 0.03149385f, -0.03495545f, 0.03129726f, -0.03176900f, 
    -0.01046138f, 0.02760052f, 0.01739288f, 0.01139631f, -0.03797534f, -0.02271953f, 0.03045484f, -0.02618382f, 
    -0.00915035f, -0.00631683f, -0.01535504f, 0.02841433f, 0.01846909f, -0.04273675f, -0.03226962f, 0.00618732f, 
    -0.01610734f, -0.02707191f, 0.01343517f, -0.03501920f, 0.02496048f, 0.01795650f, -0.01871798f, 0.02898398f, 
    -0.04283457f, -0.03588461f, -0.04008675f, 0.01735702f, 0.03543549f, -0.03535963f, -0.01696540f, 0.00897426f, 
    -0.02267406f, -0.02987173f, 0.02517152f, 0.00986182f, 0.00467625f, 0.01333317f, -0.00931802f, -0.02455422f, 
    0.00860277f, -0.01481073f, -0.00558776f, -0.03207133f, -0.00152446f, 0.02325179f, -0.03458565f, 0.00801957f, 
    -0.00613420f, -0.03156977f, 0.00808064f, -0.01403732f, -0.01460435f, -0.03120571f, 0.02588665f, 0.02240901f, 
    0.01770069f, -0.04254097f, -0.00860885f, 0.01118236f, -0.00238434f, -0.04373715f, 0.01793320f, -0.00594495f, 
    -0.02396374f, 0.03148704f, 0.00312810f, 0.02733616f, 0.02375234f, -0.00623733f, 0.01741956f, 0.02323601f, 
    0.01539682f, 0.01384741f, 0.00922925f, -0.02380543f, 0.02677785f, 0.02307682f, 0.01543853f, 0.01985324f, 
    -0.02799509f, 0.00625392f, -0.04059153f, 0.00558191f, -0.01379533f, 0.00542435f, -0.02278004f, 0.02412724f, 
    -0.00325301f, -0.03866629f, -0.03342964f, 0.01903516f, -0.02931011f, 0.01162582f, -0.03511551f, -0.01232881f, 
    0.02647243f, 0.00296167f, 0.01262687f, -0.03389602f, 0.00211474f, -0.04251383f, 0.00085006f, 0.02554803f, 
    -0.03809394f, -0.00640370f, 0.00629452f, 0.01198594f, 0.00250633f, 0.00293389f, -0.04173028f, -0.00398013f, 
    -0.04530772f, 0.00728239f, -0.01945191f, 0.00657659f, 0.00057034f, -0.01817436f, -0.00989809f, -0.02699979f, 
    -0.04066653f, -0.00086443f, -0.03598944f, -0.01454303f, -0.01809067f, 0.01376462f, -0.03932536f, -0.02041484f, 
    -0.01835809f, -0.02524948f, -0.01641638f, 0.00552445f, -0.01655382f, -0.00084991f, 0.02624760f, -0.02261012f, 
    -0.01620671f, 0.02138579f, 0.00648552f, -0.02459025f, -0.03700907f, -0.03936965f, -0.02399948f, -0.04063928f, 
    0.01759519f, -0.01364237f, 0.02282950f, -0.04824322f, 0.01846632f, -0.03945588f, -0.02128704f, -0.03696109f, 
    -0.04039561f, 0.02684188f, -0.04505287f, -0.01806557f, -0.01282776f, 0.01858977f, -0.02920319f, 0.02130486f, 
    0.00221466f, -0.00563972f, -0.00755388f, 0.02933875f, -0.00215086f, -0.02745963f, -0.01014700f, -0.03690773f, 
    -0.01149271f, 0.00767382f, 0.02946340f, 0.02716345f, 0.00520516f, 0.01505204f, -0.00824562f, -0.01547568f, 
    0.00079454f, 0.01946540f, -0.03849587f, 0.02258934f, -0.00598545f, -0.00048829f, 0.01880299f, 0.00460379f, 
    -0.01528741f, 0.01949777f, -0.03664355f, 0.02006727f, -0.03181141f, 0.02064997f, -0.01278288f, -0.02780285f, 
    0.00673461f, 0.00003478f, 0.01085299f, -0.00261563f, -0.04193071f, -0.00688650f, -0.04105277f, -0.03579482f, 
    -0.00759160f, 0.02856559f, -0.02809268f, -0.00472189f, -0.01811227f, 0.02712491f, -0.02579184f, -0.00952587f, 
    0.00019862f, -0.03927973f, -0.03818319f, 0.02730586f, -0.00106591f, 0.02028498f, -0.04185848f, -0.03759369f, 
    -0.02488280f, -0.04558893f, -0.01195307f, 0.02419196f, 0.01297176f, -0.04232453f, 0.02024323f, 0.01024101f, 
    0.00056522f, 0.01138321f, -0.00432009f, -0.04589861f, -0.05002207f, 0.01635749f, 0.02587805f, -0.03843702f, 
    0.00718380f, -0.03077899f, 0.02502465f, -0.01119541f, 0.01693565f, 0.02759487f, 0.00638450f, 0.03131608f, 
    -0.02296257f, -0.00603540f, -0.02385909f, -0.04371479f, 0.01781445f, 0.02687115f, -0.00150121f, -0.03859127f, 
    -0.04270799f, -0.03986702f, -0.01640752f, 0.01730949f, 0.01191398f, -0.01741909f, -0.00807407f, -0.03700189f, 
    -0.00351642f, 0.02218724f, -0.02239932f, -0.03529976f, -0.03645239f, 0.00462902f, -0.03288043f, -0.00441556f, 
    0.01441344f, -0.03176809f, -0.03539059f, -0.01382528f, 0.02604934f, 0.02388817f, -0.00814095f, 0.01626112f, 
    0.00460155f, 0.02701361f, -0.03501182f, 0.03017843f, -0.00814729f, 0.01631344f, -0.00264267f, -0.04130301f, 
    -0.02790111f, -0.02689371f, -0.00909983f, -0.02002947f, 0.02128367f, -0.00250952f, -0.01090795f, 0.00067580f, 
    0.02053892f, 0.01019593f, 0.00348232f, 0.02306613f, -0.02848716f, 0.00546097f, -0.02192550f, -0.02623055f, 
    -0.02810739f, -0.02745436f, 0.02437302f, -0.02839594f, -0.02050936f, -0.02704748f, -0.02842224f, 0.00820507f, 
    0.03384775f, -0.02214389f, 0.03594925f, 0.01996434f, -0.03199868f, 0.01070643f, 0.01513029f, 0.02451113f, 
    0.02264669f, -0.02927222f, 0.02591609f, 0.00148966f, -0.04529609f, -0.02921149f, -0.04121279f, 0.00245196f, 
    0.02331981f, 0.01931920f, -0.03683455f, -0.01715374f, 0.00098737f, 0.01770167f, 0.02276070f, -0.03442700f, 
    0.00020358f, -0.03578752f, -0.01085575f, 0.00652943f, -0.04078342f, 0.01159897f, 0.01050529f, 0.00391153f, 
    0.00070231f, -0.02405586f, -0.00763284f, 0.02369375f, 0.01329189f, -0.00949005f, 0.02330137f, -0.02661993f, 
    0.00823361f, -0.00281940f, -0.00024977f, 0.01983350f, 0.03027382f, -0.03285800f, -0.03777158f, 0.01334929f, 
    0.00415560f, -0.02695997f, 0.00629886f, -0.03718532f, -0.04908795f, 0.00979441f, -0.04384854f, -0.00766777f, 
    -0.00821374f, 0.01051605f, -0.01397664f, 0.01299927f, -0.01307902f, 0.00866275f, 0.02342423f, 0.00557139f, 
    -0.02833758f, -0.02904264f, -0.03644729f, 0.02792503f, -0.04490267f, -0.03490935f, 0.00038891f, 0.00906377f, 
    -0.04069624f, -0.00864869f, -0.00787967f, 0.03059089f, 0.00607616f, 0.02461486f, 0.02062593f, -0.02716956f, 
    -0.00733753f, 0.02647645f, -0.01220051f, -0.00607599f, -0.00010011f, 0.03093240f, 0.01481861f, -0.03170904f, 
    0.02505267f, 0.02632891f, -0.02268625f, 0.02660310f, -0.04802092f, 0.00909394f, 0.01801436f, -0.03129636f, 
    0.01202062f, 0.01730214f, 0.00005874f, 0.02479112f, 0.03204563f, 0.01073625f, -0.01037238f, -0.01920268f, 
    -0.00347611f, 0.02001333f, 0.00410542f, -0.03649132f, -0.02486133f, -0.01563788f, -0.03089056f, -0.00898634f, 
    0.00102010f, 0.01767803f, 0.01387959f, -0.00050850f, 0.02729127f, 0.02244785f, 0.00268665f, 0.02263304f, 
    0.02239581f, -0.02599604f, 0.01650993f, 0.03123112f, 0.03366696f, 0.03119174f, -0.04354056f, -0.03737099f, 
    0.01433075f, -0.04351906f, -0.00448927f, -0.02793000f, -0.01480139f, -0.02777717f, -0.03674485f, 0.00614169f, 
    -0.04544416f, 0.02193240f, -0.00938036f, 0.00042538f, 0.00823591f, -0.01480495f, -0.03687349f, -0.01902489f, 
    -0.01910432f, -0.04699833f, -0.03050348f, -0.04550232f, 0.01974655f, -0.00289652f, -0.01183596f, -0.01514037f, 
    -0.02905323f, -0.00447043f, 0.00006939f, 0.02229340f, 0.00795591f, 0.02340001f, -0.00578243f, 0.02741127f, 
    -0.00210416f, -0.01016540f, 0.02537134f, -0.02661718f, -0.00338836f, 0.02148699f, -0.02621801f, -0.00901110f, 
    -0.03875959f, -0.04277909f, -0.03508480f, -0.03885623f, -0.04290367f, -0.02974194f, 0.01321590f, -0.00349386f, 
    0.00878761f, -0.00593947f, -0.00404865f, -0.04195403f, -0.03472663f, -0.00896147f, -0.03332345f, -0.01265408f, 
    -0.03872469f, -0.02058068f, 0.02317204f, -0.04184225f, -0.01269092f, -0.02845311f, -0.01524160f, 0.01764444f, 
    -0.03758433f, 0.00002863f, -0.00882602f, 0.03136198f, -0.00865639f, -0.03651847f, 0.01753576f, -0.03130520f, 
    -0.04476266f, 0.01767872f, -0.00770490f, -0.02025789f, -0.01621665f, -0.02949101f, -0.01033722f, -0.00968079f, 
    -0.00473300f, -0.00992413f, -0.02222909f, -0.03101806f, 0.02236862f, -0.00736062f, 0.00358224f, -0.00957919f, 
    -0.02302391f, -0.01114457f, -0.04070820f, 0.00924458f, 0.00632215f, -0.00462356f, 0.00151721f, -0.01456904f, 
    0.01394446f, -0.00262878f, -0.03286246f, -0.02050488f, -0.01817436f, -0.01596181f, 0.00500602f, -0.00852412f, 
    0.01611988f, -0.04270234f, -0.00164476f, -0.00696601f, -0.03251947f, -0.00140214f, 0.02920553f, -0.03949979f, 
    -0.00658934f, -0.02907652f, -0.01739759f, 0.03450223f, 0.03761082f, 0.02574853f, 0.01444790f, 0.02206925f, 
    -0.00419658f, -0.01225232f, -0.00192041f, 0.02105317f, -0.03451340f, 0.01157569f, -0.03639911f, -0.02943170f, 
    -0.02953303f, 0.03045927f, -0.00927571f, -0.03689360f, 0.00685299f, 0.01566114f, -0.03216317f, 0.02443681f, 
    0.02375026f, -0.02108809f, -0.03909545f, 0.01418228f, 0.03198145f, -0.03248842f, 0.02315051f, -0.01232254f, 
    0.01328628f, 0.01548150f, 0.02408425f, -0.02840344f, 0.01253061f, -0.00071370f, -0.02601620f, 0.00029931f, 
    -0.02840893f, 0.01282846f, 0.00870685f, 0.02367833f, 0.01552149f, 0.00841471f, -0.04215991f, -0.03066884f, 
    0.01591321f, -0.02012504f, -0.01696360f, 0.01014118f, 0.00723616f, 0.02074298f, 0.00384562f, 0.01522192f, 
    -0.00722302f, -0.02680316f, 0.00453342f, -0.02868302f, -0.03359029f, -0.02209806f, -0.03488603f, -0.01845492f, 
    0.03297911f, -0.03578158f, 0.02614269f, -0.03501955f, 0.02795030f, 0.02939929f, 0.01040691f, 0.01868083f, 
    0.03294376f, -0.03466938f, -0.01681576f, -0.03185460f, -0.00765268f, -0.03593157f, -0.02337308f, 0.02711668f, 
    -0.01363313f, 0.02870580f, -0.02409033f, -0.03592169f, 0.01303392f, -0.01461154f, -0.04290174f, 0.00456092f, 
    0.01609172f, -0.00406709f, 0.00598040f, -0.02280968f, -0.00856767f, 0.01025378f, 0.01826295f, 0.01142937f, 
    -0.01773892f, -0.01870181f, -0.00380946f, -0.03541021f, 0.02318601f, -0.04407712f, -0.01220435f, 0.00996191f, 
    0.00588299f, 0.01988091f, 0.01531912f, -0.00991662f, 0.03264600f, 0.00709018f, -0.03288978f, -0.02168222f, 
    -0.01899061f, -0.02263521f, -0.03243852f, 0.02577800f, -0.00805508f, 0.02465339f, 0.03317909f, 0.00591857f, 
    -0.00028937f, -0.00930853f, 0.03239497f, 0.01673787f, -0.03741969f, -0.04138032f, -0.01114825f, 0.01444449f, 
    -0.03501797f, 0.00356117f, -0.03846911f, -0.00678034f, 0.02679472f, 0.00158641f, 0.01423951f, -0.03262879f, 
    -0.03021516f, -0.00667691f, -0.02251079f, -0.01719018f, -0.01598032f, 0.01596116f, -0.00668539f, -0.04271330f, 
    -0.02876278f, -0.00795170f, 0.03228339f, -0.01122429f, 0.02035955f, 0.03115537f, -0.04241654f, -0.01147669f, 
    0.00991210f, -0.01998202f, 0.02678498f, 0.02435709f, 0.01660286f, 0.00410924f, 0.00444371f, 0.00427328f, 
    0.00296713f, 0.00050603f, -0.00807533f, 0.03127955f, -0.01787943f, 0.00367698f, 0.02369044f, 0.00858446f, 
    -0.02071645f, 0.01728928f, -0.04014674f, -0.04267948f, 0.02086739f, -0.02611528f, 0.00717501f, 0.03061408f, 
    -0.02233671f, -0.01946167f, -0.03327932f, -0.04501304f, -0.02341081f, -0.03733456f, -0.00686926f, -0.04098403f, 
    -0.01292330f, -0.03469705f, 0.00598429f, 0.02196228f, -0.01812750f, -0.02184781f, -0.03646315f, 0.02297145f, 
    0.01628090f, 0.00773320f, 0.02658178f, -0.00037188f, -0.01644128f, -0.02760330f, -0.03084502f, -0.01190736f, 
    -0.03060289f, 0.00137481f, -0.03297265f, 0.01252266f, -0.00995125f, 0.00603001f, -0.04269363f, -0.01036643f, 
    -0.03676329f, -0.04091784f, 0.00603985f, 0.00849141f, 0.03329503f, -0.02478127f, 0.00298537f, 0.02449018f, 
    0.01936383f, 0.03430666f, -0.00080492f, -0.00723182f, -0.00690587f, 0.00329301f, 0.02694564f, -0.02691304f, 
    -0.00716833f, -0.03239346f, -0.03425815f, -0.04427988f, -0.02372805f, -0.01867005f, -0.03216654f, -0.02921791f, 
    0.01317557f, 0.03094568f, -0.01483581f, -0.04460961f, 0.00956961f, 0.03175090f, 0.00016559f, -0.02706468f, 
    -0.01696482f, 0.00774917f, -0.03520058f, -0.03676901f, 0.00923496f, 0.00718295f, -0.01513549f, 0.03335688f, 
    -0.03637305f, 0.02730295f, -0.03314586f, -0.01720392f, 0.00170698f, 0.01605944f, 0.00825377f, -0.00574570f, 
    -0.02469433f, 0.00015296f, 0.02985975f, -0.02704375f, -0.03896167f, -0.02903471f, -0.00001607f, -0.02190561f, 
    -0.00494677f, 0.01596891f, -0.00416529f, -0.00046134f, 0.03158444f, 0.02503750f, -0.00259905f, 0.02658639f, 
    0.02646586f, 0.02581373f, -0.00116102f, -0.03740760f, -0.00579421f, -0.04533820f, -0.00069246f, -0.03591768f, 
    -0.02466773f, 0.03081619f, -0.01011420f, -0.00603544f, 0.00828316f, -0.04107851f, 0.00063828f, -0.04116320f, 
    -0.02924222f, 0.01885433f, 0.00228217f, -0.02702248f, 0.02541745f, -0.04124756f, 0.02630958f, -0.03915998f, 
    -0.01530142f, 0.03665917f, 0.00215811f, -0.01575753f, 0.03424278f, 0.01074630f, -0.02862343f, -0.02931122f, 
    -0.01562384f, -0.04543702f, 0.02573011f, -0.02071531f, -0.04322726f, 0.01977615f, -0.00361696f, 0.02963508f, 
    0.02377725f, -0.03694042f, 0.00280389f, -0.01430347f, -0.01966830f, -0.00462248f, -0.03060131f, 0.02470306f, 
    -0.01182267f, -0.02018583f, -0.03429756f, 0.00073073f, 0.02778864f, 0.02408277f, -0.00276442f, -0.02465267f, 
    0.01440874f, 0.00011360f, 0.00793900f, 0.00320678f, -0.00446610f, -0.02711618f, -0.04098791f, -0.03214875f, 
    -0.00000499f, -0.02476605f, -0.01467634f, 0.03128404f, -0.01707194f, 0.00841213f, -0.01210580f, 0.00328653f, 
    0.01905307f, -0.01332105f, 0.02584107f, -0.03744414f, 0.01951358f, -0.00185392f, 0.02112924f, 0.01248668f, 
    0.02462299f, -0.02534540f, -0.02749793f, -0.01731920f, -0.02368606f, -0.00619603f, 0.03004999f, -0.03366001f, 
    -0.04091493f, -0.03718912f, -0.02328759f, -0.00215114f, -0.03558956f, -0.04372984f, -0.02177371f, -0.01575903f, 
    -0.00960079f, -0.00416439f, -0.03059337f, -0.02170698f, -0.02049875f, -0.01453003f, 0.02604159f, 0.03076251f, 
    -0.01483178f, -0.01200158f, 0.02886107f, -0.04360569f, 0.01016760f, -0.00567333f, -0.00636646f, 0.00357383f, 
    -0.04207533f, -0.01629682f, -0.04359675f, -0.00044021f, -0.03318824f, -0.03560875f, 0.00728852f, -0.04355020f, 
    0.00437488f, -0.02433074f, 0.01918896f, -0.03335185f, 0.01301362f, 0.01445847f, 0.03334597f, 0.00261829f, 
    -0.02019370f, 0.01906193f, -0.04202766f, -0.03338344f, -0.02864477f, -0.00766686f, -0.00040057f, 0.01987158f, 
    0.01113932f, 0.00035678f, -0.01931033f, 0.00695279f, -0.00471235f, -0.01497425f, -0.04013549f, -0.00614112f, 
    0.02417329f, 0.00747500f, -0.02386205f, -0.04173214f, -0.02695643f, -0.00166473f, -0.01383334f, 0.00874212f, 
    -0.04105302f, 0.00075198f, -0.04546366f, 0.01209636f, -0.04339708f, 0.02286516f, -0.00189537f, -0.01454035f, 
    0.01670296f, 0.02108266f, 0.02186527f, -0.03735651f, -0.03639681f, -0.02637380f, 0.00956107f, -0.03207316f, 
    -0.02490937f, -0.03821234f, 0.01819820f, 0.02608258f, -0.03041344f, -0.01078567f, -0.02604540f, 0.02934688f, 
    0.01368802f, -0.02738822f, -0.03166972f, -0.03888177f, 0.00586868f, -0.03127538f, -0.03076698f, -0.04244653f, 
    -0.03092037f, -0.03171011f, -0.00891430f, -0.03296636f, -0.03622828f, 0.02387862f, 0.00308153f, -0.02513764f, 
    -0.01488997f, -0.04338606f, 0.01751873f, 0.01152502f, -0.03553830f, 0.00610453f, 0.00394816f, 0.01072213f, 
    -0.03867588f, 0.03442788f, -0.02259671f, -0.00525683f, -0.00885826f, -0.03691377f, -0.01818408f, 0.01668774f, 
    -0.01342250f, -0.00941587f, 0.02272151f, -0.03225951f, 0.02338565f, -0.00201970f, -0.01852364f, 0.03112121f, 
    -0.02870690f, -0.00468356f, -0.03384329f, 0.02684467f, -0.01460056f, 0.02075474f, 0.00587126f, 0.01585608f, 
    -0.02102037f, -0.01323200f, -0.02873757f, -0.04488395f, 0.00398753f, 0.02754484f, -0.02134919f, 0.01232015f, 
    0.02362378f, -0.00564914f, -0.02720024f, 0.02405000f, -0.00752702f, -0.01099790f, 0.03267279f, -0.01935590f, 
    -0.02145676f, 0.02361294f, -0.02329278f, 0.02034128f, -0.01769619f, -0.01886792f, 0.01168256f, -0.02765911f, 
    -0.03354940f, -0.04322317f, -0.01957252f, 0.01304732f, -0.02023736f, -0.02033513f, -0.01745913f, -0.03966029f, 
    0.01813637f, -0.01560808f, -0.01028387f, -0.01936622f, -0.02387351f, 0.00678363f, -0.02078290f, 0.01992209f, 
    0.02372062f, -0.03105334f, -0.01954296f, -0.00715905f, 0.00214384f, -0.02112303f, -0.00113659f, -0.01400394f, 
    -0.00058305f, -0.02864759f, -0.00940415f, -0.04247911f, -0.03255056f, -0.03301036f, -0.01901661f, -0.03835106f, 
    0.03540412f, 0.01410119f, -0.01075946f, 0.01903835f, -0.02989404f, 0.02832482f, -0.03741989f, 0.02476507f, 
    0.02448667f, 0.01817099f, 0.00367329f, 0.02929659f, -0.02975799f, 0.02971529f, 0.02648194f, -0.00640752f, 
    -0.02115463f, -0.00409427f, 0.01961529f, -0.03256992f, -0.03053932f, -0.02809438f, 0.01752001f, 0.03151521f, 
    -0.02948585f, 0.01641091f, -0.01309558f, -0.03361171f, -0.00676662f, -0.01541808f, -0.02610743f, 0.03027977f, 
    -0.02208134f, -0.02101297f, -0.02676778f, 0.02199223f, 0.01344657f, 0.01182303f, 0.01166284f, -0.00713125f, 
    0.01768812f, -0.00481442f, -0.00761856f, 0.02694407f, 0.00627475f, -0.00848790f, -0.04300367f, -0.00644884f, 
    -0.02444571f, -0.02709554f, -0.04462886f, 0.01787625f, 0.02297993f, -0.04067002f, -0.02290491f, 0.01419740f, 
    -0.03855584f, -0.02064974f, 0.02679811f, -0.04481126f, -0.00619521f, -0.04347451f, -0.01136860f, -0.02589011f, 
    -0.00353672f, 0.00547084f, -0.03978112f, 0.02412677f, -0.00268169f, 0.02515128f, 0.03285612f, 0.02348135f, 
    -0.00829990f, 0.01019724f, 0.02420042f, -0.03809750f, -0.01428686f, -0.02682443f, -0.01796918f, -0.02830473f, 
    -0.02590957f, 0.02040667f, 0.00353780f, -0.01074896f, -0.00553782f, 0.01012790f, 0.00671191f, -0.03077283f, 
    -0.00209792f, -0.00366881f, 0.01788400f, -0.04301708f, -0.02482071f, -0.01588825f, 0.01299390f, -0.02297892f, 
    -0.01130798f, -0.02383617f, -0.03097900f, -0.02728081f, 0.03056757f, -0.00665171f, 0.00137508f, -0.04463109f, 
    -0.00328353f, 0.01982807f, -0.01060965f, -0.01318445f, -0.04160709f, 0.01405469f, 0.02199837f, -0.02653354f, 
    0.02273070f, 0.00471794f, 0.01223443f, 0.03236378f, -0.03201092f, -0.00128694f, -0.04344409f, -0.03391769f, 
    -0.03338327f, 0.01609821f, -0.00637530f, -0.03268141f, 0.00091875f, 0.00791030f, 0.01918641f, -0.00685400f, 
    -0.01931121f, -0.04313890f, -0.03482584f, 0.02509958f, 0.02716226f, -0.02110360f, 0.01682956f, -0.02995722f, 
    0.02727939f, -0.01303263f, 0.00258136f, -0.01614305f, -0.04113030f, -0.03396225f, 0.02381788f, 0.03135160f, 
    -0.02797776f, -0.03490539f, -0.00983580f, -0.03722728f, 0.00327606f, 0.01434192f, 0.02828911f, -0.01518010f, 
    -0.03852062f, 0.00820401f, -0.03316205f, 0.03007940f, -0.02188060f, 0.00098081f, -0.00297223f, -0.03438887f, 
    -0.01905185f, 0.02747019f, -0.00796545f, -0.04376150f, -0.03596894f, 0.03084964f, -0.00009345f, -0.03295254f, 
    0.02636770f, -0.02884415f, 0.00723245f, -0.02238611f, 0.01820701f, 0.00157404f, -0.04172685f, -0.02463759f, 
    0.00028784f, -0.00707295f, 0.02256954f, 0.02401532f, -0.03664150f, 0.03849033f, -0.00348170f, -0.00083488f, 
    -0.04438702f, -0.02461422f, -0.03463854f, -0.02351916f, -0.02795630f, 0.01371722f, -0.03610466f, 0.00190071f, 
    0.00391962f, 0.00993441f, 0.01597759f, -0.01379787f, 0.01688471f, 0.01847514f, -0.00459664f, -0.04218933f, 
    0.03342330f, 0.00003252f, 0.02483313f, 0.01911309f, 0.00081439f, -0.02495127f, 0.03172473f, -0.00505591f, 
    -0.00945698f, 0.02636684f, 0.01023145f, -0.02196609f, 0.02694350f, 0.00012594f, -0.04035127f, -0.02038166f, 
    -0.02171490f, -0.03220794f, -0.00003832f, 0.01334144f, -0.03599293f, 0.03226541f, -0.01416575f, -0.00643157f, 
    -0.03996302f, 0.00264778f, -0.03021799f, 0.00336338f, -0.00479009f, 0.03039315f, -0.00374586f, 0.00078284f, 
    -0.02564799f, -0.02218603f, 0.03641176f, -0.01992989f, -0.03110488f, 0.00023467f, -0.02337129f, 0.00761202f, 
    -0.02686717f, 0.00223742f, 0.02936571f, -0.01877969f, -0.04322646f, -0.02340482f, 0.02156270f, 0.01153516f, 
    0.03393474f, 0.00647385f, -0.03492207f, -0.03542898f, -0.03199426f, 0.02781800f, -0.02596663f, -0.02197308f, 
    0.01026233f, -0.00321989f, -0.03341586f, -0.00636165f, 0.00547007f, -0.03635045f, 0.01083913f, 0.00542091f, 
    -0.02166169f, -0.00449513f, -0.01297796f, -0.03907964f, -0.03323579f, -0.00876480f, -0.01401446f, 0.00821939f, 
    0.02473730f, -0.03123673f, -0.02556374f, 0.01211969f, -0.00696318f, 0.00271398f, -0.03136259f, 0.03840360f, 
    0.01325200f, -0.00755334f, -0.03739202f, 0.02255933f, -0.00643793f, -0.03774774f, 0.02097946f, -0.03915466f, 
    -0.04176006f, 0.03112372f, -0.04280339f, -0.04066730f, 0.00109902f, 0.02526251f, 0.01075343f, -0.03588289f, 
    -0.03445455f, -0.04432381f, -0.02563745f, -0.01974178f, -0.04016460f, -0.02204924f, -0.02324937f, -0.01653076f, 
    0.03189810f, -0.02670311f, 0.03083478f, -0.03134420f, 0.01913819f, -0.03516317f, 0.03030269f, -0.02146583f, 
    -0.02852738f, -0.02478478f, -0.01538912f, 0.02030134f, 0.02075973f, 0.00355498f, -0.00607134f, -0.02751436f, 
    -0.02941072f, -0.01884484f, 0.01289184f, -0.00092931f, 0.02759193f, 0.01159288f, -0.00690541f, -0.00886601f, 
    0.00455127f, 0.00160087f, 0.00310780f, 0.00161331f, -0.03616491f, 0.00254595f, -0.03430504f, 0.00504039f, 
    -0.00603997f, -0.02355844f, -0.01585109f, -0.00564290f, -0.02947859f, -0.00191495f, -0.02893676f, -0.03716734f, 
    -0.02903120f, -0.00011866f, -0.02221148f, 0.02158151f, -0.00522958f, -0.00210607f, 0.00627702f, -0.02753449f, 
    -0.01310338f, -0.02270767f, -0.03644185f, 0.02412357f, -0.02671300f, 0.00979010f, 0.00719918f, 0.01919447f, 
    -0.02091387f, 0.02700560f, -0.04446228f, 0.02869678f, 0.02473479f, 0.02048803f, -0.03529641f, -0.00644158f, 
    0.01533908f, -0.02177384f, -0.01765828f, -0.04290456f, -0.00345652f, -0.02602187f, 0.00266942f, -0.02153682f, 
    0.01424564f, 0.00304853f, 0.00702722f, 0.00374055f, -0.02879157f, -0.00096398f, -0.03394886f, -0.02580775f, 
    0.02340750f, -0.02210829f, 0.02618326f, 0.02765050f, -0.01156983f, 0.03208466f, -0.04477676f, -0.02853385f, 
    -0.02842371f, -0.03242255f, -0.04361756f, -0.03300663f, 0.01175513f, -0.01854683f, -0.02019237f, -0.01761611f, 
    -0.04198163f, 0.01691302f, -0.01032040f, 0.03369397f, 0.03350453f, -0.00749982f, -0.01273489f, -0.00829294f, 
    -0.03896350f, 0.02146051f, -0.04371208f, 0.00110038f, -0.00467653f, -0.03901561f, -0.02810208f, 0.03404826f, 
    -0.00391777f, -0.00791577f, 0.01625696f, 0.03013489f, 0.00531054f, 0.02237709f, 0.03170781f, -0.03909706f, 
    0.01992921f, 0.01239897f, -0.01438455f, 0.02431917f, 0.02649345f, -0.01473741f, 0.00313513f, 0.03403749f, 
    -0.00560504f, -0.01112070f, 0.02729892f, -0.01587733f, 0.03019197f, 0.03285760f, 0.01954350f, -0.00535958f, 
    -0.01047214f, -0.02920886f, -0.02427649f, -0.01151406f, 0.02678312f, 0.03933887f, 0.02678241f, -0.02589685f, 
    -0.04425149f, 0.01339658f, 0.01382833f, 0.01926717f, 0.02385629f, -0.00136995f, -0.03108996f, 0.02590462f, 
    -0.01048815f, -0.01263868f, 0.01728377f, -0.02769149f, 0.01324420f, -0.00075632f, 0.00429366f, -0.00376304f, 
    0.00272090f, 0.02344086f, -0.03380140f, 0.02270194f, -0.00188539f, 0.01738042f, 0.00952818f, 0.01463602f, 
    -0.02675422f, -0.00449310f, -0.01152699f, 0.03359284f, 0.01714819f, -0.03993051f, -0.02887131f, 0.02086067f, 
    0.02622169f, -0.04377901f, 0.01128534f, -0.00445042f, 0.01763120f, -0.00299675f, 0.02309422f, -0.01357154f, 
    -0.03057361f, -0.03110442f, 0.01250985f, -0.02997133f, -0.02758800f, 0.01869050f, -0.02746608f, -0.01397734f, 
    0.00631496f, 0.01270814f, 0.01300186f, -0.04156851f, -0.01735076f, 0.00628054f, 0.00865284f, -0.03654023f, 
    -0.02543074f, -0.01939867f, -0.01440830f, 0.00129453f, -0.01694432f, -0.00949049f, -0.02095971f, -0.03786071f, 
    0.01367770f, 0.03320040f, -0.02272050f, -0.02915391f, -0.00933551f, -0.02642181f, -0.03563006f, 0.01822809f, 
    -0.00902599f, 0.01035220f, 0.00490622f, -0.00956487f, 0.02454329f, 0.01247057f, -0.00726551f, 0.00602670f, 
    0.01908467f, -0.03380520f, 0.01690941f, -0.04044536f, -0.00586959f, -0.03093696f, 0.01147817f, -0.01177256f, 
    -0.03558433f, -0.01260577f, -0.00470212f, -0.01966340f, -0.00212453f, 0.01274309f, 0.03264329f, 0.03051999f, 
    -0.02914168f, -0.04028491f, -0.04121646f, -0.02026795f, -0.03433486f, 0.00339989f, -0.01401932f, -0.01461264f, 
    0.00198710f, -0.01525818f, -0.01590013f, -0.01275408f, 0.02933351f, -0.04023906f, 0.00052992f, 0.02706437f, 
    0.01567875f, -0.01221456f, 0.00347429f, 0.01282048f, -0.01075150f, 0.03184468f, -0.01081895f, -0.01744581f, 
    -0.04334154f, -0.00242758f, -0.01284632f, 0.00499740f, -0.02372114f, 0.03327560f, -0.02809115f, 0.01530530f, 
    -0.00500602f, -0.01715371f, -0.03433800f, 0.03003883f, -0.04145579f, 0.00943612f, -0.02962441f, -0.03175224f, 
    -0.02283056f, -0.03138848f, 0.00632642f, -0.03944897f, -0.02983232f, -0.01085920f, -0.02354792f, -0.04390100f, 
    -0.02420932f, -0.03078573f, 0.03103653f, 0.01741770f, -0.01865103f, -0.02495832f, -0.00272188f, -0.03969892f, 
    0.02426887f, 0.03240223f, -0.01818595f, 0.03311961f, -0.01242344f, -0.03276776f, 0.01133143f, 0.03367953f, 
    -0.02617729f, -0.02675495f, -0.00976589f, 0.01819841f, 0.01010114f, 0.00058980f, 0.01289920f, 0.02820652f, 
    0.03864957f, 0.02945915f, -0.01672336f, -0.03422990f, -0.00164693f, 0.00495223f, 0.00550256f, 0.01399834f, 
    0.00118340f, -0.01221272f, -0.03826149f, -0.02714829f, -0.01552764f, 0.00851152f, 0.01162099f, -0.00195545f, 
    -0.03940770f, -0.04166655f, 0.01862208f, 0.01825439f, -0.04236720f, -0.02414669f, -0.04168692f, 0.00015400f, 
    0.01481200f, -0.02248799f, 0.01058876f, -0.02418697f, -0.03912923f, 0.03337792f, -0.00433616f, 0.02962719f, 
    -0.02889732f, 0.00746204f, -0.03028854f, -0.03144336f, -0.00369694f, -0.01861318f, 0.01640561f, -0.03558503f, 
    0.03346568f, 0.01583894f, -0.03921752f, 0.01426284f, -0.01390952f, 0.03300837f, -0.01355657f, 0.03418290f, 
    -0.00185369f, -0.02512160f, -0.01082501f, -0.03663152f, 0.00077214f, -0.03923218f, -0.01178826f, 0.00878063f, 
    0.03195022f, -0.03535493f, -0.02351533f, 0.02024375f, -0.01385838f, -0.02912945f, 0.00431018f, 0.03129204f, 
    -0.03944012f, 0.00956370f, -0.00565275f, 0.02924531f, -0.01642088f, -0.01162008f, -0.01657987f, -0.02128398f, 
    -0.09785309f, -0.08283948f, -0.06197360f, -0.03210110f, 0.02612209f, 0.08336369f, -0.00698294f, 0.02776505f, 
    0.11285574f, 0.04610215f, 0.05213693f, 0.10149067f, 0.06645365f, 0.01905799f, -0.01295704f, 0.06791580f, 
    -0.04154620f, -0.01182218f, -0.05716884f, -0.00354916f, -0.00836531f, -0.06918064f, -0.08548468f, -0.04430095f, 
    0.21135013f, -0.04030827f, -0.05985441f, -0.09760221f, -0.09349932f, 0.00372262f, -0.08672494f, 0.01963387f, 
    -0.06777932f, -0.05147460f, 0.03247367f, 0.06258107f, 0.01985025f, 0.14142290f, 0.03239670f, 0.02452242f, 
    0.33948761f, -0.14408106f, -0.05464190f, 0.03231472f, -0.18472025f, -0.08451492f, -0.00161675f, -0.16602959f, 
    0.10218399f, 0.11346228f, 0.01192189f, 0.04825042f, 0.03613538f, -0.02498011f, 0.08879317f, -0.21154776f, 
    -0.00379717f, 0.00382076f, -0.09134975f, -0.01818816f, -0.16611946f, -0.09804730f, 0.10197398f, 0.04401394f, 
    -0.03876384f, 0.24345942f, 0.13785452f, -0.01976812f, 0.12558326f, 0.04405987f, -0.05350657f, 0.07496028f, 
    -0.02839217f, 0.03645982f, 0.02545936f, 0.06288443f, -0.05767761f, 0.23432265f, -0.13347332f, 0.00100757f, 
    0.14667436f, -0.22564015f, -0.00075734f, 0.17923978f, 0.10453093f, 0.06437797f, -0.15058599f, 0.04685608f, 
    0.23500523f, -0.04814067f, -0.02556005f, 0.00668568f, 0.08009016f, -0.01371685f, -0.01493499f, -0.01476903f, 
    -0.08916938f, -0.08117037f, -0.15282638f, 0.00960767f, 0.04511351f, -0.24227297f, 0.03531688f, -0.10776843f, 
    0.02889231f, -0.00848070f, 0.05376988f, 0.03433669f, -0.02326324f, -0.09633332f, 0.08338442f, -0.08662096f, 
    0.00485281f, -0.02029008f, -0.00633497f, 0.05758145f, 0.07848848f, 0.01761148f, -0.06509195f, -0.00569755f, 
    -0.09307954f, 0.16072790f, 0.17145716f, -0.18400708f, -0.28313059f, 0.18606476f, 0.08809546f, 0.01216938f, 
    0.00227927f, -0.02904185f, -0.05450976f, -0.01589020f, -0.05345894f, 0.04332224f, -0.22287323f, -0.03593757f, 
    -0.02341246f, 0.01420102f, -0.06237803f, -0.05204627f, 0.28820074f, 0.15426311f, -0.11233155f, 0.08094523f, 
    -0.09769313f, -0.10441155f, -0.12784915f, -0.00488041f, -0.07370044f, 0.04672929f, -0.08325342f, -0.05026777f, 
    0.03391700f, 0.10002062f, 0.08603076f, -0.08324136f, 0.02642080f, 0.07528397f, -0.00166836f, 0.06721069f, 
    0.17572200f, 0.04527055f, 0.06868501f, -0.12219606f, 0.20412554f, 0.07647411f, 0.05329653f, -0.00175228f, 
    0.01198154f, 0.06594916f, -0.01870016f, 0.02976942f, -0.08427396f, -0.04612966f, 0.06581121f, 0.05165297f, 
    -0.04009131f, 0.12946254f, 0.09186500f, 0.00744120f, 0.19730519f, -0.12339818f, -0.01810655f, 0.05730605f, 
    -0.14558640f, -0.02150843f, -0.07163025f, 0.02423554f, -0.01197102f, -0.03154207f, 0.04728664f, 0.09285848f, 
    0.04507009f, 0.09883166f, -0.03801720f, 0.04280191f, -0.04696883f, -0.02914664f, -0.15989985f, -0.10064875f, 
    -0.03466640f, 0.18580878f, -0.06333341f, -0.29932532f, -0.22484629f, -0.12765068f, 0.16435306f, 0.18124418f, 
    0.05452680f, 0.06296258f, -0.09500188f, -0.08693261f, 0.00723017f, -0.05640412f, 0.04410226f, 0.02097172f, 
    0.00288090f, -0.07096007f, 0.09300905f, 0.12228481f, 0.57496721f, -0.22713608f, -0.17141604f, 0.07042129f, 
    0.11847746f, -0.08824256f, -0.06355410f, 0.01414461f, -0.05199722f, 0.10804854f, -0.07876937f, 0.04841470f, 
    0.10000341f, -0.03597116f, -0.06138645f, 0.09068989f, -0.01984341f, -0.00336649f, -0.02234139f, 0.04993559f, 
    0.41017079f, -0.41085386f, -0.08304737f, 0.01997172f, -0.15567859f, 0.03728768f, -0.02182361f, -0.03686246f, 
    -0.06087883f, -0.06990491f, -0.00827917f, -0.05922990f, 0.05352244f, -0.07314454f, 0.07275095f, -0.10175941f, 
    0.00356749f, 0.03498479f, -0.01920197f, 0.07475677f, -0.31875631f, -0.07744280f, 0.16506103f, -0.00767013f, 
    0.12874210f, -0.00000704f, 0.01268696f, -0.03487466f, 0.07677194f, -0.10062614f, 0.03255069f, 0.08033016f, 
    0.01307821f, 0.04019756f, 0.06646325f, -0.08977891f, 0.03031253f, 0.01857167f, -0.13640071f, -0.01324596f, 
    -0.20951334f, -0.04993061f, 0.00234835f, 0.09184903f, -0.12089639f, 0.09370010f, 0.01377480f, -0.02278795f, 
    0.01131033f, -0.03205294f, 0.00658491f, -0.03126738f, 0.00081647f, 0.04623565f, -0.03198890f, -0.05851475f, 
    0.04379409f, -0.04683133f, -0.10262482f, -0.09867650f, -0.01644346f, 0.08466958f, 0.03834776f, -0.16382797f, 
    -0.27739263f, 0.14909415f, 0.03904505f, 0.08560590f, 0.04232626f, 0.02214460f, -0.04216400f, 0.04735813f, 
    -0.04731847f, -0.06664409f, -0.07953513f, -0.04798153f, 0.02042200f, -0.06959509f, 0.01652054f, 0.00426251f, 
    -0.44514066f, 0.18352900f, -0.04477648f, 0.12776905f, -0.20881887f, 0.01346681f, 0.05295742f, 0.00745778f, 
    0.02672615f, -0.00146640f, 0.04670523f, -0.04575393f, -0.02771065f, 0.04818613f, -0.02827472f, 0.06585743f, 
    -0.10272324f, 0.02634083f, -0.03808180f, 0.03702930f, 0.60183418f, -0.22168843f, 0.00644285f, 0.05842591f, 
    -0.03625958f, -0.04841857f, 0.04635839f, 0.02811665f, -0.07137468f, 0.10971804f, -0.05952846f, -0.00483403f, 
    -0.03251412f, -0.06262081f, 0.05459762f, -0.00275644f, 0.01520495f, -0.04184932f, -0.02540785f, 0.05994229f, 
    -0.00821733f, -0.04366856f, -0.03850158f, 0.05258423f, -0.18363790f, 0.12273798f, -0.07510661f, 0.05521385f, 
    -0.02432695f, -0.01359351f, -0.04336350f, -0.01822321f, 0.03256020f, 0.06903080f, 0.13270935f, 0.16355830f, 
    -0.04568768f, 0.01386337f, 0.15380904f, -0.08754079f, -0.03777829f, 0.09626569f, -0.03285994f, -0.07993630f, 
    -0.08676806f, -0.03407664f, -0.06738709f, -0.07465470f, -0.03167761f, 0.03112279f, -0.00520533f, 0.01707553f, 
    -0.01638442f, -0.03659913f, -0.16251722f, -0.05435956f, -0.02818726f, 0.04939019f, -0.09217250f, 0.00831325f, 
    0.06631683f, -0.13683714f, 0.03067083f, 0.06865790f, 0.08134835f, -0.04221435f, 0.03936714f, 0.00848085f, 
    0.02460776f, 0.14416125f, 0.00789188f, 0.03540188f, -0.04692833f, -0.03748942f, -0.00771892f, 0.13228570f, 
    0.17264381f, 0.01510138f, 0.09855497f, 0.08380035f, 0.44092894f, -0.11374078f, 0.16883132f, 0.25773990f, 
    0.11918747f, 0.07774077f, -0.01539359f, 0.08955283f, 0.06703024f, -0.07000491f, -0.01455845f, -0.00131557f, 
    -0.09543566f, 0.11747874f, 0.01956672f, 0.03779124f, 0.04923728f, -0.03762465f, 0.20530942f, 0.00491976f, 
    0.41551563f, -0.24209169f, -0.24935444f, 0.09377055f, 0.07300974f, 0.01872608f, -0.05147059f, -0.05035253f, 
    -0.04521292f, 0.04928805f, -0.03221170f, 0.15112023f, 0.01789509f, -0.01689212f, -0.02069193f, 0.07990326f, 
    -0.06874821f, 0.01612650f, -0.04087754f, 0.05172318f, -0.02315263f, -0.48746532f, -0.12571472f, -0.00420223f, 
    0.24300352f, 0.02734566f, 0.07473259f, -0.10665189f, 0.00542275f, 0.04693322f, 0.01875963f, -0.02832883f, 
    0.02964454f, 0.06550304f, 0.02693101f, 0.05772952f, -0.08997469f, 0.00307103f, -0.03681082f, 0.04373023f, 
    0.07679795f, 0.24259563f, 0.05640552f, -0.25476125f, -0.17953686f, 0.03681974f, 0.07209773f, 0.15254776f, 
    0.08100070f, 0.03481826f, 0.00860825f, 0.00941821f, 0.03677880f, -0.03621253f, -0.07675798f, 0.10721982f, 
    0.04599386f, -0.00848590f, -0.08814071f, -0.05272799f, 0.72160631f, -0.33931398f, -0.09829150f, -0.14790432f, 
    -0.01595538f, 0.03281701f, 0.00396895f, -0.05448999f, 0.04863004f, 0.02920307f, -0.06435715f, -0.01015028f, 
    0.03684222f, 0.13217033f, 0.00162244f, 0.02440767f, -0.03763565f, -0.02340417f, -0.09911279f, -0.02330540f, 
    0.33963445f, -0.03315083f, 0.00511081f, -0.07151209f, 0.00907562f, -0.11568537f, -0.03096101f, 0.00032472f, 
    -0.07067469f, 0.02251223f, 0.00421429f, -0.08392826f, 0.07929444f, 0.08056431f, 0.02891321f, 0.02098651f, 
    -0.04362689f, -0.01536891f, 0.05206469f, 0.12372176f, 0.20131359f, -0.03089255f, 0.13666160f, 0.13895938f, 
    0.38146427f, 0.01421015f, -0.00483053f, 0.20137808f, 0.10786901f, 0.06909275f, -0.09109376f, -0.06282678f, 
    -0.01375629f, 0.00211747f, 0.09227037f, 0.09968796f, 0.05400756f, 0.07746743f, 0.05366909f, 0.09185326f, 
    0.12390426f, 0.28034759f, -0.04617064f, -0.02562301f, -0.08916120f, 0.03591393f, 0.09010877f, -0.00834130f, 
    0.06483334f, -0.04641536f, 0.01516611f, -0.01273009f, -0.05830972f, -0.07261458f, -0.12893073f, -0.08916947f, 
    0.06544815f, 0.05164215f, 0.21647778f, 0.03649725f, 0.09055612f, -0.30050102f, -0.12798488f, -0.00555451f, 
    0.08217322f, -0.10809086f, 0.02397128f, 0.03045130f, 0.21653514f, -0.02677711f, -0.07476735f, -0.00038997f, 
    0.08856145f, 0.04795588f, -0.00299017f, 0.07838152f, 0.03962663f, 0.11336282f, -0.01224231f, 0.00376494f, 
    0.32351089f, -0.21023984f, -0.10980006f, 0.04595687f, -0.11274208f, 0.06480782f, 0.03651337f, -0.01291791f, 
    -0.03460957f, 0.18891673f, -0.01636092f, 0.12104044f, 0.08808563f, 0.14963810f, 0.08552007f, 0.01831912f, 
    0.06465511f, -0.08953431f, -0.01637733f, -0.05512839f, -0.00134673f, 0.15969840f, 0.04504053f, -0.09129975f, 
    -0.05044154f, 0.01839441f, 0.07689112f, 0.04171747f, -0.09228191f, -0.01106424f, -0.00552693f, -0.06114386f, 
    -0.00113928f, -0.09039477f, -0.12639911f, 0.06433655f, 0.01796034f, -0.06242194f, 0.23431732f, 0.03090678f, 
    -0.00399625f, -0.03842551f, 0.03070967f, -0.01243475f, -0.03360059f, 0.00428178f, -0.00611185f, -0.01545307f, 
    -0.00607523f, -0.01260965f, 0.02871239f, -0.00481551f, -0.04071252f, 0.00637488f, 0.00081971f, -0.00873608f, 
    0.00869746f, 0.00196101f, -0.03099316f, -0.01851314f, 0.00793993f, 0.00099090f, 0.03127154f, 0.02791123f, 
    -0.00165401f, -0.02640699f, 0.02301594f, 0.00604227f, 0.02955539f, -0.00585151f, -0.01409343f, -0.03394549f, 
    0.03082024f, 0.03007212f, -0.03992208f, -0.01618700f, 0.00406938f, 0.00319943f, -0.01375603f, -0.01749639f, 
    0.00942504f, 0.02112453f, -0.01381687f, 0.01298456f, -0.01377878f, -0.01311673f, 0.01367069f, 0.00937478f, 
    0.00944950f, -0.00674426f, 0.01845033f, 0.00490519f, -0.02176901f, -0.03133897f, 0.01634496f, -0.00567546f, 
    -0.04713035f, -0.02361308f, -0.00574633f, -0.01844917f, 0.02207249f, -0.03563650f, -0.04442419f, 0.01419862f, 
    0.02756782f, 0.02914634f, -0.01813734f, -0.04245704f, -0.04241544f, 0.02914145f, -0.00016717f, -0.00578653f, 
    0.01723353f, -0.02320402f, -0.01250859f, -0.00246788f, -0.03636758f, -0.00461999f, -0.03959545f, 0.02147078f, 
    0.01974996f, 0.01321133f, -0.00918404f, -0.02971998f, -0.04591515f, -0.01981611f, -0.04304826f, 0.00455368f, 
    -0.02295593f, -0.00583224f, -0.01672110f, -0.02353916f, 0.02165183f, -0.02744096f, 0.02209865f, -0.00461262f, 
    -0.01544193f, 0.03266495f, -0.00762794f, -0.02447961f, -0.04233478f, 0.02040086f, -0.04502506f, -0.00178014f, 
    -0.01293868f, -0.01510480f, -0.02813345f, 0.01382110f, 0.00218107f, 0.00461873f, -0.02193217f, 0.02634154f, 
    0.00418010f, -0.00004613f, -0.03104647f, -0.02566639f, 0.00887969f, -0.03160824f, -0.04561456f, 0.02125118f, 
    -0.02776266f, -0.03993959f, 0.02928317f, 0.02272923f, 0.01943115f, 0.03055404f, -0.00484830f, -0.00292595f, 
    0.00968733f, 0.00106871f, -0.03192719f, 0.00988015f, 0.02425906f, 0.00063577f, 0.04362934f, -0.00754810f, 
    -0.00970459f, -0.02681133f, -0.04493400f, -0.01364027f, 0.01699919f, -0.02088304f, -0.01512440f, 0.01928151f, 
    0.02378489f, 0.04043032f, -0.02578448f, -0.03212745f, -0.01533013f, 0.02796893f, -0.01785709f, -0.02170183f, 
    0.02915546f, 0.00290739f, -0.00678036f, -0.00628459f, -0.00202291f, -0.03595939f, -0.00144377f, -0.03537338f, 
    -0.01676136f, 0.02457651f, 0.03000798f, 0.02184288f, -0.02416195f, 0.02250141f, 0.03294000f, 0.02133418f, 
    0.01940292f, 0.01968188f, 0.03432436f, 0.02694911f, -0.04501252f, -0.03181532f, 0.00154351f, -0.04257762f, 
    -0.02246077f, 0.02338761f, 0.01713669f, 0.02595874f, 0.02082116f, -0.00601366f, -0.03866491f, -0.01179277f, 
    -0.01019777f, -0.00007451f, -0.03799875f, -0.03365890f, 0.01103125f, -0.04234514f, -0.01726698f, -0.01812511f, 
    0.01451103f, -0.01768094f, -0.00908716f, 0.02209060f, 0.02839881f, -0.01905792f, 0.00756621f, -0.03524315f, 
    -0.01907346f, 0.01906488f, -0.03448980f, -0.03141317f, -0.02724336f, -0.01188516f, -0.00763430f, 0.00479269f, 
    -0.02589872f, -0.01994330f, -0.02247495f, 0.02480424f, 0.01562428f, 0.02276757f, -0.00309153f, -0.02616847f, 
    0.00196379f, 0.03008112f, -0.02319564f, -0.03837166f, 0.03088817f, 0.00702648f, -0.04019285f, -0.00423546f, 
    0.04386823f, -0.01229232f, 0.02462733f, 0.03271448f, 0.02728486f, -0.00443038f, 0.00772315f, 0.02455038f, 
    -0.00350346f, -0.00689132f, 0.00518553f, -0.04508335f, -0.00804791f, -0.04607114f, -0.04653503f, 0.01983727f, 
    0.01993059f, 0.02907441f, 0.01982665f, -0.00094445f, -0.01881867f, -0.04044834f, -0.03073303f, 0.00515924f, 
    -0.03468542f, -0.01531894f, -0.01351095f, -0.01024720f, -0.03388847f, -0.02453601f, -0.01179081f, -0.00354955f, 
    -0.02839023f, 0.01037561f, -0.01247100f, -0.02558449f, -0.00344697f, 0.01936707f, -0.03717158f, 0.02220012f, 
    -0.03553950f, -0.00227790f, -0.04474260f, -0.03222261f, 0.01951175f, -0.01599012f, -0.04089836f, 0.01468258f, 
    -0.04046869f, -0.03766632f, 0.00545091f, -0.01918957f, 0.00573720f, -0.01063843f, -0.04407716f, 0.01808212f, 
    -0.01710784f, -0.01297992f, -0.04052602f, -0.00694659f, 0.01818871f, 0.02604473f, 0.01670835f, 0.00098005f, 
    -0.02411390f, -0.02887631f, 0.00766149f, 0.00570767f, -0.03290537f, -0.04393902f, -0.00148257f, -0.00819130f, 
    -0.03178616f, -0.00876605f, -0.04275869f, -0.03120561f, -0.04153324f, -0.00230236f, -0.00233184f, 0.03936379f, 
    0.02793762f, 0.02553657f, -0.02271243f, -0.01085982f, -0.02973912f, 0.03179444f, 0.02970675f, 0.00356446f, 
    0.03122176f, 0.02900570f, -0.04223101f, 0.00533189f, -0.03206692f, -0.03046625f, -0.00397295f, -0.02240935f, 
    -0.02152864f, 0.01606762f, -0.04044544f, -0.01943346f, -0.02482199f, 0.00368823f, 0.03458888f, -0.01605531f, 
    -0.01145063f, 0.03259498f, 0.00499438f, 0.00779667f, -0.02854123f, -0.03927746f, -0.04304156f, -0.04271491f, 
    0.01254756f, -0.03991074f, 0.00668554f, 0.02396139f, 0.00749806f, 0.03108546f, -0.03678550f, 0.00511377f, 
    -0.01903914f, -0.02682250f, -0.02221686f, 0.01606759f, -0.00753805f, 0.01195394f, -0.01723965f, 0.03351917f, 
    -0.04381460f, 0.02163926f, 0.01456495f, -0.03849109f, -0.04588803f, -0.02926128f, 0.00527370f, -0.03856342f, 
    -0.04007816f, 0.01435078f, 0.03248457f, 0.02548579f, -0.04147229f, -0.01883520f, -0.03872591f, 0.02032011f, 
    0.01101937f, -0.03980417f, 0.03020769f, -0.01733725f, -0.03204750f, 0.01051612f, 0.01115018f, -0.00530694f, 
    -0.01648089f, -0.02134711f, -0.01577686f, 0.02715328f, -0.00614280f, 0.01315645f, -0.01445666f, -0.00307811f, 
    0.02439357f, 0.01405035f, -0.03929231f, 0.00247659f, -0.02683702f, -0.03764668f, 0.00228274f, -0.00960824f, 
    0.00424035f, 0.01255445f, 0.03121288f, -0.02991257f, 0.02512499f, -0.00425349f, -0.01851222f, 0.02716085f, 
    -0.03637574f, -0.03665235f, -0.04646814f, 0.00008904f, -0.03143642f, -0.04342044f, 0.00665589f, -0.02165069f, 
    -0.02189703f, -0.03341005f, 0.03088166f, 0.01561953f, 0.01814299f, 0.02228107f, -0.00547863f, -0.01895195f, 
    0.00819613f, -0.00577276f, -0.00262641f, -0.00745571f, -0.03040400f, -0.03172241f, 0.02983168f, -0.00439435f, 
    0.00643609f, 0.02500489f, 0.02279196f, -0.02918415f, -0.02212057f, -0.01683944f, 0.02668792f, -0.04179218f, 
    0.00003080f, 0.00203002f, -0.00954642f, 0.02005916f, 0.02909326f, -0.01292076f, 0.02934568f, 0.01855022f, 
    0.01036984f, -0.03463371f, -0.02931136f, 0.04194141f, 0.00707561f, 0.02449062f, -0.04167008f, 0.02126834f, 
    -0.01154015f, -0.01116444f, 0.02178455f, -0.01378663f, -0.04369798f, -0.01030446f, 0.00953576f, 0.00654864f, 
    0.03437316f, -0.03701464f, -0.03651226f, -0.03485817f, 0.02828922f, 0.00853804f, -0.00961149f, 0.00846553f, 
    -0.04623937f, -0.00479261f, -0.01631325f, -0.02236757f, -0.03405524f, -0.04339253f, 0.01125506f, 0.03099745f, 
    -0.04111880f, -0.04782682f, 0.00166447f, -0.03214011f, 0.00509008f, -0.03845988f, 0.01001808f, -0.00209449f, 
    0.00466670f, -0.02029253f, 0.02575179f, 0.01699750f, 0.03800036f, 0.00185155f, -0.01474193f, 0.02040864f, 
    0.02603080f, -0.01020327f, -0.00138665f, -0.01960508f, 0.01230368f, 0.00255263f, 0.00888541f, 0.00307897f, 
    -0.00807465f, -0.03141944f, -0.03841288f, 0.00136261f, 0.02843926f, 0.00437105f, 0.00190724f, 0.00195352f, 
    -0.01744330f, 0.01766403f, -0.03402278f, -0.03953266f, -0.00415464f, 0.03798319f, 0.01978288f, -0.04569031f, 
    0.02498147f, -0.00995022f, 0.02713073f, -0.02736321f, 0.02403395f, -0.02630737f, 0.03153118f, 0.02237488f, 
    0.00047349f, 0.00581559f, -0.02891481f, 0.02691369f, 0.01808688f, -0.00599650f, 0.00502981f, -0.02095252f, 
    -0.03833304f, 0.00037103f, 0.01876331f, -0.00412662f, -0.02897377f, -0.00260174f, 0.00263027f, -0.00966838f, 
    0.01683119f, -0.03767513f, 0.02043774f, 0.02212408f, 0.00042842f, -0.04104882f, -0.01471804f, 0.02458262f, 
    -0.03908873f, -0.03895158f, -0.00918809f, 0.00940105f, 0.02656581f, -0.01899204f, 0.02367976f, 0.00909495f, 
    -0.03685702f, -0.02977044f, -0.04416027f, -0.00479574f, -0.02386706f, -0.02343202f, -0.01352102f, -0.04019427f, 
    0.01609747f, -0.00856433f, -0.00952434f, -0.03208145f, -0.04333376f, -0.03948328f, -0.02888526f, -0.03216577f, 
    -0.02374875f, 0.00292821f, -0.02408914f, -0.02254346f, -0.00418436f, -0.00095822f, -0.03246983f, -0.01070657f, 
    0.02565484f, 0.01519225f, 0.02068682f, 0.03772169f, 0.01884900f, 0.01969372f, 0.02110506f, 0.00742923f, 
    0.01017748f, 0.00403355f, -0.00100856f, -0.01020301f, 0.00924796f, 0.03103359f, 0.00070200f, 0.01384718f, 
    -0.00570170f, -0.00879656f, -0.03227588f, -0.03082279f, -0.03043900f, 0.00691167f, -0.02936897f, -0.00744271f, 
    -0.00083688f, 0.01191380f, 0.02468202f, 0.02147133f, 0.01431284f, 0.01346785f, -0.03476497f, -0.00176052f, 
    0.01581679f, 0.01006959f, -0.02318404f, -0.03721544f, -0.00699787f, 0.02904203f, -0.01040656f, 0.03042755f, 
    -0.03212169f, -0.04028063f, 0.00155154f, -0.03792656f, 0.00202532f, 0.01814215f, -0.02281087f, -0.00400362f, 
    -0.00612592f, -0.00154573f, -0.03676046f, 0.01460011f, -0.04189109f, 0.01772061f, -0.04469386f, -0.03096844f, 
    -0.03917129f, 0.02612977f, -0.04317079f, -0.03419983f, 0.03035565f, 0.02055863f, -0.01808212f, 0.02285233f, 
    -0.08600212f, 0.03238804f, 0.10733696f, 0.09549505f, 0.05021264f, -0.07771739f, 0.02304360f, -0.01237869f, 
    0.05676116f, -0.04137989f, 0.11425652f, 0.01388508f, 0.07998949f, -0.06409258f, 0.14661469f, 0.04824724f, 
    0.09145610f, -0.06717540f, 0.03996564f, 0.04492192f, -0.01664911f, 0.15331912f, 0.13167574f, -0.03556702f, 
    0.08719824f, 0.11023114f, -0.01819190f, 0.02837962f, 0.17969932f, -0.01496618f, 0.01358957f, 0.00223165f, 
    -0.02031729f, 0.01678300f, 0.05597366f, 0.00225878f, 0.12035960f, -0.04411993f, -0.01937754f, 0.03405808f, 
    0.22776043f, 0.10225710f, -0.00571249f, 0.00024835f, -0.16292699f, 0.03635360f, 0.09485555f, -0.04167393f, 
    0.03798766f, 0.07764141f, 0.15566757f, -0.02533907f, 0.03074849f, 0.02406962f, 0.01569298f, 0.03759906f, 
    0.12266387f, -0.01099888f, 0.08702015f, -0.03729307f, 0.42603129f, -0.33479705f, 0.16080146f, -0.21430567f, 
    0.08833653f, -0.04556725f, -0.04111534f, -0.06305923f, 0.14234006f, -0.06259080f, -0.13956392f, 0.05309443f, 
    0.01304825f, -0.05769766f, -0.02616321f, -0.10207737f, -0.09900361f, -0.17913601f, -0.02354487f, -0.11902599f, 
    0.31892374f, -0.20893660f, 0.10491378f, -0.17842382f, 0.19666462f, -0.25739741f, 0.00005039f, -0.15297745f, 
    -0.03839468f, -0.07842324f, 0.03238894f, 0.08888034f, -0.02459468f, 0.06777672f, -0.06919687f, -0.01153681f, 
    0.10807512f, 0.01309223f, -0.01437724f, 0.01051439f, -0.25994477f, 0.14232430f, -0.01619677f, -0.10528553f, 
    0.07611655f, 0.03700226f, 0.03650730f, -0.03954961f, 0.00232766f, -0.01756196f, -0.07343666f, -0.07627373f, 
    -0.07421925f, -0.03799481f, -0.09348995f, 0.04267350f, 0.02477540f, 0.05329739f, -0.07541599f, 0.05587149f, 
    -0.11366435f, 0.22993581f, -0.09141022f, -0.01507053f, 0.23690537f, -0.09795214f, -0.24753368f, 0.03770928f, 
    0.01927651f, 0.03310629f, 0.07231290f, 0.09243548f, 0.00148883f, 0.08457252f, -0.06984305f, 0.13946676f, 
    0.15230562f, -0.04266828f, -0.00340914f, 0.03509887f, 0.26219374f, 0.18588640f, 0.09559517f, 0.05930912f, 
    -0.13442203f, 0.19127661f, 0.02029119f, 0.00779886f, 0.17351213f, 0.12003225f, 0.05378797f, -0.05407667f, 
    0.09517397f, 0.08391500f, -0.13334908f, 0.05725214f, 0.17425936f, -0.08659024f, 0.06417682f, 0.01382193f, 
    0.18016458f, -0.30282861f, 0.14895974f, 0.17075041f, 0.09202398f, -0.01924128f, 0.15193547f, -0.00930823f, 
    0.14160658f, -0.01538193f, -0.08439068f, 0.01806544f, 0.00928608f, 0.03656855f, 0.02742447f, 0.00594492f, 
    0.02851330f, 0.05374946f, -0.01254504f, -0.07028869f, -0.09966175f, 0.28585145f, -0.14239198f, 0.01448707f, 
    0.12020113f, -0.00759316f, 0.02552342f, 0.04286708f, -0.07501151f, 0.08904687f, 0.14283760f, 0.00971778f, 
    0.02100305f, -0.12251041f, 0.01154002f, 0.08733052f, -0.01631891f, 0.15714663f, -0.01725432f, 0.02365929f, 
    0.19286712f, 0.00908964f, 0.04670478f, 0.34562045f, 0.05971239f, 0.01623685f, 0.05624928f, 0.05554340f, 
    -0.06091569f, 0.04439102f, -0.10329376f, -0.02744197f, -0.04117352f, -0.02472772f, -0.08105172f, -0.05987817f, 
    -0.15880945f, -0.10618617f, 0.04312640f, 0.08709767f, 0.07458542f, 0.03583988f, 0.18415706f, 0.07777148f, 
    -0.30166179f, 0.00999462f, 0.05813371f, 0.07966604f, 0.11603821f, 0.01200442f, 0.11384846f, 0.07343818f, 
    -0.01709938f, 0.01972351f, -0.01214783f, 0.01467546f, -0.03907318f, 0.05717223f, -0.13618904f, 0.13131781f, 
    0.15416151f, -0.02483184f, 0.11041903f, -0.11742444f, 0.05261887f, 0.06826411f, 0.10018661f, -0.01479658f, 
    0.00531769f, 0.03989169f, 0.04832293f, 0.03076439f, 0.06694017f, -0.01272808f, -0.08666536f, -0.01438898f, 
    0.06836111f, 0.05152556f, -0.00566102f, 0.05436851f, 0.16342854f, -0.10616139f, -0.18246125f, -0.01347818f, 
    0.13779409f, -0.14304869f, -0.07720306f, 0.03113970f, -0.03100116f, -0.08585329f, -0.00810121f, 0.05169980f, 
    -0.00821869f, -0.01510108f, 0.14224365f, -0.00372123f, 0.03097273f, 0.00630281f, -0.00863748f, 0.03290937f, 
    0.00549770f, 0.20403743f, 0.09466085f, -0.00673383f, 0.20988101f, -0.13970947f, 0.00112032f, -0.02325583f, 
    -0.01936811f, 0.06342897f, 0.00213173f, 0.00402595f, 0.05484734f, 0.10865524f, -0.02464729f, -0.02896427f, 
    0.11170460f, -0.00509429f, -0.02057719f, 0.00408305f, -0.11762620f, 0.18211621f, -0.07156517f, 0.10548880f, 
    0.11875999f, 0.00091778f, -0.16341120f, -0.00244830f, -0.03835325f, 0.07875937f, -0.04784274f, -0.02013182f, 
    -0.05084272f, 0.06092918f, -0.07196555f, 0.17600390f, 0.04292624f, -0.06954569f, 0.01207940f, 0.10616197f, 
    0.33728099f, 0.17815007f, 0.18314156f, -0.15570959f, 0.25647423f, -0.18509404f, -0.20617068f, -0.12647763f, 
    0.07566513f, 0.06968396f, 0.04557090f, -0.03476536f, 0.02865221f, 0.13001001f, -0.04056162f, 0.06105960f, 
    0.13200220f, -0.12059167f, 0.10971942f, -0.03254339f, 0.27409655f, 0.12541594f, 0.00323173f, 0.05322246f, 
    -0.02491705f, -0.03970435f, 0.09127595f, 0.14178357f, 0.05063815f, 0.07329182f, 0.04852662f, -0.05374997f, 
    -0.01178356f, 0.09743580f, 0.06632748f, 0.06821235f, -0.01752543f, 0.04492933f, -0.08028045f, -0.00382388f, 
    -0.05405864f, 0.00677012f, 0.00622047f, 0.13981888f, -0.06302226f, 0.00481425f, 0.01687972f, 0.06240045f, 
    -0.02889118f, 0.13081361f, 0.06538011f, 0.09896881f, -0.02581981f, -0.04454003f, 0.07723989f, 0.04330897f, 
    -0.04782677f, 0.00723205f, 0.13136131f, 0.12023669f, -0.44632706f, 0.07368257f, 0.20885921f, -0.09222303f, 
    0.15518503f, -0.32194754f, -0.09640835f, -0.02434238f, -0.09797475f, 0.10767019f, 0.04275459f, -0.00559777f, 
    0.06893714f, -0.07998318f, 0.00681943f, -0.05606451f, 0.06832209f, -0.00686692f, -0.04214338f, 0.11735472f, 
    0.21533762f, -0.06427471f, -0.09518665f, 0.04116604f, 0.18404354f, 0.02137685f, 0.14327106f, 0.08487446f, 
    0.04492665f, -0.05675363f, 0.06908573f, -0.06521764f, 0.01994162f, -0.06627454f, 0.05302278f, 0.09970438f, 
    -0.02609047f, 0.08798065f, -0.04224791f, -0.08160631f, 0.00014662f, -0.11760297f, -0.07630960f, -0.01236473f, 
    -0.06305638f, -0.06819581f, -0.07454566f, 0.05371186f, -0.01965061f, 0.06976203f, -0.02588441f, 0.03185385f, 
    0.04330359f, -0.00335421f, 0.05516522f, -0.03466034f, 0.00854259f, 0.04640728f, 0.11133096f, 0.00469916f, 
    0.17552975f, 0.18490075f, 0.12085821f, -0.03699774f, -0.20451200f, 0.07514915f, 0.07523969f, 0.07221917f, 
    0.15809365f, -0.00226609f, 0.02504481f, 0.10666737f, 0.01634695f, 0.00457275f, 0.00340071f, 0.00648977f, 
    0.04760179f, 0.01957924f, -0.01555072f, 0.02567750f, 0.05376776f, 0.21004353f, 0.06899130f, 0.01442469f, 
    0.20221168f, 0.02717195f, 0.06582675f, 0.03895377f, 0.01568171f, 0.10910634f, -0.01460210f, 0.14630361f, 
    0.04279431f, -0.06777047f, 0.01359753f, 0.12287277f, -0.16723092f, 0.04840114f, -0.01261902f, -0.04617398f, 
    -0.46220970f, -0.05482096f, 0.21830718f, 0.02481441f, 0.16800566f, -0.11346689f, -0.08384139f, 0.02963369f, 
    -0.01730980f, -0.00234564f, -0.05904325f, 0.11319555f, 0.16366886f, 0.10106182f, -0.06138428f, -0.02619185f, 
    -0.03313866f, 0.03158771f, 0.04665780f, 0.02001059f, 0.23118088f, -0.10291880f, 0.06158002f, 0.02596293f, 
    -0.21354836f, 0.08088357f, 0.26641753f, 0.00349769f, -0.04469113f, 0.00559985f, 0.19689596f, 0.08064051f, 
    0.07625269f, 0.07356431f, -0.08472750f, 0.09125096f, 0.18447860f, 0.04282859f, 0.01566293f, 0.07886626f, 
    0.14252913f, -0.07865030f, 0.10322663f, 0.17187117f, 0.07705019f, -0.00190784f, 0.03458950f, 0.01834405f, 
    0.16509522f, 0.06014069f, 0.01877712f, -0.04820589f, 0.04841572f, 0.01078282f, -0.10189387f, 0.00688588f, 
    -0.06756369f, 0.01019940f, 0.06455439f, -0.10100069f, 0.22821145f, -0.29324952f, 0.25072357f, -0.10537289f, 
    -0.02247438f, 0.01845932f, 0.24273790f, -0.01470418f, -0.01184877f, 0.04139682f, -0.04016770f, 0.05743570f, 
    0.00852322f, 0.00232886f, -0.07472187f, -0.04858682f, -0.08492868f, 0.01863224f, 0.07060567f, -0.00988224f, 
    -0.15276426f, -0.38651502f, 0.08368954f, 0.17783418f, -0.14820243f, -0.01313041f, 0.07503574f, 0.03398037f, 
    0.06808307f, -0.06675496f, 0.00514990f, 0.02473182f, -0.00428980f, 0.06182035f, -0.01551403f, -0.07360505f, 
    0.04070000f, -0.14482757f, -0.00817566f, 0.04736801f, 0.20592876f, 0.35006779f, -0.00952408f, -0.28707087f, 
    0.22515830f, 0.21960303f, -0.03312501f, 0.07786725f, -0.06066143f, 0.05239360f, 0.14568217f, 0.03447194f, 
    -0.03633815f, 0.02391003f, 0.27303299f, 0.00482094f, -0.08972009f, 0.03094754f, 0.00084746f, -0.06892153f, 
    -0.08545201f, 0.11651026f, -0.01072915f, 0.07421343f, -0.16085286f, 0.07211451f, 0.14677660f, -0.01192871f, 
    -0.02779965f, 0.04678404f, -0.02539130f, 0.07826108f, -0.07111777f, 0.02930836f, 0.09474766f, 0.01492497f, 
    0.08463333f, -0.01687903f, 0.05969047f, 0.10033007f, -0.03858803f, -0.04567694f, -0.12622198f, 0.11070824f, 
    -0.25285506f, 0.09161887f, 0.03092146f, -0.06793457f, -0.00226292f, 0.02723416f, -0.04774134f, -0.00081574f, 
    -0.12263629f, -0.01927948f, -0.05424869f, 0.02366029f, -0.08226309f, -0.03225901f, 0.05397952f, -0.00086044f, 
    0.07129651f, 0.00675711f, -0.00565988f, 0.03947749f, 0.04142694f, 0.06248825f, 0.01505008f, 0.06878621f, 
    -0.05974367f, 0.04348834f, 0.00565079f, -0.05720766f, -0.01471955f, 0.04552556f, -0.05250476f, 0.02592550f, 
    -0.06515957f, 0.00934358f, -0.00337338f, -0.03593890f, -0.21985748f, -0.02365836f, 0.25862157f, -0.03096095f, 
    0.19901055f, 0.10556550f, 0.24745250f, -0.10842058f, -0.00422487f, -0.02624982f, 0.03066536f, 0.06328592f, 
    -0.03015016f, 0.01945864f, 0.03440319f, 0.05773826f, -0.01029628f, 0.09413903f, 0.06832690f, 0.04763345f, 
    -0.17741086f, -0.07912726f, 0.17172587f, 0.17991266f, 0.23016925f, 0.05700022f, 0.18098545f, 0.00517744f, 
    0.11729606f, 0.06758367f, 0.05714827f, -0.01764077f, 0.04467686f, 0.03696590f, 0.06653461f, 0.00687821f, 
    -0.03997264f, 0.01339981f, 0.02449281f, 0.03228105f, -0.24492079f, 0.43988910f, -0.13630044f, 0.07660396f, 
    -0.12506595f, -0.04322187f, 0.06722306f, -0.06657501f, -0.00669632f, -0.00201945f, -0.07487583f, -0.01137388f, 
    0.03664403f, -0.00835898f, -0.17470714f, 0.10751328f, -0.00788748f, 0.13791841f, 0.05677948f, 0.03991152f, 
    -0.06434966f, 0.30549005f, 0.10135646f, 0.09878580f, -0.07388818f, 0.16769008f, 0.05866739f, 0.00798136f, 
    0.06495316f, 0.06580417f, 0.08960211f, -0.03967660f, 0.17344928f, -0.01249801f, 0.02668773f, 0.05403856f, 
    -0.00198943f, 0.04214920f, -0.03173750f, -0.02612407f, 0.63591784f, -0.32739621f, 0.11037754f, 0.19669892f, 
    -0.10708109f, 0.08175498f, -0.04070063f, 0.07512940f, -0.07119667f, 0.08663325f, 0.06843863f, 0.02986299f, 
    -0.05191603f, -0.01914390f, 0.03948188f, -0.03177002f, 0.02259372f, -0.05098106f, 0.04516784f, -0.08637227f, 
    0.20542391f, -0.10422898f, 0.37664872f, 0.12675507f, -0.25237766f, 0.13047561f, -0.04198390f, 0.01122333f, 
    -0.02564243f, 0.00007908f, -0.02372705f, -0.01353109f, -0.00702597f, -0.10370565f, -0.02124960f, -0.03167104f, 
    0.01932769f, 0.00590815f, 0.06434271f, -0.02123596f, -0.22468400f, -0.14626326f, 0.07943219f, 0.10634506f, 
    0.19244547f, 0.04218896f, 0.12700044f, 0.01309017f, -0.05842358f, -0.03440285f, 0.00543353f, 0.13473287f, 
    -0.03135283f, -0.07714617f, 0.01784121f, -0.00571687f, -0.09748836f, -0.04829615f, 0.07467388f, 0.03355570f, 
    -0.11317397f, 0.11184751f, -0.11267168f, -0.07945021f, -0.09280677f, -0.06514855f, 0.05621992f, -0.04226035f, 
    -0.01627081f, -0.02427845f, 0.01546754f, -0.04223914f, -0.03731936f, -0.03972370f, -0.01631384f, -0.08989795f, 
    0.03407551f, 0.05351713f, 0.05190521f, 0.09925102f, 0.43540418f, -0.18624327f, 0.14097737f, 0.19118606f, 
    0.02682593f, -0.02491336f, -0.09154671f, 0.11563947f, -0.03167990f, -0.05308000f, -0.01923118f, 0.06785370f, 
    -0.04634960f, 0.10282502f, -0.02209510f, 0.02327815f, 0.04827687f, -0.03752195f, -0.01281447f, 0.02606183f, 
    -0.05697540f, -0.07192186f, -0.34493431f, -0.08736888f, -0.02449522f, 0.00318731f, 0.01070708f, -0.07350540f, 
    0.03391159f, -0.10208071f, -0.01870231f, 0.05613645f, 0.08071504f, 0.05997016f, 0.00867536f, 0.04736455f, 
    0.08090169f, 0.05931086f, 0.04504859f, 0.01676937f, 0.03606570f, -0.01227868f, 0.25093666f, -0.25151554f, 
    0.16884887f, 0.14868431f, 0.18314703f, -0.08786372f, -0.03926549f, -0.08099123f, -0.09076132f, -0.01055762f, 
    0.10052319f, 0.09308042f, -0.02707511f, 0.04032197f, 0.04871610f, 0.10588133f, 0.00370026f, 0.02744537f, 
    0.05724544f, -0.10291664f, 0.10298765f, 0.15298125f, 0.10992665f, 0.03168174f, 0.12622918f, 0.03569950f, 
    -0.01687151f, 0.15118146f, 0.05158173f, -0.01044228f, 0.13241477f, 0.08724726f, 0.06998485f, -0.00580418f, 
    0.02802108f, 0.03205106f, 0.07480022f, -0.07894463f, 0.03340282f, 0.08309716f, 0.10663071f, 0.07259333f, 
    -0.01041440f, -0.04938621f, 0.00207831f, -0.05468316f, 0.05464218f, 0.06686760f, -0.08534583f, 0.05786864f, 
    0.08206764f, -0.03427857f, -0.00108082f, -0.01457759f, 0.00983621f, 0.02989349f, -0.01934117f, -0.07288772f, 
    0.10024004f, 0.03935975f, -0.08490963f, 0.15626289f, 0.07411763f, 0.01750452f, -0.08625505f, 0.06305996f, 
    0.00656440f, -0.04386865f, 0.06900889f, -0.03801792f, 0.00987232f, -0.02300609f, -0.04371405f, -0.00010856f, 
    -0.05892775f, -0.02443454f, -0.03192667f, -0.08086337f, 0.03503642f, -0.06629497f, 0.13691065f, -0.06849784f, 
    -0.17040478f, -0.01630962f, 0.03344373f, -0.00014200f, -0.01303414f, -0.10185486f, -0.01636077f, 0.04948831f, 
    0.04197329f, -0.17086092f, -0.05430333f, -0.00449360f, 0.07632933f, 0.02865509f, 0.06777944f, 0.05520554f, 
    0.05266834f, 0.45230305f, 0.13600886f, 0.12375320f, -0.18179734f, -0.01574783f, 0.02746979f, 0.11273998f, 
    0.08215478f, 0.00557278f, -0.03390010f, 0.05827805f, 0.00554278f, -0.05704397f, 0.07608342f, 0.02364936f, 
    -0.08831457f, -0.00924524f, -0.01008682f, 0.02343363f, -0.15473893f, -0.08857968f, 0.23728769f, -0.01913095f, 
    0.19240217f, 0.07998192f, 0.18070956f, -0.02197350f, -0.01728677f, 0.01629914f, 0.08196831f, -0.01763804f, 
    0.07895874f, -0.00746908f, -0.10683949f, -0.09647282f, -0.06896438f, 0.05929795f, 0.08712429f, 0.00808353f, 
    0.30415517f, 0.03490464f, -0.10081344f, 0.05284664f, 0.07949698f, 0.06432243f, -0.01969032f, 0.01091474f, 
    0.03972179f, -0.04733673f, 0.01948642f, -0.08604135f, -0.04409739f, -0.02764074f, 0.04572768f, 0.05111149f, 
    -0.05093460f, -0.04864219f, 0.00286333f, -0.04145881f, 0.29588354f, 0.30240011f, -0.07543619f, -0.04019621f, 
    -0.06422295f, -0.00025489f, -0.05921543f, 0.03376077f, 0.02882776f, -0.10775844f, -0.05945605f, 0.08731756f, 
    -0.00185070f, 0.11226694f, -0.01957547f, 0.05383126f, -0.08940436f, -0.04268911f, -0.05264835f, -0.00842661f, 
    -0.09621379f, 0.20106438f, 0.02006696f, -0.04473640f, -0.09318198f, -0.02317437f, -0.10041774f, -0.05507208f, 
    -0.01013495f, -0.00019165f, -0.04625792f, -0.06528903f, 0.03279531f, -0.01208175f, -0.11602416f, 0.00134278f, 
    -0.03036699f, -0.07907154f, 0.10160713f, -0.05488928f, 0.46898502f, 0.07310485f, -0.01537371f, 0.01164668f, 
    -0.02926631f, -0.02881298f, 0.00738349f, -0.05749114f, 0.02016983f, -0.05128909f, 0.06959377f, -0.00254909f, 
    -0.00352707f, 0.11058360f, 0.00105855f, -0.01394679f, 0.00559619f, -0.04045434f, -0.04385532f, -0.04876238f, 
    -0.21615371f, -0.04170837f, 0.28569740f, -0.10070680f, 0.18914394f, 0.05220000f, 0.21480580f, -0.13318732f, 
    -0.07407883f, 0.03170410f, 0.04883888f, -0.01011932f, 0.03689703f, 0.11769413f, 0.02329426f, 0.01365113f, 
    -0.08915580f, 0.15421243f, 0.04119530f, 0.04449280f, 0.54426229f, -0.02496226f, 0.08577300f, 0.10821997f, 
    -0.12174082f, 0.10604780f, -0.00185562f, 0.11351454f, -0.01231205f, 0.03691592f, 0.02203813f, -0.01749206f, 
    -0.02237462f, 0.06973207f, 0.07895206f, 0.09344760f, 0.10656346f, 0.02086239f, -0.02185945f, 0.02108136f, 
    -0.09924104f, 0.26518425f, -0.02309346f, -0.14873709f, -0.16507773f, -0.14231959f, -0.07313713f, -0.08096837f, 
    0.04319585f, -0.00438603f, -0.02625783f, 0.07096035f, -0.02762046f, -0.05680118f, 0.04761314f, -0.06621635f, 
    -0.08921161f, 0.09642643f, 0.06357583f, 0.03690028f, -0.23267722f, -0.06573608f, 0.10230584f, 0.04793306f, 
    0.35616750f, 0.05540943f, -0.07593584f, 0.00549903f, 0.08628415f, -0.00219968f, -0.01939495f, 0.00230983f, 
    -0.13665591f, 0.15291521f, 0.04339638f, 0.02068249f, 0.01876853f, -0.04094264f, 0.02972351f, 0.00272297f, 
    0.08209255f, 0.07595941f, -0.00409209f, -0.06648272f, 0.09856819f, 0.01393842f, 0.07545244f, 0.02850983f, 
    0.00017357f, -0.00086388f, 0.04120612f, -0.00648378f, 0.01081612f, -0.00872864f, 0.06194072f, 0.10616110f, 
    0.03392563f, -0.07122887f, 0.21508999f, 0.08439693f, 0.07533674f, 0.12346270f, -0.07476667f, -0.10426302f, 
    0.02015010f, -0.03283349f, -0.05479494f, 0.04489237f, 0.06116911f, -0.07374302f, -0.02339619f, -0.04586607f, 
    0.06468935f, 0.00865140f, 0.05425692f, 0.05199183f, 0.04933197f, 0.18921539f, -0.00287795f, -0.01220613f, 
    0.09221115f, -0.19849633f, -0.05340338f, -0.08807302f, 0.10402625f, -0.04658126f, 0.01412690f, -0.01881474f, 
    -0.11430003f, -0.01864291f, 0.01493765f, -0.03291281f, -0.07294709f, 0.03477081f, -0.03320373f, -0.11682038f, 
    -0.06764944f, 0.11551518f, 0.05371953f, -0.00732866f, 0.11194286f, -0.40848714f, 0.09425253f, 0.23421636f, 
    -0.13643847f, 0.07584929f, -0.15323809f, 0.01070865f, -0.07693871f, -0.02575025f, -0.09980105f, 0.03308550f, 
    0.02324935f, -0.01004600f, -0.20420545f, 0.04565473f, -0.05577691f, 0.10453402f, -0.03623644f, 0.12840712f, 
    0.13389608f, -0.10664593f, -0.08537962f, 0.02704736f, 0.19747396f, 0.01541186f, -0.03880581f, 0.04630307f, 
    0.06060730f, 0.02465208f, 0.03351863f, -0.00258825f, -0.05709819f, 0.03722632f, -0.03677171f, 0.01601887f, 
    -0.03744103f, -0.05344541f, 0.01552378f, -0.04609073f, 0.20048079f, -0.36839601f, -0.09790908f, -0.16091958f, 
    0.03956537f, -0.10041094f, -0.01574553f, 0.05443242f, -0.13020039f, -0.00354849f, 0.09484132f, 0.01758619f, 
    0.00905498f, -0.02179452f, -0.06855900f, -0.08683561f, -0.00864269f, 0.05396617f, 0.09753194f, 0.12381914f, 
    -0.07319121f, -0.10702033f, 0.06512383f, 0.03913821f, 0.08967977f, 0.01349371f, 0.03438094f, -0.03746677f, 
    0.09801290f, 0.03716073f, -0.01012948f, 0.05173052f, -0.01705346f, -0.04588868f, 0.04253444f, -0.05891746f, 
    -0.04739222f, -0.12714057f, 0.00016614f, -0.07197678f, 0.06820191f, -0.27923381f, 0.02111258f, -0.13210152f, 
    0.11002095f, 0.00043212f, -0.04143923f, -0.08893394f, -0.11193459f, -0.08087016f, -0.03453884f, -0.09194975f, 
    -0.07580532f, -0.01673546f, -0.04985446f, -0.02649660f, -0.11886932f, -0.00953971f, -0.06152577f, -0.02569346f, 
    0.16979221f, -0.16741958f, 0.31700802f, 0.07171842f, -0.03243194f, -0.12638769f, -0.03608181f, -0.16320233f, 
    0.15250319f, -0.02779786f, -0.08464133f, -0.02184452f, -0.01262909f, 0.01981695f, 0.04075973f, -0.10245270f, 
    -0.00765422f, -0.02428535f, -0.05104010f, -0.00760366f, -0.38030103f, 0.13886605f, -0.23133408f, 0.06704126f, 
    -0.12387352f, 0.09304378f, 0.17953922f, -0.02556400f, 0.06446843f, -0.03304417f, -0.00083266f, 0.06248932f, 
    0.02800878f, 0.00195639f, -0.02564870f, 0.05144694f, -0.02142109f, 0.12212726f, 0.02279185f, -0.05112624f, 
    0.02265523f, -0.01980095f, -0.07226466f, 0.14688639f, 0.14150576f, 0.26255816f, -0.11084322f, 0.10555622f, 
    0.17712976f, 0.06622219f, 0.11590278f, -0.07925191f, 0.06821231f, -0.04427155f, 0.00268542f, -0.04570490f, 
    -0.02865151f, -0.05067863f, 0.02380943f, 0.08703437f, 0.05259110f, -0.12638924f, -0.03034878f, 0.05393657f, 
    0.13337186f, -0.01747922f, 0.05059351f, 0.07687540f, -0.03059991f, 0.05445435f, 0.06631594f, 0.06861255f, 
    -0.02315251f, 0.03061296f, -0.00607213f, 0.01568082f, 0.05829024f, -0.02529025f, -0.01638010f, -0.01125699f, 
    0.29705438f, 0.32522348f, -0.03398404f, -0.06448199f, -0.09056097f, 0.27494630f, 0.02372602f, -0.07750715f, 
    -0.02732060f, -0.01869133f, 0.02679467f, 0.04261766f, -0.14299971f, 0.08921169f, -0.10738073f, 0.09005331f, 
    -0.04385031f, -0.00717448f, 0.02311775f, -0.05477238f, 0.06882926f, -0.08261692f, 0.21870367f, -0.11147439f, 
    -0.08299769f, -0.13422100f, -0.11232098f, -0.07179105f, -0.06324299f, -0.17136572f, -0.03143235f, -0.05154448f, 
    -0.09332874f, 0.01220009f, 0.02345781f, -0.00266933f, 0.01881324f, 0.09239040f, 0.01222006f, 0.01654422f, 
    0.01420661f, 0.05628729f, -0.01819674f, -0.32684174f, 0.05460862f, 0.08293353f, 0.04920479f, 0.04499674f, 
    0.05506212f, -0.03527829f, 0.06886708f, 0.08048458f, -0.06560299f, -0.05204738f, -0.08955091f, 0.02929562f, 
    -0.00839509f, 0.11517319f, 0.12702563f, 0.02710743f, 0.15725048f, -0.07852734f, -0.04274772f, 0.08119318f, 
    0.06923984f, -0.04013729f, -0.02646787f, 0.04470334f, -0.04174702f, 0.04357799f, 0.05934027f, 0.09759513f, 
    -0.05355396f, -0.00495410f, 0.06495342f, -0.04041922f, -0.06818797f, -0.00276897f, -0.15298294f, 0.01233493f, 
    -0.22684151f, -0.05257728f, -0.13243289f, -0.32132483f, -0.22882096f, -0.02505630f, 0.07248976f, 0.10123718f, 
    0.02506889f, -0.07119525f, -0.00679406f, -0.04164628f, -0.09566780f, -0.07106738f, -0.04323772f, 0.02376194f, 
    -0.00025260f, -0.07546923f, 0.05803114f, 0.04631998f, 0.60663360f, -0.35037395f, 0.01146827f, -0.19115588f, 
    -0.04345018f, -0.06478199f, 0.02247790f, 0.06498750f, -0.18537453f, -0.00372963f, 0.02159094f, 0.01465134f, 
    0.08792292f, -0.03400297f, -0.08767841f, 0.07644750f, -0.05448410f, 0.04232674f, -0.08573739f, 0.14775707f, 
    0.28766698f, -0.10624147f, -0.03089506f, -0.00217641f, 0.11133344f, -0.05625146f, 0.06478462f, 0.00696183f, 
    -0.03569375f, 0.00378397f, 0.02364063f, -0.05640982f, 0.09998089f, -0.02300914f, -0.01420022f, 0.00759436f, 
    0.07925449f, 0.01239495f, -0.01315671f, -0.05399489f, -0.03845715f, -0.17075559f, 0.01970039f, 0.03939942f, 
    0.09122795f, -0.07891790f, 0.05786419f, -0.09180944f, 0.01324909f, -0.07108907f, 0.11387403f, 0.02867484f, 
    0.04370266f, 0.05128006f, 0.04608237f, -0.06725305f, -0.08927694f, 0.07776746f, 0.01479495f, -0.05959345f, 
    0.07633960f, -0.05377925f, -0.13333698f, 0.07467986f, -0.03720292f, -0.00256271f, -0.01076425f, 0.08011345f, 
    -0.00933977f, 0.06197748f, -0.09044599f, -0.00419803f, -0.04616708f, -0.00367870f, -0.01649091f, -0.09323901f, 
    -0.05799568f, -0.06767426f, -0.06827571f, -0.12454843f, -0.06586028f, 0.24881780f, -0.02186046f, -0.17338824f, 
    -0.08418785f, 0.13463314f, 0.00458775f, 0.00171276f, 0.03914862f, 0.00444485f, 0.08841138f, 0.06924379f, 
    -0.02650916f, 0.03143112f, -0.12464713f, 0.04440258f, 0.05924680f, -0.08394382f, 0.01265304f, 0.04381071f, 
    -0.19112110f, 0.09549106f, -0.17678805f, 0.11270911f, -0.13295083f, 0.00409432f, 0.03721786f, -0.02352285f, 
    -0.03225377f, 0.05150574f, 0.04765955f, -0.03049399f, -0.02186622f, -0.04844083f, -0.01737223f, -0.05359794f, 
    -0.05573357f, 0.04591385f, -0.01652941f, 0.04970194f, 0.41568673f, 0.08179561f, 0.17227861f, -0.06072493f, 
    0.01068398f, -0.08037335f, 0.15108712f, 0.12256843f, -0.02660588f, 0.03134722f, 0.05708983f, -0.09502260f, 
    0.10572964f, 0.01873227f, 0.01283906f, 0.01425906f, 0.02370280f, -0.00265604f, -0.02656780f, 0.04952544f, 
    -0.32848728f, 0.01660969f, -0.01823056f, -0.02304559f, -0.07577094f, -0.05435067f, 0.04093374f, 0.02468782f, 
    0.06361152f, -0.00332031f, -0.05788270f, -0.04349271f, 0.01615413f, -0.01137656f, 0.17153078f, 0.14277485f, 
    -0.03987397f, 0.00636006f, 0.04073025f, -0.03466522f, 0.23062326f, 0.00751363f, -0.11714240f, 0.04211422f, 
    -0.02599981f, -0.03406557f, 0.01713253f, 0.00314009f, -0.09732516f, 0.06343337f, 0.11715523f, 0.06540351f, 
    0.05070045f, -0.03118672f, -0.06776688f, 0.04597862f, -0.13698834f, 0.05537308f, -0.03047368f, 0.14226431f, 
    -0.01440331f, 0.09801066f, 0.01390788f, -0.01741589f, -0.03748924f, -0.03279888f, 0.11124849f, 0.10570716f, 
    -0.06279931f, 0.03408102f, -0.05618661f, -0.05248819f, 0.06420077f, -0.03695350f, -0.01835567f, 0.04276974f, 
    0.12943962f, 0.05163869f, 0.12644608f, 0.13762642f, 0.25388047f, 0.07937729f, -0.01569247f, 0.01706974f, 
    0.21408735f, 0.16930492f, 0.00297673f, -0.02821583f, 0.01691260f, 0.02145194f, 0.05120324f, 0.04047048f, 
    0.01453430f, 0.03512377f, 0.08924299f, 0.02819037f, 0.08343481f, 0.01656590f, 0.11719359f, -0.03327037f, 
    0.55118781f, -0.30749238f, 0.07821582f, 0.00798978f, -0.00768254f, -0.05453674f, -0.00176658f, -0.06443789f, 
    -0.11435945f, -0.00241503f, 0.01866181f, 0.04004049f, 0.00041894f, 0.06563023f, -0.01139840f, 0.08102344f, 
    -0.07384000f, 0.08067978f, -0.09044302f, 0.04437210f, 0.31679595f, -0.41598961f, -0.11720707f, 0.01657611f, 
    0.14284331f, -0.04323321f, 0.12342761f, -0.08895335f, -0.02214587f, 0.12558436f, -0.00956528f, 0.10227136f, 
    0.02540373f, 0.00993100f, 0.09699108f, 0.07436804f, -0.03766644f, -0.00224151f, -0.10890500f, -0.00366669f, 
    0.12093734f, 0.22064126f, -0.06751867f, -0.15608244f, -0.09930576f, 0.05649104f, -0.01049649f, 0.04370972f, 
    0.07224107f, -0.01436598f, 0.13706015f, 0.13740310f, 0.01351681f, 0.00543695f, -0.12878264f, 0.11570685f, 
    0.02274228f, 0.05764119f, 0.00834963f, -0.04083460f, 0.17128050f, -0.14788976f, 0.32310161f, -0.06057239f, 
    0.13496687f, -0.12198196f, -0.00396895f, -0.06006891f, 0.10549466f, -0.01895491f, -0.05380102f, -0.04585804f, 
    -0.01608693f, 0.04068724f, 0.07411086f, -0.03783263f, 0.04857909f, -0.09538364f, -0.14008088f, -0.01916741f, 
    0.28995165f, 0.13644269f, 0.07337751f, -0.21009052f, -0.03969419f, -0.09051034f, -0.03459015f, 0.09010697f, 
    -0.08746898f, -0.05220937f, 0.02824440f, -0.07092004f, 0.14839686f, 0.04475141f, -0.00114985f, 0.03492644f, 
    -0.09434075f, -0.06509926f, 0.08656550f, 0.11128771f, -0.23362893f, 0.00940647f, 0.12915488f, -0.00092657f, 
    0.14998047f, 0.16208522f, -0.03440601f, 0.15132041f, 0.05059961f, -0.03730084f, -0.08268870f, -0.05701509f, 
    -0.03239890f, -0.01923445f, 0.15452771f, 0.02061374f, 0.11208000f, 0.15176892f, 0.14539799f, 0.03712127f, 
    0.23079620f, 0.11199064f, -0.11963192f, -0.26580891f, -0.08382300f, 0.11814941f, 0.14763461f, 0.00051467f, 
    0.04864572f, -0.05345217f, -0.04406935f, 0.01954711f, -0.04265499f, -0.12808070f, 0.00233176f, 0.00915489f, 
    -0.01165116f, 0.04221663f, 0.04514809f, 0.05692025f, -0.05472408f, 0.01776332f, -0.18003531f, 0.11732570f, 
    0.14327675f, -0.02667271f, -0.04602023f, -0.12125455f, 0.03584926f, -0.00005233f, -0.12827289f, 0.04126894f, 
    -0.01725334f, -0.02694460f, 0.08450147f, -0.01214847f, 0.00868966f, 0.07112702f, -0.04931955f, -0.09786145f, 
    0.06063254f, -0.16750748f, 0.08583289f, 0.04223415f, 0.13000685f, -0.11213714f, 0.05363629f, -0.01310543f, 
    -0.00677896f, 0.10425910f, 0.04647034f, 0.04619246f, 0.06146142f, 0.02631265f, 0.11665000f, -0.05683146f, 
    -0.00063111f, -0.03289123f, -0.01260562f, 0.03494437f, 0.01937053f, -0.02135652f, 0.00480216f, -0.26289153f, 
    0.00802840f, -0.02956191f, -0.07092996f, 0.03306685f, -0.02512128f, -0.11691748f, 0.07787322f, 0.01486576f, 
    -0.08249194f, -0.00164828f, -0.07383233f, 0.07059947f, -0.02488800f, -0.05467106f, 0.13105972f, 0.03464077f, 
    -0.02827268f, -0.01549528f, -0.00197535f, 0.01630081f, 0.01344914f, -0.00228068f, -0.00949694f, 0.01127045f, 
    0.02561515f, -0.01750946f, -0.00789993f, -0.01676004f, -0.01224243f, -0.03891892f, 0.03008326f, -0.02063606f, 
    0.00576709f, -0.00850923f, -0.01874787f, 0.02422030f, -0.02300081f, 0.00930457f, -0.01853620f, -0.02010726f, 
    -0.03757101f, 0.03714805f, -0.00978300f, -0.03081718f, 0.03650360f, -0.01942971f, -0.00964972f, 0.01055560f, 
    -0.00364830f, -0.03730214f, -0.03045845f, 0.01671475f, -0.01071007f, 0.02459027f, -0.03198139f, -0.01488374f, 
    0.00527387f, -0.02583823f, 0.00071403f, 0.02915389f, 0.01034815f, 0.00755547f, -0.00760628f, -0.01373870f, 
    0.00603629f, -0.01543381f, -0.00582875f, 0.03558382f, -0.00319985f, -0.03359051f, 0.03044645f, 0.03863994f, 
    -0.01597907f, 0.00963643f, -0.01864406f, 0.01087337f, -0.00440353f, -0.02715386f, 0.01911894f, -0.03052708f, 
    -0.02794111f, 0.03098896f, -0.00588484f, -0.01097769f, -0.00768066f, -0.03138904f, -0.03865323f, 0.02883911f, 
    0.00261364f, -0.00100503f, -0.01886633f, 0.01694523f, -0.03552487f, -0.03231502f, -0.02125845f, -0.01244840f, 
    0.01380286f, 0.01151150f, 0.00084694f, 0.00635964f, -0.00164807f, -0.01883993f, -0.02992551f, -0.02854248f, 
    0.00868711f, 0.02559434f, -0.00609074f, 0.03527746f, 0.01618688f, -0.02529360f, 0.00012979f, 0.02984862f, 
    0.02075014f, -0.01567694f, -0.01894533f, -0.02456643f, 0.00087109f, 0.01851984f, -0.00162786f, -0.02417550f, 
    0.02434591f, -0.03783267f, 0.02766773f, -0.03074143f, 0.03757816f, -0.03579468f, -0.01704671f, -0.03400461f, 
    -0.00046688f, 0.02873994f, -0.02439671f, -0.01878930f, -0.00325661f, 0.00955147f, 0.02595123f, -0.03905042f, 
    0.02326236f, 0.02819734f, -0.01532734f, 0.00228925f, 0.03456816f, -0.02244367f, -0.02978384f, -0.02866697f, 
    -0.02436077f, -0.03909470f, 0.00656694f, 0.03544727f, -0.03065785f, -0.00943357f, 0.02683752f, 0.00739770f, 
    -0.00313808f, -0.01479323f, -0.03794725f, 0.02664996f, 0.02436790f, -0.02169566f, -0.00396061f, -0.01136482f, 
    -0.00804181f, -0.02766290f, -0.02276495f, 0.02940884f, 0.02960340f, 0.00559968f, -0.02764244f, -0.00509552f, 
    -0.01042754f, -0.02803501f, 0.00536699f, -0.03800838f, 0.00873227f, 0.01859343f, -0.03950889f, 0.01711901f, 
    0.03782445f, 0.03653181f, -0.03837033f, 0.02330075f, -0.02007483f, 0.00601376f, 0.03894608f, 0.02798233f, 
    0.00091221f, -0.01422890f, -0.00461106f, 0.00243261f, -0.00187192f, 0.02460559f, -0.03580787f, 0.02633404f, 
    0.00327695f, -0.01657089f, 0.03264813f, -0.03841158f, -0.00489608f, 0.00241249f, 0.00496623f, 0.01022770f, 
    -0.01768727f, -0.02979694f, 0.02162257f, -0.03472941f, 0.01296725f, 0.01286650f, 0.02091800f, -0.02744792f, 
    -0.01814269f, 0.03559929f, -0.00865844f, -0.01865001f, 0.03477017f, 0.02829122f, -0.00360723f, -0.00872883f, 
    -0.02984482f, -0.00105087f, -0.03072737f, 0.02686423f, -0.03088005f, -0.00487446f, 0.01456487f, -0.01073181f, 
    -0.00421967f, -0.00191517f, -0.00970290f, -0.03287956f, 0.03693364f, 0.01304702f, 0.03717213f, -0.02427005f, 
    -0.01581562f, -0.03009269f, 0.01887712f, 0.00552869f, -0.00673601f, -0.01339486f, -0.01086086f, -0.01596014f, 
    0.01838564f, 0.02265491f, -0.02438602f, 0.03006317f, -0.01623074f, -0.01761169f, -0.01848967f, 0.00744329f, 
    0.00703673f, -0.00806457f, -0.01682125f, 0.03937443f, -0.02273045f, 0.02604291f, 0.03686425f, -0.00516297f, 
    -0.00559744f, 0.02046582f, -0.00043906f, 0.00883279f, -0.03823112f, -0.01349870f, 0.02929547f, -0.03041345f, 
    -0.01727301f, -0.03803612f, 0.01368859f, 0.02325559f, -0.00319767f, 0.00134030f, -0.01217328f, -0.03923622f, 
    0.00173935f, 0.00026657f, 0.02088379f, -0.00769190f, 0.00650662f, 0.01015358f, -0.03006071f, 0.03876464f, 
    0.01049230f, 0.02624856f, 0.00939313f, 0.02209146f, 0.02724494f, -0.01485346f, -0.01170014f, 0.02582190f, 
    0.01651372f, -0.01675232f, -0.02326989f, 0.02311045f, 0.02290033f, 0.01533603f, -0.00678039f, 0.00227914f, 
    -0.00706862f, -0.00667067f, 0.03728570f, 0.01653357f, -0.00454295f, -0.02301267f, -0.00241535f, -0.02120319f, 
    0.00073710f, 0.03800535f, -0.01245701f, -0.03410948f, 0.02208691f, -0.01940113f, -0.00960098f, -0.01738338f, 
    -0.03398703f, -0.01565708f, -0.03860065f, -0.00337120f, 0.01495671f, 0.02977337f, 0.00458984f, 0.03795173f, 
    -0.01254834f, 0.02114868f, 0.03945346f, 0.01407911f, -0.00622002f, 0.02563369f, -0.01959548f, -0.00994378f, 
    -0.00255427f, -0.02439516f, -0.01767385f, -0.01583130f, 0.03333499f, 0.00678646f, 0.00145758f, -0.03139340f, 
    -0.01102490f, -0.03508115f, -0.03186121f, -0.00479590f, 0.02434518f, -0.00553865f, -0.01038649f, 0.00669758f, 
    0.02408919f, -0.01877274f, 0.00695824f, 0.00675993f, -0.03573400f, 0.02224220f, -0.02922737f, 0.02063200f, 
    0.02591671f, 0.02529274f, 0.00823457f, -0.01420116f, -0.03025744f, -0.01800032f, 0.03255108f, 0.01924216f, 
    0.02261800f, -0.00235643f, -0.02057876f, 0.00227243f, 0.03064172f, -0.02107678f, -0.01549469f, -0.01518217f, 
    0.01103669f, -0.03398545f, 0.03893162f, 0.01341361f, 0.00309103f, -0.01710793f, 0.01954518f, 0.03352432f, 
    -0.03031781f, -0.03196091f, 0.00396806f, -0.01445708f, -0.03625761f, -0.02958376f, 0.03431621f, -0.03714425f, 
    0.02363303f, -0.02003890f, -0.01445391f, -0.03721226f, -0.02151839f, -0.02594792f, 0.01769494f, -0.02145906f, 
    -0.03572952f, 0.03310841f, -0.00330571f, -0.01023881f, 0.00304871f, -0.01419986f, -0.03899727f, -0.00874211f, 
    0.00301539f, -0.00939694f, 0.02927792f, -0.02717927f, -0.01322502f, 0.00519399f, 0.00508944f, 0.03482575f, 
    -0.00438500f, -0.02324997f, -0.01069032f, -0.00077135f, 0.00139730f, 0.00380922f, -0.01574176f, -0.03158992f, 
    0.02907699f, 0.00166334f, 0.02803835f, 0.01807774f, 0.03926685f, 0.02272284f, -0.03772474f, 0.01319932f, 
    0.00191792f, 0.00993724f, -0.02669861f, -0.02140700f, -0.02435613f, -0.03710730f, 0.00451416f, 0.02334785f, 
    -0.03174359f, 0.02452699f, -0.00275449f, 0.00350215f, 0.03126653f, 0.02785010f, 0.00825166f, -0.02164359f, 
    -0.01819768f, 0.00105242f, 0.00064869f, -0.02838366f, -0.02104023f, 0.00360888f, -0.01754340f, -0.03671388f, 
    -0.02626550f, 0.02392221f, -0.02297977f, -0.01517752f, -0.03848477f, -0.00121289f, 0.02752244f, -0.03687145f, 
    -0.01313070f, -0.00716040f, -0.03058501f, -0.01992627f, -0.00748497f, 0.01490989f, -0.02032066f, 0.00518529f, 
    0.02144613f, 0.00947714f, -0.00598691f, 0.01567605f, 0.00036510f, 0.01827294f, -0.02823505f, -0.02625200f, 
    0.02843392f, 0.00867364f, 0.00436007f, -0.02641701f, -0.02370469f, 0.00976966f, -0.01372720f, 0.01458601f, 
    -0.01707477f, 0.02487423f, -0.03784047f, -0.03938238f, 0.02839779f, -0.01628458f, 0.03513219f, -0.03026841f, 
    -0.02775136f, -0.00730567f, 0.02648446f, -0.00590463f, 0.03412609f, 0.01928663f, 0.02627995f, -0.02355721f, 
    -0.00008815f, 0.02919950f, -0.02566031f, -0.03946289f, -0.03622213f, 0.01727885f, -0.03232823f, -0.02313750f, 
    0.02376240f, -0.01692208f, -0.03239349f, 0.01205407f, -0.01772194f, 0.01612297f, -0.00952838f, 0.01838505f, 
    -0.02009953f, -0.02614532f, -0.00460885f, 0.03114169f, -0.03568539f, -0.01886510f, -0.03669564f, -0.01388059f, 
    -0.03468514f, -0.03639552f, 0.03493388f, 0.03796909f, -0.01928454f, -0.03540472f, -0.02851275f, -0.02858916f, 
    -0.03846588f, 0.00711014f, -0.03655009f, 0.00066003f, -0.02794169f, 0.03048079f, 0.02478824f, -0.00211667f, 
    -0.02683799f, -0.02485432f, -0.00124915f, 0.03273435f, -0.03452174f, 0.02339751f, 0.01606435f, 0.03730527f, 
    0.00216217f, -0.02556177f, -0.01007873f, 0.01544529f, 0.00350530f, 0.02315830f, 0.00230470f, -0.03848279f, 
    0.01938613f, 0.00012353f, -0.01431734f, 0.00385410f, 0.01178820f, 0.00571373f, -0.03497224f, 0.02959910f, 
    -0.02007027f, 0.00026219f, 0.03033249f, 0.02631059f, -0.02265585f, -0.03234594f, -0.02364867f, 0.03421797f, 
    -0.03287549f, -0.03178640f, 0.02814618f, 0.01673549f, -0.02043335f, 0.02774780f, -0.03881897f, -0.00644330f, 
    0.02378617f, -0.03146165f, -0.00431305f, -0.01996862f, 0.03255465f, 0.02105979f, 0.02016338f, -0.01787351f, 
    0.00477095f, -0.02174530f, -0.03486282f, 0.01872932f, 0.02393745f, 0.01729621f, 0.02440327f, -0.02346611f, 
    -0.01338517f, 0.00517380f, -0.00129120f, -0.00199425f, 0.01710760f, 0.00341701f, 0.01360846f, -0.02990898f, 
    0.03492203f, -0.03551926f, 0.01103029f, 0.02922120f, 0.02182934f, -0.00624006f, 0.02594481f, -0.01037292f, 
    -0.00752997f, 0.02352039f, -0.00845551f, 0.00001115f, -0.01444723f, 0.03656933f, -0.01129154f, 0.00513071f, 
    -0.01803546f, -0.03244605f, -0.02119399f, -0.00408569f, 0.01323799f, -0.02246818f, -0.01386455f, -0.03731965f, 
    -0.01171659f, -0.03894619f, 0.02759700f, 0.03941945f, 0.01460632f, 0.03485215f, -0.02486462f, -0.02029309f, 
    0.00832035f, 0.01251782f, 0.00761278f, -0.00278438f, 0.02736733f, 0.03600083f, -0.00976529f, 0.01543118f, 
    -0.01809816f, 0.00301023f, -0.03936357f, 0.01589585f, 0.01781606f, -0.03865922f, -0.01173948f, 0.03906371f, 
    -0.02487149f, -0.03094644f, 0.03600013f, -0.02967992f, 0.01919512f, 0.01611222f, -0.02834104f, -0.02613912f, 
    0.10504068f, 0.06487685f, -0.04724010f, 0.10729174f, 0.08449561f, 0.12476169f, 0.06195422f, 0.01667076f, 
    0.03691853f, 0.09546417f, 0.01579725f, 0.01555763f, 0.02708059f, -0.00593469f, 0.04422351f, 0.02600413f, 
    0.06841891f, 0.02029116f, 0.04546151f, 0.03014727f, -0.02758652f, -0.12773658f, -0.05445450f, 0.06458788f, 
    -0.22290528f, -0.01332999f, -0.08571077f, 0.02542714f, -0.06906496f, 0.00394951f, -0.00662362f, 0.02755349f, 
    0.05135239f, 0.05742865f, 0.09027255f, 0.05223396f, -0.01283697f, -0.02538734f, 0.05211543f, 0.14641555f, 
    -0.19929004f, 0.05291660f, -0.14058018f, 0.02002494f, -0.11032088f, 0.05497630f, 0.07090729f, -0.06482569f, 
    0.08422493f, 0.12309164f, -0.00858601f, -0.00419708f, -0.00706750f, 0.05377780f, 0.05203621f, -0.09603554f, 
    -0.01358558f, -0.00425945f, -0.02923031f, 0.07011735f, -0.00096996f, 0.09588633f, -0.04007344f, 0.06053371f, 
    -0.14032915f, 0.00161277f, -0.05944057f, -0.03744964f, 0.01095960f, -0.01560766f, 0.08224054f, 0.02108072f, 
    0.03819295f, 0.07494937f, 0.10071473f, 0.05858842f, 0.11072276f, 0.04152369f, 0.05512866f, 0.01132146f, 
    0.05882348f, 0.22315840f, 0.03026711f, 0.08824190f, -0.04514610f, 0.13427335f, 0.08491139f, 0.05867497f, 
    -0.06335286f, 0.07266591f, 0.02999764f, -0.04631068f, 0.18361294f, 0.07276098f, 0.04836045f, 0.03980277f, 
    -0.06880072f, 0.04192201f, -0.05224153f, -0.01537496f, -0.15889028f, 0.09651794f, 0.14125666f, 0.12085650f, 
    0.18175216f, -0.05585058f, 0.04760329f, 0.05064397f, 0.08969387f, -0.01897075f, 0.01056688f, 0.06595023f, 
    0.02951953f, 0.05596408f, 0.10703782f, 0.11454164f, -0.07970341f, 0.04870404f, -0.01038947f, 0.06476337f, 
    0.35519251f, -0.04183988f, 0.17340541f, 0.07781781f, 0.12051141f, -0.01644824f, -0.01798934f, -0.05088070f, 
    0.04198145f, 0.01444138f, 0.07769401f, 0.06979170f, 0.06344198f, -0.02778947f, 0.01047433f, 0.02691496f, 
    -0.03270188f, 0.06949208f, 0.01893354f, -0.00894517f, -0.08603863f, -0.02349522f, -0.04860506f, -0.05998373f, 
    -0.11166359f, -0.05686761f, 0.03404765f, 0.00703313f, 0.10126018f, 0.06540799f, -0.01540710f, 0.05327636f, 
    0.03698804f, 0.11293925f, 0.05389147f, 0.01408946f, 0.05879726f, 0.06104984f, -0.02428015f, 0.09594638f, 
    -0.26799387f, -0.12693083f, 0.00380919f, 0.06861886f, -0.13988332f, -0.00366925f, -0.01647056f, 0.11570960f, 
    0.03946171f, -0.07391738f, 0.06614012f, 0.09033087f, 0.01804818f, 0.05546624f, 0.12717810f, 0.01483621f, 
    -0.01163219f, -0.04164266f, 0.10829782f, 0.10069386f, 0.07272841f, 0.11827443f, 0.10071573f, 0.10260987f, 
    0.18453485f, 0.17344952f, 0.06537144f, -0.02530688f, 0.06819218f, 0.01956656f, -0.06005250f, -0.02291960f, 
    0.11595341f, 0.08656809f, 0.06193269f, 0.04436319f, -0.07961130f, 0.01923185f, 0.04012600f, -0.08535989f, 
    -0.08644143f, -0.18195751f, 0.08855951f, -0.09763548f, -0.21083972f, -0.06594364f, 0.01035186f, -0.00746542f, 
    0.05030208f, -0.00229508f, 0.10246756f, 0.01880064f, 0.08599307f, 0.04435279f, 0.15175103f, 0.03775875f, 
    0.16331576f, 0.13120633f, 0.00695188f, 0.07921029f, -0.13957785f, -0.17212042f, -0.11771706f, 0.03126027f, 
    -0.09645534f, -0.00212734f, -0.11694739f, -0.04624986f, -0.10792439f, 0.12597789f, -0.03228843f, 0.02058145f, 
    -0.05324394f, 0.06904362f, 0.08844908f, -0.02982071f, 0.04548258f, 0.03396315f, -0.02947879f, 0.03113244f, 
    -0.42902830f, 0.17185789f, -0.13700409f, 0.09672525f, 0.03172420f, 0.07931820f, 0.01226433f, 0.01179631f, 
    0.07386256f, 0.12649645f, 0.05398767f, -0.02970991f, 0.01443526f, 0.02553934f, 0.10835937f, 0.03651856f, 
    0.06054286f, -0.06193224f, -0.03134771f, 0.05838205f, -0.00544352f, -0.14977480f, 0.02430972f, 0.03619418f, 
    0.13122720f, 0.14124328f, 0.12167193f, 0.01438277f, -0.01650884f, 0.03677782f, 0.03972127f, 0.05499287f, 
    -0.00277994f, -0.01185099f, 0.06494378f, -0.05364162f, 0.07006675f, 0.00966751f, 0.05384272f, 0.04577700f, 
    0.16771211f, 0.08822639f, -0.07872105f, 0.10941599f, 0.17117961f, 0.18162896f, 0.14413622f, -0.00634470f, 
    0.07028835f, 0.07570751f, -0.00537343f, 0.10886601f, 0.05203833f, -0.00624098f, 0.07678106f, 0.03994550f, 
    0.03500486f, -0.00981569f, 0.08240147f, 0.06175230f, 0.36566472f, -0.16009267f, 0.29182810f, -0.03602967f, 
    -0.03465267f, -0.01359783f, 0.07536905f, -0.05706520f, 0.03882887f, 0.08618834f, 0.13281514f, 0.03182636f, 
    0.11925682f, -0.05144849f, 0.08467005f, 0.06003260f, 0.00012214f, 0.09583931f, 0.06125655f, -0.03157670f, 
    0.34378752f, 0.23043656f, 0.14437820f, 0.15056680f, 0.28570664f, 0.21123289f, 0.11057616f, -0.06748338f, 
    0.08332683f, 0.01783112f, 0.04919778f, 0.13136555f, -0.01158694f, -0.07086153f, 0.05573764f, 0.03873661f, 
    0.06737857f, 0.01641129f, 0.02456494f, -0.01134310f, -0.36109817f, 0.08847138f, -0.18854812f, 0.13630083f, 
    -0.07095047f, 0.08592661f, -0.02713035f, -0.03048350f, 0.08690569f, 0.02207461f, -0.01280305f, -0.02415364f, 
    0.07233665f, -0.04728044f, 0.05674342f, 0.04822929f, 0.01834366f, -0.03717124f, 0.00401318f, -0.00426557f, 
    0.12542996f, 0.05354794f, 0.06309015f, -0.03674445f, 0.01319696f, -0.01741337f, 0.09402878f, -0.01031410f, 
    0.06204228f, -0.04363069f, 0.04791159f, 0.05666111f, 0.05053039f, 0.11188997f, 0.00941690f, 0.12943135f, 
    0.00235288f, 0.03952263f, 0.00114484f, 0.02573974f, 0.19484241f, 0.28181672f, -0.08243825f, -0.15886435f, 
    0.09509424f, 0.02864745f, -0.09531473f, -0.03117513f, -0.03568377f, 0.06359478f, 0.02336683f, 0.06472691f, 
    0.09843770f, 0.12902915f, 0.04019199f, 0.01237770f, 0.11963843f, -0.02918645f, 0.08351486f, -0.01233798f, 
    -0.20578383f, 0.07204085f, -0.05415818f, 0.09489859f, -0.07646402f, 0.06831493f, -0.06720513f, 0.05517206f, 
    0.04929980f, 0.03531693f, 0.03887610f, 0.05899249f, -0.01238423f, 0.11390655f, 0.06114173f, -0.00818436f, 
    -0.11904833f, -0.03444325f, 0.00430355f, -0.04105317f, -0.08030481f, -0.21893167f, 0.06132814f, -0.13963825f, 
    -0.19620049f, 0.11878745f, 0.07561835f, 0.02477497f, -0.09415548f, 0.09649608f, 0.11868820f, -0.01092157f, 
    0.04580033f, 0.02885850f, -0.06941397f, 0.05582817f, 0.10662160f, 0.04450795f, -0.02364706f, 0.08510466f, 
    -0.13777840f, -0.10922915f, -0.07507559f, 0.06780385f, -0.12826663f, -0.01439770f, -0.05888888f, -0.01338305f, 
    -0.11337547f, 0.12244451f, -0.00419957f, -0.03302713f, -0.02557100f, 0.01855178f, 0.10633835f, -0.00606326f, 
    0.01501046f, 0.02150802f, 0.05975583f, 0.03248965f, -0.14655514f, -0.10790338f, 0.01000055f, -0.00389041f, 
    0.23112784f, 0.00739579f, -0.02971241f, 0.02382918f, -0.04588508f, 0.02755876f, 0.02019481f, -0.00332255f, 
    0.00492248f, 0.06439049f, 0.10089047f, 0.05710417f, 0.10186628f, -0.03625927f, -0.01338069f, 0.08017234f, 
    0.36705148f, 0.08767042f, 0.34367782f, -0.27285057f, -0.12333393f, -0.02657750f, 0.02328446f, -0.04872213f, 
    -0.00304133f, 0.03346038f, 0.07813069f, -0.15532012f, -0.01470500f, 0.03327304f, 0.10564949f, -0.03260585f, 
    0.06185673f, -0.09296890f, 0.03319509f, -0.01084550f, 0.00287195f, 0.22840194f, -0.13031678f, -0.01525394f, 
    -0.07596160f, 0.20038272f, -0.00768217f, 0.00672134f, -0.02094540f, 0.09365717f, 0.00518851f, -0.06093217f, 
    0.02320740f, 0.08866718f, -0.01285683f, 0.06048909f, 0.00935085f, 0.05341880f, 0.08863417f, -0.01714105f, 
    -0.24408935f, 0.02807504f, -0.19095652f, 0.01368422f, -0.07103883f, -0.09140221f, -0.04573287f, 0.08390339f, 
    0.15297487f, 0.07860520f, 0.01941328f, -0.03807364f, 0.01404359f, 0.04372136f, 0.12491746f, 0.02825843f, 
    0.06916201f, 0.05173863f, -0.05092791f, 0.00522185f, 0.21141738f, 0.00707461f, -0.04206930f, 0.00480466f, 
    -0.14752725f, -0.02643306f, -0.12871163f, -0.01819032f, -0.05203754f, -0.03582757f, 0.17823967f, 0.03549967f, 
    0.16592631f, 0.08810065f, 0.07566322f, 0.05813213f, 0.15082806f, -0.00421244f, -0.04094130f, 0.01425782f, 
    -0.40581363f, -0.25254071f, -0.00428402f, -0.08944570f, -0.09581659f, 0.00970144f, -0.00047403f, 0.01772134f, 
    0.06218222f, 0.03841972f, -0.08025394f, 0.08760630f, -0.01314192f, 0.03027488f, 0.05064871f, 0.01290204f, 
    0.03708449f, -0.02496354f, 0.06560744f, 0.11412097f, 0.34756908f, -0.20471744f, 0.00562762f, -0.06868555f, 
    0.12220996f, -0.12488605f, 0.11979340f, -0.02006739f, 0.05133707f, -0.11462873f, -0.00643965f, -0.05915342f, 
    0.18402912f, -0.08113687f, 0.11187015f, 0.06041430f, 0.03464200f, 0.06097908f, 0.04666129f, -0.01488696f, 
    0.05958707f, 0.28638309f, 0.07416087f, -0.05156187f, -0.00548609f, 0.11907467f, 0.10595362f, 0.02247476f, 
    0.08822277f, 0.00858903f, -0.00555260f, 0.05005137f, 0.03795422f, 0.10150362f, 0.01649441f, 0.06716087f, 
    0.03277801f, 0.07432055f, -0.00740451f, -0.01050172f, -0.26222876f, -0.07701501f, -0.02394523f, -0.00544426f, 
    -0.09549597f, -0.05552409f, 0.02915903f, 0.03667548f, 0.06152686f, 0.03350826f, 0.13597102f, 0.03607606f, 
    0.10834269f, 0.00967125f, 0.04106876f, 0.06224377f, 0.00614293f, 0.03714002f, 0.01756559f, 0.06780759f, 
    -0.15505452f, -0.13831896f, 0.03328828f, -0.05931713f, -0.11126268f, -0.01659069f, 0.04752851f, -0.02222041f, 
    0.08341499f, -0.00149321f, 0.05053923f, 0.03947738f, -0.00982326f, -0.12632178f, -0.01430644f, -0.08013795f, 
    0.06911401f, -0.02862976f, 0.05312285f, 0.07666386f, 0.25428784f, 0.00436746f, 0.00159817f, 0.24377427f, 
    -0.16903129f, -0.08707675f, -0.20287220f, 0.12776248f, -0.03430464f, 0.00907246f, -0.00008953f, -0.09665232f, 
    0.01488030f, -0.04061602f, -0.05581190f, 0.04515438f, -0.03944751f, -0.07680780f, 0.00396371f, 0.03885259f, 
    0.37951577f, 0.02870595f, 0.12492485f, 0.08142488f, -0.16337039f, -0.07659030f, -0.01386190f, 0.06368504f, 
    -0.01238684f, -0.01489316f, -0.03756185f, -0.04657023f, 0.01504333f, 0.01492887f, -0.13594249f, -0.05643597f, 
    -0.01252417f, 0.00356303f, -0.02105965f, -0.09525893f, 0.06367606f, -0.04216101f, 0.14526276f, -0.11816177f, 
    0.18340395f, 0.15279229f, 0.11148968f, 0.00677905f, 0.12004504f, -0.08393060f, 0.02623196f, 0.11429235f, 
    -0.03105452f, 0.03582773f, 0.17005166f, -0.14468285f, 0.02058324f, 0.09484169f, -0.04634101f, -0.11334394f, 
    -0.04030239f, -0.17015626f, -0.00135351f, -0.04072565f, -0.08487036f, -0.01191247f, 0.11647651f, 0.02781988f, 
    -0.01938042f, 0.06951942f, 0.00362123f, -0.05998287f, -0.08821198f, 0.05187906f, -0.00543865f, -0.10711662f, 
    0.03617162f, -0.07144334f, 0.00680210f, 0.03802412f, -0.47270942f, 0.40013847f, 0.07296339f, -0.14095712f, 
    0.20082045f, -0.08181942f, 0.09213532f, -0.11647058f, 0.07131632f, -0.03737113f, -0.00835595f, -0.02401197f, 
    0.07450548f, 0.09014917f, 0.02795499f, 0.08323743f, 0.05555774f, -0.01122700f, -0.10830711f, 0.13088840f, 
    0.20064838f, -0.21034008f, -0.36320466f, -0.29127377f, 0.15046470f, -0.09888545f, 0.03018939f, 0.02135207f, 
    0.04771949f, 0.01542434f, 0.14605533f, 0.05231642f, -0.05130580f, 0.02090731f, 0.00956590f, 0.03717352f, 
    0.02567333f, 0.00962150f, -0.02681000f, 0.08931228f, 0.47361448f, 0.14556107f, 0.13359651f, 0.11836015f, 
    -0.05518277f, -0.11558989f, -0.09954549f, 0.00056116f, 0.05263235f, -0.04530767f, -0.05291255f, -0.14969738f, 
    0.05998090f, 0.08781935f, -0.06726060f, -0.03215737f, 0.12447113f, 0.02717155f, -0.04134813f, -0.09285279f, 
    0.13153291f, 0.04900579f, 0.05920539f, 0.10958207f, 0.19459996f, 0.09288583f, 0.01303859f, 0.02669580f, 
    0.04257176f, -0.06056716f, -0.00463245f, 0.13443284f, -0.00189863f, -0.03247735f, 0.02521653f, 0.02934067f, 
    -0.10664357f, 0.00615029f, -0.01268705f, -0.03790851f, -0.30005226f, 0.18251610f, -0.05060751f, -0.15821487f, 
    -0.10241103f, 0.08228584f, 0.01858571f, -0.02495744f, 0.02497827f, 0.06024648f, -0.00369514f, -0.03351144f, 
    0.12834336f, -0.12963316f, 0.01395394f, -0.07993685f, -0.00373290f, 0.09709849f, -0.04340699f, 0.05562556f, 
    0.09515879f, -0.00218318f, 0.18579991f, 0.11012429f, 0.12181143f, -0.01879705f, -0.02310804f, 0.05824478f, 
    -0.13885109f, 0.04977402f, 0.06325432f, -0.02157944f, -0.13548240f, -0.05100965f, -0.09763817f, 0.00939657f, 
    0.09224018f, -0.08600193f, 0.00614648f, 0.08950954f, 0.00455214f, 0.09418825f, 0.20355108f, 0.31916490f, 
    -0.04946497f, -0.09204732f, -0.17398603f, 0.13611297f, 0.01630788f, 0.12631260f, -0.00375767f, 0.11879422f, 
    -0.09540220f, 0.02707723f, -0.01860919f, 0.00189965f, 0.03980287f, 0.02072896f, -0.08197402f, 0.04692765f, 
    0.04462503f, 0.12559035f, 0.00236471f, -0.04082093f, -0.06432233f, -0.03160627f, 0.01051216f, -0.05192701f, 
    0.05009560f, 0.08247353f, 0.02503030f, 0.04638818f, 0.01120093f, -0.06548978f, -0.05246599f, 0.00271229f, 
    0.11235423f, -0.04161465f, -0.01017501f, -0.00971330f, -0.06970043f, -0.20775804f, 0.06250443f, -0.05264333f, 
    0.05321911f, 0.17223017f, 0.00058397f, 0.13367945f, -0.01184954f, -0.09646779f, 0.04063331f, -0.04350087f, 
    0.00478209f, 0.07625725f, 0.06420095f, -0.08848999f, -0.00515868f, 0.04968783f, -0.05642122f, 0.06728827f, 
    -0.11716867f, -0.15371536f, -0.09404609f, -0.24415846f, -0.13112608f, -0.00094780f, 0.06181374f, 0.00225173f, 
    -0.07895222f, 0.10114241f, -0.05561269f, 0.02183457f, 0.02844697f, 0.00748421f, -0.00676996f, -0.02854787f, 
    0.05764421f, 0.03663002f, 0.04120163f, 0.04667393f, 0.17449431f, -0.13749142f, -0.11019667f, -0.13780797f, 
    0.02494569f, 0.11780041f, 0.00252663f, 0.01322327f, 0.00892871f, 0.06357266f, 0.11233837f, -0.00292888f, 
    -0.03544015f, 0.04643149f, 0.04030431f, 0.00762409f, -0.01508786f, -0.04413612f, -0.03696639f, 0.01309629f, 
    -0.06757970f, -0.19594936f, -0.25121677f, -0.21939537f, -0.00269650f, 0.07745899f, 0.03037433f, -0.07083052f, 
    0.04136918f, -0.01069703f, 0.12900896f, -0.01823242f, -0.09869241f, 0.00733538f, -0.06855547f, 0.02874538f, 
    0.04281678f, -0.02565973f, 0.01938421f, 0.01986109f, 0.32288039f, 0.26220524f, 0.05381584f, 0.13803013f, 
    -0.12493856f, -0.02705759f, -0.10462897f, 0.00388170f, 0.01736725f, 0.08175627f, -0.04298430f, 0.03211215f, 
    -0.05515574f, -0.01523046f, 0.08988627f, 0.05635067f, 0.06695362f, 0.03172828f, -0.13364631f, -0.02692187f, 
    -0.17996362f, -0.03034540f, 0.14770480f, 0.00484245f, 0.04684906f, -0.10096381f, 0.01293463f, -0.02466640f, 
    0.06861674f, -0.03092568f, 0.02673487f, 0.05480984f, 0.02601604f, 0.04236848f, -0.10806001f, 0.01562468f, 
    0.05334238f, 0.02205970f, -0.03018690f, 0.07297543f, -0.14394580f, -0.17643152f, -0.05396542f, -0.15492688f, 
    0.00902807f, 0.08275192f, -0.06582175f, -0.03957321f, 0.06081625f, 0.07174025f, 0.08140000f, -0.01982861f, 
    0.01058832f, -0.06358458f, 0.01571134f, -0.02840079f, 0.02770534f, 0.02186617f, 0.05335902f, 0.10351382f, 
    0.24852884f, 0.01666760f, 0.04351418f, 0.04930368f, 0.03504464f, 0.04709676f, 0.15722093f, 0.04481018f, 
    -0.00237855f, -0.00789846f, 0.02577523f, 0.07376296f, -0.03365460f, -0.02173086f, 0.08079144f, -0.03272801f, 
    0.01487953f, 0.09588089f, 0.02832934f, -0.04277982f, -0.35694724f, 0.00650862f, -0.16328892f, -0.19595291f, 
    0.04574033f, 0.07286401f, -0.01219572f, 0.08689582f, -0.02109597f, 0.11628292f, -0.05008364f, 0.08833610f, 
    -0.01404907f, 0.01488061f, 0.06202147f, 0.07127351f, -0.04784311f, 0.08615107f, -0.03214071f, 0.00837326f, 
    0.24373715f, 0.11878967f, 0.08835422f, 0.24618423f, -0.16018443f, -0.06881008f, -0.09828757f, 0.07837634f, 
    0.05189389f, 0.02856931f, -0.12646089f, 0.07563312f, 0.01210375f, -0.02633370f, -0.17532332f, -0.02223126f, 
    0.08915202f, 0.01506508f, 0.02493891f, -0.13089664f, -0.35294765f, 0.20491056f, -0.07858727f, -0.07728266f, 
    0.18855512f, -0.02705951f, 0.01728268f, -0.12648776f, 0.00137120f, 0.05619546f, -0.07112024f, 0.05614759f, 
    0.09228046f, 0.06698290f, 0.05220559f, 0.01895892f, -0.00556248f, -0.07441176f, -0.02216442f, -0.03179765f, 
    0.11197922f, -0.19171776f, -0.07854252f, -0.15326953f, 0.05752143f, 0.13916962f, -0.01955033f, -0.06847834f, 
    0.00269970f, -0.01338661f, 0.07280975f, -0.03752402f, 0.06108041f, 0.02683434f, -0.03236501f, 0.02368969f, 
    0.05735150f, -0.01284557f, -0.03601760f, 0.08625937f, 0.35539356f, -0.00636482f, 0.09448465f, 0.12154806f, 
    -0.29033780f, 0.03006187f, 0.15485674f, 0.04511659f, -0.06232750f, -0.00332947f, 0.05110438f, -0.09928554f, 
    0.07815143f, -0.06126785f, -0.07384889f, 0.03755988f, 0.00106940f, 0.11061146f, -0.06524362f, 0.09973999f, 
    0.22861587f, 0.06273631f, 0.18299240f, 0.18279305f, 0.07125232f, -0.10055628f, -0.07097286f, -0.05582208f, 
    -0.04729678f, 0.02153353f, -0.02447320f, -0.06408769f, 0.01612775f, 0.02426023f, 0.01779621f, 0.05722112f, 
    0.01063731f, -0.02470688f, -0.03058025f, -0.01683843f, 0.02191544f, 0.06161145f, 0.04689366f, 0.25788283f, 
    -0.12356097f, 0.04152651f, 0.01111587f, -0.00299188f, 0.03725531f, 0.06304254f, -0.12537308f, 0.05985237f, 
    0.01460023f, -0.00834838f, 0.01143750f, 0.02259857f, 0.01151077f, -0.05421678f, 0.05766192f, 0.04603275f, 
    -0.10690210f, 0.11342129f, -0.02016455f, -0.03504260f, 0.10605410f, -0.02508825f, 0.06198974f, 0.06651039f, 
    0.16244476f, 0.10818619f, -0.10531746f, 0.05966159f, 0.03984682f, -0.01740843f, 0.00428619f, -0.02494403f, 
    0.07210873f, -0.11128028f, 0.04201574f, 0.11647887f, 0.15206778f, 0.10798959f, -0.09141026f, -0.35582405f, 
    0.05194074f, -0.06286860f, 0.12251282f, -0.01601629f, 0.12451345f, -0.07048911f, 0.00232655f, -0.00712962f, 
    0.00593956f, -0.05209719f, 0.21694368f, 0.03424145f, 0.05015269f, 0.02132661f, -0.01996880f, -0.18027203f, 
    -0.02781339f, 0.21465516f, 0.13343619f, -0.03325981f, 0.00129838f, 0.02326227f, 0.01039288f, -0.00398507f, 
    0.09037808f, -0.03061749f, -0.00707512f, 0.02609472f, 0.08924920f, 0.03642052f, -0.01492010f, -0.00313029f, 
    0.05010482f, 0.03060095f, -0.03595936f, 0.04313131f, -0.22549689f, 0.17170751f, 0.05380890f, 0.16615954f, 
    0.25599629f, 0.08360041f, -0.06538914f, -0.01617763f, 0.09175128f, 0.01597782f, 0.03116974f, -0.04241641f, 
    -0.00382534f, 0.04724123f, -0.03065950f, 0.15124956f, 0.01476186f, -0.01370865f, 0.09203493f, -0.04842742f, 
    0.22425900f, 0.31447282f, -0.05063869f, -0.09174205f, 0.01631501f, 0.01771754f, 0.02636185f, -0.00083653f, 
    0.01618297f, -0.01892073f, 0.09356888f, 0.03191638f, -0.08886062f, -0.05058320f, -0.05967839f, 0.05588242f, 
    0.05226819f, 0.02477171f, 0.05524782f, 0.10241105f, -0.08678119f, -0.01583186f, -0.00519732f, 0.21778397f, 
    -0.07204136f, 0.11477564f, -0.01881643f, 0.06038003f, 0.01497969f, 0.09350786f, -0.00414306f, 0.05572291f, 
    0.03282033f, -0.02183653f, 0.01495112f, -0.02215771f, 0.01732065f, -0.15602800f, -0.10294649f, -0.00800287f, 
    0.14730835f, 0.05925956f, 0.15764377f, 0.07713021f, -0.05669418f, 0.05477985f, 0.07303123f, -0.01507022f, 
    0.21949132f, -0.06834053f, 0.08793636f, 0.00433952f, -0.11236005f, -0.02457892f, -0.03431716f, 0.01946962f, 
    0.02212028f, 0.04853281f, -0.01914934f, 0.04268546f, -0.64830345f, 0.04050483f, 0.31166652f, -0.09679216f, 
    0.22226328f, 0.00203989f, -0.04949680f, 0.14085843f, 0.11148790f, 0.10628146f, 0.10302042f, -0.01379412f, 
    0.02939268f, -0.01172626f, 0.06194613f, 0.08903854f, -0.03249731f, 0.06486727f, 0.07389287f, 0.03593074f, 
    -0.17069165f, 0.35591957f, 0.00505379f, 0.00033703f, 0.05422639f, -0.06084000f, -0.03201875f, -0.03216776f, 
    -0.06885461f, 0.03674745f, -0.01346250f, 0.00582322f, 0.05371258f, -0.02528614f, 0.11674187f, 0.12416977f, 
    -0.11261261f, 0.11646374f, 0.01975433f, -0.12931167f, 0.20369983f, -0.27926436f, 0.06102215f, 0.04929774f, 
    -0.06041018f, 0.05559468f, 0.00713381f, 0.03604428f, 0.04325075f, -0.05009691f, 0.06406507f, -0.05430872f, 
    0.05841940f, 0.15005760f, 0.08391946f, -0.01305533f, -0.03430188f, 0.09260622f, 0.07853447f, 0.08859952f, 
    -0.18702509f, -0.32900751f, 0.01014100f, -0.18511276f, -0.10326895f, -0.06043090f, 0.18284994f, -0.13778739f, 
    0.02941351f, -0.00993138f, -0.11019894f, -0.04672684f, 0.08349350f, -0.03134556f, 0.06429210f, -0.07675827f, 
    -0.02423092f, 0.09309995f, 0.03544407f, 0.05167399f, -0.09985447f, -0.36381471f, -0.01037239f, 0.34303209f, 
    -0.03932830f, 0.01979855f, 0.03179925f, 0.02972778f, 0.07234934f, 0.15571520f, 0.08761359f, 0.02441273f, 
    0.07429990f, -0.01950726f, 0.11145224f, -0.02440184f, 0.01450381f, -0.01017564f, 0.04565648f, -0.00919443f, 
    -0.15175138f, -0.07917086f, 0.12564433f, 0.10832463f, -0.05728245f, -0.04028731f, 0.01384093f, 0.03906980f, 
    -0.10447620f, 0.02268271f, -0.04004763f, -0.00069694f, -0.08587448f, -0.02722305f, 0.07544695f, 0.07553529f, 
    -0.06572642f, -0.12474276f, 0.07074910f, -0.02848119f, 0.15816259f, -0.12460463f, 0.18978000f, -0.06686641f, 
    -0.05866976f, 0.08817749f, 0.01403096f, -0.06019187f, 0.02307923f, -0.12606502f, -0.09688310f, -0.02549144f, 
    0.14247164f, 0.11063893f, 0.02854129f, -0.04946657f, 0.10945869f, 0.00646163f, 0.12305249f, 0.09990948f, 
    0.09242674f, -0.14222872f, 0.21442415f, 0.07041888f, -0.20929570f, 0.03314698f, -0.00100072f, -0.08222730f, 
    0.03083481f, -0.01668893f, -0.02729116f, 0.04496749f, 0.06210092f, -0.01282700f, -0.02147320f, -0.07158620f, 
    0.11297755f, -0.03814660f, -0.08552340f, -0.02795769f, -0.01191150f, -0.11618884f, -0.02691725f, 0.11808480f, 
    0.09421568f, -0.00786519f, 0.03435613f, 0.05264933f, 0.05291948f, 0.21453013f, -0.05629645f, 0.00846295f, 
    -0.13467214f, 0.05112331f, -0.08828565f, -0.10538622f, 0.03370091f, -0.11220758f, 0.04434615f, -0.09298089f, 
    0.09429786f, 0.01659846f, -0.08358867f, 0.00421993f, -0.12176032f, -0.00765739f, 0.03242196f, -0.04428024f, 
    0.05016052f, -0.01700814f, 0.04943920f, 0.04946696f, -0.09889991f, -0.05216671f, -0.02386408f, -0.07168832f, 
    -0.09789978f, -0.05111831f, 0.10611807f, 0.21367906f, -0.11514324f, 0.11758726f, 0.42404294f, -0.29118258f, 
    -0.02853116f, -0.03664422f, -0.03388470f, 0.15529706f, 0.04776604f, -0.05603288f, 0.06705329f, 0.03372813f, 
    -0.03179103f, 0.07980664f, 0.01115786f, 0.02006333f, -0.00483312f, 0.09051955f, 0.03325065f, 0.15592116f, 
    0.04664314f, 0.00407834f, 0.13786002f, -0.17795272f, 0.01762851f, 0.10851039f, -0.00409485f, -0.00371945f, 
    -0.00368963f, -0.09684472f, 0.00024939f, 0.05598912f, -0.07245649f, -0.01627711f, 0.12009929f, 0.01393949f, 
    0.00537388f, 0.05127576f, 0.17757842f, 0.12286844f, 0.01724165f, -0.18943781f, 0.18467762f, -0.10637224f, 
    0.01992823f, -0.07513997f, -0.05133331f, -0.06303489f, 0.07777511f, 0.05615117f, -0.08633990f, -0.03201950f, 
    0.09916130f, -0.03766715f, 0.04701635f, -0.13027909f, 0.02707037f, 0.02921128f, 0.04037830f, -0.09376270f, 
    -0.12220121f, -0.14550509f, -0.05264346f, -0.13980681f, 0.28607330f, 0.09230988f, 0.04753468f, -0.07142714f, 
    -0.04319591f, -0.13521788f, -0.08867001f, 0.10042027f, -0.00832714f, 0.04549534f, -0.00401297f, 0.14768204f, 
    -0.07874811f, 0.08305454f, 0.00779861f, 0.01148235f, -0.01857605f, -0.09736827f, -0.08153269f, 0.11086400f, 
    -0.14602344f, -0.01837465f, -0.05732739f, -0.26045710f, 0.14511165f, 0.05708229f, -0.07097569f, 0.18914792f, 
    -0.12048262f, 0.02469643f, 0.02741364f, -0.04670037f, -0.07182658f, -0.06266884f, -0.04157642f, 0.07729758f, 
    0.12233741f, 0.15481766f, -0.03642848f, 0.22336546f, -0.01033238f, 0.05951655f, -0.09026236f, 0.00629666f, 
    -0.06378775f, 0.07566892f, 0.05952084f, -0.04046417f, 0.07407172f, 0.04930777f, -0.07782242f, -0.00172631f, 
    0.00141123f, -0.00350306f, 0.03874731f, 0.03152127f, -0.14375168f, 0.06809486f, 0.16230549f, -0.25544029f, 
    -0.16999784f, 0.12055798f, 0.07301858f, 0.11214570f, 0.05175607f, -0.04854166f, -0.13109893f, 0.11673252f, 
    0.11976008f, -0.00009834f, 0.01024988f, -0.08184661f, 0.09713676f, 0.11178309f, 0.11418325f, -0.00684003f, 
    -0.03256027f, -0.13355480f, 0.16979752f, 0.21311113f, -0.14774233f, -0.08237551f, -0.10770088f, -0.08545784f, 
    -0.02340766f, 0.11363325f, 0.01051426f, 0.05289587f, -0.01977824f, 0.18668991f, -0.03744273f, -0.08654896f, 
    -0.01800200f, -0.04953168f, -0.12778650f, -0.06474552f, 0.13611683f, -0.05095367f, -0.06016332f, -0.01397305f, 
    -0.33565137f, 0.00749101f, 0.04596939f, 0.05722913f, -0.04535761f, -0.06779756f, 0.05621181f, -0.06643350f, 
    -0.09555777f, 0.04931209f, -0.12798376f, 0.05581682f, -0.04714235f, 0.14782862f, 0.10604493f, 0.28910840f, 
    -0.02390746f, 0.04213585f, -0.03433331f, 0.08589271f, 0.04809769f, 0.05104956f, -0.10201598f, 0.00081018f, 
    -0.03364682f, 0.11961426f, 0.09189382f, 0.02356139f, -0.06244520f, -0.06248317f, -0.08663793f, -0.02893544f, 
    0.04285443f, -0.05013846f, 0.02288844f, -0.10827828f, 0.04741486f, -0.07160708f, 0.30026853f, -0.05699026f, 
    0.24281998f, 0.07134861f, -0.11075967f, 0.01316758f, -0.04424072f, -0.03882328f, 0.12949060f, -0.10149269f, 
    -0.03350139f, -0.01796681f, 0.01186209f, -0.03681185f, 0.00504786f, -0.03562911f, 0.17891756f, -0.03177335f, 
    -0.07953914f, 0.07941104f, 0.09633689f, -0.26893285f, -0.11268894f, 0.02174000f, 0.01985613f, 0.10084152f, 
    -0.03630018f, 0.01750172f, -0.09933539f, -0.15657134f, -0.08118641f, -0.15563402f, -0.01520354f, 0.11300732f, 
    0.02285175f, -0.02955961f, 0.02541355f, 0.04245088f, 0.35916889f, 0.37131214f, -0.06954372f, 0.01221877f, 
    -0.13110432f, 0.04631691f, 0.04279095f, -0.00829266f, 0.01056809f, -0.01101738f, 0.10877903f, -0.03711124f, 
    0.07554439f, -0.07848110f, -0.00040460f, -0.01935230f, -0.03891064f, 0.04798711f, 0.10945487f, 0.04819021f, 
    0.26660720f, -0.16853091f, -0.02692876f, 0.26065654f, -0.19912334f, -0.08076382f, 0.11027998f, -0.04566045f, 
    0.00741137f, 0.06395564f, 0.04630077f, 0.04869242f, 0.02345710f, 0.02115983f, 0.02982496f, -0.06033159f, 
    -0.05428776f, 0.02974892f, -0.17483924f, -0.01299974f, 0.24480119f, 0.02257037f, -0.03403434f, 0.29170570f, 
    -0.09791658f, -0.11501781f, -0.00411938f, 0.02704376f, 0.10997231f, -0.01235466f, 0.00332145f, -0.00356723f, 
    0.07181566f, -0.04629444f, 0.04506604f, 0.05648208f, -0.00803899f, -0.02397617f, -0.02761905f, 0.04354577f, 
    0.24743897f, -0.04517540f, 0.02219269f, -0.03942029f, -0.19719198f, -0.08022960f, 0.09677865f, -0.01983734f, 
    0.01397933f, -0.06742960f, -0.03689681f, 0.06122379f, 0.00880218f, -0.01156704f, -0.02022995f, 0.10701263f, 
    0.14807051f, 0.01452022f, 0.10667977f, 0.13784280f, 0.31275010f, -0.53296626f, -0.02296568f, -0.03314548f, 
    -0.10477654f, -0.14430670f, -0.06908291f, 0.06406460f, 0.15104948f, 0.02278633f, -0.03144544f, -0.03545481f, 
    0.04518534f, -0.09071604f, 0.07628679f, -0.02347654f, -0.05530850f, 0.15441358f, -0.13835834f, -0.01483865f, 
    0.13681553f, 0.28547281f, 0.20392723f, -0.06321324f, -0.06868117f, 0.08563459f, -0.11095879f, 0.08300534f, 
    -0.05007309f, 0.02509824f, 0.05077161f, 0.02065264f, 0.06347257f, -0.05603593f, -0.06768326f, 0.02783929f, 
    -0.04596775f, 0.07564183f, 0.09826098f, 0.02552029f, 0.13614915f, 0.04898732f, -0.11902173f, 0.19268355f, 
    -0.12626344f, -0.17389630f, 0.05844095f, -0.04481871f, 0.02480872f, 0.08809843f, 0.03722196f, 0.08493270f, 
    0.15406309f, -0.05208585f, -0.05341860f, 0.06423793f, 0.00395609f, 0.05083830f, -0.11396902f, 0.00653918f, 
    0.03092926f, -0.04088812f, -0.00091280f, 0.01808836f, -0.00644629f, -0.03133745f, 0.00657222f, 0.00794295f, 
    0.02284306f, 0.02831268f, 0.01255740f, -0.02851123f, -0.01488767f, -0.00571275f, 0.02302767f, -0.03424161f, 
    -0.00618573f, -0.03968254f, -0.00626682f, 0.01940685f, 0.00692833f, 0.01501178f, 0.02643974f, -0.02849828f, 
    0.02018116f, 0.02312098f, 0.01675786f, 0.02911767f, 0.00015841f, -0.03401696f, -0.01412998f, -0.04054423f, 
    0.00879279f, -0.02190568f, -0.03600735f, -0.01658702f, -0.01854823f, -0.04317758f, -0.02256164f, 0.03887173f, 
    0.02451446f, 0.01900895f, -0.02149989f, 0.02825628f, -0.02044935f, 0.00445847f, -0.03363530f, -0.02329788f, 
    0.02866607f, 0.01390008f, 0.01811295f, -0.04269905f, -0.02285658f, -0.01756056f, 0.03080570f, -0.00551411f, 
    -0.00002963f, -0.03282492f, 0.01789356f, -0.02385231f, -0.03759904f, 0.01393611f, 0.00234796f, -0.02378413f, 
    -0.04308499f, -0.02183459f, -0.03999958f, -0.01267927f, -0.03049789f, 0.00319616f, 0.02174330f, 0.02304975f, 
    0.01376853f, -0.01386852f, 0.00743410f, -0.02762665f, -0.03278084f, 0.02998674f, 0.01363352f, 0.02859947f, 
    -0.01664169f, -0.01718610f, -0.00023704f, -0.02276196f, -0.02037809f, 0.01085037f, -0.00348964f, 0.01141240f, 
    0.00202240f, 0.01061026f, -0.00076662f, -0.04486654f, 0.01137927f, 0.02112559f, -0.01946539f, 0.00224676f, 
    -0.01857993f, -0.01368400f, 0.01215946f, -0.02704614f, -0.03665310f, 0.00337405f, -0.00560137f, -0.03605121f, 
    -0.00422910f, -0.02573667f, -0.02595071f, 0.01579808f, 0.01159986f, -0.02891908f, 0.01476678f, -0.00643160f, 
    -0.03720719f, -0.02950776f, -0.00414707f, 0.03215807f, 0.01632686f, 0.01611201f, 0.01668469f, 0.00030901f, 
    -0.02421392f, 0.03416984f, 0.00953320f, 0.00323596f, -0.01772968f, 0.00552443f, 0.01681999f, 0.00365555f, 
    0.02685028f, -0.00708146f, 0.00411327f, 0.02184649f, -0.02269588f, 0.02788333f, 0.00094454f, -0.00209398f, 
    -0.00352005f, 0.02949336f, 0.03163892f, 0.02496696f, 0.02523315f, -0.00339489f, -0.00228896f, 0.03256796f, 
    0.02828316f, -0.03445164f, 0.00579620f, -0.04249519f, -0.02685122f, 0.03895767f, 0.02960745f, -0.04345026f, 
    0.02135604f, -0.00947318f, 0.03601902f, -0.02948700f, 0.00009916f, 0.01879160f, 0.00150440f, -0.03573560f, 
    -0.01298289f, 0.00949559f, 0.04403229f, -0.02525296f, 0.00501548f, 0.00280064f, 0.01028689f, -0.01381484f, 
    0.00661200f, 0.02984771f, -0.03784335f, 0.01988281f, -0.02276775f, 0.00236548f, -0.00352403f, 0.00607942f, 
    0.00171873f, -0.00191590f, 0.03112440f, -0.02143905f, -0.00230153f, 0.01903450f, 0.01885186f, -0.03377035f, 
    0.02911924f, -0.01956211f, -0.03081322f, -0.00694471f, 0.00534344f, -0.03380383f, 0.01130090f, -0.03318550f, 
    0.02492080f, -0.00339535f, -0.04363903f, -0.02969155f, -0.00776719f, 0.00407179f, -0.02670467f, -0.00975316f, 
    -0.01871484f, -0.01626846f, -0.01931051f, 0.00794159f, 0.00256635f, -0.02041753f, 0.02310536f, -0.00774896f, 
    -0.02264249f, 0.03492997f, -0.03443966f, -0.00012261f, -0.02722844f, -0.01282269f, 0.00847555f, 0.00967439f, 
    -0.01409005f, -0.01303496f, -0.01273246f, -0.00529127f, -0.00609759f, -0.01365891f, 0.01334942f, 0.01226640f, 
    0.00643487f, -0.04026507f, 0.00492213f, 0.01413617f, -0.01896017f, -0.03448050f, 0.00669625f, -0.03329596f, 
    0.02861171f, -0.02553163f, -0.03924800f, -0.04296217f, -0.03831841f, -0.02686998f, -0.03604146f, -0.02280173f, 
    -0.03449566f, 0.00350537f, -0.03627951f, -0.01633279f, -0.03584861f, 0.02676008f, -0.01886504f, -0.04161019f, 
    -0.01836283f, -0.03437443f, -0.03415148f, -0.01123802f, -0.04408469f, -0.03505298f, -0.02711440f, -0.00403857f, 
    -0.03943161f, -0.03184761f, 0.01859440f, -0.01172645f, -0.01550892f, -0.03445797f, 0.01722311f, -0.01246930f, 
    0.00909717f, 0.00405427f, -0.01734353f, -0.02928691f, 0.00560593f, -0.01968057f, 0.00114328f, 0.02577647f, 
    0.01340148f, 0.02762908f, -0.01053484f, -0.01272621f, 0.01183222f, 0.01646446f, 0.00363343f, 0.01714603f, 
    0.02422664f, -0.02668331f, -0.00418872f, -0.02438820f, -0.04163807f, -0.01000826f, 0.02026191f, -0.01696228f, 
    -0.02168225f, -0.02642066f, -0.02238026f, -0.01111812f, -0.04054186f, -0.01960116f, 0.03667480f, -0.02486487f, 
    -0.04706063f, 0.00477936f, 0.02808697f, 0.00123416f, -0.02932527f, -0.04266343f, 0.01545628f, -0.01767955f, 
    0.02253370f, -0.02330814f, -0.00594345f, 0.00524624f, 0.02009628f, 0.00322905f, -0.03166424f, -0.03927836f, 
    -0.02593344f, -0.01619053f, -0.01738609f, -0.02787955f, -0.01900740f, -0.03044415f, -0.01468581f, 0.00328925f, 
    0.03071205f, 0.00033586f, 0.03930699f, -0.00266770f, 0.03486362f, 0.00376023f, 0.02703869f, -0.02134355f, 
    0.03123344f, 0.01439982f, -0.01420360f, -0.02265930f, -0.00521960f, 0.00113629f, 0.02488057f, 0.02632184f, 
    -0.04657513f, 0.00421805f, -0.02925799f, -0.00221046f, -0.03859849f, -0.02076374f, -0.03588056f, 0.03026755f, 
    0.00860067f, 0.02887754f, 0.02294826f, 0.01523799f, 0.03838624f, 0.02351546f, 0.03028536f, -0.00662112f, 
    -0.03774929f, -0.03578955f, -0.02284365f, -0.04230293f, 0.01139123f, -0.00403894f, 0.02032997f, 0.00267439f, 
    -0.01723189f, -0.04447648f, 0.01282489f, 0.02935290f, -0.01783395f, 0.00201403f, -0.01394906f, 0.02083621f, 
    -0.04083342f, -0.00037215f, 0.00960568f, -0.04334306f, -0.01626803f, -0.01163933f, 0.00420405f, -0.00978184f, 
    -0.01524666f, 0.01774434f, 0.00955634f, -0.04513137f, -0.02108274f, 0.00361598f, 0.02088596f, 0.02900349f, 
    -0.01129852f, -0.02982986f, -0.02970705f, 0.00546679f, -0.03340589f, -0.03253124f, -0.04417467f, -0.03049620f, 
    0.02734278f, -0.00101383f, 0.00601105f, -0.01716319f, -0.00109823f, 0.01055903f, 0.00204912f, 0.02603968f, 
    0.01291375f, -0.00863592f, -0.00824454f, -0.02538231f, -0.02763248f, -0.00956934f, -0.03762770f, -0.00861435f, 
    0.00995848f, 0.03581802f, -0.01388260f, -0.03266690f, -0.01847186f, -0.00250410f, -0.03020146f, 0.03493397f, 
    -0.02705215f, -0.01637712f, 0.01322267f, 0.03060028f, -0.00336950f, 0.02597178f, -0.00098539f, 0.00886391f, 
    0.02148338f, 0.03149015f, -0.00063434f, -0.04017029f, -0.02328489f, -0.00745015f, 0.00136637f, -0.02437004f, 
    -0.02537328f, -0.02829133f, -0.00796812f, -0.03934388f, 0.02885787f, -0.01102982f, 0.02303541f, -0.01883620f, 
    0.01498738f, -0.02979288f, -0.03348784f, 0.00531771f, -0.01006163f, -0.00039224f, 0.01736272f, 0.01511999f, 
    0.03469341f, 0.02083052f, 0.02508216f, 0.01248688f, 0.03016917f, -0.04603000f, -0.01282930f, 0.00171174f, 
    0.02034669f, 0.00846887f, -0.00862520f, 0.03171140f, 0.00157048f, -0.01288837f, -0.00999531f, -0.01166037f, 
    0.00214987f, 0.00850170f, -0.01392565f, 0.03036480f, -0.04299435f, -0.00036844f, 0.02687477f, 0.00673165f, 
    0.00504206f, 0.00007841f, -0.04135854f, 0.02013900f, -0.00302284f, -0.02700083f, -0.03787861f, -0.04005975f, 
    -0.03099340f, -0.03337326f, 0.01372442f, -0.04076569f, -0.03311616f, 0.01988912f, 0.00141126f, 0.00041990f, 
    0.02996892f, 0.02577381f, 0.03135397f, -0.02362801f, 0.01528098f, -0.02621249f, -0.00400636f, -0.02143243f, 
    0.02755877f, 0.02029674f, 0.01969165f, -0.01875416f, 0.00177782f, -0.01524741f, -0.03847791f, -0.02222299f, 
    0.01696961f, -0.01194900f, -0.03139121f, -0.02418182f, 0.00245335f, 0.02636075f, -0.01130053f, 0.03355723f, 
    0.03111640f, 0.02806699f, 0.01223287f, 0.01123082f, -0.04373173f, -0.00119555f, -0.04590366f, 0.01493497f, 
    0.03521482f, -0.00055204f, -0.00232648f, -0.00481854f, 0.01894705f, 0.01868558f, -0.00490222f, 0.02206858f, 
    -0.03797463f, -0.02056245f, 0.00511487f, -0.00100894f, 0.01781005f, 0.01074759f, -0.02279138f, 0.00472308f, 
    -0.03374254f, 0.03057882f, -0.02691645f, 0.00547837f, -0.03765253f, -0.00319366f, 0.01116036f, -0.00506831f, 
    -0.00238210f, 0.00140009f, 0.02820703f, -0.02905970f, 0.01486537f, 0.00620607f, -0.01404141f, -0.01126924f, 
    0.00884570f, -0.01623302f, -0.03523739f, -0.00103772f, 0.02143751f, -0.04668513f, 0.00335222f, -0.04248433f, 
    -0.03861831f, 0.00334736f, 0.02159565f, -0.00718585f, -0.00337010f, 0.00400419f, 0.00410465f, -0.00201121f, 
    0.01647524f, -0.02197210f, 0.00745658f, -0.00222794f, -0.02114248f, -0.00345672f, -0.00613187f, -0.03395218f, 
    0.03191642f, 0.01372989f, -0.03609795f, -0.04572636f, -0.01545429f, 0.03362083f, -0.01691457f, -0.03608157f, 
    0.02533321f, -0.04394528f, -0.02931459f, -0.02612404f, 0.02230969f, 0.02567393f, -0.00111882f, -0.01061652f, 
    0.00682245f, 0.01381015f, -0.01341281f, 0.00074333f, 0.03386474f, -0.01218424f, 0.01360727f, -0.02466592f, 
    -0.01164500f, -0.01881336f, -0.00967796f, -0.03638677f, -0.04483160f, -0.02728931f, -0.03649462f, 0.00734838f, 
    -0.04547803f, 0.00991142f, 0.01365889f, 0.02773604f, -0.03946287f, -0.02755813f, 0.01016145f, 0.02144132f, 
    0.01923186f, -0.01811739f, -0.00853560f, 0.02757317f, -0.01209356f, -0.03333604f, -0.03696912f, -0.00144144f, 
    -0.01068197f, 0.00258674f, 0.03512648f, -0.01022978f, 0.01434352f, 0.00151662f, -0.02448969f, 0.01261698f, 
    0.02755331f, 0.02868009f, -0.04160823f, -0.04139780f, -0.02436561f, -0.00806294f, 0.02146784f, 0.01502749f, 
    -0.02845128f, -0.01010967f, -0.04854761f, -0.00385445f, -0.02303709f, 0.03585197f, -0.04182205f, -0.02634076f, 
    -0.02951026f, -0.02833991f, -0.00692978f, -0.01002767f, 0.02083363f, -0.03095375f, 0.00379406f, 0.00286894f, 
    0.01521612f, 0.00965364f, 0.01867743f, -0.00756434f, -0.00631688f, 0.00467845f, 0.02173419f, 0.02337115f, 
    0.00833688f, -0.01802560f, -0.00185650f, -0.04481414f, -0.01195595f, -0.03163390f, 0.00093392f, -0.00194389f, 
    -0.00364481f, 0.01761299f, -0.01439519f, -0.04218455f, 0.01742299f, -0.01028631f, 0.02004960f, -0.00703925f, 
    -0.04747488f, -0.03614290f, -0.00154785f, -0.02286155f, -0.03134931f, 0.00230100f, -0.01987216f, -0.02717741f, 
    -0.03899499f, -0.03769318f, -0.01754254f, -0.02765882f, -0.04849927f, -0.02448899f, -0.02676065f, -0.02296808f, 
    -0.04029568f, -0.01503356f, 0.01041156f, -0.00737611f, -0.01056891f, 0.01254675f, 0.00479185f, -0.02136211f, 
    0.03592154f, 0.02844561f, 0.00387954f, -0.04338490f, -0.01692455f, -0.02069603f, 0.00682955f, 0.01521591f, 
    0.00002903f, -0.01192925f, -0.01245851f, -0.03262929f, -0.01963077f, -0.03112958f, -0.01641250f, 0.01175059f, 
    0.01390827f, 0.02567453f, -0.03746673f, -0.03070084f, -0.04028517f, 0.00287058f, 0.01871363f, -0.00080164f, 
    0.01837878f, 0.02709325f, 0.03362750f, 0.02821290f, -0.03659883f, -0.02065894f, 0.03054576f, 0.01007355f, 
    0.00855272f, -0.03321002f, -0.00402983f, 0.00884412f, 0.01598771f, 0.02123796f, -0.03594458f, -0.01574081f, 
    -0.00110224f, -0.03414651f, -0.02247138f, 0.01630090f, -0.00664245f, 0.01534338f, -0.04465991f, -0.01707285f, 
    -0.01111719f, -0.04466058f, 0.00055860f, -0.02739436f, 0.02494629f, 0.00547743f, 0.01563948f, -0.00848919f, 
    -0.02840137f, -0.00024941f, -0.04531146f, -0.01196204f, -0.00555271f, 0.00275917f, 0.02654658f, -0.02737636f, 
    -0.02826476f, -0.01899110f, -0.03778319f, -0.02882819f, 0.00847773f, -0.00336421f, 0.02290866f, 0.02532401f, 
    -0.01379494f, -0.03059148f, 0.00360203f, -0.03505067f, -0.02688486f, -0.03505614f, 0.00002480f, 0.01709898f, 
    0.00535204f, 0.01446768f, -0.03036752f, -0.02366882f, 0.02096608f, -0.00240260f, -0.03915001f, -0.03902813f, 
    -0.04759271f, 0.02756235f, -0.00634028f, 0.01775622f, -0.00699550f, -0.02710892f, -0.01226824f, 0.02161045f, 
    -0.04326372f, 0.02167336f, -0.01847769f, -0.03720569f, -0.01132079f, 0.01290667f, -0.02003933f, -0.04145416f, 
    -0.03217062f, -0.02641665f, -0.00837318f, -0.04224529f, -0.04432268f, 0.02438101f, 0.02301889f, 0.03342763f, 
    -0.00917642f, 0.00473295f, -0.00911657f, 0.00953077f, 0.01239448f, -0.02331814f, -0.01244748f, 0.01048147f, 
    -0.00911464f, -0.02092257f, 0.03705675f, -0.00095606f, 0.02628233f, 0.01752115f, -0.02814098f, -0.00027795f, 
    0.03492497f, 0.02891576f, 0.03068410f, -0.01976819f, 0.00697815f, 0.03943818f, 0.02597245f, -0.01661491f, 
    -0.03362761f, -0.02520253f, -0.02887171f, 0.00669572f, 0.00648064f, -0.02418907f, -0.01219052f, -0.03715241f, 
    -0.04512081f, -0.01920296f, -0.01508460f, 0.02816231f, -0.02004592f, -0.01593401f, 0.00359533f, 0.01106556f, 
    -0.02031794f, 0.01471903f, -0.01549187f, -0.03684292f, -0.01318629f, 0.03152308f, -0.02038000f, -0.00622495f, 
    -0.02788723f, 0.02534474f, 0.01114241f, -0.01659462f, 0.00341836f, -0.00781853f, -0.01457553f, -0.03898177f, 
    -0.03220352f, -0.04057299f, 0.00717972f, 0.02961268f, -0.01631934f, 0.01033506f, 0.01300739f, 0.01001725f, 
    -0.03926877f, 0.00308618f, -0.00793330f, 0.01274728f, -0.01425627f, -0.04243627f, -0.00268794f, 0.01631922f, 
    0.02839002f, 0.02492679f, 0.01045364f, 0.01132305f, -0.03828361f, -0.00102173f, -0.02902928f, -0.01476309f, 
    0.02151346f, 0.01077619f, -0.03307097f, -0.03085910f, 0.00640553f, -0.02097811f, -0.04475147f, -0.01755883f, 
    -0.01377778f, 0.01259473f, -0.00476755f, 0.00455598f, -0.03560854f, 0.02653766f, -0.00871862f, -0.01130520f, 
    -0.03697967f, -0.00036407f, -0.00775720f, -0.02448533f, -0.01129082f, -0.01897230f, -0.03070264f, 0.00990520f, 
    -0.03949727f, -0.03445829f, 0.01545482f, -0.00602658f, -0.02017892f, -0.00399494f, -0.04542277f, 0.00959931f, 
    -0.03213052f, 0.01364842f, 0.03292034f, -0.03084821f, -0.00241000f, -0.01119485f, -0.03476160f, -0.02402139f, 
    0.01474225f, 0.00073241f, 0.01086929f, 0.01163450f, -0.01156877f, -0.03558002f, 0.00563172f, -0.02163508f, 
    0.01676881f, 0.02139097f, -0.03805950f, 0.00839834f, -0.02221433f, -0.01770466f, 0.02884721f, -0.03340232f, 
    0.02137917f, 0.00048573f, 0.02217093f, 0.02254154f, -0.04849685f, -0.01466330f, -0.00880040f, 0.02366545f, 
    -0.03860564f, 0.00679737f, 0.01551396f, 0.02622342f, -0.02736725f, -0.02121086f, 0.00006259f, 0.02329881f, 
    -0.02316928f, 0.00871252f, -0.02450234f, 0.00134612f, -0.00716154f, 0.00681757f, 0.02956024f, 0.00433496f, 
    -0.01609935f, 0.00250122f, 0.02693403f, -0.01787319f, 0.00732503f, 0.00969249f, 0.00437360f, 0.01260461f, 
    0.01759062f, 0.00713040f, -0.03657882f, 0.00182488f, 0.02907068f, -0.00611047f, 0.01074232f, -0.02132842f, 
    0.01000409f, 0.02408512f, -0.02757484f, 0.00689672f, -0.00041675f, -0.04349046f, -0.03259343f, -0.02328165f, 
    0.00040041f, -0.00492020f, -0.03552685f, 0.01862519f, 0.02895194f, -0.02849694f, -0.00992959f, -0.02445921f, 
    0.00575270f, -0.03352311f, 0.00095177f, 0.01783498f, -0.03647961f, -0.01567486f, 0.02376195f, -0.00653188f, 
    0.02188467f, -0.03679726f, 0.01268606f, -0.03742684f, -0.02773944f, 0.00581836f, 0.02149055f, -0.00982039f, 
    -0.03336425f, 0.00842591f, -0.00272700f, 0.00000854f, 0.02637576f, -0.00609454f, -0.00345894f, -0.02775875f, 
    0.03401912f, 0.02856374f, -0.01547192f, -0.03872700f, 0.00702259f, 0.00417250f, -0.02726270f, 0.02682593f, 
    0.02240579f, 0.00164333f, -0.02195633f, 0.00203120f, 0.03319899f, 0.00578682f, 0.00608308f, -0.00927396f, 
    -0.04240501f, -0.04834364f, 0.00577822f, 0.01718842f, 0.00781198f, 0.01584776f, -0.01496679f, -0.03356337f, 
    -0.04393087f, 0.01101399f, 0.01540956f, -0.01795158f, -0.00576358f, -0.04659918f, 0.01718847f, -0.00734937f, 
    0.02820842f, 0.01193990f, 0.00722024f, -0.02272751f, -0.01397433f, -0.04784939f, -0.02707474f, 0.03057683f, 
    -0.03344512f, -0.01216850f, 0.00786895f, -0.02094089f, -0.01221375f, 0.01261253f, 0.02818379f, -0.03811988f, 
    0.03218766f, 0.03169528f, 0.01817807f, 0.02019978f, -0.02395883f, -0.00683778f, 0.01829295f, -0.00676243f, 
    -0.02997219f, -0.02280619f, -0.04050834f, 0.02479651f, -0.03349956f, -0.00521226f, -0.00664967f, 0.02443115f, 
    -0.02142538f, -0.01634971f, 0.00632244f, -0.03560330f, 0.02382612f, 0.01113756f, -0.00690634f, -0.02969932f, 
    -0.00365508f, -0.03883901f, -0.02397294f, 0.03228076f, 0.02219541f, -0.01155148f, -0.04800683f, -0.01648126f, 
    -0.00280519f, -0.02924676f, -0.03647863f, 0.00283091f, 0.00550971f, 0.02966809f, 0.00999561f, -0.00055411f, 
    0.02545913f, 0.03322395f, 0.00302218f, -0.02521341f, -0.02806681f, -0.03193588f, 0.01529907f, -0.00024912f, 
    -0.03703349f, 0.02361052f, 0.02127326f, -0.03043640f, 0.01381546f, 0.03348941f, 0.00136089f, 0.02007470f, 
    0.01579548f, -0.03578198f, 0.02053941f, 0.03505038f, -0.04590333f, -0.04412759f, -0.03004737f, 0.02107260f, 
    -0.01082516f, -0.02711448f, 0.03481039f, -0.03072749f, -0.00654141f, 0.01018049f, 0.00565491f, 0.00590880f, 
    -0.03650671f, 0.02566623f, -0.00950271f, 0.01318110f, 0.04087252f, -0.03393335f, -0.04224502f, 0.02785151f, 
    0.02652480f, -0.00677841f, 0.00647705f, 0.00529622f, -0.00800367f, -0.03194040f, -0.01931814f, -0.00629737f, 
    -0.02025200f, -0.00380343f, -0.03148532f, -0.02043440f, 0.01699858f, -0.00102831f, 0.01947059f, -0.00287361f, 
    -0.01104573f, -0.03518032f, -0.03535665f, -0.01742535f, -0.00241116f, -0.00150906f, -0.04465161f, -0.00261002f, 
    -0.02709575f, 0.01790807f, 0.03276380f, 0.01777673f, 0.01464344f, -0.00288286f, 0.00772913f, 0.00821959f, 
    -0.00975893f, -0.02375293f, 0.00473247f, -0.03878953f, -0.04082115f, 0.00244302f, 0.02283414f, -0.01379331f, 
    0.02634103f, 0.01741704f, -0.03886279f, -0.02788495f, -0.02243233f, -0.02425112f, -0.03492600f, 0.00962786f, 
    -0.04248075f, -0.01073101f, -0.04169760f, -0.03406272f, -0.02605190f, -0.04592020f, -0.02742971f, -0.02703409f, 
    0.03929006f, -0.03697860f, 0.02138312f, 0.02716140f, -0.03103109f, -0.01725762f, -0.03076910f, -0.01575354f, 
    -0.02459092f, -0.00914486f, -0.02202792f, 0.03263771f, -0.01663233f, -0.01909608f, 0.02899635f, -0.03809710f, 
    -0.03290652f, -0.02573592f, -0.01452690f, 0.02903662f, 0.02424113f, 0.00033961f, -0.01598317f, -0.04417736f, 
    -0.03248386f, -0.01979113f, -0.01253450f, -0.02000312f, 0.02822958f, -0.01088243f, -0.01157867f, -0.02307883f, 
    0.01179411f, -0.03090898f, 0.00469298f, 0.02250061f, -0.02889257f, -0.02303367f, 0.02703329f, 0.01180251f, 
    -0.03429528f, -0.02500127f, 0.01947808f, 0.00963617f, -0.04400344f, -0.01808647f, -0.00177489f, -0.00590246f, 
    0.00165015f, -0.01654363f, -0.00222041f, -0.00337851f, -0.04517978f, -0.03502501f, -0.00939306f, 0.02845713f, 
    0.01759182f, -0.02470474f, -0.01851210f, -0.00667891f, -0.02628238f, 0.01921669f, 0.01111276f, -0.00449539f, 
    -0.00242060f, -0.01975926f, 0.02416020f, -0.04365008f, 0.02363024f, 0.02812876f, -0.04227866f, 0.02906051f, 
    -0.01177382f, -0.02814392f, 0.02234023f, 0.02804759f, 0.00482688f, -0.04020953f, -0.02531574f, -0.02952140f, 
    -0.01329873f, -0.00874296f, 0.02611003f, -0.00905781f, -0.02470250f, 0.01966701f, -0.03614377f, 0.03262254f, 
    0.00728358f, -0.03978702f, -0.00108355f, -0.01293689f, -0.01264040f, -0.03248235f, 0.00359863f, 0.01525785f, 
    -0.00782884f, 0.02814121f, -0.01509353f, -0.00705361f, 0.02645191f, 0.01401845f, -0.01642692f, -0.02067339f, 
    0.02352296f, -0.03287645f, -0.00232244f, -0.03052763f, 0.01823308f, 0.01643307f, -0.02861986f, 0.00613694f, 
    0.00876979f, -0.02065299f, 0.00536894f, -0.01678589f, -0.00969520f, 0.02377751f, -0.02869759f, -0.04133502f, 
    0.01123509f, -0.01820726f, 0.00919771f, 0.00658646f, 0.03217620f, -0.00022938f, 0.00634176f, 0.03275834f, 
    -0.03236814f, 0.02298191f, 0.02036647f, -0.04446139f, -0.03261775f, 0.00411313f, -0.01654053f, 0.01813640f, 
    0.01517805f, 0.01193114f, -0.02549877f, 0.00408376f, -0.02321573f, -0.01925278f, -0.02443783f, -0.03074625f, 
    -0.01590062f, -0.00448519f, -0.04456942f, -0.01694415f, -0.00791228f, 0.02053876f, 0.02635823f, -0.00156401f, 
    -0.02914919f, 0.02350726f, -0.04117621f, -0.02125022f, -0.00805818f, -0.01035509f, -0.03817232f, 0.01434504f, 
    0.03025161f, -0.01474767f, -0.00661309f, -0.02850391f, 0.01897558f, -0.00200179f, 0.01932504f, -0.01368462f, 
    -0.04016470f, 0.01826801f, -0.00390063f, 0.02867702f, -0.03099419f, -0.02424735f, -0.03263718f, 0.00705024f, 
    0.00882000f, -0.00176917f, -0.01834928f, 0.00800498f, -0.04251431f, -0.01563604f, -0.02090872f, -0.03933778f, 
    0.01710896f, -0.00827088f, -0.00282747f, 0.00993451f, -0.02706968f, 0.03701023f, 0.00052397f, 0.00806338f, 
    -0.01760693f, 0.00241809f, 0.01602959f, 0.01025047f, 0.01207925f, -0.01350674f, 0.00246962f, -0.04155714f, 
    -0.03861667f, -0.01489300f, 0.00524237f, -0.03669454f, 0.01704296f, -0.00849020f, 0.01688037f, 0.00443373f, 
    0.03073733f, 0.02639530f, 0.00597184f, -0.00133686f, -0.01359839f, -0.03477569f, -0.01303573f, -0.01146227f, 
    -0.01040953f, 0.02546212f, 0.02956214f, 0.00654650f, -0.04305224f, 0.00931109f, -0.04133108f, -0.04444201f, 
    -0.03216914f, 0.01604122f, 0.02023910f, -0.02269889f, 0.03262163f, -0.04411124f, 0.02877981f, -0.03113391f, 
    -0.04293322f, 0.02484579f, 0.04515176f, -0.00622674f, -0.00419187f, 0.00463567f, 0.01350575f, -0.01653984f, 
    -0.03965756f, -0.00212891f, -0.00177454f, -0.01593120f, -0.02250245f, -0.02400431f, 0.01630184f, 0.03187677f, 
    0.01530577f, -0.01539127f, -0.01004481f, -0.00217750f, 0.02855027f, -0.02517960f, 0.00417988f, -0.02301459f, 
    0.03661665f, -0.03167002f, 0.00337133f, -0.00996816f, -0.01568198f, -0.00147783f, 0.01886244f, 0.00605209f, 
    -0.01159284f, -0.00136644f, -0.01754291f, -0.02523474f, -0.00272546f, -0.02720690f, -0.01493757f, -0.04256523f, 
    0.01878992f, 0.03061967f, 0.02801372f, 0.01237308f, -0.00302799f, 0.01545393f, 0.01271706f, -0.03508407f, 
    0.01275490f, 0.02600782f, 0.02396023f, -0.03872769f, -0.01180793f, -0.04357273f, 0.02976000f, 0.02342916f, 
    -0.03246713f, -0.01309893f, -0.00326060f, -0.04488638f, 0.01367037f, -0.04190546f, 0.03154016f, -0.01385958f, 
    0.01048071f, -0.02418967f, -0.04530080f, -0.02682197f, -0.03333845f, -0.00517374f, -0.04475052f, -0.00335356f, 
    0.01091356f, -0.03430612f, -0.00585830f, 0.02370565f, -0.02475674f, -0.00462160f, 0.00384262f, -0.01263297f, 
    0.00242167f, 0.00256346f, 0.03763322f, 0.04042960f, -0.02985612f, -0.03058730f, -0.01911870f, -0.04249094f, 
    -0.03648558f, -0.01212294f, -0.02300481f, 0.01845394f, 0.03184682f, -0.02109876f, 0.01354072f, -0.03346179f, 
    0.02722292f, -0.00138811f, 0.00321443f, -0.01970403f, -0.01779813f, 0.02915908f, -0.03770089f, -0.00875929f, 
    -0.01984688f, 0.01604650f, -0.00820419f, -0.04080846f, -0.00605446f, 0.01917307f, 0.00286598f, 0.02159004f, 
    0.04117042f, -0.01297831f, 0.01621405f, -0.01319000f, -0.02756126f, -0.04337626f, 0.02536385f, 0.02342886f, 
    0.01227244f, 0.01627421f, 0.02832522f, 0.01245639f, -0.01172739f, -0.03009138f, 0.01601829f, 0.03057577f, 
    0.02252091f, -0.01035382f, 0.00607422f, 0.04301594f, 0.02381008f, -0.03570781f, 0.01209801f, 0.01455259f, 
    -0.04408297f, -0.03964791f, 0.02359236f, -0.01713680f, 0.00358961f, -0.02119290f, -0.04348421f, 0.00770742f, 
    0.02518442f, 0.01688009f, -0.02013820f, -0.03007106f, 0.02903743f, -0.01176129f, 0.00499682f, -0.04157916f, 
    0.00361236f, 0.00574795f, -0.02133248f, 0.01691460f, 0.01662743f, -0.00032361f, -0.01215886f, -0.00642971f, 
    -0.02448134f, -0.02170987f, -0.04299484f, 0.00554598f, -0.02141982f, 0.00394292f, -0.01845700f, -0.01384060f, 
    0.00301324f, 0.01775112f, 0.03125852f, 0.03664092f, -0.04049629f, -0.01598096f, 0.01412238f, 0.02170975f, 
    -0.03063459f, -0.00056846f, 0.02814819f, -0.00957890f, -0.00478344f, 0.02111146f, -0.01385702f, 0.00700482f, 
    0.02965984f, 0.03674759f, -0.02556009f, 0.02514425f, -0.02522135f, -0.01348680f, 0.00981218f, -0.02873432f, 
    0.01351336f, -0.02177299f, 0.01589766f, -0.02650723f, -0.00150856f, -0.03610195f, 0.02814052f, 0.02019266f, 
    -0.04456808f, 0.00983181f, -0.00170073f, -0.01576563f, -0.04102068f, -0.01266676f, 0.02461720f, -0.03238215f, 
    -0.04295418f, -0.00580107f, -0.04340297f, -0.01645035f, -0.00942401f, 0.01292022f, 0.01268145f, -0.00798169f, 
    -0.03430336f, -0.03416482f, 0.01670838f, -0.03310145f, 0.01776339f, -0.04256513f, 0.02061614f, 0.01532492f, 
    -0.03009480f, 0.03112228f, -0.02467189f, -0.02263306f, -0.01378683f, -0.00959734f, 0.03874577f, -0.00784885f, 
    -0.03437042f, 0.00415104f, -0.00151036f, -0.01285366f, 0.01375990f, 0.02068621f, -0.01261659f, 0.00412342f, 
    0.01337526f, 0.03172848f, 0.01787651f, 0.02324110f, -0.00845371f, -0.03896178f, -0.02108598f, 0.02015626f, 
    -0.02201258f, 0.02383635f, 0.02219916f, -0.03906106f, -0.03367027f, -0.04066669f, -0.03734368f, -0.03587330f, 
    -0.02966749f, 0.00533718f, 0.00560527f, -0.01349141f, 0.01436997f, 0.00683990f, -0.02891335f, 0.00636150f, 
    0.01747072f, -0.04394353f, 0.00313815f, -0.04389958f, 0.00166702f, -0.00082004f, 0.00464610f, 0.03408627f, 
    0.01799290f, -0.01257648f, 0.02006811f, 0.01196579f, 0.02149752f, -0.03573935f, -0.01626500f, -0.03568590f, 
    0.00275114f, -0.04269959f, 0.00535537f, 0.00185853f, 0.02968603f, -0.00831881f, 0.01936097f, 0.02643537f, 
    0.00787529f, -0.02995044f, 0.01370831f, 0.01295719f, -0.00262349f, 0.02524167f, 0.01668170f, -0.01774593f, 
    0.01140697f, -0.03954519f, 0.00894355f, -0.04405363f, -0.02339733f, 0.00549997f, 0.02118406f, 0.03195741f, 
    -0.01105679f, -0.02410879f, -0.00035084f, -0.02454102f, 0.00403991f, -0.03441805f, 0.01198941f, 0.02121303f, 
    -0.01961095f, -0.00418724f, -0.00708366f, 0.00776375f, 0.01505641f, 0.02863436f, 0.00122079f, -0.03251974f, 
    -0.01925158f, -0.00323234f, -0.01132372f, -0.01817731f, 0.01356485f, -0.00833861f, 0.03997860f, 0.03228388f, 
    0.01380182f, -0.02933843f, 0.03379874f, -0.02150324f, 0.03221188f, 0.03313252f, -0.01093097f, 0.01482246f, 
    0.02613871f, 0.01808084f, 0.02383391f, 0.01574908f, 0.02790472f, -0.01115693f, -0.03649515f, 0.03006699f, 
    0.01377912f, -0.01452866f, -0.03453888f, 0.02215091f, -0.00670539f, 0.01116860f, -0.02034516f, -0.00416007f, 
    0.02160915f, 0.00801059f, 0.01779738f, -0.01285321f, -0.03614536f, -0.00811872f, 0.00312855f, -0.03847657f, 
    -0.02090138f, -0.02205159f, 0.03199527f, -0.01395043f, 0.02564892f, 0.02442991f, 0.00238458f, -0.02641837f, 
    0.00749241f, -0.02933894f, 0.00122313f, -0.00780805f, -0.00951481f, -0.02635885f, -0.01273221f, 0.02044299f, 
    0.01903691f, 0.00162990f, 0.00841402f, -0.04322214f, -0.01729456f, 0.00221908f, 0.00997946f, 0.03259994f, 
    -0.04285077f, -0.03234965f, -0.00160773f, -0.03978341f, -0.00622783f, 0.02262211f, -0.04031621f, 0.00086378f, 
    -0.02429032f, -0.00646455f, -0.03695638f, -0.02307368f, 0.03202045f, -0.00898563f, -0.00329520f, -0.00512112f, 
    -0.03577755f, -0.04255385f, -0.00707058f, 0.01303138f, 0.00282162f, -0.00911975f, 0.00897103f, -0.00961784f, 
    0.03257082f, -0.02698662f, -0.00055423f, -0.00095653f, 0.00052203f, 0.01153786f, -0.00880240f, -0.01374327f, 
    0.01914167f, -0.03531221f, -0.03974763f, -0.00268633f, 0.03931725f, -0.03461317f, -0.00756064f, -0.00330557f, 
    0.00628563f, 0.02451682f, 0.00739442f, 0.03290754f, -0.04503208f, 0.01970880f, -0.02024761f, 0.02994846f, 
    -0.01452502f, -0.03350949f, -0.01726236f, -0.02254880f, -0.00984270f, -0.02726885f, -0.01353053f, -0.00993251f, 
    -0.02646483f, -0.00259614f, -0.03448381f, -0.04528197f, -0.01861060f, -0.02794132f, -0.04082260f, -0.00077943f, 
    0.01881427f, -0.00701636f, -0.04108934f, 0.03091709f, -0.04420224f, -0.01851247f, -0.01613865f, -0.03250698f, 
    -0.03037891f, -0.04269081f, -0.02577678f, 0.02136728f, -0.03671773f, -0.02806507f, 0.03179989f, 0.03306245f, 
    0.02342045f, 0.01083400f, -0.00729146f, -0.01603960f, -0.03934774f, 0.01483955f, -0.02288572f, -0.02252523f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03279902f, 0.06339724f, 0.01699374f, 0.00907246f, -0.03118482f, 0.00509741f, 0.06384876f, -0.07358611f, 
    0.03375101f, 0.01213015f, 0.03100183f, -0.04981738f, -0.04766523f, 0.02278694f, 0.03677165f, 0.03212195f, 
    0.15745644f, -0.00401879f, 0.00105252f, 0.02626090f, 0.06667395f, -0.03943808f, 0.04587094f, -0.07481635f, 
    0.01401566f, 0.01601714f, 0.06708273f, 0.01436335f, -0.00714791f, -0.00434166f, -0.04844609f, 0.01479500f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.11691888f, -0.13890240f, -0.28403035f, -0.06296425f, -0.02290959f, -0.07053509f, -0.04830050f, 0.50658810f, 
    0.12649499f, -0.48940751f, -0.36864135f, -0.10933955f, -0.06447213f, -0.65815598f, 0.00388996f, 0.10738952f, 
    0.10359025f, -0.16179012f, -0.10195607f, -0.08070311f, -0.35324585f, -0.04678968f, 0.25184417f, -0.08459362f, 
    -0.05142850f, -0.05458135f, 0.17212705f, 0.07571691f, 0.29030979f, 0.04977901f, 0.10528968f, 0.07545650f, 
    0.05130579f, 0.14569165f, -0.06609331f, 0.14584921f, 0.15566479f, -0.08860224f, 0.40400502f, -0.73256236f, 
    0.09857444f, -0.39762509f, -0.12964134f, -0.33274713f, -0.03462253f, -0.39735302f, -0.45526248f, 0.07052289f, 
    0.22152179f, -0.13443618f, -0.16084266f, -0.14210913f, 0.17997265f, -0.16849090f, 0.33378711f, -0.34709570f, 
    -0.11385428f, 0.09088382f, 0.10705128f, 0.11590153f, -0.15201099f, 0.09267684f, 0.04248429f, -0.13433653f, 
    0.07197580f, 0.25654310f, -0.61231804f, 0.00851400f, 0.03944686f, -0.12579645f, 0.16873722f, 0.21313271f, 
    0.14331186f, 0.23349647f, -0.06477715f, -0.24500538f, 0.15441476f, -0.03823712f, -0.64492065f, 0.27401209f, 
    0.00830030f, -0.07144652f, 0.14023951f, -0.12254576f, 0.04829408f, -0.09601300f, -0.18467744f, 0.09144715f, 
    0.40036041f, -0.02132428f, -0.09366365f, -0.19137430f, 0.15236916f, 0.02896671f, 0.04385940f, 0.04346971f, 
    0.30925658f, 0.13108687f, -0.17196648f, 0.14293860f, -0.14104563f, 0.13677202f, -0.51345122f, 0.10131344f, 
    0.14356916f, 0.25274879f, 0.22324327f, 0.23259561f, -0.13297860f, -0.46330047f, 0.27242020f, 0.35799798f, 
    -0.11513697f, -0.07520387f, -0.05968769f, -0.18121998f, 0.04040490f, 0.02317694f, -0.05299555f, -0.54262310f, 
    -0.41921088f, -0.02861092f, -0.17292677f, 0.20716466f, -0.10383848f, 0.10283569f, -0.05389294f, 0.06403816f, 
    -0.41832799f, 0.28914961f, 0.20981364f, 0.09800287f, 0.11858723f, 0.16696945f, -0.25227433f, -0.11567750f, 
    0.11186216f, 0.39234650f, 0.05218489f, 0.16064821f, 0.09098499f, -0.48144776f, -0.10358655f, -0.33654884f, 
    0.17852874f, 0.09417388f, 0.11882237f, 0.16365927f, -0.53133720f, 0.03503819f, -0.01499155f, 0.15255381f, 
    -0.52283800f, -0.13659111f, 0.17759869f, -0.15960388f, -0.27163649f, -0.12254649f, -0.04207362f, -0.12562074f, 
    0.09672336f, -0.24829331f, 0.35567710f, 0.05548023f, -0.00617059f, 0.04207044f, 0.33488527f, -0.18571223f, 
    -0.10877155f, -0.07717199f, -0.11163755f, -0.41631240f, -0.15557592f, 0.07651129f, 0.33457318f, 0.15201326f, 
    0.16966932f, -0.13436882f, 0.09002136f, 0.06229090f, -0.39734101f, 0.07081480f, -0.20790042f, -0.00766097f, 
    -0.51947773f, -0.04580408f, 0.03833616f, -0.48341686f, 0.08893025f, 0.12326794f, 0.08962132f, -0.18109532f, 
    0.34411779f, -0.11752591f, -0.05971337f, 0.12971553f, 0.02255421f, -0.01056338f, -0.25283644f, -0.18598589f, 
    0.13607171f, 0.16020754f, -0.49753031f, -0.16485447f, 0.10260534f, -0.02852931f, 0.27053288f, -0.17304890f, 
    0.16188796f, 0.03874198f, -0.14846243f, 0.12868571f, 0.48210806f, 0.05820370f, -0.05968815f, 0.29209539f, 
    0.49032745f, 0.01719669f, -0.05435235f, -0.57475460f, -0.54061896f, -0.16474427f, 0.14263605f, -0.15121022f, 
    0.18039125f, -0.32769275f, 0.17685619f, -0.02318769f, 0.03740022f, 0.03340624f, -0.09785176f, 0.12802348f, 
    0.17173763f, 0.24770822f, 0.24184680f, 0.18509509f, 0.05966667f, 0.29571491f, 0.02014724f, -0.03588409f, 
    -0.37860569f, 0.00386523f, 0.09391239f, -0.00222278f, -0.12719631f, 0.14799729f, 0.08754961f, 0.36422634f, 
    -0.07294612f, -0.04481093f, -0.48523119f, 0.08851870f, -0.00392809f, -0.11960083f, 0.12432033f, -0.14927410f, 
    0.22050080f, 0.10607609f, -0.05588664f, 0.04915378f, 0.12363631f, 0.02284350f, 0.06105342f, -0.44874308f, 
    0.15890834f, -0.57015544f, 0.40605360f, 0.15225695f, -0.13080244f, 0.27455175f, -0.25250769f, 0.07324868f, 
    -0.02030955f, -0.07363614f, 0.10286207f, -0.11892631f, -0.62471050f, 0.01670511f, -0.25561988f, 0.23525286f, 
    0.32820916f, 0.10428544f, 0.20752573f, -0.27747241f, -0.13963106f, -0.09641991f, -0.00547103f, 0.13155244f, 
    -0.43792531f, 0.13106216f, 0.04863215f, 0.10918833f, 0.02559670f, 0.13704364f, -0.14466338f, 0.17576922f, 
    -0.05829650f, -0.02592863f, -0.14531921f, -0.04854426f, 0.00091988f, 0.12516361f, -0.05907712f, -0.71173275f, 
    -0.01259380f, -0.02085948f, -0.16994949f, -0.11947722f, 0.45867655f, 0.11273155f, -0.36476642f, 0.25998780f, 
    -0.02775397f, 0.10354842f, 0.26405969f, -0.04040856f, 0.47362864f, -0.04727715f, -0.09783228f, -0.12409060f, 
    0.07671303f, -0.16522254f, -0.09022802f, 0.08528961f, -0.15309003f, 0.05244348f, 0.01082790f, -0.33254927f, 
    0.12037675f, -0.03826099f, 0.13897522f, -0.37442768f, -0.14167513f, 0.66245109f, 0.13874076f, -0.05068121f, 
    0.11047703f, -0.00284926f, -0.17955548f, -0.13330775f, 0.15984067f, 0.12371483f, -0.03330417f, -0.69829410f, 
    0.14458883f, -0.17240706f, -0.12428715f, 0.32601023f, 0.18379284f, -0.00584572f, -0.02182915f, -0.00801652f, 
    -0.57272363f, -0.49874407f, 0.15478653f, 0.15948176f, -0.13301080f, -0.12394264f, 0.16263886f, 0.10479449f, 
    0.10116073f, 0.15407690f, -0.47348669f, 0.38142300f, 0.15490744f, 0.09194965f, 0.00454492f, 0.29365388f, 
    0.07731449f, 0.02718979f, -0.06677303f, -0.03427831f, -0.16048336f, 0.17713068f, -0.34372944f, -0.15921582f, 
    0.26652992f, -0.01506345f, 0.14736475f, 0.35676232f, -0.58453369f, -0.17010838f, 0.08778407f, 0.02387272f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13058521f, 0.03687186f, -0.09953390f, 0.06062549f, 0.19733393f, 0.18723789f, -0.02649834f, -0.08184173f, 
    -0.00762141f, -0.04225013f, -0.07292490f, 0.09254511f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
