#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.73862743f, 0.90454167f, 0.12703271f, -0.84509766f, 0.16195804f, -0.68728262f, -0.14914832f, 0.09764428f, 
    -0.32423410f, 0.90339583f, 0.12563519f, -0.75116330f, -0.42743352f, -0.18029597f, 0.42648989f, -0.11224055f, 
    0.08150761f, 0.36194220f, 0.71254140f, -0.41778740f, -0.80865949f, -0.39542425f, -0.22704984f, -0.71704525f, 
    -0.21337958f, -0.06926399f, 0.69902581f, 0.60688943f, 0.67612022f, 0.60607737f, 0.14232828f, 0.36490795f, 
    0.37152132f, -0.64560288f, -0.40451723f, 0.26581448f, 1.00539577f, 1.08956730f, 0.23208711f, 0.09339947f, 
    -0.24015465f, 0.27410275f, 0.36401102f, 0.33542043f, -0.19201170f, -1.03067291f, 0.04480283f, 0.70428401f, 
    -0.02532708f, -0.46497202f, -0.67622495f, 0.14409217f, -0.21375291f, -0.42809865f, 0.95543599f, 0.41449270f, 
    -0.48324150f, 0.08646652f, -0.14480506f, 0.33098301f, -0.36085483f, 0.18966934f, 0.59524506f, 0.67342681f, 
    0.76818305f, -0.89437079f, 0.33140221f, 0.40350521f, -0.19431064f, 0.51259089f, -0.12470885f, -0.23666237f, 
    -0.56511199f, -0.70142829f, -0.91007060f, -0.13658655f, -0.52582568f, -0.15459666f, 0.00245137f, 0.51007277f, 
    0.39723110f, 0.57983118f, -0.13744022f, 0.87140852f, -0.84674615f, 0.29359543f, -0.26694521f, 0.69181937f, 
    0.52019316f, 0.02139684f, -0.67684025f, 0.59153903f, -0.46527672f, -0.44709697f, 0.18098187f, -1.00180972f, 
    0.41461763f, -0.17297453f, 0.45964625f, 0.60956794f, 0.11263282f, -0.65436745f, 0.15985821f, -0.89372861f, 
    -0.65696359f, -0.17777860f, 0.58465481f, 0.35452026f, 0.38980636f, -0.37678975f, -0.38167185f, -0.18196076f, 
    1.02908027f, 0.59131110f, 0.28919381f, -0.16586119f, -0.65370411f, 0.86987978f, -1.12433696f, 0.17393503f, 
    0.73313689f, -0.91781437f, 0.42502046f, 0.03119167f, -0.43292877f, -0.21558422f, 0.85319775f, -0.18074562f, 
    -0.45895973f, -0.30225250f, -0.65598178f, 0.11204839f, -0.35519001f, 0.50909668f, 0.31913337f, 0.54430723f, 
    0.61040300f, 0.64035243f, 0.33611506f, -0.45045522f, -0.45789075f, 0.47237375f, 0.48708451f, 0.41497326f, 
    0.56822860f, -0.52935010f, -0.84791839f, 0.79073757f, 0.38773298f, -0.43138921f, -0.03860640f, 0.47344038f, 
    -0.05866205f, 0.60032564f, -1.07578909f, -0.05333332f, 0.83839852f, 0.79493511f, 0.06458029f, -0.42352405f, 
    -0.28571609f, -0.12595254f, -1.34657776f, 0.78741550f, 0.92963648f, 0.60241401f, 0.76492774f, 0.49345219f, 
    0.22840358f, 0.02695594f, 0.07284774f, -0.39344874f, 1.03892171f, 0.88670325f, 0.41712055f, -0.42914659f, 
    0.46428588f, -0.61827129f, 0.07057734f, -0.22198279f, 0.28318673f, -0.71533072f, -0.00339228f, -0.33093172f, 
    0.90871513f, 0.93796438f, -0.03646075f, 0.45292726f, -0.27429393f, -0.75046569f, -0.59087944f, -0.01240706f, 
    -0.75913769f, -0.60242134f, 0.06972650f, 0.40656939f, 0.19637038f, 0.05308013f, 0.42948610f, 0.27005720f, 
    0.69002360f, 0.41071320f, 0.23518504f, 0.79633898f, -0.41000989f, 0.15172479f, 0.38263777f, -0.96644735f, 
    -0.22552423f, 0.64478606f, 0.38141936f, 0.45427153f, 0.52976996f, -0.57921314f, -0.42857683f, -0.50588721f, 
    0.03951663f, 0.89337963f, 0.31619266f, 0.21947266f, -0.28483951f, 0.24354742f, -0.39541614f, -0.21781023f, 
    0.28234544f, 0.70857292f, -0.71454763f, 0.74437445f, -0.15744516f, -0.32532519f, -0.65409976f, 0.42291230f, 
    0.56438816f, 0.15130205f, -0.47408822f, 1.02478898f, -0.78855026f, 0.36056572f, 0.74428594f, -0.62762612f, 
    -0.33420002f, -0.33889839f, -0.03029259f, -0.83301413f, -0.80307919f, -0.77428979f, -0.53714073f, 0.93504751f, 
    0.71386427f, -0.01036806f, -0.09981401f, -0.08401249f, 0.39401406f, 1.02456093f, 0.84058952f, -0.22544183f, 
    0.59437144f, -0.42365676f, 0.49572656f, -0.14830050f, 0.02365806f, -1.15404654f, 0.99306303f, -0.16342312f, 
    -0.11969592f, 0.79189783f, -0.41855583f, -0.26956150f, 0.24736732f, 0.36643159f, -0.74470812f, -1.08690739f, 
    -0.47984686f, -0.50538856f, 0.22917667f, -0.07319521f, -0.28549910f, -0.07829279f, 0.36030912f, -0.55420423f, 
    0.26490706f, 1.06396914f, 0.61025083f, 0.57843024f, -0.36512169f, 0.00942568f, 0.45228565f, 0.30657706f, 
    0.84938133f, 0.11114673f, -0.92448837f, -0.77680707f, 0.08842341f, 0.55249888f, -0.31957573f, -0.47333449f, 
    -0.23109011f, -1.17130387f, -0.35464862f, -0.32636222f, 0.79558206f, 0.64047831f, 0.20719281f, 0.31466487f, 
    -0.31564125f, 0.05682632f, -0.17717621f, 0.89569998f, 0.62419468f, -0.16700333f, 0.80552912f, -0.55222309f, 
    -0.16711447f, 0.06518390f, -0.10615183f, 0.08196989f, 0.69862044f, -0.26548401f, -0.68873990f, -0.47016206f, 
    -0.59512073f, -0.17713296f, -0.50983524f, -0.40734324f, 0.28001043f, 0.85967243f, -0.27361658f, 0.91529608f, 
    -0.31131181f, -0.76675975f, 0.09610578f, -0.16230081f, -0.01525800f, -0.39648581f, 0.91920364f, -0.91937828f, 
    0.29613626f, -0.76831764f, -0.23531348f, 0.69125879f, 0.14659664f, -0.20045955f, -0.47951165f, -0.75283515f, 
    -0.77006215f, 0.69152069f, 1.02870476f, -0.38026068f, 0.01783730f, -0.01068486f, 0.20279048f, -0.42726851f, 
    -1.40699232f, 0.16074918f, 0.71329397f, 0.67474192f, 0.69912964f, -0.11032563f, 0.16094176f, 0.09919710f, 
    -0.07095528f, 0.93713427f, 0.22701640f, 0.72695386f, -0.22439131f, -0.65435678f, -0.37615064f, -0.21233490f, 
    -0.61823678f, -0.11917835f, -1.04228318f, 0.29592502f, -0.03854576f, -0.01479210f, 0.65922499f, -0.02500780f, 
    0.33052811f, 0.32689235f, -0.47161976f, -0.31066877f, 0.41744536f, -0.89488286f, -0.23094738f, 0.55760193f, 
    -0.02339421f, -0.41421646f, 0.61966920f, -1.04068971f, -0.60131383f, 0.96593565f, 0.70424509f, 0.27315682f, 
    -0.52239239f, -0.45992523f, 0.10486641f, -0.30003577f, 0.78296208f, 0.15048996f, -0.60653323f, 0.86795527f, 
    0.47943580f, -0.71908885f, -0.29532859f, -0.47998387f, -0.41019562f, 0.55332911f, 0.53493959f, 0.67011440f, 
    0.37694141f, 0.18716255f, 0.44002551f, -0.29560474f, -0.19178332f, -0.28810802f, 1.01558721f, 0.27225250f, 
    -0.10789024f, 0.07291090f, 0.71072346f, -0.04749030f, -0.13492851f, -0.42358387f, 0.23077087f, -0.40230927f, 
    -0.83650804f, -0.19820584f, 0.83589464f, 0.04583029f, 0.43865010f, -0.29588318f, -0.32447973f, -0.52871168f, 
    -0.67658865f, -1.03360212f, -0.45579416f, 0.23907417f, -0.42386168f, 0.06823742f, -0.54707348f, 0.05628705f, 
    -0.47589105f, -0.48726991f, -1.19068718f, -0.44991496f, -0.03210977f, 0.79777324f, 0.04827907f, -0.01728445f, 
    -0.15085572f, -0.37848070f, -0.88443202f, 0.13383968f, -1.02124715f, -0.37568653f, 0.17581615f, -0.05352815f, 
    0.31155971f, -0.51245642f, -0.14054801f, 0.66622764f, 0.36205450f, 0.53363472f, -1.09372914f, -0.19645546f, 
    -0.48363033f, 0.30345529f, 0.03583101f, -0.20283094f, 0.53648180f, -0.27553004f, 0.30324060f, 0.92978323f, 
    -0.74724108f, 0.43546689f, -0.38295910f, 0.39830297f, -0.49827984f, 0.62064505f, -0.44518140f, 0.49104598f, 
    -0.71181458f, -0.89224446f, -0.66551429f, 0.01834255f, -0.40500674f, 0.05959731f, 0.50416809f, -1.05949163f, 
    -0.82923937f, -0.80077028f, 0.69741583f, -0.01827236f, 0.73570555f, 0.06128743f, -0.27854776f, 0.79080117f, 
    0.65265757f, 0.43043649f, -0.09607840f, -0.93552876f, -0.17122582f, 0.49270049f, 0.36464202f, 0.07964804f, 
    0.51603526f, -1.20587337f, 0.86344492f, -0.01125280f, -0.69006604f, -0.71416080f, 0.02050231f, -0.37090921f, 
    -0.16679597f, -0.22915605f, 0.85683173f, -0.75048876f, -0.46501637f, -0.58478618f, -0.54717135f, -0.22251207f, 
    0.21642081f, 0.38993528f, 0.24412353f, 0.28202024f, 0.72453028f, 0.59925795f, -0.64599043f, 0.46636412f, 
    0.26836726f, 0.26323330f, 0.13084747f, 0.78419667f, 0.87602890f, 0.16427989f, 0.35458437f, 0.51070535f, 
    0.52195776f, 0.44076368f, -0.21714509f, 0.21074179f, 0.87119889f, 0.04379291f, 0.70827496f, 0.22677010f, 
    0.19202231f, -0.03296550f, 0.18775603f, -0.35818973f, -0.50605106f, 1.02899539f, 0.60608816f, -0.56574023f, 
    0.06336743f, 0.09319582f, -0.56682301f, 0.02722770f, -0.22568908f, 0.49245751f, 0.93095142f, 0.70287120f, 
    0.55614471f, -0.55425757f, -0.66572618f, -0.30592704f, -0.12248956f, 0.17287768f, 0.48530263f, 0.09697103f, 
    1.04892969f, 0.84630299f, -0.90384340f, 0.60093868f, 0.16012342f, -0.18674536f, 0.22333437f, -0.37788460f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08875991f, 0.04998591f, 0.36379933f, 0.11700036f, -0.08502588f, 0.13977788f, 0.11595540f, -0.00378359f, 
    0.12589617f, 0.20819902f, 0.00606275f, 0.06191692f, 0.21464966f, 0.08925731f, 0.14969993f, -0.13464750f, 
    0.35459021f, 0.18221372f, 0.21278839f, 0.31885368f, 0.14553523f, 0.37103075f, 0.06722863f, -0.02805296f, 
    0.15702215f, 0.02190129f, -0.24489164f, 0.18680292f, -0.05717110f, 0.14298345f, 0.31186017f, 0.37722781f, 
    0.13838705f, -0.13717663f, 0.08307536f, 0.02101359f, -0.09077962f, -0.14592832f, 0.42226207f, 0.23388892f, 
    -0.09727433f, 0.27049768f, 0.36125252f, -0.07012534f, 0.04275576f, 0.33435807f, 0.24402490f, 0.06622644f, 
    -0.10938954f, 0.33920860f, -0.10989928f, 0.13665275f, -0.13758950f, 0.04617821f, 0.13374016f, -0.02185876f, 
    0.18651360f, 0.32273573f, 0.16861132f, 0.26232192f, 0.08636159f, 0.02205552f, -0.01979438f, 0.28250083f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07405278f, 0.06563251f, 0.01350259f, -0.12036512f, 0.17642853f, -0.02365400f, 0.01579835f, -0.06893756f, 
    0.02237291f, 0.10604944f, -0.02375855f, 0.05774472f, -0.03939119f, -0.05586968f, 0.04766707f, -0.05746392f, 
    0.06294408f, 0.00974072f, 0.03884509f, -0.05642495f, -0.03797201f, -0.11289688f, -0.02079156f, -0.09921774f, 
    0.03228868f, -0.01322587f, 0.01537499f, -0.08081314f, 0.04672143f, 0.01366515f, -0.01650830f, 0.00172001f, 
    0.06257459f, 0.05281232f, -0.00218274f, -0.00120001f, -0.04711283f, -0.05876194f, 0.03180148f, -0.01526690f, 
    -0.14386883f, -0.18785912f, 0.17011172f, 0.03594410f, -0.05958515f, 0.02948046f, 0.03883336f, 0.07596143f, 
    0.04123130f, 0.00797385f, -0.01386060f, 0.04377944f, 0.01481047f, 0.03644646f, -0.05717007f, 0.01088760f, 
    -0.04494050f, -0.07348660f, 0.01893298f, -0.08591522f, 0.05181871f, 0.07262984f, -0.04306930f, -0.02671277f, 
    0.13385615f, -0.03910000f, -0.13836615f, 0.00080406f, 0.03744176f, -0.00176362f, 0.02598072f, -0.02053338f, 
    0.03123562f, 0.00168027f, -0.00215338f, 0.06743459f, 0.13179295f, -0.06716605f, -0.06061451f, 0.05395317f, 
    0.24164842f, 0.03305541f, 0.06267133f, -0.27772674f, 0.21876477f, -0.11321722f, 0.00620166f, 0.00091706f, 
    0.04319502f, 0.01099883f, 0.00752127f, -0.02051581f, -0.02913875f, 0.04334572f, 0.01892572f, 0.01372727f, 
    0.00809821f, 0.00465912f, -0.02354166f, 0.06779341f, -0.27932826f, -0.09734508f, -0.03858644f, 0.02070661f, 
    -0.05851411f, -0.02291883f, -0.11750276f, 0.01974081f, 0.01271466f, -0.01694536f, 0.04033066f, 0.06184625f, 
    0.03293018f, 0.03097678f, -0.12121163f, 0.02679545f, -0.02433786f, -0.03124869f, -0.00304708f, -0.00683466f, 
    0.09851093f, -0.10874936f, 0.03882781f, -0.17286941f, 0.14492016f, -0.01272936f, -0.04807994f, -0.07053050f, 
    0.04728008f, -0.02228785f, 0.00218274f, 0.04857690f, -0.02635773f, 0.07975118f, -0.00227081f, 0.06250259f, 
    -0.04162620f, 0.00086859f, -0.06690814f, 0.06899753f, -0.03411834f, 0.01052815f, 0.12364778f, -0.11496840f, 
    0.35750452f, -0.18707907f, 0.11779225f, 0.11882833f, 0.09312209f, -0.07634178f, -0.03614303f, -0.00319810f, 
    -0.01838582f, -0.03950455f, 0.05726369f, 0.04949806f, -0.03805033f, 0.06248194f, -0.05560319f, -0.05305136f, 
    -0.14600372f, -0.46497178f, -0.08262631f, 0.01362467f, -0.17769848f, 0.01369866f, -0.11158517f, 0.02095530f, 
    0.06572082f, 0.08227889f, -0.05385156f, -0.03734148f, -0.04162500f, -0.09279636f, 0.05039687f, 0.10168634f, 
    -0.05944069f, 0.05631288f, 0.01836913f, -0.09318937f, 0.14533646f, -0.02797709f, -0.06083260f, 0.06053867f, 
    -0.11544190f, -0.02487367f, -0.08314493f, -0.07575586f, 0.01899147f, -0.02976397f, 0.02278833f, 0.07782405f, 
    -0.00758087f, -0.01126456f, -0.02114998f, -0.03978547f, -0.02960417f, 0.01301050f, 0.00819254f, -0.01362617f, 
    0.07307587f, -0.22452192f, -0.01045082f, 0.06005761f, 0.06598367f, 0.01496266f, -0.03030058f, -0.02051463f, 
    0.01222083f, 0.09789546f, 0.10248663f, 0.08864439f, -0.04132799f, 0.05526419f, 0.04734098f, 0.04611266f, 
    -0.14832479f, 0.19434939f, -0.05829328f, -0.13828178f, 0.03313878f, -0.26780891f, 0.12429713f, -0.05285062f, 
    0.12242318f, -0.05857423f, -0.01599670f, 0.00290033f, -0.00056713f, 0.03128922f, -0.08416528f, 0.02487981f, 
    -0.02652359f, 0.07864705f, -0.02421610f, 0.02349027f, 0.03451725f, 0.02613622f, 0.05049283f, -0.03708338f, 
    -0.18141912f, 0.16953672f, -0.00938117f, -0.14863151f, -0.02414560f, -0.07925665f, 0.04584306f, -0.10001672f, 
    -0.07357603f, 0.06936900f, -0.07026558f, -0.03969168f, -0.05118962f, -0.03096248f, 0.01081743f, -0.03803876f, 
    -0.01194884f, 0.00216846f, -0.02553255f, 0.01312317f, 0.21745586f, -0.34056240f, 0.11793329f, 0.10653839f, 
    -0.31112450f, 0.10173154f, 0.06028179f, 0.00191144f, 0.00954809f, -0.02779760f, -0.18539093f, 0.02491217f, 
    -0.01294377f, 0.00522488f, 0.08797961f, -0.04751508f, 0.00518267f, 0.05867584f, 0.04000934f, -0.01175102f, 
    0.08177211f, -0.19185252f, 0.08014251f, -0.04286433f, -0.06541040f, -0.00468603f, 0.00665534f, -0.07380418f, 
    0.00824047f, -0.00327159f, -0.09147397f, 0.04858780f, -0.02359104f, 0.04935195f, 0.04385585f, -0.03965158f, 
    -0.07426288f, -0.08048601f, 0.06126915f, -0.05438573f, -0.05523243f, -0.01421308f, 0.04621927f, -0.03938286f, 
    -0.01589775f, -0.08527678f, -0.01142654f, 0.02371703f, -0.00325251f, -0.05024289f, 0.02876340f, -0.00123898f, 
    -0.00027720f, -0.01458723f, 0.00228575f, 0.04498835f, -0.02773522f, 0.05646317f, 0.01438359f, -0.01799974f, 
    0.05148045f, -0.02170957f, -0.04141282f, -0.05175331f, 0.08325531f, -0.07091174f, -0.09295523f, 0.03747634f, 
    -0.09816368f, -0.04033582f, -0.03764408f, 0.07412533f, 0.06548992f, -0.00384894f, 0.02358823f, 0.00443193f, 
    0.05795597f, 0.06923062f, 0.02182578f, 0.04618596f, 0.00825299f, 0.15434550f, 0.13206883f, 0.03914883f, 
    -0.04071178f, 0.03169858f, -0.00839551f, -0.00030472f, -0.04630731f, -0.06879651f, -0.03200495f, 0.00056442f, 
    0.00665336f, 0.00062934f, 0.05372082f, 0.03641151f, 0.07265475f, 0.00520316f, -0.04641271f, 0.02503224f, 
    0.16095982f, -0.03797266f, 0.24749760f, 0.04482386f, 0.14960393f, 0.01927861f, -0.04862547f, 0.09379981f, 
    -0.05180265f, -0.01146923f, -0.00847213f, -0.11524609f, 0.04267475f, -0.04560652f, 0.09702919f, 0.05798976f, 
    -0.06308057f, -0.09890170f, 0.05853132f, -0.05857337f, -0.20426452f, 0.12616311f, 0.07729807f, 0.07937993f, 
    0.14922838f, -0.04836749f, -0.10540029f, 0.00896439f, 0.02382272f, -0.01634149f, 0.03885915f, -0.10533927f, 
    -0.03347976f, 0.00867523f, -0.02088161f, 0.00320395f, -0.02375555f, -0.07001449f, -0.02902151f, 0.00287463f, 
    -0.13593470f, 0.15257938f, -0.15800847f, -0.14083362f, -0.07831275f, -0.14704841f, 0.03137277f, -0.06766512f, 
    -0.04326424f, -0.04972230f, 0.00743826f, -0.03600749f, 0.04339302f, -0.01151491f, 0.02829654f, -0.01188552f, 
    -0.02533160f, -0.01570462f, 0.01541744f, 0.01678845f, -0.26324940f, -0.23558339f, -0.25053012f, 0.07274776f, 
    -0.06560489f, -0.03760518f, -0.01180599f, -0.03294756f, 0.00345922f, 0.01400279f, -0.02740957f, -0.02388632f, 
    -0.03158946f, -0.06202975f, -0.01029793f, 0.01732568f, 0.06907184f, -0.03997604f, 0.02766171f, 0.01094247f, 
    -0.03194795f, -0.02721461f, -0.08989440f, 0.06777687f, 0.02919001f, 0.06895499f, -0.04770435f, 0.03506103f, 
    0.01694644f, -0.04733279f, 0.00100639f, -0.01321498f, -0.00517843f, 0.02513587f, -0.03499051f, 0.03441538f, 
    0.06949727f, -0.01323488f, -0.08551718f, 0.03577481f, -0.06540005f, 0.14565419f, 0.14467865f, 0.09947366f, 
    -0.12768725f, 0.01597844f, 0.04725305f, 0.07586524f, 0.05569270f, 0.05683559f, 0.02677598f, -0.03045223f, 
    -0.06318105f, -0.04617053f, -0.05091227f, 0.13713185f, -0.02989879f, -0.10243189f, 0.06289963f, 0.09856594f, 
    -0.05677798f, 0.08467390f, 0.06714732f, -0.03177070f, 0.12706269f, -0.09031230f, -0.11595231f, -0.01174692f, 
    -0.04661369f, -0.09493001f, 0.01523707f, -0.02806899f, -0.08180621f, 0.04297532f, 0.04091808f, -0.00322023f, 
    0.02159357f, -0.02767403f, -0.08163720f, 0.03446440f, 0.09915619f, -0.17210658f, 0.05968142f, 0.00981237f, 
    -0.24855073f, -0.11384062f, -0.01790071f, 0.03339586f, -0.05511931f, -0.06250039f, -0.08216599f, 0.09660777f, 
    -0.01014148f, -0.01135085f, -0.05750327f, -0.00817817f, -0.12127325f, 0.01108462f, 0.06373371f, -0.01897117f, 
    0.46236035f, 0.06841472f, 0.12866557f, -0.10127578f, 0.20365843f, -0.01578312f, -0.00304666f, 0.05279174f, 
    -0.05667708f, -0.04406368f, 0.09191313f, 0.03019435f, -0.04287966f, 0.03841461f, 0.04060034f, -0.07244051f, 
    0.00815862f, 0.00295457f, -0.04882691f, 0.02808708f, -0.16030715f, 0.23801725f, -0.04220191f, -0.20134917f, 
    -0.25242653f, 0.05975208f, 0.07435081f, -0.01993627f, 0.03374369f, -0.03341737f, 0.01900503f, -0.01692482f, 
    -0.02198838f, 0.08545837f, -0.05788443f, -0.02465858f, -0.02063227f, -0.04450626f, 0.06693368f, -0.04155428f, 
    0.06202694f, 0.17549478f, -0.02887873f, -0.15253465f, 0.07749294f, -0.10722908f, -0.06853714f, 0.03367968f, 
    0.06415489f, -0.02678829f, 0.01517253f, 0.02399685f, -0.05468556f, 0.01152101f, 0.08677665f, -0.07258965f, 
    -0.02751380f, 0.02344563f, -0.01473220f, -0.05260504f, 0.31508115f, 0.03543693f, 0.10755691f, -0.17721021f, 
    0.06528738f, 0.00026812f, -0.02234968f, 0.02828100f, -0.05059405f, -0.01745134f, 0.02673741f, -0.03187930f, 
    -0.11141814f, -0.05119188f, 0.06087869f, -0.13727628f, -0.06699101f, 0.09496678f, -0.00194597f, 0.00158161f, 
    -0.14995676f, -0.02138238f, -0.10787059f, 0.01595729f, -0.18124735f, 0.00734301f, -0.05321211f, 0.04501062f, 
    0.02703216f, -0.04539745f, -0.00493225f, 0.01385246f, -0.01645204f, -0.02948924f, 0.01585795f, -0.02607265f, 
    -0.07669306f, 0.04217842f, -0.00909419f, 0.05992609f, -0.14514557f, 0.01188449f, 0.17573617f, 0.02572423f, 
    -0.07549852f, -0.06626835f, -0.05611521f, 0.06049751f, -0.04281860f, -0.02637131f, 0.00469476f, 0.05800998f, 
    0.03610449f, 0.00768092f, -0.02948483f, -0.00957657f, -0.00981874f, -0.01376104f, -0.04870948f, -0.02973793f, 
    -0.02332000f, 0.00298038f, -0.01912834f, 0.10920734f, 0.14186995f, -0.08292650f, 0.00408111f, -0.11415347f, 
    0.00278184f, -0.03456031f, -0.03103979f, -0.09198586f, 0.11026521f, -0.09702890f, -0.05740631f, -0.03734836f, 
    0.05723388f, -0.08596570f, 0.00876439f, -0.10388888f, 0.40212575f, -0.00060318f, 0.17528939f, -0.13261208f, 
    -0.30875674f, 0.06146461f, 0.09285611f, -0.06637218f, 0.05822005f, 0.03258238f, -0.00931194f, -0.02357067f, 
    0.00217216f, 0.01809461f, 0.05539872f, 0.12499913f, 0.09581812f, 0.01397856f, 0.06502033f, -0.02469844f, 
    -0.03387479f, 0.01095459f, 0.12214264f, -0.14505169f, 0.07297572f, -0.05482926f, 0.01094574f, 0.05087471f, 
    0.01075534f, 0.08423672f, -0.07167847f, 0.06804138f, -0.03995582f, -0.00403735f, 0.00533929f, 0.01226562f, 
    -0.03668727f, 0.02911518f, -0.02435058f, -0.08502621f, -0.00936404f, -0.03714984f, 0.12908851f, 0.03230433f, 
    0.09354930f, 0.00132611f, 0.01806953f, 0.02214121f, -0.01838947f, 0.02420128f, 0.03737582f, 0.03597848f, 
    0.05312395f, -0.04998492f, -0.03711891f, 0.02883835f, 0.01373386f, 0.08319291f, -0.00441435f, -0.06311103f, 
    0.09435001f, -0.05854740f, 0.05336497f, -0.03417470f, 0.13674760f, -0.17022257f, -0.04757685f, 0.08337810f, 
    -0.03862069f, 0.02688512f, -0.01149582f, 0.01842045f, -0.06773832f, 0.02882145f, 0.00420096f, 0.07525805f, 
    0.04324168f, 0.05357812f, -0.14856325f, -0.03682667f, 0.16913919f, -0.16964628f, 0.18489096f, 0.04983078f, 
    0.08649941f, -0.06477943f, -0.04038423f, 0.05899889f, 0.02963261f, 0.07712648f, 0.16979453f, 0.02581614f, 
    -0.04830838f, 0.03079818f, 0.04277351f, 0.06011591f, 0.01992915f, 0.10148568f, 0.01419515f, -0.10649733f, 
    0.14322974f, 0.13527264f, 0.00521670f, -0.13736385f, -0.17103226f, -0.05532323f, -0.01300336f, -0.02156790f, 
    -0.03499417f, -0.07555282f, 0.01914644f, 0.05797807f, -0.01352207f, 0.03315277f, 0.00268511f, 0.01481862f, 
    0.01603306f, 0.05453152f, 0.00115834f, -0.04714568f, -0.06408173f, 0.19149269f, 0.00508449f, -0.09602250f, 
    -0.21904440f, 0.07176460f, -0.00003136f, -0.00449772f, 0.02941274f, -0.06081333f, 0.02657853f, -0.00851630f, 
    -0.04573216f, -0.03135063f, 0.01105623f, 0.06070952f, 0.00502713f, -0.01948852f, -0.03228056f, -0.03316301f, 
    0.00112873f, 0.08200293f, 0.13951349f, -0.02366987f, 0.07336731f, -0.04410493f, -0.18322754f, 0.07220801f, 
    0.00445842f, -0.02723993f, 0.01072547f, 0.03619728f, -0.07969080f, 0.09336755f, -0.00413350f, 0.05505469f, 
    0.04905613f, -0.01636490f, -0.05466107f, -0.01317812f, -0.05362182f, -0.00076802f, -0.10347027f, 0.04650494f, 
    -0.20900631f, 0.04030770f, 0.02305437f, -0.00897756f, -0.00581054f, -0.04003962f, 0.05143343f, -0.00968432f, 
    -0.06786191f, -0.00537824f, 0.04016189f, -0.03142061f, 0.00811084f, -0.00806796f, -0.06307708f, -0.01343437f, 
    -0.12470406f, -0.03408369f, -0.14486805f, 0.13112456f, -0.02613320f, 0.01545361f, 0.00860272f, -0.09762800f, 
    0.01943858f, -0.05631399f, 0.02925533f, -0.01024841f, 0.04732136f, -0.01128955f, 0.03758791f, -0.09641603f, 
    0.04335561f, 0.02026820f, 0.01932381f, -0.02078762f, -0.43187156f, 0.04130598f, 0.26353765f, 0.16228266f, 
    -0.26117811f, 0.04918550f, -0.04181840f, 0.07615317f, 0.08017998f, -0.02819670f, 0.00327290f, 0.01223474f, 
    -0.01971952f, -0.03232024f, -0.07718159f, -0.03469080f, -0.02796534f, 0.04819725f, -0.03068215f, 0.05261051f, 
    0.05470221f, -0.15127909f, 0.12426800f, 0.06281597f, 0.24457662f, -0.03496873f, -0.05343675f, 0.00858483f, 
    0.01795328f, -0.07625377f, 0.05124783f, 0.06670203f, -0.01757621f, -0.01917450f, -0.04058783f, 0.00744182f, 
    0.06870252f, 0.04284363f, -0.03808670f, 0.05051969f, 0.05261601f, 0.03540861f, -0.01628897f, 0.00371167f, 
    0.05106872f, -0.13846721f, -0.15556811f, 0.01202450f, 0.02292129f, -0.04676307f, -0.00713497f, 0.02027908f, 
    0.00558761f, -0.03482111f, -0.01719578f, 0.09498797f, 0.00539992f, -0.08841902f, -0.02855147f, 0.07893595f, 
    0.00600709f, 0.04357314f, 0.04378669f, -0.02979881f, 0.15652387f, -0.16453950f, -0.07852630f, -0.05212144f, 
    0.03106475f, 0.02497728f, -0.02137100f, -0.02993703f, 0.00510366f, -0.01249073f, -0.07580271f, 0.02426231f, 
    -0.02376140f, -0.03520709f, -0.01948189f, 0.02663981f, 0.02946681f, 0.04698275f, 0.05620488f, -0.01348306f, 
    -0.26248583f, 0.12271074f, 0.04111296f, 0.03391789f, 0.02749213f, -0.03058377f, 0.02560076f, -0.07651410f, 
    0.04519199f, 0.00125605f, -0.03227196f, 0.04281538f, 0.05838782f, -0.02194549f, 0.01704390f, 0.02034634f, 
    -0.05379979f, -0.24338193f, -0.17555422f, -0.00287691f, -0.37430847f, 0.07604799f, -0.02873450f, -0.00286498f, 
    0.03726233f, 0.03797049f, 0.06344136f, -0.13750139f, 0.04199461f, -0.02746565f, -0.01976324f, 0.03065494f, 
    -0.10754281f, 0.03821334f, -0.06059984f, 0.07383257f, -0.12369152f, 0.09110226f, -0.01670420f, -0.08580285f, 
    -0.33102754f, 0.04384078f, 0.01944955f, -0.02328343f, 0.01691908f, -0.03756994f, -0.02778766f, 0.00546957f, 
    0.00168815f, 0.04019961f, -0.04073450f, -0.00659615f, 0.04149109f, 0.04411273f, -0.04451122f, 0.02484350f, 
    0.36813501f, 0.00345082f, -0.10626402f, -0.01300342f, -0.23776731f, -0.00214277f, -0.03136677f, -0.06068263f, 
    0.02592261f, 0.01874134f, -0.01608187f, -0.03215706f, -0.03598192f, 0.04662365f, 0.02790216f, 0.07775398f, 
    -0.00089032f, -0.08478739f, -0.08148278f, -0.08395705f, 0.11805433f, 0.03441963f, -0.02696104f, -0.00587842f, 
    0.02148823f, -0.10471170f, -0.07093032f, -0.13132441f, 0.01245894f, -0.02381760f, 0.03844157f, -0.02926891f, 
    -0.00671141f, -0.06932919f, 0.01027632f, -0.07663104f, 0.04499464f, 0.00976575f, 0.03832635f, 0.02776090f, 
    0.39141047f, -0.17567702f, 0.06164511f, 0.05795938f, -0.22931296f, 0.01905936f, 0.06046951f, 0.07372718f, 
    -0.02860524f, 0.03938444f, -0.19603546f, 0.00338490f, 0.08255070f, 0.08976995f, -0.04590562f, 0.00517057f, 
    -0.06278484f, -0.05928236f, -0.08965067f, 0.06602058f, 0.19656511f, -0.11677502f, 0.09456208f, 0.10828530f, 
    -0.09124890f, -0.00258640f, -0.00713761f, 0.02259893f, 0.04841994f, 0.02233142f, -0.09037632f, -0.03433660f, 
    -0.05076615f, 0.05671609f, 0.00524676f, 0.01931067f, 0.00889778f, 0.03476825f, 0.09869301f, -0.01654168f, 
    -0.33153939f, -0.00165239f, -0.05875574f, 0.12150282f, -0.08914766f, -0.10286301f, -0.07306489f, 0.04900707f, 
    -0.12362654f, 0.04745892f, 0.03101876f, -0.05153528f, -0.08837506f, -0.04603293f, 0.05298216f, -0.04518773f, 
    -0.06795429f, 0.02602865f, -0.04208816f, 0.01229175f, 0.13142924f, -0.06527475f, 0.05776097f, -0.11514743f, 
    0.07975455f, -0.13284792f, -0.03554587f, 0.00606579f, 0.04352609f, -0.02248902f, 0.05654472f, -0.05718936f, 
    0.00047888f, 0.03937021f, -0.01925192f, 0.04557572f, -0.00013312f, 0.03290110f, 0.05061684f, 0.05632581f, 
    0.15786691f, -0.33140132f, 0.05277785f, 0.02061308f, -0.26836517f, 0.02153328f, -0.04256656f, 0.02624736f, 
    -0.08986365f, 0.02610350f, -0.13407104f, 0.06809503f, -0.13863447f, 0.02571899f, 0.04138949f, -0.06363219f, 
    -0.09923409f, 0.12856719f, 0.01875272f, -0.00483181f, -0.01921827f, -0.08783176f, 0.08983122f, -0.06267027f, 
    0.03587118f, -0.05703172f, -0.01034794f, -0.00673946f, -0.09115260f, 0.05026162f, -0.05657201f, -0.02015606f, 
    -0.04216109f, 0.00614457f, -0.04721107f, -0.05188254f, 0.01645616f, 0.07402194f, 0.01452135f, -0.00063810f, 
    -0.21431549f, -0.05722367f, 0.03193463f, -0.02590102f, -0.14025553f, -0.08692320f, 0.03004137f, 0.02061925f, 
    -0.10014816f, 0.04078975f, -0.02523975f, -0.00694052f, -0.05676923f, -0.01027289f, -0.05070170f, -0.07709770f, 
    -0.04298693f, -0.05199029f, -0.03276537f, 0.00066887f, -0.00230869f, 0.03110781f, -0.04807360f, -0.20959182f, 
    0.14769024f, -0.10565708f, -0.08138490f, 0.06394610f, 0.06787215f, -0.05283321f, -0.08014710f, 0.04469223f, 
    -0.02210788f, 0.06900429f, 0.06309407f, -0.01549170f, -0.01517501f, -0.03288378f, -0.07745618f, 0.03580082f, 
    0.17939480f, 0.01883055f, 0.03327953f, -0.05957606f, -0.02978838f, -0.20615672f, -0.13993818f, 0.04642033f, 
    0.04471311f, 0.04233329f, -0.00261858f, 0.02358756f, -0.01393223f, -0.06577676f, 0.04842568f, -0.00194105f, 
    -0.07231017f, 0.06772208f, 0.00018159f, 0.06715089f, 0.00219238f, 0.08332244f, 0.08062659f, -0.09772255f, 
    0.19843081f, -0.19076267f, -0.02025588f, -0.03907824f, 0.11268070f, 0.03135188f, 0.01570328f, -0.01174923f, 
    0.05207076f, 0.02803504f, -0.12087014f, 0.12331782f, -0.08382806f, 0.03664413f, -0.02941184f, -0.06341760f, 
    0.11197756f, 0.08074379f, 0.05144107f, -0.15240932f, 0.04881620f, -0.05789914f, -0.12023673f, -0.08061935f, 
    0.06530605f, -0.03221503f, 0.02268125f, -0.03628930f, 0.01410666f, 0.02376937f, -0.03750823f, 0.01821389f, 
    0.02057604f, 0.00713906f, 0.07373659f, 0.01889943f, 0.00857900f, 0.06676736f, -0.05243529f, -0.01845794f, 
    0.22037293f, -0.08318216f, -0.09951628f, -0.03357460f, -0.00903943f, 0.00466070f, -0.00326321f, -0.02842512f, 
    0.08272887f, -0.06417522f, 0.01030635f, 0.03832258f, 0.02406822f, -0.05352682f, 0.00251429f, -0.03411900f, 
    0.22694458f, 0.05718102f, -0.25311777f, -0.02032916f, 0.06343745f, 0.00765214f, -0.08448166f, 0.10907964f, 
    0.01304474f, 0.01113981f, 0.02839560f, -0.03710810f, 0.03364065f, 0.10551868f, -0.06834366f, -0.04193433f, 
    0.01336379f, -0.05112588f, -0.08419538f, 0.03504009f, 0.19638091f, -0.32690305f, 0.12331095f, -0.07605787f, 
    -0.08609344f, -0.03795130f, -0.04443277f, -0.01170778f, 0.04181725f, -0.05360033f, -0.06073361f, 0.04812295f, 
    -0.07675916f, 0.06678803f, 0.02525943f, -0.02256166f, -0.09506426f, 0.05447274f, -0.05131455f, -0.11226052f, 
    0.13227290f, -0.20435035f, -0.04142430f, -0.15032405f, 0.03452481f, -0.01455235f, -0.08475076f, 0.05515911f, 
    0.03509766f, 0.02041313f, -0.10177504f, -0.00937663f, -0.04089915f, -0.04422171f, 0.10612512f, -0.00449731f, 
    -0.02952258f, -0.04542784f, -0.03827550f, -0.06016870f, 0.19997892f, 0.20721680f, 0.06451902f, 0.04987463f, 
    0.14191930f, -0.03125725f, 0.05482287f, 0.01001702f, -0.02556726f, 0.03315734f, 0.02158038f, -0.00063243f, 
    -0.05242975f, -0.05298275f, 0.00986317f, 0.04575415f, 0.03030022f, 0.10616005f, -0.01753791f, 0.03568294f, 
    0.04302762f, 0.00147468f, 0.16710113f, 0.16817074f, 0.06610110f, -0.05261412f, -0.09529505f, 0.02702408f, 
    -0.01166126f, -0.04547783f, -0.02062677f, 0.03385698f, -0.06700203f, 0.09599099f, -0.05403815f, -0.04787957f, 
    0.02868451f, -0.03420612f, -0.02947137f, -0.04697365f, -0.20967487f, -0.04234504f, -0.16642125f, -0.07961867f, 
    -0.27377468f, 0.02772584f, 0.06148804f, 0.02957029f, 0.03799675f, -0.03590360f, -0.13497454f, 0.02248644f, 
    -0.08928578f, -0.08050510f, 0.01938828f, 0.04249448f, -0.06093105f, -0.02621593f, -0.05490103f, -0.02137032f, 
    0.16593008f, -0.04062122f, 0.11477632f, -0.00535826f, -0.01804367f, 0.03314721f, -0.17308164f, -0.06803161f, 
    0.02999518f, -0.04675080f, 0.02954200f, -0.06196593f, 0.02464346f, -0.03148703f, 0.04545514f, -0.03574978f, 
    0.00409156f, 0.04449791f, 0.02193737f, -0.14750227f, 0.19935483f, -0.30167866f, -0.00584290f, -0.21933369f, 
    -0.04617931f, -0.05229833f, -0.03821227f, -0.04560195f, -0.05504979f, -0.00846171f, -0.02153083f, -0.04625830f, 
    -0.04236127f, -0.03543231f, 0.01028618f, -0.11909842f, 0.04108668f, -0.03949559f, 0.06378953f, 0.05907607f, 
    0.00379415f, 0.13619243f, 0.06526887f, 0.02142157f, -0.07393330f, 0.01945063f, -0.04851544f, 0.12142570f, 
    0.02618262f, 0.00483514f, -0.01542814f, -0.15161481f, 0.11371748f, 0.01428915f, -0.07980250f, 0.06583823f, 
    0.16804077f, -0.11275095f, 0.01585934f, -0.02927331f, -0.06625671f, -0.05789964f, 0.02448785f, 0.03322247f, 
    0.00163641f, 0.02716323f, 0.00906217f, -0.00179485f, 0.02727308f, -0.08324648f, 0.12225381f, 0.03970592f, 
    -0.01779775f, -0.02914201f, -0.03794655f, 0.02259178f, -0.02053318f, 0.02032379f, -0.04954884f, -0.00538772f, 
    -0.15897934f, -0.11316244f, -0.13852827f, -0.04541838f, 0.02127561f, 0.01494671f, -0.05627799f, 0.09992471f, 
    -0.07678242f, 0.06201840f, -0.12064122f, -0.08145818f, 0.08584852f, -0.06148854f, 0.08778360f, -0.02673174f, 
    0.05413497f, -0.12826611f, -0.12736087f, 0.03319618f, -0.03668984f, -0.12037455f, 0.07786730f, -0.13424037f, 
    0.02463499f, 0.08472369f, -0.10822455f, 0.04998003f, -0.05211388f, -0.06456757f, 0.01436552f, -0.07605625f, 
    0.04403666f, -0.03860212f, 0.01358542f, -0.03864641f, -0.02342085f, -0.17389312f, -0.03348261f, -0.05405647f, 
    0.27200714f, -0.17898886f, 0.03557929f, 0.01293474f, 0.08886367f, -0.09039924f, 0.03651167f, -0.02504761f, 
    0.07515987f, -0.02743963f, 0.06794020f, 0.03638243f, 0.00437843f, 0.10068948f, -0.04576311f, 0.03406716f, 
    0.00925794f, 0.03619750f, -0.05196635f, 0.03769779f, -0.00796901f, 0.09778144f, 0.15640032f, -0.11479621f, 
    -0.09721649f, -0.02445509f, 0.11749142f, 0.02694208f, -0.05529640f, 0.12658541f, 0.13605869f, -0.01273580f, 
    0.04364210f, 0.03467133f, -0.08066859f, -0.03490267f, 0.00374253f, -0.04777523f, 0.12835443f, -0.02260694f, 
    0.02001350f, -0.14031437f, 0.09287110f, -0.03189523f, -0.01552720f, 0.05723556f, 0.01477414f, 0.04986990f, 
    0.03464059f, -0.02484241f, -0.02810791f, -0.06875958f, -0.04115663f, -0.01243593f, -0.02168105f, 0.02229925f, 
    -0.05719778f, 0.02025359f, -0.06962673f, -0.07092059f, -0.10053657f, 0.12487263f, 0.12943123f, -0.03508256f, 
    0.08098656f, -0.05355184f, -0.03287528f, 0.00248538f, -0.05437178f, 0.05485576f, -0.02061489f, 0.02057918f, 
    0.01969722f, 0.00362938f, -0.01376234f, -0.01278823f, -0.00162650f, -0.05731957f, -0.01608641f, 0.03445559f, 
    0.19850400f, -0.39758480f, -0.06658005f, -0.08509714f, -0.05319121f, 0.07065839f, 0.05384368f, -0.08336738f, 
    0.01771958f, 0.01962755f, -0.02531574f, -0.08498273f, -0.05645455f, 0.01653414f, -0.06196250f, 0.09334029f, 
    0.06301348f, -0.11531285f, -0.01660436f, 0.03723057f, 0.26975450f, -0.25668705f, -0.04321631f, -0.00374967f, 
    -0.10904097f, 0.05338869f, 0.07952411f, -0.03660262f, 0.02131871f, 0.00233671f, 0.15003882f, 0.01930608f, 
    0.03273686f, -0.01105825f, -0.08983665f, 0.01747310f, 0.03585288f, -0.08233310f, 0.04024202f, 0.02258249f, 
    -0.40822709f, 0.13710687f, -0.04991310f, -0.08611647f, 0.05553843f, -0.12125022f, 0.11380298f, -0.06044760f, 
    -0.06080615f, 0.03596554f, -0.05254451f, 0.05613199f, 0.09780180f, -0.05971273f, -0.01187302f, 0.11637671f, 
    -0.09975494f, 0.07255466f, 0.01054474f, 0.06557175f, 0.21786970f, 0.02822347f, -0.09320697f, -0.01778184f, 
    0.12977283f, 0.02694720f, 0.05120990f, 0.02548709f, -0.11483420f, 0.01311821f, -0.00600930f, 0.03074760f, 
    0.03195731f, -0.00253831f, 0.05337463f, 0.04644753f, -0.04909361f, 0.06089663f, -0.02414389f, -0.03306891f, 
    0.12013897f, -0.06500570f, 0.05739678f, -0.01122974f, 0.00973711f, 0.01642062f, 0.01341009f, 0.02120037f, 
    0.04406632f, -0.01752527f, 0.01099072f, -0.06744736f, -0.07582535f, 0.02609497f, -0.16866660f, 0.04653717f, 
    -0.07262017f, 0.00847626f, 0.01590502f, 0.07943858f, -0.03862989f, 0.05009559f, 0.03929198f, -0.02231775f, 
    -0.15205704f, 0.02394047f, 0.00140180f, -0.02228068f, 0.14403377f, 0.00396165f, -0.04846018f, -0.08908512f, 
    0.03180349f, 0.07816862f, -0.09972133f, 0.03427235f, -0.01118925f, -0.01997544f, -0.07267173f, -0.10977130f, 
    0.20180695f, 0.22643113f, -0.06901351f, 0.01778219f, -0.01194986f, -0.03641922f, -0.00403544f, -0.05689742f, 
    -0.05418928f, 0.10864013f, 0.06862355f, -0.00899511f, 0.03853690f, -0.09519798f, 0.01484066f, -0.00432924f, 
    0.02104762f, 0.03840074f, 0.08510818f, 0.05205141f, -0.11824440f, 0.03076286f, -0.04335453f, 0.06837378f, 
    -0.08960223f, 0.04994701f, -0.01301274f, -0.05702016f, -0.13423105f, 0.05650585f, 0.02016738f, 0.26699418f, 
    -0.11599594f, 0.00714035f, -0.01929199f, -0.05837812f, -0.08332844f, 0.11197155f, -0.00269477f, -0.06782798f, 
    0.22587138f, 0.06896564f, -0.00192319f, -0.00275547f, 0.19785653f, -0.03208134f, 0.05248828f, 0.04184343f, 
    0.01656117f, 0.00942168f, -0.04444014f, -0.06362197f, -0.00496789f, 0.04973668f, 0.05171646f, 0.03364218f, 
    -0.00203646f, 0.06843521f, 0.03190324f, -0.04457552f, -0.03125080f, -0.11754825f, 0.03421053f, -0.05334816f, 
    -0.07430854f, -0.01162793f, 0.00357738f, -0.05617495f, 0.02266122f, -0.06647620f, 0.08590093f, -0.00588552f, 
    0.05552586f, -0.05208154f, 0.04516297f, -0.01980975f, 0.09047779f, -0.06861943f, 0.00121175f, 0.06221047f, 
    -0.38450572f, -0.22406094f, -0.12157799f, -0.12657070f, 0.08658065f, 0.09725676f, -0.06971294f, -0.13414040f, 
    0.03533332f, 0.01622962f, 0.05182220f, 0.02794807f, 0.02241426f, -0.06819928f, 0.11983334f, -0.00339934f, 
    -0.02621667f, -0.08438095f, -0.01621167f, -0.08847965f, 0.19018799f, -0.06749865f, -0.08874425f, 0.01047916f, 
    -0.16362403f, -0.11115810f, -0.00768541f, -0.05225864f, -0.00844204f, 0.07289807f, 0.03433620f, -0.04454361f, 
    -0.00860520f, -0.02868864f, 0.10490888f, 0.05760740f, -0.01402341f, 0.03237116f, -0.13118666f, 0.06470060f, 
    0.09908429f, 0.13777612f, 0.05054473f, -0.07159006f, 0.23921503f, -0.04975117f, -0.06509760f, 0.03013833f, 
    -0.01303336f, -0.02474401f, -0.03101986f, -0.03752107f, 0.05587019f, -0.01038342f, -0.03113788f, -0.00652816f, 
    0.04638400f, 0.02630101f, -0.07083390f, -0.02696875f, -0.40117446f, 0.12109067f, -0.11570201f, -0.08435302f, 
    0.09301617f, -0.08987975f, 0.03892867f, -0.00646951f, -0.04452491f, 0.09038939f, 0.07756320f, -0.02635797f, 
    0.07885972f, 0.00524569f, 0.00520651f, 0.03267506f, -0.01567568f, 0.01610138f, -0.03321878f, -0.08968304f, 
    0.08752733f, -0.07152676f, 0.00713092f, 0.05926029f, -0.15190437f, -0.09129179f, -0.06734458f, 0.06410383f, 
    0.07602940f, 0.03565581f, -0.03108505f, -0.02094943f, -0.02877313f, 0.04840311f, 0.00721190f, 0.04816821f, 
    0.04351411f, -0.05493584f, -0.06151320f, -0.08787605f, -0.16160916f, 0.10044623f, 0.08184475f, -0.07447392f, 
    0.14049140f, -0.13940994f, 0.06960113f, -0.05238688f, -0.00978704f, 0.09653214f, 0.02435520f, -0.05670711f, 
    -0.01353703f, -0.06200583f, -0.05454202f, -0.03561131f, 0.02377267f, 0.06271252f, -0.00480102f, 0.07313149f, 
    0.18552060f, -0.26151031f, 0.09548881f, -0.16389963f, -0.04407940f, -0.13213196f, -0.05971144f, -0.02719256f, 
    0.08287420f, -0.11335761f, -0.02597318f, 0.06505811f, -0.20204440f, 0.11743138f, -0.07445557f, -0.06433396f, 
    -0.10506932f, 0.06187185f, 0.05878988f, -0.09453116f, -0.25537595f, 0.17059262f, -0.17902564f, 0.05289487f, 
    -0.12232741f, 0.07184096f, -0.02292615f, 0.01029305f, 0.00293216f, -0.02366562f, -0.01693461f, 0.06876390f, 
    -0.05906593f, -0.01056326f, 0.05841559f, 0.07452395f, 0.05835982f, -0.02331056f, -0.02549270f, 0.04015896f, 
    0.03698874f, 0.15814616f, -0.01241672f, -0.00547508f, 0.27294394f, -0.13586795f, 0.06122672f, 0.01598122f, 
    -0.03086723f, 0.06287151f, 0.04984149f, -0.09792972f, 0.18083125f, 0.01471389f, -0.02891813f, -0.02453699f, 
    0.05379969f, 0.04706096f, -0.02109365f, 0.11267161f, 0.02971233f, -0.00236272f, -0.35227981f, -0.33849296f, 
    0.04442519f, 0.03573469f, -0.06221791f, 0.06842908f, 0.05043648f, -0.02841724f, -0.01976982f, -0.17294225f, 
    0.01112790f, 0.01139092f, -0.11143545f, -0.08991053f, -0.05435864f, -0.04446640f, 0.04654131f, -0.06418323f, 
    -0.16117992f, -0.31536376f, 0.10120793f, -0.13964765f, 0.20347449f, 0.02697669f, -0.08948710f, -0.03574677f, 
    -0.04099975f, -0.02491468f, -0.03711389f, 0.02776970f, 0.01962552f, -0.05858402f, -0.02131979f, -0.02773094f, 
    -0.03482980f, -0.15248355f, 0.04426273f, 0.03188981f, -0.28840640f, -0.25849769f, -0.35286853f, -0.14477180f, 
    0.14166856f, 0.05298183f, -0.02807382f, -0.02641577f, -0.08026715f, 0.02678027f, 0.13107370f, 0.16219084f, 
    -0.00904372f, -0.01599411f, 0.04864198f, -0.09182031f, -0.04030696f, -0.17198206f, 0.03480731f, 0.07809136f, 
    0.06547476f, -0.06946775f, -0.13568188f, 0.05618989f, -0.11585493f, 0.06460651f, 0.04776195f, 0.00097372f, 
    0.06160630f, 0.07854428f, -0.06173243f, -0.01105389f, 0.01027534f, -0.03624911f, -0.01687892f, 0.07287082f, 
    0.02342474f, -0.08800226f, -0.01803849f, -0.03657752f, 0.18615091f, -0.02682408f, -0.09754474f, 0.05917000f, 
    -0.22131196f, -0.05695307f, 0.10050654f, 0.04639231f, -0.01862451f, 0.11562312f, 0.03063206f, -0.02220579f, 
    -0.01904151f, 0.07374059f, 0.00410516f, 0.07277614f, 0.09677294f, 0.03302875f, -0.01257990f, -0.00790365f, 
    -0.04492529f, -0.11612387f, 0.03018566f, -0.10126776f, 0.21688497f, -0.01535075f, -0.00193742f, -0.00486789f, 
    -0.05405922f, -0.01677040f, 0.01154615f, -0.00769879f, 0.04320360f, -0.09639449f, 0.00620851f, 0.06371891f, 
    -0.10163060f, 0.01698514f, 0.06547487f, 0.03353088f, -0.08712832f, -0.04562965f, 0.01997464f, 0.01320309f, 
    -0.08470191f, -0.07838445f, 0.04881568f, 0.04803267f, 0.03468563f, 0.04179361f, -0.00664530f, -0.00785827f, 
    0.00110563f, -0.00635114f, -0.06063138f, 0.04731927f, 0.11618475f, -0.01879516f, 0.05246149f, 0.01512259f, 
    -0.11911747f, 0.00026589f, -0.01614120f, -0.13534853f, -0.13101214f, 0.00539500f, -0.01673038f, -0.10951076f, 
    0.03710303f, 0.01844135f, -0.13928010f, -0.04009295f, -0.07322682f, 0.01883101f, 0.03188532f, -0.00392155f, 
    -0.04137131f, 0.00309017f, 0.06900560f, -0.04878192f, -0.06430887f, 0.00936504f, -0.19026609f, -0.02960669f, 
    -0.25494379f, -0.01905248f, -0.02422403f, 0.02613265f, -0.07879490f, 0.06848815f, -0.03363878f, 0.00787100f, 
    -0.07515743f, 0.02368338f, 0.05231147f, -0.02542724f, 0.02934672f, 0.00566858f, 0.00261354f, 0.07730218f, 
    0.08459264f, -0.36303708f, 0.05382052f, -0.09281182f, -0.06567079f, -0.02379383f, -0.04611997f, -0.04062414f, 
    0.01592839f, -0.04738422f, -0.14336173f, -0.01469736f, -0.09404480f, -0.09372584f, 0.01755720f, -0.10736931f, 
    0.05715520f, -0.05179046f, 0.11064637f, -0.01176547f, 0.12854993f, 0.09157708f, 0.09445170f, 0.09140488f, 
    0.11678989f, -0.00403895f, -0.01472421f, 0.00271265f, -0.00215797f, 0.05137729f, -0.02586105f, 0.01455637f, 
    0.02923528f, -0.03421587f, -0.03718113f, 0.01410182f, -0.00644265f, 0.04858790f, 0.05921911f, -0.00247057f, 
    0.23313123f, -0.02763426f, 0.10256324f, 0.02620386f, 0.05456658f, 0.00607418f, -0.01686371f, -0.05299913f, 
    0.00505491f, -0.02619408f, -0.00228392f, 0.03023766f, -0.05002388f, 0.03021890f, -0.01048455f, -0.07079227f, 
    0.05415411f, -0.03786401f, 0.04692281f, 0.03812899f, 0.06813301f, -0.00996714f, -0.09680211f, 0.03581573f, 
    -0.14728919f, -0.01442505f, 0.04432055f, -0.03811983f, -0.08195355f, 0.04237172f, 0.12295315f, 0.09751602f, 
    -0.08615778f, -0.01554432f, 0.06519150f, 0.03402606f, 0.04091206f, 0.03971768f, 0.01008660f, 0.03096525f, 
    0.11513080f, 0.01620197f, 0.03537977f, 0.07373582f, -0.23082511f, -0.02984005f, -0.02927255f, 0.05925231f, 
    0.06318467f, 0.03443426f, 0.06508730f, 0.01359866f, 0.08212537f, 0.06931496f, -0.05445662f, -0.06333394f, 
    0.15066859f, -0.04206261f, -0.06321184f, -0.00258292f, 0.22133861f, -0.11589302f, -0.23109134f, 0.08147712f, 
    -0.17715426f, -0.06181242f, -0.03695871f, -0.00823510f, 0.00304402f, 0.06920478f, 0.03539653f, 0.05543241f, 
    -0.04829115f, 0.02687693f, 0.01277214f, 0.06800507f, 0.02342846f, -0.02858359f, -0.00980724f, 0.02508041f, 
    0.14723504f, 0.10569613f, -0.10181937f, -0.08119895f, 0.06489719f, 0.17396165f, 0.04860042f, 0.04913387f, 
    0.05166642f, 0.06958324f, 0.08165760f, -0.14451180f, 0.03001888f, -0.03347884f, 0.03048130f, -0.03481036f, 
    -0.01770715f, 0.04894353f, -0.06204113f, -0.04135613f, 0.07758812f, -0.07936443f, -0.19233696f, 0.07217525f, 
    -0.03571365f, 0.09310230f, -0.08445864f, 0.06487006f, 0.04338494f, -0.05824930f, 0.04462745f, 0.03948833f, 
    0.03888471f, 0.09138690f, -0.06482993f, 0.02839329f, -0.02341819f, -0.03317213f, -0.04043779f, -0.00309330f, 
    0.05714391f, -0.01802741f, 0.08748803f, -0.03050114f, 0.10570911f, -0.10879960f, -0.01922677f, -0.04261365f, 
    -0.05823467f, -0.03057965f, 0.17970625f, -0.09260948f, 0.05990460f, -0.02674254f, -0.04870913f, -0.04794523f, 
    -0.02754622f, 0.03569727f, 0.06220295f, 0.11430886f, -0.02419413f, -0.08113385f, -0.05027909f, -0.02644883f, 
    -0.16775252f, 0.04762712f, 0.02872881f, 0.06891620f, -0.02078844f, -0.02593092f, -0.02388733f, 0.04102743f, 
    0.07665156f, -0.01054881f, 0.02056037f, -0.10083630f, -0.10167501f, -0.16377658f, -0.07380092f, -0.02785461f, 
    0.35233107f, -0.39028272f, -0.18334541f, 0.07688327f, 0.03902952f, -0.08488833f, 0.06512480f, -0.04094448f, 
    0.10470953f, 0.01098762f, 0.01940088f, 0.03996554f, 0.02593978f, 0.05608467f, -0.03083772f, 0.14067923f, 
    -0.03210388f, -0.03229343f, -0.02428875f, -0.01417915f, -0.12146642f, 0.05658316f, 0.15542527f, 0.02705977f, 
    0.08822029f, -0.01522542f, -0.07538042f, 0.03485585f, 0.01189972f, -0.01184713f, -0.02286681f, 0.04935788f, 
    0.07283299f, 0.06399575f, -0.00063972f, 0.00785212f, 0.00962789f, -0.10280582f, -0.00373940f, -0.07361214f, 
    -0.21474162f, 0.11266139f, 0.13733746f, -0.16105203f, -0.28463513f, -0.04421048f, 0.08336449f, 0.01496025f, 
    0.01118908f, -0.04753685f, 0.15629880f, -0.03089482f, 0.13979521f, -0.06214470f, 0.07406969f, -0.09100285f, 
    -0.00634135f, -0.18138985f, 0.03501880f, -0.02943368f, -0.11536187f, -0.07417111f, -0.10601670f, -0.23980060f, 
    0.12746570f, 0.02944294f, -0.10151815f, 0.11588495f, 0.05769680f, 0.00223501f, -0.01615489f, -0.03269006f, 
    0.03112402f, 0.00547969f, 0.11095493f, -0.06415524f, -0.01640182f, -0.09673101f, -0.09954114f, -0.08920953f, 
    0.06312802f, 0.18886198f, 0.07900934f, -0.00463784f, 0.13853790f, -0.09054830f, -0.09109767f, 0.00006547f, 
    -0.03275236f, 0.08063911f, 0.05018503f, 0.05566652f, 0.14554799f, -0.01299657f, 0.03028918f, -0.03962444f, 
    0.03828628f, 0.01118564f, 0.06925936f, 0.11743935f, 0.14963520f, 0.09429139f, 0.13261016f, 0.08327436f, 
    0.14352268f, -0.05950876f, -0.04982257f, -0.00472156f, -0.00044434f, -0.02033999f, 0.03428657f, 0.02615896f, 
    -0.02644017f, 0.01080752f, -0.04957155f, -0.01133137f, 0.05888278f, 0.05170820f, -0.04696404f, 0.01912269f, 
    0.17228550f, 0.02535607f, 0.06191959f, 0.08027393f, 0.10692158f, 0.04694856f, -0.02383403f, -0.01545316f, 
    0.05142047f, -0.02375904f, 0.02353480f, 0.00077295f, -0.06170474f, 0.02321498f, -0.09634610f, -0.01756885f, 
    0.05167894f, 0.08963305f, -0.04044334f, 0.06500306f, 0.30134165f, -0.28142390f, 0.10216077f, -0.16712496f, 
    -0.05125989f, -0.05536590f, -0.14352980f, -0.00566430f, 0.00176572f, -0.01615562f, -0.06127118f, 0.01331469f, 
    -0.05455157f, -0.05051524f, 0.14425071f, -0.15827008f, -0.03095996f, -0.10461485f, -0.00955033f, -0.05382385f, 
    0.08997648f, -0.04878501f, -0.00533280f, 0.07691015f, 0.04970469f, 0.00497926f, -0.10428988f, 0.03162657f, 
    0.00307435f, -0.00971146f, -0.03631688f, -0.05562758f, -0.01504975f, 0.01756131f, 0.08356062f, 0.11133240f, 
    -0.02094764f, -0.07986272f, -0.03815093f, -0.03030448f, -0.07291081f, 0.20545478f, -0.11228658f, -0.02079403f, 
    0.09240151f, 0.10819002f, 0.01278868f, 0.03691222f, 0.02674353f, 0.03571293f, 0.01673272f, -0.01206469f, 
    -0.02902848f, 0.03158389f, -0.10300015f, -0.04006887f, -0.04163108f, 0.07292377f, -0.09050658f, 0.04300128f, 
    0.05348976f, 0.13087308f, -0.10634398f, -0.18236412f, 0.04327060f, 0.00228103f, 0.07142267f, 0.06063108f, 
    -0.04725702f, 0.00396057f, -0.04816359f, 0.00627940f, -0.06385604f, -0.06063530f, 0.02053494f, 0.03623492f, 
    0.01076549f, 0.02088929f, -0.01914720f, 0.01690909f, 0.06200983f, 0.05606183f, -0.09128185f, 0.05197690f, 
    -0.15186545f, -0.01150905f, -0.01314420f, 0.12421840f, 0.07247090f, 0.06554174f, -0.04347524f, -0.02006363f, 
    -0.01759814f, -0.08344237f, -0.04365605f, 0.04006543f, 0.02608556f, 0.01657416f, 0.06811167f, -0.00570459f, 
    -0.08707656f, -0.08355096f, -0.02023798f, -0.13604921f, -0.28057638f, 0.02920139f, 0.03057374f, -0.01093541f, 
    -0.02620018f, 0.01683126f, 0.00657784f, 0.01413677f, -0.00465015f, -0.03970008f, -0.01875521f, -0.02870682f, 
    0.00729536f, 0.06592716f, -0.02355576f, -0.00156546f, -0.14125922f, -0.07667319f, 0.03260911f, -0.07229970f, 
    0.03756976f, 0.08553689f, -0.00375672f, 0.05014345f, 0.04995046f, -0.03420680f, 0.00170771f, 0.03008329f, 
    0.03292438f, 0.02025639f, -0.04306986f, -0.09143271f, -0.07436813f, 0.00879073f, -0.04145975f, -0.02780086f, 
    0.04215311f, 0.02085469f, 0.05221471f, -0.15331244f, 0.07373326f, 0.03466779f, 0.01656004f, 0.12568656f, 
    0.01799120f, -0.00897431f, 0.00553691f, 0.05964515f, 0.08180962f, -0.04069060f, -0.02804975f, 0.06879500f, 
    -0.01796064f, 0.02229561f, -0.00889259f, -0.04717477f, 0.27095208f, -0.21647984f, -0.14405812f, 0.02365074f, 
    -0.12872967f, -0.05043227f, -0.00277341f, -0.01424883f, -0.00053719f, -0.05508546f, -0.00047298f, -0.02807295f, 
    -0.01722688f, -0.03025202f, -0.04398594f, 0.03796644f, 0.03277648f, -0.00355491f, 0.08356133f, -0.01948385f, 
    -0.08813091f, -0.00382498f, 0.04638835f, -0.07027481f, -0.06960574f, -0.05851617f, -0.03436335f, 0.09063587f, 
    0.00839700f, 0.01862232f, -0.09061506f, 0.00626790f, 0.01248781f, -0.00826696f, -0.04793400f, 0.03405159f, 
    0.00593741f, -0.00356780f, 0.02590167f, -0.01970862f, 0.27150136f, -0.26480320f, -0.02470543f, -0.14656794f, 
    -0.05693954f, 0.03604756f, -0.12883505f, 0.09716348f, 0.02859786f, -0.01479942f, 0.00796736f, -0.03078039f, 
    0.05553382f, 0.01357000f, 0.03443565f, 0.00511143f, -0.12106387f, -0.00096579f, 0.04271460f, -0.05146629f, 
    0.08051396f, -0.28387678f, 0.06457004f, -0.11788133f, -0.26170665f, -0.01714626f, -0.09634922f, -0.13789529f, 
    0.03288599f, 0.01637630f, 0.01446237f, 0.00986047f, -0.02733178f, -0.09683420f, 0.00175013f, -0.03943203f, 
    0.01688905f, 0.15073656f, 0.01903858f, -0.04754688f, 0.09991002f, 0.16522418f, 0.00318611f, -0.00276110f, 
    -0.00647521f, 0.04781873f, 0.03078293f, 0.03786628f, 0.01341736f, -0.04777017f, 0.00348292f, -0.03575699f, 
    0.00194520f, 0.00031542f, -0.04855632f, -0.00465595f, 0.02787240f, -0.06209325f, 0.07013477f, -0.00550294f, 
    0.05364193f, -0.05664166f, -0.09105282f, -0.12333724f, -0.17951766f, 0.07686222f, -0.08049700f, -0.16053669f, 
    -0.03851261f, -0.07020427f, 0.02604011f, 0.00469727f, -0.00061599f, -0.02370775f, 0.02595467f, -0.03143468f, 
    -0.06506867f, 0.01395916f, 0.05869563f, -0.03432330f, -0.21020092f, -0.09354430f, 0.05722160f, -0.21131665f, 
    -0.18409154f, 0.08388823f, -0.02435166f, 0.03906116f, -0.01634496f, 0.07560349f, -0.02618963f, 0.05029783f, 
    -0.00841194f, -0.11496636f, -0.01769004f, 0.07487195f, -0.02628067f, 0.06869440f, -0.06140534f, -0.08237213f, 
    0.08179045f, 0.07514265f, 0.11522342f, 0.06821693f, 0.04901406f, 0.03840134f, -0.10285054f, -0.01803805f, 
    0.03392920f, 0.03111559f, -0.02976785f, -0.01427022f, 0.04854180f, 0.01748076f, -0.04857375f, -0.00296546f, 
    -0.07294679f, -0.05610531f, -0.00203568f, 0.00125104f, -0.38085568f, 0.15949309f, -0.02764190f, -0.02265058f, 
    -0.02142147f, -0.00262773f, 0.03358505f, -0.08157246f, 0.02088513f, 0.02392059f, 0.01261804f, -0.05753291f, 
    0.01796105f, -0.04212601f, 0.05187913f, -0.06343827f, 0.09175115f, -0.06045923f, -0.06459452f, 0.05757141f, 
    -0.09394009f, 0.05195358f, -0.00639879f, -0.08957855f, -0.02644372f, 0.02957157f, 0.06435599f, 0.02908476f, 
    -0.00722458f, 0.01944380f, -0.00997505f, -0.01271087f, -0.00070117f, -0.02676207f, -0.04900893f, 0.01271620f, 
    0.03309229f, -0.00228546f, -0.00991099f, -0.05049955f, 0.03703237f, 0.00849573f, 0.03766621f, -0.02231095f, 
    -0.00957704f, 0.04955318f, 0.08314811f, 0.07126798f, -0.04053970f, -0.07078893f, 0.03406561f, 0.09408931f, 
    -0.05277109f, -0.06504934f, 0.01595813f, 0.02357734f, -0.03206850f, 0.02319385f, -0.07020119f, 0.01281551f, 
    -0.04307880f, -0.11431616f, 0.10530333f, -0.01646424f, -0.00399710f, -0.05378822f, -0.03556211f, -0.00870280f, 
    0.05826115f, 0.01548062f, -0.02320984f, -0.03994470f, -0.05505728f, -0.00747204f, -0.03077599f, 0.00367103f, 
    -0.04604077f, -0.02657208f, -0.04619046f, -0.00507294f, -0.10220415f, 0.00606475f, 0.14937745f, 0.04204828f, 
    0.14917603f, -0.04425649f, -0.03867897f, -0.01957969f, 0.05321329f, 0.06833526f, 0.00027138f, -0.05842956f, 
    0.01393665f, -0.00156409f, 0.01960179f, -0.03096775f, -0.03209778f, -0.03809954f, -0.07532735f, 0.00242089f, 
    0.29962358f, 0.08094141f, -0.11868633f, 0.00837779f, 0.01145479f, -0.02629115f, -0.04201334f, 0.05887467f, 
    -0.00046126f, 0.00587087f, -0.02471459f, 0.00980202f, -0.04980462f, 0.00474331f, 0.00510751f, 0.00045864f, 
    -0.04916484f, -0.14546998f, 0.00645146f, -0.00084431f, 0.11852030f, -0.01531982f, -0.07795489f, 0.02152523f, 
    -0.03831344f, 0.00315726f, 0.04981407f, 0.01806738f, 0.01064713f, 0.01129593f, -0.03308139f, 0.01668998f, 
    -0.01109974f, -0.00653002f, -0.00639747f, -0.05010491f, -0.00927309f, -0.04024629f, -0.00659182f, 0.02678281f, 
    0.21344031f, 0.09940295f, 0.02781445f, 0.06689606f, 0.07203033f, -0.02257606f, -0.10053389f, 0.02328034f, 
    -0.01281568f, 0.05790837f, -0.02941776f, -0.00238419f, -0.00050728f, -0.03602568f, -0.03049818f, 0.00974188f, 
    -0.02925857f, -0.04842373f, -0.02074541f, 0.03046500f, 0.25043416f, -0.17200856f, -0.06486902f, 0.00239655f, 
    -0.21852963f, -0.03436668f, 0.00885838f, -0.06337855f, -0.02520999f, -0.04137383f, -0.03466451f, 0.02038493f, 
    -0.03274108f, -0.08509526f, -0.04627551f, 0.04486582f, -0.05443821f, -0.01744381f, 0.01759170f, -0.03619060f, 
    -0.08116286f, -0.01724666f, 0.03282163f, -0.02289863f, -0.02928129f, -0.02637564f, -0.05077003f, 0.06837031f, 
    -0.00194518f, -0.01494164f, 0.00323780f, 0.03133311f, -0.01689602f, 0.07420359f, 0.05592719f, -0.06744322f, 
    -0.04836300f, -0.06937977f, 0.02334913f, -0.02255142f, 0.24090070f, 0.01255305f, -0.06820478f, 0.02174306f, 
    0.13128479f, -0.06041607f, -0.06805667f, 0.07819037f, 0.11863749f, 0.00275181f, 0.06146561f, -0.05197138f, 
    0.06943585f, -0.06537700f, 0.07905047f, -0.02302876f, -0.05026890f, -0.10590526f, -0.03098347f, -0.03310779f, 
    -0.02214434f, -0.02563236f, 0.02848958f, -0.02047649f, -0.06837133f, 0.04649306f, 0.05718526f, 0.01445827f, 
    -0.05111115f, -0.00938770f, -0.01022978f, 0.00511461f, 0.02540975f, 0.05180124f, -0.07657964f, -0.10109987f, 
    0.02316206f, -0.02126060f, -0.03125395f, 0.01928408f, -0.09816635f, 0.01894036f, 0.03672620f, -0.08509397f, 
    -0.07315075f, -0.01013452f, 0.06069931f, -0.01877691f, -0.00507446f, -0.03118966f, 0.07039101f, -0.04224781f, 
    0.03524438f, -0.03797631f, 0.04037799f, 0.02615854f, -0.02149437f, 0.06416814f, 0.03549381f, -0.03099418f, 
    0.11799481f, -0.10336117f, 0.00237193f, -0.18518835f, -0.01941249f, 0.08168856f, -0.00345947f, 0.04049363f, 
    -0.05791778f, 0.09468684f, -0.03167220f, -0.04097483f, -0.00241369f, 0.06068955f, -0.02601628f, -0.03647991f, 
    -0.06187123f, 0.02671676f, -0.11715393f, -0.05015102f, 0.25693107f, 0.03642664f, 0.01587736f, 0.18011011f, 
    0.10403429f, -0.13795497f, 0.00360560f, -0.02620831f, 0.03263017f, 0.06298765f, -0.00090496f, 0.00911585f, 
    0.03614881f, 0.05367630f, -0.04851247f, 0.00640804f, -0.04887155f, -0.07185791f, 0.04311519f, -0.01073097f, 
    0.06902102f, 0.07965772f, -0.00587207f, 0.07748803f, 0.07145842f, 0.02206542f, 0.04021525f, 0.04655991f, 
    -0.00197228f, -0.06751463f, 0.00004030f, 0.00463792f, -0.06814363f, -0.01909776f, 0.00450997f, -0.03389423f, 
    -0.04856160f, -0.02944949f, -0.06742832f, -0.01368622f, 0.18382911f, -0.00519903f, -0.11522504f, -0.12012062f, 
    -0.06169018f, 0.02291284f, 0.01497525f, -0.01241291f, -0.07021143f, -0.01076739f, -0.03352387f, 0.03361407f, 
    0.01233059f, 0.02289332f, 0.01483830f, -0.10053353f, 0.00908042f, -0.00975264f, -0.03218845f, 0.01962701f, 
    0.36322087f, -0.23627752f, -0.09324795f, 0.00797438f, 0.06688056f, -0.10534620f, 0.02877820f, -0.10280529f, 
    0.03231845f, -0.02632413f, 0.05443576f, 0.00805786f, -0.01596983f, 0.02107780f, 0.00455441f, -0.08362943f, 
    0.03394674f, 0.08545627f, 0.01507747f, -0.00206261f, 0.20032096f, -0.05870844f, -0.06811123f, -0.00496511f, 
    -0.07493541f, -0.03784506f, 0.02453283f, 0.04206689f, 0.02457467f, -0.02118218f, 0.00656811f, 0.04541918f, 
    -0.04551166f, -0.00246446f, 0.05704034f, -0.01513209f, -0.04924912f, 0.01442386f, 0.03737426f, -0.05593311f, 
    0.07911719f, -0.14597823f, -0.20491113f, 0.08698722f, -0.14721014f, -0.01313869f, -0.06137981f, 0.06149838f, 
    0.09068559f, 0.10106091f, 0.02979610f, 0.04270441f, -0.02631577f, -0.01017384f, -0.00522347f, -0.00668988f, 
    0.03314287f, 0.03396742f, -0.01145352f, -0.03785099f, 0.38222718f, 0.02058622f, 0.18504526f, 0.02381500f, 
    0.26135442f, -0.01322682f, -0.14582078f, -0.18325351f, -0.00296577f, 0.07113673f, 0.00262081f, -0.02792709f, 
    -0.01513438f, -0.05903819f, 0.04021928f, 0.04780656f, -0.05758599f, 0.00413711f, 0.00476448f, -0.01380754f, 
    0.12151705f, -0.00457951f, -0.13252829f, -0.05185036f, 0.00097886f, 0.03355100f, 0.02115774f, 0.05013711f, 
    -0.06242885f, -0.01532198f, 0.00189831f, -0.00377890f, 0.02360126f, -0.05459947f, 0.00771670f, -0.05871980f, 
    -0.04840399f, -0.06041859f, -0.06731530f, -0.05215991f, -0.11621106f, -0.17652912f, -0.06484462f, -0.12501593f, 
    -0.11928287f, 0.00366365f, 0.03245277f, 0.03557280f, -0.11920492f, -0.01338701f, -0.07918616f, 0.03947981f, 
    -0.01070609f, -0.03289663f, -0.00067772f, 0.03388659f, -0.01060087f, 0.15114796f, -0.06205524f, -0.09112894f, 
    0.15892145f, -0.19203122f, 0.07017732f, -0.13316828f, -0.04258755f, 0.09038509f, 0.04534565f, 0.11058550f, 
    0.01619478f, -0.04110448f, -0.02312959f, 0.05282265f, 0.00646050f, 0.01091215f, -0.04082405f, 0.02469411f, 
    -0.06428792f, 0.03200959f, -0.06312261f, -0.00387489f, -0.07910632f, 0.03185855f, 0.00346464f, -0.09596255f, 
    -0.16376473f, 0.03131602f, -0.11741842f, 0.09012443f, -0.10627593f, -0.02512973f, -0.08811587f, -0.00378667f, 
    0.01301071f, -0.05553902f, 0.00621198f, 0.06376671f, -0.06359376f, 0.10752387f, 0.04812830f, 0.04838030f, 
    0.20377201f, -0.05587885f, 0.15253307f, 0.03736778f, 0.13815691f, -0.00379672f, -0.09717294f, -0.06223292f, 
    0.02543966f, 0.02928595f, 0.06702567f, -0.02115619f, -0.05599491f, 0.01328574f, -0.01296722f, -0.01310055f, 
    -0.05769232f, 0.02935781f, 0.03904552f, -0.02572849f, 0.09865861f, 0.04440839f, 0.16855723f, 0.05747615f, 
    0.16823356f, -0.12116581f, -0.07762522f, -0.07701264f, 0.02978881f, -0.01372951f, 0.04344242f, -0.05838745f, 
    -0.04911594f, -0.09491506f, 0.02830118f, -0.04189974f, -0.03393677f, -0.00759642f, 0.06976304f, 0.04499758f, 
    0.04129520f, -0.27281630f, 0.01794823f, -0.03092808f, -0.01069450f, 0.04959534f, 0.04206865f, 0.08628943f, 
    -0.03630239f, -0.00202646f, -0.01228993f, -0.01087655f, -0.02962205f, 0.01918814f, -0.07642119f, 0.00129438f, 
    -0.00848091f, 0.00773021f, -0.09606972f, -0.06108121f, 0.10574380f, 0.04036853f, -0.01532805f, -0.04741927f, 
    0.00167814f, -0.08330385f, -0.01747592f, -0.02396366f, -0.04172008f, -0.06154812f, -0.01129414f, -0.03858738f, 
    -0.02806751f, -0.05873699f, 0.02728928f, 0.02450608f, 0.03410946f, -0.01773332f, 0.06877772f, 0.03036856f, 
    0.26791236f, 0.00383265f, -0.17918009f, 0.08347297f, -0.14114097f, -0.03967162f, 0.02062940f, -0.03193687f, 
    -0.04328883f, 0.04161977f, 0.04419953f, 0.02328060f, -0.01570268f, -0.05172250f, -0.02716768f, -0.02307190f, 
    0.01631461f, -0.06296605f, 0.07065532f, -0.07417822f, 0.37516403f, -0.35469672f, -0.10088409f, -0.01189162f, 
    0.00513176f, -0.09475008f, -0.06295907f, 0.02130816f, -0.01129172f, 0.06124549f, 0.01265903f, 0.04509073f, 
    0.01293445f, -0.04736170f, 0.09453052f, 0.00991408f, -0.04537281f, 0.06132812f, 0.04153777f, 0.00426352f, 
    0.13637392f, -0.38478127f, 0.08479302f, -0.10859364f, -0.00748046f, 0.10570519f, -0.05036691f, 0.00663485f, 
    0.02168356f, 0.11227421f, 0.00105062f, 0.00075884f, 0.04082584f, 0.04554010f, -0.08075365f, 0.00486846f, 
    -0.09227018f, -0.02370720f, -0.05417247f, -0.10805140f, -0.14999335f, 0.01721336f, -0.03657877f, -0.09315688f, 
    0.01005622f, 0.04258947f, 0.02431994f, 0.03379157f, 0.00347516f, 0.01960515f, -0.03520902f, -0.01317790f, 
    0.01443356f, -0.02509803f, 0.03551475f, -0.06284171f, -0.05178044f, -0.03180295f, -0.10148919f, -0.01570054f, 
    -0.01203146f, -0.03205107f, 0.10886519f, -0.09787487f, 0.00213077f, 0.01112380f, -0.05738906f, 0.04250402f, 
    0.03679644f, 0.02652618f, -0.06712130f, 0.02975194f, 0.02789607f, 0.03333604f, -0.04369368f, -0.06293686f, 
    -0.06954956f, 0.03756574f, 0.00018522f, -0.02500294f, -0.04859524f, 0.04145667f, 0.11856888f, 0.11444015f, 
    0.16166715f, -0.04917053f, -0.05056638f, -0.09573393f, 0.01550199f, 0.00088968f, -0.00504162f, -0.01865725f, 
    0.00903525f, 0.02272489f, 0.03847847f, -0.05155160f, 0.00484864f, -0.10098936f, -0.06424429f, 0.02299800f, 
    -0.12676224f, -0.18354778f, -0.03894202f, 0.02677340f, -0.01718023f, -0.08705917f, 0.02068671f, -0.07620167f, 
    -0.00447769f, -0.05488613f, -0.05797895f, 0.01150716f, -0.01772325f, 0.05235931f, 0.03820562f, -0.02700756f, 
    -0.02816966f, -0.01453052f, -0.00599538f, 0.03445136f, 0.15222731f, -0.13320073f, 0.09307273f, 0.05295097f, 
    0.13671939f, -0.12050379f, 0.00253082f, -0.10004638f, 0.01176444f, 0.01584334f, 0.01700508f, -0.02752328f, 
    0.03562017f, 0.04294256f, 0.02621362f, 0.01770840f, -0.03801246f, 0.03406009f, -0.00269732f, -0.02188591f, 
    -0.12520181f, -0.16860013f, -0.12183177f, 0.00478441f, -0.06551568f, -0.07967438f, 0.00012496f, -0.06062827f, 
    -0.15576343f, -0.02489226f, -0.04661876f, 0.01477744f, 0.05885070f, -0.01507887f, 0.03283273f, -0.01778886f, 
    -0.07228666f, -0.04250392f, 0.01212634f, -0.01146477f, 0.03101494f, 0.16616817f, -0.03181326f, -0.07687721f, 
    0.02212533f, 0.04050751f, 0.05543359f, -0.00446715f, -0.03617017f, -0.04075709f, -0.04863516f, -0.02859347f, 
    -0.08343718f, -0.07702094f, -0.01032167f, 0.00018280f, 0.02782621f, -0.01903653f, 0.03881750f, 0.00613426f, 
    -0.28066313f, 0.11158266f, 0.10409230f, -0.00562655f, 0.02386366f, 0.03611920f, -0.00970101f, -0.09757712f, 
    0.04514480f, 0.09948964f, 0.00997798f, 0.00152083f, 0.05561983f, -0.00389713f, 0.08166552f, 0.04254520f, 
    0.04561485f, -0.09696738f, -0.00730486f, -0.01593926f, -0.29808906f, 0.01170204f, -0.03282357f, -0.15677288f, 
    0.01352093f, 0.01122583f, 0.06004803f, -0.04609345f, -0.01996319f, -0.11842881f, -0.02640850f, -0.01388070f, 
    0.00158133f, -0.04789537f, -0.05984002f, -0.06939623f, 0.06846304f, 0.08714293f, 0.00426863f, -0.02972630f, 
    0.32213095f, -0.15522228f, 0.14346002f, -0.00890997f, -0.21334736f, -0.09991898f, 0.03820240f, 0.01273856f, 
    -0.01127172f, -0.01117992f, -0.02737918f, 0.01532602f, 0.03010643f, 0.05016140f, -0.00916950f, 0.05898205f, 
    0.00574350f, 0.06243585f, 0.09562789f, 0.01633686f, -0.06835730f, 0.07052629f, 0.02851851f, -0.07870677f, 
    0.05774152f, 0.07116406f, 0.07718242f, 0.08317860f, -0.04376060f, -0.02287981f, -0.06166803f, 0.07954302f, 
    0.01085013f, -0.10162029f, 0.02807929f, 0.00859491f, -0.03734705f, -0.02658219f, -0.06294163f, 0.01858147f, 
    -0.27655709f, -0.07509743f, -0.08844533f, -0.09132399f, -0.08296081f, 0.00963827f, 0.05140731f, -0.03562379f, 
    0.00479510f, -0.09522301f, 0.04804404f, -0.08567491f, 0.01001778f, -0.02011817f, 0.00263088f, 0.02583350f, 
    0.01433594f, 0.04485046f, -0.04003488f, -0.04424014f, -0.13485026f, -0.04275779f, -0.12109726f, -0.14910129f, 
    -0.15028104f, 0.07094926f, -0.02357588f, 0.00932467f, -0.02938072f, 0.01830569f, -0.03020829f, 0.00434486f, 
    -0.03166455f, -0.03825097f, 0.00551415f, -0.01924378f, -0.00782149f, 0.07866778f, 0.02872808f, -0.02190971f, 
    -0.07202865f, 0.11541942f, 0.06383733f, 0.02299435f, 0.05536998f, -0.07618432f, 0.01851904f, 0.00895250f, 
    -0.03213593f, -0.06923419f, -0.02277769f, 0.00530264f, -0.04693694f, -0.00084225f, 0.06517848f, 0.03326553f, 
    -0.07069739f, -0.06409275f, -0.03721108f, 0.02625242f, 0.09027703f, -0.02164253f, 0.06748624f, -0.10395471f, 
    0.06442671f, 0.01383881f, -0.04272648f, 0.09322920f, 0.04614716f, -0.03576126f, -0.03347467f, -0.00785449f, 
    0.01107062f, 0.05077358f, -0.01870206f, -0.07172927f, -0.02338978f, -0.02255354f, -0.04631969f, -0.01484129f, 
    -0.17533956f, 0.06769570f, 0.00117952f, -0.08123347f, 0.13402432f, 0.10367732f, 0.03806641f, 0.04628189f, 
    0.06565747f, -0.01587309f, -0.05772445f, -0.00587725f, 0.00836493f, -0.00249352f, 0.02753038f, -0.04655115f, 
    0.02008040f, -0.01864507f, -0.06072655f, -0.01189085f, 0.06392384f, -0.13376613f, 0.01106388f, -0.19110376f, 
    0.00826310f, 0.05757859f, -0.04446802f, 0.06620472f, -0.02390134f, 0.01522342f, -0.12396182f, 0.07161906f, 
    0.07821051f, -0.06239821f, 0.00333220f, -0.01209044f, 0.00210159f, 0.07230046f, 0.01957568f, 0.01741808f, 
    -0.16114703f, 0.11139099f, 0.00071596f, -0.06677675f, 0.05928192f, 0.02190906f, 0.12017808f, 0.05810215f, 
    -0.02983125f, -0.02998791f, -0.04617435f, 0.03051384f, 0.00170763f, -0.05129498f, -0.02489127f, -0.01855711f, 
    -0.02399703f, 0.05445268f, -0.04353617f, 0.00002291f, 0.07962847f, 0.04745466f, -0.16339356f, -0.06210693f, 
    0.00557499f, 0.04894203f, 0.04301815f, 0.00299872f, -0.02680145f, -0.04777186f, -0.05644590f, -0.01795770f, 
    0.03316687f, -0.02479448f, 0.00946470f, 0.00225437f, 0.01184753f, -0.07603431f, -0.04819031f, -0.02421044f, 
    -0.15729852f, -0.00889261f, -0.08378208f, -0.11689960f, 0.24135821f, 0.02511494f, 0.10786114f, -0.02222908f, 
    -0.07098436f, 0.05063451f, 0.05351432f, -0.01235986f, 0.07680609f, -0.01071620f, 0.01338416f, 0.04764697f, 
    0.03211109f, -0.03367706f, 0.02427656f, 0.10737300f, 0.20260379f, -0.10832468f, 0.03765638f, 0.04808103f, 
    0.05745795f, 0.01476807f, -0.00667589f, -0.00385515f, -0.01576628f, -0.00288807f, 0.03620252f, 0.01484182f, 
    0.01683412f, -0.03527100f, 0.03965457f, -0.01970820f, 0.00393617f, -0.01150736f, -0.00999969f, 0.05750214f, 
    0.14791892f, 0.03528913f, 0.12880524f, -0.01462139f, -0.05502985f, 0.01031982f, -0.02417412f, -0.02300855f, 
    -0.04177561f, 0.00003564f, 0.02916799f, 0.03313280f, 0.02716076f, -0.05689339f, -0.05102225f, 0.04474387f, 
    -0.02038822f, 0.04687914f, -0.03532138f, 0.00983141f, -0.31488568f, -0.38346577f, -0.19753452f, -0.02683290f, 
    -0.13390757f, -0.06765208f, 0.02297924f, 0.06847794f, 0.02498028f, -0.10894390f, -0.02880060f, -0.06601071f, 
    0.07879233f, 0.04756760f, -0.01500103f, 0.07656085f, -0.02940688f, 0.00398812f, -0.03032537f, 0.06600007f, 
    -0.19347133f, -0.47938448f, -0.35262570f, -0.03277515f, 0.08819175f, -0.12089052f, -0.01086501f, 0.07753307f, 
    0.02915555f, -0.04443156f, -0.01726854f, 0.04197354f, -0.07494951f, -0.07745584f, 0.08621138f, -0.09437779f, 
    -0.02295013f, -0.04421488f, -0.02604281f, -0.01804064f, 0.03562393f, 0.04224936f, 0.06258841f, 0.06165718f, 
    0.00319173f, 0.10219587f, -0.02170055f, 0.04840894f, 0.01369490f, 0.01049632f, 0.04477256f, 0.07194293f, 
    -0.01087208f, -0.07181106f, -0.05704159f, -0.09121674f, -0.02301748f, -0.01383804f, 0.04327863f, -0.00743227f, 
    0.15021534f, -0.16498557f, -0.15517315f, 0.03339700f, 0.01161402f, 0.01246171f, -0.08207761f, -0.03352411f, 
    0.04283290f, 0.04365981f, 0.00405393f, -0.01011950f, -0.02915221f, 0.02098423f, 0.07021093f, 0.01218671f, 
    -0.03968024f, -0.01849701f, -0.06048227f, 0.03190672f, 0.12389228f, 0.13572598f, -0.07472790f, 0.00406638f, 
    0.02932717f, -0.05753354f, -0.03961191f, 0.01466165f, 0.01480427f, 0.00220241f, 0.00881094f, -0.07103274f, 
    -0.03657554f, -0.00070862f, 0.01462863f, -0.14420752f, 0.04049318f, -0.02373860f, -0.00433710f, -0.02968869f, 
    0.13164254f, 0.06594376f, -0.14700800f, 0.06537125f, -0.07471779f, -0.08850876f, -0.03972218f, -0.13273546f, 
    -0.02620167f, -0.00803780f, -0.11585954f, -0.02539023f, 0.04157837f, 0.01392002f, 0.03426243f, 0.04393221f, 
    0.00249831f, 0.09579875f, -0.02744358f, 0.01679453f, -0.34624931f, 0.14214207f, -0.12223598f, 0.12403470f, 
    0.05139092f, -0.00371697f, 0.03532527f, 0.00564409f, 0.06140865f, -0.02666466f, -0.02863069f, 0.00263514f, 
    0.01795170f, -0.07053273f, 0.01688894f, 0.01809477f, -0.01164117f, -0.07867853f, 0.04164596f, -0.04410300f, 
    0.18536018f, 0.29331121f, 0.04495244f, 0.01178487f, -0.07613494f, 0.09492152f, -0.01531117f, 0.09099839f, 
    0.02325376f, -0.00858589f, -0.04030222f, -0.04354586f, 0.01798708f, 0.02966132f, -0.03533211f, 0.01006088f, 
    0.02096335f, 0.01857579f, 0.00799050f, 0.02311392f, 0.14014319f, 0.08608145f, 0.00333620f, 0.16395651f, 
    0.03062569f, 0.04507734f, 0.01916902f, -0.06235183f, 0.01471041f, 0.02553496f, -0.00289491f, 0.02373396f, 
    -0.06620835f, -0.00663688f, 0.02468417f, 0.06362791f, 0.00383679f, 0.11138680f, -0.05914408f, -0.00650936f, 
    -0.11241874f, -0.11688168f, -0.03922456f, -0.05864352f, -0.16114621f, -0.04979816f, -0.06004480f, 0.00603369f, 
    -0.00938050f, -0.01629755f, -0.05349610f, 0.07461329f, -0.00021504f, 0.02442737f, -0.00555812f, 0.00109247f, 
    -0.00401966f, -0.04626209f, -0.00226715f, 0.00977792f, 0.04881087f, 0.17321819f, -0.05505040f, 0.07473420f, 
    0.03545465f, -0.03761844f, 0.13100086f, -0.04151618f, 0.00134187f, -0.04296260f, -0.02241741f, 0.06772447f, 
    -0.06397209f, -0.00319931f, -0.00856804f, -0.02127479f, 0.06868346f, -0.00788134f, -0.05083868f, -0.00979793f, 
    0.10826375f, 0.06380911f, 0.05582699f, 0.09495551f, 0.05283087f, 0.02596285f, 0.00352341f, -0.04338896f, 
    0.00340362f, -0.01299150f, 0.04004908f, -0.02598425f, -0.00241669f, 0.00217079f, 0.00488731f, 0.00303074f, 
    -0.03114965f, 0.02461354f, 0.03192959f, 0.04332506f, -0.04585746f, -0.26169562f, -0.02525491f, 0.15180382f, 
    0.00969689f, 0.07276361f, -0.02664648f, 0.11284935f, 0.03472855f, -0.04534855f, -0.04055563f, -0.01664277f, 
    -0.07502350f, -0.08169492f, -0.00495121f, 0.05536926f, -0.01802360f, 0.10152538f, -0.06092949f, -0.06461550f, 
    0.07025605f, 0.09396683f, -0.07133407f, 0.02343713f, -0.09003782f, -0.03529881f, -0.02558715f, 0.03530158f, 
    0.01617633f, -0.03073126f, -0.06873889f, -0.03622502f, 0.05670336f, 0.02346760f, -0.00341351f, -0.02774031f, 
    -0.05649281f, 0.02541234f, -0.08377565f, -0.03304322f, -0.11981928f, -0.03967466f, -0.17621052f, -0.06030868f, 
    -0.18830429f, -0.01631806f, 0.01761315f, 0.01681540f, -0.03030140f, -0.02829619f, -0.02227950f, 0.00819671f, 
    0.06177440f, 0.01672743f, 0.00240976f, 0.02566398f, -0.04472271f, -0.00473299f, -0.04046360f, 0.03535445f, 
    -0.36198136f, 0.09710957f, 0.01869914f, -0.19537640f, -0.17263959f, -0.03550125f, -0.06189683f, -0.06311846f, 
    0.06134726f, -0.04999962f, 0.08932870f, -0.03693251f, -0.05065203f, 0.04747354f, -0.01789796f, 0.00407323f, 
    0.02365805f, -0.11633046f, 0.01721023f, -0.02711172f, -0.07380486f, -0.30570930f, -0.17301628f, 0.06924800f, 
    0.07560465f, -0.07258871f, -0.02441934f, 0.01839975f, 0.03757227f, -0.04509858f, -0.01550623f, -0.00876997f, 
    -0.02784152f, 0.04860633f, 0.03084996f, -0.00506974f, -0.00184084f, -0.00541927f, -0.00615925f, 0.01451402f, 
    -0.08049673f, -0.07751156f, 0.04512059f, -0.01491440f, -0.15476961f, -0.00263888f, -0.08190364f, -0.06785118f, 
    -0.02813882f, -0.06876950f, -0.04705982f, 0.04348294f, -0.02290036f, 0.06833424f, 0.11677661f, -0.00710519f, 
    0.01235338f, -0.03842775f, -0.03241352f, 0.01626129f, -0.03846943f, 0.04066918f, 0.11085181f, 0.10125801f, 
    0.03382624f, -0.03708549f, -0.04636210f, -0.03364692f, -0.05040512f, -0.03117739f, -0.01625839f, -0.02897182f, 
    0.05481452f, -0.05183767f, 0.00771880f, 0.01906391f, 0.06042065f, 0.01475695f, 0.03272582f, -0.03355256f, 
    -0.13533631f, -0.33610508f, 0.00702438f, -0.06455833f, -0.15732445f, -0.01070451f, -0.09298386f, 0.12821837f, 
    -0.00745568f, -0.10029519f, -0.10537870f, -0.02700258f, 0.02300784f, 0.00232938f, 0.09871544f, 0.06485991f, 
    0.02577311f, 0.02168625f, -0.04102052f, 0.01515032f, -0.11078970f, -0.10472418f, 0.12053622f, -0.17671762f, 
    -0.12397092f, -0.11195687f, -0.13733174f, 0.00999046f, 0.03308071f, -0.02197992f, -0.04773482f, -0.13258524f, 
    0.09183684f, -0.01671312f, -0.00173880f, -0.02532166f, 0.10643411f, 0.07997891f, 0.05888021f, 0.11115169f, 
    0.02743719f, -0.20247959f, -0.14909366f, -0.01865170f, 0.06052497f, -0.06731076f, 0.01019004f, 0.01328063f, 
    0.03149294f, -0.00665273f, 0.05409947f, 0.00098804f, -0.05879411f, 0.12074168f, -0.02678114f, 0.01724199f, 
    0.05108917f, 0.02677502f, 0.00122062f, 0.01915703f, -0.14123243f, 0.07742849f, -0.07063245f, 0.12517893f, 
    0.02163769f, 0.03650752f, 0.03681733f, -0.00004545f, 0.04932048f, -0.01197390f, 0.06003032f, -0.01192438f, 
    -0.04929977f, -0.03018872f, -0.03294367f, 0.06444808f, -0.03294338f, 0.05767372f, 0.02477160f, -0.07667946f, 
    0.29507306f, 0.24836148f, -0.02104512f, -0.01164667f, -0.02690826f, 0.01911258f, -0.01058914f, 0.05031129f, 
    0.07065237f, 0.09729172f, -0.09733243f, -0.08193126f, -0.06584375f, 0.12174128f, -0.09198968f, -0.01368966f, 
    -0.03851998f, -0.02183416f, 0.09711175f, 0.09496253f, -0.08302309f, 0.04338251f, 0.02666829f, -0.00397749f, 
    -0.07380287f, -0.04982452f, -0.09475362f, 0.09632228f, -0.04737555f, -0.04324107f, -0.06837867f, 0.01918719f, 
    -0.05859870f, -0.00619661f, 0.01590051f, 0.03628768f, 0.00730702f, 0.02040730f, 0.14511526f, -0.00102845f, 
    -0.31889120f, -0.15438853f, 0.04050465f, 0.07192820f, 0.08551177f, -0.08357558f, -0.03540447f, 0.01471402f, 
    0.06149429f, -0.05014842f, -0.05358872f, 0.02594221f, 0.07232866f, -0.06749666f, 0.00921744f, -0.03513974f, 
    -0.00135568f, -0.06097708f, -0.03578781f, 0.05950765f, 0.22637393f, 0.26226735f, 0.02494708f, -0.05315391f, 
    -0.06732259f, -0.00292981f, 0.02149264f, -0.11083592f, 0.12928134f, 0.00093635f, 0.00835109f, -0.03023306f, 
    -0.12161685f, 0.01504626f, -0.10425176f, -0.01674707f, -0.03639562f, -0.11926652f, 0.06617648f, -0.00890706f, 
    -0.00753660f, -0.02193958f, 0.01074481f, 0.09354573f, -0.01042427f, -0.09606114f, -0.11548761f, 0.04411709f, 
    -0.06006651f, -0.01955164f, -0.04907566f, -0.00184637f, -0.03693210f, -0.01845608f, 0.01586751f, -0.02212935f, 
    0.01277885f, 0.09022218f, 0.01846091f, 0.02947145f, -0.06020085f, -0.05408296f, 0.09781634f, 0.01084052f, 
    -0.03041432f, 0.01969534f, 0.02168280f, -0.03226681f, 0.00907836f, -0.06623142f, 0.01564046f, -0.00309274f, 
    -0.05054112f, 0.02094491f, -0.06061430f, -0.02066885f, -0.02393602f, -0.05036062f, -0.02348391f, -0.01881205f, 
    0.09804976f, -0.18153764f, 0.14033748f, 0.00585052f, 0.10994278f, -0.07924693f, 0.08993389f, 0.03986270f, 
    -0.05847617f, 0.03188873f, -0.02153863f, 0.01827609f, -0.04083544f, -0.01717418f, -0.01010981f, 0.02949516f, 
    -0.01387859f, 0.05119424f, -0.01638486f, 0.05097919f, -0.08538348f, 0.07349253f, -0.08565681f, -0.03773042f, 
    0.00776096f, -0.00409655f, -0.17738396f, -0.00179622f, 0.05230228f, -0.07839109f, -0.02232556f, -0.05424042f, 
    -0.01312177f, -0.05624559f, 0.02747731f, -0.06147400f, -0.00928822f, 0.05748187f, -0.01192442f, -0.00200828f, 
    0.11765557f, 0.08708221f, -0.04919041f, 0.03545320f, 0.08073140f, -0.06976705f, -0.02141253f, -0.01011034f, 
    0.08553305f, 0.00451568f, -0.04103727f, -0.00296994f, 0.07119107f, 0.00734225f, -0.02912289f, -0.03191571f, 
    0.03301008f, -0.12858790f, 0.05518464f, 0.04438001f, 0.12288286f, 0.07951446f, 0.02257258f, 0.00296859f, 
    0.09065755f, 0.08997716f, 0.09355119f, -0.00460227f, -0.01047946f, 0.06538866f, -0.01730113f, -0.06251337f, 
    0.05488962f, -0.04288816f, -0.01507516f, 0.06479155f, 0.02713110f, 0.08124176f, 0.04390538f, -0.02620374f, 
    0.41627869f, 0.20498008f, -0.08366762f, 0.19578265f, -0.02862056f, -0.01364930f, -0.01281288f, -0.00121091f, 
    0.01946485f, 0.02510817f, -0.04511207f, -0.02004466f, -0.03978140f, 0.03135535f, -0.00189420f, -0.06206261f, 
    0.06715374f, 0.02124100f, 0.07749968f, -0.03631394f, 0.35402179f, 0.34945971f, -0.11133031f, 0.10843751f, 
    0.00076926f, 0.07847475f, 0.11125669f, 0.04566315f, 0.08487009f, 0.05088389f, -0.01170378f, -0.07447872f, 
    -0.07635827f, -0.04704244f, 0.05857454f, -0.05392687f, -0.03293498f, 0.10402352f, 0.02872743f, -0.09025811f, 
    0.00221471f, 0.04363431f, -0.13119686f, -0.01796167f, -0.02015601f, 0.01704776f, -0.11164040f, 0.07361238f, 
    -0.01885866f, -0.00310996f, -0.01256217f, -0.00392238f, 0.00754665f, 0.02982142f, -0.02475641f, -0.01728176f, 
    -0.02319547f, -0.00270100f, 0.04037269f, -0.02592217f, 0.17949997f, -0.08048248f, 0.02741164f, -0.08153296f, 
    -0.17101730f, -0.00976429f, -0.03579831f, -0.05366223f, -0.03824301f, -0.05319839f, -0.02596434f, -0.01664233f, 
    0.01316080f, -0.02464331f, -0.00483168f, 0.00143959f, -0.03389936f, -0.06055539f, -0.01285822f, 0.03883506f, 
    0.35024548f, 0.00084658f, -0.21515468f, 0.07839975f, 0.07756940f, -0.00099750f, -0.01338912f, -0.07067534f, 
    0.02172296f, 0.05302472f, -0.02361161f, -0.02770627f, 0.01793629f, 0.03767582f, -0.01562786f, 0.00398069f, 
    0.09107786f, 0.01733665f, 0.03526440f, -0.03929197f, 0.18899047f, -0.00744327f, 0.05261393f, 0.01044311f, 
    -0.03033200f, 0.01139565f, 0.03301111f, -0.03825560f, -0.05795993f, -0.02574207f, 0.01659407f, -0.01415744f, 
    0.02347442f, 0.01592144f, 0.02487949f, -0.00315723f, -0.00491889f, -0.05797248f, -0.02632939f, -0.00163604f, 
    -0.00917625f, -0.01968508f, 0.08061674f, 0.10548357f, 0.02022340f, -0.01179697f, -0.01582912f, 0.00111915f, 
    -0.04390696f, -0.03753817f, -0.08219063f, -0.00271219f, 0.01387742f, 0.01176851f, 0.05125786f, 0.00592557f, 
    0.07304404f, -0.00714771f, -0.05234595f, -0.00904707f, -0.05134469f, -0.08728557f, 0.06437430f, 0.01087618f, 
    0.00803872f, -0.00430838f, -0.08043253f, -0.11329662f, 0.06308846f, -0.04322844f, 0.03372189f, -0.00000935f, 
    0.07596728f, -0.00890554f, -0.08014587f, -0.04176700f, 0.01995783f, 0.04080790f, 0.03317382f, -0.02021269f, 
    0.05185334f, -0.05779228f, 0.04981961f, 0.05265033f, -0.00123317f, -0.04836950f, -0.01599114f, -0.03382820f, 
    -0.01553660f, 0.02514631f, -0.05593729f, -0.03424634f, 0.01746836f, 0.06944841f, 0.04762504f, 0.02154151f, 
    0.01351237f, 0.04992338f, -0.01011795f, -0.00150598f, -0.34305823f, -0.31957969f, -0.18076687f, -0.03621791f, 
    -0.06202663f, -0.09150951f, -0.02691233f, 0.00896450f, 0.01244758f, -0.05246091f, -0.02818554f, -0.02973501f, 
    0.03839394f, -0.00642594f, 0.02307921f, 0.04368212f, -0.02662056f, 0.02836720f, 0.00350498f, 0.04669192f, 
    -0.19536676f, -0.16754663f, -0.20123702f, -0.06969025f, -0.07591385f, -0.05833820f, -0.00018841f, -0.01100328f, 
    0.00146009f, 0.04232461f, -0.10085978f, -0.01303573f, 0.00884774f, 0.06651026f, -0.05927945f, 0.03222921f, 
    -0.05513230f, -0.01812228f, -0.09012682f, 0.02277654f, -0.00331184f, -0.07545613f, -0.07435215f, -0.07568302f, 
    -0.01222750f, -0.01761791f, -0.05236908f, -0.01893438f, 0.00171344f, 0.03123597f, -0.00337643f, -0.04516327f, 
    0.06585053f, -0.07146250f, 0.04960991f, 0.03125030f, 0.01493528f, 0.02080598f, -0.02341601f, 0.00460075f, 
    0.09520486f, -0.05936765f, 0.00562332f, -0.00812285f, -0.05298011f, -0.14733034f, -0.04652445f, -0.06020731f, 
    0.08162125f, 0.02085012f, -0.02958223f, -0.09832407f, 0.09500227f, -0.06625848f, 0.03362741f, -0.07150865f, 
    0.01378798f, 0.08563758f, 0.03757840f, 0.05133771f, -0.02645551f, -0.00480256f, 0.02808043f, 0.02563436f, 
    -0.00925047f, -0.07041892f, -0.14074051f, 0.06066276f, -0.03813163f, 0.02255574f, -0.02667799f, 0.03027054f, 
    0.03849086f, -0.05163021f, 0.03731155f, -0.01985117f, 0.01725878f, -0.01124440f, 0.08247349f, 0.00351814f, 
    0.03231307f, 0.20176031f, -0.12971866f, -0.06475081f, -0.03814613f, -0.10155663f, -0.12791285f, 0.12057486f, 
    -0.06893608f, -0.07884692f, 0.03329136f, -0.04041040f, -0.10222452f, 0.00671796f, -0.03860833f, -0.00556290f, 
    -0.04658667f, 0.15697969f, 0.10510743f, -0.04814041f, -0.23077834f, 0.06486532f, -0.12554178f, 0.08884946f, 
    0.21593566f, 0.06071759f, 0.13508061f, 0.05140405f, -0.01140013f, 0.03600236f, -0.00206750f, -0.00138319f, 
    0.03933934f, -0.14411445f, 0.02027573f, 0.01576931f, -0.00725122f, -0.01345345f, 0.06031376f, -0.05215022f, 
    -0.19959238f, 0.00522375f, -0.29928556f, 0.22738060f, 0.05640571f, -0.06996243f, -0.05657920f, 0.03549961f, 
    -0.04038408f, -0.05689337f, -0.03642127f, -0.02245702f, -0.11852183f, 0.01426377f, 0.04035196f, 0.06368405f, 
    -0.04111959f, 0.02659031f, -0.06555958f, -0.01771032f, 0.04523182f, 0.08351687f, 0.03990088f, 0.17165007f, 
    0.12345223f, 0.07397474f, 0.09023257f, 0.06875987f, -0.01918699f, 0.08184378f, 0.03239563f, 0.01658372f, 
    -0.03876400f, -0.06648312f, -0.08579945f, 0.05358335f, 0.05319604f, 0.06664763f, 0.04186050f, -0.00494100f, 
    0.01659658f, -0.01120393f, 0.07622778f, 0.04891695f, -0.02692156f, -0.03038715f, -0.05243440f, 0.00567282f, 
    -0.02631817f, 0.02629912f, -0.05763500f, 0.04048597f, -0.06783591f, 0.02719405f, 0.00745997f, -0.04316177f, 
    0.07468474f, -0.00205785f, -0.06085725f, -0.02323294f, 0.07024695f, -0.36905804f, -0.31306279f, 0.14963831f, 
    0.07526222f, 0.01263286f, 0.06253611f, 0.06423305f, -0.00076082f, -0.00420510f, -0.04022447f, 0.02764098f, 
    -0.10490622f, -0.16667390f, -0.00828094f, 0.01690957f, -0.08588642f, 0.06256286f, 0.01233582f, -0.02430257f, 
    0.03865175f, 0.01417598f, 0.03508608f, 0.15917756f, 0.05267067f, 0.06456047f, 0.09983230f, 0.01104036f, 
    0.01926073f, 0.04586516f, 0.04427210f, 0.06066261f, -0.10796552f, -0.02717103f, -0.03375423f, -0.00772613f, 
    0.07943747f, 0.03786726f, 0.08238889f, -0.00714852f, 0.17600761f, 0.09161306f, 0.02654167f, 0.08105239f, 
    0.04416775f, -0.00607082f, 0.07284703f, 0.00489611f, 0.04743306f, 0.00038441f, 0.03406383f, 0.05410505f, 
    -0.02672523f, -0.00366309f, -0.02924746f, 0.01775191f, -0.09175704f, 0.07778665f, 0.02017452f, 0.07965207f, 
    -0.06476202f, -0.28437874f, -0.20690760f, 0.11374281f, 0.02982208f, 0.04724813f, 0.01887617f, 0.07192212f, 
    -0.04117529f, -0.05358763f, 0.00436039f, 0.05456343f, -0.00393164f, -0.11501341f, 0.00899423f, 0.03308673f, 
    0.00109052f, 0.02076985f, -0.05591474f, -0.06084586f, -0.28135338f, -0.36159220f, -0.10657296f, -0.11777195f, 
    -0.12893891f, -0.10725891f, -0.07262670f, -0.04410497f, 0.01130213f, -0.02943086f, -0.03970506f, -0.00009426f, 
    0.00872799f, 0.02442274f, 0.03181064f, 0.03037462f, -0.03905492f, -0.00939315f, 0.00994676f, 0.02141980f, 
    -0.34093800f, -0.26008442f, -0.30600569f, -0.06540006f, 0.02858918f, -0.13190790f, 0.00595213f, -0.01402724f, 
    0.04596499f, 0.01642979f, -0.01144618f, -0.01245707f, 0.00080685f, -0.01916735f, 0.00696952f, -0.00484745f, 
    -0.01428564f, 0.03466710f, -0.00804179f, 0.00136036f, 0.06733290f, -0.14368449f, 0.01487915f, -0.06945425f, 
    0.03674052f, 0.00339104f, 0.04044623f, 0.00997085f, -0.05318196f, 0.01900215f, 0.00938106f, -0.01341459f, 
    -0.04486024f, 0.07305617f, -0.03166086f, -0.00199795f, -0.01385171f, -0.02542357f, -0.04493854f, 0.01905484f, 
    0.07952252f, -0.32370934f, -0.17032409f, 0.09688013f, 0.16923720f, 0.03771024f, 0.05857143f, 0.11290031f, 
    -0.00726713f, -0.04454186f, 0.04853395f, 0.02929094f, -0.09232390f, -0.06494609f, -0.03648848f, 0.06748559f, 
    -0.01660866f, 0.05745164f, -0.00061347f, -0.02895727f, -0.34915093f, 0.13552842f, -0.11693440f, 0.04083160f, 
    0.15739457f, -0.03686994f, 0.07219363f, -0.02625499f, 0.00241754f, -0.03794983f, -0.06691312f, -0.00807940f, 
    0.07161928f, 0.01510449f, 0.01652136f, -0.05570447f, 0.00125987f, -0.08874325f, 0.08602379f, 0.01349047f, 
    -0.08582278f, -0.03808563f, 0.19906496f, 0.16954632f, -0.01785462f, -0.08754610f, -0.07760711f, 0.04570482f, 
    -0.10826887f, -0.04678755f, 0.11136098f, 0.01575348f, -0.00664081f, -0.09149307f, 0.05807012f, 0.09219954f, 
    0.02762854f, -0.00495734f, -0.06110232f, 0.02762138f, 0.25832868f, -0.00553266f, -0.10162597f, -0.02628175f, 
    -0.19083470f, -0.06547242f, -0.09238999f, 0.02402345f, -0.18999992f, -0.01101815f, -0.01749815f, 0.05380778f, 
    0.00521908f, -0.07450061f, -0.02523551f, -0.03196320f, -0.00232312f, 0.03643339f, -0.00632172f, -0.07353842f, 
    0.10080388f, 0.02960863f, -0.12523626f, 0.15046817f, -0.10729846f, -0.06895003f, 0.01135700f, 0.02483250f, 
    0.02921632f, -0.14034478f, 0.07951997f, -0.00813131f, -0.00940668f, 0.03841275f, 0.01005941f, -0.00941100f, 
    0.03910392f, 0.00540461f, 0.08899886f, 0.02851473f, 0.02794724f, 0.06377342f, 0.00765150f, -0.02405022f, 
    0.01857190f, -0.00423303f, -0.06090197f, -0.00451334f, 0.05883539f, 0.04760513f, 0.02092145f, 0.09592536f, 
    -0.00501775f, -0.03660711f, -0.03861739f, -0.04686634f, -0.01703812f, -0.03352505f, 0.04399491f, 0.02580248f, 
    -0.11210553f, -0.22762173f, 0.05180737f, 0.06700007f, 0.00002032f, -0.07935897f, -0.03177185f, -0.03179698f, 
    0.03227615f, 0.05113129f, 0.08196894f, -0.06555240f, -0.05259618f, -0.04957852f, -0.04767837f, 0.14022820f, 
    -0.06576338f, -0.00456974f, 0.03625306f, -0.02671563f, 0.10575230f, 0.12651265f, -0.00025395f, -0.18377304f, 
    -0.09268954f, -0.12165708f, 0.00177987f, -0.07530916f, -0.05447935f, -0.01773619f, 0.01875322f, -0.06213574f, 
    -0.01444910f, 0.05133839f, 0.04424959f, -0.08439961f, 0.04250376f, 0.02788168f, 0.03720419f, 0.02195347f, 
    0.24580094f, -0.15382077f, -0.09825312f, 0.04970920f, -0.21798117f, -0.10806593f, 0.01389266f, 0.05983455f, 
    -0.09724863f, -0.06116300f, -0.09526041f, 0.08194922f, 0.03271867f, -0.06141058f, -0.01743008f, -0.07809070f, 
    0.06592020f, -0.05183593f, 0.04603130f, -0.05746144f, 0.04035516f, -0.10030966f, -0.12743725f, -0.00664136f, 
    -0.25344893f, -0.02803272f, -0.03775237f, -0.01268287f, -0.00937452f, -0.03775202f, -0.01014812f, -0.00481304f, 
    -0.02595196f, -0.02011365f, -0.07854675f, 0.04030543f, 0.10470036f, 0.00230436f, -0.06724606f, 0.09025642f, 
    -0.01517493f, 0.10334791f, -0.02237272f, 0.08067381f, 0.08117599f, 0.10779306f, 0.07892388f, -0.01753066f, 
    0.13381210f, 0.06639301f, 0.13911329f, 0.06098279f, -0.00648770f, -0.03221881f, -0.05008842f, -0.01641873f, 
    -0.02807327f, -0.07699550f, -0.02507858f, 0.07732312f, -0.26511344f, -0.24295793f, 0.07810725f, -0.03534610f, 
    0.07812843f, -0.04217485f, 0.05060843f, 0.03376399f, -0.02615870f, 0.02941519f, -0.00032203f, 0.02220700f, 
    -0.04148748f, -0.06654863f, 0.01125651f, -0.01060488f, -0.09071058f, -0.03754393f, 0.03219648f, -0.04318683f, 
    -0.10914670f, -0.08527930f, 0.26332504f, -0.04282472f, -0.09350134f, 0.08279671f, 0.15558235f, -0.02530921f, 
    -0.06804424f, -0.06516447f, 0.10205917f, 0.00217394f, -0.03149727f, 0.03235176f, -0.00407165f, -0.09134537f, 
    0.09920015f, -0.05689451f, -0.06085267f, -0.05725224f, -0.08372288f, -0.10116746f, 0.00582846f, 0.12555346f, 
    -0.20837414f, -0.09346605f, 0.01755802f, 0.00916653f, 0.01308370f, -0.08840040f, 0.05838920f, -0.09942976f, 
    0.00367223f, 0.05191002f, 0.06786913f, -0.03263221f, 0.06791136f, -0.02921221f, 0.00058287f, 0.07347352f, 
    -0.26153687f, -0.12161665f, 0.14131591f, -0.01059950f, 0.04705384f, 0.01098901f, 0.02046030f, 0.01517165f, 
    -0.05486250f, 0.00136036f, 0.01207270f, -0.03360863f, 0.10418504f, 0.05842886f, 0.05641753f, 0.00884612f, 
    0.04790151f, 0.03397710f, 0.02788644f, -0.04615156f, -0.13253956f, 0.14945279f, -0.12844281f, -0.03341070f, 
    -0.10450251f, 0.02768737f, -0.10725188f, -0.04027501f, -0.02710507f, -0.06952182f, -0.00657293f, 0.01004180f, 
    -0.09847030f, -0.02080725f, -0.06053054f, -0.04828358f, -0.04802027f, -0.07872481f, -0.09520624f, 0.00924518f, 
    0.03159829f, -0.02768941f, -0.05521289f, 0.09324394f, -0.08490127f, -0.16996937f, -0.03848330f, 0.02572291f, 
    -0.04892104f, 0.00683976f, 0.00200499f, 0.02985558f, 0.03598451f, 0.01469602f, -0.04616631f, -0.02586366f, 
    0.06924076f, 0.05705224f, -0.05639738f, 0.03149007f, -0.34312966f, -0.09957162f, 0.06245243f, 0.06628695f, 
    0.08358428f, -0.04080787f, 0.02562658f, -0.09247091f, 0.03678670f, 0.05965820f, -0.03238910f, -0.04057233f, 
    -0.01945610f, 0.00114651f, 0.09831323f, -0.13160482f, -0.05910878f, -0.07802417f, -0.02224674f, -0.04464656f, 
    -0.03472652f, 0.17291814f, -0.01454031f, 0.10514854f, -0.10623098f, 0.01871863f, -0.05113146f, 0.10400948f, 
    -0.00920789f, -0.12256453f, -0.01743793f, -0.00683070f, -0.03329108f, -0.00366617f, 0.03907972f, 0.03510597f, 
    -0.10568798f, 0.04217867f, -0.02454447f, 0.02847368f, -0.40655932f, 0.17663960f, 0.06342772f, 0.07399200f, 
    -0.00421964f, 0.05823609f, -0.06967013f, 0.00445616f, -0.01462980f, -0.05635471f, -0.04853853f, -0.00210071f, 
    -0.03142294f, 0.07103879f, 0.04480428f, 0.01990532f, -0.05417117f, 0.07004334f, -0.04067929f, -0.02102809f, 
    0.26725751f, 0.35187054f, -0.24869213f, -0.01469469f, 0.08492345f, -0.00297059f, 0.01445661f, 0.18547104f, 
    0.08351041f, 0.00049828f, -0.02927663f, 0.02899869f, 0.01891591f, 0.01825153f, -0.07456537f, 0.06089997f, 
    0.05279944f, -0.20034786f, -0.04291376f, -0.03744396f, 0.29447895f, 0.07865281f, -0.03422168f, -0.06660859f, 
    0.00964444f, -0.01387630f, -0.03909252f, 0.09490834f, 0.06223790f, 0.05419356f, 0.02097858f, 0.03334947f, 
    0.10613254f, 0.04289777f, -0.07685860f, -0.01083195f, 0.00540417f, 0.03916539f, -0.03412784f, 0.08647197f, 
    -0.52969974f, 0.00880605f, 0.12465195f, 0.01596561f, 0.06886152f, 0.05087990f, 0.11493076f, 0.00841041f, 
    -0.07807420f, 0.10708080f, -0.02262318f, -0.00098510f, 0.10820737f, 0.03255334f, 0.00519373f, 0.09239068f, 
    0.05155110f, -0.03838578f, 0.01873916f, -0.07709984f, -0.03694471f, 0.01734851f, -0.04192144f, 0.04351693f, 
    0.14867431f, 0.03080043f, -0.01158083f, 0.03353045f, 0.03765026f, -0.02092697f, 0.09609811f, 0.04135623f, 
    -0.05222237f, -0.04380435f, 0.03379636f, -0.05716263f, -0.00124637f, 0.00403479f, 0.03901856f, 0.04479814f, 
    -0.01376615f, -0.11706774f, -0.04821330f, 0.01670452f, 0.09597802f, -0.00329473f, -0.05893878f, -0.03145054f, 
    0.08564551f, -0.00621526f, -0.00024011f, 0.01831854f, 0.05467632f, 0.04039203f, -0.02520930f, 0.06367449f, 
    0.00139521f, -0.05087155f, -0.01941512f, -0.05251191f, 0.19734110f, 0.02272992f, -0.24692856f, -0.01934487f, 
    0.19263273f, -0.06804246f, 0.03041858f, 0.05122424f, 0.08207916f, -0.01209044f, 0.00918436f, -0.08091100f, 
    0.02740318f, 0.08679841f, -0.01760336f, -0.04889122f, 0.05411373f, 0.00950685f, -0.04611797f, -0.01346147f, 
    0.09111115f, 0.02424942f, -0.01115695f, 0.01627991f, 0.02857646f, 0.06319284f, -0.04143605f, 0.04822131f, 
    0.07465500f, 0.01832082f, -0.06757857f, 0.09164771f, 0.03421203f, -0.02866124f, -0.08898471f, -0.02470139f, 
    0.01410964f, -0.01328804f, 0.00641230f, 0.11164408f, -0.17628951f, -0.13059631f, 0.13416840f, 0.00601700f, 
    -0.03919451f, 0.03395987f, -0.02427121f, -0.09526906f, -0.06766631f, 0.00203826f, 0.00634624f, -0.07471015f, 
    -0.03400040f, 0.01606907f, 0.00365610f, -0.04415829f, -0.06502499f, -0.02488298f, -0.07057727f, -0.01793187f, 
    -0.14922342f, -0.03972817f, -0.06764024f, -0.01995653f, -0.19141383f, 0.05354144f, -0.02023037f, 0.12421887f, 
    -0.05841851f, -0.01984206f, -0.07467490f, -0.03045134f, -0.04990869f, -0.02346608f, 0.02336286f, -0.01564667f, 
    0.11714203f, -0.00010289f, 0.05401150f, 0.06016592f, -0.34073153f, -0.01291895f, 0.04318461f, 0.04268580f, 
    0.20563011f, 0.07779864f, -0.01595595f, -0.02047329f, 0.03410728f, 0.08352947f, -0.00116655f, -0.07492744f, 
    0.02229634f, 0.03819549f, -0.03483006f, -0.05614414f, 0.07593370f, 0.07726573f, 0.05943198f, -0.15230143f, 
    -0.49879590f, -0.04685919f, -0.04580919f, 0.03071438f, 0.07431421f, -0.01316070f, -0.02486415f, 0.11250138f, 
    -0.00216091f, 0.05902755f, 0.07349272f, 0.02128772f, -0.09863940f, -0.02615152f, -0.01303920f, 0.06935311f, 
    0.04787566f, -0.13100614f, 0.09535209f, 0.06684650f, -0.07358502f, 0.12480107f, 0.16688472f, -0.08803799f, 
    -0.08295365f, 0.11753453f, 0.01267701f, 0.09720131f, -0.04417002f, -0.08893407f, -0.02284557f, 0.02627179f, 
    -0.06827971f, 0.01435041f, 0.05080642f, -0.05213796f, 0.11495488f, -0.01037028f, -0.01045291f, -0.04569840f, 
    -0.26533940f, 0.06790663f, 0.04734375f, 0.05891160f, 0.06976803f, 0.02906670f, -0.04999095f, -0.12835047f, 
    0.10800552f, 0.10519513f, 0.01647210f, 0.00008617f, 0.00082374f, 0.00757036f, 0.01939272f, -0.00648477f, 
    -0.00417076f, 0.00190169f, 0.08089738f, -0.05403683f, -0.06303787f, 0.22306722f, -0.22353677f, -0.20904310f, 
    -0.03901394f, 0.04031017f, -0.04139824f, -0.00798499f, 0.03531344f, -0.05136058f, 0.00855986f, 0.04736534f, 
    -0.05484989f, 0.03854207f, 0.01351317f, 0.07832620f, 0.00176437f, -0.07189491f, 0.01016650f, -0.06471379f, 
    0.22018968f, -0.01575830f, -0.05526154f, -0.02317086f, -0.06938252f, 0.04924614f, -0.11559729f, 0.00615494f, 
    -0.06201153f, 0.04914761f, 0.02826739f, -0.02419530f, -0.01250182f, -0.02020730f, 0.10844868f, 0.05732365f, 
    -0.03912774f, 0.03111600f, -0.01996454f, 0.02813415f, -0.20845725f, 0.07728986f, -0.14247617f, -0.04928777f, 
    0.20820245f, 0.05509599f, 0.06463581f, 0.04990333f, -0.00201238f, -0.02772620f, 0.01826646f, -0.05289411f, 
    0.09386892f, 0.00048100f, -0.09317059f, -0.00279829f, 0.02153858f, 0.03090255f, 0.07083800f, 0.02572491f, 
    -0.28715008f, 0.19817472f, 0.02846358f, 0.00410174f, -0.01473222f, -0.01695048f, -0.03798274f, 0.09021979f, 
    0.00369987f, -0.02396770f, 0.04149187f, 0.01848668f, -0.08397187f, -0.01491218f, 0.02374230f, 0.02173011f, 
    0.08907048f, -0.05669102f, -0.02406704f, 0.03734410f, 0.02695912f, -0.03744105f, 0.02247551f, 0.15216674f, 
    -0.03678887f, -0.11017946f, 0.00822817f, 0.04102578f, -0.06236621f, 0.02112409f, 0.04121370f, 0.06182872f, 
    0.00379499f, 0.01163769f, 0.04601682f, -0.01724733f, 0.08249850f, -0.02681573f, 0.03433554f, 0.13725996f, 
    -0.15632711f, 0.06087171f, 0.03024031f, -0.07378436f, -0.00807361f, 0.01806683f, 0.01962809f, -0.02668042f, 
    0.02846994f, 0.05502759f, -0.03958803f, -0.11657909f, 0.07308175f, 0.04114199f, 0.02808856f, -0.11632522f, 
    0.02722133f, 0.03585742f, -0.06201964f, 0.06177863f, 0.04753613f, -0.04735764f, -0.13787635f, -0.10666431f, 
    -0.09872676f, -0.00938848f, -0.02738499f, -0.07911545f, -0.03598945f, -0.15706643f, -0.17880793f, -0.17358761f, 
    0.06366657f, -0.07740449f, 0.00211893f, -0.02082813f, 0.01568682f, 0.18792228f, -0.12902726f, 0.02680374f, 
    -0.39190987f, 0.06344055f, 0.03951841f, 0.02039764f, 0.07776012f, 0.01084500f, 0.03066553f, 0.04965772f, 
    0.02204636f, 0.00141180f, -0.01450167f, -0.01208879f, -0.01075888f, 0.01196752f, 0.02005935f, -0.01128839f, 
    0.00768230f, 0.12172895f, 0.09158096f, 0.00210899f, -0.45265254f, 0.07249348f, -0.08119188f, -0.01621311f, 
    0.12027410f, 0.05750025f, -0.01645632f, -0.01135803f, 0.03572265f, 0.08776130f, 0.01021048f, 0.05456017f, 
    -0.02546389f, 0.04336356f, 0.02950074f, 0.03590481f, 0.02938106f, 0.02626809f, 0.02875036f, -0.04878690f, 
    0.13146265f, 0.19589823f, -0.00510543f, 0.03707712f, -0.02366639f, 0.00357383f, 0.03644338f, 0.00794883f, 
    -0.00980300f, 0.06068404f, 0.00455149f, -0.03543260f, 0.05492382f, 0.07266629f, 0.00292202f, -0.11863822f, 
    0.06227539f, 0.05333778f, -0.04991787f, 0.08274981f, -0.18596026f, 0.06944274f, -0.01012491f, -0.03480509f, 
    0.08274807f, -0.00623617f, -0.00359791f, -0.09926841f, 0.06419612f, 0.11707893f, -0.08732567f, 0.00710976f, 
    0.00376573f, 0.01419435f, -0.00731366f, -0.05828757f, -0.09261810f, -0.08005485f, 0.02855002f, -0.04965532f, 
    -0.04106389f, -0.06702805f, 0.02597558f, 0.03522112f, 0.12641427f, -0.04269795f, -0.03216720f, 0.00483038f, 
    -0.00323262f, 0.03391511f, 0.04502236f, -0.01616286f, -0.08445251f, 0.01424924f, 0.04226582f, -0.08427192f, 
    -0.02814558f, -0.15305094f, 0.03684316f, -0.06227300f, 0.21059294f, 0.26407203f, -0.28151691f, -0.49488515f, 
    -0.06367312f, -0.12761767f, -0.01783800f, -0.05225307f, 0.04516532f, -0.17917421f, 0.02293493f, -0.06072944f, 
    -0.17011046f, 0.12656248f, 0.00779832f, 0.00081600f, 0.05654487f, 0.01358386f, -0.04967033f, -0.00946458f, 
    0.00669517f, 0.18533526f, -0.00744396f, 0.12996525f, -0.13531335f, 0.08729407f, -0.03572519f, 0.02461179f, 
    0.05398839f, -0.00330562f, -0.03140076f, -0.04894312f, 0.02105833f, 0.11503802f, 0.04779169f, -0.04291754f, 
    0.02801029f, 0.01790140f, -0.08903770f, 0.01896819f, 0.07189292f, 0.04611798f, 0.05394352f, -0.07538388f, 
    0.02943675f, 0.03259717f, 0.01554962f, -0.02015819f, 0.03562164f, 0.01570668f, 0.03697902f, -0.01330181f, 
    0.05058515f, 0.04133555f, -0.04685085f, 0.04600645f, 0.05740766f, -0.03812168f, -0.00682817f, 0.00625811f, 
    0.23535018f, 0.05042540f, 0.02972943f, -0.04719056f, -0.08785819f, 0.01982850f, -0.01219608f, 0.00254564f, 
    0.09603953f, 0.00267657f, 0.02181152f, -0.04450596f, 0.01447728f, 0.02444318f, 0.08644322f, -0.05308663f, 
    0.04559767f, -0.05110883f, -0.00575642f, -0.05463602f, -0.14551961f, -0.08784909f, -0.13409810f, 0.08226833f, 
    0.18305914f, 0.05401130f, -0.02348571f, 0.03711550f, 0.05423989f, 0.00933423f, 0.01746026f, -0.03896170f, 
    0.01882498f, 0.01975884f, 0.02180827f, -0.00263689f, 0.00830311f, 0.04038623f, 0.00507644f, 0.00071416f, 
    -0.26173931f, -0.04862287f, -0.01505020f, 0.12868099f, 0.20136711f, 0.03758606f, 0.01086347f, -0.04105571f, 
    0.16619849f, 0.07296032f, 0.04138880f, -0.02984923f, 0.01789863f, 0.03723501f, 0.00628443f, -0.03236163f, 
    0.03293013f, -0.04888592f, 0.16371286f, 0.12320410f, -0.46428984f, 0.06246095f, 0.07120800f, 0.09700603f, 
    0.10085031f, -0.01308943f, 0.02327482f, -0.02753505f, 0.07807641f, 0.08984667f, -0.03939585f, -0.02893476f, 
    0.01151838f, 0.04946123f, 0.00448398f, -0.04248581f, 0.09422556f, 0.06047081f, 0.07040882f, -0.05396649f, 
    0.07653964f, -0.08112077f, -0.11662640f, -0.09352518f, 0.06226290f, -0.02665506f, 0.03531130f, 0.00298629f, 
    0.00842900f, 0.03466913f, 0.00383073f, 0.03085002f, 0.14971709f, -0.01752025f, -0.05817064f, -0.02209514f, 
    -0.03693032f, -0.11579181f, 0.09245628f, 0.10529562f, -0.22117130f, -0.28921714f, 0.12217928f, 0.14544562f, 
    -0.01750081f, -0.10050876f, -0.02660581f, 0.07006988f, -0.10960379f, -0.02901933f, 0.04120308f, 0.04292617f, 
    -0.00202495f, -0.09152365f, 0.07112362f, 0.04399741f, -0.07006857f, -0.02173327f, 0.04370124f, 0.02296016f, 
    -0.15260656f, -0.14771023f, -0.19853060f, -0.09744545f, 0.02653021f, 0.09812123f, 0.00366530f, 0.06590668f, 
    -0.02756658f, -0.06020282f, 0.10566441f, -0.00074651f, -0.02661816f, -0.04167171f, -0.13271362f, 0.02300446f, 
    -0.12262038f, -0.09854481f, -0.03042074f, -0.02896994f, -0.02954270f, -0.11426152f, 0.06186122f, 0.20040469f, 
    -0.02462155f, -0.02864764f, -0.00024303f, 0.00743300f, -0.04068496f, -0.02379318f, 0.07989427f, 0.07221477f, 
    -0.07621968f, -0.04753765f, 0.05948502f, -0.02908703f, 0.03757916f, 0.09002111f, 0.05287177f, 0.03964609f, 
    -0.29974845f, 0.21849570f, -0.02128368f, -0.09077155f, -0.04384783f, 0.00705803f, 0.05738785f, 0.05444594f, 
    0.13922258f, -0.02344220f, -0.01413049f, -0.00774899f, 0.04238088f, -0.03627931f, -0.03603677f, -0.07844865f, 
    -0.04304275f, 0.04045654f, -0.00034747f, -0.15483780f, -0.24727759f, -0.29226416f, 0.07293808f, 0.13760276f, 
    -0.00032866f, -0.17132993f, 0.02351632f, -0.12240648f, -0.11749804f, 0.03059375f, 0.11147886f, 0.03020849f, 
    -0.01097558f, -0.04639843f, 0.00587678f, -0.15504104f, -0.11883146f, 0.02352718f, 0.01897758f, -0.01352675f, 
    -0.00602197f, 0.03623540f, 0.14992826f, 0.08103257f, -0.07276418f, 0.08820109f, -0.02180284f, -0.05814670f, 
    -0.01710965f, -0.03007969f, 0.01426086f, -0.01424511f, -0.06819864f, 0.00667880f, -0.06333402f, 0.01753212f, 
    0.01798695f, 0.07617522f, 0.06892337f, 0.01649864f, 0.00652374f, -0.10411391f, 0.05609766f, 0.01740624f, 
    -0.14601411f, -0.01790667f, 0.05208290f, -0.02953899f, -0.00620788f, -0.02495475f, 0.04514422f, 0.08124260f, 
    -0.01000368f, 0.01937374f, 0.09518923f, -0.03127802f, 0.00283303f, -0.02978450f, 0.05076540f, 0.04998858f, 
    0.09887413f, -0.07350617f, -0.09671175f, -0.11586538f, 0.08478402f, 0.04369050f, -0.03575382f, -0.16856939f, 
    0.01525928f, -0.02066399f, -0.03065656f, -0.04216539f, -0.02156452f, -0.01649028f, -0.04589803f, 0.02056097f, 
    -0.04284756f, -0.13363822f, -0.02983223f, -0.09124652f, 0.13451740f, -0.06269233f, -0.03696631f, -0.00408861f, 
    0.00530015f, 0.00300052f, 0.03099079f, -0.04862648f, 0.09005193f, 0.02716750f, 0.02977205f, -0.05805357f, 
    0.01966568f, -0.00604235f, 0.01551513f, 0.07140019f, -0.03187164f, -0.08156303f, 0.02972326f, -0.00381437f, 
    0.00087059f, 0.11480857f, 0.18018422f, -0.13472077f, -0.07440961f, 0.06980237f, 0.11090647f, -0.02168347f, 
    -0.00286588f, 0.12624227f, 0.07283442f, -0.11763933f, 0.03172627f, -0.06211412f, 0.02939863f, 0.04419867f, 
    0.00183559f, -0.06682204f, 0.01727212f, 0.02087654f, 0.14195342f, -0.09976814f, -0.06790762f, 0.07292550f, 
    -0.19768687f, -0.10698881f, -0.00132953f, 0.07648481f, 0.01372754f, -0.01814257f, -0.00473488f, -0.03301315f, 
    0.01275840f, 0.01780139f, -0.03770876f, -0.12447424f, 0.03175614f, -0.01741993f, 0.02281063f, 0.00684969f, 
    -0.19414888f, -0.27852476f, 0.09890078f, 0.17399442f, 0.02995078f, -0.11540008f, 0.04596574f, 0.01172271f, 
    -0.02322331f, -0.02767305f, 0.05874353f, 0.08521140f, -0.01404389f, -0.07230344f, -0.04572315f, -0.11421748f, 
    0.00045830f, -0.04093127f, 0.04552219f, 0.05804883f, -0.13950825f, 0.09271845f, 0.18224679f, 0.06525751f, 
    -0.00623053f, -0.06080447f, -0.09516726f, 0.12492137f, -0.05421659f, 0.01016121f, 0.04707028f, -0.02168201f, 
    -0.04242320f, -0.06290346f, 0.04845675f, 0.02223418f, 0.00859006f, -0.01770872f, -0.05096278f, -0.01459650f, 
    0.00006789f, -0.13237558f, -0.03627286f, 0.09889907f, 0.10306302f, -0.05240088f, -0.02424277f, -0.01987119f, 
    0.03186568f, -0.05943082f, -0.09392084f, -0.06880182f, 0.07581692f, 0.09998763f, 0.16005528f, -0.11663146f, 
    -0.10553685f, -0.01553455f, 0.04999230f, -0.03374645f, -0.06370141f, 0.06073659f, 0.02816213f, -0.01076265f, 
    0.02706417f, -0.00712461f, -0.01029755f, -0.03885806f, -0.03548355f, 0.05454336f, -0.04799404f, -0.06175587f, 
    -0.04722867f, -0.04613964f, -0.02233344f, 0.01265280f, -0.03180782f, -0.02522532f, -0.01280909f, 0.05366751f, 
    -0.02891547f, -0.12086073f, 0.04836638f, 0.04109420f, 0.06697224f, -0.03808840f, -0.09999962f, 0.04186736f, 
    0.03589041f, 0.08816814f, 0.05450729f, -0.08050828f, 0.06236538f, 0.05940296f, -0.03198462f, -0.07057582f, 
    0.01483533f, -0.15484975f, -0.02582289f, 0.01507731f, 0.13348815f, -0.00213946f, 0.08660847f, -0.03434313f, 
    0.07751974f, 0.04065848f, -0.01228066f, -0.03365815f, -0.10856751f, 0.01528819f, -0.00200385f, 0.01023171f, 
    0.04301114f, 0.04299558f, 0.03550605f, 0.06726466f, -0.05389495f, 0.02652597f, 0.08087883f, 0.00222231f, 
    -0.00923639f, 0.11425415f, -0.08624084f, 0.06441711f, -0.07734458f, -0.04061311f, 0.04333252f, -0.07815936f, 
    -0.03378716f, 0.00436815f, -0.07514412f, -0.06099328f, 0.02413982f, 0.02596699f, 0.02807920f, 0.04019771f, 
    -0.01289565f, 0.07273749f, 0.02068102f, 0.06352708f, 0.02587987f, -0.01447970f, 0.01404390f, 0.09499363f, 
    -0.00355673f, -0.03751863f, 0.06415959f, -0.02910374f, 0.03149153f, -0.04570857f, 0.05806241f, 0.00666292f, 
    0.03518305f, 0.05023060f, 0.14010246f, -0.12244645f, 0.01902068f, 0.01127245f, -0.03092474f, -0.08227090f, 
    0.00940690f, 0.09900384f, 0.02183989f, -0.03487273f, 0.02096530f, 0.00199089f, -0.03170498f, 0.01853868f, 
    -0.02506570f, 0.03905156f, -0.01035506f, -0.08444607f, -0.07153718f, -0.03343636f, -0.10425375f, 0.08868038f, 
    -0.06366956f, -0.01507167f, 0.04535168f, 0.11683048f, -0.04743778f, 0.12424303f, 0.02064164f, 0.01018043f, 
    0.05093782f, 0.01842559f, -0.13019474f, -0.08447720f, -0.07202377f, 0.09367821f, -0.08846768f, 0.01570602f, 
    -0.03593000f, -0.03703826f, 0.04805614f, 0.04649659f, -0.01880310f, -0.08287951f, 0.10411568f, -0.01827148f, 
    -0.45663229f, -0.26683149f, -0.08602465f, -0.08428518f, 0.04210511f, -0.01789837f, 0.12714568f, 0.00563967f, 
    -0.04969037f, 0.11264238f, -0.05628639f, 0.13027485f, 0.07842689f, 0.11425719f, 0.06434999f, 0.00663571f, 
    0.04362848f, -0.04268979f, -0.04005945f, -0.06776179f, 0.07190555f, 0.04759008f, 0.00669720f, -0.04422043f, 
    -0.01196532f, -0.11736304f, -0.09160925f, 0.03809004f, -0.00459845f, 0.08118305f, -0.00115618f, -0.08748583f, 
    0.00895245f, -0.04473284f, 0.04819303f, -0.00732060f, 0.02751274f, -0.00096129f, -0.05115764f, 0.05979887f, 
    -0.00236780f, 0.00584068f, 0.12909706f, 0.06508560f, -0.06583989f, -0.07165712f, -0.16186315f, 0.01936920f, 
    -0.04956552f, 0.05699254f, 0.02076429f, -0.00979230f, 0.05046792f, 0.03146632f, -0.06225156f, -0.05686257f, 
    0.04147579f, -0.16584390f, -0.02650596f, 0.10993300f, 0.03450516f, -0.03550341f, 0.02257043f, 0.04685667f, 
    -0.00957545f, -0.06526422f, -0.08827639f, 0.05871945f, 0.07292468f, 0.07323036f, 0.00523181f, 0.02363342f, 
    0.03377599f, 0.06467512f, -0.05232736f, -0.03868752f, -0.00115157f, -0.09010699f, 0.05763765f, -0.05309423f, 
    -0.08251229f, 0.11843646f, -0.08492113f, -0.01420850f, -0.01999785f, 0.06409322f, -0.02082472f, 0.06207971f, 
    -0.08901005f, -0.06514958f, 0.05383428f, 0.03161078f, -0.10751811f, -0.05204154f, -0.04587485f, 0.06330130f, 
    0.02725174f, 0.02721168f, 0.07236035f, 0.00217587f, -0.16062640f, -0.19219083f, -0.15419821f, 0.03867381f, 
    0.03864900f, 0.01392090f, -0.04809231f, -0.04449790f, 0.05725355f, -0.01577126f, 0.16487686f, 0.08971995f, 
    0.02315150f, 0.01320818f, -0.01326886f, 0.05193595f, -0.11370619f, 0.01180161f, -0.05686823f, -0.09425345f, 
    0.03017518f, -0.00124904f, -0.02293165f, -0.00611517f, 0.00947346f, -0.05387532f, -0.08226845f, 0.00275684f, 
    -0.00216531f, 0.05099338f, 0.00596463f, -0.09699546f, 0.01780460f, -0.05796069f, 0.00422808f, 0.03579732f, 
    -0.06227518f, -0.02753929f, -0.05477486f, -0.01299318f, 0.11756511f, -0.02252731f, 0.01340451f, 0.10357483f, 
    0.00028801f, -0.02672684f, 0.01751217f, 0.06727168f, 0.06315427f, 0.04255210f, -0.04552514f, -0.07931096f, 
    -0.01646188f, 0.04739302f, 0.05361532f, 0.05223049f, 0.11212019f, -0.02464810f, 0.01622155f, -0.01477497f, 
    -0.21973573f, 0.04378939f, 0.00589538f, -0.08286522f, 0.07346272f, 0.05824472f, -0.03887706f, -0.01177922f, 
    -0.01033688f, 0.07711279f, 0.05934265f, -0.00075464f, 0.10203840f, 0.04142867f, 0.01488860f, -0.08889349f, 
    0.05248471f, -0.12297875f, 0.05015744f, -0.09663263f, -0.01233496f, 0.19368128f, -0.08649247f, -0.06222707f, 
    0.01236898f, -0.05691723f, 0.01492076f, -0.03249655f, 0.01835759f, -0.12709653f, 0.05924824f, 0.01737834f, 
    -0.02269881f, -0.08142649f, 0.06313653f, -0.06368178f, 0.01493321f, 0.04840718f, 0.09679134f, 0.00501119f, 
    -0.39119619f, -0.13204716f, 0.14220390f, 0.02772068f, -0.29588118f, 0.10788373f, -0.06539179f, -0.05180963f, 
    -0.03780392f, -0.00948429f, 0.02349820f, -0.00495196f, -0.02587066f, 0.05963990f, -0.07832514f, -0.06307977f, 
    0.08775122f, 0.22718112f, 0.04394665f, 0.02482539f, -0.09112434f, -0.07124495f, 0.17681217f, 0.09816359f, 
    -0.17328183f, 0.01810697f, -0.02642003f, -0.05527620f, 0.03604548f, -0.10406528f, -0.03350560f, -0.01245565f, 
    -0.04694293f, -0.09876027f, 0.05835244f, -0.05632631f, 0.05667150f, 0.10342585f, 0.10748914f, -0.06610925f, 
    -0.09665727f, 0.15809777f, -0.00589494f, -0.02472348f, -0.12534188f, -0.00595903f, -0.02850332f, 0.00613128f, 
    0.01642931f, -0.11163379f, 0.05551809f, 0.05627346f, -0.10768772f, -0.09833530f, -0.01306150f, 0.00238683f, 
    -0.00988674f, 0.05079225f, 0.11106792f, -0.01825644f, -0.01027761f, -0.11545693f, -0.10224875f, -0.00091781f, 
    0.12677267f, 0.09544406f, -0.00249571f, -0.01206118f, 0.01468117f, 0.01347224f, 0.02733484f, 0.05107611f, 
    0.03273634f, 0.12060862f, 0.02083514f, -0.01410404f, -0.03169676f, 0.09000488f, -0.20573446f, 0.06781998f, 
    0.08380277f, 0.13179128f, 0.17987838f, 0.01335900f, 0.03707224f, 0.04973295f, 0.02526399f, -0.01485891f, 
    -0.06430453f, 0.02905849f, -0.04023244f, -0.02367966f, -0.03466166f, 0.06222015f, -0.08287866f, 0.02972628f, 
    -0.07287046f, 0.04309997f, 0.00462951f, 0.06890044f, -0.01254532f, 0.23304644f, 0.06252039f, -0.02991924f, 
    -0.21240874f, 0.07410993f, -0.00952203f, 0.02380010f, -0.16812007f, 0.04860673f, 0.03449781f, -0.14826228f, 
    -0.10864949f, -0.08046637f, -0.15920581f, 0.04273389f, -0.00933188f, 0.02482731f, 0.05870030f, -0.03455310f, 
    -0.03539222f, -0.02751536f, 0.13937309f, 0.04981744f, -0.12240211f, 0.04294622f, -0.10350745f, -0.00423140f, 
    -0.02420939f, 0.06315191f, -0.03418217f, -0.00018076f, -0.00190783f, -0.16634484f, -0.00705590f, 0.04344333f, 
    -0.00168952f, 0.01181509f, 0.08726302f, -0.00858457f, -0.01625857f, -0.00785560f, 0.01201377f, 0.18277258f, 
    0.15883934f, -0.03337212f, -0.00225339f, 0.12185530f, 0.12805095f, 0.09354474f, 0.05100781f, -0.07480096f, 
    0.04993467f, 0.07010169f, 0.08927317f, 0.01049514f, 0.14423612f, -0.10337038f, -0.05561589f, -0.09677532f, 
    -0.05153712f, 0.09996087f, 0.11312030f, -0.10516191f, -0.06982537f, -0.19500454f, 0.05760428f, 0.06382401f, 
    -0.07693458f, 0.04408395f, 0.08574598f, 0.02000597f, 0.03218719f, -0.08541390f, -0.10838852f, -0.03558460f, 
    -0.10005487f, -0.06049103f, 0.07266208f, 0.03656332f, -0.29393199f, -0.02855070f, -0.27974966f, -0.21616641f, 
    -0.03572991f, 0.12581825f, 0.01176187f, 0.08217636f, -0.03644729f, -0.11558006f, 0.09399366f, 0.05750050f, 
    -0.09891969f, -0.00907789f, -0.06077163f, -0.00035180f, -0.06872178f, -0.04007397f, -0.01814187f, 0.02690393f, 
    -0.06219462f, -0.04708862f, 0.05607648f, 0.12053213f, -0.31854358f, -0.05134363f, 0.02265994f, -0.04442897f, 
    0.01959751f, 0.05537209f, -0.02580264f, 0.03595082f, 0.05707572f, -0.01341159f, 0.08693961f, -0.01694375f, 
    -0.05512577f, 0.04589234f, 0.03808391f, 0.10412873f, -0.25474569f, -0.14135437f, 0.07604149f, 0.10612370f, 
    -0.18295334f, -0.02172372f, 0.01318279f, 0.00493590f, -0.03612750f, -0.00019380f, -0.02281898f, 0.00624598f, 
    0.06125580f, -0.02333262f, -0.03613112f, -0.01861551f, -0.03699303f, -0.08351058f, 0.03906315f, 0.02766203f, 
    -0.32099012f, -0.05212474f, -0.29119736f, -0.07449300f, -0.07189488f, 0.12540869f, 0.14527446f, -0.05301433f, 
    -0.00241525f, -0.05243400f, -0.05560964f, 0.09378870f, 0.08550723f, 0.00976986f, -0.01228175f, -0.09011775f, 
    0.03841344f, -0.03040705f, -0.01083390f, -0.02129328f, -0.18194906f, -0.09645130f, 0.12717500f, 0.08658160f, 
    -0.11916496f, 0.06596895f, 0.01001053f, -0.02750166f, 0.03853188f, 0.00040826f, -0.00799022f, 0.02300078f, 
    0.04866324f, 0.01733939f, -0.00559285f, -0.02901636f, 0.04644033f, 0.01831949f, 0.06821334f, -0.05484307f, 
    0.00521370f, -0.05178626f, 0.04494968f, -0.13697357f, 0.03918286f, 0.03571773f, 0.09614600f, -0.05037985f, 
    -0.03745808f, 0.07256287f, -0.00587606f, -0.00250786f, 0.08582228f, -0.03369726f, -0.01688425f, -0.11128733f, 
    0.00264017f, 0.13281316f, -0.01405848f, 0.00321001f, -0.45462310f, -0.12334852f, -0.06369738f, -0.18693769f, 
    -0.15672697f, 0.03779244f, 0.08844446f, 0.11307355f, -0.06467602f, -0.07386175f, 0.07761739f, -0.09418483f, 
    -0.04314255f, -0.09444211f, -0.01635557f, 0.05261790f, 0.00524116f, -0.00723574f, -0.03874418f, 0.00485972f, 
    -0.10580643f, -0.15835606f, 0.02731298f, 0.10005736f, -0.22739910f, 0.03275130f, -0.00692162f, -0.07545151f, 
    0.02159270f, -0.05523224f, 0.05131147f, 0.02590140f, -0.04783875f, -0.00807308f, 0.00567117f, -0.03188608f, 
    -0.04837001f, 0.05229754f, 0.00777440f, -0.03500537f, 0.05991003f, -0.02617097f, 0.06108764f, 0.12307630f, 
    0.00437522f, -0.05855608f, -0.02978002f, -0.03386570f, 0.06560335f, 0.02734428f, -0.06998066f, 0.02129295f, 
    0.01075005f, 0.20485730f, 0.11994098f, -0.07692373f, -0.00755609f, -0.15027487f, -0.09440856f, -0.02275687f, 
    -0.05053380f, 0.02191317f, 0.01833955f, 0.06662644f, -0.08352102f, -0.04866543f, -0.06972150f, 0.01505115f, 
    -0.02970832f, 0.13511389f, -0.01660988f, -0.01415296f, -0.07129493f, -0.04312588f, -0.00824543f, 0.02468730f, 
    -0.02932281f, -0.08762718f, 0.09795643f, 0.01904227f, -0.20141317f, 0.04610864f, 0.08648950f, 0.12376982f, 
    -0.11986542f, -0.07468627f, 0.03881864f, 0.05688318f, -0.00206273f, 0.15996206f, -0.09772298f, -0.04541164f, 
    -0.11558402f, 0.06456741f, -0.14506975f, 0.04977328f, 0.04402071f, -0.26468834f, -0.06327732f, 0.01103802f, 
    -0.32136139f, 0.00740171f, -0.20513450f, -0.16456577f, 0.04792634f, 0.08294070f, 0.07125164f, 0.02321886f, 
    -0.02421759f, -0.08000785f, 0.05259120f, 0.01354422f, 0.11987244f, -0.04152457f, 0.07941303f, -0.01474245f, 
    0.08309890f, -0.13843197f, -0.03765412f, 0.01440522f, -0.41650251f, 0.07937409f, -0.14156078f, -0.06391019f, 
    -0.12073625f, 0.01219666f, 0.01475300f, -0.00056222f, -0.00301930f, -0.16781901f, -0.01697881f, -0.01117292f, 
    0.07149524f, -0.09745403f, -0.04532057f, 0.05619365f, -0.01875245f, 0.02990549f, 0.05666578f, 0.05614179f, 
    -0.01723161f, -0.11784902f, 0.07844734f, 0.09443751f, -0.21402161f, 0.01653184f, -0.03996780f, 0.01709487f, 
    0.02790198f, -0.04214682f, -0.08259656f, 0.05581759f, 0.00910416f, -0.01240928f, 0.07867312f, -0.07783856f, 
    -0.15439394f, 0.02777155f, 0.03294629f, -0.05296813f, -0.20108405f, -0.04587135f, -0.09390051f, 0.05643362f, 
    -0.08356739f, 0.00432042f, -0.00187428f, 0.07719413f, -0.03203197f, -0.03740511f, -0.01685872f, 0.01492163f, 
    -0.00029308f, 0.01351106f, -0.04699076f, 0.05882284f, -0.00234603f, -0.00980411f, 0.03446338f, 0.06434059f, 
    0.02353180f, -0.04052894f, -0.03451967f, -0.03564161f, 0.03778560f, 0.03638867f, 0.05668637f, 0.03242875f, 
    -0.03083975f, 0.04022048f, 0.00289034f, -0.05120407f, 0.07009915f, 0.02717415f, -0.10609141f, 0.10284656f, 
    -0.04425690f, 0.09637044f, -0.12415250f, 0.09348229f, -0.25510192f, 0.22533605f, 0.06122668f, 0.12727554f, 
    -0.09178184f, 0.06515378f, 0.00009068f, -0.03545520f, -0.08941274f, 0.00679083f, -0.01391954f, 0.07629141f, 
    0.07196891f, -0.13766232f, 0.00599836f, -0.01069971f, 0.03735116f, -0.07944321f, 0.09654627f, -0.16009514f, 
    0.08340004f, 0.10234432f, -0.01075773f, -0.10541453f, 0.06702709f, -0.00351045f, -0.04792019f, 0.06253704f, 
    -0.01008776f, -0.04893845f, 0.09846853f, 0.01381730f, 0.02804290f, -0.03125965f, 0.04016865f, -0.01449843f, 
    0.00075851f, -0.05731183f, 0.04042226f, 0.00310200f, 0.12526990f, 0.04965240f, 0.08356306f, 0.02821401f, 
    0.02825608f, 0.02655817f, -0.00346040f, 0.04064312f, -0.04119801f, 0.00850073f, 0.03900339f, 0.03969548f, 
    0.00115878f, 0.03509097f, -0.00170355f, 0.02087289f, -0.04633475f, 0.11668579f, 0.02678505f, -0.00718405f, 
    0.13174334f, 0.04650941f, 0.01788544f, 0.03214366f, 0.19763657f, -0.07683221f, -0.04073739f, 0.00035524f, 
    -0.08268001f, 0.03087677f, 0.03709276f, 0.06413771f, 0.05456125f, -0.01627887f, 0.04643718f, 0.05936962f, 
    -0.06405730f, 0.03938728f, 0.03158922f, 0.03729356f, -0.05388268f, 0.12865955f, -0.04549319f, -0.05236895f, 
    -0.14086920f, 0.05590296f, 0.02827012f, 0.05202618f, -0.06677141f, -0.06595855f, 0.02540857f, 0.06531247f, 
    -0.02249928f, -0.07375949f, -0.03421948f, 0.04570450f, -0.00273683f, -0.01687015f, -0.03276384f, -0.07651190f, 
    -0.20990053f, 0.21689221f, -0.24890259f, -0.02839295f, 0.00603844f, 0.18320762f, 0.10933635f, 0.08593562f, 
    -0.14590670f, 0.09416739f, -0.03081341f, 0.19045192f, -0.02504426f, -0.06700821f, 0.04761033f, -0.00387944f, 
    -0.01779161f, 0.05612571f, -0.01801232f, -0.12624118f, -0.25776163f, 0.06518592f, -0.28826824f, -0.16091579f, 
    -0.00236122f, 0.13771854f, 0.06673602f, 0.00886986f, -0.05632748f, -0.04108449f, -0.03929720f, -0.01487506f, 
    -0.05504349f, -0.02078655f, 0.00710097f, 0.02528642f, -0.03291334f, -0.02016729f, 0.01722944f, -0.01564118f, 
    -0.57675958f, 0.01943041f, 0.02402901f, 0.07622735f, 0.06154801f, 0.01491675f, 0.03104971f, 0.05787071f, 
    0.01152700f, 0.07013050f, 0.04656128f, 0.05536471f, 0.01972879f, 0.06822333f, -0.06298945f, -0.01624100f, 
    -0.03613712f, 0.05358153f, -0.16085723f, 0.02101841f, 0.05663081f, 0.04324190f, -0.00470467f, 0.03612693f, 
    0.09959577f, -0.10043814f, 0.01264889f, -0.01243622f, 0.07519852f, 0.04367883f, -0.12850076f, -0.13731173f, 
    0.09075942f, 0.03126244f, 0.13103314f, 0.00536945f, 0.05500649f, 0.00051217f, -0.01074572f, 0.00826183f, 
    -0.19078223f, -0.03819715f, 0.07314107f, 0.09533347f, -0.06685249f, 0.03712032f, -0.06521569f, 0.01197602f, 
    -0.03951301f, 0.03182952f, 0.02824312f, 0.01180001f, 0.01233625f, -0.07382189f, 0.05316335f, -0.04797769f, 
    0.02660417f, 0.10534323f, -0.04223469f, -0.14591971f, 0.00858444f, 0.05010106f, 0.00979548f, -0.07224710f, 
    0.17353298f, -0.02681412f, -0.15314817f, -0.08931687f, 0.05593655f, 0.03097802f, -0.00293578f, -0.06573296f, 
    0.09359707f, 0.11138554f, 0.06114822f, 0.03471015f, -0.04561946f, -0.10150503f, -0.11600878f, -0.07096058f, 
    -0.41201451f, -0.29287151f, 0.02311428f, -0.05880383f, 0.08028710f, 0.10284606f, -0.12579995f, -0.11902455f, 
    -0.02212682f, -0.09228440f, -0.00141827f, 0.00799287f, -0.04617723f, -0.01614460f, 0.01566490f, -0.01585800f, 
    0.05278505f, -0.02408071f, -0.10546684f, -0.00542576f, 0.11954354f, 0.05636356f, -0.07877716f, 0.11143245f, 
    0.00370123f, -0.04475147f, 0.02019502f, -0.01035880f, 0.04971652f, -0.02555158f, 0.00523895f, -0.10308292f, 
    -0.02772209f, 0.06654936f, 0.06966908f, 0.00769971f, 0.09302730f, 0.05974964f, -0.01587809f, 0.04493545f, 
    0.02465054f, 0.07601994f, -0.08288512f, 0.15819904f, 0.21305509f, -0.01246391f, -0.05282523f, -0.06334593f, 
    0.11268964f, 0.10590829f, -0.00424525f, 0.12413169f, 0.08070877f, 0.06282707f, 0.08945262f, 0.10199021f, 
    0.07424269f, -0.01985905f, -0.10337499f, -0.05754029f, 0.04725932f, 0.01375663f, 0.12468482f, 0.21848881f, 
    -0.07275722f, -0.06532487f, 0.04807777f, 0.06987964f, -0.07195155f, 0.06669083f, 0.01969651f, -0.11508982f, 
    -0.04481439f, 0.08631407f, -0.07986815f, 0.01552021f, 0.06971379f, -0.15228063f, -0.02419270f, -0.02774383f, 
    -0.05652559f, -0.07688249f, 0.10303726f, 0.24692197f, -0.08120562f, 0.00933942f, 0.08777531f, 0.02138836f, 
    0.06803411f, -0.01089180f, 0.02826876f, -0.02849454f, -0.13466813f, -0.00240164f, 0.02426497f, -0.01575695f, 
    0.05450803f, 0.08379667f, -0.03939220f, -0.01699072f, 0.11352706f, 0.13462752f, 0.12346426f, 0.04883030f, 
    -0.04549989f, 0.03338563f, -0.03210203f, 0.01941580f, -0.04876030f, 0.08589689f, -0.02653743f, 0.01392503f, 
    -0.01208578f, -0.03791485f, -0.02767649f, 0.09137955f, -0.00070951f, 0.03863368f, 0.10719109f, 0.03710398f, 
    -0.01264521f, 0.02820092f, 0.02733857f, 0.16197671f, 0.09867214f, -0.00499059f, 0.07639152f, -0.02482472f, 
    -0.07767539f, 0.02844945f, -0.07018124f, 0.07662901f, 0.04395619f, -0.04142521f, -0.00851107f, 0.05365713f, 
    0.05478761f, -0.04489961f, 0.04512601f, -0.04324977f, -0.03382312f, 0.03784214f, -0.03683745f, 0.09107558f, 
    0.29807886f, -0.00831649f, -0.13381121f, 0.12108907f, -0.09534875f, 0.05458311f, 0.06659324f, -0.06293803f, 
    -0.01454460f, 0.02383392f, 0.01248437f, 0.05144763f, 0.08640493f, -0.15781765f, 0.09101295f, 0.05432400f, 
    0.10361858f, 0.08005396f, 0.00755223f, 0.05720397f, 0.08546212f, -0.10731097f, -0.08753937f, 0.03727460f, 
    -0.00050503f, 0.03832018f, -0.06564244f, -0.08410649f, 0.03674818f, 0.13343647f, 0.03598509f, -0.00922983f, 
    -0.01968960f, 0.00736063f, 0.01176339f, -0.05486614f, 0.10578642f, -0.05247964f, 0.03240540f, 0.03963047f, 
    -0.19794419f, -0.11764638f, 0.07565064f, -0.07314243f, 0.00925685f, -0.01161582f, 0.03017049f, 0.11667731f, 
    0.01596689f, 0.09674235f, 0.08663994f, -0.04646785f, -0.04011205f, 0.08998223f, 0.06428391f, -0.03850430f, 
    -0.22188219f, 0.20488393f, 0.10041177f, -0.02844753f, -0.45183334f, 0.13383615f, 0.15646197f, 0.10241242f, 
    0.01973509f, 0.00782534f, -0.06059335f, 0.03681996f, -0.09179950f, 0.05820679f, -0.10427754f, 0.01402052f, 
    -0.01441559f, 0.03448509f, 0.04209257f, 0.01440502f, -0.04487538f, -0.05389304f, 0.07118413f, 0.02097910f, 
    0.08411103f, 0.06895347f, -0.02671677f, 0.01624287f, 0.01316263f, 0.02143769f, 0.03942293f, -0.00502873f, 
    0.08016356f, -0.01324451f, -0.15601721f, -0.02812288f, 0.03453427f, -0.04057726f, -0.01754098f, 0.00615047f, 
    -0.02774145f, -0.00880922f, -0.07762526f, -0.10538089f, 0.03595451f, 0.00231020f, 0.08497681f, -0.06529418f, 
    -0.04240055f, 0.03074789f, -0.05253141f, -0.00333251f, -0.02291843f, -0.00478183f, -0.06939188f, 0.08041513f, 
    0.01449623f, 0.06997041f, 0.06497581f, -0.01132439f, -0.17912287f, 0.13241860f, 0.02290547f, 0.14459601f, 
    -0.20850401f, -0.06713498f, -0.06795195f, 0.03633886f, 0.02849858f, 0.07889941f, -0.03426671f, 0.00042468f, 
    0.02516499f, -0.03089086f, 0.10624804f, -0.04139441f, 0.00230099f, -0.09776769f, 0.01032410f, -0.08010883f, 
    -0.33258468f, 0.27944171f, -0.08324128f, 0.13555090f, -0.13334173f, -0.09918046f, -0.07749958f, -0.02150027f, 
    0.04417757f, -0.01337083f, 0.02308878f, 0.06298867f, 0.08586796f, -0.00674254f, -0.02271605f, -0.05289594f, 
    0.02007810f, -0.00032307f, -0.05112496f, 0.00135415f, 0.20254673f, -0.02549651f, 0.03822444f, -0.18631013f, 
    0.13299122f, 0.04438869f, -0.06680157f, 0.01200128f, 0.00490258f, 0.04080723f, -0.00300504f, 0.01537142f, 
    0.01462187f, -0.06672131f, -0.08198459f, 0.01029746f, -0.01094542f, 0.03999428f, 0.01181155f, 0.02491568f, 
    -0.07026528f, 0.04862411f, 0.03183796f, 0.01368814f, -0.01270592f, -0.08058264f, 0.06869254f, -0.07179485f, 
    0.01993327f, 0.09014107f, -0.01770257f, 0.01872194f, 0.09327951f, -0.00540156f, -0.01235952f, -0.10444678f, 
    0.00521492f, -0.06113383f, -0.07958236f, -0.04457384f, -0.07620070f, 0.03762252f, -0.22692603f, 0.29873410f, 
    -0.08792803f, 0.08475060f, 0.02639217f, -0.02457225f, 0.05546203f, 0.08935048f, 0.07549106f, 0.00618473f, 
    0.04004451f, -0.02221476f, 0.00368993f, -0.00790951f, 0.00972926f, 0.03236556f, -0.07102019f, -0.00744558f, 
    -0.05368956f, 0.03872421f, -0.02370978f, -0.25031126f, 0.12744403f, -0.08778537f, -0.03435299f, 0.01306474f, 
    -0.07919350f, -0.10528453f, 0.04458817f, -0.06124628f, -0.08908103f, -0.02638795f, 0.01832557f, -0.14904915f, 
    -0.08591826f, 0.04815792f, 0.04444110f, 0.03986067f, 0.11096650f, 0.11075756f, 0.08179139f, 0.10895786f, 
    0.02001985f, 0.06374590f, 0.03335820f, -0.03942340f, -0.01835014f, 0.01122618f, -0.05112490f, 0.02193646f, 
    0.01362130f, 0.03905756f, -0.05199505f, 0.03521135f, -0.00568777f, 0.00507544f, -0.01160903f, -0.09958672f, 
    0.07193626f, 0.01736500f, -0.10973044f, 0.07630633f, 0.25390396f, 0.05676745f, 0.08609999f, -0.03092024f, 
    0.03699159f, -0.13772780f, -0.07466772f, 0.00551540f, -0.14707629f, -0.03605178f, 0.04431632f, 0.00429512f, 
    0.02628586f, 0.08860272f, 0.14342789f, -0.06826474f, 0.04111712f, -0.08635959f, -0.11490744f, -0.04168007f, 
    -0.03000563f, 0.02468388f, 0.11675796f, -0.10072800f, -0.04499589f, -0.00665799f, 0.03285354f, -0.07207857f, 
    -0.04422674f, -0.01202736f, 0.05628886f, -0.08404177f, -0.00829235f, 0.17340519f, -0.04714074f, 0.08419748f, 
    0.12403160f, -0.19800811f, 0.01362972f, -0.02429324f, 0.07504097f, 0.06857209f, -0.04120107f, -0.00980842f, 
    0.06431868f, -0.06930156f, -0.07607920f, 0.00617670f, 0.10523295f, 0.02084073f, 0.03841947f, -0.01141769f, 
    0.00548568f, -0.02428200f, -0.11098407f, -0.00379150f, -0.01998704f, -0.14462994f, -0.03868654f, -0.16084787f, 
    0.31099737f, 0.01999249f, 0.07137163f, 0.07482277f, -0.01063155f, 0.01081791f, -0.08740597f, -0.05991233f, 
    -0.03518641f, 0.05531690f, 0.04864493f, 0.01052898f, 0.03789555f, 0.15314308f, 0.00814556f, 0.08299942f, 
    0.09547339f, -0.06944028f, 0.09517492f, -0.10783701f, 0.02485062f, 0.04299671f, 0.02239162f, -0.00642308f, 
    0.05301674f, 0.02322233f, -0.00477979f, -0.01110701f, 0.01926827f, -0.00184740f, -0.02857786f, -0.03222775f, 
    0.04475262f, 0.13074449f, 0.02990468f, 0.03113570f, 0.02526950f, 0.11490720f, -0.03330288f, 0.10244592f, 
    -0.10318618f, -0.01982851f, -0.03975517f, -0.06862926f, 0.02158320f, 0.03384876f, 0.00009778f, 0.06424030f, 
    -0.06416816f, -0.03248097f, -0.16285682f, -0.00764926f, -0.06148506f, -0.00343147f, -0.08123784f, -0.07963983f, 
    -0.02158537f, -0.20761900f, -0.08316960f, -0.10607320f, 0.13573375f, -0.08387613f, 0.05200470f, 0.00404547f, 
    0.06144515f, -0.01442983f, 0.00297804f, -0.02494336f, -0.06829938f, -0.03064425f, 0.02338743f, -0.08342794f, 
    -0.03128127f, 0.08159745f, -0.05231292f, 0.02351669f, 0.11266752f, -0.24303143f, -0.08596270f, -0.17893012f, 
    0.22723535f, 0.00265440f, 0.01567724f, -0.03873734f, 0.05702915f, 0.02560459f, -0.01781719f, 0.02384457f, 
    0.07050317f, 0.07892109f, -0.01198588f, 0.07694816f, -0.01645058f, -0.03061269f, -0.14812176f, 0.03940837f, 
    0.29748204f, -0.38702971f, -0.12013367f, 0.19345979f, -0.04357805f, -0.10929532f, -0.05252256f, -0.00209510f, 
    -0.03391698f, 0.02200830f, 0.02578143f, -0.01487168f, -0.07653790f, -0.08534706f, 0.06606130f, -0.04637358f, 
    -0.01970390f, -0.09532385f, -0.07240108f, -0.08434670f, -0.08109605f, 0.18683206f, -0.04338660f, 0.04085619f, 
    -0.10823552f, -0.02889495f, -0.05918995f, 0.02758282f, 0.03630272f, 0.05354606f, 0.06423090f, 0.00320397f, 
    0.04415160f, 0.02509795f, -0.00349323f, 0.00140369f, -0.01103079f, -0.07589599f, -0.01785484f, 0.00179360f, 
    0.22969195f, -0.39128247f, 0.05348500f, -0.00393506f, 0.12582365f, 0.05014944f, -0.00930760f, -0.04790971f, 
    -0.02310209f, -0.04213275f, -0.04443105f, 0.02998034f, 0.14040093f, 0.03706266f, 0.07759622f, -0.08341198f, 
    0.05257520f, -0.04581506f, -0.05422042f, -0.04876952f, -0.03274374f, -0.00064798f, -0.13643962f, -0.12591523f, 
    -0.04776102f, -0.00752969f, 0.04981287f, 0.03004535f, -0.04868498f, -0.03803803f, 0.04372565f, -0.01718111f, 
    -0.03606219f, -0.02199410f, -0.01645363f, -0.10918576f, -0.00337198f, 0.01285264f, 0.02761321f, 0.00694233f, 
    -0.20925429f, 0.05114992f, 0.02577373f, 0.21262491f, 0.02067738f, -0.07706931f, 0.01163707f, 0.03967547f, 
    0.04543383f, 0.05768863f, -0.08116386f, 0.01492494f, -0.01979571f, -0.06811527f, 0.15419021f, -0.03789226f, 
    0.02026795f, -0.15846035f, -0.02243224f, -0.26656210f, 0.10774416f, -0.37661314f, -0.16420805f, -0.01719517f, 
    -0.11887615f, 0.01044216f, 0.11404277f, -0.03881540f, -0.00547030f, -0.00212349f, -0.05210965f, 0.00778670f, 
    0.01092639f, 0.05602643f, 0.16316015f, 0.11323791f, -0.00903805f, -0.09916588f, -0.09964574f, -0.05544564f, 
    -0.14205468f, 0.25657809f, -0.00652591f, 0.00999540f, -0.14354628f, -0.02785502f, 0.02915387f, 0.05606334f, 
    0.01689542f, -0.00937361f, 0.06020880f, 0.04295461f, 0.03859014f, 0.01121808f, 0.04705115f, -0.04690829f, 
    -0.04255886f, -0.05261824f, 0.03385754f, -0.06309307f, 0.11361232f, 0.09380206f, -0.05197618f, -0.00650971f, 
    0.10260580f, -0.05861297f, -0.02906483f, 0.00754843f, -0.08601714f, -0.02366745f, -0.00277438f, 0.01389047f, 
    -0.04203218f, -0.06437238f, -0.07644060f, 0.04913405f, -0.19876829f, 0.05851978f, -0.04577564f, 0.03515997f, 
    -0.07482632f, -0.07594618f, -0.02616733f, 0.21531105f, 0.04773011f, -0.01739049f, 0.09443750f, -0.11038379f, 
    0.08464818f, -0.06418846f, -0.14811216f, 0.01875546f, -0.03242543f, 0.02165684f, 0.05696751f, 0.15135054f, 
    -0.03914576f, 0.12904565f, -0.06217616f, 0.02085586f, -0.13768607f, -0.19868940f, -0.02868011f, -0.22696581f, 
    0.07682742f, 0.01592383f, 0.05367021f, 0.04495423f, -0.09529641f, -0.01675190f, -0.06327379f, -0.04854720f, 
    0.08416454f, 0.05128438f, 0.06153861f, -0.00526720f, -0.02796764f, -0.02097565f, -0.04483492f, 0.05881875f, 
    0.08203594f, 0.18313159f, 0.16308913f, 0.02920281f, -0.15629795f, 0.03573715f, -0.15122992f, 0.01165411f, 
    0.00986401f, -0.02925023f, 0.03117059f, -0.01266230f, -0.02339521f, 0.00752112f, -0.04750413f, -0.04012823f, 
    -0.00597318f, -0.06864978f, -0.03131662f, -0.15444848f, 0.06752458f, -0.08786286f, 0.09965476f, 0.12817881f, 
    0.13853912f, 0.06832327f, -0.00852280f, 0.05102926f, 0.05860514f, -0.05712054f, -0.06827134f, 0.04892176f, 
    -0.07095328f, -0.00495637f, -0.07859869f, 0.01640747f, 0.01634974f, 0.13170105f, 0.08674378f, 0.03721771f, 
    -0.06794731f, -0.04301134f, -0.07965647f, -0.29437903f, 0.08792172f, -0.00220803f, 0.00679014f, 0.02715175f, 
    -0.08755568f, -0.01686146f, 0.07753703f, -0.04212735f, 0.00207517f, -0.03290265f, -0.06679884f, 0.06343386f, 
    -0.03901527f, -0.03956296f, 0.00620250f, 0.04202829f, 0.20547609f, -0.17171215f, -0.08652660f, 0.19595718f, 
    0.03344797f, -0.03262907f, -0.01096495f, 0.03521524f, -0.01543158f, 0.02644159f, 0.01156443f, -0.02334351f, 
    0.02230402f, -0.00392648f, -0.03987836f, -0.01921484f, -0.02345673f, 0.01684989f, -0.11433854f, 0.02335678f, 
    -0.16674061f, 0.00230407f, -0.09189806f, 0.17390071f, -0.00441996f, 0.12830913f, -0.06267513f, 0.05456140f, 
    0.01766860f, -0.11911535f, -0.01635361f, -0.04220214f, 0.01138189f, 0.00898041f, -0.13512312f, 0.12514460f, 
    0.02548341f, -0.12002828f, 0.02604247f, 0.06529454f, 0.15889648f, -0.31258345f, -0.04363689f, -0.03645093f, 
    -0.05170406f, -0.13428506f, 0.00417609f, -0.11813418f, -0.01493866f, 0.00702735f, 0.00193900f, 0.10440203f, 
    -0.02519535f, 0.04306641f, 0.12077014f, -0.14025566f, 0.01331862f, -0.01591991f, -0.09385151f, 0.01776773f, 
    0.09381028f, 0.03680959f, 0.08278205f, -0.11091924f, -0.10790224f, 0.14073880f, 0.01711896f, 0.07793713f, 
    0.00938863f, -0.00003554f, -0.02321119f, -0.02176554f, -0.00637805f, 0.02632135f, -0.09344300f, -0.04692811f, 
    -0.05603963f, 0.07368138f, 0.04269579f, 0.06478391f, -0.17221384f, 0.14069484f, -0.09446143f, -0.04507590f, 
    -0.10696614f, 0.06062747f, 0.01837797f, 0.07104541f, 0.00699764f, -0.02746288f, -0.07513765f, 0.06676155f, 
    -0.08275052f, -0.08045814f, 0.01307098f, 0.06515708f, -0.08760041f, 0.05512193f, 0.05343425f, 0.02808001f, 
    0.09325553f, 0.07195618f, -0.21738157f, 0.16439900f, -0.15931353f, -0.10884517f, 0.11663105f, -0.04270517f, 
    0.09096307f, -0.13728367f, -0.00851902f, 0.05705797f, -0.00769229f, 0.00205497f, 0.07246096f, -0.02201464f, 
    0.06088889f, 0.11865246f, -0.07514993f, 0.02713375f, 0.20521168f, -0.06255531f, -0.00737918f, 0.18878338f, 
    -0.02967270f, -0.05095851f, -0.02442321f, -0.02342318f, -0.10793775f, -0.03954925f, 0.01777834f, 0.01966207f, 
    0.02461834f, 0.05518433f, 0.04938391f, -0.04105293f, -0.05026761f, 0.04731927f, -0.07451927f, 0.02770030f, 
    0.08778173f, -0.15176266f, -0.01376667f, -0.10866809f, 0.08055075f, -0.06447551f, 0.02892951f, -0.04708462f, 
    -0.07729957f, -0.04348386f, 0.07396524f, 0.05002839f, -0.05802509f, 0.03016379f, 0.09582563f, -0.01244877f, 
    -0.01497986f, 0.08495918f, -0.05298669f, 0.06773472f, 0.08355801f, -0.48246661f, -0.00999518f, 0.00067867f, 
    0.04291657f, -0.03854316f, 0.00280929f, -0.00688549f, -0.00751654f, 0.01791964f, 0.00946174f, 0.01450297f, 
    0.03006661f, 0.08191822f, -0.01337782f, -0.06652171f, 0.03308899f, -0.06931935f, -0.09162794f, -0.01440631f, 
    -0.05186597f, 0.09722452f, -0.08147617f, 0.06845687f, -0.03527271f, -0.11323156f, 0.04443815f, 0.01554182f, 
    0.07889663f, -0.01270883f, 0.08331692f, 0.02522264f, 0.03242774f, -0.00667744f, -0.09860186f, 0.03091253f, 
    0.07084633f, 0.08240899f, -0.08838812f, 0.12700583f, 0.05228483f, -0.14496346f, 0.09507302f, 0.05848967f, 
    0.06684414f, 0.04191909f, 0.01217163f, 0.02951208f, -0.03777518f, 0.00009899f, 0.07851402f, 0.00820190f, 
    0.05161580f, 0.01346371f, 0.04571764f, -0.04961589f, 0.00330859f, 0.06138924f, -0.03474208f, -0.12617965f, 
    0.00512883f, -0.07695568f, 0.03417863f, -0.08348900f, -0.09346905f, 0.02700387f, 0.01008268f, 0.07229183f, 
    -0.01514512f, 0.03287235f, 0.05812694f, -0.04429772f, -0.09852057f, -0.05755747f, 0.07997806f, -0.06637849f, 
    0.02387099f, 0.00773636f, 0.07851534f, -0.07355744f, 0.21257354f, -0.36250636f, -0.22764668f, 0.12540632f, 
    0.01144813f, 0.08485493f, 0.03179189f, 0.04677768f, 0.07232208f, 0.02784304f, 0.05707725f, 0.01784553f, 
    0.08378954f, 0.01337560f, -0.01423258f, 0.06491995f, -0.03849341f, 0.03072917f, -0.08472316f, 0.10523305f, 
    -0.11820265f, -0.17263676f, -0.14159253f, 0.07472326f, 0.06165942f, -0.05295593f, 0.06979524f, -0.04493866f, 
    -0.01087966f, -0.00485449f, -0.04368052f, 0.02861844f, 0.01919284f, 0.02861555f, 0.04761881f, 0.04540642f, 
    0.02653975f, 0.06362139f, -0.11224949f, 0.05914874f, -0.19306919f, 0.13745323f, 0.00841264f, 0.14334670f, 
    -0.00861536f, -0.00083842f, -0.05498669f, -0.01411127f, 0.06314543f, 0.01536791f, -0.01446654f, -0.01564800f, 
    -0.00598422f, 0.00415426f, 0.07208912f, 0.01253730f, -0.02050269f, -0.14400551f, 0.00731018f, -0.04601112f, 
    -0.31377292f, 0.01239582f, 0.02617197f, 0.09778073f, -0.09384528f, -0.00095145f, 0.00866912f, 0.00046398f, 
    0.00204427f, -0.05426247f, -0.01466378f, -0.09184593f, 0.08680710f, 0.04268251f, -0.06054226f, 0.10196631f, 
    -0.02387023f, -0.05388800f, -0.02859091f, 0.01853224f, -0.03948887f, -0.17371053f, 0.00761957f, -0.18924105f, 
    0.04416569f, -0.05534241f, 0.01636317f, -0.01323413f, 0.04733793f, 0.01486436f, -0.04415386f, 0.04945205f, 
    0.02718913f, 0.07641987f, 0.09636991f, -0.00451086f, 0.07456540f, -0.07134219f, -0.04733368f, 0.01165852f, 
    -0.25092873f, -0.08834784f, 0.01137860f, -0.53947330f, 0.08419127f, -0.12170416f, -0.12664914f, 0.02087871f, 
    0.02438996f, -0.15407440f, -0.06940943f, -0.02821814f, -0.08490912f, -0.03846357f, 0.01497902f, 0.08280829f, 
    0.01261930f, 0.03370710f, -0.02999981f, -0.01539867f, 0.22779001f, -0.11432704f, -0.03806999f, -0.27021533f, 
    0.02379634f, -0.00293246f, 0.00296745f, 0.02557332f, -0.00015991f, -0.08638003f, -0.01600383f, 0.02136723f, 
    0.09450589f, 0.00597782f, -0.03612887f, 0.05665588f, 0.00695214f, -0.01421475f, -0.10259771f, 0.08353191f, 
    -0.27208936f, 0.04453354f, 0.13073178f, 0.08014720f, 0.09747433f, 0.01853009f, -0.14120078f, -0.06209417f, 
    -0.08940832f, -0.15103723f, -0.07105228f, -0.02701209f, -0.00098327f, 0.02284073f, 0.05412494f, -0.09368844f, 
    0.03663259f, -0.02179213f, 0.08425074f, 0.07597976f, -0.04799073f, 0.16207552f, 0.08828523f, -0.03719396f, 
    -0.25831795f, 0.05842697f, 0.02769944f, -0.02317868f, 0.01050440f, 0.02099845f, 0.01859631f, 0.01489729f, 
    -0.11883383f, 0.03346743f, -0.08500792f, 0.06908274f, -0.01443716f, -0.02757576f, 0.03487254f, -0.02588536f, 
    -0.23400228f, 0.08364778f, 0.03431508f, 0.10636480f, 0.12824069f, -0.07866207f, 0.03390608f, 0.07867273f, 
    0.03508018f, -0.03074856f, -0.05626701f, -0.00936605f, -0.06617624f, 0.05063549f, 0.10274673f, -0.06525925f, 
    0.04902360f, -0.01085142f, 0.03835218f, 0.04093136f, 0.02563115f, 0.10140600f, -0.07790493f, -0.08398348f, 
    -0.13886678f, -0.02435204f, 0.06812735f, 0.09302248f, -0.00286193f, 0.05147535f, -0.03145602f, -0.09523922f, 
    -0.01703712f, -0.00349336f, 0.00930321f, 0.09629316f, -0.09314660f, 0.01384149f, 0.14885972f, 0.02786719f, 
    0.17699568f, 0.15340512f, -0.08963317f, -0.19203304f, 0.11254220f, 0.03700120f, 0.00153400f, 0.06242248f, 
    -0.01753874f, -0.00448886f, -0.04913118f, -0.13103664f, 0.00802883f, -0.12039196f, 0.02465404f, 0.05631810f, 
    0.09574401f, 0.06911754f, 0.05986741f, 0.14776100f, -0.13405491f, 0.16579013f, -0.05634282f, 0.00201110f, 
    -0.16471799f, -0.03194359f, 0.00904010f, 0.02669912f, 0.03544179f, 0.00982995f, -0.01691164f, 0.06870574f, 
    -0.03235049f, 0.00477424f, -0.07046346f, 0.02297303f, 0.00530828f, 0.06552485f, 0.01355257f, 0.00275698f, 
    -0.00319952f, 0.09127286f, -0.12278094f, -0.09051432f, 0.09703773f, -0.10421044f, -0.05325133f, 0.08009307f, 
    0.00114116f, 0.08740322f, -0.02960201f, 0.01184654f, 0.01214145f, -0.10476760f, 0.00357040f, 0.01232330f, 
    -0.14940730f, 0.05406492f, 0.13587151f, 0.12420518f, -0.10300902f, 0.02153534f, 0.04146871f, 0.05032558f, 
    0.02799159f, 0.02965014f, -0.01224932f, -0.05155036f, -0.00926967f, 0.02440432f, -0.00169475f, 0.02331194f, 
    0.00140741f, 0.01913084f, -0.01144294f, -0.01286210f, -0.07202267f, 0.11236146f, 0.04329520f, -0.00589886f, 
    -0.11299370f, 0.10323161f, -0.04457357f, 0.13459246f, -0.01461193f, 0.00953505f, -0.04540939f, 0.04810939f, 
    -0.02474398f, -0.06263143f, -0.03997383f, 0.03484719f, 0.03795006f, 0.00051267f, -0.04991381f, 0.00502655f, 
    0.01212167f, -0.03333270f, 0.04032284f, -0.03583035f, -0.45776355f, 0.14650863f, -0.12166081f, 0.14860542f, 
    -0.03362317f, -0.07514439f, 0.02825885f, -0.06946851f, 0.06152935f, -0.00103216f, 0.08666427f, 0.04504309f, 
    0.02772176f, -0.03480568f, 0.01356768f, -0.03983639f, 0.02615886f, -0.11009301f, 0.01414958f, -0.13354145f, 
    -0.11904664f, 0.11514474f, 0.04828366f, 0.03776591f, 0.01136057f, -0.11600601f, -0.09845214f, -0.04939098f, 
    0.05721208f, -0.11263024f, -0.00371185f, 0.05249058f, 0.00836954f, 0.09955510f, 0.06166276f, -0.06261712f, 
    -0.05658179f, -0.05272947f, -0.02376866f, -0.05308454f, -0.14216097f, 0.12841535f, -0.09247135f, 0.12122209f, 
    -0.25904265f, 0.00918088f, 0.16722953f, -0.05951815f, 0.05189381f, 0.03496644f, 0.00854735f, 0.06194386f, 
    0.06268577f, 0.02415100f, -0.11695902f, 0.04493367f, -0.04474223f, 0.06161366f, 0.01681627f, -0.00833795f, 
    -0.12413048f, 0.16535679f, 0.07725602f, 0.01450770f, -0.23509963f, 0.04294403f, 0.01582663f, 0.02258690f, 
    0.00129411f, 0.05999333f, -0.03333417f, 0.00251691f, 0.02507229f, -0.01548276f, -0.03919346f, 0.02523864f, 
    -0.04120740f, -0.00656281f, -0.00492249f, -0.07769795f, -0.01228463f, 0.09437790f, 0.11485265f, -0.02602026f, 
    -0.15489522f, 0.06226601f, -0.03742474f, 0.06243875f, 0.00415293f, -0.03243589f, -0.05533367f, -0.02610741f, 
    -0.02571297f, 0.02526303f, -0.09926664f, 0.00440234f, 0.02266129f, -0.02923439f, 0.02530476f, -0.01396388f, 
    -0.10318220f, -0.14095579f, -0.11354506f, 0.04564718f, 0.06225014f, -0.00408077f, -0.11700010f, -0.03190386f, 
    0.01499734f, -0.03588612f, -0.05807973f, 0.02940078f, -0.05251296f, -0.01393568f, -0.03632087f, -0.00470799f, 
    -0.01945210f, 0.01831578f, -0.00291300f, -0.02771646f, 0.03131491f, 0.17026459f, -0.00118636f, -0.05006301f, 
    0.08986690f, -0.05337859f, 0.11055250f, -0.03598525f, -0.00171565f, 0.03634062f, -0.01082829f, -0.02260862f, 
    -0.03654681f, -0.02650034f, 0.03522665f, 0.02160004f, 0.01624354f, 0.04262011f, -0.05964765f, 0.06563447f, 
    0.08556771f, 0.11309786f, -0.00773198f, -0.00560739f, 0.10872442f, -0.03563311f, 0.02339320f, -0.06802607f, 
    0.00012598f, -0.01135853f, -0.03943243f, -0.00593150f, -0.02020915f, -0.02294539f, -0.01520013f, -0.03931963f, 
    -0.02953343f, 0.03848044f, -0.04055622f, -0.03195755f, 0.01463376f, -0.18161285f, -0.08784200f, -0.11593550f, 
    -0.13125354f, -0.04966391f, -0.08331238f, -0.01336822f, -0.05347112f, -0.06390063f, 0.02067072f, 0.02114763f, 
    -0.01685352f, 0.04889965f, -0.03317024f, 0.01892027f, 0.00058657f, -0.03716900f, 0.00179841f, -0.01052724f, 
    -0.44840276f, 0.01195895f, -0.06742048f, -0.20186591f, -0.22720301f, 0.04885158f, -0.00651120f, 0.04285319f, 
    0.02676392f, -0.06739684f, -0.03523623f, 0.01332865f, 0.01670977f, 0.00831535f, -0.04214927f, -0.02812657f, 
    0.00366323f, 0.01183517f, -0.01412500f, 0.05952103f, 0.10302795f, 0.05490707f, 0.06404379f, 0.11065542f, 
    0.09781136f, 0.05847030f, 0.04056859f, -0.01456019f, 0.00258187f, 0.00282121f, 0.01508680f, -0.00625090f, 
    -0.02139201f, -0.01706558f, 0.02432665f, 0.01349180f, 0.00053349f, 0.00327394f, 0.00326139f, 0.05896986f, 
    -0.00582799f, 0.11649483f, -0.01789670f, -0.03619255f, -0.06519475f, -0.04169226f, 0.09877472f, -0.06339109f, 
    0.01268306f, 0.05518237f, -0.02930936f, 0.02342034f, -0.00556965f, -0.01297402f, -0.03736502f, -0.00287549f, 
    0.02167732f, 0.01001866f, -0.00405654f, 0.02557919f, -0.39110640f, 0.14508097f, 0.06259861f, 0.02291572f, 
    0.01064152f, -0.02489704f, -0.00849712f, -0.05799840f, 0.03689525f, -0.08310239f, 0.07740144f, 0.02702754f, 
    -0.02797294f, 0.00700337f, -0.03360766f, 0.05584524f, 0.00779413f, 0.02920143f, -0.02851358f, -0.02110887f, 
    0.10242146f, 0.16166577f, 0.16076019f, 0.07134551f, 0.12196101f, -0.01167814f, 0.03966951f, -0.04159456f, 
    -0.03198103f, -0.02095546f, -0.01553329f, 0.08665177f, -0.05669083f, 0.00415918f, -0.02469281f, -0.04092297f, 
    -0.01796681f, 0.07152520f, 0.02201431f, -0.04947029f, 0.10655536f, -0.21039863f, -0.02881659f, -0.03789513f, 
    0.00973477f, -0.04975775f, -0.05537743f, -0.00389213f, -0.04463842f, -0.00215411f, -0.02956775f, -0.07007086f, 
    -0.01016067f, 0.02582424f, -0.04832426f, -0.03099030f, 0.03213732f, 0.01203579f, -0.04093495f, 0.03022852f, 
    -0.14129062f, 0.03839158f, 0.01897488f, 0.03580314f, -0.01598427f, 0.00816977f, -0.09509622f, -0.00492950f, 
    0.09628232f, 0.01067605f, -0.00097801f, 0.00977119f, 0.02849896f, -0.05375607f, 0.00166102f, 0.01290424f, 
    -0.06973670f, 0.07858657f, 0.04448642f, 0.01465381f, -0.01326436f, 0.11846156f, -0.11632743f, 0.05130780f, 
    0.05412098f, -0.05988947f, -0.03643416f, -0.09881250f, 0.04752769f, -0.03787144f, -0.05237110f, 0.01056636f, 
    -0.02541820f, -0.03093899f, -0.01810713f, -0.03751698f, 0.02496540f, 0.08272373f, 0.00771534f, 0.00897107f, 
    0.07554716f, 0.00294000f, 0.03056649f, -0.05219223f, -0.03063106f, -0.07089469f, 0.01200898f, -0.02065604f, 
    -0.03742770f, 0.03932227f, -0.00040479f, 0.00855541f, -0.01559576f, -0.07017405f, -0.02677631f, -0.03437580f, 
    0.00278827f, 0.00455770f, -0.00734001f, -0.06316517f, -0.02590644f, 0.09910479f, -0.10816773f, 0.05918103f, 
    0.07925351f, -0.03604239f, -0.02658313f, -0.08828512f, 0.03560286f, -0.05547205f, -0.12200472f, 0.01356096f, 
    -0.07567349f, -0.03741910f, -0.01714120f, 0.01533275f, -0.07252281f, 0.02384616f, -0.02037660f, -0.03540940f, 
    0.05876566f, 0.10653191f, -0.04901678f, -0.00028454f, 0.04457320f, -0.05473208f, 0.03229645f, -0.07164907f, 
    0.02934175f, -0.02926325f, -0.05730424f, 0.00252986f, -0.02245313f, -0.01343925f, -0.00069862f, -0.04873995f, 
    -0.01434051f, 0.06008627f, -0.00983820f, 0.03033757f, -0.16963883f, -0.04811458f, -0.07303103f, -0.06279101f, 
    0.01576625f, 0.00482833f, -0.08406484f, -0.02851147f, 0.03227415f, -0.03734996f, -0.05617327f, -0.00477901f, 
    -0.01734564f, 0.00520534f, 0.02014908f, -0.02233067f, 0.03703225f, 0.06043429f, 0.00627189f, 0.10406726f, 
    -0.12638600f, 0.03067015f, 0.00146165f, -0.02660106f, 0.11880182f, -0.06522600f, 0.04908256f, -0.08303972f, 
    0.00951311f, -0.01246617f, -0.02650566f, 0.01454418f, -0.06617568f, -0.04477623f, -0.01733367f, -0.02026547f, 
    -0.04196624f, 0.04732281f, -0.02142481f, -0.02057406f, -0.11580354f, 0.01043312f, 0.05372960f, -0.05768647f, 
    -0.01327403f, -0.10462505f, 0.02002469f, -0.01171767f, -0.02882739f, -0.04012157f, -0.02851938f, 0.04741756f, 
    -0.06000121f, -0.04760240f, -0.01563700f, -0.03268214f, -0.00434619f, 0.00609280f, -0.03602348f, 0.01874455f, 
    0.16228786f, -0.08958280f, 0.08122399f, -0.00042600f, -0.07174521f, 0.08850028f, -0.03175261f, 0.01305605f, 
    -0.06890067f, -0.02227713f, -0.01900738f, -0.01607387f, -0.06850822f, 0.00271852f, -0.03790162f, -0.00121974f, 
    0.04363391f, 0.03585358f, 0.00630798f, -0.00552729f, 0.00611909f, -0.00494039f, -0.07916079f, -0.10293194f, 
    -0.15107264f, -0.02404160f, -0.05672527f, -0.01901810f, -0.01643320f, -0.06554267f, -0.01613855f, 0.00007326f, 
    -0.03739684f, -0.00743244f, -0.06720439f, 0.03619239f, 0.02756080f, -0.00615501f, -0.01016442f, -0.03896249f, 
    0.18939263f, -0.15180418f, 0.03642827f, -0.06945159f, -0.07581629f, -0.04933035f, 0.05961047f, -0.06999367f, 
    0.00352473f, 0.02882634f, 0.01575502f, 0.03828708f, -0.04745320f, -0.01457657f, -0.01347017f, -0.02541068f, 
    0.04817836f, 0.03857182f, 0.00389588f, -0.05757227f, 0.09318073f, -0.05413122f, 0.11222620f, 0.04488034f, 
    0.06464296f, -0.00274865f, 0.00489993f, -0.00640274f, -0.05990488f, -0.02327203f, -0.04971477f, 0.01551888f, 
    -0.03911915f, -0.02440883f, 0.02753456f, -0.07536150f, 0.00595644f, -0.04508013f, 0.03259749f, 0.00733418f, 
    0.11699249f, -0.05862167f, -0.09479484f, -0.07015059f, -0.05320789f, -0.01149765f, -0.09563140f, -0.02349706f, 
    -0.05310101f, -0.05892858f, 0.07245196f, 0.00088272f, 0.01849854f, -0.01225390f, -0.07438397f, 0.00904457f, 
    -0.01886117f, -0.00759151f, -0.03811307f, 0.04673026f, 0.03240808f, 0.00506018f, 0.09891790f, 0.08496241f, 
    0.08032424f, 0.08246925f, 0.06884054f, -0.00006100f, -0.00405448f, -0.02776547f, 0.01065122f, -0.03804580f, 
    0.04754879f, 0.00220136f, -0.03590788f, -0.00982812f, -0.05761547f, -0.04791992f, -0.01310028f, -0.02421835f, 
    -0.00556347f, 0.02823073f, -0.00077796f, -0.03034239f, -0.08709648f, 0.01662405f, -0.08012377f, -0.02248406f, 
    -0.00978940f, -0.04032317f, -0.00198248f, 0.04557567f, 0.03336433f, 0.00587617f, -0.02502908f, 0.01815062f, 
    0.01036208f, -0.02314447f, -0.03105175f, 0.01032135f, 0.01529911f, 0.05596287f, -0.13821812f, 0.01805564f, 
    0.14754266f, -0.10153240f, -0.04785932f, -0.02987182f, -0.00978781f, -0.01994723f, -0.04367951f, -0.01300522f, 
    -0.07586761f, 0.00998323f, -0.03569141f, -0.02378307f, -0.05988978f, -0.01822231f, -0.03908203f, 0.01223260f, 
    -0.26717094f, 0.08197033f, 0.08706428f, 0.06079151f, 0.03539905f, -0.00661942f, -0.05944534f, -0.03345346f, 
    0.10876956f, 0.03357406f, -0.03873691f, -0.01659395f, 0.00876594f, 0.07903176f, -0.10180549f, 0.08677302f, 
    0.00398009f, 0.01970235f, -0.06042420f, 0.00512053f, 0.14363712f, 0.04496300f, 0.18731584f, 0.01628288f, 
    0.03304145f, 0.06017291f, 0.03412865f, -0.01859683f, -0.02175703f, -0.03215353f, -0.03561789f, 0.05123280f, 
    -0.01811007f, -0.00656301f, -0.03266646f, -0.04525270f, 0.03734547f, 0.00842062f, 0.03044505f, -0.02100815f, 
    -0.01166527f, -0.28843310f, 0.02843938f, -0.05317480f, -0.19919291f, -0.03564065f, 0.02805542f, 0.02827278f, 
    -0.01655883f, -0.06247775f, -0.05238051f, -0.07359935f, -0.03193676f, 0.00096113f, -0.02261993f, 0.02880468f, 
    0.00197298f, -0.01205302f, 0.03006052f, 0.05127753f, -0.00354329f, -0.12439877f, 0.04906118f, 0.05325098f, 
    -0.09347197f, 0.05364649f, -0.07196356f, 0.00409052f, 0.03802463f, 0.02076759f, -0.02881867f, 0.02391145f, 
    0.01148496f, -0.02219716f, -0.07299022f, 0.07491006f, 0.03174450f, 0.00862236f, -0.05533529f, 0.01698018f, 
    0.04381539f, 0.10199731f, 0.15450914f, 0.03910363f, 0.09160034f, 0.07635974f, 0.04148225f, 0.01159300f, 
    -0.05030688f, -0.05183373f, -0.07089069f, 0.02587990f, -0.03238088f, 0.00494061f, -0.00448460f, -0.04409124f, 
    0.06918985f, 0.01132659f, 0.05305714f, -0.03907990f, 0.09789316f, -0.04307592f, -0.00502354f, -0.07046443f, 
    -0.04188076f, 0.04176292f, 0.00429256f, 0.00954479f, -0.00788118f, -0.02869962f, -0.03593398f, 0.02795249f, 
    -0.00188176f, -0.01244966f, 0.01820231f, 0.00466828f, -0.01027219f, -0.01294457f, 0.02704361f, -0.01492369f, 
    0.01334427f, 0.17195831f, -0.01719107f, -0.03964512f, 0.08870623f, 0.02324126f, 0.03423432f, -0.01353186f, 
    -0.02458964f, 0.00893219f, -0.03367269f, 0.01582536f, 0.00794667f, -0.04004639f, 0.03982176f, 0.02050233f, 
    0.01658275f, -0.04730372f, 0.00302674f, 0.03410778f, -0.06210684f, 0.12057929f, 0.17548518f, 0.12514125f, 
    0.10340827f, 0.07302994f, 0.08762787f, 0.01703569f, 0.04905248f, -0.00554826f, -0.07087524f, 0.04634311f, 
    0.08214661f, -0.04082031f, 0.01251324f, -0.00118843f, 0.01684385f, 0.04154372f, 0.02931415f, -0.01777631f, 
    -0.02584099f, -0.16313443f, -0.00827459f, 0.04385291f, -0.18654689f, 0.04608906f, -0.05147339f, -0.02913197f, 
    -0.02392179f, -0.07013753f, -0.04998717f, -0.02460629f, -0.05538569f, 0.00084050f, -0.05343588f, 0.00992947f, 
    -0.01629825f, -0.02270715f, -0.02836065f, -0.02271106f, -0.10933091f, 0.02374952f, -0.03614137f, 0.07735400f, 
    0.12625192f, 0.03175884f, -0.05928649f, -0.07473010f, -0.00747175f, -0.02662770f, 0.00572830f, 0.01153124f, 
    -0.02661091f, 0.01392572f, -0.04804426f, 0.01535710f, -0.07653295f, -0.04117366f, -0.00995384f, -0.04078654f, 
    -0.16551524f, 0.14799377f, -0.01506801f, 0.04843506f, 0.03896577f, -0.01304997f, -0.05223241f, -0.02821289f, 
    0.02221168f, -0.02850919f, -0.04763030f, 0.01712797f, 0.03923647f, 0.00131232f, -0.05192080f, 0.08448955f, 
    0.01424537f, 0.05808787f, 0.02758634f, -0.01110807f, -0.30586272f, 0.12910908f, 0.01435929f, 0.02904121f, 
    0.06998159f, 0.04852448f, -0.12281639f, 0.03940527f, 0.04736623f, -0.02009918f, 0.10122299f, 0.05772157f, 
    0.05074465f, -0.04345876f, 0.01238917f, -0.00380465f, -0.00247927f, 0.07107917f, 0.00400654f, -0.05483105f, 
    -0.09741752f, 0.11841065f, 0.14851050f, -0.00656224f, 0.07005829f, 0.00741729f, 0.04547659f, 0.01915543f, 
    0.04439837f, -0.00119011f, -0.04445120f, 0.03915607f, -0.02836754f, 0.00144896f, -0.05633010f, -0.04700075f, 
    -0.00067191f, 0.02919789f, -0.01768884f, -0.03593701f, -0.01184780f, -0.14149012f, 0.07718757f, 0.02274958f, 
    0.16083385f, -0.01852400f, 0.02983329f, -0.00921092f, -0.01950504f, -0.07008146f, 0.02740704f, -0.00904124f, 
    -0.04297409f, 0.01938157f, 0.00319735f, -0.03384509f, -0.00014853f, 0.01353887f, 0.01119778f, -0.00988944f, 
    -0.05963497f, 0.12442243f, -0.10075298f, 0.11402195f, -0.00904572f, -0.01694746f, -0.05338768f, -0.02347557f, 
    0.01210211f, -0.01113703f, -0.02909649f, 0.02424860f, 0.04999353f, 0.09121597f, -0.07639720f, 0.03560766f, 
    -0.05701769f, 0.01482332f, 0.01231518f, -0.02925113f, 0.12086957f, -0.03445304f, 0.04529193f, 0.01951830f, 
    0.11123936f, -0.04444266f, -0.02131404f, -0.03962669f, -0.00319373f, -0.04312699f, -0.01715847f, -0.00649886f, 
    -0.03323157f, 0.01358805f, 0.01001531f, -0.04947523f, -0.00675663f, -0.00041712f, 0.02523615f, -0.01981483f, 
    0.13467407f, -0.07914023f, -0.00095696f, 0.02445983f, 0.03340495f, -0.01742227f, -0.01588821f, -0.01105383f, 
    -0.03122366f, -0.02450163f, 0.00356925f, 0.02271250f, -0.01223729f, -0.00668725f, -0.01813310f, -0.09200417f, 
    0.02365210f, -0.02477617f, 0.05360137f, 0.02188082f, 0.06172570f, 0.07118273f, 0.14716081f, 0.08724190f, 
    0.16843121f, 0.13402535f, 0.15569662f, -0.02652944f, 0.01831042f, 0.00463950f, -0.00447362f, -0.00901555f, 
    0.02266536f, 0.03825939f, -0.01232861f, 0.01702387f, 0.02816578f, -0.01122815f, 0.00515951f, 0.03161862f, 
    -0.12650791f, 0.14718276f, -0.08994196f, 0.02059633f, 0.00315751f, -0.08839742f, 0.03526773f, -0.04219007f, 
    -0.02029575f, -0.03424888f, 0.01144922f, -0.00381951f, -0.04744839f, 0.02615153f, -0.10112296f, -0.00481482f, 
    0.00490824f, -0.01987073f, -0.00735727f, -0.02701667f, 0.02582882f, -0.14120841f, -0.12393518f, -0.14752403f, 
    -0.11219339f, -0.02871477f, -0.02294497f, 0.01441883f, -0.02542977f, -0.03374505f, 0.00782871f, -0.01017353f, 
    -0.01088711f, 0.00753584f, -0.03478346f, -0.00731230f, -0.06297733f, -0.03561695f, -0.03709761f, 0.01054674f, 
    -0.15212002f, -0.01147956f, -0.09628842f, -0.11186970f, -0.09671793f, -0.05650902f, 0.02149581f, -0.03956417f, 
    -0.05337826f, -0.00032866f, 0.03681186f, -0.04463027f, 0.00321893f, -0.00989056f, -0.00730319f, 0.01675350f, 
    -0.02054063f, -0.01303049f, 0.00254011f, -0.02844852f, 0.05259831f, 0.07126693f, 0.10483237f, 0.07883375f, 
    0.05672409f, 0.00926166f, 0.02787514f, -0.01231980f, 0.00610993f, -0.02661986f, -0.04891672f, 0.03746165f, 
    0.01817315f, -0.03800384f, -0.05565573f, -0.01428832f, -0.02537540f, -0.00402389f, -0.02177462f, 0.02638351f, 
    0.11034648f, 0.09555431f, 0.20655011f, 0.20874159f, 0.14679982f, 0.08731127f, 0.13681169f, -0.00234647f, 
    0.00923152f, 0.00125821f, -0.03278602f, 0.01303059f, -0.06136726f, 0.00178754f, -0.08924029f, -0.01928352f, 
    -0.01434016f, 0.02453814f, -0.05735484f, 0.02832278f, 0.01359871f, 0.10811371f, 0.21028805f, 0.03839103f, 
    0.11316752f, 0.05541607f, 0.07742529f, 0.01090867f, 0.02260211f, -0.00708664f, -0.01437072f, 0.01530693f, 
    0.02634420f, 0.00964048f, -0.04138743f, -0.04542022f, -0.03718852f, -0.01822669f, 0.00006322f, -0.05461756f, 
    -0.04999577f, 0.06374554f, 0.14108743f, 0.07061405f, 0.06857977f, 0.14026055f, 0.01107523f, 0.00441639f, 
    0.01911726f, 0.02629457f, 0.03037563f, 0.00180186f, 0.08396473f, -0.04078684f, -0.06015200f, 0.03427747f, 
    -0.07172236f, -0.00556777f, 0.05941989f, -0.00780472f, -0.01514681f, -0.17437740f, -0.13145839f, -0.02933042f, 
    0.03854332f, -0.04673179f, -0.09601221f, -0.02917336f, 0.02536919f, -0.03725069f, -0.04458774f, 0.00088004f, 
    0.00197666f, -0.02995291f, -0.02248215f, -0.03416966f, 0.01082865f, -0.00527362f, -0.02395983f, 0.01855016f, 
    0.17151187f, 0.01436183f, -0.10060428f, -0.00465343f, -0.02339942f, -0.02111262f, 0.02823218f, -0.06211803f, 
    0.06686344f, -0.01873892f, -0.06460665f, 0.04946818f, -0.08018961f, -0.02444154f, -0.07853839f, -0.01203911f, 
    -0.06426826f, 0.05153188f, -0.05852925f, 0.00283040f, 0.04763856f, 0.03174037f, -0.14663199f, 0.09384855f, 
    0.16689400f, -0.10020406f, -0.10722090f, -0.03316298f, -0.03266290f, -0.01929667f, -0.03884001f, 0.03035173f, 
    0.01047361f, 0.03716749f, -0.04610743f, -0.02531859f, -0.03565158f, -0.03111846f, 0.00613622f, 0.01365902f, 
    0.12400509f, 0.15737371f, 0.15218462f, -0.06799398f, 0.11871096f, -0.11768138f, 0.01791134f, -0.06423685f, 
    -0.02087394f, 0.03132087f, 0.01408901f, 0.06634226f, -0.00593663f, -0.00112109f, -0.05182036f, 0.00183700f, 
    -0.00763646f, 0.02809482f, 0.01688729f, -0.06203322f, -0.37791851f, -0.02827287f, -0.21622027f, -0.08479317f, 
    -0.05009434f, -0.00259480f, -0.06607025f, -0.06194224f, 0.01472677f, -0.02452800f, -0.06653889f, 0.04846754f, 
    0.04348344f, -0.04823822f, 0.02536607f, -0.04023696f, 0.00433803f, 0.02633778f, -0.00833639f, 0.09477637f, 
    0.01301184f, 0.02973505f, -0.07126297f, 0.07848751f, 0.16224888f, -0.09564895f, -0.07585223f, -0.03809842f, 
    -0.03906834f, -0.00431970f, -0.09073394f, 0.02253238f, -0.06855666f, 0.00023114f, -0.03665731f, 0.01303179f, 
    -0.02974832f, -0.03797133f, -0.03355770f, -0.02431511f, -0.00207034f, 0.07342039f, 0.02804825f, -0.01250596f, 
    0.09293548f, 0.01907879f, -0.06416053f, -0.10524236f, 0.05494035f, 0.00201805f, -0.03160338f, -0.00219552f, 
    -0.01259762f, -0.01936577f, -0.06581336f, 0.00367287f, -0.07190198f, -0.01157597f, -0.00712970f, -0.00599510f, 
    -0.08020592f, -0.02683422f, -0.11711457f, -0.13089660f, -0.01246230f, 0.05469840f, -0.04330438f, -0.01797722f, 
    0.04027998f, -0.03904610f, -0.07096409f, 0.01166487f, -0.05051319f, -0.04529578f, 0.00421240f, 0.00781027f, 
    -0.04053718f, -0.01236067f, 0.00800626f, 0.01424827f, -0.20080060f, 0.00760077f, 0.07987265f, -0.05931449f, 
    -0.13678434f, -0.00036214f, 0.02241218f, 0.03751081f, -0.02078424f, -0.04107352f, 0.03922082f, 0.00337445f, 
    -0.05754840f, -0.03644393f, -0.06523202f, -0.02308021f, 0.03319497f, -0.02311434f, -0.02113399f, -0.02100366f, 
    -0.09600697f, -0.08407421f, -0.17484462f, -0.04998622f, -0.09966154f, -0.09011045f, -0.05177737f, 0.01334193f, 
    -0.04395399f, -0.02811309f, 0.01680550f, -0.01557063f, -0.03088379f, 0.01812251f, 0.00607642f, 0.00142434f, 
    -0.05005184f, -0.02275275f, -0.00528177f, -0.03062250f, -0.20518516f, 0.14975853f, -0.02232469f, -0.02025259f, 
    0.02358728f, 0.00109572f, 0.06600745f, -0.07098057f, 0.01023546f, -0.01626270f, -0.05042325f, -0.01755018f, 
    -0.02757538f, 0.00325909f, -0.04660639f, 0.02314174f, 0.01363214f, 0.05728788f, 0.00408426f, -0.03898703f, 
    -0.19155002f, -0.09576540f, -0.17211924f, -0.06950548f, -0.03532867f, -0.00569017f, -0.05028732f, -0.04304828f, 
    0.00237412f, -0.00607208f, -0.10578705f, 0.00674303f, 0.03349860f, -0.03304562f, -0.05516318f, -0.05690907f, 
    0.03195295f, 0.00869181f, 0.02304232f, 0.05466877f, 0.12388237f, -0.41643617f, 0.11413451f, -0.10259835f, 
    -0.17776853f, -0.00530711f, -0.04223255f, -0.00672727f, -0.03386435f, -0.03250076f, -0.01140245f, -0.03876856f, 
    -0.07652239f, 0.02924654f, -0.03834938f, -0.02849662f, 0.04603757f, -0.00597475f, 0.01721284f, -0.05563833f, 
    -0.01828292f, -0.07991888f, -0.21140926f, 0.00933266f, 0.04922695f, 0.04477135f, -0.03252992f, -0.08917456f, 
    -0.04366568f, -0.02126129f, 0.02060803f, -0.05626213f, 0.09159436f, 0.00856532f, 0.07861109f, 0.00044008f, 
    -0.06208469f, -0.03934790f, 0.02588654f, -0.05517821f, -0.12197247f, 0.10190936f, -0.13520983f, -0.10073043f, 
    -0.15356386f, -0.03411971f, -0.00858775f, -0.05711067f, 0.00212729f, -0.01962980f, 0.09577609f, 0.00652266f, 
    -0.01771160f, 0.03355262f, 0.04376506f, -0.05939352f, -0.00236521f, -0.07068919f, 0.04775815f, 0.03044439f, 
    -0.12447072f, 0.11449686f, -0.12495729f, -0.11618052f, -0.22691759f, -0.09184927f, -0.00939667f, -0.02592656f, 
    0.01997745f, -0.03890281f, 0.03098901f, 0.01004827f, 0.04863177f, 0.00035459f, 0.03092351f, 0.01798663f, 
    -0.00510353f, -0.14393404f, -0.05826183f, 0.05426620f, 0.12345858f, -0.00140900f, 0.00385344f, 0.07966124f, 
    0.15989172f, 0.03762427f, 0.04471506f, -0.06097286f, -0.03913664f, -0.03030186f, -0.03194373f, -0.02638293f, 
    -0.03805079f, -0.04714466f, -0.01186889f, -0.05301033f, 0.05058660f, 0.03896425f, 0.05105557f, -0.02935514f, 
    0.07388905f, 0.10960315f, -0.17539473f, 0.04665589f, 0.07045216f, 0.07653622f, 0.08383295f, -0.04874372f, 
    -0.00044854f, 0.00131554f, -0.01868001f, -0.02304727f, -0.02914291f, 0.04393558f, 0.01353036f, -0.05849973f, 
    0.03000256f, 0.02359251f, 0.07633103f, -0.06473745f, -0.10580013f, -0.18836816f, 0.00746588f, -0.19955012f, 
    -0.16780393f, 0.08282876f, -0.03052738f, 0.01869410f, -0.00897338f, 0.00844999f, 0.02818676f, 0.02095708f, 
    0.00292364f, 0.02396252f, -0.00764392f, -0.03036848f, -0.00976842f, 0.03093322f, -0.08256583f, -0.03311238f, 
    -0.01357091f, 0.06527816f, -0.09172861f, 0.03249212f, -0.02738043f, -0.00143808f, -0.00739492f, -0.03779217f, 
    0.00643858f, 0.00981017f, 0.10689154f, 0.00492885f, -0.01305879f, -0.01341958f, 0.05308409f, -0.02691676f, 
    0.00247043f, -0.01398268f, 0.05899599f, 0.03543815f, 0.01876658f, 0.15563996f, -0.15299046f, 0.05868522f, 
    -0.05909642f, 0.01873422f, 0.03968658f, -0.11626641f, -0.06191022f, -0.01842009f, 0.00157869f, 0.01929287f, 
    0.00368981f, 0.03534066f, 0.04473614f, 0.02661368f, -0.04816277f, -0.06881224f, 0.07783420f, -0.04947209f, 
    -0.18411760f, 0.06606501f, 0.09848897f, -0.04932836f, -0.11263457f, 0.02495895f, 0.02304989f, -0.04075400f, 
    -0.02763593f, -0.12928842f, 0.04317869f, -0.01528066f, 0.02167484f, 0.08700366f, 0.02477537f, 0.04770349f, 
    0.07393927f, -0.09181425f, -0.13944414f, 0.03956526f, 0.03470794f, -0.04525828f, -0.13030308f, -0.06137925f, 
    0.02129231f, 0.08101762f, 0.01696311f, 0.02092819f, -0.01393069f, -0.04355643f, -0.00310340f, 0.04614019f, 
    0.00471364f, 0.03095166f, -0.02880606f, 0.02834182f, 0.02760648f, 0.03352920f, -0.00231802f, -0.00816072f, 
    -0.10467460f, 0.08769165f, -0.14830524f, -0.11541385f, -0.16101328f, 0.04806997f, -0.02960197f, -0.03791831f, 
    0.00485311f, -0.08534646f, 0.05314491f, 0.03703766f, 0.03745219f, 0.05875430f, -0.01077034f, 0.03740802f, 
    0.01645007f, -0.22626919f, -0.07105486f, -0.00797085f, -0.03446362f, 0.04109716f, -0.09799218f, -0.07598628f, 
    -0.09013151f, -0.07989465f, 0.02613505f, -0.07799789f, 0.00201993f, 0.00582954f, 0.00499314f, 0.04892504f, 
    0.03549415f, -0.00175900f, 0.06277973f, 0.01992382f, -0.00946802f, -0.06738807f, 0.03454064f, 0.04808528f, 
    0.05800286f, 0.10728686f, -0.08509275f, 0.03045805f, 0.08418142f, 0.03097080f, -0.05337924f, 0.02999210f, 
    -0.06029537f, -0.00802289f, 0.04899608f, -0.00338853f, -0.07583588f, -0.03955002f, 0.07191354f, -0.01101493f, 
    -0.01090951f, 0.02071209f, 0.00016104f, 0.03680373f, -0.18552442f, 0.16419242f, 0.12463222f, -0.13094613f, 
    -0.10655996f, -0.04715939f, -0.00336464f, -0.05451362f, 0.00624012f, -0.18723522f, 0.07983927f, 0.06200442f, 
    0.02249590f, 0.03251726f, -0.00833701f, -0.08385807f, 0.07840764f, -0.03441267f, -0.01641922f, -0.11184420f, 
    -0.09604631f, 0.01853498f, -0.07145014f, -0.10882713f, -0.10171444f, 0.00492764f, -0.03223841f, -0.00569712f, 
    -0.01300430f, -0.02776551f, 0.06430327f, 0.02260442f, 0.04890284f, 0.08283565f, -0.00683658f, 0.00913514f, 
    0.01559018f, -0.06885359f, 0.04750156f, 0.05367203f, 0.13319837f, 0.03431924f, -0.13845120f, -0.00877018f, 
    0.06610522f, 0.08442847f, 0.03262193f, 0.01639009f, -0.00494925f, -0.04050231f, 0.02641032f, -0.01638128f, 
    0.06729568f, -0.00015459f, -0.01342026f, 0.03366371f, 0.06359074f, 0.07619166f, 0.08218032f, 0.00147836f, 
    0.04272996f, 0.12887536f, 0.05701718f, 0.04662772f, -0.07931564f, -0.11838377f, 0.00915810f, -0.01329976f, 
    -0.00718675f, 0.03182150f, 0.02128460f, -0.04355274f, 0.03539935f, 0.02096193f, 0.00763726f, -0.01503978f, 
    -0.01807910f, -0.07381717f, 0.08301452f, 0.01139963f, 0.11686249f, 0.11620035f, 0.09843829f, 0.00060907f, 
    0.06191630f, -0.08624122f, -0.07459014f, 0.03168115f, -0.04855761f, -0.05697368f, -0.02040689f, -0.06874246f, 
    -0.04550640f, -0.04148436f, 0.03116438f, -0.01424022f, -0.01807172f, -0.00912423f, 0.10724314f, -0.04841131f, 
    0.07015457f, 0.06504042f, -0.00570158f, 0.07401946f, 0.13240400f, -0.09606716f, -0.07495799f, -0.01984564f, 
    0.00119242f, -0.01080794f, -0.02436711f, -0.00929940f, -0.02566680f, -0.03459922f, -0.02955072f, 0.03866742f, 
    -0.00280065f, 0.02397897f, 0.05923258f, 0.06840441f, 0.04284250f, -0.01670977f, -0.00284479f, 0.01198846f, 
    0.08144902f, 0.03082937f, 0.00535863f, -0.07062586f, -0.00510758f, -0.01380828f, 0.00408892f, -0.01888977f, 
    -0.00053245f, -0.02178273f, 0.00550139f, -0.03674517f, 0.01184729f, 0.06386231f, -0.02067707f, -0.01162709f, 
    0.01534082f, 0.05050466f, -0.00824860f, 0.01878039f, 0.12273082f, -0.02748211f, 0.01326957f, 0.03524032f, 
    -0.07566365f, 0.04315738f, 0.06503345f, 0.06231283f, -0.04470767f, 0.03024652f, 0.05286171f, 0.01428853f, 
    0.00737868f, 0.04003306f, 0.01682176f, -0.00567303f, -0.11766724f, -0.07686321f, 0.12067514f, -0.06844302f, 
    -0.07376458f, -0.01485540f, -0.02727384f, 0.03524614f, 0.00303332f, -0.09790286f, 0.01398962f, 0.00818626f, 
    0.03905286f, 0.05496359f, -0.01679199f, -0.00959460f, -0.00411950f, -0.02311244f, -0.23214653f, 0.03887770f, 
    0.17651662f, 0.10737924f, 0.01659914f, 0.02034829f, 0.11765285f, 0.02608165f, 0.02192648f, -0.12414964f, 
    -0.04821921f, -0.00048607f, -0.02644551f, 0.06885064f, -0.04557037f, -0.05882585f, -0.04640882f, -0.04045476f, 
    -0.03959164f, 0.06499442f, 0.00409334f, 0.00303116f, 0.03576316f, 0.01102165f, 0.11148581f, 0.00098234f, 
    0.09491342f, -0.01510247f, 0.01260808f, -0.01997627f, -0.04478750f, -0.06947978f, -0.03282332f, -0.00324313f, 
    -0.02074583f, -0.10887075f, 0.03026439f, -0.02984507f, 0.02362471f, 0.05661320f, 0.04458486f, 0.00843337f, 
    0.04591932f, -0.04772361f, 0.00615343f, 0.01433382f, 0.13803811f, 0.00797846f, 0.02483102f, -0.13907406f, 
    0.00263884f, -0.02385972f, 0.03681722f, 0.00614401f, 0.03822572f, -0.11004210f, 0.02941049f, -0.03632902f, 
    0.01443739f, -0.01820605f, 0.05967496f, -0.02781698f, 0.11065989f, 0.06433202f, -0.03400271f, -0.08271156f, 
    -0.01373770f, -0.04838521f, 0.01684953f, -0.01653699f, -0.15927993f, -0.05478678f, -0.06476430f, 0.04233409f, 
    0.04639892f, -0.02010832f, -0.06452410f, 0.00027100f, 0.04492665f, 0.00329867f, -0.03922716f, 0.00101570f, 
    0.17741159f, 0.11959060f, -0.22592719f, 0.05156324f, -0.06429589f, 0.00415129f, -0.03857928f, -0.23804617f, 
    -0.15637954f, 0.03910572f, 0.06576623f, -0.02401772f, 0.04863345f, -0.04420087f, -0.00427605f, -0.00589214f, 
    -0.00780832f, -0.06442118f, 0.12192363f, -0.08114464f, -0.12485995f, -0.06248659f, 0.14450376f, 0.05440241f, 
    0.13194878f, -0.07878780f, -0.03799495f, 0.00859229f, -0.11195067f, -0.03755663f, -0.01093485f, -0.00846807f, 
    -0.07989807f, 0.03063499f, 0.04528714f, -0.01267853f, -0.02774259f, -0.00605169f, 0.03858135f, 0.04460375f, 
    0.06552447f, -0.05271250f, -0.23812212f, 0.05788584f, 0.16367765f, 0.11466916f, 0.06359766f, -0.01629897f, 
    -0.01249494f, -0.05740218f, -0.02007685f, -0.02341206f, 0.04901249f, 0.04683979f, -0.06943752f, 0.05066163f, 
    0.04810428f, -0.01033972f, 0.07073313f, -0.04437025f, 0.03356238f, 0.06783519f, -0.12056752f, 0.06509086f, 
    -0.03898325f, 0.00291574f, -0.01259873f, -0.09620576f, -0.05244078f, 0.02882954f, 0.01393133f, -0.03378223f, 
    0.01147013f, -0.03816932f, -0.05415904f, 0.01542871f, -0.01911656f, -0.06560441f, 0.06415977f, 0.02518339f, 
    -0.21079446f, -0.10239540f, 0.16873176f, -0.13592401f, -0.09173088f, 0.05559105f, 0.01110638f, 0.04561799f, 
    -0.08209977f, -0.05818364f, 0.02084594f, -0.05867312f, 0.05637715f, -0.06708355f, -0.02639847f, -0.03269679f, 
    -0.00357818f, -0.04070788f, -0.08768024f, -0.03198859f, 0.08205586f, -0.02651410f, -0.08424515f, 0.01206604f, 
    0.05235416f, -0.00272180f, -0.01053208f, 0.01306275f, 0.00971268f, -0.01600252f, 0.03395339f, -0.02683924f, 
    0.02443803f, -0.01797361f, 0.04755020f, 0.02780177f, -0.03522322f, 0.00683244f, 0.03253676f, 0.07173205f, 
    -0.16889976f, 0.09130482f, -0.12054339f, -0.09997213f, -0.16283867f, 0.02812400f, 0.02385709f, -0.00542367f, 
    0.00405790f, -0.04190199f, 0.04914828f, 0.00733802f, -0.10369962f, 0.01864056f, 0.03816865f, -0.08384914f, 
    -0.07365539f, -0.00163680f, 0.06885888f, -0.05882767f, -0.16275640f, -0.16455565f, 0.16220687f, 0.09867021f, 
    0.09880115f, -0.04189169f, -0.07451914f, -0.02293230f, -0.07134434f, 0.03394918f, 0.00673683f, 0.02757752f, 
    -0.07582083f, 0.01901910f, 0.02162975f, -0.01736018f, 0.03373421f, 0.02205404f, 0.05342547f, 0.04147078f, 
    0.04217970f, 0.03720450f, -0.20680073f, 0.06042041f, 0.06010152f, 0.00141566f, -0.01816033f, -0.03578879f, 
    -0.00270146f, 0.03254307f, -0.00988817f, -0.03783369f, 0.01284341f, -0.01349545f, 0.04118924f, 0.05376076f, 
    -0.00499497f, -0.00048741f, 0.09873994f, 0.00676143f, -0.06828190f, -0.04320769f, -0.14670584f, -0.01412056f, 
    -0.04182873f, 0.04218775f, -0.05581547f, -0.07698574f, -0.01535211f, -0.02196503f, 0.04375434f, 0.01308566f, 
    0.06824373f, -0.04536565f, 0.03554808f, -0.07298344f, 0.00878121f, -0.07099323f, -0.02534701f, -0.09357152f, 
    -0.01668966f, 0.02670523f, -0.07854503f, 0.08806702f, -0.01821515f, 0.03339231f, -0.01910434f, -0.09763510f, 
    -0.02444493f, -0.02046465f, 0.10779914f, 0.00623660f, 0.05686063f, -0.05586127f, 0.09479421f, -0.03633053f, 
    0.04804239f, -0.02304496f, 0.14145182f, -0.05055727f, -0.17500879f, 0.18882880f, -0.12327373f, -0.10707830f, 
    -0.15376334f, 0.03456099f, 0.00229564f, -0.14961250f, 0.03526558f, -0.08622166f, -0.01852753f, -0.04184242f, 
    0.02586678f, 0.01424834f, 0.06080854f, 0.09727999f, -0.02284908f, -0.07769468f, 0.08969996f, -0.03187563f, 
    -0.04602689f, -0.04045845f, 0.12943920f, 0.07256644f, 0.00737484f, -0.12953974f, -0.02996331f, 0.00178244f, 
    -0.04403018f, 0.00267585f, 0.02160056f, -0.06471245f, -0.02386525f, 0.02582840f, 0.01811761f, 0.04845966f, 
    -0.01868676f, -0.07511574f, 0.01798670f, -0.02587504f, -0.06090423f, -0.03634112f, 0.12088547f, 0.05629201f, 
    0.13501339f, -0.09176886f, -0.05116716f, -0.00462955f, -0.03668600f, -0.03857395f, 0.03000088f, -0.06566069f, 
    -0.01357543f, -0.11454614f, 0.03981801f, 0.00555390f, -0.01396703f, 0.00812571f, 0.08021430f, 0.04372424f, 
    -0.05486797f, -0.04156794f, -0.02849422f, 0.09801438f, 0.02266216f, 0.04054225f, -0.01134771f, -0.08464735f, 
    0.01653176f, -0.01090552f, 0.08772186f, 0.01856840f, 0.10221421f, -0.03312912f, 0.09695690f, -0.00754690f, 
    0.04725402f, -0.02993040f, 0.05237643f, -0.05701045f, -0.05806720f, -0.03818256f, 0.07140784f, -0.03655951f, 
    0.08026838f, -0.01630032f, 0.01387766f, -0.03102228f, -0.00160135f, -0.06638943f, 0.05493236f, 0.00417139f, 
    0.04208805f, 0.05027726f, 0.00196815f, 0.00316115f, 0.05910404f, 0.01483567f, -0.09372150f, 0.00418587f, 
    -0.04052832f, -0.08013932f, 0.15661018f, -0.14573331f, 0.05839740f, -0.00756949f, -0.05328147f, 0.00273967f, 
    0.00372634f, -0.02303613f, 0.01753974f, -0.02250182f, 0.06452220f, -0.02410577f, 0.02900813f, -0.01994126f, 
    -0.02376960f, 0.01364216f, -0.14116113f, 0.03036834f, -0.10896254f, -0.25029784f, 0.07450806f, -0.10517569f, 
    -0.14259169f, -0.07878754f, -0.08415169f, -0.01190869f, -0.04076350f, -0.06427241f, 0.02663400f, -0.02156256f, 
    0.05492232f, -0.03148221f, 0.06751269f, 0.03420487f, -0.06921794f, -0.00408600f, 0.05651861f, 0.03790948f, 
    0.14290631f, 0.08992872f, -0.01721523f, 0.02057499f, -0.09703718f, -0.04087552f, 0.02164308f, -0.00215934f, 
    -0.09857371f, -0.03482071f, 0.00854019f, -0.04845192f, 0.04716882f, -0.01700991f, 0.05570850f, 0.02867025f, 
    -0.01895242f, -0.06846859f, 0.12194954f, -0.10604765f, 0.09078977f, 0.13154991f, 0.01758294f, 0.04611184f, 
    0.11925093f, 0.02160414f, 0.01855863f, -0.06566875f, -0.00806326f, -0.04097007f, 0.01680668f, -0.02009862f, 
    -0.00567463f, -0.08170881f, -0.02638922f, -0.05542333f, -0.00929813f, 0.06326314f, 0.03950205f, -0.00436557f, 
    0.13339281f, 0.03366310f, -0.10891188f, 0.09895569f, 0.01303422f, 0.01108303f, 0.00269606f, -0.00226981f, 
    -0.06468044f, -0.03975273f, 0.01998311f, 0.00838654f, -0.05290817f, -0.07440453f, -0.01621034f, -0.09125447f, 
    -0.04490674f, -0.03746143f, 0.04962267f, -0.04634876f, -0.07285069f, 0.03208842f, 0.14510408f, -0.05882578f, 
    0.08822910f, -0.01285158f, -0.05457747f, -0.01568271f, -0.02657472f, -0.02280226f, -0.05810780f, 0.03469691f, 
    0.00117456f, -0.03936999f, -0.01055753f, -0.05133003f, 0.01237223f, -0.01303548f, 0.04514854f, -0.06056966f, 
    -0.13348278f, -0.12417828f, 0.19525808f, -0.19115607f, -0.11126580f, 0.06086117f, 0.04012790f, -0.07055289f, 
    -0.12968673f, -0.07380348f, 0.01227181f, 0.03168705f, -0.02877291f, 0.07401987f, -0.00572626f, -0.07321431f, 
    0.02463881f, 0.00881222f, -0.16349646f, -0.03112515f, -0.11497602f, -0.07013427f, 0.18278496f, -0.00176781f, 
    0.06081150f, -0.05935524f, -0.03969170f, -0.00238901f, -0.03934469f, -0.01080981f, 0.05567544f, -0.00036196f, 
    -0.06662598f, -0.01278935f, 0.06268653f, -0.03081065f, 0.00060697f, -0.03505591f, 0.01547531f, 0.00759231f, 
    -0.07805197f, -0.07570394f, 0.10803246f, -0.07183170f, -0.07614608f, 0.01845629f, -0.03685994f, 0.02624242f, 
    -0.07843922f, 0.04794918f, 0.00683365f, 0.05793177f, -0.06372184f, 0.07064378f, -0.01249151f, -0.02188314f, 
    0.00635935f, 0.05408444f, -0.08411939f, -0.01724951f, -0.05671244f, -0.15928289f, -0.18915132f, -0.15072379f, 
    0.01843102f, 0.09214468f, 0.03168553f, -0.01371622f, -0.02428212f, -0.04221619f, 0.06519700f, 0.02190445f, 
    -0.00493144f, 0.01039478f, -0.02098689f, 0.00764734f, 0.02444527f, 0.05503697f, -0.03507825f, -0.03417077f, 
    -0.03402262f, 0.14001998f, 0.00164513f, -0.05063130f, 0.01398157f, -0.01034490f, -0.00645806f, -0.00818564f, 
    -0.10863458f, -0.03229078f, 0.07802918f, 0.09292687f, -0.02268319f, 0.00846512f, 0.02403408f, -0.05959458f, 
    -0.00318783f, -0.03285402f, 0.04643712f, -0.04511710f, -0.14281437f, -0.11091857f, -0.03253358f, -0.19535957f, 
    -0.04230493f, -0.00913814f, 0.03186247f, -0.04497934f, -0.06570119f, -0.07979002f, 0.01914407f, 0.02322526f, 
    0.02756873f, -0.01701121f, 0.00909451f, -0.02571255f, 0.11070297f, 0.09543656f, -0.06232487f, -0.03253637f, 
    -0.10799944f, 0.23708953f, -0.01019954f, -0.09937305f, -0.10937111f, 0.07161593f, -0.00311877f, -0.05977167f, 
    -0.07191975f, 0.01873225f, 0.03335842f, -0.01390214f, 0.02684799f, 0.04067619f, 0.04243219f, -0.03887521f, 
    -0.02511357f, 0.02287699f, -0.02979940f, 0.08818609f, 0.04092282f, 0.06926451f, -0.11677406f, -0.06200914f, 
    0.03489882f, 0.08957755f, 0.07162418f, -0.04384395f, 0.00172688f, -0.00921951f, 0.01437195f, 0.02768420f, 
    -0.02503861f, 0.06022608f, -0.02118034f, 0.02131883f, 0.04634030f, 0.03866778f, 0.04606766f, -0.02440146f, 
    -0.18508504f, -0.00945760f, 0.03370807f, -0.10790318f, -0.11622486f, -0.01715425f, -0.04349410f, -0.07224548f, 
    -0.05915136f, -0.09365298f, 0.00618413f, 0.03197582f, 0.00064289f, -0.00937768f, -0.08005875f, -0.02324655f, 
    0.03953470f, 0.02039200f, -0.14229272f, -0.04293307f, -0.11683736f, 0.08198822f, -0.22539316f, -0.18446957f, 
    -0.15647818f, 0.03386079f, -0.08797283f, -0.15825716f, 0.02877741f, -0.00870741f, 0.04139174f, -0.01419026f, 
    0.04260112f, -0.06169585f, 0.04666512f, 0.04327197f, 0.00118471f, -0.10204463f, 0.01071228f, 0.03182076f, 
    0.10215772f, 0.06924275f, 0.00178506f, -0.04256272f, 0.07601988f, 0.08137104f, -0.02970956f, -0.02106177f, 
    0.01688245f, -0.04034845f, 0.03019201f, 0.05485973f, -0.00153919f, 0.05644353f, -0.07237723f, 0.04229054f, 
    -0.01560894f, 0.05549397f, -0.01181219f, -0.00431127f, 0.07972533f, 0.07760206f, -0.06507449f, 0.08335403f, 
    0.05661734f, 0.04372038f, -0.00946991f, -0.06860400f, -0.00771194f, -0.04212271f, -0.03275689f, -0.04131003f, 
    -0.01507066f, -0.01735434f, -0.07439917f, -0.06058372f, 0.00590665f, 0.02106037f, 0.04696438f, -0.03004954f, 
    0.07679374f, 0.07767016f, -0.04763459f, 0.14582478f, 0.08106779f, 0.07388688f, 0.01721130f, -0.04153815f, 
    -0.09372334f, -0.06041535f, 0.03284711f, -0.02794680f, 0.06145504f, 0.01138272f, -0.02918625f, -0.05906834f, 
    -0.00137722f, 0.04078865f, 0.01085623f, -0.11945345f, -0.07611908f, -0.09156153f, -0.22987881f, 0.13228528f, 
    -0.03574594f, -0.04650843f, 0.04766085f, -0.06258436f, -0.04402499f, -0.01942233f, 0.09095039f, 0.02486109f, 
    0.04327929f, -0.05270859f, 0.03267309f, -0.04896850f, -0.00065765f, -0.03107269f, 0.11085152f, -0.05022419f, 
    -0.01080895f, -0.16079457f, -0.10870371f, -0.04808941f, 0.07539653f, 0.03626563f, 0.01754343f, -0.02438191f, 
    -0.01058626f, -0.01002701f, 0.05178697f, 0.02148507f, 0.04250896f, -0.00713397f, 0.06489556f, -0.00088718f, 
    0.09572172f, 0.06803245f, 0.03785966f, -0.02210642f, 0.02991159f, -0.08130793f, -0.06853218f, 0.11272819f, 
    0.11254778f, 0.05657129f, 0.01396458f, -0.00523270f, -0.03398335f, -0.02820731f, 0.00225795f, 0.04231931f, 
    -0.01395679f, 0.00473657f, 0.02634341f, -0.01527472f, -0.02585208f, 0.02345777f, 0.04585404f, -0.00608092f, 
    -0.12644422f, -0.13038132f, 0.05857819f, -0.17736845f, -0.12052818f, -0.07926460f, -0.03975273f, -0.12005869f, 
    0.03946528f, -0.06055199f, -0.00838016f, 0.09610779f, -0.03184064f, -0.06187496f, -0.14587873f, 0.00873249f, 
    0.03067444f, 0.10026892f, -0.01524900f, -0.02505037f, -0.32250157f, 0.02940154f, -0.04742872f, 0.10797925f, 
    -0.03245339f, 0.05877006f, 0.05837126f, -0.02280954f, 0.04608448f, -0.00193756f, 0.01513274f, -0.07675951f, 
    0.02572262f, 0.03906637f, 0.00804866f, 0.03033523f, -0.00513873f, 0.02237245f, 0.03553250f, -0.00887235f, 
    -0.30596945f, 0.10686762f, 0.02551452f, 0.00604790f, 0.02238203f, 0.04773890f, 0.06403953f, -0.06093648f, 
    -0.06238140f, -0.03084351f, -0.08604815f, -0.00169518f, -0.03380064f, -0.03711954f, 0.09807148f, 0.05079852f, 
    -0.02967686f, 0.07672625f, 0.04967996f, 0.03103027f, 0.02176475f, -0.17603317f, -0.02138371f, 0.07027800f, 
    -0.01344291f, 0.03946736f, 0.06847036f, 0.08287144f, 0.04032178f, -0.14135395f, -0.01131888f, 0.01144838f, 
    -0.05644750f, 0.03278884f, -0.17781396f, 0.00816626f, -0.00974222f, -0.08504962f, -0.11509382f, -0.06778806f, 
    0.11984905f, -0.04074961f, 0.23549479f, -0.05107088f, -0.25867486f, 0.00886137f, 0.04509201f, 0.08889880f, 
    -0.07424483f, 0.04509632f, -0.11837371f, 0.03195669f, -0.01161395f, -0.15671057f, 0.10825446f, -0.03733378f, 
    0.00014847f, -0.03225541f, -0.03651372f, -0.01617267f, -0.18833990f, -0.04946567f, -0.01082206f, 0.05316496f, 
    0.14812054f, -0.01316428f, -0.03487822f, 0.01637116f, -0.00263997f, 0.07303818f, -0.00277226f, -0.00813310f, 
    0.05568992f, -0.03823530f, -0.06049164f, 0.11936805f, -0.01299067f, 0.00813373f, -0.02001811f, 0.01985007f, 
    -0.30523998f, 0.08834368f, 0.01303781f, 0.11729904f, -0.03507238f, 0.06489687f, 0.04398323f, 0.05671081f, 
    0.01294150f, -0.06186591f, 0.05375393f, -0.01326506f, -0.00900325f, 0.06223745f, 0.04855264f, 0.03981698f, 
    -0.00334296f, 0.01179905f, -0.00235393f, 0.04012161f, -0.34431973f, 0.07931493f, 0.36009374f, -0.16745999f, 
    0.13467865f, 0.08980211f, 0.03514490f, -0.00592752f, 0.04302114f, -0.06123618f, 0.00589814f, 0.00852142f, 
    0.08502515f, 0.04982821f, -0.04031125f, 0.07437519f, 0.01437348f, 0.08326872f, -0.08541524f, 0.05334843f, 
    -0.22860733f, -0.26779976f, -0.02434291f, 0.28503105f, 0.00096720f, 0.00712703f, 0.04740372f, -0.01114976f, 
    -0.12482861f, -0.09705190f, -0.03569697f, 0.00231830f, -0.14570065f, -0.08655595f, 0.00030664f, -0.04517967f, 
    -0.05973221f, 0.05744338f, 0.03735216f, 0.07665326f, -0.02990984f, -0.02234227f, 0.11032953f, -0.13124879f, 
    -0.27119288f, 0.00998867f, -0.02342015f, 0.03291509f, -0.03655807f, 0.00327508f, -0.01011304f, 0.03911069f, 
    -0.00757952f, 0.08444490f, 0.00622774f, -0.05695471f, 0.02353706f, -0.00315185f, 0.12082844f, -0.00141027f, 
    -0.04552929f, -0.20670794f, 0.02482110f, -0.05341911f, 0.17028132f, -0.19512379f, 0.06865583f, 0.03994327f, 
    0.09116872f, -0.06745255f, -0.05794153f, -0.00579310f, -0.09987044f, -0.01785701f, -0.06375109f, -0.01248758f, 
    -0.04754308f, 0.11453810f, 0.01527363f, 0.17052637f, -0.19000560f, 0.24949686f, -0.00287308f, -0.10222159f, 
    -0.06381238f, -0.01654397f, 0.03051075f, 0.02036032f, -0.01577837f, 0.08376131f, -0.03998789f, -0.00208156f, 
    -0.02743198f, -0.01568285f, -0.06515752f, 0.05752173f, -0.06260665f, 0.00004531f, 0.08670463f, -0.01644827f, 
    -0.02834742f, 0.08522456f, -0.07129989f, 0.14703815f, -0.07741532f, 0.03430930f, 0.01420373f, -0.01071049f, 
    0.01659184f, 0.06676906f, -0.02934599f, 0.01071248f, 0.05556812f, -0.01993485f, 0.04078023f, 0.02563825f, 
    -0.08397948f, 0.00377938f, -0.05181513f, -0.06598902f, 0.42933732f, 0.07159958f, -0.07298908f, 0.05443475f, 
    -0.01763757f, -0.03441904f, -0.02929601f, 0.07598189f, 0.02336124f, -0.03695355f, -0.08203740f, -0.06666879f, 
    0.07966059f, -0.01892865f, 0.05354787f, 0.12107535f, 0.03125154f, -0.03801881f, -0.01046980f, 0.08092567f, 
    -0.18630613f, 0.14236553f, -0.12384050f, 0.06447855f, -0.08523627f, 0.02337828f, 0.03224634f, 0.02037923f, 
    -0.03593226f, 0.03669233f, -0.00330647f, 0.01567431f, -0.02450917f, 0.00648690f, 0.07653309f, 0.01232293f, 
    -0.01977069f, -0.06577358f, 0.06991495f, 0.01295912f, 0.06569788f, 0.17197247f, 0.08308605f, -0.43177402f, 
    -0.19124943f, -0.00299686f, 0.00612970f, -0.03889591f, -0.06685669f, 0.03310138f, 0.00075181f, -0.09949291f, 
    0.09249448f, -0.09568481f, 0.03397833f, -0.03583344f, -0.03693298f, 0.02761920f, 0.02524918f, 0.03186982f, 
    -0.21921290f, 0.23943190f, 0.03288551f, 0.17900045f, -0.03845486f, 0.11931039f, 0.00905252f, -0.03152772f, 
    -0.00389107f, 0.02230143f, -0.00599937f, 0.00304199f, 0.03285262f, -0.05118630f, 0.00871202f, 0.03645604f, 
    -0.05024518f, 0.05263993f, -0.01219805f, -0.02894252f, 0.10706744f, 0.01885630f, -0.12446731f, 0.08369607f, 
    0.01365050f, 0.14286302f, 0.01805628f, -0.01961450f, 0.07339176f, 0.13857275f, -0.11329874f, -0.01485760f, 
    0.02610011f, 0.01478889f, -0.07339643f, 0.05170333f, -0.03320969f, -0.01443860f, -0.03529043f, -0.05979764f, 
    0.02269647f, -0.18492591f, 0.05672830f, -0.05071042f, -0.05845284f, 0.09484762f, 0.02154667f, -0.04488998f, 
    -0.07553566f, -0.06600567f, 0.03998579f, -0.08631587f, 0.03729139f, 0.10973246f, 0.10507538f, -0.03609928f, 
    0.01569762f, -0.07150606f, -0.01683184f, 0.01732422f, 0.01836420f, -0.16909193f, 0.05535536f, -0.03476296f, 
    -0.08543932f, 0.02663410f, 0.00226840f, -0.04153316f, 0.00659144f, -0.00217649f, -0.05145533f, 0.04585742f, 
    0.05651764f, 0.06665923f, -0.00909142f, 0.00205287f, -0.00762301f, -0.19274965f, -0.06052965f, -0.15162966f, 
    0.00154503f, -0.09877422f, -0.13397925f, 0.14397763f, -0.13804477f, 0.09189648f, -0.02719517f, -0.00850698f, 
    0.02158938f, -0.03801452f, -0.04727194f, -0.01839343f, 0.03370079f, -0.04491549f, 0.13602050f, 0.01297214f, 
    -0.02558209f, 0.01876123f, -0.01641999f, 0.00801751f, 0.01042892f, -0.10843501f, -0.01136252f, 0.13975479f, 
    0.03473287f, -0.07386409f, 0.00058189f, -0.05104300f, -0.02164762f, 0.06194535f, 0.03014947f, 0.03488442f, 
    0.02859728f, -0.09064075f, 0.02796014f, 0.01837468f, 0.00533480f, -0.00143326f, 0.10660172f, 0.01636567f, 
    0.11477478f, -0.03524065f, -0.00229205f, -0.00547122f, -0.02520711f, 0.04900856f, 0.07499612f, 0.07418103f, 
    -0.01572222f, -0.16426270f, 0.07692802f, 0.07494979f, -0.04288910f, 0.01331291f, -0.09968126f, -0.03648763f, 
    0.01356643f, -0.07398159f, 0.01423287f, 0.01785493f, 0.00129986f, -0.06779578f, 0.09640311f, -0.04023097f, 
    0.09412494f, 0.04223044f, -0.06511657f, 0.05356387f, 0.00263702f, 0.03075072f, -0.00445604f, -0.00732147f, 
    0.09618556f, 0.16821566f, 0.01691870f, 0.03016341f, 0.06982201f, -0.00966919f, 0.03126872f, 0.02701580f, 
    0.08782835f, -0.25960219f, 0.02931935f, -0.03762025f, -0.05527508f, -0.05058651f, 0.05954073f, 0.05189747f, 
    -0.05696717f, -0.05628908f, 0.04482752f, -0.02983238f, 0.00703688f, 0.03912288f, -0.04833837f, 0.04322955f, 
    0.03867415f, -0.03839102f, -0.22110680f, -0.06236957f, 0.09200910f, 0.09700111f, -0.11221096f, -0.28689265f, 
    -0.20489699f, -0.00802511f, -0.01223177f, -0.03390932f, -0.04667497f, -0.05515162f, -0.14006907f, 0.02052930f, 
    -0.05220724f, 0.09945437f, 0.05041689f, -0.06176819f, 0.03642853f, 0.05606823f, 0.11031947f, 0.04772656f, 
    0.00816407f, -0.14169982f, 0.17515840f, -0.05094745f, 0.17672011f, 0.03656491f, 0.01008661f, 0.09282658f, 
    0.03368828f, -0.13464323f, 0.05134435f, -0.02788850f, 0.01620912f, 0.07679298f, -0.05931967f, 0.02523094f, 
    0.06161081f, 0.03705092f, -0.09089069f, 0.10801221f, 0.07956166f, -0.21260041f, -0.02908803f, 0.13460609f, 
    -0.05376560f, -0.03977729f, 0.03804363f, -0.07966176f, 0.07041788f, 0.00583850f, -0.02385160f, 0.09965523f, 
    -0.01412151f, -0.05963100f, 0.04534404f, -0.05305795f, 0.03296169f, -0.01202366f, 0.03082923f, 0.02647971f, 
    -0.06890869f, -0.13515936f, 0.10919068f, -0.04688662f, -0.10185875f, 0.03298924f, 0.02923309f, -0.14458977f, 
    0.01951697f, 0.04797595f, -0.05605968f, -0.02971006f, -0.07042821f, -0.01580444f, -0.06735755f, 0.00195404f, 
    -0.08684690f, 0.11926775f, 0.01179820f, 0.04209180f, 0.33479831f, -0.37255138f, -0.01334612f, -0.02235208f, 
    0.12478214f, -0.09744440f, 0.00845373f, 0.02905612f, 0.02038868f, -0.07589272f, -0.03589757f, -0.05765771f, 
    0.03815529f, 0.01676908f, -0.01742375f, 0.04945425f, -0.02599686f, 0.00555261f, -0.10313085f, 0.07328648f, 
    0.21625799f, -0.08051293f, 0.11153223f, 0.07670224f, 0.09839786f, 0.00972792f, -0.03756558f, -0.02851916f, 
    -0.04812112f, 0.09309169f, -0.09339861f, 0.00892128f, -0.06673064f, -0.00104756f, 0.02446948f, 0.02198711f, 
    -0.03723141f, 0.03753123f, 0.00435303f, 0.04532144f, 0.00913797f, 0.04800000f, 0.05455619f, -0.21295592f, 
    0.07039149f, 0.05637233f, -0.03175502f, -0.01796209f, 0.02732356f, 0.00043871f, 0.00321602f, -0.02586329f, 
    -0.02978758f, 0.08278625f, -0.00663888f, -0.03539819f, -0.00192309f, -0.03687416f, -0.05030672f, -0.00445368f, 
    -0.13570070f, 0.14048676f, 0.03961049f, 0.08758985f, -0.16614455f, -0.09747362f, 0.00674122f, 0.01764766f, 
    0.04569633f, 0.04720681f, 0.00993301f, 0.01276217f, 0.14419973f, 0.08821084f, 0.02875892f, 0.02888095f, 
    0.01094407f, 0.05607054f, -0.05623319f, 0.01190153f, -0.11146264f, -0.16977355f, -0.20805354f, 0.16023336f, 
    0.04070143f, 0.02148940f, -0.04347586f, -0.02352201f, 0.03741506f, 0.18421240f, -0.03511816f, 0.03168090f, 
    0.05164871f, 0.09669648f, -0.02161497f, -0.08362419f, -0.03244571f, -0.01587361f, -0.00688075f, 0.00355755f, 
    0.09678353f, -0.26169813f, 0.12363645f, -0.12193693f, 0.14543025f, 0.05194981f, 0.00277192f, -0.10496923f, 
    0.03285937f, -0.05419705f, 0.02499983f, 0.04223333f, -0.07150064f, 0.04491279f, 0.00517976f, 0.03066126f, 
    0.05436556f, -0.05710081f, -0.05065074f, 0.01835264f, -0.06675348f, -0.07821814f, 0.13276811f, -0.12684023f, 
    -0.06690020f, -0.13625890f, 0.00886993f, -0.12875357f, 0.00106522f, 0.00762245f, 0.03005223f, -0.00651877f, 
    0.03660622f, -0.09564192f, -0.03703856f, 0.00098580f, 0.10006078f, 0.07297411f, -0.04623771f, -0.00574486f, 
    -0.45824108f, 0.17332077f, 0.20241934f, -0.25050235f, 0.00536497f, -0.00022980f, 0.06536383f, 0.00088065f, 
    -0.02824105f, 0.06018626f, -0.01627789f, -0.01124171f, 0.01036130f, -0.06389409f, 0.04100822f, 0.00062868f, 
    -0.01432080f, 0.08814965f, -0.09201305f, -0.00761378f, -0.26032278f, -0.35682222f, 0.23556873f, -0.25690469f, 
    -0.00720777f, -0.01101913f, 0.07506187f, 0.00689357f, 0.15621094f, 0.01715277f, -0.10349211f, -0.04176343f, 
    0.07907286f, -0.01263435f, -0.04995390f, -0.07127158f, 0.06100307f, -0.04056212f, 0.07179401f, -0.05134325f, 
    -0.18116887f, -0.14972487f, 0.02771456f, 0.21474849f, 0.04517050f, 0.07110209f, -0.00085052f, -0.07048594f, 
    -0.00631660f, 0.12263540f, -0.04060858f, -0.00091088f, -0.05310280f, 0.02689998f, -0.07178458f, -0.05403528f, 
    -0.12371706f, 0.05277017f, -0.03705193f, -0.01701050f, 0.35224748f, -0.08861604f, -0.03883271f, 0.03045362f, 
    0.05194813f, 0.10839687f, -0.06101155f, -0.01937374f, -0.06032636f, 0.05960733f, -0.04746768f, 0.02925063f, 
    -0.06558266f, 0.05156886f, -0.03635146f, -0.06827693f, -0.07517208f, -0.03946945f, -0.08271626f, -0.04460338f, 
    -0.27390599f, -0.03293088f, 0.08323037f, -0.24624419f, 0.05152628f, -0.04273535f, 0.08830053f, -0.13060901f, 
    -0.01418727f, 0.04629076f, -0.13082147f, -0.05004226f, 0.00588565f, -0.07329137f, 0.05428018f, 0.10172711f, 
    0.06831915f, -0.05745570f, -0.00276784f, -0.00375287f, 0.25115576f, -0.05562604f, -0.08960731f, -0.04083228f, 
    0.06561368f, 0.02288603f, 0.03546483f, -0.03798663f, -0.05924794f, -0.03232345f, -0.02619329f, 0.03792104f, 
    -0.09065413f, -0.02961624f, -0.02919391f, 0.00091044f, 0.02571839f, -0.00953246f, -0.00272577f, 0.10537244f, 
    0.11232034f, -0.05886752f, -0.00995764f, 0.03009579f, -0.04266167f, 0.02357651f, -0.01071336f, 0.04313206f, 
    0.05107602f, -0.02885493f, -0.01691326f, 0.05555590f, 0.06942105f, -0.01144314f, -0.01325234f, 0.08964005f, 
    -0.02679116f, 0.08080918f, 0.00775613f, 0.10259786f, -0.00141980f, -0.13319850f, 0.05354200f, -0.01060025f, 
    0.26622367f, 0.11212937f, -0.04658751f, 0.04294189f, 0.02366346f, 0.13687892f, 0.01474718f, -0.01776996f, 
    0.06345870f, 0.05748950f, -0.03926541f, 0.02110558f, 0.08146705f, 0.02370740f, -0.02257362f, -0.13606541f, 
    -0.56585318f, 0.32752445f, -0.00413898f, 0.03837983f, 0.10893660f, 0.10141103f, 0.03652193f, -0.03247001f, 
    0.05661622f, 0.10651346f, -0.04202893f, -0.04251794f, -0.03680192f, -0.02133942f, 0.03964640f, 0.18553545f, 
    0.01659087f, 0.12403760f, 0.03978263f, 0.05527985f, 0.01632854f, -0.09738068f, 0.02635882f, -0.00443916f, 
    -0.00712115f, -0.00127328f, 0.10886530f, -0.00038917f, -0.00860358f, -0.15345657f, 0.01093218f, -0.02485625f, 
    -0.09142034f, 0.02875461f, 0.00171064f, -0.02537174f, 0.04092597f, -0.07147879f, -0.00899613f, -0.05312027f, 
    -0.28575915f, 0.07443346f, -0.08039074f, 0.02912822f, -0.03849923f, 0.09471282f, 0.03941553f, 0.01064830f, 
    -0.00936498f, -0.02131713f, 0.00727483f, -0.01631472f, -0.02377515f, 0.00565934f, 0.00609983f, 0.04379867f, 
    -0.00010220f, 0.04726148f, -0.08829565f, -0.00214157f, 0.22849689f, 0.07608632f, -0.08741435f, -0.08367515f, 
    0.10367248f, 0.06743071f, -0.04527530f, -0.02612856f, 0.02458596f, 0.09760123f, -0.03408777f, -0.13027024f, 
    -0.00735062f, 0.06200474f, 0.00667928f, 0.03770437f, -0.05508960f, 0.04212009f, 0.07705902f, -0.05542819f, 
    0.18721452f, -0.11331386f, -0.10879973f, 0.11191310f, 0.02723318f, -0.01020807f, 0.03939598f, 0.02724505f, 
    -0.05744040f, 0.04995966f, -0.03941456f, -0.06291912f, 0.03809096f, 0.10248854f, 0.10777530f, 0.09709387f, 
    -0.07387108f, -0.02691492f, 0.05503675f, 0.00424505f, -0.01138516f, -0.20146187f, -0.06208098f, 0.09515531f, 
    0.05213295f, 0.00867236f, 0.00730204f, -0.01879474f, -0.03478644f, 0.10677062f, 0.02060823f, 0.00642005f, 
    0.01764066f, -0.00126738f, 0.03727382f, -0.01488588f, -0.04842380f, -0.02722140f, 0.05492916f, -0.01958467f, 
    0.05345198f, -0.44650814f, -0.03275294f, 0.09125169f, -0.13040747f, -0.21777357f, 0.03222429f, 0.04138146f, 
    0.18644521f, -0.02788258f, -0.12696236f, 0.05479430f, -0.00049496f, -0.04024483f, -0.02993091f, 0.02347614f, 
    0.13550532f, 0.10299525f, 0.03866815f, 0.03365882f, -0.16446583f, -0.10294474f, 0.10512468f, -0.19692884f, 
    -0.25301275f, -0.09123167f, 0.00174993f, -0.03297256f, -0.02667503f, 0.04305090f, -0.01283693f, -0.00608963f, 
    0.02907336f, -0.04143031f, -0.04623498f, -0.09520878f, -0.03801384f, 0.04056213f, 0.01758191f, -0.01979750f, 
    0.27992919f, 0.19424245f, -0.12347689f, -0.06314304f, -0.04781496f, -0.06729358f, -0.01043748f, -0.05890299f, 
    0.12710387f, -0.13158642f, -0.00610683f, 0.09677704f, 0.01816964f, -0.03688355f, 0.07175937f, 0.07708564f, 
    0.07969844f, -0.02108167f, -0.04793301f, 0.11181223f, -0.01534968f, -0.07467764f, -0.03348732f, -0.14236608f, 
    -0.25944889f, -0.09051670f, 0.05282021f, -0.05926560f, 0.00691392f, -0.00496452f, -0.04039565f, -0.01331030f, 
    -0.00347396f, -0.03794990f, 0.03444133f, -0.00919597f, 0.07429238f, -0.00809562f, -0.01331149f, 0.01351423f, 
    -0.16003178f, -0.01913599f, -0.04071261f, 0.19264321f, -0.15543050f, 0.02615194f, 0.06410077f, -0.04541573f, 
    -0.04498786f, 0.06215037f, 0.00851271f, 0.06991214f, 0.07747563f, 0.16544378f, 0.05504901f, -0.06050371f, 
    -0.08761486f, -0.10135828f, 0.02374679f, -0.02682095f, 0.14241329f, 0.00378611f, 0.16242614f, -0.25521645f, 
    -0.29820281f, 0.02085365f, -0.02335522f, 0.06958137f, -0.02926297f, 0.06841350f, -0.03497763f, -0.07054622f, 
    -0.04542132f, -0.17349537f, -0.00514037f, -0.02478655f, 0.03340924f, -0.09004524f, -0.01006937f, -0.04011317f, 
    0.20331548f, -0.07364104f, -0.18167160f, -0.24373543f, -0.17093511f, -0.00487135f, 0.07426336f, -0.02133034f, 
    0.00070561f, -0.11307952f, -0.01632397f, -0.04428164f, 0.02501276f, 0.07704034f, -0.05104984f, -0.01968299f, 
    0.09986538f, 0.03270661f, -0.11677634f, 0.02339023f, -0.05324397f, -0.17237040f, -0.01301469f, 0.00703636f, 
    -0.04151621f, -0.06438302f, 0.02629134f, 0.06480625f, 0.03686338f, -0.06048223f, -0.07464387f, -0.04938357f, 
    0.00119965f, -0.02610803f, -0.06550545f, 0.01792409f, 0.06623346f, 0.05840481f, 0.05182420f, 0.01442405f, 
    0.16104823f, 0.01665139f, -0.02217326f, -0.31152606f, -0.16658227f, 0.00211948f, 0.01759511f, 0.05066460f, 
    0.07712334f, -0.05635475f, 0.01308056f, -0.02981221f, 0.04738577f, 0.02459714f, -0.04751889f, 0.08544089f, 
    0.05547475f, -0.12427103f, 0.05466744f, -0.07694989f, 0.02489630f, -0.06881242f, 0.08529252f, 0.07183361f, 
    -0.09481434f, -0.00750967f, 0.01065258f, 0.01996014f, -0.06961425f, -0.06097084f, 0.00680930f, 0.04832627f, 
    -0.01210784f, -0.00805205f, 0.00901183f, 0.04654291f, -0.06857307f, 0.00544033f, -0.13368954f, -0.03446743f, 
    0.15429446f, -0.03537935f, -0.06892138f, 0.02788555f, -0.14587514f, 0.01705285f, 0.03955507f, -0.00976266f, 
    0.03458586f, 0.01360159f, -0.00677058f, -0.00842592f, -0.08845561f, -0.00032956f, -0.04284152f, 0.10862811f, 
    -0.01844239f, 0.02522165f, 0.02310853f, 0.08792698f, -0.43356156f, 0.13515201f, 0.16612735f, -0.12101378f, 
    -0.10706247f, 0.07693196f, 0.07553191f, -0.02144604f, 0.00519013f, -0.01887482f, -0.03820097f, 0.02454425f, 
    -0.05215914f, -0.02165990f, 0.05412117f, 0.06464380f, 0.00629220f, 0.16157582f, -0.12310267f, 0.01575869f, 
    -0.09261622f, -0.07534022f, 0.06805163f, -0.09092212f, -0.17557521f, -0.04098679f, 0.07809071f, -0.04177337f, 
    -0.00114133f, 0.03047742f, -0.00879827f, 0.01896108f, -0.05391188f, -0.11100554f, -0.05716185f, -0.05415597f, 
    -0.04380479f, -0.00525391f, 0.01370181f, -0.00044819f, 0.23049003f, -0.38049436f, 0.21480992f, -0.06880879f, 
    -0.02563024f, 0.03876843f, 0.00645472f, -0.05228733f, -0.03084057f, 0.01703696f, -0.02689082f, 0.00224179f, 
    0.07755299f, -0.11383081f, -0.00076269f, -0.00166982f, 0.05682382f, -0.03705320f, 0.02219526f, 0.06782695f, 
    -0.33553693f, -0.11305131f, 0.23216887f, 0.09218181f, -0.17239037f, 0.01974061f, -0.03034436f, 0.02657783f, 
    0.02693681f, 0.03288244f, 0.00580198f, 0.03163416f, -0.02938654f, 0.05065257f, -0.00008846f, -0.02432110f, 
    -0.05779318f, -0.03727478f, -0.10630791f, -0.07036266f, -0.25820225f, -0.21185733f, 0.04401852f, 0.04413142f, 
    0.23882821f, 0.01590518f, 0.05519133f, 0.01897913f, -0.02705074f, -0.06538752f, 0.03769827f, -0.02799057f, 
    0.01050167f, 0.04427816f, 0.04210670f, 0.05742173f, 0.00011950f, -0.02953346f, 0.03918725f, -0.00617439f, 
    -0.00197063f, -0.04750167f, 0.03401411f, 0.05219222f, 0.04295567f, 0.05689549f, 0.08288103f, 0.05574196f, 
    0.03326935f, 0.05004099f, -0.01867044f, 0.04605842f, -0.00617713f, 0.05334948f, 0.05872978f, 0.02505315f, 
    0.00369065f, -0.10442729f, 0.00511978f, 0.01817867f, -0.34477583f, -0.18758471f, -0.09856157f, -0.07007096f, 
    -0.15395382f, 0.05401108f, 0.01322378f, -0.09016546f, -0.01344790f, -0.00534663f, -0.00010564f, -0.10469212f, 
    -0.08377891f, -0.03742784f, 0.02306528f, 0.00271722f, -0.03674132f, 0.05295789f, 0.04275455f, 0.01576746f, 
    -0.50825608f, -0.33900559f, -0.26247588f, -0.06046679f, -0.07110673f, 0.08002197f, 0.00106891f, -0.06783151f, 
    -0.05296357f, -0.07918935f, 0.02959322f, 0.04514940f, -0.02147693f, 0.11402205f, -0.03222316f, 0.03135627f, 
    0.01218250f, 0.03773191f, -0.01267448f, -0.01504382f, -0.02757469f, 0.13472699f, 0.00408606f, 0.08300992f, 
    0.04770441f, 0.02645643f, -0.00551469f, 0.04392252f, -0.01942617f, -0.00735880f, -0.04399421f, -0.02860877f, 
    0.00231047f, 0.04153477f, -0.03789711f, 0.00017811f, -0.00588661f, -0.04952907f, -0.02527702f, 0.00181193f, 
    -0.33348444f, -0.23967227f, -0.04039066f, -0.00768972f, 0.17807673f, 0.04034149f, 0.04394037f, 0.00720037f, 
    -0.02626447f, -0.08711677f, 0.02821445f, -0.03274562f, -0.00896981f, 0.01483942f, -0.00043383f, 0.06616810f, 
    0.01858204f, 0.05912524f, 0.01417358f, -0.04537001f, -0.24766016f, -0.20945337f, -0.16423212f, -0.02344299f, 
    -0.04223994f, 0.00851244f, 0.01136610f, 0.03244988f, -0.00860859f, -0.04273952f, 0.07445855f, 0.01312693f, 
    -0.07209296f, -0.02239609f, 0.06652986f, 0.00119845f, 0.01793088f, 0.03862454f, 0.12836653f, 0.02593631f, 
    0.20951973f, 0.05580422f, -0.04237403f, -0.07786284f, -0.07185049f, 0.07078316f, -0.02454211f, 0.14850716f, 
    0.05043241f, 0.03114453f, -0.09745972f, -0.07883476f, 0.00410174f, -0.06306793f, -0.03043307f, 0.01060515f, 
    0.01297371f, -0.15366536f, 0.01710971f, 0.01237649f, -0.08968782f, -0.00440782f, 0.01917751f, -0.05384446f, 
    -0.07141602f, 0.05015789f, 0.02417217f, -0.02102350f, 0.00837532f, 0.02785689f, 0.01875894f, 0.02634243f, 
    0.00077922f, 0.02192289f, 0.01350057f, 0.07535151f, 0.06273273f, 0.07915940f, 0.04305002f, 0.06235390f, 
    0.15603738f, 0.11971765f, -0.11989442f, 0.07011637f, 0.07250511f, 0.02080211f, 0.01443622f, 0.02659256f, 
    0.01020935f, 0.00028815f, 0.02786766f, -0.01544456f, 0.00699493f, -0.04035075f, 0.10731246f, 0.01931363f, 
    -0.00506501f, -0.07251777f, -0.00023419f, -0.03068576f, 0.09478609f, -0.04991192f, 0.03096594f, 0.00405083f, 
    0.11677345f, 0.05048167f, 0.05948839f, 0.03494529f, 0.01370869f, -0.00283466f, -0.01470510f, 0.02536735f, 
    0.04750844f, -0.02927248f, -0.04546755f, 0.05637852f, 0.02786720f, -0.13243978f, -0.01170312f, 0.00673603f, 
    0.13587691f, 0.00703583f, -0.06434268f, 0.00419611f, 0.05137787f, -0.05833627f, 0.00183528f, 0.00719053f, 
    0.00984865f, -0.00201836f, -0.01386991f, -0.02858083f, -0.05476473f, -0.07086185f, 0.02709216f, -0.05050191f, 
    0.04293055f, 0.05469899f, 0.04947020f, 0.05298724f, -0.19999728f, -0.04413278f, 0.13138811f, 0.09231828f, 
    0.09353027f, 0.02286960f, -0.02160275f, 0.08671715f, -0.02866745f, 0.08467304f, -0.02370288f, 0.04519244f, 
    0.04609424f, -0.03598719f, 0.04373160f, -0.01165321f, -0.06344493f, -0.01851986f, 0.03322115f, -0.00917126f, 
    -0.05062326f, -0.08707249f, -0.00108733f, -0.00138948f, 0.10923571f, 0.04152084f, 0.02338792f, 0.00171832f, 
    -0.01991510f, -0.00135548f, 0.03758952f, 0.00502207f, -0.00032246f, 0.04445963f, -0.00227998f, 0.07292702f, 
    -0.00407872f, -0.00587179f, -0.02775829f, -0.00502354f, -0.16217220f, -0.14315966f, -0.10111897f, -0.07644286f, 
    -0.04991176f, 0.03698559f, -0.02698001f, -0.05741598f, -0.01451892f, 0.02466422f, 0.00103156f, -0.00697929f, 
    0.06713475f, 0.04131817f, -0.02376522f, 0.05521310f, 0.06718841f, -0.01816382f, 0.02872312f, -0.04007337f, 
    0.05465251f, 0.08588426f, -0.07627666f, 0.02708186f, -0.04030481f, 0.01055419f, -0.04276836f, 0.02033464f, 
    0.06701353f, 0.02047048f, 0.02678958f, -0.01563433f, -0.01446207f, 0.03276141f, 0.04266407f, 0.03717471f, 
    0.03429264f, 0.01937285f, 0.10402340f, 0.03047284f, 0.08416134f, 0.04165452f, -0.00322061f, 0.07177183f, 
    -0.02639446f, -0.07973945f, -0.01392460f, 0.00031510f, 0.04440049f, -0.02142362f, 0.02601116f, -0.01585357f, 
    0.03565964f, -0.09620825f, -0.02185338f, -0.02519076f, -0.02079863f, 0.05829466f, 0.04689108f, -0.03950474f, 
    -0.33239916f, 0.08205251f, -0.19730233f, -0.06118765f, 0.04583577f, 0.10944357f, 0.02556067f, -0.06081782f, 
    -0.02096884f, 0.03375154f, 0.02312019f, 0.04849654f, 0.01118866f, -0.03887096f, 0.09542125f, -0.06121289f, 
    0.01142693f, 0.17177087f, 0.02153328f, 0.04053001f, -0.34320313f, 0.02869973f, -0.06393490f, -0.10288271f, 
    -0.05986205f, 0.11322356f, 0.01652898f, -0.05757650f, -0.02165405f, 0.05778299f, 0.05190691f, 0.01340564f, 
    0.00226616f, -0.04029193f, 0.05087393f, -0.00258989f, 0.01953515f, 0.06011423f, -0.00106207f, 0.06317589f, 
    0.14044563f, 0.00281580f, -0.05769055f, -0.04824908f, 0.09932740f, -0.05136679f, 0.03902061f, 0.02565483f, 
    0.00717618f, -0.02414505f, 0.00693997f, -0.03765878f, -0.05584057f, -0.10348102f, -0.01979384f, -0.08922897f, 
    0.04542007f, 0.10070197f, 0.05000337f, 0.07191624f, 0.18047579f, 0.18178497f, 0.02808947f, -0.10688642f, 
    -0.01526591f, 0.12493974f, 0.02475031f, 0.09192298f, 0.05447086f, 0.01862527f, -0.04906759f, 0.01396820f, 
    0.01131105f, 0.00403639f, -0.06352690f, 0.07874926f, 0.00722629f, -0.00208896f, -0.08647060f, 0.07523250f, 
    -0.23242694f, -0.16986839f, -0.06645264f, -0.06937978f, -0.05749186f, -0.00547747f, 0.06811100f, -0.08183806f, 
    0.00247147f, 0.02280021f, -0.00180715f, -0.10858423f, 0.00394440f, 0.01302884f, 0.08988841f, -0.02819268f, 
    -0.01776573f, 0.07602221f, 0.04248727f, 0.07672563f, 0.09842429f, 0.02407739f, -0.07120096f, -0.03198684f, 
    0.05618663f, -0.10521165f, 0.02026471f, -0.14597246f, 0.05751713f, -0.05373555f, -0.00069039f, 0.09711690f, 
    -0.05893712f, -0.13978587f, 0.02804210f, -0.06615297f, -0.08636620f, 0.05427699f, -0.07903265f, 0.02240748f, 
    -0.31026942f, -0.02783360f, -0.08088960f, -0.04955284f, -0.03190531f, 0.10433375f, 0.04196057f, -0.06009300f, 
    -0.06036996f, 0.00042448f, 0.02173030f, -0.01216179f, -0.05510550f, -0.04284944f, 0.08073154f, -0.00513898f, 
    -0.02825929f, 0.06835563f, 0.00460649f, -0.01655544f, -0.02510312f, 0.06431838f, 0.01625826f, -0.07930107f, 
    -0.15618986f, 0.07193404f, 0.04182368f, -0.06423955f, 0.00690484f, 0.01721573f, 0.01209224f, 0.02536895f, 
    0.03152962f, -0.00559245f, -0.00328369f, 0.06733850f, 0.10703875f, -0.00871368f, -0.00981779f, 0.04717156f, 
    -0.18740827f, -0.08023138f, -0.10795048f, 0.09117796f, -0.07000169f, -0.04238838f, 0.03186801f, -0.06734464f, 
    -0.03630961f, -0.02740641f, -0.00606646f, 0.04108950f, 0.03400086f, -0.12311641f, 0.12917976f, -0.01485290f, 
    0.00976936f, -0.09827474f, 0.02102921f, -0.09891730f, 0.16917136f, -0.05696791f, -0.05307560f, 0.04068742f, 
    0.00618428f, -0.08684624f, -0.00153694f, -0.08783406f, -0.00769870f, -0.00443834f, 0.01471128f, 0.06074915f, 
    -0.03924273f, 0.00382913f, -0.04618556f, -0.02208562f, 0.05704505f, 0.01306525f, -0.13327818f, 0.06147462f, 
    -0.37160331f, -0.27535605f, -0.18394342f, -0.20009595f, -0.12199244f, 0.07709468f, 0.06240659f, -0.14813843f, 
    -0.04160743f, 0.06465128f, -0.00111296f, -0.07285634f, -0.06089109f, 0.04368252f, 0.05632230f, 0.00572355f, 
    0.01138264f, 0.07247841f, 0.03045153f, 0.02876936f, -0.12453058f, 0.01051054f, -0.16084464f, 0.09279279f, 
    0.09732547f, 0.01523211f, -0.00550870f, -0.08659036f, -0.00729333f, 0.05067345f, 0.00867431f, 0.01021185f, 
    0.08190750f, -0.03558606f, 0.12079482f, 0.06983294f, 0.04864581f, 0.03963328f, -0.06406052f, -0.00704225f, 
    0.15587534f, 0.07949947f, -0.05187779f, 0.00262205f, -0.08345289f, 0.04803917f, 0.00448326f, 0.04644786f, 
    -0.01447073f, 0.01340822f, -0.00956949f, 0.04049062f, 0.01966562f, -0.04967923f, -0.03294455f, 0.02780977f, 
    0.05047670f, -0.06442215f, -0.06940167f, 0.03559658f, -0.17253225f, 0.04925802f, -0.11994620f, -0.00736031f, 
    -0.00223116f, 0.03809774f, 0.04844143f, -0.00665473f, 0.02298197f, 0.03448703f, 0.03200844f, 0.03836681f, 
    0.06809116f, -0.04383858f, 0.03478089f, -0.01653557f, 0.04090443f, 0.05914117f, 0.02629753f, 0.07782811f, 
    -0.23046699f, -0.16193733f, 0.03675095f, 0.04203539f, 0.15999757f, 0.03388287f, 0.06353351f, 0.06639804f, 
    -0.01498835f, -0.09785543f, -0.01159968f, 0.00441643f, 0.00526257f, -0.04100881f, 0.03890686f, -0.07469951f, 
    0.00779008f, -0.02400469f, -0.01578343f, 0.00054796f, 0.20441829f, 0.11093201f, -0.13664703f, 0.05708969f, 
    -0.09054644f, -0.14560597f, -0.12075057f, 0.00727612f, -0.02224826f, -0.08117778f, 0.01689999f, 0.02877326f, 
    -0.10556287f, -0.02393135f, -0.07061321f, -0.05701879f, -0.04735688f, 0.01567107f, -0.01229907f, -0.06694387f, 
    -0.38523471f, -0.06823000f, -0.16237038f, -0.03444305f, -0.00666809f, 0.02338464f, 0.06292816f, -0.06687354f, 
    -0.00653766f, 0.04144259f, 0.00914330f, -0.00473235f, 0.02709948f, -0.02375402f, 0.03844875f, 0.00257045f, 
    -0.02143436f, 0.03035095f, 0.02909722f, 0.01781724f, -0.00682390f, 0.09225667f, 0.16311912f, 0.13996156f, 
    -0.03378529f, 0.02680162f, -0.02140407f, 0.00714704f, 0.01097393f, -0.04000168f, -0.01082846f, -0.01261892f, 
    -0.00059363f, -0.01843584f, -0.01486291f, -0.04200204f, -0.10516156f, -0.19983283f, -0.08809166f, -0.03020271f, 
    -0.34012353f, -0.24622042f, -0.18294586f, -0.07876640f, -0.05126863f, 0.06210491f, -0.01883628f, 0.00798064f, 
    -0.05927014f, 0.02193731f, 0.06682284f, 0.00379631f, 0.00017973f, -0.02324439f, 0.01916283f, -0.03164182f, 
    -0.13910642f, -0.02765195f, 0.07694514f, -0.03246235f, 0.03087715f, -0.02775703f, -0.07159841f, -0.02228359f, 
    0.02629323f, 0.03975129f, -0.03605916f, 0.07177483f, 0.06116442f, -0.07071647f, 0.00331580f, 0.05664387f, 
    0.00108476f, 0.03627812f, 0.00620055f, -0.00293852f, 0.09769608f, -0.07997080f, 0.10503702f, 0.08022176f, 
    0.21061939f, 0.12714791f, -0.05789036f, 0.06304307f, -0.11896011f, -0.06469546f, -0.06651933f, 0.06123320f, 
    0.01080335f, -0.02353779f, -0.01221153f, 0.01437022f, 0.00420543f, -0.04955655f, 0.01129898f, 0.03673581f, 
    0.02619347f, -0.02274331f, -0.03668891f, -0.03819476f, 0.12067690f, 0.11874124f, -0.02896617f, 0.03171872f, 
    -0.02831455f, -0.08122810f, -0.07561293f, 0.07678812f, 0.09370861f, -0.00187834f, 0.00819479f, -0.03040823f, 
    -0.02165555f, -0.06488719f, -0.01250358f, 0.00986062f, 0.00468514f, 0.12261784f, -0.02498421f, 0.03352507f, 
    -0.38961348f, -0.05576732f, -0.07775796f, -0.11775041f, -0.12282584f, 0.09321353f, 0.02503671f, -0.01534474f, 
    -0.03315302f, 0.02312735f, 0.02680132f, 0.03493371f, -0.03448712f, -0.07219838f, 0.02021153f, -0.06002850f, 
    -0.11505793f, -0.04094426f, -0.01214505f, -0.01655443f, 0.03862594f, 0.06288473f, 0.00880664f, -0.02047727f, 
    -0.01629251f, 0.06507123f, -0.00681830f, 0.06188883f, 0.07361124f, 0.00478383f, -0.02135177f, 0.01802355f, 
    0.00329310f, 0.01328398f, 0.03940049f, 0.01402031f, 0.03266423f, 0.08797655f, 0.04859375f, 0.06943091f, 
    -0.00415695f, 0.17345770f, 0.04877366f, -0.06654990f, 0.05767892f, 0.01940704f, 0.04867614f, 0.03532337f, 
    0.02141202f, -0.00600310f, -0.02881087f, 0.00205662f, -0.00061897f, 0.04254641f, 0.01990409f, 0.09692114f, 
    0.11352474f, 0.06015234f, -0.05253560f, 0.12775855f, 0.01059735f, 0.18044360f, -0.11748143f, 0.11778884f, 
    0.00425187f, 0.02006617f, 0.00124271f, -0.08228344f, -0.00763788f, -0.00432497f, -0.03998501f, 0.00281619f, 
    -0.02484611f, -0.06962527f, -0.00982632f, -0.08672318f, -0.08487670f, -0.01650576f, -0.03426540f, -0.03249343f, 
    -0.18602142f, -0.04976422f, -0.04435517f, 0.00332912f, -0.18747309f, 0.00944682f, 0.07047962f, 0.06216323f, 
    0.00391867f, -0.04248456f, 0.11549649f, -0.01725655f, 0.00208547f, -0.08466082f, 0.02227066f, 0.04631596f, 
    -0.04125906f, 0.00935450f, 0.10831372f, -0.01579267f, -0.26855683f, -0.18933117f, -0.05988914f, -0.09135234f, 
    -0.12069674f, 0.05819337f, 0.07890299f, -0.03922421f, -0.02542192f, 0.01895151f, -0.01852496f, -0.07218486f, 
    -0.00528782f, 0.02168085f, 0.04220472f, -0.02653723f, -0.02531338f, 0.07609222f, 0.02414728f, 0.03405242f, 
    -0.20813073f, -0.17569059f, -0.00180957f, -0.05006667f, -0.07865627f, 0.03457078f, 0.06383980f, 0.03610950f, 
    -0.03629840f, -0.04269679f, 0.05491604f, 0.01158735f, 0.01134376f, -0.06526635f, 0.06514283f, -0.00114448f, 
    0.04363828f, 0.07786647f, 0.07549375f, 0.06781937f, 0.11490060f, 0.08262493f, 0.03397894f, 0.02620912f, 
    -0.03778319f, -0.05667420f, -0.06515492f, 0.00855943f, 0.02658168f, 0.03865718f, 0.01932769f, 0.05519664f, 
    -0.06914920f, -0.03646566f, -0.06439810f, -0.06072180f, -0.05784260f, 0.06085953f, 0.00173313f, -0.01762878f, 
    0.16139005f, 0.05630411f, -0.00871284f, -0.04249428f, -0.05763291f, -0.01105359f, -0.05492854f, 0.01144965f, 
    -0.09592038f, 0.00782329f, 0.00392227f, 0.02397384f, -0.07787378f, -0.04130301f, -0.08699158f, 0.02279277f, 
    -0.03526539f, -0.08321779f, -0.09630682f, -0.03654755f, 0.17571427f, 0.04529703f, -0.08342142f, 0.00632165f, 
    -0.02747929f, -0.06636539f, -0.02662606f, -0.02163845f, 0.03686279f, -0.01724631f, 0.02434941f, 0.00500247f, 
    -0.04671158f, -0.02307203f, -0.02133375f, -0.03498003f, -0.02147854f, -0.02439322f, -0.08450755f, -0.02315959f, 
    0.07191424f, -0.10330026f, 0.06708261f, 0.08006307f, -0.04476761f, -0.04022303f, 0.07129262f, -0.08321224f, 
    0.00902028f, -0.04915840f, 0.05763163f, 0.09339350f, -0.05414077f, 0.07067500f, 0.08483173f, -0.09617810f, 
    -0.10482474f, -0.11671839f, -0.18776481f, -0.05923820f, -0.02635481f, 0.03857937f, 0.16457121f, -0.01638762f, 
    -0.11123904f, 0.09391198f, 0.00335725f, 0.04346611f, 0.00383172f, 0.02621761f, -0.00884858f, 0.01332446f, 
    0.03756476f, 0.08901674f, 0.01574038f, 0.03342660f, 0.03439029f, 0.03618174f, -0.07134222f, -0.03362237f, 
    -0.22011790f, -0.12826048f, 0.04173301f, -0.06059854f, -0.00503881f, 0.05567941f, 0.04794985f, 0.04294167f, 
    -0.04791858f, 0.10603959f, -0.02291544f, -0.01581539f, 0.00963092f, -0.05019182f, 0.04557825f, -0.04717781f, 
    0.00808063f, 0.09337833f, 0.09789477f, 0.07890886f, -0.07478329f, 0.09150023f, 0.21613458f, -0.05392397f, 
    -0.22731547f, 0.07201556f, -0.02488030f, 0.00087849f, -0.01427231f, 0.01918981f, -0.01457608f, 0.03007542f, 
    -0.05055072f, -0.00528411f, -0.01737561f, -0.04745985f, -0.00294042f, -0.12698525f, -0.13555969f, -0.12330312f, 
    0.03944040f, -0.11009149f, -0.02147078f, 0.03896173f, 0.02522875f, 0.01593418f, 0.05085682f, -0.03377340f, 
    -0.00744988f, -0.02050129f, 0.00521218f, -0.05886949f, -0.03136417f, -0.03078930f, -0.03379006f, -0.04051312f, 
    -0.01711960f, -0.00026057f, 0.06569482f, 0.06361772f, -0.17501265f, -0.04690643f, -0.03303029f, -0.09676610f, 
    0.01599109f, 0.06348184f, -0.02450054f, -0.02419794f, 0.00325232f, -0.02532176f, -0.02350508f, 0.02318195f, 
    0.03120341f, 0.09764796f, -0.01851680f, 0.06925929f, 0.03075209f, -0.01528329f, -0.00751762f, -0.00642166f, 
    -0.05947782f, 0.10662789f, 0.12419962f, 0.02824888f, -0.15883334f, 0.03560193f, 0.00308821f, 0.00104962f, 
    -0.02975020f, 0.02634533f, -0.02312739f, 0.03967161f, 0.03687297f, -0.04329127f, 0.05080500f, -0.00579830f, 
    -0.02037263f, -0.12589784f, -0.06499464f, -0.00517138f, 0.12324599f, 0.04772832f, 0.01255050f, 0.09626386f, 
    0.04359496f, 0.05190907f, 0.04431969f, 0.02510253f, 0.05238295f, 0.00464969f, -0.00061524f, 0.02495721f, 
    0.05444798f, 0.01788124f, 0.06827560f, 0.02367328f, 0.01571877f, -0.10367460f, -0.01176269f, -0.03770205f, 
    -0.21527849f, -0.12924097f, 0.03910353f, -0.00921624f, 0.01410970f, -0.00175014f, 0.03641113f, -0.00911387f, 
    0.00254881f, 0.08861990f, -0.03656875f, -0.00248888f, 0.01183707f, 0.04671129f, 0.01522863f, 0.01452508f, 
    0.07907647f, 0.13066678f, 0.06386565f, 0.06602290f, -0.19683518f, -0.22288947f, -0.13112938f, -0.08226579f, 
    -0.01876868f, 0.07822670f, -0.00015952f, -0.03710280f, -0.04842274f, -0.00082102f, 0.02332844f, -0.04821910f, 
    -0.04944945f, 0.01543369f, 0.02797175f, 0.01174426f, 0.03537327f, 0.07842798f, 0.04147837f, 0.05132956f, 
    -0.29546869f, -0.21774702f, -0.05336423f, -0.08591677f, -0.23314753f, 0.04448915f, 0.03012566f, 0.00133496f, 
    -0.04920821f, -0.00790404f, -0.03177817f, 0.00125787f, 0.01247085f, 0.01772935f, -0.00705128f, -0.05852061f, 
    0.00699065f, 0.03197675f, -0.01368719f, 0.02928412f, -0.37516040f, -0.29165784f, 0.00997013f, -0.04503335f, 
    -0.03721197f, 0.03888462f, 0.08417778f, 0.03528306f, -0.03514425f, -0.05278231f, 0.10328427f, 0.02601974f, 
    -0.04528262f, 0.00950403f, 0.06631825f, 0.03670024f, -0.05869399f, -0.05755250f, 0.01263739f, -0.02368847f, 
    -0.23723783f, -0.05185995f, 0.09020684f, -0.10555538f, -0.05902722f, 0.08739591f, -0.00193911f, -0.06006756f, 
    -0.03217622f, 0.00758247f, 0.05030437f, 0.01584671f, 0.01101443f, 0.11717192f, -0.00045715f, 0.07086025f, 
    0.02348804f, -0.02154129f, -0.07491986f, -0.03253251f, -0.35729241f, 0.00513244f, -0.17467238f, -0.06032697f, 
    -0.03610205f, 0.03571858f, -0.01452704f, -0.04042641f, -0.02475057f, 0.06879634f, -0.00076197f, -0.01148357f, 
    -0.08559987f, 0.06481995f, 0.05224012f, 0.04701315f, -0.05180683f, 0.06286214f, -0.04638132f, 0.04930237f, 
    0.34479025f, 0.11372666f, -0.20983596f, -0.10873467f, -0.18437879f, -0.08867276f, 0.02569038f, 0.00264221f, 
    0.00280168f, -0.06525097f, 0.07661477f, 0.04717922f, -0.05417470f, -0.04664359f, -0.02663234f, -0.00805624f, 
    0.02379939f, 0.05914574f, -0.01282970f, 0.05295107f, -0.27004430f, 0.28303376f, -0.06155072f, 0.07537318f, 
    0.06853740f, 0.10614256f, 0.06906421f, 0.03819692f, 0.00226886f, -0.03745123f, 0.03796647f, 0.07365750f, 
    -0.02000709f, -0.00465202f, 0.05357376f, -0.01966041f, 0.10054238f, -0.03046260f, -0.05497853f, 0.02109136f, 
    -0.00020287f, 0.09694692f, -0.05773677f, 0.03908241f, 0.08378705f, 0.05128798f, -0.07448959f, -0.01961028f, 
    0.00708747f, 0.02556019f, 0.07436399f, 0.04864304f, -0.03473473f, -0.03773172f, 0.03972873f, -0.02926462f, 
    0.07338959f, 0.04952890f, -0.04737352f, 0.05364217f, -0.14844322f, -0.00528752f, -0.11673582f, -0.11820074f, 
    -0.24878813f, -0.03883142f, 0.02185686f, -0.02737544f, -0.02068233f, 0.08655585f, 0.00019815f, -0.03812236f, 
    -0.02267740f, -0.04649111f, 0.04423494f, -0.10582393f, -0.00956094f, -0.02636338f, -0.05655823f, 0.01463734f, 
    0.32799178f, -0.07598799f, -0.11285871f, -0.08167630f, -0.09371679f, 0.15157235f, 0.03501759f, -0.00817303f, 
    -0.01133585f, 0.00478195f, 0.07597113f, 0.00252110f, 0.00470674f, -0.00500285f, -0.00432549f, -0.00799679f, 
    -0.03250856f, -0.03675906f, -0.02517985f, 0.07957593f, -0.07855632f, -0.08160237f, 0.02911851f, 0.07278994f, 
    0.09113909f, -0.08080567f, 0.04587574f, 0.03721744f, 0.00763805f, -0.08404696f, -0.02128893f, -0.04459723f, 
    -0.07017963f, 0.08224887f, 0.05729698f, 0.05325262f, 0.04935081f, -0.04142306f, 0.03929117f, 0.09215018f, 
    -0.17167056f, 0.20484926f, -0.08190253f, 0.08574336f, -0.02437919f, 0.11395803f, -0.01566638f, -0.02530459f, 
    0.03747837f, -0.01139166f, -0.01866338f, 0.03635693f, -0.00911393f, 0.02997430f, 0.04346522f, -0.00636508f, 
    0.06188065f, 0.01325975f, -0.09000234f, -0.02956990f, 0.05116636f, -0.19091791f, -0.01095999f, 0.08815392f, 
    0.01995493f, 0.05328591f, 0.06915639f, 0.03054455f, -0.01114290f, 0.05757273f, 0.02070677f, 0.03745390f, 
    0.04739392f, 0.01802954f, -0.09739034f, -0.03712480f, -0.01750657f, -0.05084767f, -0.04590334f, -0.00661378f, 
    0.14566095f, 0.14462437f, -0.10221267f, -0.11745187f, -0.00494900f, -0.02849859f, -0.09084262f, 0.01190181f, 
    -0.11522792f, -0.02535054f, 0.08577987f, 0.06407276f, -0.04511624f, 0.02848199f, -0.05124159f, 0.04299038f, 
    -0.03339713f, 0.08424796f, -0.03553748f, -0.11037184f, 0.19546954f, 0.05813522f, -0.08284093f, 0.02428713f, 
    0.15886651f, 0.05247476f, -0.02039053f, 0.01599736f, 0.02310999f, 0.03005586f, 0.05557653f, 0.03157669f, 
    0.02117837f, 0.01550780f, 0.02212788f, -0.03387811f, -0.01361131f, -0.00163731f, 0.00413189f, -0.02382029f, 
    0.00144836f, -0.08395141f, -0.10315972f, 0.04334903f, -0.05643898f, -0.09835073f, 0.01670550f, -0.01921770f, 
    0.05062471f, 0.02108636f, 0.01053695f, -0.06411495f, 0.01196079f, 0.03807546f, -0.08375856f, 0.06346148f, 
    0.00741829f, 0.07308152f, 0.09505962f, -0.10258083f, 0.03889940f, 0.10182127f, -0.14038703f, 0.09087635f, 
    0.07199675f, 0.08303187f, -0.03848916f, 0.00117621f, 0.04128949f, 0.01846594f, 0.02804540f, 0.06645563f, 
    0.00848824f, 0.02551137f, -0.05607250f, 0.03424658f, -0.02328003f, 0.04798897f, -0.06975272f, 0.03419715f, 
    -0.21841611f, 0.01403852f, -0.03169509f, 0.02203486f, -0.12272397f, 0.07658472f, 0.04272054f, 0.03551917f, 
    0.02910556f, 0.06493051f, -0.01549781f, -0.01467376f, 0.00587862f, -0.00593805f, -0.03718702f, -0.02189404f, 
    -0.01589824f, -0.06891262f, -0.06149507f, -0.04466704f, 0.00417674f, -0.16385849f, 0.03769797f, -0.01604070f, 
    0.06030317f, -0.00023344f, -0.17474720f, 0.04267954f, 0.09504400f, 0.10822538f, -0.06018394f, -0.01477731f, 
    0.07266656f, 0.01598257f, -0.04061642f, 0.00694815f, 0.02206801f, 0.01616258f, 0.04312267f, -0.03572826f, 
    -0.07484403f, 0.15892343f, -0.04276519f, -0.01391509f, 0.04169776f, 0.06220812f, -0.03831690f, 0.02887039f, 
    0.05264944f, 0.02563574f, -0.00132614f, 0.07423721f, -0.02708417f, -0.01238748f, 0.00071673f, 0.00666708f, 
    0.04201267f, 0.05148858f, -0.07613631f, -0.00321185f, 0.24429864f, -0.11342110f, -0.16724403f, 0.03372526f, 
    -0.01578587f, 0.06661532f, -0.00739873f, -0.04591623f, 0.02107985f, -0.00327123f, 0.07054164f, 0.02846158f, 
    -0.01403220f, 0.06025751f, 0.02774795f, 0.00424724f, -0.04411886f, -0.03429608f, 0.01509239f, 0.06080306f, 
    0.03821012f, -0.14487810f, 0.08051006f, 0.01378052f, -0.05262070f, -0.00595339f, 0.03669132f, -0.00915504f, 
    -0.06444992f, 0.03515673f, 0.02117758f, -0.03274915f, -0.04883016f, -0.03752346f, -0.09113039f, -0.06447791f, 
    0.01185808f, 0.01461707f, -0.02110021f, -0.01611509f, -0.13518330f, -0.25969580f, 0.04146028f, -0.00322434f, 
    -0.06976144f, 0.04900744f, 0.01142942f, 0.07357123f, -0.03179866f, 0.10061873f, -0.09117234f, 0.03238714f, 
    -0.05835667f, 0.00705605f, -0.03832638f, -0.05188575f, 0.02052256f, -0.03750232f, -0.06582025f, 0.00755131f, 
    -0.32518253f, -0.02096000f, -0.02288182f, -0.02071303f, 0.03274637f, -0.00140260f, 0.06779409f, -0.09339039f, 
    0.03078417f, -0.01542342f, -0.07204663f, 0.07009345f, 0.05092992f, 0.09467901f, 0.06040845f, 0.01136890f, 
    0.03682336f, -0.01635892f, -0.09533155f, 0.01077073f, -0.09216151f, -0.07381170f, 0.02630217f, -0.02810064f, 
    -0.02836951f, 0.00439506f, 0.07790886f, -0.02001727f, 0.00014949f, -0.00964647f, 0.05222832f, -0.05007944f, 
    0.04643800f, -0.02584294f, -0.04557303f, -0.01793636f, 0.00027105f, -0.03077297f, -0.00287544f, 0.07542272f, 
    -0.44013685f, 0.13909133f, -0.09826529f, 0.03448930f, -0.05343973f, 0.02470243f, 0.05220501f, 0.06181833f, 
    0.01629175f, 0.13028741f, 0.01415566f, -0.02250936f, 0.01387435f, -0.05530911f, 0.00062604f, -0.01036885f, 
    0.01504959f, -0.07625923f, -0.12591073f, -0.10733549f, -0.15458028f, 0.19482428f, -0.03143637f, -0.10944989f, 
    0.02802923f, -0.10720390f, -0.01133211f, 0.04482326f, -0.05921440f, -0.03125283f, -0.00136485f, -0.02913802f, 
    -0.03870286f, -0.02877293f, 0.09231512f, 0.05380837f, -0.02666046f, -0.04391943f, 0.09251980f, -0.06267585f, 
    -0.29939255f, -0.20603903f, -0.04807440f, -0.17260075f, -0.10579481f, -0.03403097f, 0.03204383f, -0.05742828f, 
    0.04780869f, 0.10010836f, 0.02496540f, -0.07625145f, -0.04233440f, -0.12705053f, -0.06892535f, -0.07232139f, 
    -0.03530320f, 0.01687231f, -0.07564823f, -0.09709750f, -0.45896229f, -0.07070234f, 0.08386691f, -0.12910290f, 
    0.01044252f, -0.00773692f, 0.00469931f, 0.00990918f, 0.09463481f, -0.09116024f, -0.09466307f, 0.06531416f, 
    0.09385465f, -0.01717974f, -0.02213943f, -0.06286778f, -0.00171616f, -0.01488108f, -0.06202291f, 0.05254983f, 
    -0.03659705f, -0.02935097f, -0.02226494f, 0.00279855f, -0.05097406f, -0.04986269f, 0.05907433f, -0.04219987f, 
    0.03116428f, -0.04987484f, 0.03106042f, -0.11789205f, 0.00193815f, 0.02641881f, 0.01444111f, -0.05966214f, 
    -0.02145440f, -0.03807534f, -0.04135219f, 0.03178132f, 0.04016377f, -0.03058621f, -0.08971801f, 0.05241436f, 
    0.22512041f, 0.10738774f, -0.08934917f, -0.01030047f, 0.07994509f, 0.04376893f, 0.00754446f, -0.03280026f, 
    0.00838008f, 0.04157733f, 0.02464972f, -0.01089063f, -0.01136019f, 0.02321153f, -0.02145016f, -0.02051725f, 
    -0.07199875f, -0.15641560f, -0.22777267f, 0.07054850f, -0.30258724f, -0.03289088f, 0.08114188f, -0.00841537f, 
    0.04112957f, -0.00347044f, -0.07371715f, -0.06528280f, 0.01120451f, 0.04046156f, -0.02861550f, 0.00169919f, 
    0.10419977f, 0.00196951f, -0.14812927f, -0.07290648f, -0.12278189f, 0.13603228f, 0.05810156f, 0.01144086f, 
    -0.08042044f, 0.01203517f, -0.05328907f, -0.00479270f, -0.03023451f, -0.02970923f, -0.02324915f, -0.06766710f, 
    0.02328498f, -0.08082719f, -0.01542198f, 0.03562077f, 0.04901597f, -0.03047803f, -0.00242500f, -0.01012282f, 
    0.39516732f, -0.07227763f, -0.25785300f, 0.00534226f, -0.07595891f, -0.05378592f, 0.04443097f, -0.03556082f, 
    -0.03422903f, 0.01424931f, 0.00696781f, 0.00458757f, 0.05997182f, -0.01362909f, -0.04008907f, 0.02758199f, 
    -0.07204988f, -0.02595422f, 0.00315487f, -0.03181173f, -0.18206228f, 0.08573629f, -0.02968370f, 0.06741288f, 
    -0.11339395f, -0.00417725f, 0.00920209f, -0.03874931f, 0.05650318f, -0.02202326f, -0.04826502f, -0.01904721f, 
    0.08095557f, 0.06958009f, 0.00942348f, 0.04591447f, 0.01993600f, -0.02312225f, -0.07876949f, -0.08720308f, 
    0.06444766f, 0.16297844f, -0.03281416f, -0.02430046f, 0.06956188f, -0.06677245f, -0.07730512f, 0.03805339f, 
    -0.05813784f, -0.12224934f, 0.05234177f, -0.04259435f, 0.01172958f, -0.02893019f, 0.02942853f, 0.01964138f, 
    -0.01276627f, -0.03982691f, -0.01520942f, 0.03588243f, 0.11838543f, 0.01509256f, -0.03273770f, 0.11934828f, 
    0.03291325f, -0.00354600f, 0.01282034f, 0.01061592f, -0.02260345f, -0.00729484f, 0.02663512f, -0.01464497f, 
    -0.02803190f, 0.02642038f, 0.00476835f, 0.04344119f, -0.00050160f, -0.01424367f, -0.01536136f, -0.00760120f, 
    -0.21109733f, 0.25946060f, -0.03599772f, 0.02335582f, -0.01613289f, 0.09899620f, 0.02582414f, 0.03998658f, 
    -0.02114384f, 0.05156020f, 0.02363452f, 0.02136303f, -0.01965051f, 0.01817717f, 0.05794073f, -0.01998637f, 
    0.09840350f, -0.06078498f, 0.06087723f, 0.11809554f, -0.00232307f, -0.16062726f, 0.09733649f, -0.09460337f, 
    0.05819707f, -0.10216482f, 0.04953844f, 0.02157097f, 0.02154046f, -0.10572519f, -0.06247972f, -0.00844512f, 
    0.05981410f, 0.09903034f, -0.07246671f, -0.06104912f, -0.09293270f, 0.00245132f, -0.16503502f, -0.04845308f, 
    0.17255554f, 0.03893871f, -0.18376426f, 0.04761863f, -0.25575027f, -0.08052471f, -0.03138374f, -0.00473986f, 
    -0.02049247f, -0.01866782f, -0.02114957f, 0.01907552f, 0.06947575f, -0.04067025f, 0.02077479f, 0.06457034f, 
    0.00473222f, -0.07856945f, -0.03962429f, -0.00909860f, 0.18312091f, 0.04043312f, -0.10052335f, -0.03951380f, 
    -0.12213581f, -0.05007788f, -0.01589699f, 0.01664289f, -0.01473558f, -0.04533985f, 0.07132829f, -0.08543671f, 
    -0.09469128f, 0.05516808f, -0.04235740f, 0.08417077f, 0.05820741f, 0.06737310f, 0.00125747f, 0.08325580f, 
    0.14661184f, -0.24947834f, -0.16792288f, 0.11627808f, 0.00274082f, 0.02286652f, -0.02026709f, -0.05664124f, 
    -0.01497743f, -0.05630590f, 0.07005478f, -0.05452147f, -0.01986281f, 0.08857101f, -0.01494147f, 0.04151696f, 
    -0.01360983f, -0.06509127f, -0.06483454f, -0.04060140f, 0.08399475f, -0.06303997f, 0.04439498f, 0.06206631f, 
    0.17510936f, -0.01953404f, 0.06298589f, -0.01158067f, -0.01817956f, -0.02738310f, 0.06486711f, 0.07818628f, 
    -0.03950962f, -0.00123833f, -0.08162512f, 0.05190089f, -0.01507811f, 0.05822574f, 0.02029700f, -0.04083544f, 
    0.16507001f, -0.04834686f, 0.05148899f, 0.03159406f, -0.01877600f, 0.03038991f, 0.08069579f, 0.04804996f, 
    -0.04556275f, -0.00479860f, -0.07928497f, -0.10281937f, 0.04134705f, 0.03372529f, -0.07251603f, 0.00275075f, 
    -0.02138044f, -0.01292980f, -0.07277954f, -0.00897697f, -0.24340354f, 0.00926156f, -0.00376099f, -0.00566649f, 
    0.06725702f, -0.02659299f, 0.02346427f, 0.02984165f, 0.00679913f, 0.03655741f, -0.04242569f, -0.07676136f, 
    0.04069183f, 0.01724908f, -0.02145304f, -0.07262745f, -0.08527145f, 0.00818401f, -0.13972692f, -0.03009955f, 
    0.04567423f, -0.09937961f, -0.11759239f, -0.04407056f, -0.14481533f, -0.01207246f, -0.00140621f, 0.05143896f, 
    -0.01920616f, -0.08460487f, 0.03215691f, -0.00884741f, -0.02993391f, 0.04196711f, -0.02705937f, 0.03886503f, 
    0.05223132f, -0.04827921f, -0.02317229f, -0.04355261f, -0.14909302f, 0.12511016f, -0.02080525f, -0.03884131f, 
    0.06251123f, 0.02464003f, -0.06872718f, 0.05639860f, 0.00035275f, 0.10053927f, 0.01791411f, -0.02890881f, 
    0.00150896f, -0.01759441f, 0.00333403f, -0.01457630f, -0.02756899f, -0.00678508f, -0.11736712f, -0.06423814f, 
    -0.26075086f, 0.16963813f, 0.03938146f, -0.03039723f, 0.10141844f, -0.09318567f, -0.00518464f, 0.05371172f, 
    -0.01291568f, 0.03387504f, 0.04728497f, 0.05154112f, -0.01395307f, -0.00681143f, -0.08228443f, -0.03205448f, 
    0.01471366f, -0.04251478f, 0.05548934f, -0.01107030f, -0.17888035f, -0.07066258f, 0.05711778f, 0.06972451f, 
    0.25442547f, -0.15896231f, 0.01575590f, 0.04100781f, 0.01314582f, -0.09447729f, 0.03874871f, -0.04201565f, 
    -0.05653266f, 0.05629579f, 0.01567405f, 0.02138807f, -0.00607640f, 0.00507499f, -0.06179582f, 0.07684650f, 
    0.07567821f, -0.20974293f, -0.11120723f, 0.05818769f, -0.14077580f, -0.02769156f, -0.03393036f, 0.10738064f, 
    -0.04368959f, 0.05338904f, -0.04554430f, 0.01171146f, -0.00046365f, -0.01171881f, -0.11617259f, -0.10825223f, 
    0.05432980f, -0.03597639f, -0.04385985f, -0.08147344f, -0.01485689f, -0.13571720f, -0.11547245f, -0.13555959f, 
    -0.19630326f, 0.00930363f, -0.00641244f, 0.08416406f, 0.00303055f, 0.06374074f, -0.01120164f, 0.02451142f, 
    -0.00374964f, -0.05939820f, 0.01625357f, -0.05406127f, 0.03458863f, -0.04213113f, -0.04068547f, -0.00602162f, 
    -0.03380719f, 0.01818139f, -0.07563419f, 0.00351998f, -0.17336759f, 0.11972781f, 0.06954459f, 0.00538423f, 
    0.03098876f, 0.07483316f, 0.00660588f, 0.00386350f, -0.02130299f, 0.00983390f, 0.05032949f, -0.04423599f, 
    0.06192511f, 0.05281101f, -0.01912986f, -0.02898965f, -0.06755824f, -0.10445519f, 0.03506369f, -0.06148401f, 
    0.02386337f, -0.09684592f, 0.00638969f, -0.02391487f, 0.01384709f, -0.13985200f, -0.07769575f, -0.05439088f, 
    0.04565144f, 0.02529776f, -0.05473340f, -0.10224407f, -0.09606210f, 0.03476756f, 0.01499328f, 0.05290449f, 
    0.12493370f, 0.03837113f, -0.06449489f, -0.14914113f, 0.01065859f, -0.17179824f, -0.08470569f, -0.09183273f, 
    -0.04999550f, -0.16245069f, -0.09385876f, -0.01713292f, -0.01369704f, 0.02503214f, -0.02733139f, -0.03801955f, 
    -0.05305336f, 0.05600619f, 0.05248000f, -0.00721450f, -0.02215101f, 0.08048021f, 0.04037845f, 0.01108123f, 
    0.00138818f, -0.00032590f, -0.06790540f, 0.04826540f, -0.05107003f, -0.14073218f, -0.03335036f, -0.03138298f, 
    0.06337844f, -0.02158787f, -0.00172433f, -0.00937454f, -0.02472666f, -0.00377320f, -0.00640652f, -0.00317192f, 
    0.11305904f, -0.04149479f, 0.00987668f, -0.10977065f, 0.04039174f, -0.12198289f, -0.07948280f, -0.07649147f, 
    -0.12221268f, -0.00494575f, -0.01198440f, -0.06716346f, -0.03467535f, -0.02423640f, -0.06697633f, 0.10380650f, 
    0.04980962f, -0.08691895f, 0.02522374f, 0.03900624f, 0.25715125f, 0.09632324f, -0.18079369f, -0.09636638f, 
    0.14886314f, 0.03106190f, -0.04223523f, -0.04708728f, 0.00511257f, -0.00962609f, 0.09668294f, 0.05538582f, 
    -0.02306556f, -0.02419837f, -0.04027775f, -0.00263529f, -0.00843571f, 0.04362236f, 0.01515729f, 0.06849692f, 
    0.05955829f, -0.18637589f, 0.02392339f, -0.10129837f, -0.04272668f, 0.08051071f, -0.01121556f, -0.03846021f, 
    0.09090444f, 0.05319271f, -0.10122300f, -0.04911641f, 0.00458595f, -0.03499907f, -0.07064905f, 0.02134786f, 
    0.04727197f, 0.02973335f, 0.00255079f, -0.07671880f, 0.04257315f, 0.10501371f, -0.08435909f, -0.19274101f, 
    0.30449346f, 0.09208466f, -0.09241946f, 0.01103610f, 0.05347272f, 0.02310744f, 0.01405800f, -0.01057479f, 
    0.02805094f, -0.03830932f, -0.03275786f, 0.02413276f, 0.00540176f, 0.03673063f, 0.04356821f, 0.11695635f, 
    -0.09577306f, 0.15648821f, -0.01606196f, -0.01014758f, 0.03747163f, 0.11870623f, 0.01006929f, 0.01936906f, 
    -0.01423012f, -0.07229895f, -0.06267670f, 0.07023312f, -0.02814358f, -0.11129154f, 0.00130258f, -0.04311467f, 
    0.03553580f, -0.05115159f, 0.08520819f, 0.02420234f, 0.30896831f, 0.05888380f, -0.11261705f, -0.07788599f, 
    0.04004842f, 0.04505175f, -0.01626202f, -0.05583334f, 0.06905873f, -0.01519591f, 0.07462166f, 0.07059950f, 
    -0.00933581f, 0.01876475f, 0.01960781f, -0.00548586f, -0.03554219f, -0.00153055f, -0.01325407f, 0.07864201f, 
    -0.00660616f, -0.03585318f, 0.02710726f, 0.00406383f, 0.33914986f, 0.08853571f, -0.10780592f, 0.01776317f, 
    0.04908646f, 0.00661504f, 0.02279964f, -0.07819593f, 0.03952085f, 0.05065001f, -0.00863656f, -0.00556446f, 
    0.07609756f, -0.01153366f, 0.01655714f, -0.00033797f, -0.03792154f, 0.09441687f, -0.07976667f, 0.03579656f, 
    0.07702114f, 0.04574663f, -0.00130388f, -0.00657165f, -0.00255443f, -0.04367283f, 0.04193107f, 0.05541812f, 
    -0.00553560f, -0.01923418f, -0.02429611f, 0.07820211f, 0.05172500f, 0.00347271f, -0.06993280f, 0.03877857f, 
    0.12151592f, -0.16401879f, 0.01518156f, -0.11075347f, -0.04410101f, 0.03387591f, 0.02857311f, -0.02892193f, 
    0.04733393f, 0.04923708f, 0.06323624f, -0.01543180f, -0.00338044f, 0.01699618f, 0.07152259f, -0.01505971f, 
    0.02980780f, -0.03031967f, -0.00337245f, -0.02868592f, 0.04937039f, -0.21217303f, -0.06181199f, 0.00089164f, 
    -0.13029285f, -0.00487652f, 0.02708601f, 0.01232291f, 0.00097877f, 0.05292484f, -0.01044396f, 0.04464064f, 
    -0.00329528f, 0.00416285f, 0.03042692f, -0.04534552f, -0.05164476f, -0.02994740f, -0.09600716f, -0.01324885f, 
    0.12278651f, -0.15193853f, -0.07435313f, -0.08948029f, -0.06074340f, 0.01843659f, -0.07439647f, 0.04289431f, 
    -0.03042111f, 0.02360274f, 0.01742835f, 0.00803492f, -0.01355315f, -0.01509300f, -0.01735695f, -0.02939690f, 
    -0.01239456f, -0.02140067f, -0.03135550f, -0.06972911f, 0.18598615f, 0.17466764f, -0.13023677f, 0.11994851f, 
    -0.02675775f, 0.08946733f, 0.02382118f, -0.06250088f, -0.02004878f, 0.01169206f, -0.05571237f, 0.01687139f, 
    0.01885803f, 0.02439592f, 0.08268033f, -0.02933809f, 0.05368674f, 0.09725451f, -0.05922578f, 0.03645857f, 
    0.21758659f, 0.22896807f, -0.15633585f, -0.08726682f, 0.00973191f, 0.02168103f, -0.02126092f, -0.06334985f, 
    0.06027322f, -0.01163319f, 0.07102392f, 0.05506334f, 0.01062390f, -0.02093659f, 0.01531088f, -0.00834338f, 
    -0.01919491f, 0.03880272f, -0.04215493f, 0.06162702f, 0.23957808f, 0.06127733f, -0.14404522f, -0.03300140f, 
    -0.11963131f, -0.11471573f, -0.04280721f, -0.03142820f, 0.05224732f, 0.00117012f, 0.04696958f, -0.02931650f, 
    0.00166970f, -0.00491965f, 0.03506273f, 0.01316081f, 0.00227109f, -0.01753072f, 0.00078945f, 0.04693640f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04604596f, 0.00787224f, -0.02688450f, -0.02617406f, 0.00872753f, 0.00895228f, 0.00476449f, -0.02074626f, 
    -0.02149404f, 0.03423766f, 0.05183198f, 0.00812545f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
