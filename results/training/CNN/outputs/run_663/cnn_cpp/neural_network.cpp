#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.83624357f, -0.68207216f, -0.58895868f, -0.63413459f, -0.29306754f, -0.18276076f, -0.01718752f, -0.10266764f, 
    0.07141504f, -0.24284506f, -0.70894665f, 0.54294640f, -0.72268599f, -0.73369098f, 0.10091226f, 0.37972990f, 
    -0.00870123f, -0.09890348f, -0.59550226f, -0.64918810f, -0.53480667f, -0.18078130f, -0.11417719f, -0.09970118f, 
    0.04302542f, 0.56971097f, 0.32097492f, -0.49169743f, -0.71130782f, -0.48751810f, 0.39089802f, 0.53453815f, 
    0.37588769f, -0.44706970f, -0.02808554f, -0.18454862f, -0.75984800f, 0.49431276f, 0.80762601f, -0.48902962f, 
    0.65618378f, 0.10067689f, -0.31059599f, -0.27635208f, 0.36412829f, -0.26833174f, -1.08706343f, -0.58557469f, 
    -0.43735546f, 0.66629207f, 0.63806313f, 0.18559587f, 0.16990320f, 0.00213474f, -0.35815859f, -0.65860558f, 
    -0.48961464f, 0.58257991f, 0.74897802f, -0.50486511f, -0.27826312f, -0.30150360f, -0.04469655f, -0.53780097f, 
    -0.63848007f, -0.03865508f, -0.26106501f, -0.56130755f, -0.19885728f, -0.42244050f, 0.33394021f, -0.33233598f, 
    -0.19323581f, -0.68696791f, 0.29179043f, -0.62784714f, 0.19384226f, -0.63800061f, 0.08883485f, -0.25992745f, 
    -0.61536539f, 0.80250251f, 0.76412612f, 0.74014074f, -0.00664997f, 0.19841754f, -0.05776456f, 0.42144027f, 
    0.04465428f, -0.18341637f, -0.29897332f, -0.39429024f, -0.79489952f, 0.02427002f, -0.53514951f, 0.39148957f, 
    -0.39117929f, -0.28511047f, 0.13880703f, -1.01846564f, 0.69667190f, -0.09118991f, -0.05837984f, 0.59481066f, 
    0.37451831f, -0.23134069f, 0.31739333f, 0.17973043f, 0.79529601f, 0.03436674f, 0.52683878f, -0.70787174f, 
    0.18863527f, -0.34789377f, -0.01028293f, 0.44332376f, 0.29008946f, 0.13870212f, 1.01969302f, 0.47391632f, 
    0.05417896f, -0.62494141f, -0.43474185f, -0.33862156f, -0.10614062f, -0.25084445f, 0.65178782f, -0.03920260f, 
    -0.45169491f, -0.54867673f, 0.20775594f, 0.70031440f, -0.26399818f, -0.07388993f, 0.47655669f, -0.58160025f, 
    0.22228697f, 0.68947005f, 0.77704322f, 0.67998660f, -0.06297795f, -0.00126798f, 0.12308021f, -0.33416000f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05219378f, 0.33699617f, 0.11249850f, 0.06847953f, 0.06223474f, 0.35676438f, 0.04407026f, 0.24638142f, 
    0.03749364f, 0.16870795f, -0.02220071f, 0.01125905f, 0.20053650f, 0.14580810f, 0.07700734f, -0.14828278f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08139043f, 0.10741029f, 0.15114026f, 0.05504472f, 0.14744586f, 0.01459868f, -0.06827837f, -0.02638352f, 
    -0.05263979f, -0.03480922f, -0.00358705f, 0.01604884f, -0.03276106f, 0.06664735f, 0.05458547f, 0.01919290f, 
    0.02775344f, -0.02215812f, -0.01988196f, 0.07064764f, -0.12038157f, 0.14131066f, 0.12544928f, -0.04243926f, 
    -0.08234413f, 0.00633007f, -0.02474665f, 0.02851630f, 0.11817324f, -0.02058246f, -0.01473569f, -0.00422863f, 
    0.13410166f, 0.05578992f, 0.15505016f, 0.02082441f, 0.08117600f, 0.12179642f, -0.03971123f, -0.02685255f, 
    -0.07351539f, 0.10066120f, -0.09064458f, 0.03704134f, -0.12790604f, 0.03338362f, 0.00610071f, 0.06057240f, 
    0.00416958f, -0.03535827f, 0.02097661f, -0.07228389f, -0.04749616f, 0.02669390f, 0.08222403f, 0.16496699f, 
    0.04179754f, 0.05990673f, -0.07202973f, 0.08444446f, 0.07886204f, 0.05231528f, -0.02422429f, -0.04758549f, 
    -0.19722605f, 0.12979896f, 0.04035865f, 0.11642420f, 0.03363532f, -0.04896608f, 0.06495609f, -0.07849925f, 
    -0.03282230f, -0.00390304f, 0.04651092f, 0.03439386f, 0.07882691f, -0.02680164f, 0.01096823f, 0.07557575f, 
    -0.05010955f, 0.01957378f, 0.05556121f, 0.13180219f, 0.19216800f, -0.05931484f, 0.02670267f, -0.06260323f, 
    -0.02426985f, 0.03172769f, -0.05115028f, 0.07222068f, -0.00533746f, -0.00329942f, 0.07223766f, 0.12976246f, 
    -0.04855110f, 0.08618104f, 0.06808636f, 0.06444470f, -0.12477083f, 0.07429308f, -0.07322683f, 0.03729847f, 
    -0.12008092f, 0.10207531f, 0.02093684f, 0.10230891f, 0.01165547f, 0.00266738f, 0.09300827f, -0.02561233f, 
    -0.01936733f, -0.00250309f, 0.03695292f, 0.05944451f, 0.01685688f, 0.02420384f, -0.00616386f, 0.14246489f, 
    0.33739096f, -0.07032610f, -0.06196399f, -0.05591255f, -0.09437554f, 0.03573686f, -0.02892623f, 0.10490881f, 
    0.10642390f, 0.05535992f, -0.00980741f, -0.04800824f, -0.09239718f, -0.09035780f, 0.04584190f, 0.07782292f, 
    0.01725751f, -0.11593106f, -0.06675543f, 0.04666069f, -0.08182386f, 0.02949547f, 0.09168364f, -0.01726328f, 
    -0.02129789f, 0.04767416f, -0.08156542f, 0.04387119f, 0.01324363f, -0.01171020f, -0.05027337f, -0.04882432f, 
    0.00325137f, -0.03305015f, 0.07540537f, 0.08123105f, 0.02647263f, 0.07828571f, -0.01217141f, 0.02305229f, 
    -0.00254267f, 0.07867405f, -0.04483689f, 0.12397456f, -0.03405135f, 0.19805279f, 0.03049013f, -0.00829691f, 
    -0.06842854f, 0.08307730f, 0.06199742f, -0.04809162f, 0.01350885f, 0.00767746f, 0.00244501f, 0.11602084f, 
    -0.01333845f, 0.02333484f, -0.02226186f, 0.02644696f, 0.36034912f, 0.12656146f, -0.21724255f, 0.18598737f, 
    0.14984331f, 0.14758515f, 0.00240624f, -0.01580694f, 0.00076915f, -0.06621370f, 0.13060731f, -0.00203440f, 
    0.05034713f, -0.00107559f, -0.10203629f, 0.05711164f, -0.00916051f, 0.05348788f, -0.00999519f, -0.07740560f, 
    -0.13501203f, -0.00916938f, 0.01093480f, -0.05612101f, -0.02204898f, 0.04472214f, 0.08953439f, 0.07538935f, 
    -0.06337977f, 0.03504641f, -0.02496402f, -0.14090729f, 0.02448025f, 0.03627108f, 0.01396445f, 0.05591273f, 
    0.15043320f, -0.04229271f, 0.03563510f, 0.02761942f, -0.25307533f, 0.21709627f, -0.00542004f, 0.05292656f, 
    0.05963985f, 0.09684747f, 0.09859221f, -0.05979433f, -0.02710058f, 0.09876859f, 0.00171884f, -0.04626218f, 
    0.00483623f, 0.04067311f, 0.07740708f, 0.07615218f, 0.02250736f, -0.06808136f, 0.10281765f, 0.00051374f, 
    0.18226838f, 0.12363054f, -0.07558053f, 0.06899549f, 0.07347655f, 0.12142643f, 0.00578246f, -0.04718373f, 
    -0.00538242f, 0.01637345f, 0.01657449f, 0.10960833f, 0.01154782f, 0.04943571f, -0.00723387f, 0.08603696f, 
    0.01620539f, -0.01695601f, -0.03180661f, 0.05664781f, 0.20962366f, -0.01185822f, -0.08859287f, 0.09688935f, 
    0.14608712f, -0.03030676f, 0.01691356f, -0.12081223f, -0.01917527f, 0.00607404f, 0.09637123f, -0.02227584f, 
    0.12342473f, 0.06936660f, 0.12543058f, 0.18744253f, 0.03142799f, -0.01023026f, 0.05797246f, -0.06974918f, 
    -0.20856234f, 0.08957981f, -0.00203061f, 0.02401703f, 0.05015390f, 0.15593839f, 0.03539244f, 0.03937527f, 
    0.04744774f, -0.01221196f, 0.03377822f, 0.01790020f, 0.02168268f, 0.04906668f, 0.07599749f, -0.00022263f, 
    0.10609750f, 0.07053886f, 0.01882384f, -0.01908153f, -0.07126316f, -0.20649648f, 0.04305588f, 0.06391067f, 
    0.05597212f, -0.14001805f, -0.04691726f, 0.00745387f, -0.00661378f, 0.08408479f, 0.00044270f, 0.06042659f, 
    0.03703276f, 0.02614843f, 0.04882612f, -0.02355240f, -0.03347990f, -0.07974577f, 0.06267361f, 0.00468905f, 
    -0.17393738f, 0.14545877f, 0.01135146f, -0.17776594f, -0.02712420f, -0.03296532f, 0.00284749f, -0.06670087f, 
    0.04141066f, -0.07592589f, 0.12697960f, 0.07012770f, -0.01670276f, 0.03295705f, 0.04531500f, -0.03909103f, 
    0.05362859f, -0.14777625f, -0.11021182f, 0.06866152f, -0.10191587f, 0.04948593f, 0.10223587f, -0.10186256f, 
    0.09762701f, -0.00159267f, 0.01492685f, -0.14434485f, 0.05780297f, 0.00616678f, -0.06910555f, 0.05389839f, 
    0.08330271f, 0.08582850f, 0.05659955f, 0.07896627f, 0.05196317f, 0.00841256f, -0.17299145f, -0.04863482f, 
    0.12662876f, 0.08465586f, -0.00947802f, -0.04135541f, -0.20081764f, -0.03328644f, -0.03696207f, -0.00787470f, 
    -0.05574706f, 0.02435778f, -0.03559453f, 0.08296180f, 0.03340352f, 0.07484654f, -0.10117155f, 0.13140661f, 
    0.09397736f, -0.03977770f, 0.11479989f, 0.08464301f, 0.15665607f, 0.13450114f, 0.22448519f, 0.18075624f, 
    0.11036696f, -0.11480115f, -0.08139040f, -0.03371860f, 0.03691993f, 0.02130366f, 0.02882503f, -0.02982205f, 
    -0.03010310f, -0.17663643f, 0.01368750f, -0.09693471f, -0.05747586f, 0.10487437f, -0.03942050f, -0.01504375f, 
    -0.12030485f, -0.01429052f, -0.18592693f, -0.16520704f, -0.07818341f, 0.01234987f, 0.06329346f, -0.21712928f, 
    -0.03348761f, -0.03539367f, 0.07927736f, 0.00118874f, 0.07542916f, 0.06515113f, 0.02279079f, 0.05171809f, 
    -0.07056760f, 0.04002908f, -0.01894172f, 0.01010225f, 0.22949527f, -0.01142493f, 0.20814307f, 0.15471138f, 
    0.08378728f, -0.09069536f, -0.05801568f, -0.00023596f, 0.00480847f, -0.05485850f, 0.07166737f, 0.10388493f, 
    -0.12881306f, 0.04633788f, -0.08571438f, 0.13131055f, 0.06184103f, 0.04130401f, 0.02734725f, 0.03216630f, 
    0.00564783f, 0.06109911f, 0.04933194f, 0.08863099f, -0.04285641f, 0.00439113f, -0.05487036f, 0.11921538f, 
    0.00521517f, 0.13826914f, -0.04264996f, 0.00215494f, 0.04455014f, -0.08417576f, -0.06373816f, -0.01164610f, 
    0.03841374f, -0.10849570f, 0.04396897f, -0.06299384f, 0.02872524f, 0.04471312f, -0.07170874f, -0.00970186f, 
    0.00740090f, -0.07817741f, 0.00608013f, -0.00030026f, -0.02035955f, 0.05498113f, -0.01182396f, 0.05557600f, 
    -0.01921685f, 0.05215953f, 0.07353704f, -0.03474454f, 0.11947864f, 0.06574659f, -0.02357749f, 0.11985210f, 
    -0.20985766f, 0.00743463f, 0.01631629f, 0.12889323f, 0.23527995f, 0.03221909f, -0.00782060f, 0.05374177f, 
    0.00485489f, 0.04212409f, -0.00187826f, -0.07422936f, 0.04822434f, 0.06531289f, 0.02051377f, -0.07510135f, 
    0.06981962f, -0.05040362f, -0.06626211f, -0.13399510f, 0.30195981f, -0.11484306f, -0.07324880f, -0.05998304f, 
    -0.03809402f, 0.33132207f, 0.20059890f, 0.02304873f, -0.21669748f, -0.12943025f, -0.00264583f, 0.00289638f, 
    -0.04589326f, 0.16303110f, -0.01348568f, -0.01079464f, 0.14705741f, 0.08211721f, -0.02736510f, -0.08007026f, 
    -0.12594576f, 0.03289174f, 0.12474877f, 0.02899659f, 0.10318375f, -0.06304870f, -0.02534000f, -0.02666136f, 
    0.01970031f, 0.05287775f, -0.01595584f, -0.01562774f, 0.01540253f, -0.07250304f, -0.02990837f, 0.00229587f, 
    0.09041987f, -0.01480928f, -0.10920712f, 0.03038090f, -0.10008617f, 0.05508751f, -0.12930319f, 0.01071550f, 
    -0.09047318f, -0.03007831f, 0.08860312f, -0.15095836f, -0.03689740f, -0.03442866f, -0.07873710f, 0.02787407f, 
    0.07028670f, 0.04741336f, 0.00467527f, 0.01820067f, 0.07824926f, -0.01505812f, -0.05990882f, 0.12035754f, 
    -0.10977390f, 0.02439551f, -0.13941960f, -0.07875758f, 0.21591248f, 0.04231363f, 0.05678110f, 0.17661007f, 
    0.08161201f, -0.05628995f, 0.07698142f, 0.01623793f, -0.04576589f, -0.01888715f, 0.11605873f, 0.05010120f, 
    0.06916070f, 0.11613849f, 0.00009442f, 0.06634290f, -0.05307375f, -0.22692785f, -0.11620307f, 0.01522430f, 
    0.08324654f, 0.15935008f, 0.06491774f, -0.00813870f, -0.19293572f, -0.06243274f, 0.03292854f, -0.03816990f, 
    0.10739712f, 0.05986974f, 0.07670552f, -0.04656659f, 0.05454639f, -0.04651267f, -0.12610699f, -0.12413000f, 
    0.11432637f, 0.25428197f, 0.05192313f, -0.07758434f, 0.02284217f, -0.03429010f, 0.05194144f, 0.15225132f, 
    0.07382480f, 0.05385683f, 0.05726071f, 0.00543912f, -0.04914976f, -0.00728843f, 0.09975387f, 0.01427333f, 
    -0.03727750f, 0.15289599f, 0.10798007f, 0.24741869f, 0.09035338f, 0.20264089f, -0.16545728f, -0.15850331f, 
    0.02244072f, 0.03367905f, 0.10855226f, -0.07307405f, -0.03087330f, 0.02914459f, 0.00335140f, -0.01733602f, 
    -0.12868087f, 0.06206404f, 0.03743812f, -0.12044673f, -0.01164906f, 0.08820666f, 0.09885673f, -0.06969703f, 
    -0.03532504f, -0.02432220f, 0.00205923f, -0.03480241f, -0.05205048f, 0.00110294f, -0.06002481f, -0.04852381f, 
    0.02221667f, -0.04382445f, 0.01817940f, -0.03871744f, -0.02205215f, 0.04759120f, 0.02647920f, -0.02352767f, 
    -0.06338947f, 0.01636213f, -0.03818637f, -0.00378697f, 0.04343544f, -0.03024578f, 0.01527451f, 0.00887599f, 
    -0.05031227f, -0.02522265f, 0.04006235f, 0.05395735f, 0.01348280f, -0.05612288f, 0.02919121f, 0.03436118f, 
    -0.05642468f, -0.01943216f, 0.04863933f, 0.00005509f, -0.05333456f, -0.03148625f, 0.00131100f, 0.04045069f, 
    -0.01934440f, -0.01583248f, -0.02004040f, 0.01331044f, -0.05490148f, -0.03230917f, -0.02441948f, -0.02392383f, 
    0.00768162f, 0.02269798f, 0.02718972f, -0.01622867f, 0.04889559f, -0.03824088f, -0.03263555f, -0.00172730f, 
    0.00501461f, -0.05557679f, -0.00715806f, 0.03556878f, -0.04826334f, -0.01634563f, -0.01257686f, 0.03036489f, 
    -0.01313557f, 0.03460604f, -0.02198132f, 0.04238930f, -0.00031415f, -0.03973284f, -0.04659853f, -0.00409127f, 
    -0.04132960f, 0.00719178f, 0.01695446f, -0.04343611f, -0.05888814f, -0.03572747f, 0.00137721f, -0.00553672f, 
    0.04044292f, -0.01454402f, 0.01111445f, 0.01255970f, -0.04270117f, -0.03778446f, -0.03159157f, -0.04422780f, 
    0.02246255f, -0.05864164f, -0.00557017f, -0.01370817f, -0.06012408f, 0.02273647f, 0.04679467f, -0.00982427f, 
    -0.03904487f, -0.01902782f, -0.04861310f, 0.01926518f, -0.01674668f, -0.06021991f, 0.00580814f, 0.00405824f, 
    -0.03201488f, 0.04782573f, -0.04506882f, -0.04560926f, 0.00338254f, -0.00208043f, -0.01890108f, 0.03504581f, 
    0.02051485f, 0.01982159f, -0.03145540f, -0.04057642f, -0.00247604f, 0.02070525f, -0.03725142f, -0.00653862f, 
    -0.02433941f, -0.04697004f, 0.03158290f, -0.05783998f, -0.04410540f, -0.04776594f, -0.04000729f, -0.03930066f, 
    -0.04308376f, -0.03980068f, 0.00653814f, -0.06022548f, -0.03756844f, -0.02429745f, -0.00891339f, -0.00829491f, 
    -0.01234654f, -0.02770252f, -0.01414621f, 0.05096241f, 0.03136612f, -0.03116967f, -0.01353964f, 0.02943491f, 
    0.03208660f, -0.01823387f, 0.01316148f, -0.04522550f, 0.02494574f, 0.00720933f, 0.03724907f, -0.01842364f, 
    0.03938918f, -0.03453132f, -0.04764041f, -0.05167361f, 0.00709189f, 0.03853478f, 0.01194136f, 0.02759761f, 
    -0.02089763f, -0.03995143f, -0.02418086f, 0.04004381f, 0.05187017f, 0.00782854f, -0.00157989f, -0.03998774f, 
    -0.06703624f, 0.03798460f, -0.01756153f, 0.00689571f, 0.03551082f, 0.03357411f, -0.00886867f, 0.00433944f, 
    0.01493398f, 0.01432569f, -0.03277487f, -0.04769557f, -0.03230000f, 0.04209502f, 0.04433983f, -0.01711741f, 
    -0.02120409f, -0.05643709f, -0.02335655f, 0.00222746f, -0.02591711f, -0.01312668f, -0.02124445f, -0.01588246f, 
    0.02884662f, -0.03497774f, 0.01673774f, 0.01587871f, 0.03004136f, 0.05747631f, -0.03915001f, 0.00909259f, 
    -0.06386606f, 0.04444544f, -0.00264034f, 0.04597781f, 0.02667277f, 0.01612383f, -0.05838100f, 0.01074625f, 
    0.00627117f, 0.03683184f, -0.02881726f, -0.06388665f, -0.04764972f, -0.02165481f, 0.03492764f, -0.00139739f, 
    0.03467229f, -0.05234662f, 0.00317522f, -0.02102031f, -0.03934284f, -0.05093961f, 0.02521441f, -0.03333191f, 
    0.04491112f, -0.01773294f, 0.00506165f, -0.00149740f, 0.00394820f, 0.00247120f, 0.03506990f, 0.04438589f, 
    -0.00062663f, -0.01072731f, -0.00872226f, -0.00677189f, 0.04914083f, -0.05265578f, -0.01222945f, -0.00753304f, 
    -0.00108685f, 0.03588599f, 0.04304505f, 0.03827759f, -0.04877762f, -0.04437181f, -0.04701643f, -0.06422907f, 
    0.03215705f, -0.02158800f, 0.02423362f, 0.04982701f, -0.03965741f, -0.03900582f, 0.03368696f, -0.03973053f, 
    0.03914719f, 0.03485020f, 0.00458789f, -0.04580004f, 0.04332149f, 0.00156797f, 0.04470851f, -0.04964111f, 
    -0.06112202f, 0.04328709f, -0.03568091f, 0.05321093f, -0.04557676f, -0.01684324f, -0.00031646f, 0.03263974f, 
    -0.05233426f, 0.00980643f, -0.02958088f, 0.03807482f, 0.04298321f, -0.05435845f, 0.01309382f, -0.01386531f, 
    -0.05500613f, 0.04664610f, -0.01259562f, 0.00480164f, 0.03540549f, -0.00113442f, 0.03701563f, -0.00543197f, 
    0.02102640f, 0.04318444f, 0.03590919f, -0.00908214f, -0.00244999f, -0.04656091f, -0.04893707f, 0.04696538f, 
    0.02816754f, -0.06005006f, -0.03659973f, -0.02292982f, 0.00604170f, -0.00091996f, -0.00023513f, -0.03404463f, 
    -0.00312792f, 0.00329655f, 0.03359524f, 0.04667146f, -0.05293775f, -0.03497529f, -0.01563939f, -0.04930445f, 
    -0.03020463f, 0.02461683f, 0.02240831f, -0.06099252f, -0.02292437f, -0.03516915f, -0.05178910f, -0.00065085f, 
    -0.05021767f, 0.01078973f, -0.04714174f, 0.03108035f, -0.00892903f, -0.03720499f, -0.03928589f, -0.00893718f, 
    -0.01669728f, -0.05934211f, 0.03012846f, -0.00334100f, 0.03109434f, -0.03441109f, -0.00821335f, -0.00961500f, 
    -0.01753806f, -0.00895777f, -0.02710927f, -0.03634306f, 0.04002456f, -0.03505931f, -0.04515945f, 0.04464687f, 
    0.01130181f, 0.01663325f, 0.02882970f, 0.04287538f, -0.00730348f, 0.01764370f, -0.04480893f, -0.01226457f, 
    -0.02675210f, 0.00002073f, -0.01365104f, 0.00691951f, 0.00235828f, -0.00030856f, 0.04415981f, 0.03230289f, 
    0.00522177f, 0.01619666f, -0.03275266f, 0.02288949f, -0.02781941f, 0.04315127f, 0.02725438f, -0.00914626f, 
    -0.04687806f, -0.05233904f, -0.05324534f, -0.02649675f, -0.03759844f, -0.00218534f, -0.03513709f, 0.00706120f, 
    0.00109871f, 0.02560192f, 0.03648552f, 0.00062846f, -0.02021066f, 0.04215258f, 0.01918196f, -0.02106250f, 
    -0.00130122f, 0.03009403f, 0.02226356f, 0.02991568f, -0.00018427f, 0.02496624f, 0.01688545f, 0.01668865f, 
    -0.03000813f, -0.05661588f, 0.02973066f, -0.04345874f, 0.01200167f, 0.00546115f, 0.01185967f, 0.01126781f, 
    -0.03504509f, 0.00200199f, -0.04498788f, -0.01623222f, -0.00533594f, 0.02330453f, -0.01341543f, -0.03351256f, 
    0.00411083f, -0.03830869f, -0.01865575f, -0.05962428f, -0.01599001f, 0.02297784f, -0.03569356f, -0.04141832f, 
    -0.04913758f, 0.03076619f, 0.02507906f, 0.05530648f, 0.02911914f, 0.03914325f, 0.05078842f, 0.04438959f, 
    -0.03136441f, -0.00773570f, -0.03382546f, -0.02015730f, -0.05131140f, 0.03595670f, 0.00774555f, -0.05854148f, 
    0.01871001f, 0.01463538f, -0.04467360f, -0.02623253f, -0.02540469f, 0.03461169f, -0.04306222f, -0.00424457f, 
    -0.00250068f, -0.04196948f, 0.00764945f, -0.06053000f, -0.06253815f, 0.02766941f, 0.00394380f, -0.00481140f, 
    -0.02896319f, 0.00929644f, 0.03570452f, -0.04383064f, -0.04939084f, -0.02111443f, 0.04455778f, -0.04716533f, 
    -0.05397842f, 0.03968863f, 0.01929274f, -0.00549075f, 0.02784417f, 0.02038673f, 0.04115206f, -0.03145373f, 
    0.00895611f, 0.01390585f, -0.05822145f, -0.00680296f, 0.02881753f, -0.06117778f, -0.04787516f, 0.01595794f, 
    0.03582314f, -0.02939335f, -0.03539242f, -0.01282105f, 0.00692546f, -0.04984806f, -0.04361333f, 0.02822550f, 
    -0.01389798f, -0.04557697f, 0.00465531f, -0.04310861f, -0.04667896f, -0.03521858f, 0.02510338f, 0.03227273f, 
    0.00991295f, 0.03911455f, -0.01903597f, -0.00881297f, 0.03527405f, -0.03975318f, -0.02712982f, -0.05338228f, 
    0.00174396f, -0.00959043f, 0.04371504f, -0.04883879f, -0.00409195f, 0.01368731f, -0.03797407f, -0.01215685f, 
    0.00632559f, -0.02013192f, 0.02724387f, 0.03560774f, 0.01478474f, 0.03065655f, -0.05621757f, -0.00210316f, 
    -0.00681400f, -0.02244790f, 0.03648878f, -0.00014864f, 0.00576469f, 0.04604163f, -0.06311574f, -0.00732346f, 
    -0.02356041f, 0.03564711f, 0.03329466f, 0.01103107f, -0.06092063f, -0.05580267f, 0.01965798f, 0.03580977f, 
    -0.03510581f, -0.03248580f, -0.01273589f, -0.00497030f, -0.00046730f, -0.04276955f, 0.02525681f, 0.01448323f, 
    -0.05249466f, -0.01894462f, -0.04071270f, 0.00886181f, -0.00906670f, 0.02466395f, -0.04857320f, -0.01583735f, 
    -0.04687088f, 0.04039211f, -0.00645129f, -0.03114966f, -0.00625927f, 0.05165466f, -0.03088738f, 0.03145548f, 
    -0.01477962f, 0.03256613f, 0.00386046f, -0.03628401f, -0.00633979f, -0.04151393f, -0.04268855f, 0.00495432f, 
    -0.03308017f, -0.03577345f, -0.04472878f, -0.03802237f, -0.05366014f, 0.00309082f, -0.05642499f, -0.05172874f, 
    -0.02661219f, 0.00464336f, -0.04576842f, 0.04837187f, 0.03378198f, 0.00534500f, -0.06103077f, -0.04482112f, 
    0.02388771f, -0.01334069f, 0.02701759f, -0.05014221f, 0.03173443f, 0.01264179f, -0.04520066f, -0.04105261f, 
    -0.04998216f, 0.03851937f, 0.02726696f, 0.02900813f, 0.00788916f, -0.05867528f, -0.06131065f, 0.00574469f, 
    -0.06068334f, -0.00014708f, 0.01688048f, -0.05936197f, 0.03409439f, -0.02509997f, -0.03037086f, -0.03979921f, 
    -0.05303767f, 0.02012596f, -0.00130072f, -0.02545683f, 0.00645129f, 0.00024766f, -0.01691757f, 0.00084241f, 
    -0.03063994f, -0.04352139f, 0.00159891f, 0.00152327f, -0.04874550f, -0.03184358f, 0.02230162f, -0.02807384f, 
    0.03298942f, 0.02912101f, -0.01556062f, -0.02641049f, 0.03044345f, -0.01393019f, -0.03330415f, 0.01220617f, 
    -0.02387869f, 0.01166322f, 0.03266803f, -0.00379793f, 0.04623846f, -0.01930225f, 0.03288480f, -0.06026591f, 
    0.00905989f, -0.06010214f, -0.05293811f, 0.04366087f, 0.03333559f, -0.00789243f, 0.04122300f, 0.03563888f, 
    -0.09621990f, -0.50009531f, 0.05957749f, -0.00495636f, 0.22763634f, 0.04943363f, -0.03901003f, -0.05010321f, 
    0.00367923f, 0.14481401f, 0.07071865f, 0.01786239f, -0.09081692f, 0.08592050f, -0.06265198f, 0.04908858f, 
    -0.03996892f, -0.01636530f, -0.15730490f, -0.05894967f, -0.03699742f, 0.06162306f, -0.20214179f, 0.15784177f, 
    0.04306626f, 0.07630456f, -0.08887301f, -0.02543530f, 0.03504106f, 0.00601252f, -0.05831270f, -0.11434075f, 
    0.08215713f, -0.00020088f, 0.07901584f, 0.06036622f, 0.01934135f, 0.00446937f, 0.07813873f, -0.06196975f, 
    -0.23135522f, -0.27336761f, -0.23378213f, 0.13752411f, 0.05439224f, -0.05047716f, 0.03338401f, 0.02558767f, 
    -0.04225944f, 0.05484134f, 0.01670611f, 0.10829595f, -0.01600437f, 0.02050383f, 0.04110415f, 0.03020477f, 
    0.05110318f, 0.07002498f, -0.02256212f, 0.00020997f, 0.12008911f, 0.02130470f, -0.25041598f, -0.10646991f, 
    -0.17663118f, -0.02955419f, 0.03121296f, 0.02496998f, -0.00989948f, 0.03466474f, 0.09182958f, 0.09788522f, 
    -0.09030356f, 0.06362889f, 0.00455116f, 0.04495596f, 0.08355821f, -0.14873831f, -0.01671429f, 0.01209185f, 
    0.32186237f, -0.03814315f, -0.06470620f, 0.01286872f, -0.02757860f, 0.02351009f, 0.00313641f, -0.02590105f, 
    -0.01038024f, -0.07086854f, 0.00278343f, 0.07194364f, -0.02871760f, 0.07478272f, -0.09842673f, 0.00226255f, 
    -0.00270425f, 0.05874959f, 0.03535485f, -0.14086546f, 0.04776095f, -0.15369560f, -0.25118113f, -0.11556952f, 
    -0.11853614f, 0.03491568f, -0.02311923f, -0.03529975f, 0.01807710f, -0.00964745f, 0.08918639f, -0.01290303f, 
    -0.01511128f, -0.07362621f, 0.08485768f, 0.08433960f, -0.03767167f, -0.07396492f, 0.02026739f, -0.06078646f, 
    0.14249681f, -0.09631315f, -0.22809248f, -0.15145683f, 0.15128104f, 0.09101931f, 0.08362884f, -0.06399383f, 
    0.11089808f, 0.00920118f, 0.02560107f, 0.09195517f, 0.04801166f, -0.02331503f, 0.06836254f, 0.15971805f, 
    0.08661270f, -0.07885116f, 0.00463782f, 0.02973712f, -0.10943456f, -0.14848721f, -0.24434924f, 0.17205758f, 
    0.06656612f, 0.03732063f, -0.01333685f, 0.10096844f, -0.07897133f, 0.01093197f, -0.05393798f, 0.07358316f, 
    0.02740056f, 0.07120806f, -0.05273999f, 0.02496010f, -0.04011288f, 0.01872724f, 0.03066627f, 0.01905460f, 
    -0.00593967f, -0.00518470f, -0.14110272f, 0.14074694f, 0.10577369f, 0.14231294f, 0.07953498f, -0.05265973f, 
    0.01188202f, 0.02481496f, -0.04755761f, 0.04426107f, -0.03574664f, -0.07574683f, 0.06998491f, 0.06416519f, 
    0.04212638f, 0.00079917f, -0.09723472f, 0.06108661f, 0.18177581f, 0.38083640f, 0.22540174f, 0.06842353f, 
    -0.12377201f, -0.00931237f, -0.06828997f, 0.06728915f, 0.11808916f, -0.02385095f, -0.07836567f, -0.03312851f, 
    0.03796880f, 0.02341655f, -0.04960013f, -0.03261960f, 0.02070233f, 0.06674787f, 0.01184678f, 0.02434654f, 
    -0.27512091f, -0.05952855f, -0.11519782f, -0.11339711f, -0.00927261f, 0.02801949f, 0.01534744f, -0.09015223f, 
    -0.04148952f, 0.13105755f, -0.04675820f, -0.02451727f, -0.06446287f, 0.13302405f, -0.07868195f, -0.01794191f, 
    0.06711090f, 0.01669250f, 0.09862322f, 0.00687418f, -0.24139708f, 0.04624933f, -0.11127437f, -0.10889426f, 
    -0.07593595f, -0.00804745f, 0.00060578f, -0.00891114f, 0.01471077f, -0.03221514f, 0.10115401f, -0.03218959f, 
    -0.01223195f, -0.05869776f, 0.02089929f, 0.05069821f, -0.01940053f, 0.13408546f, 0.13273381f, 0.00114093f, 
    0.15874466f, 0.15193626f, 0.07792789f, 0.17108619f, -0.11866815f, -0.08243234f, -0.05961489f, 0.03651393f, 
    0.02866772f, 0.20066206f, 0.03853793f, -0.12962359f, -0.07510073f, 0.09928302f, 0.05357182f, 0.02921929f, 
    -0.03130675f, -0.00608991f, 0.03856229f, -0.04361330f, 0.14780809f, 0.20632659f, 0.07870708f, 0.00441699f, 
    -0.08669312f, 0.06072055f, 0.02823309f, 0.02005710f, 0.00908620f, 0.05883707f, -0.15886623f, 0.04526308f, 
    0.07175515f, 0.06154436f, 0.04559210f, -0.00835090f, -0.08055110f, -0.02943933f, 0.08850997f, 0.04929100f, 
    -0.12245901f, -0.01368935f, 0.00575076f, 0.07508277f, 0.05963765f, 0.04739346f, -0.00050790f, 0.04541479f, 
    0.03382421f, 0.01175784f, -0.02671677f, 0.00640701f, -0.03937851f, -0.00164755f, -0.06625386f, -0.01079629f, 
    0.03185012f, 0.11154872f, -0.02251203f, -0.01035840f, -0.17256603f, -0.03781531f, 0.24014646f, 0.00743038f, 
    -0.06538104f, 0.04610100f, 0.04219086f, -0.03020400f, -0.01081792f, 0.03222845f, -0.05668411f, -0.09239987f, 
    -0.01957677f, -0.14796166f, -0.08064302f, 0.08799028f, 0.01060870f, 0.14129104f, 0.04267764f, 0.00358057f, 
    0.14939207f, -0.21730632f, -0.04478336f, -0.15688200f, 0.18095677f, -0.03568299f, 0.04261034f, 0.08411284f, 
    -0.02920915f, 0.11909061f, -0.01824522f, 0.06806501f, -0.02211313f, 0.02451494f, -0.04124831f, 0.00125587f, 
    0.01521438f, 0.00493399f, 0.09003017f, 0.03767533f, -0.12004137f, 0.18658477f, 0.03186485f, -0.09956906f, 
    -0.21697806f, 0.09329949f, 0.01802390f, 0.05483525f, 0.05245884f, -0.04310547f, -0.11278649f, -0.00482011f, 
    0.01599640f, 0.02641945f, 0.02037040f, 0.02643048f, -0.02666462f, 0.08515900f, 0.08452672f, -0.03963974f, 
    0.30884680f, 0.02713061f, 0.19063880f, -0.04185938f, -0.04788769f, -0.10021735f, -0.01506199f, 0.04619458f, 
    0.00608922f, -0.02816521f, -0.02939537f, -0.19231927f, 0.01900428f, 0.05230371f, -0.02308193f, -0.07668398f, 
    0.08510125f, -0.03088193f, 0.01836743f, 0.04231360f, 0.29365242f, -0.19892585f, -0.09899545f, -0.11127814f, 
    -0.05265422f, -0.10200565f, 0.04665125f, -0.12368996f, 0.01150813f, -0.07397189f, 0.04726007f, 0.11186558f, 
    -0.12365176f, 0.04368927f, -0.02971939f, -0.01353154f, 0.08223516f, -0.06319879f, -0.10310481f, 0.05617805f, 
    0.15060270f, -0.10462342f, -0.05504176f, -0.09978772f, 0.10868078f, -0.01087426f, -0.01694278f, 0.01483305f, 
    -0.07180747f, 0.02138867f, -0.07070808f, -0.03990074f, -0.02655149f, -0.01126419f, 0.08844653f, 0.00382172f, 
    0.04168373f, 0.07173061f, -0.01449395f, 0.00844734f, 0.49317977f, -0.18175904f, 0.03807424f, 0.01177834f, 
    0.10232099f, -0.13285518f, 0.02698850f, -0.01249401f, -0.01931788f, 0.02666584f, 0.04037738f, -0.03306453f, 
    0.01208263f, -0.00629960f, -0.00263499f, 0.06553184f, 0.01374366f, -0.01550172f, -0.00696296f, 0.05954962f, 
    0.30622375f, -0.21278647f, -0.07653695f, -0.10384486f, 0.06217530f, -0.00124333f, -0.06877418f, -0.03907990f, 
    -0.03063038f, -0.07480896f, -0.01669198f, 0.08740316f, 0.07425801f, -0.00315022f, 0.03411810f, 0.03020600f, 
    -0.06788208f, -0.02933251f, 0.03625688f, -0.01168531f, -0.02196323f, 0.11337496f, 0.04056437f, -0.19152665f, 
    -0.06148819f, 0.04663202f, -0.02504625f, 0.15332130f, -0.04264377f, -0.03209195f, -0.02124268f, -0.00832376f, 
    0.04790635f, 0.03005744f, -0.00503244f, 0.08993953f, -0.03015720f, -0.01223291f, 0.00729298f, 0.07890477f, 
    0.18094696f, 0.09345551f, 0.01515069f, -0.12460185f, 0.01327082f, 0.00713193f, -0.07785417f, 0.08966213f, 
    -0.01366015f, -0.04617870f, -0.07426693f, -0.00193144f, -0.01810149f, -0.03915086f, 0.00152438f, 0.07909939f, 
    -0.01677635f, -0.00082311f, 0.00005429f, -0.00150868f, -0.09323148f, 0.24014407f, 0.09207298f, 0.17111644f, 
    -0.05170078f, -0.03125331f, -0.01839089f, 0.06411047f, 0.14431389f, 0.00002452f, 0.05251006f, 0.05172822f, 
    0.05972732f, 0.11194021f, -0.03199102f, -0.02602510f, -0.00035725f, 0.00767379f, -0.06230991f, -0.08613344f, 
    -0.25358030f, 0.00656393f, 0.16780932f, -0.17741244f, 0.02033761f, -0.06787725f, -0.04238924f, 0.11191545f, 
    -0.03920526f, 0.11251591f, 0.04576149f, -0.09796524f, -0.00191569f, 0.08848792f, -0.12247699f, -0.03370041f, 
    -0.02507262f, -0.08303798f, 0.12879758f, 0.00570171f, -0.21206190f, 0.04327492f, -0.09435081f, -0.02514150f, 
    -0.07675818f, -0.04608949f, -0.07963396f, -0.02741367f, -0.07778259f, 0.09341562f, -0.06746962f, 0.04001613f, 
    0.00378809f, 0.01739442f, -0.00999984f, 0.07580018f, 0.00401021f, 0.03511933f, 0.01230734f, -0.01249432f, 
    0.08469091f, 0.15412542f, 0.00209935f, 0.08369742f, -0.05578572f, 0.11643952f, -0.01663837f, -0.03701958f, 
    0.10886972f, 0.02064670f, 0.00533910f, 0.01661679f, 0.03109793f, -0.01059033f, 0.02446176f, 0.08153334f, 
    0.04906874f, 0.05025923f, -0.07066837f, -0.02710269f, -0.08868527f, 0.19865729f, -0.10072296f, -0.06969261f, 
    -0.00838312f, 0.06548741f, -0.01929545f, 0.05430789f, -0.01300310f, 0.10141081f, 0.00441908f, -0.05308148f, 
    -0.00122579f, -0.00815974f, -0.02676679f, 0.01187275f, -0.06324379f, -0.06028677f, 0.03517432f, 0.02424756f, 
    -0.00735183f, -0.07643096f, 0.14079766f, 0.07797775f, 0.09999068f, 0.08574732f, -0.01845283f, -0.01654792f, 
    0.07564998f, -0.03796573f, 0.01759368f, -0.05310972f, 0.00741000f, 0.07535852f, -0.02066658f, 0.01007006f, 
    0.03115903f, 0.05918442f, -0.02223047f, -0.05283862f, 0.08081112f, -0.35845941f, -0.07744254f, 0.12506594f, 
    0.07375932f, -0.04024401f, 0.10349021f, -0.04428384f, -0.01969531f, 0.12058578f, -0.02768663f, 0.06887719f, 
    -0.01328515f, 0.02261893f, 0.03522353f, 0.02075377f, -0.04641833f, 0.10160581f, -0.04224333f, 0.08789635f, 
    0.24027158f, 0.19725464f, 0.09271626f, 0.19114728f, -0.00646584f, -0.06244318f, 0.00570887f, -0.02034948f, 
    -0.04905066f, -0.03822706f, -0.04106216f, -0.06791294f, 0.00433748f, -0.14333937f, 0.03518759f, 0.05663093f, 
    -0.02632080f, 0.06965704f, 0.02189944f, 0.00753142f, 0.19134520f, -0.13047376f, 0.01854614f, 0.14636511f, 
    0.07730879f, 0.00701097f, -0.02447286f, 0.05029316f, -0.10915617f, -0.06085775f, 0.05613330f, 0.02879083f, 
    0.00668845f, -0.04019266f, -0.08759663f, -0.03661784f, 0.07100074f, -0.07513753f, 0.11975420f, 0.09564324f, 
    -0.22371943f, 0.00452046f, -0.01876701f, -0.07279997f, 0.04474815f, 0.03815370f, -0.02584605f, -0.03799643f, 
    0.01541680f, 0.04041262f, 0.05819395f, 0.01267008f, 0.00139286f, -0.12891625f, 0.11787432f, -0.03359229f, 
    -0.02848627f, 0.09354378f, 0.02148369f, 0.02467496f, -0.18130766f, 0.13119832f, -0.00965601f, -0.14777778f, 
    -0.09171351f, 0.13961479f, 0.01888455f, 0.10528878f, 0.06567828f, 0.06713741f, -0.03010368f, -0.01122727f, 
    0.15968254f, 0.03561214f, 0.01269088f, 0.04411547f, 0.09505386f, 0.07522108f, 0.03002551f, -0.02842645f, 
    -0.29551733f, 0.06968440f, 0.13627666f, 0.20261502f, -0.10169605f, 0.05760186f, 0.00780802f, 0.07440492f, 
    -0.04848432f, -0.04514674f, 0.04114036f, -0.09532093f, -0.04780681f, 0.07005763f, -0.03432043f, 0.05755482f, 
    0.03588938f, -0.10054864f, 0.05980188f, 0.06266471f, -0.22407991f, 0.10069088f, -0.10945413f, -0.10673645f, 
    -0.13338462f, 0.09463941f, 0.03453832f, 0.03904510f, 0.09378958f, 0.04446973f, 0.03131942f, 0.12390751f, 
    0.01492960f, 0.00097815f, 0.06166940f, -0.07524771f, 0.08526403f, -0.02208371f, 0.04439275f, -0.06270598f, 
    -0.13199134f, 0.19519636f, 0.02242294f, -0.01204404f, -0.18938546f, -0.04413465f, -0.01388794f, 0.04270781f, 
    0.05055115f, 0.02193735f, 0.05797988f, 0.03048642f, -0.02807315f, 0.13967264f, 0.09164716f, -0.03300736f, 
    0.09177134f, 0.12128098f, -0.03419201f, 0.05263565f, 0.07107796f, 0.00052771f, 0.18019015f, 0.10098560f, 
    0.13227856f, 0.03806382f, -0.00421063f, -0.12158497f, 0.02698278f, 0.01085767f, 0.02194709f, -0.01492748f, 
    -0.01635720f, -0.10808961f, 0.01640594f, 0.00595667f, 0.00562643f, 0.08209054f, 0.05805868f, -0.02449462f, 
    -0.02127282f, 0.11081532f, 0.14008473f, 0.14514172f, -0.01726712f, 0.03706497f, 0.03851252f, -0.09878866f, 
    0.05415098f, 0.02878454f, 0.00739835f, 0.09825323f, -0.01583841f, -0.00974374f, 0.04375460f, 0.01169555f, 
    -0.08267464f, 0.10181425f, 0.10249563f, -0.01946708f, -0.21803403f, -0.20695774f, -0.13210417f, -0.08858062f, 
    0.21094295f, -0.21350630f, -0.06302977f, -0.06526377f, -0.09467521f, -0.08557677f, -0.03183743f, -0.04360787f, 
    -0.08419710f, -0.21791869f, -0.02715005f, -0.00664949f, 0.04939253f, -0.21760972f, -0.07994562f, 0.01584134f, 
    0.27887666f, 0.11418472f, -0.18635561f, 0.24775691f, -0.07365234f, 0.09661160f, 0.07582290f, 0.03704111f, 
    0.04406368f, -0.08968941f, -0.01855747f, 0.06763946f, 0.00773154f, 0.08881783f, 0.06269482f, 0.07264089f, 
    0.02702409f, 0.02038272f, -0.02693007f, 0.03124243f, 0.22668552f, 0.13788109f, 0.17414987f, -0.23925428f, 
    -0.02291242f, 0.09352560f, 0.07948851f, 0.00745738f, -0.01350171f, -0.06422973f, 0.01465934f, -0.04518296f, 
    -0.06420638f, -0.00050655f, 0.00528275f, -0.04526396f, 0.07093918f, -0.12309191f, 0.03834605f, -0.05443204f, 
    0.02465714f, -0.00713090f, -0.06062245f, 0.01977651f, 0.02429381f, -0.10184184f, -0.02973923f, -0.08265223f, 
    -0.07918081f, -0.07303866f, 0.06616138f, -0.01239580f, -0.14659181f, -0.04975320f, -0.05453779f, -0.10150331f, 
    -0.09248494f, -0.13695656f, 0.03473443f, -0.11435074f, 0.17440490f, 0.00250423f, 0.06780347f, 0.16974224f, 
    0.19019336f, -0.02400823f, -0.04740103f, -0.11620626f, -0.03766276f, 0.02322132f, 0.01073524f, -0.00232933f, 
    -0.06987255f, 0.08135094f, -0.08273350f, 0.15449087f, 0.08589147f, -0.02926551f, 0.00573153f, 0.01085008f, 
    0.19495176f, -0.09911756f, -0.22457516f, -0.12803097f, -0.02223034f, -0.03132024f, -0.01475203f, 0.06275582f, 
    -0.01029076f, 0.04160803f, -0.06567307f, 0.01295454f, 0.01591479f, -0.05362598f, 0.09851027f, 0.02721448f, 
    0.03191664f, -0.16678207f, -0.08423844f, 0.06604891f, 0.00187355f, 0.14581953f, 0.07491777f, -0.07297549f, 
    -0.19129939f, -0.03575826f, -0.11497546f, 0.04528944f, 0.01974459f, -0.10499676f, 0.06543028f, 0.01484877f, 
    0.11669166f, 0.10406587f, -0.01609448f, 0.08490440f, 0.01012011f, -0.05933941f, -0.03275238f, 0.01381590f, 
    -0.17662695f, 0.00586198f, -0.09360500f, 0.01815354f, -0.00271126f, -0.03561827f, -0.01788652f, -0.01186571f, 
    -0.02954949f, -0.00563066f, 0.05194058f, -0.10627706f, 0.06004974f, 0.07042281f, -0.02920171f, 0.03590378f, 
    0.05477351f, -0.08556624f, -0.04294513f, -0.00889202f, 0.29182974f, -0.03261703f, 0.05715256f, -0.03937137f, 
    0.16417426f, 0.07940257f, 0.01441720f, -0.02633151f, -0.04391841f, 0.04788703f, 0.07945108f, 0.06684840f, 
    0.02370411f, 0.06007221f, 0.02340457f, -0.00065739f, 0.02273239f, -0.00477402f, -0.02383736f, 0.09865594f, 
    -0.18679497f, -0.06085840f, -0.05795159f, -0.05614183f, 0.07135694f, 0.07021449f, 0.11100984f, 0.04162864f, 
    0.02708144f, 0.01783719f, 0.06054326f, 0.06074313f, 0.05025828f, 0.07017217f, -0.00551090f, -0.01967042f, 
    -0.00492037f, -0.06200589f, 0.03203153f, 0.05001145f, -0.08790475f, -0.00105746f, -0.04473468f, -0.03907862f, 
    0.22629768f, 0.03680744f, 0.05358380f, 0.14089471f, 0.07875260f, -0.01237071f, -0.00459348f, -0.07517789f, 
    0.03575870f, 0.02988913f, 0.08728922f, 0.02007936f, 0.02656932f, 0.01028351f, -0.02186743f, -0.04609914f, 
    0.17362919f, -0.08980919f, -0.03990326f, 0.05188435f, -0.07292499f, 0.00151760f, 0.01708242f, -0.09855562f, 
    0.01108017f, 0.03683132f, 0.03011299f, 0.11441189f, -0.03171295f, 0.01233122f, 0.07922643f, -0.00861063f, 
    0.07280090f, 0.05528073f, -0.09371278f, 0.04986185f, -0.21843600f, 0.02403852f, 0.00037065f, -0.07749856f, 
    0.15657669f, 0.11412492f, 0.01096441f, 0.09250333f, 0.04239196f, -0.07379340f, 0.00557463f, 0.05848515f, 
    0.01296937f, -0.04623302f, -0.06874118f, -0.05992441f, 0.04126597f, 0.00361525f, 0.01121698f, 0.04126770f, 
    -0.22226237f, 0.14681086f, 0.00630657f, -0.07779755f, 0.12249266f, -0.01872526f, 0.09586561f, -0.00800945f, 
    0.03399957f, 0.03668930f, 0.02430237f, -0.03591972f, 0.05769766f, 0.01324063f, -0.01562412f, 0.07545069f, 
    0.11117810f, 0.00400498f, 0.01163423f, 0.02518046f, 0.17865151f, 0.00409578f, -0.12332933f, 0.03237314f, 
    0.15413253f, 0.07321573f, 0.05290850f, 0.03435812f, -0.00377840f, -0.02203870f, 0.00861504f, 0.08815408f, 
    0.05026244f, 0.06428491f, 0.10615059f, -0.03420311f, -0.03476386f, -0.02277719f, 0.11478492f, 0.05253588f, 
    0.10939040f, -0.02046441f, 0.09025025f, 0.00255029f, 0.04668331f, -0.03072768f, 0.07861066f, -0.02268093f, 
    0.08257293f, 0.05401032f, -0.06331557f, 0.08083086f, 0.07085200f, -0.04859765f, 0.03393712f, -0.08106396f, 
    0.08581679f, 0.01926048f, -0.03778683f, 0.15433690f, -0.24369280f, 0.12459224f, 0.19827707f, 0.01868521f, 
    -0.21851696f, 0.11228052f, 0.13652444f, -0.07126758f, -0.10517220f, 0.03682979f, 0.05924556f, 0.03737100f, 
    0.04351526f, 0.10184082f, 0.13417597f, 0.12705930f, 0.06376339f, 0.04194747f, 0.08599708f, 0.03452513f, 
    -0.05976424f, -0.13151725f, -0.00065836f, -0.05229162f, 0.12576874f, 0.12751636f, 0.12878194f, -0.08158559f, 
    0.18793516f, 0.01510416f, -0.05623320f, 0.05837264f, 0.03028521f, -0.13218877f, -0.00529600f, 0.04609062f, 
    0.09068837f, 0.00880248f, -0.02270047f, 0.06057613f, 0.15085107f, -0.38667518f, 0.06461242f, 0.22337051f, 
    0.05802161f, -0.02181527f, 0.06411165f, 0.10098492f, 0.05031963f, 0.07197476f, 0.05557457f, 0.11448595f, 
    0.02124084f, -0.00714318f, 0.08974605f, 0.07229285f, -0.01595875f, 0.05662083f, -0.04127481f, -0.00574081f, 
    -0.13100056f, -0.09356173f, 0.21699345f, 0.05321349f, -0.01855933f, -0.08348852f, -0.05471292f, 0.12563092f, 
    -0.01880844f, 0.14583220f, -0.01088072f, -0.10028858f, 0.03935107f, 0.06335948f, 0.10615075f, -0.00249285f, 
    0.05863989f, 0.08139938f, 0.07256144f, -0.00885808f, -0.10555609f, 0.19554141f, 0.26848626f, 0.07324748f, 
    -0.24339515f, 0.00056257f, -0.05327342f, 0.02112713f, -0.10079360f, -0.00898956f, -0.01353696f, 0.05315675f, 
    0.03988437f, 0.06069979f, 0.11991116f, -0.10104577f, -0.03571433f, -0.03668053f, 0.02139569f, -0.06138891f, 
    -0.10454924f, 0.02619676f, 0.04752329f, 0.04947952f, 0.18174201f, -0.01401080f, 0.15550365f, 0.08753900f, 
    -0.03102146f, 0.01790821f, 0.00584968f, -0.00136473f, 0.08306594f, -0.03695658f, -0.04640799f, 0.00275049f, 
    0.10507670f, -0.02616690f, 0.10824601f, 0.00007498f, 0.04957473f, 0.09646698f, -0.20045860f, -0.05657223f, 
    -0.16870813f, 0.10216702f, 0.09611665f, 0.02186946f, 0.02389874f, -0.04022364f, 0.10379898f, -0.01897920f, 
    -0.06475806f, 0.01502508f, 0.07989996f, -0.00254516f, -0.00326568f, 0.04018496f, -0.07318682f, -0.13794746f, 
    -0.05509752f, -0.05550825f, -0.05640667f, -0.01146422f, -0.03020892f, -0.00631974f, -0.02378972f, -0.02461392f, 
    0.04464447f, 0.00713476f, -0.03747253f, -0.02073647f, -0.05057168f, 0.11478069f, 0.08202299f, -0.04670798f, 
    0.00899560f, -0.06653538f, -0.10942733f, 0.02036473f, -0.09130366f, -0.02062102f, 0.05987596f, -0.03140902f, 
    -0.02211445f, 0.04029113f, 0.02941714f, 0.02892982f, 0.10921096f, 0.02644926f, 0.05362040f, -0.06422379f, 
    0.05730325f, 0.10369777f, 0.01016041f, 0.03359884f, 0.00901688f, 0.06959107f, -0.11005445f, 0.07198345f, 
    -0.23434162f, -0.00993297f, 0.03244524f, 0.05885030f, -0.03259906f, 0.08391289f, 0.03812347f, 0.04902098f, 
    0.06227530f, 0.02941620f, 0.01136542f, 0.08218949f, 0.07013809f, 0.03741112f, -0.05409384f, 0.01285082f, 
    0.02322375f, -0.02940585f, 0.04365958f, 0.09470068f, -0.07250447f, -0.01723475f, -0.07573590f, -0.00614454f, 
    -0.06545734f, 0.13123299f, 0.05303309f, 0.04509417f, -0.02717730f, 0.08148145f, 0.04431480f, -0.04097706f, 
    -0.00185340f, 0.05915865f, 0.04381393f, 0.03268283f, -0.02116013f, -0.03158783f, 0.01687029f, 0.06070549f, 
    0.14852899f, 0.13307756f, 0.02748600f, 0.04406773f, -0.00907207f, -0.05417543f, 0.08894280f, 0.03261160f, 
    -0.05527207f, -0.06032561f, -0.05467732f, 0.02337806f, 0.10322548f, -0.04209013f, -0.07531288f, -0.00671283f, 
    -0.03473429f, 0.06233355f, 0.00177019f, 0.02973314f, -0.19470979f, -0.01512350f, -0.11419634f, 0.09734198f, 
    -0.07428476f, 0.10741587f, 0.03840516f, 0.00407933f, 0.07712011f, 0.03197801f, 0.05324545f, -0.00409226f, 
    0.03262948f, -0.00919724f, 0.04528651f, 0.06065806f, -0.00612214f, -0.02170456f, 0.02782699f, 0.04953324f, 
    -0.07043452f, -0.10676003f, -0.17560150f, -0.08302368f, -0.06646763f, 0.11733436f, 0.01521600f, -0.00575177f, 
    -0.00729756f, 0.17339054f, -0.06321894f, 0.10826610f, -0.06139039f, -0.06654539f, 0.10654822f, 0.06918809f, 
    0.02340110f, -0.02720767f, 0.07769958f, -0.00128133f, -0.07113904f, 0.01593556f, -0.08189670f, -0.00570232f, 
    -0.01322982f, -0.06159583f, 0.02259667f, 0.08139326f, 0.05570488f, 0.02455979f, -0.07361887f, 0.06040800f, 
    0.05302902f, 0.08813958f, 0.04011177f, 0.00309615f, -0.01130937f, 0.00400449f, 0.00503429f, 0.00848240f, 
    -0.21964066f, -0.01816518f, -0.13742913f, 0.09465864f, -0.10152095f, 0.10774532f, 0.05522548f, 0.06232858f, 
    0.00222832f, 0.09322281f, -0.03951211f, 0.01544345f, 0.04889407f, 0.03480722f, -0.04918467f, -0.04004600f, 
    0.08599646f, 0.01990735f, 0.03198098f, 0.06137970f, 0.34151259f, 0.17420164f, 0.17845657f, 0.19993821f, 
    0.09076247f, 0.05009248f, 0.07545268f, 0.00585186f, 0.04605284f, 0.01062183f, 0.01522069f, -0.00766842f, 
    0.06462633f, 0.06299902f, -0.06087364f, 0.01588898f, 0.06296472f, -0.00403997f, 0.07090923f, -0.06161228f, 
    -0.10602892f, -0.07200175f, -0.10069041f, -0.12167063f, -0.01960758f, -0.03113142f, -0.01263899f, -0.04642786f, 
    0.06151868f, 0.18332370f, -0.00298912f, 0.01275236f, 0.08273780f, -0.09786877f, 0.03431648f, 0.05444054f, 
    0.13672502f, -0.04725348f, 0.06729992f, 0.01220234f, -0.16960765f, -0.05324493f, -0.07118021f, 0.11470866f, 
    0.08765920f, -0.04486985f, 0.03290783f, 0.00322819f, -0.07166710f, -0.01221173f, 0.03985993f, -0.08326427f, 
    0.06280054f, 0.02068132f, -0.00117822f, -0.01043299f, -0.00707472f, 0.01903330f, 0.01073796f, 0.06849105f, 
    0.07508373f, -0.04548346f, 0.11039073f, 0.05689180f, -0.05681089f, -0.04381181f, -0.01502988f, 0.05685750f, 
    -0.04891417f, 0.01525782f, -0.01256711f, -0.03710409f, -0.00870192f, 0.04026495f, 0.02556374f, 0.03477899f, 
    0.00983126f, -0.09975418f, 0.04136626f, 0.01487403f, 0.19849688f, -0.09617762f, 0.14275087f, 0.02785033f, 
    -0.02459949f, -0.10229503f, 0.10589973f, -0.01049184f, -0.01656405f, 0.04945855f, 0.00244780f, 0.00467346f, 
    0.08446176f, -0.01465919f, 0.18490304f, 0.04563795f, 0.00423190f, 0.00010199f, -0.03658225f, 0.01659214f, 
    0.04432685f, 0.03422824f, -0.00978344f, 0.09430107f, -0.03445631f, -0.04212127f, -0.04471436f, 0.00206627f, 
    -0.04596641f, 0.04014072f, 0.04363641f, -0.05793151f, -0.07003558f, -0.09521561f, 0.00271371f, -0.07556634f, 
    -0.05658800f, 0.03548533f, 0.03156891f, -0.10853603f, -0.13618377f, 0.02634075f, 0.02513152f, -0.01505410f, 
    0.20377974f, 0.00153611f, -0.10302696f, -0.02560977f, -0.09905776f, -0.01184301f, -0.09460998f, -0.03926176f, 
    -0.03392531f, -0.04050987f, -0.05456718f, -0.02349755f, 0.02665063f, -0.01905576f, 0.08909126f, 0.02216032f, 
    -0.04441472f, -0.18390444f, -0.11079980f, -0.05194324f, -0.01832156f, 0.10346321f, -0.09631748f, 0.14762248f, 
    -0.00658739f, -0.13768858f, -0.06557711f, 0.11520331f, -0.07350541f, -0.06341945f, 0.00701554f, 0.00177893f, 
    0.09785587f, 0.21082665f, 0.05837663f, 0.07413495f, -0.05164256f, 0.03353185f, -0.11071735f, -0.03329534f, 
    -0.09515249f, 0.06216611f, 0.01409750f, -0.00648630f, -0.04594536f, 0.06585714f, 0.01407248f, 0.03084374f, 
    -0.02352913f, -0.07408514f, -0.05261926f, -0.00074121f, -0.00365584f, -0.01896592f, 0.20830753f, -0.08190241f, 
    0.06875712f, -0.08253370f, 0.00561252f, -0.11246705f, 0.06696256f, 0.06520540f, 0.06634647f, 0.03789755f, 
    0.07623857f, 0.00664977f, -0.03512899f, -0.02831039f, -0.09189472f, -0.11612333f, -0.12907417f, -0.04574624f, 
    0.08516292f, 0.07588354f, 0.07761323f, 0.05382238f, -0.06138922f, -0.10435518f, -0.13911384f, 0.01246781f, 
    0.10538848f, -0.00243360f, -0.02223948f, -0.04091678f, 0.09385253f, 0.14167194f, -0.02089056f, -0.04314829f, 
    -0.00252096f, 0.11626380f, -0.01884092f, 0.00351316f, 0.06648361f, -0.01628189f, 0.01195023f, 0.07170054f, 
    0.24706124f, 0.12164508f, -0.19395638f, -0.03668478f, 0.23879614f, -0.05633343f, 0.10406809f, 0.03408216f, 
    0.00286176f, 0.02424815f, -0.10152846f, 0.06650630f, -0.04288644f, -0.01391138f, -0.06903810f, 0.03606277f, 
    -0.00223234f, -0.06660654f, 0.12580463f, -0.01963849f, 0.13123928f, 0.04012820f, -0.11026025f, 0.03559721f, 
    0.01757489f, 0.12095018f, 0.05637528f, 0.13843270f, 0.06963298f, 0.25550085f, -0.04438543f, -0.04650059f, 
    0.02706553f, -0.07352125f, -0.02981011f, 0.03614414f, 0.01276440f, -0.03837885f, 0.04982130f, -0.05442077f, 
    0.06973421f, -0.22901064f, -0.01141233f, -0.03574298f, 0.06287736f, 0.10605787f, -0.07847087f, -0.03793069f, 
    0.02979378f, 0.14048590f, -0.01686525f, -0.01791808f, -0.00811859f, 0.06164677f, -0.02801781f, 0.06512757f, 
    -0.07830954f, 0.12515083f, -0.12590800f, 0.08053238f, -0.07718418f, -0.02885773f, 0.00579785f, -0.01801251f, 
    0.10556150f, -0.11282709f, 0.10600650f, -0.09591836f, 0.04650064f, 0.04726732f, -0.01439662f, 0.01638751f, 
    -0.00254620f, -0.09004841f, -0.10524195f, 0.09538165f, 0.01908214f, 0.00828914f, 0.16400875f, 0.00699209f, 
    0.13626017f, -0.07793777f, -0.00860743f, -0.11605708f, -0.01616530f, 0.07038900f, -0.05846869f, -0.12634028f, 
    -0.09217028f, -0.00430940f, -0.07255958f, -0.00335434f, -0.06609475f, 0.01785514f, -0.05703360f, 0.16366987f, 
    -0.00819018f, 0.04316209f, 0.15385522f, -0.00206593f, 0.04034001f, 0.28445077f, 0.26448113f, 0.05045090f, 
    -0.12831250f, -0.07788604f, -0.04546399f, 0.01213265f, -0.02295665f, 0.08977619f, 0.11162955f, 0.10017245f, 
    0.03839901f, -0.01563512f, -0.02761919f, 0.01075338f, -0.10205001f, -0.11835925f, -0.04493409f, 0.00275618f, 
    -0.05557097f, -0.08790755f, -0.16501908f, 0.01758368f, 0.07435085f, -0.03622716f, -0.11943451f, 0.07607181f, 
    0.12044403f, 0.02175942f, 0.13375460f, -0.03006598f, -0.11489845f, -0.11472237f, -0.07446821f, -0.04565862f, 
    -0.03883127f, -0.00511228f, 0.15980935f, -0.09912375f, 0.16429490f, 0.10664771f, -0.33393270f, -0.13821103f, 
    -0.04985503f, -0.03665542f, 0.07456665f, 0.05697262f, 0.03810177f, 0.22377923f, -0.19163534f, -0.06597339f, 
    0.00298473f, -0.05629456f, -0.00058958f, 0.10440733f, -0.02027882f, -0.05802844f, 0.01625808f, -0.05975970f, 
    0.01787112f, 0.23068556f, 0.10758281f, 0.09913592f, 0.00750424f, 0.02634539f, 0.05784497f, -0.02135795f, 
    -0.10499438f, 0.00121708f, -0.06785619f, 0.10582029f, 0.02929621f, 0.07520401f, -0.03664802f, 0.03568101f, 
    0.07769879f, 0.03251585f, 0.03197311f, -0.00213946f, 0.09094941f, 0.18294920f, 0.21235126f, 0.05369307f, 
    -0.01905135f, -0.15190819f, 0.06219126f, -0.05932336f, -0.00872410f, -0.09737992f, -0.01687633f, 0.05351486f, 
    0.11007373f, -0.05733594f, 0.03157863f, -0.02334946f, 0.09279533f, -0.05578646f, -0.04593347f, 0.04260381f, 
    -0.17187703f, 0.08180968f, -0.09500418f, 0.15922193f, -0.06032749f, 0.11778105f, -0.03407273f, 0.04423536f, 
    0.03045321f, 0.05822768f, -0.03610286f, 0.00888107f, -0.03209430f, -0.02775966f, -0.07300793f, 0.01089788f, 
    0.05621714f, -0.09974041f, -0.04968258f, -0.08715033f, 0.24160589f, -0.19531235f, -0.11882438f, -0.25108856f, 
    -0.02548885f, 0.04276321f, 0.06324822f, 0.09663224f, -0.08438135f, 0.17010242f, -0.07107396f, 0.09065731f, 
    0.02419627f, 0.06730299f, 0.08332643f, 0.06270506f, -0.09153792f, -0.09797341f, -0.20102942f, -0.04081782f, 
    0.02930709f, -0.26327211f, 0.00028517f, 0.20748895f, -0.25037402f, 0.01659237f, 0.07521731f, -0.01917623f, 
    0.11267079f, 0.11146343f, -0.09991530f, -0.08893622f, 0.05142647f, 0.04232740f, 0.09055708f, 0.01604153f, 
    -0.04243932f, 0.08603048f, 0.01131110f, -0.03772376f, 0.32948315f, -0.22638462f, -0.09052013f, 0.17771932f, 
    -0.13439056f, -0.00107444f, 0.01760632f, -0.03149347f, -0.01573160f, 0.03797480f, 0.05811871f, 0.05308789f, 
    0.01018767f, -0.02840601f, -0.07036591f, 0.01759313f, 0.03194785f, 0.00260725f, 0.17784615f, -0.01438283f, 
    -0.19171366f, -0.25319877f, -0.07982218f, 0.16736896f, -0.00644679f, 0.00629438f, -0.01024158f, -0.03268033f, 
    0.05456294f, 0.04466418f, -0.02687708f, 0.02033086f, 0.04431216f, -0.11061507f, 0.04091170f, -0.06029705f, 
    0.00659528f, 0.09199800f, 0.00260782f, 0.01903862f, -0.09923717f, 0.02873889f, -0.12233613f, 0.07941354f, 
    0.03398957f, 0.05477482f, 0.05143589f, 0.02164823f, 0.07680145f, 0.09713341f, 0.05277331f, -0.06714535f, 
    0.02336286f, 0.06075693f, -0.02484914f, -0.01982927f, 0.03148086f, -0.00144774f, 0.03818932f, -0.05931982f, 
    0.24629280f, 0.09140387f, -0.11617216f, 0.07957736f, -0.03493144f, 0.07468307f, 0.10591144f, 0.10285293f, 
    0.04903589f, -0.01650057f, 0.07910548f, 0.00694241f, -0.03284809f, 0.10385999f, -0.07609390f, 0.02047707f, 
    0.03340565f, -0.00590595f, 0.02946512f, -0.00977340f, -0.00601036f, -0.03543036f, -0.24457194f, 0.03871205f, 
    -0.07158962f, 0.01332848f, 0.04256875f, -0.02664363f, 0.08939502f, 0.10093240f, 0.03362843f, 0.03376615f, 
    -0.00343307f, 0.03823776f, 0.03567725f, 0.00185862f, -0.06201750f, 0.08223844f, 0.03687830f, 0.01496943f, 
    -0.22920638f, -0.04270952f, 0.01684573f, -0.03588249f, 0.03786169f, 0.01427792f, -0.04728358f, -0.09840634f, 
    0.05017847f, 0.11291803f, 0.06887712f, -0.03052789f, -0.01662942f, 0.12324646f, 0.05711264f, 0.03292747f, 
    0.01031130f, 0.11239018f, 0.04395400f, 0.02697789f, 0.08513060f, -0.24269268f, -0.02247684f, 0.11240087f, 
    0.01014335f, 0.05369624f, 0.07466687f, -0.08698214f, -0.00656746f, 0.13453774f, 0.07270318f, 0.00771122f, 
    0.06093956f, 0.02914261f, -0.00817952f, -0.04777378f, 0.03527352f, -0.02405492f, 0.08697361f, 0.01721833f, 
    0.06378082f, -0.18933319f, -0.09529890f, 0.12857954f, -0.20800422f, -0.04545327f, 0.03858119f, -0.07061651f, 
    0.13262632f, 0.12863807f, 0.10653286f, 0.08437189f, 0.04297114f, -0.04864278f, 0.02207194f, -0.05138831f, 
    0.02881491f, -0.03259230f, 0.07753901f, 0.08092684f, -0.28987458f, 0.09389022f, 0.25298372f, -0.11056902f, 
    -0.02556319f, 0.00803244f, 0.01758968f, 0.12761375f, 0.05519476f, -0.01524402f, -0.08534517f, -0.06334023f, 
    -0.03811655f, -0.01959531f, -0.00737187f, 0.06277510f, -0.01039519f, 0.00377939f, 0.02267056f, 0.05918386f, 
    -0.05744703f, -0.18505432f, -0.27753657f, 0.13143310f, -0.04366116f, 0.09204729f, 0.06435486f, -0.06131845f, 
    0.10172784f, 0.13919140f, 0.01556157f, 0.05482878f, -0.02101943f, 0.05020161f, 0.09734815f, 0.07400914f, 
    -0.04862211f, 0.04297717f, 0.03539547f, 0.09819041f, 0.48745957f, -0.01357541f, -0.02357951f, -0.07924595f, 
    0.08069830f, -0.02182997f, -0.00592300f, 0.11269785f, 0.00616617f, -0.01905246f, 0.06643905f, 0.01610223f, 
    0.06866557f, -0.08682393f, 0.09867033f, -0.04494113f, -0.01872264f, 0.06918391f, -0.01849597f, -0.00279467f, 
    -0.22032446f, -0.01163015f, 0.15363228f, -0.06061818f, -0.16558935f, -0.06184513f, 0.10937352f, 0.10677739f, 
    -0.04745556f, -0.07383376f, 0.02937225f, -0.08020785f, -0.02247021f, 0.06112538f, 0.02594553f, -0.08925867f, 
    0.02615383f, 0.04668503f, 0.12538551f, 0.01500480f, -0.01555762f, -0.04340839f, 0.24311560f, 0.00098322f, 
    0.06640315f, -0.02907778f, -0.01265797f, -0.00235977f, -0.02908645f, 0.06342298f, -0.13363639f, 0.06623572f, 
    0.02356285f, -0.02522238f, 0.02688422f, 0.05429071f, 0.08253567f, -0.00848436f, -0.07546755f, -0.00775680f, 
    0.19087015f, -0.11665303f, -0.18957320f, 0.01275704f, 0.01115842f, -0.03856850f, 0.03269264f, 0.02424040f, 
    -0.04263190f, 0.06918129f, -0.04484073f, -0.08006807f, 0.00582976f, 0.08242474f, -0.02326946f, 0.01867656f, 
    -0.09573954f, -0.05035588f, 0.04960010f, 0.06634220f, 0.10279863f, 0.22919819f, 0.10877567f, -0.11893471f, 
    0.11359248f, 0.10189117f, -0.08154818f, 0.11875945f, 0.05978251f, -0.03109019f, 0.14158584f, -0.04752600f, 
    0.03912238f, 0.01077981f, 0.03297569f, 0.04749150f, 0.01860359f, 0.01412616f, 0.12003811f, -0.06104532f, 
    -0.04212142f, 0.14349671f, -0.09871617f, -0.21812221f, -0.11262371f, 0.07188486f, 0.02957826f, 0.02529495f, 
    0.10314319f, -0.02412727f, -0.05732172f, 0.04106081f, -0.01545213f, -0.00250835f, 0.05453843f, 0.01815661f, 
    0.03056671f, 0.13619931f, 0.04123781f, 0.09425650f, -0.11150333f, -0.07685677f, -0.08921693f, -0.06443997f, 
    -0.02222332f, -0.12762925f, -0.01592575f, 0.06801006f, -0.05970808f, 0.05196613f, 0.07210279f, 0.02530371f, 
    0.02789002f, -0.11940153f, 0.05646968f, 0.03885476f, 0.04653544f, 0.00277105f, 0.16486208f, 0.05410067f, 
    0.05685058f, -0.06947477f, 0.04666630f, -0.04615247f, -0.02485252f, 0.02298994f, 0.09794725f, 0.00511072f, 
    0.02393151f, -0.08516771f, 0.00800600f, -0.05153757f, -0.17379925f, -0.09320672f, 0.03673778f, -0.05493826f, 
    -0.00507840f, 0.09892891f, 0.03996001f, 0.10548119f, -0.02199872f, -0.13024527f, 0.12105358f, -0.00459986f, 
    0.06727990f, 0.02831339f, 0.02651558f, -0.07010293f, -0.02062166f, 0.10269975f, 0.04956653f, -0.05157736f, 
    -0.01336708f, 0.15718271f, 0.05094629f, 0.01953257f, 0.06512189f, -0.09641736f, -0.04038947f, -0.01127610f, 
    0.39410871f, -0.08077956f, 0.07262263f, -0.00166197f, 0.18471983f, -0.02308073f, 0.01710937f, 0.07275076f, 
    -0.07015102f, 0.13262765f, 0.05770328f, -0.00728444f, -0.08908789f, -0.03952698f, 0.02429662f, -0.05444744f, 
    0.03571438f, -0.00314269f, 0.06814317f, 0.03159339f, 0.07207125f, 0.09495027f, -0.04767938f, 0.03071954f, 
    0.07998595f, 0.06556153f, -0.00357868f, 0.04266152f, 0.01912806f, 0.14717726f, 0.08183889f, -0.06463851f, 
    0.05797809f, 0.02458153f, 0.07486904f, -0.01829857f, -0.05839260f, -0.02361954f, 0.01161372f, 0.00318592f, 
    0.07791221f, -0.33861318f, 0.21265393f, -0.01934345f, 0.04067278f, 0.09160975f, 0.00013304f, -0.09412884f, 
    0.04867479f, 0.07768013f, -0.09748885f, 0.01175492f, -0.04783257f, 0.13502751f, 0.01445529f, 0.00784291f, 
    -0.14819609f, 0.14510037f, -0.08332378f, 0.00148030f, -0.16833493f, -0.13131660f, 0.01203651f, -0.10982687f, 
    -0.06277458f, -0.05682516f, 0.00757174f, 0.01748529f, -0.01024146f, -0.05561097f, 0.04505792f, 0.01163167f, 
    -0.04121727f, 0.02282394f, -0.04484453f, 0.13825634f, -0.08367412f, -0.02225404f, 0.12454032f, 0.00110234f, 
    0.07242700f, -0.23153894f, -0.13802236f, -0.10737580f, -0.04251851f, -0.05570901f, -0.11419734f, -0.04018301f, 
    -0.06644829f, -0.02293474f, -0.03614656f, -0.02196796f, 0.04472389f, 0.04108948f, -0.07091051f, 0.05277501f, 
    0.02229552f, 0.06023009f, 0.09287282f, 0.00740936f, 0.30052361f, 0.28876856f, 0.14455396f, 0.06750727f, 
    -0.02638078f, 0.02196346f, 0.00594265f, 0.05378460f, -0.09158748f, -0.07454355f, 0.07991491f, 0.08483221f, 
    0.05735384f, 0.00552005f, -0.02169776f, -0.00835133f, -0.01576088f, -0.02488250f, -0.00962979f, -0.06743850f, 
    -0.06134418f, -0.01027163f, 0.02842708f, 0.01801551f, 0.00021452f, 0.00366863f, -0.11519466f, -0.02433054f, 
    0.04499543f, 0.03836517f, -0.00197030f, -0.02664214f, -0.05520523f, 0.06577524f, 0.03202107f, 0.07531545f, 
    -0.04051977f, 0.03500296f, 0.07362893f, -0.00026850f, 0.33439282f, -0.00167680f, -0.06044937f, 0.15868133f, 
    0.05443383f, 0.06130270f, -0.01214151f, 0.05084474f, 0.01004936f, 0.07599870f, -0.04435760f, -0.06701203f, 
    0.08222581f, 0.06315354f, -0.02969815f, 0.08250305f, -0.08017480f, -0.06803654f, -0.05108172f, -0.02521001f, 
    0.22076835f, 0.11495676f, -0.06407327f, -0.09045870f, -0.03464969f, 0.06751211f, 0.02257419f, -0.05030087f, 
    -0.07001933f, -0.09552658f, -0.09035351f, 0.01230660f, 0.05971890f, 0.02001234f, -0.01663949f, -0.04696710f, 
    0.03261951f, 0.02874906f, 0.03451924f, -0.02194104f, 0.00081259f, 0.02360645f, -0.02336707f, -0.16047809f, 
    -0.13819420f, 0.02153039f, 0.10878001f, -0.05335065f, -0.00767193f, 0.00430210f, 0.03542518f, 0.06122095f, 
    0.08732001f, -0.00882516f, 0.00003061f, 0.06126180f, 0.14456935f, 0.00755917f, -0.04102634f, 0.02410209f, 
    -0.22400221f, 0.16876435f, -0.07470904f, 0.19027978f, -0.06186277f, 0.08077941f, 0.01429650f, -0.00034548f, 
    0.11181168f, 0.10619523f, -0.00591208f, -0.02570264f, 0.02820730f, 0.04062577f, -0.02023750f, -0.03702786f, 
    0.06742030f, 0.03057211f, -0.06506623f, -0.01916293f, 0.28043082f, -0.20409493f, -0.04809663f, 0.01397125f, 
    0.13574755f, 0.02552969f, 0.06714141f, 0.04236946f, -0.00770483f, 0.10037432f, -0.04152895f, 0.03110638f, 
    0.09353852f, 0.13219276f, 0.08931764f, 0.11712160f, -0.05744246f, -0.14792871f, -0.15907840f, 0.00274968f, 
    -0.25727943f, 0.21447128f, -0.06830176f, -0.00815451f, 0.05506953f, -0.08366510f, -0.03756597f, 0.01963456f, 
    -0.01106796f, -0.01115825f, 0.09630456f, 0.02053800f, 0.01711635f, 0.05326549f, 0.04217186f, 0.03927744f, 
    0.15336584f, -0.00622557f, 0.01852437f, 0.10822283f, 0.07217412f, 0.11203413f, 0.04813945f, -0.07791872f, 
    0.20030254f, 0.09201541f, -0.02663218f, 0.09285335f, -0.06070478f, 0.04514828f, 0.04435804f, 0.01852891f, 
    0.03508285f, -0.01306591f, 0.07928662f, -0.01899144f, 0.05709768f, 0.05748177f, 0.08943373f, 0.05901076f, 
    0.11472622f, 0.24529538f, -0.13756645f, -0.11871075f, 0.01565538f, -0.04215487f, -0.05887296f, 0.03745609f, 
    -0.09971895f, -0.00988199f, 0.03911438f, 0.05885610f, -0.09299660f, 0.02007811f, 0.00308283f, -0.04273245f, 
    -0.03779269f, -0.01224479f, -0.00379439f, 0.03667412f, -0.00215062f, -0.07026412f, 0.00553197f, -0.02224912f, 
    0.08540609f, -0.10617514f, -0.14699648f, -0.03301420f, 0.01379280f, 0.07256018f, -0.03147624f, 0.00907402f, 
    0.08642006f, 0.04228499f, -0.02769604f, 0.00911862f, -0.03806470f, 0.03989619f, 0.00308326f, 0.00231806f, 
    -0.02766057f, -0.01644737f, 0.04227465f, -0.03237683f, 0.08453033f, 0.05451356f, 0.05227062f, 0.00929012f, 
    0.03333842f, 0.06024263f, 0.03214431f, 0.02462910f, 0.01284176f, 0.03096087f, 0.02219037f, -0.01041095f, 
    0.06909102f, -0.00598960f, -0.06613734f, -0.03369178f, 0.02809922f, 0.01870056f, 0.03300302f, -0.09075470f, 
    0.10582607f, 0.06542115f, -0.10278063f, 0.03932092f, -0.07112563f, -0.06355426f, 0.00251575f, -0.01176344f, 
    0.05495767f, 0.00683432f, 0.00936669f, -0.07176016f, 0.10900635f, 0.03036061f, 0.08606455f, 0.00802033f, 
    0.00342478f, 0.01168550f, -0.10943283f, 0.12231834f, 0.04738586f, -0.10509244f, 0.04307450f, 0.05639368f, 
    -0.08998943f, -0.01747078f, -0.05667500f, -0.00293814f, 0.01133322f, 0.05091593f, -0.06723122f, 0.02004457f, 
    -0.02891802f, 0.04623432f, -0.00371324f, 0.05381737f, 0.20672704f, 0.23000194f, -0.08661138f, -0.04841028f, 
    0.13005762f, -0.06270391f, -0.10295247f, 0.03099108f, 0.04215390f, -0.04703758f, 0.06100298f, 0.11722165f, 
    -0.01465741f, 0.00674755f, 0.05101199f, 0.12550539f, -0.03829486f, 0.05572794f, 0.23053809f, 0.03257003f, 
    -0.02674552f, 0.21324338f, 0.13224429f, -0.03502110f, 0.17200235f, -0.11197703f, -0.06631486f, -0.05718474f, 
    -0.05162062f, 0.02195060f, -0.11379795f, -0.02441725f, 0.05679797f, -0.07046140f, 0.05128559f, 0.00367885f, 
    0.08886316f, 0.07373665f, 0.02775795f, 0.07260967f, -0.24659616f, -0.07875674f, -0.06770020f, -0.10702911f, 
    -0.23547632f, 0.14102840f, 0.10021708f, -0.04294482f, -0.05064132f, 0.10956383f, 0.14892033f, 0.03671615f, 
    -0.02120630f, 0.05818047f, 0.11920109f, 0.05416194f, 0.02205903f, -0.01401701f, -0.04897869f, -0.04367588f, 
    0.12487320f, -0.06757502f, -0.06134315f, -0.15913633f, 0.04957810f, -0.11203878f, -0.11606680f, -0.00607707f, 
    0.07068978f, 0.00357356f, -0.05014737f, 0.07219468f, 0.08042594f, 0.00379283f, 0.04404417f, 0.06278399f, 
    -0.02764798f, 0.01882335f, 0.03065389f, 0.09452404f, -0.01019182f, -0.17273460f, -0.01966466f, 0.12405655f, 
    -0.04442010f, -0.09779462f, 0.01207786f, 0.05332959f, 0.12723078f, 0.05092558f, -0.15133566f, 0.08587155f, 
    0.03962655f, 0.11457624f, 0.07762676f, 0.04467912f, 0.06179717f, 0.06981877f, -0.19016783f, -0.07200654f, 
    -0.31933144f, -0.11630008f, 0.09321139f, 0.08152723f, 0.08290598f, 0.05232934f, 0.01571491f, 0.01048790f, 
    -0.02311646f, 0.06277473f, 0.04876139f, -0.00194641f, 0.09226554f, 0.04812325f, 0.01534317f, 0.10759016f, 
    0.07827526f, 0.12888958f, -0.01290706f, -0.00794229f, -0.14257696f, 0.08681449f, 0.09539943f, -0.02910472f, 
    -0.21687454f, 0.05880772f, 0.06063211f, -0.05232032f, -0.06469464f, -0.04314749f, 0.03537176f, -0.04152072f, 
    0.02435619f, -0.03218873f, 0.01493445f, 0.02146709f, 0.00529144f, -0.10566912f, -0.01480925f, -0.00389109f, 
    -0.18780619f, 0.01685798f, 0.01350795f, 0.15451191f, 0.10837321f, -0.00707240f, 0.12255364f, 0.12072151f, 
    0.01562061f, -0.07029994f, 0.12863252f, 0.03755723f, 0.05872869f, 0.11350198f, -0.05307104f, 0.08429265f, 
    0.12861662f, -0.01665373f, 0.02441625f, -0.02271360f, -0.07423252f, -0.06328565f, -0.35792476f, -0.07795712f, 
    -0.24860452f, 0.12688802f, 0.11834257f, -0.11732381f, 0.12451489f, 0.03492134f, 0.07497452f, 0.03885281f, 
    -0.07694585f, 0.07218246f, 0.04975537f, -0.08148717f, 0.11819039f, 0.00987898f, -0.08953290f, -0.07430721f, 
    -0.02099925f, -0.06098574f, 0.02625256f, -0.06074945f, 0.04845940f, -0.00146391f, -0.03423520f, -0.00372400f, 
    0.03237368f, -0.05070961f, -0.03436841f, -0.04275791f, -0.05953155f, 0.02976345f, 0.03121832f, -0.04957259f, 
    -0.04159759f, 0.03946536f, 0.01241778f, -0.05543655f, 0.00796203f, -0.02422445f, -0.05960216f, -0.02887681f, 
    0.04050737f, 0.02054216f, 0.02461204f, -0.04336492f, 0.02324144f, -0.06038664f, -0.00672052f, 0.02575567f, 
    0.04712114f, 0.02391348f, -0.00750504f, -0.05235241f, -0.04978097f, -0.04045100f, 0.04349615f, 0.01979929f, 
    0.01711752f, -0.00764107f, 0.02339378f, 0.04603219f, -0.04689429f, 0.04881968f, -0.02415330f, -0.05381792f, 
    -0.02137468f, -0.02358341f, -0.02624723f, 0.03298016f, -0.04708092f, 0.04774651f, -0.03050029f, -0.02694085f, 
    0.02140619f, -0.05988524f, -0.03211140f, -0.06020609f, -0.02653884f, 0.00053858f, 0.00886153f, -0.04357962f, 
    0.01296957f, -0.05078992f, -0.05984990f, 0.01082158f, 0.03020444f, 0.01307363f, -0.01741380f, 0.01542828f, 
    -0.05453288f, -0.06335229f, 0.03185611f, 0.01407151f, -0.01839084f, -0.03024869f, -0.00010367f, 0.03380548f, 
    -0.00666182f, 0.03748728f, 0.02952238f, -0.00828576f, -0.05882763f, -0.04035764f, -0.01001720f, 0.04543339f, 
    -0.02064956f, 0.03870029f, -0.02727319f, 0.01746430f, 0.01074191f, -0.02164943f, 0.01496298f, 0.02616942f, 
    0.01206928f, -0.05855712f, -0.02049247f, 0.00560307f, -0.03385945f, 0.02129481f, -0.01971899f, -0.03261402f, 
    0.00935401f, -0.01714766f, -0.03271471f, 0.00913787f, -0.02720632f, 0.04676650f, 0.02368363f, 0.00699590f, 
    -0.03030962f, -0.04399833f, -0.03113019f, -0.05503426f, -0.05586582f, -0.05559259f, -0.02134501f, -0.03430573f, 
    0.01464972f, -0.00873188f, -0.04216065f, 0.02459935f, 0.02298954f, 0.02619974f, -0.01649352f, 0.03793757f, 
    -0.05319143f, 0.04205184f, -0.02589070f, -0.04473126f, -0.02713392f, -0.00666210f, -0.02769326f, -0.01464098f, 
    -0.01310737f, -0.03296828f, -0.00982437f, -0.04532581f, 0.02094242f, -0.04278287f, 0.03785818f, -0.04198353f, 
    -0.02792058f, 0.00152227f, -0.05148414f, -0.05131562f, -0.03043465f, 0.03806749f, -0.05396916f, 0.01530492f, 
    0.00394325f, 0.04706689f, -0.02528896f, 0.04318008f, 0.02318433f, 0.02189993f, 0.02341349f, -0.00260907f, 
    -0.00835319f, 0.01420889f, -0.01053449f, 0.00760076f, -0.03651015f, 0.00969934f, -0.05938158f, 0.01589293f, 
    0.03545388f, 0.00818170f, 0.00760485f, -0.03862562f, 0.03067634f, 0.01575273f, -0.00741718f, -0.00583326f, 
    -0.03588011f, 0.02883627f, 0.03878921f, -0.05121094f, -0.04525348f, -0.00716121f, -0.02649159f, -0.02232111f, 
    -0.03518193f, 0.00162087f, -0.04967887f, -0.02465322f, -0.01977657f, 0.04453720f, 0.01837678f, -0.06029323f, 
    -0.04494362f, -0.05517294f, -0.04580486f, 0.04362555f, -0.04962736f, 0.00940342f, 0.00023519f, 0.04769162f, 
    -0.04003403f, 0.02278270f, 0.00613068f, 0.04656820f, -0.00880883f, -0.00569039f, 0.02292011f, 0.03874457f, 
    -0.00577804f, -0.03028467f, -0.04395158f, -0.00691275f, 0.02455749f, 0.00145941f, -0.04363337f, -0.01122411f, 
    0.01188642f, 0.00602711f, 0.03813288f, -0.03262433f, -0.05263216f, -0.04779971f, 0.02201618f, -0.06071617f, 
    0.01791269f, -0.00397252f, -0.02351460f, -0.03591934f, 0.03143689f, -0.01700138f, -0.05303317f, 0.03378381f, 
    0.02027095f, -0.03571476f, -0.00910012f, -0.01458604f, -0.05077919f, -0.03916841f, -0.04505483f, 0.01285674f, 
    -0.05112939f, -0.00842436f, 0.04435883f, -0.00216246f, 0.00162136f, -0.01117463f, -0.01744287f, 0.02222087f, 
    0.01789984f, -0.00155618f, 0.02294270f, 0.02101405f, 0.00849300f, 0.03224075f, 0.02290328f, -0.01359986f, 
    -0.06096557f, -0.00934144f, -0.01181717f, 0.00602028f, -0.06073225f, -0.04931375f, -0.01634796f, 0.03829191f, 
    -0.03123101f, -0.05289377f, -0.03511758f, -0.01495842f, 0.00643506f, -0.03698652f, -0.01050519f, -0.00104339f, 
    -0.02492017f, -0.04516654f, 0.01050047f, -0.04060029f, -0.05372788f, 0.04238961f, -0.05950161f, -0.00777221f, 
    -0.05844257f, 0.01256256f, -0.03269703f, -0.03349648f, 0.01320557f, 0.04070726f, -0.03848565f, -0.04346654f, 
    -0.04351065f, 0.00700232f, -0.01530916f, -0.05618327f, -0.02948882f, -0.00917431f, -0.03073002f, -0.00234716f, 
    0.04220521f, -0.04961471f, -0.01939587f, -0.04133441f, 0.03131486f, -0.02843012f, -0.02625163f, 0.03062345f, 
    0.04071971f, 0.00478896f, -0.01380427f, -0.00891401f, 0.03957198f, 0.02403272f, 0.04284681f, -0.00322633f, 
    -0.02186275f, -0.01870230f, -0.05803327f, -0.00695566f, 0.03968293f, 0.01165398f, 0.01867210f, -0.04589521f, 
    -0.02352116f, 0.01501174f, 0.04609264f, -0.04751879f, 0.01680709f, -0.00630226f, 0.04140544f, -0.00435125f, 
    -0.04919064f, -0.02326284f, -0.03062637f, -0.05288912f, 0.02232097f, -0.02633854f, 0.01788351f, 0.03451898f, 
    -0.03059350f, -0.00774038f, 0.01547633f, -0.04804580f, 0.03714642f, 0.04094425f, -0.02976608f, -0.03941870f, 
    -0.02529909f, 0.03967656f, 0.02206229f, -0.03107248f, 0.01301741f, 0.00900221f, -0.01535570f, -0.04590497f, 
    0.00062414f, -0.00371863f, 0.03619041f, -0.01780003f, -0.03766940f, 0.04536211f, 0.00231861f, -0.02184172f, 
    -0.00120516f, -0.06249910f, -0.05888671f, -0.05366835f, 0.03566219f, 0.00899973f, 0.05634921f, -0.03619888f, 
    0.00207673f, -0.06329799f, 0.05933678f, -0.06160665f, -0.06050401f, -0.00457815f, -0.05531909f, 0.03898743f, 
    -0.01957736f, 0.02764900f, 0.02822948f, 0.05117319f, -0.05137970f, -0.03965293f, -0.06219454f, 0.03679843f, 
    0.03391282f, -0.00154670f, -0.00156302f, 0.01049610f, 0.02565445f, 0.02842782f, -0.04077906f, -0.03174813f, 
    -0.05829590f, 0.04125731f, 0.01559780f, -0.05809398f, -0.05331329f, -0.01279760f, -0.03836795f, 0.03166717f, 
    0.02068264f, -0.01109991f, -0.03953920f, 0.04997884f, -0.04650934f, -0.04590567f, -0.01264284f, -0.04320285f, 
    0.00728317f, -0.02123873f, 0.03419897f, -0.05919699f, -0.05317925f, 0.02628749f, 0.03418341f, 0.01119460f, 
    -0.00914553f, -0.03280284f, -0.01357673f, -0.02972450f, 0.02433226f, 0.02283894f, 0.02264252f, 0.03187398f, 
    -0.04401005f, -0.02060659f, 0.01793033f, 0.02239636f, -0.05769522f, 0.03615620f, 0.03008921f, -0.01058043f, 
    -0.00439753f, -0.02255770f, -0.04309626f, -0.02086796f, 0.04192628f, 0.03517493f, 0.02346857f, -0.00248573f, 
    0.04237628f, -0.05737092f, -0.02819721f, -0.00201261f, 0.00056603f, 0.04595916f, 0.02405140f, -0.04192237f, 
    -0.03963605f, 0.02769897f, 0.05421020f, 0.01754190f, -0.04143716f, 0.03024855f, -0.01856029f, 0.04230218f, 
    -0.03076513f, 0.04629363f, 0.02544523f, 0.01068647f, -0.03894690f, 0.00434280f, -0.02234193f, 0.01949223f, 
    0.00907165f, 0.04852897f, 0.03112556f, 0.00774798f, -0.05832413f, -0.00626898f, -0.00442291f, -0.03700245f, 
    0.03384163f, 0.00956719f, -0.04184642f, -0.00853568f, -0.04649546f, -0.02672588f, 0.00858782f, -0.04772424f, 
    -0.00160690f, -0.05059037f, 0.02649852f, -0.00350143f, 0.02892858f, 0.01462993f, 0.04143707f, -0.03657670f, 
    -0.04849576f, 0.03819535f, -0.05812619f, -0.02078143f, -0.02598860f, -0.05639688f, -0.01949665f, -0.05067576f, 
    0.03947141f, -0.00854551f, 0.02213133f, -0.02409781f, 0.01754200f, 0.04865716f, -0.01900562f, 0.01183698f, 
    0.01958813f, -0.03308921f, 0.00961330f, -0.00719293f, 0.02903535f, 0.02481025f, 0.04363991f, 0.04375498f, 
    0.05120302f, -0.06551128f, 0.04028484f, -0.01687193f, 0.04463546f, -0.03342741f, 0.01811501f, 0.00062163f, 
    -0.00522009f, -0.04914571f, -0.03037659f, 0.04079235f, -0.02678787f, 0.05843872f, -0.00531273f, -0.01216446f, 
    0.04486009f, -0.01693650f, -0.02028470f, -0.02460642f, 0.03854628f, -0.01843454f, 0.01824332f, 0.02558285f, 
    -0.00915894f, 0.03090177f, -0.00539645f, -0.03723482f, 0.01768745f, -0.04130679f, 0.01053475f, -0.04941401f, 
    -0.03873222f, 0.04513060f, -0.01451876f, 0.00119674f, -0.00867398f, 0.01975384f, 0.02259870f, 0.04374438f, 
    0.00678366f, -0.04238809f, -0.03161187f, 0.02429312f, 0.05221350f, -0.01484786f, 0.03287590f, -0.00648712f, 
    -0.01242778f, 0.01015582f, -0.05811363f, -0.04717993f, -0.06471158f, -0.03328907f, -0.01497403f, 0.02949949f, 
    -0.05093620f, 0.01243007f, -0.05571407f, 0.04332076f, -0.03018833f, -0.03335955f, -0.02496027f, 0.01139257f, 
    -0.04908295f, -0.05577001f, 0.02047914f, -0.02669504f, -0.03459477f, -0.01073494f, 0.04469478f, -0.01826513f, 
    -0.01625643f, 0.03612082f, 0.02008869f, -0.05460616f, -0.03966314f, -0.03679832f, 0.02833424f, -0.03412741f, 
    0.01870960f, -0.03901135f, 0.04735606f, 0.03547319f, 0.03779276f, 0.04161081f, 0.01859952f, -0.00589909f, 
    0.03559168f, -0.05813871f, -0.03434705f, -0.01297882f, -0.05794467f, -0.04785142f, 0.05375222f, -0.04509688f, 
    -0.04249403f, -0.01203817f, 0.03601103f, 0.03006343f, -0.04194050f, -0.02169332f, -0.04455699f, 0.04878826f, 
    0.03071479f, -0.03889190f, -0.03165701f, 0.00678333f, 0.05036383f, -0.04076977f, -0.03922472f, 0.04067989f, 
    0.05219785f, -0.03542131f, -0.05332247f, -0.04596475f, -0.02774698f, -0.04946775f, -0.05202480f, -0.03418379f, 
    -0.01665608f, -0.05739787f, -0.04512409f, -0.05303464f, -0.01342287f, 0.03135710f, -0.05856048f, 0.00407926f, 
    0.04964986f, 0.04969231f, 0.05606107f, -0.03366450f, 0.02982183f, -0.03872182f, 0.02654638f, 0.00256981f, 
    -0.03109229f, 0.01155916f, 0.01983248f, -0.05364026f, -0.04089920f, 0.02758377f, 0.03009065f, 0.04115087f, 
    -0.00519318f, -0.02320828f, 0.01695832f, -0.01791886f, -0.01727205f, -0.03416742f, 0.02256460f, 0.01550892f, 
    -0.02766140f, -0.00763758f, -0.05241964f, -0.06440153f, 0.02874020f, 0.04767287f, 0.00831230f, -0.02580094f, 
    0.02543269f, 0.02080139f, 0.00887668f, 0.01309542f, 0.01591736f, -0.00920884f, -0.03581929f, 0.04787616f, 
    0.02621886f, -0.03061760f, -0.02766502f, -0.02752676f, -0.05545002f, -0.00146040f, 0.04165306f, 0.05665268f, 
    -0.01087292f, -0.01753926f, 0.01722339f, -0.04645473f, -0.01544904f, 0.02592784f, -0.01367808f, -0.04685533f, 
    0.00787894f, -0.05468815f, -0.02813284f, -0.03849917f, 0.00167850f, -0.04180631f, -0.01563041f, -0.01012034f, 
    0.04246965f, -0.02999413f, -0.03539249f, 0.02400007f, 0.03382277f, 0.01398473f, -0.01870804f, 0.01826794f, 
    -0.00727800f, -0.01716442f, -0.04254113f, -0.02684693f, -0.06041922f, -0.02528633f, 0.02221451f, -0.00242433f, 
    0.02618953f, -0.03287213f, -0.01965705f, 0.00586588f, -0.03433586f, -0.00780261f, -0.01275528f, 0.03432001f, 
    0.04378280f, 0.02781866f, -0.02805644f, 0.04078974f, 0.03946242f, -0.06341658f, 0.01673901f, 0.00711021f, 
    0.02545015f, -0.00834076f, 0.01016691f, -0.05816425f, 0.01097200f, 0.04647824f, -0.03875772f, 0.03665576f, 
    -0.01255569f, -0.03659287f, 0.02804272f, -0.02162670f, 0.02102629f, -0.01584228f, 0.01045161f, -0.00203784f, 
    -0.02040809f, 0.02628205f, -0.05651383f, 0.00758925f, -0.03900456f, 0.03135794f, 0.03624571f, 0.00332578f, 
    -0.01612946f, 0.00879891f, 0.00479407f, -0.04499286f, -0.03872660f, 0.00938455f, 0.03235139f, 0.00375779f, 
    0.00560951f, 0.00323573f, -0.00922056f, 0.04007353f, 0.02012292f, 0.01518246f, 0.04256286f, 0.01692345f, 
    -0.02682203f, -0.03285542f, -0.02047025f, -0.00555333f, -0.00469311f, 0.02837069f, -0.03114995f, -0.03854224f, 
    -0.02541338f, -0.00555342f, -0.01973035f, -0.01760506f, 0.03531326f, -0.03819067f, -0.06414000f, -0.01518622f, 
    -0.01669112f, -0.02541826f, -0.00290097f, -0.05912890f, -0.03966201f, -0.03846290f, -0.05056294f, -0.02587985f, 
    -0.02638453f, 0.04426780f, -0.02266075f, -0.02410385f, -0.01612694f, -0.00753856f, -0.05405322f, -0.00019728f, 
    -0.06412748f, -0.01006225f, -0.01789744f, -0.01868217f, 0.03966714f, -0.04804917f, -0.01552854f, 0.02941553f, 
    -0.03765330f, 0.00602041f, -0.02297537f, 0.00181834f, 0.04793735f, -0.01145696f, -0.01985171f, -0.00183697f, 
    -0.05991128f, -0.03659387f, -0.02484165f, -0.06193507f, 0.01783969f, 0.03134842f, -0.02966361f, 0.03247492f, 
    0.04188289f, -0.01134326f, -0.03941121f, 0.03003482f, 0.00027670f, 0.02561823f, -0.03960916f, 0.04582297f, 
    0.02502906f, -0.00661355f, -0.04762724f, 0.03258695f, -0.01207947f, -0.02781643f, -0.04643288f, -0.04479147f, 
    -0.01329731f, -0.05457782f, 0.03278609f, -0.04126392f, -0.01773106f, -0.00760992f, -0.03531437f, -0.02499904f, 
    -0.06150337f, 0.02651474f, 0.01543642f, -0.04631586f, 0.04464751f, -0.01328153f, -0.03285607f, 0.01176209f, 
    0.00572963f, 0.01164314f, 0.01911550f, 0.00682330f, -0.01227501f, 0.00495529f, 0.02502473f, -0.05771351f, 
    0.05524083f, 0.00392004f, -0.04908570f, -0.03394801f, -0.02813988f, -0.03920143f, 0.03757914f, 0.04512500f, 
    0.04348304f, 0.02264823f, -0.05067841f, -0.03806801f, -0.01338096f, -0.04484591f, -0.01498126f, -0.04402758f, 
    -0.00554281f, -0.00147999f, -0.03173669f, 0.04651897f, 0.02016528f, -0.03539030f, 0.03691291f, -0.03217265f, 
    0.02223735f, -0.01381491f, -0.02930909f, -0.06324771f, 0.03623304f, 0.02373528f, 0.05278799f, 0.01839159f, 
    0.05289141f, -0.01117351f, -0.02050138f, 0.00693547f, -0.04088495f, 0.02180197f, 0.00864413f, 0.04929266f, 
    0.01239729f, -0.04077977f, -0.05429775f, -0.03959953f, 0.00679665f, 0.03037047f, -0.01175408f, -0.02475594f, 
    0.01085092f, 0.02009722f, -0.03778975f, -0.02417421f, 0.04656879f, -0.01997702f, 0.01551173f, -0.04084900f, 
    -0.02800644f, 0.01050124f, 0.00143565f, 0.00976494f, 0.00633893f, 0.00228284f, -0.00329035f, -0.02446074f, 
    0.01407281f, -0.05616880f, -0.05451133f, -0.00694137f, -0.06157627f, 0.01090606f, 0.03495129f, 0.05291782f, 
    0.03490196f, -0.00351243f, 0.01333446f, -0.05072015f, -0.02194565f, -0.00537716f, 0.00427188f, 0.04552706f, 
    -0.05633000f, -0.02628306f, 0.02299281f, 0.03021592f, -0.02703499f, -0.04863270f, 0.04308914f, -0.03073408f, 
    -0.00741663f, 0.16856705f, 0.01939398f, 0.02598280f, 0.14687878f, 0.05851273f, 0.03634913f, 0.02427199f, 
    -0.04497527f, -0.06478221f, 0.09154855f, 0.07856280f, -0.01245279f, -0.09141667f, -0.02976735f, 0.06519138f, 
    0.08290989f, 0.03516028f, 0.14901674f, 0.06486630f, -0.06306487f, -0.00472622f, 0.06056178f, -0.00986429f, 
    0.20104055f, 0.02151079f, 0.10706846f, 0.00405212f, -0.06137142f, -0.01745814f, -0.06416906f, 0.06360883f, 
    -0.06401427f, 0.01410700f, 0.06886123f, -0.01334318f, 0.00061435f, -0.01485910f, 0.11745628f, 0.04272873f, 
    0.21561283f, 0.19861530f, 0.05734829f, -0.08313517f, 0.01395009f, -0.01988944f, -0.04446663f, -0.05137495f, 
    -0.00640243f, 0.03045232f, -0.01043481f, 0.00402503f, 0.02792431f, -0.03470472f, 0.01472356f, -0.02529299f, 
    0.07443202f, 0.09304952f, 0.05598037f, -0.01394855f, -0.04779496f, -0.00955738f, 0.07200580f, 0.05953967f, 
    -0.00086925f, -0.11603449f, -0.06013782f, -0.01860003f, 0.07152208f, 0.02101579f, -0.02238502f, 0.08713888f, 
    0.06742135f, 0.05373435f, -0.02759334f, 0.01583651f, -0.04576473f, -0.01202041f, 0.02238932f, -0.04992441f, 
    -0.36203444f, 0.08809488f, -0.14076492f, 0.03052327f, -0.01132857f, -0.01566019f, 0.00647825f, -0.03019098f, 
    0.02228265f, 0.00117896f, 0.03501729f, -0.01081266f, 0.00774184f, 0.09478594f, 0.05518018f, -0.03400735f, 
    0.06384046f, -0.02833608f, -0.03600616f, 0.09755703f, 0.03338436f, 0.01075761f, 0.15174903f, -0.07481396f, 
    0.05996842f, -0.00523943f, -0.09534781f, -0.03348003f, 0.02645132f, 0.05476959f, -0.02974848f, -0.01017722f, 
    0.10406823f, -0.04691709f, 0.02093246f, -0.08051945f, 0.09933081f, 0.00588253f, 0.05389598f, -0.05324551f, 
    -0.09341617f, 0.01396035f, -0.01522227f, 0.09213622f, -0.01507861f, -0.07782826f, 0.02441407f, 0.09972988f, 
    0.00759273f, -0.03403094f, -0.02470350f, -0.09674130f, -0.01326610f, -0.02855900f, -0.06097221f, -0.01110542f, 
    -0.01602651f, 0.02412465f, 0.09075622f, -0.02586896f, 0.03697374f, 0.15882859f, 0.05606757f, 0.00562902f, 
    0.12026417f, -0.05282255f, 0.04422171f, -0.10705105f, 0.01906785f, -0.02706888f, 0.00536487f, 0.09200324f, 
    -0.09436824f, 0.02242184f, 0.03789292f, 0.02896418f, -0.00443059f, 0.09192552f, 0.08604905f, 0.02915954f, 
    0.00935184f, 0.09828656f, 0.15573081f, -0.06630591f, 0.28547230f, 0.01763051f, -0.05478305f, 0.02604323f, 
    -0.01265994f, 0.02367672f, -0.01357177f, -0.03161690f, -0.05595061f, 0.02749000f, 0.06161918f, 0.16683741f, 
    0.05703028f, 0.01760914f, 0.11578032f, -0.00364439f, -0.07699037f, -0.30336365f, -0.23278317f, -0.15179145f, 
    -0.15250671f, -0.15258753f, -0.11232258f, -0.05239562f, -0.08962429f, -0.00979179f, 0.08323918f, 0.03061891f, 
    -0.01674157f, -0.01795568f, 0.05333465f, -0.04191630f, -0.07306275f, -0.08193905f, -0.02510949f, 0.03046053f, 
    0.06289697f, 0.18576644f, -0.07739214f, 0.21131706f, 0.10261135f, -0.02936562f, -0.03151725f, 0.05885862f, 
    -0.04353651f, -0.15133621f, 0.09068305f, 0.11866108f, -0.03752068f, 0.04219078f, 0.00379864f, -0.01643661f, 
    -0.08032276f, 0.06251613f, 0.02699873f, 0.00592010f, -0.21771264f, 0.10719115f, -0.02127053f, -0.23405437f, 
    -0.08987692f, -0.07718468f, -0.04592423f, -0.01478563f, 0.03084976f, 0.09161296f, -0.14574985f, -0.07789101f, 
    0.03634737f, -0.02161024f, 0.03893422f, -0.07533269f, 0.10808068f, -0.12871733f, -0.19280629f, 0.03083206f, 
    -0.05906394f, 0.11136445f, -0.05966508f, 0.08754693f, 0.10842401f, -0.02757520f, -0.03862201f, -0.03665312f, 
    -0.02470308f, -0.07914038f, 0.03273701f, 0.08619926f, 0.05896208f, -0.04864274f, 0.01641345f, 0.00432843f, 
    -0.01131464f, 0.09625305f, 0.04182279f, 0.09272248f, 0.15629846f, 0.02422090f, -0.15566604f, 0.10122387f, 
    0.02123917f, -0.00680346f, 0.08359917f, -0.00445883f, -0.02030381f, -0.18411714f, 0.06123989f, 0.03143423f, 
    0.00504714f, 0.01454075f, 0.04376896f, 0.09508803f, -0.00187187f, 0.06112142f, -0.06333300f, 0.02277890f, 
    0.11316895f, 0.09415995f, 0.08473573f, -0.08521419f, -0.01710403f, 0.00376709f, 0.00232230f, -0.01129405f, 
    0.01542065f, 0.06097775f, 0.03951719f, -0.03763654f, -0.01421999f, -0.03451475f, 0.14625479f, 0.01802909f, 
    0.10376950f, -0.06786482f, -0.06430963f, 0.09461646f, -0.02256668f, 0.00130561f, -0.28982374f, -0.25920996f, 
    -0.18905935f, -0.00648975f, 0.07393179f, 0.01154291f, -0.03075307f, 0.08140634f, 0.00541444f, 0.06246486f, 
    0.04356399f, 0.11661136f, 0.01315237f, -0.09236792f, -0.04017135f, -0.02164089f, -0.10289787f, -0.03685566f, 
    0.06000548f, -0.13338405f, -0.13281839f, -0.02964777f, 0.17898716f, 0.02305737f, -0.09488580f, 0.02056918f, 
    0.04880641f, -0.02002593f, 0.04433281f, 0.01973186f, -0.03072761f, 0.00325165f, 0.12132151f, 0.02138769f, 
    0.06821360f, -0.01247305f, -0.18917547f, -0.01693732f, -0.23283771f, 0.10420682f, -0.13657665f, 0.04083452f, 
    0.12413075f, 0.03107530f, -0.06053842f, 0.02176368f, 0.15150641f, 0.05918781f, 0.02484149f, -0.02550901f, 
    0.05008498f, 0.10827978f, 0.06883836f, -0.01067532f, -0.03407414f, -0.03164591f, -0.11910275f, -0.01213480f, 
    0.04581006f, 0.17256843f, -0.10123492f, 0.01850815f, 0.07674480f, -0.02323085f, -0.03013247f, 0.05636540f, 
    0.00704578f, 0.05402144f, -0.01298387f, 0.09643188f, 0.04364714f, 0.07896751f, 0.01667037f, -0.00372025f, 
    -0.06296702f, 0.01156238f, 0.06840494f, -0.02784055f, -0.06087280f, 0.10828798f, -0.22517583f, 0.03199528f, 
    -0.00406377f, 0.07527905f, 0.02206962f, 0.01049425f, -0.10658416f, 0.01094130f, 0.05997005f, 0.05562632f, 
    0.10252969f, 0.04227381f, 0.04225056f, 0.06783419f, -0.00884595f, 0.01914553f, 0.02221433f, 0.03232033f, 
    -0.26938969f, 0.14532213f, -0.02383943f, -0.06432327f, -0.15425527f, 0.03573893f, 0.00745297f, -0.00209026f, 
    -0.04034272f, -0.05488194f, -0.05383918f, -0.01825435f, 0.02374050f, 0.04597156f, -0.15506676f, -0.00020641f, 
    -0.08761572f, 0.00406181f, -0.11623757f, 0.03244888f, -0.21387702f, -0.00459883f, -0.11548795f, 0.07703596f, 
    -0.11222155f, 0.01260407f, -0.01911254f, -0.03922497f, 0.04363012f, -0.02574769f, 0.01832348f, 0.05898301f, 
    -0.03369414f, -0.08897693f, -0.00898049f, 0.06863540f, 0.00169572f, 0.04603925f, -0.01808907f, -0.04107891f, 
    -0.13287088f, -0.07631880f, -0.20866570f, -0.06393857f, 0.01965387f, 0.00763458f, 0.09334761f, 0.01918522f, 
    0.01483132f, 0.02494685f, -0.04110387f, 0.02983886f, -0.06364014f, -0.07729878f, 0.08349524f, 0.06443802f, 
    0.02580165f, 0.03165993f, 0.04188835f, -0.01753242f, 0.00503691f, 0.16390723f, -0.07527824f, 0.05383405f, 
    0.12672982f, -0.05098121f, -0.07188253f, -0.03519532f, -0.02163180f, 0.05156299f, -0.03847449f, 0.03855560f, 
    -0.02008539f, 0.07841942f, 0.04638492f, -0.03970699f, 0.04352178f, 0.07531652f, 0.10206287f, 0.06517554f, 
    -0.25301981f, 0.11801231f, -0.08676600f, 0.01802359f, 0.26027563f, 0.16235165f, 0.01885267f, -0.00804252f, 
    0.05573672f, -0.04637215f, -0.05873106f, -0.09805975f, 0.06819130f, 0.02023782f, -0.00982580f, -0.00196876f, 
    0.13399486f, 0.06343649f, 0.08165458f, -0.02664745f, 0.43174958f, 0.01370024f, -0.01520988f, 0.18356399f, 
    0.03058926f, 0.04547727f, 0.03737626f, 0.07100909f, 0.02815785f, -0.00604042f, 0.00265400f, -0.00750957f, 
    0.03028432f, 0.07118368f, -0.01812068f, -0.02332550f, 0.01645862f, -0.02735912f, -0.02368545f, 0.04268305f, 
    -0.04223361f, 0.07584445f, -0.09038413f, 0.04152624f, 0.03574541f, -0.03071368f, 0.02989588f, -0.02827357f, 
    0.00016245f, 0.04179572f, -0.00208313f, -0.03094328f, 0.15387820f, -0.05659513f, 0.01259185f, -0.05976686f, 
    0.09340712f, 0.00516420f, 0.09184337f, 0.04843392f, -0.53809345f, 0.13747072f, 0.02035139f, -0.22277620f, 
    -0.05086602f, -0.01794574f, 0.03340007f, -0.00473546f, 0.09031627f, -0.06123347f, 0.14018428f, 0.06141744f, 
    0.02610071f, 0.09780992f, -0.05329413f, -0.07882616f, 0.01722314f, -0.02742684f, 0.03591609f, 0.04936716f, 
    0.18765599f, 0.02586049f, 0.05459692f, 0.06736014f, 0.17863026f, 0.04244616f, -0.08440019f, -0.02533269f, 
    0.06766517f, 0.07131104f, 0.10547090f, -0.08342212f, -0.01105645f, -0.08861961f, 0.04269716f, 0.00421252f, 
    -0.02242850f, -0.03160963f, -0.10572889f, 0.00156883f, 0.31426063f, -0.10489322f, -0.12369701f, 0.12259976f, 
    0.00943673f, -0.03048997f, 0.16009349f, 0.07678913f, -0.01433528f, -0.04522298f, -0.07502635f, -0.06272414f, 
    0.03636469f, 0.08594266f, 0.01996657f, -0.00247669f, 0.02103601f, 0.02270492f, 0.11292406f, -0.03050846f, 
    0.22222938f, 0.01356461f, 0.10291303f, 0.02948819f, -0.11587888f, -0.05531275f, -0.07270491f, -0.10152154f, 
    -0.05890387f, -0.00114511f, -0.02438394f, 0.04201695f, -0.07953189f, -0.02774541f, -0.00930776f, -0.00250186f, 
    -0.04308042f, 0.09504433f, 0.04756919f, 0.06576607f, -0.32081038f, 0.04709349f, -0.06151542f, -0.03458820f, 
    -0.03866833f, 0.01899768f, -0.01335829f, 0.00124202f, -0.00572330f, -0.04232527f, -0.14233960f, 0.01950438f, 
    -0.00887212f, -0.02502337f, -0.08701871f, 0.02290913f, 0.06421274f, 0.04012764f, -0.00571241f, 0.00700579f, 
    0.01688465f, 0.01099106f, 0.02290196f, 0.02926778f, -0.03449482f, 0.00263550f, 0.01157527f, 0.00519086f, 
    -0.05871592f, 0.00052773f, 0.01671042f, -0.00828921f, -0.00791770f, 0.01122020f, -0.03735916f, -0.04938566f, 
    -0.01280641f, -0.00623774f, -0.01445418f, -0.03968912f, -0.05948299f, -0.04456875f, -0.05116466f, 0.03347344f, 
    -0.04513132f, -0.05270793f, 0.02858921f, 0.01402263f, -0.00197005f, 0.03337303f, 0.04191018f, -0.00079289f, 
    -0.01660694f, -0.03192959f, -0.01056974f, -0.02380260f, 0.04033865f, -0.02864256f, -0.04827232f, -0.04259460f, 
    0.02717448f, 0.00095379f, 0.03781370f, -0.02108119f, -0.05941857f, -0.00399249f, 0.01841623f, 0.02754462f, 
    0.02100798f, 0.01355128f, 0.02769203f, -0.01783282f, 0.00095759f, 0.00580839f, -0.00694791f, 0.01715179f, 
    -0.03010610f, -0.05588160f, -0.06381936f, -0.03700937f, -0.00337717f, -0.04301545f, -0.03500397f, -0.03615737f, 
    -0.00256508f, 0.02770080f, 0.03265626f, -0.01387339f, 0.03290499f, 0.01428736f, -0.03389651f, 0.02363948f, 
    -0.02722109f, 0.03730708f, -0.01640015f, -0.01530968f, 0.01479883f, 0.03837380f, -0.03707965f, -0.04833098f, 
    -0.00090724f, -0.06250336f, -0.02677591f, 0.00707289f, 0.00600583f, -0.03985356f, -0.05132163f, -0.00766115f, 
    0.01277316f, -0.00663210f, 0.03010179f, -0.04892256f, 0.00479520f, -0.01015691f, -0.00789586f, 0.04743792f, 
    0.03435864f, -0.05047805f, -0.02655466f, 0.02360817f, -0.01828529f, -0.00964451f, 0.03691315f, -0.04393816f, 
    0.00276158f, -0.02066834f, -0.01173771f, 0.01623125f, 0.02248232f, -0.02206505f, -0.06466614f, -0.01893585f, 
    0.02905378f, -0.02279661f, -0.02014575f, -0.02343107f, -0.00696285f, -0.01888271f, 0.02142761f, 0.01940012f, 
    0.01935172f, 0.03495338f, -0.05859566f, -0.01682338f, -0.01429793f, -0.03458178f, -0.03413679f, 0.00046373f, 
    -0.04780942f, -0.04920370f, -0.04425000f, 0.03311325f, -0.01582293f, -0.03228661f, 0.03353022f, -0.01819273f, 
    -0.05812090f, -0.05657766f, 0.03892975f, -0.00628456f, 0.01832997f, 0.02223477f, -0.00259888f, 0.01694848f, 
    -0.05683371f, 0.03879166f, -0.03336161f, 0.03404681f, 0.03193322f, 0.01658053f, -0.03319935f, -0.06364305f, 
    -0.03681477f, 0.01916886f, -0.03405230f, 0.03593506f, -0.04943458f, 0.02374977f, -0.00415786f, -0.02243947f, 
    0.00960487f, -0.05309602f, -0.05418704f, -0.00816268f, -0.03562158f, -0.02464529f, -0.04924449f, -0.03274741f, 
    -0.01887101f, 0.04009357f, -0.02546153f, -0.00605729f, 0.04239061f, -0.03777860f, -0.03450728f, -0.01331810f, 
    0.02364950f, -0.03978831f, 0.02331128f, 0.01236691f, 0.04406385f, -0.03207593f, -0.00168402f, -0.04781369f, 
    -0.05166514f, 0.00327742f, -0.02224457f, -0.02923629f, -0.00735048f, 0.03008737f, 0.02623986f, -0.06441694f, 
    0.01434843f, 0.02907586f, 0.00916435f, -0.00792406f, -0.01447147f, -0.01356737f, -0.02795630f, -0.02154172f, 
    0.02937949f, 0.02863093f, -0.03897028f, 0.03038011f, -0.01567297f, 0.02922286f, -0.04001864f, -0.00204347f, 
    -0.01446242f, -0.02052593f, -0.02165326f, -0.04160060f, 0.03293725f, -0.02941607f, -0.00636430f, 0.03964110f, 
    -0.00613812f, 0.04750169f, -0.01011620f, 0.00718649f, 0.02158907f, 0.03657954f, 0.02136131f, -0.03573832f, 
    -0.04085338f, 0.02404074f, 0.02161540f, 0.03521402f, -0.05180604f, 0.02814576f, 0.04257406f, -0.02824983f, 
    -0.03023723f, -0.02303139f, 0.00218089f, -0.02367313f, -0.00115890f, 0.03648772f, -0.00729785f, -0.03052207f, 
    -0.00363557f, -0.06046570f, 0.02898521f, -0.02923860f, -0.04031112f, 0.02569607f, -0.02867520f, -0.01129315f, 
    -0.03989390f, -0.02987737f, -0.02431966f, 0.03377987f, 0.03610324f, 0.00975635f, -0.00092905f, -0.04372624f, 
    -0.03849511f, 0.01650687f, 0.04365978f, 0.04532140f, -0.04521838f, -0.01588741f, 0.04876352f, 0.00002222f, 
    0.01639753f, -0.02859708f, 0.04291423f, -0.05750399f, -0.05962941f, 0.02680124f, -0.01058033f, -0.02839367f, 
    0.03871429f, -0.03662041f, 0.01662168f, -0.04439173f, -0.02084941f, -0.06165931f, 0.00734729f, -0.03219284f, 
    -0.00102313f, 0.00199914f, -0.06632877f, 0.00659422f, 0.01942436f, -0.00280237f, -0.02243260f, -0.06302577f, 
    0.00013936f, 0.04415373f, -0.03757738f, 0.04925162f, -0.00786619f, 0.01413682f, -0.04124891f, -0.01685695f, 
    0.02241572f, -0.05538348f, -0.04834220f, 0.00586403f, 0.02744681f, 0.00955174f, 0.02812331f, -0.03999908f, 
    0.01128624f, -0.03525335f, 0.03657352f, -0.03699957f, 0.01302131f, 0.01798893f, -0.05553309f, -0.03682713f, 
    0.02449334f, -0.06659342f, -0.03837982f, -0.02300423f, 0.01329992f, -0.02177190f, -0.03875810f, 0.01551561f, 
    0.18163697f, 0.08520770f, 0.00954237f, -0.04810132f, -0.00429845f, 0.08893829f, 0.03396973f, 0.00146274f, 
    -0.02316861f, 0.08654802f, 0.02659634f, 0.02581998f, -0.05081021f, -0.00060218f, 0.02853069f, 0.05960535f, 
    -0.00595121f, 0.18750335f, 0.16960575f, 0.10596953f, 0.12869750f, 0.07044000f, -0.13022502f, 0.03653529f, 
    0.00085610f, -0.13984188f, 0.07036674f, 0.05822067f, -0.04106040f, 0.06070255f, -0.04259227f, 0.10486746f, 
    -0.01557078f, -0.17214367f, 0.01749745f, 0.04771879f, 0.02204759f, -0.08812582f, 0.29324740f, -0.12738205f, 
    0.43007678f, -0.06444486f, 0.06453293f, 0.04930191f, -0.02335059f, -0.10522658f, -0.03833263f, -0.09588879f, 
    -0.06887094f, -0.03193433f, 0.04071223f, -0.03741683f, -0.07014444f, -0.15899472f, 0.03915659f, -0.04752931f, 
    0.05305537f, 0.16404627f, 0.04119480f, 0.02063231f, 0.21907561f, -0.07736216f, 0.13353169f, 0.03632321f, 
    0.06405416f, -0.09890712f, -0.05593313f, -0.07251108f, 0.02655222f, 0.03902750f, -0.01628049f, -0.04406388f, 
    0.05669840f, 0.13188221f, -0.02779594f, -0.04084098f, 0.00998791f, -0.03950212f, 0.00265781f, 0.01784310f, 
    0.26444489f, -0.06797074f, -0.03764321f, -0.06616506f, 0.11251999f, 0.03726585f, 0.04636167f, 0.09522130f, 
    0.04461863f, 0.02245319f, 0.00611160f, -0.05448243f, -0.02625407f, 0.09917831f, 0.01694065f, 0.08830372f, 
    0.00895948f, -0.03203325f, 0.07680138f, 0.01064685f, 0.44410074f, -0.04969393f, 0.06290200f, 0.13143715f, 
    0.02739409f, -0.09751654f, -0.02081675f, -0.02102773f, -0.05174024f, 0.07219056f, -0.04269212f, 0.00046420f, 
    0.03417647f, -0.02650756f, 0.05663312f, -0.08181942f, -0.01721133f, -0.04651681f, 0.04485460f, 0.03425378f, 
    0.13573250f, -0.13406314f, 0.07248440f, 0.08878516f, 0.02274959f, 0.00275144f, -0.10009639f, -0.04014695f, 
    0.08718728f, 0.05865615f, -0.06575858f, 0.05281145f, -0.09003548f, 0.06756063f, -0.03519051f, -0.07472321f, 
    -0.12021109f, 0.14186771f, -0.10701311f, 0.01211243f, 0.13806704f, 0.00050795f, 0.12014046f, 0.01242053f, 
    -0.00634774f, -0.15216292f, 0.05640829f, -0.00804566f, -0.03411588f, -0.01082063f, 0.02743780f, 0.05624799f, 
    -0.05762308f, -0.04668216f, -0.03176711f, 0.12835695f, -0.03447479f, 0.04332270f, 0.12661147f, -0.01037468f, 
    0.13355741f, 0.03220190f, 0.03634910f, 0.00430920f, -0.01293804f, -0.08012210f, -0.04229872f, -0.01765833f, 
    0.00170223f, -0.02676662f, 0.01338160f, -0.00151243f, 0.02253224f, 0.08507700f, -0.06919923f, 0.13619716f, 
    0.04844685f, 0.03409806f, 0.17025384f, 0.03898890f, -0.03658890f, -0.02846571f, 0.00771822f, -0.18068421f, 
    -0.08441711f, 0.00295700f, 0.00919803f, 0.10731619f, 0.01829868f, -0.13913824f, 0.00086711f, -0.03713438f, 
    0.00917590f, -0.01570127f, -0.11399632f, 0.01370559f, -0.09907446f, -0.03852985f, -0.15535577f, -0.02392933f, 
    0.16556029f, -0.02141060f, -0.07693131f, 0.11119687f, 0.03090663f, -0.08427414f, -0.09293576f, 0.03984542f, 
    0.01496558f, 0.06161774f, -0.02087162f, -0.02815338f, -0.07542796f, 0.16949190f, 0.10389280f, 0.02693108f, 
    -0.10609452f, -0.00706859f, 0.05261465f, 0.05053206f, 0.29429978f, 0.12661304f, -0.05161261f, -0.04401731f, 
    -0.20173888f, -0.15668428f, -0.14905697f, 0.00986390f, 0.07865115f, -0.02136280f, -0.09978523f, 0.02565046f, 
    0.13631013f, 0.04328314f, -0.06369348f, 0.06304664f, -0.00596309f, -0.10528579f, -0.03513804f, -0.05806386f, 
    -0.06525011f, 0.22669490f, -0.10841066f, -0.07400044f, -0.03846672f, 0.08920813f, 0.11709902f, 0.03626842f, 
    -0.02037500f, -0.07608937f, -0.06447022f, 0.00514182f, -0.01039075f, 0.02331459f, -0.05032919f, 0.02729619f, 
    0.06052068f, 0.07878658f, 0.02606167f, 0.06090152f, 0.01643495f, -0.15850428f, -0.18454547f, -0.17436016f, 
    -0.00513340f, 0.06586538f, 0.12962601f, -0.04455318f, -0.01582427f, 0.00877799f, 0.01844517f, -0.08599845f, 
    -0.09099422f, -0.04798679f, -0.16121589f, 0.10993602f, 0.09985650f, -0.03672490f, -0.00168412f, 0.01961933f, 
    -0.09060469f, 0.04387867f, -0.01902522f, 0.18614645f, -0.08161721f, 0.08413969f, -0.00432434f, 0.11681761f, 
    0.05475966f, -0.01672203f, 0.02458649f, -0.01179550f, -0.04783639f, 0.10133050f, -0.09973864f, 0.05294568f, 
    0.04197496f, 0.00692556f, -0.06292547f, 0.02610305f, 0.19581987f, -0.18827021f, -0.02972539f, -0.07634676f, 
    0.01974138f, 0.05780819f, -0.07357037f, -0.02275356f, 0.02324435f, 0.08188278f, -0.00113814f, -0.01079740f, 
    0.13086481f, 0.07929895f, 0.03956449f, 0.00654441f, -0.06247083f, -0.13008849f, -0.10209483f, -0.02841133f, 
    0.15536170f, 0.20382223f, 0.09635779f, 0.21932085f, 0.11512376f, 0.03566632f, 0.06634829f, -0.03748779f, 
    -0.08206152f, -0.08603266f, -0.10602550f, -0.10837999f, 0.07562657f, -0.02362772f, 0.11981001f, 0.09004761f, 
    0.04845701f, 0.26105219f, 0.08449427f, 0.08799022f, 0.33236128f, -0.10016086f, -0.09952436f, 0.17196944f, 
    0.14754350f, -0.02848242f, 0.03021518f, -0.03418132f, -0.19375120f, 0.06904009f, -0.05578178f, 0.10991412f, 
    0.00973068f, -0.02830257f, -0.00632686f, 0.03946837f, 0.07671803f, -0.02846558f, 0.25761279f, 0.05504452f, 
    -0.06692997f, -0.01885259f, -0.07272917f, 0.03379285f, 0.04639638f, 0.09187458f, 0.00059991f, -0.07812709f, 
    -0.05068579f, -0.08287361f, 0.01218401f, 0.09811603f, -0.04450555f, -0.09189919f, 0.09213287f, -0.11311422f, 
    -0.11072423f, 0.17682309f, 0.07617741f, 0.07770220f, -0.09274388f, 0.01751493f, 0.04776459f, -0.14673448f, 
    0.01235900f, 0.04217209f, 0.02791027f, 0.17501758f, 0.07412869f, 0.05142929f, 0.04745811f, -0.01112998f, 
    0.06891410f, 0.08836398f, -0.04986791f, 0.06734723f, 0.05987532f, 0.00446523f, 0.01684618f, -0.04206563f, 
    0.18298317f, -0.07188956f, 0.12885502f, 0.27200499f, 0.00407940f, 0.06513842f, 0.06781927f, -0.02615509f, 
    0.05499849f, -0.01949265f, -0.03933153f, 0.05809733f, -0.19285023f, 0.04538808f, 0.00328443f, 0.04051936f, 
    0.07590362f, -0.15409650f, -0.00165017f, -0.02138550f, -0.15772460f, 0.18066405f, -0.03373416f, -0.08181085f, 
    -0.05437838f, 0.03926762f, 0.01451309f, 0.03602058f, 0.01459826f, 0.01433043f, -0.02059101f, 0.05955342f, 
    0.00579095f, -0.01554571f, 0.05992218f, -0.04862420f, 0.01206154f, 0.01796905f, 0.05222805f, -0.03101267f, 
    -0.06324273f, 0.14419183f, 0.12887712f, -0.04980618f, 0.03023622f, -0.03883093f, 0.00559004f, 0.05317936f, 
    0.07657386f, 0.03533152f, 0.02467372f, -0.02506802f, -0.03671215f, 0.11865208f, 0.04063895f, -0.00133679f, 
    0.11665966f, 0.10122294f, -0.07565632f, 0.13623942f, 0.06691747f, -0.03883421f, 0.06119235f, 0.10807604f, 
    0.15983649f, 0.02306075f, -0.06866014f, -0.05592944f, 0.06350086f, 0.06882987f, -0.01370437f, -0.02567740f, 
    -0.02772274f, -0.11354793f, -0.00285797f, 0.04863645f, -0.04594984f, 0.03355646f, 0.08737280f, 0.05787317f, 
    0.06671727f, -0.08912594f, 0.11102442f, 0.00873281f, 0.05807818f, -0.05092176f, 0.03095639f, -0.14325283f, 
    0.05399174f, 0.10478859f, -0.14785771f, 0.10838450f, 0.01670838f, 0.09289902f, 0.04300392f, 0.01600975f, 
    -0.03202992f, 0.08833574f, 0.12550941f, 0.14863117f, -0.11759617f, 0.04479087f, -0.04592020f, -0.12665558f, 
    -0.04304010f, -0.15071759f, -0.10003760f, -0.01886402f, -0.05004056f, -0.09112220f, -0.04291798f, -0.03634191f, 
    0.03081184f, -0.22800839f, -0.05945319f, -0.00019074f, 0.02914884f, -0.13856453f, -0.10108256f, -0.05119121f, 
    0.25415117f, 0.09835181f, -0.09171139f, 0.16027728f, -0.03644072f, 0.01863196f, 0.00002607f, 0.09337690f, 
    0.09973861f, -0.07890397f, -0.03019244f, 0.01081952f, 0.05750799f, 0.10571245f, 0.09978284f, 0.09331143f, 
    -0.00509131f, 0.08085989f, 0.03354824f, 0.08635337f, 0.47576725f, -0.08530719f, 0.04055921f, 0.02659320f, 
    -0.04031871f, 0.14589287f, -0.04251903f, 0.01689882f, 0.09373496f, 0.02448365f, -0.03826509f, 0.03782249f, 
    -0.07410207f, 0.03551563f, -0.04020683f, 0.06065106f, 0.01252701f, -0.08063737f, -0.04298570f, -0.08440462f, 
    0.09304090f, -0.03162863f, -0.08670789f, -0.00366959f, -0.07716940f, -0.07673824f, 0.00741304f, -0.11574966f, 
    -0.12629138f, -0.12094966f, -0.06629002f, -0.07130740f, -0.07890432f, -0.07312067f, -0.11056332f, -0.14436975f, 
    -0.02341237f, -0.12268884f, -0.01036333f, -0.16746144f, 0.14935039f, 0.07707324f, 0.15673196f, 0.05293266f, 
    0.07029383f, -0.11688896f, 0.01181073f, -0.11626612f, -0.00270412f, -0.01694636f, 0.03511256f, 0.04382095f, 
    -0.04191261f, 0.08663360f, -0.04128608f, 0.13389058f, 0.01715370f, -0.09800888f, 0.00091983f, -0.01026717f, 
    -0.04104257f, 0.04080266f, -0.24360396f, -0.11219261f, 0.04285295f, -0.09180056f, 0.06371931f, 0.07671240f, 
    -0.00574840f, -0.01565046f, -0.06841818f, 0.06114903f, 0.03460048f, -0.09371822f, 0.03894337f, 0.00141241f, 
    0.06249119f, -0.17883293f, -0.12554100f, 0.01563987f, 0.17695619f, 0.14547691f, 0.08508359f, -0.08731268f, 
    -0.21119727f, 0.10063629f, -0.03421503f, 0.13614170f, 0.02904881f, -0.07345872f, 0.07324011f, 0.05075493f, 
    0.09596241f, 0.14883871f, -0.00689257f, 0.10434052f, 0.03129366f, -0.20930195f, -0.09414111f, -0.18289706f, 
    0.04256922f, -0.00482951f, -0.00763141f, -0.00975609f, -0.00885443f, -0.00138497f, -0.03849458f, 0.03365064f, 
    0.02628770f, -0.03177431f, 0.05023060f, 0.01516762f, -0.05489265f, 0.00500414f, 0.03103108f, -0.03764531f, 
    -0.00918825f, 0.02831024f, -0.00172271f, 0.04388132f, 0.03354877f, -0.05034184f, 0.00563832f, -0.05908887f, 
    0.02791626f, 0.00497415f, 0.04659184f, 0.00456456f, 0.01181590f, -0.05636558f, -0.04168376f, -0.05683129f, 
    -0.04122862f, -0.00568294f, -0.04488703f, 0.03200827f, 0.04898083f, -0.06051787f, 0.00660327f, -0.01291214f, 
    -0.02662874f, -0.05756036f, -0.05705238f, -0.05395729f, -0.05330671f, 0.04804056f, 0.00734169f, 0.03510491f, 
    -0.00154817f, -0.02392054f, -0.02212494f, -0.00825526f, -0.02055596f, -0.06037969f, -0.01881105f, 0.04479671f, 
    -0.02762511f, 0.04031951f, -0.02234334f, 0.04712432f, 0.01494758f, -0.00611732f, 0.01595088f, -0.04684482f, 
    0.01662198f, -0.05698662f, -0.04996279f, 0.01201922f, 0.01644779f, 0.02519397f, 0.02874528f, 0.01555065f, 
    0.01079592f, -0.02668143f, 0.03479298f, -0.02854400f, -0.02025796f, 0.01159598f, -0.05205111f, 0.00422053f, 
    0.00594211f, -0.03265812f, 0.00196112f, -0.05275394f, -0.02847896f, -0.01475300f, -0.05871300f, 0.02429853f, 
    0.00115073f, -0.03377276f, 0.00652095f, -0.03933596f, -0.05328134f, -0.02535374f, 0.00720902f, -0.02510435f, 
    0.02328202f, 0.00260043f, 0.02579206f, 0.00424007f, 0.03767680f, 0.02697943f, -0.02820607f, -0.04925666f, 
    -0.00932808f, 0.02199571f, -0.03819187f, -0.00982126f, 0.03977390f, -0.03360394f, -0.04638099f, -0.06067555f, 
    0.00069958f, 0.02867881f, 0.02140289f, -0.05513737f, -0.01498167f, -0.03958129f, -0.03956765f, 0.02498044f, 
    -0.04198801f, -0.03080153f, -0.04636729f, 0.04226255f, -0.04452638f, -0.00734905f, 0.02477001f, 0.04792112f, 
    -0.02360548f, 0.03942357f, 0.01816704f, -0.05654410f, -0.03076462f, 0.00006003f, 0.04952003f, 0.01794814f, 
    -0.00971310f, -0.03677748f, -0.05015174f, -0.04934673f, -0.01682336f, -0.03313462f, 0.02162618f, 0.03094495f, 
    0.04391149f, -0.01366684f, 0.00182956f, 0.01015679f, -0.04649743f, -0.02430718f, -0.04535383f, -0.05958259f, 
    -0.04792922f, 0.03922523f, 0.01200916f, -0.01010447f, -0.01560374f, -0.04578242f, -0.01704652f, -0.05705970f, 
    0.00619484f, 0.01278685f, -0.05940557f, 0.00262022f, -0.01262852f, 0.01000997f, -0.00193233f, -0.00036611f, 
    0.04944449f, 0.01000911f, 0.04270815f, 0.02745402f, 0.04846491f, -0.03365249f, -0.03550307f, 0.01577953f, 
    -0.02332757f, -0.01418818f, -0.00326383f, -0.00575653f, 0.02180513f, -0.05965476f, -0.05991173f, 0.01082999f, 
    -0.00505443f, -0.02001774f, -0.04413175f, 0.01142155f, 0.03190744f, -0.04648902f, -0.00829399f, 0.03497542f, 
    -0.01528937f, 0.00114923f, 0.01283776f, 0.01377101f, -0.00283501f, -0.03004957f, -0.04178036f, 0.04781107f, 
    0.00906737f, 0.00588043f, 0.00520503f, 0.01667503f, -0.05168689f, 0.02508021f, -0.02608706f, -0.02361995f, 
    0.00965680f, -0.02992274f, -0.03114569f, -0.04921133f, 0.00189983f, -0.03259915f, -0.04464212f, 0.01397170f, 
    0.00971105f, 0.01859917f, 0.03280048f, 0.03003621f, 0.01166646f, -0.03098796f, 0.01035977f, -0.04272196f, 
    0.05486115f, -0.00090389f, -0.00214671f, -0.00481726f, -0.00774879f, 0.05142943f, -0.01472604f, -0.01313116f, 
    -0.00960893f, -0.00399021f, -0.04207831f, 0.00512276f, -0.02197909f, 0.01206860f, -0.04233738f, 0.00455023f, 
    -0.05342164f, -0.01656498f, -0.04368379f, -0.04944559f, 0.00913443f, -0.02607874f, 0.01376625f, -0.05059221f, 
    0.01532124f, -0.01143282f, -0.02378661f, 0.03334184f, 0.00583037f, 0.03725930f, -0.02673324f, -0.03574872f, 
    -0.00244109f, -0.01720091f, -0.01777634f, 0.02791738f, -0.01617333f, -0.04694168f, -0.00866061f, -0.04840677f, 
    0.04462392f, -0.03686563f, -0.05264108f, 0.04276640f, -0.04221638f, 0.01492708f, -0.04121168f, 0.00252216f, 
    0.02233264f, -0.01609310f, -0.01727486f, -0.03447847f, 0.01160484f, 0.02765892f, -0.04412968f, 0.02144979f, 
    -0.04851778f, -0.02284357f, -0.00494179f, 0.01910390f, 0.03584585f, -0.04253550f, -0.04196692f, -0.00045095f, 
    0.02790455f, -0.03682380f, -0.03905027f, 0.02755075f, -0.02934602f, 0.03581586f, 0.02678057f, -0.01134238f, 
    0.02638294f, 0.03899965f, -0.04756794f, -0.01309795f, 0.00200697f, -0.04480893f, -0.01876247f, 0.02137546f, 
    0.01575600f, 0.01384452f, -0.00944457f, 0.00752576f, -0.02208869f, 0.01609326f, -0.01324672f, 0.04231879f, 
    -0.04698936f, -0.01443478f, 0.00308304f, 0.04332388f, -0.05653972f, -0.05017219f, -0.02062221f, 0.00659978f, 
    0.03659895f, -0.07068349f, -0.01939811f, -0.12560976f, 0.19526672f, -0.11865846f, -0.00855219f, 0.01452965f, 
    0.06251384f, 0.04717980f, -0.01178282f, -0.08815303f, 0.00840176f, 0.00949901f, -0.08094015f, -0.00751562f, 
    -0.04261378f, -0.06142486f, 0.02549677f, 0.03230650f, 0.03998196f, 0.08865239f, 0.05568437f, -0.04001779f, 
    -0.10491423f, 0.15351409f, -0.05749390f, -0.01255084f, 0.07350828f, 0.03510347f, -0.05967537f, -0.09536803f, 
    0.02074204f, 0.06784809f, -0.03295485f, -0.00293521f, -0.08973805f, 0.01693452f, 0.00259309f, 0.01225912f, 
    -0.21669465f, -0.17524812f, 0.09125037f, 0.00091887f, 0.09519935f, 0.05473369f, 0.05488131f, 0.03695907f, 
    -0.01171022f, -0.01765227f, -0.10597603f, -0.00501373f, 0.04216226f, 0.00522949f, -0.00150918f, -0.06292654f, 
    0.05640472f, -0.11808646f, 0.03810739f, 0.02115289f, 0.12805711f, -0.07605252f, -0.15528913f, -0.16677727f, 
    0.01957646f, 0.00813567f, 0.08414497f, -0.03151890f, -0.01797271f, -0.07114150f, 0.00452985f, 0.08086457f, 
    -0.08975985f, 0.00359215f, 0.00638575f, 0.05640028f, 0.07778848f, -0.03107901f, 0.06470052f, 0.05973191f, 
    0.45578122f, -0.35461178f, 0.15731147f, 0.00744522f, 0.08375093f, 0.10237022f, 0.00885804f, -0.01304579f, 
    -0.12882076f, 0.02920006f, -0.01247362f, 0.06770134f, -0.02176656f, 0.01706871f, 0.09564963f, -0.04030269f, 
    -0.01230755f, 0.09819701f, 0.02338174f, -0.00088898f, 0.07832360f, -0.22405268f, 0.03915841f, -0.09815487f, 
    -0.04877490f, -0.00152599f, 0.05203313f, 0.01739351f, -0.05568361f, -0.08242516f, 0.06897896f, 0.04007968f, 
    -0.05995031f, 0.00022659f, 0.04127311f, 0.00862972f, -0.02743866f, 0.06339542f, 0.02671363f, 0.04621631f, 
    0.07610863f, 0.08077478f, -0.19245425f, -0.19747472f, 0.13044642f, 0.09185244f, 0.04564501f, -0.04184171f, 
    -0.02882401f, -0.04746289f, -0.01000495f, 0.06961604f, -0.00875385f, 0.01777203f, 0.00307517f, 0.11006053f, 
    0.02945019f, -0.00517551f, 0.05033733f, 0.00677480f, -0.04057816f, -0.04016274f, -0.06057501f, -0.09653544f, 
    0.04432986f, 0.14093481f, -0.03574247f, 0.13401194f, -0.07933342f, -0.06886759f, -0.01623537f, -0.06853884f, 
    0.02582003f, 0.00406692f, -0.03026879f, 0.09561316f, -0.03162179f, 0.01014595f, -0.10657530f, -0.00868196f, 
    0.13984400f, -0.01589847f, -0.02351576f, -0.09692208f, -0.04167373f, 0.09502374f, 0.05602405f, 0.09114242f, 
    0.01458845f, -0.01413995f, -0.06438075f, 0.04096892f, 0.01379658f, -0.03514401f, 0.02838903f, -0.04920948f, 
    0.01340345f, -0.06927155f, -0.12391756f, 0.07455602f, -0.05702314f, 0.29714832f, 0.11025748f, 0.25858074f, 
    -0.03076972f, -0.05522845f, 0.05040586f, -0.00606396f, 0.07233574f, -0.03180024f, -0.06177650f, -0.03227026f, 
    -0.02207451f, 0.10470162f, -0.02775780f, -0.01408687f, -0.01757059f, 0.18628989f, 0.03950467f, -0.02389489f, 
    -0.18707062f, -0.10301435f, 0.17639402f, -0.37555730f, -0.10500938f, 0.21878013f, 0.13852029f, 0.03038142f, 
    -0.02252863f, 0.18388033f, -0.08778162f, -0.11690028f, -0.07373614f, 0.07162338f, -0.12424274f, 0.01229715f, 
    0.03460864f, -0.06706709f, 0.08036278f, -0.08294863f, -0.09627767f, -0.36298618f, 0.06312229f, 0.21227875f, 
    -0.00386665f, -0.00447791f, -0.03455488f, -0.09144387f, -0.13694926f, 0.06904303f, 0.10290416f, 0.06810413f, 
    -0.05408519f, 0.01116719f, 0.03661120f, -0.01221305f, 0.02094040f, 0.12053558f, 0.05827773f, 0.02177805f, 
    0.17009014f, -0.00607492f, 0.02856555f, 0.02684213f, -0.11034505f, -0.00783618f, 0.02432533f, -0.01644541f, 
    0.09545814f, 0.07449549f, -0.06084622f, -0.05950925f, 0.02105406f, 0.08793030f, 0.11107970f, 0.07613201f, 
    0.06345921f, -0.07222627f, 0.06055870f, -0.05968851f, -0.13064463f, 0.15399377f, 0.04279781f, 0.08015716f, 
    -0.01831390f, -0.03849920f, -0.05427679f, 0.10690548f, 0.12781747f, 0.01600982f, -0.15037553f, 0.04677231f, 
    -0.03692214f, -0.00179126f, 0.00399330f, 0.04829155f, 0.01477902f, 0.02012268f, -0.01491528f, -0.02849274f, 
    -0.12200180f, -0.08834241f, 0.09921109f, 0.05735124f, 0.13974747f, 0.05404129f, -0.03947180f, 0.02227597f, 
    -0.03265734f, 0.01816037f, -0.01301134f, -0.00216417f, 0.02084042f, 0.00848793f, -0.05777241f, -0.00576475f, 
    0.05681955f, 0.02096515f, 0.02331046f, -0.00952785f, -0.14207292f, -0.16278102f, 0.12631097f, 0.35018110f, 
    0.05637150f, -0.00921764f, 0.02904015f, 0.00840334f, -0.16033229f, -0.11621746f, -0.04457871f, -0.01704035f, 
    -0.09832522f, -0.03748356f, 0.05725424f, 0.04638564f, -0.03939651f, 0.13673380f, 0.06379064f, 0.01550936f, 
    -0.11660978f, -0.04482470f, -0.10621390f, -0.12687342f, 0.27164483f, 0.10025214f, -0.08415649f, 0.00356361f, 
    0.01952886f, -0.05964173f, 0.11246875f, 0.14689623f, 0.01903813f, 0.01787652f, -0.03861311f, -0.01849669f, 
    0.17209271f, -0.10768198f, -0.00832921f, 0.03048121f, -0.26837716f, 0.27579498f, -0.01417915f, -0.13829437f, 
    0.08755623f, 0.01818757f, -0.04584195f, 0.03158236f, 0.08558401f, 0.02096340f, -0.01040924f, 0.05252353f, 
    0.04187021f, -0.03777972f, 0.13580240f, 0.04610424f, -0.09867888f, 0.04969416f, 0.08470851f, -0.02137104f, 
    0.24517372f, 0.21191844f, -0.04657488f, -0.04486789f, -0.02424875f, -0.04608330f, -0.08799931f, 0.15720423f, 
    -0.00023876f, -0.04765793f, -0.01499723f, -0.03369561f, -0.09502418f, -0.07513569f, 0.05547614f, -0.00899086f, 
    -0.03796359f, 0.03487174f, -0.00299066f, 0.06224940f, 0.15370663f, -0.14769366f, 0.00100783f, 0.02828217f, 
    -0.02552100f, -0.08193222f, -0.06056684f, -0.03436690f, -0.03232024f, -0.08184024f, 0.00461278f, 0.09804157f, 
    0.00437179f, 0.06269331f, 0.00556585f, -0.07678099f, -0.05362041f, -0.02295116f, -0.03165311f, 0.09928142f, 
    -0.10383190f, 0.01208900f, -0.14128397f, -0.16784790f, 0.14717256f, 0.01481808f, 0.03721469f, -0.02244015f, 
    0.07481218f, 0.10768690f, -0.02976813f, 0.04627993f, -0.03036935f, -0.00988349f, -0.03150813f, 0.01976537f, 
    -0.07854345f, 0.01633429f, -0.05145108f, 0.06054627f, 0.17188726f, -0.00085261f, 0.02164928f, 0.01911308f, 
    0.01277715f, 0.00190738f, -0.05661800f, 0.07193688f, -0.02775264f, -0.01225508f, 0.01196213f, -0.03649453f, 
    0.02210676f, -0.00834529f, -0.04004106f, 0.02433113f, 0.03785981f, -0.04024195f, -0.01793999f, 0.03902911f, 
    0.22914995f, -0.13179697f, -0.11056623f, 0.05297703f, 0.04316952f, 0.01426726f, 0.02139884f, 0.04395590f, 
    -0.03927276f, -0.02885167f, -0.11105273f, 0.01680563f, 0.07433992f, -0.02881358f, -0.04372297f, -0.03164585f, 
    -0.07245036f, -0.01381023f, 0.02578988f, 0.04568674f, 0.07475358f, 0.22257937f, -0.06520457f, -0.05149916f, 
    0.05169731f, -0.09016624f, 0.02035886f, 0.09565514f, -0.04215814f, 0.00801130f, 0.10105418f, 0.13990858f, 
    -0.10549380f, 0.02366591f, 0.01370768f, 0.09235302f, -0.15804534f, 0.05902256f, 0.07743254f, 0.03540374f, 
    0.08825152f, 0.10382376f, 0.06113673f, -0.13232422f, 0.24368022f, 0.07488557f, -0.09107853f, 0.02916688f, 
    -0.03293884f, -0.05347273f, -0.06900845f, -0.03060768f, 0.02695822f, 0.04193497f, -0.01815889f, 0.10838234f, 
    -0.00434015f, 0.02232091f, 0.08128522f, 0.02765698f, 0.18605679f, -0.00633937f, -0.08442901f, -0.06507397f, 
    -0.28722799f, 0.03417822f, -0.11733268f, -0.05815769f, 0.02201982f, 0.03658805f, 0.06593424f, 0.10356274f, 
    0.03436738f, 0.17685072f, 0.07251098f, 0.05803420f, -0.03787140f, -0.07907097f, -0.06046396f, -0.01616391f, 
    0.03419923f, 0.04746779f, 0.07194354f, -0.12341643f, 0.08601243f, -0.05260611f, -0.18319088f, 0.14037368f, 
    -0.06682341f, 0.01730350f, 0.02949755f, 0.06117668f, 0.06747620f, 0.04275477f, -0.07573080f, -0.10133097f, 
    -0.09518319f, 0.00863464f, 0.01055499f, 0.06076187f, -0.37606019f, 0.00234783f, -0.06299335f, -0.06578460f, 
    -0.04995267f, -0.09475835f, -0.02849199f, 0.04859583f, 0.01857483f, -0.01950501f, -0.16322583f, 0.04130970f, 
    0.03458876f, 0.01701014f, 0.02225355f, 0.03737387f, -0.08546565f, 0.05770291f, -0.15730676f, 0.00042449f, 
    -0.03056748f, 0.10172731f, -0.05807646f, -0.02171822f, 0.06171764f, 0.15413381f, -0.05690825f, -0.09635341f, 
    0.11204123f, 0.04351512f, 0.02374963f, 0.12149053f, 0.04713937f, -0.00407289f, 0.01790456f, 0.08975471f, 
    0.10239183f, 0.08860003f, -0.08961305f, 0.08254948f, 0.00808625f, 0.15888326f, -0.11901869f, -0.07410000f, 
    -0.08080664f, 0.05743574f, 0.03175915f, -0.03785113f, 0.01863741f, 0.00675701f, 0.12733939f, 0.00753335f, 
    0.06221876f, -0.00915681f, -0.04470001f, -0.02441681f, 0.00050978f, -0.04499539f, 0.03538957f, 0.07298467f, 
    -0.38770100f, 0.06857875f, 0.13939908f, 0.06879698f, 0.13357900f, 0.05329082f, -0.03556148f, -0.02945175f, 
    0.01546298f, -0.02364558f, 0.03495198f, 0.03357635f, -0.02998694f, 0.05354926f, 0.05289163f, 0.03273389f, 
    0.10453271f, 0.05941428f, -0.04470807f, -0.06660329f, -0.13094869f, -0.28333253f, -0.19787507f, -0.05054972f, 
    -0.04377471f, 0.05115366f, 0.14304882f, -0.00821248f, -0.04537163f, 0.08750133f, -0.09886450f, -0.01114452f, 
    0.01936780f, 0.02936829f, 0.06917439f, -0.09859170f, 0.02295538f, 0.06453300f, -0.17651530f, 0.05505712f, 
    0.13125029f, -0.22602504f, -0.10375568f, 0.14695504f, -0.21482785f, 0.06104586f, 0.03401060f, 0.08261318f, 
    -0.01051275f, -0.00981767f, -0.04607372f, 0.07167321f, 0.06804977f, -0.04099553f, 0.05345060f, -0.02199842f, 
    -0.02649712f, 0.06079702f, -0.02079314f, -0.03107656f, -0.08161995f, -0.08898458f, -0.08614501f, 0.11028653f, 
    -0.05950949f, -0.00828279f, 0.09286422f, 0.02137153f, 0.06742725f, 0.06471243f, 0.02133388f, 0.02935763f, 
    -0.00179215f, -0.01997145f, -0.07718403f, 0.07714508f, -0.06168417f, 0.00725627f, -0.01747318f, -0.07799822f, 
    0.03603450f, 0.06191922f, 0.00846650f, 0.05230818f, 0.03430978f, 0.09392478f, 0.04653434f, -0.05605375f, 
    0.06309357f, 0.10858566f, 0.01693240f, -0.02882818f, 0.00184886f, -0.06843429f, -0.03428537f, 0.04518648f, 
    -0.02800650f, -0.01508498f, 0.01638468f, -0.04652042f, -0.29213220f, -0.03690393f, -0.07794420f, 0.10300507f, 
    0.01387652f, 0.06625730f, -0.01387384f, 0.01831168f, 0.02181986f, 0.03764195f, 0.04241769f, -0.00231108f, 
    0.12558842f, 0.09992210f, -0.04335258f, 0.07974599f, 0.03747419f, 0.03287899f, 0.04485081f, -0.00925504f, 
    -0.37487003f, 0.35748354f, -0.13772134f, 0.00987062f, -0.13979858f, 0.01681353f, -0.03161528f, 0.19466545f, 
    0.13457011f, -0.03699699f, 0.07139961f, -0.08417164f, 0.06591003f, -0.00986746f, -0.10097893f, 0.00040962f, 
    -0.12048213f, -0.06357043f, -0.10813710f, -0.01745342f, -0.16981451f, 0.09752811f, -0.07973332f, 0.17026201f, 
    -0.11763280f, 0.08497483f, 0.03327930f, -0.00844963f, 0.13636692f, 0.12175245f, -0.03141301f, -0.06120464f, 
    0.06843209f, -0.03131821f, -0.07873509f, 0.09621277f, 0.03657702f, 0.04976109f, -0.04419532f, -0.07826246f, 
    -0.21525815f, -0.16011453f, -0.09544029f, 0.09445667f, -0.05223542f, 0.03170912f, 0.02516188f, -0.07296202f, 
    0.02949478f, -0.01397830f, 0.05582382f, -0.02909974f, -0.00274794f, 0.04196322f, 0.05769869f, -0.09595228f, 
    0.01425290f, 0.14465864f, 0.01718280f, -0.03986323f, -0.03034586f, 0.03217037f, 0.03983129f, 0.14297815f, 
    0.01129624f, -0.06065668f, 0.06313024f, -0.03909108f, 0.04260441f, 0.00096395f, -0.04167809f, 0.00439928f, 
    -0.03377279f, 0.05990965f, -0.02044738f, -0.07855146f, 0.02769539f, 0.03959768f, 0.08034556f, 0.01452220f, 
    -0.21408255f, 0.08565181f, -0.06257818f, 0.02946292f, -0.09012288f, 0.09732269f, -0.04206964f, 0.06712306f, 
    0.04333893f, 0.05060349f, 0.05784864f, -0.11984071f, -0.01325704f, 0.02893157f, 0.00244581f, 0.07520262f, 
    0.01499891f, -0.01716951f, 0.17174993f, -0.01931715f, 0.14689612f, -0.06179141f, 0.12064464f, -0.01092630f, 
    0.06742283f, -0.12329679f, -0.11858631f, 0.08933775f, 0.15045549f, 0.15734509f, -0.00512782f, 0.05498524f, 
    0.05005042f, -0.09214539f, 0.00160948f, 0.07408879f, -0.00581107f, -0.02354287f, 0.03959450f, 0.11501376f, 
    0.12064849f, -0.04634439f, -0.19569854f, 0.19644755f, 0.02077330f, -0.19967787f, -0.04881387f, 0.02106873f, 
    -0.03598684f, -0.03897442f, 0.04116507f, -0.01459123f, 0.07130197f, 0.00506552f, 0.12322000f, 0.03579658f, 
    0.01205318f, -0.03003064f, 0.10082168f, -0.04615847f, -0.09044529f, 0.29189110f, -0.12257764f, -0.25446105f, 
    0.04878831f, -0.01445864f, 0.05677381f, 0.19181369f, 0.10570846f, -0.05192315f, 0.01865719f, -0.06025221f, 
    0.07707163f, -0.04501621f, 0.02965558f, -0.10360566f, 0.02220207f, -0.02210913f, -0.01248597f, -0.01068536f, 
    0.10746964f, 0.08157450f, 0.09849074f, 0.10722311f, 0.06335265f, 0.02406243f, -0.04949848f, 0.04328783f, 
    -0.00420217f, -0.00124284f, 0.14249954f, -0.01502902f, -0.00389323f, -0.11312017f, 0.00533399f, -0.00684565f, 
    -0.04192321f, -0.09038378f, 0.02787454f, -0.02424564f, 0.29902101f, -0.00760097f, 0.08078296f, -0.01464583f, 
    0.05396271f, -0.13234845f, 0.09321794f, 0.18371794f, 0.04814014f, -0.01384476f, 0.00077931f, -0.07894963f, 
    0.05621518f, -0.00652478f, 0.00575847f, -0.00073267f, 0.05355937f, 0.02232024f, 0.04713010f, 0.09482944f, 
    0.28791606f, -0.10642061f, -0.04381194f, -0.11075479f, -0.15647110f, 0.00491761f, -0.12086435f, -0.10868430f, 
    -0.06226996f, 0.07231347f, -0.05104223f, -0.03815880f, -0.04908941f, -0.02396164f, 0.01627505f, 0.02438595f, 
    -0.07596113f, 0.00558369f, -0.00450728f, -0.03980388f, -0.00815307f, 0.10585746f, -0.12624905f, -0.07057332f, 
    0.15863697f, 0.10244033f, -0.01241657f, 0.12078130f, 0.03840134f, 0.14889950f, -0.11574451f, 0.13762251f, 
    0.07848256f, -0.04114418f, -0.05596413f, 0.01910319f, 0.06429912f, 0.00493445f, 0.07906989f, 0.02720134f, 
    -0.15019102f, -0.09043393f, -0.08811740f, -0.10846595f, 0.08414880f, -0.02463014f, -0.02913406f, 0.06774058f, 
    -0.01095873f, -0.13213189f, 0.06672484f, -0.04735995f, 0.09765068f, 0.02358614f, -0.05603720f, 0.02546252f, 
    0.11446764f, 0.02355313f, 0.00668767f, 0.10713082f, -0.08014607f, -0.01854715f, -0.01327130f, -0.00000134f, 
    0.15329865f, 0.06002723f, -0.03674618f, -0.02746695f, 0.08997013f, -0.08322568f, -0.04006425f, -0.08606683f, 
    0.05151084f, 0.09630923f, 0.14276634f, 0.02777605f, -0.01752714f, 0.02821437f, -0.08370861f, 0.10762814f, 
    -0.06708127f, 0.11904198f, -0.04363025f, -0.17187881f, 0.00189479f, 0.02085670f, 0.03902934f, -0.08615791f, 
    0.08917478f, 0.01483024f, 0.12048198f, 0.11047206f, 0.08464108f, 0.06836054f, -0.07131934f, 0.01307316f, 
    -0.00131959f, -0.08895642f, -0.02784808f, -0.06847273f, -0.22925919f, -0.07411375f, -0.17681722f, -0.15147118f, 
    0.08066101f, -0.00557700f, -0.02536867f, 0.06802111f, 0.08343501f, 0.03977838f, -0.07387775f, -0.04445617f, 
    -0.11533363f, -0.01364606f, 0.02978870f, 0.11299881f, 0.02264316f, -0.03341147f, 0.01715733f, 0.03516370f, 
    -0.22851062f, 0.28651315f, -0.25991547f, 0.05373663f, -0.09434767f, 0.04312042f, 0.03647308f, 0.05896553f, 
    -0.00226045f, 0.10608950f, 0.03222691f, 0.04163330f, 0.01745256f, -0.01428886f, 0.01317609f, 0.00920310f, 
    0.00663856f, 0.04818656f, -0.09089495f, 0.00781952f, -0.30151737f, -0.00260589f, -0.00422666f, -0.14036733f, 
    0.09869300f, 0.13093226f, -0.01391335f, 0.11519731f, 0.06454024f, -0.02334695f, -0.05842688f, -0.01034567f, 
    -0.01481928f, 0.05148179f, -0.06263775f, 0.12577143f, 0.07786316f, 0.06701508f, 0.03916443f, 0.05159201f, 
    -0.07071511f, -0.13437556f, -0.07202642f, -0.20221116f, -0.00088664f, -0.10349485f, 0.08444525f, -0.06576063f, 
    -0.04106638f, -0.03574962f, 0.02004255f, -0.10808493f, -0.07081168f, -0.00848189f, 0.07634203f, 0.11817603f, 
    0.05532100f, -0.03999959f, 0.05624723f, -0.00834110f, -0.08604915f, 0.10936900f, -0.10916767f, -0.11581592f, 
    0.03615221f, -0.00183295f, 0.03901635f, 0.01191747f, 0.05440395f, 0.01386269f, -0.03895959f, 0.05147632f, 
    -0.02805275f, 0.03386384f, -0.00268157f, -0.01010942f, -0.01293460f, 0.08460805f, -0.00850105f, 0.01713310f, 
    -0.05761124f, 0.07332185f, -0.03829612f, -0.05577108f, 0.15379192f, 0.12247182f, -0.00820441f, -0.05270728f, 
    0.00695677f, -0.04589339f, -0.12153997f, -0.00232883f, 0.13410108f, -0.05112990f, 0.13985041f, 0.03255180f, 
    0.02466939f, 0.00363903f, 0.05526938f, -0.04570026f, 0.09323713f, 0.17884760f, 0.05856277f, 0.26318303f, 
    0.05931512f, 0.06879899f, 0.01464928f, 0.01119039f, 0.09000454f, 0.04150868f, 0.13418743f, 0.02481905f, 
    0.03546807f, 0.09612859f, 0.00186449f, 0.03781305f, 0.04910633f, 0.01565806f, 0.07839117f, 0.01215702f, 
    -0.23097515f, -0.03934209f, -0.16888833f, -0.10789160f, 0.04781337f, -0.01228258f, 0.04389036f, -0.02180673f, 
    0.04243661f, 0.05610761f, 0.02519836f, -0.09721155f, -0.04031039f, -0.09860920f, -0.10589859f, -0.05987955f, 
    0.07999323f, 0.01831075f, 0.05518226f, 0.02147446f, -0.45913962f, 0.16761665f, -0.08795092f, 0.00107512f, 
    0.08413573f, -0.00476253f, 0.11957927f, 0.03746044f, 0.11163642f, 0.03315264f, -0.03365161f, 0.01867111f, 
    -0.07325183f, 0.01546359f, -0.07402323f, -0.04415188f, 0.05309885f, 0.01416332f, 0.01162882f, 0.04095251f, 
    0.02218188f, 0.08585723f, 0.14957038f, 0.16442038f, 0.28897187f, 0.03757562f, -0.02708311f, 0.04749674f, 
    -0.00896867f, 0.12692386f, 0.16430064f, 0.01060432f, 0.08004897f, -0.06568050f, 0.04692853f, 0.09090498f, 
    -0.02437394f, 0.04508458f, -0.09936833f, -0.03023670f, 0.06460472f, 0.18242139f, 0.07514198f, 0.18057491f, 
    -0.12121132f, 0.03394032f, 0.06601074f, 0.06633140f, 0.01499014f, -0.04106589f, -0.00231250f, 0.02655945f, 
    0.14279991f, 0.09272690f, 0.18185717f, -0.00176303f, -0.06316237f, 0.05795291f, 0.05577034f, 0.05990905f, 
    0.10159833f, -0.02265632f, 0.09192187f, -0.01147718f, 0.01426943f, 0.08788180f, -0.00988917f, -0.03902382f, 
    -0.04234922f, 0.07453313f, -0.01265832f, -0.04746036f, 0.03975684f, 0.00599331f, -0.03286929f, 0.06013046f, 
    0.13493915f, -0.00748114f, 0.05123894f, 0.01914393f, 0.00258586f, -0.10882553f, -0.27026507f, -0.01801795f, 
    -0.17742492f, 0.01496980f, 0.07225793f, -0.06101918f, 0.03076781f, 0.08491161f, -0.05269660f, 0.08571989f, 
    -0.04936109f, 0.02736880f, 0.01747169f, -0.00265753f, 0.06564674f, 0.02480588f, -0.10160433f, -0.09200317f, 
    0.04308069f, 0.08029550f, -0.01685248f, -0.05685606f, 0.06523495f, -0.01303059f, 0.05955058f, 0.01752178f, 
    -0.00977492f, 0.09706432f, -0.08707924f, -0.07508871f, 0.00166675f, -0.04259279f, -0.05807810f, 0.00061432f, 
    0.03880451f, 0.10613504f, 0.12140409f, 0.02334612f, 0.21405981f, -0.00751310f, -0.03306267f, 0.03053533f, 
    -0.01932294f, 0.02952442f, 0.04824571f, 0.04794616f, -0.08406641f, 0.10776001f, 0.00343061f, 0.07994787f, 
    0.02249374f, -0.08039703f, -0.04031439f, -0.05303372f, 0.05787886f, -0.00264370f, 0.15623340f, 0.04054643f, 
    0.18000808f, -0.10075553f, 0.08833745f, -0.00188929f, 0.06948490f, 0.01947156f, 0.01129301f, -0.03122267f, 
    -0.02090276f, 0.01691487f, 0.02402824f, -0.02069637f, 0.02311351f, -0.05266305f, -0.00347935f, -0.12010288f, 
    0.01449201f, 0.02601081f, 0.00869008f, 0.03394528f, 0.13318564f, -0.03951113f, 0.09917589f, 0.03064044f, 
    0.06798510f, -0.04271620f, 0.07524864f, -0.04455650f, -0.02804929f, -0.00918537f, 0.04267722f, 0.04704056f, 
    -0.01865123f, 0.07851653f, -0.05677866f, -0.05226090f, 0.02355707f, 0.00562399f, -0.04049298f, -0.07864231f, 
    0.42467201f, -0.34803501f, 0.08134211f, 0.01277033f, 0.01869336f, 0.04780072f, 0.00180487f, 0.01707057f, 
    0.06801435f, 0.00669078f, 0.06802317f, 0.04795274f, -0.03479803f, -0.00509674f, 0.06703972f, -0.02182816f, 
    0.08068458f, -0.02866457f, -0.00031165f, -0.03868595f, 0.29172143f, -0.02711882f, 0.14844236f, -0.06900831f, 
    0.13515590f, -0.05900446f, 0.05144453f, -0.03846076f, -0.01793983f, -0.05157341f, -0.04580602f, -0.01913830f, 
    0.03654689f, 0.02210663f, 0.00088475f, -0.09827946f, -0.01062531f, 0.04500766f, 0.01674254f, -0.03467296f, 
    0.04828724f, 0.05885844f, 0.15965500f, -0.04372475f, 0.17023578f, 0.01416108f, 0.08500498f, -0.04883859f, 
    0.00013063f, -0.02503398f, -0.05442090f, 0.00104793f, 0.01642951f, 0.06051764f, -0.10374485f, 0.02342121f, 
    -0.02194551f, 0.13379921f, -0.03346960f, 0.05479661f, 0.06670079f, -0.01395327f, 0.08604873f, 0.02021741f, 
    0.06890488f, 0.07460561f, 0.04446288f, 0.08935630f, -0.03067275f, -0.04003344f, 0.00673552f, 0.05241593f, 
    -0.01233065f, -0.04263338f, -0.06020981f, 0.00389842f, -0.07497816f, -0.00413441f, 0.03820602f, -0.00251161f, 
    0.27423450f, -0.07596404f, 0.12317966f, -0.01600862f, -0.00063441f, -0.09012212f, -0.02830804f, 0.00251665f, 
    0.07676712f, 0.00540203f, -0.02550702f, 0.08825798f, 0.01237776f, 0.04630842f, -0.05864696f, 0.05760045f, 
    -0.02980654f, 0.05291865f, 0.01245725f, 0.14352320f, -0.46119937f, -0.01760236f, 0.12022402f, -0.21253997f, 
    -0.23135337f, -0.11421340f, -0.06295753f, -0.02881770f, -0.06701848f, -0.03012821f, -0.03589344f, 0.01039435f, 
    -0.10711550f, 0.02719647f, 0.05056093f, 0.00377529f, -0.11906137f, -0.05895722f, -0.00861413f, 0.02193017f, 
    0.09421658f, 0.15093412f, 0.11770300f, 0.05649858f, 0.06415898f, 0.14042318f, 0.01279052f, 0.13131408f, 
    0.11725350f, -0.05732029f, -0.01901686f, 0.01875415f, -0.06582309f, 0.10852083f, 0.02966586f, 0.02913659f, 
    -0.11395241f, -0.01976983f, 0.00294094f, 0.04768086f, 0.37751487f, -0.32308722f, -0.01317066f, 0.09618878f, 
    -0.11184479f, 0.01249579f, -0.12524556f, 0.04974702f, 0.00721522f, 0.09207623f, 0.05184983f, 0.01875474f, 
    -0.00490101f, -0.02185747f, -0.00695920f, 0.14256985f, 0.05613326f, 0.08421840f, -0.06504492f, 0.00607701f, 
    -0.16846861f, 0.00216320f, -0.00727812f, 0.00933755f, -0.18763681f, -0.06988718f, 0.11237603f, 0.03003605f, 
    -0.00147544f, -0.02994090f, -0.11255513f, -0.05875436f, -0.02713626f, -0.03331887f, -0.02466197f, -0.04545010f, 
    0.06342734f, -0.01089410f, 0.09509586f, 0.04188965f, -0.24163471f, 0.21212521f, 0.00008127f, -0.14450458f, 
    -0.10754411f, 0.06629127f, -0.06463813f, -0.00993012f, -0.00024918f, -0.03486358f, -0.05656593f, 0.11225679f, 
    -0.08573140f, -0.06767008f, -0.15361267f, -0.03646120f, -0.02185573f, -0.05978143f, -0.01241223f, 0.03292061f, 
    -0.13858679f, -0.09113760f, 0.03266599f, 0.01609537f, 0.08845727f, 0.07294477f, 0.05863675f, 0.01248651f, 
    0.05638247f, 0.01442563f, -0.02092644f, -0.04343784f, 0.12592356f, 0.10954706f, -0.00741757f, -0.01245466f, 
    -0.00746242f, -0.01670008f, -0.01655663f, -0.02658503f, 0.17838362f, 0.01662370f, 0.02451654f, 0.07540669f, 
    -0.12997341f, 0.10626352f, 0.10928332f, 0.06793007f, 0.06262548f, 0.01362822f, 0.09880884f, 0.05681151f, 
    -0.00414419f, 0.06643973f, 0.02647307f, 0.05279092f, -0.01316405f, -0.00202057f, -0.04542008f, -0.02485992f, 
    -0.05959491f, -0.00612069f, 0.04037165f, 0.02414093f, 0.01781589f, 0.00088573f, -0.04121285f, 0.03180400f, 
    0.01311943f, -0.05246616f, 0.04682635f, -0.00809310f, -0.02245559f, 0.04605073f, 0.03190703f, -0.02643798f, 
    0.02503689f, 0.03900752f, 0.05297970f, -0.04446220f, -0.00621658f, 0.04241662f, -0.04110279f, -0.01120658f, 
    0.00217747f, 0.03232557f, 0.01587577f, 0.03842754f, -0.05239795f, -0.02693764f, 0.01877865f, -0.00411399f, 
    -0.02929955f, -0.05701449f, 0.03771194f, -0.05245058f, -0.00882572f, -0.05339606f, 0.01847336f, -0.05274435f, 
    -0.06094587f, -0.04048593f, 0.04023637f, 0.00744102f, -0.06091698f, -0.05212798f, 0.05009539f, 0.04625138f, 
    0.01494622f, 0.01263667f, -0.00308237f, -0.04354985f, -0.05576137f, 0.01521735f, -0.00117468f, -0.05319634f, 
    0.01430121f, 0.04701507f, 0.04004971f, 0.01001777f, -0.05186294f, -0.04313286f, -0.01251185f, 0.01376896f, 
    -0.06286347f, 0.03622936f, 0.04574397f, -0.04748952f, -0.01586973f, 0.05593894f, -0.00858166f, 0.03167487f, 
    -0.02565218f, -0.01883724f, -0.06369979f, 0.03633050f, 0.04093332f, -0.00290999f, -0.04262020f, 0.02923473f, 
    0.04188465f, -0.06170277f, -0.06138841f, -0.02365873f, -0.01372156f, -0.04710664f, -0.05145984f, 0.02536335f, 
    0.04800593f, -0.03698803f, 0.03852879f, -0.01423835f, -0.01181291f, -0.01254188f, -0.05689451f, 0.04119033f, 
    0.04859355f, -0.05575470f, -0.00864854f, 0.05122159f, -0.03852018f, 0.03400125f, 0.01754759f, 0.00179557f, 
    -0.00906272f, -0.05327233f, -0.00437423f, -0.02046086f, 0.00233410f, -0.00689563f, 0.04962930f, -0.05107727f, 
    0.01057188f, 0.04524649f, 0.03291010f, 0.00654095f, 0.00462703f, 0.04831680f, -0.04249754f, 0.02555430f, 
    -0.05281829f, 0.00535266f, 0.01641488f, -0.06079338f, -0.04021151f, -0.01412936f, 0.02055478f, -0.03031515f, 
    -0.06349155f, 0.04828586f, -0.04473291f, -0.02958083f, -0.00579627f, -0.01207303f, -0.01908696f, -0.04656300f, 
    -0.05877180f, 0.01331837f, -0.00392880f, -0.02961937f, 0.00118308f, 0.04021274f, -0.04898855f, 0.02483511f, 
    -0.02242410f, -0.01019241f, -0.01096062f, 0.03579976f, -0.01258936f, -0.03366174f, 0.02732836f, 0.00059101f, 
    0.04305961f, -0.03654035f, 0.03610776f, 0.02605806f, 0.02319882f, 0.02882461f, 0.03541961f, 0.04393261f, 
    -0.05455484f, 0.05198983f, -0.03356072f, -0.03688542f, 0.02313623f, -0.03941177f, -0.04501012f, -0.03866153f, 
    -0.02065319f, -0.03959748f, -0.06446796f, 0.00939752f, -0.06144780f, -0.05640885f, -0.03079804f, -0.02135579f, 
    -0.00203387f, 0.02158830f, 0.02030807f, -0.04434806f, 0.01705086f, -0.01995496f, -0.02519952f, -0.03166922f, 
    0.03237833f, -0.01851824f, 0.01980407f, 0.03234606f, -0.05072944f, -0.01649079f, 0.01439154f, -0.04056537f, 
    -0.00261742f, -0.03453854f, -0.00256822f, 0.00229270f, -0.03020042f, -0.01575564f, 0.05166583f, -0.03310235f, 
    -0.03014031f, 0.01315190f, -0.03151451f, 0.04557403f, -0.03718452f, -0.05654544f, 0.01101029f, -0.04909503f, 
    0.03291658f, -0.05084138f, 0.04956647f, 0.01792345f, 0.04233118f, -0.00639308f, 0.01857198f, 0.05113161f, 
    0.01445134f, 0.01038918f, 0.02581819f, 0.04608999f, 0.01409009f, -0.00935520f, -0.01429319f, -0.02970768f, 
    0.00842888f, 0.01485017f, 0.01693477f, 0.00294198f, -0.05111309f, -0.02866946f, -0.03547789f, -0.04215182f, 
    0.03093303f, 0.02747394f, 0.01422227f, -0.04200786f, 0.01964935f, 0.04033499f, -0.04314914f, 0.05222074f, 
    0.04536406f, 0.01674323f, -0.05603199f, 0.03644158f, 0.04383728f, -0.02247833f, -0.01034713f, -0.04254917f, 
    0.04721635f, 0.00630231f, -0.04549653f, -0.02428426f, 0.01275522f, 0.02283004f, 0.03042099f, -0.04612768f, 
    -0.04655978f, -0.05313956f, -0.04479938f, -0.04469639f, 0.00452253f, -0.05150494f, -0.03609132f, -0.05477936f, 
    -0.03477620f, -0.05725532f, 0.01355317f, -0.00531799f, 0.00998834f, -0.01594524f, 0.02233727f, 0.03141155f, 
    -0.03617897f, 0.03859485f, 0.02187853f, -0.00056412f, 0.00520034f, 0.03193666f, -0.01820819f, -0.04664474f, 
    -0.00057748f, -0.03329628f, -0.05615488f, -0.00124623f, -0.03115272f, -0.05712944f, -0.00728271f, -0.02127985f, 
    -0.04056259f, 0.02631263f, 0.01341374f, -0.03803195f, -0.01681573f, 0.02441742f, 0.00732317f, -0.03281614f, 
    -0.02114228f, 0.00624567f, 0.00510569f, 0.00299716f, -0.05310766f, -0.00863957f, -0.06163029f, -0.04055664f, 
    0.01587189f, 0.00427519f, -0.03181896f, -0.01525067f, 0.00462370f, 0.00424386f, 0.03498387f, -0.01269183f, 
    -0.04709207f, 0.01858590f, 0.05688460f, -0.03629084f, 0.04320480f, -0.01863070f, -0.00174325f, 0.02236131f, 
    0.01669288f, 0.51804650f, 0.01195675f, -0.00612334f, 0.12622124f, 0.00687452f, -0.01004021f, -0.04152710f, 
    -0.09420003f, -0.04566846f, -0.03375364f, -0.01253526f, -0.00024533f, 0.02435115f, 0.00287708f, 0.02645824f, 
    0.14181252f, 0.23529619f, 0.08098330f, 0.18112110f, 0.25092825f, -0.11997407f, -0.00187457f, 0.07407910f, 
    0.19413836f, -0.10628512f, -0.03599166f, 0.00022441f, -0.16273238f, 0.00359151f, 0.04661603f, -0.00010851f, 
    -0.01439884f, -0.09416312f, 0.02837143f, -0.03037887f, 0.03302523f, -0.01847893f, 0.23654406f, 0.14123936f, 
    -0.10271454f, 0.09277416f, -0.02572695f, -0.04490183f, 0.01773674f, -0.00547620f, -0.08732895f, -0.11368261f, 
    -0.17475164f, -0.11861906f, 0.11343443f, 0.16453619f, -0.09839669f, 0.06500543f, 0.07427133f, -0.08542711f, 
    -0.09779196f, 0.09810852f, -0.08936450f, -0.07751198f, -0.18721746f, -0.07402641f, 0.02883142f, -0.16704676f, 
    0.07699865f, 0.01317927f, -0.06787764f, 0.07026186f, -0.02094112f, 0.08297640f, -0.03812892f, -0.06607633f, 
    0.08477042f, 0.01257726f, 0.06829036f, 0.10224208f, 0.11973003f, -0.03480801f, 0.00763435f, 0.02367148f, 
    0.16483018f, -0.05220071f, 0.24519153f, 0.37986848f, -0.02885493f, 0.11918444f, -0.09542964f, 0.10710444f, 
    -0.01396532f, 0.03939997f, -0.04128692f, -0.01797472f, -0.08182921f, 0.10852993f, 0.04203232f, -0.01551336f, 
    0.06519871f, -0.22068983f, 0.12602961f, -0.01501957f, -0.19363657f, 0.17712477f, -0.05849213f, -0.09449640f, 
    -0.04813559f, 0.13559964f, -0.07844657f, 0.04234393f, -0.04043308f, -0.07139321f, -0.03304992f, 0.01923314f, 
    0.11298586f, -0.04266699f, 0.10815710f, -0.02434660f, -0.04723009f, -0.02277133f, 0.06227967f, -0.00746471f, 
    -0.06897782f, -0.00653961f, 0.20161495f, -0.11379617f, 0.08458089f, -0.04453934f, 0.10378442f, 0.01383209f, 
    0.03047772f, 0.03381978f, 0.00095470f, 0.03128696f, -0.13141429f, 0.14126699f, 0.06632883f, 0.08272558f, 
    0.00859248f, 0.00363677f, -0.09786654f, 0.12382212f, -0.10759956f, 0.02411658f, 0.08194071f, 0.05576577f, 
    0.06718517f, -0.11873438f, -0.17955357f, -0.19226310f, 0.02344552f, -0.03199309f, 0.01959316f, 0.03211655f, 
    -0.05830074f, 0.02161651f, 0.07662147f, 0.05840604f, -0.13911223f, 0.04111459f, 0.15299006f, -0.10794558f, 
    -0.06010970f, 0.13847001f, 0.09358768f, -0.14948307f, 0.10856621f, -0.01620308f, 0.00824686f, -0.06042138f, 
    -0.05749761f, -0.16613460f, -0.11403410f, 0.14685751f, 0.04301690f, -0.01092877f, 0.03568824f, -0.04355624f, 
    0.10003106f, 0.10335432f, 0.15054029f, 0.06526729f, 0.17725459f, 0.06176464f, -0.06308328f, 0.17665003f, 
    0.12075203f, 0.01657459f, 0.07333887f, 0.07669971f, 0.04585096f, -0.00871573f, 0.05460434f, -0.07123446f, 
    0.11887269f, -0.16366695f, 0.08643483f, 0.04038967f, -0.07061072f, -0.16798227f, -0.00773970f, -0.13110816f, 
    0.27357596f, 0.11636591f, -0.02027240f, -0.00741809f, -0.04391642f, -0.06069537f, -0.08118663f, 0.02134770f, 
    -0.08054590f, -0.05549141f, -0.12608345f, 0.01368750f, 0.12175927f, 0.06026357f, -0.07041200f, 0.05353659f, 
    0.12608665f, 0.05237601f, 0.03646000f, 0.08920480f, 0.24650995f, 0.01238954f, 0.08223936f, 0.20822309f, 
    -0.05212510f, -0.01454424f, -0.09938309f, 0.04257268f, 0.12847084f, 0.01825207f, -0.02132257f, -0.02450432f, 
    -0.02209506f, 0.12220787f, -0.07595207f, -0.01058818f, 0.00658421f, -0.21078202f, 0.05266245f, -0.08642707f, 
    0.05463443f, 0.21835384f, -0.10562892f, -0.01785196f, 0.15551560f, 0.09037384f, 0.01570842f, 0.06873013f, 
    -0.06921549f, -0.02565842f, -0.13629030f, -0.06747034f, -0.01290450f, -0.00529053f, -0.02084785f, -0.08815368f, 
    -0.07213460f, 0.01183831f, 0.00197016f, -0.19898757f, 0.19518276f, 0.06141799f, -0.09899730f, 0.04686714f, 
    -0.11010709f, 0.01528322f, 0.12169357f, -0.06353065f, 0.05903732f, -0.15326288f, 0.05819033f, 0.05016716f, 
    -0.02461534f, -0.03025776f, 0.03201389f, 0.10876483f, 0.08307523f, 0.05389376f, 0.11542213f, -0.02141673f, 
    -0.14085881f, 0.30410057f, -0.02032050f, 0.15666780f, -0.03397663f, 0.11174878f, -0.07614153f, 0.20125231f, 
    -0.08425370f, 0.13766739f, 0.04658737f, 0.02396969f, 0.04230907f, -0.01144892f, -0.05387661f, 0.01225252f, 
    0.15679982f, -0.15704769f, -0.10316355f, -0.00843186f, 0.24194841f, -0.20095840f, -0.04831175f, 0.05514706f, 
    -0.19318581f, -0.04572855f, -0.03421476f, -0.00239839f, 0.17556354f, -0.14382035f, -0.01568565f, -0.02993077f, 
    0.13694131f, 0.17627239f, 0.06097578f, 0.15832537f, 0.12896603f, -0.20498338f, -0.05236136f, -0.07671610f, 
    -0.02267056f, -0.03339367f, -0.01116776f, 0.01431132f, 0.01587105f, -0.04373436f, 0.00577454f, 0.04147936f, 
    0.02204571f, -0.03317814f, 0.03724745f, -0.04643439f, 0.04292313f, -0.00791265f, 0.00652025f, -0.02974018f, 
    0.03769777f, -0.02444066f, -0.04368601f, 0.03555869f, -0.03380684f, -0.01699546f, -0.00250674f, -0.02527467f, 
    0.01476566f, -0.02818480f, -0.03689748f, 0.03398843f, -0.04090510f, 0.02306051f, -0.01142638f, -0.00302192f, 
    -0.04711599f, 0.02963675f, -0.02735410f, -0.01548423f, -0.03351060f, 0.00825671f, -0.03205283f, -0.04619242f, 
    -0.03475174f, -0.00055904f, 0.01863135f, -0.04136310f, -0.03128842f, -0.01891985f, -0.05608318f, -0.01740226f, 
    -0.01076295f, 0.01879922f, -0.02370293f, -0.04577273f, 0.03162549f, 0.00651220f, -0.05539140f, -0.04623289f, 
    -0.01165269f, -0.02684663f, -0.01641281f, -0.02236163f, -0.05281923f, 0.02413246f, -0.04894909f, -0.03113115f, 
    -0.05924705f, 0.04251406f, -0.01198822f, 0.04248766f, -0.02438009f, 0.04533627f, 0.02478931f, -0.01499020f, 
    0.02171318f, 0.03130490f, -0.05020409f, 0.01608211f, 0.02087186f, 0.02897717f, -0.04921110f, -0.02533625f, 
    0.03921177f, -0.01546802f, -0.03379040f, 0.03173978f, -0.03330531f, -0.05299112f, -0.00440365f, -0.03350189f, 
    0.03544249f, -0.05490043f, 0.03735419f, -0.04279541f, 0.00838707f, -0.02833511f, -0.05248358f, 0.04701557f, 
    0.04412770f, 0.00791489f, 0.02612989f, -0.01473466f, 0.00998151f, 0.01391762f, -0.05043003f, -0.03167389f, 
    0.03785796f, -0.03064132f, 0.03537669f, -0.04004699f, 0.00403468f, -0.01709814f, 0.03116799f, -0.03345549f, 
    -0.00182134f, -0.05972657f, -0.03489838f, -0.00451851f, -0.05257317f, -0.04534783f, -0.03367854f, -0.02919764f, 
    -0.00154589f, 0.00785693f, -0.01378652f, 0.02134508f, 0.04010929f, 0.00390898f, 0.04697051f, -0.02490911f, 
    0.01642474f, 0.00505195f, -0.02593973f, -0.00340982f, 0.02184035f, -0.03083817f, -0.00526856f, -0.05550709f, 
    -0.04194444f, 0.04468122f, 0.01068974f, -0.02552828f, -0.00659722f, -0.04911514f, 0.02950317f, -0.00668590f, 
    -0.04907209f, -0.01540540f, -0.05310924f, -0.03653714f, -0.00401473f, -0.00107094f, -0.04463104f, -0.00258685f, 
    0.04492642f, 0.01558640f, 0.01334235f, 0.01129618f, 0.03481452f, -0.03000201f, 0.01975726f, 0.04695302f, 
    -0.06071765f, -0.03415532f, 0.04812687f, 0.01815933f, -0.01172271f, -0.04405923f, 0.03009479f, 0.03553016f, 
    -0.03869494f, -0.04047883f, -0.04944727f, 0.02821519f, 0.03054898f, -0.01928892f, -0.03912450f, -0.03979718f, 
    -0.03482847f, 0.03227223f, -0.02734906f, 0.02297626f, -0.02116330f, 0.01190127f, -0.00474309f, 0.00182304f, 
    0.01736775f, 0.00571654f, -0.02760047f, 0.01204063f, -0.04979698f, 0.04262874f, -0.04946555f, 0.00946720f, 
    0.01169956f, 0.03156908f, 0.01349986f, 0.02289380f, -0.02906086f, -0.00068276f, 0.04268976f, 0.00222523f, 
    -0.03273115f, -0.04139442f, 0.03762007f, -0.04744120f, 0.03585323f, -0.00254788f, -0.02568841f, 0.01282397f, 
    -0.05576601f, -0.03947331f, 0.01036119f, 0.03530360f, -0.04652788f, -0.05231743f, 0.01749702f, 0.01811931f, 
    0.03137156f, -0.05567493f, -0.03082023f, -0.01607764f, 0.02922642f, -0.03379726f, -0.02130988f, -0.04476845f, 
    -0.05109977f, -0.05745829f, -0.03385666f, -0.03874216f, -0.02495524f, -0.04150817f, -0.01406134f, -0.02872509f, 
    0.01709946f, -0.01363951f, -0.02695557f, -0.02784055f, 0.01856002f, 0.01753182f, 0.03833101f, -0.03846932f, 
    0.02506009f, -0.00846867f, -0.05343321f, -0.03341514f, 0.04159387f, 0.00026187f, -0.06087809f, -0.04138391f, 
    0.00816069f, 0.00222050f, -0.05497450f, -0.06187499f, -0.01134419f, 0.00556823f, 0.02226399f, -0.04150466f, 
    0.04908906f, -0.05945350f, 0.03653317f, 0.03488253f, -0.00206196f, 0.01989201f, 0.03155123f, 0.01929208f, 
    -0.01716985f, 0.00545577f, -0.04631041f, 0.00663961f, 0.00521509f, -0.04740930f, 0.00524914f, 0.00228129f, 
    -0.05818943f, 0.04510720f, -0.05369795f, -0.00633278f, -0.00433034f, 0.02561200f, -0.00286270f, 0.04042332f, 
    -0.06092297f, -0.01228878f, -0.02558770f, -0.04196519f, 0.01425035f, -0.02357080f, -0.00793936f, -0.02200017f, 
    -0.04944030f, -0.05146468f, 0.02748645f, 0.04979961f, 0.02632381f, 0.03548112f, 0.01911042f, 0.04024037f, 
    -0.03330186f, -0.03377858f, 0.02218143f, 0.00753324f, 0.02946304f, -0.03266350f, -0.00651538f, -0.05244382f, 
    -0.02049889f, -0.02594274f, 0.03219050f, 0.03401770f, 0.03138314f, 0.00468311f, -0.04614046f, 0.01942680f, 
    -0.05508488f, -0.03845536f, -0.00429628f, 0.01598116f, -0.01691972f, -0.00940583f, -0.02073489f, -0.03059331f, 
    0.24268632f, -0.32515237f, 0.13156374f, -0.08232716f, -0.11259528f, 0.16745456f, 0.13054767f, 0.08442199f, 
    0.00285359f, 0.03933664f, 0.00081349f, 0.02694603f, 0.02099201f, -0.04402661f, 0.03305772f, -0.08573671f, 
    -0.10532327f, -0.00321177f, 0.10235432f, -0.04634506f, -0.10601469f, 0.12666051f, -0.12688567f, 0.03177927f, 
    -0.17074141f, 0.00330893f, 0.05052972f, 0.04249977f, 0.10849032f, -0.02943165f, -0.08122205f, 0.04267246f, 
    0.02787198f, 0.05261450f, -0.05648094f, -0.00621078f, 0.05817980f, 0.00646329f, -0.08005120f, 0.00353920f, 
    0.35591727f, -0.08422484f, 0.08056787f, -0.06361798f, -0.18062675f, 0.02662863f, -0.05513826f, -0.03253116f, 
    0.02980169f, 0.11710735f, -0.00479240f, -0.11194328f, 0.06552385f, -0.03763881f, 0.03174030f, -0.00260609f, 
    0.01920321f, -0.00391829f, 0.01309534f, 0.00629321f, 0.24785006f, 0.05107598f, 0.16386190f, -0.01254928f, 
    -0.22396764f, 0.01887004f, 0.06957299f, -0.08088507f, 0.08961684f, -0.02220528f, 0.03760783f, 0.00723639f, 
    0.02234239f, 0.02465560f, -0.05414357f, 0.00114189f, 0.05396811f, -0.08715844f, 0.01693874f, 0.08591765f, 
    -0.15519044f, 0.15054870f, -0.05434688f, 0.03880330f, 0.13170493f, -0.07703109f, 0.02786729f, -0.00754056f, 
    0.04873494f, -0.08395603f, -0.06050495f, -0.09215676f, 0.07147815f, 0.03016327f, 0.02090162f, 0.05298170f, 
    0.02278662f, 0.03628055f, 0.05656501f, 0.00060279f, 0.23272672f, 0.09488793f, 0.03885875f, 0.05334447f, 
    -0.09494601f, -0.08496717f, 0.02146282f, -0.00487942f, 0.03761876f, 0.12353309f, -0.04210951f, 0.00629705f, 
    0.02887488f, 0.07757937f, 0.02659636f, -0.02074669f, -0.05920606f, 0.01379479f, -0.04644166f, 0.01349647f, 
    0.29711586f, 0.03461248f, 0.20775184f, 0.06931226f, -0.23400468f, -0.01923523f, -0.07143229f, 0.02376492f, 
    0.04692649f, -0.04307095f, 0.10476631f, -0.00463582f, -0.01456153f, 0.06022646f, -0.01396680f, 0.01755211f, 
    0.02963798f, -0.04410806f, -0.05200903f, -0.05062762f, -0.04031061f, -0.17988279f, 0.00289238f, -0.07379051f, 
    -0.19246474f, 0.02403890f, 0.05901536f, 0.08490641f, 0.03799141f, 0.01877206f, 0.02338022f, -0.01910254f, 
    0.06909203f, -0.00960975f, -0.12366787f, -0.06251624f, 0.03381439f, -0.12782240f, -0.08137268f, 0.08810887f, 
    0.16664298f, -0.21458602f, -0.10423366f, -0.02441831f, -0.16566767f, 0.06600354f, 0.04161428f, 0.02414854f, 
    0.05236981f, -0.02378872f, 0.03939695f, 0.04811016f, -0.08330212f, 0.11773813f, -0.07182804f, 0.14154263f, 
    -0.13612251f, -0.01913852f, -0.06594744f, -0.04640898f, -0.00262697f, -0.02673721f, 0.00877923f, -0.04480753f, 
    0.21804266f, 0.04740749f, -0.14584152f, -0.03194588f, 0.04078750f, -0.03766207f, -0.08430281f, 0.05427685f, 
    0.00748315f, -0.03842343f, 0.00133987f, 0.05782781f, -0.02868313f, -0.03813742f, -0.03434587f, 0.00911099f, 
    0.06565347f, 0.13709810f, -0.00567439f, 0.07079420f, -0.14906839f, -0.02841586f, -0.02536116f, 0.04805294f, 
    0.04837920f, -0.01758030f, 0.06256735f, 0.03676776f, -0.03640994f, 0.07957999f, 0.10855044f, -0.06254501f, 
    -0.05948589f, -0.03753789f, -0.07055195f, -0.06787550f, 0.07545110f, 0.33525306f, -0.11674243f, -0.13859601f, 
    -0.03281499f, 0.11673437f, 0.00238389f, -0.09420928f, -0.02881442f, 0.00209048f, 0.00198787f, -0.06003966f, 
    0.00745817f, -0.11382929f, -0.02041824f, -0.00726599f, -0.07376228f, 0.03332326f, 0.00795455f, -0.02058694f, 
    0.09534291f, 0.04754491f, -0.10322496f, -0.05236933f, 0.03185826f, 0.01150278f, 0.03175028f, -0.05142467f, 
    0.03784249f, -0.08449043f, -0.03130764f, 0.10064969f, -0.01913328f, -0.01493045f, -0.07236370f, -0.04944871f, 
    0.07783720f, -0.03678421f, -0.02437134f, 0.07230783f, -0.06717578f, -0.01473963f, -0.18345547f, 0.01916071f, 
    0.26390857f, 0.01008794f, -0.12167454f, -0.03631081f, 0.03934692f, 0.07131569f, 0.01755795f, -0.07193010f, 
    0.02930455f, -0.02990849f, 0.02730112f, 0.01794434f, -0.06608205f, 0.00540144f, -0.00969729f, 0.05909223f, 
    0.03687403f, 0.07183766f, -0.03835143f, -0.10714608f, -0.04266584f, -0.00969823f, -0.04793628f, -0.02519619f, 
    0.01822070f, -0.04540175f, -0.05150116f, -0.01165737f, -0.02822548f, -0.01309095f, 0.09906527f, -0.09851284f, 
    0.02670457f, 0.01323524f, -0.09643827f, 0.09993932f, 0.17548348f, 0.00665271f, 0.21336506f, -0.05547652f, 
    0.16576634f, -0.13244079f, -0.03837388f, 0.02104343f, 0.00820665f, 0.10470004f, 0.03323366f, 0.06941011f, 
    0.02505588f, -0.03509933f, -0.00653105f, 0.07043814f, -0.10142498f, -0.00277993f, 0.02526472f, 0.02868382f, 
    -0.15111893f, -0.08357359f, -0.15120921f, 0.03893122f, -0.27923834f, 0.00321334f, -0.03524878f, 0.08437195f, 
    -0.06408042f, 0.04724368f, -0.00001103f, -0.08446689f, 0.03160957f, 0.05905697f, -0.01105608f, -0.04644207f, 
    -0.01301315f, 0.04815355f, 0.10262357f, 0.03022255f, 0.30074188f, -0.06457534f, 0.07986084f, -0.04923037f, 
    -0.11928215f, 0.17261016f, 0.02600121f, -0.03707644f, -0.02044286f, 0.01733427f, 0.02522106f, 0.10384495f, 
    -0.04601408f, 0.09117277f, -0.02613480f, 0.02969040f, 0.00020352f, -0.02390159f, 0.00868271f, 0.07306861f, 
    -0.12748270f, -0.09438481f, 0.00160093f, -0.10032526f, -0.03514959f, -0.06963953f, 0.01681427f, -0.03986577f, 
    0.03179829f, -0.02941433f, 0.08074809f, -0.01013425f, -0.04221475f, -0.03796276f, 0.00236136f, -0.06975473f, 
    0.06631609f, -0.02981880f, 0.10248200f, 0.02564299f, -0.06518654f, 0.02211315f, -0.06893833f, -0.01937789f, 
    0.24833950f, -0.11413658f, -0.09043112f, -0.01786678f, 0.10437367f, 0.10919474f, -0.03053020f, -0.09106852f, 
    -0.11785769f, -0.06153635f, 0.09419757f, 0.04423307f, -0.05803850f, -0.02419518f, 0.03931685f, -0.04575717f, 
    0.14850613f, 0.06141263f, -0.16370437f, -0.00530330f, -0.15625101f, 0.05666316f, 0.03920402f, 0.09519046f, 
    0.07549381f, -0.02741622f, 0.08754876f, 0.04028472f, -0.05361451f, -0.01731036f, 0.08274202f, -0.03550908f, 
    0.12045787f, 0.08071667f, 0.06409892f, 0.01607848f, 0.01221624f, -0.05645630f, -0.00476005f, -0.11053812f, 
    0.18058164f, 0.02325614f, 0.04508511f, 0.00874842f, 0.03830406f, 0.00612341f, 0.00168024f, -0.01207618f, 
    0.00978461f, 0.10287125f, 0.06994256f, -0.05367653f, 0.07768624f, 0.09571800f, 0.13632897f, 0.07217894f, 
    -0.07586440f, -0.02928638f, -0.05964360f, -0.14202425f, 0.24190485f, -0.07261772f, 0.02136275f, -0.05732762f, 
    0.04864300f, 0.06978528f, 0.06983329f, -0.03498137f, 0.05040464f, 0.14157076f, 0.00981252f, 0.03748371f, 
    -0.04572917f, 0.05063181f, -0.01250777f, 0.00814760f, 0.07032332f, -0.01333599f, -0.03460077f, -0.06962104f, 
    -0.04969559f, 0.06744362f, 0.10375354f, -0.03044191f, 0.03421301f, -0.00584605f, 0.06250726f, 0.06520549f, 
    0.03675722f, 0.05267566f, 0.03913461f, -0.02279704f, -0.03819747f, -0.04742152f, 0.05432147f, -0.02415966f, 
    0.08118232f, 0.05150633f, -0.03808928f, -0.03118992f, -0.13674435f, -0.10151204f, 0.08862724f, -0.05914582f, 
    0.10060103f, 0.03717398f, -0.11218658f, 0.08321716f, -0.00901444f, -0.00827864f, 0.10603260f, -0.02130976f, 
    0.00190346f, -0.00155794f, 0.04105224f, 0.05594928f, -0.51344508f, 0.12836015f, 0.21709292f, 0.07050058f, 
    -0.06730567f, 0.18555388f, 0.21652600f, 0.02288204f, 0.01705228f, 0.03898145f, 0.02227898f, -0.03836701f, 
    0.04819464f, 0.04974600f, 0.01122709f, 0.03625430f, 0.06078164f, 0.04618009f, 0.02826666f, -0.04374550f, 
    -0.11827915f, -0.23480508f, -0.09438393f, 0.00659759f, 0.03104367f, 0.09648687f, 0.00173179f, -0.11520764f, 
    0.07875995f, 0.14592063f, 0.03216385f, 0.07541632f, -0.12760107f, -0.09199274f, 0.04969918f, 0.02071683f, 
    -0.10562199f, -0.00066761f, 0.02108414f, 0.03875581f, 0.38804141f, -0.06658410f, -0.12492272f, 0.23730713f, 
    0.04345499f, -0.05285075f, 0.00214977f, 0.07379619f, 0.04230398f, 0.04218223f, 0.03738146f, 0.03736521f, 
    0.00032602f, -0.05871316f, 0.03060415f, 0.07012566f, 0.04508578f, 0.15577213f, -0.02376659f, 0.06058438f, 
    -0.31256726f, -0.05556582f, 0.22204888f, 0.08128559f, -0.05415279f, -0.06655923f, 0.11131541f, 0.14978628f, 
    -0.05970067f, 0.08428796f, 0.02521662f, -0.06305988f, 0.03269628f, 0.06946542f, 0.10248760f, 0.06615450f, 
    0.04607179f, 0.01032025f, 0.07190958f, 0.05432225f, -0.22148372f, 0.07938644f, 0.29915556f, 0.05057714f, 
    -0.17232123f, 0.17704688f, 0.13584276f, 0.07603373f, -0.07037057f, -0.00635152f, -0.12134492f, 0.08326857f, 
    0.00651638f, -0.00248317f, 0.03810789f, -0.13001104f, -0.00229839f, -0.02678090f, -0.04852918f, 0.04499393f, 
    0.14164156f, -0.08400869f, -0.02934143f, 0.11214735f, 0.10720720f, -0.03600053f, 0.02760910f, 0.18228735f, 
    0.00590955f, -0.00443902f, -0.00368135f, -0.04488778f, 0.12781374f, 0.12850776f, -0.04460126f, -0.03735380f, 
    0.01398398f, 0.01149147f, 0.20630816f, -0.01992214f, 0.37586439f, 0.04098178f, -0.17478894f, -0.00380145f, 
    -0.06040041f, 0.06585077f, 0.00155661f, -0.05624092f, 0.18576035f, 0.02029883f, 0.15119392f, -0.01492503f, 
    -0.06148778f, -0.00049176f, 0.14310737f, 0.02852667f, -0.06099319f, 0.07749018f, 0.04320424f, -0.00860057f, 
    -0.03698536f, -0.02573525f, 0.00404448f, -0.01294542f, -0.01907278f, 0.00498312f, -0.06071790f, 0.01545822f, 
    -0.05012844f, 0.04486258f, -0.04090429f, -0.04703111f, 0.03549928f, -0.05369855f, -0.01011900f, -0.03177229f, 
    0.03913781f, -0.05306059f, -0.03190209f, -0.03696611f, 0.04106152f, -0.03823795f, -0.03518863f, 0.00143291f, 
    -0.03501061f, -0.05021045f, 0.00261996f, -0.05950473f, 0.01832701f, -0.03509583f, -0.01360948f, -0.01329647f, 
    0.02903560f, -0.05764191f, -0.03843128f, 0.01296845f, 0.00629596f, -0.02937301f, -0.02081235f, -0.01223255f, 
    -0.04629931f, -0.05269237f, -0.01550379f, 0.02666603f, -0.00499431f, -0.02978401f, 0.01596284f, -0.05538520f, 
    -0.03804492f, 0.00142056f, -0.05472706f, 0.03189658f, -0.03583389f, 0.02473186f, 0.00134369f, 0.02381963f, 
    0.03207225f, -0.01230288f, 0.04914825f, 0.00784457f, 0.00736335f, -0.04130660f, 0.03439804f, 0.00412200f, 
    0.00235200f, -0.05878347f, -0.00635023f, 0.02732623f, -0.01642917f, 0.04291658f, -0.01160695f, -0.00137647f, 
    -0.05870686f, -0.00634857f, 0.00673655f, 0.01004246f, -0.04045993f, 0.03786438f, -0.02157309f, -0.02920771f, 
    0.00618723f, 0.01892643f, 0.02752817f, -0.02379709f, -0.01945683f, 0.03359993f, -0.05857355f, -0.04962994f, 
    0.01146181f, -0.04221926f, -0.00351299f, -0.00095399f, 0.01799872f, 0.05092454f, -0.03964389f, -0.06832148f, 
    -0.03046472f, 0.03440000f, 0.04748570f, -0.02862541f, -0.02654154f, -0.05345589f, -0.03564626f, -0.01352854f, 
    -0.00133385f, -0.06242095f, -0.01612295f, -0.00970309f, 0.03567661f, -0.04352429f, 0.01828090f, 0.03330728f, 
    -0.05174498f, 0.04144572f, -0.03605137f, -0.05380794f, -0.06382065f, -0.01633123f, -0.03620815f, -0.04843504f, 
    -0.05313081f, 0.02612248f, 0.00997085f, -0.04557164f, -0.01368398f, 0.01361221f, 0.01747587f, -0.05157087f, 
    0.00305970f, -0.02150390f, 0.04025583f, 0.01325326f, -0.01769149f, 0.03242439f, -0.05992026f, 0.00594715f, 
    0.03597388f, -0.04349158f, 0.03881604f, -0.05217884f, 0.04036478f, -0.01484298f, 0.03963384f, 0.03563081f, 
    -0.00234678f, -0.02880794f, 0.02779566f, 0.03662018f, 0.04557242f, 0.01693307f, 0.03931814f, 0.00713613f, 
    0.01032798f, -0.01329551f, -0.04859263f, -0.05849569f, -0.03703719f, -0.00291845f, -0.04291663f, -0.02440058f, 
    0.03316942f, 0.02541075f, 0.02712333f, -0.04419525f, 0.03559161f, 0.04534065f, -0.01774776f, -0.01770630f, 
    -0.01227479f, 0.00744595f, 0.00074804f, 0.03950148f, 0.02240964f, -0.03210927f, -0.02892673f, 0.00309301f, 
    -0.05691503f, -0.01274062f, 0.04939323f, -0.01106738f, 0.00313460f, -0.02658516f, 0.03041432f, -0.02101786f, 
    -0.02831551f, 0.01882568f, -0.01042373f, 0.00592770f, 0.04698797f, 0.01445432f, 0.00578272f, -0.01894034f, 
    -0.04630034f, 0.04261781f, -0.03987445f, 0.04045971f, -0.05607664f, -0.04022774f, -0.01236688f, 0.00638196f, 
    -0.05597252f, 0.01867364f, 0.02731856f, -0.04634972f, -0.05585427f, 0.04215273f, 0.01591532f, 0.03227411f, 
    -0.03819443f, 0.01768586f, 0.00708214f, 0.00526370f, -0.04046890f, 0.04039610f, -0.02866697f, 0.00777568f, 
    0.03012137f, -0.04627494f, -0.04403212f, -0.05341941f, -0.03765956f, -0.05844965f, -0.02606658f, 0.00220421f, 
    -0.05782713f, -0.04250006f, -0.01909321f, 0.01003608f, 0.02162295f, 0.03042153f, 0.04364230f, 0.00885787f, 
    0.02329215f, 0.03884071f, -0.01066625f, -0.04741624f, 0.02502864f, 0.03716761f, -0.05472968f, -0.05316015f, 
    -0.02442440f, -0.00911927f, 0.02205055f, 0.01559335f, -0.06689789f, -0.01701234f, -0.00587640f, 0.00480578f, 
    -0.03751866f, -0.01738205f, 0.00431863f, 0.02097020f, 0.02511584f, 0.02865999f, -0.04752506f, 0.02982149f, 
    0.01204330f, -0.00915751f, 0.01803954f, 0.02610516f, 0.04370512f, 0.04085473f, 0.04418404f, -0.01559727f, 
    0.02266723f, 0.03997231f, -0.01347288f, 0.02856357f, -0.06608190f, 0.01031508f, 0.00845378f, 0.02494191f, 
    -0.01581800f, -0.05433204f, -0.01704760f, 0.03221845f, 0.03873891f, -0.02623937f, -0.02220050f, 0.03569517f, 
    -0.01034843f, -0.01425965f, 0.01522597f, -0.04273818f, 0.01849648f, -0.02464610f, 0.03041879f, 0.02600969f, 
    -0.01952756f, -0.05673305f, 0.01383602f, 0.03507170f, 0.00232196f, -0.03425796f, -0.03351798f, -0.05846722f, 
    0.01646591f, -0.02383911f, -0.04455454f, -0.03194122f, -0.00210685f, 0.04730076f, -0.03420568f, 0.03020782f, 
    -0.03282434f, -0.04538343f, 0.01537404f, 0.02351712f, -0.00645316f, -0.04343657f, -0.03486624f, -0.03057930f, 
    -0.03690827f, -0.05626218f, 0.00616862f, -0.05501996f, 0.02423138f, 0.03320746f, 0.02254303f, -0.00291862f, 
    -0.33104417f, 0.16210377f, -0.09815435f, -0.09876677f, -0.26170737f, 0.04118224f, -0.10225534f, -0.03306500f, 
    0.08799465f, -0.12007872f, 0.06787419f, 0.04169318f, -0.04305977f, 0.10907502f, 0.03527988f, -0.06796137f, 
    0.05844282f, -0.15503705f, -0.06192829f, 0.10225270f, 0.06993613f, 0.03519440f, 0.13426416f, -0.13575421f, 
    0.03853283f, 0.10331295f, 0.05020398f, 0.00309500f, 0.05008845f, -0.09180303f, 0.06933589f, 0.05747943f, 
    0.05069778f, 0.03579405f, 0.04077479f, 0.05998468f, -0.01483122f, 0.05948026f, -0.19174175f, 0.07891087f, 
    -0.03042063f, 0.05616131f, 0.01116676f, -0.02031772f, -0.01604332f, -0.05613597f, 0.03018822f, 0.04609370f, 
    -0.07156065f, -0.01728330f, 0.11451634f, 0.08499691f, 0.04587136f, 0.05966242f, -0.07758680f, -0.01554948f, 
    -0.01150776f, -0.12649143f, 0.03575003f, 0.04231278f, -0.02876668f, 0.00480968f, 0.14128275f, 0.03937676f, 
    0.21644916f, -0.04614987f, -0.07442790f, 0.03874322f, -0.05527190f, 0.01152431f, -0.07345728f, -0.04156034f, 
    -0.10360199f, -0.02902453f, 0.06676035f, -0.07474519f, -0.08118807f, -0.01651568f, -0.02597896f, 0.05004228f, 
    0.01600146f, 0.05491598f, -0.14907734f, -0.02476968f, 0.04005107f, -0.01264431f, 0.07581737f, -0.05653959f, 
    -0.05402506f, 0.05989281f, -0.03194911f, 0.11956509f, 0.05838163f, 0.01167798f, 0.08002821f, -0.04520344f, 
    -0.00390600f, 0.03594184f, -0.05661160f, 0.04865306f, -0.12667847f, 0.03931164f, 0.14541176f, 0.02228256f, 
    0.25648963f, 0.00763605f, -0.03341036f, 0.05627304f, 0.03715663f, -0.06165837f, 0.01068005f, -0.01930932f, 
    -0.00757491f, -0.01237929f, 0.03563430f, -0.05088446f, 0.10280916f, -0.02446558f, 0.02714595f, 0.01449846f, 
    -0.04708694f, -0.03297019f, 0.04157328f, -0.08893251f, 0.13468511f, -0.04440859f, 0.06714875f, 0.02113932f, 
    -0.08259124f, 0.11419017f, 0.04011128f, -0.09666868f, 0.00299214f, -0.03132293f, -0.03062310f, 0.02172119f, 
    -0.03038454f, -0.11081685f, -0.01454882f, -0.02736445f, 0.05743657f, 0.02077512f, -0.13457881f, -0.11812667f, 
    0.02618670f, 0.01447054f, -0.03599670f, 0.08636945f, 0.05392154f, 0.04642281f, 0.03063111f, 0.09681495f, 
    0.05032990f, 0.09871911f, 0.10190793f, 0.04871473f, 0.06498460f, -0.04714143f, -0.01160775f, -0.01056753f, 
    -0.01167526f, -0.00865644f, -0.08944318f, -0.08929107f, -0.08405190f, 0.02781013f, 0.01420025f, -0.03559712f, 
    0.02686907f, 0.04679859f, 0.03227795f, -0.04800745f, 0.04740971f, 0.03780086f, -0.01772330f, -0.13565315f, 
    0.09388457f, -0.01268897f, -0.10517460f, -0.04962214f, 0.11537480f, 0.02237486f, -0.05912099f, 0.02995570f, 
    0.02320745f, 0.30927870f, 0.20958251f, -0.01640351f, -0.15414587f, 0.04849396f, 0.02517421f, 0.01592623f, 
    -0.03603175f, 0.11392901f, 0.00450698f, 0.11405285f, 0.05312343f, 0.06043667f, 0.08484956f, -0.05202951f, 
    -0.14631070f, -0.15495510f, 0.02998224f, -0.20474672f, 0.05564265f, 0.06857438f, -0.03933962f, -0.01601845f, 
    0.04660913f, -0.01218582f, 0.03072056f, 0.06359422f, 0.01283730f, -0.17452621f, -0.03482625f, 0.05226383f, 
    0.14298514f, 0.00000134f, -0.04016586f, -0.00211718f, -0.01354701f, -0.04635231f, -0.05201946f, 0.27826962f, 
    0.07170820f, -0.09255305f, 0.06445417f, 0.01542825f, -0.01538308f, -0.04193605f, -0.11659463f, -0.00502025f, 
    0.04095398f, 0.00324440f, 0.02673684f, 0.04289930f, 0.00123290f, 0.03826470f, -0.10346980f, 0.08802305f, 
    -0.13380072f, -0.05099656f, -0.00374465f, -0.07936021f, 0.06908889f, -0.02466553f, 0.01285862f, 0.07164849f, 
    -0.02754361f, 0.06887785f, 0.04744060f, 0.03217558f, -0.01434366f, 0.00761936f, 0.07763001f, 0.06494988f, 
    0.06901915f, 0.13757174f, -0.00709271f, 0.09934575f, -0.21037187f, -0.04818077f, 0.16395219f, 0.01617221f, 
    -0.13804765f, 0.13448697f, 0.12267610f, -0.04804990f, -0.00625239f, -0.01178268f, 0.08756062f, 0.05004675f, 
    0.13053185f, 0.02279464f, 0.12255648f, -0.16086069f, 0.01674986f, 0.01402392f, -0.02092907f, -0.07761430f, 
    -0.05952052f, 0.21229251f, 0.01129340f, 0.14102694f, 0.03086434f, 0.00263660f, 0.01063830f, 0.06699335f, 
    0.03426583f, 0.01157451f, 0.09384528f, -0.00148203f, 0.04435600f, 0.05938603f, 0.06940336f, 0.03469722f, 
    0.01014876f, 0.01892422f, 0.16207179f, 0.09691858f, 0.12116363f, 0.01254085f, -0.25853023f, -0.01861501f, 
    0.07374385f, 0.06271640f, 0.12040701f, -0.08942847f, 0.00682417f, -0.10911071f, 0.07489435f, -0.04469642f, 
    -0.18868652f, -0.07990905f, 0.10468584f, -0.06377924f, -0.02501734f, 0.04969354f, 0.00083946f, -0.06613613f, 
    -0.02844172f, -0.00088868f, -0.02531222f, 0.02490486f, 0.01507696f, 0.03495595f, -0.00627978f, -0.02519978f, 
    -0.04441418f, -0.03761949f, 0.00983563f, -0.04600893f, -0.06105882f, 0.04438452f, -0.01027826f, -0.04648227f, 
    0.01746766f, -0.00554873f, 0.00483143f, -0.03623008f, -0.05080652f, -0.02121169f, 0.02366181f, 0.03098871f, 
    -0.00412383f, 0.03298575f, -0.02745958f, 0.02315960f, -0.03023014f, 0.04321636f, -0.03960674f, -0.05227761f, 
    -0.05167588f, -0.05244011f, -0.01521695f, 0.04904154f, -0.04376490f, 0.02476730f, 0.01019509f, -0.00940915f, 
    -0.05018338f, -0.05211824f, -0.00450413f, 0.01923407f, 0.01489013f, -0.03696708f, 0.02526196f, -0.02300230f, 
    0.04524337f, -0.04113698f, -0.05777071f, 0.04007746f, 0.04606321f, 0.01340247f, -0.04424055f, -0.05153194f, 
    0.01462266f, 0.04867591f, 0.01436610f, -0.02661323f, 0.00369228f, -0.02471522f, -0.03043453f, -0.02226668f, 
    -0.01285166f, -0.05948886f, 0.02083746f, -0.03518926f, -0.02980084f, -0.00613697f, 0.04171465f, -0.02455755f, 
    -0.05324484f, -0.00941451f, 0.01009191f, 0.01783706f, 0.00917336f, 0.02098348f, -0.01046796f, -0.05981349f, 
    -0.00753851f, -0.00042893f, 0.01942455f, 0.02569229f, 0.04104600f, -0.05428671f, -0.01781960f, -0.00827341f, 
    -0.00051253f, 0.04431130f, -0.04600521f, -0.05464603f, 0.00374272f, 0.03322290f, 0.02405657f, 0.01893692f, 
    0.03912295f, -0.00649951f, -0.05055306f, -0.01592285f, -0.04555277f, -0.00623700f, -0.03120006f, -0.05701182f, 
    -0.03546423f, -0.03730284f, -0.02451922f, -0.01067485f, 0.00863652f, -0.00584609f, -0.00418033f, -0.00492530f, 
    -0.00371399f, -0.05040752f, -0.00982757f, -0.00093546f, 0.04162879f, -0.04631953f, 0.01231776f, 0.01024261f, 
    0.04669679f, 0.01244428f, 0.01888884f, -0.05475484f, 0.04504631f, 0.03450744f, -0.03954791f, -0.05584874f, 
    -0.02660619f, 0.00330981f, 0.04830100f, 0.02121316f, 0.02931317f, -0.03780881f, 0.04240882f, 0.03726076f, 
    -0.03696758f, -0.03169399f, -0.02718835f, 0.00928153f, -0.01108750f, 0.02879281f, -0.01881468f, -0.02337277f, 
    -0.01938290f, -0.01690862f, -0.04496082f, -0.05255599f, -0.00691981f, -0.02760279f, 0.02684083f, -0.01492412f, 
    -0.01269905f, -0.02769765f, -0.00037216f, -0.04670734f, -0.04651789f, 0.01082667f, -0.02625579f, -0.03659872f, 
    -0.03464840f, -0.01882221f, 0.01086114f, 0.00488225f, -0.01429821f, -0.01633754f, 0.00454432f, 0.03343409f, 
    -0.03490437f, 0.01848001f, 0.00786456f, 0.02098997f, -0.02059312f, -0.02224093f, -0.03656311f, 0.02550191f, 
    0.00184487f, -0.00417999f, -0.04774747f, 0.02725654f, -0.01458681f, 0.01925366f, -0.02967482f, -0.05116170f, 
    -0.03476288f, -0.03057547f, 0.02220008f, 0.04564182f, 0.00195114f, 0.01407022f, 0.03155381f, -0.00761145f, 
    -0.01900687f, -0.00378319f, -0.04835482f, -0.04127985f, -0.02121841f, 0.00317470f, 0.02873610f, -0.02748116f, 
    -0.02947300f, -0.00949856f, 0.02552022f, 0.04405024f, 0.01203357f, -0.02069801f, 0.03369266f, 0.01389941f, 
    -0.01409679f, -0.01052993f, 0.01169981f, 0.01030057f, -0.04250331f, -0.02992208f, 0.00466465f, -0.05710729f, 
    0.00249016f, -0.05001863f, 0.02894299f, 0.04144661f, 0.03587737f, -0.04792980f, -0.01529586f, 0.02537254f, 
    0.01658034f, -0.00934624f, -0.05230362f, 0.02261304f, -0.05959459f, 0.00524642f, -0.04757097f, -0.03208778f, 
    -0.01856795f, 0.02492144f, -0.04302510f, -0.02703155f, -0.00516488f, -0.04264756f, -0.03611759f, -0.03308463f, 
    -0.06089829f, 0.02072498f, -0.06025216f, 0.00070377f, -0.00822011f, -0.00231940f, -0.01239164f, -0.05606565f, 
    -0.03391500f, 0.02577876f, -0.01516702f, -0.01043544f, -0.06029890f, -0.03737361f, -0.05559225f, -0.04962587f, 
    0.01073686f, 0.01765824f, -0.01190982f, -0.00687931f, 0.01713582f, -0.05481274f, -0.01343047f, -0.00562639f, 
    0.01427529f, 0.03910175f, -0.03148150f, -0.01388327f, -0.03641878f, -0.01032113f, -0.02504347f, 0.04242734f, 
    0.04032023f, -0.00215561f, 0.01187569f, 0.00613551f, 0.04779486f, 0.00348557f, -0.00238509f, -0.01510665f, 
    -0.01538819f, -0.04588796f, 0.02957587f, -0.02781708f, 0.03815647f, -0.00199285f, 0.00589458f, -0.00336504f, 
    0.03128892f, 0.04248125f, -0.01224754f, -0.03098812f, -0.05285516f, -0.01468842f, -0.04856164f, 0.02900888f, 
    0.04363716f, 0.04743752f, -0.05442662f, -0.04591187f, -0.04779660f, -0.03836683f, 0.00995503f, 0.04273671f, 
    0.04141034f, 0.04040690f, -0.05712154f, -0.01895011f, 0.00366185f, -0.00371186f, 0.00116222f, 0.02768120f, 
    -0.03620590f, -0.04290363f, -0.01513877f, -0.05035868f, 0.04855597f, -0.02951383f, -0.01056772f, 0.00804130f, 
    -0.17819573f, -0.04902160f, -0.16263378f, 0.04882406f, -0.21331294f, 0.11068720f, -0.12809254f, -0.03241383f, 
    0.05463394f, -0.09228233f, -0.08264523f, 0.01527918f, -0.02998917f, 0.11400436f, 0.12693937f, 0.04427404f, 
    0.06714100f, 0.09895454f, 0.00376512f, -0.02525710f, -0.00255852f, -0.16354519f, -0.07609820f, -0.00778279f, 
    0.02575859f, -0.08022057f, -0.00165219f, 0.06919268f, -0.00577434f, 0.06999647f, 0.11159580f, -0.00123405f, 
    0.04031545f, 0.00048253f, -0.01261441f, 0.08447402f, -0.01684994f, 0.02919129f, 0.10636536f, 0.04390706f, 
    -0.06688082f, -0.08372938f, -0.08156139f, 0.13987745f, 0.14836848f, 0.08080142f, 0.08205380f, 0.06689008f, 
    -0.02649306f, -0.09340897f, 0.01127747f, 0.05223064f, -0.08316141f, -0.05452162f, -0.08311450f, -0.02184383f, 
    -0.02092120f, 0.08923273f, 0.06789336f, 0.11143510f, -0.14931378f, 0.03156726f, -0.07758872f, 0.16489151f, 
    0.01328899f, 0.22264893f, 0.09147101f, 0.01942849f, 0.00477095f, 0.10999055f, -0.01195374f, -0.08288069f, 
    0.04124520f, 0.13108297f, -0.01272982f, 0.03434300f, 0.04307966f, 0.02281399f, -0.02425242f, -0.02468222f, 
    0.22018756f, 0.07796547f, 0.00885029f, -0.05543918f, 0.05396950f, -0.03315328f, 0.02426134f, -0.02508122f, 
    0.03230277f, 0.05770646f, 0.06578360f, 0.00311056f, 0.02153805f, 0.02651531f, 0.02154770f, -0.01452243f, 
    -0.01807617f, -0.02099263f, 0.03104347f, 0.00590980f, -0.24165428f, 0.12832305f, -0.16406745f, 0.11949550f, 
    0.06574861f, 0.18351887f, 0.13548231f, 0.05004494f, 0.09826066f, 0.18429434f, -0.08201756f, -0.12707008f, 
    0.09929660f, -0.01336802f, 0.03151148f, 0.07181405f, -0.04047401f, -0.02784515f, 0.03334101f, -0.05742791f, 
    -0.24125119f, -0.15587382f, 0.05228300f, 0.10646100f, -0.04066187f, 0.10818420f, 0.01378839f, 0.01656982f, 
    0.03730812f, 0.13577302f, -0.12112541f, -0.02073807f, -0.08914617f, 0.11127017f, -0.01830499f, -0.08591697f, 
    -0.03572049f, 0.15060952f, 0.05460703f, 0.00194924f, -0.01411531f, -0.10250369f, -0.05645516f, 0.04075479f, 
    0.07482878f, -0.10408791f, 0.05296560f, -0.00519660f, 0.05501758f, -0.03542831f, 0.04300185f, -0.02604889f, 
    -0.00394220f, -0.05222232f, -0.02873437f, 0.04972556f, 0.02388028f, 0.03228179f, 0.10374826f, 0.04548543f, 
    -0.11931679f, -0.20025775f, -0.10060460f, -0.04669469f, -0.08994400f, 0.03117187f, -0.03777012f, 0.02663755f, 
    0.00331172f, 0.00222602f, 0.02646589f, -0.05757275f, -0.02758383f, 0.00694317f, -0.10197413f, -0.01991775f, 
    0.10910472f, 0.05707946f, 0.08704931f, 0.05168882f, 0.48240346f, 0.11696922f, 0.24900156f, -0.04424176f, 
    -0.03326166f, 0.08290765f, 0.00979257f, 0.02753245f, -0.07706271f, 0.08192336f, 0.08696708f, 0.03405908f, 
    0.03200520f, -0.01929165f, 0.06191646f, 0.07344911f, 0.07581989f, -0.00403476f, 0.01666303f, -0.00611285f, 
    0.04298628f, -0.20859818f, -0.09904230f, 0.08679620f, 0.07080586f, 0.08371958f, -0.10523496f, -0.01354989f, 
    0.03251190f, -0.02562381f, -0.00012504f, -0.10179579f, 0.12492832f, 0.02196328f, 0.04626426f, 0.06746908f, 
    0.04190486f, 0.00722627f, 0.00729057f, -0.03811633f, 0.30689898f, -0.16119348f, 0.00278510f, 0.04073259f, 
    0.05733726f, 0.14724460f, 0.07826400f, 0.09851207f, 0.07024138f, 0.02948508f, -0.01886568f, -0.07796317f, 
    0.16955186f, -0.01531495f, 0.02635390f, -0.02369497f, -0.02259116f, 0.00102877f, -0.07243880f, -0.02451596f, 
    0.08980867f, -0.08435387f, 0.08191785f, -0.09109994f, -0.07741760f, -0.00029327f, -0.00601322f, 0.02081014f, 
    -0.07663258f, -0.03329741f, 0.01488622f, -0.00654898f, -0.02062539f, -0.02058166f, 0.03488959f, -0.07537125f, 
    0.03242292f, -0.02703769f, 0.06878625f, 0.05212525f, 0.06239339f, -0.04171899f, 0.33658478f, -0.09868735f, 
    -0.13241920f, -0.14934421f, 0.08883621f, -0.07827470f, -0.08566114f, -0.02372015f, 0.03112573f, 0.06357305f, 
    0.00165127f, -0.00474873f, 0.08933001f, 0.06125755f, 0.12635095f, 0.03264557f, -0.09800094f, -0.01709006f, 
    -0.17490558f, 0.17191941f, -0.20398942f, 0.14866224f, -0.00756828f, 0.05129204f, 0.06202921f, -0.07421653f, 
    0.05597301f, 0.10276278f, -0.00061649f, -0.10540298f, -0.04473613f, -0.01153255f, -0.06023894f, 0.03291316f, 
    0.00197387f, 0.08723979f, -0.04400862f, 0.01466699f, -0.16164877f, 0.07783511f, -0.10041349f, -0.18694079f, 
    0.14021677f, 0.04233046f, 0.05773496f, 0.07825506f, -0.08209488f, 0.05545558f, -0.07351515f, 0.06263062f, 
    -0.04340642f, 0.04541015f, -0.01178688f, 0.00524409f, -0.00575148f, -0.11881910f, -0.07689915f, -0.07306165f, 
    0.10443604f, 0.41573894f, -0.27404413f, -0.04001545f, -0.10977255f, -0.09521089f, 0.07585014f, 0.05080398f, 
    0.03546111f, 0.00875829f, -0.11238642f, 0.03407748f, -0.01335239f, -0.03477396f, -0.02843251f, 0.06341249f, 
    0.03071812f, 0.11462874f, 0.07995908f, 0.11796917f, -0.04307396f, -0.18314783f, 0.13628523f, -0.05991450f, 
    0.07530542f, 0.02071167f, -0.00552806f, 0.08848406f, -0.19598548f, -0.00152893f, -0.01136672f, 0.13957214f, 
    -0.09300365f, -0.01738741f, -0.16296561f, -0.03127604f, -0.01307370f, 0.03256544f, 0.07043531f, -0.02885398f, 
    -0.01324933f, 0.15425751f, 0.28222823f, 0.09325550f, 0.19419222f, 0.11316815f, 0.11455973f, 0.03151945f, 
    0.07810047f, 0.04820842f, 0.08712180f, 0.11687572f, -0.04841878f, 0.06131922f, -0.04483189f, 0.02291597f, 
    -0.06010450f, -0.02911209f, -0.09163652f, 0.01483198f, -0.30932000f, -0.25033861f, -0.02047211f, 0.17990385f, 
    0.22687460f, -0.00687798f, -0.11949395f, -0.05419834f, -0.06705626f, 0.21186572f, -0.03520228f, 0.09942803f, 
    0.07314483f, 0.15428446f, 0.09294594f, 0.16214806f, 0.07762775f, 0.12253553f, 0.06970225f, -0.00219331f, 
    0.15714471f, -0.03165912f, 0.24530351f, -0.18493031f, 0.06481648f, 0.03890159f, -0.09198673f, 0.15234622f, 
    -0.01981015f, -0.00849116f, -0.09365361f, -0.09142648f, -0.10900527f, -0.00433258f, -0.07802120f, 0.04302160f, 
    0.03720561f, -0.15302767f, -0.06324334f, -0.07587047f, -0.03623402f, -0.07084849f, 0.17150360f, 0.16823263f, 
    0.15264693f, -0.06519098f, 0.02776103f, 0.01106939f, -0.04123444f, 0.16549392f, -0.06722228f, 0.04385305f, 
    0.09362198f, 0.07762778f, 0.02106353f, 0.08940833f, 0.03427194f, 0.02521466f, -0.02880828f, -0.12490584f, 
    -0.36475837f, -0.07305874f, 0.02388458f, 0.04566408f, 0.07693459f, -0.05974560f, -0.02833153f, -0.11689363f, 
    0.06890345f, 0.12858376f, 0.01485747f, 0.12685181f, 0.03169747f, 0.11479384f, 0.07645426f, -0.00306992f, 
    -0.03046533f, 0.14989191f, 0.17432252f, -0.05895470f, -0.04089854f, 0.02968984f, 0.28142324f, -0.05302708f, 
    0.06899826f, -0.03467736f, 0.13942698f, 0.06848202f, 0.04819914f, 0.01057754f, 0.04479276f, -0.04709469f, 
    -0.04271236f, -0.03820070f, 0.00278325f, 0.05019882f, 0.02223049f, -0.01246276f, 0.12592377f, -0.02038576f, 
    -0.10529546f, 0.02972370f, 0.07497135f, -0.23636228f, -0.13953815f, 0.02036197f, -0.02449262f, 0.06150322f, 
    -0.05550736f, 0.11065490f, 0.00837510f, -0.02605107f, 0.09982575f, 0.07933476f, 0.02008355f, 0.04331321f, 
    0.07221691f, 0.17005542f, 0.15759145f, 0.09520132f, -0.18035667f, 0.06743779f, 0.10763510f, 0.27146417f, 
    0.11875002f, -0.07500344f, -0.05270636f, -0.15966627f, 0.09704593f, 0.00388609f, 0.06788775f, -0.00267450f, 
    -0.03773864f, -0.17793620f, -0.13764125f, -0.10594286f, 0.03435798f, -0.09648652f, 0.04690269f, -0.09968258f, 
    0.04212373f, -0.07141665f, 0.06948042f, -0.00714139f, 0.07774919f, -0.05935408f, -0.14548278f, 0.07323690f, 
    0.02190492f, -0.02999973f, 0.14444102f, -0.05308107f, 0.04716066f, 0.01007876f, 0.08806116f, 0.08835956f, 
    -0.11644993f, 0.03185387f, 0.19054045f, -0.01409922f, 0.25123215f, -0.08191933f, 0.14640073f, 0.10668853f, 
    0.14084181f, 0.05483690f, -0.13143580f, 0.08626365f, -0.03040791f, 0.04386960f, 0.02257916f, -0.03584995f, 
    0.00860767f, 0.10448530f, -0.08640077f, 0.12982666f, 0.01488477f, -0.07844419f, 0.06930298f, -0.05645709f, 
    0.01424732f, -0.18547878f, -0.00126373f, 0.17323445f, -0.06989541f, -0.02258614f, -0.01243356f, -0.18244097f, 
    -0.19805160f, -0.17681085f, 0.01861192f, -0.02553828f, 0.02448198f, 0.06029163f, -0.09661856f, -0.10532567f, 
    0.07494552f, -0.05865258f, 0.05490964f, -0.04879777f, 0.07192074f, 0.01194036f, 0.08022376f, 0.11129462f, 
    0.00835429f, -0.09994844f, 0.17548655f, 0.04541361f, 0.11365879f, 0.06281210f, 0.05760784f, -0.05792844f, 
    0.00195781f, 0.00272294f, -0.09348862f, 0.10834048f, 0.15719256f, 0.09560230f, 0.10223174f, 0.06968551f, 
    0.41331688f, -0.20048647f, 0.10708171f, -0.11194882f, -0.18477218f, -0.07592653f, -0.07006502f, -0.15183201f, 
    -0.00560485f, 0.02476248f, -0.09386402f, -0.00591012f, -0.08251584f, 0.00208300f, -0.02254919f, 0.02013299f, 
    -0.09207243f, -0.08225698f, 0.07117399f, -0.23445790f, 0.23450826f, 0.03594568f, -0.38828531f, 0.10575406f, 
    0.19302960f, 0.00440711f, -0.12564145f, -0.00415578f, -0.01295954f, -0.02310942f, -0.08435696f, 0.05403418f, 
    -0.08048667f, 0.10882097f, 0.09062910f, 0.06045005f, 0.10682914f, -0.05289032f, -0.00590050f, -0.00680392f, 
    -0.11925248f, -0.10726788f, 0.26876006f, 0.10917458f, 0.11197259f, -0.04967443f, 0.00244527f, -0.03959804f, 
    0.06914774f, 0.00252285f, -0.06817216f, -0.06452089f, -0.03267870f, 0.01039321f, 0.01933707f, 0.02971441f, 
    -0.12837642f, -0.05749102f, -0.00543071f, -0.10074028f, -0.11236706f, 0.00270737f, -0.00867037f, 0.07828803f, 
    -0.15466951f, -0.01104639f, -0.06725173f, -0.07046576f, 0.07084460f, 0.01459976f, -0.01422208f, -0.05363209f, 
    0.09600751f, 0.08048008f, 0.08319166f, 0.06989510f, 0.04533428f, 0.10792573f, -0.15027915f, 0.08266726f, 
    -0.32163140f, -0.22250329f, -0.15747817f, -0.00106998f, -0.13954443f, 0.02535884f, -0.01971349f, 0.11867084f, 
    -0.03726812f, -0.01075183f, -0.05024285f, 0.04002325f, 0.07297336f, 0.09095278f, 0.05172611f, 0.10401202f, 
    0.02486031f, 0.05301049f, 0.05577214f, 0.07296719f, 0.06146596f, 0.20946959f, -0.07616361f, -0.16866677f, 
    -0.27081609f, 0.15589000f, 0.06980438f, 0.09768061f, -0.01500649f, -0.07684259f, -0.00732965f, 0.07153046f, 
    -0.05517168f, -0.03106136f, 0.01405838f, 0.01977925f, 0.05886075f, 0.01028087f, -0.03428936f, -0.00883934f, 
    0.10403848f, -0.09969356f, 0.11601481f, 0.11389314f, 0.06830609f, -0.03103109f, 0.06490747f, -0.16512299f, 
    0.06230444f, -0.00257675f, -0.06056588f, -0.02417137f, 0.14294267f, 0.06347887f, -0.05083447f, 0.00811762f, 
    -0.09816377f, 0.04797977f, 0.04743065f, 0.00510619f, -0.26950434f, 0.04093465f, -0.25743645f, -0.03703164f, 
    -0.20396399f, 0.04641325f, 0.05287695f, 0.08369265f, 0.03174476f, -0.03545525f, 0.00548675f, 0.02794796f, 
    -0.10401874f, -0.00525143f, 0.02962062f, 0.12080469f, -0.00978884f, 0.01558351f, -0.00662530f, 0.06940392f, 
    0.02385397f, 0.17270982f, 0.00512311f, -0.08388388f, -0.09765261f, 0.12839705f, -0.00120013f, 0.02920034f, 
    0.05218974f, -0.01385418f, -0.08813157f, 0.03560841f, 0.04515083f, -0.09177744f, 0.05079300f, -0.02075576f, 
    0.03617982f, -0.06318473f, 0.01015756f, -0.04523158f, -0.20290957f, -0.15747571f, -0.07670054f, 0.10555846f, 
    -0.11282043f, 0.12332751f, -0.01092970f, 0.12187547f, -0.05984550f, -0.02138831f, -0.01418487f, -0.02889808f, 
    0.11745859f, 0.04041463f, 0.01807393f, 0.02083269f, 0.01805678f, -0.00589084f, -0.17444128f, 0.01322518f, 
    -0.10714000f, -0.24919192f, 0.02125641f, 0.25047135f, -0.02055954f, 0.07825302f, 0.09956522f, 0.05225569f, 
    0.04511137f, 0.08427256f, 0.09706535f, -0.01706568f, 0.04745929f, -0.02353014f, -0.08418607f, -0.08840933f, 
    -0.04515994f, -0.01208624f, -0.17023687f, 0.02081482f, 0.39265308f, 0.14461873f, -0.03845421f, 0.09802905f, 
    0.23422638f, 0.07130200f, -0.01097361f, -0.14033276f, -0.10527210f, -0.13685383f, -0.09930731f, -0.05228621f, 
    0.05621955f, 0.05578788f, -0.00934660f, 0.03701620f, 0.08961182f, 0.15096109f, 0.03576099f, 0.05762148f, 
    -0.19664268f, 0.04048736f, 0.09028170f, -0.03544993f, -0.12740761f, 0.11240651f, 0.07723566f, -0.02785007f, 
    0.01502231f, 0.01076024f, -0.00854945f, -0.07556690f, 0.06607065f, 0.01330614f, -0.03645498f, 0.01173343f, 
    0.16271269f, -0.01198483f, -0.04061442f, 0.05105228f, -0.11035430f, 0.02138730f, 0.09845677f, 0.02241801f, 
    0.05762108f, 0.18810189f, 0.05159522f, -0.18764731f, 0.08021040f, -0.04723105f, 0.19059159f, -0.02970764f, 
    -0.04279193f, -0.03059150f, -0.00395372f, -0.04709597f, 0.01802170f, 0.04950425f, 0.07087463f, 0.01150576f, 
    0.28969768f, -0.10804009f, -0.07719085f, 0.03320772f, -0.03824997f, -0.01431621f, -0.01992024f, 0.00225346f, 
    0.01890805f, 0.08633313f, 0.05200525f, -0.03454478f, 0.02472985f, 0.07185429f, 0.04526302f, -0.02855094f, 
    -0.08394308f, -0.11614630f, -0.02199619f, -0.08142098f, -0.00625678f, 0.00051511f, 0.06641414f, 0.07993502f, 
    0.17589916f, 0.01550486f, -0.11572105f, -0.10204118f, -0.04594380f, -0.02377849f, -0.02399066f, 0.08186889f, 
    0.06202947f, 0.03182552f, 0.14582197f, 0.03841600f, -0.05151800f, -0.00509605f, 0.01894359f, -0.04961450f, 
    -0.18246195f, 0.05788241f, -0.10879320f, -0.02580033f, 0.07962357f, -0.04433744f, 0.06177025f, 0.00618364f, 
    0.03299302f, -0.03536070f, -0.00905336f, -0.01111971f, 0.01203368f, 0.00409257f, 0.07768480f, 0.02517212f, 
    -0.02168452f, 0.08452945f, 0.12434486f, 0.02450220f, -0.06028991f, 0.14771610f, 0.37328795f, -0.00796727f, 
    0.09636080f, -0.01809676f, -0.02313530f, -0.07407296f, -0.01825589f, 0.01840396f, -0.06605641f, -0.03592131f, 
    0.04889888f, -0.07566602f, -0.01963237f, 0.02243183f, 0.05774127f, -0.03607000f, 0.11752099f, 0.01438620f, 
    0.20251730f, -0.04679209f, 0.24291112f, 0.05875832f, 0.39385611f, -0.04618886f, -0.06099859f, -0.12642451f, 
    0.01459863f, 0.03033389f, -0.03138579f, -0.02225976f, 0.04916887f, 0.01307652f, 0.00762938f, -0.00565140f, 
    0.00983615f, -0.03736060f, -0.01948985f, -0.12102710f, -0.06000756f, 0.20159531f, -0.07452231f, 0.16858764f, 
    0.15941043f, -0.02002563f, 0.05511155f, -0.01109545f, 0.07574228f, -0.01039362f, -0.03330150f, -0.09312648f, 
    -0.01259388f, 0.07062629f, 0.03608114f, 0.00643743f, -0.05057284f, 0.00040149f, -0.09044279f, 0.04423965f, 
    -0.05082114f, 0.02509749f, -0.10264084f, 0.02657087f, 0.00370914f, 0.05712380f, -0.00126545f, 0.04942363f, 
    -0.00362026f, -0.01777394f, -0.12209532f, -0.02719515f, 0.09191079f, 0.06268066f, 0.02200785f, 0.06673660f, 
    0.02306872f, 0.10185129f, 0.01218301f, 0.00050082f, 0.10037001f, 0.14106314f, -0.00688924f, -0.00653348f, 
    -0.17114383f, 0.06133426f, 0.14647280f, 0.09362618f, -0.06775895f, -0.07803784f, 0.03704458f, 0.08409715f, 
    0.07772745f, -0.08066689f, 0.00691833f, -0.01016900f, 0.08122098f, 0.04471778f, 0.05219670f, 0.03428582f, 
    -0.07892377f, -0.09343715f, 0.10285661f, 0.09602182f, -0.06522336f, -0.02970650f, -0.08440913f, -0.01722975f, 
    -0.01627105f, -0.00022608f, -0.03623684f, 0.02546890f, 0.05390109f, -0.01697184f, -0.02654569f, 0.00608289f, 
    -0.05185601f, 0.08223095f, -0.07593101f, 0.01905206f, -0.11976089f, 0.00221795f, 0.00736841f, -0.01729760f, 
    -0.12115435f, 0.08558925f, 0.01201408f, 0.08871249f, 0.07388482f, -0.08990767f, -0.04351733f, 0.03926653f, 
    -0.02497402f, -0.01490959f, 0.02300551f, 0.02276753f, 0.00832479f, -0.01096353f, -0.02800877f, -0.00335191f, 
    0.06583495f, 0.15401579f, -0.01051690f, 0.10860804f, 0.05841260f, 0.04576618f, 0.07881351f, 0.02151054f, 
    -0.00384571f, -0.08609674f, -0.02284636f, 0.07713162f, -0.03239056f, -0.06022239f, -0.01390113f, 0.03840787f, 
    0.13650033f, -0.10346732f, -0.02784819f, 0.01821211f, -0.02591032f, 0.10302944f, -0.03597083f, 0.21190706f, 
    0.12085286f, 0.06922173f, -0.08072527f, -0.00294047f, 0.00586057f, -0.00316977f, -0.08746046f, -0.06545766f, 
    -0.00896982f, -0.06118316f, 0.00117468f, 0.03861612f, -0.05172870f, 0.05567078f, -0.16696878f, -0.02740099f, 
    0.02177312f, 0.09455398f, 0.14532052f, 0.20179583f, 0.25726837f, 0.02251037f, -0.06507270f, 0.08345665f, 
    0.02913447f, -0.08714987f, -0.01174669f, -0.00098740f, -0.10342743f, -0.07584967f, 0.00806491f, -0.03975981f, 
    0.00409235f, -0.04146936f, -0.15361819f, 0.02249642f, 0.29962891f, 0.03709539f, -0.14422673f, -0.01558357f, 
    -0.03850333f, -0.17221610f, -0.11777178f, 0.11084049f, 0.10356396f, 0.07424885f, -0.00339062f, 0.06021645f, 
    0.08718623f, 0.05335746f, 0.09132060f, -0.04720804f, 0.03410602f, 0.05982817f, 0.05777883f, 0.12967715f, 
    0.14818597f, 0.28750956f, 0.13059981f, -0.04857191f, 0.06127509f, 0.09874488f, 0.15296438f, 0.00856117f, 
    -0.06052113f, -0.06149879f, -0.04743617f, 0.00488716f, 0.01569783f, 0.04227371f, -0.15250503f, -0.02341370f, 
    0.08448909f, 0.04869500f, -0.01705132f, -0.05559677f, -0.38458863f, 0.01301043f, 0.12517093f, -0.13687874f, 
    -0.02296751f, 0.13434182f, 0.03277750f, -0.02128414f, 0.01052127f, -0.04898931f, 0.12733471f, 0.05688455f, 
    -0.04390550f, 0.01418953f, 0.02890527f, -0.10794087f, 0.07152396f, 0.06578345f, 0.10737723f, 0.00041105f, 
    0.21777777f, 0.00820909f, -0.06165943f, 0.09464332f, 0.07818266f, -0.02531379f, -0.11742583f, -0.00699473f, 
    0.13935196f, 0.17182101f, -0.04019493f, 0.04041491f, -0.01581092f, 0.02774079f, 0.12548739f, -0.04896022f, 
    -0.04897552f, -0.04145368f, 0.01517001f, -0.05899462f, 0.17104928f, 0.02301944f, -0.08483037f, 0.01529288f, 
    0.08176330f, -0.09663627f, -0.19090500f, 0.06130354f, 0.10640436f, -0.00367209f, -0.04239871f, 0.02909878f, 
    -0.01585610f, 0.04404077f, 0.00555858f, 0.04106476f, -0.04472971f, 0.03574513f, 0.09231158f, 0.02562810f, 
    -0.13460502f, 0.06159475f, 0.09656695f, -0.06834771f, 0.15834841f, 0.03145785f, 0.03688171f, -0.07009844f, 
    0.00722174f, 0.03274690f, 0.01786697f, 0.05261917f, 0.03964253f, -0.07261323f, 0.05152632f, -0.01515184f, 
    0.12974688f, 0.04369511f, -0.09771147f, 0.06148537f, -0.35887223f, 0.05586805f, 0.20037444f, 0.11496186f, 
    -0.13512182f, -0.03656960f, 0.08045895f, 0.15278985f, -0.12056084f, -0.02285193f, -0.08232677f, 0.10693576f, 
    0.09779736f, 0.01055931f, -0.10897054f, -0.00317457f, -0.01992672f, 0.01969398f, 0.05842779f, 0.06750936f, 
    -0.05466768f, 0.01371008f, -0.00070352f, -0.05372192f, 0.00029540f, 0.04596966f, 0.01778905f, -0.05258549f, 
    -0.00718042f, -0.01158872f, 0.02859027f, -0.02621662f, -0.02221292f, 0.00253970f, -0.02114729f, 0.05064534f, 
    -0.04270272f, 0.01142363f, -0.01499079f, 0.01041294f, 0.01627749f, 0.00206011f, -0.01147819f, -0.01741206f, 
    -0.05394386f, 0.00266657f, -0.04119745f, -0.04936074f, -0.03588124f, 0.01779926f, 0.02708822f, 0.01634883f, 
    -0.02175755f, 0.01126650f, -0.01871678f, -0.05928273f, 0.00719052f, -0.01885150f, -0.01933776f, -0.00065610f, 
    -0.00651909f, 0.01400227f, -0.04715269f, 0.03787199f, 0.04375763f, -0.01198098f, -0.00805035f, -0.02266690f, 
    -0.00045410f, -0.01572450f, -0.04884731f, -0.00576615f, -0.03097426f, 0.00525045f, 0.04918716f, 0.01126076f, 
    -0.00572448f, 0.01190190f, -0.05833730f, -0.00982047f, 0.00148679f, 0.04007054f, -0.05340551f, -0.01883050f, 
    0.04737124f, -0.04517385f, 0.01977984f, -0.05240344f, -0.04067654f, 0.04679118f, 0.01536246f, -0.05723289f, 
    -0.03891827f, 0.04498132f, 0.02488754f, -0.01294111f, -0.02461510f, -0.01988296f, -0.03844236f, 0.04566798f, 
    -0.06025258f, -0.01834538f, -0.02626973f, -0.02837236f, -0.05341965f, 0.01349987f, 0.01848687f, 0.00905442f, 
    0.04169330f, -0.01265180f, -0.02249332f, -0.04884700f, -0.06071244f, -0.06044037f, 0.02280377f, -0.00416204f, 
    -0.01557087f, 0.02943133f, 0.04201991f, -0.01372704f, -0.03532559f, -0.03943055f, -0.02045049f, -0.05498918f, 
    -0.05196967f, -0.03006491f, 0.04304826f, -0.01173776f, -0.04611003f, -0.00242330f, -0.03797879f, -0.04347232f, 
    0.03278773f, -0.05088032f, 0.03645516f, 0.02408243f, -0.01745935f, 0.01147443f, 0.01813365f, -0.03849655f, 
    0.04977776f, -0.01544654f, -0.00700482f, -0.05655703f, 0.00519662f, -0.02714333f, -0.03959239f, -0.01550146f, 
    0.04997413f, 0.01867287f, -0.03800642f, -0.02218310f, -0.02377441f, 0.00198833f, 0.00617776f, -0.03486157f, 
    -0.00547867f, -0.01117628f, -0.04809002f, 0.04022531f, -0.04607367f, 0.00298260f, 0.00296169f, -0.05424636f, 
    -0.04809150f, 0.01446121f, 0.04545309f, -0.05523888f, 0.02331842f, 0.04123411f, -0.03858607f, -0.01462049f, 
    -0.01705514f, -0.05072261f, 0.04383423f, -0.03951024f, 0.00775942f, 0.03282288f, -0.04916482f, 0.04057948f, 
    0.03903297f, -0.01960352f, 0.01287673f, 0.02389175f, 0.03842000f, -0.01886172f, 0.00607621f, -0.04969922f, 
    0.01895315f, 0.03512255f, 0.00444115f, 0.03338782f, 0.00381648f, -0.00313602f, -0.04113010f, 0.00730662f, 
    0.03785811f, 0.00484311f, -0.04449875f, -0.03920471f, 0.04180833f, 0.04884063f, -0.05750730f, -0.04304661f, 
    0.01284391f, -0.02783388f, 0.04124159f, -0.06001906f, 0.02754672f, 0.04027307f, -0.01368237f, 0.03439670f, 
    -0.03880968f, -0.02675731f, -0.00977417f, -0.00718596f, 0.01522693f, -0.00851646f, -0.01745769f, 0.02037444f, 
    -0.04493025f, -0.01323608f, -0.00484029f, 0.01753184f, -0.03080275f, 0.01831496f, -0.05314073f, 0.01282491f, 
    -0.03755580f, 0.05007745f, 0.04869122f, -0.03141192f, 0.03589899f, -0.00418418f, 0.00335202f, 0.02092147f, 
    -0.02845070f, 0.01211419f, -0.06077604f, 0.03322590f, 0.00282625f, -0.01399461f, -0.00408576f, -0.03686612f, 
    -0.03236997f, 0.02599184f, -0.02294489f, -0.04445755f, 0.01814380f, -0.05165126f, -0.05166361f, -0.03359007f, 
    0.01119436f, -0.00112448f, -0.02716223f, 0.00978152f, -0.03141649f, 0.00039058f, -0.05538981f, 0.00632837f, 
    0.01563266f, 0.04285837f, 0.02175709f, -0.03677015f, 0.01066165f, -0.05763503f, -0.00032438f, 0.04443806f, 
    0.01949102f, -0.00463388f, -0.04568163f, -0.05383292f, 0.04563084f, -0.03983169f, -0.04793008f, -0.01115214f, 
    0.04404379f, -0.05126058f, 0.00407037f, 0.02819510f, -0.05319713f, 0.01132410f, -0.00698670f, -0.03652866f, 
    -0.03261162f, 0.05054535f, -0.02963211f, 0.04326480f, -0.05053601f, 0.01267164f, -0.05503811f, -0.04222839f, 
    -0.01134899f, -0.04022167f, 0.01763075f, -0.01798383f, 0.04912723f, 0.01212536f, 0.02817154f, -0.02340751f, 
    -0.00974403f, -0.04643060f, 0.01249867f, -0.01599035f, -0.00576967f, 0.01729728f, 0.02570141f, -0.01974446f, 
    -0.00020612f, 0.00267787f, -0.01397421f, 0.03371818f, -0.04328469f, 0.02359175f, -0.01140411f, -0.01161528f, 
    0.02732321f, 0.01641909f, 0.00873732f, 0.02065858f, -0.03734609f, -0.04223460f, 0.02244357f, -0.00083583f, 
    -0.05159317f, -0.02050181f, 0.02189913f, 0.01997758f, -0.04071692f, -0.04589965f, -0.02039885f, -0.03869407f, 
    0.00445690f, -0.02642307f, 0.05549287f, -0.01329527f, 0.01506878f, -0.04232382f, -0.02747714f, -0.01348345f, 
    -0.07587259f, -0.03210099f, 0.00843150f, -0.11484314f, -0.17821516f, 0.07114451f, 0.00952513f, 0.03838749f, 
    0.12363386f, 0.00507282f, -0.01421503f, 0.00098164f, -0.04386381f, 0.05374677f, -0.04415837f, -0.02235032f, 
    -0.12890747f, 0.07001971f, 0.02059716f, 0.01709080f, -0.13640548f, -0.30796868f, -0.12059203f, -0.09861045f, 
    -0.07654119f, -0.03598551f, 0.05269040f, -0.05183563f, -0.07820918f, -0.08299544f, 0.04110475f, 0.03929143f, 
    -0.03683399f, 0.07912717f, -0.05999312f, 0.02096281f, 0.02046296f, 0.00560447f, -0.20507833f, 0.03209336f, 
    -0.09007711f, -0.18280569f, 0.12665053f, -0.01505128f, -0.09646978f, -0.02799221f, -0.00759647f, -0.01275057f, 
    0.03302207f, 0.03741904f, 0.00988250f, -0.00830407f, 0.01498879f, -0.01075322f, 0.05778426f, 0.08926015f, 
    0.02430632f, -0.00169218f, 0.05293644f, 0.01543586f, 0.00051658f, 0.13488275f, 0.16291173f, 0.13640539f, 
    0.01371945f, -0.03605897f, -0.06984702f, -0.04254177f, -0.01625014f, -0.03819789f, -0.01033875f, 0.00004831f, 
    -0.12973887f, -0.11392552f, 0.00444599f, -0.00863512f, 0.00278776f, 0.07657853f, 0.00749546f, -0.02102069f, 
    0.00502431f, 0.04087035f, 0.16978255f, 0.09784748f, -0.02801373f, -0.00190599f, 0.06170592f, -0.08946733f, 
    -0.07615200f, 0.06738472f, 0.03339463f, 0.06231894f, 0.09026472f, -0.02443419f, 0.02037976f, 0.00216800f, 
    0.01552598f, -0.01602260f, 0.12377667f, 0.01392067f, -0.04567702f, 0.16147028f, 0.12626325f, 0.05093283f, 
    -0.00211996f, -0.04661214f, -0.01427080f, -0.07847246f, 0.03504758f, 0.12581490f, 0.02997037f, 0.09010240f, 
    -0.07424187f, 0.12410275f, 0.03088881f, 0.05650847f, -0.05025717f, 0.02698446f, -0.00394609f, 0.09240265f, 
    -0.05708425f, 0.10549903f, 0.23506641f, -0.09182774f, -0.03250568f, -0.02830448f, -0.06709248f, -0.08081747f, 
    -0.00026686f, 0.04452121f, -0.02538310f, 0.06869496f, 0.02123015f, 0.03078583f, 0.09476204f, -0.02901675f, 
    -0.05922914f, -0.01598854f, 0.07024094f, -0.00302112f, -0.19349895f, -0.35363036f, 0.05565288f, -0.11925946f, 
    -0.17051315f, 0.00241272f, 0.00412487f, -0.05724537f, 0.05465193f, -0.00569330f, -0.04399502f, -0.01111330f, 
    0.05597704f, 0.07210594f, 0.02920451f, -0.01510956f, 0.07699125f, -0.04714640f, -0.16806485f, -0.02119084f, 
    -0.05447957f, -0.29644468f, -0.20845886f, -0.08551234f, -0.20429564f, -0.04476558f, 0.07997806f, 0.01894557f, 
    0.05299558f, -0.01444082f, 0.13743238f, 0.10211121f, -0.00293952f, 0.10444785f, 0.00851580f, 0.02627406f, 
    -0.09805535f, 0.05330440f, -0.10592470f, -0.02747607f, 0.20914723f, 0.07096705f, 0.11847921f, 0.08462527f, 
    0.24637416f, 0.04428593f, 0.05381509f, -0.00826519f, -0.00560958f, -0.05173274f, -0.01265412f, -0.01014215f, 
    -0.02937031f, -0.06267933f, -0.02398372f, -0.08060887f, 0.12283525f, 0.02671562f, 0.05459904f, -0.01321139f, 
    -0.19027843f, 0.01323865f, 0.09041767f, -0.05214133f, -0.10374746f, 0.06875194f, 0.03327370f, -0.07424381f, 
    0.09096473f, 0.03151055f, 0.04085003f, 0.01021615f, -0.08363602f, -0.02084279f, -0.02021476f, 0.03658937f, 
    0.04079116f, 0.07199829f, 0.00506649f, 0.02787243f, 0.22481725f, 0.20521374f, 0.10991862f, 0.07211534f, 
    0.18721890f, 0.08849737f, 0.07665060f, -0.04107716f, -0.17596464f, 0.01601747f, 0.11324430f, -0.11357872f, 
    0.03085353f, -0.12228404f, -0.06864712f, 0.06253880f, -0.03159920f, -0.00653471f, 0.10859674f, 0.04366811f, 
    0.13627377f, 0.04819805f, -0.16579245f, -0.00773673f, 0.07050595f, -0.09909219f, 0.06516441f, 0.03283900f, 
    -0.04856111f, -0.07050803f, 0.00571780f, 0.01104345f, 0.06492563f, 0.06502362f, -0.03124753f, -0.06329470f, 
    0.02000089f, -0.02009684f, 0.07161912f, 0.08568161f, -0.15564758f, -0.17093886f, 0.02717475f, 0.02531888f, 
    0.18976934f, 0.03817736f, -0.14540210f, -0.06661232f, 0.00566709f, -0.03865945f, 0.05178947f, 0.00175599f, 
    0.11246642f, 0.02451099f, 0.08477243f, 0.05188755f, 0.05766395f, 0.12704140f, 0.03087823f, -0.10978150f, 
    0.17398235f, 0.14292252f, 0.00381978f, -0.16103965f, -0.03138131f, -0.00698268f, -0.05572926f, 0.05993591f, 
    0.01011468f, 0.05721486f, 0.00154216f, 0.01607529f, 0.00213818f, -0.06570549f, 0.01060166f, -0.14051336f, 
    -0.05266320f, 0.01466330f, 0.01141875f, 0.09508628f, 0.28234935f, 0.24293663f, 0.29639110f, 0.12205097f, 
    0.19197761f, -0.12784062f, -0.13374613f, 0.04963736f, -0.09462007f, -0.00148765f, 0.03836504f, -0.03434742f, 
    0.07540284f, -0.07621298f, -0.03193511f, 0.13074324f, -0.11924979f, 0.02090114f, 0.09020043f, -0.07326397f, 
    -0.04846877f, 0.01984903f, -0.04405924f, 0.01049386f, -0.02606655f, 0.04285090f, -0.06524253f, 0.03301341f, 
    -0.00450844f, 0.00063417f, 0.00588854f, -0.00767581f, -0.06414434f, -0.00415186f, 0.00009110f, 0.01926828f, 
    -0.03296982f, -0.01536356f, 0.01005646f, 0.04830450f, -0.00826823f, -0.00778138f, 0.04919955f, 0.04791296f, 
    0.03330082f, 0.02170672f, -0.04504023f, -0.04794170f, -0.04469124f, 0.04073333f, -0.06231968f, 0.01036551f, 
    -0.00653213f, -0.02171060f, -0.03773463f, -0.02243717f, -0.04373852f, -0.02489246f, -0.00354063f, 0.01166451f, 
    -0.03609517f, -0.00896969f, -0.02452132f, -0.02844146f, -0.03817213f, 0.01728905f, -0.03348722f, -0.04447974f, 
    -0.03319582f, -0.05179532f, -0.04723052f, -0.00061665f, 0.03876285f, 0.02315117f, 0.04972839f, -0.00134851f, 
    0.03951170f, 0.00647561f, 0.00658464f, 0.02546894f, 0.02590906f, 0.02409078f, -0.00665852f, 0.01734712f, 
    0.00990465f, -0.03378092f, 0.01187170f, -0.00961687f, 0.02559239f, -0.02136479f, 0.00253257f, -0.01365340f, 
    0.02348178f, -0.00924921f, -0.01772655f, -0.01668785f, -0.00671021f, -0.00146516f, -0.02922849f, -0.02324319f, 
    0.01739843f, -0.04445518f, 0.04035946f, -0.02734697f, 0.04708497f, -0.02809541f, -0.01273687f, -0.00383680f, 
    0.03778577f, -0.01935597f, -0.04843399f, -0.05038186f, -0.03168030f, 0.02791182f, 0.04919962f, 0.00423500f, 
    0.03400642f, 0.00697176f, -0.02086649f, -0.04670109f, -0.01674599f, -0.05081610f, -0.02202128f, -0.00589979f, 
    0.01816770f, -0.02148844f, -0.03453740f, 0.05362692f, 0.03487058f, 0.02622106f, 0.04730094f, -0.00816254f, 
    -0.05332902f, -0.00228078f, -0.01325974f, -0.05153043f, -0.02743777f, -0.05661375f, 0.02270767f, 0.01487201f, 
    0.02607214f, 0.04814848f, -0.02839587f, -0.03659008f, 0.00524605f, -0.02093393f, 0.00874947f, -0.01777178f, 
    -0.05660061f, 0.03652444f, -0.04172919f, -0.01695071f, -0.00936123f, -0.02350909f, -0.06119940f, 0.00434182f, 
    -0.02936157f, 0.01348167f, 0.03549611f, -0.02653352f, -0.00200882f, -0.04055739f, 0.05504456f, -0.03426439f, 
    0.04478070f, 0.04170571f, 0.01221954f, 0.01792832f, -0.03087083f, 0.01948486f, -0.00466459f, 0.05152942f, 
    0.02913576f, 0.04143005f, 0.00047556f, 0.00373969f, -0.03563011f, 0.01856129f, 0.05135670f, 0.04620707f, 
    -0.05456463f, 0.03709289f, -0.01101434f, 0.03398139f, -0.04661167f, -0.02623109f, 0.00622312f, -0.02139127f, 
    0.02006527f, 0.02998193f, 0.03889944f, 0.04022784f, -0.04996623f, 0.04395514f, -0.05508664f, 0.04867760f, 
    0.04768292f, -0.00359043f, 0.01363602f, -0.02608619f, -0.02932985f, -0.03925507f, 0.03627865f, -0.05011518f, 
    0.04988578f, -0.06638137f, -0.04224757f, -0.03657338f, 0.02124230f, -0.01743332f, -0.00392288f, 0.02187011f, 
    -0.03908281f, -0.01138940f, -0.05140391f, -0.04523759f, -0.04806024f, 0.03567630f, 0.01770518f, 0.02483824f, 
    0.04283234f, 0.04221124f, 0.03528299f, 0.01556418f, 0.02496559f, 0.02264948f, 0.04022223f, -0.00681540f, 
    0.01616927f, 0.02064000f, 0.00316892f, -0.04167452f, 0.01473632f, -0.00565875f, 0.03986541f, -0.00583946f, 
    0.02738973f, -0.04795013f, 0.00824759f, 0.04637655f, -0.03464394f, 0.05026181f, -0.01531896f, -0.04871905f, 
    0.04429042f, -0.05086258f, 0.04917124f, -0.00920341f, -0.01426830f, -0.02451582f, -0.03073226f, 0.04274555f, 
    0.04407918f, -0.02864111f, -0.04377642f, 0.03403588f, -0.05555223f, -0.02610420f, -0.00798938f, -0.03653008f, 
    -0.04699941f, -0.00382917f, -0.05811395f, 0.04340441f, -0.02090536f, -0.01814752f, -0.01941360f, -0.04428714f, 
    0.01637174f, 0.01588651f, -0.01375508f, -0.00058673f, -0.03515426f, -0.01484604f, -0.02229706f, -0.05191299f, 
    -0.06153746f, -0.01466060f, -0.02287349f, -0.02990338f, -0.00967958f, -0.03896116f, -0.05850177f, -0.03194513f, 
    -0.01392571f, -0.04329154f, -0.04310340f, -0.03947045f, 0.01698636f, 0.05046899f, -0.03346455f, 0.02566124f, 
    0.01414199f, -0.01145771f, 0.01990558f, 0.00319791f, 0.01344491f, -0.05184783f, -0.01938887f, -0.01949428f, 
    0.00423738f, -0.00942116f, -0.03718673f, 0.00150115f, 0.04746918f, -0.00325360f, 0.00951144f, -0.01746836f, 
    0.00781823f, -0.04122283f, 0.01624890f, -0.01678178f, 0.00777712f, -0.01103526f, -0.01743791f, 0.04351866f, 
    -0.05126555f, -0.01829946f, -0.02452878f, 0.02984180f, 0.04182477f, -0.01147756f, -0.06360482f, 0.03853752f, 
    0.01686902f, -0.02159393f, -0.02970328f, 0.05082835f, 0.01497197f, -0.01095747f, 0.03105616f, 0.04278296f, 
    -0.00732843f, 0.03510563f, -0.03381752f, 0.01943391f, -0.04883452f, 0.04636527f, -0.01757569f, 0.00328646f, 
    -0.00867924f, -0.25824612f, -0.20982367f, -0.05209402f, -0.12396909f, 0.02622515f, 0.11511537f, 0.13717130f, 
    -0.05305167f, -0.07329042f, -0.00790108f, 0.05174470f, 0.12870389f, -0.06118548f, -0.05867236f, -0.05430141f, 
    -0.02092435f, -0.00031087f, 0.09603664f, 0.02892246f, -0.28567728f, -0.01805365f, 0.10834075f, -0.01815488f, 
    -0.16491415f, 0.04096282f, 0.04062950f, -0.00280020f, 0.13439982f, -0.06809568f, 0.00283888f, 0.08609861f, 
    -0.06770431f, 0.08451805f, 0.01690817f, -0.08297388f, 0.01888898f, 0.06381980f, 0.02361989f, -0.01202896f, 
    0.13688777f, 0.11764871f, 0.09416255f, -0.17691630f, -0.10262176f, 0.10175250f, 0.11473079f, 0.17314872f, 
    0.17147100f, 0.01009462f, 0.05951235f, -0.08197297f, -0.02169452f, 0.02958760f, 0.03578328f, 0.02140905f, 
    0.02910298f, -0.09369792f, -0.05158732f, -0.01420162f, -0.15381882f, -0.05978918f, 0.03917131f, -0.01836449f, 
    -0.00513908f, -0.12290899f, -0.01172062f, -0.07150894f, 0.08479201f, 0.03505830f, -0.03667684f, 0.09944636f, 
    -0.05328452f, 0.14927654f, 0.07231180f, 0.09807028f, 0.10013214f, -0.00176157f, -0.03211702f, -0.00539337f, 
    -0.29388404f, 0.25862613f, -0.21953073f, -0.13240930f, 0.12715380f, -0.00161081f, -0.04549296f, 0.08496959f, 
    0.02038499f, 0.11274177f, -0.02888885f, -0.02107211f, -0.01125254f, -0.09628436f, 0.04239698f, 0.03580643f, 
    0.08649114f, 0.00349169f, -0.01683944f, 0.00002711f, -0.06253076f, 0.25079951f, 0.06595322f, -0.11369082f, 
    0.01609237f, -0.01260213f, 0.02835063f, 0.08289750f, 0.04394950f, 0.09494622f, -0.00561044f, -0.06636690f, 
    0.01134819f, 0.09527443f, -0.02740306f, 0.05399073f, 0.05407050f, 0.05637394f, -0.08992781f, 0.05996154f, 
    0.12031882f, -0.13590990f, 0.03431474f, -0.12565801f, -0.10679635f, -0.10333568f, 0.01041224f, -0.00412684f, 
    0.00957200f, -0.05284243f, 0.07718009f, 0.02522257f, 0.04795788f, 0.08991861f, 0.10072624f, 0.02260250f, 
    -0.04048222f, 0.10094212f, 0.05112715f, -0.02193094f, -0.11046027f, -0.08207920f, 0.02092042f, -0.09923705f, 
    -0.11299805f, 0.02691015f, 0.13793941f, 0.01475967f, 0.14857315f, 0.03688262f, -0.00734618f, 0.04030786f, 
    0.02091067f, -0.02611750f, -0.02070807f, -0.06524585f, -0.00948550f, 0.02392433f, -0.04781650f, 0.07914251f, 
    0.04441263f, -0.10103378f, -0.08940042f, -0.09496640f, -0.13873994f, 0.10322187f, -0.00622236f, -0.04371434f, 
    0.03933546f, 0.04051853f, 0.10457113f, -0.03979227f, -0.00322478f, -0.08545952f, 0.07193760f, 0.14572360f, 
    -0.06969554f, 0.04026705f, -0.02160766f, 0.01008869f, -0.01963122f, 0.19567865f, 0.04619993f, 0.13574640f, 
    0.26112941f, -0.08672392f, -0.14280312f, -0.06995001f, 0.04899867f, 0.08866382f, 0.10167824f, 0.06386347f, 
    0.07875369f, 0.05591690f, -0.10204083f, 0.09693620f, 0.05697555f, -0.00762527f, 0.04356233f, 0.02387059f, 
    -0.24418122f, -0.00867788f, -0.04820214f, 0.01782748f, -0.00591903f, -0.10272604f, -0.00924897f, 0.02808873f, 
    0.06691513f, 0.05381959f, 0.23350126f, -0.08813288f, -0.11861083f, -0.06004035f, 0.01252300f, -0.07849278f, 
    0.00800953f, -0.03348394f, 0.07066415f, -0.03829416f, -0.14584570f, 0.28584975f, -0.04885105f, -0.20258594f, 
    0.23932505f, 0.10005582f, 0.02283573f, 0.09655120f, -0.04766005f, 0.09259546f, -0.03923484f, -0.01822688f, 
    -0.11454055f, -0.08790776f, 0.01675176f, 0.03273679f, -0.05465036f, 0.04972001f, -0.00906711f, -0.03123057f, 
    0.21941744f, -0.13727885f, 0.03737279f, 0.15150775f, 0.09249723f, 0.01796544f, -0.04526194f, -0.14064047f, 
    -0.05390331f, -0.01414964f, 0.18358584f, 0.11040832f, 0.05043968f, 0.00029465f, -0.03211320f, 0.06555656f, 
    0.03005894f, 0.00798907f, -0.09299088f, 0.07733665f, -0.11011607f, 0.25573176f, 0.10726865f, 0.13324909f, 
    0.10677194f, -0.05616324f, -0.06452615f, 0.03666464f, -0.06724133f, 0.04032421f, 0.03097062f, -0.02749143f, 
    0.14128019f, -0.01979410f, 0.07375762f, 0.04365296f, -0.03696973f, 0.10068788f, 0.05729668f, 0.02159066f, 
    0.16794819f, -0.18044461f, 0.07092603f, -0.15459071f, -0.01903478f, -0.04144184f, 0.01802590f, -0.13133851f, 
    -0.07864349f, 0.03996104f, 0.06932111f, 0.01922096f, 0.03533446f, -0.00369103f, 0.01299136f, -0.02186538f, 
    -0.01537668f, 0.01829802f, 0.07916936f, -0.15718792f, 0.34336367f, -0.00082011f, -0.04155558f, -0.04719254f, 
    0.04213056f, -0.15608568f, -0.03781111f, 0.00148952f, 0.02494103f, 0.19624665f, -0.00164274f, 0.09562187f, 
    0.02215625f, 0.00896745f, 0.10963433f, 0.08850600f, -0.03272249f, 0.02105071f, -0.06923065f, -0.03413963f, 
    -0.03493624f, 0.04572837f, 0.03665216f, -0.01512286f, 0.00100118f, -0.00059197f, -0.05189152f, -0.02189114f, 
    0.01504074f, 0.03684790f, -0.02060949f, -0.01744559f, -0.04677707f, -0.02219416f, 0.03336905f, 0.03401658f, 
    -0.06145138f, 0.03709918f, 0.02476867f, -0.06116027f, -0.05889270f, -0.05555965f, 0.01282859f, 0.02051865f, 
    -0.04059904f, -0.00350226f, 0.04414196f, -0.04642839f, -0.01834526f, -0.03506182f, 0.01086010f, -0.02628930f, 
    0.04268718f, -0.00315471f, -0.01719158f, -0.05426033f, -0.05522738f, 0.03454723f, -0.02294062f, 0.00167593f, 
    -0.03004518f, -0.04401081f, -0.01300397f, -0.01904135f, 0.03686621f, -0.05117284f, -0.05722380f, -0.02537777f, 
    -0.04181024f, -0.02783409f, 0.01298179f, 0.02914248f, -0.03156596f, 0.02642890f, -0.01756055f, 0.04041177f, 
    0.00878201f, -0.04111519f, -0.04627543f, -0.03469559f, 0.03809590f, -0.05073328f, 0.04043636f, -0.02887939f, 
    0.04950168f, -0.05432002f, 0.01595283f, 0.01281101f, 0.04967185f, -0.03834897f, 0.02787122f, 0.01098839f, 
    0.04058652f, 0.01201954f, 0.01800193f, -0.04451687f, -0.01012986f, -0.04856327f, 0.03130845f, -0.05434847f, 
    -0.04309726f, 0.04893603f, -0.02998932f, -0.03436762f, -0.02144704f, 0.02409676f, 0.01349897f, 0.02169953f, 
    -0.00973105f, -0.00833285f, 0.00781814f, -0.03858284f, -0.02047005f, -0.01246922f, -0.01534585f, 0.03820971f, 
    0.03971827f, -0.01561317f, 0.03650164f, -0.00402286f, 0.00509418f, -0.02450960f, -0.03222095f, -0.05265002f, 
    -0.00176287f, -0.04693218f, 0.03713257f, -0.02334913f, -0.01264193f, -0.04735087f, -0.03693619f, -0.05686627f, 
    0.04822744f, -0.05911561f, 0.00926522f, -0.05893387f, -0.05958167f, -0.03636787f, 0.02627887f, 0.03510137f, 
    -0.02746400f, 0.04559630f, -0.05990578f, -0.03924306f, -0.04678027f, -0.02900712f, 0.00270153f, -0.02317902f, 
    0.00354988f, 0.01431377f, -0.02469502f, -0.04838738f, -0.03165542f, 0.04060179f, -0.05886764f, 0.01549909f, 
    -0.03136387f, 0.03463567f, 0.01418687f, 0.03017776f, 0.02998994f, 0.01886073f, -0.03115104f, 0.01942745f, 
    -0.00252924f, -0.06027202f, 0.02622005f, -0.06186932f, -0.02016802f, 0.00748519f, -0.03764810f, 0.04726273f, 
    -0.00286116f, 0.01300068f, -0.03861430f, -0.01662925f, 0.02950184f, -0.00295153f, -0.02832266f, 0.00326827f, 
    -0.05441558f, -0.00672821f, 0.00131185f, -0.01216704f, -0.04043043f, 0.00805041f, 0.01970049f, -0.02524968f, 
    -0.00041038f, 0.03751056f, -0.03120608f, 0.02062311f, 0.03605297f, 0.04303767f, -0.05689042f, 0.01026420f, 
    0.03847078f, -0.05810225f, 0.03929435f, -0.01575175f, 0.03157007f, 0.04531783f, 0.01686545f, -0.04572779f, 
    0.01108135f, 0.02180886f, 0.02546758f, -0.03662718f, 0.00749830f, 0.04780883f, 0.04810918f, -0.02328232f, 
    -0.01639340f, 0.02090299f, -0.00454506f, 0.00034605f, -0.01801986f, -0.02180156f, -0.01820595f, -0.01608535f, 
    -0.05601611f, 0.00285425f, -0.02587034f, 0.02890386f, -0.05066895f, 0.00593045f, -0.04106805f, 0.00575081f, 
    -0.03647964f, 0.03278888f, -0.00270720f, 0.00080523f, 0.03964286f, 0.00888393f, -0.00830511f, -0.03314746f, 
    -0.05345419f, -0.01067406f, 0.02188555f, -0.02292931f, -0.02494408f, -0.01621363f, 0.01500937f, -0.04770359f, 
    0.01106751f, 0.03857927f, -0.02847620f, -0.06182668f, -0.05838635f, 0.02133802f, -0.01163160f, -0.01775695f, 
    -0.01303208f, -0.01508427f, -0.03082020f, -0.02877221f, -0.00876114f, -0.01108735f, -0.00773002f, 0.02232562f, 
    -0.05095256f, 0.03785852f, 0.00362333f, 0.00008574f, -0.02868284f, 0.04461643f, 0.01527864f, 0.03858620f, 
    0.00158320f, -0.00727378f, -0.04896035f, 0.03756389f, -0.01566070f, -0.01052642f, -0.04850571f, 0.01956933f, 
    -0.01936493f, 0.04240738f, -0.04263951f, 0.01051197f, 0.01594870f, -0.05226664f, -0.03033318f, -0.05151970f, 
    -0.03122028f, -0.05300951f, -0.03039080f, -0.04514764f, 0.01859422f, -0.01662065f, 0.01363689f, 0.00439737f, 
    0.02041451f, 0.01626944f, 0.01937273f, -0.03877699f, -0.05010507f, 0.01416382f, -0.03583706f, 0.00150863f, 
    0.00132326f, 0.02091428f, -0.00131433f, -0.04961981f, 0.02887764f, -0.04668587f, 0.02421476f, -0.04601416f, 
    -0.01028631f, 0.01798539f, 0.01576095f, 0.03815288f, -0.05427202f, -0.00608557f, 0.00938786f, 0.00107426f, 
    -0.04425497f, 0.03457062f, -0.04914271f, -0.02264004f, 0.02696756f, -0.03183826f, -0.05543422f, -0.03279705f, 
    0.03262597f, 0.00127445f, -0.04100612f, 0.03673236f, 0.03437315f, -0.04414785f, -0.00092563f, 0.00746973f, 
    -0.02116467f, 0.03631271f, -0.04471976f, -0.03154997f, -0.02608421f, 0.04444736f, 0.04945565f, 0.03708549f, 
    0.00213718f, 0.00000620f, 0.01743254f, 0.00686510f, -0.00562027f, -0.01249756f, 0.03629734f, -0.02339447f, 
    0.03907467f, 0.02298889f, 0.00659927f, 0.05086256f, -0.05874858f, -0.03918206f, -0.01676082f, -0.03126384f, 
    -0.04288432f, -0.02254542f, 0.03172205f, -0.02679862f, 0.03793228f, -0.03936454f, -0.00754085f, -0.03269485f, 
    0.03039566f, 0.03436402f, 0.03907917f, 0.02192104f, -0.01274409f, -0.05083793f, 0.03801068f, 0.02782662f, 
    -0.04709441f, -0.03716376f, -0.03151267f, -0.02366839f, -0.01192224f, -0.04519448f, -0.04644083f, 0.00203691f, 
    -0.04481277f, 0.01027204f, -0.03774759f, 0.03765018f, -0.04432279f, -0.04550553f, 0.00606160f, -0.05274367f, 
    0.04568814f, 0.00861953f, 0.00310198f, -0.04229974f, 0.00718027f, 0.02992816f, -0.06539385f, 0.00126827f, 
    0.00115269f, -0.02290104f, -0.04699541f, 0.02583988f, 0.01853939f, 0.03105390f, -0.03284651f, 0.04206645f, 
    -0.00567610f, 0.01194912f, -0.00731203f, -0.00248930f, 0.02004231f, 0.00898980f, 0.02797270f, 0.00010195f, 
    -0.00881153f, -0.01402636f, 0.04736328f, 0.00515741f, 0.03782359f, -0.04923722f, -0.01001212f, -0.00395241f, 
    -0.00981254f, -0.01019136f, 0.00733993f, 0.02616658f, 0.01155121f, -0.03342367f, -0.01858973f, -0.06198151f, 
    0.04199354f, 0.02287189f, -0.06148150f, 0.03494729f, -0.02742768f, 0.03629167f, -0.02662295f, 0.02647397f, 
    -0.03357644f, 0.04581138f, 0.00247165f, -0.01214971f, -0.00554056f, 0.03046091f, 0.01709610f, 0.03859958f, 
    0.03867519f, -0.00436717f, -0.02805623f, -0.00084634f, 0.03571440f, -0.03572124f, 0.01439246f, -0.01115968f, 
    0.00352611f, -0.05608914f, 0.00200023f, -0.03877688f, 0.02152649f, -0.00146961f, 0.02927717f, -0.01843048f, 
    -0.04761293f, 0.02173203f, -0.00529862f, 0.00601596f, 0.03099787f, -0.02180684f, -0.03734463f, -0.04360078f, 
    0.03357686f, -0.00403862f, -0.04085320f, 0.03219666f, 0.00261819f, -0.05738901f, 0.03672082f, -0.04601072f, 
    -0.01503507f, 0.01019492f, -0.01554643f, -0.01550120f, -0.02891586f, -0.02483386f, 0.01469682f, -0.01422193f, 
    -0.00787029f, -0.03579091f, -0.01477767f, -0.01535166f, -0.04215176f, -0.00752228f, -0.01270518f, 0.03904163f, 
    0.01593729f, -0.01962109f, -0.03091004f, 0.03653643f, 0.02737814f, 0.01891644f, 0.00209239f, -0.05219350f, 
    0.01388615f, 0.03104828f, -0.00207543f, 0.04110695f, -0.02903600f, -0.01276619f, -0.03477290f, -0.00660448f, 
    -0.05090073f, 0.04527201f, 0.04808262f, -0.02530916f, 0.02527056f, 0.03973084f, -0.03266184f, -0.00321455f, 
    -0.03306843f, 0.01550180f, -0.02531307f, 0.01843857f, -0.04617224f, -0.04032104f, 0.00117004f, -0.02785619f, 
    0.02062190f, -0.01619598f, -0.01815463f, -0.06587680f, 0.02335283f, 0.01989481f, -0.04017264f, 0.00205042f, 
    -0.01207939f, 0.01184603f, -0.05262640f, 0.00493537f, -0.02536623f, 0.03581220f, 0.00353989f, 0.02872474f, 
    -0.04584038f, 0.02404407f, 0.02301750f, -0.01081470f, -0.04720398f, -0.01690450f, -0.05686079f, 0.02859365f, 
    -0.05347675f, 0.04647520f, -0.02426039f, 0.03828784f, -0.03357936f, -0.03278884f, -0.02027634f, 0.00071260f, 
    0.00597141f, -0.03769687f, -0.01105724f, -0.04499340f, -0.01645854f, -0.02606830f, -0.02191151f, -0.00353556f, 
    0.05124253f, -0.02912751f, 0.04578138f, 0.01791889f, -0.06239670f, 0.04643703f, -0.03689787f, -0.01708117f, 
    -0.05528909f, -0.00457331f, -0.03574644f, -0.04148951f, -0.01766286f, -0.04988278f, -0.03614894f, 0.01199392f, 
    -0.02604913f, -0.03168342f, 0.03348143f, 0.02872862f, 0.01061398f, -0.05527337f, -0.01007959f, -0.05174644f, 
    -0.05379804f, 0.04253995f, -0.05235523f, 0.04481769f, -0.00946584f, -0.03866593f, 0.00166532f, -0.00247109f, 
    -0.00128104f, 0.00870327f, 0.04253654f, -0.01109592f, 0.00301200f, 0.00304100f, 0.01482698f, -0.05960102f, 
    0.04564970f, 0.02300446f, -0.00923674f, -0.01451716f, 0.02961354f, 0.00287783f, -0.05343335f, 0.01033807f, 
    0.02492131f, -0.03422570f, 0.03284855f, -0.03870071f, -0.02584389f, -0.05033527f, -0.05493063f, -0.05281477f, 
    -0.04034096f, -0.03435128f, -0.03824734f, -0.03690616f, -0.00782243f, 0.01131464f, -0.01924026f, 0.03048183f, 
    -0.01235655f, -0.05957371f, 0.03715509f, -0.01765723f, 0.02530551f, -0.04748939f, -0.00764159f, -0.05593563f, 
    -0.05206228f, 0.02246439f, -0.00885109f, 0.03578790f, 0.02680608f, 0.02022294f, -0.05928664f, 0.01736727f, 
    0.00934078f, 0.03893140f, 0.02792051f, -0.03541738f, -0.05896971f, -0.03529373f, -0.04022783f, -0.02633706f, 
    -0.03426301f, -0.03461502f, 0.01589523f, -0.06293126f, 0.00040164f, -0.06015241f, -0.01848663f, 0.00950838f, 
    -0.02823850f, 0.04179198f, -0.01370713f, -0.05927484f, 0.02347537f, -0.05615594f, -0.03219919f, 0.04226576f, 
    -0.00876249f, -0.03464873f, -0.05114505f, -0.00928354f, -0.00902708f, -0.05086167f, -0.05144929f, 0.02416069f, 
    -0.02287980f, -0.04792128f, 0.00101409f, -0.04405177f, -0.05973254f, -0.03689741f, 0.01458870f, -0.01336762f, 
    0.02954875f, -0.04556132f, -0.02097718f, 0.03177879f, -0.01841518f, -0.03148347f, 0.04055217f, 0.00154413f, 
    -0.04762502f, 0.04264408f, 0.02194702f, 0.01228484f, 0.03059970f, -0.00259754f, -0.03350699f, 0.04865063f, 
    0.01144634f, 0.02979142f, -0.02999204f, -0.05541554f, 0.01897684f, -0.00829010f, 0.03413720f, -0.03768677f, 
    -0.04344206f, 0.03195946f, -0.00377142f, 0.00595336f, 0.00841569f, -0.04122060f, -0.00968387f, 0.00053627f, 
    0.02935705f, 0.00544935f, 0.00294442f, -0.03441544f, -0.02600686f, -0.04656590f, -0.01616837f, -0.05775121f, 
    0.01685002f, -0.05899063f, 0.02712834f, -0.02343082f, 0.00024222f, 0.00740257f, 0.00331356f, 0.03535544f, 
    0.02592444f, -0.05341984f, -0.05327775f, 0.03968044f, 0.01560374f, -0.01064464f, -0.00640846f, -0.00826656f, 
    -0.03548260f, -0.01225935f, 0.01939798f, 0.02910253f, 0.02928908f, 0.05014078f, 0.02199038f, -0.00078314f, 
    -0.03256115f, 0.03609803f, 0.01854122f, 0.00396061f, -0.05494424f, 0.00743977f, 0.01177973f, -0.05445871f, 
    -0.00885967f, 0.01488042f, -0.02789813f, 0.04208965f, -0.04519954f, -0.01504764f, 0.02234814f, -0.00707099f, 
    -0.03101765f, -0.05689816f, -0.04489728f, -0.02753564f, -0.05292865f, -0.01873213f, 0.02121664f, -0.03651248f, 
    -0.01474419f, -0.03295974f, -0.05891012f, 0.02286700f, 0.01376720f, 0.01745854f, 0.00197764f, -0.01660078f, 
    -0.03195840f, 0.01763149f, 0.00866027f, -0.05467737f, 0.04195659f, 0.02276134f, 0.00188514f, 0.01502587f, 
    -0.04657277f, 0.01079918f, -0.01622021f, -0.00274023f, 0.02904652f, -0.02714832f, -0.06215335f, 0.01012684f, 
    0.01814979f, 0.03152200f, 0.03609410f, -0.01390939f, 0.01128992f, 0.04204674f, 0.01980960f, -0.05849474f, 
    -0.03834661f, 0.04347507f, 0.00195250f, -0.05218261f, -0.00353171f, 0.01740145f, -0.03528377f, -0.06126225f, 
    -0.00425784f, -0.04219092f, 0.02024244f, 0.00049537f, -0.04361319f, -0.04166082f, -0.01218113f, 0.02551635f, 
    0.01901319f, -0.01899339f, 0.01832092f, -0.00470160f, -0.03668022f, -0.03048982f, 0.03162172f, -0.02521582f, 
    -0.03333183f, -0.05443475f, -0.02951381f, 0.04740165f, -0.05292455f, -0.05561176f, 0.04312620f, -0.01488925f, 
    0.03497831f, -0.06148336f, -0.03379080f, 0.04906916f, -0.04237930f, -0.00443956f, -0.05403692f, 0.00844883f, 
    -0.05353011f, -0.03402132f, -0.02268806f, -0.03574974f, 0.02871228f, -0.01681399f, 0.03597927f, 0.03509204f, 
    -0.00246999f, -0.03564987f, -0.02512701f, -0.01722379f, -0.03325184f, 0.04060286f, -0.02072755f, 0.03928495f, 
    0.04543550f, -0.02719091f, 0.00993837f, -0.05321233f, 0.00552013f, 0.01427166f, 0.00277563f, -0.03330444f, 
    -0.00499763f, -0.00110261f, 0.04059027f, -0.02215297f, 0.02736860f, 0.03438031f, 0.02340089f, -0.00643888f, 
    -0.05339427f, -0.04051157f, 0.04517940f, 0.01302002f, -0.01405638f, 0.02576666f, 0.00092439f, 0.02089249f, 
    0.04253080f, 0.03841216f, 0.00653926f, -0.05191367f, -0.00469094f, 0.03683489f, 0.01815171f, 0.03417360f, 
    -0.01994355f, 0.05431425f, -0.00119464f, 0.05357676f, 0.04529544f, 0.02153982f, 0.04187004f, -0.05008906f, 
    -0.05141434f, 0.02250386f, -0.01459052f, -0.00948440f, 0.00021466f, -0.04275604f, -0.05994171f, 0.01315685f, 
    0.03079943f, 0.01676629f, -0.03907013f, -0.01724721f, -0.05418829f, 0.01263677f, 0.04180967f, -0.01361436f, 
    0.03472380f, 0.00540845f, -0.03524334f, -0.04016560f, -0.00884367f, -0.02149799f, -0.02695361f, -0.02839883f, 
    -0.05149995f, -0.00995057f, -0.01292963f, 0.04283724f, 0.04454750f, 0.00322026f, 0.01578745f, 0.01231934f, 
    -0.00805980f, 0.01568418f, -0.02328001f, 0.03609900f, -0.01398619f, -0.05690702f, -0.01858184f, 0.04158394f, 
    -0.02541061f, 0.03376601f, -0.04854384f, 0.01165523f, -0.02623479f, 0.03354857f, 0.01688965f, -0.02498586f, 
    0.03137359f, -0.02910750f, 0.03460019f, 0.00439365f, -0.03869558f, -0.03498157f, -0.00719759f, 0.03156324f, 
    0.02266952f, 0.03753973f, 0.03668746f, -0.04374056f, 0.02913033f, 0.04858794f, -0.04012571f, -0.04400829f, 
    -0.01619134f, 0.00027308f, 0.05430127f, -0.03781260f, -0.01767020f, 0.03991709f, 0.02313843f, -0.00896406f, 
    0.01587275f, -0.05908735f, -0.04633719f, -0.03000318f, -0.02147547f, 0.02403789f, 0.00659951f, -0.06561670f, 
    0.07875823f, -0.02275871f, 0.02523273f, -0.17183815f, -0.05174971f, 0.06376769f, 0.03886829f, 0.10970259f, 
    0.03572595f, 0.05273597f, 0.02660397f, 0.13360153f, -0.07138152f, 0.09895321f, -0.04942750f, -0.09983710f, 
    -0.00553858f, -0.10179184f, -0.06211705f, 0.05517029f, -0.12932859f, 0.12871866f, 0.16804270f, -0.08671038f, 
    -0.17344742f, 0.03187666f, 0.06226172f, -0.00294900f, 0.09904388f, -0.05909452f, -0.06872085f, 0.04772389f, 
    0.00725323f, 0.14486898f, 0.01566560f, -0.03491655f, 0.00830735f, -0.03229154f, -0.12803639f, -0.03733776f, 
    0.29917005f, -0.06612702f, 0.09687809f, -0.04861348f, -0.15203981f, -0.09907951f, -0.05087577f, -0.05889311f, 
    -0.02331966f, -0.02066492f, 0.00371035f, -0.11184473f, -0.02768644f, -0.03814397f, 0.06236721f, 0.07400490f, 
    0.14835246f, 0.02062272f, 0.03099723f, 0.02424216f, 0.33225521f, -0.00640424f, 0.10689511f, -0.02497001f, 
    0.03789843f, -0.14682640f, 0.01976523f, -0.07487032f, -0.05661312f, 0.03640556f, 0.07676888f, 0.02188828f, 
    -0.07588186f, -0.04368554f, 0.02400416f, -0.08869284f, 0.02218603f, 0.02331886f, -0.04105558f, 0.05543358f, 
    0.18752477f, -0.00667373f, -0.02436384f, -0.05687027f, 0.02750176f, 0.00527492f, 0.05463217f, -0.02040648f, 
    -0.12510563f, -0.02331273f, 0.00652036f, -0.05799878f, 0.04846249f, -0.02879222f, 0.03036642f, 0.01772707f, 
    0.03421718f, 0.09122195f, 0.07983418f, -0.02881422f, 0.46474087f, -0.05724417f, 0.10062336f, 0.12158244f, 
    0.06865938f, -0.15097040f, 0.04127124f, 0.06527516f, -0.00889976f, -0.00212250f, 0.12910394f, -0.01090362f, 
    -0.00690033f, 0.07894988f, -0.01897239f, 0.07416028f, -0.02041919f, 0.04256347f, 0.05374699f, 0.06403305f, 
    0.28763065f, -0.04992086f, 0.12658146f, -0.07468433f, -0.01547200f, 0.03610790f, -0.11526473f, 0.01023027f, 
    0.05582923f, 0.01515980f, 0.03859195f, 0.04997706f, 0.02324218f, -0.06795660f, 0.02646763f, -0.02195818f, 
    0.02434331f, -0.13621038f, -0.01264272f, -0.04380357f, -0.03606989f, -0.10225794f, 0.10163876f, -0.18050717f, 
    -0.08918433f, -0.02692980f, 0.08657490f, 0.09628915f, -0.05471532f, 0.02854245f, 0.01703741f, 0.10524729f, 
    0.05152854f, 0.09786374f, 0.03764183f, 0.04023566f, 0.00465225f, -0.03124896f, -0.09249265f, 0.05240899f, 
    0.11704787f, -0.02878784f, -0.07943814f, 0.01979727f, -0.04925714f, 0.06476606f, 0.03423640f, 0.00781355f, 
    -0.03637855f, 0.02939072f, 0.00470610f, -0.01626045f, 0.05155394f, 0.07254452f, -0.02588590f, 0.05820626f, 
    -0.03073594f, -0.09102812f, -0.06375664f, -0.08539788f, 0.03995746f, 0.07203786f, -0.02894555f, 0.07558893f, 
    0.12072973f, 0.12968725f, 0.07895166f, -0.05271887f, -0.10545437f, -0.09555129f, -0.03128548f, -0.04468045f, 
    -0.02739372f, 0.09536938f, -0.09023854f, 0.00250076f, 0.08427700f, 0.10098226f, -0.06923949f, -0.05021565f, 
    -0.26762861f, -0.00360008f, 0.18048488f, -0.06062330f, 0.06797930f, -0.04105105f, -0.03554409f, 0.09660501f, 
    -0.01176829f, 0.12560120f, 0.03697179f, -0.03958968f, -0.01984412f, -0.02725347f, 0.05985317f, -0.05586059f, 
    0.08159266f, 0.01312598f, 0.02601965f, 0.01092688f, -0.01086215f, 0.21270017f, -0.12771645f, 0.07473489f, 
    -0.05389787f, -0.05509479f, 0.01450864f, -0.14792900f, -0.11063244f, 0.04283373f, -0.01535100f, -0.01400565f, 
    0.05709487f, 0.00080717f, -0.07520223f, 0.08384393f, 0.02046318f, 0.05373310f, 0.04463002f, 0.03851235f, 
    0.03962148f, 0.17863421f, -0.15060709f, -0.05644744f, 0.05431831f, 0.10772616f, 0.07864256f, 0.07535049f, 
    0.05943791f, -0.06090049f, 0.10108250f, -0.02151449f, -0.05817655f, 0.04596985f, 0.05717400f, 0.18398739f, 
    0.11526921f, 0.01610049f, -0.04953660f, 0.08713784f, -0.05123423f, -0.11945144f, -0.13436411f, -0.02649323f, 
    0.16046323f, 0.18277970f, 0.02242118f, 0.01929366f, -0.01654387f, 0.07206777f, 0.05614768f, -0.07658071f, 
    0.09521591f, 0.03160273f, 0.07943556f, 0.04607617f, 0.06224177f, -0.00399960f, -0.10535371f, -0.07606571f, 
    0.16230319f, 0.13701995f, 0.08403163f, -0.02510758f, 0.03982235f, 0.03749509f, 0.03352471f, 0.08516455f, 
    0.07069446f, -0.01570437f, -0.00204908f, 0.03171622f, -0.11906289f, 0.08060905f, 0.01975352f, -0.01492404f, 
    0.01716865f, 0.10360323f, 0.12742607f, 0.07553999f, 0.23714699f, -0.10066016f, -0.04837791f, -0.04278788f, 
    0.09227840f, -0.07820678f, -0.02490803f, -0.14096321f, -0.02635995f, 0.08853170f, -0.00426692f, 0.04058491f, 
    -0.01515697f, 0.04465922f, 0.07748316f, 0.07963277f, 0.00933769f, 0.03196819f, 0.00885924f, 0.06568695f, 
    0.25895533f, 0.11927218f, -0.11095901f, -0.11518674f, 0.15875265f, 0.00307103f, -0.00935086f, -0.01975308f, 
    -0.04334766f, -0.11673917f, -0.03938657f, -0.00490151f, 0.03024513f, -0.10852937f, -0.07633132f, 0.04601546f, 
    0.01467568f, 0.22925141f, 0.10778160f, 0.02910741f, 0.02723131f, -0.10425325f, -0.18799086f, 0.13653015f, 
    0.12154227f, -0.05062732f, 0.01304727f, 0.00945901f, -0.09869758f, -0.07726327f, -0.00732010f, -0.09226285f, 
    -0.03576784f, -0.04398346f, 0.03391176f, -0.12675409f, -0.03145026f, -0.00488584f, 0.02842779f, -0.01691141f, 
    0.08584531f, 0.03881772f, 0.14575371f, -0.14803356f, 0.05653927f, 0.00983868f, 0.02711182f, -0.12430781f, 
    -0.02940918f, 0.02555332f, 0.08186343f, 0.00199084f, 0.03460971f, 0.07934567f, 0.02137263f, -0.04826358f, 
    0.00654512f, 0.03112088f, 0.01941838f, -0.04421359f, -0.17078759f, -0.11898992f, 0.03725613f, 0.06698143f, 
    0.09970775f, 0.01898760f, 0.09877674f, -0.05445902f, 0.00113158f, -0.07097465f, 0.03770328f, 0.01473062f, 
    -0.04241131f, 0.10849316f, 0.01861422f, -0.00295569f, 0.13017629f, -0.09773725f, -0.05519743f, -0.05812596f, 
    0.07474535f, 0.12867244f, -0.04598674f, 0.17538951f, -0.17999449f, 0.06179189f, -0.06825219f, 0.07520323f, 
    -0.08684734f, 0.10772549f, -0.10932010f, -0.00718870f, -0.05864168f, -0.00346300f, 0.00670838f, -0.09706749f, 
    0.02674087f, -0.05604570f, 0.11060079f, 0.01707583f, 0.02808033f, 0.09654014f, 0.11837459f, -0.03432899f, 
    0.05752088f, 0.03343733f, 0.02906571f, -0.05319229f, -0.05182867f, 0.05181851f, -0.06707457f, 0.00037602f, 
    0.07413580f, 0.03496211f, -0.04658381f, 0.08421203f, -0.06407674f, 0.02791665f, -0.01441865f, -0.04056247f, 
    -0.00933498f, -0.07246391f, 0.26441911f, -0.11016252f, 0.10830216f, 0.00607743f, 0.13532434f, -0.05301668f, 
    0.07527968f, -0.07021677f, 0.08729743f, -0.03635387f, -0.08026143f, 0.09946930f, 0.00845317f, 0.01269685f, 
    0.05306219f, 0.05751143f, -0.03118408f, 0.01561865f, -0.10535039f, -0.05170442f, 0.03193291f, 0.03293608f, 
    0.11235740f, 0.05138974f, -0.03698311f, -0.12074551f, 0.08606369f, -0.08391662f, -0.02499009f, -0.04338528f, 
    -0.02869309f, -0.05484986f, -0.04697892f, 0.00109561f, -0.13111050f, 0.02000291f, -0.08047686f, -0.11850493f, 
    0.17646287f, -0.08871936f, -0.00382609f, -0.12834615f, 0.12578797f, 0.00235716f, -0.05164550f, -0.04135822f, 
    0.06156221f, -0.18394865f, 0.01227572f, 0.06253788f, -0.01222932f, 0.05771063f, 0.01365408f, 0.03287274f, 
    -0.03872304f, 0.05846494f, 0.00417152f, -0.07400588f, 0.28062966f, 0.23948069f, 0.05809399f, 0.05019210f, 
    0.22636254f, -0.15667994f, -0.04965774f, 0.15767126f, 0.07011517f, -0.10499745f, 0.04587648f, -0.00648083f, 
    0.00671657f, -0.12230831f, 0.01807949f, -0.02570226f, -0.08920497f, -0.11804549f, 0.01939742f, 0.00071420f, 
    0.12050489f, 0.20388110f, 0.06556197f, 0.13660195f, 0.16959210f, 0.05653469f, 0.01713735f, 0.01627940f, 
    -0.05051478f, -0.07369594f, 0.07739428f, -0.01983107f, -0.00390937f, 0.06740475f, -0.10921071f, 0.00863036f, 
    -0.00742733f, -0.00338113f, 0.13534926f, -0.13822044f, 0.03068410f, 0.13652641f, -0.05145818f, -0.09692707f, 
    -0.05126128f, 0.10185436f, -0.00432933f, 0.08120127f, 0.02852086f, 0.00734040f, 0.03325307f, -0.05581350f, 
    -0.05554597f, 0.03084585f, -0.17259316f, 0.01405327f, -0.06267033f, -0.03287739f, -0.03502173f, -0.03165514f, 
    0.39724922f, 0.35799223f, -0.03532350f, 0.07846680f, 0.25565028f, 0.02629450f, -0.03408565f, -0.10341786f, 
    -0.05078337f, -0.08040392f, -0.03053381f, -0.05109717f, 0.00483959f, -0.13894771f, 0.02018661f, -0.00563164f, 
    -0.05825042f, -0.03675522f, -0.06209457f, -0.09156896f, 0.28151309f, 0.16741286f, -0.12212444f, 0.10485637f, 
    0.00865557f, -0.07652852f, 0.04095022f, 0.07307927f, -0.01642148f, -0.09122866f, 0.01188131f, 0.00215465f, 
    0.04830953f, 0.04173639f, -0.03519287f, 0.04883458f, -0.02228214f, 0.01416989f, 0.10062087f, 0.08658883f, 
    0.11514137f, 0.18238771f, 0.05940742f, -0.04186592f, -0.10358190f, 0.09845518f, -0.10049178f, -0.03675346f, 
    0.00458354f, 0.12809114f, -0.00837375f, 0.08581180f, -0.04093776f, -0.10252932f, -0.02738448f, -0.05098990f, 
    0.11944085f, -0.11717928f, -0.07700944f, -0.08734220f, 0.40464967f, 0.00083963f, 0.05018437f, 0.08261918f, 
    -0.01130402f, -0.05509932f, 0.00001302f, 0.07202872f, 0.05748489f, 0.00107846f, -0.00390695f, 0.10715078f, 
    0.11941977f, 0.11310627f, 0.00618497f, 0.12611423f, 0.07142311f, -0.08365256f, -0.09141713f, 0.00476905f, 
    0.01467820f, -0.00166317f, -0.04215864f, -0.00393005f, 0.03445032f, -0.06076302f, -0.05551830f, -0.01571183f, 
    0.03759571f, 0.03566773f, 0.04446201f, 0.04362785f, 0.03936651f, 0.02301155f, -0.00692798f, 0.04488276f, 
    -0.02791720f, 0.03229939f, -0.02813361f, 0.02549640f, -0.04755571f, -0.00807673f, 0.01156520f, 0.04773482f, 
    -0.00645274f, -0.02514302f, -0.01778089f, 0.04114578f, 0.03250293f, 0.00382455f, -0.04828963f, -0.04262653f, 
    0.01290357f, -0.02695852f, -0.05325887f, 0.02630944f, 0.04641688f, 0.01627765f, 0.01826300f, 0.00304615f, 
    0.01620645f, 0.04204780f, -0.05174492f, -0.05349262f, -0.05785453f, 0.04418012f, 0.04368195f, -0.01946582f, 
    0.04485130f, -0.04512996f, -0.01884144f, 0.02029211f, 0.01554915f, -0.03353179f, -0.04729797f, -0.05330829f, 
    -0.05620357f, 0.02372746f, -0.00307521f, 0.00947820f, 0.00429204f, -0.01957272f, -0.01652801f, 0.04017270f, 
    -0.04998662f, -0.04403178f, -0.04925129f, -0.00151820f, -0.01189332f, 0.04721731f, -0.04218492f, -0.00925935f, 
    -0.03300106f, -0.05784285f, 0.00821726f, -0.05767633f, -0.04880679f, 0.00550325f, 0.02421884f, -0.04681909f, 
    0.00263756f, -0.02081092f, 0.03575906f, -0.04310411f, -0.03500353f, 0.02422694f, 0.00720121f, -0.04370384f, 
    -0.02929452f, 0.03648067f, 0.03934970f, -0.05978416f, -0.05290774f, 0.00816404f, -0.02944226f, 0.03804029f, 
    -0.04099660f, 0.01036264f, -0.01328378f, 0.01413582f, 0.00047892f, -0.02979378f, 0.03433153f, -0.01048338f, 
    -0.01263109f, -0.00833234f, 0.01959337f, -0.02440425f, -0.05063676f, -0.02951871f, -0.05436412f, -0.05871699f, 
    0.02562146f, -0.01516224f, -0.04421115f, -0.00998551f, -0.03033883f, -0.02448686f, 0.03191125f, -0.00149759f, 
    -0.05795408f, -0.02399768f, 0.02533292f, 0.02051129f, 0.02414340f, -0.02012422f, 0.02945287f, -0.01480078f, 
    0.04674407f, -0.04598340f, 0.01071247f, 0.01223739f, -0.06132005f, -0.05627549f, 0.01413186f, -0.00762154f, 
    -0.01602676f, -0.03535109f, -0.03607003f, 0.03487371f, 0.02946734f, -0.04398045f, 0.00400249f, 0.00853626f, 
    0.04880963f, 0.04327967f, 0.02666610f, 0.01433773f, -0.03104250f, 0.04724819f, 0.03290042f, 0.03651258f, 
    -0.03002929f, 0.00007971f, -0.05826969f, 0.00996059f, -0.02458597f, -0.00575780f, 0.01357980f, 0.03250115f, 
    -0.02741294f, 0.03328291f, -0.03976544f, 0.04039330f, -0.00095875f, -0.06080810f, 0.03957882f, -0.00786565f, 
    -0.05568446f, -0.02285301f, -0.05496439f, -0.02987667f, 0.03492366f, 0.04657979f, -0.01124577f, -0.04922154f, 
    -0.01270610f, 0.02808529f, 0.04284378f, -0.05610117f, 0.01679838f, -0.05184783f, -0.03918199f, -0.02285093f, 
    -0.03217577f, -0.03478796f, -0.04055678f, -0.04662455f, -0.00274554f, -0.00336610f, -0.04545231f, -0.01604308f, 
    0.00891165f, 0.04480972f, 0.04851688f, 0.03366176f, -0.01268682f, 0.00398970f, 0.02823049f, 0.01107108f, 
    -0.05287436f, -0.03398638f, 0.00985561f, -0.05161107f, -0.03069261f, -0.00912297f, -0.05080380f, -0.01648469f, 
    -0.03695380f, -0.03844319f, 0.02425212f, -0.05876986f, -0.03124960f, -0.02215374f, 0.04507737f, 0.00863278f, 
    -0.04527856f, -0.04950020f, -0.00867616f, -0.01059336f, -0.00309873f, 0.01448396f, -0.04073118f, -0.01233222f, 
    -0.04874586f, -0.00036194f, 0.02610322f, -0.03140189f, 0.02538463f, 0.00163348f, 0.00862608f, 0.00464854f, 
    -0.02348017f, 0.01675989f, -0.04449366f, -0.03290861f, 0.04673361f, -0.02000155f, 0.03520567f, -0.01785037f, 
    -0.01705469f, -0.03155742f, -0.03706410f, 0.00154542f, -0.02378757f, -0.02585877f, -0.04534996f, -0.05223601f, 
    0.00246987f, -0.03329746f, 0.03145163f, -0.03715232f, 0.04529314f, -0.01421038f, -0.05433703f, 0.01578258f, 
    -0.02474134f, 0.00683950f, -0.01002954f, 0.04661951f, 0.03831734f, 0.02404048f, -0.01979636f, -0.06067332f, 
    0.01311873f, 0.03500110f, 0.04457469f, 0.04435050f, 0.04137614f, -0.01560722f, -0.03410644f, 0.04829800f, 
    0.01652550f, 0.02163110f, 0.03973003f, 0.04373510f, 0.02925607f, 0.04830115f, -0.03482527f, 0.00211263f, 
    -0.03493849f, 0.02762844f, 0.00334782f, -0.05717378f, -0.03381105f, 0.01887030f, 0.00360036f, -0.03094602f, 
    0.02453100f, 0.03167965f, -0.04146562f, -0.01624863f, -0.05343310f, 0.00049076f, -0.02048287f, -0.04561077f, 
    0.05310542f, -0.03907446f, -0.04923506f, -0.02301202f, -0.02929009f, 0.05570596f, 0.00757347f, -0.02773256f, 
    0.04672379f, -0.04791698f, 0.01608025f, -0.04209557f, 0.01297953f, -0.03162893f, -0.03016126f, -0.03652408f, 
    0.03601755f, -0.00655969f, -0.03936908f, 0.02544257f, -0.00931441f, 0.05383990f, -0.05385784f, 0.04562927f, 
    -0.13834505f, 0.10445851f, 0.25920552f, 0.14189695f, 0.11608647f, -0.07273363f, -0.00680314f, -0.10520981f, 
    0.06359597f, -0.03099345f, 0.10086443f, -0.08256004f, -0.00071323f, -0.01219012f, 0.05364839f, 0.01176897f, 
    -0.02353130f, -0.12629688f, -0.08769958f, -0.06394811f, 0.14706799f, 0.11240518f, 0.08298015f, 0.04869856f, 
    0.16787961f, 0.05388691f, -0.05740449f, 0.00632028f, -0.00162994f, -0.02025407f, -0.01495158f, 0.02063581f, 
    0.09102508f, 0.06428577f, 0.00720464f, 0.11479311f, 0.08442736f, 0.04472250f, -0.05869987f, 0.04674826f, 
    -0.16373275f, 0.04238464f, -0.11156236f, 0.08440841f, -0.05401034f, -0.00236514f, -0.00517627f, 0.03346829f, 
    -0.02258056f, -0.06778728f, -0.03234871f, -0.00357309f, 0.04601985f, 0.04419402f, 0.05946561f, 0.10391840f, 
    -0.00236218f, 0.07679382f, 0.03639623f, 0.07528215f, 0.08587751f, 0.14142641f, 0.06571835f, -0.05408125f, 
    -0.10167583f, 0.04311247f, 0.06331433f, 0.14507399f, 0.04787043f, -0.05018049f, -0.04191493f, 0.04669843f, 
    0.01424854f, -0.14693159f, -0.06447592f, 0.02409052f, -0.06213225f, 0.01706161f, -0.00909138f, 0.00236303f, 
    0.01343368f, -0.21069229f, 0.19434984f, 0.06492727f, 0.13604794f, 0.04107007f, 0.04747986f, -0.14514355f, 
    -0.03293693f, 0.03111144f, 0.02094644f, 0.04658115f, 0.06867423f, 0.02689178f, 0.07611082f, 0.06170306f, 
    0.03068051f, 0.04059328f, -0.05173363f, 0.13338171f, -0.08609918f, 0.08966462f, 0.04842023f, -0.05247020f, 
    -0.00484495f, 0.05435605f, -0.05217602f, 0.03105907f, 0.07271429f, -0.05172915f, -0.01665555f, 0.11585074f, 
    -0.11660119f, 0.02246657f, 0.04010095f, -0.03093050f, 0.10447387f, -0.00217039f, -0.00641408f, 0.01384932f, 
    0.01209127f, 0.34362444f, 0.00496789f, 0.10316695f, 0.02860138f, -0.00907268f, 0.02757493f, 0.10478054f, 
    -0.00433761f, 0.00729495f, -0.04519261f, 0.02285814f, 0.03402828f, -0.07720011f, -0.06083832f, -0.02560871f, 
    0.10368969f, -0.05349595f, 0.03521466f, 0.07032245f, 0.14730729f, 0.02802600f, -0.06470031f, 0.10460725f, 
    0.01234412f, 0.03727523f, -0.03767066f, 0.05586640f, 0.01357341f, 0.06573591f, -0.02849606f, -0.02169137f, 
    0.03490682f, 0.01695887f, 0.06839233f, 0.09380396f, 0.10236763f, 0.01574908f, -0.00291666f, 0.04792422f, 
    0.01996217f, 0.03290122f, 0.18593352f, 0.17611809f, 0.13969277f, 0.00356550f, -0.06339423f, 0.04602220f, 
    0.01686512f, 0.10227316f, -0.05191679f, 0.02667427f, -0.00631534f, -0.01724856f, 0.04524292f, -0.09100164f, 
    -0.00879685f, 0.03689525f, -0.07531258f, 0.09752185f, -0.11600875f, -0.11328226f, -0.17455637f, -0.07285833f, 
    -0.08521885f, 0.12611528f, 0.10973126f, -0.06945411f, -0.16412528f, -0.07525985f, 0.01057577f, -0.06012488f, 
    0.05514701f, 0.10372390f, 0.14081115f, 0.00684663f, 0.04081476f, 0.11228186f, 0.03022241f, 0.01367280f, 
    0.02418095f, 0.09348629f, 0.19448033f, -0.06238660f, -0.01401332f, 0.09635663f, 0.09704223f, 0.04905181f, 
    0.08157165f, 0.01307388f, -0.11311551f, 0.09540307f, 0.01173796f, 0.01010934f, -0.02152284f, 0.05173593f, 
    0.02520339f, 0.09266022f, -0.08562788f, 0.17601244f, 0.04265807f, -0.24831955f, 0.13920984f, 0.13561621f, 
    0.01362295f, 0.11124144f, 0.07203629f, -0.11913937f, -0.02784413f, 0.02346317f, 0.00461355f, 0.11059212f, 
    -0.00371930f, 0.00473807f, 0.09907486f, -0.01165686f, 0.02936796f, -0.01294987f, 0.06448331f, 0.06785002f, 
    -0.12115937f, -0.18184860f, -0.05270954f, -0.00937314f, -0.02668990f, -0.06119824f, -0.05314421f, 0.01647037f, 
    0.07626928f, 0.08903919f, 0.05314607f, -0.00997242f, 0.00052972f, 0.02932168f, 0.03147129f, 0.05139283f, 
    0.04966702f, 0.11222549f, 0.03124613f, 0.03570210f, -0.21210742f, -0.05598982f, 0.15934148f, 0.00157226f, 
    0.01324553f, 0.00426374f, -0.10768826f, -0.06863187f, -0.00132402f, 0.04389292f, 0.07629856f, 0.01021979f, 
    -0.05629082f, 0.06455708f, 0.08764554f, -0.01177598f, -0.00152469f, -0.06341934f, -0.02789564f, -0.07319219f, 
    -0.14431588f, -0.03531348f, 0.02567233f, -0.07552656f, 0.18564178f, -0.04354269f, 0.09970354f, 0.11378669f, 
    0.02265451f, -0.00798329f, 0.08093105f, 0.03226758f, 0.05086873f, 0.04746573f, 0.00908152f, 0.08322299f, 
    0.07621110f, 0.04792167f, -0.06302129f, 0.17968094f, -0.31338596f, 0.20945753f, 0.04508281f, -0.03801405f, 
    -0.14143679f, 0.06836320f, 0.04486877f, -0.03385096f, -0.03437496f, -0.07218384f, 0.07376144f, -0.01039720f, 
    0.01998277f, 0.03085818f, -0.04230402f, -0.03972030f, 0.07373343f, -0.03484609f, 0.03623970f, -0.00743014f, 
    0.03197727f, 0.01203143f, -0.02830016f, 0.02543342f, 0.03424968f, 0.01086847f, 0.04739825f, -0.03997048f, 
    -0.04504075f, -0.05525934f, -0.06520403f, -0.04425529f, 0.03917185f, 0.00839156f, -0.02757664f, -0.01063942f, 
    0.01990042f, -0.01344880f, 0.02247729f, 0.01016656f, -0.01789216f, 0.03136313f, 0.01578069f, 0.00025602f, 
    -0.00202437f, -0.01544429f, 0.03376253f, -0.03236560f, -0.00405424f, -0.05349663f, -0.00041288f, -0.04771383f, 
    -0.04300484f, 0.02459946f, -0.00361579f, 0.01404139f, 0.04590403f, -0.00292248f, -0.01431391f, 0.04871623f, 
    0.01392164f, -0.02651806f, 0.03754146f, -0.00290941f, 0.02293676f, 0.00832287f, -0.02901165f, -0.02668803f, 
    -0.01292791f, 0.00301510f, -0.03028806f, -0.00200682f, 0.03656004f, -0.02331400f, -0.00525528f, 0.00096379f, 
    -0.01721794f, -0.00189838f, 0.00353587f, 0.04278639f, -0.00888413f, -0.06492854f, 0.01852869f, -0.03782979f, 
    -0.02721765f, -0.00433872f, 0.01821094f, 0.00656945f, 0.04407963f, 0.03183600f, 0.03004866f, -0.03802701f, 
    -0.00577705f, -0.01148968f, -0.05165660f, -0.00809427f, 0.03013873f, -0.04240654f, -0.00179621f, 0.03000506f, 
    -0.04929800f, -0.00427650f, -0.02902529f, 0.03708819f, -0.04669880f, -0.03789763f, -0.05566895f, -0.02965610f, 
    0.01754640f, -0.01469252f, -0.05042645f, -0.04761465f, -0.02802007f, -0.03491961f, -0.03345728f, -0.00931770f, 
    0.03511020f, 0.02223822f, -0.04467655f, -0.04389067f, -0.02823697f, 0.02139820f, -0.04044195f, 0.01890475f, 
    -0.03512886f, 0.04465488f, -0.04853458f, -0.04027480f, -0.00018228f, -0.02728591f, -0.03729103f, -0.00419518f, 
    0.05393440f, -0.02675524f, 0.03784540f, 0.01080055f, -0.03722084f, 0.04718954f, -0.00892356f, -0.00629244f, 
    0.02319555f, -0.06230954f, -0.03158713f, 0.04504557f, -0.03755721f, -0.04028206f, -0.06003074f, -0.01669616f, 
    0.04507110f, -0.06322970f, -0.01277746f, 0.01252482f, 0.01729354f, 0.01167828f, -0.00033683f, -0.04852627f, 
    -0.05819186f, -0.01945499f, -0.06414431f, 0.03525522f, 0.01988200f, 0.04072597f, -0.03771885f, 0.02987696f, 
    -0.03704631f, -0.03790467f, 0.03224876f, 0.02018363f, -0.05476332f, 0.04484971f, 0.04923758f, -0.04072400f, 
    0.02720394f, -0.04716466f, 0.01971179f, -0.01720501f, -0.04075002f, -0.03654870f, -0.02774932f, -0.04008315f, 
    -0.02313524f, -0.04866477f, 0.01560195f, 0.02093233f, -0.00929418f, -0.00436152f, 0.03279771f, -0.00117484f, 
    -0.00917370f, 0.03127774f, 0.00907611f, 0.01272552f, 0.00742978f, -0.03007260f, -0.00707339f, -0.04978549f, 
    -0.02315000f, -0.02567447f, 0.02131436f, -0.01145076f, -0.01313908f, 0.02662194f, 0.04387663f, 0.01840077f, 
    0.00302009f, -0.03212718f, -0.05896433f, -0.01465105f, -0.05809140f, -0.00851404f, 0.01665554f, 0.00387470f, 
    -0.00311182f, 0.02018882f, 0.03418784f, -0.02645054f, -0.00299053f, 0.01589926f, 0.03235644f, -0.01557612f, 
    -0.06335096f, -0.04372442f, 0.02226880f, -0.02581259f, 0.02507954f, 0.00271337f, 0.00660904f, -0.00320708f, 
    0.02005688f, -0.03482946f, 0.03747153f, 0.01351449f, 0.00628607f, 0.00937645f, -0.02395811f, 0.01003558f, 
    -0.04160753f, -0.02581166f, -0.01582635f, -0.00762708f, -0.03285850f, 0.02004744f, -0.00296390f, -0.01140499f, 
    -0.04610197f, -0.00916934f, 0.00232604f, 0.01957436f, 0.02707430f, 0.03647248f, 0.05767144f, -0.05683725f, 
    -0.03937160f, 0.01283046f, 0.02257077f, 0.03874459f, 0.03083714f, -0.02568320f, 0.01196375f, 0.01985414f, 
    -0.03381265f, 0.00285330f, -0.04865898f, -0.02063764f, -0.04071689f, 0.01342559f, 0.00062136f, -0.02973531f, 
    -0.02361302f, 0.01582168f, -0.02721086f, -0.00462864f, -0.03609524f, -0.02125587f, 0.03943948f, 0.04347612f, 
    -0.02607570f, -0.03043347f, -0.05420013f, -0.06188314f, 0.00863623f, -0.00809529f, -0.05323754f, -0.01848226f, 
    -0.04751406f, -0.05611591f, 0.01016436f, -0.05583081f, 0.01175077f, 0.00963855f, -0.04350551f, 0.02969826f, 
    0.02395523f, 0.00130345f, -0.02649311f, 0.02622505f, -0.03186526f, -0.03806797f, -0.05378061f, 0.01310632f, 
    -0.01769100f, 0.03082303f, 0.00461520f, 0.05111012f, -0.06395546f, -0.05571733f, -0.00094069f, 0.01551573f, 
    -0.04765984f, 0.03305914f, -0.05880704f, 0.00598545f, 0.02135074f, -0.03375648f, 0.02079302f, 0.01180789f, 
    -0.01210491f, 0.03909471f, -0.04979269f, -0.00030090f, -0.01164473f, -0.06322084f, -0.05070745f, -0.02627659f, 
    -0.05799224f, -0.02246491f, -0.02318076f, -0.00896202f, 0.00895649f, 0.04732323f, 0.04216734f, 0.02540703f, 
    0.03541163f, -0.03645742f, -0.06584131f, -0.02653171f, -0.06910872f, -0.04343618f, -0.00472723f, -0.01489318f, 
    -0.02019374f, -0.41750669f, 0.16997860f, 0.15485263f, 0.05408388f, 0.00334357f, 0.06189264f, -0.04289097f, 
    0.01931035f, 0.04284166f, -0.09590562f, -0.06457576f, 0.05557729f, 0.10613907f, 0.08731087f, 0.01162182f, 
    -0.03756876f, -0.00195704f, -0.04221993f, -0.03834032f, -0.08394404f, -0.03456353f, -0.02234001f, 0.06943086f, 
    -0.12662514f, 0.04975270f, 0.03033079f, -0.08314274f, 0.14894937f, -0.01225885f, -0.04701145f, -0.04889883f, 
    0.13217048f, 0.00502238f, 0.04652609f, 0.06843759f, 0.02636394f, 0.02959230f, 0.01406445f, 0.03803480f, 
    -0.26710990f, -0.17631195f, -0.12564491f, 0.08055626f, -0.13002253f, 0.06408093f, 0.06085471f, 0.18367569f, 
    0.07189638f, 0.02472460f, -0.09374810f, -0.01037225f, 0.07995912f, -0.00111980f, 0.07561313f, 0.08595154f, 
    0.07042785f, 0.02225349f, 0.11396364f, 0.12504089f, 0.17634249f, 0.13798314f, -0.08682653f, -0.10592789f, 
    -0.29701567f, 0.13986549f, 0.08416771f, 0.04438795f, 0.10094230f, 0.02029099f, -0.05557815f, -0.00425326f, 
    -0.01007571f, 0.04331521f, -0.00744542f, -0.00255312f, -0.00912652f, -0.05172475f, -0.00396321f, 0.09054052f, 
    0.17612135f, 0.03087622f, -0.07432811f, 0.14864346f, 0.18427749f, -0.00606709f, 0.01966725f, -0.19038086f, 
    0.00660151f, -0.04875392f, 0.01932829f, 0.08885191f, 0.08048273f, 0.00398318f, 0.04824376f, 0.07540909f, 
    -0.00708798f, 0.12183417f, 0.04276634f, 0.05455752f, -0.12151174f, 0.06894696f, -0.27989879f, -0.02885477f, 
    -0.14253268f, 0.09137806f, 0.07915866f, 0.06130296f, 0.13946085f, 0.04349610f, 0.01297283f, 0.03089416f, 
    -0.07438542f, 0.00453569f, 0.03533267f, 0.10162906f, -0.01565469f, -0.04322216f, -0.06507478f, 0.08216057f, 
    0.23001173f, 0.10903358f, -0.04669677f, -0.03813173f, -0.16092046f, 0.05747332f, 0.02381724f, 0.04815259f, 
    0.04482787f, -0.00110556f, -0.03517682f, 0.10432185f, 0.01249958f, -0.00497500f, 0.01790786f, 0.07966856f, 
    0.06444623f, -0.02039171f, -0.08586716f, 0.08931234f, -0.09858739f, -0.19584541f, -0.11452433f, 0.10546828f, 
    -0.08036461f, 0.13260740f, 0.03340410f, 0.12693320f, 0.02962193f, 0.09453506f, -0.03231997f, -0.04612201f, 
    0.09232011f, -0.04325810f, -0.04445528f, 0.00117332f, -0.01593432f, -0.08295532f, -0.05032080f, 0.11359923f, 
    0.09844026f, -0.26475874f, 0.00074129f, 0.24940243f, -0.05864919f, 0.02188447f, 0.05804766f, 0.02872976f, 
    0.09577066f, 0.07839326f, 0.01004293f, 0.03735149f, -0.07712267f, -0.04648781f, -0.03351905f, 0.03145845f, 
    -0.05876157f, -0.01482631f, -0.09295496f, 0.09327146f, 0.14684755f, 0.20682012f, 0.09159014f, -0.03855309f, 
    0.13577241f, -0.00647562f, -0.11627489f, -0.03838621f, -0.06723029f, -0.06760997f, -0.07713686f, 0.06435803f, 
    0.00098191f, 0.03015109f, -0.01268367f, 0.05005234f, 0.06566980f, 0.09944134f, -0.00993584f, 0.02393194f, 
    -0.14706002f, -0.07416796f, 0.01831813f, -0.07731879f, -0.00599785f, 0.09269555f, 0.07335110f, -0.04752605f, 
    0.04089473f, 0.10909505f, 0.02030279f, 0.03299940f, 0.05669421f, -0.00860346f, -0.02444378f, 0.01477191f, 
    0.00261850f, 0.01968982f, -0.01804956f, 0.05939304f, 0.02393752f, 0.01818733f, -0.11350878f, 0.00415324f, 
    0.03299179f, 0.18819445f, 0.09308995f, -0.13203180f, -0.01958735f, -0.02620880f, 0.13981526f, -0.00209810f, 
    -0.01486683f, 0.00512679f, 0.07305714f, -0.04041942f, -0.02224731f, 0.15336877f, 0.06521739f, 0.06869014f, 
    0.23703961f, -0.09251012f, 0.05353523f, 0.08895501f, -0.12543249f, -0.05857614f, -0.02584871f, -0.09518120f, 
    0.06993572f, 0.10447020f, -0.01318700f, 0.01251675f, 0.00736357f, 0.09218849f, 0.06906344f, 0.00243348f, 
    0.02809986f, -0.02011144f, 0.03304680f, 0.05106246f, -0.08605341f, 0.10165893f, 0.20508443f, 0.00088095f, 
    0.14909641f, -0.12187915f, -0.19371390f, -0.11024314f, -0.01134701f, 0.02235322f, -0.06235391f, 0.08741780f, 
    -0.01630168f, -0.00376713f, 0.12091086f, 0.02547426f, -0.09856585f, -0.04920697f, -0.02708101f, -0.00221435f, 
    -0.20868151f, -0.04100955f, -0.13223979f, 0.05783978f, 0.18818592f, 0.07125676f, 0.06414083f, -0.05737427f, 
    0.04498116f, -0.01237213f, -0.05000528f, -0.06277442f, 0.02220681f, -0.01235778f, 0.00263732f, -0.02102455f, 
    -0.01146097f, 0.01038483f, 0.03037107f, 0.04802885f, -0.12071575f, 0.15899046f, 0.37458116f, 0.06374811f, 
    -0.00067631f, -0.03772977f, 0.01922890f, 0.01234304f, -0.14413169f, 0.07930626f, -0.04991937f, 0.02724195f, 
    0.06026211f, -0.01569349f, -0.07271123f, 0.04357602f, -0.00083009f, -0.01181583f, -0.00691095f, -0.03097753f, 
    0.01270514f, -0.02428990f, -0.01155746f, 0.04197771f, -0.04592229f, 0.04208530f, 0.04643922f, 0.01402286f, 
    0.01242348f, 0.05482893f, -0.01240006f, -0.01693659f, 0.03836817f, -0.02092844f, 0.03518005f, -0.03142576f, 
    0.01886860f, 0.04641531f, 0.00407955f, 0.00504027f, -0.04802753f, -0.02192697f, 0.01350996f, -0.01774458f, 
    0.03281071f, -0.00298913f, -0.02222954f, -0.00590345f, -0.01091212f, 0.03805573f, -0.01916368f, 0.01149770f, 
    0.02865595f, -0.04066293f, -0.04524662f, -0.03944112f, 0.04404981f, -0.02321965f, -0.02704106f, 0.02862154f, 
    0.03172683f, 0.02499199f, -0.02196173f, -0.01074765f, -0.05325867f, 0.00768454f, -0.03820296f, -0.00448861f, 
    -0.05614101f, 0.03813257f, 0.00865879f, -0.02786834f, -0.03987171f, 0.01628601f, -0.02062970f, -0.04692387f, 
    -0.04815042f, -0.04760053f, 0.02896808f, -0.03061414f, -0.00835121f, 0.01941468f, -0.00577613f, -0.00239721f, 
    0.01215697f, -0.04003742f, -0.01958700f, -0.06181302f, -0.03362017f, -0.02667177f, -0.01164137f, -0.00987783f, 
    -0.04289627f, 0.01682844f, -0.02756801f, 0.02478907f, -0.02043314f, 0.02950936f, -0.00202177f, 0.01477823f, 
    -0.05406594f, 0.03849437f, -0.04113420f, -0.03716629f, -0.06289205f, -0.03504625f, -0.00462175f, -0.04785990f, 
    -0.00138799f, 0.03056006f, 0.03985589f, -0.02003074f, -0.03768729f, 0.04195521f, 0.01660537f, 0.02676260f, 
    -0.05503254f, 0.02730763f, -0.05916701f, 0.02254408f, 0.04304968f, -0.02616164f, -0.01778170f, -0.00330854f, 
    -0.06370808f, 0.02943984f, -0.00266233f, 0.03270322f, -0.03721068f, -0.05361110f, -0.01727600f, -0.05641397f, 
    -0.00998272f, 0.01117803f, -0.03734474f, -0.00990351f, -0.03940697f, -0.00931042f, 0.02401669f, 0.04570958f, 
    0.00154037f, -0.03384905f, -0.05901275f, -0.03334977f, -0.01183168f, 0.00164418f, -0.05275541f, -0.00015148f, 
    -0.02102615f, -0.02298233f, 0.02131017f, -0.03807839f, -0.04830746f, -0.05711002f, 0.02431346f, -0.03742560f, 
    0.01868764f, 0.01748877f, 0.03154278f, -0.00426447f, -0.02057016f, 0.02571334f, -0.01063666f, 0.04712948f, 
    -0.01399131f, -0.03466803f, 0.01530661f, -0.03507540f, 0.04467963f, 0.01875925f, 0.00997310f, 0.01299851f, 
    0.01695548f, 0.03373951f, 0.02463164f, -0.01122841f, -0.00869904f, -0.04766960f, 0.00715423f, -0.03876530f, 
    0.01045944f, -0.05212282f, 0.00269443f, -0.03776871f, 0.01269518f, -0.01580335f, -0.01685205f, -0.05997392f, 
    0.00835572f, 0.03761035f, 0.03860585f, 0.01223372f, -0.02734891f, -0.00699491f, 0.00624389f, -0.00559735f, 
    0.00871362f, 0.00009000f, -0.04985573f, 0.03386823f, 0.02289699f, 0.00774878f, 0.02282283f, -0.00101530f, 
    -0.04442089f, -0.03779565f, 0.01643198f, -0.02113687f, -0.04077240f, 0.02807674f, 0.04153714f, -0.03851211f, 
    -0.05614167f, -0.01540183f, 0.02133364f, -0.03419435f, -0.05274396f, 0.00585719f, 0.04706524f, -0.01731352f, 
    -0.00457576f, -0.05806451f, -0.03481028f, -0.00623635f, 0.02310914f, 0.01008950f, -0.00973351f, -0.01326417f, 
    0.01923517f, 0.02054843f, 0.04334016f, -0.01146726f, 0.04010782f, -0.02538563f, -0.04119953f, -0.00617813f, 
    0.02269412f, 0.00393782f, -0.04271755f, 0.00903475f, 0.01221022f, -0.04984365f, -0.01101469f, 0.02232209f, 
    0.00813769f, 0.00011886f, 0.05140625f, 0.01681398f, -0.05418430f, -0.01540619f, -0.03700221f, 0.04558033f, 
    -0.04845173f, 0.00151980f, 0.03170891f, -0.04927004f, -0.01227739f, -0.04655231f, -0.03129612f, -0.00100226f, 
    0.02700374f, -0.04785542f, 0.00755614f, -0.04808273f, 0.03356108f, -0.02332404f, 0.04520616f, -0.01630187f, 
    -0.05388721f, -0.05731232f, -0.00372838f, -0.04508546f, 0.00403592f, 0.01021605f, -0.05904947f, -0.05120183f, 
    -0.00244006f, 0.04687113f, 0.03446811f, -0.03065765f, 0.02206728f, 0.02868383f, 0.02279440f, -0.05478314f, 
    0.03576757f, -0.03476819f, -0.00127495f, -0.04595412f, -0.04480416f, -0.00982844f, 0.04156878f, -0.05127191f, 
    -0.00421279f, -0.02540013f, 0.00431398f, 0.01977878f, -0.01955981f, 0.04706205f, -0.03186416f, 0.02117398f, 
    0.02688032f, 0.01954267f, 0.02650901f, 0.04554734f, 0.04328852f, 0.02105253f, -0.02543259f, 0.03780400f, 
    -0.05607166f, 0.02650464f, 0.03549660f, 0.02196447f, -0.04267038f, 0.03083026f, 0.04476909f, -0.03130535f, 
    -0.02716306f, -0.03981912f, -0.02853826f, 0.04687894f, -0.00317960f, -0.01239664f, 0.01924419f, -0.01360350f, 
    0.02423819f, -0.01834853f, -0.02829598f, -0.06025283f, -0.01700194f, -0.06630959f, -0.02022298f, -0.04631126f, 
    0.00949688f, -0.00930988f, -0.05544740f, 0.01591809f, 0.00193839f, 0.03888485f, -0.00816788f, -0.05323475f, 
    -0.27736136f, -0.02575777f, -0.17346473f, -0.18877061f, 0.23785025f, -0.01457037f, -0.09442512f, -0.07562952f, 
    0.02407228f, -0.02983732f, 0.04744589f, 0.05608942f, -0.11258601f, 0.09668992f, -0.09715372f, -0.05898848f, 
    -0.02223044f, -0.07726695f, -0.05008982f, 0.05849530f, 0.01169917f, 0.14526363f, -0.19712630f, -0.21412452f, 
    0.11443080f, 0.02206641f, -0.01056659f, 0.09455720f, 0.08512833f, 0.00927454f, 0.00856406f, -0.06054814f, 
    0.01863744f, -0.00425084f, 0.08223598f, 0.04250592f, -0.06715604f, 0.01097151f, -0.02652459f, 0.01422829f, 
    -0.23571679f, -0.16322358f, -0.36314371f, 0.03380467f, 0.00508613f, -0.01774972f, 0.11667893f, -0.00056740f, 
    -0.02385701f, 0.02257146f, 0.03601591f, 0.12381986f, 0.03997343f, 0.13513091f, -0.04466352f, 0.06946541f, 
    -0.03029428f, -0.08969648f, -0.04697596f, 0.02906964f, -0.11180161f, -0.16841877f, -0.09514414f, -0.12561007f, 
    -0.06373086f, 0.10192697f, 0.04164221f, -0.11415156f, -0.07409732f, 0.00088958f, 0.01483673f, 0.04436945f, 
    -0.01010630f, -0.06302927f, 0.05057328f, -0.01321335f, -0.07607460f, 0.00046539f, -0.11226237f, 0.00041416f, 
    0.28970033f, 0.02266536f, 0.01620514f, -0.08726337f, -0.05316462f, 0.03130117f, 0.06037138f, -0.09090846f, 
    -0.10562247f, 0.05725151f, 0.04836064f, 0.03103783f, 0.04873917f, 0.05979428f, 0.01248581f, 0.02650963f, 
    -0.05380271f, 0.07405402f, -0.03684532f, -0.02378442f, -0.12687656f, -0.29738417f, -0.13838662f, -0.08704951f, 
    -0.05235368f, 0.10582701f, -0.03524396f, -0.00884404f, -0.04471790f, -0.05576783f, 0.06728186f, 0.07236335f, 
    0.10067574f, -0.05124782f, 0.09881265f, 0.01457270f, 0.01046253f, -0.06766164f, -0.00444621f, 0.04108476f, 
    -0.15347664f, -0.17963922f, -0.25626439f, -0.17760316f, 0.17266306f, 0.10327386f, 0.02878686f, -0.11287561f, 
    -0.03628090f, -0.04095302f, 0.01329590f, -0.00928795f, 0.06793473f, -0.10236767f, 0.00186781f, 0.06059629f, 
    -0.02753690f, -0.02081670f, 0.06436682f, -0.03023128f, 0.02196138f, -0.07341871f, -0.23589522f, -0.03662854f, 
    0.09814258f, 0.03087728f, -0.00431444f, 0.11987862f, -0.00436090f, -0.01645878f, -0.00641266f, 0.09391622f, 
    0.03303437f, 0.06822530f, 0.14312878f, 0.05050165f, 0.05578827f, -0.04144082f, 0.01949076f, -0.03654490f, 
    -0.06625736f, -0.01758280f, -0.21451655f, -0.11834013f, 0.22110257f, 0.03715278f, 0.07131924f, 0.06208608f, 
    0.01311036f, -0.06969897f, -0.05815656f, 0.01383824f, 0.05601807f, 0.00031090f, -0.03447290f, -0.00937108f, 
    0.21013135f, 0.00589098f, -0.02315097f, 0.11803071f, 0.28634274f, 0.16547063f, 0.27890328f, 0.26448485f, 
    -0.08893747f, 0.04416925f, 0.04203721f, -0.01967822f, -0.00581514f, 0.00991441f, -0.07388873f, 0.05263037f, 
    0.06683159f, 0.04696568f, 0.02804477f, -0.01747878f, -0.00537775f, 0.04549930f, 0.01100616f, -0.03847564f, 
    -0.25495118f, -0.26686385f, -0.15803806f, -0.26210877f, 0.08019717f, 0.05272796f, -0.05808943f, -0.07116000f, 
    0.02611967f, 0.09373512f, -0.02983708f, 0.02606537f, 0.00851294f, -0.01971458f, 0.00293628f, -0.02447222f, 
    0.09823029f, 0.01672110f, 0.02708784f, 0.03447469f, -0.14556856f, -0.15261261f, 0.10376035f, 0.06106219f, 
    -0.16503714f, 0.02266291f, -0.01628120f, -0.07411467f, 0.07730941f, 0.02840019f, 0.11490612f, 0.06473527f, 
    0.06750271f, 0.02159423f, -0.05875247f, -0.01944014f, -0.06592182f, -0.02499535f, -0.07955566f, 0.00632715f, 
    -0.05490207f, 0.14083710f, 0.11915123f, 0.11041845f, 0.10251583f, -0.02995538f, -0.06592973f, 0.14103857f, 
    0.01291888f, 0.05972874f, -0.00197365f, -0.10813706f, 0.01272852f, 0.05032589f, -0.07994460f, 0.06445353f, 
    -0.06452194f, 0.00049684f, -0.01917469f, -0.00266788f, 0.18086417f, 0.02848555f, 0.09286770f, 0.06083861f, 
    -0.13079117f, -0.00933497f, 0.11164509f, 0.05307451f, -0.02118017f, 0.01731207f, -0.07806554f, 0.07739288f, 
    0.08969826f, 0.02705277f, 0.05292148f, 0.06673972f, 0.04129022f, 0.10442710f, 0.05583466f, 0.08250654f, 
    -0.16333289f, 0.10884327f, 0.10322724f, 0.07658887f, -0.01504793f, 0.08718849f, -0.00277802f, -0.00473795f, 
    0.01275272f, -0.00254309f, -0.13067612f, -0.02697662f, -0.03868115f, -0.00704639f, -0.00504043f, -0.01416359f, 
    -0.02184953f, 0.13314091f, 0.03667902f, 0.09332975f, -0.19926286f, -0.13793713f, -0.03390150f, -0.02123301f, 
    -0.05703654f, 0.14190817f, 0.08395842f, -0.09400469f, -0.10999814f, -0.02366618f, -0.03471520f, -0.10433170f, 
    -0.01626538f, -0.08102965f, -0.07613331f, -0.04747182f, 0.04947482f, 0.09070334f, 0.07009536f, 0.04370994f, 
    -0.08244456f, 0.22209048f, -0.21080056f, -0.01006506f, -0.18784001f, 0.00364847f, -0.05031846f, -0.06077670f, 
    -0.03754915f, -0.06681298f, -0.05190808f, 0.03240361f, 0.01753783f, 0.04706074f, 0.08107444f, -0.02504576f, 
    -0.04908019f, 0.09388816f, -0.16890416f, 0.00750380f, 0.06621165f, -0.20438613f, -0.02840732f, -0.02750712f, 
    0.27390885f, 0.02530813f, -0.08837175f, 0.00024531f, -0.02608900f, 0.00907910f, 0.06704286f, 0.07800394f, 
    -0.05429281f, 0.02371680f, -0.00768118f, 0.01238909f, -0.05566497f, -0.01809731f, -0.02975013f, 0.07173762f, 
    -0.13184145f, 0.05928491f, 0.09047902f, 0.09250651f, 0.18497749f, 0.09214728f, 0.07643163f, 0.15471996f, 
    0.01639044f, 0.02704933f, 0.11509933f, 0.08084049f, -0.13809094f, 0.00058839f, -0.04694945f, -0.01012668f, 
    -0.08033269f, -0.03058817f, 0.09412951f, 0.01585150f, -0.20558484f, 0.05456421f, 0.07895313f, 0.19190279f, 
    0.15932684f, 0.13733418f, -0.04082136f, 0.09552708f, -0.00549029f, 0.13599409f, -0.05124310f, -0.02253351f, 
    -0.00828210f, 0.00994665f, -0.07252970f, -0.01693144f, -0.06438157f, 0.02990084f, 0.05677307f, -0.09169797f, 
    0.01347456f, 0.05642159f, -0.00833934f, -0.09000343f, -0.08485175f, -0.04369171f, -0.05035195f, -0.00046657f, 
    0.05328071f, 0.09724340f, -0.00550085f, 0.04081810f, 0.01828765f, 0.01657851f, -0.04442944f, -0.03280250f, 
    0.01401347f, -0.12642100f, -0.07200731f, -0.02510160f, -0.21893141f, 0.08101057f, 0.08646717f, 0.03529692f, 
    0.12357810f, 0.10454216f, 0.07502974f, 0.04280198f, 0.03733484f, -0.01267038f, -0.01843193f, 0.00476474f, 
    -0.04848351f, -0.02154411f, -0.10957588f, -0.07832778f, 0.07126396f, -0.00822903f, 0.10568681f, -0.08942690f, 
    -0.48517174f, 0.11263186f, 0.05388048f, 0.01451536f, 0.07271177f, -0.02295767f, 0.01385677f, -0.08033960f, 
    0.02769602f, 0.09146896f, -0.03975092f, -0.00952243f, -0.07176798f, 0.08323047f, -0.00793774f, 0.02441321f, 
    -0.06219757f, 0.02477598f, 0.12185202f, -0.00087261f, 0.07606383f, 0.01275609f, -0.01191870f, 0.05463243f, 
    0.15027438f, 0.01548792f, -0.00813538f, -0.00990972f, 0.09938794f, -0.00792901f, 0.05279849f, 0.03449272f, 
    -0.01403901f, 0.06333882f, 0.00639002f, -0.07182583f, 0.09014418f, -0.01918894f, 0.06917845f, -0.00525797f, 
    -0.14151046f, -0.12934783f, 0.03922311f, -0.09220674f, 0.06882128f, -0.07804917f, 0.04440711f, 0.02050391f, 
    -0.00070153f, -0.03522790f, -0.03947720f, -0.03926553f, 0.00078413f, 0.10584526f, -0.02110688f, -0.08567598f, 
    -0.03748807f, -0.03467168f, 0.10122541f, 0.04586993f, 0.11525674f, -0.09990195f, 0.10637420f, -0.07753304f, 
    -0.00658741f, 0.03764221f, 0.06714363f, -0.06092041f, -0.05969733f, 0.05931358f, 0.03030965f, -0.05834423f, 
    0.01031724f, -0.04023426f, 0.10976679f, 0.08307242f, 0.06839176f, -0.10729793f, 0.10890020f, 0.04693905f, 
    0.16573292f, -0.01512367f, 0.03289498f, 0.08072459f, 0.16721819f, 0.07138337f, -0.03997515f, -0.08309989f, 
    0.03347313f, -0.08453792f, -0.00144540f, 0.02302554f, 0.03990321f, -0.03865222f, 0.00829072f, -0.01238390f, 
    0.01119072f, 0.02746321f, -0.05871107f, -0.01204474f, 0.13133381f, -0.21080092f, 0.11920752f, 0.06795708f, 
    0.07429970f, 0.01455251f, 0.01668477f, 0.08395045f, 0.07211453f, -0.01317351f, 0.05744525f, -0.08151779f, 
    0.04474779f, -0.01987482f, -0.00151868f, 0.04317700f, 0.05300516f, -0.00587494f, -0.02765435f, 0.03570608f, 
    -0.06759179f, -0.20180917f, 0.08849774f, 0.00562133f, 0.01913802f, -0.05718111f, -0.09371690f, -0.07071887f, 
    -0.08271046f, 0.00627916f, 0.00205662f, -0.04524349f, -0.01875552f, 0.02861028f, -0.00188432f, -0.15493481f, 
    0.04890484f, -0.02732050f, -0.02477810f, 0.00121824f, 0.04241168f, -0.05722411f, 0.24853049f, 0.03014426f, 
    -0.08526037f, -0.05048366f, 0.02170095f, -0.04860272f, -0.00551730f, -0.08902264f, -0.02744666f, -0.00621772f, 
    0.03945191f, -0.08796801f, 0.07555763f, -0.02817003f, 0.05193240f, -0.02799527f, -0.00526639f, 0.01376357f, 
    0.24847676f, 0.07534522f, -0.02836191f, -0.03340178f, -0.03835188f, -0.16535361f, 0.01790468f, 0.00722265f, 
    -0.07444592f, 0.12377872f, 0.07769746f, -0.01965947f, -0.06499674f, -0.03730219f, 0.07376051f, -0.00025406f, 
    0.01194684f, -0.00762665f, -0.02866860f, -0.02917930f, -0.08695386f, 0.35269850f, -0.17523611f, -0.09017446f, 
    0.15555653f, 0.16186181f, -0.03503329f, 0.02748028f, 0.07401884f, 0.01562061f, 0.04912483f, 0.05632538f, 
    -0.05778630f, -0.07932197f, -0.01682235f, -0.06370868f, 0.00667013f, -0.08404519f, 0.05435788f, -0.08079053f, 
    0.10894652f, -0.33114815f, 0.06450465f, 0.09391758f, -0.09245033f, 0.13782296f, 0.10668209f, 0.13899258f, 
    0.04287796f, 0.06482878f, 0.02233655f, 0.08965988f, 0.07651981f, 0.07804809f, 0.08945820f, 0.00919211f, 
    -0.00894103f, 0.10440397f, -0.04037398f, 0.06261292f, -0.04912889f, 0.11816882f, -0.00269757f, 0.17778046f, 
    -0.20069547f, -0.01364827f, 0.09738050f, 0.06143867f, 0.11209782f, 0.11912485f, 0.01972003f, 0.12260940f, 
    0.06569353f, 0.06133122f, 0.00581373f, 0.06645160f, 0.06639995f, -0.00955115f, 0.10156858f, -0.01000548f, 
    0.23051426f, 0.08966600f, -0.05217256f, 0.11979355f, -0.10849347f, -0.02588253f, -0.02731006f, -0.05187823f, 
    0.04118934f, 0.13988456f, -0.00401031f, -0.17230543f, 0.03688433f, -0.10574803f, -0.02313997f, 0.11604094f, 
    0.19388053f, 0.07416631f, 0.05019895f, 0.01667736f, 0.16376437f, 0.00996356f, -0.07285787f, 0.05332712f, 
    -0.10549407f, -0.09216395f, -0.00948925f, -0.03343775f, 0.12491305f, 0.12570830f, 0.01375918f, -0.01895392f, 
    0.11687888f, 0.14645649f, -0.08365542f, -0.05874219f, 0.00995168f, 0.08524499f, -0.04763386f, -0.01990079f, 
    -0.18595466f, 0.22817731f, -0.23056689f, -0.05936744f, 0.04571416f, 0.02894948f, 0.14777556f, 0.00839555f, 
    0.09206580f, -0.02856911f, 0.09677672f, -0.00939578f, 0.01863609f, 0.07334629f, 0.01840102f, 0.13864148f, 
    0.00465185f, 0.08813588f, 0.03060682f, 0.07053111f, 0.25732756f, 0.03323212f, -0.10397742f, 0.11334438f, 
    -0.06969812f, -0.04499418f, 0.03382191f, 0.01715679f, 0.04789403f, 0.21791391f, 0.05961428f, 0.04717265f, 
    0.03525230f, 0.07858009f, -0.05610003f, 0.08601566f, 0.06705792f, 0.01067136f, 0.02309853f, 0.06543972f, 
    0.17103891f, -0.07386306f, -0.14014706f, 0.09176461f, -0.13785450f, 0.06086609f, -0.09722622f, 0.01323834f, 
    0.06178285f, 0.06928816f, 0.00975813f, -0.03734595f, 0.01162486f, 0.03095913f, -0.00567011f, -0.00598000f, 
    -0.06957973f, 0.13000038f, 0.00476399f, -0.06377549f, 0.09923045f, 0.07189278f, 0.03579013f, 0.03782995f, 
    -0.08582997f, -0.09982476f, 0.11622243f, 0.04694324f, 0.04954069f, 0.11096910f, 0.00257342f, -0.02181732f, 
    0.03307663f, 0.08246745f, -0.02698651f, -0.00907300f, 0.10848282f, 0.05669937f, 0.14667536f, 0.11647163f, 
    -0.08587508f, 0.03677348f, 0.02980878f, 0.16140376f, -0.10896632f, -0.03316313f, -0.02756716f, 0.00065506f, 
    0.06221668f, 0.11508208f, 0.06879215f, -0.02327602f, 0.01341621f, -0.00050199f, -0.01943766f, 0.13471796f, 
    -0.01234951f, -0.00303741f, 0.14049636f, 0.04756990f, -0.20788251f, -0.13928837f, -0.00439328f, -0.09304075f, 
    -0.02694521f, 0.00330930f, -0.03612560f, -0.00598002f, 0.06703387f, -0.02403334f, -0.02322143f, -0.00280942f, 
    -0.02947735f, -0.00072029f, -0.00420070f, 0.04502625f, 0.05324257f, 0.00178362f, -0.08611562f, 0.02695870f, 
    0.06807866f, -0.09876523f, -0.13260987f, 0.22862642f, -0.02815517f, -0.15627442f, -0.06457273f, 0.01967060f, 
    -0.01361389f, 0.06508268f, 0.09557481f, 0.09174757f, 0.00646798f, 0.07395991f, 0.10000444f, -0.07411972f, 
    -0.09737962f, -0.05077545f, 0.04841976f, 0.09914442f, 0.03893049f, 0.26766247f, -0.17453888f, -0.31000593f, 
    -0.01847506f, -0.00060696f, -0.00343030f, -0.03258130f, 0.08338995f, 0.06389859f, 0.05874310f, -0.04502260f, 
    0.02481900f, 0.01768562f, 0.02265137f, -0.01021598f, 0.13586424f, 0.00229246f, -0.00495785f, 0.07269175f, 
    -0.10559613f, 0.04022178f, 0.01583790f, 0.04300293f, -0.03918321f, 0.10919813f, 0.07048127f, 0.05693257f, 
    0.05221091f, 0.00233614f, 0.14950287f, 0.10542196f, 0.00146851f, 0.04368053f, -0.04445577f, 0.07221244f, 
    0.14739725f, 0.02895582f, -0.01342174f, 0.05768278f, 0.04367393f, -0.03944985f, -0.00313997f, -0.02513178f, 
    0.18419726f, 0.05726068f, 0.06547732f, 0.02180468f, -0.03256603f, 0.04185214f, 0.01880266f, -0.04287195f, 
    0.08071404f, 0.04794365f, -0.01347383f, 0.10873636f, -0.00511490f, 0.00368924f, -0.05495354f, 0.08841141f, 
    0.22622696f, -0.14450197f, -0.00256356f, 0.05114665f, -0.03164139f, 0.02895976f, 0.06350486f, 0.05008728f, 
    0.07968895f, 0.03825479f, -0.06185746f, 0.04532189f, -0.01450407f, 0.06983855f, 0.01802870f, 0.07157280f, 
    -0.05549150f, 0.09760635f, 0.06790756f, 0.02360676f, -0.02872128f, 0.06048382f, 0.00655292f, -0.13732576f, 
    0.09416671f, 0.12281132f, -0.01641227f, 0.02424844f, 0.06751478f, 0.16938813f, 0.05384744f, 0.09793154f, 
    0.07714019f, 0.05159737f, 0.05073286f, 0.02325495f, -0.01024159f, 0.01867959f, -0.00003125f, 0.08342076f, 
    0.11759922f, 0.14989407f, 0.14594641f, 0.02923131f, 0.14162952f, -0.09054704f, 0.03600315f, -0.01890334f, 
    0.04411962f, 0.10271674f, 0.02047473f, -0.06826850f, 0.02945359f, -0.14398269f, -0.03570367f, 0.02262466f, 
    0.01862021f, -0.06341201f, -0.06050971f, 0.01274507f, 0.21462226f, 0.01946903f, 0.18362397f, 0.00780644f, 
    0.13812132f, 0.09804537f, 0.04798380f, -0.05442706f, -0.07235757f, -0.01027477f, 0.03660951f, 0.00450308f, 
    0.02831089f, 0.04008187f, -0.13565040f, -0.04421474f, 0.07923449f, -0.00489012f, -0.07174135f, 0.08831542f, 
    -0.05117078f, 0.01295678f, 0.06112001f, -0.05073091f, -0.00261613f, 0.03036093f, 0.06040091f, 0.00799638f, 
    0.09412417f, 0.10768601f, 0.00556653f, 0.07882223f, 0.04714542f, -0.02346010f, -0.03008823f, 0.03464217f, 
    0.03550555f, -0.03764385f, 0.02665119f, -0.02662061f, 0.02902796f, 0.00213603f, -0.07002009f, -0.01709910f, 
    0.05491818f, 0.00168336f, 0.02575365f, 0.15281157f, 0.04451677f, -0.01920977f, -0.07977208f, 0.10983440f, 
    -0.03029722f, -0.06873406f, 0.05935486f, 0.00903888f, -0.09945422f, 0.00386856f, 0.08615321f, 0.03920190f, 
    -0.10858554f, -0.12442996f, 0.03102343f, -0.06757067f, -0.09083107f, 0.19090125f, -0.06547634f, -0.02096605f, 
    -0.03334937f, 0.08863460f, 0.01698736f, 0.03937071f, -0.03474000f, -0.03656723f, 0.03632751f, 0.02551362f, 
    -0.04429338f, -0.01989218f, -0.06428376f, 0.05090268f, 0.06241219f, -0.15699759f, 0.07035335f, -0.12220347f, 
    0.01555487f, -0.01069568f, 0.00414086f, 0.02524741f, 0.03004113f, -0.05783931f, -0.02479702f, 0.07099512f, 
    -0.07452835f, 0.06378382f, -0.00576065f, 0.01129627f, 0.09750858f, 0.07386631f, 0.12223135f, -0.05490293f, 
    -0.16218284f, 0.12924935f, -0.05029254f, 0.06996465f, 0.08721417f, -0.04334347f, 0.10138660f, 0.00927021f, 
    0.08658251f, -0.07450408f, 0.01477838f, 0.00038913f, 0.00293249f, -0.00491679f, 0.02062827f, 0.02909573f, 
    0.04877955f, -0.10508813f, 0.13229100f, 0.10441522f, 0.16305973f, 0.11810042f, 0.08128767f, 0.20679663f, 
    0.11528660f, 0.11252832f, 0.01206431f, -0.01464819f, 0.06052452f, -0.00007511f, 0.04102448f, 0.01007976f, 
    0.02254791f, -0.02729704f, -0.03502412f, -0.05630201f, 0.03255004f, 0.09520036f, -0.00324746f, -0.03799151f, 
    -0.04379307f, 0.14812702f, 0.25506860f, 0.17376129f, 0.15748802f, -0.02521306f, 0.05603486f, -0.00741499f, 
    0.05693160f, 0.00813093f, -0.05971190f, -0.06023173f, -0.08156360f, -0.01494891f, -0.01217890f, 0.01936482f, 
    -0.02884444f, 0.05189501f, -0.02966970f, -0.03263014f, -0.45247141f, -0.30420730f, -0.09629232f, -0.00642926f, 
    -0.04710287f, -0.15651724f, -0.02155250f, -0.01230744f, 0.03304134f, -0.03145336f, -0.12782593f, -0.03105870f, 
    -0.06100781f, -0.03395960f, 0.09427632f, -0.06629371f, -0.01388576f, -0.00891662f, 0.03204598f, 0.10856957f, 
    0.10783441f, 0.06727394f, 0.03719973f, 0.03168771f, 0.07698298f, 0.08059769f, 0.09726232f, 0.01304395f, 
    0.04700749f, 0.01964054f, 0.00260299f, 0.01576626f, 0.00126246f, -0.00464926f, 0.01202356f, 0.02616843f, 
    -0.02519782f, 0.06046717f, 0.02966847f, -0.00413409f, -0.37203503f, -0.16613884f, 0.03909162f, -0.09244338f, 
    -0.05786641f, 0.04572819f, 0.05701311f, -0.11539759f, -0.01526235f, -0.05537987f, 0.09073394f, 0.08626679f, 
    -0.06552579f, 0.10490446f, 0.08147740f, 0.00216910f, 0.00595761f, -0.02493042f, 0.10154165f, 0.03646743f, 
    -0.09318803f, -0.08034321f, -0.01573961f, 0.04927252f, 0.04525709f, -0.19989899f, -0.01482001f, 0.08213108f, 
    -0.00996238f, -0.04330172f, 0.02877053f, -0.12316664f, 0.07363933f, -0.04481818f, 0.08479935f, -0.07656536f, 
    -0.07337482f, -0.03129863f, 0.06652562f, -0.00468591f, -0.01295530f, -0.04459016f, -0.09168347f, 0.14114471f, 
    0.03948789f, 0.10430322f, -0.08680654f, 0.04599147f, 0.03296209f, -0.06333172f, -0.18971498f, 0.04707551f, 
    -0.07454978f, -0.01479993f, -0.04801993f, 0.08359935f, -0.05441052f, -0.04939910f, 0.09540423f, -0.06823238f, 
    0.20498998f, -0.11350644f, 0.13456124f, -0.19029215f, 0.06087679f, -0.13482487f, 0.07895242f, 0.04814004f, 
    -0.14191453f, 0.03133089f, 0.03308287f, 0.08156204f, -0.02510362f, -0.04772745f, 0.02938624f, -0.01859390f, 
    -0.01037031f, -0.09872218f, -0.02090899f, 0.07136022f, -0.09380024f, 0.11366896f, -0.09772834f, 0.00958735f, 
    -0.13490696f, -0.02293204f, 0.02934160f, 0.00426773f, 0.00559025f, -0.15789396f, 0.04368086f, 0.04564301f, 
    -0.12059882f, -0.06586786f, 0.05103225f, -0.06995539f, 0.01973558f, 0.01770145f, 0.10891540f, 0.02112342f, 
    -0.08660865f, 0.34506631f, 0.13378268f, 0.17109047f, -0.21294554f, -0.00654635f, 0.07485389f, -0.01858397f, 
    0.03885203f, -0.04714929f, 0.01591948f, -0.00529799f, -0.05179986f, 0.01412328f, 0.07489352f, 0.04873753f, 
    0.02021970f, -0.03524309f, -0.00249311f, 0.02309289f, 0.16043150f, 0.03307651f, 0.09629534f, -0.02466035f, 
    0.11824044f, -0.06030885f, 0.01874289f, 0.01666835f, -0.06450862f, -0.02313330f, 0.08801626f, 0.07780775f, 
    0.02361208f, -0.02226821f, -0.03851631f, 0.00371904f, 0.11730692f, -0.08287185f, 0.05139322f, -0.01020443f, 
    -0.09181396f, 0.07157786f, -0.03401771f, 0.08233165f, 0.01900248f, 0.00600203f, -0.03604547f, 0.01933345f, 
    -0.00441123f, 0.02759204f, 0.08079814f, 0.07276864f, -0.02838487f, 0.00325562f, -0.01132115f, 0.07080908f, 
    -0.09300613f, -0.01514207f, 0.03168555f, 0.07738223f, -0.12335958f, 0.08780151f, 0.14563397f, 0.16699362f, 
    -0.03991158f, 0.03855119f, -0.07181986f, 0.11214729f, 0.00797686f, 0.10587465f, 0.03779255f, -0.00550541f, 
    0.10550454f, -0.01437473f, -0.01019605f, 0.01499127f, -0.07583980f, 0.01025011f, 0.05520486f, 0.05039690f, 
    -0.14690882f, -0.01911378f, 0.10368320f, -0.02019645f, 0.14510269f, -0.03767143f, -0.03013803f, -0.02054890f, 
    0.07136112f, -0.00189754f, 0.01892679f, -0.00418189f, 0.00905596f, 0.03527242f, 0.03787296f, 0.06280858f, 
    0.02169047f, -0.07091546f, 0.05693938f, 0.00959498f, -0.21678945f, 0.08351207f, -0.02213383f, 0.15127207f, 
    -0.04529972f, -0.00625019f, -0.00420974f, -0.00231242f, -0.01240381f, 0.11233195f, 0.02477468f, 0.07542329f, 
    -0.06131881f, 0.04543286f, 0.08288471f, 0.01178050f, 0.06579422f, 0.02507036f, 0.05850903f, -0.02367859f, 
    -0.13357273f, 0.07924376f, 0.01661561f, 0.28906968f, -0.12451032f, 0.02818064f, -0.09319542f, 0.06066170f, 
    -0.00219499f, 0.05653213f, -0.04811509f, 0.01869221f, -0.05551408f, -0.05339360f, -0.10035910f, -0.03651095f, 
    0.00074568f, 0.00698991f, 0.03670432f, -0.05239270f, 0.15835111f, -0.00144885f, 0.20101891f, 0.06036896f, 
    0.00618566f, -0.03636065f, 0.03769423f, -0.01321772f, 0.02479516f, 0.03067871f, 0.04406270f, -0.00085065f, 
    -0.01490534f, -0.01746455f, -0.00243110f, 0.05467004f, 0.07286025f, -0.02493082f, 0.04214033f, 0.03504889f, 
    -0.20417227f, -0.03318537f, 0.11815067f, 0.05230125f, -0.03363946f, -0.08118514f, -0.08356410f, 0.01634049f, 
    -0.00809118f, 0.00309024f, 0.08966962f, -0.01245589f, -0.09232987f, 0.02609814f, -0.01224241f, -0.03841786f, 
    0.00375272f, 0.06433762f, 0.10842565f, -0.00625919f, -0.17652898f, -0.30907479f, -0.19055794f, -0.15000461f, 
    0.04038178f, 0.08438118f, 0.05807931f, -0.08707277f, -0.01878873f, -0.02732227f, -0.00093395f, 0.02098723f, 
    -0.03879241f, -0.04608940f, 0.00605563f, -0.06385259f, 0.01536173f, -0.05101476f, 0.10609959f, 0.03218920f, 
    0.25770926f, -0.01075518f, -0.02556993f, 0.16128252f, -0.03653753f, -0.02934957f, -0.05746364f, -0.01293839f, 
    0.03532229f, -0.11177330f, -0.01224495f, 0.11224110f, 0.06905516f, -0.00046526f, 0.09604106f, 0.07489999f, 
    -0.03787336f, 0.06151289f, -0.09573559f, 0.03003845f, 0.36353901f, 0.07867152f, 0.13146503f, -0.03381336f, 
    0.07954513f, 0.07291281f, 0.06618072f, 0.03822153f, -0.01859054f, -0.05088903f, -0.01160152f, 0.00639836f, 
    0.06604280f, -0.00664550f, 0.04557120f, 0.06808914f, 0.00032896f, -0.05348531f, -0.00224430f, -0.03557566f, 
    -0.18296018f, -0.17280708f, -0.10043030f, -0.15457253f, -0.06205193f, -0.00279333f, 0.06711888f, -0.04213979f, 
    0.04002980f, -0.03720837f, 0.00641781f, 0.13127950f, 0.01823293f, 0.04014619f, -0.02181324f, -0.15083483f, 
    0.04396622f, 0.03034747f, 0.18218498f, 0.11163542f, 0.05568262f, -0.28947988f, -0.01130544f, -0.04894569f, 
    0.13995829f, -0.00841948f, -0.05265411f, -0.10927386f, 0.05362200f, 0.01728347f, 0.14036791f, -0.06593761f, 
    -0.08576160f, -0.04426279f, -0.05450039f, 0.05705982f, 0.15071645f, 0.06787591f, 0.00190963f, 0.04489017f, 
    0.00610430f, 0.02354725f, -0.14024571f, 0.00625886f, -0.06927372f, -0.09553467f, 0.04902557f, 0.04430756f, 
    -0.03814485f, -0.04152229f, 0.10830993f, 0.10103776f, 0.07177165f, 0.04386239f, 0.09750611f, 0.09531654f, 
    -0.02986565f, -0.05186567f, -0.00330023f, 0.03950629f, -0.17712156f, 0.18035138f, -0.01828137f, -0.03778589f, 
    0.06686667f, 0.03414298f, -0.08950105f, -0.01598796f, 0.07372593f, 0.00645455f, 0.08449318f, -0.06591117f, 
    0.05590960f, -0.03187259f, -0.00998250f, -0.02351305f, 0.10023779f, -0.05397576f, 0.06865486f, 0.05240879f, 
    -0.14271934f, 0.23569031f, -0.05561616f, -0.08356766f, 0.13166057f, -0.00604284f, -0.09426348f, -0.00553452f, 
    0.00149237f, 0.00113993f, 0.05172093f, -0.04099952f, 0.05729732f, -0.02730534f, 0.02733483f, 0.00856114f, 
    0.05137073f, 0.04849319f, -0.00317984f, 0.08603808f, -0.02843757f, 0.00638271f, 0.10414659f, -0.03272875f, 
    0.18444499f, -0.00150727f, 0.05872718f, -0.02401641f, 0.02148209f, 0.01211176f, 0.03539296f, -0.04807667f, 
    -0.03099729f, 0.03061450f, 0.14980198f, -0.05353626f, -0.00543229f, 0.10307622f, -0.03270919f, 0.08147774f, 
    -0.20190164f, 0.08743676f, -0.08310898f, -0.09090509f, 0.01368116f, 0.03454550f, 0.02285486f, -0.00373906f, 
    -0.06111072f, -0.02626505f, 0.04886174f, 0.15325180f, 0.02395494f, 0.12014101f, 0.04890621f, -0.10306684f, 
    -0.14494860f, -0.03949751f, -0.04966690f, -0.09618612f, -0.20742986f, 0.02630872f, -0.08371382f, -0.19472034f, 
    -0.03745158f, 0.05704562f, -0.02168927f, 0.04037572f, 0.03949483f, -0.07256968f, 0.02409721f, -0.04039847f, 
    -0.01416975f, -0.01436893f, 0.13626613f, 0.04927913f, 0.00649063f, -0.01211192f, -0.01057970f, 0.00841980f, 
    -0.10182726f, 0.11331426f, 0.05474036f, 0.22264463f, -0.06820130f, 0.07247379f, -0.11010946f, 0.07931053f, 
    -0.00152905f, 0.09930511f, -0.08208990f, 0.07822907f, -0.00416175f, -0.01362529f, 0.09187218f, -0.08742370f, 
    0.00484133f, -0.02386851f, 0.08185648f, -0.04282026f, -0.40520328f, 0.07781986f, -0.07509268f, -0.18298486f, 
    -0.00179904f, 0.16154823f, -0.04726990f, 0.03910352f, -0.00568335f, -0.05509493f, -0.01840801f, -0.02680288f, 
    0.06603398f, 0.00546189f, 0.02270155f, 0.01073291f, -0.01993201f, -0.03823325f, 0.05271560f, 0.05297861f, 
    0.00303570f, -0.07305035f, -0.03407682f, -0.12206101f, 0.03996000f, -0.11040690f, 0.16856052f, -0.03968580f, 
    0.00402757f, -0.09979230f, 0.01794136f, -0.00479352f, -0.05496801f, 0.05497655f, 0.12942252f, 0.08220455f, 
    0.02430415f, -0.07408758f, -0.01844978f, 0.13113247f, -0.04509804f, 0.18816152f, -0.04952484f, -0.06044235f, 
    0.10837557f, 0.06532165f, -0.10392269f, -0.08469413f, -0.01720669f, -0.08318648f, -0.06918234f, -0.02743894f, 
    -0.06000087f, 0.03292698f, 0.06268411f, 0.03227551f, -0.03789515f, 0.02213708f, -0.04346192f, -0.09351185f, 
    -0.04877173f, 0.15069619f, -0.03145133f, -0.11409523f, 0.14267099f, 0.07475118f, 0.01291105f, -0.00871556f, 
    -0.05365020f, -0.04134478f, -0.07256917f, -0.02637466f, 0.00276012f, -0.08433687f, 0.01828046f, -0.00859611f, 
    0.10770199f, 0.06337140f, -0.00485987f, 0.01161129f, 0.35869676f, 0.21195208f, -0.05605043f, 0.29620519f, 
    0.01848103f, 0.04207261f, -0.00594745f, 0.10673907f, 0.12242951f, 0.04501122f, 0.05187405f, 0.07594651f, 
    0.14377320f, -0.01520689f, 0.06034809f, -0.00046960f, -0.00317558f, -0.03278531f, 0.04181511f, 0.01081411f, 
    0.04740522f, 0.13686202f, -0.05465164f, -0.21681628f, -0.04112667f, 0.03105044f, 0.02469009f, -0.01374053f, 
    -0.01528711f, -0.01037590f, -0.05423447f, 0.01562918f, 0.07524096f, -0.03321458f, -0.13203616f, 0.04168883f, 
    0.16043206f, -0.00822487f, 0.02854146f, -0.03958926f, -0.34032577f, 0.05460011f, 0.05378293f, 0.21521515f, 
    0.10147444f, 0.01612668f, 0.10621390f, 0.11058684f, 0.14024492f, -0.01274576f, -0.01341754f, 0.05130441f, 
    -0.06691539f, 0.09927585f, 0.02731366f, -0.09279903f, -0.04229526f, 0.00116248f, 0.02185134f, -0.04362061f, 
    0.13417977f, 0.16332991f, 0.04624389f, 0.12910220f, 0.22657880f, 0.00227946f, 0.02082969f, 0.00171718f, 
    0.02647443f, 0.08814593f, -0.04021367f, -0.06456944f, 0.02703255f, 0.05586512f, 0.02826246f, 0.04600082f, 
    -0.13941115f, 0.04319128f, 0.04101356f, -0.05479387f, 0.20866539f, 0.12285974f, 0.00922959f, 0.15428729f, 
    -0.15534726f, -0.02428743f, 0.01681902f, 0.10532175f, 0.15374668f, -0.09614734f, 0.07421678f, 0.07306197f, 
    -0.01831536f, 0.01682496f, 0.11317188f, -0.04702692f, -0.03562687f, 0.07013313f, 0.21633293f, -0.00781397f, 
    -0.14811981f, 0.08787195f, 0.10998750f, 0.06669906f, -0.00545601f, 0.06089772f, -0.07746310f, 0.07369256f, 
    -0.03292133f, 0.08412749f, 0.06936764f, 0.07786322f, 0.01921947f, 0.01739557f, -0.03288267f, -0.00592765f, 
    0.15817684f, -0.02037805f, 0.00175305f, -0.05825741f, 0.01291869f, -0.14126594f, 0.03445331f, 0.07841440f, 
    -0.18203105f, 0.00404111f, 0.05249732f, -0.02051659f, 0.06096588f, -0.16963863f, -0.03534489f, -0.01646538f, 
    -0.02116119f, 0.06905919f, 0.00559676f, 0.05367472f, -0.01692593f, -0.02598201f, -0.05132353f, -0.00091106f, 
    -0.24244751f, 0.40509135f, -0.03630496f, 0.02979806f, -0.04575950f, 0.07409069f, -0.01955110f, -0.05077095f, 
    0.09030767f, -0.04954373f, -0.00653297f, 0.11493260f, 0.01125577f, -0.00196293f, 0.12371495f, 0.04469843f, 
    0.05960014f, 0.04428943f, -0.01030480f, 0.07435548f, 0.12922722f, -0.00530285f, -0.10630997f, -0.12046140f, 
    0.17056091f, -0.12885900f, -0.06834516f, 0.10496367f, -0.05074605f, 0.08174799f, 0.05155597f, 0.10476192f, 
    0.04276379f, -0.06862555f, 0.00797491f, 0.05434140f, 0.05455100f, -0.04731840f, 0.15531397f, 0.00360150f, 
    -0.01825379f, 0.04282272f, -0.08870169f, 0.22108451f, 0.03818697f, 0.02639480f, -0.02882260f, 0.04041649f, 
    -0.05660800f, -0.05094846f, 0.04751821f, 0.13743308f, -0.03397550f, -0.03942116f, 0.02693523f, -0.01814245f, 
    -0.07802742f, 0.09230871f, 0.05678427f, 0.09728108f, 0.07583242f, 0.00475648f, 0.18690889f, 0.14026093f, 
    0.01532449f, 0.12798694f, 0.00126290f, -0.04357466f, 0.02545821f, 0.09404308f, 0.05162697f, -0.09459712f, 
    0.09214979f, 0.04966861f, -0.03572497f, 0.00482386f, -0.04273954f, 0.04400302f, 0.03768841f, -0.04680261f, 
    0.28852731f, -0.15075086f, 0.21721359f, -0.09050171f, 0.18596032f, 0.04331554f, 0.08018363f, -0.05877582f, 
    0.04940167f, -0.00656409f, 0.04412810f, 0.00880777f, 0.05804515f, 0.10597862f, -0.01221114f, 0.01242460f, 
    -0.02449441f, -0.05710269f, -0.00908047f, -0.00611434f, -0.02333075f, 0.04532257f, -0.07443741f, 0.06608897f, 
    0.00538381f, 0.05847251f, 0.03238447f, -0.03737988f, -0.04309211f, 0.07105244f, 0.01613421f, 0.05876319f, 
    0.13353279f, -0.05033879f, 0.10995325f, -0.11090751f, -0.04164376f, -0.07367671f, 0.06382930f, -0.05653172f, 
    -0.04848990f, -0.05607303f, 0.10864627f, 0.22823490f, -0.00233614f, 0.03797766f, -0.00390349f, 0.06266648f, 
    -0.00272982f, 0.13523769f, -0.04308208f, -0.01360852f, 0.06177360f, 0.05698939f, -0.11105021f, -0.06726282f, 
    -0.03023900f, 0.06231247f, -0.00142484f, 0.00791501f, 0.07707401f, 0.05302175f, -0.03009957f, 0.03089535f, 
    0.09536361f, -0.09853074f, -0.04395026f, -0.02354245f, 0.04602126f, -0.00140775f, 0.04715684f, 0.01475647f, 
    -0.01834580f, -0.04897705f, 0.08064342f, 0.13714881f, 0.00544981f, 0.03098127f, 0.12012210f, -0.01930707f, 
    -0.06088132f, -0.02053379f, 0.08485989f, -0.10339522f, 0.01632592f, -0.01301387f, -0.02917913f, -0.01001186f, 
    0.00201428f, 0.00066444f, -0.02935382f, 0.02711385f, -0.00143911f, 0.10998446f, -0.08409642f, -0.02804051f, 
    0.11505864f, 0.06788109f, 0.10305603f, 0.07244616f, 0.17637277f, -0.11221908f, 0.01639678f, -0.16283175f, 
    -0.28612939f, 0.12400980f, 0.02057238f, -0.06779347f, -0.14333005f, -0.01530206f, 0.03697003f, -0.00361215f, 
    -0.07300211f, -0.01693213f, 0.08776204f, 0.07838340f, -0.07153354f, -0.10726551f, -0.04529553f, -0.01147240f, 
    0.30160579f, -0.01117136f, 0.02796791f, -0.03075928f, 0.00404729f, 0.02948856f, -0.14573477f, 0.01440930f, 
    -0.02152775f, -0.02799159f, -0.04552607f, 0.13706547f, 0.13274640f, 0.06743325f, 0.06629582f, 0.15963374f, 
    0.00994176f, 0.04249412f, -0.06041684f, 0.13330221f, 0.39362830f, -0.25818017f, 0.16417859f, 0.21936868f, 
    -0.14020097f, 0.07225959f, -0.04532496f, 0.03603196f, 0.09197760f, 0.02298785f, -0.07331686f, -0.03037575f, 
    0.10952710f, 0.03022214f, 0.01411913f, 0.08265943f, 0.03812398f, -0.09632379f, -0.13234776f, -0.06089173f, 
    -0.15005781f, 0.01335106f, -0.00430883f, -0.24715622f, -0.13391271f, 0.03023592f, 0.04947944f, 0.04885918f, 
    0.01172443f, -0.06665874f, -0.11756113f, -0.01187236f, -0.03261294f, -0.03466308f, -0.06756706f, -0.10620014f, 
    0.08835218f, 0.12653621f, 0.11171268f, 0.05096800f, 0.05030238f, -0.13876218f, 0.02682101f, -0.28576341f, 
    -0.15403116f, 0.00862331f, 0.10352180f, -0.14381358f, 0.01569165f, -0.05190066f, 0.07083299f, -0.04908035f, 
    -0.07128726f, -0.05830293f, 0.00773429f, 0.06550276f, 0.12696065f, -0.01124624f, -0.07522823f, 0.04095492f, 
    -0.35280555f, 0.16894095f, -0.04000635f, 0.20235085f, 0.00114714f, 0.06181262f, 0.03998733f, 0.10468114f, 
    0.07367454f, -0.00210071f, 0.06335079f, -0.04860918f, 0.09738721f, -0.02014442f, 0.00561615f, 0.05263616f, 
    0.02614569f, -0.05788356f, -0.10876459f, 0.05088411f, -0.19123542f, -0.03801107f, -0.07518315f, -0.08907139f, 
    0.02762503f, 0.11481357f, 0.05286679f, 0.06677171f, -0.04601438f, -0.00666177f, -0.04064448f, -0.06570161f, 
    0.05186741f, 0.02483072f, 0.02933573f, -0.05316560f, 0.07147794f, -0.16809128f, -0.00348021f, -0.02910105f, 
    0.10748160f, -0.14964128f, 0.13679270f, 0.09809567f, 0.06715546f, 0.03216120f, 0.11628493f, 0.08123810f, 
    -0.06609506f, 0.12565611f, 0.01244840f, 0.02659662f, -0.01896818f, 0.03698410f, 0.03045042f, 0.01818513f, 
    0.07162617f, 0.06026666f, 0.11673569f, 0.02644098f, 0.00957834f, 0.25927827f, 0.07249986f, 0.10696661f, 
    -0.18335074f, -0.03375292f, -0.00616988f, 0.00708736f, 0.03930264f, 0.06064694f, 0.01107247f, 0.09135523f, 
    -0.07811972f, -0.04603783f, 0.02760027f, 0.04182294f, 0.11120842f, -0.00921513f, 0.25985476f, -0.03052173f, 
    0.28927472f, 0.10305392f, -0.05805027f, 0.01692811f, -0.09543380f, -0.08946099f, -0.17746820f, -0.00877509f, 
    0.03201459f, -0.04477781f, -0.07143299f, -0.12917285f, -0.04183597f, -0.09105127f, 0.02331666f, 0.04374392f, 
    0.08130155f, 0.11802250f, -0.03242163f, 0.09211300f, 0.16192918f, -0.09578051f, -0.17433488f, -0.07629494f, 
    -0.18776093f, -0.04159126f, -0.06981574f, -0.05494481f, 0.02477806f, 0.02240540f, 0.04323197f, 0.02026752f, 
    0.04950872f, 0.12463886f, -0.01326375f, -0.03974243f, -0.04899027f, -0.03471249f, -0.08386388f, 0.10351763f, 
    -0.20697869f, 0.20547542f, -0.12034246f, 0.03307817f, 0.28907251f, 0.10729527f, 0.00098183f, 0.09767528f, 
    0.08205315f, -0.03982611f, 0.03344879f, -0.08436327f, -0.00856050f, 0.00099435f, -0.06223066f, 0.16287793f, 
    -0.00531455f, -0.02193069f, 0.11547411f, 0.00650852f, 0.23909803f, -0.00249999f, -0.10101151f, 0.03425709f, 
    -0.17783852f, -0.03007098f, -0.03808594f, 0.01386663f, 0.00198849f, 0.10160657f, 0.02320982f, 0.03945510f, 
    0.01716159f, 0.10960112f, 0.07975137f, 0.03186208f, 0.03659680f, -0.05842118f, 0.03387478f, 0.01497058f, 
    0.34153870f, -0.06633270f, -0.23915412f, 0.10477658f, -0.14112552f, 0.00360235f, -0.10289257f, 0.05587957f, 
    0.05911981f, -0.04850997f, -0.00161523f, 0.01761528f, -0.02979672f, 0.05608885f, 0.04979619f, 0.05844880f, 
    -0.05147325f, 0.06357846f, -0.02781561f, -0.01041113f, 0.07965708f, 0.09319524f, 0.03346249f, -0.00694320f, 
    -0.12888367f, -0.13779518f, -0.00024570f, 0.00565471f, -0.00639634f, 0.08229654f, -0.00268638f, -0.02007682f, 
    0.00797701f, 0.03381436f, -0.05928098f, 0.08506113f, 0.04820573f, -0.00802719f, 0.06043943f, 0.15381935f, 
    0.01369984f, 0.10505534f, -0.00964152f, 0.12444675f, -0.06537855f, 0.03511485f, -0.06264072f, 0.00324974f, 
    0.00397866f, 0.10267716f, 0.08097260f, -0.01064990f, -0.10004701f, 0.04189435f, 0.11583355f, 0.18364337f, 
    0.00909028f, -0.03543760f, 0.14178076f, 0.06476773f, -0.29176688f, -0.09407105f, -0.06436542f, -0.01121732f, 
    -0.03349363f, -0.05293304f, -0.07076028f, -0.02474079f, 0.06495505f, 0.09314357f, 0.14402449f, 0.09169979f, 
    0.06530751f, -0.01281023f, 0.00625130f, -0.02853433f, -0.02532327f, 0.01245061f, -0.03265783f, 0.05150022f, 
    0.05607188f, -0.06331805f, -0.18183750f, 0.03885053f, -0.06023381f, -0.18198590f, -0.16119033f, 0.12428780f, 
    -0.10070691f, -0.07099345f, 0.02460016f, 0.01809853f, -0.01015772f, 0.13608380f, 0.06009428f, -0.03181861f, 
    -0.05091649f, -0.00381216f, 0.11542269f, 0.02578349f, 0.06611241f, 0.36807308f, -0.12324561f, -0.18406861f, 
    -0.04671953f, -0.04722984f, -0.05291708f, 0.01528004f, 0.12664552f, 0.03526561f, -0.06987558f, -0.00458031f, 
    -0.04376853f, -0.04036811f, 0.11457269f, 0.08919812f, 0.01791983f, 0.00873806f, 0.04272991f, -0.02648880f, 
    -0.14585660f, 0.10139573f, 0.04987983f, 0.17821890f, -0.03179552f, 0.13199763f, 0.12945716f, 0.01662906f, 
    0.04292135f, 0.05514567f, 0.09277813f, 0.09781001f, 0.04477634f, 0.06334744f, -0.00735974f, 0.05436842f, 
    0.07434135f, 0.08291440f, 0.01766559f, 0.00315859f, 0.08416551f, 0.09595355f, -0.12491855f, -0.02096996f, 
    0.12279587f, 0.08012306f, 0.10858051f, 0.03062376f, 0.09210204f, 0.13871233f, 0.09129436f, -0.05061335f, 
    -0.00338031f, 0.05715840f, -0.01474312f, 0.07998087f, 0.06576557f, 0.03990734f, 0.04045167f, 0.12470836f, 
    -0.04607294f, -0.19205610f, -0.08617909f, 0.13820423f, 0.10809273f, 0.03596528f, -0.03054398f, 0.06977356f, 
    0.02131846f, -0.05562586f, -0.01448258f, 0.08409528f, 0.01305644f, 0.07633872f, 0.06801760f, 0.01350684f, 
    0.06993529f, -0.03414983f, 0.02201362f, -0.04027444f, -0.00360212f, -0.26106361f, -0.04923936f, -0.11703783f, 
    -0.02994139f, 0.02308043f, -0.01139333f, -0.04804917f, 0.13591504f, 0.17248128f, 0.06206827f, 0.06226130f, 
    0.15977019f, 0.02235557f, 0.08564369f, -0.03970369f, -0.05902024f, -0.00710409f, -0.11560217f, 0.06965552f, 
    0.12412171f, 0.24617355f, 0.05410829f, -0.06910606f, 0.25683528f, -0.06873966f, -0.07890300f, -0.03840160f, 
    -0.11220309f, -0.05001303f, -0.03227211f, 0.06176572f, 0.06918933f, -0.00927846f, -0.04324694f, 0.05028889f, 
    0.09528474f, 0.04822884f, 0.03724338f, -0.04553520f, -0.15986645f, 0.07358521f, 0.07335358f, 0.02496496f, 
    0.24754351f, -0.11060294f, -0.12230023f, -0.04838273f, 0.00867948f, -0.01599933f, -0.07692888f, -0.02052435f, 
    -0.04952284f, 0.00891149f, 0.10595958f, -0.00519826f, -0.03090915f, -0.04671678f, 0.02097351f, -0.09921477f, 
    0.20512706f, 0.18640114f, 0.07901606f, -0.00666026f, 0.10909507f, -0.04594561f, -0.09567908f, -0.02146676f, 
    -0.10437769f, -0.03011713f, -0.02790326f, 0.03165557f, 0.00074210f, 0.03915053f, 0.03254812f, 0.01262952f, 
    0.08693563f, 0.07865524f, 0.01546252f, -0.08866731f, 0.05937403f, 0.09064475f, 0.08673694f, 0.08338959f, 
    0.09220038f, 0.05725224f, 0.01135374f, 0.07208496f, 0.02521553f, -0.02411532f, 0.03835919f, 0.02393690f, 
    0.07181101f, 0.00304649f, -0.04401845f, -0.05353992f, 0.02471955f, -0.02700612f, -0.00227403f, 0.01623264f, 
    -0.16984224f, -0.13321799f, 0.00451541f, -0.04787118f, -0.04870186f, -0.01898794f, 0.02193243f, -0.03246263f, 
    0.00329930f, 0.01240117f, 0.04420350f, -0.06445206f, -0.02618245f, 0.02338830f, -0.03844361f, 0.07524278f, 
    0.00064190f, -0.06918011f, -0.07213755f, 0.05674858f, 0.00947232f, 0.14039983f, 0.19960035f, 0.07209139f, 
    0.00254367f, -0.00826800f, 0.03526426f, -0.01530781f, 0.09831525f, -0.05648243f, -0.00309580f, 0.00594852f, 
    -0.04214141f, -0.01401425f, -0.06417240f, -0.03823297f, -0.01903419f, 0.00448548f, -0.04680340f, -0.05293988f, 
    0.11848085f, 0.16890776f, 0.17907791f, 0.03783588f, 0.03154210f, 0.01872926f, 0.09805749f, 0.12199897f, 
    -0.05272315f, -0.03457795f, 0.02913301f, -0.02945546f, -0.03075944f, -0.01764756f, -0.05697315f, -0.07831539f, 
    0.02864310f, 0.00883522f, 0.00422527f, -0.07582122f, 0.00638347f, 0.12724072f, 0.07657494f, 0.01562500f, 
    0.07428136f, -0.07970164f, -0.09400489f, -0.05100811f, -0.01570083f, 0.00861108f, -0.10606806f, -0.00252502f, 
    -0.03382209f, 0.02643581f, 0.00780084f, -0.00733314f, -0.00486300f, 0.01314005f, 0.01582885f, -0.06749450f, 
    0.05507202f, 0.12509450f, 0.16815770f, 0.04181121f, 0.33994883f, 0.04936192f, -0.11782304f, -0.01157875f, 
    -0.02496723f, -0.03534725f, -0.00095361f, -0.03678197f, 0.00671114f, 0.02622569f, 0.00077173f, 0.08717180f, 
    -0.08308101f, 0.02085007f, 0.00372340f, -0.08694633f, 0.47832620f, -0.17230093f, -0.32981849f, -0.17569365f, 
    -0.23668416f, 0.02087455f, -0.05076491f, 0.03232209f, -0.04493313f, 0.03983404f, 0.04972585f, -0.00619619f, 
    -0.09609045f, 0.02444543f, -0.03907678f, -0.04111567f, 0.02312068f, -0.03272375f, -0.06891675f, 0.02967224f, 
    0.01468033f, 0.33318186f, 0.20798506f, 0.12480685f, 0.16927339f, -0.01612971f, -0.01331843f, 0.01661977f, 
    -0.10461271f, -0.09028024f, 0.09185252f, -0.01872818f, 0.08016151f, 0.02588338f, -0.08226136f, -0.04676078f, 
    0.06077564f, -0.01009372f, 0.04427768f, 0.00569410f, -0.30023396f, -0.17514890f, 0.08581521f, -0.11210874f, 
    -0.08164796f, -0.02118245f, 0.00620891f, -0.01776892f, 0.00897825f, -0.08211695f, -0.06128419f, 0.05717728f, 
    0.09432288f, -0.00544839f, -0.05484729f, 0.00092083f, 0.05810934f, -0.10027599f, -0.15128949f, -0.03533179f, 
    0.34955102f, 0.09834254f, -0.13581795f, 0.02091571f, 0.19043317f, 0.10654490f, -0.02107092f, -0.15345559f, 
    0.03848964f, 0.02118273f, 0.09450648f, 0.01563747f, -0.04866169f, -0.12736435f, 0.05964475f, -0.00610221f, 
    0.00966504f, -0.02829262f, -0.08161759f, 0.08543743f, 0.08754033f, 0.04283755f, -0.19061121f, -0.02549815f, 
    -0.12022343f, -0.04539130f, -0.03397853f, -0.01464170f, 0.02492503f, -0.02402928f, 0.07095640f, -0.10535047f, 
    -0.03209332f, -0.00143018f, 0.00331662f, 0.12714991f, 0.01174767f, -0.03178383f, 0.10033066f, -0.05686832f, 
    0.06689819f, 0.20268936f, 0.10580768f, -0.05905047f, -0.08768761f, 0.05217772f, 0.01178570f, -0.08751836f, 
    0.01122162f, 0.03484096f, -0.00326557f, 0.04964081f, -0.05632157f, -0.05116276f, 0.11315756f, -0.03515208f, 
    0.09177464f, 0.03869069f, -0.08659184f, 0.07136488f, -0.16049255f, -0.04784932f, -0.08144503f, -0.11258294f, 
    -0.08511378f, 0.07431632f, 0.08854306f, 0.08139849f, -0.00933615f, 0.10183309f, -0.10189491f, 0.12888387f, 
    -0.02659513f, 0.03625381f, -0.03062855f, -0.03473163f, -0.00089972f, -0.04515688f, -0.07656435f, 0.00709495f, 
    0.08082189f, 0.11573644f, -0.03949354f, -0.08820661f, 0.12741673f, -0.13442941f, 0.06221694f, 0.08469298f, 
    -0.07575483f, 0.08508118f, 0.01070629f, -0.02016479f, 0.01944267f, -0.06897824f, -0.11127782f, 0.06403186f, 
    0.08727846f, 0.12550527f, 0.00926447f, 0.05532493f, 0.08680481f, 0.00046174f, 0.20102268f, 0.02299130f, 
    0.09566846f, 0.07070600f, -0.06856082f, 0.05749514f, -0.11674486f, 0.00206808f, 0.01626743f, -0.01525103f, 
    -0.09153802f, -0.10498499f, 0.03527121f, -0.04387932f, -0.05777260f, 0.11499320f, 0.03598393f, 0.02359936f, 
    -0.05694169f, 0.09356906f, 0.10790700f, -0.13683429f, 0.03570944f, -0.01969024f, 0.06518147f, -0.11503187f, 
    0.00020121f, -0.02237343f, 0.01452363f, 0.04660708f, -0.08169010f, 0.04041950f, -0.05608479f, -0.14722055f, 
    0.02316220f, 0.01118242f, -0.06359575f, 0.01164147f, -0.14970553f, -0.10465222f, -0.05915902f, -0.02476263f, 
    0.17721622f, -0.07716970f, -0.06362502f, 0.03769099f, 0.03785114f, -0.02352644f, -0.04426347f, 0.06889958f, 
    0.03182618f, 0.01609170f, 0.07781179f, 0.09039152f, 0.07821687f, -0.07461300f, -0.01647577f, -0.00373530f, 
    0.07896174f, -0.12624592f, 0.09933493f, 0.00954863f, -0.07226928f, 0.10658128f, -0.15545957f, 0.10099801f, 
    -0.01196492f, -0.00967034f, 0.03478643f, 0.00476923f, -0.07257286f, -0.00639860f, 0.02945164f, -0.05348677f, 
    0.12168122f, -0.06258196f, -0.05318949f, -0.07822803f, 0.03666960f, -0.12536177f, 0.11097296f, -0.20132941f, 
    0.10866323f, 0.02426522f, -0.11199439f, 0.00202016f, -0.02441117f, -0.08413748f, 0.03444827f, -0.00020711f, 
    -0.02580138f, 0.00117176f, -0.01154512f, -0.00733998f, 0.08285549f, 0.02662411f, 0.04257156f, -0.02874380f, 
    -0.09986226f, 0.07466327f, -0.18956265f, -0.09435298f, 0.10459470f, -0.03396802f, 0.02912257f, -0.01995065f, 
    0.02208914f, -0.08609027f, 0.01969620f, 0.01217591f, 0.04361876f, 0.14931436f, -0.00112912f, 0.21867166f, 
    0.06128498f, 0.04289282f, 0.12094995f, 0.04583366f, -0.06688380f, 0.06578512f, 0.10235706f, -0.03045513f, 
    0.10368730f, 0.10350050f, -0.02413546f, 0.06841671f, -0.00534632f, -0.05151046f, -0.03593488f, -0.01069095f, 
    -0.09981810f, 0.00453754f, -0.01762010f, 0.04726001f, -0.05656836f, 0.14289001f, 0.11316034f, 0.00094325f, 
    -0.01631763f, 0.21308981f, 0.18008809f, -0.02551710f, 0.03516164f, -0.04734651f, 0.05173677f, 0.04128459f, 
    0.05044603f, 0.02337096f, -0.16793187f, 0.00806666f, -0.04924474f, -0.02108736f, 0.11609777f, 0.06392719f, 
    0.05612168f, 0.02844086f, -0.01283712f, -0.03808168f, -0.44257715f, -0.03015378f, 0.06067788f, 0.17809160f, 
    0.02994775f, -0.18786642f, 0.00862286f, -0.02909285f, 0.00995058f, 0.00174987f, -0.05138550f, -0.05392171f, 
    -0.01119079f, -0.01634388f, -0.02016431f, -0.09267655f, -0.02431143f, -0.09601811f, -0.08528728f, 0.01625037f, 
    -0.00354278f, 0.02836585f, 0.08355781f, -0.04700456f, 0.11563648f, -0.01209007f, 0.14101708f, 0.01330179f, 
    0.01836462f, 0.04159905f, -0.02579360f, 0.05285548f, -0.09681513f, 0.00639831f, -0.00075394f, 0.05332183f, 
    -0.07803035f, 0.08386734f, 0.16784316f, -0.03493319f, -0.23084800f, -0.07515765f, 0.02761549f, -0.07902773f, 
    0.02117089f, 0.03773941f, -0.07297664f, 0.03594151f, 0.00787013f, 0.02536638f, 0.09269453f, 0.07288042f, 
    -0.04024266f, 0.04108656f, -0.02606416f, 0.00478391f, -0.01947424f, 0.03600523f, 0.04030982f, 0.02447863f, 
    -0.12163671f, -0.01619890f, 0.05113483f, 0.29509273f, 0.08846111f, -0.05050987f, 0.08347553f, 0.04926581f, 
    -0.09389370f, 0.07679071f, 0.02412424f, -0.08703079f, 0.04580216f, 0.01458661f, 0.04351461f, 0.13383484f, 
    -0.07391348f, -0.04893419f, -0.00712011f, -0.16025648f, 0.01888930f, 0.18195356f, 0.01259879f, 0.22476020f, 
    0.01666888f, 0.03558037f, 0.01260226f, 0.01157085f, 0.08562643f, -0.04987465f, -0.02319421f, 0.03234220f, 
    -0.03234355f, 0.01162821f, -0.01632380f, 0.04257865f, -0.06124604f, -0.02954384f, 0.03599650f, -0.03583208f, 
    0.29345602f, -0.21230131f, 0.16751012f, -0.07098059f, 0.04134098f, -0.05899818f, 0.06255493f, -0.01147529f, 
    -0.06201109f, 0.02003586f, 0.01722266f, -0.01347701f, 0.02242703f, -0.03536399f, -0.03955501f, -0.01306040f, 
    0.12360106f, -0.12430172f, 0.06724130f, -0.12727867f, 0.04882647f, -0.04889576f, -0.14738162f, 0.02731652f, 
    -0.13743937f, -0.04940809f, 0.01686060f, -0.03324674f, 0.09842200f, -0.11632605f, 0.01350726f, -0.05706342f, 
    0.03874084f, 0.05087589f, -0.00162918f, -0.04186670f, 0.03253350f, 0.00438508f, -0.13782066f, 0.02254292f, 
    0.22856325f, -0.18845272f, 0.06961717f, 0.02394936f, 0.12043545f, 0.03683352f, 0.02708453f, 0.04584659f, 
    -0.03187939f, 0.04772300f, 0.05045928f, 0.07766484f, 0.04162139f, -0.07930737f, 0.00538024f, -0.02871656f, 
    -0.01582144f, -0.07491712f, 0.00156197f, -0.02988712f, -0.14559828f, 0.12748754f, 0.10347853f, 0.13794009f, 
    0.00545773f, 0.08115376f, 0.03802529f, 0.02941299f, 0.05454863f, -0.07981038f, 0.01018799f, 0.03092910f, 
    -0.00167331f, 0.03501924f, -0.02210695f, 0.01445940f, -0.06406485f, 0.04437317f, -0.03691999f, -0.04078226f, 
    0.13324425f, 0.16624570f, 0.01125974f, -0.16844845f, -0.14535981f, 0.05701371f, -0.08477252f, -0.06721748f, 
    0.07241203f, 0.05633874f, 0.00188324f, -0.05824637f, 0.11932783f, 0.08478237f, 0.05049176f, 0.11780027f, 
    0.09177697f, 0.01887985f, 0.01490640f, 0.00180579f, -0.09173565f, 0.00826608f, -0.05596888f, 0.03805316f, 
    -0.09845203f, -0.05899265f, -0.02565149f, 0.07742911f, 0.07451150f, -0.05264295f, -0.02279875f, 0.05458470f, 
    -0.00359662f, 0.02635309f, 0.04257302f, 0.04603665f, 0.02555446f, 0.01602386f, 0.01939191f, 0.02974634f, 
    -0.47228777f, 0.39821923f, -0.24812078f, -0.01338726f, -0.05489835f, 0.04040655f, -0.01420564f, 0.07992981f, 
    0.05527744f, -0.05095515f, 0.02858007f, -0.07276997f, 0.05709039f, -0.09458856f, 0.00542731f, 0.06686904f, 
    0.01890444f, 0.03418576f, -0.01408713f, 0.00553677f, 0.02983242f, 0.07551305f, -0.00391848f, 0.03974983f, 
    -0.10996105f, -0.05045952f, -0.05927566f, 0.10293505f, 0.13334124f, 0.04008898f, -0.06128600f, 0.05109400f, 
    -0.03789382f, 0.11947558f, -0.06070782f, 0.08569626f, 0.06282775f, 0.07389070f, -0.01548156f, -0.06189776f, 
    0.08293779f, 0.01777552f, -0.14090219f, 0.09767058f, -0.08818154f, -0.07718495f, 0.02811227f, 0.01877056f, 
    0.04367608f, -0.12042885f, 0.05132239f, -0.05360593f, 0.04546876f, -0.03551202f, 0.08780302f, 0.03381225f, 
    0.08919508f, -0.04867561f, 0.05731450f, -0.07928827f, -0.02858307f, 0.16651800f, 0.05335736f, 0.00879743f, 
    -0.05588426f, 0.06774733f, 0.00819188f, -0.05200189f, 0.06104132f, 0.04724576f, -0.01660602f, -0.01158419f, 
    -0.05758353f, 0.07511725f, -0.00646521f, -0.10898019f, -0.01078521f, 0.05573633f, -0.07085285f, 0.03691598f, 
    -0.01901524f, 0.14988033f, 0.09796087f, 0.11499899f, 0.01419851f, 0.06991427f, -0.03031513f, -0.02126798f, 
    0.00009094f, -0.03049112f, 0.02087699f, -0.03730299f, 0.02425724f, -0.04298990f, 0.14143847f, 0.07217264f, 
    -0.01550478f, -0.03422020f, 0.03069866f, -0.09030880f, -0.13798167f, -0.11748472f, -0.14498220f, 0.01447329f, 
    0.16981372f, -0.17989007f, -0.10375842f, 0.02237710f, 0.11977317f, 0.10631688f, 0.04124359f, 0.03858383f, 
    0.09729279f, 0.05332098f, 0.01292865f, -0.04581024f, -0.00123872f, -0.02418404f, 0.06953198f, 0.11616141f, 
    0.00907350f, 0.07824375f, -0.17711848f, 0.07731838f, -0.00924866f, -0.06198103f, 0.03891465f, 0.03120045f, 
    -0.08548202f, -0.01087642f, 0.05775956f, 0.03669837f, -0.02762076f, -0.00013337f, 0.04964190f, -0.03883789f, 
    0.01645855f, -0.06799173f, 0.02365620f, -0.04339895f, -0.43674743f, 0.45390809f, -0.11782052f, -0.36364135f, 
    0.05674393f, 0.02208868f, 0.08923241f, -0.01928108f, 0.06779733f, 0.03983816f, 0.04039760f, -0.02548615f, 
    -0.05934203f, -0.04969731f, -0.05555644f, -0.10689168f, -0.02389314f, 0.01323073f, 0.03299741f, -0.01796408f, 
    -0.02122043f, 0.03517340f, 0.05503689f, 0.26064345f, 0.28514728f, 0.08622428f, -0.07209431f, -0.04938526f, 
    0.12464566f, 0.00618635f, 0.16573502f, 0.07596458f, 0.00745965f, -0.07842120f, 0.03435840f, 0.09959996f, 
    0.03947639f, 0.02539613f, -0.02567513f, 0.04203711f, 0.22049735f, 0.10696041f, -0.06664644f, 0.25681078f, 
    0.29248729f, -0.03932945f, 0.04107443f, 0.09358355f, 0.02657176f, -0.04369949f, 0.02066255f, 0.00521718f, 
    0.03106460f, 0.02080754f, 0.02828238f, -0.02248306f, -0.04721215f, 0.07371012f, 0.02142632f, 0.03515509f, 
    0.36631456f, -0.12295070f, 0.08890324f, -0.20984802f, 0.01858643f, -0.05387849f, -0.02022405f, -0.07980476f, 
    -0.08625841f, -0.01752091f, -0.05358945f, 0.08042753f, -0.05779249f, 0.01455707f, 0.08450662f, 0.03541809f, 
    0.03421420f, 0.03568527f, 0.05900501f, -0.02461787f, -0.02522138f, 0.08909760f, -0.01054949f, -0.09226549f, 
    -0.03085710f, -0.10122275f, 0.02323431f, -0.05816889f, 0.14169806f, 0.09099291f, -0.02532257f, 0.15252660f, 
    0.04181532f, -0.02114498f, 0.03019453f, 0.00369928f, -0.03314200f, 0.09012295f, 0.01981212f, 0.06393710f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09832986f, 0.10114240f, 0.02021816f, -0.06122786f, 0.04691591f, 0.02232239f, -0.04769783f, 0.01735637f, 
    0.02727633f, 0.05536148f, -0.01864700f, 0.05272194f, 0.03488609f, 0.00256783f, -0.05847112f, 0.04494411f, 
    0.05359532f, 0.06641105f, 0.03582875f, 0.01725670f, -0.00068187f, -0.04103012f, 0.00441793f, 0.05500876f, 
    0.03864767f, 0.03891135f, 0.01992778f, -0.05382117f, -0.02324143f, -0.05769689f, 0.02172823f, 0.09649719f, 
    0.03227062f, 0.07322612f, -0.02416146f, 0.04909049f, -0.07263385f, 0.02065232f, -0.00190533f, 0.03194108f, 
    0.00148770f, -0.04849081f, 0.00326395f, -0.04374477f, -0.01820962f, 0.01221275f, 0.02593304f, -0.11189973f, 
    -0.04720094f, 0.07410102f, -0.01178567f, -0.02008283f, -0.01202798f, 0.02258256f, 0.03830699f, 0.06005330f, 
    0.02072767f, -0.03642479f, 0.00042564f, 0.07428708f, 0.02348351f, -0.05980321f, 0.04215408f, 0.00493488f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20507540f, -0.03290543f, -0.01887611f, -0.11790016f, 0.06490859f, 0.37234205f, -0.21285772f, 0.00447699f, 
    -0.03317387f, 0.08093498f, 0.07912491f, 0.08168385f, 0.05836266f, 0.09796353f, 0.10802413f, -0.02325583f, 
    -0.14634144f, -0.29064164f, -0.11241463f, 0.17663141f, 0.02730449f, 0.03086872f, 0.30309516f, 0.06602724f, 
    -0.07817583f, 0.05651912f, 0.04332591f, 0.00373849f, -0.11431451f, -0.11021171f, 0.16152127f, 0.14620166f, 
    -0.10087154f, 0.12529701f, -0.06562991f, -0.15658337f, -0.10346526f, 0.11552282f, -0.05036322f, 0.05244803f, 
    -0.15431558f, 0.06118602f, -0.03807060f, 0.04791899f, 0.02896020f, 0.01101807f, 0.23286909f, -0.13188992f, 
    -0.03211289f, 0.19924438f, -0.13338734f, 0.20805596f, 0.05301184f, 0.12204516f, -0.26621014f, 0.17327519f, 
    -0.11120669f, -0.06280474f, -0.18057203f, -0.05763820f, 0.21317013f, -0.07439652f, -0.11913927f, -0.05453428f, 
    -0.04660773f, -0.07407365f, 0.11759022f, 0.02448419f, -0.01133674f, 0.00293185f, -0.04170552f, -0.02794674f, 
    0.03795902f, -0.09966840f, -0.07466564f, -0.11269300f, -0.12484135f, -0.11754599f, -0.10859340f, -0.04751845f, 
    -0.11707413f, -0.10032237f, -0.04728287f, -0.06093116f, 0.04937400f, 0.05110402f, 0.09358525f, -0.07000048f, 
    -0.00211101f, -0.03360940f, -0.10051858f, -0.01606429f, 0.04452695f, -0.03000502f, 0.14132302f, 0.03846515f, 
    -0.08549638f, -0.04952275f, -0.06042592f, -0.10569959f, -0.01409775f, -0.04469506f, 0.05819864f, -0.05832189f, 
    -0.03375615f, 0.09735562f, -0.07780223f, -0.00918168f, -0.04434173f, -0.09062649f, -0.09011016f, -0.08975260f, 
    -0.10792284f, -0.11022205f, 0.04126143f, -0.01864959f, -0.05065368f, -0.04815868f, 0.01088062f, -0.06702662f, 
    0.07295775f, -0.10399595f, 0.06190035f, -0.11190534f, -0.02537354f, 0.02829900f, -0.12594178f, -0.11442309f, 
    0.05900444f, -0.05592711f, 0.07870813f, -0.12470233f, 0.00677608f, -0.08926809f, 0.06947565f, -0.06902068f, 
    -0.07630881f, -0.11355049f, -0.06518426f, 0.05235505f, 0.10035025f, 0.12007159f, 0.11180486f, -0.01796475f, 
    -0.04352588f, -0.10162655f, -0.00173046f, -0.09616578f, -0.05031716f, 0.06393974f, 0.05011089f, 0.11221258f, 
    -0.09794351f, -0.01542971f, -0.04367599f, 0.08070742f, -0.04984040f, 0.12099658f, -0.10339049f, 0.00669057f, 
    0.09103569f, 0.10560539f, -0.12060884f, -0.02779835f, 0.03086185f, -0.03930086f, 0.04395989f, -0.09712186f, 
    0.01988066f, -0.12458646f, -0.01600503f, 0.05745184f, -0.09957744f, -0.02237374f, -0.02768141f, 0.08820470f, 
    0.07685427f, -0.04885161f, 0.03064948f, -0.08538115f, 0.06627826f, -0.00823393f, 0.01837421f, -0.12104136f, 
    -0.03307642f, -0.10341529f, -0.01623598f, 0.05060904f, -0.07429658f, -0.01162502f, -0.06618097f, 0.10112526f, 
    0.07156164f, -0.22609682f, -0.03490134f, 0.08500123f, 0.10511234f, -0.03855746f, 0.11137506f, 0.08270447f, 
    -0.18001923f, 0.28637359f, 0.09562869f, 0.18124902f, -0.08088889f, -0.05513024f, -0.00417431f, 0.08554547f, 
    -0.16237265f, -0.45290226f, -0.00534344f, 0.26937249f, 0.18904097f, 0.01579764f, -0.08063968f, -0.03559013f, 
    -0.10452127f, -0.12278129f, 0.27873677f, -0.02113572f, 0.11521845f, -0.09061186f, 0.17189820f, -0.00174300f, 
    -0.04938863f, -0.20509246f, 0.01598255f, -0.05184081f, -0.11581931f, 0.05137171f, -0.07876000f, -0.04501531f, 
    0.12026535f, -0.02393432f, 0.20210040f, 0.07677213f, -0.02738954f, -0.06166059f, 0.14545739f, 0.22219326f, 
    0.03674596f, -0.13694838f, -0.01449854f, 0.10605159f, -0.08910231f, -0.25560409f, -0.20610324f, 0.06089530f, 
    -0.24859247f, -0.02907402f, -0.01292715f, 0.07633670f, 0.09967515f, -0.46403480f, -0.12757896f, -0.13813435f, 
    -0.02168608f, 0.19191073f, 0.06803844f, 0.01438763f, -0.13007246f, 0.13614622f, 0.20740740f, 0.01328639f, 
    -0.09208195f, -0.20532256f, 0.13465314f, -0.08501152f, -0.02783364f, -0.04538423f, -0.11709646f, -0.01079922f, 
    0.06697313f, -0.24389999f, -0.05769568f, 0.21534671f, 0.09050059f, -0.10689653f, 0.15818985f, -0.05159394f, 
    -0.25253358f, -0.25111783f, 0.18207309f, 0.10638710f, 0.09948421f, -0.09768040f, 0.09105381f, -0.03348710f, 
    0.04971615f, 0.09195256f, 0.12616129f, -0.12297688f, 0.01714955f, -0.00586795f, -0.08154722f, 0.08839384f, 
    0.07911537f, 0.04048342f, -0.05531634f, 0.05937391f, -0.11401927f, 0.09047966f, 0.07806776f, -0.21934535f, 
    0.07538030f, 0.24626379f, -0.04782670f, 0.04614453f, 0.09431698f, -0.19272746f, -0.27668348f, 0.17024158f, 
    0.06444599f, 0.15457591f, -0.03371332f, 0.13957128f, 0.14596482f, -0.24866496f, 0.13505384f, -0.07310700f, 
    -0.02924803f, -0.13399166f, -0.04809267f, -0.09826814f, 0.08110995f, -0.13342713f, 0.01039720f, 0.08314174f, 
    0.07921710f, 0.33697873f, 0.16480181f, 0.19450080f, 0.13950589f, -0.01329327f, 0.11446378f, 0.07589216f, 
    0.12256657f, 0.05295851f, -0.09929131f, 0.18420829f, 0.19671100f, 0.07587826f, -0.15520042f, 0.30757225f, 
    0.21622944f, 0.16328347f, -0.11103889f, -0.10428502f, 0.20515272f, 0.03302810f, -0.03692312f, 0.01326513f, 
    -0.06763887f, -0.11875759f, 0.07496536f, 0.27496657f, -0.32723299f, -0.03961909f, 0.06766061f, 0.11764260f, 
    -0.25426069f, 0.05057268f, -0.03793404f, -0.03062356f, -0.06620924f, -0.03590851f, -0.26240683f, 0.16032968f, 
    0.09391458f, -0.00711454f, 0.07551019f, 0.17282078f, -0.01086250f, -0.05991119f, -0.17755523f, -0.01413650f, 
    -0.35659206f, -0.14717492f, 0.11285137f, 0.37489024f, 0.17851159f, 0.03320391f, -0.41382524f, 0.01462553f, 
    0.09635089f, 0.18376887f, -0.00721280f, 0.01461911f, 0.02288707f, 0.21704607f, 0.02476123f, -0.17645983f, 
    -0.02597049f, 0.18212962f, -0.10922097f, 0.14904037f, -0.06172337f, -0.01065622f, 0.00342376f, -0.02773176f, 
    0.12776668f, 0.22985359f, -0.10060532f, 0.18233879f, 0.03055778f, 0.05616119f, -0.08572993f, 0.16991095f, 
    0.09148660f, 0.08757641f, -0.12147906f, -0.09648485f, 0.19266070f, 0.07009684f, 0.29781085f, -0.11477918f, 
    0.05704084f, -0.06115578f, 0.09027819f, -0.10508613f, -0.09964157f, 0.12474146f, 0.06655745f, -0.02362719f, 
    -0.01610649f, -0.00586638f, 0.11946747f, -0.08007758f, -0.00311653f, 0.01003122f, 0.20675176f, 0.31709445f, 
    0.05706081f, -0.01859665f, -0.01332490f, -0.06635502f, 0.06405684f, -0.07351716f, -0.09384004f, 0.03585318f, 
    -0.20840210f, -0.05899310f, 0.08911289f, -0.15089066f, 0.05233418f, 0.33921951f, 0.01643394f, 0.29485935f, 
    0.19586818f, 0.13664059f, -0.05476160f, -0.09081780f, -0.12994573f, 0.26537478f, 0.00114323f, -0.00711978f, 
    0.05244216f, -0.03970740f, 0.04885076f, -0.02250753f, 0.02237624f, 0.07098543f, 0.02994152f, -0.01177732f, 
    0.14990360f, -0.07704827f, -0.01770704f, 0.12442076f, -0.11854193f, 0.01059662f, -0.15397190f, 0.02538885f, 
    0.13093831f, 0.02891143f, -0.15494084f, 0.07170241f, -0.08003521f, -0.01862758f, 0.28332058f, 0.11837326f, 
    -0.09204875f, 0.05377191f, 0.03988147f, -0.14722410f, 0.05162043f, 0.05893032f, 0.01982163f, -0.04989230f, 
    0.04660332f, -0.11139224f, 0.34811267f, 0.08553092f, 0.05927669f, 0.07428604f, 0.19811712f, -0.04950187f, 
    0.05146696f, 0.00948028f, -0.00442689f, 0.06699177f, -0.00146172f, -0.24213521f, -0.22044602f, 0.19951853f, 
    -0.09925875f, 0.09063321f, -0.09648712f, -0.25420710f, 0.20416538f, -0.12560323f, 0.03493097f, 0.36897349f, 
    0.14421062f, 0.18722107f, 0.06213628f, -0.05825068f, -0.04184842f, -0.25085285f, 0.29295856f, 0.06959171f, 
    0.11440136f, -0.25201875f, 0.03918239f, -0.12871306f, 0.12877283f, 0.01868285f, -0.14209661f, 0.11947195f, 
    -0.02314069f, 0.16628206f, -0.03396944f, -0.09477097f, -0.02764852f, -0.00576891f, -0.06586381f, -0.15438870f, 
    0.13799360f, -0.04243925f, -0.22839150f, 0.00147314f, -0.01869480f, 0.05059972f, -0.35851505f, 0.09702303f, 
    -0.08421694f, 0.24353747f, -0.02327028f, -0.04872879f, 0.08332452f, 0.23601036f, 0.06453367f, 0.03428519f, 
    0.10076223f, -0.06095101f, -0.12170685f, 0.00421913f, 0.06988337f, -0.04478630f, 0.07365033f, -0.22315827f, 
    -0.10003683f, 0.23138487f, -0.01058978f, -0.08446945f, 0.04131593f, 0.21001984f, 0.37656984f, -0.09234585f, 
    0.31307241f, 0.33849800f, 0.12455820f, 0.26254174f, -0.02203180f, 0.09168453f, -0.02397041f, -0.03836523f, 
    -0.06407367f, 0.07963903f, 0.01323730f, 0.05294554f, 0.02728537f, 0.10723455f, -0.16789949f, -0.00553882f, 
    0.19449818f, 0.39696991f, 0.17472196f, 0.36504561f, 0.18485637f, 0.06523748f, -0.01443167f, -0.10990148f, 
    -0.12600178f, -0.17503953f, -0.01528353f, -0.02620075f, 0.04678527f, -0.02543667f, -0.05847139f, -0.08441199f, 
    -0.00370941f, 0.11605177f, -0.02969063f, -0.08134499f, 0.18037975f, -0.00527974f, -0.18456316f, 0.17057037f, 
    0.04032317f, 0.33200893f, -0.11071987f, 0.18070213f, 0.15349209f, -0.16883491f, -0.17196693f, -0.01568990f, 
    0.03729093f, -0.02948403f, 0.09521680f, -0.09557071f, -0.11373755f, -0.02467044f, -0.01310982f, 0.05880395f, 
    -0.00376680f, -0.02038118f, -0.05483016f, 0.12675998f, -0.12058157f, 0.16379386f, 0.14004341f, -0.05349780f, 
    -0.26015148f, -0.16382363f, 0.08056392f, 0.21070184f, -0.06495348f, -0.08257032f, 0.00377430f, -0.28798383f, 
    -0.03164548f, -0.08219324f, -0.09420683f, 0.05719081f, -0.04671414f, -0.04756087f, 0.14513300f, 0.23924959f, 
    -0.03825375f, -0.18206511f, 0.11073139f, -0.16580255f, 0.27709746f, 0.05631685f, 0.04307725f, 0.04904224f, 
    -0.00704604f, -0.10403495f, 0.08628324f, -0.00320380f, 0.16967441f, 0.11012767f, 0.15461296f, 0.12497392f, 
    -0.07339909f, 0.09616795f, 0.22899550f, -0.08162669f, 0.23716125f, -0.09155679f, -0.26878190f, 0.25056022f, 
    0.09052641f, 0.07722889f, -0.06444648f, -0.14741884f, 0.07046360f, -0.22140388f, -0.07831468f, 0.09154330f, 
    -0.24211946f, -0.07252274f, 0.06675654f, -0.10863426f, -0.10733023f, -0.02985633f, -0.16059265f, -0.23086250f, 
    0.11465521f, 0.20760769f, -0.10122069f, -0.11916090f, 0.05915215f, -0.06448766f, -0.04429936f, 0.00437598f, 
    0.24222866f, 0.04338367f, 0.19559743f, -0.10526171f, 0.17472294f, -0.27696171f, 0.28408638f, 0.14155795f, 
    0.02118560f, -0.14711268f, 0.08232068f, -0.01413132f, 0.01197237f, 0.08701844f, 0.20170055f, 0.05710223f, 
    -0.02430301f, -0.01830656f, -0.16334574f, 0.11522166f, -0.04729978f, -0.03545110f, -0.07285759f, -0.05700672f, 
    -0.00045525f, 0.11987665f, 0.01029560f, -0.02325303f, 0.21726513f, 0.05220149f, 0.02690635f, -0.03012708f, 
    -0.01273203f, 0.24073598f, -0.06840061f, -0.06258668f, 0.09588028f, 0.09992565f, -0.05268450f, -0.00087946f, 
    -0.03094664f, 0.01626853f, 0.11268394f, -0.19125532f, -0.06237595f, 0.14343007f, 0.14852639f, 0.04157721f, 
    0.05082526f, -0.01187702f, 0.03696367f, -0.06499527f, -0.10291144f, 0.06034456f, -0.11868463f, 0.31451017f, 
    0.07997163f, 0.05092108f, -0.01405355f, 0.09510972f, -0.10821438f, -0.08881786f, -0.10694584f, -0.10057700f, 
    0.08680243f, -0.22306286f, 0.29613346f, -0.17168140f, 0.07496170f, 0.06603343f, 0.21551090f, 0.10643996f, 
    0.10927303f, -0.00766775f, 0.10343812f, -0.06798424f, 0.04833326f, 0.25145027f, -0.06195172f, -0.06771060f, 
    0.06135504f, 0.19085325f, -0.21995215f, 0.09931518f, 0.26530385f, 0.07609510f, 0.00379699f, -0.01111792f, 
    0.14215203f, 0.23038428f, 0.07420863f, 0.00035703f, -0.16843766f, 0.00577592f, -0.07661907f, 0.45064917f, 
    0.16634664f, 0.30939227f, -0.25198942f, 0.04884496f, 0.03916703f, 0.06009043f, -0.04167451f, -0.10355280f, 
    -0.07083370f, -0.07127956f, 0.11791736f, 0.00304189f, 0.20038681f, -0.22855558f, 0.05177733f, -0.05519595f, 
    -0.37374321f, 0.09686208f, 0.21785657f, 0.03396389f, -0.10647497f, -0.11991521f, -0.08872862f, -0.16137262f, 
    -0.07393284f, -0.06588960f, 0.09315347f, -0.15753473f, -0.07619966f, 0.17745255f, 0.07606636f, 0.15071735f, 
    -0.19077377f, 0.04875191f, 0.15765302f, 0.04373299f, 0.12231328f, 0.18796490f, 0.18488176f, 0.19076401f, 
    0.05550751f, 0.24033174f, -0.00829633f, 0.01312295f, -0.01784621f, 0.07070474f, -0.19374691f, 0.10948523f, 
    0.02694661f, -0.11634209f, 0.09585448f, -0.09410673f, 0.18465869f, 0.07061161f, 0.00312602f, -0.11389058f, 
    -0.08286347f, -0.29020211f, 0.01893044f, -0.07348733f, -0.11051228f, 0.03181215f, -0.08480975f, 0.12897877f, 
    -0.08938430f, -0.12768446f, -0.07632305f, -0.05329994f, -0.28209358f, 0.08504514f, 0.05658659f, 0.11585310f, 
    -0.00059160f, 0.05635571f, -0.02778910f, 0.07909528f, -0.18194120f, 0.28723493f, -0.07827239f, -0.09668505f, 
    0.19490978f, -0.07973219f, 0.16135906f, 0.01046572f, -0.03575060f, 0.00683445f, 0.14580914f, -0.45759645f, 
    -0.05888248f, 0.29101303f, 0.10418358f, 0.28139946f, 0.00868400f, 0.09794770f, 0.06229747f, -0.02091468f, 
    0.01202656f, 0.04786905f, -0.22627211f, 0.03702076f, 0.12162078f, 0.12545261f, -0.23640832f, -0.00879878f, 
    0.00314003f, 0.01166348f, 0.03374950f, 0.05236632f, -0.22902150f, -0.10910771f, 0.23072197f, 0.04725770f, 
    0.03232340f, -0.13738349f, 0.01994303f, 0.21275449f, 0.00185903f, -0.01095596f, 0.00089832f, -0.00739540f, 
    -0.05246696f, -0.14764257f, -0.09106613f, -0.05695923f, 0.22214265f, 0.03075752f, -0.12451918f, -0.13619287f, 
    -0.11065024f, -0.16398644f, 0.06599698f, -0.07762475f, 0.19070518f, 0.07141101f, -0.00067823f, -0.08373193f, 
    -0.02623321f, 0.07073007f, 0.11469604f, 0.09460218f, 0.00434876f, 0.22501443f, 0.00753493f, -0.10325639f, 
    0.22608919f, 0.06308561f, -0.06770875f, 0.01058152f, 0.01089141f, -0.06021044f, -0.01291165f, -0.15451731f, 
    -0.02435268f, 0.20019123f, -0.05192975f, 0.17758094f, 0.00917808f, -0.28347564f, 0.18130547f, -0.06119661f, 
    0.04822138f, 0.36641255f, 0.10637248f, 0.38604978f, 0.07342190f, -0.21302620f, -0.29432768f, -0.22365357f, 
    0.07863343f, -0.22541104f, 0.00565322f, -0.01030940f, -0.01674317f, -0.47547603f, 0.35960418f, 0.11370347f, 
    -0.00130196f, -0.13542019f, 0.18467793f, -0.00917696f, -0.06431034f, 0.00779663f, 0.11661069f, 0.09700590f, 
    0.09864242f, -0.04770023f, -0.09759126f, -0.15025771f, 0.32956389f, -0.08552068f, -0.22356121f, -0.35464475f, 
    0.06441703f, -0.18268748f, 0.07255342f, 0.11307444f, 0.13284089f, -0.05378102f, 0.08172098f, -0.14298008f, 
    -0.00731369f, -0.17431019f, -0.05540913f, 0.17213109f, 0.05954017f, 0.23470372f, 0.12191694f, -0.05684799f, 
    -0.04504078f, 0.04437055f, 0.05383632f, 0.04657738f, -0.01609450f, -0.02363400f, -0.34105095f, -0.00975648f, 
    0.05311479f, 0.16310468f, 0.10072385f, 0.14396054f, -0.04691805f, -0.35458314f, 0.28974050f, 0.12516925f, 
    0.08281646f, 0.09448966f, -0.07832181f, 0.09494859f, -0.06556839f, 0.06673062f, 0.05452744f, 0.17037851f, 
    0.06463426f, 0.01340851f, 0.09992023f, 0.06328683f, 0.04939191f, 0.04243645f, 0.02546067f, -0.03139748f, 
    0.00318977f, -0.01106133f, -0.11153007f, 0.00659035f, -0.00888545f, 0.05564329f, 0.10758881f, -0.03079480f, 
    -0.02949636f, -0.02642217f, 0.11576530f, 0.06016156f, -0.01944025f, -0.02393052f, -0.02890641f, -0.04644870f, 
    -0.01962074f, -0.04362710f, 0.10706194f, -0.04698342f, -0.05351903f, 0.08667108f, -0.00754394f, -0.04094169f, 
    0.12168013f, 0.07341982f, -0.02605292f, 0.03148970f, -0.00946456f, -0.02710862f, 0.01805826f, -0.04434876f, 
    -0.08954927f, -0.02845913f, 0.09488854f, 0.11283218f, 0.11728954f, 0.09851477f, 0.01407171f, -0.01215457f, 
    0.01912185f, -0.10382144f, -0.10303538f, -0.10688116f, -0.00095554f, -0.02408627f, -0.03300710f, -0.12053233f, 
    0.08287074f, -0.05051504f, 0.06278993f, 0.09255668f, -0.00690645f, -0.05067274f, -0.06867348f, -0.10764703f, 
    0.19085345f, 0.06371123f, 0.10346607f, -0.13144560f, 0.02212955f, -0.14597304f, 0.10205618f, -0.12550378f, 
    0.19338693f, 0.14558125f, 0.00711801f, 0.16147345f, 0.09319685f, -0.11754300f, -0.02906044f, 0.06715451f, 
    -0.07941862f, 0.22274129f, 0.10969160f, 0.06575722f, 0.07494531f, 0.04624444f, 0.03789936f, -0.07713458f, 
    0.18442151f, 0.09898552f, -0.24944672f, -0.08785671f, 0.34152976f, -0.04433824f, -0.21055834f, -0.08510762f, 
    0.07075378f, 0.14781354f, -0.10161936f, 0.27030903f, 0.09495717f, 0.18461807f, 0.10408685f, 0.02177906f, 
    -0.02676058f, 0.04572625f, -0.01186932f, 0.04753472f, 0.07014260f, -0.08499151f, -0.16044764f, 0.19389394f, 
    0.01025778f, -0.08713571f, 0.02341671f, 0.01079563f, 0.11831415f, 0.24283619f, -0.03681008f, -0.09487891f, 
    0.06646077f, 0.10893288f, 0.33499613f, 0.22654305f, 0.00887495f, -0.14299731f, -0.12048569f, -0.11557315f, 
    -0.07400221f, 0.04566434f, 0.08501196f, 0.00813007f, -0.08553171f, 0.02706701f, 0.00087988f, -0.09963278f, 
    0.07057078f, -0.06405498f, -0.05231743f, -0.09976998f, -0.02381581f, 0.05195110f, -0.08540383f, 0.04431570f, 
    -0.01663151f, 0.02197374f, -0.09101275f, 0.02739559f, -0.09620994f, 0.11299692f, -0.12176849f, 0.12331349f, 
    -0.12424546f, -0.04066156f, -0.11391202f, -0.05385643f, 0.00777616f, 0.05704242f, -0.10844900f, -0.03204504f, 
    -0.01866509f, 0.02661206f, 0.06429030f, 0.05231296f, -0.10209657f, 0.03529069f, -0.11276710f, 0.07800299f, 
    -0.03441325f, -0.05584404f, -0.12453777f, 0.04606645f, 0.01889217f, -0.05241449f, 0.12412150f, 0.04883796f, 
    0.03123729f, -0.09679487f, 0.00796959f, -0.01048003f, -0.03531215f, 0.01035547f, 0.03322397f, -0.09922038f, 
    -0.06148037f, 0.04062571f, -0.05145802f, 0.05141522f, -0.05550826f, -0.05004033f, 0.02942318f, 0.08133154f, 
    0.10230594f, -0.13805345f, -0.03512137f, -0.09737574f, -0.13222434f, -0.00039051f, -0.01706472f, -0.07124448f, 
    -0.11580361f, -0.12059818f, 0.04929013f, -0.04110386f, -0.03697755f, -0.03939769f, 0.03316100f, -0.03888465f, 
    0.04437696f, 0.08057792f, 0.06272166f, -0.10227149f, 0.03636181f, 0.03607014f, -0.00882495f, 0.09130704f, 
    0.04578339f, -0.05725719f, 0.07550552f, 0.10946950f, -0.06962106f, 0.00782368f, -0.03140122f, 0.03561086f, 
    -0.11424305f, 0.04978417f, 0.07166283f, -0.01165158f, -0.11995764f, 0.06012268f, -0.00897964f, -0.03305379f, 
    -0.09713942f, -0.10350750f, -0.07294664f, 0.03990589f, 0.05184245f, -0.02329570f, -0.04091629f, -0.08308592f, 
    0.11248894f, -0.08907908f, 0.01825216f, -0.03883335f, 0.11486603f, -0.09366317f, 0.10879008f, -0.01806482f, 
    -0.05350048f, -0.08061707f, 0.03761320f, -0.07485002f, 0.06898572f, -0.01871997f, 0.04108528f, 0.05401567f, 
    0.09106688f, 0.05071969f, -0.06777281f, 0.11548687f, -0.24541971f, -0.18322013f, -0.02213367f, -0.08480202f, 
    -0.10163632f, 0.15645276f, -0.17445184f, 0.11068454f, 0.18447356f, 0.09446096f, 0.04331313f, -0.05217130f, 
    0.29362756f, 0.11859301f, 0.05150834f, 0.19583061f, 0.07462460f, 0.01919194f, -0.07830141f, 0.13387689f, 
    0.13840145f, 0.08487149f, -0.01594635f, 0.09352470f, 0.08803021f, -0.12350892f, 0.02648017f, -0.15847445f, 
    0.07333489f, -0.16908759f, 0.08198998f, 0.10735182f, 0.39683017f, -0.23688294f, -0.07385232f, -0.09494237f, 
    -0.07904465f, 0.07134555f, 0.07057534f, -0.06115225f, -0.10040186f, -0.02331011f, -0.21644744f, 0.03191274f, 
    0.02187018f, 0.02024731f, -0.06555149f, -0.24561439f, 0.00712575f, -0.16360952f, 0.20498590f, 0.04782248f, 
    0.07336966f, 0.22346023f, 0.09686341f, 0.30496639f, -0.05140744f, 0.33190751f, 0.01269865f, 0.00618693f, 
    0.10810171f, -0.15708630f, 0.10505936f, 0.00232315f, 0.20150940f, -0.02642648f, 0.14658321f, -0.16290824f, 
    0.14173830f, 0.14699234f, 0.10970948f, 0.21523523f, -0.10399106f, 0.08504865f, -0.04839129f, -0.01564693f, 
    -0.07527909f, 0.02397753f, 0.03262810f, 0.19799340f, 0.18258110f, 0.02630662f, -0.05294601f, 0.03937146f, 
    0.08691669f, -0.21301703f, 0.07792313f, -0.01664159f, 0.16107474f, -0.10086524f, 0.08169799f, -0.09448026f, 
    -0.04796953f, -0.20268854f, 0.06368298f, 0.10947868f, 0.00863149f, 0.03053265f, -0.02865777f, -0.11346616f, 
    -0.26350898f, 0.11005011f, -0.01606265f, -0.07673384f, -0.00776022f, 0.04235460f, -0.01141153f, -0.03723302f, 
    0.03995293f, -0.04518440f, -0.04224393f, 0.16375406f, -0.01171473f, -0.08134013f, -0.08888991f, 0.12325840f, 
    -0.22187024f, 0.08835393f, -0.02023238f, 0.15381470f, 0.20163289f, -0.22065736f, 0.05581228f, -0.06373553f, 
    -0.08800667f, 0.11193719f, 0.10014776f, 0.06289335f, 0.02555004f, 0.04176825f, -0.08720172f, -0.09841952f, 
    -0.11149211f, -0.12397780f, -0.07345421f, -0.08660023f, 0.03025457f, -0.07539682f, -0.10687501f, 0.01472842f, 
    -0.01104158f, -0.09117056f, -0.08667536f, -0.07561488f, -0.03382959f, 0.06499633f, -0.04889630f, 0.00590131f, 
    0.01109166f, -0.04340354f, -0.03498602f, 0.10440278f, -0.15474020f, -0.11640520f, -0.03107681f, -0.06140082f, 
    -0.02107733f, 0.01440929f, 0.12165165f, 0.08152289f, -0.07719626f, -0.11009705f, 0.03568727f, 0.04113217f, 
    0.01383715f, -0.09600572f, -0.03004409f, 0.01643498f, 0.03683310f, 0.03372591f, 0.04265382f, -0.03191001f, 
    -0.00230886f, -0.02453600f, 0.08145091f, -0.13114713f, 0.01403405f, 0.02247979f, -0.07348401f, -0.06949551f, 
    0.05505893f, -0.02573770f, 0.05717565f, 0.06957018f, -0.03966955f, -0.00843439f, 0.01169404f, -0.07259510f, 
    0.15886404f, 0.31049389f, 0.11385487f, 0.07864746f, -0.06609678f, -0.15279353f, -0.01356391f, 0.08857959f, 
    -0.04393657f, -0.11867908f, -0.02961179f, -0.09659249f, 0.20696042f, 0.00408851f, 0.05121187f, 0.02755193f, 
    0.25370440f, 0.03724471f, -0.09090608f, 0.03793627f, -0.04622927f, -0.03945905f, -0.29277328f, 0.29044554f, 
    0.05312036f, 0.01818411f, 0.14101624f, -0.04253308f, -0.19477543f, 0.05734611f, 0.17273478f, -0.17663881f, 
    -0.08833151f, 0.15917611f, -0.04577461f, 0.11833458f, -0.33290330f, 0.07669855f, 0.19294629f, -0.11613241f, 
    -0.05923136f, 0.09423526f, -0.12733312f, -0.07735312f, 0.03231755f, -0.08317166f, 0.08975577f, -0.02392237f, 
    -0.06903853f, 0.11314133f, 0.04499058f, 0.04945463f, -0.04309103f, -0.05238169f, -0.04695585f, 0.20277876f, 
    0.00186467f, 0.11052559f, -0.16453764f, 0.20532867f, 0.12552369f, 0.35222933f, -0.30155936f, 0.08055878f, 
    0.22393745f, -0.11267059f, 0.09685767f, -0.00007159f, -0.06146828f, 0.19803384f, 0.11700504f, -0.11305438f, 
    -0.00946630f, 0.07488122f, -0.11714458f, 0.16406091f, -0.22467665f, 0.10702641f, -0.04310495f, -0.11467722f, 
    -0.03720148f, 0.19869383f, 0.08349587f, 0.01133935f, -0.01794342f, 0.01898363f, -0.06714865f, -0.07378314f, 
    0.18595757f, 0.10353704f, -0.13010684f, -0.11408352f, 0.23181261f, 0.08526688f, 0.29449341f, -0.18141595f, 
    0.11549982f, 0.00263777f, 0.02123915f, 0.10541077f, -0.00269761f, 0.04218085f, 0.08171488f, 0.03283757f, 
    0.15254870f, 0.09470648f, 0.08397589f, -0.02644364f, -0.05295723f, 0.11404037f, 0.19417313f, 0.14521389f, 
    -0.03543377f, -0.13047741f, 0.10985039f, 0.08907721f, -0.03059823f, -0.08687405f, -0.26014799f, 0.01078920f, 
    -0.16628298f, 0.07842586f, 0.23530672f, -0.12592202f, 0.07378592f, -0.09104787f, -0.11939377f, 0.22097541f, 
    0.02152420f, 0.18521124f, -0.08776161f, -0.03854683f, -0.11350075f, 0.01761781f, -0.12374787f, -0.19139817f, 
    0.01318085f, 0.05811958f, -0.00634503f, 0.26969442f, -0.15799278f, 0.05717744f, -0.03754162f, -0.09451084f, 
    -0.13846059f, -0.08516235f, -0.05582871f, 0.19161284f, 0.02505784f, -0.10266335f, 0.04725986f, -0.04769607f, 
    -0.10742633f, -0.08306103f, -0.04977795f, -0.09374042f, -0.08086708f, 0.02764900f, 0.47174901f, -0.10034204f, 
    -0.08054885f, -0.05107753f, -0.00265671f, -0.03338801f, 0.11872942f, 0.28129625f, -0.15321314f, 0.11258911f, 
    0.31529620f, 0.04842344f, 0.23780920f, -0.01227030f, -0.10893600f, -0.02630660f, 0.32154146f, -0.02004855f, 
    0.11532091f, 0.02793494f, 0.04140702f, 0.19025385f, -0.05323572f, -0.20663172f, -0.07840238f, 0.18143891f, 
    -0.27533934f, -0.03164642f, -0.04364831f, -0.15906489f, 0.03855599f, -0.09428890f, -0.36967281f, -0.01907630f, 
    -0.03238154f, -0.11567956f, -0.10825193f, -0.07391325f, 0.04462248f, -0.11622654f, -0.14793324f, 0.10324582f, 
    -0.14374532f, -0.12196958f, 0.01072766f, 0.05791539f, 0.02332782f, 0.08714870f, -0.09271593f, -0.02245700f, 
    -0.02459865f, -0.01785384f, -0.05818649f, 0.02732429f, -0.12611131f, 0.11895490f, -0.02924496f, 0.03221681f, 
    0.05345367f, -0.11436030f, 0.01124591f, 0.04090708f, -0.03838471f, 0.07737313f, 0.02560207f, -0.01611935f, 
    0.04931431f, -0.07415286f, 0.08043264f, -0.06771506f, 0.04735656f, 0.03448980f, -0.01633620f, -0.04055752f, 
    -0.06906794f, 0.04377536f, 0.11422140f, -0.04639968f, 0.11690405f, 0.12123028f, -0.08849936f, -0.02919353f, 
    -0.02692011f, -0.13965419f, -0.12313165f, -0.03540099f, -0.07749928f, 0.08502392f, 0.09104548f, 0.03529571f, 
    0.01404094f, 0.05535969f, 0.01039124f, 0.02972605f, -0.11244146f, 0.02119646f, 0.01977047f, -0.11937192f, 
    -0.00655463f, -0.02557976f, 0.01279126f, -0.09323715f, -0.09517293f, -0.12047926f, 0.18198499f, -0.01570294f, 
    0.09197733f, 0.16639659f, 0.24933189f, 0.14506325f, -0.00598421f, 0.09029803f, 0.02457889f, 0.02725057f, 
    0.01627798f, -0.12180861f, 0.04672397f, 0.21056890f, 0.21655747f, -0.00574189f, -0.13816506f, -0.27276266f, 
    0.14533423f, -0.13423386f, 0.17867237f, 0.03356970f, -0.07436640f, 0.06866957f, 0.09809070f, 0.24125056f, 
    -0.08471451f, 0.12183871f, -0.01580284f, 0.25003430f, 0.09425143f, -0.25478125f, -0.25913233f, -0.08030418f, 
    -0.07577843f, 0.01977797f, -0.15963444f, -0.02242306f, -0.08782136f, 0.09388602f, -0.13804148f, -0.05558297f, 
    -0.10659589f, -0.03637394f, 0.04420007f, -0.00279038f, 0.11789379f, -0.29206327f, 0.14030637f, 0.16342001f, 
    -0.13071056f, 0.25780055f, -0.17510563f, 0.18746874f, 0.09262647f, -0.33049384f, -0.17544565f, -0.17294501f, 
    -0.00118791f, 0.06839735f, -0.00663264f, 0.00228413f, 0.01808488f, 0.00131921f, -0.01179763f, -0.01616805f, 
    0.09775013f, -0.11878034f, -0.04817082f, -0.13822241f, -0.02805324f, 0.01401136f, -0.00804268f, -0.03234189f, 
    0.25273544f, 0.11904862f, -0.10715097f, -0.12244278f, -0.24684092f, -0.00038757f, -0.15849400f, 0.17391159f, 
    0.23805946f, 0.10067829f, -0.00651421f, 0.00256093f, -0.14746435f, -0.05358424f, 0.16661011f, -0.06971061f, 
    -0.11550692f, 0.08118793f, 0.10667166f, 0.07514969f, 0.31086925f, -0.05085923f, -0.04175394f, -0.04802957f, 
    0.06097268f, -0.04489993f, 0.20003758f, 0.10552738f, 0.08797648f, -0.04127574f, 0.11236572f, -0.05526258f, 
    -0.06416591f, 0.00602217f, 0.10674682f, 0.07850336f, 0.10358651f, 0.12766932f, 0.26072386f, 0.08732418f, 
    0.09838556f, -0.09005088f, -0.08780366f, -0.23685063f, 0.08746650f, 0.31767058f, 0.09893161f, 0.28557691f, 
    -0.02408083f, 0.02703997f, -0.09476244f, -0.10343930f, -0.19574274f, -0.18322775f, -0.07353544f, 0.20757313f, 
    -0.02636421f, -0.01398311f, 0.17681468f, 0.13424362f, 0.20033693f, -0.06983450f, -0.11472555f, -0.07603531f, 
    -0.06850146f, -0.25337106f, -0.01674258f, 0.15157092f, 0.16220473f, 0.11090888f, -0.22448762f, -0.13414764f, 
    -0.12257591f, 0.12598975f, 0.22123669f, -0.04107205f, 0.15953144f, 0.07622917f, -0.25584936f, 0.20218992f, 
    0.07471740f, 0.18074830f, 0.08340371f, 0.01895934f, 0.13121225f, -0.35179046f, -0.32547992f, -0.09278717f, 
    0.12270285f, -0.07922212f, -0.08528339f, -0.00015228f, -0.02359844f, 0.05563780f, 0.08500178f, 0.07742002f, 
    -0.02578184f, 0.05840476f, 0.11634877f, -0.01728786f, -0.08229718f, 0.10884947f, 0.33626372f, 0.08068166f, 
    0.05541002f, 0.04899912f, 0.00615159f, 0.35367766f, -0.01398321f, -0.26635695f, 0.07254227f, -0.26152602f, 
    0.01487573f, 0.09321699f, -0.01851146f, -0.01578320f, -0.11406310f, -0.28566408f, 0.30791923f, 0.03785774f, 
    0.00730141f, 0.21489289f, 0.19984816f, 0.06952824f, 0.04499459f, -0.02016460f, -0.10505720f, -0.01055910f, 
    0.06494090f, 0.01716998f, -0.01867568f, 0.09457549f, 0.19680679f, 0.05609858f, -0.51684231f, -0.14363082f, 
    0.28055838f, 0.09687466f, -0.11140050f, 0.12096172f, 0.18444315f, 0.01432412f, -0.14764680f, 0.18681417f, 
    0.03400285f, -0.14033535f, -0.09271704f, -0.00431008f, 0.01585232f, -0.28532618f, -0.15428656f, -0.08354884f, 
    0.13813296f, 0.12403002f, -0.05462791f, 0.05608398f, 0.09075967f, 0.07455657f, 0.03089658f, 0.16666548f, 
    -0.08661710f, -0.24530429f, -0.02884736f, -0.14983268f, -0.02097611f, -0.37260914f, 0.16389118f, 0.03864374f, 
    -0.08643293f, 0.04930035f, 0.08059822f, -0.01015551f, 0.12832370f, 0.03258507f, 0.03341624f, 0.09393246f, 
    -0.00393988f, 0.02793967f, 0.00712832f, 0.06855136f, -0.12181188f, 0.11609624f, -0.08813719f, 0.11249764f, 
    0.02900738f, 0.07163503f, 0.06275406f, 0.29052916f, 0.18952467f, 0.10428017f, 0.05229697f, -0.06816777f, 
    0.05289647f, -0.26835084f, 0.06592213f, -0.01388436f, 0.13891052f, 0.09236041f, 0.18165980f, 0.00632393f, 
    -0.29395336f, 0.03261412f, 0.30249819f, 0.04307996f, 0.14600323f, 0.08978776f, -0.17716262f, 0.10149702f, 
    0.07492576f, 0.08560894f, -0.00802736f, -0.06179178f, 0.35235932f, -0.15309367f, -0.14696249f, 0.00436244f, 
    0.16524497f, 0.07370273f, 0.09313155f, -0.06364930f, 0.12169335f, -0.07234993f, 0.09562439f, 0.15167296f, 
    0.11616401f, 0.00625725f, -0.04440032f, -0.19989182f, 0.08559704f, 0.09963379f, 0.18687131f, -0.12123103f, 
    0.09166110f, -0.11791544f, -0.06717806f, 0.06696209f, -0.07855467f, 0.05445877f, 0.36211374f, -0.15845996f, 
    -0.06493716f, 0.01283415f, 0.11463116f, -0.09163681f, 0.30352303f, 0.33556670f, -0.15461303f, 0.12100842f, 
    -0.07574569f, 0.10766230f, 0.23172936f, -0.06495781f, 0.02957056f, 0.10714271f, -0.01510033f, -0.07486468f, 
    -0.02537595f, 0.13848822f, 0.03608623f, 0.14924452f, -0.12098382f, -0.02975345f, 0.20525372f, -0.01796389f, 
    0.12549631f, 0.02013100f, 0.31968516f, -0.03737792f, -0.15727656f, 0.08896597f, -0.00853594f, 0.21015973f, 
    0.05021064f, -0.10059038f, -0.00702377f, -0.21169972f, 0.10793708f, -0.16547607f, -0.00320313f, -0.10578583f, 
    -0.24853279f, -0.03162379f, -0.12929071f, -0.11660038f, 0.04183023f, -0.03391360f, 0.18499833f, -0.02126890f, 
    0.09686220f, -0.05732472f, 0.06829458f, 0.09711808f, -0.00976617f, 0.19768235f, -0.03779716f, 0.14843035f, 
    0.16243877f, -0.17686623f, -0.12399662f, -0.03569001f, 0.10907397f, -0.09860602f, 0.36567983f, -0.01496795f, 
    0.24195993f, -0.01170202f, -0.02861649f, 0.03289476f, 0.29629037f, 0.08504806f, -0.07178280f, 0.01160297f, 
    0.23803253f, 0.01505042f, -0.11674603f, 0.02812440f, 0.01705587f, 0.04626562f, 0.06949715f, -0.10910726f, 
    -0.02169634f, 0.37313884f, 0.03095572f, -0.08118886f, -0.18292901f, -0.08225787f, 0.06561627f, 0.07539102f, 
    0.09306546f, 0.31012875f, -0.23669931f, 0.02824171f, 0.11357705f, 0.12141131f, -0.15837298f, 0.01077827f, 
    -0.09881218f, -0.02120428f, 0.09123629f, -0.00824364f, 0.05685410f, 0.36252895f, 0.02362320f, -0.02184662f, 
    -0.12486225f, -0.12175523f, 0.03201077f, -0.05458674f, -0.09668557f, 0.06309729f, 0.15660736f, -0.00064163f, 
    0.03915055f, 0.06894310f, 0.01186924f, 0.04601983f, -0.11240386f, 0.40515819f, -0.25324100f, 0.14842133f, 
    -0.16261765f, -0.12001657f, 0.30188072f, -0.17123182f, 0.17008895f, 0.02775419f, -0.02042252f, 0.14953446f, 
    0.05450489f, 0.18455026f, -0.09106894f, -0.08274852f, -0.21240078f, -0.24958056f, 0.18400614f, 0.02239174f, 
    0.16539671f, -0.17765950f, -0.12239452f, 0.07080912f, -0.21800995f, 0.11126176f, 0.01888160f, 0.10359102f, 
    -0.07541464f, 0.29360998f, -0.06015156f, -0.09415863f, -0.02870523f, 0.10480437f, 0.01998160f, -0.22588626f, 
    0.02185272f, 0.18781100f, -0.22175881f, -0.11866195f, 0.04842464f, -0.00069359f, 0.00585635f, 0.00932620f, 
    0.07295503f, 0.18674539f, 0.06160265f, 0.10828276f, 0.21067117f, 0.42764130f, 0.11778378f, -0.07615525f, 
    0.45897904f, -0.10061523f, -0.02169626f, -0.10481262f, -0.07638863f, -0.01198886f, 0.17277379f, 0.28883389f, 
    0.10954268f, 0.02148361f, -0.04487137f, 0.06559771f, 0.05700637f, -0.08433025f, 0.24660674f, -0.02942896f, 
    0.16410699f, 0.18953733f, 0.03110783f, -0.14137055f, -0.22269192f, 0.45479375f, 0.10844987f, 0.04490567f, 
    -0.02563390f, -0.12658820f, 0.05725633f, -0.05822239f, 0.27406400f, 0.09702831f, -0.22619194f, 0.16421025f, 
    0.15189248f, 0.22073066f, 0.12144797f, 0.03901147f, 0.19223076f, 0.10036664f, -0.07009527f, -0.02755482f, 
    -0.02945601f, -0.08110137f, -0.02675894f, -0.20547423f, 0.01477652f, 0.07775676f, 0.08460054f, 0.29158065f, 
    0.04249153f, 0.29349059f, 0.11596237f, -0.06660446f, -0.14116216f, 0.08475144f, -0.07873619f, 0.04564182f, 
    0.02671462f, 0.26183978f, 0.06944850f, 0.06672937f, -0.28920251f, 0.21019223f, 0.21414727f, -0.05820112f, 
    -0.20945607f, -0.05403120f, 0.17655240f, -0.04959771f, -0.00450050f, 0.00915410f, -0.18283920f, -0.24212421f, 
    -0.01348548f, 0.08336552f, -0.09298662f, 0.32346117f, -0.04247969f, 0.17007828f, 0.08616897f, 0.13699941f, 
    -0.17841451f, -0.06705699f, 0.27880827f, 0.09988664f, 0.00513912f, -0.09126883f, -0.04177821f, -0.04052767f, 
    -0.05503365f, 0.15119182f, -0.06690885f, 0.12648924f, 0.00566941f, -0.09013528f, -0.09903442f, 0.06721793f, 
    0.08126673f, -0.12395172f, 0.10098274f, -0.13942084f, 0.03482038f, -0.03898996f, -0.00615374f, 0.02680279f, 
    -0.01724904f, 0.44161940f, 0.03389828f, -0.17853771f, -0.13497667f, 0.07993326f, -0.25309986f, 0.07342283f, 
    0.21400635f, 0.26327848f, -0.18130882f, 0.04760511f, 0.00746896f, 0.02222212f, -0.03203567f, -0.04679679f, 
    -0.07630129f, 0.08267193f, 0.06756189f, -0.01451929f, 0.16377492f, -0.05989770f, 0.01388881f, -0.04873923f, 
    -0.18879339f, -0.05351194f, 0.06567504f, -0.03550217f, 0.01390390f, 0.06375416f, -0.14126523f, 0.08163130f, 
    -0.03282124f, -0.08565363f, -0.07004166f, -0.04827430f, 0.00165067f, 0.18506138f, 0.11047794f, 0.18913694f, 
    0.14208092f, -0.07113218f, 0.14012571f, -0.18493806f, 0.10852306f, 0.11753005f, 0.19053955f, 0.33474433f, 
    -0.10544886f, 0.06202146f, -0.06165176f, -0.06781398f, 0.03569253f, -0.06470791f, -0.12415412f, -0.10142123f, 
    -0.12207095f, 0.06746470f, -0.05646052f, -0.07941146f, 0.02178467f, 0.03574513f, -0.11948126f, -0.12158026f, 
    -0.03445322f, 0.10622709f, -0.07315436f, 0.01231234f, -0.13253748f, 0.08963259f, 0.07784333f, 0.00021719f, 
    0.07125298f, 0.00463399f, -0.02306185f, 0.11802793f, -0.10247878f, 0.06146176f, -0.10211434f, -0.08604969f, 
    -0.03551015f, -0.12374237f, -0.04985650f, 0.02220661f, 0.08172310f, 0.02584291f, -0.10440606f, -0.05677205f, 
    -0.08598357f, 0.10648565f, 0.03455488f, -0.07448757f, 0.09526326f, -0.10694094f, -0.02093204f, -0.09806189f, 
    -0.03742002f, 0.03062017f, 0.07482827f, 0.08416648f, -0.00435908f, -0.11991120f, 0.08756708f, -0.00486004f, 
    -0.02865555f, 0.01793167f, 0.00892641f, -0.12284102f, 0.06200049f, -0.00645542f, 0.11177922f, 0.02610122f, 
    -0.13920322f, -0.05120446f, 0.03585596f, 0.00266357f, 0.07244638f, -0.13763386f, -0.07399227f, -0.15190347f, 
    0.09943648f, 0.01265933f, -0.05466331f, 0.04233887f, -0.11172388f, 0.05644445f, 0.07318287f, 0.06117572f, 
    0.03059149f, 0.00547633f, -0.02118033f, 0.03857785f, -0.08920152f, 0.08247255f, -0.04544981f, 0.08201139f, 
    -0.02746626f, -0.09547580f, 0.05221460f, 0.06249216f, -0.07558230f, 0.10503635f, -0.10502616f, -0.01238645f, 
    -0.11961094f, -0.12386937f, -0.08957580f, 0.00992155f, -0.02932451f, 0.04429016f, -0.00432158f, 0.06868879f, 
    -0.07869169f, 0.10651422f, -0.06039586f, 0.10022542f, 0.10831805f, -0.00564685f, -0.01462955f, -0.02162239f, 
    -0.11308576f, -0.00759333f, 0.00843667f, 0.00032312f, 0.00569857f, -0.02485898f, 0.03765706f, -0.01361112f, 
    0.01578947f, -0.02282122f, 0.09394634f, 0.01349638f, -0.15523100f, -0.12727015f, 0.05066237f, 0.01845719f, 
    0.06399871f, -0.18107499f, -0.01993488f, -0.11755764f, 0.17808488f, 0.11638811f, 0.28365609f, -0.04993738f, 
    -0.02638346f, 0.20533113f, 0.08104603f, -0.20308532f, 0.18913157f, -0.11202022f, -0.01974100f, -0.07419062f, 
    0.31285408f, 0.00876409f, -0.08149492f, 0.02497611f, 0.11326937f, -0.04758867f, -0.01646161f, 0.25106552f, 
    0.28708130f, 0.20217314f, 0.11621414f, -0.12492320f, -0.02189368f, 0.08457641f, 0.05149932f, 0.01009476f, 
    -0.06302290f, -0.19790621f, 0.11112394f, -0.17682435f, -0.07677224f, -0.11529311f, 0.11996160f, 0.03598274f, 
    -0.22377664f, 0.09095790f, 0.22576699f, -0.10588259f, 0.08561338f, -0.05785962f, -0.16862854f, 0.00029684f, 
    0.07437807f, -0.10798886f, -0.00095368f, 0.06575450f, 0.01923200f, -0.20536511f, -0.03512651f, 0.22796819f, 
    0.16951190f, -0.01337954f, 0.11484929f, -0.17419851f, 0.27906540f, -0.10526938f, 0.18068603f, 0.21948686f, 
    0.00026036f, 0.07603879f, -0.07585847f, -0.02486555f, -0.10669983f, -0.25570804f, 0.33462429f, 0.01609011f, 
    -0.14378428f, 0.08335176f, 0.26246291f, -0.05129284f, 0.01285114f, -0.07207864f, -0.00680569f, -0.09303176f, 
    0.02786271f, -0.24675626f, 0.01033371f, -0.07646162f, 0.26560086f, 0.09850060f, -0.08427625f, -0.26715159f, 
    0.14030589f, -0.05551660f, 0.07019268f, 0.11784836f, 0.03255964f, 0.07922964f, 0.08513854f, 0.19810040f, 
    0.09606671f, 0.05211674f, -0.12680513f, 0.05311178f, 0.09937009f, -0.03236226f, -0.07946786f, -0.09392583f, 
    0.29551476f, 0.12553650f, 0.06223959f, 0.09352494f, 0.06800308f, -0.01636473f, -0.09717541f, 0.03004075f, 
    0.06872149f, 0.06142571f, -0.08194681f, -0.14413376f, -0.00535151f, -0.40094936f, 0.13462828f, 0.10547785f, 
    0.14352360f, 0.26617557f, -0.19322905f, 0.06064593f, -0.08078401f, -0.28830123f, -0.00994814f, 0.11995435f, 
    0.05789364f, 0.16952236f, 0.04530996f, -0.04139739f, 0.19189611f, 0.20187899f, -0.07036927f, 0.06959121f, 
    -0.17202392f, 0.08313692f, -0.11581030f, 0.02389256f, 0.26101059f, 0.07635999f, 0.00364937f, 0.09292670f, 
    0.20895122f, -0.00954822f, -0.05272735f, 0.28478327f, 0.12325587f, -0.03548748f, 0.08002669f, 0.41866520f, 
    -0.27323002f, -0.12309782f, 0.18195361f, -0.04377605f, 0.12061755f, -0.07739183f, 0.04559491f, -0.00784212f, 
    -0.04222889f, 0.11788843f, 0.05193114f, -0.16252717f, -0.22791202f, -0.04940506f, 0.10556629f, -0.09289482f, 
    -0.23977423f, -0.00906813f, -0.15949574f, -0.02346292f, 0.05151536f, 0.05630625f, 0.19110158f, -0.05327878f, 
    0.04827428f, 0.25458342f, -0.11748841f, 0.04373647f, 0.08803594f, 0.23084538f, -0.14919072f, 0.01931391f, 
    0.07350172f, 0.02880193f, -0.11001319f, 0.25375283f, 0.01695550f, 0.20405476f, 0.04867198f, 0.03368404f, 
    -0.10873360f, 0.16151249f, -0.11916534f, -0.04518187f, -0.06559948f, -0.06376671f, 0.09699056f, 0.18690771f, 
    0.02734894f, -0.09243967f, 0.16231611f, 0.06260785f, 0.24098714f, 0.04270118f, 0.03563170f, -0.08635813f, 
    -0.10420811f, -0.03835265f, 0.11695094f, 0.05942082f, 0.05455358f, -0.02163459f, 0.11173136f, 0.13127621f, 
    -0.09417094f, -0.05038694f, 0.25899398f, 0.03510450f, 0.14913258f, -0.09087466f, -0.23942815f, 0.18933132f, 
    0.03100730f, 0.20973614f, -0.02186735f, 0.15593627f, 0.01482648f, -0.08611441f, -0.17666617f, -0.02208044f, 
    -0.14085543f, -0.09752905f, -0.03477380f, -0.07740811f, 0.02180686f, -0.08750385f, 0.03133560f, -0.32188082f, 
    -0.00962901f, 0.17538276f, 0.02850588f, -0.14377697f, 0.08267808f, 0.17014182f, 0.15223919f, 0.03517657f, 
    0.14393087f, 0.19748700f, -0.06475160f, 0.28037184f, -0.04225504f, -0.25200060f, 0.04398954f, -0.14891626f, 
    0.08432223f, -0.03741119f, 0.09059633f, 0.01669270f, 0.02943039f, 0.22923885f, -0.21198443f, 0.18004069f, 
    -0.01010495f, 0.37331113f, -0.06346031f, 0.31682318f, 0.14089563f, -0.01120333f, -0.00162713f, -0.11059166f, 
    0.05915203f, -0.09281735f, 0.01258549f, 0.15305509f, -0.08330420f, 0.07837310f, 0.01196086f, 0.18605731f, 
    -0.09419831f, 0.11665698f, 0.05626748f, 0.02068754f, 0.08064655f, -0.10768001f, -0.02362442f, 0.25851899f, 
    0.06093625f, 0.26820606f, -0.10447742f, 0.18901712f, 0.11215468f, -0.35848376f, -0.28782904f, -0.10396486f, 
    -0.11319744f, -0.10949332f, 0.16326167f, -0.02922963f, -0.05401145f, -0.07709856f, 0.06523253f, 0.02549053f, 
    0.02039236f, -0.17960714f, 0.04451026f, -0.03043570f, 0.06649028f, 0.03770079f, -0.05732936f, 0.03410889f, 
    -0.19534071f, -0.19312389f, 0.13440397f, -0.06177466f, -0.02449778f, -0.17222819f, 0.17174913f, -0.13485900f, 
    0.16302434f, 0.08277848f, -0.02228029f, 0.02500381f, 0.40644240f, -0.01804931f, -0.04734559f, 0.19022231f, 
    0.23208736f, 0.00769221f, 0.14632602f, 0.04848586f, -0.14581963f, -0.01126239f, -0.08589587f, 0.10621890f, 
    -0.38908994f, -0.05377837f, -0.02369795f, 0.03091196f, -0.00891974f, -0.07112494f, 0.43355826f, -0.17426668f, 
    -0.17909646f, 0.00737135f, 0.06157133f, -0.08947852f, 0.00005903f, 0.04305370f, -0.25264579f, 0.12288448f, 
    0.08037344f, 0.00419804f, 0.06023018f, 0.13252582f, -0.02548342f, 0.33887514f, 0.08217894f, 0.07066314f, 
    0.02948345f, -0.07677950f, -0.13363065f, 0.01925749f, 0.08149035f, -0.08641241f, 0.06556398f, -0.15339279f, 
    -0.11850655f, -0.00014522f, -0.14475714f, 0.12967984f, -0.00674626f, 0.44345692f, -0.20187788f, -0.00611551f, 
    -0.08911753f, -0.17803311f, 0.12001655f, -0.03212739f, -0.07710467f, -0.26134223f, 0.05795012f, -0.24488655f, 
    -0.03280009f, -0.18792212f, -0.04551183f, -0.00553029f, -0.14196365f, -0.15970059f, 0.34229526f, -0.01289068f, 
    -0.00410426f, 0.11225133f, 0.20841014f, -0.13917406f, 0.02352546f, 0.06531179f, 0.07879598f, 0.01631804f, 
    0.18465662f, -0.09500823f, -0.11921361f, 0.06244072f, 0.09924886f, 0.09683331f, -0.36286101f, -0.24675015f, 
    0.15511866f, 0.21329397f, -0.11693461f, -0.05083928f, 0.12815239f, 0.06099589f, 0.16843221f, 0.08613035f, 
    -0.03335274f, -0.10023157f, -0.08643816f, -0.06016495f, 0.07735655f, -0.05357440f, -0.19869000f, -0.10883793f, 
    0.10879923f, 0.06071506f, 0.24690692f, 0.05842744f, 0.07263945f, -0.12047857f, -0.07498178f, 0.00386703f, 
    -0.11027548f, -0.08457910f, -0.03404981f, 0.02808664f, -0.08912914f, -0.39270920f, -0.14861450f, 0.09336684f, 
    0.10952312f, 0.11439133f, 0.01750096f, -0.21708676f, 0.21074221f, -0.30239856f, 0.16237912f, 0.12618819f, 
    -0.01958117f, -0.04761080f, -0.05876296f, 0.07424577f, 0.12827481f, 0.36064366f, -0.17307767f, -0.10103600f, 
    -0.01301152f, 0.18433630f, 0.15818861f, -0.01330381f, -0.00541296f, 0.07935682f, -0.10966334f, -0.09985458f, 
    -0.11199765f, -0.23093845f, -0.09270900f, 0.10742307f, 0.05649390f, 0.11380136f, 0.20620814f, 0.07601243f, 
    -0.11154939f, -0.08123089f, 0.32702327f, -0.05378812f, -0.09507447f, -0.08996452f, 0.45687017f, 0.19323748f, 
    -0.00605414f, -0.12290340f, 0.04167475f, -0.10306665f, -0.09683480f, -0.04881638f, -0.04812447f, 0.08003169f, 
    0.13154416f, 0.02607426f, 0.08480899f, -0.03884193f, -0.04073201f, 0.04778585f, 0.21732941f, 0.21185234f, 
    -0.06934020f, -0.19648048f, 0.01649134f, 0.09920616f, 0.10844270f, -0.21808577f, -0.48791024f, -0.06559460f, 
    -0.26361224f, -0.18051453f, 0.08443852f, -0.14176513f, 0.14054000f, -0.35540742f, 0.15062930f, 0.04544225f, 
    -0.12338336f, 0.17192763f, 0.05655507f, -0.11545916f, 0.11719327f, 0.03474043f, -0.21634278f, 0.01564389f, 
    0.16145514f, 0.11968977f, 0.30581927f, 0.10389496f, -0.18169458f, 0.11881586f, 0.06626659f, 0.08092717f, 
    -0.03540254f, 0.09285942f, -0.09164997f, 0.28527084f, -0.23874725f, 0.08005743f, -0.12578663f, -0.12565723f, 
    0.22732061f, -0.04470290f, -0.04778675f, 0.09661387f, -0.18766282f, -0.04759037f, 0.08288793f, 0.10941478f, 
    -0.07175561f, 0.01433197f, 0.04246472f, 0.17395064f, -0.08154609f, 0.03326192f, -0.13089803f, 0.01413743f, 
    0.19446100f, -0.09355136f, 0.14117047f, -0.04926366f, 0.06464908f, -0.03240216f, 0.31613883f, -0.12208492f, 
    -0.08533916f, -0.19448188f, -0.00675143f, -0.03376799f, 0.06153056f, 0.10123595f, 0.09531186f, 0.21409027f, 
    -0.14224660f, -0.10160448f, -0.32921878f, -0.14392067f, -0.00546562f, 0.00306922f, -0.27525932f, 0.14530541f, 
    0.04175801f, 0.14950824f, -0.08562017f, -0.08450974f, 0.26484913f, -0.04577595f, 0.23469961f, -0.01169926f, 
    0.12714617f, -0.06364069f, 0.09963423f, -0.00659147f, 0.05857437f, -0.05593675f, -0.07345957f, 0.07014644f, 
    0.15863463f, 0.27429393f, 0.06903169f, 0.17326686f, 0.16168025f, -0.03331383f, 0.00158942f, 0.01530810f, 
    0.02465110f, -0.09225933f, -0.09390474f, 0.04111643f, 0.21952944f, -0.08696213f, -0.24970767f, -0.23352963f, 
    -0.08354769f, -0.23328584f, 0.12710950f, -0.03868486f, -0.24891625f, 0.32934394f, 0.26863882f, 0.12690470f, 
    -0.11317787f, 0.13095421f, -0.25830221f, 0.09771928f, -0.04136678f, -0.04752608f, -0.11934343f, 0.06790815f, 
    -0.07586118f, 0.15781742f, -0.08050358f, 0.16243452f, 0.10790976f, 0.28949368f, 0.03713773f, 0.03785417f, 
    0.07905799f, 0.09372986f, 0.14747000f, 0.23073375f, 0.08857270f, 0.20569900f, -0.07662956f, -0.02744356f, 
    0.09216587f, -0.07498078f, 0.08008044f, -0.03722275f, 0.22917604f, -0.08836956f, 0.29142326f, 0.20366526f, 
    -0.07302972f, -0.23585902f, 0.04596422f, -0.03977521f, 0.10607981f, 0.01579281f, 0.00705198f, 0.05156913f, 
    0.01138451f, 0.03664434f, 0.06122818f, 0.07117350f, 0.28360578f, -0.11874893f, 0.07244161f, -0.13384742f, 
    -0.10969165f, -0.07033605f, 0.09102585f, 0.07463270f, 0.29160950f, -0.10680206f, -0.23399526f, 0.10964958f, 
    0.02408405f, -0.12256279f, 0.06096271f, -0.10060313f, -0.00067236f, -0.05970791f, 0.19230795f, -0.11971235f, 
    -0.10856929f, -0.10811506f, -0.15509760f, 0.08348975f, -0.07620861f, -0.11415066f, -0.16489442f, 0.08465247f, 
    -0.02682434f, 0.23664334f, -0.02165140f, 0.03410495f, -0.04996550f, 0.15579997f, 0.04574797f, -0.01312500f, 
    0.31004298f, 0.17791393f, 0.21291834f, 0.18972172f, -0.11321568f, -0.12486182f, 0.25153822f, -0.12211632f, 
    -0.07072680f, -0.10133526f, 0.00963712f, -0.04379460f, -0.04594610f, 0.00842484f, 0.00330214f, 0.00755367f, 
    -0.02742718f, 0.01681463f, 0.00512362f, 0.05197012f, -0.06850728f, 0.01137395f, 0.06538674f, 0.00800599f, 
    -0.09608401f, 0.04083574f, -0.02407514f, -0.10057773f, -0.09214512f, -0.06862248f, -0.03724565f, -0.14580041f, 
    -0.12537006f, -0.08082383f, 0.07794939f, -0.08238512f, 0.04088806f, 0.00140704f, 0.07572148f, -0.11461422f, 
    -0.11115993f, -0.06930912f, -0.09374288f, -0.09854499f, 0.05722705f, 0.09979191f, 0.02044462f, 0.02802195f, 
    -0.07336712f, -0.06354438f, -0.13805322f, -0.06751011f, -0.08871860f, -0.04854508f, -0.10863380f, -0.01189498f, 
    0.01186447f, -0.01909459f, 0.02062371f, 0.02777896f, -0.01581365f, -0.06127927f, 0.00043078f, -0.03072712f, 
    -0.05080672f, 0.03009032f, -0.04197717f, 0.06847777f, -0.03286583f, -0.08200776f, -0.08049032f, -0.07253084f, 
    0.01658960f, -0.13551462f, 0.02882797f, 0.00506698f, -0.17061403f, 0.08551230f, -0.03981701f, 0.12419946f, 
    -0.03060346f, 0.27663934f, -0.08112490f, 0.20656863f, -0.03024709f, -0.11480033f, -0.00532507f, 0.04871693f, 
    -0.06926584f, -0.17048675f, -0.09397259f, 0.03683758f, 0.14075758f, -0.02438694f, 0.17590012f, 0.15271856f, 
    0.00017069f, -0.24385567f, 0.27252036f, -0.01592897f, -0.00359226f, -0.09949286f, 0.31575587f, -0.06592659f, 
    0.07175630f, -0.00463679f, -0.04560693f, 0.20049137f, 0.17962728f, 0.05077487f, 0.13214849f, 0.02426311f, 
    -0.02427348f, -0.03257990f, 0.05159536f, 0.05830230f, 0.09559516f, -0.02314337f, -0.16002609f, 0.16189048f, 
    0.09951773f, 0.10533853f, -0.07207794f, 0.09638806f, 0.00729427f, -0.06970748f, 0.15278663f, -0.03400272f, 
    -0.14154589f, 0.11839782f, -0.10706993f, 0.33761135f, -0.13919392f, 0.15562895f, -0.20825183f, -0.23805936f, 
    0.05447822f, 0.15464184f, 0.00028107f, 0.11087584f, 0.14651904f, 0.00757808f, 0.15827033f, 0.08502763f, 
    -0.14379822f, -0.27474234f, -0.00859370f, -0.23274580f, 0.08046548f, 0.00814149f, 0.04498637f, -0.09138329f, 
    0.15289266f, 0.05469485f, -0.06757131f, -0.21810640f, 0.19659379f, -0.09974439f, 0.10031507f, -0.08762494f, 
    -0.05008975f, 0.17778306f, 0.13300306f, 0.06401236f, 0.08157123f, -0.02921951f, 0.09027743f, 0.18837373f, 
    -0.04613909f, -0.08559653f, 0.01661603f, -0.21623893f, -0.22506340f, 0.00990281f, 0.24981523f, -0.10565046f, 
    0.03155717f, 0.01400859f, 0.08497208f, 0.02217456f, 0.03879871f, -0.00740196f, 0.08334959f, 0.05917202f, 
    -0.11221284f, 0.16145985f, -0.07680075f, 0.16647884f, 0.09705691f, -0.05228123f, -0.16516607f, 0.08167490f, 
    0.15290251f, -0.09924020f, 0.15371606f, -0.30772215f, 0.07594753f, 0.06627385f, 0.19109446f, 0.27785227f, 
    -0.09843186f, -0.10236845f, 0.08715287f, 0.01145682f, 0.01068892f, -0.05474859f, 0.03280322f, -0.11600327f, 
    -0.07997576f, 0.04196091f, 0.06209580f, -0.01865948f, -0.04541494f, -0.11103448f, -0.09514466f, -0.11620280f, 
    0.01594766f, 0.03430000f, 0.00467998f, -0.01981941f, 0.06523111f, -0.06945603f, -0.10184483f, -0.03339936f, 
    -0.09799621f, 0.01534742f, 0.00102256f, -0.01012184f, -0.04419946f, 0.08572893f, 0.10133006f, -0.13613246f, 
    -0.10510503f, 0.08674316f, -0.08480586f, -0.11216751f, 0.02498362f, -0.03716927f, -0.07449925f, -0.12317127f, 
    0.02846143f, 0.10814758f, -0.09448279f, -0.00180055f, -0.02735606f, -0.12006544f, -0.02153058f, -0.04768812f, 
    -0.06640519f, 0.02950688f, -0.03708284f, 0.01810056f, 0.04134698f, -0.05940813f, -0.01862901f, -0.13340017f, 
    -0.11664195f, -0.00475935f, 0.07375573f, -0.13074851f, 0.02634606f, 0.02320107f, -0.10289983f, 0.06122622f, 
    -0.05509071f, 0.17989250f, 0.03302746f, 0.05217240f, -0.04255680f, 0.22797355f, -0.18232515f, 0.06624781f, 
    -0.14197798f, 0.05428301f, -0.14300828f, 0.02512060f, 0.23007327f, 0.00707172f, -0.05358826f, -0.05456502f, 
    0.27517453f, 0.03659255f, 0.01702177f, 0.35049164f, 0.17192145f, -0.07311714f, -0.03549332f, 0.28626952f, 
    -0.00197144f, -0.14710250f, 0.24138236f, -0.05186379f, -0.05882081f, -0.08597045f, -0.08123993f, -0.06867909f, 
    0.01146040f, -0.12481362f, -0.00863691f, 0.08190467f, 0.09484753f, -0.24446829f, 0.06007246f, -0.10992315f, 
    -0.20238476f, -0.03821914f, -0.03647661f, 0.08357625f, 0.10445242f, -0.06267289f, 0.13578314f, -0.00160958f, 
    0.09373557f, 0.04623447f, -0.11192968f, -0.14565006f, 0.04857202f, 0.18597531f, 0.10277380f, 0.09216891f, 
    -0.05713971f, -0.05685794f, -0.17244717f, 0.23584543f, 0.17908004f, 0.39206025f, 0.13730820f, -0.10562368f, 
    0.09028030f, -0.13217035f, 0.01578350f, -0.08905848f, 0.32705516f, -0.02713519f, -0.01532652f, 0.18714528f, 
    0.25719357f, 0.17893557f, 0.28749850f, -0.10833008f, 0.01865043f, -0.03413817f, -0.10319648f, -0.06383808f, 
    -0.20826696f, 0.16545103f, 0.08365309f, -0.27820611f, 0.01764848f, -0.06377047f, 0.30819762f, -0.20990144f, 
    0.19869384f, 0.22459717f, -0.15741369f, -0.00959164f, -0.18557304f, 0.02534039f, -0.21528633f, 0.09076715f, 
    -0.04723612f, -0.16033834f, -0.05043396f, 0.28957099f, 0.05625275f, 0.43085861f, 0.03089259f, -0.10148148f, 
    0.12860098f, -0.10013165f, 0.11884478f, -0.06703683f, 0.11263002f, -0.05433835f, -0.22816269f, -0.03331557f, 
    0.01658147f, 0.12677883f, 0.09636148f, 0.29575247f, 0.02794076f, 0.12252588f, 0.19718364f, -0.08649873f, 
    0.08291224f, -0.13748683f, -0.01989674f, -0.23650672f, -0.11638124f, -0.27307492f, 0.05677361f, 0.11117820f, 
    0.19900961f, -0.06221719f, -0.11170802f, 0.06749658f, 0.28277424f, -0.06235789f, -0.22973253f, 0.15006360f, 
    0.25792226f, 0.17481968f, -0.02785881f, 0.13929290f, -0.18208942f, 0.06609948f, 0.08706460f, -0.10055079f, 
    -0.13990244f, 0.24607259f, 0.09125593f, -0.15973702f, -0.10101310f, 0.02724133f, 0.12133927f, 0.11210535f, 
    -0.03551950f, 0.22353266f, -0.11384695f, -0.02083145f, 0.06179602f, -0.11804659f, -0.00458183f, -0.09054560f, 
    -0.07087038f, 0.12537253f, -0.12105791f, 0.33910924f, 0.10157426f, 0.29620281f, 0.06979766f, -0.02909580f, 
    0.12362780f, 0.07396817f, 0.22069417f, -0.09379702f, -0.07490903f, 0.00086951f, 0.09498281f, 0.14127414f, 
    0.02707703f, -0.12563039f, -0.13715349f, 0.22899945f, 0.01195775f, 0.35179982f, 0.05961556f, -0.06704812f, 
    -0.27767599f, -0.09866353f, 0.16915010f, -0.00098291f, 0.00076203f, 0.00979783f, -0.17688347f, -0.12487868f, 
    0.14046434f, 0.19209947f, -0.04609803f, -0.00262468f, -0.05363880f, -0.21578534f, 0.01138235f, 0.20185246f, 
    -0.03693045f, -0.12746879f, -0.19659793f, 0.02272017f, 0.10771839f, -0.10867779f, -0.01539975f, 0.04393237f, 
    0.02936695f, 0.10845006f, -0.08068909f, -0.03258074f, 0.01261449f, -0.10159986f, -0.09993101f, 0.19125973f, 
    -0.06396914f, 0.26622444f, -0.07203803f, -0.04029365f, 0.28020129f, -0.01171166f, -0.20187891f, 0.04843162f, 
    -0.01551241f, 0.28915867f, -0.09182437f, 0.13551569f, -0.29040691f, 0.05892689f, -0.04609349f, 0.09441345f, 
    -0.06871962f, 0.01385541f, 0.09251375f, -0.04671716f, -0.03468245f, 0.03573596f, -0.04555352f, 0.15429084f, 
    -0.06949149f, 0.12618297f, -0.10944937f, -0.10166980f, 0.10079876f, 0.04470121f, 0.15491115f, -0.08318004f, 
    -0.11764006f, -0.18932445f, 0.28972870f, -0.02626896f, -0.21807243f, 0.24661508f, -0.11444333f, -0.04820172f, 
    -0.14765565f, -0.00766181f, -0.09763235f, -0.08285767f, 0.16655497f, -0.13937303f, 0.25529590f, 0.20134138f, 
    0.02611626f, 0.08609513f, 0.17715237f, 0.01523534f, -0.04082486f, 0.05297741f, 0.02034479f, -0.03575646f, 
    0.03228191f, 0.01213662f, 0.08761344f, -0.18247424f, 0.15793878f, 0.09675752f, -0.00219423f, -0.27722660f, 
    0.10315146f, 0.13272464f, 0.21215251f, 0.05752053f, 0.10189516f, 0.12118585f, -0.16583300f, 0.11118077f, 
    -0.00404507f, 0.12862809f, 0.08539157f, 0.09756084f, 0.10151309f, 0.07842869f, 0.05594188f, -0.08877876f, 
    0.22593163f, -0.07262874f, 0.17468764f, -0.10896783f, -0.06766757f, 0.03622604f, -0.13153119f, 0.21421348f, 
    0.12297274f, -0.07464810f, -0.11431328f, -0.00150572f, -0.07853898f, -0.13346069f, 0.29144686f, -0.11830900f, 
    0.22371818f, -0.10288614f, 0.17265208f, -0.15519425f, -0.14238040f, 0.05554429f, 0.21419525f, -0.01075444f, 
    -0.01341468f, 0.13870119f, 0.00241296f, -0.10956945f, 0.30573091f, -0.16455948f, 0.12336931f, 0.09422827f, 
    0.00724576f, -0.04405315f, 0.15040424f, -0.21499719f, -0.11491214f, -0.07489696f, 0.11393744f, -0.07978727f, 
    -0.09628787f, 0.38495675f, -0.08869097f, -0.33961299f, 0.00469809f, -0.00251190f, -0.00599089f, -0.19598693f, 
    0.13761246f, 0.20484996f, -0.29486057f, 0.06167032f, -0.18973322f, 0.06518827f, -0.14979060f, 0.06007404f, 
    -0.00217620f, 0.02563952f, 0.05360994f, 0.06990217f, -0.26139840f, 0.44248161f, 0.02800709f, 0.05294770f, 
    0.07364171f, -0.01547184f, 0.18758163f, -0.02944171f, -0.06147265f, -0.09213186f, -0.17809075f, -0.12014047f, 
    0.10955267f, 0.19984646f, -0.04298817f, 0.32512945f, 0.02133169f, 0.13130528f, 0.27894500f, 0.13919532f, 
    0.15670127f, -0.02575590f, 0.04682789f, -0.23469016f, -0.05931145f, 0.05428607f, 0.05587048f, 0.06859511f, 
    -0.10066205f, 0.03425268f, -0.01857498f, -0.10219771f, -0.03208337f, -0.03899780f, 0.06277812f, 0.06083165f, 
    0.05670970f, 0.02471588f, -0.10345906f, -0.13425766f, -0.13117540f, -0.08775643f, 0.06033579f, 0.02230573f, 
    0.02394932f, 0.04285899f, 0.07006052f, -0.14493537f, -0.03193212f, 0.00326405f, 0.11074644f, -0.04629302f, 
    -0.08450919f, 0.04032255f, -0.10570916f, 0.07866967f, -0.15498777f, -0.01169312f, 0.07229465f, -0.04322365f, 
    0.11093467f, 0.03370086f, -0.03816049f, -0.01053200f, -0.10613195f, 0.04419152f, 0.05796869f, 0.04206194f, 
    -0.07052598f, 0.11714451f, 0.02409067f, 0.01885803f, -0.09911965f, 0.01434921f, 0.07503669f, -0.07150508f, 
    -0.05775456f, -0.11342517f, -0.08790025f, -0.06830875f, 0.01941074f, -0.05816718f, -0.00625946f, -0.04059615f, 
    -0.03588532f, -0.02115549f, -0.01365717f, 0.00442454f, -0.11581901f, -0.07313164f, -0.12419062f, -0.00755282f, 
    -0.09149788f, 0.00656975f, -0.10066424f, 0.05997604f, 0.03468725f, 0.12852088f, 0.05288544f, 0.02857486f, 
    -0.00949215f, 0.17608424f, 0.19413437f, 0.33918568f, -0.23279469f, 0.00075346f, 0.05798426f, -0.01748602f, 
    0.00792099f, -0.06517601f, 0.06796197f, 0.10072919f, 0.22875623f, 0.09914505f, 0.16593781f, -0.15451784f, 
    0.20610413f, -0.16070513f, 0.29395860f, 0.01096481f, 0.09897147f, 0.05980500f, 0.04326821f, 0.05562524f, 
    -0.00533521f, -0.17968908f, -0.07180621f, 0.30842605f, 0.30754894f, -0.01182918f, 0.08052348f, -0.00479962f, 
    0.32052618f, -0.03589648f, 0.02675687f, -0.01471454f, 0.01329029f, -0.10351028f, -0.05593408f, 0.28134024f, 
    -0.04190322f, -0.08814512f, -0.04633292f, -0.00121477f, -0.07007325f, -0.07842910f, 0.19855611f, 0.07081222f, 
    -0.16784671f, -0.07730291f, -0.06803615f, 0.07595445f, -0.02922389f, 0.07337818f, -0.15958667f, -0.07569603f, 
    0.01796273f, 0.20227361f, 0.12422772f, -0.07271072f, -0.26757488f, -0.20650259f, -0.06103189f, 0.14852594f, 
    0.04546748f, 0.02707329f, 0.01894324f, -0.01639209f, -0.00039960f, 0.05266748f, 0.04706616f, 0.04597283f, 
    0.21477029f, 0.10621174f, -0.08653117f, -0.03503915f, -0.10608985f, 0.04516590f, -0.31919947f, 0.09926225f, 
    0.04704306f, 0.10570813f, -0.09033745f, 0.05957521f, -0.01664937f, -0.01036889f, -0.03766008f, 0.25289404f, 
    0.07744161f, 0.22114472f, -0.07182191f, 0.03131533f, -0.05959446f, -0.20369609f, -0.24673881f, -0.12374926f, 
    -0.00821485f, 0.02648615f, 0.11704060f, -0.04057170f, 0.03391847f, -0.11001714f, 0.09298445f, -0.15357879f, 
    -0.03734522f, -0.01848700f, 0.00268339f, -0.01645088f, -0.01774362f, -0.14419861f, 0.22107804f, 0.02578198f, 
    -0.04357589f, 0.18512172f, 0.08805545f, 0.02602160f, 0.08364754f, -0.01061587f, -0.12350396f, 0.16203640f, 
    0.18204452f, 0.25212187f, 0.08091533f, -0.04674600f, 0.24243033f, 0.13043895f, -0.28348652f, 0.10964480f, 
    0.11365300f, -0.03039023f, 0.07289065f, 0.15514004f, 0.05239043f, -0.09431607f, 0.03911755f, 0.03794197f, 
    0.05704125f, -0.09659295f, -0.08507359f, 0.06536093f, -0.11063010f, -0.08874240f, 0.15055721f, 0.06176974f, 
    -0.21294884f, 0.10353269f, 0.09365403f, 0.10949192f, 0.00291120f, 0.00436721f, 0.03700141f, 0.09636297f, 
    -0.01055599f, 0.10816058f, -0.11303876f, -0.09771329f, -0.40605852f, 0.16222934f, -0.07314323f, 0.11151532f, 
    -0.02036466f, -0.04551800f, 0.03965901f, 0.07050853f, 0.02909368f, -0.07491766f, 0.25729162f, 0.03517891f, 
    -0.08497167f, 0.14979170f, 0.01563744f, 0.18623379f, 0.11448301f, 0.24162906f, -0.13429043f, 0.05245028f, 
    -0.29692218f, -0.29764497f, 0.10791395f, -0.01956176f, -0.02517337f, 0.01162350f, -0.20915732f, -0.06515989f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01776631f, 0.01870695f, -0.05164128f, 0.09323289f, 0.08580682f, -0.07043844f, -0.01476636f, 0.06674186f, 
    0.10590006f, 0.11437050f, 0.04121345f, -0.06329790f, -0.00431043f, 0.10139993f, -0.01116144f, -0.11573317f, 
    -0.01265649f, -0.06379997f, -0.00467980f, -0.00275725f, 0.03956510f, 0.06528068f, -0.00145798f, 0.10899904f, 
    0.02033097f, -0.09159691f, 0.07430679f, 0.08407219f, 0.12837583f, 0.12207005f, -0.14311633f, -0.11414775f, 
    0.06734011f, 0.04060780f, -0.06972235f, 0.10663851f, 0.15727557f, -0.09944142f, -0.03614344f, -0.07870279f, 
    -0.00376463f, 0.05346902f, -0.02988379f, -0.06062486f, 0.06984387f, 0.09708098f, 0.00025686f, -0.01203201f, 
    0.06529831f, -0.11647068f, 0.09885154f, -0.09993033f, 0.11477213f, -0.10976143f, 0.00165115f, 0.15740910f, 
    0.15930972f, 0.14158027f, -0.07623231f, -0.03657060f, -0.02107308f, -0.07875323f, -0.06600579f, 0.16123554f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.04751133f, -0.07591759f, 0.10561568f, 0.28071687f, 0.10540667f, 0.18825687f, 0.01296325f, 0.10814669f, 
    -0.16115251f, -0.18512391f, -0.14305680f, 0.14267419f, -0.23790492f, 0.00675674f, 0.27606878f, 0.29956824f, 
    -0.04337675f, -0.00932816f, -0.01621246f, 0.00551127f, -0.28432539f, 0.17830004f, 0.00537773f, -0.10378358f, 
    0.15388294f, 0.12034059f, -0.07382090f, 0.01756988f, -0.17692885f, -0.36635298f, -0.06611708f, -0.33033636f, 
    -0.14828581f, -0.02648340f, -0.03944457f, 0.09880984f, -0.19804421f, -0.10198218f, 0.09574372f, 0.11200386f, 
    0.21952701f, -0.23824421f, -0.25536087f, -0.37249994f, 0.09563131f, 0.22740361f, 0.12200495f, -0.23258746f, 
    0.03229521f, -0.04343485f, 0.02169207f, 0.24806345f, 0.11597573f, -0.02735261f, -0.46954131f, 0.17345509f, 
    0.02844043f, -0.23447950f, 0.08285479f, 0.06568334f, 0.12227257f, 0.19350043f, -0.33347389f, -0.10541201f, 
    0.07516132f, 0.04327239f, -0.09691112f, -0.23214501f, -0.13577601f, -0.11815188f, 0.22707710f, 0.12550712f, 
    -0.13374710f, -0.05994346f, -0.44165477f, -0.11400127f, 0.16190748f, 0.05498701f, -0.45432684f, -0.31294948f, 
    0.10707629f, -0.12342650f, -0.00077756f, -0.09030442f, 0.29706258f, 0.02057421f, 0.00808033f, -0.00450761f, 
    0.08176557f, 0.11932226f, -0.08100021f, -0.30337012f, 0.30272478f, -0.54152864f, -0.29031238f, -0.19160280f, 
    0.21921460f, 0.14074078f, 0.05278909f, 0.03217035f, 0.17887707f, -0.11660342f, 0.04360263f, 0.09343073f, 
    -0.25446036f, -0.06968872f, -0.35006210f, -0.04498192f, 0.14500245f, -0.06691381f, 0.11628757f, 0.29042163f, 
    -0.01235581f, -0.34510875f, -0.05986102f, -0.01058612f, -0.03459235f, -0.11729384f, 0.09615061f, 0.22784214f, 
    0.20644079f, -0.31438586f, -0.15752669f, 0.24388646f, -0.00760644f, 0.07505384f, -0.11260375f, 0.03405872f, 
    0.08419759f, 0.08778848f, -0.03704491f, 0.25502607f, 0.00604426f, 0.07711292f, 0.12998328f, 0.11573885f, 
    -0.41134107f, 0.16228515f, -0.27372321f, -0.18255699f, -0.29290932f, -0.19246109f, -0.26091138f, -0.27807531f, 
    -0.03261246f, -0.15716235f, -0.05704458f, 0.00299563f, -0.20315707f, 0.03350421f, -0.09772813f, -0.13090989f, 
    0.09097987f, 0.07821112f, 0.05521666f, 0.27900061f, -0.19154689f, 0.17089553f, 0.26456347f, -0.03499610f, 
    0.18393755f, -0.11852138f, -0.18447918f, -0.09230625f, -0.17219760f, 0.12423763f, -0.01744203f, 0.01141748f, 
    0.24439016f, -0.11768930f, -0.07890399f, 0.20835143f, 0.04710539f, 0.20260610f, 0.36812729f, 0.33835834f, 
    -0.26636189f, -0.34450632f, 0.06329931f, -0.06789068f, -0.09843750f, 0.01855278f, -0.07702584f, -0.28976473f, 
    -0.05913351f, -0.17064960f, -0.01084396f, -0.61817312f, -0.01501274f, 0.20369124f, 0.04547866f, 0.13083453f, 
    -0.03774473f, -0.13620339f, -0.03826889f, -0.24524079f, 0.22816212f, -0.07853403f, 0.15975422f, 0.19292770f, 
    0.19686264f, -0.59754080f, 0.21178064f, 0.05779712f, 0.14150630f, -0.32297549f, 0.00021826f, 0.00351252f, 
    0.01149085f, 0.04339207f, 0.07832859f, -0.08982844f, 0.05795085f, 0.15663587f, -0.00868077f, -0.04782110f, 
    0.07300600f, -0.31191528f, 0.10178242f, -0.03808271f, -0.04973019f, -0.08657218f, 0.19535658f, -0.13796313f, 
    0.11755477f, 0.15226386f, -0.05298992f, -0.27385458f, 0.12514333f, 0.08462436f, 0.02165333f, 0.18433182f, 
    0.18171851f, 0.05043605f, 0.01004256f, -0.38399470f, -0.10345588f, 0.36524710f, -0.51919758f, -0.40025777f, 
    0.17066318f, 0.05158582f, 0.04447166f, -0.50036615f, 0.14003856f, -0.10047218f, -0.01388759f, -0.53512615f, 
    -0.38035643f, -0.28645289f, -0.24396990f, -0.42416617f, 0.01708996f, -0.26263297f, -0.01538390f, -0.33421668f, 
    -0.31921235f, -0.06439129f, 0.09882963f, -0.22926341f, -0.26061636f, 0.06980832f, -0.19565563f, -0.05078678f, 
    0.12341791f, 0.11299051f, 0.08163024f, -0.05160413f, 0.11158983f, -0.19616629f, -0.01002789f, 0.12871079f, 
    0.04191531f, 0.03037504f, -0.01472999f, 0.09825283f, 0.11027591f, -0.15282087f, -0.06809840f, -0.21814080f, 
    -0.12495276f, -0.18417837f, 0.05524382f, 0.11758775f, 0.16259976f, 0.19688793f, 0.24164385f, 0.01922195f, 
    -0.01395318f, -0.07284754f, 0.09048341f, 0.05800690f, 0.18614097f, 0.07993886f, -0.09366510f, 0.10680521f, 
    0.21820115f, -0.34953868f, 0.04407969f, 0.10367537f, -0.34852675f, 0.30687433f, -0.34304082f, 0.02693755f, 
    -0.18899532f, -0.05485822f, -0.10363518f, -0.00765246f, -0.09255376f, -0.07828832f, -0.12510490f, 0.13691871f, 
    -0.02875829f, 0.04282305f, 0.25004351f, 0.07544127f, -0.08163343f, 0.04411488f, 0.20551175f, -0.31042400f, 
    -0.09466028f, 0.08011537f, 0.05944356f, -0.47165927f, -0.18519719f, 0.01609212f, -0.10854480f, -0.19694416f, 
    0.23734777f, 0.01920647f, 0.05736046f, 0.16776319f, -0.10661560f, -0.05968444f, -0.17216016f, -0.01432462f, 
    0.05239524f, 0.12135946f, 0.06054834f, 0.02422269f, -0.56049061f, -0.18207176f, -0.00488917f, -0.16882847f, 
    -0.09471685f, -0.58096367f, -0.09876052f, -0.39331082f, -0.07278571f, -0.06409676f, -0.20529616f, -0.17288354f, 
    0.09661794f, 0.19410850f, 0.13007249f, 0.15661564f, 0.08132273f, -0.11204238f, 0.08675537f, 0.00121540f, 
    -0.12971982f, -0.05190102f, 0.05403787f, -0.14903906f, 0.29095137f, -0.20384489f, -0.49342972f, -0.01841929f, 
    0.20772268f, 0.13535510f, -0.00094804f, -0.27034944f, 0.20900409f, 0.01853931f, -0.28595987f, 0.16519508f, 
    0.06123771f, 0.21649987f, 0.22727963f, 0.34852320f, -0.08796015f, -0.10760954f, -0.16780111f, 0.11210632f, 
    0.15320453f, -0.04589797f, -0.12057453f, 0.11756877f, -0.01842612f, 0.11630766f, -0.03414913f, -0.08190900f, 
    -0.30130720f, 0.17205095f, 0.20418115f, 0.17965691f, 0.19809215f, -0.40611935f, -0.23981096f, -0.40016708f, 
    0.09121110f, 0.02750618f, 0.02201904f, 0.04417282f, -0.10892636f, 0.07498807f, 0.01996037f, -0.46715918f, 
    -0.00219570f, -0.44450256f, 0.01826150f, -0.17157748f, -0.14497267f, 0.00448430f, -0.18978883f, 0.23764949f, 
    0.24517436f, 0.13963240f, -0.39007211f, 0.12744763f, -0.08734836f, 0.00285205f, 0.06183168f, 0.11596289f, 
    -0.34364888f, 0.08117916f, 0.05601656f, 0.34537339f, 0.13619141f, -0.03738356f, 0.25211272f, -0.58880931f, 
    -0.13017406f, -0.01468181f, -0.02926518f, 0.03658754f, -0.00844134f, 0.03429884f, 0.05048548f, 0.02287352f, 
    0.08971874f, -0.04041804f, 0.03919585f, -0.39106268f, -0.01213958f, 0.03139344f, -0.27611563f, 0.02697938f, 
    -0.29176241f, -0.05025287f, -0.11819951f, 0.00508533f, 0.15172154f, -0.21126227f, 0.09201848f, -0.27330509f, 
    0.00649480f, -0.04883071f, 0.01358253f, 0.10623496f, -0.20938437f, -0.07299069f, 0.08015648f, 0.13263053f, 
    -0.12383869f, -0.25586674f, -0.04090074f, -0.05295663f, 0.12733981f, -0.30536154f, -0.12940806f, 0.05704046f, 
    -0.36440393f, 0.20113674f, -0.13022742f, -0.15332201f, -0.06143909f, 0.14642864f, -0.06850582f, 0.32658881f, 
    0.03549323f, -0.45396149f, 0.08453753f, -0.51022410f, -0.20506001f, 0.03637010f, -0.01169223f, 0.04928567f, 
    0.13752308f, 0.24363801f, -0.01897838f, -0.17838514f, -0.15383035f, -0.27574515f, 0.09622757f, -0.13088013f, 
    0.15554482f, 0.18930343f, 0.01917255f, 0.13643219f, 0.13881223f, 0.00354108f, 0.22351795f, -0.34889153f, 
    -0.26552272f, 0.02429691f, 0.13766713f, -0.13516033f, -0.02197461f, 0.13223352f, -0.19825774f, 0.02155343f, 
    0.13150717f, -0.14052038f, 0.10998561f, -0.11094525f, 0.13969523f, -0.63104069f, 0.02795373f, 0.08589108f, 
    0.22875293f, 0.19898443f, -0.18471585f, -0.11472507f, -0.15535556f, 0.23427579f, 0.30962247f, -0.37467819f, 
    -0.07257681f, 0.09824158f, -0.00811777f, -0.13671634f, -0.07798495f, -0.39676279f, -0.08193868f, -0.11480586f, 
    0.15960191f, 0.31529438f, 0.07734671f, -0.20478079f, -0.06018272f, 0.12544855f, -0.32856137f, 0.23576228f, 
    -0.32398540f, 0.09168603f, 0.30666298f, -0.07665911f, -0.19761251f, 0.01350280f, -0.01127692f, -0.41556129f, 
    0.07696577f, -0.12102353f, 0.03581085f, 0.15283030f, 0.15096264f, -0.08139922f, -0.20589224f, -0.22009823f, 
    -0.36615545f, -0.21700823f, 0.07552443f, 0.04794884f, -0.08843783f, 0.06883571f, -0.32578313f, -0.15582292f, 
    0.17006207f, 0.18340847f, -0.02608856f, -0.27650973f, -0.08870133f, -0.14853317f, 0.11561296f, 0.19265948f, 
    0.07203151f, 0.08769710f, 0.07814704f, -0.02163399f, 0.10446727f, 0.15225276f, -0.32576862f, -0.27487502f, 
    0.13661472f, 0.13572359f, -0.08064405f, -0.46367636f, -0.08710005f, 0.14295307f, 0.28324392f, -0.00217566f, 
    0.04258439f, 0.10571038f, 0.03116530f, 0.09946550f, -0.04077896f, 0.21772864f, -0.08068813f, 0.01046805f, 
    -0.21514957f, 0.09392583f, -0.00571800f, 0.30495256f, -0.28166795f, 0.19568773f, -0.08661080f, -0.07091641f, 
    0.08048623f, -0.03406767f, -0.18948208f, 0.03737077f, -0.16754055f, -0.04742488f, -0.08110448f, -0.09440275f, 
    -0.00299776f, 0.08515454f, 0.25503695f, 0.01588001f, 0.22033678f, -0.28005680f, -0.42816827f, 0.04512279f, 
    0.14340357f, 0.01629343f, 0.03123303f, 0.22374883f, -0.43340054f, -0.00141467f, 0.09881075f, 0.01633776f, 
    0.04397767f, -0.18023454f, -0.14028634f, -0.27976313f, -0.09026869f, 0.13358967f, -0.12170077f, -0.04782797f, 
    0.24051118f, -0.02191758f, 0.08585385f, -0.05355759f, 0.18868551f, -0.01721688f, -0.14960714f, 0.20726737f, 
    0.08995932f, -0.34940118f, 0.21066208f, -0.25856033f, 0.08482993f, 0.47299930f, -0.04900970f, -0.14158702f, 
    -0.00808134f, -0.47945318f, -0.00423394f, 0.06301699f, -0.18002979f, -0.39914781f, 0.14436154f, 0.26675066f, 
    -0.37055787f, -0.04924689f, 0.08538724f, 0.04303570f, 0.02335290f, 0.04682853f, -0.30329505f, -0.20868973f, 
    0.19625233f, -0.10492461f, -0.41528368f, 0.24201527f, 0.00758545f, -0.11662345f, -0.04983780f, 0.15349944f, 
    0.08149990f, 0.22087689f, 0.20760435f, -0.01631622f, -0.23810063f, -0.06847184f, 0.32533535f, 0.18763366f, 
    -0.12961222f, -0.09408880f, -0.08048327f, -0.20378686f, 0.23352338f, -0.09317540f, 0.09003518f, -0.23016295f, 
    -0.28362310f, 0.03394075f, -0.31412965f, 0.00956473f, 0.03862453f, -0.60337639f, 0.18083005f, 0.10730434f, 
    -0.20272467f, 0.01357944f, -0.07394953f, -0.25726449f, -0.27103481f, 0.32303113f, 0.29278266f, -0.07857862f, 
    -0.04110213f, -0.00645493f, -0.25062904f, 0.13073471f, 0.24289502f, -0.19132642f, 0.03548532f, -0.13405330f, 
    -0.04789927f, 0.17520379f, 0.07254282f, -0.01700876f, 0.19688025f, -0.03958394f, -0.05872368f, 0.17267343f, 
    0.15889768f, -0.20558806f, -0.09757081f, -0.28237113f, -0.06775210f, -0.12934339f, 0.01768944f, -0.28342047f, 
    -0.33749184f, 0.13140324f, -0.01257163f, 0.13647965f, 0.09737583f, -0.08041763f, 0.00645085f, 0.07730033f, 
    -0.30771524f, 0.11360023f, -0.15101565f, 0.10550787f, -0.59326386f, -0.27336982f, -0.17793165f, -0.31598186f, 
    0.15680447f, -0.14177300f, 0.05029780f, 0.00164124f, -0.09902753f, 0.00787873f, 0.10624599f, -0.45972213f, 
    0.10782319f, 0.33662999f, -0.17694527f, -0.17725433f, 0.06132859f, -0.14407177f, 0.06451719f, 0.08774018f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.02248810f, 0.11785878f, -0.13277565f, -0.05100631f, 0.03306498f, -0.03876941f, -0.11766438f, -0.06426192f, 
    -0.12584107f, 0.08119716f, 0.09142479f, -0.10459465f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
