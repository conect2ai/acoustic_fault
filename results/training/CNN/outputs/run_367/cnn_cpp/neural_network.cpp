#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.90423328f, 0.62554520f, 0.39313757f, 0.64644539f, -0.44433728f, 0.60180545f, 0.48650855f, -0.50773609f, 
    0.44031432f, -0.95096362f, 0.69430190f, 1.02924776f, 0.84108698f, -0.39628294f, -0.64047325f, -0.41710272f, 
    0.37556711f, -0.24134742f, -0.48078564f, -0.79532707f, 0.00772242f, -0.91492569f, -0.04115614f, -0.27008128f, 
    0.58769149f, -0.45390010f, 0.03679356f, 1.17081785f, 0.93643463f, 0.13565271f, -0.16233441f, 0.04292061f, 
    -0.25997579f, -0.02913409f, -0.13042206f, 0.14526732f, 0.80742121f, 0.97845507f, 0.97383618f, 0.64505571f, 
    0.52389401f, 0.04621441f, 0.45092008f, -0.33940637f, 0.13107492f, 0.92069477f, 0.37717354f, -0.70498621f, 
    0.26909292f, 0.80308872f, -0.47021931f, 0.29026505f, -0.17636411f, -0.24346331f, 0.09221119f, -1.24212742f, 
    -0.69209790f, -0.80226958f, 0.60179782f, 0.25224540f, 0.37191534f, -0.04269190f, -0.11524133f, -0.00918730f, 
    0.96557188f, 0.77186030f, -0.07482395f, 0.71625137f, 0.54077566f, -0.10831460f, 0.56298411f, -0.22833596f, 
    -1.19295740f, 0.90040541f, -0.74795365f, 0.81767303f, 0.53779799f, 0.17532441f, -0.30670473f, -0.15597449f, 
    -0.25886872f, 0.64169520f, 1.06801474f, 0.05484892f, 0.78553778f, -0.33795893f, -0.50572252f, -0.63854694f, 
    -0.11832129f, -0.57881874f, 0.17152259f, -0.17127517f, 0.40508983f, -0.39983556f, -1.05844343f, 0.44094098f, 
    0.11624802f, 0.45184499f, -0.43410417f, 0.84046447f, 0.79927117f, -0.81603932f, -0.69636416f, 0.47001860f, 
    0.84902591f, -0.51425594f, -0.29208800f, 0.34613243f, 0.89339679f, 0.98962075f, 0.40589184f, -0.86630273f, 
    -0.12905698f, -0.33395690f, 0.28678402f, 0.45158446f, -0.26739216f, -0.49599835f, -1.07303441f, -0.68971711f, 
    0.34412330f, 1.05946946f, -0.20054285f, -0.20517932f, -0.21438903f, -0.32835644f, 0.29877993f, -0.56293553f, 
    -0.85596430f, 0.75708926f, -0.67634898f, -0.11930020f, -0.67880762f, -0.06241723f, 0.42455488f, -1.01745975f, 
    0.09798075f, 0.36770415f, 0.79802364f, 0.84442180f, 0.51238990f, -0.14269367f, -0.31600466f, 0.20717525f, 
    0.53616071f, 0.36072394f, -0.48923945f, 0.07814441f, 0.34692127f, 0.67356098f, 0.50617963f, 0.40523741f, 
    0.62063295f, 0.78269541f, -0.84527475f, -0.68808031f, -0.68289727f, -0.25017396f, -0.45910257f, 0.17797060f, 
    0.13617657f, -0.00276222f, -0.70964348f, -0.04063609f, -0.70726383f, 0.77198875f, -0.54789788f, -1.05629933f, 
    0.00512095f, 0.15739767f, 0.43870610f, 0.95821661f, -0.76293975f, -0.56216276f, -0.27120206f, -0.57874012f, 
    -0.18342014f, -0.30503306f, -0.52706742f, 0.10102840f, -0.12473075f, -0.59588051f, 0.86276835f, -0.80821478f, 
    -0.72831202f, 0.11913752f, 0.20119226f, -0.64481789f, -0.48473510f, -0.80874330f, 0.21923137f, 0.48217598f, 
    -0.44522819f, 0.92373908f, -0.76865023f, -0.12742014f, 0.38568661f, -0.38437220f, -0.69755667f, -0.35055837f, 
    -1.02202427f, -0.15217508f, -0.31624404f, -0.39624244f, 0.24851723f, 0.35580796f, 0.12523083f, -1.08746409f, 
    -0.34096867f, -0.89148045f, -0.61232537f, 0.94796944f, 0.54377025f, -0.11042159f, 0.15316135f, 0.36382145f, 
    0.43326554f, -0.46181685f, 0.82377332f, 0.27406639f, -0.79043406f, 0.82378608f, 0.03560792f, -0.45039776f, 
    0.12072152f, -1.32235706f, 1.28825963f, 0.22001870f, -0.36194876f, 0.76515621f, -0.34243074f, -0.19879691f, 
    -0.22128347f, -0.10015506f, -0.56882799f, -0.70022458f, -0.63869637f, -0.61404938f, -0.80370682f, -0.44248769f, 
    0.45435640f, 0.25985503f, 0.15569699f, -0.00538926f, -0.52249140f, 0.61014259f, 0.12941918f, -1.01117063f, 
    -0.98380506f, -0.00326443f, 0.36731982f, 0.37805596f, 0.95763046f, 0.75023443f, 1.00533736f, -0.61598527f, 
    -0.70948684f, -0.60339582f, 0.03410140f, 0.44924694f, 0.06573546f, -0.09847219f, -1.09640074f, 0.96992677f, 
    0.85426861f, 0.47884336f, -0.08758281f, -0.04217798f, 0.38709694f, -0.01876933f, -0.94909382f, -0.73618144f, 
    0.60248429f, 0.06236021f, -0.17066109f, 0.62679911f, -0.38099355f, -0.22639877f, -0.18024601f, -0.29347306f, 
    -0.99545449f, -0.75556350f, 0.42048755f, 0.12320731f, 0.40750715f, -0.40706199f, -0.04939608f, -0.00602304f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03537684f, -0.08705845f, 0.25501174f, 0.20791113f, 0.04321583f, 0.34553429f, 0.33357453f, 0.38048092f, 
    -0.04228280f, -0.15124871f, 0.18792656f, 0.27072817f, 0.37070647f, 0.15109363f, 0.06031842f, 0.24464507f, 
    -0.11181559f, 0.21102339f, -0.09250037f, -0.10320921f, 0.10606547f, 0.18279544f, 0.15648726f, 0.16285424f, 
    0.26114744f, 0.08642311f, 0.16332990f, 0.02255377f, 0.03977756f, 0.25171614f, 0.00239153f, 0.17699520f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03957364f, -0.07384085f, 0.14972720f, 0.04334970f, 0.17022066f, 0.02791942f, 0.09241382f, -0.05418871f, 
    -0.01070624f, -0.02122361f, -0.04482664f, 0.05099081f, -0.00394593f, -0.06290903f, 0.06000660f, -0.09329683f, 
    -0.09753689f, 0.08955821f, -0.06623842f, 0.00176460f, -0.28204033f, 0.24368195f, 0.08507533f, 0.10111825f, 
    -0.08679305f, -0.04785817f, -0.02676453f, 0.08367689f, -0.06752411f, -0.04660914f, 0.03683294f, 0.08733537f, 
    -0.02939243f, -0.01472005f, 0.06261295f, -0.02599601f, 0.01220732f, 0.06634077f, -0.02095776f, 0.00822327f, 
    -0.09925167f, 0.09047259f, 0.07021780f, -0.03968847f, 0.15617016f, 0.03331251f, -0.02827622f, -0.02672982f, 
    0.02629835f, -0.04728419f, -0.01293212f, -0.02228555f, -0.04702461f, 0.11436076f, 0.04769537f, -0.02409874f, 
    -0.04366184f, 0.00371182f, -0.02654220f, -0.01064345f, 0.15113139f, 0.11504851f, -0.09457269f, -0.08183024f, 
    0.12932214f, -0.08889956f, -0.07325085f, 0.00550344f, 0.01538614f, 0.01947922f, 0.01635080f, -0.01048110f, 
    0.02013034f, -0.03904947f, -0.01353184f, 0.11225110f, 0.06124601f, -0.02483338f, 0.09189417f, 0.05722912f, 
    0.10428421f, -0.05926562f, -0.19539446f, -0.18000048f, 0.07355502f, -0.02039436f, 0.01421720f, 0.03760592f, 
    0.01206704f, 0.01099411f, 0.00391821f, 0.03513452f, 0.02243449f, -0.00567809f, 0.03372888f, -0.03954300f, 
    0.02164407f, 0.07778280f, 0.09354945f, 0.06721047f, -0.05499710f, -0.06441784f, 0.02917144f, -0.05279453f, 
    0.00856904f, -0.12367128f, -0.00116423f, 0.05427821f, -0.04278997f, -0.02981837f, 0.01232442f, 0.07163178f, 
    -0.01042629f, -0.08833162f, 0.01981439f, -0.04446393f, -0.00122868f, 0.02935441f, 0.04825872f, -0.01707883f, 
    -0.18410061f, 0.23702317f, 0.12599377f, -0.08347204f, -0.04968994f, -0.00985372f, 0.09031378f, 0.05347288f, 
    -0.01732619f, -0.00498456f, 0.02906704f, -0.01468965f, -0.04833191f, -0.09093831f, -0.02424976f, -0.09606746f, 
    -0.02313580f, 0.03000261f, 0.02354910f, 0.03181922f, -0.07897074f, 0.04420990f, -0.10454841f, -0.05848480f, 
    0.13207890f, -0.01057880f, -0.00218142f, 0.01838793f, -0.03628282f, 0.06715756f, -0.03755378f, -0.08051092f, 
    0.01411992f, -0.01428666f, 0.01811536f, -0.02480116f, 0.03779514f, 0.04650467f, -0.01055766f, -0.03544060f, 
    0.28878254f, 0.02779745f, 0.10584154f, 0.07082840f, -0.08121911f, 0.13791887f, -0.02322029f, 0.02243029f, 
    0.00872637f, -0.05659121f, -0.00210564f, -0.04018866f, -0.09070861f, -0.03029209f, -0.00049660f, 0.02569459f, 
    0.00862621f, 0.01282727f, 0.00150850f, -0.05560241f, 0.27308655f, -0.10458533f, 0.01555582f, -0.09469622f, 
    0.06234625f, 0.03882040f, -0.13580151f, -0.01443385f, -0.00821002f, -0.07815916f, 0.10224584f, 0.03530551f, 
    0.00561874f, 0.06850760f, -0.13670151f, 0.06404191f, 0.06621609f, -0.02585590f, 0.03706089f, -0.06740926f, 
    0.03217722f, -0.00367939f, -0.16926850f, -0.03500689f, 0.07495717f, -0.01817929f, 0.07898730f, -0.18826018f, 
    -0.00125725f, 0.02533301f, -0.03269776f, -0.00150499f, 0.02748845f, 0.03928851f, 0.05041584f, -0.02261497f, 
    -0.05455840f, -0.05239834f, -0.04368143f, 0.00519969f, -0.08810485f, 0.09255393f, -0.05328232f, -0.13694115f, 
    0.08609394f, -0.01891266f, 0.06630263f, -0.07194967f, -0.03499215f, 0.02098006f, -0.02585443f, -0.01231485f, 
    0.12126774f, -0.06986911f, 0.09831627f, -0.07969777f, 0.11036889f, -0.09383794f, 0.02382967f, 0.02137639f, 
    0.03869029f, -0.09682439f, -0.13463193f, 0.06588769f, 0.18895592f, -0.04479178f, -0.09148040f, -0.07630610f, 
    -0.01495877f, -0.05354650f, 0.06216300f, 0.05379455f, -0.02679599f, -0.01104824f, 0.10373367f, 0.03161165f, 
    0.01047049f, 0.03060345f, 0.04540212f, 0.01855910f, -0.06720153f, 0.24576664f, 0.36020914f, -0.01849226f, 
    -0.07957087f, -0.02054140f, 0.08895357f, 0.10486702f, 0.08780390f, -0.09278540f, -0.04143901f, -0.01213860f, 
    0.02720284f, -0.00578925f, -0.04065149f, -0.03087815f, 0.12166578f, 0.03330595f, 0.01562324f, -0.05133676f, 
    0.36056241f, -0.05187862f, 0.09363192f, 0.26041159f, 0.05837215f, -0.00239393f, 0.07033538f, 0.03688280f, 
    0.07149225f, -0.07209092f, 0.01778855f, 0.01433440f, -0.01737123f, 0.01188255f, 0.02974500f, 0.04707364f, 
    0.00718299f, -0.00466218f, -0.06503412f, 0.04190480f, 0.06987226f, 0.12828074f, 0.12293239f, 0.02837244f, 
    0.05297571f, 0.03248310f, 0.01945214f, -0.01376740f, 0.09165828f, -0.00233835f, -0.05191350f, -0.06553991f, 
    0.04310634f, -0.03859220f, -0.01832726f, -0.00981875f, 0.00699690f, 0.09074729f, 0.05163883f, 0.10890955f, 
    -0.30674270f, 0.06380521f, -0.13496001f, 0.00413219f, 0.05583024f, 0.07855190f, -0.03601926f, -0.06928179f, 
    -0.00836103f, 0.08257107f, 0.08803847f, 0.01263085f, 0.07218517f, 0.06328421f, 0.00026397f, -0.00483870f, 
    0.02737693f, 0.17029499f, -0.01085492f, 0.03274958f, -0.06159594f, 0.03793131f, 0.02926889f, 0.06301205f, 
    0.18215968f, 0.03476772f, -0.00197216f, 0.05227855f, 0.10365304f, -0.02757100f, 0.06316620f, -0.01106000f, 
    0.02671659f, -0.04806409f, -0.07023983f, -0.01830787f, -0.04727476f, -0.09616965f, 0.02297646f, 0.05842228f, 
    0.11568066f, -0.08570910f, 0.04009932f, -0.01212246f, -0.00526248f, -0.00954765f, -0.04447891f, 0.07566492f, 
    -0.09127823f, 0.13511553f, 0.05582963f, -0.03524613f, 0.09794471f, 0.03133473f, 0.03265434f, 0.04467172f, 
    0.04752954f, 0.01383921f, 0.07089905f, -0.08159228f, 0.04860663f, 0.09228805f, 0.05316240f, 0.25620046f, 
    0.10102926f, 0.01488482f, 0.04278466f, -0.01070772f, 0.05787346f, 0.00309893f, -0.04414150f, 0.08044015f, 
    0.02585538f, 0.03677868f, 0.07090831f, -0.02579299f, 0.06608152f, 0.01446986f, -0.02672849f, -0.07692503f, 
    0.00040351f, -0.05028084f, -0.12045977f, 0.17058581f, 0.28512523f, -0.01472962f, -0.05638384f, -0.02136689f, 
    0.02831203f, 0.05899988f, -0.02200308f, 0.06645424f, 0.01788120f, 0.06468961f, 0.01065105f, -0.06508564f, 
    0.00998886f, -0.00137579f, -0.09429574f, -0.02635409f, 0.05325953f, 0.03888508f, 0.08551010f, -0.04029812f, 
    -0.30706933f, 0.05429173f, 0.02393567f, -0.01646420f, 0.02238283f, 0.07744833f, -0.03585910f, 0.10801990f, 
    -0.02297468f, -0.02822626f, 0.02715703f, 0.15667734f, -0.07286894f, -0.03305606f, -0.00065859f, -0.09446976f, 
    0.13831264f, -0.06876287f, 0.09960888f, -0.02871843f, 0.02250473f, 0.12901910f, -0.06462871f, 0.01302186f, 
    0.09746900f, 0.04856814f, 0.14265175f, 0.01961885f, 0.05790455f, 0.02891633f, -0.02818363f, 0.14960302f, 
    -0.03784468f, 0.04072700f, -0.03240557f, -0.14116329f, 0.05512332f, 0.26000369f, 0.17219271f, -0.04574179f, 
    -0.01812684f, 0.07572880f, 0.06135609f, -0.03425088f, 0.00231745f, -0.08523069f, 0.03136377f, 0.00375972f, 
    -0.02485638f, 0.07526219f, -0.04414015f, 0.02409769f, 0.03102354f, 0.03211866f, -0.05818016f, -0.06453943f, 
    -0.15465593f, -0.04741827f, -0.04274915f, 0.00076373f, -0.10899571f, -0.00120845f, -0.05268528f, -0.13349891f, 
    0.00790211f, 0.05298815f, -0.06736947f, 0.07458655f, 0.04572463f, -0.06317997f, -0.05714902f, -0.04892163f, 
    -0.00402498f, 0.00085925f, -0.06555990f, 0.04394887f, -0.13361412f, 0.25003365f, 0.04379231f, 0.11517834f, 
    -0.13920319f, 0.06598103f, -0.02844614f, -0.02838839f, -0.06326122f, 0.04649006f, 0.00463128f, 0.05197361f, 
    0.00483260f, 0.01268735f, 0.00483019f, -0.00018892f, -0.09777980f, 0.01295222f, -0.10918522f, -0.08414108f, 
    0.02694708f, -0.03918972f, 0.09785596f, 0.00230910f, 0.06272097f, 0.04084653f, -0.03418168f, 0.02560690f, 
    0.06798658f, -0.00632506f, -0.00104683f, 0.07947942f, 0.02931080f, -0.02554266f, -0.05358447f, 0.05302711f, 
    -0.04457086f, -0.02409990f, -0.05569717f, -0.06367311f, -0.02218855f, -0.19611882f, 0.06285147f, 0.07653680f, 
    0.10441487f, 0.01842879f, -0.03276569f, -0.05979990f, 0.02979774f, 0.03915308f, -0.10537002f, -0.04048457f, 
    -0.01133236f, 0.08049892f, -0.02273693f, -0.05760520f, 0.08453871f, -0.09019937f, 0.04175724f, -0.10529590f, 
    0.04545392f, -0.07082224f, -0.13224345f, 0.00562192f, 0.10113011f, 0.00409219f, -0.13373558f, -0.07315218f, 
    0.06188192f, -0.06520043f, 0.01153318f, -0.01657198f, 0.03740408f, 0.07073464f, 0.01496845f, 0.07950862f, 
    0.07208271f, -0.00569740f, 0.03114713f, 0.04565344f, -0.41695824f, 0.22424120f, 0.17195593f, 0.01280023f, 
    -0.06376950f, -0.04294555f, 0.03120611f, 0.02115561f, 0.07771534f, -0.11286765f, 0.03198202f, 0.03990802f, 
    -0.01126186f, -0.00015377f, 0.05251071f, 0.01856289f, -0.02890088f, 0.04891736f, 0.01165121f, 0.00298475f, 
    -0.24944523f, 0.22250544f, 0.09049521f, 0.17533845f, 0.19699752f, -0.08267209f, 0.15586643f, 0.01632649f, 
    0.09908930f, 0.04087828f, 0.05325627f, -0.05000626f, 0.02565210f, -0.10021472f, -0.13641985f, -0.05497804f, 
    -0.04414415f, 0.07660492f, -0.08487241f, 0.10082302f, 0.02229683f, 0.13848181f, 0.09333785f, 0.16949926f, 
    -0.00725454f, 0.09983075f, 0.09458556f, 0.04470914f, 0.03587328f, -0.13320264f, 0.03115338f, -0.01768626f, 
    -0.01616380f, -0.01636078f, -0.03620769f, -0.00094912f, 0.06229909f, -0.01260053f, 0.02601292f, 0.04477415f, 
    -0.23435672f, -0.07510537f, 0.14954147f, 0.02984545f, 0.14525706f, 0.15208368f, -0.04621825f, -0.04169931f, 
    0.04069975f, 0.00127345f, 0.09003058f, 0.05960841f, -0.06003615f, -0.05827680f, -0.09028467f, 0.02100914f, 
    0.04933449f, 0.16260839f, -0.10755304f, 0.12328934f, 0.05300086f, -0.19022442f, 0.01392749f, 0.16582799f, 
    -0.07323099f, 0.01443835f, 0.10583736f, 0.05146446f, 0.00191749f, -0.12649067f, 0.07804729f, -0.02790463f, 
    -0.09225579f, -0.08549266f, 0.18755871f, 0.00567991f, 0.08468337f, 0.07335322f, 0.13449000f, 0.01360524f, 
    -0.23325039f, 0.13265094f, 0.14467753f, -0.06291176f, 0.21557973f, 0.18478067f, -0.03226775f, -0.04598949f, 
    -0.06041282f, -0.14926180f, -0.06016932f, -0.04586253f, 0.06388235f, 0.02230066f, 0.00240516f, 0.03976438f, 
    0.04505505f, 0.08306994f, -0.20333712f, 0.00055592f, 0.16110916f, -0.27481601f, -0.15627861f, 0.05836040f, 
    0.24598365f, 0.02321617f, -0.00065720f, -0.03882370f, -0.14477429f, -0.02309956f, -0.01593514f, -0.04635557f, 
    0.03303711f, 0.19027644f, 0.07402918f, 0.00183019f, 0.08885337f, -0.05345158f, 0.05232872f, -0.00978254f, 
    0.20630579f, -0.07568574f, -0.04009918f, -0.01964627f, -0.08790430f, 0.07828066f, 0.05278988f, -0.00712724f, 
    -0.02910211f, -0.00709756f, -0.06260837f, -0.08360329f, 0.05384085f, -0.05237215f, -0.01030925f, 0.03514939f, 
    0.04153942f, 0.03879572f, 0.13767728f, 0.11474270f, 0.06234716f, -0.08042303f, -0.10167857f, -0.01019209f, 
    -0.08225741f, 0.00252474f, 0.03420362f, 0.02010336f, -0.12737206f, 0.01853424f, 0.07892571f, 0.05675468f, 
    -0.00220296f, 0.04135505f, 0.08117012f, -0.08107061f, 0.10162447f, -0.07834422f, 0.09535655f, 0.02806868f, 
    -0.39054337f, 0.02954384f, 0.08584619f, -0.08506259f, 0.05009183f, 0.05588687f, -0.00053238f, -0.00625474f, 
    0.03997653f, -0.12101594f, 0.03127800f, 0.08214123f, -0.10104012f, -0.01754051f, -0.05085573f, 0.05805268f, 
    0.13786693f, 0.04880785f, 0.00836617f, -0.00563478f, -0.09949438f, 0.08130329f, -0.00929596f, -0.12496170f, 
    -0.12301403f, -0.03795460f, 0.10792410f, -0.12636431f, 0.05509634f, 0.01912186f, 0.02488697f, -0.00868499f, 
    -0.01790411f, 0.05795913f, 0.01621763f, -0.00100022f, 0.13462906f, 0.13775308f, 0.04026662f, 0.12469675f, 
    -0.44937742f, 0.29285201f, 0.09958074f, -0.08551797f, -0.11941188f, 0.00490599f, 0.01556539f, -0.05557777f, 
    -0.02929235f, -0.02634484f, -0.03320843f, -0.08433687f, 0.08872110f, -0.03613210f, -0.06856940f, 0.02120012f, 
    -0.00105164f, -0.02650264f, 0.03782060f, -0.00177349f, 0.20808259f, -0.27558658f, -0.15139933f, 0.02049637f, 
    -0.06444804f, 0.05815448f, -0.09993836f, -0.06002533f, -0.09499340f, -0.06269526f, -0.02485032f, 0.03648864f, 
    0.05069284f, 0.02130913f, 0.03341533f, -0.03769719f, -0.05372639f, -0.08366928f, 0.21545373f, -0.05048378f, 
    0.07045235f, 0.09859220f, -0.16881828f, 0.14231211f, 0.33814791f, 0.11571821f, 0.02092775f, -0.15644763f, 
    0.07627801f, 0.08883107f, -0.03451711f, -0.05148770f, -0.12394683f, 0.18969943f, 0.01598150f, -0.09564121f, 
    0.06628554f, 0.10135832f, -0.04172817f, 0.01174274f, 0.09129488f, 0.03438886f, -0.01871304f, -0.12061782f, 
    -0.01146298f, -0.00422383f, 0.14778902f, -0.02768586f, -0.11816570f, 0.07361988f, -0.00019894f, 0.09907695f, 
    -0.03509913f, -0.04230464f, 0.04617045f, -0.05383194f, -0.00082674f, 0.14243600f, 0.05254671f, 0.13360380f, 
    0.19744180f, -0.17769268f, -0.23223762f, 0.14839533f, 0.27338856f, 0.02989400f, 0.00516871f, 0.03199530f, 
    0.05860390f, -0.01564540f, 0.04386940f, -0.02052603f, -0.02302397f, 0.05777896f, 0.13038608f, 0.01656385f, 
    0.00670016f, -0.01082632f, -0.02642610f, 0.05432425f, -0.09604038f, 0.28439966f, 0.00141683f, 0.10801446f, 
    -0.09313228f, 0.03437361f, -0.03906612f, 0.13969588f, -0.00024799f, -0.11031412f, 0.01615193f, -0.03736423f, 
    -0.07529695f, -0.11242791f, 0.00358150f, -0.03958854f, 0.05773577f, -0.10035283f, 0.08142269f, -0.06253505f, 
    0.24082389f, 0.24699762f, -0.14058642f, 0.13820982f, -0.06639164f, 0.00337046f, 0.04300110f, -0.02362508f, 
    0.16128327f, 0.09882037f, 0.11663432f, 0.04315693f, 0.15340260f, -0.11095637f, -0.08730543f, 0.03204738f, 
    -0.00247212f, -0.08216979f, 0.08394902f, -0.03029774f, -0.53933644f, 0.20989557f, 0.04513948f, -0.05602526f, 
    -0.12356430f, -0.09649725f, -0.00269552f, -0.00161320f, 0.04621814f, -0.09567406f, -0.02616234f, -0.02647661f, 
    0.04873895f, -0.12419558f, -0.09920342f, -0.00000271f, 0.00415893f, 0.13933899f, 0.10084279f, 0.08663248f, 
    0.08320086f, 0.13984481f, 0.00805321f, -0.06202188f, -0.03448918f, 0.03363192f, -0.06115599f, 0.01744251f, 
    0.03452745f, 0.13612008f, 0.02114471f, -0.04034533f, -0.03304457f, 0.00889003f, -0.04743762f, -0.04933030f, 
    0.04275472f, 0.05523181f, 0.07601377f, 0.12260842f, -0.07750255f, 0.20945600f, 0.20582916f, 0.14719798f, 
    0.21630321f, -0.02164263f, -0.03307187f, -0.06957463f, 0.09227049f, -0.04856640f, 0.05287962f, -0.01052765f, 
    0.04938808f, 0.10000407f, 0.03840522f, -0.02502067f, 0.06077132f, -0.17362541f, -0.12163749f, -0.02629027f, 
    0.10369708f, 0.21806079f, -0.06725945f, -0.05582808f, -0.10907268f, -0.10122294f, -0.01622663f, 0.05832728f, 
    0.05488125f, 0.10538351f, -0.01351059f, 0.02008247f, 0.07645226f, -0.00666585f, -0.02272421f, -0.05165969f, 
    0.02033786f, -0.08543658f, 0.05698343f, -0.08504876f, -0.00737174f, 0.33735862f, 0.18276010f, 0.08830792f, 
    0.22937033f, -0.01665139f, -0.00290338f, -0.02731727f, -0.04915625f, 0.02274273f, 0.14538960f, 0.09296868f, 
    -0.02487885f, 0.06789465f, -0.03430343f, -0.06966807f, -0.05156955f, -0.08051789f, -0.14000422f, -0.03833842f, 
    -0.09982109f, 0.08117723f, 0.12877414f, 0.06632235f, 0.39515325f, 0.15710318f, 0.05457788f, -0.06999499f, 
    0.08988913f, 0.12699100f, -0.08827563f, -0.03164830f, 0.12181520f, 0.07460210f, 0.04941857f, -0.12480690f, 
    0.12286787f, -0.01187205f, -0.17725846f, -0.10987633f, -0.07141304f, 0.33732060f, -0.11268430f, 0.05070410f, 
    -0.04422995f, -0.00935330f, -0.00426078f, 0.04394901f, 0.17800580f, -0.02319423f, -0.00546012f, -0.02516713f, 
    -0.00524083f, 0.10282034f, 0.00269435f, 0.03719983f, 0.06214115f, -0.04614960f, -0.00668083f, -0.09280070f, 
    0.08650333f, 0.27522889f, -0.02268137f, -0.12475218f, 0.00229842f, -0.06421247f, -0.02117721f, 0.05603284f, 
    -0.02133301f, 0.00807680f, -0.00389396f, 0.06612266f, 0.09971011f, 0.11322125f, -0.04179294f, 0.19144760f, 
    0.03901442f, -0.05313774f, -0.07625622f, -0.05868773f, -0.28431234f, 0.09247766f, 0.04564690f, -0.03547697f, 
    -0.05232847f, 0.01613046f, -0.00312437f, 0.09682348f, -0.08515798f, -0.06031235f, 0.04376545f, 0.07486653f, 
    0.02108440f, -0.03232381f, -0.04277491f, 0.09607295f, 0.02899812f, -0.00932599f, -0.06073532f, -0.02512840f, 
    -0.02174216f, -0.11920787f, -0.08162587f, 0.03075700f, 0.16799343f, 0.03190804f, -0.06338017f, -0.06298509f, 
    -0.07002871f, 0.02182403f, 0.05531131f, 0.04353867f, 0.09394069f, 0.06259686f, -0.08889209f, -0.01908148f, 
    -0.02565696f, 0.13593023f, -0.06294423f, 0.02654421f, -0.46822110f, 0.32742792f, -0.05909581f, 0.31693161f, 
    -0.36873773f, -0.00078313f, -0.03633866f, -0.14372571f, 0.00455296f, 0.07379531f, 0.03636607f, 0.05029064f, 
    0.11179742f, 0.07113279f, 0.04544075f, 0.01681441f, -0.07861087f, -0.15914847f, -0.02685438f, -0.06750207f, 
    0.12161490f, 0.27066103f, 0.02656149f, -0.13536961f, 0.06849070f, -0.01440734f, -0.07910723f, -0.02748130f, 
    0.01405723f, 0.02039208f, -0.01459020f, 0.03634823f, 0.11610010f, 0.15545017f, -0.01885913f, 0.11974177f, 
    0.05000926f, -0.05257431f, -0.18689023f, 0.03220829f, 0.15620653f, 0.09754493f, -0.06044893f, 0.24533048f, 
    0.21640512f, 0.05424733f, 0.02248736f, 0.02746179f, 0.13296296f, 0.04387899f, 0.06583806f, 0.02556296f, 
    -0.02876196f, 0.13112755f, 0.06194073f, 0.05274153f, 0.04836844f, -0.13316628f, 0.08740301f, -0.07298703f, 
    0.20562196f, -0.21579796f, -0.29173818f, 0.26136541f, 0.34597501f, 0.05987806f, -0.08208551f, 0.06651430f, 
    -0.04258055f, 0.00297222f, 0.08829473f, -0.07162289f, 0.06955515f, 0.12917100f, 0.05191860f, 0.13506138f, 
    0.05864217f, 0.06193120f, -0.08012229f, -0.02082400f, -0.39249450f, 0.27963933f, 0.11629832f, 0.10350123f, 
    0.01366290f, -0.00511156f, 0.08667031f, -0.11853452f, 0.09595996f, -0.06242990f, 0.10975409f, -0.02907353f, 
    -0.02250113f, 0.01359239f, -0.00322490f, 0.10036671f, -0.03767114f, 0.02944285f, 0.13086714f, -0.06334540f, 
    -0.12699528f, 0.22020750f, 0.14324988f, 0.07283469f, 0.17835407f, 0.00083782f, -0.00876405f, -0.05343750f, 
    0.04770764f, -0.01549960f, 0.02169931f, 0.00867620f, 0.00164150f, -0.11105844f, -0.17005937f, -0.09215332f, 
    0.05994597f, 0.13614610f, -0.13899037f, 0.07672366f, 0.02453020f, 0.17058867f, 0.01217437f, 0.07767352f, 
    -0.07348685f, 0.05761066f, 0.04697413f, 0.09322260f, 0.00077112f, -0.04803630f, 0.01178807f, 0.06965591f, 
    0.04749203f, -0.22277716f, -0.02884371f, -0.01637091f, 0.04521586f, -0.00943477f, 0.04784575f, 0.00398077f, 
    0.00537268f, -0.03871401f, -0.03700680f, -0.01083063f, -0.01280947f, -0.02131958f, -0.02863138f, 0.03003531f, 
    -0.01560945f, -0.01200473f, -0.02830136f, 0.03589004f, -0.03201569f, -0.04301228f, 0.01297332f, 0.00001950f, 
    -0.02165062f, 0.00172977f, 0.02694495f, 0.01416525f, -0.02708543f, 0.01901733f, 0.00830168f, -0.01355520f, 
    0.01866055f, 0.00966342f, -0.02880617f, 0.00816676f, -0.01879848f, -0.04156081f, -0.02632189f, -0.02994066f, 
    -0.04205262f, -0.00562052f, -0.03695748f, -0.01547090f, 0.01949808f, 0.02470488f, -0.03790519f, -0.00845401f, 
    -0.01222961f, -0.02388865f, -0.00825706f, -0.00811450f, -0.01724026f, -0.00826437f, 0.01566865f, -0.02344498f, 
    -0.03253570f, -0.03255803f, -0.01548757f, -0.00880514f, -0.04088184f, -0.02004361f, 0.01040337f, -0.01584997f, 
    0.02309069f, 0.00656897f, -0.02196570f, -0.02850318f, 0.00074071f, 0.02148124f, -0.04325410f, -0.03363178f, 
    0.01946706f, -0.01162010f, -0.02291420f, -0.03013613f, -0.02621058f, 0.00779028f, -0.02421329f, 0.03124295f, 
    0.01249508f, 0.01567877f, 0.00716195f, -0.01386091f, -0.02449840f, 0.01483855f, 0.02367895f, -0.03265040f, 
    0.03268825f, -0.02341810f, -0.04121590f, -0.00232274f, -0.01613519f, 0.02767290f, 0.00276972f, -0.03877429f, 
    -0.04044815f, 0.02840341f, 0.02555134f, -0.01587065f, 0.03058180f, 0.01756188f, -0.01371457f, 0.01265014f, 
    -0.00523301f, 0.01668407f, 0.00341471f, 0.00366513f, 0.01872849f, 0.00761749f, 0.00457947f, 0.01459765f, 
    0.02859998f, -0.01386778f, -0.03778086f, -0.01447400f, 0.02813467f, -0.00294983f, -0.00949972f, 0.00891999f, 
    -0.03863318f, 0.02047057f, -0.03605659f, 0.00466813f, -0.01367589f, -0.02664183f, -0.02042382f, -0.04283387f, 
    0.00070686f, 0.03151055f, 0.00003887f, -0.02806274f, 0.00949085f, -0.04327222f, -0.00033629f, 0.01641723f, 
    0.00743313f, -0.04444289f, 0.02112830f, 0.00093080f, -0.00844870f, -0.02951012f, 0.01582376f, -0.03468618f, 
    -0.02492265f, -0.01008536f, 0.00078122f, -0.03759471f, -0.03720227f, 0.02784475f, -0.04174171f, 0.02704781f, 
    0.02368341f, 0.02530399f, -0.01387067f, 0.02832215f, 0.01081529f, -0.02604204f, 0.01576448f, -0.00983687f, 
    -0.04050951f, 0.02567635f, 0.01399673f, -0.03811513f, 0.03238507f, -0.04361034f, -0.03123751f, 0.01343450f, 
    -0.02032236f, -0.03774526f, 0.00108119f, -0.03566329f, -0.01651320f, 0.00143142f, 0.03329790f, 0.01047639f, 
    -0.03018906f, 0.02231289f, -0.04189805f, 0.02246892f, -0.00429185f, -0.01259511f, -0.03565041f, -0.03454167f, 
    0.02086902f, 0.00598435f, 0.02885254f, 0.02567849f, 0.02425627f, 0.02003312f, -0.03096167f, 0.00248366f, 
    -0.03286754f, 0.00139950f, -0.01651356f, 0.00178406f, 0.00865399f, 0.01937201f, -0.03445000f, -0.02534333f, 
    -0.02989002f, -0.02418355f, -0.02244159f, -0.03354479f, 0.01506889f, 0.02108987f, 0.01992817f, -0.01301410f, 
    -0.01654209f, -0.01885819f, -0.03056948f, -0.01497900f, 0.00624402f, -0.02357991f, 0.01635985f, -0.01539964f, 
    -0.02408454f, -0.03083643f, 0.01736834f, -0.03813875f, -0.03797743f, -0.03360627f, 0.02336004f, -0.03188763f, 
    -0.02959692f, 0.03154375f, -0.00921440f, 0.01085312f, -0.02412658f, -0.04222021f, 0.02445266f, 0.02047515f, 
    0.01733014f, -0.01254946f, 0.01817969f, -0.01776303f, 0.00625645f, 0.01022882f, 0.01804095f, 0.01829717f, 
    -0.02037377f, -0.03535935f, 0.03078708f, -0.04147249f, -0.00483339f, 0.02096486f, 0.00581375f, -0.03879823f, 
    -0.01102451f, 0.00426704f, -0.02808957f, 0.00826995f, -0.02468453f, 0.00405128f, 0.02060222f, -0.03006816f, 
    -0.04107207f, 0.03274837f, -0.02317935f, -0.01752354f, 0.02118146f, 0.00217924f, 0.03292862f, 0.01009049f, 
    -0.01344673f, -0.03375694f, -0.03815004f, -0.01345387f, 0.02063200f, -0.04427040f, 0.02013974f, -0.04405906f, 
    0.00663118f, -0.00806748f, -0.02425375f, -0.00688646f, -0.01661292f, 0.00556971f, -0.02650939f, 0.01527947f, 
    -0.00518953f, -0.00175216f, -0.01725801f, -0.04197371f, -0.01527316f, 0.00287189f, -0.04294359f, -0.02024543f, 
    0.01970929f, 0.01554608f, -0.00707431f, -0.00306683f, -0.01424643f, -0.01077634f, -0.02047375f, 0.01694294f, 
    -0.04214283f, 0.02664196f, -0.00236525f, -0.03728965f, -0.02324934f, -0.02221466f, -0.00099606f, -0.00172661f, 
    -0.00213568f, 0.02494319f, -0.01012398f, 0.00154890f, -0.02420252f, 0.00933546f, 0.00421613f, 0.01513568f, 
    0.02852967f, -0.03780293f, 0.02498508f, 0.02429311f, 0.02262920f, -0.01057946f, -0.03528100f, -0.02808553f, 
    -0.02284661f, -0.02749581f, -0.00918125f, -0.00751419f, -0.02539384f, -0.01739487f, -0.03525907f, 0.02004527f, 
    0.00901005f, 0.01416311f, 0.02795036f, -0.02030563f, 0.02464570f, -0.04308571f, 0.02479388f, 0.00756211f, 
    -0.00388171f, 0.01770706f, -0.03167123f, -0.00282769f, -0.02342114f, 0.01895758f, 0.02784369f, -0.00670250f, 
    0.00845702f, 0.00138162f, -0.01894303f, 0.03190345f, 0.01910956f, 0.01662545f, 0.00803974f, 0.00267371f, 
    -0.02925254f, 0.02224695f, 0.00098287f, -0.02507186f, -0.01468197f, -0.03414216f, -0.03233517f, 0.02846815f, 
    0.00591115f, -0.02099431f, -0.01849025f, -0.00191428f, 0.03295753f, 0.03009713f, 0.03150810f, -0.01169444f, 
    -0.00069183f, 0.03072188f, -0.02069942f, 0.00567339f, -0.02532526f, 0.00098869f, -0.00536601f, 0.01281893f, 
    0.01262822f, -0.00620215f, -0.03671448f, 0.00881624f, 0.00624659f, -0.01011567f, 0.00888688f, 0.03454472f, 
    0.01285677f, 0.01563545f, 0.02873031f, 0.02626141f, -0.00510552f, -0.04242891f, 0.03299840f, -0.00758490f, 
    -0.02787649f, -0.02111386f, 0.01561251f, 0.01207733f, 0.03129233f, 0.02923481f, 0.00535253f, -0.04063105f, 
    -0.02058899f, 0.02281879f, -0.01643014f, -0.00130310f, 0.01890309f, -0.01720070f, -0.00425960f, -0.03610058f, 
    -0.02661966f, 0.01978853f, 0.01531692f, -0.03552867f, 0.02277576f, -0.02942551f, 0.00798019f, 0.01590796f, 
    0.00254984f, 0.03011421f, -0.00011926f, -0.01009844f, 0.00468108f, -0.04162531f, 0.00157109f, 0.03146193f, 
    0.00902334f, -0.00389438f, 0.03165638f, 0.03486612f, -0.03896168f, -0.03716037f, -0.02759166f, 0.02547963f, 
    0.02433932f, 0.02724943f, -0.01674296f, 0.01676619f, -0.00093075f, -0.02823772f, 0.02748312f, -0.01888719f, 
    0.02457516f, 0.02363725f, -0.01791632f, -0.01496265f, -0.01232202f, -0.01776489f, -0.03753681f, -0.01395629f, 
    -0.03156400f, -0.02331392f, -0.00272320f, 0.01069748f, 0.02471322f, -0.00801031f, 0.01227977f, -0.01099859f, 
    0.02765461f, 0.02254443f, -0.03041570f, -0.03644272f, -0.01796772f, -0.01704765f, 0.00336969f, -0.01139767f, 
    0.01754745f, -0.02743789f, -0.03402313f, -0.01985526f, 0.03142508f, -0.04249249f, -0.01271074f, -0.00910687f, 
    0.02330197f, -0.04002121f, 0.01379709f, -0.00379030f, -0.02532351f, -0.02357927f, -0.00329818f, 0.02531996f, 
    -0.02484342f, -0.03173730f, 0.02895411f, 0.02856694f, 0.02472159f, -0.03584787f, -0.01706238f, -0.02106400f, 
    0.01118000f, -0.00806332f, 0.03307223f, 0.01543977f, 0.03202017f, 0.02772323f, -0.04116784f, -0.03519100f, 
    -0.01390595f, -0.01866826f, 0.02836802f, 0.02260621f, -0.02148237f, -0.00024280f, 0.02940677f, -0.00839921f, 
    -0.02637671f, -0.00395034f, -0.02448787f, 0.01995926f, 0.03493705f, -0.03802083f, 0.03248186f, 0.02096329f, 
    -0.01208338f, 0.02090278f, 0.02327438f, -0.02696128f, -0.03619020f, -0.01708019f, -0.02295343f, 0.00678545f, 
    -0.01886551f, 0.01653862f, 0.01909399f, -0.03658806f, -0.00532039f, 0.02059420f, 0.02030792f, -0.00687154f, 
    -0.03272676f, -0.04116277f, -0.03632850f, -0.01713869f, -0.00939081f, -0.04288494f, -0.02485037f, -0.01280772f, 
    0.01533160f, -0.04297363f, 0.00100170f, 0.00360238f, -0.01582829f, 0.02028121f, -0.04343760f, 0.02627030f, 
    0.02471923f, 0.03081291f, -0.04107802f, 0.02126731f, 0.02317937f, -0.01002667f, 0.02770767f, 0.03065893f, 
    -0.00612103f, -0.04139491f, 0.00790076f, -0.01994932f, -0.02425794f, -0.00703568f, -0.00569026f, 0.02353568f, 
    -0.01989582f, 0.02966387f, 0.01194178f, -0.00779454f, -0.02550044f, 0.02869554f, -0.00773328f, -0.00342159f, 
    -0.01171875f, -0.02152534f, -0.00933425f, -0.01766003f, 0.02573564f, -0.02504895f, 0.00242138f, 0.01807424f, 
    0.00559161f, -0.00554102f, -0.02893297f, -0.03708155f, -0.02022135f, -0.00370145f, -0.00240050f, -0.02727860f, 
    0.00184886f, -0.03369350f, 0.02641649f, -0.00776070f, 0.00176656f, 0.01992875f, 0.00079328f, -0.04146352f, 
    -0.03796954f, 0.01444435f, 0.03411083f, 0.03431351f, 0.03153268f, -0.04080998f, -0.00984029f, -0.00948398f, 
    0.02985326f, 0.00245415f, -0.01572322f, -0.04037857f, -0.00461132f, 0.03243041f, 0.00522304f, 0.01837315f, 
    0.01798374f, -0.02242048f, -0.02866080f, -0.02413581f, -0.02835510f, 0.00232448f, 0.01123685f, -0.01878784f, 
    -0.02778253f, -0.03007599f, -0.02585693f, -0.03565143f, -0.01126753f, -0.00664195f, 0.00381803f, -0.02383170f, 
    -0.01300979f, -0.01478559f, -0.04553202f, -0.01929049f, -0.01132124f, 0.01130235f, 0.01855482f, 0.02401563f, 
    -0.01265504f, -0.00273487f, -0.00105981f, -0.00569566f, -0.01736419f, -0.01431971f, -0.01197705f, -0.00530184f, 
    -0.02939112f, -0.00536214f, 0.03305384f, 0.00472802f, 0.01488672f, -0.04075449f, 0.01113825f, 0.03120623f, 
    -0.22930856f, -0.40524989f, 0.17086819f, -0.00865736f, -0.32418618f, -0.07885962f, 0.06109731f, 0.00874984f, 
    0.03382212f, 0.14331132f, 0.06838668f, -0.08373990f, -0.06108715f, 0.04650444f, -0.03475742f, -0.02785810f, 
    0.07635696f, 0.09314600f, -0.10541350f, -0.10370617f, -0.17497510f, -0.15944566f, 0.43625104f, 0.31549096f, 
    -0.13447426f, 0.07554130f, -0.08865530f, 0.05110528f, 0.05517546f, -0.18401472f, -0.06253938f, 0.02987579f, 
    -0.01262345f, 0.07901299f, 0.09795950f, 0.00402716f, 0.00078661f, -0.06922252f, 0.14317752f, -0.27615187f, 
    -0.13294601f, -0.01505706f, -0.07754202f, 0.19338608f, 0.14111246f, -0.14105573f, -0.05215147f, -0.05199108f, 
    -0.02391110f, 0.00756794f, -0.02076034f, 0.03593090f, 0.05504656f, 0.00455829f, 0.01185869f, 0.05386881f, 
    -0.02346505f, 0.01811020f, 0.00942466f, 0.02017791f, 0.19653468f, 0.15953843f, -0.07029329f, -0.12151586f, 
    0.28583702f, 0.07984088f, 0.01576753f, 0.00861641f, 0.01475164f, 0.04610070f, -0.12971628f, -0.04544695f, 
    -0.00021231f, -0.02209263f, 0.04145049f, 0.05864717f, 0.00868639f, 0.05893299f, 0.02451723f, 0.13638964f, 
    0.27596158f, -0.13549165f, 0.10393257f, -0.03947896f, -0.21759026f, -0.05569726f, 0.02896655f, 0.13064580f, 
    -0.02150318f, -0.02983613f, 0.02996997f, -0.00439554f, -0.00174924f, 0.03140290f, 0.04855748f, 0.05183834f, 
    -0.08357453f, -0.00183080f, -0.01807694f, 0.05602949f, -0.12893191f, 0.18891262f, 0.08658707f, 0.06794727f, 
    0.32226482f, 0.11984093f, 0.02370917f, 0.04120307f, 0.03979550f, 0.05304270f, 0.02337002f, 0.03282921f, 
    0.07703777f, -0.01797942f, -0.05570425f, 0.13397579f, 0.01461977f, 0.00153784f, -0.04230104f, 0.03780159f, 
    -0.44610736f, 0.00445893f, -0.10431235f, 0.16300847f, -0.11983048f, 0.07455175f, -0.08435765f, -0.08940661f, 
    -0.03656901f, 0.00569682f, -0.03027039f, 0.13110071f, -0.01354272f, -0.01710018f, 0.00565595f, -0.10224067f, 
    0.00002021f, 0.01492600f, 0.05034831f, 0.03890289f, 0.06504047f, -0.26490733f, 0.15544662f, -0.01882792f, 
    -0.11119723f, -0.04537131f, 0.04228765f, -0.08786958f, 0.04445603f, -0.05897009f, 0.01977353f, 0.09187336f, 
    0.10444379f, -0.01639014f, 0.07139011f, -0.00246797f, -0.02088653f, -0.04611066f, 0.05403908f, -0.03939467f, 
    0.20212863f, 0.22330126f, 0.36389390f, -0.16270609f, -0.20751870f, 0.03277205f, 0.14373440f, 0.18252467f, 
    0.10926356f, 0.03960561f, -0.03511820f, -0.12723991f, 0.02611209f, 0.01615124f, -0.07808387f, 0.00209553f, 
    -0.01405901f, -0.01702267f, 0.02392851f, 0.07402816f, 0.28271687f, 0.04402973f, 0.08809081f, -0.01601689f, 
    -0.03935341f, 0.08659487f, -0.03941687f, 0.07962523f, 0.01482745f, -0.02268386f, -0.01432307f, 0.05240298f, 
    -0.02919627f, 0.13284741f, 0.09571271f, 0.16604033f, 0.09292519f, 0.01921652f, -0.05183692f, 0.07922221f, 
    0.31650075f, 0.08581547f, -0.03086223f, 0.20389022f, 0.04572174f, -0.06950095f, -0.01839999f, -0.03498567f, 
    0.10066245f, 0.15408640f, -0.01345571f, -0.08210084f, 0.05985367f, 0.00087830f, 0.11589225f, -0.04840992f, 
    0.06811019f, 0.08632896f, 0.04714923f, -0.08639313f, -0.06821847f, 0.13710946f, -0.00140942f, -0.02302478f, 
    0.11371531f, -0.02696008f, 0.08580904f, 0.08546768f, -0.03553989f, 0.03184807f, 0.10186134f, -0.04152784f, 
    0.10449678f, 0.00095065f, -0.10450150f, 0.02421740f, -0.01542312f, 0.07871212f, -0.02466350f, 0.13423251f, 
    0.26092827f, 0.15077034f, 0.02466267f, -0.09740163f, 0.20940161f, -0.04470767f, 0.06560820f, 0.01958462f, 
    0.12301549f, 0.01857297f, -0.10789987f, -0.09816158f, 0.01348046f, -0.10332195f, 0.10807145f, -0.03745264f, 
    -0.00476192f, 0.00781703f, 0.11011119f, -0.02063249f, -0.46000552f, 0.08693274f, -0.23041646f, -0.16660218f, 
    -0.01264693f, 0.18668747f, 0.15108614f, 0.02662313f, -0.03834534f, -0.02889650f, 0.03946140f, 0.02143604f, 
    0.04785453f, -0.04278792f, 0.06758536f, 0.00970041f, 0.04724464f, -0.03318751f, 0.00641561f, 0.07598901f, 
    0.07971604f, 0.11194079f, 0.01878727f, -0.04725982f, -0.06455823f, 0.20469514f, 0.05245038f, -0.13552779f, 
    0.15195759f, 0.20157522f, -0.00269613f, 0.11154034f, 0.11367679f, 0.06111741f, -0.01170339f, 0.13978761f, 
    0.03952710f, 0.16977932f, -0.11553162f, 0.07057388f, 0.04019593f, 0.01047842f, 0.22207385f, -0.09457073f, 
    -0.27279595f, 0.07735383f, 0.00420735f, 0.05430059f, -0.03044604f, -0.01196839f, 0.10411453f, -0.10411599f, 
    0.07174763f, 0.03148394f, 0.02032768f, 0.06288052f, -0.00043078f, -0.10350171f, 0.00625927f, -0.00851822f, 
    -0.09134756f, 0.04954376f, 0.00181848f, 0.00674722f, -0.12636103f, 0.02763286f, 0.00331322f, 0.07903945f, 
    0.06070526f, 0.09930049f, -0.01743756f, -0.01343245f, -0.08000813f, 0.06818858f, 0.02437302f, -0.00697341f, 
    -0.11526695f, -0.10925671f, 0.00958333f, -0.05061848f, -0.24972405f, -0.15732414f, 0.07425060f, 0.23526278f, 
    0.10431124f, -0.01499200f, -0.08594576f, 0.07157708f, -0.13861069f, 0.17411262f, 0.06388687f, -0.02541174f, 
    0.06318449f, 0.02808530f, 0.13132712f, -0.05178475f, 0.06664287f, -0.01715807f, 0.02616952f, -0.00293554f, 
    -0.06600174f, -0.16305466f, -0.02298480f, -0.01766828f, -0.05017361f, -0.08483014f, 0.13613862f, -0.05015625f, 
    0.03315840f, 0.16370699f, 0.02738260f, 0.08154691f, -0.02732663f, 0.03702983f, -0.11427537f, -0.04952321f, 
    0.00438293f, 0.13718687f, -0.01840908f, -0.10327016f, 0.14579231f, 0.02130607f, 0.15581183f, 0.14414284f, 
    0.18896022f, 0.02154332f, -0.00895206f, -0.07329088f, 0.02340964f, 0.13337316f, 0.02975769f, -0.04544260f, 
    0.13148192f, 0.16183767f, 0.09766091f, 0.03563264f, -0.02420697f, 0.13316621f, -0.09751312f, 0.07230406f, 
    0.37234598f, -0.00060876f, -0.10899094f, 0.13526173f, 0.17407642f, -0.15699266f, -0.09053857f, 0.05060324f, 
    0.16579886f, 0.09933934f, 0.07903687f, -0.03642141f, 0.28025019f, 0.02464927f, 0.09448817f, -0.02449119f, 
    0.09352402f, -0.03062016f, 0.03863758f, 0.01748414f, 0.15699625f, -0.17678016f, 0.24061349f, -0.01988510f, 
    0.07289691f, 0.06733990f, 0.05495378f, 0.00411889f, 0.15458316f, -0.17297332f, -0.08621337f, 0.00566990f, 
    0.00526577f, 0.06365059f, 0.00472346f, -0.07821859f, -0.02813651f, 0.01835302f, 0.04362974f, 0.02822800f, 
    -0.40846103f, -0.33268327f, -0.14790896f, 0.11965749f, 0.01599900f, -0.13616857f, 0.04309846f, -0.08596730f, 
    -0.06250054f, -0.01620465f, -0.10231252f, 0.15325606f, -0.07931399f, 0.05066096f, 0.09837939f, 0.03610542f, 
    -0.00185576f, 0.14378332f, 0.07826634f, 0.05250114f, -0.27298883f, 0.00698324f, -0.22076826f, -0.12630318f, 
    -0.22854359f, 0.06841029f, 0.02561033f, 0.04668773f, 0.07543020f, -0.08615769f, 0.04123557f, 0.22187930f, 
    -0.04917888f, 0.01663166f, -0.05380022f, -0.04902373f, -0.09348199f, -0.05994646f, 0.10740892f, 0.03896058f, 
    0.38158739f, -0.18895401f, -0.07174887f, 0.11751459f, -0.17391835f, 0.01569861f, 0.04852914f, 0.03147782f, 
    0.10123612f, -0.00211172f, -0.06787531f, -0.11959010f, -0.06503590f, 0.10004986f, -0.04489582f, 0.07635286f, 
    0.02782198f, 0.02721135f, -0.06484454f, 0.05639104f, 0.36558977f, -0.16145559f, 0.39259341f, 0.19266097f, 
    -0.08303891f, -0.01450717f, 0.03151123f, -0.08580143f, 0.07200148f, -0.05708504f, 0.04304533f, 0.07151307f, 
    0.03898018f, 0.12690039f, -0.04338599f, 0.05308004f, -0.02764374f, 0.03544104f, 0.08876054f, 0.06244576f, 
    -0.36914542f, -0.33746389f, -0.15228957f, 0.12301093f, 0.10511370f, -0.14988920f, -0.06634298f, -0.08196657f, 
    -0.05968801f, 0.07580477f, 0.08125539f, 0.05021305f, -0.03038050f, -0.01820153f, 0.11233120f, 0.11271803f, 
    0.07615488f, 0.11237478f, 0.02605964f, -0.00222545f, 0.22771975f, 0.05608508f, -0.14431258f, 0.20052469f, 
    0.18163355f, -0.03595341f, 0.05907527f, 0.04499588f, 0.03673586f, 0.08327082f, -0.03988034f, -0.02156519f, 
    -0.02412087f, 0.15764669f, 0.00060141f, 0.07723262f, 0.01782117f, 0.19125170f, 0.03244421f, -0.23982285f, 
    0.42218825f, 0.24186745f, -0.10032665f, -0.10124410f, 0.05126180f, -0.08658887f, -0.02476755f, 0.08248433f, 
    0.06495836f, 0.01375466f, -0.08600233f, -0.09897244f, -0.00580072f, -0.00120871f, 0.04259993f, -0.09629957f, 
    -0.04213693f, 0.06059309f, 0.07252367f, -0.05993272f, -0.20553024f, 0.19954495f, 0.14309186f, 0.16092667f, 
    -0.02259016f, 0.01937283f, 0.05028436f, 0.02470650f, -0.04540135f, 0.05962582f, -0.02002820f, 0.15462536f, 
    0.12635227f, 0.01372070f, -0.04819493f, 0.13264680f, 0.02753172f, -0.07759678f, 0.03817331f, -0.10122510f, 
    0.09969144f, 0.16038956f, 0.06220952f, 0.27862278f, -0.24206069f, 0.10498582f, -0.06551380f, 0.04613401f, 
    -0.02266150f, 0.15179741f, 0.08859696f, -0.13254263f, 0.07049454f, -0.01235687f, -0.10095082f, 0.05838330f, 
    -0.02760943f, 0.00941176f, 0.15269729f, 0.01871698f, -0.03330115f, 0.00763630f, -0.28432190f, -0.08113249f, 
    -0.10202761f, 0.15421097f, 0.15538850f, -0.00491611f, -0.07493667f, -0.07520134f, -0.12365012f, 0.05514079f, 
    0.05200856f, -0.01857629f, 0.04012483f, 0.08765583f, -0.06350610f, 0.08644131f, 0.03873969f, 0.10697065f, 
    -0.13035461f, -0.06474567f, -0.09927861f, -0.13134874f, -0.04373990f, 0.07436997f, -0.10291567f, -0.03536067f, 
    -0.02767161f, 0.07721432f, 0.04027767f, 0.02219586f, 0.08789544f, -0.09174513f, -0.00511953f, -0.07252197f, 
    -0.03669428f, 0.09402418f, -0.02862194f, 0.02943204f, -0.34347790f, 0.20563860f, -0.01515504f, -0.22465482f, 
    -0.00900265f, 0.13204506f, -0.23024589f, -0.05241751f, -0.06311332f, 0.05213055f, 0.05713215f, -0.03586693f, 
    0.04817794f, -0.04495614f, 0.02115902f, 0.00954571f, -0.03295372f, 0.01143303f, -0.07304730f, -0.13679363f, 
    -0.11263079f, -0.06353842f, 0.15308848f, -0.00975937f, 0.06084004f, 0.01838581f, 0.00891982f, -0.02727585f, 
    0.00514975f, 0.04605939f, -0.02293367f, 0.10136995f, -0.09055216f, 0.03387925f, -0.01569152f, 0.03378456f, 
    -0.00267688f, -0.01379750f, -0.11600358f, 0.07493591f, -0.32387143f, -0.22531255f, 0.08826900f, -0.03695009f, 
    0.02124318f, -0.01819085f, 0.04134502f, -0.17118779f, 0.01858998f, -0.01935597f, 0.05816242f, -0.06711405f, 
    -0.00525931f, -0.06950966f, -0.00128336f, 0.06686209f, 0.02655757f, -0.03461972f, 0.04280999f, -0.02393278f, 
    -0.02613163f, -0.03421947f, -0.12562369f, -0.08305154f, 0.04878122f, 0.10318890f, 0.07189132f, -0.08517296f, 
    -0.06285746f, -0.03975014f, 0.03173952f, -0.04920534f, -0.04996721f, -0.02854008f, 0.02254778f, -0.01354283f, 
    0.05253337f, 0.13562548f, 0.11378556f, 0.08642128f, -0.36864913f, 0.23556906f, -0.03247410f, 0.05459930f, 
    -0.00974276f, 0.05034326f, 0.05939522f, -0.01931964f, -0.03080387f, -0.10082473f, 0.12261439f, 0.04675905f, 
    0.02576686f, 0.02133166f, 0.03638551f, 0.07934301f, 0.02755622f, -0.02469943f, 0.02830455f, 0.03742912f, 
    -0.27727121f, 0.11379170f, 0.08180710f, 0.02841826f, -0.12647985f, 0.02028947f, 0.11463029f, -0.03745382f, 
    0.03681475f, 0.01715654f, -0.01361691f, 0.04325161f, -0.07466767f, 0.02867738f, -0.04119049f, -0.07086683f, 
    -0.05571565f, -0.05618444f, -0.05313059f, -0.05607575f, 0.05021373f, -0.17776291f, 0.11909522f, 0.07210098f, 
    0.09725506f, 0.04698401f, 0.02969578f, -0.10770594f, -0.03610529f, -0.07810325f, -0.02651328f, 0.06675904f, 
    -0.03693335f, 0.00527227f, 0.03013745f, 0.08432957f, 0.06525557f, 0.03437755f, 0.00863733f, 0.08512913f, 
    0.03315948f, -0.22389728f, 0.05689939f, 0.08403274f, -0.14289783f, 0.05075423f, 0.01250243f, 0.06592241f, 
    0.01449095f, -0.10477514f, -0.02022933f, 0.00782251f, -0.04429808f, -0.04942061f, -0.00261556f, 0.06697937f, 
    0.12750770f, -0.06865178f, 0.18330796f, 0.04788557f, -0.15684117f, 0.22309732f, 0.04993246f, -0.03460984f, 
    0.15802722f, -0.05676551f, 0.00556540f, -0.14969192f, 0.02662997f, 0.02683415f, -0.06733444f, 0.01595373f, 
    -0.03428495f, -0.01270154f, 0.10330150f, 0.04019067f, 0.04609585f, -0.02214801f, 0.11280307f, -0.00248843f, 
    0.24542372f, -0.26805180f, 0.05005081f, 0.02932891f, -0.10541103f, -0.03766803f, -0.05522617f, 0.07187929f, 
    -0.06877391f, 0.11751125f, -0.07228930f, 0.13424620f, -0.01058142f, -0.05393067f, 0.08102406f, 0.05013214f, 
    0.05308033f, -0.05113512f, -0.04757424f, 0.10539324f, 0.24245961f, -0.25311357f, 0.07155674f, -0.13524848f, 
    0.12509057f, -0.05717975f, 0.09027347f, -0.03604010f, -0.02817077f, -0.04048313f, 0.04087838f, 0.03391155f, 
    0.09502887f, 0.02302833f, 0.06680831f, 0.05168622f, -0.05248272f, 0.00441256f, 0.09159517f, 0.07715370f, 
    -0.19482383f, -0.25357184f, 0.08043639f, 0.00267669f, -0.03685995f, -0.05955124f, -0.06650664f, -0.06878500f, 
    0.00337456f, 0.00984687f, -0.06514702f, -0.00868289f, -0.00065306f, 0.01420066f, 0.07071938f, 0.01773229f, 
    -0.01299492f, -0.02049204f, 0.01992293f, -0.03685109f, -0.26419610f, 0.25802219f, 0.03371878f, 0.18239787f, 
    -0.12710160f, 0.05710220f, 0.08040066f, 0.04366121f, 0.00560285f, 0.06117035f, -0.03442038f, 0.02598498f, 
    -0.03133922f, -0.00026522f, -0.05604536f, -0.01018978f, 0.06500582f, -0.03832000f, 0.14653754f, -0.08251499f, 
    -0.03981686f, 0.26282394f, 0.04620550f, 0.06920620f, -0.05259554f, 0.12522377f, 0.10271588f, 0.06998820f, 
    -0.02406928f, -0.02325516f, 0.06693250f, 0.02222505f, 0.03222931f, 0.02241293f, 0.12439326f, 0.07223063f, 
    -0.04514297f, -0.02268351f, 0.02369900f, 0.06376696f, 0.09146625f, 0.18284753f, -0.04487252f, 0.02888141f, 
    -0.01908932f, 0.04844858f, 0.01735958f, 0.06738135f, -0.04403084f, 0.02224751f, 0.01319947f, -0.01453943f, 
    -0.00873926f, -0.03829572f, -0.00895987f, -0.03638843f, 0.05073741f, 0.10151415f, 0.10831306f, 0.04587106f, 
    0.23394850f, 0.00295904f, -0.09992827f, 0.00044641f, -0.00621796f, 0.00038397f, 0.03894450f, -0.13054772f, 
    -0.04048167f, -0.08251665f, 0.05784381f, 0.05931761f, -0.00038932f, 0.09116577f, 0.05233324f, 0.04199760f, 
    0.06574569f, 0.12598911f, 0.03032828f, 0.05080644f, -0.17749949f, 0.13216336f, 0.04264742f, 0.22724327f, 
    -0.15362093f, -0.07341583f, 0.00968563f, -0.02831794f, 0.03037384f, 0.00327051f, -0.06500839f, 0.02126053f, 
    -0.01983795f, 0.06418086f, 0.04633969f, -0.06851164f, -0.08334377f, -0.14651129f, -0.11402618f, 0.05914652f, 
    -0.24244805f, 0.04643780f, -0.04271566f, 0.07565834f, -0.08329264f, 0.03418336f, -0.01933602f, 0.12159134f, 
    0.02867374f, 0.11794983f, 0.07983884f, 0.04109348f, 0.07403457f, -0.02555765f, -0.00961143f, 0.10844266f, 
    -0.03917162f, -0.01448562f, 0.06684982f, 0.02517617f, -0.11614597f, 0.08232956f, 0.10626123f, 0.24487296f, 
    -0.07779308f, -0.06963445f, 0.10256617f, -0.09352512f, -0.01862342f, -0.09260046f, -0.06654850f, -0.00265402f, 
    0.04948484f, 0.03495649f, 0.16845727f, 0.02244829f, -0.02618776f, -0.07460311f, -0.09267393f, -0.01296583f, 
    0.24763411f, -0.02241781f, 0.13377349f, 0.12625232f, -0.04333073f, -0.01474463f, -0.03108746f, 0.02016383f, 
    -0.04697104f, 0.06337234f, 0.05685696f, 0.18148674f, 0.00762868f, -0.02454978f, -0.07635586f, 0.06017318f, 
    0.12937997f, 0.07054821f, -0.06574339f, 0.08959445f, -0.27498966f, -0.04900667f, 0.18435459f, 0.01876562f, 
    0.16380826f, -0.00539014f, 0.01705226f, -0.02178597f, 0.04373457f, 0.11147091f, 0.05227016f, 0.06348268f, 
    -0.07454085f, 0.05038070f, 0.02391609f, 0.05029472f, 0.03686931f, -0.08887129f, -0.00777659f, 0.12070020f, 
    -0.02333011f, -0.03720870f, 0.20323721f, 0.20504792f, 0.05744816f, 0.10310788f, 0.07334705f, 0.04111727f, 
    0.10034913f, -0.07254233f, -0.00289650f, -0.00095205f, -0.02431021f, 0.02922857f, -0.00718069f, -0.08482270f, 
    0.01651358f, -0.13169877f, 0.01165072f, -0.00213045f, 0.17910041f, -0.15709452f, 0.19433230f, 0.05839893f, 
    -0.04711861f, 0.04243676f, 0.01976697f, -0.00506162f, 0.10186321f, 0.08151171f, 0.03487658f, 0.13218728f, 
    -0.08064200f, 0.04044266f, -0.01164404f, 0.02455316f, 0.00868124f, 0.02673346f, 0.04633632f, 0.04459059f, 
    0.37705901f, -0.08400133f, 0.00384445f, -0.03171676f, -0.10334047f, 0.00312252f, 0.06600706f, -0.00914426f, 
    0.02984107f, -0.10419520f, 0.03662726f, 0.02958211f, -0.08862410f, 0.04848665f, -0.02989209f, 0.00681251f, 
    0.01603439f, 0.08170225f, -0.00868758f, 0.10161776f, 0.08725205f, -0.11253385f, 0.18564491f, -0.00422433f, 
    0.21566075f, 0.07718904f, -0.07407198f, -0.05071098f, 0.00671044f, 0.00060954f, 0.06058266f, -0.04795775f, 
    -0.04855295f, -0.05756413f, 0.06518947f, 0.03589774f, 0.00952876f, 0.05089091f, -0.06580753f, 0.01972703f, 
    -0.03446666f, 0.00516724f, 0.19676986f, 0.10849889f, 0.08203366f, 0.10428084f, -0.00571814f, 0.01921530f, 
    0.04384885f, -0.08208184f, -0.00932535f, 0.02093511f, -0.10627426f, 0.02810643f, -0.03352594f, 0.04552929f, 
    0.10901799f, -0.07306692f, -0.03471640f, 0.06391282f, 0.07886457f, 0.32798627f, -0.09145589f, -0.11311772f, 
    -0.05842107f, -0.11126021f, -0.08174413f, -0.00489398f, -0.00736668f, -0.10244637f, -0.04028580f, -0.02910706f, 
    -0.02936624f, -0.04538675f, -0.05380627f, -0.04809563f, 0.10056309f, -0.05354686f, -0.02454801f, -0.00928465f, 
    -0.19894697f, -0.38570750f, 0.15087675f, -0.14152370f, -0.15562810f, -0.05203779f, -0.04221923f, -0.10575221f, 
    -0.02435987f, 0.06153988f, -0.03766501f, -0.03094151f, 0.02984270f, 0.03783068f, -0.01120612f, -0.09894089f, 
    0.04183637f, 0.03761983f, 0.11729790f, -0.03141844f, -0.04545569f, 0.32994074f, -0.05936028f, -0.12783103f, 
    -0.02848557f, 0.09461083f, -0.10325031f, 0.01842945f, -0.04729164f, -0.01685786f, 0.00556544f, 0.04044164f, 
    -0.02872417f, 0.08589213f, -0.05422556f, -0.01690849f, 0.01109201f, 0.02415521f, 0.10313173f, -0.05287525f, 
    0.32517150f, 0.00999697f, 0.11141985f, 0.11514597f, 0.22171776f, 0.12943384f, 0.12996706f, 0.04349182f, 
    0.02462984f, 0.06397211f, -0.02664879f, -0.03379911f, 0.07325548f, 0.08764779f, -0.08796137f, 0.10536081f, 
    0.08683610f, 0.05395395f, -0.00321586f, 0.02399472f, -0.05703928f, 0.15892753f, 0.13375813f, 0.08296556f, 
    0.01451999f, 0.08715629f, 0.11416551f, 0.07731781f, 0.01624044f, -0.02989007f, 0.01441877f, 0.01523234f, 
    0.03170530f, -0.02437893f, 0.05356793f, 0.09781934f, -0.02036733f, 0.12544650f, 0.03400495f, 0.01305807f, 
    -0.03518157f, -0.00550339f, 0.02750174f, -0.04269329f, -0.00665250f, -0.00395105f, -0.02859281f, 0.01225348f, 
    -0.03675848f, 0.01864126f, -0.03188396f, -0.02240038f, -0.02561118f, 0.03140910f, -0.00432478f, -0.02136994f, 
    -0.02436854f, -0.02864205f, -0.03819473f, -0.01193242f, 0.01993698f, -0.01369531f, -0.01504043f, -0.04291947f, 
    0.01969106f, -0.02434186f, 0.01677817f, 0.00416915f, -0.02240122f, -0.04410033f, 0.02714038f, 0.01096782f, 
    -0.03136443f, 0.03322048f, -0.01925474f, 0.02473581f, -0.00570604f, -0.01419375f, 0.00562521f, -0.01730537f, 
    0.02751730f, -0.00309381f, -0.04086137f, 0.02638099f, -0.03087613f, 0.00241395f, -0.03718876f, -0.02829907f, 
    0.03017835f, 0.01368897f, 0.03294057f, 0.02206357f, 0.02456541f, 0.03351350f, -0.00912156f, -0.02950720f, 
    -0.01769221f, 0.01317040f, 0.00400407f, -0.02866390f, 0.00429443f, -0.03783961f, -0.00321496f, -0.04140115f, 
    -0.03038607f, 0.02032787f, -0.00058667f, -0.00766241f, 0.00938254f, -0.01821914f, -0.03793990f, 0.01134764f, 
    0.03178375f, 0.01642136f, -0.03283115f, -0.01865786f, 0.01200305f, -0.00427322f, 0.04482133f, 0.03081806f, 
    -0.03951327f, 0.01776832f, -0.02807728f, -0.03712471f, 0.02015925f, 0.02774372f, -0.01827564f, -0.00478705f, 
    0.03031385f, 0.00078025f, -0.02615604f, 0.00575412f, 0.00645255f, 0.00518666f, 0.03293630f, -0.04382484f, 
    0.01032466f, 0.00607226f, -0.02128335f, -0.03669084f, -0.04335843f, -0.03870344f, -0.01015627f, 0.00780745f, 
    0.02520712f, 0.03197470f, -0.00086504f, 0.02906613f, -0.00048976f, 0.00571237f, 0.00926299f, -0.02545394f, 
    -0.03246788f, 0.02416738f, -0.01688923f, -0.01922421f, -0.03690680f, -0.00890956f, -0.03092112f, 0.00813234f, 
    -0.04421128f, 0.00534464f, 0.02823587f, 0.02763101f, -0.02844870f, -0.04344533f, 0.02168092f, -0.02233366f, 
    -0.02798637f, -0.01629289f, -0.02089461f, 0.01519321f, 0.02133832f, -0.00058150f, -0.00956453f, 0.00993677f, 
    -0.03366310f, 0.02093578f, 0.00810870f, 0.02180275f, -0.02102429f, 0.01349711f, -0.02390606f, -0.01271556f, 
    0.02223673f, -0.00974070f, 0.03267418f, 0.00570928f, -0.01410659f, -0.04387403f, 0.02235569f, -0.02739066f, 
    -0.00800964f, -0.02869111f, 0.00851167f, -0.00084321f, 0.01097493f, 0.02346784f, -0.04247211f, -0.02150280f, 
    -0.02431544f, 0.00947904f, -0.01729236f, 0.01871189f, -0.00281390f, 0.03037116f, -0.00282238f, 0.00678775f, 
    -0.03512419f, -0.00493370f, -0.00767647f, -0.01676222f, -0.04342664f, -0.00687082f, -0.02439096f, 0.01131235f, 
    -0.03043906f, -0.02406744f, -0.01925160f, -0.03667796f, 0.01426314f, 0.00637446f, 0.01186545f, -0.00909761f, 
    -0.00195919f, -0.00668365f, 0.01534074f, 0.02159743f, 0.01965479f, 0.03151414f, -0.03588883f, 0.01493796f, 
    0.01619900f, -0.04127823f, 0.03326893f, -0.01181216f, 0.00918129f, 0.02309635f, 0.02415173f, 0.02520804f, 
    -0.00335437f, -0.00343877f, 0.00643777f, -0.04333309f, 0.00346292f, 0.00314634f, 0.02675732f, -0.02338521f, 
    -0.01270816f, -0.02063674f, 0.01237576f, 0.00852350f, 0.01128480f, -0.03344032f, -0.03008279f, -0.03883037f, 
    -0.04216464f, -0.02488759f, -0.03176968f, -0.03559230f, 0.01576926f, 0.01927418f, 0.02732187f, -0.02367407f, 
    0.02923046f, -0.03939031f, 0.01165682f, -0.03103568f, -0.01291955f, -0.02094346f, -0.02732946f, -0.01316627f, 
    0.01916947f, 0.00984565f, 0.01691251f, 0.01089014f, 0.00202708f, 0.02406750f, -0.04234210f, -0.01403666f, 
    -0.02374680f, -0.02676692f, -0.01002859f, 0.02957987f, -0.03361897f, 0.02479894f, -0.02537558f, -0.00105890f, 
    0.01662625f, -0.00548323f, 0.01512184f, 0.03342125f, -0.01299233f, -0.02523790f, -0.02405945f, -0.00726586f, 
    -0.02105791f, 0.00809413f, 0.03057564f, -0.00482700f, -0.04193031f, -0.02883425f, 0.00177490f, -0.00940729f, 
    -0.04030081f, 0.00692281f, 0.01451992f, 0.02767991f, 0.02429653f, 0.00762123f, 0.01468886f, 0.00130814f, 
    0.01535008f, 0.03567902f, -0.00114833f, -0.03231735f, 0.00396486f, 0.01068511f, 0.02112531f, -0.02928821f, 
    -0.00620594f, -0.01792948f, 0.02334602f, 0.03070760f, -0.00840252f, -0.03474740f, -0.03619028f, -0.03767446f, 
    0.02464067f, 0.01992144f, -0.04426948f, 0.01899085f, 0.01206179f, 0.01339629f, -0.01112771f, -0.00086458f, 
    -0.01365756f, 0.02070209f, 0.01555000f, 0.00916040f, -0.04047586f, 0.00598529f, -0.03786107f, 0.02773350f, 
    -0.03604311f, -0.00207495f, 0.01689539f, -0.01051209f, 0.02717647f, -0.01485738f, 0.00769407f, 0.02061670f, 
    -0.01576739f, 0.02527026f, -0.00632098f, -0.01013203f, 0.00680549f, -0.03326666f, -0.01899994f, -0.04038332f, 
    -0.02048920f, -0.00770669f, -0.02177467f, 0.01180629f, -0.04150790f, -0.00448832f, -0.01033878f, -0.01517141f, 
    -0.01561475f, -0.02410100f, -0.01663851f, 0.02195242f, -0.01493285f, 0.02785806f, -0.03748438f, -0.01592307f, 
    -0.03635278f, -0.03146603f, -0.04344409f, -0.03039951f, 0.01931631f, -0.00970158f, 0.02421992f, -0.04109265f, 
    -0.01497974f, -0.02259508f, -0.04222377f, -0.01261654f, -0.04100428f, -0.01669997f, -0.03551078f, -0.01960062f, 
    0.01050725f, 0.00625881f, -0.02306780f, -0.04163777f, -0.03492220f, 0.02444220f, -0.04056954f, 0.01026167f, 
    -0.01796566f, -0.00621867f, -0.02762442f, 0.02346304f, -0.01661924f, -0.02415710f, -0.01526510f, 0.03096087f, 
    -0.01953638f, -0.04124558f, 0.01360641f, 0.00073074f, -0.01804090f, -0.00419537f, -0.02913010f, -0.01987916f, 
    -0.01045278f, -0.03365469f, -0.01330748f, -0.02460304f, 0.02327466f, -0.00849384f, 0.03091969f, 0.01376655f, 
    -0.02301194f, -0.04517880f, 0.01291225f, -0.01366025f, 0.03353789f, 0.03335815f, -0.02220714f, 0.01706588f, 
    0.00991343f, 0.01187174f, 0.02256792f, 0.02919275f, -0.02766210f, 0.00762085f, 0.03248788f, 0.02039230f, 
    -0.00411698f, -0.03051312f, -0.03636252f, 0.03252759f, -0.02461536f, -0.00927345f, 0.01622000f, -0.03763307f, 
    0.01185697f, -0.01605005f, -0.04434227f, -0.00829629f, -0.02252295f, 0.02674577f, -0.02126865f, 0.00665968f, 
    0.01204609f, -0.02443088f, 0.02294770f, 0.02293537f, -0.03442829f, 0.01686148f, -0.03437240f, -0.00377616f, 
    -0.02352034f, -0.03104957f, 0.02349674f, -0.01026594f, -0.03304147f, 0.01922118f, -0.03952192f, 0.00881681f, 
    -0.00150628f, -0.00158308f, -0.00949351f, -0.00620198f, -0.01118790f, -0.03376089f, 0.01267570f, -0.01268829f, 
    0.02596746f, -0.02071927f, 0.00174446f, 0.01187926f, -0.03963844f, 0.00078528f, 0.01095157f, -0.03129992f, 
    0.01822536f, 0.00870348f, -0.01014734f, 0.01705889f, -0.01932391f, 0.01395328f, 0.00208488f, 0.02629362f, 
    -0.02241484f, 0.02627894f, 0.01997260f, -0.00344699f, -0.04249079f, 0.00051982f, 0.00763213f, 0.01524848f, 
    0.02874741f, -0.00058060f, 0.00044369f, -0.02795393f, 0.00863576f, 0.02487929f, -0.00144175f, 0.03286898f, 
    -0.02720270f, -0.01941852f, -0.02070755f, 0.01119540f, -0.03172976f, -0.01204861f, -0.04210054f, -0.04117646f, 
    0.01404545f, 0.03044601f, -0.01547449f, 0.02995021f, 0.01678883f, 0.01189641f, -0.01238943f, 0.03224036f, 
    0.03067217f, -0.02085008f, 0.02177971f, -0.00194404f, -0.01065433f, -0.01539531f, -0.02863181f, 0.01472821f, 
    -0.00251789f, -0.00307060f, -0.02421910f, -0.00227710f, -0.00342100f, 0.00768219f, -0.02571480f, -0.03592749f, 
    -0.01298478f, 0.01691772f, -0.04177616f, -0.00917987f, -0.01622532f, -0.00486496f, -0.03335151f, -0.02283617f, 
    -0.01154092f, -0.03032874f, -0.00428050f, -0.00038594f, -0.03218865f, 0.02591886f, -0.01026457f, -0.00174223f, 
    0.02904207f, -0.02488649f, -0.01410943f, -0.03164295f, -0.02120584f, 0.01502768f, 0.02708229f, 0.01865549f, 
    0.02375123f, -0.01163703f, -0.01840700f, 0.00020456f, -0.01689639f, -0.02547718f, 0.01219660f, -0.00128529f, 
    0.03178042f, -0.03232435f, -0.00320012f, 0.02970833f, -0.00998620f, 0.03092049f, -0.03252174f, 0.01314930f, 
    -0.03283999f, -0.00481245f, -0.00641448f, -0.02420904f, -0.02979155f, 0.02957426f, -0.02695441f, -0.01026565f, 
    -0.03333386f, 0.01964194f, -0.01914698f, -0.04483934f, -0.00592936f, -0.00366467f, -0.03637085f, 0.01032235f, 
    0.02857675f, -0.02431464f, 0.02002663f, -0.03198711f, -0.04055215f, 0.01908308f, -0.01361767f, 0.01378714f, 
    -0.03504929f, 0.02496955f, -0.04363677f, -0.03401069f, -0.01566545f, 0.01882260f, -0.02740357f, 0.02862886f, 
    -0.03097374f, -0.03770597f, -0.03331342f, -0.03416537f, -0.04545823f, -0.02964538f, 0.02492639f, -0.02515195f, 
    -0.03079112f, 0.02284116f, -0.04478641f, -0.04348637f, -0.02325753f, 0.00969648f, 0.02635793f, 0.02916205f, 
    -0.02940436f, -0.03247496f, -0.03277043f, -0.01932936f, -0.01982905f, 0.01769199f, -0.01194434f, 0.01011635f, 
    -0.03723706f, -0.01014869f, -0.01902353f, 0.01809553f, -0.03093063f, -0.02549270f, -0.03104575f, 0.02978964f, 
    -0.00590312f, 0.00943737f, 0.03212454f, -0.01465026f, -0.00828087f, -0.04331834f, -0.01830526f, 0.00306327f, 
    -0.02592246f, -0.04342028f, 0.00358415f, -0.03281185f, 0.03245403f, -0.02460127f, 0.03111760f, 0.01977604f, 
    -0.03686723f, 0.02109713f, 0.03078130f, 0.02913365f, -0.02907317f, -0.02553756f, 0.01965974f, -0.00048329f, 
    -0.00957031f, -0.01491626f, 0.01282047f, -0.04400455f, 0.00528864f, -0.02659291f, 0.01189426f, -0.02117071f, 
    -0.02696102f, 0.02149371f, 0.03435911f, 0.02850307f, -0.01998015f, 0.03307153f, -0.00527478f, 0.00967417f, 
    -0.00375667f, 0.00235304f, -0.03763516f, -0.03640517f, 0.01196189f, -0.01881854f, 0.01846275f, 0.00915991f, 
    -0.00803078f, 0.00414225f, -0.02091374f, -0.01993255f, -0.02189218f, -0.01922585f, 0.00231866f, 0.00706386f, 
    -0.01210165f, -0.04269505f, -0.00352734f, -0.02046552f, 0.00668237f, -0.00344894f, -0.00937799f, -0.03068243f, 
    0.01263336f, 0.00614129f, -0.02497099f, -0.04810043f, 0.03429723f, 0.02831615f, -0.01054084f, -0.01352382f, 
    0.02252380f, -0.01919668f, 0.02026598f, -0.01662653f, -0.00458512f, 0.01868236f, -0.03139926f, -0.02672400f, 
    0.02355910f, -0.00687392f, 0.01015395f, -0.02515799f, 0.00483038f, -0.00778860f, -0.03541901f, -0.02268694f, 
    -0.03396771f, -0.00297724f, -0.01499579f, -0.01193935f, 0.01078181f, 0.03163185f, 0.03025555f, 0.01812071f, 
    -0.05320176f, 0.02587966f, 0.02637084f, -0.01360588f, -0.00061383f, -0.00137962f, -0.03160695f, -0.01192864f, 
    -0.01459837f, 0.01321663f, -0.03313940f, -0.01468569f, -0.04850338f, 0.01696118f, 0.01528593f, 0.01577036f, 
    -0.03702557f, -0.01203853f, -0.01600976f, -0.02875618f, -0.00029719f, -0.03385850f, 0.01432021f, -0.02733153f, 
    -0.03233973f, 0.01064652f, 0.00149173f, -0.01414512f, -0.03221226f, -0.04647800f, -0.00333317f, 0.00889342f, 
    0.02939563f, -0.01250706f, 0.02547024f, -0.04277238f, 0.00093961f, -0.04872883f, 0.03465670f, -0.03669894f, 
    -0.00915612f, -0.00250647f, -0.03659308f, 0.02776910f, -0.02488400f, -0.01755761f, -0.02359143f, -0.03981190f, 
    0.01964490f, 0.00175041f, 0.01839251f, 0.02637682f, -0.02457606f, 0.03512517f, -0.00218438f, -0.03468717f, 
    -0.00607246f, 0.00886100f, -0.00487194f, -0.01491294f, -0.01880605f, -0.03566922f, -0.00261458f, -0.02046270f, 
    0.01322020f, 0.03872143f, -0.04211762f, 0.01298799f, -0.03981911f, 0.02089005f, -0.04535109f, -0.00833464f, 
    0.00227924f, 0.00825470f, -0.01348086f, 0.01147570f, -0.01573898f, -0.01005078f, 0.02373806f, -0.01350510f, 
    -0.02628773f, 0.00082087f, 0.01228964f, -0.04922240f, 0.02675843f, -0.00461889f, -0.02249554f, -0.04258569f, 
    -0.02816060f, -0.00887005f, -0.02168056f, 0.01057522f, -0.03517153f, -0.00380459f, -0.00198488f, 0.01523777f, 
    -0.00714927f, 0.01411165f, 0.00428438f, 0.02979352f, 0.02559565f, -0.03042204f, 0.03048611f, 0.03627658f, 
    0.02085156f, 0.02660601f, 0.02438608f, -0.03610861f, 0.04593884f, -0.03107214f, 0.01564347f, -0.02040028f, 
    -0.01456862f, 0.01371183f, -0.02987035f, 0.02166612f, 0.02404957f, 0.03999741f, -0.00237195f, 0.01183676f, 
    -0.04307806f, -0.02033124f, 0.00103000f, 0.01814631f, -0.00066795f, 0.02811835f, -0.03529608f, -0.03109992f, 
    -0.02648473f, 0.02720516f, 0.00005675f, 0.02061266f, 0.02550904f, 0.01764351f, -0.00590160f, 0.00230725f, 
    0.03290759f, 0.02907132f, -0.00269385f, 0.01252340f, -0.00492629f, -0.01063406f, -0.00962242f, 0.00885613f, 
    0.00379265f, 0.00515620f, -0.02296434f, -0.02099006f, 0.01592848f, -0.00727944f, 0.01538253f, -0.00121657f, 
    -0.00304580f, 0.03732956f, 0.02322613f, 0.00389684f, -0.02217044f, 0.01836949f, 0.00833539f, 0.02010061f, 
    0.02142629f, 0.01208422f, -0.04325677f, -0.00682641f, 0.02936821f, -0.00438381f, -0.03229408f, -0.02781009f, 
    0.02145054f, 0.01739989f, -0.03057304f, -0.02510298f, 0.00380258f, -0.03959933f, -0.00843630f, 0.01096026f, 
    0.03401587f, 0.02434280f, -0.01159698f, 0.00092499f, -0.00178880f, 0.03065709f, 0.02427350f, 0.02382127f, 
    -0.01433754f, -0.02419081f, -0.01946162f, -0.02048660f, 0.01245257f, -0.01875325f, -0.03489059f, 0.00735895f, 
    0.02138685f, 0.00558702f, -0.02149001f, 0.02912462f, 0.03828966f, 0.01171682f, -0.01262624f, -0.00553703f, 
    -0.03964965f, 0.01091919f, -0.00327879f, 0.02359655f, 0.03787884f, -0.03395438f, -0.02274730f, -0.00718042f, 
    0.04195294f, -0.01339938f, -0.04348030f, -0.01180278f, -0.01517785f, -0.03024136f, 0.01335036f, 0.00651780f, 
    -0.00917635f, 0.01908961f, -0.02062518f, 0.04109572f, 0.00198814f, 0.00031921f, -0.04578453f, -0.00170154f, 
    -0.02723230f, -0.00250442f, -0.01863056f, -0.02125749f, -0.01814749f, 0.00824827f, -0.00549301f, -0.01037326f, 
    -0.02104785f, 0.02505289f, 0.01966164f, 0.01049807f, -0.03268491f, -0.03751932f, -0.03690058f, 0.03347431f, 
    0.02742224f, -0.01000372f, -0.01885327f, -0.01524266f, -0.01603006f, 0.01754105f, 0.01526806f, 0.01671878f, 
    0.02653007f, -0.02048578f, -0.02870578f, 0.01138647f, -0.03564409f, 0.03192314f, 0.00786763f, 0.03265166f, 
    0.01206662f, -0.04464476f, -0.01132444f, 0.02247042f, 0.00596275f, 0.00589362f, -0.00992617f, -0.01592311f, 
    -0.02244093f, 0.04128027f, 0.00961558f, -0.03993673f, -0.02633692f, -0.03795353f, 0.02812989f, -0.03552845f, 
    -0.01249819f, -0.02601667f, 0.03183525f, -0.00168454f, 0.02654653f, 0.01385105f, -0.03570995f, 0.03446932f, 
    -0.00679803f, 0.00612529f, -0.03634854f, -0.03623591f, 0.00879186f, -0.01319547f, -0.01098710f, -0.00356018f, 
    -0.03401292f, 0.00658146f, -0.01745318f, 0.01314097f, -0.00387853f, 0.01818977f, -0.02726701f, 0.02106969f, 
    -0.01769801f, 0.00304717f, -0.01558633f, 0.00688362f, 0.02454473f, 0.01430648f, -0.01760419f, -0.02156143f, 
    0.01187370f, 0.03926016f, -0.01298768f, -0.03009585f, -0.04136643f, 0.03662816f, 0.00673537f, 0.01845071f, 
    -0.03728258f, 0.01525267f, 0.01725007f, 0.03326197f, 0.03763589f, -0.00820916f, -0.01355729f, -0.01665379f, 
    -0.02305190f, -0.03523519f, -0.01531351f, 0.03114358f, -0.02522512f, 0.01300543f, -0.00500127f, 0.02600055f, 
    -0.02173549f, -0.02284326f, -0.01737718f, 0.02910241f, 0.00387399f, 0.02659262f, -0.00131443f, -0.02996402f, 
    0.04273082f, 0.04136252f, 0.03843198f, 0.01261311f, 0.01799186f, 0.00550231f, 0.03144412f, -0.03473325f, 
    -0.00294558f, -0.00976669f, -0.04070843f, 0.01936437f, -0.04255402f, 0.04521435f, 0.00384266f, 0.01701177f, 
    -0.00576635f, -0.03660118f, 0.02453015f, -0.04495372f, 0.00514411f, -0.00974461f, 0.02326237f, 0.01054000f, 
    0.00160922f, 0.02023036f, -0.03013197f, -0.00987088f, -0.00974583f, -0.02289081f, -0.02170548f, -0.03751978f, 
    -0.02496590f, -0.03002358f, 0.03275544f, -0.03601927f, 0.01695514f, 0.03757953f, -0.02260362f, -0.02037701f, 
    0.04050785f, 0.00352941f, -0.02248896f, -0.02996476f, 0.04672465f, -0.02210050f, -0.03251051f, -0.03482595f, 
    0.00034674f, -0.01017478f, 0.00449845f, 0.03419553f, 0.00593402f, -0.03447698f, 0.01293197f, 0.01045137f, 
    -0.03225482f, -0.02736417f, -0.02390473f, 0.00625817f, -0.03828266f, 0.05066707f, -0.03917279f, -0.01336565f, 
    -0.02408719f, -0.01003958f, 0.03024541f, -0.00990958f, -0.03892440f, 0.02474754f, -0.01158125f, -0.01193412f, 
    -0.02063025f, 0.00427166f, -0.02321288f, -0.03364326f, -0.04671781f, 0.00988490f, -0.01721340f, 0.01078473f, 
    0.01623094f, 0.02953359f, -0.03672614f, -0.03850887f, 0.02792374f, 0.00140769f, 0.03611473f, 0.00294466f, 
    -0.03314550f, 0.00216762f, -0.04110422f, -0.00655464f, -0.00085636f, 0.03790497f, 0.00605928f, 0.00591215f, 
    -0.00854800f, -0.02105507f, -0.00365737f, 0.00273578f, 0.04316746f, 0.02968390f, -0.00738625f, -0.02321971f, 
    0.01645196f, -0.02428016f, 0.02414098f, -0.03163507f, 0.03223756f, -0.04348065f, -0.01780699f, 0.01472170f, 
    0.02485431f, 0.01373899f, -0.00436575f, -0.02865999f, 0.01407650f, 0.03564389f, -0.01439893f, -0.03735413f, 
    0.01595904f, 0.02959367f, 0.01320079f, 0.00394764f, -0.00811505f, 0.02563051f, -0.02455067f, -0.04160309f, 
    -0.02871558f, -0.02479758f, -0.00530595f, 0.00561043f, -0.01111448f, 0.02410615f, 0.02154147f, -0.02041093f, 
    -0.00388941f, 0.03764770f, -0.01430434f, -0.02297378f, 0.00473686f, 0.01396089f, 0.00835207f, -0.00803206f, 
    -0.02455650f, -0.02602395f, -0.03001891f, 0.00750918f, -0.00194103f, -0.03728412f, -0.00285947f, -0.00035473f, 
    0.00548298f, 0.00719702f, -0.00682592f, 0.02626299f, 0.03564935f, 0.01824023f, 0.03574563f, 0.01729923f, 
    -0.00135121f, 0.02591882f, -0.03109969f, -0.01139626f, -0.04585978f, -0.01598177f, -0.00897277f, -0.03726374f, 
    -0.00331153f, -0.02126107f, -0.01743955f, -0.03557647f, -0.03320015f, -0.00184708f, 0.00510628f, -0.01452349f, 
    -0.02582440f, -0.02277697f, 0.02283578f, -0.05756982f, 0.01962191f, -0.03819378f, -0.02280146f, 0.01130202f, 
    0.00083492f, -0.01535751f, 0.04187958f, -0.01264605f, -0.03194955f, 0.00416482f, 0.03203294f, -0.00637612f, 
    0.00559151f, -0.03362502f, 0.01873964f, -0.02660685f, 0.04325264f, -0.01953701f, 0.02720578f, 0.02551966f, 
    -0.04738465f, -0.00701298f, -0.03370257f, 0.03185000f, -0.00113870f, -0.02072768f, 0.01647129f, -0.01562481f, 
    -0.01627149f, 0.01002753f, -0.00801368f, 0.02575412f, 0.00356240f, 0.03244785f, 0.00708598f, 0.02667104f, 
    -0.01715357f, -0.00503599f, -0.00661175f, -0.03116456f, -0.01424843f, -0.03793254f, 0.01025631f, -0.00439528f, 
    0.01323421f, 0.04382112f, -0.00083801f, -0.02216970f, -0.02330179f, 0.02465414f, -0.01418360f, 0.02833051f, 
    -0.02875894f, -0.01597687f, 0.01462397f, 0.01766667f, 0.02647321f, -0.02803321f, -0.01005255f, -0.00236166f, 
    -0.27401060f, -0.15388058f, 0.00506777f, 0.01233227f, -0.05153828f, 0.05629197f, 0.01075623f, 0.08411676f, 
    -0.02593365f, -0.03948032f, 0.08324683f, -0.03362697f, -0.03131742f, 0.08911414f, 0.06146808f, 0.17465666f, 
    0.11357560f, 0.08492397f, 0.02782553f, -0.00315441f, -0.07010349f, -0.20416240f, -0.09031735f, 0.30758303f, 
    0.07887077f, -0.01468818f, 0.16980182f, -0.00827030f, -0.02527699f, 0.09706378f, -0.02815001f, -0.02338894f, 
    0.03642343f, -0.05126736f, 0.02536665f, 0.17598438f, 0.02568726f, 0.01579259f, 0.14528225f, 0.07181111f, 
    0.25837064f, 0.12918878f, 0.08628944f, 0.01415989f, 0.06996401f, 0.03325946f, 0.04251064f, 0.02139141f, 
    -0.02518559f, -0.01045827f, -0.06358702f, 0.08068193f, 0.07451855f, -0.06162575f, -0.08590076f, 0.06383432f, 
    0.09792970f, -0.03408309f, 0.05118416f, -0.00756453f, -0.15314023f, 0.06565648f, -0.08052368f, -0.03347559f, 
    -0.20941730f, 0.13672170f, 0.07896639f, 0.04676365f, -0.04937536f, -0.02822480f, -0.02824601f, -0.00069703f, 
    0.00209144f, 0.09654460f, 0.02834288f, 0.02894826f, -0.08385532f, 0.12309948f, -0.07129217f, -0.02954520f, 
    0.04854664f, -0.11866211f, 0.08357014f, -0.03662812f, -0.30001962f, 0.00098711f, 0.00206392f, 0.02153955f, 
    -0.09353622f, -0.04990295f, 0.07000281f, -0.05109499f, -0.01362610f, 0.09907860f, 0.00442391f, 0.02531453f, 
    -0.11028888f, 0.02795740f, -0.03970743f, -0.02330428f, -0.07755935f, -0.05456808f, -0.06359811f, 0.05299587f, 
    -0.12902775f, 0.05428310f, 0.06084027f, 0.06492671f, -0.04599836f, 0.04560317f, 0.04077997f, -0.00204375f, 
    0.01488126f, 0.02348827f, -0.00536728f, 0.01882204f, 0.00892852f, 0.00734870f, 0.01178933f, 0.04681873f, 
    0.44472781f, -0.16239411f, 0.04006992f, 0.01881072f, 0.11836361f, -0.03077306f, 0.03446876f, -0.02824333f, 
    -0.01749269f, -0.02630239f, 0.02200800f, 0.09387129f, 0.06710764f, 0.04866407f, 0.00057037f, 0.03344842f, 
    0.03290318f, -0.01090072f, 0.03935569f, 0.07072707f, 0.05510687f, -0.06540177f, 0.00755230f, -0.08251851f, 
    -0.27590871f, -0.00005337f, 0.09553413f, -0.10139259f, -0.03002151f, -0.00807494f, -0.00434724f, 0.08013068f, 
    0.01635899f, 0.05084334f, 0.01188478f, -0.03602540f, 0.08987450f, 0.13511637f, -0.04229198f, 0.07011864f, 
    -0.44359627f, 0.02427530f, 0.02146238f, 0.05316030f, 0.02032302f, -0.05211705f, 0.02493107f, -0.08577648f, 
    0.06990039f, 0.02630026f, -0.02219595f, 0.13072921f, 0.09271006f, 0.05494739f, -0.06967294f, 0.00343300f, 
    -0.10775975f, 0.02960226f, -0.16774487f, 0.00664343f, -0.20137806f, 0.03986434f, -0.15724607f, -0.13180770f, 
    -0.18777356f, 0.01861179f, 0.08921304f, 0.01039449f, -0.11274235f, -0.06401614f, -0.02069078f, -0.01372273f, 
    0.01860008f, -0.07486063f, 0.05283897f, -0.00493926f, -0.11726481f, -0.01705072f, 0.00237517f, 0.00532291f, 
    0.02034989f, 0.40400082f, 0.04787781f, -0.11297694f, 0.03852687f, 0.10100502f, -0.02563538f, 0.05733712f, 
    0.08727182f, -0.01179109f, -0.01811950f, 0.03854556f, -0.02811058f, -0.01387438f, 0.02372665f, 0.09321801f, 
    0.11967177f, 0.06174835f, 0.03822666f, 0.03077092f, -0.27671289f, 0.28295511f, 0.07142530f, 0.08854934f, 
    -0.10140174f, 0.05883811f, 0.14498423f, 0.02724328f, 0.06794181f, -0.03244865f, 0.00179950f, 0.00939471f, 
    -0.06733052f, 0.09185067f, -0.02013206f, 0.00324733f, 0.04517768f, 0.12963182f, -0.01479406f, 0.10344635f, 
    0.09352314f, 0.13620289f, -0.06541903f, -0.09374312f, -0.14872363f, 0.18957837f, 0.07894564f, 0.06293129f, 
    -0.00556678f, 0.02118246f, -0.04859523f, 0.05434361f, 0.04060892f, 0.08337925f, -0.02944862f, 0.04757868f, 
    -0.03079310f, 0.00614261f, -0.03194182f, 0.01091457f, 0.59349990f, -0.07061657f, -0.07593580f, 0.04982179f, 
    0.08625340f, -0.02893578f, -0.02705310f, 0.02933955f, -0.12019002f, 0.03772741f, 0.00670352f, 0.08903584f, 
    -0.01872692f, -0.03969594f, -0.10369660f, -0.02020646f, -0.07009789f, -0.04630997f, -0.13170916f, 0.02320919f, 
    0.08641601f, 0.20168403f, 0.08134640f, -0.09720383f, 0.15715261f, 0.00919144f, -0.07122487f, -0.01908981f, 
    -0.00827758f, 0.08229475f, -0.03421180f, -0.05947935f, 0.07781771f, 0.01932564f, -0.03695850f, -0.05160863f, 
    0.03076699f, -0.01458708f, 0.00238866f, -0.04926047f, -0.15048568f, -0.12226828f, -0.01923267f, -0.01953310f, 
    -0.06612213f, -0.05331149f, 0.05887702f, -0.00892167f, -0.04156034f, 0.04456528f, 0.05817701f, 0.09329921f, 
    0.04485740f, 0.03423233f, 0.03779078f, -0.02755194f, -0.10704145f, 0.04812960f, -0.04511837f, 0.04096713f, 
    -0.08821110f, -0.00777701f, 0.22888480f, -0.00621457f, 0.00113539f, 0.01801812f, 0.04138082f, 0.12531687f, 
    0.09657321f, -0.01175969f, -0.04014089f, -0.05446884f, -0.02682800f, -0.11896572f, -0.03413707f, 0.05607127f, 
    0.01440443f, -0.06872352f, 0.05849646f, 0.01468157f, 0.19931011f, 0.01026288f, 0.05657285f, -0.07840498f, 
    0.27410051f, 0.09516778f, 0.04442698f, -0.08497181f, -0.03972241f, 0.11421803f, 0.04011803f, 0.06186459f, 
    -0.01837004f, 0.09138653f, 0.07032979f, 0.09751590f, 0.16606860f, 0.06985541f, 0.05392805f, -0.07131451f, 
    0.06135512f, 0.12612247f, -0.02351147f, 0.26177877f, 0.10280325f, 0.01726895f, -0.05201486f, -0.00957491f, 
    0.01752660f, -0.14383142f, -0.07710486f, 0.00816902f, -0.04498629f, -0.00817305f, -0.09415410f, -0.00809610f, 
    0.01264229f, 0.05128283f, 0.02144540f, -0.00149734f, -0.00221746f, 0.09408973f, -0.04995890f, -0.15152739f, 
    0.29162872f, 0.00387710f, 0.04695202f, 0.05344747f, -0.01528539f, 0.06517119f, 0.12514316f, -0.03230701f, 
    -0.00840788f, 0.01000618f, -0.01213084f, -0.00102838f, -0.00173140f, -0.03205340f, -0.07341177f, 0.02865177f, 
    -0.07474921f, 0.13767387f, -0.03569739f, -0.18197420f, 0.12697276f, 0.02780438f, 0.07517711f, -0.03871946f, 
    0.00360027f, -0.03652987f, -0.08685675f, -0.06807390f, 0.00216449f, 0.04090161f, -0.00003111f, 0.02160974f, 
    -0.07007313f, -0.11459251f, -0.01278106f, -0.02372378f, 0.24519871f, -0.01763892f, -0.09812680f, 0.14010909f, 
    0.22894245f, -0.00929367f, 0.00217957f, 0.08316707f, 0.02691739f, -0.01691902f, 0.01007508f, -0.06127211f, 
    0.07842802f, 0.01597354f, -0.04781463f, -0.01524098f, 0.06800969f, 0.04600126f, -0.04287912f, 0.08920198f, 
    -0.01128384f, 0.14693196f, 0.03855273f, 0.05133997f, 0.05592219f, -0.04250050f, -0.01389401f, 0.10235370f, 
    -0.18567412f, -0.00388154f, -0.06498345f, -0.04719556f, -0.02982671f, 0.02305861f, -0.11190090f, -0.03113491f, 
    0.02547145f, -0.08377641f, 0.10166392f, -0.01354202f, 0.33938700f, -0.21175477f, -0.08473165f, 0.10739398f, 
    -0.07217309f, -0.08631214f, 0.04939287f, -0.01897800f, -0.06095386f, 0.00719721f, -0.07868187f, 0.02496213f, 
    0.07534852f, -0.07032670f, -0.01571135f, -0.05017373f, 0.03600552f, -0.01455918f, -0.09993595f, 0.10772344f, 
    -0.07529736f, 0.20082606f, -0.09267940f, -0.03186770f, 0.05277961f, -0.01046370f, -0.01447149f, 0.08356002f, 
    0.04897297f, 0.12202376f, 0.05461768f, -0.12129011f, 0.10008835f, 0.10470889f, 0.01992608f, 0.08212291f, 
    -0.06799969f, 0.01845552f, 0.04156181f, -0.01920689f, -0.19082499f, -0.45053977f, -0.10595484f, 0.12261996f, 
    0.05383910f, -0.01777497f, 0.01116635f, -0.08185244f, 0.05368638f, -0.05205558f, -0.03440954f, -0.04135795f, 
    0.06108030f, -0.00883289f, 0.02187615f, 0.08604018f, 0.02163845f, 0.00379798f, 0.00943279f, -0.01763394f, 
    0.17808805f, 0.21735539f, -0.01572434f, -0.09915005f, 0.01611826f, -0.05377044f, 0.02263819f, -0.01771992f, 
    -0.07755839f, 0.04609841f, -0.05288513f, -0.09992094f, 0.03707939f, -0.00341028f, 0.00431400f, 0.05631649f, 
    -0.00132320f, -0.02059814f, 0.14553836f, -0.04983426f, 0.21144417f, 0.22565104f, -0.25353691f, 0.02137928f, 
    0.11125092f, 0.08418333f, -0.02207235f, 0.15417062f, 0.07190373f, 0.10277823f, 0.10818448f, 0.10853060f, 
    0.09017928f, -0.03594672f, 0.04988397f, 0.13738506f, 0.03032055f, 0.03912024f, -0.00740932f, 0.05507177f, 
    0.22160093f, 0.21756625f, -0.13390307f, -0.16636109f, -0.14303222f, 0.11992990f, 0.05843745f, 0.05803165f, 
    -0.01775449f, 0.06558089f, 0.00063053f, 0.03665470f, -0.03667260f, 0.01464447f, 0.00477439f, 0.00331689f, 
    0.06136382f, -0.03806582f, -0.11097801f, 0.02520736f, 0.40683666f, -0.18124883f, -0.10495511f, 0.16773330f, 
    0.21082637f, -0.03135530f, 0.08843808f, -0.00876639f, -0.00981311f, 0.20237693f, 0.00731363f, 0.02288881f, 
    -0.04445037f, 0.00084088f, -0.02595639f, -0.02832838f, 0.04895371f, 0.06444593f, -0.03754302f, 0.05034044f, 
    0.03095606f, 0.11888919f, -0.02230598f, 0.10375362f, -0.02176783f, 0.10422374f, -0.04167087f, 0.01257860f, 
    -0.05877212f, 0.00760473f, -0.09120622f, 0.06997845f, -0.01483369f, 0.01369769f, 0.08789581f, 0.05088456f, 
    0.01387827f, -0.03800709f, -0.07065826f, 0.02034580f, 0.35263163f, -0.06852841f, 0.17140383f, -0.04004614f, 
    0.07781934f, -0.06172114f, -0.01254359f, 0.03357074f, -0.09694541f, 0.06705006f, -0.02734532f, -0.01681413f, 
    -0.03334231f, -0.00062984f, -0.04391843f, -0.09963717f, -0.03125614f, -0.04057642f, -0.05339054f, -0.04214837f, 
    -0.01636995f, 0.02102673f, -0.03119160f, -0.00606256f, 0.02691340f, -0.03456488f, -0.03649196f, 0.01657797f, 
    -0.04138862f, -0.04006336f, 0.01096604f, -0.00515117f, -0.00651262f, -0.00044319f, -0.03529126f, 0.01300661f, 
    -0.01390203f, -0.04274432f, -0.03302542f, 0.00240193f, 0.01153413f, 0.02809031f, -0.03194961f, 0.03269861f, 
    -0.00237696f, -0.01811796f, 0.00537535f, 0.03210609f, 0.01543557f, 0.00648228f, -0.01508774f, 0.01360834f, 
    -0.03812251f, 0.02455080f, 0.02157822f, 0.03198546f, -0.03081792f, -0.03189719f, -0.01830251f, -0.02253780f, 
    0.01138992f, -0.02781124f, -0.01564493f, -0.01317053f, 0.00474177f, 0.00697323f, -0.00634875f, -0.02330921f, 
    0.03078120f, 0.00326851f, -0.00983160f, -0.02430560f, -0.01691229f, 0.02425752f, 0.01379870f, -0.03866232f, 
    0.02451085f, -0.01448718f, 0.00874184f, -0.00457779f, -0.01219778f, -0.02834840f, 0.00354953f, 0.00090235f, 
    0.01822048f, 0.02151595f, -0.03600032f, -0.04037175f, -0.03464659f, -0.02500363f, -0.03931793f, -0.02833501f, 
    -0.03829351f, 0.01102049f, -0.02726380f, 0.00628396f, 0.01260659f, 0.01909036f, -0.04324415f, 0.02072822f, 
    -0.02067017f, 0.00258828f, -0.01213553f, -0.01587317f, 0.02146493f, -0.00207470f, -0.02335794f, -0.00245301f, 
    -0.01127780f, 0.00686209f, 0.03084004f, 0.01600419f, -0.02617008f, -0.03114561f, 0.02498105f, 0.01325185f, 
    -0.01196878f, 0.02872728f, -0.03511132f, -0.03775288f, 0.02307644f, -0.01447387f, 0.00000603f, 0.01350246f, 
    -0.00396183f, -0.03537714f, -0.00712228f, -0.01242490f, -0.04363905f, -0.02040754f, -0.02802099f, -0.01505851f, 
    0.00510316f, -0.00257215f, 0.01017660f, -0.00037307f, 0.01342241f, 0.02232763f, -0.04000399f, -0.01582883f, 
    -0.03772552f, 0.02616156f, -0.01692270f, -0.00214790f, 0.03382612f, 0.02725608f, -0.01810897f, 0.01587184f, 
    0.01031627f, -0.03062771f, -0.03723678f, -0.04432004f, -0.02592354f, -0.00146968f, 0.00477755f, -0.01947773f, 
    0.00635389f, -0.03571052f, -0.02747541f, -0.00773031f, 0.02781633f, -0.00210305f, -0.00618044f, -0.01618257f, 
    0.01337441f, -0.03041299f, -0.00585285f, -0.00733612f, 0.01111561f, 0.02488237f, -0.03859542f, -0.00518452f, 
    -0.01044196f, -0.01075943f, -0.00927339f, -0.00923767f, -0.04146959f, 0.02665878f, -0.02168087f, 0.03141520f, 
    -0.02475986f, -0.01410668f, -0.00616223f, -0.02260868f, -0.01987698f, 0.00614586f, -0.00811229f, -0.03541550f, 
    0.02107020f, 0.02578025f, -0.03429968f, -0.02202383f, -0.03476081f, 0.01632241f, -0.04254903f, 0.02206862f, 
    -0.01005233f, -0.02764529f, -0.04077744f, 0.02355417f, 0.02108290f, 0.03382322f, -0.02695699f, -0.01093701f, 
    0.00696548f, -0.00716215f, 0.02933838f, -0.03286081f, 0.01384003f, 0.03035166f, -0.00875462f, -0.02034888f, 
    0.02352003f, 0.02873161f, -0.00801320f, -0.00768726f, 0.00657301f, -0.03032110f, 0.00034353f, 0.03788915f, 
    -0.01347795f, 0.01723413f, 0.01126329f, -0.01731084f, -0.04166887f, 0.03253261f, 0.03134223f, -0.01543185f, 
    -0.04129145f, 0.00582353f, -0.00399680f, -0.01212745f, -0.03732070f, 0.03225978f, -0.00248598f, -0.02364465f, 
    0.00455102f, -0.04411513f, 0.01468744f, -0.02999239f, -0.02505453f, 0.02044476f, -0.01796350f, -0.00503240f, 
    0.01479893f, -0.04154732f, 0.03358988f, -0.00911395f, 0.00357157f, -0.01059197f, 0.02747622f, 0.01955864f, 
    0.01530657f, -0.03821947f, 0.03286581f, 0.02158056f, -0.00706118f, 0.01108704f, 0.01766210f, -0.03164304f, 
    -0.01078772f, -0.03571671f, -0.00715761f, -0.02120288f, 0.03278358f, -0.01070134f, -0.04284913f, -0.01983604f, 
    -0.03490185f, 0.00120743f, -0.04481770f, 0.03105279f, -0.00118945f, -0.03825976f, -0.03807753f, -0.00773007f, 
    -0.01512728f, 0.00132464f, -0.03566203f, -0.02144910f, -0.02474019f, 0.01918126f, -0.00171627f, -0.04252950f, 
    0.02918949f, -0.00811034f, 0.02214199f, 0.02981010f, -0.00134285f, 0.03122149f, -0.00443198f, -0.01260700f, 
    0.02291371f, -0.03595317f, -0.01187772f, 0.01932755f, -0.00238313f, -0.04236351f, 0.01006117f, 0.01337379f, 
    0.00604872f, 0.00550847f, -0.02989124f, -0.03202811f, 0.02205133f, 0.01599494f, 0.02661206f, -0.01421451f, 
    -0.02519540f, -0.04408020f, 0.00711371f, -0.02914453f, -0.00917932f, -0.00147888f, 0.02869551f, 0.02377161f, 
    -0.01336590f, -0.03687214f, -0.03431213f, 0.00360602f, 0.01173430f, 0.02062173f, -0.01357207f, 0.00690709f, 
    -0.03883104f, -0.02868905f, 0.00017256f, -0.01408789f, 0.00060626f, -0.00973229f, -0.03310456f, -0.01630986f, 
    0.03208554f, -0.02287672f, 0.01019341f, 0.01756009f, 0.02249235f, -0.01101800f, -0.03491310f, -0.02089916f, 
    0.00188912f, -0.03521907f, 0.03376682f, -0.02753744f, -0.00915195f, 0.02629608f, -0.03308922f, -0.03274818f, 
    0.00860027f, 0.03784713f, 0.00173488f, 0.02924304f, 0.02719548f, 0.01051620f, 0.00837924f, -0.02507742f, 
    0.01961360f, -0.00617895f, -0.00849340f, -0.00632009f, 0.00507030f, 0.01087269f, -0.02750515f, -0.02440283f, 
    0.00404969f, -0.01658446f, -0.01374853f, -0.00146040f, 0.01753975f, -0.01003600f, -0.03908637f, -0.01155553f, 
    -0.00082594f, 0.00076910f, 0.03240780f, 0.01540003f, -0.03412934f, -0.01165331f, -0.00527660f, -0.01472696f, 
    0.01071015f, 0.01158908f, -0.03816683f, -0.02879730f, -0.02405509f, -0.00053704f, -0.01209961f, -0.00043234f, 
    -0.03192751f, 0.02611915f, -0.02836802f, -0.00302167f, 0.00745019f, 0.02823160f, -0.03499367f, -0.04255299f, 
    0.00206132f, 0.00267944f, -0.04436455f, -0.02699286f, 0.00152040f, 0.01158748f, -0.02721852f, -0.03661707f, 
    0.01992521f, -0.03118865f, -0.01712970f, -0.01798753f, -0.01372644f, 0.00905363f, -0.03809436f, -0.03790957f, 
    0.02024829f, -0.03795566f, 0.00342304f, -0.02189472f, -0.02583424f, 0.02571696f, -0.00091767f, -0.02844078f, 
    0.00106540f, -0.00331448f, -0.03914984f, -0.01891699f, -0.00418091f, -0.01984350f, -0.01216467f, 0.00595428f, 
    -0.02992295f, -0.03398363f, 0.01800601f, 0.00757455f, -0.04252454f, -0.02418133f, -0.01259494f, 0.03257085f, 
    0.02321292f, -0.01071591f, 0.01047857f, -0.01722627f, -0.02252177f, 0.01916791f, 0.01289447f, -0.02272201f, 
    -0.02678201f, 0.02924647f, -0.02399542f, -0.00024153f, -0.01019941f, -0.03118680f, 0.00959802f, -0.01021949f, 
    -0.00836176f, -0.04304108f, 0.02254044f, 0.00241934f, -0.00912065f, 0.01998904f, -0.01806692f, 0.00408463f, 
    0.02520093f, -0.01799274f, -0.03725777f, 0.00014136f, -0.02119130f, -0.04403090f, -0.00779438f, 0.00951375f, 
    0.02828086f, 0.00327067f, -0.01421081f, 0.02405327f, 0.01561665f, -0.04405775f, -0.00242632f, -0.03945477f, 
    -0.01188503f, -0.03283067f, 0.03308028f, -0.02259281f, -0.02846427f, -0.01526909f, -0.03915129f, 0.01912920f, 
    -0.02729102f, -0.01334799f, -0.01668524f, 0.00789357f, 0.02015178f, -0.00381504f, -0.03769311f, -0.03474438f, 
    -0.01438219f, 0.02117212f, 0.03041172f, -0.03442475f, -0.02645465f, -0.03667061f, 0.03068952f, 0.03162586f, 
    -0.03206309f, -0.01152660f, 0.02165208f, -0.03840118f, -0.02290776f, -0.03745634f, 0.01775662f, 0.01445501f, 
    0.03034516f, -0.01034798f, -0.04044829f, -0.03402007f, 0.02021207f, 0.01988806f, -0.02360453f, -0.01521535f, 
    -0.04367157f, 0.00565079f, 0.02510926f, 0.02844712f, 0.02394969f, -0.03605309f, 0.00340231f, -0.02244131f, 
    0.00443650f, 0.00082640f, -0.03825480f, -0.01573570f, 0.03246508f, 0.03235389f, -0.01916919f, -0.03492136f, 
    -0.01303653f, -0.01714573f, 0.00762115f, -0.02218649f, -0.00539015f, -0.00245003f, 0.03228527f, 0.01561570f, 
    0.01114770f, 0.01850767f, -0.01296861f, -0.00546001f, 0.02636250f, -0.04037562f, 0.02563249f, 0.01212396f, 
    0.01960290f, -0.00342606f, -0.03370828f, 0.01578197f, -0.01503344f, -0.02878373f, -0.02698608f, 0.00581515f, 
    -0.03769805f, -0.03883549f, -0.04111543f, 0.02364007f, -0.02747160f, 0.02840760f, -0.00875540f, -0.00569338f, 
    0.00392542f, -0.00699203f, -0.03161165f, -0.00878220f, -0.00927119f, -0.00228972f, -0.04443666f, -0.01333725f, 
    -0.04259437f, -0.00914613f, 0.00730952f, -0.02505656f, -0.03828992f, 0.00812147f, -0.03660562f, -0.02582116f, 
    0.00097157f, 0.03704910f, -0.01308593f, 0.02235801f, 0.00942183f, 0.03934945f, -0.00669923f, -0.00517142f, 
    0.02712269f, 0.03085073f, -0.00119217f, 0.01408366f, 0.02526321f, -0.01520811f, -0.03458756f, 0.02499388f, 
    -0.03983356f, -0.04078768f, -0.00933852f, -0.00837396f, -0.02440767f, -0.00961259f, -0.01348343f, -0.00445939f, 
    -0.01577922f, 0.00622902f, -0.01193740f, -0.04246276f, -0.02267653f, 0.01519869f, -0.03961699f, 0.00737410f, 
    -0.03905528f, -0.02246197f, -0.01994598f, 0.00023879f, 0.02074694f, -0.00520178f, -0.02377217f, 0.02693669f, 
    0.00267527f, -0.02131246f, 0.02410983f, 0.01986668f, -0.00464292f, 0.02404165f, -0.00661898f, -0.03991590f, 
    -0.02232187f, -0.04454860f, -0.04455449f, 0.03214169f, -0.03736192f, -0.02400081f, 0.03175934f, -0.02734962f, 
    0.03758722f, -0.00960453f, -0.00820471f, 0.02537408f, -0.02670989f, -0.01423758f, 0.00634705f, 0.01914794f, 
    -0.02629419f, -0.02331356f, -0.03066732f, -0.03967819f, -0.03410200f, -0.00626632f, -0.00677045f, -0.02445043f, 
    0.00449433f, 0.02607896f, 0.00674858f, 0.00809315f, -0.00001082f, 0.01237184f, 0.01078152f, 0.03327347f, 
    0.09305375f, -0.10420602f, -0.10967026f, 0.08822566f, -0.01320098f, 0.04703056f, -0.03691821f, 0.04389537f, 
    0.01947455f, 0.05562491f, -0.09877042f, 0.00183394f, -0.02324172f, -0.02219432f, -0.01712178f, 0.07078171f, 
    0.01115734f, -0.14392191f, 0.05822714f, 0.03797867f, 0.28043389f, 0.16218296f, -0.15999819f, -0.14888398f, 
    0.10921114f, -0.01088195f, 0.17258187f, -0.07363178f, 0.05889217f, 0.01377565f, -0.01130014f, 0.01033928f, 
    -0.01938999f, 0.08879958f, -0.13618220f, 0.00176798f, 0.05711796f, -0.03772886f, 0.03037172f, 0.06951655f, 
    -0.17892595f, 0.26137859f, -0.09749690f, 0.04043521f, 0.01726123f, 0.06477842f, -0.05553615f, 0.00611021f, 
    -0.00903718f, 0.06556073f, 0.06179026f, -0.07313246f, 0.07818107f, -0.09734347f, 0.08077478f, -0.02201835f, 
    0.02717675f, 0.07875136f, 0.13175882f, -0.02594271f, 0.08142176f, 0.10483896f, 0.14334065f, 0.17790264f, 
    -0.26728597f, 0.00937246f, 0.00690496f, -0.00676935f, 0.04745148f, 0.07163373f, 0.07230438f, 0.02764193f, 
    0.03823969f, 0.05174088f, 0.02409118f, -0.05329471f, -0.03452663f, -0.10515882f, -0.00089803f, 0.00284549f, 
    -0.19621149f, 0.17837037f, 0.07699464f, 0.11211389f, 0.01845884f, -0.05941182f, -0.04265240f, -0.00253576f, 
    0.05760054f, 0.10857695f, -0.01119594f, 0.04051335f, 0.05576618f, 0.00506673f, 0.04389801f, 0.06706713f, 
    0.08718668f, -0.07337503f, -0.06889874f, -0.04118042f, 0.10624915f, -0.03636891f, -0.04403910f, 0.07984722f, 
    -0.14533938f, 0.04695371f, 0.01773691f, -0.04937700f, 0.03851446f, 0.05047865f, -0.12543766f, 0.04611129f, 
    0.00276415f, 0.05455526f, -0.02362747f, -0.03071265f, 0.08851347f, -0.03143324f, -0.09784613f, 0.06234699f, 
    -0.05650228f, -0.02581388f, -0.17463398f, -0.04488631f, 0.17321621f, 0.04634843f, -0.04628470f, -0.00386149f, 
    0.05647489f, 0.05430357f, -0.00080601f, -0.00166402f, 0.05744207f, 0.00179401f, -0.01005511f, 0.10822783f, 
    0.08030511f, 0.03379064f, 0.04774831f, 0.00867984f, -0.15410152f, 0.06178841f, 0.11411714f, 0.03891524f, 
    -0.03227093f, 0.00069967f, -0.02241688f, 0.13028872f, 0.07443686f, 0.07998025f, 0.08005223f, -0.00363503f, 
    0.00696220f, 0.00184979f, -0.03560327f, 0.04956773f, 0.06169326f, 0.00912913f, -0.04558760f, -0.09819608f, 
    -0.19261761f, -0.14002535f, -0.15950643f, 0.00557195f, 0.02448848f, -0.05064763f, 0.03325657f, 0.04975652f, 
    0.04593500f, -0.01419879f, 0.08855413f, 0.06114483f, 0.10974259f, 0.16699779f, 0.06585059f, 0.00270661f, 
    -0.08990041f, -0.04001607f, -0.01618762f, 0.02222920f, -0.04978387f, 0.28318611f, -0.05643094f, 0.16237751f, 
    -0.06961171f, -0.11397167f, 0.04608510f, 0.05208415f, 0.05787015f, 0.00783584f, -0.01139416f, -0.09720982f, 
    0.05447028f, -0.00332303f, 0.04871991f, -0.02582820f, 0.00218864f, 0.02215913f, -0.07050534f, 0.04410222f, 
    0.00123327f, -0.12154133f, -0.06289186f, 0.08773461f, 0.00148315f, 0.06543737f, 0.01905438f, 0.08418454f, 
    -0.00108699f, -0.04715813f, 0.07165558f, 0.02555540f, -0.00713334f, -0.09259129f, 0.04982059f, 0.04132189f, 
    -0.05167911f, 0.03769979f, 0.12329893f, 0.00214160f, 0.06953622f, -0.05158186f, 0.14274712f, 0.00120193f, 
    -0.04797878f, 0.01438867f, -0.06686503f, 0.05112522f, 0.01062901f, 0.03434384f, -0.04349206f, -0.00112200f, 
    -0.06910814f, 0.02966382f, -0.02883514f, 0.11243995f, 0.07066286f, -0.07713803f, -0.07838114f, -0.05235934f, 
    -0.01650426f, 0.02687481f, 0.11806196f, 0.16762815f, -0.13920715f, -0.07331543f, -0.01271957f, 0.04757361f, 
    0.03641922f, 0.01801407f, 0.11481480f, 0.02974300f, 0.05612928f, 0.00370996f, -0.03313274f, -0.01403007f, 
    0.01447214f, -0.06615063f, -0.02621804f, 0.08030108f, -0.16788258f, -0.11547901f, -0.26112774f, -0.07126535f, 
    -0.00380479f, 0.06049793f, -0.01007831f, -0.01916954f, 0.00092472f, 0.00887790f, -0.05498060f, 0.07889973f, 
    0.10052370f, 0.12689424f, 0.03764113f, 0.00540768f, 0.01985785f, 0.12855695f, -0.00982220f, 0.09732533f, 
    0.11665978f, -0.05539289f, -0.24277076f, -0.05298050f, 0.04846489f, -0.15652984f, 0.00290808f, 0.08452553f, 
    -0.10422467f, -0.05365676f, 0.06885291f, -0.01132520f, 0.02654427f, -0.03898406f, -0.04097490f, 0.00336727f, 
    0.06248470f, 0.05899532f, 0.04908988f, -0.00795584f, -0.26249599f, -0.20521228f, -0.22827576f, -0.00870127f, 
    -0.08790382f, 0.00940454f, 0.12708208f, 0.07346668f, -0.03979839f, 0.04934809f, -0.03459772f, 0.12028603f, 
    -0.00103891f, 0.11742652f, 0.01296194f, 0.07515102f, 0.02243025f, 0.00006219f, -0.08368526f, -0.03793482f, 
    0.09369892f, -0.23669592f, 0.02445439f, 0.04156414f, -0.02153073f, 0.00589572f, 0.07890180f, -0.07800704f, 
    0.02271704f, -0.03447416f, -0.04298995f, 0.03925749f, -0.03364983f, -0.03536269f, 0.02873481f, -0.12631500f, 
    -0.01142824f, -0.14537549f, -0.07614837f, -0.09261263f, 0.03443613f, 0.13268745f, -0.16413814f, 0.04694106f, 
    0.17673874f, 0.03128428f, -0.03211832f, -0.02322605f, 0.00251230f, -0.06537681f, -0.02468243f, 0.08055113f, 
    -0.05442098f, -0.04558784f, -0.05305774f, 0.02541050f, -0.00732462f, 0.15456256f, -0.01105720f, 0.01139767f, 
    0.07671610f, 0.07333744f, 0.04244935f, 0.08557058f, 0.09182216f, -0.05162458f, 0.01442686f, 0.06589145f, 
    -0.00278243f, -0.15199655f, -0.00153801f, -0.03665479f, -0.11487812f, 0.00771776f, 0.06497075f, 0.04116854f, 
    0.06203000f, -0.01908680f, -0.09542970f, 0.09183533f, 0.21115114f, 0.15812102f, -0.10086003f, -0.07932675f, 
    0.13187850f, 0.03914903f, -0.03003453f, 0.03858019f, -0.02321646f, -0.07770821f, -0.02892501f, 0.04836770f, 
    -0.02460811f, -0.06687465f, -0.05181892f, 0.05997896f, 0.01068667f, 0.11505791f, 0.04793287f, 0.08393541f, 
    -0.07552627f, 0.01037945f, 0.17044932f, -0.10073306f, -0.00659861f, 0.11977966f, 0.06636034f, 0.06078091f, 
    -0.01540755f, 0.06662245f, 0.00301302f, -0.09212855f, -0.20613970f, -0.01129608f, 0.10013282f, 0.08367658f, 
    0.05821351f, -0.01793283f, 0.17926049f, 0.11228937f, -0.20986857f, 0.13533270f, 0.11637673f, 0.02234733f, 
    0.07981538f, 0.07132776f, -0.02043492f, -0.00792408f, -0.06321208f, -0.01154888f, -0.04202646f, 0.05242114f, 
    -0.01498776f, 0.00912389f, -0.00634979f, -0.03559818f, 0.09422562f, 0.12792520f, -0.03822576f, 0.03068928f, 
    0.11383530f, 0.34999734f, -0.13106094f, 0.00848627f, 0.16328065f, 0.00616676f, 0.05950520f, 0.03848615f, 
    0.02915382f, 0.04453724f, 0.07378240f, -0.01974330f, 0.05873135f, 0.02383585f, 0.04374917f, -0.01295768f, 
    -0.03962824f, 0.03717327f, 0.03499788f, 0.05409301f, -0.33349133f, -0.03913990f, -0.16000056f, -0.10321081f, 
    0.08741412f, 0.11310498f, -0.01448798f, 0.08860781f, -0.08209663f, 0.09082668f, -0.07613162f, -0.10430079f, 
    0.13199423f, -0.02731713f, 0.05342914f, -0.02246713f, 0.02621478f, 0.07450620f, 0.03923835f, -0.01803111f, 
    0.05517252f, -0.05377627f, 0.09410145f, 0.01772634f, 0.21743010f, 0.06656876f, -0.00983624f, 0.08088386f, 
    -0.02012752f, 0.11364101f, 0.05612760f, 0.03668302f, 0.02472951f, 0.00158204f, 0.06405958f, 0.03537549f, 
    0.03799677f, -0.03847885f, 0.15976045f, -0.02400680f, -0.04887833f, 0.04874086f, 0.12349108f, -0.05242028f, 
    0.04626150f, 0.00089589f, 0.05657651f, 0.11280181f, 0.01386445f, -0.04607997f, -0.04179085f, -0.02077163f, 
    0.03531479f, 0.06143984f, -0.03988869f, -0.01895333f, 0.11660562f, 0.11977223f, 0.05121196f, 0.13008843f, 
    -0.05282284f, 0.19054383f, -0.15683636f, 0.05852026f, 0.12342069f, 0.07527964f, 0.02910042f, 0.08283007f, 
    0.01643744f, -0.00466285f, 0.05850250f, -0.04265188f, 0.02738426f, -0.03404089f, 0.00222314f, -0.09845589f, 
    -0.09629168f, -0.00522017f, 0.15571618f, 0.07023817f, -0.13837770f, -0.05859710f, 0.04957177f, 0.15105176f, 
    0.05078229f, -0.02860295f, 0.07949083f, -0.01719251f, -0.00344599f, -0.05390561f, 0.08908955f, -0.07629076f, 
    -0.09124267f, 0.06252738f, -0.05346381f, -0.05089973f, -0.07985725f, -0.01320865f, 0.04919629f, 0.19612810f, 
    -0.06542340f, 0.04355536f, 0.17592818f, 0.31370115f, -0.10814548f, -0.09089018f, 0.01096887f, 0.00863800f, 
    0.01813431f, 0.02611067f, 0.00187081f, 0.00402888f, 0.00602398f, 0.00290453f, 0.01542068f, 0.03642327f, 
    -0.10723741f, -0.09002629f, 0.01878241f, 0.03765101f, -0.08360757f, -0.09359520f, -0.21350984f, -0.01086372f, 
    0.05100868f, 0.16759580f, 0.01909910f, -0.01818752f, 0.02263069f, 0.07064068f, -0.01452027f, -0.03128575f, 
    -0.02655636f, 0.10445539f, -0.00133596f, 0.04837599f, 0.08920012f, -0.02820985f, -0.08803862f, -0.04143405f, 
    -0.06860554f, -0.10519961f, -0.10312706f, -0.12824972f, -0.03628194f, 0.03044813f, 0.00851022f, -0.05048398f, 
    -0.01085593f, -0.09367917f, -0.09586927f, 0.04087091f, -0.05165642f, 0.10085598f, 0.05818956f, 0.06743799f, 
    0.05635604f, -0.06742039f, 0.08574003f, -0.00527858f, -0.08584914f, -0.15960649f, -0.22835356f, -0.16140577f, 
    0.01540460f, 0.01455826f, -0.03743521f, 0.01528737f, -0.03283918f, 0.10624316f, 0.05633650f, 0.06779316f, 
    0.04658603f, 0.12326170f, -0.02174177f, 0.03502646f, 0.03331336f, -0.01303654f, 0.04134157f, -0.02219048f, 
    0.00090383f, -0.00358573f, -0.04031395f, -0.00353925f, -0.03616432f, 0.00281228f, -0.01734026f, -0.03053067f, 
    0.03101514f, 0.00331446f, -0.01824073f, -0.00537514f, -0.00651934f, 0.02412060f, -0.00536591f, 0.01434672f, 
    -0.03658793f, 0.01482713f, -0.00575171f, 0.02697549f, 0.02400685f, 0.03044663f, -0.00272875f, 0.00653492f, 
    0.00828459f, -0.00614423f, 0.01573214f, -0.03247036f, -0.02465361f, -0.00465055f, 0.01355412f, -0.00188504f, 
    0.02069793f, -0.01019127f, 0.01372789f, -0.01846287f, -0.03865721f, 0.01081490f, -0.04077602f, 0.01271360f, 
    -0.03625119f, 0.01462065f, -0.00846819f, -0.02894171f, -0.03611513f, -0.01471173f, 0.01615651f, 0.00233821f, 
    -0.00080275f, 0.03067888f, 0.00041622f, -0.02917793f, -0.03241017f, -0.00583711f, -0.03450131f, -0.00974013f, 
    -0.01611470f, 0.01099612f, -0.00622509f, -0.02273288f, -0.01502877f, -0.03724341f, 0.02903241f, -0.02070095f, 
    -0.02075429f, -0.02399394f, -0.02867233f, -0.00621048f, -0.03298245f, 0.03033385f, -0.01307130f, -0.01204360f, 
    0.02264441f, 0.00792171f, -0.03317399f, 0.03153805f, -0.02394649f, -0.00472494f, 0.02431542f, -0.04294283f, 
    -0.00457200f, 0.00276944f, -0.03129528f, 0.00074478f, -0.00347118f, -0.03844751f, -0.00939984f, -0.00351874f, 
    0.00279368f, -0.01982710f, 0.00651755f, -0.00219728f, -0.01569402f, 0.00075822f, 0.01034881f, 0.03970695f, 
    0.01457849f, -0.02055201f, -0.03623104f, -0.02918672f, 0.01700743f, 0.00049091f, 0.01162915f, 0.02908993f, 
    -0.03552832f, 0.00882844f, -0.01696955f, -0.01641929f, 0.00388180f, 0.00881271f, -0.03716935f, -0.01259228f, 
    0.00400607f, -0.01821621f, -0.03667697f, 0.02936334f, -0.01845421f, 0.02550763f, -0.03482903f, 0.01511212f, 
    -0.01757278f, -0.01133534f, 0.01517093f, -0.01122914f, -0.01221653f, -0.00405358f, 0.00240293f, 0.02934928f, 
    -0.00221974f, -0.02213396f, -0.04036366f, -0.02544782f, 0.02919207f, 0.01592064f, 0.00253847f, 0.01008953f, 
    -0.00998067f, -0.03412260f, -0.01377702f, 0.02596980f, 0.00540921f, 0.01141700f, -0.03819434f, -0.02988459f, 
    0.01383505f, 0.02484539f, -0.02605356f, -0.00736118f, 0.03062039f, 0.02881735f, -0.04132134f, -0.02673891f, 
    0.01021318f, -0.00872833f, 0.00617396f, -0.03199726f, -0.02169470f, -0.03952162f, -0.01911186f, -0.00456274f, 
    0.00129397f, 0.01727409f, 0.00283068f, -0.03394299f, -0.04539342f, 0.01248728f, 0.01673252f, 0.01810925f, 
    -0.01574762f, -0.00957518f, -0.00057617f, 0.01706207f, -0.03744858f, -0.02154838f, 0.03333481f, 0.02234451f, 
    0.00584621f, -0.00750599f, 0.01922474f, -0.03718486f, -0.00055100f, 0.00444238f, -0.02172441f, 0.02369684f, 
    -0.01782929f, -0.00207142f, -0.00415965f, 0.00862411f, 0.02247302f, -0.02975252f, 0.02357070f, -0.00564061f, 
    0.01172229f, 0.02414716f, -0.03457906f, -0.02885946f, 0.01584206f, 0.02669469f, 0.00781119f, -0.00934799f, 
    0.03022674f, 0.00803149f, -0.03357373f, -0.04095106f, -0.03766791f, 0.00523377f, -0.04012706f, 0.02447113f, 
    0.00483452f, -0.00654970f, -0.03890127f, 0.03346282f, 0.02463363f, 0.01963793f, -0.04226703f, -0.03179930f, 
    -0.04511123f, -0.02693819f, 0.00245450f, -0.02578334f, -0.01191455f, 0.00814846f, -0.03998131f, 0.00889325f, 
    -0.02889453f, 0.00345491f, -0.01972686f, -0.01941225f, 0.00199960f, -0.04522416f, -0.00617495f, -0.01653195f, 
    -0.02873637f, -0.01845679f, 0.00232378f, 0.00277951f, -0.01018567f, 0.01962061f, -0.01522029f, -0.01489540f, 
    -0.00846221f, 0.01703701f, -0.02232858f, -0.04252802f, -0.03435960f, -0.00924270f, 0.02209778f, 0.02988948f, 
    -0.02538222f, -0.03875691f, -0.02160929f, 0.02077303f, -0.01991641f, 0.03088728f, 0.02755534f, -0.03467715f, 
    -0.00144670f, -0.00246185f, -0.01759284f, -0.01369766f, -0.03866941f, -0.02079476f, 0.02374726f, 0.00046474f, 
    0.00970579f, -0.00773790f, -0.04449305f, -0.01620946f, 0.02502576f, -0.00333397f, 0.02363513f, -0.00210338f, 
    -0.00698907f, -0.00511176f, 0.02650131f, 0.01413580f, 0.01841258f, -0.03908768f, 0.03132010f, -0.03195478f, 
    0.00956882f, 0.03219673f, -0.01511512f, -0.00381943f, -0.00131890f, -0.04146770f, -0.03565604f, -0.02054584f, 
    -0.03833022f, -0.00136062f, 0.00646212f, 0.02893485f, -0.02897709f, -0.04057366f, 0.02211184f, -0.02874193f, 
    0.00962506f, -0.03339896f, -0.00027948f, 0.01928422f, -0.02424537f, -0.01683417f, 0.03032792f, -0.04396204f, 
    0.01213255f, 0.01729372f, -0.04019378f, -0.02070291f, -0.01628336f, -0.00792469f, 0.02658268f, -0.00418977f, 
    -0.00028447f, 0.02628631f, -0.02452655f, 0.02188238f, -0.01898879f, 0.00514277f, 0.00173868f, 0.02146218f, 
    -0.03716584f, 0.03291824f, 0.03064761f, -0.03612238f, -0.02169743f, 0.00381249f, 0.00397037f, -0.02343617f, 
    0.03145654f, 0.01406918f, -0.03786514f, 0.00754146f, 0.02495476f, 0.02444622f, 0.01999704f, -0.03177322f, 
    0.01737767f, -0.01376512f, 0.01910898f, -0.00042916f, -0.02753099f, 0.00433157f, -0.03900632f, 0.01035455f, 
    0.02497552f, 0.03325827f, -0.00739807f, 0.02064347f, -0.02034689f, 0.00829571f, 0.00087602f, -0.02272817f, 
    -0.04539279f, -0.04342851f, 0.00110240f, -0.00921868f, -0.02588434f, -0.02524246f, -0.01723534f, 0.01091357f, 
    -0.03168144f, 0.00815068f, 0.00776130f, 0.00860610f, -0.01295430f, 0.02251507f, -0.00758229f, 0.00450184f, 
    -0.04448618f, 0.01384718f, 0.03183481f, 0.00267067f, -0.04531898f, -0.02271199f, 0.02883994f, -0.02213813f, 
    0.03299754f, -0.00392592f, -0.00422130f, -0.00525101f, 0.01331068f, -0.01460602f, -0.00274104f, 0.02120583f, 
    -0.03517537f, -0.00075418f, -0.01725125f, -0.00986973f, 0.02329403f, -0.00402095f, -0.00655801f, -0.03616029f, 
    -0.00223194f, -0.00076871f, -0.00131776f, 0.02515843f, -0.04202982f, 0.02033843f, 0.01526485f, -0.00725111f, 
    -0.04153280f, 0.01077667f, -0.02306113f, -0.02384951f, -0.00491542f, -0.00594563f, -0.04407401f, 0.00809607f, 
    0.01387232f, 0.03031339f, 0.02800282f, 0.00653283f, 0.00189113f, 0.02585113f, 0.00210145f, -0.01804524f, 
    -0.02411253f, 0.01427034f, 0.00419169f, -0.03983165f, 0.03222346f, 0.00506261f, 0.02724727f, 0.01270806f, 
    0.02942484f, -0.03194935f, 0.01921581f, -0.04397840f, -0.03711270f, -0.01823073f, -0.04098421f, 0.00351484f, 
    -0.03052385f, -0.04444533f, -0.01221380f, -0.02047268f, -0.02347526f, -0.00849516f, -0.02135646f, 0.00179658f, 
    0.02417991f, 0.00629083f, -0.01117020f, 0.03021462f, -0.03561188f, 0.02299957f, 0.00944917f, -0.01552363f, 
    -0.03050999f, -0.03344102f, -0.00176551f, -0.03737306f, 0.00836222f, -0.00359711f, -0.04325898f, 0.00719226f, 
    -0.01418047f, -0.03209944f, -0.02536855f, -0.04214346f, -0.01855531f, 0.01855893f, 0.00490730f, 0.03332555f, 
    -0.03749320f, -0.00478373f, -0.02791882f, 0.03115184f, -0.01453625f, 0.01539849f, -0.03447709f, 0.01097441f, 
    -0.04201535f, 0.03291595f, 0.03501575f, -0.03450937f, 0.02058047f, -0.02521920f, -0.03366529f, -0.04231057f, 
    -0.03551466f, -0.00777209f, 0.00443211f, -0.00870496f, 0.00500611f, 0.01282179f, -0.02970282f, -0.00564114f, 
    0.01062672f, -0.00296941f, -0.03215616f, -0.00078676f, 0.00516793f, -0.00647936f, -0.02509070f, -0.02301709f, 
    0.01806572f, -0.04520416f, -0.03988075f, 0.02202229f, 0.01531833f, 0.02617551f, -0.00681239f, 0.01295177f, 
    0.01797145f, 0.00734488f, -0.00547784f, 0.00276492f, 0.00845006f, 0.01057879f, 0.00446088f, 0.00238485f, 
    -0.02074386f, 0.01462913f, -0.03862207f, 0.02042569f, 0.02218349f, -0.03370832f, -0.02066813f, -0.04344425f, 
    -0.01085148f, 0.02455138f, 0.02104559f, -0.03298477f, 0.00936761f, -0.02343861f, 0.02178554f, -0.02293431f, 
    0.00982216f, 0.00525537f, -0.00655262f, -0.02021088f, 0.00872225f, -0.00450587f, -0.04541090f, 0.01843245f, 
    0.00708673f, 0.01104787f, -0.04421868f, -0.02566655f, -0.03752439f, 0.02854846f, -0.00739481f, -0.02688551f, 
    0.02992809f, -0.00696701f, 0.01517732f, 0.02243704f, -0.01363691f, 0.00799943f, 0.02946550f, 0.01369600f, 
    -0.03656606f, 0.01845687f, -0.03158670f, -0.00501343f, 0.02868827f, 0.01061382f, -0.03306058f, 0.03042359f, 
    0.01676006f, 0.01513887f, -0.02516351f, -0.02741004f, -0.04524723f, -0.01155351f, 0.01078748f, 0.02517864f, 
    -0.01018574f, -0.02449320f, 0.02735576f, 0.00503166f, -0.02780826f, -0.03161228f, 0.03325538f, 0.02886102f, 
    -0.03622546f, 0.01530994f, -0.04131545f, 0.01257985f, -0.03886163f, -0.04106913f, 0.01276719f, -0.01575440f, 
    -0.00744158f, -0.02025223f, 0.02550398f, -0.01158936f, 0.00634795f, 0.01997119f, -0.04512117f, 0.01547331f, 
    -0.03452114f, -0.01608131f, 0.02501491f, 0.01364542f, -0.04342261f, -0.04190275f, -0.01219162f, -0.00736015f, 
    -0.04283149f, 0.02429684f, -0.00449674f, -0.04262602f, -0.03650815f, -0.03092066f, -0.01358997f, 0.00022667f, 
    -0.01082206f, -0.03803091f, 0.03216615f, -0.04090139f, 0.00562880f, -0.03087798f, 0.02485646f, -0.04122816f, 
    -0.03189909f, 0.01960257f, 0.02574291f, 0.00083952f, 0.01334594f, -0.01976138f, -0.03203964f, 0.02539619f, 
    0.02595921f, -0.00528194f, -0.02724618f, -0.03510240f, -0.01942651f, 0.02018745f, 0.02739272f, 0.01519224f, 
    0.02947431f, 0.00813173f, 0.00686935f, -0.01104807f, -0.02586092f, -0.00213595f, -0.02212903f, -0.03233761f, 
    -0.04908206f, -0.03770288f, 0.08489297f, 0.06224973f, 0.19560488f, 0.01292983f, 0.02255479f, 0.06208195f, 
    -0.13597307f, 0.09627211f, -0.03470653f, -0.00115787f, 0.06848319f, -0.07087903f, 0.06434468f, 0.05987187f, 
    0.04343756f, 0.03867530f, 0.10607547f, 0.00413644f, -0.21895792f, 0.13561946f, 0.14319371f, 0.06101098f, 
    0.18236196f, -0.04138302f, -0.00556742f, 0.02069337f, -0.13878050f, 0.09716456f, -0.03634872f, 0.05857632f, 
    0.03369125f, 0.05584077f, -0.20731325f, -0.10948725f, -0.15042336f, -0.00158263f, -0.08463889f, 0.13320725f, 
    -0.03112769f, 0.07481153f, -0.16708097f, 0.16262656f, -0.23333733f, 0.03714009f, -0.03413557f, 0.05304193f, 
    0.12416095f, 0.01887227f, 0.08049158f, -0.04984627f, -0.11094663f, 0.04123693f, 0.02759817f, 0.06322242f, 
    -0.01366143f, 0.09896865f, 0.03720185f, -0.09979821f, 0.33078235f, 0.09324341f, 0.04301496f, -0.08977054f, 
    0.17177059f, -0.19204108f, -0.12300045f, -0.02968651f, 0.13791697f, 0.05746012f, 0.05473160f, -0.02873988f, 
    -0.00830847f, 0.15023765f, -0.04812641f, 0.12788643f, 0.05434145f, -0.00949236f, -0.10211481f, -0.03865499f, 
    -0.08934196f, 0.03663067f, 0.05862840f, -0.04963941f, 0.24708827f, -0.23311152f, -0.18498687f, 0.05501064f, 
    0.01478063f, 0.02189809f, -0.06466804f, 0.08556460f, 0.00967444f, 0.07280412f, 0.06811925f, -0.01014680f, 
    0.01035000f, 0.05795069f, -0.12549067f, 0.02152297f, 0.23584552f, -0.16593674f, 0.03377094f, -0.01790892f, 
    0.28985471f, -0.12853920f, 0.02737007f, -0.04061007f, 0.09267148f, 0.03687453f, -0.08305162f, 0.01384090f, 
    -0.03560702f, 0.01509442f, 0.13150744f, -0.05968492f, 0.03758639f, 0.01553268f, 0.02061823f, -0.01259992f, 
    0.00766790f, -0.14704725f, -0.22687002f, 0.18325388f, -0.05692388f, -0.04287966f, 0.05474719f, 0.11955917f, 
    -0.01300191f, 0.04045922f, 0.01227052f, -0.01821841f, 0.05813763f, 0.10810363f, 0.06265619f, 0.07568627f, 
    -0.01004438f, -0.00205756f, -0.04016725f, 0.07768650f, -0.40738592f, 0.25208363f, 0.01046859f, 0.01764103f, 
    0.29397932f, -0.00177326f, -0.05188005f, 0.00033848f, 0.02708298f, 0.03874090f, 0.10293514f, 0.03741081f, 
    0.10279767f, 0.00035148f, 0.03880505f, 0.00627360f, 0.05844475f, 0.04064269f, -0.07550506f, -0.01953827f, 
    0.18093412f, 0.03725883f, -0.11919243f, -0.19980495f, 0.03842056f, -0.05437431f, -0.00059108f, -0.11545338f, 
    0.01907866f, -0.11586271f, 0.15134598f, 0.16257395f, -0.06284938f, -0.04101130f, 0.14116907f, -0.04051945f, 
    0.00760007f, 0.05196633f, -0.04958489f, -0.02759134f, 0.00811138f, -0.12529178f, 0.06745876f, -0.08558296f, 
    0.37988678f, -0.24307892f, -0.15614222f, 0.04463276f, 0.07392225f, -0.02056185f, -0.01103725f, -0.05092411f, 
    -0.10306022f, 0.00799838f, -0.13262075f, 0.11814906f, 0.01896021f, -0.02667500f, -0.01024866f, 0.01918769f, 
    -0.08646987f, 0.07237726f, 0.17654763f, 0.18303025f, -0.05117323f, 0.07158132f, 0.09978756f, 0.01671716f, 
    -0.00412394f, -0.00237998f, -0.07133768f, -0.00785423f, 0.09739060f, -0.02312815f, -0.02405043f, 0.05455077f, 
    0.02614286f, -0.03317298f, 0.14546362f, 0.04345472f, -0.05981212f, -0.01374426f, 0.09090155f, -0.05754908f, 
    0.34846169f, -0.09904744f, -0.17609738f, -0.18715449f, 0.09780107f, -0.18392509f, -0.08255105f, -0.03418014f, 
    0.02696132f, 0.08144478f, 0.04317994f, 0.03066405f, 0.04088722f, 0.04438645f, -0.04450747f, -0.04923272f, 
    0.20976654f, 0.15002935f, 0.07289349f, 0.01862421f, 0.09520769f, -0.04965680f, -0.02604362f, -0.05298888f, 
    0.07727061f, 0.09550453f, 0.03169423f, 0.06308195f, 0.02841772f, 0.10204479f, -0.04034870f, 0.03300284f, 
    0.05648507f, -0.04550229f, -0.01100934f, -0.03380377f, 0.38418883f, -0.00591948f, -0.30003959f, -0.18353492f, 
    -0.56711978f, 0.00370441f, 0.00758855f, -0.01399093f, 0.08506147f, 0.01957539f, 0.01172101f, 0.13359168f, 
    -0.01851689f, 0.05924590f, -0.01363839f, 0.12599400f, 0.12301926f, 0.07405837f, -0.06313490f, 0.04374604f, 
    0.19062498f, -0.34345475f, -0.00481870f, -0.17697674f, 0.00944052f, -0.10331251f, 0.01828691f, 0.13238436f, 
    -0.14506234f, -0.12815478f, -0.02243206f, -0.00610020f, -0.00030196f, -0.00336957f, 0.01205524f, 0.02303150f, 
    0.02967462f, -0.04391043f, -0.12968346f, -0.05936086f, -0.03994513f, 0.03357065f, 0.04117398f, -0.00270312f, 
    -0.01650050f, -0.01738214f, 0.13331559f, -0.06570555f, -0.06664054f, -0.01462549f, 0.02518203f, 0.05195493f, 
    0.00081218f, -0.03785206f, 0.09528543f, 0.09675813f, 0.01680103f, 0.03451686f, 0.03507755f, 0.10283400f, 
    -0.04588912f, -0.26216185f, -0.07252124f, -0.02371623f, 0.19224520f, -0.10340764f, -0.00863115f, -0.01078777f, 
    0.03433146f, -0.07686448f, 0.00936078f, -0.01069504f, -0.01154996f, -0.04357905f, 0.09851969f, 0.06454969f, 
    -0.00425234f, 0.05407460f, -0.10205276f, 0.01470446f, 0.09949794f, -0.48868272f, 0.13785252f, 0.12068102f, 
    0.04918814f, 0.01422797f, 0.07432415f, 0.10285186f, 0.05111549f, 0.10979688f, -0.03280668f, 0.02168624f, 
    0.02544396f, 0.02578752f, 0.02065237f, 0.01821284f, -0.11223582f, 0.03194076f, 0.02474488f, 0.01950106f, 
    0.29930750f, 0.02372022f, -0.15225276f, 0.07796688f, 0.16120188f, 0.06898550f, -0.12342824f, 0.02930504f, 
    -0.15854040f, -0.04344687f, -0.00544749f, -0.06045219f, -0.00120860f, -0.01870146f, 0.11098982f, 0.02828473f, 
    0.05104563f, -0.06808708f, -0.12221766f, -0.08518094f, 0.13042273f, -0.61008644f, 0.28832364f, -0.11121743f, 
    0.07018644f, 0.02275310f, 0.08440141f, 0.04759941f, -0.05664086f, 0.04528243f, -0.05840825f, -0.03951710f, 
    -0.03926777f, -0.03694477f, 0.01757323f, -0.08704372f, -0.03672739f, -0.10050911f, 0.09688869f, -0.06062271f, 
    -0.24896565f, 0.17189108f, -0.03822289f, 0.27078128f, -0.33250576f, -0.01637763f, -0.04897293f, 0.00955811f, 
    0.15535791f, 0.07115636f, 0.01883770f, 0.01057442f, -0.02837524f, 0.03408098f, 0.07986068f, 0.05505838f, 
    -0.10357047f, -0.01848526f, 0.19247691f, 0.06258751f, -0.29920003f, 0.02583415f, 0.10535111f, 0.03331451f, 
    0.15697759f, 0.03518733f, 0.08530728f, 0.00439816f, -0.05754581f, 0.13316776f, 0.00333132f, 0.10834310f, 
    0.07456992f, -0.08403815f, -0.14658186f, 0.01375553f, -0.04578842f, 0.19974700f, -0.04161238f, 0.03765298f, 
    0.24024309f, 0.07984478f, -0.23004404f, 0.09593945f, -0.09558710f, 0.01946705f, -0.00787687f, 0.20484646f, 
    0.11104634f, 0.19788703f, -0.00745879f, -0.15304242f, 0.06707825f, -0.01261863f, 0.14278692f, 0.12619555f, 
    0.06236041f, 0.02139092f, 0.04783679f, -0.06903552f, 0.10075048f, 0.38207680f, -0.24165411f, -0.14620201f, 
    -0.25681195f, 0.11900210f, -0.00915883f, 0.03483160f, 0.14447866f, 0.02977282f, 0.02101944f, -0.09909964f, 
    0.02762097f, 0.00691927f, 0.14456894f, 0.09122328f, 0.06880699f, 0.02983583f, 0.02133833f, 0.05688702f, 
    0.05119855f, -0.03537212f, 0.24563260f, 0.16576540f, -0.03436452f, 0.04569965f, 0.02970992f, 0.07659793f, 
    -0.02459693f, 0.15774116f, 0.06220132f, 0.02089582f, 0.03103577f, -0.05303331f, 0.19196057f, 0.12608254f, 
    -0.04420347f, -0.00683116f, 0.22087473f, 0.02943781f, -0.06770184f, 0.02879007f, -0.04920451f, -0.27247953f, 
    0.46888676f, -0.12899198f, 0.12359121f, 0.10482750f, 0.04091072f, 0.02260069f, -0.00342257f, -0.03005055f, 
    0.07435417f, -0.04235632f, -0.00838296f, 0.09462387f, -0.05885855f, 0.14684738f, 0.08524229f, -0.03216006f, 
    -0.01650345f, -0.11284991f, -0.16960493f, 0.08548019f, -0.07519628f, 0.03943340f, 0.04030574f, 0.24624293f, 
    0.19303301f, 0.08790792f, -0.06128569f, -0.02687331f, -0.01350900f, -0.03767918f, -0.00906257f, 0.06268478f, 
    -0.00350801f, -0.10543708f, 0.10433456f, -0.04614624f, -0.27252409f, -0.16439003f, 0.22871000f, 0.08128635f, 
    -0.09815256f, 0.01786821f, 0.03863596f, 0.16910885f, -0.08835881f, 0.02234453f, -0.00509236f, 0.00309528f, 
    -0.02768197f, 0.02778342f, 0.03191853f, -0.03086287f, -0.03234413f, -0.12599719f, 0.07798541f, 0.05332962f, 
    0.23359022f, 0.22629072f, 0.14238594f, 0.02694036f, 0.01373112f, -0.05128525f, -0.11950149f, 0.00584237f, 
    0.06085381f, 0.05316553f, 0.02312570f, -0.02872743f, -0.04392005f, 0.09862675f, -0.01502468f, 0.15497088f, 
    0.02052395f, -0.09989101f, 0.01122980f, 0.01609096f, 0.01464830f, -0.01674548f, 0.08745364f, 0.08177843f, 
    -0.40612009f, 0.05156412f, 0.02494772f, 0.06258225f, 0.00330561f, 0.17324241f, -0.10029706f, 0.05000083f, 
    0.11732111f, -0.02222125f, 0.06288631f, -0.09126204f, 0.07008059f, 0.07426297f, -0.12676360f, 0.05420498f, 
    -0.39465344f, 0.13566026f, -0.01818189f, 0.12573819f, -0.68939102f, -0.01160953f, 0.04880588f, -0.01141196f, 
    0.10245440f, -0.02843292f, 0.04623593f, 0.02875474f, -0.09092185f, 0.07673448f, 0.07451632f, 0.06643130f, 
    -0.03431532f, -0.04077355f, 0.13940720f, 0.04466230f, 0.21561795f, -0.13443582f, -0.24589059f, -0.22719292f, 
    -0.45546660f, 0.04225864f, 0.06051293f, 0.06171655f, -0.01150297f, 0.04779334f, 0.12193706f, 0.03118305f, 
    0.09243917f, 0.06515705f, -0.08971375f, 0.08190343f, 0.09169153f, -0.04355352f, -0.09256583f, 0.05170475f, 
    0.01360952f, -0.02889336f, 0.00502763f, 0.00580746f, 0.02624270f, -0.01408590f, -0.02042797f, 0.01337356f, 
    -0.02681653f, -0.04242157f, -0.02057252f, -0.03743359f, 0.01381697f, 0.02023423f, 0.02630804f, -0.01333828f, 
    -0.02607561f, -0.02244901f, 0.02369709f, -0.03151756f, -0.03963584f, 0.01571900f, -0.01447161f, 0.00772441f, 
    -0.01379144f, -0.01954115f, -0.04011122f, 0.02888397f, -0.02169622f, -0.02860103f, -0.02057218f, -0.00740739f, 
    -0.03190984f, -0.03316970f, 0.02298920f, -0.00567467f, -0.00781205f, -0.00147528f, -0.00636134f, -0.03660812f, 
    0.02933661f, -0.02378166f, -0.02937411f, 0.01840026f, 0.01479061f, -0.02286041f, 0.02063409f, -0.00141476f, 
    -0.02134191f, 0.00718163f, 0.02804820f, -0.02116714f, 0.03560734f, 0.02033046f, 0.03219356f, -0.03845612f, 
    -0.04376789f, 0.00609742f, 0.02152308f, 0.01879567f, 0.00053032f, 0.01016943f, 0.00805325f, -0.01459899f, 
    -0.01077691f, -0.03438585f, 0.00907981f, -0.01615245f, -0.03793812f, -0.02898601f, 0.02427128f, -0.00478951f, 
    -0.01692748f, -0.00133108f, 0.02765265f, -0.00492765f, -0.03580776f, -0.02651235f, 0.02899105f, 0.00697725f, 
    0.04524594f, -0.01927206f, 0.00330974f, -0.03726955f, 0.02434539f, 0.03136967f, -0.02478878f, -0.03107552f, 
    0.03882556f, -0.03651969f, 0.02155033f, 0.01481577f, -0.03497134f, -0.03532735f, -0.02333264f, 0.02988990f, 
    0.00524860f, -0.03841534f, -0.00542628f, 0.00191645f, -0.00199591f, -0.01471184f, -0.04728919f, 0.02335527f, 
    -0.00059989f, -0.02362572f, 0.02129827f, -0.00405559f, -0.00901556f, 0.00282955f, -0.03343271f, -0.00781439f, 
    0.00417657f, 0.01961086f, -0.03018927f, 0.01165401f, -0.01766583f, 0.00534694f, 0.01472190f, -0.01213970f, 
    -0.02450899f, -0.04080009f, -0.04651251f, -0.00524292f, 0.02284869f, 0.00032138f, 0.02166593f, -0.04338803f, 
    -0.02916503f, -0.04749254f, -0.00579498f, -0.02896583f, 0.03549857f, 0.02736537f, 0.01097948f, -0.03149281f, 
    0.00305104f, -0.04160132f, 0.00539013f, 0.00842239f, 0.01561143f, 0.00045594f, 0.02764428f, 0.01833179f, 
    -0.01175422f, -0.03884237f, -0.00764158f, -0.02737568f, -0.01624707f, 0.03319479f, 0.01840739f, -0.04470845f, 
    0.00397841f, -0.02152085f, 0.00911301f, -0.03349613f, -0.02968298f, 0.03742220f, -0.04558492f, 0.01099081f, 
    0.02167082f, 0.01230269f, 0.01392823f, 0.03100584f, 0.00398576f, 0.03160869f, -0.00158866f, 0.00276190f, 
    0.02529025f, 0.00226864f, -0.02250216f, -0.04048502f, 0.01573425f, -0.03450051f, 0.02259372f, -0.04512174f, 
    -0.00575104f, 0.02644468f, 0.01441214f, -0.02561538f, -0.01638002f, 0.00350042f, -0.03719565f, 0.00340736f, 
    -0.04386313f, 0.02171245f, 0.02719457f, 0.02462936f, -0.03224793f, 0.03224123f, 0.00796713f, 0.00571725f, 
    -0.03427118f, -0.04385507f, -0.01281822f, -0.04041054f, -0.01159069f, 0.02653133f, -0.02234299f, -0.00837619f, 
    0.01473796f, 0.02454160f, -0.00955169f, -0.02639678f, 0.01753612f, 0.01774843f, -0.02246230f, 0.02985371f, 
    0.02345134f, -0.00011653f, 0.01604984f, -0.03654852f, -0.00649472f, -0.02287883f, -0.00394975f, -0.01509287f, 
    0.00851291f, -0.03606340f, 0.00462620f, -0.02589620f, 0.03880167f, -0.01477164f, -0.03830483f, -0.04696867f, 
    -0.01096446f, -0.04814875f, -0.03382958f, -0.03080117f, 0.02772639f, 0.02834955f, -0.02547400f, -0.00780510f, 
    0.00915627f, -0.02601888f, 0.00546268f, 0.02571237f, -0.02284705f, -0.00091953f, -0.00755055f, 0.01919047f, 
    0.02740362f, -0.03352234f, 0.02647865f, 0.00365273f, -0.02116424f, 0.01950454f, -0.01812752f, 0.01705476f, 
    0.00580504f, -0.03933532f, -0.03121650f, -0.02493445f, -0.03199653f, 0.02842328f, -0.01837662f, 0.01558418f, 
    0.02751239f, 0.02493176f, -0.00012897f, 0.00285325f, 0.02293913f, -0.04011036f, 0.00402352f, 0.03939661f, 
    -0.02174499f, -0.02621506f, -0.00010929f, -0.01727216f, -0.00824125f, -0.02133047f, -0.02608388f, -0.01580198f, 
    0.02124791f, -0.03893405f, 0.02491687f, 0.01170923f, -0.01538390f, 0.04301821f, -0.01696376f, -0.01577933f, 
    -0.03580674f, 0.02078878f, 0.00263903f, -0.02211057f, 0.01896058f, -0.01705498f, 0.03330954f, -0.03520564f, 
    -0.03896689f, -0.03862326f, -0.02706512f, -0.04225059f, 0.02676341f, -0.00493226f, -0.00322933f, -0.02533026f, 
    -0.01986872f, -0.03361417f, 0.02706863f, -0.01804486f, -0.02372595f, -0.00393734f, -0.03749589f, 0.01893011f, 
    -0.02216811f, -0.03233947f, -0.02005360f, 0.00742610f, -0.00050395f, -0.01814333f, 0.00979347f, -0.04342231f, 
    -0.03572277f, -0.01034711f, -0.03862412f, 0.02177561f, 0.01769709f, 0.00955392f, -0.02085835f, -0.04696986f, 
    -0.03089812f, -0.04126181f, 0.00633833f, -0.02006305f, 0.02498323f, -0.00599371f, -0.03849339f, 0.02085333f, 
    -0.03218374f, -0.00638440f, 0.01405756f, 0.03393876f, 0.00643620f, -0.02984572f, 0.01532692f, 0.02636692f, 
    0.02537932f, -0.01049996f, 0.01275317f, -0.03841510f, -0.00355255f, -0.02330334f, -0.02205873f, 0.03994958f, 
    0.02171630f, -0.03055822f, -0.00041695f, -0.01078263f, -0.03488800f, -0.04559992f, -0.01839025f, -0.02248361f, 
    0.01887416f, -0.02801557f, -0.01738563f, -0.01318530f, 0.01928147f, 0.03620186f, -0.01781232f, -0.00488648f, 
    -0.00702370f, -0.01746936f, 0.01956327f, 0.00121939f, 0.01780179f, 0.01407607f, -0.01435784f, 0.02047717f, 
    0.02710888f, -0.04131830f, 0.02265498f, 0.00291714f, -0.02318654f, 0.00375815f, 0.01941713f, 0.00806840f, 
    0.00191584f, 0.00928966f, -0.00416471f, -0.04576246f, -0.01438201f, -0.00923343f, -0.01575530f, -0.02258232f, 
    0.02662793f, 0.01531549f, 0.00894246f, 0.00297489f, 0.02638270f, -0.01051921f, 0.00668707f, -0.02502459f, 
    0.02222197f, -0.04005056f, 0.02517334f, 0.01151703f, -0.01205514f, 0.00399361f, 0.02433636f, 0.03298457f, 
    -0.01065510f, -0.03058477f, 0.02795332f, -0.04234562f, -0.03556475f, -0.03942285f, 0.00694357f, -0.01222642f, 
    -0.00128881f, -0.02809818f, 0.00606418f, -0.03658814f, 0.03792113f, 0.02706076f, 0.01431852f, 0.01414571f, 
    -0.03943325f, -0.03788308f, -0.00226166f, 0.01734993f, -0.03618407f, 0.01611256f, -0.01400176f, -0.03247062f, 
    -0.01942368f, -0.03403856f, -0.02233432f, 0.01578880f, -0.01489654f, -0.01800310f, 0.01625777f, -0.00103324f, 
    -0.04432137f, -0.02035037f, -0.01640849f, -0.02864558f, 0.01527940f, 0.00215305f, -0.03604579f, 0.00892610f, 
    0.02767873f, 0.01047731f, 0.02920988f, 0.00612284f, -0.00890080f, -0.04515434f, -0.03469016f, 0.00098259f, 
    0.02866071f, -0.02980926f, 0.01160230f, 0.00389019f, -0.01379391f, -0.03409449f, 0.02277169f, 0.00067758f, 
    -0.01420741f, 0.02601558f, -0.02643596f, -0.02181812f, -0.02256205f, 0.00916290f, 0.02128818f, -0.03408952f, 
    0.00554207f, -0.02149314f, -0.03386398f, -0.04143928f, 0.02685304f, -0.03231612f, 0.01395883f, -0.00672029f, 
    0.01133574f, 0.00682267f, -0.01773649f, -0.04432001f, -0.00577905f, 0.04231682f, -0.04294502f, -0.02566899f, 
    -0.04620206f, 0.02504720f, -0.03450586f, 0.02050478f, 0.02770261f, -0.02990640f, -0.00917829f, -0.03860822f, 
    -0.02787080f, -0.02776922f, -0.02155221f, -0.00398733f, 0.01785189f, 0.00699521f, 0.00433087f, 0.02874366f, 
    0.00150479f, -0.00024805f, 0.02375911f, 0.03551891f, -0.03735396f, -0.01342434f, -0.01693936f, -0.01518891f, 
    -0.00554349f, 0.02935069f, -0.01104222f, -0.02686053f, -0.03217218f, -0.00054496f, 0.03042523f, -0.03639301f, 
    -0.04731772f, -0.01152873f, -0.00340738f, -0.03911616f, 0.02252467f, -0.02901957f, 0.02066514f, 0.02598460f, 
    -0.03391529f, -0.01835637f, 0.00742788f, 0.01423767f, -0.03221332f, -0.02959614f, 0.01983700f, 0.01543603f, 
    -0.02509866f, -0.01209414f, 0.00762298f, 0.03310217f, 0.00442699f, 0.00106355f, -0.01622727f, 0.02190802f, 
    0.02256973f, -0.04095355f, 0.01737902f, 0.01036098f, -0.01058090f, -0.01224562f, 0.00226213f, -0.04214198f, 
    -0.03812596f, 0.01231349f, 0.04139697f, -0.03319789f, -0.00604895f, 0.02436544f, 0.00798920f, -0.00116312f, 
    -0.04029534f, -0.00684811f, 0.00795329f, 0.00002903f, -0.02840890f, 0.00488362f, -0.02583999f, -0.04243902f, 
    -0.01525977f, 0.00077557f, 0.01794643f, -0.03302848f, -0.02571720f, 0.01250622f, -0.01306266f, 0.00111237f, 
    -0.04433789f, -0.00271306f, 0.00453480f, -0.03249129f, -0.02067839f, 0.03041483f, -0.00790264f, 0.00807778f, 
    -0.00647247f, 0.02794447f, -0.01947781f, 0.03230109f, -0.02729927f, -0.00505591f, -0.02085679f, -0.04290283f, 
    -0.00006284f, -0.00631397f, -0.02938741f, -0.00261452f, -0.01741063f, 0.00341712f, 0.02114172f, -0.03596135f, 
    0.02274678f, -0.01887162f, -0.01340652f, 0.02994940f, -0.00759556f, 0.01035630f, -0.00963567f, -0.04201447f, 
    0.00597115f, -0.03954166f, 0.04436492f, 0.03847368f, -0.01135769f, -0.01298484f, -0.00849444f, 0.02427142f, 
    -0.00286933f, -0.03570810f, -0.03968761f, 0.01006478f, 0.03627320f, -0.02430573f, -0.03582373f, -0.01529549f, 
    -0.03750254f, -0.00222277f, 0.00909586f, -0.03302069f, -0.00020985f, -0.00730104f, -0.02160730f, 0.01641006f, 
    -0.04310405f, 0.02857948f, -0.03239249f, 0.03011058f, 0.01158299f, 0.02437438f, -0.02590101f, -0.01035569f, 
    -0.04412015f, 0.01706599f, -0.03713890f, -0.00503354f, -0.01729420f, -0.00438575f, -0.01410632f, 0.03249551f, 
    -0.01810426f, 0.01824423f, -0.00544783f, 0.02523524f, -0.02578470f, 0.02771404f, 0.03322104f, 0.00980655f, 
    0.03783150f, -0.03658917f, -0.03572716f, -0.01394092f, 0.00582254f, 0.03727961f, 0.00960419f, -0.03311661f, 
    0.01135519f, -0.02625183f, -0.00843620f, -0.02159366f, -0.01364732f, 0.00790612f, -0.03844895f, -0.03026937f, 
    0.02565829f, -0.00634901f, -0.02742377f, 0.01099091f, -0.02340073f, -0.03909233f, -0.02474415f, -0.03901575f, 
    0.01416330f, -0.00625181f, -0.02606238f, -0.03398450f, 0.03914882f, -0.01772542f, 0.03341027f, -0.03302745f, 
    -0.01872070f, -0.02531390f, -0.03738322f, -0.02752258f, -0.01839139f, -0.01552539f, 0.03823399f, 0.00009665f, 
    0.00955581f, 0.02887096f, 0.03707203f, 0.00884753f, -0.00262461f, -0.01209214f, 0.00910827f, 0.00790862f, 
    -0.00534551f, -0.01437547f, 0.02538762f, -0.01023636f, -0.01257245f, -0.01378470f, 0.01088996f, -0.00680688f, 
    0.01728763f, -0.02885679f, -0.02475670f, 0.01933745f, 0.01121680f, -0.02939986f, -0.01985162f, -0.01833020f, 
    0.00564551f, 0.02056473f, -0.01591690f, -0.03313484f, -0.02749925f, 0.02121599f, 0.02697726f, -0.02857492f, 
    -0.00229464f, -0.02473371f, 0.02214069f, -0.03535920f, 0.01922498f, 0.00767721f, 0.03133490f, 0.02115864f, 
    -0.03433339f, -0.03506413f, 0.00885462f, 0.02843181f, -0.00221956f, 0.00387000f, 0.00605763f, -0.01596499f, 
    -0.01156381f, -0.02520984f, 0.02652560f, -0.01221543f, -0.02732764f, -0.01688287f, 0.01074505f, 0.00563046f, 
    -0.01340089f, -0.01456518f, -0.01161651f, 0.00434763f, 0.02372377f, -0.00288979f, 0.01656145f, 0.01895909f, 
    -0.00677502f, -0.02238694f, 0.01530354f, -0.00066845f, 0.00985095f, 0.01159107f, -0.01904658f, 0.00796236f, 
    0.02459846f, -0.01042155f, 0.00012439f, 0.03863985f, -0.01143150f, -0.02684062f, -0.00697652f, 0.01116845f, 
    -0.02674317f, 0.00666752f, 0.00147350f, -0.02645110f, -0.01463262f, -0.00306976f, -0.02626182f, -0.03292274f, 
    -0.02420470f, -0.01134886f, 0.03769497f, -0.03646892f, 0.02403618f, -0.00721109f, -0.03692770f, 0.01930297f, 
    0.00628108f, 0.02804385f, -0.02222301f, -0.00459677f, 0.03520282f, -0.03029769f, 0.00779185f, -0.02848128f, 
    0.00658586f, 0.02683722f, 0.00373917f, 0.02045794f, -0.00221221f, -0.03743067f, -0.01762115f, -0.02509027f, 
    -0.03017040f, -0.03474002f, 0.01435890f, 0.01494639f, 0.03926148f, 0.00046600f, -0.03107800f, 0.01810021f, 
    -0.01447103f, -0.02614007f, -0.03261179f, -0.03463338f, 0.00668484f, 0.03884204f, -0.00630630f, -0.03483346f, 
    0.03394188f, 0.02829447f, -0.02819166f, -0.03508627f, 0.03670514f, 0.03907435f, -0.00795370f, 0.03331222f, 
    0.03078015f, 0.02876021f, -0.02697343f, -0.00486794f, -0.00904194f, -0.02746354f, 0.02973891f, 0.02546663f, 
    -0.01867348f, -0.03581652f, 0.03939359f, -0.02336436f, 0.00649612f, 0.03927165f, -0.02319754f, -0.00175841f, 
    0.02097452f, -0.02219509f, -0.01177585f, 0.02892027f, -0.00682923f, 0.03762719f, 0.01247805f, -0.00148956f, 
    0.03602105f, 0.00654542f, -0.03390085f, -0.03196646f, -0.01598683f, 0.03595200f, -0.01569802f, 0.00134725f, 
    0.02077151f, -0.03805279f, -0.02676599f, -0.03395506f, 0.02690084f, -0.03039044f, -0.00841153f, 0.01998785f, 
    -0.01637158f, 0.03880536f, -0.00119731f, 0.00679183f, 0.01311434f, -0.03671484f, 0.01800507f, 0.01934611f, 
    -0.02821003f, 0.01949539f, -0.03060774f, 0.01698103f, 0.02170140f, 0.03373627f, 0.02828049f, 0.00677280f, 
    0.00258962f, 0.03840582f, -0.02722264f, 0.01264531f, 0.03413905f, 0.03548043f, -0.03863675f, -0.02086638f, 
    -0.02305292f, 0.02588817f, -0.02853282f, -0.03744736f, 0.03092527f, -0.02699621f, -0.02771425f, 0.01177161f, 
    0.00203113f, 0.03460425f, -0.03852220f, -0.00233261f, 0.00559014f, 0.00606200f, 0.00939982f, -0.00246740f, 
    -0.01085398f, 0.02198286f, -0.01534062f, -0.02320078f, 0.00959059f, 0.03363752f, 0.01123029f, 0.01644015f, 
    -0.00394350f, 0.01074264f, -0.01463192f, 0.03475652f, 0.00361336f, 0.03840448f, 0.00175264f, -0.03546158f, 
    -0.01100692f, -0.02289350f, -0.01747766f, -0.00185678f, -0.01856202f, -0.00258271f, -0.02265987f, -0.02071488f, 
    -0.00592248f, -0.03072508f, 0.01557407f, -0.03610557f, -0.03401947f, -0.01504301f, -0.01678010f, 0.01868822f, 
    -0.03756296f, 0.01326290f, -0.01051663f, 0.00441863f, -0.02656613f, 0.01015879f, -0.02913817f, -0.00175155f, 
    -0.01567842f, -0.03580828f, 0.00687555f, -0.00429028f, -0.03541480f, -0.01727009f, -0.03236568f, 0.00375906f, 
    -0.03932789f, -0.01502336f, -0.03251211f, -0.01238017f, -0.00521754f, 0.03597477f, -0.00577422f, -0.02927068f, 
    0.01042506f, -0.00027520f, -0.01926494f, -0.00878284f, 0.01146686f, -0.01134594f, -0.03237833f, -0.03606637f, 
    0.03373443f, 0.02990117f, 0.00393601f, -0.03061490f, 0.01914542f, 0.00707108f, -0.00681548f, 0.01971570f, 
    0.00744260f, -0.01610017f, 0.01451276f, -0.01158021f, 0.01870585f, 0.00619544f, -0.02266734f, 0.00198950f, 
    0.01504531f, 0.00600708f, -0.02309876f, -0.03694738f, -0.03596668f, 0.01327574f, 0.03763931f, -0.02945595f, 
    -0.02429979f, 0.01062189f, 0.03843577f, 0.02529527f, 0.01657022f, 0.03305314f, 0.02676862f, 0.01806332f, 
    0.03042924f, -0.00051188f, 0.00189001f, -0.00721371f, -0.01997043f, -0.00170482f, -0.01985694f, 0.01729966f, 
    -0.03559924f, 0.01266688f, -0.00978918f, -0.03075168f, 0.00196913f, -0.00647670f, -0.01392106f, -0.02509245f, 
    0.00176392f, 0.03271648f, -0.00824793f, 0.00861344f, -0.00710996f, 0.03652760f, 0.01007733f, -0.01851797f, 
    -0.01514839f, 0.01840885f, 0.03317664f, 0.02630322f, -0.00459548f, -0.00267130f, 0.02838582f, -0.02034105f, 
    0.03577989f, -0.01943226f, -0.01530156f, -0.00460184f, -0.03115739f, -0.03008675f, 0.03222405f, 0.02195573f, 
    0.03066573f, -0.01539044f, 0.00149215f, 0.01020520f, 0.02896687f, -0.00262566f, -0.00319684f, -0.02161924f, 
    0.01395530f, 0.03060457f, -0.01105317f, -0.03889937f, -0.01919219f, 0.02127514f, -0.01289291f, -0.01664986f, 
    -0.02440688f, -0.01713103f, 0.02686155f, 0.02092463f, 0.00551545f, -0.02863390f, 0.01886139f, 0.01306860f, 
    0.01595833f, 0.01737817f, 0.00932956f, -0.03794899f, -0.01598582f, -0.01010373f, -0.00933938f, -0.03013908f, 
    0.03370004f, -0.02640242f, 0.01224513f, -0.03778324f, -0.01756444f, 0.01159837f, -0.03260444f, 0.01789262f, 
    0.03542397f, -0.00271500f, -0.03132752f, -0.03192654f, 0.03292205f, -0.00832552f, -0.00977619f, 0.03815657f, 
    -0.02611862f, -0.02769770f, -0.03688295f, -0.02413303f, -0.02481895f, -0.02493888f, 0.03400181f, 0.01740428f, 
    0.02873535f, 0.03556748f, 0.02995443f, -0.02922523f, 0.01436757f, -0.00939253f, -0.01790162f, 0.00393015f, 
    -0.01476085f, 0.00362500f, -0.00318764f, -0.03855950f, 0.03545676f, 0.00199830f, -0.03502800f, -0.00754902f, 
    -0.01578755f, 0.03423107f, -0.00997605f, -0.00367612f, 0.03310206f, 0.01892795f, -0.02814355f, -0.02913128f, 
    -0.03879262f, 0.01337626f, -0.02420679f, 0.02974862f, -0.02983036f, 0.00293859f, -0.02362853f, -0.03129413f, 
    -0.01652830f, -0.02488795f, -0.01486897f, 0.00965622f, 0.02365719f, -0.00697653f, -0.03813836f, -0.03910674f, 
    -0.01427402f, 0.02479606f, -0.03818398f, 0.00886309f, 0.01457578f, -0.00485860f, 0.03865971f, -0.00514330f, 
    -0.02813629f, -0.02319741f, -0.00869104f, 0.02459972f, -0.02332160f, -0.02616143f, 0.01863478f, -0.01974986f, 
    0.02141979f, -0.00846467f, 0.03101875f, -0.01866771f, 0.00966933f, 0.03451186f, -0.01191690f, 0.00239450f, 
    -0.03536619f, 0.01713335f, -0.03442112f, -0.00884774f, 0.01845142f, -0.00429702f, -0.02165966f, 0.01291549f, 
    -0.00224310f, -0.00385352f, -0.01427075f, 0.02637313f, 0.02289832f, -0.01959475f, -0.00267909f, 0.03806415f, 
    0.01636972f, -0.01073572f, -0.02154344f, -0.02505655f, -0.00706893f, -0.02915315f, -0.00874028f, 0.01579900f, 
    -0.02253951f, -0.03349282f, 0.03053370f, 0.02873406f, -0.01201242f, -0.01611631f, -0.00860334f, -0.01301032f, 
    -0.00417555f, 0.03694228f, 0.00784798f, -0.02882854f, 0.02963535f, 0.02607681f, -0.01129426f, 0.02282443f, 
    0.02982021f, -0.02583234f, -0.01760277f, -0.01334057f, -0.00322194f, -0.00187691f, -0.01565012f, 0.01332909f, 
    -0.01167033f, 0.03774835f, -0.03744822f, -0.02541529f, 0.03613922f, 0.03549596f, -0.02636028f, 0.01641169f, 
    -0.01742735f, -0.01921631f, -0.01572907f, -0.01517300f, 0.03530210f, -0.03889879f, 0.01710516f, -0.03944375f, 
    -0.02819983f, 0.03123105f, -0.02252191f, -0.02501320f, 0.00268152f, 0.03260900f, 0.01422528f, -0.00355734f, 
    -0.00317960f, 0.00046494f, -0.01962867f, -0.00551105f, -0.00861233f, -0.02062483f, 0.02213031f, 0.00675976f, 
    0.03045953f, 0.00738130f, 0.00064394f, -0.03367786f, -0.03336544f, -0.03786643f, -0.00668931f, 0.03391174f, 
    0.03748043f, 0.00871305f, -0.02157751f, 0.00044288f, 0.02752661f, 0.00027504f, -0.03013275f, -0.01820010f, 
    0.03144986f, -0.00149801f, -0.02287246f, -0.03789152f, -0.02351271f, -0.01934378f, 0.03600275f, 0.03096283f, 
    0.00022836f, -0.00494513f, 0.02408785f, 0.02377066f, 0.01167842f, -0.02671723f, -0.03929351f, -0.03273727f, 
    -0.02228455f, 0.02065292f, 0.00714759f, 0.01081084f, -0.03890185f, 0.00946331f, 0.00539541f, -0.01286971f, 
    0.13573699f, 0.37862119f, -0.26895693f, -0.13516538f, -0.06833211f, -0.00353641f, 0.01058512f, -0.09197516f, 
    0.15038800f, -0.03141529f, 0.07099079f, 0.02540554f, 0.03876939f, 0.07236725f, 0.02552667f, -0.02346830f, 
    -0.00453026f, -0.11739612f, 0.02272216f, -0.02189780f, 0.37523186f, 0.11993948f, -0.18396978f, 0.02125220f, 
    0.05050734f, 0.10101073f, -0.01792291f, -0.01536706f, 0.17704876f, 0.10926490f, -0.01971049f, 0.00573124f, 
    0.05192054f, 0.03678092f, -0.08706069f, -0.05836088f, 0.14294007f, -0.01627754f, 0.00069676f, -0.01228570f, 
    0.09427981f, 0.01453421f, 0.09539207f, 0.09746367f, -0.03920894f, -0.15876436f, -0.00017278f, 0.02159208f, 
    -0.03433691f, 0.10200096f, -0.00034577f, 0.05780404f, 0.03105370f, -0.06580240f, 0.04428858f, 0.04888744f, 
    0.07546961f, -0.05839035f, 0.25011960f, 0.10166167f, -0.58956170f, -0.43483627f, -0.04413549f, -0.15310748f, 
    -0.16560617f, 0.08153781f, 0.11560816f, 0.01549191f, -0.01639535f, 0.00390156f, 0.02337052f, 0.13079451f, 
    0.00929837f, -0.15303624f, -0.01021117f, -0.02857685f, 0.03010686f, 0.06503704f, -0.05007659f, 0.00042902f, 
    -0.54664689f, -0.31306016f, -0.08695257f, -0.11299551f, -0.17331968f, 0.07803637f, 0.01956248f, -0.05044821f, 
    -0.04717004f, -0.08136881f, 0.02916825f, -0.04006459f, 0.01676023f, 0.02136425f, -0.01851989f, 0.01208393f, 
    -0.03366536f, 0.00859276f, 0.00789516f, 0.03206439f, -0.32078025f, -0.05164777f, 0.03045627f, -0.07462230f, 
    -0.14821230f, 0.03773147f, 0.06352163f, 0.04302146f, 0.05674385f, 0.07970129f, 0.03861606f, -0.08168690f, 
    0.00738291f, -0.00266621f, -0.00247813f, 0.08663579f, -0.05192335f, 0.10159650f, -0.00809366f, 0.00341818f, 
    0.25665748f, 0.09179533f, 0.15550935f, 0.05536783f, 0.03017400f, -0.12929332f, -0.00219915f, -0.04763724f, 
    -0.01921713f, 0.04961862f, -0.02480097f, 0.03088519f, 0.02352966f, 0.06371780f, 0.05235517f, -0.01995697f, 
    0.05164322f, 0.05234375f, 0.07990539f, 0.03742346f, -0.13405685f, -0.28172106f, -0.07213625f, -0.18913038f, 
    -0.06531805f, -0.00777877f, -0.02408598f, 0.03858716f, 0.05097558f, -0.00361929f, -0.03928328f, -0.02868832f, 
    -0.06208317f, -0.01410923f, 0.03250332f, -0.03438890f, -0.04791776f, -0.12708849f, 0.03550923f, 0.07609599f, 
    0.35119203f, 0.08887795f, -0.08884524f, 0.12253790f, 0.05792452f, -0.01655547f, 0.01027129f, 0.08015672f, 
    0.09270105f, 0.08852375f, -0.16458510f, -0.01727259f, -0.01425117f, 0.12984142f, 0.02581058f, -0.00299803f, 
    0.02134494f, 0.04987056f, 0.07585398f, 0.08392892f, -0.20279032f, -0.08155625f, -0.13773349f, 0.04235536f, 
    -0.14602950f, 0.16934191f, 0.19764771f, 0.04000934f, -0.06439306f, 0.09025183f, 0.04120370f, -0.00321039f, 
    -0.01454924f, 0.13662654f, -0.03986456f, -0.00406774f, 0.04031423f, 0.09266068f, -0.13533409f, 0.01457750f, 
    0.18300311f, -0.00517126f, 0.06972501f, 0.10976689f, -0.01093258f, 0.02414593f, 0.03248665f, 0.16128893f, 
    -0.07669979f, 0.00047403f, -0.03497412f, 0.05255752f, 0.04704555f, -0.07135096f, 0.03164053f, 0.06720956f, 
    0.01555189f, -0.01196574f, -0.00475301f, 0.00377987f, -0.03182677f, -0.33101052f, -0.11676335f, 0.08583441f, 
    -0.04163977f, 0.00488282f, 0.01133773f, 0.25432491f, 0.04278448f, 0.06376222f, -0.00850745f, 0.04222095f, 
    0.06863596f, -0.03803143f, 0.03772842f, 0.02241349f, -0.02231443f, -0.10470989f, -0.00643961f, 0.02864646f, 
    -0.44083962f, -0.26932272f, 0.11392881f, -0.05644857f, 0.03619109f, 0.06186154f, 0.05794070f, 0.08669879f, 
    -0.10063229f, -0.02902819f, 0.00650992f, 0.04670203f, 0.01537614f, -0.10903877f, 0.01164518f, -0.02744506f, 
    0.08652601f, 0.08230786f, -0.01324078f, -0.02585433f, 0.02451669f, 0.01092260f, 0.30701253f, 0.18916155f, 
    0.26855242f, -0.20311412f, -0.17641981f, -0.08252990f, 0.10535907f, 0.08149606f, -0.02776769f, 0.06079701f, 
    0.06420511f, 0.07785717f, -0.06861647f, -0.01314327f, -0.08625853f, 0.10608915f, 0.03882975f, -0.00822137f, 
    -0.10539206f, 0.21119605f, 0.01028001f, 0.31905398f, -0.06084789f, 0.08152813f, -0.01859096f, -0.00403900f, 
    -0.00574449f, 0.03425354f, -0.05916406f, -0.02553309f, -0.11041790f, 0.09004036f, 0.12228853f, 0.05196386f, 
    -0.03599107f, 0.12161131f, 0.05868825f, 0.07519445f, 0.31711477f, 0.04456163f, -0.13191949f, -0.02761635f, 
    0.05097447f, 0.03215277f, -0.13928133f, -0.06256509f, 0.20545687f, 0.13024105f, 0.03077454f, -0.00675018f, 
    0.01436208f, 0.03781478f, 0.09729435f, -0.07679597f, 0.03610194f, -0.09654223f, -0.00314912f, -0.02960666f, 
    -0.02112920f, -0.06096596f, 0.02584608f, -0.09441338f, -0.06960231f, -0.05909013f, 0.02639310f, 0.02596931f, 
    -0.02622237f, -0.04747006f, -0.07757031f, 0.01166960f, 0.07868177f, -0.00504224f, 0.00074067f, 0.06810392f, 
    0.08643446f, 0.08340878f, 0.07710128f, 0.04366734f, 0.02050627f, 0.24935423f, 0.03048646f, -0.02537749f, 
    -0.26141000f, -0.03128542f, 0.10444888f, -0.00216387f, -0.10206164f, -0.02164368f, 0.06862962f, -0.00602557f, 
    -0.07285017f, -0.11585797f, -0.04606945f, -0.01234408f, 0.05533157f, 0.09306321f, 0.11018747f, 0.11976466f, 
    0.32068056f, 0.19477624f, 0.03025151f, 0.00294235f, -0.00398039f, 0.04409602f, -0.05201367f, -0.04881356f, 
    0.18524805f, 0.00556900f, -0.01455760f, -0.02837021f, 0.03398703f, -0.03296537f, 0.03603646f, 0.09217650f, 
    -0.01874088f, 0.22270398f, 0.03050377f, 0.22769631f, -0.05683620f, 0.17436664f, 0.02716489f, 0.21159787f, 
    -0.17524491f, 0.01086504f, 0.07123153f, 0.11057492f, 0.05575152f, -0.01487952f, 0.02443500f, 0.03950626f, 
    -0.03445312f, -0.06656392f, 0.05483235f, 0.09450059f, 0.09285346f, 0.14193973f, 0.12099663f, 0.07619023f, 
    0.24563642f, -0.05042146f, 0.11809524f, 0.14579540f, 0.05354400f, 0.05277723f, 0.09660382f, 0.05767738f, 
    -0.09525109f, -0.08991898f, -0.03554426f, 0.16306423f, -0.02159505f, -0.03602555f, -0.05368515f, 0.04656505f, 
    0.11184585f, -0.03402403f, 0.06699318f, -0.05086795f, 0.18188033f, 0.31545517f, 0.22084497f, 0.06714406f, 
    -0.02231459f, 0.03217380f, -0.00892553f, -0.00589051f, 0.00725948f, 0.03265268f, 0.05588589f, 0.03449306f, 
    -0.00196364f, 0.00006724f, 0.06728666f, 0.07106733f, 0.04711547f, -0.09237859f, 0.13922957f, 0.04735586f, 
    0.12125880f, -0.05456962f, -0.02053215f, 0.02250215f, -0.03614965f, -0.04379724f, -0.08643641f, -0.13464491f, 
    -0.02195430f, -0.07712620f, -0.00472438f, 0.01954330f, 0.01484407f, -0.08140978f, 0.07087502f, -0.15183376f, 
    -0.06263003f, 0.15758121f, 0.01858090f, 0.10721032f, 0.21057129f, 0.03382265f, 0.15833454f, 0.13652582f, 
    0.04778709f, -0.18548708f, -0.15286201f, -0.04786414f, -0.01199648f, 0.04811409f, -0.04022311f, 0.08020946f, 
    -0.07325819f, 0.06614165f, -0.03824316f, -0.01896826f, 0.12285081f, 0.00897205f, 0.15603854f, -0.05895029f, 
    0.07378263f, -0.06887206f, -0.10770448f, 0.05019169f, 0.05052638f, 0.04861466f, 0.10756175f, 0.00371016f, 
    -0.05878528f, -0.15442301f, -0.13613100f, 0.05511742f, -0.03238877f, -0.05576490f, 0.09091097f, -0.04753610f, 
    0.15001944f, -0.11400061f, -0.05441498f, -0.02184035f, 0.35054457f, 0.29768199f, -0.08321117f, -0.08664782f, 
    0.03288913f, 0.10367774f, 0.05192281f, -0.01087465f, 0.12687431f, -0.00119849f, 0.04799289f, -0.04201692f, 
    -0.07431495f, 0.00984675f, 0.03425681f, -0.05776040f, 0.11216962f, 0.00238589f, 0.01271885f, 0.15699710f, 
    0.24036533f, 0.15232116f, 0.06678034f, 0.03269471f, -0.11660834f, -0.03791270f, -0.01256846f, -0.08497311f, 
    -0.08415706f, -0.04723896f, 0.04155896f, 0.00117178f, -0.03567049f, -0.13981242f, -0.02100879f, -0.09557423f, 
    0.05042737f, 0.12384328f, 0.07017872f, 0.08270928f, 0.30549341f, 0.26238194f, -0.01452124f, 0.02480105f, 
    -0.12028823f, 0.11905257f, 0.08229270f, -0.11980787f, 0.01059622f, -0.03559164f, -0.08272409f, -0.06803961f, 
    -0.05316924f, -0.18140659f, -0.12362239f, 0.04027377f, 0.13178878f, 0.20182867f, -0.05744196f, 0.05266915f, 
    -0.53430879f, -0.29795986f, -0.04748527f, -0.00871030f, -0.01965050f, 0.11562309f, 0.16075207f, 0.04871016f, 
    -0.01379004f, -0.06157603f, -0.00237964f, 0.13577995f, -0.03283330f, -0.19392096f, -0.07239156f, -0.05654935f, 
    0.08058406f, 0.10840614f, 0.05751226f, -0.03088920f, 0.10091209f, -0.07393340f, -0.04258820f, -0.18241286f, 
    0.11168719f, 0.04534057f, -0.02394528f, -0.02543272f, -0.00020390f, -0.18531923f, 0.02440359f, 0.01136115f, 
    -0.04326554f, 0.04972941f, 0.01050873f, -0.05081315f, -0.02287224f, 0.05323404f, 0.01228007f, 0.01589282f, 
    0.46787080f, -0.27362022f, 0.04151848f, -0.12094163f, 0.43405363f, -0.17894465f, -0.00322325f, -0.00447173f, 
    0.04555247f, -0.03875446f, 0.09940889f, -0.05116649f, 0.08836494f, 0.05025810f, 0.11716908f, -0.03202301f, 
    0.02252011f, -0.09177956f, -0.02097916f, 0.03176837f, 0.12193396f, 0.04052217f, 0.08739834f, 0.21569023f, 
    0.15976454f, -0.10877841f, -0.17744227f, -0.02756867f, 0.01155443f, 0.09358746f, -0.07809328f, -0.04493018f, 
    0.01119445f, 0.08259483f, 0.15059705f, 0.05194948f, -0.12370208f, 0.05766908f, -0.02452278f, 0.00476052f, 
    0.10052674f, 0.26414290f, -0.07781898f, 0.01297327f, -0.13393354f, 0.11627340f, -0.08954038f, 0.01642262f, 
    0.01921969f, 0.07963869f, 0.00342405f, -0.00560356f, 0.04072753f, -0.07935598f, -0.15929548f, 0.08207020f, 
    0.08782779f, -0.07791869f, -0.02250641f, 0.12298104f, 0.33765367f, 0.01694816f, -0.08251247f, -0.25361067f, 
    -0.01814131f, 0.06064053f, -0.01802369f, -0.15599106f, 0.05604674f, 0.03532004f, -0.08076402f, 0.04988460f, 
    0.01521314f, -0.02468549f, 0.07473317f, -0.11067088f, -0.02266357f, 0.10532860f, -0.01562130f, 0.05814874f, 
    0.01634598f, -0.14383438f, -0.05281630f, 0.18358009f, -0.10313518f, 0.18468967f, 0.05900383f, 0.00446365f, 
    0.10435130f, 0.08177151f, 0.06464230f, -0.05023036f, -0.03752228f, 0.02854504f, -0.02502509f, -0.03358608f, 
    -0.03385567f, 0.02771517f, -0.13754153f, 0.00530012f, -0.02749864f, -0.21284071f, 0.27746922f, 0.18900375f, 
    0.07610361f, -0.08743605f, -0.08476804f, 0.05685892f, 0.01302096f, 0.05843486f, 0.00238511f, -0.05637769f, 
    0.03504694f, -0.00776899f, -0.01354411f, 0.01196394f, 0.00632716f, -0.09594096f, 0.05020624f, 0.00598617f, 
    -0.22078007f, 0.28947225f, 0.23267636f, 0.15771727f, 0.20167834f, 0.02997876f, 0.03678807f, 0.03382067f, 
    0.05906466f, 0.06353052f, 0.01231679f, -0.01813095f, 0.03651115f, 0.00608014f, -0.01600256f, 0.12642318f, 
    0.03920020f, -0.00204915f, 0.04262420f, 0.01122561f, 0.15483129f, -0.07356990f, 0.06792577f, -0.14855871f, 
    0.08949388f, 0.02882207f, -0.13425280f, -0.06355459f, -0.00373382f, 0.00053481f, -0.01226233f, -0.01371070f, 
    0.00753744f, 0.09501418f, 0.04607118f, -0.00268541f, 0.14207888f, -0.07098968f, 0.02351436f, 0.06308613f, 
    -0.09472454f, -0.28727826f, -0.11716244f, 0.02456492f, 0.10269547f, 0.03256098f, 0.06088659f, -0.04039783f, 
    0.14205176f, 0.07320996f, 0.02956363f, -0.01180256f, -0.01668818f, 0.08240878f, -0.04144346f, 0.11224795f, 
    0.03612479f, 0.05522590f, -0.09932689f, -0.03789252f, 0.03347254f, 0.21576512f, 0.13784635f, 0.09929782f, 
    0.04120470f, -0.02861407f, 0.03477509f, 0.06929209f, 0.00424741f, -0.06311455f, 0.02063339f, 0.08489197f, 
    -0.00131317f, 0.13893676f, 0.03502960f, 0.08440825f, 0.00450909f, 0.11397410f, 0.08595213f, 0.02899256f, 
    -0.19722302f, 0.15934861f, -0.04806114f, -0.03945640f, 0.08837089f, 0.10854299f, -0.06102924f, 0.09357281f, 
    -0.02790907f, 0.01759801f, 0.14699283f, -0.02223143f, 0.09457345f, -0.08015056f, 0.10068651f, 0.07101702f, 
    -0.03953088f, -0.00049801f, 0.11467922f, 0.06928083f, -0.08460553f, 0.13266036f, 0.18768594f, 0.16933668f, 
    0.10606018f, -0.06371211f, -0.08046814f, 0.03833604f, -0.00973991f, 0.06693308f, -0.10085915f, 0.02465143f, 
    0.05253271f, -0.05212967f, 0.10026824f, 0.00770191f, -0.08713847f, -0.05600698f, 0.03894770f, 0.02568243f, 
    -0.00710700f, -0.15503715f, 0.10138053f, 0.31758311f, 0.03968067f, -0.03144124f, 0.02498682f, 0.04450854f, 
    -0.03722169f, -0.05529379f, 0.05929182f, 0.00009826f, 0.01248825f, 0.06239747f, -0.08152769f, -0.01424707f, 
    -0.01631562f, 0.00979145f, 0.03258586f, -0.06064894f, 0.61571711f, -0.38871253f, 0.14923896f, -0.04653125f, 
    0.04189213f, -0.07873382f, -0.05836386f, -0.00890206f, -0.09996663f, 0.06652368f, -0.01466252f, 0.00049664f, 
    -0.05198132f, 0.05142909f, -0.12434948f, 0.03021888f, -0.11480818f, 0.09003577f, 0.10336225f, -0.06498922f, 
    -0.15211503f, -0.09916949f, 0.22705443f, 0.14303006f, 0.00415001f, -0.10713021f, -0.02593298f, 0.07500416f, 
    0.00410617f, -0.01345370f, -0.08698594f, -0.04306031f, 0.02435311f, 0.02822472f, 0.00202998f, 0.03364149f, 
    -0.00850869f, -0.05649628f, -0.08383268f, 0.00358397f, -0.31761181f, -0.06849619f, -0.33971688f, 0.01673749f, 
    0.13888040f, 0.07362486f, 0.06833325f, -0.10573401f, 0.07003488f, 0.08242203f, 0.11934257f, -0.00800939f, 
    -0.03153804f, 0.06557938f, 0.09094942f, -0.03785607f, 0.09328875f, -0.01685825f, 0.11603717f, 0.04785791f, 
    -0.39778119f, -0.05267837f, -0.09227401f, -0.12150649f, -0.09269492f, -0.08366447f, 0.02475007f, 0.05170597f, 
    -0.08985931f, 0.12078140f, 0.08858679f, 0.01161221f, 0.00336186f, -0.15120415f, -0.03793592f, 0.01688392f, 
    0.05667068f, -0.01294761f, 0.18797453f, 0.01457770f, -0.20457953f, 0.22787780f, -0.11550362f, 0.06563188f, 
    -0.08258244f, 0.06914903f, -0.04048293f, 0.09740598f, -0.10494646f, -0.07206874f, 0.13957781f, 0.00670981f, 
    -0.05119012f, -0.06869726f, 0.03487496f, 0.09591535f, 0.12846221f, 0.05564938f, 0.13046017f, -0.05328071f, 
    0.49473286f, 0.02905519f, 0.14244255f, 0.00589416f, -0.02069257f, -0.15513904f, -0.00256276f, 0.02795927f, 
    -0.00821373f, -0.01613945f, 0.00318172f, -0.02193440f, -0.00910394f, 0.02902749f, -0.00625402f, 0.05824135f, 
    0.01939006f, -0.08316891f, 0.06865498f, 0.01545974f, 0.05770464f, -0.18026759f, -0.01288998f, 0.13719499f, 
    -0.17409016f, -0.00676369f, 0.00117426f, 0.04078708f, 0.11312550f, 0.01325773f, -0.04323710f, 0.02766292f, 
    0.08462282f, 0.01288682f, 0.01982774f, 0.06965657f, -0.05947743f, 0.00670533f, -0.10994382f, -0.04865387f, 
    -0.27562904f, 0.06434774f, 0.04929452f, -0.11584107f, 0.03418528f, -0.01493580f, 0.06294689f, 0.07010865f, 
    0.04690111f, 0.08859017f, -0.05572790f, 0.08790895f, 0.03670280f, -0.01176958f, 0.05149905f, 0.00167230f, 
    0.06183482f, -0.10646745f, -0.05808193f, 0.19056268f, 0.12019855f, -0.14924859f, -0.09185515f, -0.10313838f, 
    -0.14898896f, -0.05647391f, -0.03449190f, 0.02589761f, 0.03168077f, -0.07087918f, -0.03033675f, 0.01562916f, 
    0.06000070f, 0.02497852f, -0.06411147f, 0.01588642f, -0.16171925f, 0.01256326f, -0.01686328f, -0.03575327f, 
    -0.05127082f, -0.02551067f, 0.14654480f, 0.10738855f, -0.29763901f, 0.11754277f, 0.12423982f, 0.03045827f, 
    -0.05967873f, 0.12056214f, 0.02525458f, 0.03551555f, -0.06604826f, -0.10363546f, 0.01954503f, 0.00919653f, 
    0.06333712f, -0.00198208f, -0.07580687f, 0.01233441f, -0.30676839f, -0.02500018f, -0.03879328f, -0.09559386f, 
    0.06810229f, 0.01160830f, -0.00144021f, -0.01825801f, -0.01183534f, 0.04270376f, -0.00898401f, -0.00684952f, 
    -0.12363052f, 0.05489413f, 0.01255750f, -0.21613841f, 0.02957314f, 0.04927931f, 0.01792422f, 0.10841909f, 
    -0.12007475f, 0.13140923f, -0.00910669f, 0.10800619f, 0.18178187f, 0.15823747f, 0.13274750f, 0.04972264f, 
    0.12336653f, 0.09831642f, 0.02402712f, 0.03518260f, 0.04163126f, 0.10224105f, 0.10720287f, -0.05669164f, 
    0.01440598f, -0.06808577f, -0.09693929f, 0.13204136f, -0.29219034f, -0.11139057f, -0.21846272f, -0.01226206f, 
    0.21560086f, 0.09546953f, 0.07202820f, 0.05928382f, 0.03747004f, 0.13600956f, 0.09706654f, 0.01809002f, 
    -0.01094454f, 0.02406966f, 0.04150773f, 0.05663980f, -0.05791783f, 0.03053852f, 0.05055718f, 0.02489843f, 
    0.09408326f, 0.03358353f, 0.12460542f, 0.09920148f, 0.18222523f, 0.07184034f, 0.04508329f, 0.00755663f, 
    -0.10764874f, -0.05202144f, 0.02359796f, 0.04501048f, -0.08629377f, 0.08289164f, 0.01447756f, -0.02047792f, 
    -0.05599068f, 0.00240946f, 0.01559926f, 0.03509119f, -0.01578886f, 0.18941152f, 0.06607081f, -0.06458129f, 
    -0.00494732f, -0.05295105f, 0.03171359f, 0.10851623f, 0.02101973f, 0.01304923f, 0.07812516f, 0.00921120f, 
    -0.05380783f, -0.03401233f, -0.03484730f, -0.07012306f, -0.01980990f, 0.03403034f, 0.07508550f, 0.15633468f, 
    -0.01568779f, 0.07295006f, 0.05200450f, 0.17579652f, 0.05418658f, 0.09460761f, 0.14938888f, -0.02029211f, 
    0.13503276f, 0.10269905f, 0.07683608f, 0.03516217f, 0.10242901f, 0.12084897f, -0.03269147f, -0.07738575f, 
    0.00218191f, -0.03387280f, -0.14505903f, 0.09525452f, -0.11536222f, 0.11715029f, 0.19757482f, -0.01110538f, 
    -0.10185818f, -0.10134574f, 0.06216899f, -0.07463683f, -0.00990194f, -0.06896730f, -0.02886056f, 0.01015199f, 
    -0.01620357f, 0.02206140f, 0.07164413f, -0.09341656f, 0.01497233f, -0.02083783f, -0.02775077f, 0.10023727f, 
    -0.26165593f, -0.10232522f, 0.30367735f, 0.34042889f, 0.06512510f, -0.08643796f, 0.06323012f, 0.15865734f, 
    -0.01401928f, 0.02375585f, -0.09342941f, -0.09266260f, 0.08723316f, 0.02973901f, 0.07136668f, -0.01795016f, 
    0.00631641f, -0.07735063f, -0.04949141f, -0.08745669f, -0.22017612f, 0.11877391f, -0.07813783f, -0.08236656f, 
    -0.10343014f, 0.06667550f, -0.00931431f, -0.06529864f, -0.05857310f, -0.03825929f, -0.02268873f, -0.09767053f, 
    0.06182968f, -0.00865801f, -0.01223447f, 0.02112616f, 0.10152527f, -0.03157137f, 0.11288326f, 0.01557290f, 
    0.26233059f, -0.09933572f, -0.12476414f, -0.09366558f, -0.10524485f, 0.08708441f, 0.03514855f, -0.00939276f, 
    -0.06013760f, 0.08186604f, -0.04449815f, 0.07333264f, -0.03563783f, 0.04335882f, -0.04887298f, -0.08163627f, 
    0.06509364f, 0.04982651f, 0.16739821f, -0.02685979f, -0.26632041f, 0.00033917f, -0.19976820f, -0.04505188f, 
    0.07153704f, -0.00997649f, 0.03187808f, 0.01491504f, 0.05434510f, 0.11234146f, 0.08246007f, 0.10247223f, 
    -0.02152618f, -0.08850216f, 0.00465329f, 0.09411412f, 0.09188423f, 0.05068996f, 0.11867476f, 0.03446158f, 
    -0.03148691f, 0.18692206f, -0.04639362f, -0.14087273f, -0.15261485f, 0.07166591f, 0.07658629f, -0.04281444f, 
    -0.02209185f, -0.01657150f, 0.00799629f, 0.01668235f, 0.02764326f, 0.01898395f, -0.04379772f, 0.05319268f, 
    -0.08878513f, -0.08816899f, -0.06524370f, -0.03520748f, -0.05492417f, 0.21010330f, -0.09058660f, -0.17104957f, 
    -0.06175659f, 0.02748075f, -0.04339951f, -0.06050912f, 0.04987001f, 0.03630013f, -0.05590714f, 0.02336781f, 
    0.09234909f, 0.03992701f, -0.01283013f, 0.02428260f, 0.07190903f, -0.05871977f, 0.03757960f, -0.08526357f, 
    0.02433830f, -0.13015436f, 0.00734116f, 0.21853216f, 0.06447287f, -0.11687976f, 0.06717877f, -0.04981622f, 
    0.07736670f, 0.03695830f, 0.10359067f, 0.08972027f, -0.01263647f, -0.01995914f, 0.05427467f, 0.05628530f, 
    -0.10358534f, -0.08644780f, 0.13936718f, -0.01366687f, 0.15832794f, -0.14024188f, 0.14519095f, -0.08853743f, 
    0.09478740f, -0.08393449f, 0.00675464f, 0.03819879f, 0.05052615f, 0.00557787f, 0.00400499f, -0.04478657f, 
    -0.11582611f, -0.12007142f, -0.00104207f, 0.02979654f, 0.06983341f, 0.00226128f, -0.00691629f, 0.03374780f, 
    0.00417423f, -0.07579642f, 0.09024765f, -0.17418523f, 0.18871070f, 0.04849045f, 0.14844438f, 0.03328644f, 
    -0.03036389f, -0.01099327f, -0.00884944f, -0.02553347f, -0.03191505f, -0.07183088f, -0.04548261f, 0.08751381f, 
    0.05079120f, -0.05321981f, -0.00750509f, 0.07027517f, -0.10471942f, 0.05958531f, 0.21462516f, -0.21160775f, 
    0.05891935f, 0.01128892f, -0.08144710f, 0.02503835f, -0.04449670f, -0.05651765f, 0.01639872f, -0.03766752f, 
    0.00150314f, -0.01884934f, -0.04489464f, -0.03224890f, 0.03376243f, -0.01772686f, -0.05765323f, -0.00905641f, 
    -0.07519151f, -0.02651282f, -0.01495414f, 0.22205530f, -0.07251012f, -0.02752368f, 0.05723119f, -0.11598185f, 
    0.04688348f, 0.03115924f, -0.02653754f, 0.05005176f, -0.03022922f, -0.00184311f, 0.02823754f, -0.02507676f, 
    -0.14944413f, 0.02908572f, -0.00400191f, -0.17326501f, 0.17802455f, -0.20055793f, 0.20657142f, -0.07760163f, 
    0.13411935f, -0.02209619f, -0.01353842f, 0.05635505f, 0.00268927f, -0.07368296f, -0.04222780f, 0.00029518f, 
    0.02839141f, -0.08183235f, 0.04012234f, 0.02838301f, -0.05295679f, -0.11561242f, -0.04164853f, 0.03155602f, 
    0.03436149f, -0.29806033f, -0.10037902f, -0.08223582f, -0.06105714f, 0.22484314f, 0.02501517f, 0.12261190f, 
    -0.02422241f, -0.01497030f, 0.03881842f, -0.03829247f, 0.03781807f, 0.01036373f, -0.06685615f, -0.00405945f, 
    0.09949934f, -0.03282628f, 0.09424233f, 0.02611482f, 0.19687338f, 0.18002750f, 0.18447556f, -0.16444510f, 
    0.29004979f, 0.05346888f, -0.04639320f, 0.04789167f, 0.04417612f, 0.11997958f, -0.11037917f, 0.02803378f, 
    -0.01195316f, 0.05242350f, -0.01151371f, 0.02129128f, 0.06545971f, -0.02542132f, -0.02822806f, -0.02272365f, 
    0.18714978f, -0.42394394f, -0.00097270f, 0.02913325f, -0.17720287f, -0.24024697f, -0.04391081f, 0.07014949f, 
    -0.05661474f, 0.12441100f, 0.01021383f, 0.06419448f, 0.09743110f, -0.10841843f, 0.00137159f, -0.04739066f, 
    0.04810763f, -0.04794366f, -0.06234615f, -0.03028180f, 0.48875886f, -0.20913582f, 0.10522816f, -0.20319633f, 
    -0.14168251f, -0.05261108f, 0.01335661f, 0.05295500f, -0.00061148f, 0.08601597f, 0.01646416f, -0.03869124f, 
    -0.00148762f, -0.00859298f, 0.06704265f, 0.02994575f, -0.06328351f, -0.00215925f, 0.04742312f, 0.00351750f, 
    -0.03000039f, -0.23720343f, 0.12234230f, -0.03534503f, 0.05572125f, -0.10787394f, -0.02961349f, 0.05481681f, 
    -0.09809650f, -0.00473768f, -0.01462966f, -0.05342635f, -0.03504147f, -0.13363199f, 0.08990210f, -0.04281966f, 
    -0.03533986f, 0.00590094f, -0.05418496f, -0.02970154f, -0.52935284f, 0.18895765f, 0.19055352f, 0.31988287f, 
    0.07006884f, 0.13062014f, 0.04369994f, -0.05346310f, 0.04688377f, 0.25297785f, -0.11639540f, -0.03443820f, 
    0.04593790f, 0.01853661f, -0.00853805f, -0.05354441f, 0.01714194f, 0.16039087f, 0.14651635f, -0.09580711f, 
    -0.06922323f, 0.12644993f, 0.12275908f, 0.26349416f, 0.01908528f, 0.06517384f, -0.01613011f, 0.03462378f, 
    0.01508589f, 0.09058202f, -0.00664053f, -0.08183485f, -0.09120254f, 0.06839910f, 0.10557041f, 0.14393058f, 
    -0.05371077f, 0.03112865f, -0.08926403f, 0.14044508f, -0.05697492f, 0.27194542f, 0.03524660f, -0.05982859f, 
    0.09003176f, 0.13957874f, -0.02227722f, 0.07489595f, -0.02346654f, 0.06419868f, 0.05866307f, 0.06304301f, 
    0.04816671f, 0.11219522f, -0.10858514f, 0.04133660f, 0.01673936f, -0.09334984f, 0.04333873f, -0.07720377f, 
    0.38351861f, -0.09250084f, 0.05888877f, 0.00572975f, -0.23881680f, 0.05583962f, 0.01226648f, -0.02866878f, 
    -0.11369800f, -0.07651763f, -0.05869144f, 0.02668990f, -0.10123401f, 0.05225268f, 0.03455070f, -0.00232879f, 
    -0.15499437f, 0.01893468f, -0.03423128f, -0.02619211f, 0.09020520f, 0.06364606f, -0.04584505f, 0.19727448f, 
    -0.16321781f, 0.00123560f, -0.03189935f, 0.07011267f, 0.07798953f, -0.04045342f, -0.17115526f, 0.16974306f, 
    0.01278911f, -0.03543872f, 0.09385730f, 0.03526604f, -0.12827490f, 0.05179114f, -0.08108922f, -0.10702643f, 
    -0.43403348f, -0.05461338f, 0.13411380f, -0.03001633f, 0.05717352f, 0.05167067f, -0.01021219f, 0.10337275f, 
    0.02344491f, 0.18651482f, -0.01244489f, 0.03901278f, 0.08173121f, 0.00321567f, -0.06903806f, 0.10472197f, 
    -0.10017692f, 0.05469495f, -0.01699477f, 0.02380188f, 0.18880779f, 0.24691045f, -0.08390598f, 0.18947475f, 
    -0.17826582f, -0.04099078f, -0.04801757f, -0.04467133f, -0.02822425f, -0.03497824f, -0.12919313f, 0.08795287f, 
    -0.00357848f, -0.01573873f, 0.10796715f, -0.04150961f, 0.01108531f, 0.16095212f, -0.00098795f, -0.00169971f, 
    0.16378096f, -0.03039262f, -0.06667543f, 0.21819602f, 0.01616448f, -0.08130641f, -0.06047134f, 0.04580860f, 
    -0.00169045f, 0.09185893f, 0.06433634f, 0.12678394f, 0.07747104f, 0.04670446f, -0.07149921f, 0.01980826f, 
    0.07403844f, 0.04261050f, -0.00160455f, 0.02017402f, -0.16378555f, -0.02168917f, 0.23117803f, -0.08821177f, 
    0.03585650f, -0.02548629f, 0.01837622f, -0.05252670f, 0.01941225f, 0.11238502f, 0.09679940f, -0.07299914f, 
    0.00811634f, -0.07734299f, -0.01787705f, -0.05747973f, 0.01892082f, -0.13859919f, 0.00659035f, 0.01504785f, 
    0.00502295f, -0.10552140f, 0.03641987f, 0.14345494f, 0.06559978f, 0.11062235f, 0.02016574f, 0.02557117f, 
    0.16831949f, 0.03715317f, 0.05251214f, 0.08300203f, 0.03604565f, -0.04031149f, -0.00027380f, 0.02684485f, 
    0.02849165f, 0.11193731f, -0.00774615f, -0.10853346f, 0.33368739f, -0.02754097f, 0.09848984f, 0.11685570f, 
    -0.01842350f, 0.02323791f, 0.01463113f, -0.06176867f, 0.19993566f, 0.13415346f, -0.00913981f, 0.02314663f, 
    -0.01934108f, -0.10214475f, -0.01344040f, -0.05110122f, 0.03702698f, 0.07997762f, 0.10970827f, -0.00724846f, 
    0.38744217f, -0.08512813f, -0.14925270f, -0.10305088f, -0.11205810f, -0.03653800f, -0.07367206f, -0.03654818f, 
    0.02182838f, -0.04431039f, -0.00048046f, -0.03940662f, -0.08532505f, -0.09441774f, -0.06955309f, -0.03024696f, 
    -0.00060681f, -0.07334191f, -0.00993514f, 0.11777931f, 0.18203415f, -0.06413756f, 0.13814275f, -0.18245816f, 
    -0.02711164f, -0.04556437f, 0.04705565f, 0.03327189f, 0.07477553f, -0.01972591f, 0.12278313f, -0.10737233f, 
    -0.01182941f, 0.06462761f, -0.02601310f, 0.03660876f, 0.02357807f, 0.00361255f, -0.14059398f, 0.02995919f, 
    -0.01848630f, -0.04864953f, 0.08185457f, 0.25350472f, 0.11750627f, -0.00919499f, 0.05263709f, -0.02950905f, 
    0.05352031f, -0.00333910f, -0.01634451f, 0.09843677f, 0.00638521f, -0.04111692f, 0.00725821f, 0.06633414f, 
    0.02225416f, 0.01822392f, 0.06644624f, 0.00408409f, -0.07837964f, 0.09203580f, -0.01799192f, -0.06136281f, 
    0.04639673f, -0.13524263f, -0.01038681f, -0.09956060f, 0.06445213f, -0.04553163f, 0.05340771f, -0.03141524f, 
    0.00267777f, 0.10103549f, 0.04689940f, -0.12388722f, 0.12442826f, -0.09747797f, -0.06490584f, 0.02271818f, 
    -0.04797268f, -0.34124160f, 0.07525693f, -0.02004864f, -0.00438937f, -0.09224319f, 0.04603998f, -0.05667404f, 
    -0.00564793f, -0.03901837f, -0.07239775f, 0.00057497f, 0.04451046f, -0.09942602f, 0.06303848f, -0.16234735f, 
    -0.01323735f, -0.07219163f, 0.03771676f, 0.06081709f, -0.16305274f, 0.30538869f, -0.00753268f, -0.43533915f, 
    -0.13079973f, 0.05290082f, -0.09980747f, -0.04434032f, -0.01782613f, 0.04504091f, -0.03872134f, 0.03399123f, 
    -0.04490851f, 0.10318468f, -0.08061456f, -0.01622573f, 0.11174481f, -0.13325489f, 0.08611832f, -0.07235845f, 
    0.36532626f, 0.23950869f, -0.11070086f, 0.04496202f, 0.19779153f, -0.00930941f, 0.10819735f, 0.00222061f, 
    0.09409453f, 0.02954190f, 0.01446504f, -0.04659431f, 0.08248891f, 0.11915044f, -0.09366386f, -0.02187101f, 
    -0.02485374f, -0.02239868f, 0.00164974f, 0.03947767f, 0.02489372f, 0.20972092f, 0.00638005f, 0.33429590f, 
    0.04842415f, 0.12019464f, 0.06596266f, -0.05980067f, -0.02981851f, 0.12004255f, 0.06548551f, -0.00050248f, 
    0.03385337f, 0.07428951f, 0.13337287f, 0.05277624f, -0.05080203f, 0.10198975f, 0.03305791f, 0.05221806f, 
    0.02158340f, 0.02758894f, -0.04114509f, 0.04340824f, -0.01614730f, 0.01471248f, 0.01574524f, 0.03003881f, 
    0.00266698f, -0.00833602f, 0.02010517f, -0.01044037f, -0.01589913f, 0.02263298f, -0.02282382f, -0.03679928f, 
    -0.02955660f, 0.02971973f, -0.02925989f, 0.02763569f, -0.03075058f, -0.01625638f, 0.02897698f, 0.02583008f, 
    0.02508274f, 0.02978835f, -0.04521394f, -0.00165664f, -0.03434789f, -0.02024274f, 0.04130295f, 0.00759730f, 
    0.03936735f, -0.02215389f, -0.02469010f, -0.03147465f, 0.00700611f, 0.00947340f, -0.01479003f, -0.03687323f, 
    -0.01116051f, 0.02343311f, 0.01826767f, -0.03971018f, 0.03307606f, -0.03650632f, -0.03409627f, -0.00811972f, 
    0.02047181f, 0.01300139f, -0.02546866f, -0.02186874f, 0.00199100f, -0.00799114f, -0.02781050f, -0.03606873f, 
    -0.03115346f, 0.03574321f, -0.00263287f, -0.01578582f, 0.02449061f, 0.01225363f, 0.02606228f, 0.02618828f, 
    0.00942986f, 0.00721977f, 0.02536974f, 0.00054140f, -0.00813308f, -0.01318346f, 0.00527019f, 0.03633897f, 
    -0.00503343f, 0.02960377f, 0.01996749f, -0.00325153f, 0.01020101f, -0.02585212f, -0.02938276f, -0.03681732f, 
    -0.01901349f, -0.00892192f, -0.00706982f, -0.03837638f, -0.02484877f, -0.00115999f, 0.02345074f, 0.02439175f, 
    0.04046329f, -0.03155379f, 0.02029540f, -0.01061990f, -0.02470377f, 0.01088363f, -0.03103714f, -0.01183061f, 
    0.00582742f, -0.04158372f, 0.01290993f, -0.00113669f, -0.02184244f, -0.00362836f, 0.00591665f, -0.01575266f, 
    0.01911147f, -0.04605085f, -0.04078881f, -0.02809869f, 0.00878660f, -0.01889338f, -0.03950614f, 0.02805088f, 
    0.00971156f, -0.02870476f, -0.04371031f, -0.04510498f, 0.00152743f, -0.04182639f, -0.01119537f, -0.03403119f, 
    -0.01752060f, -0.02073169f, -0.03523018f, 0.03284361f, 0.02700610f, -0.00228427f, -0.02881783f, 0.00765075f, 
    0.00733948f, 0.00446452f, -0.01371399f, 0.02584762f, 0.02784759f, 0.02279506f, -0.01537755f, -0.01295176f, 
    -0.00991594f, 0.02305539f, -0.04174162f, 0.01211547f, -0.00735036f, -0.02476374f, -0.01935106f, -0.03106988f, 
    0.03297203f, 0.00831999f, -0.00568136f, 0.00303135f, -0.02136400f, 0.00909315f, -0.03678417f, 0.03086210f, 
    0.01539207f, -0.00603475f, 0.02354725f, -0.02691528f, -0.02951761f, -0.01619248f, -0.01851643f, -0.03931642f, 
    0.03457223f, 0.01315498f, -0.02949332f, -0.02812006f, 0.00772231f, -0.00173476f, -0.03525941f, 0.03528114f, 
    0.02953938f, -0.02982428f, 0.01237310f, -0.03142563f, -0.02282502f, 0.01564980f, -0.02435913f, -0.02696694f, 
    -0.02208198f, 0.00115383f, 0.01004025f, -0.04594281f, 0.02880504f, 0.01150927f, -0.03943184f, -0.02554093f, 
    -0.03939303f, -0.01504478f, -0.02792141f, -0.02290461f, 0.00089183f, 0.01462021f, -0.02363535f, -0.02330543f, 
    0.01658183f, 0.01744538f, -0.01231468f, -0.00631998f, 0.01171804f, 0.02142667f, 0.01339416f, -0.03015616f, 
    0.01496018f, -0.02105641f, 0.01963953f, -0.01809709f, -0.01728073f, 0.02931836f, -0.00653882f, -0.00215192f, 
    -0.00169483f, -0.00966530f, -0.02892263f, 0.02002225f, 0.00513596f, 0.00204253f, -0.01767679f, -0.00337106f, 
    -0.02945960f, 0.01351949f, -0.04189992f, 0.00646028f, -0.04189755f, 0.02181442f, 0.03121069f, 0.01439505f, 
    0.01665352f, 0.02896846f, 0.02026054f, -0.00510743f, -0.00904160f, -0.00005559f, -0.03227595f, -0.04159136f, 
    -0.01194794f, 0.00108717f, -0.04075420f, -0.03318566f, 0.00985867f, -0.01168468f, -0.04371889f, -0.02994174f, 
    0.01723845f, -0.01964625f, -0.02898441f, 0.01192490f, 0.00208643f, 0.02634039f, -0.03374588f, 0.03587658f, 
    0.00505738f, 0.03504884f, 0.01982614f, -0.01599864f, 0.03763492f, 0.00956799f, -0.00149860f, 0.01126051f, 
    0.02567549f, 0.00049003f, 0.02227597f, 0.00366486f, -0.04046658f, -0.04026370f, 0.00906039f, 0.03117157f, 
    0.02949358f, -0.04094826f, -0.01154259f, -0.02267685f, 0.00943748f, 0.00216449f, -0.00462345f, 0.03297755f, 
    0.00684390f, 0.02275342f, -0.01275063f, 0.02042121f, -0.02782723f, 0.01911787f, -0.04252924f, -0.01915221f, 
    -0.03554165f, 0.01831093f, -0.00735753f, -0.02868296f, 0.02344467f, -0.01006896f, -0.02520115f, 0.01355847f, 
    0.02017103f, -0.02505250f, -0.00911678f, 0.02018339f, -0.04473863f, -0.00263121f, -0.00579517f, 0.03185339f, 
    0.03812301f, 0.00886449f, -0.01536815f, 0.00236298f, 0.00430603f, 0.01133682f, -0.03693666f, -0.03959959f, 
    -0.03512633f, -0.01310281f, 0.01723703f, -0.01173736f, 0.03188254f, -0.02760055f, -0.03601224f, -0.02483526f, 
    0.02627020f, -0.03737154f, -0.01927280f, 0.02259927f, -0.01836668f, -0.02667996f, -0.01494266f, 0.00706942f, 
    0.00344025f, -0.03700212f, 0.00432507f, -0.03408581f, -0.02509768f, -0.01927738f, -0.01775380f, 0.00543945f, 
    0.00323267f, -0.00576314f, -0.04430808f, -0.00008435f, 0.02927460f, -0.04534287f, -0.02889485f, -0.02404714f, 
    -0.01415401f, -0.00560632f, -0.00108863f, -0.01990453f, -0.01638092f, -0.01079068f, 0.02217533f, 0.01332926f, 
    -0.00650816f, -0.01673460f, -0.00356863f, 0.03168528f, -0.03923915f, 0.02310315f, 0.02761277f, -0.04218920f, 
    -0.04008372f, -0.00021978f, -0.01240780f, -0.02260707f, 0.00533947f, -0.00440626f, 0.00697519f, 0.01706222f, 
    -0.01265393f, -0.01514280f, -0.00440014f, 0.01867105f, 0.02537042f, 0.00034120f, -0.01500623f, -0.01086641f, 
    -0.03479932f, 0.00039074f, -0.01110479f, 0.02089844f, -0.01603240f, 0.00307769f, -0.02127665f, 0.01452766f, 
    -0.00722219f, -0.02289477f, 0.00528128f, -0.02352298f, -0.04187549f, 0.00566622f, 0.02910970f, -0.02519173f, 
    0.01362901f, -0.03134564f, 0.02101935f, 0.00883688f, -0.01468532f, 0.00861069f, 0.04277198f, -0.02539187f, 
    -0.00299041f, -0.01297906f, -0.01735288f, -0.00958513f, -0.01974170f, -0.02518489f, 0.02223183f, -0.03575804f, 
    0.01715420f, 0.00509279f, 0.00068582f, 0.01394011f, -0.03949225f, 0.00594757f, -0.03782099f, 0.02437849f, 
    -0.02086655f, 0.01212165f, -0.04030349f, 0.02967857f, 0.02519199f, 0.00054626f, -0.02922718f, 0.01176364f, 
    -0.01983865f, -0.00953794f, 0.02518808f, -0.01792047f, -0.00129471f, -0.04368209f, 0.01608936f, -0.01450008f, 
    0.01510031f, 0.00109585f, -0.02962665f, 0.00511643f, 0.01782405f, -0.00452070f, -0.02255556f, 0.02013702f, 
    -0.03938388f, 0.00891776f, 0.02007553f, -0.00200511f, -0.01982976f, -0.00434374f, -0.01556747f, -0.04004243f, 
    0.02424158f, 0.02126377f, -0.01121626f, -0.00065790f, 0.03967310f, -0.02910933f, -0.02428779f, 0.02642475f, 
    0.02262604f, -0.03781304f, -0.00167565f, -0.01661942f, -0.00569534f, 0.01002364f, 0.00597595f, -0.04245697f, 
    -0.02403722f, -0.03391518f, 0.02618894f, -0.01111236f, -0.00464296f, 0.01893338f, 0.01406203f, -0.02450924f, 
    0.00321365f, 0.02954960f, -0.01439253f, -0.00281216f, -0.01932806f, -0.02465802f, -0.01673978f, 0.01054759f, 
    -0.00253467f, 0.00754821f, 0.03254802f, 0.00349899f, 0.00273434f, 0.01597805f, -0.02638524f, 0.03610407f, 
    -0.00511891f, -0.01357886f, 0.01239599f, 0.01030354f, 0.02024091f, -0.02284102f, -0.00554496f, 0.02820686f, 
    -0.02623757f, 0.03253142f, 0.01958377f, 0.01677628f, 0.01227180f, -0.02424678f, 0.02577829f, 0.02565628f, 
    0.00508129f, -0.04141346f, -0.03003746f, -0.02986827f, 0.03182393f, 0.03226993f, 0.00739107f, 0.00364203f, 
    -0.02322602f, -0.02465451f, 0.00588249f, -0.01492754f, -0.00834102f, -0.01733599f, -0.01771094f, 0.02214679f, 
    -0.01838515f, -0.02074675f, 0.02124870f, 0.01092365f, -0.03676310f, -0.00326310f, 0.00443421f, -0.03591605f, 
    0.01537716f, -0.03501320f, -0.00957512f, 0.03075973f, 0.00646724f, -0.02657512f, -0.03257174f, -0.01912316f, 
    -0.00510508f, -0.03891599f, 0.03757859f, 0.00992701f, -0.03350779f, -0.04135428f, 0.01575430f, -0.01034633f, 
    0.02513486f, 0.02840272f, 0.01363960f, 0.02690709f, -0.00974793f, -0.03338221f, -0.02538686f, 0.00482434f, 
    0.00434801f, -0.03217790f, 0.01406600f, 0.04083880f, 0.00477136f, -0.00636322f, 0.01047296f, -0.02992982f, 
    0.02231292f, -0.02803262f, 0.00472952f, -0.02262439f, -0.03114463f, 0.00036847f, 0.01605360f, 0.01960789f, 
    0.00777655f, -0.03824985f, -0.02768045f, -0.02164252f, 0.00454098f, -0.02027399f, 0.01655161f, 0.03242882f, 
    0.03355220f, -0.00196254f, -0.01599835f, -0.02935865f, -0.01848884f, -0.03962188f, -0.03856698f, 0.01547672f, 
    0.03332360f, -0.03307980f, -0.01464867f, -0.01994708f, -0.02874539f, -0.01726364f, 0.03284868f, -0.01850092f, 
    0.01106481f, -0.02217539f, 0.01801355f, 0.02653774f, -0.02556949f, 0.03073443f, 0.02460627f, 0.02522572f, 
    0.00770619f, 0.02151473f, 0.01253137f, -0.00777298f, -0.01753122f, 0.00443832f, -0.02804860f, -0.03100561f, 
    -0.03208324f, -0.03620220f, 0.04574309f, -0.00068499f, -0.02098468f, 0.03693722f, -0.00593837f, -0.00152617f, 
    0.00654780f, 0.02894341f, 0.01330657f, 0.01098630f, -0.03785430f, -0.04587365f, -0.02675857f, -0.02907155f, 
    -0.01784226f, -0.03991534f, 0.00835516f, 0.00484976f, 0.01882503f, -0.00615206f, -0.01845492f, -0.00148713f, 
    -0.03235414f, 0.03404290f, 0.02482703f, 0.03455750f, -0.03536921f, -0.03110077f, 0.02076199f, -0.01016681f, 
    0.01125120f, 0.02085157f, 0.00751018f, -0.03630652f, -0.00605011f, 0.01038064f, 0.00347539f, -0.00384919f, 
    0.07341376f, -0.10641749f, -0.15312603f, 0.11301494f, -0.20178302f, -0.12946494f, 0.04848209f, 0.10675634f, 
    -0.01705620f, 0.00784216f, -0.03631175f, -0.01779038f, 0.08840325f, 0.08133155f, 0.18924960f, 0.02046601f, 
    -0.06408434f, -0.06042305f, 0.08095902f, -0.16575797f, 0.02677369f, 0.10331497f, 0.05763757f, 0.32764727f, 
    0.19150154f, 0.11223248f, -0.10741198f, 0.08644991f, 0.07041245f, 0.10297976f, 0.01970255f, 0.04793519f, 
    0.04074110f, 0.11114155f, -0.23038112f, 0.00724288f, -0.07258528f, 0.00268976f, -0.08190788f, -0.07349192f, 
    0.15234284f, 0.15880276f, 0.03912154f, 0.06781172f, -0.09108233f, -0.16359580f, -0.03461250f, -0.06832016f, 
    -0.01375465f, 0.11440331f, 0.04954498f, 0.01648412f, 0.00914736f, -0.04815505f, 0.00229263f, 0.01773595f, 
    0.03035935f, -0.03667254f, 0.29107514f, -0.02359470f, -0.44172156f, 0.17210174f, -0.09242772f, -0.16133678f, 
    -0.22442587f, 0.04485605f, -0.01323216f, -0.01071357f, 0.12489899f, 0.01331597f, -0.03743628f, 0.06612130f, 
    -0.00678625f, -0.08078635f, -0.09957732f, 0.02611934f, -0.10196967f, 0.03636900f, -0.00788119f, 0.02606866f, 
    -0.26610190f, -0.14188081f, -0.01933423f, -0.05095798f, -0.19319174f, -0.16219117f, -0.17860714f, 0.05776923f, 
    0.03390918f, -0.07875001f, 0.09784880f, 0.04266336f, -0.00320836f, 0.05240340f, 0.06099707f, -0.05582818f, 
    -0.08186109f, 0.02504318f, -0.14229168f, -0.05033448f, -0.39881423f, 0.08735420f, -0.05056227f, 0.10899281f, 
    0.13609348f, -0.04766696f, 0.09152078f, -0.07425557f, 0.16727987f, 0.03468702f, -0.11464407f, -0.05532067f, 
    0.04499755f, -0.07162574f, -0.06204609f, 0.07308912f, -0.04047424f, 0.08656313f, -0.08157947f, -0.00451068f, 
    0.47960114f, 0.02579604f, 0.12053944f, 0.01257555f, 0.06338028f, -0.11159538f, -0.09034454f, -0.01354002f, 
    -0.13676278f, 0.13453235f, -0.00613269f, -0.00159420f, 0.10211728f, 0.02927942f, 0.04721400f, -0.03227032f, 
    0.01981269f, -0.02811909f, 0.01045857f, 0.13502896f, -0.23803498f, -0.18318620f, -0.06888271f, -0.07402454f, 
    -0.00538465f, 0.00850143f, -0.10494371f, 0.07017327f, -0.05345095f, -0.05390197f, -0.01051957f, -0.04552445f, 
    0.05320570f, -0.07001635f, -0.02593760f, -0.01703501f, 0.01983599f, -0.06948697f, -0.02273644f, -0.13730370f, 
    0.44944417f, 0.10815375f, 0.02220832f, 0.05566141f, 0.03361987f, -0.11725633f, -0.03492291f, 0.02077354f, 
    0.11497531f, -0.01089410f, -0.03568402f, 0.12516040f, -0.07276379f, 0.12014462f, 0.04279013f, -0.01866535f, 
    -0.04077677f, 0.02064977f, -0.03813909f, 0.02276824f, -0.07832554f, 0.23586531f, -0.11939135f, -0.00729458f, 
    -0.00287037f, -0.09274136f, 0.00109755f, 0.13014621f, 0.12539327f, -0.04607833f, 0.00376726f, 0.03752647f, 
    -0.07385410f, 0.12281579f, -0.10616007f, 0.06281893f, 0.03360188f, 0.13303688f, -0.11585784f, 0.09168515f, 
    0.15951110f, 0.25465211f, 0.04404690f, 0.08323994f, -0.05717631f, 0.05375452f, 0.10632288f, 0.13606328f, 
    -0.00210097f, -0.02872240f, -0.07925293f, -0.01850720f, 0.10045466f, -0.15951639f, -0.01613563f, 0.05031432f, 
    0.00195563f, -0.11153415f, 0.08076265f, -0.04071077f, -0.34659204f, 0.00677375f, -0.02818473f, 0.02874233f, 
    0.16295731f, 0.01135259f, -0.09330958f, 0.04652910f, 0.12345450f, -0.10136085f, -0.02820422f, -0.04149893f, 
    0.08984856f, 0.01423825f, 0.00576529f, 0.05905698f, 0.12352385f, -0.10121156f, -0.16056700f, 0.01177347f, 
    -0.30372909f, 0.09694964f, 0.03187740f, -0.09990829f, -0.06434470f, 0.14544520f, 0.05097305f, -0.04376119f, 
    0.05218521f, -0.02377580f, 0.00273032f, 0.05645296f, -0.00002135f, -0.04542168f, -0.18213177f, -0.05260566f, 
    0.07116212f, 0.01954954f, 0.10266816f, -0.01780019f, 0.40944105f, 0.03198767f, 0.24327770f, -0.11283430f, 
    0.01018056f, -0.04136472f, 0.04940876f, -0.01804549f, 0.07319120f, -0.06526350f, -0.04380068f, 0.14486969f, 
    0.12556724f, 0.08031193f, -0.07504142f, 0.09989545f, -0.01902064f, 0.12184624f, -0.05969644f, 0.13645555f, 
    0.28729871f, 0.01236578f, 0.06426043f, 0.02388740f, 0.19232036f, -0.00076061f, 0.07944811f, -0.03289386f, 
    -0.06143876f, -0.12665133f, -0.21612598f, -0.00383234f, -0.12660299f, 0.08289444f, 0.00203641f, 0.05073039f, 
    0.07169040f, 0.11085536f, -0.11792932f, -0.06796999f, 0.44038957f, -0.28491300f, 0.05614118f, 0.05984259f, 
    -0.04524568f, -0.00832279f, -0.03885608f, -0.04593345f, 0.03732036f, 0.07440712f, 0.00518446f, 0.03287413f, 
    0.05858983f, 0.10162493f, 0.11551193f, 0.03938827f, -0.03149270f, -0.05725102f, -0.06249926f, 0.00486584f, 
    -0.32362977f, -0.28225628f, 0.02937880f, -0.04785220f, 0.03984465f, -0.00797744f, 0.06180483f, -0.05306219f, 
    0.01392036f, -0.06277822f, -0.00797518f, 0.05265198f, 0.08511518f, -0.02019482f, 0.07835580f, -0.00908689f, 
    0.12945470f, -0.01681927f, 0.00143437f, -0.03068634f, 0.23094141f, 0.01739079f, 0.04286848f, -0.09435695f, 
    0.20379660f, -0.05364032f, 0.05239604f, -0.03039842f, -0.08576382f, 0.16331957f, 0.06242365f, -0.06796149f, 
    -0.06593163f, -0.08857493f, -0.04972866f, 0.04265394f, 0.02420771f, 0.21138175f, 0.18139865f, 0.11839919f, 
    0.42682460f, 0.14990222f, 0.00620200f, 0.14567322f, 0.24323517f, 0.08923690f, -0.07777589f, -0.04439129f, 
    -0.03633562f, -0.10375606f, -0.03893990f, 0.00652445f, -0.06315859f, -0.04337637f, 0.03576718f, 0.01844524f, 
    0.08775333f, 0.19746666f, -0.05633904f, -0.01112098f, 0.18647021f, -0.06925115f, 0.15404460f, 0.00869258f, 
    0.29656112f, -0.00225780f, 0.23811631f, 0.04776570f, 0.03339074f, 0.07651096f, -0.11528297f, -0.13784057f, 
    0.02343509f, -0.07386938f, 0.00249190f, 0.11954576f, 0.10556288f, 0.07807138f, 0.10026301f, 0.10956647f, 
    0.22901428f, 0.03443436f, -0.04120846f, 0.10776288f, -0.08572941f, -0.11347473f, 0.00372577f, 0.05872621f, 
    -0.01225299f, -0.10233562f, -0.03030926f, 0.04354216f, -0.06353664f, -0.02786766f, -0.02183909f, 0.03361151f, 
    -0.05596552f, 0.00205370f, 0.28317964f, 0.13974677f, 0.21409188f, 0.02544659f, 0.31731993f, 0.18285923f, 
    0.03698200f, 0.14713725f, 0.08217496f, 0.01978794f, -0.01867906f, -0.01096778f, -0.01180684f, 0.05371383f, 
    0.02735800f, -0.09136607f, -0.05043026f, 0.01836907f, -0.05288327f, 0.09915050f, 0.05589748f, 0.00532533f, 
    0.05366957f, -0.02298687f, -0.05438799f, 0.10179878f, 0.11224663f, -0.05407578f, -0.13765304f, -0.04938488f, 
    -0.13674420f, -0.00972279f, -0.02026143f, -0.04314973f, -0.06680728f, -0.13382041f, 0.11861370f, -0.12093244f, 
    -0.05264772f, 0.10589875f, 0.15776494f, 0.03280294f, 0.25249955f, 0.08537625f, 0.09108175f, -0.04182996f, 
    -0.14091048f, -0.07636575f, -0.09036100f, -0.00172741f, -0.03211492f, -0.01768680f, -0.09217308f, -0.00704287f, 
    -0.01502944f, 0.13836367f, 0.03266352f, -0.02437329f, 0.06996594f, 0.07567052f, 0.11123707f, 0.09495234f, 
    -0.00742794f, -0.01980842f, -0.04157170f, 0.16476452f, -0.02345751f, -0.03231138f, 0.10651410f, 0.11448510f, 
    -0.01859267f, -0.02220935f, -0.14305942f, -0.05261105f, 0.02427045f, -0.03560103f, 0.12538019f, 0.03684788f, 
    0.02248591f, -0.07591873f, 0.10487228f, -0.04589773f, 0.43186772f, -0.21476455f, 0.21906984f, 0.01186517f, 
    0.36373398f, 0.12741300f, -0.00710031f, 0.08367548f, 0.09050312f, -0.08173732f, -0.12673616f, 0.02576383f, 
    -0.08601377f, -0.00728811f, -0.06148453f, 0.05386463f, 0.03903050f, 0.11621395f, 0.03389668f, 0.05189934f, 
    0.04560834f, -0.08466540f, -0.09921036f, 0.09464304f, -0.02182862f, -0.06749560f, -0.02148274f, 0.06764174f, 
    -0.06161889f, 0.07318711f, 0.00750434f, -0.02468283f, -0.08000880f, -0.18826656f, -0.01155954f, -0.14440814f, 
    0.00161297f, 0.07185547f, 0.25609577f, -0.05426927f, 0.11704426f, 0.03841373f, -0.03721538f, 0.06261905f, 
    0.00151956f, 0.16329788f, 0.06308084f, 0.03155896f, -0.06883197f, 0.08706250f, -0.10313504f, -0.02094502f, 
    -0.00511066f, -0.18668808f, -0.14177996f, 0.11909481f, -0.03856046f, 0.22799283f, 0.06892229f, 0.01563429f, 
    -0.22239886f, 0.13206272f, -0.03890729f, -0.11277588f, -0.12676865f, 0.09350041f, 0.01938288f, -0.03002156f, 
    0.05330655f, -0.05628854f, -0.04458861f, 0.07487072f, -0.11273985f, -0.18739286f, -0.19400072f, 0.01449962f, 
    0.02436518f, -0.01928007f, 0.13588376f, -0.06422008f, 0.25928479f, -0.31626496f, -0.05294202f, 0.10843670f, 
    0.08913187f, -0.02448902f, 0.10001897f, 0.02632330f, -0.03557743f, -0.01923354f, 0.00268974f, 0.09500983f, 
    0.00814491f, 0.05973299f, 0.00879537f, -0.07979426f, -0.01797714f, 0.08755067f, -0.12905988f, 0.10541296f, 
    0.12624952f, -0.31265986f, 0.05753727f, 0.18268369f, -0.17694989f, 0.09795128f, 0.00715360f, 0.02410793f, 
    -0.03877299f, -0.02109556f, 0.06912491f, -0.01611786f, -0.03340945f, -0.00163098f, 0.15586142f, 0.09518429f, 
    0.00284999f, -0.16157292f, 0.12899573f, -0.00073717f, 0.34112591f, -0.09013855f, 0.09563350f, -0.16587195f, 
    0.07717562f, -0.12522127f, 0.02587563f, 0.02341837f, 0.01774195f, -0.05205483f, -0.07715094f, 0.01164566f, 
    0.01355399f, 0.13201110f, 0.02342352f, 0.02935991f, -0.05492861f, 0.03258212f, -0.04937397f, -0.02418745f, 
    0.09846485f, -0.08325437f, 0.07084838f, 0.12760235f, 0.04236033f, 0.02392686f, -0.09504739f, -0.02098096f, 
    0.05064432f, 0.06581523f, 0.06273567f, -0.00706075f, 0.01842996f, -0.04277264f, -0.08925629f, -0.09196518f, 
    0.07061733f, 0.06994732f, -0.02375507f, 0.06926162f, 0.12384379f, -0.07622416f, 0.09694458f, 0.04352176f, 
    -0.06248013f, 0.11786813f, -0.03716949f, 0.00131710f, 0.06549414f, -0.05991809f, 0.04049274f, 0.04400390f, 
    -0.06247744f, 0.01007515f, 0.14319076f, -0.06286550f, -0.01438024f, 0.12059444f, 0.00486422f, 0.00847319f, 
    -0.03075133f, -0.05411353f, 0.03177777f, -0.08573974f, -0.01894766f, 0.12666367f, 0.04379770f, 0.07217427f, 
    -0.03103901f, -0.05012764f, -0.08066633f, -0.06662707f, 0.04497110f, 0.11405689f, 0.03322593f, -0.02642811f, 
    0.04315511f, 0.12274703f, -0.20920709f, 0.06329424f, -0.20305663f, -0.02593376f, -0.05088127f, 0.16380082f, 
    0.12169620f, 0.06356243f, -0.01686359f, -0.04164367f, -0.01762889f, 0.06258766f, -0.01186315f, -0.06702250f, 
    0.09299515f, 0.05178551f, 0.02706204f, 0.03960338f, -0.05617983f, -0.08870706f, 0.08128470f, 0.04098294f, 
    -0.02366471f, 0.21896574f, -0.04617063f, 0.27291137f, -0.04605456f, 0.07496177f, 0.04594341f, -0.04812330f, 
    0.05824346f, 0.01440454f, -0.00553128f, -0.03753217f, 0.04050710f, 0.03388313f, -0.02928088f, 0.04094212f, 
    -0.00510024f, 0.02131934f, 0.08533953f, 0.07321382f, 0.01237121f, 0.07347377f, -0.15332681f, 0.18306866f, 
    0.08988091f, 0.05676616f, -0.02821696f, -0.00339559f, -0.01138833f, 0.06499296f, 0.05852366f, 0.02077239f, 
    0.06141026f, 0.06799235f, 0.01063285f, 0.03314845f, 0.07339156f, 0.02085751f, 0.04744231f, 0.03620347f, 
    -0.21110936f, -0.05503596f, 0.03023954f, -0.16874109f, 0.06732508f, 0.05610333f, 0.00104347f, 0.04557493f, 
    0.04153563f, -0.03280903f, 0.04480113f, -0.00714268f, -0.00064933f, -0.00402550f, 0.02655726f, 0.05375175f, 
    0.12896255f, 0.04530412f, -0.03577717f, 0.13320094f, -0.03757573f, 0.15515390f, -0.04220225f, 0.18604210f, 
    -0.00023586f, -0.01994801f, -0.00558292f, -0.07007598f, 0.02534644f, -0.00447083f, 0.03331437f, 0.07328301f, 
    -0.00968732f, 0.14336079f, 0.01223204f, 0.00299724f, 0.03381488f, 0.15339983f, 0.12405144f, 0.02328240f, 
    0.03823332f, 0.34027779f, 0.18720725f, 0.08778154f, 0.03891500f, -0.10551930f, -0.00786571f, -0.03210252f, 
    -0.06396358f, 0.04741699f, -0.00362539f, -0.05434919f, 0.00039030f, -0.09566183f, 0.11119461f, 0.04541083f, 
    -0.03312064f, 0.07581199f, 0.08556116f, 0.02033390f, -0.17730772f, -0.09400731f, -0.02025863f, 0.22517897f, 
    -0.27042902f, -0.00721280f, -0.04555157f, 0.02959423f, -0.07938010f, -0.02112643f, 0.05280046f, 0.03014744f, 
    0.09036057f, -0.05891069f, 0.10106001f, -0.05598727f, -0.06922009f, 0.06201587f, 0.09064053f, 0.05170929f, 
    -0.03469111f, 0.19047746f, -0.00892189f, 0.10939755f, 0.20228019f, 0.12360128f, 0.08397618f, -0.08038475f, 
    0.06073270f, -0.08635227f, 0.08175351f, 0.00938762f, -0.02980693f, 0.14867853f, -0.02931119f, 0.00843018f, 
    0.02581908f, 0.08991265f, -0.04138563f, -0.04444268f, -0.06483896f, -0.04977114f, 0.02403039f, 0.15153129f, 
    0.16655636f, 0.00694132f, 0.04213134f, 0.01511904f, -0.09970077f, 0.01240903f, 0.04927792f, 0.04321562f, 
    0.00652773f, 0.06130907f, -0.06188492f, -0.00967514f, -0.05326332f, 0.00396046f, 0.06411242f, 0.01800183f, 
    -0.08689787f, 0.09587091f, -0.00337628f, 0.15653905f, 0.11767094f, -0.00133363f, -0.00379628f, -0.02929810f, 
    0.03730061f, 0.06702098f, -0.07070162f, -0.05254235f, -0.00460133f, 0.14542949f, 0.02021178f, 0.09166114f, 
    0.01064606f, -0.02177740f, 0.04577873f, 0.04327215f, -0.12902276f, -0.03779612f, -0.26103437f, -0.26370963f, 
    0.09173346f, -0.01816193f, 0.09321024f, 0.04255367f, 0.01324324f, -0.11998387f, 0.17393906f, -0.05045149f, 
    -0.03057453f, -0.04370471f, 0.13998638f, 0.08273701f, 0.07858856f, -0.14157395f, -0.00813063f, 0.09431487f, 
    -0.15057099f, -0.02917951f, -0.07824276f, -0.26975837f, -0.04633951f, -0.03982751f, 0.07634427f, 0.05101072f, 
    0.01762429f, 0.05949845f, 0.13621828f, 0.16184416f, 0.12305998f, -0.16322944f, -0.12760410f, -0.06756037f, 
    0.07378088f, -0.02910644f, 0.23612945f, -0.00491312f, 0.05982834f, -0.03988076f, -0.01745469f, 0.04999212f, 
    -0.14163926f, -0.09762026f, -0.03927165f, 0.06763177f, -0.00128101f, -0.11183116f, 0.03103981f, -0.12357981f, 
    -0.08990306f, -0.14076532f, 0.08584936f, 0.02534118f, 0.08287831f, 0.13483997f, 0.00372238f, 0.00116731f, 
    0.02200987f, 0.24604078f, -0.08453697f, 0.04899042f, 0.07516547f, -0.03547734f, -0.02952064f, 0.04127638f, 
    0.09359995f, 0.08312986f, 0.07030933f, -0.02554798f, 0.04116600f, 0.01684562f, -0.00786457f, 0.07370649f, 
    0.12739018f, -0.01754287f, 0.06442663f, 0.06029014f, -0.15675519f, 0.03200667f, -0.00126697f, -0.02326302f, 
    0.02781130f, -0.01912278f, -0.02161718f, 0.06424690f, 0.00683935f, 0.07464620f, 0.15704031f, -0.18282832f, 
    0.01206670f, 0.02815701f, -0.03944643f, -0.05130901f, 0.08478048f, -0.08298308f, 0.01833201f, 0.05578701f, 
    0.11909464f, -0.00125847f, -0.04402452f, -0.17594935f, -0.05726383f, -0.08770278f, 0.13098483f, -0.01608681f, 
    -0.07285038f, 0.02566033f, 0.02714916f, 0.08152231f, 0.01551232f, 0.04707117f, 0.05860373f, -0.11212701f, 
    0.11709298f, -0.15571673f, 0.07946605f, 0.09055456f, -0.12785017f, -0.18825492f, -0.03497305f, -0.11783195f, 
    0.05295933f, 0.05202235f, 0.07945732f, 0.01737481f, 0.02856541f, 0.01237453f, 0.10497952f, 0.01502487f, 
    0.05817864f, 0.07399237f, -0.06240091f, 0.01064451f, -0.15668322f, -0.12119248f, -0.03258170f, -0.03890653f, 
    0.00378900f, -0.04213602f, 0.12437833f, -0.13142298f, -0.07574648f, 0.09736136f, 0.06596322f, -0.04510917f, 
    0.01230566f, 0.04176113f, -0.07759178f, -0.07723010f, 0.06260815f, -0.03296014f, 0.10662187f, -0.01622331f, 
    0.00889262f, -0.01047488f, -0.15399405f, -0.03765019f, 0.03175705f, -0.04642312f, -0.14669310f, 0.03997293f, 
    -0.10849913f, 0.07337185f, 0.00663957f, 0.03672369f, 0.03704076f, -0.09211437f, -0.03408333f, 0.01513780f, 
    -0.09785509f, 0.09424155f, 0.08372979f, -0.02827242f, 0.00188219f, 0.05934047f, -0.02228281f, -0.04503835f, 
    -0.13238668f, 0.03841699f, 0.09549987f, -0.09291510f, 0.02103199f, -0.00974215f, 0.09111487f, -0.09565116f, 
    0.02581023f, 0.02023742f, -0.00962656f, 0.10978947f, 0.00269402f, 0.12234177f, 0.08652185f, -0.06390451f, 
    0.02375082f, -0.11433095f, -0.07762650f, 0.16395822f, -0.54362035f, -0.07643001f, -0.06547950f, -0.07048206f, 
    0.13826373f, 0.05541205f, 0.02101024f, 0.12871760f, -0.05461805f, -0.06852304f, 0.15539852f, 0.07537406f, 
    0.04981995f, 0.07498665f, -0.02054236f, 0.04639395f, -0.06386425f, -0.04117674f, -0.05329091f, 0.05573061f, 
    -0.25513533f, -0.07054136f, 0.14344959f, 0.19299008f, 0.08672428f, 0.04063449f, 0.08314420f, -0.03956729f, 
    -0.09409260f, 0.01693854f, -0.01361416f, 0.03438681f, 0.05472285f, 0.10550442f, -0.01299307f, 0.00533711f, 
    0.00596723f, 0.07510945f, -0.03188784f, -0.07646563f, -0.11040425f, 0.25930318f, 0.05229668f, 0.30742699f, 
    -0.15003785f, 0.09861668f, -0.04487407f, -0.03724781f, 0.00430196f, 0.05393168f, 0.03526182f, 0.10398967f, 
    -0.02064604f, -0.04769388f, 0.03979868f, -0.09993711f, -0.07289680f, 0.01444079f, 0.08737267f, 0.02091460f, 
    -0.01482407f, 0.09768723f, 0.03776100f, -0.12526943f, 0.00032375f, 0.01937902f, 0.02641609f, -0.02771491f, 
    -0.02105569f, 0.02337539f, 0.04027248f, 0.02144171f, 0.05621246f, 0.17854747f, 0.04037142f, -0.00267203f, 
    0.04115453f, 0.06809908f, -0.20464844f, 0.08683664f, 0.15065610f, 0.08838168f, 0.02004324f, 0.05209383f, 
    -0.01290530f, 0.04610724f, -0.00317876f, -0.01561595f, -0.03724443f, -0.00299828f, -0.04439879f, 0.07727266f, 
    -0.00615483f, 0.08219033f, 0.00208193f, 0.03705898f, 0.01344634f, 0.09419979f, 0.06337049f, -0.07123946f, 
    -0.06893223f, 0.16627540f, 0.05036129f, 0.23856767f, 0.12775214f, 0.02771001f, -0.02095994f, 0.06050268f, 
    0.00639600f, 0.05064888f, -0.01790102f, 0.00702039f, 0.00688788f, 0.10629035f, 0.01852737f, 0.04557453f, 
    0.02705494f, 0.08958149f, -0.02824956f, -0.11391860f, -0.14843632f, 0.04235573f, 0.02111932f, 0.28254294f, 
    0.06911892f, 0.00267588f, 0.07438802f, -0.03840536f, 0.00640448f, -0.10226038f, 0.07612177f, 0.04272143f, 
    0.12125816f, -0.10639450f, 0.02716719f, 0.06401782f, -0.03238661f, 0.06920005f, 0.06059824f, 0.01956651f, 
    -0.14117512f, -0.11714784f, 0.03029103f, -0.08779573f, -0.04285575f, 0.04285609f, -0.04976719f, 0.05659500f, 
    -0.03371624f, 0.03043046f, -0.00046199f, 0.00749351f, -0.00527153f, -0.08555027f, 0.01538717f, -0.07319008f, 
    0.05589033f, 0.07264686f, 0.04713459f, 0.05082403f, -0.37864470f, -0.01888318f, -0.15233733f, -0.30615932f, 
    0.08048531f, 0.01329518f, 0.02947386f, 0.01278878f, 0.06484558f, -0.10672740f, -0.07593117f, 0.14831983f, 
    -0.08081919f, -0.13414985f, -0.06020698f, -0.00268414f, 0.04636373f, -0.04863168f, 0.10607398f, 0.05083425f, 
    0.04984248f, -0.31211933f, -0.17691050f, 0.07116010f, -0.09516071f, -0.01978693f, -0.09695082f, -0.00252091f, 
    0.13090712f, 0.07530335f, -0.02279251f, -0.00809140f, 0.07206227f, -0.05372289f, -0.07318581f, -0.02136936f, 
    -0.00969479f, -0.10357419f, -0.02454395f, -0.03736012f, 0.14785568f, 0.15559027f, -0.03413292f, -0.09074776f, 
    0.07473819f, 0.05796906f, 0.05681202f, 0.01508952f, 0.13158606f, -0.15263894f, 0.06612544f, -0.08334933f, 
    0.01188141f, 0.04783045f, 0.03777802f, 0.08709328f, 0.08622536f, 0.00552119f, -0.00966346f, -0.13527082f, 
    -0.30580485f, 0.31943688f, 0.04187661f, -0.14647675f, 0.20441949f, -0.00229879f, -0.08086190f, 0.09198252f, 
    -0.04199836f, 0.04887492f, 0.00002460f, 0.03022719f, 0.10242572f, -0.13898511f, 0.06395721f, -0.06053578f, 
    0.02785745f, 0.08390800f, 0.06489570f, 0.11491493f, -0.27505994f, 0.08049578f, -0.03696818f, 0.23058565f, 
    -0.30502400f, 0.09835628f, 0.10760056f, -0.10737148f, -0.04102705f, 0.02350612f, 0.07717954f, 0.05374492f, 
    0.07143622f, -0.04744013f, 0.06588232f, -0.04297427f, 0.00409386f, -0.09537495f, 0.08005375f, 0.13059746f, 
    -0.09350879f, 0.06333023f, -0.21759295f, 0.21624649f, -0.18777698f, 0.00488548f, 0.01825297f, -0.09058579f, 
    -0.00294483f, 0.02835650f, 0.08481952f, -0.01851732f, 0.05687879f, 0.01392354f, 0.04720274f, -0.01081307f, 
    0.07712007f, -0.03734839f, 0.06739514f, -0.03745406f, -0.25423861f, 0.21055168f, -0.16397512f, 0.30257025f, 
    -0.21597722f, 0.09190580f, 0.13349503f, -0.06241035f, 0.01802472f, -0.02000298f, 0.03706874f, 0.04073345f, 
    0.07162815f, 0.04451861f, -0.07967265f, 0.00253222f, 0.04467037f, -0.00845242f, -0.08564951f, 0.03209965f, 
    -0.37622073f, 0.38680226f, 0.06276940f, -0.26018786f, 0.15470357f, 0.11934676f, -0.11335233f, -0.01125761f, 
    0.02142486f, -0.01352727f, 0.00318496f, 0.01050178f, 0.05492344f, -0.04990674f, 0.01005589f, -0.01236739f, 
    0.12661122f, -0.04119644f, 0.11840350f, 0.03494957f, -0.08047839f, -0.16639927f, 0.06576195f, 0.09061889f, 
    -0.15952735f, 0.06577930f, 0.04654536f, 0.03034222f, 0.05812957f, 0.02433116f, 0.04334402f, 0.01285679f, 
    -0.04906875f, -0.03618985f, -0.01764740f, -0.01118975f, 0.12952448f, -0.01919309f, 0.05225527f, -0.11986010f, 
    -0.04150323f, -0.19094342f, 0.05849975f, 0.17156726f, -0.05673891f, -0.08510312f, 0.08045668f, 0.10728234f, 
    0.02193381f, -0.00331875f, -0.13309237f, -0.03877159f, 0.07070654f, 0.11642741f, -0.00537396f, 0.07600711f, 
    -0.06098658f, -0.03043334f, 0.02087663f, 0.06731284f, -0.08206070f, 0.40170437f, -0.11257792f, 0.29179099f, 
    -0.43965191f, -0.00892626f, 0.06502650f, -0.04952881f, 0.02121820f, -0.00449874f, 0.12889996f, 0.02548805f, 
    0.01560051f, 0.01479398f, 0.10844028f, -0.02870210f, 0.07070687f, 0.04210569f, -0.03401336f, 0.07988562f, 
    0.18363978f, -0.12013248f, -0.09727437f, -0.06319313f, 0.14080232f, 0.00586183f, 0.05624788f, 0.08007530f, 
    -0.02079239f, 0.01810923f, 0.02771966f, 0.06071740f, 0.00919793f, -0.04817875f, 0.09574170f, 0.04658999f, 
    0.02717161f, 0.06281246f, 0.05172864f, 0.09300706f, -0.13715744f, 0.00984830f, 0.06084350f, 0.10394470f, 
    -0.05373640f, 0.08328334f, 0.03608625f, 0.03260991f, -0.09604965f, 0.08725858f, 0.06436902f, 0.04819496f, 
    0.03703614f, -0.00809238f, -0.05343615f, 0.07445412f, 0.01564540f, -0.14127326f, 0.03328601f, -0.00306431f, 
    -0.08971942f, -0.08650022f, 0.02606064f, 0.16505541f, -0.08219171f, 0.00182566f, 0.03994916f, -0.02346988f, 
    -0.01689455f, 0.02255200f, 0.04882930f, 0.03996299f, -0.05124573f, -0.01945751f, 0.05846877f, -0.01502980f, 
    -0.00975007f, 0.03794647f, 0.05890543f, 0.08486134f, -0.40298608f, 0.04720370f, 0.03043639f, -0.05983784f, 
    0.16744056f, 0.06467666f, 0.08192164f, 0.09349260f, 0.00441444f, -0.13953817f, -0.02659103f, -0.01706052f, 
    0.08574815f, 0.04481471f, 0.10489417f, 0.00527456f, -0.00540173f, 0.03164320f, 0.08573405f, 0.07469077f, 
    0.26657334f, 0.24283691f, -0.26269570f, -0.01544376f, 0.00332907f, -0.04931613f, 0.12428113f, 0.05566901f, 
    -0.00503079f, 0.01704631f, 0.08395912f, 0.06699598f, -0.00115784f, 0.00209066f, -0.02273812f, -0.01633026f, 
    0.05869598f, 0.09489372f, 0.12389152f, 0.09221590f, -0.05182540f, -0.29979700f, -0.22591777f, 0.02941470f, 
    -0.14392896f, 0.03349372f, 0.08202312f, 0.09034821f, 0.00405614f, 0.01828879f, -0.00989078f, -0.05708320f, 
    0.00527174f, 0.03284229f, 0.03791093f, 0.03084153f, 0.10551374f, 0.05800498f, -0.11689544f, 0.02024099f, 
    -0.15525438f, -0.06638127f, -0.17893058f, 0.10994890f, 0.03658229f, 0.13115282f, 0.17887959f, -0.14413975f, 
    -0.03713090f, 0.10817651f, 0.02422847f, 0.15779872f, -0.00202035f, 0.03435884f, -0.00556310f, -0.14671506f, 
    0.06475295f, -0.11102767f, -0.00576045f, -0.15148452f, -0.30534703f, 0.59707856f, -0.13764821f, 0.00497181f, 
    0.25844285f, -0.01953936f, -0.09921708f, -0.04108103f, -0.11928284f, -0.05815355f, 0.04199246f, -0.07813880f, 
    -0.04447410f, 0.04204978f, -0.04255686f, -0.02373448f, 0.11110143f, 0.03012819f, -0.01079425f, 0.13301809f, 
    0.12405363f, 0.00927133f, 0.01336660f, 0.02438730f, -0.10840306f, -0.13073276f, 0.17792526f, 0.03380939f, 
    0.12237941f, -0.06982280f, 0.09846341f, -0.00965900f, -0.06799796f, 0.09903146f, 0.02367560f, -0.00316422f, 
    0.00274277f, 0.08635164f, -0.01906082f, 0.11099207f, -0.02515222f, 0.49951705f, -0.12281302f, 0.15521458f, 
    0.27474779f, 0.01607455f, -0.02998773f, -0.03277276f, -0.00430443f, -0.13714772f, 0.05617311f, -0.02731850f, 
    0.09117918f, 0.01613290f, 0.01731597f, 0.18416105f, 0.01497790f, 0.07932393f, -0.02328830f, 0.16795363f, 
    0.28945476f, -0.14395122f, 0.23828791f, -0.18160777f, 0.23797446f, 0.09578029f, 0.00798022f, 0.07147045f, 
    -0.02463249f, 0.03412708f, -0.02031551f, -0.04353847f, -0.10666636f, 0.00639568f, 0.04531841f, 0.08611935f, 
    0.15818091f, 0.03560154f, 0.10580659f, 0.14078772f, -0.10607539f, 0.08595648f, 0.11838546f, 0.18182217f, 
    -0.02487344f, 0.16062412f, -0.02974579f, -0.01668801f, -0.04792812f, -0.14374337f, -0.02863250f, 0.07780442f, 
    -0.08745072f, 0.09553640f, 0.15404017f, 0.05416636f, 0.07734847f, 0.06430004f, 0.07426213f, 0.01468961f, 
    -0.00418180f, 0.23435038f, 0.05409461f, -0.02010185f, 0.19164556f, -0.15650736f, 0.08747630f, -0.06382858f, 
    0.00829997f, -0.12234408f, 0.12786607f, 0.06953075f, -0.03281914f, 0.07952950f, 0.00830410f, -0.09830834f, 
    -0.08193292f, -0.03346039f, 0.07412328f, 0.10872687f, -0.48704925f, -0.21164083f, 0.15916944f, -0.05010225f, 
    0.15321341f, 0.05811020f, -0.06206651f, 0.12942882f, -0.10274600f, -0.05592323f, -0.05454523f, 0.04806724f, 
    0.08941919f, 0.07482708f, -0.02872982f, 0.01149871f, -0.00326549f, -0.03947596f, 0.07598688f, -0.08979297f, 
    0.16797124f, -0.17657003f, 0.02081479f, -0.01352795f, 0.17605330f, 0.07098799f, 0.06911188f, 0.02629359f, 
    0.06191090f, -0.01554999f, -0.06344907f, -0.00166850f, 0.00248401f, 0.11146607f, -0.04652661f, 0.02101711f, 
    0.06654974f, -0.00112882f, 0.05265115f, -0.12159959f, 0.06710433f, 0.08731657f, 0.31119293f, 0.38323599f, 
    -0.10575067f, 0.09274627f, -0.05092568f, 0.02077676f, 0.01184067f, 0.00101188f, -0.03873727f, 0.04355564f, 
    -0.04599470f, 0.05567218f, -0.00743039f, 0.04234847f, 0.15085328f, 0.03970141f, 0.07606965f, 0.15760477f, 
    -0.15019293f, 0.25534448f, -0.05471725f, -0.05789388f, 0.20636503f, -0.02972643f, -0.03288361f, 0.01772194f, 
    -0.08657048f, -0.05877311f, 0.14020880f, -0.01076492f, -0.01440897f, 0.04812173f, 0.08113744f, -0.14351366f, 
    -0.01269459f, 0.08425792f, -0.00117510f, 0.10518844f, 0.12801439f, 0.08834260f, -0.10442485f, 0.13120593f, 
    0.16883640f, 0.07514527f, 0.01542130f, -0.07505811f, 0.08223969f, -0.01200729f, 0.08037270f, -0.03818591f, 
    -0.13652487f, 0.03139648f, -0.09373055f, 0.08130709f, -0.06996033f, 0.13541561f, 0.07728216f, 0.10306643f, 
    -0.02838824f, -0.04841252f, 0.05545867f, 0.13426852f, -0.12866220f, -0.08291341f, -0.03246685f, -0.08873102f, 
    0.01244029f, -0.00102718f, 0.10215815f, 0.09100842f, -0.01228407f, 0.00562855f, -0.07076442f, -0.03689292f, 
    -0.07466704f, 0.08691289f, 0.15039152f, -0.01713511f, -0.15341400f, 0.04164410f, -0.19831014f, 0.11038915f, 
    0.29710490f, 0.11651130f, 0.00679771f, -0.04864590f, 0.04835916f, -0.07944643f, -0.01738953f, 0.01831847f, 
    0.03929705f, 0.11856791f, -0.06950763f, 0.11048394f, -0.02455779f, -0.04219224f, -0.09909109f, -0.07954521f, 
    0.03191103f, -0.21244107f, 0.10718144f, -0.10299379f, 0.39408213f, 0.05084534f, 0.01525482f, 0.01849871f, 
    -0.05136059f, 0.01411001f, -0.08026271f, -0.00021811f, 0.11583885f, 0.06887896f, 0.07257759f, 0.10533252f, 
    0.11552672f, 0.07038543f, 0.01267679f, -0.00414774f, -0.30294213f, -0.00751032f, -0.06436853f, -0.20988654f, 
    0.20595951f, 0.04042488f, 0.01444868f, 0.08582425f, -0.01431982f, -0.10478997f, -0.10295115f, 0.12409366f, 
    0.02705226f, 0.08292635f, 0.09109223f, 0.03760287f, -0.01029154f, 0.07695200f, 0.08701526f, -0.03022846f, 
    0.32496843f, 0.09613793f, 0.02210291f, 0.01890223f, 0.18558745f, -0.14603032f, 0.18712807f, -0.08467005f, 
    0.02914631f, 0.02365513f, -0.12165128f, 0.07268306f, -0.02741918f, 0.03379091f, 0.00748831f, -0.04913301f, 
    -0.07895522f, -0.14931630f, -0.01201894f, -0.06053744f, 0.23297735f, 0.22271396f, -0.00192562f, -0.19560027f, 
    0.04201388f, -0.13637203f, 0.18063450f, 0.02149692f, 0.09765193f, -0.03111096f, 0.02784718f, -0.02867326f, 
    0.04148775f, 0.12733358f, -0.00508849f, -0.00209010f, 0.08417007f, -0.05366786f, -0.02729519f, 0.10135356f, 
    -0.03025562f, 0.00406243f, -0.08021796f, -0.09491478f, 0.06719062f, -0.11325861f, -0.05662740f, 0.07864147f, 
    -0.01371678f, -0.00103585f, 0.07305082f, -0.00621352f, 0.04313995f, -0.02507089f, 0.11707748f, -0.03587758f, 
    -0.01861190f, 0.03770987f, 0.20398754f, 0.06502236f, 0.31279668f, 0.23802489f, 0.07553647f, 0.08048160f, 
    -0.14752847f, 0.04074884f, 0.08649153f, 0.06965230f, 0.04884804f, 0.08821572f, 0.06537150f, 0.10173600f, 
    0.05062873f, -0.11904371f, 0.04286975f, -0.01027218f, 0.08718128f, -0.01923756f, -0.00110254f, 0.05425336f, 
    0.13732003f, 0.09454302f, -0.17966875f, -0.06220176f, 0.05021061f, 0.11310449f, 0.06639493f, -0.02576355f, 
    0.07536644f, 0.08405389f, -0.00613053f, 0.09952331f, 0.02564624f, 0.02235818f, -0.01121353f, -0.04242736f, 
    0.04148791f, -0.14560121f, -0.00318026f, -0.08188483f, 0.13341142f, -0.02982066f, 0.20162411f, -0.02860462f, 
    -0.12128901f, 0.07780632f, 0.01233569f, 0.07971147f, 0.07346155f, 0.05388249f, -0.01529797f, -0.00869241f, 
    0.09416419f, -0.06051930f, -0.08467082f, -0.01554573f, -0.10419121f, 0.06666854f, -0.12262406f, 0.00397789f, 
    -0.04384420f, 0.36855462f, 0.00636177f, -0.05485654f, -0.05128130f, 0.06658192f, -0.02537874f, 0.03195674f, 
    0.01867539f, -0.02364562f, 0.01039642f, -0.08062689f, 0.09985400f, -0.06947062f, 0.04895294f, 0.00191612f, 
    0.00607784f, 0.05479921f, 0.07694739f, -0.00009049f, 0.15904044f, 0.04885921f, -0.12881124f, 0.04103418f, 
    0.05548230f, 0.03475109f, -0.00604470f, 0.11948729f, 0.04744524f, 0.11273671f, -0.03050278f, -0.09018891f, 
    0.09517238f, -0.08965496f, 0.07029524f, -0.03218770f, -0.07110186f, -0.11900273f, -0.06235879f, -0.09720971f, 
    0.42862400f, -0.24402407f, -0.07211103f, 0.08467931f, 0.12029044f, 0.03460013f, 0.11742731f, 0.07897098f, 
    0.03913920f, 0.11191896f, -0.13037039f, -0.06651779f, 0.04163938f, 0.12948510f, 0.02162923f, -0.06665432f, 
    0.03247688f, 0.01800675f, -0.03539112f, -0.01251053f, 0.19282497f, -0.02615431f, 0.07501135f, 0.01531242f, 
    -0.25349841f, 0.17145306f, 0.15268515f, 0.11231124f, 0.07989708f, 0.07618449f, 0.21549638f, 0.00962222f, 
    0.07459960f, 0.02238319f, -0.06512013f, -0.06172969f, 0.10152312f, 0.05917418f, -0.19053861f, 0.08910958f, 
    -0.14818741f, -0.19610675f, -0.09166019f, -0.19179654f, 0.01848190f, -0.07541984f, 0.04658139f, 0.00002690f, 
    -0.05915393f, -0.02506464f, 0.07690910f, -0.01134076f, 0.10728355f, -0.02217342f, 0.06142507f, 0.01973643f, 
    -0.10326719f, -0.07499412f, -0.04997714f, 0.01368585f, -0.12676018f, 0.15349305f, -0.15952238f, 0.16512313f, 
    -0.17885239f, 0.12695357f, -0.05904892f, 0.13050021f, 0.07252688f, 0.10191337f, 0.02270681f, 0.05351418f, 
    0.06232702f, -0.02708930f, 0.02878345f, -0.00695176f, 0.06312866f, -0.16494091f, 0.02398758f, -0.08783907f, 
    0.09861993f, 0.12108116f, 0.12944685f, 0.04421921f, -0.02511725f, 0.00917474f, 0.04034706f, 0.10432639f, 
    -0.09245829f, -0.06849133f, 0.17108208f, 0.03254215f, 0.00695397f, -0.08637290f, 0.00850794f, 0.04296623f, 
    0.00045618f, 0.06691764f, 0.02152522f, 0.03995997f, -0.24021485f, -0.20636694f, 0.24567077f, -0.01134126f, 
    0.24161027f, -0.05919779f, -0.00707464f, 0.01610925f, 0.05599066f, -0.08667810f, 0.00296302f, -0.12454928f, 
    0.12799035f, 0.08383989f, 0.07562619f, -0.04231752f, -0.00333251f, 0.16875455f, -0.00814124f, -0.01335226f, 
    0.00613468f, -0.21530297f, 0.00163708f, 0.18692397f, -0.07289474f, -0.01961645f, -0.05137021f, -0.01244140f, 
    -0.00508703f, -0.05121132f, 0.06351321f, 0.04263616f, -0.05665203f, 0.06720543f, 0.07736200f, -0.04662721f, 
    -0.03807729f, 0.12275515f, -0.00992009f, 0.08379310f, 0.23575187f, -0.12946028f, -0.04765778f, 0.02912342f, 
    0.20892912f, 0.03860732f, 0.06462675f, 0.03426478f, 0.19093674f, 0.12296300f, -0.08776056f, 0.04764844f, 
    0.00625131f, 0.12660158f, 0.01468747f, -0.01917928f, 0.06664734f, -0.09156527f, -0.13278997f, -0.02127714f, 
    -0.23469016f, -0.01820924f, -0.08323568f, 0.02647247f, 0.04186566f, 0.16976142f, 0.17106290f, 0.01774437f, 
    -0.05474183f, 0.10379013f, -0.00786193f, 0.11790796f, 0.06566392f, 0.01958181f, -0.04547122f, -0.13144040f, 
    -0.09264101f, 0.00243602f, -0.03857525f, -0.12949078f, -0.15031624f, 0.11353591f, -0.21315892f, -0.14744174f, 
    -0.14353354f, 0.12652296f, -0.07544516f, 0.06531255f, -0.09074619f, -0.12659667f, 0.01542923f, -0.03533067f, 
    0.02462956f, -0.08481026f, -0.05871682f, 0.01194225f, 0.01005485f, 0.11910278f, 0.10416178f, 0.11389949f, 
    0.12400141f, -0.24075612f, 0.19118516f, -0.12328703f, -0.10647789f, -0.04130262f, 0.08893605f, -0.04278956f, 
    0.06105055f, -0.04842921f, 0.13693230f, -0.06089388f, -0.11148472f, 0.14377350f, 0.07151855f, 0.01126005f, 
    -0.03728782f, 0.15213704f, -0.01422835f, 0.06922560f, -0.07512156f, 0.18646604f, -0.25135559f, 0.10090178f, 
    -0.17021579f, 0.09197518f, -0.23151220f, 0.09338870f, 0.01122344f, -0.06505510f, -0.02260411f, 0.08417021f, 
    0.02605673f, -0.02219597f, 0.00905348f, 0.01248130f, 0.12386641f, 0.21957073f, 0.17265156f, 0.12587313f, 
    -0.04315707f, -0.12481020f, -0.00058388f, -0.12187592f, 0.14056818f, 0.06722785f, -0.06142091f, 0.03197097f, 
    0.01686442f, -0.11112118f, 0.10527775f, 0.05413700f, -0.06538568f, 0.06922571f, 0.07692736f, 0.06298349f, 
    0.02926103f, 0.00329971f, 0.13173074f, 0.08069268f, 0.21137385f, -0.02897103f, 0.06064947f, -0.15477949f, 
    -0.26421133f, 0.00298516f, -0.08283821f, -0.07917778f, -0.12848981f, -0.02990862f, 0.01083719f, 0.09617940f, 
    0.03740307f, -0.00970344f, 0.09157410f, 0.12075933f, 0.00775242f, 0.00839286f, 0.02664235f, -0.13095631f, 
    0.11115522f, -0.16177437f, -0.00905084f, -0.11842703f, -0.09679122f, -0.03765257f, -0.05393959f, -0.08956610f, 
    0.01931594f, -0.02289383f, 0.10962143f, 0.03538872f, 0.00828839f, -0.05608409f, -0.05866524f, 0.01629547f, 
    -0.10984144f, 0.15779351f, 0.11596334f, 0.07239311f, -0.21060053f, 0.21821840f, 0.14753583f, 0.06657140f, 
    0.15158440f, -0.00092204f, -0.01069217f, -0.06742704f, -0.07355542f, 0.03089556f, -0.02967655f, -0.09224635f, 
    0.03716096f, -0.04203613f, -0.03808470f, 0.04439413f, 0.00048265f, -0.01181368f, 0.04102281f, -0.12169152f, 
    -0.18417411f, 0.01129531f, -0.00139511f, -0.06921227f, -0.01563975f, 0.00539491f, -0.00624313f, -0.06529368f, 
    0.08244431f, 0.00382576f, -0.01398887f, 0.04625121f, 0.07257627f, -0.06044755f, -0.01955209f, -0.07345100f, 
    0.10975616f, -0.14123201f, -0.00094959f, -0.05001912f, 0.13152146f, 0.22498612f, -0.03011822f, -0.06507148f, 
    -0.14324392f, -0.00002143f, 0.02898408f, 0.12870230f, -0.04879838f, -0.05189908f, -0.02649469f, 0.00964517f, 
    0.00006273f, 0.11335467f, 0.10391912f, -0.07309389f, 0.15297242f, 0.05498194f, -0.03722807f, 0.02196795f, 
    -0.04671553f, -0.16008769f, -0.04003154f, -0.03833767f, -0.03406155f, -0.04491615f, 0.01778855f, 0.01903409f, 
    -0.00615865f, -0.02684661f, 0.10600778f, 0.05507812f, -0.00464760f, -0.08175191f, -0.01402597f, -0.03939446f, 
    -0.11110136f, 0.08722345f, 0.11850771f, 0.09164043f, -0.07563978f, -0.34329343f, 0.10428919f, 0.01995562f, 
    -0.06024784f, 0.03712549f, 0.06143778f, -0.17837922f, 0.03347111f, -0.08741491f, 0.00274504f, -0.09210437f, 
    -0.15705658f, 0.05547554f, 0.01296107f, -0.02580314f, -0.01646287f, 0.04751186f, 0.00871668f, 0.03168916f, 
    0.01840116f, 0.12968627f, 0.07481323f, 0.06983558f, 0.06970290f, -0.01962032f, 0.07223906f, -0.01746219f, 
    0.01043233f, -0.06733780f, 0.11255081f, 0.08217773f, 0.01009214f, -0.04106069f, -0.01940695f, -0.02613357f, 
    -0.12084145f, 0.05789505f, 0.10391487f, 0.12788555f, -0.05175038f, -0.11856504f, 0.05147824f, -0.14542757f, 
    0.08518346f, 0.05039342f, 0.00347834f, 0.03760372f, 0.10435537f, -0.09618533f, 0.01021751f, -0.00243016f, 
    -0.04565370f, 0.03218843f, 0.12364892f, 0.13596848f, -0.04552650f, 0.00664214f, -0.11295129f, -0.04864551f, 
    -0.22432870f, -0.01848908f, -0.05954969f, -0.22865872f, 0.34161338f, -0.24684033f, 0.09366260f, -0.00902792f, 
    0.05894737f, -0.08757428f, 0.08871639f, -0.05071349f, 0.09928283f, 0.01401101f, 0.04729136f, -0.00919738f, 
    -0.02640941f, -0.05860857f, -0.02629578f, -0.00011270f, -0.15722662f, -0.07396514f, -0.01803062f, 0.20942518f, 
    0.17405236f, -0.02493819f, -0.14238101f, -0.01058899f, 0.00420187f, -0.00330763f, 0.06363057f, -0.03265514f, 
    -0.03257812f, 0.12054047f, 0.04440794f, 0.04731925f, -0.03413285f, -0.00941966f, 0.05902153f, -0.01717500f, 
    0.02388762f, -0.04299657f, -0.04389306f, 0.02018676f, 0.02609600f, -0.00636661f, 0.00972332f, 0.01153196f, 
    0.01785348f, -0.02064268f, -0.03249023f, -0.02633435f, 0.03131870f, -0.03407626f, 0.00630645f, -0.02344229f, 
    -0.00820061f, 0.02675126f, -0.01689718f, -0.04108439f, -0.00706701f, 0.02923924f, 0.00569750f, -0.03606932f, 
    -0.03723879f, 0.02424418f, 0.02322603f, -0.01866412f, -0.02036158f, -0.01034357f, 0.02912105f, -0.00191037f, 
    -0.01320473f, -0.00021647f, 0.02832506f, -0.02993063f, 0.02806195f, 0.01017596f, 0.01562427f, -0.00439106f, 
    -0.02652322f, 0.00947804f, -0.01330098f, -0.03498348f, 0.02489291f, -0.02173555f, -0.03787334f, 0.02320324f, 
    -0.01105108f, 0.03142736f, 0.00740252f, -0.02757745f, -0.00262502f, -0.00786249f, 0.01133245f, -0.03097531f, 
    -0.02503064f, -0.03460163f, -0.03773639f, -0.00697258f, -0.00494673f, 0.02392503f, 0.03164627f, -0.03034470f, 
    0.00143651f, 0.01021525f, 0.01818919f, 0.01714138f, 0.00340330f, -0.04085088f, -0.00043187f, -0.04094223f, 
    -0.00739418f, 0.00290553f, -0.01794310f, -0.03962963f, 0.02277764f, -0.02587014f, -0.01534198f, -0.02609503f, 
    -0.02739334f, -0.00152687f, -0.02232340f, -0.03166910f, -0.00564646f, -0.01546412f, 0.01028506f, -0.04345176f, 
    0.03065775f, 0.01276448f, 0.00448498f, -0.04005144f, 0.00108615f, -0.02786390f, 0.00698825f, 0.00118447f, 
    -0.04478893f, 0.01075081f, 0.01032856f, -0.01169681f, 0.00584827f, 0.01271366f, 0.02134306f, -0.04519044f, 
    -0.02713049f, -0.02514772f, 0.00166909f, -0.04423734f, -0.01469037f, -0.03005048f, -0.02163386f, 0.00675190f, 
    -0.02301677f, 0.02126626f, -0.02645501f, -0.02389175f, 0.00406332f, -0.02899531f, 0.00812938f, 0.02977430f, 
    -0.02295168f, -0.02440343f, -0.02456314f, -0.03892071f, 0.01757174f, -0.04058299f, 0.01110752f, -0.00333288f, 
    -0.01308605f, 0.01637468f, -0.02616634f, -0.01439316f, 0.02556752f, 0.03327252f, -0.00820293f, -0.01524499f, 
    -0.03044107f, 0.02556157f, -0.01705918f, 0.00163193f, -0.00725064f, -0.00526971f, -0.02741432f, 0.00238039f, 
    -0.02675473f, -0.01366140f, 0.00153301f, 0.02582726f, -0.03540269f, -0.00115708f, -0.01064214f, -0.03062420f, 
    -0.01453232f, -0.04227376f, -0.01047636f, -0.04342582f, 0.01825965f, -0.03584123f, -0.04372729f, 0.02741641f, 
    0.01369265f, -0.01702228f, 0.01480217f, 0.02217989f, 0.01841252f, -0.03898846f, 0.00963604f, 0.03227830f, 
    -0.01107453f, -0.04435661f, 0.02297622f, 0.00751265f, 0.03214544f, 0.02858769f, 0.03299334f, -0.03791128f, 
    -0.01361877f, 0.00527926f, 0.02501049f, 0.02992332f, -0.00636889f, 0.02281736f, -0.00199943f, 0.01700237f, 
    -0.02405926f, 0.00760561f, -0.03289950f, -0.02079017f, 0.02380921f, 0.01039253f, 0.02882852f, -0.01868490f, 
    -0.03649460f, -0.00270963f, -0.03196637f, -0.03740241f, -0.00520398f, -0.04225878f, 0.00432332f, -0.03209637f, 
    0.03129898f, -0.00981248f, -0.04282742f, -0.03606379f, 0.01757355f, -0.03224931f, -0.02120451f, -0.03237740f, 
    0.01183791f, -0.02070783f, -0.03556824f, -0.00103729f, 0.02123575f, 0.01515403f, 0.01061758f, -0.03960941f, 
    0.02819747f, -0.02474063f, -0.03939627f, 0.03204957f, -0.03214986f, -0.01004158f, -0.01957330f, -0.01235777f, 
    -0.00964241f, 0.00329822f, -0.01274975f, 0.01490684f, -0.03179935f, 0.01130081f, 0.01243361f, -0.01651152f, 
    0.02180380f, 0.01504148f, 0.00517177f, -0.02799094f, 0.02266545f, -0.03667784f, 0.01226498f, -0.02121841f, 
    0.00115637f, 0.01885128f, -0.00665727f, -0.01549138f, -0.00578780f, 0.00814783f, -0.02760900f, 0.01413206f, 
    0.00721251f, -0.02273132f, -0.02284729f, 0.00583294f, 0.02269499f, -0.01794385f, -0.00987755f, 0.00784859f, 
    -0.02182089f, 0.00342853f, 0.00398583f, -0.01882972f, 0.00076055f, 0.01785483f, -0.02719354f, -0.03179167f, 
    0.00203600f, -0.04344308f, -0.04257220f, -0.02452939f, -0.04225899f, -0.00370740f, 0.02072466f, 0.01804917f, 
    0.00740357f, -0.04198736f, -0.04236517f, 0.02210060f, 0.02793922f, 0.00783993f, -0.02045191f, -0.03523860f, 
    -0.01669386f, -0.02110196f, 0.00149017f, -0.02925953f, 0.01172308f, -0.02273291f, -0.02850275f, -0.03396353f, 
    -0.01357632f, -0.02178225f, -0.01617302f, 0.00492773f, -0.01871273f, -0.02946776f, -0.00706562f, -0.00187754f, 
    -0.01754204f, 0.01914458f, -0.00717623f, 0.02142758f, 0.02573742f, -0.02100928f, 0.03071095f, -0.01490604f, 
    0.02141174f, 0.02176688f, -0.01171992f, 0.00264977f, -0.03737757f, -0.03010989f, -0.03495014f, -0.04196988f, 
    0.02383055f, -0.00883381f, -0.02995975f, -0.00033217f, -0.03911390f, -0.02759504f, -0.03068292f, -0.01291046f, 
    0.03215936f, 0.02642076f, 0.00676302f, -0.03236965f, 0.01403722f, 0.01846051f, -0.01304617f, -0.01627955f, 
    -0.01485483f, -0.03631062f, 0.03120799f, -0.01063634f, -0.00100468f, -0.00792698f, -0.03777801f, -0.00870492f, 
    -0.02357242f, 0.01420844f, 0.02863735f, -0.03225409f, -0.04436844f, -0.02693203f, 0.00705901f, 0.01330325f, 
    -0.02448926f, -0.03526013f, 0.02465405f, -0.04354779f, 0.00779135f, -0.03757259f, -0.01969822f, 0.00890900f, 
    0.02005676f, -0.01196149f, -0.02796399f, -0.01195005f, -0.02000698f, 0.01667043f, -0.00327331f, -0.00739138f, 
    -0.02514764f, -0.03938414f, 0.02316089f, -0.02143211f, -0.02169819f, -0.01118694f, -0.01413533f, -0.04300098f, 
    -0.04389433f, -0.04321007f, -0.02901577f, -0.01556916f, -0.04405826f, -0.03181631f, 0.00702429f, 0.00455521f, 
    0.02047997f, -0.01752760f, 0.01796221f, -0.02466305f, -0.00069432f, 0.00618299f, 0.03090926f, -0.03792806f, 
    -0.00107246f, -0.01453708f, -0.02360710f, -0.02550785f, -0.01404039f, 0.02471842f, 0.00872306f, -0.00572776f, 
    0.02800067f, -0.02270810f, 0.00162431f, 0.01155923f, -0.01114944f, -0.01587240f, -0.02114497f, 0.00673933f, 
    0.00709131f, -0.00678134f, 0.01531080f, 0.01780391f, 0.02199044f, 0.01801214f, -0.02012484f, -0.01027041f, 
    -0.04532124f, 0.01217920f, 0.02257689f, 0.00506333f, -0.03504070f, -0.01450004f, -0.00208930f, -0.01001240f, 
    0.03065416f, -0.01063396f, 0.02461624f, -0.03183068f, 0.00612692f, -0.02813396f, -0.02350015f, 0.01116000f, 
    -0.02625512f, 0.00627941f, -0.02051637f, 0.03183330f, 0.00761984f, 0.02968045f, -0.03730024f, 0.03022840f, 
    0.02322615f, 0.01206127f, -0.02530965f, 0.03177739f, 0.03042403f, -0.00791240f, 0.00114603f, 0.01859578f, 
    0.00582189f, 0.02081297f, -0.02437136f, -0.00391644f, 0.01091670f, -0.01680971f, 0.01743610f, 0.00269381f, 
    0.02208167f, -0.02217133f, 0.00819580f, -0.02227966f, -0.03508246f, 0.00899353f, 0.02989382f, -0.00997213f, 
    0.01741534f, 0.03118396f, -0.02357428f, -0.00038430f, -0.03126832f, -0.00978301f, 0.02105549f, -0.01209259f, 
    -0.00154827f, -0.02021255f, -0.03366711f, -0.00811530f, -0.03387734f, -0.03162114f, -0.01017641f, 0.00521058f, 
    -0.00409206f, -0.01255409f, 0.03109693f, 0.01187576f, -0.03596020f, -0.00371526f, -0.02212086f, -0.00537725f, 
    -0.00565604f, -0.02827461f, 0.00656960f, 0.02123761f, -0.01244703f, -0.03651056f, -0.03681079f, -0.00266999f, 
    -0.03113272f, -0.01626626f, 0.01799840f, 0.02667852f, -0.01848361f, 0.01624104f, -0.04221258f, 0.00353800f, 
    0.02632245f, 0.01276420f, 0.03248646f, 0.00639946f, -0.00499410f, 0.01821395f, -0.03959984f, 0.02203789f, 
    0.01722733f, 0.01087001f, 0.02749240f, 0.00746299f, 0.02153834f, -0.02508442f, 0.01665854f, 0.02011770f, 
    0.01686216f, -0.03955437f, -0.00053912f, -0.00019278f, -0.03546051f, -0.00263955f, -0.00511598f, -0.03635846f, 
    -0.00969033f, -0.01790143f, 0.00140273f, -0.01677637f, 0.02725683f, -0.02188309f, -0.01817284f, -0.04441967f, 
    -0.01760807f, -0.02374159f, 0.02407174f, 0.02851654f, 0.00803782f, -0.02401672f, -0.02459040f, -0.03229856f, 
    -0.04161210f, 0.01139758f, -0.02487602f, -0.02559046f, 0.00637077f, -0.00472990f, -0.01694744f, 0.01871973f, 
    0.01669405f, 0.01839017f, 0.02101857f, -0.00057943f, -0.03950909f, -0.01298537f, -0.03751343f, 0.00782935f, 
    0.02183530f, 0.01881197f, 0.00140714f, -0.00417174f, 0.00954809f, 0.01293391f, -0.03800431f, -0.03412974f, 
    -0.04123241f, 0.03317432f, 0.01042149f, 0.00583979f, 0.00372376f, -0.04513074f, 0.01114606f, -0.03659758f, 
    -0.03181174f, -0.02621867f, 0.01697134f, -0.03520112f, -0.03312441f, -0.02645976f, -0.04462179f, -0.01492627f, 
    -0.00885050f, 0.00959751f, 0.01192511f, 0.02262869f, 0.01773972f, -0.01842790f, 0.01547884f, -0.02786790f, 
    -0.04491995f, -0.03156159f, -0.00538862f, -0.04142773f, -0.02889457f, -0.02289599f, 0.02333787f, -0.01559592f, 
    -0.03348787f, 0.02303572f, -0.00394215f, 0.00027607f, -0.01689650f, -0.04401056f, -0.04318457f, 0.01490163f, 
    -0.03688186f, 0.00380968f, 0.00873201f, 0.02269121f, -0.03090171f, 0.00836026f, -0.00461199f, 0.01013006f, 
    -0.02880549f, 0.01742833f, -0.04534306f, -0.02156340f, 0.00948225f, -0.03325538f, -0.01892797f, -0.01158243f, 
    -0.01679531f, -0.02459462f, 0.01021925f, 0.02433028f, 0.03179354f, 0.03188308f, -0.04195008f, 0.00839988f, 
    -0.02776090f, -0.00104478f, -0.00301714f, -0.04184957f, -0.02686910f, -0.04072988f, -0.01759681f, -0.04381069f, 
    0.02774981f, -0.00249547f, -0.00656843f, -0.01072892f, 0.01543765f, -0.00780908f, -0.03252530f, 0.02302622f, 
    -0.18300569f, -0.05051175f, 0.14090982f, -0.16949126f, 0.16755256f, 0.10202748f, 0.15503326f, -0.05097461f, 
    -0.07061449f, 0.19327645f, 0.03558758f, 0.02372915f, 0.01708388f, -0.03131003f, -0.01586667f, -0.04092054f, 
    0.08165447f, 0.15494020f, 0.00376452f, 0.05728589f, -0.51888454f, 0.22666922f, 0.26145017f, -0.09956072f, 
    -0.19420183f, -0.09947540f, 0.06791320f, -0.09822805f, -0.13876034f, 0.01166931f, -0.07978862f, 0.03406651f, 
    0.13114183f, -0.01482685f, 0.14304994f, -0.05901775f, 0.05572809f, 0.00133463f, -0.01616757f, 0.02175229f, 
    0.11683294f, -0.11343245f, -0.08508031f, 0.05879741f, 0.11565800f, 0.02741667f, 0.05776223f, -0.00792581f, 
    0.07525276f, 0.01030667f, 0.00869292f, 0.05143231f, 0.00511131f, 0.06691822f, 0.02725871f, 0.03595116f, 
    -0.03133368f, -0.00533710f, -0.08422451f, 0.08587368f, 0.26649612f, -0.02842927f, 0.23012879f, -0.07553133f, 
    0.10216039f, -0.07114089f, -0.02280810f, 0.10197619f, -0.04346510f, 0.06937563f, 0.10791036f, -0.00024700f, 
    -0.01803550f, 0.02750069f, 0.04714893f, 0.15453961f, -0.01029343f, 0.03129472f, -0.02962680f, 0.04021075f, 
    0.11512576f, -0.03389477f, 0.04219970f, -0.20274301f, -0.01611282f, 0.10526717f, 0.07430617f, -0.02872505f, 
    -0.06585506f, 0.15894057f, 0.06467073f, 0.05670904f, -0.05407998f, 0.00360959f, 0.07089551f, 0.03103086f, 
    -0.04358952f, 0.02291422f, 0.02449112f, 0.07905950f, 0.11133953f, -0.04886840f, 0.27605116f, -0.08749345f, 
    0.12328254f, 0.09256985f, -0.02550902f, 0.15686773f, -0.02620176f, 0.02701808f, 0.24487248f, 0.03934695f, 
    0.03078688f, -0.07799380f, 0.04145141f, 0.04705370f, 0.04528349f, 0.06028452f, 0.01932689f, 0.00117490f, 
    -0.26881638f, -0.05116078f, -0.15145247f, 0.22257006f, -0.11529654f, 0.06133759f, 0.11094866f, 0.04528980f, 
    0.10470349f, -0.00420061f, 0.02403099f, -0.01216280f, 0.01305207f, -0.02187487f, -0.09349595f, -0.01214159f, 
    -0.06619965f, -0.02602394f, -0.01712823f, -0.06318471f, 0.03777821f, 0.08710179f, -0.07744179f, -0.08879618f, 
    0.14047089f, 0.02298518f, 0.13642666f, -0.09546857f, 0.05340911f, 0.07554214f, -0.03187859f, 0.06416941f, 
    0.08270399f, -0.03434023f, 0.17006166f, 0.00218833f, 0.01583233f, 0.08421290f, -0.04940544f, 0.17441140f, 
    0.14742208f, -0.20176928f, 0.11047618f, -0.11196849f, -0.04286417f, 0.12733857f, 0.17811060f, 0.02025606f, 
    -0.12759954f, -0.08376032f, 0.04435371f, -0.01144607f, -0.01935320f, -0.11005715f, 0.11276430f, -0.00189567f, 
    0.04155363f, 0.06274683f, -0.03438884f, -0.00824818f, -0.08490226f, -0.27333128f, 0.26900515f, -0.17380337f, 
    -0.04073073f, 0.14823449f, 0.04182982f, 0.02834668f, -0.03550053f, 0.05604848f, 0.02790539f, 0.01795238f, 
    0.03430651f, -0.09030720f, 0.00560951f, 0.10243914f, -0.01713981f, -0.00835170f, 0.05915702f, 0.00011274f, 
    0.06979977f, -0.09422077f, 0.08519952f, -0.01020678f, -0.04446103f, -0.05322356f, 0.00614775f, -0.07599784f, 
    0.06715191f, 0.09651527f, 0.03046001f, 0.08739123f, 0.08883590f, 0.13462831f, -0.00859209f, 0.00799210f, 
    0.03797774f, -0.01000500f, -0.01793268f, 0.07007531f, 0.02166192f, 0.07128523f, -0.02865910f, -0.01940753f, 
    0.14812367f, -0.02024971f, 0.07047158f, -0.00006795f, -0.01064015f, -0.01139237f, 0.03234798f, 0.02988963f, 
    0.07096361f, 0.05707440f, 0.07491419f, -0.02583795f, -0.03591072f, 0.09641779f, 0.09082787f, -0.03862355f, 
    0.25540492f, 0.00256948f, 0.21044350f, 0.03463602f, -0.01294904f, -0.08888549f, -0.02125308f, 0.04243085f, 
    -0.04317810f, 0.04905212f, -0.00889219f, 0.02182983f, -0.01058857f, 0.12674724f, 0.15544978f, 0.05688312f, 
    -0.04759600f, 0.05711909f, -0.07502789f, -0.00062946f, -0.03597746f, 0.00892614f, -0.21748687f, 0.08582430f, 
    -0.19534777f, 0.09018373f, 0.06693161f, 0.04142683f, 0.04037420f, 0.04885218f, 0.01032736f, -0.07279393f, 
    0.00340609f, -0.06897718f, -0.06767246f, -0.02226976f, 0.01103661f, -0.01623596f, -0.07387503f, -0.13436522f, 
    -0.13953626f, -0.28452635f, 0.06787558f, 0.04189130f, -0.03167434f, 0.07804183f, -0.11873169f, 0.10263334f, 
    -0.03663153f, 0.03926473f, 0.06116834f, 0.02424868f, 0.01295310f, 0.02037332f, 0.08159181f, 0.06061283f, 
    -0.01513583f, -0.04194117f, -0.02453521f, 0.07930334f, 0.06598716f, 0.24920820f, 0.02135016f, -0.06598096f, 
    0.14824529f, 0.09854709f, 0.16435182f, 0.02527079f, 0.08420355f, 0.03744910f, -0.00361068f, -0.00900277f, 
    0.04263718f, 0.03888145f, 0.00752235f, 0.00112694f, 0.00126470f, 0.06796803f, 0.06115042f, 0.03145090f, 
    -0.06479538f, 0.15266749f, -0.11510459f, -0.05441806f, 0.13270167f, 0.09546924f, 0.04107417f, 0.08788788f, 
    0.00203518f, 0.01799627f, 0.01438835f, -0.05893908f, -0.05528853f, 0.03168628f, 0.07947539f, 0.17159317f, 
    0.01477963f, 0.13190360f, 0.00475021f, 0.04995997f, -0.17597415f, -0.49551523f, -0.11411862f, 0.13761124f, 
    -0.13319892f, 0.20535205f, -0.06934053f, 0.16267952f, 0.10253097f, -0.03728597f, 0.01795937f, -0.02442073f, 
    0.02206252f, 0.06635176f, 0.11160231f, -0.00980992f, -0.06123198f, -0.23476221f, -0.03410343f, -0.09937082f, 
    -0.04474885f, -0.21428503f, -0.01465650f, -0.02639985f, -0.00523353f, 0.00268957f, -0.00960083f, 0.05413334f, 
    -0.11495339f, 0.10133069f, 0.09250674f, -0.03048823f, 0.02080300f, 0.04254126f, -0.02825407f, 0.01881192f, 
    -0.01100829f, -0.05197225f, 0.05415878f, 0.02213475f, -0.16471522f, -0.53136235f, -0.09954555f, 0.23128514f, 
    -0.12949641f, 0.01529504f, -0.13529234f, 0.03894727f, 0.00994339f, -0.00838428f, 0.03489323f, 0.02290913f, 
    0.06372390f, 0.09765731f, 0.17907472f, -0.05120401f, -0.05952901f, -0.07327148f, -0.09904790f, -0.02572045f, 
    -0.07938280f, 0.12925005f, -0.05942732f, 0.05498132f, -0.06743364f, -0.03379461f, -0.12929417f, -0.02365018f, 
    0.10407887f, 0.05445879f, 0.09174515f, 0.05020483f, 0.10389640f, 0.05318293f, 0.09772150f, 0.04180636f, 
    -0.03026046f, 0.00165749f, -0.08378761f, 0.02201789f, -0.11435804f, -0.18083271f, -0.00477970f, -0.09586654f, 
    0.05895932f, -0.12602772f, 0.01455800f, -0.02970312f, 0.00839615f, 0.16256188f, 0.00753362f, 0.09981465f, 
    -0.01461871f, -0.04821567f, 0.03471588f, 0.03545304f, -0.02006653f, 0.06031210f, -0.07070033f, -0.00407590f, 
    0.15576895f, -0.27991936f, 0.03244857f, 0.11638109f, -0.04271384f, 0.06950989f, 0.06113915f, 0.14695524f, 
    0.16579567f, 0.03997020f, 0.04374702f, 0.04715533f, -0.03471105f, 0.02481911f, -0.04269370f, 0.13871747f, 
    0.06673393f, -0.12977192f, 0.04743089f, -0.05947480f, 0.12033496f, 0.09648253f, -0.20869987f, 0.05648367f, 
    -0.02280321f, 0.10086275f, 0.07915144f, -0.04208259f, 0.19002503f, 0.04761811f, 0.09036579f, 0.04554247f, 
    0.06744748f, -0.06397121f, 0.01522868f, -0.00206956f, -0.00586113f, -0.03344065f, -0.12719129f, 0.01469048f, 
    -0.05631544f, -0.07292721f, 0.09899192f, -0.01556650f, -0.21162041f, -0.03086206f, -0.01692171f, -0.04589223f, 
    0.09912198f, 0.12166362f, 0.06628758f, 0.03953664f, -0.01352608f, 0.02061651f, 0.00635806f, -0.04150619f, 
    -0.00449252f, -0.01172579f, -0.00367086f, 0.14433381f, -0.21577606f, -0.05665292f, -0.01914889f, -0.11736677f, 
    0.05241651f, -0.15577953f, 0.08377418f, 0.02816795f, -0.07363676f, 0.02144696f, 0.09240673f, 0.05807262f, 
    0.05579746f, -0.03819419f, 0.17937957f, -0.00978417f, -0.09159408f, 0.01729427f, -0.16769579f, -0.06108711f, 
    0.12294444f, -0.21685213f, -0.00666844f, 0.07747298f, 0.10799230f, 0.09389906f, 0.00270709f, 0.03581226f, 
    0.18670724f, 0.00103605f, 0.05461845f, 0.09191318f, -0.01812216f, 0.05968518f, -0.05338008f, 0.16044660f, 
    0.05821871f, -0.06782796f, -0.06585314f, 0.04333908f, 0.06656549f, 0.00493371f, 0.01653991f, 0.02685364f, 
    0.00799985f, -0.14728382f, -0.10480559f, -0.00167315f, 0.01604116f, -0.01860447f, -0.06252223f, -0.06257021f, 
    0.07763898f, 0.11714618f, 0.16980118f, -0.12181987f, 0.21988691f, -0.22774406f, -0.07089359f, -0.08846859f, 
    0.16917863f, 0.02100397f, 0.29828873f, -0.12457024f, -0.12903404f, -0.10065737f, -0.01625947f, -0.02315424f, 
    0.02582680f, 0.06813341f, 0.00249403f, -0.04402511f, 0.05921806f, 0.22817987f, 0.13828810f, -0.05194283f, 
    -0.04754708f, -0.08510109f, 0.01203564f, 0.02864327f, -0.30396885f, 0.35242292f, 0.14735818f, -0.00456127f, 
    -0.27263236f, 0.11401558f, 0.00029252f, 0.07196747f, 0.07863739f, 0.12785321f, -0.03482925f, 0.05778224f, 
    0.11057027f, -0.01636491f, -0.02111162f, 0.12775065f, 0.01028789f, 0.08368906f, -0.01364760f, -0.03583972f, 
    -0.19073509f, 0.40392426f, -0.20728053f, -0.02388554f, -0.03668639f, -0.00855780f, 0.14329033f, -0.04729932f, 
    0.14072470f, 0.06388246f, 0.01244289f, 0.04166138f, 0.02006730f, -0.01125590f, -0.08185481f, -0.02853932f, 
    -0.04281119f, -0.00354384f, -0.00231020f, 0.08555974f, -0.07350639f, 0.02860144f, -0.13314718f, 0.17105961f, 
    -0.08423673f, 0.18039282f, 0.04377772f, -0.01892520f, 0.06374216f, -0.06463984f, 0.07021740f, -0.02532570f, 
    -0.02138037f, -0.08929964f, -0.05307232f, 0.10886341f, 0.00650865f, 0.00969257f, -0.03634747f, 0.02904751f, 
    -0.01812933f, 0.13075320f, 0.14224938f, 0.12009613f, 0.10321076f, 0.02768181f, -0.01546502f, 0.04843244f, 
    -0.11498258f, -0.03564360f, 0.07154154f, 0.02251413f, -0.03175984f, 0.02483321f, 0.03227375f, 0.08602227f, 
    0.08801891f, 0.14988366f, 0.09086378f, 0.07985808f, -0.19486679f, -0.19494188f, 0.01947967f, 0.09205671f, 
    -0.04117720f, -0.04844825f, 0.02077867f, 0.03139560f, -0.15465517f, 0.14330903f, -0.01407559f, 0.06290998f, 
    0.05826249f, -0.04552299f, 0.05847320f, 0.04016792f, -0.09937584f, 0.04350146f, 0.05878192f, 0.20656213f, 
    0.27725345f, -0.16079721f, 0.03253727f, 0.01478970f, -0.14485183f, 0.20181470f, 0.14099146f, 0.05868076f, 
    0.06847794f, 0.00722625f, 0.01441864f, 0.04639976f, 0.01845256f, 0.13507681f, -0.03540637f, 0.06770790f, 
    0.03035134f, 0.00145788f, -0.13289407f, -0.04425201f, 0.08621208f, 0.16673225f, 0.06322002f, 0.04626581f, 
    0.11496463f, 0.00142075f, -0.04495048f, 0.12186600f, 0.03699743f, -0.00770379f, -0.10020694f, -0.05863668f, 
    0.02400657f, 0.09024370f, -0.02171709f, 0.00912756f, -0.07436572f, 0.04364355f, 0.00202732f, -0.06758285f, 
    0.15944910f, 0.20825121f, 0.18680602f, 0.15248987f, 0.14125602f, 0.02653768f, -0.02158923f, 0.03443579f, 
    0.00629169f, -0.00845823f, -0.05463839f, -0.00428521f, 0.00929970f, 0.01180544f, -0.03067577f, -0.02422031f, 
    -0.01214715f, 0.07371221f, -0.04784384f, 0.00866246f, 0.31335023f, -0.10729523f, 0.00576750f, 0.02592148f, 
    0.13453580f, -0.01727321f, -0.10512126f, 0.06174554f, -0.00944170f, 0.02715640f, 0.00602859f, 0.03176540f, 
    -0.01987248f, -0.00373030f, 0.04917855f, 0.04416166f, -0.03864584f, 0.01176993f, 0.10495354f, -0.02624224f, 
    0.40415615f, -0.24715714f, 0.01528208f, 0.02359785f, 0.02734984f, 0.01217539f, 0.06646229f, 0.03848729f, 
    -0.02339540f, 0.06227324f, 0.09937900f, 0.03191842f, 0.02702107f, 0.05843633f, -0.01714615f, 0.06429421f, 
    -0.02541789f, 0.02868900f, -0.02740196f, 0.05855155f, 0.18812658f, 0.33983582f, -0.07295105f, 0.07572783f, 
    0.02526617f, 0.05827995f, 0.02394047f, 0.02599685f, -0.07772669f, -0.00044807f, 0.00987094f, 0.06208653f, 
    -0.00118605f, 0.08895369f, -0.03885699f, -0.00792021f, -0.03889041f, 0.22523251f, -0.02301662f, 0.03172132f, 
    -0.15556160f, 0.20269798f, 0.03883972f, -0.00430610f, 0.10299014f, -0.04853745f, -0.04579606f, -0.16713606f, 
    -0.08112328f, -0.02388608f, 0.16671428f, 0.06643769f, -0.05287169f, -0.10933376f, 0.10555993f, 0.05146322f, 
    0.01101486f, 0.07084753f, -0.02599367f, -0.02300463f, -0.11286309f, -0.18463050f, 0.16811073f, -0.10158832f, 
    0.19419323f, -0.00122936f, -0.04517447f, 0.03465844f, -0.00548135f, -0.04684431f, -0.07065861f, -0.02426573f, 
    0.00214976f, -0.09506764f, -0.02846029f, 0.03368411f, -0.09816853f, -0.05257944f, 0.10367666f, -0.03522960f, 
    -0.27537474f, 0.33263150f, 0.13353425f, -0.09768443f, -0.04814788f, 0.11908887f, 0.03681144f, -0.02272196f, 
    0.14515029f, -0.04290025f, 0.02976831f, 0.01698748f, -0.05657066f, 0.10099275f, -0.08233454f, 0.02063868f, 
    0.04983783f, 0.06200915f, 0.03734573f, -0.00072589f, 0.00211122f, 0.18402806f, 0.06266999f, 0.04285773f, 
    0.08654267f, 0.03879960f, -0.01308629f, -0.09940954f, 0.05919527f, -0.06351497f, -0.02585928f, -0.01331928f, 
    -0.00073465f, 0.11911952f, -0.03987824f, -0.07971180f, 0.00797184f, 0.18004717f, 0.00354448f, 0.01594645f, 
    0.17636217f, 0.30524775f, 0.01799560f, -0.07595406f, -0.01909497f, 0.08873518f, -0.02668503f, 0.08577295f, 
    0.02260518f, 0.00327749f, -0.02689787f, -0.02614175f, 0.01435245f, 0.14940616f, -0.05116685f, 0.08085498f, 
    -0.00414124f, 0.03142487f, -0.06415496f, -0.05183572f, 0.50147605f, -0.09554418f, -0.15052667f, -0.10808862f, 
    -0.00928939f, -0.03492376f, 0.05778161f, -0.06498262f, -0.03867106f, 0.06316661f, 0.14760341f, 0.03924377f, 
    -0.10225508f, -0.02303776f, 0.01057863f, 0.06716172f, 0.00373916f, -0.12170840f, -0.14224088f, 0.03789247f, 
    -0.15230392f, -0.16146667f, 0.21847217f, -0.24881797f, 0.08299777f, -0.03717874f, -0.01333329f, 0.01410708f, 
    -0.02499924f, -0.00596737f, 0.04142363f, -0.00499244f, 0.07886456f, -0.08840667f, -0.08871648f, -0.07321320f, 
    0.07003229f, -0.11629328f, 0.07390929f, -0.13064781f, 0.14933507f, 0.12481475f, 0.08981475f, 0.06276914f, 
    0.08513174f, -0.08581100f, 0.02422135f, 0.00559223f, -0.10617957f, -0.08520700f, 0.05459165f, 0.09189159f, 
    -0.00066641f, -0.08833909f, 0.07208820f, 0.05287449f, -0.08977461f, 0.08635426f, 0.04126107f, 0.08386544f, 
    0.06272376f, 0.24923253f, 0.09844243f, -0.00025992f, 0.11042020f, -0.17101933f, -0.15879287f, 0.10793184f, 
    0.03063189f, -0.01664611f, 0.01739663f, -0.07041068f, 0.03935958f, -0.01047669f, -0.00302899f, 0.16221373f, 
    0.05630264f, 0.10020831f, 0.08960614f, 0.15294331f, 0.19401716f, -0.35838687f, 0.05806271f, -0.09112581f, 
    -0.02298388f, 0.10430643f, 0.09861446f, -0.00449863f, 0.12044266f, 0.09967214f, 0.04601593f, -0.02913948f, 
    0.02351944f, 0.09043597f, 0.08206438f, 0.07334068f, 0.04112720f, -0.06126250f, 0.01831602f, -0.03785855f, 
    -0.13461569f, -0.01432543f, -0.04045891f, 0.06051299f, 0.08644188f, 0.15845741f, -0.07292981f, -0.05630595f, 
    -0.04649063f, 0.01233643f, -0.01905679f, 0.09952402f, 0.03462190f, -0.02545490f, 0.02671478f, -0.06797336f, 
    0.09285564f, -0.18122919f, 0.04224589f, -0.05391261f, 0.00130269f, -0.42252564f, -0.08466648f, -0.28291485f, 
    -0.03443136f, 0.04388240f, 0.12740882f, 0.04933690f, 0.01117950f, 0.07866354f, 0.04039153f, -0.01743693f, 
    0.03045091f, 0.01472931f, -0.09272231f, -0.12776951f, -0.10703938f, -0.13447194f, 0.01801445f, -0.07029290f, 
    -0.28553635f, 0.18524249f, -0.12508616f, -0.11057849f, -0.27465361f, -0.00016569f, 0.05852783f, -0.00883751f, 
    0.04202617f, -0.03140802f, 0.00547669f, -0.05140607f, 0.00024631f, 0.02673395f, 0.03684026f, -0.07942837f, 
    -0.14206330f, 0.00987320f, -0.17099558f, -0.07025795f, 0.15777500f, -0.20498469f, -0.27880770f, -0.02866479f, 
    0.09108646f, -0.01643744f, 0.07007168f, 0.14440835f, -0.03787019f, 0.05477714f, 0.04015989f, -0.02255266f, 
    0.03674768f, -0.00240811f, -0.04076213f, -0.01992003f, -0.02638917f, 0.08225714f, -0.07824714f, 0.03663250f, 
    -0.05788337f, -0.04536140f, 0.03329668f, 0.03141338f, -0.05211453f, 0.14363912f, 0.04513848f, 0.09160292f, 
    0.02751628f, 0.11932070f, -0.02537082f, -0.03194050f, 0.03227247f, 0.02802840f, -0.02762718f, 0.04369996f, 
    0.09363100f, -0.14778161f, -0.02782005f, -0.00879435f, 0.29199386f, 0.01199903f, -0.12055120f, 0.08770750f, 
    0.02164783f, -0.01712892f, 0.10449701f, 0.00457479f, 0.05664168f, -0.00180856f, 0.08246792f, -0.07588611f, 
    0.12052558f, -0.01148505f, 0.09504416f, -0.02212379f, -0.01430668f, -0.02072436f, -0.12552874f, 0.11091591f, 
    -0.31782132f, 0.36091226f, 0.10388161f, 0.05332452f, -0.00137434f, 0.01819792f, -0.00641410f, 0.00024570f, 
    -0.02663605f, 0.06863627f, 0.10395075f, 0.00492468f, 0.09273684f, 0.04075910f, 0.04124226f, 0.06283707f, 
    -0.12422577f, 0.05192204f, -0.00028363f, 0.05850649f, -0.27603999f, -0.20696837f, -0.24278660f, -0.06184282f, 
    0.11757473f, 0.04232722f, 0.02830870f, 0.02386172f, -0.04157783f, 0.05570218f, 0.02104711f, -0.00006450f, 
    0.11218313f, -0.11951480f, 0.07323081f, 0.04587797f, -0.11701725f, 0.05201277f, 0.00862578f, -0.07524127f, 
    0.04095752f, -0.05661616f, 0.05242787f, -0.05348624f, -0.08500160f, 0.08720741f, 0.05969397f, 0.05984055f, 
    0.08022551f, 0.13890474f, -0.01991748f, 0.06025190f, 0.08785935f, 0.10755128f, -0.06523004f, 0.08080138f, 
    0.04717652f, -0.12420371f, -0.07221684f, -0.03646282f, -0.13396536f, -0.01074472f, 0.01921640f, -0.16160919f, 
    -0.09696797f, -0.04532077f, 0.01449182f, 0.17164661f, -0.05041065f, 0.03838471f, -0.02025464f, 0.11273358f, 
    0.22481644f, -0.04351859f, 0.12473944f, 0.01629677f, 0.00777100f, -0.06446745f, -0.01596016f, -0.01344977f, 
    0.07360688f, 0.34302813f, 0.05513418f, -0.06313192f, 0.01867709f, 0.08929995f, 0.00971736f, 0.08207381f, 
    0.05859908f, 0.01460202f, -0.07842363f, 0.00198300f, 0.00374149f, 0.09695980f, 0.00960789f, 0.06441713f, 
    0.09426641f, -0.01945907f, -0.09899773f, 0.03854406f, 0.30522808f, -0.12116466f, 0.12439276f, 0.18874815f, 
    -0.05310550f, -0.13868718f, 0.05408270f, 0.04935107f, 0.00709526f, 0.08936183f, -0.01373141f, -0.02577602f, 
    0.02397408f, -0.08068755f, 0.07432253f, -0.09213421f, 0.06302042f, 0.10134912f, 0.09038194f, 0.12897401f, 
    -0.15105648f, 0.11354350f, -0.10680625f, 0.02941893f, -0.36244100f, 0.12143258f, 0.01329490f, 0.02832673f, 
    -0.10063285f, 0.03999427f, -0.01271130f, 0.12042770f, -0.13317032f, -0.02055875f, 0.07246998f, -0.00502839f, 
    -0.06172175f, 0.04464870f, -0.01835980f, -0.01319538f, 0.05485054f, -0.05282392f, 0.10238538f, -0.13126293f, 
    0.04814170f, -0.05409184f, 0.01898549f, -0.06244448f, 0.02318258f, 0.09049513f, 0.06215968f, -0.02575450f, 
    -0.06102338f, -0.01956126f, -0.10215378f, -0.07110466f, 0.14350678f, -0.10244524f, 0.03528645f, 0.00737786f, 
    -0.02721511f, 0.45105365f, 0.06525058f, -0.11871366f, 0.28354388f, 0.03548665f, -0.06508327f, -0.02334583f, 
    -0.06354394f, -0.09698824f, 0.10805623f, 0.12840222f, 0.03727297f, 0.06638629f, -0.01355564f, 0.09724300f, 
    0.07387811f, 0.01366708f, 0.09235091f, 0.08663520f, 0.28583643f, -0.14436619f, -0.10307183f, 0.00347779f, 
    0.19322547f, -0.03205641f, 0.03607432f, -0.06150072f, -0.02814361f, 0.18511428f, 0.02800874f, 0.03304052f, 
    -0.00316340f, -0.08651902f, -0.04794901f, -0.04895065f, -0.01467514f, -0.01060042f, 0.06255023f, 0.14226942f, 
    -0.03002147f, -0.00475228f, 0.07904053f, 0.08874422f, -0.14662318f, 0.11385031f, 0.01963387f, 0.07764629f, 
    0.03458381f, -0.10474063f, -0.01748894f, 0.02826744f, -0.08491553f, 0.05906647f, 0.10821338f, 0.07621051f, 
    0.08513692f, 0.02398727f, 0.05526049f, -0.00694631f, 0.14969501f, -0.37608147f, -0.13918124f, -0.13666457f, 
    0.17721091f, -0.00475264f, 0.00870948f, -0.02051604f, -0.02601354f, 0.00079738f, 0.05736169f, 0.06808020f, 
    -0.06607038f, 0.15295757f, 0.01254559f, -0.03823242f, 0.08353107f, 0.10568612f, -0.06145283f, -0.10625347f, 
    -0.06704750f, -0.21929549f, 0.00463354f, -0.04956749f, 0.16228361f, 0.08343536f, 0.00600781f, -0.05080663f, 
    -0.03872484f, -0.06300893f, -0.08028997f, 0.03940815f, 0.02758184f, 0.05736462f, -0.01023111f, 0.01586706f, 
    -0.01450959f, 0.01843969f, -0.03849047f, -0.03699413f, 0.31321287f, -0.21979457f, -0.05518568f, -0.12519060f, 
    -0.08955625f, -0.09930552f, 0.08046508f, 0.02190334f, -0.03495578f, 0.09133288f, -0.02440087f, -0.05457392f, 
    -0.02828608f, 0.11396654f, 0.13670763f, -0.05140845f, 0.02023878f, -0.05117003f, 0.06283300f, 0.00906351f, 
    0.19047536f, -0.10013596f, -0.01599054f, 0.14606130f, -0.09277041f, -0.07877059f, 0.04350071f, 0.16487283f, 
    0.02823354f, 0.02698611f, 0.04044256f, -0.00582162f, -0.06075116f, 0.15100057f, 0.04382419f, 0.01966914f, 
    0.02733640f, 0.06607561f, -0.02533264f, 0.10321086f, -0.15522923f, 0.20457442f, -0.08556225f, -0.10615060f, 
    0.14904247f, 0.03672298f, 0.04775991f, -0.03565945f, 0.03269815f, 0.02896544f, 0.01164788f, 0.03988919f, 
    -0.03086746f, 0.02119188f, 0.08021383f, 0.04002670f, 0.02473458f, 0.04660257f, 0.02764140f, 0.11641913f, 
    -0.06502673f, 0.18184620f, -0.27076185f, -0.16201094f, 0.09029317f, -0.07215602f, -0.02994280f, -0.25514090f, 
    0.03620382f, 0.01385739f, 0.07161642f, 0.02943881f, -0.04641291f, 0.00494984f, 0.05003357f, -0.10005424f, 
    0.04687294f, 0.04360505f, 0.01025662f, 0.02128102f, 0.05647598f, -0.41097698f, -0.21901971f, -0.14651471f, 
    0.40325639f, 0.01232398f, 0.02073582f, -0.07299251f, -0.08566608f, 0.02471503f, 0.02968730f, -0.09714433f, 
    -0.06229882f, 0.01821776f, -0.04663740f, 0.01462197f, 0.05128059f, -0.05685461f, 0.03795481f, -0.11103940f, 
    -0.14043032f, 0.05464215f, 0.16818956f, 0.04764508f, 0.04665065f, 0.15673150f, 0.02581711f, 0.02085619f, 
    0.00853225f, -0.03781138f, -0.01465811f, 0.00014421f, -0.03251532f, 0.02928034f, -0.01618825f, 0.04059590f, 
    -0.01815535f, -0.01167934f, 0.02859875f, 0.00295646f, 0.04352946f, -0.10956319f, -0.06810832f, 0.01589127f, 
    0.10287575f, -0.04040426f, 0.02742259f, -0.02323367f, 0.10510356f, -0.05251710f, -0.05924464f, 0.09173697f, 
    -0.07279917f, 0.07908737f, 0.13094144f, -0.03577890f, 0.00229161f, 0.10692938f, 0.04658159f, -0.00626882f, 
    0.06620103f, -0.07818173f, -0.12145376f, -0.05126042f, 0.20166847f, 0.12926851f, 0.11696398f, 0.05419797f, 
    0.03933252f, 0.03527603f, 0.12483801f, 0.06507245f, 0.04303384f, 0.08089715f, 0.02411136f, 0.01966473f, 
    0.01583737f, 0.02304401f, -0.02954717f, -0.02719606f, 0.41815054f, -0.08773424f, -0.12228283f, 0.09842168f, 
    -0.31393382f, -0.19026102f, -0.26143536f, 0.03753104f, -0.02559154f, 0.10546211f, -0.04632599f, -0.00539726f, 
    -0.03690030f, -0.07199457f, -0.01877877f, 0.02591230f, -0.05753395f, 0.00772260f, -0.04711667f, -0.03657889f, 
    -0.13814236f, 0.00794899f, 0.02632171f, 0.10781282f, -0.13879345f, -0.02622571f, -0.04025506f, 0.04146986f, 
    0.06537310f, -0.06431589f, 0.01001984f, -0.06991307f, 0.00711494f, 0.04871405f, 0.09917040f, 0.01354505f, 
    -0.12181050f, -0.10653587f, -0.08273716f, -0.03337506f, -0.18503310f, 0.20900203f, 0.05525610f, -0.11011165f, 
    0.12520742f, -0.09418827f, -0.04105042f, -0.15669656f, 0.09881322f, 0.09488261f, -0.01502236f, 0.04140502f, 
    0.03707789f, -0.02144461f, 0.00135132f, 0.00089915f, -0.02415964f, -0.02244461f, 0.04852305f, 0.06752270f, 
    0.18300809f, -0.01386905f, 0.00054834f, -0.05327440f, 0.03376641f, -0.09991107f, -0.17569241f, 0.05903447f, 
    0.08524108f, -0.07721688f, -0.03176102f, -0.09973951f, 0.07458644f, -0.06442363f, 0.01731217f, 0.09334127f, 
    -0.03549538f, 0.10236721f, 0.01018059f, 0.11906008f, 0.11463937f, 0.03230644f, 0.26502669f, -0.03960998f, 
    -0.22561134f, -0.04627311f, 0.11584093f, 0.00185141f, 0.15320650f, -0.01030882f, 0.10349662f, 0.05442548f, 
    0.03374870f, 0.01721044f, 0.03717330f, -0.00789554f, -0.06086837f, -0.00920850f, 0.05924714f, 0.05007707f, 
    0.26586613f, 0.15251592f, -0.19814697f, -0.04081542f, -0.05589992f, 0.07123706f, -0.13710269f, -0.07862731f, 
    0.04748411f, -0.03201543f, 0.00745839f, -0.10330482f, 0.08061524f, 0.03955982f, 0.10036029f, -0.05389925f, 
    -0.07374579f, -0.05363373f, 0.02806165f, 0.01083580f, -0.12359488f, -0.06904507f, 0.29668710f, -0.11097743f, 
    -0.23892646f, -0.05438452f, 0.07810903f, 0.10304926f, 0.00249622f, 0.05539052f, 0.14659856f, 0.08213340f, 
    -0.16726595f, -0.02436498f, 0.04235443f, -0.12393708f, 0.06640982f, -0.08320603f, 0.05594572f, -0.06847733f, 
    -0.28876582f, 0.13423635f, 0.15188754f, 0.14743079f, -0.04303082f, 0.12087418f, 0.04980890f, -0.04560285f, 
    0.03783570f, -0.05083146f, -0.06205825f, 0.03487793f, 0.00959059f, -0.02954786f, -0.02749664f, 0.00718075f, 
    0.06059391f, 0.02844426f, 0.06168060f, -0.08612334f, -0.06350517f, 0.39253560f, -0.17952038f, 0.08909442f, 
    0.12592490f, -0.15732256f, -0.00320431f, 0.03572350f, 0.08064914f, 0.13628598f, 0.06669341f, 0.04897147f, 
    0.11914536f, -0.02199525f, -0.09092608f, 0.07507995f, 0.02697426f, -0.10146873f, 0.04896655f, 0.03457903f, 
    0.25785512f, 0.16313589f, -0.16383293f, -0.11974794f, -0.23327704f, -0.01235327f, -0.02439092f, 0.11655338f, 
    0.03336709f, 0.05781785f, -0.02918539f, -0.07693429f, 0.10671342f, -0.00131774f, 0.08229538f, 0.11010200f, 
    0.09318534f, 0.12990215f, -0.07098326f, -0.04980600f, 0.24672309f, 0.33618551f, 0.02056960f, 0.08111636f, 
    -0.11059714f, -0.16913821f, -0.11806694f, -0.06762423f, 0.01310009f, 0.05097160f, -0.07350889f, -0.04561742f, 
    0.00960606f, 0.00238189f, 0.04088692f, 0.06619295f, 0.10137427f, 0.03016980f, 0.02509572f, 0.02931684f, 
    -0.07842991f, 0.08395091f, 0.13035464f, 0.00644022f, 0.15718438f, 0.07486547f, 0.02969502f, 0.01559457f, 
    -0.03584672f, 0.06673691f, 0.02837675f, 0.05091637f, 0.11789627f, -0.01218046f, 0.07462402f, 0.05055558f, 
    0.05415040f, 0.05864048f, 0.06681962f, 0.01143152f, -0.25213620f, 0.32270694f, -0.39778087f, -0.25044799f, 
    0.31038773f, -0.12869476f, 0.13235240f, -0.07031469f, 0.11615411f, 0.11743289f, 0.02916489f, -0.02682920f, 
    0.10589023f, -0.02886569f, 0.06433169f, 0.00502679f, 0.05193210f, -0.10072085f, 0.16597043f, -0.10822803f, 
    0.17167343f, 0.22353506f, 0.05816527f, -0.09651878f, -0.30569535f, -0.09315339f, 0.00242340f, 0.05952728f, 
    0.00166779f, -0.03018292f, -0.12253380f, -0.03297371f, 0.05420269f, -0.01894321f, -0.01518801f, 0.07692861f, 
    0.05126742f, 0.00094560f, 0.01331704f, 0.03578609f, -0.02441363f, 0.02441662f, 0.13205793f, -0.01946056f, 
    -0.25403124f, 0.12156018f, 0.06543425f, 0.12359809f, -0.00452497f, 0.00807138f, 0.08634602f, 0.06765562f, 
    0.07888294f, -0.09388106f, 0.05628119f, 0.00405010f, 0.03069293f, -0.05334134f, -0.01417035f, 0.13939384f, 
    0.06541424f, -0.17696682f, -0.17332862f, -0.04871830f, 0.26826799f, 0.19451083f, 0.07647362f, 0.01790958f, 
    -0.00775953f, 0.02685681f, 0.11911291f, -0.00525174f, -0.05040212f, -0.06295921f, -0.00249226f, 0.12235130f, 
    0.11787102f, 0.03465419f, -0.13774379f, 0.01902015f, 0.33072957f, -0.12816428f, 0.12301636f, -0.05225828f, 
    -0.19427465f, 0.02676392f, -0.01287966f, 0.00436269f, 0.08301459f, -0.04953818f, -0.02012394f, -0.04438217f, 
    0.02573290f, 0.01740744f, 0.06777326f, -0.04683453f, 0.01362924f, 0.07306889f, 0.11180703f, 0.06775767f, 
    -0.01508044f, -0.04712857f, 0.15269504f, -0.09852123f, -0.21722268f, -0.17478199f, -0.09417884f, -0.05583152f, 
    0.10156782f, -0.11317483f, 0.01861963f, 0.04802838f, 0.00432451f, 0.04944846f, 0.02692664f, -0.01762241f, 
    -0.00320623f, 0.03383571f, -0.08210833f, 0.04260283f, 0.36287609f, 0.03505792f, -0.02552825f, 0.07471357f, 
    -0.37183133f, -0.12503174f, -0.17016928f, -0.02402195f, 0.04069751f, 0.09558569f, 0.05481251f, -0.06476180f, 
    0.04592150f, -0.03307016f, 0.02698008f, -0.06724077f, 0.03348083f, 0.01885383f, -0.06829049f, 0.04272828f, 
    -0.01687102f, 0.01260577f, -0.09217621f, -0.06635721f, 0.03821974f, 0.00944997f, -0.02916221f, 0.03739111f, 
    -0.01135274f, -0.08986107f, -0.02673226f, 0.12662715f, -0.00228015f, 0.09427715f, 0.01275357f, 0.11201800f, 
    -0.03042153f, -0.01791272f, 0.14568953f, 0.01389624f, -0.10178627f, -0.11002661f, -0.20587572f, -0.18791291f, 
    0.10903253f, -0.02976927f, 0.16699758f, -0.02989479f, -0.05079173f, 0.15636502f, 0.07044952f, -0.11187527f, 
    0.02986129f, -0.02220434f, 0.05998901f, 0.18638855f, 0.07612570f, -0.05169459f, 0.06412645f, 0.15353708f, 
    0.17442338f, 0.03820711f, 0.07994951f, -0.12423984f, 0.03821996f, 0.08723492f, 0.06459250f, 0.06095505f, 
    -0.01639492f, -0.00632474f, 0.04734025f, 0.10247548f, 0.08105812f, -0.07836580f, -0.01802715f, 0.04565834f, 
    0.04166837f, -0.05565917f, 0.13648823f, 0.03653689f, -0.01158138f, 0.14064057f, 0.15296918f, 0.12074846f, 
    -0.32550895f, 0.16349791f, 0.10008784f, -0.02521977f, -0.03937161f, -0.05792428f, 0.07125776f, 0.07711280f, 
    -0.04954579f, 0.06490950f, 0.08533323f, -0.09977368f, -0.04522510f, 0.10640462f, -0.05247748f, -0.05621780f, 
    0.23746397f, 0.14003161f, -0.00590210f, 0.07404769f, -0.09010430f, 0.10815902f, 0.08874231f, -0.02548217f, 
    -0.06375685f, 0.03435318f, 0.06498343f, -0.01214664f, -0.01965984f, 0.00481968f, 0.03635193f, 0.00004715f, 
    0.05589329f, -0.05715227f, -0.00438388f, -0.06272715f, 0.05528585f, 0.16383980f, -0.02289275f, 0.06871047f, 
    -0.24800573f, 0.15958446f, 0.04219093f, 0.01668925f, -0.05683525f, 0.01513314f, -0.00930162f, 0.00573169f, 
    -0.00010034f, 0.08080722f, 0.00525716f, 0.04194022f, -0.03860459f, 0.02974415f, 0.01714550f, 0.04317918f, 
    0.26256996f, 0.02320150f, 0.05061422f, -0.03652116f, 0.09782191f, 0.08745417f, 0.07625143f, 0.03558834f, 
    0.01852791f, 0.03112775f, -0.00128370f, 0.02459907f, 0.16004878f, 0.03439942f, 0.02280372f, 0.04408570f, 
    -0.00860114f, -0.03637174f, 0.01846658f, -0.05668123f, 0.37417802f, -0.01676103f, 0.05692956f, 0.09874664f, 
    -0.17202733f, 0.15310873f, 0.07643306f, -0.01107076f, -0.01843112f, 0.06419875f, 0.06980536f, 0.02349497f, 
    -0.00614751f, -0.00928904f, 0.00115644f, 0.04019275f, 0.00639298f, 0.04173278f, -0.05648338f, 0.01975133f, 
    -0.51345479f, -0.45523673f, -0.19441783f, 0.09328266f, 0.14777005f, -0.00526808f, 0.06472870f, -0.16029461f, 
    0.04275402f, 0.01456561f, -0.02729966f, 0.11854643f, 0.07300506f, 0.06520864f, -0.06999240f, 0.05851223f, 
    -0.00897767f, -0.05529461f, -0.10262739f, -0.00164714f, -0.20220783f, 0.19621922f, -0.02396043f, -0.11620758f, 
    -0.12394336f, 0.05762931f, 0.23434554f, -0.04470665f, -0.05174717f, 0.01822020f, 0.01163259f, 0.02129493f, 
    0.07316891f, -0.13540779f, 0.12431616f, -0.06640495f, 0.02099873f, -0.00052694f, 0.05667853f, -0.04287797f, 
    -0.10826476f, 0.03942353f, 0.02707038f, -0.36541745f, -0.20994344f, -0.01347318f, -0.10754383f, 0.17128210f, 
    0.06156292f, 0.03279621f, 0.05638175f, 0.13953280f, -0.01465999f, -0.02723662f, 0.01353660f, 0.09514096f, 
    0.06362330f, 0.02693729f, 0.06627843f, 0.12723430f, -0.13819951f, 0.25958413f, 0.09874087f, 0.11083969f, 
    -0.24891892f, 0.13885185f, 0.07259975f, -0.00004792f, 0.11166310f, -0.04527580f, -0.02151456f, 0.02012666f, 
    -0.08624197f, 0.06338472f, 0.08448017f, 0.03455583f, 0.03440563f, 0.05593569f, 0.06490725f, 0.00648334f, 
    0.17238095f, 0.04311407f, -0.01162835f, -0.09642358f, -0.34380728f, 0.16340315f, 0.04403703f, 0.02147863f, 
    -0.03472874f, 0.06114881f, 0.07920001f, 0.02551813f, -0.00881585f, 0.03788814f, -0.07552817f, 0.07013174f, 
    -0.03991633f, 0.02499455f, -0.03077023f, 0.02722175f, 0.29099911f, -0.18679173f, 0.01285312f, 0.19307061f, 
    0.13185309f, 0.02472172f, -0.04168411f, -0.05566515f, -0.13569650f, 0.16914347f, -0.06832719f, 0.05071228f, 
    0.02520861f, 0.03095170f, -0.02543998f, -0.05567271f, -0.14430456f, -0.01035098f, -0.07612211f, -0.05705589f, 
    -0.10339341f, 0.09771457f, 0.06271505f, -0.03828192f, 0.13475907f, -0.00985037f, -0.06995643f, -0.04025296f, 
    -0.00670611f, -0.05126631f, 0.01349560f, -0.07206319f, -0.01213891f, 0.11590611f, 0.05740355f, -0.07283533f, 
    -0.08822951f, -0.03347357f, 0.04574671f, 0.02020202f, -0.02594836f, -0.17811677f, -0.16619293f, 0.06444323f, 
    0.15561211f, 0.04488939f, 0.07748342f, -0.01683059f, -0.04566050f, 0.13940071f, 0.01653754f, 0.18540242f, 
    0.06801734f, 0.13918415f, 0.05488672f, -0.07007696f, -0.09017046f, 0.03809737f, -0.05928519f, 0.00817455f, 
    0.14860263f, 0.01957895f, 0.12876625f, 0.06976881f, 0.04980607f, 0.09989975f, 0.14032993f, -0.00815992f, 
    -0.02424957f, -0.09744268f, -0.07364305f, 0.01611635f, -0.01206595f, -0.08997558f, -0.04702737f, -0.02182239f, 
    0.02238422f, -0.00925022f, 0.02602168f, -0.03960792f, 0.04270494f, 0.23573501f, -0.16697262f, -0.18429539f, 
    0.04319649f, 0.14546183f, 0.06508972f, -0.11927321f, -0.03207714f, -0.09753612f, -0.08492723f, 0.13569607f, 
    -0.03200796f, 0.12207150f, 0.12844169f, 0.06454042f, 0.12335374f, 0.05327870f, -0.04683192f, -0.04506244f, 
    -0.32405996f, -0.03729856f, 0.03283045f, 0.24247159f, 0.08035956f, 0.05538883f, -0.06246057f, 0.03903579f, 
    0.06640758f, -0.15106227f, 0.05753230f, -0.02398303f, 0.02178682f, 0.01873833f, -0.09327900f, 0.06115356f, 
    -0.13080721f, -0.00566409f, 0.03783011f, 0.04474403f, -0.11804099f, 0.23485258f, -0.25677752f, -0.15680405f, 
    -0.07374492f, -0.01449884f, -0.10769650f, 0.00016905f, -0.01250883f, -0.05429525f, 0.01500482f, -0.00613434f, 
    -0.03326007f, -0.05193263f, 0.02725627f, -0.00411637f, 0.18149182f, -0.01137116f, -0.01983751f, 0.13711819f, 
    -0.09182598f, 0.00212751f, -0.02586490f, -0.29954052f, 0.01431641f, 0.06002343f, 0.04213513f, 0.06719331f, 
    -0.01845567f, -0.02798764f, -0.00766962f, -0.01882728f, -0.09348845f, 0.03450717f, -0.02604214f, 0.03667999f, 
    0.00307959f, 0.08821905f, 0.02708803f, 0.02710671f, 0.03550545f, -0.14160338f, -0.12620659f, 0.11067549f, 
    0.23547065f, -0.08927266f, -0.04012355f, 0.06131247f, -0.07854781f, -0.02404125f, 0.05787248f, -0.00728952f, 
    0.10312127f, 0.02120435f, 0.03443068f, 0.05645214f, 0.09990163f, -0.00477907f, 0.00100325f, 0.09557389f, 
    -0.01258858f, 0.12162893f, 0.18626611f, 0.05784782f, -0.00862988f, -0.03249368f, 0.01907229f, 0.13822402f, 
    -0.06304415f, -0.05454549f, 0.00915055f, -0.00869931f, 0.01610017f, 0.04475856f, -0.13656946f, -0.04055313f, 
    0.07200771f, -0.12920091f, 0.09476145f, 0.05113945f, 0.35819009f, -0.32236800f, 0.11540537f, 0.20686029f, 
    0.11501446f, -0.11068130f, 0.04083923f, -0.06623834f, -0.06058268f, 0.14251383f, -0.10739768f, -0.04809206f, 
    0.11178675f, -0.06887692f, 0.03822590f, -0.02434298f, 0.02068400f, 0.05234913f, -0.09657550f, 0.07519354f, 
    0.03727505f, 0.22785184f, 0.02959470f, -0.23159620f, 0.01838539f, 0.00860134f, -0.05806034f, 0.01026202f, 
    0.14013602f, 0.02933546f, 0.10124393f, -0.02816551f, 0.05276537f, 0.02381331f, 0.02788812f, 0.06569715f, 
    -0.03403128f, 0.01552295f, 0.06826121f, 0.01848066f, -0.16236934f, -0.44108075f, -0.20297970f, -0.06605959f, 
    0.13324237f, -0.00877691f, 0.03132526f, 0.02882147f, -0.00121136f, -0.06410215f, 0.00072768f, -0.06660521f, 
    0.07264712f, -0.00600130f, 0.07372083f, 0.08657895f, 0.13728441f, -0.03436486f, -0.01204596f, 0.03062341f, 
    0.02482798f, 0.14904700f, 0.06972235f, -0.14651707f, -0.01536395f, 0.00353543f, 0.06654389f, 0.09748507f, 
    -0.00210404f, -0.03468653f, 0.01107477f, -0.06061349f, -0.01628233f, 0.00710134f, -0.04675144f, 0.00189620f, 
    -0.00775805f, -0.08793800f, 0.11041315f, 0.06126729f, -0.12882297f, 0.00009102f, -0.20492174f, -0.26581657f, 
    0.00376640f, -0.06831407f, -0.05920558f, 0.02902495f, 0.04429794f, -0.04064311f, 0.17758672f, -0.01786042f, 
    0.15853913f, -0.05226197f, 0.08197555f, 0.01976470f, -0.08077022f, -0.05631352f, -0.01048597f, 0.20174956f, 
    0.11335573f, 0.05690428f, 0.06884985f, -0.26247087f, -0.24423525f, 0.02985783f, 0.07996845f, -0.07712560f, 
    -0.02895989f, 0.05189944f, 0.09475783f, 0.08141848f, 0.06115926f, -0.00386437f, 0.05388815f, -0.03778686f, 
    -0.01123044f, -0.01485394f, -0.04896246f, 0.18482512f, 0.53606737f, -0.19071577f, -0.21471259f, -0.06607550f, 
    0.23076825f, 0.03874318f, -0.03034349f, 0.06431305f, 0.05495923f, 0.18653286f, -0.00940577f, -0.07126552f, 
    -0.09027405f, 0.10708361f, -0.03789817f, -0.02688923f, 0.05917555f, 0.00146617f, 0.01048727f, 0.04561328f, 
    0.10556988f, 0.05269485f, -0.10135197f, -0.12553219f, 0.17745675f, 0.10617635f, 0.01123246f, -0.04973059f, 
    -0.00908500f, -0.06054359f, -0.06165842f, 0.10811040f, 0.02744729f, 0.08468546f, 0.12572780f, 0.06703231f, 
    0.04527041f, 0.00291630f, -0.15672149f, -0.04720791f, 0.05325412f, -0.07667121f, 0.36799976f, 0.11555047f, 
    0.16625744f, -0.01042084f, -0.07377812f, -0.00797137f, -0.00008402f, 0.14618528f, 0.01915075f, -0.06920104f, 
    -0.01228741f, 0.07583412f, 0.03826241f, -0.04634906f, 0.02839025f, 0.03364672f, -0.00748532f, -0.08442493f, 
    -0.01189078f, 0.02383308f, -0.04347070f, -0.04177805f, 0.01634879f, -0.03718229f, 0.00226074f, -0.02085862f, 
    -0.04235920f, -0.03995540f, -0.00483750f, -0.00283147f, 0.01023171f, -0.03375230f, -0.00254894f, 0.01051582f, 
    -0.00615745f, -0.03964520f, -0.01010552f, 0.01316539f, 0.00717739f, -0.00092071f, 0.02981347f, 0.03309720f, 
    -0.01306797f, -0.03096795f, -0.03433957f, -0.01680512f, -0.02470751f, -0.00081161f, -0.00737842f, 0.00269779f, 
    -0.04159346f, 0.00827124f, 0.00630316f, -0.00636525f, 0.03329765f, -0.00788587f, 0.02200307f, 0.00529409f, 
    0.02584119f, 0.01890196f, -0.03733046f, -0.00321172f, 0.00864249f, -0.00607912f, -0.00174398f, -0.02322268f, 
    0.02259636f, -0.02868898f, -0.03029556f, 0.02362559f, -0.03002588f, 0.00507795f, -0.04415133f, 0.00991847f, 
    -0.00898885f, 0.02916987f, 0.01971157f, 0.02910622f, 0.01564026f, -0.02157390f, -0.01026225f, 0.01224570f, 
    0.00464079f, -0.04422676f, -0.00860726f, -0.00672210f, -0.00469786f, -0.02122327f, 0.02229947f, -0.00216937f, 
    -0.04189225f, -0.02120160f, -0.01969658f, -0.04010154f, -0.02426525f, -0.01327416f, -0.01074453f, 0.02756657f, 
    -0.03961411f, 0.01180565f, -0.03213223f, -0.01060478f, -0.02609217f, 0.00917405f, 0.02806594f, -0.04101645f, 
    0.01674356f, -0.01913876f, 0.03232408f, -0.00317155f, -0.03284017f, -0.02767699f, 0.00749031f, -0.00185117f, 
    0.03254130f, -0.04468862f, -0.02221660f, 0.00541710f, -0.01036952f, -0.03172541f, 0.01470085f, 0.03043407f, 
    0.02161820f, 0.01562225f, -0.03389452f, 0.01361141f, -0.00136021f, -0.02973707f, -0.01885087f, -0.00771408f, 
    0.01647952f, -0.02128877f, 0.01653192f, -0.01577179f, -0.01312050f, -0.03989541f, 0.02175189f, -0.01701907f, 
    0.01992596f, -0.02224633f, -0.00863099f, 0.02969653f, -0.00080299f, -0.04470562f, 0.03249158f, -0.00829508f, 
    0.02088241f, -0.02641666f, -0.03955732f, -0.01141090f, -0.02863836f, 0.02414197f, 0.02450399f, -0.02997819f, 
    -0.03883470f, -0.02254524f, 0.00580474f, 0.01785992f, 0.00295089f, 0.01335147f, -0.03562053f, -0.03441455f, 
    -0.04413643f, -0.02062790f, 0.02232595f, 0.02831742f, 0.00591903f, -0.00764530f, -0.01740092f, 0.02075998f, 
    -0.04432093f, 0.00744170f, 0.02032064f, -0.01482528f, 0.03037384f, 0.01811890f, 0.00381225f, 0.00334899f, 
    -0.01927674f, -0.03415647f, -0.03487110f, -0.03520286f, 0.03258555f, 0.00917203f, 0.00515122f, 0.02770305f, 
    0.00995719f, 0.03173912f, -0.00236547f, 0.03208623f, 0.00568861f, -0.02393235f, 0.01338486f, 0.01260267f, 
    -0.03018293f, 0.01261059f, -0.03155803f, 0.01681354f, -0.02713975f, -0.01197855f, 0.02936658f, -0.00084676f, 
    -0.04447221f, 0.02427677f, -0.00614731f, 0.00260454f, 0.00437930f, 0.02587314f, -0.03589090f, 0.00698091f, 
    -0.01119304f, -0.00500583f, -0.03691690f, -0.01816780f, 0.01377965f, 0.02469293f, -0.00606181f, 0.02230957f, 
    0.02304945f, 0.02404040f, -0.04306753f, 0.03127027f, 0.00345137f, 0.01810549f, -0.02747403f, 0.00768880f, 
    -0.03245460f, -0.03851413f, -0.04174658f, -0.00811323f, -0.02015176f, -0.00833270f, -0.02131082f, -0.03588162f, 
    -0.03846145f, -0.01443128f, -0.00803082f, -0.03061955f, 0.02744334f, -0.02169675f, 0.01380140f, 0.00794100f, 
    0.00606039f, -0.04084521f, 0.02853430f, -0.02237366f, 0.02024969f, -0.01412710f, 0.03275996f, -0.02756929f, 
    -0.00881066f, 0.00135035f, 0.01159589f, 0.01122004f, 0.01696858f, -0.03155940f, 0.02682741f, 0.01016886f, 
    -0.03988558f, 0.00499242f, -0.02844623f, -0.01822363f, 0.02242455f, -0.03990168f, 0.02279051f, -0.04184898f, 
    0.00588645f, -0.02501965f, -0.00233093f, -0.01592773f, -0.04379487f, 0.02231245f, -0.02160036f, -0.02531416f, 
    -0.04223094f, 0.00488367f, -0.04520873f, 0.00248066f, -0.02280196f, -0.04274341f, 0.01861791f, 0.01693378f, 
    0.01002499f, -0.03433662f, 0.02534796f, -0.04178610f, 0.01688389f, 0.02941109f, -0.02136778f, -0.03839863f, 
    -0.02086862f, 0.03147909f, -0.00901656f, -0.00562253f, -0.02506619f, 0.01267572f, -0.01483668f, -0.03045559f, 
    -0.00348528f, -0.03275417f, -0.01407375f, -0.03032406f, -0.00660205f, 0.01615956f, -0.04049876f, -0.01729898f, 
    -0.03725521f, 0.03203253f, -0.00195007f, -0.03462566f, -0.04141901f, 0.01609991f, -0.02119406f, 0.02460430f, 
    0.03150212f, -0.02687931f, -0.03340298f, -0.03709556f, -0.02895644f, -0.01372848f, 0.01358242f, -0.00502151f, 
    -0.02708032f, -0.00282933f, -0.00702515f, -0.00348977f, -0.03782628f, -0.00350684f, -0.02958722f, 0.03045748f, 
    -0.03116450f, 0.00465649f, -0.01788172f, -0.04259836f, 0.00510415f, 0.03227762f, -0.02077536f, -0.03491209f, 
    0.03054650f, 0.02709399f, 0.00075602f, -0.00413629f, -0.01968031f, -0.03231852f, -0.04416406f, 0.02621437f, 
    0.02857785f, -0.00308360f, -0.04371671f, 0.02843036f, -0.03977215f, -0.00245389f, -0.01410298f, 0.02338554f, 
    -0.00769038f, -0.00088063f, -0.02181652f, 0.01975794f, -0.01031819f, 0.01473748f, -0.04356258f, -0.00959938f, 
    0.03329611f, 0.01367184f, -0.03880282f, -0.02366828f, -0.03491473f, -0.02150417f, 0.02883615f, -0.03286570f, 
    -0.03277090f, -0.04508236f, 0.01961012f, 0.01934665f, -0.02402016f, -0.00724471f, -0.00818885f, -0.02208338f, 
    -0.01317169f, -0.03594044f, -0.02805186f, 0.01816091f, -0.01685868f, -0.01662729f, -0.00606847f, -0.01770144f, 
    0.01643549f, -0.03602050f, -0.00428549f, 0.03330937f, 0.00347435f, -0.02150337f, 0.02631591f, 0.01075032f, 
    -0.00437934f, 0.01985552f, -0.03650884f, -0.02249739f, 0.00638854f, 0.00726191f, -0.01202606f, 0.01204838f, 
    0.02641680f, -0.01056316f, -0.02152652f, -0.03024697f, -0.01527846f, -0.00354702f, 0.00947915f, -0.01584838f, 
    0.02661468f, 0.00063565f, -0.02915760f, 0.02614724f, -0.03112815f, -0.01769530f, 0.02472197f, -0.01525340f, 
    0.00449690f, 0.00839188f, 0.00966760f, 0.01398644f, -0.04446458f, 0.02834764f, -0.04071855f, 0.02703442f, 
    0.03061229f, -0.02371181f, -0.01370614f, -0.02511149f, -0.02613342f, -0.01041036f, 0.00546819f, 0.01606703f, 
    0.00325584f, 0.02377219f, -0.00461571f, -0.01634760f, 0.03121532f, 0.01922285f, -0.00284036f, -0.01620930f, 
    -0.00398098f, -0.02973836f, -0.03934807f, 0.02823132f, -0.03502923f, -0.01638724f, -0.01497932f, 0.01435820f, 
    -0.01864308f, 0.02563491f, -0.01692992f, -0.00289653f, -0.02868735f, 0.03056629f, 0.00455253f, -0.00974019f, 
    -0.01472251f, 0.02189698f, 0.01086383f, 0.00932209f, 0.00562808f, -0.01717846f, -0.01778349f, 0.00088863f, 
    -0.01035331f, -0.02277959f, -0.00007790f, -0.03396371f, -0.04329216f, -0.01473254f, -0.04141555f, 0.02696065f, 
    -0.03028785f, 0.02141889f, 0.01227381f, -0.00395404f, 0.02730294f, -0.04210306f, -0.02363098f, 0.02382677f, 
    0.03162249f, -0.03975344f, -0.04543044f, 0.03117816f, -0.04423211f, -0.01277965f, 0.02300699f, -0.00493296f, 
    -0.01788374f, 0.02336693f, -0.02247968f, -0.00173283f, 0.00883480f, -0.01646057f, -0.04150987f, 0.02952387f, 
    0.00909178f, -0.02578222f, -0.00555652f, -0.01185717f, 0.02060027f, 0.03252946f, 0.01129449f, 0.00608924f, 
    0.00646747f, 0.01714877f, 0.03328463f, 0.00018093f, 0.00467758f, 0.00522968f, 0.02498345f, -0.04509223f, 
    0.01890876f, -0.04171298f, 0.02896306f, 0.01603541f, -0.04406300f, 0.00815654f, 0.01097322f, 0.01149439f, 
    0.00436412f, 0.02071891f, -0.02103009f, 0.00524149f, 0.01289294f, 0.02859081f, -0.03934784f, -0.03140476f, 
    -0.01780573f, 0.00393435f, -0.03934830f, 0.00287127f, 0.03198685f, -0.03573833f, -0.01255736f, -0.03337085f, 
    0.02720546f, 0.02930841f, -0.00249335f, -0.01730690f, -0.02621598f, 0.02933232f, -0.02031173f, 0.02578472f, 
    -0.01618269f, -0.02781912f, -0.02023300f, -0.00473271f, -0.02082375f, -0.01409526f, -0.00118979f, 0.00109661f, 
    -0.03057430f, -0.03728940f, 0.00717961f, -0.00667980f, -0.03999038f, 0.02919399f, 0.03056976f, 0.01629409f, 
    -0.01895499f, -0.01459284f, 0.02382912f, -0.04298898f, -0.01884118f, 0.01838748f, 0.01776821f, 0.01798006f, 
    -0.01409918f, -0.01186944f, 0.01564040f, 0.03140303f, 0.02048514f, -0.03453205f, 0.00428046f, -0.02871197f, 
    -0.00382379f, 0.00419995f, 0.00587292f, 0.01684586f, 0.00528575f, 0.02823490f, -0.04449920f, -0.03941824f, 
    -0.02238433f, -0.03431989f, -0.02623272f, -0.02703934f, -0.01141999f, -0.01167041f, -0.01214589f, 0.02050598f, 
    0.01224508f, -0.00161747f, -0.04308339f, 0.00249172f, 0.02803289f, -0.01442756f, -0.01186610f, -0.02024807f, 
    -0.01260459f, -0.04377280f, -0.01342199f, -0.02899351f, 0.02543182f, 0.02195120f, -0.04503183f, -0.04295805f, 
    -0.01490655f, 0.01567421f, 0.01114060f, 0.00898353f, -0.04395910f, -0.02984387f, -0.02704746f, -0.01054557f, 
    0.02804784f, -0.03392690f, -0.01923982f, -0.03605674f, 0.02255739f, 0.02189220f, -0.00851522f, -0.03448889f, 
    0.01175627f, -0.02229331f, -0.02185598f, 0.02389913f, -0.02557497f, 0.00302719f, 0.00709000f, -0.02469983f, 
    0.03021829f, -0.02090209f, -0.00822531f, -0.03826365f, -0.01465855f, 0.02544780f, -0.00868856f, -0.03045252f, 
    -0.00354615f, -0.02077667f, 0.01315308f, -0.02957619f, -0.04050777f, -0.00872133f, -0.01446074f, 0.02696037f, 
    0.01445851f, 0.01833943f, -0.02857579f, 0.00021562f, -0.03667168f, 0.03057390f, -0.01626528f, -0.03690786f, 
    0.17286180f, 0.20567328f, 0.06472611f, 0.02211973f, -0.07489616f, -0.04144030f, 0.04580914f, -0.02328221f, 
    0.02817252f, -0.04503204f, 0.00379241f, -0.00636024f, 0.11101345f, 0.01862328f, 0.11179243f, -0.00837252f, 
    0.00193444f, 0.02811130f, 0.07652454f, -0.07980279f, -0.14129230f, 0.02425168f, 0.17044103f, -0.07560285f, 
    0.07340953f, 0.00874540f, -0.18150987f, -0.04831995f, 0.01294084f, 0.08924663f, 0.07752711f, -0.00034044f, 
    0.12782098f, 0.06629565f, -0.01824684f, 0.12814312f, -0.09304575f, -0.11453512f, -0.12300023f, -0.05315897f, 
    0.04132530f, -0.26405966f, -0.04624460f, -0.21288668f, -0.22479871f, -0.15268490f, -0.04313569f, 0.01974589f, 
    0.01362480f, 0.04601441f, 0.03561415f, 0.06842101f, -0.06023216f, 0.04271880f, -0.04590683f, 0.02587731f, 
    -0.00069534f, -0.08873354f, 0.11214003f, 0.01231215f, 0.10516710f, 0.25783369f, 0.16091542f, 0.06389632f, 
    0.16197670f, 0.06690875f, 0.13827419f, -0.06509037f, 0.01887123f, -0.02028225f, -0.08669908f, 0.05682812f, 
    -0.00033781f, -0.16379072f, -0.09508067f, -0.02728943f, 0.01937463f, 0.07240103f, -0.01225179f, -0.05691716f, 
    0.31977820f, 0.19327532f, 0.04683449f, 0.14319380f, 0.34802744f, 0.12118378f, 0.09660498f, -0.02358050f, 
    -0.09467398f, -0.14018534f, 0.05863436f, 0.01746518f, -0.03674333f, -0.03044526f, -0.08430862f, -0.04482746f, 
    0.03463740f, 0.04853850f, -0.04691739f, -0.06458441f, -0.01433673f, 0.26827803f, 0.10509437f, 0.10637727f, 
    0.15807390f, 0.03178208f, 0.05033783f, 0.00887914f, 0.02488242f, 0.01171418f, 0.02105882f, -0.01565383f, 
    0.05844082f, 0.00070235f, -0.03106006f, 0.13994236f, -0.08717183f, 0.08127706f, -0.02461832f, -0.00859689f, 
    0.09154013f, 0.08195759f, 0.01258898f, -0.05975883f, -0.17684324f, -0.07907572f, 0.00532344f, -0.01862330f, 
    -0.03690994f, 0.11057631f, -0.02802126f, 0.00025677f, 0.04106998f, 0.06061902f, 0.10729697f, -0.05934605f, 
    -0.09674810f, -0.05789528f, 0.00914291f, 0.04681822f, 0.41678429f, -0.03780700f, 0.12801816f, 0.15651359f, 
    0.19135526f, 0.15320793f, -0.03193712f, -0.00834496f, -0.04755434f, -0.02711436f, -0.08833424f, 0.06636350f, 
    0.00363121f, -0.05270907f, -0.01247753f, 0.05599187f, -0.07761761f, -0.04141800f, -0.00238117f, -0.00999980f, 
    0.36264497f, -0.12073859f, -0.04067890f, 0.00881645f, 0.02683445f, -0.01128711f, -0.05711065f, -0.06358582f, 
    0.04429919f, -0.00549059f, -0.06045850f, 0.00879261f, -0.09850956f, 0.00925646f, -0.02103290f, 0.01564277f, 
    0.14906991f, -0.07936043f, 0.04339830f, 0.06705675f, 0.01416430f, 0.20624894f, 0.18143199f, 0.06195143f, 
    0.29050925f, -0.01006445f, 0.07729433f, -0.11592288f, 0.09087378f, -0.01372955f, 0.02488521f, 0.10885518f, 
    -0.04215969f, 0.03392286f, 0.02856511f, 0.00082962f, 0.15159234f, 0.01627896f, -0.02966090f, 0.01828490f, 
    -0.08301149f, -0.07777929f, 0.03291968f, -0.25339940f, -0.28462800f, -0.09311305f, -0.05692469f, 0.05246959f, 
    0.04597028f, 0.01335904f, 0.00591865f, 0.07891472f, 0.10405494f, -0.07558724f, 0.00757876f, 0.06620779f, 
    0.08693782f, -0.06884380f, -0.02433597f, 0.03951740f, 0.01088300f, 0.03784191f, -0.10476788f, 0.14447810f, 
    -0.06302717f, 0.08941057f, -0.04481669f, 0.01792979f, 0.14311525f, 0.01937251f, 0.04625335f, -0.02081131f, 
    0.10780355f, 0.00291373f, 0.02818472f, 0.00817692f, -0.01396116f, -0.09230856f, 0.03440411f, -0.04504099f, 
    0.03120026f, 0.10001650f, 0.09775590f, -0.15396859f, -0.03285202f, 0.12173658f, 0.04329667f, -0.04201280f, 
    -0.07185727f, -0.04014401f, -0.06352775f, 0.03817021f, 0.05916730f, -0.07083052f, -0.10785031f, -0.02053806f, 
    0.04352167f, 0.09221322f, 0.06900030f, -0.07712577f, 0.00693234f, -0.08140466f, 0.29313716f, 0.01754422f, 
    -0.00299539f, 0.02788080f, 0.01584773f, -0.07986934f, 0.00215941f, 0.20389329f, 0.01284231f, 0.00710652f, 
    -0.00141585f, 0.06906138f, 0.03317779f, 0.06988025f, -0.02491481f, 0.08275145f, -0.01699530f, 0.01037658f, 
    -0.28742367f, -0.05194650f, 0.23507582f, -0.07618429f, -0.11537350f, 0.06556654f, 0.00117424f, -0.03506437f, 
    -0.02289921f, -0.03117613f, -0.02121116f, 0.00545613f, -0.09584031f, 0.12621595f, 0.12891473f, 0.00216218f, 
    0.00794074f, 0.04429888f, -0.06189189f, 0.05856433f, 0.53861040f, -0.00646401f, 0.16720909f, 0.07678454f, 
    0.19699810f, 0.07627583f, -0.03223138f, -0.04241056f, 0.02409714f, 0.23887518f, 0.03990766f, 0.03672656f, 
    0.03117440f, 0.07035060f, 0.03512749f, 0.00771608f, 0.01800901f, -0.12342568f, 0.03019430f, -0.01125245f, 
    0.16211921f, 0.11957939f, -0.04277831f, 0.09350190f, -0.09085703f, 0.05938764f, 0.10410523f, -0.02418398f, 
    -0.13724782f, -0.01729465f, -0.00443606f, 0.07836078f, 0.07446547f, 0.07790683f, 0.01211817f, 0.07514989f, 
    -0.06616487f, 0.05498331f, -0.03499708f, 0.03013427f, -0.14074686f, 0.02549909f, -0.19956678f, -0.19803891f, 
    -0.38021433f, -0.02259306f, 0.06122211f, 0.04187753f, -0.07474406f, 0.01527583f, -0.11218104f, 0.06161322f, 
    -0.00260221f, 0.08044921f, 0.04896688f, 0.00631167f, -0.00703072f, 0.10186916f, 0.08408300f, 0.11558672f, 
    -0.39001721f, -0.31352517f, 0.03419836f, -0.07425839f, -0.10521007f, 0.12360372f, -0.01347479f, -0.06547955f, 
    0.02644914f, 0.03787352f, 0.07181514f, 0.11670975f, 0.02311316f, -0.02768011f, -0.02050943f, 0.02862900f, 
    -0.05132679f, 0.06509607f, 0.04812531f, -0.02163276f, -0.15810406f, -0.13275050f, -0.21107863f, -0.00964246f, 
    -0.35307994f, 0.03995635f, 0.09338219f, -0.06717063f, 0.01219200f, -0.03946467f, -0.08064350f, -0.09330579f, 
    0.07845631f, 0.06854204f, 0.11590923f, 0.04538960f, 0.09626489f, 0.13278095f, 0.03688940f, 0.02995849f, 
    0.09303910f, -0.12816082f, -0.18529195f, -0.06254110f, -0.16521521f, -0.15651739f, -0.04908407f, 0.00245768f, 
    -0.04794412f, -0.09915669f, 0.14131677f, 0.12922043f, 0.01272544f, -0.03422193f, -0.13988614f, 0.05370924f, 
    -0.02736555f, 0.16311613f, 0.06996550f, 0.10004428f, 0.06001512f, -0.33788949f, 0.07309258f, -0.07139491f, 
    -0.00413547f, 0.03957556f, 0.03064577f, 0.00422011f, -0.04871661f, 0.01331166f, 0.08921358f, -0.01847826f, 
    0.02560572f, 0.01916048f, 0.02221370f, 0.03663740f, 0.02984811f, -0.05674784f, 0.09442028f, 0.07194401f, 
    -0.37899643f, -0.39164516f, 0.03145264f, -0.04519834f, -0.16617197f, 0.02897572f, -0.00842254f, -0.07991011f, 
    0.05188005f, -0.11345719f, -0.06263892f, -0.01319924f, -0.15641437f, -0.09587206f, -0.04727552f, -0.09291594f, 
    0.04564829f, 0.05889735f, 0.06192684f, 0.04890634f, 0.39004737f, -0.02867953f, 0.13003495f, 0.11723251f, 
    -0.01181681f, -0.04019246f, -0.00520025f, -0.06295270f, 0.10988680f, 0.08380166f, -0.01838667f, -0.05978433f, 
    -0.05762374f, -0.03994953f, 0.00715575f, -0.00113102f, -0.02227467f, -0.00729862f, 0.14624031f, 0.08176643f, 
    0.22237559f, 0.19546950f, 0.01259204f, -0.08045719f, -0.10175221f, 0.04518516f, 0.05276586f, -0.06012871f, 
    0.10020232f, -0.14294504f, -0.00824295f, 0.00164489f, -0.01363926f, -0.07229912f, -0.02473649f, -0.00387493f, 
    0.05598091f, -0.07014933f, -0.04648083f, -0.01635267f, 0.41779310f, -0.29332501f, 0.05486512f, -0.15551011f, 
    0.29205847f, 0.04304038f, 0.01559664f, -0.01411545f, -0.01055555f, 0.01084149f, 0.06012288f, -0.07760921f, 
    -0.03089345f, -0.05785553f, 0.00427018f, 0.05880101f, 0.13471808f, 0.06181160f, 0.03479087f, -0.01448262f, 
    -0.33821008f, -0.44801584f, 0.05050154f, -0.07994670f, -0.20291822f, -0.07440151f, 0.01086525f, 0.02043677f, 
    0.00853566f, -0.07277194f, 0.02111712f, 0.05559608f, -0.14908028f, -0.06672340f, 0.01021416f, -0.00624993f, 
    0.03702894f, 0.07110036f, 0.04229924f, 0.03811593f, -0.24153475f, -0.14301099f, -0.11905389f, -0.34727031f, 
    -0.22321171f, -0.07930803f, -0.04588114f, -0.04733850f, -0.07315040f, 0.01169948f, 0.03784903f, 0.05743938f, 
    0.10112169f, -0.15462796f, 0.07586728f, 0.01337098f, 0.00046484f, 0.11507881f, -0.09178521f, 0.03735583f, 
    -0.03827094f, 0.05169114f, 0.11407761f, -0.25851062f, -0.01225762f, 0.11513565f, 0.14418983f, -0.16401362f, 
    0.03048343f, -0.06568908f, 0.01196621f, 0.08710725f, 0.00282000f, -0.06109834f, -0.06303537f, -0.07264674f, 
    0.10608508f, 0.07500406f, 0.10623775f, 0.03856309f, 0.48152611f, -0.06202021f, 0.12162826f, -0.14614657f, 
    0.09996007f, -0.02963461f, -0.08126163f, 0.13165283f, -0.00044421f, 0.08407477f, -0.03751555f, 0.07545498f, 
    -0.06604693f, 0.03611568f, 0.05475609f, -0.01971610f, 0.04066266f, -0.07011313f, 0.01682095f, 0.03191553f, 
    0.22448736f, -0.12780705f, 0.04244125f, -0.02287690f, 0.03097646f, 0.08163428f, -0.02799745f, -0.02701986f, 
    -0.01621728f, 0.03524550f, 0.04851841f, 0.04026725f, -0.00045126f, 0.07882965f, 0.16190177f, 0.20601225f, 
    -0.03316484f, -0.02654160f, 0.04087764f, -0.01583927f, -0.04762607f, 0.01254283f, 0.19905743f, -0.01213924f, 
    0.07255977f, 0.00745936f, -0.07130765f, 0.00203083f, 0.07263798f, 0.08347235f, 0.00947490f, -0.15034011f, 
    -0.04546990f, 0.12053514f, 0.09023583f, 0.00814769f, 0.00418762f, 0.05588160f, -0.01834404f, 0.03224912f, 
    0.02345994f, 0.01445018f, -0.00873469f, 0.02926365f, 0.02014604f, 0.02973798f, -0.01126845f, -0.02972873f, 
    -0.01868426f, 0.02826149f, 0.03196416f, 0.02087398f, 0.01255510f, -0.02633729f, 0.01029048f, -0.01243092f, 
    -0.04019501f, 0.01904090f, -0.01582985f, 0.01822047f, -0.01517928f, -0.03958123f, -0.03993266f, 0.01270137f, 
    0.01173523f, 0.01222692f, -0.04229899f, 0.02464622f, -0.01035279f, -0.00506362f, 0.01588829f, -0.02775375f, 
    -0.01470398f, 0.02833307f, -0.00377590f, -0.00045076f, 0.01611316f, -0.01060812f, -0.03348133f, -0.02895691f, 
    0.00807577f, 0.02224215f, -0.03335361f, -0.01775537f, 0.01489046f, -0.01056037f, -0.03657963f, 0.00595640f, 
    -0.03017744f, -0.04720933f, -0.03093727f, 0.02784760f, -0.03452894f, -0.01915613f, 0.02938742f, -0.04510275f, 
    0.01252337f, 0.02666946f, 0.01316481f, -0.04672894f, -0.00866413f, 0.03180614f, 0.02382867f, -0.02626733f, 
    -0.00143107f, 0.02424674f, 0.02258286f, 0.00661578f, -0.02816855f, -0.03648348f, 0.00317409f, 0.00398411f, 
    -0.03734687f, -0.04506107f, -0.03848092f, -0.01960582f, 0.01398698f, -0.02729404f, 0.03253581f, 0.01289038f, 
    -0.00345498f, -0.02345533f, 0.00478076f, -0.03234597f, -0.00273637f, -0.00289620f, -0.00678317f, -0.02839987f, 
    -0.00395463f, 0.01164003f, -0.02159876f, -0.02825857f, 0.01390574f, -0.02487929f, 0.00032130f, 0.00042079f, 
    0.02865449f, -0.02551115f, 0.00664870f, 0.02940934f, 0.02430013f, 0.00368629f, -0.01275418f, -0.02382279f, 
    0.02664296f, -0.02831968f, -0.03995174f, -0.04796806f, -0.01364629f, -0.02751083f, 0.03020617f, -0.01051585f, 
    0.01238584f, 0.02235941f, -0.04135395f, 0.01091491f, -0.01044761f, 0.00562589f, 0.01023694f, 0.00188203f, 
    -0.04678042f, -0.03358974f, 0.01393787f, 0.01091308f, -0.00032959f, 0.02212102f, 0.00676862f, -0.00687544f, 
    0.01678555f, -0.00861926f, -0.03971438f, 0.00119654f, -0.03675998f, 0.00312770f, 0.02701034f, -0.01404782f, 
    -0.02704125f, -0.03808012f, 0.02204965f, 0.01740225f, -0.03508831f, -0.02636270f, -0.04186779f, -0.01492012f, 
    -0.02927752f, -0.04350743f, -0.03996562f, 0.00947213f, 0.02591236f, 0.00507968f, 0.03348339f, 0.01809990f, 
    -0.01644439f, 0.00620280f, -0.04395868f, -0.03298856f, -0.01543278f, -0.04427084f, 0.01256663f, -0.02833017f, 
    0.00821933f, -0.03879055f, -0.04679365f, -0.01847875f, 0.02001969f, -0.04802313f, -0.04040432f, -0.01505725f, 
    -0.03216372f, -0.01877056f, 0.00485698f, -0.01931971f, -0.03704557f, -0.01078184f, -0.03194942f, 0.02454707f, 
    -0.01054664f, 0.01160573f, 0.00135702f, -0.00607569f, -0.00846128f, 0.02914270f, 0.00159332f, 0.00065495f, 
    -0.02578346f, 0.01061083f, 0.00460582f, 0.01173434f, 0.00904476f, 0.00942590f, -0.00151220f, -0.00488039f, 
    -0.00951040f, 0.01603992f, -0.02275626f, 0.03308874f, 0.00950408f, -0.01194587f, 0.01989123f, -0.02159731f, 
    -0.03547142f, -0.02089353f, -0.04534067f, -0.03235986f, -0.02781643f, 0.02548285f, -0.04073688f, -0.02197120f, 
    -0.01293065f, -0.00955243f, 0.01277768f, -0.02135809f, -0.01841283f, -0.01476346f, 0.01448845f, -0.00391071f, 
    -0.02980639f, 0.02193823f, -0.02825865f, 0.00124295f, -0.01828372f, 0.01754602f, -0.02187556f, -0.03854390f, 
    0.02138516f, -0.01521835f, 0.01035438f, -0.03586343f, -0.02363625f, -0.03764626f, -0.04630516f, -0.01753286f, 
    -0.02205764f, 0.03311408f, 0.02750624f, -0.03531614f, -0.02747548f, -0.03729158f, -0.03486931f, 0.02342208f, 
    0.01580496f, 0.00219388f, -0.00817171f, 0.00840203f, -0.00053817f, -0.00363201f, 0.00375692f, -0.00760786f, 
    -0.01738625f, -0.02102429f, 0.01807779f, 0.00468195f, -0.03213850f, -0.03916063f, 0.02449958f, -0.02600058f, 
    -0.02659050f, 0.00203249f, -0.01078471f, -0.04101531f, 0.02546856f, -0.02764121f, 0.00102674f, 0.03222820f, 
    -0.02330903f, -0.01126501f, 0.02662371f, 0.00145119f, -0.02506596f, -0.00402545f, 0.00883653f, 0.00444495f, 
    -0.01218246f, 0.02530062f, 0.01067592f, -0.02857596f, 0.00898284f, -0.04068299f, -0.00989402f, -0.00604641f, 
    -0.04855987f, 0.01087862f, 0.01872952f, 0.01246577f, -0.01327323f, 0.01564117f, -0.04783761f, -0.02156319f, 
    0.02472985f, 0.00546907f, -0.03189390f, -0.02675020f, -0.04578099f, -0.03938011f, -0.02654421f, 0.02654586f, 
    -0.03545292f, -0.03343536f, 0.02853314f, 0.02423244f, -0.00441678f, 0.00471437f, -0.01373149f, 0.00005503f, 
    -0.03969875f, -0.04645338f, 0.01141247f, -0.00156464f, 0.01647216f, -0.00101561f, 0.02477109f, -0.00429869f, 
    -0.02507981f, -0.03221348f, -0.00305461f, 0.00704166f, -0.01018356f, 0.00559709f, 0.03071004f, -0.01125737f, 
    -0.04238277f, -0.02300040f, 0.01814472f, 0.02140046f, -0.00681609f, -0.04295402f, -0.02137732f, -0.02673277f, 
    0.02033851f, -0.04606048f, 0.00976648f, -0.02667528f, -0.03318333f, 0.00303178f, -0.02413822f, -0.02292177f, 
    0.00956850f, -0.04180389f, 0.01649738f, -0.04180704f, -0.00311957f, -0.00526571f, -0.01564478f, -0.01007030f, 
    -0.03751936f, 0.01916681f, -0.02354656f, -0.04265966f, -0.00064628f, -0.02180588f, 0.00146952f, 0.02437538f, 
    -0.00699629f, -0.02579235f, 0.01823135f, -0.01644306f, 0.02333047f, 0.03567645f, -0.00958256f, -0.03373350f, 
    -0.03745122f, 0.00787404f, 0.00375340f, 0.00805375f, -0.03370458f, -0.00766249f, 0.01896349f, 0.00959390f, 
    -0.02389337f, 0.01953840f, 0.03542629f, 0.00210619f, 0.02615020f, -0.03724679f, 0.00661197f, -0.03359076f, 
    -0.02657932f, -0.03073368f, 0.01951366f, -0.00597702f, -0.00985427f, -0.01692968f, -0.00491222f, -0.04281596f, 
    -0.00908778f, -0.01571614f, 0.02718393f, 0.01629288f, -0.02794021f, 0.03980675f, -0.01059245f, -0.01481728f, 
    0.02226980f, 0.00657395f, -0.01388489f, -0.03738213f, -0.02936837f, -0.01385440f, -0.01638413f, 0.02526523f, 
    0.00233072f, -0.01959297f, 0.02460210f, -0.01414338f, -0.01139729f, -0.01212280f, 0.00551235f, 0.01340571f, 
    -0.01288537f, -0.01295449f, -0.03000523f, -0.01033358f, -0.04543435f, 0.00003492f, -0.04038148f, -0.01530104f, 
    0.01766114f, -0.01309633f, -0.04420627f, 0.01141203f, -0.02104926f, -0.01528322f, -0.00091201f, 0.02897966f, 
    -0.02915285f, 0.01508926f, 0.02188060f, -0.01148729f, 0.01383366f, 0.01451796f, -0.03629235f, -0.02110705f, 
    0.01038302f, 0.00472804f, 0.00002585f, 0.02107661f, 0.01731408f, 0.01437700f, 0.02197741f, 0.01594541f, 
    -0.01749009f, -0.03944829f, 0.01524560f, -0.04467512f, 0.00604991f, -0.01089134f, -0.03229841f, -0.03435025f, 
    0.02245189f, 0.02853351f, -0.00514702f, -0.03634316f, 0.00651651f, 0.01712622f, 0.03176649f, -0.02427547f, 
    -0.03268956f, -0.02381119f, -0.03000891f, 0.01092493f, 0.00065364f, -0.02566831f, -0.02536870f, 0.00160476f, 
    -0.03539123f, 0.02684768f, 0.02703529f, 0.00878252f, 0.00578766f, 0.02491293f, -0.02165988f, -0.00659480f, 
    -0.00638238f, -0.03215386f, 0.00409956f, -0.03453925f, -0.01164805f, -0.04051410f, -0.04106408f, -0.02177623f, 
    0.01111282f, 0.01100103f, 0.01527000f, -0.04755274f, 0.01718875f, -0.02656578f, -0.00388021f, -0.03963263f, 
    0.01093822f, 0.01882705f, -0.04584960f, 0.00506609f, -0.03921107f, -0.03830719f, -0.01634175f, -0.00364175f, 
    -0.02100891f, 0.00821563f, -0.01812916f, 0.02233087f, -0.00374424f, 0.01675880f, -0.01618903f, 0.02620314f, 
    0.02048010f, -0.02529664f, -0.02624703f, -0.03898188f, -0.03515930f, 0.02818974f, -0.04343061f, -0.02500752f, 
    0.02303432f, 0.00924719f, 0.00946731f, -0.04761681f, -0.02928519f, 0.01167446f, -0.03160220f, 0.02094791f, 
    0.01313385f, 0.01086060f, -0.02420024f, -0.00958017f, -0.02211692f, 0.03026918f, -0.01805542f, -0.03109980f, 
    -0.03845565f, 0.00430602f, -0.03765890f, -0.04252477f, 0.02051965f, -0.02400061f, -0.00180541f, 0.02111806f, 
    0.00656123f, 0.00507371f, 0.00990931f, 0.00778935f, -0.03697646f, 0.02050985f, -0.02541333f, -0.02305193f, 
    0.02240877f, -0.03186663f, 0.01073988f, 0.03720464f, -0.04129190f, -0.04156337f, 0.01235057f, -0.03566327f, 
    0.01848093f, -0.02999958f, -0.03457803f, 0.02765772f, 0.02569221f, -0.04002502f, 0.02681926f, -0.01248229f, 
    0.01306723f, -0.04307483f, -0.03997309f, 0.01246750f, -0.03511749f, -0.02005506f, -0.02563244f, 0.02750491f, 
    -0.01586699f, -0.04519490f, -0.02809086f, -0.03889664f, 0.01822459f, -0.02506772f, 0.02568663f, 0.01266135f, 
    -0.04160115f, -0.02578005f, 0.01133484f, 0.00175075f, -0.00904445f, 0.01127261f, -0.04237362f, -0.03684849f, 
    -0.00019787f, -0.01733999f, -0.00355889f, 0.00751488f, 0.00019410f, -0.01184229f, 0.03301836f, -0.01990245f, 
    0.00547502f, -0.01293442f, -0.01929715f, 0.02356282f, -0.02750775f, -0.01774085f, 0.02893652f, -0.00817568f, 
    0.02413085f, 0.03318004f, -0.02716613f, -0.00001981f, -0.02294153f, -0.02101646f, 0.00294730f, -0.00294715f, 
    -0.04594117f, -0.00108514f, -0.00551673f, 0.00441210f, -0.03316999f, -0.01018749f, -0.02137310f, 0.02474926f, 
    0.01300342f, 0.02297439f, 0.01460290f, -0.04108495f, 0.02522088f, 0.02177788f, 0.00474463f, -0.01957771f, 
    0.01596498f, -0.01409586f, -0.03840426f, 0.03057326f, -0.03380412f, -0.00485356f, -0.01647569f, 0.02280246f, 
    -0.00058096f, -0.02520762f, 0.00166347f, -0.01222089f, -0.02415490f, 0.00914932f, 0.00434518f, 0.01782904f, 
    0.34347847f, 0.35019743f, 0.05858714f, 0.10782550f, 0.19030756f, 0.04492817f, 0.00970742f, -0.06011870f, 
    0.01670340f, -0.15368459f, -0.10760298f, 0.08753225f, -0.04882393f, 0.00097178f, -0.08811160f, 0.01692736f, 
    -0.16327423f, -0.20261624f, 0.02913181f, -0.00603505f, 0.53837258f, 0.07102507f, -0.21491276f, -0.20784222f, 
    0.12487651f, -0.10062150f, 0.12169455f, 0.00646952f, 0.01083954f, -0.01807999f, 0.02532159f, 0.03651048f, 
    -0.03282049f, -0.00182959f, -0.02049281f, -0.02057843f, 0.03965114f, 0.03741065f, 0.00218106f, 0.16066605f, 
    -0.14157988f, -0.00316200f, -0.05937419f, -0.05978604f, -0.01913965f, 0.07142870f, -0.04078678f, 0.00833173f, 
    0.02788891f, -0.02659039f, 0.03503416f, -0.09648875f, -0.01650551f, 0.00457169f, 0.09869672f, -0.09304723f, 
    -0.02570315f, 0.03010422f, 0.04269839f, -0.14450049f, 0.52874535f, 0.08780647f, -0.03418391f, 0.13029602f, 
    0.11988179f, -0.15938658f, -0.03851556f, 0.03594024f, 0.06299333f, 0.04018338f, -0.03121100f, 0.02124124f, 
    0.04271922f, -0.05798073f, 0.03827091f, -0.06480999f, 0.12308323f, -0.08184671f, 0.06171363f, -0.02018424f, 
    0.06513633f, 0.23387115f, 0.00655202f, 0.04455082f, 0.37857565f, -0.10624289f, -0.03490486f, 0.04652148f, 
    0.10240494f, 0.01902407f, -0.12968206f, 0.03713701f, 0.07997705f, -0.01198598f, -0.03005848f, 0.01465506f, 
    0.12621506f, -0.04570637f, 0.02212764f, -0.03021759f, 0.45492014f, -0.17745233f, 0.00776876f, -0.11378063f, 
    -0.12829621f, -0.11496750f, -0.03597803f, -0.06857840f, -0.00108247f, 0.02469782f, -0.18012013f, 0.02307015f, 
    -0.03410121f, 0.05286696f, -0.01559484f, -0.16257624f, -0.01616704f, -0.12279790f, 0.02796428f, -0.01488791f, 
    0.12664983f, 0.13680758f, 0.00533033f, -0.07205631f, 0.05718470f, -0.03524712f, 0.02279674f, 0.08665382f, 
    0.06708577f, 0.04360054f, 0.03689255f, -0.06164443f, 0.05661993f, -0.05521525f, 0.04855753f, 0.07493003f, 
    -0.00798397f, 0.02366251f, 0.04233606f, -0.03552243f, 0.05415856f, 0.29163873f, 0.02660387f, 0.04722612f, 
    0.23424207f, -0.04968236f, -0.10409688f, 0.24203107f, 0.02669301f, 0.04741780f, 0.03225362f, -0.11020451f, 
    -0.00796619f, -0.02690200f, -0.04306424f, 0.05139881f, -0.00567641f, -0.06234087f, -0.05938718f, -0.09485365f, 
    0.03089540f, 0.11720382f, -0.29255468f, -0.00643513f, 0.17875075f, 0.12258833f, -0.10206869f, -0.03071955f, 
    -0.02051703f, 0.06939920f, 0.11483661f, -0.04462284f, 0.01312768f, 0.13208297f, -0.04880740f, -0.04192172f, 
    0.01215303f, -0.02696503f, 0.00269450f, -0.04094181f, 0.40957215f, 0.05941351f, -0.06910607f, 0.09567424f, 
    0.33094946f, -0.00110689f, -0.10808178f, 0.10131236f, 0.05795760f, 0.06868166f, -0.03047453f, -0.05429103f, 
    0.06775111f, 0.06735211f, -0.05594065f, -0.02102594f, 0.12693176f, -0.10427445f, -0.00929138f, -0.05911886f, 
    -0.23951390f, -0.17904241f, -0.14813359f, -0.05232030f, 0.06073172f, -0.04826463f, -0.00293603f, 0.03251898f, 
    -0.04651384f, -0.03540407f, 0.00696952f, -0.07345831f, -0.00377772f, 0.00046262f, -0.05114190f, -0.03633687f, 
    -0.12718526f, 0.01279595f, -0.02430012f, -0.03944270f, 0.35578141f, 0.00020079f, 0.08386906f, -0.07380339f, 
    -0.17632425f, -0.00293239f, -0.09528623f, -0.05505316f, 0.04135067f, 0.12173579f, -0.10659741f, -0.01951296f, 
    -0.03744854f, -0.11792466f, 0.01151238f, -0.07438169f, -0.02688105f, -0.11774146f, 0.01818519f, -0.10079262f, 
    0.09718582f, -0.07577739f, -0.10624163f, 0.13963589f, 0.16350399f, -0.05979789f, -0.01557672f, 0.04343398f, 
    0.01709323f, -0.09601285f, 0.14892331f, -0.02628416f, -0.02196128f, -0.01412824f, -0.01277804f, 0.00609258f, 
    0.03440260f, -0.09684141f, 0.00662956f, 0.05820296f, -0.14555533f, 0.06355359f, 0.34118423f, 0.04338680f, 
    0.05109813f, 0.03756219f, 0.01754778f, 0.05184571f, 0.02937899f, 0.01662917f, 0.00380011f, -0.01532401f, 
    0.07170910f, 0.12364068f, 0.07648837f, 0.01152536f, 0.10253212f, 0.12104481f, 0.16469638f, 0.07076018f, 
    0.19358379f, -0.02768465f, -0.02045021f, 0.11715697f, -0.02060562f, -0.12015521f, 0.03634553f, 0.00101158f, 
    0.05221908f, -0.04618357f, 0.06531339f, -0.03564939f, -0.06137682f, -0.08716311f, -0.01922250f, -0.04920946f, 
    -0.01447925f, -0.02259905f, 0.03191151f, -0.00646242f, -0.30615401f, 0.02775269f, 0.02796693f, 0.03616535f, 
    0.12325475f, -0.00795450f, 0.01622724f, -0.00277086f, 0.05002999f, 0.04865329f, -0.09648127f, 0.03668452f, 
    -0.03408429f, -0.00133604f, -0.03115416f, 0.08625969f, 0.07653770f, -0.01528195f, -0.02638515f, -0.01825899f, 
    0.18886922f, -0.00289135f, 0.03663885f, 0.05319542f, -0.04385270f, 0.03340109f, 0.00089535f, -0.01485210f, 
    -0.06714320f, -0.00022004f, 0.04533306f, 0.11688602f, 0.10970718f, 0.00667462f, -0.03732959f, -0.09979395f, 
    -0.10108361f, -0.02545763f, -0.12976128f, -0.04923125f, 0.18357918f, 0.25845018f, 0.07717903f, -0.01304571f, 
    0.01519463f, -0.03762016f, 0.05265388f, 0.00791265f, 0.11067158f, -0.15229231f, -0.08519027f, 0.04771074f, 
    0.07409065f, -0.06309927f, -0.15904330f, 0.06363446f, -0.01911382f, 0.13262381f, -0.01374547f, 0.01324970f, 
    -0.05678625f, 0.07500473f, 0.15069082f, -0.09658166f, 0.05778715f, 0.03165351f, -0.00967820f, -0.00847798f, 
    0.04573325f, 0.08641361f, 0.00236637f, -0.04822256f, 0.03574674f, 0.05062355f, 0.12879555f, 0.00461555f, 
    -0.02392005f, -0.05586686f, 0.01029796f, 0.00697643f, 0.24071340f, 0.35621616f, 0.00671725f, -0.09498218f, 
    -0.09543911f, -0.02383086f, -0.04430883f, 0.00792809f, 0.02729091f, -0.04878527f, -0.03599940f, 0.09084279f, 
    -0.08865497f, -0.09865214f, -0.06589141f, -0.04780849f, 0.07568367f, 0.11235151f, 0.20548789f, -0.01825874f, 
    -0.18313369f, -0.09923110f, -0.01965927f, 0.04217106f, 0.12708722f, 0.09801120f, 0.06167959f, 0.04549962f, 
    -0.09358339f, -0.01227637f, 0.02031504f, -0.02849271f, -0.15208052f, -0.01628482f, 0.03665482f, -0.05800141f, 
    0.04158308f, 0.05585370f, 0.07110708f, -0.08513541f, -0.09533226f, 0.20527302f, -0.02240575f, -0.07636956f, 
    -0.25483197f, 0.02908764f, -0.04383497f, -0.07018220f, -0.07085799f, 0.06586981f, 0.01137827f, -0.02035712f, 
    -0.00693116f, -0.01871586f, 0.01447324f, -0.04256756f, 0.01188402f, -0.04523116f, 0.06126232f, -0.11499122f, 
    0.07807801f, 0.29029387f, -0.00745802f, -0.11153196f, -0.03295143f, 0.11956037f, 0.01348612f, 0.03460748f, 
    0.04952719f, 0.12743264f, 0.12979184f, -0.05595015f, 0.12616807f, 0.02853925f, 0.04464403f, 0.08742491f, 
    -0.05159125f, 0.11245229f, -0.01866580f, -0.04476420f, -0.15914860f, 0.31686044f, 0.17122573f, 0.00997275f, 
    0.13329421f, 0.09657030f, -0.04734118f, -0.00825268f, -0.09444036f, 0.08078313f, -0.00964788f, -0.13117291f, 
    0.04293450f, 0.01081201f, -0.02249343f, 0.10476445f, 0.04744364f, 0.11606716f, 0.09861589f, -0.09355876f, 
    -0.02138519f, 0.05372915f, -0.06322343f, -0.08825017f, 0.20924395f, -0.01412463f, -0.06154871f, -0.01132684f, 
    -0.04486788f, 0.00511728f, 0.06447173f, 0.11482024f, 0.04235243f, -0.08506965f, 0.01661794f, -0.09063450f, 
    -0.03012258f, 0.01074697f, 0.03246839f, -0.02026855f, -0.04282613f, 0.50839472f, -0.15567043f, -0.10087301f, 
    -0.19208686f, -0.01783914f, 0.03905727f, 0.16682786f, -0.01527850f, 0.03088172f, 0.03443519f, -0.04128665f, 
    0.05710043f, 0.08678827f, -0.10958674f, -0.01068233f, 0.09736335f, -0.04522624f, 0.01776616f, 0.02280323f, 
    -0.08575278f, 0.08342262f, 0.00682521f, 0.03299409f, -0.06302779f, 0.04400818f, 0.05882713f, 0.00851346f, 
    0.08032992f, 0.01314479f, -0.03909474f, 0.01326665f, 0.10615913f, 0.06396861f, 0.04924903f, -0.06517431f, 
    -0.09237066f, 0.00381203f, -0.02224413f, 0.03302556f, -0.39354768f, -0.38857394f, 0.27290294f, 0.05290500f, 
    -0.03412303f, 0.01760726f, 0.08004487f, -0.06502236f, 0.05872224f, -0.09194934f, 0.05936020f, -0.03889545f, 
    -0.06887774f, 0.05595692f, -0.03380322f, -0.10089425f, -0.11027038f, -0.05678274f, 0.00972892f, 0.11520213f, 
    -0.07318152f, -0.12772067f, -0.20814441f, 0.35293156f, 0.29987678f, -0.05255267f, -0.04014491f, 0.02534505f, 
    0.04811161f, -0.12428419f, 0.06195152f, -0.01107866f, 0.11177329f, -0.05110778f, -0.00975537f, 0.09918768f, 
    -0.02126496f, 0.01736245f, 0.00507040f, 0.12898530f, -0.18576632f, -0.09061638f, 0.07063751f, -0.23912196f, 
    -0.02019210f, -0.05061135f, -0.03760076f, -0.01515619f, 0.04234996f, -0.10434763f, 0.07047008f, -0.13721529f, 
    -0.11604467f, 0.06154366f, 0.05689316f, -0.00098706f, 0.01313790f, -0.05365138f, -0.00156653f, 0.04709548f, 
    -0.16587138f, -0.04599849f, 0.14545269f, -0.07671075f, 0.05329758f, -0.14183228f, 0.03079886f, -0.06279724f, 
    0.01170086f, -0.13117728f, 0.02782364f, -0.01578919f, -0.07245944f, -0.01187142f, -0.03338643f, -0.03822151f, 
    -0.00443790f, 0.04380165f, 0.00318050f, -0.00476411f, -0.03104717f, 0.01355791f, 0.05285551f, 0.17810816f, 
    -0.03943098f, -0.00957955f, -0.06140316f, -0.06604183f, -0.01819123f, 0.06999344f, 0.11316559f, 0.00223727f, 
    0.01551358f, 0.04887744f, 0.02078266f, 0.02346675f, 0.09493195f, 0.01463668f, 0.03194424f, -0.00692480f, 
    0.01667585f, 0.00453328f, -0.01733426f, -0.03808225f, -0.02931921f, 0.01512085f, -0.00939403f, 0.02108539f, 
    -0.04060252f, 0.00039478f, 0.01163672f, -0.03391457f, -0.01461112f, -0.04710509f, -0.01665936f, 0.00493360f, 
    0.00113372f, -0.01900837f, -0.00131514f, 0.02500798f, -0.00529445f, 0.02663565f, 0.01603844f, 0.02598213f, 
    -0.00590280f, -0.02944847f, 0.00548371f, 0.00759646f, -0.02473475f, 0.01615489f, 0.03242391f, -0.01914172f, 
    0.02081724f, 0.00286761f, -0.03729563f, 0.03795438f, -0.01899533f, -0.03449003f, 0.03254198f, -0.03628173f, 
    -0.02213838f, -0.03669685f, 0.00928931f, -0.01212205f, -0.00356467f, 0.01789810f, 0.02251056f, 0.01522226f, 
    -0.03630392f, -0.03837196f, -0.00216919f, -0.00433271f, -0.04063600f, 0.00344574f, 0.01363364f, 0.00233075f, 
    0.03555809f, -0.00821780f, 0.03488046f, -0.00376918f, -0.02329493f, 0.01114528f, -0.01433910f, -0.03078131f, 
    0.00022318f, -0.01105123f, 0.02297285f, 0.01071656f, -0.05192367f, 0.00735859f, -0.00976923f, 0.02489149f, 
    -0.01057858f, 0.01694335f, 0.00594664f, -0.01439361f, -0.01661837f, -0.02356974f, -0.03402942f, 0.02533081f, 
    -0.05162672f, -0.04037929f, 0.02617477f, -0.00804378f, -0.01709488f, 0.01368664f, 0.00029418f, -0.03008038f, 
    0.00791355f, -0.00830900f, -0.02268534f, 0.01986820f, -0.00314683f, 0.00924819f, 0.00951058f, -0.05029403f, 
    -0.02305675f, 0.00285522f, 0.00444663f, -0.01782393f, -0.04090836f, -0.01393849f, 0.01351003f, -0.02994277f, 
    0.01281981f, 0.02049932f, -0.02507895f, -0.00296937f, -0.03401680f, 0.01278603f, 0.01262569f, -0.03396072f, 
    0.00902653f, 0.01219430f, 0.00790402f, -0.01985868f, 0.01620260f, 0.03271050f, -0.01835176f, 0.01329308f, 
    -0.01168608f, 0.00296243f, 0.00807053f, 0.01360321f, -0.03009373f, -0.00872134f, 0.02376520f, -0.01286024f, 
    0.01992793f, -0.00069288f, -0.02152748f, 0.01383332f, 0.00869477f, -0.01206351f, 0.02530885f, -0.00670681f, 
    -0.02756675f, -0.01213464f, 0.00087864f, -0.03290802f, 0.01331668f, -0.03090722f, -0.00208300f, -0.00884001f, 
    0.02108918f, 0.02971892f, 0.00742706f, 0.02221977f, -0.02517837f, -0.01702992f, -0.02470362f, 0.03016640f, 
    -0.00035648f, -0.03032556f, -0.03829785f, 0.02077661f, 0.01656455f, 0.02737226f, 0.01495275f, 0.01354380f, 
    0.00848159f, 0.03346589f, 0.02383184f, 0.02679911f, -0.03834597f, -0.00097414f, -0.03747488f, -0.03495481f, 
    -0.02178290f, 0.03097912f, -0.03557029f, -0.02371855f, -0.02456503f, -0.02569351f, -0.02671825f, 0.02846479f, 
    0.01838057f, 0.02226395f, -0.00256807f, -0.03480633f, 0.02677125f, -0.04959520f, 0.01440739f, -0.00057620f, 
    0.01424369f, -0.02326015f, 0.00854873f, -0.03360196f, -0.02018041f, -0.02463693f, 0.00407142f, 0.00152346f, 
    -0.04096960f, -0.02929101f, -0.03643841f, -0.00469398f, 0.00815421f, -0.01462540f, -0.02951828f, -0.03214177f, 
    -0.01161376f, 0.02769029f, -0.03957149f, 0.00038390f, 0.00895488f, 0.00645798f, 0.01836337f, -0.02214035f, 
    -0.03914977f, -0.00489947f, -0.02009469f, -0.01491544f, 0.00271642f, 0.00696674f, -0.01238875f, 0.02494891f, 
    -0.01690182f, -0.04760100f, 0.02149968f, -0.02730499f, -0.03445404f, 0.01385813f, 0.01231439f, -0.01087996f, 
    0.02197754f, -0.00572799f, -0.03999981f, 0.01459227f, 0.00479216f, -0.04203320f, -0.01734972f, -0.03367786f, 
    -0.00517430f, -0.01316889f, -0.02561524f, -0.01356666f, -0.00787817f, 0.01679613f, 0.01950571f, 0.02640623f, 
    0.00582052f, -0.02022451f, -0.00678137f, -0.03966871f, 0.01150142f, -0.02446361f, -0.00634835f, 0.01968907f, 
    -0.02755948f, -0.00689401f, 0.02640798f, -0.03207345f, -0.02234332f, 0.03020598f, 0.00262426f, -0.00329482f, 
    -0.00011757f, -0.03195954f, -0.02369547f, 0.01831994f, -0.03546628f, -0.01193491f, 0.02069662f, -0.03677117f, 
    -0.01538158f, 0.03154810f, 0.00701869f, -0.03444288f, 0.03338182f, -0.00166661f, -0.00708350f, -0.00162031f, 
    0.03358949f, 0.02034052f, -0.02616287f, 0.02374911f, -0.02417739f, -0.02035297f, 0.03420142f, 0.00830311f, 
    -0.00598796f, 0.01426158f, -0.01098852f, 0.00038702f, 0.01923596f, 0.03198078f, -0.00608257f, 0.03388247f, 
    -0.02642572f, 0.02195189f, -0.02429279f, -0.03230232f, -0.03438549f, 0.02453949f, -0.01961890f, 0.02476234f, 
    -0.02734560f, 0.01295435f, -0.00773734f, 0.01338732f, 0.02155861f, -0.02474151f, -0.01640940f, 0.01108828f, 
    -0.01964813f, -0.03952850f, -0.04182604f, -0.03318001f, 0.01795410f, 0.03490745f, -0.02273234f, -0.00455674f, 
    -0.02018345f, -0.03606676f, 0.02768922f, 0.01484944f, -0.03934281f, 0.01956292f, 0.02672155f, -0.04298840f, 
    0.01809229f, -0.01147325f, -0.03042446f, -0.02525144f, 0.01859827f, 0.01236743f, 0.00559336f, -0.02927394f, 
    0.01889141f, 0.00121094f, -0.02411217f, -0.00498411f, -0.05078105f, -0.02089858f, -0.02475196f, 0.01398360f, 
    -0.01693079f, 0.02773492f, -0.04590807f, -0.00798296f, 0.03123994f, -0.02087842f, 0.01535178f, -0.00676418f, 
    0.00404582f, 0.00202130f, -0.00221324f, -0.00053522f, -0.00428134f, 0.03177955f, 0.01713340f, -0.04048890f, 
    -0.01126991f, -0.02442696f, -0.01625417f, 0.00286589f, 0.00348359f, -0.00140825f, 0.03039691f, -0.00944119f, 
    0.01541275f, 0.01227048f, 0.02699595f, -0.00519142f, 0.01067071f, -0.04320568f, 0.02858937f, -0.03519198f, 
    -0.02352523f, -0.00616652f, -0.02121389f, -0.01076979f, 0.03016391f, -0.04893633f, -0.04491667f, 0.01448764f, 
    -0.01784225f, 0.00955144f, -0.01522174f, -0.02077628f, -0.03939915f, -0.03511450f, 0.02352262f, 0.00015526f, 
    0.01476149f, 0.03150794f, 0.01060735f, -0.03361655f, -0.01378386f, 0.00553559f, -0.03009619f, -0.02112656f, 
    -0.01495608f, -0.04221228f, 0.00564908f, -0.03129337f, -0.01528249f, -0.01529271f, -0.01082455f, -0.00702386f, 
    -0.01665450f, 0.00144728f, -0.02609265f, -0.00830474f, 0.03159448f, 0.00615154f, -0.04016699f, -0.02815501f, 
    0.01562369f, 0.01958235f, 0.02526588f, -0.01068448f, 0.00007809f, 0.01080522f, -0.04445228f, -0.03990673f, 
    0.02301666f, -0.01798255f, 0.02844130f, 0.02980522f, -0.04426480f, 0.03200380f, -0.01309330f, -0.02572905f, 
    0.00440331f, -0.04035486f, -0.00702558f, 0.02375912f, -0.01867246f, -0.03043231f, -0.01027659f, -0.00532368f, 
    0.00288592f, -0.01985017f, -0.02898902f, -0.00548917f, 0.02037343f, -0.02232360f, -0.02296028f, -0.00028545f, 
    0.01313925f, 0.01272084f, 0.02162246f, -0.02386617f, -0.00752956f, -0.01992923f, 0.00529640f, -0.02964826f, 
    0.00464873f, -0.00701327f, 0.00282519f, -0.04094710f, -0.03280136f, -0.03966302f, -0.00153539f, -0.03307194f, 
    -0.03193935f, 0.02105542f, -0.02459205f, 0.00569828f, 0.01558469f, 0.00436595f, -0.01855052f, -0.04445674f, 
    -0.02277075f, -0.03699536f, -0.03314754f, -0.00968323f, 0.02259684f, -0.01848020f, -0.01743324f, -0.00146347f, 
    0.01544784f, -0.01757101f, 0.02858603f, 0.02850592f, 0.01464717f, -0.04627823f, 0.00145421f, 0.01652331f, 
    0.01880927f, -0.03483054f, 0.00191602f, 0.01111491f, 0.01563630f, 0.03325589f, 0.00020833f, 0.02242162f, 
    0.00828382f, -0.01005229f, 0.00720687f, 0.03122021f, 0.02527795f, 0.02495425f, 0.01102748f, -0.04079384f, 
    0.01097506f, -0.02815480f, -0.03256685f, 0.00655950f, -0.03124484f, -0.01823504f, 0.03401988f, 0.00898463f, 
    0.01783689f, -0.03797317f, -0.01752964f, 0.02637457f, -0.00164825f, -0.03882058f, -0.02530326f, 0.00235507f, 
    -0.03766204f, -0.00400711f, 0.00304331f, -0.03423871f, 0.02274209f, -0.04320904f, -0.02851282f, 0.01636028f, 
    -0.02199080f, -0.02952037f, -0.04485103f, -0.03668037f, -0.01365269f, -0.02566786f, 0.03362093f, 0.02147769f, 
    -0.03499981f, -0.02412767f, -0.00265111f, -0.04309342f, -0.01703368f, 0.00848205f, 0.01578427f, 0.02997177f, 
    0.02383163f, 0.03309244f, 0.01275300f, -0.03349185f, -0.01982291f, 0.01491726f, -0.00514850f, -0.01105082f, 
    -0.02670890f, 0.03121303f, -0.03587794f, 0.00963440f, -0.03779907f, 0.03581200f, -0.00250949f, 0.00485459f, 
    -0.03585547f, -0.03371128f, -0.03497399f, -0.00726303f, -0.02015434f, -0.03981498f, -0.01969451f, 0.01571332f, 
    -0.00073169f, -0.03412785f, -0.03751497f, -0.00661536f, -0.03411044f, 0.01008919f, -0.00056133f, -0.04833480f, 
    -0.01001895f, 0.01522184f, -0.02675339f, -0.04099023f, 0.01754703f, 0.01315378f, -0.03216838f, 0.02356521f, 
    -0.04009940f, -0.00913599f, 0.00787011f, 0.01730111f, -0.02785133f, 0.00490785f, 0.01965361f, 0.02384595f, 
    -0.01611424f, 0.01446242f, 0.02598119f, -0.03918580f, -0.01248375f, -0.00421452f, 0.01210510f, 0.02860315f, 
    -0.01701644f, 0.02122170f, 0.00656592f, -0.01122063f, -0.02497640f, 0.01649619f, -0.04806954f, 0.00017318f, 
    -0.00485571f, -0.02564820f, 0.00373240f, -0.03609190f, -0.00544742f, 0.01964841f, 0.01746397f, 0.00671682f, 
    -0.00498778f, 0.01059703f, 0.00359550f, 0.00138643f, -0.01008830f, -0.03492270f, 0.01669365f, 0.02001636f, 
    -0.01881981f, 0.01803059f, -0.03024579f, 0.01782263f, -0.03140778f, -0.01203413f, 0.01913889f, -0.02321876f, 
    0.00925644f, -0.03983236f, 0.01253125f, -0.01791486f, 0.00776186f, 0.01890819f, -0.00659106f, -0.00903355f, 
    -0.01945218f, -0.02263684f, -0.01134664f, 0.03591437f, -0.02152560f, -0.03159405f, 0.02857700f, -0.02454739f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00865326f, 0.02829849f, -0.03819393f, 0.04087555f, 0.00578686f, -0.02462451f, 0.02394847f, 0.00341173f, 
    -0.03821578f, 0.02477315f, 0.00714182f, 0.00843653f, -0.01064319f, -0.01850750f, -0.00466692f, 0.02134437f, 
    -0.06072760f, 0.03335989f, -0.03990526f, 0.07186965f, 0.03226398f, 0.01341418f, -0.03045339f, 0.07523999f, 
    0.01239382f, 0.00439969f, 0.03063842f, 0.00254489f, -0.04284880f, -0.02345943f, -0.04308959f, 0.02331344f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.40360075f, -0.28247237f, -0.00577772f, 0.28444034f, 0.10982278f, -0.08561503f, 0.09289732f, -0.42919329f, 
    0.10084697f, -0.16162018f, 0.11537090f, 0.42107385f, 0.12035707f, 0.10486916f, -0.27156737f, -0.20585500f, 
    0.09412406f, 0.05189780f, 0.24075231f, -0.17417154f, -0.18701193f, 0.08163590f, 0.10036060f, 0.22864054f, 
    -0.06017790f, -0.06254972f, -0.55223876f, -0.01617552f, 0.25154680f, 0.06029359f, -0.01643258f, 0.06333203f, 
    -0.26195991f, -0.03424093f, 0.03352566f, -0.25584814f, -0.16139056f, 0.15884778f, -0.12888823f, 0.19277306f, 
    -0.17277823f, 0.15320104f, 0.03476909f, 0.35390466f, 0.06900868f, -0.09452436f, -0.53299886f, 0.31106079f, 
    0.02558419f, -0.13712266f, -0.17453544f, -0.14386411f, -0.33454227f, -0.29569820f, 0.08806837f, 0.04005535f, 
    0.30690897f, 0.27686492f, 0.18104358f, -0.15688744f, -0.04293863f, 0.01660546f, 0.25345513f, -0.15079649f, 
    -0.14005990f, -0.42891577f, 0.15708186f, -0.08285443f, -0.61753553f, 0.08428458f, -0.07888696f, 0.15603635f, 
    -0.09150337f, -0.31372750f, -0.13768233f, -0.22490545f, -0.09359709f, -0.17142493f, 0.38488835f, -0.04195288f, 
    0.03555152f, -0.15143287f, 0.10693820f, -0.13873838f, -0.52904564f, 0.31462717f, 0.00101395f, 0.01436999f, 
    0.28672764f, 0.16467637f, 0.04567927f, 0.13980858f, 0.31834167f, -0.15297577f, 0.12080213f, -0.01292914f, 
    -0.21648994f, 0.21555409f, -0.13833009f, 0.09369278f, -0.04647550f, -0.05283090f, 0.10212058f, -0.03015387f, 
    -0.14709666f, 0.09662794f, -0.05994875f, 0.02027241f, 0.02494922f, 0.13941343f, 0.41223285f, 0.12255692f, 
    -0.04330177f, -0.15040092f, 0.15492529f, -0.03007255f, 0.12175834f, -0.22568458f, -0.02868847f, -0.49330077f, 
    -0.41834286f, 0.44974729f, -0.43020546f, -0.10006814f, -0.67934752f, -0.01241678f, 0.23561251f, 0.13423958f, 
    0.00265935f, -0.11464733f, 0.12191712f, -0.15987013f, 0.18005532f, 0.16698577f, 0.03967287f, -0.44392252f, 
    -0.07382037f, 0.22911926f, -0.00319142f, -0.15629672f, 0.15828161f, -0.07192124f, 0.12830545f, 0.37155405f, 
    0.37829542f, 0.17669302f, -0.20175436f, -0.08572597f, 0.26731151f, 0.32442608f, -0.11328319f, 0.07256614f, 
    -0.38972053f, -0.27574572f, -0.08043158f, 0.10760501f, -0.06463679f, 0.13005166f, 0.36757126f, -0.01658615f, 
    -0.11856708f, 0.25309300f, 0.16076408f, 0.43177295f, -0.00512997f, -0.03557643f, -0.05953976f, 0.06773238f, 
    0.07074289f, 0.01997513f, 0.08178607f, -0.09731930f, -0.13861530f, 0.01725005f, -0.51136160f, 0.31107301f, 
    -0.09510825f, -0.12359099f, -0.22738762f, 0.33956164f, 0.16370432f, -0.22715288f, 0.15916911f, 0.10898387f, 
    0.02583426f, -0.44239950f, -0.21495055f, 0.14229971f, -0.23963167f, 0.05482189f, -0.29369786f, 0.10445158f, 
    -0.43874973f, -0.50040197f, -0.05884929f, -0.06304601f, -0.27516201f, 0.04919850f, -0.07487755f, 0.24164917f, 
    -0.09509522f, 0.30493990f, -0.01190841f, 0.08016286f, 0.03523655f, 0.15410280f, -0.03073966f, 0.05381528f, 
    -0.67345589f, 0.08692913f, 0.41822925f, 0.19566748f, 0.37847173f, 0.09229677f, 0.03751358f, -0.28328988f, 
    0.03544207f, -0.40206909f, 0.17002587f, 0.07528552f, 0.05760182f, 0.14627062f, -0.15589593f, -0.05080021f, 
    0.29278052f, 0.16583543f, 0.13269509f, -0.07398501f, 0.24176992f, 0.01953793f, 0.10073842f, 0.25590074f, 
    0.06068764f, -0.03180354f, 0.01564278f, -0.47123238f, 0.02501643f, 0.06514548f, 0.17975308f, -0.26807317f, 
    0.28549960f, -0.10466146f, 0.25178754f, -0.40512064f, 0.19112469f, -0.27220094f, 0.08083540f, -0.47824460f, 
    -0.26004308f, -0.44923326f, 0.06779445f, 0.15032573f, 0.11280955f, -0.12584092f, 0.16654862f, -0.13702099f, 
    0.08938843f, 0.18291435f, -0.05958468f, -0.36163351f, 0.28763705f, 0.16587745f, -0.15256236f, -0.19579074f, 
    0.09633657f, -0.34121341f, -0.10350981f, -0.44170055f, 0.11962308f, 0.14111996f, -0.19844863f, -0.06559142f, 
    -0.26929575f, 0.14922035f, -0.43041438f, 0.22444540f, 0.15614711f, 0.05576123f, -0.15674253f, -0.17531772f, 
    0.07624220f, 0.18977870f, 0.18129450f, 0.09425180f, 0.43562457f, 0.07278141f, 0.23542278f, -0.04772402f, 
    -0.53031069f, -0.50644100f, 0.12903972f, 0.22193973f, 0.42016336f, -0.12405814f, -0.05073582f, 0.18741655f, 
    0.06913947f, -0.00639936f, -0.04755960f, -0.13920605f, 0.06566434f, 0.17284258f, 0.12461419f, 0.00355986f, 
    0.44002688f, -0.10706016f, 0.10684020f, -0.45521075f, 0.08373770f, -0.10900436f, -0.06544852f, 0.03862151f, 
    -0.20535204f, -0.19707008f, 0.33972040f, 0.03468688f, 0.43917355f, -0.14926822f, -0.60784447f, 0.05696881f, 
    0.04280315f, 0.12289090f, 0.00009493f, -0.35989043f, 0.24231015f, -0.06462792f, -0.10428315f, 0.33185238f, 
    0.03198383f, -0.16319378f, -0.10697923f, 0.04584607f, -0.03872880f, -0.00260474f, 0.27593711f, -0.16911285f, 
    -0.41068369f, 0.00006107f, 0.06204589f, 0.07085149f, -0.03461849f, -0.27898881f, -0.16452183f, 0.25824898f, 
    0.10641780f, 0.28155583f, 0.06037240f, -0.16546972f, -0.47262037f, -0.10427801f, -0.76536232f, 0.15448630f, 
    0.18023823f, 0.27561888f, 0.04666736f, 0.12462626f, -0.45734820f, 0.09095313f, 0.15342692f, 0.31334990f, 
    -0.01354959f, 0.10871053f, 0.01275082f, -0.04304205f, -0.02092768f, 0.08632218f, -0.32238844f, -0.73056281f, 
    -0.25446430f, -0.01326735f, -0.10102513f, -0.25536120f, 0.22940278f, 0.37517223f, -0.05822698f, 0.02570905f, 
    -0.18276271f, 0.07646420f, 0.28684065f, 0.13442139f, -0.34468085f, 0.13191184f, 0.18453990f, 0.13814111f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14821042f, -0.02435159f, -0.13463716f, -0.01360454f, 0.10129969f, 0.13570231f, 0.15505670f, -0.18243451f, 
    -0.07848373f, -0.01343265f, 0.01706980f, 0.06577003f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
