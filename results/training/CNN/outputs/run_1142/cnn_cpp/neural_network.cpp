#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.29069078f, -0.15384977f, -0.69809145f, -0.55636638f, -0.15246685f, -0.37734130f, 0.00219127f, -0.06614939f, 
    -0.39212039f, -0.07711741f, 0.49754933f, 0.44873959f, 0.46113244f, -0.00079283f, 0.07912253f, -0.17696109f, 
    0.09798764f, -0.23119316f, -0.13994634f, -0.11437562f, 0.03522727f, -0.16188927f, -0.04857086f, -0.02558759f, 
    -0.07590429f, 0.74616730f, -0.49412769f, -0.25653213f, -0.50886559f, -0.79088348f, 0.25075099f, 0.27116743f, 
    0.13644038f, 0.00672577f, 0.38307685f, -0.13605057f, 0.28686109f, -0.30470586f, -0.14138910f, 0.48310375f, 
    -0.26941311f, 0.01973095f, -0.11369716f, -0.11814138f, 0.14647165f, 0.17850864f, -0.37271172f, 0.14789023f, 
    0.05779944f, 0.04275690f, -0.99433690f, -0.34876874f, -0.28757995f, -0.19126596f, -0.23095322f, -0.09969440f, 
    0.41862661f, 0.35364562f, 0.28368029f, 0.39586776f, 0.12209994f, 0.14092906f, -0.08637524f, 0.27654210f, 
    0.13410135f, -0.12616834f, 0.03487181f, -0.23669675f, -0.33987606f, -0.19556962f, -0.13835594f, 0.22039279f, 
    0.13314456f, 0.23812620f, -0.20924428f, -0.30900297f, -0.07216278f, -0.56491584f, -0.36175138f, 0.13482678f, 
    -0.32708448f, -0.50150144f, -0.29774183f, -0.34169444f, -0.36662692f, -0.16439202f, 0.03248679f, 0.23241968f, 
    -0.21730751f, 0.02594229f, 0.04733245f, -0.22300200f, -0.27586490f, -0.33246258f, -0.23435874f, -0.18729906f, 
    0.14029163f, -0.30525586f, 0.19051211f, -0.13240570f, 0.07364824f, -0.19968547f, 0.82456678f, 0.25455806f, 
    -0.60952348f, -0.52027780f, -0.39538872f, -0.34642434f, -0.37290716f, -0.43433225f, 0.17615694f, -0.05479125f, 
    -0.20590724f, -0.11926128f, -0.37031481f, -0.30077645f, 0.00279501f, 0.17858024f, -0.10533296f, -0.26419303f, 
    0.00809683f, -0.17856501f, -0.08481874f, -0.23505931f, -0.17981307f, 0.35343489f, 0.21885572f, 0.41759682f, 
    0.24203037f, 0.38909066f, -0.20596889f, -0.61876130f, -0.49112839f, -0.19655691f, -0.15720585f, -0.08729643f, 
    -0.09821652f, 0.14079890f, -0.02824488f, -0.08166615f, -0.05949251f, -0.36987412f, 0.16781341f, 0.27170762f, 
    0.01007654f, -0.28021565f, 0.16591884f, -0.09175496f, -0.10062829f, 0.27149478f, -0.21991317f, 0.51071459f, 
    -0.37243277f, -0.62511826f, -0.71411902f, -0.11578227f, 0.09811849f, 0.44013727f, 0.29652825f, -0.21612883f, 
    -0.25393409f, -0.33734989f, -0.17482142f, -0.34385827f, 0.03008624f, 0.06269296f, -0.03904003f, 0.01523389f, 
    0.17178831f, -0.25814939f, -0.34879380f, -0.12665007f, -0.35845557f, -0.26413330f, -0.62091070f, 0.45975503f, 
    -0.87055427f, 0.04273990f, 0.39082786f, 0.31106734f, -0.42846692f, -0.10305890f, 0.33908147f, -0.15181068f, 
    -0.01296915f, 0.16629843f, -0.05075731f, 0.25355941f, -0.32605463f, 0.10514427f, 0.10872974f, 0.10038082f, 
    -0.06363259f, -0.00618616f, 0.07391540f, 0.15683784f, -0.33924347f, -0.17987156f, 0.09202611f, 0.04100070f, 
    0.13105702f, -0.15689465f, -0.37236750f, 0.04459967f, -0.30928674f, -0.21120046f, -0.33091754f, -0.12483180f, 
    0.04314856f, -0.04062890f, -0.42556426f, -0.48163238f, 0.32920992f, -0.47183874f, 0.20135687f, -0.03750696f, 
    0.23053488f, 0.02956842f, -0.05070146f, -0.33153310f, -0.35510695f, -0.18759878f, -0.16648418f, -0.28283283f, 
    -0.33455664f, -0.48825452f, -0.65626115f, -0.55117464f, 0.37072834f, 0.43815279f, 0.19394782f, 0.71204537f, 
    -0.16900970f, -0.88681287f, -0.52216560f, -0.31026232f, 0.08041377f, -0.08085643f, -0.27834573f, -0.28432497f, 
    0.01070310f, -0.03293337f, 0.21493700f, 0.40861756f, 0.29857171f, 0.24421372f, -0.13581055f, -0.12289128f, 
    0.00608105f, -0.09475956f, 0.84016806f, 0.20336908f, 0.27899054f, -0.41082337f, -0.66103274f, 0.15556750f, 
    0.07748828f, -0.09131686f, 0.01249485f, -0.21587059f, -0.26044840f, -0.06729914f, -0.06961077f, 0.19624270f, 
    0.38220406f, 0.10260187f, -0.04648050f, -0.26082137f, -0.26319727f, -0.33914980f, -0.28686723f, -0.41872072f, 
    -0.34160227f, -0.09191231f, -0.06804800f, 0.35183546f, 0.38075885f, 0.17821899f, 0.38537925f, -0.04549675f, 
    0.30871299f, 0.24237524f, -0.15102413f, 0.11697358f, -0.11868146f, 0.11671879f, -0.14876701f, 0.20105663f, 
    -0.05489432f, -0.33566967f, -0.03002812f, 0.01266884f, -0.09509933f, -0.11063140f, -0.08322839f, 0.17087877f, 
    0.21179107f, 0.05324836f, -0.01328011f, -0.30146465f, -0.22478296f, -0.73602784f, -0.23506765f, -0.05794336f, 
    0.15126815f, -0.51526225f, -0.56672835f, 0.16907281f, -0.16948254f, -0.34488010f, -0.29470113f, 0.35855731f, 
    -0.05728840f, 0.11978693f, -0.36690119f, 0.23044264f, 0.21428873f, 0.03139879f, 0.27599788f, 0.04272366f, 
    -0.13655049f, 0.07726717f, 0.04689902f, -0.26105720f, 0.36459675f, 0.01384264f, 0.15641408f, -0.00129352f, 
    -0.06396728f, 0.18790089f, 0.07537504f, -0.35511884f, 0.04541212f, -0.19425118f, 0.34372413f, 0.18796788f, 
    -0.36099625f, 0.03155004f, 0.05466284f, 0.22348335f, -0.16799758f, 0.12231339f, -0.00473691f, 0.14065775f, 
    -0.16039751f, -0.31933847f, 0.28371659f, 0.05610951f, 0.04178749f, 0.05818484f, -0.69750661f, -0.00974469f, 
    0.21790408f, 0.31392926f, 0.06573217f, -0.64659232f, -0.30944678f, 0.28611621f, 0.51380140f, 0.28416386f, 
    -0.06784590f, -0.27223989f, 0.56373638f, -0.65884030f, 0.45268673f, -0.17574602f, -0.25389326f, 0.09121731f, 
    -0.05251066f, 0.20576234f, -0.01296583f, 0.02776678f, 0.00761196f, 0.00422236f, 0.25333405f, -0.68058681f, 
    -0.23783666f, -0.29345235f, -0.47635269f, -0.41939342f, -0.10723511f, -0.09922633f, -0.33991033f, -0.35469493f, 
    -0.13336278f, -0.00268680f, -0.08777408f, -0.18492830f, -0.26556191f, 0.15158917f, -0.31832293f, -0.10141560f, 
    -0.39737129f, -0.49018171f, -0.02880771f, 0.01687764f, -0.15025191f, 0.07299280f, 0.19694079f, 0.04788676f, 
    0.80903333f, -0.86293602f, -0.76756305f, 0.15285565f, -0.15227735f, 0.70851970f, 0.42036867f, 0.30570099f, 
    -0.20805350f, 0.13045813f, -0.12967908f, 0.15289846f, -0.31695524f, -0.27056095f, 0.19303961f, 0.10354955f, 
    0.12543094f, 0.06336938f, -0.07810736f, -0.28468558f, 0.05600570f, -0.15166424f, 0.01588254f, -0.00410060f, 
    0.05162746f, -0.72434944f, -0.71120507f, -0.24835399f, -0.02280670f, 0.71622407f, 0.11321647f, 0.40260202f, 
    0.19089331f, 0.01383794f, -0.13117102f, -0.14985444f, -0.44366416f, -0.00967958f, -0.19245452f, 0.24098535f, 
    -0.13743867f, -0.26477122f, -0.30938506f, 0.35047051f, 0.02453903f, -0.06557667f, -0.20498778f, -0.05618582f, 
    -0.32524461f, -0.56062824f, 0.32321051f, -0.60639805f, -0.70907235f, -0.17190020f, -0.11257219f, 0.37947997f, 
    0.27627769f, 0.17653200f, -0.13349521f, 0.12470515f, 0.30706710f, 0.06134550f, -0.09320573f, -0.10357583f, 
    0.18936753f, 0.03507337f, -0.07548389f, -0.25698945f, -0.16804035f, -0.23714238f, -0.07413246f, 0.20363194f, 
    0.41528663f, 0.38827947f, 0.00623499f, 0.47257271f, -0.22822909f, -0.44022745f, 0.19235921f, 0.07504942f, 
    -0.36598980f, 0.12448303f, 0.27041021f, 0.22707352f, 0.35807064f, 0.05894158f, 0.61289865f, -0.27922922f, 
    -0.44290754f, -0.14135851f, -0.13274771f, 0.09723770f, 0.22161472f, 0.09808388f, -0.38115814f, -0.22270711f, 
    0.20093392f, -0.07072145f, -0.22777861f, 0.08057109f, -0.84630543f, -0.16267969f, 0.23436643f, 0.70150256f, 
    -0.22532561f, -0.20905687f, -0.69860548f, -0.05363669f, 0.49683982f, 0.11888255f, -0.32624501f, -0.18823378f, 
    -0.30310073f, 0.58359200f, 0.23512135f, -0.10818176f, 0.12979344f, -0.14753203f, 0.11284978f, 0.19759542f, 
    0.05665291f, 0.02931151f, -0.00416566f, -0.21088547f, -0.23302068f, -0.43876132f, 0.05406525f, -0.13580064f, 
    0.36150718f, 0.03244760f, 0.09284390f, 0.28021047f, 0.25008184f, -0.31639794f, -0.27901214f, 0.28559938f, 
    -0.20082848f, -0.20880990f, 0.27516675f, -0.02932090f, 0.29644674f, -0.43194735f, -0.12143925f, -0.12485228f, 
    -0.17202444f, -0.34939539f, 0.41300386f, 0.42186111f, -0.11601230f, 0.13094118f, -1.14798915f, -0.36168540f, 
    -0.48204732f, -0.37734520f, -0.12143932f, 0.70098639f, -0.21717738f, 0.35009581f, 0.25011605f, 0.38375944f, 
    0.35597962f, -0.16742612f, -0.14005697f, -0.04612529f, 0.04140640f, 0.09064925f, 0.11501923f, 0.25437450f, 
    0.37869525f, -0.20329705f, -0.05325624f, 0.04998924f, 0.08219878f, -0.17884265f, -0.08460747f, 0.70117116f, 
    0.15143973f, 0.30031663f, 0.14541848f, -0.07274909f, 0.15598068f, -0.36222950f, -0.02555558f, 0.03239772f, 
    0.19853261f, 0.28909570f, -0.10204050f, 0.00795268f, 0.08925494f, 0.35965627f, -0.05390994f, 0.13340297f, 
    0.17369668f, -0.11441879f, 0.06068476f, -0.12967098f, 0.30766985f, 0.35761702f, 0.01496899f, -0.22793263f, 
    1.04093301f, -0.15839578f, -0.00233960f, -0.86327547f, -1.00566220f, 0.40686920f, 0.15106915f, 0.10607098f, 
    0.31501102f, 0.07462268f, -0.03337251f, 0.31781226f, 0.00472923f, -0.14131588f, -0.15532826f, 0.08784058f, 
    -0.34949151f, -0.21041247f, 0.18502136f, 0.18203703f, -0.06417426f, 0.18708117f, 0.00711981f, -0.18492474f, 
    0.26123720f, 0.00763973f, -0.56563658f, 0.21397728f, 0.28159377f, 0.27705556f, 0.07735093f, 0.13937083f, 
    -0.22746073f, -0.04454321f, 0.08499846f, -0.00801897f, 0.43457159f, -0.12456299f, -0.50673509f, -0.08741704f, 
    0.13347772f, 0.24638519f, -0.15820985f, -0.20917946f, -0.36880273f, 0.28438765f, 0.26364318f, -0.14225526f, 
    -0.07915580f, 0.09759454f, -0.30096480f, -0.51967281f, -0.35000595f, -0.41788957f, -0.19063295f, 0.23379290f, 
    0.26861587f, 0.51072049f, 0.43836239f, 0.26472726f, 0.05705593f, 0.14840887f, 0.07370792f, 0.08613615f, 
    -0.39342222f, -0.10333494f, 0.06045819f, 0.20077889f, -0.18261708f, 0.27781257f, -0.10741557f, -0.17882259f, 
    -0.08920040f, 0.02535283f, -0.05418900f, -0.56400645f, 0.50601643f, 0.46582621f, -0.51556134f, -0.50276124f, 
    0.39743319f, 0.18955608f, -0.49550167f, -0.60301304f, -0.49173453f, 0.07614885f, -0.02483914f, -0.05981920f, 
    -0.25530097f, 0.14216338f, 0.37993956f, -0.26776972f, 0.05394767f, -0.21993750f, -0.10982206f, -0.01560280f, 
    0.43602031f, -0.06077471f, -0.04940951f, 0.35892922f, -0.97543257f, -0.61980683f, -0.02838197f, 0.52508122f, 
    0.58382255f, 0.76146781f, 0.09742007f, -0.39349386f, -0.42828751f, 0.32527667f, 0.14152142f, 0.10112719f, 
    -0.29657531f, -0.08288652f, -0.56079996f, -0.20336650f, 0.03699831f, 0.27395192f, -0.08440658f, 0.12965037f, 
    -0.23454581f, 0.00885356f, 0.08333937f, 0.14383750f, -0.08732731f, 0.63370460f, 0.25633681f, -0.31956074f, 
    -0.08861735f, 0.11699553f, -0.56391275f, 0.06273688f, -0.66465205f, -0.60851544f, -0.65305394f, -0.14663386f, 
    0.42736697f, -0.03449517f, -0.33188924f, 0.46610641f, -0.13633345f, 0.18604445f, -0.06906488f, -0.17038640f, 
    0.14054018f, -0.05542139f, -0.09667357f, 0.24426354f, 0.14239383f, -0.18596151f, -0.83640754f, 0.06350475f, 
    0.32630628f, 0.31894660f, -0.03910611f, -0.68259394f, 0.57542974f, 0.07218070f, -0.01018696f, 0.17851397f, 
    0.29579091f, 0.07136049f, 0.38359383f, -0.30881071f, -0.28940523f, 0.03734070f, -0.36622182f, 0.19542357f, 
    -0.23511155f, -0.10934722f, -0.19432873f, 0.02441410f, -0.07731263f, -0.03565912f, 0.57023305f, 0.25688851f, 
    0.45081988f, 0.29512784f, 0.35635826f, 0.30052724f, -0.13312607f, -0.06298415f, 0.33144709f, 0.13731997f, 
    0.15922676f, 0.13608156f, 0.13338171f, -0.05436291f, -0.03915388f, 0.10518016f, 0.02286101f, 0.21217425f, 
    -0.12582377f, 0.12845184f, -0.30820635f, -0.21599151f, -0.04316001f, -0.09654436f, -0.09463810f, -0.08913312f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15183817f, 0.46527854f, 0.13336243f, -0.23164622f, 0.02016370f, 0.16233301f, 0.03224844f, 0.18206014f, 
    -0.06959834f, -0.12681663f, 0.14442748f, -0.18980791f, 0.18086061f, 0.25169536f, 0.07375430f, -0.25576746f, 
    0.22679144f, 0.05538616f, 0.08103050f, 0.13371883f, 0.09584143f, 0.25091416f, 0.11085618f, -0.06045419f, 
    0.32645804f, 0.34578598f, -0.19832031f, 0.41082928f, 0.14492688f, 0.21832310f, 0.22761607f, -0.18333718f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01209596f, 0.00316154f, -0.04811982f, 0.03337664f, -0.00443968f, 0.00172476f, -0.01519253f, -0.05528754f, 
    -0.03042873f, -0.05276978f, 0.00025792f, 0.02114950f, -0.01236856f, -0.05215186f, 0.01177221f, -0.04757849f, 
    0.03622169f, -0.02552407f, 0.04470220f, -0.03580208f, -0.05733346f, -0.02722612f, -0.04490215f, 0.01375177f, 
    -0.02476894f, 0.00125105f, 0.01945395f, 0.02947659f, -0.04568131f, -0.01492200f, 0.03620099f, -0.01841801f, 
    -0.04089607f, -0.05909620f, -0.00001451f, -0.02385467f, -0.03247327f, -0.02361512f, 0.02495461f, -0.03427282f, 
    -0.02951579f, 0.00318609f, -0.03959469f, 0.02949893f, 0.02399189f, 0.03514399f, 0.00907629f, 0.00431027f, 
    -0.02101627f, 0.01027291f, 0.01059137f, 0.04311105f, 0.01009817f, -0.02938485f, -0.00795622f, 0.03285208f, 
    -0.03179264f, 0.01006547f, 0.00266753f, -0.01704875f, -0.01797363f, -0.00045533f, -0.01251389f, 0.04624894f, 
    0.01275339f, -0.00493497f, 0.01238113f, -0.04076885f, -0.01691800f, 0.00646032f, -0.03266143f, -0.05191785f, 
    -0.04342285f, 0.01710048f, 0.00354519f, -0.04250264f, -0.00522850f, -0.02621514f, 0.03362810f, -0.03771580f, 
    -0.03129438f, -0.02703572f, -0.01386427f, -0.04224201f, 0.01818583f, -0.02707590f, -0.01577514f, 0.02682450f, 
    -0.02904313f, -0.01946761f, -0.01110082f, -0.03043701f, 0.03452422f, -0.01119529f, 0.00609014f, -0.02659345f, 
    -0.00116407f, 0.00564515f, -0.04095700f, 0.01051967f, 0.01497749f, -0.00358657f, 0.01697354f, 0.04080220f, 
    -0.01427942f, -0.04178505f, 0.00146701f, 0.03624753f, -0.01313981f, -0.00405583f, -0.03084326f, 0.03372171f, 
    -0.02539848f, -0.05721751f, -0.01356774f, -0.00532412f, -0.03465693f, -0.04659611f, 0.02501727f, -0.05324277f, 
    -0.05312961f, -0.01506431f, -0.02508794f, -0.04922532f, -0.05164900f, -0.01132053f, 0.03622717f, 0.02344783f, 
    0.03532594f, 0.00265376f, -0.02826363f, 0.02349910f, 0.04083211f, 0.01974108f, -0.00314274f, -0.04347226f, 
    0.02520245f, -0.02813979f, -0.04694433f, -0.02950081f, 0.03626610f, 0.03486541f, 0.03317231f, 0.01214804f, 
    0.01073393f, 0.04095525f, -0.01685278f, -0.04730567f, -0.02355472f, -0.01928373f, 0.01122522f, -0.00897396f, 
    -0.05451246f, -0.02205323f, -0.03823672f, -0.04254108f, -0.05077744f, -0.02472290f, 0.00371694f, -0.01198411f, 
    -0.04537968f, -0.04967256f, -0.05120645f, 0.03218867f, 0.00747776f, -0.03024256f, 0.04668363f, -0.02556042f, 
    0.04083780f, 0.03688239f, 0.03641313f, -0.00435355f, 0.03696654f, 0.03824058f, 0.03616715f, -0.02659754f, 
    0.00444507f, -0.04189356f, 0.03529669f, 0.05029038f, -0.04849588f, -0.05897119f, 0.02106614f, -0.01037735f, 
    -0.04247307f, 0.03143845f, -0.00478341f, -0.00416480f, 0.03819643f, 0.03663455f, 0.01489666f, -0.03493870f, 
    -0.01802211f, 0.00004539f, 0.00270701f, 0.03545476f, 0.02798707f, -0.03357064f, 0.01302214f, 0.00113561f, 
    -0.02348592f, -0.01126366f, 0.01265429f, -0.02835441f, -0.04774192f, 0.03675384f, 0.02915344f, 0.02895956f, 
    0.03227445f, 0.03094780f, -0.01483817f, -0.02643494f, -0.04332981f, 0.02751930f, -0.01927053f, 0.00246772f, 
    -0.00792129f, 0.02138045f, 0.00273826f, -0.02401415f, 0.01460206f, 0.00612528f, -0.00725768f, 0.05162797f, 
    0.00230185f, -0.04264002f, -0.05794593f, -0.02731826f, -0.00296429f, 0.01397238f, -0.01712274f, -0.00659529f, 
    -0.00829696f, 0.04153906f, -0.03635620f, -0.03281813f, 0.03255320f, 0.00167361f, 0.01603099f, 0.01386304f, 
    -0.03426007f, -0.04804838f, -0.05453323f, -0.05261566f, 0.01273049f, -0.00525737f, 0.01545509f, -0.04131108f, 
    -0.01529789f, 0.02288807f, 0.01261858f, 0.04313308f, 0.02590274f, 0.02125855f, -0.01665241f, -0.03074386f, 
    0.00182644f, 0.00414097f, -0.01502408f, -0.01948344f, -0.01740971f, 0.01014554f, 0.02852033f, -0.04660959f, 
    -0.04481801f, -0.04410329f, -0.03169854f, -0.02382779f, 0.04113575f, -0.01289097f, -0.04383513f, -0.01620812f, 
    -0.00462701f, -0.03889473f, -0.05464398f, 0.00473576f, -0.04704366f, 0.03761616f, 0.02596018f, -0.00417358f, 
    0.01109038f, 0.00560754f, -0.05227792f, -0.05736498f, -0.00783414f, -0.04099869f, -0.03978627f, 0.02202390f, 
    0.01611422f, -0.00028652f, -0.03204868f, -0.05784403f, -0.00647678f, 0.01118284f, 0.04457138f, 0.01543933f, 
    0.02698294f, 0.04170471f, 0.00492642f, -0.03012771f, -0.01863717f, 0.03812113f, -0.00183588f, -0.02547714f, 
    0.03074162f, 0.00848446f, -0.03656192f, 0.00138028f, -0.04630026f, -0.03100419f, -0.00874151f, -0.05648931f, 
    -0.00739763f, 0.00070815f, -0.05329866f, -0.05730558f, -0.05106277f, -0.03370123f, 0.01036320f, -0.01460062f, 
    -0.02641655f, -0.03045238f, 0.04153541f, -0.02582602f, 0.02045099f, -0.01261859f, 0.00286687f, -0.03917117f, 
    -0.01683998f, 0.02249337f, 0.01229899f, -0.03393500f, -0.02865738f, 0.02638570f, 0.00198034f, -0.00593083f, 
    0.00201105f, -0.04457507f, 0.03192367f, 0.01081242f, -0.05365874f, -0.01101137f, 0.00081665f, -0.04747673f, 
    -0.03283019f, 0.00819931f, 0.03995422f, 0.02583265f, 0.04075265f, 0.03221162f, 0.02895764f, -0.00719468f, 
    -0.05192989f, 0.00239128f, -0.05752140f, -0.04103874f, -0.05383189f, -0.00284004f, -0.00240822f, -0.05279629f, 
    0.01854969f, -0.04530336f, -0.02208996f, 0.00394937f, 0.01411962f, 0.03335986f, -0.03838423f, 0.02379279f, 
    -0.05452893f, -0.01313709f, -0.02229008f, 0.01843670f, 0.03822363f, -0.02595268f, -0.02941647f, 0.00888772f, 
    -0.05199196f, -0.04964070f, 0.04399103f, -0.03555038f, 0.02240741f, -0.05301077f, -0.01801511f, 0.02056649f, 
    -0.01577901f, -0.01080477f, -0.02912877f, 0.04730827f, 0.03489391f, -0.01017942f, -0.00036156f, -0.00348277f, 
    -0.01063909f, -0.01305045f, 0.02965128f, -0.04501184f, 0.03108738f, 0.00486051f, -0.00354678f, -0.02252172f, 
    0.01485673f, 0.00587711f, -0.01490587f, 0.03597435f, 0.02172424f, 0.01006150f, -0.01315003f, -0.01180353f, 
    -0.02360737f, -0.00601360f, 0.02154147f, 0.04351281f, 0.00359853f, -0.00692852f, 0.02148663f, -0.02941407f, 
    -0.02692494f, 0.03097824f, -0.03316194f, -0.02824701f, -0.04967142f, -0.01441493f, 0.02633710f, -0.05451310f, 
    -0.04906178f, -0.00766433f, -0.01685051f, 0.00398504f, -0.00659676f, 0.02328951f, -0.03787646f, 0.01412690f, 
    -0.02668914f, -0.02099909f, 0.00553150f, -0.01522657f, 0.03025218f, -0.02544348f, -0.03972036f, 0.02317355f, 
    0.04227932f, -0.00170489f, -0.01914938f, -0.04948203f, 0.01225059f, -0.03035564f, -0.00790499f, 0.03347339f, 
    0.01990074f, 0.01331753f, -0.04140589f, -0.04970013f, -0.00711308f, 0.04526392f, -0.03466609f, 0.01899497f, 
    0.00035389f, -0.02837417f, -0.01381948f, 0.03182241f, -0.03516868f, -0.02639400f, 0.04418977f, -0.03418916f, 
    0.00617109f, 0.03706468f, -0.01584330f, -0.05116957f, -0.02836624f, 0.02662830f, 0.00613983f, 0.02219249f, 
    -0.02912650f, 0.01741972f, 0.01411185f, -0.02886308f, 0.04133840f, 0.03328453f, -0.00376120f, 0.03326342f, 
    -0.03461426f, -0.02138495f, -0.04643776f, -0.00264516f, -0.03594711f, 0.02185600f, 0.01073632f, 0.01129102f, 
    -0.03918232f, -0.00135702f, -0.04374352f, 0.02393894f, 0.00910175f, -0.02920854f, 0.03784926f, 0.00856286f, 
    -0.02099389f, 0.03157674f, -0.02871378f, -0.00598318f, 0.00033836f, 0.02241838f, -0.00167733f, -0.00755415f, 
    -0.00518825f, -0.03121373f, 0.01855742f, -0.04439584f, 0.03647062f, -0.05146916f, -0.01050834f, 0.01733488f, 
    -0.01057111f, 0.01060212f, -0.05154814f, -0.02106334f, 0.02234190f, 0.03901264f, 0.01090654f, -0.00341902f, 
    0.00189212f, -0.00615069f, 0.02454869f, -0.04664100f, -0.03519240f, 0.00347381f, -0.04811927f, -0.03511354f, 
    -0.01250827f, -0.02488308f, 0.00756541f, -0.01237623f, 0.02706569f, -0.01325922f, 0.01688254f, -0.04141593f, 
    0.02489839f, 0.00706688f, 0.00681821f, 0.03798280f, -0.03941876f, -0.04443680f, 0.00486358f, -0.00294096f, 
    -0.01852126f, -0.01584856f, 0.01585185f, -0.01249755f, -0.00384069f, 0.00058926f, -0.05895968f, -0.02462925f, 
    0.01845719f, 0.01739869f, -0.04536805f, 0.01739946f, -0.03181278f, 0.04264579f, -0.02309533f, 0.02214360f, 
    0.00565795f, -0.04846532f, 0.00713163f, -0.02935760f, -0.03326122f, 0.04497355f, 0.03596519f, -0.03614526f, 
    0.02980731f, -0.00652240f, -0.03770874f, 0.03171252f, 0.02599513f, -0.02400729f, 0.02377591f, 0.03175702f, 
    0.03454540f, -0.05195810f, 0.02097812f, -0.01317522f, -0.01969389f, -0.03971414f, 0.04553453f, -0.00219927f, 
    -0.00602190f, -0.00225716f, 0.02142762f, -0.00691627f, -0.01012373f, 0.00136245f, 0.02492092f, -0.05168781f, 
    -0.04090982f, -0.00412646f, 0.04705936f, -0.02099988f, -0.04864195f, -0.03127071f, -0.00064102f, -0.04286657f, 
    -0.02524301f, -0.03077470f, 0.03261271f, -0.01654963f, -0.01623837f, -0.03412489f, 0.00894871f, -0.00623867f, 
    0.00933908f, -0.01981754f, -0.00950632f, -0.05179968f, -0.04360189f, 0.03816198f, -0.01053166f, -0.02620229f, 
    0.00456338f, -0.00611899f, 0.00906645f, -0.02981192f, 0.03911175f, 0.00295901f, 0.03616866f, 0.01321576f, 
    0.02051482f, -0.01119504f, 0.02367584f, -0.04056614f, 0.01002853f, -0.05405436f, -0.02007602f, 0.04039890f, 
    -0.00376648f, -0.05086926f, -0.02024825f, 0.00210922f, 0.04102365f, 0.04527559f, 0.04071604f, 0.00021689f, 
    -0.03884614f, 0.04344382f, 0.02355855f, -0.04356961f, -0.03913802f, 0.01291213f, 0.00440566f, 0.00457523f, 
    0.03230940f, 0.00591426f, -0.01612897f, 0.00686059f, -0.02023901f, -0.00141540f, 0.01568385f, -0.00259998f, 
    -0.04779726f, -0.02389698f, -0.01842202f, 0.02511497f, -0.00874937f, 0.01805671f, -0.04690219f, -0.05626328f, 
    -0.00246193f, 0.03644770f, -0.03862201f, 0.02838632f, 0.04379256f, 0.02143669f, -0.00247416f, 0.02474778f, 
    0.02944360f, -0.04487148f, -0.05615945f, 0.04069534f, -0.00643610f, -0.01681007f, -0.04631189f, 0.03381923f, 
    0.01218231f, -0.04296590f, -0.05259852f, -0.00327903f, 0.03337016f, -0.00083034f, -0.03142626f, 0.01856549f, 
    -0.04830183f, -0.00244795f, -0.04300101f, -0.02563608f, -0.05105289f, -0.04346903f, -0.04770497f, 0.00613670f, 
    0.01687939f, -0.02867510f, 0.00096503f, -0.02262213f, -0.03515621f, -0.04306850f, -0.04871694f, -0.02192998f, 
    -0.04751713f, -0.01888401f, 0.04367453f, -0.02994899f, -0.00127363f, -0.02689800f, 0.00452522f, -0.05283117f, 
    0.03118551f, 0.00533965f, -0.01961201f, -0.03096181f, -0.02449533f, -0.02816567f, 0.03562235f, -0.02699427f, 
    -0.02994147f, -0.02897203f, -0.01780103f, -0.00270319f, -0.02919406f, 0.03206822f, -0.03668704f, -0.01955347f, 
    0.03235247f, -0.03733202f, -0.00102993f, -0.01105100f, -0.03273033f, 0.02544163f, -0.00467870f, 0.03235726f, 
    -0.00962177f, -0.00197683f, 0.03420714f, 0.00015711f, -0.02102599f, -0.02566546f, 0.00278813f, 0.00741412f, 
    -0.00666486f, 0.03115055f, -0.03029893f, -0.02262965f, -0.02008626f, -0.04737093f, -0.04092095f, -0.00345821f, 
    -0.00410763f, -0.00578131f, 0.03759398f, 0.04425895f, 0.01336913f, -0.02068420f, 0.00018542f, -0.03893888f, 
    -0.02670805f, 0.02400403f, -0.01294097f, 0.03889317f, -0.05303028f, -0.05787412f, -0.04024879f, 0.01862338f, 
    -0.08284251f, -0.21201475f, 0.18098214f, 0.10529657f, -0.05689511f, -0.12974042f, -0.02355905f, 0.05114547f, 
    -0.01277771f, -0.00390727f, -0.03254012f, -0.11789696f, -0.18179218f, 0.02263824f, 0.06488066f, 0.04710501f, 
    -0.02707177f, -0.07369731f, 0.11282323f, 0.13697848f, -0.04996762f, -0.03907438f, 0.07493988f, -0.00000234f, 
    0.15522361f, 0.09560794f, -0.09089489f, 0.09303350f, -0.02952480f, -0.03826530f, -0.06010880f, 0.01159689f, 
    0.12253746f, 0.07272681f, -0.04654536f, -0.00102348f, -0.12963527f, -0.12085050f, 0.15056160f, -0.08673014f, 
    0.00963286f, -0.10509282f, 0.15661515f, 0.05380445f, 0.07973578f, 0.08640258f, 0.08522638f, -0.03001910f, 
    0.04833840f, 0.07436577f, 0.13476977f, 0.43404460f, 0.03217229f, 0.12678687f, 0.21040016f, -0.10204843f, 
    -0.00242300f, 0.05968846f, -0.05029529f, -0.09138004f, 0.34025806f, -0.07362524f, 0.25873649f, 0.13143422f, 
    0.01371607f, 0.04200030f, 0.09690056f, 0.04406528f, 0.01087373f, 0.03755763f, -0.03804727f, -0.02576402f, 
    0.10170653f, -0.06896581f, -0.17859201f, -0.01150622f, -0.03588423f, -0.15181150f, 0.10279025f, 0.17789176f, 
    0.00733379f, 0.04802121f, 0.05168105f, -0.14940271f, 0.13823420f, -0.13994813f, 0.00655299f, 0.00725348f, 
    0.05143551f, -0.05302401f, -0.01772048f, 0.20837198f, -0.03072561f, 0.02325113f, 0.11425819f, -0.19328910f, 
    -0.00101419f, -0.12009846f, -0.02731077f, -0.08310521f, -0.02283840f, -0.08747543f, 0.07402844f, 0.08885807f, 
    0.08425827f, 0.06322496f, 0.09614288f, -0.23258840f, -0.26163530f, -0.01109627f, 0.14535637f, 0.19930772f, 
    -0.13211048f, 0.05930930f, -0.21660379f, 0.04232373f, -0.04649456f, -0.03986376f, -0.11332281f, -0.05192895f, 
    -0.27139065f, 0.06727979f, -0.17369771f, 0.06634540f, -0.05426728f, -0.06241067f, 0.02060988f, -0.07171512f, 
    0.02076159f, 0.03128456f, -0.05174047f, -0.03708041f, -0.21229845f, -0.01455552f, 0.05730923f, 0.04603188f, 
    0.02532932f, 0.00648566f, -0.02282066f, 0.01231512f, -0.04913146f, -0.00924008f, -0.06031939f, -0.06720689f, 
    -0.08698121f, -0.10963251f, 0.28380284f, 0.19558576f, 0.08012678f, -0.07559682f, -0.19206493f, 0.03476971f, 
    0.07521684f, -0.00708721f, 0.02785391f, 0.01310708f, 0.06256337f, -0.00369006f, -0.03004213f, 0.02015602f, 
    0.02558003f, 0.09607968f, -0.07112350f, 0.00663179f, 0.05551501f, 0.11140606f, -0.03044990f, 0.02276226f, 
    0.34405148f, -0.14900318f, 0.00937662f, -0.14302056f, 0.02286036f, -0.12826550f, 0.00082053f, 0.02797258f, 
    -0.01571626f, 0.00341225f, 0.06009389f, 0.02526271f, -0.18765861f, -0.18635809f, -0.13637781f, 0.02878885f, 
    -0.07139486f, -0.20706870f, 0.02627073f, 0.00661508f, 0.13133983f, 0.05156011f, 0.07564540f, -0.03184126f, 
    -0.50945270f, 0.11791813f, 0.03528120f, -0.11028974f, -0.02688871f, 0.06531830f, 0.03003498f, -0.01006749f, 
    -0.04920547f, -0.02883013f, 0.02805237f, 0.07822715f, -0.18964143f, -0.02352510f, 0.05158121f, -0.03719278f, 
    0.00624412f, -0.05160677f, -0.05797585f, -0.10313837f, 0.07424380f, 0.00847584f, -0.10501024f, 0.00942188f, 
    -0.14510033f, -0.03488364f, 0.03498016f, 0.00047653f, 0.03603479f, 0.10193812f, 0.01690424f, 0.12242895f, 
    0.14968757f, 0.10906082f, 0.09078833f, 0.04029488f, 0.01767334f, -0.08530514f, -0.07413992f, -0.01189924f, 
    -0.01497188f, -0.06339972f, 0.07849669f, -0.06048297f, -0.08284952f, -0.04550032f, 0.19392087f, -0.01188754f, 
    0.22522946f, -0.02526307f, -0.22396000f, 0.10985861f, -0.07988025f, -0.00811822f, 0.18068413f, -0.11592933f, 
    -0.06967947f, -0.02680146f, -0.13181792f, 0.05001771f, 0.09397005f, 0.22761130f, -0.14221992f, -0.02964738f, 
    0.01798600f, 0.01395050f, -0.13456543f, 0.06183042f, 0.10333786f, -0.10771571f, -0.08264165f, -0.09476874f, 
    0.20547098f, -0.34009215f, -0.11509011f, 0.14601684f, -0.00569398f, -0.11943833f, 0.09837957f, 0.03076297f, 
    0.16371058f, 0.02412506f, 0.04159323f, 0.02247849f, -0.05064269f, 0.05012094f, -0.04051980f, -0.07672017f, 
    0.11771153f, 0.13877515f, 0.11539630f, -0.02995742f, 0.14257471f, 0.07056598f, 0.06836355f, 0.03712109f, 
    -0.32294035f, -0.01298323f, 0.35987145f, 0.07605290f, 0.03026445f, 0.14029311f, 0.22634253f, 0.05355637f, 
    -0.10047105f, -0.04130962f, 0.19457020f, -0.01498250f, -0.01738321f, 0.06180116f, 0.10772417f, -0.09842928f, 
    -0.03337981f, -0.02175353f, -0.01329673f, -0.06639633f, -0.03311431f, -0.03396336f, 0.15546301f, -0.10083136f, 
    0.00941839f, 0.00965927f, -0.02762810f, -0.12745985f, -0.03321680f, 0.01247184f, -0.06653053f, 0.13675025f, 
    0.11463112f, 0.00180278f, 0.10278202f, -0.01488265f, -0.04245275f, 0.07525138f, 0.06268487f, 0.20108196f, 
    -0.04725609f, -0.00618514f, 0.10482702f, 0.02569353f, 0.02435279f, -0.03319708f, 0.04101322f, -0.01177170f, 
    -0.28772846f, 0.13520683f, -0.03652109f, 0.01056706f, 0.07614718f, 0.00285701f, 0.00258698f, -0.10720077f, 
    -0.01582176f, 0.12181957f, 0.03331525f, 0.00184478f, -0.04849518f, 0.18614338f, 0.27756506f, 0.15912257f, 
    0.04501995f, 0.14705712f, 0.06435621f, 0.15124577f, 0.09131484f, -0.00564353f, 0.05024314f, -0.02406914f, 
    0.24775888f, -0.04317182f, -0.10243870f, 0.34970903f, -0.04752123f, -0.12436123f, -0.07057703f, 0.02083012f, 
    0.15214033f, -0.01551163f, -0.03515245f, -0.02651664f, -0.02001932f, 0.07452463f, -0.14758644f, -0.07963666f, 
    0.01936567f, 0.05965021f, 0.04847970f, 0.04646514f, 0.06418301f, 0.05493536f, 0.10250933f, 0.01879472f, 
    0.02091894f, -0.01539044f, -0.08653098f, -0.09081461f, -0.02927662f, -0.06399052f, 0.08478998f, -0.03219116f, 
    -0.19574140f, -0.07158516f, -0.17449839f, -0.03729226f, -0.09697511f, 0.16474940f, 0.13911800f, 0.29742104f, 
    0.00910721f, 0.03758371f, 0.06712630f, 0.12555903f, 0.04185731f, 0.10452290f, 0.03967923f, 0.08656672f, 
    0.05707870f, 0.02344032f, 0.06743770f, 0.23551451f, -0.08920855f, -0.01626214f, -0.00192610f, 0.03465573f, 
    0.12079089f, 0.00265625f, -0.05524508f, 0.07352906f, -0.07275911f, -0.16062440f, -0.13267589f, -0.11423370f, 
    -0.06264688f, -0.14089572f, 0.14937547f, -0.05287375f, 0.13026273f, -0.09342858f, 0.02437884f, -0.03622193f, 
    0.08291610f, 0.07333031f, 0.15126890f, 0.26484889f, 0.21447127f, 0.17272395f, 0.09814209f, -0.15717372f, 
    -0.02178407f, 0.06409606f, -0.07419411f, -0.03350216f, -0.24887963f, 0.00258598f, 0.32443628f, 0.31091136f, 
    0.00292970f, -0.07474940f, 0.01885804f, -0.01717528f, 0.05069901f, -0.09018712f, -0.02610206f, 0.10230299f, 
    0.15351227f, 0.07028503f, -0.06885508f, 0.09112022f, 0.05126791f, 0.00658164f, 0.06210789f, 0.17718592f, 
    -0.05207676f, -0.06035112f, 0.22026975f, -0.15017092f, 0.29999453f, -0.02324185f, -0.12830730f, 0.14961560f, 
    0.21570763f, 0.00223932f, -0.09564505f, -0.02610266f, 0.01379491f, 0.12814802f, -0.04535901f, -0.06736845f, 
    -0.14496301f, -0.13927378f, -0.03110936f, 0.07409719f, -0.02689742f, 0.02055898f, 0.04232262f, -0.03999789f, 
    -0.01179975f, -0.04514137f, 0.08436843f, -0.22664800f, -0.03208976f, 0.30636096f, -0.23477966f, -0.06952881f, 
    0.00947430f, 0.02597996f, 0.12968355f, -0.08418077f, -0.04567754f, 0.04201136f, -0.03624672f, -0.08402096f, 
    -0.32029778f, -0.02256532f, -0.09278841f, 0.00454613f, -0.04186652f, 0.00181050f, -0.10178687f, 0.01970928f, 
    0.11688203f, 0.14551049f, 0.01785131f, -0.03961192f, -0.51878667f, -0.03820458f, -0.06494064f, -0.09387092f, 
    0.03203266f, -0.09354195f, -0.13990109f, -0.14040245f, -0.06794419f, -0.19601117f, 0.01259705f, -0.17032844f, 
    0.13620727f, -0.13307196f, -0.04053868f, -0.01909420f, 0.14989585f, 0.09814806f, 0.01934832f, 0.05851088f, 
    0.11633250f, -0.06260812f, -0.01504512f, 0.08493783f, -0.01939012f, -0.02044032f, 0.20677511f, -0.00789326f, 
    0.02338350f, -0.06863910f, -0.07641874f, -0.04875445f, 0.06684206f, -0.01077192f, 0.02372119f, 0.05946393f, 
    0.51330739f, -0.07565188f, -0.25517979f, 0.08555241f, -0.00630327f, -0.16005440f, -0.05222857f, 0.08399082f, 
    -0.00950540f, -0.02623261f, -0.04931891f, 0.00150165f, -0.09827401f, -0.17877588f, -0.14822982f, 0.04467143f, 
    0.04048849f, -0.01145492f, -0.02858473f, -0.02227131f, 0.05367669f, 0.04053952f, -0.03208501f, -0.01175478f, 
    -0.51191920f, 0.15793091f, 0.28212604f, -0.33711541f, 0.01692528f, 0.05088201f, 0.03832417f, 0.03770391f, 
    -0.01013603f, -0.09171187f, 0.02158923f, -0.06309552f, 0.04570593f, 0.19796827f, 0.05781538f, -0.15527077f, 
    0.02898272f, -0.12029028f, 0.04929609f, 0.02421219f, -0.02724720f, 0.03017600f, -0.07806454f, -0.12246989f, 
    -0.25632027f, -0.15751715f, 0.17866142f, -0.13482060f, 0.04255618f, 0.12508820f, -0.07998977f, -0.14314659f, 
    0.15851176f, -0.00025827f, -0.00857531f, -0.01884677f, -0.07111070f, -0.12090731f, -0.35526475f, 0.01654787f, 
    -0.08521667f, -0.16165045f, 0.00905359f, 0.09823991f, 0.05769142f, 0.02912251f, 0.08161274f, 0.10974244f, 
    0.27714962f, -0.18322372f, -0.08570547f, 0.13400109f, 0.06042056f, 0.01922036f, 0.06184547f, -0.08154441f, 
    0.05584058f, 0.07403266f, 0.05572306f, -0.00904695f, 0.15511474f, 0.05790645f, -0.07149342f, -0.04691873f, 
    0.12946895f, -0.05393615f, 0.06507878f, 0.05692872f, 0.10745209f, -0.09294650f, 0.05135984f, -0.00326117f, 
    -0.17119130f, 0.03457858f, 0.01369572f, -0.00263570f, 0.14084654f, -0.05739520f, 0.06484364f, 0.05664980f, 
    -0.05074093f, -0.17697166f, 0.13810045f, 0.06692798f, -0.68217385f, -0.10317554f, 0.06676264f, -0.16597734f, 
    -0.08437775f, -0.05325858f, -0.18488573f, -0.06798402f, 0.06221794f, -0.01483584f, -0.15405069f, 0.01589054f, 
    -0.21982653f, 0.37434694f, -0.27259049f, 0.44320351f, 0.01144282f, 0.02752082f, -0.14364508f, 0.10456374f, 
    0.06386276f, 0.02021653f, 0.04822138f, 0.18060821f, 0.24428922f, 0.10227370f, 0.07693239f, -0.01709088f, 
    -0.01431554f, -0.02605895f, -0.13937563f, 0.03474260f, -0.06767260f, -0.01535037f, 0.10335380f, 0.14316057f, 
    -0.13254391f, 0.00616014f, 0.03266948f, 0.24337658f, 0.09325597f, -0.03726051f, -0.09078328f, 0.13883898f, 
    -0.13050126f, -0.02185296f, 0.10162439f, 0.05337574f, 0.04990288f, 0.03410774f, 0.00897227f, -0.08421461f, 
    0.20725337f, -0.04144888f, -0.01095537f, 0.06906035f, 0.05186910f, 0.09284330f, -0.08895227f, 0.01724447f, 
    -0.27780777f, 0.06142994f, 0.05169358f, -0.16378927f, -0.00643337f, 0.00139695f, 0.01784877f, 0.08875146f, 
    0.03050226f, 0.11144663f, 0.09003635f, 0.10145654f, -0.34286207f, -0.24166183f, 0.10041352f, 0.08747817f, 
    0.23401329f, 0.09637786f, 0.05617437f, 0.07951161f, 0.01544791f, 0.01701820f, 0.10831741f, 0.03118407f, 
    0.34553751f, -0.00161945f, -0.22743611f, 0.09352275f, 0.12521343f, -0.07552348f, 0.01604880f, 0.07663497f, 
    0.18100141f, -0.04451302f, 0.12502007f, 0.10963067f, -0.42102599f, -0.23896357f, -0.09114402f, -0.07006969f, 
    -0.09910897f, -0.17631081f, -0.09365170f, -0.06235377f, -0.02037993f, 0.03231909f, 0.08817773f, 0.16190229f, 
    0.08179884f, 0.03415658f, -0.13591982f, -0.07104930f, 0.02735499f, 0.11103952f, 0.07048663f, -0.20294052f, 
    0.12405600f, 0.09409232f, -0.09235737f, -0.06857941f, -0.14630239f, -0.17983198f, -0.13309443f, -0.14730206f, 
    0.01323523f, 0.08127502f, -0.02797574f, -0.17216964f, 0.11794761f, 0.03609155f, -0.08950087f, -0.18103677f, 
    -0.19919321f, -0.29953071f, -0.27733615f, -0.05762767f, 0.02270168f, -0.02778769f, -0.01525368f, -0.00292203f, 
    0.02405246f, 0.06025434f, 0.10868765f, -0.16913390f, 0.01110831f, 0.00965074f, -0.01856812f, 0.05916207f, 
    0.03702475f, 0.07569221f, -0.01281175f, 0.00857149f, 0.01460441f, 0.03929097f, -0.06692147f, -0.03411004f, 
    0.03444861f, 0.01244048f, -0.06596018f, -0.04813401f, -0.07321245f, -0.30654210f, -0.10407072f, 0.18149169f, 
    0.00837418f, 0.02902484f, 0.00696194f, -0.01793441f, -0.04258696f, 0.09184095f, 0.01207345f, 0.03767719f, 
    0.05820652f, 0.04053231f, -0.13185617f, 0.05471790f, 0.02379737f, -0.01656594f, 0.01840783f, 0.04997109f, 
    -0.31455985f, -0.25773472f, -0.13299425f, -0.16195101f, -0.00106287f, 0.06391221f, -0.05008835f, -0.12514824f, 
    -0.05038365f, -0.15005508f, -0.09263448f, -0.16114502f, 0.00392755f, -0.00856911f, 0.03074298f, -0.02253530f, 
    0.08444002f, -0.09036486f, 0.05545481f, -0.03190356f, -0.04366198f, 0.02138540f, -0.17183580f, 0.06430668f, 
    -0.36460888f, -0.12700322f, -0.06508084f, -0.12486272f, -0.08584167f, -0.16713078f, -0.05987260f, -0.02767268f, 
    -0.04729679f, -0.13147986f, -0.13741907f, -0.03049272f, 0.01431768f, -0.02126421f, -0.25411141f, -0.21494254f, 
    0.10514921f, 0.00705805f, -0.11535497f, 0.18502764f, -0.03735539f, 0.01763362f, -0.03593912f, 0.01179783f, 
    0.04781277f, -0.04379552f, -0.13339218f, -0.12779923f, 0.00628865f, 0.11211991f, -0.05213270f, -0.02597826f, 
    -0.06150874f, -0.02931172f, 0.01629168f, -0.08708201f, -0.04880987f, -0.04526608f, -0.06298514f, 0.03124511f, 
    -0.03960298f, -0.01420580f, -0.02836275f, 0.00492613f, -0.03360128f, -0.03608663f, -0.00173886f, -0.00105829f, 
    0.04803688f, 0.09196342f, -0.18469898f, -0.22996752f, 0.10552607f, 0.02877358f, 0.04468724f, -0.12863380f, 
    0.00500881f, -0.03993361f, 0.01250829f, 0.02136044f, -0.06757728f, 0.01029542f, 0.07003289f, -0.03799319f, 
    -0.00411384f, -0.10933213f, -0.10300798f, -0.03789344f, -0.04641644f, -0.08931958f, 0.00393103f, 0.01235988f, 
    -0.02653364f, -0.01978750f, 0.11655930f, 0.08307797f, 0.01074181f, 0.02690679f, -0.06109120f, 0.03563549f, 
    -0.16872366f, 0.00625353f, 0.01301486f, -0.00076085f, -0.11921720f, -0.13179603f, -0.07842928f, -0.00306156f, 
    0.06888066f, 0.06643195f, 0.03405124f, 0.07492770f, 0.02207782f, 0.04511744f, 0.01364321f, -0.04512704f, 
    0.08990014f, 0.00979962f, 0.05198672f, -0.02728160f, -0.01234579f, 0.02285960f, 0.04046800f, 0.04318949f, 
    -0.06681632f, -0.12831250f, -0.19429602f, -0.04583009f, -0.10914852f, -0.31188101f, -0.26286021f, -0.10275411f, 
    0.02892799f, 0.05604765f, -0.02253946f, 0.02799414f, 0.05242628f, -0.14580695f, -0.11658825f, -0.09461249f, 
    -0.02528891f, 0.10699368f, 0.08604824f, -0.01907404f, -0.08796416f, -0.01627620f, -0.04699655f, -0.10591550f, 
    -0.14329545f, -0.05739062f, -0.02865757f, -0.17188226f, -0.05899330f, 0.10396665f, 0.11528876f, 0.04380859f, 
    0.05216748f, -0.04224958f, -0.02679791f, 0.01548601f, 0.20178254f, -0.05888862f, -0.09586087f, 0.08719634f, 
    -0.00898791f, -0.09741680f, 0.01349584f, -0.01217228f, 0.01150635f, -0.04912641f, 0.06099448f, 0.19508357f, 
    -0.13653556f, -0.10690927f, -0.01900656f, -0.08405062f, -0.08804648f, 0.00183646f, 0.11479208f, -0.02650760f, 
    -0.03165562f, 0.01411827f, 0.02844638f, -0.05690676f, -0.13311347f, 0.05718007f, 0.03881466f, -0.09294250f, 
    0.02610560f, 0.06267710f, -0.01000387f, -0.00634265f, 0.04140280f, 0.02255580f, 0.01114225f, -0.10350463f, 
    -0.16040777f, -0.07104575f, 0.00298821f, -0.08614384f, -0.07386928f, 0.00738500f, 0.04300592f, -0.06921659f, 
    -0.01368259f, -0.05538461f, -0.08219884f, -0.06732638f, -0.06655632f, -0.02968870f, -0.03930364f, -0.08726469f, 
    0.13396348f, 0.05317505f, -0.22502899f, 0.00917724f, 0.03538798f, -0.04790621f, -0.13519499f, -0.06385847f, 
    0.07501242f, 0.20901705f, -0.24286571f, -0.18714930f, 0.00915944f, 0.02234942f, 0.08354244f, 0.00228058f, 
    0.02899026f, 0.00649524f, -0.04926989f, 0.08726300f, -0.00677759f, -0.02102853f, -0.19643041f, 0.14567630f, 
    -0.00761896f, -0.02776832f, 0.05476381f, 0.05958663f, 0.05595025f, -0.00765023f, 0.04861325f, -0.09772012f, 
    -0.16597235f, -0.09882741f, -0.11289821f, -0.06693963f, -0.03753553f, -0.05819811f, -0.13091460f, -0.34711888f, 
    -0.05243940f, -0.00337356f, 0.03883278f, 0.04099681f, 0.02345440f, 0.03208955f, -0.06463991f, 0.01342487f, 
    0.00702267f, 0.05850968f, 0.10271100f, 0.04979894f, -0.04871089f, -0.09841221f, 0.04615802f, 0.14321168f, 
    -0.18783233f, -0.06055140f, -0.21661800f, 0.04968712f, -0.02985720f, 0.12765455f, 0.03753649f, -0.10770830f, 
    -0.00113501f, 0.10090070f, 0.09453899f, 0.06011406f, -0.04439892f, -0.01635190f, -0.04127725f, 0.03687927f, 
    0.01092113f, 0.04009219f, -0.03079650f, 0.08855321f, -0.09090374f, 0.04563180f, -0.02638173f, -0.03368708f, 
    -0.18140878f, 0.01471115f, -0.01025997f, 0.02042550f, 0.04050499f, 0.03097303f, -0.01157850f, 0.05297162f, 
    -0.01158942f, 0.01215843f, -0.04383215f, 0.03594497f, -0.10779983f, -0.13376758f, -0.07877158f, -0.02355776f, 
    0.37540042f, 0.45078522f, 0.13888288f, 0.05851455f, 0.05019997f, -0.01641462f, 0.04746054f, 0.14816178f, 
    -0.02957223f, -0.12365957f, -0.12654243f, -0.03501271f, 0.25939849f, -0.07974726f, -0.02437603f, -0.04302754f, 
    0.00852644f, 0.04787093f, -0.10326799f, 0.08092231f, 0.03286468f, -0.08530962f, -0.08562279f, 0.05077321f, 
    0.12660635f, 0.00231049f, 0.01606196f, 0.27767506f, -0.00340424f, -0.08222382f, 0.00115032f, -0.05527657f, 
    0.14899459f, -0.04060521f, 0.05282060f, -0.07125193f, 0.11934314f, 0.38889447f, 0.27391589f, 0.04898460f, 
    0.09094005f, 0.07283602f, -0.04994506f, -0.01447310f, -0.00953956f, -0.17116851f, -0.02554220f, 0.04353315f, 
    0.24614251f, 0.23861510f, 0.07718368f, 0.01797050f, -0.00933346f, -0.08376885f, -0.02399398f, 0.14051491f, 
    -0.05053933f, -0.03896412f, 0.00911603f, -0.12566675f, 0.00091259f, -0.19815855f, -0.15680046f, -0.13381876f, 
    0.06807998f, -0.06142957f, 0.00440235f, 0.10103781f, 0.00429952f, -0.05821389f, -0.10038830f, 0.13556965f, 
    -0.09658995f, 0.27486753f, -0.07148664f, -0.00501834f, 0.02251554f, 0.00934384f, -0.04223607f, -0.00096699f, 
    0.04728792f, -0.09051401f, 0.08128661f, 0.05136586f, 0.15085518f, -0.43120193f, 0.04597263f, -0.24504547f, 
    0.15033178f, -0.08484901f, 0.14393212f, 0.03864314f, 0.01060347f, -0.02523422f, -0.02232233f, 0.07755266f, 
    0.21684898f, 0.19494988f, 0.12906265f, 0.03004799f, 0.06356012f, 0.10093765f, 0.07495187f, 0.00631198f, 
    -0.07001018f, -0.19576886f, 0.10176819f, 0.00806390f, 0.10656296f, 0.20009036f, 0.26028973f, -0.11681416f, 
    -0.06437853f, -0.00450040f, 0.01622296f, 0.20484158f, 0.04783480f, 0.02209893f, -0.06667466f, 0.06735533f, 
    -0.09157635f, -0.22049914f, -0.27910683f, -0.05697612f, 0.02529826f, 0.01468942f, -0.03561824f, -0.14195751f, 
    0.03779869f, -0.00033815f, -0.06793994f, 0.10148264f, -0.29423106f, -0.42745027f, -0.22561027f, 0.01742203f, 
    0.15299030f, -0.04525287f, -0.08052349f, 0.03801464f, 0.04767885f, 0.00335215f, 0.08810767f, 0.04847769f, 
    0.21908696f, 0.23466712f, 0.29570618f, 0.10871345f, 0.07238695f, 0.05716055f, 0.06836206f, 0.06279468f, 
    0.04678772f, 0.06018039f, -0.09147713f, 0.02742825f, -0.20407702f, -0.16691820f, -0.04390352f, -0.14992838f, 
    0.10289560f, 0.03459494f, -0.07250760f, 0.11905491f, 0.05279954f, -0.06136030f, 0.00588083f, 0.00136183f, 
    -0.35185793f, -0.23758850f, -0.36380672f, 0.32349455f, 0.00069594f, -0.17571954f, -0.06970333f, -0.03171772f, 
    0.00860142f, -0.06336907f, -0.12631296f, 0.14073770f, 0.13008118f, 0.28742975f, 0.13649510f, 0.13726337f, 
    0.06282135f, 0.06162908f, 0.04021052f, 0.01427525f, 0.03322992f, -0.04581286f, -0.08097642f, -0.04246094f, 
    0.25516680f, -0.57033259f, -0.14606073f, -0.20328321f, -0.07457369f, -0.04501507f, -0.07091330f, 0.11087006f, 
    0.15137231f, -0.04370843f, 0.15065886f, 0.02698425f, -0.07665399f, -0.03039495f, 0.16881090f, 0.18015954f, 
    0.07085741f, -0.04967998f, -0.01682310f, 0.03603722f, -0.06867999f, -0.01231608f, -0.05890960f, 0.04670695f, 
    0.15769035f, -0.14783178f, -0.05023154f, -0.22279707f, -0.06821772f, 0.02238531f, 0.07397912f, -0.11240570f, 
    0.09247618f, -0.01159570f, -0.01328349f, -0.11291795f, 0.13975884f, -0.40945625f, -0.11097939f, -0.08700190f, 
    -0.02875576f, -0.03883333f, -0.06297679f, 0.03859061f, 0.03071715f, -0.15069512f, 0.00983280f, -0.03181931f, 
    0.15727192f, -0.30512568f, 0.28381062f, 0.25925595f, -0.04825459f, -0.04865885f, -0.03749881f, -0.11469691f, 
    0.12145303f, -0.04531111f, -0.00447074f, 0.03580691f, -0.08470140f, -0.00820781f, 0.10855777f, 0.07792961f, 
    0.02836268f, -0.06715220f, -0.02007717f, -0.02795684f, 0.12351184f, -0.08378375f, -0.08206288f, -0.11244542f, 
    -0.06244799f, 0.20892175f, 0.14121574f, -0.01557664f, -0.01351474f, 0.03395196f, 0.11923707f, 0.15712330f, 
    0.12450324f, -0.07731306f, 0.02580096f, -0.09736682f, -0.25805384f, -0.32375789f, -0.06207018f, -0.15135957f, 
    0.08155120f, 0.19617505f, 0.05660830f, 0.04990204f, 0.10555162f, -0.00939979f, 0.05563371f, -0.06746326f, 
    0.18766940f, -0.15805171f, -0.17193541f, -0.34302795f, -0.00964391f, 0.17684226f, 0.07227465f, 0.01036585f, 
    0.01211761f, 0.03238736f, -0.03313314f, 0.06136191f, -0.00277465f, -0.35726526f, 0.18585180f, 0.04469079f, 
    0.04712469f, -0.01905137f, -0.13442641f, 0.07292753f, 0.01043430f, 0.06484865f, 0.08927949f, 0.12086678f, 
    0.19686607f, -0.06890337f, -0.05028365f, 0.01167045f, 0.02410677f, 0.08715995f, 0.08131178f, 0.08068080f, 
    -0.05393033f, 0.02326030f, 0.17375588f, 0.07622340f, 0.00597404f, 0.42233083f, -0.01646104f, -0.00440451f, 
    0.06319433f, -0.05781548f, 0.17378521f, 0.20532684f, 0.05259216f, -0.09392225f, -0.00692951f, -0.01770096f, 
    0.13357739f, -0.45599449f, 0.26872823f, -0.01213364f, -0.06720120f, -0.10444663f, -0.04633593f, 0.02011594f, 
    0.18555345f, 0.10475905f, 0.02216210f, -0.10698336f, 0.36024672f, 0.25704175f, -0.03070831f, -0.13246319f, 
    0.00058745f, -0.04473731f, 0.11026175f, 0.14257948f, -0.09972069f, -0.09155447f, 0.02451256f, -0.05320764f, 
    -0.24145699f, -0.00667217f, -0.18711208f, 0.32855612f, -0.04434812f, -0.16226837f, -0.03982105f, 0.10234052f, 
    -0.05363258f, 0.14890926f, -0.12924282f, 0.19302818f, -0.30280259f, -0.40476939f, -0.12430495f, 0.08620738f, 
    0.17238715f, 0.11469229f, 0.02667941f, 0.01780617f, 0.13484652f, 0.00404971f, 0.17848323f, 0.14502637f, 
    -0.04421897f, -0.00668922f, -0.00086447f, 0.00470763f, -0.03978482f, -0.04096799f, 0.02876624f, -0.02397512f, 
    0.01361001f, -0.01594350f, -0.04763078f, -0.01901299f, -0.00814470f, 0.01180194f, -0.02777604f, 0.04509825f, 
    0.00263385f, -0.00211172f, -0.03667590f, 0.02906020f, 0.03386916f, -0.00876133f, 0.04321613f, 0.03179180f, 
    -0.03139010f, -0.04319358f, -0.00685467f, 0.00116759f, -0.01376556f, -0.01366413f, -0.00085066f, -0.01848168f, 
    0.00515089f, -0.04793509f, 0.02994129f, -0.01256793f, -0.05130292f, -0.03022749f, 0.01121611f, -0.03020609f, 
    -0.04192292f, 0.04629626f, 0.00412677f, 0.04910067f, 0.02227605f, -0.01212328f, -0.02872922f, -0.04404580f, 
    -0.02114277f, 0.01969665f, 0.03708809f, 0.04417869f, -0.03938762f, 0.01041157f, -0.03479946f, -0.04660992f, 
    -0.02684221f, -0.04812592f, 0.04263702f, -0.02406234f, 0.02635376f, -0.04642836f, 0.01706493f, -0.03631392f, 
    0.00559546f, -0.01551258f, -0.04855841f, -0.03158058f, 0.00065299f, -0.01490422f, -0.04685677f, -0.02428858f, 
    -0.03680321f, 0.01689174f, 0.00441265f, -0.00313095f, 0.01946211f, 0.03402206f, -0.00134648f, -0.04382335f, 
    -0.02767170f, 0.01545390f, 0.02714009f, -0.01034743f, -0.02760005f, 0.03754072f, -0.01691232f, -0.03560811f, 
    0.03692804f, 0.02364608f, 0.01031583f, -0.00602886f, 0.03179926f, -0.04208541f, 0.00672185f, -0.01037140f, 
    0.04418908f, 0.03524935f, 0.04306689f, -0.03465544f, -0.02548164f, 0.01629874f, 0.02068216f, -0.04446454f, 
    0.04599703f, 0.04182788f, -0.00214947f, 0.00337985f, -0.00992300f, -0.03331660f, 0.01627399f, -0.02726176f, 
    -0.01501702f, -0.04373178f, 0.02831795f, -0.02314303f, 0.00759129f, 0.00932201f, 0.02827685f, 0.01828509f, 
    0.03284057f, -0.00438884f, 0.05460957f, 0.02394060f, -0.02002075f, -0.01826386f, 0.04922646f, -0.04316741f, 
    -0.00470122f, 0.03517219f, 0.02750353f, 0.03211871f, -0.00227299f, 0.00497636f, -0.05307458f, 0.02489357f, 
    0.03081738f, -0.00302141f, 0.03799877f, -0.03306911f, 0.01196363f, 0.00892234f, -0.01253802f, 0.04694148f, 
    -0.04883908f, -0.04904054f, -0.02502316f, -0.04096029f, 0.00735786f, 0.03540627f, -0.00776861f, -0.03146417f, 
    -0.01977657f, 0.00647826f, 0.03485131f, 0.00716355f, -0.03556698f, -0.00262381f, -0.03334017f, -0.02627371f, 
    0.01891037f, 0.01840984f, -0.02697802f, 0.05029285f, -0.01126966f, -0.04067727f, 0.04372947f, -0.02877250f, 
    -0.05105801f, -0.01821425f, 0.00011505f, -0.03590384f, 0.02172915f, 0.01145555f, 0.01612048f, 0.04654804f, 
    -0.00966074f, -0.01401777f, -0.05503697f, 0.02447322f, 0.04849609f, -0.02458303f, 0.04428660f, -0.03628069f, 
    -0.01974628f, 0.03925268f, -0.01262709f, -0.01383051f, -0.01171351f, -0.02736770f, 0.02105735f, 0.03495175f, 
    -0.02982328f, -0.02697603f, -0.01756277f, 0.03562220f, -0.01691524f, 0.04704668f, -0.02509824f, -0.02506757f, 
    0.01669127f, 0.00478049f, -0.04450079f, -0.02364380f, -0.01012772f, 0.00143904f, -0.02318812f, 0.02838701f, 
    0.04593459f, -0.00070742f, -0.04100024f, 0.04646431f, 0.04411797f, 0.00086814f, -0.03216382f, -0.05329200f, 
    0.04861163f, 0.02551047f, 0.02383112f, -0.02880619f, 0.02529950f, -0.04533803f, 0.02652976f, 0.01815584f, 
    -0.01523140f, -0.04113579f, 0.04338484f, 0.03404501f, -0.02882646f, 0.01352717f, -0.05056671f, -0.04223112f, 
    -0.01225557f, -0.04662120f, -0.01747246f, -0.01081535f, -0.04699550f, -0.02024478f, 0.01091594f, 0.04252273f, 
    0.01064362f, -0.05309398f, 0.00708210f, 0.03530668f, 0.04662621f, 0.00306159f, 0.02681317f, -0.01730700f, 
    0.03375914f, 0.02321807f, -0.01222108f, -0.03107548f, 0.01188826f, -0.03795015f, 0.02472229f, -0.00114108f, 
    0.01363259f, 0.04610860f, 0.04536651f, 0.04897496f, -0.01181538f, -0.05477176f, -0.00868740f, -0.00522669f, 
    0.00488408f, 0.00570387f, 0.02877887f, -0.04542967f, -0.01171755f, -0.00303037f, 0.01678009f, -0.01472254f, 
    0.02957996f, -0.01774236f, -0.03166949f, -0.00173658f, 0.03369122f, -0.04395056f, -0.02979966f, -0.01750285f, 
    -0.01442373f, -0.01035226f, 0.01781559f, 0.04068850f, -0.02552207f, -0.02430634f, 0.02676389f, -0.04434062f, 
    -0.03794364f, 0.00961124f, -0.02627283f, -0.02981094f, -0.01203978f, -0.04491068f, 0.03421273f, -0.03464366f, 
    -0.02542237f, 0.02859381f, -0.03629468f, -0.02798345f, 0.04186145f, -0.02534058f, -0.03501878f, -0.01768905f, 
    -0.00388862f, -0.01495217f, -0.01806221f, 0.03640300f, -0.05191039f, 0.00203790f, 0.00594575f, -0.04063817f, 
    0.00016401f, 0.04468328f, -0.01204701f, 0.04664117f, 0.00240449f, -0.01343747f, 0.02364327f, -0.03672716f, 
    -0.02002790f, -0.04668633f, 0.03967252f, -0.03402694f, -0.05389756f, 0.00887683f, 0.01452944f, -0.00197115f, 
    -0.04832802f, -0.01215597f, 0.00571129f, 0.02950476f, 0.03381223f, -0.04464122f, -0.02426113f, 0.00718937f, 
    -0.03006806f, 0.01665227f, 0.00173775f, 0.02523089f, -0.05155985f, 0.01946204f, -0.02184010f, 0.00772525f, 
    -0.04474982f, -0.04486405f, -0.03600188f, -0.03739855f, 0.01364017f, 0.02650497f, -0.03648532f, -0.05370573f, 
    0.03447031f, -0.03371096f, -0.02641340f, -0.02560384f, -0.03183686f, -0.01741968f, -0.00803713f, 0.03680303f, 
    0.02630603f, -0.01226981f, -0.04215153f, 0.01067465f, -0.00280580f, -0.00769647f, -0.00462447f, 0.01999440f, 
    0.00036967f, 0.04351766f, 0.01678876f, -0.02813560f, 0.03898752f, -0.04506433f, -0.01773501f, 0.01225150f, 
    0.03795094f, -0.02340904f, -0.02499813f, 0.00821111f, -0.01714650f, 0.03602261f, 0.03496272f, 0.04234016f, 
    -0.32170388f, -0.20789431f, 0.21503131f, 0.16658416f, -0.22525550f, -0.03726550f, 0.01012011f, 0.03438966f, 
    0.04087659f, 0.03359549f, 0.04011165f, -0.06762694f, 0.29880092f, 0.36103374f, 0.27599090f, 0.09112028f, 
    -0.00305142f, 0.13325934f, 0.03709590f, 0.09744948f, 0.17481205f, 0.09246190f, 0.07722306f, 0.03816732f, 
    -0.15435742f, 0.27703848f, 0.30838129f, 0.14876044f, -0.10193606f, 0.02415223f, -0.02827451f, -0.01543813f, 
    -0.04509368f, 0.03351238f, 0.07895164f, -0.04600586f, -0.28682902f, -0.21849661f, -0.02992000f, 0.02466725f, 
    0.00700172f, 0.00267587f, -0.07927347f, 0.08025102f, 0.05053793f, 0.10352337f, 0.04046221f, 0.05159874f, 
    -0.12126354f, -0.11061984f, -0.15018529f, -0.31125179f, 0.10641347f, -0.09458111f, -0.08565671f, -0.05373862f, 
    0.00567201f, 0.04052686f, 0.09074567f, 0.02178210f, 0.06866145f, -0.01953027f, -0.15528527f, -0.04226112f, 
    -0.11222422f, 0.01178311f, 0.01134119f, -0.07878290f, -0.07392013f, -0.07542403f, -0.08131945f, -0.16632526f, 
    0.06002688f, 0.00855800f, 0.06669761f, -0.07743748f, 0.05444374f, -0.03306391f, -0.01030980f, -0.20421407f, 
    0.03967423f, 0.07583734f, -0.01336672f, -0.08108830f, -0.03624873f, 0.19207524f, -0.16423246f, 0.20433903f, 
    -0.12200998f, 0.21666068f, -0.06505559f, 0.08553928f, 0.18756297f, 0.00766883f, 0.14420094f, 0.02428906f, 
    -0.12086435f, -0.00786349f, -0.08182050f, 0.02263894f, 0.07912784f, 0.13875005f, 0.02054068f, -0.05891072f, 
    0.15568784f, 0.06759980f, 0.03888775f, -0.06710055f, -0.29000244f, -0.49134058f, 0.22533685f, -0.01344707f, 
    -0.07337308f, 0.02426227f, -0.14170654f, -0.01443218f, 0.04848455f, -0.03719429f, -0.08375409f, -0.17051324f, 
    0.24260762f, 0.27369785f, 0.13617136f, -0.02262412f, 0.08420605f, -0.10385289f, 0.01733386f, -0.08294696f, 
    0.10895979f, -0.04922697f, -0.07322826f, 0.02474554f, 0.01325284f, 0.02785210f, -0.04913900f, -0.08537795f, 
    -0.15660687f, -0.13018169f, -0.03957506f, -0.10662788f, -0.11116412f, -0.05253408f, -0.04960046f, -0.04242781f, 
    -0.36641416f, 0.05125482f, -0.10410536f, 0.25823331f, -0.17359029f, 0.04506384f, -0.10322239f, -0.10818341f, 
    -0.06215111f, -0.03734714f, 0.01099923f, -0.11117491f, -0.02105996f, 0.05599827f, -0.15861849f, 0.10153084f, 
    0.03286767f, -0.02168330f, 0.01143806f, 0.07306889f, -0.08628675f, 0.05634297f, -0.08957876f, 0.03384395f, 
    -0.20073345f, -0.11455685f, -0.22642018f, 0.12142111f, 0.08140516f, 0.07045622f, -0.14282525f, 0.00717248f, 
    -0.03905447f, 0.12360717f, -0.03346564f, 0.17913488f, -0.15573998f, -0.03286589f, 0.18661812f, 0.16461058f, 
    -0.08162307f, -0.06523406f, 0.03477045f, 0.00809481f, -0.07255312f, 0.05147256f, 0.07853499f, 0.02545920f, 
    0.40746424f, 0.17472659f, 0.38888210f, 0.07365131f, -0.01158912f, 0.05491751f, -0.18306793f, -0.10215094f, 
    0.13252625f, 0.04761622f, 0.05319630f, 0.21041271f, -0.18391503f, -0.10685997f, 0.24384195f, 0.15275577f, 
    -0.09777930f, 0.04367144f, 0.00306488f, 0.03896354f, 0.04232948f, 0.01368951f, -0.06716869f, -0.12647179f, 
    0.01921088f, 0.12603931f, 0.16842960f, -0.02455632f, -0.07469020f, 0.01008910f, -0.01716131f, 0.13978282f, 
    0.03697382f, -0.01401597f, 0.07844934f, 0.01837853f, -0.00025064f, 0.19728239f, 0.12014657f, -0.11191669f, 
    -0.07790320f, -0.04505911f, -0.13602786f, -0.08651309f, 0.15590124f, 0.07957140f, -0.07904973f, 0.04567436f, 
    -0.43585166f, 0.10117366f, -0.34536856f, 0.16607355f, -0.14809430f, 0.01169831f, 0.11443451f, 0.11723001f, 
    -0.08046447f, -0.00302879f, 0.05201524f, 0.00413112f, 0.03918039f, -0.03604521f, 0.13144270f, 0.00179264f, 
    0.01903932f, 0.04812770f, 0.00613503f, 0.10022438f, 0.07501013f, 0.19476688f, 0.18692102f, 0.15362637f, 
    -0.38205484f, 0.05832050f, 0.11465274f, 0.33821514f, 0.03140461f, -0.10872446f, 0.03743962f, -0.07508955f, 
    -0.09106511f, 0.11009546f, -0.15995783f, -0.09324436f, -0.09293302f, 0.05949478f, -0.17872624f, 0.00639203f, 
    0.00382599f, -0.14196959f, -0.10393914f, -0.12237172f, -0.02066451f, 0.02467375f, -0.04899630f, 0.05111622f, 
    0.29604232f, 0.61007315f, 0.25560066f, -0.01570156f, -0.04471555f, 0.08301531f, 0.01438228f, 0.02766110f, 
    0.07292307f, 0.12929194f, -0.04391657f, -0.00984364f, 0.04381018f, 0.02358523f, 0.01323650f, 0.26209921f, 
    0.03167395f, -0.00689483f, -0.03892577f, 0.02132161f, 0.12799816f, -0.02065835f, -0.18062922f, 0.19423011f, 
    -0.13084574f, 0.14753109f, 0.09242561f, -0.00335802f, -0.13711606f, -0.10106723f, -0.05341693f, -0.21193130f, 
    0.18030426f, -0.06582498f, 0.00483016f, -0.02157699f, -0.02908806f, -0.25534573f, 0.33181453f, 0.09367944f, 
    0.05667810f, -0.13301611f, 0.11777312f, -0.00414184f, -0.03091039f, 0.14666590f, 0.10127579f, 0.02481283f, 
    -0.13784787f, -0.16941729f, -0.12456719f, 0.28118142f, 0.13708326f, -0.03369620f, 0.06057258f, 0.15059605f, 
    0.07936466f, 0.05420063f, -0.00063009f, 0.13307843f, -0.08261451f, -0.14755702f, 0.06444708f, 0.02108894f, 
    -0.02698497f, 0.05137287f, -0.02370935f, -0.19155219f, 0.03474312f, 0.00438047f, -0.06105702f, 0.17143220f, 
    0.12353075f, -0.03779686f, 0.04505110f, -0.12899356f, -0.08995731f, 0.15221269f, -0.21631698f, -0.09566927f, 
    0.10414562f, -0.01063343f, -0.01252289f, 0.08812353f, -0.11496008f, -0.04042755f, -0.02009757f, -0.07173023f, 
    -0.14557594f, -0.13333054f, 0.01286407f, -0.08706450f, 0.02603937f, -0.01113672f, -0.04840936f, -0.05882625f, 
    -0.03699194f, 0.00536155f, 0.02857348f, -0.01953149f, 0.02100410f, 0.04914708f, -0.01514500f, -0.04790394f, 
    -0.00382414f, 0.03269422f, 0.03155545f, 0.03867519f, -0.02102663f, 0.01448715f, -0.00828725f, -0.01174148f, 
    -0.04481097f, -0.04321807f, 0.00018738f, 0.00666471f, -0.04169715f, 0.03238942f, -0.04475991f, -0.02595407f, 
    -0.04794117f, 0.03593175f, 0.03351657f, 0.03549048f, -0.01049003f, 0.00264291f, 0.03730896f, -0.02321153f, 
    -0.05201869f, -0.04365224f, 0.04389386f, -0.03098174f, 0.00530780f, -0.01261957f, -0.03652725f, -0.00661321f, 
    -0.00402113f, 0.03760868f, 0.00642730f, -0.03504276f, -0.00347577f, -0.00654808f, 0.00435201f, -0.02654260f, 
    0.01722043f, 0.02321945f, 0.00183486f, 0.00871392f, -0.03367076f, 0.00857649f, -0.01220951f, 0.05133567f, 
    -0.03048990f, -0.03011722f, 0.00683445f, -0.05062712f, 0.00952986f, -0.02197130f, -0.02936093f, 0.03106455f, 
    0.03899335f, -0.05174277f, -0.00918456f, -0.05555331f, 0.00935641f, -0.03073995f, 0.01812583f, -0.03995624f, 
    -0.00704133f, 0.01494007f, 0.02438005f, 0.02622135f, -0.01422886f, -0.00438649f, 0.01202666f, -0.01295735f, 
    -0.03480818f, 0.00271448f, -0.02518261f, -0.02219008f, 0.03119985f, 0.03840153f, 0.03206352f, 0.00852899f, 
    -0.01641133f, 0.01279136f, 0.00772900f, -0.05858389f, 0.00344432f, -0.05622211f, -0.01770964f, -0.02567686f, 
    -0.04570513f, 0.01845795f, 0.00627253f, -0.04457789f, 0.04963475f, -0.03405326f, 0.02880660f, -0.02379682f, 
    0.01211758f, -0.01924863f, -0.02659203f, -0.00575955f, -0.00677394f, -0.03210075f, -0.04255462f, 0.01557128f, 
    0.04825945f, 0.01415004f, -0.01351160f, -0.04784907f, 0.03165145f, -0.02598990f, -0.03607250f, 0.03880651f, 
    -0.02244249f, 0.03393741f, 0.02726152f, -0.04456578f, -0.03991479f, 0.00862773f, -0.02872882f, 0.02951954f, 
    -0.05769547f, -0.02176923f, -0.00534538f, -0.00006398f, 0.00680992f, -0.02602600f, -0.00323603f, -0.01839220f, 
    -0.01403994f, -0.01718329f, 0.01690095f, 0.03019001f, 0.01897731f, 0.04199535f, 0.03720099f, -0.00668927f, 
    -0.00193116f, 0.00445274f, 0.04077316f, -0.02459128f, -0.01974468f, -0.01712200f, 0.02332017f, 0.03290227f, 
    -0.01978544f, -0.00140632f, -0.02713042f, 0.04520159f, -0.05049193f, 0.02563386f, -0.00335431f, -0.05444529f, 
    -0.02925861f, -0.02038644f, -0.03349363f, -0.02656538f, 0.01476299f, -0.02216554f, -0.04516341f, -0.05582213f, 
    0.03890651f, 0.00004321f, -0.02830843f, -0.04181544f, -0.04294727f, -0.02213709f, -0.05718426f, -0.03053496f, 
    -0.02887179f, -0.02075495f, -0.02412034f, -0.01052726f, 0.04977348f, -0.03827401f, 0.03890177f, 0.00650345f, 
    0.03412946f, 0.04576390f, -0.03155402f, -0.04101866f, -0.00812672f, -0.03741530f, -0.02727395f, -0.05781553f, 
    -0.05351647f, -0.00231447f, -0.05125070f, 0.03309491f, -0.01726395f, 0.00021852f, 0.01355451f, 0.04286490f, 
    -0.02409234f, 0.04122134f, 0.00828571f, -0.01628661f, 0.00043284f, 0.02382820f, 0.01258974f, -0.02374429f, 
    0.01858328f, 0.01957469f, 0.03162178f, -0.04070137f, -0.05206529f, 0.00305160f, 0.05338294f, -0.01510805f, 
    -0.04443789f, 0.00692709f, -0.01104860f, 0.00321929f, -0.04607264f, -0.05573353f, 0.02962369f, -0.04686480f, 
    0.01820510f, -0.01726286f, -0.02316023f, -0.03643717f, 0.03798278f, -0.05251161f, -0.03182134f, -0.04715123f, 
    -0.03602834f, -0.00644572f, 0.00788329f, -0.01532210f, -0.02040466f, -0.01295181f, -0.02003172f, -0.05778335f, 
    0.04416284f, 0.02579171f, 0.02571876f, -0.02553748f, 0.03470827f, -0.03583615f, -0.00255448f, -0.03196036f, 
    -0.04070755f, 0.01043425f, 0.01595658f, -0.01174554f, 0.03607955f, 0.01360716f, 0.00220883f, 0.03509417f, 
    -0.03176385f, -0.02678502f, 0.03189147f, 0.00266105f, 0.01657484f, 0.02325558f, -0.00143004f, 0.00270365f, 
    0.04173540f, -0.04399232f, -0.01293926f, -0.05323657f, -0.00323628f, -0.00468238f, -0.01069612f, -0.03612964f, 
    -0.02368880f, -0.00677886f, 0.02117904f, -0.04050247f, 0.03998741f, 0.04282859f, 0.00868773f, -0.02175690f, 
    0.02308962f, -0.01198308f, 0.01949584f, -0.02611218f, -0.02545147f, -0.02233487f, -0.05782153f, -0.03853801f, 
    -0.03589022f, -0.02545525f, -0.01137017f, 0.01567073f, -0.01353568f, -0.01631833f, 0.04019722f, -0.02949788f, 
    0.02739365f, -0.00249675f, -0.04173724f, -0.03711891f, -0.03226902f, -0.02739588f, 0.01628629f, 0.01034685f, 
    0.03214218f, -0.03639183f, 0.00858426f, -0.00293768f, -0.02639097f, -0.05621032f, 0.02857870f, -0.01480114f, 
    -0.02472547f, -0.01234559f, 0.02475439f, -0.04279299f, -0.00162050f, -0.03865669f, 0.01978163f, 0.03871167f, 
    -0.05766833f, -0.04146525f, -0.03751464f, 0.01815794f, 0.03975034f, -0.02829148f, 0.01561382f, -0.00781605f, 
    -0.01650562f, 0.01903919f, 0.01702198f, -0.04856332f, 0.01291237f, -0.04757897f, 0.03818937f, -0.02554262f, 
    0.03294888f, -0.03468889f, 0.01252346f, 0.00724847f, 0.01597200f, 0.01820566f, -0.02711550f, 0.04046866f, 
    -0.03903756f, 0.01745842f, -0.00610407f, 0.04269046f, 0.01658498f, 0.02218318f, -0.03031599f, -0.01451038f, 
    0.02945680f, 0.03261200f, -0.02347885f, -0.05245209f, -0.03846570f, 0.03107768f, -0.05705129f, 0.02096051f, 
    -0.05517364f, -0.05446947f, -0.02764245f, 0.00045307f, -0.04775204f, 0.02717700f, 0.03169712f, -0.01136024f, 
    0.00637328f, 0.00355932f, -0.01001297f, 0.04775233f, -0.04093637f, -0.03771255f, -0.00481312f, -0.01906620f, 
    0.02643355f, 0.04096255f, 0.01789795f, 0.02118056f, 0.01472454f, 0.02419477f, -0.01101334f, 0.03961657f, 
    -0.28387642f, -0.27941781f, -0.08564623f, 0.12924080f, 0.01015594f, 0.10592623f, 0.04412505f, -0.00058212f, 
    -0.07251785f, -0.03121110f, 0.00652188f, -0.00720514f, 0.06805898f, 0.00194098f, 0.10616750f, 0.18438119f, 
    0.04924819f, 0.13140514f, 0.14913668f, 0.01214584f, 0.04055138f, 0.04525716f, 0.10727367f, 0.01165599f, 
    -0.07101359f, -0.19088578f, 0.03135946f, -0.10953549f, -0.03081403f, 0.10976207f, 0.02669390f, 0.18259116f, 
    0.01353972f, 0.10762563f, 0.06855699f, -0.01212573f, -0.09148679f, -0.18653211f, -0.06423794f, 0.24483435f, 
    0.02764092f, -0.09979846f, 0.08763466f, 0.06256321f, -0.06249277f, -0.05607698f, -0.12564343f, 0.02249108f, 
    -0.19931968f, -0.07034507f, -0.01564570f, -0.00333395f, -0.03545571f, 0.11709265f, -0.05222846f, -0.01431355f, 
    -0.13265242f, -0.09314816f, -0.03131961f, 0.01589691f, -0.00299442f, 0.02665732f, -0.07021745f, -0.11776963f, 
    -0.16328757f, -0.15250611f, -0.11411775f, -0.18077403f, -0.00892810f, -0.08809023f, -0.02021346f, -0.02032369f, 
    0.06881003f, 0.07008062f, 0.12309235f, 0.21950187f, -0.00193831f, 0.04931499f, 0.03306594f, -0.02020711f, 
    -0.13052072f, 0.02158633f, -0.07311826f, -0.09102217f, -0.10408325f, 0.38144520f, -0.20915936f, 0.24846910f, 
    -0.02175543f, 0.07604015f, 0.11474115f, -0.18282768f, 0.06472055f, 0.01800622f, 0.17514786f, 0.10637713f, 
    -0.13010813f, -0.05436226f, -0.08035721f, 0.10506377f, 0.00462786f, 0.05666012f, 0.01344748f, 0.00368058f, 
    0.06777339f, 0.07671328f, -0.12004448f, -0.10274644f, -0.00942518f, 0.10310034f, -0.02841796f, 0.08791479f, 
    0.00840503f, -0.02382435f, 0.14566419f, 0.02702413f, 0.02071201f, -0.03302201f, 0.08689000f, 0.02549306f, 
    0.23822179f, 0.01281034f, 0.20746443f, 0.01132473f, -0.01564855f, -0.03232945f, 0.05563762f, 0.05630143f, 
    0.17924261f, -0.09570446f, -0.10065500f, -0.17015547f, 0.15455073f, 0.21083723f, -0.04079083f, -0.04542794f, 
    -0.21871310f, -0.22851846f, -0.11934446f, -0.03455952f, -0.02825332f, 0.03504115f, -0.02397630f, -0.04692559f, 
    -0.12008402f, 0.04160560f, -0.30282292f, 0.08825101f, -0.08873152f, 0.10205965f, 0.10279365f, -0.05332275f, 
    0.01901771f, -0.04486024f, -0.07395843f, 0.03026606f, 0.07148583f, 0.09249648f, 0.07356864f, -0.07819836f, 
    -0.14104643f, -0.01651600f, 0.07424295f, 0.03038120f, -0.00738039f, 0.09230761f, 0.02778988f, 0.12682022f, 
    0.39696288f, -0.12617552f, -0.34869331f, 0.07837229f, 0.11034898f, 0.05842495f, 0.01401334f, -0.15210702f, 
    0.09491168f, 0.25174767f, -0.09643962f, 0.08894780f, -0.02522570f, -0.09978563f, 0.10584547f, 0.08901820f, 
    0.08409050f, 0.04850225f, -0.04517769f, 0.11411828f, -0.08869771f, 0.00987641f, -0.00986528f, -0.01224330f, 
    0.29900333f, 0.21213810f, 0.31800112f, -0.00311498f, 0.05956323f, -0.03864219f, 0.02288358f, -0.06141149f, 
    0.06461988f, 0.11816225f, -0.01758754f, 0.01790662f, 0.16663264f, 0.07807094f, -0.11039932f, -0.04676522f, 
    -0.05299965f, -0.10156495f, 0.04303901f, -0.00675673f, 0.03031306f, -0.00621634f, 0.04979311f, -0.18134522f, 
    -0.10643041f, -0.03993698f, 0.06742623f, -0.09051257f, -0.03100168f, -0.02757253f, 0.12016094f, 0.18609956f, 
    0.19175860f, 0.17684725f, 0.17187074f, 0.00841965f, 0.00247034f, 0.17300838f, 0.13828552f, -0.07918013f, 
    -0.07101931f, -0.15298320f, -0.07314401f, -0.10285207f, 0.03163007f, 0.13495010f, -0.09550932f, 0.14814973f, 
    -0.16569546f, 0.16605447f, -0.15388021f, -0.03433805f, 0.14613412f, 0.00220587f, -0.01012034f, 0.07215125f, 
    -0.15050510f, 0.00316263f, 0.07525317f, -0.17241383f, 0.06769003f, 0.11395197f, -0.09034770f, -0.00088458f, 
    -0.06253025f, 0.02469867f, 0.06132793f, 0.05880907f, -0.05251131f, 0.15214497f, 0.23162523f, 0.19056194f, 
    -0.02950360f, 0.08713397f, -0.14820521f, -0.13558583f, 0.13208723f, -0.02452585f, 0.13489285f, 0.07411055f, 
    -0.08168661f, 0.04299666f, -0.01026803f, -0.03430703f, -0.03435764f, 0.04371831f, 0.09477813f, -0.13233103f, 
    -0.21890362f, -0.12945198f, -0.17532465f, -0.06637321f, -0.04004292f, 0.08510645f, -0.03331352f, 0.06574161f, 
    0.18712002f, 0.40471792f, -0.00809652f, 0.23776348f, -0.08891932f, 0.04789907f, 0.05215462f, 0.02170035f, 
    0.02586975f, 0.11449516f, 0.13295346f, 0.10800828f, 0.08737412f, 0.17400682f, -0.10843047f, -0.02067295f, 
    -0.01222387f, -0.13174598f, -0.07273620f, 0.07714596f, 0.04491002f, 0.08385159f, -0.10671346f, 0.05653301f, 
    -0.17922971f, -0.05942206f, -0.14118075f, -0.11731856f, -0.09453280f, -0.06625140f, -0.00245519f, -0.11406984f, 
    0.15082225f, 0.07009632f, -0.10386634f, 0.02949885f, -0.07369564f, -0.14537242f, 0.28631037f, 0.19962582f, 
    0.15202646f, -0.00250575f, -0.08939528f, -0.00477054f, -0.11513080f, 0.07303584f, 0.06547809f, 0.06950428f, 
    -0.03596175f, 0.33070633f, -0.28990859f, -0.16013817f, 0.03065795f, 0.01667732f, 0.07698087f, 0.32609513f, 
    0.02704262f, 0.02680368f, 0.01940347f, 0.20630859f, -0.28646711f, -0.33559671f, 0.13443016f, 0.11718331f, 
    -0.06277417f, 0.04354842f, -0.04423639f, 0.01470647f, -0.03377873f, -0.01950761f, -0.12965220f, 0.12541410f, 
    0.26305810f, -0.00872237f, -0.12688220f, -0.26193962f, 0.01073223f, 0.12528220f, -0.04049917f, -0.16771945f, 
    0.08866832f, 0.05673265f, 0.27553937f, -0.00090512f, 0.03564898f, 0.07512736f, 0.03753842f, -0.12867428f, 
    -0.18830074f, -0.21158241f, -0.09008697f, -0.10515959f, 0.05431781f, -0.06752399f, -0.16088764f, -0.05134072f, 
    -0.01774933f, -0.04970432f, -0.01808084f, 0.00114737f, 0.01050064f, 0.00433313f, 0.00820807f, -0.04936695f, 
    0.01172271f, 0.03217360f, -0.00312842f, -0.02255483f, 0.03704920f, 0.00087890f, 0.02608184f, 0.01888866f, 
    -0.00217492f, -0.04408740f, -0.03745518f, -0.01651471f, 0.03574044f, -0.01484762f, 0.01913907f, 0.00651457f, 
    -0.03933838f, -0.03007340f, -0.05742759f, -0.03111001f, 0.03602719f, -0.05460988f, 0.00284291f, 0.03049186f, 
    0.03012158f, 0.02566838f, -0.01570366f, -0.01905023f, -0.00987558f, -0.02842531f, -0.03475277f, -0.03786075f, 
    0.02274134f, -0.00686089f, 0.02146347f, 0.00467679f, -0.03445262f, 0.02487057f, 0.03831017f, -0.04467268f, 
    -0.02196961f, -0.00773827f, -0.01617401f, 0.02927518f, 0.03516512f, -0.05325902f, -0.02084639f, -0.04994827f, 
    0.03245872f, 0.03579765f, -0.03809490f, 0.01685318f, 0.00244894f, 0.01078400f, 0.01603190f, -0.03776963f, 
    0.04127632f, -0.01732645f, 0.00785275f, 0.03401410f, -0.05077100f, 0.01063113f, 0.02891289f, -0.01249263f, 
    0.01904763f, 0.03908854f, -0.03638052f, 0.03179090f, -0.02176357f, 0.01579490f, -0.04588110f, -0.02150209f, 
    -0.00434140f, -0.05890901f, 0.04013560f, -0.02078302f, -0.04580560f, -0.00506015f, -0.05815948f, -0.02909452f, 
    -0.05135474f, -0.03576882f, -0.02413016f, -0.02785132f, 0.01651505f, 0.00972654f, 0.03495175f, 0.00526418f, 
    -0.05355157f, -0.01464644f, 0.04453046f, 0.02887249f, -0.03144279f, 0.00863998f, -0.02430348f, -0.03974003f, 
    -0.01235940f, -0.04108525f, -0.01286087f, -0.03238886f, -0.00578251f, -0.03315435f, -0.03220844f, 0.03689258f, 
    -0.01405607f, 0.03685018f, -0.03100866f, 0.04213104f, -0.03719705f, -0.03305877f, 0.01473152f, -0.00750067f, 
    0.05334560f, -0.03170696f, -0.03113608f, 0.02544959f, 0.00142443f, 0.02557876f, -0.03200979f, -0.03939634f, 
    -0.05158454f, 0.03156951f, -0.04755051f, -0.02263693f, -0.03913958f, -0.00670518f, 0.02828826f, -0.04117068f, 
    -0.04845174f, -0.03649974f, -0.01209005f, 0.02968912f, 0.03390823f, 0.01481225f, -0.01215105f, -0.01529328f, 
    -0.00006650f, -0.00046164f, -0.04050705f, 0.03440201f, -0.01064361f, -0.00144783f, 0.01987815f, -0.00496588f, 
    0.02423564f, 0.04614441f, 0.00025014f, 0.03596359f, 0.01309219f, -0.05814504f, -0.03457234f, 0.02795230f, 
    -0.05235943f, -0.03052648f, 0.03568147f, -0.04557081f, -0.04077810f, -0.00148636f, 0.00894918f, 0.02779546f, 
    -0.02483437f, -0.02502975f, -0.00762704f, -0.04801069f, -0.03352781f, -0.04905447f, 0.01167013f, 0.02877683f, 
    0.04186307f, 0.03351869f, 0.05012506f, 0.02918481f, 0.02167859f, -0.02848222f, 0.02041110f, 0.03605140f, 
    0.04465709f, -0.03404747f, 0.00200299f, 0.03601582f, 0.00340280f, -0.05413519f, -0.00538892f, -0.04064395f, 
    0.01417834f, -0.01068355f, 0.02923204f, -0.03693591f, -0.02916285f, -0.00837173f, -0.02482070f, 0.02536874f, 
    0.03797659f, -0.04606153f, -0.03476262f, 0.03986140f, -0.00484083f, 0.03346575f, -0.01654452f, -0.03881519f, 
    -0.04866416f, 0.01651231f, -0.02133051f, -0.00162288f, -0.03929390f, -0.00126200f, 0.00064991f, 0.04051722f, 
    -0.01178828f, -0.00166245f, -0.03141953f, -0.00619280f, -0.01156080f, -0.04030172f, -0.03968269f, 0.03080378f, 
    0.03448437f, -0.01914185f, 0.01974087f, 0.04885922f, -0.01891490f, 0.01211006f, -0.03930056f, 0.03351676f, 
    -0.03242681f, 0.00839884f, -0.03239461f, 0.00553111f, -0.01710016f, 0.02338436f, -0.05260776f, 0.03318287f, 
    -0.05816765f, 0.02615066f, -0.05214648f, -0.00489784f, -0.05553617f, -0.03519077f, 0.00789382f, 0.03441631f, 
    0.01415883f, 0.04891704f, -0.00168780f, -0.03296103f, -0.03471499f, -0.02534004f, -0.03595491f, -0.03413613f, 
    -0.03843267f, -0.03311444f, -0.01575645f, -0.00052286f, -0.00540147f, 0.02531373f, 0.03002116f, -0.01048827f, 
    0.03153627f, 0.04146779f, 0.02504659f, -0.05472589f, 0.01308207f, -0.03669621f, 0.02865954f, -0.05641436f, 
    -0.04078903f, 0.01471711f, -0.00667393f, -0.01407785f, 0.02161657f, -0.05180895f, 0.00359011f, -0.04673193f, 
    -0.04947511f, -0.04582796f, -0.01450816f, -0.02752652f, 0.00299278f, 0.01182494f, 0.03205429f, 0.00182778f, 
    0.04159194f, 0.00547073f, 0.02112976f, -0.03017090f, -0.04453203f, 0.00346781f, 0.02940100f, -0.04215148f, 
    -0.05338516f, -0.00761124f, 0.00471350f, 0.04010331f, 0.00937335f, -0.04128328f, -0.03424744f, 0.02938196f, 
    -0.00767880f, -0.01140060f, -0.04016381f, -0.04452787f, -0.05163901f, -0.02028458f, -0.00580540f, -0.03656231f, 
    0.00137329f, -0.05492017f, -0.01552767f, 0.01068373f, -0.00762314f, -0.04176486f, 0.00010638f, -0.01072832f, 
    -0.00840120f, -0.03860563f, -0.02456529f, -0.01583958f, -0.04874612f, 0.02932477f, -0.02992985f, 0.02290038f, 
    -0.00311808f, -0.00929606f, -0.03147651f, -0.04768132f, 0.03019416f, -0.02087396f, -0.04708764f, -0.02825117f, 
    -0.02118514f, 0.03286892f, -0.02279912f, 0.01767132f, -0.04891911f, -0.02557504f, 0.02512872f, -0.01770201f, 
    0.01508316f, -0.01209509f, 0.00101240f, 0.02926740f, -0.01652087f, 0.03543967f, -0.04214921f, -0.01162105f, 
    0.04335071f, -0.06109388f, 0.00423293f, -0.01750908f, 0.04530497f, -0.01768684f, 0.03113742f, -0.02520314f, 
    -0.00855723f, -0.00513598f, -0.01687715f, 0.03902741f, 0.02893999f, -0.01338207f, -0.04417168f, 0.00365830f, 
    -0.02500642f, -0.04661798f, 0.04590285f, 0.01704661f, -0.04456055f, -0.00116201f, -0.01690280f, -0.01491925f, 
    -0.03422627f, -0.03647492f, -0.03448044f, -0.04079201f, 0.01043553f, 0.04424000f, -0.03299404f, 0.02249560f, 
    0.25307629f, 0.36481187f, 0.16431232f, 0.03196041f, -0.03667612f, -0.08132838f, -0.00646250f, 0.06762868f, 
    0.26313871f, 0.14611100f, 0.00466527f, -0.13210250f, 0.02819170f, 0.08972222f, 0.02881499f, 0.02188585f, 
    -0.09875728f, -0.18533696f, 0.02653430f, -0.19054739f, -0.08146133f, -0.07519415f, -0.08234752f, 0.09171777f, 
    0.37039375f, 0.22869758f, 0.11339093f, 0.08241357f, -0.02689065f, -0.19624785f, -0.01924154f, -0.15301602f, 
    0.05125982f, 0.07339220f, 0.02339063f, 0.14256294f, 0.13190949f, 0.02504971f, 0.01226806f, 0.07239116f, 
    0.07599410f, 0.10876771f, 0.12229836f, 0.11576355f, 0.04026172f, 0.07033066f, 0.08247899f, -0.05144646f, 
    0.02147875f, 0.00480816f, -0.00678983f, 0.39310586f, -0.05520030f, 0.08135577f, 0.14343254f, 0.04645052f, 
    0.13177592f, 0.08889447f, 0.00023494f, 0.14492458f, -0.04008533f, -0.14630643f, 0.11312921f, 0.15509328f, 
    0.22320114f, 0.13179821f, 0.05465738f, -0.07153367f, -0.08605482f, -0.05860054f, -0.06089832f, -0.09376540f, 
    -0.00448475f, -0.11404227f, -0.15511017f, 0.16886248f, 0.04993925f, -0.00809022f, 0.09970498f, 0.04444734f, 
    0.17400938f, 0.24570514f, 0.30369309f, 0.43043378f, -0.24760869f, -0.00107290f, -0.04766394f, -0.30991426f, 
    -0.13571174f, 0.02108419f, 0.12095381f, 0.04319960f, -0.00690151f, 0.14020641f, -0.13859978f, -0.22234805f, 
    -0.04313630f, 0.05528865f, -0.03404947f, 0.08748520f, -0.04170183f, 0.05330601f, 0.18592183f, 0.06578358f, 
    0.06208626f, 0.27140597f, 0.05420976f, 0.39642355f, -0.00580455f, -0.07459372f, -0.02177843f, 0.05430838f, 
    0.08693727f, 0.09296850f, -0.15072379f, 0.08326954f, -0.16437337f, -0.16300781f, 0.01648857f, -0.05091549f, 
    0.02493002f, 0.13606003f, -0.16272536f, -0.02512046f, -0.15884247f, -0.00475410f, -0.12027086f, -0.00606185f, 
    -0.04877001f, 0.25411108f, 0.28026721f, 0.28479058f, 0.01202756f, -0.09637915f, 0.06728262f, -0.03504353f, 
    0.19854613f, 0.20427369f, -0.03706774f, -0.12667963f, 0.07228856f, -0.00982858f, -0.08574195f, 0.15351492f, 
    0.01063476f, -0.16223575f, -0.06211492f, -0.21508385f, 0.03721656f, -0.14343916f, -0.00369606f, 0.12546059f, 
    -0.02086963f, 0.04683705f, 0.11517260f, -0.22641563f, -0.00210882f, -0.19913389f, -0.00647425f, -0.01531548f, 
    -0.03490895f, -0.02386293f, -0.05417954f, -0.17748998f, -0.25915337f, -0.23212765f, -0.06320819f, -0.30914134f, 
    -0.13668758f, 0.21869944f, 0.27788010f, -0.25784418f, -0.06256812f, -0.08369545f, -0.00362958f, -0.03285838f, 
    -0.02360275f, -0.01079722f, 0.15683061f, -0.15679403f, 0.02064147f, -0.11222312f, -0.22260849f, -0.00502855f, 
    0.04649557f, -0.08386994f, -0.04518294f, 0.05312393f, -0.02426723f, -0.04872102f, 0.00291408f, 0.01088781f, 
    -0.30727723f, 0.01069964f, -0.26202255f, -0.01023195f, -0.02989148f, -0.11119588f, 0.07129455f, -0.19867943f, 
    0.11101919f, 0.07132436f, 0.18169460f, 0.08686302f, 0.00745656f, 0.09514058f, -0.09456087f, -0.07840054f, 
    -0.08361838f, 0.14158577f, 0.00045467f, -0.02542188f, 0.09440380f, 0.17694141f, 0.19165063f, 0.34645396f, 
    0.16240498f, 0.26931149f, -0.12952408f, 0.21476968f, -0.04949711f, -0.12611638f, -0.07232273f, -0.18788193f, 
    -0.07604410f, -0.11205369f, -0.08303595f, -0.09690196f, -0.12874348f, -0.12983310f, 0.07856062f, -0.18968743f, 
    0.02615031f, -0.04191356f, 0.00313097f, -0.07630337f, 0.11889400f, 0.11807225f, 0.15479001f, 0.02395482f, 
    0.25479949f, 0.28769940f, -0.03409282f, -0.27422917f, 0.01922784f, 0.22995973f, -0.01011496f, -0.15266006f, 
    0.12103814f, -0.01940409f, -0.05836622f, 0.27466226f, 0.08350808f, 0.08166196f, -0.04338259f, -0.08065426f, 
    0.00552325f, -0.08465742f, -0.19572189f, -0.05510127f, -0.18511957f, -0.19127457f, -0.05410598f, -0.17556095f, 
    0.57615495f, -0.19601811f, 0.29961401f, 0.03818860f, -0.07100966f, 0.09964120f, -0.13995349f, 0.04969769f, 
    0.17229438f, 0.02874354f, -0.14402619f, 0.06300294f, 0.28800207f, -0.34979627f, -0.07477698f, -0.02102691f, 
    0.02429384f, 0.14944503f, 0.09432175f, -0.15326825f, -0.17872421f, -0.37489861f, -0.15586941f, -0.11468399f, 
    -0.22701742f, -0.26835993f, 0.14142263f, 0.19278957f, 0.09265151f, -0.11766922f, 0.04267283f, -0.23796867f, 
    0.03865208f, -0.06655520f, 0.05681546f, -0.05421800f, 0.02215207f, -0.04816598f, 0.10988333f, -0.05314846f, 
    0.07649635f, -0.02404581f, -0.08759104f, -0.21747996f, -0.10923635f, 0.00390798f, 0.00797655f, -0.22716825f, 
    0.12520193f, 0.19533081f, 0.31443352f, 0.19902614f, -0.01916727f, -0.11511644f, -0.04524455f, 0.05354750f, 
    0.03932023f, 0.14687176f, -0.05397168f, 0.18234281f, 0.03029654f, -0.01584678f, -0.01625624f, 0.16110618f, 
    0.01248530f, 0.00388050f, -0.00480905f, -0.01687775f, -0.09119145f, -0.17958522f, -0.18282166f, -0.14078233f, 
    0.20296758f, 0.24214113f, 0.34443706f, -0.15201449f, 0.00759550f, 0.03911625f, -0.23790899f, -0.09374457f, 
    0.01318403f, 0.12063029f, 0.03258335f, -0.11108305f, 0.12188119f, 0.23529933f, 0.11051280f, 0.19220729f, 
    0.03578873f, 0.07746015f, 0.07841894f, 0.14601918f, -0.00324082f, -0.18141179f, -0.07845155f, -0.14122649f, 
    -0.16272852f, 0.35809466f, 0.25875047f, 0.01955442f, -0.10237566f, -0.33276403f, 0.10514931f, -0.00322546f, 
    -0.07008835f, 0.06109679f, -0.02128552f, -0.18728365f, -0.02963034f, -0.15317117f, -0.28331757f, -0.16209333f, 
    0.05986066f, 0.11519581f, -0.03320704f, -0.02050812f, -0.07375824f, 0.06904522f, 0.14701204f, 0.12648802f, 
    -0.06725107f, -0.08263765f, -0.05003601f, -0.27984291f, -0.01125590f, -0.09503704f, -0.01426108f, 0.01565474f, 
    -0.14208707f, -0.26758260f, -0.07430377f, -0.10686890f, 0.03105733f, 0.03406368f, -0.01539442f, -0.07738061f, 
    0.01820508f, 0.01682324f, 0.05999788f, 0.20825136f, 0.01497517f, -0.07259413f, 0.06996775f, -0.05730818f, 
    -0.07416024f, -0.06975330f, -0.20445660f, 0.07712486f, -0.05226447f, -0.06711905f, -0.11424839f, 0.00464234f, 
    0.19961371f, 0.10228547f, 0.08753327f, -0.14177550f, -0.01135565f, 0.06237952f, 0.05066009f, -0.13974829f, 
    0.00510376f, 0.03344061f, 0.25589970f, -0.04486166f, 0.00242329f, 0.01261534f, 0.04228775f, 0.01920575f, 
    0.16418581f, 0.01772216f, 0.01122414f, 0.21458609f, 0.11647306f, 0.13347764f, 0.15344858f, 0.12461749f, 
    0.02689671f, 0.02673978f, -0.09327342f, -0.11708121f, -0.20043786f, -0.24241178f, -0.16627239f, -0.04970264f, 
    0.12752354f, 0.01432888f, 0.09023950f, 0.01405945f, 0.03355870f, -0.01574135f, -0.14490351f, 0.01092734f, 
    -0.06957182f, 0.11059959f, -0.18212874f, 0.01354491f, -0.04439154f, -0.02254638f, 0.08484178f, 0.24109894f, 
    0.06132773f, -0.17585905f, -0.13572860f, -0.40871873f, 0.10423484f, -0.24926400f, -0.02689282f, -0.05190329f, 
    0.24553294f, 0.06652417f, -0.08150303f, 0.18007866f, -0.06157640f, -0.05708378f, 0.09180063f, -0.12888552f, 
    0.05570236f, -0.06134274f, 0.08063192f, 0.02581625f, 0.00154068f, -0.00982251f, 0.12081189f, 0.09445673f, 
    -0.01103699f, -0.31233910f, -0.15792066f, -0.26578641f, -0.07685506f, -0.03581032f, -0.02637903f, -0.23459348f, 
    -0.02177122f, 0.00504710f, 0.08149924f, 0.20016274f, -0.06257778f, 0.00238572f, -0.00596102f, 0.00717238f, 
    -0.08660209f, 0.00458855f, -0.16614406f, 0.03920396f, -0.04302681f, -0.00474436f, 0.00359400f, 0.08065594f, 
    0.15391304f, -0.12901878f, -0.00501778f, -0.08878987f, -0.24739024f, -0.05912399f, -0.11416388f, -0.02347690f, 
    0.00896441f, -0.02120808f, -0.04208039f, -0.09690584f, 0.01022052f, 0.02187053f, -0.00933932f, -0.04561205f, 
    0.02860432f, -0.00335456f, 0.02751974f, 0.05576990f, 0.27399519f, 0.16084452f, 0.12380297f, 0.25483245f, 
    -0.04249142f, 0.06231219f, 0.06063482f, 0.11304363f, -0.03796983f, 0.01150162f, 0.03976497f, -0.02745039f, 
    0.06519187f, 0.01019434f, -0.01052531f, -0.06092390f, 0.07811220f, 0.13286065f, 0.11376906f, 0.02309211f, 
    0.20464514f, -0.24600074f, 0.10974207f, 0.13423654f, -0.06461051f, -0.00534059f, 0.02707230f, -0.07279433f, 
    -0.10429243f, 0.01798945f, 0.16441751f, 0.19177262f, -0.17694680f, -0.03264192f, -0.13461952f, -0.21868907f, 
    0.01906852f, 0.05020004f, -0.01790555f, 0.06909069f, 0.06885051f, -0.00452384f, 0.11106386f, -0.04121599f, 
    -0.21555658f, -0.17432657f, 0.20716375f, -0.18223962f, -0.03367811f, -0.04491034f, 0.00257482f, -0.01640390f, 
    -0.04026184f, -0.04211380f, 0.05196909f, -0.09539930f, 0.08996456f, 0.04062978f, 0.07721494f, 0.02136345f, 
    0.02636489f, -0.00832824f, -0.10439301f, 0.05881403f, 0.10080729f, -0.00262784f, -0.10236482f, -0.14235023f, 
    -0.05858358f, 0.00015234f, -0.00640950f, -0.17056713f, -0.06865980f, -0.02862591f, 0.04415104f, -0.01677160f, 
    0.07070342f, 0.17237693f, 0.03534840f, -0.02420632f, 0.03301500f, 0.02663500f, 0.12898552f, -0.04492351f, 
    -0.01763806f, -0.10082096f, -0.05022658f, -0.11228246f, 0.11228989f, -0.20896892f, 0.25232065f, 0.11169709f, 
    0.16089593f, -0.16857733f, 0.00333376f, 0.05339582f, 0.15720204f, 0.19514599f, 0.12637271f, 0.02710339f, 
    0.02216751f, 0.02147616f, -0.02832611f, -0.12761807f, -0.01662787f, 0.28712150f, -0.06521232f, -0.03450084f, 
    0.00320278f, 0.13623233f, 0.06204989f, 0.05667822f, 0.08815373f, 0.17160395f, -0.09475458f, 0.17054540f, 
    0.00097929f, -0.16400209f, -0.13123409f, -0.19063538f, -0.10456014f, -0.07095986f, 0.09642331f, 0.17131618f, 
    0.12677218f, -0.02319552f, 0.00703572f, -0.08341366f, -0.09849904f, -0.11860214f, -0.00060738f, -0.12602741f, 
    -0.00413369f, -0.01649293f, -0.04740239f, -0.05181618f, 0.03745722f, -0.03438826f, 0.09269205f, 0.02634322f, 
    -0.02377568f, -0.12131517f, 0.04723707f, -0.20067294f, -0.03810757f, 0.11366036f, 0.22808585f, 0.06136407f, 
    0.09272604f, -0.04688797f, 0.12098327f, 0.10354272f, 0.06644758f, -0.05975548f, 0.27654719f, 0.05474022f, 
    0.03557428f, -0.01963566f, -0.03273088f, -0.06907299f, 0.00125552f, -0.04006653f, 0.32661578f, -0.04863100f, 
    -0.17028940f, -0.04624677f, -0.18780088f, -0.17218761f, -0.11857571f, -0.05515907f, -0.12998646f, 0.03175761f, 
    0.03901163f, -0.02598579f, 0.13095148f, -0.01963816f, -0.10984728f, 0.14176163f, -0.05533946f, -0.23109475f, 
    -0.08184502f, 0.12379228f, 0.28518429f, 0.14084272f, 0.06761383f, -0.06207682f, -0.00194567f, 0.10139095f, 
    -0.05811115f, -0.08629489f, 0.33047718f, 0.20103981f, 0.09280463f, -0.16404876f, -0.05732230f, 0.09929203f, 
    0.08049224f, -0.00863960f, 0.07680143f, -0.01054402f, -0.19233279f, 0.16319869f, 0.14114991f, -0.15731828f, 
    0.11974818f, 0.06357426f, 0.01334952f, 0.15686852f, 0.08806513f, -0.05807461f, 0.13350873f, -0.09590353f, 
    0.16504376f, -0.18286873f, 0.09174849f, 0.40484414f, -0.00336039f, -0.11454896f, 0.03474634f, 0.01698647f, 
    0.08632021f, -0.03090334f, 0.05838526f, 0.19154266f, -0.06810037f, -0.07097144f, -0.09456527f, -0.11500416f, 
    -0.05018860f, -0.07730237f, -0.05326033f, -0.06764973f, -0.10113192f, -0.11097527f, 0.07534399f, -0.11057440f, 
    -0.00456257f, 0.22383808f, 0.21026519f, -0.02674931f, -0.01141011f, -0.06663242f, -0.00891562f, 0.09077390f, 
    0.14989653f, -0.04800962f, 0.05447682f, 0.02887442f, 0.36088106f, -0.05914396f, -0.12676817f, -0.12852733f, 
    0.04670817f, 0.00755995f, -0.03181623f, 0.10496262f, 0.02374408f, -0.03266163f, 0.10537339f, 0.07337335f, 
    -0.10933436f, 0.00551709f, 0.00238042f, 0.11618154f, -0.03760146f, -0.15243419f, -0.04845970f, 0.05534349f, 
    0.21678446f, 0.03481729f, 0.25848839f, 0.01498315f, -0.06373103f, 0.24852590f, 0.15814167f, 0.07042384f, 
    0.05806046f, 0.00175309f, -0.01482368f, -0.04736368f, 0.10600296f, -0.07074293f, 0.13223608f, 0.14736892f, 
    0.07799308f, 0.04317480f, -0.03148314f, 0.04204470f, 0.10233315f, 0.00334114f, -0.01668850f, -0.00468036f, 
    0.03921847f, 0.04015728f, 0.07383632f, -0.03853777f, 0.14259543f, -0.34956327f, -0.25750658f, 0.17739423f, 
    0.14742111f, 0.00447659f, 0.13501492f, 0.02151060f, 0.05037608f, 0.02747624f, -0.09202431f, 0.11080462f, 
    -0.16772930f, 0.19817370f, -0.14482738f, -0.02127769f, -0.01217405f, 0.01515306f, -0.03724238f, -0.08343272f, 
    0.03115930f, -0.01629601f, 0.01511534f, 0.00543766f, 0.19258390f, -0.26688784f, -0.01333559f, -0.05663433f, 
    0.04077315f, -0.08943352f, 0.16580863f, -0.01918206f, 0.01909417f, -0.10178460f, 0.10834467f, 0.02031603f, 
    0.12494199f, 0.06216639f, 0.00155066f, -0.08130842f, 0.07878084f, 0.05807460f, 0.02091559f, -0.00565501f, 
    0.01040835f, -0.14721759f, 0.08450942f, 0.00335025f, -0.24837165f, -0.17046274f, 0.34398752f, -0.04136045f, 
    0.00931369f, 0.08616605f, -0.07334495f, 0.00532367f, 0.04521362f, 0.06278824f, 0.02430788f, -0.01553283f, 
    0.37770972f, 0.24263281f, -0.18904085f, -0.01733870f, 0.09492650f, 0.03296980f, 0.05661931f, 0.00178008f, 
    -0.02617331f, 0.09040690f, 0.04222308f, 0.05855827f, 0.34573722f, 0.14938070f, 0.13172844f, 0.20878460f, 
    0.03401289f, -0.01463594f, 0.03067990f, -0.08419553f, 0.05987163f, 0.02117576f, -0.09952673f, -0.06085868f, 
    -0.23375636f, -0.01391305f, 0.22571675f, 0.03523179f, 0.06777995f, -0.00395350f, -0.05464613f, -0.04704798f, 
    0.00549076f, 0.03585903f, 0.06056813f, 0.00101512f, 0.09291994f, -0.09136505f, -0.01800038f, 0.02797500f, 
    0.13467392f, -0.00862341f, -0.04429447f, 0.01678490f, -0.05568671f, -0.04345436f, -0.03227875f, 0.00409086f, 
    -0.28352234f, 0.07311291f, -0.29118207f, 0.49458537f, -0.07047926f, -0.07787862f, -0.03574558f, 0.08692551f, 
    0.02209263f, 0.02126125f, -0.06744145f, 0.06675938f, -0.09846267f, 0.15368754f, 0.16421477f, 0.12809508f, 
    0.04899343f, -0.04867656f, -0.04214692f, -0.03404247f, 0.07660904f, -0.01314422f, 0.12779760f, 0.11140077f, 
    0.53306419f, -0.43785381f, 0.12602317f, -0.02033724f, -0.09877623f, -0.03000281f, -0.05170363f, 0.06266913f, 
    0.06788734f, 0.00877717f, 0.17351282f, 0.01267190f, -0.22042921f, -0.14382137f, 0.19132590f, 0.15604612f, 
    -0.07994519f, -0.06934648f, -0.06602858f, 0.13612626f, 0.05328639f, 0.02622310f, -0.03757214f, -0.00724965f, 
    0.22806817f, -0.13070354f, 0.00346604f, -0.22925128f, -0.07007760f, -0.06363547f, -0.03701758f, 0.08860543f, 
    0.13764437f, 0.03541652f, 0.13506779f, -0.07594872f, 0.42147899f, -0.15249604f, 0.10924584f, -0.12816808f, 
    0.08024901f, 0.01406228f, -0.04968270f, -0.04628965f, 0.16924268f, -0.08007101f, -0.01774791f, -0.00074054f, 
    -0.11563724f, -0.31858617f, 0.02421228f, 0.16294768f, -0.08486508f, 0.01998432f, 0.06301757f, -0.18260625f, 
    0.03899452f, -0.13812850f, -0.01057376f, 0.13227256f, 0.12641726f, -0.13505198f, 0.27183548f, -0.11735597f, 
    -0.00735621f, -0.10736760f, -0.03026014f, 0.12627201f, 0.11790188f, -0.08788140f, 0.03275369f, -0.09194048f, 
    -0.38503182f, -0.08323124f, 0.08363573f, -0.01411582f, -0.18199730f, -0.05571881f, -0.14519894f, 0.02281590f, 
    0.07990986f, -0.00870770f, -0.04438328f, -0.07916233f, 0.15678118f, -0.11758979f, 0.00080692f, 0.08327848f, 
    0.04108320f, 0.07088152f, -0.06115814f, -0.00883071f, -0.00716021f, -0.03520110f, -0.03423279f, -0.03911057f, 
    0.47689813f, 0.07246665f, -0.13870871f, -0.30407581f, 0.04734159f, -0.00722570f, 0.05530100f, -0.08047818f, 
    0.09393324f, 0.08618451f, 0.07215389f, 0.13482586f, 0.41014382f, -0.25595862f, 0.19829345f, 0.11853022f, 
    0.08945123f, 0.03689184f, 0.01408489f, 0.02288835f, 0.04024446f, 0.04011985f, 0.01605426f, 0.04326930f, 
    0.09312040f, -0.02485993f, 0.16817701f, -0.00887565f, -0.11171228f, -0.12074433f, -0.04402897f, 0.02237119f, 
    -0.03455433f, -0.01524828f, 0.01082893f, 0.16586930f, -0.07111927f, 0.19959289f, 0.06429669f, 0.00066993f, 
    0.01756575f, -0.03866101f, 0.09419548f, 0.04458804f, 0.09188914f, 0.05636965f, 0.01880631f, 0.00896775f, 
    0.29010582f, -0.58914179f, 0.49951416f, 0.14239049f, -0.00641831f, 0.03242194f, -0.11940907f, 0.05021547f, 
    0.01203024f, 0.13056019f, -0.11259540f, 0.11677823f, 0.14571451f, 0.13974258f, -0.02617692f, -0.07580499f, 
    0.01259750f, -0.01863670f, 0.09750502f, -0.06829390f, -0.03844219f, -0.02611647f, 0.07044105f, -0.05047796f, 
    -0.13006806f, 0.15844350f, -0.00491249f, 0.16255397f, -0.09149165f, -0.00344321f, -0.00460159f, 0.05154283f, 
    0.03493715f, 0.07685681f, -0.16374223f, 0.13688277f, 0.10622019f, 0.00525577f, -0.01882777f, 0.11304936f, 
    0.04699703f, -0.02941387f, 0.03884849f, 0.04372884f, 0.05486957f, -0.05656584f, 0.04935744f, 0.05553408f, 
    0.15098509f, -0.15175508f, -0.26127318f, 0.12793405f, 0.18860473f, 0.11288537f, 0.14267880f, 0.09932607f, 
    0.08829716f, -0.01196211f, 0.03834166f, 0.08065592f, -0.11036042f, -0.32605374f, -0.00994052f, -0.20047520f, 
    -0.01095995f, 0.06271122f, -0.02553489f, 0.09070572f, 0.20706238f, 0.02598206f, 0.08259904f, 0.03782548f, 
    0.01448724f, -0.30767617f, -0.24622986f, -0.11848056f, 0.00237257f, 0.09845706f, 0.04310004f, 0.01009242f, 
    0.06214886f, -0.02116118f, -0.09438346f, 0.01118141f, 0.25844568f, 0.20746522f, 0.06428516f, 0.20977794f, 
    0.17962171f, 0.07916391f, 0.01214627f, 0.02942711f, 0.06981945f, 0.04758469f, -0.05700024f, 0.12080413f, 
    0.09233533f, 0.17165203f, 0.05930904f, 0.02590203f, 0.06551783f, 0.03383465f, -0.02556529f, 0.25154117f, 
    -0.07729027f, -0.05128464f, -0.03907905f, -0.01352225f, 0.25780517f, 0.41519594f, 0.33231640f, 0.05279119f, 
    0.06222399f, -0.08066067f, -0.01695887f, -0.09230094f, -0.09435041f, -0.06337007f, 0.01409341f, -0.01255094f, 
    0.08350611f, 0.02061258f, 0.12168262f, 0.06179162f, 0.08793515f, 0.09091077f, -0.07771547f, 0.03844000f, 
    -0.06662579f, -0.00897640f, -0.10739011f, -0.16899481f, 0.07076086f, 0.04479551f, -0.03167622f, -0.00370348f, 
    0.18070702f, -0.06573463f, 0.08362280f, -0.13767833f, 0.01749514f, 0.00338536f, -0.05484829f, 0.02377994f, 
    0.15285422f, 0.15630341f, 0.06082543f, 0.05593189f, 0.21852279f, 0.08706578f, -0.04363380f, 0.04059761f, 
    0.06121650f, -0.00751329f, -0.04446518f, -0.10279472f, 0.42426091f, 0.36209938f, -0.17723353f, -0.17082357f, 
    0.00937337f, 0.08366645f, 0.14232239f, 0.10798994f, 0.04573423f, -0.03451506f, 0.01934681f, 0.09813670f, 
    -0.01051039f, -0.24510735f, 0.14041696f, 0.06234029f, -0.01071319f, -0.00241010f, -0.01826571f, 0.01165931f, 
    0.10018378f, -0.19778462f, -0.21916264f, -0.32482406f, 0.18120164f, 0.10518567f, 0.14162235f, 0.38356271f, 
    -0.09665540f, -0.07907658f, -0.09479044f, -0.00175727f, -0.15709019f, -0.08437768f, 0.04419084f, 0.00093479f, 
    0.25093594f, 0.18629447f, -0.09551653f, 0.03072372f, 0.16742106f, 0.12261690f, 0.14576353f, 0.01196226f, 
    -0.04487265f, -0.11771218f, -0.03547267f, -0.02514338f, -0.04782101f, 0.09159778f, 0.03488370f, -0.22037132f, 
    0.08103467f, 0.00153950f, -0.05254324f, -0.04146650f, 0.05555671f, 0.05024453f, -0.01109492f, 0.11155903f, 
    0.12997183f, -0.00720640f, -0.22545843f, -0.19636856f, 0.12241740f, -0.02126684f, 0.03108720f, -0.06502392f, 
    0.22525385f, 0.05080110f, -0.11381096f, 0.10832258f, 0.26488489f, 0.21125153f, 0.14389272f, 0.08252318f, 
    0.14125767f, 0.28544536f, 0.10347584f, 0.11477547f, -0.00800520f, 0.00493938f, 0.03803605f, 0.08534779f, 
    0.53747559f, -0.28222227f, -0.13391367f, -0.08484562f, -0.08194379f, -0.08344857f, -0.02524200f, -0.05339332f, 
    0.20262130f, -0.00269768f, -0.15670317f, 0.00729145f, 0.31630871f, 0.00078266f, -0.06838486f, 0.07246741f, 
    0.08306950f, -0.03814983f, 0.02387629f, -0.06431258f, -0.08858322f, 0.00043121f, -0.10438126f, -0.18644720f, 
    -0.01782170f, -0.39585912f, -0.22274141f, -0.15870713f, 0.10392319f, 0.12310056f, 0.17237774f, -0.04917634f, 
    0.15781477f, -0.01848007f, 0.02753975f, 0.01090082f, 0.18484265f, 0.00888303f, 0.06591880f, 0.07742054f, 
    -0.04388436f, -0.12255269f, -0.00969672f, -0.10331777f, 0.13187045f, -0.02280783f, -0.12373006f, 0.10016239f, 
    0.10658494f, -0.16191322f, 0.25458118f, -0.18217671f, 0.09901217f, -0.22540298f, 0.12626752f, 0.15338762f, 
    -0.02955537f, 0.02741683f, 0.06520755f, -0.14517947f, 0.00233612f, -0.18831234f, -0.06357338f, 0.09772351f, 
    -0.05000447f, 0.07813682f, -0.05031128f, -0.03546632f, 0.08649512f, 0.14177428f, 0.05221490f, 0.22228350f, 
    -0.03694857f, -0.01214027f, -0.50813055f, -0.41534412f, 0.08872500f, 0.06837077f, 0.03613085f, 0.06416885f, 
    0.06000304f, 0.00011212f, 0.02477889f, 0.04573981f, -0.12495109f, 0.14320441f, 0.09339782f, -0.04149148f, 
    0.02494109f, 0.01926555f, -0.06138100f, 0.08842022f, 0.02016313f, 0.01001729f, 0.03838947f, 0.00163655f, 
    0.12537652f, -0.21741191f, -0.18488179f, -0.13909820f, -0.13172151f, 0.13094018f, -0.14497678f, 0.11132355f, 
    0.05237680f, 0.21955948f, 0.04181781f, 0.08784731f, 0.12740882f, 0.10909182f, -0.07795309f, 0.05773814f, 
    -0.06831206f, -0.05552138f, 0.03425275f, -0.01327606f, -0.05663666f, 0.09499804f, -0.08019758f, 0.17096551f, 
    -0.00549698f, -0.48828465f, -0.39539373f, -0.09448574f, -0.03626634f, 0.11260128f, 0.04809554f, -0.03980787f, 
    0.12063330f, -0.04211927f, 0.10059361f, -0.02288088f, -0.06016157f, 0.04116679f, -0.08851436f, 0.10635959f, 
    0.06528942f, 0.21346866f, -0.03679299f, 0.26211524f, 0.01118984f, 0.03275885f, 0.06831838f, 0.01628347f, 
    0.30704647f, 0.08065348f, -0.33699062f, -0.20908326f, -0.23505305f, 0.11856954f, 0.06654949f, 0.09959866f, 
    0.26090202f, 0.03103855f, 0.00287382f, 0.20963992f, 0.20180900f, 0.06769417f, -0.12082904f, -0.08244054f, 
    -0.02743376f, 0.04395938f, -0.03746772f, 0.19352958f, -0.06852639f, -0.00663181f, -0.07588180f, -0.01418206f, 
    0.04908443f, -0.05490477f, -0.34094471f, 0.08018215f, -0.07667018f, 0.06869413f, -0.05898317f, -0.02075994f, 
    0.20145091f, 0.09448005f, 0.11652786f, 0.18078080f, -0.03090372f, 0.20654012f, 0.13784762f, 0.11156359f, 
    -0.06710777f, -0.07106341f, -0.03943541f, -0.08198205f, 0.01423900f, 0.00089257f, -0.00075329f, 0.10344306f, 
    0.20859140f, -0.03776374f, -0.16561815f, 0.00609271f, 0.08894454f, 0.21785836f, 0.11561459f, 0.03465802f, 
    0.01700747f, -0.02324767f, -0.06098057f, 0.04612578f, 0.03578381f, 0.05690785f, 0.15085550f, 0.07543048f, 
    0.00685661f, 0.17672467f, -0.06329627f, 0.00300349f, 0.20076646f, -0.02053794f, 0.03553343f, -0.16766214f, 
    0.05869855f, 0.06714929f, 0.10163526f, -0.12601115f, 0.06067388f, 0.13734186f, 0.09389590f, 0.04681935f, 
    -0.02629993f, 0.05145666f, -0.16408595f, -0.06007567f, 0.20797610f, 0.09559903f, -0.07764525f, 0.03732109f, 
    0.05925526f, 0.17506874f, 0.05676598f, 0.00396580f, -0.05681485f, 0.05921084f, -0.07406142f, 0.00330688f, 
    0.12474676f, 0.07055433f, -0.00828236f, -0.20868202f, -0.01789275f, 0.02573659f, -0.07423300f, 0.30523416f, 
    -0.08301513f, -0.04097406f, 0.02206522f, 0.01151634f, -0.39392352f, 0.09992898f, -0.18245505f, -0.07389138f, 
    -0.04902989f, -0.05845500f, -0.15887851f, -0.00586377f, -0.01644549f, 0.04024553f, 0.07316864f, -0.00520775f, 
    0.00473919f, -0.05197895f, 0.08919852f, -0.00932120f, 0.10723640f, 0.19585317f, -0.12472971f, 0.02937048f, 
    -0.03467174f, 0.00756097f, -0.14942206f, -0.05972161f, -0.13549373f, 0.12031170f, -0.03059435f, 0.02058156f, 
    0.08942366f, 0.16590200f, -0.10882665f, -0.09413651f, -0.12427488f, -0.07400147f, 0.03993974f, 0.02991458f, 
    0.05470318f, 0.06704690f, 0.09320416f, 0.14717267f, 0.04260099f, 0.12625602f, -0.06556669f, 0.03041787f, 
    -0.01214960f, -0.06825580f, -0.23786658f, 0.07874791f, 0.38297540f, 0.05500496f, -0.15971546f, -0.11714417f, 
    0.13919534f, 0.03808694f, 0.08462816f, 0.14458092f, -0.01721841f, -0.00516094f, 0.10296188f, 0.01497559f, 
    -0.22872795f, -0.29246831f, 0.11455320f, 0.00377133f, 0.03167125f, -0.04740523f, -0.09293254f, 0.04143666f, 
    -0.04938342f, -0.19518840f, -0.06540634f, -0.16962364f, -0.19543567f, 0.00486858f, -0.07415609f, -0.04233116f, 
    -0.05357084f, -0.01261982f, -0.01302779f, 0.00809040f, -0.05167547f, 0.03029396f, 0.10421309f, 0.12646089f, 
    0.27931470f, 0.24853164f, -0.22639357f, -0.04545594f, 0.11633868f, 0.15796106f, 0.18260270f, 0.08594447f, 
    -0.03854530f, 0.05231435f, 0.07702956f, 0.05484167f, -0.10952400f, 0.06719106f, -0.10225317f, 0.01425810f, 
    -0.11724206f, -0.09645957f, 0.03714038f, -0.07727300f, -0.03136948f, 0.02372728f, 0.02688700f, 0.14832409f, 
    -0.12869385f, 0.00168909f, 0.22346009f, -0.10269757f, 0.02920795f, -0.06332035f, -0.01647092f, -0.03826142f, 
    0.09795895f, -0.04900939f, 0.09522156f, 0.15220769f, 0.26386932f, 0.13011245f, 0.05700365f, 0.01858369f, 
    0.17057325f, 0.22027421f, 0.08939081f, 0.15137349f, -0.00093235f, 0.01184161f, 0.03356589f, -0.03442198f, 
    0.30490559f, 0.03928486f, -0.06368381f, -0.02919876f, -0.10523704f, -0.01166276f, -0.03891182f, -0.02060491f, 
    0.11191129f, 0.08516719f, -0.11348868f, -0.06179536f, 0.39793518f, 0.10178657f, -0.07197453f, -0.16346443f, 
    0.05930509f, 0.06546871f, 0.06919653f, 0.02786280f, -0.08308908f, -0.04008610f, -0.11204915f, -0.06300183f, 
    0.02552683f, 0.03063286f, -0.09772955f, 0.12464266f, -0.02651420f, 0.09036630f, 0.01850514f, -0.07712577f, 
    0.05070723f, 0.12969391f, -0.01092916f, 0.03481057f, -0.30523324f, 0.24084508f, 0.00851693f, -0.10458192f, 
    -0.05935289f, 0.02891402f, 0.01714413f, -0.02533960f, 0.00821421f, -0.02566282f, -0.16200227f, 0.04172760f, 
    -0.11044486f, 0.21010548f, 0.05745072f, -0.19420047f, 0.08579142f, 0.05909802f, 0.16007678f, 0.27715275f, 
    0.00295257f, 0.02303687f, -0.01470622f, -0.14783536f, -0.06724776f, 0.02471253f, -0.05174787f, 0.11743069f, 
    -0.01808291f, 0.12219582f, 0.12387827f, 0.02998735f, 0.03123382f, 0.35851538f, 0.01728179f, 0.27488646f, 
    0.08827642f, 0.17343944f, -0.12047227f, -0.07729548f, 0.14821692f, 0.10929695f, 0.10364054f, 0.07376777f, 
    -0.02273108f, 0.08052734f, -0.03598358f, 0.05778585f, -0.15385592f, -0.08278872f, -0.01814824f, -0.04595087f, 
    -0.02820941f, -0.17042528f, -0.11625291f, -0.01477636f, -0.08251145f, 0.03541531f, 0.06120000f, 0.08140528f, 
    -0.06732011f, -0.09365758f, -0.17171052f, 0.20223352f, -0.03580710f, -0.10395665f, -0.17062216f, 0.05866349f, 
    0.02001543f, 0.03387807f, -0.05810590f, -0.13445820f, -0.18203561f, 0.03798275f, 0.03939131f, 0.01249928f, 
    -0.04926272f, -0.07264404f, 0.01240077f, -0.00625932f, 0.03727416f, 0.03177101f, 0.02469388f, 0.02919761f, 
    -0.01302421f, -0.11259840f, -0.05108839f, 0.03251350f, 0.08132817f, 0.06175799f, -0.00531778f, 0.01054910f, 
    0.10648710f, 0.08213636f, 0.06994989f, -0.05783367f, 0.27269390f, 0.02621186f, -0.05861308f, 0.01050487f, 
    0.05897113f, 0.19277740f, 0.06123961f, 0.22165139f, -0.07186043f, 0.04831635f, 0.16967134f, 0.09038477f, 
    0.24567468f, 0.22589135f, -0.02878538f, -0.11194376f, -0.11498865f, -0.15410307f, 0.04247900f, 0.11839055f, 
    0.18795933f, -0.07910151f, 0.03087745f, 0.09800038f, 0.01015822f, -0.01573298f, 0.05253221f, -0.09485610f, 
    0.13399240f, 0.06887543f, -0.02787723f, 0.06660964f, -0.04067670f, 0.04456719f, 0.07394703f, 0.03739067f, 
    0.00978272f, -0.10318770f, 0.24081817f, -0.31403166f, -0.02394852f, 0.03873541f, -0.02069755f, -0.02658254f, 
    0.08887500f, -0.10262753f, 0.21764898f, 0.05843106f, -0.20432675f, -0.07495215f, 0.07001408f, 0.03695008f, 
    -0.08297574f, -0.07695349f, -0.08302073f, -0.05534330f, -0.11080556f, -0.05891091f, -0.06940360f, -0.04018519f, 
    0.15879153f, 0.40883216f, 0.19524397f, -0.18111178f, 0.00359437f, -0.08308060f, -0.06452803f, 0.06693331f, 
    -0.01690823f, -0.02529000f, -0.03944692f, 0.01780877f, 0.25648034f, -0.02817169f, -0.07553420f, -0.16550769f, 
    0.05560729f, -0.10579737f, -0.01021159f, 0.11758208f, 0.07465173f, 0.00531679f, 0.11829392f, 0.00001779f, 
    -0.04375976f, 0.14459486f, 0.02980181f, 0.20398802f, -0.08081144f, -0.22289994f, -0.05785810f, 0.01564838f, 
    0.16053391f, -0.00612464f, 0.19927731f, 0.02561578f, -0.01513095f, 0.20785755f, 0.13745777f, -0.19653778f, 
    0.08013511f, 0.08207764f, -0.04915551f, -0.04459552f, -0.00021012f, -0.02879288f, 0.06547108f, 0.05091182f, 
    0.19090292f, 0.07589731f, -0.03404269f, 0.09411210f, 0.14824215f, 0.06599820f, 0.07102315f, 0.03281075f, 
    0.08356499f, -0.04112901f, 0.01646008f, -0.00349691f, 0.09605028f, -0.40514553f, -0.25256085f, 0.26804236f, 
    0.16134755f, 0.19420117f, 0.24114439f, 0.20573683f, -0.06771815f, -0.03872839f, -0.12420043f, -0.02382574f, 
    -0.04558890f, 0.07922340f, -0.16191430f, -0.13555081f, -0.02451150f, -0.01114640f, 0.10844504f, 0.06519740f, 
    0.16166168f, -0.02032840f, 0.17181365f, 0.10095359f, 0.01590832f, -0.31098571f, 0.05999144f, -0.24482672f, 
    0.16167186f, 0.01499600f, -0.00147714f, 0.18712546f, 0.08390760f, -0.02121345f, -0.06052465f, -0.05727254f, 
    0.16980404f, 0.05440399f, 0.03805854f, -0.10910263f, -0.02252049f, -0.05693798f, 0.02994507f, 0.06093092f, 
    -0.01189272f, -0.01523671f, 0.09507705f, 0.17852652f, -0.20134315f, -0.15256368f, 0.17936862f, -0.13476062f, 
    0.01396685f, 0.07602242f, -0.09923133f, 0.03089895f, -0.02515008f, 0.00674701f, -0.12334363f, 0.00958733f, 
    0.17343797f, 0.04085923f, -0.18630226f, 0.07007775f, -0.05448471f, 0.07104266f, -0.04017672f, 0.02089424f, 
    0.00754788f, 0.15552953f, 0.11906525f, 0.19383296f, -0.02551108f, -0.12667306f, 0.03116772f, 0.13492790f, 
    0.11753456f, 0.04234251f, 0.00233392f, -0.05063670f, 0.00564323f, -0.05660982f, -0.08739071f, -0.09144098f, 
    -0.03931685f, -0.08145748f, 0.24116936f, -0.06526596f, 0.06288197f, 0.00526015f, 0.03563808f, 0.06164869f, 
    -0.00137362f, 0.01635034f, 0.05571047f, -0.01389366f, 0.03252217f, -0.22075512f, -0.03333328f, 0.10661645f, 
    0.14986075f, 0.05228908f, 0.06092840f, -0.03087274f, -0.02456154f, 0.00880075f, -0.07356405f, -0.12325627f, 
    -0.41894838f, -0.14556953f, 0.06419719f, 0.32869330f, -0.08247386f, -0.16782589f, -0.12268829f, 0.07590114f, 
    -0.01752715f, -0.06219394f, 0.01962657f, -0.00618410f, -0.10465348f, 0.12597734f, -0.02326050f, -0.14787638f, 
    -0.01071425f, -0.01261542f, 0.00730204f, -0.04321408f, 0.06515566f, -0.09656797f, 0.02075347f, 0.04925292f, 
    0.03317888f, -0.11354499f, -0.12038614f, -0.12336844f, -0.03488519f, -0.00688454f, -0.20426157f, 0.11746738f, 
    0.12845592f, 0.07762551f, 0.13359964f, -0.01808837f, -0.17097081f, 0.06915173f, 0.22967967f, 0.09632895f, 
    -0.00338551f, -0.01480874f, -0.05536026f, 0.08645404f, 0.09457356f, 0.04657159f, 0.00799795f, 0.11758528f, 
    0.19794618f, 0.01310858f, -0.04437962f, -0.11520717f, 0.01134622f, 0.00506686f, -0.12949871f, -0.05729358f, 
    0.06647880f, -0.04060998f, -0.04624620f, -0.00393163f, 0.26200923f, -0.12147173f, -0.03771730f, -0.13532898f, 
    0.05573036f, 0.00563380f, -0.03867427f, 0.04905031f, 0.14129244f, -0.03155260f, 0.13071753f, -0.02786634f, 
    -0.04437236f, -0.26041532f, 0.00227890f, 0.04472592f, -0.01569276f, 0.04717840f, 0.01302685f, -0.14739975f, 
    0.06920247f, 0.00730601f, -0.01396242f, 0.03104203f, -0.01685609f, -0.05879272f, 0.12986717f, -0.03056690f, 
    0.05233391f, -0.00556437f, -0.03842611f, -0.03625888f, 0.05566231f, -0.03377845f, -0.07385113f, -0.15487523f, 
    -0.15822174f, 0.03097292f, 0.20088756f, -0.00644240f, -0.15382291f, -0.04143314f, 0.01936572f, -0.00178905f, 
    0.10590094f, -0.07770730f, -0.07382981f, 0.00090610f, 0.02485993f, -0.28654677f, -0.15424971f, 0.01671469f, 
    0.12917247f, 0.23010428f, 0.15723474f, 0.05220935f, 0.01922329f, -0.10458433f, -0.03358010f, -0.05404847f, 
    0.17624244f, -0.11878249f, -0.02551619f, -0.35807341f, 0.15610433f, -0.06521793f, 0.09525378f, -0.00663989f, 
    0.15688027f, -0.01131110f, 0.01963494f, 0.06084347f, 0.06646895f, -0.15166041f, 0.16902427f, 0.07913517f, 
    0.09972281f, 0.03939405f, -0.07008050f, 0.01245794f, 0.03368498f, 0.01642257f, 0.15436441f, 0.01191364f, 
    0.15290456f, 0.01208799f, 0.21184924f, 0.04829451f, 0.00410322f, -0.07955123f, -0.09463114f, 0.01682981f, 
    -0.12199496f, 0.02100351f, 0.16127074f, 0.20060971f, 0.00787004f, 0.18401809f, -0.21265118f, -0.13466321f, 
    -0.09155465f, -0.01738420f, 0.14527933f, 0.03255523f, 0.07389570f, -0.12895636f, -0.08896713f, -0.03496731f, 
    0.13169302f, -0.53071100f, 0.44974923f, 0.21848916f, 0.02973736f, -0.02375146f, -0.11610647f, -0.21123604f, 
    0.16000977f, 0.11705618f, -0.06377565f, 0.01159702f, 0.28122154f, 0.12603952f, -0.13458316f, -0.11897974f, 
    0.12751666f, 0.13092819f, 0.17475565f, -0.04162570f, -0.03948819f, -0.09586554f, 0.10300782f, -0.06854711f, 
    -0.24390915f, 0.02348839f, 0.25754672f, 0.31007990f, -0.06870911f, -0.06432542f, -0.04141553f, 0.07827352f, 
    0.03581891f, -0.00893239f, -0.15753330f, 0.15193120f, -0.11007948f, -0.17572053f, -0.21438241f, 0.04065190f, 
    0.16449198f, 0.08023658f, -0.01817969f, -0.03506752f, -0.01586889f, -0.04265529f, 0.12189565f, 0.02497737f, 
    0.00536950f, -0.03984519f, -0.03179861f, -0.04500077f, 0.04076383f, 0.00028141f, 0.01488338f, -0.04347401f, 
    -0.03218988f, -0.01277538f, 0.00672734f, -0.04550166f, 0.01169424f, -0.03236273f, -0.04367919f, 0.00828572f, 
    -0.03703358f, -0.04013466f, 0.02475396f, 0.00065345f, -0.02126419f, -0.03492467f, -0.04868066f, -0.00461659f, 
    -0.05158134f, -0.05402590f, 0.04371208f, 0.03187027f, 0.03526381f, 0.00336183f, -0.00496652f, 0.01606163f, 
    0.00510867f, -0.02706215f, -0.03949507f, -0.02650776f, 0.02765559f, 0.00060622f, -0.05105834f, -0.01896487f, 
    -0.04881163f, -0.02142855f, -0.00329594f, -0.03079975f, -0.00581962f, 0.00614000f, 0.00446814f, 0.03282982f, 
    -0.04281015f, 0.02726102f, -0.04063303f, -0.04760903f, -0.01792865f, 0.01541643f, 0.01760430f, -0.00060747f, 
    -0.02710836f, -0.03929271f, 0.04422772f, 0.03527216f, 0.00869244f, -0.04589272f, -0.00208193f, -0.04239043f, 
    0.03862728f, 0.04252877f, -0.04813883f, -0.03461619f, -0.02406036f, -0.02523958f, -0.00449163f, -0.02157593f, 
    0.01851354f, -0.03001584f, -0.01125760f, -0.03122343f, 0.00894319f, 0.04229771f, 0.01049992f, 0.01706008f, 
    -0.00697752f, 0.00831752f, 0.02802297f, -0.00410346f, -0.01147063f, 0.03920233f, -0.04175272f, -0.03500959f, 
    0.04447442f, 0.03875495f, -0.00039394f, 0.02928322f, -0.03802844f, -0.01041772f, -0.04861460f, -0.01504193f, 
    0.03492769f, -0.00618336f, 0.03588122f, -0.00862653f, 0.01492648f, -0.02421313f, 0.00998988f, -0.04143503f, 
    0.00809373f, -0.00075562f, 0.01909315f, -0.02237989f, 0.03967566f, 0.03934512f, -0.04192800f, 0.01135546f, 
    -0.04105702f, -0.04063024f, 0.01968552f, 0.03244971f, 0.01943941f, 0.03732708f, 0.03971511f, 0.03536848f, 
    0.00748113f, -0.02012464f, -0.04286700f, -0.00725252f, 0.04290668f, -0.04644762f, 0.02333785f, -0.04669772f, 
    -0.05242649f, 0.00347163f, -0.02622527f, -0.01727831f, -0.00090189f, 0.00680411f, -0.03750506f, -0.04361014f, 
    -0.00322549f, -0.02864238f, -0.03421394f, 0.00058829f, 0.01515941f, 0.02208440f, 0.02699618f, -0.00197946f, 
    0.02394882f, 0.02284723f, -0.02542773f, -0.02909127f, -0.00713851f, 0.00293662f, -0.03745915f, -0.03338677f, 
    -0.03900885f, -0.00748483f, -0.02330928f, -0.01274971f, -0.01934901f, -0.01281991f, -0.01610666f, -0.04770231f, 
    0.02979816f, 0.02308893f, 0.02989049f, 0.02645763f, -0.01654217f, -0.01495419f, -0.05475817f, -0.04103036f, 
    -0.00712466f, 0.00786822f, 0.00724266f, -0.03963948f, -0.03848458f, -0.04767045f, 0.02612866f, -0.02207404f, 
    0.04448612f, 0.03711633f, -0.04197138f, -0.02639291f, 0.03375700f, -0.05097312f, -0.03557954f, 0.03680586f, 
    0.03548500f, 0.01139382f, 0.00207188f, -0.01025551f, -0.03318634f, 0.02092250f, -0.03556026f, -0.02502507f, 
    -0.05319447f, -0.02106418f, -0.01841725f, -0.00680555f, 0.01166468f, 0.00858891f, 0.01005529f, 0.01630492f, 
    -0.02995978f, -0.01974970f, -0.04318968f, -0.04380659f, 0.01597691f, 0.00097325f, -0.04645920f, -0.03886599f, 
    -0.01112827f, -0.03401368f, -0.01814681f, 0.04872024f, -0.02925608f, 0.03816488f, 0.03205835f, 0.04081400f, 
    0.04300361f, -0.03017529f, 0.02291358f, -0.03245535f, -0.00682777f, -0.04267926f, 0.03200211f, -0.01383843f, 
    0.03054399f, 0.02559089f, -0.01212482f, -0.00274729f, -0.03328370f, -0.05436951f, -0.00055109f, 0.05107238f, 
    0.02417766f, -0.01827923f, 0.00173085f, -0.03460984f, -0.00190078f, 0.02325505f, -0.02369227f, -0.02761520f, 
    -0.01561334f, 0.02237105f, 0.01520472f, 0.04522696f, -0.04417198f, 0.02529962f, -0.03685075f, 0.00905184f, 
    -0.00245448f, -0.04509348f, 0.01326592f, 0.00433286f, 0.01748188f, 0.04248084f, -0.00074986f, -0.04285230f, 
    0.00902696f, 0.03344877f, -0.01783443f, -0.02597539f, 0.03225134f, 0.03424792f, 0.03575361f, 0.02391388f, 
    -0.02100727f, -0.04794808f, -0.05026631f, 0.02311140f, -0.00216711f, -0.00606440f, 0.03142868f, 0.03621369f, 
    -0.04174374f, 0.01655809f, -0.02312376f, 0.01774304f, -0.00954300f, 0.00972440f, -0.03926388f, 0.00778071f, 
    0.04317939f, -0.00917229f, 0.03363432f, -0.04585543f, 0.01243953f, 0.02358367f, -0.00722314f, -0.01503482f, 
    0.03721727f, 0.03586134f, 0.01040625f, 0.03876645f, -0.03764634f, -0.02382539f, 0.03864299f, 0.04273465f, 
    -0.04524229f, 0.01941337f, -0.02497928f, -0.01606249f, -0.02708951f, 0.04978260f, -0.01413663f, -0.02958913f, 
    -0.01917790f, 0.04398723f, -0.04467482f, -0.04061608f, -0.00973449f, 0.00056666f, -0.02099772f, -0.00765352f, 
    -0.00238986f, 0.00986497f, -0.04775329f, 0.03852393f, -0.03685136f, -0.00640576f, -0.01586837f, 0.01201647f, 
    0.02172447f, -0.00580448f, -0.02693181f, 0.03641883f, 0.01808836f, 0.03704792f, 0.04284771f, 0.02064897f, 
    0.00455771f, 0.04312569f, -0.02592462f, -0.03450945f, -0.01447551f, -0.03841667f, -0.01226873f, -0.03605415f, 
    -0.02027996f, -0.01008468f, 0.03926744f, -0.04561443f, 0.04285115f, -0.05607226f, 0.00461295f, -0.05693572f, 
    0.00932320f, -0.01241136f, -0.00765179f, 0.00224370f, 0.01745821f, 0.02794151f, -0.03220920f, 0.04685599f, 
    0.02436306f, 0.01175705f, -0.01318087f, 0.01331613f, 0.03002168f, -0.04102076f, -0.05029111f, 0.03081244f, 
    -0.01681721f, -0.04940184f, 0.00592291f, -0.03634173f, 0.05300649f, -0.05308782f, -0.01348315f, 0.01488636f, 
    -0.00726388f, 0.01314383f, -0.01350959f, 0.03704045f, -0.04577287f, 0.00953655f, 0.01256638f, -0.05318393f, 
    0.04844310f, 0.00148027f, -0.04289882f, -0.01281152f, -0.03815058f, -0.04610249f, 0.01765276f, -0.01882255f, 
    -0.22617424f, -0.10074546f, -0.09871241f, -0.27186662f, -0.14149636f, -0.04315976f, 0.04071013f, -0.02696106f, 
    -0.14026926f, -0.08606116f, -0.05415762f, 0.07433125f, 0.22566110f, -0.18300718f, -0.07133913f, -0.04700717f, 
    -0.04598642f, 0.16916080f, 0.08459557f, -0.00569630f, 0.11083343f, -0.00307219f, 0.03336446f, 0.14143370f, 
    -0.22788905f, -0.24859145f, -0.11377842f, -0.09530701f, -0.03942826f, -0.02192577f, -0.10784242f, -0.00866862f, 
    0.09301080f, -0.00484455f, 0.16159944f, 0.02176903f, -0.10521239f, -0.02294375f, -0.03994527f, -0.00129889f, 
    -0.06254956f, -0.16808984f, 0.12152028f, -0.08133312f, 0.00512766f, 0.00688018f, -0.01172624f, 0.03301456f, 
    -0.04076958f, 0.00989824f, 0.02382709f, -0.13313207f, 0.02930800f, 0.07472344f, -0.01612945f, -0.01234997f, 
    -0.00091670f, -0.02766818f, -0.03968799f, 0.09210522f, -0.00898850f, 0.09700266f, -0.04690033f, -0.17648257f, 
    0.11155473f, 0.02057419f, -0.08591302f, -0.07640546f, -0.09880865f, -0.07377539f, -0.04870817f, -0.02407325f, 
    -0.14614446f, -0.02967609f, 0.13387266f, 0.07677622f, 0.00515715f, 0.09571311f, 0.02091707f, 0.15255737f, 
    -0.06210999f, 0.01546032f, 0.01009466f, -0.02840394f, 0.06992710f, -0.03191222f, -0.09021522f, 0.08280359f, 
    0.29807508f, -0.09998535f, 0.28862041f, -0.02138818f, 0.11091867f, 0.02852867f, -0.05740484f, 0.05953017f, 
    -0.04179803f, -0.03807960f, -0.13743962f, -0.00720779f, 0.06569149f, -0.00706596f, -0.03939702f, 0.00584900f, 
    0.17333627f, 0.09813254f, -0.07524998f, 0.04858536f, 0.10478043f, 0.19561315f, -0.14743456f, -0.25993428f, 
    0.04333786f, -0.11263610f, 0.25888252f, 0.08016464f, 0.00376330f, -0.04418396f, 0.00844802f, -0.00073742f, 
    0.24428870f, -0.14210756f, 0.08958369f, -0.09240539f, 0.04265734f, 0.11493909f, 0.10405376f, -0.02391723f, 
    0.18338452f, -0.04740167f, 0.09629391f, 0.10752489f, -0.17586888f, -0.05900833f, -0.02261686f, -0.13445838f, 
    -0.09713057f, -0.13072339f, -0.08204150f, -0.01999157f, -0.09311956f, -0.07496868f, -0.07083518f, -0.04936208f, 
    0.07041053f, 0.04721524f, -0.20995991f, -0.11197123f, 0.07823249f, -0.04493209f, 0.23162888f, 0.07489847f, 
    0.01818323f, -0.02391039f, -0.04966895f, -0.00125152f, 0.08894596f, 0.03464164f, 0.01261546f, -0.13205896f, 
    0.02014437f, 0.06810252f, -0.02584602f, 0.04556656f, -0.00301957f, -0.08274361f, 0.06529888f, 0.04282316f, 
    0.32117537f, -0.08153146f, -0.35425317f, 0.19282812f, 0.14496517f, 0.13942003f, 0.00381146f, -0.03807575f, 
    0.08748187f, 0.14206021f, 0.01033989f, -0.02168924f, -0.10149714f, 0.00543849f, 0.02988182f, -0.17631599f, 
    -0.01493456f, 0.09995048f, 0.02678948f, 0.03744768f, -0.01789149f, -0.01850771f, -0.04617400f, -0.07166331f, 
    0.24315475f, -0.13547720f, 0.20395397f, -0.00136947f, -0.04972711f, -0.00823194f, 0.07634284f, -0.01492713f, 
    0.04578006f, 0.07027214f, 0.08300950f, 0.01735204f, 0.17050715f, -0.07766479f, -0.05705739f, 0.13842328f, 
    0.09406164f, -0.05363052f, 0.00971879f, 0.07664895f, -0.00680620f, -0.04178848f, 0.14346960f, 0.00033190f, 
    -0.19241725f, -0.14376752f, 0.08782444f, -0.13073440f, -0.10342539f, -0.08025077f, 0.06092724f, 0.12655953f, 
    -0.01674741f, -0.03578207f, 0.11316191f, -0.13548410f, 0.00557434f, 0.02588648f, 0.14551596f, 0.17375223f, 
    -0.02183084f, -0.01744886f, 0.01207266f, -0.04147865f, 0.04391208f, 0.18016124f, 0.00311552f, 0.21596789f, 
    0.19038327f, -0.07343267f, 0.06724565f, 0.03278220f, 0.31464034f, -0.09700840f, 0.09788135f, -0.02523075f, 
    0.20362219f, -0.05149261f, 0.19770582f, -0.09945261f, -0.24821533f, -0.00055556f, 0.01141289f, -0.03854763f, 
    -0.01634709f, 0.05963301f, 0.03209656f, 0.03320495f, 0.02514534f, 0.08165943f, 0.17294487f, 0.14626957f, 
    -0.01313286f, 0.11736411f, -0.07916321f, -0.19791368f, 0.01057246f, 0.03667131f, 0.13345805f, 0.12894432f, 
    0.04005362f, -0.15081237f, 0.02119964f, -0.04176054f, 0.01693943f, -0.02286510f, 0.07583551f, -0.07455874f, 
    -0.09221273f, 0.04388407f, -0.06701918f, -0.00111915f, -0.02076159f, -0.05019677f, -0.03529518f, -0.00366137f, 
    0.19382976f, 0.23350772f, 0.00793552f, -0.05588319f, -0.07207488f, 0.07815745f, 0.08873153f, 0.04351441f, 
    0.00821551f, 0.24227116f, -0.01625150f, 0.08004384f, -0.03084366f, 0.06003935f, -0.00518193f, -0.00634828f, 
    0.07469591f, -0.02409631f, -0.06175400f, 0.07812077f, 0.02918025f, 0.08583513f, -0.08648288f, 0.00846116f, 
    -0.10733239f, -0.03782678f, -0.12983546f, -0.07515049f, -0.08163173f, -0.05081932f, 0.04081234f, -0.10079213f, 
    0.10900885f, 0.00302127f, 0.04817757f, 0.04747923f, -0.36383873f, 0.02021571f, -0.02519428f, -0.10458822f, 
    -0.08589967f, 0.11328091f, -0.01759423f, -0.05142586f, 0.01933860f, 0.03150242f, -0.06934772f, -0.00015998f, 
    -0.00609553f, 0.01704296f, -0.06155974f, -0.03509384f, 0.11059238f, -0.18690740f, -0.05033847f, 0.25881109f, 
    0.09317188f, -0.00680563f, 0.18343508f, 0.06777827f, -0.08994018f, -0.30892760f, -0.18016429f, -0.11294621f, 
    -0.05790218f, 0.05076052f, 0.03087957f, 0.06362901f, -0.01397464f, 0.02376465f, -0.03468481f, 0.08047650f, 
    0.08809970f, -0.01672146f, -0.28343773f, 0.18742199f, 0.07585761f, 0.07830445f, 0.00156902f, -0.01337348f, 
    0.04509726f, 0.22171660f, 0.15632549f, 0.00697074f, 0.08704957f, 0.02451419f, 0.04447104f, 0.02219970f, 
    -0.05231761f, -0.04941485f, -0.10105443f, 0.00774416f, -0.11294503f, -0.09980592f, -0.08954423f, -0.14850518f, 
    -0.03590596f, -0.02861741f, 0.04926123f, 0.11130639f, 0.07091836f, -0.13283469f, 0.12671164f, -0.01671560f, 
    -0.06414455f, -0.05100064f, -0.03751227f, 0.00957163f, -0.20148715f, 0.02966999f, 0.11844723f, 0.04439903f, 
    -0.05466773f, -0.00477167f, -0.00960531f, -0.08811621f, 0.05496373f, 0.08961307f, -0.04732634f, 0.04545236f, 
    0.16927160f, 0.10487083f, 0.02570747f, 0.30695331f, -0.07961912f, -0.04031195f, 0.06713308f, 0.02337680f, 
    0.07581338f, 0.09096161f, -0.01943926f, 0.02303312f, -0.18127358f, -0.13858894f, 0.03109840f, -0.02374274f, 
    -0.05748167f, -0.14203112f, 0.28924105f, 0.01216282f, 0.06866825f, -0.01427685f, 0.07508432f, -0.02393978f, 
    0.02761437f, 0.05100500f, 0.17717010f, 0.40265456f, 0.09885196f, 0.14260715f, 0.23922209f, -0.08315820f, 
    -0.01492166f, 0.07477116f, -0.04203935f, -0.04474492f, -0.19137090f, -0.04794234f, 0.35032082f, 0.15329513f, 
    0.01916618f, -0.09442180f, -0.05622877f, 0.16346930f, 0.09370280f, -0.09938730f, -0.00105789f, -0.11153425f, 
    0.14299963f, 0.00609167f, -0.14792967f, 0.01186478f, -0.01474415f, -0.12886280f, 0.18655820f, 0.08370382f, 
    0.03516161f, -0.01615011f, 0.14291617f, -0.01702745f, 0.06505105f, -0.03774200f, 0.02427551f, 0.13661936f, 
    0.26840115f, 0.00326920f, -0.00073218f, 0.04469280f, -0.05108799f, 0.17514984f, -0.11893716f, -0.06207568f, 
    -0.06051583f, -0.17807391f, -0.03105867f, 0.06006710f, -0.02915792f, -0.07900328f, 0.11932655f, 0.04659284f, 
    0.04306714f, 0.07817760f, 0.08106167f, -0.07752038f, -0.25304249f, 0.22336444f, -0.16214710f, -0.19317001f, 
    -0.08866268f, 0.01271226f, -0.07869622f, 0.12633561f, -0.04470171f, -0.00324903f, -0.06670055f, 0.02658121f, 
    -0.36673620f, 0.07918496f, -0.05336313f, 0.07224163f, -0.04804607f, -0.01099744f, -0.09730722f, 0.01414657f, 
    0.11372007f, 0.22233155f, 0.00781792f, -0.04153237f, -0.27365711f, -0.10911094f, -0.09772498f, -0.06477484f, 
    0.08670622f, 0.00368986f, -0.10108041f, 0.03889321f, 0.10498732f, -0.16238137f, -0.00728245f, -0.21270677f, 
    -0.04310838f, -0.09059665f, -0.03527627f, 0.07344016f, 0.03713171f, -0.00347431f, -0.03387335f, 0.15434153f, 
    0.06327151f, -0.11943081f, 0.04056282f, 0.09394186f, 0.01133914f, -0.13784255f, 0.18392949f, -0.02526424f, 
    -0.02766458f, -0.07644275f, -0.18669932f, -0.10629950f, 0.14170094f, -0.05467222f, -0.00333786f, 0.01262686f, 
    0.10242057f, -0.12991029f, -0.22005486f, 0.04935165f, -0.06051017f, -0.05988829f, -0.15635675f, 0.09327980f, 
    -0.03774477f, 0.06527023f, -0.14103039f, -0.09689243f, -0.14078844f, -0.13628307f, -0.02845849f, 0.06806657f, 
    -0.01318186f, -0.09819506f, -0.05807983f, 0.11737035f, 0.02553629f, 0.00180148f, -0.07066608f, 0.01551192f, 
    -0.43319526f, 0.18915728f, 0.32970005f, -0.38243696f, 0.15843894f, 0.13412565f, 0.03673542f, -0.06483287f, 
    0.01447446f, -0.04539051f, 0.05842921f, -0.03510454f, -0.14737605f, 0.21861662f, 0.10544115f, 0.00925315f, 
    0.02312354f, -0.05073864f, 0.03993966f, 0.03600599f, -0.08338933f, 0.03604034f, -0.02479170f, -0.08142482f, 
    -0.11510596f, -0.11124888f, 0.22572048f, -0.07286203f, 0.10931114f, 0.02146451f, -0.01464686f, -0.31747606f, 
    0.09806068f, 0.03919250f, 0.01604160f, -0.11778532f, 0.05991384f, -0.33098105f, -0.10371171f, -0.03354610f, 
    0.00615678f, -0.01788388f, -0.01280511f, 0.10269617f, 0.09877624f, 0.04840390f, 0.11226819f, 0.04561774f, 
    0.20220578f, -0.03310857f, -0.01928970f, 0.19530886f, -0.04559140f, 0.02943633f, 0.00644575f, -0.02081033f, 
    -0.06004726f, -0.04935979f, 0.00671839f, 0.06314446f, 0.22358598f, 0.20086284f, -0.08112711f, -0.06803349f, 
    0.07650146f, 0.01658097f, -0.09672844f, 0.04710594f, -0.02141465f, -0.17586724f, 0.07672181f, -0.13527966f, 
    -0.05523618f, -0.09505007f, 0.02609498f, -0.01292847f, 0.22349839f, -0.02585545f, 0.02017676f, 0.08091427f, 
    0.08741248f, -0.27489945f, 0.17701952f, 0.08427539f, -0.46275797f, -0.25128976f, 0.00149472f, -0.11715709f, 
    -0.01193067f, 0.04904277f, -0.15118504f, -0.02999505f, 0.08400689f, -0.09862054f, -0.20000370f, -0.07106288f, 
    -0.33965465f, 0.39813393f, -0.10183107f, 0.12982294f, -0.02638633f, 0.13091640f, -0.20456772f, -0.01628537f, 
    0.16111133f, -0.01538652f, 0.15698954f, 0.05290312f, 0.16370355f, 0.06994002f, 0.10409243f, -0.04272455f, 
    0.09985563f, 0.05525419f, -0.08962572f, 0.05040108f, -0.03312576f, -0.11970817f, 0.01975161f, 0.20317067f, 
    0.02016055f, 0.03840961f, -0.04029279f, 0.19655423f, 0.14698088f, 0.02947424f, -0.11296248f, 0.05576644f, 
    -0.11178561f, -0.04733062f, 0.08839931f, 0.04625846f, 0.02109894f, 0.08653247f, 0.09100627f, -0.03020631f, 
    0.11066249f, -0.04509526f, 0.06359014f, 0.08859812f, 0.10840950f, -0.08175451f, -0.18807909f, 0.01098711f, 
    -0.39477974f, -0.02805311f, 0.20961870f, -0.26924771f, 0.10950778f, 0.04645865f, -0.05730386f, 0.09275728f, 
    0.00912326f, 0.10816471f, 0.03087179f, 0.10084716f, -0.18640742f, -0.16199014f, 0.12634739f, -0.02813775f, 
    0.21574676f, -0.01284881f, 0.08406576f, 0.15878376f, -0.04513816f, -0.03097404f, -0.01318561f, -0.05858596f, 
    0.13379812f, -0.06760608f, -0.28627315f, 0.25889975f, 0.10714138f, -0.12290758f, -0.05499527f, 0.06205391f, 
    0.11181574f, 0.06441763f, 0.06766531f, 0.09388195f, -0.41181278f, -0.39243534f, -0.09860906f, 0.01642522f, 
    -0.04445761f, -0.08472513f, -0.12374157f, -0.06997008f, 0.13662395f, 0.04779019f, 0.12440879f, 0.19908197f, 
    -0.01458993f, 0.03580986f, -0.03521712f, -0.05481192f, 0.00620525f, -0.03845817f, 0.01581671f, -0.01342220f, 
    -0.04293432f, -0.03762435f, -0.04569843f, -0.01560008f, -0.00380781f, -0.03403327f, 0.01562415f, 0.03671190f, 
    -0.04486458f, 0.03303631f, 0.02363282f, -0.02064765f, -0.04122150f, -0.05063754f, -0.00592293f, -0.04078522f, 
    0.01213556f, 0.00275578f, -0.01465250f, -0.01396946f, -0.04737871f, -0.03371058f, -0.05462372f, 0.03537422f, 
    0.02882469f, 0.00701536f, -0.04933986f, 0.01518870f, -0.02288311f, -0.05643058f, -0.04620982f, -0.04180549f, 
    0.04927609f, 0.01482696f, 0.00294646f, -0.04496316f, -0.02195378f, -0.04830542f, 0.01184773f, -0.02073835f, 
    -0.00909333f, -0.02465412f, 0.01066732f, 0.00925867f, -0.01726063f, -0.02948359f, -0.04039638f, 0.00661403f, 
    0.01553148f, -0.03945637f, 0.01390987f, 0.00053168f, -0.02354299f, -0.01425924f, -0.02505862f, -0.00286660f, 
    0.02151341f, -0.01509460f, -0.03709877f, -0.04185582f, -0.01384758f, -0.01916881f, -0.01733312f, -0.04298484f, 
    0.01915276f, 0.01117839f, -0.04599603f, 0.03557679f, 0.02305761f, 0.02039351f, -0.02596688f, 0.02257038f, 
    -0.04704173f, -0.01829487f, -0.01218445f, 0.02384824f, -0.03345111f, 0.04331957f, -0.01373335f, -0.00537015f, 
    0.01018562f, -0.05649120f, -0.04711524f, -0.03882108f, -0.02313535f, -0.03315742f, 0.03217956f, -0.01192197f, 
    -0.03900091f, -0.03391623f, -0.01412379f, 0.01979686f, -0.01631049f, 0.03122360f, -0.02917621f, -0.00849142f, 
    -0.05057599f, -0.02613177f, 0.01793885f, 0.01964615f, -0.03191971f, -0.02655317f, -0.01379365f, -0.05481780f, 
    -0.03485372f, -0.00837481f, -0.00443487f, -0.03238558f, 0.00010672f, -0.01996632f, -0.00356396f, -0.03434836f, 
    0.01112096f, 0.02703418f, -0.05536559f, -0.02731589f, -0.04390388f, 0.04519905f, 0.02028988f, -0.03620837f, 
    0.04083882f, 0.04232943f, 0.03564338f, 0.01556922f, -0.00200412f, 0.00575479f, -0.04644025f, -0.02637287f, 
    0.00518688f, 0.02918711f, -0.04675023f, 0.00461216f, -0.05732616f, -0.04250683f, 0.02621108f, 0.04248270f, 
    0.01044098f, -0.02846655f, 0.01144541f, 0.03881196f, 0.02668877f, -0.00984367f, 0.03020506f, -0.03331001f, 
    0.03291982f, 0.00928694f, -0.02139959f, -0.01290995f, -0.00290308f, 0.03040809f, -0.03491522f, 0.00986909f, 
    -0.03623535f, -0.01979982f, 0.01239229f, -0.02097038f, 0.03575677f, 0.01204435f, -0.02255969f, 0.03622743f, 
    0.01920670f, -0.02593776f, -0.03110770f, -0.01553528f, 0.00704492f, -0.02484639f, -0.05291993f, -0.02289790f, 
    -0.02314358f, -0.03608618f, 0.02996193f, 0.00377345f, -0.02457680f, -0.05279179f, 0.00025125f, 0.01944016f, 
    -0.00929444f, -0.03544638f, 0.01290645f, -0.04027653f, -0.03806978f, 0.01111807f, -0.05290974f, -0.00233280f, 
    -0.03779380f, 0.03836426f, 0.00532905f, -0.05570653f, -0.03047977f, 0.00771130f, -0.03938530f, -0.01684918f, 
    -0.04662307f, -0.04513873f, 0.00568319f, -0.02691350f, -0.03219837f, 0.03715999f, -0.01665836f, -0.04390441f, 
    -0.03965083f, 0.03180347f, -0.04427256f, -0.03756109f, -0.02112116f, -0.04168318f, 0.03517861f, -0.00725851f, 
    -0.02311663f, -0.03294126f, 0.03158478f, -0.00864640f, 0.01911280f, -0.01039292f, -0.02133664f, -0.02783135f, 
    0.00806698f, 0.04201176f, -0.01689241f, 0.03921144f, 0.00518313f, 0.00801622f, -0.01307171f, -0.04264282f, 
    -0.01091638f, -0.00983484f, -0.05271901f, -0.01685037f, 0.02725341f, -0.01717982f, -0.04887057f, -0.01849101f, 
    0.01087133f, 0.03169911f, -0.03609738f, 0.03315064f, 0.03282252f, -0.04826678f, -0.03907644f, -0.01167273f, 
    0.04035963f, 0.02276904f, 0.00861848f, -0.01886830f, -0.02495367f, -0.01510569f, -0.05662458f, -0.02591883f, 
    0.00548695f, -0.04405328f, -0.02262005f, -0.02791739f, 0.03578918f, 0.01474951f, 0.01866333f, -0.01401454f, 
    -0.00713694f, -0.02135578f, -0.00549517f, -0.05573803f, 0.00363909f, -0.04054829f, -0.01572581f, 0.02239753f, 
    -0.05437362f, -0.05286317f, -0.03836656f, 0.02877635f, -0.03962491f, 0.00138861f, 0.02703510f, 0.03896224f, 
    0.00986261f, 0.02520985f, 0.00492622f, 0.01935498f, -0.03507597f, 0.00788237f, 0.01427762f, -0.04714511f, 
    -0.02957607f, 0.02121784f, -0.04075788f, -0.04262013f, 0.01766022f, 0.01610681f, -0.05150355f, 0.02919098f, 
    0.00474224f, -0.04315810f, 0.04103908f, -0.05075085f, 0.02483778f, 0.02985668f, 0.02141522f, -0.05119682f, 
    0.01021798f, -0.04387813f, -0.03793888f, 0.00381874f, -0.03775420f, -0.00188231f, -0.04333233f, -0.00405424f, 
    0.02684923f, 0.03244166f, -0.02982575f, -0.05024917f, 0.01800219f, -0.01543042f, 0.00714747f, -0.04830111f, 
    0.01118114f, 0.03410088f, -0.04197554f, 0.01666969f, 0.01766151f, -0.03666886f, 0.02584757f, 0.03260037f, 
    -0.05046251f, -0.04677151f, -0.03030820f, -0.01842335f, -0.03159454f, 0.00500834f, 0.04533280f, -0.01354865f, 
    -0.05459204f, 0.03690075f, 0.03097713f, -0.03880255f, -0.05451299f, 0.04012946f, -0.00930493f, -0.02976817f, 
    -0.02668242f, -0.05606690f, 0.04177884f, -0.01777855f, 0.01129769f, 0.02331837f, 0.04227616f, -0.05574688f, 
    -0.02877430f, 0.03015283f, -0.05603125f, -0.03539822f, 0.02928415f, 0.00707595f, -0.05213306f, 0.01392565f, 
    -0.03938837f, -0.03694308f, -0.01462215f, -0.05616341f, 0.02304320f, 0.03094854f, -0.00566228f, 0.01530181f, 
    -0.04609065f, 0.01527652f, 0.04401141f, -0.03369030f, 0.01865219f, -0.00840571f, 0.02719986f, 0.03711331f, 
    0.00594986f, 0.03309967f, 0.01146228f, 0.00944897f, -0.01344237f, 0.00545468f, -0.00270524f, -0.00951077f, 
    0.03172982f, 0.12599304f, 0.11425865f, 0.01498183f, -0.01089937f, -0.00082331f, -0.02702153f, 0.00383237f, 
    -0.00514010f, 0.02473487f, -0.08978934f, 0.02683616f, 0.20419559f, 0.34114590f, 0.40025538f, -0.23427136f, 
    -0.05993906f, 0.11916108f, -0.11254252f, -0.21736081f, 0.11247203f, 0.13005626f, -0.09459388f, -0.04443373f, 
    0.10015150f, 0.30992523f, 0.37553340f, 0.19650544f, -0.05615595f, 0.01217483f, 0.07069784f, 0.02063990f, 
    -0.12192891f, -0.07650018f, -0.09017991f, 0.01066918f, 0.08966066f, 0.00336897f, -0.07739368f, 0.10014601f, 
    0.10015549f, 0.16244835f, 0.06842175f, 0.06045841f, -0.03499744f, 0.08856074f, 0.00416489f, -0.06056304f, 
    -0.07722861f, -0.04786231f, -0.05862483f, -0.30113652f, 0.02683169f, -0.03448977f, -0.03676395f, 0.10449548f, 
    -0.06360634f, -0.04033561f, -0.03878990f, 0.03616145f, -0.25505418f, -0.11529638f, -0.19939969f, 0.09100366f, 
    -0.01560925f, 0.18740205f, -0.00974943f, 0.09863514f, 0.01238076f, -0.01922134f, 0.03001183f, -0.02980510f, 
    0.18652244f, 0.00678072f, 0.21263467f, -0.02717871f, 0.01369931f, -0.00442636f, -0.11830330f, -0.19924110f, 
    -0.03187916f, 0.10958191f, 0.06533346f, 0.16119011f, -0.24561580f, 0.11248778f, -0.03615353f, 0.15370061f, 
    0.08500224f, 0.13066357f, -0.07694827f, -0.13113996f, 0.05142087f, 0.01596750f, 0.00800818f, 0.12757146f, 
    0.00719750f, 0.13013572f, -0.03273132f, 0.10491131f, 0.14012474f, 0.09262138f, -0.12916571f, 0.05566268f, 
    0.06939741f, 0.18957432f, -0.00861340f, 0.19345002f, 0.03594838f, -0.09520051f, -0.01897470f, -0.12180224f, 
    0.14563969f, -0.01958494f, 0.00241033f, 0.01426936f, 0.04977654f, -0.02906605f, 0.10192249f, -0.02916929f, 
    -0.03807697f, 0.04111727f, 0.14270581f, -0.19525212f, -0.03688066f, -0.00792419f, -0.05908988f, -0.04194865f, 
    -0.17298488f, 0.05609410f, 0.13303293f, 0.12306087f, -0.09516878f, -0.18604150f, -0.15782630f, -0.07556657f, 
    -0.06128696f, 0.01894891f, -0.02833554f, 0.09808232f, -0.09436053f, -0.06751347f, 0.03166063f, 0.11736359f, 
    -0.02457921f, 0.19547352f, -0.22207627f, 0.02299874f, -0.01001236f, 0.09162983f, 0.06769416f, -0.05743845f, 
    -0.05839135f, 0.00887761f, 0.09092503f, 0.02347377f, -0.07908956f, -0.14280820f, -0.09998523f, 0.05594693f, 
    0.05547929f, 0.12096864f, 0.08627482f, 0.03293043f, -0.01884982f, -0.02421099f, -0.06463441f, 0.07427787f, 
    -0.37846306f, 0.07918481f, 0.04329486f, 0.04809625f, 0.09750484f, 0.12469883f, -0.08932834f, 0.08736137f, 
    0.20351540f, 0.01422788f, 0.09135511f, 0.01396689f, 0.18035024f, 0.14892234f, 0.13994902f, -0.02005364f, 
    0.09359383f, 0.11863989f, 0.11168689f, 0.16228819f, -0.09128067f, -0.06017972f, -0.10109129f, -0.03434598f, 
    0.28392640f, 0.15992461f, -0.01504060f, 0.01410571f, -0.00468303f, -0.07993180f, -0.13464151f, -0.12698059f, 
    0.03220178f, -0.00794749f, -0.01013177f, 0.00747734f, 0.12417650f, 0.23981424f, 0.20826484f, 0.25039491f, 
    0.03892006f, 0.03450647f, 0.08539345f, 0.06373765f, 0.01103658f, 0.01552485f, 0.08719368f, 0.04668299f, 
    0.21129215f, 0.07874048f, 0.24501269f, 0.08072170f, 0.02787966f, 0.03104587f, -0.03283890f, -0.12288518f, 
    -0.01448063f, -0.16198759f, -0.09824277f, -0.08391821f, -0.05132140f, -0.10651360f, -0.02970517f, -0.05831123f, 
    -0.05267191f, -0.01756886f, -0.10606094f, -0.00647736f, 0.03562305f, 0.15144253f, -0.18024924f, -0.01289451f, 
    -0.20947000f, 0.36160991f, -0.09014202f, 0.10837944f, 0.02651094f, -0.10092860f, -0.04889395f, 0.22308229f, 
    0.11745384f, -0.03832544f, 0.03281935f, 0.09188204f, 0.00140030f, -0.22600889f, 0.06995807f, 0.04381277f, 
    0.07528290f, -0.00242699f, -0.02514238f, 0.07210290f, -0.08666375f, 0.01143141f, 0.08720275f, -0.07967409f, 
    -0.20027481f, 0.25361094f, 0.21495740f, 0.21688330f, 0.03553892f, 0.09155203f, 0.00085759f, -0.18117622f, 
    -0.03082252f, 0.06223377f, 0.07085189f, 0.05690325f, -0.14799584f, -0.19079766f, -0.13488340f, 0.05304976f, 
    -0.02244239f, -0.05476659f, 0.04779461f, 0.09055059f, -0.04985941f, 0.07267117f, 0.04033935f, 0.05915658f, 
    0.22188476f, 0.28362295f, 0.01181893f, -0.07530536f, -0.00535064f, -0.03652364f, -0.32305023f, -0.00928914f, 
    0.00109796f, 0.06008979f, -0.23524339f, -0.16450343f, -0.27753195f, -0.03157205f, -0.17358555f, 0.10934118f, 
    0.01836565f, 0.11122518f, -0.00553300f, 0.12345260f, 0.03162136f, -0.04177515f, -0.07711674f, 0.07113836f, 
    0.11677090f, 0.13389920f, 0.15903832f, 0.23234670f, -0.00551251f, -0.00152939f, 0.02221657f, -0.02003560f, 
    -0.01962538f, 0.11482224f, -0.04631801f, 0.03562941f, 0.29374376f, -0.21708091f, 0.05646240f, -0.01300749f, 
    0.05991142f, 0.13181427f, -0.06909864f, 0.07068842f, 0.02917491f, -0.00724564f, -0.00379880f, -0.01900504f, 
    -0.16753060f, -0.15963575f, -0.01032214f, 0.08312217f, 0.04094776f, 0.04993305f, -0.04467529f, -0.02669795f, 
    0.12203235f, 0.09473059f, -0.02774108f, 0.03081390f, 0.09862338f, -0.29177940f, -0.20208946f, -0.17212979f, 
    -0.04839528f, 0.01736849f, 0.07762952f, -0.13217603f, -0.06992525f, 0.07692428f, -0.12466019f, 0.05029938f, 
    -0.25160718f, -0.07407694f, 0.08604063f, -0.30661708f, -0.01343873f, 0.13898753f, -0.04785944f, 0.01930519f, 
    0.07561545f, -0.02030776f, 0.06861724f, 0.03615551f, -0.16224748f, -0.15822782f, -0.09649631f, 0.08059445f, 
    -0.04538252f, 0.08458270f, -0.03381370f, -0.01166391f, 0.07327441f, 0.08851624f, 0.02419073f, 0.07516810f, 
    0.04084415f, -0.04064196f, 0.02304399f, 0.00891843f, -0.03195719f, 0.04094822f, -0.01468712f, 0.01990199f, 
    -0.05178021f, -0.00439198f, 0.03274791f, -0.01475776f, -0.01449410f, 0.00861425f, -0.00687485f, 0.04643403f, 
    0.03329503f, -0.01826215f, 0.02442442f, 0.02016927f, 0.01800455f, -0.00164837f, -0.05274980f, -0.01128297f, 
    0.01669990f, -0.04744558f, -0.02073863f, -0.03998646f, -0.00566773f, -0.04866875f, -0.00379666f, -0.02916603f, 
    -0.05322026f, -0.03588538f, -0.04032573f, 0.04407302f, 0.03673606f, -0.02111303f, 0.03297733f, -0.00953149f, 
    -0.04115304f, -0.01454107f, -0.00417872f, -0.04981338f, 0.00462178f, -0.03115732f, 0.01494358f, 0.00750410f, 
    0.02889739f, -0.02660398f, 0.04546403f, 0.03337228f, 0.03497999f, -0.02373305f, -0.00280574f, -0.01352427f, 
    0.00350360f, -0.03491836f, 0.00466592f, -0.01461091f, 0.01910876f, -0.00644257f, -0.03585852f, 0.02986195f, 
    -0.01825041f, 0.02741690f, 0.03414614f, 0.03220299f, -0.04915639f, -0.02042871f, -0.04778003f, -0.03674134f, 
    -0.04442491f, -0.05719261f, -0.05425313f, 0.00978709f, 0.01667305f, -0.01514069f, -0.03980192f, -0.04132667f, 
    -0.03428159f, -0.02840729f, 0.01396436f, 0.00521687f, -0.02394938f, 0.01480506f, -0.02513917f, 0.01638517f, 
    0.03695715f, -0.03852044f, 0.02833854f, -0.04623709f, 0.00447330f, -0.01187847f, 0.04121397f, 0.00814701f, 
    -0.05239078f, -0.02826384f, 0.00952785f, -0.01079773f, -0.01689458f, 0.02208464f, 0.03839380f, -0.03245971f, 
    -0.02823959f, 0.00279623f, -0.00475254f, -0.04733248f, -0.01284046f, 0.00601361f, -0.03546863f, -0.03861922f, 
    -0.02309701f, 0.01588988f, 0.03898094f, 0.02728000f, -0.00464651f, -0.04584064f, -0.01431290f, -0.02956854f, 
    -0.01191651f, -0.01327991f, -0.05131176f, -0.02788785f, -0.01394622f, -0.00320333f, 0.02413876f, 0.03465093f, 
    0.02200908f, 0.02845362f, 0.01724811f, 0.04441350f, -0.02238382f, -0.02729280f, 0.00934579f, -0.05586588f, 
    -0.02852773f, 0.02697787f, 0.02658739f, -0.04203006f, 0.00827729f, 0.01065946f, -0.02760140f, 0.04195470f, 
    -0.04416477f, -0.03428378f, -0.05083985f, -0.05403788f, 0.00147668f, -0.02030188f, -0.03789185f, 0.03058492f, 
    0.00598809f, 0.03105057f, 0.02716240f, -0.02927069f, -0.03424189f, -0.05648211f, 0.00560784f, -0.04102983f, 
    -0.01909832f, -0.00450525f, 0.02255112f, -0.04321157f, -0.01269471f, -0.01772191f, 0.03184994f, -0.03915611f, 
    0.02794281f, 0.01676848f, -0.01224911f, -0.01016055f, -0.04157132f, -0.01696872f, 0.04081636f, -0.05415611f, 
    -0.03917232f, -0.04625883f, -0.04594571f, -0.00005176f, -0.05072700f, -0.04678411f, 0.00044589f, -0.04009214f, 
    0.01121961f, 0.02699524f, -0.04994604f, -0.02272641f, 0.00505441f, -0.00812247f, -0.01622425f, -0.03356074f, 
    -0.05412290f, 0.00846563f, -0.04829643f, -0.04474933f, 0.01345636f, -0.03528936f, -0.03510658f, -0.02668009f, 
    -0.05244386f, -0.04692893f, -0.00712137f, 0.02735510f, -0.02015000f, 0.02285351f, -0.04430307f, -0.02941702f, 
    -0.01152545f, -0.05002958f, 0.01682755f, -0.04359816f, 0.04494627f, 0.05199968f, -0.04656172f, 0.01697993f, 
    0.00401639f, 0.00910219f, -0.00661934f, 0.03635552f, 0.02944514f, -0.01003388f, -0.02751998f, 0.02929898f, 
    -0.01665396f, -0.02655287f, 0.02419363f, -0.03202543f, 0.00392672f, 0.04432610f, 0.02749687f, 0.03361194f, 
    -0.02469383f, -0.05426869f, 0.03506510f, 0.00737315f, 0.00373564f, -0.03594000f, 0.00827382f, -0.03082298f, 
    0.02780394f, -0.01549328f, 0.03301050f, -0.03515524f, -0.02746912f, 0.01508594f, -0.02026545f, 0.02740005f, 
    0.00327539f, 0.00950199f, -0.01190880f, 0.02405519f, -0.04493359f, 0.01896185f, 0.04265757f, 0.01932797f, 
    -0.03322720f, -0.00940967f, -0.02525484f, 0.02531662f, -0.02046677f, 0.01985708f, 0.02921644f, -0.00928796f, 
    0.01733140f, -0.03376461f, 0.02028297f, -0.02556143f, -0.02887603f, -0.04255978f, 0.03061817f, 0.00952864f, 
    -0.01178087f, 0.02671031f, -0.02874230f, -0.04462514f, -0.00388244f, 0.03906650f, -0.03349476f, -0.03862050f, 
    -0.01169100f, -0.01402350f, 0.01666036f, -0.01628494f, -0.02126507f, -0.01037697f, -0.05694245f, -0.03641970f, 
    -0.00690122f, 0.00721984f, 0.02377964f, -0.03951024f, -0.02372238f, 0.01345637f, -0.05364616f, -0.02849057f, 
    0.01660567f, 0.03410208f, -0.00073897f, 0.01032644f, 0.02903944f, 0.01390248f, 0.01316189f, 0.00555017f, 
    0.00133703f, 0.01840097f, -0.02937587f, 0.00508774f, 0.02525102f, 0.00812448f, 0.03438377f, -0.03346564f, 
    -0.03351935f, 0.04085950f, -0.01862814f, 0.04165367f, -0.02915773f, -0.00260699f, -0.03356190f, -0.05573422f, 
    -0.03708598f, 0.04700819f, 0.02836732f, 0.03407360f, -0.03985341f, -0.05302669f, -0.00017048f, 0.02980952f, 
    -0.03307228f, -0.03531403f, -0.03727645f, -0.02096586f, 0.01802775f, 0.00495603f, -0.03004532f, 0.01575058f, 
    -0.04603779f, -0.03240342f, 0.02821758f, -0.00098056f, -0.00083674f, -0.00043383f, -0.02947665f, -0.01570903f, 
    -0.03197673f, -0.02532607f, 0.02333613f, 0.02551419f, -0.00125321f, -0.02425861f, 0.00411375f, -0.04569946f, 
    -0.04232876f, -0.00842208f, 0.02989864f, 0.03232239f, -0.00712797f, 0.00945643f, -0.03665649f, 0.02624973f, 
    -0.00543460f, -0.01157939f, 0.01326445f, 0.00173129f, 0.03160284f, 0.01633040f, -0.01763538f, 0.00586772f, 
    -0.05045499f, 0.00406026f, 0.02708586f, -0.01176237f, 0.01193700f, -0.04073695f, -0.04632509f, -0.01494579f, 
    -0.05150963f, 0.03981125f, -0.01131016f, 0.04502399f, -0.03742281f, -0.02364601f, -0.05216481f, 0.02055412f, 
    -0.23183581f, 0.25154808f, 0.25837761f, -0.26533729f, -0.16416620f, -0.18168861f, -0.08992384f, -0.00465453f, 
    -0.04123188f, 0.01830837f, -0.01697785f, -0.00873300f, 0.33789423f, 0.04741354f, -0.00899836f, -0.15054847f, 
    0.11286328f, -0.00820442f, -0.02715965f, 0.10123126f, 0.02839637f, 0.07204701f, -0.02025638f, 0.24625309f, 
    -0.28999290f, 0.11015134f, 0.08118867f, 0.38090751f, -0.11429415f, -0.15267228f, -0.05547370f, -0.11759612f, 
    0.11622389f, -0.06402954f, 0.12225728f, 0.09429990f, -0.15338363f, 0.05509395f, 0.13584171f, -0.27108335f, 
    -0.07225094f, -0.16284350f, -0.10638987f, -0.13597035f, 0.03349251f, 0.06054577f, 0.10056993f, 0.03250749f, 
    0.07907554f, 0.09640631f, -0.01318662f, -0.05046785f, -0.00999277f, -0.02891281f, 0.06051758f, -0.14949426f, 
    0.06475551f, 0.06387525f, 0.06418002f, 0.04869597f, 0.41742936f, -0.07194627f, -0.10443066f, 0.00360642f, 
    0.11671033f, 0.16821098f, 0.15053996f, 0.17433511f, -0.11824227f, -0.12541652f, -0.13158569f, 0.01309497f, 
    -0.11452686f, 0.10683593f, -0.09724953f, -0.26446512f, 0.02303558f, -0.00491683f, 0.10575847f, 0.07558893f, 
    0.05822937f, 0.06129036f, 0.13046342f, 0.07840878f, 0.15753511f, -0.21526733f, -0.02223463f, -0.02650327f, 
    0.20261794f, 0.00041812f, 0.19469818f, 0.22104804f, 0.07864463f, 0.01462876f, 0.06744599f, -0.00226256f, 
    0.04778501f, -0.02142979f, -0.00007103f, -0.20391986f, 0.12141494f, -0.02474087f, 0.01795119f, -0.03328884f, 
    0.12556009f, 0.04377060f, 0.25223538f, 0.04391650f, -0.36830762f, -0.14106956f, 0.28319088f, -0.11664131f, 
    -0.06535583f, -0.03776043f, -0.01296675f, 0.01886524f, 0.07986796f, 0.07895487f, -0.12853719f, -0.00303644f, 
    0.22582863f, 0.12337256f, -0.06367458f, -0.03647850f, 0.06046557f, 0.03678602f, 0.00703330f, -0.00186641f, 
    0.04105994f, 0.28003934f, 0.09728006f, 0.32388002f, -0.03992511f, -0.11201107f, -0.01834786f, -0.09645373f, 
    0.05237380f, -0.03641455f, 0.03216106f, -0.00508328f, -0.00684825f, -0.02941700f, -0.01151381f, -0.08608007f, 
    -0.08138316f, -0.07478654f, 0.28121731f, -0.03476329f, 0.11875201f, -0.04184854f, -0.02506926f, 0.03479058f, 
    0.03358307f, 0.05694298f, -0.01534085f, 0.02901980f, 0.13594489f, -0.06570005f, 0.00232958f, 0.09975478f, 
    0.08317301f, 0.12864752f, 0.04739727f, 0.19521756f, -0.00282185f, -0.03201270f, -0.00809585f, -0.06056384f, 
    -0.31272420f, 0.07313336f, -0.26326400f, 0.29051644f, 0.04260331f, 0.05804297f, 0.01955069f, 0.06041125f, 
    -0.01423026f, -0.10646229f, -0.04583844f, 0.09004968f, -0.27311862f, 0.05351140f, -0.00611608f, -0.21753347f, 
    -0.06426718f, -0.12115426f, 0.03231820f, -0.10316562f, 0.03652341f, -0.03940550f, 0.01976517f, -0.07350422f, 
    -0.08265230f, -0.24901240f, 0.00452519f, 0.02206815f, -0.06901135f, -0.04555292f, -0.15252003f, 0.10710215f, 
    0.08977074f, 0.02876380f, 0.16567804f, 0.17800578f, -0.35974452f, -0.13059837f, 0.36094806f, 0.25893417f, 
    -0.02903807f, -0.00433486f, -0.00596138f, -0.01245988f, 0.10813054f, 0.05462098f, 0.20852329f, 0.03254560f, 
    -0.07263660f, -0.10115075f, 0.08578917f, -0.10867125f, 0.07845197f, -0.03171661f, -0.19318876f, 0.05452644f, 
    -0.06152945f, -0.08172524f, 0.00174419f, -0.07301784f, 0.30385622f, -0.27656201f, -0.09030860f, 0.27769724f, 
    -0.02929612f, 0.08349881f, -0.08590905f, 0.04422159f, 0.13934296f, 0.11398739f, 0.14964582f, 0.01823928f, 
    -0.00653008f, -0.25456196f, 0.01240229f, 0.29908440f, 0.08782095f, -0.04606411f, 0.12128603f, -0.14728206f, 
    0.23787624f, -0.05125237f, 0.06839713f, 0.12036180f, -0.12227227f, -0.04747243f, 0.18996845f, 0.05121272f, 
    0.13015532f, 0.02363629f, -0.10999100f, -0.06109806f, 0.14631890f, -0.12988816f, 0.07727215f, -0.18130754f, 
    -0.49532863f, 0.00709467f, 0.30899727f, 0.13948117f, -0.09612262f, -0.00758385f, 0.11693598f, -0.01373600f, 
    0.08123060f, -0.10700548f, 0.07364326f, 0.03704802f, 0.16074137f, 0.01306327f, -0.06351608f, 0.06044966f, 
    0.06443658f, 0.13623415f, 0.15437190f, -0.01761698f, 0.06722613f, -0.06433374f, -0.00073831f, -0.10271446f, 
    0.26175129f, 0.08988842f, 0.15470211f, -0.41300657f, 0.15261063f, 0.14348005f, 0.01755744f, 0.01049447f, 
    0.05628529f, 0.21283387f, 0.08053003f, 0.17293204f, 0.01668342f, -0.03711008f, -0.06776852f, 0.23138544f, 
    -0.01101201f, 0.24095707f, 0.00314842f, 0.03346905f, 0.14654310f, 0.03733959f, 0.19002092f, -0.02427173f, 
    -0.10586173f, 0.00081260f, 0.11330058f, 0.03391528f, -0.10171024f, -0.04876911f, -0.09038679f, -0.15855302f, 
    0.02051764f, 0.00532737f, 0.18389212f, 0.14525403f, -0.25105527f, 0.19934887f, -0.05195145f, -0.14089277f, 
    -0.10553503f, 0.02620384f, 0.13891132f, -0.08322617f, 0.13614380f, -0.04644660f, -0.05314107f, -0.02586930f, 
    -0.27807602f, -0.54742831f, 0.15497191f, 0.45552266f, 0.01063977f, 0.03195131f, -0.04423662f, -0.02422956f, 
    0.21017061f, -0.01762895f, 0.19462559f, 0.06666403f, 0.22049317f, 0.03939218f, -0.18691829f, -0.13873562f, 
    -0.03842354f, 0.07426655f, 0.08885638f, -0.06106790f, 0.08845695f, 0.02189091f, -0.02910661f, 0.00718697f, 
    -0.18672286f, -0.11408786f, -0.16933614f, 0.33283830f, 0.12310781f, -0.03945488f, -0.04622982f, 0.03189157f, 
    0.15379795f, 0.21104209f, -0.03259756f, 0.11692718f, 0.01884779f, -0.08019030f, -0.20687588f, 0.00099148f, 
    -0.00781806f, 0.02933157f, -0.02861077f, 0.02456989f, 0.01261736f, -0.05481390f, 0.09452859f, -0.03729190f, 
    -0.01387957f, -0.04155990f, 0.04825387f, 0.01869694f, 0.00614543f, 0.03495471f, -0.02482206f, 0.00410754f, 
    -0.00431958f, 0.03431523f, -0.02110326f, -0.05990218f, 0.03492527f, 0.02348161f, 0.02293216f, -0.03190675f, 
    -0.01379930f, -0.05697826f, -0.05498191f, -0.01398882f, -0.00308946f, 0.03245807f, -0.01380278f, -0.04963890f, 
    -0.03640662f, -0.00756224f, 0.02420940f, -0.00975106f, 0.00645889f, 0.04081611f, -0.04012700f, 0.02653383f, 
    0.03279484f, -0.01817217f, -0.05335794f, -0.04575032f, -0.00806736f, 0.02079807f, 0.01059053f, 0.00809865f, 
    -0.05121338f, -0.02541395f, 0.02764591f, 0.04136990f, 0.02809559f, 0.00462675f, 0.01392057f, 0.00854923f, 
    -0.04056122f, -0.00944140f, -0.04301020f, 0.04067204f, 0.00777932f, 0.04080929f, -0.00155459f, 0.01361958f, 
    -0.04744325f, 0.03178758f, 0.02105550f, -0.02518724f, -0.02811240f, 0.03994714f, -0.04894010f, -0.00757508f, 
    0.03555501f, -0.00628022f, -0.03565099f, 0.03049660f, -0.01427600f, -0.04183204f, -0.02935176f, -0.00211532f, 
    -0.04700201f, 0.01920128f, 0.00398662f, -0.02531917f, -0.00661855f, 0.03120861f, -0.01318368f, 0.00683906f, 
    -0.02231555f, 0.03627947f, -0.02155252f, 0.03442531f, -0.05535631f, -0.01234335f, 0.00715771f, 0.03074627f, 
    0.00127399f, -0.02583623f, 0.03114483f, 0.03907058f, -0.01923318f, -0.01948780f, -0.03931955f, -0.01889802f, 
    -0.00253211f, 0.00285085f, -0.01800815f, -0.04851563f, -0.02861939f, -0.04483883f, -0.03424329f, -0.05675786f, 
    0.02162178f, 0.02736548f, -0.04404387f, -0.00954256f, 0.02951183f, 0.03557734f, 0.00998833f, 0.00334734f, 
    0.02648048f, 0.03275760f, -0.00424983f, 0.01813278f, -0.02833904f, 0.03721032f, -0.01098932f, -0.01805808f, 
    0.02791634f, -0.01892181f, -0.04239038f, 0.02019469f, 0.01696189f, -0.00695380f, -0.02459808f, 0.04208547f, 
    0.00262114f, 0.00977226f, -0.03128112f, -0.00800591f, -0.05665592f, -0.02657885f, -0.01788426f, -0.02235112f, 
    0.01350686f, -0.03622632f, -0.04590761f, 0.01317157f, -0.00826093f, -0.03056947f, 0.04728505f, -0.03726665f, 
    0.01619692f, 0.02013301f, 0.04393294f, -0.03305260f, -0.04984329f, 0.04045998f, 0.04534404f, -0.05485623f, 
    0.04170823f, 0.03491755f, -0.01072314f, -0.02813478f, -0.02967466f, -0.02758552f, -0.03936867f, -0.00319731f, 
    -0.04938360f, 0.04101241f, -0.03944618f, -0.04694398f, 0.02855810f, 0.03259512f, -0.01660886f, -0.02413219f, 
    0.01213171f, 0.00923121f, -0.03923194f, -0.04484659f, -0.04630405f, 0.03271276f, -0.04896352f, -0.00666797f, 
    -0.04178167f, -0.02901882f, 0.03901520f, 0.02228244f, 0.03056275f, 0.02956668f, -0.02359904f, -0.02698096f, 
    0.05583682f, 0.05255930f, 0.00556058f, 0.01288212f, -0.02297446f, -0.02346145f, 0.01362074f, -0.05244964f, 
    0.01502419f, 0.03157551f, 0.01168084f, 0.01608856f, -0.02450156f, -0.02319631f, -0.05001269f, 0.04363953f, 
    -0.03477801f, -0.01353562f, -0.05149168f, -0.03093566f, -0.00693872f, 0.00065093f, -0.02884221f, -0.04889946f, 
    -0.01098538f, 0.03795559f, -0.02443883f, -0.03988278f, 0.01611040f, -0.02484043f, 0.03246785f, 0.00537263f, 
    -0.04810503f, -0.02622923f, 0.00284459f, 0.04934040f, -0.02708617f, 0.03806135f, 0.04017663f, 0.03821541f, 
    -0.00252386f, 0.01783328f, 0.03855264f, 0.02766425f, 0.00409469f, 0.02296183f, 0.04085665f, -0.05451719f, 
    -0.02744621f, 0.01083722f, -0.00220514f, -0.04334702f, 0.00952484f, -0.00968142f, -0.04380573f, -0.02564605f, 
    -0.01203989f, 0.03504465f, 0.02219473f, 0.03345641f, -0.00089122f, 0.01332767f, -0.04036710f, 0.02645672f, 
    0.03491634f, -0.02276294f, -0.00653425f, -0.03075854f, -0.03618438f, 0.02402360f, -0.01204244f, -0.00838553f, 
    -0.02964542f, -0.01575743f, 0.00924571f, 0.00159894f, 0.01743558f, 0.02418997f, -0.02447599f, 0.01986517f, 
    0.01965392f, -0.01307507f, -0.03706720f, -0.01096700f, 0.01248018f, -0.02944794f, -0.02174250f, -0.02199936f, 
    -0.02614391f, 0.02407798f, -0.04133190f, 0.03515542f, -0.01033444f, 0.01723148f, 0.02096338f, 0.00802318f, 
    0.02313740f, 0.01132166f, -0.01661548f, 0.04051493f, 0.00510116f, 0.02643398f, -0.04720380f, -0.04111151f, 
    -0.05300817f, 0.00259747f, 0.01648739f, -0.01657200f, 0.02320483f, 0.01710781f, -0.06121342f, -0.00235304f, 
    -0.02764655f, -0.05850468f, 0.00058998f, -0.04869531f, 0.02748589f, 0.01331138f, 0.02804132f, 0.00433445f, 
    -0.04369162f, 0.02714838f, 0.00038384f, -0.03203521f, 0.01079341f, 0.00788841f, 0.02636525f, -0.04558890f, 
    0.03191651f, -0.02246555f, 0.02894743f, 0.01525332f, 0.02827504f, 0.02766374f, 0.03589080f, -0.04308432f, 
    -0.00661324f, 0.03332520f, -0.00197374f, 0.04102521f, -0.03718587f, 0.01268183f, -0.03117719f, -0.02991272f, 
    0.01775274f, -0.05408452f, -0.05352180f, -0.00789756f, -0.04437849f, 0.03924204f, -0.05531389f, -0.05252836f, 
    -0.00774320f, 0.02094947f, 0.00250542f, 0.01620200f, -0.00680911f, -0.04946714f, -0.01313967f, -0.04757439f, 
    -0.00384339f, 0.01586380f, -0.04954334f, 0.02960886f, 0.01662043f, -0.01540034f, -0.01363501f, -0.03406959f, 
    0.01423295f, 0.01642855f, 0.03965807f, 0.02637016f, -0.03049157f, -0.02332430f, -0.03250509f, 0.00065774f, 
    -0.03009649f, -0.01684197f, 0.00219021f, 0.02764470f, -0.00727763f, 0.03814457f, -0.01127466f, -0.05060905f, 
    0.00459434f, 0.02386756f, 0.03240582f, -0.03074135f, -0.00186685f, -0.04178628f, 0.02093012f, -0.05184444f, 
    0.02137573f, -0.05033575f, 0.00672888f, -0.02099633f, -0.02161153f, -0.04472636f, -0.03332388f, -0.03682838f, 
    -0.38595119f, -0.32727233f, -0.14468187f, -0.08840756f, -0.04858220f, 0.09236669f, 0.07136635f, 0.09986017f, 
    -0.04489072f, 0.02850999f, 0.00126835f, -0.00099133f, 0.15953843f, 0.04895279f, 0.00719302f, 0.30255345f, 
    -0.02895164f, -0.01515037f, 0.15833101f, 0.03508219f, -0.00866667f, 0.04335720f, 0.05671383f, 0.17971845f, 
    -0.11037043f, -0.12157205f, -0.00973336f, -0.20420246f, -0.06348819f, 0.03687948f, -0.10491941f, 0.14142390f, 
    -0.06612977f, 0.13595304f, 0.06897517f, 0.12201627f, -0.11658126f, -0.33267626f, -0.15279602f, 0.02118734f, 
    -0.05657361f, -0.06168064f, -0.02555021f, 0.05628175f, -0.05577016f, 0.08961456f, -0.08349923f, 0.01360657f, 
    -0.23548181f, -0.17770119f, -0.06991360f, -0.17997751f, -0.09587378f, 0.03901586f, -0.01730983f, -0.07363318f, 
    0.00335254f, -0.03067730f, -0.03421051f, 0.15782420f, 0.16907258f, 0.24098818f, 0.06553251f, -0.13756570f, 
    -0.17798135f, -0.10391979f, -0.11633822f, -0.06935782f, -0.03437531f, -0.07148985f, -0.01290568f, -0.05933719f, 
    0.03901371f, -0.01717772f, 0.20474879f, 0.10185744f, -0.04308084f, -0.01209207f, 0.07810964f, 0.06945284f, 
    -0.08687137f, 0.12275528f, 0.09083138f, 0.07080384f, -0.10023419f, 0.39011705f, -0.23368733f, 0.16780236f, 
    -0.12745163f, 0.00479979f, 0.22768618f, -0.04968763f, 0.11428374f, 0.05798717f, 0.10743514f, -0.03048875f, 
    -0.20301189f, -0.09035978f, -0.17136577f, -0.01164847f, -0.04208908f, 0.05023827f, 0.07970177f, 0.04249577f, 
    0.13727905f, 0.17333606f, 0.02068339f, 0.10910968f, 0.06979070f, 0.00702050f, -0.11118418f, 0.16280998f, 
    0.03899750f, -0.08747816f, 0.18729293f, -0.05199125f, -0.05153998f, -0.04538909f, 0.04501343f, 0.00311236f, 
    0.20402345f, 0.03370334f, 0.31468403f, -0.00990079f, 0.00705559f, -0.09500298f, 0.15552285f, 0.02223444f, 
    0.13929614f, -0.02063164f, 0.08234659f, 0.15326208f, 0.08811502f, 0.17614096f, -0.01787418f, -0.18663219f, 
    -0.17285290f, -0.20788209f, -0.11868493f, -0.09064045f, -0.07827133f, 0.09970418f, 0.03356227f, 0.05131799f, 
    -0.04386852f, -0.02462705f, -0.26723853f, -0.01639304f, -0.10722237f, -0.03923691f, 0.13103607f, -0.01987144f, 
    -0.05559050f, -0.08990787f, -0.11136367f, -0.06434043f, 0.13319214f, 0.19331165f, -0.01167653f, 0.03038282f, 
    -0.12275517f, 0.08644197f, -0.00142972f, 0.01031566f, -0.00489048f, -0.03404772f, 0.11683697f, 0.04550565f, 
    0.40867880f, 0.03794082f, -0.08913521f, -0.12143579f, 0.11630610f, 0.07244742f, 0.11973968f, -0.09412953f, 
    0.09322846f, 0.01495168f, -0.02179727f, 0.01647055f, -0.10337932f, -0.23639685f, -0.06777512f, -0.05823649f, 
    -0.07477955f, -0.07478039f, -0.01915105f, 0.02253065f, -0.10219457f, -0.02900150f, -0.07022256f, -0.06776026f, 
    0.21440861f, 0.33439758f, 0.01448923f, 0.27940860f, 0.07609878f, 0.00125842f, 0.05209960f, 0.08826412f, 
    -0.01145695f, 0.17121299f, 0.08043098f, 0.12414277f, 0.23658094f, 0.04924995f, -0.14670180f, 0.00159081f, 
    0.04700018f, -0.08066049f, -0.02366824f, 0.04911680f, -0.02618695f, 0.02124341f, 0.28290865f, 0.10481839f, 
    -0.23608945f, 0.10212745f, -0.00740796f, 0.10571868f, -0.12856540f, -0.13275591f, -0.00126340f, 0.28665975f, 
    -0.07606637f, -0.01101741f, 0.09373543f, -0.01736615f, -0.03401871f, 0.22083800f, -0.03830359f, 0.14499275f, 
    -0.07979041f, 0.05003249f, -0.00006883f, -0.07560585f, -0.08712360f, 0.28048214f, 0.03042232f, 0.15252981f, 
    0.01326438f, 0.19375966f, -0.09781563f, -0.06591533f, 0.22956941f, 0.05585003f, 0.16367868f, 0.10764841f, 
    0.06826892f, 0.00696663f, 0.11452433f, 0.07010810f, -0.14472610f, -0.01950301f, 0.05557764f, 0.09297966f, 
    -0.10255380f, 0.01964238f, 0.02294436f, -0.00290672f, -0.04253867f, 0.04932345f, 0.17101346f, 0.16543689f, 
    0.13688555f, 0.14128345f, -0.07985344f, -0.09699848f, -0.01614751f, 0.04786149f, 0.18708232f, 0.04211895f, 
    -0.08278624f, 0.09391394f, 0.00882415f, -0.07237141f, 0.18314782f, 0.19716354f, 0.04966595f, -0.05232982f, 
    -0.25950518f, -0.19420551f, -0.07359345f, -0.09691935f, -0.06692468f, -0.06079634f, -0.07616777f, -0.08079237f, 
    0.15708971f, 0.29206613f, 0.10774235f, 0.35238817f, 0.03698306f, 0.06148782f, 0.14313477f, 0.07197339f, 
    -0.09629916f, 0.10930663f, 0.01916493f, 0.14188986f, 0.01182065f, 0.23719384f, -0.17621046f, 0.04872473f, 
    -0.06181772f, -0.07590653f, 0.00141131f, -0.06005279f, 0.07005913f, 0.14776836f, -0.01827039f, -0.02824217f, 
    -0.20624258f, 0.03380370f, -0.07046452f, -0.26268938f, -0.05286297f, -0.09044088f, 0.01369969f, -0.00764666f, 
    0.14678343f, 0.12244562f, -0.08913749f, 0.11286663f, -0.20692702f, -0.31906602f, 0.10437588f, 0.11931273f, 
    0.05022947f, 0.01357444f, -0.05471235f, -0.11681116f, -0.16953126f, 0.06706493f, 0.09854582f, 0.04360245f, 
    -0.12130823f, 0.28789347f, -0.32526144f, 0.11723939f, 0.09542090f, 0.08227552f, 0.01210072f, 0.23840229f, 
    -0.01741094f, 0.03430089f, 0.15960422f, 0.12553313f, -0.19953506f, -0.28746510f, -0.07130221f, 0.17595826f, 
    -0.12017681f, 0.09759209f, -0.05166510f, 0.10040508f, -0.04461347f, -0.02758934f, -0.06801747f, 0.15620942f, 
    0.22567643f, 0.05529818f, 0.02925015f, -0.25853124f, 0.02520129f, 0.05767837f, 0.03329402f, -0.13576674f, 
    0.13272850f, 0.23057720f, 0.24906455f, -0.14217404f, 0.17900358f, 0.16029514f, 0.01231113f, -0.19560193f, 
    -0.24834949f, -0.10645851f, -0.12975107f, -0.04438337f, 0.00316566f, 0.01642223f, -0.23468301f, -0.18938982f, 
    0.04847884f, 0.01015656f, -0.04375595f, 0.01535094f, 0.01259884f, -0.01056339f, 0.00052648f, -0.01084420f, 
    0.00266937f, 0.04137088f, -0.00861049f, -0.03112979f, -0.03554834f, -0.03403534f, -0.02454536f, -0.04833382f, 
    -0.04130279f, -0.05697363f, -0.03835935f, 0.01227149f, 0.01186148f, 0.04033608f, -0.03510439f, -0.01798606f, 
    -0.00618694f, -0.04142634f, 0.00675930f, 0.03381075f, 0.02765579f, 0.04319304f, -0.00628466f, -0.03141784f, 
    -0.05434440f, -0.04786689f, 0.01104150f, 0.01423789f, 0.00703361f, 0.00373490f, 0.01631684f, 0.05412683f, 
    -0.00898013f, -0.01167311f, -0.02034174f, 0.01076238f, -0.04724843f, -0.01594024f, 0.00940659f, 0.04725411f, 
    0.04569203f, 0.02267702f, -0.05487952f, -0.05076936f, 0.02641988f, 0.04912539f, -0.00838328f, 0.02186298f, 
    -0.03703844f, 0.02582977f, -0.04851958f, -0.02467098f, 0.00410669f, -0.05721056f, -0.03631143f, -0.04963900f, 
    0.04319861f, 0.01435325f, 0.02686963f, -0.05351258f, 0.02637143f, -0.01145702f, -0.00690294f, 0.00542886f, 
    -0.04432013f, 0.03962174f, -0.01612624f, 0.03253761f, 0.03337891f, 0.01680451f, 0.02466785f, 0.03125139f, 
    0.02365131f, 0.00362130f, -0.00267382f, -0.00731636f, -0.05912615f, 0.03726689f, 0.02287472f, 0.00292529f, 
    -0.02183090f, 0.03787269f, 0.02512283f, 0.01213023f, 0.01848492f, -0.02294172f, -0.01990943f, -0.02670913f, 
    0.00435128f, 0.00132093f, -0.00623417f, 0.03902256f, -0.03810840f, -0.02845497f, 0.00420742f, -0.03278008f, 
    0.02798038f, 0.03546742f, 0.00799104f, 0.01058680f, 0.01313027f, 0.02820817f, -0.05064248f, 0.05539860f, 
    -0.00743878f, -0.00587558f, -0.02896372f, -0.03555815f, 0.01077968f, -0.00319767f, 0.02239594f, 0.04171486f, 
    0.02604312f, -0.05063161f, -0.05544705f, -0.05026558f, 0.00441533f, -0.02635070f, -0.03017680f, 0.03124087f, 
    0.03557752f, -0.00442022f, -0.05629940f, -0.00131143f, 0.02360040f, -0.01130362f, 0.00175500f, -0.02059687f, 
    0.00941967f, -0.00012931f, -0.03479806f, -0.00264236f, -0.05080412f, 0.04392435f, 0.03995395f, 0.02031261f, 
    -0.04459713f, -0.03563440f, 0.02729627f, 0.02204696f, 0.01015732f, -0.00148002f, 0.03245790f, -0.04615360f, 
    0.04268127f, -0.03365631f, 0.03276021f, -0.01448982f, -0.03474649f, -0.01228665f, -0.05734640f, 0.04194385f, 
    -0.04190434f, -0.02437719f, -0.03363244f, 0.03934870f, -0.01399824f, -0.04598422f, -0.00183361f, 0.00711451f, 
    -0.05197266f, -0.01935007f, 0.01800734f, 0.01707058f, -0.03453989f, -0.02822192f, -0.00032339f, 0.01973458f, 
    -0.00150874f, 0.03135314f, -0.03876843f, -0.04804692f, -0.05326265f, -0.03682121f, -0.00979711f, 0.02098673f, 
    -0.04051134f, -0.02957392f, -0.02820901f, 0.03792147f, 0.04509531f, -0.00032253f, 0.00845650f, -0.00832860f, 
    -0.03394135f, -0.03383388f, 0.01388895f, 0.01205666f, 0.01617022f, 0.04622420f, -0.05867075f, 0.00681564f, 
    0.03146547f, 0.01139208f, 0.02662290f, -0.02765644f, -0.04139888f, -0.00794561f, -0.02140314f, -0.05243029f, 
    0.04988586f, -0.01463719f, -0.00123732f, -0.00741091f, 0.00145060f, 0.04678188f, -0.00562979f, 0.03238466f, 
    0.01856743f, -0.00459290f, 0.01215890f, -0.03001960f, 0.01262126f, 0.03159854f, -0.02159809f, -0.02073444f, 
    0.03107254f, 0.02980104f, -0.03992473f, 0.01186074f, -0.00698023f, 0.00323825f, -0.04871803f, 0.03752517f, 
    0.03105952f, 0.01211338f, 0.02113410f, 0.01614186f, -0.03143593f, -0.01313171f, -0.02810520f, 0.02039621f, 
    -0.04091495f, 0.01636680f, -0.03695183f, 0.02931447f, 0.04383460f, -0.04688776f, -0.03495523f, 0.02579443f, 
    -0.05190410f, -0.02998721f, 0.02219638f, 0.01470415f, -0.04309203f, -0.00841906f, -0.03750677f, -0.04293679f, 
    0.03198028f, -0.00921153f, -0.03964522f, -0.03874424f, -0.05684102f, -0.03069701f, -0.05447688f, 0.02180969f, 
    0.02079810f, 0.03909056f, -0.01739142f, -0.00267938f, 0.03732850f, 0.04704613f, -0.02539675f, -0.03005138f, 
    -0.03115998f, 0.02559620f, 0.03995138f, 0.03856363f, -0.01230746f, 0.00820062f, 0.03351738f, 0.02237756f, 
    -0.04145011f, -0.02083161f, -0.05590508f, -0.05699524f, -0.02096964f, -0.00374580f, -0.02921865f, -0.00676140f, 
    -0.00305481f, -0.05032410f, -0.00282176f, -0.04230766f, -0.04359666f, -0.04724511f, -0.05069735f, -0.01845494f, 
    -0.04855338f, -0.05055116f, 0.00658102f, 0.02660637f, -0.01755944f, 0.02018278f, 0.01880836f, 0.03922315f, 
    0.01641783f, 0.02930549f, -0.03062581f, -0.03832019f, -0.04215225f, 0.01259054f, -0.03256539f, -0.04572814f, 
    0.01595727f, 0.00957854f, -0.02515163f, -0.00732690f, -0.03502498f, -0.01614773f, -0.05599107f, 0.04261130f, 
    -0.03257013f, -0.02811958f, -0.02451148f, 0.03121316f, 0.01008503f, -0.01826246f, 0.03279021f, -0.05380811f, 
    -0.05307587f, -0.02479080f, -0.01804177f, 0.02088961f, -0.00586700f, -0.03968782f, -0.01246391f, 0.02379102f, 
    0.01757290f, 0.02097647f, -0.05873561f, -0.04074078f, 0.00001973f, -0.02688332f, 0.02878426f, 0.02953301f, 
    0.01041621f, -0.04638021f, 0.00193268f, -0.00267461f, 0.04632500f, -0.03772607f, 0.00008516f, -0.05332217f, 
    -0.03555993f, 0.04097469f, -0.03007297f, -0.00159331f, -0.01118251f, -0.02265029f, 0.03662678f, 0.03173210f, 
    0.03711057f, -0.03188555f, 0.01163130f, -0.04580653f, -0.03496610f, 0.01927933f, -0.02960332f, -0.05137288f, 
    -0.01132258f, 0.01259008f, 0.02812961f, 0.00164075f, -0.03906661f, 0.03972746f, 0.00804806f, 0.03080840f, 
    0.02963078f, -0.05418391f, -0.00802911f, -0.03813539f, -0.02592399f, 0.03108093f, 0.03164269f, 0.01342623f, 
    -0.04237730f, -0.04440488f, -0.01447943f, 0.04079919f, 0.04057256f, -0.04156717f, 0.00790591f, 0.00590438f, 
    0.04737850f, -0.03227580f, -0.00940781f, -0.02404788f, -0.00216912f, 0.01387885f, -0.03144006f, -0.01994433f, 
    -0.03102098f, -0.04785722f, 0.00371733f, 0.00335934f, 0.00739803f, -0.03922524f, 0.01177112f, 0.00200311f, 
    -0.01329037f, -0.00733336f, -0.05525617f, 0.00646598f, -0.02390141f, -0.00366512f, 0.03133043f, -0.01863699f, 
    -0.03933983f, 0.04313964f, -0.01062843f, 0.00684745f, -0.01458853f, 0.01508612f, -0.04764510f, -0.03984285f, 
    -0.00232147f, 0.00694625f, 0.01055488f, -0.01193621f, -0.02351053f, 0.04150111f, 0.00050647f, -0.03527156f, 
    -0.03550741f, -0.01076153f, -0.05638444f, -0.04693621f, -0.04853271f, 0.02714267f, -0.05395576f, -0.03392650f, 
    -0.01082418f, 0.02853959f, 0.03848385f, 0.00319557f, 0.00277011f, -0.04525891f, 0.00361388f, -0.03173767f, 
    -0.02876395f, -0.01483057f, 0.00107653f, -0.00968539f, -0.01212382f, -0.01691998f, 0.01216579f, 0.01753277f, 
    -0.00757365f, -0.00253427f, 0.00919277f, -0.03714981f, -0.05441195f, 0.01433189f, 0.03655051f, 0.03309993f, 
    0.00435345f, 0.04723789f, -0.05078863f, 0.01205012f, -0.02618104f, 0.00523425f, 0.04309944f, -0.00113451f, 
    -0.02228809f, 0.04081332f, -0.05430047f, -0.01493363f, 0.01918594f, 0.01877715f, -0.03110402f, -0.04934266f, 
    0.00295949f, -0.02611897f, -0.00621312f, -0.02739060f, 0.00739480f, -0.03253564f, -0.02110241f, 0.04781283f, 
    -0.00870792f, -0.04474409f, -0.03592599f, 0.02388933f, -0.05565403f, 0.01316832f, -0.03485059f, -0.03360344f, 
    -0.04459197f, -0.01296050f, -0.01828022f, -0.00089556f, -0.04338092f, 0.02058703f, -0.05239243f, 0.05313573f, 
    0.03346162f, -0.04222035f, -0.00632176f, 0.00137376f, -0.05090580f, -0.04741534f, -0.00841790f, 0.03034395f, 
    0.00213680f, 0.04069100f, 0.02572503f, -0.05184198f, -0.01061833f, 0.00820735f, 0.00212672f, -0.04789833f, 
    0.03855441f, 0.00453112f, 0.01476925f, -0.04561270f, 0.03381236f, -0.01863172f, 0.05080932f, 0.00749915f, 
    -0.02279562f, -0.02324452f, -0.05347131f, 0.02720765f, -0.02246816f, -0.02645699f, 0.03623804f, 0.03438923f, 
    -0.01437921f, -0.02540368f, -0.04106087f, -0.04932085f, -0.02171746f, -0.02219469f, -0.02151675f, 0.03455426f, 
    -0.00546753f, -0.04693637f, 0.01544877f, 0.04067301f, -0.02936233f, 0.03498650f, -0.00931448f, 0.00260642f, 
    0.02901921f, -0.01417503f, -0.01761558f, 0.02587026f, -0.04548998f, -0.04171482f, -0.03916896f, 0.02764931f, 
    -0.04876383f, 0.03399044f, 0.01216502f, 0.01739428f, -0.00621136f, 0.00694690f, 0.01366965f, -0.00728276f, 
    -0.05091467f, 0.03256574f, -0.04875418f, 0.02618550f, -0.03480652f, 0.03747068f, -0.03403242f, -0.01297207f, 
    0.03182071f, 0.01546683f, -0.02786600f, 0.03143403f, -0.01117944f, -0.00882298f, -0.01873782f, 0.00740305f, 
    0.02461836f, 0.03928244f, -0.00357374f, -0.02813157f, 0.01069492f, -0.00618495f, 0.03288799f, 0.02112748f, 
    0.01833816f, 0.01541899f, -0.00153627f, -0.00466780f, 0.01612401f, 0.03349255f, -0.05260577f, -0.04124236f, 
    -0.02449705f, 0.03928725f, -0.04173251f, -0.04205064f, 0.00055197f, -0.04605626f, 0.00817818f, -0.03675033f, 
    -0.02768183f, -0.03968155f, 0.01121880f, 0.04032819f, -0.04539349f, -0.01087491f, 0.03774033f, 0.00079119f, 
    0.03752964f, -0.04488900f, -0.05693760f, -0.00020507f, 0.01701736f, -0.05534109f, -0.01320756f, 0.02740248f, 
    -0.00536612f, 0.03459651f, -0.04607395f, -0.02822983f, 0.00338746f, -0.01317602f, 0.02479364f, -0.04345877f, 
    0.04240638f, 0.02470509f, -0.04329481f, -0.01595331f, -0.00142731f, -0.01185001f, 0.03959952f, -0.01962706f, 
    -0.04461460f, 0.02499052f, -0.05325241f, -0.02464721f, -0.04477410f, -0.05496843f, 0.00449324f, 0.03566228f, 
    -0.00599396f, 0.03756738f, -0.02974051f, 0.04090317f, 0.00084815f, 0.03060757f, 0.00601061f, -0.00738692f, 
    -0.05089724f, 0.01206341f, 0.02545088f, -0.01607465f, -0.04243802f, 0.01308234f, -0.01529006f, -0.03991831f, 
    -0.04777128f, -0.03320122f, 0.03787500f, -0.00977218f, 0.03336715f, -0.00152178f, -0.02491014f, -0.04633340f, 
    0.02919099f, 0.00803176f, -0.03001989f, 0.03229291f, -0.02299296f, 0.00197746f, -0.05021349f, 0.04008909f, 
    -0.04532408f, -0.04277302f, 0.03553006f, 0.02915251f, 0.03781912f, -0.03153669f, -0.05040972f, -0.05007583f, 
    -0.01026076f, -0.03952198f, 0.04552928f, 0.01790716f, 0.00238380f, -0.04517303f, -0.03081753f, 0.02128189f, 
    0.03774603f, -0.01537722f, 0.02645826f, -0.02328577f, -0.05446269f, -0.01640587f, -0.00823087f, -0.03790490f, 
    0.01713987f, 0.01515336f, 0.01302399f, -0.04757478f, -0.04551778f, 0.03828998f, 0.01785587f, -0.04208606f, 
    -0.05799511f, -0.04497941f, -0.01056851f, 0.00406741f, 0.00967406f, 0.04219975f, -0.04549726f, -0.04129442f, 
    0.00681195f, -0.00585849f, 0.03644936f, -0.02084578f, 0.02402722f, 0.01153585f, -0.00782757f, 0.04100076f, 
    -0.00706832f, 0.02768139f, -0.03778528f, -0.00495847f, 0.03636464f, -0.03303546f, -0.04709041f, -0.05455258f, 
    -0.02589005f, -0.01790325f, -0.04951326f, -0.04434199f, -0.02782731f, -0.04143802f, -0.02529715f, 0.01606795f, 
    0.02265549f, 0.05221935f, 0.04293014f, -0.01786247f, -0.01391750f, -0.04918679f, -0.04623573f, -0.00998841f, 
    0.04417535f, -0.03657318f, -0.05538347f, -0.02787674f, -0.02443171f, -0.00781076f, -0.00128696f, 0.05647692f, 
    0.04511772f, -0.03996823f, -0.02977755f, -0.01540279f, 0.00562819f, 0.04047195f, -0.01118198f, 0.03844153f, 
    -0.06229461f, -0.12718810f, 0.11480017f, 0.28901836f, -0.00559627f, -0.05887722f, 0.09300803f, -0.08389392f, 
    -0.04502586f, 0.08594827f, -0.01593514f, 0.00720200f, -0.24598172f, 0.09277506f, 0.00394620f, 0.39387637f, 
    0.07812908f, -0.14745216f, 0.05799939f, -0.07162262f, -0.09970298f, 0.03614724f, 0.03745390f, 0.15530758f, 
    0.10258518f, -0.05327859f, 0.11068022f, 0.20415632f, 0.00835115f, 0.01134481f, 0.05428857f, -0.08842453f, 
    -0.00176587f, 0.00640977f, -0.12260002f, 0.18265897f, -0.02476896f, -0.14832076f, 0.06836044f, 0.08107058f, 
    -0.04117819f, -0.08805982f, 0.02725011f, 0.06207382f, -0.00707386f, -0.01136974f, 0.04862585f, -0.02465593f, 
    0.02384760f, 0.04443807f, 0.25775546f, 0.22483031f, 0.01465208f, 0.08220784f, 0.11504398f, -0.15667298f, 
    0.01001874f, 0.04638417f, -0.04005038f, 0.00521344f, 0.33180377f, 0.16933352f, 0.36168233f, 0.08919835f, 
    -0.15832463f, -0.06812196f, 0.03356623f, 0.10553876f, 0.06858116f, -0.07054565f, 0.00686254f, -0.05363578f, 
    0.22088768f, -0.02916916f, -0.05201061f, 0.06318706f, -0.06348588f, -0.16823870f, 0.16454676f, 0.06883050f, 
    0.03898988f, 0.10087557f, 0.26745549f, 0.22596587f, 0.10453662f, 0.06513698f, -0.03173028f, -0.05967367f, 
    -0.25306508f, -0.00017590f, -0.01053775f, 0.17455579f, 0.01242163f, 0.04933097f, 0.05728193f, -0.06934900f, 
    -0.08601251f, -0.07503311f, 0.03537094f, 0.01820974f, -0.08436519f, -0.10315704f, 0.04881385f, -0.02566146f, 
    -0.08035221f, 0.13570838f, 0.16209762f, 0.07601745f, -0.08909173f, 0.20565942f, -0.03726047f, 0.28514883f, 
    0.06751722f, 0.09765321f, 0.04526641f, -0.14506972f, -0.06558286f, 0.06267986f, -0.01358270f, 0.04186545f, 
    -0.16782446f, 0.15994503f, 0.09508450f, 0.18044811f, -0.05035307f, -0.05247826f, -0.01497803f, -0.06627378f, 
    -0.01824854f, 0.17584035f, 0.08279070f, 0.11930428f, 0.02120631f, -0.00006591f, 0.05222894f, -0.09593964f, 
    0.05312757f, -0.03310513f, 0.02007678f, 0.03461217f, 0.03562713f, -0.06132050f, -0.01352259f, -0.15038325f, 
    0.06910889f, -0.09700001f, 0.23813790f, 0.03922966f, -0.04810128f, 0.00854845f, -0.14796124f, 0.00434486f, 
    0.04560059f, 0.00015675f, 0.00906492f, -0.06331437f, 0.07991691f, 0.10042654f, -0.06641857f, -0.00673438f, 
    -0.05101505f, 0.04086909f, -0.09274508f, -0.03448904f, 0.09284637f, -0.05185971f, -0.09511714f, -0.15299080f, 
    0.30110201f, -0.06567493f, -0.05501676f, -0.43146467f, 0.02169310f, -0.15411784f, -0.02946766f, -0.04910411f, 
    -0.03828673f, -0.04551338f, -0.13760708f, -0.23984961f, 0.02516207f, -0.11535008f, -0.06751639f, 0.26020461f, 
    -0.09982599f, -0.13029334f, -0.01074225f, -0.10546204f, 0.03177167f, 0.03874412f, -0.05087299f, -0.02606909f, 
    -0.75104904f, 0.23120297f, -0.23669828f, 0.01215590f, 0.13455810f, 0.03678920f, 0.03208258f, 0.06837679f, 
    -0.12470369f, -0.02562246f, 0.03900789f, 0.18861802f, -0.20011765f, 0.04680973f, -0.05583389f, -0.13812020f, 
    -0.00916711f, 0.02308666f, -0.00885579f, -0.06776613f, -0.02396348f, 0.18986320f, 0.10986834f, 0.16178721f, 
    -0.30392495f, -0.07092790f, -0.07919293f, 0.08196626f, 0.13132089f, 0.02459033f, -0.12091197f, -0.07857827f, 
    0.10475421f, 0.00061535f, -0.06977682f, 0.06618643f, -0.11195102f, -0.13874955f, -0.34907559f, 0.07664295f, 
    -0.00776550f, 0.03080008f, 0.03335880f, 0.04607982f, -0.17164902f, 0.08759606f, 0.11555337f, -0.08227404f, 
    0.16996393f, -0.00066960f, -0.04474674f, 0.11418261f, -0.09860420f, -0.01274327f, -0.13640957f, -0.19196364f, 
    0.02936836f, 0.10270466f, -0.06084961f, 0.07940625f, 0.11866795f, 0.03947407f, -0.12090352f, 0.00619960f, 
    0.06299701f, -0.01761488f, -0.12781040f, -0.01610054f, -0.01628890f, -0.31026357f, -0.01768902f, -0.09729406f, 
    -0.01353815f, -0.23067284f, -0.06336260f, 0.11813522f, 0.11327981f, 0.02061504f, 0.05171281f, -0.10759379f, 
    0.04421113f, 0.04396331f, 0.16065088f, 0.09764516f, 0.03356555f, 0.06014417f, 0.02908263f, -0.05137255f, 
    -0.07374164f, -0.04461986f, -0.07443183f, -0.03899688f, 0.08874469f, -0.03651939f, -0.13934004f, -0.12140129f, 
    -0.38343090f, -0.00071303f, -0.01894280f, 0.40888771f, 0.05963295f, -0.06447430f, -0.06646393f, -0.03079751f, 
    0.08864330f, -0.14631286f, 0.20314988f, 0.14922795f, 0.05648539f, 0.24132656f, -0.19236210f, -0.18466491f, 
    0.00412667f, 0.01858844f, 0.03680344f, -0.03492716f, -0.04208990f, -0.10291249f, 0.01025690f, -0.11370725f, 
    -0.20648189f, -0.10130206f, 0.00173547f, -0.01473037f, 0.10783152f, 0.07109395f, 0.05903898f, 0.06831137f, 
    -0.01674699f, 0.02578245f, 0.07061935f, 0.05900783f, 0.05247537f, 0.02439147f, 0.16379087f, 0.21028577f, 
    0.17134187f, -0.11567266f, -0.07012542f, -0.20646133f, -0.02414160f, 0.00201773f, 0.01109179f, -0.09167258f, 
    -0.30648491f, 0.16759014f, -0.40919986f, -0.13349728f, 0.20084393f, 0.10122945f, 0.04201831f, -0.11550149f, 
    -0.08746797f, 0.01668091f, 0.00754934f, -0.04272031f, -0.10618606f, 0.13730475f, 0.17912361f, 0.36629161f, 
    0.07217946f, 0.00004493f, 0.02620974f, 0.08673831f, 0.02450235f, -0.00263866f, -0.00802957f, -0.00159023f, 
    0.10123596f, -0.05548355f, -0.22950071f, -0.05117556f, 0.10199943f, -0.14182189f, -0.07719740f, -0.10383673f, 
    0.02763201f, -0.06419651f, 0.03601930f, -0.15854172f, 0.10997004f, 0.03154539f, -0.01425920f, -0.13824588f, 
    -0.09390750f, -0.07431098f, 0.00978583f, 0.05987521f, 0.03634124f, -0.03034514f, -0.08575509f, -0.02555066f, 
    0.05758581f, -0.20968422f, 0.05735780f, 0.30566615f, 0.05911963f, -0.08767302f, -0.01660084f, 0.03628868f, 
    -0.03841368f, -0.10551972f, -0.06473357f, 0.00979223f, -0.13996704f, 0.24879584f, 0.01174107f, 0.13882053f, 
    -0.02227750f, -0.03007656f, 0.03080911f, 0.08118841f, -0.02673179f, 0.14852372f, 0.02003668f, -0.09326348f, 
    0.24291129f, 0.09656820f, 0.05134522f, 0.09688387f, 0.02594252f, -0.00350474f, 0.00420459f, 0.17186174f, 
    0.02006825f, -0.01447050f, -0.06315205f, -0.08726820f, -0.05476968f, -0.03442679f, 0.05976155f, 0.13495867f, 
    0.05623567f, 0.11851785f, 0.20745721f, 0.10723778f, 0.05810151f, -0.06852419f, -0.03125717f, -0.03151768f, 
    0.04973415f, 0.01423746f, 0.16900466f, 0.35916242f, 0.11506865f, 0.12898515f, 0.15474257f, -0.03542674f, 
    -0.07001726f, -0.10933205f, -0.12086176f, -0.19688393f, -0.52951449f, -0.08493229f, 0.00467459f, 0.00304828f, 
    -0.18644798f, -0.00820262f, -0.08785887f, 0.13367102f, 0.20226929f, -0.08411307f, -0.00269544f, 0.02935955f, 
    0.15349565f, 0.07016192f, -0.06535882f, 0.13177322f, -0.09769219f, -0.05908587f, 0.10411236f, -0.03903181f, 
    0.15456812f, -0.05088121f, -0.08781680f, -0.16844842f, -0.13067843f, 0.04616781f, 0.08793925f, 0.14372960f, 
    0.14442545f, 0.14248030f, -0.17961825f, 0.09463166f, -0.10999709f, 0.08928712f, 0.00534030f, 0.11348642f, 
    -0.09520064f, -0.08568341f, 0.08430975f, 0.20364684f, 0.00918209f, 0.05832182f, 0.10085932f, 0.01975051f, 
    -0.03437568f, -0.00272024f, 0.07623280f, -0.24225748f, -0.34354386f, 0.12901619f, 0.16786729f, 0.00512289f, 
    -0.01504714f, 0.01882754f, -0.00171157f, 0.15144032f, -0.11064784f, 0.10858034f, -0.00988703f, -0.06289730f, 
    -0.14711195f, 0.24294382f, -0.12287980f, 0.06390329f, -0.05146654f, -0.03750125f, -0.09635417f, 0.08935134f, 
    -0.01927003f, 0.04498111f, -0.16438212f, -0.20896713f, 0.19962852f, -0.03496516f, -0.15370451f, -0.07323547f, 
    -0.07569357f, -0.07718116f, -0.04091973f, 0.07947320f, 0.14168555f, -0.13801558f, 0.05756709f, -0.07451671f, 
    -0.17920454f, 0.10038242f, 0.07267147f, 0.18390945f, 0.09649607f, 0.23484093f, -0.05453283f, 0.01975038f, 
    0.02470028f, 0.03544316f, 0.01369535f, 0.05678268f, -0.06691667f, -0.06542564f, 0.07004423f, 0.16411366f, 
    -0.03628414f, 0.00452112f, -0.06500769f, -0.02104142f, 0.15792429f, 0.05003907f, -0.03488950f, 0.12325135f, 
    -0.21434286f, -0.24547124f, 0.19479080f, 0.13862099f, -0.18011782f, 0.05019942f, -0.20980413f, 0.09821386f, 
    -0.07621569f, 0.23680271f, 0.10741486f, 0.08052702f, -0.00489399f, -0.07554235f, 0.14193338f, 0.36326417f, 
    -0.03761277f, 0.09608875f, -0.06240869f, 0.16121514f, 0.04790824f, 0.04488752f, 0.00877571f, 0.08061624f, 
    -0.21395063f, 0.26543641f, 0.31742844f, -0.46131316f, 0.01434988f, 0.04554801f, 0.00931524f, 0.01394385f, 
    0.04123299f, -0.06593941f, 0.03312343f, -0.17812656f, -0.09074341f, 0.20374742f, 0.04926731f, -0.18955037f, 
    -0.03000828f, -0.03234794f, -0.03559230f, 0.05732930f, 0.01903880f, 0.05327041f, -0.24755128f, -0.25797668f, 
    0.04768210f, 0.17397746f, 0.07648899f, 0.01138083f, 0.05265019f, 0.02519171f, 0.23424602f, -0.16270952f, 
    0.19283417f, 0.10771825f, 0.16845641f, 0.05598142f, -0.03731578f, 0.01132400f, -0.06108695f, -0.16040398f, 
    -0.01485891f, -0.07538686f, -0.04496051f, 0.06396055f, 0.05332702f, -0.21203132f, 0.17907719f, -0.03731408f, 
    -0.09768797f, -0.00322236f, -0.03779886f, 0.21650432f, -0.14339006f, 0.07496146f, -0.06645609f, -0.02058252f, 
    -0.16194303f, 0.14273712f, -0.18795516f, -0.03885135f, 0.21695641f, 0.19749060f, -0.12891084f, 0.00809004f, 
    0.05273482f, -0.10629640f, 0.20117402f, 0.04283182f, 0.08960046f, 0.17327005f, -0.03720072f, 0.10762708f, 
    -0.22792597f, -0.06286234f, 0.05776519f, 0.11975218f, 0.10497152f, -0.06481244f, 0.01789878f, 0.15521024f, 
    -0.02659287f, -0.12576276f, 0.18291630f, 0.04421717f, -0.40102848f, -0.26432946f, -0.10676847f, -0.09883386f, 
    -0.02614375f, -0.04842502f, -0.08373807f, -0.00153859f, 0.08791773f, 0.10845163f, -0.08430899f, 0.08090272f, 
    -0.02274912f, 0.30033410f, -0.21431901f, 0.19567250f, -0.08213615f, 0.06127703f, -0.03553343f, 0.13177797f, 
    0.14100635f, -0.07683314f, 0.04198340f, 0.12958609f, 0.14904928f, -0.12401438f, 0.14383970f, -0.05282707f, 
    -0.06366010f, -0.11994523f, -0.03066416f, 0.09504683f, 0.00361667f, -0.23470321f, 0.09325987f, 0.16557333f, 
    0.03888953f, 0.22328264f, -0.23915572f, 0.00093341f, 0.01741073f, -0.06451190f, -0.10476319f, 0.15370871f, 
    -0.05294321f, -0.04967310f, -0.04804933f, -0.08932123f, 0.25838488f, 0.08495498f, 0.15433967f, 0.03650241f, 
    0.27232724f, -0.06614004f, 0.17225687f, 0.21120772f, 0.15154459f, -0.06353401f, -0.07101671f, 0.13793395f, 
    -0.20908582f, 0.19209151f, 0.34968406f, -0.12979369f, 0.11816563f, 0.10999727f, 0.01349646f, 0.20539261f, 
    -0.08679757f, 0.12925446f, 0.01757270f, -0.02295955f, -0.35446993f, 0.19352014f, 0.30275121f, 0.09451086f, 
    0.21163478f, -0.10816230f, -0.02507498f, 0.08800713f, -0.06177569f, -0.01193324f, 0.05538121f, -0.05457617f, 
    0.11549093f, -0.13508022f, 0.03984275f, 0.07983384f, -0.07501125f, 0.10896545f, -0.09286020f, 0.06756496f, 
    -0.00531516f, -0.11147689f, 0.10731482f, 0.13006276f, -0.33274770f, -0.36762801f, 0.10128572f, 0.01423527f, 
    -0.10789830f, -0.17248173f, -0.08343931f, -0.13385208f, 0.07143401f, 0.11223965f, 0.11986250f, 0.07819622f, 
    0.02921689f, 0.00869385f, 0.03688359f, -0.04164640f, 0.03568204f, 0.00802054f, -0.01825004f, 0.03047001f, 
    0.03772816f, -0.04237787f, -0.03228260f, 0.01830752f, -0.00007395f, -0.01600516f, -0.01399318f, -0.05170574f, 
    -0.01068196f, 0.02006821f, -0.04402098f, 0.01533913f, -0.00875582f, 0.00876088f, 0.03726724f, 0.00065750f, 
    0.01603831f, 0.02404934f, 0.00273568f, 0.02797321f, 0.03192944f, 0.00106367f, -0.00411154f, 0.00557957f, 
    0.01081483f, 0.01536618f, -0.03672810f, 0.00849209f, 0.03216301f, 0.00673535f, -0.03267342f, 0.04159169f, 
    0.00270357f, -0.00970591f, 0.00980734f, -0.03189095f, -0.03957222f, -0.00787339f, -0.01579009f, -0.05286869f, 
    -0.03961097f, 0.04916482f, -0.03649805f, -0.04917843f, 0.02759922f, 0.02102016f, -0.00271848f, 0.01625531f, 
    -0.03455312f, 0.00781297f, -0.02940687f, 0.00515323f, 0.01906786f, -0.05218709f, -0.00836479f, 0.01405862f, 
    -0.02355949f, 0.01198715f, -0.00927985f, -0.01669386f, -0.05284753f, 0.01252168f, 0.02672088f, 0.02926486f, 
    -0.03303034f, -0.03245144f, -0.03628864f, -0.01980188f, -0.05517063f, 0.04454618f, 0.03640686f, -0.04136990f, 
    0.01482498f, 0.02372556f, -0.04534446f, 0.00224251f, -0.01776625f, -0.01661217f, -0.03216976f, 0.03108009f, 
    -0.03245517f, -0.03874278f, -0.01325305f, 0.03345220f, 0.00284286f, -0.02623678f, 0.01950121f, -0.02875929f, 
    -0.02448557f, 0.04017144f, -0.00276083f, -0.01153594f, -0.03930645f, 0.02233531f, -0.02516850f, 0.03304571f, 
    0.01188201f, -0.04466073f, -0.00013379f, -0.00265536f, -0.05051516f, -0.02058273f, 0.02047376f, 0.02939983f, 
    -0.00372159f, -0.03092370f, 0.04883631f, 0.02370777f, -0.05361851f, -0.05401155f, -0.02514318f, -0.04980445f, 
    0.00212240f, -0.04232427f, -0.02579048f, -0.00041529f, -0.02016862f, -0.03624406f, -0.01597446f, 0.04085949f, 
    0.00050812f, -0.01296320f, -0.02462612f, -0.04821724f, 0.02598417f, -0.01414170f, -0.02791183f, 0.03372706f, 
    -0.01029714f, -0.00930288f, -0.03744045f, -0.04539102f, -0.04980967f, 0.02462990f, -0.00425481f, 0.03176871f, 
    0.03027734f, -0.04661141f, 0.00348225f, -0.04455993f, 0.02177407f, -0.03372821f, -0.04572714f, 0.02570783f, 
    -0.05203493f, 0.01919566f, 0.00795707f, 0.00638566f, -0.01308495f, 0.02649541f, -0.02537936f, -0.00999258f, 
    -0.01720370f, 0.03488356f, 0.02166907f, -0.05743221f, 0.01189752f, 0.03850266f, 0.00699955f, -0.00027616f, 
    -0.05471061f, 0.01025127f, 0.01101264f, 0.00941090f, -0.05556722f, -0.05332701f, 0.03545247f, 0.00096455f, 
    0.04228857f, -0.02845726f, 0.00353864f, -0.04613677f, 0.00642981f, -0.04154881f, -0.04814955f, 0.01019093f, 
    -0.01611755f, -0.00180525f, 0.04457102f, 0.01560344f, -0.01490102f, -0.01053115f, -0.02963073f, 0.02783434f, 
    -0.01194417f, -0.00006065f, -0.03451173f, -0.04738343f, 0.02422075f, 0.01478312f, 0.03950228f, 0.01814148f, 
    0.00869437f, -0.02510319f, -0.02178649f, -0.02884991f, -0.03786992f, -0.03150885f, -0.00676831f, -0.04569077f, 
    0.02749584f, -0.04014216f, 0.03414154f, 0.00890063f, -0.00767510f, -0.02396508f, -0.00707464f, -0.00686698f, 
    0.01616177f, -0.04521729f, -0.05196844f, -0.05268079f, 0.01280993f, -0.00692563f, -0.04037519f, -0.02010870f, 
    -0.01758643f, -0.04410988f, 0.00254585f, -0.05133934f, -0.01308032f, -0.04083145f, -0.03318958f, 0.04358293f, 
    0.01657512f, 0.00984016f, -0.02165531f, -0.01313085f, -0.05618101f, -0.05072697f, -0.04687100f, -0.05324792f, 
    0.01102887f, -0.00174014f, 0.03744544f, -0.04841572f, 0.02046095f, 0.01746117f, 0.03477061f, -0.05684344f, 
    -0.04583770f, -0.00705696f, 0.02319337f, 0.00636750f, -0.01988388f, -0.02183489f, 0.02915880f, -0.02220948f, 
    -0.01071905f, -0.05387378f, 0.03670506f, 0.04120486f, -0.02604382f, -0.00453826f, 0.01383373f, 0.04432938f, 
    0.00231448f, -0.01260600f, -0.02469076f, -0.03405938f, 0.01253438f, -0.04063924f, -0.02340543f, 0.01955527f, 
    0.02331039f, 0.01286919f, -0.04299270f, -0.02142216f, 0.00719433f, 0.01111021f, 0.01831452f, 0.00085229f, 
    0.00560946f, 0.02375677f, -0.02297073f, 0.00933930f, 0.02795912f, 0.04225476f, 0.03935980f, 0.02013386f, 
    -0.03765899f, -0.03514735f, -0.05254095f, -0.05195030f, 0.00487269f, -0.02693872f, 0.01836882f, 0.03704417f, 
    0.02705725f, -0.02309862f, -0.04363202f, -0.04230546f, 0.03615596f, -0.01383050f, -0.04654247f, -0.05348904f, 
    0.00955529f, -0.04552327f, -0.00486485f, -0.00303658f, 0.00449415f, -0.03007586f, 0.04207864f, 0.00385049f, 
    -0.04021526f, -0.03218232f, 0.01497704f, 0.04368785f, 0.00832165f, -0.02844832f, -0.03213743f, 0.03622041f, 
    0.02861937f, -0.02383086f, -0.00525309f, -0.03187265f, -0.03997174f, 0.01969739f, 0.00069230f, -0.04261874f, 
    0.05053572f, -0.04684833f, 0.01348478f, -0.01352342f, 0.00207760f, -0.01456559f, 0.04260074f, -0.00025155f, 
    -0.00107615f, 0.00078947f, 0.01949811f, 0.04438373f, -0.00009635f, -0.05339982f, -0.05341107f, -0.05611329f, 
    -0.04318337f, 0.03655316f, -0.01261636f, -0.01015964f, -0.03146613f, 0.03787385f, -0.04639179f, -0.01872804f, 
    0.02024941f, 0.02632807f, -0.03220019f, -0.05602521f, -0.00055944f, -0.04583953f, -0.01681684f, 0.02566099f, 
    0.00083185f, -0.00892983f, 0.02955622f, -0.04451986f, -0.03434738f, -0.03034101f, -0.05201438f, -0.01884772f, 
    0.01726157f, -0.03770651f, -0.04844430f, -0.04361445f, -0.00872878f, -0.02128438f, 0.03729301f, 0.00234727f, 
    -0.00683890f, -0.03544339f, -0.02642361f, 0.01712084f, 0.01185254f, 0.03360030f, -0.02269613f, -0.04327326f, 
    0.19978736f, -0.11839624f, 0.06714830f, 0.25324574f, 0.01047321f, 0.03530611f, 0.05164450f, 0.02944262f, 
    0.06879580f, 0.14826550f, -0.04215517f, -0.09321447f, -0.21406290f, 0.10190400f, -0.12813088f, 0.09579257f, 
    0.02874590f, -0.15797532f, 0.03733963f, 0.05141596f, -0.08159166f, -0.02802714f, -0.06713776f, 0.07375472f, 
    0.24013335f, 0.17830290f, -0.04481510f, -0.01469023f, -0.00491119f, -0.12414439f, 0.00521612f, -0.12670350f, 
    0.06171768f, 0.10054699f, -0.11739962f, -0.01079501f, 0.05186423f, -0.07086702f, 0.09719159f, -0.10110316f, 
    0.05639722f, 0.00969656f, -0.01728236f, 0.10112064f, 0.00956707f, 0.03438893f, -0.02081935f, -0.09442632f, 
    0.03115725f, 0.00584635f, 0.21385138f, 0.37903172f, -0.00737383f, -0.05006888f, 0.19211511f, -0.02330544f, 
    0.03303089f, 0.04647416f, -0.07086623f, -0.05080957f, 0.29101592f, 0.12538846f, 0.24975610f, 0.01764323f, 
    0.03587007f, -0.00100506f, -0.04214143f, 0.10431655f, -0.01040898f, -0.06220022f, -0.04876185f, -0.04552028f, 
    0.07924163f, -0.17453319f, -0.19205603f, -0.14680929f, 0.00799066f, -0.04543466f, 0.06559060f, 0.03220479f, 
    0.13159835f, 0.01160317f, -0.04810169f, 0.07691177f, -0.09702347f, -0.13467258f, 0.31178823f, -0.11750191f, 
    0.04843164f, 0.00642374f, -0.12434608f, 0.28127810f, -0.15512718f, 0.00508713f, -0.00193628f, -0.01610244f, 
    0.00108167f, -0.10936949f, 0.09545808f, -0.05959733f, -0.05359334f, -0.07125646f, 0.07176422f, 0.04507324f, 
    -0.02489038f, 0.01991444f, 0.03279553f, -0.02303196f, -0.16904533f, 0.11397447f, 0.03469763f, 0.26235163f, 
    0.00192717f, 0.13356188f, -0.07124139f, 0.04220026f, -0.11605573f, 0.01256679f, -0.13489811f, 0.04560052f, 
    -0.21099536f, 0.06543900f, -0.16157904f, 0.13044301f, 0.02451480f, 0.02416347f, -0.07413776f, 0.00712203f, 
    -0.21863303f, 0.07771535f, 0.11283772f, 0.06804430f, 0.06183592f, -0.09242233f, 0.02480564f, -0.03670165f, 
    -0.00830357f, 0.01850778f, -0.01102070f, -0.00972677f, 0.05510382f, -0.09347516f, 0.01113435f, -0.08693274f, 
    0.05175491f, -0.05854425f, 0.35385659f, 0.09456357f, 0.09084173f, 0.03307923f, -0.22763534f, 0.06379965f, 
    -0.02685472f, 0.02511083f, -0.01977493f, -0.04178595f, 0.04728357f, 0.14285475f, -0.03975747f, 0.03416759f, 
    0.00987010f, 0.00695805f, -0.11285936f, 0.01799997f, -0.02589653f, -0.03792720f, -0.06334218f, -0.06474049f, 
    -0.17320877f, 0.00245079f, 0.51728559f, -0.24207465f, -0.16566111f, -0.06777468f, -0.09605898f, 0.03119049f, 
    0.01312951f, -0.00082168f, 0.13072330f, -0.06038754f, -0.01247934f, -0.12221945f, -0.13583617f, 0.03875102f, 
    -0.09038585f, -0.18350466f, -0.03932291f, 0.03845134f, 0.04767481f, 0.00796021f, -0.03188743f, -0.00118322f, 
    -0.48894742f, 0.29662886f, -0.40217522f, -0.00092927f, 0.02442386f, -0.02301222f, 0.02099986f, 0.03088001f, 
    -0.14971067f, -0.04839597f, 0.07455757f, 0.05377372f, -0.14642353f, 0.06136265f, 0.00299011f, -0.12647532f, 
    -0.05190420f, 0.11459611f, 0.02468122f, -0.10881500f, 0.05491219f, 0.09005922f, -0.04720837f, 0.10422877f, 
    -0.09054289f, 0.17731488f, -0.19860397f, 0.14279184f, 0.09479858f, -0.01558424f, -0.05405109f, -0.05677197f, 
    -0.03729700f, -0.01356234f, -0.07233419f, -0.01164154f, -0.02981411f, -0.08689366f, -0.24062626f, 0.15703908f, 
    -0.05496519f, 0.12405025f, -0.00977833f, 0.09607633f, 0.01048889f, -0.05968205f, 0.30201650f, -0.15131789f, 
    0.05110564f, 0.07337143f, 0.06425992f, 0.05607856f, -0.06451436f, 0.15481983f, 0.00137628f, -0.00568179f, 
    -0.01120042f, 0.02113032f, -0.14993249f, 0.15426825f, 0.10083775f, 0.17620745f, -0.01116208f, 0.19589911f, 
    0.10779141f, 0.03873847f, -0.08680540f, 0.05133191f, 0.10034796f, -0.11987710f, -0.08711432f, 0.01454888f, 
    0.27967829f, -0.09041651f, 0.01086687f, 0.15756887f, 0.05777267f, 0.04529637f, 0.01214433f, -0.02474967f, 
    -0.05927626f, -0.01347155f, 0.06525299f, -0.05080457f, 0.07696033f, -0.04767282f, -0.09006310f, -0.05525316f, 
    0.01460679f, 0.00580172f, 0.01170734f, -0.05368949f, 0.00051981f, -0.06919659f, -0.05740732f, -0.02110586f, 
    -0.08631881f, -0.40472558f, 0.22077483f, 0.12101877f, 0.07708784f, -0.03989605f, 0.05383782f, 0.05463659f, 
    0.03009130f, -0.07804411f, 0.08549546f, 0.03424894f, -0.13762152f, 0.05900864f, -0.01360011f, -0.04359661f, 
    -0.08719966f, -0.01024544f, 0.08398830f, -0.08887316f, -0.05136222f, -0.14351456f, 0.08786674f, -0.03592606f, 
    0.08408085f, -0.00063892f, 0.00852520f, -0.01752023f, 0.10802896f, 0.03257599f, -0.13930546f, 0.01668232f, 
    -0.02129143f, 0.00826808f, 0.12469834f, 0.00056804f, 0.24777877f, 0.12865488f, 0.06432202f, 0.08402840f, 
    0.01666238f, 0.04562748f, 0.09608733f, -0.00068328f, 0.07881381f, -0.10000169f, -0.05363860f, -0.03300343f, 
    -0.39300677f, 0.32199100f, 0.02754103f, 0.10995477f, 0.07552144f, 0.16010749f, 0.01329061f, -0.18266053f, 
    -0.14085358f, 0.04632475f, 0.05500882f, -0.05154540f, 0.14850846f, 0.36727488f, 0.29577690f, 0.29355103f, 
    0.09992404f, -0.00138200f, 0.04541165f, 0.18727620f, -0.04521289f, -0.04980284f, 0.06740088f, 0.00629726f, 
    0.01218885f, -0.00842657f, 0.14366421f, 0.21437263f, -0.01758718f, -0.15344411f, -0.01393202f, 0.04876130f, 
    0.00977716f, 0.04908718f, -0.07555798f, -0.01148915f, 0.02070003f, -0.10351631f, -0.18763198f, -0.07829467f, 
    -0.02378257f, -0.01937744f, -0.02050859f, 0.05103630f, 0.01542979f, 0.11474548f, 0.03782264f, -0.06496811f, 
    0.19065046f, 0.22439183f, -0.04331091f, -0.07460712f, 0.09214436f, 0.11954644f, 0.01564830f, 0.16716869f, 
    0.03284953f, -0.09369853f, 0.09213674f, -0.03325684f, -0.03109957f, -0.04629704f, 0.18976329f, -0.24379516f, 
    0.00203287f, -0.05064859f, -0.25302225f, 0.03726276f, 0.01298096f, -0.08071114f, 0.07137742f, -0.07169630f, 
    0.26268575f, 0.12948819f, 0.02810233f, -0.08152498f, -0.03289080f, -0.00697568f, 0.00279987f, -0.03020792f, 
    -0.12818439f, -0.09286056f, 0.09174921f, -0.01077275f, 0.19138333f, 0.19750947f, -0.05929323f, -0.05042483f, 
    0.02650833f, 0.14633729f, -0.01282157f, 0.05598449f, -0.05830104f, -0.03876344f, -0.08411739f, -0.06322610f, 
    0.10332305f, 0.03173126f, -0.17424864f, -0.16351283f, -0.16860232f, -0.02564576f, -0.10741459f, 0.25690830f, 
    -0.04193687f, -0.10146477f, 0.03380359f, -0.07319547f, -0.06407385f, -0.06544524f, -0.20122732f, 0.06921484f, 
    0.04747362f, -0.04973420f, 0.01851851f, 0.00681072f, -0.05051630f, 0.03934573f, 0.01693502f, -0.04719900f, 
    -0.19561771f, -0.01925208f, -0.00730175f, -0.04994614f, 0.03146579f, -0.02615116f, -0.09946131f, -0.05095236f, 
    -0.00053469f, -0.02032088f, -0.05292850f, 0.09238753f, -0.10104525f, -0.09655317f, 0.03574733f, -0.16297595f, 
    -0.00526865f, 0.17147002f, -0.00379005f, -0.13205236f, -0.00412284f, -0.15108046f, -0.01651854f, 0.03779992f, 
    0.17427450f, 0.14616480f, 0.00948058f, 0.03610460f, -0.02577017f, -0.00799141f, 0.00945324f, 0.01111426f, 
    -0.05826044f, -0.14539506f, -0.03153497f, 0.16290188f, 0.23534492f, -0.21348186f, 0.02887105f, -0.19112514f, 
    0.08476853f, 0.08422527f, -0.07693741f, 0.25507513f, -0.00979072f, -0.08215444f, 0.06560057f, 0.05280740f, 
    -0.21204537f, -0.25071535f, -0.00800177f, 0.09550878f, -0.05403929f, -0.05444937f, -0.00493466f, 0.03819811f, 
    -0.00949597f, 0.02236949f, 0.09168044f, 0.04532251f, 0.06241607f, 0.04822204f, 0.10277625f, 0.21570636f, 
    0.03817121f, 0.00120972f, 0.08039761f, 0.07814470f, 0.11334444f, 0.12849736f, 0.06218406f, 0.18390174f, 
    0.14782386f, 0.10802728f, -0.07952765f, -0.03678435f, 0.00146548f, -0.02701228f, 0.09561349f, 0.03380813f, 
    -0.06161896f, -0.02825241f, -0.00952258f, -0.05101093f, -0.04053655f, -0.14260320f, -0.09804914f, -0.01484095f, 
    -0.08946356f, -0.03094674f, 0.06136926f, -0.07031208f, -0.11267726f, -0.02781235f, -0.04720688f, 0.06116034f, 
    -0.25617480f, 0.15917073f, 0.04096527f, -0.05850555f, 0.03581971f, -0.01834522f, 0.04418468f, -0.01744355f, 
    0.13216081f, -0.15977569f, 0.01952830f, -0.05481749f, 0.23715584f, 0.16521305f, 0.02711783f, -0.13204302f, 
    0.01377700f, 0.16305467f, -0.00052956f, 0.17379846f, -0.11244344f, -0.09134261f, -0.01801158f, -0.08040451f, 
    0.49391809f, -0.43281934f, 0.13004513f, 0.10324326f, -0.01586443f, -0.05431412f, -0.01929864f, -0.09243770f, 
    0.05620888f, 0.17435803f, -0.00677170f, -0.04846482f, 0.23317085f, -0.06694248f, 0.10106480f, 0.14356512f, 
    0.03929107f, 0.00811141f, -0.09807178f, -0.03319083f, -0.04049373f, -0.05353011f, 0.00591071f, 0.14796928f, 
    0.34549186f, -0.06023043f, -0.02086070f, -0.00850807f, 0.00877112f, -0.07822162f, -0.03537123f, -0.11119263f, 
    -0.17133102f, 0.02707000f, -0.07008252f, 0.14668511f, 0.00424055f, 0.01286661f, 0.32794419f, -0.24270159f, 
    -0.02945049f, 0.06512643f, -0.01372650f, -0.00238082f, -0.00222178f, 0.00360348f, -0.19635251f, -0.05532297f, 
    0.08032423f, 0.19790582f, 0.10710307f, -0.17530863f, -0.00194763f, -0.03012730f, 0.04129155f, 0.01897796f, 
    -0.06294727f, 0.00545107f, 0.05951234f, 0.00324044f, 0.04108156f, 0.06047219f, 0.12683408f, 0.12614399f, 
    0.05405298f, 0.08125680f, 0.07657762f, -0.16328777f, -0.06256930f, 0.11259377f, -0.11411696f, 0.09005366f, 
    0.41430157f, 0.14675854f, 0.00700953f, -0.01595083f, -0.03133179f, -0.00577018f, -0.08404437f, 0.06407288f, 
    0.11684743f, -0.02163001f, -0.15178840f, 0.06857295f, 0.05401644f, -0.08477919f, 0.03646793f, -0.05824100f, 
    0.03405005f, 0.01993441f, 0.08800289f, 0.01548995f, 0.00014386f, 0.08108912f, 0.05604092f, 0.03567560f, 
    -0.18964051f, -0.26691708f, 0.15972963f, -0.34718972f, 0.00144140f, -0.09818071f, -0.02597477f, 0.02295466f, 
    -0.07163261f, 0.01997746f, -0.05525333f, -0.17834143f, -0.04782298f, -0.00794727f, 0.26801085f, 0.10033122f, 
    -0.05660837f, 0.08480480f, 0.04023968f, -0.01796386f, 0.06258547f, 0.05620483f, -0.05483124f, 0.02872698f, 
    0.27714431f, 0.09415199f, 0.05345826f, 0.00129513f, 0.04378926f, -0.03797350f, -0.00480941f, -0.02002174f, 
    0.06795800f, 0.11088315f, 0.06535423f, 0.10919315f, 0.16726312f, 0.15831977f, -0.23832041f, -0.04774258f, 
    -0.14176172f, 0.17306551f, 0.02147208f, 0.13045637f, -0.02617169f, -0.05675841f, 0.01254168f, -0.09865043f, 
    0.52175748f, -0.22573145f, 0.25477496f, 0.03629070f, -0.25832611f, 0.12872569f, 0.00697937f, -0.15910861f, 
    0.12103056f, -0.08662277f, -0.03884602f, -0.04808563f, 0.24880718f, 0.07884736f, -0.09986245f, -0.29995313f, 
    -0.09876810f, 0.02721042f, -0.06339929f, 0.09755636f, 0.00776442f, -0.00348137f, 0.00493306f, -0.12751983f, 
    -0.08756375f, 0.22595249f, 0.14814229f, -0.08654997f, -0.06679918f, 0.13382766f, 0.05510479f, 0.03022931f, 
    -0.14704783f, -0.04621458f, -0.18883491f, 0.02713474f, -0.09884141f, -0.01253799f, 0.07203738f, 0.08002247f, 
    0.08415824f, 0.11811566f, 0.01549984f, -0.04583651f, 0.07608062f, 0.10770927f, 0.10278082f, 0.14275356f, 
    0.22519170f, -0.14818347f, 0.02504120f, 0.00276140f, 0.00132680f, 0.07412456f, 0.06028010f, 0.06033905f, 
    0.07273706f, -0.04003423f, 0.00257116f, -0.18001413f, -0.20186798f, 0.02512807f, -0.06212021f, 0.00151311f, 
    0.04829601f, 0.06767225f, 0.05593082f, 0.20851602f, -0.05750417f, -0.05479939f, -0.00666036f, -0.08784842f, 
    0.03467892f, -0.01790393f, -0.19349790f, -0.09395111f, 0.01265682f, 0.04953979f, -0.00891483f, 0.00305810f, 
    0.14999250f, 0.05999512f, -0.19894074f, -0.18560416f, 0.06632479f, 0.07558072f, 0.09171187f, -0.17281306f, 
    0.02276754f, 0.02324720f, -0.08513156f, 0.01486517f, 0.12801102f, 0.12982270f, 0.06325163f, 0.06352547f, 
    0.20928307f, 0.03878347f, 0.04793549f, 0.09509825f, 0.11833124f, -0.05143335f, 0.07941564f, 0.07010980f, 
    0.08612521f, 0.05588138f, 0.02289561f, -0.07842517f, 0.22199945f, 0.26424381f, 0.24099350f, -0.10978205f, 
    -0.03257514f, -0.03989886f, -0.02132597f, 0.01677890f, 0.04260415f, 0.03287287f, -0.10452210f, -0.07904310f, 
    -0.08357210f, -0.01953288f, -0.09965425f, -0.05962577f, 0.05631097f, 0.06684182f, 0.04872601f, 0.16514187f, 
    0.02060821f, 0.00445360f, -0.12005262f, -0.22656742f, 0.12773646f, -0.18859263f, 0.12882327f, -0.03144245f, 
    0.10651559f, 0.12825298f, -0.05511239f, 0.21743095f, -0.01513899f, -0.08235741f, 0.05886554f, -0.08037777f, 
    0.11735518f, 0.02040576f, 0.22362961f, -0.09665251f, 0.04505390f, 0.06781168f, -0.00123431f, -0.00153571f, 
    0.10637939f, -0.03718234f, 0.02233686f, -0.20549233f, 0.13435704f, -0.12089347f, 0.14583874f, 0.03439146f, 
    -0.01469434f, 0.09073365f, -0.10438588f, 0.07180398f, -0.05679916f, -0.08135548f, 0.01472916f, 0.02580203f, 
    -0.31116918f, -0.07599688f, -0.11506094f, 0.08830909f, 0.07838531f, 0.00485388f, 0.02799388f, 0.03677657f, 
    0.03361095f, -0.11290030f, -0.20673829f, -0.10798198f, -0.07478640f, 0.11612809f, 0.03243920f, 0.03272616f, 
    -0.04155643f, -0.00509328f, -0.00970414f, -0.08479711f, -0.01731073f, -0.01883303f, -0.06168919f, 0.09010863f, 
    0.20691517f, 0.10863144f, 0.22046572f, 0.09520429f, 0.18296625f, 0.10733482f, -0.08245486f, 0.12140673f, 
    0.02769201f, -0.00560112f, -0.00250925f, 0.02855704f, -0.04112307f, 0.15953070f, 0.02901157f, -0.01121257f, 
    0.03004496f, -0.03174154f, -0.00579017f, -0.01973091f, 0.08976230f, 0.10422157f, 0.06694981f, 0.09873764f, 
    0.14577968f, -0.04236734f, 0.27547690f, -0.15807256f, -0.04614757f, -0.03537106f, 0.10813845f, -0.06281777f, 
    -0.01098531f, -0.05583381f, 0.15275285f, 0.16293943f, -0.00667395f, -0.02258201f, -0.12792721f, -0.04238276f, 
    -0.07310399f, 0.02592549f, 0.02894968f, 0.01536249f, 0.08096704f, 0.06651506f, 0.03985263f, 0.05464172f, 
    -0.18668823f, -0.14697298f, -0.12155187f, -0.00781908f, -0.13075301f, -0.04656428f, -0.05411821f, 0.01855883f, 
    -0.00225877f, -0.20043874f, -0.11045959f, 0.06285360f, 0.04003013f, -0.12873951f, 0.02302936f, -0.14483632f, 
    0.10142788f, 0.00048532f, -0.05698306f, -0.04037104f, 0.08717423f, 0.02280494f, -0.12698163f, -0.05259129f, 
    -0.00555287f, -0.10391027f, -0.17607963f, 0.07850993f, 0.01073537f, 0.01049728f, 0.08014103f, 0.01371077f, 
    -0.01687991f, 0.06325305f, -0.15451691f, 0.04809131f, -0.08172742f, 0.03523374f, -0.07752261f, -0.01487795f, 
    -0.03328690f, 0.01302713f, 0.05258932f, -0.05930292f, -0.05806141f, -0.23934583f, 0.14458370f, 0.07997148f, 
    0.14043340f, -0.06982420f, 0.04707174f, -0.11007603f, -0.00852783f, 0.08441624f, 0.16299485f, 0.03102782f, 
    0.01540590f, 0.05256050f, -0.06407216f, 0.00259048f, 0.04955489f, 0.09954204f, -0.14602356f, 0.07388573f, 
    -0.05767401f, 0.12270544f, 0.10059167f, -0.07482007f, 0.10031985f, 0.08100430f, -0.17305961f, 0.13558553f, 
    0.15524006f, -0.14611952f, -0.27476391f, 0.04148980f, -0.04779753f, -0.07635087f, 0.10421000f, 0.10863728f, 
    0.06259383f, -0.05437918f, -0.07831871f, -0.02879435f, -0.07633127f, 0.08547396f, -0.03117652f, -0.07121891f, 
    0.10200569f, -0.04038803f, 0.05546826f, 0.07194974f, 0.02248379f, 0.05876904f, 0.08421285f, -0.00917529f, 
    -0.22432169f, -0.33264419f, 0.14145426f, -0.03903210f, -0.01746447f, 0.10128294f, 0.14024657f, 0.08731799f, 
    -0.04451058f, 0.06072229f, 0.09675036f, -0.04173967f, 0.05879226f, 0.00096431f, 0.13517882f, 0.06810532f, 
    -0.03007633f, 0.00129340f, 0.14974622f, -0.11395578f, -0.07433856f, -0.15889768f, 0.20763931f, 0.05955320f, 
    0.01335948f, -0.21006776f, -0.21507666f, -0.20075075f, -0.04010017f, -0.06472964f, -0.08506604f, 0.12590030f, 
    0.08717951f, -0.04899098f, 0.13248535f, -0.15387698f, 0.01582402f, 0.20407033f, -0.09476295f, 0.05505498f, 
    -0.04980370f, 0.08320048f, 0.21841736f, 0.16287355f, 0.03499666f, -0.01910806f, 0.06594733f, 0.09702285f, 
    0.02373022f, 0.08848700f, -0.02633131f, 0.10966581f, -0.09116571f, -0.01989915f, 0.10335216f, -0.06757459f, 
    0.13028276f, 0.00053205f, 0.09802561f, 0.02445938f, 0.04221015f, 0.48639509f, 0.24658830f, 0.06270980f, 
    0.04726607f, -0.03116590f, -0.10055052f, 0.11675353f, -0.04211516f, 0.05932229f, 0.09839115f, -0.04726081f, 
    0.16519621f, -0.14052151f, -0.01126980f, 0.29163787f, -0.04010249f, 0.01199866f, -0.01848245f, 0.03189813f, 
    0.07575746f, -0.04743525f, -0.00204776f, 0.13934588f, -0.05723045f, 0.06858067f, -0.07899563f, -0.02285741f, 
    0.02518354f, -0.04149891f, -0.01406070f, -0.08553965f, 0.02470666f, 0.12112505f, 0.05855450f, 0.02277466f, 
    0.05098782f, -0.01714948f, -0.04632436f, -0.22205321f, 0.03159270f, -0.02652750f, 0.08371101f, 0.19563152f, 
    0.16183037f, 0.03846213f, 0.05449672f, 0.02981125f, -0.14025407f, -0.30648676f, -0.03838517f, -0.53150594f, 
    -0.04778669f, -0.04250887f, -0.03900069f, 0.00114060f, 0.08928342f, 0.09203443f, -0.02121118f, -0.11498624f, 
    -0.08786269f, -0.14695813f, -0.14691058f, -0.07536974f, -0.07154142f, -0.20133406f, 0.01294429f, -0.05836416f, 
    0.09788793f, -0.01402442f, -0.03732900f, -0.12160702f, -0.04280869f, 0.06995647f, -0.06093258f, -0.14605363f, 
    0.17626654f, 0.13259320f, 0.09022368f, 0.05268437f, 0.03022745f, -0.03931201f, 0.03349343f, 0.08083348f, 
    0.04431286f, -0.05978274f, 0.05010263f, 0.18253295f, 0.05926812f, -0.02732689f, 0.15294255f, 0.12301545f, 
    -0.00332727f, -0.06272849f, 0.04774915f, -0.01817856f, 0.18233196f, 0.19550726f, 0.10696097f, 0.21598361f, 
    0.10458319f, 0.10403571f, 0.00486625f, -0.01495751f, -0.08457365f, -0.10073541f, -0.00883833f, -0.04075691f, 
    -0.15095581f, -0.25034738f, -0.17065260f, -0.19624175f, -0.01762526f, -0.00032606f, 0.05037690f, -0.03823270f, 
    0.14591324f, -0.10711551f, 0.02420002f, 0.01077325f, -0.09447091f, -0.01170675f, 0.09742931f, 0.03412771f, 
    0.09004901f, -0.03404297f, 0.05790414f, -0.05414858f, -0.01681392f, -0.07847726f, -0.09444169f, -0.03199140f, 
    0.09599264f, -0.16965123f, -0.02650946f, -0.20721017f, 0.10565581f, -0.03879549f, -0.01256177f, 0.09970102f, 
    0.07909312f, -0.08428942f, 0.01354603f, 0.09543841f, -0.24360272f, -0.06411248f, -0.20084202f, -0.39014691f, 
    0.08349877f, 0.01393068f, -0.11191411f, 0.03983527f, 0.06161875f, 0.06139664f, -0.00992386f, 0.02983492f, 
    0.23834245f, 0.10752086f, 0.05683222f, 0.03908226f, 0.01887053f, 0.02664258f, 0.02871990f, -0.04668432f, 
    0.07778817f, 0.19606222f, 0.02743610f, -0.13825497f, 0.26654875f, 0.19034632f, 0.24176286f, 0.21240517f, 
    0.01207612f, 0.05048213f, -0.02694549f, -0.01123133f, -0.01845404f, -0.10504515f, -0.02361317f, 0.05619790f, 
    -0.36820614f, -0.01836349f, -0.18946739f, -0.28067207f, 0.23633023f, 0.10683108f, 0.04728707f, -0.06237315f, 
    -0.00528867f, -0.04023246f, -0.04560344f, -0.03885664f, 0.04860857f, 0.00049838f, -0.00079804f, 0.01045986f, 
    0.08675578f, -0.05212243f, -0.03678522f, -0.02302133f, -0.19132148f, -0.05308985f, -0.07649553f, -0.01026493f, 
    -0.21378529f, 0.18488646f, 0.08694262f, 0.04724816f, -0.00343849f, 0.00444945f, -0.04821209f, -0.00707403f, 
    0.04749816f, 0.04156379f, -0.04352060f, -0.11543929f, -0.14764920f, 0.06354331f, -0.15015122f, -0.24511564f, 
    0.20777991f, 0.12353758f, -0.06922601f, 0.23190476f, 0.00376039f, -0.00353367f, 0.03958551f, 0.02784275f, 
    0.39116609f, 0.00198514f, 0.02536332f, 0.06171488f, -0.08453966f, -0.04721132f, -0.06950818f, -0.05062406f, 
    0.10120062f, 0.04707315f, 0.00397430f, -0.03754206f, -0.02865822f, -0.11595038f, 0.17317569f, 0.06439910f, 
    0.00258997f, -0.01757383f, -0.11801637f, 0.01581160f, 0.11466607f, -0.00896300f, -0.04098433f, -0.07559025f, 
    0.04899944f, -0.11853930f, -0.02373496f, -0.07727942f, -0.03724650f, -0.07725799f, -0.06190525f, -0.06385318f, 
    -0.03967238f, -0.04314058f, -0.19951676f, -0.08963038f, 0.27748498f, 0.03294828f, 0.17682628f, 0.05052554f, 
    -0.03665255f, 0.01851796f, -0.05986743f, -0.00351219f, 0.21610361f, -0.07417845f, -0.01149827f, -0.03123354f, 
    -0.25637040f, -0.15019470f, 0.01008267f, -0.20325722f, 0.09446306f, -0.15137947f, -0.04867595f, 0.01555311f, 
    0.05371776f, 0.02463751f, -0.04815606f, -0.13794525f, 0.07448274f, -0.05801997f, 0.07936650f, 0.07493370f, 
    0.03652681f, -0.08008822f, -0.03953591f, -0.15018138f, -0.04901440f, 0.04343214f, -0.05169976f, -0.06790763f, 
    -0.34467643f, -0.18105097f, -0.20108910f, -0.19654009f, -0.23432322f, -0.17486674f, -0.12128437f, -0.09190717f, 
    0.00663192f, -0.07518321f, 0.02490211f, 0.00633621f, 0.03574970f, 0.08457114f, 0.07234433f, 0.05756373f, 
    0.05146517f, 0.02008007f, -0.05080876f, 0.01820627f, -0.11828849f, -0.10422852f, -0.07085739f, 0.00803732f, 
    0.16860861f, -0.10522830f, -0.08668362f, -0.38446829f, -0.03488752f, -0.04758459f, -0.18255214f, 0.11835630f, 
    0.03826043f, 0.03871348f, 0.06641512f, -0.11342284f, 0.19406301f, 0.03729744f, 0.06569622f, 0.26641229f, 
    -0.01079157f, 0.05083578f, -0.01421298f, 0.00087955f, -0.00781730f, -0.03937025f, 0.00336839f, 0.09918470f, 
    0.11707133f, -0.14595756f, 0.00894781f, 0.02698885f, -0.17092337f, -0.07959544f, -0.09743328f, -0.07197894f, 
    -0.00635160f, -0.06414468f, 0.10634051f, 0.06709903f, -0.07919011f, 0.06272967f, -0.34910348f, -0.08198406f, 
    0.04820570f, 0.30314863f, 0.03537449f, 0.21015607f, 0.02666927f, -0.01608090f, -0.05476858f, 0.00771188f, 
    0.16055307f, -0.07382509f, 0.07716028f, 0.06817659f, -0.18352672f, 0.04815139f, -0.06221156f, -0.15698744f, 
    0.15962850f, -0.03025713f, -0.16945347f, 0.05002360f, 0.23641564f, 0.09863457f, -0.13357866f, -0.12212415f, 
    -0.02404378f, 0.01288488f, 0.20827478f, 0.07337710f, -0.08753500f, -0.03951226f, -0.07263178f, 0.01254988f, 
    -0.04236881f, 0.08428552f, 0.04426387f, 0.20205213f, -0.09836580f, -0.02371079f, -0.09475639f, -0.01698301f, 
    0.07435209f, 0.07958767f, 0.01762891f, 0.08932737f, 0.08525338f, 0.02364169f, 0.06512558f, 0.11424808f, 
    0.02246862f, 0.06313129f, -0.03528630f, -0.04626084f, -0.07140429f, -0.03240141f, -0.00475137f, -0.03435727f, 
    -0.13451867f, -0.03095221f, 0.05442564f, 0.00071015f, 0.07811289f, -0.05741166f, 0.03905016f, -0.01866061f, 
    -0.00364817f, -0.08271819f, -0.08057566f, -0.10331768f, -0.04232459f, -0.20284329f, -0.14849129f, -0.01354548f, 
    0.06252313f, -0.11627953f, 0.08810054f, -0.00491363f, 0.07022810f, -0.02249461f, 0.10680214f, 0.04367171f, 
    0.20807756f, -0.06146191f, -0.18519829f, 0.18651053f, 0.05338356f, -0.06513104f, -0.11627186f, 0.03273617f, 
    0.14474379f, 0.10285342f, 0.05445848f, -0.05943190f, -0.10383949f, 0.00455265f, 0.10657197f, -0.02244377f, 
    0.02704534f, -0.07199643f, 0.21596077f, -0.03174320f, 0.07028907f, 0.06175647f, 0.01964727f, -0.06170797f, 
    -0.04740599f, 0.01262650f, 0.11269300f, 0.53548598f, 0.08942363f, 0.15835114f, 0.25355330f, 0.01136333f, 
    0.06780458f, 0.07463540f, -0.09844247f, -0.01300748f, 0.02323541f, -0.41372746f, -0.07061719f, -0.01722002f, 
    0.20603468f, 0.07745323f, 0.16753919f, 0.08671772f, 0.09183061f, -0.03007778f, -0.02940919f, 0.05330379f, 
    0.06398855f, -0.11132449f, -0.25215572f, -0.00261145f, -0.06347308f, -0.03772131f, 0.14141677f, 0.18325068f, 
    0.11921007f, -0.03916715f, 0.10878804f, -0.03502816f, 0.01965419f, -0.18477960f, -0.03986484f, -0.16494304f, 
    0.25050026f, -0.05785503f, 0.08398460f, 0.08063136f, -0.09312237f, 0.10569152f, -0.09604143f, -0.17237990f, 
    0.03110180f, -0.18044604f, -0.03362854f, -0.03295746f, -0.03992293f, -0.04594886f, 0.14450096f, 0.13596156f, 
    0.09911859f, 0.07626106f, -0.03188781f, -0.17261620f, -0.23507926f, 0.26663890f, -0.04128924f, -0.09316135f, 
    0.00777296f, -0.04295055f, 0.01201658f, 0.13161364f, -0.09597360f, 0.11233249f, -0.00470947f, 0.06042958f, 
    0.01285520f, 0.01428970f, -0.17354549f, 0.12807938f, -0.03438690f, 0.01447836f, 0.07066421f, 0.11145592f, 
    0.04826827f, 0.08539633f, 0.03210416f, -0.02695101f, -0.07908357f, -0.11006301f, -0.04511066f, -0.10669330f, 
    0.05163678f, 0.08035889f, -0.04967987f, -0.04667017f, 0.08977534f, 0.03545462f, -0.04687888f, -0.09856894f, 
    -0.10308848f, -0.08084724f, 0.04907323f, 0.06822851f, 0.18274114f, -0.04862279f, 0.00809037f, 0.14489886f, 
    0.03318722f, -0.01882759f, 0.02488406f, 0.07846911f, 0.13242127f, -0.10387898f, 0.10908005f, -0.16181700f, 
    -0.01467337f, 0.02051102f, -0.00154889f, -0.11925035f, 0.09815340f, 0.03617245f, 0.09602010f, -0.02107359f, 
    0.15835236f, -0.19473031f, 0.00216387f, 0.13309266f, -0.17519581f, -0.18123806f, -0.03281002f, 0.05297231f, 
    -0.03140058f, 0.04810524f, -0.01173058f, -0.09447727f, -0.16040367f, -0.09503777f, -0.09648968f, 0.00901454f, 
    -0.05219205f, -0.14650761f, -0.14680134f, 0.07016563f, 0.20309402f, 0.05727012f, 0.07606240f, 0.02072268f, 
    -0.38102636f, -0.01298721f, -0.07253856f, -0.24519148f, 0.03443884f, -0.04531837f, 0.11296202f, -0.00993154f, 
    -0.01461922f, 0.00318368f, 0.16242075f, -0.11693678f, -0.07723086f, 0.17351644f, -0.03268365f, 0.02625535f, 
    0.04641017f, -0.05242119f, 0.04037912f, 0.02979899f, 0.01534877f, 0.03050970f, -0.06706320f, -0.07343729f, 
    -0.09994018f, -0.12255168f, -0.11181524f, -0.27211425f, 0.15511318f, -0.02564966f, -0.01054930f, -0.19946283f, 
    0.06857729f, 0.15972584f, 0.13108480f, -0.07250537f, 0.20597382f, -0.34155485f, 0.04431782f, 0.06391216f, 
    0.07160033f, -0.04036818f, 0.08829091f, 0.02278961f, 0.09554718f, 0.02277375f, 0.20181319f, 0.00892437f, 
    0.23624286f, -0.09831623f, 0.00789242f, 0.09480788f, 0.10858916f, 0.03046660f, 0.05112181f, -0.18445322f, 
    0.01013249f, -0.04685885f, 0.04597856f, 0.02552398f, 0.14285997f, 0.26642713f, -0.06541677f, -0.12201852f, 
    -0.02329111f, -0.12006023f, -0.15674797f, 0.08694601f, -0.01239996f, -0.12110818f, 0.06359151f, -0.16018954f, 
    0.03435991f, -0.25755268f, -0.04165812f, -0.16669258f, 0.06217238f, 0.02026615f, 0.00767142f, 0.11243445f, 
    0.14909627f, -0.17326185f, 0.05392561f, 0.00295909f, -0.02746835f, -0.26978052f, 0.02429277f, -0.16213994f, 
    -0.04308018f, 0.17292419f, 0.01306485f, -0.00616152f, 0.06167679f, -0.21665481f, -0.05143255f, -0.08144847f, 
    -0.07126797f, -0.10051642f, -0.01701237f, -0.05309442f, 0.02376720f, 0.11184517f, -0.04411601f, -0.11594766f, 
    0.10266089f, 0.03342541f, 0.26055580f, 0.14911813f, 0.18227597f, -0.08722115f, 0.03875869f, -0.20081636f, 
    0.08768766f, 0.03623890f, -0.02212434f, -0.00110110f, 0.03082839f, -0.00706524f, 0.18370125f, -0.02161903f, 
    -0.03665875f, -0.20418462f, -0.06621728f, -0.02919209f, 0.11985738f, -0.01023993f, -0.14355953f, 0.09810213f, 
    -0.03855082f, -0.00130114f, 0.07879385f, 0.07215375f, -0.08161061f, 0.15162291f, 0.07178017f, -0.02935846f, 
    -0.03796782f, 0.07971878f, 0.10605408f, 0.02155501f, 0.16827776f, -0.11779334f, -0.07824868f, 0.00607900f, 
    -0.21023758f, 0.09639575f, 0.18650809f, -0.17747179f, 0.07832187f, 0.17178483f, -0.08996781f, 0.11503963f, 
    0.04317048f, 0.08700845f, 0.01814099f, 0.02828937f, -0.03958195f, -0.03576719f, 0.15338284f, 0.09221534f, 
    0.13655037f, 0.02686380f, 0.08084334f, 0.19808055f, -0.00363506f, -0.09833677f, 0.05080167f, 0.01290567f, 
    -0.05535033f, -0.08708432f, -0.14077412f, 0.34095651f, -0.03726111f, -0.18535683f, 0.01292984f, 0.03074684f, 
    0.18395148f, 0.20809481f, 0.07097985f, 0.09445528f, -0.05272974f, -0.12362671f, -0.10991435f, -0.09329323f, 
    0.10173268f, 0.04280463f, 0.02417777f, 0.02417849f, 0.00362939f, -0.07245977f, 0.07548798f, -0.07828126f, 
    -0.04332356f, -0.21108486f, -0.03300462f, 0.34806222f, 0.03205420f, 0.08913433f, 0.04431719f, 0.07749970f, 
    0.13189027f, 0.16038226f, 0.10729406f, 0.03269924f, 0.00355850f, -0.00793485f, 0.10157473f, 0.13743711f, 
    -0.00385890f, -0.00458346f, 0.07705522f, -0.01354856f, 0.05814533f, 0.06221593f, 0.03313214f, -0.10434173f, 
    0.26842022f, 0.10621183f, 0.06399991f, -0.14257711f, -0.03204511f, 0.01336668f, 0.00023160f, 0.04878393f, 
    -0.12119697f, 0.00741820f, 0.06800716f, 0.01592563f, -0.06450436f, -0.16958785f, -0.05358668f, 0.28125027f, 
    0.07716969f, 0.00324383f, -0.04797129f, 0.17977795f, -0.09849283f, 0.00546772f, 0.00325613f, 0.01737055f, 
    -0.20472287f, -0.12411918f, -0.00887146f, -0.05541668f, 0.00211911f, 0.09533437f, -0.17683275f, -0.10017140f, 
    -0.12537058f, -0.00688958f, -0.04254182f, -0.00858709f, -0.07048742f, 0.07004411f, 0.13620348f, 0.16671346f, 
    -0.15394957f, -0.04904290f, -0.09209102f, -0.17176491f, 0.04442742f, -0.00856811f, 0.10010861f, 0.05309647f, 
    0.05990786f, -0.07134335f, 0.10836770f, 0.19183987f, -0.05483379f, -0.00945848f, 0.00876644f, -0.12653330f, 
    -0.08785106f, 0.03164349f, -0.03077984f, 0.08586813f, -0.15864569f, 0.33895823f, 0.04400053f, 0.18277545f, 
    -0.18005405f, 0.05719827f, -0.07761947f, -0.10597877f, 0.08910778f, 0.06778905f, -0.02631147f, 0.04803174f, 
    -0.16384120f, -0.04003000f, -0.07029775f, 0.06497775f, -0.02809300f, 0.05272812f, 0.04922638f, 0.00038271f, 
    0.06981976f, 0.16407262f, -0.04270804f, 0.08736357f, -0.10724600f, -0.02862320f, 0.00526390f, 0.27175209f, 
    -0.01596004f, -0.00601861f, -0.07002199f, -0.11978940f, -0.07479530f, -0.03386101f, -0.00798419f, -0.00525160f, 
    0.06874572f, 0.15341908f, 0.16909984f, -0.01002390f, -0.07166993f, -0.08035230f, -0.06182823f, -0.03557126f, 
    -0.00487661f, -0.10136692f, -0.06165438f, -0.14826170f, 0.25714436f, 0.19867003f, 0.18786199f, 0.17591700f, 
    -0.11880347f, 0.02666095f, -0.03099141f, -0.04366664f, 0.06003954f, 0.03568405f, 0.00274818f, 0.07634323f, 
    -0.16223258f, -0.03257293f, -0.11519703f, 0.15360111f, -0.24781846f, -0.03898844f, -0.16409191f, -0.12024119f, 
    0.00173189f, -0.02995393f, -0.03125304f, -0.09032867f, 0.03414948f, -0.02677798f, 0.07719089f, 0.03147834f, 
    -0.08241575f, -0.04072741f, 0.02239374f, -0.00049062f, 0.01247548f, -0.00299496f, -0.05604986f, 0.05647915f, 
    0.17882618f, 0.04097022f, -0.03010093f, -0.11363952f, 0.12004538f, 0.01732466f, -0.06039289f, -0.01746950f, 
    0.04390245f, 0.15454029f, -0.08516150f, -0.02930896f, 0.05340706f, -0.08907957f, 0.07619122f, 0.28007388f, 
    -0.01394055f, -0.07710359f, -0.00683162f, 0.09126067f, -0.09835114f, -0.02773711f, -0.05685776f, 0.01778879f, 
    0.34387550f, 0.32546830f, 0.16859131f, 0.00314675f, 0.06025532f, 0.02721245f, 0.07485224f, -0.03810541f, 
    0.02790124f, 0.00984436f, -0.00718770f, 0.01559262f, 0.05189770f, 0.09921136f, -0.19101997f, -0.12403200f, 
    -0.02626328f, -0.01562908f, -0.00037479f, 0.00704370f, -0.05332680f, -0.04954120f, -0.12705870f, -0.05778148f, 
    0.17352863f, 0.16861771f, 0.04141303f, 0.11978526f, -0.02741441f, 0.01743065f, 0.18119445f, 0.16519237f, 
    0.01539350f, 0.04715651f, 0.21472837f, 0.09356053f, -0.03441291f, 0.17650492f, 0.05344623f, -0.16075619f, 
    -0.05295084f, 0.04098767f, -0.02753573f, 0.02484787f, -0.06851679f, 0.08798864f, -0.13081929f, 0.00317636f, 
    -0.23869166f, 0.25943261f, -0.22429214f, -0.17312784f, -0.14048010f, 0.04683149f, -0.09309286f, 0.04920245f, 
    -0.22458054f, -0.04888723f, -0.05333766f, 0.03656242f, 0.27743509f, -0.04828248f, 0.00748502f, 0.10881107f, 
    -0.01194225f, -0.05999808f, 0.00650708f, 0.09096865f, -0.11628101f, 0.08612120f, 0.19621070f, 0.06454015f, 
    0.25065461f, 0.05522731f, -0.06343441f, -0.01068817f, 0.04612931f, -0.00241046f, -0.14046752f, -0.00189617f, 
    -0.15193322f, 0.04816889f, -0.02771045f, -0.03729694f, 0.02109279f, 0.00030447f, 0.06956989f, 0.06205427f, 
    -0.04284687f, -0.02972813f, -0.11090554f, -0.04626360f, -0.05130475f, 0.10671642f, 0.02642861f, 0.02522376f, 
    0.14050990f, 0.36935756f, -0.03664834f, 0.33673340f, -0.05963272f, 0.00678905f, 0.04535924f, 0.06582687f, 
    0.01646514f, 0.00762116f, 0.05938357f, -0.00214885f, 0.07856777f, 0.18414320f, 0.00755135f, -0.11634109f, 
    -0.00510901f, -0.07771700f, 0.02634482f, 0.05417620f, -0.05363747f, -0.01668707f, -0.27816030f, 0.15040684f, 
    -0.01326162f, 0.07219442f, -0.01967900f, -0.08445664f, -0.04429154f, 0.06491128f, 0.04718840f, 0.06571675f, 
    0.01619882f, -0.01448638f, -0.24012633f, -0.05517059f, 0.17119755f, -0.30042064f, 0.22709772f, 0.26345739f, 
    0.15452544f, -0.12552685f, -0.15350522f, -0.04808077f, -0.13686752f, 0.06387056f, 0.01662319f, -0.01367246f, 
    0.13717674f, 0.35455477f, -0.19016890f, -0.22200322f, 0.07619838f, 0.21580441f, -0.01475137f, 0.06451594f, 
    -0.16168591f, 0.03144549f, -0.07731496f, 0.12607087f, -0.11941368f, -0.13072446f, 0.14430031f, 0.24850681f, 
    0.05411169f, 0.01421720f, 0.03645806f, -0.09034730f, -0.09966211f, -0.03551401f, -0.02527180f, 0.05828048f, 
    0.17951021f, 0.26892722f, 0.10281795f, -0.34016061f, -0.03994485f, 0.18827327f, -0.05621458f, -0.06508565f, 
    -0.01373219f, 0.01880665f, 0.01474041f, -0.05005269f, 0.04478459f, -0.00577021f, 0.03919876f, 0.01616459f, 
    -0.06391302f, -0.08897000f, 0.00790454f, -0.09348652f, 0.09943666f, 0.09271158f, -0.08565687f, 0.09544761f, 
    0.02042142f, -0.01755666f, -0.22221011f, -0.16864368f, -0.03076658f, 0.12990050f, -0.03584724f, 0.05499822f, 
    -0.12179370f, -0.11939391f, -0.07043916f, 0.02397915f, 0.06470864f, -0.06626633f, -0.14025360f, 0.14431228f, 
    -0.04277459f, -0.00271709f, 0.09148850f, 0.28272462f, 0.14908586f, 0.13176610f, 0.09745628f, -0.05798564f, 
    -0.22644500f, -0.17126296f, -0.12843212f, -0.12522079f, -0.03779683f, 0.00921304f, -0.02102500f, 0.06961889f, 
    0.12886155f, 0.09601395f, -0.06546137f, -0.09466719f, 0.24555513f, 0.13648225f, 0.01069004f, -0.00526686f, 
    0.01762152f, 0.01398241f, -0.02336947f, -0.07935725f, -0.03264227f, -0.01070600f, -0.10967060f, 0.13631381f, 
    0.17143691f, 0.03805278f, 0.16217278f, -0.00789595f, 0.11216548f, 0.12977834f, 0.05638037f, 0.08336145f, 
    -0.11231919f, -0.13860948f, -0.07286832f, 0.00251713f, 0.02360038f, 0.19834465f, -0.00360790f, 0.04065086f, 
    -0.04219463f, -0.01151264f, -0.05927762f, -0.10577108f, -0.01973818f, -0.05063217f, -0.02805204f, 0.08981783f, 
    0.20870416f, 0.06526488f, 0.12841375f, -0.02785101f, -0.01101406f, -0.00414576f, -0.04119962f, 0.14817221f, 
    -0.04491088f, -0.04826885f, -0.15352693f, -0.26298580f, 0.05506385f, -0.10468289f, 0.09190666f, -0.02502582f, 
    0.18835615f, 0.07695361f, 0.00640764f, 0.09852993f, -0.02936081f, 0.01362357f, 0.05606339f, 0.03693484f, 
    0.17031239f, 0.08481700f, 0.18864322f, 0.12157612f, 0.04278859f, -0.10525763f, -0.01362794f, 0.08745033f, 
    -0.07509410f, -0.10867180f, 0.00292333f, -0.13112889f, 0.21120745f, 0.40156430f, -0.16977768f, 0.04801776f, 
    0.03128607f, 0.05075124f, 0.25972193f, -0.01683541f, -0.06358458f, 0.04779272f, -0.04334338f, 0.02426280f, 
    0.09349025f, -0.21828657f, 0.01103516f, 0.00521295f, -0.10540836f, 0.02242581f, 0.00677847f, 0.10917252f, 
    0.09095217f, -0.12921347f, -0.09435763f, -0.17009699f, 0.07433306f, 0.03189865f, -0.00665387f, 0.11974983f, 
    -0.11458281f, -0.03049906f, -0.13234964f, -0.08965394f, -0.22637813f, -0.01073766f, -0.04503802f, -0.11791907f, 
    0.28880960f, 0.17494939f, 0.04554803f, 0.00066904f, 0.24825713f, 0.20648675f, 0.19230759f, 0.10462016f, 
    -0.04601141f, -0.05349081f, -0.04615188f, 0.07479929f, 0.02497903f, 0.20885907f, 0.04610935f, -0.03313164f, 
    0.03072588f, 0.04729900f, -0.00062116f, -0.07351483f, 0.04112889f, 0.08550237f, 0.02335670f, 0.04872078f, 
    -0.01864661f, -0.13286884f, 0.27876014f, 0.15471295f, -0.12040005f, -0.11544374f, -0.02180626f, 0.00669165f, 
    -0.00036871f, -0.01411653f, -0.00803758f, 0.09606527f, 0.09421202f, 0.14745025f, 0.07815376f, -0.08023064f, 
    0.20032595f, 0.30200475f, 0.10609607f, -0.01267031f, 0.03452072f, -0.07064620f, -0.02509574f, -0.07638163f, 
    0.03781832f, 0.11717138f, -0.22684151f, -0.03654587f, -0.01268265f, -0.10046392f, -0.06085111f, 0.08157557f, 
    0.02746396f, -0.05336665f, -0.07956763f, -0.09708739f, 0.24568737f, 0.15166339f, 0.02003529f, -0.10220008f, 
    -0.02318680f, -0.11466332f, -0.01431661f, -0.04955306f, 0.00298494f, 0.06972791f, -0.08711608f, -0.25581363f, 
    -0.16126114f, -0.16048226f, -0.23920919f, -0.07834795f, -0.05709015f, 0.05434649f, -0.00805201f, -0.01845299f, 
    0.14406566f, 0.03607901f, -0.05385939f, -0.10879120f, 0.23248339f, 0.18518239f, -0.25133365f, 0.32461482f, 
    -0.09476882f, -0.08215477f, -0.02128454f, 0.03304064f, 0.09240468f, -0.11098877f, 0.11802588f, 0.07117330f, 
    -0.16003840f, -0.21779636f, 0.22004779f, -0.05513179f, 0.15490097f, -0.00633674f, -0.00732789f, 0.12781988f, 
    0.05109122f, 0.04016110f, 0.01699387f, -0.24804084f, -0.09431946f, -0.08471048f, -0.09390382f, 0.08545029f, 
    0.02430067f, 0.00942968f, 0.06752472f, 0.01242725f, 0.02846170f, 0.13993527f, -0.00263203f, 0.20804931f, 
    -0.47059017f, 0.10042071f, -0.27502319f, -0.31540471f, 0.02782243f, 0.07468979f, 0.15829660f, 0.03123748f, 
    -0.02532911f, 0.04742973f, 0.16730337f, -0.03876716f, -0.15159634f, 0.01900611f, -0.04993546f, -0.00814498f, 
    -0.00989079f, -0.05352302f, 0.03569503f, -0.00780093f, 0.00110392f, 0.03625642f, -0.04625909f, -0.04631563f, 
    0.37123546f, -0.28743774f, -0.30167663f, 0.07977555f, -0.10247839f, 0.06874367f, -0.00547627f, 0.08200131f, 
    0.09074660f, 0.05544847f, 0.04080120f, 0.17201212f, 0.03922120f, 0.04654638f, -0.02121577f, 0.15444690f, 
    -0.08083445f, -0.08994997f, 0.03675266f, 0.05712127f, -0.00629578f, -0.08398719f, 0.25478667f, 0.10337526f, 
    -0.11740317f, -0.37247550f, -0.26332846f, -0.10861904f, -0.06161349f, 0.02366493f, -0.18102977f, -0.11563148f, 
    -0.02259535f, 0.00296076f, 0.15934497f, -0.03229600f, 0.00005659f, 0.17651880f, 0.01187838f, -0.08311712f, 
    0.09851386f, 0.14544901f, 0.13099200f, 0.22741611f, 0.03323950f, -0.03113726f, 0.06602254f, 0.08303045f, 
    -0.12377866f, 0.07256533f, -0.17617050f, 0.10574538f, -0.06500642f, -0.03945482f, 0.08445772f, 0.00237718f, 
    0.16798131f, -0.06301279f, 0.08122386f, 0.13572186f, 0.04350042f, -0.00172047f, -0.02957555f, -0.01657152f, 
    0.10696145f, 0.08285011f, 0.13437565f, 0.09149657f, -0.03148571f, 0.02205611f, 0.00758336f, 0.03570745f, 
    0.03407503f, -0.22859335f, 0.09708812f, 0.16115086f, -0.01380047f, -0.01109513f, -0.01210764f, 0.05186305f, 
    0.21771191f, 0.02501385f, 0.09525411f, 0.30664381f, 0.07442556f, 0.09787985f, 0.10086373f, 0.02082368f, 
    -0.05884288f, -0.01957044f, -0.14681911f, -0.03091778f, -0.09492494f, -0.05157501f, -0.05557111f, -0.10373498f, 
    0.03176350f, -0.00182232f, 0.01514140f, -0.03191338f, 0.02677137f, -0.00494223f, -0.03339642f, -0.03791699f, 
    0.00449001f, -0.00893684f, 0.00850979f, -0.05305178f, -0.03521460f, 0.01408654f, -0.01783128f, 0.03239724f, 
    0.03796443f, 0.03516924f, 0.02593330f, -0.01832799f, 0.04119684f, 0.02348505f, -0.02169226f, 0.02943017f, 
    0.03175288f, -0.02684494f, -0.00742046f, -0.03383821f, 0.00410743f, 0.03547712f, -0.02269456f, -0.05744189f, 
    -0.01729109f, 0.01729099f, 0.00636180f, -0.01624908f, 0.01584355f, -0.04417739f, -0.03453744f, 0.01676663f, 
    -0.03294785f, 0.00802327f, 0.02628805f, -0.03725362f, 0.03332836f, -0.00478810f, -0.01369924f, -0.04370108f, 
    0.00761581f, -0.05203971f, 0.00244880f, -0.04000807f, -0.01155681f, -0.01880194f, 0.01860988f, -0.01836618f, 
    0.00713225f, 0.02852340f, -0.03907765f, -0.04105817f, 0.00050575f, -0.02806614f, -0.05172737f, 0.02002062f, 
    -0.03210520f, -0.01152477f, -0.04714065f, -0.00351832f, -0.04614156f, -0.04734663f, 0.03861187f, 0.00659070f, 
    -0.02385684f, -0.00394423f, 0.00568761f, -0.05339761f, 0.01014711f, -0.01036849f, 0.01788309f, 0.01341949f, 
    0.03576820f, 0.00819860f, -0.05307456f, 0.01633314f, -0.01003176f, 0.02487965f, -0.04051273f, 0.01190779f, 
    -0.01675096f, -0.03419825f, -0.00539145f, 0.03713049f, -0.04186003f, -0.03608934f, -0.03109980f, -0.03071322f, 
    -0.03643984f, 0.03566478f, 0.04201503f, 0.03626795f, -0.00991597f, -0.04720753f, -0.02197733f, -0.01822389f, 
    0.02765354f, -0.03202846f, -0.05321147f, -0.05665364f, -0.00541257f, 0.01975712f, -0.00051640f, 0.04030170f, 
    -0.03512580f, -0.03939009f, -0.01715589f, -0.03999964f, -0.05145220f, 0.04123151f, 0.01550487f, -0.03270314f, 
    -0.01529463f, -0.05708588f, -0.00818390f, -0.00806173f, 0.00311544f, -0.02348236f, 0.02522208f, -0.04145915f, 
    0.00133875f, -0.03956093f, -0.05184675f, -0.04665583f, -0.02758252f, -0.00858539f, -0.02511415f, -0.04981953f, 
    0.02352886f, -0.01764967f, -0.01553369f, -0.05508149f, -0.05023343f, 0.00504205f, 0.00014481f, -0.05735574f, 
    0.02089644f, -0.01836201f, 0.01018380f, 0.01497155f, -0.00143213f, 0.00186732f, 0.02375128f, 0.00408405f, 
    -0.02377654f, -0.01730417f, -0.00387452f, 0.00280657f, 0.03910987f, -0.00041992f, -0.02586548f, 0.01063296f, 
    0.02679757f, 0.03569894f, -0.01963371f, 0.03958499f, 0.00088166f, -0.02665979f, 0.00008685f, -0.00281922f, 
    0.03795447f, 0.04686155f, -0.01884685f, 0.02022099f, -0.00405438f, -0.02610087f, 0.01022460f, -0.01845086f, 
    -0.02980630f, 0.00006901f, -0.01118233f, 0.00201409f, 0.04191546f, 0.01418827f, -0.01604472f, 0.01059435f, 
    -0.00547869f, -0.01073520f, -0.01425850f, -0.04280147f, 0.00970701f, 0.03795804f, 0.04223968f, -0.05547572f, 
    0.02667709f, 0.01171307f, -0.01775724f, -0.04470073f, -0.04915203f, -0.02190584f, 0.01055010f, -0.05035294f, 
    0.03313160f, 0.01673788f, -0.04863934f, -0.01445717f, -0.03728122f, -0.02249146f, -0.04218829f, 0.02490220f, 
    0.03604024f, -0.02850656f, 0.01812395f, -0.02191011f, -0.04416477f, 0.00988555f, -0.04277684f, 0.00717600f, 
    0.00742071f, 0.00575524f, 0.00109468f, -0.05240135f, 0.00847897f, 0.00789060f, -0.01033006f, -0.02922437f, 
    0.01129331f, -0.01594433f, 0.03814247f, 0.01703542f, -0.03570646f, 0.00818338f, 0.02592024f, -0.03729530f, 
    0.00967177f, 0.00715308f, -0.04302320f, -0.04300012f, 0.01366434f, -0.05170657f, -0.02076353f, 0.03728952f, 
    0.00609307f, -0.04220331f, 0.03731540f, 0.02624389f, -0.02776512f, -0.01355320f, -0.04844663f, -0.01329223f, 
    -0.05277158f, -0.05094038f, 0.01429635f, 0.03542152f, -0.00513717f, -0.04731422f, 0.02345207f, -0.03132330f, 
    0.00879947f, -0.02957898f, -0.03692717f, -0.04307122f, -0.03201400f, -0.02897662f, 0.02789321f, 0.00391704f, 
    -0.02017941f, 0.02208607f, 0.00960975f, 0.02377401f, -0.03915206f, 0.02339988f, 0.03527729f, 0.04046295f, 
    -0.03488791f, -0.03740890f, 0.01714212f, 0.02529405f, 0.00600712f, -0.00749056f, -0.00154783f, 0.04338483f, 
    -0.03057213f, 0.04066708f, 0.00311722f, -0.01425095f, -0.04521479f, 0.04753570f, -0.02292796f, -0.03006351f, 
    -0.03131630f, -0.04324712f, 0.00433276f, 0.03144578f, 0.00244444f, 0.04240594f, -0.05226457f, 0.00045714f, 
    -0.05351425f, 0.00258069f, -0.05596004f, -0.03113216f, -0.02703969f, 0.03281908f, -0.04278784f, 0.01415277f, 
    0.02244984f, 0.03180565f, -0.03548864f, -0.02903165f, -0.02337591f, -0.03035520f, -0.05026593f, 0.01513337f, 
    -0.01946338f, 0.04390885f, 0.03472596f, 0.00099495f, -0.00249948f, -0.00378358f, -0.03226855f, -0.02483267f, 
    0.02164440f, 0.04054189f, -0.01818772f, 0.04062174f, -0.03486096f, 0.02273064f, -0.02750131f, -0.04014131f, 
    0.00049656f, 0.02227864f, -0.00363491f, 0.01596663f, -0.03026839f, -0.01212866f, 0.00311792f, 0.02825596f, 
    0.02199209f, 0.02585336f, 0.03506067f, 0.02268353f, 0.00625255f, -0.00774926f, -0.01897472f, 0.03927220f, 
    -0.03188753f, -0.03833546f, 0.02772666f, -0.01242036f, 0.01289690f, 0.02074612f, 0.01685922f, -0.03200595f, 
    0.04170014f, -0.01650806f, -0.02769761f, -0.00259733f, -0.02228139f, 0.02481392f, -0.04114400f, -0.04128901f, 
    -0.02685411f, 0.02447062f, 0.03459297f, -0.04198207f, -0.04052550f, 0.02997254f, -0.03930769f, -0.02260510f, 
    0.04024944f, -0.03789767f, 0.02609393f, -0.05338072f, -0.00017405f, -0.04027086f, -0.02411976f, -0.04336319f, 
    -0.02223383f, -0.05369792f, -0.02791582f, -0.02696946f, 0.02165414f, 0.01437771f, -0.03148661f, 0.00431107f, 
    -0.05371842f, -0.02164324f, -0.00556527f, 0.02480188f, 0.00201863f, -0.01890850f, -0.03239017f, -0.00582949f, 
    0.01285982f, -0.01986624f, 0.03798804f, 0.01711229f, 0.03963548f, -0.00385521f, 0.03329602f, 0.00039324f, 
    0.02980405f, -0.04850625f, 0.03048904f, -0.03573361f, 0.01825273f, -0.01154723f, -0.04413225f, -0.01854705f, 
    -0.01095009f, -0.03582147f, 0.03460459f, -0.05434581f, 0.01276359f, 0.02792551f, -0.03135856f, 0.00335103f, 
    -0.03648579f, 0.00354528f, 0.03783516f, -0.02689543f, 0.01726597f, -0.01989589f, 0.03660744f, 0.00467316f, 
    -0.05502450f, -0.03665027f, 0.02962700f, -0.02023244f, 0.01003424f, -0.05643468f, -0.03610930f, 0.01303132f, 
    0.02220550f, 0.01165260f, -0.02291200f, -0.02516345f, -0.00417218f, 0.00720676f, 0.02898005f, 0.02723305f, 
    -0.01607413f, -0.00141963f, -0.02493295f, -0.04377754f, 0.03410748f, -0.03604732f, 0.01146403f, 0.02939585f, 
    -0.00634035f, -0.00326727f, -0.00098121f, -0.01252293f, -0.02249327f, -0.00590846f, 0.03470598f, 0.04190274f, 
    -0.02898869f, 0.03056013f, -0.03489549f, 0.00711899f, -0.00666298f, -0.02045632f, 0.00727176f, -0.03609248f, 
    -0.01615014f, -0.02867634f, -0.02342355f, 0.00600370f, -0.02847100f, 0.01226527f, 0.03676652f, 0.04124261f, 
    -0.03055939f, -0.05033615f, -0.04348580f, 0.02711922f, 0.02572943f, -0.03241482f, -0.04726379f, 0.01865982f, 
    -0.01772479f, -0.02987000f, 0.03608019f, 0.03391385f, 0.00291181f, 0.00026222f, -0.01724673f, -0.05726471f, 
    -0.02828841f, -0.02877134f, -0.00003617f, 0.00607115f, 0.01908959f, -0.02065252f, 0.00206006f, -0.05711560f, 
    -0.01034318f, -0.02071808f, -0.05825590f, 0.01509251f, 0.01057136f, 0.01126523f, -0.02648347f, 0.01522247f, 
    0.01708036f, 0.00684161f, 0.01645250f, 0.01235840f, -0.00500131f, -0.00427469f, 0.03329844f, -0.00849335f, 
    0.02837490f, 0.02563800f, 0.02564566f, 0.01234301f, -0.04837039f, 0.03389578f, 0.00997626f, -0.03242162f, 
    -0.02650596f, -0.04286067f, -0.01151165f, 0.04228439f, -0.02036935f, -0.03311712f, -0.03148842f, -0.03841592f, 
    -0.04135713f, -0.01404713f, 0.01822235f, -0.00690407f, 0.03479616f, 0.00447845f, 0.02149214f, 0.01216893f, 
    -0.00622828f, -0.05313859f, 0.01250035f, 0.04552382f, 0.01403775f, -0.04208625f, -0.03872109f, 0.05175734f, 
    -0.01664399f, -0.01298924f, 0.01826981f, -0.00957276f, 0.01601400f, -0.01713664f, 0.00871907f, -0.04215197f, 
    0.05101595f, -0.02048274f, -0.04339358f, 0.01744956f, 0.04173162f, 0.01157500f, 0.03791100f, 0.03331583f, 
    -0.04224944f, -0.00875264f, 0.00761981f, 0.03246893f, -0.03619792f, -0.05576730f, -0.05696873f, -0.05412372f, 
    -0.05865402f, -0.05819469f, 0.02577392f, 0.00593937f, -0.01184373f, -0.04900761f, -0.04893255f, 0.03644438f, 
    0.03548757f, 0.03904516f, -0.00436730f, 0.00657216f, -0.01878819f, -0.03583959f, -0.01204136f, -0.02171434f, 
    -0.03743098f, -0.03313193f, -0.01817211f, -0.04527544f, 0.02720262f, -0.06280074f, -0.03190156f, 0.03727144f, 
    -0.01923747f, -0.02976942f, 0.03734778f, 0.03506239f, 0.01444987f, 0.01344686f, 0.03963476f, 0.01304075f, 
    0.03444989f, -0.01527232f, -0.03645315f, -0.00324022f, -0.02912541f, -0.03393454f, 0.00876317f, 0.00431040f, 
    -0.01681210f, 0.01509406f, 0.00677300f, 0.02510798f, -0.02787612f, -0.03252661f, 0.01349042f, 0.04598413f, 
    -0.01003052f, 0.00979631f, 0.00950310f, 0.00177077f, -0.00830539f, -0.05015611f, -0.03244184f, -0.02641153f, 
    -0.03410601f, -0.01249458f, 0.03303793f, -0.04576580f, 0.03635659f, 0.03506703f, -0.06117970f, 0.03326968f, 
    0.00764998f, -0.04624643f, -0.03341157f, -0.03662881f, 0.00334212f, 0.02118142f, -0.01668552f, -0.01565070f, 
    -0.03939281f, -0.00087317f, -0.04169681f, -0.02744777f, 0.01244703f, 0.01539610f, -0.05839457f, 0.00119064f, 
    -0.05848600f, 0.02504774f, -0.04676413f, 0.02414119f, -0.05309205f, -0.01585116f, -0.00371482f, -0.01167011f, 
    -0.03908571f, 0.02539403f, -0.00371603f, -0.04919733f, -0.04134949f, -0.00425444f, -0.02032992f, -0.00561543f, 
    -0.00688547f, -0.01650056f, -0.01306061f, 0.01392662f, -0.03721111f, 0.01462537f, 0.01775202f, 0.01617159f, 
    -0.01883016f, 0.02213065f, -0.01596805f, -0.01180855f, -0.04018745f, -0.01281152f, -0.04683386f, 0.00712278f, 
    -0.03397066f, 0.01289877f, 0.03015865f, -0.04341498f, 0.00567389f, -0.01458255f, 0.00354805f, 0.01258481f, 
    -0.03263540f, 0.02289310f, 0.02951564f, 0.00906256f, 0.00641126f, -0.00439512f, -0.02121193f, -0.00583787f, 
    -0.01420469f, 0.01903277f, 0.02059401f, -0.00762686f, -0.03027869f, -0.02960634f, 0.01991244f, -0.01156911f, 
    -0.01645518f, 0.01155543f, 0.01638807f, -0.03621497f, -0.04670366f, -0.00199981f, -0.03143201f, -0.01045300f, 
    0.03702170f, 0.00687516f, 0.00600446f, 0.02129198f, 0.03110367f, 0.02695042f, -0.03926137f, -0.03034323f, 
    -0.03658470f, 0.00325466f, 0.00561140f, -0.01193155f, -0.02272090f, 0.01709052f, -0.00275703f, -0.02256021f, 
    0.03646012f, -0.03313678f, 0.03379831f, -0.03806906f, 0.00891958f, -0.00958560f, 0.00688373f, -0.02167371f, 
    -0.01127227f, -0.04118984f, -0.04360219f, 0.03414833f, -0.03132125f, -0.02523927f, 0.00821879f, -0.00680651f, 
    0.03808276f, -0.04115479f, 0.00234488f, 0.03144387f, 0.01035005f, -0.04481855f, -0.05307786f, 0.00910991f, 
    0.00512009f, 0.02408873f, 0.00011395f, 0.01810883f, -0.00587866f, -0.04299795f, 0.01424115f, 0.03319163f, 
    0.04285888f, -0.03867466f, -0.02006043f, 0.03837210f, 0.01293154f, -0.03482419f, 0.03427606f, 0.01529286f, 
    0.21749085f, 0.15943184f, 0.05936683f, 0.18402591f, 0.11978158f, -0.03596163f, 0.16338757f, -0.02677961f, 
    -0.00565414f, 0.11490837f, 0.13353315f, 0.09998593f, -0.06779253f, 0.14191945f, 0.30729443f, -0.14191090f, 
    -0.09382324f, 0.08791641f, -0.15084743f, -0.17404282f, -0.07170520f, 0.06035069f, -0.09474374f, 0.00331825f, 
    0.30321246f, 0.17428134f, 0.26647246f, 0.19611605f, 0.09500875f, -0.00819537f, 0.14606641f, -0.09858578f, 
    -0.17669129f, -0.06090570f, -0.00221210f, 0.07000056f, 0.20469515f, 0.11169058f, -0.05910482f, 0.10186831f, 
    -0.01275003f, 0.07096870f, 0.07172339f, -0.01140521f, 0.00828834f, 0.05757008f, -0.04741595f, 0.03398042f, 
    0.04185407f, 0.10506187f, 0.01187170f, -0.11491869f, -0.12667862f, -0.03344508f, 0.01955559f, 0.22451594f, 
    -0.06001432f, 0.00779398f, -0.00200287f, 0.09248311f, -0.32278588f, 0.18489930f, 0.13951981f, -0.02950094f, 
    0.02164541f, -0.07176812f, -0.13951588f, 0.02726503f, -0.04362103f, 0.02022410f, 0.13033961f, -0.31129739f, 
    0.14866853f, 0.06181620f, 0.20259561f, 0.15404165f, 0.15324149f, -0.00564569f, -0.00332634f, -0.12119494f, 
    0.08854154f, 0.10416103f, 0.00735158f, 0.18864480f, -0.49278548f, 0.17030251f, -0.00501800f, 0.20174862f, 
    -0.02445904f, 0.08175666f, -0.09218095f, -0.14349905f, 0.09875680f, 0.16221675f, 0.00765965f, 0.18059187f, 
    0.08936536f, 0.13051611f, 0.01130272f, 0.08122297f, -0.01803674f, 0.04227289f, -0.05430380f, -0.01576614f, 
    0.08937490f, 0.13805310f, 0.01395391f, 0.16264443f, 0.27213848f, 0.05062167f, 0.17097807f, -0.17120695f, 
    0.00885519f, -0.00647829f, -0.01131248f, 0.24538177f, 0.07075529f, -0.09835557f, 0.04110837f, -0.01660631f, 
    -0.25797331f, -0.13133146f, 0.14871457f, -0.15020777f, -0.03011316f, -0.10185371f, 0.00222621f, -0.10864609f, 
    0.00029631f, 0.03117199f, 0.09278119f, 0.07425738f, -0.16707247f, -0.21974829f, -0.22957811f, 0.04749965f, 
    -0.03842035f, -0.10073036f, -0.24950700f, 0.21150722f, -0.03774486f, -0.12365497f, 0.23339348f, 0.12676555f, 
    0.09187678f, 0.27615216f, -0.10322398f, 0.09510480f, -0.11473651f, 0.04702161f, 0.10972618f, -0.05188631f, 
    0.00723780f, 0.04099105f, -0.08598482f, -0.04325609f, -0.19399434f, -0.19022270f, -0.16366561f, -0.10487158f, 
    -0.00238323f, 0.03209256f, 0.04122405f, -0.14913391f, -0.00308975f, -0.20994201f, -0.18094718f, -0.05498059f, 
    -0.23680095f, -0.05738345f, -0.15831876f, -0.14681660f, 0.23790926f, 0.19454528f, -0.04809496f, -0.22004420f, 
    0.09102330f, -0.02039636f, -0.16133769f, -0.09783453f, 0.26557830f, 0.25090644f, 0.19319130f, 0.04454089f, 
    0.03111199f, 0.10436922f, 0.01666587f, 0.09801283f, -0.22132538f, 0.00319405f, -0.16481832f, -0.13776506f, 
    0.32746565f, 0.15424809f, 0.23127089f, 0.04043088f, 0.06021762f, -0.07085437f, -0.06548266f, -0.01614616f, 
    0.08256071f, 0.10969386f, -0.01910164f, 0.11899380f, 0.10935771f, 0.12773757f, 0.14555895f, 0.27777219f, 
    0.11180337f, -0.06300908f, 0.03719565f, 0.01140362f, -0.00937681f, 0.03094370f, 0.10122125f, 0.09012187f, 
    0.23114778f, 0.05125023f, 0.10760284f, 0.07844433f, 0.04245831f, -0.06469098f, 0.02092382f, -0.12663440f, 
    0.02269920f, -0.06579692f, -0.04399270f, -0.00431961f, -0.12988277f, -0.06981704f, 0.19913708f, -0.05964345f, 
    -0.08197886f, 0.09125131f, -0.21138214f, -0.06439658f, 0.00881114f, 0.11020436f, -0.11380176f, 0.07558048f, 
    0.08053638f, 0.17931095f, 0.04813848f, 0.01964361f, 0.05997225f, -0.04892826f, -0.04265108f, 0.11780690f, 
    0.13899729f, 0.05496665f, -0.00403540f, 0.07535122f, 0.00113675f, 0.02706118f, 0.02237874f, 0.16733618f, 
    0.07436229f, 0.07802522f, 0.06377209f, -0.14736284f, -0.09617615f, -0.06858933f, 0.04694302f, 0.05993155f, 
    0.30031291f, 0.22448710f, 0.21503176f, 0.12591921f, 0.07867986f, 0.06217790f, -0.02578989f, 0.02743234f, 
    0.08383317f, 0.04817741f, 0.05716440f, 0.01699885f, -0.36278766f, -0.13020347f, -0.21794975f, -0.15674415f, 
    -0.08875354f, -0.11979950f, -0.12578641f, 0.07550962f, -0.05187693f, -0.03237156f, 0.03511796f, -0.06259573f, 
    -0.21765096f, 0.11148121f, 0.03938995f, -0.39986530f, -0.21092166f, 0.00163044f, -0.02210893f, 0.14248225f, 
    -0.06759646f, 0.03927237f, -0.07683875f, -0.01089588f, -0.32700285f, 0.00164742f, -0.05941031f, 0.08241798f, 
    -0.02993777f, -0.05679543f, 0.02900167f, 0.04579254f, -0.03491709f, -0.02801576f, -0.13113223f, 0.04851888f, 
    0.19049965f, 0.19499476f, -0.08295386f, 0.07440975f, 0.06776116f, 0.06953945f, 0.17840627f, -0.03064728f, 
    0.07494494f, 0.16511717f, 0.01250358f, 0.07109276f, 0.18307704f, 0.07644789f, 0.06244278f, 0.04797591f, 
    0.01501711f, 0.08114880f, -0.09897467f, 0.08723220f, 0.03025049f, -0.00931415f, 0.01531373f, 0.03653752f, 
    -0.10502054f, 0.13414742f, 0.09248666f, -0.17247421f, 0.03485690f, 0.03408116f, -0.02508317f, 0.13441536f, 
    0.07378800f, -0.04479064f, -0.08746888f, -0.09540230f, 0.21557111f, 0.10582806f, 0.01035206f, -0.14126258f, 
    -0.00734156f, -0.08149306f, -0.03678697f, 0.07868070f, 0.02485265f, 0.08999845f, -0.20074090f, -0.11107076f, 
    -0.12047552f, -0.09189128f, -0.23028207f, -0.16960129f, 0.20091553f, 0.02858624f, -0.11394242f, 0.02009279f, 
    -0.11821242f, -0.00341417f, 0.02582530f, -0.10221897f, -0.49341574f, -0.44859087f, -0.08477390f, 0.21937771f, 
    -0.21781127f, 0.01601247f, -0.01680979f, -0.19976097f, 0.02600690f, 0.03268609f, -0.02969715f, 0.00402400f, 
    0.03223507f, 0.05553889f, -0.04048899f, -0.03377234f, -0.03409373f, 0.01665725f, -0.05740348f, -0.02405920f, 
    -0.03935868f, 0.02861491f, -0.00338972f, 0.02904451f, 0.01817760f, -0.04492651f, 0.00551941f, 0.01976718f, 
    0.03360456f, -0.03628939f, 0.04209345f, 0.04202863f, -0.04561519f, -0.05269641f, -0.02024176f, 0.01279970f, 
    -0.00795738f, 0.03491918f, -0.03717720f, -0.00136533f, -0.02248574f, -0.04082146f, -0.03021866f, 0.02283759f, 
    0.00768098f, -0.01220335f, -0.02167822f, -0.02022918f, 0.00821288f, 0.01377672f, -0.02990603f, 0.03362263f, 
    -0.00893992f, -0.03191802f, -0.01368228f, 0.02815848f, 0.02636748f, -0.03368937f, 0.02421540f, 0.01172443f, 
    -0.01322378f, -0.03721357f, 0.00133293f, 0.00690594f, 0.01288879f, -0.01026395f, 0.05511999f, 0.01327558f, 
    0.03418764f, -0.03465517f, 0.01218320f, -0.02946228f, 0.00661617f, 0.02394902f, -0.00624796f, -0.02288544f, 
    0.00233260f, -0.01036255f, -0.03973539f, 0.03584575f, 0.01600192f, -0.02899926f, -0.01871987f, 0.02752434f, 
    -0.04485978f, -0.03306800f, 0.03769097f, -0.02204185f, 0.03328497f, -0.01831853f, -0.02143865f, -0.04291357f, 
    -0.02281758f, 0.00354919f, -0.02126745f, -0.05151762f, -0.00936721f, 0.03557736f, 0.01163057f, -0.03206642f, 
    0.01820230f, -0.00409993f, -0.03287425f, 0.04103200f, -0.00256524f, -0.03123779f, -0.01902202f, 0.03758667f, 
    0.01659056f, -0.02204039f, -0.02097741f, -0.04140052f, -0.02109646f, 0.03522865f, 0.01022595f, 0.02340653f, 
    -0.03144585f, 0.01996480f, -0.00820036f, 0.00195392f, 0.03028668f, -0.02130240f, 0.00499123f, -0.04368135f, 
    -0.00154464f, 0.01818203f, -0.00014853f, 0.00191151f, 0.02506050f, 0.04196697f, 0.01700942f, -0.01287687f, 
    -0.02973804f, -0.03912709f, -0.01199736f, 0.03191686f, -0.04566775f, -0.02976106f, 0.03257764f, -0.01768207f, 
    -0.00025277f, -0.05203843f, -0.02249287f, 0.01611771f, -0.03308491f, -0.00586971f, -0.03224672f, 0.03278363f, 
    -0.01807425f, -0.03293030f, -0.00743538f, -0.04032385f, 0.00874182f, -0.03026134f, -0.01803073f, -0.01196168f, 
    -0.05171872f, 0.03322104f, 0.04178992f, -0.04219485f, -0.04125705f, -0.05451794f, -0.05535816f, 0.03728554f, 
    0.04480352f, 0.05322199f, 0.00237618f, -0.03609128f, -0.03476062f, 0.03961815f, 0.00743522f, 0.00778416f, 
    -0.04362774f, -0.03352090f, -0.01973221f, -0.00496606f, -0.04230048f, 0.01589994f, 0.03076538f, -0.05512828f, 
    0.03525763f, -0.04139517f, -0.02607633f, 0.04182691f, -0.03614349f, -0.03941547f, -0.02236471f, 0.02846638f, 
    0.00158652f, -0.01009250f, -0.03490436f, -0.04716550f, 0.00951999f, 0.00087803f, -0.03218897f, -0.04092820f, 
    -0.03832478f, 0.05652249f, -0.02180152f, 0.02747558f, -0.03947415f, 0.03966723f, -0.00862027f, -0.00738227f, 
    -0.03023048f, -0.04958394f, 0.02195607f, -0.04385256f, -0.04762143f, 0.02178367f, -0.03846988f, 0.03700000f, 
    0.00739080f, -0.01396307f, 0.00386032f, -0.04603648f, 0.02851345f, -0.02067097f, 0.01173587f, 0.04054101f, 
    0.01946482f, 0.00815304f, 0.03249713f, -0.00293793f, 0.00696461f, -0.01407017f, -0.01935193f, -0.03529109f, 
    0.02374144f, -0.04894565f, -0.00572225f, 0.00222241f, 0.03464580f, -0.02022939f, 0.03765269f, -0.02619324f, 
    -0.02525006f, -0.01299897f, -0.02009725f, 0.02403404f, -0.01242988f, 0.02793330f, -0.03368305f, -0.05512745f, 
    -0.00284184f, 0.00581606f, 0.00987628f, -0.04741679f, 0.02035218f, 0.01710749f, -0.05565600f, 0.04173032f, 
    -0.04400679f, -0.00262179f, -0.04171536f, 0.00729770f, -0.05414117f, 0.04182790f, -0.00470878f, -0.01586902f, 
    0.03910945f, -0.01233035f, 0.03141515f, -0.05084880f, -0.00028761f, 0.01241919f, -0.03909387f, 0.01325986f, 
    -0.00256823f, -0.02482139f, -0.02907834f, 0.03275804f, -0.01655366f, -0.02233274f, -0.04477902f, -0.01427086f, 
    0.02928696f, -0.02771173f, 0.00612470f, 0.04166662f, 0.03167856f, -0.02130296f, 0.02386603f, -0.00677530f, 
    0.02381475f, 0.03593938f, 0.01363476f, 0.04599434f, 0.01492061f, 0.00335134f, -0.05037491f, 0.01128994f, 
    -0.03901339f, -0.01039716f, -0.01931555f, -0.00555305f, 0.01073350f, -0.01161272f, 0.02276180f, 0.00055973f, 
    -0.04702134f, -0.04866654f, 0.03985039f, -0.03040764f, 0.00562602f, 0.03359207f, 0.01515706f, 0.01129824f, 
    -0.02038638f, 0.01687809f, -0.04676560f, -0.03895613f, -0.02124900f, -0.02956258f, -0.05721835f, -0.05650646f, 
    0.01034907f, -0.02374640f, 0.02035606f, -0.03017234f, 0.02309350f, -0.00518235f, 0.00086186f, 0.04320526f, 
    -0.05423402f, 0.01870722f, 0.03385969f, -0.03512451f, -0.04261889f, 0.02687373f, 0.01722631f, 0.02047528f, 
    -0.01500915f, -0.03948481f, 0.00477653f, 0.01009406f, -0.05301370f, -0.00833527f, -0.02502381f, 0.03056630f, 
    0.03506688f, -0.02671531f, -0.04900365f, 0.04855856f, -0.03767248f, 0.04836950f, 0.04054475f, 0.03856402f, 
    0.02298705f, -0.05378994f, -0.05247223f, 0.03291867f, -0.03095448f, -0.05692105f, 0.03732491f, -0.02621092f, 
    -0.00529994f, -0.02805487f, -0.03354520f, -0.04182375f, -0.02330286f, -0.03035386f, -0.03223667f, -0.00427592f, 
    -0.01727097f, -0.01954507f, 0.00679825f, -0.03242422f, -0.01052087f, -0.03223376f, -0.05687304f, 0.03616213f, 
    -0.03566586f, -0.00154970f, 0.00699340f, -0.02252743f, -0.01168695f, -0.05302656f, 0.01965276f, -0.03196947f, 
    -0.03354452f, -0.00614401f, -0.04649933f, -0.00663248f, -0.03635014f, -0.00230782f, 0.03446810f, -0.02212783f, 
    0.03655455f, 0.00850583f, 0.01329240f, 0.01304283f, 0.01881482f, -0.02924914f, -0.03261463f, 0.02931265f, 
    -0.00843562f, -0.13128887f, -0.20355387f, 0.07556002f, 0.09748958f, 0.04404444f, 0.05055441f, 0.01843741f, 
    -0.03840129f, -0.00153752f, -0.00435168f, -0.03352750f, -0.04488682f, 0.02048731f, 0.04104087f, 0.35717788f, 
    -0.04821220f, 0.05747991f, 0.01620072f, -0.07914250f, -0.02967455f, -0.02265079f, 0.04813967f, 0.04407564f, 
    0.26122928f, -0.10462793f, 0.04468511f, -0.10911808f, 0.00745639f, 0.20841655f, 0.07888987f, 0.18286899f, 
    0.00992312f, 0.00508867f, -0.04006650f, 0.13622552f, -0.02367831f, -0.25163049f, -0.29840615f, 0.07873655f, 
    -0.07233290f, -0.08937609f, 0.04007892f, 0.00477208f, 0.02715371f, -0.01404236f, -0.04477947f, -0.03956006f, 
    -0.15153676f, -0.04357978f, 0.04471602f, 0.01168228f, 0.13846554f, 0.08404233f, -0.07875039f, -0.09978266f, 
    0.07785479f, -0.00019814f, 0.00136417f, 0.05957421f, -0.26437044f, 0.06030842f, 0.24898195f, 0.03162915f, 
    0.01304507f, -0.13756503f, -0.00596863f, -0.02030298f, -0.01184487f, -0.04091545f, 0.11628477f, -0.00739362f, 
    0.05032540f, -0.01969294f, 0.10216785f, 0.33354059f, -0.00077277f, 0.11455663f, 0.08860296f, 0.13116993f, 
    -0.01683722f, 0.01541459f, 0.09006568f, 0.05972759f, 0.12581410f, 0.27860567f, -0.27979565f, 0.10010032f, 
    -0.08739778f, -0.00884117f, 0.15762116f, -0.19535100f, 0.07303098f, 0.09210063f, 0.01503567f, 0.02377714f, 
    -0.23959734f, -0.10669076f, -0.10660749f, 0.07740532f, 0.02580731f, 0.09437837f, 0.09144253f, -0.05507331f, 
    -0.01740461f, 0.14403173f, -0.05464379f, 0.07425918f, 0.28969744f, 0.25263920f, -0.24489942f, 0.14580418f, 
    0.05045521f, -0.09618916f, 0.05491760f, -0.12841810f, 0.06374755f, 0.01383028f, 0.06618392f, 0.06568994f, 
    -0.03021009f, -0.02932198f, 0.12820984f, 0.03674525f, -0.04614172f, -0.04768813f, 0.00957847f, 0.12144105f, 
    0.03539670f, 0.05135333f, 0.13084221f, 0.04007780f, -0.15489414f, 0.07466739f, -0.11273537f, -0.21879226f, 
    -0.16535038f, -0.22843400f, -0.09793244f, -0.01898531f, -0.00861541f, -0.06014214f, 0.01534428f, -0.00411515f, 
    0.13334648f, -0.10817605f, -0.32817000f, -0.03448459f, -0.10584848f, -0.07604955f, 0.06752434f, -0.05637801f, 
    0.04579730f, -0.10350240f, 0.05040465f, 0.08619986f, -0.06753477f, -0.03219314f, 0.07162959f, -0.15826502f, 
    -0.12257926f, -0.06753454f, -0.10656099f, 0.05271415f, 0.04715974f, -0.12361219f, 0.00014804f, 0.04199186f, 
    0.51825774f, 0.18873134f, -0.32052195f, -0.15506583f, 0.10941611f, -0.05039414f, 0.20206103f, -0.01734560f, 
    0.03846651f, 0.06517279f, -0.08395879f, -0.06479694f, 0.01741783f, -0.21332909f, -0.13556804f, 0.09155961f, 
    -0.00102269f, -0.03553930f, -0.08152903f, -0.11416972f, -0.10977476f, -0.07581112f, -0.03444613f, -0.00504008f, 
    -0.22003028f, 0.04112152f, 0.15242538f, -0.09567083f, -0.01988559f, 0.08731521f, 0.21792999f, -0.06073816f, 
    0.05849804f, 0.01578378f, 0.06983487f, 0.07320955f, 0.22058654f, 0.05618267f, -0.22929290f, -0.12159040f, 
    -0.00349281f, -0.04174575f, 0.14056906f, 0.03933967f, -0.02118207f, 0.00953520f, 0.17825194f, 0.07775801f, 
    -0.21123412f, -0.08546897f, 0.01452050f, 0.05113631f, -0.00791854f, 0.02957772f, -0.02184956f, -0.01040322f, 
    0.05912654f, -0.04723185f, 0.14648695f, 0.05591388f, -0.22695251f, -0.03767297f, -0.07082264f, -0.11930190f, 
    -0.04549498f, -0.06983051f, 0.12390505f, 0.01339846f, -0.01100600f, 0.24180971f, -0.00338888f, 0.21431190f, 
    0.27256745f, 0.06318910f, 0.00323536f, -0.07834724f, 0.08213356f, 0.03145961f, 0.03714942f, -0.02830961f, 
    0.04774085f, -0.08442315f, 0.02064072f, 0.10382987f, 0.06968654f, 0.03954709f, -0.20213875f, -0.14879709f, 
    -0.05030318f, 0.00985612f, 0.01736678f, 0.02245238f, -0.07549877f, 0.03418038f, 0.20355180f, 0.13218990f, 
    0.31564149f, 0.03187796f, -0.01003657f, -0.16995387f, 0.10159522f, 0.16091135f, 0.07755207f, 0.23015089f, 
    -0.03938914f, -0.01296101f, 0.03168952f, 0.13162023f, -0.27835649f, -0.06624443f, 0.11383574f, -0.17862514f, 
    -0.17932199f, -0.18781672f, -0.23696516f, -0.12389683f, -0.08176890f, -0.18664332f, -0.28521350f, -0.03293256f, 
    -0.37579373f, 0.26385909f, -0.17536700f, 0.61237413f, 0.07309519f, -0.05191767f, -0.07719447f, -0.03310252f, 
    0.02876098f, 0.10729124f, 0.08158229f, 0.14709678f, 0.12715517f, 0.12139728f, -0.09376474f, -0.19320196f, 
    -0.04045296f, -0.07888922f, -0.03130871f, -0.08242133f, -0.07538746f, 0.17188983f, -0.10085526f, -0.08401246f, 
    -0.16786532f, 0.15564243f, -0.01922627f, 0.06200727f, 0.01029214f, 0.14578165f, 0.23731485f, 0.33566105f, 
    0.02984925f, 0.12336329f, -0.08810488f, 0.05238186f, -0.04500606f, -0.16072905f, 0.09834661f, 0.13670404f, 
    0.20441291f, -0.11507508f, -0.23282933f, -0.13330106f, -0.09779341f, 0.10879613f, -0.00848767f, -0.03663448f, 
    0.26152596f, 0.27987364f, -0.07369334f, -0.30590823f, -0.01543859f, -0.01692256f, -0.03027936f, 0.16324535f, 
    -0.03018302f, 0.09684563f, 0.15412861f, 0.13839418f, -0.41486967f, -0.18422641f, 0.04849428f, 0.17990324f, 
    0.11999352f, 0.10523648f, -0.01975109f, 0.05753588f, 0.09713946f, 0.00277096f, -0.03179808f, 0.06724378f, 
    0.28199452f, 0.22489388f, -0.09414024f, -0.29629403f, 0.08099874f, 0.02620684f, 0.15551774f, -0.02699552f, 
    0.10501617f, -0.02878892f, 0.35312527f, -0.11497328f, -0.05538843f, -0.09071923f, 0.01648176f, -0.24808227f, 
    -0.23829812f, -0.18171687f, -0.06087487f, -0.05624448f, -0.18315434f, -0.18128327f, -0.20391670f, -0.00130307f, 
    0.00551600f, 0.03196510f, -0.01098217f, -0.01097436f, 0.00242540f, -0.05426566f, 0.00458906f, -0.03943729f, 
    0.04839404f, -0.03295368f, 0.03569060f, 0.02405214f, -0.05803230f, 0.01117050f, 0.00656056f, -0.02643757f, 
    -0.01750482f, -0.02801619f, 0.03061706f, 0.00677876f, 0.00594298f, 0.00694282f, -0.00311663f, 0.00789887f, 
    -0.02997740f, -0.04516513f, -0.01207316f, 0.01362913f, 0.01096816f, 0.02555838f, -0.03457969f, -0.03767703f, 
    0.01326591f, -0.04855100f, -0.05801074f, 0.03972916f, -0.01440966f, 0.02767194f, -0.01543131f, -0.03190025f, 
    -0.01085826f, 0.03466767f, -0.02727868f, 0.02647229f, -0.04841429f, 0.02050733f, 0.00490838f, -0.04001435f, 
    0.01500090f, 0.04090445f, -0.02624949f, 0.01918591f, 0.03786680f, 0.02588107f, 0.01536308f, -0.02306101f, 
    0.02241755f, 0.02552900f, 0.01401979f, -0.00217544f, 0.01037036f, 0.00545648f, -0.02729042f, -0.02558490f, 
    0.00461061f, 0.00951289f, -0.05119816f, -0.03685373f, 0.02015183f, -0.05823475f, 0.03636892f, -0.03762752f, 
    -0.05938172f, 0.01458104f, -0.04696808f, -0.03435679f, 0.00579082f, 0.03705853f, -0.04893566f, -0.05799796f, 
    0.02703620f, 0.03044643f, -0.02551275f, -0.00422341f, 0.02175536f, 0.02046051f, -0.02850540f, -0.01517501f, 
    0.01330239f, 0.03854356f, -0.03273518f, 0.00251666f, -0.02491521f, -0.00236770f, -0.01904412f, -0.05099281f, 
    0.01814088f, -0.05438535f, 0.00744716f, 0.05042406f, -0.05715672f, 0.03285032f, -0.05626913f, 0.02506906f, 
    -0.00975826f, -0.01774709f, -0.04610078f, 0.00614608f, -0.02066042f, -0.02752465f, -0.04086249f, 0.00849370f, 
    0.00094553f, 0.01165779f, 0.01643785f, 0.04755988f, -0.03059721f, -0.03803470f, -0.00757891f, 0.00211219f, 
    0.01002420f, -0.03163951f, -0.04904797f, -0.03442578f, 0.02364786f, 0.00696568f, 0.02199283f, -0.03697088f, 
    -0.02625983f, -0.03332569f, 0.01646429f, -0.00825455f, -0.03766934f, -0.00291712f, 0.03922902f, -0.04804216f, 
    -0.05344604f, 0.00281448f, -0.02876549f, -0.04459231f, 0.02375905f, -0.04855895f, -0.03594392f, 0.02757862f, 
    -0.05270614f, -0.03259882f, -0.03713016f, 0.01289415f, -0.02132586f, -0.01999558f, 0.00755236f, -0.00290837f, 
    -0.00115979f, -0.02920629f, -0.05837893f, -0.05966613f, -0.04327958f, -0.00946063f, -0.03702683f, 0.00001367f, 
    -0.04399302f, 0.04192343f, -0.02933825f, -0.03680038f, -0.00723730f, -0.05594334f, 0.01783504f, 0.02006305f, 
    -0.05930263f, -0.02905638f, 0.01764176f, -0.01001116f, -0.01188570f, -0.04673775f, 0.03876439f, -0.03376798f, 
    0.01064556f, 0.00405492f, -0.01267646f, -0.02787142f, -0.02299520f, -0.04236902f, 0.00313224f, -0.02776505f, 
    -0.00066135f, 0.00721242f, 0.05006569f, -0.03421123f, 0.01652004f, -0.01188215f, -0.04370027f, -0.01189983f, 
    -0.02562157f, -0.03086345f, 0.01253693f, 0.02495796f, -0.05463280f, -0.01190726f, -0.04562682f, -0.03286918f, 
    -0.05723553f, 0.04166415f, -0.00843819f, 0.03817853f, -0.05880115f, 0.00480355f, -0.04048513f, 0.01504271f, 
    -0.03526856f, 0.03897551f, 0.03087163f, -0.05507117f, -0.03846271f, -0.02133677f, -0.02850142f, -0.05700866f, 
    0.00932189f, -0.00532351f, -0.03270627f, -0.03396722f, -0.00646787f, 0.03071436f, -0.01930535f, 0.01928998f, 
    0.03496037f, 0.00482819f, -0.03780451f, -0.00803003f, -0.00207004f, -0.00323746f, -0.03315984f, -0.01807678f, 
    -0.03010624f, 0.02417704f, -0.01523421f, -0.01720029f, -0.03759740f, -0.00266669f, -0.01584641f, 0.00069257f, 
    0.00794773f, -0.04339247f, -0.04306150f, -0.00495034f, 0.02823922f, 0.01064076f, -0.02739029f, -0.00281471f, 
    -0.00037846f, -0.01915744f, 0.00056950f, -0.00202917f, 0.03466342f, 0.01106814f, 0.00975544f, -0.00279771f, 
    0.01906196f, -0.01906526f, -0.02901024f, -0.05155630f, -0.04546472f, 0.00096210f, 0.01441911f, -0.05842321f, 
    0.01570189f, 0.00457700f, -0.05759175f, 0.02621813f, -0.04770722f, -0.01343848f, 0.00520426f, -0.04133061f, 
    -0.05043302f, -0.02114484f, -0.01326367f, -0.02444887f, -0.01497857f, 0.03754596f, -0.00939819f, 0.01547409f, 
    -0.05436950f, -0.04327656f, 0.01003803f, -0.00132902f, 0.00909328f, -0.01459973f, -0.00575793f, -0.01575958f, 
    -0.01455544f, -0.02175110f, -0.01064902f, -0.05287432f, -0.04673819f, -0.03701957f, -0.03975439f, -0.03907157f, 
    0.03743157f, 0.02247293f, 0.00540806f, -0.01299885f, -0.01259458f, -0.04956069f, -0.02166308f, -0.03359429f, 
    0.03407085f, 0.00722108f, -0.02976041f, 0.00322024f, -0.00449289f, 0.03266968f, -0.05249943f, 0.02983081f, 
    -0.01345130f, 0.02144391f, 0.03629787f, -0.05144156f, 0.02980625f, 0.01829113f, -0.03598741f, 0.00876661f, 
    -0.00172223f, -0.04634027f, -0.04936828f, -0.00682408f, 0.02888152f, -0.02014224f, -0.04049971f, -0.00829916f, 
    -0.05051392f, -0.03179574f, -0.03321091f, -0.00662805f, -0.05977128f, 0.03829549f, 0.00691718f, -0.02340878f, 
    -0.05630676f, -0.04314559f, 0.01860184f, -0.05540967f, 0.01914642f, -0.03276009f, 0.01144884f, -0.05902645f, 
    -0.04922388f, -0.03457403f, -0.04841616f, 0.00961119f, -0.01304411f, -0.03058472f, -0.00128604f, -0.05806123f, 
    -0.01217945f, 0.03985418f, -0.04963887f, -0.03713926f, -0.04834682f, 0.02839958f, 0.00351124f, -0.03648531f, 
    0.00876411f, -0.03183453f, -0.02680357f, 0.00031232f, 0.02193705f, 0.03787286f, -0.05873112f, 0.00434614f, 
    -0.05278369f, 0.02535237f, -0.05282307f, -0.05003817f, -0.04835066f, -0.00587972f, -0.01752270f, 0.04035335f, 
    -0.00459606f, -0.00577577f, 0.03068774f, 0.01396541f, 0.02142095f, -0.03533766f, -0.01374253f, 0.03511770f, 
    -0.25837466f, -0.12807593f, 0.03482446f, 0.15798064f, -0.00825288f, -0.07022052f, 0.04804439f, 0.01838917f, 
    0.09894681f, 0.08491848f, 0.02870098f, -0.04259308f, -0.19455567f, -0.01556574f, 0.14846684f, 0.10634673f, 
    0.01925899f, -0.06508394f, 0.05740540f, -0.12259504f, -0.06044094f, -0.07638500f, 0.08088411f, 0.08924234f, 
    0.11986961f, 0.10077123f, 0.03713467f, 0.16254775f, 0.05688051f, -0.12547757f, -0.09179465f, -0.05847586f, 
    -0.13553682f, 0.00890465f, 0.06265090f, 0.05450926f, -0.04239895f, -0.19166072f, -0.00349370f, 0.12012569f, 
    0.06692297f, 0.02027519f, 0.11889487f, 0.19153999f, -0.00479295f, 0.08360291f, -0.04383313f, -0.15761225f, 
    -0.18784395f, -0.02773640f, 0.10105413f, 0.27607712f, -0.13191485f, 0.06057138f, 0.08015237f, 0.06398244f, 
    -0.07669023f, 0.18535095f, -0.01742958f, 0.05904748f, 0.44570032f, -0.00399317f, 0.23140472f, 0.13383077f, 
    0.05854507f, 0.03394498f, 0.04915693f, 0.03908540f, -0.12761673f, -0.02485825f, 0.01913670f, -0.13020307f, 
    0.20309295f, -0.15907316f, -0.01929538f, -0.00593308f, 0.03992955f, 0.05264967f, 0.03554422f, 0.00896379f, 
    0.03101389f, 0.19276281f, 0.12015930f, 0.20026881f, -0.35707396f, 0.43203804f, -0.01298801f, 0.05736738f, 
    -0.09437653f, 0.00588989f, 0.12975015f, 0.08239324f, 0.07819036f, 0.12342342f, 0.01808417f, -0.09344564f, 
    -0.02238129f, -0.00087066f, -0.18548614f, 0.08506338f, -0.05084173f, 0.02121644f, 0.06493017f, 0.12637697f, 
    0.11140030f, 0.23429754f, -0.01928618f, 0.16628724f, -0.19927290f, 0.08962206f, -0.10748773f, 0.16554219f, 
    0.06845681f, 0.01827552f, -0.07633074f, 0.13684887f, -0.04874048f, -0.11458253f, -0.00035184f, 0.05407552f, 
    -0.02406431f, 0.16946900f, 0.14920494f, 0.00786867f, -0.05994892f, 0.01031367f, 0.07888222f, 0.01901636f, 
    0.01076134f, 0.11221662f, 0.16713326f, 0.07582931f, -0.07555465f, -0.17351122f, 0.10548810f, 0.00294199f, 
    0.02090231f, 0.16281028f, -0.15813947f, 0.02345947f, 0.02137527f, 0.05707835f, -0.03093650f, -0.00498507f, 
    -0.13256386f, -0.11370014f, -0.11832772f, -0.02131654f, -0.10979191f, -0.07432923f, -0.06152801f, 0.04521804f, 
    0.06618575f, -0.00930772f, -0.03279883f, -0.14425242f, 0.17976208f, -0.04092154f, -0.03348908f, -0.06314080f, 
    -0.10650478f, 0.00547798f, -0.01365580f, -0.10242545f, -0.06582420f, -0.05263951f, -0.03960326f, -0.16272824f, 
    0.25838503f, -0.08261571f, -0.09905411f, -0.33888158f, 0.14154559f, -0.10409594f, -0.05953474f, -0.00220756f, 
    0.07222310f, 0.00020936f, -0.02488866f, -0.12762403f, -0.08443036f, -0.18459478f, -0.08164158f, 0.04224357f, 
    -0.01565431f, -0.13269891f, 0.06824076f, 0.09578364f, -0.06786644f, 0.08302100f, -0.07601768f, -0.00659204f, 
    -0.24167866f, 0.35205194f, -0.02691204f, -0.00742763f, 0.06236558f, -0.06058344f, 0.08084229f, -0.11151403f, 
    -0.02497263f, 0.11432066f, 0.07125513f, 0.14131060f, -0.01892605f, 0.12505038f, -0.05350037f, 0.13161957f, 
    0.08357818f, 0.07929052f, -0.03728360f, -0.15681770f, -0.05101413f, 0.09006727f, 0.17527676f, 0.22314525f, 
    -0.20376734f, 0.04777149f, 0.13253455f, 0.18065427f, -0.04219693f, -0.15837622f, -0.06533913f, -0.00667560f, 
    -0.09555823f, -0.09015703f, 0.08562842f, -0.09356797f, 0.04142912f, -0.06641842f, 0.00989812f, -0.01997399f, 
    0.05310015f, -0.03880861f, -0.06279229f, -0.01399583f, -0.08524010f, 0.25212944f, 0.05320448f, -0.02764980f, 
    0.21131907f, 0.27417469f, -0.12875368f, -0.06367056f, 0.04052838f, -0.02759257f, 0.10302958f, 0.03806577f, 
    0.02540598f, 0.00000245f, 0.09658892f, 0.26841599f, 0.02266151f, 0.16679536f, -0.03140604f, 0.14535823f, 
    -0.07720167f, -0.04141801f, -0.28552788f, -0.02082941f, -0.14991145f, -0.20572948f, 0.14388004f, -0.14663281f, 
    0.38651842f, -0.22751878f, 0.04976413f, 0.05321947f, 0.15768567f, -0.02733490f, 0.02266637f, -0.08800700f, 
    0.12032213f, 0.00201941f, 0.09891132f, -0.04172324f, 0.36550096f, 0.03557345f, -0.15348394f, -0.04357073f, 
    -0.01892169f, 0.06274263f, -0.01202901f, -0.15977411f, -0.07903439f, -0.22894488f, -0.10373869f, -0.18834496f, 
    -0.28680077f, -0.00468082f, 0.38532308f, 0.08295037f, 0.01112442f, -0.05150165f, 0.02196574f, -0.03134288f, 
    -0.07280953f, 0.02678130f, 0.13850075f, -0.13815516f, -0.18119070f, 0.13769440f, -0.04003588f, -0.07181514f, 
    0.15034476f, 0.01204962f, -0.03966458f, -0.17414929f, 0.02679205f, 0.13239762f, -0.08728377f, -0.07079657f, 
    0.12221139f, 0.00511562f, 0.13478307f, -0.09035540f, 0.11062865f, 0.02492938f, -0.02434894f, -0.12001840f, 
    0.11824565f, 0.15496303f, -0.01948378f, 0.12130582f, -0.09094585f, -0.18291202f, 0.24713373f, 0.17280363f, 
    -0.07824374f, 0.08000458f, -0.07351370f, -0.11293086f, -0.00071131f, 0.01112060f, -0.07916205f, -0.17701390f, 
    -0.40397036f, 0.30677643f, -0.23403944f, -0.22896454f, 0.09807453f, 0.17781577f, -0.13283169f, 0.01810290f, 
    -0.13311347f, 0.10015391f, 0.02893786f, -0.02197017f, 0.11239329f, -0.11860196f, 0.14876676f, 0.19107705f, 
    -0.02272363f, 0.12273721f, 0.11615126f, 0.25258282f, 0.04183896f, -0.12451270f, -0.13840641f, -0.00349838f, 
    -0.03870624f, 0.11709788f, 0.03825280f, -0.00131888f, -0.04889500f, -0.08242483f, -0.09777828f, -0.12141038f, 
    -0.00210946f, 0.16736929f, 0.12706520f, -0.16195154f, 0.04922218f, -0.02079460f, -0.22124790f, -0.15209629f, 
    -0.12494867f, 0.05271910f, -0.05545637f, 0.11642350f, 0.10205658f, 0.07541496f, -0.05505673f, 0.00903011f, 
    0.02141402f, 0.02485975f, -0.01433524f, -0.04123772f, 0.04282722f, -0.00437834f, -0.04348882f, -0.02153921f, 
    -0.03031737f, 0.01980385f, 0.01941098f, -0.01733601f, 0.00975856f, 0.04820582f, 0.02654099f, -0.05635199f, 
    -0.01823859f, 0.00135130f, 0.00464561f, -0.03687939f, 0.00175565f, -0.01181634f, 0.04369729f, 0.01080118f, 
    -0.01169489f, -0.04008681f, -0.02750427f, 0.03961530f, -0.05232366f, 0.03510281f, 0.02930725f, 0.02629487f, 
    -0.03146068f, 0.03071508f, 0.00011909f, 0.03540419f, 0.01925115f, -0.00327726f, -0.00966309f, 0.01306843f, 
    -0.03393961f, 0.01208879f, 0.04072175f, 0.01337019f, 0.02251264f, 0.00514334f, -0.04311241f, -0.00082397f, 
    -0.00216971f, -0.02265101f, -0.04323187f, -0.02881740f, -0.01975466f, 0.01790149f, -0.00750770f, -0.04596906f, 
    -0.02002669f, -0.04005305f, 0.03863306f, 0.00149842f, 0.00174430f, 0.00830524f, -0.05707733f, -0.00672356f, 
    0.00982415f, 0.02049801f, -0.05338386f, -0.03119474f, -0.03537637f, -0.02752528f, 0.00582299f, -0.02509315f, 
    0.03230206f, 0.01637617f, -0.03776442f, -0.04172739f, -0.02161969f, 0.04180766f, -0.01897880f, -0.04001905f, 
    -0.00694143f, 0.04343393f, -0.05715191f, -0.00433917f, -0.04552854f, 0.02663138f, -0.05186874f, 0.00748577f, 
    -0.01748631f, -0.04425599f, 0.02920645f, -0.01829668f, 0.01217307f, 0.02818589f, -0.04116756f, 0.01565174f, 
    -0.00535577f, 0.00243750f, 0.00040878f, -0.00599194f, 0.02453480f, 0.03997751f, -0.00769833f, -0.02131011f, 
    0.03551913f, 0.04786919f, -0.03990182f, -0.03896739f, 0.00714403f, 0.03280141f, -0.00952829f, -0.05103150f, 
    -0.02687997f, 0.02469158f, 0.00142395f, 0.03646906f, -0.04835722f, -0.05153828f, 0.00847836f, -0.01251874f, 
    0.00038198f, 0.01665607f, 0.02329126f, -0.05359341f, -0.06042903f, 0.04334239f, -0.00163839f, -0.05725177f, 
    -0.05157819f, -0.04296605f, -0.05976470f, -0.00343239f, 0.02370098f, -0.01478707f, 0.03764122f, -0.04236357f, 
    0.00117929f, -0.03312248f, -0.02384756f, -0.00145204f, 0.01934854f, -0.01712450f, -0.01667828f, 0.02945623f, 
    0.03182613f, -0.02684106f, 0.04673984f, -0.05343662f, -0.00254045f, 0.03863630f, -0.04627792f, -0.00062326f, 
    -0.01429466f, 0.04242196f, 0.00868838f, 0.01703744f, 0.02625043f, -0.00361923f, -0.05042700f, -0.03741143f, 
    0.01160127f, 0.01733184f, -0.05109103f, -0.05259752f, -0.04985662f, 0.02239082f, 0.03737459f, 0.00612419f, 
    0.03886190f, 0.03813217f, -0.01666032f, 0.04292395f, 0.01763941f, -0.00861079f, 0.00896365f, -0.00980414f, 
    0.01291250f, -0.05629329f, 0.00056997f, -0.00151382f, 0.00001461f, -0.03186299f, -0.03840237f, 0.01062852f, 
    0.04771263f, -0.02672786f, -0.01970938f, -0.02029638f, -0.01474706f, 0.00282634f, -0.03015352f, -0.03003608f, 
    -0.05950204f, 0.02848800f, -0.01379379f, -0.05785558f, 0.03901640f, 0.01923638f, 0.00677748f, -0.05185324f, 
    0.01769499f, -0.00061604f, 0.00723585f, -0.02944304f, -0.00595893f, 0.03396697f, 0.02516053f, 0.01376747f, 
    0.01204863f, 0.03341174f, -0.00614286f, 0.02671812f, 0.01110645f, -0.03369341f, -0.04064430f, 0.04097098f, 
    -0.02490475f, -0.00656793f, -0.05227211f, 0.00965584f, -0.04872404f, 0.00823069f, -0.04156645f, 0.03443783f, 
    0.03326667f, -0.02732064f, 0.04176685f, -0.04750355f, -0.02945712f, 0.02209276f, -0.04759905f, -0.04458543f, 
    0.02799557f, -0.00774032f, -0.03313606f, 0.02741248f, -0.03041353f, -0.00784559f, -0.02870238f, 0.00293661f, 
    -0.02518733f, -0.05355647f, 0.00958450f, -0.01051527f, -0.00601928f, -0.04710914f, -0.01952995f, -0.03962504f, 
    -0.01036525f, -0.00604519f, -0.03712062f, -0.04112210f, -0.04488086f, 0.01035530f, 0.02000374f, 0.03018270f, 
    -0.02132387f, 0.03337507f, -0.03413370f, -0.00189538f, -0.05509156f, -0.03406531f, 0.03953648f, -0.05934469f, 
    -0.04012821f, 0.01643916f, 0.03198645f, -0.02713617f, -0.00735150f, 0.03378852f, 0.04038112f, -0.04002021f, 
    0.01607942f, 0.00207227f, 0.01176966f, 0.03021471f, -0.03912755f, 0.02408169f, 0.01211232f, -0.02517633f, 
    0.01949137f, 0.01838253f, -0.02230021f, 0.03827398f, -0.05676450f, 0.00874138f, 0.02192066f, 0.00132355f, 
    0.01792144f, 0.02604795f, -0.05297443f, 0.01058171f, -0.00889843f, -0.00396358f, 0.00965491f, -0.00329181f, 
    0.01551285f, -0.05010463f, 0.04290834f, -0.02992218f, -0.01166821f, -0.01883131f, -0.01334213f, -0.01056801f, 
    -0.03169588f, 0.02304071f, 0.02716161f, -0.00441261f, -0.03754246f, 0.02409594f, -0.02745710f, -0.02274908f, 
    -0.02881670f, -0.05435458f, 0.03086742f, -0.04815332f, -0.03009662f, -0.02701872f, -0.05344649f, 0.00995550f, 
    -0.05431483f, -0.02427072f, -0.03947929f, -0.02916804f, -0.00816005f, 0.00710727f, -0.05453693f, 0.00418122f, 
    0.02494089f, 0.01447431f, -0.02352681f, -0.00870578f, -0.03312056f, -0.02142407f, -0.02950108f, -0.01121013f, 
    0.03623854f, -0.01420532f, -0.00797947f, 0.00188383f, 0.02897151f, -0.03587507f, 0.00661893f, -0.01265368f, 
    0.00168840f, -0.04394700f, 0.00228682f, -0.01015215f, -0.00470605f, -0.04992627f, -0.03838041f, -0.04115725f, 
    -0.01541896f, -0.02919594f, 0.00108911f, -0.04640391f, -0.00194257f, -0.02298081f, -0.00861312f, 0.02876945f, 
    0.00483380f, 0.00099195f, -0.00597107f, 0.02074492f, -0.00947127f, -0.04032437f, -0.03770265f, -0.03999316f, 
    -0.01615860f, -0.00555806f, -0.03860973f, 0.03820005f, 0.03952438f, 0.00521781f, -0.00883288f, -0.02661194f, 
    0.03179643f, -0.03871662f, -0.05839475f, -0.04331293f, 0.03907610f, -0.05541418f, -0.05510764f, -0.01314559f, 
    0.24757898f, 0.03771759f, 0.05294606f, 0.17334598f, -0.07062301f, 0.16030094f, 0.05028751f, 0.01069658f, 
    0.07262503f, 0.07972764f, -0.01725030f, 0.00701501f, 0.31602210f, 0.27477911f, 0.08284188f, 0.29989657f, 
    0.00783559f, 0.09203652f, 0.07368214f, 0.12701812f, 0.12134144f, 0.01866535f, 0.10962804f, -0.02992771f, 
    -0.04114200f, 0.18357144f, 0.13594221f, -0.15196328f, 0.06226193f, 0.12400360f, 0.01770502f, 0.06816585f, 
    0.00753945f, 0.09865860f, -0.00570071f, 0.03366906f, 0.22997126f, 0.11145917f, 0.02345716f, 0.08133699f, 
    0.00515841f, 0.20379317f, -0.25404716f, 0.03241397f, -0.03937167f, -0.00641263f, 0.03425485f, 0.11736722f, 
    0.04527824f, -0.01119259f, -0.04384837f, -0.37365308f, 0.11705386f, -0.07548580f, -0.18448395f, 0.03072020f, 
    -0.00816944f, 0.02514336f, 0.06403507f, 0.07355273f, -0.17690249f, 0.05769417f, -0.12659988f, 0.02474434f, 
    -0.15662938f, 0.00552124f, -0.04900012f, -0.06247612f, -0.04572687f, -0.06325668f, -0.03976396f, 0.03614602f, 
    0.03129902f, 0.14628860f, 0.19204909f, 0.09404773f, 0.00594853f, 0.09484684f, -0.05233062f, -0.07566009f, 
    0.01467849f, 0.02474194f, -0.08336177f, 0.06952015f, 0.07524281f, 0.02214073f, -0.02039759f, 0.06063494f, 
    -0.21344523f, 0.11744653f, -0.07683604f, 0.08445203f, 0.00836373f, -0.10714847f, 0.08516885f, 0.00996825f, 
    0.11957967f, 0.17504683f, 0.25233948f, 0.10839021f, -0.02433963f, 0.07413992f, 0.01236952f, 0.01362702f, 
    0.02507792f, -0.01968701f, 0.05600761f, 0.13070302f, 0.28264451f, -0.15300302f, 0.07669080f, 0.33930790f, 
    0.13096140f, 0.15758190f, 0.07596908f, -0.16478550f, -0.01383369f, 0.02215477f, -0.00288884f, -0.07964174f, 
    0.10919864f, -0.01318747f, 0.02360081f, 0.00677174f, 0.06094274f, -0.04093420f, -0.07780080f, -0.09846418f, 
    -0.05708827f, -0.13221815f, -0.01121913f, 0.04006653f, -0.07277254f, 0.03387411f, -0.10875475f, -0.14576568f, 
    -0.13206093f, -0.00661890f, -0.01724832f, -0.15878500f, -0.14673175f, -0.00883273f, -0.00826173f, 0.04623031f, 
    0.15295346f, 0.08191645f, 0.11506484f, 0.05569739f, -0.03346188f, 0.13135934f, 0.01711039f, -0.07716592f, 
    -0.01269753f, 0.06425463f, -0.03044573f, -0.04087364f, -0.15481244f, 0.05873808f, -0.05893736f, 0.08737098f, 
    0.02628499f, -0.04622256f, -0.02514235f, -0.05116466f, -0.06375208f, 0.06672210f, -0.05479294f, -0.03993420f, 
    -0.05279633f, 0.04620420f, 0.21870191f, 0.03224839f, 0.02954315f, 0.02275135f, 0.00016989f, -0.03275102f, 
    -0.07397865f, 0.02591822f, 0.03808179f, 0.20577259f, 0.16177903f, 0.17405410f, 0.13939799f, 0.16074930f, 
    0.11727674f, 0.11193701f, 0.06761094f, -0.06755507f, -0.05148502f, 0.05438082f, 0.03929586f, 0.01869904f, 
    0.10029614f, 0.15012898f, -0.07529169f, 0.19387674f, 0.01244841f, 0.02447763f, -0.14389938f, -0.07509513f, 
    0.08831717f, 0.02626906f, -0.00965432f, 0.05247303f, 0.09657798f, 0.06583039f, -0.04399125f, -0.10169174f, 
    -0.03743669f, 0.10239969f, -0.00055280f, -0.00117997f, 0.03724708f, 0.12321173f, -0.06613085f, -0.03528168f, 
    -0.02300711f, 0.20802763f, -0.07436246f, 0.13697809f, -0.06592941f, 0.10667044f, -0.02541005f, 0.07789260f, 
    0.05931117f, -0.05194113f, -0.03187291f, -0.00859451f, -0.18063346f, 0.20652281f, -0.19134346f, -0.12420843f, 
    -0.04068999f, -0.00901836f, -0.11517393f, -0.02864226f, 0.05066563f, -0.06250889f, -0.00679029f, 0.07010777f, 
    -0.29012215f, 0.10399747f, -0.03994105f, -0.14002560f, 0.00979105f, 0.07238973f, -0.04883604f, 0.16682407f, 
    -0.02981087f, 0.02228290f, -0.03839544f, -0.02847534f, 0.03414977f, -0.10996713f, 0.06340062f, -0.01891355f, 
    0.03086740f, 0.03695632f, 0.06214000f, 0.05586169f, -0.07493890f, 0.18461674f, 0.02663022f, 0.18623909f, 
    -0.05658432f, 0.20947915f, 0.03096676f, 0.07112280f, 0.03130587f, 0.07926092f, -0.05612956f, -0.09213190f, 
    -0.20425811f, 0.27412385f, -0.08807871f, -0.07393277f, -0.13708985f, -0.05967508f, -0.19645619f, 0.04688102f, 
    0.00618355f, -0.15378468f, -0.09622361f, -0.09588233f, -0.13070944f, 0.09500308f, -0.00695785f, -0.10865826f, 
    0.27523381f, 0.07509563f, -0.02508363f, 0.31917533f, 0.02154053f, -0.07978977f, 0.04427883f, -0.04241520f, 
    0.06590325f, 0.03369284f, -0.08621651f, -0.01613858f, -0.02097783f, -0.02741393f, 0.00155931f, 0.03320402f, 
    -0.11383106f, -0.03979577f, 0.05171543f, -0.04230540f, -0.01855489f, -0.11474995f, -0.03674693f, -0.00163160f, 
    -0.15156956f, -0.01925229f, 0.06326363f, -0.01784199f, -0.07520900f, -0.08674254f, -0.06156242f, -0.08898846f, 
    0.01062059f, 0.04281205f, 0.03543625f, -0.04619754f, 0.22812031f, -0.07727209f, 0.06499702f, 0.16482435f, 
    0.10413773f, -0.13887781f, 0.10292106f, 0.01158720f, -0.12087524f, 0.11631352f, 0.12103940f, 0.02847404f, 
    0.11544341f, -0.00431167f, -0.07820591f, 0.23540945f, 0.01390485f, -0.13917297f, 0.09679136f, -0.05836210f, 
    -0.09761222f, 0.02266125f, -0.05357027f, 0.11146703f, 0.12408955f, 0.12855995f, -0.02030083f, 0.23851722f, 
    -0.00758482f, 0.07824177f, 0.03247038f, -0.17070846f, 0.00857686f, 0.01583731f, 0.05450644f, -0.00485147f, 
    0.11501142f, 0.01949488f, 0.31032169f, -0.21503398f, -0.12943958f, 0.09790154f, 0.02449898f, -0.11876687f, 
    -0.03368908f, -0.14381163f, -0.00216296f, 0.14055465f, -0.07918806f, -0.08245454f, -0.11636398f, -0.08694188f, 
    -0.06616624f, -0.12047538f, -0.08491100f, -0.05930239f, -0.16380128f, 0.04274204f, -0.12314981f, 0.03821612f, 
    0.24479321f, 0.23081559f, -0.12110403f, -0.09254445f, 0.09633434f, 0.08021241f, 0.03609688f, 0.10716576f, 
    -0.11981919f, -0.09130171f, -0.06000011f, -0.00843326f, -0.15654966f, -0.38263601f, -0.01675804f, 0.20026271f, 
    0.06226820f, 0.00566446f, -0.00809306f, 0.14692017f, 0.04155069f, -0.11685903f, 0.22896169f, 0.09562508f, 
    -0.06441005f, -0.16144417f, -0.23297320f, 0.20347902f, 0.06328553f, 0.01932407f, -0.02787493f, -0.01833719f, 
    0.13373640f, 0.07339536f, -0.00369765f, 0.09594646f, 0.24044061f, 0.28094900f, 0.03382103f, 0.03673963f, 
    0.03189296f, -0.06632344f, 0.05711498f, -0.05908630f, 0.06199683f, -0.04156669f, 0.04038377f, 0.02540850f, 
    0.24352391f, 0.18228115f, 0.09128787f, 0.19013812f, 0.06705299f, 0.24199681f, 0.06099116f, 0.04385507f, 
    -0.07201909f, 0.05644697f, 0.02281373f, 0.01546393f, 0.02725315f, -0.07327541f, 0.12208533f, 0.18487906f, 
    0.14478318f, -0.07835121f, -0.01344985f, -0.09026033f, 0.10229298f, -0.00325175f, -0.04416862f, 0.12037813f, 
    0.04522578f, -0.10540408f, -0.06038164f, 0.08318266f, 0.11994231f, 0.14936264f, -0.05694662f, 0.15818599f, 
    -0.04611210f, 0.00132819f, 0.07429256f, -0.05400146f, 0.17166066f, -0.13492885f, -0.02375304f, -0.16066012f, 
    0.15313047f, -0.13565347f, 0.09750765f, -0.04995646f, 0.05146934f, 0.00013149f, -0.10440543f, -0.15850882f, 
    0.20371176f, 0.06874260f, 0.03699197f, 0.10462756f, -0.02678586f, 0.03645035f, 0.04766390f, 0.08955383f, 
    0.02860246f, 0.08216919f, -0.10822910f, 0.04331826f, 0.44105569f, 0.48005471f, -0.26349309f, -0.06751319f, 
    0.09612065f, 0.07682739f, 0.16654761f, -0.00286489f, -0.07753578f, -0.05136187f, -0.01894946f, 0.05472041f, 
    -0.29523808f, -0.32791653f, -0.13282534f, 0.15622221f, 0.01467600f, 0.09990217f, -0.00426360f, 0.04008409f, 
    0.13713907f, -0.01883862f, 0.00323999f, -0.00017003f, -0.42154729f, -0.16462749f, -0.03738743f, -0.03022161f, 
    0.05170485f, -0.02235799f, -0.07803512f, 0.01081140f, -0.03219651f, 0.02283024f, 0.03180145f, -0.01246714f, 
    0.41998649f, 0.04806409f, 0.04195110f, -0.02115975f, 0.12962633f, -0.00529338f, 0.08396186f, 0.08411570f, 
    0.09031834f, -0.03004457f, -0.00781882f, 0.01021170f, -0.11670885f, -0.13455069f, -0.02884326f, -0.21076646f, 
    0.05440361f, -0.08780652f, -0.07165020f, -0.06098654f, 0.04495306f, -0.01806866f, 0.01884902f, -0.02080930f, 
    0.23203607f, -0.06157965f, -0.14468136f, -0.03358429f, -0.03506799f, -0.24301054f, -0.06316588f, 0.08235478f, 
    0.09828535f, -0.08737238f, -0.14139982f, 0.00903553f, 0.17716533f, 0.10490334f, -0.07218324f, 0.01700016f, 
    0.01577140f, -0.07861172f, 0.00313140f, 0.08777230f, 0.02960615f, -0.04805082f, 0.06392112f, 0.11372491f, 
    -0.17693989f, -0.38556463f, -0.35023353f, -0.17455269f, 0.07136096f, 0.07971907f, -0.02481009f, -0.04016991f, 
    -0.02421876f, -0.09314454f, 0.11227538f, -0.04398224f, 0.09362894f, 0.17807081f, 0.01775950f, 0.01039168f, 
    0.06679063f, -0.04760483f, -0.01602113f, -0.05471818f, -0.18052734f, -0.04564776f, -0.04858672f, 0.03553383f, 
    -0.06278428f, -0.37918571f, -0.17833345f, -0.09262122f, -0.05619145f, 0.02420059f, -0.05884971f, -0.20843913f, 
    0.14466678f, -0.00618938f, -0.02686864f, 0.03265560f, 0.06766117f, -0.32188728f, -0.19715962f, -0.08823784f, 
    0.01336891f, -0.09502442f, 0.07993060f, 0.06195642f, 0.03221744f, 0.01926700f, -0.01456372f, 0.03775544f, 
    0.15596941f, -0.07191960f, 0.19433306f, -0.09237348f, 0.06333849f, -0.02754005f, 0.11956341f, -0.03884915f, 
    0.12280267f, -0.11155719f, 0.07101870f, -0.03844527f, -0.05342105f, -0.07545169f, -0.05975614f, -0.07923460f, 
    -0.05095616f, -0.08049107f, -0.08915796f, 0.03355746f, 0.08342353f, 0.01151955f, -0.04977133f, 0.00126764f, 
    0.06558350f, 0.06193197f, -0.17511639f, -0.36313722f, 0.11911879f, 0.17422803f, 0.16122715f, 0.02649797f, 
    0.00242896f, -0.06599285f, -0.07389672f, 0.03947835f, -0.26422825f, -0.13496782f, -0.01502683f, -0.12155537f, 
    -0.01518584f, 0.03349844f, -0.02630522f, -0.00330697f, 0.06173803f, -0.06043963f, -0.02257540f, -0.06551185f, 
    -0.24793053f, -0.40245029f, -0.07911597f, 0.10522354f, 0.04543378f, 0.04568789f, -0.15601145f, -0.06818612f, 
    -0.03906691f, 0.00922682f, 0.15201227f, 0.18025486f, 0.19855908f, -0.12932052f, 0.01276159f, -0.27636877f, 
    0.01509314f, -0.10048993f, -0.02842217f, -0.08472391f, 0.02753051f, 0.10348113f, 0.07154258f, 0.10972836f, 
    -0.06283094f, -0.39467421f, -0.15715131f, 0.00945437f, 0.19126253f, 0.09166401f, 0.06728262f, 0.07646441f, 
    -0.07742810f, 0.03774516f, 0.15741494f, 0.13450526f, 0.02154224f, 0.21873157f, -0.06742319f, 0.01518240f, 
    -0.11048064f, -0.04503661f, 0.01903589f, -0.02429730f, 0.02903700f, 0.00377818f, 0.07304022f, -0.03290341f, 
    0.13335924f, 0.01426130f, 0.01490236f, -0.33355093f, -0.04873285f, 0.12212101f, 0.05814132f, -0.09109817f, 
    -0.02228605f, 0.00948685f, 0.03185719f, 0.04846447f, 0.22222364f, 0.00694007f, 0.00120772f, 0.01263566f, 
    0.16501234f, 0.05075232f, 0.14359111f, 0.02365395f, 0.04557106f, -0.07959488f, 0.01120088f, -0.01410008f, 
    -0.03350853f, -0.00292504f, -0.28175581f, 0.13963613f, -0.08464701f, -0.13739154f, 0.08395126f, 0.10945125f, 
    0.04136670f, 0.06406233f, -0.10037817f, 0.21992847f, -0.20852984f, -0.09384079f, -0.12644164f, -0.06192958f, 
    0.03489303f, 0.00605370f, -0.05606090f, -0.05056221f, -0.05345158f, -0.00549953f, 0.14550801f, 0.11745235f, 
    0.30539063f, 0.23147787f, 0.10937806f, 0.08125166f, 0.05623952f, -0.14492767f, 0.15698352f, 0.05805124f, 
    0.19403915f, 0.18375652f, 0.07828809f, -0.01223586f, -0.02798235f, 0.02142080f, 0.17326599f, -0.31955409f, 
    -0.07512032f, 0.01443832f, -0.17616630f, -0.22400653f, -0.03278831f, -0.04087651f, -0.10173926f, 0.08344750f, 
    0.46437201f, 0.15146860f, 0.15092342f, 0.22955689f, 0.01754147f, -0.12549967f, 0.02930490f, -0.21523209f, 
    0.03734345f, -0.00797812f, 0.06176662f, 0.14984979f, 0.00861136f, 0.15410499f, -0.00931696f, 0.10406362f, 
    0.06449763f, 0.07827021f, 0.06634068f, 0.09578654f, 0.08524258f, -0.04938560f, 0.02749212f, 0.00072623f, 
    0.07123174f, 0.24727006f, -0.07238135f, 0.14225802f, -0.06687497f, -0.00748233f, 0.05067668f, 0.08421928f, 
    0.00711141f, 0.05127890f, 0.06656930f, 0.00342966f, -0.04622687f, 0.14741229f, 0.23394428f, -0.07575116f, 
    0.12239032f, -0.02033946f, -0.06670675f, 0.04709100f, -0.14291947f, -0.04713539f, -0.07357406f, -0.27208966f, 
    -0.18594617f, 0.04498758f, -0.12699290f, 0.22354223f, 0.07328355f, 0.00624526f, 0.08289592f, -0.12863378f, 
    0.09605231f, 0.09583936f, 0.12989211f, 0.30338168f, -0.11664120f, -0.10057127f, -0.03446457f, -0.12954454f, 
    -0.09863181f, 0.06558380f, 0.06548452f, -0.16767821f, 0.05658613f, 0.04291861f, -0.17462505f, 0.08806722f, 
    0.00450498f, 0.04656247f, 0.00052336f, -0.00750015f, 0.07130160f, 0.17278643f, 0.07701581f, -0.04314089f, 
    0.00978595f, -0.01178652f, 0.16440143f, 0.25418389f, 0.04073915f, -0.22539322f, 0.12830032f, -0.30805504f, 
    0.06889481f, 0.03986650f, -0.10429911f, 0.22606565f, 0.03121278f, -0.08043183f, 0.04211893f, 0.01916068f, 
    -0.09835578f, 0.14698847f, 0.04415624f, -0.02352770f, -0.09480250f, -0.04344963f, -0.16263807f, -0.09982981f, 
    -0.01688353f, 0.30038357f, 0.11445618f, 0.22939003f, 0.09767366f, 0.06193751f, 0.08966632f, 0.09603339f, 
    0.08309252f, -0.10281245f, -0.11752469f, 0.05842393f, 0.19649677f, -0.25958952f, 0.09541633f, 0.13491574f, 
    -0.05976479f, 0.00545677f, -0.08524408f, -0.07412305f, -0.02330467f, -0.07750481f, 0.02119293f, 0.03036392f, 
    -0.02715049f, -0.06116262f, 0.09427835f, -0.13000140f, -0.12139186f, -0.22170863f, -0.05959560f, -0.07760376f, 
    -0.02346551f, -0.00579058f, -0.17024738f, -0.12592331f, -0.27467093f, -0.19402486f, -0.23485552f, -0.27005368f, 
    -0.21460067f, 0.17543729f, -0.40087304f, -0.19742423f, 0.04722301f, 0.15975212f, -0.01843534f, -0.29094493f, 
    0.01682496f, -0.06123769f, -0.22577594f, -0.17393973f, -0.00198091f, 0.11187310f, -0.00095373f, 0.07373504f, 
    -0.00318206f, -0.01005325f, -0.02903399f, 0.13973995f, -0.12778205f, -0.14770187f, 0.00615153f, 0.05521052f, 
    0.18154858f, -0.36430413f, 0.24625097f, -0.02142546f, -0.19604650f, -0.05441798f, -0.00931483f, -0.20602612f, 
    0.24305759f, 0.08893645f, 0.01591614f, 0.17938146f, 0.04882982f, -0.14784655f, 0.03759125f, 0.23778470f, 
    -0.05649354f, -0.00253658f, -0.01972966f, 0.06391597f, 0.18025763f, 0.06295907f, 0.23479804f, 0.25018257f, 
    0.29926932f, -0.06872901f, 0.11432310f, 0.00073537f, 0.02424773f, -0.09711785f, -0.02856513f, -0.27951932f, 
    -0.07084821f, -0.12891977f, -0.12440222f, -0.00869639f, -0.06678558f, -0.17584968f, 0.32450289f, -0.23642038f, 
    0.05200161f, 0.03861339f, -0.07030085f, -0.29456484f, 0.01775250f, 0.07327648f, -0.07013374f, 0.04198107f, 
    0.35391873f, 0.11994298f, 0.00203616f, -0.01739431f, -0.12171403f, -0.05376531f, 0.02024625f, -0.02124948f, 
    0.10438295f, 0.04941450f, -0.02161160f, 0.25621769f, 0.03768649f, 0.07493079f, 0.05009122f, 0.11169638f, 
    0.03487539f, 0.07641033f, -0.09606681f, -0.26448536f, -0.05270893f, -0.17183842f, -0.08161793f, -0.12630092f, 
    0.58587366f, -0.09459978f, 0.08010761f, 0.14172733f, -0.10360153f, 0.07165133f, -0.09911713f, 0.05399653f, 
    0.26054087f, -0.11633959f, -0.03043746f, 0.16791257f, 0.02538543f, -0.12566306f, 0.06787083f, -0.18100739f, 
    0.00671347f, 0.07228581f, -0.16943872f, -0.13600206f, -0.08239849f, -0.24760516f, -0.13628525f, -0.02056339f, 
    -0.34924486f, -0.00305356f, 0.16988157f, -0.35872409f, -0.03746957f, -0.02452847f, -0.06957744f, -0.04837993f, 
    0.03855985f, 0.07822032f, -0.05782067f, -0.04292282f, 0.07723606f, 0.01781026f, 0.14460254f, 0.05681396f, 
    0.11402762f, 0.06884264f, -0.06070729f, -0.01587048f, -0.08703121f, -0.07635017f, -0.11833391f, -0.05910632f, 
    0.39953595f, 0.31380850f, 0.03858109f, 0.13223363f, -0.20305991f, -0.03856209f, 0.20337722f, -0.05801947f, 
    0.09159420f, 0.11383978f, 0.04556755f, 0.13277201f, 0.01796788f, 0.13773617f, -0.14484449f, 0.08403936f, 
    0.07536647f, 0.07230564f, 0.01633751f, 0.16924866f, -0.02348328f, -0.05730091f, -0.05428894f, -0.13973528f, 
    0.48785996f, -0.13151917f, 0.27875373f, -0.19388178f, -0.12713274f, -0.03385971f, -0.09539602f, 0.06241165f, 
    0.08949846f, 0.03778065f, 0.03211376f, -0.13764954f, 0.03886951f, 0.19593018f, 0.10618327f, -0.16816245f, 
    0.07733322f, 0.01610702f, -0.01763216f, 0.18995790f, 0.03665430f, -0.05483944f, -0.15695995f, -0.23672135f, 
    -0.04168743f, 0.30800205f, -0.17656921f, 0.01887930f, 0.08103953f, -0.03687888f, -0.08545830f, -0.05511393f, 
    -0.13679636f, 0.01591505f, -0.02241784f, -0.21067658f, -0.15222432f, -0.14036247f, 0.07660551f, 0.16326477f, 
    -0.14835960f, -0.02191618f, 0.19740714f, -0.20353353f, 0.00680999f, -0.00799044f, 0.11035693f, 0.17704979f, 
    -0.36838305f, -0.31572670f, 0.17084369f, 0.06154644f, -0.10370886f, -0.12937374f, -0.05408840f, 0.05287635f, 
    0.03472676f, -0.07451872f, 0.00943247f, -0.00620982f, -0.05202067f, 0.18780641f, 0.09018186f, -0.02796165f, 
    -0.01380395f, -0.00864197f, 0.09411734f, 0.03015042f, -0.07726908f, 0.11827546f, 0.02714402f, 0.01563623f, 
    0.00015702f, 0.10451357f, -0.02613459f, 0.14510202f, -0.03346658f, -0.07473750f, -0.03584353f, -0.06670181f, 
    0.04175640f, 0.06021015f, 0.11094253f, 0.07446248f, -0.26194382f, -0.28640535f, -0.01391699f, -0.08101634f, 
    -0.00119836f, -0.05137272f, 0.22634070f, 0.09339035f, 0.13099173f, 0.20417884f, 0.04953241f, -0.01907858f, 
    -0.09486657f, -0.08506971f, 0.05106497f, 0.25823247f, 0.04066997f, 0.08207726f, 0.13742688f, -0.00409904f, 
    0.05198022f, 0.04963010f, -0.02355401f, -0.04439052f, 0.17792059f, -0.10096024f, 0.00735705f, -0.12529072f, 
    0.05942362f, 0.06052181f, 0.08394514f, 0.08437438f, 0.00970611f, 0.03034139f, 0.02254543f, -0.06863102f, 
    0.18605688f, -0.04710868f, -0.01792195f, -0.00537527f, 0.02127935f, -0.08819164f, 0.11298008f, 0.02475885f, 
    0.07408356f, 0.12107689f, 0.00166408f, -0.08067691f, -0.20303178f, 0.06836423f, 0.06626174f, 0.06136548f, 
    0.17994376f, 0.04879249f, -0.03629768f, 0.24399161f, 0.00100708f, 0.05004092f, 0.09059376f, 0.00140349f, 
    -0.08485164f, -0.09789366f, -0.10381570f, 0.01385341f, 0.06163459f, 0.05666069f, 0.01861637f, 0.14039685f, 
    0.19698492f, 0.17468277f, 0.11166632f, -0.12770280f, -0.39814708f, -0.07942323f, 0.08914857f, -0.06429384f, 
    -0.06544793f, -0.04265307f, -0.13003562f, 0.14841081f, 0.03433378f, -0.02915912f, 0.03422713f, -0.00951340f, 
    0.10081336f, 0.33117729f, 0.20728843f, 0.05457475f, -0.02841359f, -0.04009455f, 0.09936579f, -0.03961220f, 
    0.04106416f, -0.05996250f, -0.03070792f, -0.06594005f, -0.02787196f, -0.07031298f, -0.01911379f, -0.07582213f, 
    -0.08420969f, -0.00857261f, -0.01858466f, -0.05745205f, -0.03403261f, -0.06891697f, -0.03525051f, -0.07883694f, 
    -0.34553567f, -0.06408685f, -0.02409581f, 0.14236672f, 0.03160032f, 0.04304016f, -0.09274682f, 0.08040801f, 
    0.01024389f, 0.01159989f, -0.02055536f, -0.03010930f, 0.13419400f, 0.03068752f, -0.01518686f, 0.07528344f, 
    -0.05027260f, 0.11677815f, 0.05508388f, 0.02054399f, -0.00373835f, 0.09082358f, 0.00421424f, 0.03026422f, 
    0.18056105f, -0.25255635f, 0.02660376f, 0.00334854f, 0.03063275f, 0.15318015f, -0.07430362f, -0.06338447f, 
    0.01212401f, 0.08217036f, 0.10626099f, -0.00861162f, -0.22002928f, -0.20347807f, -0.01982347f, 0.01018877f, 
    -0.09560483f, -0.10474823f, -0.05796402f, 0.12208354f, 0.04702170f, 0.14237124f, -0.00807633f, 0.01463434f, 
    -0.23765101f, 0.39288825f, 0.28932229f, -0.03613759f, -0.02381483f, 0.00730551f, 0.01499470f, 0.00349602f, 
    -0.10503866f, 0.00935350f, 0.02736596f, -0.03439980f, -0.02920941f, 0.10860114f, 0.19320214f, 0.20024258f, 
    0.06484714f, -0.02091449f, -0.06014809f, -0.05491596f, 0.00239800f, 0.01919712f, -0.00356291f, -0.01121040f, 
    -0.15151379f, 0.03428297f, 0.13166308f, 0.03490336f, -0.02208422f, -0.12422598f, 0.01998397f, 0.11628017f, 
    0.05751659f, 0.08918764f, 0.07357724f, 0.02902885f, 0.06971302f, -0.02068949f, 0.18501772f, 0.12078445f, 
    -0.01134035f, -0.04427817f, -0.02928490f, -0.04706722f, -0.05593757f, 0.08948555f, 0.18410838f, -0.02305118f, 
    0.05000700f, 0.13712917f, -0.24244617f, 0.15729426f, -0.01574947f, 0.04637460f, 0.07595687f, 0.03265105f, 
    -0.08807816f, 0.08590750f, 0.06414038f, 0.00153654f, 0.01526947f, 0.24999173f, -0.04631520f, 0.16871516f, 
    -0.00535757f, 0.02074774f, -0.00656816f, 0.08598281f, 0.05260073f, 0.01260488f, 0.09646843f, 0.00283090f, 
    0.03515823f, -0.19739479f, 0.05966214f, 0.11226831f, 0.02084424f, -0.18567705f, 0.00753254f, -0.02048117f, 
    0.06885262f, 0.00042078f, 0.09706745f, -0.02914112f, 0.02017525f, -0.07156444f, -0.11498438f, -0.02752663f, 
    -0.05874186f, 0.04274555f, 0.05448228f, -0.00232688f, -0.04422528f, -0.07022557f, 0.01280726f, 0.01653121f, 
    0.01816799f, 0.28543967f, 0.38466865f, -0.10416102f, -0.02443860f, 0.11323506f, 0.08972965f, 0.18696398f, 
    -0.08107822f, 0.05726142f, 0.16724259f, 0.01218218f, -0.17214316f, 0.04247867f, 0.01538779f, 0.08820441f, 
    0.07918454f, -0.01319154f, -0.03645090f, 0.00792044f, 0.06366210f, -0.03682801f, 0.03980047f, -0.00149771f, 
    -0.08913483f, 0.07593288f, -0.00306554f, -0.01911872f, 0.00086317f, -0.14398892f, -0.17240803f, -0.12206410f, 
    0.08705704f, -0.01222015f, -0.02839786f, 0.00276207f, -0.07106628f, -0.10744520f, 0.25228661f, 0.06835927f, 
    -0.04589440f, 0.07933360f, 0.14064726f, 0.00615734f, 0.16028523f, 0.00562662f, -0.01006391f, 0.02605482f, 
    -0.50882900f, 0.17277905f, -0.05365426f, 0.03428391f, 0.21157506f, 0.13028535f, -0.11130655f, 0.10982740f, 
    0.01762786f, 0.09363405f, 0.21186863f, 0.00001539f, -0.09564308f, -0.09156111f, 0.11763324f, 0.01525109f, 
    0.05091132f, 0.00895416f, 0.01478656f, 0.06607009f, 0.00764613f, 0.02364048f, -0.01209276f, 0.01969128f, 
    0.05882816f, -0.19830647f, 0.04637578f, 0.21269447f, 0.00240100f, 0.08836500f, -0.03956125f, -0.02682911f, 
    0.15215610f, 0.10494491f, 0.08339889f, 0.05718877f, -0.01659665f, -0.04337511f, -0.10649104f, -0.09532082f, 
    -0.07846256f, -0.07862960f, 0.00681561f, -0.06596004f, 0.00400113f, -0.00046079f, -0.01548639f, -0.09518719f, 
    0.19153164f, 0.04327299f, 0.09403576f, 0.31329355f, 0.15906762f, 0.10300585f, 0.06140518f, 0.15401073f, 
    0.12593544f, 0.18209529f, 0.16028644f, 0.07728987f, 0.05626584f, -0.09371493f, -0.05394136f, -0.10149323f, 
    0.00076579f, -0.04651573f, -0.05763374f, -0.00021233f, 0.00885042f, 0.03767547f, 0.08345797f, 0.05511420f, 
    0.13436180f, 0.16192080f, -0.01462720f, -0.02683036f, 0.08722062f, -0.08391209f, -0.05951820f, -0.10027327f, 
    -0.07446021f, -0.01355626f, 0.04372705f, -0.00871478f, 0.21689679f, 0.11448062f, 0.22529322f, 0.19512816f, 
    0.00791696f, 0.12319057f, -0.11130234f, 0.16870300f, -0.02678793f, 0.03615357f, 0.00341542f, 0.08621363f, 
    -0.05142370f, 0.09214262f, 0.09104852f, 0.06900904f, -0.14598262f, -0.09499986f, -0.02312088f, 0.17877062f, 
    -0.00871733f, 0.07205644f, 0.08720492f, 0.04075461f, 0.48550323f, 0.20643054f, 0.10521006f, -0.01229192f, 
    -0.09591794f, -0.04053286f, -0.11519754f, -0.14363863f, -0.05161972f, 0.03617759f, -0.01107782f, -0.13669272f, 
    0.20667309f, -0.14496200f, 0.08719156f, -0.12086836f, 0.04862585f, 0.00385867f, -0.10191257f, -0.01327054f, 
    0.00652157f, 0.16525993f, 0.01664188f, 0.39948037f, -0.24327303f, 0.03637587f, 0.10325745f, -0.07364424f, 
    -0.14669500f, -0.02022924f, -0.00111824f, 0.03133293f, -0.00895458f, 0.08263703f, -0.09275378f, 0.02703553f, 
    0.19284998f, 0.20915776f, 0.07709396f, -0.04391505f, 0.03950515f, 0.00952427f, -0.07173433f, 0.15872194f, 
    -0.01066355f, 0.14445408f, 0.05829062f, 0.28306967f, 0.12652992f, 0.12750904f, 0.15578187f, 0.34820428f, 
    0.01501089f, 0.12762952f, -0.06218396f, 0.06673096f, 0.01050713f, -0.09434709f, -0.04569046f, 0.04384581f, 
    0.00123048f, -0.11707097f, 0.02523810f, -0.00416441f, -0.01019979f, 0.04474666f, -0.01159605f, -0.03146173f, 
    -0.09948972f, 0.08366868f, 0.10465317f, 0.02773245f, 0.06608440f, -0.26478434f, -0.10167067f, 0.18200149f, 
    -0.05929354f, 0.08682565f, -0.08118358f, -0.06564663f, -0.02217161f, -0.03366383f, 0.05346448f, -0.00904576f, 
    0.05449518f, 0.20452923f, 0.25080144f, 0.09354614f, -0.08340816f, -0.06637072f, -0.10958388f, -0.17774361f, 
    -0.01634915f, 0.02058079f, -0.02227399f, -0.11962380f, 0.01745638f, -0.03720298f, -0.20535563f, -0.23100342f, 
    -0.02203496f, -0.01296522f, -0.08412216f, -0.04351040f, -0.05707742f, 0.01123129f, -0.03253581f, -0.12039285f, 
    -0.40034252f, -0.06642436f, 0.13629299f, -0.39650843f, 0.10210213f, -0.12403344f, -0.03608677f, -0.09713404f, 
    0.10570498f, -0.01494801f, -0.09320359f, -0.13982032f, 0.25976831f, 0.19946396f, 0.20515153f, 0.19564410f, 
    0.06065119f, -0.07568778f, 0.11758402f, 0.10292281f, -0.06572280f, 0.02941291f, -0.05624696f, 0.02535268f, 
    0.19391924f, 0.10537082f, -0.35966206f, 0.17881301f, 0.09392513f, -0.00635142f, -0.10544414f, 0.08242462f, 
    -0.04987654f, 0.00592034f, -0.03125199f, 0.17070320f, -0.12071002f, -0.03127065f, 0.13086627f, 0.18177931f, 
    0.08399964f, 0.10225251f, -0.00726721f, -0.08877204f, -0.02950544f, 0.07505720f, 0.13890004f, 0.18741986f, 
    0.15567930f, 0.20658641f, -0.16688311f, 0.18457499f, 0.14300664f, 0.01920612f, -0.00908898f, 0.11810518f, 
    -0.02170450f, 0.01858452f, 0.02210290f, 0.02960022f, -0.03971118f, -0.06217740f, -0.06934153f, -0.00411341f, 
    0.00176571f, 0.11673437f, -0.04649046f, 0.05285110f, -0.03556724f, 0.15358642f, -0.06516746f, -0.11687551f, 
    -0.11495808f, 0.19749287f, 0.13886589f, -0.10852622f, -0.02709112f, -0.19401267f, 0.00131528f, 0.03999185f, 
    -0.04135602f, -0.03364262f, -0.00579430f, 0.11363648f, -0.03275771f, -0.12268610f, 0.12709638f, 0.26352662f, 
    0.02162086f, 0.08911161f, -0.02312852f, 0.03098962f, -0.06460120f, -0.07591312f, 0.05235458f, -0.09064022f, 
    0.25209972f, 0.10694986f, 0.15356618f, 0.10608744f, 0.20578369f, 0.02169494f, -0.04378875f, -0.13499615f, 
    -0.01909786f, 0.08719219f, -0.02522657f, -0.01027762f, 0.22757602f, -0.00023036f, -0.16917238f, -0.08242276f, 
    0.02112820f, -0.02444847f, 0.03350406f, -0.05077942f, -0.00413090f, 0.05067536f, 0.08581121f, -0.05007570f, 
    0.08184604f, -0.41038230f, 0.13094857f, -0.27151689f, -0.03040825f, -0.03502299f, 0.03495717f, 0.01838026f, 
    -0.10257027f, 0.14057408f, 0.09603900f, -0.17050964f, -0.34232625f, 0.09253423f, -0.09182817f, 0.15312921f, 
    -0.07267770f, -0.02189049f, 0.06473740f, -0.07943834f, -0.06949256f, -0.03784430f, -0.18912420f, 0.00221104f, 
    0.11720414f, -0.21645741f, 0.07697228f, -0.10402932f, 0.15495464f, 0.02447190f, 0.06216088f, -0.11584528f, 
    0.05953889f, 0.09385136f, 0.03921515f, 0.05882973f, 0.21592100f, 0.03349898f, 0.11089234f, 0.28223550f, 
    -0.16284734f, 0.14717127f, -0.06417820f, 0.01329182f, -0.00286772f, -0.03864647f, 0.01073627f, -0.03959926f, 
    -0.31026885f, 0.03013712f, -0.32036680f, 0.01130557f, -0.08005963f, 0.17685208f, 0.03665096f, -0.18836516f, 
    -0.03520700f, 0.03759526f, -0.13866195f, 0.00730177f, 0.68142456f, 0.27649248f, 0.06481688f, 0.11156355f, 
    -0.10490385f, 0.06264320f, 0.08174551f, 0.11190131f, -0.07891361f, -0.02081846f, -0.05352145f, 0.01939108f, 
    -0.33188447f, 0.05543643f, 0.10222780f, -0.06609641f, -0.08436609f, -0.02836156f, -0.02487327f, -0.21179672f, 
    -0.07953686f, 0.13789490f, -0.08063255f, -0.11462375f, -0.06821635f, -0.02343859f, -0.21224523f, -0.04570793f, 
    -0.01845069f, 0.07400060f, -0.04915509f, -0.06540886f, 0.10391762f, 0.19798450f, -0.00108791f, 0.01705727f, 
    -0.10708284f, 0.05879273f, -0.13496721f, -0.42350420f, -0.04848117f, 0.03660608f, -0.10820547f, -0.03277904f, 
    -0.16000703f, -0.08611317f, -0.16011335f, -0.02429313f, 0.17119630f, -0.01308526f, -0.16236015f, 0.04916228f, 
    0.01369957f, 0.01120354f, 0.12376399f, 0.07983241f, 0.10061718f, -0.03574900f, 0.11196570f, 0.05545278f, 
    -0.33047292f, -0.16060568f, -0.01944062f, -0.04826344f, -0.06355022f, 0.06837782f, -0.13535458f, 0.07065816f, 
    0.10857144f, 0.20371421f, 0.08087149f, -0.05036354f, 0.05470154f, 0.05306549f, -0.12857096f, -0.14834207f, 
    -0.03551767f, 0.02461751f, 0.09117545f, -0.18153811f, -0.06089158f, -0.03067800f, -0.02956317f, 0.06519831f, 
    0.13990346f, -0.07301172f, -0.01944530f, -0.09454034f, 0.14595728f, 0.17491962f, 0.04278924f, 0.05887962f, 
    -0.00195005f, 0.03783328f, -0.06410544f, 0.10344899f, -0.16985448f, -0.22592489f, -0.22311610f, 0.09213787f, 
    0.14190972f, 0.03057340f, 0.04620371f, -0.02257301f, -0.01050213f, -0.03817695f, -0.04619868f, 0.12575909f, 
    0.04983718f, 0.02559457f, 0.09550153f, -0.07660996f, -0.00413032f, 0.10038505f, 0.00537204f, 0.25070864f, 
    0.04061672f, -0.04502390f, 0.01594321f, -0.14545915f, 0.03181389f, -0.03572308f, -0.04626555f, -0.01171932f, 
    0.31397238f, 0.01634200f, 0.16890682f, 0.10075936f, -0.04337972f, 0.02075472f, 0.04505254f, -0.08825543f, 
    0.07656211f, 0.04964244f, 0.04985870f, 0.01470287f, 0.01314120f, -0.06521264f, 0.03083311f, 0.11418656f, 
    0.06100474f, 0.01830050f, -0.09212744f, -0.00085805f, 0.28710288f, 0.24354841f, -0.22544311f, 0.00225126f, 
    0.10021614f, -0.02465117f, 0.25399762f, -0.10395972f, -0.04762197f, 0.07579647f, 0.01630687f, 0.01816560f, 
    0.11575720f, -0.16590190f, 0.00342966f, -0.02388972f, -0.06720803f, 0.08128141f, 0.06145971f, 0.14418617f, 
    0.14304225f, -0.04063770f, 0.20025039f, 0.05400329f, -0.13471365f, -0.06024981f, 0.04101537f, -0.16005000f, 
    -0.00645169f, -0.05573774f, -0.06979426f, -0.06820422f, -0.12713470f, 0.07717729f, -0.05278089f, -0.06764986f, 
    0.19877240f, -0.00101961f, -0.03341599f, -0.17422864f, 0.19928466f, 0.06814021f, 0.18728189f, 0.15039483f, 
    -0.02204768f, -0.01001504f, 0.02770864f, 0.07063660f, 0.05598849f, 0.02289522f, 0.01056998f, -0.01590674f, 
    0.11006000f, 0.04551202f, 0.07789756f, 0.02723609f, 0.07189100f, -0.09197436f, 0.05373077f, 0.08311315f, 
    0.18077795f, -0.00016460f, 0.14435796f, 0.20222819f, -0.07147258f, -0.04499896f, 0.08146417f, 0.03106650f, 
    0.03029515f, -0.15614122f, 0.07611778f, 0.13806450f, -0.00573935f, -0.04566100f, -0.18727359f, -0.33097607f, 
    0.07245462f, 0.09738763f, -0.03384690f, -0.06161345f, 0.00919575f, -0.10396925f, 0.08191294f, -0.03618039f, 
    -0.19937555f, 0.15684818f, -0.23638667f, 0.04833434f, -0.03959619f, -0.06335206f, 0.02290645f, 0.16701336f, 
    -0.04936311f, 0.08660778f, 0.11552467f, -0.07466172f, 0.20011304f, 0.17417972f, 0.07081380f, -0.04709965f, 
    0.05018222f, -0.04920284f, 0.01179737f, -0.02284316f, 0.02009850f, 0.05724729f, 0.07651378f, 0.05087092f, 
    -0.19486263f, -0.02895611f, -0.08964396f, -0.05383451f, -0.01127933f, 0.03943004f, -0.13817768f, 0.04055416f, 
    0.07690672f, 0.10352768f, 0.08959270f, -0.17314166f, 0.18689092f, 0.21524848f, -0.21020298f, 0.28739303f, 
    0.00082774f, -0.09575433f, 0.04536121f, -0.02142354f, 0.02924858f, 0.04016907f, 0.22873095f, 0.14606796f, 
    0.08341330f, -0.08302753f, 0.14797495f, 0.02102231f, 0.32220721f, 0.08756687f, 0.07880369f, 0.02888327f, 
    0.24328418f, -0.07316045f, 0.09283381f, -0.18065068f, -0.18926217f, 0.08236265f, 0.02446986f, -0.09246033f, 
    0.03548661f, 0.06084071f, -0.05834685f, 0.03026149f, 0.07531173f, 0.15538150f, 0.04666770f, 0.10664067f, 
    -0.33072439f, 0.09769667f, -0.04166900f, -0.30645454f, 0.01660363f, 0.09105459f, 0.14349498f, 0.09780772f, 
    -0.02111507f, 0.07154068f, 0.04115767f, -0.11102918f, 0.01974113f, 0.00095060f, 0.00672322f, 0.03842283f, 
    -0.11751800f, 0.08400965f, 0.04745307f, 0.00333728f, -0.02242511f, -0.11667284f, 0.01802824f, -0.12061961f, 
    0.25131074f, -0.17617489f, -0.16123748f, 0.13961357f, 0.06355923f, 0.02162902f, 0.05264558f, -0.02621084f, 
    0.03182375f, -0.02438038f, 0.09217505f, 0.20094550f, 0.00432653f, -0.02536799f, -0.03728636f, -0.01226992f, 
    0.00360439f, -0.05383981f, -0.00248865f, -0.07202510f, 0.01992968f, 0.09962848f, 0.31494299f, -0.08312187f, 
    -0.24696259f, -0.13835807f, -0.10079957f, -0.00351854f, -0.02068107f, -0.00727144f, -0.13474800f, -0.09130921f, 
    0.03741243f, 0.05385691f, 0.13142173f, 0.03493595f, -0.17135391f, -0.03761159f, -0.06325246f, -0.29254365f, 
    -0.04949870f, 0.09489045f, 0.07514384f, -0.06589445f, 0.03750115f, -0.01937949f, 0.03206144f, 0.02851395f, 
    -0.08670793f, 0.02701268f, 0.13014640f, 0.10112104f, 0.08669178f, -0.08224990f, -0.01737893f, 0.06750219f, 
    0.14200950f, 0.03724062f, 0.11327817f, 0.12112142f, 0.04552161f, -0.21665831f, -0.18552148f, -0.04163348f, 
    0.08877438f, 0.13204770f, 0.12454165f, 0.03985599f, -0.04225342f, 0.00424310f, 0.09223227f, 0.10677452f, 
    -0.02743332f, -0.14794983f, 0.23879176f, 0.04965336f, 0.04784960f, -0.18063661f, 0.10265981f, 0.14499648f, 
    0.22708263f, 0.15090373f, 0.16153352f, 0.16407315f, 0.07434142f, 0.01660190f, -0.09197443f, -0.05752281f, 
    -0.02959288f, 0.04810748f, -0.02632098f, 0.00293810f, -0.20390916f, -0.11499905f, 0.01435367f, -0.19995803f, 
    -0.03281493f, -0.01587308f, -0.02469018f, -0.01430031f, 0.03751514f, 0.03902538f, 0.00429001f, -0.04958489f, 
    0.01787691f, 0.01190912f, -0.03145254f, -0.00651476f, -0.01369634f, 0.03180242f, 0.02072247f, -0.01549565f, 
    -0.04312634f, 0.02295247f, -0.02123079f, -0.05376473f, -0.00400768f, -0.00431991f, 0.04261678f, 0.03029217f, 
    -0.00414341f, 0.00327514f, 0.02309484f, 0.01016788f, -0.02815217f, -0.00507234f, -0.01974281f, 0.03093217f, 
    -0.01713271f, 0.01870953f, 0.00731522f, -0.00483682f, -0.04815973f, 0.00436170f, -0.01040259f, 0.03743466f, 
    -0.01184950f, -0.02022105f, -0.01006814f, -0.05548687f, 0.00296605f, -0.02289298f, 0.02311217f, 0.03017625f, 
    -0.01683191f, -0.00420479f, -0.00254393f, 0.01484570f, -0.02105088f, -0.04883001f, 0.01014428f, -0.01863589f, 
    0.04183228f, 0.01136963f, -0.03340899f, 0.03768429f, -0.04743652f, -0.00320868f, -0.04569038f, 0.03027252f, 
    -0.02830479f, -0.04441031f, 0.02539835f, -0.00052010f, -0.04557886f, 0.00564357f, -0.01018868f, 0.03635134f, 
    -0.04146157f, 0.02281355f, 0.02710211f, -0.03468651f, 0.03104038f, -0.00779582f, -0.01230832f, 0.03576239f, 
    -0.04404975f, -0.02931560f, 0.00685697f, 0.04195965f, 0.00958547f, -0.04803432f, 0.04381300f, 0.01679837f, 
    0.02946416f, -0.04195493f, -0.05162523f, -0.05519742f, -0.04984704f, 0.00611448f, 0.03789151f, -0.03254913f, 
    0.00918131f, -0.05175148f, -0.05532912f, -0.01285139f, -0.01649591f, 0.02740147f, -0.00581901f, 0.01246873f, 
    -0.01789869f, 0.01859228f, -0.03029166f, -0.01265771f, 0.01544776f, -0.04794015f, 0.01259470f, 0.01507774f, 
    0.02266891f, -0.01909729f, -0.01509623f, 0.02627137f, -0.03280678f, -0.00236172f, -0.02078983f, -0.03525477f, 
    -0.04695417f, 0.03260720f, -0.00370486f, 0.01405618f, 0.01068320f, 0.02144988f, 0.02387063f, -0.03395666f, 
    -0.03164890f, -0.04761139f, -0.03361009f, -0.00692998f, 0.01760167f, 0.03560333f, -0.03594173f, -0.00353751f, 
    -0.00799161f, 0.03250414f, 0.03930821f, -0.00018972f, -0.04387335f, -0.01948182f, 0.02974926f, 0.01905861f, 
    -0.04821622f, -0.03956089f, -0.05112244f, -0.02482799f, -0.05137032f, -0.02465356f, -0.04839629f, 0.02407333f, 
    0.02894668f, 0.00658745f, 0.02069433f, -0.02489204f, -0.00466148f, 0.00529830f, 0.01132537f, 0.03263813f, 
    0.03277610f, -0.01590408f, -0.02966210f, 0.03001937f, 0.00120084f, -0.04366923f, -0.00818578f, -0.05445588f, 
    0.03978148f, -0.02725425f, 0.02217476f, 0.04452692f, 0.03751762f, 0.02232377f, -0.02104013f, -0.05113370f, 
    -0.00369382f, -0.04107312f, -0.05389985f, 0.03618224f, -0.02886806f, 0.00629106f, -0.00007246f, 0.02433863f, 
    -0.01699846f, -0.00999580f, -0.05440404f, -0.05117888f, -0.02829172f, -0.00329238f, -0.04435506f, 0.04231985f, 
    0.01559688f, -0.05534189f, 0.02429837f, 0.03092592f, -0.04052930f, 0.00370615f, -0.01601063f, -0.04816945f, 
    0.02174446f, 0.00453813f, -0.05484078f, -0.02697357f, -0.04607580f, 0.03081252f, -0.00427212f, -0.00744775f, 
    0.01833288f, 0.03837804f, -0.03239120f, -0.04486731f, -0.04872587f, 0.04058568f, -0.05202784f, 0.03149263f, 
    -0.00891214f, -0.00557872f, -0.02886982f, -0.02075131f, -0.04457994f, -0.02924012f, -0.04215683f, -0.05387383f, 
    -0.02790738f, -0.01108229f, -0.01146413f, 0.03074905f, -0.03127825f, -0.00948757f, 0.02325749f, -0.00729394f, 
    0.00262914f, 0.02286858f, -0.01011215f, 0.03963394f, 0.00288115f, 0.01608054f, -0.00890343f, 0.01157427f, 
    -0.04067111f, -0.04363481f, -0.01447869f, -0.00514133f, -0.01794011f, 0.00765382f, 0.01614281f, 0.04560583f, 
    -0.00060545f, -0.05524014f, 0.01870648f, -0.04714426f, 0.03850271f, 0.04298941f, 0.04047005f, -0.00935515f, 
    -0.02813020f, -0.04358849f, 0.01338072f, 0.03993697f, -0.01520174f, -0.02977905f, 0.00405667f, 0.03434149f, 
    -0.03925622f, -0.03652234f, -0.01415096f, 0.02789151f, -0.04809143f, 0.03801040f, -0.01022848f, -0.04092589f, 
    -0.01503271f, -0.04740085f, 0.01395184f, 0.03631897f, 0.03991206f, 0.03887285f, -0.03383062f, -0.05236556f, 
    -0.03716277f, -0.03885731f, -0.05254189f, -0.02986893f, -0.00353967f, 0.01890494f, -0.04202099f, -0.05019271f, 
    0.01351377f, -0.05357289f, 0.01090927f, -0.01282684f, -0.05374429f, -0.02447630f, -0.01741839f, 0.03908787f, 
    -0.05042831f, -0.02522662f, -0.01399378f, -0.01438953f, -0.03052495f, 0.00026690f, -0.02434662f, -0.02064161f, 
    -0.04157110f, -0.01050040f, -0.01905968f, 0.04063468f, -0.03466471f, 0.04121754f, -0.05762354f, 0.02270528f, 
    -0.01939461f, -0.03176580f, -0.01834187f, -0.03038551f, 0.01005318f, -0.03405308f, -0.05833037f, -0.00396312f, 
    0.03652597f, 0.02111675f, 0.02221082f, 0.02666378f, -0.01114557f, 0.03281832f, -0.05185832f, -0.04325626f, 
    0.02296092f, -0.00198254f, -0.04796068f, -0.05131150f, -0.05896392f, 0.04069890f, -0.00602627f, 0.00796859f, 
    -0.03467009f, 0.04163213f, -0.02578401f, 0.04105956f, 0.01515648f, -0.02820910f, -0.04410957f, 0.01185898f, 
    0.01831208f, 0.00404672f, 0.00799961f, -0.05367558f, -0.02574143f, -0.04097417f, 0.03943972f, -0.03352829f, 
    0.03044251f, -0.00799305f, -0.04384575f, -0.00068739f, -0.02293924f, -0.02038273f, -0.03448895f, -0.01716086f, 
    0.03633299f, 0.04101472f, 0.00393806f, 0.00675066f, 0.04232062f, 0.00713913f, -0.02540665f, 0.03544279f, 
    -0.00207265f, 0.00039319f, 0.02082917f, -0.02635643f, -0.00723224f, 0.02167458f, -0.00809494f, -0.04986241f, 
    0.03946477f, -0.02015680f, -0.01524570f, -0.05579314f, -0.03290381f, -0.01037533f, -0.00236058f, -0.02931968f, 
    -0.24037549f, -0.31490070f, -0.02370298f, 0.01826382f, -0.07368023f, 0.15073438f, -0.12528074f, 0.00274971f, 
    0.07586841f, 0.04211950f, -0.05859879f, -0.09188640f, 0.17914757f, 0.14037758f, 0.12572792f, 0.14115907f, 
    -0.01557937f, 0.14273787f, 0.07389620f, 0.03376841f, 0.16158435f, 0.13736977f, 0.09820265f, -0.02349689f, 
    -0.28486130f, 0.05810462f, 0.12440914f, -0.26899460f, -0.09782954f, 0.11613409f, -0.01307494f, 0.04172267f, 
    -0.07405195f, 0.05738062f, 0.12074631f, -0.02662443f, -0.00251682f, -0.07325911f, -0.10846189f, 0.15392260f, 
    -0.04862541f, 0.11662906f, -0.17329586f, 0.08425553f, -0.07485330f, 0.01207473f, -0.11212910f, 0.04788924f, 
    -0.19526421f, -0.18797231f, -0.16789860f, -0.45847744f, -0.01612001f, -0.08464249f, -0.21868740f, 0.03797653f, 
    -0.03359427f, -0.05020432f, 0.01318926f, 0.03365479f, 0.02484254f, 0.12393948f, -0.10815439f, 0.01052159f, 
    -0.15777366f, -0.04268814f, -0.05187876f, -0.09427653f, -0.03290991f, -0.00370980f, -0.03102150f, -0.01979960f, 
    0.04149216f, -0.05197646f, 0.20587036f, 0.01087397f, -0.00855000f, 0.06534068f, -0.06211148f, -0.15120013f, 
    -0.04763974f, 0.07249203f, -0.17434929f, -0.10122050f, -0.11833759f, 0.16117051f, -0.07703775f, 0.07973300f, 
    -0.11647635f, 0.15326020f, 0.04798663f, -0.07775893f, 0.19567940f, 0.00156874f, 0.02516981f, 0.02484032f, 
    -0.06057791f, 0.05882929f, 0.01475472f, 0.04802750f, 0.09106601f, 0.07878265f, -0.04777568f, -0.00127410f, 
    0.08886290f, 0.01180875f, -0.18994039f, -0.01071133f, 0.11049128f, -0.38647920f, 0.03563624f, 0.17074211f, 
    -0.05315717f, 0.04620536f, -0.00304879f, -0.03916019f, -0.13111417f, -0.19901723f, -0.01399249f, -0.11827070f, 
    0.29446167f, 0.05768394f, 0.23697360f, -0.10241146f, 0.02046558f, -0.13897948f, -0.10342356f, -0.07357989f, 
    0.09899704f, -0.22303294f, -0.12733987f, -0.04865554f, 0.09474315f, 0.13726258f, 0.11143801f, 0.04414358f, 
    -0.14523347f, -0.02931312f, 0.02912080f, -0.07198390f, -0.09235518f, 0.00854076f, 0.04200786f, 0.11476202f, 
    -0.10745969f, 0.08941277f, -0.13396889f, 0.02426599f, -0.16967478f, 0.12666862f, -0.00802336f, -0.03071789f, 
    -0.22145292f, -0.13225430f, -0.13580893f, -0.14911926f, 0.01061795f, 0.11307389f, 0.05140119f, 0.08551472f, 
    0.12140739f, 0.00380871f, 0.10822071f, 0.04790766f, -0.01558054f, 0.13425465f, 0.08975190f, 0.09131832f, 
    -0.02525195f, 0.14370765f, 0.09325291f, 0.14306030f, 0.00586547f, 0.12148261f, 0.02523293f, -0.00833506f, 
    0.07135518f, 0.07117812f, -0.02429583f, 0.18403572f, 0.05042481f, -0.03116088f, 0.12852903f, -0.01469751f, 
    -0.01587156f, -0.01067515f, -0.00600503f, 0.03672161f, -0.07007328f, -0.01994505f, 0.00486216f, -0.08820332f, 
    0.41175199f, 0.01114930f, -0.00736712f, 0.15216281f, -0.05241391f, -0.02481413f, 0.00463451f, -0.03506467f, 
    0.14457271f, 0.06712438f, 0.01771377f, 0.08686980f, 0.12217365f, -0.06404421f, -0.03723915f, -0.03499822f, 
    -0.10335190f, 0.07204971f, -0.00868222f, -0.03295560f, -0.01618309f, 0.01876169f, -0.05262006f, -0.03586153f, 
    0.04358124f, 0.07420374f, 0.03834230f, 0.08447331f, -0.05805180f, -0.00393403f, 0.08421332f, 0.05042819f, 
    0.03569639f, -0.04796468f, 0.11971822f, -0.01406155f, -0.00273379f, 0.21080832f, 0.01906985f, -0.06234751f, 
    0.00746125f, -0.02713598f, -0.03858858f, 0.00561694f, 0.15615673f, 0.19023320f, -0.05266964f, 0.21125396f, 
    -0.45513633f, 0.24495026f, -0.12393902f, -0.22914103f, 0.07227552f, 0.13377906f, 0.13398878f, 0.22331755f, 
    -0.11515452f, -0.14786485f, 0.03326101f, -0.07047915f, -0.00942193f, -0.15375908f, 0.03438465f, -0.02226011f, 
    -0.05682601f, 0.02791258f, -0.06330382f, 0.05743785f, -0.06963098f, 0.16511697f, 0.17421450f, 0.18095966f, 
    -0.23278290f, 0.06074193f, -0.13219357f, -0.01240460f, -0.01017436f, 0.01725043f, 0.00427434f, 0.07440000f, 
    -0.32406089f, 0.05508614f, -0.19131383f, -0.13726629f, 0.07464080f, 0.13851923f, 0.06968474f, 0.08490694f, 
    0.02327647f, -0.01712357f, 0.04007956f, 0.05452154f, -0.06572916f, 0.11713550f, 0.01416880f, 0.06741367f, 
    0.30970272f, 0.20522775f, 0.01506530f, 0.13188422f, 0.01848812f, -0.02345089f, 0.06276947f, -0.04859218f, 
    0.10043184f, 0.21589872f, -0.14296186f, 0.02499874f, -0.00040498f, 0.07966425f, -0.08201423f, 0.10602330f, 
    0.03025289f, 0.03247682f, -0.04431398f, -0.07605992f, -0.05847428f, 0.04559007f, 0.00026229f, 0.14442064f, 
    -0.20572159f, -0.18321232f, -0.05224418f, -0.12451083f, -0.08511840f, -0.04159894f, 0.07403406f, -0.06088155f, 
    0.18021411f, 0.09291722f, -0.07581728f, -0.06031692f, 0.02533083f, -0.34850535f, 0.12150498f, 0.10049659f, 
    0.00107106f, -0.02151448f, 0.02455986f, -0.02079307f, -0.16665904f, 0.02218102f, -0.02318128f, 0.01089208f, 
    0.09335819f, 0.04818123f, -0.13274822f, 0.09171494f, -0.03657899f, -0.00052473f, 0.01088182f, 0.17187116f, 
    0.00860141f, 0.13538150f, 0.11876222f, 0.12990791f, -0.00405768f, -0.13657531f, -0.00955922f, 0.13629062f, 
    -0.06500557f, 0.01760586f, -0.08958311f, -0.22032347f, -0.07671124f, -0.02176796f, -0.11946779f, 0.08738135f, 
    0.04696680f, 0.05136608f, 0.21446116f, -0.22071296f, -0.07749493f, 0.17267716f, -0.01294031f, -0.03933362f, 
    0.13182843f, 0.10093164f, 0.01056331f, 0.08624816f, 0.03492157f, 0.13248308f, 0.03636275f, 0.04539487f, 
    -0.04771761f, 0.02902716f, -0.02912184f, 0.02070722f, 0.10380661f, 0.20660500f, 0.00854424f, 0.04132093f, 
    -0.22276177f, -0.14131072f, 0.16732419f, 0.16310996f, -0.08106371f, -0.07627919f, 0.03623572f, -0.00470718f, 
    0.08169618f, 0.01876034f, 0.06037566f, 0.02328945f, -0.02881810f, -0.07705564f, 0.10682330f, -0.10512013f, 
    -0.01070272f, 0.12922227f, 0.06072108f, 0.02428203f, -0.09755692f, 0.13185334f, -0.09415461f, 0.00580366f, 
    0.04701447f, 0.00909439f, -0.00093494f, 0.01977585f, -0.08737310f, -0.07099505f, -0.02357097f, -0.01749463f, 
    -0.01217640f, -0.04456013f, 0.02368966f, -0.01599319f, -0.20724040f, 0.00946521f, 0.21951133f, 0.17527252f, 
    0.04625235f, -0.06569805f, 0.02567586f, 0.16585027f, 0.06686939f, -0.00131211f, -0.01520463f, -0.05276161f, 
    -0.10121586f, 0.08172601f, 0.01430149f, 0.08328873f, -0.00930494f, -0.08212696f, -0.05235643f, -0.02519031f, 
    -0.02523552f, -0.00765976f, 0.05459342f, -0.06619481f, 0.51221681f, 0.30162010f, 0.25263223f, -0.11091964f, 
    -0.08506029f, -0.03575815f, -0.03387472f, 0.03103111f, -0.02418240f, -0.00934321f, -0.01426058f, -0.07987411f, 
    -0.03150399f, 0.14159049f, 0.04083309f, 0.04741181f, 0.02982238f, -0.02434656f, 0.02659387f, -0.13082014f, 
    -0.06228155f, 0.06126777f, -0.02198208f, 0.00754199f, 0.12746325f, -0.03843961f, 0.00853676f, 0.07237510f, 
    0.05068555f, 0.05487698f, 0.17149530f, -0.04607607f, 0.17549701f, -0.03315323f, 0.02167105f, 0.08041867f, 
    -0.05878215f, -0.03834674f, -0.06703869f, 0.02171019f, 0.22929171f, 0.07257646f, -0.00403845f, -0.10903653f, 
    0.14238581f, 0.10047179f, 0.15192740f, -0.05698351f, -0.28680670f, -0.17740281f, 0.28374016f, -0.10477173f, 
    -0.12249036f, 0.05986354f, -0.10860606f, 0.16484967f, 0.08796313f, -0.09604367f, -0.02313208f, 0.01499702f, 
    0.09348377f, 0.08019829f, 0.12424795f, 0.02888661f, 0.08248632f, 0.05525430f, 0.02010890f, -0.11460400f, 
    -0.01185407f, 0.09840344f, -0.16483925f, 0.07979583f, 0.13483362f, 0.07308342f, 0.17340694f, 0.20285530f, 
    -0.05361670f, -0.07091736f, -0.01803970f, 0.00064226f, 0.02002068f, -0.07164375f, 0.01683950f, 0.05190344f, 
    -0.20470132f, 0.05036197f, 0.05841390f, 0.15853186f, -0.13055499f, -0.06450050f, -0.10772809f, -0.03820710f, 
    0.07383249f, -0.05370733f, -0.00807836f, -0.05050339f, 0.10445413f, 0.01298691f, 0.03059755f, -0.12409143f, 
    0.02617018f, 0.07061005f, -0.01519487f, 0.05508932f, -0.04523396f, 0.09388300f, 0.00051322f, -0.01993253f, 
    0.39971140f, -0.01026171f, -0.40467429f, -0.09844183f, 0.26924625f, 0.19093269f, 0.00534442f, -0.15039083f, 
    0.02222602f, 0.12638305f, -0.04592622f, -0.00874825f, -0.20552801f, 0.00121133f, 0.13527282f, 0.20691547f, 
    -0.07384230f, -0.11516159f, -0.01400011f, 0.08901519f, 0.00087477f, 0.01772367f, -0.00779367f, 0.02691630f, 
    0.36258474f, -0.25185162f, 0.21694976f, -0.01357724f, -0.11457352f, -0.03249720f, -0.04925481f, -0.08830463f, 
    0.10095698f, -0.02754625f, -0.02796908f, 0.14613216f, -0.08383697f, -0.17270370f, 0.12349219f, 0.26121023f, 
    0.01702161f, -0.04493256f, -0.09889080f, -0.01590710f, 0.07267201f, -0.01404485f, 0.04322052f, -0.07567187f, 
    0.04253972f, -0.16403583f, 0.18544205f, -0.07619024f, -0.14125986f, -0.00917595f, 0.21148095f, 0.23419148f, 
    -0.00887521f, -0.00313889f, 0.02896558f, 0.04292779f, 0.03704675f, 0.00815561f, 0.21872811f, -0.03409624f, 
    0.02616946f, 0.00572501f, -0.01183949f, -0.02709604f, 0.03736524f, 0.01652070f, -0.08186768f, 0.02127433f, 
    0.04305433f, -0.01401517f, -0.07882553f, 0.07012916f, 0.01507383f, -0.14425860f, 0.10577554f, -0.01661704f, 
    -0.06087136f, 0.11197241f, 0.05160895f, -0.03455805f, 0.04120864f, 0.02562928f, 0.13028596f, 0.14000222f, 
    -0.03275387f, -0.00071764f, 0.13974802f, -0.02108245f, 0.04735461f, 0.04168299f, 0.10043821f, 0.02130376f, 
    0.04412951f, -0.09820483f, -0.11699677f, 0.08886802f, -0.05719531f, -0.21182236f, -0.03886973f, 0.12067398f, 
    0.11424173f, -0.10752536f, -0.14876671f, -0.00297874f, 0.04982826f, 0.05553973f, 0.08911551f, -0.03977343f, 
    -0.00215301f, 0.06254720f, -0.00676779f, 0.03750498f, -0.02224958f, -0.00280570f, -0.02413692f, 0.04189219f, 
    0.12771524f, 0.37112263f, 0.26930311f, -0.24667758f, -0.09617351f, 0.08529784f, 0.09207879f, 0.16723195f, 
    -0.03556035f, 0.30279240f, 0.02727745f, -0.06629104f, 0.14064850f, 0.09912017f, 0.13834766f, 0.15763469f, 
    -0.02355588f, 0.07202366f, -0.08992083f, 0.09965894f, 0.09837465f, 0.01655401f, -0.28804961f, 0.18545924f, 
    0.04110410f, -0.04631487f, -0.06624856f, -0.10514196f, -0.11971410f, -0.05625041f, 0.02770528f, -0.10920619f, 
    0.14462949f, -0.04649922f, 0.01608809f, -0.00368493f, -0.17830117f, 0.00767737f, 0.15796408f, 0.19119398f, 
    0.06853715f, -0.03324056f, 0.03140389f, 0.13871963f, -0.01195744f, 0.09661037f, -0.02186020f, 0.07773608f, 
    0.06853161f, -0.07157411f, -0.28107935f, 0.12874472f, -0.05711807f, 0.10468210f, -0.01780280f, -0.02984167f, 
    0.10184311f, 0.12294181f, 0.06995270f, 0.15692464f, 0.00894387f, 0.16633101f, 0.08583991f, 0.02161551f, 
    -0.15485656f, -0.07602800f, -0.09712800f, -0.02957112f, -0.02314867f, 0.01164306f, -0.12338965f, 0.02690275f, 
    0.29671639f, 0.18684252f, -0.48484731f, 0.18117614f, -0.01016165f, 0.24111722f, -0.10140532f, -0.09703844f, 
    0.07031615f, 0.17037551f, 0.03575975f, 0.01653941f, 0.05698464f, 0.05192944f, 0.02780278f, -0.04264149f, 
    -0.06712165f, 0.00520761f, 0.01186824f, -0.07049227f, 0.08196982f, -0.00569620f, 0.03758049f, 0.04556609f, 
    0.20799498f, -0.02469254f, -0.21509147f, -0.06321888f, 0.08701767f, 0.08966050f, 0.20274545f, -0.00520522f, 
    0.12643808f, 0.24449664f, -0.00401902f, 0.04049458f, -0.04986627f, -0.26308164f, -0.33082649f, 0.18873799f, 
    0.04155526f, 0.02898232f, 0.10409039f, -0.07153459f, -0.05506655f, 0.11132021f, -0.18394451f, -0.01024580f, 
    0.05097748f, -0.30684474f, -0.17646709f, -0.09014052f, 0.02346295f, -0.02616149f, 0.04847176f, 0.07121450f, 
    -0.03218703f, 0.08889473f, -0.06751490f, -0.12252492f, 0.21494703f, 0.11090173f, 0.12749036f, 0.16589734f, 
    0.08074319f, -0.03330014f, -0.04520088f, -0.08796028f, -0.08047793f, 0.00651293f, -0.09326387f, -0.12189090f, 
    -0.08673025f, 0.09201960f, 0.29361466f, -0.02492750f, -0.05318093f, -0.10982381f, 0.08679592f, -0.00000933f, 
    -0.05975986f, -0.06253001f, -0.01297481f, -0.00815290f, 0.19823846f, 0.44589585f, 0.35315093f, -0.18900780f, 
    -0.05119527f, -0.07053727f, -0.22381334f, 0.01825508f, -0.04165413f, 0.06005657f, 0.08747607f, 0.07214282f, 
    0.03601774f, 0.00049106f, 0.04481335f, -0.13279085f, -0.06260403f, 0.00399899f, -0.10702844f, -0.02933157f, 
    0.02726217f, 0.02200108f, 0.02055272f, 0.19196449f, 0.04365548f, -0.00568784f, 0.14896308f, 0.07190238f, 
    0.00712368f, -0.06178465f, 0.22727981f, 0.13392434f, -0.02369742f, 0.13321994f, -0.13542685f, 0.20724601f, 
    -0.09085147f, 0.00303075f, 0.06645051f, -0.00485181f, -0.00890910f, -0.10326900f, -0.03525945f, 0.05612672f, 
    -0.00247270f, 0.06649105f, 0.11603834f, 0.11852446f, 0.17822094f, 0.58010483f, -0.09846873f, 0.09636195f, 
    0.07570097f, 0.01013732f, 0.28648022f, 0.03956044f, -0.01744604f, -0.01855823f, -0.01600691f, 0.04052137f, 
    -0.00567408f, -0.25225195f, -0.00762449f, -0.06577812f, 0.03411898f, 0.19467479f, 0.01597688f, 0.02606216f, 
    0.09420422f, 0.09481767f, 0.01292836f, -0.00300865f, 0.21625319f, -0.00611046f, 0.02572067f, 0.01456685f, 
    0.02811128f, -0.04893830f, 0.03008762f, 0.09624925f, -0.03792617f, -0.01106270f, 0.09646643f, 0.02380212f, 
    0.30128771f, 0.18105426f, 0.04794782f, -0.11663117f, 0.03234218f, 0.01511733f, 0.06498691f, -0.02884580f, 
    0.00749339f, -0.05664454f, -0.07593978f, 0.08161124f, 0.01437483f, 0.09474137f, 0.05461175f, -0.04830702f, 
    -0.03064291f, 0.05445899f, -0.04155128f, 0.10538656f, -0.04424614f, -0.07314835f, 0.04484666f, -0.06404513f, 
    0.15250407f, 0.12364480f, 0.03033384f, -0.03761342f, 0.14511621f, 0.08249252f, 0.04907135f, -0.02795524f, 
    -0.06665181f, 0.09269465f, 0.02045085f, -0.11644197f, 0.21774204f, 0.14327876f, 0.16712151f, 0.05616930f, 
    0.02490045f, 0.09061083f, 0.01994302f, -0.08034048f, -0.00596684f, 0.02281954f, -0.13110571f, -0.05595515f, 
    0.10261604f, 0.06010891f, -0.23090175f, 0.07862350f, 0.07441413f, 0.02626599f, 0.03226487f, 0.08405230f, 
    -0.00851453f, -0.04007491f, -0.02323326f, -0.00258232f, 0.06056065f, -0.04251071f, -0.19571993f, -0.15272412f, 
    0.05703111f, -0.06297848f, -0.01670370f, -0.02933557f, 0.05557724f, 0.10694453f, 0.17799801f, -0.01113294f, 
    -0.03584667f, 0.09095986f, -0.04644824f, 0.10244595f, -0.05551980f, -0.10045284f, 0.05186867f, -0.07726515f, 
    -0.07763315f, -0.00205354f, -0.10795277f, -0.12430896f, 0.15734568f, -0.02082128f, -0.18839155f, 0.18071009f, 
    0.00993663f, 0.12778409f, 0.00379656f, 0.06305019f, -0.07537588f, -0.08606844f, 0.09765483f, -0.09669603f, 
    0.08394647f, -0.19354829f, 0.31793824f, 0.11037647f, 0.23751763f, -0.23299636f, -0.03830013f, 0.01980562f, 
    0.08345906f, 0.09964675f, 0.05324404f, 0.02430046f, -0.11672852f, 0.10367476f, 0.08888795f, 0.16506158f, 
    -0.05467216f, 0.03366769f, 0.16092810f, -0.18195091f, -0.10695006f, -0.16347653f, -0.03667283f, 0.02892135f, 
    0.11282871f, 0.21726972f, -0.07365259f, -0.09181179f, 0.13689968f, 0.01771779f, 0.12863782f, -0.11210842f, 
    -0.07152422f, -0.20453730f, 0.13118561f, -0.06945869f, 0.08989224f, 0.11776038f, 0.03835522f, -0.01430492f, 
    -0.01627076f, -0.02322242f, -0.05829896f, -0.03823460f, -0.02149947f, 0.00143535f, -0.02937475f, -0.11346795f, 
    0.17404418f, -0.15825434f, -0.20972918f, 0.02844313f, -0.05257163f, 0.06189474f, -0.00629705f, -0.06918148f, 
    0.00275962f, 0.03260829f, 0.04275392f, -0.05870507f, -0.01772421f, 0.27040005f, -0.15482199f, -0.00936282f, 
    0.05635181f, -0.04825946f, 0.13326782f, 0.13883731f, 0.03390010f, -0.05904797f, -0.04234378f, 0.14605451f, 
    0.17294931f, -0.08244422f, -0.19644065f, -0.05174850f, -0.01503787f, 0.10750172f, 0.03536972f, 0.05472752f, 
    -0.10869695f, -0.02100537f, 0.01952036f, 0.04266688f, -0.11836411f, 0.44062918f, -0.04492258f, 0.06706235f, 
    0.15606855f, 0.17180400f, -0.12378911f, -0.12427139f, -0.02755714f, -0.02363024f, -0.04811387f, 0.00478798f, 
    -0.09705898f, 0.33220875f, -0.29168668f, -0.19379085f, -0.02102619f, 0.09461764f, 0.20415758f, 0.11642613f, 
    -0.03501556f, -0.05374058f, -0.11208712f, -0.06475125f, 0.06687097f, 0.17964584f, -0.08572415f, 0.07623156f, 
    -0.09875232f, -0.13783756f, -0.02666814f, 0.20778973f, -0.05312608f, 0.11770993f, -0.06013098f, 0.02549120f, 
    -0.01050795f, 0.18977889f, -0.26951286f, 0.06245324f, 0.02702704f, -0.05429652f, 0.00047293f, 0.01816825f, 
    -0.13681073f, 0.13098449f, 0.24991652f, 0.03453559f, 0.10219011f, 0.05479978f, 0.12027641f, 0.07118148f, 
    -0.00898061f, 0.00376180f, -0.02591635f, 0.06170462f, 0.01113892f, 0.02839679f, 0.03650209f, -0.01514093f, 
    -0.02394573f, 0.00733185f, 0.01689370f, -0.00333736f, 0.01327761f, -0.02728300f, 0.03600604f, 0.03530454f, 
    -0.02734871f, 0.02697224f, -0.04954802f, 0.00159153f, -0.03947397f, -0.00366946f, 0.04167401f, 0.00788002f, 
    -0.03981931f, 0.04077688f, 0.02503554f, 0.02773711f, -0.04580775f, 0.00917987f, 0.00063515f, -0.03087010f, 
    -0.04834377f, -0.03243299f, -0.05236136f, -0.01318335f, -0.05462251f, -0.00952937f, 0.03397117f, 0.03545854f, 
    0.00038037f, -0.03412325f, 0.02854165f, 0.00003829f, 0.01859292f, -0.00164376f, 0.04231679f, 0.02992271f, 
    -0.03718976f, -0.03866778f, 0.03839942f, 0.00428938f, 0.00184241f, 0.02247266f, 0.01300738f, 0.01788112f, 
    0.03741407f, 0.00532289f, 0.03309854f, -0.04124997f, 0.02211999f, 0.00466052f, 0.02482302f, 0.01310347f, 
    -0.02564375f, -0.03257433f, -0.02372846f, -0.02782911f, 0.02600135f, -0.04003393f, 0.01698204f, 0.00605863f, 
    0.05540217f, 0.03360721f, -0.00195012f, -0.04828683f, -0.01906666f, -0.03853567f, -0.00173764f, -0.02737619f, 
    -0.01809664f, -0.04953991f, -0.01234380f, -0.02140710f, -0.01654837f, 0.01051074f, 0.01204994f, 0.04053690f, 
    0.01450031f, -0.02857030f, 0.00671689f, 0.00838347f, 0.03098497f, -0.01460133f, -0.01921604f, -0.01577721f, 
    0.02119159f, -0.01006368f, -0.02124892f, 0.02945805f, 0.01429564f, 0.02703946f, -0.02324530f, -0.03105437f, 
    -0.00463228f, -0.00305099f, 0.00924667f, -0.02770563f, -0.05056110f, -0.03250831f, 0.03529865f, -0.03666108f, 
    0.02228558f, -0.05703571f, 0.01813974f, 0.02179758f, 0.02237986f, 0.00138627f, -0.01416415f, -0.01300129f, 
    0.03248239f, -0.01712861f, -0.02320496f, -0.01070672f, 0.03037409f, 0.03725527f, 0.02611717f, -0.00191058f, 
    0.05308050f, -0.00027365f, -0.02837364f, 0.01414358f, -0.05305863f, 0.01239965f, -0.02048564f, 0.01664802f, 
    -0.03903564f, -0.00005084f, -0.03196004f, -0.02081968f, -0.04545129f, -0.03497008f, 0.02805405f, 0.05435074f, 
    -0.00403208f, -0.01671471f, -0.04008502f, -0.03144500f, 0.03993100f, -0.05443641f, 0.03656642f, -0.02318950f, 
    -0.05245407f, 0.00053758f, -0.00338515f, 0.02579300f, -0.04849956f, -0.05650088f, -0.00917758f, 0.01571415f, 
    -0.03414525f, -0.01244194f, 0.00122864f, -0.04286271f, -0.02512001f, -0.01189648f, -0.04127508f, -0.00199088f, 
    -0.00012484f, -0.04478800f, 0.03356940f, 0.03399538f, -0.00876716f, 0.00843641f, 0.00557662f, -0.05501473f, 
    -0.00150082f, -0.00618160f, -0.01864494f, 0.01175700f, -0.01348440f, -0.02230480f, -0.04446511f, -0.01552938f, 
    -0.00112580f, 0.00098309f, 0.02304436f, 0.03753887f, -0.04717951f, 0.01433677f, -0.00806581f, -0.04170030f, 
    0.02789321f, -0.03698158f, 0.04181367f, 0.03841849f, -0.04724795f, 0.02761860f, -0.01811221f, -0.02533714f, 
    0.03573648f, 0.05978262f, -0.04243116f, 0.02685098f, 0.00745796f, -0.05296967f, 0.03942418f, -0.01806157f, 
    0.01949779f, -0.02239550f, -0.04184652f, -0.04389971f, 0.03756427f, -0.03016791f, 0.02658525f, -0.00913922f, 
    0.03819533f, -0.04090188f, -0.05178429f, -0.05001653f, -0.04226317f, 0.00303509f, -0.02664332f, 0.00073157f, 
    0.01789594f, -0.04555411f, -0.05173821f, 0.02186674f, 0.00441831f, 0.02751531f, -0.03753202f, -0.00272015f, 
    0.03693638f, 0.03282972f, -0.03936114f, -0.03051546f, -0.03477939f, -0.01178380f, -0.03008103f, -0.03793583f, 
    -0.04059229f, 0.01263190f, 0.00508017f, -0.05348526f, 0.01257506f, 0.02222461f, 0.00107090f, -0.01359240f, 
    0.04086706f, 0.00198988f, -0.02272534f, 0.01289009f, 0.02342180f, 0.00270016f, -0.01180781f, 0.03573376f, 
    -0.05064482f, 0.00023559f, -0.05190858f, -0.03959247f, -0.03489804f, 0.01667394f, -0.02968271f, 0.00574242f, 
    0.03479709f, 0.02957698f, 0.03641020f, -0.03135505f, 0.03219731f, 0.00852141f, -0.05634458f, 0.04211798f, 
    -0.00798612f, 0.01493334f, 0.01622709f, -0.01209992f, 0.03372355f, -0.00686843f, -0.02933602f, -0.02234803f, 
    -0.00865948f, -0.04481768f, -0.00538200f, 0.03176786f, 0.02632318f, 0.03983815f, -0.01282113f, 0.02508576f, 
    -0.05381135f, 0.02469272f, 0.01979888f, -0.01379234f, 0.00880651f, -0.02919175f, -0.03246098f, 0.02756391f, 
    -0.01924016f, 0.02773130f, 0.03647312f, -0.01588040f, -0.04836503f, -0.03178256f, -0.04923593f, -0.00293695f, 
    -0.03123191f, 0.04194521f, 0.00639369f, 0.02011266f, 0.01766086f, -0.02316943f, -0.00936271f, 0.02951974f, 
    0.03763454f, 0.01660520f, -0.01858045f, -0.04396715f, -0.02374775f, 0.03287868f, -0.01157037f, -0.00187995f, 
    0.03772294f, 0.03708573f, 0.00991212f, 0.04390055f, 0.02228650f, -0.02471899f, 0.04146141f, -0.03180044f, 
    -0.02484697f, -0.00797117f, -0.02950269f, -0.00787233f, 0.00023826f, 0.00656868f, -0.02500246f, 0.00014929f, 
    0.04103958f, 0.04029755f, -0.03596958f, -0.00885655f, -0.05553196f, -0.05508135f, -0.05560856f, 0.01641169f, 
    -0.04338432f, 0.02803453f, -0.02816847f, -0.03587298f, -0.02682962f, -0.05069228f, -0.00323629f, -0.01261672f, 
    -0.00057311f, -0.02065933f, -0.00985270f, 0.00248881f, -0.01675062f, -0.03137483f, -0.01106566f, 0.02973121f, 
    -0.04434909f, -0.05610498f, -0.00612232f, 0.01150882f, -0.04593177f, -0.04476556f, 0.03646395f, 0.01499548f, 
    -0.01032372f, -0.05200536f, 0.04398759f, -0.04748022f, -0.05517122f, -0.04840475f, -0.05298511f, 0.00377013f, 
    0.01529430f, 0.04043821f, 0.00457528f, -0.04906907f, -0.03639904f, -0.02595512f, -0.03268776f, -0.04087301f, 
    -0.00209434f, 0.03427709f, -0.03504575f, 0.05280181f, -0.05559926f, 0.04051093f, -0.01765072f, 0.04078216f, 
    0.39944324f, 0.16124286f, 0.07329852f, 0.03601697f, -0.13839489f, -0.12179689f, 0.05458129f, -0.05545957f, 
    0.16399279f, 0.19981812f, 0.01769812f, -0.01209719f, 0.02688121f, 0.18080828f, -0.00082227f, 0.20303345f, 
    -0.05837520f, 0.00844081f, 0.01831867f, -0.10293689f, -0.09163945f, 0.00884344f, -0.14473285f, 0.05215701f, 
    0.35885897f, 0.12434065f, 0.14512976f, 0.05513324f, -0.06654913f, -0.05314571f, 0.08786183f, -0.08058336f, 
    0.06159610f, 0.06493551f, -0.00071913f, 0.17237586f, 0.02986834f, 0.04396377f, 0.00403673f, -0.01456146f, 
    0.04172016f, 0.00754513f, -0.06871880f, 0.09196749f, -0.00659190f, -0.08808944f, -0.01012585f, -0.07935547f, 
    0.07334105f, 0.11886586f, 0.05462390f, 0.10350474f, 0.12913971f, -0.01535544f, 0.01656787f, -0.03479954f, 
    0.12732084f, 0.01393819f, 0.03721099f, -0.00657866f, -0.24442631f, 0.33991021f, 0.24294096f, -0.01532197f, 
    0.11147938f, -0.03062006f, -0.13583644f, 0.19043802f, -0.05733670f, -0.09963650f, -0.00128836f, -0.20138200f, 
    -0.08945800f, 0.12178636f, -0.10479265f, 0.19936563f, 0.04594266f, 0.01000942f, 0.09534344f, 0.02638901f, 
    0.15498607f, 0.02173121f, 0.22793700f, 0.27254131f, 0.11565906f, -0.22042105f, -0.02050952f, -0.16123293f, 
    -0.13366480f, 0.12295116f, 0.03229848f, 0.04896940f, 0.05651195f, 0.10307611f, -0.16564128f, 0.16070618f, 
    -0.14969207f, -0.08058189f, 0.13246748f, 0.02931374f, 0.06383361f, 0.00196390f, 0.07523513f, -0.14079583f, 
    0.03622238f, -0.00469809f, 0.19774002f, 0.16742441f, -0.06327809f, -0.17370409f, 0.05171394f, -0.00911491f, 
    -0.00115956f, 0.04871399f, 0.00203465f, 0.04310858f, -0.13147369f, 0.00350677f, -0.11038601f, -0.05069798f, 
    -0.09230478f, 0.20982932f, -0.09907714f, 0.06313819f, 0.02431604f, -0.05531632f, -0.26921737f, -0.09171612f, 
    -0.09408838f, 0.23134600f, 0.17235616f, 0.23878828f, 0.06575090f, 0.07563622f, 0.03028361f, -0.21086723f, 
    -0.02454153f, -0.23075229f, -0.05105874f, -0.07075321f, 0.03786236f, -0.22897041f, -0.02569521f, 0.03006680f, 
    -0.02898817f, -0.07910805f, 0.00786584f, -0.05732550f, -0.07550640f, 0.01425245f, 0.00804993f, 0.04695553f, 
    -0.00560400f, 0.01233735f, 0.06770692f, -0.09574261f, -0.08441188f, 0.00222315f, 0.08817543f, 0.13918237f, 
    -0.01211502f, 0.01064032f, -0.26129445f, 0.08320218f, -0.17673048f, -0.25646719f, -0.10181076f, -0.26722685f, 
    0.00026007f, 0.26110387f, 0.02872417f, -0.09922527f, -0.01937474f, 0.06166616f, -0.00162053f, -0.04101827f, 
    -0.13565439f, -0.02078985f, -0.00442089f, -0.11243641f, -0.00314571f, -0.04544199f, -0.10090537f, 0.10385919f, 
    0.01807534f, -0.02139639f, -0.01766932f, -0.08491960f, -0.08175788f, -0.08371896f, -0.04950522f, -0.01916716f, 
    -0.30472320f, -0.15070112f, 0.07799434f, -0.05409981f, -0.16818392f, -0.05267899f, 0.21232013f, -0.15750946f, 
    0.08178169f, 0.03287318f, 0.02040484f, 0.13346635f, 0.01980691f, -0.08729784f, -0.12693708f, -0.12533084f, 
    -0.17129929f, 0.07064480f, 0.04727143f, 0.12912157f, 0.20932193f, 0.06342594f, 0.15446435f, 0.18300143f, 
    0.06220186f, 0.16201243f, 0.04592770f, 0.13838507f, -0.12521805f, -0.00387429f, 0.00633581f, -0.19932291f, 
    -0.01317531f, -0.12456789f, -0.13985896f, 0.00029665f, -0.13576265f, -0.08899966f, -0.02342845f, -0.14699198f, 
    -0.07441662f, 0.11563814f, -0.01206203f, -0.08428013f, 0.05910940f, -0.00527254f, 0.13183421f, 0.05145510f, 
    0.25893682f, -0.12746370f, 0.04920249f, 0.01969667f, -0.06786902f, 0.12538305f, -0.05742677f, -0.07153063f, 
    0.16207677f, 0.06791268f, -0.08693501f, 0.19075970f, 0.12879921f, 0.05338617f, -0.11781583f, -0.03927286f, 
    -0.01477402f, -0.00396569f, 0.05505887f, -0.06197711f, -0.07630932f, -0.20331588f, -0.08987248f, -0.09573957f, 
    0.26857078f, 0.05758722f, 0.20932640f, 0.18337686f, -0.09925441f, 0.08640914f, -0.00957132f, 0.12420952f, 
    0.15621611f, -0.13502017f, 0.05968860f, 0.10682034f, -0.18653618f, -0.08025127f, 0.21759547f, -0.06116698f, 
    -0.03301618f, 0.05076989f, -0.19326411f, -0.01067555f, -0.14766763f, -0.32860127f, -0.29903507f, -0.04667459f, 
    -0.25116694f, 0.18983881f, -0.18339695f, 0.41020101f, -0.01210336f, -0.05918035f, 0.06108152f, -0.10211577f, 
    0.16260698f, 0.02641539f, -0.09923021f, -0.06271287f, 0.16466311f, 0.02919242f, 0.07370948f, 0.03620538f, 
    0.02160450f, -0.07848010f, 0.01338334f, -0.07060881f, -0.13563307f, -0.17732410f, -0.01924164f, -0.03955717f, 
    0.03481214f, 0.45212933f, 0.05205301f, 0.19902715f, -0.30994406f, -0.02866356f, 0.12007013f, 0.24014926f, 
    -0.05306770f, 0.11208696f, -0.02168062f, 0.03388061f, 0.04044892f, 0.15407830f, -0.13023162f, 0.01760442f, 
    0.20004287f, -0.13622864f, 0.04171148f, 0.04522203f, -0.11825220f, -0.02829378f, -0.12784858f, -0.10999408f, 
    0.32462865f, 0.05181416f, 0.30150801f, -0.05579580f, -0.03000991f, -0.13310218f, 0.01344298f, -0.06010375f, 
    -0.03149558f, 0.10049259f, 0.10838551f, -0.08918673f, -0.22372235f, 0.25399157f, 0.14430414f, 0.15917230f, 
    0.08749563f, 0.05146816f, -0.03031891f, 0.07847998f, -0.05806920f, -0.10480827f, 0.04693002f, -0.14851609f, 
    0.22243449f, 0.33538154f, -0.04973389f, 0.05509218f, 0.04637719f, -0.13103335f, 0.14526512f, -0.02000601f, 
    -0.05156207f, -0.04885779f, 0.01402355f, -0.18968205f, -0.08812059f, -0.23639977f, 0.02848345f, -0.14320156f, 
    -0.12073458f, -0.21609114f, 0.05638491f, -0.14184970f, -0.03962646f, 0.05858421f, 0.11096894f, 0.25565729f, 
    -0.04447070f, 0.03698817f, -0.02465582f, 0.04396375f, 0.00873024f, -0.03856715f, 0.01780372f, -0.05265826f, 
    -0.00019911f, -0.03581997f, -0.00459568f, -0.05222487f, -0.06430195f, -0.05353932f, 0.01932861f, 0.02845281f, 
    -0.01110519f, -0.00458219f, -0.05716496f, -0.00935860f, -0.04455636f, 0.00118776f, -0.04366641f, -0.02598980f, 
    -0.00253476f, -0.03260077f, 0.00758213f, -0.02033654f, -0.04691955f, 0.01027930f, 0.02100855f, 0.01230894f, 
    -0.02737651f, 0.00775915f, 0.01882954f, -0.00374027f, -0.01051759f, 0.01902981f, -0.00294222f, 0.00990236f, 
    -0.01199307f, -0.03177012f, -0.03510466f, -0.04593519f, 0.02859384f, -0.04219224f, -0.06411488f, 0.00054576f, 
    -0.00436516f, 0.04684140f, -0.01513158f, -0.05004239f, -0.00452294f, 0.00758785f, -0.05023593f, -0.01935305f, 
    -0.03978157f, 0.03436663f, -0.02406514f, 0.01697635f, -0.01545863f, -0.03375950f, 0.02139802f, 0.03314745f, 
    0.02449116f, -0.04509740f, 0.03612938f, -0.02316889f, 0.02874448f, -0.01269652f, 0.02975880f, -0.05409710f, 
    0.01999785f, -0.01458182f, -0.03492947f, -0.06446043f, -0.03247485f, -0.04718069f, 0.01813032f, -0.01746846f, 
    -0.04679663f, -0.06280621f, -0.02732170f, -0.02586731f, 0.00418996f, -0.06205567f, -0.04207014f, -0.00417498f, 
    -0.00714445f, -0.05880248f, 0.02354793f, 0.02233619f, -0.03961542f, 0.01996694f, -0.02363418f, 0.02211198f, 
    0.01844411f, -0.05907998f, -0.05916461f, 0.02167619f, 0.00484726f, -0.00356553f, -0.05366915f, -0.01996902f, 
    0.02038210f, -0.04300823f, -0.04444449f, -0.00420891f, 0.03662818f, 0.05046189f, -0.01319523f, 0.00536130f, 
    -0.03212861f, -0.01910075f, -0.04526271f, -0.03714533f, -0.03020265f, -0.03116638f, -0.00933609f, -0.00339663f, 
    -0.05987604f, -0.04254663f, -0.02085604f, -0.02157302f, -0.03469231f, -0.03761497f, -0.02005911f, -0.03928639f, 
    -0.05582255f, -0.04101697f, -0.06265863f, -0.04785764f, -0.05062618f, -0.01581960f, 0.01349064f, 0.02509475f, 
    -0.00466966f, 0.01076231f, 0.00494990f, -0.03757129f, 0.01901313f, 0.01657413f, 0.00743155f, -0.05950325f, 
    -0.03289182f, 0.01962404f, 0.02016473f, -0.01051587f, -0.00243531f, -0.03736741f, -0.03260456f, -0.03883706f, 
    -0.04930734f, -0.02856084f, -0.02099949f, -0.03561835f, 0.01924434f, -0.00010419f, 0.01878285f, -0.01917636f, 
    -0.03381202f, -0.04509446f, -0.05200418f, -0.01244893f, -0.00917599f, -0.03764300f, -0.01215181f, -0.05017964f, 
    -0.01451131f, -0.05758055f, -0.01388962f, -0.03409356f, -0.00052438f, -0.00678267f, -0.05569223f, 0.01944793f, 
    0.01701052f, 0.00584438f, 0.03029075f, -0.03074294f, 0.02540135f, -0.01853263f, 0.01246115f, -0.00443518f, 
    -0.04510222f, 0.03372405f, -0.01501606f, -0.04892291f, -0.04883930f, 0.00023191f, -0.02730712f, 0.02073915f, 
    -0.03964765f, 0.03172098f, -0.01923490f, -0.02851553f, -0.06238508f, 0.00002199f, -0.05955256f, 0.01081597f, 
    0.01817538f, 0.03196765f, 0.02878487f, 0.02300322f, 0.04663820f, 0.02094689f, -0.02217760f, -0.05027985f, 
    0.04912930f, 0.00281388f, -0.05278066f, 0.03493917f, 0.00643293f, -0.01793932f, 0.01075106f, -0.03698231f, 
    -0.03487581f, -0.02408587f, -0.01997162f, 0.00111442f, 0.00832930f, 0.02669789f, -0.03834791f, -0.01972068f, 
    -0.04471093f, -0.05295021f, -0.05810611f, -0.05648388f, 0.02066869f, -0.00538389f, 0.01348451f, 0.02357029f, 
    -0.02887945f, -0.01149729f, -0.05778625f, -0.05535008f, 0.03330955f, 0.03589356f, -0.05133621f, -0.06384296f, 
    -0.00479568f, -0.04928946f, 0.03419600f, 0.02265264f, -0.02404904f, -0.02844032f, -0.04450459f, 0.02698541f, 
    -0.00403837f, 0.03661468f, -0.01594275f, -0.01383119f, -0.05578062f, 0.02046687f, -0.02199288f, -0.02141857f, 
    -0.02123063f, 0.02760325f, 0.03461721f, 0.03023159f, -0.03921608f, -0.01051029f, -0.04986474f, 0.00054683f, 
    -0.00432255f, 0.03195347f, 0.01381938f, 0.01615582f, -0.06155531f, -0.03897133f, -0.05377108f, -0.04946318f, 
    -0.02365691f, -0.05278211f, -0.06357465f, -0.04475264f, -0.00388919f, -0.05782073f, -0.02965263f, 0.02744755f, 
    0.01232545f, -0.01664516f, -0.05458218f, -0.00396389f, -0.02814690f, -0.03889930f, -0.05792718f, -0.06100895f, 
    -0.03610295f, 0.02134422f, -0.01021322f, -0.04284850f, -0.05952169f, -0.02500284f, -0.06301685f, -0.02800342f, 
    0.02959705f, -0.02444818f, 0.01620456f, -0.06359200f, 0.02325887f, 0.01782212f, -0.06394310f, 0.01889686f, 
    -0.03326507f, -0.05703768f, 0.03641826f, -0.05065370f, -0.02146375f, -0.04185155f, 0.00241795f, 0.02191347f, 
    -0.02298607f, -0.01344640f, 0.03113719f, -0.04537970f, -0.05147832f, 0.00818222f, 0.01364038f, -0.00104393f, 
    -0.04158055f, 0.01262968f, -0.00021432f, -0.03591882f, -0.02313495f, -0.02267564f, 0.03595101f, 0.00592848f, 
    -0.05702574f, -0.02932400f, -0.02721260f, -0.00340183f, -0.04548750f, 0.01629931f, -0.03393609f, -0.02671825f, 
    0.02067159f, -0.00959150f, -0.04945992f, 0.03457697f, -0.04613309f, 0.01073882f, -0.02531589f, 0.00509094f, 
    -0.00870089f, 0.03330391f, 0.00817957f, -0.04828403f, -0.02739300f, -0.00222556f, 0.01798982f, -0.04790252f, 
    0.00187891f, 0.02128829f, -0.02425260f, 0.03748152f, -0.00310868f, -0.01220894f, -0.05993696f, 0.02778640f, 
    0.03339686f, -0.05813367f, -0.04397675f, 0.02020842f, 0.03567728f, -0.02027779f, -0.00204811f, -0.05972446f, 
    -0.05422736f, -0.01626864f, -0.03046482f, 0.02665117f, -0.02222792f, -0.05462136f, -0.04123498f, 0.02294098f, 
    0.02322929f, -0.04446695f, 0.01902564f, -0.05570011f, -0.00469690f, 0.00246393f, 0.00918994f, 0.01631502f, 
    -0.06393668f, 0.09646536f, 0.26391193f, -0.08951014f, -0.28281325f, -0.22143579f, -0.10948357f, -0.14067613f, 
    -0.05582603f, 0.06442413f, 0.00225120f, -0.05336462f, 0.25422603f, 0.32289270f, 0.03176083f, 0.16985947f, 
    -0.00107245f, -0.08665603f, 0.11312443f, -0.01492885f, -0.00323187f, 0.04166997f, -0.01350890f, 0.16033004f, 
    -0.16122702f, 0.12879448f, 0.20563073f, 0.25726831f, -0.04717281f, -0.06486455f, 0.04012110f, -0.02263646f, 
    0.10372446f, -0.00583831f, 0.04301229f, 0.19423802f, -0.20232676f, -0.06775181f, 0.06820057f, -0.21411809f, 
    -0.11750311f, -0.12559421f, -0.15467438f, -0.06782075f, -0.02067391f, -0.02962041f, 0.17604616f, 0.08226801f, 
    0.03059147f, -0.05713668f, 0.01150766f, -0.12089688f, 0.05256888f, 0.05994938f, 0.07860970f, -0.34489039f, 
    0.07834011f, -0.00073941f, 0.08408399f, 0.06086291f, 0.07957123f, -0.17855890f, 0.02138979f, 0.18604097f, 
    0.04666699f, 0.15205562f, 0.19390471f, 0.15438455f, -0.00980200f, -0.01389107f, 0.00506654f, -0.01423983f, 
    -0.05077758f, 0.14710560f, -0.02936852f, -0.03489914f, -0.05032146f, -0.02023837f, 0.15399250f, 0.07615893f, 
    0.07011992f, 0.05008152f, 0.20645520f, 0.15092400f, 0.08983080f, -0.05252014f, -0.03393606f, -0.00385124f, 
    0.03321454f, -0.00078049f, 0.04397736f, 0.27147490f, 0.03947339f, 0.06359602f, 0.06015243f, -0.08110044f, 
    -0.10072827f, -0.08296336f, 0.04129234f, -0.14679956f, -0.11814000f, -0.01139261f, 0.13322820f, -0.03391666f, 
    -0.03352314f, -0.06294430f, 0.22045867f, 0.04616448f, -0.35385397f, -0.28890115f, 0.25249937f, 0.17524336f, 
    -0.07097580f, -0.00403161f, -0.00597476f, -0.16389021f, -0.02915887f, 0.10557868f, -0.08699347f, 0.01755500f, 
    0.12956820f, 0.31196192f, 0.03944298f, -0.02673354f, -0.06410068f, -0.01008457f, -0.01141466f, -0.00914133f, 
    0.02695769f, 0.33241865f, 0.20378126f, 0.33055452f, -0.00960739f, -0.08152609f, -0.09024104f, -0.19873458f, 
    -0.01302445f, 0.04179461f, 0.04962796f, -0.05857772f, 0.00726407f, -0.00768414f, 0.01759007f, -0.10613484f, 
    -0.17123932f, -0.22423193f, 0.22696164f, -0.04977270f, -0.04115503f, -0.01096060f, -0.06735940f, -0.01177411f, 
    0.04323116f, 0.03668427f, -0.00455752f, -0.04510843f, 0.13437027f, 0.06447229f, -0.03300859f, 0.13537689f, 
    0.09872238f, 0.10801318f, 0.04495411f, 0.12132466f, -0.01676742f, 0.02583716f, -0.07720075f, -0.08823760f, 
    -0.09939354f, -0.11097610f, -0.11743689f, 0.11214292f, -0.07933844f, -0.01486948f, -0.05133575f, 0.10930696f, 
    -0.05257030f, -0.09541287f, -0.02369596f, 0.03560075f, -0.24711797f, -0.16403699f, -0.05342140f, -0.05389681f, 
    -0.17529941f, -0.19846247f, -0.01473330f, -0.21730700f, 0.01071583f, -0.02633349f, -0.03984326f, 0.02562514f, 
    -0.58692312f, 0.09747038f, 0.01839906f, 0.00873081f, 0.04672729f, 0.06209312f, 0.01347490f, 0.09961473f, 
    0.03287955f, -0.01892604f, 0.14054300f, 0.17291541f, -0.33774498f, -0.07694261f, 0.15892626f, 0.11469620f, 
    -0.14587627f, 0.00641367f, 0.07100057f, 0.09502130f, 0.16500944f, 0.13581637f, 0.15912382f, 0.08729501f, 
    -0.10368312f, 0.05716521f, -0.01644721f, 0.00523783f, 0.03586037f, 0.04175657f, -0.10371194f, 0.00092647f, 
    0.03956317f, -0.08059028f, 0.00525442f, -0.05976643f, 0.02479536f, -0.05544959f, -0.15648597f, 0.15046728f, 
    0.06397846f, 0.03990782f, -0.04601119f, 0.00642556f, 0.10833854f, -0.02233762f, 0.21446605f, 0.04938441f, 
    -0.01346376f, -0.19040063f, -0.04701108f, 0.36744475f, -0.05261194f, 0.01072101f, -0.02667786f, -0.13943559f, 
    0.13536312f, -0.00090155f, -0.04323373f, 0.18859789f, 0.00321471f, -0.04387441f, 0.01150219f, -0.10443491f, 
    0.04936729f, -0.04982137f, -0.06576658f, 0.09620370f, 0.04561863f, -0.20182244f, 0.02486990f, -0.12132929f, 
    -0.44610411f, 0.00157456f, 0.27653649f, 0.30226132f, -0.10720783f, 0.03569989f, 0.06324690f, -0.00252116f, 
    0.06617515f, 0.05795702f, 0.13545558f, 0.08939244f, 0.00935826f, 0.02286485f, -0.05115433f, 0.09940503f, 
    0.06699989f, 0.08466916f, 0.12763351f, 0.03999246f, 0.05697866f, -0.05442352f, -0.09870067f, -0.07660845f, 
    0.04818531f, 0.24862963f, 0.06524392f, 0.03905474f, 0.11910998f, 0.02035571f, 0.01882339f, 0.05819523f, 
    0.10288391f, -0.03431990f, -0.09148467f, 0.17945848f, -0.01091055f, -0.08393070f, -0.14788581f, 0.04949415f, 
    0.02502099f, 0.03013766f, -0.00107634f, -0.04666063f, 0.02686290f, -0.02307935f, 0.25301722f, -0.18216354f, 
    -0.22562356f, 0.16990010f, 0.17960544f, 0.12556498f, 0.00434522f, 0.02291181f, 0.03298404f, 0.08110934f, 
    -0.08026972f, -0.00909072f, 0.08203373f, 0.01082475f, -0.11574011f, -0.00768471f, 0.01164041f, -0.12209313f, 
    0.08568586f, -0.17504035f, 0.07933945f, -0.23462488f, 0.02330222f, -0.08724712f, -0.08095049f, -0.00729792f, 
    -0.26850802f, -0.32786131f, 0.07033973f, 0.32874763f, 0.23176938f, -0.11152012f, -0.04592414f, -0.10236781f, 
    -0.06725898f, 0.12655696f, 0.15209106f, -0.07832916f, -0.12875046f, 0.03178254f, 0.01691398f, 0.11555942f, 
    0.06321657f, 0.06548365f, 0.05434119f, -0.12704638f, 0.07832856f, 0.01115946f, 0.03937691f, -0.02248876f, 
    0.00115146f, -0.05749753f, 0.04960691f, 0.17819323f, 0.06575653f, -0.01193635f, 0.00371421f, 0.00032580f, 
    0.08919417f, -0.01440104f, 0.00642066f, 0.03977706f, 0.02688813f, -0.03240180f, -0.13077940f, -0.06707506f, 
    0.06547999f, 0.00762775f, -0.00797749f, 0.04834627f, -0.07746328f, -0.12302294f, -0.08200071f, -0.13170391f, 
    -0.00639867f, -0.04801445f, -0.04643487f, -0.04225073f, -0.02338233f, -0.03201018f, -0.00167368f, 0.00583012f, 
    -0.01304359f, 0.03495252f, 0.00352274f, 0.00771911f, -0.04077847f, 0.02986360f, 0.02752304f, 0.01028946f, 
    -0.05575025f, 0.02032336f, -0.00673573f, -0.04040939f, -0.02031539f, -0.02998284f, 0.00956833f, -0.05635951f, 
    -0.01210756f, 0.03451888f, 0.01965096f, -0.05871461f, 0.01638021f, -0.02065194f, 0.02188314f, 0.00388056f, 
    -0.04719064f, -0.04228433f, 0.00133370f, -0.01607761f, -0.05323780f, 0.00476116f, 0.01080498f, 0.00313125f, 
    -0.04258911f, 0.02954390f, -0.04084135f, -0.02525714f, 0.00642358f, -0.00524444f, -0.05569154f, 0.02436056f, 
    0.01293668f, -0.04633209f, -0.05046578f, -0.03608046f, 0.03545856f, -0.02774918f, 0.03914531f, 0.02078540f, 
    -0.03229561f, 0.03681245f, -0.00790955f, -0.02829839f, 0.03206286f, -0.03995061f, -0.04418372f, -0.01992238f, 
    -0.05755670f, 0.01705895f, -0.02500139f, -0.05028391f, -0.03659912f, 0.00990290f, -0.00526975f, 0.01553117f, 
    0.03453064f, -0.04873196f, -0.04562404f, 0.01916628f, 0.02146707f, 0.03452655f, -0.01681182f, 0.02216724f, 
    0.03599658f, 0.03200932f, -0.02010926f, -0.01672620f, -0.02036419f, 0.03850506f, 0.02175176f, -0.02790360f, 
    0.00928111f, 0.01026906f, -0.01356870f, 0.02261841f, 0.01731499f, 0.04078671f, 0.02122147f, 0.02961058f, 
    -0.01660082f, 0.01171760f, 0.00028500f, -0.05708430f, -0.03238499f, -0.00049643f, -0.02076307f, -0.00647121f, 
    0.01330450f, -0.04205954f, -0.05824963f, -0.02000636f, -0.05613210f, -0.01460042f, -0.01065493f, -0.00012558f, 
    0.03938247f, 0.03415519f, -0.01197068f, 0.04002376f, 0.03036234f, 0.01853110f, 0.01607453f, 0.00338039f, 
    0.04070679f, -0.04948648f, 0.01836445f, -0.00701505f, -0.02987329f, 0.02221829f, 0.04765765f, -0.00902043f, 
    -0.02208318f, -0.05829547f, -0.02237400f, 0.02453269f, 0.03843959f, 0.02842411f, -0.01879397f, 0.01491975f, 
    -0.05171382f, 0.00501127f, 0.02653779f, -0.03505379f, -0.00379703f, -0.05781497f, -0.04579826f, 0.00368946f, 
    -0.02946525f, -0.00940043f, -0.04551860f, 0.02193866f, -0.02356339f, -0.05771286f, -0.01216719f, 0.00176684f, 
    -0.01661306f, -0.03134539f, -0.04005514f, 0.00509749f, 0.04308122f, -0.02207941f, -0.00489857f, -0.03694081f, 
    0.03837560f, -0.04173100f, 0.00140292f, 0.00980062f, -0.02112090f, -0.01856149f, -0.03978522f, -0.04177293f, 
    -0.01992535f, -0.03450567f, -0.04099241f, 0.03793989f, 0.02490075f, -0.00504832f, 0.01230911f, -0.04541253f, 
    0.03494947f, -0.04975750f, -0.04420936f, 0.00627318f, -0.01277399f, 0.03282962f, 0.03007887f, -0.02370863f, 
    -0.04383520f, 0.03834789f, -0.02661864f, -0.04151384f, 0.01741449f, -0.04346083f, 0.03119706f, -0.02252252f, 
    0.02533921f, 0.00359254f, 0.02265171f, -0.03126151f, -0.01269440f, -0.05123618f, -0.05581554f, -0.04851059f, 
    0.01361339f, 0.00235238f, 0.03266601f, 0.02055289f, -0.00943665f, 0.03344416f, 0.03936801f, -0.03940000f, 
    -0.00883762f, -0.03130637f, -0.02803654f, -0.00777647f, 0.03224453f, -0.05850550f, 0.03731601f, -0.00230374f, 
    -0.04664085f, -0.00054735f, -0.01188996f, 0.01326715f, 0.00708508f, 0.02930238f, 0.02284377f, -0.05037501f, 
    -0.03565209f, -0.04234078f, 0.02424899f, -0.01163108f, 0.03744322f, -0.05155182f, -0.03842642f, -0.03853511f, 
    0.04256047f, 0.01078306f, -0.02104724f, -0.03077468f, -0.00492770f, 0.01794933f, 0.02455544f, 0.02899806f, 
    -0.00837241f, -0.03565535f, 0.01834210f, -0.03412687f, -0.04342978f, -0.02205915f, -0.03544091f, 0.00262022f, 
    -0.04036841f, -0.01000191f, -0.00035837f, 0.02361577f, -0.00788698f, -0.04911544f, 0.04317413f, 0.01251037f, 
    0.03952455f, -0.04330736f, 0.01344945f, -0.04435638f, 0.01463487f, -0.04817208f, -0.02234406f, -0.05166117f, 
    -0.02843844f, 0.01329172f, 0.02219624f, -0.00763381f, 0.01214615f, -0.02811802f, 0.03593061f, 0.01001693f, 
    0.03197215f, 0.02551321f, -0.01971023f, 0.00289051f, -0.04715534f, -0.00055194f, -0.04941019f, -0.02367444f, 
    0.03426957f, -0.04457386f, 0.01280994f, -0.02631781f, 0.03204910f, 0.02763207f, -0.03749605f, -0.01001123f, 
    0.01932511f, 0.02193280f, 0.02910429f, -0.02746411f, -0.02395698f, -0.04506814f, -0.04521279f, 0.04644814f, 
    -0.04822740f, -0.04173913f, 0.03840914f, -0.01032403f, -0.02413733f, 0.00684539f, -0.00084997f, -0.01646980f, 
    -0.00025587f, 0.03115578f, -0.00705509f, 0.01700330f, 0.03803428f, -0.01545292f, 0.03595784f, -0.00068964f, 
    -0.02021656f, -0.03128994f, -0.05228340f, 0.03560473f, 0.02269966f, -0.03730411f, 0.03541772f, -0.01720788f, 
    0.02244105f, -0.05661559f, -0.04098489f, -0.00191385f, -0.01005223f, 0.04300468f, -0.04272962f, -0.01645140f, 
    0.01156836f, -0.04578121f, 0.02978515f, 0.01337191f, 0.00382643f, 0.02872229f, -0.04598203f, 0.03730430f, 
    0.03498937f, 0.02116431f, 0.00519206f, 0.00120907f, 0.01387339f, 0.03155567f, -0.03112469f, -0.00087128f, 
    -0.00034813f, -0.02389801f, -0.04199243f, -0.03114824f, -0.02687852f, -0.02160485f, -0.01428120f, -0.01698762f, 
    -0.02446709f, 0.02316119f, 0.00483139f, -0.00913700f, 0.01641634f, -0.00359304f, -0.00399119f, 0.01985634f, 
    -0.04077549f, -0.03852321f, 0.01861346f, -0.00264757f, 0.01487146f, -0.05120990f, 0.00408342f, -0.03954207f, 
    -0.00518237f, -0.00235362f, 0.00806515f, -0.02611712f, -0.02028524f, 0.04313334f, -0.04940556f, 0.01129436f, 
    0.04674781f, 0.00888519f, 0.00959126f, -0.01148748f, 0.01246960f, -0.03928044f, 0.00297054f, -0.02543962f, 
    0.12134025f, -0.01130547f, 0.11138549f, 0.11155425f, -0.10693696f, 0.12013431f, -0.08262277f, -0.03272406f, 
    0.00590731f, 0.08739149f, -0.12213621f, -0.05613021f, 0.03192321f, 0.10963918f, -0.20197126f, 0.43732339f, 
    0.05374925f, -0.02010057f, 0.14368892f, 0.15985973f, 0.09907143f, 0.04735550f, 0.05779734f, 0.09571669f, 
    -0.23857905f, -0.02748458f, -0.01355569f, -0.07696128f, 0.03835428f, 0.03536582f, 0.05010532f, 0.10766216f, 
    0.17371185f, 0.12247872f, -0.02039021f, -0.08853858f, 0.05979570f, 0.06848813f, 0.16566318f, -0.09564310f, 
    -0.05667870f, 0.03944122f, -0.20177431f, -0.09445623f, 0.14149806f, 0.08443812f, 0.06461488f, 0.09962460f, 
    0.09330107f, -0.03627753f, 0.18361385f, 0.05187579f, 0.16372113f, 0.03090712f, 0.03160126f, -0.16268241f, 
    0.02090740f, 0.02639119f, 0.03701803f, -0.05831525f, 0.23202373f, 0.08986624f, 0.11997887f, 0.10512509f, 
    -0.05728503f, 0.08170256f, 0.03174943f, 0.03248742f, -0.05078470f, -0.04359946f, -0.08991002f, 0.04254762f, 
    0.07041529f, -0.00397154f, -0.08429383f, -0.12315284f, 0.04629592f, 0.07113412f, 0.06226470f, 0.13839266f, 
    0.10776795f, 0.10984094f, 0.06992247f, -0.11795557f, 0.15858535f, -0.09010429f, 0.03208673f, -0.04277842f, 
    -0.01933534f, 0.01315155f, -0.04295707f, 0.27596495f, -0.04597176f, 0.05538563f, 0.09810224f, -0.07440052f, 
    0.08782869f, -0.04230936f, 0.15905474f, -0.06464088f, -0.02323170f, 0.03624654f, 0.10871986f, 0.03435900f, 
    0.07413842f, -0.00169452f, 0.05409792f, -0.06703460f, -0.10848524f, 0.07962938f, -0.03123282f, 0.34206977f, 
    0.03285939f, 0.10561205f, 0.14051813f, -0.20885098f, -0.12146952f, 0.12696074f, -0.03144799f, -0.02439296f, 
    0.13909386f, 0.12182377f, -0.02822367f, 0.06435012f, 0.02485386f, 0.01962754f, -0.03716221f, 0.00313599f, 
    0.02856686f, 0.00957513f, -0.03350160f, 0.00545484f, 0.03943613f, 0.03249473f, 0.06541511f, -0.09731296f, 
    -0.04229512f, -0.01602737f, -0.02935655f, -0.07522031f, -0.07618358f, -0.06198390f, -0.00447117f, -0.07237326f, 
    0.10691452f, -0.05343304f, 0.35013741f, 0.02975993f, -0.00688288f, 0.14662670f, -0.14031771f, 0.05755107f, 
    0.02291985f, 0.02462165f, -0.04421090f, 0.01561245f, 0.10671596f, 0.15214251f, 0.02997576f, 0.11361860f, 
    0.07122699f, 0.05231198f, -0.09191746f, 0.04930958f, -0.01425041f, -0.01178665f, 0.04050113f, -0.08140066f, 
    -0.14079459f, 0.14335303f, 0.29416630f, 0.09892607f, -0.15084629f, -0.16829291f, 0.06599835f, 0.11260863f, 
    -0.05523864f, -0.07678390f, 0.00511380f, 0.24897178f, -0.03484813f, -0.06163755f, -0.04163864f, 0.16473345f, 
    0.00485421f, 0.00576397f, 0.02569008f, -0.17039822f, 0.05404094f, 0.03256501f, 0.12227561f, 0.01029345f, 
    -0.22095881f, 0.23482493f, -0.37970319f, 0.07678922f, 0.00884826f, 0.05083237f, 0.01653881f, 0.09729383f, 
    -0.05242347f, -0.11173073f, 0.00108772f, 0.08198727f, -0.18399008f, 0.07325026f, -0.03569455f, -0.17722899f, 
    -0.04150299f, 0.05301420f, 0.09784387f, 0.07489519f, 0.09218046f, 0.10449614f, -0.02893292f, -0.06155049f, 
    -0.08226309f, 0.07596635f, -0.17279913f, 0.03402700f, 0.02485867f, 0.10199297f, -0.02818385f, -0.01373177f, 
    0.10649014f, -0.01202434f, -0.03535076f, -0.02586948f, 0.06805359f, 0.07205461f, -0.33470187f, 0.11666507f, 
    0.00456585f, 0.00808885f, 0.02983804f, 0.05221073f, 0.08969750f, -0.06612880f, 0.15012369f, 0.06201848f, 
    -0.17365500f, -0.18715598f, 0.07320941f, 0.11203715f, 0.03517773f, 0.12464461f, 0.01100959f, 0.06989619f, 
    0.12680489f, -0.08909375f, -0.10850755f, 0.05986279f, 0.01087270f, -0.03761103f, -0.02926531f, -0.05653607f, 
    -0.00736665f, 0.00352224f, -0.13149442f, 0.05439612f, 0.05744592f, -0.04755821f, -0.01934010f, 0.03985834f, 
    -0.46650392f, 0.01413061f, -0.02290296f, -0.00792486f, -0.07942999f, 0.02575007f, 0.10842484f, 0.00281264f, 
    -0.17249234f, 0.06586839f, 0.01974809f, -0.14390336f, 0.02581800f, 0.12385490f, -0.04737199f, 0.08259078f, 
    0.02423945f, 0.01602351f, -0.03228043f, -0.01906653f, -0.03604472f, -0.01927408f, -0.04450595f, -0.10834306f, 
    0.17295565f, -0.19943209f, -0.16954149f, 0.29864413f, 0.08768897f, 0.05418118f, 0.02980547f, -0.11974137f, 
    0.11763907f, 0.04565641f, 0.01951207f, 0.18740740f, 0.08813901f, -0.01213006f, -0.10029612f, -0.01098686f, 
    -0.05846408f, -0.02644583f, 0.11462482f, -0.09734154f, -0.08920831f, -0.07779727f, 0.15869030f, 0.00122675f, 
    -0.19791755f, -0.23204947f, -0.07627801f, -0.01007046f, 0.06628002f, 0.00057939f, -0.03679500f, 0.12969698f, 
    -0.00635859f, 0.03022067f, 0.15565713f, -0.00040525f, -0.03109358f, 0.02981262f, 0.04472489f, -0.00138036f, 
    0.12867795f, -0.17142631f, 0.13036574f, -0.01834982f, -0.01837133f, -0.04027259f, 0.07025218f, 0.06369938f, 
    -0.14573123f, 0.12183689f, -0.09051514f, 0.19107331f, 0.03577121f, -0.07167515f, 0.14325783f, -0.03391163f, 
    -0.09454133f, 0.09414817f, 0.08010165f, 0.11407386f, 0.00403517f, 0.26232132f, 0.16355142f, 0.31481993f, 
    0.10623735f, 0.10241354f, 0.05938923f, -0.08556169f, -0.06457710f, -0.04531483f, 0.09867539f, -0.01019293f, 
    0.05646949f, -0.15111275f, 0.20729771f, 0.03589226f, -0.05166690f, -0.16693830f, 0.04310637f, 0.08491184f, 
    0.18774612f, 0.01499985f, 0.01672717f, 0.14072721f, 0.03409593f, 0.00724157f, -0.05036286f, -0.06509197f, 
    -0.01997114f, -0.06809647f, -0.01979922f, 0.04431797f, -0.08424593f, 0.00035015f, -0.01145490f, -0.03735693f, 
    0.02969774f, -0.00109650f, -0.05195740f, 0.00475496f, -0.05614244f, -0.01011523f, 0.03998433f, 0.04748333f, 
    0.02178278f, -0.02009482f, 0.01680674f, -0.00732797f, 0.03732726f, 0.02895475f, -0.01279262f, -0.00540744f, 
    -0.04838647f, -0.02619266f, -0.04371860f, -0.05184190f, 0.00215606f, -0.00773312f, -0.02622532f, 0.03210167f, 
    0.01021403f, -0.04485222f, 0.01777686f, 0.02450819f, 0.03011821f, 0.00022728f, -0.03863762f, -0.03881155f, 
    0.00783657f, 0.03942843f, -0.05419609f, -0.04310495f, 0.02512391f, 0.04174806f, -0.02619469f, -0.03677320f, 
    -0.01095046f, 0.03782689f, -0.03743512f, 0.03659764f, -0.00434188f, -0.02361659f, 0.02540094f, -0.02774434f, 
    -0.01571289f, 0.04412194f, 0.03991157f, -0.04222086f, -0.01441940f, -0.05681655f, -0.00281533f, 0.02771090f, 
    0.00640067f, 0.03342215f, 0.01819167f, -0.02595889f, 0.02770442f, 0.04639178f, 0.04215022f, 0.00609323f, 
    0.02184920f, -0.00788160f, -0.05563873f, -0.03077401f, -0.05104877f, -0.03415821f, -0.01044733f, -0.03770998f, 
    -0.03542387f, -0.02999748f, -0.05503850f, -0.02863358f, 0.02829037f, 0.02402103f, -0.00971766f, 0.03409917f, 
    -0.01186357f, 0.00739189f, -0.05149646f, -0.05092598f, -0.05257514f, -0.01572560f, 0.02997374f, -0.04698041f, 
    -0.01808197f, 0.00077337f, 0.01563531f, -0.01333436f, -0.02688080f, 0.00281776f, -0.00148371f, -0.03947152f, 
    -0.00627408f, 0.00651362f, 0.04736555f, -0.04138674f, -0.00704377f, 0.03320635f, 0.02049104f, -0.05447917f, 
    -0.03345311f, 0.02324775f, -0.00166489f, 0.04392947f, -0.02956822f, -0.03815507f, -0.00609291f, -0.02280251f, 
    -0.03917082f, -0.03734955f, -0.00322407f, -0.04483376f, -0.03781535f, 0.00989530f, 0.01658642f, -0.05445689f, 
    -0.04298897f, -0.01626760f, 0.01650675f, -0.05168071f, 0.00669291f, 0.02573427f, 0.03850000f, -0.00877767f, 
    -0.04141895f, -0.04926131f, 0.03382500f, -0.04589630f, -0.04014745f, -0.01532696f, -0.02580136f, 0.00476148f, 
    -0.03159912f, 0.01326725f, -0.00577041f, -0.04084210f, -0.04994491f, -0.00466689f, 0.04455955f, -0.03767326f, 
    -0.00050228f, 0.04202369f, -0.03561501f, -0.05176268f, -0.02521887f, -0.04313755f, 0.03822634f, 0.02303916f, 
    -0.02986244f, 0.01769465f, -0.04334867f, 0.01908537f, 0.04054075f, -0.03239282f, -0.00183461f, -0.00648984f, 
    -0.05541106f, -0.00971850f, 0.04087139f, -0.00357911f, 0.04040977f, 0.00007270f, 0.00738360f, 0.03992078f, 
    -0.00188519f, 0.00511342f, -0.00102532f, 0.00528710f, -0.01219116f, 0.04395689f, 0.01609437f, -0.04066999f, 
    -0.05279917f, -0.03352508f, 0.00705889f, -0.02841317f, 0.00703442f, -0.04347815f, 0.04000721f, 0.02062440f, 
    0.01105207f, -0.01373637f, -0.02488593f, 0.00305544f, 0.04397197f, 0.01482571f, -0.04460267f, 0.04320358f, 
    0.01728157f, 0.03113471f, 0.00858783f, -0.05611147f, -0.00745343f, 0.01868152f, 0.01368464f, -0.01036771f, 
    0.03653106f, 0.04908960f, -0.01775296f, -0.01915258f, 0.01679029f, 0.01105590f, -0.05608781f, 0.03539805f, 
    -0.02279530f, -0.04513912f, -0.03388702f, 0.04116759f, -0.03878941f, 0.00500548f, -0.03881574f, -0.02428161f, 
    0.03554271f, -0.01900195f, 0.01157757f, 0.01802396f, 0.01382980f, -0.03664839f, -0.01082002f, -0.04658305f, 
    -0.04677480f, 0.00281300f, -0.03025220f, -0.04594380f, 0.00803662f, -0.04424195f, -0.05346463f, 0.02536095f, 
    0.03495848f, -0.00965102f, -0.02547505f, -0.01252585f, 0.00075705f, -0.05613954f, 0.02743913f, -0.04994946f, 
    0.00074092f, 0.02369030f, 0.03822516f, -0.05135785f, -0.00943552f, -0.02345596f, 0.02079955f, 0.04019098f, 
    -0.00315440f, -0.03147797f, 0.03363470f, -0.02108121f, 0.02731849f, 0.00597489f, -0.04234932f, 0.03282550f, 
    -0.04305616f, -0.00903963f, -0.01070280f, -0.02770756f, -0.01223835f, -0.04478732f, 0.04206965f, 0.00558733f, 
    -0.04483703f, 0.01944111f, -0.01150279f, 0.00536466f, 0.03208904f, -0.03593437f, 0.04518203f, -0.05488871f, 
    -0.01609425f, -0.01495722f, -0.01513929f, -0.05210873f, -0.01578428f, 0.01525855f, -0.02565333f, -0.05406657f, 
    -0.04350796f, 0.03910983f, 0.04255652f, 0.01561536f, -0.01517721f, 0.03308681f, 0.00214160f, -0.01278069f, 
    0.00502141f, 0.03856651f, 0.01322748f, 0.02749870f, 0.01215075f, -0.03557158f, 0.04446406f, 0.00847829f, 
    -0.01255317f, 0.00039284f, -0.05700641f, 0.02684938f, -0.03745593f, 0.03567053f, -0.02920813f, -0.03114383f, 
    -0.01318341f, -0.00148797f, -0.01561068f, -0.02767345f, 0.00410477f, 0.02958963f, 0.00455408f, 0.03614528f, 
    0.04453783f, 0.02029056f, -0.01105427f, -0.05102877f, -0.00809451f, -0.05112360f, -0.02957811f, 0.03637307f, 
    -0.02385850f, 0.00334485f, -0.00394356f, 0.01620842f, -0.00698107f, -0.02218736f, -0.05324966f, 0.02445578f, 
    -0.03717721f, -0.03576035f, -0.01767332f, -0.05682394f, 0.01528380f, -0.03246690f, 0.02015447f, 0.01614770f, 
    -0.02212217f, -0.02270005f, -0.03827437f, 0.00243309f, 0.01921089f, 0.03695060f, -0.00915519f, 0.03051581f, 
    -0.02222186f, -0.04078464f, 0.03417219f, 0.00873361f, 0.02319115f, -0.02929499f, -0.05371919f, 0.02144617f, 
    0.01481551f, 0.01554255f, -0.01727524f, -0.03369642f, 0.02411791f, -0.03135778f, -0.00965647f, -0.02299692f, 
    0.03557245f, 0.03301789f, -0.01889011f, -0.01761064f, 0.00092935f, -0.04340303f, -0.00912736f, -0.05231800f, 
    0.01677455f, 0.00039546f, 0.03416571f, 0.04157915f, -0.04261569f, -0.03737451f, 0.03314703f, -0.02864210f, 
    0.03722020f, -0.04832723f, -0.04827382f, 0.01135959f, -0.03641115f, -0.04682383f, -0.00274554f, 0.00144534f, 
    -0.25038123f, 0.05666352f, 0.19496131f, 0.18343195f, 0.03987529f, -0.06164684f, 0.02045609f, 0.08708514f, 
    0.17836066f, 0.05060633f, 0.09106921f, 0.09580851f, 0.33825034f, -0.05149506f, -0.06030348f, -0.14916807f, 
    -0.04679393f, 0.01031937f, -0.04514590f, 0.01103103f, 0.09281942f, 0.06184701f, 0.04802073f, 0.02991688f, 
    -0.01424326f, -0.00022341f, 0.01280048f, -0.03719039f, -0.10503402f, -0.11412768f, -0.00773084f, -0.03182711f, 
    -0.01481076f, -0.03890859f, 0.27869076f, 0.06021893f, -0.10615747f, 0.02637479f, 0.14977154f, 0.25100774f, 
    0.08436561f, -0.00764991f, -0.09324901f, 0.17387503f, 0.01809616f, -0.01560151f, 0.02576968f, -0.02822376f, 
    -0.11786737f, -0.02833272f, -0.11415896f, -0.10365913f, -0.10801785f, -0.02121972f, -0.12858701f, -0.06345669f, 
    -0.03573027f, -0.04190957f, 0.09971357f, 0.05393003f, 0.17353167f, -0.05404831f, -0.06101940f, 0.03311556f, 
    -0.00298360f, 0.01505332f, -0.04570697f, -0.01001414f, -0.05108776f, 0.01516782f, -0.00452982f, -0.00946369f, 
    -0.14787866f, 0.06288210f, -0.06027751f, -0.02906792f, -0.02534130f, -0.02520580f, 0.00709071f, -0.16830266f, 
    -0.01277838f, 0.05429498f, -0.03070599f, 0.21203861f, -0.05406811f, 0.06816816f, -0.05414070f, 0.05252348f, 
    -0.01984863f, 0.07646123f, 0.16412930f, -0.14203471f, 0.08699611f, 0.03479245f, -0.03196713f, 0.08053678f, 
    0.01041649f, 0.00586241f, -0.05924607f, -0.07840940f, 0.04380248f, 0.11292663f, -0.03772335f, -0.01112886f, 
    0.04055976f, 0.13293266f, 0.09821996f, 0.18031055f, -0.34479669f, -0.22817865f, 0.26283348f, -0.01436408f, 
    -0.05226946f, -0.00237437f, -0.04350331f, 0.07108303f, 0.03707790f, 0.01826586f, -0.03967019f, 0.01630061f, 
    0.37436634f, 0.26289690f, 0.00187674f, -0.01343511f, 0.03114713f, -0.01270074f, 0.03344317f, -0.03052659f, 
    0.02884982f, 0.14005575f, 0.00171256f, 0.15529190f, 0.31689170f, 0.14179786f, 0.14629850f, 0.11669762f, 
    -0.03611570f, -0.03033569f, 0.01228725f, 0.02480405f, 0.04968897f, 0.02626374f, -0.08486518f, 0.05904175f, 
    -0.35745665f, -0.04723424f, -0.03539679f, 0.05082468f, -0.13689032f, -0.11070170f, -0.00330105f, -0.06362808f, 
    -0.06845520f, -0.00630853f, -0.05779008f, -0.00223886f, 0.12330429f, -0.06547555f, -0.03851052f, 0.02512181f, 
    -0.00162543f, -0.01725223f, -0.02056331f, 0.05705173f, -0.12052667f, -0.09597061f, -0.00764980f, -0.04169986f, 
    -0.18120213f, 0.10925531f, -0.25582525f, 0.21453787f, 0.00690427f, 0.06493518f, -0.02888216f, 0.00731485f, 
    -0.00546406f, 0.12116501f, -0.12821437f, -0.01438256f, -0.12976643f, 0.02197288f, 0.25355595f, 0.26001555f, 
    0.09168285f, -0.06877687f, -0.03132396f, -0.01652671f, -0.04307597f, 0.03355778f, 0.00942656f, 0.00507577f, 
    0.65449399f, -0.09339754f, 0.14400832f, 0.07199316f, 0.03457182f, -0.00381965f, -0.06313822f, -0.04622307f, 
    0.21342167f, 0.14292195f, 0.14761147f, 0.12417369f, -0.19068263f, -0.15577286f, 0.06699888f, 0.13304962f, 
    -0.06943949f, 0.01909461f, -0.08256604f, 0.07939737f, 0.03507934f, 0.01369851f, 0.08964904f, 0.12311330f, 
    0.22203018f, 0.04893814f, 0.08227210f, -0.06201044f, -0.10775483f, -0.13453087f, 0.04568724f, 0.07566479f, 
    -0.03577030f, 0.01480664f, 0.10300592f, -0.01285640f, 0.30317742f, 0.00612435f, 0.19095124f, -0.04756757f, 
    -0.01868771f, 0.02708939f, -0.01312338f, -0.02685182f, 0.10026602f, 0.17147194f, -0.09333454f, -0.01155216f, 
    -0.27612266f, -0.02898957f, -0.08629632f, 0.09445989f, -0.11486275f, -0.05711670f, -0.00759799f, -0.04765222f, 
    -0.02688325f, -0.00554172f, 0.10507152f, 0.13201261f, 0.05943615f, -0.10019317f, 0.25813043f, 0.09734488f, 
    -0.03283829f, -0.05390043f, 0.06742129f, -0.00702694f, -0.02370545f, -0.01088336f, 0.20499562f, -0.09739105f, 
    -0.10804894f, -0.02681213f, 0.11518819f, 0.03201314f, -0.12416741f, -0.04332171f, -0.19570889f, -0.04242695f, 
    -0.09587429f, -0.07199763f, -0.09187324f, -0.03783189f, 0.22729746f, -0.03802101f, -0.04407656f, 0.05207356f, 
    -0.02613460f, 0.02916793f, 0.00304863f, -0.06256867f, -0.00459325f, -0.10287969f, -0.04041896f, -0.06429194f, 
    0.40297344f, 0.27014276f, 0.04363968f, -0.29262447f, 0.02305868f, 0.02675108f, 0.03451464f, -0.05960391f, 
    0.06022324f, 0.10416771f, 0.00499893f, -0.03783661f, 0.24174273f, -0.08848615f, 0.06471878f, 0.16715634f, 
    0.05260759f, 0.08148130f, -0.03624535f, 0.04332406f, 0.04956408f, 0.10362160f, -0.22339989f, 0.12570205f, 
    0.01970464f, 0.02264726f, 0.04012812f, -0.07417922f, -0.10777204f, -0.10911369f, -0.03928804f, -0.08555955f, 
    0.04526302f, -0.01324510f, -0.10205488f, 0.17182152f, -0.14053044f, -0.05339737f, 0.16105106f, 0.17443560f, 
    0.07688618f, -0.00302777f, -0.03379597f, -0.07305317f, 0.02631135f, 0.03296085f, -0.06681476f, -0.06522619f, 
    0.15280727f, -0.22604942f, 0.04189321f, -0.01779502f, 0.00821069f, 0.09726625f, -0.08427770f, 0.07150877f, 
    -0.02226405f, 0.04500945f, -0.08172817f, 0.07018894f, 0.13157566f, -0.03617683f, -0.05088840f, -0.02361350f, 
    -0.09628604f, -0.01903193f, 0.11560269f, -0.08390946f, 0.00067160f, -0.07935628f, -0.02896209f, 0.08847263f, 
    -0.07601237f, 0.28092244f, -0.05911670f, -0.13767764f, -0.06643706f, 0.14151780f, -0.08063361f, -0.03936871f, 
    -0.04799938f, 0.22842908f, -0.12725182f, -0.00261908f, 0.06580766f, 0.03925104f, 0.08814938f, 0.00142407f, 
    0.01795765f, -0.00901672f, -0.04955919f, -0.06644857f, 0.07158291f, 0.02576111f, -0.04474416f, 0.03077908f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03933561f, -0.01316882f, 0.01964881f, 0.07995600f, 0.00369036f, 0.09093932f, 0.02372981f, 0.22253110f, 
    -0.00911646f, 0.11686859f, -0.03378362f, -0.08931733f, 0.04035218f, 0.13916801f, 0.04608273f, -0.03035074f, 
    0.04683922f, 0.02963123f, 0.08973805f, 0.06242216f, -0.00033072f, 0.04905545f, 0.00999424f, 0.15462075f, 
    0.02816096f, 0.09077823f, 0.04226643f, 0.03195032f, -0.02026138f, 0.09860288f, -0.00472685f, -0.08750273f, 
    -0.07672948f, 0.04648649f, 0.02525287f, -0.03165459f, -0.03583465f, 0.08759236f, 0.02196320f, -0.03912094f, 
    0.01442410f, 0.00218406f, -0.03607483f, -0.03016109f, -0.00974237f, -0.00076435f, 0.06746140f, -0.02511874f, 
    -0.08993417f, 0.10973924f, -0.02793067f, 0.05339117f, -0.05751881f, 0.13510697f, 0.14185753f, -0.03388911f, 
    -0.05342700f, -0.08379420f, -0.01913543f, 0.09923261f, 0.02467212f, 0.00323009f, -0.01326557f, 0.13178615f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03287240f, -0.06050592f, -0.43621814f, -0.16935267f, 0.10335448f, 0.14805694f, 0.09406500f, -0.42438790f, 
    0.10444929f, -0.45570844f, 0.10009751f, 0.23291935f, -0.06941637f, -0.28957316f, 0.11832656f, 0.19769062f, 
    0.08051497f, -0.06900726f, -0.00880133f, -0.32796484f, -0.12020335f, 0.13660587f, 0.09196913f, -0.23903577f, 
    0.06009453f, -0.22585160f, 0.01228854f, -0.01486241f, -0.12210979f, -0.17803040f, -0.10991910f, -0.02768542f, 
    0.27689603f, -0.01694465f, 0.09622659f, -0.33580565f, -0.15610926f, 0.11318604f, -0.01195171f, -0.07943852f, 
    0.22091854f, 0.04356098f, 0.05252537f, -0.11130095f, -0.31205663f, -0.00247213f, 0.15095010f, 0.16913943f, 
    0.14765316f, -0.47107217f, 0.11372875f, 0.16822664f, 0.00205612f, -0.19406697f, -0.45793331f, 0.11861406f, 
    -0.07137334f, 0.15489608f, -0.03329667f, -0.21951291f, -0.07650907f, -0.04179035f, -0.12222335f, -0.37190831f, 
    -0.07812423f, -0.08249377f, -0.37206277f, -0.55119985f, 0.12922850f, 0.12613682f, 0.06936282f, 0.16359855f, 
    0.05636583f, 0.16825850f, 0.09657993f, -0.49096754f, -0.13510622f, 0.10099829f, 0.30526406f, 0.06522856f, 
    -0.12178912f, 0.06670145f, 0.12556545f, -0.63215858f, -0.08181806f, 0.17732517f, -0.02967737f, -0.03856591f, 
    0.07614725f, 0.11561476f, -0.10539629f, -0.02455390f, -0.32295519f, -0.10166459f, 0.10486989f, -0.36791831f, 
    0.01570504f, -0.07326210f, 0.22813439f, -0.34168640f, 0.08131170f, 0.16685553f, 0.10846329f, -0.04572577f, 
    0.14426185f, -0.02790677f, -0.25924677f, 0.05946499f, -0.24630298f, -0.04555609f, 0.17611192f, -0.05157313f, 
    -0.17073025f, -0.10237680f, 0.15289184f, -0.08873776f, 0.02987995f, 0.27146417f, 0.17529988f, 0.10196501f, 
    0.00067182f, -0.50880104f, -0.12747467f, -0.23510335f, -0.01383218f, -0.01100406f, 0.02231153f, 0.22529568f, 
    -0.02775311f, 0.05348330f, -0.15440924f, 0.37692022f, 0.05466196f, -0.12632318f, 0.06901626f, 0.23692659f, 
    0.08423778f, 0.11126274f, -0.10497397f, -0.18112472f, -0.04228827f, -0.08327202f, -0.26430643f, -0.01223089f, 
    -0.20429809f, 0.01966996f, 0.08073413f, 0.38868359f, 0.10117570f, 0.27923632f, 0.00441483f, 0.03780987f, 
    -0.03880523f, 0.02232846f, 0.05543718f, -0.02403400f, 0.01023740f, 0.28360480f, -0.09666774f, -0.27753302f, 
    -0.00477458f, -0.20329764f, -0.15778200f, -0.26986080f, -0.02782925f, -0.25378969f, -0.02743853f, 0.04262783f, 
    0.32522726f, 0.04431771f, 0.16815069f, -0.00378008f, -0.19239452f, -0.06651894f, -0.04103845f, -0.29675362f, 
    0.16532761f, 0.06148379f, -0.32963654f, -0.20897344f, 0.08347452f, -0.10134748f, 0.11442064f, -0.07701422f, 
    0.01695260f, 0.30195513f, 0.06918066f, 0.18862794f, -0.07084256f, -0.17828158f, 0.04522935f, -0.06484941f, 
    0.05566858f, -0.01515962f, 0.07364617f, 0.22372088f, -0.19495851f, -0.13052940f, 0.04890842f, -0.15949120f, 
    -0.11598928f, 0.04713657f, 0.01543926f, 0.15734111f, -0.40181032f, -0.61734086f, 0.08293168f, 0.01933207f, 
    -0.23771837f, 0.10639357f, -0.14644845f, 0.30963409f, -0.12340806f, 0.12433367f, 0.10517734f, -0.51527566f, 
    -0.04064247f, 0.03189367f, 0.10069521f, -0.06985244f, 0.35800111f, 0.18547224f, -0.07217337f, 0.09728532f, 
    -0.23709290f, -0.19699323f, -0.11381536f, 0.14891042f, 0.40054169f, -0.05605390f, -0.09938068f, -0.09835863f, 
    0.12986428f, 0.01132224f, 0.25782326f, 0.03980310f, 0.51295012f, 0.09046081f, -0.00307340f, 0.14054017f, 
    -0.06940076f, 0.03335300f, 0.15646057f, -0.21066496f, 0.02292638f, -0.14297850f, -0.16338407f, 0.08962416f, 
    -0.01480037f, -0.06341388f, 0.06624620f, -0.29172111f, -0.11229150f, -0.03184172f, 0.00807353f, -0.22264956f, 
    0.04053244f, -0.08256591f, 0.11320087f, 0.01481826f, -0.05247779f, 0.20309170f, -0.08000887f, 0.00539294f, 
    0.00691748f, -0.47258139f, -0.04335617f, 0.17085607f, -0.22772358f, 0.24704397f, -0.08096509f, -0.16860774f, 
    0.14474225f, -0.00264772f, -0.30196494f, 0.05033436f, 0.05406093f, -0.03546497f, -0.13498875f, -0.01078107f, 
    0.08470988f, -0.73389220f, -0.01853131f, 0.05028710f, 0.25185835f, 0.10315584f, 0.07224775f, 0.16324593f, 
    -0.01985865f, 0.04270164f, -0.07642579f, -0.06640091f, 0.05887880f, -0.26129532f, -0.04973464f, -0.05280447f, 
    -0.03609029f, -0.06843975f, -0.14100090f, -0.09444068f, -0.12620476f, -0.06634333f, 0.12564690f, 0.05651187f, 
    0.15706627f, -0.16783509f, 0.15232064f, -0.47889355f, -0.04021193f, -0.24683407f, 0.06679763f, -0.03904779f, 
    0.01760867f, 0.27900273f, -0.06198848f, 0.14162011f, 0.00528393f, 0.14551589f, -0.11950694f, 0.07049078f, 
    -0.05391206f, 0.09859404f, -0.07167029f, 0.21561933f, 0.05466559f, 0.26886445f, 0.07606930f, -0.12261797f, 
    -0.04407699f, -0.15833324f, 0.00742198f, -0.28800762f, 0.27188766f, 0.18035427f, 0.16903490f, -0.01616031f, 
    0.11352082f, 0.00955209f, 0.03440753f, 0.18626231f, -0.04085100f, -0.06077060f, 0.05348455f, 0.03395784f, 
    -0.00090378f, -0.35006058f, 0.06158681f, -0.04170316f, -0.10927529f, 0.21014343f, 0.09370669f, -0.02586799f, 
    -0.14585610f, 0.04818528f, 0.16438891f, 0.28950533f, -0.25989673f, 0.31314760f, 0.09132006f, 0.09291663f, 
    -0.08624440f, -0.10327006f, -0.26885727f, 0.09513187f, -0.66175550f, 0.05027227f, 0.00124073f, 0.15419252f, 
    -0.29607105f, -0.06223257f, -0.12216911f, 0.21714211f, 0.10205495f, -0.17108747f, -0.09682485f, 0.07490823f, 
    0.04178651f, -0.25187117f, 0.04385734f, -0.01202750f, 0.10069010f, 0.13208535f, -0.01100906f, -0.18654442f, 
    0.08437552f, 0.11376998f, -0.16922553f, 0.00001727f, 0.07764975f, -0.63987404f, 0.08481828f, 0.15685101f, 
    0.09045587f, 0.04366030f, 0.08192352f, 0.21683225f, 0.03271181f, 0.23916292f, -0.86478806f, -0.22723709f, 
    0.18455672f, -0.06900039f, 0.13285902f, -0.17266722f, 0.06790793f, 0.03389789f, 0.08984669f, 0.13786277f, 
    0.08209586f, 0.21611370f, 0.10974514f, 0.03392318f, -0.05999463f, -0.24970062f, -0.04250769f, -0.22373268f, 
    -0.20297326f, -0.42579448f, -0.13882509f, 0.10182642f, -0.01646608f, -0.24188754f, -0.03654431f, 0.05383907f, 
    -0.71034843f, 0.10575622f, 0.14533587f, -0.02055581f, 0.04600187f, -0.05279841f, 0.16739868f, -0.32503796f, 
    -0.37891793f, 0.05472045f, -0.39006686f, 0.29014760f, -0.08436500f, 0.13804400f, -0.11572955f, -0.33388126f, 
    0.06095269f, 0.02795465f, -0.10543733f, 0.34194392f, 0.05447267f, 0.09421425f, 0.00532692f, 0.18097623f, 
    -0.01524783f, -0.10383341f, 0.07160418f, -0.33642223f, 0.11337478f, -0.20938246f, 0.04872766f, -0.19874810f, 
    -0.09986890f, 0.17510632f, 0.03226136f, 0.30751121f, 0.27280778f, 0.01385044f, -0.01634698f, -0.18589833f, 
    -0.28094095f, 0.00327655f, 0.15007117f, 0.04511629f, -0.01086750f, -0.57289678f, -0.05801902f, -0.22169617f, 
    -0.04921058f, 0.08925980f, 0.05772012f, -0.07541219f, -0.03220795f, 0.22641671f, 0.05147222f, -0.03398551f, 
    0.07178508f, 0.06249885f, -0.01665743f, 0.38752186f, 0.12620236f, -0.31349233f, -0.05809701f, -0.03177600f, 
    -0.47620451f, -0.05190301f, 0.37892789f, -0.07115689f, 0.06113065f, -0.05425619f, -0.39727786f, -0.11911533f, 
    0.33884463f, 0.09190889f, -0.47625127f, -0.14454706f, 0.09967559f, -0.17689942f, 0.27395236f, 0.08322836f, 
    0.09424012f, 0.28601751f, 0.09064781f, -0.28794667f, -0.06678770f, -0.28942057f, 0.11179674f, 0.07459007f, 
    0.08487820f, 0.00724736f, 0.19832505f, 0.44238621f, -0.03745387f, -0.44115436f, 0.04073969f, 0.08900814f, 
    0.06952966f, 0.11734365f, 0.09120841f, -0.35760158f, 0.21129034f, -0.21980298f, 0.30861545f, 0.18426356f, 
    -0.74670398f, 0.03248351f, 0.16732565f, 0.05765256f, -0.12646717f, -0.15720178f, 0.08494459f, -0.18732834f, 
    0.02663961f, 0.16692103f, 0.05857735f, 0.06371682f, 0.00505456f, -0.39506149f, 0.07098950f, -0.37385216f, 
    -0.02827254f, 0.21296076f, -0.28942716f, -0.05342930f, 0.01517383f, -0.02858703f, 0.05321306f, -0.01433915f, 
    -0.60217214f, 0.05432161f, 0.46364820f, -0.00008285f, -0.05209329f, -0.13260046f, 0.11746691f, 0.41405365f, 
    -0.31637678f, -0.05673438f, -0.69097447f, 0.15054907f, 0.01837241f, 0.22012949f, 0.16002727f, -0.23659392f, 
    -0.03785337f, -0.20467566f, 0.08298597f, -0.21625493f, 0.10703377f, 0.04947854f, 0.04915541f, -0.27576843f, 
    0.08540223f, -0.09870325f, 0.06576208f, -0.35239056f, -0.32778689f, 0.18366207f, -0.05767686f, 0.06102625f, 
    0.11234286f, -0.28755409f, -0.10673308f, 0.24475661f, 0.10980237f, 0.20289594f, -0.27827099f, -0.21504724f, 
    0.24378730f, -0.11792787f, 0.05967989f, 0.15542649f, -0.02092923f, 0.15321988f, 0.08789122f, 0.26002496f, 
    0.02136745f, -0.21726668f, 0.03429772f, 0.08231863f, -0.55320746f, -0.32431224f, 0.08742361f, -0.08709095f, 
    0.25643679f, -0.17736554f, 0.17032792f, 0.24780548f, -0.30851293f, -0.57310289f, -0.03098269f, -0.04656428f, 
    0.13026799f, 0.08095559f, -0.42020276f, 0.01137428f, 0.33412835f, 0.10847571f, -0.36207318f, 0.16977471f, 
    0.29817399f, 0.20022292f, 0.19348705f, -0.11568832f, -0.05073019f, -0.17032526f, 0.15133092f, -0.47795537f, 
    0.11536200f, -0.21549365f, -0.10385709f, -0.07251821f, 0.04200521f, -0.47767118f, -0.01518324f, 0.14436969f, 
    0.04133986f, -0.00711354f, 0.15969306f, -0.32862756f, -0.28334373f, -0.46767828f, -0.09837195f, 0.22751416f, 
    -0.01542720f, 0.01520154f, 0.00206532f, 0.07710766f, 0.30019140f, -0.36307204f, -0.25376463f, 0.23780620f, 
    -0.19469146f, -0.07372482f, -0.24930865f, -0.18417470f, -0.08812743f, 0.12138162f, -0.08080934f, -0.32677159f, 
    0.02634300f, 0.03956196f, 0.11181622f, -0.06608992f, -0.23159809f, 0.41457060f, -0.05847122f, 0.45478129f, 
    -0.02678799f, 0.30275512f, -0.29749528f, -0.06873160f, 0.18611470f, 0.06355287f, 0.07107592f, -0.02161922f, 
    0.01186396f, -0.06426081f, -0.30735692f, 0.00426600f, -0.03896518f, 0.03353429f, 0.28599265f, -0.37177441f, 
    -0.50681823f, 0.32337686f, 0.05808384f, -0.05607347f, 0.09126592f, 0.23697381f, -0.13137417f, -0.52627915f, 
    0.00311146f, -0.14532962f, 0.05759679f, -0.11972422f, 0.07237534f, 0.20194922f, -0.07835568f, -0.27354574f, 
    0.06048779f, 0.04195868f, 0.19304660f, -0.25787610f, -0.22947831f, -0.12049548f, -0.11171085f, -0.08274595f, 
    0.01214814f, -0.09373914f, -0.08448101f, -0.15471832f, -0.07607231f, -0.42835659f, -0.09410315f, -0.38855261f, 
    -0.31672525f, -0.13106412f, 0.15741232f, -0.26307067f, 0.07584243f, -0.18782328f, -0.06379936f, 0.23807810f, 
    -0.04182493f, 0.27947208f, -0.05717603f, -0.03642615f, 0.44964099f, -0.55850035f, -0.04652427f, 0.35371643f, 
    -0.45128715f, 0.08795367f, -0.12073290f, 0.02402588f, -0.27334610f, 0.12396144f, -0.08822937f, 0.06788830f, 
    -0.19634584f, -0.04044000f, -0.12080359f, 0.09715524f, 0.27532825f, -0.04269180f, -0.09636904f, -0.35649261f, 
    -0.46261823f, 0.17173897f, 0.40334642f, 0.14873210f, 0.07217713f, -0.01219983f, 0.13207401f, 0.33524501f, 
    0.06102053f, -0.23658285f, 0.05502138f, 0.24181417f, 0.10668410f, 0.23819435f, -0.05489582f, -0.15619777f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02907024f, 0.18302177f, 0.10202280f, -0.11912341f, -0.09224395f, 0.07994558f, -0.02421554f, 0.07364780f, 
    -0.04727193f, -0.09109803f, 0.16551583f, 0.10721723f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
