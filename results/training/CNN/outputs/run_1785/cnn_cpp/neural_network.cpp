#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.98835301f, -0.76146716f, -0.36307517f, 0.20585121f, -0.13060834f, -0.62201428f, -0.29239205f, -0.33732086f, 
    -0.65000296f, -0.51962531f, -0.10841949f, -0.41563755f, -0.45604643f, -0.22293490f, -0.45453581f, -0.04947617f, 
    -0.11274437f, -0.00421280f, -0.02473406f, 0.03595801f, 0.09977037f, -0.15666483f, 0.07605672f, 0.04448347f, 
    0.05851362f, -0.94070983f, 0.87975049f, 0.98401815f, -0.79287815f, -0.47221276f, -0.49106956f, 0.33800796f, 
    0.01590559f, 0.25318840f, 0.03601129f, -0.16336340f, -0.27834097f, 0.14921398f, 0.03699884f, -0.20938776f, 
    0.14297502f, -0.09771699f, -0.11968813f, -0.34816220f, -0.20934902f, -0.45218113f, -0.44649020f, -0.40283531f, 
    -0.11678635f, -0.47212106f, -0.64183700f, -0.60357696f, -0.48633522f, -0.58561337f, -0.99298364f, 0.70590496f, 
    0.56382632f, 0.18550333f, -0.01859440f, 0.80254096f, 0.06076854f, 0.37429747f, 0.16301526f, -0.02308363f, 
    0.18946286f, -0.13582903f, 0.14154495f, -0.15269382f, -0.21094997f, 0.35041839f, -0.14456192f, -0.14069963f, 
    -0.03625085f, 0.09962104f, -0.17624684f, 0.59533077f, 0.17504920f, 0.12854263f, 0.06168888f, -0.26533613f, 
    0.12393501f, 0.46877012f, 0.41818553f, 0.08625146f, -0.21774030f, -0.20956039f, 0.40207991f, 0.46245736f, 
    -0.60010767f, -0.45912510f, -0.23906824f, -0.10529079f, -0.35957667f, -0.25253293f, 0.02756950f, 0.24772663f, 
    0.22666450f, -0.32221523f, -0.31064188f, 0.24331449f, -0.10005587f, 0.23550299f, 0.23469673f, 0.12658529f, 
    0.26967096f, 0.36973259f, 0.28817272f, 0.30015102f, 0.30461234f, -0.20729789f, 0.05596469f, 0.00968635f, 
    -0.22857611f, 0.07566164f, 0.35829473f, -0.01103225f, -0.13075802f, -0.01295139f, -0.07471078f, 0.17252083f, 
    -0.01582851f, 0.18667443f, 0.06299718f, -0.14869222f, 0.06729700f, -0.15280913f, -0.37076715f, -0.12179971f, 
    0.74003887f, 0.27636820f, -0.69170046f, -0.48397484f, -0.19317052f, 0.19014136f, -0.40278253f, -0.14731783f, 
    0.44927284f, 0.12764376f, 0.34069341f, 0.10732462f, -0.18220372f, 0.00596612f, 0.16827087f, -0.13934302f, 
    -0.52608752f, -0.12653632f, -0.33696333f, -0.03525786f, 0.07937328f, 0.39796743f, 0.27067685f, 0.65379333f, 
    0.22838967f, -0.00043963f, -1.10641110f, -0.95255244f, -0.61216247f, -0.45590001f, -0.68677962f, -0.62623012f, 
    -0.13831641f, -0.11869431f, -0.34406674f, -0.42154908f, -0.00575839f, -0.30246246f, 0.19430710f, -0.14094011f, 
    -0.26349348f, -0.35184711f, -0.01481205f, -0.09713321f, -0.12183139f, -0.14672904f, -0.22283289f, -1.18605578f, 
    -0.09776098f, 0.15782025f, -0.66541243f, -0.18677132f, 0.61033332f, 0.30338046f, -0.15694115f, 0.41034636f, 
    0.48100051f, -0.15701829f, -0.35488042f, -0.46432498f, -0.64448637f, -0.50462431f, 0.24518350f, 0.35483482f, 
    -0.40833634f, -0.36944082f, -0.26356849f, -0.12572369f, 0.05601694f, -0.14649314f, -0.12532522f, -0.26537338f, 
    0.58292437f, -0.64002115f, -0.35680935f, 0.05787009f, 0.01926586f, -0.13469674f, -0.05883053f, 0.02510527f, 
    0.11808257f, 0.23864529f, 0.30377629f, 0.01275334f, 0.10815726f, -0.19884019f, -0.31224754f, -0.37910709f, 
    -0.07288334f, 0.21587281f, -0.03867530f, -0.24570101f, -0.01608432f, -0.02179573f, 0.14236341f, 0.37145630f, 
    0.44060937f, 0.15041658f, 0.22435516f, -0.08551805f, 0.32030714f, -0.48231193f, -0.08149415f, 0.67523628f, 
    -0.39694193f, -0.48212674f, 0.44317293f, 0.35106498f, -0.24587567f, -0.03322979f, -0.17820947f, -0.06862570f, 
    0.14812499f, -0.31954485f, 0.01519152f, 0.24857348f, 0.17294356f, 0.10236993f, 0.12923855f, -0.37325677f, 
    -0.32030672f, 0.42755112f, -0.20316783f, -0.70359349f, -0.38018402f, 0.35348186f, 0.85032457f, 0.56654704f, 
    0.85486197f, 0.19874883f, -0.73215652f, -0.85728806f, -0.30848223f, 0.34250426f, -0.04340392f, -0.32724327f, 
    -0.19012608f, -0.29384705f, 0.05509262f, 0.01207534f, -0.15745431f, 0.23663428f, 0.21401104f, -0.34822711f, 
    -0.28647351f, -0.02063030f, 0.17037299f, -0.71108091f, -0.37224108f, 0.24638692f, -0.16921681f, -0.37200069f, 
    -0.75395155f, -0.83594543f, 0.31904319f, 0.39895698f, 0.10507447f, -0.53109902f, -0.27993807f, 0.04124522f, 
    -0.14463434f, 0.01251916f, 0.24968830f, -0.42660084f, -0.27804193f, -0.41933399f, -0.74124408f, -0.11785436f, 
    -0.24554136f, -0.12578787f, -0.37173378f, -0.13435511f, -1.06341004f, -0.17309026f, 1.34917104f, -1.21447217f, 
    -0.82623261f, 0.09893231f, 0.37061989f, -0.02085498f, -0.00851926f, 0.09628081f, -0.16756371f, 0.07887080f, 
    -0.13451955f, 0.23643808f, 0.07676691f, -0.06011359f, -0.01941481f, -0.39935076f, -0.36365396f, -0.26640201f, 
    0.20010050f, 0.35469276f, 0.20404796f, -0.05539869f, -0.03594646f, -0.56949598f, -0.53256732f, -0.51553917f, 
    -0.25966501f, -0.04496861f, -0.13003983f, -0.25105995f, -0.25455046f, -0.52578008f, -0.44789141f, 0.49341759f, 
    0.28183466f, 0.35818025f, -0.05909378f, 0.24623553f, -0.22508962f, -0.25385442f, 0.08288872f, 0.04687259f, 
    -0.11906189f, 0.28950915f, 0.09482589f, 0.22872891f, 0.30858022f, 0.22241275f, 0.91397637f, -0.66847056f, 
    -1.05245197f, -1.02382469f, -0.28246111f, 0.10504394f, -0.36832502f, -0.04106088f, 0.17908731f, -0.09637345f, 
    0.82461679f, 0.13653564f, 0.33251879f, -0.12386221f, -0.27424812f, -0.01626673f, -0.32393941f, -0.38207731f, 
    -0.37763369f, -0.37917188f, -0.23639745f, -0.28723508f, -0.06578392f, -0.34375039f, -0.55339968f, -0.67971563f, 
    -0.55979872f, -0.45515069f, -0.24343307f, -0.60930955f, -0.48643166f, -0.25902623f, -0.65837854f, -0.77819198f, 
    -0.77521867f, -0.01278418f, -0.35185611f, -0.15083005f, 0.34891763f, -0.24898712f, -0.10723122f, -0.36437467f, 
    -0.15786655f, -0.32541227f, -0.46861193f, -0.04192019f, -0.33930528f, -0.47597805f, 0.22350179f, 0.42747492f, 
    0.63154674f, 0.87107241f, -0.53313166f, -1.00265753f, -0.07255121f, 0.70492482f, 0.68010867f, -0.29189184f, 
    -0.87278324f, -0.92587328f, -0.08067217f, 0.33481154f, -0.20875198f, 0.10467593f, -0.08269978f, 0.11879358f, 
    -0.43026927f, -0.22339265f, 0.17655066f, -0.15454610f, -0.04398901f, 0.14383605f, 0.14312154f, 0.30623028f, 
    0.33281472f, -1.29132044f, -0.90709007f, 0.01650348f, 0.92091376f, 0.53769642f, 0.71699578f, 0.24486600f, 
    -0.48251384f, -0.04491872f, 0.50998181f, 0.17101170f, -0.29132450f, -0.10026982f, -0.17800376f, -0.21020626f, 
    0.15601672f, 0.15592308f, -0.07184968f, 0.31577092f, 0.15359448f, 0.12706368f, -0.14782064f, -0.19181652f, 
    0.09840292f, -0.29400176f, 0.28553379f, 0.68471450f, -0.22142152f, 0.14370549f, -0.21572691f, 0.02465963f, 
    0.35095578f, 0.09677910f, 0.03140679f, 0.21743624f, -0.17250700f, -0.16108969f, -0.15983383f, -0.29197657f, 
    -0.08479533f, 0.07750551f, 0.02118162f, -0.13879740f, -0.07094945f, -0.17222442f, -0.49503860f, -0.16835280f, 
    -0.51800638f, -0.39080107f, -0.66993862f, 1.35874975f, 0.44368598f, -0.50080311f, -0.31040779f, -1.52508342f, 
    0.19356126f, -0.20934848f, 0.17622586f, 0.60887098f, -0.23468590f, -0.09626497f, -0.45296586f, -0.09319452f, 
    0.65551877f, -0.21987607f, 0.02976413f, 0.05569712f, 0.07739687f, -0.06196780f, -0.19616908f, -0.06250859f, 
    0.20287785f, 0.06511331f, -0.04992389f, 0.26307970f, -0.58049452f, -0.74356222f, -0.28396562f, -0.05782310f, 
    0.03228744f, 0.73517734f, 0.24289182f, 0.22917098f, -0.51498574f, 0.50407439f, 0.18212129f, -0.07225069f, 
    -0.12216807f, 0.32272646f, -0.07063992f, 0.06324140f, 0.33688536f, -0.55547911f, -0.06500351f, 0.04175325f, 
    -0.23356040f, -0.46455327f, 0.19465996f, 0.36211237f, 0.08068015f, -0.04976907f, -0.49209347f, -0.34351203f, 
    -0.50911987f, -0.38973951f, -0.06400797f, -0.17293023f, -0.42815295f, -0.25184405f, 0.11861426f, -0.04239563f, 
    -0.11573476f, 0.27862206f, 0.32033849f, -0.02405648f, 0.26819259f, 0.21216923f, -0.26268691f, 0.14997654f, 
    0.05701356f, -0.37661141f, -0.17764942f, 0.02428951f, -0.27490047f, -0.18474323f, 0.57092315f, 0.08708273f, 
    -0.11782461f, -0.05068444f, 0.15188883f, 0.13024510f, 0.47805136f, 0.29528785f, -0.32088006f, 0.07299560f, 
    -0.15962255f, 0.03441415f, 0.23380272f, 0.25003341f, -0.59112030f, 0.14572410f, -0.17175017f, 0.17686522f, 
    0.05634483f, -0.35038692f, -0.03597029f, 0.33307427f, 0.20506197f, -0.19864912f, -0.19303767f, 1.19242930f, 
    0.93311268f, 0.61658186f, -0.29913664f, -0.66207570f, -0.52851981f, -0.24408054f, 0.24815342f, -0.52527040f, 
    -0.66262835f, -0.13793957f, -0.13929473f, 0.26657689f, 0.10694033f, -0.00790518f, 0.13334318f, 0.20507425f, 
    0.13302109f, -0.15212087f, 0.10974915f, -0.17571239f, -0.22280438f, -0.42890248f, 0.24134871f, -0.05990369f, 
    -1.23384404f, -0.66498524f, -0.81345552f, -0.54875755f, 0.08267172f, -0.34983608f, -0.24504973f, 0.34126583f, 
    0.07248241f, -0.44778740f, 0.23794770f, 0.28451532f, 0.00235050f, 0.11111169f, 0.53594440f, -0.21295968f, 
    0.03496910f, -0.39027348f, -0.67048937f, -0.28427938f, 0.02286306f, 0.30986199f, 0.32952330f, 0.03070778f, 
    -0.13715594f, -0.05976167f, -0.25791088f, 0.23645316f, 0.28024858f, -0.89439982f, -0.46313825f, -0.35859561f, 
    -0.99276018f, -0.86479259f, -0.42937908f, 0.07772531f, 0.27368549f, 0.29006901f, -0.13962646f, 0.18906108f, 
    0.14227718f, 0.06174080f, 0.11264194f, -0.10211004f, 0.18413918f, -0.01575366f, 0.04937835f, 0.02648420f, 
    0.01302850f, -0.25112653f, -0.59963304f, 0.32524472f, -0.10885227f, 0.37749800f, 0.40212804f, -0.14092603f, 
    -0.56111670f, -0.31599993f, 0.31402138f, 0.67971247f, -0.02216920f, 0.60399234f, -0.40731204f, -0.42683861f, 
    -0.09684411f, 0.04063794f, 0.25603491f, -0.02796686f, -0.04317311f, -0.21129428f, -0.24543968f, -0.08541301f, 
    -0.09260213f, -0.19363829f, 0.17666824f, 1.22214496f, 0.58454579f, -0.48410913f, -0.03141475f, -1.00139248f, 
    0.56175721f, -0.37020797f, -0.12044024f, -0.12571709f, 0.27999344f, 0.02716598f, 0.02409823f, -0.22144313f, 
    -0.22297104f, -0.20910063f, 0.21972631f, -0.09068549f, 0.20017928f, -0.10610892f, -0.19032072f, -0.04022639f, 
    0.07211421f, -0.23294799f, 0.04662680f, 0.11106917f, -0.34922582f, -0.49956635f, -0.06684987f, 0.47164449f, 
    0.39472693f, 0.01552319f, -0.28837112f, -0.09819962f, 0.20471548f, -0.18576860f, 0.38215426f, -0.35834038f, 
    -0.16432452f, 0.17816974f, 0.42152855f, -0.12801710f, -0.35830492f, 0.09916835f, 0.05339938f, -0.28216892f, 
    -0.38953149f, 0.33238974f, -0.19045734f, 0.12546457f, 0.35332513f, -0.70937979f, 0.59091181f, 0.01902917f, 
    -0.07319876f, -0.15186116f, -0.19403392f, 0.08495808f, 0.78328675f, -0.33453733f, -0.27867687f, -0.05413869f, 
    -0.15938333f, -0.43232894f, 0.73395514f, -0.00521803f, 0.09723651f, -0.41725442f, -0.68401706f, 0.18150529f, 
    -0.26608261f, 0.13149372f, -0.13990699f, 0.47074166f, 0.30929506f, -0.13735245f, -0.24761674f, -0.20429097f, 
    -0.07770875f, 0.33617786f, -0.30233321f, 0.65920800f, 0.62461942f, -0.24032794f, -0.23284735f, 0.38094828f, 
    0.47829926f, -0.25556454f, 0.31648502f, -0.30713508f, -0.24470086f, -0.07827888f, -0.24721639f, -0.10108174f, 
    -0.05988470f, 0.05279516f, -0.06102620f, 0.17001945f, 0.27070615f, 0.28355289f, 0.02347893f, -0.72725761f, 
    -0.29071000f, -0.07061163f, 0.18903157f, 0.13299419f, -0.01198470f, -0.58545589f, -0.39523694f, 0.00980114f, 
    0.27496585f, 0.15745267f, -0.01382118f, -0.06692518f, 0.22126061f, 0.54587436f, -0.22896917f, 0.05535935f, 
    0.09910506f, 0.45189494f, -0.14472657f, -0.26158446f, -0.31098074f, 0.13831043f, -0.36951008f, -0.54149848f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.31265730f, 0.06908518f, 0.20110433f, 0.30635431f, -0.02187727f, 0.14250934f, -0.00241477f, -0.23401293f, 
    0.34962451f, 0.04323494f, 0.53294194f, 0.19109860f, 0.33978319f, -0.13772260f, -0.06276563f, -0.31456691f, 
    0.43165579f, 0.11551233f, 0.01719285f, 0.41082758f, 0.47660464f, 0.08579974f, 0.09720193f, 0.29081911f, 
    -0.01077896f, 0.20313673f, 0.27384180f, 0.39871085f, 0.30761933f, 0.01854213f, 0.25190610f, -0.15103252f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.56385511f, 0.23457311f, 0.03474821f, -0.28907609f, 0.21527562f, 0.10391039f, 0.19029385f, 0.03682453f, 
    -0.01536448f, -0.04804301f, -0.01176214f, -0.16459027f, -0.63100523f, -0.34627855f, 0.18345690f, 0.15956242f, 
    -0.04895803f, 0.04755122f, 0.00014380f, 0.11781553f, -0.06462760f, -0.11020987f, -0.03398574f, 0.11350100f, 
    0.19934568f, -0.15193462f, -0.10716673f, 0.08512989f, 0.14699346f, 0.10574410f, 0.05293628f, -0.07600727f, 
    0.01448054f, 0.00093902f, 0.00571908f, -0.06892630f, -0.38109902f, -0.14722387f, -0.62766033f, 0.08886494f, 
    0.03298413f, 0.06719901f, -0.00075607f, 0.05094341f, 0.02071067f, -0.12062313f, 0.02511300f, -0.12064302f, 
    -0.01218468f, 0.03021923f, -0.05580625f, -0.01640825f, -0.01298841f, 0.02364707f, 0.09827053f, 0.03131193f, 
    -0.16325755f, -0.00234271f, -0.00515204f, -0.14955497f, 0.00533491f, 0.20001486f, 0.18020803f, -0.36960202f, 
    -0.12343149f, -0.09228363f, 0.00720818f, -0.06614129f, 0.07907226f, -0.05132557f, -0.06865257f, -0.14290123f, 
    0.21088962f, 0.21955346f, 0.01967568f, -0.10974502f, -0.10451680f, 0.01905562f, -0.00979639f, 0.04368788f, 
    -0.03179188f, -0.09294923f, -0.08050226f, 0.00080342f, 0.10884087f, 0.48981863f, 0.03700863f, -0.10774230f, 
    0.08866310f, 0.10776322f, 0.04329150f, 0.15217239f, 0.05307329f, 0.28871298f, 0.04162957f, -0.14115976f, 
    -0.09544509f, 0.05489891f, -0.08330460f, -0.00163702f, 0.04801247f, 0.07329465f, -0.01521849f, -0.02550656f, 
    -0.00333576f, -0.11006616f, -0.07407349f, -0.01131628f, -0.06926566f, -0.02271015f, -0.09777496f, 0.03944469f, 
    -0.04528169f, -0.00702594f, 0.02638756f, 0.00640410f, -0.09405873f, 0.01378636f, -0.05909767f, 0.00039810f, 
    0.40101650f, -0.34046027f, -0.41185653f, -0.00798461f, -0.21986686f, -0.20504685f, 0.09635840f, -0.25840354f, 
    -0.20409559f, -0.13866930f, 0.07373539f, -0.23433346f, 0.15706047f, 0.27799517f, 0.31423438f, -0.03498420f, 
    -0.16568044f, -0.09117404f, -0.05702085f, 0.01635035f, -0.24872246f, -0.21079090f, -0.25023437f, 0.07392462f, 
    0.01121821f, -0.41035905f, -0.00900589f, -0.20335519f, -0.03067174f, 0.18900554f, 0.02240781f, -0.09326324f, 
    -0.26741692f, -0.21208437f, -0.13456288f, -0.05851582f, 0.36758691f, 0.32326105f, -0.06487133f, -0.00228388f, 
    0.05359223f, -0.06460550f, 0.00536444f, -0.19564615f, 0.05058571f, -0.02815965f, -0.01997698f, -0.04292374f, 
    0.34128976f, 0.06806830f, -0.40739775f, 0.08336733f, 0.07867792f, 0.00663510f, -0.02044048f, -0.03754378f, 
    -0.14911875f, 0.01345533f, 0.01287034f, 0.04868085f, 0.41245055f, 0.19204262f, -0.16074398f, -0.25156608f, 
    0.23619862f, 0.01420750f, 0.10132392f, 0.19067201f, -0.01321517f, -0.12271495f, -0.05163480f, -0.10598659f, 
    0.11063504f, -0.18188694f, -0.85960168f, 0.36132792f, 0.10164224f, -0.20558427f, -0.23615018f, -0.14206572f, 
    -0.05933233f, -0.05098578f, -0.09415324f, -0.07893756f, 0.79617769f, 0.23557089f, 0.04388558f, -0.31516352f, 
    -0.14957355f, -0.06327122f, 0.09118577f, -0.02871253f, 0.03470999f, 0.02261460f, -0.02312839f, -0.07621475f, 
    -0.42854962f, -0.24083164f, -0.00890174f, 0.08935197f, 0.07976492f, 0.03778485f, 0.00427837f, -0.01310905f, 
    -0.08114174f, -0.12411983f, 0.00263102f, 0.25647768f, -0.03292719f, -0.58215225f, -0.15915087f, 0.11436814f, 
    -0.11522405f, 0.14087668f, -0.11104461f, -0.08938975f, -0.09578929f, -0.04708342f, -0.05501174f, -0.16925876f, 
    0.13257678f, 0.03426342f, -0.29743671f, -0.07104124f, 0.00114918f, -0.01186291f, 0.02509890f, 0.03267414f, 
    -0.07425189f, -0.12359135f, -0.15307853f, -0.18807513f, 0.36167508f, 0.20241621f, 0.00712158f, -0.11936735f, 
    0.12143637f, 0.08344009f, -0.03759254f, 0.08124818f, 0.06344369f, 0.06675852f, 0.04569656f, 0.06317298f, 
    -0.22441112f, -0.30095887f, -0.52763140f, 0.12417778f, 0.05236869f, 0.01272704f, 0.09331498f, 0.02214396f, 
    0.04831505f, -0.03062705f, -0.09766954f, -0.08966690f, 0.02114234f, -0.31167319f, -0.05836169f, -0.15523979f, 
    0.07457630f, 0.03921637f, -0.21130015f, -0.16249149f, 0.04379452f, 0.03323715f, 0.02141221f, 0.06512461f, 
    0.40280682f, 0.21350937f, 0.01114234f, -0.29736453f, 0.06109414f, 0.24248785f, 0.01520016f, -0.19457218f, 
    -0.01853304f, -0.09371752f, -0.00391627f, 0.00893934f, 0.40706989f, 0.19723991f, -0.13736907f, -0.26216319f, 
    0.06160669f, 0.00232442f, 0.02879660f, 0.16202886f, 0.00654658f, 0.03307965f, 0.02990336f, 0.07182328f, 
    -0.78603506f, 0.32211763f, 0.02499984f, -0.37190288f, -0.04640545f, 0.00933935f, 0.04221218f, 0.03774344f, 
    -0.02019705f, -0.01320110f, -0.02926254f, -0.06001871f, -0.69899851f, -0.69153571f, -0.92776984f, 0.08986060f, 
    -0.01066885f, 0.06501853f, -0.06911603f, 0.06748956f, -0.15586060f, -0.07862591f, -0.15442163f, 0.08772390f, 
    -0.14609189f, 0.18675658f, 0.21622181f, -0.13247238f, -0.07924489f, 0.07073047f, 0.06914901f, -0.13969061f, 
    0.05072178f, -0.16660377f, -0.04893798f, -0.06577624f, -0.04465948f, -0.28371748f, -0.01378698f, 0.05798503f, 
    0.08955696f, -0.07273138f, -0.07903725f, 0.02376615f, -0.06015520f, 0.04442610f, -0.16450402f, 0.16348904f, 
    -0.01276899f, -0.10236844f, -0.05789347f, 0.05960295f, 0.01346940f, -0.05339847f, 0.00751390f, 0.03282333f, 
    -0.04683140f, -0.21324350f, -0.34562626f, -0.17077479f, 0.28886634f, 0.26560861f, 0.12958826f, -0.11602657f, 
    -0.08690740f, 0.17529564f, 0.00002200f, -0.05991940f, 0.16118324f, -0.06662282f, 0.01677241f, 0.09995160f, 
    0.23460819f, 0.11915022f, 0.38332725f, 0.02118878f, -0.06400086f, -0.07975542f, 0.13707787f, -0.07363445f, 
    -0.00774383f, 0.06301535f, -0.02170715f, -0.02420979f, 0.12314666f, -0.19334145f, -0.00325329f, -0.18325271f, 
    0.09350652f, 0.05045934f, -0.08045047f, -0.01445928f, -0.06115591f, -0.10103299f, -0.31387344f, -0.49098527f, 
    0.35448840f, -0.10297071f, -0.18786226f, -0.16897075f, -0.08376431f, -0.01003551f, -0.11980052f, -0.20001042f, 
    -0.01769101f, 0.01041393f, -0.05216209f, -0.18228483f, 0.70272344f, 0.32638445f, 0.24983577f, 0.15680869f, 
    -0.02362235f, -0.04209724f, -0.05113702f, 0.03022317f, -0.02050937f, 0.02062058f, -0.20158924f, 0.09718186f, 
    0.06488158f, 0.05070326f, 0.15660459f, 0.15182757f, 0.03877164f, -0.03743966f, -0.01258827f, -0.00551086f, 
    0.03340415f, 0.05426459f, 0.06341577f, -0.05852888f, -0.49121180f, -0.07947798f, -0.40603092f, -0.20061946f, 
    -0.11670520f, 0.04362319f, -0.15553796f, -0.17488569f, -0.01231096f, 0.05111740f, 0.02784497f, 0.21549426f, 
    -0.02247250f, -0.15434082f, -0.07986166f, -0.71766478f, -0.16859230f, -0.10246146f, -0.29048139f, 0.00991572f, 
    -0.01691523f, -0.09002433f, -0.09387226f, 0.07066662f, 0.41056746f, 0.31444323f, -0.14225055f, -0.22031130f, 
    -0.02003624f, -0.03408429f, -0.11597318f, 0.02324511f, -0.13011061f, -0.10676951f, -0.55078071f, -0.22326072f, 
    0.10929698f, 0.15282996f, -0.05162564f, -0.07264438f, 0.06606202f, 0.07655453f, 0.01851215f, -0.01221386f, 
    0.00607306f, -0.02687315f, -0.03738264f, 0.04373907f, 0.05200966f, 0.14659669f, 0.06117227f, 0.01951464f, 
    -0.09879872f, 0.18705328f, -0.17424396f, -0.01372380f, 0.01895668f, -0.05533154f, 0.15244292f, -0.16573802f, 
    0.41486609f, -0.64929795f, 0.15773718f, 0.12392110f, -0.01962816f, -0.07156446f, 0.27019495f, -0.17260545f, 
    0.42314765f, 0.18067358f, -0.03694217f, 0.09117924f, -0.20639768f, 0.27542484f, -0.14345086f, -0.02921188f, 
    0.10553446f, 0.21138774f, 0.01734498f, 0.08852454f, -0.02298565f, 0.17136692f, 0.16622755f, -0.11642439f, 
    -0.29094130f, -0.20110801f, 0.12685448f, -0.11121839f, 0.01100628f, -0.17050967f, -0.33521563f, 0.22930363f, 
    -0.06904018f, -0.02219347f, 0.18830958f, -0.03295147f, -0.14757253f, 0.01396264f, 0.07126205f, 0.05310344f, 
    0.09031326f, 0.26066005f, 0.03716278f, 0.00947223f, -0.19741718f, -0.01837637f, 0.04116774f, 0.00097165f, 
    -0.00684926f, -0.17549269f, -0.40037251f, -0.13987090f, -0.05693937f, 0.00007715f, 0.03001372f, 0.07875372f, 
    0.09543622f, -0.24371226f, -0.23753794f, -0.00768209f, 0.15169419f, 0.01143612f, 0.43206528f, 0.06675048f, 
    0.14953460f, 0.02931047f, 0.18583710f, 0.02391231f, 0.06432492f, -0.02267426f, 0.07344718f, -0.10526107f, 
    0.59321040f, -0.49160460f, 0.03233333f, 0.09918396f, -0.19287421f, -0.01669142f, 0.22153489f, 0.08132932f, 
    -0.10609379f, -0.06525195f, -0.11382017f, 0.16122280f, 0.18212906f, 0.04541098f, -0.11236086f, 0.02145136f, 
    -0.15215740f, 0.04779886f, 0.10120156f, 0.12178247f, 0.13461310f, -0.35918418f, 0.01663472f, -0.03023894f, 
    0.00542078f, 0.09359822f, 0.10632025f, 0.08778324f, -0.01206400f, 0.04345296f, -0.06776603f, -0.01368986f, 
    -0.26629415f, -0.10581671f, -0.14861907f, -0.00830570f, 0.62422365f, -0.17640404f, 0.06683540f, -0.41211841f, 
    0.08897176f, 0.06230993f, 0.02052994f, -0.09823488f, -0.04126819f, 0.06905344f, -0.05914265f, -0.01708691f, 
    0.42299268f, -0.11726707f, -0.31500459f, -0.03519536f, -0.01741357f, 0.04279039f, 0.15728749f, -0.18217881f, 
    0.24722971f, -0.07089727f, 0.12177480f, -0.17356327f, -0.01438375f, 0.00654615f, 0.00618682f, 0.27323082f, 
    -0.02627739f, 0.08486794f, -0.09297466f, -0.14519468f, 0.07852402f, -0.06747723f, 0.03978478f, -0.04123463f, 
    0.38265318f, 0.01573742f, 0.25693205f, 0.08057591f, -0.10375193f, 0.01467092f, 0.01938246f, -0.03762031f, 
    -0.16324487f, 0.05354432f, 0.02820535f, 0.08583081f, 0.37423265f, -0.09114569f, 0.05375765f, -0.21009745f, 
    -0.02773848f, -0.24145240f, -0.03650525f, -0.32937095f, -0.03992028f, 0.02292557f, -0.06363544f, 0.08153946f, 
    -0.47162449f, 0.15103255f, 0.16023864f, 0.04632582f, 0.12348531f, 0.27470860f, -0.01472132f, -0.06813321f, 
    -0.13469033f, 0.09462858f, 0.07962814f, -0.07878543f, 0.02670041f, 0.19301739f, 0.05297270f, -0.22634716f, 
    -0.18887332f, -0.15932834f, -0.18050270f, 0.09686922f, 0.03904863f, -0.04504967f, -0.00781135f, 0.06281048f, 
    -0.23783614f, 0.29466760f, 0.23916616f, -0.02992646f, 0.03595970f, 0.11670851f, -0.17409858f, -0.02730791f, 
    0.03236545f, -0.10831549f, -0.04284253f, 0.16230044f, 0.64977777f, 0.03906615f, 0.59830236f, -0.22932836f, 
    -0.02987467f, -0.01395556f, -0.04578699f, -0.04712243f, -0.02242662f, -0.00086871f, 0.12229635f, 0.04750314f, 
    -0.18370324f, 0.05716312f, -0.04733420f, 0.08102662f, -0.02820628f, 0.07892440f, 0.05203021f, 0.03090236f, 
    -0.09613341f, 0.20562498f, 0.01675701f, -0.01170055f, -0.34409630f, -1.05376399f, 0.07603282f, -0.21322957f, 
    -0.04045119f, -0.12573962f, 0.24033669f, 0.02791585f, -0.01474020f, -0.13179915f, 0.14722556f, 0.00239329f, 
    0.10282126f, 0.07548706f, 0.03004479f, 0.00119177f, -0.04068893f, -0.03539786f, 0.03362978f, 0.11100804f, 
    -0.17658539f, 0.20218644f, 0.06007191f, 0.07514288f, -0.30272159f, 0.09967813f, 0.03471900f, -0.11208973f, 
    0.03417401f, 0.07960095f, 0.09455299f, 0.05593413f, -0.31968129f, -0.04589307f, -0.01739739f, -0.04864110f, 
    -0.91913992f, -0.26752505f, -0.21742323f, 0.02837316f, -0.20981982f, -0.05760717f, 0.19141522f, 0.02725581f, 
    -0.01302520f, -0.05729900f, -0.05317946f, -0.01747975f, 0.34882781f, -0.13451718f, -0.02697201f, -0.01772921f, 
    0.01603854f, -0.06045625f, -0.03951924f, -0.01470913f, -0.09078243f, 0.14756517f, 0.12054461f, -0.06834317f, 
    0.30708286f, 0.20411019f, 0.49596825f, 0.33572415f, -0.06259446f, -0.01803710f, 0.10623232f, -0.14026585f, 
    -0.11306318f, 0.07491892f, 0.01338876f, 0.10296731f, -0.09897474f, 0.00158246f, -0.30155313f, -0.11938568f, 
    -0.01215772f, -0.03379858f, -0.06420863f, 0.04921256f, 0.02783238f, -0.20119537f, -0.01208848f, -0.09309991f, 
    0.02976704f, -0.11775061f, -0.16881151f, -0.00939798f, -0.03942290f, -0.02292819f, 0.06012527f, 0.07967220f, 
    -0.18910071f, 0.07833274f, -0.20605086f, 0.06820634f, -0.44944185f, 0.08144315f, -0.24497057f, 0.27159458f, 
    -0.22018227f, -0.21965076f, -0.25613475f, -0.01734279f, 0.03403095f, -0.01842931f, 0.00666457f, -0.01552082f, 
    -0.71663320f, -0.37888747f, 0.39893281f, -0.30161080f, -0.00489843f, -0.08759546f, -0.34590414f, -0.21626318f, 
    0.04833162f, -0.08870456f, -0.01529580f, 0.06590731f, -0.16970961f, -0.01319800f, 0.39048409f, 0.39758027f, 
    0.01929007f, 0.00969978f, -0.13361958f, 0.00068897f, 0.12857270f, -0.00356282f, -0.20686865f, 0.16624832f, 
    -0.10252492f, 0.06959451f, -0.03901526f, -0.03202956f, -0.10444017f, 0.07454955f, 0.01998007f, -0.00447605f, 
    0.03705664f, -0.03012192f, 0.14528833f, -0.10212594f, 0.05518031f, 0.06304576f, 0.01123026f, -0.15164895f, 
    -0.05621081f, 0.03828064f, -0.41420868f, 0.27392814f, 0.04203359f, -0.01943433f, 0.04068146f, -0.04705437f, 
    0.17081821f, 0.10132353f, -0.14185736f, 0.03397728f, 0.11011627f, -0.08781985f, 0.08729397f, 0.33215240f, 
    0.15584700f, 0.12134729f, -0.12247200f, -0.08716889f, 0.42577818f, 0.41381818f, -0.06382731f, 0.31196842f, 
    0.01112927f, 0.11148921f, 0.11821586f, -0.08562186f, 0.03042194f, -0.19027460f, -0.07920975f, 0.00681138f, 
    1.04669487f, 0.14640287f, 0.36230925f, 0.44748896f, 0.20877382f, -0.04437337f, -0.29606548f, 0.28583267f, 
    0.07450651f, -0.09652237f, -0.15214874f, 0.06488326f, -0.29307821f, -0.28417563f, 0.01173691f, 0.00527368f, 
    0.03300584f, -0.19410005f, -0.03524797f, -0.08360590f, -0.05168978f, 0.01388671f, 0.05973883f, -0.06634131f, 
    -0.44973731f, 0.19334716f, 0.03623417f, 0.30547968f, -0.04620693f, -0.09514357f, 0.08625261f, -0.13815632f, 
    0.06355168f, 0.08099057f, 0.08112565f, 0.23836833f, -0.49901932f, -0.49911118f, 0.02653978f, -0.15306643f, 
    0.04140814f, -0.06787360f, -0.04393705f, -0.08726934f, -0.03034477f, -0.02542846f, -0.01162536f, -0.08562759f, 
    0.10737599f, -0.30245799f, 0.17883053f, -0.63145238f, 0.03492300f, -0.11124595f, -0.06605543f, -0.05332520f, 
    0.02473073f, -0.04742116f, 0.01757647f, -0.14587291f, 0.02098618f, -0.16906255f, -0.09918164f, 0.17802007f, 
    0.09054192f, -0.08042042f, -0.00841274f, 0.21900967f, 0.10184676f, 0.12049504f, 0.05684903f, -0.03182173f, 
    0.11555830f, -0.12674345f, -0.08580808f, -0.10782241f, 0.07971887f, 0.02201479f, 0.00216386f, -0.02856008f, 
    0.22356315f, 0.16686262f, 0.11574368f, 0.07859655f, -0.73773843f, 0.62569225f, 0.11024742f, -0.32835692f, 
    -0.04127245f, 0.09106772f, -0.10403029f, 0.09715294f, -0.01601683f, -0.02823682f, -0.01026916f, 0.04700017f, 
    0.07834580f, -0.35421836f, 0.30501652f, 0.03626925f, 0.08539155f, 0.02867043f, 0.04817681f, -0.01843876f, 
    -0.00932652f, -0.09307650f, 0.06188247f, 0.06091907f, 0.06271227f, -0.04858592f, 0.12260234f, 0.16757846f, 
    -0.00018561f, 0.15446873f, 0.22224310f, -0.10587576f, 0.04022540f, 0.03893353f, 0.07797018f, 0.09684625f, 
    -0.07767124f, -0.37772030f, -0.10424481f, -0.02711340f, 0.03414777f, -0.09721969f, 0.03646174f, 0.00499112f, 
    0.04492882f, -0.43460739f, 0.24968281f, -0.06457242f, -0.57418430f, -0.07029015f, 0.45594409f, -0.63041329f, 
    -0.05209877f, -0.04219076f, 0.00060266f, -0.36200863f, 0.03025847f, 0.06172196f, -0.04718396f, -0.05903912f, 
    -0.05199020f, 0.20048980f, 0.23724809f, 0.03317175f, -0.12198391f, 0.01272716f, 0.16953740f, -0.00910829f, 
    -0.16142784f, 0.06672619f, -0.15519439f, 0.03175383f, -0.35472536f, -0.41311800f, -0.16367194f, -0.35294721f, 
    0.08140873f, 0.04590211f, -0.16835667f, -0.14893265f, 0.07992355f, 0.07619856f, -0.00832563f, 0.02206091f, 
    0.06418461f, -0.35008371f, -0.01396173f, 0.05597530f, 0.10974006f, -0.03321307f, -0.03517579f, 0.05323156f, 
    0.04231822f, -0.15437564f, -0.04428752f, -0.05140006f, -0.52348876f, 0.56146133f, 0.44935808f, -0.79296750f, 
    0.01165938f, 0.06317342f, -0.29339197f, 0.18350679f, -0.02183366f, 0.13010281f, -0.04643069f, 0.06159537f, 
    -0.28369632f, 0.16956629f, -0.15525170f, 0.12896687f, 0.07708371f, 0.09444485f, -0.03526082f, 0.14377788f, 
    -0.07341767f, 0.11411893f, 0.12827069f, 0.01441945f, 0.39517444f, -0.25747648f, -0.05344725f, -0.04947880f, 
    -0.01548199f, 0.08157369f, 0.10277736f, -0.26914456f, -0.00069998f, -0.01412691f, 0.11946436f, -0.07886524f, 
    -0.05271656f, -0.08418772f, 0.05363929f, -0.08226942f, 0.09370934f, -0.14136490f, -0.00403129f, 0.10121235f, 
    -0.07877588f, -0.27028999f, 0.14116487f, -0.09612075f, -0.04231346f, -0.04147818f, 0.02632806f, 0.18023726f, 
    0.05339230f, -0.14194752f, 0.06652948f, -0.06457950f, 0.04592283f, 0.00525767f, -0.00517555f, -0.00130796f, 
    -0.23511161f, -0.02840568f, -0.14572233f, 0.11325537f, 0.00898132f, 0.08206704f, -0.14127895f, 0.03441722f, 
    -0.16989695f, 0.00309511f, -0.05957029f, -0.03180386f, 0.81731063f, 0.14745429f, 0.34685141f, -0.23171914f, 
    -0.08045010f, 0.12377643f, -0.00998982f, -0.16923541f, 0.00749497f, -0.10820148f, 0.21830463f, -0.13073811f, 
    -0.27635393f, -0.40197939f, 0.05889142f, 0.24540704f, 0.26626274f, -0.01692248f, 0.10377999f, -0.05943320f, 
    -0.15524003f, 0.05915042f, -0.19845390f, 0.10239494f, -0.32254958f, -0.27309185f, 0.01925656f, 0.00997802f, 
    0.11606954f, 0.02999965f, -0.18956891f, 0.04120164f, -0.05661353f, 0.01574142f, -0.17535041f, -0.12148456f, 
    -0.48349157f, -0.17446755f, -0.09365150f, -0.19988869f, 0.08998230f, 0.10488959f, 0.00740713f, 0.01621560f, 
    -0.25602999f, -0.17438796f, -0.03175964f, -0.24258061f, 0.12833700f, 0.01757774f, -0.10201085f, 0.26036903f, 
    -0.02718562f, -0.13984978f, -0.04549078f, 0.21646015f, -0.03105602f, 0.07439321f, 0.03954136f, 0.01447979f, 
    -0.03835192f, -0.20015065f, 0.12597434f, 0.16880167f, -0.12511563f, -0.04562373f, 0.05187574f, 0.04192368f, 
    -0.06213221f, 0.09513026f, -0.13074353f, 0.02765613f, 0.77549165f, -0.30137363f, 0.03222388f, 0.04989634f, 
    0.27981630f, 0.28650659f, 0.10776753f, 0.16677287f, -0.19190106f, -0.07066989f, 0.04144254f, 0.13436352f, 
    -0.22651137f, 0.23240639f, 0.15410799f, 0.21567066f, -0.02828651f, -0.27678806f, 0.05461466f, -0.50402158f, 
    -0.04055405f, 0.22745021f, -0.05034672f, -0.06175425f, 0.02836302f, -0.26006544f, -0.21030858f, 0.04601657f, 
    0.00971602f, -0.13165008f, -0.10618705f, -0.16654429f, -0.16625223f, -0.31020659f, 0.12001023f, -0.25365061f, 
    0.00356405f, 0.80204558f, -0.30798090f, -0.01131034f, 0.07941820f, -0.10941344f, -0.04322667f, -0.08844521f, 
    -0.30815521f, -0.13620196f, -0.17387973f, 0.05072447f, 0.14605771f, -0.16256708f, -0.11086711f, -0.08932017f, 
    -0.00805214f, -0.10128690f, -0.06915210f, 0.08929179f, -0.00204178f, -0.01469619f, 0.01779631f, 0.07978414f, 
    0.57100439f, 0.09894980f, 0.20913953f, 0.36902067f, -0.10644235f, 0.05866571f, -0.16574593f, 0.07959667f, 
    0.02546247f, 0.11080419f, -0.02282883f, 0.11860240f, -0.01881368f, -0.11169536f, -0.13445264f, 0.17139661f, 
    0.00624958f, 0.16708404f, 0.08464753f, 0.08355749f, 0.10457441f, -0.00633492f, 0.21720646f, -0.06167384f, 
    -0.14208156f, 0.12065792f, 0.03997999f, 0.16904862f, -0.04365560f, 0.18300933f, 0.07018621f, -0.03224318f, 
    -0.09671153f, 0.05152043f, 0.03747657f, 0.26474366f, -0.08408837f, -0.24687141f, -0.06912123f, 0.16903311f, 
    0.00120282f, 0.08031448f, -0.01471649f, 0.11588797f, -0.10436981f, 0.05877623f, -0.10030134f, -0.10089832f, 
    -0.18828528f, -0.08620195f, 0.42492193f, 0.58357704f, 0.08032443f, -0.09251754f, -0.25539792f, -0.17155357f, 
    -0.11846998f, -0.22632696f, 0.06552821f, -0.12311243f, -0.44695210f, 0.98932034f, 0.04673169f, -0.59298724f, 
    0.19354193f, 0.09607365f, -0.01036131f, -0.17350069f, -0.32672256f, 0.01152908f, -0.01183478f, -0.03697598f, 
    -0.30875805f, 0.01947740f, -0.09498326f, -0.05306814f, -0.01787909f, 0.09364659f, -0.15996426f, 0.19118138f, 
    -0.00332974f, 0.16263691f, -0.00033777f, -0.05503829f, -0.40811175f, -0.21505967f, 0.12859064f, 0.25957108f, 
    -0.11058675f, -0.08212659f, -0.18824159f, -0.11130862f, -0.03340056f, 0.01642149f, 0.11974870f, 0.01540555f, 
    -0.41246754f, -0.06053732f, -0.08464508f, -0.35625017f, 0.27438480f, 0.14394513f, -0.00183625f, -0.19741225f, 
    -0.22749931f, -0.23102312f, -0.04670883f, 0.06882522f, -0.14684433f, -0.21521311f, -0.01274037f, 0.23618680f, 
    -0.09483700f, -0.11185969f, 0.12651631f, -0.19548978f, -0.06263872f, -0.03691569f, -0.17215542f, 0.19503824f, 
    -0.26313195f, -0.29264647f, -0.33746955f, -0.18423262f, 0.32116565f, 0.22348300f, -0.20507452f, 0.02162393f, 
    -0.06476828f, 0.02200285f, 0.23844619f, -0.03864493f, -0.09485971f, -0.33139998f, 0.37334010f, 0.21115839f, 
    -0.07072601f, -0.21732564f, 0.11129710f, 0.00980363f, 0.09931841f, 0.16151705f, 0.14731655f, 0.04620248f, 
    0.17918113f, -0.17279722f, -0.06775887f, 0.08678535f, 0.08638506f, -0.05669096f, 0.10466854f, 0.25094149f, 
    -0.07343118f, 0.00163649f, -0.03580350f, 0.09235162f, -0.12189421f, -0.21572013f, -0.02332258f, 0.46190676f, 
    0.12021063f, -0.06262176f, 0.07997400f, -0.05428900f, -0.09332187f, 0.11491793f, -0.14877827f, 0.08623630f, 
    0.08215154f, -0.00282791f, -0.30788386f, -0.29668719f, -0.09876489f, -0.22465035f, -0.12032352f, -0.11266097f, 
    0.04058377f, 0.30622286f, -0.16859193f, 0.06423082f, -0.89361817f, -0.01161182f, 0.18049397f, 0.13918197f, 
    -0.21627985f, 0.07827787f, -0.17170741f, -0.16134927f, -0.07359125f, 0.04605573f, 0.15421882f, -0.19803788f, 
    -0.08777043f, 0.13660555f, -0.14778553f, -0.36367407f, -0.01606988f, -0.01695916f, -0.18996762f, 0.05279228f, 
    -0.02852998f, -0.08032536f, 0.26592851f, -0.04407356f, 0.18642990f, 0.24533971f, -0.07741523f, -0.11095000f, 
    -0.17396235f, 0.05241562f, -0.04454503f, -0.17379685f, 0.02507911f, -0.27889219f, 0.28530562f, 0.00525810f, 
    -0.28908843f, 0.08526707f, 0.05458292f, -0.33960244f, 0.23713261f, 0.39033782f, -0.02746968f, -0.06911121f, 
    0.07800750f, 0.01506106f, 0.05721641f, -0.08684514f, 0.18397920f, 0.07328087f, -0.14193465f, 0.09647242f, 
    0.37800953f, 0.15830480f, -0.01276239f, -0.22905171f, -0.07641381f, 0.02683887f, 0.05999407f, 0.09735072f, 
    -0.18254587f, -0.08332551f, 0.12854709f, 0.03435380f, -0.12295379f, 0.06875540f, -0.01371187f, -0.10861880f, 
    -0.04993758f, 0.02414162f, -0.04548806f, 0.06267781f, -0.21173272f, 0.04951835f, -0.29157364f, 0.05695330f, 
    0.04771829f, -0.10760873f, -0.01329353f, -0.12274113f, 0.11962882f, 0.04264323f, 0.20919488f, 0.36231977f, 
    0.15232281f, 0.28598669f, 0.14860104f, 0.08976719f, -0.02410697f, -0.19353557f, 0.07445785f, 0.07513452f, 
    -0.00567110f, -0.25343552f, 0.06137194f, 0.07790363f, 0.13170663f, -0.09882277f, -0.30014864f, -0.45652303f, 
    -0.01551668f, -0.03258178f, 0.01774146f, 0.00370736f, -0.03127610f, 0.03033964f, -0.13604619f, -0.34653088f, 
    0.15357830f, 0.05992451f, 0.00889138f, -0.10953537f, 0.15323265f, 0.06282321f, 0.03342488f, 0.03721848f, 
    0.04433101f, -0.00169209f, 0.04214619f, 0.11235178f, 0.16055907f, -0.09247611f, 0.39622706f, 0.11337941f, 
    -0.26430926f, 0.04578110f, -0.13865967f, 0.12246247f, -0.06687891f, -0.08572522f, -0.01406564f, -0.10965296f, 
    0.19232038f, 0.26684979f, 0.05175270f, 0.28985968f, 0.19154923f, 0.11424883f, 0.00066430f, 0.08879783f, 
    0.00476637f, -0.05957599f, 0.04809859f, -0.03773222f, -0.32295778f, -0.48153460f, -0.28153399f, 0.17262425f, 
    0.02986536f, -0.08317702f, 0.18408024f, -0.01760027f, 0.13544019f, -0.03515263f, 0.14391018f, 0.01978458f, 
    0.07361179f, 0.00581484f, 0.16207789f, -0.04103883f, 0.00644211f, 0.05478008f, 0.02529298f, 0.12456289f, 
    -0.17047955f, -0.05706432f, -0.11597394f, -0.22876987f, 0.02997671f, 0.01467269f, -0.02757377f, 0.14224045f, 
    0.03573989f, 0.04966246f, -0.11546361f, 0.00093942f, -0.09651943f, 0.01787292f, -0.17658845f, 0.09074207f, 
    -0.34904537f, -0.48001847f, 0.26387009f, -0.15307751f, -0.04082583f, 0.28662631f, -0.24296024f, -0.13332681f, 
    -0.02415499f, -0.02611972f, -0.08829786f, -0.25635472f, -0.03528890f, 0.00332889f, -0.12539122f, -0.00088605f, 
    -0.07182360f, -0.05061322f, 0.07162376f, -0.13400356f, -0.07707985f, -0.00890023f, 0.17769457f, 0.02818087f, 
    -0.17702059f, 0.15033863f, -0.17172068f, 0.02722833f, -0.12278038f, -0.14094654f, 0.08971880f, -0.61902142f, 
    0.05836722f, -0.23803096f, 0.02546275f, -0.26231453f, 0.21480414f, 0.17190398f, 0.12782954f, 0.00697821f, 
    -0.04296235f, -0.14811021f, -0.08661103f, 0.19924849f, 0.14648545f, 0.04312664f, 0.03811818f, 0.08263069f, 
    0.09933789f, 0.07528622f, 0.28577811f, 0.20395261f, -0.10969733f, -0.00821818f, -0.09271433f, -0.03261881f, 
    0.38127908f, -0.01983682f, 0.10449591f, -0.04371846f, 0.00446910f, 0.16784680f, 0.13429743f, 0.22139379f, 
    -0.15120991f, -0.10073632f, -0.08503106f, -0.08312987f, -0.03056349f, 0.00587018f, -0.07485350f, 0.09185147f, 
    0.01931918f, 0.35118660f, -0.42536482f, 0.08508740f, 0.35754710f, -0.05851933f, -0.11299344f, -0.07236819f, 
    -0.09531151f, 0.03736794f, 0.09363806f, -0.10348640f, 0.05948889f, -0.62888998f, 0.08778660f, 0.36731222f, 
    -0.27275494f, -0.04044691f, -0.01479323f, -0.17995454f, -0.15639822f, 0.08369464f, -0.22122465f, 0.08670811f, 
    0.33796638f, -0.06926601f, -0.08585786f, -0.00750168f, 0.07558253f, 0.01682180f, 0.05605787f, -0.05840509f, 
    -0.01703194f, 0.09843519f, 0.15591343f, 0.32368320f, -0.45112282f, 0.07562423f, -0.19228145f, 0.26927137f, 
    -0.00662598f, -0.05078516f, -0.08688487f, 0.04588327f, -0.07308841f, 0.00217621f, -0.00083157f, 0.01076068f, 
    -0.04000695f, 0.01274405f, -0.06191735f, 0.04100971f, -0.01504100f, -0.12845020f, 0.04532373f, -0.04938887f, 
    -0.29882628f, 0.06397948f, -0.14560582f, -0.18275020f, -0.01525148f, 0.12482680f, 0.10565517f, 0.20559277f, 
    -0.07252321f, -0.03158502f, -0.07370456f, 0.04885699f, -0.07419837f, -0.01613081f, -0.05999936f, 0.00246005f, 
    0.06694800f, 0.15087795f, 0.03835654f, -0.05755223f, 0.10259078f, 0.06971245f, 0.04751344f, -0.00375793f, 
    0.06507535f, -0.21117841f, -0.05094528f, -0.00784978f, 0.02496279f, 0.47661397f, -0.09176748f, 0.22656409f, 
    -0.11837750f, 0.18216394f, -0.32860139f, 0.08474839f, 0.06095781f, -0.00208434f, -0.05210272f, -0.09065107f, 
    0.13687733f, -0.01979435f, 0.11843557f, 0.18300337f, -0.07021952f, -0.05550182f, -0.11624223f, 0.06542315f, 
    0.17263205f, -0.13903634f, 0.06612617f, 0.02811200f, 0.13320614f, 0.34758833f, 0.26847005f, 0.14631689f, 
    -0.05663141f, -0.09800964f, 0.06033470f, 0.09049005f, 0.06017174f, -0.02675838f, 0.01914034f, -0.05182458f, 
    0.07766303f, -0.22227395f, -0.30057833f, 0.25603321f, -0.10457464f, -0.01510143f, 0.19966562f, -0.00051795f, 
    -0.13575004f, -0.10104025f, -0.01287647f, 0.01700782f, -0.13809079f, -0.29855460f, -0.73551029f, -0.18407179f, 
    0.18118404f, -0.02091262f, 0.12178846f, 0.09155054f, 0.14382362f, 0.04529519f, -0.19280450f, 0.10439499f, 
    0.18453261f, -0.05288697f, 0.11364373f, -0.00110116f, 0.04339680f, -0.23074305f, -0.04919138f, -0.03025516f, 
    -0.16336909f, -0.10429752f, -0.34725866f, -0.11412109f, 0.06117068f, 0.03038148f, -0.00493845f, 0.19937651f, 
    -0.06505217f, 0.02369183f, -0.08351169f, 0.07673071f, -0.00478541f, -0.20365401f, -0.27634460f, -0.16335543f, 
    0.27446094f, 0.21626620f, -0.03283011f, 0.03635873f, 0.00603824f, 0.01360796f, 0.02366190f, -0.03995075f, 
    -0.04497581f, -0.17256027f, -0.13324870f, -0.15331475f, -0.04691475f, -0.00129317f, -0.06324048f, 0.18857077f, 
    -0.09110925f, -0.16987330f, -0.02405074f, -0.04275624f, -0.00404176f, 0.10691160f, -0.15963930f, 0.26191977f, 
    0.03733013f, 0.16120629f, 0.14393887f, 0.11605630f, 0.10992643f, 0.02717432f, 0.10825597f, 0.06271840f, 
    0.09403170f, 0.07762266f, 0.07999435f, 0.06496575f, -0.42760834f, -0.00827092f, -0.16039932f, 0.19573145f, 
    0.04114917f, 0.10786485f, -0.03506779f, -0.02753435f, -0.10818554f, -0.29070467f, -0.48263356f, -0.12415645f, 
    -0.55277085f, -0.31484395f, -0.36460778f, -0.21508440f, -0.01363070f, 0.08159810f, -0.05499885f, 0.18400756f, 
    0.12093625f, 0.00254664f, -0.04726183f, -0.03725519f, -0.28165519f, -0.64234620f, -0.29438138f, 0.37415496f, 
    -0.03041285f, -0.00875217f, 0.07290579f, -0.06183565f, 0.04298546f, 0.04999158f, 0.47343636f, 0.29282218f, 
    -0.09217911f, -0.25965071f, -0.08694331f, 0.10249545f, -0.11957809f, -0.08301309f, -0.10288896f, -0.05859076f, 
    -0.01691268f, -0.10824741f, -0.16864236f, 0.20550188f, 0.17767546f, 0.05463077f, 0.28123391f, 0.12061147f, 
    0.20436002f, 0.02894086f, 0.31443501f, 0.06304070f, -0.00225376f, -0.03055592f, 0.03325497f, 0.10832360f, 
    0.19597466f, 0.17635217f, 0.19491065f, 0.27910247f, 0.12935509f, 0.10898584f, 0.11804333f, 0.14982949f, 
    0.01783801f, 0.05347857f, 0.10952214f, -0.14616136f, -0.81370789f, -0.18150659f, -0.07668956f, -0.46901709f, 
    -0.05570555f, -0.08534250f, 0.04963315f, -0.11660362f, 0.01805424f, -0.33774963f, -0.06957065f, 0.05139434f, 
    0.02028167f, -0.24902466f, 0.07399052f, -0.04679990f, -0.11793056f, 0.14434966f, -0.20349105f, -0.02961424f, 
    0.13688685f, -0.07279193f, 0.08356190f, 0.08970188f, -0.08107297f, -0.02459976f, -0.14366610f, -0.01093455f, 
    0.25110173f, -0.40033886f, 0.12813832f, 0.03639042f, 0.19934373f, 0.10625263f, -0.22462066f, 0.29723132f, 
    0.03106909f, 0.37551859f, -0.12550348f, -0.11496840f, -0.02647645f, -0.04976918f, 0.02691841f, 0.20705590f, 
    -0.06610166f, -0.05947139f, 0.05973069f, 0.15519327f, 0.02271166f, -0.22417635f, 0.28698650f, 0.05090855f, 
    0.07756433f, 0.04005506f, -0.09151273f, -0.03962060f, 0.19399033f, -0.12285054f, -0.32523918f, -0.23376289f, 
    -0.23343745f, 0.00698125f, -0.16541272f, -0.09790467f, 0.13331245f, -0.16655324f, 0.22397172f, 0.10873879f, 
    0.17555520f, 0.29760364f, -0.18232416f, 0.03282626f, 0.03588514f, 0.01259086f, -0.04930662f, -0.18424061f, 
    0.07865620f, 0.09723657f, 0.24401630f, -0.03712174f, 0.11839288f, 0.02549620f, -0.01256663f, 0.04876943f, 
    0.15576357f, -0.05637213f, 0.00302169f, -0.40262324f, 0.13071649f, 0.03886388f, 0.02946533f, -0.13986318f, 
    -0.19586122f, -0.20823619f, -0.01242928f, -0.17276545f, 0.01233206f, 0.19975720f, 0.01040468f, -0.06700569f, 
    0.04947759f, 0.19378203f, -0.17372121f, -0.08626105f, 0.03287319f, -0.01505601f, -0.03037945f, 0.18706389f, 
    -0.29346055f, 0.47318274f, -0.39347333f, -0.63278425f, -0.00381958f, 0.29745084f, -0.05574628f, -0.08448741f, 
    0.18931778f, 0.09517244f, -0.07843093f, -0.04359723f, -0.48462766f, -0.06874185f, 0.30696478f, -0.09098300f, 
    -0.02724237f, -0.39026451f, -0.03232175f, 0.08100729f, 0.01479476f, -0.00128553f, -0.08388456f, 0.01943015f, 
    -0.00392226f, -0.17891335f, -0.14562716f, 0.07391348f, -0.00415221f, 0.01243905f, 0.01951295f, 0.08449545f, 
    0.02946431f, -0.49727997f, -0.39092973f, -0.49640384f, 0.47802219f, -0.00059358f, -0.29693261f, -0.10074031f, 
    0.00970009f, 0.19971010f, 0.01377170f, 0.04708822f, 0.22306925f, -0.11563175f, 0.03089250f, 0.04946289f, 
    -0.41997707f, -0.07275799f, 0.00399102f, 0.05844511f, -0.04580617f, 0.02010313f, -0.08958260f, 0.23677595f, 
    0.11818586f, 0.17610888f, -0.06857319f, 0.20181268f, -0.00092398f, -0.04962928f, 0.00960036f, -0.37898439f, 
    0.08354362f, -0.12389308f, -0.01037177f, 0.03395966f, -0.07820610f, 0.03347760f, -0.02980767f, 0.03422160f, 
    -0.14084102f, 0.12896742f, -0.20608005f, 0.07791172f, -0.02569870f, -0.07597911f, -0.00008247f, 0.05128027f, 
    0.10250993f, 0.00093128f, -0.05966044f, -0.04776954f, -0.02698534f, -0.02940023f, -0.53815293f, 0.25384820f, 
    0.14699693f, 0.25003278f, -0.06301544f, 0.01902155f, -0.06497034f, -0.18235351f, 0.10371220f, -0.05078147f, 
    0.08866825f, 0.08983588f, -0.13936520f, 0.08151926f, -0.09963672f, -0.16636068f, 0.06322811f, -0.08738241f, 
    0.22818109f, -0.02476693f, -0.05926032f, 0.00090930f, 0.07319026f, -0.02150615f, -0.01730840f, -0.09436113f, 
    0.22098388f, 0.18165740f, 0.03116954f, 0.09257625f, -0.07884341f, 0.07230659f, 0.05604010f, -0.08302167f, 
    -0.08974586f, -0.17468047f, 0.31524661f, 0.11784025f, 0.03750698f, -0.09045603f, 0.02743330f, 0.20149933f, 
    0.13504499f, -0.08003831f, 0.34110630f, -0.00130746f, 0.39031351f, -0.13973743f, -0.74972856f, -0.28235349f, 
    0.14089173f, 0.07168143f, -0.06719879f, 0.10921548f, 0.17463318f, -0.10279342f, -0.07277955f, -0.16239458f, 
    0.29758382f, -0.34064850f, 0.20845391f, -0.03400205f, -0.16838111f, -0.03171434f, 0.24616854f, -0.04329249f, 
    0.14210942f, -0.18955356f, -0.03186359f, 0.08586023f, -0.32707533f, 0.37267014f, -0.19687343f, 0.18308441f, 
    0.11523561f, -0.13216740f, -0.14673211f, -0.10068032f, -0.06250404f, 0.28590226f, -0.09956827f, -0.06238357f, 
    -0.27021465f, -0.14032865f, -0.05708359f, 0.06045430f, -0.03089767f, -0.02942222f, -0.08304608f, -0.13475464f, 
    0.25841415f, 0.00295722f, 0.02209737f, 0.01098415f, 0.02521190f, 0.00206141f, 0.10501988f, -0.15345541f, 
    -0.08125859f, -0.07340815f, 0.01500011f, 0.15464061f, 0.11249202f, -0.06241482f, -0.00917741f, -0.38875818f, 
    -0.54966050f, -0.64874130f, -0.73912770f, 0.16869797f, -0.27063078f, -0.15678357f, -0.03158386f, -0.28928411f, 
    -0.06524471f, 0.01817890f, -0.04947471f, -0.12893698f, 0.19388235f, 0.08081215f, 0.18738385f, -0.16162221f, 
    -0.08704513f, 0.07839635f, -0.03778437f, 0.08912866f, 0.17485546f, 0.30400428f, 0.12413424f, 0.22701044f, 
    -0.01237765f, 0.38826954f, 0.42717305f, 0.31618187f, -0.04571622f, -0.07562961f, -0.03087267f, 0.06206631f, 
    -0.19172989f, -0.13960424f, 0.09432184f, 0.13375506f, -0.22014250f, 0.07965191f, -0.01768227f, -0.32928035f, 
    0.05914813f, -0.07868770f, 0.05267379f, -0.15271145f, -0.10383085f, 0.11158128f, -0.13328888f, -0.06075929f, 
    -0.03783465f, -0.04976089f, -0.01490365f, 0.00136339f, 0.07650063f, -0.03156568f, -0.06011911f, -0.02507645f, 
    0.02747049f, -0.25962427f, 0.05542056f, -0.24510559f, -0.12857978f, -0.16765171f, -0.42771029f, -0.30935240f, 
    0.01024148f, 0.12326291f, 0.07056908f, 0.07816091f, 0.02710326f, -0.07883296f, -0.21179055f, -0.02115370f, 
    -0.56814170f, -1.39569211f, -0.51481462f, -0.50699162f, -0.01897153f, 0.19716747f, 0.26554033f, -0.20274250f, 
    0.09908987f, 0.06417649f, -0.00289726f, 0.02957532f, 0.05903024f, -0.01839603f, 0.02865590f, -0.09758959f, 
    -0.08239244f, -0.00823545f, 0.00092344f, 0.04954787f, -0.06006244f, 0.19567527f, 0.27656645f, 0.06166117f, 
    -0.06254103f, -0.05588313f, -0.14059600f, 0.06953792f, -0.14273258f, -0.20645697f, 0.01008806f, 0.04975709f, 
    0.03479183f, 0.10469341f, -0.19455779f, -0.19713339f, 0.18388647f, -0.12568882f, -0.03915938f, -0.01976573f, 
    0.24682775f, -0.22242142f, 0.38384590f, 0.03568161f, -0.04396577f, -0.10197163f, -0.06284227f, -0.06168742f, 
    -0.67391616f, -0.14584456f, 0.26883146f, 0.22519001f, 0.09106828f, -0.12452495f, 0.06324372f, -0.17153884f, 
    -0.01684948f, 0.07683908f, 0.04121486f, 0.11685453f, 0.06564299f, -0.49489915f, -0.50565463f, -0.55161285f, 
    -0.27644774f, -0.09151129f, 0.07825556f, -0.07753354f, -0.11643066f, 0.02872388f, 0.18588194f, 0.11956441f, 
    -0.01570042f, -0.22326113f, 0.34038606f, 0.02781937f, 0.01016074f, -0.02299860f, -0.02292626f, -0.17725207f, 
    0.06485526f, -0.01093267f, 0.11377764f, 0.03027464f, -0.59112543f, -0.21776584f, 0.06887310f, 0.03479273f, 
    -0.31515691f, -0.43401635f, -0.26360199f, -0.32723916f, -0.10546823f, -0.13786753f, -0.11104006f, 0.00768670f, 
    0.10903449f, 0.53141248f, -0.20077474f, -0.08339238f, 0.03591394f, 0.06495863f, -0.02841323f, 0.20843749f, 
    0.04152920f, 0.16248366f, 0.01612438f, -0.03100058f, -0.68997747f, -0.86464721f, -0.50930119f, -0.25175452f, 
    -0.10940863f, -0.46579891f, 0.11569283f, -0.35412434f, -0.03422464f, 0.00903856f, -0.00410005f, -0.00470825f, 
    -0.51326692f, -0.50978589f, 0.46680897f, -0.07354990f, 0.06479073f, -0.05740212f, 0.02120020f, -0.00780114f, 
    0.01696212f, 0.08959758f, -0.04999301f, -0.16267414f, -0.08442330f, -0.29633152f, 0.23309034f, 0.08049849f, 
    0.17664179f, -0.13153596f, 0.13049091f, 0.10010697f, 0.11127037f, 0.30519497f, 0.08842389f, 0.04220404f, 
    0.10480998f, 0.09445290f, -0.09889808f, -0.11436029f, -0.04753343f, -0.07259147f, 0.02317872f, 0.03613471f, 
    0.08746716f, 0.31408015f, 0.21727836f, 0.01376730f, 0.87103719f, 0.48731917f, 0.00211676f, -0.16354401f, 
    -0.07275589f, -0.17821728f, 0.31660050f, 0.04097218f, 0.18598139f, -0.07550805f, 0.05423170f, 0.00730542f, 
    -0.24978100f, 0.04024063f, 0.49309593f, -0.07555269f, -0.05368385f, -0.01979166f, -0.02941685f, 0.22949409f, 
    -0.19704032f, 0.21269092f, 0.08285104f, 0.05497420f, -0.24138033f, -0.03201887f, -0.16942790f, -0.08544133f, 
    0.01615336f, 0.08830500f, -0.01697676f, 0.09380561f, 0.09743097f, 0.06757160f, -0.01775004f, 0.02256292f, 
    -0.09522244f, -0.07439920f, -0.08683674f, -0.25152978f, 0.01127651f, 0.03993361f, -0.05217393f, 0.10787388f, 
    -0.06268938f, 0.16760689f, -0.29246604f, -0.30476499f, 0.42459768f, -0.13404964f, -0.04301574f, -0.78139168f, 
    -0.10997861f, 0.08163416f, 0.38124168f, -0.03361282f, -0.01404954f, 0.06008014f, -0.04488079f, 0.10807931f, 
    -0.79294646f, 0.24305497f, 0.00044209f, -0.51841372f, -0.29227564f, -0.08149717f, -0.22322489f, 0.05052037f, 
    -0.09646830f, -0.05086312f, 0.09966382f, -0.06684557f, -1.07060623f, -0.97842348f, -0.77281821f, -0.06800510f, 
    0.13540614f, 0.11143221f, -0.13204230f, -0.53434998f, 0.08629443f, -0.05320371f, -0.01875756f, 0.05266822f, 
    0.09311917f, -0.06986594f, -0.29042929f, 0.17735091f, 0.02343748f, -0.07546496f, 0.07900160f, 0.08375186f, 
    0.05375813f, 0.16970825f, -0.02744438f, -0.02267519f, 0.58970100f, -0.16284768f, -0.08104718f, -0.49164364f, 
    -0.01097635f, -0.08314034f, 0.22784355f, 0.05365142f, 0.04047102f, 0.17759879f, 0.00901789f, -0.11865922f, 
    -0.11625914f, -0.15171464f, 0.05535077f, 0.16010025f, 0.02350567f, -0.11554071f, -0.07141117f, 0.06309962f, 
    -0.06391545f, 0.00822485f, 0.08159567f, 0.03717776f, 0.00904180f, 0.06331518f, -0.23937799f, -0.48336884f, 
    0.14270639f, 0.18823834f, -0.12503347f, 0.16532092f, -0.01367353f, 0.12412295f, 0.29685384f, -0.10396969f, 
    -0.01645855f, 0.01041546f, 0.30162421f, 0.05931538f, -0.06918046f, -0.13999140f, 0.04060834f, 0.04822823f, 
    0.07720600f, -0.10720442f, -0.05898423f, -0.04652549f, -0.38967896f, -0.25218624f, -0.20716672f, 0.16427770f, 
    -0.29788426f, 0.17224376f, -0.02071878f, -0.00514319f, 0.17444362f, 0.16392300f, 0.13674308f, 0.15700163f, 
    -0.22549954f, -0.46528527f, -0.14271727f, 0.11242594f, 0.09691745f, -0.33367199f, -0.16690980f, 0.19582635f, 
    0.01775804f, -0.03428124f, -0.13110033f, -0.09374059f, -0.00982106f, 0.13417470f, -0.14304496f, 0.13613074f, 
    -0.05796696f, 0.12193336f, 0.06316400f, 0.00989722f, -0.04512709f, 0.07579093f, 0.02367079f, 0.07145680f, 
    0.20423359f, -0.58058167f, -0.33842891f, -0.27068889f, -0.05798587f, 0.07872007f, -0.02549169f, 0.06212541f, 
    0.13124533f, -0.06456390f, 0.03671673f, -0.03518842f, -0.07989147f, 0.10875325f, -0.04731274f, 0.08753949f, 
    0.11504043f, 0.02128250f, 0.06571882f, 0.02413268f, -0.03573512f, 0.07083180f, -0.14918181f, -0.33494616f, 
    0.11099184f, 0.01217332f, -0.00668141f, -0.06840941f, 0.00454974f, -0.01720206f, 0.03056499f, 0.03044639f, 
    0.09737313f, 0.05132328f, -0.04391029f, -0.11612962f, -0.12976284f, -0.49166679f, 0.31660122f, -0.04711220f, 
    0.04365645f, 0.09433514f, 0.12141187f, -0.05109684f, 0.05981432f, -0.00787705f, 0.06912541f, -0.06465089f, 
    -0.72053516f, 0.37618732f, -0.21619987f, 0.46904689f, 0.00273808f, -0.09455936f, -0.04664078f, 0.10117017f, 
    -0.01675846f, -0.13040750f, -0.01484012f, 0.02083871f, 0.22491270f, -0.08050925f, -0.01991141f, -0.15589461f, 
    0.07234608f, 0.09735513f, -0.10710107f, 0.09798948f, 0.20632572f, 0.15685803f, 0.03550128f, -0.05048209f, 
    0.00678977f, -0.11492786f, 0.00695020f, -0.01025562f, -0.15545718f, 0.03924167f, 0.13490532f, -0.04689441f, 
    -0.01750859f, -0.08458509f, -0.06470543f, 0.03519071f, 0.10460841f, 0.10727894f, 0.12027851f, -0.13311501f, 
    -0.04076677f, 0.01375330f, 0.02710160f, -0.02150770f, -0.02546926f, 0.00980591f, -0.04966620f, 0.05049572f, 
    -0.21441363f, -0.03037815f, 0.04499569f, -0.20969263f, -0.05560453f, -0.02443853f, 0.03522967f, -0.00540637f, 
    -0.25752348f, 0.07982481f, -0.16116485f, -0.18920287f, -0.39008418f, -0.10391870f, -0.22238223f, 0.47429392f, 
    -0.04561178f, -0.00652605f, -0.12182542f, -0.04652842f, -0.04559920f, 0.08320957f, -0.07982794f, 0.07690006f, 
    -0.25342914f, -0.02319556f, -0.38059497f, 0.24652110f, -0.03519904f, 0.34885955f, -0.05513191f, -0.04912429f, 
    -0.01346741f, 0.10082820f, 0.03572661f, 0.13544689f, 0.03949089f, -0.23896357f, -0.21522817f, -0.06436343f, 
    -0.02502913f, -0.11508618f, -0.08331412f, 0.01057924f, 0.07189976f, 0.00614657f, 0.04399100f, 0.08191711f, 
    -0.17638123f, -0.84938377f, -0.40097487f, 0.14801569f, -0.12135218f, -0.10667764f, 0.08139945f, 0.04834346f, 
    0.03594488f, 0.18181328f, 0.14564568f, -0.13605344f, -0.61370265f, -0.15984038f, 0.20324536f, 0.25097492f, 
    0.05383317f, -0.19221015f, -0.02880707f, 0.19691713f, -0.07324637f, 0.03416023f, -0.14292347f, 0.05063538f, 
    -0.41294983f, 0.73465288f, 0.25622332f, 0.25837353f, -0.01919884f, -0.39736477f, 0.13280481f, -0.06198406f, 
    -0.04868065f, -0.07748879f, -0.03579494f, -0.00169514f, 0.62528831f, -0.16117096f, -0.06737154f, -0.48966587f, 
    0.09183546f, 0.00655189f, -0.29159844f, -0.06097438f, -0.14843100f, 0.01178751f, -0.05948786f, -0.07351606f, 
    0.08367888f, 0.13358423f, 0.08789723f, 0.13163224f, -0.02412004f, -0.03378797f, -0.03646962f, -0.00913787f, 
    0.10775109f, -0.19631433f, -0.07722676f, -0.25579423f, -0.62634099f, 0.08410220f, 0.05028285f, 0.09164102f, 
    -0.04445843f, 0.02166682f, 0.12381296f, -0.05789972f, -0.09041416f, 0.04723551f, 0.03312195f, -0.06042397f, 
    0.24418966f, -0.01919479f, -0.12038948f, -0.24549459f, -0.16466840f, 0.05067199f, -0.03732027f, -0.00499356f, 
    0.02349746f, 0.29335251f, -0.18389678f, 0.05668385f, -0.39495900f, -0.34198940f, -0.06058254f, -0.29106236f, 
    -0.00139253f, 0.09484037f, 0.05057378f, 0.01132315f, -0.05035241f, -0.02355404f, -0.05322709f, -0.00857273f, 
    0.03822340f, 0.01020296f, -0.01325916f, 0.03451763f, 0.05787185f, -0.00791579f, 0.08083750f, -0.01973887f, 
    0.11906683f, -0.10637101f, 0.01593369f, 0.08291782f, -0.35056826f, 0.34610415f, -0.32194000f, -0.00697295f, 
    -0.10312191f, -0.03208470f, -0.09308348f, 0.33680755f, 0.09833663f, 0.04564187f, 0.12477665f, 0.03582573f, 
    0.47923413f, -0.56998086f, -0.60334712f, -0.26808411f, 0.29793045f, -0.09262361f, 0.09410727f, -0.19789396f, 
    0.04436934f, 0.10002062f, 0.10012892f, -0.02260462f, -0.80010706f, -0.57743758f, 0.18642849f, 0.41144171f, 
    0.14643925f, -0.04241340f, -0.00169917f, -0.04355822f, 0.02226721f, 0.04284661f, 0.02495009f, 0.01947057f, 
    0.29924470f, -0.06279867f, 0.10121968f, -0.21914715f, 0.05525494f, 0.00511789f, -0.03898199f, -0.11100851f, 
    -0.02568482f, -0.07356545f, -0.06931973f, 0.06477559f, -0.08359755f, 0.09250898f, 0.11268762f, -0.05607314f, 
    0.11871687f, 0.01557787f, 0.01342971f, -0.02657792f, -0.12154155f, -0.18170065f, 0.23519747f, 0.13317189f, 
    0.24359742f, -0.05567499f, 0.00445927f, -0.19129084f, -0.01526116f, 0.12477007f, -0.01029648f, -0.08441819f, 
    0.00578806f, -0.05274322f, 0.00511475f, -0.09079333f, -0.24307516f, 0.64268637f, -0.55173540f, 0.24222916f, 
    0.02845275f, -0.01283108f, 0.06680703f, -0.13871913f, 0.05095344f, 0.06956568f, -0.33540517f, -0.18648593f, 
    0.07406254f, 0.11573184f, -0.00746712f, -0.15374176f, -0.04761440f, 0.14001836f, 0.12998541f, 0.04526588f, 
    -0.08037366f, -0.17733766f, -0.12351791f, -0.09063400f, 0.40895152f, -0.37854651f, -0.12758057f, -0.08649752f, 
    0.00932963f, 0.08871156f, -0.09796965f, -0.04233617f, 0.14365865f, -0.12696940f, -0.07258473f, -0.07756554f, 
    0.21003050f, 0.08358656f, -0.51485151f, -0.31108186f, -0.03969774f, -0.00312560f, 0.01134276f, -0.12041190f, 
    0.06469663f, 0.01566341f, 0.06637460f, 0.08946136f, -0.07750233f, -0.10145722f, 0.02437074f, 0.07845280f, 
    -0.00932028f, 0.00441205f, -0.03504589f, 0.14452916f, -0.13798152f, -0.09114038f, -0.07265855f, -0.26879054f, 
    -0.60660499f, -0.46149555f, -0.30256876f, 0.13884726f, -0.04486736f, 0.17378801f, 0.16959369f, 0.20049396f, 
    0.13461173f, -0.10941716f, 0.02464522f, -0.02413659f, -0.36879888f, 0.19357871f, 0.05317515f, -0.05698287f, 
    -0.15991095f, -0.03153168f, -0.07625779f, -0.08205874f, -0.11401056f, 0.13238353f, -0.02376313f, 0.20713732f, 
    -0.10313033f, -0.00371231f, 0.05158397f, -0.17444596f, -0.04662488f, -0.01222012f, 0.03303929f, 0.03551728f, 
    0.00469126f, 0.06242260f, 0.04364837f, 0.16329727f, 0.50621092f, 0.19584994f, 0.03135916f, -0.06901839f, 
    0.19820468f, -0.11019521f, -0.05119652f, -0.22424172f, 0.27943009f, 0.00612081f, 0.05375538f, 0.04577548f, 
    -0.38527921f, -0.12805530f, -0.11982075f, -0.13630787f, 0.26348692f, -0.06936419f, -0.14347474f, -0.18732290f, 
    0.03208271f, 0.02572490f, -0.01547665f, 0.00639957f, -0.29393244f, 0.33296832f, -0.00950834f, 0.18169978f, 
    -0.18321042f, 0.03256683f, 0.03682076f, -0.00875867f, -0.08725640f, 0.20934919f, -0.08208109f, -0.16046631f, 
    0.04392192f, -0.04968773f, -0.04996310f, -0.01494422f, 0.16424266f, -0.07210819f, 0.06605694f, -0.02247913f, 
    0.21914998f, 0.18411200f, 0.23427945f, 0.30881250f, -0.20160845f, -0.06556904f, 0.12984642f, -0.00971309f, 
    0.03942103f, -0.02325113f, 0.04544257f, -0.05120084f, 0.00900010f, 0.08375106f, 0.16089158f, -0.03015156f, 
    0.41296309f, 0.18215974f, -0.25554371f, -0.17452635f, -0.36973464f, 0.01517674f, 0.12340175f, -0.02852152f, 
    0.08512111f, -0.05229428f, 0.17359932f, 0.18979581f, 0.31773528f, -0.21083249f, -0.30983585f, -0.15087488f, 
    0.32736805f, 0.12823959f, 0.06601077f, 0.22366707f, 0.06417053f, -0.05092147f, -0.07758249f, -0.21075754f, 
    -0.36305469f, -0.22547716f, -0.23222429f, 0.20298533f, 0.11085285f, 0.21475033f, -0.12099698f, 0.30637434f, 
    0.06274594f, 0.20935901f, 0.09179837f, 0.18517262f, -0.18714158f, -0.50592518f, -0.40493903f, -0.08186024f, 
    -0.23751435f, -0.04045073f, 0.01752325f, 0.03579935f, 0.00530213f, 0.04359615f, 0.06272236f, 0.03470260f, 
    0.18551481f, -0.02267555f, -0.26366380f, -0.41230628f, 0.03508129f, 0.12658413f, 0.07509411f, 0.06779472f, 
    -0.28298694f, -0.19478191f, -0.39098781f, -0.52189344f, -0.32791466f, -0.44831657f, -0.36676538f, -0.30781192f, 
    0.03789133f, -0.15858965f, 0.16400945f, -0.07066078f, 0.06298935f, 0.01547492f, 0.10477757f, 0.04778431f, 
    -0.62675625f, -0.29175454f, 0.10140413f, 0.12863766f, -0.25483415f, 0.00541238f, 0.15731800f, 0.04295948f, 
    0.07156631f, 0.14861643f, 0.13106488f, 0.06183178f, 0.16631553f, 0.12872799f, -0.23666747f, -0.39307666f, 
    0.11106221f, -0.16661258f, 0.09518931f, -0.03667970f, 0.04738095f, 0.06587830f, 0.11163623f, -0.06467667f, 
    -0.48807538f, -0.16635816f, -0.06044601f, -0.14183772f, -0.13317527f, -0.10592445f, -0.20588434f, -0.11302701f, 
    -0.16689904f, -0.12594846f, -0.27710164f, -0.36602113f, -1.08385885f, 0.15999204f, 0.21756150f, 0.28784117f, 
    0.18514240f, 0.05205230f, -0.12145112f, 0.16531289f, -0.00772095f, 0.14680366f, 0.03152206f, 0.12549369f, 
    0.02019263f, -0.06394108f, -0.07049813f, -0.00681767f, -0.20211230f, 0.09843795f, 0.03475274f, 0.13911946f, 
    0.25446448f, -0.19728348f, 0.04829957f, -0.16968448f, 0.01541542f, -0.25280270f, 0.02229477f, 0.25665382f, 
    0.06556024f, 0.16171011f, 0.08862917f, 0.18008809f, -0.00649109f, -0.16934790f, -0.06664839f, -0.23900419f, 
    -0.21524926f, 0.13530990f, 0.16764177f, -0.10870127f, -0.13138093f, 0.01169586f, -0.04151311f, -0.03487953f, 
    -0.07142793f, 0.07009620f, -0.13713954f, 0.12320223f, -0.74684823f, -0.07090557f, 0.18654351f, 0.46896386f, 
    0.13204400f, -0.14464550f, -0.00967329f, -0.10475250f, -0.03616525f, -0.27454528f, 0.00882746f, -0.16333959f, 
    -0.39233774f, -0.78130192f, -0.70245153f, -0.37264800f, 0.08052200f, 0.23825216f, 0.09192351f, 0.07827455f, 
    -0.02593735f, 0.03264738f, -0.04292187f, 0.12245310f, -0.25452220f, -0.08886397f, -0.09094454f, 0.19031119f, 
    0.09960759f, 0.18104339f, -0.00998028f, 0.09815958f, -0.00702315f, 0.00848293f, -0.00063623f, -0.07434142f, 
    0.48536122f, 0.10149652f, -0.09241683f, -0.32068020f, 0.02900271f, -0.23896608f, 0.15676264f, -0.24312563f, 
    -0.14714922f, 0.03140094f, -0.03114973f, 0.06258861f, -1.16953015f, -0.06981889f, 0.18388379f, 0.43656126f, 
    -0.03642337f, -0.09770435f, -0.20539750f, -0.03051395f, -0.04178333f, 0.07523313f, 0.07201215f, -0.10500427f, 
    0.13468155f, 0.02529217f, -0.07009002f, -0.26001632f, 0.04187884f, -0.12821656f, -0.01623857f, 0.01150983f, 
    0.10273149f, 0.14558917f, 0.11596621f, 0.30232853f, 0.37008563f, -0.12182292f, -0.14093916f, -0.16320898f, 
    0.00749985f, 0.23794913f, 0.03937368f, 0.09886947f, 0.05204222f, 0.27231818f, 0.24902186f, 0.00977539f, 
    -0.05885028f, -0.03418422f, -0.02464157f, 0.00596346f, -0.10148147f, 0.03802872f, 0.05281664f, -0.00354058f, 
    0.20520996f, 0.11774487f, 0.21575652f, 0.09596008f, 0.05186578f, 0.01604914f, -0.17723016f, -0.23028785f, 
    0.18020469f, 0.01454421f, 0.18054269f, 0.11341894f, -0.27556086f, -0.16965358f, -0.16778108f, -0.23851022f, 
    -0.54170823f, -0.37902620f, -0.01446192f, -0.19766358f, 0.15873396f, -0.15390185f, -0.27871284f, 0.15620583f, 
    0.00207327f, 0.00198591f, 0.11268092f, 0.01809913f, -0.36847177f, 0.39511991f, -0.34643731f, 0.32389301f, 
    -0.10585891f, -0.19788335f, 0.10771945f, -0.10558880f, 0.01779391f, 0.13858011f, 0.02807339f, 0.21563882f, 
    0.09104524f, 0.29908860f, 0.22038737f, -0.37526453f, -0.19962640f, -0.14763728f, -0.36654481f, -0.28098139f, 
    0.04904251f, -0.03398846f, 0.08482780f, 0.17741562f, -0.10492657f, -0.09351721f, 0.13580313f, 0.04824406f, 
    0.11918671f, -0.00891774f, -0.07524180f, 0.04587339f, 0.14284396f, 0.13908492f, -0.12580292f, 0.02574559f, 
    -0.27613899f, -0.00948018f, 0.15568241f, 0.15103117f, 0.12631275f, 0.14835155f, -0.02585182f, 0.00745146f, 
    0.09432160f, 0.01164390f, 0.20719688f, 0.06553775f, -0.01611560f, -0.33225647f, -0.42070994f, 0.08275119f, 
    0.19291447f, -0.18630093f, 0.20982985f, 0.16077442f, -0.11318482f, -0.19318353f, -0.08716644f, -0.07556620f, 
    0.24618185f, 0.14680013f, -0.68237889f, -0.12515520f, -0.06254523f, -0.01127926f, 0.14079359f, 0.16904595f, 
    0.07830652f, 0.08734655f, 0.04368141f, 0.06694764f, -0.00802710f, 0.18096128f, -0.00133006f, 0.37070096f, 
    0.01122801f, 0.13366635f, -0.14495462f, -0.21921128f, 0.12931997f, 0.14508250f, 0.14101772f, 0.12846622f, 
    0.21873641f, -0.02277493f, 0.28213844f, -0.12072184f, 0.19265036f, -0.02186039f, 0.07103038f, 0.15442671f, 
    -0.08816262f, 0.14783767f, -0.09907310f, -0.06173620f, -0.03541281f, -0.56604445f, 0.00194839f, -0.29844511f, 
    -0.10862947f, 0.20911099f, 0.00002516f, -0.14545214f, 0.20503886f, 0.11772577f, -0.07280681f, 0.01815115f, 
    -0.26516506f, -0.14126094f, 0.17972271f, -0.26125339f, 0.17593889f, 0.04695313f, -0.40523246f, 0.07528593f, 
    0.02107307f, -0.07446320f, -0.05664356f, 0.12874717f, -0.42469722f, 0.13043962f, -0.31340870f, 0.20267485f, 
    0.03254619f, 0.03058288f, -0.01262428f, -0.05456414f, 0.14579155f, 0.11047799f, 0.06711472f, 0.04620556f, 
    -0.52278942f, 0.46592757f, -0.78276551f, -0.35801783f, -0.39554986f, 0.08233688f, -0.33601236f, -0.05162367f, 
    0.00446864f, -0.21276753f, -0.03765233f, -0.07017654f, 0.10799471f, 0.01930599f, 0.18559687f, -0.16940469f, 
    0.14170671f, -0.03500138f, 0.06563893f, 0.14151417f, -0.04686805f, -0.10084692f, -0.04006498f, -0.00672756f, 
    0.12921570f, 0.29313919f, 0.80565602f, -0.50735968f, -0.06086264f, -0.21906465f, -0.04429594f, -0.10382646f, 
    0.00715188f, 0.14881115f, 0.02058083f, -0.02429100f, -0.45315126f, 0.04618896f, -0.19439933f, -0.09047055f, 
    -0.16983259f, 0.04592383f, 0.17643200f, 0.24855641f, 0.01182276f, 0.10398607f, 0.11770143f, -0.08557861f, 
    -0.22174741f, -0.18325633f, 0.16193511f, -0.52467269f, -0.24708962f, -0.11637520f, 0.09021095f, 0.09974386f, 
    0.06039482f, -0.05704348f, -0.01501610f, 0.02465044f, -0.43182337f, -0.35507753f, 0.09622782f, 0.49487683f, 
    -0.05879211f, 0.22340862f, -0.38693014f, -0.12154917f, 0.32712784f, 0.06221110f, -0.01022407f, 0.05429764f, 
    -0.00349147f, -0.00029744f, 0.04042709f, 0.20069808f, -0.02688972f, 0.11732455f, 0.10348088f, 0.01951241f, 
    0.10977873f, 0.11538704f, 0.18352449f, 0.30780393f, -0.13964844f, -0.04534194f, -0.52444291f, -0.76652318f, 
    -0.04858547f, -0.33137566f, 0.08665190f, -0.05475482f, 0.02460578f, 0.10773143f, -0.03498526f, -0.03157801f, 
    0.34370968f, 0.17538822f, -0.04121779f, 0.39567578f, -0.01790115f, 0.02904687f, -0.37498036f, -0.08697640f, 
    -0.01135828f, -0.07335178f, -0.01741334f, -0.19045272f, 0.01899490f, 0.05405674f, 0.08173551f, -0.16650365f, 
    -0.42398545f, -0.03789064f, -0.06997793f, 0.07179277f, 0.00760579f, 0.10725181f, 0.08398083f, 0.02093682f, 
    0.01008645f, -0.35991713f, 0.18210128f, 0.00575752f, 0.19855618f, -0.02676704f, 0.08479017f, -0.04410714f, 
    0.17155260f, 0.12525319f, -0.18195766f, 0.04050986f, -0.37057322f, 0.39470243f, -0.75417364f, -0.05455293f, 
    0.22954087f, -0.05227264f, 0.38769001f, 0.27319330f, -0.13424246f, -0.10010082f, -0.08791178f, 0.06222669f, 
    -0.25794265f, 0.18343957f, 0.27103943f, 0.51797152f, 0.18308884f, -0.53502411f, -0.05364216f, -0.01750812f, 
    0.00113104f, -0.15027788f, 0.04816521f, 0.00060426f, 0.49499619f, 0.14078723f, -0.15696508f, -0.50621426f, 
    -0.25069237f, -0.06977908f, 0.08980159f, 0.15382795f, 0.07173961f, -0.06244839f, -0.00448596f, -0.00649982f, 
    -0.16556622f, -0.49877334f, -0.00977989f, 0.07224555f, -0.02634088f, 0.19949843f, -0.02553201f, -0.20334248f, 
    0.01177004f, 0.05947274f, -0.04511016f, -0.15722929f, -0.00376761f, 0.01306189f, -0.16538967f, -0.19623719f, 
    -0.04001273f, -0.01006250f, 0.07069211f, -0.01204397f, -0.03828188f, -0.04716918f, 0.08255564f, -0.05645771f, 
    0.07247259f, -0.13128611f, 0.21303713f, 0.17633204f, 0.38929251f, -0.05534871f, -0.11261514f, -0.09041785f, 
    -0.05761243f, -0.11095939f, -0.08379997f, -0.03334274f, -0.42705202f, 0.09660183f, -0.06789073f, 0.36222282f, 
    0.00804467f, -0.15335874f, -0.12470404f, -0.19024745f, 0.09370933f, -0.14603020f, 0.17491867f, -0.14721939f, 
    0.24356110f, -0.20170079f, 0.15788378f, -0.04111642f, -0.02836157f, 0.30517226f, -0.38467085f, 0.12407296f, 
    -0.06972156f, 0.05819421f, -0.03314795f, -0.17619440f, 0.28591511f, -0.20514090f, 0.33522809f, 0.15231916f, 
    -0.11606308f, -0.02096920f, -0.26531962f, 0.02905914f, 0.14826001f, -0.03755255f, 0.09433616f, 0.05289659f, 
    -0.40707800f, -0.09053917f, -0.62287283f, 0.21849713f, -0.10856284f, 0.15864161f, -0.21384828f, 0.25662577f, 
    -0.02849974f, 0.15174310f, 0.06695165f, 0.05945954f, 0.38712570f, 0.00334495f, 0.39185724f, -0.25323623f, 
    -0.11954822f, -0.09602766f, 0.07872116f, 0.21214052f, -0.12677005f, -0.19025590f, -0.39190668f, -0.25099537f, 
    -0.03351352f, 0.07089256f, 0.14201781f, -0.03371103f, 0.00257780f, 0.03165733f, -0.20690629f, 0.02206583f, 
    -0.17989379f, 0.24124336f, 0.03543510f, -0.27519375f, -0.29654580f, -0.17212833f, 0.39053109f, -0.20122814f, 
    -0.02484589f, -0.12919548f, -0.00425564f, 0.13831615f, -0.01694304f, -0.39008698f, 0.03108009f, 0.12920366f, 
    -0.04221635f, -0.13190460f, -0.30058852f, -0.44846445f, -0.19328472f, -0.25196266f, 0.09934974f, -0.08959258f, 
    0.14883772f, 0.11989820f, 0.06091498f, -0.11026251f, -0.61756080f, 0.34201851f, 0.04979925f, -0.06458957f, 
    -0.10543850f, 0.08873011f, -0.16986015f, -0.18631674f, 0.02318379f, 0.09466475f, 0.05848867f, -0.17460263f, 
    -0.06600119f, -0.30190027f, -0.07703116f, -0.04796907f, -0.12529857f, 0.23667079f, 0.16650316f, -0.10662908f, 
    0.09710757f, 0.16114600f, 0.02009960f, -0.05511664f, 0.30480966f, -0.25801483f, 0.03168871f, -0.10692619f, 
    -0.03030594f, -0.12338980f, 0.12216286f, -0.02651800f, -0.04486479f, -0.05208813f, -0.23828523f, -0.51653129f, 
    -0.12968637f, 0.12012033f, -0.12269893f, 0.16269709f, -0.19957931f, 0.03168920f, 0.08668358f, 0.20009537f, 
    0.07516102f, 0.02515600f, 0.27571163f, 0.37516642f, 0.05760696f, -0.21186393f, 0.32134363f, -0.00238255f, 
    -0.27169168f, 0.03563678f, 0.25190136f, -0.15505502f, -0.07768276f, -0.10838527f, 0.09920230f, -0.07968251f, 
    -0.10507388f, -0.06293302f, 0.08339547f, 0.27113035f, -0.14697134f, 0.08336681f, -0.37226975f, 0.18945359f, 
    0.03021466f, -0.19932508f, 0.02802666f, -0.04212750f, 0.00724172f, -0.10617050f, 0.32208186f, -0.07937703f, 
    -0.07674960f, -0.01006701f, 0.11018821f, -0.00803306f, -0.13980919f, -0.02917898f, -0.13963467f, -0.11412776f, 
    0.64209002f, 0.03422542f, 0.28671411f, -0.18390483f, 0.01295443f, -0.00771715f, 0.31182453f, -0.02954828f, 
    -0.11829516f, 0.07391506f, 0.26927361f, 0.19191335f, -0.20237988f, -0.03703967f, 0.04759022f, 0.13641769f, 
    -0.17533511f, -0.02112492f, -0.05852310f, -0.01269522f, 0.02620034f, 0.07055901f, 0.19780920f, 0.11992390f, 
    -0.22975069f, -0.24332191f, -0.72125494f, 0.46727210f, 0.12667096f, 0.04195386f, 0.00587555f, 0.15806472f, 
    -0.12704878f, -0.34964389f, -0.59023845f, -0.27155256f, -0.06789519f, 0.06564139f, -0.31855783f, 0.09544370f, 
    -0.16337456f, 0.18145901f, -0.17197071f, -0.19048506f, 0.16302928f, 0.29034454f, 0.00669646f, -0.14425200f, 
    0.42792541f, -0.43194613f, 0.49519676f, 0.09201886f, -0.03220039f, -0.04079999f, 0.01658711f, 0.14347403f, 
    0.15545031f, 0.08427501f, 0.12646136f, 0.25184911f, -0.58577394f, -0.15229042f, -0.27979541f, -0.19253555f, 
    0.03680171f, 0.27928659f, -0.23969610f, -0.14081611f, -0.32748005f, -0.03147014f, -0.11505089f, -0.29476771f, 
    -0.18091881f, 0.10387190f, 0.15818147f, -0.43899384f, -0.11142912f, -0.03974049f, -0.01812569f, -0.15901259f, 
    0.00182673f, -0.15086754f, -0.36279890f, -0.52117723f, -0.14879486f, 0.06080210f, -0.10644969f, 0.30270809f, 
    -0.00854604f, 0.01433599f, 0.10018312f, -0.09356470f, 0.01445003f, 0.06789026f, -0.20646706f, -0.10377989f, 
    -0.09098683f, 0.27046895f, 0.31800452f, 0.13423879f, 0.17032076f, -0.07610546f, -0.02455159f, 0.03794984f, 
    0.02397525f, 0.26736876f, 0.08221725f, 0.04683964f, -0.19361591f, 0.00572230f, -0.03814944f, 0.12629218f, 
    0.16542892f, -0.13863803f, 0.04650401f, 0.05147009f, -0.13679664f, -0.04181328f, -0.13905014f, -0.14321242f, 
    -0.33053890f, 0.09074467f, -0.17833710f, -0.14342344f, -0.18080521f, -0.06186070f, -0.11190518f, -0.01189445f, 
    -0.11660539f, 0.28109235f, -0.28300005f, 0.29462686f, -0.02450000f, -0.64471358f, -0.00050785f, -0.03324664f, 
    -0.10306579f, 0.17363799f, -0.05815344f, 0.11739041f, -0.20297991f, -0.01373409f, 0.00765552f, -0.10336861f, 
    0.05905053f, 0.02102191f, -0.08381196f, -0.01462495f, -0.06053061f, -0.04480379f, -0.14651856f, 0.03548521f, 
    -0.01673749f, 0.12277112f, -0.05293646f, 0.05000684f, -0.20208213f, -0.29854637f, 0.27619892f, 0.07028601f, 
    -0.06068001f, 0.28773803f, 0.12917276f, -0.03805013f, -0.04258930f, 0.06705551f, 0.03128242f, 0.15663275f, 
    -0.47554755f, 0.20802096f, 0.07952379f, -0.00380686f, -0.15811297f, -0.06261471f, 0.16329275f, 0.03436093f, 
    -0.03894592f, -0.22593859f, -0.09652544f, -0.01586122f, -0.22799079f, 0.33177227f, -0.50303972f, 0.79103923f, 
    -0.02945643f, 0.03386659f, 0.17725761f, -0.13959464f, 0.06816206f, -0.10322350f, -0.05170425f, 0.01515213f, 
    -0.31503785f, 0.14915159f, -0.37375998f, 0.05268670f, -0.12586057f, 0.05406873f, 0.12726443f, -0.24866053f, 
    0.17487872f, 0.19500722f, 0.04034618f, 0.02328582f, 0.38351023f, 0.29770529f, 0.42727372f, -0.17237782f, 
    -0.11827262f, 0.09496940f, 0.07838615f, 0.38453743f, 0.29862499f, 0.08216545f, -0.23108386f, 0.15505292f, 
    -0.06778676f, 0.07716040f, 0.23256898f, 0.24870004f, -0.05858393f, 0.02165127f, -0.06935989f, -0.08978052f, 
    -0.12511262f, 0.19942889f, -0.09192839f, 0.26113844f, -0.51218230f, 0.08706065f, -0.20568855f, -0.14436090f, 
    -0.01230439f, 0.01545962f, 0.11582417f, 0.04598533f, -0.17307277f, -0.10676215f, -0.13959199f, -0.20735699f, 
    0.03171327f, -0.60726815f, -0.07873323f, 0.02294131f, -0.07088476f, 0.03422975f, -0.15307161f, -0.07308894f, 
    -0.11797255f, 0.01794414f, 0.06359551f, -0.06729756f, 0.07660979f, -0.16932100f, 0.24831995f, -0.16621959f, 
    0.10535750f, 0.04096010f, 0.12300882f, 0.15895040f, 0.07131787f, 0.17664167f, 0.25796029f, 0.00571818f, 
    -0.46936369f, 0.36537203f, -0.50961947f, -0.24918349f, 0.01867998f, -0.03034563f, 0.31959927f, -0.10182588f, 
    0.05881121f, -0.00578335f, -0.20078538f, -0.10236673f, 0.11675163f, 0.00531979f, 0.10149147f, -0.27418137f, 
    -0.18210281f, 0.11972237f, -0.09057886f, 0.08106254f, -0.15549269f, 0.14196078f, 0.26186121f, -0.00283597f, 
    0.01561476f, -0.00211030f, -0.27005619f, -0.15325987f, -0.02913667f, 0.16825245f, -0.00133865f, 0.06120602f, 
    0.07976380f, -0.00495637f, 0.05444099f, -0.09887601f, 0.61296296f, 0.01033484f, 0.12282673f, 0.44774312f, 
    0.13484474f, -0.11129694f, -0.22313872f, 0.07267434f, 0.03124500f, 0.26044670f, 0.13266750f, 0.01933782f, 
    0.30184001f, -0.17993122f, 0.29158589f, -0.01055004f, -0.16971952f, -0.11784873f, -0.05780639f, -0.25590575f, 
    -0.07534126f, 0.15449628f, 0.01985873f, 0.12887785f, -0.16470379f, 0.06633364f, 0.13558839f, -0.00524549f, 
    0.18533316f, 0.14451800f, 0.00449969f, -0.12586078f, 0.02005863f, -0.13950300f, 0.24749981f, 0.10501681f, 
    -0.03003633f, 0.08045577f, 0.03715100f, 0.08137105f, 0.07159962f, -0.13426961f, 0.04691162f, 0.24373201f, 
    -0.21274574f, -0.11330848f, -0.20847301f, -0.30971077f, -0.48851621f, 0.32881537f, -0.21761900f, 0.36591831f, 
    -0.01421042f, -0.14145434f, 0.24782847f, -0.08432440f, 0.07018564f, 0.00005821f, 0.03165622f, -0.07537215f, 
    -0.81494457f, 0.28608763f, -0.14567107f, 0.14475819f, 0.14861447f, 0.16256335f, 0.11712076f, -0.01008364f, 
    -0.06848153f, -0.07128207f, -0.04040693f, 0.16360243f, -0.00250110f, -0.36022970f, 0.20465712f, -0.49847341f, 
    0.16060199f, -0.08725882f, 0.06436946f, 0.03168019f, -0.12071224f, 0.14699534f, 0.18660913f, 0.06444135f, 
    -0.71004719f, -0.27869052f, 0.10920424f, -0.38985676f, -0.03241903f, 0.12061106f, 0.50764149f, -0.27565560f, 
    0.04906651f, -0.12739666f, -0.36348116f, 0.13617307f, -0.05024473f, 0.03639613f, -0.09324931f, -0.00512515f, 
    0.05628806f, -0.28009588f, -0.26971015f, -0.18771955f, -0.15989423f, -0.11927270f, -0.22990544f, -0.27262285f, 
    -0.69626921f, -0.60231280f, 0.09410752f, -0.06540634f, -0.04893530f, 0.04239433f, 0.03316923f, 0.10878651f, 
    -0.09582900f, 0.19678703f, 0.14976351f, 0.02208018f, -0.22502077f, -0.38828969f, -0.08267797f, 0.07816035f, 
    -0.11786297f, -0.15431355f, -0.05523690f, -0.08139323f, 0.08133067f, 0.10412598f, -0.03423421f, -0.03987442f, 
    -0.10909951f, 0.41389886f, -0.27589464f, -0.25971761f, -0.15369476f, 0.24368338f, -0.40310532f, 0.07688168f, 
    -0.05259912f, 0.03034905f, -0.04619762f, -0.00989264f, -0.66271502f, 0.13456149f, -0.60871506f, 0.23675932f, 
    0.14436682f, -0.09128044f, 0.37047604f, -0.18840837f, -0.00618995f, -0.07399045f, 0.37532452f, 0.15069623f, 
    -0.02900616f, 0.14044821f, -0.07019765f, -0.16808748f, -0.00116767f, -0.03920682f, -0.12854207f, 0.06364213f, 
    -0.00092966f, 0.08138613f, 0.16091852f, 0.06828206f, 0.05259474f, -0.95333111f, 0.67504537f, 0.32085761f, 
    0.17893709f, 0.04648806f, -0.11361106f, 0.09225921f, -0.11962161f, -0.19656695f, 0.03567983f, -0.00056809f, 
    -0.57908720f, 0.30570075f, 0.02723057f, 0.18620387f, 0.15131429f, -0.04465043f, 0.05336782f, 0.04389323f, 
    -0.02985198f, -0.12359002f, -0.03618999f, 0.21116734f, 0.08814447f, 0.05447206f, -0.08854692f, -0.28310722f, 
    0.08969064f, -0.13410318f, -0.18555264f, -0.02250184f, 0.02567829f, -0.00377792f, 0.07153176f, -0.00194248f, 
    0.32090673f, 0.23700421f, 0.12804902f, 0.01052241f, 0.02917300f, 0.03894188f, -0.11129780f, 0.22303613f, 
    -0.13328588f, -0.11169246f, 0.22544710f, -0.13245626f, 0.77917641f, 0.03846287f, 0.73588806f, -0.15719216f, 
    -0.00563302f, 0.03744227f, -0.22088358f, 0.13154311f, -0.03895657f, 0.05404316f, -0.03548683f, -0.01572278f, 
    -0.37248269f, -0.48347601f, 0.37420815f, -0.36245921f, -0.20450401f, 0.08379114f, -0.28195593f, 0.03799158f, 
    -0.00044156f, 0.02151316f, 0.04066216f, -0.08023006f, -0.20984204f, 0.00354841f, -0.01747178f, 0.19647519f, 
    -0.50733697f, -0.20159508f, 0.03315505f, -0.15586096f, -0.06747574f, -0.05366352f, -0.14754122f, 0.01953098f, 
    0.06622969f, 0.23822936f, -0.15602207f, 0.24984059f, -0.06801812f, 0.03595975f, -0.23037195f, -0.02625030f, 
    -0.04759496f, 0.18640235f, -0.15935509f, -0.16304673f, -0.11281184f, 0.01501037f, 0.35081685f, 0.35716766f, 
    -0.03963207f, -0.04643048f, 0.08863841f, 0.12593229f, -0.25705001f, 0.14538521f, -0.01056769f, -0.04348155f, 
    0.02588077f, 0.08573335f, -0.26643091f, 0.32009023f, 0.09348629f, -0.05701348f, -0.16192630f, 0.12403605f, 
    0.10551254f, 0.00882497f, 0.29147851f, -0.17498179f, 0.32645267f, -0.44307381f, 0.50379634f, -0.24572283f, 
    0.02825785f, -0.01941542f, -0.09189786f, 0.22260633f, 0.00343620f, -0.32075554f, -0.08446205f, 0.35235110f, 
    -0.67306560f, 0.22870052f, -0.44922072f, 0.09205041f, 0.12726924f, -0.09052085f, 0.16766077f, 0.02139483f, 
    0.00374158f, -0.03154720f, -0.01462462f, -0.03689590f, 0.01525682f, 0.09298108f, -0.05864736f, 0.11674146f, 
    0.09150790f, -0.01631870f, -0.05234860f, -0.03809279f, 0.08498707f, 0.23252568f, 0.08951048f, 0.08815149f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18772133f, 0.12965351f, 0.17828470f, -0.11213198f, -0.11009368f, 0.08005083f, 0.05147612f, -0.23486163f, 
    0.15205070f, -0.00601539f, 0.02094600f, 0.00114987f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
