#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.87500697f, -0.56101668f, -0.36398447f, -0.01676142f, -0.48482525f, 0.16543920f, 0.23954782f, -0.29124194f, 
    0.01000470f, -0.79365855f, -0.36707002f, -0.30088729f, 0.32563934f, 0.72820824f, 0.15605682f, 0.52500492f, 
    0.18105736f, 0.11087500f, -1.05675888f, 0.26625028f, 0.54900062f, 0.28314191f, -0.25369531f, 0.35732529f, 
    0.12749405f, 0.05228655f, 0.16701865f, 0.96904337f, 0.42761353f, 0.67673868f, 0.47369653f, 0.34123120f, 
    0.26180425f, -0.30680105f, 0.11118183f, 0.11525069f, -0.21478203f, 0.25879887f, -0.36864790f, 0.47919843f, 
    -0.24328281f, -0.54506987f, -0.39036635f, -0.44325849f, -0.45976168f, -0.11842055f, -0.20302062f, -0.40218362f, 
    0.30611667f, -0.51441759f, 0.54189229f, -0.35834524f, -0.05862606f, -0.35628492f, 0.44475394f, 0.77727109f, 
    0.56694484f, -0.39722651f, -0.64891124f, 0.07815052f, -0.06647109f, -0.00518048f, -0.06286991f, -0.01701527f, 
    0.16090909f, 0.12171756f, -0.84228867f, -0.77597576f, -0.12057800f, -0.18292098f, 0.12774293f, -0.16592175f, 
    0.17139697f, 0.45561722f, 0.28415722f, 0.25835958f, 0.35825345f, 0.61559391f, -0.18395306f, -0.48376268f, 
    0.00450478f, 0.64293379f, 0.50607044f, 0.07099686f, -0.42800501f, 0.39978975f, -0.08845863f, 0.37292275f, 
    0.69797754f, 0.01809989f, 0.40189418f, -0.59920794f, 0.17315069f, -0.69327396f, -0.28245738f, -0.54928684f, 
    0.19579656f, 0.49408174f, 0.26116803f, -0.40406466f, -0.57049447f, -0.60184914f, 0.55776936f, 0.47457340f, 
    -0.34186548f, -0.33505353f, 0.27619419f, -0.12800817f, -0.73428434f, -0.21425736f, -0.02079935f, 0.47086826f, 
    0.81713510f, 0.44468242f, -0.29571828f, -0.49802107f, 0.02408613f, 0.61838758f, 0.48162037f, 0.51813728f, 
    -0.51334041f, 0.18590552f, -0.34595773f, 0.28131157f, -0.18247862f, 0.32690325f, 0.76317811f, 0.75853652f, 
    -0.18984152f, -0.20972897f, 0.38624978f, -0.31563270f, -0.20368214f, 0.01987936f, 0.03605384f, 0.56145030f, 
    0.65785134f, -0.78621507f, 0.32877633f, -0.08512097f, -0.04514671f, 0.02178643f, -0.01389190f, -0.00387801f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09038960f, -0.07234123f, 0.06471662f, -0.01554842f, 0.12147359f, -0.37958658f, -0.02577464f, 0.23561302f, 
    -0.10701489f, 0.06241427f, 0.11278047f, -0.17290673f, 0.14008525f, 0.16543627f, -0.28144911f, -0.07982836f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01962782f, 0.04953501f, -0.01908915f, -0.05797928f, 0.02639321f, 0.00277947f, -0.03876475f, -0.05441006f, 
    0.00979953f, -0.03450441f, 0.00126570f, -0.04099833f, 0.08799697f, -0.06068930f, -0.07719073f, -0.07389307f, 
    -0.09840677f, 0.01406565f, -0.05577070f, -0.07381377f, -0.05064140f, 0.06478063f, -0.08865978f, 0.04662577f, 
    -0.08626559f, -0.06058678f, -0.08433572f, 0.02162224f, -0.02236132f, -0.11937183f, 0.03602157f, 0.00990582f, 
    -0.03040382f, 0.01850906f, -0.10701125f, -0.08631063f, -0.05972088f, 0.02591839f, -0.01646846f, 0.04195323f, 
    0.02624072f, -0.08647323f, 0.01566322f, -0.07942797f, -0.00644691f, 0.00025894f, 0.00116769f, -0.02527653f, 
    -0.02388495f, -0.05254341f, -0.01347109f, -0.08066675f, -0.07478023f, -0.07936957f, -0.08904381f, -0.01667457f, 
    0.03719373f, -0.01276117f, 0.04212327f, -0.02070164f, -0.11554442f, -0.12045056f, -0.03227696f, -0.01120669f, 
    -0.05090610f, -0.08173271f, 0.02151965f, -0.00320530f, 0.01267931f, 0.00423408f, -0.05940815f, 0.03703237f, 
    0.02986632f, -0.02339551f, -0.00469154f, -0.05706022f, -0.04689661f, -0.06091771f, 0.01920447f, -0.07861858f, 
    -0.08777770f, -0.07600855f, -0.07303937f, -0.05844332f, -0.09776781f, -0.08958467f, -0.10231597f, -0.05158282f, 
    -0.13248470f, -0.08097964f, 0.03614122f, -0.06937414f, -0.06193033f, -0.08202577f, -0.00323645f, -0.01428200f, 
    -0.10193633f, 0.03241063f, 0.04342818f, 0.00385899f, -0.00014080f, -0.00417454f, -0.07552019f, -0.03245847f, 
    -0.03718522f, -0.09045081f, -0.06854006f, -0.00878562f, 0.00435123f, -0.03228873f, 0.02123984f, 0.07214861f, 
    -0.01960135f, -0.07767632f, -0.00482369f, -0.03483882f, -0.04506210f, 0.05218040f, -0.02195612f, -0.04928814f, 
    -0.02144691f, -0.03522908f, 0.03688888f, -0.03526082f, -0.01283887f, -0.06354002f, 0.00310036f, -0.06186627f, 
    -0.08159453f, 0.01952616f, 0.01520661f, -0.00767151f, -0.02433667f, 0.01813027f, 0.02164134f, -0.01141207f, 
    -0.05543048f, -0.10726830f, -0.04465208f, 0.04110086f, -0.07524001f, -0.07916940f, 0.04742708f, 0.01663879f, 
    0.35529664f, 0.30416140f, -0.10561313f, -0.04429286f, -0.05958789f, -0.03824171f, 0.03431204f, 0.17108865f, 
    0.05997992f, -0.26713479f, -0.08378997f, 0.10051522f, -0.16742644f, -0.09456415f, -0.06474414f, 0.21460421f, 
    -0.01227257f, -0.19648841f, -0.41651946f, -0.00016528f, 0.12198137f, 0.14406651f, 0.17779593f, -0.11746706f, 
    -0.04749446f, 0.09185047f, 0.10255088f, 0.04257822f, -0.07727922f, 0.05706842f, 0.09745617f, 0.01826081f, 
    -0.02594506f, 0.06837577f, 0.14309964f, -0.00854954f, -0.32781166f, 0.02605435f, 0.15748005f, 0.03048612f, 
    0.25967559f, -0.03753793f, -0.23845126f, 0.11804815f, -0.07010550f, 0.08201470f, 0.34283987f, -0.08459559f, 
    -0.11500041f, 0.07283566f, -0.12838332f, -0.09747706f, -0.24763027f, -0.18539038f, 0.69787109f, 0.01836411f, 
    -0.14608949f, 0.10721545f, -0.07425974f, 0.14275034f, 0.14765841f, 0.01808040f, 0.01610565f, 0.09612616f, 
    -0.00435111f, -0.16192287f, -0.02605173f, -0.06365090f, 0.09060292f, 0.05884222f, -0.19364747f, -0.12245921f, 
    0.15507564f, 0.06537193f, 0.27295387f, -0.30289966f, -0.01952717f, -0.12143004f, 0.05826131f, 0.12368704f, 
    0.04541859f, 0.43021730f, -0.09037735f, 0.22465518f, -0.01600584f, -0.14423911f, -0.04755456f, -0.02525537f, 
    -0.01950876f, 0.02800299f, -0.05741758f, -0.11077584f, -0.07969796f, -0.02866071f, -0.13691516f, 0.12234706f, 
    0.12841570f, 0.04658332f, -0.13440065f, -0.10166240f, -0.01662030f, -0.44412997f, -0.01791454f, -0.06635507f, 
    -0.02215695f, -0.14984010f, -0.22009155f, 0.01611477f, -0.77389902f, -0.11833006f, -0.16918078f, -0.00615371f, 
    0.24755189f, -0.15147516f, -0.13610409f, 0.03841176f, 0.01664860f, 0.49098796f, 0.28965083f, 0.03513222f, 
    0.02706709f, 0.09954865f, 0.09211900f, 0.02671928f, -0.00707473f, 0.16105317f, 0.34826714f, -0.07126335f, 
    0.05005154f, -0.07747524f, 0.03023937f, 0.07840076f, 0.03272949f, -0.12235463f, 0.00871567f, 0.21350564f, 
    -0.24802646f, -0.06235436f, 0.23245303f, -0.11503773f, 0.01157076f, 0.06720618f, 0.17336529f, 0.01021341f, 
    0.00743086f, 0.00276242f, -0.03004817f, 0.01904411f, -0.09163459f, -0.08470705f, 0.05190928f, -0.01307049f, 
    0.05827599f, 0.01613028f, -0.01915389f, -0.07620735f, -0.05372083f, 0.05547640f, 0.00123475f, 0.02759908f, 
    0.03313180f, 0.05916511f, -0.04917023f, -0.06648013f, 0.01925492f, 0.01785590f, 0.03324869f, -0.07635496f, 
    -0.05121205f, -0.10111592f, -0.09208494f, -0.11494093f, 0.04302980f, 0.01915861f, 0.02240142f, -0.01468203f, 
    -0.05074606f, -0.03524518f, -0.02732177f, -0.07020027f, 0.04346691f, -0.02874448f, -0.08887229f, -0.08434900f, 
    0.03287283f, -0.03146432f, 0.03596912f, 0.03667121f, -0.07960787f, 0.02430240f, 0.03406134f, 0.02125789f, 
    -0.01962310f, 0.05092181f, -0.02170108f, -0.05189457f, -0.00235163f, 0.04162123f, -0.03215438f, -0.01041768f, 
    -0.07207002f, 0.02887284f, -0.01720624f, -0.09513812f, -0.05186279f, 0.04932809f, -0.04744892f, 0.04761818f, 
    0.05329840f, 0.02915397f, -0.02546910f, -0.04554390f, 0.02656172f, -0.06974807f, 0.00643090f, 0.03377241f, 
    -0.03523665f, -0.04356833f, 0.02921024f, -0.09485102f, -0.01219041f, 0.04729412f, 0.02978734f, 0.03447629f, 
    0.03809088f, 0.02928185f, -0.00651687f, 0.01198805f, 0.00645747f, 0.03806372f, 0.02781253f, 0.01644583f, 
    0.02770504f, -0.01067006f, -0.00764857f, 0.01718624f, -0.01094293f, 0.01498851f, -0.02319242f, -0.08149116f, 
    -0.07863596f, -0.04848075f, -0.10778712f, -0.08944812f, -0.01038601f, -0.02024723f, -0.01674492f, -0.03826502f, 
    0.00783417f, -0.00990730f, 0.03429464f, 0.06179029f, 0.04774121f, -0.05162490f, 0.00264855f, 0.02298025f, 
    -0.02949147f, 0.00450784f, -0.07374994f, 0.05436579f, -0.04928208f, 0.05374733f, -0.04338868f, -0.06290823f, 
    0.02744501f, 0.03432843f, 0.00808854f, -0.07351789f, -0.07414563f, 0.05462713f, 0.04711330f, 0.00269054f, 
    -0.01268496f, 0.00148729f, -0.01882137f, -0.06125198f, -0.02717852f, 0.04305131f, -0.06349352f, 0.00451310f, 
    -0.10173832f, -0.09234924f, -0.06475319f, 0.05387369f, 0.00404688f, -0.03305238f, -0.00615247f, 0.02833169f, 
    -0.32704729f, 0.24745506f, -0.02950369f, 0.03612072f, -0.13934048f, 0.02190132f, 0.07546396f, 0.16378112f, 
    -0.06894714f, 0.08526862f, -0.01317925f, -0.19221942f, -0.01666002f, 0.11729855f, 0.04637090f, -0.09238982f, 
    -0.09041893f, -0.07284054f, -0.10525686f, -0.00364208f, 0.08306671f, 0.03588585f, 0.26217425f, -0.09600776f, 
    0.03382136f, 0.04641560f, 0.02661289f, 0.23999241f, 0.13538425f, 0.06000736f, -0.15310547f, -0.04642575f, 
    -0.20187980f, 0.09729792f, 0.23658802f, 0.03016386f, -0.24874477f, -0.16592507f, 0.04421635f, 0.06287152f, 
    -0.00004372f, -0.09356017f, 0.16887054f, 0.10747059f, -0.05064670f, -0.00421044f, 0.10198442f, -0.16773222f, 
    0.27682745f, 0.08168904f, 0.01746343f, -0.11058455f, -0.28676921f, -0.01923359f, -0.04964236f, 0.08935397f, 
    0.01510689f, -0.07910585f, -0.41491142f, 0.01723099f, -0.06430769f, 0.04059517f, 0.14946182f, -0.27191663f, 
    -0.12809888f, -0.03314316f, 0.05860002f, 0.03559871f, 0.24105136f, 0.03710524f, 0.31070822f, 0.05745891f, 
    0.23710348f, 0.25240287f, 0.03077640f, -0.17719033f, -0.16896442f, -0.41649401f, 0.34657437f, 0.02315847f, 
    0.03114744f, 0.27185246f, 0.25961506f, 0.06980778f, -0.10324465f, -0.22326237f, -0.03840138f, 0.02474264f, 
    0.07466595f, 0.24918857f, 0.01811623f, -0.20838203f, 0.10629351f, 0.02826359f, 0.31077051f, 0.10834153f, 
    -0.08731571f, -0.12463834f, 0.07282863f, -0.13484618f, -0.37143090f, -0.39114538f, 0.02304965f, 0.04235178f, 
    -0.08595637f, -0.01858459f, -0.02768413f, -0.04878371f, 0.21173891f, 0.35000709f, -0.14125590f, 0.01077625f, 
    -0.08190474f, -0.08437023f, 0.17505939f, -0.08164954f, -0.10683743f, 0.20021135f, 0.01637694f, 0.20123371f, 
    -0.22855531f, -0.06568318f, 0.01962884f, -0.10882300f, -0.11574707f, 0.12586680f, 0.24467672f, 0.04080433f, 
    0.08647255f, -0.19885467f, 0.03376924f, 0.12572666f, -0.18358555f, -0.07326939f, -0.04871433f, -0.34670711f, 
    -0.27562600f, -0.03521722f, 0.10048974f, -0.04149555f, -0.01597754f, -0.12665676f, -0.01054307f, 0.07920716f, 
    -0.04004201f, -0.01258990f, -0.07570241f, -0.09576672f, 0.00485925f, -0.07354821f, 0.01618151f, -0.00859638f, 
    -0.02908995f, -0.01725177f, 0.04791563f, -0.06850987f, -0.08948684f, -0.00213678f, -0.08300659f, -0.03633758f, 
    -0.01362674f, -0.04443052f, -0.04173034f, -0.08104052f, -0.02895275f, -0.01668471f, 0.02974347f, -0.06201141f, 
    0.04235741f, 0.02232074f, 0.01656198f, -0.04733184f, -0.06749985f, -0.02986391f, -0.01011095f, 0.06467547f, 
    -0.07738198f, -0.07313068f, 0.05555487f, 0.02606620f, -0.01621426f, -0.01871617f, -0.01126100f, -0.03155918f, 
    -0.07911267f, 0.03242027f, -0.04919661f, -0.05143361f, 0.06719460f, 0.00137927f, -0.01450333f, -0.05634832f, 
    0.07133697f, -0.05151470f, -0.03854305f, 0.04201500f, 0.05146088f, 0.05221426f, 0.05963361f, 0.05566229f, 
    -0.08931854f, 0.01724927f, 0.06794979f, -0.01856587f, 0.02469878f, -0.05034620f, 0.05532372f, 0.04054995f, 
    -0.08828830f, 0.03012265f, -0.08388972f, 0.06406894f, -0.03961381f, -0.00259992f, -0.04031981f, 0.05702700f, 
    0.03774171f, 0.04961341f, -0.08767294f, 0.05651062f, -0.05875364f, -0.06706125f, -0.04880382f, -0.07511669f, 
    0.06969097f, 0.05078151f, -0.04735993f, -0.05183617f, -0.08048611f, -0.00095711f, 0.05898818f, -0.05344804f, 
    -0.02590869f, -0.05800733f, -0.06383489f, -0.03781156f, 0.07215722f, -0.05747140f, -0.05244943f, 0.04109859f, 
    -0.05441277f, 0.03522240f, 0.00358176f, -0.05601775f, 0.02789491f, 0.03913240f, -0.00829739f, -0.06115918f, 
    -0.06686316f, 0.05442072f, -0.03637138f, -0.06777985f, 0.03699892f, -0.05193163f, -0.08513778f, 0.06322078f, 
    -0.08549973f, -0.03638502f, -0.03720548f, 0.02437981f, 0.02249308f, 0.06259761f, -0.05241264f, -0.00024776f, 
    -0.00806719f, -0.00143105f, -0.07692986f, -0.02288004f, 0.04430096f, 0.06551611f, -0.09490185f, 0.05156527f, 
    0.06820240f, -0.04768052f, -0.06194701f, 0.00737535f, 0.04323614f, -0.00813185f, -0.08999293f, -0.02452175f, 
    0.00142320f, 0.03927622f, 0.01196211f, 0.06485569f, 0.04281217f, -0.05110489f, 0.05466411f, -0.04162392f, 
    0.03759314f, 0.01316546f, -0.08237057f, -0.07178355f, -0.08313685f, 0.06347560f, 0.01038598f, 0.00874705f, 
    0.03342623f, -0.07696549f, -0.06020134f, 0.05349339f, 0.05607489f, 0.01147214f, -0.02106502f, 0.04204887f, 
    -0.03732024f, -0.00161299f, -0.08851866f, 0.00461299f, -0.07377239f, 0.05049599f, 0.01188305f, 0.00664236f, 
    -0.08580333f, -0.00426198f, -0.07182594f, 0.06010262f, -0.00610186f, -0.06955618f, -0.00664584f, -0.05051742f, 
    0.03389900f, 0.04950301f, -0.09015096f, -0.06883695f, 0.03850823f, -0.02624025f, -0.08801897f, -0.04251033f, 
    0.01088607f, -0.04374146f, -0.04973957f, -0.03211905f, 0.05164623f, -0.03540015f, -0.06561334f, -0.03626887f, 
    0.02227478f, 0.02741234f, -0.02723542f, -0.04876249f, 0.01633337f, -0.03751438f, -0.02657554f, -0.08284743f, 
    0.04214272f, -0.00604736f, -0.03706583f, 0.06694529f, -0.04746736f, -0.04978277f, -0.05842052f, 0.04009216f, 
    -0.02308675f, -0.03629846f, -0.03453439f, 0.01447397f, 0.06420260f, -0.08759586f, -0.00545898f, -0.09102646f, 
    0.03190969f, 0.00313402f, 0.06644285f, -0.05191043f, -0.07495374f, -0.00476102f, 0.02364295f, -0.08383553f, 
    -0.01307497f, -0.03552084f, -0.07584104f, -0.01468824f, 0.05075745f, -0.00163987f, -0.00000711f, 0.06132843f, 
    -0.00071469f, -0.07761718f, -0.01574215f, -0.07700609f, -0.05964534f, 0.00327429f, 0.01213941f, -0.00171320f, 
    -0.02468651f, 0.00198243f, 0.03783608f, -0.02259942f, 0.03935147f, -0.05874373f, -0.05220638f, 0.06218933f, 
    0.02597376f, -0.02420846f, 0.07166894f, -0.03762162f, 0.03850414f, -0.05802457f, -0.08128379f, -0.01824138f, 
    0.03480150f, -0.00666246f, 0.07026371f, -0.05305456f, 0.02840594f, -0.00286487f, 0.02730249f, -0.02055972f, 
    -0.05589310f, 0.07151262f, -0.08088049f, 0.02612341f, 0.01058291f, 0.03778165f, -0.06160654f, -0.08506896f, 
    -0.04449907f, 0.00074081f, -0.01929575f, 0.01623593f, -0.06936689f, 0.04335491f, -0.03874642f, -0.03016057f, 
    0.05737683f, 0.00799761f, -0.05789263f, -0.09206074f, -0.01346274f, -0.08669039f, 0.04805158f, -0.05486019f, 
    -0.05417638f, 0.02286019f, -0.12566501f, -0.28701118f, 0.26224479f, 0.12408265f, -0.21949771f, 0.15481696f, 
    0.10851859f, 0.32472384f, 0.11425122f, -0.16193052f, -0.03427475f, -0.02162486f, 0.01332713f, 0.00793273f, 
    0.07423402f, 0.02585233f, -0.12954624f, -0.02205076f, -0.29051557f, -0.03827688f, 0.01575355f, 0.04997044f, 
    0.18856525f, 0.14239034f, 0.29172394f, -1.17035222f, -0.56099421f, -0.22101291f, 0.11018448f, 0.27864933f, 
    -0.04245973f, 0.06344274f, -0.10729856f, 0.10964834f, 0.08061669f, -0.08009415f, -0.21577217f, 0.08691092f, 
    0.08571903f, 0.03113833f, -0.14141347f, -0.16756603f, -0.00167072f, -0.13215159f, -0.04714090f, -0.26131746f, 
    0.02387038f, 0.01669967f, -0.31303421f, -0.07359950f, -0.13180286f, -0.13433632f, 0.13722630f, -0.09601901f, 
    -0.10839028f, 0.36575535f, -0.04858387f, -0.00652779f, -0.13504864f, -0.08941288f, -0.12468904f, 0.25939026f, 
    0.21242596f, -0.06422960f, 0.12527110f, 0.02833109f, 0.21465753f, 0.04494149f, 0.04087406f, 0.11313115f, 
    -0.24303366f, -0.25345618f, 0.02048682f, 0.10010031f, 0.11096223f, -0.12853590f, 0.13324952f, -0.16760840f, 
    -0.03872359f, -0.08697798f, -0.10426860f, -0.02962689f, -0.01691359f, -0.07446135f, 0.01792323f, -0.01794380f, 
    0.08955191f, 0.22757162f, 0.28314868f, 0.18689917f, -0.00204762f, 0.10066777f, -0.10119350f, 0.22410902f, 
    -0.02937360f, 0.00528637f, -0.05767078f, 0.17604543f, -0.15722300f, -0.09943571f, -0.38681239f, -0.12457407f, 
    0.08457023f, 0.23370130f, -0.10567544f, -0.04496543f, 0.20493028f, 0.06004396f, 0.09557246f, -0.10450660f, 
    0.01933758f, -0.04176738f, 0.09402385f, 0.10857825f, -0.00185365f, -0.17884396f, 0.06024304f, 0.07000386f, 
    0.11536467f, 0.06442420f, 0.04541590f, 0.07381251f, 0.02680706f, -0.19980390f, -0.47116610f, 0.00469918f, 
    -0.00036034f, -0.04156624f, 0.15304795f, 0.02807312f, -0.05877279f, -0.09969081f, -0.16907787f, -0.18305308f, 
    0.09210472f, -0.10976920f, -0.06250035f, -0.08509786f, -0.03187713f, -0.20297001f, -0.00390940f, 0.04961478f, 
    -0.00621778f, -0.15793255f, 0.24184592f, -0.00915452f, 0.08750458f, 0.05179320f, -0.01802475f, -0.18227428f, 
    -0.11799002f, 0.59631383f, 0.28368968f, 0.25081533f, -0.04212322f, -0.10477922f, 0.06173442f, 0.30754039f, 
    -0.05678068f, 0.20199902f, 0.44858614f, 0.08133057f, -0.27566102f, -0.01483102f, 0.05114627f, 0.06695831f, 
    -0.15534645f, -0.14299960f, 0.04599988f, -0.14286648f, 0.06067243f, 0.23423868f, -0.20087805f, 0.01219373f, 
    -0.02778463f, -0.24317957f, 0.04249426f, 0.14727443f, -0.22142611f, -0.36811924f, -0.01708097f, -0.04162276f, 
    0.10593040f, -0.03840437f, -0.03283578f, 0.00197213f, -0.00759937f, 0.01615199f, 0.19531576f, 0.29876825f, 
    -0.33590668f, 0.23127891f, 0.30256692f, 0.13636957f, -0.08517421f, -0.01487971f, -0.28456515f, 0.14727938f, 
    -0.31836876f, 0.13892621f, -0.07496056f, 0.10492999f, -0.01495462f, -0.03572912f, 0.00335926f, -0.25689811f, 
    -0.28877744f, -0.31496623f, -0.08308030f, -0.02953012f, -0.07957586f, 0.01256542f, 0.06282420f, -0.02774517f, 
    0.06977357f, 0.27059269f, -0.01753074f, 0.27049232f, 0.09807891f, 0.23134841f, 0.06642258f, 0.04999070f, 
    0.07530839f, -0.14333861f, -0.04407416f, 0.05504136f, 0.10965176f, -0.16507342f, 0.06057751f, -0.05493681f, 
    -0.10520899f, -0.10002009f, 0.05662698f, -0.02530164f, -0.14776267f, 0.05582139f, -0.09043550f, -0.02502422f, 
    0.00002814f, -0.06575633f, -0.20855387f, 0.12856200f, -0.08483372f, 0.16243042f, 0.03884804f, -0.11839257f, 
    -0.13950729f, 0.09245287f, 0.14644869f, 0.02088350f, 0.27147222f, 0.26466379f, 0.22983852f, -0.02811676f, 
    0.10089025f, -0.04269164f, 0.01415567f, 0.12531319f, 0.15417238f, -0.10639974f, -0.00583045f, -0.14187340f, 
    -0.15372325f, 0.01829462f, 0.04705470f, -0.04773253f, 0.00117234f, -0.16392563f, 0.33660242f, -0.24380809f, 
    -0.00266232f, 0.05758164f, -0.07831674f, 0.12742716f, 0.00918461f, -0.07770419f, -0.12864433f, 0.09691694f, 
    -0.39025563f, -0.21374486f, -0.20968428f, -0.01426185f, -0.06482043f, -0.03720754f, -0.09217484f, 0.11977732f, 
    -0.40204117f, -0.15231319f, -0.21052976f, 0.12856576f, 0.05435620f, 0.02979372f, -0.01034779f, 0.09370772f, 
    -0.02644516f, -0.46248677f, -0.31365260f, -0.09662872f, 0.16635436f, 0.06024471f, 0.00587109f, -0.00410413f, 
    -0.15037556f, -0.04248707f, -0.29169336f, -0.46159810f, -0.08468152f, -0.13600983f, -0.04089510f, 0.04895525f, 
    -0.02153827f, -0.02801277f, 0.11289638f, -0.27722844f, 0.18340114f, 0.24070555f, 0.07913116f, 0.24589303f, 
    0.02490554f, 0.10830443f, -0.03042210f, 0.04698377f, -0.20529158f, 0.05605608f, 0.18129835f, -0.13114280f, 
    0.04054309f, -0.07566807f, 0.16498797f, 0.00627273f, 0.21198212f, -0.38997295f, 0.03381277f, -0.16781352f, 
    -0.13320391f, 0.17863852f, 0.03253502f, -0.27047259f, -0.24802807f, -0.01539267f, 0.10751461f, -0.13853380f, 
    0.12239277f, -0.02318674f, 0.07877463f, -0.08818691f, -0.10829727f, 0.09157947f, 0.15498622f, -0.16044736f, 
    -0.00870661f, 0.17393705f, 0.10845640f, 0.20828319f, 0.07332999f, 0.08993878f, 0.09402832f, 0.17549853f, 
    0.17560984f, -0.00333125f, 0.11292899f, 0.02795325f, 0.06735518f, 0.06762504f, 0.07289159f, 0.06563152f, 
    -0.03007389f, -0.03062786f, 0.16951610f, 0.12576240f, -0.14708008f, -0.10665503f, 0.10384358f, 0.05732203f, 
    0.13784002f, -0.02038623f, 0.18124668f, 0.10059749f, -0.23653893f, -0.05790566f, -0.00312798f, 0.03141735f, 
    -0.06546778f, -0.14404297f, 0.09747498f, -0.36086375f, 0.16951515f, -0.20310199f, 0.36957744f, 0.01647556f, 
    -0.15592532f, 0.12977026f, -0.12636237f, -0.09955452f, 0.00712016f, -0.32814667f, -0.14071791f, 0.09180346f, 
    0.12504815f, 0.06317899f, -0.00997224f, 0.05955256f, -0.05576101f, 0.18171433f, 0.17910455f, 0.24367546f, 
    -0.07816926f, 0.10764587f, 0.04611765f, 0.12909763f, -0.02090607f, 0.01631599f, 0.16840662f, 0.01851060f, 
    0.13932873f, 0.10750885f, -0.19892420f, 0.16038816f, -0.14057055f, 0.13567640f, -0.10643514f, -0.10462438f, 
    -0.06588783f, 0.31707612f, -0.05264429f, -0.21458402f, -0.14783527f, -0.06581410f, 0.10651122f, 0.10887170f, 
    0.49179411f, 0.01314638f, 0.23065425f, -0.02389454f, 0.29428002f, 0.17979035f, 0.06291185f, -0.17443432f, 
    -0.04757492f, 0.12860592f, 0.13585891f, 0.17227025f, -0.00952206f, -0.03299309f, 0.10766739f, 0.05333797f, 
    -0.06247965f, -0.01532151f, -0.05475290f, 0.16426629f, -0.03692763f, 0.05174984f, -0.03100794f, -0.09813917f, 
    0.07138804f, -0.02165995f, 0.11711994f, -0.22540593f, 0.00690444f, 0.06800189f, 0.09534124f, -0.12409939f, 
    -0.05475011f, 0.15515716f, 0.08989890f, 0.16030335f, 0.13987587f, 0.11490159f, 0.12601596f, -0.13230397f, 
    0.21558006f, 0.23507868f, 0.05217439f, -0.08627582f, 0.05491901f, 0.07992552f, 0.06091625f, -0.10231912f, 
    0.29244238f, 0.02252949f, -0.05466136f, -0.01868312f, -0.15927225f, 0.05237512f, -0.33728036f, 0.11611199f, 
    -0.01946834f, -0.03721593f, 0.12203670f, -0.25713474f, -0.06739713f, -0.11111774f, -0.02738490f, 0.06029616f, 
    -0.09722743f, -0.03566463f, -0.14498024f, -0.02197613f, 0.12169068f, -0.25856760f, 0.11209653f, 0.13848661f, 
    0.10584407f, 0.00233357f, 0.08518775f, -0.02854336f, 0.16678014f, 0.10532442f, 0.05648878f, 0.16472112f, 
    0.11098734f, -0.21707763f, -0.04240844f, -0.09959808f, 0.09735880f, 0.05583914f, -0.16015077f, 0.11181151f, 
    -0.04072275f, 0.08343864f, -0.41621125f, 0.19666366f, 0.17093560f, -0.15874127f, 0.04894840f, 0.04289868f, 
    -0.30652931f, -0.07679390f, 0.02576643f, 0.33573765f, 0.23270828f, 0.06317282f, -0.06954678f, -0.05508530f, 
    0.04598788f, 0.34326860f, 0.19400030f, -0.05513941f, 0.16339424f, 0.13706230f, -0.02079497f, 0.11102141f, 
    -0.02380176f, 0.08675751f, -0.00777774f, 0.04923349f, 0.04402953f, -0.07496983f, -0.09111450f, -0.09977784f, 
    -0.05990848f, 0.04708251f, -0.11181442f, -0.00000006f, 0.05843369f, 0.03324386f, -0.34220126f, -0.01290922f, 
    0.07435217f, -0.06135964f, -0.00718687f, 0.07697558f, -0.09953538f, 0.17070512f, -0.03625891f, -0.66257650f, 
    -0.01749933f, -0.25240853f, -0.20311759f, -0.03079916f, 0.07750637f, 0.05790178f, -0.15861274f, 0.00394175f, 
    0.06033577f, 0.04497327f, -0.06923942f, -0.05112989f, 0.17203294f, -0.07208721f, -0.29395774f, 0.12668359f, 
    0.01604504f, 0.18956296f, 0.17606917f, -0.07686135f, -0.04005982f, 0.00261799f, 0.01329097f, 0.12166823f, 
    0.18059283f, 0.03685331f, -0.07275496f, -0.04367108f, 0.06945594f, 0.00325753f, 0.02136890f, -0.05971097f, 
    0.07726031f, -0.11488901f, -0.16714473f, -0.27381015f, 0.17252816f, -0.02192667f, -0.04677913f, 0.16016555f, 
    0.03810956f, -0.11181581f, -0.13224624f, -0.13339144f, 0.41617420f, 0.01339330f, -0.09556028f, -0.07050622f, 
    -0.06671104f, -0.00883793f, 0.12277902f, 0.06405338f, 0.05710184f, 0.40604642f, 0.06275430f, 0.03270997f, 
    -0.07588837f, 0.05300088f, 0.05055203f, 0.06416081f, -0.04528614f, 0.01505466f, -0.15443148f, -0.37223554f, 
    -0.16334563f, 0.14529708f, 0.27250060f, -0.02985623f, -0.05013787f, -0.07932262f, -0.13904765f, -0.05332449f, 
    0.08370052f, 0.04215598f, -0.03985981f, 0.08860201f, -0.01031314f, 0.17822970f, -0.18664387f, -0.20905346f, 
    -0.54462761f, -0.01160518f, -0.08820079f, 0.17657559f, -0.06697749f, 0.09705432f, 0.03547312f, 0.12162611f, 
    -0.14775093f, 0.12204890f, -0.13743426f, -0.10686147f, 0.00554937f, 0.18936075f, -0.07188285f, 0.03495219f, 
    0.04700800f, -0.00875265f, 0.06189045f, 0.14291961f, 0.18363820f, -0.15282699f, -0.22188735f, -0.10334919f, 
    -0.02801662f, 0.02028437f, 0.10410790f, 0.01207012f, 0.22975792f, 0.00732434f, -0.04464989f, -0.02799739f, 
    -0.06101769f, 0.03573653f, -0.00644820f, 0.12012550f, 0.01901163f, 0.09688012f, 0.08593476f, -0.00070553f, 
    -0.14862880f, 0.33200073f, -0.06012647f, 0.07715295f, 0.14931062f, -0.20222136f, -0.06069202f, -0.03206988f, 
    0.20297439f, 0.13830543f, -0.01766527f, -0.02099347f, 0.03984060f, 0.03646375f, 0.21283829f, -0.18570478f, 
    -0.42769137f, 0.04708014f, -0.10269711f, -0.01057015f, 0.15036638f, 0.02548018f, 0.02230513f, 0.14607339f, 
    0.10245854f, -0.07061479f, -0.19696461f, -0.03882526f, -0.05974967f, -0.15856111f, 0.35285541f, -0.01703733f, 
    -0.06387555f, 0.07435680f, -0.04071716f, 0.10067537f, 0.06083146f, -0.00379701f, -0.07778060f, -0.11682387f, 
    -0.03116006f, 0.29748258f, 0.05823069f, -0.27368641f, -0.08730596f, -0.20363778f, -0.27842781f, -0.12178688f, 
    -0.01494410f, -0.03244641f, 0.50753397f, 0.19396167f, -0.34909859f, 0.03957593f, -0.05000523f, 0.07960113f, 
    0.14304987f, 0.05105257f, -0.05372878f, -0.46878007f, 0.02056469f, 0.12506180f, 0.12781161f, -0.06128097f, 
    0.23276681f, -0.04560339f, -0.10942771f, -0.15971604f, 0.01572208f, 0.16135851f, 0.08111567f, 0.14970264f, 
    0.08960147f, -0.03965223f, 0.05445441f, -0.02076310f, 0.13508509f, -0.49099588f, 0.01471111f, -0.01522601f, 
    0.20887746f, -0.15058979f, 0.04995206f, 0.02907950f, -0.17821220f, 0.08866622f, -0.32075107f, 0.07578903f, 
    0.26403993f, -0.05771103f, 0.22840278f, -0.15782420f, 0.04211272f, 0.06492610f, -0.08996513f, -0.03613878f, 
    0.08122700f, 0.20825045f, -0.00493275f, 0.00849088f, -0.12714212f, -0.02988756f, 0.09774491f, 0.01755648f, 
    -0.07501237f, -0.11520698f, 0.12310465f, 0.04027786f, -0.02151921f, -0.03942675f, 0.06097632f, -0.01820090f, 
    -0.00027076f, -0.27215126f, 0.35647693f, 0.01413068f, -0.08542096f, 0.01254734f, 0.06511404f, -0.16631185f, 
    0.09079166f, 0.11948691f, 0.05350094f, 0.18896976f, 0.06939860f, 0.01989727f, 0.06918465f, -0.15858422f, 
    -0.07375256f, -0.06294688f, 0.11535512f, 0.12475622f, -0.22586317f, 0.23857038f, -0.18010989f, -0.19295391f, 
    -0.03847899f, -0.03676952f, -0.03288027f, 0.11219751f, 0.15971981f, -0.21641910f, -0.12913465f, 0.01249981f, 
    -0.19484344f, 0.18155898f, 0.12630121f, 0.00739129f, 0.02943012f, -0.00616096f, 0.24723196f, 0.00751334f, 
    0.20292060f, -0.10623002f, -0.02737962f, -0.07673653f, -0.05885533f, -0.07371432f, -0.18968479f, 0.30136758f, 
    -0.20807301f, -0.11923365f, -0.06199692f, 0.21262801f, 0.16520055f, 0.06071680f, 0.06944562f, 0.08539462f, 
    -0.04250547f, 0.02873259f, 0.07892042f, -0.12456895f, -0.02264294f, -0.16514315f, 0.04427144f, -0.18630177f, 
    -0.07512370f, 0.28375193f, 0.07319548f, 0.06738364f, 0.07578450f, -0.23782471f, -0.09977598f, 0.07253178f, 
    0.07352016f, 0.17231096f, 0.28551999f, 0.27406454f, -0.05818169f, -0.23646809f, -0.11090800f, -0.07582974f, 
    0.20948307f, 0.07525568f, -0.19392328f, -0.09480917f, 0.04856106f, -0.00128948f, -0.03439967f, -0.01568394f, 
    0.00242062f, 0.02753844f, 0.02411519f, -0.26377767f, 0.08547975f, -0.01806284f, 0.07379337f, 0.20478545f, 
    -0.07536813f, 0.13796537f, 0.09143282f, 0.02754573f, 0.34567040f, 0.07679906f, 0.08961131f, 0.00644551f, 
    0.06107507f, 0.05213362f, -0.13273948f, -0.19476050f, -0.02016877f, 0.26987737f, 0.00309246f, 0.22159755f, 
    0.05487898f, -0.00363003f, -0.00377620f, -0.06837441f, -0.00189047f, 0.00697056f, -0.05918843f, -0.44356248f, 
    0.14889050f, 0.02584261f, -0.11079024f, 0.08736873f, -0.03906171f, 0.00982711f, 0.08802568f, 0.17443243f, 
    -0.13136682f, 0.03802472f, -0.07470489f, -0.07319561f, -0.05480397f, 0.19129406f, -0.00388875f, 0.09807786f, 
    -0.33145830f, -0.09025764f, 0.09410427f, 0.06172300f, 0.06392221f, 0.02679276f, -0.13942839f, 0.03469860f, 
    -0.15415464f, -0.31909099f, -0.27062720f, 0.13342142f, -0.00025920f, 0.10100533f, 0.05479221f, 0.07378329f, 
    -0.17993739f, 0.09169792f, 0.09286231f, -0.20123473f, 0.13760519f, -0.20162712f, -0.02020711f, -0.03785146f, 
    0.13155925f, -0.14697352f, 0.00796797f, -0.06002995f, 0.21410447f, -0.00228382f, -0.12880698f, 0.10290038f, 
    0.03669944f, 0.08415314f, 0.02945329f, -0.07802017f, 0.16681404f, -0.06717401f, -0.08023050f, 0.03345247f, 
    0.14517833f, -0.22842710f, -0.14973062f, 0.27084592f, -0.01833943f, -0.25370169f, -0.17877553f, 0.25405443f, 
    0.21836685f, -0.01539213f, 0.11191975f, -0.06037918f, -0.17327306f, 0.07248846f, -0.20406055f, -0.13714914f, 
    -0.08018979f, 0.09904452f, 0.17046385f, 0.03096523f, 0.02096309f, -0.08992543f, 0.02619169f, 0.30848989f, 
    0.29615974f, 0.12374341f, -0.29030123f, -0.07168876f, -0.06791357f, 0.00155146f, -0.08062581f, -0.09142576f, 
    -0.29797530f, 0.04026785f, -0.04688936f, 0.40129703f, 0.18890819f, 0.01008500f, 0.14761531f, 0.00401861f, 
    -0.01022071f, 0.13913955f, 0.07673589f, 0.04832239f, 0.13070723f, 0.04742559f, 0.05684022f, -0.05587677f, 
    -0.06623101f, -0.09205163f, 0.19566040f, 0.02635230f, -0.11125972f, -0.08858381f, 0.02292582f, 0.16827030f, 
    0.01465778f, -0.04400352f, -0.11365166f, 0.07617324f, 0.11801921f, -0.00302736f, -0.13154922f, 0.15978284f, 
    0.20807855f, 0.14939693f, 0.09510454f, -0.12078205f, 0.11241969f, 0.25676551f, -0.09471617f, -0.05745301f, 
    0.00109081f, 0.05791045f, -0.13355832f, 0.13863893f, -0.14608790f, 0.41243988f, 0.01214506f, 0.14249186f, 
    -0.15589836f, 0.19199435f, -0.03034801f, -0.03861081f, -0.44910944f, 0.10452930f, 0.02543018f, -0.32258609f, 
    0.00697874f, -0.29651466f, -0.07234876f, -0.30699795f, 0.01803374f, -0.05513577f, -0.06284519f, 0.16064659f, 
    -0.22376984f, -0.12116648f, -0.02930806f, 0.02087236f, -0.01273740f, 0.06654977f, 0.10049684f, 0.01452324f, 
    -0.00570932f, -0.28785962f, -0.05026074f, 0.03017450f, -0.18366398f, 0.05251185f, 0.10945333f, 0.04857034f, 
    -0.16848406f, -0.29423228f, -0.04260074f, -0.08404639f, 0.01710759f, 0.00853567f, -0.28341043f, -0.21564266f, 
    0.04427440f, 0.09713846f, 0.13810684f, 0.13506415f, -0.22707829f, -0.29933515f, -0.19685704f, -0.12716006f, 
    -0.03483601f, 0.11423146f, -0.07914897f, -0.10260256f, 0.14405473f, 0.29715189f, 0.04698010f, -0.08957357f, 
    -0.01229446f, 0.01970278f, -0.07067253f, 0.20345436f, 0.28041947f, 0.27171591f, 0.03899574f, 0.15148903f, 
    0.06416361f, 0.23502208f, -0.04374993f, -0.02034936f, 0.20927824f, 0.06338319f, 0.04774931f, 0.03177776f, 
    -0.24637820f, -0.09488875f, 0.03791614f, -0.11123949f, 0.03198631f, -0.09804358f, -0.04989408f, 0.33700070f, 
    -0.13028781f, 0.11577170f, -0.26381913f, -0.20785759f, 0.04961470f, 0.01988731f, -0.09774670f, -0.07595196f, 
    0.33258650f, 0.36813822f, -0.12581101f, -0.01829676f, 0.03591762f, -0.05176553f, -0.06138462f, -0.02113993f, 
    0.13582499f, 0.03319807f, 0.13797155f, -0.11183646f, 0.17879823f, 0.00915653f, -0.06332964f, 0.17472579f, 
    0.04356412f, -0.07708820f, 0.01427716f, 0.24827045f, 0.04723592f, -0.11382874f, -0.05969026f, -0.29166827f, 
    0.06123542f, 0.07951251f, 0.03308820f, 0.17885487f, -0.23001237f, -0.11118771f, -0.02518683f, 0.26871863f, 
    -0.05714646f, 0.00013310f, -0.33319443f, 0.09098855f, -0.31963858f, -0.27820969f, 0.20511518f, 0.18936954f, 
    0.41113067f, -0.03170125f, -0.07161878f, -0.17964135f, 0.13251334f, 0.11591024f, 0.02182040f, -0.04935014f, 
    0.01152710f, 0.25478005f, 0.00190136f, 0.16152577f, 0.17515472f, 0.01811687f, -0.09412804f, 0.19111589f, 
    -0.22872518f, -0.17207341f, 0.18700421f, -0.17971659f, -0.07947973f, 0.02221210f, 0.42041758f, -0.16016588f, 
    -0.40537867f, 0.13815299f, -0.02417871f, -0.01334950f, 0.15653308f, 0.12279245f, 0.06138980f, -0.04655789f, 
    0.24462752f, 0.10437595f, 0.24854918f, 0.25888124f, -0.00326500f, 0.17563780f, 0.12039576f, -0.13328902f, 
    -0.50929272f, 0.05269568f, -0.20465688f, 0.18342954f, 0.09917916f, 0.32227245f, 0.04364701f, -0.06713431f, 
    -0.02388272f, -0.01976647f, 0.02413840f, -0.05537527f, -0.09338214f, 0.02309839f, -0.31270358f, 0.16822468f, 
    0.01334292f, -0.11030384f, -0.12974688f, -0.05136439f, -0.01828415f, 0.10830536f, 0.05948174f, -0.19361731f, 
    0.04366273f, 0.04783209f, -0.13472731f, -0.49827829f, -0.06178368f, 0.47300354f, -0.08418878f, -0.17941380f, 
    0.13200484f, -0.20376137f, 0.11292387f, 0.09545249f, -0.41867056f, -0.17605995f, 0.06169340f, 0.03353788f, 
    -0.04442069f, 0.09674715f, -0.02886783f, 0.12454250f, 0.02911537f, 0.28418356f, -0.09411229f, 0.12713490f, 
    0.18358958f, -0.07496126f, -0.11892151f, 0.07976106f, -0.13315047f, 0.22349969f, 0.29219505f, -0.20608422f, 
    0.00238671f, -0.05572611f, 0.15718141f, -0.03324623f, 0.26522058f, -0.02878529f, 0.03323498f, 0.18602763f, 
    0.01625274f, -0.00702158f, 0.10520665f, -0.02133054f, 0.08267916f, -0.05043189f, 0.00198096f, 0.10112724f, 
    -0.38958728f, 0.10765818f, 0.46346834f, 0.17287578f, 0.09760791f, 0.01219651f, 0.00173335f, 0.12157001f, 
    -0.00074124f, 0.06751759f, -0.08235388f, 0.31184849f, -0.30349460f, -0.20259628f, 0.12021406f, -0.10217345f, 
    -0.07634419f, -0.01559837f, 0.11352339f, -0.10286326f, 0.32556665f, 0.03779624f, -0.02683434f, -0.17874230f, 
    0.06295086f, -0.08766928f, 0.14243163f, -0.24467070f, -0.03326285f, -0.05729142f, 0.06087444f, 0.04516216f, 
    0.06975364f, -0.06500119f, 0.14563471f, 0.04010948f, -0.38990298f, -0.28774923f, -0.08804475f, 0.14357822f, 
    0.10232872f, -0.22364172f, 0.14307438f, -0.31605402f, 0.12686081f, 0.12245873f, -0.29219174f, 0.11814030f, 
    -0.16779639f, 0.05767160f, 0.00136086f, -0.01037973f, 0.17023037f, 0.14717580f, 0.07077469f, -0.11421083f, 
    0.04135855f, 0.05635624f, -0.01297277f, 0.04507544f, 0.33537087f, 0.00777936f, -0.27879634f, 0.04693124f, 
    -0.27695978f, -0.25338590f, 0.26259387f, 0.05462453f, 0.09619223f, -0.01433999f, 0.19770756f, -0.03262473f, 
    0.05019267f, 0.14741974f, -0.09537711f, -0.07346141f, -0.08153093f, 0.10632741f, 0.13064539f, 0.16585918f, 
    -0.11818270f, 0.33261546f, 0.12423382f, -0.26297203f, 0.13068846f, -0.00549373f, -0.07770561f, 0.14176252f, 
    0.01499400f, -0.31697071f, 0.30629185f, 0.15372664f, -0.41428849f, 0.08037635f, 0.09799821f, 0.16846192f, 
    0.01408997f, -0.05792207f, 0.01782316f, 0.00017898f, 0.02977383f, -0.05847769f, 0.11564358f, 0.01112045f, 
    0.11948330f, -0.11370734f, -0.24221534f, 0.12298116f, 0.06415473f, 0.09311417f, 0.14814395f, -0.38007700f, 
    0.09672495f, 0.15818395f, -0.11305698f, 0.18751121f, 0.06185741f, 0.00160481f, -0.12672789f, -0.48440787f, 
    0.16764133f, 0.06460303f, -0.01303059f, 0.22871248f, -0.09492067f, 0.15354742f, 0.31441283f, 0.00107351f, 
    -0.54808360f, 0.04081652f, 0.04152111f, 0.11218092f, -0.23984763f, 0.08873633f, -0.07598767f, -0.02039360f, 
    0.10777058f, 0.04966370f, -0.02685809f, 0.20887750f, -0.05688157f, 0.02502484f, 0.12468015f, 0.04711451f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04877933f, -0.07610008f, -0.08249603f, 0.21941867f, -0.04707341f, 0.03706580f, 0.22257324f, -0.02054008f, 
    0.02452997f, 0.05894795f, -0.07011539f, 0.15710975f, 0.02462234f, -0.00054360f, 0.26030412f, 0.10806889f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20101275f, -0.31136018f, -0.23084341f, 0.34086964f, 0.20406067f, -0.20911755f, -0.14747275f, -0.23148090f, 
    0.51856756f, 0.13361499f, -0.16570507f, 0.04721475f, -0.45072427f, -0.05311352f, -0.02996113f, 0.36387125f, 
    -0.06178424f, 0.55267888f, -0.09890267f, -0.24677534f, -0.16530941f, -0.04969103f, 0.41907668f, 0.05060095f, 
    -0.11744265f, -0.54353863f, -0.21780026f, 0.00764804f, 0.02283045f, 0.17962146f, 0.22870445f, 0.34952074f, 
    -0.11148732f, 0.39343113f, -0.12622343f, 0.32312372f, -0.01185167f, 0.17058647f, -0.31770325f, -0.29760748f, 
    0.18563303f, 0.29930592f, -0.47173992f, 0.43923151f, 0.15681121f, 0.09866802f, -0.12092826f, -0.47405192f, 
    0.11047655f, -0.07248464f, 0.09588152f, 0.38281590f, -0.09064431f, 0.19480728f, 0.01886312f, -0.35065088f, 
    0.13004653f, 0.32916725f, -0.02955851f, 0.05796271f, -0.34305060f, -0.20443577f, -0.04060612f, 0.33759540f, 
    0.08575806f, -0.17148048f, 0.05629113f, -0.14507905f, -0.15686992f, -0.03097194f, -0.13060492f, -0.10066488f, 
    -0.17888808f, 0.01666030f, -0.21405196f, -0.11648259f, -0.19391313f, -0.21232161f, -0.07755545f, 0.16138312f, 
    0.21694012f, 0.00077452f, -0.13656113f, -0.16828246f, -0.15238725f, 0.08475438f, 0.39505243f, -0.41450253f, 
    0.05422320f, 0.05658712f, 0.35714781f, 0.35266060f, 0.17488487f, 0.07783860f, 0.34223047f, -0.25816602f, 
    0.10481687f, 0.03146251f, -0.24973932f, -0.04075319f, 0.00374573f, -0.13402666f, 0.09481566f, 0.26139444f, 
    -0.30512422f, 0.26994622f, 0.46985289f, 0.72709519f, 0.04783459f, 0.45741811f, 0.05439679f, -0.08602479f, 
    0.01919135f, -0.13461854f, -0.00278681f, -0.29528505f, 0.08950043f, -0.09075562f, -0.09228487f, -0.12210618f, 
    -0.14816330f, -0.12166421f, -0.10114604f, -0.10714693f, 0.21668443f, 0.31117329f, 0.48089752f, 0.06639886f, 
    0.14422809f, -0.08927535f, -0.04786041f, 0.19320495f, -0.07816001f, -0.09853204f, -0.38211983f, -0.48640934f, 
    0.69060159f, -0.11514685f, -0.03985020f, 0.16098237f, -0.09920306f, 0.28307876f, 0.42496589f, -0.01597248f, 
    -0.10100369f, 0.26903647f, -0.05656635f, 0.17093734f, -0.19963375f, 0.07827652f, 0.31897399f, -0.19412456f, 
    -0.13451867f, -0.08108811f, -0.41317952f, -0.07422188f, -0.02291176f, -0.17772715f, 0.02744739f, 0.55145001f, 
    -0.09064261f, -0.30890712f, -0.22732809f, -0.57671785f, 0.14905450f, 0.23657796f, 0.19719741f, -0.63250959f, 
    -0.65152657f, 0.14762551f, 0.32681027f, 0.00765053f, 0.23328020f, 0.23565274f, 0.02728875f, 0.24239458f, 
    -0.15469250f, 0.12216762f, 0.14472409f, -0.33366224f, 0.09412017f, 0.08624675f, 0.48056614f, -0.25147101f, 
    0.50217229f, -0.10861775f, -0.19817597f, 0.53028131f, -0.28928158f, -0.01757209f, 0.24890913f, 0.11295146f, 
    -0.08023503f, -0.04209954f, -0.03178203f, -0.13086201f, 0.17098907f, 0.14782155f, -0.12511778f, -0.15230066f, 
    -0.09298315f, -0.00777042f, 0.11055873f, -0.01928995f, -0.05824112f, -0.12004486f, -0.15478508f, 0.04010773f, 
    -0.12202828f, -0.22491212f, 0.17916812f, 0.42387614f, 0.15862425f, 0.16925932f, 0.81002069f, -0.46927035f, 
    0.58550763f, -0.05526620f, -0.04238913f, -0.17436181f, -0.16007578f, 0.10122009f, -0.02089885f, 0.03630852f, 
    0.24014321f, 0.20126496f, 0.11681315f, -0.11166647f, 0.19363448f, 0.05392458f, 0.10854629f, 0.11436350f, 
    -0.37954646f, -0.14096485f, -0.02772231f, 0.12243490f, 0.23495176f, -0.23055820f, 0.30140057f, -0.23668168f, 
    -0.14080261f, 0.16990919f, -0.19066904f, 0.49099308f, 0.09288594f, 0.22349936f, -0.37708533f, -0.05033231f, 
    -0.23770383f, -0.07708132f, -0.27684388f, 0.09327425f, -0.38756952f, 0.37505400f, 0.27580068f, 0.04946434f, 
    0.24287245f, -0.12875800f, -0.14389345f, -0.05469581f, -0.17965803f, 0.11220482f, -0.31096381f, 0.17020634f, 
    -0.32563737f, -0.10404661f, 0.19092479f, -0.14813741f, -0.23303196f, 0.05864795f, -0.23117425f, 0.28503636f, 
    -0.03967762f, -0.21326214f, -0.15775694f, -0.00058552f, 0.05507816f, 0.07198073f, -0.23482689f, 0.05902963f, 
    -0.50203019f, -0.24694005f, 0.24511696f, -0.27615872f, -0.01799458f, 0.71308994f, 0.26493290f, 0.35843846f, 
    0.21791215f, -0.04576544f, -0.18670484f, 0.11838023f, 0.10425619f, -0.23148060f, 0.61059564f, 0.15600087f, 
    -0.24406505f, 0.48773456f, 0.23160173f, -0.22546983f, 0.35687286f, -0.37986326f, 0.03158446f, 0.07069792f, 
    0.07949071f, -0.22192289f, -0.08912709f, -0.45107672f, -0.21119843f, 0.00307570f, -0.15519811f, 0.10843348f, 
    -0.21062240f, 0.34548488f, 0.27103466f, -0.14821446f, 0.20393483f, 0.50907773f, 0.13533814f, -0.07109882f, 
    0.14447066f, -0.22613420f, -0.20752560f, 0.02342924f, 0.14405210f, -0.13135956f, -0.16056259f, 0.04101947f, 
    0.08610551f, 0.36254519f, 0.39988297f, -0.27361879f, 0.11519454f, 0.67975920f, -0.41039982f, -0.25716844f, 
    -0.02301390f, 0.42085382f, 0.13457046f, -0.51660317f, 0.23526850f, -0.19553404f, 0.07037596f, -0.55226946f, 
    0.42292136f, -0.09922162f, 0.46980774f, 0.31724328f, -0.08509565f, 0.30525619f, -0.01341472f, -0.02545187f, 
    -0.00675933f, 0.27157134f, -0.29831371f, -0.04325553f, -0.21031860f, 0.24317661f, 0.33433107f, 0.39788082f, 
    -0.27225479f, -0.16620877f, 0.52685654f, -0.20589732f, 0.36773878f, -0.19365613f, 0.09911449f, 0.14503685f, 
    0.05332047f, 0.20424227f, 0.13262396f, 0.07494257f, 0.10011288f, 0.16615801f, 0.68213063f, -0.21287550f, 
    0.01842676f, 0.22705598f, -0.41469058f, -0.18215226f, 0.42844254f, -0.06932037f, -0.32179442f, 0.14929980f, 
    0.12711981f, -0.16305292f, -0.07799260f, 0.20615576f, -0.24756068f, 0.09884551f, -0.36785316f, 0.01925419f, 
    0.25492397f, 0.16427295f, -0.04275889f, -0.44842356f, -0.01762092f, -0.20683321f, 0.26081493f, 0.09196228f, 
    -0.29294583f, 0.27235571f, -0.22482710f, 0.37186521f, 0.18065923f, -0.12168241f, 0.55751717f, -0.16196847f, 
    -0.70985371f, 0.45314708f, -0.30420250f, -0.41201726f, -0.10517013f, 0.27049702f, 0.00941418f, 0.32770175f, 
    0.00108055f, 0.45422411f, 0.08210176f, -0.11780372f, 0.07799459f, 0.03604886f, -0.16715319f, -0.12017254f, 
    -0.17274277f, -0.11928548f, -0.06904167f, -0.41028783f, 0.00314254f, -0.15313591f, 0.25223780f, 0.43063122f, 
    0.08977051f, 0.48963532f, -0.16284214f, -0.16891482f, 0.05549061f, -0.10677952f, 0.42622986f, 0.35735926f, 
    -0.15560073f, 0.25500077f, -0.39934018f, 0.28004175f, -0.47759503f, -0.21047799f, 0.24841315f, -0.00959903f, 
    0.09051150f, 0.05471679f, 0.09693428f, 0.34867281f, -0.01946626f, 0.23649861f, 0.05868901f, 0.15340567f, 
    -0.27910703f, -0.09366068f, -0.10033228f, 0.33162758f, -0.43266022f, 0.03767869f, 0.00208292f, 0.33538765f, 
    -0.00788826f, -0.64171839f, 0.22342233f, -0.00867751f, 0.14787653f, -0.17330948f, 0.42037371f, 0.21663179f, 
    -0.43391973f, 0.30565473f, 0.12272422f, 0.07938836f, -0.51354980f, 0.13057107f, 0.22773938f, 0.22123559f, 
    0.08346489f, 0.28941664f, -0.16445741f, 0.26010963f, -0.20612298f, 0.03337641f, 0.06540744f, 0.35724759f, 
    0.14236821f, 0.29826763f, -0.17812736f, 0.17529881f, -0.51853192f, -0.18522806f, -0.20721059f, 0.38288254f, 
    0.04686429f, -0.33607346f, -0.10940541f, -0.21661279f, -0.13414831f, -0.21579485f, 0.00102613f, 0.35630164f, 
    0.00884082f, -0.45460162f, 0.18540348f, 0.57154554f, -0.38817224f, 0.44344500f, 0.34104499f, 0.12818122f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.54817742f, 0.06099600f, 0.07973442f, 0.57165271f, -0.19587970f, 0.44375932f, 0.03073180f, 0.65956622f, 
    0.27805561f, 0.09785885f, 0.15320113f, 0.19217342f, -0.15243568f, 0.15653506f, 0.21866520f, 0.23298073f, 
    0.12379562f, 0.13798833f, 0.29933739f, -0.09058104f, -0.10421754f, -0.00850510f, -0.23897369f, 0.18421270f, 
    0.04047602f, 0.37246847f, 0.09545574f, 0.41205385f, 0.04707057f, 0.45787248f, 0.04078215f, 0.16672537f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.68246949f, 0.60167605f, -0.57430232f, -0.52487904f, 0.04363931f, 0.13814273f, 0.36951503f, 0.05690686f, 
    -0.57057649f, -0.19012912f, 1.25438321f, -0.20598052f, -0.13697357f, -0.84905589f, 0.66806382f, -0.38288513f, 
    -0.37301561f, 0.29701936f, 0.02865295f, 0.39915732f, 0.15753159f, 0.12054759f, 0.47947726f, -0.06482468f, 
    -0.19880147f, -0.03285145f, 0.45412552f, 0.22336587f, -0.16911626f, -0.11727359f, -0.05913798f, 0.21576977f, 
    0.03663412f, -0.04522056f, 0.27820161f, -0.00237257f, -0.15205342f, -0.02641481f, -0.18560290f, 0.29727414f, 
    -0.10690440f, 0.27284375f, 0.30650410f, -0.02800626f, 0.13792020f, -0.15497260f, 0.62496042f, -0.16124344f, 
    -0.24973251f, -0.06960788f, 0.28079790f, 0.03342313f, -0.36405596f, -0.38607475f, 0.21725971f, 0.29203036f, 
    0.20615192f, 0.14357644f, 0.36681351f, 0.36428958f, 0.30961016f, 0.33107656f, 0.11959712f, -0.36247253f, 
    0.01822096f, -0.07341132f, -0.36625278f, 0.09164496f, -0.09687523f, -0.04447859f, -0.09286521f, 0.42284834f, 
    -0.06171643f, 0.08923906f, -0.11274489f, 0.25286207f, 0.10984180f, 0.04222344f, -0.18570101f, -0.65592903f, 
    -0.23284248f, -0.40708181f, 0.04125396f, 0.46422863f, 0.18066031f, 0.15890694f, 0.01556540f, 0.36226586f, 
    -0.22329414f, 0.08354221f, -0.12539236f, 0.37050036f, -0.42106926f, -0.01660915f, -0.05467613f, -0.29256472f, 
    0.05781861f, 0.59843475f, -0.41044021f, -0.29868492f, -0.03112774f, -0.02304715f, 0.16338894f, 0.77574694f, 
    -0.06855440f, 0.05378279f, 0.11476284f, 0.28358269f, -0.03415801f, -0.01814250f, 0.18224411f, -0.19907066f, 
    0.12712485f, 0.02551814f, 0.04416522f, 0.23235659f, -0.18712002f, 0.32729590f, -0.06954470f, 0.04708764f, 
    -0.15589850f, 0.01602498f, -0.08440705f, 0.41144338f, -0.00158085f, -0.01178873f, -0.04097868f, 0.45899874f, 
    0.16030417f, -0.10532463f, 0.67735445f, 0.27273902f, 0.03676788f, 0.10075518f, 0.10067585f, -0.08690341f, 
    0.28818804f, -0.24739456f, -0.88368559f, 0.11070640f, 0.11642221f, -0.35920158f, -0.30484933f, 0.10158654f, 
    -0.12970814f, 0.15657054f, -0.01412277f, 0.40652618f, 0.48486951f, 0.26035514f, -0.30439720f, -0.29803866f, 
    0.25014740f, -0.06881358f, -0.13147521f, 0.29310736f, -0.10226383f, -0.18040662f, 0.22243574f, 0.24457723f, 
    0.30619663f, -0.36716422f, 0.79352176f, 0.14206542f, -0.07038983f, 0.10576959f, 0.18708423f, -0.00890680f, 
    0.25900555f, -0.44985637f, -0.02499666f, -0.02113926f, -0.05571189f, -0.28074932f, -0.26214814f, 0.26242557f, 
    0.38944566f, 0.17634277f, 0.01505962f, 0.39963284f, 0.41140234f, -0.27372661f, -0.08869223f, -0.18567795f, 
    0.26292452f, 0.02772294f, -0.43659517f, -0.18787791f, -0.09394428f, 0.46429306f, 0.15528215f, 0.15061708f, 
    0.24823308f, 0.13039228f, 0.04686252f, 0.09721788f, -0.09426630f, 0.45488414f, 0.15575346f, -0.04938303f, 
    0.55357122f, -0.19695440f, -0.36030126f, 0.56978917f, 0.03844308f, -0.02927696f, -0.05412398f, -0.02467406f, 
    -0.03951472f, -0.28562793f, 0.06520811f, -0.01024821f, -0.25997275f, 0.71013075f, -0.31145528f, -0.29442596f, 
    -0.04665296f, -0.32833692f, -0.22643957f, 0.02116216f, 0.22872850f, -0.07691813f, 0.00115836f, 0.27321693f, 
    0.20054723f, -0.56689686f, 0.49488276f, 0.10486645f, 0.13940343f, -0.06078156f, 0.24920176f, -0.00883457f, 
    0.03925219f, -0.14402355f, 0.50907385f, -0.32899138f, -0.15739459f, -0.04085999f, 0.15880252f, 0.35327113f, 
    0.46772853f, 0.16041103f, 0.27331105f, 0.07808934f, 0.16046163f, -0.74954343f, -0.09362249f, 0.08738725f, 
    0.00914547f, 0.23685588f, -0.58177465f, -0.05122552f, -0.02304030f, 0.52672142f, 0.01506317f, -0.09522831f, 
    0.24303937f, -0.00228367f, 0.80885386f, 0.32797816f, -0.14217682f, 0.20137881f, -0.09551121f, 0.20910858f, 
    0.09393530f, 0.29286051f, 0.57861781f, -0.06808815f, -0.04360927f, 0.38507929f, 0.10955311f, -0.06156826f, 
    -0.04307077f, -0.12531738f, 0.29236987f, 0.23455273f, 0.01356984f, -0.66624755f, -0.09181293f, 0.32168624f, 
    -0.01965078f, 0.33017743f, 0.41731229f, -0.06927822f, -0.08281063f, -0.16238873f, -0.07741712f, -0.29741082f, 
    -0.21171960f, -0.13420138f, -0.00296854f, -0.42888764f, 0.15200314f, 0.19270071f, 0.20668504f, -0.03003728f, 
    -0.12933113f, -0.69807768f, 0.34240678f, -0.02285744f, 0.07207791f, 0.63446826f, -0.03631393f, -0.90888381f, 
    -0.24184309f, 0.10094647f, 0.24853125f, 0.40308005f, 1.07779253f, 0.24621840f, 0.03585605f, 0.16442716f, 
    -0.19397828f, -0.18905026f, -0.44163913f, -0.22550561f, -0.62019229f, 0.13115875f, -0.23838016f, 0.10452659f, 
    -0.16716236f, -0.13933073f, 0.05432315f, 0.02706179f, 0.07204616f, 0.04999074f, -0.20604616f, -0.11859202f, 
    -0.03688245f, -0.01017248f, -0.01364685f, 0.05420854f, -0.13073318f, 0.06889714f, 0.05196009f, -0.16843283f, 
    -0.09977554f, -0.12435158f, 0.10930280f, -0.08187219f, -0.00629098f, -0.16069147f, -0.04268257f, -0.19062081f, 
    0.01651832f, -0.17125164f, 0.09129913f, -0.06851619f, 0.10443295f, -0.13644740f, 0.02367104f, -0.07857727f, 
    0.20816037f, -0.20061593f, -0.16645591f, 0.54319680f, -0.02941148f, 0.11221147f, 0.02204653f, -0.02412741f, 
    -0.16341352f, 0.14977138f, -0.02334264f, 0.24671385f, 0.11035008f, -0.10915302f, -0.05655431f, 0.04200973f, 
    -0.05974906f, -0.12567830f, 0.18750978f, -0.11241540f, -0.31802529f, -0.24753860f, 0.12072174f, 0.43353996f, 
    -0.18270768f, 0.23121245f, -0.32338935f, 0.15273792f, 0.50599432f, 0.28640449f, 0.23751925f, -0.17380553f, 
    -0.04435391f, -0.17005172f, 0.42333752f, 0.16698088f, -0.17075081f, 0.24467009f, 0.31929913f, -0.36732689f, 
    -0.20325954f, -0.06313886f, 0.05816010f, 0.29770499f, 0.08501774f, 0.22504163f, 0.14913309f, -0.08813033f, 
    -0.23145898f, -0.14100389f, 0.08561338f, -0.39780289f, -0.44366068f, 0.13595070f, -0.13890521f, 0.20406257f, 
    -0.47857255f, 0.25691518f, -0.63571042f, 0.36470997f, 0.50062108f, 0.43630153f, 0.19059829f, 0.13529302f, 
    -0.13131094f, 0.10190986f, 0.04003066f, -0.05455392f, -0.00025004f, 0.03244402f, -0.22937270f, -0.10170493f, 
    -0.07234035f, 0.07367350f, -0.04841828f, -0.12919194f, -0.04676703f, 0.13940296f, 0.03581802f, -0.14042662f, 
    0.04160067f, 0.01421319f, -0.16752324f, -0.02447655f, 0.08226202f, -0.05308370f, -0.00518764f, -0.21338274f, 
    -0.11199302f, 0.02820708f, 0.00476474f, -0.18997782f, 0.10165019f, -0.00806194f, -0.10184646f, 0.04482909f, 
    -0.04573873f, 0.26185763f, 0.30717191f, -0.04529969f, -0.06870164f, 0.05133923f, -0.03422325f, -0.52687436f, 
    -0.11895075f, 0.11304025f, -0.30462834f, -0.00902699f, 0.06434100f, -0.05529243f, 0.44211689f, -0.08514437f, 
    -0.26171121f, -0.27442995f, 0.20431606f, -0.31448272f, 0.34795237f, 0.42461550f, 0.09456237f, 0.14868885f, 
    -0.09491587f, 0.25504106f, 0.25135180f, 0.43250647f, 0.08055338f, -0.32017553f, 0.28120959f, -0.32547775f, 
    0.03881055f, -0.16003354f, -0.17851871f, -0.08429568f, -0.02350020f, 0.02460314f, -0.13928638f, -0.12587270f, 
    -0.15016887f, 0.14461502f, 0.02194938f, -0.01179548f, 0.09221444f, -0.04044977f, -0.18321699f, -0.10740928f, 
    -0.13138999f, -0.02180091f, -0.13175085f, -0.03311835f, 0.10219408f, -0.06874198f, -0.12527274f, 0.03858207f, 
    0.09983506f, -0.10165212f, 0.15240559f, 0.07633738f, -0.16253909f, 0.02338869f, -0.10528766f, -0.07850454f, 
    0.30444410f, 0.03035003f, 0.30418223f, 0.29249454f, -0.17590851f, -0.04639078f, -0.09604383f, 0.06343298f, 
    0.19012736f, 0.22173668f, -0.21907924f, -0.08795726f, 0.03956191f, 0.64549249f, -0.27411887f, 0.29440516f, 
    0.32998046f, 0.30469868f, -0.11745618f, 0.41226453f, 0.80852163f, -0.44436476f, -0.40988794f, 0.35027558f, 
    0.15726103f, 0.48550144f, 0.28799263f, -0.03971014f, -0.24398696f, 0.04300733f, 0.04730012f, -0.16522217f, 
    0.03322982f, 0.09665683f, -0.30836585f, 0.05511864f, -0.08211076f, 0.17877902f, -0.10421409f, 0.14185335f, 
    -0.07692944f, 0.26410767f, -0.59717625f, 0.09753059f, 0.18977426f, 0.36110440f, 0.00000445f, 0.34631690f, 
    0.31200677f, 0.13269055f, 0.06497034f, -0.33491236f, -0.28691694f, 0.05544824f, -0.01364072f, -0.00637831f, 
    -0.08584057f, 0.32665843f, 0.05275061f, 0.10124519f, 0.29552120f, 0.35074896f, -0.01023387f, 0.07776968f, 
    0.12194090f, 0.46578661f, -0.02236499f, 0.02161113f, -0.02870445f, 0.23190017f, -0.15053590f, -0.02398069f, 
    0.37538242f, 0.29047877f, 0.22344865f, 0.32223037f, 0.03740709f, 0.33203113f, 0.36263758f, 0.29879084f, 
    -0.36606514f, -0.11530547f, -0.01976577f, -0.30975527f, -0.02159091f, 1.05224657f, 0.26383483f, -0.02434720f, 
    0.03119074f, 0.05463981f, 0.66869342f, 0.10411234f, 0.11938564f, -0.63616848f, 0.06338076f, -0.14442098f, 
    0.21216655f, 0.05595943f, 0.68511784f, 0.27626678f, -0.14402628f, -0.09634656f, 0.12470281f, 0.11086799f, 
    0.38944358f, -0.13170783f, -0.60498923f, -0.16763747f, -0.09369955f, 0.34458426f, -0.16903390f, 0.16679595f, 
    0.22685659f, 0.32962567f, 0.21520883f, 0.29665664f, 0.57045811f, -0.74859744f, 0.05127355f, -0.19809441f, 
    0.48934376f, -0.07558547f, 0.31664148f, -0.21736988f, -0.04687319f, -0.07381377f, -0.02606600f, -0.14804672f, 
    -0.10891240f, 0.09497178f, 0.23377317f, 0.10511784f, -0.08778017f, 0.50578076f, -0.03609473f, 0.21918567f, 
    0.29560816f, -0.16187944f, 0.66856575f, 0.01981656f, 0.09272759f, 0.29674610f, 0.02098684f, -0.19251174f, 
    0.47264102f, 0.27246255f, 0.28061590f, 0.10338935f, 0.17566396f, 0.35142842f, 0.18923621f, 0.25262415f, 
    0.10724921f, -0.02917644f, 0.50145829f, -0.10616607f, -0.46394089f, -0.21800961f, -0.34236181f, 0.13244788f, 
    -0.02765889f, 0.16926722f, 0.13558874f, -0.20776960f, -0.03665324f, -0.10155369f, 0.06199658f, 0.37079194f, 
    -0.48174128f, -0.03109116f, -0.28976479f, -0.21970408f, -0.03335939f, -0.57697952f, 0.35115388f, 0.18589884f, 
    0.03207310f, 0.23394397f, 0.15102755f, 0.00447372f, 0.10337101f, -0.01109795f, 0.36237040f, 0.05488915f, 
    0.02778522f, 0.29458717f, -0.09280541f, 0.26040742f, 0.20561224f, 0.41233698f, 0.34867004f, 0.29027268f, 
    0.38762060f, 0.44828939f, -0.57021201f, 0.16889323f, 0.03316122f, -0.20265099f, -0.07886062f, -0.04523097f, 
    0.39680296f, 0.42279077f, -0.61207402f, 0.18738261f, -0.13859327f, 0.21453126f, -0.70422816f, 0.38633147f, 
    0.40675646f, 0.18785939f, -0.07461151f, -0.10297406f, 1.02358496f, 0.00255859f, -0.22506048f, -0.07550728f, 
    0.24815649f, 0.26424286f, 0.45139021f, -0.04137954f, 0.15962476f, -0.05508987f, 0.30395246f, 0.38011086f, 
    -0.23308349f, 0.08415382f, 0.68543369f, -0.12020534f, -0.03807475f, 0.25558600f, 0.22843668f, 0.43754011f, 
    -0.16127336f, -0.33323771f, -0.18344077f, 0.00941501f, -0.07528811f, -0.10878766f, 0.29952791f, -0.03364158f, 
    0.12443236f, 0.30808634f, 0.14753482f, 0.02986441f, 0.17718451f, 0.16342685f, 0.37774867f, 0.11684053f, 
    0.13129333f, 0.26949832f, 0.24054424f, -0.03392103f, -0.22700197f, 0.15830123f, -0.18632253f, -0.17903921f, 
    0.13250145f, -0.01658461f, 0.58710825f, 0.37288570f, 0.11765864f, 0.19719483f, 0.09955882f, -0.27294758f, 
    -0.08252605f, 0.22902723f, 0.23791882f, 0.19820446f, 0.10904846f, 0.32618925f, -0.03294532f, -0.19598758f, 
    -0.14058736f, -0.59645599f, 0.20025651f, 0.09341816f, 0.06094986f, -0.58211178f, -0.27851000f, 0.38157582f, 
    -0.09126902f, 0.21180800f, -0.22761622f, 0.16591628f, -0.12414464f, -0.25946090f, 0.31459463f, -0.74360174f, 
    0.04706043f, -0.24589603f, 0.71162224f, -0.07436447f, 0.01125614f, 0.37795788f, 0.35299024f, 0.49703151f, 
    0.36459532f, -0.30703735f, -0.42427334f, 0.11709942f, 0.06647012f, -0.13507630f, 0.32209855f, 0.35987961f, 
    0.13949525f, -0.09713276f, -0.10907560f, 0.35708541f, -0.33317438f, 0.18355934f, -0.36630061f, -0.34002817f, 
    -0.00397811f, -0.07233118f, -0.28213936f, 0.45657808f, 0.15208222f, 0.44596446f, 0.05114036f, 0.49301219f, 
    0.22257738f, -0.08602990f, -0.22880375f, 0.33432949f, -0.09576910f, -0.01787825f, 0.21901864f, 0.21899211f, 
    0.31535253f, 0.07912000f, -0.92863768f, 0.35727456f, -0.05218603f, 0.16883194f, -0.10704231f, 0.55262482f, 
    0.04474273f, 0.38725877f, -0.14545833f, -0.13746090f, -0.18371026f, -0.13450265f, -0.40619048f, -0.39950654f, 
    -0.08781353f, 0.06285248f, -0.42700997f, 0.28994629f, 0.33560488f, 0.40598491f, 0.23991652f, 0.68971580f, 
    0.04967070f, -0.02990210f, 0.01613765f, -0.23353086f, 0.12463025f, -0.08026684f, -0.06493644f, -0.03945537f, 
    0.02983971f, -0.03811507f, -0.13775523f, -0.06342185f, -0.12456705f, 0.04938557f, 0.10166148f, -0.00166800f, 
    -0.09575212f, -0.02962558f, -0.09532223f, -0.11468651f, -0.03588887f, 0.05180034f, -0.24938057f, -0.18693383f, 
    -0.02799347f, -0.26006481f, 0.00882585f, -0.21515661f, -0.10164703f, -0.02701757f, -0.17751001f, 0.03732795f, 
    -0.05336196f, -0.30606472f, -0.46620438f, 0.20524244f, 0.15031236f, 0.00418016f, 0.27466729f, -0.26341134f, 
    -0.14905724f, 0.04960968f, 0.27469915f, -0.13470861f, -0.14105585f, 0.15598468f, -0.19767153f, 0.22341445f, 
    0.22570437f, 0.06788728f, 0.21384662f, -0.41306564f, -0.22328621f, -0.04438222f, 0.33149555f, 0.40264240f, 
    -0.11109842f, 0.01322999f, -0.33719468f, 0.00659087f, 0.32250950f, 0.35084593f, 0.02979026f, 0.03235111f, 
    -0.12310289f, -0.04738326f, -0.39906803f, -0.07552784f, 0.04586352f, 0.41340232f, -0.08343727f, 0.94359481f, 
    0.29314959f, -0.22844030f, -0.16518776f, 0.08260867f, 0.10843197f, 0.28264120f, -0.02755673f, -0.15697584f, 
    0.15157378f, 0.16655065f, 0.01087016f, 0.31283695f, -0.40470403f, 0.16848478f, -0.15290114f, -0.16151670f, 
    0.11084145f, 0.06895465f, 0.02592784f, -0.07781412f, -0.15509860f, 0.41911301f, -0.41719070f, 0.22370675f, 
    -0.35689515f, 0.12416080f, -0.14193924f, -0.07789778f, -0.16656812f, 0.19785208f, 0.44713271f, 0.00953150f, 
    -0.24968022f, -0.24808794f, 0.89501607f, 0.34506771f, 0.12520544f, 0.02791675f, 0.29789045f, -0.24596436f, 
    -0.00560007f, 0.14935255f, 0.20763715f, 0.14994466f, -0.24219844f, 0.93556499f, 0.41861013f, 0.12029043f, 
    -0.21102801f, 0.08030937f, -0.34943673f, 0.07513030f, -0.07858108f, 0.03634723f, 0.18688764f, 0.42859632f, 
    0.24807666f, 0.21715374f, -0.42491376f, 0.38172486f, 0.04277800f, -0.45845944f, -0.21885185f, 0.10718320f, 
    -0.25341329f, 0.40276998f, -0.09785629f, -0.00431872f, -0.07190966f, -0.06449217f, -0.10103977f, 0.03800201f, 
    -0.33003983f, -0.15817998f, 0.22348011f, -0.29364380f, 0.07250159f, -0.47570255f, 0.17252626f, 0.38867134f, 
    0.14224865f, 0.13297080f, 0.26173705f, 0.28390390f, 0.35661134f, 0.17684740f, 0.44491586f, -0.20329219f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26784247f, 0.39072686f, 0.01186491f, 0.22613955f, 0.03090163f, 0.38773918f, 0.29921380f, 0.04873182f, 
    0.49631938f, -0.00238811f, -0.19436491f, 0.34028500f, 0.32514217f, 0.08154267f, 0.06807480f, 0.12785079f, 
    0.27702340f, 0.12692349f, 0.07060847f, 0.17093484f, 0.41974223f, -0.15098476f, -0.11388773f, 0.24360357f, 
    0.34401724f, 0.45293710f, 0.25383449f, 0.02947383f, -0.22988050f, 0.46942818f, -0.10877986f, 0.03300175f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.93013179f, -0.15917951f, -0.15321124f, -0.49049121f, -0.02374656f, 0.34328726f, -0.36383760f, 0.43681467f, 
    0.06389697f, -0.53896046f, -0.06973244f, 0.04435546f, 0.09616943f, -0.08164705f, -0.41681051f, -0.08095452f, 
    0.18448558f, 0.06237653f, -0.51959270f, 0.34513941f, -0.07535730f, 0.22940013f, -0.01005676f, 0.33022028f, 
    -0.18696785f, 0.06036310f, 0.11731447f, 0.08662917f, 0.33127066f, 0.16515526f, -0.03376461f, -0.23416917f, 
    0.42970386f, 0.25648424f, -0.07461586f, -0.64318460f, 0.03766184f, 0.13502446f, -0.15559325f, 0.30200231f, 
    0.13647686f, 0.17723237f, -0.01029852f, 0.28342327f, 0.32027397f, 0.08994512f, -0.00206584f, 0.16714527f, 
    0.09441236f, -0.05161526f, -0.07785633f, 0.09578194f, -0.56583327f, -0.00570368f, -0.16660199f, -0.25529677f, 
    0.34097460f, 0.04977313f, 0.09170359f, 0.10082061f, 0.07552683f, -0.22058557f, -0.36837503f, 0.25557938f, 
    -0.59122783f, -0.11133448f, 0.28042641f, 0.22139210f, -0.15493055f, -0.27005014f, 0.06077914f, 0.13182975f, 
    -1.27732098f, -1.03646934f, 0.00797731f, 0.18118082f, 0.42525747f, 0.16637251f, 0.09740089f, -0.05739905f, 
    -0.58636343f, 0.07245056f, -0.04107342f, -0.72566992f, -0.85890359f, 0.37013593f, 0.25705796f, -0.38046014f, 
    -0.99922657f, 0.01477235f, 0.37756756f, 0.12248524f, 0.40716338f, -0.42794982f, 0.33653814f, 0.21498488f, 
    0.15785742f, -0.09625468f, -0.22959667f, 0.06415901f, -0.58139813f, -0.07718175f, 0.14636289f, -0.11159393f, 
    -0.07820174f, -0.11562990f, -0.06667400f, 0.07912993f, 0.14377519f, 0.02924157f, -0.11152396f, -0.03482784f, 
    -0.81131029f, -0.12653731f, 0.09762738f, -0.06999639f, 0.37840343f, -0.20364472f, -1.12972033f, 0.05545763f, 
    -0.07653338f, 0.00933905f, -0.34068620f, 0.06274045f, 0.34062311f, 0.30749270f, 0.29774466f, -0.54367346f, 
    -0.59341717f, 0.02327511f, 0.37068328f, 0.18848456f, 0.19733407f, 0.30989859f, 0.27491358f, -0.08598145f, 
    -0.11499247f, 0.08268346f, -0.04680974f, 0.11189398f, -0.10020259f, -0.14631443f, -0.25164428f, 0.00510515f, 
    -0.28121406f, -0.13295904f, -0.24067225f, 0.14202230f, 0.03971967f, -0.00318698f, -0.17264615f, 0.04613214f, 
    -0.33144963f, 0.33767566f, 0.01674746f, 0.09251478f, -0.27652228f, 0.32005769f, -0.05934898f, -0.07408441f, 
    0.63203812f, 0.06863596f, -0.39705032f, -0.28498754f, 0.12572362f, 0.20509842f, 0.00377555f, -0.12623109f, 
    0.14978720f, 0.26722583f, -0.05103058f, 0.04389021f, -0.14826202f, -0.08147488f, 0.07906447f, -0.13921562f, 
    0.43259177f, -0.17375070f, -0.05500722f, 0.17663579f, 0.15777850f, -0.41325265f, 0.13993131f, -0.16364148f, 
    0.37291798f, -0.07761844f, -0.15048242f, -0.04556381f, -0.30734006f, -0.55698335f, -0.29882979f, 0.01035391f, 
    -0.56991494f, -0.42729566f, -0.55225307f, -0.37234297f, 0.32645789f, 0.15019679f, 0.36948797f, -0.35084543f, 
    -0.20643839f, -0.77241141f, -0.07617920f, 0.00752684f, 0.12675707f, -0.05523956f, 0.20018162f, -0.05433564f, 
    -0.09677488f, -0.09790356f, 0.38468596f, -0.14011101f, 0.23100603f, -0.59513366f, -0.11365413f, 0.05564192f, 
    0.03661428f, 0.13017380f, -0.10593484f, -0.14147411f, -0.21451367f, -0.36344039f, 0.28401583f, -0.30795479f, 
    0.35315418f, -0.29774222f, -0.05992537f, 0.28115296f, -0.15215707f, 0.13954301f, -0.83976251f, 0.25430307f, 
    -0.10003839f, 0.42701358f, -0.01636651f, -0.71205407f, -0.94937903f, 0.02908399f, -0.36430725f, -0.05204885f, 
    -0.19152068f, -0.86801833f, -0.37681034f, 0.14869256f, -0.00084442f, 0.29431534f, 0.04616315f, 0.14209852f, 
    -0.32271048f, -0.06184819f, -0.85031837f, -0.04614408f, -0.25538301f, -0.00113507f, 0.22427066f, -0.09621083f, 
    -0.30930263f, 0.22808933f, -0.17314582f, -0.21288307f, -0.18844959f, -0.44700938f, -0.34357595f, -0.36441484f, 
    0.11251610f, 0.53679037f, -0.19728404f, 0.12928805f, -0.56184095f, -0.13940625f, 0.21791343f, 0.12659012f, 
    0.17532928f, 0.04630816f, 0.27508241f, 0.04914145f, -0.03502070f, 0.10641885f, 0.45500365f, -0.06058548f, 
    -0.16761576f, -1.30078316f, -0.34752262f, -0.17178658f, 0.14694020f, -0.08926997f, -0.29454857f, 0.48481676f, 
    0.11635208f, -0.47326663f, -0.01589923f, 0.07061766f, 0.07594045f, -0.02153996f, 0.14967367f, -0.38092610f, 
    -0.19006632f, 0.53961962f, -0.11364853f, -0.12427890f, -0.15677634f, -0.11385686f, -0.50810140f, -0.08038242f, 
    0.26691332f, 0.14278468f, 0.14736860f, 0.06802045f, -0.08385667f, -0.44683462f, 0.31798464f, -0.29596636f, 
    -0.53171247f, 0.19572693f, 0.34341598f, 0.05661066f, -0.23017327f, 0.36972994f, -0.23309185f, -0.28054404f, 
    0.06106121f, 0.19839998f, 0.32431501f, 0.17956918f, -1.19314492f, -0.30648407f, -0.29510778f, -0.03875667f, 
    0.25758383f, -0.38074577f, 0.02524887f, 0.22916922f, 0.28948212f, -0.04698437f, 0.08912766f, 0.10385459f, 
    -0.23055393f, -0.10672715f, -0.24043332f, -0.71151382f, 0.03285523f, -0.11580543f, -0.52287894f, 0.09056786f, 
    0.66511822f, -0.20878372f, -0.56752861f, -0.00286007f, 0.02789310f, 0.05496043f, 0.19950989f, 0.12346278f, 
    0.04517443f, 0.24284534f, -0.23760226f, 0.23832926f, -0.21729489f, -0.67274517f, -0.01082165f, -0.60557967f, 
    -0.08775038f, -1.08414340f, -0.14848134f, -0.11757112f, 0.04452357f, 0.07845800f, 0.15632062f, -0.09006675f, 
    -0.26894566f, 0.07778546f, 0.20329453f, -0.13605474f, 0.09599354f, 0.10331766f, -0.17881246f, 0.35405707f, 
    -0.42742890f, 0.08669171f, -0.11021882f, 0.16425568f, -0.35758135f, 0.40723991f, 0.05825238f, -0.14689523f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19678894f, -0.08741277f, -0.20359173f, 0.09584235f, 0.36753866f, 0.04853094f, 0.03994582f, -0.41536054f, 
    -0.17024614f, 0.02136850f, 0.01680128f, 0.04747766f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
