#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.09808898f, 0.13722108f, 0.05084088f, 0.56829715f, 0.99515998f, -0.26887313f, -0.40841427f, 0.01768104f, 
    -0.34788156f, 0.24572793f, -0.01860198f, 0.50361097f, 0.16055179f, 0.18847555f, -0.02282377f, -0.13449892f, 
    -0.25319853f, -0.13989747f, 0.21105108f, 0.05826875f, 0.20335931f, -0.13558234f, -0.08012953f, -0.22595683f, 
    0.15143907f, 0.63524741f, 0.74931794f, 0.24277523f, 0.19304182f, 0.51415020f, 0.46438640f, -0.43767753f, 
    -0.63649505f, -0.20078792f, -0.19517347f, 0.47370991f, 0.69786710f, -0.27833238f, -0.06609545f, 0.23830542f, 
    0.36442530f, -0.24046004f, 0.00004067f, 0.03432436f, 0.05918024f, 0.23978779f, 0.06951809f, 0.17940862f, 
    -0.06277607f, 0.25281999f, -0.61838150f, -0.31749412f, 0.70722866f, 0.57674855f, 0.27292663f, -0.35972270f, 
    -0.84537029f, -0.48122969f, -0.37865195f, -0.77205491f, 0.49258757f, -0.20456152f, 0.28826198f, 0.20593703f, 
    -0.23113470f, -0.22962123f, 0.07585231f, -0.24207242f, 0.14528349f, 0.33821848f, 0.00622709f, -0.09233892f, 
    -0.01277485f, 0.04729295f, -0.12370179f, 1.08479345f, 0.36061436f, 0.62876272f, 0.70446092f, -0.19313012f, 
    0.29713103f, 0.02538929f, -0.66013414f, -0.38364103f, -0.51198894f, -0.29699564f, 0.04115428f, 0.00274689f, 
    0.23905697f, -0.36732396f, -0.15708923f, 0.13232808f, -0.23790933f, -0.15428162f, -0.05544004f, -0.43856367f, 
    0.26384071f, 0.13333610f, 0.09445322f, -0.22180152f, -0.15671517f, 0.30650011f, -0.42572367f, -0.97975481f, 
    -0.62427706f, 0.24196753f, -0.69248217f, -0.57787812f, -0.58913499f, -0.62250650f, -0.23320638f, -0.01780483f, 
    0.29165742f, 0.43571350f, 0.30801317f, 0.25302738f, 0.13776381f, -0.06540994f, -0.02122051f, 0.27256861f, 
    0.06321662f, 0.09763884f, 0.41965562f, 0.09756491f, 0.16820170f, -1.54985654f, 0.87847030f, 0.29656535f, 
    -0.47547865f, -0.36240661f, -0.09597538f, 0.93025953f, -0.22524709f, 0.16952018f, 0.25001398f, -0.24635930f, 
    0.10021324f, -0.02226228f, -0.10366412f, 0.17913429f, 0.17230707f, 0.12455102f, -0.08772882f, 0.00193555f, 
    -0.14270304f, 0.18196845f, 0.10555285f, 0.09254926f, -0.02007581f, -0.04134391f, -0.49244192f, 1.05981350f, 
    -0.67968696f, -0.80401444f, 0.40859386f, -0.01666602f, -0.61961204f, -0.22011194f, -0.55098158f, -0.03990946f, 
    0.44814253f, -0.30513290f, -0.26617485f, -0.45073825f, -0.54602814f, -0.02248895f, -0.08232929f, 0.14964491f, 
    -0.21642122f, -0.31226400f, -0.18410674f, -0.05355278f, -0.03215426f, -0.24932741f, 0.23152862f, -0.65237343f, 
    -0.10610513f, 0.43395302f, 0.68391591f, 0.37129223f, 0.39524528f, 0.44099528f, 0.63001859f, -0.11409130f, 
    0.57970250f, -0.06787419f, -0.52147961f, -0.36240631f, -0.48070303f, -0.41767243f, -0.29881930f, -0.53522819f, 
    -0.39403379f, -0.21791013f, -0.44669312f, -0.10785355f, 0.07914126f, -0.36731297f, -0.07432670f, -0.26342952f, 
    -0.09921620f, 1.04680336f, 0.86807293f, 0.63307834f, 0.41412646f, -0.49812099f, 0.11258244f, -0.51446885f, 
    -0.43978530f, -0.00244919f, 0.25329071f, -0.24940056f, -0.00685130f, 0.16583169f, 0.15256934f, -0.11899419f, 
    0.05464602f, 0.19200075f, 0.16398033f, 0.30753678f, 0.14421368f, 0.04837622f, 0.05070893f, -0.00283743f, 
    0.15466851f, -1.03371215f, -0.96564680f, -0.37081447f, -0.16630149f, -0.36502907f, 0.45419136f, 0.12261865f, 
    0.40007401f, -0.12846595f, -0.28874370f, 0.11218272f, 0.00268270f, 0.21127017f, 0.31596810f, 0.40167606f, 
    -0.22064520f, -0.08850140f, -0.26295739f, -0.24561408f, -0.18956754f, 0.01523428f, 0.00206940f, 0.14369753f, 
    -0.00287541f, 0.09028516f, -0.04833035f, 0.79983240f, 0.19745645f, 0.13931035f, 0.77198189f, 0.43326575f, 
    0.23226847f, 0.38106179f, 0.24109769f, -0.38455668f, -0.25893149f, -0.00219634f, -0.33589086f, 0.41800272f, 
    0.13480727f, 0.53317374f, -0.09798107f, -0.17751679f, 0.21077532f, 0.11778159f, 0.46514291f, -0.11520685f, 
    0.19698520f, -0.20054227f, 0.49687460f, -0.32922915f, -0.78761619f, 0.80266005f, 0.89274639f, 0.26813111f, 
    0.67167664f, 0.64724714f, 0.35410914f, 0.36211997f, 0.04759905f, 0.10341539f, 0.14473318f, -0.18996157f, 
    0.43489721f, -0.12014665f, 0.40185973f, 0.46208885f, -0.16720147f, 0.11857274f, -0.16710949f, -0.13937145f, 
    -0.03367385f, 0.04686322f, 0.19244646f, -0.13722080f, 0.86041975f, -0.21704945f, -0.20912811f, -0.86459833f, 
    -0.14488508f, -0.46438769f, 0.31352770f, 0.90645146f, 0.29840085f, 0.41701069f, -0.35351396f, -0.26908720f, 
    -0.42412481f, -0.20469660f, -0.26238191f, 0.13287760f, 0.10103640f, -0.02463313f, 0.23420328f, -0.00885459f, 
    0.16595381f, 0.08772472f, -0.10878811f, -0.13578437f, -0.01339293f, -0.39953083f, -0.87394857f, -0.83731723f, 
    -0.58372730f, -0.60963678f, -0.01857293f, 0.88924503f, 0.45034119f, 0.43795863f, 0.54200977f, -0.15034012f, 
    0.08384295f, -0.01423465f, -0.25880480f, -0.30216822f, -0.16333999f, 0.06130937f, 0.13304216f, 0.24065240f, 
    -0.31067872f, -0.04791583f, -0.09863422f, 0.02549797f, -0.05897368f, 0.22148214f, 0.25824311f, -0.21547472f, 
    0.93670630f, 0.41432348f, 0.14360225f, 0.28297824f, -0.44135857f, -0.35311228f, -0.62363547f, 0.37483338f, 
    0.23387431f, 0.39607793f, 0.39523503f, 0.24554604f, 0.03461141f, 0.23620439f, -0.36412069f, 0.00556403f, 
    0.26583174f, -0.38619897f, 0.01793353f, 0.25727397f, -0.13244188f, 0.18051270f, 0.33313245f, 0.86825567f, 
    -0.02498798f, 0.40254584f, 1.27547395f, 0.65719479f, -0.29119810f, 0.42259675f, 0.08455848f, 0.41790077f, 
    0.22626671f, -0.25838706f, -0.29615793f, -0.22036414f, 0.13323931f, -0.06533588f, -0.11828945f, 0.03718803f, 
    0.00554946f, 0.15907899f, 0.05159122f, 0.05134399f, -0.02161736f, -0.18092223f, -0.17070742f, -0.04028489f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.13174306f, -0.05183424f, 0.25834572f, 0.21872069f, 0.31260675f, 0.01917201f, 0.20815089f, 0.13400055f, 
    0.00459367f, 0.18544096f, 0.00916297f, 0.11600155f, -0.10952374f, 0.06921749f, 0.12654872f, 0.04730346f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26248953f, 0.06176898f, 0.17255847f, -0.11359001f, -0.15506169f, -0.14046821f, 0.00622298f, 0.10705540f, 
    0.12673017f, -0.01122023f, -0.01946458f, 0.13527329f, 0.13250563f, 0.21818759f, 0.23158315f, -0.09415428f, 
    0.12393788f, 0.08245341f, -0.09764767f, 0.01792754f, 0.10743021f, 0.11856335f, -0.17545630f, 0.12264246f, 
    0.11164612f, 0.18468255f, 0.07142918f, -0.35652339f, 0.06380756f, 0.01395211f, 0.16082467f, 0.25241807f, 
    0.05079569f, 0.10166171f, 0.09386858f, 0.22169089f, 0.38248363f, 0.10907541f, 0.03921579f, -0.08416948f, 
    0.06885623f, -0.09790340f, 0.06956147f, -0.02563113f, 0.07749352f, 0.02857186f, 0.08937716f, -0.05065638f, 
    -0.06327929f, -0.23962346f, 0.07006188f, 0.11299428f, -0.03736776f, 0.23408638f, 0.18418032f, -0.00685818f, 
    0.09561265f, 0.10768275f, 0.00743571f, 0.10276992f, -0.49251726f, -0.63258034f, -0.10733444f, -0.09367190f, 
    -0.23194484f, 0.14975430f, 0.02077625f, -0.11260121f, 0.13538964f, 0.07225746f, 0.22691047f, 0.02766033f, 
    0.11756718f, -0.34255216f, 0.04537795f, -0.12665708f, -0.12631649f, 0.14825387f, 0.03699160f, 0.11997541f, 
    0.10444043f, 0.11040314f, 0.09618253f, 0.16919737f, 0.12770484f, 0.15945205f, 0.09905399f, 0.21360655f, 
    0.01755118f, -0.00611744f, -0.03427152f, 0.11514255f, -0.08384250f, 0.03029991f, -0.19846146f, 0.10074790f, 
    0.46159464f, 0.14685674f, 0.32447192f, -0.20878914f, 0.05464386f, -0.04832128f, 0.07096511f, 0.04281540f, 
    -0.04265468f, 0.08266219f, 0.07000587f, 0.02907767f, -0.19659296f, -0.06791420f, -0.07302258f, 0.00248483f, 
    0.16199799f, 0.10692962f, 0.08805012f, 0.07635242f, 0.02168288f, 0.04083353f, 0.07261950f, 0.06658250f, 
    -0.05481960f, 0.09355424f, 0.11972998f, 0.04997512f, 0.13172174f, 0.08633051f, -0.06248383f, 0.05641187f, 
    0.10475161f, 0.10235533f, 0.06961852f, -0.08536498f, 0.07573666f, 0.16432463f, 0.00677009f, 0.15879981f, 
    0.34917808f, 0.01884272f, -0.01024633f, -0.04003357f, -0.02679933f, -0.02403942f, 0.16638294f, 0.16578491f, 
    0.23416407f, -0.07749455f, -0.10333216f, -0.06964614f, 0.08699510f, 0.12315195f, -0.09402842f, 0.06219906f, 
    0.10794678f, -0.07854932f, 0.19701757f, -0.06626186f, -0.10265196f, -0.25318095f, -0.29967812f, -0.32772496f, 
    0.15673070f, 0.08574380f, -0.17828308f, 0.10539841f, 0.19742803f, -0.03537787f, 0.08504120f, 0.03187119f, 
    0.22188389f, 0.16366060f, 0.16832159f, 0.09570169f, -0.09720989f, -0.11973009f, 0.09951844f, 0.11435467f, 
    0.05219354f, -0.01529805f, 0.08666693f, 0.12944640f, 0.19849384f, -0.07104180f, 0.13388251f, 0.22410402f, 
    -0.02707293f, -0.11011589f, -0.01398557f, 0.04971955f, -0.03816221f, 0.13134955f, -0.03924947f, 0.04178314f, 
    -0.29777420f, -0.03974650f, 0.00441356f, -0.03672014f, 0.00160108f, 0.01645714f, 0.07423545f, -0.06572986f, 
    -0.04069604f, -0.00101597f, -0.04575391f, -0.05369795f, -0.20682456f, -0.07205629f, 0.04413401f, -0.13693185f, 
    0.13370416f, 0.03185493f, -0.00909578f, -0.13159275f, 0.06757380f, 0.05415168f, 0.03574264f, 0.02357164f, 
    0.33033669f, 0.66714519f, -0.09290443f, -0.18150485f, 0.02418557f, 0.04134457f, -0.00497571f, -0.01764721f, 
    0.01182991f, 0.27121305f, -0.02532206f, -0.06961795f, -0.46803281f, -0.16917165f, 0.17510326f, -0.16705568f, 
    0.15530516f, 0.05964661f, -0.00399179f, 0.01174000f, 0.02904728f, 0.06747520f, 0.07691787f, -0.01139564f, 
    -0.01467963f, -0.02581802f, -0.01878577f, -0.24164575f, 0.16433218f, 0.04023904f, 0.07558367f, 0.03617657f, 
    0.11280422f, 0.13893242f, 0.01125678f, 0.03199559f, -0.08992574f, -0.00409246f, -0.47441366f, -0.23724636f, 
    0.03418716f, 0.00846118f, -0.01053831f, 0.11464912f, -0.01436831f, 0.06485673f, 0.01938245f, -0.07047632f, 
    0.17596115f, 0.19277689f, -0.28026912f, -0.34376132f, 0.07384980f, 0.04465591f, 0.14873655f, 0.10378744f, 
    -0.10646755f, 0.15370017f, 0.11738781f, 0.12792517f, 0.41224796f, -0.06247305f, -0.17912653f, 0.25031543f, 
    0.04912828f, 0.18132475f, -0.09373923f, 0.09566916f, -0.02025773f, -0.12808995f, -0.02374341f, 0.00451613f, 
    -0.23198380f, 0.02818870f, -0.11002225f, 0.02857889f, 0.08332869f, 0.02945271f, -0.13685024f, -0.09583249f, 
    0.13258620f, -0.03612165f, 0.00797831f, -0.07555136f, 0.59020239f, 0.25036937f, 0.09695241f, 0.12075586f, 
    -0.15416399f, -0.16733348f, 0.16309600f, 0.00093274f, -0.00387468f, -0.07153918f, -0.19028266f, -0.02247570f, 
    0.10583744f, -0.03294871f, -0.23126037f, -0.02164068f, 0.05293672f, 0.02935817f, -0.04473344f, -0.03157096f, 
    0.02370014f, 0.03848403f, -0.16753753f, 0.10170883f, 0.51666582f, -0.07700671f, -0.10607074f, -0.02280129f, 
    -0.12625098f, 0.05315948f, -0.13359100f, 0.00693163f, -0.00152612f, -0.03072830f, 0.00336636f, -0.03845285f, 
    0.26203206f, -0.17200907f, 0.02136405f, 0.28518626f, 0.12731956f, -0.04763987f, 0.14917319f, 0.31535864f, 
    -0.02024356f, -0.02524056f, 0.08093647f, 0.02608935f, 0.38972548f, -0.35019103f, 0.21298511f, 0.21351363f, 
    -0.20007299f, -0.08541130f, -0.06280506f, 0.16211332f, 0.11253735f, -0.08591122f, 0.00740310f, -0.05611152f, 
    -0.02787428f, 0.11546833f, 0.08039369f, 0.02774530f, 0.09915446f, 0.07721782f, -0.00563511f, -0.06350498f, 
    -0.00764301f, 0.00548352f, 0.12068231f, -0.08357811f, -0.05939346f, 0.00195533f, 0.06648733f, 0.05886851f, 
    0.04178698f, 0.03068287f, 0.00212081f, 0.07715136f, -0.08567134f, 0.07510170f, 0.04051918f, 0.07190890f, 
    -0.13321210f, -0.08753505f, 0.03600805f, 0.17741179f, 0.04514363f, -0.09378090f, 0.18648952f, -0.05876631f, 
    -0.11650004f, -0.11463703f, -0.12637684f, 0.00019610f, -0.32969162f, -0.02768885f, -0.01276725f, 0.14717710f, 
    0.03143167f, -0.04179587f, -0.08229156f, 0.00225998f, -0.13053432f, -0.04789493f, -0.12271139f, 0.02207995f, 
    -0.05953187f, 0.15322796f, 0.13576819f, 0.16073942f, 0.02092083f, 0.05519073f, -0.15536322f, 0.00524131f, 
    -0.04407176f, 0.20136067f, -0.02703374f, 0.16542961f, -0.06962086f, 0.12481865f, 0.13427612f, 0.07899711f, 
    -0.05517812f, 0.10658047f, 0.18290091f, 0.09678128f, 0.03984304f, -0.08296599f, 0.06799455f, 0.19570562f, 
    0.33029482f, -0.02766527f, 0.27690607f, 0.36411241f, 0.00143497f, -0.02282984f, 0.02254847f, 0.06838205f, 
    0.01275005f, 0.28836665f, 0.18628241f, 0.08194732f, -0.67201561f, 0.18265060f, 0.03834415f, 0.01147528f, 
    0.05218579f, -0.00377390f, 0.09698404f, 0.01336699f, 0.14262013f, -0.05296318f, -0.09704240f, 0.09623593f, 
    0.24480659f, 0.01884254f, -0.00970902f, 0.34528801f, 0.00664193f, 0.02063784f, 0.10494117f, 0.02577696f, 
    -0.02338826f, 0.03875364f, -0.06729893f, 0.03556170f, -0.06451742f, 0.19170642f, -0.01299900f, -0.01636994f, 
    -0.01760680f, -0.00368482f, 0.04200710f, 0.04032391f, -0.03941609f, 0.06547537f, -0.15034197f, -0.04587730f, 
    -0.28256813f, -0.14297040f, 0.12691697f, 0.15025409f, -0.13781019f, 0.03039913f, -0.02408600f, 0.11669013f, 
    -0.03502977f, 0.00323897f, 0.02666307f, -0.02823388f, -0.06502052f, 0.07462383f, -0.26672813f, 0.08479427f, 
    0.15545514f, 0.14773434f, 0.05722619f, 0.07812067f, -0.10476233f, -0.12219983f, -0.03150513f, -0.02373296f, 
    0.32683170f, 0.00864323f, -0.14760818f, -0.15265748f, -0.11109959f, -0.06472696f, 0.13610317f, -0.18672541f, 
    0.15455306f, 0.13157673f, -0.02081291f, 0.11330007f, -0.32056484f, 0.30801669f, 0.04449229f, -0.23621985f, 
    -0.02741948f, -0.14034364f, -0.15288019f, 0.09400744f, 0.01334772f, -0.03928914f, -0.06444465f, -0.02265085f, 
    0.07873145f, -0.25360826f, 0.26811624f, -0.17480420f, -0.09836132f, 0.02565266f, -0.01776895f, -0.03311521f, 
    0.12210949f, 0.02591451f, -0.07615168f, -0.05485632f, -0.00342629f, 0.10327214f, -0.13849023f, 0.21669841f, 
    0.24882744f, 0.14494912f, -0.08024045f, -0.00161551f, 0.00814578f, 0.13296226f, 0.03403435f, -0.11241063f, 
    -0.08755032f, -0.04208461f, 0.13164139f, -0.02318350f, 0.09557762f, 0.01281494f, -0.16254386f, 0.06477957f, 
    0.06942062f, -0.19050205f, 0.03402871f, 0.06006615f, 0.02973433f, 0.23127612f, 0.02453057f, -0.21198542f, 
    -0.06761725f, 0.11267079f, 0.02665151f, -0.06377864f, 0.04733804f, 0.08682774f, 0.12845041f, -0.07171250f, 
    0.44679865f, 0.12834166f, 0.16102408f, -0.04409183f, -0.12274844f, 0.01213640f, -0.01526590f, -0.03205253f, 
    -0.06805764f, -0.14178926f, 0.09591639f, -0.03130163f, -0.25819659f, 0.09580263f, 0.10273778f, -0.06013780f, 
    0.05407398f, -0.03136471f, -0.03754894f, -0.04729193f, 0.15072428f, -0.14144409f, 0.09345588f, -0.21183969f, 
    0.09560269f, -0.22945039f, 0.08026316f, 0.08318879f, -0.11796834f, 0.07081927f, -0.07138893f, -0.14828968f, 
    0.02547847f, -0.03894811f, 0.15127486f, 0.03333145f, -0.28268802f, 0.25089315f, 0.17511003f, 0.08988586f, 
    -0.11546921f, 0.10735317f, 0.04883960f, -0.08329654f, -0.10566901f, 0.06465237f, 0.02525478f, 0.03257488f, 
    -0.25720778f, 0.08483537f, -0.06987159f, 0.21261798f, -0.08520716f, -0.12762932f, -0.13764852f, -0.13386609f, 
    -0.00157823f, 0.01544756f, 0.10057664f, 0.03888024f, 1.05570793f, -0.13897878f, -0.12823693f, 0.22592211f, 
    0.26739714f, 0.09322015f, 0.02147496f, 0.22040327f, -0.06784923f, -0.05080559f, -0.01975751f, 0.03154406f, 
    -0.13290657f, -0.22991118f, 0.22034359f, 0.34357619f, -0.00323833f, -0.21024331f, -0.01703911f, 0.00438487f, 
    -0.06287158f, 0.09983332f, 0.06573557f, -0.01355737f, 0.21785334f, -0.00308211f, -0.05784172f, -0.18564734f, 
    0.06295124f, 0.08476514f, 0.08123796f, 0.05350722f, -0.18124969f, 0.05055715f, 0.14216302f, 0.05954523f, 
    0.02441643f, 0.27549696f, 0.26259968f, 0.03078595f, -0.08714266f, 0.02189286f, -0.24979442f, -0.06860948f, 
    -0.05055921f, -0.13106419f, 0.02919847f, -0.00186042f, -0.03271353f, -0.03853756f, 0.04532349f, 0.07441419f, 
    0.10025398f, 0.02986535f, -0.06384052f, -0.05549338f, 0.11757935f, 0.02284855f, 0.06270571f, 0.09056064f, 
    -0.05469539f, 0.10527412f, 0.22452043f, -0.06670252f, 0.06126208f, -0.18146902f, -0.15103477f, -0.08417419f, 
    -0.01132815f, -0.15495756f, 0.07731348f, -0.03768748f, -0.12375671f, -0.09326537f, -0.05084748f, 0.02227932f, 
    -0.04544817f, -0.11882597f, 0.04610869f, 0.11272960f, 0.07191863f, 0.01773527f, -0.05310604f, -0.25406870f, 
    0.06992114f, -0.21978015f, 0.08710857f, 0.08795066f, 0.02062827f, -0.00231058f, 0.16802195f, -0.10675703f, 
    -0.14711969f, 0.08568083f, 0.08082983f, 0.00375659f, 0.10401127f, 0.33502853f, -0.02128014f, 0.16505903f, 
    0.15705526f, 0.08815098f, 0.16172630f, 0.09768485f, -0.10647407f, -0.03717373f, 0.08217959f, 0.10237701f, 
    -0.10000747f, -0.03670488f, -0.15642454f, -0.06026548f, -0.01410470f, -0.30301574f, -0.21676819f, -0.06961242f, 
    -0.01162210f, 0.02680011f, -0.36422887f, -0.11019682f, 0.28979909f, 0.21797518f, 0.11045051f, 0.07069145f, 
    -0.02382282f, -0.06074928f, -0.02805956f, -0.20146230f, -0.00190193f, -0.07775348f, 0.03932917f, 0.10378678f, 
    0.13717467f, 0.09906346f, 0.06352198f, -0.09059064f, 0.16650996f, -0.11138782f, -0.06734627f, 0.03555442f, 
    0.13462110f, -0.05711650f, 0.11435913f, -0.02431158f, 0.27006704f, -0.12418075f, -0.20444894f, 0.07650138f, 
    0.07067563f, 0.10942842f, 0.07166236f, -0.00411906f, 0.09474429f, -0.00361671f, -0.14228567f, 0.04379323f, 
    0.32444152f, -0.13143885f, 0.23415385f, -0.18260334f, -0.03115873f, 0.10662355f, 0.12579167f, 0.09632401f, 
    0.05895211f, 0.10224074f, 0.13778603f, 0.01468306f, -0.05899893f, -0.13788210f, 0.19581924f, -0.02176878f, 
    0.12836063f, 0.05119262f, 0.01139134f, -0.13023502f, 0.19872780f, 0.04336944f, 0.00021103f, 0.00842375f, 
    0.56034154f, -0.06993497f, -0.28933346f, 0.11307156f, -0.03520909f, -0.01231817f, -0.15949476f, -0.06584528f, 
    0.08242258f, 0.06353740f, 0.10394870f, -0.05016713f, -0.32199791f, 0.22834860f, -0.32337803f, 0.24149939f, 
    -0.15380812f, 0.04926172f, 0.01897094f, 0.12618774f, -0.05522246f, 0.03352914f, 0.04775701f, 0.01265426f, 
    0.11793110f, 0.22842351f, -0.03505217f, 0.51744705f, 0.07212025f, 0.09197467f, 0.16224396f, -0.15937592f, 
    0.01687815f, 0.18839757f, -0.13953032f, 0.11914537f, 0.06472895f, -0.40581700f, 0.01398587f, -0.18797672f, 
    0.00927559f, -0.11366896f, -0.01844590f, 0.18732315f, 0.06714354f, 0.10006483f, -0.01532909f, 0.08270147f, 
    0.11319149f, 0.15166065f, 0.15258291f, 0.06777716f, 0.20965223f, -0.13245393f, -0.02005644f, 0.12845381f, 
    0.11117582f, 0.07358565f, 0.00169294f, 0.06998451f, -0.01377841f, -0.11207479f, 0.02346224f, -0.35835764f, 
    0.01249848f, 0.19220009f, 0.08900619f, -0.11396524f, 0.00372054f, 0.02015257f, 0.09678543f, 0.06878080f, 
    -0.29692861f, -0.12974481f, 0.14388235f, 0.02286422f, 0.20784980f, 0.01653099f, 0.00102131f, -0.11600798f, 
    0.06173218f, -0.08798368f, 0.09087712f, -0.04866474f, -0.41613007f, -0.27910510f, 0.19878536f, -0.05230386f, 
    -0.09003492f, -0.09850872f, 0.06560087f, 0.19151577f, -0.06555504f, 0.13173538f, -0.00947416f, -0.13913782f, 
    -0.47073185f, 0.23344079f, -0.07605220f, 0.10090450f, 0.04876935f, 0.13036478f, 0.14645068f, -0.12832071f, 
    0.02279100f, 0.01810652f, 0.02636087f, 0.02016591f, 0.03201592f, 0.23651025f, -0.17162819f, 0.07452629f, 
    -0.17393880f, -0.01480725f, -0.07924571f, -0.12631056f, -0.06196057f, -0.09878663f, 0.09076799f, 0.03071612f, 
    0.22607969f, -0.12784144f, 0.09965283f, 0.26516089f, 0.01240246f, -0.20395865f, -0.07835887f, 0.06509896f, 
    0.27832845f, -0.00603877f, 0.03430521f, 0.07552665f, -0.15610321f, 0.01449297f, 0.29327875f, -0.42044044f, 
    0.04751878f, -0.01364667f, -0.10454992f, 0.22033416f, -0.11294578f, 0.07246984f, 0.07726474f, -0.01466032f, 
    -0.04880424f, -0.16112246f, -0.27105802f, 0.10943218f, -0.00267828f, -0.09881189f, -0.20402935f, -0.02806984f, 
    0.22767131f, 0.09462540f, -0.13296148f, -0.02192318f, 0.16073518f, 0.01637092f, -0.17612430f, 0.07478689f, 
    0.11561665f, -0.20255755f, -0.06599007f, -0.00430994f, -0.12179453f, -0.04468875f, -0.00500388f, -0.12851183f, 
    -0.09613167f, -0.07772932f, -0.08454498f, -0.07329542f, 0.07465144f, -0.22070593f, -0.17709732f, 0.08503514f, 
    -0.11035781f, -0.03140752f, 0.05329520f, -0.15843357f, 0.29346296f, -0.11320359f, -0.05886063f, 0.18133768f, 
    -0.00883328f, -0.07000904f, -0.10069653f, -0.00304251f, 0.19288695f, -0.05796306f, 0.08273832f, 0.15869175f, 
    0.46668085f, -0.00922090f, 0.17543633f, 0.28308973f, -0.13731584f, 0.03303047f, -0.00857792f, -0.04346585f, 
    -0.01441974f, 0.05385084f, -0.17432328f, 0.03016873f, -0.24567911f, 0.29006940f, 0.23334047f, 0.18992232f, 
    0.08474781f, -0.02091251f, 0.02045459f, 0.18117842f, -0.13210410f, 0.08994379f, 0.07059911f, 0.18611149f, 
    0.23141119f, 0.18900105f, 0.02870624f, 0.09145144f, -0.10323577f, 0.18322535f, -0.05658036f, 0.08870525f, 
    0.14506111f, 0.06365815f, 0.10401978f, 0.07664724f, -0.44081190f, -0.01648199f, -0.08357154f, -0.14035957f, 
    0.08884673f, 0.04438700f, 0.06661844f, 0.07470455f, 0.06090687f, 0.09460412f, 0.16496092f, 0.17304993f, 
    0.00756170f, -0.22296400f, -0.07796931f, -0.19156583f, -0.01381354f, -0.19435889f, -0.06332620f, -0.02835276f, 
    -0.11913807f, -0.24544124f, 0.08741763f, 0.09920350f, 0.65140957f, 0.23090477f, 0.31472620f, 0.38954344f, 
    0.10812351f, 0.00638702f, -0.09108726f, -0.08202159f, -0.01779740f, -0.14274256f, 0.04511723f, 0.23284869f, 
    -0.15640369f, 0.09727438f, 0.03686261f, -0.13037089f, -0.06958370f, -0.17461976f, 0.03292450f, -0.04881684f, 
    -0.03225224f, 0.05622379f, -0.02536152f, -0.06660631f, -0.11926246f, -0.00722284f, 0.04660024f, -0.05573083f, 
    0.21894655f, 0.02530064f, -0.00071680f, 0.06388026f, -0.07641304f, -0.00880389f, 0.14583705f, -0.01162770f, 
    0.19989601f, 0.09756300f, 0.10531028f, -0.16503531f, 0.04453886f, -0.08071993f, 0.03707762f, 0.23648809f, 
    -0.10578098f, 0.17945507f, -0.12144888f, 0.03189387f, 0.20253746f, 0.14016850f, 0.22679307f, -0.07735063f, 
    0.03988453f, -0.00097450f, 0.07288681f, 0.11777586f, 0.04635425f, 0.06431375f, -0.09660109f, 0.01847646f, 
    -0.12336615f, -0.29981425f, -0.11045347f, 0.01323441f, 0.07028310f, -0.02942703f, 0.08055159f, 0.01454487f, 
    0.05296705f, 0.10401413f, -0.03437255f, -0.03118804f, -0.25529480f, -0.18143544f, -0.18272346f, -0.19558148f, 
    -0.16642027f, -0.04065298f, -0.08539873f, -0.00052589f, 0.00405646f, -0.16035427f, -0.01195410f, 0.11140292f, 
    0.31783074f, -0.28054231f, 0.18797773f, 0.28425375f, 0.04178374f, 0.04015211f, -0.03542654f, -0.03416863f, 
    0.05363415f, -0.00784759f, -0.17497069f, -0.06554043f, -0.14361787f, -0.34165663f, 0.19400527f, 0.18657954f, 
    -0.06165328f, 0.02465726f, -0.02379713f, -0.04474257f, -0.00564200f, -0.05094367f, -0.03943200f, 0.11022424f, 
    -0.20562792f, 0.14242971f, -0.02613343f, 0.22545977f, 0.08318428f, 0.01218521f, -0.18634692f, -0.02486464f, 
    -0.21092281f, 0.20213290f, 0.02341061f, -0.07743435f, 0.05851717f, -0.04065751f, 0.12971798f, 0.28376460f, 
    -0.00324643f, 0.03202061f, 0.01388182f, 0.05387747f, 0.00552781f, -0.08271520f, 0.12716380f, 0.11946616f, 
    0.21642514f, -0.07676779f, 0.11554583f, -0.01681841f, -0.04834724f, -0.11661664f, 0.11697058f, 0.09963898f, 
    0.03089697f, 0.27087331f, 0.16986543f, 0.01298490f, -0.73634416f, 0.56708288f, -0.11161878f, -0.34229875f, 
    -0.12030161f, -0.01548620f, -0.00850081f, -0.04799470f, 0.08381736f, 0.08206169f, -0.01990948f, 0.01121202f, 
    0.36708638f, 0.19177680f, -0.15394180f, -0.03585191f, -0.02688349f, 0.04658429f, 0.12213466f, -0.03198353f, 
    -0.00876545f, 0.08623165f, -0.00741407f, -0.09401373f, -0.10994948f, 0.17310013f, -0.02181066f, 0.12674972f, 
    0.08281310f, -0.00797484f, -0.10707196f, 0.07510466f, 0.07202494f, 0.13999897f, 0.04144690f, -0.04639168f, 
    -0.28016615f, 0.01777817f, -0.07277963f, 0.28745553f, -0.07061151f, 0.04390061f, 0.04938680f, -0.09381738f, 
    -0.05436384f, 0.01848808f, 0.11338405f, 0.05987849f, 0.07234498f, 0.26616967f, -0.16174135f, 0.05709587f, 
    0.05953252f, 0.08132172f, 0.03510169f, 0.19914567f, -0.15726055f, -0.15042068f, -0.08125772f, 0.02469917f, 
    0.38460028f, -0.06929160f, -0.30729675f, -0.15550239f, -0.10907013f, -0.06897858f, -0.01133060f, -0.14358991f, 
    0.21059886f, 0.11539149f, -0.07727935f, 0.08748310f, -0.36283049f, 0.24242224f, -0.11816949f, -0.05291903f, 
    -0.08235491f, -0.11997174f, -0.15552507f, 0.14251162f, 0.07210785f, 0.03618276f, 0.00533571f, 0.01860531f, 
    0.08626790f, -0.15216906f, 0.02331217f, -0.42827007f, -0.00727510f, 0.00238904f, 0.07388688f, -0.12525028f, 
    0.09784017f, 0.06388608f, -0.10872444f, 0.06685206f, 0.19386537f, 0.07476462f, -0.07844689f, 0.07415875f, 
    0.01041258f, -0.11525386f, -0.00823151f, 0.02634585f, -0.05585554f, 0.06323352f, 0.17050560f, -0.10292744f, 
    -0.21132456f, -0.10216498f, 0.18230301f, 0.19724758f, 0.14326663f, -0.04717036f, -0.09681124f, 0.05061726f, 
    0.17394805f, -0.00088045f, 0.07118395f, 0.04301638f, 0.38752741f, 0.01160158f, -0.10894329f, 0.25005558f, 
    0.02968979f, 0.12259113f, 0.00951178f, 0.05169524f, -0.02878156f, 0.07477118f, 0.10851739f, -0.01987913f, 
    0.17603609f, 0.19610380f, -0.07560943f, 0.10924640f, 0.05414753f, -0.12557320f, -0.17845926f, 0.17204805f, 
    -0.00414522f, 0.14596830f, -0.02866929f, -0.12168226f, 0.28879160f, -0.08604550f, 0.06876465f, -0.01549925f, 
    0.03608271f, -0.06241747f, 0.11728926f, 0.00867221f, 0.17799352f, 0.10266834f, 0.04924035f, 0.02058437f, 
    -0.11309366f, -0.40039784f, -0.18864946f, 0.04344609f, -0.12337334f, 0.06014189f, 0.11898643f, -0.02923630f, 
    -0.04546179f, -0.15283509f, -0.05445096f, -0.16789094f, 0.22548252f, 0.02263624f, -0.09995220f, 0.03025381f, 
    -0.00048681f, -0.05563015f, -0.15675500f, -0.19758897f, -0.03859135f, 0.08674118f, -0.02400290f, -0.17911707f, 
    -0.05403776f, 0.23909241f, -0.28298932f, -0.03187858f, -0.01059988f, -0.07180433f, -0.13387041f, 0.01629913f, 
    -0.02155416f, -0.06139197f, 0.02673717f, 0.03986577f, 0.57677078f, 0.24251579f, -0.03196948f, 0.22610863f, 
    0.13231266f, 0.08754659f, -0.01908249f, -0.01808675f, -0.14986029f, 0.07220114f, 0.01775384f, -0.02643533f, 
    -0.18267585f, -0.05950780f, -0.05622373f, 0.08542643f, 0.18037477f, -0.01196073f, -0.05059975f, -0.05180360f, 
    0.04465747f, -0.01205340f, 0.09194572f, -0.13869081f, 0.09202076f, -0.22154725f, -0.05592179f, -0.01818023f, 
    0.03284245f, 0.05012235f, -0.01697250f, -0.02764951f, 0.06773372f, 0.11767816f, 0.11423548f, 0.02699152f, 
    0.47700521f, -0.12612107f, -0.13759722f, 0.10460523f, 0.12852827f, -0.11915333f, -0.05776367f, -0.16878757f, 
    -0.03261607f, -0.10706623f, 0.09822156f, 0.13257484f, -0.00147204f, 0.10234112f, 0.24054891f, 0.10118112f, 
    -0.02918700f, 0.04311332f, -0.01087195f, -0.13564968f, -0.00437072f, 0.10804164f, 0.11741742f, -0.00469386f, 
    -0.27032036f, -0.01095787f, 0.18717065f, 0.10375142f, 0.05356831f, 0.01548807f, -0.08145131f, -0.02771965f, 
    -0.01524861f, -0.13782392f, -0.03589883f, -0.05976646f, 0.25872549f, -0.28052264f, 0.19914964f, 0.11705685f, 
    -0.15870629f, 0.13193293f, 0.07310030f, 0.00542902f, -0.16190423f, 0.11665498f, -0.00738900f, -0.12628372f, 
    -0.10822278f, 0.37997979f, 0.03242244f, -0.00115944f, 0.07202002f, -0.12817943f, 0.07480261f, -0.10075744f, 
    0.00792106f, 0.04569011f, -0.02157493f, 0.16367947f, 0.27398336f, 0.39126945f, 0.33406892f, 0.18007122f, 
    0.05938523f, 0.01153544f, 0.10695606f, 0.01424828f, 0.00542876f, -0.03575874f, 0.01745626f, -0.00348549f, 
    0.11199161f, 0.05230242f, -0.30897427f, -0.04471638f, -0.10187524f, -0.03646541f, 0.07150001f, -0.12726812f, 
    0.03725068f, 0.20071322f, -0.15600276f, -0.04541155f, 0.26481849f, -0.03079424f, 0.08740888f, -0.00884565f, 
    0.12830947f, -0.02118766f, -0.04733185f, 0.03033463f, -0.00852823f, -0.11467956f, -0.14130384f, -0.21348383f, 
    0.12598918f, -0.22004323f, 0.04660058f, 0.01232774f, 0.11601661f, 0.09100695f, -0.06303851f, 0.00529156f, 
    0.05310281f, 0.00253400f, -0.07290420f, 0.01856947f, -0.17802568f, -0.05254229f, -0.08133674f, 0.02438955f, 
    0.04071735f, 0.14170887f, 0.05706462f, 0.05119532f, 0.20109850f, -0.06000803f, -0.11947960f, 0.12717110f, 
    -0.15252517f, -0.35513648f, 0.01921101f, -0.26872572f, -0.13588326f, 0.13214266f, -0.02538796f, -0.01917155f, 
    0.02232926f, 0.13015310f, -0.07648376f, 0.03059631f, -0.18468240f, -0.18826061f, -0.04326271f, 0.14813168f, 
    0.03158227f, 0.01723938f, -0.00016550f, 0.06230310f, 0.02633387f, -0.04308178f, 0.08129279f, -0.07713700f, 
    0.06442174f, 0.27483538f, -0.29372779f, -0.36338815f, 0.06034904f, 0.00959377f, -0.01666758f, -0.15708509f, 
    0.17076293f, -0.02116743f, 0.17022943f, -0.00739915f, 0.24787566f, 0.38397098f, -0.15972379f, 0.00485533f, 
    -0.01298157f, -0.14603725f, 0.08119333f, -0.02816366f, 0.15166880f, 0.02840871f, -0.13126296f, -0.14674437f, 
    -0.12189928f, 0.58878785f, -0.42627454f, -0.18954392f, 0.22729938f, 0.06601220f, -0.03070187f, -0.11952974f, 
    0.03706427f, -0.13959102f, 0.14980301f, -0.01609059f, 0.36206064f, -0.11566293f, 0.19985582f, 0.11466579f, 
    0.02615880f, -0.05633910f, -0.02307649f, -0.02966562f, 0.03827408f, -0.05102767f, 0.04329105f, -0.12373800f, 
    -0.37789366f, -0.07697661f, 0.18525273f, 0.13139188f, 0.09226713f, 0.07153558f, 0.15010276f, 0.14036043f, 
    0.10265834f, 0.15792499f, -0.06898974f, 0.02400007f, -0.10081235f, 0.09819616f, 0.26182243f, -0.27699870f, 
    -0.05151257f, -0.04437205f, -0.17865093f, -0.06067748f, -0.12194477f, 0.00537629f, -0.13559969f, 0.06547161f, 
    0.35029566f, 0.05403407f, -0.14698862f, 0.09586906f, 0.05322725f, 0.01099246f, -0.08708524f, 0.00951182f, 
    -0.01083946f, 0.07332230f, 0.00880373f, 0.08765665f, -0.00553441f, -0.40925932f, 0.11245427f, 0.14347768f, 
    -0.30049223f, -0.08958423f, -0.00797703f, 0.05576388f, -0.00557528f, -0.04355811f, -0.00633813f, 0.08911885f, 
    -0.07078809f, -0.20050521f, -0.05925009f, -0.16676983f, 0.01522900f, 0.09782011f, 0.06634344f, 0.12391774f, 
    0.20017754f, 0.07221103f, -0.07342052f, -0.15011507f, 0.19483672f, 0.16412228f, 0.21209843f, 0.21838908f, 
    -0.22063860f, 0.01832781f, -0.00067745f, -0.04097411f, -0.07830413f, -0.05606278f, 0.11347397f, 0.22527467f, 
    -0.11822639f, 0.00969073f, -0.13703646f, 0.05188779f, 0.10132154f, -0.00507578f, -0.00273835f, 0.09878921f, 
    0.15906011f, -0.00373581f, 0.15477896f, 0.06551751f, 0.47140047f, 0.04441655f, 0.09194850f, 0.36524412f, 
    0.19100726f, -0.01373077f, -0.08956457f, 0.10521718f, 0.03764354f, 0.10000672f, 0.16525087f, 0.00352874f, 
    0.40375331f, 0.23392242f, 0.31043631f, -0.36639246f, 0.06107872f, -0.03268116f, -0.01456938f, 0.25002396f, 
    -0.03746712f, -0.05674370f, -0.00041746f, 0.14331354f, 0.24408871f, -0.09714305f, 0.14533347f, -0.23592071f, 
    0.21085396f, 0.00933440f, 0.09741741f, 0.03572513f, 0.21773084f, 0.15147969f, 0.00881816f, 0.27481812f, 
    0.29572254f, 0.02626363f, 0.04726849f, -0.17224659f, 0.04099829f, 0.07911719f, 0.17973687f, 0.15614109f, 
    0.13481867f, 0.05241709f, 0.09838168f, 0.02262380f, 0.00017203f, -0.14214940f, 0.08756258f, -0.12611614f, 
    0.15528625f, -0.00251454f, 0.01316401f, -0.20741916f, -0.08209801f, 0.25362134f, 0.01525689f, -0.10116171f, 
    -0.25839302f, -0.07964151f, -0.18575984f, -0.09775491f, 0.05767325f, 0.04261586f, 0.15600637f, -0.01241387f, 
    -0.10641354f, 0.08922852f, -0.01657532f, 0.09364177f, -0.23838936f, -0.31007382f, -0.46519563f, 0.02473811f, 
    -0.03643133f, 0.13569140f, -0.11661979f, -0.04293098f, 0.06018817f, 0.10752138f, 0.11052896f, 0.01599233f, 
    -0.23263834f, -0.35289323f, -0.11325207f, -0.03620193f, -0.00064930f, 0.06558532f, 0.10314488f, -0.07665132f, 
    0.06781436f, -0.03573004f, -0.00785338f, 0.02155590f, 0.36817035f, 0.01015541f, 0.01292969f, 0.16061926f, 
    -0.08056843f, -0.05629842f, 0.00638763f, 0.04234662f, -0.08789048f, 0.04210466f, -0.15243250f, 0.02911368f, 
    0.35900730f, 0.26569784f, -0.02904288f, -0.10548337f, 0.10383569f, -0.04101280f, 0.12051071f, -0.02834552f, 
    -0.07941437f, 0.13919525f, 0.14883055f, 0.16507563f, -0.06222256f, -0.01691693f, -0.01434641f, 0.15260746f, 
    -0.13741742f, 0.03704349f, 0.09592136f, -0.10232940f, 0.03504991f, 0.01674585f, -0.05003846f, 0.00588530f, 
    -0.43543738f, -0.06031207f, 0.33192995f, 0.08032721f, 0.18988107f, 0.13132432f, -0.10823829f, 0.04079482f, 
    0.15031710f, 0.23412250f, -0.09208830f, 0.13746725f, 0.10790674f, 0.02482434f, 0.12696850f, 0.39454231f, 
    -0.05725992f, 0.22522183f, 0.01610623f, -0.03916948f, -0.07457308f, 0.00306365f, 0.09487332f, 0.04695777f, 
    0.12340976f, 0.00155163f, 0.01756764f, -0.03836267f, 0.13736680f, -0.06261323f, 0.09459987f, -0.02982667f, 
    0.00821227f, -0.05448806f, -0.02199158f, -0.05336717f, 0.50731891f, -0.08009586f, -0.33414587f, -0.27314553f, 
    0.01907227f, -0.04884976f, -0.00196446f, 0.00136614f, 0.18761609f, -0.17955483f, -0.02318900f, 0.03515201f, 
    0.17175122f, 0.16679072f, 0.16145231f, 0.12651196f, -0.22100595f, -0.01016219f, 0.04938461f, 0.10058387f, 
    -0.08043291f, 0.02433279f, 0.07603239f, 0.13999563f, 0.11359107f, -0.14613786f, 0.16164611f, 0.03983864f, 
    0.00302591f, -0.02099633f, -0.07138634f, 0.15282728f, -0.07725410f, 0.14681849f, -0.12843870f, -0.06452813f, 
    0.01734195f, -0.00883358f, -0.03242296f, -0.00727478f, -0.04186580f, 0.06139798f, -0.05132051f, -0.02350193f, 
    0.03044609f, 0.03776256f, -0.02429449f, 0.05278606f, -0.00064692f, -0.07233692f, 0.00479200f, 0.02428690f, 
    -0.07475146f, -0.00155433f, -0.00313675f, 0.01950302f, 0.00195005f, 0.00004756f, 0.01006978f, -0.02292705f, 
    -0.02198334f, 0.04480256f, -0.03073350f, -0.07711180f, -0.04536224f, 0.05750852f, -0.02845577f, 0.04668614f, 
    -0.06343337f, -0.01315423f, -0.03560495f, -0.04721290f, -0.04870654f, -0.07068733f, 0.02399777f, 0.00696133f, 
    -0.03164601f, 0.05346364f, 0.01236835f, 0.01866233f, 0.02792906f, 0.00142797f, 0.02890613f, -0.06498270f, 
    -0.00979874f, -0.06298973f, 0.05692338f, -0.00876824f, -0.00844123f, -0.03943512f, -0.02577055f, 0.00752333f, 
    -0.03232802f, 0.01584467f, 0.04027081f, 0.02777291f, 0.04493759f, 0.06040582f, -0.03758392f, -0.02231325f, 
    -0.01797823f, -0.07592471f, 0.00013968f, -0.05284914f, 0.03069767f, -0.02516024f, -0.06186815f, -0.02590040f, 
    0.00990091f, 0.01337215f, -0.01124662f, 0.01542422f, 0.05382636f, 0.01415860f, 0.04069084f, -0.07254043f, 
    -0.04509497f, 0.05459179f, -0.04051686f, -0.03104358f, 0.03369442f, 0.00509387f, 0.01835248f, -0.05784050f, 
    0.00425606f, -0.04303668f, -0.02362907f, -0.05845186f, 0.04522603f, 0.00207211f, 0.02770579f, -0.03757142f, 
    -0.00561810f, -0.01950363f, 0.04486481f, -0.07367352f, 0.02617203f, -0.06699675f, -0.07203374f, -0.04685480f, 
    -0.01353758f, 0.02260092f, 0.04026541f, -0.05141599f, -0.01327085f, -0.02158113f, 0.03060765f, -0.03561958f, 
    -0.04406232f, -0.00122362f, -0.00471640f, -0.01833204f, 0.03270904f, -0.01953656f, -0.04370657f, 0.01277972f, 
    -0.05625099f, 0.00768050f, 0.00805326f, -0.02624911f, 0.00946496f, -0.06584782f, 0.00786674f, 0.02409322f, 
    0.00675355f, -0.01226201f, 0.03144332f, 0.04078098f, -0.00202248f, 0.04108182f, -0.05967585f, -0.02274923f, 
    0.05744982f, 0.04995382f, -0.03490726f, 0.00392952f, 0.06315213f, -0.02750787f, -0.04382679f, -0.01847394f, 
    -0.03371314f, -0.03801078f, 0.00065467f, 0.05119088f, -0.03765211f, -0.05055121f, -0.02692392f, -0.01550267f, 
    -0.03095172f, -0.06341346f, -0.02507735f, -0.06827577f, -0.03156498f, -0.07751930f, -0.06350677f, 0.00946339f, 
    -0.07409757f, -0.00870861f, -0.02116989f, -0.02382864f, -0.00528322f, 0.03056989f, 0.04320036f, 0.00452970f, 
    0.04899064f, -0.00804687f, 0.01367090f, 0.00906956f, 0.04951365f, -0.06875573f, -0.05036068f, -0.03653783f, 
    0.06648829f, 0.04544166f, 0.02709778f, -0.03790463f, 0.01744911f, -0.04894932f, -0.05040676f, -0.00187839f, 
    0.02055484f, -0.07520732f, -0.02038975f, 0.06021587f, -0.05847532f, 0.02750211f, -0.06026942f, 0.00962248f, 
    0.04832807f, -0.15330496f, -0.24532026f, 0.12615500f, 0.07141867f, -0.14063428f, 0.01765580f, 0.00903209f, 
    0.06206329f, 0.04514278f, 0.09729154f, 0.05352720f, 0.21941800f, -0.05269136f, -0.09685627f, 0.15165274f, 
    -0.02957988f, 0.00363590f, 0.05768431f, 0.05827951f, 0.04841511f, -0.12036456f, -0.01089258f, -0.03274279f, 
    0.10941164f, -0.10689426f, 0.12717146f, -0.00428822f, 0.03214454f, -0.06879438f, 0.00684454f, 0.12019593f, 
    0.04888804f, 0.01185023f, -0.06878048f, 0.16970582f, 0.00346185f, 0.15448271f, 0.12758364f, -0.11704463f, 
    0.04393812f, 0.04750361f, 0.02802835f, 0.08272046f, 0.06975549f, -0.00974116f, -0.02698101f, 0.05611784f, 
    0.34251377f, -0.05775921f, -0.09687509f, 0.12356496f, 0.00238685f, 0.06785737f, 0.06031537f, -0.01159656f, 
    0.16746423f, 0.05578417f, 0.15538463f, 0.02871659f, -0.26023310f, 0.05737152f, -0.05566999f, 0.18720353f, 
    -0.16763771f, -0.04494038f, 0.11849915f, -0.14302768f, -0.07101540f, -0.00788753f, -0.08319874f, 0.04969878f, 
    0.09373131f, -0.01878527f, 0.16941831f, 0.63122880f, 0.01976397f, -0.01138249f, 0.03181195f, -0.01789095f, 
    0.10137653f, 0.04960297f, -0.07072411f, 0.17892663f, -0.14460583f, -0.06441491f, 0.00811554f, -0.16735280f, 
    0.00156890f, -0.04900789f, -0.05899426f, 0.16531165f, 0.06631942f, -0.00167470f, -0.05667650f, -0.06487232f, 
    -0.05689563f, 0.14364776f, -0.14986058f, -0.04651658f, 0.16385123f, -0.02990101f, 0.05464455f, 0.19160777f, 
    0.01311225f, 0.03968715f, 0.09021775f, 0.26955166f, -0.35905010f, -0.10315210f, 0.06490210f, -0.38327011f, 
    0.07429254f, 0.08896261f, 0.08066138f, 0.03183752f, 0.13548779f, 0.00378747f, 0.17778020f, 0.03598396f, 
    -0.07390150f, -0.06537972f, -0.07083046f, -0.08865676f, 0.08076830f, -0.03637052f, 0.07665606f, -0.03636703f, 
    0.01696622f, -0.10055149f, 0.10815501f, -0.08076657f, -0.57464439f, -0.03950128f, 0.06425074f, -0.07935065f, 
    -0.06705265f, -0.02516649f, 0.00429340f, 0.08257943f, -0.09102336f, 0.08198527f, -0.06498315f, -0.06109395f, 
    -0.37210321f, 0.30699202f, -0.12452899f, 0.00138298f, -0.02212129f, 0.15909734f, -0.04920740f, -0.25151595f, 
    0.12272858f, 0.02337718f, -0.01464994f, -0.01864341f, -0.19021805f, 0.43222591f, -0.06674156f, 0.15706854f, 
    -0.21809895f, 0.01258136f, -0.06902704f, 0.03595313f, -0.12914623f, 0.03333072f, 0.00968179f, -0.02405066f, 
    0.17767899f, -0.29250804f, 0.07779032f, 0.16490136f, 0.03102390f, -0.04071177f, -0.11394923f, 0.15984835f, 
    0.12706304f, -0.04632086f, 0.15018882f, 0.14388795f, -0.02933573f, 0.02387544f, -0.05278320f, -0.16551931f, 
    0.10253824f, -0.02929720f, 0.03366624f, 0.14837836f, -0.01501345f, 0.10219062f, -0.03013034f, -0.08351510f, 
    -0.46972987f, 0.52625370f, -0.07115882f, -0.20826118f, 0.00958102f, -0.03290374f, 0.01283104f, 0.05907862f, 
    -0.07134503f, -0.09576632f, 0.09625713f, 0.02672480f, -0.10766527f, 0.31017223f, -0.02772645f, -0.21241234f, 
    0.06984422f, -0.00686885f, -0.06477206f, 0.00354736f, -0.07296677f, -0.01745519f, 0.03678260f, -0.06041495f, 
    0.23807617f, 0.11019526f, 0.01684652f, -0.18161805f, -0.15290330f, -0.12276477f, 0.21203260f, 0.17673805f, 
    0.17829360f, -0.09986766f, 0.02234784f, 0.04862633f, -0.22652519f, 0.20531847f, 0.14097759f, -0.56584388f, 
    0.05524972f, 0.13303871f, -0.02569288f, -0.00847677f, 0.07162818f, 0.00787201f, 0.12397496f, 0.08454052f, 
    0.04329039f, -0.12532827f, 0.07669155f, 0.41577378f, -0.07155882f, 0.17281719f, -0.07429016f, 0.01290635f, 
    -0.06855347f, -0.12337250f, 0.01843559f, 0.03656284f, 0.20617048f, -0.66060394f, -0.05889559f, 0.39093569f, 
    0.10744774f, -0.01728301f, 0.13945732f, -0.03802823f, -0.14717208f, 0.01605953f, 0.18142770f, 0.05962878f, 
    -0.08171535f, -0.32421386f, -0.05429754f, 0.18325996f, 0.04908582f, 0.09821829f, 0.09459919f, 0.12362150f, 
    -0.03973470f, 0.13174437f, 0.00265537f, 0.15136011f, 0.13622527f, -0.23051603f, 0.01882966f, -0.19825539f, 
    0.00896491f, 0.06309889f, 0.01542927f, 0.07940372f, 0.11854750f, -0.15694205f, 0.01624720f, 0.26821789f, 
    0.23581792f, 0.08041396f, 0.15034051f, -0.35948709f, 0.08278261f, 0.09690132f, -0.08876926f, 0.08035333f, 
    0.01470421f, -0.14635092f, -0.14401098f, -0.05962058f, 0.14110076f, 0.11214340f, -0.00293427f, 0.18372291f, 
    -0.01850206f, 0.11181342f, 0.11581669f, -0.01999676f, 0.07211459f, 0.06618899f, 0.04558944f, -0.01209262f, 
    -0.30471495f, 0.05129731f, 0.17909640f, 0.14660288f, -0.00368943f, 0.06320265f, -0.01626853f, 0.09032214f, 
    -0.10522117f, -0.06613450f, 0.12091313f, -0.11701527f, 0.57389832f, -0.05535940f, 0.06714451f, -0.26874381f, 
    0.11020997f, 0.08270445f, 0.01528878f, 0.09722105f, 0.12661874f, 0.03454482f, 0.12184496f, -0.08756801f, 
    -0.06825591f, -0.07946559f, 0.25187320f, 0.53230608f, -0.00634301f, 0.10876831f, 0.05014581f, 0.14597790f, 
    -0.06635720f, -0.13121590f, 0.34042966f, -0.05373344f, -0.25122473f, -0.14099248f, 0.15713935f, 0.08395692f, 
    0.15403810f, -0.06342462f, -0.05908747f, 0.04403494f, 0.08009035f, 0.21519446f, 0.09041831f, -0.05350329f, 
    0.10475778f, 0.28949499f, -0.01203667f, -0.23058827f, 0.02966593f, -0.22365716f, -0.04918270f, -0.07096457f, 
    0.05134889f, -0.00981254f, 0.03437649f, -0.04076543f, -0.30361438f, 0.35415086f, 0.26086223f, -0.47786495f, 
    -0.05868375f, 0.07904472f, 0.02342838f, 0.06374782f, -0.05399688f, 0.01286000f, -0.11711583f, 0.11393624f, 
    0.42642066f, 0.01061652f, 0.15015700f, -0.09617449f, 0.13869624f, 0.04741371f, 0.03500237f, 0.06718831f, 
    -0.05489427f, 0.09960056f, -0.11221186f, 0.15096469f, 0.56326187f, -0.15791652f, 0.10631514f, -0.07752050f, 
    0.15529794f, 0.09258284f, 0.06508783f, 0.07258625f, 0.05575733f, 0.03327355f, -0.06045891f, 0.14392772f, 
    0.09264164f, -0.13567087f, 0.05407166f, 0.06410550f, 0.16899221f, 0.14208408f, 0.12577450f, 0.08700029f, 
    -0.01545356f, 0.10652306f, 0.19238481f, 0.09013645f, 0.37997410f, -0.04979490f, -0.13052420f, 0.20400725f, 
    0.01642750f, -0.02898279f, 0.06608474f, 0.03306243f, 0.06961650f, 0.07326588f, -0.23450209f, 0.00814583f, 
    -0.29408947f, -0.09944243f, -0.01267634f, -0.12007555f, 0.15214230f, 0.03434611f, 0.07701557f, 0.10456086f, 
    0.06880990f, -0.01947145f, 0.04375539f, -0.00481466f, -0.32943937f, -0.10804532f, -0.07048683f, -0.11162946f, 
    -0.19334756f, 0.18912072f, -0.19729948f, 0.02721366f, -0.03502338f, -0.07328662f, 0.15164065f, 0.01576775f, 
    0.11400344f, -0.08688121f, 0.20055088f, 0.05888427f, -0.05775884f, 0.07622730f, 0.05993006f, -0.00531866f, 
    0.17198773f, 0.02858920f, 0.05349365f, 0.12991232f, -0.00052093f, 0.11094079f, 0.03076408f, 0.01350397f, 
    0.06299264f, -0.01363845f, 0.02643073f, 0.06758395f, -0.00880860f, 0.18055172f, -0.00183737f, 0.01614813f, 
    0.34441209f, 0.02549333f, -0.09414900f, 0.05198542f, 0.09304061f, -0.07517559f, 0.06858273f, -0.02583491f, 
    -0.11106327f, 0.06413631f, 0.16226783f, 0.12561288f, -0.19192952f, -0.16298240f, -0.06018961f, 0.00492153f, 
    0.15252861f, 0.13332748f, 0.08193861f, 0.01382890f, 0.03363440f, 0.13316627f, 0.23909838f, -0.04007670f, 
    -0.18874758f, -0.06464688f, 0.30326617f, 0.03010854f, 0.19476116f, 0.10135448f, -0.03900500f, 0.05696755f, 
    0.10264716f, -0.03372797f, 0.07841931f, -0.07524154f, -0.34133157f, 0.15928762f, -0.10762715f, 0.20421295f, 
    0.22379482f, 0.01262340f, 0.09053485f, -0.18091291f, -0.11623331f, -0.03296418f, -0.06591472f, 0.10745570f, 
    0.13782975f, 0.25241929f, -0.27167213f, -0.26573139f, 0.07327294f, -0.01927691f, -0.02609632f, 0.05441116f, 
    -0.13607128f, 0.06858278f, -0.20696570f, 0.01759284f, 0.10255208f, -0.08419678f, -0.29122040f, -0.15090786f, 
    0.01797393f, 0.02452785f, -0.09890174f, 0.09728727f, -0.10084536f, -0.22787324f, -0.09839526f, 0.07748134f, 
    0.29675004f, -0.07044218f, 0.05704619f, 0.29848987f, -0.30806589f, 0.18175589f, 0.08161124f, 0.07627168f, 
    -0.08755375f, 0.02777485f, -0.01630132f, 0.09342882f, -0.11134832f, -0.35686526f, 0.08046708f, 0.02525021f, 
    -0.06868065f, -0.18763164f, -0.06230606f, 0.08104320f, -0.04368857f, 0.04259383f, -0.07050516f, -0.10682635f, 
    0.03509379f, -0.08501000f, -0.16978379f, 0.28398472f, 0.12268784f, -0.13750976f, 0.02710636f, 0.11885970f, 
    0.08724729f, 0.15558894f, -0.05347586f, -0.09533220f, 0.35596326f, -0.18195011f, 0.28512698f, 0.21873546f, 
    0.04849527f, -0.07911532f, -0.04162674f, -0.00660656f, 0.04043430f, -0.04066421f, 0.25719768f, -0.00440072f, 
    -0.15886386f, 0.12177180f, -0.13889405f, 0.28097141f, 0.12359921f, 0.00957631f, -0.12185057f, -0.05853087f, 
    -0.02491367f, -0.18625700f, -0.01572433f, -0.13906305f, 0.09226466f, 0.12872279f, -0.13977884f, 0.05581913f, 
    -0.05678576f, 0.07016432f, -0.11692979f, 0.08047032f, -0.00437693f, 0.06755719f, -0.16940495f, -0.03312444f, 
    -0.29034635f, -0.02471315f, -0.13316190f, -0.23154880f, -0.10367031f, 0.04361958f, 0.09805990f, 0.08270935f, 
    -0.03360755f, 0.05334921f, -0.01321231f, 0.06935751f, 0.37283984f, 0.33829579f, 0.05014276f, -0.19052695f, 
    0.04743116f, 0.15099874f, -0.01808109f, -0.09890754f, 0.04865897f, 0.06708508f, -0.03451243f, -0.01535835f, 
    -0.01450843f, -0.34886384f, 0.08862955f, -0.06493703f, -0.03099851f, -0.10860072f, 0.08106343f, -0.12644240f, 
    0.07846364f, 0.00697616f, 0.08277645f, -0.15004848f, -0.25640312f, 0.44031316f, -0.27462092f, -0.06506459f, 
    -0.01612022f, 0.23846984f, -0.00753507f, 0.04175982f, 0.04206240f, 0.24494499f, 0.07256423f, -0.00522722f, 
    0.02543573f, 0.00943417f, -0.45645085f, 0.22072342f, -0.23946626f, 0.23669410f, -0.07458530f, -0.14312311f, 
    0.02522623f, -0.03495247f, 0.13700938f, 0.13843493f, 0.02211767f, 0.32402971f, 0.02248047f, 0.06499970f, 
    -0.10160888f, -0.02348479f, -0.13138974f, 0.22561984f, 0.17805657f, -0.14435235f, 0.13983759f, 0.08333716f, 
    0.14561728f, -0.02452452f, 0.13061783f, -0.13987491f, 0.03837240f, -0.07024311f, 0.06758523f, -0.04107594f, 
    0.06133776f, 0.01641260f, -0.03508690f, 0.09668470f, -0.05623196f, 0.25405374f, -0.08406250f, 0.02299241f, 
    -0.00191847f, 0.19521835f, -0.13139988f, 0.10706329f, -0.04852881f, -0.13380617f, -0.00845745f, 0.00602741f, 
    -0.02395723f, 0.39067453f, 0.04951973f, -0.15353020f, -0.07139415f, -0.22708356f, 0.14663377f, -0.21047091f, 
    -0.12383114f, 0.05063048f, -0.02574124f, 0.14018613f, 0.30495259f, 0.45603225f, 0.26815301f, 0.15550154f, 
    0.13755620f, 0.01506990f, 0.16140692f, 0.16562234f, -0.07703689f, 0.04201224f, -0.03555574f, -0.19433238f, 
    0.05073322f, 0.01013938f, -0.05939021f, -0.17156740f, 0.04027260f, 0.11563595f, -0.08572169f, 0.00188012f, 
    -0.07020327f, 0.15367673f, -0.21505392f, 0.11142426f, 0.02502214f, -0.00504778f, -0.27839935f, 0.25024462f, 
    0.06389398f, 0.08651035f, 0.04653267f, 0.09535746f, 0.08840415f, -0.01962964f, -0.12286698f, 0.01962904f, 
    0.21951629f, -0.15883327f, 0.00351673f, 0.37982953f, -0.06073292f, -0.20543237f, -0.08431476f, 0.06836259f, 
    0.26223353f, 0.06482063f, -0.15432085f, -0.01984416f, -0.16225651f, 0.11386567f, 0.13537191f, 0.28336799f, 
    -0.16216040f, 0.01236597f, -0.06374397f, -0.00662082f, -0.09305156f, 0.05560171f, -0.05322288f, -0.11805770f, 
    -0.35989875f, 0.11322791f, 0.18882504f, -0.02636966f, 0.05268845f, -0.12351549f, -0.02827485f, 0.09511215f, 
    -0.03204736f, 0.02373743f, -0.10807746f, 0.01202518f, 0.45553046f, 0.18225738f, -0.01403610f, 0.09413885f, 
    -0.05951617f, -0.08133836f, -0.05878944f, 0.10271871f, 0.18220083f, -0.08610669f, 0.13798417f, 0.09006424f, 
    0.48123786f, -0.08826554f, 0.12416463f, 0.13832407f, -0.08280902f, 0.16664438f, 0.15169661f, 0.11065976f, 
    0.06158945f, 0.04134084f, 0.04713688f, 0.08589274f, -0.46405002f, 0.40403709f, 0.20705383f, -0.05270953f, 
    -0.19412452f, 0.05602697f, 0.01833928f, -0.07095630f, 0.02661482f, 0.06181723f, -0.00815837f, 0.04956979f, 
    0.37729853f, 0.16874655f, -0.18095604f, -0.08737105f, -0.01753796f, -0.01787298f, 0.02431519f, 0.11649578f, 
    -0.08695323f, 0.07989622f, -0.01304694f, 0.03743948f, -0.31574506f, -0.00332043f, 0.10531057f, 0.12289437f, 
    0.03588080f, 0.02365631f, -0.03491792f, 0.24713586f, 0.04091535f, 0.01465398f, 0.03074460f, 0.07367008f, 
    -0.04297516f, 0.01132037f, 0.21821921f, 0.08224741f, 0.00121207f, -0.04378970f, 0.00368928f, 0.01457837f, 
    0.06982273f, 0.03061353f, 0.02058065f, -0.03220483f, 0.01201019f, 0.17823704f, 0.00897273f, -0.11838125f, 
    0.09006000f, 0.16434568f, -0.07101312f, -0.03517158f, -0.13156053f, -0.12922259f, -0.00520961f, 0.15177931f, 
    0.18917723f, 0.04378178f, -0.19687967f, -0.06171927f, -0.08874755f, -0.13914156f, -0.03207633f, -0.01653829f, 
    0.02692464f, -0.01844547f, 0.06623247f, -0.15639149f, -0.28910381f, 0.13757981f, -0.05839225f, -0.08779728f, 
    0.12384937f, -0.05551983f, -0.03494702f, 0.28424835f, -0.00105070f, 0.04465003f, -0.01020782f, -0.00393871f, 
    -0.13637547f, -0.08558340f, 0.08948139f, -0.21970297f, 0.01958735f, 0.15029319f, -0.05938967f, -0.11030915f, 
    0.18561801f, 0.15083297f, 0.15867579f, -0.06188469f, -0.39656082f, 0.05232049f, -0.10215320f, -0.11339428f, 
    0.14368974f, -0.11278908f, -0.03351656f, -0.01994291f, 0.02169556f, 0.19483930f, 0.11890806f, -0.12379290f, 
    -0.18086489f, 0.00698048f, 0.15684856f, -0.03141417f, 0.24517131f, -0.23212308f, 0.02316350f, 0.01193854f, 
    0.16796026f, -0.03424542f, -0.02605840f, -0.03433890f, 0.28174779f, 0.11156385f, -0.14432268f, 0.38936865f, 
    0.01538304f, 0.03548582f, 0.09006656f, -0.01240579f, -0.03700144f, -0.00603413f, -0.03235621f, 0.16444403f, 
    -0.29725754f, 0.35700849f, -0.08478753f, 0.12516885f, 0.15155642f, -0.13787548f, 0.01126831f, -0.16582303f, 
    0.02815933f, -0.04451220f, 0.10112736f, -0.05395553f, 0.23281093f, 0.13758108f, -0.02246836f, 0.15235396f, 
    0.13447499f, 0.14655559f, -0.06706155f, -0.12754792f, -0.12967502f, -0.01865033f, -0.12530011f, -0.11169641f, 
    -0.33350497f, -0.04824410f, -0.02531713f, -0.32320607f, 0.00348892f, -0.14622217f, -0.06604769f, -0.03926446f, 
    0.01578929f, 0.10655466f, -0.03549868f, 0.03210736f, 0.19454715f, 0.23591796f, 0.06369569f, -0.03107712f, 
    0.17769685f, 0.17895535f, -0.09636078f, -0.05401485f, -0.05269514f, 0.00285779f, 0.28028536f, 0.01800265f, 
    -0.00530286f, 0.09855144f, -0.11103176f, -0.07314294f, -0.10476896f, -0.14156014f, -0.13646129f, -0.05956880f, 
    -0.01709461f, -0.05603287f, 0.16839094f, -0.11558619f, -0.07962275f, -0.27954957f, -0.00983072f, -0.01900085f, 
    0.07679110f, 0.01026097f, 0.15012628f, 0.05870475f, -0.10609175f, 0.10500765f, -0.00134222f, 0.03424653f, 
    0.05672669f, 0.05134977f, -0.33435720f, -0.16279477f, 0.06200379f, 0.14275433f, -0.09348116f, -0.04318389f, 
    -0.19234134f, 0.14499506f, 0.20551105f, 0.07062448f, 0.26702502f, -0.22336760f, -0.02630483f, 0.02135028f, 
    -0.00038281f, -0.04047686f, 0.10360466f, 0.01551891f, 0.08486860f, 0.07032346f, 0.19914162f, 0.19500594f, 
    0.31402621f, -0.12779851f, 0.10508723f, 0.26217887f, 0.26629534f, -0.01548589f, -0.03520048f, -0.06148568f, 
    0.05382840f, -0.01365434f, -0.08035653f, -0.07536069f, -0.24902429f, -0.00374464f, 0.05121443f, -0.23017998f, 
    0.05430397f, -0.00579359f, 0.06518860f, 0.04047520f, -0.09830172f, 0.04932942f, 0.04506743f, -0.02519926f, 
    0.41122007f, -0.03373322f, 0.02226513f, 0.26589653f, 0.09236621f, -0.04001546f, -0.08296321f, -0.12887010f, 
    -0.14042115f, -0.20190418f, 0.08027659f, -0.02030449f, 0.59724522f, -0.12155160f, 0.09217306f, -0.25423539f, 
    -0.00233791f, 0.05542523f, -0.05458834f, 0.04372491f, 0.07764166f, 0.02029685f, -0.11178312f, 0.05585434f, 
    -0.27606654f, 0.19907869f, -0.22226083f, 0.35925534f, -0.03397547f, -0.00365349f, 0.15600798f, 0.14891127f, 
    0.01937617f, -0.06937307f, 0.21955968f, 0.08000862f, -0.40349618f, -0.28083712f, 0.20212087f, 0.38358694f, 
    -0.02922253f, -0.05360917f, -0.02415376f, 0.12880453f, -0.07505303f, 0.07143051f, 0.12193485f, 0.02975660f, 
    0.19545181f, 0.19687930f, -0.08921960f, -0.19788688f, 0.12055174f, -0.13697638f, -0.00456081f, -0.05378211f, 
    0.33139026f, -0.14176734f, 0.02473296f, -0.02711879f, 0.18558399f, 0.37803084f, 0.18728553f, -0.06498067f, 
    0.28027231f, 0.08229128f, 0.05048617f, 0.02089015f, 0.09604693f, 0.08875393f, 0.03446623f, 0.13768607f, 
    -0.31708330f, -0.25624213f, -0.15396751f, -0.26042661f, 0.16559514f, -0.14197229f, 0.06014583f, 0.12672529f, 
    -0.00701127f, -0.03152440f, 0.06863295f, -0.03923277f, -0.37785530f, -0.09221609f, -0.17648493f, -0.34281868f, 
    0.09539773f, 0.00409913f, 0.09469540f, -0.08142494f, 0.01173747f, 0.02480239f, 0.02079836f, 0.06454439f, 
    0.18942088f, 0.14057826f, 0.06148702f, 0.10625172f, -0.02370457f, -0.10880457f, -0.03768659f, 0.13742274f, 
    0.07168242f, -0.00766336f, -0.04496919f, 0.09199397f, -0.10429562f, 0.00740206f, 0.18189576f, 0.13937628f, 
    -0.05006491f, -0.26306069f, 0.00682868f, -0.22288565f, -0.09574245f, -0.07142563f, 0.12964346f, 0.00979909f, 
    0.33468956f, 0.08340535f, 0.09604272f, 0.45943078f, -0.00888003f, 0.05739980f, -0.00611416f, 0.05869016f, 
    0.18246619f, 0.15173265f, 0.05486395f, -0.11554300f, 0.11972252f, -0.40123218f, 0.05856528f, 0.11341982f, 
    0.15390606f, 0.05193537f, 0.22547717f, -0.07454804f, 0.00221413f, 0.09365878f, 0.03369646f, -0.12639137f, 
    0.02796585f, -0.06564141f, 0.09107151f, 0.15500228f, -0.10491894f, -0.04811962f, 0.16988525f, -0.06902347f, 
    0.01922666f, 0.00516715f, -0.16248639f, -0.07336938f, -0.02964135f, -0.06706142f, -0.41453475f, -0.46310663f, 
    0.02871045f, -0.00771025f, -0.20400085f, -0.06752392f, 0.03758109f, -0.18318453f, -0.05307343f, -0.02018218f, 
    -0.12249460f, 0.02423704f, 0.04467445f, 0.00966141f, -0.05414300f, -0.11756159f, -0.14081322f, -0.06080089f, 
    0.05394465f, 0.07959452f, 0.01288935f, 0.26559094f, 0.03261919f, -0.00330732f, 0.07090272f, 0.29972899f, 
    0.28805658f, 0.08661906f, 0.10531969f, 0.06281213f, 0.01697623f, -0.11046534f, 0.06507828f, 0.11540347f, 
    -0.35799974f, -0.17722304f, -0.22502424f, -0.30403078f, -0.28707299f, 0.04997553f, -0.05538560f, -0.08734438f, 
    0.05636181f, 0.15875034f, -0.02452027f, 0.20897029f, -0.39021581f, -0.35527343f, -0.16696405f, -0.38504896f, 
    -0.00338087f, 0.16853940f, -0.14430663f, 0.06337446f, -0.01691437f, -0.00339322f, -0.02433105f, 0.19150241f, 
    -0.09958810f, -0.13633361f, 0.07490374f, 0.17141484f, 0.13710240f, 0.00682223f, -0.00783820f, -0.00231713f, 
    0.03035230f, 0.00922755f, -0.03636526f, -0.11728492f, 0.01461305f, 0.04434192f, 0.09919959f, 0.20827046f, 
    0.36718091f, 0.20990202f, 0.06761169f, 0.01082980f, 0.12560302f, -0.12188753f, -0.00144670f, 0.00942572f, 
    -0.07022522f, 0.01374424f, -0.22590740f, -0.14473604f, 0.07827602f, -0.12932791f, 0.01673212f, 0.10233615f, 
    0.11237556f, 0.09379585f, 0.02139755f, 0.12178454f, -0.18937737f, -0.11256821f, -0.11010591f, -0.38903403f, 
    -0.09521280f, -0.17219174f, -0.13141735f, -0.14143832f, 0.03125442f, 0.02641905f, -0.10770558f, 0.03236214f, 
    -0.53355825f, 0.02793846f, -0.37812898f, 0.30864462f, 0.26072493f, 0.03437132f, 0.04578818f, -0.13083887f, 
    -0.02956247f, 0.09644166f, 0.08477595f, -0.12022587f, 0.51326036f, -0.09655939f, -0.00922555f, 0.17730354f, 
    0.15901756f, -0.03408630f, -0.07217037f, -0.05046111f, -0.05325611f, -0.06122694f, 0.06454548f, -0.05321483f, 
    -0.05390512f, 0.24445194f, -0.18249467f, 0.19655082f, 0.06589458f, -0.11296716f, -0.04100569f, -0.00593085f, 
    -0.06597566f, 0.05132874f, -0.07314301f, -0.12470576f, 0.17321968f, -0.01525367f, -0.30326438f, 0.04739514f, 
    0.07592169f, 0.07061707f, -0.14066954f, 0.08247729f, 0.01947322f, -0.00520270f, 0.03368475f, 0.03426427f, 
    -0.12629162f, -0.06146212f, -0.11575127f, -0.27105835f, -0.06079506f, 0.07923869f, -0.07285480f, 0.19903259f, 
    0.13021508f, 0.03817248f, 0.00888453f, -0.05155629f, 0.11556862f, 0.02974966f, 0.07988609f, -0.08382212f, 
    -0.07853400f, -0.03821234f, -0.08726396f, 0.06477773f, 0.05252446f, 0.01530251f, 0.03239037f, 0.00965205f, 
    0.24809441f, -0.03036925f, -0.04354838f, -0.32160616f, -0.06381839f, 0.15485950f, -0.03821248f, 0.05730097f, 
    0.00305913f, 0.08696189f, 0.08726104f, -0.01894124f, -0.29365951f, 0.04264969f, -0.24176882f, -0.12732595f, 
    0.10354626f, 0.07283452f, 0.06727553f, 0.08732042f, 0.15312478f, 0.22423165f, 0.20256871f, 0.02935026f, 
    0.20781605f, -0.08226860f, -0.44941622f, 0.40753981f, 0.11963243f, 0.14952660f, -0.11923706f, -0.14556350f, 
    -0.00675510f, -0.17805931f, 0.11003999f, -0.09357659f, 0.17249605f, 0.09030432f, 0.19621207f, -0.00428891f, 
    0.05509046f, -0.18511643f, -0.06177841f, 0.15989506f, 0.05428159f, 0.06235320f, 0.05087828f, 0.00534324f, 
    0.13490821f, -0.05944872f, 0.04184457f, 0.02476153f, 0.08513529f, 0.04251226f, -0.02186484f, -0.00293518f, 
    -0.09559013f, -0.28166959f, 0.02418175f, -0.03960818f, 0.34528980f, 0.19093475f, 0.11024832f, -0.14625131f, 
    -0.02334342f, -0.07677167f, -0.10851402f, 0.01440139f, 0.06243148f, -0.01591065f, -0.01943455f, -0.06533795f, 
    -0.02746197f, 0.49371216f, -0.26641494f, 0.29131842f, -0.06473839f, -0.11430321f, 0.11758488f, 0.10615160f, 
    -0.24577132f, 0.08026548f, 0.05501242f, 0.24860325f, -0.19401340f, 0.01807495f, 0.27052656f, 0.45140764f, 
    -0.18150505f, -0.04122971f, -0.02529448f, 0.28606018f, -0.16327552f, 0.10150386f, -0.04216761f, -0.11005425f, 
    0.18580741f, -0.08061617f, -0.06941749f, -0.12037272f, 0.06386302f, 0.22174191f, 0.05751270f, -0.02336449f, 
    0.02191303f, 0.01229552f, -0.03469957f, -0.00621826f, -0.32801270f, -0.00898108f, -0.10291041f, 0.01297327f, 
    0.17147955f, 0.02180525f, 0.07027212f, 0.04861111f, -0.00900303f, 0.00335093f, -0.07705453f, 0.01433392f, 
    -0.69410342f, -0.23332946f, -0.43722913f, 0.24683502f, 0.09591585f, 0.01469704f, 0.08520216f, -0.11714878f, 
    -0.03055128f, -0.00854408f, 0.15679882f, -0.09996866f, -0.21904841f, 0.23116903f, -0.08786962f, -0.01779487f, 
    0.15674219f, -0.02896180f, -0.00944315f, 0.05468110f, 0.11281390f, -0.07826613f, 0.13575862f, 0.07186521f, 
    0.21345198f, 0.07899025f, 0.02194044f, -0.14630000f, 0.03614131f, -0.10339175f, -0.09448727f, 0.00297536f, 
    0.07402743f, 0.00311963f, -0.07959779f, 0.09073637f, -0.43053210f, 0.16685072f, -0.04571692f, -0.04393974f, 
    -0.02707578f, 0.01968377f, 0.07248225f, 0.01731648f, -0.02188949f, -0.14764251f, 0.02150702f, 0.04501313f, 
    0.29427952f, 0.17015837f, -0.09654608f, -0.03832543f, -0.12600234f, 0.00322781f, 0.00718217f, -0.07797097f, 
    0.25442475f, 0.09951698f, 0.11860105f, -0.04584633f, 0.40294281f, 0.03381393f, 0.16996635f, 0.31492153f, 
    0.13091321f, -0.16444011f, 0.12779282f, -0.09528600f, 0.03901282f, 0.06423796f, -0.05284629f, 0.10795040f, 
    -0.25089186f, 0.23150609f, 0.17020734f, 0.30192742f, 0.11657947f, -0.03173208f, -0.13899967f, 0.10936503f, 
    0.01241367f, -0.04953332f, 0.08989413f, 0.15960671f, 0.08677497f, -0.04661066f, -0.11038556f, -0.20584227f, 
    0.04074692f, -0.05862007f, -0.07596969f, 0.00583420f, 0.09732429f, -0.26723555f, -0.09261198f, 0.03106848f, 
    -0.38818920f, -0.12340038f, -0.08144740f, 0.09193572f, 0.04346318f, 0.08702547f, -0.12122126f, 0.08746313f, 
    0.20233124f, 0.10972068f, -0.04173455f, 0.04630829f, -0.05069389f, -0.12602751f, 0.25078630f, -0.18091723f, 
    0.12434493f, -0.07234010f, 0.03858806f, 0.07092043f, 0.11342575f, 0.13783786f, -0.01749581f, 0.03925247f, 
    0.20185287f, 0.15665495f, -0.12401146f, -0.02643551f, 0.08770335f, 0.07795920f, 0.07822162f, 0.00752967f, 
    -0.10983732f, -0.01367212f, 0.16981545f, 0.12801464f, -0.10988583f, 0.02593541f, 0.13435394f, -0.03483955f, 
    0.06165473f, -0.08903167f, -0.02772163f, -0.01265825f, 0.01281162f, -0.05954339f, -0.10943335f, 0.16299909f, 
    -0.14749575f, 0.15271927f, -0.02468708f, 0.17048052f, -0.22061417f, 0.24970491f, 0.01426638f, -0.05288554f, 
    0.07145391f, 0.10398223f, 0.06549960f, -0.12690604f, 0.02827329f, 0.35759941f, 0.38652170f, 0.43092856f, 
    -0.19333813f, -0.02023423f, -0.03337884f, 0.13833070f, 0.06144663f, 0.15961079f, 0.02724008f, -0.01214510f, 
    0.23638231f, -0.03423366f, -0.05394573f, -0.14142817f, 0.12453805f, -0.01752884f, -0.03464950f, -0.05737186f, 
    0.11241098f, 0.01693095f, 0.22923464f, 0.07963119f, -0.30078840f, 0.10068583f, -0.13137719f, 0.08278395f, 
    0.19262557f, -0.13594972f, -0.08047344f, 0.01828072f, 0.10852298f, 0.06574190f, 0.00561968f, -0.00522136f, 
    0.03249884f, -0.01481424f, 0.02017396f, -0.04062385f, 0.04588904f, 0.05640055f, -0.02544564f, 0.03810996f, 
    -0.06795430f, 0.05336229f, 0.03735797f, 0.01629982f, 0.00960737f, 0.05078610f, -0.04033636f, -0.01153164f, 
    0.04367146f, -0.03200868f, -0.04321232f, -0.00492195f, -0.04792891f, -0.00842766f, -0.02938153f, -0.01818313f, 
    0.03634265f, -0.07598685f, 0.04808799f, -0.03445360f, -0.01351873f, 0.05119410f, 0.01310164f, -0.02588784f, 
    0.05100263f, 0.03955082f, -0.03471255f, 0.02947612f, 0.06603325f, 0.00280076f, 0.01834632f, -0.00209764f, 
    0.03560301f, 0.04142195f, -0.07374295f, -0.04717585f, -0.00407774f, -0.03943642f, -0.01284727f, -0.06699017f, 
    0.02365286f, 0.04165374f, -0.07148342f, 0.02228606f, 0.02617522f, -0.05485494f, 0.06057619f, -0.00527574f, 
    -0.01950435f, -0.00117147f, 0.05769959f, 0.03002622f, -0.07538542f, -0.03490627f, -0.06608868f, 0.01271926f, 
    -0.07627238f, 0.02854938f, -0.04826516f, 0.00105026f, -0.02092291f, -0.03521341f, -0.01399558f, -0.02142570f, 
    -0.03819079f, -0.04329480f, -0.03611166f, -0.02074770f, 0.05565520f, 0.04473492f, -0.07494998f, -0.05655975f, 
    -0.02935094f, -0.02094210f, -0.04290401f, 0.04904390f, 0.01685368f, -0.07484121f, -0.07129932f, 0.03977564f, 
    -0.05756862f, 0.05190060f, -0.02308355f, 0.03980842f, -0.02330853f, -0.02283679f, -0.05326743f, 0.06542942f, 
    -0.01934960f, 0.02169970f, -0.07617855f, -0.05993998f, -0.02710227f, -0.05530630f, 0.06097142f, -0.00510539f, 
    0.00260748f, -0.04779155f, -0.05806122f, -0.02401918f, 0.01662114f, 0.01956885f, 0.06311221f, 0.00019859f, 
    -0.05756646f, -0.05664590f, -0.02789575f, -0.03880552f, 0.03123386f, -0.04073774f, 0.00002112f, -0.00396324f, 
    0.03894504f, -0.04940511f, -0.03957587f, -0.01065601f, -0.07600328f, -0.03606408f, 0.06447025f, -0.05461294f, 
    0.03542480f, -0.03414065f, 0.04046640f, -0.05895780f, 0.03588309f, -0.03488469f, 0.01369700f, -0.06497738f, 
    -0.05126433f, -0.01587299f, -0.00211582f, 0.03269441f, 0.00617665f, 0.01465732f, -0.04420458f, 0.03498241f, 
    -0.06624129f, -0.05708789f, -0.04534507f, 0.02769811f, -0.01776789f, -0.02437890f, 0.02701742f, -0.04897059f, 
    0.01197997f, 0.03226500f, -0.04625428f, 0.02465802f, 0.04638388f, -0.03891419f, -0.02817368f, 0.01968903f, 
    -0.02660894f, -0.07770459f, -0.07531947f, 0.01338575f, -0.02414406f, -0.00667495f, -0.03095751f, 0.03599657f, 
    0.03636855f, -0.02678160f, -0.07507670f, -0.03889343f, -0.04896131f, 0.00110172f, 0.01708451f, 0.06173038f, 
    0.02312567f, -0.02872836f, -0.05191426f, 0.04983905f, -0.07111787f, 0.06410009f, -0.03704577f, -0.02999522f, 
    0.05618412f, 0.02912864f, 0.05415808f, -0.04951110f, 0.03142490f, -0.04143673f, -0.06886807f, -0.07207450f, 
    -0.15738614f, -0.12060378f, -0.05928818f, 0.02919516f, 0.25432241f, 0.10370369f, 0.07408822f, -0.07933971f, 
    -0.13400000f, -0.06122928f, -0.16612153f, -0.03161855f, 0.32887089f, -0.08239318f, -0.15358540f, 0.09375490f, 
    0.20263717f, 0.04646584f, 0.02628423f, 0.03617160f, -0.07526086f, -0.00713220f, -0.19502312f, 0.10345199f, 
    0.21048366f, -0.03481746f, 0.04469649f, 0.27239481f, 0.05705952f, 0.08200945f, -0.00859634f, 0.00536919f, 
    -0.09783886f, 0.15839960f, 0.08833815f, 0.16298853f, -0.05291861f, -0.15914199f, 0.01463865f, 0.34029534f, 
    0.03339323f, 0.00609533f, 0.22690353f, -0.04688710f, 0.03200397f, 0.08603457f, -0.19207568f, 0.06335640f, 
    0.22687320f, 0.12811263f, -0.02656993f, 0.02243043f, 0.09271799f, -0.16283372f, -0.12876028f, -0.00610824f, 
    0.29195261f, 0.24227412f, 0.06597041f, -0.03945862f, -0.78636140f, 0.16088371f, -0.08322594f, 0.18620297f, 
    -0.06573515f, 0.04608772f, -0.11922511f, 0.01327018f, -0.00325812f, -0.05514137f, 0.11117752f, 0.02220727f, 
    0.09155419f, 0.16489254f, 0.26492661f, 0.43938705f, 0.15918507f, 0.07290286f, -0.07898327f, 0.04716294f, 
    0.24554151f, 0.05923687f, 0.00270008f, 0.04138986f, 0.02041621f, 0.12743549f, -0.07971224f, -0.27387953f, 
    0.06418550f, -0.07320619f, -0.04971300f, -0.02843239f, 0.09430692f, 0.07781016f, -0.06140332f, -0.11451431f, 
    0.05784792f, -0.26239416f, -0.06938886f, 0.12576689f, 0.08610062f, -0.00880228f, 0.02734285f, 0.11152852f, 
    -0.18561701f, 0.11633275f, 0.26136506f, 0.16008340f, -0.04703020f, -0.26242357f, -0.01976888f, 0.11230861f, 
    0.05396747f, -0.02740365f, 0.10845988f, -0.12494522f, 0.02269441f, 0.24332532f, 0.08251557f, -0.02096627f, 
    -0.02700576f, -0.10112300f, 0.21487854f, -0.02024878f, 0.23441033f, 0.05617322f, 0.01166275f, -0.07107260f, 
    0.10421422f, 0.13702339f, 0.03962613f, 0.14178184f, -0.34915388f, 0.26118591f, 0.15847151f, -0.01230695f, 
    0.11244091f, -0.13843249f, -0.00351107f, -0.17086414f, -0.10558314f, 0.12426080f, -0.16234192f, 0.16447444f, 
    0.05877433f, 0.33976230f, -0.25926217f, -0.15199412f, -0.10757479f, 0.16281742f, -0.01839303f, -0.00944161f, 
    -0.05549900f, 0.14359145f, -0.20103559f, -0.06269616f, 0.35190088f, 0.15575254f, -0.25586104f, 0.03560502f, 
    -0.19053505f, 0.07332703f, -0.12018933f, -0.03788312f, 0.00098960f, -0.19545965f, -0.17250282f, -0.00755457f, 
    0.37212315f, -0.23468797f, 0.13608730f, 0.34854960f, -0.06182610f, 0.21279651f, 0.02348966f, 0.16760969f, 
    -0.10499282f, -0.02985523f, 0.25821266f, 0.14402212f, -0.28119501f, -0.19436274f, 0.00588960f, -0.31277567f, 
    0.07638095f, -0.14342636f, -0.19357052f, -0.09023570f, 0.16736896f, 0.05840014f, -0.04148016f, -0.11597804f, 
    -0.42532134f, 0.39064091f, -0.12406478f, -0.17687997f, 0.15910621f, 0.20622618f, 0.06259355f, -0.13693458f, 
    0.03875902f, -0.13168204f, 0.19638720f, 0.01104723f, -0.05436508f, 0.21731360f, -0.28429037f, -0.07341169f, 
    0.01714872f, -0.09324983f, 0.02179301f, -0.05562025f, -0.10276179f, -0.04554607f, 0.16282041f, -0.19384979f, 
    0.30954602f, 0.16014712f, 0.13943925f, 0.16990221f, -0.01052314f, 0.02830790f, 0.08545793f, 0.06965026f, 
    0.14192152f, -0.03720482f, 0.04626390f, 0.06253800f, -0.30623898f, -0.00867188f, 0.00889695f, -0.19209759f, 
    0.06084020f, 0.16014875f, 0.03690081f, 0.05699904f, 0.04458368f, 0.06431121f, 0.07526042f, 0.21907049f, 
    0.44290146f, -0.01073894f, -0.10081308f, 0.28034323f, 0.11887274f, -0.03059096f, -0.20623983f, -0.02756669f, 
    0.04989959f, -0.12452660f, -0.02999049f, -0.01893688f, 0.34724554f, 0.02497220f, -0.00988849f, 0.22745115f, 
    0.16464873f, 0.06623795f, 0.02494902f, 0.12400664f, -0.15889296f, -0.12699288f, -0.04792741f, 0.02935932f, 
    0.04086008f, 0.07347324f, 0.08331286f, 0.48350972f, 0.09828129f, 0.10839457f, 0.11789776f, -0.00868114f, 
    -0.00256209f, 0.14634956f, -0.13087742f, 0.01869749f, -0.03122500f, -0.26582250f, 0.01729234f, -0.20253773f, 
    0.05131389f, 0.05341418f, 0.09694421f, -0.04936982f, 0.13961381f, -0.12294704f, 0.23193662f, 0.19955426f, 
    -0.07107861f, -0.12097622f, 0.03838380f, -0.18774930f, 0.09351590f, 0.09029760f, -0.04707747f, 0.13280335f, 
    0.00403395f, -0.10718941f, -0.10348161f, -0.17209485f, 0.37850082f, -0.05710133f, -0.09651193f, -0.07397073f, 
    -0.08533785f, 0.01692641f, 0.13988656f, -0.03767229f, 0.03371011f, 0.12293892f, 0.08718258f, -0.05841045f, 
    -0.30591187f, -0.06191139f, 0.12111469f, 0.03495190f, -0.08386914f, -0.02143589f, 0.13682657f, -0.03291066f, 
    -0.05890290f, -0.08235686f, 0.11934288f, 0.01041398f, 0.29032829f, -0.13731664f, 0.05645166f, -0.29852837f, 
    -0.00407166f, 0.01701476f, 0.06885933f, 0.06724942f, 0.11125121f, 0.03978365f, 0.01404811f, -0.02963888f, 
    -0.17292708f, 0.01118060f, 0.18461134f, 0.47162253f, -0.08421090f, -0.01641739f, 0.11844083f, 0.10995103f, 
    -0.12754714f, -0.04498257f, 0.09526218f, 0.16301167f, -0.13036138f, 0.02274130f, 0.17395826f, 0.25567484f, 
    -0.05827239f, -0.04396702f, 0.09888455f, -0.09595943f, 0.02913191f, 0.21634410f, 0.03849759f, 0.01085392f, 
    0.12006404f, -0.03205166f, -0.14209788f, 0.01254704f, 0.01265090f, 0.09644642f, 0.05932642f, 0.04389890f, 
    0.00776619f, 0.00572243f, -0.05629523f, -0.04384050f, -0.57566530f, 0.05517384f, 0.19452070f, -0.71864742f, 
    -0.03830974f, 0.11211190f, 0.09644213f, 0.03849363f, 0.12158240f, -0.01681411f, -0.05125150f, 0.16797653f, 
    0.17525415f, -0.19343109f, 0.24378033f, -0.05998551f, -0.00044880f, 0.06808338f, 0.03639064f, -0.01157684f, 
    0.12454034f, 0.18100004f, 0.06865992f, 0.08706516f, -0.03502531f, -0.06816855f, 0.08162688f, -0.10498986f, 
    -0.01497989f, -0.08199996f, 0.20748131f, -0.02544026f, 0.09433842f, -0.01440189f, 0.21476890f, 0.01315502f, 
    0.50686049f, 0.35788488f, -0.03037879f, 0.19691680f, 0.07397421f, 0.10882285f, 0.07124157f, 0.05872883f, 
    0.08680341f, -0.04555257f, 0.16904189f, -0.10834154f, -0.36809331f, -0.03533910f, 0.03484385f, -0.11294787f, 
    0.07539260f, 0.05610366f, -0.02989737f, -0.12087574f, -0.01758703f, 0.15642416f, -0.03125208f, 0.00819836f, 
    0.02667717f, -0.18539096f, -0.18522872f, -0.14966783f, 0.13199663f, 0.10266026f, 0.03209568f, 0.04589416f, 
    -0.00515335f, 0.06595781f, -0.12704973f, 0.10700669f, 0.46322715f, 0.29417819f, -0.38330406f, -0.17416504f, 
    -0.14401178f, 0.13296919f, -0.23562197f, 0.16160795f, -0.04741838f, 0.12124236f, 0.03048706f, -0.04540224f, 
    0.08717334f, 0.04993438f, 0.13967089f, -0.18140188f, 0.02658462f, -0.04562170f, 0.14691705f, 0.01478029f, 
    0.12900433f, -0.00192265f, -0.00562481f, -0.12437251f, -0.08162948f, 0.04975134f, -0.10686113f, -0.01799139f, 
    -0.01063451f, 0.13110647f, -0.06800415f, -0.02653037f, -0.05984252f, 0.01553433f, -0.08020101f, 0.10913382f, 
    -0.25279328f, 0.24432895f, -0.16178824f, -0.17034072f, 0.02533799f, 0.00375994f, -0.13860802f, 0.00309737f, 
    -0.06826502f, -0.00885358f, -0.02750703f, 0.09264428f, 0.75706953f, 0.15669975f, -0.04329003f, 0.08777172f, 
    -0.23849183f, -0.02514962f, -0.08942609f, 0.02023150f, -0.01245441f, -0.11810236f, -0.06069756f, 0.11394534f, 
    -0.51461560f, 0.02181308f, -0.00568649f, -0.18154180f, -0.06251776f, -0.02763347f, -0.04228079f, 0.06898847f, 
    0.01977385f, 0.19099624f, 0.03013106f, 0.06635877f, 0.16227087f, -0.08061112f, -0.24298759f, 0.08551266f, 
    0.03704723f, 0.12661920f, 0.00881072f, 0.04999730f, -0.03078977f, -0.03472982f, 0.24131238f, -0.05673225f, 
    -0.10507905f, -0.13585211f, 0.05249737f, 0.06397473f, -0.01153085f, -0.07962856f, 0.23209384f, 0.09755147f, 
    -0.13217810f, -0.05293865f, 0.01012510f, 0.14380486f, 0.45401782f, -0.06094741f, -0.00330598f, -0.27715641f, 
    -0.25428444f, -0.00854085f, 0.28830644f, -0.00038449f, 0.06225713f, 0.01796893f, 0.01647586f, 0.01017276f, 
    -0.08319063f, 0.00176103f, 0.00601798f, 0.06058902f, 0.01003391f, 0.15189417f, 0.08558626f, -0.11536638f, 
    -0.18891828f, 0.23874727f, -0.09944013f, 0.00390314f, -0.14352921f, -0.25887129f, -0.14370026f, 0.08603187f, 
    -0.04714632f, -0.01070189f, -0.06098623f, 0.02706226f, -0.15303166f, -0.03386613f, -0.16245909f, 0.16525246f, 
    0.43966609f, 0.19823021f, 0.16506477f, -0.01217723f, 0.01160107f, 0.11496498f, -0.04117374f, -0.04291487f, 
    -0.18379936f, -0.06354014f, -0.22212076f, 0.10100555f, 0.04965511f, -0.02230687f, 0.19936624f, -0.02476618f, 
    -0.09240714f, 0.07426740f, -0.06030816f, 0.04047448f, -0.06690855f, 0.15345125f, -0.16878255f, 0.22656004f, 
    -0.53966480f, -0.39131683f, -0.21591265f, 0.09395192f, 0.00151813f, 0.10133472f, -0.02563295f, -0.06730394f, 
    -0.04508851f, 0.09710788f, -0.00605318f, 0.01983464f, 0.38495421f, -0.08896454f, -0.10102911f, 0.39851686f, 
    -0.01334004f, -0.09474197f, 0.11410900f, -0.05170432f, -0.18421040f, -0.03963756f, 0.00722305f, -0.12025554f, 
    -0.31987610f, 0.38030499f, 0.10986707f, 0.00712307f, -0.00021954f, -0.10930453f, 0.01411732f, 0.04086599f, 
    0.01166361f, 0.15446304f, 0.12458283f, 0.04420708f, -0.22153425f, 0.01175467f, 0.11642478f, 0.16179700f, 
    0.21710727f, 0.14008264f, -0.08811993f, 0.03056751f, 0.01805339f, 0.08502819f, 0.00125767f, 0.05125172f, 
    -0.05864837f, 0.18169327f, -0.04450331f, -0.14534628f, 0.18045031f, 0.07851421f, -0.16566499f, 0.13990015f, 
    0.03493971f, -0.11272814f, 0.02755901f, 0.00970211f, 0.16142629f, 0.06530630f, 0.19730854f, 0.18954013f, 
    -0.01978734f, 0.00270115f, 0.08641392f, -0.16702741f, -0.03152180f, 0.01503150f, -0.07321441f, -0.15710552f, 
    0.36182076f, -0.18765080f, 0.25414822f, 0.12287926f, -0.06556748f, -0.02728606f, 0.09145497f, -0.08499289f, 
    -0.07923180f, 0.11361097f, 0.19121957f, 0.05879607f, -0.07401291f, 0.07879024f, 0.03932369f, 0.28943223f, 
    0.15799880f, 0.03147713f, 0.03427888f, -0.06053714f, -0.06477635f, 0.13951719f, -0.04092405f, 0.09695851f, 
    0.18398079f, 0.14848284f, 0.11961914f, 0.19845735f, 0.00702286f, 0.15014265f, -0.06109543f, -0.02973857f, 
    0.02657233f, 0.13413277f, -0.08492053f, 0.13842109f, 0.25374073f, 0.17531489f, 0.20533682f, 0.24957560f, 
    0.06944171f, -0.02670574f, 0.14326650f, -0.18941832f, 0.01431056f, -0.01172332f, 0.08551425f, 0.10217214f, 
    0.43452430f, -0.02470836f, -0.12626441f, -0.34828335f, 0.14572851f, 0.02159778f, 0.01342662f, 0.15352571f, 
    0.04016462f, 0.05950624f, -0.10803200f, 0.00872919f, 0.25910884f, -0.15451846f, -0.17295964f, -0.30150998f, 
    0.25881559f, 0.08542611f, -0.02364285f, -0.02127883f, 0.15505552f, -0.07906607f, -0.04559282f, 0.16098328f, 
    -0.03487929f, 0.23157267f, -0.04639129f, 0.11837659f, -0.04590677f, -0.00333210f, 0.06343804f, 0.13472997f, 
    -0.09295292f, -0.04992584f, 0.08927651f, 0.03506539f, 0.62106824f, 0.10199752f, 0.23583697f, 0.24262887f, 
    -0.12326282f, -0.06553610f, -0.07054570f, -0.12447152f, -0.05449982f, -0.01405067f, 0.04627249f, -0.20558293f, 
    0.40263435f, -0.31559378f, 0.23485705f, 0.25501981f, -0.18962413f, 0.08807457f, -0.05587094f, 0.05449357f, 
    -0.02181466f, -0.04490534f, 0.04635839f, 0.08237214f, -0.40344840f, -0.07110681f, 0.09499352f, 0.17597091f, 
    -0.17933527f, 0.13320290f, -0.01431627f, 0.09881279f, 0.01097680f, -0.12698248f, -0.02128740f, -0.02720983f, 
    -0.18350103f, -0.14011611f, 0.13396734f, 0.18605274f, 0.05815185f, 0.11223572f, 0.00783787f, -0.08918706f, 
    0.12708220f, -0.02094350f, -0.00288445f, 0.13319349f, 0.14881252f, 0.05227629f, 0.18224393f, 0.20444486f, 
    -0.16877225f, 0.07233553f, -0.03025772f, 0.23152350f, 0.04287520f, -0.02328007f, 0.06616113f, 0.19727834f, 
    0.20288645f, -0.08215311f, 0.20853315f, 0.05175747f, -0.01047037f, 0.09606332f, 0.12279356f, 0.11084837f, 
    -0.00399430f, -0.07576954f, 0.01719636f, -0.04188486f, -0.03325860f, 0.34001839f, 0.20853411f, -0.15741768f, 
    0.04871868f, -0.01005488f, 0.13754395f, -0.06251298f, 0.16823377f, -0.02006970f, -0.04763342f, 0.03805064f, 
    0.09471448f, 0.17112258f, 0.07976836f, 0.26259032f, -0.02260740f, -0.19870856f, 0.21452504f, 0.04765141f, 
    0.02526848f, 0.02497076f, 0.01469651f, 0.04392826f, -0.13443650f, 0.13751833f, 0.17399047f, 0.05579364f, 
    -0.06091858f, 0.00176778f, 0.05121711f, 0.09549637f, -0.00562146f, -0.03522569f, 0.05715016f, -0.08262151f, 
    -0.50143254f, 0.22751124f, 0.28822613f, 0.21313192f, -0.07534426f, 0.00741328f, 0.12976198f, 0.12820947f, 
    0.04374676f, 0.05054043f, -0.08556254f, -0.07421368f, -0.26102647f, -0.12385290f, -0.08186137f, -0.28555924f, 
    0.11172327f, 0.17706278f, 0.01833153f, 0.08084961f, 0.05679276f, -0.04831567f, -0.00462256f, 0.05915406f, 
    0.24630170f, 0.01282987f, -0.17793861f, -0.14428096f, -0.09975341f, -0.02983077f, 0.10490455f, -0.06007720f, 
    0.01484469f, 0.03338769f, 0.15106606f, -0.04139720f, -0.73440385f, -0.12248889f, -0.16011576f, 0.01197466f, 
    -0.15706426f, -0.04334485f, 0.18559344f, 0.11030944f, 0.08971896f, -0.07626665f, -0.07892007f, -0.01293897f, 
    -0.15593308f, -0.28570375f, 0.18986231f, -0.17077647f, -0.14875765f, 0.11088496f, -0.05449961f, -0.15479738f, 
    0.05053493f, 0.05775622f, -0.02272892f, 0.07781234f, -0.36108264f, 0.15340562f, 0.01893492f, 0.07302498f, 
    0.10235296f, 0.01685724f, 0.07128920f, -0.11903559f, -0.15662554f, 0.03447635f, 0.12696785f, 0.16689450f, 
    -0.20843078f, -0.17864230f, 0.14438462f, 0.11326465f, 0.16942008f, -0.04844192f, -0.14095084f, -0.00365660f, 
    -0.00927487f, -0.06720327f, -0.05399646f, 0.02127136f, 0.37415597f, 0.09037662f, -0.11109587f, 0.14524983f, 
    -0.08599400f, 0.09736593f, 0.09234428f, -0.04475861f, 0.08820244f, 0.14155164f, 0.26441419f, 0.08078104f, 
    -0.13367011f, -0.17546093f, -0.07167800f, 0.02029656f, -0.15136069f, 0.07115468f, 0.04999053f, -0.21622196f, 
    -0.13542883f, -0.10497560f, 0.06050416f, -0.07696380f, -0.06885783f, 0.28618839f, -0.09874363f, -0.20599701f, 
    0.07556442f, -0.05662179f, -0.00367329f, 0.08778036f, -0.01740194f, -0.00816974f, 0.07474948f, -0.12423892f, 
    0.34867996f, 0.26252678f, 0.06190337f, 0.10138934f, 0.06642238f, 0.03363500f, -0.11184043f, 0.08178171f, 
    -0.02620658f, -0.07653169f, 0.06065356f, -0.04554501f, -0.20006987f, 0.18291694f, -0.13624966f, 0.26479566f, 
    -0.01132954f, -0.06877983f, 0.02158226f, 0.07474969f, -0.08278524f, 0.07816980f, -0.16483977f, 0.05452167f, 
    -0.00296991f, 0.23614247f, 0.16641578f, 0.00539095f, 0.04517067f, 0.10234631f, -0.10472365f, -0.27881563f, 
    0.05190972f, 0.10023044f, -0.01877039f, 0.13752387f, 0.61425507f, -0.13663046f, 0.30180579f, 0.17993954f, 
    0.07191646f, 0.13222538f, -0.14119878f, 0.00936130f, 0.05656382f, -0.07029311f, 0.04095693f, 0.10662486f, 
    -0.29969743f, 0.11705823f, 0.41407830f, -0.01194273f, 0.11407008f, -0.00028538f, -0.19560021f, 0.21218437f, 
    0.01971810f, 0.09177434f, 0.07370751f, -0.00376074f, 0.10191175f, 0.30332458f, -0.16947764f, -0.25718629f, 
    0.10526022f, -0.00515613f, -0.11475134f, -0.08954466f, -0.00106070f, -0.07762671f, -0.13438363f, -0.03845683f, 
    -0.18697408f, 0.01224714f, 0.04407634f, -0.13645238f, -0.00816652f, -0.04783405f, -0.26027313f, -0.00701086f, 
    -0.11518876f, 0.10049725f, 0.12907587f, -0.03250308f, 0.16944872f, -0.19632563f, 0.11915424f, 0.12736222f, 
    0.25239900f, 0.08329969f, 0.06384903f, 0.01735958f, 0.14128837f, -0.00797805f, 0.06070050f, 0.08721537f, 
    -0.11396701f, 0.12359002f, 0.13712269f, -0.14572234f, -0.07244024f, 0.05274252f, -0.03304857f, 0.13573128f, 
    0.07305721f, -0.04260791f, 0.01352724f, 0.09730466f, -0.24417937f, 0.28806520f, -0.09721386f, 0.10979250f, 
    0.21617492f, -0.15635459f, -0.20741935f, -0.12810946f, 0.11384121f, -0.12512124f, -0.13204446f, 0.04216763f, 
    0.27937487f, -0.24655160f, -0.06205334f, -0.02830971f, -0.12035635f, 0.22259447f, -0.16910169f, 0.08492786f, 
    -0.21798335f, 0.15868787f, 0.10854579f, -0.16625780f, 0.21568912f, 0.19955704f, -0.02134774f, -0.14196247f, 
    0.24298003f, 0.26233959f, 0.14892243f, 0.00748713f, 0.09832091f, 0.03098673f, -0.03825450f, 0.15267941f, 
    0.05995626f, 0.01163048f, -0.14970371f, -0.00527751f, 0.06169184f, -0.05806977f, -0.14563581f, -0.08227919f, 
    -0.26926684f, 0.22456139f, 0.02077210f, -0.05779894f, -0.27242407f, -0.14945769f, -0.09978995f, 0.37413779f, 
    0.02540238f, -0.24264179f, -0.21052898f, -0.16701497f, 0.00739591f, -0.10481077f, -0.03647104f, -0.21897328f, 
    0.39879578f, 0.17225404f, 0.00885842f, 0.15568434f, 0.04809367f, 0.23911738f, -0.04626084f, 0.00643969f, 
    0.15271713f, 0.14157236f, 0.04299016f, 0.11204078f, 0.23904148f, -0.09780438f, -0.21287565f, 0.21767515f, 
    -0.22704343f, -0.08595590f, 0.08539802f, 0.01797109f, -0.13422917f, 0.04214023f, 0.13934161f, -0.20094833f, 
    -0.14108483f, -0.16742651f, 0.08908014f, 0.39312297f, 0.11137339f, 0.17688140f, 0.03483164f, 0.04801109f, 
    0.06815732f, -0.20701465f, 0.03779558f, -0.06750335f, 0.55290037f, -0.06196728f, -0.20348682f, 0.16615812f, 
    0.05298757f, 0.02133651f, -0.16763328f, 0.13732427f, 0.03312952f, 0.07417476f, 0.04871443f, 0.15491968f, 
    0.22211972f, -0.01840436f, 0.03181844f, 0.10006322f, 0.03075945f, -0.06377508f, -0.08245476f, 0.22953059f, 
    -0.21161294f, -0.14754725f, -0.02735574f, -0.00133305f, 0.20544384f, 0.54281247f, 0.41284996f, 0.04790911f, 
    0.00430074f, 0.12759008f, -0.06487038f, 0.11580854f, -0.17325002f, -0.08419723f, -0.01337121f, 0.02726864f, 
    0.20633775f, 0.12027846f, 0.28088963f, 0.07075101f, -0.06147487f, 0.06671949f, 0.09964182f, -0.03808789f, 
    0.00154501f, 0.05797711f, -0.04784703f, -0.09253174f, -0.57593292f, -0.06621717f, 0.08089337f, -0.14240509f, 
    -0.01970945f, 0.01772254f, 0.08298124f, -0.03064982f, 0.06575585f, 0.07474186f, 0.37990767f, 0.24548942f, 
    0.24174790f, -0.08339582f, -0.02016938f, -0.04134998f, -0.00871854f, -0.04627863f, 0.10388238f, -0.03453381f, 
    -0.02778900f, -0.19554564f, 0.03933932f, -0.10447480f, 0.30334291f, 0.05014312f, -0.01861040f, -0.06643488f, 
    -0.00827673f, 0.01218968f, -0.12177705f, -0.05170322f, -0.01650750f, 0.06000837f, 0.19041374f, 0.14738721f, 
    -0.45298964f, 0.05006944f, 0.08371594f, -0.11398460f, -0.08613856f, 0.01848447f, 0.08502757f, 0.02842483f, 
    -0.10893751f, -0.09058338f, 0.08219498f, -0.24014971f, -0.24305683f, -0.10563706f, 0.05470976f, -0.08284513f, 
    0.14668015f, 0.11632084f, 0.11356055f, -0.06685816f, -0.01203610f, 0.11641653f, -0.00717301f, -0.20032997f, 
    -0.36879432f, 0.24452505f, -0.01085468f, -0.14333589f, 0.05901559f, -0.06230339f, 0.06108803f, -0.01074605f, 
    -0.18346450f, 0.02317601f, 0.04725206f, 0.22783312f, -0.23152143f, 0.15404493f, -0.01279683f, -0.32011902f, 
    0.01268436f, -0.12248280f, 0.10716724f, -0.13163154f, -0.14705132f, 0.19400050f, 0.09518892f, 0.14266887f, 
    -0.14414766f, -0.21068570f, -0.05957582f, 0.19937482f, 0.04907737f, 0.13782729f, 0.13517635f, -0.07747725f, 
    -0.18606606f, 0.08231651f, -0.35826975f, -0.05621218f, -0.06735842f, -0.10545095f, -0.00985505f, -0.17044851f, 
    -0.11180346f, 0.18198453f, 0.17917910f, -0.06256652f, -0.02929672f, -0.17308570f, -0.01582088f, 0.08312990f, 
    0.00152476f, -0.01435880f, 0.00576877f, -0.00623931f, -0.04444234f, 0.03244746f, -0.04468173f, 0.01813888f, 
    -0.02156927f, -0.03029535f, -0.05832947f, 0.05302432f, 0.04528024f, -0.01302365f, -0.08651429f, -0.05401260f, 
    0.03278703f, -0.01745192f, -0.01726771f, 0.04770368f, -0.07153878f, -0.03593563f, -0.03767478f, -0.07819371f, 
    -0.07820261f, 0.00327286f, -0.02924740f, -0.02248170f, 0.05638917f, 0.00515406f, -0.07829234f, 0.04935590f, 
    0.04558149f, -0.04927232f, -0.03559181f, -0.05452141f, -0.00701566f, -0.01414954f, -0.05707360f, 0.03947322f, 
    -0.06119424f, -0.04966023f, 0.02748033f, -0.02323143f, -0.04400058f, 0.03323074f, -0.01676420f, 0.05545622f, 
    0.03879806f, 0.03095298f, 0.05818009f, -0.04931836f, -0.06484679f, 0.03234301f, -0.02019049f, 0.00178611f, 
    -0.06379160f, -0.03067161f, -0.02230013f, 0.01742857f, -0.06138649f, -0.07738464f, -0.07921640f, -0.00399681f, 
    -0.02045330f, 0.05430556f, -0.00057462f, -0.07929731f, 0.04578798f, 0.03244243f, 0.05276047f, 0.04004517f, 
    -0.00882537f, -0.02102632f, 0.00179748f, -0.02391338f, -0.00309229f, 0.05309175f, -0.05386815f, 0.01808415f, 
    0.05038193f, 0.05318114f, -0.00720601f, -0.00709051f, -0.06837590f, -0.05667702f, 0.03058328f, 0.05698476f, 
    -0.00094380f, -0.07297746f, -0.00029700f, 0.03900321f, 0.04140025f, -0.07189766f, -0.04210007f, 0.01523643f, 
    -0.03743772f, 0.02808375f, 0.05192094f, -0.05054021f, 0.02146271f, 0.03915183f, -0.04001287f, -0.01911064f, 
    0.05788091f, -0.04097044f, -0.04129445f, -0.06242558f, 0.02708368f, 0.00979032f, -0.03764890f, 0.02358613f, 
    -0.04481204f, -0.02860382f, 0.01516793f, -0.04105752f, -0.02052324f, 0.03202492f, -0.04623498f, 0.00816587f, 
    -0.04969034f, -0.06575595f, -0.02349915f, 0.04855160f, 0.02785700f, 0.04658853f, -0.07126532f, -0.05742253f, 
    -0.06507345f, -0.07687908f, 0.05632740f, -0.06812714f, 0.05179769f, 0.02554164f, 0.00864235f, -0.01528713f, 
    -0.02484631f, 0.03312385f, -0.06139245f, 0.01023401f, 0.04879523f, -0.01085207f, 0.02784913f, -0.05082622f, 
    0.02910430f, 0.00628580f, 0.01218455f, 0.02896769f, -0.05067633f, -0.04562201f, -0.04848659f, 0.05798807f, 
    -0.06713220f, -0.07067347f, 0.00520298f, 0.01468753f, -0.06449803f, -0.02831492f, 0.06187573f, -0.07811236f, 
    0.00951990f, -0.02051264f, 0.04758058f, -0.02853216f, -0.06473552f, -0.01604919f, -0.01245356f, -0.01515000f, 
    0.05589718f, -0.05467881f, -0.00782562f, 0.00217394f, -0.03321248f, -0.01130365f, 0.03505312f, 0.05306086f, 
    0.05016125f, 0.01819377f, -0.06628263f, 0.04181579f, -0.05433607f, 0.01859207f, -0.02199716f, 0.05225348f, 
    0.03041756f, -0.06336907f, -0.07222103f, -0.01783075f, -0.02208538f, 0.05553212f, -0.06938287f, -0.00175061f, 
    0.15022524f, -0.13675566f, 0.05987657f, -0.03224790f, -0.01743684f, 0.13452619f, -0.08164753f, 0.00128732f, 
    0.06310751f, 0.06670877f, -0.00520553f, -0.15251596f, -0.06943425f, -0.04995663f, -0.04962737f, 0.01555822f, 
    0.06025517f, 0.06664565f, 0.15334849f, -0.01309600f, 0.09934714f, 0.07311659f, 0.08991434f, 0.04012876f, 
    0.02513322f, 0.25405109f, -0.12697215f, -0.02732133f, 0.08010592f, 0.07145659f, 0.00153314f, 0.02946549f, 
    -0.04846216f, 0.08361226f, -0.08665272f, -0.13937089f, -0.20411368f, -0.19038855f, 0.00372435f, 0.12298921f, 
    0.02947570f, 0.01643234f, -0.05973872f, -0.01264266f, 0.00447743f, 0.10156710f, 0.09185020f, 0.00199442f, 
    0.02573971f, 0.08406120f, -0.25026643f, -0.41001517f, 0.03031616f, 0.02244835f, -0.06503414f, 0.05115608f, 
    -0.01153903f, -0.01875842f, -0.06245173f, 0.04639621f, 0.34329060f, 0.62308306f, -0.33010221f, -0.11772842f, 
    0.08996794f, 0.06978600f, 0.02061013f, 0.08027065f, 0.00105624f, 0.06986331f, -0.15912740f, -0.17763701f, 
    -0.04485261f, 0.55475366f, -0.27279902f, -0.40163130f, 0.17080127f, -0.00751644f, 0.07956203f, 0.02921041f, 
    0.03531754f, 0.08470394f, 0.15607457f, -0.04349174f, 0.23856981f, -0.09563155f, 0.04696288f, 0.21317062f, 
    0.03265191f, 0.12027130f, -0.00135825f, -0.02794480f, 0.04983816f, -0.06678466f, 0.03936967f, -0.01285568f, 
    -0.12682094f, 0.12943377f, -0.08442189f, 0.09643272f, 0.13009746f, -0.03177707f, 0.06480850f, -0.12377717f, 
    0.04322759f, -0.02625266f, 0.04431288f, -0.03184556f, 0.56366950f, 0.09455615f, 0.21426356f, -0.08844139f, 
    -0.17080964f, -0.04755163f, -0.00329310f, -0.07112771f, 0.02371661f, 0.02005176f, -0.21337885f, 0.02848383f, 
    -0.00372585f, 0.08482900f, -0.10632554f, 0.08636770f, -0.04426151f, -0.06625511f, -0.03757907f, 0.02023913f, 
    -0.07996892f, -0.08587255f, -0.12829612f, -0.01585383f, 0.48108888f, -0.21280913f, 0.07602353f, 0.03129023f, 
    -0.17468727f, 0.06637380f, -0.08980592f, -0.09366580f, 0.04802640f, 0.00207090f, 0.01769235f, -0.02501148f, 
    -0.05604682f, -0.06967469f, -0.08896467f, 0.03378656f, 0.17429876f, -0.02929603f, 0.21373872f, 0.16910499f, 
    0.01717901f, -0.03924954f, -0.04937626f, 0.02667614f, 0.26076254f, -0.12079865f, 0.29248297f, 0.03925674f, 
    -0.18719502f, -0.06935706f, 0.15528126f, -0.00318366f, -0.03184295f, 0.00992289f, 0.10574974f, 0.08335844f, 
    -0.09328556f, 0.05697815f, 0.00306272f, 0.05450702f, 0.15028976f, 0.07796690f, -0.00281968f, -0.13814436f, 
    -0.06697676f, 0.13462295f, 0.02418377f, -0.09382511f, 0.24750905f, -0.12735413f, -0.03292977f, 0.24963520f, 
    0.00568871f, -0.02615569f, 0.06409200f, 0.00919368f, -0.10915786f, -0.08579699f, -0.03597287f, 0.04178992f, 
    0.25177428f, 0.20026518f, 0.03340470f, -0.02450786f, -0.11245968f, 0.12154371f, 0.00927140f, -0.16879994f, 
    0.25108361f, -0.20503920f, 0.11246196f, 0.08881041f, -0.12833388f, 0.17550476f, -0.15308005f, -0.01898498f, 
    -0.00783352f, -0.00257111f, -0.09123265f, 0.02775792f, -0.00182653f, -0.22275829f, 0.16423190f, -0.41506720f, 
    0.02873606f, 0.12549864f, 0.04058104f, 0.07772940f, 0.06889712f, -0.02228830f, -0.05604754f, -0.05886992f, 
    0.14353257f, -0.09642329f, 0.05457953f, -0.11823507f, 0.14202118f, 0.19885127f, -0.00606008f, -0.08835341f, 
    0.12816007f, 0.11161403f, -0.17197882f, 0.05527655f, 0.07103896f, -0.04400568f, 0.19569333f, 0.28898096f, 
    0.32143599f, -0.25733808f, 0.07751346f, 0.24258479f, -0.08888867f, -0.10472120f, -0.18554117f, -0.02349917f, 
    -0.01602268f, -0.17914969f, -0.09702528f, 0.06402666f, 0.88001221f, 0.18018389f, 0.27901521f, 0.02245572f, 
    0.10726401f, 0.09278145f, 0.07469960f, 0.16437334f, -0.05150525f, -0.13872747f, -0.04346874f, 0.05036069f, 
    0.19593556f, -0.01445218f, 0.22745043f, 0.02678606f, -0.06429364f, -0.15068267f, 0.07866646f, 0.14414302f, 
    -0.10176125f, 0.28143781f, 0.01842826f, 0.07946979f, -0.10441948f, -0.27763739f, 0.03509043f, -0.09761809f, 
    -0.07200121f, 0.10411323f, 0.13682905f, 0.07766992f, 0.01874229f, 0.00798991f, 0.34224865f, 0.41390210f, 
    0.01312576f, 0.28003746f, 0.18905652f, -0.09316485f, 0.19131990f, 0.03194445f, -0.23535490f, 0.14785379f, 
    0.06558455f, -0.35399494f, -0.13611874f, -0.31762210f, 0.27614334f, 0.08450214f, -0.16236907f, -0.19689706f, 
    0.04568457f, 0.07799990f, -0.04624040f, 0.14610884f, 0.04418152f, 0.02486470f, 0.15572463f, 0.12278137f, 
    -0.15753332f, 0.09768286f, -0.06652474f, -0.18932533f, -0.03179133f, -0.12896301f, -0.08464099f, 0.15523474f, 
    -0.07775045f, -0.35550985f, 0.23069006f, -0.31232077f, 0.13052912f, -0.20814289f, -0.06876452f, -0.12185423f, 
    0.19654688f, -0.07151242f, -0.04411279f, 0.18047924f, 0.03953681f, 0.09996526f, -0.02326316f, -0.18285976f, 
    -0.16654845f, -0.29277593f, -0.05797207f, 0.24971886f, -0.00942792f, 0.09781370f, 0.09111735f, -0.07472998f, 
    -0.15611498f, -0.09395380f, 0.25909173f, 0.17445996f, -0.41168448f, 0.07254769f, 0.00847338f, -0.03013141f, 
    0.03144470f, -0.05879911f, 0.24702311f, -0.00703302f, -0.09622793f, 0.21696737f, 0.08952916f, 0.10201516f, 
    -0.23011506f, -0.04173658f, -0.11624248f, -0.20469433f, 0.21551917f, -0.12882231f, -0.03884786f, -0.15385269f, 
    0.11671368f, 0.06974492f, -0.39398518f, -0.18660641f, -0.05180985f, 0.10731906f, 0.13833380f, -0.01803844f, 
    0.04564757f, 0.08183891f, 0.16883047f, -0.08845942f, -0.09291666f, -0.09456519f, 0.03201521f, 0.24358216f, 
    -0.05026554f, -0.00491404f, 0.00752514f, -0.07235842f, -0.04386682f, 0.12007630f, 0.19736828f, -0.02802615f, 
    0.05676589f, 0.04465118f, 0.02964355f, 0.07547003f, -0.02342506f, 0.08734003f, 0.33450568f, -0.15469158f, 
    -0.03365050f, -0.03985957f, -0.00789628f, -0.08223351f, 0.05794046f, -0.05342969f, 0.13067774f, -0.16296357f, 
    -0.05556802f, 0.30631682f, -0.08107080f, -0.02198436f, 0.15860355f, 0.07295187f, -0.06627828f, -0.06346136f, 
    0.12411126f, 0.06024189f, 0.03391796f, 0.05500850f, -0.09192430f, 0.30573809f, -0.04557438f, -0.09793494f, 
    0.02953231f, 0.10485544f, 0.03684936f, 0.11194818f, 0.04327757f, -0.05367725f, 0.03165976f, 0.08820552f, 
    -0.47398576f, -0.16763555f, 0.31332183f, -0.20335981f, 0.01332584f, 0.14052241f, 0.19953069f, 0.11679003f, 
    0.01350125f, -0.06266735f, -0.01515268f, 0.01500575f, 0.50412899f, -0.54179174f, 0.18295480f, -0.36823797f, 
    -0.02473456f, 0.00203273f, 0.01656501f, -0.05163234f, 0.14070345f, 0.07485835f, 0.10760283f, 0.00389207f, 
    -0.03964748f, -0.37972564f, 0.09993004f, -0.50507694f, -0.20129591f, -0.03708810f, 0.11178263f, 0.08478687f, 
    0.01903796f, 0.01289749f, 0.24069168f, 0.08475398f, -0.05482914f, 0.38797057f, -0.03639110f, 0.21428008f, 
    0.03792656f, 0.15802523f, 0.10267690f, 0.16835374f, -0.05725893f, 0.12660354f, 0.07224832f, 0.18550667f, 
    -0.12267341f, 0.13600308f, -0.03033359f, 0.05359918f, -0.15249930f, 0.12040548f, -0.03658203f, 0.01271571f, 
    0.06878952f, 0.01855140f, -0.05264188f, -0.12605923f, -0.03917083f, 0.10924433f, -0.08782176f, 0.10359678f, 
    0.10221887f, -0.11898941f, 0.01248183f, 0.23707934f, 0.08616956f, 0.01020011f, 0.09352849f, -0.01244637f, 
    0.39640668f, 0.01738685f, -0.15372628f, -0.10139668f, 0.01768444f, 0.02613943f, 0.11001037f, 0.10353975f, 
    0.08074988f, 0.01620549f, 0.09744106f, 0.00236317f, 0.33004788f, 0.20084967f, -0.32239249f, 0.06312884f, 
    0.09538247f, 0.12038969f, 0.07148015f, 0.15935567f, 0.16756484f, -0.08810902f, 0.07522800f, 0.09717653f, 
    0.42989057f, -0.17698278f, 0.04817738f, 0.08481089f, -0.08041375f, -0.05884913f, 0.01179419f, 0.06267345f, 
    -0.00219333f, -0.10624205f, 0.25093183f, 0.06930643f, -0.18002060f, -0.19425708f, 0.14374749f, 0.06641876f, 
    0.19066249f, 0.01353543f, 0.07962232f, 0.39108452f, 0.08884148f, 0.07032685f, -0.03238913f, 0.06573109f, 
    -0.11132500f, 0.27115685f, 0.05875676f, -0.36288345f, -0.03444524f, 0.17609522f, -0.01329306f, -0.07209331f, 
    0.00295767f, -0.05575961f, -0.07463102f, -0.11261785f, 0.13635957f, 0.11309092f, -0.25331503f, 0.36412266f, 
    0.13979621f, 0.01596480f, 0.06650403f, 0.06771974f, -0.01017656f, 0.13598356f, 0.11488867f, 0.16028376f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16922827f, 0.14199370f, 0.06804968f, -0.04025885f, 0.05412377f, 0.02776752f, 0.08063807f, -0.14307579f, 
    0.03382751f, 0.14343885f, -0.05001058f, 0.15900265f, 0.07650047f, 0.04811236f, -0.05804307f, 0.14412551f, 
    0.07368650f, -0.06307133f, 0.03622825f, 0.03714546f, 0.03032335f, 0.02627272f, 0.08239172f, 0.10852690f, 
    -0.06391351f, -0.02995513f, -0.05283105f, -0.11015641f, 0.05662426f, -0.00517371f, 0.03216703f, -0.01860263f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13247000f, -0.59107566f, -0.36238405f, 0.41120192f, -0.55321789f, -0.13534212f, -0.09627871f, 0.11926492f, 
    0.00008310f, 0.11387611f, -0.02918377f, -0.10666115f, -0.43039840f, 0.22767465f, 0.34359807f, 0.10945533f, 
    -0.52447581f, -0.38307372f, -0.31749010f, -0.22566177f, 0.07524877f, -0.41442919f, -0.54537809f, 0.26469508f, 
    0.11080857f, 0.15637849f, 0.51732749f, 0.25322735f, -0.01686012f, 0.01089926f, 0.17069264f, 0.19489829f, 
    0.28241557f, 0.23306680f, 0.16321795f, -0.43810368f, -0.42543063f, 0.48042950f, 0.43014625f, -0.11967245f, 
    -0.01521957f, 0.22704098f, -0.05729831f, -0.51105297f, -0.21619982f, 0.09796964f, 0.05993646f, 0.25663573f, 
    0.07458317f, -0.15223378f, -0.13865533f, -0.48782998f, -0.03452389f, -0.13574940f, -0.54152632f, -0.04494597f, 
    0.34516269f, -0.17303281f, -0.69903326f, -0.21764725f, -0.02116684f, 0.12424285f, -0.71701312f, 0.09240873f, 
    -0.24092892f, 0.46971169f, -0.42141521f, 0.37716159f, -0.17775184f, -0.96364081f, -0.25271508f, 0.39794329f, 
    -0.01644128f, 0.21292000f, -0.14757423f, -0.43291438f, -0.04404008f, 0.00929805f, 0.44675380f, -0.73231208f, 
    0.12372325f, -0.00219620f, 0.39055264f, -0.12506171f, -0.04627170f, -0.33834025f, 0.13903849f, 0.38781801f, 
    -0.27326638f, -0.38725927f, -0.30351037f, -0.27117887f, -0.07522381f, 0.33850271f, -0.10265080f, 0.24301472f, 
    -0.28652510f, 0.02561600f, 0.24895522f, -0.49012923f, 0.05452044f, 0.38583884f, 0.36968681f, -0.47445497f, 
    -0.02204736f, -0.60322440f, -0.17525682f, -0.04155181f, -0.56600201f, 0.03435922f, -0.13996595f, 0.20065522f, 
    -0.42843190f, -0.77368784f, 0.14423476f, -0.07715931f, -0.01303771f, 0.36002055f, 0.26797348f, 0.13797735f, 
    -0.05508017f, 0.13496517f, -0.01277523f, 0.48383242f, 0.11722162f, 0.26274011f, 0.29159918f, -0.34377456f, 
    -0.00127606f, -0.05375310f, 0.42246190f, 0.10781761f, -0.01243526f, -0.37816504f, 0.35831863f, -0.43979627f, 
    0.11898246f, -0.48499426f, -0.09537429f, 0.24354275f, -0.01354466f, -0.37291074f, 0.12185959f, 0.45919189f, 
    0.15953098f, 0.01034573f, 0.02328512f, 0.23392269f, 0.13731560f, -0.57253069f, -0.07101499f, -0.36983794f, 
    -0.34220788f, 0.35644108f, -0.22388466f, -0.11222974f, 0.04290770f, -0.11726211f, 0.34528214f, 0.19728184f, 
    0.26546547f, -0.44967592f, 0.31715444f, 0.06262561f, 0.17233966f, -0.64542103f, -0.04238292f, -0.35450822f, 
    -0.16672218f, 0.24701200f, -0.01345398f, 0.20114134f, -0.01902389f, 0.35381204f, -0.20148897f, -0.09520265f, 
    -0.11227512f, -0.54182827f, -0.28125474f, -0.03983902f, 0.00576068f, 0.50857103f, -0.11076213f, -0.72826242f, 
    0.14346166f, 0.02284037f, 0.28240168f, -0.24980216f, 0.11508524f, -0.70062935f, -0.41552237f, -0.08447206f, 
    0.19271782f, -0.03418798f, -0.30372766f, 0.27684781f, 0.45383334f, -0.47053748f, -0.64842802f, 0.14993602f, 
    0.07702665f, 0.28476602f, 0.14567888f, -0.17990732f, 0.40728450f, -0.07452545f, -0.78280056f, 0.04855463f, 
    0.13151868f, -0.58723539f, -0.83179897f, -0.38492000f, -0.15456791f, -0.64121932f, 0.29662749f, 0.19899087f, 
    -0.03364714f, -0.05194876f, -0.66894650f, 0.19118325f, 0.11509811f, 0.15556799f, 0.50883436f, -0.17809394f, 
    -0.45498189f, -0.17633423f, 0.16917495f, 0.39818841f, -0.30206454f, 0.16525386f, -0.13667023f, 0.45708942f, 
    0.07181881f, -0.24080385f, 0.04524398f, -0.25373402f, 0.13372184f, -0.63301581f, 0.24657355f, -0.03750546f, 
    -0.17054126f, 0.75980550f, -0.19624691f, 0.36016950f, -0.15883583f, -0.06388467f, 0.29820743f, -0.05574693f, 
    0.16509937f, -0.18042924f, 0.28253090f, 0.11628359f, 0.02698662f, 0.10365031f, 0.01281915f, -0.41081819f, 
    0.01324341f, 0.12747656f, -0.34627536f, -0.39450336f, 0.05016350f, -0.22606848f, -0.12814651f, 0.33323702f, 
    0.46369600f, -0.14834908f, -0.09687210f, 0.07357524f, -0.42183280f, -0.00102631f, -0.22763088f, 0.01051811f, 
    0.40629905f, -0.05974812f, 0.23674707f, 0.46433958f, -0.02345399f, 0.09626408f, -0.41236940f, -0.69213814f, 
    0.17714417f, -0.23427267f, 0.02173658f, -0.49140385f, 0.02035227f, 0.37065256f, -0.55989653f, -0.20568936f, 
    0.24148969f, 0.18540365f, -0.18197195f, -0.15652509f, -0.72314036f, 0.18192999f, -0.91262525f, -0.33092052f, 
    -0.64754182f, -0.16946068f, 0.02772197f, -0.55536610f, 0.51630014f, -0.08659882f, -0.11781526f, -0.09373193f, 
    0.21418388f, -0.07037082f, 0.37032586f, 0.20409417f, 0.11539059f, -0.40427071f, 0.29045960f, -0.03188044f, 
    -0.14528739f, -0.45527029f, 0.39552152f, -0.13229208f, -0.14954987f, -0.15427510f, 0.28882894f, 0.41044602f, 
    0.07188743f, 0.53698671f, 0.03581787f, -0.52563089f, 0.30118996f, 0.08720211f, 0.07155257f, -0.54865640f, 
    -0.07784224f, 0.32359493f, -0.01744586f, 0.16477191f, -0.03525904f, -0.10326645f, -0.03877234f, -0.06015528f, 
    -0.63242036f, 0.46615767f, -0.25041029f, 0.34554857f, 0.01631621f, 0.22623818f, 0.05716151f, 0.59959579f, 
    -0.56738824f, -0.29392439f, 0.29559666f, -0.46373835f, 0.15376718f, 0.20900115f, -0.46399751f, -0.21119869f, 
    0.08069576f, -0.60350442f, -0.19089277f, -0.47342089f, 0.43793511f, 0.23995712f, -0.12936558f, 0.43753731f, 
    -0.52693409f, -0.02647993f, 0.11111042f, 0.40818888f, 0.02254069f, 0.28196687f, 0.35136884f, 0.21312620f, 
    0.10933771f, 0.04991997f, 0.50568849f, -0.10137527f, 0.14840151f, 0.18851922f, 0.06304734f, -0.12370283f, 
    -0.31237009f, -0.39530963f, -0.52878010f, 0.41589728f, -0.09742459f, -0.33312282f, -0.03521727f, -0.38805991f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00210148f, 0.20351920f, 0.00985367f, -0.09771249f, -0.11582850f, -0.02707515f, -0.05975979f, -0.10899610f, 
    0.07553156f, 0.14673615f, 0.06233105f, 0.11201411f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
